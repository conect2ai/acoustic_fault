#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.47414163f, 0.13930158f, -0.25608844f, -0.79601854f, -0.61790538f, 0.00007554f, -0.21057041f, 0.02364730f, 
    0.25864640f, 0.02724763f, 0.45467004f, 0.22757672f, 0.39166704f, -0.03745187f, 0.08092108f, -0.11328647f, 
    -0.01474515f, -0.17641512f, -0.38472375f, -0.28371310f, 0.07515536f, -0.04549670f, -0.26951101f, -0.33056480f, 
    -0.34820855f, -0.97584397f, -0.85329801f, -0.75600278f, 0.33699110f, 0.54006672f, 0.36240083f, -0.06413215f, 
    -0.18818437f, -0.02839031f, 0.64965087f, 0.46814921f, -0.04962629f, -0.08463084f, 0.17568776f, 0.51021075f, 
    -0.17392823f, 0.03638558f, 0.10564791f, -0.12626486f, -0.21784495f, -0.11576796f, -0.07426443f, 0.14666750f, 
    0.11123941f, 0.14202231f, 0.52028298f, 0.01153972f, 0.29430401f, -0.13103321f, -0.16343898f, 0.06824020f, 
    0.10379398f, 0.16763310f, 0.17190699f, 0.08484256f, -0.20725182f, -0.06587691f, 0.40656111f, -0.00803551f, 
    0.00634888f, -0.09653153f, -0.28482819f, -0.02871286f, -0.19829777f, 0.21243434f, 0.29057360f, 0.28222695f, 
    0.19531338f, -0.27780104f, -0.34241453f, -0.77631968f, -0.84953314f, -0.41850102f, 0.21671826f, 0.40518466f, 
    0.15435514f, 0.02218221f, -0.38971493f, -0.03106676f, 0.53380507f, -0.13814688f, 0.14408511f, 0.09324814f, 
    0.06649280f, -0.05529295f, -0.02939159f, 0.20225421f, -0.15957206f, -0.20899121f, 0.06213613f, -0.21262933f, 
    -0.34314746f, -0.36020723f, -0.34459546f, -0.32025886f, 0.32066467f, 0.58735490f, 0.28222027f, -0.33981159f, 
    -0.25885737f, 0.20560123f, -0.06259634f, 0.08582775f, -0.28931981f, -0.17716962f, -0.01656512f, -0.37397256f, 
    0.17058851f, 0.09927196f, -0.37720388f, 0.32146195f, -0.06009473f, -0.25059015f, -0.01352572f, -0.00098779f, 
    -0.28916815f, 0.26730603f, -0.04260062f, 0.22225615f, 0.32786053f, -1.19926858f, -0.12915356f, -0.47720671f, 
    -0.25602889f, 0.45369646f, 0.18758553f, 0.07001068f, 0.22346465f, 0.63080460f, 0.70940495f, 0.19660161f, 
    0.03102734f, -0.27432805f, 0.18412825f, -0.28874359f, -0.11124188f, -0.14298698f, -0.35372451f, 0.07939044f, 
    0.23352206f, 0.10943054f, -0.11491773f, 0.16554376f, 0.12869798f, -0.12036049f, 0.20483479f, -0.39623627f, 
    0.49836493f, 0.63875401f, 0.76467568f, -0.44322863f, -0.43954065f, -0.49681070f, -0.27729940f, 0.00814947f, 
    0.21720804f, -0.12065248f, 0.08167311f, 0.08083085f, -0.09182342f, -0.10292522f, -0.17408000f, 0.13190885f, 
    0.02283071f, -0.28526136f, 0.04685454f, 0.08413948f, -0.13150892f, 0.31851742f, 0.09121720f, -0.17593460f, 
    -0.72709590f, -0.38659605f, 0.03101482f, -0.40023997f, 0.16656765f, 0.17861225f, -0.15900695f, 0.12428869f, 
    -0.17550990f, 0.41195408f, 0.34137008f, 0.31855023f, 0.29529792f, 0.16813733f, 0.03204286f, -0.26158386f, 
    -0.05846441f, 0.29891130f, -0.05622909f, -0.06288733f, -0.06917777f, -0.03554009f, -0.29264894f, -0.21618767f, 
    -0.09256808f, 0.17646310f, 0.05404188f, 0.03680387f, 0.20213330f, 0.29449013f, 0.31627825f, 0.32739121f, 
    -0.55446726f, -0.58320302f, 0.05658914f, 0.38165474f, -0.06756011f, -0.35590160f, 0.08010726f, -0.05422381f, 
    0.06321055f, -0.44888592f, -0.05925695f, 0.21897627f, 0.31697318f, 0.06945323f, -0.17325848f, 0.04593023f, 
    -0.16804001f, -0.05213000f, -0.41972113f, -0.42648941f, -0.42958021f, 0.09926084f, -0.25934556f, -0.04294953f, 
    -0.95499307f, -0.61530089f, -0.04641243f, 0.29672226f, -0.08153021f, 0.53809357f, 0.23202391f, -0.05579357f, 
    -0.20265661f, -0.21731922f, 0.15567073f, -0.43152127f, -0.33948362f, 0.45740151f, -0.46512517f, -0.23023470f, 
    -0.20759247f, -0.00511807f, -0.00111035f, -0.36972025f, -0.58458406f, -0.80839711f, -0.77918065f, 0.05314956f, 
    0.21846448f, 0.53016484f, 0.21925829f, 0.22328258f, 0.31737918f, 0.51223415f, 0.35976231f, 0.19092074f, 
    -0.18582326f, -0.05382489f, -0.04381120f, 0.12775624f, -0.16957161f, 0.13843697f, 0.09250736f, -0.28857693f, 
    -0.13264734f, 0.15934761f, -0.24613488f, -0.15845351f, 0.11043207f, 0.17319046f, -0.06217642f, 0.29063907f, 
    -0.24885724f, -0.29704097f, -0.03225972f, 0.17443720f, 0.15023617f, -0.22224915f, 0.35921597f, -0.45599753f, 
    -0.43199366f, 0.64745855f, -0.10096818f, 0.22078967f, -0.26370254f, 0.04653246f, 0.04754472f, 0.26348674f, 
    0.13165256f, 0.10231982f, -0.13183179f, -0.28099695f, -0.07381361f, -0.33281562f, -0.44519439f, 0.40366545f, 
    0.41401160f, 0.33091348f, 0.50477523f, -0.14709964f, 0.31528553f, -0.25921050f, -0.25741881f, -0.12459674f, 
    0.09820344f, -0.08190447f, -0.22686964f, -0.24995017f, -0.19813327f, -0.02349181f, 0.10944560f, -0.04947487f, 
    0.09971547f, -0.33443996f, -0.33194432f, -0.17617773f, -0.47053567f, 0.20558260f, 0.21378346f, -0.45590308f, 
    -0.25757784f, -0.46138075f, -0.30067053f, 0.31447631f, 0.20310956f, -0.11772243f, 0.32464471f, -0.12478960f, 
    -0.13571139f, -0.44480556f, -0.52567041f, -0.02802758f, 0.49910942f, -0.02264218f, 0.29993927f, 0.35597101f, 
    -0.10142078f, -0.22924238f, -0.15403651f, -0.26426202f, -0.44606119f, -0.48250505f, 0.63777804f, 0.38443071f, 
    0.75287133f, -0.33629337f, -0.71672916f, 0.23422821f, -0.05624699f, -0.32632843f, -0.34741309f, -0.44628567f, 
    0.16642839f, -0.14016519f, -0.21407056f, 0.38159722f, -0.06874721f, 0.05012969f, -0.02057408f, -0.01102989f, 
    -0.27063364f, 0.27842239f, 0.06996581f, 0.09079711f, 0.19752444f, -0.12993854f, -0.13750020f, 0.00298804f, 
    -0.24480608f, 0.09835559f, 0.25999069f, -0.16814983f, 0.17827721f, 0.05299518f, -0.02568348f, 0.10401662f, 
    0.11185406f, 0.08873785f, 0.29777470f, -0.15031046f, -0.44167000f, 0.17955485f, -0.19317213f, 0.30137184f, 
    -0.32320389f, 0.22081208f, -0.30744866f, -0.02007654f, 0.22420488f, -0.05073688f, 0.06682822f, 0.45879546f, 
    -0.45906669f, 0.06966066f, 0.32235789f, 0.56532633f, -0.14030021f, -0.20868757f, 0.20133974f, 0.05823166f, 
    0.21987388f, 0.04389019f, 0.24697818f, -0.42253223f, -0.39476490f, 0.48406795f, 0.18941116f, -0.17230254f, 
    0.20278527f, 0.00265499f, -0.31689784f, -0.30791640f, 0.09723207f, 0.12719499f, -0.20955700f, 0.16413447f, 
    -0.22044419f, -0.35133949f, -1.11211026f, 0.11061048f, 0.99361277f, 0.48495820f, 0.03796003f, 0.04528009f, 
    -0.59179378f, -0.40566543f, 0.12188242f, -0.49616194f, 0.33145520f, -0.23391654f, -0.15170626f, 0.16166253f, 
    0.03882468f, 0.08916301f, -0.21628146f, 0.31589440f, 0.36015776f, 0.12490529f, -0.33066112f, -0.25437650f, 
    -0.12067761f, -0.14753224f, -0.61345756f, -0.28196380f, -0.36689496f, 0.42521814f, 0.62225235f, -0.04320612f, 
    0.43002731f, 0.34324783f, -0.59132552f, -0.42627934f, 0.29649141f, -0.38957775f, -0.46081346f, -0.06992228f, 
    -0.06549216f, 0.07588435f, -0.42063162f, -0.18871439f, -0.06721247f, 0.53633058f, -0.25636315f, 0.22215009f, 
    -0.05462169f, -0.11201894f, 0.02560489f, 0.49773732f, -0.46448809f, -0.80056471f, -0.28535876f, -0.32492915f, 
    0.26413405f, 0.33591476f, 0.44410565f, 0.09634035f, 0.02191668f, -0.02522576f, -0.08616906f, -0.24670535f, 
    -0.04743590f, 0.16704510f, -0.22004081f, -0.34049174f, 0.15754908f, 0.44011495f, -0.01366043f, 0.15083475f, 
    -0.01895592f, -0.14747214f, 0.18740900f, 0.13526225f, 0.17145838f, 0.54384667f, 0.19139461f, 0.16706499f, 
    -0.24711238f, -0.67601669f, -0.03782961f, 0.08045229f, -0.16072078f, -0.07970464f, -0.15663564f, 0.35017797f, 
    -0.10409501f, 0.34596309f, -0.01994149f, 0.00930240f, -0.13089673f, 0.16695774f, 0.08774291f, -0.39982152f, 
    -0.09113229f, -0.01542986f, -0.04723223f, 0.26615125f, 0.11261854f, -0.66737169f, -0.55454564f, -0.38923082f, 
    0.00436684f, 0.61555392f, -0.26408949f, -0.06851503f, 0.07463693f, 0.34153453f, -0.08689043f, 0.58893079f, 
    -0.25231251f, 0.46203852f, 0.19658670f, 0.26483065f, -0.28432840f, -0.27825788f, -0.28904918f, 0.11413383f, 
    -0.18125062f, -0.17031132f, 0.37737396f, 0.31801865f, -0.01038300f, 0.41502830f, 0.24855985f, -0.35662436f, 
    -0.03313801f, 0.07852347f, -0.16800503f, 0.65075833f, 0.21318822f, -0.31428155f, -0.24803081f, 0.64332747f, 
    -0.10185517f, 0.40296337f, -0.17011566f, -0.58967149f, -0.39910954f, -0.34682420f, -0.14558716f, 0.14239837f, 
    -0.36118811f, -0.04568837f, 0.14976887f, 0.21273006f, 0.20002176f, -0.00050495f, 0.42393234f, 0.05525512f, 
    -0.46836427f, 0.27861682f, -0.11407968f, 0.19555117f, -0.39459950f, -0.03433006f, -0.29907289f, 0.48195177f, 
    -0.01451011f, 0.47847706f, -0.51447952f, 0.13969886f, 0.23985149f, -0.10688067f, -0.45015779f, 0.06762712f, 
    0.19158271f, -0.05692315f, 0.12690075f, 0.13176738f, 0.14176980f, -0.37750635f, -0.18525529f, 0.37277725f, 
    -0.81688744f, 0.13198808f, 0.34133247f, 0.55775499f, 0.30682358f, -0.43192372f, -0.77550894f, -0.31110895f, 
    0.27084911f, 0.61175066f, 0.13746080f, 0.35103628f, -0.04625231f, -0.19872461f, 0.40311173f, -0.25317818f, 
    -0.15294859f, 0.16225584f, -0.16688277f, -0.32724372f, 0.07404349f, -0.10836085f, 0.12548620f, 0.37528077f, 
    -0.03244913f, -0.32829094f, -0.42741349f, 0.42249763f, 0.19873174f, 0.17922722f, 0.79601222f, 0.49570006f, 
    -0.22510278f, -0.44405007f, -0.23923647f, -0.45751584f, -0.19991520f, 0.10507697f, -0.06308010f, -0.01340015f, 
    0.03367772f, -0.34294650f, -0.05336476f, 0.20634831f, -0.03539237f, -0.20125552f, 0.19785599f, -0.03680341f, 
    -0.00390408f, 0.17014532f, -0.16881162f, -0.45595926f, -0.48739886f, -0.33941099f, -0.33332366f, -0.59928781f, 
    -0.45938343f, -0.30368710f, -0.53434551f, -0.53612572f, 0.07240795f, -0.00894067f, 0.27025250f, 0.35284343f, 
    0.40671396f, 0.01071934f, 0.02771510f, -0.25436962f, -0.30222431f, -0.27085009f, -0.10355818f, -0.30458236f, 
    -0.05061401f, 0.12477534f, 0.10435990f, -0.36891302f, -0.02128270f, 0.36419719f, 0.16423954f, -0.67819500f, 
    -0.38091779f, -0.46353671f, -0.79436272f, -0.59632581f, -0.48188457f, 0.21397039f, -0.26354861f, -0.09683610f, 
    -0.10455561f, -0.02974575f, -0.15384513f, -0.39424112f, -0.08796278f, -0.17762247f, -0.22597425f, 0.34183800f, 
    0.07305373f, -0.07412419f, 0.26159474f, -0.06308457f, 1.00794160f, -0.46442276f, -0.72296512f, -0.60986501f, 
    -0.38290524f, 0.71947199f, 0.31591716f, 0.49825141f, -0.14738871f, -0.27003786f, -0.18694675f, 0.15425594f, 
    -0.38065869f, -0.30398557f, -0.29653728f, -0.16270593f, -0.25234652f, -0.17523593f, -0.51586449f, -0.50270694f, 
    -0.10446572f, -0.07280271f, 0.00081881f, -0.29402685f, -0.23262367f, 0.45942006f, 0.38464570f, -0.22618300f, 
    -0.48040378f, -0.09092227f, 0.09917066f, 0.28043270f, -0.20170744f, -0.42068082f, -0.29723892f, 0.23284395f, 
    -0.01794766f, -0.02003491f, -0.21607773f, 0.35038760f, -0.25866827f, -0.04634760f, -0.15465102f, -0.35603607f, 
    -0.31309602f, -0.40601406f, -0.43071285f, -0.09351641f, -0.48502943f, -0.48946133f, -0.31076264f, -0.03472261f, 
    0.42571098f, 0.02948361f, -0.16220570f, 0.26966143f, 0.42938215f, 0.21869157f, -0.46134603f, 0.31196183f, 
    0.13787130f, -0.07240017f, -0.03707884f, -0.15093052f, -0.29392064f, 0.06443347f, 0.02296111f, -0.10115878f, 
    -0.20787084f, -0.02921293f, -0.04962923f, -0.22107099f, -0.01369996f, 0.15778980f, -0.20615236f, 0.34355107f, 
    0.08015493f, -0.09852716f, -0.22717774f, -0.72068083f, -0.77605587f, -0.04364572f, 0.25923496f, -0.32609683f, 
    -0.78397387f, -0.32645631f, 0.07868019f, -0.00537481f, -0.22707230f, -0.02610725f, 0.30898383f, 0.23828448f, 
    -0.11361032f, 0.08829904f, -0.02237142f, 0.19381803f, 0.09093478f, -0.13715169f, -0.02584124f, 0.22064872f, 
    0.07063013f, 0.60679603f, 0.34070700f, -0.17037299f, 0.19786754f, 0.03616485f, -0.10860881f, 0.34448519f, 
    -0.04132468f, 0.04583044f, -0.30029482f, -0.16322418f, 0.24085839f, -0.08376355f, -0.13102674f, 0.25436658f, 
    0.29331177f, -0.13604951f, -0.01310445f, -0.02121517f, -0.08939206f, -0.35134661f, -0.44852406f, -0.34335300f, 
    -0.52233088f, -0.53683478f, -0.06952548f, 0.27933627f, 0.17176063f, 0.42570159f, 0.13600165f, 0.29902568f, 
    0.16133676f, 0.12793869f, 0.28845638f, 0.21314229f, -0.15212509f, 0.17424966f, -0.00389050f, 0.01486891f, 
    0.26068160f, -0.13338216f, 0.09432515f, -0.07151952f, -0.11993035f, 0.13842236f, 0.07410605f, -0.18401961f, 
    -0.11902830f, -0.23471916f, 0.24817739f, 0.88991731f, 0.45887190f, -0.45600277f, -0.12374470f, -0.40708822f, 
    -0.26211300f, 0.22323121f, -0.33206129f, -0.61905873f, 0.05477950f, 0.34075919f, -0.11179901f, 0.17336866f, 
    0.01778843f, 0.01829831f, 0.02260618f, -0.00610513f, 0.12027222f, 0.24214604f, 0.29660875f, 0.00169809f, 
    -0.28850526f, 0.24636431f, -0.00783066f, -0.01423498f, -0.31633070f, -0.40928614f, -0.50414878f, -0.30848524f, 
    0.33061886f, 0.12550397f, -0.20195436f, 0.20225342f, 0.46516997f, 0.18443772f, -0.39616376f, -0.22725141f, 
    0.47298226f, 0.35700029f, 0.08581923f, -0.23487647f, 0.00227086f, -0.17300804f, -0.27725312f, 0.21387050f, 
    0.00160799f, 0.22605622f, 0.17752093f, 0.04660721f, 0.48681933f, 0.18806569f, -0.29454595f, 0.04975269f, 
    0.01479149f, 0.33727860f, 0.30897123f, -0.23637429f, -0.42983481f, -0.43065953f, 0.36245561f, -0.01402611f, 
    -0.26843482f, -0.24247530f, 0.40371400f, -0.11625633f, -0.42073596f, 0.03251378f, 0.17430861f, 0.28558272f, 
    0.37748393f, -0.09939140f, -0.16759670f, -0.12855241f, 0.02342833f, -0.52864414f, -0.17338163f, -0.39563784f, 
    -0.12233290f, -0.15083927f, -0.50931853f, -0.52124137f, -0.68098921f, -0.70543993f, -0.20475590f, -0.04862648f, 
    -0.08578122f, 0.44154543f, -0.63693500f, -0.11731251f, -0.31433326f, -0.05325974f, -0.29243314f, -0.36500707f, 
    -0.29148382f, -0.05485875f, -0.00968896f, -0.14596824f, 0.17789733f, 0.23075803f, -0.45954192f, -0.31222302f, 
    -0.45948747f, -0.02712440f, 0.05956851f, -0.46172220f, -0.45719036f, -0.36999032f, -0.13611108f, -0.34749925f, 
    -0.26815104f, -0.31391841f, -0.23735334f, -0.09217793f, -0.18318509f, -0.19411005f, 0.24739179f, -0.01447783f, 
    -0.15616541f, -0.13452387f, -0.05496548f, 0.06428102f, 0.06277258f, 0.17917837f, -0.07141964f, 0.58371812f, 
    -0.86709690f, -0.41627043f, -0.45065910f, 0.36638844f, -0.74185425f, -0.34222358f, 0.01220021f, -0.06093341f, 
    -0.11599004f, 0.22672369f, 0.63363016f, 0.51488054f, -0.47375694f, -0.09891514f, -0.11791126f, -0.12318479f, 
    -0.42543781f, 0.16649716f, 0.10526139f, 0.50101674f, -0.29149628f, -0.06795453f, -0.24912266f, 0.00899274f, 
    -0.96210289f, -0.77041453f, -0.16398261f, 0.40830892f, -0.04528863f, -0.00359177f, 0.33205625f, 0.15244290f, 
    0.23096396f, 0.21446605f, 0.20401749f, 0.20250948f, 0.17293322f, 0.46336782f, -0.33712417f, -0.24176988f, 
    -0.12284750f, -0.28617805f, -0.12918426f, 0.25423414f, -0.00242003f, -0.19536801f, 0.26591623f, 0.16531898f, 
    -0.38986170f, 0.04229913f, 0.48144332f, 0.50975180f, -0.15050285f, 0.21485572f, 0.37249741f, -0.60938483f, 
    -0.13950868f, -0.27577445f, -0.32152084f, 0.28319171f, -0.15661879f, -0.09539039f, -0.10414255f, 0.23322612f, 
    -0.24646750f, 0.10675884f, 0.21525566f, 0.36728162f, 0.04270019f, -0.03425302f, -0.11469129f, -0.32650828f, 
    -0.12393153f, -0.24684784f, -0.24888507f, -0.05228524f, -0.41513357f, -0.17530639f, -0.21972226f, 0.25963998f, 
    -0.16305704f, -0.25667676f, 0.49692783f, -0.28131229f, 0.14309847f, -0.34445706f, 0.44638342f, -0.18592426f, 
    0.00997734f, -0.29118851f, -0.45392168f, -0.02096828f, -0.23030844f, 0.06919098f, -0.02586906f, 0.34070206f, 
    0.07620945f, -0.09118321f, 0.39627352f, -0.04868034f, 0.18371885f, -0.07945941f, 0.01763817f, -0.46673951f, 
    0.73361540f, -0.09637703f, -0.35474399f, -0.54568529f, 0.50390220f, 0.04891105f, -0.11445437f, -0.16236898f, 
    0.43510047f, -0.39649671f, -0.52184564f, 0.23159267f, 0.22262993f, -0.10660859f, 0.01343891f, 0.35573334f, 
    -0.08829273f, 0.08882876f, 0.00054912f, -0.15630205f, 1.13477731f, -1.24393272f, -0.55555803f, -0.14238828f, 
    -0.06410094f, 0.23668759f, 0.85483176f, -0.04774316f, -0.13756597f, -0.17347528f, 0.09558421f, -0.08703896f, 
    0.25850192f, -0.32951567f, -0.01615244f, 0.12834781f, 0.06870372f, -0.19777985f, 0.04699885f, 0.16191708f, 
    -0.13545655f, -0.19102442f, 0.10603057f, 0.12235652f, -0.03287571f, -0.13724343f, -0.02516584f, 0.23082383f, 
    0.24101506f, -0.24884365f, -0.13731414f, -0.24088915f, -0.04691397f, -0.15687174f, -0.12396289f, 0.31529891f, 
    -0.22837625f, 0.13875306f, 0.32660103f, 0.08705841f, 0.27322134f, 0.11607174f, 0.26522151f, 0.31132978f, 
    0.36708784f, -0.00203402f, 0.18841338f, -0.07941364f, -0.09150848f, -0.22713956f, 0.55230683f, 0.87520921f, 
    0.27693224f, -0.18646730f, 0.14092112f, -0.62733048f, -0.16572458f, -0.38626975f, -0.11005428f, -0.07250035f, 
    -0.04501186f, -0.09292050f, -0.21230967f, -0.08431802f, -0.13340484f, 0.29368249f, 0.20283315f, -0.02745766f, 
    0.13549891f, -0.10007822f, -0.00902707f, -0.00011281f, -0.32297051f, -0.28974018f, -0.07564800f, 1.23135221f, 
    -0.57548022f, -0.79975474f, -0.55565232f, -0.83010590f, 0.71356100f, 0.38212484f, 0.17078565f, 0.13886155f, 
    0.15417805f, 0.21024504f, -0.00014002f, -0.10547650f, 0.03587600f, -0.04589825f, 0.11411561f, 0.03134371f, 
    0.15955679f, 0.07882529f, -0.14178775f, -0.07349546f, 0.04366890f, 0.14266388f, -0.13339040f, 0.22060445f, 
    0.64984167f, 0.54496616f, -0.30437794f, 0.13177164f, 0.12506308f, 0.12381959f, -0.36507300f, 0.04666407f, 
    0.49338984f, 0.05598718f, 0.30432883f, -0.15502419f, -0.24437104f, -0.34716001f, -0.22142647f, -0.18298766f, 
    -0.13537779f, 0.11352365f, -0.04907169f, -0.21823022f, -0.28458393f, 0.26373658f, 0.10566242f, 0.07295521f, 
    -0.10176263f, -1.14554393f, -0.72092330f, 0.19987854f, 0.02065561f, 0.45739993f, 0.66848928f, 0.45215467f, 
    -0.27499881f, -0.34547943f, 0.22181879f, -0.33781549f, -0.48546013f, -0.52997017f, -0.18096356f, -0.10834353f, 
    0.01155276f, 0.04451468f, -0.12202404f, -0.27861622f, -0.26201147f, 0.08804606f, -0.04319150f, -0.15342657f, 
    0.01015018f, -0.21970765f, -0.39246327f, 0.40228266f, -0.30747226f, 0.01940887f, -0.34490323f, -0.00295081f, 
    -0.08178336f, -0.25742134f, 0.24281429f, -0.28334832f, 0.02586792f, 0.32179767f, -0.19455026f, -0.04100041f, 
    -0.13511615f, -0.21727897f, 0.02749345f, 0.07445861f, -0.32044327f, -0.04928336f, 0.22140777f, -0.01188923f, 
    0.06502282f, 0.29107323f, 0.21483374f, -0.26306722f, -0.11176370f, -0.27444214f, -0.55835497f, -0.53146178f, 
    0.30682623f, 0.54193103f, -0.21061748f, -0.01829134f, -0.10230456f, 0.00969822f, 0.34329847f, -0.14731580f, 
    -0.03996981f, -0.32547310f, -0.02639692f, -0.33758852f, -0.29102144f, 0.23779093f, -0.34680030f, 0.18829563f, 
    0.28512889f, 0.39969426f, 0.36550257f, -0.10935518f, -1.01235974f, -0.38628882f, 0.04819316f, -0.53305072f, 
    -0.44108152f, -0.04158594f, -0.24463470f, -0.59324068f, -0.33775645f, 0.21735772f, -0.01355814f, -0.27335671f, 
    -0.18146615f, 0.02538249f, -0.33204180f, -0.08294391f, -0.09344404f, -0.37749919f, -0.08289372f, -0.11613423f, 
    0.13384931f, 0.27057976f, 0.47068688f, 0.20014191f, 0.06351528f, -0.27707213f, -0.23684277f, 0.21015182f, 
    0.17615795f, -0.27674428f, -0.52078980f, -0.40466890f, -0.03885121f, -0.35384899f, 0.24407330f, 0.11768789f, 
    -0.15476000f, -0.00852908f, 0.35755116f, 0.12780268f, -0.16872768f, 0.19610968f, 0.12013308f, 0.16659074f, 
    -0.00610159f, 0.19143173f, 0.13391848f, -0.11037254f, -0.06025034f, -0.34541160f, -0.37309042f, -0.64068758f, 
    -0.49331594f, -0.52723294f, -0.51873684f, 0.16260746f, -0.16393794f, -0.36036941f, -0.30777529f, -0.01072115f, 
    -0.32926267f, -0.48535034f, -0.03332586f, 0.34767741f, -0.01103300f, -0.03628386f, -0.04272443f, -0.09029822f, 
    -0.37377772f, -0.42768189f, -0.39331374f, -0.27893987f, 0.08917946f, -0.07985606f, -0.20143512f, -0.35219032f, 
    -0.17277873f, 0.01284653f, 0.37555766f, 0.35968256f, 0.14076202f, -0.15127718f, 0.28314292f, -0.13209373f, 
    -0.05163380f, 0.08485755f, -0.22512889f, 0.16966107f, -0.04510690f, -0.11686609f, -0.34690255f, 0.04729798f, 
    0.31584525f, 0.14781716f, -0.07404041f, -0.18114901f, 0.10879100f, 0.10956148f, 0.26267758f, 0.36620069f, 
    -0.03116891f, 0.10855883f, 0.20803566f, 0.20340028f, 0.10247462f, 0.13633263f, 0.18256354f, 0.14634179f, 
    0.32572579f, 0.20986757f, 0.16838150f, 0.24846023f, -0.36347336f, -0.14412570f, 0.12924254f, 0.04542226f, 
    -0.13652791f, -0.25326422f, 0.13951389f, 0.00315726f, -0.05874875f, -0.29511836f, 0.22620802f, -0.00550671f, 
    0.23335446f, -1.25546765f, -0.43727106f, -0.53770471f, -0.91499275f, -0.46040615f, 0.41715893f, -0.02693399f, 
    -0.64476818f, -0.25668550f, 0.42242855f, -0.31809878f, -0.42375162f, -0.39387983f, -0.50438982f, -0.38678265f, 
    0.25844553f, 0.19619930f, -0.12393518f, 0.11499008f, -0.02986063f, -0.07398214f, -0.04922353f, -0.09841023f, 
    -0.12064914f, -0.13893391f, 0.25225216f, 0.14878634f, 0.16656749f, 0.34975636f, -0.59512228f, 0.24111338f, 
    0.22334999f, 0.14399454f, 0.15372591f, 0.02622270f, -0.36176696f, -0.23711437f, -0.19894692f, -0.06627045f, 
    -0.11054110f, 0.20521075f, -0.08270832f, -0.24052484f, 0.08067200f, -0.06383228f, -0.33256727f, -0.12257040f, 
    0.12763028f, -0.32118627f, -0.25808093f, 0.19841930f, 0.34066978f, -0.00461139f, -0.06629132f, 0.11544991f, 
    -0.08835856f, -0.27559355f, -0.20395745f, 0.31041688f, -0.07077290f, 0.09078659f, -0.26414111f, -0.05297646f, 
    0.00263119f, -0.30374926f, 0.10660886f, 0.13378711f, 0.04700587f, 0.12541589f, 0.03269273f, -0.00416210f, 
    -0.27602080f, -0.09600032f, 0.24271728f, 0.28160402f, 0.45490733f, -0.05344483f, 0.11285105f, 0.42203820f, 
    0.39999339f, 0.36945370f, 0.18565226f, 0.04713233f, -0.23160923f, -0.25205502f, 0.10066879f, 0.15045418f, 
    0.10818140f, 0.03527213f, 0.27835643f, -0.15424837f, 0.10601603f, 0.16176833f, -0.20733035f, 0.12882496f, 
    0.15453371f, -0.17308553f, -0.01650165f, 0.19261789f, -0.06136702f, 0.08798850f, 0.11985598f, 0.11728017f, 
    0.25070754f, 0.09169263f, 0.33718222f, 0.25460768f, 0.24101901f, 0.09506511f, 0.14308415f, 0.24353682f, 
    0.11059388f, 0.12663263f, -0.03853771f, 0.02148665f, 0.11913597f, -0.03819256f, 0.03208663f, 0.17960533f, 
    -0.13520691f, 0.07260017f, 0.07403518f, 0.01553021f, -0.17715123f, 0.07701872f, 0.05037440f, -0.39492011f, 
    -0.27313870f, 0.32343057f, -0.07372428f, -0.65789646f, -0.60944337f, -0.25529879f, -0.07112815f, -0.04531545f, 
    -0.03247014f, -0.07125323f, 0.36607373f, 0.15074532f, 0.34515578f, -0.09158890f, -0.25015596f, 0.09129949f, 
    0.09175532f, -0.57793570f, -0.20685962f, 0.17605013f, 0.17450899f, -0.18685818f, 0.15679353f, 0.56732506f, 
    -0.48109636f, -0.12623337f, 0.16410010f, -0.42337707f, -0.01201835f, -0.74322313f, -0.58576870f, -0.34316272f, 
    -1.10372531f, 0.66495425f, -0.00166902f, -0.04204977f, 0.28420383f, -0.02049488f, 0.06509433f, 0.12465649f, 
    0.02551629f, -0.06019688f, -0.10122785f, -0.46901226f, 0.26989412f, 0.31760022f, 0.10223085f, -0.02784659f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12691118f, 0.12383505f, 0.24052742f, 0.14932327f, 0.41400591f, 0.22587851f, 0.24459365f, 0.19536680f, 
    0.35231563f, -0.06302437f, 0.20542878f, 0.40224525f, 0.03527370f, -0.12983222f, 0.30042577f, 0.34579620f, 
    0.44347334f, 0.33449182f, 0.29037589f, 0.13796140f, 0.29879850f, 0.36787564f, 0.14033772f, 0.31797069f, 
    0.31814453f, 0.16026165f, 0.14223759f, 0.18205914f, 0.07784957f, 0.07136398f, 0.28006789f, 0.27589625f, 
    -0.01507635f, -0.07597554f, 0.23740464f, 0.28438365f, 0.26491824f, -0.23418887f, 0.01002446f, 0.33455691f, 
    0.07775354f, 0.11591872f, 0.31825611f, 0.15474969f, 0.30869767f, -0.21899284f, 0.13738841f, 0.42138427f, 
    0.45966125f, -0.07509653f, 0.03748390f, 0.13934612f, 0.02323912f, 0.25953093f, 0.10804221f, 0.14739622f, 
    0.01600067f, -0.38037476f, 0.24653549f, 0.25955939f, -0.10181073f, 0.02232983f, 0.33665386f, 0.13769624f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04223975f, -0.22300158f, -0.10125038f, -0.09906562f, -0.00221152f, 0.08525728f, -0.07130564f, 0.04581302f, 
    0.20784630f, 0.17050330f, -0.07989334f, 0.13460301f, -0.51482904f, 0.08382002f, -0.19998099f, 0.06385474f, 
    -0.06868544f, 0.08206231f, 0.11336377f, 0.03501465f, 0.05428874f, -0.03881881f, 0.06558055f, -0.07087245f, 
    0.22347812f, 0.01983907f, 0.02122039f, -0.03030870f, -0.09949452f, -0.00444710f, 0.09845100f, 0.07081086f, 
    -0.14346376f, -0.02407825f, 0.01780641f, -0.07913826f, -0.03548771f, 0.07038169f, -0.08626943f, 0.22971176f, 
    0.02129346f, 0.09039887f, 0.15887272f, -0.07785776f, 0.02106351f, 0.04549274f, 0.11319933f, 0.03247492f, 
    0.30930793f, -0.09085638f, 0.30447033f, -0.15417677f, -0.07733553f, 0.03912096f, -0.03682336f, 0.08417865f, 
    -0.08768491f, -0.01915675f, 0.01561712f, 0.03199650f, -0.27200341f, -0.01097236f, -0.21590362f, 0.17503551f, 
    -0.06750958f, 0.09077033f, 0.09833149f, 0.13820451f, 0.12020735f, 0.03566968f, 0.06119014f, 0.12165321f, 
    0.01312640f, 0.90107983f, -0.12067566f, -0.08913774f, -0.04360478f, -0.05757308f, -0.09288128f, 0.03469015f, 
    -0.04336429f, -0.05508263f, 0.02015246f, -0.05629735f, -0.04939516f, -0.01060008f, 0.00899492f, 0.08072139f, 
    -0.01807341f, 0.03946450f, 0.03437177f, 0.06926776f, 0.08899183f, 0.10662840f, 0.00163743f, 0.04811453f, 
    0.16475666f, -0.05449251f, -0.09677845f, -0.00998715f, -0.01167660f, -0.03927391f, 0.16434871f, -0.07327101f, 
    -0.02619105f, 0.11063962f, -0.01206736f, 0.08090895f, -0.02900608f, -0.12482782f, -0.09646323f, -0.02970246f, 
    0.08716241f, -0.07245542f, -0.07872187f, -0.05386971f, -0.01763645f, -0.03124307f, 0.04657999f, -0.02824534f, 
    0.20415726f, -0.00642095f, 0.01102117f, 0.04926753f, -0.07257724f, 0.07471761f, 0.14483915f, -0.03146688f, 
    0.03954223f, 0.05003683f, -0.05045304f, -0.06234669f, 0.03577554f, 0.33743808f, -0.19638649f, 0.20521137f, 
    0.18078075f, 0.14905176f, 0.08239038f, 0.00971603f, 0.01227300f, -0.08943183f, -0.13983281f, 0.04184320f, 
    -0.06546908f, -0.18341540f, -0.08012110f, 0.25030047f, -0.03581058f, 0.02162207f, 0.07119911f, 0.08148319f, 
    0.08359767f, 0.11691832f, 0.20818242f, 0.07501826f, -0.09364270f, 0.13271266f, 0.00123010f, 0.02646097f, 
    0.03273533f, 0.17481707f, -0.09149078f, -0.10539575f, 0.04646663f, 0.13774370f, 0.13146490f, 0.04207904f, 
    0.17350568f, -0.24752806f, 0.50075614f, -0.27374154f, 0.00677209f, -0.05717000f, 0.05890752f, -0.23535402f, 
    -0.01787468f, 0.04537554f, 0.08262943f, 0.11174218f, -0.07228914f, 0.10723826f, -0.14457256f, 0.16212630f, 
    0.05441020f, -0.00749962f, 0.05067181f, 0.07770347f, -0.09194688f, 0.00124357f, -0.21537171f, -0.17978910f, 
    -0.12269037f, 0.01522964f, 0.03545212f, 0.04985652f, 0.04947073f, -0.04896406f, 0.05801952f, 0.02276171f, 
    0.16682452f, 0.09860527f, 0.06526304f, 0.16125743f, 0.26500395f, 0.25881451f, -0.32643867f, 0.20677376f, 
    0.08079878f, -0.06214209f, 0.25507435f, -0.00732292f, 0.17834617f, -0.06737856f, 0.01654205f, 0.05227948f, 
    0.18664691f, -0.35163113f, 0.10512873f, -0.07746948f, 0.03312859f, 0.03323357f, 0.09983354f, -0.14778979f, 
    0.12321483f, 0.06599491f, 0.13794069f, 0.32048270f, -0.11413306f, 0.34250236f, -0.02486255f, 0.00299374f, 
    -0.06364710f, 0.14392756f, -0.03575328f, -0.07508384f, -0.06481079f, -0.10803589f, -0.08718497f, -0.14089938f, 
    0.43739039f, -0.16692130f, 0.14240713f, -0.09972597f, -0.04862075f, 0.00511172f, -0.00133284f, 0.02123284f, 
    -0.03588852f, -0.00639589f, 0.05488085f, 0.05381600f, -0.37874275f, 0.01743710f, -0.03629787f, 0.00022457f, 
    -0.06984668f, 0.19294186f, -0.03012632f, 0.12411921f, 0.06212053f, -0.07159654f, -0.02771556f, -0.11788388f, 
    -0.12258206f, 0.16988389f, -0.35977620f, 0.17812811f, 0.02346062f, 0.05511650f, -0.04913957f, 0.06478124f, 
    -0.05655959f, -0.03089780f, -0.03550169f, -0.19081980f, -0.05797013f, 0.03961438f, 0.06784497f, 0.02296464f, 
    0.10934778f, 0.05500665f, -0.11685765f, 0.19325978f, 0.05100274f, -0.10512509f, 0.07478655f, -0.04084036f, 
    -0.06958965f, 0.62560588f, -0.16375597f, 0.11974844f, 0.12353919f, 0.04837827f, -0.05476243f, 0.07269432f, 
    -0.07205816f, -0.11421217f, 0.03781893f, -0.14788277f, -0.05509472f, -0.06585659f, -0.18511647f, 0.29842985f, 
    -0.02392501f, -0.03616738f, 0.13457897f, -0.02121695f, -0.01316350f, 0.11048917f, 0.25473639f, -0.01862559f, 
    0.11492457f, -0.00684074f, 0.09248855f, -0.27312115f, 0.00380941f, -0.05959837f, -0.02831018f, -0.06181068f, 
    -0.00062653f, -0.07435899f, 0.05007821f, 0.01964210f, -0.17061764f, 0.06236647f, -0.05662335f, -0.29987550f, 
    0.00023471f, -0.28306544f, -0.00016298f, 0.05424822f, -0.08766289f, -0.03580790f, 0.08840066f, 0.06243083f, 
    0.08207848f, 0.12129125f, -0.09878946f, 0.14780077f, -0.08069001f, 0.03094104f, -0.08980119f, 0.05041609f, 
    -0.05814623f, 0.04139061f, 0.00094425f, 0.19660430f, -0.09537270f, -0.13486306f, -0.14066599f, -0.11056984f, 
    -0.04185328f, -0.04801945f, -0.05967144f, -0.02732947f, -0.14390029f, 0.08397781f, 0.12693930f, 0.17958397f, 
    0.11481275f, -0.05030143f, 0.07682840f, -0.15924789f, 0.01936081f, 0.01549064f, 0.13641542f, -0.03584476f, 
    -0.03132135f, -0.03503548f, 0.08478682f, 0.15501964f, 0.22351114f, 0.06115737f, 0.08391113f, -0.29535282f, 
    -0.21880093f, 0.01343130f, -0.03778207f, -0.12956138f, 0.01858361f, -0.01435920f, -0.07951128f, -0.02827335f, 
    0.06674249f, -0.06640439f, 0.12593912f, -0.15397465f, -0.00329103f, 0.06247424f, -0.07870726f, 0.16448207f, 
    -0.02046352f, 0.02316948f, 0.05054346f, 0.06459919f, -0.00511094f, -0.02905771f, -0.04290235f, 0.04648695f, 
    -0.00320987f, 0.00504392f, 0.02839963f, 0.06868063f, -0.10838866f, 0.00802467f, 0.06134202f, 0.09267063f, 
    0.30478650f, -0.14865816f, 0.22889051f, -0.09242038f, 0.05633957f, 0.10714786f, -0.10316421f, -0.13102025f, 
    -0.04214455f, -0.08319137f, -0.05300591f, 0.10490165f, -0.23546858f, 0.02464863f, -0.00124206f, 0.15535867f, 
    0.04828570f, 0.10888579f, 0.07973439f, 0.05650467f, -0.12199417f, -0.07343962f, 0.05032006f, -0.05836574f, 
    0.12372530f, -0.00198436f, -0.22193861f, 0.13225622f, 0.04945912f, -0.07246050f, 0.05911674f, 0.01588120f, 
    -0.09333630f, 0.01176994f, 0.04506150f, 0.00267094f, 0.08690587f, 0.00732126f, -0.10549758f, -0.09447214f, 
    0.01457563f, 0.02524621f, -0.18946849f, -0.21609153f, -0.08962778f, 0.03112157f, -0.06234236f, -0.07418077f, 
    0.07417237f, -0.04452140f, 0.11492360f, -0.22661169f, -0.00042489f, 0.04850869f, -0.03836732f, -0.17778373f, 
    -0.00637408f, -0.06386906f, 0.00779514f, -0.05794942f, 0.28192195f, 0.03786326f, -0.41295671f, 0.15749712f, 
    -0.05055141f, 0.15189415f, -0.04560712f, -0.09398037f, 0.07424527f, 0.05446630f, -0.00978011f, -0.01410643f, 
    0.05354077f, -0.08456269f, 0.05339090f, 0.03424309f, -0.08335418f, -0.00573166f, 0.17417668f, -0.02407559f, 
    -0.03484688f, 0.10972229f, -0.00443592f, -0.06055714f, 0.07381597f, 0.11467856f, 0.07007167f, -0.03911123f, 
    0.12627837f, -0.10705853f, -0.06243331f, 0.07800457f, 0.03882284f, -0.10381483f, 0.04423494f, 0.11829125f, 
    -0.15913692f, -0.11942248f, -0.02890498f, 0.18392415f, 0.11214364f, -0.04731660f, -0.01393947f, 0.02290233f, 
    0.04585323f, -0.07509480f, -0.13483697f, -0.21409814f, -0.10332143f, 0.17875166f, -0.13206387f, 0.11178593f, 
    -0.02518565f, -0.21374725f, 0.00971367f, 0.22835246f, -0.04864942f, -0.09890303f, 0.16867246f, -0.00370678f, 
    0.26043233f, 0.05149542f, -0.24217419f, 0.31240824f, -0.14732726f, -0.02488642f, 0.06366824f, 0.09380305f, 
    0.04544206f, -0.07867183f, 0.10269567f, -0.16543214f, -0.16194019f, -0.08292051f, 0.01602601f, 0.00128150f, 
    -0.06585290f, 0.00230734f, -0.09930249f, -0.09144803f, 0.02922994f, -0.10651600f, 0.04899601f, -0.11636563f, 
    0.22462119f, -0.06370685f, 0.27384090f, -0.08440785f, 0.02035574f, -0.04556187f, -0.17446502f, -0.03613352f, 
    -0.02120642f, -0.07464113f, 0.02396615f, 0.02482715f, 0.15324716f, 0.47817951f, -0.21510573f, 0.23074725f, 
    0.01088796f, 0.11907446f, -0.06143707f, 0.04220879f, -0.04220176f, -0.06283897f, 0.05109273f, -0.00994597f, 
    0.06770462f, 0.28735569f, 0.29097041f, 0.26143774f, -0.03085379f, -0.05418809f, -0.00672476f, 0.06376654f, 
    -0.06103440f, 0.05799809f, -0.01200274f, 0.10966664f, 0.03462717f, -0.20425449f, 0.01667573f, -0.04340374f, 
    0.00567116f, -0.04765364f, 0.05012833f, -0.15331267f, 0.05955831f, -0.02060913f, 0.02517823f, 0.00658963f, 
    -0.15188889f, -0.16783777f, -0.03408713f, 0.00397936f, 0.16718158f, 0.06729352f, -0.10869659f, 0.20022851f, 
    -0.10552161f, -0.07202920f, -0.26356670f, -0.06849994f, 0.10674562f, 0.03821759f, -0.17064148f, 0.17946108f, 
    0.03203885f, -0.11668971f, 0.02578667f, 0.07629349f, -0.08671248f, -0.09710550f, -0.16967532f, -0.05911826f, 
    0.16638079f, 0.00709204f, 0.05662874f, 0.08719394f, 0.09078249f, 0.04568364f, 0.14079148f, -0.10977583f, 
    -0.06212331f, -0.03292603f, -0.01264642f, -0.10424975f, -0.02789403f, 0.11417349f, 0.05548762f, -0.20503864f, 
    -0.09791562f, -0.11966740f, 0.02100441f, -0.03803355f, 0.02345028f, -0.02868696f, 0.07642001f, 0.05286639f, 
    0.07989448f, 0.06827355f, 0.30592597f, 0.01863188f, 0.02228810f, -0.02425725f, -0.03772307f, -0.04521556f, 
    -0.01460125f, -0.03414102f, 0.12447906f, -0.01430987f, -0.09891017f, 0.08490639f, 0.01236200f, 0.02760109f, 
    0.01171301f, -0.00541899f, 0.00405525f, -0.02355646f, -0.01429342f, -0.05269092f, -0.02855414f, -0.06013409f, 
    0.06188340f, 0.02303047f, 0.00872281f, 0.15003742f, 0.01259873f, 0.00637141f, 0.03095534f, 0.03380575f, 
    0.01217472f, 0.07790451f, -0.04852368f, 0.04819208f, 0.21427768f, 0.37959370f, 0.19425857f, 0.36919880f, 
    -0.04816907f, 0.13763542f, 0.00648389f, -0.08578742f, -0.06828981f, 0.05521143f, 0.02928881f, -0.02088811f, 
    0.12253989f, 0.04470050f, 0.12120046f, -0.08468312f, 0.00109552f, -0.02022934f, -0.00135716f, -0.02991791f, 
    0.04017125f, 0.09980971f, 0.17299360f, 0.15155210f, 0.13084656f, -0.04148930f, 0.22036198f, 0.00470741f, 
    -0.01458910f, 0.04336820f, -0.07312772f, 0.11163411f, -0.00138780f, -0.10280854f, -0.07152724f, -0.05346628f, 
    0.03995285f, 0.10993211f, -0.08175313f, 0.19827481f, -0.06200535f, -0.10005366f, 0.08767888f, -0.01811346f, 
    0.00698793f, 0.00815550f, -0.05178878f, -0.01239963f, -0.05338949f, 0.03958909f, 0.02020124f, 0.02571929f, 
    -0.03214893f, 0.03224140f, 0.05743371f, 0.07071967f, -0.06660173f, -0.00674535f, -0.01147489f, 0.05720529f, 
    -0.00911547f, -0.04346775f, -0.08876586f, -0.22683875f, -0.17983170f, 0.06178703f, 0.07701516f, 0.08599142f, 
    0.03599993f, 0.05173220f, 0.04032391f, -0.02281247f, -0.24214603f, 0.14276251f, 0.09051253f, -0.02721919f, 
    -0.13628487f, -0.11768645f, 0.02749440f, -0.11511386f, 0.07366991f, 0.02904714f, 0.05317531f, 0.01443857f, 
    -0.01246292f, -0.00017135f, -0.00642779f, 0.02208910f, -0.00832231f, -0.01231300f, -0.02784166f, -0.03481025f, 
    0.01088654f, 0.00667384f, -0.04417010f, -0.01878706f, 0.02620929f, -0.04049838f, 0.03152798f, -0.03566383f, 
    -0.02985509f, -0.00253430f, 0.02920227f, -0.04064784f, -0.01692026f, -0.01427527f, 0.01173378f, -0.02237039f, 
    0.00996843f, -0.01868241f, -0.02182438f, -0.00678876f, -0.00844172f, -0.03783840f, -0.03973757f, 0.01596426f, 
    -0.03428552f, 0.01698044f, 0.02301213f, 0.02813286f, 0.02669040f, -0.01896117f, -0.02094459f, 0.01395339f, 
    -0.00380425f, 0.02521330f, 0.03163748f, -0.00973611f, 0.01557804f, 0.02089080f, -0.03685781f, -0.02222101f, 
    -0.03339309f, 0.01167303f, -0.03093447f, -0.03623950f, -0.01443859f, -0.00652053f, -0.04137935f, -0.01342009f, 
    -0.00084835f, 0.00906561f, 0.02137614f, -0.02541164f, -0.03063201f, -0.01896007f, -0.02949889f, -0.03553241f, 
    -0.02457252f, 0.02332029f, -0.00069503f, 0.03104863f, 0.01127178f, -0.01535637f, -0.02525973f, -0.01107335f, 
    0.00367197f, -0.02053444f, 0.02956021f, 0.00840269f, -0.03399809f, -0.01721670f, -0.03743761f, -0.03216843f, 
    -0.02563512f, 0.00964809f, -0.03956498f, 0.00465985f, -0.02055776f, -0.02619571f, -0.02863581f, 0.02031294f, 
    0.01836835f, -0.02560985f, -0.02027892f, 0.01207796f, -0.00836422f, 0.00052476f, -0.04029214f, 0.02368444f, 
    -0.01874672f, 0.00363276f, 0.02815852f, -0.04327096f, 0.01799820f, -0.00337650f, 0.02320802f, -0.01837509f, 
    -0.03189401f, -0.01241808f, 0.01202126f, -0.00043273f, -0.02030338f, -0.00333371f, -0.00841872f, -0.02573029f, 
    -0.02545237f, 0.02167815f, 0.02677731f, -0.03064481f, -0.03966172f, -0.03294212f, 0.02417349f, -0.02204512f, 
    -0.00384963f, 0.00260898f, 0.00127853f, -0.03831447f, 0.00000605f, -0.02806129f, 0.01106788f, -0.02138783f, 
    0.01125360f, -0.03668872f, 0.02379639f, -0.01269170f, -0.01523434f, -0.00159530f, -0.04203042f, -0.03918483f, 
    -0.02082107f, 0.02628804f, 0.00281416f, 0.01468003f, -0.02323121f, -0.03584251f, 0.00826825f, 0.00726683f, 
    -0.00602245f, -0.03072898f, -0.03170324f, -0.03043381f, -0.04413162f, -0.00790950f, -0.00322514f, -0.04020885f, 
    -0.03935540f, 0.02807005f, 0.01507956f, 0.01651122f, 0.02770968f, 0.00107980f, 0.02172053f, -0.01483425f, 
    -0.03790362f, -0.02673348f, 0.02332386f, 0.01612113f, 0.02772519f, 0.01048088f, -0.03501534f, 0.01711849f, 
    0.02386923f, 0.00277900f, -0.03336533f, 0.01588955f, 0.00395700f, -0.02614159f, -0.01749796f, 0.00446735f, 
    -0.02718937f, 0.00236619f, 0.00040834f, 0.00980578f, 0.02189106f, 0.02196783f, -0.03548938f, 0.02709269f, 
    -0.02429399f, 0.01806746f, 0.00204401f, -0.00748299f, -0.01994906f, -0.02791052f, -0.03733618f, 0.02584044f, 
    0.01521105f, -0.01997625f, 0.00456724f, -0.00089418f, 0.02035468f, -0.00822153f, 0.00074025f, 0.02588082f, 
    0.01497151f, 0.00980726f, 0.01280612f, -0.00387320f, -0.00200479f, -0.04296936f, 0.01736587f, 0.02422032f, 
    -0.02977505f, -0.03657066f, -0.00574244f, 0.00906493f, -0.03374771f, -0.01554270f, -0.00748671f, -0.01008508f, 
    -0.01995137f, -0.00708329f, -0.02142375f, 0.02044993f, 0.01356051f, 0.00797068f, -0.02610067f, 0.01461324f, 
    0.01283250f, 0.02360666f, -0.00083576f, -0.03997046f, -0.01526722f, 0.01785395f, 0.02496880f, 0.01320225f, 
    0.00014377f, -0.01485353f, -0.03769170f, -0.00115055f, 0.00736408f, 0.02717909f, 0.02209709f, -0.03519930f, 
    0.01417156f, 0.01110062f, -0.01527021f, 0.00729149f, 0.02840897f, 0.02268937f, -0.02908153f, -0.02684425f, 
    0.02088761f, -0.01175168f, 0.01739044f, 0.00418416f, -0.00604214f, 0.01840250f, -0.01593296f, 0.02631579f, 
    -0.01341182f, -0.00539895f, -0.04173749f, -0.01153888f, -0.01184519f, -0.04119212f, -0.02521045f, -0.00318016f, 
    0.01546754f, 0.00425310f, 0.02697754f, -0.00839810f, -0.02434506f, 0.02405708f, 0.02262440f, -0.00865691f, 
    0.00610375f, -0.03131460f, 0.02129196f, -0.02174457f, -0.04359210f, -0.02736034f, -0.03981131f, -0.00149252f, 
    0.00698386f, -0.01451264f, -0.02658856f, -0.02699726f, 0.01407523f, -0.03185254f, 0.02149735f, 0.01866686f, 
    0.01038000f, 0.02341731f, 0.00400061f, -0.03347465f, 0.01543006f, -0.03201218f, -0.01392042f, 0.02156327f, 
    0.01650152f, -0.01020031f, -0.01046352f, -0.01792883f, 0.01255565f, 0.01847407f, -0.01791855f, 0.01437889f, 
    -0.04360096f, -0.03329722f, 0.00355825f, 0.02362198f, -0.00478781f, 0.00360068f, -0.01103956f, -0.03652826f, 
    -0.02698715f, -0.01312914f, 0.01835763f, -0.04215402f, -0.02616909f, -0.01257237f, -0.03603100f, -0.02954261f, 
    -0.00931971f, -0.02521699f, 0.01745577f, 0.00652411f, -0.03816670f, 0.01661455f, -0.02288090f, 0.01883595f, 
    -0.01452773f, -0.01919026f, -0.03141964f, -0.02318126f, 0.01664701f, -0.03156810f, 0.01503070f, 0.02636447f, 
    0.02348424f, -0.01876837f, 0.01022388f, -0.01719776f, -0.01546879f, 0.02136859f, 0.01389683f, -0.01245174f, 
    -0.01214839f, -0.00043937f, -0.02278755f, -0.01024313f, -0.01381088f, 0.02242092f, -0.02557856f, -0.02040164f, 
    0.01546574f, -0.00191679f, -0.02629967f, 0.00337743f, 0.02588038f, -0.03049673f, -0.01549073f, -0.04123186f, 
    0.01487800f, -0.00967755f, -0.03098764f, -0.00520344f, 0.00499790f, -0.01304768f, -0.03301384f, -0.03328415f, 
    -0.00751751f, -0.01547019f, 0.00960819f, -0.02656446f, 0.00717551f, -0.03183400f, 0.00321809f, 0.01074507f, 
    0.02362340f, -0.02406061f, -0.00893753f, 0.01684709f, 0.00324078f, -0.00871107f, 0.01988368f, -0.00104209f, 
    -0.02640228f, -0.02969767f, -0.01664684f, 0.01092151f, -0.00415990f, -0.01173040f, -0.01763630f, -0.02009260f, 
    -0.00022574f, -0.02375089f, -0.03125122f, -0.01934046f, -0.02309334f, 0.00678779f, -0.01778743f, 0.00737497f, 
    -0.00504304f, 0.01504855f, 0.02470888f, -0.03644036f, -0.03945557f, -0.01222236f, -0.00761307f, -0.03647119f, 
    -0.01532373f, -0.00228037f, -0.02994739f, 0.00742003f, -0.03285670f, 0.01873237f, -0.02162822f, -0.01402896f, 
    -0.01729763f, -0.01136359f, -0.00392323f, -0.02950942f, -0.01991221f, 0.01586407f, -0.00133708f, -0.02363973f, 
    -0.00328473f, -0.03109930f, -0.03988925f, 0.02666395f, -0.04016039f, 0.00013421f, 0.02488514f, 0.02108106f, 
    0.02243947f, -0.02747715f, 0.01225546f, -0.03200316f, -0.02452685f, -0.00355320f, -0.02343835f, -0.03931882f, 
    0.01777561f, -0.01402005f, -0.03851948f, 0.01148751f, -0.02761110f, -0.00204447f, -0.00882911f, -0.04345841f, 
    -0.00397812f, 0.00760772f, -0.03292360f, 0.02703340f, 0.00414807f, -0.02789426f, 0.01431387f, 0.02975933f, 
    0.00104272f, -0.01933694f, -0.02758127f, -0.01338030f, 0.02168257f, -0.01840715f, -0.00400743f, -0.01874781f, 
    0.00221032f, 0.00961149f, 0.00071122f, 0.00135167f, -0.02546572f, 0.01243164f, -0.00018884f, -0.01767163f, 
    0.01030366f, -0.04313675f, -0.00898940f, -0.02806802f, -0.03211841f, 0.00208753f, 0.02235844f, -0.00039327f, 
    -0.02123288f, 0.02562822f, 0.00515753f, -0.01754603f, -0.01829387f, -0.01673482f, -0.03481387f, -0.01420161f, 
    0.00402724f, 0.02884769f, 0.01431380f, -0.00864654f, 0.02367402f, -0.04153280f, 0.00818462f, -0.01306281f, 
    0.01961775f, -0.04007373f, -0.01103980f, -0.03459832f, -0.03739936f, -0.01679203f, -0.02101518f, -0.01344990f, 
    -0.02931805f, 0.00168916f, 0.01463134f, 0.02660503f, 0.01268306f, 0.00546785f, -0.03421789f, 0.01398897f, 
    0.01095947f, -0.00869821f, -0.02199999f, -0.03307739f, -0.00266437f, 0.01863682f, -0.00315743f, -0.03654822f, 
    0.00927803f, 0.00168711f, 0.01251835f, -0.03964543f, 0.02158730f, 0.00154125f, -0.03228888f, -0.02202364f, 
    -0.04116186f, 0.01689693f, 0.00737588f, -0.01288912f, 0.02112674f, 0.02529480f, -0.00788032f, -0.01566614f, 
    0.01990806f, 0.01072193f, 0.02385919f, -0.00246803f, -0.00912808f, 0.01138354f, -0.04333627f, 0.00335098f, 
    -0.01174416f, 0.02422879f, 0.01768391f, -0.00954925f, 0.01141866f, -0.00815958f, -0.00930547f, -0.01146551f, 
    -0.03777721f, -0.00535801f, -0.01573250f, 0.00211076f, 0.00810099f, -0.00369669f, -0.03559228f, 0.01215337f, 
    0.01649113f, 0.02158769f, 0.02049295f, -0.03311348f, -0.03889060f, -0.02101552f, -0.00604339f, 0.02467856f, 
    -0.00166465f, 0.00759566f, 0.01782182f, 0.00744620f, -0.01558180f, -0.03324036f, 0.02666463f, 0.01945451f, 
    -0.03325800f, -0.00928543f, 0.02232621f, -0.00306051f, -0.00850900f, 0.01330280f, -0.03983065f, -0.00441927f, 
    -0.03327087f, 0.00874198f, 0.02321560f, -0.02828265f, -0.03567761f, 0.01064595f, 0.03295650f, 0.01919781f, 
    -0.02787917f, 0.02172342f, -0.01546030f, 0.02368227f, -0.00752118f, 0.01555384f, -0.02573420f, 0.00416311f, 
    -0.00086902f, -0.00311518f, -0.00433677f, -0.02939586f, -0.02278762f, -0.01642467f, 0.00722919f, -0.01485393f, 
    0.01848304f, 0.00016153f, -0.00769061f, 0.02327812f, 0.01041084f, 0.01609550f, -0.03024174f, -0.00505001f, 
    0.02198125f, -0.00048402f, 0.00698956f, -0.03416248f, -0.04060367f, 0.02806953f, -0.03815659f, 0.00642396f, 
    0.02688060f, -0.02433145f, -0.03194583f, 0.02402454f, -0.00057052f, 0.02204635f, -0.00308925f, 0.02390173f, 
    -0.01632766f, -0.00387006f, 0.00787906f, -0.01546914f, 0.02168502f, -0.01207806f, -0.02387024f, 0.01098328f, 
    -0.04180925f, 0.02567967f, -0.01113326f, 0.00349335f, -0.01262837f, 0.01703518f, 0.00668192f, 0.00766985f, 
    0.02636496f, -0.02421158f, 0.00498935f, -0.00424351f, -0.00728137f, 0.01095616f, 0.00470142f, 0.01615627f, 
    -0.00988119f, -0.01841675f, -0.00761215f, 0.00358892f, -0.00327037f, -0.03634274f, -0.04181977f, -0.03657744f, 
    0.02589350f, -0.02112119f, -0.01262068f, 0.01173411f, -0.04157240f, -0.03056008f, 0.00392250f, -0.00697655f, 
    0.02029248f, -0.01788710f, -0.02275155f, 0.00220430f, 0.00458695f, 0.02116208f, -0.02976946f, -0.02180433f, 
    -0.01885190f, -0.00741841f, -0.01822325f, 0.02066524f, -0.02649530f, -0.03246667f, 0.00642251f, 0.02755831f, 
    0.01055096f, 0.01410086f, -0.00240655f, -0.03306473f, 0.02143292f, -0.04054968f, -0.01060106f, 0.00053762f, 
    0.02533647f, 0.01181509f, -0.00903365f, 0.02536888f, -0.00679708f, -0.01788713f, -0.01060367f, 0.03125174f, 
    0.01831972f, -0.04026886f, 0.00112368f, 0.02233653f, -0.03496104f, 0.02143092f, -0.00239211f, 0.00351186f, 
    -0.02394003f, -0.03579995f, -0.00355354f, 0.01510866f, 0.00738429f, -0.01259691f, -0.02404232f, -0.01037140f, 
    0.00704074f, -0.02595186f, -0.04181020f, -0.03846567f, -0.02439356f, -0.01430619f, -0.03212932f, -0.02412283f, 
    -0.02778897f, -0.01321082f, -0.01711008f, -0.04290359f, 0.00472734f, 0.02338666f, -0.01904238f, -0.02508155f, 
    -0.02053808f, 0.00853821f, -0.02303153f, -0.01935393f, -0.00408855f, 0.00584226f, -0.02496352f, 0.00458771f, 
    0.02113482f, 0.00124667f, -0.02989105f, 0.01999376f, 0.00326319f, 0.02837205f, -0.01937245f, 0.00024869f, 
    -0.03754679f, -0.02048079f, -0.00011900f, 0.01243543f, 0.01628298f, 0.01882741f, -0.00571166f, 0.02667282f, 
    -0.02295912f, 0.00694633f, 0.00710869f, -0.01661771f, -0.03684567f, -0.01045737f, 0.01939465f, -0.04298070f, 
    -0.12548745f, -0.06647281f, -0.05380052f, -0.12237952f, -0.05139331f, -0.03640994f, 0.01970388f, -0.06839602f, 
    0.08651066f, -0.08378174f, 0.02468524f, -0.12840167f, 0.35482603f, -0.05301077f, 0.22723275f, 0.21828198f, 
    -0.20047513f, 0.04713762f, -0.05869858f, 0.02816181f, 0.00982664f, 0.06867787f, -0.01332581f, -0.04170366f, 
    0.08884016f, 0.01582918f, 0.00032852f, 0.11658489f, -0.03433714f, -0.06341507f, 0.05183335f, 0.08038472f, 
    -0.01921020f, 0.02567373f, 0.10185239f, 0.01562619f, 0.23984101f, -0.31844655f, 0.20734581f, -0.10732754f, 
    -0.16201831f, -0.07149741f, -0.15059549f, 0.06210965f, 0.06377405f, -0.06697959f, 0.11738221f, -0.05742057f, 
    0.03204409f, 0.01024770f, -0.20378748f, 0.00982161f, 0.07395212f, -0.00413854f, 0.17267583f, 0.03463031f, 
    0.03072495f, -0.03039249f, -0.12039183f, 0.10206295f, 0.03040792f, 0.37841350f, 0.17105913f, 0.08476685f, 
    -0.09381028f, -0.09482221f, -0.10426608f, -0.08611944f, 0.06258182f, -0.05296968f, -0.17212476f, 0.04606988f, 
    -0.20843342f, -0.31325313f, 0.04774403f, -0.10081104f, 0.00129615f, 0.11168791f, 0.11348473f, 0.14398447f, 
    0.05305576f, -0.05103365f, -0.04592219f, 0.00031704f, 0.13751914f, 0.02060921f, 0.03922998f, -0.10622603f, 
    0.04361068f, -0.04939325f, 0.06485793f, 0.04833056f, 0.05927315f, 0.19681293f, 0.09536996f, 0.04345299f, 
    0.15460257f, -0.04542073f, -0.06071282f, 0.04332380f, 0.05051286f, -0.07029510f, 0.00375065f, 0.15486309f, 
    0.10882779f, 0.09540992f, 0.02186073f, -0.03106142f, -0.02338572f, -0.09442542f, 0.35458750f, -0.06685285f, 
    0.00768680f, -0.05890958f, -0.05506526f, 0.03845270f, 0.05025680f, -0.12029008f, 0.02281814f, 0.02815900f, 
    0.00723455f, 0.17080896f, -0.00663421f, -0.16283616f, -0.10855743f, -0.09834192f, -0.02843617f, 0.03889832f, 
    0.10695604f, -0.03836953f, 0.05204958f, 0.06710467f, -0.02758705f, -0.06485878f, -0.06664495f, 0.11660413f, 
    -0.02448149f, -0.10210750f, -0.05631812f, 0.20068827f, 0.01780473f, 0.15993564f, 0.03598633f, 0.03108888f, 
    0.01518794f, -0.09594889f, 0.02201023f, -0.07862759f, -0.03079417f, -0.09860127f, -0.06621435f, 0.00159671f, 
    0.02831642f, -0.06445224f, 0.09833701f, -0.17178673f, -0.16460045f, -0.07852248f, 0.10670871f, -0.16035709f, 
    0.04354601f, -0.10358503f, -0.03974162f, -0.09950718f, 0.01708907f, -0.22192247f, -0.14444165f, 0.09792992f, 
    0.10176966f, 0.33644623f, -0.35879457f, -0.16442029f, -0.07932229f, -0.13725562f, 0.01097428f, 0.30245939f, 
    -0.01939590f, 0.03493972f, 0.01150580f, -0.01163783f, 0.08409449f, -0.07488576f, 0.02283832f, -0.08026234f, 
    0.07007378f, 0.25549433f, -0.03393310f, 0.02976226f, 0.07203973f, -0.10941994f, 0.03303652f, 0.11525422f, 
    0.09890499f, -0.08836208f, 0.11919268f, 0.15225388f, -0.00438601f, 0.14251518f, -0.01345833f, -0.00976671f, 
    0.07152832f, 0.02711012f, -0.08663000f, -0.08089580f, 0.13988721f, -0.44208428f, 0.29900444f, -0.26952404f, 
    0.03270805f, 0.12334090f, -0.31430152f, 0.22273487f, -0.04674130f, 0.02513179f, -0.00492130f, -0.18952699f, 
    -0.14068957f, 0.03187818f, 0.24403742f, 0.13716604f, -0.01410495f, -0.06136135f, 0.00809803f, -0.10715567f, 
    0.12060111f, 0.11742425f, -0.18065329f, -0.11768694f, 0.08523790f, -0.01053687f, 0.16560520f, -0.25397196f, 
    -0.09466232f, -0.00687178f, -0.00512713f, 0.00063706f, 0.02514239f, 0.20436044f, -0.04083237f, -0.11770317f, 
    -0.39373153f, -0.04442657f, -0.04520799f, 0.14585660f, 0.07378872f, 0.08453412f, -0.12084264f, -0.02747475f, 
    -0.00438738f, -0.07579955f, -0.05600957f, -0.00233348f, 0.13328756f, 0.11498265f, -0.02137750f, 0.17654373f, 
    -0.02904484f, 0.00999510f, 0.09459359f, -0.05697434f, -0.10787391f, -0.00755041f, -0.01568390f, 0.01117663f, 
    0.27004409f, 0.01813427f, 0.20294088f, -0.28243336f, -0.11850397f, 0.05609749f, -0.00405999f, 0.09868922f, 
    0.05501599f, -0.12501657f, -0.03356674f, 0.04268424f, -0.07258765f, 0.15969548f, 0.10225108f, 0.03082113f, 
    -0.13405153f, 0.04824558f, 0.10241350f, 0.06232384f, 0.09626781f, 0.14550465f, -0.11741039f, 0.11034310f, 
    -0.40051311f, -0.23767714f, 0.15688671f, 0.20947525f, -0.07633445f, 0.19608724f, 0.07388096f, 0.03007168f, 
    0.04416561f, -0.04001160f, 0.13769934f, 0.00560051f, 0.18204631f, -0.25553101f, 0.15832312f, 0.08837239f, 
    -0.08529229f, -0.05382458f, -0.00673957f, 0.03451464f, 0.15766434f, 0.19104061f, 0.00015400f, -0.11245774f, 
    -0.07020194f, 0.15241989f, 0.14091837f, 0.12202676f, 0.15763004f, 0.02921676f, -0.03046308f, -0.10291325f, 
    -0.03711019f, 0.04416201f, -0.05879743f, 0.01959157f, -0.15112893f, 0.03485339f, 0.00395290f, 0.01656379f, 
    0.10082090f, 0.08246500f, 0.00790526f, 0.10841595f, 0.06231352f, -0.06667722f, -0.01211388f, 0.01731472f, 
    0.19165866f, 0.09555248f, 0.11681566f, -0.22201319f, -0.07398117f, -0.16645272f, 0.03694473f, 0.11772143f, 
    0.02389810f, -0.04206634f, -0.03939871f, -0.26393229f, 0.14532465f, 0.08094327f, 0.11501555f, -0.11920551f, 
    0.02556047f, -0.06560054f, 0.00372550f, 0.00663756f, -0.01633110f, -0.01395591f, -0.15593925f, -0.10191821f, 
    0.20232657f, -0.09310153f, 0.05777279f, 0.18776813f, 0.00849040f, -0.07315052f, -0.02868841f, -0.02399336f, 
    -0.00500559f, 0.13076870f, -0.11288995f, -0.04021541f, -0.00768233f, 0.29551032f, -0.12411039f, 0.04880717f, 
    0.20598865f, 0.17088775f, 0.16005252f, 0.02243116f, -0.00309682f, -0.01827840f, 0.00012541f, 0.12076755f, 
    0.01669929f, 0.07758144f, -0.05971303f, 0.14244261f, 0.02544045f, -0.11889000f, 0.01581730f, -0.09445827f, 
    -0.01642151f, -0.19236286f, -0.17077670f, -0.05036249f, 0.09866464f, 0.07494774f, 0.05191822f, 0.10458915f, 
    -0.03826884f, -0.04563030f, -0.06211952f, 0.02284154f, -0.04108926f, -0.05651701f, 0.00283015f, 0.04884395f, 
    -0.20073000f, 0.06020820f, -0.32263824f, 0.00891882f, 0.02634479f, -0.15856446f, 0.06713962f, 0.06477042f, 
    -0.15122660f, 0.11437941f, 0.02391411f, -0.02085213f, 0.15410233f, 0.13025318f, 0.23848478f, -0.18830389f, 
    -0.08784764f, -0.04767256f, -0.00915151f, 0.05250665f, -0.05577524f, 0.09049951f, 0.00904807f, -0.01593650f, 
    0.13618053f, 0.02080808f, 0.03517924f, -0.27724537f, 0.10026459f, -0.00205157f, -0.06350396f, 0.13860612f, 
    0.06528623f, 0.11007288f, -0.13499582f, 0.05941022f, -0.10146687f, -0.15356456f, 0.29167974f, 0.12815158f, 
    0.03416746f, 0.14189444f, 0.04682152f, 0.10895310f, 0.04694678f, -0.03390018f, 0.10178285f, 0.05898420f, 
    -0.19850942f, 0.07264663f, 0.12625863f, 0.11432390f, 0.08898970f, 0.07280535f, 0.09556310f, 0.11399326f, 
    0.02157958f, 0.05153769f, 0.03482061f, -0.02926077f, -0.09014817f, -0.05541408f, 0.19553272f, 0.10365451f, 
    0.15494673f, 0.13866231f, -0.09596223f, 0.24284799f, 0.07913154f, -0.05395521f, -0.15297072f, 0.06775545f, 
    0.26738641f, 0.10551877f, -0.08540361f, 0.05023062f, 0.01928165f, -0.10966811f, 0.00205972f, -0.04432526f, 
    0.01232822f, 0.02385245f, 0.05735127f, 0.03637938f, -0.04274800f, 0.02925919f, -0.21126080f, -0.15688901f, 
    -0.00419516f, -0.06284617f, 0.00988940f, 0.09291377f, -0.16645877f, 0.08989910f, 0.11164518f, -0.02523603f, 
    -0.08824261f, 0.16365154f, 0.02387020f, -0.03492684f, -0.09269129f, 0.11924378f, 0.16837753f, 0.02817512f, 
    -0.05922275f, -0.02440496f, 0.07550903f, 0.04560651f, 0.50802362f, 0.11749978f, 0.18136965f, -0.07301234f, 
    -0.04735820f, 0.06327276f, -0.14324002f, 0.28954953f, 0.19868809f, 0.13372339f, 0.20490439f, -0.16034132f, 
    0.44088638f, -0.35377714f, 0.49639621f, -0.27011991f, -0.11018407f, -0.02652936f, -0.00461064f, 0.09085112f, 
    0.02582611f, 0.09133124f, 0.20945919f, 0.13665314f, -0.10125593f, -0.02415149f, -0.15303564f, -0.15683511f, 
    0.03548726f, -0.06318040f, 0.05882325f, -0.03485532f, -0.06081143f, 0.08757795f, -0.01935447f, 0.06887332f, 
    -0.12664700f, 0.10693354f, -0.22237852f, -0.11797879f, 0.05437008f, -0.08642825f, -0.05350298f, -0.01657798f, 
    0.09673575f, -0.02525917f, -0.02010426f, 0.13062598f, 0.31115475f, -0.05707100f, 0.24247499f, -0.37853354f, 
    -0.15189755f, -0.18232323f, 0.09189782f, 0.06530825f, 0.02001620f, 0.02555927f, -0.04535908f, -0.03462277f, 
    0.27473488f, -0.08002349f, 0.00699115f, -0.02308889f, 0.03451153f, 0.01438501f, 0.06777664f, -0.05775633f, 
    0.17352229f, -0.04885974f, 0.07442359f, 0.02285076f, 0.02141462f, -0.48013893f, 0.25408342f, 0.29859117f, 
    0.00189840f, -0.13069955f, -0.16108264f, 0.11608712f, 0.13456430f, -0.00119146f, 0.02814703f, -0.10965403f, 
    -0.03139145f, 0.02892029f, 0.04887934f, -0.04837617f, -0.12577945f, 0.12730606f, 0.12043717f, 0.07108128f, 
    -0.03466636f, -0.04884162f, 0.15017484f, 0.01054304f, 0.05344238f, 0.04818519f, 0.19674639f, -0.32664812f, 
    -0.06619535f, -0.09346952f, 0.18288529f, 0.05929411f, -0.00788325f, -0.00439363f, -0.02581889f, -0.02511436f, 
    -0.13511948f, 0.05817934f, 0.06005730f, 0.04364381f, 0.00329124f, 0.05119883f, 0.01395734f, 0.18478888f, 
    0.07023462f, -0.01227984f, 0.07365891f, -0.08705511f, -0.15202998f, 0.06060783f, -0.00496584f, 0.00266989f, 
    0.08448532f, 0.07866754f, 0.09689356f, 0.09908237f, 0.01611423f, 0.08101122f, 0.05756208f, -0.03744321f, 
    0.09859367f, 0.22577801f, 0.08602438f, -0.04303175f, 0.05068647f, 0.03363536f, 0.08301675f, 0.08887945f, 
    0.04240045f, -0.03677570f, -0.09827673f, -0.14507227f, 0.01827334f, -0.10077055f, -0.06256378f, 0.01771850f, 
    -0.08882888f, 0.08310116f, 0.07142418f, 0.03435219f, 0.02872684f, -0.02083009f, -0.02606855f, -0.06413645f, 
    0.03098271f, -0.04098376f, 0.09112285f, -0.09909668f, -0.08432470f, -0.02209429f, -0.00437937f, -0.07079304f, 
    0.06588490f, 0.12247185f, -0.11414433f, 0.04021382f, -0.34413317f, 0.00758616f, 0.16892098f, -0.01090992f, 
    -0.01440854f, -0.13404839f, -0.24459377f, 0.09644310f, 0.07684599f, -0.09874356f, -0.11914701f, -0.10203964f, 
    0.23712465f, -0.11506393f, -0.07419966f, 0.06576177f, -0.00262522f, -0.01127673f, 0.02258652f, -0.00625506f, 
    -0.00487453f, 0.10664307f, -0.17735900f, 0.03101738f, -0.07415980f, 0.10397409f, -0.00035913f, -0.04197378f, 
    0.02678204f, 0.06776304f, 0.05495853f, -0.03549248f, 0.02642789f, 0.02990992f, 0.08031505f, 0.11146745f, 
    0.02504769f, -0.00447845f, -0.01998091f, -0.10021318f, -0.03130519f, 0.02007229f, -0.02722944f, 0.10029665f, 
    0.04450249f, 0.07894050f, 0.08907865f, -0.04328750f, 0.07699134f, 0.04458386f, 0.06135876f, 0.01548675f, 
    0.00044406f, -0.04574874f, -0.06208144f, 0.00128554f, 0.02130405f, -0.01926505f, -0.01937910f, 0.01870796f, 
    -0.29945627f, -0.00305310f, 0.22253436f, 0.16930228f, 0.05239404f, 0.07533911f, 0.05282707f, -0.13675885f, 
    -0.01475025f, -0.01939164f, -0.01251531f, -0.02741862f, -0.15979442f, 0.32249287f, 0.00392798f, -0.14926116f, 
    0.05079124f, -0.00847071f, 0.02868112f, -0.00427344f, -0.08997588f, -0.00953365f, 0.04708454f, 0.04734541f, 
    -0.01520299f, 0.22191180f, 0.09004304f, 0.04746338f, -0.00602561f, 0.05207038f, -0.00207817f, -0.04369060f, 
    0.27749172f, 0.11975636f, 0.02581269f, 0.20595647f, 0.56664383f, -0.05862409f, 0.46045002f, -0.07204627f, 
    0.10674877f, 0.10680225f, 0.01226140f, -0.04900115f, -0.12252205f, -0.11259904f, 0.02133846f, 0.00638208f, 
    -0.05693176f, -0.00556496f, -0.24677068f, -0.05283423f, 0.14630479f, 0.02669007f, -0.06806191f, -0.05872900f, 
    0.08654827f, -0.10384481f, -0.02394112f, 0.11346751f, 0.29426509f, 0.01610379f, 0.16761763f, 0.25319883f, 
    0.04399655f, 0.13057765f, 0.07953426f, -0.09974819f, 0.09764495f, 0.07396656f, 0.02560753f, 0.16939130f, 
    -0.35816675f, -0.13235389f, 0.05952987f, -0.09318873f, -0.03713781f, -0.02964104f, -0.04222484f, 0.03353837f, 
    -0.05492689f, -0.09672976f, 0.07538841f, -0.09809687f, 0.39241260f, 0.11565970f, 0.23288794f, 0.50016141f, 
    0.00416218f, 0.01496821f, -0.05048008f, 0.05988145f, -0.06789795f, -0.01047108f, -0.06866828f, 0.10954521f, 
    -0.29780200f, 0.09468322f, -0.02546368f, 0.09089139f, -0.04888377f, -0.01180525f, -0.08561277f, -0.09871323f, 
    -0.03729270f, -0.07833363f, 0.02161719f, -0.02124402f, 0.10393088f, 0.13611048f, 0.10819395f, 0.08980213f, 
    0.04462845f, -0.03091450f, -0.00323563f, 0.08587359f, 0.09025601f, 0.13080245f, 0.10563564f, 0.10182844f, 
    0.03514803f, -0.09975494f, 0.00143701f, 0.03345857f, 0.04121929f, -0.15389004f, -0.09334686f, 0.01763453f, 
    -0.00503436f, 0.07238235f, -0.06591565f, 0.10164848f, 0.21804881f, 0.14082155f, -0.06369442f, -0.09776343f, 
    0.10313090f, 0.04135927f, 0.06804129f, 0.24246487f, 0.03341230f, -0.04377716f, -0.03652364f, 0.05010977f, 
    0.12019529f, 0.30473864f, 0.29227588f, 0.19143304f, 0.06058053f, -0.03974466f, 0.06412393f, -0.12772022f, 
    0.14261512f, 0.06908774f, 0.07472452f, 0.12419441f, 0.09476183f, -0.17047444f, -0.11413098f, -0.19192807f, 
    0.12329099f, -0.01686460f, -0.04699782f, 0.07235269f, 0.09200072f, -0.10088090f, -0.28224313f, 0.04941349f, 
    0.18653055f, -0.05576049f, -0.04677081f, 0.15818165f, 0.01411056f, -0.02438039f, 0.02770160f, 0.06538083f, 
    0.11385399f, 0.10267268f, 0.23901497f, 0.18396404f, 0.04158911f, -0.05304254f, 0.19239928f, 0.03130249f, 
    0.04946491f, 0.11005326f, 0.05666383f, 0.02925523f, 0.03536147f, 0.17655486f, 0.27836418f, 0.22164871f, 
    -0.03399570f, -0.16531384f, -0.34799290f, -0.23135614f, 0.01573480f, 0.02490811f, -0.07405619f, 0.10289589f, 
    -0.01093417f, 0.02767537f, -0.05165634f, 0.02631488f, -0.08612693f, -0.05438210f, 0.06502479f, -0.07945722f, 
    -0.06581431f, -0.00896155f, -0.03454527f, 0.00132152f, -0.00696987f, 0.04654972f, -0.06763823f, -0.08300400f, 
    -0.11465900f, 0.08961719f, -0.13009994f, -0.12246436f, -0.05754311f, -0.06913175f, -0.03296244f, 0.06177235f, 
    0.00574134f, 0.00153156f, 0.04756020f, 0.03336963f, 0.43469715f, 0.20677650f, -0.15884617f, -0.21200909f, 
    -0.07552351f, 0.04030547f, 0.02875770f, -0.02071099f, 0.13878912f, -0.05587401f, -0.02656406f, -0.04323264f, 
    0.25125602f, 0.06980710f, -0.19082102f, -0.30474204f, 0.08000704f, -0.01653213f, 0.07153863f, 0.11872953f, 
    -0.03842196f, 0.05261815f, 0.00839498f, -0.00412692f, 0.15154602f, 0.05241469f, 0.26308063f, 0.20920627f, 
    0.12688051f, -0.00937038f, -0.05991975f, -0.00341978f, 0.03740333f, -0.15947779f, 0.10748271f, 0.04704920f, 
    -0.44682869f, -0.11789911f, -0.09167190f, -0.20923448f, -0.10477836f, -0.08454434f, -0.16678753f, -0.13260227f, 
    0.03139834f, -0.15434517f, 0.01593501f, -0.00867148f, 0.00095207f, 0.31322393f, 0.04244589f, -0.08098833f, 
    0.18491904f, 0.05486812f, 0.09174455f, 0.00137323f, -0.06148366f, -0.01911040f, 0.05010787f, -0.10993984f, 
    0.33078414f, -0.38499674f, 0.26709664f, -0.13130563f, 0.04770895f, 0.07260195f, -0.00035349f, -0.00531304f, 
    0.05630933f, 0.13100874f, -0.01675351f, 0.02805197f, -0.16468386f, 0.00826987f, -0.24307126f, -0.32909039f, 
    0.02547089f, 0.11764141f, -0.19582123f, 0.04519520f, 0.04450744f, 0.02528302f, -0.06637333f, -0.19725090f, 
    0.19285850f, -0.02356115f, 0.06592494f, -0.15016684f, 0.02036223f, -0.01146172f, 0.05177450f, 0.00122404f, 
    0.01054002f, -0.05671869f, 0.04219386f, 0.14849307f, 0.09926835f, 0.28833899f, 0.19113567f, 0.09400302f, 
    -0.01558033f, 0.07747471f, -0.11895566f, 0.16729327f, -0.04588041f, 0.02853681f, 0.32092407f, -0.20924923f, 
    0.18877205f, 0.00787210f, 0.02637145f, -0.04812590f, 0.02740585f, 0.14377911f, 0.20219912f, 0.15746464f, 
    -0.00717663f, -0.02981503f, 0.00619977f, -0.07631890f, 0.12496046f, 0.16335745f, -0.09220720f, -0.08892668f, 
    0.09746146f, 0.11057603f, 0.07344616f, 0.24395701f, -0.03189646f, -0.05780056f, 0.02699390f, -0.07260834f, 
    0.38219947f, 0.14340723f, 0.29897198f, 0.17515804f, -0.00768919f, 0.03597105f, -0.02744227f, -0.07827134f, 
    0.16551086f, 0.12751456f, -0.07690397f, 0.14374019f, 0.03292573f, -0.21441166f, 0.18308525f, 0.03279941f, 
    0.04737795f, -0.06039897f, -0.01211074f, -0.09669726f, 0.11105835f, 0.12346836f, 0.02099703f, 0.18718362f, 
    0.18839455f, -0.09727894f, -0.07855693f, -0.04799229f, -0.04152010f, -0.00140314f, -0.00270090f, 0.01855791f, 
    0.10769283f, -0.00940922f, 0.13520113f, 0.07237162f, -0.01363873f, 0.05755276f, 0.03538376f, -0.14721444f, 
    0.00702351f, -0.04911491f, 0.02766531f, -0.05204052f, -0.04304085f, 0.01876646f, -0.08208554f, -0.09316366f, 
    -0.21022931f, -0.03419671f, -0.04982090f, 0.17086989f, 0.07116546f, 0.03618085f, -0.05706429f, -0.04684994f, 
    0.16571507f, 0.10275985f, 0.11215778f, 0.31374526f, 0.04110954f, 0.02241996f, 0.09955281f, 0.23328654f, 
    -0.04518285f, 0.02251974f, -0.11264081f, 0.01685137f, -0.06642125f, 0.00153221f, 0.03692137f, 0.00636431f, 
    -0.28834286f, 0.00983948f, -0.14041866f, 0.03462202f, 0.01780382f, -0.05777491f, 0.05366203f, -0.01773182f, 
    0.20880863f, -0.03251861f, -0.09953568f, -0.00796282f, 0.21631792f, -0.02548701f, 0.11875473f, 0.11264935f, 
    -0.05128937f, 0.13130844f, 0.06963640f, -0.16553017f, -0.00983431f, -0.06718081f, 0.18011369f, 0.03159367f, 
    -0.11430683f, -0.40008926f, 0.13915947f, -0.20512523f, -0.05202207f, -0.05329929f, -0.11457218f, 0.20698807f, 
    -0.09979739f, 0.01606772f, -0.01850654f, -0.05462618f, 0.26817355f, 0.12279351f, -0.33364278f, -0.04062377f, 
    0.16642079f, 0.20478946f, 0.18081154f, 0.05795017f, -0.05029448f, -0.10308759f, -0.14480793f, -0.06527131f, 
    0.22319719f, -0.01044943f, 0.03363921f, -0.05539355f, 0.05600952f, 0.07719329f, 0.11801606f, 0.10085263f, 
    -0.02186640f, -0.10076443f, -0.08055291f, -0.00632082f, 0.04462268f, 0.39390349f, -0.16312012f, -0.04408694f, 
    0.06523258f, -0.08294656f, 0.01449282f, -0.08287907f, 0.18551061f, 0.14462808f, 0.00301038f, 0.02541052f, 
    0.22048122f, 0.03513225f, 0.22678743f, 0.19337420f, -0.08684456f, -0.14675803f, 0.01542084f, 0.02656263f, 
    -0.12860048f, -0.06984645f, 0.06869177f, -0.07608394f, -0.17580630f, -0.06636696f, -0.02664158f, -0.22364208f, 
    -0.03605955f, 0.08626289f, -0.11372593f, -0.04307745f, -0.04801187f, 0.01072039f, 0.09970095f, 0.17662515f, 
    0.00227434f, 0.16666962f, -0.25379553f, 0.06249259f, 0.12665616f, -0.04877878f, -0.07414853f, -0.01495339f, 
    -0.05883918f, 0.13511074f, -0.12598075f, -0.13335030f, 0.16880795f, -0.53394079f, -0.22433537f, -0.33586955f, 
    -0.06287611f, 0.29636788f, -0.16014342f, -0.15442488f, 0.03033981f, -0.15268895f, 0.02391280f, 0.12392326f, 
    0.14425531f, 0.15963630f, 0.04489299f, -0.10836541f, 0.08610237f, -0.13242954f, 0.06731056f, -0.27171654f, 
    0.14646599f, -0.15783007f, 0.00422635f, 0.02477054f, -0.03051969f, 0.05391249f, 0.04585908f, -0.11432248f, 
    -0.01904280f, 0.04553727f, 0.04456463f, 0.00941326f, 0.14143313f, 0.08961128f, 0.14116411f, -0.02302602f, 
    -0.55304909f, -0.19593485f, 0.01658827f, -0.15334819f, 0.08821654f, 0.03916856f, -0.07499620f, 0.08707903f, 
    0.06264251f, 0.01475110f, 0.02110807f, 0.16042131f, 0.07531310f, 0.31448266f, 0.20025630f, -0.01672004f, 
    0.13891551f, -0.03451873f, -0.06901611f, -0.14908625f, 0.12342712f, 0.04297134f, 0.11304347f, 0.17381711f, 
    -0.45559418f, -0.21361567f, 0.17015918f, -0.10490904f, 0.00794122f, -0.04981597f, -0.00190494f, -0.04206384f, 
    0.02042378f, 0.06515691f, -0.06606868f, 0.11103608f, 0.27706432f, 0.20631641f, 0.25578126f, 0.19420253f, 
    0.09747192f, 0.02199563f, -0.11996524f, 0.02775044f, 0.07604100f, 0.11489194f, -0.10030098f, 0.02227967f, 
    0.11649444f, -0.03674336f, -0.09065587f, 0.07389032f, 0.18986580f, -0.00796797f, -0.13090029f, -0.08976598f, 
    -0.10655534f, -0.03336426f, -0.06811380f, 0.01607550f, 0.15730834f, 0.04214721f, -0.00068948f, 0.21509010f, 
    0.07532198f, 0.03094998f, -0.01323661f, 0.08677922f, 0.03993044f, -0.16545811f, -0.03602456f, 0.11145188f, 
    0.27132523f, 0.12401495f, 0.15594980f, 0.24713144f, 0.04348361f, 0.22073735f, 0.02010475f, 0.19887972f, 
    -0.04747555f, -0.05573795f, -0.01116165f, 0.04382443f, 0.06634589f, 0.11676120f, -0.08386540f, 0.04760331f, 
    0.02511605f, 0.00618034f, 0.02086299f, 0.03907182f, 0.00961521f, 0.03821321f, 0.06329376f, 0.11758715f, 
    0.27184325f, 0.02337213f, 0.25906813f, 0.28151301f, 0.10802644f, 0.22693175f, 0.02640588f, 0.08965219f, 
    -0.03275661f, -0.01224529f, 0.06024972f, -0.00309457f, -0.11551484f, 0.07992624f, -0.01609673f, -0.05289023f, 
    -0.05092875f, 0.08872996f, 0.01270674f, 0.02437699f, -0.00184615f, -0.05102599f, 0.02125072f, -0.10182749f, 
    -0.11838846f, -0.08494637f, -0.00557972f, -0.03895910f, -0.03805227f, 0.08684494f, 0.01163378f, 0.07689468f, 
    -0.09195113f, 0.06218292f, 0.09260760f, -0.10131716f, 0.46494424f, 0.24978593f, 0.21816041f, 0.33315521f, 
    0.12771446f, 0.20366573f, -0.03467442f, 0.00335667f, 0.04072768f, 0.05573970f, -0.02972439f, 0.13654649f, 
    -0.15047902f, 0.14044185f, 0.09934372f, -0.03314657f, 0.03809104f, -0.01473469f, -0.01588939f, 0.07108223f, 
    -0.06811988f, 0.06564750f, 0.26826987f, 0.10000680f, -0.37416980f, -0.13243301f, -0.02419322f, 0.01296351f, 
    0.03786111f, -0.02585333f, 0.10057049f, 0.01345494f, -0.04175629f, -0.01509608f, -0.01042098f, -0.03012912f, 
    -0.21378554f, -0.24307223f, 0.12816271f, 0.09387392f, -0.15113552f, -0.12753993f, -0.03810565f, -0.08180247f, 
    0.03284878f, -0.00680716f, 0.00878632f, -0.00525570f, 0.04204211f, 0.00006505f, 0.05689000f, -0.01622984f, 
    0.00412249f, -0.00161808f, -0.07733680f, -0.00693866f, -0.01024119f, 0.00345882f, 0.03544426f, 0.01695723f, 
    0.08974108f, 0.09836625f, -0.16349635f, -0.13245669f, 0.05023894f, 0.14366269f, 0.16926000f, -0.08148390f, 
    0.09260071f, -0.06901579f, 0.04657292f, -0.07436138f, 0.06442808f, -0.30495298f, -0.32601303f, -0.35396504f, 
    0.04513973f, 0.08879244f, -0.00756871f, 0.15501198f, 0.09088168f, 0.08514044f, -0.06718948f, -0.03085994f, 
    -0.03527464f, 0.31666335f, 0.01777556f, -0.19200440f, 0.04239707f, 0.00537186f, 0.02659211f, 0.03785259f, 
    0.14133523f, 0.22998516f, -0.00520498f, -0.19548050f, 0.38473222f, -0.51022756f, 0.35030922f, 0.01641073f, 
    0.04843711f, 0.00746907f, -0.02420501f, -0.02755348f, 0.08912380f, 0.06656487f, 0.06087824f, 0.06100879f, 
    -0.05670954f, 0.15218672f, -0.07980253f, -0.00167548f, 0.07437418f, 0.04415505f, 0.06661533f, -0.06435615f, 
    0.05141580f, 0.11110052f, 0.00677635f, 0.15974703f, 0.13212511f, -0.26670560f, 0.07299529f, -0.05415238f, 
    -0.04892749f, 0.01021493f, 0.08495454f, 0.03313807f, 0.27603915f, -0.03085842f, 0.07654575f, -0.00656926f, 
    -0.24741706f, 0.17250408f, 0.12860043f, -0.03912810f, 0.10779525f, 0.12086192f, 0.05226608f, 0.06462520f, 
    0.04054743f, 0.04441072f, 0.04069905f, -0.04894213f, 0.31764132f, -0.28310040f, 0.12402713f, 0.13249205f, 
    0.03254209f, -0.05038721f, -0.08394916f, -0.03201565f, 0.21758541f, -0.00287867f, 0.09986579f, 0.02130044f, 
    0.48591530f, -0.28122422f, 0.08176368f, 0.08646324f, 0.10550938f, 0.00135657f, 0.01548651f, -0.02264515f, 
    0.08489800f, 0.02244727f, -0.01269797f, -0.02262740f, 0.05571545f, -0.03153293f, 0.04525140f, -0.04358189f, 
    -0.06909724f, -0.03298991f, 0.00525318f, -0.04361470f, 0.05781054f, -0.18443385f, 0.05372146f, 0.06357226f, 
    -0.06850412f, 0.13082853f, 0.16483401f, -0.00276743f, 0.00199639f, 0.13804349f, 0.09813133f, 0.00960704f, 
    0.00973491f, 0.09708332f, -0.04856399f, -0.03832644f, -0.23604028f, -0.30725855f, 0.25993785f, -0.25620621f, 
    0.02098621f, -0.06070122f, 0.06377000f, -0.11656130f, -0.14437351f, 0.20770609f, -0.03242617f, 0.03104097f, 
    -0.14982569f, 0.21892023f, 0.17667402f, -0.07098554f, -0.02569425f, 0.02765027f, 0.04191932f, 0.10527553f, 
    -0.06675655f, -0.07072673f, 0.09050179f, 0.08480088f, 0.25474912f, -0.03920913f, 0.06441828f, 0.02092226f, 
    0.09420657f, 0.15656956f, 0.02066442f, -0.03518201f, 0.04668730f, -0.03170493f, 0.09910796f, -0.00727161f, 
    0.01670873f, -0.07971780f, 0.08405825f, 0.12952237f, 0.00079882f, 0.00083517f, 0.01466977f, -0.03320983f, 
    0.15920295f, 0.23760189f, 0.11220378f, 0.16663732f, -0.13403212f, -0.12703639f, 0.09233811f, 0.03055042f, 
    -0.09404586f, 0.04018198f, 0.26379207f, 0.21881588f, 0.01573828f, 0.21334383f, 0.25982153f, 0.01933516f, 
    -0.18242389f, 0.23338501f, 0.01072915f, -0.00977822f, 0.18789336f, 0.17045747f, 0.04030195f, -0.04721275f, 
    0.09366150f, 0.03564302f, 0.07727452f, 0.08329289f, 0.02106122f, -0.02835136f, -0.04833541f, -0.03678588f, 
    0.05400164f, 0.02698019f, -0.00985856f, 0.03900671f, 0.07977163f, -0.00108206f, 0.00473491f, 0.03021836f, 
    0.03140175f, 0.10361696f, 0.00192484f, 0.14377603f, 0.03671510f, 0.02253342f, 0.01641234f, -0.01821958f, 
    0.01817349f, 0.17282236f, 0.11091676f, 0.07638170f, 0.37320510f, -0.40484002f, 0.01432279f, -0.07298163f, 
    0.12828586f, 0.17137182f, 0.27130058f, 0.01178582f, 0.08693894f, 0.06368798f, 0.09457175f, 0.06913868f, 
    0.28562126f, 0.18227491f, 0.15679970f, 0.07192647f, -0.03088130f, 0.15343654f, -0.00927742f, 0.11129435f, 
    0.07656778f, 0.02221936f, 0.16775550f, -0.11959823f, 0.00107460f, -0.15153341f, 0.04575292f, 0.02207663f, 
    0.04492838f, 0.02333057f, 0.17134994f, 0.09342043f, 0.00799055f, -0.04012635f, 0.08624172f, 0.12448269f, 
    0.11550557f, 0.20191404f, -0.17336744f, 0.08638562f, 0.00935124f, -0.05470606f, 0.05597755f, 0.11440919f, 
    0.09822737f, 0.02708549f, -0.03235555f, -0.02997421f, 0.27722618f, -0.22372535f, -0.00064615f, -0.04833428f, 
    0.23831488f, -0.19393446f, -0.08217001f, -0.02952499f, -0.03115036f, 0.06529579f, -0.03526598f, 0.06541838f, 
    0.02150678f, -0.20863208f, 0.25971156f, 0.09979586f, 0.06293956f, -0.02830394f, 0.00753167f, 0.00088447f, 
    0.00831842f, 0.05114842f, 0.05757927f, -0.05804163f, 0.23351216f, -0.09036056f, -0.06124882f, 0.12052940f, 
    0.36183998f, 0.00038906f, 0.00748683f, -0.06845590f, -0.03381432f, 0.04303809f, 0.02144160f, 0.11465306f, 
    0.65418196f, -0.45813328f, -0.01884214f, 0.25895098f, 0.12467580f, -0.03017505f, -0.02316207f, -0.03133347f, 
    0.09874264f, 0.02396926f, 0.01827816f, -0.07268582f, 0.07878144f, 0.07024155f, -0.01254192f, -0.06303690f, 
    0.03655396f, -0.00054462f, -0.06218016f, -0.02018970f, 0.05413591f, 0.01909997f, 0.01951508f, 0.02938985f, 
    -0.26762229f, -0.24579985f, -0.04701279f, -0.25501147f, -0.09096342f, 0.03891111f, 0.05410583f, 0.02105178f, 
    -0.02613689f, 0.05248509f, -0.00132461f, -0.00660789f, -0.08135394f, -0.09758996f, -0.21356940f, 0.17409819f, 
    0.04486101f, 0.01867774f, 0.05117281f, -0.13159734f, 0.06152958f, 0.06255046f, 0.05045763f, -0.04493091f, 
    -0.46684727f, -0.03676118f, 0.21388927f, -0.21135101f, -0.10394707f, -0.03793956f, 0.08193032f, -0.09465576f, 
    -0.00091144f, 0.22734572f, 0.33554447f, 0.11853109f, 0.03952715f, -0.05311364f, 0.16285534f, -0.06108321f, 
    0.01957595f, 0.03232748f, 0.01855918f, 0.02473990f, 0.08716089f, 0.20023884f, 0.26982787f, 0.10289019f, 
    -0.01494896f, 0.16827866f, -0.02040843f, 0.09983164f, -0.05709052f, 0.07477976f, -0.10128964f, 0.01351024f, 
    0.11763252f, 0.16827382f, 0.17149930f, 0.03749944f, -0.39751634f, 0.02061523f, -0.19819796f, -0.02933680f, 
    0.08064797f, -0.06213868f, 0.05710608f, -0.06828528f, -0.01209239f, 0.03824302f, -0.02642632f, -0.10627346f, 
    -0.08381037f, 0.05807211f, -0.08230933f, 0.03521196f, 0.00928863f, 0.01942967f, 0.05836245f, 0.04061742f, 
    -0.10622165f, 0.04858074f, 0.07726463f, 0.02708080f, 0.04013005f, 0.04592229f, 0.00580781f, -0.06014632f, 
    -0.03247305f, 0.01514304f, 0.00210305f, -0.02019425f, 0.07241149f, 0.04869850f, 0.01198509f, -0.06597160f, 
    -0.03931123f, 0.17502010f, -0.10619866f, 0.02092615f, -0.03718681f, -0.04442566f, 0.04532590f, 0.10560157f, 
    0.06941313f, 0.02760685f, -0.01698234f, 0.05559877f, 0.07725748f, -0.18920355f, 0.09235726f, -0.07824633f, 
    0.05425217f, 0.04676199f, 0.01740801f, 0.02334954f, 0.01522834f, 0.03971152f, -0.00420500f, 0.12424126f, 
    -0.02397010f, 0.04241508f, 0.27580827f, -0.24468739f, 0.02463081f, 0.22496076f, 0.18897553f, 0.00932066f, 
    -0.10638955f, 0.05917044f, 0.09756277f, -0.00286570f, -0.16899212f, -0.16499496f, -0.19295017f, -0.34151375f, 
    -0.13356660f, -0.27986515f, -0.08641369f, 0.09104417f, -0.02246495f, -0.00650019f, -0.04756729f, -0.07697029f, 
    -0.04176825f, -0.10887644f, 0.00146174f, -0.02221707f, 0.04196296f, -0.19999924f, -0.12205732f, 0.07758182f, 
    0.06280736f, -0.05377697f, -0.00076602f, 0.02457199f, 0.14150953f, -0.07724497f, 0.16070600f, 0.00114640f, 
    0.04161528f, -0.00919073f, 0.19727370f, -0.01049049f, 0.01667953f, 0.02472663f, 0.11372454f, 0.04164150f, 
    0.10471058f, 0.02466416f, -0.02460282f, 0.10363989f, 0.00133677f, 0.01646631f, -0.05121322f, -0.01978654f, 
    0.30801430f, -0.02918084f, 0.00595125f, 0.13391790f, 0.03473318f, 0.01938161f, -0.07048933f, -0.10254267f, 
    0.08656551f, 0.08496279f, 0.18593639f, 0.08724087f, -0.09587109f, 0.01724973f, 0.10094827f, 0.01386464f, 
    -0.16000892f, -0.17798725f, 0.05958901f, -0.15916240f, 0.06795231f, -0.22217034f, 0.11004701f, -0.06656665f, 
    -0.02277690f, 0.03919442f, -0.00323959f, 0.08555910f, 0.01477020f, -0.20821899f, 0.39888835f, -0.05118735f, 
    0.06730464f, 0.00555098f, 0.08579951f, 0.25455156f, 0.06226892f, 0.03962086f, -0.09303494f, 0.19770651f, 
    -0.22398891f, -0.07728006f, 0.45713103f, -0.13771892f, 0.04471442f, 0.15816964f, 0.14148127f, 0.04467137f, 
    -0.00174258f, 0.07035054f, 0.00564648f, 0.08683906f, 0.06309846f, 0.02219788f, -0.03759246f, -0.05797457f, 
    0.03705506f, -0.03818585f, 0.06242542f, -0.00751886f, 0.07912756f, -0.01711824f, 0.00563059f, -0.02971138f, 
    -0.14455520f, -0.00024831f, -0.11850660f, -0.03498165f, 0.09103175f, 0.09323162f, 0.20077902f, 0.01998316f, 
    -0.08380236f, 0.02568799f, 0.02752030f, -0.00885720f, -0.25173348f, 0.14544459f, 0.29527956f, -0.04605971f, 
    0.02807838f, 0.08718143f, 0.15826750f, 0.17955764f, 0.00084769f, 0.14684577f, 0.07236182f, 0.15516593f, 
    -0.02072848f, -0.00809038f, 0.11744356f, -0.18821378f, 0.03501898f, -0.01185807f, 0.02613233f, -0.05553965f, 
    0.03302217f, 0.03149648f, 0.04884997f, -0.06372014f, -0.21751522f, -0.18856288f, 0.05648183f, 0.03433263f, 
    -0.03156649f, -0.03288908f, -0.15605880f, -0.00655994f, 0.06178445f, 0.06371628f, 0.24454513f, 0.18131404f, 
    -0.09221762f, -0.08086789f, -0.10197170f, 0.02233868f, -0.00272456f, -0.12643093f, -0.06773786f, -0.00810542f, 
    0.11581670f, -0.04315111f, 0.01103900f, 0.02496180f, -0.55395377f, -0.18734352f, -0.01990117f, -0.12710337f, 
    -0.19765940f, 0.03585539f, 0.03327085f, 0.03782560f, 0.04367214f, 0.01419520f, 0.05705956f, -0.01064015f, 
    -0.34274283f, -0.29525927f, -0.31813988f, -0.18276130f, -0.11571990f, -0.07535035f, -0.16125576f, -0.00719574f, 
    -0.01266465f, -0.03508952f, -0.01293464f, -0.01006741f, 0.11142858f, -0.18501644f, -0.27419862f, -0.00903406f, 
    0.22334619f, 0.13233367f, 0.18362103f, 0.05941875f, 0.11260393f, 0.00705206f, 0.01093822f, 0.02757313f, 
    -0.24777563f, -0.25772408f, -0.19954552f, -0.35202441f, -0.00177268f, 0.07130245f, 0.01993454f, 0.05078613f, 
    0.00158223f, -0.00221983f, 0.08857463f, 0.13847256f, 0.12870829f, 0.00112322f, -0.08600867f, -0.06893692f, 
    0.03158522f, -0.01731392f, 0.02726647f, 0.05980786f, 0.00456207f, 0.06133287f, 0.03000163f, 0.00306811f, 
    0.07262375f, 0.01999762f, 0.02022539f, -0.05279080f, -0.01139752f, 0.03370905f, -0.04087276f, 0.00688392f, 
    -0.02354006f, -0.06657036f, 0.06799336f, -0.01061010f, -0.48685411f, -0.16426937f, -0.15265566f, -0.25747067f, 
    -0.14781898f, 0.04391778f, 0.09294976f, 0.22181191f, 0.05493477f, -0.00886019f, 0.04073084f, 0.06473721f, 
    -0.00045256f, 0.10124198f, 0.03477807f, 0.17885269f, 0.02038636f, -0.02113144f, 0.01254182f, -0.05412222f, 
    0.03309514f, 0.12868710f, 0.17692585f, 0.06192786f, 0.00434080f, -0.00616610f, 0.09160633f, -0.00669741f, 
    0.08760268f, 0.05198061f, 0.07433090f, 0.03179631f, -0.01932721f, 0.02596724f, 0.01118005f, 0.01364414f, 
    -0.08150816f, 0.01883418f, 0.09646312f, -0.07025642f, 0.00535716f, 0.01712082f, 0.07772020f, -0.05050317f, 
    0.04487563f, -0.05093205f, -0.02307560f, 0.05204540f, 0.03972787f, 0.08529356f, 0.06953725f, -0.07461013f, 
    0.00372410f, 0.07435184f, 0.02436466f, 0.03497478f, -0.01455221f, -0.02695272f, -0.00675068f, 0.00007051f, 
    0.18463151f, -0.22636710f, -0.10292049f, 0.09681101f, 0.16237020f, -0.02060902f, 0.09917209f, 0.02528561f, 
    0.05865647f, -0.01019417f, -0.03032550f, 0.05940107f, -0.03962061f, -0.20110136f, 0.47057244f, -0.03334721f, 
    0.02596897f, -0.04424698f, -0.06394321f, -0.11146616f, 0.05239037f, -0.05700169f, -0.07195386f, -0.08975971f, 
    0.01489990f, 0.01176375f, -0.02404382f, 0.02487948f, 0.00132765f, 0.01422303f, 0.02382136f, 0.00552914f, 
    0.03325684f, -0.00682774f, -0.02010766f, 0.01720771f, 0.01326301f, 0.01635655f, 0.00171289f, 0.01425612f, 
    0.01228309f, -0.01140919f, 0.00532389f, -0.00920651f, -0.02477836f, 0.00669955f, -0.00519223f, 0.00489182f, 
    0.02339569f, -0.02029885f, 0.01139137f, -0.03128352f, 0.03027223f, -0.00932812f, -0.01351846f, 0.02367859f, 
    -0.00280906f, 0.00119066f, -0.01145797f, -0.02658940f, 0.01605090f, -0.01909638f, 0.03120236f, -0.03001631f, 
    0.00977524f, 0.02685630f, 0.00815216f, -0.02005740f, 0.02120001f, -0.00150028f, 0.01605057f, 0.00414128f, 
    -0.03977846f, 0.01017295f, -0.01285876f, 0.00212374f, -0.01949379f, -0.01237800f, 0.00568229f, 0.00968908f, 
    -0.03567071f, -0.01068092f, -0.01837178f, -0.02878579f, -0.03997621f, -0.00900971f, 0.02531008f, 0.02726482f, 
    -0.00288135f, 0.03404500f, -0.02098167f, 0.01909441f, 0.02805422f, 0.02639857f, -0.02039101f, -0.02896306f, 
    0.00713017f, -0.02723860f, -0.01384684f, -0.00803306f, -0.02856089f, 0.03119475f, 0.02878994f, -0.02421300f, 
    0.00907673f, -0.00389517f, 0.01456604f, -0.02879936f, 0.01603672f, -0.02766667f, -0.02319453f, -0.01230052f, 
    0.01220440f, -0.00913153f, 0.02061478f, 0.01835233f, 0.02255250f, 0.02764182f, -0.02687633f, -0.01078426f, 
    -0.03261583f, 0.00464640f, -0.00070740f, 0.01685181f, -0.00399840f, 0.00774408f, -0.00948759f, 0.01226159f, 
    -0.02046940f, -0.00024905f, 0.00899972f, 0.00005436f, -0.02056720f, 0.01438485f, -0.00345738f, -0.03018408f, 
    0.00956563f, -0.03673937f, 0.02095832f, -0.02610630f, 0.01158031f, 0.01744211f, -0.00799609f, -0.03724355f, 
    0.03152819f, -0.03580914f, -0.00659759f, 0.00323575f, 0.02361634f, -0.02591528f, -0.01046156f, -0.03372202f, 
    -0.01594765f, -0.02119350f, -0.00214787f, 0.02289383f, 0.02634764f, 0.01504275f, -0.03869776f, -0.03187797f, 
    -0.03003681f, -0.03563678f, 0.01920826f, 0.01935757f, 0.02865817f, -0.03033915f, -0.00535248f, -0.03103621f, 
    0.03437157f, -0.02346005f, -0.02528564f, 0.02147172f, -0.01711132f, 0.00187122f, 0.00445736f, -0.02675377f, 
    0.03111968f, 0.00969625f, 0.00282961f, -0.00397994f, -0.01537862f, -0.00137225f, -0.03002106f, 0.02552444f, 
    0.02707170f, -0.03178554f, 0.02121379f, -0.02611004f, -0.00083030f, 0.01504789f, 0.02945009f, -0.02236885f, 
    -0.02887419f, -0.02132629f, 0.01041714f, -0.03813805f, -0.01759566f, 0.02557980f, 0.01260978f, 0.01069526f, 
    -0.03662906f, 0.01642140f, -0.03100984f, -0.03071830f, 0.02842827f, -0.00242632f, 0.02058144f, -0.02200801f, 
    -0.01970526f, -0.03907460f, -0.02077302f, 0.03362101f, -0.01699249f, 0.01432203f, -0.04095126f, 0.01479702f, 
    -0.03108719f, -0.03058279f, -0.00620591f, 0.02259293f, -0.01180740f, -0.00936681f, -0.00015710f, 0.00304838f, 
    -0.03639712f, 0.02752287f, -0.00972616f, 0.02308335f, -0.01313484f, -0.00283629f, -0.03952782f, 0.01685603f, 
    0.01120865f, 0.00967641f, -0.01443874f, -0.00372922f, 0.01897771f, -0.03971718f, 0.02238408f, -0.03235162f, 
    0.02123014f, 0.03262312f, 0.02403709f, -0.01928656f, -0.01612439f, -0.01308479f, 0.01894386f, -0.01243641f, 
    -0.02214353f, -0.00062066f, 0.03108177f, -0.01259796f, -0.04091196f, 0.00175112f, -0.03088267f, 0.02407959f, 
    -0.03340460f, -0.03240111f, -0.03196041f, 0.01268869f, 0.01436705f, -0.01098234f, -0.02971315f, 0.00706807f, 
    -0.03811630f, 0.02159556f, -0.02277935f, 0.01151227f, -0.01486360f, -0.02303559f, 0.01774370f, -0.02101179f, 
    0.01224140f, -0.03012786f, -0.03028400f, -0.01703422f, -0.00801982f, 0.01694025f, -0.01907994f, -0.00884663f, 
    -0.03468669f, 0.00986721f, -0.01485990f, -0.03532026f, 0.00781617f, 0.00553201f, -0.03659720f, -0.03731561f, 
    0.01461703f, -0.03479927f, 0.02479012f, -0.00893371f, 0.03449919f, 0.02033338f, -0.00648174f, -0.02106400f, 
    0.02866553f, 0.02577419f, -0.01425258f, -0.02370689f, 0.02337769f, -0.03177588f, -0.03823217f, 0.00454285f, 
    -0.00432025f, -0.04096099f, -0.02209431f, 0.00186526f, -0.02370709f, -0.02292790f, -0.03077189f, -0.01377380f, 
    0.01046794f, 0.01598161f, -0.00056922f, -0.02553697f, -0.00987432f, -0.03448159f, -0.03551316f, 0.00123960f, 
    -0.03776404f, 0.00851920f, -0.00557501f, 0.01643640f, -0.02230741f, -0.02169257f, -0.01580462f, 0.02512305f, 
    -0.00154206f, -0.01432754f, 0.00040413f, -0.02451144f, 0.01909859f, 0.02934196f, -0.02117299f, -0.03601281f, 
    -0.00896815f, 0.00194370f, -0.03675317f, -0.02828687f, -0.02077172f, -0.03206800f, 0.00861917f, -0.02578159f, 
    -0.03411946f, 0.00954281f, 0.01753907f, 0.00808122f, -0.02936316f, -0.00181667f, -0.02379272f, -0.00213931f, 
    -0.02395539f, -0.01401920f, -0.02879151f, 0.01547433f, -0.00510904f, 0.01680014f, 0.01675217f, 0.02348591f, 
    -0.01822977f, 0.02208132f, -0.03193751f, 0.00158818f, 0.03087250f, 0.03574449f, 0.00530056f, 0.01424398f, 
    -0.00757426f, 0.02392413f, -0.00996361f, -0.03370050f, -0.00444704f, 0.01685552f, -0.03447748f, -0.00123804f, 
    -0.03700343f, -0.01039737f, 0.02468807f, 0.00798599f, -0.02274435f, 0.02967663f, -0.02291350f, -0.01408224f, 
    0.02724664f, 0.00020432f, -0.00674101f, -0.01479410f, -0.00431341f, 0.03421310f, -0.01691272f, -0.02650127f, 
    -0.03874908f, -0.01217735f, 0.01948111f, 0.00136325f, 0.02133643f, -0.03173961f, 0.00327417f, 0.00134551f, 
    0.03010620f, -0.01561106f, -0.01648183f, 0.01928119f, 0.00668107f, -0.02954814f, 0.00095703f, -0.01127693f, 
    0.01917442f, 0.03208038f, -0.00271116f, -0.01334986f, -0.00706379f, -0.00713083f, 0.00980385f, 0.01410544f, 
    -0.00456547f, 0.00861131f, 0.00474327f, -0.03359525f, 0.00320197f, 0.03557869f, 0.00208579f, 0.00867715f, 
    0.02363575f, -0.00653314f, 0.02238581f, 0.00801375f, 0.00235973f, 0.01792284f, -0.03627116f, -0.03837046f, 
    0.03607722f, -0.00353206f, -0.01759882f, 0.02289902f, -0.00077104f, 0.00747703f, -0.02959862f, -0.03875577f, 
    -0.04285671f, 0.01053263f, 0.01687176f, 0.01566236f, 0.00033608f, -0.03698245f, 0.01556358f, 0.00360121f, 
    0.01839181f, 0.02336762f, -0.00168440f, -0.00141307f, 0.02349047f, 0.00991186f, -0.00476496f, 0.00738348f, 
    0.02082678f, 0.03071197f, 0.01062647f, -0.00641384f, -0.02962076f, -0.02926011f, 0.01271817f, 0.03132690f, 
    -0.00782923f, 0.00342621f, -0.02751873f, -0.03788563f, -0.02117715f, -0.01746081f, -0.03916729f, 0.00202456f, 
    0.00927355f, 0.02764384f, 0.01266307f, 0.00691757f, 0.02126541f, -0.02242222f, 0.02023545f, 0.01382916f, 
    -0.02513627f, 0.01345052f, 0.00332777f, -0.02764677f, -0.01150035f, 0.01848510f, 0.01911783f, -0.00053806f, 
    -0.01546664f, -0.00805960f, 0.03199871f, -0.02168307f, 0.00660549f, 0.01756576f, 0.01718611f, 0.00431405f, 
    -0.02250930f, -0.00022274f, -0.00611469f, -0.01223173f, 0.03086727f, -0.00192486f, 0.02897985f, -0.03167471f, 
    -0.03175282f, 0.01974550f, -0.02227811f, 0.02957019f, -0.00032299f, 0.02580085f, -0.01842552f, -0.00813940f, 
    0.00887773f, 0.03001108f, -0.00881446f, 0.01750997f, -0.01852524f, 0.01436092f, -0.03169890f, 0.01971382f, 
    0.03152424f, -0.03094380f, 0.01280771f, 0.00904245f, 0.00450270f, 0.03275235f, 0.02681699f, -0.01588517f, 
    -0.03729596f, -0.00687551f, -0.02920882f, 0.02292123f, -0.02394460f, -0.01495711f, -0.02288899f, -0.03458316f, 
    -0.02486901f, -0.00457812f, -0.01903703f, 0.00812680f, 0.03232156f, -0.02075206f, 0.02323640f, -0.02591558f, 
    -0.00444949f, -0.01619231f, -0.00363308f, -0.01909917f, -0.02399419f, 0.03397775f, 0.00704699f, 0.00951561f, 
    0.00969439f, -0.02565626f, 0.02027684f, 0.00439044f, -0.01871454f, 0.02866161f, 0.02984249f, -0.03743061f, 
    -0.01752811f, 0.02153230f, -0.02841369f, -0.02591848f, -0.00487791f, 0.00943307f, -0.02610594f, -0.03780681f, 
    -0.00949154f, 0.01320901f, 0.02806342f, -0.00661415f, 0.01606901f, -0.01429499f, -0.00916378f, 0.02980195f, 
    -0.02179696f, 0.01546798f, -0.01050351f, -0.00790825f, 0.01681536f, -0.02673982f, 0.01532922f, 0.01641596f, 
    -0.01180965f, -0.03116051f, -0.01804017f, 0.03562002f, 0.00208835f, -0.02502071f, -0.01480998f, -0.01519618f, 
    0.01326565f, 0.01458751f, -0.02965382f, 0.01625977f, 0.00548590f, -0.00369278f, -0.00295883f, 0.03124016f, 
    -0.02772267f, 0.01261221f, -0.01379963f, -0.03592218f, 0.00604050f, 0.01094124f, -0.01174457f, -0.00978378f, 
    -0.01108737f, -0.02535242f, -0.03266378f, -0.01599809f, 0.00565182f, 0.02836908f, -0.01222909f, 0.02795213f, 
    0.01435171f, 0.00149507f, 0.00636123f, 0.01815013f, 0.00829331f, -0.00079827f, -0.02756985f, 0.01420970f, 
    -0.03772197f, -0.00218239f, -0.01318693f, -0.01084464f, -0.01102361f, -0.00856569f, -0.00110275f, 0.01654044f, 
    -0.00228959f, -0.01442946f, -0.00791780f, 0.01660397f, -0.03687141f, -0.03575635f, 0.02352985f, -0.01906500f, 
    -0.00529354f, 0.00543213f, 0.00398393f, -0.00596362f, 0.00090854f, -0.02207859f, -0.01911380f, -0.00818360f, 
    0.01563966f, -0.00295116f, -0.01522550f, 0.01387555f, 0.00504965f, -0.00417145f, 0.02223972f, -0.00274448f, 
    -0.03271586f, 0.03319226f, 0.00501921f, 0.02782071f, 0.00179529f, -0.01816750f, 0.00168380f, 0.01215637f, 
    0.00805763f, -0.01442784f, -0.03041658f, -0.01895194f, 0.01962692f, 0.03325167f, 0.02499530f, -0.01914524f, 
    -0.02317230f, -0.02126527f, -0.01578889f, 0.01207733f, 0.01624598f, -0.01095262f, -0.00687082f, -0.00546516f, 
    -0.01053148f, -0.00479709f, 0.01805889f, 0.01857256f, 0.00996819f, -0.03147871f, 0.02992883f, -0.03679949f, 
    -0.02699278f, -0.00816135f, -0.00097818f, 0.02122910f, -0.01329802f, 0.02020305f, 0.01179994f, -0.03564844f, 
    -0.03889728f, 0.00410361f, -0.02379818f, 0.01423179f, 0.01384871f, -0.03205667f, -0.00674137f, -0.01764451f, 
    -0.01321227f, -0.03686687f, 0.02544182f, -0.00838891f, -0.01754859f, 0.02161711f, -0.03203784f, 0.01047883f, 
    -0.00988839f, -0.01144754f, -0.03794472f, 0.01289071f, 0.03141040f, -0.02330089f, 0.03149113f, 0.01623790f, 
    0.03192629f, 0.01970380f, 0.02550590f, -0.02147821f, 0.00692342f, -0.01458179f, 0.02847253f, 0.02739576f, 
    0.00925292f, 0.01984113f, 0.00589190f, -0.01577078f, -0.02306383f, -0.02631812f, -0.01387729f, 0.02759821f, 
    -0.02792986f, 0.00045766f, -0.00606883f, -0.01744302f, -0.02402133f, -0.00622983f, 0.00071080f, 0.01975668f, 
    -0.03685595f, 0.02100694f, 0.01477527f, 0.01292482f, -0.02673938f, 0.00860284f, -0.03027913f, -0.03220096f, 
    -0.03360211f, 0.00501273f, -0.02177164f, -0.00568083f, 0.03472232f, 0.02848644f, -0.03688730f, -0.03708855f, 
    -0.02880209f, 0.01264877f, 0.00340680f, 0.02404897f, 0.01755866f, -0.00231525f, 0.00117660f, 0.00226322f, 
    0.00193777f, -0.01321232f, -0.03792175f, -0.03030593f, 0.00616691f, -0.01653430f, -0.03726698f, -0.02090180f, 
    -0.03912732f, -0.00528399f, -0.01697273f, -0.00498161f, -0.00753874f, 0.01739782f, -0.01443936f, 0.01569584f, 
    0.00000501f, -0.03140927f, -0.04194593f, 0.01809509f, -0.00370140f, -0.01486291f, 0.01948137f, -0.00399369f, 
    0.01733935f, 0.00838630f, -0.01912423f, -0.02210161f, -0.01534156f, -0.02862117f, 0.02127878f, -0.03275206f, 
    0.01125536f, -0.01073838f, 0.02762278f, 0.00479484f, -0.02964664f, -0.00603251f, -0.00743137f, -0.03312083f, 
    -0.00082910f, -0.03749913f, 0.02745769f, -0.02749846f, 0.01404188f, 0.01407865f, 0.02354851f, -0.02349997f, 
    0.01205353f, 0.02557915f, 0.00358193f, -0.02075266f, -0.00452876f, -0.03929911f, 0.02468851f, -0.00570072f, 
    -0.01510809f, 0.01011708f, 0.00022728f, 0.02729130f, -0.03055459f, -0.02452715f, -0.03052066f, -0.01594157f, 
    0.00190269f, -0.00748949f, 0.02337679f, -0.04186249f, -0.00849475f, -0.01058030f, 0.02232838f, 0.00779955f, 
    0.02592293f, 0.02900497f, 0.01306563f, 0.01777588f, -0.04191905f, -0.00582164f, 0.02684360f, 0.02296306f, 
    0.00434373f, -0.03453141f, -0.00620338f, -0.03780651f, -0.03247306f, 0.00629680f, -0.00474598f, -0.02391002f, 
    -0.01946500f, 0.00389748f, -0.03452739f, 0.02277196f, -0.00991884f, 0.02045053f, -0.04101016f, -0.01632417f, 
    -0.04159683f, -0.01957778f, 0.02160496f, -0.01557860f, 0.00207206f, 0.01870709f, -0.03325501f, 0.01196866f, 
    0.02977116f, -0.01628990f, 0.00131068f, -0.04171941f, -0.01689200f, 0.00118612f, 0.00995531f, -0.01956096f, 
    -0.02535803f, -0.01766078f, -0.01292563f, 0.01960045f, -0.02041830f, 0.01232431f, -0.03351203f, -0.02897489f, 
    0.00191071f, -0.00215297f, 0.00099702f, -0.00243053f, -0.02798104f, 0.01935724f, -0.02939286f, 0.00565581f, 
    -0.03069518f, 0.00270300f, 0.02782053f, 0.01642688f, 0.01109315f, -0.03376225f, -0.00687531f, -0.03396996f, 
    0.01048835f, -0.02188155f, 0.01610882f, -0.01592991f, 0.00081688f, -0.03997281f, -0.03929196f, -0.03363900f, 
    0.00246036f, -0.00193433f, 0.01134491f, 0.00718279f, -0.03291731f, 0.02486758f, -0.01082622f, -0.03780542f, 
    -0.02639362f, -0.02502176f, 0.01600338f, -0.03060510f, -0.02783207f, 0.02703010f, -0.02827704f, -0.02287504f, 
    -0.03312305f, 0.01546929f, -0.02652212f, 0.01495817f, -0.02579217f, -0.00831879f, -0.02892100f, -0.03729273f, 
    -0.02452236f, 0.01715640f, -0.01103466f, -0.01201857f, -0.00618976f, 0.00436849f, -0.02761646f, -0.03879154f, 
    -0.02236139f, 0.02695709f, 0.01885188f, -0.01639804f, 0.02295929f, 0.01485931f, -0.02841818f, -0.00307403f, 
    0.00567724f, -0.02436619f, -0.01383543f, -0.03969919f, 0.01925149f, -0.00185509f, -0.01920562f, -0.02345932f, 
    0.00908424f, 0.01125341f, 0.00795142f, -0.00738527f, -0.00136873f, -0.02125937f, -0.01074553f, -0.02211458f, 
    0.00795722f, -0.00407435f, -0.03918578f, 0.01387032f, -0.03090702f, -0.02393964f, 0.02030520f, 0.00421288f, 
    0.02368570f, -0.02815101f, -0.02827535f, 0.02837521f, 0.00655423f, -0.01367885f, 0.01874459f, 0.00079267f, 
    -0.00948377f, -0.00778052f, -0.04033305f, -0.01271670f, -0.00793745f, 0.02493547f, 0.00608556f, -0.03506949f, 
    0.00876344f, -0.03980753f, -0.03502610f, -0.00101655f, -0.03285028f, 0.01982186f, 0.01233462f, 0.00370022f, 
    -0.02823292f, 0.01623294f, -0.00319057f, -0.03440224f, 0.00512581f, 0.00748574f, -0.02029313f, 0.00734868f, 
    0.02407137f, -0.01902566f, 0.00006100f, -0.03629718f, -0.03789396f, 0.02054469f, -0.01316429f, 0.01719417f, 
    -0.03464833f, -0.01538972f, -0.01488515f, -0.02690610f, 0.00265386f, 0.01405968f, -0.04048786f, 0.01144844f, 
    0.01456057f, -0.03107773f, -0.03312903f, 0.02149066f, 0.00547917f, 0.02183258f, 0.01622425f, -0.03972695f, 
    0.02892829f, 0.01518562f, -0.02630753f, 0.01801355f, 0.02553785f, 0.02136699f, 0.01086037f, -0.02889457f, 
    0.01882460f, 0.00620518f, 0.00903206f, 0.00174906f, -0.03184294f, -0.04123456f, 0.01988981f, -0.01262019f, 
    0.02414658f, -0.01475385f, 0.00718047f, -0.04071184f, -0.00452343f, 0.00482592f, -0.00452907f, -0.02121935f, 
    -0.02414383f, 0.02051632f, 0.01851147f, 0.00530496f, -0.00122446f, 0.01206895f, -0.02376426f, -0.00072971f, 
    -0.00698614f, -0.03391980f, -0.03870584f, -0.00134701f, 0.02674971f, 0.00414033f, 0.01454761f, 0.00993006f, 
    0.02271920f, -0.00640074f, 0.00268961f, 0.02095385f, -0.03431559f, -0.03219812f, -0.04058514f, 0.02148084f, 
    0.01113323f, -0.00075563f, -0.01315292f, 0.01483354f, -0.03593901f, -0.02132155f, -0.03236853f, -0.03956479f, 
    -0.01023235f, -0.03373143f, -0.00721822f, -0.03123908f, -0.02186095f, -0.03233156f, -0.02554525f, 0.02058870f, 
    -0.02276984f, -0.02699705f, 0.00074445f, 0.02108571f, 0.02166018f, -0.02119570f, 0.01264306f, -0.00927062f, 
    0.01527483f, 0.02966023f, -0.01220615f, -0.01101348f, -0.01136669f, -0.02697774f, -0.00688574f, -0.01459012f, 
    0.02081979f, -0.01353769f, -0.00848931f, 0.01912040f, 0.01771197f, -0.01623555f, -0.00087683f, -0.03180942f, 
    0.00519755f, -0.04091826f, -0.02352483f, -0.01818465f, 0.00812626f, -0.03736909f, -0.02627143f, -0.02255989f, 
    0.01851579f, -0.04052784f, 0.01315051f, -0.02342826f, 0.01464779f, -0.03386914f, -0.01075602f, 0.01788217f, 
    -0.01266667f, -0.02364652f, 0.00098986f, 0.00938796f, -0.03610559f, -0.03476802f, -0.03918024f, -0.01981600f, 
    0.01161960f, -0.03422669f, -0.01516574f, 0.00823838f, 0.00594590f, -0.01523119f, -0.01765913f, -0.01819519f, 
    -0.02084454f, 0.00154476f, -0.01180239f, -0.00286998f, 0.00444867f, 0.02978343f, -0.01401564f, -0.03999325f, 
    -0.00821659f, -0.02024940f, 0.00010362f, 0.01856612f, -0.03783327f, -0.00514305f, -0.03612218f, 0.02302596f, 
    -0.01101836f, -0.01027424f, -0.00906499f, 0.00970386f, 0.01298075f, 0.00443006f, -0.02418379f, 0.01180149f, 
    -0.03924873f, -0.02570731f, 0.01201054f, -0.00077149f, -0.00459076f, -0.04044611f, -0.02701268f, 0.01313470f, 
    0.01592153f, -0.02555461f, -0.02274235f, -0.03872334f, 0.01180656f, 0.01721101f, -0.02339336f, -0.02411283f, 
    -0.02588869f, 0.01825833f, -0.01612940f, -0.02532458f, -0.01575108f, -0.03157791f, -0.03488711f, -0.02922826f, 
    -0.00556517f, -0.02425789f, -0.00696987f, -0.01485754f, 0.02746336f, 0.00733560f, 0.01200928f, 0.01046800f, 
    -0.01197174f, -0.01458226f, 0.01921842f, -0.03523945f, -0.00553611f, 0.01622349f, 0.01086092f, -0.02952864f, 
    -0.03900378f, -0.02316815f, -0.01073208f, 0.00798796f, 0.00023803f, -0.00064039f, 0.01357369f, -0.04157063f, 
    -0.00075479f, -0.02374655f, 0.02268517f, -0.04002408f, 0.01775526f, -0.03235526f, 0.02541820f, 0.01933132f, 
    0.01812606f, -0.02855456f, -0.02517931f, 0.01746278f, 0.01275764f, 0.02469903f, -0.03697219f, -0.01332572f, 
    -0.01162743f, -0.01891373f, -0.00101886f, -0.02815385f, 0.00057697f, -0.02781078f, -0.00620786f, -0.00092945f, 
    0.00715078f, -0.02182327f, 0.01651188f, -0.01440567f, -0.00344076f, -0.03544081f, 0.00963606f, -0.02662684f, 
    -0.02354371f, 0.01318868f, -0.02902542f, 0.01694826f, -0.00867521f, -0.01098003f, -0.01869217f, -0.00393477f, 
    0.02955589f, -0.03164624f, 0.00857902f, 0.02104254f, -0.04198428f, 0.02494477f, 0.01102120f, -0.00003296f, 
    0.02941138f, -0.01247154f, 0.01243269f, 0.02405018f, -0.03173381f, -0.01410463f, 0.02495893f, 0.00837032f, 
    0.02812583f, -0.03407437f, 0.00044312f, -0.03417227f, -0.00782184f, 0.02657911f, -0.02918630f, -0.01886788f, 
    0.00743718f, -0.03407437f, 0.00416684f, -0.03555948f, -0.03178807f, -0.01511453f, 0.01978945f, -0.02178018f, 
    0.01041381f, 0.01755387f, -0.03813595f, 0.02320037f, -0.02425296f, -0.03807150f, 0.00615290f, -0.03219616f, 
    0.02970843f, -0.00077962f, 0.01431341f, 0.02464255f, -0.02037604f, -0.01590667f, 0.02845217f, 0.01092174f, 
    -0.01250464f, -0.00881165f, -0.02956770f, 0.02982494f, 0.02765157f, -0.03296204f, 0.02735784f, 0.02264026f, 
    -0.02501625f, -0.01431826f, 0.02934442f, -0.01544464f, -0.03641471f, 0.01091046f, 0.00949215f, -0.03804343f, 
    -0.01875369f, 0.00968702f, -0.01946122f, -0.01955700f, -0.03080169f, 0.00434781f, -0.01922268f, -0.03234289f, 
    0.00409587f, 0.00607914f, -0.02668163f, -0.00769270f, -0.03426420f, -0.01393909f, -0.02125931f, 0.00255524f, 
    -0.03592705f, -0.01999623f, 0.02790579f, -0.02039264f, -0.01911567f, 0.01013022f, 0.02065311f, 0.02587092f, 
    -0.02126297f, -0.00326508f, -0.03545326f, -0.01342588f, -0.03992448f, 0.02289217f, 0.00814425f, 0.00498466f, 
    -0.00648759f, 0.01850660f, 0.00750642f, -0.01623177f, 0.01436322f, -0.02185957f, -0.01686475f, 0.00227020f, 
    -0.01852523f, 0.02190597f, 0.00300033f, -0.00597928f, -0.03211381f, -0.03060075f, 0.00250946f, 0.01623968f, 
    -0.03339522f, -0.02942784f, -0.03014920f, -0.02755275f, -0.03604553f, -0.02770301f, 0.00954016f, -0.04099114f, 
    0.00696744f, 0.00950878f, 0.00927101f, -0.01095678f, 0.02302291f, 0.01785313f, 0.02810732f, -0.03233328f, 
    -0.00447931f, -0.00103928f, 0.01064389f, -0.02297650f, -0.02208459f, -0.02952415f, -0.03204979f, 0.00158819f, 
    -0.03281421f, 0.00588430f, -0.00758475f, 0.01706582f, 0.02451238f, -0.01873102f, 0.02111678f, -0.03328103f, 
    -0.03043094f, 0.02569340f, -0.00604365f, -0.00994078f, -0.03773438f, -0.03225017f, 0.01279940f, 0.02638490f, 
    -0.00274634f, 0.01075892f, -0.03440780f, -0.03875192f, 0.02245425f, -0.00664728f, 0.02299751f, -0.00661821f, 
    -0.04206064f, -0.03149693f, -0.00655904f, -0.01487129f, -0.01120364f, -0.00900082f, 0.01046580f, -0.02323619f, 
    0.02479480f, 0.01045369f, -0.01115641f, -0.03065025f, -0.02028705f, 0.00670684f, 0.02076363f, -0.01081949f, 
    -0.01155066f, 0.02214638f, -0.01457857f, -0.02868842f, -0.03125070f, -0.03675043f, 0.01944992f, 0.00480042f, 
    -0.02789844f, -0.01914043f, 0.02478929f, -0.01100420f, 0.00975656f, 0.02997576f, -0.03196518f, -0.03184657f, 
    0.02879113f, -0.03891377f, 0.02030704f, -0.00019721f, 0.00890399f, 0.02626939f, -0.01355113f, -0.00017814f, 
    0.00145851f, -0.02969017f, -0.03841605f, -0.01597372f, -0.03230027f, 0.02748613f, 0.01093644f, 0.02816089f, 
    0.01436779f, 0.01335798f, -0.02537305f, -0.01332604f, -0.01962857f, -0.03552972f, 0.01920694f, -0.01525495f, 
    0.00178150f, 0.02032935f, -0.03081170f, -0.02441964f, -0.00199303f, 0.02774394f, 0.02178996f, 0.00279612f, 
    0.02901251f, 0.02164885f, -0.01346497f, 0.01893442f, -0.00035487f, 0.01944961f, -0.03389205f, -0.03441722f, 
    -0.03530601f, -0.01340543f, -0.00115025f, 0.01119350f, -0.02631327f, 0.01606158f, -0.02300127f, 0.02959524f, 
    -0.00038094f, -0.01350025f, 0.02596107f, 0.02546421f, 0.00701973f, -0.01182968f, -0.00793900f, -0.02920341f, 
    -0.01335067f, 0.02600713f, 0.00830354f, 0.00980063f, -0.00096901f, 0.01871635f, -0.03380617f, -0.02316233f, 
    0.02888663f, -0.02892643f, 0.01808191f, -0.02534966f, -0.01344773f, 0.00435455f, -0.00370992f, -0.01189581f, 
    0.01459312f, 0.02328966f, -0.02535093f, 0.01957799f, -0.02111481f, 0.02119355f, -0.01247942f, 0.01694035f, 
    -0.02145451f, -0.01737045f, -0.01821276f, 0.01314589f, -0.02975969f, 0.02038768f, -0.03707884f, -0.03851664f, 
    -0.00482652f, 0.01626138f, -0.02150491f, -0.02993355f, -0.03478004f, 0.00110719f, 0.02266664f, -0.01492457f, 
    0.00973353f, -0.03971233f, -0.00144946f, 0.01145081f, -0.00759687f, -0.01363281f, -0.02478357f, -0.03289363f, 
    -0.31385583f, -0.23840615f, 0.17096750f, -0.03378741f, -0.07779366f, 0.01696380f, 0.02441463f, 0.04352500f, 
    -0.10213278f, 0.01940107f, -0.01377961f, 0.03637593f, 0.51040894f, -0.06964637f, -0.12104319f, -0.09794395f, 
    0.12482076f, -0.08559374f, -0.06711355f, -0.16667911f, -0.02284704f, 0.01749404f, 0.06146895f, -0.06159030f, 
    0.11649695f, 0.05791408f, 0.00955939f, 0.05597383f, 0.02000656f, 0.01507020f, -0.09635095f, -0.09948567f, 
    0.10180244f, -0.02967829f, -0.03812724f, -0.07607094f, 0.17146666f, -0.07725690f, -0.23648909f, -0.01317135f, 
    0.06726475f, 0.01884088f, -0.08968176f, -0.14830916f, 0.11098634f, 0.02925624f, 0.01342712f, -0.03830878f, 
    0.16022874f, 0.06230313f, 0.03660966f, 0.14048223f, -0.15621442f, -0.01513056f, 0.02252235f, -0.06192195f, 
    -0.02955224f, -0.01920049f, -0.05559248f, 0.05915122f, 0.45803457f, 0.15678573f, -0.21482506f, -0.27149168f, 
    0.11966893f, 0.06119863f, -0.11000618f, -0.25713736f, -0.16153334f, -0.02564053f, 0.09491392f, 0.11260305f, 
    0.28559431f, 0.25240779f, 0.24221970f, -0.07015509f, 0.01526911f, -0.01539978f, -0.06117882f, -0.05335868f, 
    -0.07571957f, -0.00453648f, -0.01332396f, -0.10546843f, 0.04524280f, -0.23735975f, -0.16888510f, -0.03989580f, 
    0.00956817f, -0.02153569f, 0.05295191f, 0.08433982f, 0.09384962f, 0.08290287f, 0.03981393f, -0.03169918f, 
    0.00416655f, 0.23340444f, 0.01823756f, 0.02114504f, -0.05182024f, 0.07047098f, -0.04372501f, 0.00690331f, 
    -0.04707450f, 0.04575966f, 0.01306174f, 0.08916300f, -0.21856630f, 0.00007882f, -0.00203566f, -0.01585979f, 
    -0.09373141f, 0.02281757f, 0.06553295f, 0.18874425f, 0.10875743f, 0.09444854f, 0.07457828f, 0.02975349f, 
    -0.21593909f, -0.37827700f, -0.18682079f, -0.33698028f, 0.06554601f, -0.03926598f, 0.07142905f, -0.06726749f, 
    0.12739876f, 0.11062516f, 0.07464630f, -0.03728503f, 0.06463560f, 0.05788259f, 0.06688315f, -0.05476066f, 
    0.12447236f, 0.02860510f, -0.11926811f, -0.03722231f, -0.13539605f, 0.00182016f, -0.10855750f, -0.09343471f, 
    0.27393347f, 0.01536145f, -0.04986581f, 0.14888571f, 0.00552425f, 0.10051263f, -0.02776192f, -0.00327691f, 
    -0.12336186f, -0.06849004f, 0.05523362f, 0.09915902f, -0.03826496f, -0.07490954f, 0.09178667f, 0.00912782f, 
    -0.01195141f, 0.00396089f, 0.10121381f, -0.08363756f, -0.08695397f, -0.02872980f, -0.07097436f, 0.16223887f, 
    0.24932006f, 0.25474113f, 0.11853213f, 0.21911547f, -0.25365132f, 0.00332265f, 0.09056236f, 0.08213166f, 
    0.05995869f, -0.05190412f, 0.04057904f, 0.06920551f, -0.01702045f, 0.07560553f, 0.01754301f, -0.17201148f, 
    0.03110404f, 0.12935129f, -0.08441612f, -0.00126508f, -0.12529513f, 0.03996132f, -0.11878288f, -0.13237488f, 
    0.08031046f, 0.12439300f, 0.21738027f, 0.31713843f, -0.08197694f, 0.15270258f, -0.01269077f, -0.03786758f, 
    0.05368090f, -0.06545884f, 0.05007439f, -0.08221170f, -0.11635913f, 0.15794058f, -0.04887756f, -0.42751798f, 
    -0.02795282f, 0.04560310f, -0.05676023f, 0.16296653f, -0.14105003f, -0.01043070f, 0.04664869f, 0.11450549f, 
    -0.28449529f, 0.14964226f, -0.20235041f, -0.10808996f, 0.16811650f, 0.11754259f, -0.00249841f, -0.10013422f, 
    -0.01201874f, 0.09064253f, 0.01541018f, 0.13426657f, 0.26272047f, -0.28519469f, -0.11378575f, -0.06925009f, 
    0.11544549f, 0.00935990f, 0.15984972f, -0.02190070f, -0.08594595f, -0.11883855f, -0.01211774f, 0.09725508f, 
    0.10019669f, 0.36636901f, 0.19973268f, 0.11831362f, 0.04788138f, 0.03885744f, -0.04763714f, -0.03969726f, 
    0.00240478f, -0.06645245f, -0.10315865f, 0.05230364f, 0.17479409f, -0.23444641f, -0.09333365f, -0.04987765f, 
    0.08585636f, 0.06181106f, 0.03889222f, -0.05722944f, 0.06887864f, -0.01412393f, 0.04496822f, -0.05228819f, 
    0.32384413f, 0.07647008f, 0.18486114f, -0.24323928f, -0.08165172f, 0.09603477f, -0.05120012f, -0.02721456f, 
    -0.07567351f, 0.09197264f, -0.12864190f, -0.11805708f, -0.01787464f, 0.05505690f, -0.01790541f, -0.06901024f, 
    -0.08240294f, -0.01427696f, 0.01768656f, -0.12541999f, 0.02722539f, 0.00380580f, -0.05597921f, -0.04109478f, 
    0.09849893f, 0.07935497f, 0.26042780f, -0.01344746f, 0.08703098f, 0.04423559f, -0.07017683f, -0.03746016f, 
    -0.04049820f, 0.01289018f, -0.01562935f, 0.00018085f, -0.12278577f, 0.07169263f, 0.12501398f, 0.13750671f, 
    -0.02209212f, 0.09370144f, 0.01771939f, 0.11424038f, -0.05276481f, -0.03413529f, 0.10369963f, 0.18927239f, 
    -0.06042330f, 0.01719197f, 0.09485931f, 0.04838113f, 0.05043873f, -0.03576238f, 0.10315055f, 0.12627332f, 
    -0.02856183f, 0.01805857f, -0.05739558f, -0.00021857f, 0.06819080f, 0.03043341f, 0.10721580f, 0.18353227f, 
    -0.20706223f, -0.02425054f, 0.05116451f, 0.09797905f, -0.03838680f, -0.00634495f, 0.03818591f, 0.06276201f, 
    0.08640459f, -0.09525766f, -0.07814745f, 0.01004145f, 0.01290793f, 0.02077953f, 0.08879849f, 0.07517970f, 
    -0.02810431f, 0.08604447f, -0.01471373f, -0.00699320f, 0.02501152f, 0.04114299f, 0.19171634f, -0.02202738f, 
    -0.13274677f, 0.04391338f, 0.00345661f, -0.02072472f, 0.05224472f, 0.07126620f, -0.05331026f, -0.00214438f, 
    0.03398935f, 0.02427075f, -0.03572899f, 0.14464718f, -0.01662419f, 0.07762533f, 0.02658673f, -0.02604383f, 
    0.02504631f, 0.07795725f, -0.03325388f, -0.06822138f, 0.04252717f, 0.08342063f, -0.08660023f, 0.01315766f, 
    -0.00709967f, -0.11818668f, 0.07863791f, 0.04366826f, -0.07621059f, 0.02361608f, -0.10500211f, 0.00856702f, 
    -0.01315476f, 0.13425304f, 0.06627510f, 0.13211973f, -0.00175490f, 0.08880897f, 0.03320009f, -0.03215696f, 
    0.10819198f, 0.06218891f, 0.17271310f, 0.20706178f, 0.06942719f, 0.11932374f, -0.00987792f, 0.14342619f, 
    -0.08064321f, 0.01423688f, -0.02628973f, -0.05878782f, -0.04117862f, 0.00006303f, -0.02060105f, -0.13093711f, 
    0.05125659f, 0.27055672f, -0.02218125f, -0.01743883f, 0.07043328f, -0.05395732f, 0.11230159f, 0.06763463f, 
    -0.08633517f, -0.02834036f, -0.08782886f, 0.07675998f, 0.02435903f, -0.24778138f, -0.05696094f, -0.14870517f, 
    -0.10025435f, 0.02603999f, -0.02541219f, -0.10713138f, 0.00141574f, -0.09359696f, 0.00822363f, -0.05152837f, 
    0.13209325f, 0.11521405f, -0.01654582f, -0.13639662f, -0.15801799f, 0.08162474f, -0.05430201f, 0.19854979f, 
    0.01080556f, 0.03448958f, -0.04149295f, 0.03703260f, -0.15375444f, -0.08795878f, -0.03340013f, 0.06941763f, 
    -0.01409325f, 0.03074004f, 0.06117987f, 0.01893932f, -0.00601980f, -0.03526769f, 0.02858624f, 0.01862163f, 
    -0.04219836f, -0.14081660f, -0.05302150f, -0.05887701f, 0.07527027f, -0.11566100f, -0.06444504f, 0.10685614f, 
    -0.03320998f, 0.02904807f, -0.02827170f, -0.03568467f, -0.42934060f, -0.13320790f, 0.11130771f, -0.17047131f, 
    0.06391897f, -0.18414705f, -0.02531385f, -0.02650733f, 0.07042896f, 0.29557702f, 0.05925711f, 0.03440556f, 
    0.27467468f, -0.00026125f, -0.36374635f, 0.01598698f, 0.04609583f, -0.02877910f, -0.04872606f, -0.06569673f, 
    -0.00665762f, -0.05061690f, 0.00752923f, -0.01924994f, 0.12955154f, 0.05294924f, 0.01268450f, -0.20558275f, 
    -0.14769356f, 0.17523880f, 0.09958984f, -0.06270736f, 0.02928018f, 0.01422602f, -0.00162686f, 0.06024063f, 
    -0.05582067f, -0.14615278f, -0.07585547f, -0.21477853f, -0.01192788f, 0.04675307f, 0.02660214f, 0.12874022f, 
    0.07090450f, 0.10151326f, -0.07696575f, -0.14808103f, 0.03274132f, 0.11454832f, -0.07335227f, -0.28598401f, 
    -0.25133663f, 0.17416514f, 0.03946979f, -0.20048350f, 0.04756323f, -0.03277392f, 0.21308066f, 0.01857647f, 
    0.03369552f, -0.27348328f, 0.12370632f, -0.22264315f, 0.02411582f, -0.06347673f, 0.16627836f, 0.02155458f, 
    -0.10283772f, 0.00714693f, -0.01314196f, 0.01588318f, 0.06345866f, 0.12387519f, 0.03636488f, -0.04584727f, 
    -0.05546854f, 0.03125302f, 0.08544758f, 0.10409693f, 0.05136800f, -0.08392243f, -0.08166488f, -0.12756230f, 
    0.17942430f, 0.28744873f, 0.06421581f, -0.00846037f, 0.02431561f, -0.01759078f, 0.03805012f, 0.15444446f, 
    -0.10887702f, -0.01939077f, 0.04601089f, 0.12469695f, 0.02222373f, -0.45855561f, 0.03698282f, -0.33501530f, 
    -0.10970425f, -0.03739078f, 0.00759597f, -0.10499284f, -0.07388488f, 0.02384259f, -0.00636767f, -0.04116963f, 
    0.23884924f, 0.20304012f, 0.31567535f, 0.19904923f, -0.03230970f, 0.01177543f, -0.03286989f, -0.01022819f, 
    -0.07041880f, 0.08300334f, -0.00747770f, -0.06779277f, -0.05632468f, 0.00756888f, -0.19780292f, 0.15380181f, 
    0.04321493f, 0.12573376f, 0.01351127f, 0.04410378f, -0.05805085f, 0.04194670f, 0.08719835f, 0.09024798f, 
    -0.06465963f, -0.06915547f, -0.16437405f, -0.08601484f, 0.02391933f, -0.08743463f, -0.17680627f, 0.02293974f, 
    -0.13589881f, 0.03565353f, -0.00992176f, -0.05134446f, 0.01573508f, -0.08836038f, -0.22380847f, -0.11673068f, 
    -0.08383430f, 0.19167767f, 0.03135685f, 0.16679478f, -0.00167816f, 0.02265727f, 0.01583562f, 0.08905798f, 
    -0.03802000f, -0.07310472f, -0.05815357f, 0.01477221f, 0.00065762f, 0.12481665f, -0.01162581f, 0.01193350f, 
    0.02569471f, 0.03205814f, 0.01342601f, 0.01895729f, 0.12572746f, 0.09398372f, -0.08913662f, 0.10503163f, 
    0.08299220f, 0.01588305f, 0.01516314f, -0.04314624f, 0.02878796f, -0.09662297f, -0.03128452f, -0.07371457f, 
    0.00728970f, -0.09609959f, -0.04189659f, 0.09760311f, -0.03129171f, -0.02454249f, -0.04494108f, 0.03172066f, 
    0.02137221f, 0.06230190f, 0.02592126f, 0.02491789f, -0.01623023f, 0.01446873f, 0.03719506f, -0.13538677f, 
    0.11913678f, -0.00125043f, -0.11093252f, -0.01480635f, 0.02068841f, -0.08143537f, -0.06022570f, -0.16231188f, 
    0.03150380f, 0.11049994f, 0.11937633f, 0.00461073f, -0.05193695f, -0.00275179f, -0.07403755f, -0.06081448f, 
    0.03202011f, 0.09838340f, 0.07936101f, -0.08463918f, 0.14436275f, 0.01402322f, -0.12280062f, -0.22364545f, 
    -0.10642188f, -0.05175680f, -0.04841433f, 0.01756695f, 0.08319911f, 0.02103840f, 0.05190255f, 0.08785167f, 
    0.14612953f, 0.05890490f, 0.09322559f, 0.28274304f, -0.00605228f, -0.00737990f, 0.01925969f, 0.10247333f, 
    0.03468198f, -0.01360339f, 0.07158160f, 0.07251342f, 0.14689445f, 0.04628257f, 0.07707202f, 0.09991708f, 
    0.05609737f, -0.08507723f, -0.03045391f, -0.04167413f, -0.03829131f, -0.07848641f, -0.08757428f, -0.03791450f, 
    0.27212465f, 0.08447497f, 0.05773260f, -0.14081945f, -0.03362691f, 0.02853971f, -0.00618591f, -0.02918122f, 
    -0.05571149f, 0.05189208f, 0.05874554f, -0.02830117f, 0.06112181f, 0.06277366f, 0.01074534f, 0.08318762f, 
    -0.09023557f, -0.02011075f, -0.04336559f, -0.04714571f, -0.01401913f, 0.11133695f, 0.07722996f, -0.03955729f, 
    0.12722901f, 0.05924622f, 0.09424349f, 0.03567238f, 0.07922981f, 0.08010080f, -0.01726969f, -0.00459065f, 
    -0.00446240f, 0.06359115f, 0.09142484f, -0.02165787f, 0.21033245f, -0.20489949f, -0.10882606f, 0.18600993f, 
    -0.11598756f, 0.12714393f, 0.09685874f, 0.37082037f, -0.17811370f, 0.05457620f, 0.01112466f, -0.11570758f, 
    -0.02898590f, 0.03153222f, 0.00892633f, -0.03482932f, 0.01068028f, 0.01391830f, -0.01386479f, -0.01181100f, 
    -0.03384171f, -0.03473720f, -0.02924360f, 0.02473812f, -0.02496271f, 0.01654871f, -0.01743424f, 0.01261701f, 
    -0.02359974f, 0.00914607f, 0.00419496f, -0.03371640f, 0.01278152f, -0.01893564f, 0.02069972f, -0.00501738f, 
    -0.00865836f, 0.02213009f, -0.00835507f, -0.00920954f, -0.00976006f, -0.01411748f, -0.02803499f, 0.01750349f, 
    0.00877433f, -0.02462898f, -0.01297806f, -0.01015010f, 0.00665187f, -0.03481165f, -0.03763978f, -0.03959496f, 
    -0.02288906f, 0.03587020f, -0.01815806f, -0.02487204f, 0.01980654f, 0.00064108f, -0.00814731f, -0.01566648f, 
    0.01921464f, -0.03686059f, 0.02204213f, -0.03922832f, 0.01005615f, 0.02582363f, -0.01895628f, 0.00643873f, 
    0.02596853f, -0.01653905f, 0.02392414f, -0.02648714f, 0.00498071f, 0.00676689f, 0.01363938f, -0.03990360f, 
    -0.01557404f, -0.01456189f, 0.01133171f, 0.02149484f, 0.02196910f, -0.00636180f, 0.02521992f, 0.01930620f, 
    -0.02592296f, 0.01897432f, 0.02001701f, -0.02579041f, 0.02265117f, 0.02014476f, 0.02571371f, -0.02175727f, 
    0.03268723f, -0.02589651f, -0.02636300f, 0.02536377f, -0.02924287f, -0.03968492f, -0.01031954f, -0.00144704f, 
    0.02882480f, -0.01169487f, -0.02718545f, -0.02218435f, 0.01315819f, 0.00244020f, -0.00157878f, 0.03025446f, 
    0.01309146f, -0.01378833f, -0.01567678f, -0.01155587f, 0.00368643f, 0.01926908f, -0.01636537f, -0.01854801f, 
    0.00913046f, 0.01914661f, -0.01963534f, 0.00084657f, 0.00397867f, -0.02535114f, -0.04132375f, 0.01153531f, 
    0.00934783f, 0.00137589f, -0.00025625f, -0.03738321f, 0.02306002f, -0.00984265f, -0.02257976f, -0.02005013f, 
    0.02863944f, -0.00128554f, -0.01983966f, -0.02338071f, 0.01977431f, -0.01951907f, -0.02620213f, 0.02435700f, 
    -0.01966479f, 0.00113193f, 0.00641516f, -0.02619844f, 0.00765740f, 0.01424421f, -0.02226977f, 0.01139209f, 
    -0.02096528f, -0.03874282f, 0.00516394f, -0.00405106f, 0.00817113f, 0.02773946f, -0.01606965f, -0.03423302f, 
    -0.00025604f, -0.02980467f, -0.01128076f, -0.00213634f, -0.03056610f, 0.02628974f, -0.03515814f, -0.01665920f, 
    -0.00586412f, -0.02314311f, -0.03413329f, 0.00776502f, -0.01940531f, -0.01829632f, -0.02354553f, 0.01412413f, 
    -0.03543977f, 0.02784276f, -0.03345628f, -0.00070471f, 0.02297395f, -0.03278791f, -0.03506056f, -0.02124367f, 
    -0.00004872f, -0.03849981f, -0.02602509f, 0.01102328f, 0.00755711f, 0.00389997f, 0.01694663f, -0.03493630f, 
    0.01087456f, -0.02013963f, -0.04066018f, -0.01903493f, 0.01576242f, -0.02244028f, 0.01338544f, -0.01451529f, 
    -0.02154685f, 0.01414683f, -0.01988185f, 0.02199661f, -0.01034386f, 0.00734971f, -0.02922488f, 0.00000427f, 
    -0.01920851f, 0.00153136f, -0.00813567f, -0.01488333f, -0.02458772f, -0.03860535f, -0.00510600f, 0.02484209f, 
    -0.02955511f, 0.03060515f, -0.00784298f, -0.00289474f, 0.02729414f, -0.01973479f, -0.03740392f, -0.03029669f, 
    -0.04008884f, 0.00098537f, -0.00900563f, -0.02833179f, -0.02572583f, -0.04135196f, -0.03201495f, 0.00480072f, 
    -0.02085771f, -0.01657222f, -0.02158298f, 0.01284285f, -0.00549082f, 0.01614337f, 0.02001460f, -0.02749352f, 
    0.00622304f, -0.02343546f, -0.03384314f, 0.02145658f, -0.01047038f, -0.01652928f, -0.00437800f, -0.01563641f, 
    -0.02035052f, -0.00204021f, 0.00602717f, 0.02275862f, -0.03682392f, 0.00342965f, -0.01988568f, -0.01688314f, 
    0.01105980f, 0.00102300f, -0.01869908f, 0.02483806f, -0.00088933f, 0.01739205f, -0.02275804f, -0.03167057f, 
    -0.03397012f, -0.02916660f, -0.02134141f, -0.02977503f, -0.00503204f, -0.00919709f, -0.02514142f, 0.02543298f, 
    0.02770027f, -0.00463034f, 0.02425867f, -0.01050249f, -0.03107823f, 0.02441465f, -0.03763166f, 0.01458305f, 
    -0.02087407f, 0.01051554f, 0.02230316f, -0.02752249f, -0.00206042f, -0.01141206f, 0.01643092f, 0.00354283f, 
    -0.03335879f, 0.00839252f, -0.04031617f, 0.01974573f, -0.00870889f, 0.00778509f, -0.03269087f, -0.00701814f, 
    -0.03345165f, 0.01216154f, -0.01329104f, -0.02989715f, -0.03245706f, 0.00289638f, 0.02472196f, 0.02042932f, 
    -0.00051243f, -0.00157982f, 0.02265800f, -0.03590917f, -0.02273507f, -0.03650557f, 0.00357708f, -0.02902870f, 
    -0.02938402f, 0.01486957f, -0.03522631f, -0.01915468f, -0.03807873f, -0.01460296f, 0.00018106f, 0.01930006f, 
    -0.02990119f, -0.03310134f, -0.01415853f, 0.01219715f, -0.02463384f, -0.02636327f, -0.00671127f, -0.00319859f, 
    -0.01325909f, 0.02375567f, -0.02632695f, -0.03398802f, -0.03716996f, -0.02360331f, -0.00653931f, -0.01768826f, 
    -0.01743057f, 0.02597925f, -0.01835781f, -0.03068265f, -0.00021110f, 0.01623148f, -0.03947775f, -0.00589520f, 
    -0.03520861f, -0.00180509f, -0.01648616f, -0.03095118f, 0.01318121f, 0.01314515f, 0.00108798f, -0.02542324f, 
    0.00450264f, 0.00157708f, -0.01045251f, -0.01877892f, 0.01383705f, -0.00168663f, 0.01748714f, 0.00195297f, 
    -0.00228749f, -0.01173866f, -0.00131758f, -0.01001594f, 0.02656705f, 0.03113899f, -0.03335826f, 0.02687410f, 
    -0.03545327f, 0.00084117f, -0.03141081f, -0.03280504f, -0.02526963f, -0.03638383f, 0.00785402f, -0.00214212f, 
    0.00010862f, -0.02816381f, -0.03571619f, -0.03262666f, 0.00755009f, 0.00416347f, -0.00333484f, 0.01105410f, 
    0.02222204f, -0.00379278f, 0.02881942f, -0.02085022f, -0.01302075f, 0.00166565f, 0.02793708f, 0.00681058f, 
    -0.03698005f, -0.04139899f, -0.00367076f, -0.02923138f, -0.03435143f, 0.01443402f, 0.00852669f, -0.03624044f, 
    0.01122883f, 0.01834363f, 0.00252556f, 0.01239175f, -0.03498324f, 0.00463415f, -0.00822613f, -0.00443691f, 
    -0.01870652f, 0.01806504f, 0.01479382f, -0.00536155f, 0.00542273f, -0.00306504f, -0.02493049f, 0.01365051f, 
    -0.02327958f, -0.03136932f, -0.01030334f, -0.00502432f, 0.02307350f, 0.01286209f, -0.00918075f, -0.01044031f, 
    -0.00265859f, -0.00103825f, -0.00270733f, -0.01383509f, 0.02995166f, -0.01554396f, 0.01143719f, 0.00017441f, 
    -0.03129300f, -0.01330977f, 0.00474081f, -0.02791191f, -0.00712795f, -0.00574315f, -0.01847114f, 0.01355952f, 
    -0.03636409f, -0.01206649f, 0.01365218f, 0.02747358f, -0.01408209f, 0.00720133f, 0.01216340f, 0.01589248f, 
    -0.01483055f, 0.01698432f, 0.00270520f, 0.02757903f, -0.00178904f, 0.02166987f, -0.03129566f, -0.03684503f, 
    -0.02120104f, -0.00223421f, -0.02355412f, 0.00523251f, -0.03902645f, 0.00778314f, 0.01509199f, 0.00236217f, 
    -0.02008523f, -0.00104352f, 0.00723608f, 0.00360558f, 0.03239099f, -0.00339441f, -0.01792531f, 0.00116348f, 
    0.00621041f, -0.00632762f, 0.00021392f, -0.02452028f, -0.02514230f, -0.00861568f, 0.00057617f, -0.01255398f, 
    0.00873989f, 0.01371888f, 0.01449229f, 0.02591718f, 0.03118357f, -0.03531525f, 0.01133522f, 0.01225433f, 
    -0.01269285f, -0.01789483f, -0.00148894f, -0.00438391f, -0.02517608f, -0.01522763f, -0.02456387f, -0.02289192f, 
    -0.02995798f, -0.02876154f, 0.02158517f, -0.03478047f, 0.01541955f, 0.01308056f, 0.02018899f, -0.01549092f, 
    0.02327749f, 0.01476246f, -0.01461460f, -0.01711905f, -0.04085028f, -0.03368834f, 0.00193549f, -0.02854347f, 
    -0.01444113f, 0.00900130f, -0.02329148f, 0.01948300f, 0.02283675f, -0.01592771f, 0.01461773f, -0.02266695f, 
    0.03013202f, 0.02946717f, -0.02835689f, -0.03729741f, -0.02240787f, -0.02277826f, -0.02142131f, 0.00382604f, 
    -0.00626707f, -0.01844728f, -0.01464793f, 0.01648062f, 0.00190995f, -0.02568898f, -0.03868701f, -0.01343791f, 
    -0.01035712f, -0.01092540f, -0.00645355f, -0.04048052f, 0.00226998f, -0.00129499f, 0.00493220f, -0.01981025f, 
    0.02122167f, -0.01900062f, 0.00266032f, -0.03183293f, -0.03490461f, 0.01511554f, 0.00219898f, 0.00571641f, 
    -0.00606182f, 0.02864703f, 0.00659197f, 0.02208347f, 0.00733578f, -0.00794409f, 0.02035742f, 0.00052912f, 
    0.02569647f, -0.02791294f, -0.02303932f, 0.00431919f, 0.01134025f, -0.02834329f, -0.02581928f, 0.01960632f, 
    0.03572642f, -0.03299350f, -0.01610986f, -0.04151686f, -0.03171123f, -0.00122064f, 0.01525056f, -0.03598972f, 
    -0.02338495f, 0.01579438f, -0.00232593f, -0.01346839f, 0.02128241f, 0.01376939f, -0.03377397f, -0.00284791f, 
    0.01157951f, -0.03638036f, -0.00890722f, 0.02149965f, -0.02384400f, -0.02187322f, -0.02764922f, -0.02100387f, 
    0.00683549f, -0.01217247f, 0.00425906f, -0.03515581f, -0.03564094f, -0.03229690f, -0.03222344f, 0.00892674f, 
    -0.02952201f, -0.02800201f, -0.00108952f, -0.03766460f, -0.00143386f, -0.00225767f, -0.01013524f, 0.01566168f, 
    0.02318872f, 0.02185823f, -0.03322105f, -0.01611237f, -0.00534376f, 0.01545168f, -0.02612563f, 0.00815861f, 
    -0.02543839f, -0.03073652f, -0.03094457f, -0.03213387f, 0.01750076f, -0.03390117f, 0.00068484f, 0.01812146f, 
    -0.01772856f, -0.00178778f, 0.02258644f, 0.00469114f, 0.01737656f, 0.00494591f, 0.01778070f, 0.02021120f, 
    -0.02355781f, 0.00186087f, 0.01262420f, -0.01362828f, -0.00689646f, -0.02342595f, 0.02202585f, -0.04108490f, 
    0.00304336f, -0.00804329f, 0.01485852f, -0.02398692f, -0.03234277f, -0.01955585f, 0.00128453f, -0.02600010f, 
    -0.01616643f, -0.00212007f, 0.03593840f, 0.02118487f, -0.03611038f, -0.03916503f, -0.03938983f, 0.00847095f, 
    -0.02778451f, 0.01967192f, 0.02447831f, -0.01502010f, 0.01748560f, 0.00808535f, 0.01885123f, 0.00406057f, 
    -0.03393189f, -0.01051115f, -0.01277718f, -0.02973220f, -0.02132442f, -0.01219037f, -0.03506885f, -0.02223227f, 
    0.03572557f, 0.02275963f, -0.01242603f, 0.02044230f, 0.00748183f, -0.01104553f, -0.01593038f, -0.03092068f, 
    -0.00314796f, 0.02003852f, 0.02669902f, 0.03040351f, 0.00972598f, -0.00464585f, -0.01143089f, 0.02000266f, 
    -0.01818934f, -0.04103312f, 0.00814223f, -0.01948586f, -0.00896653f, -0.02285755f, 0.00941854f, 0.01420108f, 
    0.02218198f, -0.03476942f, -0.03320438f, 0.01031501f, 0.01896133f, 0.00764091f, 0.02577167f, 0.02133926f, 
    0.00106538f, 0.01489109f, -0.03520743f, -0.01470653f, 0.01114335f, 0.02819145f, 0.01730498f, -0.01064093f, 
    0.00688409f, 0.01248953f, 0.01300004f, -0.00059595f, -0.03451253f, 0.01491554f, -0.02436985f, 0.02299972f, 
    0.00794665f, -0.00670538f, -0.02272389f, -0.02087809f, 0.01788269f, -0.03163287f, 0.00340592f, -0.03501524f, 
    -0.02585276f, -0.00108812f, 0.00172479f, 0.00149281f, -0.03235721f, -0.04052851f, -0.03919374f, 0.00378229f, 
    -0.03973063f, 0.01422291f, -0.03304063f, -0.02035441f, 0.02972550f, -0.03306916f, -0.00901613f, -0.02465189f, 
    0.01665296f, 0.01032500f, -0.03329274f, -0.03157682f, 0.00269366f, 0.02086158f, 0.02200689f, -0.03131667f, 
    -0.02706374f, 0.00958595f, 0.00513443f, -0.04011571f, 0.02657850f, 0.02544145f, -0.01835103f, -0.02614662f, 
    0.02316254f, -0.02052207f, 0.01340906f, 0.00472204f, 0.02729391f, -0.03765162f, -0.01226279f, -0.03364303f, 
    0.00947132f, -0.02550990f, 0.02843252f, -0.00665716f, -0.02386458f, -0.03797847f, 0.01504821f, 0.02754511f, 
    -0.01348596f, 0.00844432f, -0.02088622f, 0.01167268f, -0.01256143f, 0.01204130f, -0.00057265f, 0.00104102f, 
    0.02088953f, -0.00318298f, 0.00611553f, 0.02530737f, 0.03077579f, 0.00093138f, 0.03622313f, 0.02743230f, 
    0.01165948f, 0.01074594f, -0.03096010f, -0.04454958f, 0.00756720f, 0.02460062f, -0.03922730f, 0.01919099f, 
    -0.00429318f, -0.00460428f, -0.03206057f, 0.00023163f, -0.03859820f, -0.01545349f, 0.02372364f, 0.00718311f, 
    0.01439906f, 0.01675946f, -0.03026187f, -0.03125178f, -0.00741888f, 0.02641751f, -0.01999452f, -0.03500220f, 
    0.00068624f, -0.01840298f, -0.02294006f, -0.00319685f, 0.02737006f, -0.00082932f, -0.01144463f, -0.03615144f, 
    0.02595946f, 0.02679017f, 0.00903232f, -0.00838043f, -0.00377901f, -0.03767641f, -0.01950117f, 0.02092307f, 
    0.01012325f, -0.01229937f, 0.02341966f, 0.01700851f, -0.03093213f, -0.03343768f, -0.03311301f, -0.00103816f, 
    -0.02583013f, -0.00242666f, -0.02674707f, 0.01582711f, -0.00669635f, -0.02366663f, -0.04499858f, -0.02885903f, 
    0.02107459f, -0.02519097f, -0.02005531f, 0.00911326f, -0.03415534f, -0.03533258f, -0.02207860f, -0.01351761f, 
    -0.02959621f, 0.02966652f, 0.02064966f, -0.00885720f, -0.00043619f, 0.01369962f, -0.03701773f, 0.00951048f, 
    0.02901775f, -0.02734527f, -0.02039635f, 0.00341818f, -0.03850224f, -0.03450319f, 0.02995631f, 0.00190222f, 
    0.02805091f, 0.00219603f, 0.01396591f, -0.01805380f, 0.01911313f, -0.01687064f, 0.00279503f, 0.01073775f, 
    -0.00390318f, 0.00707267f, -0.02242260f, -0.00040993f, 0.00818755f, -0.01819958f, -0.02348364f, 0.01959552f, 
    0.01164950f, -0.03207140f, -0.01021574f, -0.03615059f, 0.01161129f, -0.01957398f, 0.02397300f, 0.01962292f, 
    0.01737225f, -0.01126136f, -0.00520717f, 0.00668635f, 0.01300099f, -0.04118751f, 0.02356481f, -0.00462976f, 
    0.02210873f, 0.01453274f, 0.01285415f, -0.00570539f, 0.02136637f, 0.01524979f, 0.01715094f, 0.00141610f, 
    0.00205193f, -0.03631674f, 0.00518061f, -0.04030920f, -0.03577320f, 0.01296995f, -0.00836320f, 0.01775953f, 
    -0.02889544f, -0.03238055f, -0.00460985f, -0.03495128f, -0.02874868f, -0.02283909f, -0.04350787f, 0.01142424f, 
    0.02948796f, 0.00752997f, -0.02470144f, -0.03241772f, 0.02110565f, 0.01753796f, 0.01336224f, -0.02017914f, 
    -0.00881777f, 0.01361412f, -0.02146130f, -0.01958058f, 0.01505715f, -0.03152771f, -0.03232490f, -0.02259126f, 
    -0.00962668f, -0.02167919f, -0.00032407f, 0.01600920f, -0.00869576f, -0.00712402f, -0.00173687f, -0.02261235f, 
    -0.02038325f, -0.03512547f, 0.01519705f, -0.02429398f, 0.01877246f, 0.01223018f, -0.03022342f, -0.04000845f, 
    -0.02326979f, 0.01083021f, -0.00748592f, 0.02104009f, -0.01881431f, 0.00361374f, -0.03516465f, 0.00170305f, 
    0.00642156f, 0.00946170f, -0.02485243f, -0.03502605f, -0.01122339f, -0.01511740f, 0.02659823f, 0.01582722f, 
    -0.00975654f, -0.03190230f, -0.01934568f, 0.02363484f, 0.00449872f, 0.03163432f, 0.00495250f, -0.02074439f, 
    0.01641288f, 0.02603560f, 0.00598310f, 0.00306461f, -0.03403528f, -0.01800765f, 0.01963045f, 0.01584674f, 
    -0.02431885f, -0.01570591f, 0.01408566f, -0.01401094f, -0.01328445f, -0.04773636f, -0.03018362f, -0.04108178f, 
    -0.01087194f, 0.01722986f, -0.01509978f, -0.02129807f, 0.02274770f, 0.00085468f, 0.00115674f, -0.00424071f, 
    -0.02028779f, -0.00875579f, -0.00956537f, 0.00817690f, 0.02264159f, -0.03741375f, 0.01220657f, 0.00506387f, 
    -0.03275372f, 0.01860450f, -0.03217793f, 0.02191847f, 0.02549990f, 0.00447792f, -0.02078288f, -0.00238167f, 
    0.02226533f, -0.00944346f, -0.00969552f, 0.01812509f, -0.00194443f, 0.01452494f, -0.03023407f, 0.01912797f, 
    0.00836979f, -0.00498170f, 0.02598882f, -0.02764453f, -0.00078852f, -0.04303337f, -0.02594271f, 0.00597533f, 
    0.00691363f, 0.03473605f, 0.02408851f, 0.01634107f, -0.00951355f, -0.00806706f, -0.02655286f, 0.00871267f, 
    -0.03376208f, -0.01769346f, -0.02643402f, -0.01699309f, -0.01986119f, -0.03048698f, -0.00780574f, 0.02048588f, 
    -0.03123860f, -0.01956049f, -0.00012416f, 0.01049809f, 0.00595630f, -0.04519040f, -0.03563524f, -0.03665558f, 
    -0.02080334f, -0.00168838f, -0.02053927f, -0.02699181f, -0.03164911f, -0.02857727f, 0.00334680f, 0.02257185f, 
    -0.00276156f, -0.01360801f, -0.01242602f, -0.04302435f, 0.02830382f, -0.02096031f, -0.01542553f, -0.03424026f, 
    0.01515987f, 0.01411174f, -0.00397929f, -0.01685982f, -0.02857842f, -0.00618558f, 0.01505584f, -0.02770237f, 
    0.01544492f, 0.01939445f, -0.02311947f, -0.01783407f, 0.02785175f, -0.03934034f, 0.01204690f, 0.02428809f, 
    0.02138725f, -0.00521476f, 0.02113099f, -0.00679398f, -0.02951530f, -0.03694314f, -0.00659663f, -0.02347342f, 
    -0.01806473f, -0.00706198f, -0.02509864f, 0.00663380f, 0.01478705f, -0.01879366f, -0.00945102f, -0.03438261f, 
    -0.02680307f, -0.03855322f, 0.00964295f, -0.02431988f, -0.00212911f, 0.02500346f, -0.01636629f, 0.00236199f, 
    0.01796200f, -0.01844686f, -0.02545675f, -0.02937050f, -0.02482877f, 0.01201124f, -0.01746635f, -0.03390248f, 
    0.01402386f, -0.02055119f, -0.02342158f, -0.02121603f, -0.02965527f, -0.01432527f, 0.00551674f, -0.00513722f, 
    0.02341270f, -0.01461178f, -0.00674952f, 0.02121074f, -0.03410032f, 0.01441959f, -0.00771231f, 0.00378948f, 
    -0.03267664f, 0.01230931f, -0.02375598f, 0.02059867f, -0.01796987f, -0.03043445f, 0.01714807f, 0.03402086f, 
    0.00928327f, -0.03360140f, -0.00464849f, -0.02173110f, -0.00573236f, -0.01520400f, 0.02032893f, 0.02788534f, 
    0.01047877f, 0.02335812f, 0.00596866f, -0.04117530f, -0.03455546f, -0.02613349f, 0.01488590f, 0.00534449f, 
    -0.01498716f, 0.00236455f, 0.03257321f, -0.00930868f, -0.00093481f, 0.02936430f, 0.03143940f, -0.01575253f, 
    0.01522996f, 0.01928003f, -0.01537951f, -0.00524445f, -0.00758022f, -0.01539465f, 0.01907512f, -0.01159614f, 
    -0.02676084f, 0.00809673f, -0.01746782f, -0.02610061f, -0.01284379f, -0.02135284f, 0.00816641f, -0.00932178f, 
    -0.02071656f, -0.02358603f, 0.00216495f, 0.01921756f, 0.01010056f, 0.00738305f, 0.02053701f, -0.00717223f, 
    -0.02701773f, -0.03279834f, 0.01634599f, -0.02684757f, -0.03046492f, -0.03820782f, 0.00658044f, 0.00302914f, 
    0.02044591f, 0.00793360f, -0.01868336f, -0.00685123f, -0.04442583f, -0.03196423f, -0.03390330f, -0.01178247f, 
    0.01268797f, 0.00260582f, 0.02852208f, -0.03868140f, 0.00102540f, 0.00334769f, -0.00301123f, 0.01382354f, 
    -0.03227632f, -0.01381929f, -0.01041518f, -0.00412567f, -0.01438332f, 0.00278555f, -0.03980710f, -0.01690165f, 
    -0.03034822f, -0.00486316f, -0.03784670f, -0.02727913f, 0.03434908f, 0.03382899f, -0.03295661f, -0.02805231f, 
    -0.01094189f, -0.02986261f, 0.01667792f, -0.01497875f, -0.04210589f, -0.03099793f, -0.02609857f, -0.01632829f, 
    0.00683002f, 0.01977208f, 0.00554280f, -0.00381967f, -0.02000290f, 0.00314534f, 0.00216180f, -0.00040856f, 
    -0.00769696f, 0.02748301f, 0.00801081f, 0.03080093f, -0.01249037f, 0.02456662f, 0.00600863f, -0.00068703f, 
    0.00261636f, -0.02821401f, -0.03003650f, -0.00830847f, -0.01803633f, 0.02869731f, -0.01133316f, 0.02698688f, 
    -0.00396364f, -0.03061110f, -0.01793004f, 0.00977566f, 0.01798676f, -0.00146928f, -0.00303624f, -0.00215769f, 
    -0.01909121f, 0.01676777f, -0.03082542f, -0.02587800f, -0.02267574f, -0.01983676f, -0.00372542f, -0.04228450f, 
    -0.03836273f, 0.02298532f, -0.00470912f, 0.00559842f, -0.02604967f, 0.01193439f, 0.01445376f, 0.02043156f, 
    -0.02629293f, -0.02583337f, 0.02498442f, 0.02768782f, -0.01172771f, -0.00349432f, -0.03790305f, 0.02043405f, 
    -0.04192740f, 0.00436845f, -0.02695750f, 0.00657439f, -0.03704493f, 0.01096401f, 0.00646688f, 0.00272089f, 
    -0.02229520f, -0.03167460f, -0.03230598f, 0.03376558f, 0.00574721f, -0.00178601f, -0.00497531f, -0.02409761f, 
    -0.00176570f, 0.01374160f, 0.00809096f, 0.02107104f, 0.00260101f, 0.02631366f, 0.01551884f, -0.03248494f, 
    0.02329678f, -0.01767830f, -0.04162218f, -0.03014196f, 0.01487858f, 0.01267852f, -0.00363317f, -0.01868326f, 
    0.00581726f, -0.01311901f, 0.03126448f, -0.03873970f, -0.02261255f, 0.00412297f, -0.01711132f, -0.00790430f, 
    0.02245847f, 0.00236872f, -0.01159588f, 0.02394056f, -0.03821265f, 0.01861773f, -0.02565208f, 0.01934562f, 
    -0.03691267f, -0.03311552f, 0.01420702f, -0.03668854f, -0.04971002f, -0.03434807f, -0.02384859f, 0.00852643f, 
    0.02107376f, 0.02502870f, -0.00637542f, 0.02213528f, 0.01582419f, -0.02611346f, -0.01694217f, 0.00202665f, 
    0.00854581f, 0.02358910f, -0.00781701f, 0.03512203f, 0.00607143f, -0.03670846f, 0.01826605f, -0.00494602f, 
    0.00006966f, 0.00710318f, 0.01659322f, -0.02832807f, -0.00125982f, -0.03649654f, -0.02474106f, -0.02679918f, 
    0.03456490f, -0.00148594f, 0.01020870f, 0.00905167f, -0.03941828f, 0.01701188f, -0.00264819f, -0.04907980f, 
    0.03448733f, -0.00853923f, 0.01003715f, 0.00488734f, 0.02414740f, -0.01350556f, 0.00276654f, 0.02678829f, 
    0.01587362f, 0.01092850f, -0.02922082f, -0.00012103f, 0.00494176f, -0.02573683f, -0.01265376f, 0.01248726f, 
    0.01394986f, -0.03732935f, 0.01070044f, -0.01065968f, -0.02924547f, 0.01009816f, 0.02037459f, 0.00199498f, 
    0.02068199f, -0.00603768f, -0.00418538f, 0.00183090f, -0.03113078f, 0.01440436f, -0.03700416f, -0.03019391f, 
    -0.01192304f, 0.02923507f, -0.02748363f, -0.02073971f, 0.01274465f, 0.00687743f, 0.01741160f, -0.00911485f, 
    -0.02476458f, 0.01921411f, -0.01919764f, -0.02231305f, -0.03659629f, -0.03848201f, -0.02313075f, -0.00594430f, 
    -0.02992149f, -0.00438259f, -0.03758796f, 0.02284064f, -0.01700503f, 0.02498754f, 0.00760354f, -0.03898374f, 
    0.02758229f, -0.00780470f, -0.03212005f, -0.02134011f, 0.00802407f, -0.02619025f, 0.03274199f, -0.00084122f, 
    0.00380209f, 0.02639670f, 0.01527507f, -0.02199605f, -0.00289771f, -0.02386961f, 0.01567716f, -0.02114380f, 
    0.00519652f, -0.00863690f, -0.03644400f, 0.00162116f, 0.00526661f, -0.00125703f, 0.00756731f, -0.00830867f, 
    0.00995308f, -0.02662088f, -0.03366127f, 0.00268571f, -0.00956734f, 0.00765495f, 0.00747030f, -0.04041018f, 
    -0.04430223f, -0.00910564f, -0.01587674f, 0.00435506f, -0.02885839f, 0.02726663f, 0.02427395f, -0.03563960f, 
    -0.01061111f, -0.02257369f, 0.02005471f, 0.00796346f, 0.01071634f, -0.00945231f, -0.01691977f, 0.01068713f, 
    0.00834110f, 0.00427891f, 0.01805512f, -0.03518062f, 0.02245150f, -0.02630025f, 0.01349283f, -0.03076421f, 
    0.00485973f, -0.01143381f, -0.00371206f, 0.00159734f, 0.02015217f, 0.00726375f, -0.00002804f, -0.04667819f, 
    -0.00572693f, -0.02428067f, 0.01604686f, -0.01183876f, -0.01096491f, -0.03716695f, 0.01765793f, 0.00547076f, 
    0.01863145f, 0.00762341f, 0.00125176f, 0.01497136f, -0.01069831f, 0.01303425f, -0.02091880f, -0.02315839f, 
    -0.02726797f, -0.00882810f, 0.02106673f, 0.02831024f, 0.01091243f, 0.02739780f, 0.02738571f, -0.01201320f, 
    -0.00994286f, -0.03587431f, -0.00575232f, 0.01565632f, 0.00195907f, -0.02303151f, -0.01942883f, 0.01647127f, 
    -0.00708658f, -0.04203548f, -0.04518513f, 0.00602507f, -0.00172446f, -0.03032120f, -0.03135367f, -0.01912233f, 
    -0.01539187f, -0.01134049f, -0.01514525f, 0.00373013f, -0.00411750f, 0.01668995f, -0.01053737f, -0.03183061f, 
    -0.00072534f, 0.02641020f, 0.00269597f, -0.02223567f, 0.04297786f, -0.01766362f, -0.00619493f, -0.01639965f, 
    0.02680636f, -0.02319779f, 0.01717630f, -0.02093452f, -0.02087831f, -0.02882999f, -0.00415665f, -0.00588533f, 
    -0.00024237f, -0.00010219f, 0.03657706f, -0.01950249f, 0.02338456f, 0.03543908f, -0.01448931f, 0.01353982f, 
    0.00671747f, -0.00126238f, -0.00485296f, -0.04022327f, 0.02488759f, -0.03337552f, -0.01074216f, -0.02243543f, 
    -0.00225126f, 0.01763520f, -0.02898828f, 0.02965516f, -0.02936108f, 0.01760854f, 0.01798119f, -0.00292088f, 
    -0.00704988f, -0.00423818f, -0.01173844f, -0.00931031f, -0.02264890f, -0.02168089f, 0.00328396f, 0.00623223f, 
    0.01884625f, 0.00987475f, 0.00680994f, 0.00236172f, -0.00783181f, -0.04091770f, 0.00251344f, -0.00617974f, 
    0.01911589f, 0.00783744f, -0.01399348f, -0.04261743f, -0.03923012f, 0.00825401f, 0.00180270f, -0.01024937f, 
    0.01089226f, -0.01436637f, 0.02038718f, -0.02280612f, -0.00573361f, -0.02714058f, 0.01191324f, -0.00760406f, 
    0.01469969f, -0.03161367f, -0.04107256f, -0.03311394f, -0.02034050f, 0.00579277f, -0.03265479f, 0.00830234f, 
    -0.00843027f, 0.00461233f, 0.02978168f, 0.00000178f, -0.00589037f, -0.04370511f, 0.01592480f, -0.00261795f, 
    -0.01894290f, 0.03720757f, 0.01544312f, 0.01953904f, -0.01409693f, -0.02741935f, -0.02144297f, -0.01224584f, 
    0.00787587f, -0.03166993f, -0.04342882f, 0.02274767f, -0.02026925f, -0.00725788f, 0.00072458f, -0.03089082f, 
    0.01399478f, -0.03992275f, 0.01423159f, 0.01290758f, -0.01673753f, -0.02111949f, -0.03251494f, -0.04266698f, 
    -0.02860506f, 0.02422524f, 0.02044730f, -0.03701216f, -0.01222570f, -0.00975105f, 0.00419173f, 0.00238375f, 
    0.02383690f, -0.00901833f, 0.01275107f, -0.02926359f, -0.01055644f, 0.03036748f, -0.03025600f, 0.02173703f, 
    -0.03219930f, -0.01022159f, -0.03676130f, 0.02465599f, -0.02477775f, 0.01851045f, -0.03354670f, 0.00644080f, 
    -0.02404549f, -0.01935686f, -0.01323676f, -0.02096633f, 0.01466480f, 0.01815592f, 0.01826928f, 0.00669154f, 
    -0.02987447f, -0.03669203f, -0.00149650f, -0.02726072f, 0.01368201f, -0.03575742f, -0.00037716f, -0.00151608f, 
    0.02456981f, -0.00953674f, -0.02168166f, -0.03213086f, 0.02052922f, 0.00069258f, -0.01155805f, 0.02505490f, 
    -0.04282564f, 0.01983178f, 0.00562150f, -0.01030874f, 0.02041451f, -0.01150016f, -0.01068648f, -0.03531779f, 
    -0.02675444f, 0.01325790f, -0.00672529f, -0.00808622f, 0.00203141f, -0.02723721f, 0.00318754f, -0.03665932f, 
    -0.02740859f, -0.01293172f, 0.02182303f, 0.02963427f, 0.01078932f, -0.01443414f, -0.00394476f, -0.03210152f, 
    0.01064741f, 0.04023255f, -0.03604170f, 0.02297151f, -0.02223299f, -0.02909841f, -0.03082208f, 0.02245013f, 
    0.00463509f, 0.00691059f, 0.02583547f, 0.01283245f, 0.03534428f, 0.00682223f, -0.00740140f, -0.00082512f, 
    -0.03914573f, 0.00567173f, 0.02753687f, -0.01863576f, -0.01315694f, -0.01566211f, -0.01278401f, -0.01865933f, 
    -0.02546269f, -0.00489349f, 0.01437658f, -0.03820903f, -0.03312574f, -0.02988498f, -0.02536236f, -0.00440158f, 
    -0.00665814f, 0.00354445f, -0.02283667f, -0.04213869f, 0.01921281f, 0.01069489f, 0.00430021f, -0.01705926f, 
    -0.02853986f, 0.00850117f, 0.01798296f, 0.00036227f, 0.02035931f, -0.01126148f, 0.00035552f, 0.03332859f, 
    0.03991130f, -0.00253767f, 0.02217796f, -0.00770772f, 0.02359385f, 0.02976964f, -0.01968149f, -0.03044138f, 
    0.01452591f, 0.00446562f, 0.02554361f, -0.02195915f, -0.03218295f, -0.00812366f, 0.02246314f, -0.02076291f, 
    -0.01756508f, -0.01483495f, 0.02631621f, 0.02368867f, 0.01223274f, -0.00025942f, 0.01896008f, -0.00732498f, 
    -0.01023533f, -0.03095362f, -0.02606912f, -0.01627112f, 0.02844184f, 0.01912659f, -0.01173544f, -0.03247502f, 
    0.02721201f, 0.00744869f, -0.00978152f, 0.04435028f, 0.01068402f, 0.01855093f, 0.00752531f, -0.02527038f, 
    0.01388681f, -0.01448531f, -0.02627045f, -0.02108802f, -0.03443958f, 0.02103653f, -0.00736025f, -0.01021706f, 
    -0.01726542f, -0.03341097f, -0.04114103f, -0.00119488f, -0.02788650f, -0.02765885f, -0.02401864f, -0.04023558f, 
    -0.00166209f, -0.02597530f, -0.00115923f, -0.04367231f, -0.00230874f, -0.00189640f, 0.00461288f, -0.02393352f, 
    -0.01229302f, -0.01071683f, -0.02590957f, 0.02637891f, -0.02263705f, 0.00609733f, 0.02707839f, -0.02923283f, 
    -0.01823428f, 0.01479895f, -0.01532070f, -0.01896898f, 0.00582212f, -0.02469679f, -0.00156142f, -0.01351074f, 
    -0.00361658f, 0.01681279f, -0.01469417f, -0.02052021f, 0.01529392f, 0.02752182f, 0.01903257f, 0.00695604f, 
    -0.01238096f, -0.03672148f, -0.02627329f, 0.00255667f, -0.04180889f, 0.01105516f, -0.01652125f, -0.01425524f, 
    -0.02907970f, -0.04291579f, 0.01590382f, -0.01415845f, 0.02201430f, -0.00751824f, -0.02659218f, 0.00497004f, 
    0.00444425f, -0.01046758f, -0.00675965f, -0.01972687f, -0.01663956f, -0.01830924f, -0.01168859f, -0.00982901f, 
    -0.03976068f, 0.00485198f, 0.02781474f, 0.02608424f, -0.00008901f, -0.00566459f, 0.01675459f, 0.00134683f, 
    -0.03812701f, -0.02012921f, -0.00213877f, -0.04114594f, -0.01754871f, 0.02502201f, -0.04044688f, 0.00908623f, 
    -0.03277973f, -0.01119625f, -0.03173130f, 0.01851517f, -0.02551237f, 0.00288527f, -0.03516723f, -0.02665407f, 
    -0.01476757f, 0.01491225f, -0.03066670f, 0.02882032f, 0.01497018f, 0.02537133f, 0.00142671f, -0.03137463f, 
    0.00868937f, -0.01834953f, 0.01877209f, -0.00224852f, -0.03366291f, -0.00650771f, -0.02127341f, 0.02689096f, 
    -0.04006490f, 0.02297938f, -0.02624704f, 0.01919712f, -0.03037223f, -0.00228248f, 0.02351482f, 0.00780676f, 
    -0.03793255f, -0.00696534f, 0.00567094f, 0.02353339f, -0.02635409f, 0.03593906f, -0.03201162f, -0.01716179f, 
    -0.00264679f, 0.02645625f, 0.02170380f, 0.03354818f, 0.00678980f, -0.03604323f, -0.02099818f, 0.00807079f, 
    -0.00642735f, 0.02427960f, -0.01965570f, -0.03363663f, -0.04196607f, -0.02155295f, -0.01463110f, 0.02208917f, 
    -0.04121566f, 0.01139575f, 0.00790111f, -0.02851209f, 0.00555570f, -0.03438702f, -0.00015636f, -0.02133562f, 
    -0.00194490f, 0.02579214f, 0.00155452f, 0.00635743f, -0.02132858f, -0.02940968f, -0.03570927f, 0.02593787f, 
    0.03033344f, -0.00381666f, -0.03488606f, 0.01733514f, 0.02695103f, -0.04130151f, 0.00030945f, 0.02492423f, 
    -0.01389979f, -0.02463696f, -0.01483337f, -0.01483111f, -0.00927556f, -0.03779717f, -0.03119142f, 0.00764509f, 
    -0.00106270f, 0.00125534f, -0.04102528f, -0.00546206f, -0.01797207f, -0.00991228f, -0.04070817f, 0.00646248f, 
    0.01651315f, -0.03669403f, -0.04193320f, 0.01233916f, 0.03460194f, -0.01970453f, 0.02660812f, -0.03432460f, 
    -0.01467382f, 0.00619414f, 0.01875108f, 0.02263317f, 0.00024777f, -0.00999707f, -0.01667165f, -0.01823319f, 
    -0.02372452f, 0.01882557f, -0.02569944f, -0.02000684f, -0.01655551f, 0.02566532f, 0.01407907f, 0.01869533f, 
    0.01937405f, 0.00190825f, -0.00089753f, -0.00101259f, 0.03175460f, -0.03271094f, -0.02387922f, 0.00800729f, 
    0.00993656f, 0.01257540f, -0.01567092f, 0.00447485f, 0.01156767f, -0.00965529f, 0.02679870f, -0.01821745f, 
    -0.01916939f, -0.00454101f, 0.01853353f, 0.02012745f, 0.00464487f, -0.01166048f, 0.02111136f, -0.02254317f, 
    0.02215652f, -0.01923441f, -0.02123684f, -0.00336793f, 0.03034098f, 0.01355426f, -0.03926725f, 0.00175714f, 
    -0.01095670f, 0.02057042f, -0.02779351f, -0.01466601f, -0.02302709f, -0.00344599f, -0.01322951f, -0.03566358f, 
    0.00553040f, 0.01316328f, -0.00888912f, -0.00470750f, -0.01338535f, 0.00330160f, 0.01211403f, -0.02658364f, 
    -0.04205978f, 0.02458310f, 0.01337129f, -0.00162620f, -0.02398589f, -0.00408160f, 0.01705513f, -0.01346560f, 
    0.00643547f, -0.00052547f, -0.00357887f, -0.02663292f, -0.00909148f, -0.00644917f, -0.00468732f, 0.01038954f, 
    -0.01719094f, -0.01578668f, -0.03295348f, -0.01903970f, 0.00708041f, 0.01541802f, -0.02189049f, 0.00601218f, 
    -0.01173779f, -0.01111552f, 0.02267800f, 0.02064880f, -0.01735936f, 0.00926525f, -0.01265958f, -0.02506864f, 
    -0.02020871f, 0.02250662f, 0.01153056f, 0.01151584f, 0.01648704f, 0.01034087f, -0.03697338f, -0.03491626f, 
    0.01778694f, 0.04062160f, 0.01962697f, 0.01937672f, -0.01549111f, 0.00977004f, 0.01487274f, 0.02375944f, 
    -0.02633563f, -0.00119170f, -0.03118645f, -0.01239817f, -0.04126306f, -0.01728394f, -0.01887256f, 0.02280757f, 
    0.01120841f, 0.02727039f, 0.02558680f, -0.00254874f, 0.00176836f, -0.02126499f, -0.00376173f, 0.01689757f, 
    -0.00460503f, -0.01460827f, -0.00933841f, -0.02810227f, 0.00843876f, -0.04239936f, 0.00764422f, -0.00768404f, 
    0.02110452f, 0.02976331f, -0.02153403f, 0.01321806f, 0.00458539f, -0.04140796f, 0.02129740f, 0.00189411f, 
    0.00133027f, -0.02082516f, -0.04429844f, 0.01813892f, 0.02308733f, -0.03459799f, 0.01655125f, 0.00876964f, 
    -0.00642326f, 0.01056773f, -0.01396177f, 0.01526340f, 0.00582608f, 0.02486786f, -0.01330094f, -0.00599107f, 
    -0.02597761f, 0.02626815f, -0.00795213f, 0.00238141f, -0.00026081f, 0.01570421f, 0.01493546f, -0.04095117f, 
    0.00238169f, 0.00384321f, -0.03521974f, -0.02909174f, 0.01285976f, -0.01691111f, -0.02022355f, 0.02330440f, 
    0.01114202f, -0.02622151f, -0.02452203f, 0.02563246f, -0.02248107f, 0.00766576f, 0.00091639f, -0.02295460f, 
    -0.00000896f, -0.01230485f, -0.00163015f, -0.01160572f, -0.00931953f, -0.01266341f, 0.02469086f, 0.01371142f, 
    -0.00933560f, -0.01271448f, -0.02367240f, 0.00044782f, -0.02842122f, -0.01316034f, 0.02561195f, -0.02260496f, 
    -0.00660799f, 0.02252395f, -0.02344994f, 0.02644495f, -0.02393532f, 0.01792994f, 0.00531180f, -0.02817810f, 
    -0.04356637f, -0.02582774f, -0.01995982f, -0.02955010f, -0.01361308f, -0.03910847f, -0.03587023f, 0.01409123f, 
    0.01034796f, -0.00559128f, -0.00457264f, -0.01792292f, 0.01459279f, -0.02298812f, 0.01778342f, -0.01531481f, 
    -0.00747953f, 0.00315882f, -0.02241379f, 0.02282270f, -0.01383318f, -0.02650836f, 0.00106576f, -0.01323858f, 
    0.01482250f, 0.00781803f, -0.01058593f, -0.02555751f, -0.02337638f, -0.00079459f, -0.01456205f, -0.03056390f, 
    -0.04246183f, -0.01878586f, -0.02157198f, -0.02767424f, -0.01140359f, -0.02107992f, 0.01339895f, -0.01850930f, 
    0.02170468f, 0.00706412f, 0.03812193f, 0.02107336f, -0.03359270f, 0.03924501f, -0.00307561f, -0.01736719f, 
    -0.03517740f, 0.01433600f, 0.02964379f, -0.03707314f, -0.01970624f, -0.01390206f, -0.00242895f, -0.00306943f, 
    0.01503199f, -0.00976639f, 0.01922074f, 0.02397977f, -0.00636082f, -0.01793316f, 0.02681322f, -0.01374117f, 
    -0.01977607f, 0.02733672f, -0.03960700f, -0.02784714f, -0.00611942f, -0.02339456f, 0.02767031f, -0.03122317f, 
    -0.04380053f, 0.00583925f, 0.02423476f, -0.01918250f, -0.01592501f, 0.00332698f, -0.02571925f, -0.01052716f, 
    -0.03218991f, -0.02222378f, 0.00814565f, 0.00790444f, -0.00356964f, -0.04197443f, 0.00149535f, -0.01294247f, 
    -0.01024561f, -0.02321931f, 0.01519703f, -0.03185087f, -0.03670032f, 0.02186097f, 0.02039999f, -0.02200001f, 
    -0.00459621f, 0.00004068f, -0.02007776f, -0.00930200f, 0.01686914f, -0.03023141f, -0.03537599f, -0.03496845f, 
    -0.01375171f, -0.00849517f, 0.00237701f, -0.00731621f, 0.00653277f, -0.01035275f, 0.01969278f, -0.03114961f, 
    0.02350840f, 0.01346932f, 0.00551032f, 0.02568020f, -0.02200529f, 0.02386596f, 0.01290938f, -0.04363758f, 
    0.00265444f, 0.02587512f, 0.02342813f, -0.04018422f, 0.00644726f, -0.01719394f, 0.00290943f, -0.02291424f, 
    0.00379589f, 0.01085813f, -0.00968832f, -0.00109424f, -0.00923750f, -0.02455656f, 0.01271739f, -0.03013389f, 
    -0.00248882f, -0.01375378f, 0.00066581f, -0.03169822f, -0.03448210f, -0.00692804f, -0.00288939f, -0.03465584f, 
    0.00282470f, 0.01981234f, -0.01516807f, -0.00719404f, 0.02255061f, 0.03737598f, -0.01145299f, 0.00479697f, 
    0.01402986f, -0.00125255f, 0.00864451f, -0.04117329f, 0.01544347f, -0.02130396f, -0.00873708f, 0.00961231f, 
    -0.02564212f, 0.00421702f, 0.01322850f, 0.01280416f, 0.01597982f, 0.00974426f, 0.01422113f, -0.01902219f, 
    -0.02649862f, 0.01991566f, -0.01387947f, 0.01514644f, -0.01172119f, 0.00558660f, -0.01127785f, 0.00685063f, 
    -0.00291533f, -0.04799725f, -0.04829017f, 0.00012336f, -0.02293087f, -0.01966702f, -0.03617118f, -0.01655788f, 
    0.02510588f, -0.01410457f, -0.01529967f, 0.01916171f, -0.02754871f, 0.02902687f, -0.03651018f, -0.02055888f, 
    -0.00955380f, 0.02192193f, -0.02375938f, -0.03909548f, 0.01238183f, -0.03417194f, -0.02878749f, -0.04368473f, 
    0.01764056f, 0.01105761f, 0.01714479f, 0.00790891f, -0.01698623f, -0.03204292f, -0.03181989f, 0.01244971f, 
    -0.02627305f, -0.04622915f, -0.01957086f, 0.01351565f, -0.03800378f, -0.00740582f, -0.01111197f, 0.02517697f, 
    -0.03130220f, -0.01546247f, -0.01303820f, -0.03738005f, 0.02364033f, -0.03988197f, 0.02344500f, -0.00806548f, 
    0.00726071f, -0.02984233f, 0.01773858f, 0.02480274f, 0.00922539f, -0.03144683f, -0.00428906f, -0.04401937f, 
    0.02964821f, 0.00366140f, -0.04338853f, -0.00029331f, -0.04433127f, 0.01629172f, -0.04144882f, -0.03838413f, 
    0.00328634f, -0.01908993f, 0.00590496f, -0.01344907f, 0.00217888f, 0.01448294f, -0.02704463f, -0.02091207f, 
    0.00715970f, -0.02285984f, -0.01439634f, 0.01778940f, -0.03117336f, 0.02546471f, -0.00921024f, 0.00712466f, 
    0.02058907f, -0.02044421f, -0.01385188f, -0.02193440f, -0.03492006f, -0.01227698f, -0.02069205f, -0.02642000f, 
    0.01112321f, -0.01857983f, -0.04345396f, -0.02883595f, 0.02526093f, 0.01341047f, 0.00148308f, -0.02485514f, 
    0.00063579f, -0.01021707f, -0.00064715f, -0.01604822f, 0.00040594f, -0.03324449f, 0.01725470f, -0.02114817f, 
    -0.01187988f, 0.02227677f, 0.00509569f, 0.00530482f, 0.01106522f, 0.00810573f, -0.02366633f, -0.00421797f, 
    -0.00971950f, -0.03872741f, -0.00208252f, 0.01038017f, 0.00020170f, -0.00622435f, -0.00324447f, -0.02516160f, 
    0.00909447f, 0.01496665f, -0.00972177f, -0.01514929f, 0.00337928f, 0.02172825f, -0.00272249f, 0.01529454f, 
    0.03331101f, -0.03599308f, 0.02030781f, -0.03291769f, -0.00144646f, -0.04027684f, -0.01230762f, -0.04547451f, 
    0.00010284f, -0.00541292f, 0.00050321f, -0.04962055f, 0.02493690f, -0.00983207f, -0.02363698f, -0.00696183f, 
    -0.02883576f, 0.01268929f, 0.01982651f, -0.01281803f, -0.03737677f, -0.03649190f, -0.02624611f, 0.02493690f, 
    0.01605671f, -0.00731547f, -0.02453880f, 0.02565762f, -0.03639725f, -0.00010072f, -0.04378443f, -0.00127674f, 
    -0.00144920f, 0.01545780f, -0.01434010f, 0.02777926f, -0.00752861f, 0.01196142f, 0.00352875f, -0.00919036f, 
    0.00395785f, -0.01809682f, 0.01273511f, -0.03596636f, 0.01907080f, 0.01462673f, -0.00438836f, -0.04052379f, 
    -0.03571358f, 0.00333375f, -0.03241802f, -0.01640765f, -0.01044025f, -0.01291464f, -0.02269989f, -0.02236281f, 
    -0.01011590f, -0.01695413f, -0.00484132f, 0.00680168f, 0.01793255f, -0.03908848f, 0.00601859f, 0.01809981f, 
    -0.01269094f, -0.01625556f, -0.00784190f, -0.01808732f, -0.02659845f, 0.02221174f, -0.02025638f, 0.02363287f, 
    0.03454012f, -0.01185250f, -0.04423720f, 0.00979187f, -0.03465967f, -0.04904220f, -0.04294207f, 0.02093514f, 
    -0.02868233f, 0.01602181f, 0.01438419f, -0.00872611f, 0.01428086f, -0.01144775f, 0.02286104f, 0.01109423f, 
    0.02343679f, 0.01477703f, -0.01468969f, -0.01466058f, 0.01243459f, 0.00745921f, -0.01103441f, 0.02548712f, 
    -0.02000446f, -0.02155522f, 0.01913228f, 0.01255550f, 0.00851083f, -0.02854136f, 0.02135974f, 0.02575221f, 
    0.01280471f, 0.01897157f, -0.00805720f, -0.02400349f, -0.03697973f, -0.02882833f, -0.00792944f, -0.02413788f, 
    0.01155897f, -0.00156257f, -0.00742575f, 0.02339428f, -0.02457530f, -0.01388353f, 0.02596075f, -0.03236873f, 
    -0.01271778f, 0.00430405f, -0.01115558f, 0.00557771f, -0.00300379f, -0.02509828f, 0.00918279f, 0.01882004f, 
    0.01384009f, -0.04071726f, -0.02949077f, -0.00876708f, -0.00213716f, -0.02420513f, -0.00068403f, -0.02935990f, 
    -0.03827380f, 0.01166203f, -0.03200136f, 0.00195571f, -0.02596131f, 0.00560060f, -0.00708687f, 0.00348269f, 
    0.00337023f, -0.01734651f, 0.00016866f, -0.00921641f, -0.04612317f, -0.03563024f, -0.02102081f, -0.01950926f, 
    -0.02093703f, -0.03937549f, -0.03813352f, -0.03501803f, -0.01650379f, -0.02941498f, -0.00425787f, -0.00706349f, 
    -0.03968005f, 0.03168567f, -0.02008243f, -0.03604620f, -0.01493059f, -0.01000285f, 0.01747978f, -0.01761522f, 
    -0.02409832f, 0.00207737f, 0.02464919f, -0.02348996f, 0.01074991f, 0.00011150f, -0.00515707f, 0.00107023f, 
    -0.02605043f, -0.01366633f, -0.03807995f, -0.00793976f, -0.03335653f, -0.03286935f, 0.01194692f, 0.02215008f, 
    0.00338779f, -0.00528868f, 0.00966469f, -0.04320765f, 0.02464499f, -0.02838906f, 0.01009868f, 0.01206144f, 
    0.01825176f, -0.03172944f, 0.02097427f, 0.01914705f, 0.02666800f, -0.00169908f, -0.00010351f, 0.00624945f, 
    -0.02763723f, -0.02192512f, -0.01772140f, -0.03473612f, 0.00959863f, -0.02827322f, -0.00011736f, -0.03448359f, 
    -0.00578428f, 0.01110032f, -0.01503681f, -0.00607744f, -0.03415514f, 0.01064291f, -0.04148242f, -0.02152069f, 
    -0.02805187f, -0.02204364f, 0.02126552f, 0.01497425f, 0.00851867f, 0.01966275f, 0.00793699f, 0.02316808f, 
    -0.03861865f, 0.00163737f, -0.02593091f, -0.01821468f, -0.04061634f, 0.01043329f, -0.01263773f, -0.03880474f, 
    -0.01955749f, 0.01393749f, 0.01710097f, 0.02232309f, -0.02452926f, -0.00620573f, 0.01279656f, -0.02422535f, 
    0.00016528f, -0.01525734f, -0.01995196f, -0.01426951f, 0.01637684f, -0.00965401f, 0.01131000f, -0.00107153f, 
    -0.00189558f, -0.00978064f, -0.01096522f, -0.01548284f, -0.03275736f, -0.02714931f, -0.01943513f, -0.03229879f, 
    -0.00909516f, -0.03560609f, -0.02035036f, 0.02023440f, -0.01488989f, 0.01584609f, -0.00116190f, -0.04269820f, 
    0.00284847f, -0.00100748f, -0.01675110f, 0.00178697f, 0.01460923f, -0.00585704f, 0.01102651f, -0.04226635f, 
    -0.01119513f, -0.01053566f, -0.02151748f, 0.00229158f, 0.00555835f, 0.00193908f, -0.02176211f, -0.01393966f, 
    -0.01007913f, 0.02473546f, 0.02072688f, -0.04352893f, 0.01016093f, -0.03121729f, -0.02574166f, -0.01083827f, 
    0.01588126f, -0.01286695f, -0.03312533f, 0.01143085f, -0.00639624f, -0.02989716f, -0.00202154f, 0.02058135f, 
    0.01905597f, -0.02011646f, 0.01404287f, -0.03745874f, -0.03055724f, -0.02580008f, -0.02054856f, 0.01465795f, 
    -0.03046670f, 0.00257561f, -0.00892003f, -0.02078564f, -0.02065307f, -0.03666697f, 0.00517354f, -0.03086087f, 
    0.02557431f, -0.02212443f, -0.01246688f, -0.02090029f, 0.02106523f, -0.01014694f, 0.00099743f, 0.00694870f, 
    -0.01657076f, 0.02188307f, -0.03703656f, 0.01949019f, 0.01384713f, -0.01215872f, 0.02180623f, -0.04005095f, 
    0.01827345f, -0.04322010f, -0.01341517f, -0.04189545f, 0.02891013f, -0.04220209f, -0.02342266f, -0.03271472f, 
    0.01453141f, -0.04168240f, 0.01830566f, 0.01746438f, 0.02659601f, 0.00479985f, 0.00921691f, -0.03848472f, 
    -0.00058118f, -0.00917327f, -0.01586454f, 0.01693233f, -0.05265265f, -0.02679686f, 0.00191693f, 0.01319292f, 
    0.00981930f, 0.00482508f, 0.00701551f, -0.00171179f, -0.01725648f, -0.03798940f, 0.01732101f, 0.01521635f, 
    -0.02055613f, 0.02873355f, 0.00087871f, 0.03442679f, 0.01444713f, -0.01187400f, -0.00721052f, 0.01534971f, 
    -0.01211479f, -0.01883025f, 0.00686929f, -0.00367109f, -0.04461608f, -0.02469139f, 0.01870731f, 0.03219238f, 
    -0.03591191f, -0.02594215f, 0.00799120f, 0.00406007f, 0.01989560f, -0.04425882f, 0.00205522f, -0.02747437f, 
    0.02413687f, 0.02225781f, -0.03967608f, 0.00263854f, 0.00612744f, -0.03102901f, -0.02006349f, -0.00959569f, 
    0.01011837f, -0.02833105f, -0.04128110f, -0.01014273f, 0.01220329f, 0.00681454f, -0.04461055f, -0.03672395f, 
    -0.02906322f, -0.00680742f, -0.01093289f, -0.02219872f, 0.02526530f, 0.00622211f, 0.03365639f, -0.03376827f, 
    -0.00569629f, -0.03646833f, -0.00971587f, 0.01181766f, -0.04474917f, -0.00740013f, -0.03784938f, 0.01286126f, 
    -0.03274272f, -0.03642455f, -0.03162753f, 0.00053573f, 0.00511356f, 0.01136878f, 0.00108335f, -0.04140956f, 
    0.01044376f, -0.00875914f, -0.02732890f, 0.01058207f, 0.00269116f, -0.01060516f, 0.00845989f, -0.03210112f, 
    0.01910311f, -0.04123951f, 0.01675528f, -0.00450427f, -0.02961923f, 0.01661825f, 0.02151608f, 0.02467893f, 
    -0.01558758f, -0.04413944f, 0.01922500f, -0.01314442f, -0.00302239f, 0.01037229f, -0.02531121f, -0.02911017f, 
    -0.02427681f, -0.00249490f, -0.00039270f, 0.02117788f, 0.02585128f, 0.01407121f, -0.02656304f, -0.00452020f, 
    -0.01730990f, -0.00028813f, 0.00145874f, 0.00908161f, 0.01594634f, 0.00576622f, 0.01462705f, 0.02299891f, 
    0.00228352f, -0.01229684f, -0.00879805f, 0.01632525f, -0.02474256f, 0.00724821f, 0.01517621f, -0.01551325f, 
    -0.01841026f, -0.03269443f, -0.03552507f, -0.01525461f, 0.00261143f, -0.01125375f, -0.00312378f, 0.02591576f, 
    -0.03237061f, -0.02737164f, 0.03929640f, -0.01259881f, -0.04224255f, 0.02245908f, 0.01553136f, 0.00761537f, 
    0.02057684f, -0.01143266f, 0.01629867f, -0.01414595f, -0.00532478f, -0.03330363f, 0.02785782f, -0.01096279f, 
    -0.03537572f, -0.01008867f, -0.04449367f, -0.01279384f, 0.00467479f, -0.00274369f, -0.00201237f, -0.02506093f, 
    -0.02618215f, 0.00755391f, -0.02519564f, 0.01600897f, 0.02470850f, -0.04056016f, -0.03476045f, 0.00622013f, 
    -0.02241208f, -0.03578863f, 0.01610177f, -0.01415773f, 0.01990492f, 0.01389900f, 0.00339365f, -0.03483387f, 
    -0.01609695f, -0.03511193f, -0.00934261f, 0.01701503f, 0.00082074f, 0.02381732f, 0.01015505f, -0.03326911f, 
    -0.00187770f, 0.01429341f, -0.04773572f, 0.01823278f, 0.00256728f, -0.02460061f, -0.01141239f, 0.00322599f, 
    0.00663416f, 0.02583721f, -0.04309281f, -0.04249863f, 0.00518883f, 0.01174207f, -0.03976872f, 0.03311402f, 
    -0.03155542f, 0.02411171f, -0.02651265f, -0.02692433f, -0.01301763f, -0.03620336f, -0.00075725f, 0.02567517f, 
    0.02949218f, -0.02203898f, 0.00918095f, -0.01306798f, -0.00295429f, -0.02939314f, -0.03580068f, 0.02201425f, 
    -0.03363960f, 0.00150081f, 0.00586896f, 0.02093526f, 0.00673718f, 0.01357743f, 0.00303092f, -0.04159804f, 
    -0.03952929f, -0.00590265f, 0.02641530f, -0.01395843f, -0.00309100f, 0.00106799f, 0.02086107f, 0.02546507f, 
    -0.00712992f, -0.01032528f, 0.00195019f, -0.01158967f, -0.00416749f, -0.02025588f, 0.02394640f, 0.01982100f, 
    -0.02084186f, -0.02013166f, 0.00570169f, -0.01074551f, 0.01223542f, -0.00183059f, -0.02104362f, -0.02387513f, 
    -0.02805631f, -0.00052218f, -0.03787989f, 0.02127889f, 0.01288060f, -0.02377437f, -0.01813061f, -0.00943541f, 
    -0.01022434f, 0.02850243f, 0.01688264f, -0.00518128f, -0.00711168f, 0.02037712f, -0.03479055f, 0.01172038f, 
    -0.02505939f, -0.00576989f, -0.01248972f, -0.03789191f, -0.03417426f, -0.00685390f, -0.00563541f, 0.01347087f, 
    -0.01864767f, -0.00302914f, 0.00057577f, 0.02168586f, 0.01030626f, -0.01567381f, -0.00954607f, -0.04032624f, 
    -0.02562234f, -0.00531798f, -0.00308555f, -0.02767875f, -0.03804513f, -0.03212948f, -0.01298393f, -0.01522170f, 
    0.02648516f, 0.00911251f, -0.03252882f, -0.00585368f, -0.01141996f, -0.03959353f, -0.02776265f, -0.01331183f, 
    -0.03861766f, 0.02678951f, -0.00544558f, -0.00141190f, -0.01638987f, -0.03475039f, 0.00851245f, -0.02296905f, 
    -0.03737465f, 0.02601849f, 0.01470594f, 0.00750075f, 0.02940883f, 0.02046525f, -0.00185749f, -0.02149446f, 
    -0.03533794f, -0.03811212f, -0.03564344f, -0.03052171f, 0.02630360f, -0.02290079f, -0.02548701f, 0.00736157f, 
    -0.01453252f, -0.01782725f, 0.00816136f, 0.00803209f, -0.03846725f, -0.00568737f, 0.02611776f, -0.02679735f, 
    0.01344144f, -0.01613695f, 0.02296723f, 0.00987830f, -0.02199508f, -0.02429198f, -0.01395181f, 0.00779032f, 
    -0.00562376f, 0.01800271f, -0.01635157f, 0.00272277f, -0.01067120f, 0.00562110f, -0.04136796f, 0.01680439f, 
    -0.00838253f, -0.01883208f, 0.02509184f, 0.02137801f, -0.02789705f, 0.00516768f, -0.01052021f, 0.00807395f, 
    0.02054180f, 0.01435829f, -0.02129185f, 0.00535086f, 0.01534223f, -0.00504683f, 0.00914747f, 0.01693071f, 
    0.02165998f, 0.02507252f, 0.00100709f, -0.02506951f, -0.04160439f, -0.03603631f, -0.01753322f, -0.00465659f, 
    -0.00003319f, 0.02653091f, 0.00606580f, -0.04083738f, 0.01100261f, 0.02511963f, 0.01006863f, 0.02423038f, 
    0.02860383f, 0.02027113f, 0.01782518f, 0.02021772f, 0.02515244f, -0.04194960f, -0.03225101f, -0.01133036f, 
    -0.02616896f, -0.03498686f, -0.00927322f, 0.02591899f, -0.01925804f, -0.02526413f, -0.03622077f, -0.01461694f, 
    -0.03403214f, -0.04189487f, -0.02055392f, -0.00718263f, 0.01972152f, -0.01976947f, -0.02672341f, 0.00091231f, 
    0.02948351f, -0.01658515f, -0.01689370f, -0.02745549f, 0.02346475f, 0.00265654f, -0.01867988f, -0.00122266f, 
    -0.02658095f, -0.03761047f, -0.04131611f, -0.01283494f, -0.03399127f, 0.02973307f, 0.00868367f, 0.02025315f, 
    -0.02423216f, 0.00115559f, -0.03671162f, 0.00818081f, -0.01488472f, -0.03743784f, -0.03561525f, 0.01949340f, 
    -0.03294932f, 0.01524336f, -0.01742827f, -0.03133272f, 0.00594075f, -0.02827466f, 0.01141550f, -0.03135879f, 
    0.01914648f, -0.01084422f, -0.00218647f, -0.03270714f, -0.01672330f, 0.00905474f, -0.00109346f, 0.00292237f, 
    -0.02243248f, 0.00116194f, -0.02333952f, -0.00371181f, 0.01050360f, 0.02463295f, -0.01776027f, -0.02565981f, 
    0.02016856f, -0.00218906f, -0.02745068f, -0.04024507f, -0.03565789f, -0.00059360f, 0.02314020f, -0.02141725f, 
    -0.00485792f, -0.02641829f, 0.00063736f, 0.00761754f, -0.02679644f, -0.02968414f, 0.02895001f, -0.01827144f, 
    0.00683984f, -0.02807286f, -0.00938652f, 0.01316585f, -0.02749902f, 0.02706807f, -0.02985283f, -0.01749483f, 
    0.01435060f, -0.00678305f, -0.02043108f, 0.01731280f, 0.01585443f, -0.02361560f, -0.00109858f, 0.01669125f, 
    -0.02623988f, 0.02141766f, 0.02055794f, -0.02569032f, -0.00322673f, -0.04114437f, 0.01101281f, -0.01967976f, 
    -0.01065932f, -0.00919908f, -0.04196736f, 0.00232815f, -0.04093582f, -0.02453838f, 0.01307150f, -0.00595281f, 
    -0.01429065f, 0.02902022f, -0.01159853f, -0.03387899f, -0.03987173f, -0.03477536f, 0.00241648f, 0.02664158f, 
    0.02159378f, 0.01946366f, -0.02581421f, 0.00213007f, -0.00949253f, -0.01847692f, -0.01084033f, 0.02748955f, 
    -0.02511746f, 0.01528581f, -0.02706960f, -0.02256273f, 0.00806207f, -0.02388770f, 0.00129829f, -0.01328213f, 
    0.00396276f, -0.01272505f, -0.02219473f, 0.01379007f, -0.02691418f, -0.03566590f, -0.02462157f, 0.02712351f, 
    -0.00168846f, -0.02469821f, 0.00898111f, -0.03516854f, 0.02517133f, -0.02926549f, 0.02470389f, -0.02837496f, 
    -0.00768998f, -0.04238681f, -0.02768196f, 0.00819081f, 0.01497137f, -0.00636041f, 0.02481395f, -0.00256607f, 
    0.02212360f, -0.01474732f, 0.00863302f, -0.01297795f, 0.01189824f, 0.02767846f, 0.02838781f, -0.03975407f, 
    0.00636619f, -0.00882317f, -0.00639351f, -0.00181018f, 0.02290528f, -0.00285595f, 0.01709645f, -0.03272031f, 
    0.01296656f, 0.00093790f, -0.03356295f, -0.00148079f, 0.01403132f, 0.00408511f, -0.02249619f, -0.02407209f, 
    -0.00093126f, 0.02650741f, 0.02451773f, 0.02367609f, -0.03271326f, 0.00179100f, -0.03862717f, 0.00055115f, 
    0.02334661f, -0.03027307f, 0.00069576f, 0.01803822f, -0.03132756f, 0.00152759f, -0.03817530f, 0.02943603f, 
    -0.02357860f, 0.00337457f, -0.00409486f, -0.01098404f, 0.00482564f, 0.01753378f, -0.02538625f, -0.02345296f, 
    -0.03493315f, 0.02861756f, -0.03482382f, 0.01168492f, -0.01688632f, -0.04010263f, 0.02179321f, -0.03127657f, 
    -0.02177884f, 0.02449653f, -0.03666326f, -0.03376186f, -0.01957166f, -0.03733799f, -0.01267518f, -0.01784771f, 
    -0.00240361f, 0.00666371f, -0.00705507f, 0.01744772f, 0.00349348f, -0.04128854f, 0.01969810f, -0.00125024f, 
    0.01672390f, 0.00632140f, 0.00506054f, -0.01525856f, 0.00320716f, -0.03514425f, 0.02896268f, 0.02748043f, 
    0.00041337f, -0.02417026f, 0.00484408f, -0.01009659f, -0.02797609f, -0.00155572f, -0.03806927f, -0.02078499f, 
    -0.02214333f, -0.02581549f, -0.00969460f, 0.00595478f, 0.00663168f, -0.00797690f, -0.04092926f, -0.02756030f, 
    -0.01136726f, -0.01287171f, 0.02855130f, -0.00734652f, -0.03254063f, -0.00569868f, -0.00557994f, 0.00224681f, 
    -0.02078323f, -0.00956145f, 0.01560936f, -0.00489902f, -0.03424930f, 0.02575962f, -0.02372359f, -0.02174082f, 
    -0.00769670f, 0.00941126f, -0.03953361f, -0.03767768f, 0.02965772f, -0.00006019f, -0.04004914f, 0.01988464f, 
    0.00140391f, 0.01706883f, -0.00950806f, -0.01546250f, -0.00322240f, -0.02779149f, -0.00990304f, 0.02071166f, 
    0.00739844f, 0.01451349f, -0.03483896f, 0.01448728f, -0.00173890f, 0.00913337f, 0.02448979f, 0.00589440f, 
    0.01955453f, -0.01575084f, 0.02781282f, 0.01103067f, 0.02321823f, -0.02815824f, 0.00742157f, 0.01102471f, 
    -0.03957124f, 0.01293416f, -0.03174188f, -0.01867174f, 0.02434674f, 0.00532047f, 0.00181805f, -0.00423258f, 
    0.01443767f, 0.02356441f, -0.02645295f, -0.01386301f, 0.00959025f, 0.02486129f, -0.03046370f, -0.01535662f, 
    0.02735836f, 0.02891917f, -0.01478927f, 0.00542032f, 0.02302243f, -0.02217647f, -0.01948624f, 0.01064736f, 
    0.00313880f, -0.00476363f, -0.03178770f, -0.00241157f, -0.03346157f, 0.01488546f, -0.01748266f, 0.01397752f, 
    0.02254586f, -0.00658232f, 0.01068697f, 0.02535687f, 0.00835897f, -0.00065835f, -0.00665256f, 0.01432402f, 
    0.01865357f, -0.00207866f, 0.00070126f, 0.02400188f, -0.00565049f, 0.02251310f, 0.00397139f, 0.00457949f, 
    -0.02867314f, -0.01115174f, -0.00240089f, 0.01368317f, 0.00222189f, 0.00137514f, -0.02489230f, -0.00277250f, 
    -0.02337713f, -0.01587126f, 0.01040741f, -0.03597240f, 0.01300593f, -0.00527244f, 0.02703348f, -0.04160828f, 
    0.01072832f, 0.00415773f, -0.03406920f, -0.03883215f, -0.01373141f, 0.01681235f, -0.02616970f, -0.01970668f, 
    -0.01908518f, 0.00478079f, 0.00012422f, 0.00590724f, -0.02782195f, -0.00354595f, -0.01528045f, 0.00265430f, 
    -0.03338238f, -0.00214701f, -0.03128380f, -0.03916724f, -0.00616831f, 0.01597749f, -0.00565537f, 0.00595601f, 
    -0.02085449f, -0.01652596f, -0.01862519f, -0.03820504f, -0.01614098f, 0.02490663f, -0.01871696f, 0.01155303f, 
    -0.00216089f, 0.02410696f, -0.00870062f, -0.01008312f, 0.01429173f, 0.02281073f, -0.03705319f, -0.03148839f, 
    0.01084592f, -0.00762232f, 0.00334399f, 0.01415303f, -0.04153321f, -0.01685350f, 0.00243213f, 0.02945095f, 
    -0.02582194f, 0.00596142f, 0.02272269f, -0.04266546f, -0.03943637f, -0.02276685f, -0.04230050f, -0.03205731f, 
    -0.03533123f, -0.02690755f, -0.04189898f, 0.02445772f, -0.01077730f, 0.00529199f, -0.00836153f, 0.02764872f, 
    0.00345637f, -0.00658053f, 0.01340938f, -0.02153417f, 0.01191749f, -0.03353516f, -0.02008153f, 0.00288711f, 
    -0.02332043f, -0.03268765f, -0.02048586f, -0.03518561f, 0.00426269f, 0.01229605f, -0.01710413f, -0.04001897f, 
    -0.01727428f, -0.01432799f, -0.01861309f, -0.02123035f, -0.03647022f, -0.03551731f, 0.02788664f, 0.00245715f, 
    -0.03580736f, 0.00822768f, 0.02438576f, 0.00762024f, 0.01112510f, 0.01070168f, 0.00426573f, 0.01492071f, 
    -0.02383549f, 0.02771713f, 0.02522786f, 0.01661676f, -0.02451973f, -0.02594972f, 0.01688907f, -0.00198624f, 
    -0.01352529f, 0.01782873f, -0.00869359f, -0.00209430f, -0.00079652f, 0.00787977f, -0.00722421f, 0.00838787f, 
    -0.03628935f, -0.03119648f, 0.00973055f, -0.01415351f, -0.00611744f, -0.04170431f, -0.00235714f, -0.01051906f, 
    -0.00959097f, 0.00923397f, 0.01470497f, 0.00931404f, -0.01811286f, 0.02804893f, -0.02121752f, -0.01569338f, 
    0.02673410f, 0.02967998f, -0.00453387f, -0.03052665f, -0.03755123f, 0.00906521f, -0.00072584f, -0.02833777f, 
    0.00858048f, -0.03855688f, 0.00307639f, -0.03082516f, 0.01473640f, 0.00467123f, -0.03986422f, -0.01207800f, 
    -0.03153464f, 0.00107847f, -0.03546504f, 0.00659006f, -0.02878849f, -0.00245092f, 0.02849119f, -0.02141629f, 
    -0.02262662f, 0.00788673f, -0.01438067f, -0.02454342f, 0.00866880f, -0.01350693f, -0.03146145f, -0.02420010f, 
    0.01150758f, -0.02439920f, -0.01509966f, 0.02485304f, -0.01750737f, -0.01593021f, 0.02367273f, 0.02755869f, 
    -0.03517759f, 0.00496630f, -0.01991922f, 0.01911120f, -0.03811132f, -0.00115385f, -0.02868281f, -0.03685984f, 
    0.01905419f, -0.03760779f, -0.03008789f, 0.01948372f, -0.01926588f, 0.02787292f, -0.02663363f, 0.02848383f, 
    0.02386803f, -0.00884914f, 0.00790653f, 0.02920103f, -0.02673425f, 0.00761144f, -0.01467266f, 0.02682115f, 
    -0.03047865f, -0.02201108f, -0.04201320f, 0.00443722f, 0.00733525f, -0.02701282f, 0.02692891f, -0.01436806f, 
    -0.02412386f, -0.00980891f, -0.01880521f, 0.00643429f, 0.02103494f, -0.00456017f, -0.02742565f, -0.00192324f, 
    0.00008641f, 0.00979040f, -0.02703149f, -0.04123257f, 0.00526328f, 0.02351828f, -0.00806200f, -0.03379396f, 
    -0.04203887f, -0.03263222f, -0.02043616f, 0.01389834f, 0.02227950f, -0.01994015f, 0.01300545f, -0.00518717f, 
    -0.00907170f, 0.01746364f, -0.00681395f, -0.02683786f, -0.02389179f, -0.02847278f, -0.03768823f, 0.01885936f, 
    0.01358441f, 0.01993816f, -0.03677471f, -0.01411187f, 0.01888818f, -0.03019956f, 0.00251640f, 0.00792556f, 
    -0.02023573f, 0.02402252f, -0.03315514f, 0.00677301f, 0.02656374f, -0.02803522f, -0.02314177f, -0.00000009f, 
    0.01075011f, 0.00982410f, -0.00028025f, 0.01963838f, -0.03220226f, 0.02965139f, -0.02716624f, 0.03075966f, 
    -0.03352037f, 0.00352440f, 0.02793498f, -0.02004399f, 0.00349825f, -0.02424262f, -0.03957110f, 0.00947400f, 
    -0.01671745f, -0.03171548f, -0.02458553f, -0.02595346f, -0.00693154f, -0.00692456f, 0.02530412f, 0.01113063f, 
    0.02491242f, 0.02625579f, -0.02607346f, 0.01079988f, 0.02524932f, -0.00954084f, -0.02243908f, -0.03986225f, 
    -0.03654957f, -0.02682525f, -0.03795546f, -0.04093351f, 0.00848289f, -0.03417462f, -0.02004012f, -0.02843642f, 
    -0.03978684f, -0.02978359f, -0.00288893f, 0.02777555f, -0.02726937f, -0.03668020f, 0.00346886f, 0.00845573f, 
    -0.00088699f, 0.02883253f, 0.00909018f, 0.00720144f, -0.00019197f, -0.02286259f, 0.02208952f, -0.01534534f, 
    0.02118585f, 0.00769502f, -0.01153481f, -0.03052891f, -0.03754135f, -0.00240896f, -0.00457292f, 0.00982106f, 
    -0.04199633f, 0.02369921f, 0.02520574f, -0.01207613f, -0.01738289f, -0.00042948f, 0.01642675f, -0.00578636f, 
    -0.02582357f, -0.00649259f, 0.00196097f, 0.02457934f, 0.02903040f, 0.00567234f, -0.02963464f, 0.00120361f, 
    0.01807959f, 0.01966805f, -0.00837766f, -0.03616841f, -0.02938358f, 0.00574633f, -0.03654406f, 0.00544591f, 
    -0.01293726f, -0.02875195f, -0.03740172f, -0.01446553f, 0.02566731f, 0.01008527f, 0.02611165f, 0.00240928f, 
    -0.03428794f, -0.02545644f, -0.02060602f, 0.00094798f, 0.02482552f, -0.00593465f, -0.01556070f, -0.03354984f, 
    0.00371644f, 0.02795066f, -0.01384759f, -0.00353437f, 0.00887501f, 0.02718011f, 0.01170857f, 0.02230581f, 
    0.00373023f, 0.03050227f, -0.01663902f, -0.03713297f, 0.00773061f, 0.01402390f, -0.00769500f, -0.01840712f, 
    -0.02102498f, -0.00523295f, -0.01979524f, 0.02965484f, -0.02667995f, -0.02954337f, 0.02054709f, -0.01505466f, 
    -0.00137575f, -0.01642105f, -0.00954800f, -0.02528673f, -0.02977398f, -0.03262619f, 0.02836761f, 0.01413795f, 
    -0.03373003f, 0.00091561f, -0.01546692f, -0.00641955f, 0.00919735f, -0.02547849f, 0.02484869f, -0.00697494f, 
    -0.01521015f, -0.01155570f, -0.00758342f, -0.03779865f, -0.03081859f, 0.01175317f, -0.04078613f, 0.01996599f, 
    0.00104833f, -0.02212669f, -0.03026171f, 0.00810086f, -0.00563487f, -0.02096556f, 0.01625567f, 0.01195920f, 
    -0.02850289f, 0.00867479f, 0.02955638f, -0.00743269f, 0.00628187f, -0.02284832f, 0.01729047f, -0.01103773f, 
    -0.03305515f, 0.01331653f, -0.01749850f, -0.02696742f, -0.03533669f, 0.00829293f, 0.00593410f, -0.02588977f, 
    -0.01906549f, -0.03178777f, -0.01462881f, 0.02175940f, 0.01899715f, -0.00673093f, -0.03132899f, 0.00537064f, 
    0.00460633f, -0.01858315f, -0.03860065f, 0.00020352f, 0.01399294f, -0.03760767f, -0.00116491f, -0.03257548f, 
    -0.00897920f, -0.02364758f, -0.01105412f, -0.01898480f, -0.03834170f, -0.03515554f, -0.03471459f, -0.00060322f, 
    0.00899604f, -0.01870197f, -0.03374539f, 0.02634016f, -0.00027072f, -0.02059619f, -0.02792161f, -0.00530320f, 
    0.01914574f, -0.02127673f, 0.02249829f, 0.01233932f, 0.00944451f, 0.00255433f, 0.00733910f, -0.01573155f, 
    -0.02311172f, 0.00058702f, -0.00090087f, -0.00701666f, 0.00595666f, 0.01964074f, -0.00428951f, -0.02333661f, 
    0.01481275f, 0.01156703f, -0.00925951f, -0.00117675f, -0.03837068f, -0.00720114f, 0.01608580f, 0.02678371f, 
    -0.01085487f, -0.00469698f, 0.02392893f, 0.02177100f, 0.01400657f, 0.00669908f, -0.03634245f, 0.02844175f, 
    -0.00885179f, 0.01855346f, -0.02345095f, 0.00019553f, -0.01343575f, 0.02020571f, -0.02740649f, 0.02705320f, 
    -0.02374385f, 0.01242082f, -0.01186066f, 0.02166963f, 0.02141980f, 0.00080951f, 0.02558627f, -0.03883117f, 
    -0.03443379f, 0.02386437f, 0.01709757f, -0.03751719f, -0.03680835f, 0.01496697f, -0.03473509f, 0.01231422f, 
    -0.03116179f, -0.01584199f, 0.02533351f, 0.00161922f, -0.02523167f, -0.01899886f, -0.02958485f, -0.02949569f, 
    -0.01794185f, -0.02616517f, -0.01794969f, -0.00697907f, -0.00447723f, -0.02947940f, 0.00333989f, 0.01048700f, 
    -0.02692810f, 0.01266666f, -0.03566825f, -0.01339128f, -0.03942122f, -0.00952310f, 0.00660467f, -0.03730567f, 
    0.02223941f, 0.01601818f, -0.00807916f, -0.03815152f, 0.00192084f, -0.01908845f, -0.03459451f, -0.03346645f, 
    0.02144103f, 0.00305999f, 0.01739513f, 0.01663313f, 0.00946046f, 0.02538154f, -0.00977077f, 0.02419496f, 
    -0.01212811f, -0.01280945f, -0.01749072f, 0.02337349f, 0.00228256f, 0.00496580f, -0.01676588f, 0.01671978f, 
    -0.03575410f, -0.02358605f, 0.01462884f, -0.01961040f, -0.01004801f, 0.00230713f, 0.00655011f, -0.03133777f, 
    0.00991450f, 0.01442505f, 0.03007638f, -0.01173070f, 0.01627835f, 0.01669772f, -0.03535463f, -0.03685930f, 
    -0.01444922f, -0.00008522f, 0.00685745f, -0.04078678f, -0.03943917f, 0.02885926f, 0.01276736f, -0.01230570f, 
    0.02880612f, 0.00588306f, -0.02023325f, 0.01213861f, 0.00206035f, -0.03909910f, -0.01671733f, -0.00938249f, 
    0.00336537f, 0.00359258f, -0.00745612f, 0.02085545f, 0.01270005f, -0.02444888f, -0.02144777f, 0.00786558f, 
    -0.02277512f, 0.02850525f, -0.03920830f, 0.01203579f, 0.02794988f, 0.00936194f, -0.00689522f, 0.01654637f, 
    -0.00475342f, 0.03331199f, 0.00206004f, -0.03743215f, -0.02990364f, 0.00591402f, -0.02078116f, -0.00167882f, 
    0.02779663f, 0.01415062f, -0.01027958f, -0.01461621f, -0.02323670f, -0.03171276f, 0.01879304f, 0.00294064f, 
    -0.01662260f, 0.02802939f, 0.00227582f, 0.00200465f, -0.00633053f, 0.02007144f, -0.02871283f, 0.00292826f, 
    0.03319489f, 0.03244269f, -0.02367856f, 0.01598603f, 0.01795141f, 0.02619159f, -0.03870188f, -0.02625980f, 
    -0.02902613f, -0.00303070f, -0.01486129f, -0.03363455f, 0.02995576f, 0.01250371f, 0.02622630f, -0.00520382f, 
    -0.00213894f, 0.01616150f, 0.02536722f, -0.02476959f, -0.02641351f, 0.00465394f, -0.01319442f, 0.02410014f, 
    0.01973216f, -0.03886016f, -0.03379035f, -0.02818237f, -0.01417561f, -0.00620312f, 0.01841500f, 0.02223121f, 
    0.00864112f, -0.01905331f, -0.03256639f, -0.04154515f, -0.02261643f, -0.03707535f, 0.02103530f, -0.02614729f, 
    0.01375255f, -0.01907958f, -0.03128933f, -0.00213308f, -0.01186829f, -0.00945412f, 0.01206984f, -0.03628434f, 
    -0.02340325f, -0.00071895f, -0.04168554f, 0.02972815f, 0.03084121f, 0.01113419f, 0.02136666f, 0.00369861f, 
    -0.00457059f, 0.02178002f, -0.01800746f, -0.00707124f, -0.01655614f, -0.03556936f, 0.02373878f, 0.02708495f, 
    0.02365528f, -0.02030698f, 0.02107046f, 0.01289433f, 0.02685013f, -0.03764069f, -0.02371253f, 0.00526879f, 
    -0.02899147f, -0.03747835f, -0.03411295f, -0.00639787f, -0.02587566f, -0.03550190f, -0.01778937f, -0.03899428f, 
    -0.00881977f, -0.01072203f, -0.00023039f, 0.02194160f, -0.02269281f, -0.03945282f, 0.02743869f, 0.02863782f, 
    -0.01097947f, -0.02412859f, -0.00279075f, -0.01743756f, -0.02469024f, -0.03787763f, 0.01868387f, -0.02017217f, 
    -0.03820845f, -0.02932870f, -0.04055464f, 0.01338907f, 0.02381851f, -0.02529267f, 0.02213710f, 0.01672031f, 
    0.00328504f, -0.00451188f, -0.00545167f, 0.02160754f, 0.01917637f, -0.03853817f, 0.00800082f, 0.02172192f, 
    -0.01586249f, -0.02495098f, -0.00865185f, -0.03934762f, -0.00422785f, 0.02373115f, 0.01528451f, -0.03759966f, 
    0.02779166f, 0.01728424f, 0.00756008f, -0.03945535f, -0.03968229f, -0.00398029f, -0.00118710f, 0.00574133f, 
    0.02631889f, 0.01969763f, 0.01257939f, 0.00932378f, -0.03081066f, 0.00199035f, -0.03343560f, -0.04102136f, 
    -0.01860564f, 0.02458168f, 0.00199681f, 0.01772531f, -0.03419466f, -0.01003679f, -0.01404802f, 0.02318122f, 
    -0.00538340f, 0.02010187f, -0.03573143f, 0.02398857f, 0.00665832f, -0.02737689f, -0.00375273f, 0.02820718f, 
    -0.03040563f, 0.00385382f, 0.00859820f, -0.01231337f, 0.02234577f, 0.00014901f, -0.01723141f, -0.03684419f, 
    -0.04094217f, -0.00955944f, -0.03337764f, -0.00253450f, -0.03880518f, -0.00699410f, -0.00927596f, -0.00728744f, 
    -0.02560577f, 0.00707940f, 0.02758526f, 0.00562606f, 0.00114892f, 0.00867289f, 0.03046460f, -0.02410158f, 
    -0.03336244f, -0.01705608f, 0.00663888f, 0.01891498f, -0.02907590f, -0.00733584f, 0.01998194f, 0.02339844f, 
    -0.00445722f, -0.03778493f, -0.03554318f, -0.01781444f, -0.01505505f, 0.02577815f, 0.00742625f, -0.01659220f, 
    0.00658372f, -0.00869739f, -0.01186546f, -0.02779588f, 0.02995710f, -0.02540887f, 0.01685115f, -0.01421296f, 
    -0.03858231f, 0.01559089f, -0.00858517f, -0.00016408f, 0.01549621f, 0.00267313f, -0.03847685f, 0.01077317f, 
    0.02086421f, -0.01947522f, -0.02125553f, -0.02208363f, -0.03597508f, 0.00672906f, 0.02355002f, -0.03277393f, 
    0.02422759f, 0.01821013f, 0.00835962f, -0.02115546f, 0.00439024f, -0.01335855f, 0.01458944f, 0.00269917f, 
    -0.03535770f, -0.03321206f, 0.02960111f, 0.01982413f, 0.01065211f, -0.01767137f, -0.02278351f, -0.01330630f, 
    -0.02391793f, 0.02195761f, 0.02950633f, -0.01575803f, -0.02526661f, 0.00580710f, 0.02425045f, 0.02219256f, 
    0.02468000f, 0.01856147f, 0.00606664f, -0.01744028f, 0.02186932f, 0.02965194f, -0.02186000f, -0.03636966f, 
    -0.02827180f, -0.02014033f, -0.02649494f, 0.01501998f, -0.03197703f, -0.03746677f, 0.00787190f, 0.02133012f, 
    0.00658751f, 0.02908395f, 0.01820350f, 0.02423398f, 0.02102274f, 0.02148690f, 0.02519781f, -0.00458777f, 
    -0.00108261f, 0.01712887f, -0.03487696f, -0.00656152f, 0.02729240f, -0.02905137f, -0.00539003f, 0.00455348f, 
    -0.03585892f, 0.01191256f, -0.03938908f, -0.01406645f, 0.00083803f, 0.01169228f, -0.03063661f, -0.01026345f, 
    -0.01994465f, -0.02558313f, -0.03772586f, -0.03699454f, 0.00834756f, 0.00716242f, -0.01491684f, 0.02153075f, 
    0.02247890f, -0.03197392f, -0.03452113f, -0.03907111f, -0.02186759f, -0.01247526f, 0.00891809f, -0.02403758f, 
    0.01241271f, -0.02057227f, -0.00908550f, -0.00493726f, 0.01360165f, 0.03590241f, -0.00094693f, 0.01950402f, 
    0.03126395f, -0.00093383f, 0.01498642f, 0.01533946f, -0.02281729f, -0.03746540f, 0.00640284f, 0.01040156f, 
    -0.02806176f, 0.01611109f, -0.00694799f, -0.01590125f, -0.02493683f, -0.03611924f, -0.02839248f, -0.02349538f, 
    -0.01005610f, 0.00910132f, -0.03033173f, 0.01616473f, -0.02563161f, -0.00114667f, 0.00740527f, 0.02427558f, 
    -0.02907132f, -0.01911926f, -0.00160142f, -0.01627039f, -0.00171204f, -0.01083216f, -0.02022897f, 0.02360464f, 
    -0.03986094f, -0.03364275f, 0.00148603f, -0.04021417f, 0.00124719f, -0.00087848f, -0.00998511f, 0.00707861f, 
    0.00251048f, 0.03120248f, 0.02643482f, -0.03459301f, 0.01027525f, 0.01750894f, 0.02425512f, 0.01795566f, 
    0.01604553f, -0.00443636f, 0.00056707f, -0.01452049f, -0.03590138f, 0.01913258f, 0.00264054f, 0.01448305f, 
    -0.02646025f, -0.03428848f, 0.01236938f, 0.00683991f, -0.03335182f, -0.02358174f, -0.02119465f, -0.00153612f, 
    -0.02381059f, -0.01554009f, -0.03821686f, -0.04139015f, -0.03024576f, -0.03010950f, -0.00299052f, -0.02372354f, 
    -0.01419240f, -0.01487548f, -0.02703913f, 0.01018836f, -0.03112730f, 0.00226599f, 0.00173401f, -0.04176939f, 
    -0.03854910f, -0.01981944f, -0.02703755f, -0.00774287f, -0.02050406f, 0.02323258f, 0.01055423f, -0.02717037f, 
    -0.01096202f, 0.00959138f, -0.02817475f, 0.01822128f, -0.01476893f, -0.03852915f, 0.02782146f, -0.02244573f, 
    0.02593868f, 0.02613943f, -0.01471865f, -0.03318921f, -0.03795655f, -0.03797964f, -0.00213107f, -0.02339729f, 
    -0.00843346f, 0.01593040f, 0.01274294f, 0.01034730f, -0.02767575f, -0.00338129f, 0.01157524f, -0.04009397f, 
    0.02308606f, 0.01151571f, -0.03121803f, -0.03168156f, -0.02312826f, -0.03062357f, -0.04075419f, -0.00154557f, 
    0.00223418f, -0.00634047f, -0.01496143f, -0.00851165f, 0.00899568f, 0.00145620f, 0.01665901f, -0.03220526f, 
    -0.01001305f, -0.01331920f, 0.00038897f, 0.00085532f, -0.02379477f, -0.01110352f, -0.02874317f, 0.02648465f, 
    -0.02572280f, -0.01144510f, 0.00956023f, -0.02471954f, 0.02996945f, 0.00589617f, 0.01003068f, -0.04014232f, 
    -0.02902389f, 0.01531172f, 0.00256346f, -0.02099937f, 0.02948864f, 0.00191527f, -0.02901473f, 0.01040416f, 
    0.02392342f, -0.01016474f, -0.03716631f, -0.00952992f, 0.02506660f, 0.02820246f, 0.01628853f, -0.01684348f, 
    -0.00697906f, -0.02555184f, -0.03304224f, -0.01265781f, -0.02641951f, -0.02635173f, 0.00478459f, -0.01042433f, 
    -0.00983974f, 0.00783930f, -0.02265896f, -0.00428219f, -0.00878608f, -0.03761852f, 0.02880047f, -0.02740673f, 
    -0.02231262f, -0.02925725f, 0.00188042f, 0.02461733f, -0.01505229f, -0.01239204f, -0.01048575f, -0.00006741f, 
    0.02190928f, -0.03577948f, -0.01628941f, -0.04110105f, -0.03581190f, 0.02834575f, -0.03832453f, 0.02150648f, 
    -0.01585580f, 0.01965260f, 0.02415237f, 0.00269548f, -0.03500279f, 0.00256795f, -0.01650193f, 0.00786912f, 
    -0.02397667f, -0.00221474f, -0.04031085f, 0.01795778f, -0.00802018f, -0.03887657f, 0.01311377f, 0.01981638f, 
    -0.03365941f, -0.01166542f, -0.00722732f, 0.00308608f, -0.02814954f, 0.02919985f, 0.01966067f, 0.02559475f, 
    0.01014175f, 0.02690426f, 0.02043679f, -0.02613372f, 0.00154305f, -0.03389475f, -0.02213489f, -0.00577746f, 
    -0.02027812f, 0.02490111f, 0.01905238f, -0.03315620f, -0.00687322f, 0.01688158f, 0.02027326f, -0.03056866f, 
    0.02692671f, -0.01504170f, 0.02408138f, 0.00806510f, -0.01679932f, -0.00421549f, -0.01672272f, -0.03840454f, 
    -0.01925865f, -0.01311297f, 0.02183272f, -0.00904306f, -0.00108372f, -0.01344381f, 0.02502280f, -0.03669202f, 
    0.01688694f, -0.00154449f, -0.02387824f, -0.03515043f, -0.00789210f, -0.03352053f, 0.02961265f, 0.00787727f, 
    -0.01697074f, 0.00229240f, -0.00683953f, 0.02028032f, -0.00045798f, -0.00548701f, -0.01693469f, 0.00597109f, 
    0.01390433f, -0.00006017f, -0.00466842f, -0.03574433f, -0.02110912f, -0.01039553f, 0.00809685f, -0.02778087f, 
    0.00516591f, -0.02190799f, -0.03657360f, 0.00588639f, 0.00324070f, 0.00927080f, -0.02621048f, 0.02138255f, 
    0.01275591f, 0.01997632f, -0.01204410f, -0.01695346f, 0.00478466f, -0.00011800f, -0.01739519f, 0.01123382f, 
    -0.02220145f, -0.01937716f, -0.02948238f, 0.02598201f, 0.00897511f, -0.01566833f, -0.01502676f, 0.02234687f, 
    0.00398148f, -0.03679781f, 0.02068333f, 0.00806163f, -0.01665415f, -0.00678817f, -0.01007345f, -0.02911146f, 
    0.01950670f, -0.02997439f, -0.03878800f, -0.02984062f, -0.04154101f, -0.02997536f, -0.01122329f, 0.01394939f, 
    0.02148129f, -0.01102674f, -0.00107347f, -0.03008142f, -0.01864302f, -0.02837605f, 0.02925310f, 0.00217233f, 
    0.01315372f, 0.00197874f, -0.00148762f, 0.01144268f, -0.00902828f, -0.03770337f, -0.02535854f, 0.02285402f, 
    0.00144860f, -0.02243209f, 0.02998836f, 0.02694020f, -0.03348248f, -0.01026792f, -0.01802708f, -0.02819407f, 
    -0.01266838f, -0.03619514f, -0.02930627f, -0.00171851f, 0.01956530f, -0.03366280f, 0.02069720f, 0.01534098f, 
    -0.01405458f, -0.00044812f, 0.02060240f, 0.02996643f, -0.03529783f, 0.02011263f, 0.00094973f, 0.01909961f, 
    -0.04154551f, -0.02073930f, 0.02037267f, -0.00540106f, 0.02660340f, -0.02965367f, -0.01872986f, -0.03100516f, 
    -0.00143988f, 0.00405590f, -0.02021618f, 0.02153576f, 0.01089643f, 0.02023416f, 0.00863471f, 0.02468965f, 
    -0.01193329f, 0.00588568f, -0.00198566f, 0.00722043f, -0.01567467f, 0.02902379f, 0.01082544f, -0.00869277f, 
    -0.01971243f, -0.03567099f, 0.02927535f, -0.01762943f, -0.02921706f, -0.01573953f, 0.00398449f, -0.00127689f, 
    -0.02772937f, -0.00747043f, 0.00046423f, -0.02456560f, -0.02342688f, 0.01596612f, -0.03315474f, 0.00809147f, 
    -0.03833003f, -0.01384732f, -0.02749029f, 0.02772849f, -0.01230000f, -0.02476357f, 0.01186540f, 0.00295913f, 
    0.02511740f, -0.00829306f, 0.01639183f, -0.01569909f, 0.01248602f, -0.01169096f, -0.00005378f, 0.02247965f, 
    0.00453051f, 0.00995500f, -0.01086218f, -0.01290565f, 0.00897669f, -0.01067245f, -0.00344041f, 0.01498130f, 
    0.02062542f, -0.02060040f, 0.00938980f, 0.01873782f, 0.01047098f, 0.01570195f, -0.01930268f, -0.03024603f, 
    -0.01504503f, -0.03470255f, -0.01229589f, 0.01682887f, -0.02720645f, -0.02147499f, -0.03099957f, 0.02639314f, 
    -0.03865430f, -0.02500281f, -0.03574650f, -0.01770345f, -0.00433877f, -0.03758855f, -0.02483676f, -0.00521756f, 
    -0.01953784f, 0.02548636f, -0.00115939f, -0.00472181f, -0.03064689f, 0.00515655f, -0.00488880f, -0.00842105f, 
    -0.00024845f, 0.00092735f, -0.03397335f, -0.03123084f, -0.01731269f, -0.03865649f, -0.01369764f, 0.01177815f, 
    -0.01269499f, -0.02708948f, -0.03651858f, -0.04173901f, -0.03965930f, -0.03920432f, 0.01075415f, 0.00516958f, 
    -0.01961130f, -0.03989503f, -0.01063686f, 0.01089843f, -0.02718193f, -0.01468796f, 0.02995525f, -0.02951246f, 
    0.01149458f, 0.01159674f, -0.00301982f, -0.01644198f, -0.00270791f, 0.02595792f, 0.02822504f, 0.00380710f, 
    0.01647357f, -0.03843566f, -0.00332464f, 0.00935492f, -0.02196409f, 0.01322980f, -0.00143559f, -0.01734958f, 
    -0.00342478f, -0.03650286f, -0.01077169f, 0.00695470f, -0.01301910f, 0.00270883f, -0.00976382f, 0.01310761f, 
    -0.02974578f, 0.00383155f, 0.02364012f, -0.01377979f, -0.03610209f, -0.02559718f, -0.00888236f, -0.00649476f, 
    0.00905549f, -0.02667560f, -0.00014801f, -0.04019449f, -0.03170798f, -0.01990275f, -0.00604790f, 0.02566965f, 
    -0.02419927f, -0.03259744f, -0.03890783f, -0.01968881f, -0.03226064f, 0.02400737f, -0.01590654f, 0.02076744f, 
    -0.02881188f, 0.02460488f, -0.00032010f, -0.03320522f, 0.01381591f, 0.00409622f, 0.00297950f, 0.00012777f, 
    -0.01207693f, -0.00415198f, 0.01805663f, -0.01440154f, -0.04047513f, -0.00742894f, -0.03510877f, 0.02353725f, 
    -0.00668822f, 0.01267737f, -0.02430224f, -0.03179918f, 0.02217183f, -0.03138597f, -0.03945006f, -0.03319618f, 
    0.02670821f, 0.00521646f, 0.02031796f, -0.00602676f, -0.00120152f, -0.02216512f, 0.02682505f, 0.01957341f, 
    -0.01236314f, -0.02728133f, -0.00889497f, 0.00785093f, -0.03338983f, -0.01143622f, -0.02815509f, -0.00295234f, 
    0.01061335f, -0.00704543f, 0.02695317f, 0.00638040f, 0.01781775f, 0.02620579f, -0.01204854f, -0.00007742f, 
    0.02097565f, -0.01678212f, -0.03660008f, -0.03820923f, -0.00123534f, -0.01636542f, -0.00623788f, -0.04054116f, 
    -0.02320576f, -0.03824148f, -0.02289795f, -0.01705484f, 0.02524351f, -0.02829365f, 0.02642461f, -0.01571904f, 
    -0.03999674f, -0.03326135f, -0.01874310f, 0.00617012f, 0.01349384f, -0.00582461f, -0.02452227f, 0.02879510f, 
    0.01789130f, 0.00067115f, -0.01995291f, -0.00910149f, 0.00272210f, -0.01447233f, -0.00711016f, -0.03356667f, 
    0.02719249f, 0.00291488f, -0.00065092f, 0.01228276f, -0.00833604f, 0.02799115f, 0.01709029f, 0.01480811f, 
    0.02073929f, 0.01261289f, -0.01609569f, -0.03742130f, 0.00102900f, -0.02497523f, -0.01979605f, 0.02376126f, 
    0.01878454f, -0.00464788f, 0.02251820f, 0.01269137f, -0.01087440f, -0.03837919f, -0.02049488f, -0.01008897f, 
    -0.01901728f, -0.00001983f, 0.00555055f, -0.02163519f, 0.01404660f, -0.00581403f, 0.01289019f, 0.01743566f, 
    0.02812299f, -0.02588557f, 0.01923473f, -0.01555334f, -0.03488110f, -0.00913477f, 0.02012686f, 0.02371559f, 
    -0.01913756f, -0.02228911f, -0.02850187f, 0.00126972f, 0.01729321f, -0.02408886f, -0.02290433f, -0.01154454f, 
    0.00876801f, -0.00873743f, -0.01730622f, -0.00291584f, -0.01917071f, -0.03594027f, -0.01952014f, -0.01273388f, 
    0.01299789f, 0.01507645f, -0.01108601f, -0.02566616f, 0.00440371f, -0.01323902f, -0.03108502f, 0.00134650f, 
    0.00261002f, -0.01028821f, 0.00536358f, 0.01963826f, 0.00485524f, -0.02011173f, -0.00278112f, 0.01838474f, 
    -0.00984172f, -0.01750688f, -0.00440574f, -0.02887747f, -0.01738551f, 0.02096421f, -0.02957609f, -0.03218472f, 
    0.02651859f, -0.00037811f, 0.00700807f, -0.00962735f, -0.01139543f, -0.01569603f, -0.03775672f, 0.00319405f, 
    -0.03820881f, 0.01312404f, -0.03846119f, -0.02669077f, 0.00127509f, -0.00984763f, -0.02553509f, 0.01331259f, 
    0.02448388f, -0.00026528f, 0.00228420f, 0.02816659f, 0.00571087f, -0.03465503f, 0.01002201f, -0.01621774f, 
    -0.03900432f, 0.00699240f, -0.03085118f, -0.00566398f, 0.02597488f, -0.03988589f, 0.01223013f, -0.00312517f, 
    -0.00994936f, -0.03986046f, -0.00867136f, -0.03385496f, -0.00869536f, -0.01421818f, -0.03517615f, -0.03261418f, 
    -0.01692564f, -0.04126868f, -0.03111068f, 0.02270643f, 0.01527465f, -0.03267096f, -0.00690915f, -0.01554941f, 
    -0.04026359f, 0.02881440f, -0.01627438f, 0.00478996f, -0.02635991f, -0.00938574f, -0.01636582f, -0.00927827f, 
    0.01712516f, -0.03209484f, -0.02064167f, 0.02632498f, 0.02298940f, 0.02733982f, 0.00117045f, -0.01750605f, 
    0.01262269f, -0.03068030f, -0.03750635f, -0.00894728f, 0.01833258f, 0.01294578f, -0.01978589f, 0.02811963f, 
    0.02096250f, -0.00643919f, 0.00268238f, -0.01837515f, -0.01947571f, -0.00038195f, 0.00068147f, -0.00104038f, 
    -0.03511651f, -0.00816410f, 0.02118053f, 0.01530726f, 0.01540673f, 0.00768395f, 0.00300023f, -0.00327121f, 
    -0.00459790f, 0.02368357f, -0.03406810f, -0.01166847f, 0.02381655f, -0.01494443f, 0.01138006f, -0.00200669f, 
    0.01850300f, 0.01880757f, -0.00607092f, -0.00074448f, 0.00994218f, 0.00570981f, -0.02662979f, -0.03397244f, 
    0.02526202f, 0.02177680f, 0.02588245f, -0.00255356f, 0.02560106f, -0.03172138f, 0.00272858f, 0.00158194f, 
    0.00716922f, -0.02731139f, -0.04020796f, 0.00771681f, 0.00352281f, 0.02442049f, 0.01805117f, 0.02344556f, 
    -0.00508240f, -0.00273176f, -0.03926832f, 0.01277065f, -0.04070935f, -0.02541764f, 0.02717523f, -0.01297388f, 
    -0.01421613f, -0.03368528f, -0.02772898f, 0.01526628f, -0.03362371f, 0.00564516f, -0.00919022f, 0.00184924f, 
    -0.03570930f, 0.00827678f, 0.02224574f, -0.01102046f, 0.00586715f, -0.03856886f, 0.02168944f, 0.02789967f, 
    0.01113158f, -0.00725528f, 0.03131409f, 0.00847583f, -0.01265957f, -0.01532607f, -0.01775402f, -0.03582885f, 
    -0.02052263f, -0.03730508f, -0.01384040f, -0.01572460f, 0.02402713f, -0.03367873f, -0.02052470f, 0.00327074f, 
    -0.02311158f, 0.01939371f, -0.01490001f, 0.02742352f, -0.00063060f, 0.02377779f, 0.02439526f, -0.02135310f, 
    -0.01493950f, -0.01703927f, 0.03377837f, -0.02295416f, -0.03436331f, 0.00813826f, -0.00917260f, -0.03079244f, 
    -0.04143028f, -0.03814229f, -0.01904107f, -0.04120352f, -0.03039588f, 0.00649136f, -0.03209776f, 0.02798452f, 
    -0.02628565f, 0.03109599f, 0.01327206f, -0.02473099f, 0.03870160f, 0.03211240f, -0.00017344f, -0.00797542f, 
    -0.03187743f, -0.02887962f, 0.02509020f, 0.02200186f, -0.02310171f, -0.00749696f, 0.02954976f, 0.02681106f, 
    -0.02227118f, -0.01566307f, 0.01012378f, -0.02567567f, 0.01041507f, -0.02170845f, 0.00197247f, 0.01419919f, 
    -0.01100131f, 0.00866916f, 0.00932225f, 0.00141419f, 0.01120657f, 0.00994863f, -0.01262355f, -0.03656224f, 
    -0.01356637f, -0.02156827f, 0.00057380f, 0.02914919f, 0.00326865f, -0.01561792f, -0.01258650f, -0.01805214f, 
    0.01177200f, 0.02781114f, -0.03180300f, 0.01476968f, 0.03007340f, 0.01120858f, -0.00819886f, 0.01069979f, 
    -0.02093754f, 0.01915923f, 0.02737927f, -0.02819562f, 0.03064574f, -0.03217154f, 0.01572220f, 0.00877110f, 
    0.02353223f, -0.02680449f, 0.01089655f, -0.03439265f, -0.02805673f, -0.01598151f, -0.03467553f, -0.00980082f, 
    -0.02322655f, -0.01559612f, -0.00473050f, -0.01218997f, 0.02095649f, 0.01121444f, 0.02081843f, 0.00779054f, 
    -0.02919108f, 0.00951218f, -0.00241098f, 0.00155771f, -0.02194704f, 0.02593163f, -0.03767724f, 0.01950438f, 
    -0.02015437f, -0.03139264f, -0.02479258f, 0.02988601f, 0.03154235f, -0.01166693f, -0.02300296f, 0.00336657f, 
    0.00998490f, 0.00605616f, -0.01137526f, 0.02107125f, 0.03475494f, -0.00802350f, -0.01276674f, -0.02395048f, 
    -0.00463581f, -0.01160379f, 0.01834142f, -0.01206199f, 0.01214931f, -0.02038255f, -0.03723556f, 0.00311243f, 
    -0.01421676f, 0.01377947f, -0.00984739f, -0.02130289f, -0.00469016f, -0.02724952f, 0.01606248f, -0.00738037f, 
    -0.02831392f, -0.01693716f, -0.01809025f, -0.03062580f, -0.02214787f, 0.03343164f, 0.01258574f, -0.00184097f, 
    -0.01567066f, -0.03100039f, 0.02081704f, 0.01724244f, -0.02079008f, 0.01429012f, 0.02711726f, 0.01968686f, 
    -0.01851954f, 0.03132555f, -0.03568703f, 0.02596488f, -0.04119686f, -0.00137960f, 0.02622380f, -0.01917226f, 
    0.02701321f, 0.02368479f, 0.00663869f, -0.02643966f, 0.01418717f, -0.02717614f, 0.01423194f, -0.00107653f, 
    -0.00995964f, -0.02772062f, -0.02208258f, -0.02710639f, 0.00948609f, -0.04454814f, -0.03077879f, 0.02328451f, 
    -0.00321509f, -0.01235266f, 0.03397889f, -0.02499202f, -0.00226955f, -0.01632498f, -0.00973943f, -0.01374896f, 
    -0.00895711f, -0.01752859f, -0.02077083f, -0.04489855f, 0.00496062f, -0.02963488f, -0.01126906f, -0.02101800f, 
    0.02053335f, -0.02199150f, 0.00771462f, -0.00211233f, -0.00767489f, 0.02152872f, 0.01861411f, -0.01824336f, 
    0.00861012f, 0.00464904f, -0.01412028f, 0.00575890f, 0.01629413f, 0.00303897f, -0.02891498f, -0.00799182f, 
    0.01939779f, -0.01091887f, -0.03391004f, -0.01355272f, -0.00786591f, -0.01991157f, 0.03236632f, -0.00676686f, 
    0.02381634f, 0.01545479f, 0.00339683f, -0.03408807f, -0.04349736f, -0.01861685f, 0.02503690f, 0.00085115f, 
    0.02419203f, -0.02787736f, 0.00602771f, -0.02481147f, 0.00215150f, -0.01661165f, 0.03022260f, -0.00693191f, 
    -0.01053180f, 0.03285546f, 0.01477908f, 0.01354258f, 0.03655766f, 0.00204648f, -0.04079425f, -0.00282526f, 
    0.02789388f, -0.00767919f, 0.00067456f, 0.00123914f, -0.03803408f, 0.00903972f, -0.00877804f, -0.01033928f, 
    0.00090593f, -0.01466000f, -0.00711717f, -0.01297653f, -0.02440514f, 0.02498511f, 0.01148652f, -0.03077697f, 
    -0.01266655f, -0.00893265f, 0.02445725f, -0.00654339f, 0.01028255f, -0.02830650f, 0.02910572f, -0.02784663f, 
    0.01025243f, -0.00125773f, 0.01592446f, 0.00997917f, -0.02841820f, 0.01878827f, 0.01273259f, -0.04069596f, 
    0.00644293f, -0.02717843f, -0.01002088f, -0.02305773f, 0.00855846f, -0.00213018f, 0.03540171f, 0.00268156f, 
    0.00348084f, -0.04060486f, -0.03071462f, -0.01718470f, 0.00763502f, -0.03469849f, -0.01859480f, -0.03892013f, 
    0.01398453f, 0.01755294f, 0.00280148f, -0.03141608f, -0.01098499f, -0.00663692f, 0.00899523f, 0.02036387f, 
    -0.02771218f, 0.00441067f, 0.02044848f, -0.03208432f, 0.03181670f, -0.02876766f, 0.01079603f, 0.02674394f, 
    0.03283157f, 0.01702255f, -0.03057726f, -0.03091427f, 0.01423624f, -0.00729632f, -0.03163582f, 0.02590331f, 
    -0.00397857f, -0.02582373f, 0.02032427f, 0.03004856f, 0.01977020f, 0.00221763f, -0.02092639f, -0.00024267f, 
    -0.00613315f, -0.00027632f, 0.02532310f, -0.00890809f, 0.02929991f, 0.03485620f, -0.03101801f, -0.01846427f, 
    0.03501449f, -0.01842962f, -0.01186990f, 0.02470655f, -0.03119057f, -0.03191485f, -0.00300025f, -0.01807903f, 
    0.02721457f, 0.02816581f, 0.02108579f, 0.02260500f, -0.00116752f, 0.01645224f, 0.00057202f, 0.00805498f, 
    0.02944662f, 0.01876039f, 0.01748379f, 0.03486343f, 0.01733812f, -0.02341113f, -0.01233059f, 0.00508633f, 
    -0.02021310f, -0.02282794f, -0.02298875f, 0.02889837f, -0.03715023f, 0.01235524f, 0.01272576f, -0.02965786f, 
    0.00850279f, -0.04114716f, -0.01463243f, -0.00824524f, 0.02617743f, -0.01229344f, 0.00565841f, -0.00502711f, 
    0.02293723f, -0.00313748f, -0.01658920f, -0.01959536f, -0.00516613f, 0.02177360f, -0.00166424f, -0.00331723f, 
    0.01462975f, -0.04033460f, -0.01927965f, -0.02473419f, 0.03163294f, 0.00115090f, 0.03215477f, -0.02843155f, 
    0.01451686f, -0.03691284f, 0.02428686f, -0.02069695f, 0.00482753f, -0.00593477f, 0.02451247f, -0.03905921f, 
    -0.03754369f, 0.01720124f, 0.00232912f, 0.00049889f, 0.00757924f, -0.03768563f, -0.01558530f, -0.02188867f, 
    0.02301558f, -0.02025353f, -0.03749613f, -0.02846482f, -0.00364002f, 0.01723366f, -0.00302232f, -0.03349585f, 
    -0.00582064f, -0.02541850f, 0.00993526f, 0.01971035f, -0.03458519f, -0.03400913f, -0.04562235f, -0.03863097f, 
    -0.03436440f, 0.02974444f, 0.03034537f, -0.04155356f, -0.03544593f, 0.00745801f, -0.01196593f, -0.03125121f, 
    -0.00721247f, 0.02112442f, -0.01717196f, 0.00062620f, -0.02816192f, -0.01162417f, -0.03068450f, 0.01436934f, 
    0.00079718f, 0.03342558f, -0.01992598f, -0.01136363f, -0.01815387f, 0.01134197f, -0.01355422f, -0.00064456f, 
    -0.00385739f, 0.00931548f, 0.02321256f, 0.00367502f, 0.03031644f, 0.01450814f, -0.02085004f, 0.01034691f, 
    0.02801870f, -0.03485219f, -0.02964740f, 0.00227142f, 0.00879507f, 0.00288193f, -0.01334901f, -0.03247630f, 
    -0.02290163f, -0.03500316f, 0.01395218f, 0.00289225f, -0.00988893f, -0.03535349f, -0.02468022f, 0.00160046f, 
    -0.03466095f, 0.00695044f, -0.02592058f, -0.01138802f, -0.03380654f, 0.01399854f, 0.02962245f, -0.00919207f, 
    -0.00671360f, -0.01400479f, -0.03597886f, -0.03289595f, -0.00799315f, -0.02189325f, 0.01455166f, -0.01313965f, 
    -0.00996193f, 0.02456299f, -0.01974233f, -0.03499286f, -0.01912528f, 0.01629268f, -0.00410403f, -0.02520015f, 
    -0.00831882f, 0.00923309f, -0.02771431f, -0.03733404f, 0.01836462f, -0.02777857f, 0.01580115f, 0.01221087f, 
    -0.01547497f, 0.01520274f, -0.00850313f, -0.00466717f, -0.02834470f, 0.00810391f, -0.01233132f, -0.00048879f, 
    -0.00989965f, -0.04700755f, -0.04273099f, 0.00644106f, 0.01708099f, 0.01024211f, -0.02441910f, -0.02135020f, 
    -0.02995398f, 0.00834860f, 0.03205384f, 0.00138708f, -0.00119312f, -0.03555695f, -0.01540357f, 0.00074781f, 
    -0.03208837f, 0.02535885f, 0.01309790f, 0.00614741f, 0.01732943f, 0.00965816f, -0.02121479f, -0.00119760f, 
    0.00510558f, -0.03452979f, 0.02454051f, -0.03416123f, -0.01775685f, -0.01867125f, -0.01543852f, 0.01252383f, 
    0.01240547f, 0.03470995f, -0.02450207f, 0.00099263f, -0.01063605f, 0.01538352f, -0.01176416f, -0.01274999f, 
    0.02164609f, -0.01206103f, 0.01413067f, -0.01893909f, -0.03173752f, -0.02246374f, -0.01318709f, -0.04195410f, 
    -0.02526215f, -0.02033443f, -0.01684688f, 0.02675024f, -0.02446192f, -0.02303122f, 0.02418129f, 0.00135068f, 
    0.02899618f, 0.02747690f, -0.00403077f, 0.02605113f, -0.02450144f, 0.00773735f, 0.03579076f, -0.02185304f, 
    -0.02637756f, -0.01137102f, -0.03653853f, -0.03354058f, -0.01101990f, 0.00398333f, 0.03689277f, 0.02017267f, 
    -0.02567188f, 0.01777891f, 0.02037925f, -0.03639988f, -0.02040803f, 0.00694178f, -0.02816416f, -0.00149769f, 
    -0.00712881f, -0.01440073f, -0.03600421f, 0.01046702f, -0.04151827f, 0.00233403f, 0.01576442f, 0.02924565f, 
    -0.00696576f, 0.02511118f, -0.02540202f, -0.01011729f, -0.00105524f, 0.01254105f, -0.01481578f, 0.01650579f, 
    -0.04314768f, -0.01524707f, 0.02345641f, 0.01802352f, 0.01652683f, -0.00404673f, -0.03677922f, 0.02852464f, 
    0.01519573f, 0.02361397f, -0.00664751f, 0.00945952f, 0.03175274f, -0.03350278f, -0.03251366f, -0.00145089f, 
    0.00994754f, 0.02558259f, -0.02716524f, -0.03323359f, 0.00047724f, -0.00602910f, -0.03061667f, -0.02067432f, 
    -0.02004801f, -0.02166443f, 0.01181258f, -0.02112983f, -0.01768414f, -0.00710051f, 0.01439546f, -0.00432040f, 
    0.01632152f, -0.00983384f, 0.02541184f, 0.02543357f, -0.02490755f, -0.03845848f, 0.00760155f, 0.00395253f, 
    -0.02073993f, -0.00711706f, -0.02649563f, -0.00421797f, -0.02930992f, -0.01049097f, 0.00585823f, -0.01337686f, 
    0.01952972f, 0.00999808f, 0.01258783f, 0.02477992f, -0.03323348f, -0.01848150f, 0.01814613f, -0.02264763f, 
    0.00239542f, -0.03187658f, -0.01602007f, 0.02891449f, 0.00172093f, 0.01711179f, 0.02172583f, -0.01700770f, 
    -0.00950155f, -0.01255999f, -0.03221606f, 0.02128793f, 0.02315870f, -0.01177387f, 0.00169659f, 0.00235553f, 
    -0.00793054f, 0.01230342f, -0.03544520f, 0.02096877f, -0.01886029f, -0.01172829f, 0.01700174f, 0.02894399f, 
    0.00451520f, 0.00310999f, -0.01714118f, -0.00406598f, -0.01722885f, -0.01826303f, 0.03208617f, -0.03705607f, 
    -0.02866083f, 0.01750883f, 0.00064184f, 0.01714686f, 0.01795212f, 0.00078155f, -0.01881990f, 0.00520662f, 
    0.00912404f, 0.02109927f, 0.03019603f, -0.00979994f, 0.01960177f, -0.03190505f, -0.03177778f, 0.01933073f, 
    0.01406569f, 0.03161823f, 0.01390912f, -0.00785159f, -0.02010671f, -0.01916819f, -0.01457054f, 0.02211217f, 
    0.01865306f, -0.00735308f, -0.00167906f, 0.00376053f, -0.00532108f, -0.00251326f, 0.02210442f, -0.00267892f, 
    -0.02253061f, 0.01315856f, -0.00914777f, 0.02046835f, -0.03197680f, -0.00225516f, -0.02646094f, 0.00389030f, 
    -0.02405621f, -0.00696495f, -0.01768551f, -0.02020784f, 0.02863335f, -0.01552698f, 0.00852869f, -0.03421637f, 
    -0.02900748f, 0.00767753f, 0.03051126f, -0.01135156f, -0.01077817f, -0.02585582f, 0.02756262f, 0.02205794f, 
    -0.04669015f, -0.02762789f, 0.01006733f, -0.03214343f, 0.00533133f, 0.01682202f, -0.00506190f, -0.03414797f, 
    0.02335715f, -0.00517192f, -0.00039811f, -0.02356708f, 0.00605019f, -0.03434663f, 0.02862054f, -0.00469113f, 
    -0.02237907f, 0.01651360f, 0.03054583f, -0.00079200f, -0.01070448f, 0.02142749f, -0.01883793f, 0.02222424f, 
    -0.03748317f, -0.07198024f, 0.02450312f, -0.02794237f, -0.03293322f, -0.06851850f, -0.00530989f, -0.04021973f, 
    -0.05123565f, -0.05318071f, -0.04891406f, -0.04228604f, 0.00263936f, -0.00735378f, -0.00962259f, -0.02868759f, 
    -0.00335857f, -0.05068607f, -0.03020875f, -0.06278411f, 0.02812895f, 0.03423142f, 0.03165917f, 0.01663527f, 
    -0.02425365f, 0.00586405f, 0.02389133f, 0.00984261f, -0.02214963f, -0.02822651f, 0.01090039f, 0.00736239f, 
    0.01357182f, -0.01551749f, -0.07060929f, 0.00461362f, -0.04302875f, -0.05150576f, -0.01961356f, -0.04541630f, 
    -0.00013975f, 0.00692547f, -0.04147252f, -0.03009869f, -0.05145216f, -0.01624006f, 0.02021562f, 0.02394316f, 
    0.01055332f, -0.00087625f, 0.00566026f, 0.00116776f, -0.00678334f, -0.02173395f, -0.00369695f, 0.03024581f, 
    -0.06346989f, -0.03682347f, -0.02368988f, -0.00409491f, 0.02005727f, 0.00332391f, -0.04890952f, -0.00799665f, 
    0.00463252f, -0.01145733f, -0.00390018f, -0.03905481f, -0.03709334f, 0.00801063f, 0.02011535f, 0.00715778f, 
    -0.03581581f, -0.04732975f, -0.04411814f, -0.00368677f, 0.00458685f, -0.01542038f, -0.01642234f, -0.02101918f, 
    -0.05059964f, -0.05691991f, -0.03003558f, -0.00623449f, -0.03501285f, -0.04428645f, 0.00533004f, -0.02710986f, 
    -0.02641425f, -0.03363102f, -0.04634693f, -0.04217632f, 0.05036822f, 0.04335178f, 0.00573207f, 0.00777174f, 
    -0.02101085f, -0.00961744f, -0.00893624f, 0.02108932f, -0.02466494f, 0.02066877f, 0.01821377f, 0.01149902f, 
    0.01376156f, -0.02427484f, -0.04068112f, -0.07672793f, -0.05088949f, -0.01970539f, -0.04244761f, -0.07027304f, 
    0.00841317f, 0.00933571f, -0.02174078f, 0.00215492f, -0.05240766f, -0.01133061f, 0.00021893f, -0.02088938f, 
    -0.00994843f, -0.06234734f, -0.00627560f, -0.04333051f, -0.01642121f, -0.03661960f, -0.02436585f, -0.01469756f, 
    0.01079538f, 0.00962251f, -0.01370496f, 0.02354206f, -0.02492600f, -0.02254923f, -0.01053946f, -0.03919401f, 
    -0.00424570f, -0.02386583f, -0.03016288f, 0.01297715f, -0.00884278f, 0.02036056f, -0.01940859f, 0.03282927f, 
    -0.02195989f, -0.01616139f, 0.01411162f, 0.00704829f, -0.04724638f, 0.03182446f, -0.00532517f, -0.00705104f, 
    0.01745868f, -0.01891189f, 0.00340834f, 0.02567127f, 0.02966478f, 0.00517545f, 0.02690119f, -0.05448899f, 
    -0.05546326f, -0.01961607f, -0.01056187f, 0.00266594f, -0.04035917f, -0.04661229f, -0.02508376f, -0.06342474f, 
    -0.04560127f, -0.06228819f, -0.03920294f, -0.03114681f, -0.03406635f, -0.04810586f, -0.04701700f, -0.06391498f, 
    -0.02936145f, -0.04338120f, 0.00268855f, 0.01369632f, 0.01762939f, -0.02299854f, -0.00786333f, 0.01427733f, 
    -0.03269864f, -0.04352554f, -0.00965785f, -0.04543561f, 0.01773281f, -0.00473107f, 0.00759873f, -0.00744883f, 
    -0.03054960f, -0.02851641f, 0.03187160f, -0.01882933f, 0.00753129f, -0.00100020f, 0.01604127f, 0.00984452f, 
    0.01053395f, -0.02142256f, 0.02667148f, -0.03205082f, -0.03368894f, -0.02673289f, -0.01400525f, 0.00948293f, 
    -0.00458072f, -0.04207148f, 0.00895962f, 0.02392841f, -0.04525492f, -0.07030306f, -0.04826027f, -0.07012711f, 
    -0.04305701f, -0.03352192f, -0.02415412f, -0.00848012f, -0.01018430f, -0.05119140f, -0.01817878f, -0.01650062f, 
    -0.03083582f, -0.00127000f, -0.05757280f, -0.04249575f, -0.00465544f, -0.04396395f, 0.00021266f, -0.05709791f, 
    -0.05285905f, -0.03552261f, -0.00184883f, -0.00051113f, -0.04902195f, -0.00022483f, -0.04296621f, 0.00405363f, 
    -0.00646744f, -0.05574329f, -0.03082793f, -0.02877411f, 0.01890785f, -0.01920805f, -0.01894779f, -0.03645789f, 
    0.00312829f, -0.00566273f, -0.04661850f, -0.02281180f, -0.02513664f, -0.02763551f, 0.01947257f, -0.01553774f, 
    -0.01410707f, -0.04581202f, -0.02384314f, 0.02279077f, -0.05501508f, 0.02432330f, -0.01291128f, 0.01715089f, 
    0.00210654f, -0.02471840f, 0.00553329f, -0.04004432f, -0.02191847f, -0.05690930f, -0.02296922f, -0.00750405f, 
    -0.04790887f, 0.00710046f, -0.03449242f, 0.02448148f, -0.01242493f, 0.01254499f, -0.00344873f, 0.01539226f, 
    -0.02429805f, -0.00390790f, -0.00315491f, 0.01172553f, -0.01353988f, -0.05405862f, -0.00779189f, -0.02746617f, 
    0.00244954f, 0.00254603f, 0.00607314f, -0.01002638f, -0.02709590f, 0.03500510f, -0.02532203f, -0.01622256f, 
    0.02350503f, 0.05988137f, -0.00955554f, -0.03981348f, -0.02064070f, 0.02230444f, 0.00191256f, 0.00778494f, 
    0.02722891f, -0.00812922f, 0.04107056f, 0.00839769f, 0.02989129f, -0.01155892f, -0.02628462f, -0.00010065f, 
    -0.05699717f, 0.02877757f, -0.02240067f, -0.02695662f, 0.00819923f, 0.02725413f, 0.04419047f, 0.00711750f, 
    0.00638466f, -0.02492084f, 0.00267601f, 0.00536642f, -0.00869122f, 0.04990828f, 0.00137216f, 0.00851975f, 
    0.01293369f, -0.00084916f, -0.02835636f, -0.00242941f, -0.02027053f, -0.00536694f, -0.02245181f, 0.00995255f, 
    0.00706682f, 0.01166504f, -0.01891653f, 0.03045814f, -0.04704173f, -0.02036259f, -0.02247215f, -0.01859806f, 
    -0.02063630f, -0.02429365f, 0.01274530f, -0.01184484f, -0.01747162f, -0.03933155f, 0.00949570f, -0.01954441f, 
    -0.04299580f, 0.00184136f, -0.01595982f, -0.05958297f, 0.00790301f, 0.02984693f, 0.00590659f, -0.05130211f, 
    -0.04596825f, -0.02138099f, -0.01269788f, 0.00312145f, 0.02406229f, -0.01596297f, 0.02761026f, 0.03150629f, 
    -0.00272548f, -0.02197367f, -0.02599965f, -0.04763702f, -0.04355708f, -0.02577014f, -0.03692148f, 0.01032234f, 
    -0.02835890f, -0.00846529f, -0.00389341f, -0.02037051f, -0.01201480f, -0.05154350f, -0.01690509f, 0.01366937f, 
    -0.04004456f, -0.00867152f, -0.04311510f, 0.01238988f, -0.00731108f, -0.00377817f, -0.05593767f, -0.00407219f, 
    -0.01587603f, -0.05352038f, 0.01083467f, -0.02350815f, -0.00382344f, -0.00129628f, -0.04754186f, -0.01982340f, 
    -0.00093245f, -0.00110268f, -0.02882972f, -0.03644163f, 0.01630636f, -0.02947497f, -0.06344735f, -0.06200305f, 
    -0.02178052f, -0.02765470f, -0.01402548f, -0.01877145f, 0.01668037f, -0.05066828f, -0.01127148f, -0.04268065f, 
    0.01043680f, -0.00999980f, -0.04087475f, -0.04161976f, 0.00759505f, 0.00889567f, 0.00973804f, 0.01333551f, 
    0.00155461f, -0.03074531f, -0.02822772f, -0.04606088f, 0.04357762f, 0.03171461f, 0.00233508f, 0.00798900f, 
    -0.04140218f, -0.03640911f, 0.00781676f, 0.05610262f, -0.02200141f, 0.03088109f, 0.05203773f, 0.05016740f, 
    0.06489027f, 0.02761331f, 0.00588995f, -0.00420125f, -0.00646425f, -0.00677439f, 0.01551133f, -0.00856744f, 
    -0.02179915f, -0.03589114f, -0.00315770f, -0.01144501f, 0.02443435f, 0.01167870f, 0.02616739f, 0.00549171f, 
    0.01211300f, 0.00678628f, 0.01913274f, 0.02460646f, 0.01621090f, 0.00863605f, 0.00704529f, 0.01897628f, 
    -0.01090419f, -0.00038772f, 0.00224229f, 0.03197887f, 0.01729993f, -0.01513118f, -0.03705297f, 0.00015921f, 
    -0.00457167f, -0.00616077f, -0.01706868f, -0.01047054f, 0.01097115f, -0.02089306f, 0.00645585f, -0.02024013f, 
    -0.03638609f, -0.02784198f, -0.03167684f, -0.04178291f, -0.03870219f, -0.02656236f, -0.00909263f, -0.00413121f, 
    -0.02749297f, -0.00383165f, -0.03589782f, -0.05523299f, -0.01873984f, -0.02943838f, -0.02722438f, 0.00714004f, 
    -0.02254198f, 0.00584267f, -0.03087049f, 0.02385694f, -0.06396049f, 0.01894710f, -0.03877717f, -0.02196855f, 
    -0.01680074f, 0.00026685f, 0.00162736f, 0.00327526f, -0.01841631f, 0.05469406f, 0.01788585f, -0.03071750f, 
    0.04477922f, 0.01916793f, -0.05449863f, -0.02439596f, 0.00784518f, 0.01973206f, -0.04545706f, -0.02488093f, 
    -0.04218966f, 0.01751142f, -0.04672151f, -0.01576033f, -0.01817413f, -0.04312863f, 0.00874468f, -0.01788862f, 
    -0.01437724f, -0.02320188f, -0.03910055f, -0.00317545f, -0.01295613f, -0.04041037f, -0.02592731f, -0.00998498f, 
    -0.00207429f, -0.01226686f, -0.00568664f, -0.01686180f, -0.01896096f, -0.00608850f, 0.02005685f, 0.01671304f, 
    -0.06578269f, 0.00518626f, 0.01255567f, -0.05763394f, 0.01480807f, -0.02109803f, -0.04347264f, -0.03425869f, 
    0.01516133f, 0.00885744f, 0.01899065f, -0.02475875f, -0.07247327f, -0.01947021f, -0.04008912f, -0.02070538f, 
    0.03944241f, 0.02881970f, -0.02255429f, 0.04288114f, 0.02367492f, -0.01529209f, -0.03070294f, -0.03103962f, 
    -0.01556600f, -0.02015728f, -0.02551375f, -0.07627247f, 0.01095630f, 0.01962562f, -0.02909334f, 0.04047699f, 
    -0.00978848f, 0.02066193f, 0.02193807f, 0.02377248f, 0.00471549f, -0.01946103f, -0.01174822f, -0.01238285f, 
    -0.04392376f, -0.04248683f, -0.06440502f, -0.08536813f, -0.03853914f, 0.00343215f, -0.02914685f, 0.00410779f, 
    0.02099606f, -0.00864408f, -0.02380749f, -0.01773886f, 0.00666838f, 0.00036622f, -0.03052599f, -0.08022311f, 
    0.00662570f, -0.01918441f, 0.04492484f, 0.00365973f, 0.01343452f, 0.04272410f, 0.03087891f, -0.03471276f, 
    0.01103350f, 0.03512689f, 0.04109090f, -0.00011412f, 0.00418199f, -0.02169124f, -0.03006749f, 0.00687482f, 
    -0.01893783f, 0.01234729f, -0.00036568f, -0.00334991f, 0.04046027f, -0.00428033f, 0.02662718f, -0.00764681f, 
    -0.02542995f, -0.05606090f, -0.03488770f, -0.03616327f, -0.00827806f, -0.02888595f, -0.01525105f, -0.01807855f, 
    -0.00791694f, 0.02528327f, -0.01459586f, 0.01691419f, -0.01955025f, -0.01597724f, 0.00660003f, 0.04354107f, 
    -0.03662861f, 0.02322316f, 0.00961652f, 0.02441471f, -0.05855050f, -0.05152196f, -0.03003904f, -0.03828675f, 
    -0.04697283f, -0.02382873f, -0.01320073f, -0.00053142f, 0.02839729f, -0.01354800f, -0.00306439f, -0.01395616f, 
    0.00388782f, -0.04348925f, -0.04798586f, -0.03759144f, 0.01227834f, -0.00106376f, -0.03261996f, -0.04085280f, 
    -0.05165232f, -0.01509739f, -0.05156849f, -0.07070105f, 0.02685015f, 0.00854444f, 0.00847240f, -0.01426810f, 
    -0.02626435f, 0.03026503f, 0.03432060f, -0.00181880f, 0.02175680f, 0.03337278f, 0.01065108f, 0.01866726f, 
    -0.02099143f, -0.04263107f, -0.03185721f, 0.00657273f, -0.00794651f, -0.03277346f, -0.00668624f, -0.03052654f, 
    0.02089274f, -0.00965777f, -0.03877169f, -0.02996236f, -0.05079553f, -0.03641654f, -0.05774689f, -0.04480965f, 
    -0.03919120f, -0.02724032f, -0.03539161f, -0.00337646f, -0.05265822f, -0.03322368f, -0.03352427f, -0.04922266f, 
    0.01982559f, -0.04894642f, -0.03011471f, -0.02746010f, -0.00788510f, -0.04574119f, -0.00272272f, -0.04736168f, 
    -0.06451871f, -0.00533357f, 0.00635592f, -0.06577760f, -0.01295112f, -0.01320739f, -0.02552180f, -0.04248983f, 
    -0.01414736f, -0.02536043f, -0.02667568f, -0.01432719f, -0.04031205f, -0.01515479f, -0.04111496f, -0.03315972f, 
    0.01866988f, 0.01602217f, 0.02220965f, -0.00702766f, 0.01721075f, -0.01070145f, -0.03886652f, 0.03456415f, 
    -0.03903021f, -0.02210781f, 0.01675325f, 0.01895950f, 0.05321527f, 0.05137994f, 0.00534729f, -0.04334241f, 
    -0.01966701f, -0.01869419f, -0.03408135f, -0.05847063f, -0.01445384f, 0.02476951f, -0.05091991f, -0.00395240f, 
    0.00240371f, 0.18544288f, 0.02088027f, -0.16330169f, -0.02071941f, 0.01170744f, -0.02568428f, -0.03772603f, 
    0.13208042f, 0.03289930f, -0.01436636f, 0.07467864f, -0.47314221f, -0.36560875f, 0.17849953f, 0.12842263f, 
    -0.03848098f, -0.10575569f, -0.05206456f, 0.12532754f, -0.06388299f, 0.08140099f, 0.17359419f, -0.06551721f, 
    0.44906309f, 0.07740886f, 0.01357386f, 0.00543532f, -0.02216031f, 0.00015753f, -0.05123865f, 0.01640212f, 
    0.00046284f, -0.07069664f, 0.02196348f, -0.00246403f, -0.22409295f, -0.10125464f, 0.04449851f, 0.11858955f, 
    -0.01661658f, -0.12382753f, -0.08712061f, 0.04425233f, -0.04528962f, -0.02856301f, -0.07137130f, 0.08355870f, 
    0.30654639f, -0.01054558f, 0.21495074f, -0.23762879f, -0.00795913f, -0.03049479f, -0.01131402f, 0.01634800f, 
    0.01894613f, -0.00702181f, 0.05462055f, 0.01805336f, -0.33163619f, -0.07606491f, 0.01899236f, 0.28622940f, 
    0.05602568f, -0.05839069f, -0.06313155f, -0.06788663f, -0.02726454f, -0.10980116f, 0.05141081f, 0.30995220f, 
    -0.36147624f, 0.20097423f, -0.34642363f, 0.19967744f, 0.10185131f, 0.00916731f, -0.02388005f, 0.01126145f, 
    -0.03945410f, -0.05647931f, 0.00113966f, -0.05457365f, -0.20104027f, 0.04157365f, 0.06875417f, 0.00630064f, 
    -0.06002635f, -0.04781333f, 0.01062892f, 0.06476940f, -0.05314347f, 0.07246903f, 0.16018909f, -0.02001718f, 
    0.13037376f, 0.04392576f, -0.04144295f, 0.05119750f, 0.20970212f, -0.00102385f, -0.02814163f, 0.08434389f, 
    0.07896550f, 0.06160409f, 0.01113225f, 0.11581566f, -0.30836675f, -0.19132636f, 0.11027472f, 0.11516124f, 
    -0.02727997f, 0.00714324f, -0.02467681f, 0.10982653f, -0.00611144f, 0.04373942f, 0.03550775f, -0.01433920f, 
    -0.08050696f, 0.18834224f, 0.05815085f, -0.02604987f, -0.09111696f, -0.08004212f, 0.02656727f, -0.16600205f, 
    0.09316370f, 0.06663387f, -0.04608312f, -0.04038364f, 0.16026150f, -0.04846339f, -0.09602592f, 0.20587797f, 
    0.09750366f, 0.08467268f, -0.05543704f, 0.09668741f, 0.13854972f, 0.01615195f, -0.08345664f, 0.05029977f, 
    -0.07645085f, 0.07961088f, 0.13293464f, 0.05385072f, 0.02975184f, -0.01865396f, -0.01777610f, -0.00935987f, 
    -0.12669195f, -0.07606782f, 0.03540824f, -0.17421126f, 0.24597104f, -0.06957829f, -0.07980124f, -0.07610602f, 
    -0.04730219f, -0.02926880f, -0.00590591f, 0.00668002f, 0.06061366f, -0.10858271f, 0.09946500f, -0.00496128f, 
    0.37975481f, 0.14943235f, 0.21429928f, -0.22883412f, -0.06313095f, -0.00499997f, 0.15511963f, -0.01315644f, 
    0.09772518f, -0.02828608f, 0.09478360f, -0.03298859f, -0.01784049f, 0.00308096f, 0.03040341f, 0.08862439f, 
    0.12987511f, 0.02935067f, -0.04894705f, 0.02803626f, 0.06026119f, 0.03648194f, -0.04237080f, -0.01590177f, 
    0.12546173f, 0.35665268f, -0.13339140f, 0.29249170f, -0.01912615f, -0.00672111f, -0.01993418f, 0.03400604f, 
    0.04538184f, 0.02184090f, 0.17101265f, 0.05324103f, -0.42449769f, 0.05834832f, -0.14155868f, 0.31817672f, 
    0.02947248f, -0.06775479f, -0.04660992f, 0.20931463f, 0.15803376f, -0.01397227f, 0.04898474f, 0.12612535f, 
    -0.60164028f, 0.01089476f, -0.01225096f, 0.10753970f, 0.22793287f, 0.00752915f, -0.05181655f, 0.12350661f, 
    0.16449614f, 0.11442844f, 0.11326547f, 0.10512861f, 0.13871090f, 0.20438603f, 0.04876555f, -0.04120337f, 
    0.02684303f, 0.02044029f, 0.04994500f, 0.02256840f, 0.04152641f, 0.02595103f, 0.15629235f, -0.10984188f, 
    0.33447739f, -0.11561060f, -0.03853629f, -0.01948440f, -0.03113976f, -0.01195662f, 0.14494853f, 0.01403225f, 
    -0.03680424f, -0.05749595f, -0.03241637f, 0.08178923f, -0.33032268f, -0.03164021f, 0.10741407f, 0.21704061f, 
    -0.12998468f, -0.02599370f, -0.02167349f, 0.14563946f, 0.01931678f, 0.07007052f, 0.24091832f, -0.03955403f, 
    0.03205670f, 0.03743067f, -0.00996618f, -0.27991042f, -0.02146092f, 0.03966672f, -0.08486954f, 0.00704587f, 
    0.02343375f, 0.03714134f, -0.01352557f, 0.04881065f, -0.15369889f, -0.04489664f, -0.07551163f, 0.03771294f, 
    0.17067827f, 0.09891048f, -0.03432736f, 0.19453098f, 0.14224106f, 0.10944283f, -0.03315590f, 0.11583071f, 
    -0.34555489f, -0.06032644f, -0.22940512f, 0.42904383f, 0.07390209f, 0.00793112f, -0.02501265f, 0.11847284f, 
    0.02732842f, 0.12164229f, 0.01205124f, -0.00223148f, -0.48957348f, -0.09915950f, 0.31644887f, 0.15840158f, 
    0.05600044f, 0.06486641f, -0.08289445f, 0.07407221f, 0.05489157f, 0.02233693f, 0.13560817f, -0.07957234f, 
    -0.25512573f, -0.08343317f, 0.10665505f, 0.07400275f, -0.00013632f, -0.01903522f, 0.07370656f, -0.09725065f, 
    0.04497036f, -0.01564467f, 0.04476901f, -0.01281014f, -0.09367687f, -0.07293238f, 0.12827431f, 0.10405605f, 
    -0.00810511f, -0.13431276f, 0.02053023f, 0.05657079f, 0.00858081f, -0.00987926f, 0.02479887f, 0.06145945f, 
    0.11910888f, 0.31106359f, 0.26294401f, -0.17462596f, -0.03073727f, -0.05124552f, 0.02910531f, 0.11832014f, 
    -0.04082844f, 0.03180308f, 0.11524961f, 0.07583044f, 0.13637434f, 0.05521479f, 0.24219209f, -0.25095549f, 
    -0.04592352f, 0.07221124f, 0.07206050f, 0.01617779f, 0.08865784f, -0.00821240f, -0.10008626f, 0.05315139f, 
    0.17895740f, 0.07273211f, -0.00200486f, 0.03908725f, 0.05453562f, 0.02895628f, 0.00446757f, -0.02049488f, 
    -0.02679232f, 0.07466612f, 0.06332664f, 0.01653514f, 0.06015695f, 0.08496620f, 0.02828032f, -0.19365460f, 
    -0.14386758f, -0.08614337f, 0.13148509f, -0.05374794f, 0.02842054f, -0.05796411f, -0.00340308f, 0.02187689f, 
    0.17848717f, 0.05160014f, 0.07221031f, -0.06823684f, -0.02286390f, -0.04928373f, 0.01418374f, 0.00621618f, 
    0.28115711f, 0.35142031f, 0.12586002f, 0.11508838f, 0.03050324f, 0.00634644f, 0.02748400f, 0.13149215f, 
    0.04009438f, -0.05099570f, -0.07320508f, -0.02341769f, 0.11348207f, -0.04520284f, 0.05848841f, -0.02889569f, 
    0.08244059f, -0.09430919f, 0.00540271f, -0.16497260f, 0.15310226f, 0.07129613f, 0.14537337f, 0.04731333f, 
    -0.01545247f, -0.07057504f, -0.02950571f, 0.05880912f, -0.03109996f, 0.00123151f, 0.10751933f, 0.10644225f, 
    -0.04888065f, -0.00589540f, -0.00687846f, 0.19870184f, 0.16185765f, 0.00297083f, 0.16079497f, -0.05350509f, 
    0.20454168f, 0.08985264f, -0.03335193f, -0.05100100f, 0.23086786f, 0.01138921f, -0.09076659f, 0.14202696f, 
    0.18416069f, -0.04201018f, -0.02999437f, 0.06044688f, -0.13345239f, -0.14075200f, -0.00850521f, 0.20355691f, 
    -0.13699152f, 0.03121561f, -0.13000536f, -0.08978827f, -0.00512914f, 0.06600936f, -0.00639059f, -0.01250745f, 
    -0.19421665f, -0.06198880f, 0.00074149f, 0.16405526f, -0.11196523f, -0.07358478f, -0.03552568f, -0.03581132f, 
    -0.02179748f, 0.01492918f, 0.07909051f, -0.03608151f, -0.10493437f, -0.06148686f, -0.01942115f, 0.15620841f, 
    0.12031657f, 0.26400745f, 0.00311748f, 0.01764586f, 0.04327429f, 0.03769296f, -0.10605103f, 0.09583760f, 
    -0.28131747f, -0.06996313f, 0.13420646f, 0.06298775f, -0.01885663f, -0.06287259f, -0.02047082f, -0.05958243f, 
    -0.16965131f, -0.00856741f, 0.03372963f, -0.02011675f, 0.08705696f, -0.02838817f, 0.06888366f, -0.09833261f, 
    -0.05486523f, 0.16837464f, 0.04614702f, 0.07732638f, 0.12091760f, -0.00522363f, 0.06306936f, 0.08888444f, 
    -0.14925927f, -0.01138278f, -0.01008651f, 0.23704839f, -0.00408674f, -0.01653375f, -0.05797039f, 0.24491587f, 
    0.05757695f, 0.11839219f, -0.05057585f, -0.08499878f, -0.03109858f, 0.04735712f, 0.27229065f, -0.17606738f, 
    0.17106673f, 0.26012093f, 0.11576470f, 0.01146728f, 0.00043594f, 0.15110849f, 0.07354015f, 0.04840317f, 
    0.08625596f, 0.34920430f, 0.02117176f, -0.06375348f, -0.16045777f, 0.17503926f, 0.07735643f, -0.08230942f, 
    0.09851783f, -0.09278648f, 0.12019832f, -0.12838104f, -0.05655732f, -0.06211925f, -0.08056726f, -0.05223498f, 
    0.08536758f, 0.01405392f, 0.00502720f, 0.01495542f, 0.00485341f, -0.12709166f, 0.01797548f, -0.05066124f, 
    0.43041292f, -0.15285327f, 0.07506064f, -0.10241782f, -0.00511989f, -0.00091084f, 0.10489208f, 0.12135291f, 
    0.03617757f, -0.03223794f, 0.03825520f, 0.03201017f, 0.33849823f, 0.45313218f, 0.19984692f, -0.19290920f, 
    -0.09703653f, 0.04058836f, 0.00495465f, 0.08061332f, 0.10975882f, 0.01756216f, 0.18402013f, -0.06208371f, 
    0.39010179f, 0.14862926f, 0.23584192f, 0.17351300f, -0.01506266f, 0.03239822f, -0.08326433f, -0.05300191f, 
    0.02145041f, 0.07570837f, 0.01706122f, 0.02322839f, -0.35916981f, -0.09876484f, 0.27510855f, 0.09286713f, 
    0.09375778f, 0.03488360f, -0.11200944f, -0.00789033f, -0.00043553f, -0.00655659f, -0.00337752f, 0.04586001f, 
    -0.14721537f, -0.09516663f, 0.06371011f, 0.03175078f, 0.01806440f, -0.10372543f, -0.17597999f, 0.22513574f, 
    -0.01298857f, 0.07557716f, -0.13797621f, -0.05459980f, 0.11112995f, 0.24215096f, 0.22474810f, -0.06384642f, 
    -0.09952993f, -0.23496838f, 0.02041249f, 0.10554158f, -0.03069066f, 0.06902844f, 0.01915622f, -0.07640540f, 
    -0.02242745f, -0.03482609f, 0.14727706f, 0.25780433f, -0.04413181f, -0.18459336f, 0.00505285f, -0.12979896f, 
    -0.00046186f, 0.00967519f, -0.01285291f, -0.00364587f, -0.09787028f, -0.11386511f, -0.03218499f, 0.14143261f, 
    0.03167545f, 0.00359742f, 0.07857691f, -0.06738815f, -0.01085845f, -0.05058257f, 0.02763827f, 0.02746216f, 
    -0.06494914f, 0.00067363f, 0.19083501f, 0.19527005f, -0.01196859f, -0.04959298f, 0.00750235f, 0.00782676f, 
    0.12253807f, 0.07720311f, 0.03269833f, -0.01304895f, -0.11229225f, -0.01668688f, -0.02822798f, 0.05178985f, 
    0.15333672f, 0.05273303f, -0.05114468f, 0.01400145f, -0.01227187f, -0.05714661f, -0.01973398f, -0.05952546f, 
    0.06995534f, 0.04569193f, 0.03682516f, 0.13632257f, 0.01758648f, 0.00319268f, -0.04637294f, -0.00321260f, 
    0.01278301f, 0.04644223f, -0.00199122f, -0.02398656f, -0.02565406f, -0.05670492f, 0.19462012f, 0.29323393f, 
    -0.02087890f, -0.21393651f, -0.10802130f, -0.22800004f, 0.03583081f, 0.04267354f, 0.01491153f, 0.06035131f, 
    0.28172696f, 0.24299096f, 0.07889628f, 0.16748492f, 0.00659661f, -0.00743786f, 0.01007785f, -0.00073954f, 
    0.01734599f, 0.02075248f, 0.16039197f, 0.00357981f, 0.09319369f, -0.00904733f, -0.01272642f, 0.00328981f, 
    0.04539501f, 0.01661247f, 0.02703266f, 0.01392465f, -0.00489816f, 0.00462921f, -0.03557003f, -0.01015887f, 
    0.03319966f, 0.00193756f, -0.05752825f, 0.07075579f, 0.02310988f, 0.00531902f, 0.00094717f, 0.00544172f, 
    -0.03117212f, 0.00583051f, -0.05002508f, -0.01668633f, 0.04715464f, 0.06575243f, -0.00884753f, 0.02459716f, 
    -0.01436457f, -0.00742628f, -0.02657082f, -0.04772143f, 0.09040430f, 0.11000294f, 0.11895223f, 0.00577784f, 
    -0.16061407f, -0.03183858f, -0.06565743f, 0.14459978f, -0.11751417f, 0.04103538f, -0.01234384f, 0.04611205f, 
    0.00104840f, 0.04977695f, 0.01673915f, -0.06447745f, -0.33572698f, -0.04694187f, 0.05190362f, -0.05286833f, 
    0.02689329f, 0.03562465f, 0.13755628f, -0.18791407f, -0.02021269f, -0.13814273f, 0.01888006f, 0.01019423f, 
    -0.00923833f, -0.00861679f, 0.31458065f, -0.22285752f, -0.02032490f, -0.04144572f, 0.01022349f, 0.08165780f, 
    -0.20319119f, -0.10364871f, -0.23450233f, -0.08860463f, -0.31212670f, 0.16520651f, -0.20754790f, 0.40782198f, 
    0.01567899f, -0.02891659f, -0.01509617f, 0.00015573f, -0.10725807f, 0.07759692f, 0.06098520f, -0.00461918f, 
    0.11860936f, 0.19675365f, 0.22459143f, -0.05946200f, -0.01561035f, -0.06965818f, 0.01816692f, 0.05306167f, 
    -0.11152029f, -0.03751928f, -0.00430007f, 0.09894062f, -0.10797098f, 0.27675092f, -0.19110975f, 0.13192344f, 
    -0.04209584f, -0.00285317f, -0.04133497f, -0.14076354f, 0.04462092f, -0.16706076f, -0.05433800f, -0.13133061f, 
    0.14590470f, -0.08517426f, 0.16969453f, 0.00650800f, -0.12527037f, -0.06031565f, 0.05395173f, 0.01761216f, 
    -0.09802407f, 0.14046338f, -0.05407674f, -0.14651608f, 0.04970883f, 0.24292865f, 0.15921377f, -0.09723967f, 
    -0.00651471f, -0.05413051f, -0.08615348f, -0.14303939f, 0.02719706f, 0.04640795f, 0.04491465f, 0.00778079f, 
    0.01962031f, -0.12334563f, -0.52566880f, -0.02427412f, 0.00915459f, 0.12091694f, -0.03492097f, -0.02650112f, 
    -0.07991854f, 0.04389169f, -0.02169871f, -0.09877879f, -0.11908296f, -0.03068575f, 0.04943527f, -0.04931050f, 
    -0.14933610f, -0.04521644f, -0.05368345f, -0.07328121f, -0.05759893f, 0.00098256f, -0.08434559f, -0.03546245f, 
    -0.11506924f, -0.21427944f, 0.36709529f, -0.21962266f, -0.08469393f, 0.18729159f, -0.04208175f, 0.07054564f, 
    0.03627314f, -0.06437376f, 0.09403209f, 0.02232170f, -0.23338917f, -0.09605633f, -0.21738409f, 0.30239251f, 
    -0.05144652f, -0.02369709f, 0.16454105f, -0.13964397f, 0.12618528f, 0.16135851f, -0.05399452f, -0.00556351f, 
    -0.12201525f, -0.17640117f, 0.24793331f, -0.22259487f, -0.02780642f, 0.06230788f, -0.02751516f, -0.01751474f, 
    0.11171902f, 0.04110292f, -0.03024482f, -0.05148789f, -0.11085676f, 0.17066385f, 0.04258247f, -0.10090776f, 
    0.22633986f, 0.09745999f, 0.11478845f, -0.09693360f, -0.06800140f, -0.05015640f, -0.00574611f, -0.01180720f, 
    -0.02955805f, -0.05292398f, 0.27703294f, 0.11511543f, -0.04000797f, -0.00173727f, -0.10553243f, -0.12562948f, 
    0.05233321f, 0.03623030f, -0.25548530f, 0.19110650f, -0.14544396f, -0.04685388f, 0.11330702f, -0.04294103f, 
    -0.06806912f, 0.14046015f, -0.19497640f, -0.23233713f, 0.00517885f, 0.04204896f, -0.12889437f, -0.05180319f, 
    0.45921272f, -0.06124453f, 0.27457681f, 0.01790473f, -0.05966514f, -0.08137106f, -0.04330339f, 0.11760291f, 
    -0.05683379f, -0.00482233f, 0.04643593f, 0.14528602f, 0.09010446f, 0.11912334f, -0.01546236f, 0.02556103f, 
    0.10471190f, 0.11476568f, 0.02718958f, 0.09166077f, 0.05720667f, 0.19391352f, -0.05973094f, 0.03659010f, 
    -0.05755711f, 0.35546312f, -0.06564440f, 0.11299849f, -0.09070452f, 0.06001667f, 0.13482091f, 0.01011256f, 
    0.06700058f, -0.08701106f, 0.10922354f, -0.09846026f, -0.26726842f, -0.04974591f, -0.22223531f, -0.04724146f, 
    -0.04037300f, 0.18269613f, 0.01677841f, -0.01859967f, 0.22154561f, -0.10737082f, 0.15902129f, 0.06677573f, 
    -0.30916178f, -0.32127565f, 0.31848535f, 0.14524472f, 0.19053738f, 0.15314768f, -0.01952196f, -0.00142532f, 
    0.03429096f, 0.09361231f, 0.19222605f, -0.03353474f, 0.31477797f, -0.00734790f, 0.15911460f, 0.20851418f, 
    0.13641922f, -0.06372756f, 0.11104579f, 0.09389981f, 0.02793476f, -0.06596661f, -0.04265666f, 0.00122310f, 
    0.40801388f, 0.14103243f, 0.12615018f, -0.23991096f, -0.01247641f, 0.03793373f, 0.07675140f, 0.09910700f, 
    0.13044184f, 0.06457053f, 0.10363711f, 0.00883879f, -0.08503623f, -0.08857021f, 0.04780921f, 0.20455205f, 
    0.02487553f, 0.00688305f, 0.00329570f, -0.01534356f, 0.05045383f, 0.01789544f, 0.03716793f, 0.09969007f, 
    0.13931847f, 0.12994911f, 0.07744244f, 0.22385809f, -0.08377915f, 0.00004274f, -0.00919328f, 0.00359242f, 
    -0.14000368f, -0.04390132f, -0.17450091f, 0.20680012f, -0.18564254f, 0.28831387f, -0.16416416f, 0.12180164f, 
    -0.02437620f, -0.10324024f, 0.22584401f, 0.07826520f, -0.02408081f, 0.01291121f, -0.00553003f, -0.17624888f, 
    -0.27801374f, -0.02595534f, -0.32539278f, 0.04188074f, 0.15241535f, 0.02840653f, 0.00351165f, -0.03055028f, 
    0.11494320f, -0.05542231f, 0.06120316f, 0.01999393f, -0.09394515f, -0.47079909f, 0.40502053f, 0.32699814f, 
    -0.11290187f, 0.02397520f, -0.01122802f, -0.03633943f, 0.07940819f, 0.00248058f, 0.07847636f, 0.22721474f, 
    -0.28507286f, -0.00496906f, 0.10008742f, -0.00023401f, 0.00216409f, -0.01427678f, 0.03339918f, 0.04406833f, 
    0.04588846f, 0.02919222f, 0.07181765f, 0.02930045f, -0.11693861f, -0.25731000f, -0.22347148f, 0.02007505f, 
    -0.24641575f, -0.14989375f, -0.03695658f, -0.10885072f, 0.03662700f, 0.09758583f, 0.05887671f, 0.07580178f, 
    0.11044132f, -0.31438419f, -0.03737245f, 0.06495641f, 0.05646107f, -0.00311890f, -0.05935873f, 0.08859199f, 
    -0.06233668f, 0.02011804f, -0.06558195f, -0.01444609f, 0.02991066f, 0.00335650f, 0.14412721f, 0.04478119f, 
    -0.01099286f, 0.05207716f, -0.04164693f, 0.04842754f, 0.00396136f, -0.16139178f, -0.06285238f, -0.02052743f, 
    0.12635231f, 0.00394670f, 0.27173695f, 0.02186838f, -0.07426030f, 0.03951985f, -0.06190460f, -0.04844233f, 
    0.00287866f, 0.01928943f, -0.07912837f, 0.03289289f, 0.00659541f, -0.06657945f, 0.09228773f, -0.10616832f, 
    -0.09935773f, -0.07200003f, 0.04980264f, -0.05255434f, -0.10353256f, 0.03426314f, 0.00038645f, 0.00550830f, 
    -0.01647826f, -0.00380088f, 0.04398303f, -0.17409824f, 0.00289318f, -0.00462393f, -0.02915204f, -0.02238076f, 
    -0.01603703f, 0.19891766f, 0.04317421f, 0.11255383f, -0.07835364f, 0.01140308f, -0.05999798f, 0.11249518f, 
    -0.09152042f, -0.08961046f, -0.03268591f, -0.04673788f, -0.04667941f, 0.19126688f, 0.07377927f, 0.11141416f, 
    0.13343152f, -0.00841386f, 0.19770852f, -0.17196143f, 0.05535424f, 0.12211891f, 0.14704561f, 0.04023769f, 
    -0.05925988f, -0.05384370f, 0.08195603f, -0.02485183f, 0.06987219f, 0.10714577f, -0.04762753f, 0.01857801f, 
    -0.00917529f, -0.13403223f, 0.03843084f, -0.04700016f, -0.09885241f, -0.02204268f, -0.00616093f, -0.07665095f, 
    0.21492335f, -0.08039649f, 0.29376429f, 0.20674486f, 0.10403624f, 0.03099199f, -0.00813840f, -0.00951323f, 
    -0.04342785f, -0.13404360f, 0.14981796f, 0.00645420f, -0.22715083f, -0.11087245f, -0.01247800f, 0.05806764f, 
    -0.22622631f, 0.06521495f, 0.06178395f, 0.01740092f, 0.05537757f, 0.09800579f, 0.07714510f, 0.01027238f, 
    -0.04724746f, 0.04230624f, -0.10926320f, 0.05464944f, 0.02182980f, -0.09006134f, -0.07007912f, -0.11830822f, 
    -0.01536353f, 0.06455649f, 0.00152567f, 0.08238778f, -0.14134024f, -0.02498343f, 0.21892890f, -0.02862853f, 
    0.08612961f, 0.01163991f, 0.06860514f, -0.05512087f, 0.10519779f, 0.05379333f, 0.04639370f, -0.07036482f, 
    -0.18748663f, 0.17649111f, 0.03111151f, -0.06333854f, -0.08261080f, 0.04299952f, -0.08151229f, -0.13315499f, 
    0.11359782f, -0.12229428f, 0.00630835f, 0.13540080f, 0.10861582f, -0.08452780f, -0.10685503f, 0.05868496f, 
    0.01812200f, 0.08592680f, 0.14859509f, -0.11441305f, -0.16112746f, 0.00576649f, -0.08543634f, -0.10118446f, 
    -0.05994232f, -0.06638160f, 0.16539088f, -0.09505374f, 0.07751918f, -0.16222616f, 0.11422952f, 0.12435073f, 
    -0.01916265f, 0.04097763f, 0.11830334f, -0.06302029f, -0.07020758f, 0.15471594f, -0.05181914f, 0.20629361f, 
    0.05453629f, -0.10228892f, 0.41533208f, -0.31968370f, -0.17044502f, 0.10428739f, -0.02139618f, 0.18435660f, 
    0.17099512f, -0.23611119f, 0.05747379f, 0.30281073f, -0.01661654f, 0.11202913f, -0.07283613f, 0.31908122f, 
    0.01189681f, -0.18988729f, 0.09941476f, 0.00271151f, -0.04471756f, -0.01071338f, -0.05603709f, -0.10055533f, 
    -0.03109471f, 0.14941683f, 0.06049143f, -0.06867810f, -0.09083591f, -0.13462740f, -0.10740396f, -0.00090514f, 
    0.14179631f, 0.06614169f, -0.20750038f, -0.13328870f, -0.04756903f, 0.02656024f, 0.08894955f, -0.02578125f, 
    -0.17654710f, 0.06226728f, -0.08110677f, -0.07507423f, 0.48218596f, -0.16339827f, 0.19170474f, 0.10884824f, 
    -0.00803808f, -0.09193830f, 0.10120273f, 0.05299723f, -0.08059676f, 0.11480362f, 0.02431160f, 0.02048571f, 
    -0.10769706f, 0.20019783f, -0.03209144f, 0.30477798f, -0.06560243f, -0.02965118f, 0.00747442f, 0.00409971f, 
    -0.07818502f, 0.01983386f, -0.02040700f, -0.06907846f, 0.17281978f, -0.28302467f, -0.36157846f, 0.22987536f, 
    -0.02182696f, 0.09480091f, 0.13934480f, -0.08725264f, 0.11983845f, 0.04516903f, 0.09838428f, 0.02695780f, 
    -0.12203333f, 0.02171404f, 0.00761712f, -0.02535365f, 0.11843687f, -0.03334886f, 0.10389790f, 0.18097439f, 
    0.00866624f, -0.09244368f, 0.04314853f, 0.03308141f, 0.18220314f, -0.07304439f, 0.19613616f, -0.03620625f, 
    -0.01932305f, -0.00498645f, -0.03493875f, 0.24271628f, -0.08820172f, -0.01043603f, 0.00443045f, 0.05810808f, 
    0.05528259f, 0.05065993f, -0.18894455f, -0.03816868f, -0.11695369f, -0.08887379f, -0.01043216f, -0.07384239f, 
    -0.08272482f, -0.02791458f, -0.00618635f, 0.08678611f, -0.13615324f, 0.16095556f, -0.07119090f, -0.06657176f, 
    -0.06466422f, -0.07527762f, 0.05296375f, -0.07374355f, -0.01202633f, -0.09664375f, -0.03290185f, 0.04726516f, 
    0.08612532f, 0.02099338f, -0.14790325f, 0.11727978f, 0.02948109f, -0.05207089f, 0.04133078f, 0.07980210f, 
    0.05608336f, 0.11130869f, 0.03533438f, -0.02837699f, -0.05479362f, -0.02209137f, -0.04307181f, 0.07012677f, 
    0.14738236f, 0.09192637f, 0.04677426f, -0.07680007f, 0.06331279f, 0.04382315f, 0.00271019f, 0.12690717f, 
    0.05518505f, 0.10952727f, 0.05471879f, 0.01519534f, -0.05745658f, 0.03895880f, -0.05546762f, -0.05088548f, 
    0.09219007f, 0.02400403f, 0.05340239f, -0.03361742f, 0.34560311f, 0.11096089f, -0.22653641f, -0.08219528f, 
    -0.17972104f, 0.07987433f, -0.16269277f, -0.22257225f, 0.01159537f, 0.12202332f, 0.05925329f, -0.09963357f, 
    -0.08587092f, 0.12442943f, 0.29439455f, 0.06062162f, -0.05660333f, -0.02531935f, -0.08425946f, -0.04739530f, 
    0.04282783f, 0.02996123f, -0.07333843f, -0.02241525f, 0.06132868f, 0.04510753f, -0.17675932f, 0.07857049f, 
    0.03084270f, -0.02502436f, 0.08839571f, -0.10610475f, 0.03056119f, 0.03618172f, -0.05731339f, -0.02752734f, 
    0.11939373f, 0.02428949f, 0.08736312f, -0.10353789f, 0.04625370f, 0.09113941f, -0.09671267f, -0.06662241f, 
    0.01344109f, -0.03941965f, 0.02995487f, 0.04062103f, -0.03427058f, 0.00921599f, 0.07508876f, 0.03458934f, 
    -0.05719169f, 0.02124399f, 0.02370416f, -0.04228932f, 0.09635867f, 0.17893428f, 0.05505689f, 0.09092899f, 
    -0.01317901f, 0.07862076f, -0.04883535f, -0.01723457f, 0.11627128f, 0.02539350f, 0.10026296f, 0.07557941f, 
    0.01683898f, 0.17678395f, 0.00396414f, 0.06836998f, 0.27595797f, -0.16596106f, -0.22706063f, 0.28609249f, 
    -0.16311595f, -0.18711852f, -0.06701434f, 0.32572898f, -0.08000639f, 0.07400069f, 0.00390416f, 0.06365929f, 
    -0.29621896f, -0.12783916f, 0.01195867f, 0.22128169f, 0.03178220f, -0.00095662f, -0.05217373f, -0.06674670f, 
    0.03316633f, -0.04118254f, -0.02210444f, 0.01058482f, -0.24432342f, -0.07679083f, -0.31214708f, -0.02271351f, 
    0.00185920f, 0.10567404f, 0.09650055f, 0.01687974f, 0.00269683f, 0.02452464f, -0.04117260f, 0.08523093f, 
    -0.11604436f, 0.04301829f, 0.08836838f, -0.00482178f, -0.16249856f, -0.07918110f, -0.02703634f, -0.04949077f, 
    -0.07901891f, 0.13503440f, 0.02116975f, -0.01843371f, -0.06041983f, -0.03462858f, -0.09167860f, -0.00807563f, 
    0.05696051f, -0.03451455f, -0.06537820f, 0.05614424f, -0.18924828f, -0.01238540f, -0.06975131f, -0.09002183f, 
    -0.01894681f, 0.01478114f, 0.15783508f, 0.08885078f, 0.12216227f, -0.05570113f, -0.06758070f, -0.03132277f, 
    0.10028000f, 0.06988694f, 0.06824438f, 0.11955491f, 0.01617219f, -0.09118275f, -0.36424682f, -0.28294334f, 
    -0.01228294f, 0.04803417f, 0.09878896f, -0.01374375f, 0.09011313f, 0.06005445f, 0.02087322f, 0.16888878f, 
    0.26878592f, 0.46477789f, 0.06706634f, -0.00566566f, -0.08455180f, -0.10379321f, 0.06162647f, 0.08173464f, 
    -0.01726922f, -0.01253341f, 0.03953528f, 0.05453263f, -0.06014718f, -0.15928577f, -0.02927081f, 0.14978856f, 
    0.02357180f, 0.03050124f, -0.00170086f, 0.04935849f, 0.03622320f, -0.05499278f, 0.09315556f, -0.09341083f, 
    0.15375587f, 0.15428099f, -0.05615827f, -0.14083292f, -0.06466364f, -0.11668430f, 0.08534212f, 0.07778114f, 
    0.05263293f, 0.08407910f, 0.00302260f, 0.13375759f, -0.12228859f, -0.31220374f, 0.09284211f, 0.02986672f, 
    0.01539109f, 0.09358657f, -0.14284465f, 0.06300864f, -0.01112151f, 0.03694463f, 0.11740439f, -0.00029270f, 
    -0.10989003f, -0.09389188f, -0.11627911f, 0.16687432f, -0.10142921f, 0.05008765f, 0.10717107f, 0.17635481f, 
    0.08109616f, -0.03232361f, 0.02860501f, -0.05826421f, 0.19996126f, -0.00376605f, 0.15249680f, 0.08550505f, 
    0.07013102f, 0.07884988f, 0.02239428f, 0.02307955f, 0.06734205f, 0.10630725f, -0.02469926f, 0.11350640f, 
    0.02758977f, 0.12917925f, -0.21850100f, -0.08836953f, -0.02473962f, 0.00768268f, 0.02038540f, 0.04537641f, 
    0.00269384f, -0.12653133f, 0.05036854f, -0.35897312f, 0.13237092f, -0.02030051f, 0.03578126f, 0.07466438f, 
    -0.03239018f, 0.03132161f, -0.03653610f, -0.01905700f, -0.04850576f, -0.06829687f, -0.16584630f, -0.27181339f, 
    -0.50282472f, 0.08419686f, 0.42092255f, 0.15591782f, 0.17752564f, -0.19216825f, -0.03136744f, 0.09345601f, 
    0.05181376f, 0.13254392f, 0.03140670f, -0.00241512f, -0.09545349f, 0.00350674f, -0.10108438f, 0.00825957f, 
    -0.01030144f, -0.00989674f, 0.01265691f, 0.00973423f, 0.03330501f, -0.11071926f, 0.07071974f, 0.16531087f, 
    0.28060338f, 0.27757713f, -0.04516888f, 0.04070418f, 0.04302679f, -0.05605898f, 0.04867254f, 0.03628816f, 
    0.01522018f, 0.13349144f, 0.08045985f, 0.10662497f, 0.04356754f, 0.39115560f, -0.05402546f, 0.08261146f, 
    0.00501249f, 0.09931281f, -0.00875630f, -0.00170686f, -0.03687275f, 0.13382238f, 0.02332771f, 0.05262013f, 
    0.26819667f, 0.31266013f, -0.06770351f, 0.11379239f, -0.03392377f, 0.14674148f, 0.05699106f, 0.00446137f, 
    0.10509174f, 0.09139653f, 0.01712001f, 0.11694653f, -0.16729151f, 0.11219896f, 0.23929828f, 0.07077187f, 
    -0.06714407f, 0.10784294f, 0.10603017f, -0.05201966f, -0.02622456f, 0.09026539f, 0.11884981f, -0.06842107f, 
    0.08067424f, 0.00273333f, 0.26228979f, 0.22665936f, 0.06057193f, -0.04412888f, -0.02428214f, 0.08671795f, 
    -0.00050310f, 0.02140080f, 0.17168051f, 0.09376813f, 0.24171057f, -0.32845357f, -0.28348443f, 0.00103504f, 
    -0.06436044f, 0.12205824f, 0.03514349f, 0.05533367f, 0.10422982f, 0.16456856f, -0.03703827f, 0.01391112f, 
    -0.42305940f, 0.28349161f, -0.11824275f, 0.12515247f, -0.02650096f, -0.01202950f, -0.04319832f, -0.08166867f, 
    0.03984344f, -0.03902588f, 0.09491178f, 0.03384815f, 0.25323451f, 0.00823250f, -0.04630760f, 0.09449166f, 
    0.07372967f, 0.01241111f, -0.00038049f, 0.10028256f, -0.01824229f, 0.19840932f, 0.12541953f, 0.10600065f, 
    0.53761756f, 0.19146737f, -0.20671894f, -0.10780720f, 0.15143108f, -0.10358050f, -0.03501068f, -0.08753878f, 
    -0.03337663f, 0.13260056f, 0.14167465f, -0.00897256f, -0.22047864f, 0.26836348f, -0.09410213f, 0.07054944f, 
    0.03374266f, -0.07368150f, -0.06589143f, 0.01479576f, 0.02699578f, 0.04484183f, 0.09929506f, -0.10392883f, 
    -0.19972405f, -0.17403921f, 0.09100588f, 0.05623408f, 0.10041125f, 0.06766450f, -0.03165038f, -0.06650054f, 
    0.08123756f, 0.07834234f, -0.00858305f, 0.00449219f, -0.07253295f, -0.12019937f, 0.18929258f, 0.12537816f, 
    0.03696851f, 0.02448978f, 0.01629701f, 0.02664605f, 0.03803984f, 0.07793233f, -0.01076678f, 0.09764084f, 
    -0.27603057f, 0.28091848f, 0.08165865f, 0.08219802f, 0.01763606f, 0.03690095f, -0.00256661f, 0.03853291f, 
    -0.05099001f, -0.08877293f, -0.03756828f, -0.16739239f, -0.21205854f, 0.09580327f, 0.01680727f, 0.01879060f, 
    0.01079294f, 0.04538568f, 0.00750247f, -0.03979849f, 0.07013330f, 0.10868108f, -0.14413790f, -0.17812888f, 
    -0.03455904f, -0.03982116f, -0.01598988f, -0.08852228f, 0.00820727f, -0.07250908f, -0.02945948f, 0.03342260f, 
    0.09126128f, 0.01505794f, 0.02089762f, -0.01155995f, 0.01512167f, -0.07097306f, 0.07861674f, 0.38966876f, 
    0.00173554f, 0.29418024f, -0.07200333f, 0.10684056f, 0.04901075f, -0.03271932f, 0.03342070f, 0.08490384f, 
    0.03409297f, -0.11721116f, 0.06050888f, -0.16299069f, -0.07060599f, -0.07885177f, -0.06856001f, 0.01173988f, 
    -0.06038076f, -0.07213728f, 0.01566956f, -0.24572164f, -0.16536121f, -0.10749828f, -0.18351400f, -0.25644758f, 
    -0.03933302f, -0.06543501f, 0.01898746f, -0.03821865f, 0.01530488f, -0.03974312f, 0.03625661f, -0.01049294f, 
    -0.08134171f, -0.14797178f, 0.25525478f, -0.05185441f, 0.05756070f, -0.11635563f, -0.05040293f, 0.20793425f, 
    -0.16413181f, -0.05944641f, 0.02695796f, 0.05925687f, -0.28855625f, -0.00784526f, 0.11329883f, 0.04862708f, 
    0.15151790f, 0.16127606f, 0.13748929f, 0.12686321f, 0.01083304f, 0.05004432f, -0.10142366f, 0.07507847f, 
    -0.16215289f, 0.31735972f, 0.01144785f, -0.15332861f, -0.04726519f, 0.13283914f, -0.07556754f, 0.14727642f, 
    0.04436534f, 0.04786271f, -0.01884472f, 0.11020547f, -0.26050770f, -0.38377100f, 0.03307797f, 0.05233538f, 
    0.00791958f, 0.01653934f, -0.03191101f, -0.08426265f, 0.02882722f, 0.06268367f, 0.07510681f, 0.05149431f, 
    -0.18189853f, -0.07311717f, -0.09897958f, -0.00140589f, -0.05331666f, 0.01103438f, 0.01982925f, -0.05247701f, 
    0.06258167f, 0.07818151f, 0.01970915f, -0.00388222f, 0.26525095f, -0.41028494f, -0.24777193f, 0.39032122f, 
    0.04836432f, 0.15850015f, 0.03372152f, 0.18243325f, -0.04237894f, 0.01979017f, 0.06153466f, 0.01680649f, 
    -0.01786781f, -0.06064250f, -0.11143477f, -0.08765017f, -0.03376210f, 0.07192154f, 0.11390784f, -0.01175829f, 
    0.07449405f, 0.07754969f, -0.00369009f, -0.03623160f, -0.01947986f, 0.04779466f, 0.14546639f, -0.18589841f, 
    -0.04354459f, -0.09226841f, -0.19176511f, 0.03894266f, 0.06113649f, -0.01947471f, -0.08031771f, -0.06860061f, 
    0.06200045f, -0.17561391f, 0.10880011f, 0.32490474f, 0.06138491f, 0.17043969f, 0.06834518f, -0.00532793f, 
    0.07626896f, 0.09773293f, 0.02020878f, -0.00791505f, -0.06407832f, 0.29017362f, 0.20084894f, 0.42561033f, 
    0.17492846f, -0.07100246f, 0.13085666f, 0.35012922f, 0.00737386f, -0.00392993f, 0.05194897f, 0.13113478f, 
    -0.16983940f, 0.02924828f, 0.23799446f, 0.22818220f, 0.09073523f, 0.20003566f, -0.08601760f, 0.07848879f, 
    -0.00762762f, 0.03929014f, 0.04862139f, 0.03779297f, -0.12002758f, -0.02376788f, -0.03111580f, 0.01726734f, 
    0.02643444f, -0.04320724f, -0.03367403f, 0.01241743f, -0.12999868f, -0.01853610f, -0.01932013f, -0.01126147f, 
    0.04031062f, -0.12441614f, 0.52943337f, 0.02598928f, -0.00327247f, -0.00477726f, -0.21364042f, 0.07919711f, 
    -0.05697601f, -0.18428317f, -0.04961465f, -0.11738456f, -0.48162019f, 0.16745284f, 0.18532918f, 0.17942317f, 
    -0.03187625f, 0.10622602f, -0.00632537f, 0.02344839f, 0.05051571f, -0.02965067f, 0.00927691f, 0.09908973f, 
    0.18376118f, 0.15688896f, 0.26024806f, 0.04998766f, -0.06209452f, -0.00446314f, -0.06848071f, -0.00795265f, 
    -0.00052588f, -0.03488010f, -0.02602891f, 0.08790432f, -0.31259280f, 0.07424231f, 0.16870503f, -0.01971718f, 
    0.04483648f, -0.01327108f, -0.01949387f, 0.04611732f, -0.02542242f, -0.02625516f, -0.07028496f, -0.06634752f, 
    0.03215183f, -0.01999644f, -0.00127951f, 0.09122130f, 0.08066181f, 0.11396472f, 0.09326465f, 0.19047359f, 
    0.01609429f, 0.02311926f, 0.06519757f, 0.11168603f, 0.01181383f, 0.00252799f, 0.08838048f, 0.08284549f, 
    -0.08320954f, 0.10222028f, 0.04149023f, 0.02974492f, 0.10486881f, 0.07043941f, 0.12343944f, -0.01551957f, 
    -0.06166814f, -0.11405987f, -0.00425759f, 0.12986276f, 0.03080643f, -0.02968394f, 0.10511959f, -0.00581255f, 
    0.02337687f, 0.06232538f, 0.01901784f, 0.08633213f, 0.07667585f, -0.14043847f, 0.04525486f, 0.15202954f, 
    0.14521331f, 0.18438210f, 0.10886195f, 0.08713134f, 0.00859853f, 0.06010181f, 0.03744759f, -0.00853112f, 
    -0.18885586f, -0.02872997f, 0.09009611f, 0.05535439f, -0.04265839f, -0.09710100f, 0.02565719f, -0.01579612f, 
    0.11163566f, -0.03025042f, -0.01829650f, -0.07944540f, 0.08136764f, 0.01164312f, -0.15829794f, -0.19488542f, 
    0.02117294f, -0.04227330f, 0.01478682f, -0.05155172f, 0.06706619f, 0.05428908f, 0.09288847f, 0.00543409f, 
    -0.10428797f, -0.07148405f, -0.03959734f, -0.17481066f, -0.06560136f, -0.11960725f, -0.03557568f, -0.07113755f, 
    0.03852985f, -0.04718401f, -0.14891706f, 0.12034739f, -0.25092626f, -0.24774514f, 0.03383381f, 0.18207434f, 
    -0.02716567f, -0.19856602f, 0.03204140f, -0.12968902f, 0.01357227f, 0.00115447f, -0.00175978f, -0.01643147f, 
    -0.04660960f, 0.03653179f, 0.05374769f, 0.06224854f, -0.07381733f, -0.05195189f, -0.03172936f, 0.02334520f, 
    0.10938683f, 0.00680098f, -0.10671195f, -0.08005335f, 0.05569625f, 0.07231731f, 0.23692460f, -0.04929215f, 
    -0.01024291f, -0.01605935f, -0.05392793f, 0.00029657f, 0.03008192f, -0.03621789f, 0.02951102f, -0.00746635f, 
    -0.19319710f, 0.14110444f, -0.22105925f, -0.12882602f, -0.30346730f, -0.23299509f, -0.06949854f, 0.01628344f, 
    -0.11117043f, 0.02073912f, -0.08288839f, -0.06360435f, -0.22835383f, -0.08489218f, -0.14589298f, -0.14103718f, 
    -0.11919368f, -0.11777182f, -0.09136528f, -0.05015058f, 0.00351630f, 0.07675320f, 0.05127045f, -0.04044151f, 
    -0.17806017f, -0.17721681f, 0.04528961f, 0.14528921f, 0.06509195f, 0.15730956f, -0.09284834f, 0.14077859f, 
    0.02816072f, 0.12616023f, 0.13808990f, 0.08055468f, -0.50853616f, 0.05691498f, 0.11893100f, 0.38094470f, 
    0.13048580f, 0.03770354f, -0.04114573f, -0.04003510f, 0.01482488f, -0.10094789f, 0.04810988f, 0.14303975f, 
    -0.01513841f, -0.02180977f, -0.01599126f, -0.02366337f, 0.00079654f, 0.00869521f, 0.02992288f, 0.00818284f, 
    -0.03204580f, 0.00343559f, 0.00878748f, -0.01489281f, -0.03849983f, -0.02192943f, -0.02000709f, -0.01806365f, 
    -0.01815728f, -0.02863981f, 0.01240775f, 0.00856658f, -0.01689180f, -0.02506454f, -0.00086389f, 0.01535631f, 
    -0.01148862f, 0.00257162f, -0.04040244f, -0.00697322f, -0.01165056f, 0.02793135f, -0.00391016f, -0.02029514f, 
    -0.04133381f, -0.01242126f, -0.02236614f, -0.02266258f, 0.01119858f, 0.00552027f, -0.03887372f, -0.00658745f, 
    -0.02371639f, 0.02804555f, 0.01144895f, -0.03320474f, -0.02401098f, -0.02508544f, -0.03025937f, -0.01030627f, 
    0.02933941f, -0.01070283f, -0.01424966f, -0.01776922f, 0.00757770f, 0.01156245f, 0.02119904f, 0.00371171f, 
    -0.02588458f, -0.02330448f, 0.02932258f, -0.02799795f, -0.02910912f, -0.02570640f, 0.02342669f, 0.01745222f, 
    0.00540149f, 0.01156940f, 0.00862800f, -0.01206147f, -0.01760274f, -0.00469653f, -0.03562202f, 0.01132238f, 
    -0.02535280f, -0.00849464f, -0.01763878f, 0.00564698f, 0.01575814f, 0.01043439f, 0.02611039f, -0.03990117f, 
    -0.00743263f, -0.02015473f, -0.03594105f, -0.00722062f, -0.03598990f, 0.01313679f, -0.02854278f, -0.00762978f, 
    0.00423619f, -0.01389085f, 0.00321049f, 0.02925859f, -0.02095147f, -0.01628587f, 0.02381736f, -0.02467655f, 
    0.01502783f, 0.00071137f, 0.02646185f, -0.01923363f, -0.00809283f, -0.00020939f, -0.01024881f, -0.02344918f, 
    0.01476931f, -0.00992596f, 0.02051634f, 0.02380063f, -0.00512219f, 0.00341639f, 0.01400395f, -0.02102068f, 
    -0.02286180f, -0.03008344f, -0.02891775f, 0.02000574f, -0.03002910f, 0.00223849f, -0.01791804f, -0.01843368f, 
    0.02438252f, -0.00422471f, 0.02278055f, -0.04140029f, -0.02138203f, -0.03775753f, 0.02735463f, -0.00613979f, 
    -0.03016849f, -0.03921625f, 0.02993659f, 0.01760479f, -0.03162699f, -0.02902777f, 0.02977573f, 0.01711417f, 
    0.02574022f, -0.03960427f, 0.01032074f, 0.00381496f, -0.02655036f, -0.01370942f, -0.03963900f, -0.01481584f, 
    0.03546395f, 0.02178511f, 0.01749580f, -0.03785563f, -0.04063914f, 0.01760004f, 0.01602579f, -0.00859780f, 
    -0.03658415f, -0.04025758f, 0.00172362f, -0.02593839f, 0.02969579f, 0.01467589f, 0.02167770f, -0.01647505f, 
    -0.01961730f, -0.03196344f, -0.02116561f, -0.01280194f, -0.00567821f, -0.01618033f, 0.01079763f, 0.01876570f, 
    0.00541775f, -0.02443136f, -0.01555882f, -0.01341257f, -0.00040813f, 0.00661514f, 0.01624888f, -0.01942853f, 
    -0.03436263f, -0.01421312f, -0.00834968f, 0.01003783f, -0.03426265f, -0.03714379f, 0.01416900f, 0.01442995f, 
    -0.03223929f, -0.01231623f, -0.01305135f, 0.00081853f, 0.00966052f, 0.02742406f, 0.02779387f, 0.02117289f, 
    0.01839878f, 0.00191620f, 0.03127087f, -0.01495050f, -0.00600690f, -0.03824789f, -0.03879181f, 0.01158177f, 
    -0.04065245f, -0.03997469f, -0.03367892f, 0.01025912f, -0.03408271f, -0.03132958f, 0.00036376f, -0.03264559f, 
    0.01650987f, 0.02471074f, 0.01297210f, 0.02584172f, 0.00221557f, 0.00283194f, 0.01768973f, 0.01272220f, 
    0.00312137f, 0.01282581f, -0.03174711f, 0.01990432f, -0.01780655f, 0.02579216f, -0.00150090f, 0.01256213f, 
    -0.04056619f, 0.01697071f, -0.01562165f, 0.01021723f, 0.00564208f, 0.02988970f, 0.00863967f, 0.01759456f, 
    -0.03788621f, -0.00295276f, -0.01883479f, 0.01218235f, -0.00694604f, -0.03778657f, -0.03333834f, 0.00464213f, 
    -0.03982586f, 0.02139708f, -0.01615863f, -0.00552547f, -0.02201051f, 0.00759597f, -0.01512190f, 0.00921289f, 
    -0.03639521f, -0.00649200f, 0.02287609f, -0.01293888f, -0.01017732f, 0.02049642f, 0.01542959f, -0.02706549f, 
    0.01633161f, -0.02804854f, 0.02145769f, -0.03714545f, -0.00378327f, -0.02947959f, 0.01012803f, -0.03215821f, 
    -0.04013850f, 0.02969401f, 0.01254902f, 0.01249854f, -0.02885950f, 0.00365454f, 0.00534838f, -0.03137107f, 
    -0.00443174f, 0.03342590f, 0.02624095f, 0.02110769f, -0.03658988f, -0.01307513f, 0.02363157f, -0.01846555f, 
    -0.03517649f, 0.02284477f, -0.00860906f, -0.03072187f, -0.03318509f, -0.01168990f, -0.01632754f, -0.01173058f, 
    -0.00364727f, -0.02305518f, 0.02746596f, 0.01899224f, 0.00321560f, -0.03317435f, -0.00867921f, -0.02212586f, 
    -0.00115739f, -0.03069849f, -0.04169838f, 0.00317611f, 0.02007318f, 0.03775425f, -0.00189463f, 0.00536956f, 
    -0.03057119f, -0.00474081f, 0.01479929f, -0.02253087f, -0.03948119f, -0.01346542f, 0.01716797f, -0.03461709f, 
    -0.01108490f, -0.00496559f, -0.00419615f, 0.02234210f, -0.00802869f, -0.02383937f, 0.02418070f, 0.00215865f, 
    0.02197627f, -0.04072272f, -0.01981297f, 0.00936380f, -0.00797028f, -0.02907618f, 0.01766428f, -0.04008852f, 
    -0.00321287f, 0.01127738f, 0.02256601f, 0.00017908f, -0.00856896f, 0.01204089f, 0.00779971f, -0.00026667f, 
    -0.02554543f, 0.02795716f, 0.02117959f, -0.01573933f, 0.01893393f, 0.02481533f, 0.00804521f, -0.02864409f, 
    -0.02893073f, 0.01716711f, -0.02161922f, 0.00069701f, -0.01720045f, 0.02662930f, -0.02777106f, -0.03941438f, 
    0.01807059f, -0.03222809f, 0.00270301f, 0.02508947f, -0.02921701f, -0.01927491f, -0.03618793f, 0.00445712f, 
    0.03046172f, -0.00816610f, 0.00194812f, -0.04126996f, 0.00230762f, -0.02167794f, -0.03560740f, -0.01180458f, 
    0.02769964f, 0.00435186f, -0.01925808f, 0.01434193f, 0.02687849f, -0.03671657f, -0.03871683f, -0.02493175f, 
    -0.02552245f, 0.01447316f, -0.02545154f, 0.02875602f, -0.00795391f, -0.03391528f, -0.03112612f, 0.01311264f, 
    -0.01421057f, 0.02733566f, 0.01494906f, 0.03056622f, 0.02505562f, 0.00752309f, -0.03212741f, 0.00719305f, 
    0.00422241f, 0.00087101f, -0.01277202f, -0.00918389f, 0.02304236f, -0.02992355f, 0.02521555f, -0.00808165f, 
    -0.02711116f, 0.02063852f, -0.03313784f, 0.02707123f, 0.01599091f, -0.01700803f, 0.02740355f, -0.01502853f, 
    -0.03805093f, -0.02991894f, -0.01394443f, 0.00131973f, -0.00079888f, -0.00207399f, -0.02806731f, -0.02245002f, 
    0.00936902f, -0.00299188f, 0.02609842f, -0.02754633f, 0.00905165f, 0.02082916f, 0.02223967f, -0.00401961f, 
    -0.01208266f, -0.00950601f, 0.01005400f, -0.01269482f, -0.02511378f, -0.03556351f, -0.00947546f, -0.03492949f, 
    0.02861638f, -0.03995401f, -0.00080297f, -0.01613481f, 0.00191863f, -0.03691933f, 0.01679626f, -0.01302077f, 
    -0.04063182f, 0.02338427f, 0.02192703f, 0.01847914f, -0.03688658f, -0.00869349f, -0.01070311f, 0.01566838f, 
    -0.00454618f, 0.01706752f, -0.00053617f, -0.00895462f, 0.00344276f, 0.02113182f, 0.00504917f, -0.03817742f, 
    -0.02757342f, -0.03048485f, -0.03467900f, -0.01422232f, 0.02981470f, 0.01571036f, 0.00631532f, 0.00071561f, 
    0.02374740f, 0.00027627f, -0.02917052f, 0.02511431f, -0.00379715f, 0.03847001f, 0.00410717f, -0.00666713f, 
    -0.01375620f, -0.03231425f, -0.02997403f, -0.01993905f, -0.03938007f, -0.03544094f, -0.01768972f, 0.00267594f, 
    0.00342394f, 0.02835310f, -0.02806186f, -0.02487086f, -0.03262815f, 0.01713375f, -0.02593930f, -0.01050534f, 
    -0.00331249f, -0.02880413f, 0.01285509f, -0.02815896f, -0.02908872f, -0.02304908f, 0.01083410f, -0.02932904f, 
    -0.00199720f, -0.01677663f, 0.02433700f, -0.01458147f, 0.02171408f, -0.00773422f, -0.04031187f, -0.01470170f, 
    0.02051491f, -0.03044824f, -0.01825247f, -0.03671900f, -0.01316555f, 0.00189332f, -0.00515064f, -0.00234844f, 
    -0.02264243f, 0.00174135f, 0.02939966f, -0.03918465f, 0.02570598f, 0.02506793f, 0.02383757f, -0.03103011f, 
    -0.02504474f, -0.04179827f, 0.02296852f, 0.00406443f, -0.01115910f, 0.01866909f, -0.03216280f, 0.01317288f, 
    0.01989403f, -0.00985050f, -0.01826090f, -0.01716808f, -0.02042919f, -0.02443927f, -0.00328439f, 0.02479344f, 
    -0.03351511f, 0.02887175f, 0.02806364f, -0.03509543f, -0.00959676f, -0.02515708f, -0.03616888f, -0.03010446f, 
    0.00275202f, 0.01533788f, -0.02632380f, 0.02950002f, -0.04174148f, 0.00540394f, 0.02625931f, 0.01991514f, 
    -0.02424278f, 0.01385675f, -0.00472681f, 0.02503888f, -0.00445506f, -0.02196325f, -0.00956895f, -0.03052279f, 
    -0.03477338f, 0.02083624f, -0.02127756f, 0.01761732f, -0.03603583f, 0.02797953f, 0.01514604f, -0.00145706f, 
    -0.03328688f, -0.02729050f, 0.02069670f, 0.02532241f, -0.03350865f, -0.02024956f, -0.00411867f, -0.03652997f, 
    -0.01803779f, -0.01916923f, -0.00782146f, 0.01637437f, 0.04035481f, 0.00418245f, -0.04028789f, 0.02963590f, 
    -0.01874448f, -0.02966882f, -0.02944209f, -0.00208640f, -0.03841550f, 0.02502011f, -0.04082252f, -0.00288418f, 
    0.01955150f, 0.02968031f, 0.00641390f, -0.01929685f, -0.01264725f, -0.00445141f, 0.03739910f, 0.01266065f, 
    -0.02645215f, 0.00569674f, -0.02998817f, -0.00605495f, -0.01002109f, 0.01578627f, -0.00664815f, -0.02513839f, 
    0.00391934f, 0.01730548f, -0.00149619f, -0.00333837f, -0.01437893f, 0.00204675f, -0.01761515f, 0.01573515f, 
    -0.03753991f, -0.02458164f, -0.02938037f, 0.00859772f, -0.03540426f, 0.02952322f, 0.01637673f, -0.01088812f, 
    -0.01244339f, -0.00125017f, 0.00524503f, 0.02304757f, -0.02286231f, 0.02221689f, -0.03458418f, 0.01402619f, 
    -0.00199808f, 0.00520065f, -0.00149587f, 0.02762150f, -0.00475179f, -0.04103619f, 0.00727526f, -0.00203893f, 
    -0.03393368f, -0.00203845f, 0.03001561f, 0.02875689f, -0.03413933f, 0.01304405f, -0.01026400f, -0.01983098f, 
    -0.01955044f, -0.01880666f, -0.01423513f, -0.00789488f, -0.02369645f, -0.01019123f, -0.00487104f, -0.02821295f, 
    -0.02947554f, -0.03825233f, 0.02078307f, 0.02327266f, 0.01107785f, -0.02176922f, -0.00842500f, -0.01645738f, 
    0.00660436f, -0.00623088f, 0.01297200f, -0.02087565f, -0.02410513f, -0.00732124f, -0.01699108f, 0.01878737f, 
    0.01934481f, 0.03382429f, 0.00240612f, -0.02350103f, 0.01600485f, -0.00598358f, -0.01169008f, 0.00250968f, 
    0.01802653f, -0.00990222f, -0.00264720f, -0.03550063f, 0.00103793f, -0.02091891f, -0.00735205f, 0.00101494f, 
    -0.01918294f, 0.01129933f, 0.01519881f, -0.00877426f, 0.02213520f, -0.00168833f, 0.02930107f, 0.02564838f, 
    -0.03835055f, 0.00838494f, 0.00783608f, -0.01663384f, -0.02211221f, -0.00778863f, -0.00675825f, -0.02582584f, 
    -0.01725289f, 0.01022075f, -0.04132861f, 0.02936865f, -0.01560205f, -0.02735509f, -0.03757352f, -0.01248934f, 
    0.01866915f, -0.00844351f, 0.00149337f, 0.00499024f, -0.01840978f, 0.01795260f, 0.00625296f, -0.02690139f, 
    0.02514644f, -0.00106964f, 0.03316893f, -0.02113245f, -0.01610815f, 0.02789357f, -0.02297341f, -0.00535260f, 
    0.02431342f, -0.00402984f, 0.00688092f, 0.00854799f, -0.00214764f, 0.00378105f, 0.00544898f, -0.02956397f, 
    -0.02868417f, -0.02886585f, -0.02964029f, -0.03683661f, 0.00557268f, -0.00634780f, 0.02624140f, 0.02674810f, 
    -0.01114834f, 0.01663420f, 0.00815217f, -0.03986768f, 0.01343035f, -0.01791067f, 0.00231845f, 0.01173951f, 
    -0.01741909f, -0.01673725f, 0.01172896f, 0.02762406f, 0.02467844f, 0.00838511f, -0.03188261f, 0.01725557f, 
    -0.01677537f, -0.03796729f, -0.02078872f, 0.02025682f, 0.00681199f, 0.00631450f, -0.01033964f, -0.03177647f, 
    -0.02414916f, -0.03345711f, -0.01557380f, -0.02695542f, -0.03278799f, -0.00169949f, 0.02207539f, -0.04186514f, 
    0.02172517f, -0.02502438f, 0.00803216f, -0.00442059f, 0.00598434f, -0.03516167f, -0.01041247f, -0.03714819f, 
    -0.03390297f, -0.03419909f, 0.02524726f, -0.02694646f, -0.01202933f, -0.04210126f, -0.03115371f, 0.02270125f, 
    0.00992697f, -0.02227434f, 0.00393115f, -0.04413231f, 0.00129139f, -0.00616474f, 0.00841110f, -0.02665219f, 
    -0.01126176f, 0.02197574f, -0.01698486f, -0.00417377f, 0.01663500f, -0.03113627f, -0.00234425f, 0.00157742f, 
    -0.02210408f, -0.00718895f, 0.01955893f, -0.00367538f, 0.01868913f, -0.03347486f, -0.02099719f, -0.03419401f, 
    -0.03157120f, -0.01069845f, -0.01310847f, -0.04164524f, -0.02841819f, -0.03300355f, 0.01825764f, 0.02779019f, 
    -0.00197392f, 0.01174806f, -0.00748785f, 0.01121095f, 0.02783201f, 0.02385467f, -0.01510783f, -0.02026396f, 
    0.02424515f, -0.03994946f, -0.00350583f, -0.00992321f, -0.02045804f, 0.01889716f, -0.00519348f, -0.01371062f, 
    -0.02838835f, -0.00660558f, -0.00551591f, 0.00916966f, 0.00768997f, -0.02441131f, -0.02420588f, -0.00795547f, 
    0.01703953f, -0.00203990f, -0.00505965f, 0.02260646f, -0.02687518f, 0.00372940f, -0.03869839f, 0.02096511f, 
    0.01987172f, 0.02065643f, -0.01588188f, -0.02799420f, 0.01440329f, -0.03611788f, -0.03832946f, -0.04185433f, 
    -0.00422401f, -0.03197289f, -0.03298577f, 0.01672510f, 0.00592803f, -0.02919575f, -0.02946869f, 0.02734335f, 
    0.02553023f, -0.02684199f, 0.00724210f, -0.00017354f, 0.00787925f, -0.00615116f, -0.02410113f, -0.01277403f, 
    -0.01142348f, 0.02324714f, -0.02864229f, 0.00632052f, 0.00795486f, -0.03094362f, -0.01107292f, -0.01127140f, 
    -0.03677918f, 0.02054013f, -0.03908672f, -0.01055222f, 0.00310941f, 0.00824443f, -0.03780054f, 0.01061576f, 
    0.02294876f, -0.00233370f, -0.03740395f, 0.02264472f, -0.03580805f, -0.01910441f, 0.02755545f, -0.00552496f, 
    -0.04251195f, -0.01469136f, -0.01194450f, 0.02627617f, -0.02679018f, -0.00526619f, 0.00595574f, 0.01499912f, 
    -0.01621485f, 0.00410367f, 0.00897726f, -0.04303635f, 0.01416665f, 0.01003324f, -0.00801869f, -0.01017529f, 
    0.00285914f, -0.03660312f, -0.00837931f, -0.00503870f, -0.00935609f, 0.02078861f, -0.02197411f, -0.02415656f, 
    0.01847755f, -0.03527748f, -0.00217113f, 0.01615863f, 0.01525960f, -0.03225721f, -0.00343461f, 0.02351691f, 
    -0.01885203f, 0.02026677f, 0.00416530f, -0.00768065f, -0.02708661f, 0.00016408f, -0.01535582f, -0.03158277f, 
    0.00056802f, -0.03010249f, -0.03300878f, 0.02090743f, 0.00535164f, -0.03837028f, -0.02239676f, -0.00163384f, 
    0.01277918f, -0.02637790f, -0.02001394f, -0.03735159f, 0.01270675f, 0.01405834f, -0.02524753f, -0.00830907f, 
    -0.02300891f, -0.03041245f, -0.00917111f, 0.01061993f, 0.02268323f, -0.03890661f, -0.00214290f, 0.00159920f, 
    -0.03443326f, -0.01621605f, -0.01736885f, 0.00379075f, 0.01954979f, -0.04253235f, 0.01692667f, 0.02731839f, 
    -0.00875735f, 0.01367311f, 0.02879978f, -0.03729967f, -0.03063750f, -0.02097363f, -0.01614770f, 0.02571241f, 
    0.02634901f, -0.02056864f, -0.03143449f, -0.03442359f, 0.01277096f, 0.01921589f, 0.00650939f, -0.01835364f, 
    -0.00004163f, 0.00038650f, 0.01374781f, -0.00338601f, -0.00154694f, -0.01979864f, 0.01820794f, -0.04306581f, 
    -0.00619919f, -0.00567767f, -0.01001622f, 0.01676843f, -0.00174106f, 0.02670244f, -0.04166656f, 0.02323546f, 
    -0.03855729f, -0.04208882f, -0.02601400f, 0.00515314f, -0.01525676f, -0.03989131f, -0.03707347f, -0.04405744f, 
    -0.01458674f, 0.02478519f, 0.00159979f, -0.01262429f, -0.03813628f, -0.03415617f, -0.00623863f, 0.02480069f, 
    -0.00424170f, -0.04333120f, 0.02189223f, -0.03648710f, 0.02855965f, -0.02769423f, -0.01733940f, -0.03243372f, 
    0.02132985f, -0.03153859f, -0.03472542f, 0.00216696f, 0.01606934f, -0.04257412f, -0.01154587f, -0.03320223f, 
    -0.03353700f, 0.01548129f, -0.01512432f, -0.01070508f, -0.02982341f, 0.01170234f, -0.02151583f, 0.00356245f, 
    -0.03081828f, -0.00457307f, -0.03407922f, 0.01212037f, 0.02487816f, -0.01396456f, -0.00739792f, 0.02455205f, 
    -0.01616452f, 0.01500492f, 0.01335633f, -0.03698251f, -0.04334623f, 0.00070055f, 0.00480295f, 0.00404073f, 
    -0.02478683f, -0.01530376f, 0.00188229f, -0.02006223f, 0.00101647f, -0.01674723f, -0.03546387f, -0.02336294f, 
    -0.00028764f, 0.01294241f, -0.02715015f, -0.00378584f, -0.03975204f, 0.02791560f, -0.00339075f, 0.01246466f, 
    0.01424784f, -0.00548943f, -0.00584614f, -0.03695332f, 0.01016317f, -0.01106477f, 0.02340289f, -0.04011831f, 
    0.01701653f, 0.00556693f, 0.00283844f, 0.00717216f, 0.01835972f, 0.01733005f, 0.00953783f, -0.03421427f, 
    -0.03974045f, 0.00466053f, 0.02395644f, -0.03453530f, 0.01597847f, -0.04402472f, -0.01096610f, 0.02199891f, 
    -0.01337553f, -0.01251829f, -0.03669992f, -0.02519276f, 0.02063216f, -0.02854804f, -0.00051467f, -0.02268544f, 
    -0.02308937f, -0.01865686f, 0.00556286f, 0.02362823f, 0.02516445f, -0.02353331f, 0.01907233f, -0.00280102f, 
    -0.03726219f, 0.01221421f, 0.00542145f, -0.02138719f, 0.02493407f, 0.01204940f, -0.00362817f, 0.00212096f, 
    -0.02305236f, 0.02276865f, 0.02645044f, -0.03916247f, -0.03697934f, -0.00203231f, 0.02287259f, 0.00298603f, 
    -0.00165410f, -0.03294346f, 0.00506560f, -0.03109896f, -0.01323756f, -0.00081434f, 0.02911628f, -0.00965369f, 
    0.01958226f, -0.02086200f, -0.01066354f, -0.00648356f, -0.01555893f, 0.01168529f, 0.01474840f, -0.02500487f, 
    -0.02974198f, 0.01093133f, -0.00996755f, -0.00697055f, -0.01380457f, 0.02203977f, -0.00767043f, -0.00230021f, 
    -0.02062108f, 0.02716270f, -0.02079737f, -0.03074036f, 0.01282257f, -0.01779915f, -0.00990417f, -0.00051610f, 
    0.01465417f, -0.00260566f, -0.00640801f, 0.01447684f, -0.02915372f, 0.01455680f, -0.03503755f, 0.01479804f, 
    -0.00745314f, -0.03409752f, 0.00165847f, -0.00071737f, -0.00432131f, -0.03747687f, -0.01639742f, 0.02425231f, 
    -0.01804116f, -0.00882005f, 0.00839054f, 0.02313414f, -0.02911207f, -0.01919091f, -0.04196028f, -0.01557692f, 
    0.01579522f, 0.02557016f, 0.00998446f, -0.02099191f, 0.01120916f, -0.00100128f, 0.00978136f, -0.01759494f, 
    0.01605500f, 0.02405089f, -0.01785653f, -0.03396977f, 0.00296286f, -0.02249709f, 0.02361235f, 0.00160001f, 
    0.00534855f, -0.03277659f, 0.01627470f, -0.00757608f, 0.00243363f, -0.01685301f, 0.01911052f, -0.01616764f, 
    -0.03906886f, -0.02625900f, -0.00239044f, -0.03726837f, -0.01399861f, -0.02872853f, -0.00738531f, -0.00554803f, 
    0.01589804f, 0.02507434f, -0.03907175f, -0.02401785f, -0.00541430f, -0.02019276f, -0.03999297f, -0.00804953f, 
    -0.03968235f, 0.01020178f, -0.02456282f, -0.01218678f, 0.01743850f, -0.04315547f, 0.02784182f, 0.02028930f, 
    -0.01545259f, -0.01539294f, -0.02231293f, -0.03719444f, 0.00841404f, 0.02503765f, -0.02345570f, -0.02698975f, 
    0.00348163f, -0.04332444f, -0.02437512f, -0.01160124f, -0.02575945f, 0.00539962f, -0.03174637f, -0.03773469f, 
    -0.00066760f, 0.01720502f, -0.01424997f, -0.03362270f, -0.03185572f, 0.00429806f, -0.01874735f, -0.04172343f, 
    0.02251863f, -0.02277573f, -0.03778820f, -0.04261997f, -0.04148002f, 0.01911207f, 0.01870828f, 0.00576631f, 
    -0.03130594f, 0.01615793f, -0.01468369f, -0.02248524f, -0.02709198f, -0.00817369f, 0.00428989f, -0.00759144f, 
    -0.02871115f, 0.00031146f, 0.01965879f, -0.01152420f, 0.02425149f, 0.02139704f, 0.02347597f, -0.03036918f, 
    -0.00114852f, -0.00400634f, 0.02693026f, -0.03710809f, -0.03459341f, -0.03297574f, -0.02689419f, -0.02548006f, 
    -0.00204731f, -0.02319431f, 0.00924219f, -0.04271770f, 0.00364528f, -0.01647889f, 0.00330226f, 0.00466722f, 
    0.01348202f, -0.00762905f, 0.02660968f, -0.01783734f, 0.01679014f, -0.01867123f, 0.02216708f, 0.01920003f, 
    0.00594538f, -0.03195232f, -0.01486432f, 0.02938837f, 0.02655123f, 0.00211384f, 0.00352602f, -0.01530768f, 
    0.00684902f, -0.00028448f, -0.03184083f, 0.02684113f, -0.00890849f, -0.02314214f, -0.03918347f, 0.02359553f, 
    0.02224454f, -0.01148188f, -0.02929548f, 0.02032049f, -0.02502703f, 0.02658230f, 0.02304848f, 0.02282673f, 
    0.00900332f, 0.02660286f, -0.00455109f, -0.01837969f, -0.03746561f, -0.01307882f, 0.00076584f, 0.02543303f, 
    0.02608262f, -0.04014205f, 0.02594320f, -0.03380495f, -0.03429335f, 0.01531033f, -0.03612218f, 0.00446254f, 
    0.01011677f, -0.00830012f, 0.00438388f, 0.00905824f, 0.02632888f, 0.00371432f, 0.02830759f, 0.01657985f, 
    -0.04336587f, 0.02681913f, -0.00975899f, 0.01133154f, -0.01672544f, -0.04124808f, -0.01043392f, 0.01056107f, 
    -0.03759588f, 0.01648851f, 0.00728415f, -0.04215328f, -0.00709683f, -0.01526694f, 0.02517259f, -0.03815502f, 
    -0.04383081f, 0.01606290f, -0.01979456f, -0.02683427f, -0.01951542f, -0.00640161f, -0.02927070f, 0.01386412f, 
    0.02155542f, 0.00493014f, 0.01592456f, 0.02696611f, 0.01201716f, -0.01427507f, -0.01985844f, -0.00761693f, 
    -0.02340771f, -0.01960598f, -0.02068341f, -0.00253076f, -0.00465131f, 0.02766591f, 0.00157907f, -0.00661859f, 
    0.02109824f, -0.00219658f, -0.01112452f, -0.01541326f, -0.03115144f, -0.01057818f, -0.00397100f, 0.01994170f, 
    -0.01386188f, -0.04132194f, 0.01114697f, -0.03839000f, -0.00686647f, -0.01503447f, 0.00112196f, 0.01528256f, 
    0.02561512f, -0.03501276f, 0.02215197f, -0.03743025f, 0.01234735f, -0.04273072f, 0.02350074f, -0.01047664f, 
    0.02143328f, 0.02276672f, -0.02378855f, -0.01477227f, -0.00219808f, 0.00642413f, -0.02374018f, 0.01869852f, 
    -0.02301284f, -0.01391060f, 0.01711429f, -0.04098343f, -0.01815447f, -0.03139966f, 0.00520256f, -0.00295482f, 
    -0.00636996f, -0.01375556f, -0.03262384f, 0.00009878f, -0.01172487f, -0.01441929f, -0.03127190f, -0.01234123f, 
    0.01138009f, 0.00196613f, -0.03925234f, 0.01123284f, -0.03825194f, -0.02693531f, -0.00094772f, -0.03731051f, 
    -0.00915693f, -0.02028645f, -0.00181332f, 0.00587035f, 0.00814260f, 0.00240318f, 0.00364573f, -0.03935421f, 
    0.02679683f, -0.02196417f, -0.00699740f, 0.02495815f, 0.01366884f, -0.01931541f, -0.02259487f, 0.00233882f, 
    0.01915315f, -0.02703251f, -0.01260738f, -0.00805153f, -0.01259152f, 0.01816945f, 0.00567142f, -0.03965070f, 
    0.00391991f, -0.02773315f, 0.01480195f, -0.00597231f, -0.00455303f, 0.02456144f, 0.01614701f, 0.02695935f, 
    0.00849009f, 0.01968005f, -0.00594463f, 0.02623906f, -0.02108421f, -0.00961381f, -0.02551677f, -0.00378846f, 
    0.02589759f, 0.00272881f, 0.01216229f, 0.02316111f, -0.03360108f, -0.01670256f, -0.03290831f, -0.03557467f, 
    -0.03959656f, -0.00232998f, 0.00903558f, -0.01485337f, -0.03114343f, 0.00841093f, 0.02424683f, 0.02174119f, 
    0.00327405f, -0.02582715f, 0.00958233f, -0.04152648f, 0.00273948f, -0.01494852f, 0.00114597f, -0.04074327f, 
    -0.03727909f, 0.00458959f, -0.00961157f, -0.00694304f, -0.02272718f, -0.02669560f, 0.00461419f, 0.01792739f, 
    -0.04185527f, -0.04075544f, 0.02436085f, 0.02297288f, 0.01223745f, -0.02393120f, 0.01522325f, -0.00920807f, 
    0.21700275f, -0.22018565f, -0.23607917f, -0.15423808f, 0.02039036f, 0.02305122f, 0.00139693f, 0.19683681f, 
    -0.04925533f, -0.05747454f, -0.13407148f, -0.13797675f, -0.03844069f, 0.20168626f, -0.12794061f, -0.31974244f, 
    -0.17177717f, 0.09854348f, 0.15474349f, 0.14201678f, -0.00326899f, 0.12035159f, 0.16632217f, -0.03685036f, 
    0.15827152f, -0.00859404f, -0.02256777f, 0.08102871f, -0.03677796f, -0.04880334f, -0.02088027f, 0.10149934f, 
    -0.16339782f, -0.01804663f, 0.03901149f, 0.11033596f, 0.12209158f, 0.06962006f, -0.12106973f, -0.17744751f, 
    -0.00808800f, 0.12886377f, 0.16475184f, 0.02805185f, 0.00877802f, -0.07842411f, -0.00264301f, -0.11923530f, 
    0.06640732f, 0.07777248f, -0.01436860f, 0.12207782f, -0.09788197f, -0.01033801f, 0.09069848f, -0.05357137f, 
    -0.03882775f, 0.01655695f, -0.02628027f, 0.04970265f, 0.20924047f, 0.03352337f, 0.08048051f, -0.14454484f, 
    -0.10497148f, -0.03227567f, 0.00093110f, 0.07034463f, -0.08145609f, 0.12787819f, 0.00921900f, -0.01748837f, 
    -0.15555389f, -0.14542267f, -0.20518543f, 0.00254479f, 0.02839115f, 0.01338536f, -0.08642721f, -0.02698904f, 
    -0.00984728f, 0.00099089f, -0.03060296f, 0.07817294f, -0.10072407f, -0.00265151f, -0.11977283f, -0.14163393f, 
    -0.00031696f, 0.12488069f, 0.10611293f, 0.04202848f, -0.05158612f, 0.09683033f, -0.04050012f, 0.05332772f, 
    0.08672317f, -0.15635501f, 0.14301245f, 0.04405594f, 0.04609998f, -0.08225174f, 0.10335410f, -0.09844171f, 
    -0.01009466f, 0.00304565f, 0.14870481f, -0.09122722f, 0.12838891f, 0.03598760f, -0.16245756f, 0.05426111f, 
    0.00527330f, -0.02979747f, 0.13300082f, 0.07099193f, 0.14118086f, -0.08118533f, -0.07715937f, 0.01485483f, 
    0.07336643f, -0.21893974f, -0.16326569f, -0.08788437f, 0.04574981f, 0.11802658f, -0.03461845f, 0.08702058f, 
    0.18962294f, 0.02618779f, -0.02783659f, -0.00921377f, -0.13999993f, 0.04605215f, 0.05000308f, -0.04993921f, 
    -0.00435313f, -0.05629143f, 0.03004559f, 0.16687748f, -0.09654985f, 0.00039667f, 0.12546158f, -0.06774546f, 
    0.07495780f, 0.03970107f, -0.01264178f, -0.01825454f, -0.09346120f, -0.04168785f, -0.01249441f, -0.08913948f, 
    -0.02310389f, -0.06159515f, -0.04190376f, -0.00727102f, -0.18200630f, 0.03270505f, 0.18196249f, 0.08667024f, 
    0.08400835f, 0.05930586f, -0.11491620f, -0.19487439f, -0.02461665f, -0.08259352f, -0.04516698f, -0.15482706f, 
    0.44098002f, -0.06746895f, -0.06900415f, -0.14622657f, -0.04587150f, 0.00560343f, -0.01222956f, 0.14888759f, 
    -0.07591807f, -0.05160615f, 0.07022386f, -0.10202272f, 0.04580742f, 0.02792238f, 0.02110540f, 0.02777857f, 
    0.04326783f, 0.07012767f, 0.05997645f, -0.03452278f, 0.00809835f, 0.08851770f, -0.04997619f, 0.11012949f, 
    0.13141178f, -0.04181326f, 0.28497598f, -0.30697089f, -0.09683069f, 0.03427679f, -0.03377879f, 0.08435667f, 
    0.00571112f, -0.03622008f, -0.05738210f, 0.08365282f, 0.16024041f, -0.04885345f, -0.02847732f, -0.10738242f, 
    0.01566919f, 0.05383085f, 0.20363601f, 0.08528332f, 0.14579090f, -0.07732923f, 0.09933101f, -0.16642484f, 
    0.16120300f, -0.35929954f, -0.00546188f, -0.24698739f, 0.01184358f, -0.19924223f, 0.18194237f, 0.07936147f, 
    -0.05782142f, 0.13106585f, 0.06648921f, -0.00870668f, 0.10199898f, 0.06710344f, -0.17715092f, 0.09477880f, 
    0.02781479f, 0.01245342f, 0.09574748f, -0.02422290f, 0.06379121f, -0.03344980f, -0.04137198f, -0.01927484f, 
    0.08881042f, -0.07686155f, 0.02307489f, -0.17953740f, -0.17165996f, 0.05911017f, -0.00266663f, -0.06624082f, 
    -0.00133635f, 0.03050627f, 0.03469256f, -0.03127273f, -0.22551788f, 0.26877141f, 0.04375030f, -0.04479637f, 
    -0.09184042f, 0.08647216f, 0.13387747f, 0.00970420f, -0.08413023f, 0.17873381f, 0.00747571f, 0.06470861f, 
    0.35797152f, -0.03674471f, 0.08616685f, 0.09602858f, -0.04234967f, -0.02116159f, 0.08428789f, 0.02846827f, 
    0.02807556f, 0.01779886f, -0.01689486f, 0.28414768f, -0.06352611f, 0.25373545f, 0.15153751f, -0.06314628f, 
    -0.21447237f, 0.07190333f, 0.12507488f, 0.18238643f, -0.09900769f, 0.00491424f, -0.04851119f, 0.00767788f, 
    -0.22226134f, -0.06290940f, 0.12606408f, 0.01107890f, -0.14808168f, 0.06130820f, 0.07657240f, 0.22097728f, 
    -0.01341336f, -0.04368272f, 0.01164370f, -0.06183927f, 0.42179516f, -0.23506790f, 0.15046364f, 0.27937999f, 
    -0.04999366f, -0.04221290f, 0.09754051f, -0.05486941f, 0.09440926f, 0.20055676f, 0.02171118f, 0.11537153f, 
    0.07541919f, 0.12060327f, -0.09406456f, -0.06788043f, 0.04729063f, 0.02075200f, -0.06715238f, -0.03243284f, 
    0.02172084f, 0.00037203f, 0.06294268f, 0.05219797f, -0.14543478f, -0.13263467f, -0.18604308f, -0.11245238f, 
    -0.03109801f, 0.03482502f, -0.12004163f, 0.05706222f, -0.10064084f, -0.02143958f, 0.06800054f, 0.10284170f, 
    0.31527156f, -0.08313096f, -0.25578070f, 0.10523447f, -0.00657842f, -0.03658018f, 0.09056639f, 0.12614152f, 
    0.09899022f, 0.01461153f, -0.16742818f, -0.04887661f, 0.14433114f, 0.01831693f, -0.04475455f, 0.03930127f, 
    0.04777912f, -0.02910076f, -0.01191828f, 0.04872075f, -0.10650618f, -0.21371274f, -0.05118135f, -0.11174692f, 
    0.40024415f, 0.07157104f, 0.24013375f, 0.08297800f, -0.02818070f, -0.02421919f, -0.04878169f, -0.02116007f, 
    0.01297042f, -0.04880100f, -0.09790911f, 0.09823925f, 0.12496632f, -0.01452664f, 0.02116621f, 0.06545279f, 
    -0.07559970f, 0.06342407f, 0.08917893f, -0.13088492f, -0.02702321f, 0.04659497f, 0.01536762f, 0.05342638f, 
    -0.01073900f, 0.04733664f, 0.02181036f, 0.04510779f, 0.00908276f, -0.02485217f, -0.01896418f, 0.01616838f, 
    0.02108292f, -0.11570849f, -0.10415095f, -0.05160549f, 0.16922696f, 0.07544368f, 0.10426878f, -0.04688583f, 
    -0.02830874f, -0.07404149f, -0.02901336f, 0.01605529f, -0.20560358f, -0.00649961f, 0.00416863f, 0.18260531f, 
    0.06959128f, -0.03661485f, -0.07615222f, 0.02625164f, 0.09195600f, 0.05267293f, 0.10189503f, -0.19402298f, 
    -0.02501894f, 0.02918790f, 0.07796810f, -0.02864354f, 0.11770485f, 0.02447346f, -0.07222097f, -0.12374366f, 
    -0.00956272f, 0.05449082f, -0.00769924f, 0.17402175f, -0.05738760f, 0.02872118f, 0.09497291f, -0.14160213f, 
    0.23949860f, -0.08316895f, 0.03457350f, 0.25873283f, 0.21014780f, -0.08011606f, -0.01833574f, -0.16903813f, 
    -0.06022054f, -0.03608258f, 0.08351289f, -0.03124033f, 0.19756664f, 0.07073332f, 0.04867977f, 0.08083506f, 
    0.01010940f, 0.11383393f, 0.04698981f, 0.00304539f, -0.01056732f, 0.02589239f, -0.03646642f, 0.07960598f, 
    0.12483256f, 0.15506445f, 0.00152846f, -0.06119910f, 0.03928575f, 0.08425067f, 0.02839630f, -0.17590959f, 
    -0.02058939f, 0.03651794f, -0.01034003f, 0.02528270f, 0.03007402f, 0.10635491f, -0.26812300f, 0.03278587f, 
    -0.09813768f, 0.13716237f, -0.08062597f, 0.00242905f, 0.02065336f, 0.05037320f, -0.09595239f, 0.05048576f, 
    0.12646422f, 0.09871431f, -0.01263790f, -0.20034079f, -0.10172914f, 0.05118584f, 0.03934038f, 0.03279388f, 
    0.02409323f, -0.00975788f, 0.09633672f, -0.00553627f, -0.05521924f, 0.03928745f, -0.10843556f, 0.07030209f, 
    0.06463203f, 0.03747103f, -0.00241485f, -0.01530569f, -0.07442102f, -0.04690189f, 0.01446826f, -0.01746999f, 
    -0.22130154f, 0.10355940f, -0.00147661f, -0.03884053f, 0.00957916f, 0.07903535f, 0.14843844f, 0.04376830f, 
    -0.03050829f, 0.08913273f, 0.10364199f, 0.10353000f, 0.16363917f, -0.00030851f, -0.26302409f, 0.09261577f, 
    -0.03611165f, -0.02561756f, -0.01903075f, 0.15477014f, -0.02153142f, 0.01292149f, 0.10742168f, -0.07021588f, 
    0.33888248f, 0.04181342f, -0.22733681f, 0.18107097f, -0.04627103f, -0.02459016f, 0.19615242f, 0.13230772f, 
    0.14060478f, -0.00855040f, 0.13107248f, -0.00208508f, -0.15086289f, -0.07299161f, -0.08301067f, -0.10221013f, 
    -0.01418316f, 0.06400206f, -0.00877203f, -0.06233053f, -0.14267193f, -0.02881959f, 0.00784970f, -0.02844293f, 
    -0.13950932f, 0.00345731f, -0.15616800f, -0.05344293f, 0.01813207f, -0.03234498f, 0.07794707f, -0.09056605f, 
    -0.06954198f, 0.03759398f, 0.00144652f, -0.01742730f, 0.51806688f, -0.09055413f, -0.32556757f, 0.10533434f, 
    0.02106707f, 0.00108754f, 0.13590975f, 0.02951381f, 0.04619211f, 0.00949238f, -0.04571851f, -0.11141882f, 
    -0.09698277f, 0.37834728f, 0.15416434f, 0.05879195f, 0.02579445f, -0.02058730f, 0.01928410f, -0.03987547f, 
    0.02677824f, -0.00606457f, 0.02479964f, 0.07626060f, 0.51224792f, -0.30224040f, -0.21028119f, -0.29565176f, 
    -0.02436656f, -0.07228439f, 0.02630347f, 0.16274978f, 0.14946084f, 0.16476132f, 0.00806914f, -0.05259922f, 
    -0.06372230f, 0.04519324f, 0.06499089f, 0.03237313f, 0.02851307f, 0.08793407f, 0.11955821f, 0.07382088f, 
    -0.01912586f, -0.02168693f, 0.11203322f, -0.03992861f, 0.07021561f, -0.20376103f, 0.01514724f, -0.07326031f, 
    0.02742171f, 0.05313865f, 0.09880819f, 0.17906266f, -0.09245223f, -0.01707173f, -0.08806626f, 0.05250769f, 
    0.08474329f, 0.07058832f, -0.07017241f, -0.08623438f, 0.10214971f, 0.04843321f, -0.07002699f, 0.13987362f, 
    -0.11291652f, 0.02687572f, 0.03135665f, 0.00386167f, -0.18051052f, 0.05460432f, 0.03876215f, -0.20388757f, 
    -0.17684111f, -0.05487076f, 0.02725116f, 0.01903400f, -0.12277069f, 0.05383752f, 0.00721180f, 0.01635080f, 
    0.12110574f, 0.03016630f, -0.06028578f, -0.16011743f, 0.17946558f, 0.06204861f, 0.02161580f, 0.02473575f, 
    0.03332139f, -0.01652728f, -0.00111869f, -0.01061129f, -0.06413740f, 0.00376101f, 0.02390961f, 0.00403981f, 
    -0.04509685f, -0.07167417f, 0.05613406f, -0.06839483f, 0.00376111f, 0.04658520f, 0.02353037f, 0.17528158f, 
    0.17012006f, 0.08849481f, 0.15055303f, 0.02490866f, -0.02387700f, 0.01085145f, -0.01506120f, -0.02007132f, 
    0.01311437f, -0.00843098f, 0.07763081f, 0.00581154f, 0.34849584f, 0.27405435f, -0.13768056f, -0.10126440f, 
    0.09374535f, 0.08870960f, -0.18860118f, 0.01212084f, -0.07305680f, -0.01928679f, -0.06650066f, -0.12162146f, 
    0.16663498f, 0.11429082f, 0.25431249f, 0.11885113f, -0.05694767f, -0.02004887f, -0.02972616f, -0.08280243f, 
    -0.02088146f, 0.14872073f, 0.01825903f, 0.01551975f, -0.07637846f, 0.17243646f, -0.07730534f, -0.01655112f, 
    -0.00610282f, 0.01422665f, -0.05446922f, -0.10434847f, 0.08847358f, 0.01724006f, -0.01502995f, 0.03792159f, 
    0.00288064f, -0.00826868f, 0.12304778f, 0.07642431f, -0.11396476f, 0.00241053f, -0.14104176f, -0.12193523f, 
    0.02705294f, -0.02706403f, 0.01690439f, -0.00980987f, 0.17056262f, 0.08931881f, 0.09365701f, 0.01866394f, 
    -0.05867979f, -0.05288474f, -0.04515934f, -0.03758311f, -0.04944282f, -0.02622242f, -0.06336906f, 0.06873448f, 
    -0.20206411f, 0.10262921f, -0.05167161f, -0.02241175f, -0.09430490f, 0.03320616f, 0.11085803f, -0.16017634f, 
    -0.06875495f, 0.08417317f, -0.01523184f, 0.07036836f, 0.03015038f, 0.22580485f, -0.19760264f, -0.11317225f, 
    -0.04626591f, -0.15750521f, 0.05052003f, 0.00911141f, -0.01817671f, 0.14068915f, -0.03497580f, 0.10900439f, 
    0.00433923f, 0.00559626f, -0.03624107f, -0.00930968f, 0.02708496f, 0.02587499f, -0.01608027f, 0.00551755f, 
    0.00763420f, -0.02660181f, 0.00843618f, -0.00808502f, 0.02479364f, 0.00219319f, -0.03723860f, -0.02984001f, 
    0.01631531f, -0.03571705f, 0.03088866f, 0.02746866f, -0.01473027f, 0.00622115f, 0.03100917f, 0.02227281f, 
    0.01052761f, 0.00823260f, -0.02207975f, -0.03816492f, 0.02562902f, 0.02792979f, 0.01794046f, -0.03756288f, 
    -0.00380690f, -0.01056246f, 0.01681953f, 0.00271467f, -0.01509125f, -0.00362640f, -0.02321918f, 0.00653961f, 
    -0.00535755f, -0.01226374f, -0.01584266f, -0.04168166f, 0.02950068f, 0.00195889f, -0.00247306f, 0.00182376f, 
    -0.01265018f, -0.03046582f, 0.02287549f, -0.03737833f, 0.00814507f, -0.01436103f, -0.00508515f, -0.02890658f, 
    -0.03069506f, -0.04040695f, -0.02554413f, 0.00401352f, 0.03030396f, -0.01522707f, 0.01452469f, -0.04104865f, 
    -0.03885835f, 0.01327442f, -0.03696395f, -0.02367868f, 0.01593570f, -0.00872422f, -0.02056739f, -0.00593370f, 
    0.02148249f, -0.01644926f, -0.00490289f, 0.01820997f, -0.00862843f, -0.02102986f, -0.03362779f, -0.02917542f, 
    -0.01441571f, 0.01335946f, -0.03792010f, -0.03226206f, -0.00134105f, -0.00190690f, 0.00841940f, -0.01914716f, 
    -0.03967642f, 0.00740930f, 0.02318875f, 0.02857592f, 0.01835296f, -0.03049460f, -0.03667478f, 0.02302362f, 
    0.02425884f, 0.03148642f, 0.01838783f, -0.02501183f, -0.01937902f, -0.02777967f, 0.01570222f, -0.02672971f, 
    -0.02131996f, -0.02466363f, -0.02262111f, 0.01812925f, 0.02079333f, 0.01969950f, -0.03642562f, 0.00817129f, 
    -0.00778617f, -0.01109599f, -0.00452313f, 0.01517113f, -0.02385902f, -0.03165959f, -0.01081990f, -0.00890328f, 
    -0.00016419f, -0.00885038f, -0.01274889f, 0.02765657f, -0.02106332f, 0.01407895f, -0.00780126f, -0.04062378f, 
    -0.00515624f, -0.01669048f, -0.01695424f, -0.03851375f, -0.04195439f, -0.04044555f, 0.02266680f, -0.03953464f, 
    -0.03693399f, -0.03812499f, -0.02160105f, -0.02503307f, 0.00386882f, -0.00080120f, -0.01449375f, -0.01968599f, 
    -0.02195773f, 0.02346736f, 0.00499226f, -0.00855954f, 0.01746705f, -0.03362748f, 0.02666948f, 0.01186652f, 
    0.01165676f, 0.00251380f, -0.01185391f, 0.02665347f, 0.00116124f, 0.01744311f, 0.00492270f, -0.03437531f, 
    0.00088081f, -0.00575194f, 0.00086246f, 0.01308900f, -0.02404160f, -0.00279885f, -0.00153946f, 0.00850271f, 
    0.01076418f, 0.00012990f, -0.02605837f, 0.00002244f, -0.01594270f, -0.02930015f, -0.00324887f, 0.01107339f, 
    0.01703890f, -0.01287110f, 0.02738216f, -0.02277344f, 0.00134696f, -0.02051841f, 0.02119762f, 0.00994620f, 
    -0.00920638f, -0.02968379f, -0.00477339f, 0.01252201f, -0.01832066f, 0.01896028f, -0.03490143f, -0.00836677f, 
    0.01063993f, -0.02018454f, 0.00131688f, 0.01097369f, 0.00981489f, -0.03999427f, -0.02877527f, -0.01775868f, 
    -0.01046414f, -0.02621023f, 0.02915652f, 0.00240398f, -0.00821091f, -0.01733497f, 0.02098935f, -0.02470842f, 
    -0.00296274f, 0.00455589f, -0.03606397f, -0.00484139f, 0.01157692f, 0.01845508f, -0.00385629f, -0.01281156f, 
    -0.00690258f, -0.00430940f, 0.02138376f, -0.02594466f, 0.00248406f, -0.01864864f, 0.02177221f, 0.00366536f, 
    -0.04114096f, -0.01483934f, -0.00704494f, 0.01501394f, 0.02406061f, -0.00111812f, -0.03586192f, 0.02211316f, 
    -0.02085724f, -0.03735827f, -0.01685503f, -0.03859427f, -0.02716818f, 0.02486241f, 0.03043436f, 0.02423167f, 
    0.00149998f, 0.00818653f, -0.02655478f, -0.02484135f, 0.02607919f, -0.01106782f, 0.00382195f, -0.02239301f, 
    0.00191405f, -0.02665892f, 0.01520981f, -0.02860267f, 0.00917030f, 0.01945870f, -0.02765910f, 0.00407160f, 
    -0.02821285f, -0.00852931f, -0.00889369f, -0.03078284f, -0.02398814f, -0.00425778f, -0.00345739f, -0.04125941f, 
    -0.04082162f, -0.03393110f, -0.03219296f, -0.02789407f, -0.02636181f, -0.00649738f, 0.01482829f, -0.00028779f, 
    0.01086254f, 0.01822093f, -0.00999936f, -0.02978278f, 0.02277019f, 0.01542888f, -0.00879535f, 0.01728316f, 
    -0.02497842f, -0.02621667f, 0.02209515f, 0.00268114f, -0.03228832f, 0.00743429f, 0.01989704f, -0.02245657f, 
    0.00410029f, 0.02288571f, 0.01551532f, -0.00351075f, 0.03194151f, -0.02816955f, -0.00633520f, -0.02698313f, 
    0.02767581f, -0.03939977f, 0.02521183f, 0.01065460f, 0.02585479f, -0.02144482f, -0.02590936f, -0.04367479f, 
    0.00084455f, -0.00083010f, 0.00687532f, -0.00711581f, -0.03877366f, 0.01620253f, -0.02473121f, 0.02621225f, 
    0.00652761f, 0.02361633f, 0.02438031f, -0.01333319f, -0.01798172f, 0.02478572f, -0.01739332f, -0.03128771f, 
    -0.01469179f, -0.00462860f, 0.01747182f, 0.00111751f, -0.01803243f, 0.00315787f, -0.01186656f, -0.01143622f, 
    0.01027825f, 0.01139355f, 0.02792410f, 0.01858939f, -0.01772841f, -0.00147321f, 0.00815710f, -0.03576229f, 
    0.00383839f, 0.02672460f, -0.01888803f, -0.03308801f, 0.00484481f, 0.00448655f, -0.03184567f, -0.00272205f, 
    -0.00197372f, -0.03965494f, 0.02852094f, -0.01841282f, 0.00951288f, 0.00285547f, 0.02559504f, -0.01690036f, 
    -0.00796721f, -0.00899036f, -0.02811288f, 0.01785740f, -0.01344833f, -0.00764240f, 0.01601026f, 0.01796031f, 
    0.01562443f, 0.02623693f, -0.02590004f, -0.04432200f, -0.01947928f, -0.02293412f, 0.02432877f, 0.02494567f, 
    -0.00978158f, -0.00245430f, -0.01052340f, -0.02930617f, -0.00257199f, -0.03541290f, 0.02774576f, 0.01767074f, 
    -0.02449118f, -0.01535051f, -0.00747410f, 0.00397285f, -0.03225340f, 0.01798576f, -0.02375000f, -0.03727057f, 
    -0.01242653f, -0.00432544f, -0.00720836f, 0.01935025f, -0.00950106f, 0.02544660f, 0.01341677f, 0.03814255f, 
    0.00648337f, -0.01557949f, -0.03545031f, -0.00549463f, 0.03109411f, -0.03903159f, -0.00217044f, 0.02059623f, 
    -0.01621143f, 0.00757334f, 0.00856747f, 0.02601737f, 0.02990054f, 0.00589770f, -0.00479432f, -0.00127199f, 
    -0.03559701f, -0.03771271f, -0.01016128f, 0.01865427f, 0.00199971f, -0.01104385f, 0.01681493f, -0.02395703f, 
    -0.02931885f, -0.02175161f, -0.04243523f, 0.03381774f, 0.02471143f, 0.00250414f, -0.03553890f, 0.01849725f, 
    0.02469696f, -0.02206376f, 0.01353763f, 0.00358549f, -0.03634344f, -0.03463210f, 0.00749919f, -0.03395227f, 
    -0.00028987f, -0.02872144f, -0.01085102f, 0.01526767f, 0.00357487f, 0.00297103f, -0.01803598f, 0.00859214f, 
    -0.02252662f, -0.00184665f, -0.02593649f, 0.01073031f, -0.04156946f, 0.00630261f, -0.02653208f, -0.01488183f, 
    0.01930222f, -0.04279548f, 0.01899575f, 0.01426548f, 0.02178277f, -0.03878146f, 0.01476818f, -0.00922551f, 
    0.02611332f, -0.00081926f, -0.00836701f, -0.01192751f, 0.01295452f, -0.00463323f, -0.01332018f, -0.03068806f, 
    -0.01250248f, 0.00036417f, -0.04125182f, 0.01835133f, 0.00119888f, 0.00055419f, -0.03035599f, 0.00187519f, 
    0.00621512f, -0.00822280f, 0.00796245f, 0.00955878f, -0.01187773f, 0.00209063f, -0.00412339f, 0.01381612f, 
    0.01499621f, 0.02165248f, 0.00309808f, 0.03586466f, 0.02907470f, 0.00913719f, -0.01686709f, -0.00363156f, 
    -0.01013986f, 0.01721497f, 0.01767304f, 0.01248319f, -0.02615331f, 0.03360453f, -0.02054928f, 0.00577887f, 
    0.00383676f, 0.01790791f, -0.00334001f, -0.01647724f, -0.01553768f, -0.02910414f, 0.02273705f, 0.03301350f, 
    -0.00852806f, 0.00821909f, -0.01184489f, -0.01231507f, 0.02265866f, 0.02698061f, 0.00772050f, -0.01075802f, 
    0.01552131f, 0.00682276f, 0.02619356f, 0.02097058f, -0.01996321f, -0.02833750f, 0.00482900f, 0.02127069f, 
    0.02712877f, -0.02762096f, -0.03733794f, 0.02567623f, -0.00256752f, 0.02039688f, 0.02261327f, 0.03183160f, 
    -0.03401747f, -0.00941832f, -0.01279832f, -0.00956466f, 0.00617671f, -0.01857926f, 0.00300422f, 0.02799028f, 
    -0.00605017f, 0.00016454f, -0.02766417f, -0.02186189f, 0.03713322f, -0.01527305f, 0.02923989f, 0.02295340f, 
    0.01637676f, 0.02024709f, -0.01352079f, -0.00699141f, 0.01773505f, 0.00953835f, -0.02228566f, 0.03208517f, 
    -0.02705130f, 0.01498790f, 0.01063375f, -0.01450811f, -0.02368008f, -0.03228853f, -0.02877112f, 0.00755854f, 
    -0.01189248f, 0.02741043f, -0.01658499f, -0.01121129f, -0.03019135f, -0.03681134f, -0.03522867f, -0.03914967f, 
    -0.01351275f, -0.02761487f, 0.00064015f, -0.04012762f, -0.00534534f, -0.04169783f, 0.01196349f, 0.00012691f, 
    0.01254777f, 0.00950916f, 0.00944240f, 0.01863450f, -0.02798015f, -0.00270559f, -0.03320452f, -0.03372648f, 
    0.01933044f, -0.03802196f, -0.02006138f, 0.00219315f, 0.00066309f, 0.01338826f, -0.01932931f, -0.02958106f, 
    0.02653545f, 0.00622524f, -0.00870814f, -0.02622968f, -0.00008481f, -0.03601920f, -0.02401507f, -0.02942695f, 
    -0.00083738f, 0.01955166f, -0.03222850f, -0.03894405f, -0.00398607f, -0.02587504f, 0.01965904f, -0.02816919f, 
    -0.02798931f, -0.03071644f, 0.01246606f, 0.01070388f, -0.03214831f, -0.03884963f, -0.00075657f, -0.04123457f, 
    0.01315530f, 0.02676873f, 0.01495421f, -0.03065019f, 0.02349513f, -0.00301537f, -0.04080242f, -0.02465655f, 
    0.01297454f, -0.02349977f, -0.03459242f, -0.04140869f, -0.01905335f, 0.00307027f, 0.01796807f, -0.02767057f, 
    0.01741043f, -0.03394454f, 0.00728942f, -0.00479816f, 0.01637627f, 0.01357704f, 0.01945819f, -0.01365782f, 
    -0.03679432f, 0.00912818f, 0.01754164f, -0.01231264f, -0.00366871f, -0.01095992f, 0.02645254f, -0.02647644f, 
    -0.02768633f, -0.04159904f, 0.00483941f, 0.02573788f, -0.02873005f, 0.01975412f, -0.01621615f, 0.02584111f, 
    0.01614764f, -0.00743863f, 0.00387940f, -0.01581806f, 0.03791202f, 0.01025352f, 0.01963438f, 0.00044156f, 
    0.01464493f, -0.03210958f, 0.02448045f, -0.03533791f, 0.02833297f, -0.00423512f, -0.03357261f, 0.01015317f, 
    -0.00136351f, -0.02536464f, 0.01576371f, 0.00873768f, -0.00081698f, 0.00020874f, -0.04157269f, -0.00402960f, 
    0.02684409f, 0.00269229f, 0.01922431f, -0.00435522f, 0.00556206f, -0.02327727f, 0.01840557f, 0.02439339f, 
    -0.01093081f, -0.00785200f, 0.02583448f, 0.00985861f, 0.00215025f, -0.03736066f, 0.00711015f, -0.03324260f, 
    0.00078891f, -0.04261797f, -0.00111831f, -0.00627316f, -0.04156545f, 0.00682748f, -0.04090471f, -0.01884823f, 
    -0.01646615f, -0.03447854f, -0.01157112f, -0.02416372f, 0.00657824f, -0.03551316f, -0.00416593f, 0.00112624f, 
    0.02461008f, 0.02778843f, -0.03063891f, 0.00131069f, -0.01282218f, -0.03170297f, 0.00549096f, 0.01061000f, 
    -0.02092825f, -0.03174258f, 0.02158091f, 0.01995776f, 0.02018178f, 0.01235582f, -0.02325827f, -0.02388615f, 
    -0.02849414f, 0.01896859f, 0.00066723f, 0.00704757f, -0.01701381f, -0.03409646f, -0.04005844f, 0.00894232f, 
    -0.02413404f, -0.00774607f, -0.01679192f, -0.03830752f, 0.00223818f, 0.01002491f, -0.01339316f, 0.00329673f, 
    -0.04038093f, -0.00598069f, 0.00845358f, -0.03035491f, 0.02059034f, 0.01126821f, -0.03532114f, -0.02342859f, 
    -0.03565576f, -0.03509016f, -0.03011932f, 0.02247615f, 0.03014773f, -0.00306681f, -0.02649905f, 0.01442596f, 
    -0.02560894f, -0.01318056f, -0.01903254f, -0.02923778f, -0.00945297f, -0.02449578f, 0.02099740f, -0.02590224f, 
    -0.07063384f, -0.24496084f, -0.25708884f, -0.00725669f, -0.07112108f, -0.01380746f, -0.03343967f, 0.11866086f, 
    -0.34599009f, -0.06638313f, -0.17169574f, -0.15076129f, -0.15850028f, 0.00460074f, -0.07562391f, -0.40038124f, 
    0.09254614f, 0.09919363f, 0.11013430f, 0.08539549f, 0.18955480f, -0.07526151f, 0.07028583f, 0.10405678f, 
    -0.00707506f, 0.06573694f, 0.02977176f, 0.14897655f, -0.03999530f, -0.09265298f, -0.07866699f, 0.05802077f, 
    -0.15651949f, 0.17711876f, 0.23185977f, 0.17784885f, -0.20213810f, 0.15695691f, -0.10143141f, -0.19658864f, 
    0.13920064f, 0.03090455f, 0.10521137f, 0.10480019f, -0.09429312f, -0.10205706f, -0.12967947f, -0.25009236f, 
    0.02176077f, 0.03687875f, 0.08327769f, 0.07973322f, -0.17618291f, -0.06617334f, 0.02622909f, -0.18889573f, 
    0.09299722f, 0.09819494f, 0.17427343f, 0.26255178f, 0.08131363f, -0.34151199f, -0.01561203f, -0.26584229f, 
    0.12410516f, 0.07177243f, 0.04659598f, -0.09484342f, 0.01385146f, 0.06019787f, 0.24454905f, -0.01692708f, 
    0.08879369f, 0.20310289f, -0.31546465f, -0.05584090f, -0.02602951f, 0.00763075f, -0.01445415f, -0.12947647f, 
    -0.01903483f, 0.05735028f, 0.06796931f, 0.11495672f, -0.22457661f, 0.00347745f, -0.15701345f, -0.09527128f, 
    0.00830036f, 0.12010704f, -0.00329621f, 0.01606090f, -0.24896868f, -0.04351323f, 0.04052649f, -0.18088338f, 
    -0.01531093f, 0.07935021f, 0.16312806f, 0.00083681f, -0.02592150f, -0.03143380f, 0.03965536f, -0.03246037f, 
    -0.03246483f, 0.02177262f, 0.18756403f, 0.09416267f, 0.04511464f, -0.03891032f, -0.14747939f, -0.07120714f, 
    0.15855096f, 0.14664643f, 0.13602030f, 0.19062984f, -0.11540538f, -0.13770850f, 0.02411136f, -0.07455157f, 
    -0.15564032f, -0.24376221f, -0.18485577f, 0.09045579f, 0.03577316f, 0.18724678f, 0.03754896f, 0.15064497f, 
    0.04572285f, 0.04365651f, 0.05685269f, -0.06381214f, 0.09173012f, -0.03956904f, 0.35006598f, -0.09672219f, 
    -0.07763199f, 0.03400759f, -0.04280857f, 0.22706987f, 0.09879427f, 0.17619963f, 0.06317765f, -0.02786300f, 
    0.15840265f, 0.43628031f, -0.25802860f, -0.14628306f, -0.07045373f, -0.02250774f, 0.01402611f, -0.17925206f, 
    -0.21142679f, -0.25404018f, -0.00169385f, -0.22545120f, 0.20541391f, -0.12524074f, 0.14759403f, 0.12165276f, 
    -0.09833596f, 0.04255295f, -0.00353112f, 0.05269915f, -0.26939479f, -0.19730465f, -0.14379209f, -0.44417366f, 
    -0.01921842f, -0.30720997f, 0.26560178f, 0.09507164f, 0.04816131f, 0.01869176f, 0.08696672f, 0.10571342f, 
    -0.02156141f, -0.00157104f, 0.07965874f, -0.05972573f, -0.14297546f, -0.03004421f, 0.02415199f, -0.03243983f, 
    -0.03667269f, -0.08853548f, -0.05060663f, -0.08330394f, 0.19860058f, 0.21570472f, 0.31519830f, 0.31713620f, 
    0.32693416f, 0.37527445f, 0.34118885f, -0.30980730f, -0.13784869f, 0.02137980f, 0.08054485f, 0.10806309f, 
    -0.02402809f, -0.00001738f, 0.12656002f, 0.09155443f, -0.10621495f, 0.50910848f, -0.16355100f, 0.00766058f, 
    0.16166575f, 0.01675114f, 0.20678250f, -0.10493294f, 0.07299061f, -0.03388084f, 0.13466445f, -0.11649989f, 
    0.25752300f, 0.28378320f, -0.28212282f, -0.15453336f, 0.06608837f, 0.10824960f, 0.32565463f, 0.25883359f, 
    0.12174716f, 0.09379687f, 0.04040726f, 0.10341521f, 0.14999312f, -0.00764139f, -0.16587880f, 0.21176402f, 
    0.05073149f, 0.07805000f, 0.17470396f, 0.02167871f, 0.00818278f, 0.07841917f, 0.25728789f, 0.00355959f, 
    0.18618533f, -0.07306131f, 0.18393102f, -0.17855686f, 0.01785782f, 0.05647112f, 0.05241237f, -0.04486496f, 
    0.06323424f, 0.04337336f, 0.11967744f, 0.18506643f, -0.04149274f, 0.08715816f, -0.18811879f, -0.19393912f, 
    0.03970418f, 0.12233150f, 0.14754379f, 0.04764531f, 0.07336152f, 0.27663633f, 0.00578406f, 0.02603252f, 
    -0.02543494f, -0.14619756f, 0.10983486f, 0.00335263f, -0.11694184f, -0.12157232f, -0.00495673f, -0.08775478f, 
    0.22669993f, 0.19917563f, 0.10167535f, 0.27273428f, 0.13496900f, 0.22401135f, -0.05286298f, -0.10318080f, 
    0.01341669f, 0.09066507f, 0.08030600f, 0.19366357f, 0.02692382f, 0.09504926f, 0.17286298f, 0.09598629f, 
    0.61548382f, -0.02209037f, 0.22987895f, -0.25020912f, 0.00110599f, 0.06642515f, 0.06034885f, 0.13678832f, 
    0.23477535f, 0.20464985f, -0.01785374f, 0.01678869f, 0.10687878f, 0.50147718f, 0.04418902f, 0.12505266f, 
    -0.00299104f, -0.02546707f, 0.05098217f, 0.00688605f, 0.02238753f, -0.00473768f, 0.02340134f, 0.15469754f, 
    -0.04242524f, -0.08945084f, -0.07716308f, -0.04918443f, 0.14697510f, 0.15685284f, 0.04031672f, -0.02613359f, 
    -0.01825238f, -0.04963718f, -0.06392299f, -0.01530928f, 0.08670048f, -0.12018234f, 0.02145305f, -0.08867298f, 
    0.02910859f, 0.12786020f, 0.01289155f, 0.07212234f, -0.01947407f, 0.04179985f, 0.03110696f, 0.09256309f, 
    0.09641740f, 0.23008250f, -0.20061623f, 0.08315268f, -0.02104555f, 0.11511672f, 0.07714721f, 0.07148021f, 
    -0.06528090f, 0.02331546f, -0.09925469f, -0.13858762f, -0.02550083f, -0.07837965f, -0.00369764f, -0.00392695f, 
    -0.06061134f, 0.05400028f, 0.01061490f, 0.05032764f, -0.06403130f, -0.07422967f, -0.25367466f, -0.25694191f, 
    0.09244864f, 0.22038747f, 0.14336434f, -0.03712816f, -0.00845315f, 0.00785083f, -0.06657007f, -0.00747639f, 
    0.22722070f, -0.04171965f, -0.02579511f, -0.00458144f, 0.13137211f, -0.16648301f, 0.14401107f, 0.19703235f, 
    -0.03946888f, 0.21622126f, -0.07184490f, -0.03877547f, -0.06552148f, 0.01486431f, 0.03097283f, 0.10955856f, 
    -0.12719426f, 0.00053009f, 0.05226601f, -0.05036725f, -0.12671001f, -0.06448659f, -0.02299605f, 0.02236697f, 
    -0.14225172f, -0.11075084f, -0.11046233f, -0.39545816f, 0.06883255f, 0.02340100f, -0.00231039f, -0.23967172f, 
    -0.09927254f, -0.07820496f, -0.09861057f, -0.07442005f, -0.12793273f, -0.06944486f, 0.01551889f, -0.01954067f, 
    -0.06063482f, -0.23756373f, 0.31029648f, -0.15170904f, 0.07725955f, -0.09505326f, 0.11819705f, -0.02577818f, 
    -0.06141591f, 0.10849202f, 0.12522236f, 0.07884284f, -0.10350339f, -0.08086906f, -0.06133364f, -0.08032927f, 
    0.08084002f, 0.13065614f, 0.04180049f, 0.10574864f, 0.09023837f, 0.05899992f, 0.04984218f, 0.00897358f, 
    0.03542230f, -0.00925046f, 0.06784458f, 0.15533993f, -0.06506224f, -0.00050498f, 0.01388512f, 0.00193046f, 
    0.05129021f, -0.05152554f, 0.08192819f, -0.01506662f, 0.07590215f, -0.06950591f, -0.12190156f, -0.04473393f, 
    -0.00612185f, 0.05173158f, -0.05146390f, -0.03643365f, 0.04333975f, -0.01010585f, -0.03839398f, 0.15436278f, 
    0.12182183f, 0.18870907f, -0.06236051f, -0.01383811f, 0.03184643f, 0.01827219f, 0.04910459f, -0.08856393f, 
    0.01156951f, -0.01442441f, -0.03128316f, 0.04380191f, 0.12217876f, -0.04887106f, -0.30993500f, 0.28186607f, 
    -0.01607083f, 0.06418080f, 0.05450612f, 0.10418674f, -0.17935181f, -0.02465888f, 0.15750001f, 0.04522147f, 
    -0.34814158f, -0.05220969f, 0.01024843f, -0.22423203f, 0.04247259f, 0.07487456f, -0.09743834f, -0.01383679f, 
    0.12126701f, -0.08901417f, 0.08237310f, -0.14955212f, -0.25065768f, -0.11949947f, 0.15272476f, -0.16664942f, 
    -0.25167584f, 0.03204558f, -0.00896347f, -0.04811358f, 0.14254549f, -0.10532345f, -0.14735724f, -0.14233305f, 
    0.04880135f, 0.00048302f, -0.07740290f, 0.05121216f, 0.17011712f, 0.14729539f, 0.13324438f, -0.06564059f, 
    0.13556807f, 0.28718084f, 0.09619890f, 0.14314857f, -0.07994076f, -0.15712680f, 0.02754339f, 0.20430344f, 
    0.12493594f, 0.06991707f, 0.20058618f, 0.12047473f, -0.05495147f, -0.02747640f, 0.19114201f, 0.06988420f, 
    -0.05198854f, 0.39415431f, -0.22529235f, 0.20296909f, 0.06747989f, 0.08636539f, 0.26064351f, -0.05677519f, 
    0.00892800f, 0.15686223f, -0.00111904f, -0.09308055f, -0.12119726f, -0.05651512f, -0.05409782f, -0.16558823f, 
    -0.03597588f, 0.06395165f, 0.09377963f, 0.01649908f, -0.12932110f, 0.05596189f, 0.09305140f, -0.02516832f, 
    -0.26174712f, -0.33205265f, 0.31711459f, -0.04543707f, -0.16528307f, -0.08552446f, 0.00487175f, 0.06852374f, 
    -0.22042598f, -0.05380598f, -0.15897149f, -0.11152195f, 0.00497734f, 0.03438574f, -0.20543419f, 0.19491990f, 
    0.06587882f, 0.20597625f, 0.13243465f, 0.04174492f, 0.10708623f, 0.08580207f, 0.05764451f, -0.03975824f, 
    -0.02206875f, 0.39532983f, 0.26088130f, 0.11075519f, -0.02946961f, -0.08344627f, -0.04753253f, -0.04556701f, 
    -0.04432541f, 0.04380715f, -0.01558171f, 0.05348155f, 0.10128579f, 0.34181756f, 0.00137765f, -0.26694733f, 
    -0.00885693f, -0.02403799f, -0.06556314f, 0.12234754f, -0.04946338f, 0.06236041f, -0.19904348f, -0.12013180f, 
    0.04522046f, -0.05482885f, 0.01295103f, -0.12374724f, -0.05570743f, 0.11383088f, -0.02716346f, 0.04995843f, 
    0.11359283f, 0.13874039f, 0.14077392f, 0.12239584f, 0.00613605f, -0.13718131f, 0.00068622f, -0.01157206f, 
    -0.08633815f, 0.21090592f, 0.11520856f, 0.17492965f, 0.05192810f, 0.12951361f, 0.12373838f, 0.02157326f, 
    0.06605408f, -0.01293460f, 0.04664979f, -0.03308110f, 0.04367108f, -0.03124505f, 0.01650844f, 0.18738887f, 
    -0.05339636f, 0.06228952f, -0.03366349f, 0.07622261f, 0.05802102f, -0.09578524f, -0.05049462f, -0.03343206f, 
    0.08027297f, 0.05372450f, 0.03651065f, 0.16532439f, -0.11296355f, 0.01882353f, 0.04261741f, -0.07257514f, 
    -0.01214975f, -0.07604980f, -0.02859835f, 0.00554876f, 0.12603362f, 0.14364272f, 0.00443985f, 0.00649284f, 
    0.03534547f, 0.02362479f, -0.17021802f, -0.11360206f, -0.02519450f, 0.05243364f, 0.02094325f, -0.14043851f, 
    0.10498232f, -0.07875583f, -0.05196756f, -0.14771527f, 0.21418235f, 0.10108213f, 0.13975926f, 0.28601354f, 
    0.03298550f, 0.09501711f, 0.06890883f, -0.00051963f, -0.09880284f, -0.02734126f, -0.06270579f, -0.09171957f, 
    0.06870367f, -0.03673566f, 0.20397040f, 0.05278030f, 0.34035951f, 0.16030543f, 0.03008436f, -0.09457202f, 
    0.08494648f, -0.01650515f, 0.04975519f, -0.09132844f, -0.13024940f, -0.02470606f, -0.16355470f, -0.07574850f, 
    0.16406055f, 0.27698231f, 0.33943629f, 0.12548392f, -0.12115084f, -0.01569806f, -0.09433915f, -0.04695947f, 
    -0.04274861f, -0.05496028f, -0.00852877f, -0.19419366f, 0.05777249f, 0.13400356f, -0.01480908f, -0.06166101f, 
    0.02221246f, -0.11817941f, -0.03961992f, -0.13713719f, 0.05102125f, 0.00485652f, 0.07944530f, 0.01956672f, 
    -0.18903515f, -0.00599526f, 0.04735834f, -0.03584310f, -0.25764549f, -0.12172770f, -0.13223706f, -0.13586701f, 
    -0.03442971f, -0.00388426f, 0.02036806f, -0.04662659f, -0.10462975f, -0.01850077f, -0.01610793f, -0.06601787f, 
    -0.16390872f, -0.03823346f, -0.12713434f, -0.11553850f, -0.00619740f, 0.12440487f, 0.05332691f, 0.03411057f, 
    -0.00765870f, 0.03543065f, -0.13468792f, 0.06262685f, 0.15631101f, 0.13083453f, -0.07337433f, -0.04493748f, 
    0.12142128f, 0.15396240f, -0.01304834f, 0.07517351f, -0.24417953f, -0.18871474f, -0.24888714f, 0.08893709f, 
    -0.00808547f, 0.09915525f, 0.06129217f, -0.12999466f, -0.09494324f, 0.16396707f, -0.00621591f, 0.17396730f, 
    -0.06986210f, -0.19108592f, 0.04607688f, 0.11819181f, 0.00282273f, 0.02985452f, 0.02948933f, 0.00412550f, 
    -0.11944562f, -0.23639727f, 0.16079105f, 0.04286913f, 0.30603895f, 0.29948553f, -0.24656670f, 0.13355841f, 
    0.01547069f, 0.02344281f, 0.08724252f, -0.06200882f, 0.27648300f, -0.10953216f, -0.23311828f, 0.03039961f, 
    -0.05462915f, -0.09712736f, 0.08061017f, -0.02154206f, -0.01368562f, 0.02279134f, -0.03508910f, -0.03146002f, 
    0.06583750f, 0.10611531f, 0.04316873f, -0.14715996f, 0.05161852f, 0.01822647f, -0.01171117f, -0.10747208f, 
    0.05355621f, 0.02574797f, -0.08371623f, -0.03816391f, 0.09467805f, 0.00738129f, 0.02421471f, 0.04488224f, 
    0.06082696f, 0.07666778f, -0.27032265f, 0.27474692f, 0.13231067f, 0.02313007f, 0.01353932f, -0.02440502f, 
    0.00268687f, -0.01248827f, 0.01875207f, 0.07774944f, -0.17678389f, 0.25663498f, -0.16871409f, -0.35383403f, 
    -0.01844229f, 0.04826019f, 0.00987769f, 0.00820757f, 0.01922867f, 0.09567118f, -0.10144566f, 0.09742659f, 
    0.13227761f, 0.03286169f, 0.59353364f, 0.03705628f, -0.06485209f, -0.01944605f, 0.05178585f, 0.03752216f, 
    0.05916392f, -0.00893829f, 0.01711079f, 0.07464663f, 0.18485852f, -0.05317312f, -0.07035919f, 0.03174415f, 
    0.07852843f, 0.03849119f, 0.06176793f, 0.02129519f, 0.09177371f, 0.05706853f, -0.12327971f, -0.04285379f, 
    -0.05221721f, 0.03648052f, -0.16568206f, 0.15464295f, -0.03189984f, 0.04015413f, -0.13292259f, 0.00620935f, 
    -0.00965524f, 0.01576763f, 0.07912851f, -0.01567291f, 0.44113708f, 0.40004903f, 0.29407963f, 0.22572535f, 
    -0.06527279f, 0.12024236f, -0.04447795f, -0.06732489f, 0.15027423f, -0.02627365f, 0.05078217f, 0.03672643f, 
    0.12463917f, -0.23104925f, -0.16679335f, -0.03681572f, 0.11104000f, 0.06803746f, 0.00581866f, 0.15025997f, 
    -0.03502842f, 0.01647777f, 0.01754727f, -0.05501871f, -0.22696310f, 0.08486300f, 0.14237837f, 0.01046266f, 
    -0.04943039f, -0.11952842f, 0.01592153f, 0.06843556f, -0.06769009f, 0.13707694f, 0.02987290f, -0.04742550f, 
    -0.00163745f, -0.14246172f, -0.02347415f, -0.12798253f, -0.00677425f, 0.01163437f, -0.07237557f, 0.02403558f, 
    -0.06896127f, -0.05543060f, -0.08210270f, -0.00435807f, -0.01300398f, 0.17327422f, -0.09130256f, -0.05342998f, 
    0.07577218f, -0.10460638f, 0.07504241f, 0.07606196f, -0.01930737f, -0.10476779f, -0.09857471f, 0.12868880f, 
    -0.07573880f, 0.39791450f, -0.28187603f, 0.37043476f, -0.01207986f, -0.01025615f, -0.04070705f, 0.17286542f, 
    -0.03259607f, 0.08085311f, -0.04267056f, -0.02954241f, 0.03485011f, -0.02245294f, 0.07501224f, -0.01303122f, 
    0.01388673f, 0.06103032f, 0.05957161f, 0.00101060f, -0.04100166f, -0.01160428f, 0.08173756f, 0.02303958f, 
    -0.11896732f, -0.42410535f, 0.19497891f, 0.04192458f, -0.00444495f, -0.03797494f, -0.03679266f, -0.06402341f, 
    0.03493894f, 0.05290634f, -0.15184206f, -0.14236467f, -0.04323310f, -0.12449972f, 0.46998203f, -0.12148640f, 
    -0.03665896f, -0.05270834f, -0.18705536f, -0.00348007f, -0.15291324f, -0.02549359f, -0.11557649f, -0.01433289f, 
    0.00353477f, 0.16029269f, 0.15105194f, 0.26016068f, -0.12725426f, -0.12113083f, -0.02437514f, -0.21618405f, 
    -0.07611758f, -0.08367206f, -0.18002027f, 0.07342244f, -0.03383591f, -0.20087212f, -0.00603266f, -0.17298184f, 
    0.05109364f, -0.04006388f, -0.10013953f, -0.06999692f, -0.03138361f, 0.04667640f, -0.06496873f, 0.14101544f, 
    -0.19494881f, 0.12622711f, 0.08211930f, 0.22313264f, 0.24587683f, 0.01308733f, -0.17254433f, -0.01814232f, 
    -0.02614341f, 0.11576197f, 0.01697187f, 0.00217398f, 0.28598270f, 0.01672085f, 0.04699761f, -0.00629804f, 
    0.02042619f, 0.10969575f, 0.09469046f, -0.02749153f, 0.19139500f, -0.09819598f, -0.10986198f, 0.02069426f, 
    0.14646199f, 0.27604133f, -0.23041147f, -0.06305966f, -0.03458489f, 0.04273712f, 0.02984208f, 0.01170190f, 
    0.00059170f, -0.06187101f, 0.04997660f, 0.05023344f, -0.00388674f, -0.04167096f, 0.21565153f, 0.05529607f, 
    -0.13440499f, 0.00024763f, 0.24811369f, -0.16820723f, 0.02666278f, -0.01552899f, -0.03193614f, 0.00881396f, 
    -0.46375921f, 0.29546699f, 0.22362687f, -0.09433489f, -0.07938257f, 0.00309718f, -0.04669758f, -0.01936748f, 
    0.02175264f, -0.03856370f, 0.03671238f, 0.19573845f, 0.12617581f, -0.08806749f, -0.04398904f, -0.07016587f, 
    0.02169934f, -0.02844569f, 0.11319458f, -0.07998209f, 0.02518442f, 0.06346877f, -0.16813642f, 0.15215771f, 
    0.42304423f, 0.43626001f, 0.33029026f, 0.43299878f, 0.15234943f, 0.12182099f, 0.02566746f, 0.09404413f, 
    0.01478467f, -0.01851529f, -0.01802592f, 0.04822913f, 0.26755691f, 0.39458060f, 0.34089723f, 0.23416638f, 
    0.02459442f, 0.08252133f, -0.00290125f, 0.17643858f, -0.02163099f, -0.03282415f, -0.05910403f, 0.04554280f, 
    0.18857631f, -0.16140097f, -0.13373536f, 0.01668939f, 0.07692800f, 0.00119515f, 0.00682851f, 0.02438947f, 
    0.06338457f, -0.13360891f, -0.01033560f, -0.12951471f, 0.00548890f, 0.10521975f, -0.17721793f, 0.05116946f, 
    0.01595976f, 0.02385052f, 0.02752823f, 0.03420145f, -0.06738874f, -0.15435347f, -0.07911122f, -0.08701067f, 
    -0.17917532f, -0.14408687f, -0.20530382f, -0.01041701f, 0.00126362f, 0.03766321f, 0.05928454f, 0.02427991f, 
    -0.11391485f, 0.01947118f, -0.12307790f, -0.09995543f, 0.23314275f, 0.29316440f, 0.15347219f, 0.31107154f, 
    0.21926935f, 0.04136861f, -0.03233710f, 0.20135854f, -0.02526164f, -0.03251611f, 0.06081847f, 0.05844564f, 
    -0.02350431f, -0.05687048f, 0.02437865f, 0.04356737f, -0.00084853f, 0.01011648f, 0.01976447f, -0.02225642f, 
    -0.02492545f, -0.13040209f, -0.05999221f, -0.02860716f, -0.03607059f, 0.01670408f, 0.00162122f, -0.02793287f, 
    -0.02026847f, -0.03383495f, 0.00140663f, 0.00425279f, 0.05949557f, 0.06115833f, -0.00680614f, 0.12956898f, 
    0.01993057f, 0.14460540f, -0.09760796f, 0.09662122f, -0.03099446f, 0.15742563f, -0.05711088f, 0.09749835f, 
    0.02957835f, 0.05845567f, -0.00858375f, -0.06022105f, -0.00437266f, 0.05211989f, 0.00190702f, -0.10495633f, 
    0.00002339f, 0.00578264f, 0.13552433f, -0.01196078f, 0.01257253f, -0.00287360f, -0.04673655f, 0.03659470f, 
    0.00825981f, 0.19401808f, -0.17695463f, 0.11266081f, -0.03178019f, 0.02527652f, 0.02583320f, 0.03443707f, 
    0.01354036f, 0.05137789f, -0.00913461f, 0.03842840f, 0.22902738f, 0.46938249f, 0.43335736f, 0.24803185f, 
    0.18540190f, 0.11087260f, 0.21787852f, 0.13019173f, 0.05758987f, 0.00381003f, 0.12501115f, 0.08332834f, 
    0.16689506f, 0.23636808f, 0.31994465f, 0.22170657f, 0.20059991f, 0.16285893f, 0.11374840f, 0.13958269f, 
    -0.00039617f, 0.06654487f, -0.00636897f, 0.01672312f, 0.24076103f, -0.00603160f, 0.51483786f, -0.01010302f, 
    0.10360772f, -0.04412835f, -0.00891010f, 0.05622793f, 0.10575909f, -0.02572877f, 0.08627047f, -0.03249373f, 
    0.19943044f, -0.10700905f, -0.21125641f, -0.09192633f, 0.04430917f, -0.00714627f, 0.06872361f, 0.04067478f, 
    0.01860184f, 0.22075455f, -0.08313777f, 0.09190173f, 0.01133633f, 0.11338603f, -0.04603131f, 0.12350342f, 
    0.03056269f, -0.10373206f, 0.06875788f, 0.01824920f, -0.00454691f, 0.14072965f, -0.00549612f, -0.01509534f, 
    0.30517569f, 0.14743318f, 0.11812256f, -0.05201671f, 0.00500289f, 0.26980439f, 0.01383185f, -0.05009453f, 
    0.00104344f, -0.11588387f, 0.08698754f, 0.08404805f, 0.05275886f, 0.35773697f, -0.18425164f, -0.02117709f, 
    -0.17870471f, 0.04684904f, -0.06755611f, -0.11398108f, 0.07370449f, 0.03777067f, 0.05562320f, -0.18662609f, 
    0.27040368f, -0.35454243f, -0.05299263f, -0.07069185f, 0.05018314f, -0.00702242f, -0.10862323f, 0.02286403f, 
    -0.13673688f, 0.00212350f, -0.07806347f, 0.11658449f, 0.06550299f, 0.05972569f, 0.05563180f, 0.07489631f, 
    0.07905609f, 0.04831758f, 0.06581757f, 0.17074454f, 0.01110852f, 0.04434785f, -0.08141463f, 0.04470950f, 
    0.09037621f, 0.21816728f, -0.08854490f, 0.26451254f, 0.05184224f, -0.04671709f, -0.07942194f, 0.00043069f, 
    0.07893610f, 0.01857303f, 0.06321718f, -0.02479066f, -0.02402591f, -0.53759098f, -0.15813145f, -0.07565527f, 
    -0.01931831f, -0.03814208f, -0.06500553f, -0.04572258f, -0.11687446f, -0.09242192f, -0.05757749f, -0.02044672f, 
    0.30567163f, -0.03710119f, -0.27976084f, 0.00311114f, 0.01407193f, -0.01229885f, 0.05834788f, 0.02448062f, 
    0.05591195f, -0.09485139f, 0.10234188f, 0.01680460f, -0.01886294f, 0.11937089f, -0.02243097f, -0.02787084f, 
    -0.05172814f, -0.03829895f, 0.21394241f, 0.00323680f, 0.04157103f, -0.07999158f, 0.00696934f, -0.04476723f, 
    0.19325182f, 0.15228358f, 0.07584727f, 0.10678390f, -0.05070430f, 0.19539228f, 0.15088351f, -0.11968148f, 
    -0.01431080f, -0.02106991f, 0.11441699f, 0.03407959f, 0.21274212f, 0.26382202f, -0.01383354f, 0.13357432f, 
    0.20219822f, 0.18041323f, 0.08877559f, -0.15268292f, 0.00598145f, 0.04108243f, 0.04115189f, 0.00092320f, 
    0.16882622f, 0.32962108f, 0.26959527f, 0.10095174f, 0.16268015f, 0.16538405f, 0.13261069f, 0.04030517f, 
    0.06238837f, 0.06210298f, 0.02611800f, 0.07516690f, 0.00949426f, 0.19467421f, 0.24411352f, 0.08762195f, 
    0.12707561f, -0.00477138f, -0.00808902f, 0.08172144f, 0.02485139f, 0.04554201f, -0.05608011f, -0.03084427f, 
    0.24098688f, 0.27867326f, 0.06633476f, 0.07223479f, 0.12433695f, 0.03188013f, 0.08552552f, 0.03690803f, 
    0.03569727f, -0.00612268f, -0.04450312f, 0.02462603f, 0.06173270f, -0.02849895f, 0.10320706f, 0.10954700f, 
    -0.05804845f, 0.05285614f, -0.00859766f, -0.04353068f, 0.03295702f, -0.00434452f, -0.03985860f, -0.05821569f, 
    0.01483832f, -0.00869662f, 0.05066678f, -0.04095892f, 0.02466203f, -0.06864493f, 0.00668219f, 0.06573382f, 
    0.11836797f, 0.12752387f, -0.07049736f, 0.11878484f, -0.05741478f, 0.14816067f, 0.11482752f, -0.08163105f, 
    0.13257462f, 0.04382083f, 0.08909658f, 0.10334193f, 0.03814212f, -0.09952141f, -0.00337224f, 0.08062297f, 
    0.06044728f, -0.32317212f, -0.22671577f, -0.07485446f, 0.03195439f, 0.01350322f, 0.03477160f, 0.06836642f, 
    -0.00938777f, 0.01338826f, -0.22283800f, 0.09275436f, 0.06464378f, 0.00171440f, -0.01205776f, 0.11408645f, 
    0.01092582f, -0.00324898f, -0.07590256f, -0.07036788f, 0.08124521f, 0.00924546f, 0.03282458f, 0.05879963f, 
    0.17080036f, 0.03291419f, -0.04808645f, 0.02035411f, 0.11731996f, 0.09635323f, -0.00807323f, 0.06156056f, 
    0.08184854f, 0.05999768f, 0.12607700f, 0.02488301f, 0.03482149f, -0.04811225f, 0.00896492f, 0.07176057f, 
    0.06726784f, -0.00593190f, 0.03943327f, 0.01389231f, 0.02892185f, 0.06102724f, 0.02887200f, 0.12488217f, 
    0.31868571f, 0.25323355f, 0.47489911f, 0.13197315f, 0.07099459f, 0.02598712f, 0.08704317f, 0.10740755f, 
    -0.03919104f, -0.00754852f, -0.07382620f, 0.00963123f, 0.61528558f, 0.55282879f, 0.32117453f, 0.19738972f, 
    0.04144272f, 0.08206923f, 0.10003636f, 0.29192951f, -0.05110110f, 0.07760122f, 0.03692928f, -0.04906250f, 
    0.02898462f, -0.00542880f, -0.00010035f, -0.00239034f, -0.02129584f, 0.01895200f, 0.00574487f, -0.01794771f, 
    0.03078251f, 0.01587476f, -0.01558599f, 0.00008114f, 0.01052448f, 0.02478163f, -0.03960647f, 0.01235856f, 
    0.00792512f, 0.03217277f, -0.01919551f, 0.00269604f, -0.01474136f, -0.03064033f, -0.00886443f, 0.00656244f, 
    -0.00050947f, 0.00857573f, -0.02071059f, -0.03481811f, 0.03075232f, -0.03609413f, 0.01038934f, -0.00236651f, 
    -0.00758365f, -0.03159222f, -0.02428761f, -0.02112688f, 0.00130367f, -0.00962975f, 0.01386629f, 0.02518826f, 
    -0.03935354f, 0.00840364f, -0.02203334f, -0.01121846f, 0.00544878f, 0.00737044f, 0.00303320f, 0.02869882f, 
    -0.00305023f, 0.02057962f, -0.03007164f, -0.00314429f, 0.01286073f, -0.01796758f, -0.02575526f, -0.01004024f, 
    0.01403371f, -0.02246154f, -0.01576391f, 0.02790513f, -0.04305081f, 0.00761633f, -0.00796964f, -0.02429951f, 
    0.01594081f, -0.02035530f, 0.00295661f, 0.01247914f, 0.00107770f, 0.00892283f, 0.01908652f, 0.00278839f, 
    -0.01709327f, -0.02793301f, 0.01470897f, -0.03224685f, 0.03899185f, -0.00975884f, -0.01625157f, -0.00169654f, 
    0.02274778f, 0.00427813f, -0.01932167f, 0.02395272f, 0.03007992f, -0.00163367f, -0.02119141f, 0.02601076f, 
    0.01322124f, -0.02636818f, -0.01993800f, 0.02011278f, -0.00273778f, -0.02629711f, -0.00936416f, -0.00900507f, 
    -0.00753896f, 0.03124008f, -0.02918968f, 0.02752692f, 0.01633110f, -0.00276180f, -0.00833600f, -0.00693937f, 
    -0.00798967f, -0.00415885f, -0.01330299f, 0.00578185f, -0.01165755f, -0.02513725f, -0.04029338f, 0.01728515f, 
    -0.01041327f, -0.01310078f, -0.04381606f, -0.00180564f, -0.02062871f, -0.02252288f, 0.01084812f, 0.01344507f, 
    0.01826784f, -0.01532294f, 0.01024749f, 0.03147824f, -0.03132007f, 0.00199015f, -0.01550776f, -0.00986599f, 
    0.01911036f, -0.02757382f, -0.01720122f, -0.01421104f, -0.03107253f, 0.02135827f, -0.00291826f, -0.00820755f, 
    0.02250254f, 0.02148051f, 0.00325841f, -0.01279586f, -0.01322738f, -0.02034846f, 0.02216882f, -0.00882324f, 
    0.01020125f, 0.03149722f, 0.01090922f, 0.01742955f, 0.01979151f, -0.03104069f, -0.02105952f, 0.02806824f, 
    0.02696652f, 0.02941292f, 0.02909551f, -0.00856765f, 0.01559919f, -0.00783123f, 0.01916965f, 0.01362108f, 
    -0.03419439f, -0.03047032f, -0.03948645f, 0.02513644f, -0.00312960f, 0.03186176f, -0.02507969f, -0.01147038f, 
    0.04319355f, -0.02178044f, -0.00382614f, 0.01417341f, 0.00615081f, 0.01170006f, 0.00523273f, -0.01666959f, 
    -0.00393761f, 0.02169790f, 0.02700882f, 0.03484482f, -0.00000330f, 0.00952922f, -0.01554846f, -0.03405823f, 
    -0.01959139f, -0.02289944f, -0.00312777f, -0.01327913f, 0.00536507f, 0.02993071f, -0.03620352f, -0.01374802f, 
    -0.00100653f, -0.00952700f, -0.03376945f, 0.01989814f, -0.03480281f, -0.02805071f, -0.03772222f, -0.01531488f, 
    -0.00544530f, 0.02552639f, 0.01349336f, 0.03359509f, 0.01741848f, 0.02500030f, -0.00501033f, -0.01607057f, 
    0.02581838f, -0.02947405f, 0.01725343f, 0.01424171f, -0.01840358f, -0.03184673f, 0.00261661f, 0.03432953f, 
    -0.00584186f, 0.00819291f, -0.00775903f, -0.03349159f, 0.00900076f, -0.01416139f, -0.02675189f, -0.03859139f, 
    -0.01640572f, 0.01078904f, -0.03158093f, 0.00480995f, 0.01602593f, 0.02225929f, -0.02122121f, 0.02727142f, 
    -0.02787745f, 0.03313981f, 0.00343536f, -0.02421818f, -0.02131889f, -0.02083713f, 0.01298807f, -0.02938966f, 
    0.00625966f, 0.01572992f, 0.02392209f, -0.02537045f, -0.03768968f, -0.02667436f, 0.00215288f, 0.01922644f, 
    0.01059315f, 0.00107703f, 0.00803728f, -0.04210285f, -0.01785422f, 0.03491888f, -0.02537719f, 0.01269689f, 
    -0.00595749f, 0.03349620f, 0.02268939f, -0.02451133f, -0.03453952f, 0.01292151f, 0.03506729f, -0.01067796f, 
    -0.01034990f, -0.02627373f, -0.02214998f, -0.00537651f, -0.00784569f, -0.01315167f, -0.04047140f, 0.00778298f, 
    0.01962216f, 0.00328867f, -0.00166357f, -0.03417200f, -0.02396695f, -0.02900714f, -0.00710424f, -0.02694195f, 
    0.01318782f, 0.01206857f, -0.02879224f, 0.02108722f, 0.02112220f, 0.01000799f, 0.01842697f, 0.00551421f, 
    0.01477738f, -0.01116997f, -0.00844198f, 0.00990064f, 0.02180814f, 0.01829073f, 0.00252294f, -0.01059446f, 
    0.02578068f, -0.01503180f, 0.02307248f, -0.00065407f, 0.01131743f, -0.00396533f, -0.03635345f, -0.00717932f, 
    0.01463348f, 0.01903089f, -0.02849058f, -0.01619469f, 0.00790347f, -0.00205054f, -0.00378827f, 0.02074521f, 
    0.03728511f, 0.00661589f, 0.02327639f, -0.00674452f, 0.02771098f, 0.01987415f, 0.00514533f, 0.02937379f, 
    -0.01621332f, 0.02733929f, -0.02222397f, 0.01966573f, -0.01595173f, -0.01615362f, 0.01636634f, -0.03267301f, 
    0.00422203f, -0.02975078f, 0.03293438f, -0.01538973f, -0.00266240f, -0.01086428f, -0.00552635f, 0.01767678f, 
    -0.01114343f, -0.03503362f, -0.02344790f, 0.00325465f, -0.02625324f, 0.01958277f, -0.01296701f, 0.00989191f, 
    -0.01488253f, -0.03163051f, -0.02080650f, 0.00484720f, 0.03725945f, 0.04001585f, -0.00750910f, -0.01846861f, 
    0.00579249f, -0.00406399f, -0.03720230f, -0.00571580f, -0.03261062f, 0.03239994f, -0.01805400f, 0.03733955f, 
    -0.03610574f, 0.01809833f, -0.02845131f, -0.01910373f, -0.02850437f, 0.01480684f, -0.02046306f, 0.01717894f, 
    -0.00326814f, 0.01913454f, 0.00535395f, 0.02986227f, 0.00650429f, -0.00066298f, -0.00903809f, 0.02660321f, 
    0.02104212f, -0.02235176f, -0.02112475f, 0.01267959f, -0.00342600f, -0.03254402f, -0.03246779f, 0.01412672f, 
    -0.01633345f, 0.01478479f, 0.00077694f, 0.00980527f, -0.00499676f, 0.00070283f, 0.02154277f, -0.01458165f, 
    -0.02695991f, 0.00726140f, 0.00143919f, 0.00914455f, 0.01247118f, -0.02848550f, -0.01701768f, 0.02219628f, 
    -0.03214205f, -0.03033250f, 0.00601571f, 0.02458576f, -0.01835049f, -0.02099418f, 0.01045777f, 0.02064394f, 
    -0.01993847f, 0.03140496f, -0.00748829f, -0.03583014f, -0.01254475f, -0.00757927f, -0.02678174f, 0.01246267f, 
    0.00686302f, 0.00381210f, 0.00736486f, 0.00032587f, -0.02433201f, -0.03214971f, -0.01609103f, -0.02183954f, 
    -0.00629244f, -0.01445445f, 0.00868335f, -0.00622635f, -0.03718882f, -0.03946422f, 0.02590118f, 0.01592059f, 
    -0.00791183f, -0.03595961f, 0.02316703f, -0.00145970f, -0.00758475f, 0.02943529f, 0.00971693f, 0.00806366f, 
    -0.01562357f, -0.01507631f, -0.03303339f, 0.02047333f, -0.00255273f, -0.02486211f, -0.02016336f, -0.03522839f, 
    -0.00598456f, 0.01010462f, -0.03417455f, 0.02878214f, 0.00684427f, -0.00523780f, -0.00840162f, -0.01074445f, 
    -0.02111442f, 0.02573374f, 0.01345226f, -0.02586439f, -0.00889259f, 0.01952754f, 0.01951249f, -0.02697185f, 
    0.02585344f, -0.01992006f, -0.04354394f, 0.00494821f, 0.00203993f, 0.00378225f, -0.01319128f, 0.00223378f, 
    0.00544646f, 0.00841586f, 0.00563579f, 0.02441297f, 0.00975903f, 0.01601565f, -0.00583563f, 0.00961610f, 
    0.01189527f, -0.02510735f, -0.00392264f, -0.03569269f, -0.01430499f, -0.02879825f, -0.02078618f, 0.01667942f, 
    0.02131435f, -0.02982551f, 0.01922687f, 0.01401802f, -0.01214184f, 0.00937608f, -0.01444323f, -0.03659916f, 
    -0.02446011f, 0.00098138f, -0.01669237f, -0.01351215f, -0.01346763f, 0.03222197f, -0.02969441f, -0.02367608f, 
    -0.02222488f, 0.00967769f, -0.01209854f, 0.02461790f, -0.01405536f, 0.01967043f, 0.00536211f, -0.03182507f, 
    -0.03268595f, -0.01705032f, -0.00474009f, -0.03685570f, -0.03604320f, 0.02907406f, 0.00756378f, -0.03399616f, 
    -0.02313679f, -0.00383162f, -0.02946392f, -0.01354388f, -0.01973135f, -0.03091011f, -0.00074296f, -0.02070501f, 
    -0.00821768f, 0.01149485f, 0.00956290f, 0.01498355f, -0.00850841f, -0.01703671f, 0.01181639f, -0.03467401f, 
    0.02713216f, 0.03224503f, 0.01133938f, 0.03079819f, -0.00855607f, -0.02305040f, 0.02139494f, 0.01272627f, 
    -0.02652490f, -0.03585227f, -0.02161656f, -0.01824515f, -0.02802978f, -0.01607862f, 0.00288111f, 0.01519171f, 
    -0.03242268f, 0.01182437f, -0.03487677f, -0.02632817f, -0.02783761f, -0.03374204f, -0.02055516f, -0.01479173f, 
    0.02032266f, -0.02888293f, -0.01484459f, 0.00181075f, 0.02206594f, 0.01023456f, -0.00581199f, 0.00437187f, 
    0.02238138f, -0.01141197f, 0.02001082f, -0.02323192f, -0.00910209f, 0.01307270f, 0.01835515f, -0.02514688f, 
    0.02268222f, -0.01460222f, -0.01840214f, 0.02545853f, -0.00126879f, -0.00799344f, -0.00803801f, 0.02008679f, 
    0.00600158f, -0.01374425f, -0.04252783f, 0.02546813f, 0.00743995f, -0.02711391f, 0.00746493f, 0.01790522f, 
    -0.03643967f, -0.02497942f, -0.00326795f, -0.04016919f, -0.00705599f, -0.03499899f, -0.00006529f, -0.01425783f, 
    0.00035348f, 0.00183664f, 0.02831120f, 0.01661845f, -0.02788879f, -0.00032054f, -0.02729641f, 0.01705253f, 
    -0.03588383f, -0.01547298f, -0.00352035f, -0.02851436f, 0.02211597f, -0.02904747f, -0.03913020f, 0.03161244f, 
    0.03125307f, -0.01483012f, 0.02226145f, 0.01276289f, 0.03128436f, 0.01341741f, -0.02888161f, -0.03666565f, 
    0.00908688f, -0.01753598f, -0.03670293f, -0.02999377f, -0.01552663f, 0.01791145f, -0.03619741f, -0.00186663f, 
    -0.01418771f, 0.01402654f, 0.01157820f, 0.01414141f, -0.03288669f, -0.00988202f, 0.00297787f, 0.02233393f, 
    0.02585132f, -0.01895083f, -0.03750150f, 0.01591685f, 0.02501999f, 0.01493384f, 0.01643039f, 0.00815265f, 
    -0.00744044f, 0.00218599f, -0.01540399f, -0.01737235f, 0.02453287f, -0.03389150f, -0.01053831f, 0.01610988f, 
    -0.00960824f, 0.00663391f, -0.03107061f, -0.03164252f, -0.00477994f, 0.00418187f, -0.01674989f, -0.00443970f, 
    -0.03993481f, 0.00983296f, 0.00512867f, -0.00469015f, -0.00023478f, -0.01842481f, -0.02537761f, 0.01651515f, 
    -0.00180955f, 0.02378368f, -0.03991834f, -0.00827747f, 0.03210407f, -0.00667676f, 0.01925620f, 0.02096554f, 
    -0.01393290f, 0.00147612f, -0.03965247f, -0.01879705f, 0.01998549f, -0.02924910f, -0.02162786f, -0.00167889f, 
    0.00951939f, -0.01396750f, -0.01128677f, 0.03221764f, -0.02324292f, 0.01615401f, -0.00486723f, -0.01698399f, 
    0.02131788f, -0.01254754f, -0.01876673f, -0.00508723f, 0.01495252f, 0.02939634f, -0.00181785f, 0.00400118f, 
    0.00702014f, -0.03087500f, -0.03315089f, 0.01163387f, -0.01673588f, -0.02615518f, -0.03003274f, 0.01975686f, 
    0.01231763f, 0.01625498f, 0.00215861f, 0.00394411f, -0.03756170f, 0.00252437f, -0.03902823f, 0.02032663f, 
    -0.01402258f, 0.00068532f, 0.00831726f, -0.01958247f, -0.03665230f, 0.01798719f, -0.00324966f, -0.03213590f, 
    -0.02964282f, 0.01192284f, -0.01188815f, -0.02109719f, 0.01784067f, 0.00297034f, -0.00290918f, -0.01994045f, 
    -0.01502616f, -0.00611779f, 0.00027115f, 0.02919703f, 0.02191792f, 0.01542798f, -0.01949472f, -0.03077782f, 
    -0.02317052f, -0.01308448f, 0.00622810f, -0.01599184f, 0.00474047f, -0.00642555f, -0.02617070f, 0.02225912f, 
    0.00604425f, -0.00507672f, 0.00776356f, -0.00033186f, -0.03268477f, -0.01428974f, -0.03652177f, 0.00546270f, 
    -0.02922834f, -0.03835658f, 0.03179749f, -0.03175880f, -0.00725707f, -0.02509485f, -0.03305699f, 0.02032284f, 
    -0.03140755f, -0.01533621f, 0.01775513f, -0.03390013f, 0.02878683f, -0.02648256f, 0.00722180f, 0.01324878f, 
    -0.00225477f, 0.00752855f, -0.03878541f, -0.03578022f, 0.00301689f, -0.00779957f, 0.02048650f, -0.04910998f, 
    -0.00321050f, 0.01027215f, -0.00612824f, 0.01968676f, -0.02208640f, -0.03333190f, 0.01103134f, 0.02732750f, 
    0.01733550f, -0.00521348f, -0.00880566f, -0.02655199f, -0.03633608f, -0.00891610f, 0.02284214f, 0.01312688f, 
    0.00559573f, -0.02266232f, 0.00892069f, -0.00065701f, 0.02907190f, 0.00783381f, -0.02969091f, 0.01462798f, 
    0.00656612f, 0.01883509f, 0.00114834f, 0.00440629f, -0.01151808f, 0.00661608f, 0.00996614f, 0.01236050f, 
    -0.01632860f, -0.00813143f, -0.02125449f, 0.00793668f, -0.04278506f, 0.00228854f, -0.02682301f, -0.01927084f, 
    -0.00513136f, 0.00052757f, -0.04185271f, -0.02590498f, 0.02236473f, -0.02669061f, -0.02937551f, -0.02870204f, 
    0.02840047f, 0.01307264f, -0.00575510f, -0.02505522f, -0.03028519f, -0.01476508f, -0.02279395f, -0.01823125f, 
    0.00442808f, 0.02559791f, 0.00587507f, 0.01002666f, 0.00567808f, -0.04803709f, 0.02417671f, -0.02377472f, 
    -0.00782075f, -0.01557019f, 0.02945255f, 0.00613089f, 0.01411973f, 0.00360360f, 0.01222681f, 0.02572394f, 
    0.02819341f, -0.00017066f, 0.01749532f, 0.00341824f, -0.00344729f, -0.05081628f, -0.01817232f, -0.03750941f, 
    -0.00012185f, 0.00183105f, -0.01435104f, -0.00712141f, 0.02513307f, -0.01119383f, 0.00459494f, 0.01268627f, 
    0.02394755f, 0.01968178f, 0.01184940f, 0.01606953f, 0.01358315f, 0.02092925f, 0.01488615f, 0.01501709f, 
    -0.01052268f, 0.00580047f, 0.02024936f, -0.02831003f, 0.01896261f, -0.03239854f, -0.00426722f, -0.02241584f, 
    0.02201987f, 0.01883334f, -0.03202659f, 0.01714492f, 0.01399473f, -0.03521091f, -0.01897075f, -0.03478178f, 
    0.01816400f, -0.03689189f, -0.00537824f, -0.00996675f, 0.00885914f, 0.01956166f, -0.03900943f, 0.01230612f, 
    0.00434600f, -0.03124226f, -0.01828825f, 0.00562136f, -0.03878270f, 0.02567940f, -0.01441156f, 0.00970673f, 
    -0.00274938f, 0.02006368f, 0.01670428f, -0.02477503f, -0.01358265f, -0.02336700f, -0.02402306f, -0.03643122f, 
    0.01363860f, -0.01279063f, 0.02017938f, -0.02640615f, -0.03888173f, -0.03689866f, -0.02273132f, 0.02016907f, 
    0.00762601f, -0.01954616f, -0.03726528f, -0.04230801f, 0.01599296f, -0.00613694f, -0.02941442f, -0.02701713f, 
    0.00270978f, -0.00107728f, -0.01520424f, -0.01846414f, -0.01076722f, -0.03046102f, -0.01370085f, -0.04800469f, 
    -0.01569476f, -0.00298387f, -0.02946157f, -0.03308241f, -0.01966650f, -0.03515744f, -0.03370490f, -0.04304786f, 
    -0.03096279f, -0.04251068f, -0.01385850f, 0.00255620f, -0.00457729f, 0.01505212f, 0.00646082f, -0.01410727f, 
    -0.00985353f, -0.04130229f, -0.03383922f, 0.01599442f, -0.00627274f, -0.03819536f, 0.01581795f, -0.00097989f, 
    -0.02008476f, 0.01227093f, 0.00663263f, 0.01155245f, 0.01995561f, -0.02692187f, -0.03292907f, 0.00442544f, 
    -0.01275254f, 0.01271485f, -0.00792729f, -0.02931016f, -0.00287456f, -0.00254309f, 0.00046728f, -0.00856397f, 
    0.00219251f, 0.01772199f, -0.02903278f, -0.01431658f, 0.01731228f, 0.01683392f, 0.03088106f, -0.00146155f, 
    -0.03506626f, -0.03054431f, 0.00680622f, -0.02480245f, 0.01232551f, 0.01127071f, 0.02062182f, 0.00677737f, 
    -0.02673625f, -0.03666185f, -0.00934415f, -0.01545478f, 0.01322219f, -0.03654649f, -0.00008306f, -0.00699347f, 
    -0.02748846f, 0.01807788f, -0.00550766f, -0.01280593f, -0.03315545f, 0.01309679f, 0.00636518f, 0.01186555f, 
    -0.00745184f, 0.01104796f, -0.02014112f, 0.00409131f, -0.02289781f, -0.03534297f, -0.01440326f, -0.04254648f, 
    -0.01385502f, -0.02889012f, -0.00427562f, -0.03154236f, 0.02653275f, 0.02282224f, -0.03355043f, -0.00320502f, 
    0.01865605f, -0.00851888f, -0.02052148f, -0.01068884f, 0.00362258f, -0.00511189f, -0.01234868f, -0.04287662f, 
    -0.00153866f, 0.00379668f, -0.00860918f, 0.01747272f, 0.02654219f, -0.00221341f, 0.00730366f, -0.01929661f, 
    0.01393623f, -0.01261626f, -0.00685245f, -0.00449374f, -0.03564250f, 0.01778494f, 0.00059498f, -0.00252438f, 
    -0.03235093f, 0.00114118f, -0.02532637f, -0.01657464f, 0.02931075f, -0.01863092f, 0.00582587f, -0.00384571f, 
    -0.01179425f, 0.01531623f, -0.01727870f, 0.01829935f, -0.01902375f, -0.02386304f, 0.00402507f, -0.02785091f, 
    0.01262088f, -0.03033381f, -0.02941670f, 0.03218257f, 0.01154411f, -0.03078715f, 0.00911967f, -0.01231581f, 
    -0.00533636f, -0.03490131f, -0.01973724f, -0.01275311f, -0.03788556f, -0.02825179f, -0.03435105f, 0.00149678f, 
    0.01390160f, -0.02541682f, 0.01296769f, -0.03824854f, -0.03265792f, -0.02047436f, 0.01660743f, -0.03025058f, 
    0.01961123f, -0.00884227f, -0.03824062f, -0.02496080f, 0.01716982f, -0.01994482f, 0.02198003f, 0.00755002f, 
    -0.00493495f, 0.00070320f, -0.00261149f, 0.01278818f, -0.00946143f, -0.00680631f, -0.03653000f, -0.04681052f, 
    -0.03330781f, -0.00954040f, 0.02681954f, 0.01966725f, -0.02815057f, -0.00548147f, -0.03394727f, -0.02012418f, 
    -0.02876944f, -0.00380032f, 0.02505097f, 0.02425775f, -0.03051276f, 0.02371794f, -0.00285891f, -0.02358669f, 
    -0.00044735f, -0.02974019f, -0.00598422f, 0.02276890f, -0.03267817f, 0.01781652f, 0.00465062f, -0.00079029f, 
    0.02522850f, 0.00705287f, -0.01183470f, -0.03443103f, 0.00186339f, 0.02639507f, 0.00297982f, 0.02364731f, 
    -0.01981507f, -0.04137172f, -0.01172570f, 0.00514558f, -0.00454130f, 0.00177218f, -0.01577504f, -0.01501416f, 
    0.03259506f, 0.02512581f, -0.03694740f, -0.02116181f, 0.03090391f, -0.04119142f, 0.00933368f, 0.00192332f, 
    -0.02193660f, -0.03409906f, -0.01732052f, -0.00154570f, -0.02035249f, -0.00363219f, -0.02519550f, -0.04172328f, 
    0.00617255f, -0.02453032f, -0.03159354f, -0.02057070f, 0.01798441f, 0.02214468f, 0.00425211f, -0.01587976f, 
    -0.00825916f, 0.00339090f, -0.00505774f, 0.00250911f, -0.04100056f, -0.01381490f, 0.00417347f, -0.04215150f, 
    -0.03569883f, 0.01686005f, -0.03432045f, 0.00568511f, -0.01927011f, 0.00759333f, -0.01487656f, -0.00599501f, 
    0.01506706f, 0.00797286f, -0.02920243f, -0.04487011f, -0.02563554f, -0.02403022f, -0.01783398f, 0.02771607f, 
    -0.00293884f, 0.02503175f, 0.00335222f, -0.04535511f, 0.01579861f, -0.03535619f, -0.03688802f, -0.00503422f, 
    0.01462880f, -0.01343514f, -0.01147325f, 0.03121865f, -0.01191740f, -0.01841180f, 0.01867244f, -0.00286156f, 
    -0.02735178f, -0.03265500f, -0.04116508f, -0.00005161f, -0.00316244f, 0.02734125f, -0.03277705f, -0.00591361f, 
    0.02996296f, -0.02486006f, -0.00119431f, -0.00089443f, -0.00089612f, -0.01255979f, 0.02765368f, -0.00159740f, 
    0.02506590f, -0.02075487f, 0.02008668f, 0.02327375f, 0.00491279f, -0.01736982f, -0.03969671f, 0.03015146f, 
    0.01742208f, -0.03377113f, 0.01487177f, -0.02681453f, 0.00029490f, -0.00192979f, 0.03048166f, -0.02151169f, 
    -0.01098526f, -0.01531812f, -0.00663998f, -0.03882154f, 0.02648022f, 0.01093306f, 0.01360099f, -0.03690393f, 
    -0.00653400f, -0.01585015f, -0.00503159f, -0.00446340f, -0.03751171f, -0.00398065f, -0.02076466f, -0.00665134f, 
    0.01244531f, -0.03800225f, -0.03322881f, -0.03894784f, -0.03803520f, -0.04706528f, -0.03448200f, -0.00757917f, 
    0.01611256f, 0.01453723f, 0.01964374f, 0.01742797f, -0.03242645f, 0.01740805f, 0.02186084f, 0.00198019f, 
    -0.01126828f, -0.01160026f, -0.02806077f, 0.02751412f, 0.00292247f, -0.01748681f, 0.02020357f, -0.01098541f, 
    0.00764979f, -0.01722552f, 0.01552994f, 0.01730460f, 0.01025736f, -0.04732093f, -0.00374697f, -0.00624948f, 
    -0.02907700f, -0.04011240f, -0.02694263f, -0.03347763f, 0.00326388f, -0.00788245f, 0.01864733f, 0.01198800f, 
    0.00660018f, -0.04033994f, -0.04398225f, -0.02923730f, 0.00210933f, 0.02981959f, 0.01551299f, -0.02434690f, 
    -0.01494639f, -0.03823433f, -0.00989769f, -0.01163656f, -0.00153483f, -0.02517939f, -0.00105039f, -0.01794396f, 
    -0.00256781f, 0.01125569f, 0.01174040f, 0.00866626f, 0.00815420f, -0.00826867f, -0.01665327f, -0.04672785f, 
    0.00621121f, -0.00968229f, -0.01654622f, -0.02005570f, -0.01005522f, 0.01353008f, -0.01053151f, 0.00058976f, 
    -0.02621625f, 0.01168605f, 0.01933204f, 0.02065363f, 0.01840157f, -0.02384680f, -0.04449977f, -0.02027832f, 
    -0.01680540f, -0.01400529f, -0.00922278f, 0.01571969f, -0.02642120f, 0.02329674f, -0.03419725f, -0.01548452f, 
    0.01200018f, -0.00865815f, -0.02954496f, -0.02849736f, -0.01824041f, -0.00305375f, 0.02680689f, -0.01099545f, 
    0.01250784f, 0.00827195f, 0.01166320f, -0.03315725f, 0.00658917f, -0.01459529f, -0.01071712f, 0.00081921f, 
    -0.00191364f, 0.01250533f, -0.00399405f, -0.03482693f, 0.00349768f, 0.00335935f, -0.02462288f, -0.01496673f, 
    -0.00169530f, -0.03996149f, -0.02990891f, 0.03099499f, -0.01798923f, -0.03680245f, -0.03057381f, -0.04696174f, 
    0.00077101f, -0.01558149f, 0.00769401f, 0.00011137f, 0.02737493f, -0.04019397f, -0.02477909f, -0.02871363f, 
    -0.03154537f, -0.03432305f, -0.03379932f, -0.00005612f, -0.03693170f, 0.02343818f, 0.01245292f, -0.02843057f, 
    -0.03915393f, 0.00127326f, 0.01915864f, -0.04644160f, 0.01416205f, -0.01169763f, -0.03144147f, -0.01732635f, 
    0.01922867f, -0.02056607f, -0.02299097f, -0.04327180f, -0.02857628f, 0.02561190f, 0.02053167f, 0.01086278f, 
    -0.03238901f, -0.00558010f, 0.02031370f, 0.02515959f, 0.01553604f, -0.01981449f, -0.03610611f, 0.01688074f, 
    0.01156901f, 0.02217428f, 0.01630000f, -0.03947241f, -0.01626534f, 0.00155032f, 0.02646754f, -0.04672773f, 
    -0.04280965f, -0.01972539f, 0.03312638f, 0.02927620f, -0.02517726f, 0.02866113f, 0.03228363f, 0.02402675f, 
    0.01666154f, 0.00533113f, -0.00456624f, -0.03782935f, -0.02087287f, -0.03954580f, -0.00089237f, -0.00934393f, 
    -0.02995430f, 0.02005230f, -0.03596050f, -0.02003120f, 0.01046325f, -0.03740417f, -0.01994514f, -0.01286709f, 
    -0.03357768f, -0.01546924f, 0.01050899f, 0.00513366f, -0.00178669f, -0.01072895f, 0.00184636f, -0.03232104f, 
    -0.01504919f, -0.03645055f, -0.02034727f, 0.02621932f, 0.01077424f, -0.00332151f, -0.01532991f, 0.01978480f, 
    -0.03289955f, -0.02022352f, -0.02298130f, 0.02219341f, -0.02112864f, 0.02013843f, 0.02304599f, -0.00491163f, 
    0.02201438f, -0.00176544f, 0.01894052f, -0.04196456f, 0.00270849f, 0.01839202f, 0.00688828f, 0.01689368f, 
    0.00365490f, 0.02169479f, 0.00403386f, -0.03703456f, -0.02767751f, 0.01899579f, -0.01961885f, -0.02336544f, 
    -0.03849297f, -0.01192781f, 0.00292245f, 0.02285572f, -0.02383536f, -0.03236434f, 0.01867255f, 0.01460656f, 
    -0.00544813f, -0.02947692f, 0.00264446f, -0.02842750f, 0.01997019f, 0.02656071f, 0.02320891f, -0.01732721f, 
    -0.01865650f, -0.01156504f, -0.02383331f, -0.02351393f, -0.03198440f, -0.03238177f, -0.03284192f, -0.01577464f, 
    0.00440962f, 0.02306142f, -0.02026149f, 0.00437811f, 0.00268765f, -0.03244554f, -0.00143033f, -0.04519301f, 
    -0.02140399f, 0.01640948f, 0.02519920f, 0.00850879f, 0.01623877f, -0.00855992f, -0.01323316f, -0.01986272f, 
    -0.01070270f, 0.00782755f, -0.01006221f, -0.00092251f, 0.01084678f, 0.00145497f, -0.04593518f, -0.01330752f, 
    0.04640329f, -0.02204623f, -0.04257108f, 0.00253076f, -0.00921128f, 0.05236112f, -0.01190344f, 0.05188516f, 
    -0.02691779f, 0.02997323f, -0.05082243f, 0.00604413f, -0.00493558f, 0.01885256f, 0.01485471f, -0.03882639f, 
    -0.03320177f, 0.01447486f, 0.00389810f, -0.01905716f, -0.00383381f, 0.01624607f, -0.04280279f, -0.01346819f, 
    -0.00684690f, -0.00878932f, 0.02216052f, 0.03376320f, -0.02834249f, -0.00722293f, -0.00383064f, 0.02246289f, 
    -0.01026543f, -0.00007941f, -0.01604097f, -0.00471805f, 0.02260785f, 0.04312437f, 0.01743294f, -0.02409582f, 
    0.01243507f, -0.04658042f, -0.01169364f, -0.02573798f, 0.01042909f, 0.01393222f, -0.03124524f, -0.04866906f, 
    0.01287190f, -0.03338966f, -0.00442664f, -0.01899263f, 0.00724184f, -0.01708039f, -0.01026612f, 0.03032041f, 
    -0.05495814f, -0.02910887f, -0.02166756f, -0.05696183f, 0.00629897f, -0.01678173f, 0.01383275f, -0.00694533f, 
    -0.01941310f, 0.00584843f, -0.05182200f, -0.02903336f, -0.05386505f, -0.04308291f, -0.01883009f, 0.01497903f, 
    -0.00827339f, -0.03962288f, -0.03920825f, 0.02008230f, -0.02210458f, -0.03481819f, -0.01641884f, -0.00548753f, 
    -0.04513105f, -0.01187729f, -0.02875906f, -0.02963153f, 0.00173225f, -0.00963551f, -0.00069151f, 0.01192454f, 
    -0.01080610f, -0.04924835f, 0.00230043f, -0.00444530f, 0.01699283f, -0.04123160f, -0.00211265f, -0.03309333f, 
    0.00697575f, -0.04971477f, -0.02268006f, -0.02403005f, 0.00889871f, -0.00297263f, -0.05451440f, 0.01190689f, 
    -0.05519764f, 0.02886319f, 0.01302946f, -0.01884030f, -0.04096975f, -0.01194707f, -0.02072731f, -0.01093069f, 
    -0.02681805f, 0.03184617f, 0.03443833f, 0.02811788f, -0.01008764f, -0.01325732f, -0.03023000f, -0.00169718f, 
    0.00421805f, -0.01125591f, -0.01147978f, -0.01316178f, 0.01796059f, -0.00299867f, -0.04439570f, 0.00402174f, 
    0.00975463f, -0.00858530f, 0.00189021f, -0.00327375f, -0.04649473f, -0.00361963f, -0.01147377f, -0.00059734f, 
    -0.06441603f, -0.03457164f, -0.02147200f, -0.01707510f, -0.00650371f, -0.01150052f, -0.05117347f, -0.05345519f, 
    -0.01852225f, 0.01763802f, -0.00117986f, -0.03190297f, -0.00267245f, -0.02774617f, -0.06952454f, -0.02447736f, 
    0.00905350f, -0.04050879f, -0.01759351f, -0.02383352f, 0.04352960f, -0.03883712f, -0.00910016f, -0.00539162f, 
    -0.04571059f, -0.01840447f, -0.01978172f, -0.01059184f, -0.01433606f, 0.00545432f, -0.03503989f, -0.02009490f, 
    0.00293309f, -0.01075869f, -0.00145434f, 0.00541185f, -0.00289645f, -0.02511122f, -0.01469383f, -0.02418109f, 
    -0.03713832f, -0.04151838f, 0.01916792f, -0.02696608f, -0.01855312f, 0.01943323f, -0.04456965f, -0.04107158f, 
    -0.03459453f, 0.01130909f, -0.01677809f, -0.02878946f, -0.04407819f, -0.03750528f, -0.01497747f, -0.03743342f, 
    0.00960049f, -0.03104408f, -0.00128241f, 0.03623102f, -0.02930756f, -0.00672983f, -0.02230650f, 0.01474871f, 
    -0.03427614f, 0.00703576f, -0.03080244f, -0.03008523f, -0.03900411f, 0.01850346f, -0.02813901f, 0.00973427f, 
    0.00376292f, 0.03504399f, -0.00604696f, -0.05173700f, -0.06331024f, 0.03486036f, -0.00093140f, 0.00112480f, 
    -0.05689129f, -0.04213169f, -0.02408865f, -0.04149564f, -0.04309703f, 0.02265931f, 0.04579118f, 0.04959260f, 
    -0.04351265f, -0.01251734f, -0.00194397f, 0.00318850f, -0.05538381f, -0.00495962f, 0.01310236f, -0.02174635f, 
    -0.01057494f, -0.01003476f, 0.00094343f, -0.04109327f, -0.02772186f, -0.05954428f, -0.02434362f, -0.03984859f, 
    0.00007137f, -0.01905230f, -0.03298755f, 0.00349859f, -0.03272039f, 0.03970217f, -0.00293520f, 0.05362768f, 
    -0.02201350f, -0.00193770f, -0.00344465f, -0.04397170f, -0.04924143f, -0.01188752f, 0.01120084f, -0.05809485f, 
    -0.01567508f, 0.03493375f, -0.04601173f, 0.01893254f, -0.00164205f, -0.00455553f, -0.02171212f, -0.05578239f, 
    -0.01339856f, -0.00347011f, 0.01052419f, 0.02722051f, -0.00326360f, -0.02977159f, -0.05066670f, 0.00897542f, 
    -0.04104086f, 0.02590411f, 0.00790673f, 0.02797196f, -0.04697739f, -0.03341194f, -0.03184036f, 0.00113876f, 
    -0.00160878f, 0.01846403f, -0.00547029f, -0.00846429f, -0.01694932f, 0.00628957f, 0.00872467f, -0.01032520f, 
    -0.06078870f, 0.00626707f, 0.01346746f, 0.01329356f, -0.06001955f, -0.00087996f, -0.02201609f, 0.02981149f, 
    -0.00250781f, -0.00723307f, 0.00663486f, -0.05017495f, -0.03566308f, 0.00270141f, -0.02986847f, 0.00441595f, 
    0.01677043f, 0.02668584f, 0.00041848f, 0.02477459f, -0.02396135f, 0.05649975f, 0.02447315f, 0.03324035f, 
    -0.01544417f, -0.05291229f, -0.02911488f, -0.02495112f, 0.06266783f, -0.00254247f, -0.04608700f, -0.04983233f, 
    -0.01590659f, -0.05275092f, -0.03274165f, -0.01885743f, -0.04216949f, -0.01629997f, -0.02178534f, -0.04528334f, 
    -0.00197629f, 0.01770361f, -0.03402437f, -0.01097007f, -0.01982569f, -0.03241639f, -0.04776673f, -0.03128656f, 
    0.00536194f, -0.01965505f, 0.01672689f, 0.00611961f, 0.00778891f, -0.02937825f, -0.04750708f, 0.01468062f, 
    0.02581982f, -0.02205614f, 0.00800029f, 0.00251482f, 0.04852060f, -0.01956040f, -0.03350754f, -0.00053509f, 
    -0.00322645f, -0.02075554f, 0.01343313f, -0.02960493f, -0.02119705f, -0.00742952f, -0.05148469f, 0.01658454f, 
    -0.02168128f, -0.03518906f, 0.01377053f, -0.00572767f, -0.01087431f, -0.01035047f, 0.04424570f, 0.01745816f, 
    -0.01924235f, -0.04350245f, 0.01661055f, -0.03003975f, -0.01775325f, -0.03770850f, -0.06512069f, -0.02460723f, 
    -0.00905317f, -0.04583115f, -0.03328842f, -0.03188119f, -0.05233052f, -0.00970248f, -0.01026100f, -0.01094067f, 
    0.01819071f, -0.01260680f, 0.01443255f, 0.04006937f, -0.01521025f, -0.02370624f, -0.00090160f, -0.00113888f, 
    -0.02209007f, 0.02486515f, -0.03725185f, -0.00383962f, 0.02490423f, 0.04362632f, 0.06540129f, 0.03113079f, 
    0.01093209f, -0.04210499f, 0.01316689f, -0.00713964f, -0.02185279f, -0.01241140f, -0.04418160f, 0.00563324f, 
    -0.00988176f, -0.02066215f, -0.05153331f, 0.01762243f, 0.01720461f, 0.02534527f, 0.01250283f, 0.01412224f, 
    -0.01585986f, 0.00101264f, 0.00195377f, -0.03637253f, 0.00629252f, 0.01933564f, -0.00762115f, 0.01217033f, 
    -0.02843539f, -0.00223266f, -0.01800277f, 0.00900159f, -0.02115845f, -0.01929611f, -0.00690444f, 0.02192322f, 
    0.01809576f, -0.01519842f, -0.01240692f, -0.00574022f, 0.04633953f, 0.00379819f, 0.00167452f, -0.03310211f, 
    -0.03038570f, -0.01917696f, -0.02984460f, -0.04833215f, -0.01231454f, -0.03986926f, -0.04275617f, -0.01114219f, 
    -0.00185627f, 0.04850039f, -0.01673606f, 0.00493382f, -0.04022239f, -0.02265622f, -0.01841876f, -0.00869717f, 
    -0.01075247f, -0.03595543f, 0.00419236f, -0.02554235f, 0.01484811f, -0.01403705f, -0.00180381f, 0.03176998f, 
    0.02260498f, 0.00992018f, -0.03735066f, -0.04384247f, -0.03690677f, 0.00088168f, -0.00041565f, -0.03012786f, 
    -0.00465790f, -0.02468448f, 0.01202720f, 0.02462720f, 0.00916356f, 0.00828433f, -0.02635024f, -0.02314790f, 
    -0.01013215f, 0.01799236f, 0.01073159f, -0.01766179f, -0.05987199f, -0.05512587f, -0.01187175f, -0.04467906f, 
    -0.00240114f, 0.00640095f, 0.01846236f, -0.04134418f, 0.00101712f, 0.01228313f, 0.01014735f, -0.00138198f, 
    0.03913356f, 0.01248883f, 0.04922325f, 0.05074611f, -0.04899541f, -0.03733385f, -0.04831861f, -0.04080956f, 
    -0.06784350f, 0.00226798f, -0.01170835f, -0.04882351f, -0.04212374f, -0.03202976f, 0.00055188f, -0.02679563f, 
    -0.03714819f, -0.02869222f, -0.01124223f, -0.00881980f, -0.01854973f, -0.04359973f, -0.01021282f, -0.04367947f, 
    -0.02657827f, 0.00016319f, -0.00943229f, -0.00731700f, 0.04867792f, -0.02455494f, -0.02180628f, -0.00634093f, 
    -0.01713270f, -0.03772620f, 0.00496390f, -0.02506940f, 0.00355586f, 0.00359649f, -0.02782933f, -0.04341321f, 
    -0.01945055f, 0.03335747f, 0.04532289f, 0.03993215f, -0.04421137f, -0.03516047f, -0.04194201f, 0.00442635f, 
    -0.02504216f, -0.00156726f, -0.00153898f, 0.00167047f, -0.03769833f, 0.01228120f, -0.00278236f, 0.02137442f, 
    0.01068454f, -0.02309070f, -0.00915788f, 0.03847796f, 0.02075194f, 0.00387754f, 0.04458186f, 0.00706162f, 
    0.02114182f, -0.03313834f, 0.00796328f, 0.00237492f, -0.00530063f, -0.04618484f, 0.00778381f, 0.01700284f, 
    -0.04970837f, -0.00996742f, -0.03454690f, -0.02431299f, -0.02140848f, -0.03472425f, -0.05365047f, -0.04263080f, 
    0.00508259f, 0.02988010f, -0.03111672f, 0.03071648f, -0.00387985f, -0.02150204f, -0.02608324f, 0.00146616f, 
    -0.01925701f, -0.02102478f, -0.00810053f, -0.05742517f, -0.03505342f, -0.02879743f, 0.02723647f, 0.00224040f, 
    -0.02395634f, -0.02236426f, 0.02826843f, 0.03413862f, 0.02988203f, 0.00945929f, -0.03896463f, 0.00006947f, 
    -0.01165856f, -0.06276827f, -0.02418200f, -0.05837286f, 0.02926190f, 0.01764948f, 0.06123457f, 0.08901715f, 
    0.01106675f, -0.04222187f, 0.00234255f, -0.01750058f, -0.02557297f, -0.02178877f, -0.02927880f, 0.00711946f, 
    0.06514846f, 0.05646797f, 0.01867119f, 0.03663707f, 0.01285370f, -0.00973748f, -0.03304173f, -0.03892955f, 
    -0.01879432f, -0.00022851f, -0.06636918f, -0.00418439f, 0.00100751f, -0.01580873f, 0.01041642f, -0.03135735f, 
    0.00829957f, -0.01685099f, 0.02346598f, 0.00632922f, -0.03921346f, -0.04437990f, 0.00840427f, -0.01310848f, 
    0.04793113f, 0.00084260f, 0.02927866f, -0.01822945f, -0.00282251f, -0.04391876f, -0.02336401f, -0.05406792f, 
    -0.02862560f, 0.00215578f, -0.04825263f, -0.00396818f, -0.04582914f, -0.00312433f, 0.00088094f, 0.02281000f, 
    -0.04769170f, -0.00107119f, 0.03467656f, -0.00295848f, -0.05278326f, -0.03261482f, -0.03617381f, -0.03925919f, 
    -0.00960833f, 0.01330920f, -0.02729618f, 0.01245495f, -0.03780895f, -0.04168047f, 0.00554568f, 0.01422273f, 
    -0.01890068f, 0.00459454f, 0.03801841f, 0.01197383f, 0.03940081f, -0.01928037f, -0.01323772f, 0.00728234f, 
    0.01625273f, 0.02094500f, -0.01941118f, -0.03690854f, -0.03921547f, -0.03517747f, -0.05143374f, -0.04624780f, 
    -0.05681726f, -0.02838724f, -0.04293542f, -0.01820754f, 0.00078624f, -0.03097770f, -0.04866761f, -0.00752287f, 
    -0.01254883f, -0.01795847f, 0.02762027f, -0.00315404f, -0.02857851f, 0.01827670f, 0.01936235f, -0.04693092f, 
    0.01212029f, -0.01008066f, -0.03448388f, -0.04036153f, -0.02410335f, 0.00945212f, 0.01474043f, -0.00618603f, 
    -0.03218514f, -0.00821298f, -0.01277361f, -0.03638539f, -0.03652154f, 0.00724990f, 0.00331902f, -0.00246204f, 
    0.01984484f, 0.01601617f, -0.01392903f, 0.02670344f, 0.01127941f, -0.03958347f, 0.00571674f, -0.00170494f, 
    0.00690070f, -0.02910919f, -0.03959640f, -0.03723859f, -0.01757254f, 0.02464703f, 0.01508107f, 0.01520897f, 
    -0.01007077f, 0.01969060f, -0.00340592f, -0.04690289f, 0.00057256f, 0.02070875f, -0.03799361f, -0.01509570f, 
    -0.00205312f, 0.01060525f, 0.00026376f, -0.01320630f, -0.00081983f, -0.04071632f, -0.00838127f, 0.01351780f, 
    0.03070361f, 0.02048095f, -0.04380094f, 0.01108680f, -0.00983154f, -0.01870834f, -0.05579765f, -0.06455970f, 
    0.21636583f, 0.27160338f, -0.03502777f, -0.02273459f, -0.01328015f, -0.08407699f, 0.02234894f, -0.10918349f, 
    -0.07011413f, -0.04579375f, 0.25375628f, -0.10512190f, -0.26160732f, 0.09295507f, 0.23816895f, 0.06482980f, 
    -0.09421302f, -0.13065492f, -0.04239842f, 0.04175028f, 0.13126262f, -0.15618451f, -0.14418148f, 0.00324390f, 
    -0.17345762f, -0.06629041f, 0.14768259f, 0.04506732f, -0.01254192f, -0.00472073f, 0.10560815f, -0.09854226f, 
    0.10106472f, -0.00144276f, 0.09872410f, 0.15823410f, -0.14255521f, -0.03291745f, 0.26548573f, 0.02584686f, 
    0.03913116f, -0.07221241f, -0.04366782f, 0.12564531f, 0.05741724f, 0.12208746f, 0.19020960f, 0.17071173f, 
    -0.05642866f, -0.03580757f, -0.27237096f, 0.02012449f, 0.24889709f, -0.05472605f, -0.03552969f, 0.03912270f, 
    0.09319915f, 0.00315576f, 0.02923150f, 0.16035262f, -0.84510022f, -0.16386245f, 0.32932159f, 0.37151551f, 
    -0.03914975f, -0.04745182f, -0.00584984f, -0.01331235f, 0.13185801f, 0.11053097f, 0.22369432f, -0.07529631f, 
    0.31917801f, -0.19322963f, 0.23189001f, -0.11760077f, 0.26755872f, 0.11916661f, 0.12765361f, 0.06930159f, 
    0.01055247f, -0.01672968f, -0.00578520f, 0.01260878f, 0.15138665f, 0.12438216f, 0.03208150f, -0.05491412f, 
    -0.05872306f, -0.06057935f, -0.02211286f, -0.01105707f, 0.09383408f, 0.11133019f, -0.07006933f, -0.04089421f, 
    -0.10947815f, 0.04749839f, 0.04503113f, 0.11470716f, 0.03197063f, 0.18113613f, -0.11673383f, -0.05070105f, 
    0.05977761f, -0.03183031f, 0.11168975f, -0.00315789f, 0.19021711f, 0.17556369f, 0.02852632f, -0.26675081f, 
    -0.02039973f, 0.05501612f, -0.13123713f, -0.14717796f, -0.07339197f, -0.04559947f, 0.00921994f, 0.01089751f, 
    0.06664944f, 0.23637064f, -0.03119674f, -0.10090172f, -0.04365024f, -0.05372166f, -0.08505302f, 0.16694322f, 
    -0.08792949f, -0.06674341f, -0.03647130f, -0.07822827f, -0.01678215f, 0.13434482f, 0.11650597f, 0.23205103f, 
    -0.08284448f, 0.06719085f, -0.00708101f, 0.04317398f, 0.07137533f, 0.07321657f, 0.25913399f, 0.02737536f, 
    -0.12519053f, -0.01598926f, 0.15539692f, -0.02977385f, -0.04646382f, -0.03906791f, 0.05648714f, 0.05463730f, 
    0.10485978f, 0.08855779f, 0.09056588f, -0.04281216f, 0.14038153f, 0.00554866f, -0.16060075f, -0.23687792f, 
    -0.05355140f, -0.00727568f, 0.10532337f, 0.31502730f, 0.08766741f, 0.02249740f, -0.00459641f, -0.12845223f, 
    -0.12530616f, -0.09674921f, -0.12785509f, 0.24906389f, 0.25537685f, 0.20414768f, 0.17919146f, -0.02616686f, 
    -0.04260717f, 0.04020029f, -0.07011624f, 0.09883917f, -0.04991072f, -0.07192656f, 0.05019164f, 0.13294275f, 
    -0.02623950f, -0.14338835f, -0.01219379f, -0.05986243f, 0.11865531f, -0.10099003f, 0.21031776f, 0.10380898f, 
    0.08634122f, -0.17044534f, 0.03556803f, 0.36378217f, 0.14745377f, 0.02409779f, -0.07219613f, -0.02023243f, 
    -0.04076242f, 0.05840885f, 0.09535515f, 0.09733285f, 0.19380155f, -0.17697158f, 0.32076913f, 0.20970002f, 
    0.20353433f, 0.03533741f, 0.08456173f, 0.11398713f, -0.10823579f, 0.21901122f, 0.07273568f, -0.03530373f, 
    0.19183630f, 0.18931864f, 0.25506219f, 0.36055833f, -0.05230636f, 0.14684586f, 0.08357508f, 0.10304785f, 
    0.15351030f, -0.13609453f, -0.06766699f, 0.06239131f, -0.14895234f, -0.31642702f, -0.05504580f, -0.22850186f, 
    -0.09372135f, 0.03075878f, -0.16786733f, 0.01735156f, 0.07761141f, 0.14428303f, -0.05045048f, 0.14436072f, 
    0.00360499f, 0.05123932f, -0.03898923f, 0.25144184f, 0.33739850f, 0.11332251f, 0.22849403f, 0.08636843f, 
    -0.04484801f, 0.12075532f, -0.11008204f, -0.00211017f, -0.02090449f, 0.06470810f, 0.15088686f, -0.05193301f, 
    -0.05786296f, -0.18168901f, -0.07924292f, -0.02388187f, 0.00474503f, -0.08475598f, -0.19076477f, 0.02608211f, 
    -0.49959746f, 0.01525165f, -0.07447453f, 0.38365135f, -0.07407489f, -0.16737346f, -0.03230527f, -0.10483091f, 
    0.08580225f, -0.01306025f, 0.16693257f, 0.00190102f, 0.28715509f, -0.05140708f, 0.10158143f, 0.28216076f, 
    0.29882452f, -0.08850153f, 0.22664177f, 0.02670426f, 0.03859306f, 0.06053215f, 0.12822732f, 0.21466899f, 
    0.04342417f, 0.10782669f, 0.20468213f, 0.10065991f, -0.14383748f, -0.04676076f, -0.02914094f, 0.03276909f, 
    0.03067738f, 0.14894108f, 0.13310683f, 0.07293249f, 0.06138084f, 0.13347659f, -0.10024723f, -0.27027318f, 
    0.03570084f, -0.09701283f, -0.05959631f, -0.06479222f, 0.23408812f, -0.00448818f, -0.30380532f, 0.19789633f, 
    0.13603725f, 0.08386545f, -0.04957154f, -0.10616951f, -0.00988084f, -0.09088517f, -0.09813646f, -0.11929848f, 
    0.00290982f, -0.00370342f, -0.00660104f, 0.02918833f, 0.13720179f, 0.10712586f, -0.03485679f, -0.27448484f, 
    0.11255271f, 0.13819905f, 0.11994336f, -0.05638036f, 0.05754520f, 0.09084848f, -0.02210873f, 0.01390118f, 
    -0.24465705f, -0.10488283f, -0.11191594f, -0.42993590f, 0.04721538f, 0.01926030f, 0.01202879f, 0.08128393f, 
    0.11940987f, -0.00116719f, 0.19395722f, -0.08973213f, 0.03465469f, 0.08968499f, -0.13064364f, -0.15206701f, 
    0.00857120f, 0.08293691f, 0.03798865f, 0.03562527f, 0.18406744f, 0.16038135f, 0.06292379f, -0.04619924f, 
    -0.30578658f, -0.01359891f, -0.10255261f, 0.07766110f, 0.03392828f, -0.02105078f, 0.00656900f, 0.04476472f, 
    0.15175565f, 0.05129629f, 0.11686827f, 0.06272537f, -0.10471006f, -0.11898809f, -0.06958287f, -0.07637762f, 
    0.27794060f, 0.15934835f, -0.02432454f, 0.20295975f, 0.08229978f, 0.02729508f, 0.16822897f, 0.10253277f, 
    -0.10260935f, -0.12363150f, -0.09846312f, -0.07621074f, -0.06545172f, -0.00131938f, 0.05295541f, 0.01597927f, 
    -0.14471346f, -0.06423135f, -0.08004633f, -0.24510042f, -0.14338019f, -0.11524520f, -0.00159587f, 0.03331516f, 
    0.02408242f, 0.02455992f, -0.01679016f, -0.01114772f, 0.27204311f, 0.03441209f, 0.08851474f, 0.08268964f, 
    -0.10597018f, -0.09153763f, -0.08358939f, 0.08721375f, 0.01964329f, 0.11840445f, -0.01298112f, 0.08621849f, 
    -0.04610606f, -0.00138276f, -0.10587271f, -0.04401891f, -0.09911828f, 0.02020270f, -0.03111366f, -0.09754908f, 
    0.06269071f, -0.02442464f, -0.03900900f, -0.03574917f, 0.10183277f, -0.02834413f, -0.19062607f, 0.04830176f, 
    -0.14555097f, -0.02862301f, -0.21817569f, -0.00655448f, 0.02880550f, 0.20044543f, 0.17943309f, -0.05575474f, 
    0.06396315f, 0.04004892f, -0.08355088f, 0.07580502f, -0.09270576f, 0.05068538f, 0.05026215f, -0.26917619f, 
    0.04283579f, -0.07308972f, -0.03857679f, 0.08851175f, 0.03110775f, 0.01150800f, 0.11815347f, 0.03458912f, 
    -0.01079841f, 0.09341385f, 0.02540265f, -0.04664553f, 0.03896607f, 0.01650690f, 0.07308996f, 0.10941190f, 
    0.06525740f, 0.07991217f, 0.08115454f, 0.10353012f, 0.46659508f, -0.01209144f, 0.41505343f, -0.11050534f, 
    0.01117323f, 0.09974128f, 0.03706396f, 0.29036424f, -0.02277446f, -0.02938557f, 0.03057722f, -0.04463091f, 
    -0.18615422f, -0.18536566f, 0.11569113f, 0.23427698f, 0.05613161f, -0.00747825f, -0.04981395f, 0.00068840f, 
    0.24210720f, 0.11806609f, 0.12472744f, 0.05536346f, -0.13914935f, -0.01887083f, -0.05178730f, 0.12836619f, 
    0.22533114f, -0.02020175f, 0.08167437f, 0.06656534f, 0.12240505f, 0.00175232f, -0.03968505f, -0.09067496f, 
    0.15388261f, 0.03617558f, 0.02854456f, -0.02201910f, -0.02514376f, 0.04780053f, 0.03113500f, -0.08410795f, 
    0.06261240f, -0.00535192f, -0.01931846f, 0.22927712f, -0.19739942f, 0.03339085f, 0.27499810f, 0.27041483f, 
    0.11066325f, -0.02096485f, -0.13328406f, 0.24370365f, 0.21531019f, 0.06893952f, -0.04108683f, -0.06507396f, 
    0.05748351f, -0.11076320f, -0.08605427f, -0.33637986f, 0.06305439f, 0.17866990f, -0.33224779f, 0.10883288f, 
    -0.05749292f, 0.21097766f, -0.06037096f, 0.03070337f, -0.01497759f, -0.11186126f, -0.07580683f, 0.02746937f, 
    0.15664902f, -0.09840704f, 0.16638577f, 0.09825975f, 0.01804239f, 0.06950213f, -0.01138445f, 0.02594529f, 
    0.07440162f, 0.00737094f, -0.13511354f, 0.17082736f, 0.04467392f, 0.17322700f, 0.13153923f, 0.09464207f, 
    -0.00721852f, 0.01767889f, -0.05373854f, -0.09789560f, -0.15867881f, -0.02552454f, -0.02187344f, -0.22920239f, 
    -0.01240946f, 0.05923437f, -0.08444020f, 0.22500181f, 0.02286935f, -0.07352998f, -0.11100101f, -0.05545843f, 
    0.50367790f, -0.06418659f, -0.37010172f, 0.24928887f, 0.02986436f, 0.08630230f, 0.03514271f, 0.08070012f, 
    0.02989899f, -0.06177758f, 0.03104009f, 0.02575993f, -0.34145615f, 0.20768949f, 0.14569768f, -0.06477571f, 
    -0.05452143f, 0.04103547f, 0.10453454f, -0.08336987f, -0.02155706f, -0.13227898f, -0.01022530f, 0.08867396f, 
    -0.03612678f, -0.03038223f, -0.03257317f, -0.21669082f, -0.13660564f, 0.08600064f, 0.04532909f, -0.16074727f, 
    0.05969594f, 0.04979374f, -0.01129972f, -0.05469279f, -0.31452826f, 0.00326790f, -0.02234504f, -0.18680748f, 
    0.02581770f, 0.02877648f, -0.07075106f, -0.17984670f, 0.09091666f, 0.14524053f, 0.03414099f, -0.12693831f, 
    -0.27335018f, -0.08342342f, -0.04333420f, -0.28383145f, 0.10549932f, -0.05152562f, 0.18877965f, -0.00167277f, 
    0.06395072f, 0.03773873f, 0.05747484f, -0.02373594f, 0.23294212f, -0.04213931f, 0.16954608f, 0.01908492f, 
    0.14836375f, 0.05682821f, 0.11498896f, 0.18903090f, 0.08626247f, 0.08852983f, -0.01213656f, -0.03784474f, 
    -0.02378980f, 0.03053679f, -0.14197715f, -0.23409739f, 0.02021910f, -0.02343637f, -0.03658605f, 0.00324613f, 
    -0.00099144f, -0.04263026f, -0.06376232f, 0.08129404f, 0.05104340f, -0.13167556f, 0.04440881f, 0.08152885f, 
    0.08463906f, -0.10953104f, -0.05771949f, 0.01873835f, -0.01780480f, -0.00538632f, -0.08508267f, -0.02154483f, 
    -0.07714623f, 0.02240918f, -0.03783253f, 0.13516645f, 0.00045119f, -0.10252786f, -0.07102587f, 0.03702155f, 
    -0.02251186f, -0.03858965f, -0.04677593f, 0.11268832f, -0.55883169f, -0.06419658f, 0.04622426f, -0.26048130f, 
    -0.03827764f, -0.07505669f, 0.20104322f, 0.07929579f, -0.06294199f, -0.06241779f, 0.08216441f, 0.06908670f, 
    0.05995421f, -0.27326354f, -0.15701415f, -0.07044117f, 0.01573985f, -0.00668305f, -0.00999740f, 0.07748535f, 
    0.05185603f, -0.10595576f, -0.03631113f, 0.02524696f, 0.04817143f, 0.00536841f, -0.03395460f, 0.01988277f, 
    0.08785334f, 0.03383798f, -0.00423168f, 0.09301764f, -0.03920533f, -0.00014839f, 0.01340379f, 0.04135660f, 
    -0.09383139f, -0.02972591f, -0.09379715f, 0.03502383f, 0.12274334f, 0.10646836f, -0.00630709f, 0.04906020f, 
    -0.02499667f, -0.06483988f, -0.05846940f, -0.03592624f, -0.09643504f, -0.07805523f, -0.07161384f, 0.01929039f, 
    0.03126713f, 0.02184400f, -0.01345402f, -0.00807862f, 0.04489081f, 0.04261757f, 0.01924307f, 0.09367210f, 
    0.40979472f, 0.04844548f, 0.08767744f, -0.14176412f, 0.14930791f, -0.04589133f, 0.02778441f, 0.15495536f, 
    0.06170183f, -0.05780622f, -0.05864546f, 0.09995130f, 0.21606533f, 0.16388321f, 0.02956618f, -0.21580759f, 
    0.14473557f, 0.15112559f, -0.11703973f, -0.11672032f, 0.00000235f, -0.03611739f, 0.01901665f, -0.04011296f, 
    0.25222155f, 0.24411559f, 0.09810836f, 0.27034608f, 0.01319453f, -0.03807674f, 0.03557771f, -0.10534294f, 
    0.13506101f, 0.13094373f, 0.10554736f, 0.23239927f, -0.08804473f, 0.25825506f, -0.01974186f, 0.25638539f, 
    0.13558990f, -0.03541094f, -0.11270861f, 0.00087917f, 0.00816926f, 0.14207101f, -0.00945653f, -0.01405134f, 
    -0.11391002f, -0.09603474f, -0.04973918f, -0.14597517f, 0.03065280f, -0.00318345f, 0.02102560f, 0.02337390f, 
    0.05409089f, -0.09760532f, -0.15481465f, -0.13724247f, -0.11355682f, 0.25748318f, -0.07310092f, -0.07363705f, 
    0.02967752f, 0.03649184f, -0.01889663f, 0.03738159f, 0.00896448f, 0.26553804f, 0.09763777f, 0.22426756f, 
    0.06315807f, -0.01425224f, 0.05313480f, -0.06394732f, -0.03252945f, 0.01774163f, -0.04427896f, 0.01073372f, 
    -0.13034716f, -0.01819767f, 0.00276383f, -0.24513823f, 0.34922627f, 0.33438963f, 0.22949162f, -0.05931466f, 
    0.03996509f, 0.05861311f, -0.04511300f, 0.08718616f, 0.09535436f, 0.08779325f, 0.06132958f, -0.15122901f, 
    -0.21189421f, -0.20069122f, 0.07594092f, 0.27577263f, 0.09914059f, 0.09187866f, 0.01990110f, 0.03042277f, 
    -0.07185368f, -0.06709302f, -0.10650226f, -0.06306424f, -0.04907890f, 0.15219633f, 0.20228796f, 0.19854632f, 
    0.04654179f, -0.08792681f, -0.05130351f, -0.04149600f, 0.16640867f, -0.05149904f, -0.15358284f, 0.04805369f, 
    -0.08699458f, 0.07770889f, 0.01734708f, 0.01724852f, 0.03248879f, 0.15487860f, 0.09068651f, -0.05160386f, 
    0.03992973f, -0.15956233f, -0.03693017f, -0.07368480f, -0.15471955f, 0.03771082f, -0.04918061f, 0.25834951f, 
    0.13563517f, 0.01731074f, -0.02834727f, -0.00396538f, 0.07561602f, 0.19286865f, -0.01990451f, 0.07268690f, 
    0.05584900f, 0.27725753f, 0.24627228f, 0.20298381f, -0.02868624f, -0.12075011f, -0.09007233f, 0.03110326f, 
    -0.07695605f, 0.07571312f, -0.17245461f, -0.01532792f, 0.13600758f, -0.11622486f, -0.17496896f, -0.13320537f, 
    -0.12138890f, 0.10555474f, 0.16222528f, -0.28980267f, 0.04168086f, -0.13835391f, 0.11981235f, 0.15069409f, 
    -0.01873223f, 0.32416585f, 0.20582174f, -0.13423343f, 0.09515780f, 0.08911289f, -0.05866683f, 0.05450537f, 
    0.17564431f, 0.24165785f, -0.15284543f, 0.31766090f, 0.06189765f, 0.15562895f, -0.22279091f, 0.18594991f, 
    0.10060982f, 0.04749747f, 0.18271759f, 0.23501317f, 0.18380426f, 0.29275677f, 0.26946488f, 0.41346213f, 
    -0.03451355f, 0.12030637f, 0.37533209f, 0.37135249f, 0.05773415f, 0.13833325f, 0.07970905f, -0.19757193f, 
    0.05464847f, -0.01223950f, -0.04215303f, 0.04637874f, -0.01133234f, 0.00942800f, -0.01282600f, -0.06908401f, 
    -0.09574348f, -0.06210703f, 0.05140720f, -0.10008617f, -0.12372214f, -0.12119147f, 0.01428570f, -0.28644171f, 
    0.14210480f, 0.25303131f, -0.10869968f, -0.02339549f, 0.06024247f, -0.06487568f, 0.02481312f, -0.10709100f, 
    -0.01721418f, 0.01688951f, 0.06379941f, 0.11640210f, -0.47069976f, 0.15746506f, -0.12119634f, 0.44316694f, 
    0.04438519f, 0.13631921f, 0.04472065f, 0.00933664f, -0.10092284f, 0.15814672f, 0.05927995f, 0.20884453f, 
    -0.15010588f, 0.12315407f, 0.08612171f, 0.19625688f, 0.05466255f, 0.08656445f, -0.12955143f, 0.13438140f, 
    -0.01221061f, 0.02924695f, 0.07000198f, 0.02609442f, -0.22218306f, 0.40528998f, -0.13910930f, 0.25314736f, 
    -0.03323349f, -0.06621119f, -0.03579116f, -0.03575489f, -0.02113139f, 0.01675104f, 0.01316770f, 0.04603921f, 
    0.14511390f, -0.08152289f, 0.00572441f, 0.02358679f, -0.04964240f, 0.03777067f, 0.28577259f, 0.01469036f, 
    -0.10401802f, 0.08170249f, -0.06253995f, -0.14624728f, 0.07392168f, 0.07063518f, 0.24347399f, 0.15437393f, 
    -0.08131562f, -0.03023422f, -0.13591984f, 0.04275047f, 0.10577005f, -0.03129070f, 0.15642218f, -0.07329687f, 
    -0.06575157f, 0.24978445f, -0.06698021f, 0.16994190f, 0.15459117f, -0.10051478f, -0.01658888f, -0.04012301f, 
    -0.18800704f, -0.00553531f, 0.11351174f, -0.05421920f, -0.08574245f, -0.00881568f, 0.10206071f, 0.14688534f, 
    0.02379924f, 0.18305002f, 0.12629801f, -0.02822120f, 0.14269093f, -0.03255733f, 0.03148934f, -0.09563000f, 
    -0.13698734f, 0.07197466f, -0.11836926f, 0.05828874f, -0.06043057f, 0.08698262f, 0.01935525f, -0.19486532f, 
    -0.04339810f, 0.07978382f, -0.08643768f, 0.01009306f, -0.07378876f, 0.20949486f, 0.07704831f, -0.12143321f, 
    0.13276854f, 0.10024804f, -0.04388297f, -0.07796315f, -0.17051479f, -0.04249267f, 0.02355649f, 0.07281999f, 
    -0.12404070f, -0.06545002f, -0.23514783f, 0.13214533f, -0.09036996f, -0.03439914f, 0.07354255f, 0.15959045f, 
    0.08999012f, 0.05271018f, -0.00817581f, 0.01058264f, 0.07220506f, -0.07275722f, 0.06293195f, 0.23049115f, 
    0.14674141f, 0.17672946f, 0.12385563f, -0.18878862f, 0.06802367f, -0.02399305f, -0.07919943f, -0.09925918f, 
    -0.38997892f, 0.02182441f, 0.12313824f, 0.34496334f, 0.10302950f, 0.00222377f, 0.02909263f, -0.12021232f, 
    0.08674545f, 0.16576430f, 0.23923919f, 0.27414250f, -0.03302034f, 0.24316952f, -0.01604818f, 0.39012077f, 
    0.03104499f, -0.02652623f, -0.05368808f, 0.01575048f, 0.16541448f, 0.19943459f, 0.34917068f, 0.28798771f, 
    -0.08254665f, 0.20101385f, 0.13761815f, -0.15736230f, 0.06747542f, -0.00823132f, -0.04254502f, -0.02377068f, 
    -0.06765225f, 0.04448810f, 0.11225411f, 0.20612641f, -0.17188117f, -0.13140239f, -0.02649378f, 0.11175736f, 
    -0.00093964f, -0.02648450f, 0.17895553f, 0.14621861f, 0.03655708f, 0.00363187f, -0.02429393f, -0.04230386f, 
    0.15092449f, -0.07722627f, -0.04251901f, -0.23564763f, -0.15135746f, -0.05366787f, 0.09485921f, -0.05262117f, 
    0.28447080f, 0.26615739f, 0.15034516f, 0.35363778f, -0.07427872f, -0.06369180f, -0.04951689f, -0.29293650f, 
    0.02032255f, 0.03522370f, 0.04810332f, 0.00412376f, 0.20849703f, -0.05537340f, -0.02530009f, 0.08905955f, 
    0.07953919f, -0.14506678f, 0.25604269f, 0.03518302f, -0.04786377f, 0.11069749f, 0.09448993f, -0.01546463f, 
    0.03312412f, -0.07964098f, -0.09624150f, -0.13720345f, 0.22704124f, 0.27706677f, -0.19831279f, 0.33549330f, 
    -0.00523468f, -0.11874504f, 0.03177576f, 0.00935724f, 0.00652309f, -0.10379563f, -0.16743815f, 0.13157965f, 
    -0.28718719f, 0.22086869f, 0.05840702f, 0.41244394f, 0.02380136f, 0.07219351f, 0.14578636f, -0.05400865f, 
    0.05041308f, -0.16674995f, -0.03483089f, -0.07752085f, -0.06371400f, -0.04753341f, -0.01175548f, 0.06074593f, 
    -0.01677710f, -0.14394838f, -0.01399299f, 0.02826626f, -0.02714799f, 0.06061871f, -0.08030108f, -0.11509869f, 
    -0.16018549f, -0.19017538f, -0.27542728f, 0.10300564f, -0.06156754f, 0.08540622f, -0.10296810f, 0.05853261f, 
    -0.11597358f, -0.04807233f, -0.04388681f, -0.05370038f, -0.42539164f, 0.24628447f, 0.18073118f, -0.17020994f, 
    0.02571313f, 0.00779151f, 0.12483208f, 0.07676674f, -0.04282315f, 0.07219594f, 0.07179428f, -0.14860912f, 
    -0.11274006f, 0.35002580f, 0.28073746f, -0.06656673f, 0.01661033f, 0.05428910f, -0.08965588f, 0.10349274f, 
    -0.07826512f, 0.15385219f, -0.09767346f, 0.07430404f, 0.10229255f, -0.13401365f, 0.12526214f, 0.34097245f, 
    -0.11292575f, 0.09057682f, 0.13737518f, -0.08736192f, 0.19366549f, 0.14824212f, -0.00354973f, 0.09148867f, 
    0.11846261f, -0.00603884f, 0.36685944f, 0.05257435f, -0.05705877f, -0.05246818f, -0.11433648f, 0.07180195f, 
    -0.02520701f, -0.16185118f, 0.06632829f, -0.09711464f, -0.09617809f, 0.29263946f, 0.20311466f, 0.29006070f, 
    0.11822616f, 0.08512539f, 0.10680166f, -0.23025730f, -0.17737888f, 0.19752267f, -0.18388322f, 0.19056046f, 
    -0.75608706f, 0.53950250f, 0.17143808f, 0.17559043f, 0.02977012f, -0.07174971f, 0.04872250f, 0.22784093f, 
    -0.10728185f, -0.05611731f, -0.06268918f, -0.07417176f, 0.14083423f, -0.01079903f, 0.13905425f, 0.19563068f, 
    0.04446644f, 0.07058487f, -0.08969890f, -0.04988339f, 0.07098122f, -0.10683735f, -0.12221047f, 0.19633850f, 
    0.20752221f, -0.14702702f, -0.08862866f, 0.12836379f, -0.14538002f, -0.00252946f, 0.18259522f, 0.06350262f, 
    0.11062931f, 0.15492250f, 0.04194811f, -0.10875839f, -0.32724345f, 0.26404279f, 0.09049621f, 0.42211169f, 
    -0.07208264f, -0.03233522f, 0.10371719f, 0.07497690f, -0.02497502f, -0.04127485f, 0.06012781f, 0.08536796f, 
    -0.09831248f, -0.17451544f, -0.16172376f, -0.02129965f, -0.08619318f, 0.02266160f, -0.08384016f, 0.04291336f, 
    -0.06294765f, -0.00436489f, 0.06314731f, -0.08806173f, 0.01574517f, 0.20503692f, -0.14448030f, 0.13083822f, 
    0.08264544f, 0.12634787f, 0.12155404f, -0.12555413f, -0.15951213f, 0.05298386f, 0.25536865f, 0.22826988f, 
    0.10799584f, 0.06208407f, 0.23982070f, 0.08439820f, -0.04357124f, -0.11420988f, 0.16287704f, 0.05678894f, 
    -0.11407825f, 0.01070680f, -0.12007453f, -0.14405550f, 0.12503126f, 0.06123132f, 0.07943700f, 0.29474762f, 
    0.13149543f, -0.07292653f, -0.14281385f, -0.06748121f, -0.02873169f, 0.01022811f, 0.09040782f, -0.03099858f, 
    0.05637108f, -0.01265299f, -0.17940910f, -0.06615599f, -0.02410883f, -0.12271053f, -0.16230184f, -0.25166509f, 
    0.00770877f, -0.00253990f, -0.03734800f, 0.01598724f, 0.01086215f, -0.08486247f, -0.04121801f, 0.12893738f, 
    0.10923603f, 0.12941965f, -0.07166649f, -0.06977770f, 0.21011043f, -0.07765356f, -0.07374474f, 0.13937604f, 
    -0.22014354f, -0.08175240f, -0.22214216f, 0.02208916f, -0.10985695f, -0.11846654f, 0.07222792f, 0.04275712f, 
    -0.02275185f, 0.09135161f, 0.02434118f, 0.31037545f, -0.09656157f, -0.06158898f, 0.10554930f, 0.03752624f, 
    0.06411892f, 0.02472977f, -0.06880129f, 0.09744146f, -0.31354505f, -0.07015058f, -0.03954676f, -0.16750072f, 
    -0.14830434f, -0.05425502f, -0.14842303f, -0.12726983f, 0.04929046f, 0.06983598f, 0.07171977f, 0.01148559f, 
    -0.00215346f, -0.10622700f, -0.04028095f, -0.09591551f, -0.15724453f, -0.42402342f, -0.30692482f, 0.01964923f, 
    0.02417118f, 0.01198363f, 0.15246224f, 0.14694415f, 0.01030333f, 0.09180491f, 0.15234447f, 0.08461823f, 
    -0.14229409f, 0.14161821f, -0.06102747f, -0.10052288f, -0.01626187f, 0.00094899f, 0.06821483f, -0.02646454f, 
    0.12428339f, -0.01040546f, 0.09892618f, 0.14178535f, 0.09956597f, -0.18646650f, -0.14213525f, -0.03063542f, 
    -0.12749836f, -0.00241053f, -0.07997574f, 0.12401079f, -0.13324519f, 0.07264717f, -0.14427012f, -0.19675708f, 
    -0.11771144f, -0.09339623f, -0.16222245f, -0.11131582f, 0.14946209f, 0.00430899f, -0.02617905f, 0.10869392f, 
    -0.19959901f, -0.08445179f, -0.13099353f, 0.01228911f, -0.07371777f, -0.11938176f, -0.16014257f, -0.12960701f, 
    0.04059520f, -0.04022859f, 0.05696916f, 0.02071125f, 0.03098984f, -0.15140964f, -0.10444424f, -0.07488875f, 
    -0.09103799f, 0.00370369f, -0.00110505f, 0.11116265f, -0.06683073f, -0.12531464f, -0.01734091f, 0.17938535f, 
    -0.10323972f, -0.11764741f, -0.06088373f, -0.01533137f, -0.06768963f, -0.23383215f, 0.24297045f, 0.42594793f, 
    0.16831918f, 0.09951176f, 0.03605652f, 0.04581281f, 0.06024130f, -0.06290333f, 0.00049020f, -0.02607351f, 
    -0.00811757f, 0.02855343f, -0.01236301f, 0.01273001f, -0.00345222f, -0.03780831f, 0.00657895f, 0.00939133f, 
    0.02261162f, 0.03190659f, -0.02040081f, 0.02273032f, 0.01957852f, -0.00668909f, -0.02796147f, -0.03819893f, 
    -0.02667447f, -0.01403868f, 0.00214127f, 0.02678983f, -0.02128282f, -0.03820824f, -0.03793296f, -0.01468146f, 
    -0.02926545f, 0.02502962f, -0.00462124f, 0.01559940f, 0.00819744f, -0.00720430f, -0.00568148f, -0.01364862f, 
    0.01291329f, -0.02398830f, -0.00187189f, -0.01908896f, 0.00935771f, 0.00130174f, -0.01261405f, -0.01617535f, 
    0.01482784f, 0.00352521f, 0.01106583f, 0.02145752f, -0.00647362f, -0.01835657f, 0.03052782f, -0.01420801f, 
    -0.03770047f, -0.01360235f, 0.01846231f, 0.00143179f, 0.02798023f, -0.02247359f, -0.01805238f, 0.01088856f, 
    -0.03142235f, -0.01764670f, 0.00941053f, 0.01473045f, 0.01693528f, -0.02029461f, -0.02960376f, 0.03065505f, 
    0.02801910f, 0.02475391f, -0.03067459f, 0.02576013f, 0.01590558f, -0.00648521f, -0.03433060f, 0.01754374f, 
    -0.02118431f, 0.00206301f, -0.02493163f, 0.02983196f, -0.02639234f, -0.00952909f, 0.02081290f, 0.01302810f, 
    -0.00498441f, -0.02123634f, 0.02579566f, -0.03306056f, 0.02007315f, -0.02549314f, -0.00628793f, 0.02586031f, 
    0.00962087f, -0.02229515f, 0.01601199f, -0.02960313f, -0.00142696f, 0.00785199f, -0.00654238f, -0.02071909f, 
    -0.00715605f, -0.01667713f, -0.01263017f, -0.02016075f, 0.01719827f, 0.01923485f, -0.01705024f, -0.03345155f, 
    -0.02157191f, 0.00596456f, 0.00114666f, 0.02203899f, 0.00285037f, -0.00913498f, -0.04178340f, -0.00873913f, 
    -0.03760926f, -0.03910854f, 0.00691693f, 0.01547828f, 0.00487955f, -0.03203050f, -0.03031548f, 0.01371754f, 
    -0.04262361f, -0.00442214f, 0.02249703f, 0.01919151f, 0.00632516f, -0.03399486f, -0.01992674f, -0.01062579f, 
    0.00363859f, -0.00067712f, -0.03271752f, 0.02357455f, 0.01345647f, -0.00110254f, -0.01637162f, -0.01220449f, 
    0.01411853f, -0.01080847f, 0.01400090f, 0.02286039f, -0.00940191f, 0.01882250f, 0.02909038f, 0.02591330f, 
    -0.04445940f, -0.00170102f, -0.02853013f, -0.03630262f, -0.03628199f, 0.02572270f, -0.02658557f, -0.00664824f, 
    0.00279238f, 0.03314403f, -0.03050865f, -0.02576142f, -0.01989011f, 0.00771608f, -0.02023534f, 0.01576623f, 
    -0.01859735f, -0.02557026f, -0.01599758f, 0.03116351f, -0.01653936f, -0.02439033f, 0.01573382f, -0.01179743f, 
    -0.00903569f, 0.02554226f, -0.00511874f, -0.02010965f, -0.00961695f, 0.01752782f, 0.01806987f, -0.01236834f, 
    -0.03283436f, -0.02905298f, -0.04169783f, -0.00783871f, -0.00694435f, 0.01231291f, 0.01662388f, -0.00169743f, 
    -0.01186489f, 0.03464445f, 0.01807822f, -0.01886517f, -0.03419308f, -0.03457047f, 0.03611216f, -0.00572905f, 
    -0.00805017f, -0.00369163f, 0.01459780f, 0.01781852f, 0.00841181f, -0.00433941f, 0.00148836f, -0.00363853f, 
    0.02434156f, -0.03622312f, -0.02135915f, 0.02268129f, -0.01170711f, 0.00290833f, 0.02534176f, 0.00304249f, 
    0.00038293f, -0.02642873f, -0.03336728f, 0.01685705f, 0.03479402f, 0.00259696f, -0.02709825f, -0.00457988f, 
    0.00018983f, 0.01037261f, -0.03573685f, 0.03115795f, 0.02223731f, 0.01086216f, 0.01432429f, 0.02095981f, 
    -0.02097451f, -0.00669013f, 0.00523645f, -0.02671236f, 0.00532481f, -0.01450177f, -0.02187336f, 0.00391203f, 
    -0.03557567f, 0.02925229f, 0.01663543f, 0.00478074f, -0.03483237f, 0.00085404f, -0.00009559f, 0.00948027f, 
    0.00803934f, 0.01988003f, -0.01026865f, -0.04073328f, -0.02668628f, -0.00620906f, -0.04359432f, 0.02877390f, 
    -0.03176030f, -0.01620669f, 0.01198876f, -0.02442173f, -0.02187005f, -0.00754638f, 0.01399996f, 0.01389692f, 
    -0.02322173f, -0.02655238f, 0.02584401f, 0.02065389f, 0.02509178f, 0.03168511f, 0.02254952f, 0.02393444f, 
    -0.02792858f, -0.03061527f, -0.00124514f, -0.02330171f, -0.03492012f, -0.01666551f, 0.01322130f, 0.00036774f, 
    -0.01265245f, 0.00254843f, -0.02985059f, 0.03136074f, -0.04103578f, -0.01749693f, -0.03020374f, 0.02164509f, 
    0.00589931f, -0.01143506f, -0.00558325f, 0.02515711f, -0.02202984f, 0.02621474f, 0.00665371f, -0.01105489f, 
    -0.03313553f, 0.02507106f, 0.02745204f, -0.04376974f, -0.00221845f, -0.00363882f, -0.00190756f, -0.00796634f, 
    0.00082810f, 0.00484265f, -0.03791854f, -0.00659227f, 0.00676557f, -0.02977882f, 0.03155427f, -0.00057115f, 
    0.02329845f, -0.03713842f, -0.03217675f, 0.00161224f, 0.02509198f, -0.02448920f, -0.01224319f, -0.03588554f, 
    -0.02038458f, 0.02153110f, -0.04240411f, 0.00557742f, -0.01571356f, 0.01242188f, -0.00398723f, -0.02878178f, 
    -0.04034985f, 0.01924796f, -0.04017650f, 0.01265007f, -0.03169121f, 0.01857042f, 0.01680360f, -0.01676663f, 
    -0.00853348f, 0.02243154f, -0.00607321f, 0.02682364f, -0.00524280f, 0.02050980f, -0.01801286f, -0.03968900f, 
    -0.04313348f, -0.00854449f, -0.03077610f, -0.03049663f, -0.00054400f, -0.01395568f, 0.01692862f, -0.03689101f, 
    -0.03525617f, 0.00546854f, -0.00243195f, -0.03359617f, -0.04006417f, 0.02096812f, -0.03071607f, 0.00919854f, 
    0.01842564f, -0.02313863f, 0.00079286f, 0.00634226f, -0.02346514f, -0.00114443f, 0.00233886f, -0.02169462f, 
    0.02706029f, -0.04077039f, 0.00404198f, 0.00267701f, 0.00497619f, -0.01488698f, 0.01500670f, 0.01732318f, 
    -0.03400704f, -0.02766700f, -0.02389772f, 0.01687970f, -0.01774867f, 0.00070071f, -0.01459960f, 0.01190862f, 
    -0.04066461f, 0.00778882f, -0.01143647f, -0.02381432f, -0.03210025f, -0.00423890f, -0.01006968f, -0.00369566f, 
    -0.00271232f, -0.03121325f, 0.01733465f, -0.00166813f, 0.01136522f, -0.00131301f, 0.00568168f, -0.01545796f, 
    0.02058733f, 0.01857367f, 0.01062307f, 0.00586208f, 0.01406065f, -0.01695680f, -0.03392801f, 0.00610023f, 
    -0.01601906f, 0.01877395f, -0.02554115f, 0.00642612f, 0.01752023f, 0.03287155f, 0.02355241f, 0.02491045f, 
    -0.00508560f, -0.01667129f, -0.03031422f, -0.02448985f, 0.02269517f, -0.02507810f, -0.01311953f, 0.01367042f, 
    0.01517715f, 0.01679571f, 0.01034462f, 0.01637993f, 0.01261757f, -0.03702218f, 0.02157634f, 0.02845929f, 
    0.00334374f, -0.00929732f, -0.01975025f, -0.02901375f, -0.02200518f, 0.01812074f, -0.00351593f, 0.00177569f, 
    0.00239137f, 0.01900276f, 0.02285575f, 0.02082327f, -0.01052187f, 0.02680933f, 0.01450646f, -0.01258112f, 
    -0.01856215f, 0.02331871f, 0.01877375f, 0.02571446f, -0.01931231f, -0.03574616f, 0.01714214f, -0.02751875f, 
    -0.02520600f, 0.02591421f, 0.03027690f, 0.01086843f, -0.00126415f, -0.04116308f, -0.00548401f, -0.03291012f, 
    -0.04159414f, 0.01677362f, 0.00715995f, -0.03260871f, -0.00928792f, 0.02243876f, -0.00587156f, -0.01446294f, 
    -0.00414434f, -0.03400697f, -0.02548505f, 0.01248318f, 0.01203676f, -0.01191863f, 0.02432525f, 0.01171434f, 
    0.01017905f, 0.00324957f, 0.00010872f, -0.03406903f, -0.01720284f, 0.00253722f, 0.01278838f, 0.00535037f, 
    -0.03792353f, -0.00488356f, -0.03627998f, -0.00159065f, 0.02140435f, -0.02012211f, -0.01661660f, 0.02884014f, 
    0.01794563f, -0.00034549f, 0.00021211f, -0.02675505f, -0.03730076f, -0.03005880f, -0.02120044f, 0.01865921f, 
    -0.01345482f, -0.01214312f, 0.02890272f, -0.03755723f, -0.01844396f, -0.01014381f, -0.02182521f, 0.02823688f, 
    -0.03294323f, -0.02249926f, 0.02173086f, -0.02615160f, -0.01469103f, -0.02622778f, -0.01488949f, -0.03355384f, 
    -0.02196947f, -0.03857738f, 0.00838851f, -0.01751214f, -0.00756036f, -0.03787738f, -0.02568835f, -0.01066036f, 
    0.01461544f, 0.03408772f, 0.02820973f, 0.02931578f, 0.00821978f, -0.01191700f, -0.02648538f, 0.01925018f, 
    0.01443542f, -0.04078104f, -0.00007237f, 0.01094947f, 0.00980103f, -0.00222200f, 0.00903166f, 0.03225314f, 
    -0.03514937f, -0.04079197f, -0.03474866f, -0.02606749f, -0.02613668f, -0.01012370f, -0.01191457f, -0.02504758f, 
    -0.00059230f, -0.01321321f, -0.00918821f, -0.03968963f, 0.02287709f, -0.03578497f, -0.00928317f, 0.01091686f, 
    -0.00850430f, 0.01496781f, -0.00704099f, -0.04044957f, 0.02875415f, -0.03085742f, 0.02432468f, -0.03913030f, 
    -0.00656533f, -0.03178994f, -0.00119271f, -0.03160573f, -0.01513993f, 0.02213403f, 0.00753850f, -0.03141426f, 
    0.02182396f, -0.01127346f, 0.00192638f, 0.00680965f, 0.00332426f, 0.01720753f, 0.01975155f, 0.02010941f, 
    0.00091110f, -0.00630580f, -0.02038908f, 0.01517510f, -0.00780753f, 0.02495724f, 0.02159877f, 0.00110888f, 
    0.00224350f, 0.00287917f, 0.00555866f, -0.03604409f, 0.00709480f, 0.00677731f, -0.04034489f, 0.01696723f, 
    -0.00960317f, -0.03847261f, -0.03074564f, -0.00993394f, -0.02805182f, 0.01397509f, -0.02276706f, 0.02805853f, 
    -0.01892849f, -0.02338235f, -0.02997626f, 0.02269320f, -0.04272250f, -0.02668501f, -0.03252932f, 0.01967361f, 
    -0.00690020f, -0.02795245f, -0.03301655f, -0.01335850f, 0.00609194f, 0.01354672f, 0.03300544f, -0.00951049f, 
    0.00038850f, 0.02488014f, 0.01845789f, -0.00124291f, 0.02651954f, -0.00425806f, -0.01114606f, -0.04078009f, 
    -0.01718106f, -0.01220698f, -0.00494531f, -0.03509590f, -0.04176104f, 0.02842891f, -0.02827802f, 0.02779836f, 
    -0.02479068f, 0.02249674f, 0.00645214f, -0.03694076f, 0.01730096f, -0.01114349f, 0.00842068f, 0.00154360f, 
    -0.01687132f, -0.01577041f, 0.02479812f, 0.01651679f, -0.02499081f, -0.02964432f, 0.02318224f, 0.00475578f, 
    -0.02420897f, 0.01325378f, -0.01072868f, -0.01945730f, -0.03011656f, 0.02442308f, -0.00433758f, -0.03677005f, 
    0.00175969f, 0.02575252f, -0.00603632f, -0.03610906f, -0.00798841f, 0.00931719f, -0.01616764f, 0.01694602f, 
    0.02958106f, 0.02611044f, 0.01595460f, -0.00407224f, 0.03127531f, -0.00072625f, -0.03175779f, -0.00703037f, 
    -0.00197597f, -0.03849319f, -0.02562211f, -0.02260827f, 0.00392161f, 0.02632421f, -0.03518578f, 0.00072285f, 
    0.00001948f, -0.01829524f, 0.00799914f, -0.00742276f, -0.02335898f, -0.00260493f, -0.03865698f, -0.01462028f, 
    -0.00609106f, -0.04171379f, -0.03611690f, -0.01117972f, -0.03752171f, 0.00518976f, -0.01585361f, 0.01972089f, 
    0.01306634f, -0.01269452f, 0.02716778f, -0.00411851f, 0.01595257f, -0.04244725f, -0.02490444f, 0.02886652f, 
    -0.02959591f, 0.01989945f, 0.00506121f, -0.01945151f, 0.02411691f, 0.00925984f, -0.02864445f, -0.00188902f, 
    0.02340278f, 0.00363829f, -0.01318149f, 0.00470716f, 0.00699627f, 0.02241979f, -0.01652432f, 0.00219938f, 
    -0.01691531f, -0.00864914f, 0.00828533f, -0.03171110f, 0.01177799f, 0.00564091f, 0.02504197f, -0.02023471f, 
    0.00977526f, 0.02582047f, -0.03458145f, 0.02660026f, -0.01791509f, -0.01316509f, -0.00520213f, 0.00086295f, 
    0.01136956f, -0.03363435f, 0.01668511f, -0.04029525f, -0.01346115f, -0.03237496f, -0.02264072f, 0.01706840f, 
    -0.03854109f, 0.00599148f, -0.00283869f, 0.00387912f, 0.01336410f, -0.01736002f, -0.03204489f, 0.01801767f, 
    -0.01015763f, -0.03392319f, -0.04123100f, 0.00920621f, 0.01868027f, 0.01720871f, 0.01996892f, 0.01153659f, 
    -0.00013783f, -0.01879817f, -0.01929998f, 0.03039851f, -0.01428693f, 0.01770435f, 0.02482172f, 0.01870150f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05181989f, -0.01543531f, 0.08830766f, -0.01516638f, 0.08128922f, 0.02111318f, 0.02639406f, -0.00776492f, 
    -0.01741494f, 0.01751167f, -0.00549928f, 0.00756320f, -0.01215238f, 0.01466954f, -0.03372976f, -0.03186421f, 
    -0.03231892f, 0.19975576f, 0.07233019f, 0.13180229f, 0.00966975f, -0.02342928f, 0.01140093f, -0.00596311f, 
    0.13129118f, -0.03899494f, -0.01739452f, -0.01814797f, -0.04723279f, 0.11830956f, -0.03803311f, -0.02160858f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.26983023f, 0.00572719f, -0.32006454f, 0.27102882f, -0.10647812f, -0.12093893f, 0.15845443f, -0.10925449f, 
    0.17115800f, 0.10438359f, -0.17773017f, 0.03883751f, -0.13274878f, -0.12069871f, -0.17410819f, 0.11643335f, 
    0.11910048f, -0.63429952f, -0.24424569f, -0.74894994f, 0.13963605f, 0.00236600f, 0.30085686f, 0.09843829f, 
    0.06536410f, 0.12405599f, 0.08824614f, 0.16284451f, 0.02270814f, 0.11222618f, -0.05787039f, -0.11349687f, 
    0.30892459f, -0.12095612f, 0.13064897f, 0.09998064f, -0.26107574f, -0.01246020f, -0.06938116f, 0.39942837f, 
    0.07969783f, -0.03907390f, 0.00084050f, 0.00073587f, 0.14983937f, -0.01615696f, 0.01130883f, -0.10502317f, 
    0.11261926f, 0.26037648f, 0.37235019f, -0.14283356f, -0.06118682f, -0.01630324f, 0.32743144f, -0.09295069f, 
    0.17756435f, -0.02535864f, -0.06025097f, 0.04116388f, -0.04871693f, -0.23429637f, -0.75797141f, 0.06572627f, 
    0.28024358f, 0.14978939f, 0.21243599f, 0.27597469f, 0.04616994f, 0.08217626f, 0.14141597f, -0.46664286f, 
    0.08635010f, -0.00823660f, -0.14322628f, 0.11390307f, 0.12483039f, 0.09561840f, -0.13090099f, 0.04526468f, 
    -0.06496066f, 0.24502221f, -0.54276103f, 0.30935425f, -0.10318021f, 0.14359806f, -0.37884751f, 0.07229988f, 
    -0.08223741f, -0.39141867f, 0.07421747f, 0.07444955f, 0.17077929f, 0.07571187f, -0.03987579f, 0.08131298f, 
    -0.09859100f, -0.03895508f, -0.91375136f, 0.22093272f, -0.40030330f, 0.10132349f, 0.12433955f, 0.27805200f, 
    -0.09165052f, -0.15811922f, 0.17942792f, 0.10778550f, 0.10552725f, -0.17377858f, 0.08049168f, -0.16385783f, 
    -0.11557900f, 0.17831899f, -0.29598919f, 0.07372476f, 0.08254140f, -0.03725977f, -0.33871621f, -0.11948018f, 
    0.40007028f, -0.01637419f, -0.09064120f, 0.12758808f, 0.08207506f, -0.29559612f, 0.37043917f, -0.08397159f, 
    0.09260570f, 0.01634986f, 0.02781934f, -0.09805396f, -0.09800792f, -0.06809236f, -0.13402657f, -0.46821010f, 
    -0.17889757f, 0.13193162f, 0.04318527f, -0.13065295f, 0.15085584f, -0.07939836f, -0.10405419f, 0.08618658f, 
    -0.06573382f, -0.08462436f, -0.14754586f, -0.12422259f, -0.14459386f, -0.10557102f, -0.18479733f, -0.11381385f, 
    -0.88009280f, 0.32000169f, -0.10566103f, -0.14479113f, 0.14690077f, 0.15278758f, 0.27848685f, -0.11201355f, 
    -0.15598445f, 0.14388005f, 0.20902754f, -0.16587040f, -0.09066739f, -0.12450780f, -0.16528729f, -0.14388703f, 
    -0.06518169f, -0.03401284f, -0.16103655f, -0.06150734f, -0.05192736f, -0.07774963f, 0.06643494f, -0.16000958f, 
    0.09799448f, 0.04050582f, -0.59910315f, 0.02942033f, -0.16129284f, -0.05501521f, -0.09090568f, -0.12621513f, 
    0.17261261f, 0.18570043f, 0.02040692f, 0.14091104f, -0.09770896f, 0.61356330f, -0.40990093f, 0.17084554f, 
    0.13393463f, 0.16515006f, -0.35068461f, -0.11896270f, 0.24738491f, -0.01514013f, 0.00053989f, -0.63995242f, 
    0.10723291f, -0.00601779f, 0.03422293f, -0.10315996f, 0.02710273f, 0.17243797f, 0.08906590f, -0.03566665f, 
    0.08926650f, 0.28567240f, 0.17713010f, -0.48283771f, -0.15088320f, 0.11314365f, 0.14738429f, -0.01893807f, 
    0.00876571f, -0.69629866f, 0.15339002f, -0.05300855f, 0.11023907f, 0.20222180f, 0.38246396f, 0.09840266f, 
    -0.25038555f, 0.05538063f, 0.33442199f, -0.13092588f, 0.28973627f, -0.08718052f, -0.15802628f, 0.37226212f, 
    -0.07743306f, 0.09887252f, -0.04050083f, 0.16302854f, 0.02937649f, 0.06659023f, 0.04710257f, 0.14372139f, 
    -0.08163304f, -0.07661527f, -0.32685280f, -0.03676452f, 0.08308179f, -0.01609637f, 0.13702571f, -0.01183686f, 
    0.02047553f, -0.04558533f, -0.12409909f, 0.14970811f, -0.08997869f, -0.52402359f, 0.04401994f, -0.01018781f, 
    -0.00154848f, 0.09338752f, -0.49284223f, -0.08959468f, 0.30440944f, -0.16922981f, 0.11547640f, -0.07126033f, 
    0.00022723f, 0.17072570f, 0.03455035f, 0.09252832f, -0.00933129f, 0.09555393f, -0.02403993f, 0.10747784f, 
    -0.01174850f, -0.37031037f, 0.19449960f, 0.43300974f, -0.10840276f, -0.04708803f, 0.02990813f, 0.16505080f, 
    0.46832624f, -0.22343270f, -0.13574541f, 0.06557997f, 0.11462124f, 0.15477420f, -0.57298404f, 0.16058022f, 
    -0.50259340f, -0.07255051f, 0.13619843f, 0.27770850f, 0.18573827f, 0.03385756f, -0.01456138f, 0.24236159f, 
    -0.13936780f, -0.11708499f, 0.05885106f, 0.09094594f, -0.00646513f, -0.08616538f, 0.11142021f, 0.12409557f, 
    0.05340618f, 0.09385488f, 0.41470346f, -0.67083442f, 0.11124440f, 0.09965856f, -0.49586913f, 0.02630501f, 
    -0.49153334f, -0.08028385f, -0.08332021f, 0.00139984f, 0.00106005f, 0.21959132f, 0.00449375f, 0.03842431f, 
    -0.36839414f, -0.07974140f, 0.20406763f, -0.53244644f, -0.50353330f, -0.07120180f, -0.16886032f, -0.39700016f, 
    -0.17739722f, -0.02162086f, -0.12644356f, 0.14136875f, -0.14181551f, -0.02241740f, 0.11143708f, 0.06244167f, 
    0.07322365f, -0.10863982f, 0.63360858f, 0.14226416f, -0.16645798f, -0.12517849f, 0.29667023f, -0.18205754f, 
    0.23774810f, 0.03820945f, 0.01240730f, 0.02780911f, 0.06817912f, 0.02852883f, 0.31716532f, 0.14472926f, 
    0.53558552f, -0.13284959f, -0.61189991f, -0.54723430f, -0.06370982f, -0.00029095f, 0.00587116f, 0.25351876f, 
    -0.09630232f, -0.16035812f, 0.09665048f, 0.09596578f, -0.12634924f, -0.12344553f, -0.08656516f, -0.04067959f, 
    0.05034199f, 0.09987732f, 0.26677573f, 0.25203761f, -0.18221883f, -0.06932735f, -0.58582270f, 0.00454626f, 
    -0.01761094f, -0.06897458f, 0.10203255f, -0.07635640f, 0.14729504f, 0.17168513f, 0.19550766f, -0.03758666f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06957593f, -0.00771929f, 0.08485940f, -0.06706559f, -0.03069906f, -0.09593190f, -0.17623088f, -0.28880173f, 
    -0.07682869f, 0.16887480f, -0.20184201f, 0.06030026f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
