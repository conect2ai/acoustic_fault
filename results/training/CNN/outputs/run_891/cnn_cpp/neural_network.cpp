#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.21937533f, -0.31674701f, -0.69733620f, -0.81569797f, -0.15890749f, -0.02921948f, -0.31026721f, -0.23316495f, 
    -0.39993465f, 0.15868975f, 0.02597750f, -0.21401776f, 0.39712846f, 0.33959717f, 0.02761458f, 0.19126527f, 
    0.19701774f, 0.00712422f, 0.20908882f, 0.21657598f, 0.18184474f, -0.21918882f, 0.47389990f, -0.22447351f, 
    -0.47109923f, -0.49648133f, -0.23382103f, 0.42051172f, 0.11013631f, -0.77295488f, 0.18315606f, 0.20403270f, 
    -0.35948393f, -0.38336316f, -0.43889099f, -0.15741464f, 0.04504816f, -0.41381401f, -0.09523132f, -0.13370556f, 
    -0.52878249f, 0.27211782f, -0.24099220f, 0.20911168f, -0.67661285f, -0.16750222f, -0.04993781f, -0.11824521f, 
    0.06885356f, 0.22269055f, 0.90935916f, 0.26587638f, 0.45225817f, 0.70873821f, -0.62540519f, -0.46662173f, 
    -1.00709558f, -0.12306614f, 0.11472993f, -0.17895858f, -0.19420572f, 0.08320970f, 0.22956572f, -0.05614509f, 
    -0.05152213f, -0.31066287f, -0.21592812f, -0.21939835f, -0.00348317f, 0.31308582f, 0.12439187f, 0.35114560f, 
    0.16249132f, -0.15012474f, -0.04646315f, 0.82125938f, 0.73696911f, 0.77011341f, 0.65426910f, 0.19891559f, 
    0.26486832f, 0.55568534f, -0.45370656f, 0.15939422f, 0.53236264f, -0.13564229f, 0.25031501f, -0.15726209f, 
    0.16291381f, -0.24952562f, -0.27499184f, -0.17349696f, 0.14453462f, -0.23520645f, -0.28957015f, 0.03098533f, 
    0.32554320f, -0.02547695f, -0.11668959f, 0.38030717f, 0.82066536f, 1.07699502f, 0.38918012f, -0.84763539f, 
    -0.93341529f, 0.07707146f, -0.14936596f, -0.14007717f, -0.53819269f, -0.16437168f, 0.35870883f, -0.02784533f, 
    -0.13268796f, 0.28557667f, 0.19426960f, 0.00566692f, -0.00967652f, -0.14458573f, -0.04913431f, 0.01414749f, 
    -0.12291382f, 0.29534861f, 0.09938936f, -0.33499849f, 0.20244864f, 0.67768770f, 0.67860973f, 0.74017417f, 
    0.58993506f, 0.84589124f, -0.25426307f, -0.16700079f, -0.32245067f, -0.43896568f, -0.07745232f, 0.39710623f, 
    0.29938465f, -0.18141010f, -0.01205448f, 0.23573555f, 0.16356423f, 0.20542279f, 0.24353410f, 0.08623115f, 
    0.33615905f, 0.20599577f, 0.02795559f, -0.02119917f, 0.00874009f, 0.13294856f, -0.62729365f, 0.03370775f, 
    -0.29954284f, -0.99538302f, -0.69255275f, 0.09532842f, 0.53961337f, 0.19730633f, 0.70198482f, 0.07203154f, 
    0.06933915f, -0.00658643f, -0.51157868f, -0.26963565f, 0.13315372f, 0.19038594f, 0.12978567f, -0.02936665f, 
    0.25073528f, 0.04262561f, 0.16168387f, -0.27076480f, -0.01328529f, -0.18868002f, 0.03330358f, -0.94393605f, 
    0.27145082f, -0.44767383f, -0.55088162f, -0.15499777f, 0.76792014f, 0.26353285f, -0.57101005f, 0.55847335f, 
    -0.11941930f, 0.30100262f, -0.11510208f, -0.19821855f, 0.20224570f, 0.06156364f, 0.15206540f, -0.24416377f, 
    -0.18468200f, -0.05239772f, 0.14731261f, 0.21921426f, -0.08973437f, 0.32262638f, 0.31654969f, 0.39274386f, 
    -0.34368646f, -1.00145626f, -0.76050109f, -0.54669517f, -0.42932203f, 0.15711181f, -0.00113076f, -0.54701912f, 
    0.05305302f, 0.20433882f, -0.04195397f, -0.13481614f, 0.39701504f, 0.12294434f, -0.13796452f, 0.05406237f, 
    0.27455658f, 0.60958678f, 0.36684245f, -0.26475370f, -0.12995355f, -0.13960266f, -0.21554115f, 0.09510395f, 
    0.00917652f, 0.59526873f, -0.16238412f, -0.38982579f, 0.13261817f, 0.50707686f, -0.68853593f, -0.80982286f, 
    -0.81401330f, -0.62473047f, 0.00535654f, 0.17830439f, 0.53274840f, 0.00129534f, 0.23248814f, -0.18575735f, 
    0.09505004f, -0.11977687f, 0.11472184f, 0.19174531f, -0.00440153f, -0.02262981f, 0.16762842f, -0.20535743f, 
    0.06457087f, 0.34680310f, 0.51076829f, 0.41888905f, 0.38856202f, -0.37116644f, -0.63492274f, -0.62397325f, 
    -0.58151698f, -0.07714413f, 0.21455434f, -0.15820406f, 0.30411312f, -0.23354478f, -0.56998849f, -0.38812602f, 
    -0.44288951f, 0.11752073f, -0.25131619f, -0.00021564f, 0.05795315f, -0.23616603f, 0.09903548f, -0.25327674f, 
    -0.28075099f, -0.04966738f, 0.25348952f, 0.90470290f, -0.05192133f, -0.02434524f, -0.69766426f, 0.28571299f, 
    0.95480180f, 0.42759252f, 0.58182836f, 0.45199120f, 0.03838262f, -0.02929254f, 0.32259607f, 0.00911376f, 
    0.07732194f, -0.02295925f, -0.15678495f, -0.13981842f, 0.12286456f, 0.26811606f, 0.28517982f, -0.10995528f, 
    0.10414305f, -0.27494827f, -0.37359038f, 0.03212647f, 0.94666165f, -0.32012933f, 0.65786248f, 0.87661523f, 
    0.37441725f, 0.31488866f, 0.00807125f, 0.44464603f, -0.28850141f, -0.60327810f, -0.09019524f, -0.51826417f, 
    -0.31994626f, -0.04685976f, -0.21542056f, 0.03298566f, 0.14760795f, 0.16834775f, 0.31839398f, 0.12533481f, 
    -0.10169084f, 0.03478888f, -0.05546685f, -0.02923845f, -0.17738803f, -1.22787285f, -0.07579406f, -0.17267835f, 
    0.26264754f, 0.18467920f, -0.64470261f, 1.36818707f, 0.02847987f, -0.26099607f, 0.32552701f, -0.38581559f, 
    0.02508236f, 0.20877364f, -0.05730944f, 0.14881973f, -0.05860074f, -0.20654818f, -0.16852294f, -0.00099973f, 
    -0.13233328f, 0.21748057f, -0.00182205f, -0.14210182f, -0.08825290f, -0.14217672f, -0.83999610f, -0.67455173f, 
    -0.69345981f, 0.00674591f, -0.09428652f, 0.61207873f, 0.45985311f, 0.11540519f, 0.51058131f, 0.68219757f, 
    -0.05157685f, -0.43251207f, -0.13753256f, -0.14811282f, 0.01932956f, -0.34372461f, -0.06066138f, -0.22029842f, 
    -0.34431377f, -0.23664418f, -0.33791617f, -0.09565886f, -0.20456643f, -0.04910175f, -0.18070959f, 0.97264975f, 
    0.69046640f, -0.22179523f, 0.16631195f, 0.30059278f, -0.13191524f, 0.36172017f, 0.23803520f, -0.08700584f, 
    0.23735812f, 0.07677267f, 0.37781036f, 0.34121725f, -0.13700262f, -0.01908863f, 0.36464950f, -0.22711526f, 
    0.33794445f, -0.03826065f, 0.19300452f, -0.09923176f, -0.30112499f, 0.14702602f, 0.03264608f, -0.04743557f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21471831f, -0.04565127f, 0.15062495f, 0.17735690f, 0.25687993f, 0.20555364f, 0.01158801f, 0.17693600f, 
    0.24897450f, 0.35895756f, 0.26474795f, 0.16693491f, -0.04057295f, 0.24572763f, -0.01842002f, 0.02579552f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05865733f, -0.00285578f, -0.04349368f, -0.01792447f, -0.02783716f, 0.00506476f, 0.00221740f, -0.00726371f, 
    0.06067507f, -0.05675752f, -0.05724772f, -0.04128164f, 0.04624683f, -0.03866380f, -0.02807717f, 0.04489453f, 
    -0.00876140f, 0.03723192f, -0.05426715f, -0.00493790f, -0.07032572f, 0.00240976f, -0.07982129f, 0.00526824f, 
    -0.07191414f, -0.04718942f, -0.05898428f, 0.00501517f, 0.00964826f, 0.02290601f, 0.06012722f, 0.05102491f, 
    -0.05270665f, -0.05590753f, 0.02640980f, -0.01028681f, -0.06560212f, -0.00774615f, 0.03478720f, -0.02753483f, 
    0.02825574f, -0.07652185f, 0.01590807f, 0.03630198f, 0.05912706f, -0.06722934f, -0.05779854f, 0.06223040f, 
    -0.00099022f, -0.07189862f, -0.05591105f, 0.03837147f, 0.01512886f, -0.02824606f, 0.02617848f, 0.01795799f, 
    -0.02077748f, -0.07209818f, -0.06310544f, -0.05984059f, -0.07546818f, -0.07213812f, 0.00290958f, 0.03270316f, 
    -0.03458838f, -0.05144895f, -0.05051714f, -0.06295247f, -0.05264884f, -0.00920847f, -0.02138670f, 0.01989686f, 
    -0.00504172f, 0.00425776f, -0.05880670f, -0.06856636f, 0.04748702f, -0.02259308f, 0.04641893f, 0.02776035f, 
    0.03385562f, 0.01552195f, -0.01314230f, -0.02813726f, 0.00466668f, -0.02099610f, 0.05161427f, 0.00720797f, 
    -0.03707054f, 0.03267549f, -0.00984796f, 0.04034168f, 0.05828869f, -0.02802363f, -0.01338314f, 0.01723728f, 
    -0.02350657f, -0.04056240f, 0.04809863f, 0.06202465f, -0.07328632f, 0.05483862f, 0.01001535f, 0.04132553f, 
    -0.06352724f, -0.06251977f, 0.00430668f, 0.03633984f, 0.05325646f, 0.00892758f, -0.01999052f, 0.03793728f, 
    0.01124882f, -0.01681285f, 0.00749888f, -0.03082299f, 0.04750937f, -0.07999915f, 0.01488543f, 0.05647816f, 
    -0.07998837f, 0.00103968f, -0.05454855f, 0.01461713f, -0.04771002f, 0.05463453f, -0.03784987f, 0.02871600f, 
    0.04210876f, 0.00587314f, 0.00767092f, 0.00899472f, -0.03730779f, -0.07390268f, 0.05699780f, 0.03586841f, 
    0.04770611f, 0.04023457f, 0.00522394f, -0.05640061f, 0.03353769f, -0.00073918f, 0.02629568f, -0.02657053f, 
    0.02608187f, 0.00571616f, 0.05277121f, -0.04133483f, 0.02957121f, -0.06734497f, -0.02737052f, -0.04333374f, 
    -0.04593579f, -0.05323542f, -0.07431464f, 0.05402869f, -0.00458604f, 0.01200983f, -0.00963199f, -0.04353125f, 
    0.04088887f, -0.01506863f, 0.04462265f, 0.02014409f, -0.05668435f, 0.04981809f, -0.05786514f, 0.02143722f, 
    -0.02642353f, -0.06720434f, 0.05398981f, 0.03531545f, 0.00902701f, -0.02531511f, -0.01390232f, -0.06101258f, 
    -0.07539209f, 0.01655045f, -0.06140717f, -0.06108962f, -0.04886304f, 0.06092251f, -0.00204765f, 0.06559443f, 
    -0.02005606f, 0.05138120f, 0.05819592f, 0.03032735f, -0.02969002f, 0.05327986f, -0.01489808f, 0.03218547f, 
    0.13114507f, 0.10036539f, -0.06719151f, -0.07546785f, 0.02268007f, 0.17516780f, -0.01612063f, -0.06447601f, 
    0.08962648f, -0.25395995f, -0.26856622f, -0.07286800f, 0.10633433f, -0.09254188f, 0.24142906f, 0.09556270f, 
    -0.02944557f, -0.00659502f, -0.15991053f, 0.00415071f, 0.21039319f, 0.11799748f, 0.07843540f, 0.20175588f, 
    -0.04795376f, 0.15473275f, -0.07097194f, 0.14302835f, 0.10794409f, 0.11548591f, -0.24227971f, -0.25463834f, 
    0.06318724f, -0.05280254f, -0.08616316f, -0.01858829f, 0.11203072f, 0.15427177f, -0.16284512f, -0.24382097f, 
    0.08927254f, -0.16780013f, -0.24115457f, -0.16452244f, -0.03772397f, 0.13641065f, -0.05642986f, 0.21277066f, 
    0.04126497f, -0.17368098f, 0.26285532f, -0.09465190f, -0.07133035f, 0.08916088f, 0.05726037f, 0.00938911f, 
    -0.00540714f, 0.03706770f, -0.04480424f, -0.03897627f, 0.18593505f, 0.19850281f, 0.04323854f, -0.12103101f, 
    -0.05364486f, -0.18046203f, -0.06446445f, -0.21140742f, 0.06113968f, -0.27530673f, -0.07123696f, -0.17145930f, 
    0.33910397f, 0.22471674f, 0.15292813f, 0.10367933f, 0.00551084f, 0.12445438f, 0.11441232f, 0.11001325f, 
    -0.22330432f, 0.04607365f, 0.08860786f, -0.03709687f, 0.33372062f, -0.01231118f, 0.14818317f, -0.05970917f, 
    0.04695514f, -0.16188179f, -0.04104398f, 0.03565358f, -0.01165867f, -0.12994134f, 0.12180819f, 0.05060570f, 
    0.09718797f, -0.00489102f, 0.18726090f, 0.00200709f, 0.07199021f, -0.05633040f, 0.06957675f, 0.11744103f, 
    0.13203765f, -0.00870482f, -0.51650858f, -0.05383326f, 0.09829845f, 0.00148121f, 0.12666570f, 0.14026818f, 
    0.11073460f, -0.15242212f, 0.18482746f, -0.03378304f, -0.02021814f, 0.11315566f, -0.15715812f, -0.03221891f, 
    0.17499056f, -0.07243312f, 0.00929644f, -0.06374142f, -0.14540249f, -0.11809991f, -0.10682922f, -0.14050642f, 
    0.05772455f, 0.11673991f, 0.12116541f, -0.00050972f, -0.07825715f, -0.09758160f, -0.21716182f, -0.17098022f, 
    0.10201190f, -0.01230763f, 0.31035009f, 0.06161136f, 0.04594970f, 0.00649733f, -0.11014109f, -0.05135542f, 
    0.26597899f, 0.14543413f, -0.23141111f, -0.15291190f, -0.14701530f, -0.09805319f, 0.04338481f, -0.19287437f, 
    -0.05222312f, -0.05959777f, 0.05319520f, 0.15278547f, 0.50759482f, -0.19282478f, 0.11617784f, 0.03977254f, 
    -0.07050424f, 0.08748856f, 0.09430340f, 0.11817861f, -0.19314875f, -0.00389123f, 0.04284798f, 0.11207329f, 
    0.21002790f, -0.26222804f, 0.08038551f, -0.08106182f, 0.01364662f, 0.13919756f, 0.11584347f, 0.35117242f, 
    -0.07728456f, 0.08108063f, 0.27070689f, 0.41539538f, 0.00909134f, 0.27581844f, -0.10388429f, -0.01222437f, 
    0.01622872f, 0.00702108f, -0.14002471f, 0.04176388f, 0.08442640f, 0.12577330f, 0.04228613f, -0.25994042f, 
    -0.04352714f, -0.04949744f, -0.05207665f, -0.06197379f, 0.03702526f, -0.13993065f, 0.00028407f, 0.05387028f, 
    0.11554697f, 0.12416360f, 0.08552508f, -0.00140945f, -0.13930510f, -0.05561745f, -0.16165778f, -0.03505311f, 
    -0.13996920f, 0.19662349f, 0.14590429f, 0.02982165f, -0.01779424f, 0.01001145f, -0.11008317f, -0.15498744f, 
    -0.00126100f, -0.08762763f, 0.25752717f, 0.01433261f, 0.10112945f, -0.15072693f, 0.07707859f, 0.05287105f, 
    0.09265156f, 0.11214176f, 0.00413368f, 0.09130950f, 0.04933158f, -0.23794785f, -0.15017602f, 0.16748483f, 
    0.05242243f, 0.04582977f, -0.05353103f, -0.02541476f, 0.15605386f, -0.04478562f, 0.05702806f, -0.08621131f, 
    -0.04675964f, 0.23653103f, -0.34065673f, -0.06884179f, -0.09886333f, 0.06225348f, -0.02259316f, 0.07869156f, 
    0.10479274f, 0.08756940f, 0.13240688f, 0.12864928f, 0.14590953f, 0.08416847f, -0.02846102f, 0.10833634f, 
    0.03390144f, 0.09706967f, 0.06517917f, 0.10875093f, -0.01148659f, 0.06772929f, 0.03893510f, 0.22750618f, 
    0.28694302f, 0.01384400f, 0.05634709f, -0.03908894f, -0.09654004f, -0.04068085f, -0.09415794f, -0.23929410f, 
    -0.05369258f, 0.09614300f, -0.14191110f, 0.01528837f, 0.38959602f, -0.07623505f, -0.05714537f, 0.03108066f, 
    -0.01010112f, 0.05171711f, 0.10833120f, -0.00794258f, 0.15587518f, -0.06993720f, -0.12459987f, 0.07703836f, 
    -0.01357162f, 0.17735821f, -0.01974828f, 0.16609529f, -0.16288313f, 0.15374002f, -0.06579936f, -0.12987402f, 
    0.09529619f, -0.16585028f, 0.15698946f, -0.13367738f, 0.15339534f, -0.00206249f, 0.04117075f, 0.12021232f, 
    -0.16351534f, 0.01929086f, 0.13170265f, 0.07387629f, 0.04008984f, -0.20211202f, 0.19960979f, 0.18846668f, 
    0.11007638f, 0.19740024f, 0.09210225f, 0.02553946f, 0.16386949f, 0.24928570f, -0.05370906f, -0.00534981f, 
    0.09044240f, -0.08691800f, 0.12842567f, 0.16987637f, 0.01015091f, 0.00280240f, -0.10152774f, 0.04418242f, 
    -0.16022904f, 0.00662168f, 0.02044790f, -0.18739414f, 0.11700906f, -0.07905123f, 0.09084039f, 0.00334151f, 
    -0.33413351f, -0.13910908f, 0.10759185f, -0.04872182f, -0.10911599f, -0.10012691f, -0.14679116f, -0.06043736f, 
    -0.00570398f, 0.07626480f, 0.17747575f, -0.03978670f, -0.56962991f, 0.05109599f, 0.04635615f, 0.02743847f, 
    0.21721689f, 0.00481306f, 0.00922872f, -0.07586604f, 0.09962025f, 0.20562191f, 0.10315870f, -0.05959164f, 
    0.00732072f, -0.12512285f, 0.09172726f, -0.06115815f, -0.16997474f, -0.07458059f, 0.15906300f, -0.08811548f, 
    -0.05165804f, -0.01371149f, -0.11791541f, -0.17207214f, -0.15116742f, 0.01413422f, -0.17955744f, 0.01547769f, 
    0.03195884f, -0.02379111f, 0.08521438f, -0.14366825f, -0.02248527f, -0.01627989f, 0.07717913f, -0.03311684f, 
    -0.04804435f, 0.05592069f, -0.04818868f, -0.07225857f, 0.03333374f, -0.02369834f, -0.05387282f, -0.07285929f, 
    -0.03991947f, -0.06617142f, 0.04489484f, 0.06177902f, -0.06938910f, 0.01426055f, -0.04910063f, 0.05592024f, 
    -0.02788668f, -0.01583629f, 0.00926879f, 0.04701060f, 0.04967421f, 0.05360388f, 0.04013122f, 0.05819010f, 
    -0.06614000f, -0.00818796f, 0.01789461f, -0.07563650f, 0.02843298f, -0.00494188f, -0.06016807f, 0.03878715f, 
    0.05555297f, 0.03914119f, -0.02420075f, -0.06446397f, -0.02071812f, -0.01240799f, 0.02843167f, -0.00553018f, 
    0.04566032f, 0.02810867f, -0.03781072f, -0.03725982f, 0.04492540f, -0.01343545f, -0.04369766f, -0.04094282f, 
    0.04212709f, 0.04520949f, -0.00588444f, 0.00277078f, 0.00257506f, 0.04657735f, 0.04157626f, -0.06515587f, 
    0.04415216f, -0.04989811f, -0.02570386f, 0.04904816f, 0.03718901f, -0.05734371f, -0.04121178f, 0.06009464f, 
    -0.07312080f, 0.05650243f, 0.05249189f, -0.02565961f, 0.01453377f, 0.01470995f, -0.05497477f, -0.04358365f, 
    -0.05790136f, -0.01013015f, -0.01820001f, -0.07678021f, -0.02076024f, -0.06600260f, -0.06047536f, -0.03994169f, 
    0.01546318f, 0.03842830f, 0.06373214f, 0.05610537f, -0.07740185f, 0.04320504f, 0.01135683f, -0.01077337f, 
    -0.07326940f, 0.06132602f, 0.05558435f, 0.06255256f, -0.05709681f, -0.03416942f, 0.05767171f, -0.06132329f, 
    -0.07255626f, -0.04381376f, 0.04407214f, 0.02745838f, -0.06317709f, -0.02446721f, -0.00569684f, -0.05607864f, 
    -0.01005324f, 0.04540861f, -0.06764118f, -0.02693121f, 0.04008861f, -0.02833492f, -0.00606861f, -0.02227469f, 
    -0.05155884f, -0.02246876f, 0.03206312f, 0.05839554f, -0.02143078f, -0.02719037f, 0.00556253f, -0.01887015f, 
    -0.00816924f, -0.04853947f, 0.04500062f, 0.06399843f, -0.00444092f, -0.05470902f, 0.00052164f, -0.02533893f, 
    0.01797694f, -0.05610453f, 0.00568579f, 0.00310033f, 0.03418966f, -0.03441468f, -0.07017997f, -0.05958178f, 
    0.02609892f, 0.05529904f, -0.05751485f, -0.05042147f, -0.04549506f, -0.03305998f, 0.01044811f, -0.06230232f, 
    0.02371460f, -0.06421885f, 0.03840699f, 0.01559884f, 0.06244791f, 0.01122656f, -0.02531869f, 0.03498117f, 
    -0.04128009f, -0.00843488f, -0.03234353f, -0.03652562f, -0.03318247f, -0.06302836f, -0.05159568f, -0.05033993f, 
    -0.06454221f, 0.06143504f, 0.00497827f, -0.02265775f, 0.00416350f, -0.03502048f, -0.06717716f, -0.00120746f, 
    0.00347953f, -0.06181547f, -0.00303178f, 0.05097827f, -0.06416249f, -0.07943349f, -0.05309153f, 0.05875547f, 
    -0.06539001f, -0.05156525f, -0.03470534f, 0.05621862f, 0.05229543f, -0.01744891f, 0.06133831f, -0.06280296f, 
    -0.05772937f, 0.05825087f, -0.05750708f, 0.02586668f, -0.06607451f, 0.06857741f, -0.05529398f, -0.05884767f, 
    -0.07555059f, -0.00836919f, 0.05450982f, -0.05722720f, -0.08876064f, 0.10124513f, -0.08932404f, -0.01597196f, 
    -0.09824886f, 0.00530590f, -0.18109302f, 0.08700621f, -0.06169433f, 0.17348674f, 0.14435178f, 0.17572866f, 
    0.11826877f, 0.03844339f, -0.05602327f, -0.03256567f, 0.11949905f, 0.08717881f, 0.10771646f, 0.01774001f, 
    0.30070269f, 0.02196582f, -0.37694034f, 0.10661235f, 0.01993257f, 0.09964421f, -0.16621147f, -0.07433485f, 
    -0.10147686f, 0.03362981f, -0.07810879f, 0.04636969f, -0.09012061f, -0.13925926f, 0.03816837f, -0.06658110f, 
    0.06500145f, -0.02713705f, 0.00722534f, -0.00766949f, -0.07636979f, 0.19653648f, -0.12373870f, -0.01526808f, 
    -0.15210173f, -0.20703331f, 0.45332333f, -0.20302624f, -0.04247237f, -0.07808128f, 0.09930116f, -0.02231067f, 
    -0.05083289f, 0.05383539f, -0.02900428f, 0.00925926f, -0.02831580f, -0.23881912f, -0.00899376f, 0.13921013f, 
    0.08056293f, -0.03814454f, 0.06340422f, -0.10601074f, -0.01489642f, -0.06351804f, 0.02594634f, -0.11250080f, 
    0.12666658f, 0.31840801f, 0.23527521f, -0.12796719f, 0.04631869f, 0.02526227f, 0.05407148f, 0.13290536f, 
    0.03991241f, -0.05217294f, 0.05553172f, 0.08669384f, 0.07366718f, 0.17926466f, 0.19695841f, -0.07216893f, 
    0.01604418f, -0.24684930f, 0.06961035f, 0.00567639f, 0.02516558f, 0.03069969f, 0.07760814f, -0.09843900f, 
    0.04653286f, -0.09915008f, 0.21744068f, 0.00387612f, 0.08216146f, -0.01950237f, -0.04386039f, 0.17122337f, 
    -0.04250067f, -0.07795443f, -0.13943899f, 0.10775456f, -0.06876136f, 0.06787319f, 0.20257656f, 0.14628336f, 
    0.00848054f, -0.06329043f, 0.02592855f, -0.01624689f, -0.05992039f, 0.15224648f, -0.05202260f, -0.06441588f, 
    0.07515357f, -0.09124371f, 0.09616791f, 0.08133565f, -0.19585818f, -0.11122739f, -0.01970338f, 0.08781430f, 
    0.01403300f, 0.19819757f, 0.07285970f, -0.07546105f, 0.12223890f, 0.03972456f, 0.08685447f, -0.31188586f, 
    0.10626214f, -0.07606693f, -0.05159322f, 0.04588444f, -0.02222814f, 0.00712421f, -0.06838449f, 0.08539263f, 
    -0.00819105f, -0.05028075f, -0.12924483f, 0.28225347f, -0.05819549f, 0.09522296f, 0.10030063f, 0.06353431f, 
    -0.07130182f, -0.00680792f, -0.16029736f, -0.09029667f, 0.35880354f, 0.17612410f, 0.12030862f, -0.13033292f, 
    -0.01323122f, -0.03729441f, -0.04636420f, 0.18015069f, -0.04222581f, 0.05564403f, -0.06827512f, 0.07578201f, 
    0.19137140f, 0.28356904f, -0.02341132f, 0.06757545f, 0.09592742f, -0.08396965f, 0.01879736f, 0.19441544f, 
    0.11240652f, -0.00109425f, 0.05953208f, -0.00570915f, 0.02759057f, -0.10959197f, 0.05950316f, -0.04288882f, 
    0.04345664f, 0.02627699f, 0.08775876f, 0.18540986f, -0.00345512f, -0.03304069f, -0.01768392f, -0.01193596f, 
    -0.03153095f, 0.05006316f, 0.00894283f, -0.00462688f, -0.06794637f, -0.02275923f, -0.00019501f, 0.03703539f, 
    -0.00355164f, 0.05584264f, 0.05783063f, -0.01293268f, -0.05063082f, 0.02699380f, -0.05573443f, -0.01764365f, 
    0.00514422f, 0.00862576f, -0.00681167f, -0.04780452f, 0.03186337f, -0.03776729f, -0.07574489f, 0.01038729f, 
    0.02372851f, -0.06559435f, -0.02809533f, -0.06799509f, 0.03788034f, 0.03172742f, 0.01951625f, 0.05765877f, 
    0.01461698f, -0.07942218f, 0.00427820f, 0.04406761f, 0.01771198f, -0.06410741f, -0.01595445f, 0.02665371f, 
    0.05391259f, -0.07185442f, -0.03560239f, -0.02230334f, 0.00585272f, -0.01047585f, 0.05397565f, -0.05272086f, 
    -0.01502315f, 0.03068310f, -0.06617434f, -0.01775500f, 0.02507065f, -0.01498684f, -0.00174931f, -0.07792584f, 
    0.00312954f, -0.07282624f, -0.02461125f, -0.02054575f, -0.07549764f, -0.06347226f, -0.07344570f, 0.01114994f, 
    -0.05705976f, -0.06666800f, 0.05571686f, -0.07904793f, -0.04261531f, 0.05257994f, 0.03978964f, 0.04944395f, 
    -0.01367249f, -0.04157451f, -0.05333315f, 0.02951018f, -0.03823951f, -0.04537607f, -0.04452633f, 0.05710015f, 
    -0.00184559f, -0.02808977f, -0.04313534f, -0.02676923f, 0.03253489f, 0.04547849f, 0.05464967f, -0.05026559f, 
    0.05393954f, 0.02982315f, 0.04219088f, -0.01549749f, -0.06497521f, 0.00964889f, -0.02550965f, -0.02374038f, 
    -0.01349968f, -0.07854556f, -0.06314481f, 0.01838454f, 0.06518236f, 0.01042207f, -0.02082103f, 0.03994539f, 
    -0.06100745f, -0.05119351f, 0.03872747f, -0.00153869f, -0.06484849f, 0.05948888f, -0.03245767f, 0.01114549f, 
    0.03577945f, -0.01858784f, -0.02529177f, -0.00728163f, 0.01287767f, -0.05375341f, -0.03339366f, -0.01169502f, 
    -0.05299931f, -0.06902286f, 0.03040474f, 0.02439567f, -0.02188407f, -0.01813806f, -0.04501380f, -0.06020236f, 
    0.02670073f, 0.05370233f, -0.00471800f, -0.02926980f, 0.00019695f, -0.00062835f, 0.02252233f, -0.02559287f, 
    -0.01951147f, -0.02039611f, 0.03538463f, -0.07496191f, -0.00922863f, -0.05209826f, 0.00315640f, 0.01122585f, 
    0.05130649f, 0.02042318f, 0.06282233f, 0.05966019f, 0.04635994f, 0.02513089f, 0.02345034f, -0.04352335f, 
    -0.01847426f, -0.04002599f, 0.05321073f, -0.07316729f, -0.04593104f, 0.06108497f, -0.01117387f, -0.07635354f, 
    0.01033250f, 0.03137194f, 0.05702741f, -0.07442696f, -0.06909558f, -0.07031029f, -0.01809032f, -0.03822793f, 
    0.03957095f, -0.06735234f, -0.06333857f, 0.02573533f, -0.01956289f, 0.04505078f, 0.00002845f, 0.00191940f, 
    -0.03457758f, 0.03199965f, -0.04850692f, -0.01677444f, -0.06855389f, -0.02566670f, -0.06412055f, -0.03085623f, 
    0.02595501f, -0.07431631f, -0.06819838f, 0.02705453f, -0.06122854f, 0.00778827f, -0.03048710f, 0.04147963f, 
    0.05683117f, -0.17498456f, -0.04362294f, 0.02929239f, -0.12037627f, -0.08850694f, 0.13181415f, 0.04179895f, 
    0.16858599f, 0.02846363f, 0.02326255f, -0.06011481f, -0.25351810f, -0.02604792f, -0.06000148f, -0.04825768f, 
    -0.04331914f, 0.00409521f, 0.06348185f, 0.06857253f, -0.04258600f, -0.05004267f, 0.00882328f, -0.11315870f, 
    0.03454505f, -0.25256348f, -0.06670505f, 0.22062410f, 0.02227661f, 0.11900989f, -0.18989217f, -0.16707298f, 
    0.10849145f, 0.11722230f, -0.04156227f, -0.07292713f, -0.04242193f, -0.14463426f, -0.12563549f, 0.19981182f, 
    0.00776700f, 0.20529559f, -0.07896069f, 0.01730752f, -0.02640758f, 0.01997365f, -0.10792866f, -0.01251454f, 
    -0.36515805f, 0.03630589f, 0.04887544f, -0.48117030f, -0.02147955f, -0.02806741f, 0.10431304f, 0.06935094f, 
    0.01604668f, -0.04467219f, 0.06787354f, 0.10504189f, -0.21841565f, -0.21061692f, 0.06199009f, 0.39242512f, 
    -0.02503019f, 0.12463483f, -0.04175525f, -0.13851565f, 0.02071716f, 0.03095942f, -0.00822832f, 0.14425153f, 
    0.24098188f, 0.14297687f, 0.15627892f, -0.03604777f, -0.05692047f, -0.00396425f, 0.05203162f, 0.10466903f, 
    0.10265388f, -0.11680018f, -0.13201328f, 0.24810413f, 0.41170973f, 0.22877707f, 0.05981822f, -0.17108224f, 
    0.16506843f, -0.01859418f, 0.11244220f, 0.06241591f, 0.04856920f, -0.08852016f, 0.12232894f, 0.11544903f, 
    -0.25800574f, -0.01055724f, 0.10288747f, 0.07009006f, -0.06730531f, -0.17598958f, -0.03432587f, 0.13310513f, 
    0.19744787f, -0.04777597f, 0.04519944f, 0.08465356f, 0.04994772f, -0.06486804f, 0.21649803f, 0.31174543f, 
    0.00582284f, 0.00368747f, 0.07404510f, 0.06560180f, 0.07559102f, 0.06026287f, 0.01082300f, 0.07705473f, 
    -0.18778250f, -0.02782645f, -0.02703512f, 0.04189863f, 0.01533075f, 0.08558571f, -0.04749121f, 0.04100657f, 
    -0.02018171f, -0.06465080f, 0.16616593f, 0.04737036f, 0.04691775f, 0.11884177f, 0.07307334f, -0.25176898f, 
    -0.03085353f, -0.05717358f, 0.00276298f, 0.00250450f, 0.11645131f, -0.04419471f, 0.13856193f, 0.06181559f, 
    -0.15469353f, 0.08171263f, 0.05616270f, 0.30632979f, -0.04272095f, 0.02358086f, -0.03219492f, -0.05325660f, 
    0.05413378f, -0.09314661f, 0.13375558f, -0.09476100f, -0.30686891f, 0.37704256f, 0.13769168f, -0.04905931f, 
    0.10703957f, -0.01225159f, 0.06748500f, 0.04225127f, 0.04221400f, -0.00045277f, 0.01328130f, -0.08202525f, 
    0.01760775f, 0.22070323f, -0.06157062f, 0.20407398f, -0.04108728f, 0.00616418f, -0.01141994f, 0.15459552f, 
    -0.06664731f, -0.04274738f, -0.12559985f, -0.21458077f, 0.18000361f, -0.12222143f, -0.04890208f, -0.08996814f, 
    -0.07367524f, 0.03760197f, 0.10873821f, -0.03865641f, 0.11199091f, -0.06771959f, 0.12642650f, 0.03461781f, 
    -0.44796154f, 0.03730124f, -0.01200669f, 0.19422120f, -0.03144865f, 0.08041296f, -0.14955889f, 0.05909589f, 
    0.14148204f, -0.19031043f, -0.07327192f, -0.02304013f, 0.39779046f, -0.09032632f, 0.25862610f, -0.15581749f, 
    -0.01325578f, -0.05188033f, -0.08327788f, 0.02728567f, 0.00884523f, 0.01840410f, 0.31481522f, 0.17586166f, 
    -0.21321356f, 0.25245783f, 0.09491103f, -0.34133270f, 0.09445875f, 0.10094599f, 0.07495795f, 0.03582230f, 
    -0.06844470f, -0.04044749f, 0.04008607f, -0.12744774f, -0.09706886f, 0.19756757f, 0.05298517f, -0.07272152f, 
    0.18296707f, 0.07967717f, 0.02763810f, 0.01073061f, -0.03939423f, 0.13456333f, 0.03928470f, 0.06163390f, 
    0.05637854f, -0.01102814f, -0.13982554f, 0.41300359f, 0.13655223f, 0.10297570f, -0.06819896f, 0.04499389f, 
    0.08684800f, 0.09321563f, -0.09378286f, -0.07149026f, -0.03733662f, 0.20294313f, 0.13529466f, -0.16660160f, 
    0.14029928f, 0.08580061f, 0.00895955f, -0.12842846f, 0.02402013f, -0.07721421f, -0.01644018f, -0.06016127f, 
    -0.10186074f, -0.13229147f, -0.10262686f, 0.55326128f, 0.10874380f, 0.02620007f, 0.03831341f, 0.04926523f, 
    -0.10461571f, -0.04829179f, 0.15932880f, 0.01141244f, 0.01460594f, 0.15754662f, 0.04370248f, 0.23139527f, 
    0.13948053f, 0.08830493f, 0.13820624f, -0.08198231f, -0.08749428f, -0.10729684f, 0.06457806f, -0.00679526f, 
    -0.21490538f, -0.02503140f, 0.00436441f, -0.01331709f, -0.03078729f, 0.11219831f, -0.03513138f, 0.01184980f, 
    -0.06911863f, 0.20972615f, -0.06490666f, -0.06193942f, -0.11154492f, 0.31279898f, -0.25117660f, -0.31451336f, 
    -0.00075218f, 0.02148941f, 0.05277850f, -0.09386306f, 0.03270822f, -0.07019078f, -0.00423047f, 0.01512393f, 
    0.04317271f, -0.17868115f, -0.05978366f, 0.19017439f, 0.01894497f, -0.03782175f, 0.07622778f, 0.06696645f, 
    -0.00907183f, 0.03772940f, 0.04986107f, -0.07438256f, -0.13970092f, 0.34984300f, -0.13999626f, 0.28727332f, 
    -0.00621654f, 0.07919224f, 0.16115114f, 0.07270141f, 0.11642081f, 0.11287537f, -0.07888085f, 0.04585101f, 
    0.09579263f, 0.09057976f, 0.07067095f, -0.09602786f, 0.20737110f, -0.05034316f, 0.05848256f, 0.00879152f, 
    -0.03802878f, -0.10266887f, 0.01285623f, 0.07644527f, 0.26706362f, -0.42790860f, 0.24988259f, -0.07319064f, 
    0.01790424f, 0.00827487f, -0.00544320f, -0.00830917f, -0.01991575f, -0.11352546f, 0.03872185f, 0.17527656f, 
    -0.31836116f, -0.27536035f, 0.22469211f, 0.07454126f, 0.01249711f, 0.02057358f, 0.02286676f, 0.01850696f, 
    0.05652060f, 0.05297912f, 0.07614975f, 0.13610931f, -0.10304155f, 0.28303137f, -0.19096974f, 0.07857823f, 
    0.03468403f, 0.06974548f, 0.11401231f, 0.02094392f, -0.05029396f, 0.04179724f, 0.04155738f, -0.05031189f, 
    0.19158179f, 0.21245247f, 0.18788546f, 0.35660326f, 0.10160777f, -0.06248493f, 0.19445385f, -0.14134635f, 
    0.02610130f, -0.10413110f, -0.16344014f, -0.17701803f, 0.10525239f, 0.07633258f, 0.01426359f, 0.20504311f, 
    0.03974759f, -0.03682324f, -0.13602817f, 0.08121886f, -0.03320309f, -0.20345910f, 0.07579011f, 0.03595525f, 
    -0.08292904f, -0.05846529f, 0.17436446f, 0.05748606f, -0.17610334f, -0.06758998f, -0.04355219f, -0.03959058f, 
    -0.20612654f, 0.21474230f, -0.07526860f, -0.00819437f, -0.19540864f, 0.12503822f, -0.18343352f, -0.21211196f, 
    -0.08860151f, -0.14350657f, -0.18328564f, 0.09034310f, -0.00315612f, -0.17556365f, 0.05045325f, -0.00944094f, 
    0.17737070f, -0.14665987f, 0.07954054f, 0.01402519f, 0.05145064f, 0.12381311f, -0.15385371f, -0.04231093f, 
    -0.06263083f, 0.04783554f, -0.07656907f, -0.21308167f, -0.21878542f, -0.12674031f, 0.06632109f, -0.07954026f, 
    0.04331052f, -0.20055735f, 0.07148978f, -0.04976566f, -0.16959026f, -0.17143628f, -0.15626636f, 0.01944182f, 
    0.05313845f, 0.10736061f, 0.26246664f, 0.53427655f, 0.20364322f, 0.01033519f, 0.16428183f, 0.01922227f, 
    0.10345612f, 0.04062989f, 0.06043039f, 0.07434005f, -0.35073245f, 0.11367700f, 0.18498535f, 0.15769875f, 
    0.27129221f, -0.09380801f, 0.13032530f, -0.13007800f, 0.06567588f, -0.11473136f, -0.08688780f, 0.01326114f, 
    0.18486497f, 0.22157483f, 0.09456588f, 0.33638954f, 0.11671305f, 0.19688518f, 0.00787497f, 0.15825167f, 
    -0.15213336f, -0.10709281f, -0.00827647f, -0.13320971f, -0.06792360f, -0.08125254f, -0.23400626f, 0.08336283f, 
    0.10539232f, -0.17776726f, 0.01491559f, -0.07643114f, -0.01632020f, -0.06422810f, -0.13374510f, -0.06915675f, 
    0.12000970f, -0.08275898f, -0.14757155f, 0.04443066f, -0.03393261f, 0.00520451f, 0.09066228f, 0.09148154f, 
    0.05908174f, 0.10764675f, 0.00981326f, -0.05456449f, 0.15570144f, -0.27862117f, 0.03748236f, 0.10891751f, 
    -0.12704723f, -0.02207807f, -0.04930491f, -0.17402218f, -0.01125018f, 0.02792366f, -0.11108945f, 0.01680601f, 
    0.25659543f, 0.14151365f, -0.04139621f, -0.12834053f, -0.09370303f, -0.13265106f, 0.04326393f, 0.00376841f, 
    0.24923198f, 0.09561431f, -0.00347996f, -0.06680598f, 0.04334682f, 0.01774301f, 0.18420093f, -0.08524797f, 
    -0.02216842f, -0.12716407f, 0.06638427f, 0.10369785f, 0.04906626f, 0.01396034f, -0.08359426f, -0.02888959f, 
    -0.23131780f, 0.17555088f, 0.19001220f, 0.29123226f, 0.14280747f, 0.02278623f, 0.10129273f, 0.10581725f, 
    -0.07799366f, 0.15216365f, 0.10671723f, 0.00818333f, 0.05049586f, -0.01980392f, -0.11759979f, 0.03477684f, 
    -0.15446830f, -0.05791716f, -0.22186013f, -0.02186443f, -0.15921526f, -0.19392858f, -0.13312697f, -0.02817606f, 
    0.07032756f, 0.22331962f, 0.15712380f, -0.06088166f, -0.08165666f, 0.00619051f, 0.00143359f, -0.14960594f, 
    -0.02180897f, 0.09699685f, 0.07577861f, 0.00460608f, -0.11762488f, 0.33959275f, -0.02442943f, 0.37905186f, 
    -0.05398731f, 0.02873730f, -0.06752098f, -0.01291820f, 0.04128927f, 0.15319763f, -0.16743621f, 0.04176962f, 
    0.11906490f, -0.10353280f, -0.04399731f, -0.02591080f, 0.07676827f, -0.08132673f, 0.03435246f, 0.05906501f, 
    -0.08204985f, 0.07407244f, 0.03316376f, -0.02098900f, 0.02704247f, -0.25009838f, -0.13140298f, -0.00941588f, 
    0.06383800f, 0.04794231f, 0.02254440f, -0.03044381f, -0.06219070f, -0.04143041f, 0.23067214f, -0.06379432f, 
    0.05344150f, 0.17297369f, -0.16554448f, -0.13732760f, -0.00622050f, -0.06638644f, 0.02167383f, -0.02702260f, 
    -0.04967722f, 0.05612981f, 0.00474625f, 0.11298335f, -0.14233324f, -0.10175708f, -0.12856525f, 0.13024630f, 
    0.16979866f, 0.03717024f, -0.00616641f, -0.04383737f, -0.11733606f, 0.04429447f, 0.12358579f, 0.14902614f, 
    -0.00110843f, 0.11102126f, 0.08547501f, -0.18369736f, 0.00825592f, 0.14993384f, 0.06278641f, 0.03543877f, 
    0.01389081f, -0.08513834f, -0.12952046f, -0.15785688f, -0.10781965f, 0.07784151f, 0.04514939f, 0.09191141f, 
    0.05302102f, -0.05830421f, 0.03100395f, 0.10182364f, 0.15456259f, 0.15569429f, 0.02850997f, 0.05048820f, 
    0.24957615f, 0.15878643f, 0.00734083f, 0.03144128f, -0.10833824f, 0.11285293f, 0.19964512f, -0.12220699f, 
    -0.09785973f, -0.11982107f, 0.12056484f, -0.01062775f, 0.20589137f, -0.09418164f, -0.07924111f, -0.09694440f, 
    0.06861011f, 0.09604402f, -0.14645128f, 0.03188982f, -0.03637471f, -0.00640559f, 0.20174471f, 0.01616485f, 
    -0.09398496f, 0.15758114f, -0.04870010f, 0.12501082f, 0.09174200f, 0.17032243f, -0.14821681f, -0.00371321f, 
    -0.05968793f, 0.01123108f, -0.06892879f, 0.06698975f, 0.16022204f, 0.00341465f, 0.08373715f, -0.25676948f, 
    0.01466582f, -0.11411951f, -0.14638607f, 0.03395355f, -0.03615987f, -0.11850227f, 0.08561546f, -0.03041691f, 
    -0.26588795f, -0.33516479f, 0.11792057f, 0.23555368f, -0.05127358f, -0.05196762f, -0.11061317f, -0.04657263f, 
    0.01736510f, -0.01384148f, 0.09037619f, 0.00755775f, 0.31996512f, 0.05577593f, -0.03095419f, -0.02766101f, 
    0.04315890f, 0.08545915f, 0.01406738f, 0.07282170f, 0.02359516f, 0.07931565f, -0.12151618f, -0.01973505f, 
    0.28014007f, 0.34889394f, 0.08359637f, 0.04189458f, -0.10240539f, -0.12001171f, -0.00485746f, -0.00751485f, 
    -0.02097767f, 0.04293506f, -0.12319472f, -0.17058396f, -0.07901625f, -0.08657897f, 0.07297588f, 0.06685892f, 
    0.12997936f, -0.03082894f, -0.00828962f, 0.03105006f, 0.00567588f, -0.13930044f, -0.03423591f, 0.16006295f, 
    -0.02076396f, -0.15643826f, -0.06326788f, -0.00775632f, 0.18666086f, -0.07852646f, 0.05378996f, -0.00944875f, 
    0.03508767f, 0.14655118f, 0.23545286f, -0.01312940f, -0.19654651f, 0.15795556f, -0.02944010f, 0.10454622f, 
    0.01639231f, 0.12338486f, 0.12085223f, -0.00344900f, -0.07352453f, -0.13124387f, -0.14672214f, -0.15840431f, 
    0.01555847f, -0.15542579f, 0.26781857f, 0.18361853f, -0.09448995f, -0.18972060f, 0.14165105f, -0.12946947f, 
    0.00418870f, 0.08364342f, 0.01666017f, -0.01240907f, 0.04852514f, -0.08892554f, 0.06686092f, 0.21356620f, 
    -0.02718895f, 0.01248206f, 0.02402390f, -0.04978873f, 0.03106304f, -0.15585861f, 0.11500082f, -0.07788172f, 
    -0.18220812f, 0.27314410f, -0.09769622f, -0.01051086f, -0.00334198f, -0.04433289f, 0.10254230f, -0.06929507f, 
    0.02938336f, 0.03436913f, 0.19399512f, 0.06079817f, 0.00394229f, 0.05596790f, -0.00211754f, -0.14287905f, 
    -0.04975507f, 0.06986929f, -0.05122379f, 0.03263757f, 0.02688307f, 0.15376858f, 0.09443499f, 0.32852277f, 
    0.13443631f, -0.20734565f, -0.17202003f, -0.06022609f, 0.12962881f, 0.00060817f, -0.08429592f, -0.08605899f, 
    0.11135887f, 0.04576658f, -0.22851020f, 0.07438692f, -0.18799892f, -0.18647686f, -0.08161882f, -0.06626815f, 
    -0.00888566f, 0.10306865f, 0.01518764f, 0.06394865f, 0.11383417f, 0.04994150f, -0.06145087f, 0.00399910f, 
    -0.08335993f, 0.08586022f, -0.06017090f, 0.07608429f, 0.21212184f, 0.12926540f, -0.06107321f, 0.07014136f, 
    -0.02074004f, -0.17293990f, 0.29105830f, -0.04384204f, 0.08408324f, -0.20560317f, 0.05747326f, 0.05303927f, 
    0.05500251f, -0.05837365f, -0.12923749f, 0.14731397f, 0.07669311f, -0.06069651f, 0.22880948f, 0.18365607f, 
    -0.12181816f, 0.08692426f, 0.01139801f, 0.02576018f, 0.10819533f, 0.25454840f, 0.03004602f, -0.10640547f, 
    0.00482734f, -0.04879393f, -0.01633455f, 0.14166564f, 0.37971732f, -0.00496248f, 0.19223191f, -0.15423273f, 
    -0.03073752f, 0.00874494f, -0.17116909f, -0.08405547f, 0.10617997f, -0.01881201f, 0.07555181f, 0.09003694f, 
    -0.11285694f, 0.06496628f, 0.09258223f, 0.02911552f, -0.02095795f, -0.18121167f, -0.13714607f, -0.06742358f, 
    0.10133108f, 0.12371019f, 0.06248353f, -0.05679817f, -0.45056280f, -0.07007419f, -0.02221750f, -0.02155433f, 
    0.12888536f, 0.10050413f, 0.00034361f, -0.07596690f, 0.15674938f, 0.07465968f, 0.09873354f, -0.17548862f, 
    -0.09695625f, 0.14141412f, 0.03845837f, 0.02012642f, 0.07930936f, 0.06350333f, 0.00097268f, -0.08924890f, 
    -0.05183763f, -0.02423297f, -0.03463978f, -0.21240219f, 0.07043733f, -0.10353816f, -0.07478740f, -0.01665382f, 
    -0.06655647f, 0.04563708f, -0.03399374f, -0.21669205f, 0.03400294f, -0.15750255f, 0.11090249f, 0.04850784f, 
    0.07034300f, 0.14467451f, 0.03512714f, -0.08285263f, 0.01424986f, 0.08720882f, -0.14894502f, -0.13381533f, 
    -0.00116026f, -0.02223059f, -0.11566351f, 0.06881569f, -0.10463945f, 0.10168347f, -0.01696949f, 0.37515685f, 
    0.04682875f, -0.00545066f, 0.00628737f, -0.11780903f, 0.06124859f, 0.15560332f, 0.02140664f, -0.20606318f, 
    -0.14987071f, 0.28088588f, -0.11708771f, -0.16785058f, 0.15103363f, -0.03256302f, 0.08293147f, -0.10840289f, 
    0.00794406f, 0.23315567f, -0.01044392f, 0.05579453f, 0.00752557f, -0.27466938f, -0.18881050f, -0.18244669f, 
    0.28493527f, 0.17435943f, 0.08383124f, -0.22913343f, -0.01155533f, 0.16161902f, 0.08440272f, 0.03519861f, 
    -0.16615713f, 0.10227510f, 0.00689325f, -0.05552910f, 0.20874235f, 0.03878845f, 0.13131417f, -0.04191783f, 
    0.01460894f, 0.04628593f, -0.04652720f, 0.19342603f, 0.08309538f, 0.00586157f, -0.26548591f, -0.03779956f, 
    0.22916655f, -0.07075070f, -0.02347780f, -0.05974721f, -0.08530743f, 0.08253416f, 0.03107311f, 0.12083131f, 
    0.22081062f, 0.19310439f, 0.15064687f, -0.07851069f, -0.05757184f, 0.23458627f, 0.02423294f, 0.03031821f, 
    -0.10305642f, -0.02932471f, -0.05864830f, -0.10370778f, 0.12222360f, -0.03465690f, 0.15789856f, 0.33866158f, 
    -0.07021363f, -0.01206360f, -0.15030287f, 0.10533778f, 0.10095057f, 0.07846365f, -0.01197250f, 0.13696831f, 
    0.16684963f, 0.05685966f, 0.00179499f, 0.03169630f, 0.00318318f, -0.04096441f, 0.17121489f, -0.07906805f, 
    -0.03559833f, -0.04357289f, 0.07297643f, -0.11564441f, 0.13880312f, 0.10785436f, -0.09015678f, -0.24308829f, 
    0.13595609f, 0.04876383f, 0.09243994f, 0.07250591f, -0.06466565f, 0.23464447f, 0.04085861f, -0.11709812f, 
    -0.02270045f, 0.17101353f, 0.20938976f, -0.12298710f, 0.14137749f, -0.11089174f, -0.15003905f, -0.10392796f, 
    0.06721175f, 0.10945609f, -0.01704377f, 0.05946247f, -0.09723493f, 0.05541006f, 0.11153356f, -0.12269107f, 
    0.03024701f, -0.01097049f, 0.01338700f, 0.03056568f, -0.04749702f, -0.02700663f, 0.01663060f, -0.02891066f, 
    -0.48787075f, -0.26745704f, -0.24914663f, -0.02073717f, -0.02620342f, 0.04778352f, -0.15539068f, -0.03959060f, 
    0.04984554f, 0.07494083f, -0.04675169f, -0.03700138f, 0.75242883f, -0.15763761f, -0.17642540f, -0.03945241f, 
    -0.03861473f, 0.20301598f, -0.12589046f, -0.04215463f, 0.11138166f, 0.08904792f, 0.01656245f, -0.08427466f, 
    0.37961829f, 0.24195053f, 0.21327080f, 0.06164210f, 0.10226201f, -0.10427986f, -0.00078248f, 0.02979161f, 
    0.00248347f, -0.11424366f, -0.09823153f, 0.00377368f, -0.35202330f, -0.02779024f, -0.03803966f, 0.02285090f, 
    0.35352752f, -0.00697970f, 0.07045625f, -0.09743562f, -0.08642612f, 0.05060011f, 0.17307761f, -0.00680759f, 
    -0.12289761f, -0.06292901f, -0.04519087f, -0.07255717f, -0.01746572f, 0.11486343f, -0.05015140f, 0.07619580f, 
    0.10532995f, -0.06139577f, 0.07488014f, -0.06070583f, -0.00805542f, -0.08988023f, 0.01007706f, -0.20314045f, 
    -0.07814382f, 0.13386686f, -0.01370559f, 0.10552604f, -0.09835028f, 0.00954521f, 0.12458088f, 0.08514739f, 
    0.23182885f, -0.02934017f, 0.07569677f, -0.12479402f, 0.06255245f, 0.01347018f, 0.18289565f, 0.20971957f, 
    0.10095221f, -0.04830056f, 0.01479286f, 0.06719226f, 0.11240748f, -0.16653357f, 0.04230145f, 0.09377474f, 
    -0.05846830f, 0.02897738f, -0.01293744f, 0.00802396f, 0.07999521f, -0.00306420f, 0.17610016f, -0.07680687f, 
    0.44755673f, 0.09154972f, -0.22704343f, 0.27988964f, 0.03856191f, 0.00908013f, -0.05889456f, 0.08249770f, 
    0.15966947f, 0.18686479f, 0.06949291f, 0.00572779f, 0.16113143f, 0.13779336f, 0.13695423f, 0.14107227f, 
    0.14291142f, 0.06476784f, -0.06397218f, 0.00454246f, -0.08076256f, -0.03914431f, -0.02417329f, 0.02545442f, 
    -0.34307542f, -0.10764250f, -0.15608074f, -0.01877656f, 0.03831002f, -0.01046104f, -0.05241431f, -0.04484468f, 
    -0.07307143f, 0.02709367f, 0.06235863f, 0.12160929f, 0.20256950f, -0.10862652f, 0.05756196f, 0.06305467f, 
    0.05515081f, 0.00775206f, 0.02996838f, -0.16460530f, -0.17855999f, -0.02701051f, -0.01781085f, -0.03200761f, 
    0.08544313f, -0.12871163f, -0.13187389f, -0.04324096f, -0.19065547f, -0.05268806f, -0.04462115f, -0.03940641f, 
    0.07254223f, 0.00502963f, 0.01159031f, 0.01457344f, 0.03183392f, 0.29578227f, -0.02530922f, -0.17942408f, 
    0.06249382f, 0.07953195f, 0.03703056f, -0.05624989f, -0.01712937f, -0.15678233f, 0.11059343f, -0.04848018f, 
    0.20309800f, 0.16700840f, 0.09652745f, 0.14493354f, 0.08455249f, 0.17124431f, 0.08713548f, 0.11842287f, 
    0.08035571f, 0.11068759f, 0.02464377f, 0.03740037f, -0.18777187f, 0.16319153f, 0.11773571f, 0.14384800f, 
    -0.00684467f, 0.06832194f, 0.02547565f, 0.15888216f, -0.03515835f, -0.13642135f, 0.08066007f, 0.09521789f, 
    -0.05629921f, -0.29181439f, 0.21147171f, 0.00481717f, 0.09647045f, 0.01290256f, -0.05397925f, -0.02902429f, 
    -0.03157469f, -0.00811883f, -0.03203725f, 0.25591227f, -0.26065809f, -0.01048883f, -0.18716033f, 0.24298371f, 
    -0.04162916f, 0.13348289f, 0.06690133f, 0.09677766f, -0.05055203f, -0.05413111f, -0.07632519f, 0.03623016f, 
    -0.12215214f, -0.13844098f, 0.00849715f, -0.20241068f, -0.05455000f, -0.07813209f, 0.00635728f, -0.13150617f, 
    0.10931725f, 0.04056352f, 0.06230002f, 0.00342930f, 0.08313112f, 0.07855726f, -0.07668641f, 0.05125315f, 
    0.14713329f, 0.12044401f, -0.02368397f, -0.01515578f, 0.04193839f, -0.05164364f, 0.01889097f, 0.15235038f, 
    -0.21430720f, -0.02192533f, 0.18888839f, 0.03305689f, 0.05827904f, 0.16314802f, -0.12451267f, 0.01717744f, 
    -0.00585550f, -0.07098684f, 0.09142026f, -0.04803503f, -0.07040776f, -0.11342253f, 0.01081281f, -0.02223505f, 
    0.13218039f, -0.03778376f, -0.07333820f, 0.00741740f, -0.02883830f, -0.12852585f, 0.08711080f, 0.14343295f, 
    -0.09997721f, 0.04371656f, 0.03969746f, -0.04810840f, -0.00041264f, -0.11198463f, 0.09954332f, 0.02950368f, 
    -0.07519682f, -0.10521317f, 0.02401608f, -0.07700387f, 0.18763748f, 0.25541157f, 0.25140104f, 0.13383548f, 
    0.08667688f, -0.06872571f, -0.03159694f, -0.12778570f, 0.01033378f, 0.02388188f, 0.05029181f, -0.07280833f, 
    0.63108718f, 0.22366405f, 0.09558983f, 0.00295954f, 0.05622765f, 0.14552596f, -0.13174495f, -0.21186088f, 
    -0.02320555f, 0.00462123f, 0.00491727f, 0.01588084f, 0.18511441f, 0.20807800f, 0.00963735f, -0.11830571f, 
    0.02529967f, 0.02794264f, 0.08147932f, 0.03870137f, 0.05715465f, 0.03487631f, -0.00788231f, 0.07927431f, 
    -0.18377371f, -0.12418310f, -0.13237178f, 0.20874768f, 0.11319951f, 0.10782707f, 0.03838308f, 0.10404228f, 
    -0.03267478f, -0.10668004f, 0.18136345f, -0.00663898f, -0.50765985f, -0.35094959f, 0.16308793f, 0.31215823f, 
    -0.05862157f, 0.01613542f, -0.08582520f, -0.01442127f, -0.02506053f, -0.01673852f, -0.05652874f, 0.03501016f, 
    -0.09259809f, -0.12765336f, 0.19682361f, -0.09326126f, 0.21789917f, 0.15070510f, 0.08198066f, -0.02343206f, 
    0.02618021f, 0.11359160f, 0.07766966f, 0.00423074f, -0.31359917f, 0.18168503f, -0.30489397f, -0.35296291f, 
    -0.03954046f, -0.03993446f, -0.07731421f, 0.08457201f, 0.09551852f, 0.04798745f, 0.06018129f, 0.14903171f, 
    0.18483607f, -0.11830837f, 0.09547801f, -0.06259970f, -0.07631139f, 0.00280420f, 0.01760607f, 0.17079619f, 
    0.09561893f, 0.12425077f, -0.01090306f, 0.06214408f, 0.34428519f, 0.30593425f, 0.01885131f, 0.27149162f, 
    0.12155258f, 0.09954838f, -0.08110704f, 0.02286894f, -0.05592667f, 0.14729397f, 0.01819155f, 0.09557717f, 
    0.25661489f, 0.16146515f, -0.23375534f, 0.13171090f, 0.07373253f, -0.04474309f, 0.01381660f, -0.00429362f, 
    0.03762466f, 0.11973315f, -0.07409106f, 0.06547395f, 0.32568058f, -0.38323936f, -0.02912436f, -0.04343892f, 
    -0.03459979f, -0.03289150f, 0.04842798f, -0.05065383f, 0.04528555f, -0.00288068f, 0.12973012f, 0.04410609f, 
    -0.20142536f, -0.21864969f, 0.20866577f, 0.08815328f, 0.20588724f, 0.00499483f, -0.09548505f, -0.05087360f, 
    0.03489203f, -0.02119105f, 0.13181040f, 0.16427878f, 0.22125301f, 0.26937202f, -0.17238121f, 0.14971811f, 
    0.17125496f, 0.07395282f, -0.09499913f, -0.12303732f, 0.11641765f, -0.01742564f, -0.03182149f, -0.06334472f, 
    -0.15626240f, 0.02180940f, 0.01829685f, 0.15714084f, 0.00282299f, 0.07604045f, -0.07602327f, 0.05156380f, 
    0.10473863f, -0.08421506f, -0.04512939f, 0.02837585f, 0.46109501f, -0.12291318f, 0.38584486f, -0.21435830f, 
    0.03970512f, -0.10223717f, -0.03160732f, 0.00059324f, 0.05786543f, 0.09446384f, 0.23660158f, 0.32690731f, 
    0.03036514f, 0.12578554f, 0.06068270f, -0.10848179f, 0.07120878f, 0.23273844f, -0.03167212f, 0.00384148f, 
    0.03852431f, -0.04053073f, 0.06733894f, -0.00752417f, -0.16446286f, 0.18440543f, -0.11780414f, -0.03626235f, 
    0.20223220f, -0.11259722f, -0.01269290f, 0.03418477f, -0.02990072f, 0.08117907f, -0.05397163f, 0.20123838f, 
    0.14800680f, -0.16640115f, 0.09226805f, 0.38267270f, 0.09963986f, 0.14523278f, -0.19417660f, 0.11747780f, 
    0.10733762f, -0.01133309f, -0.05886655f, -0.14221826f, -0.08394141f, 0.12228223f, 0.03846771f, -0.18357980f, 
    0.09504098f, -0.00800654f, -0.01968963f, 0.06360253f, 0.03818613f, -0.13605827f, -0.15317862f, -0.27749661f, 
    -0.03186966f, 0.10795852f, 0.06425677f, 0.19450897f, -0.03652558f, 0.04569748f, 0.01627292f, 0.02447998f, 
    -0.06673210f, -0.09081442f, 0.12750548f, -0.04583718f, 0.27011243f, 0.23561403f, 0.14715485f, 0.12222461f, 
    0.07053452f, -0.01562531f, 0.11781409f, -0.03174904f, -0.08564992f, -0.08183299f, 0.13710016f, 0.04125844f, 
    -0.11796183f, 0.06479414f, 0.07750145f, -0.03619412f, -0.10278903f, -0.06931142f, -0.01581435f, -0.01663553f, 
    0.08847386f, 0.15669809f, -0.20456810f, -0.05822847f, -0.14688447f, 0.23121260f, 0.00834597f, 0.09776936f, 
    -0.05277086f, 0.08892504f, 0.12083042f, -0.07831142f, 0.08540859f, -0.06552461f, -0.16671395f, 0.00246385f, 
    0.10959718f, -0.14052464f, 0.00982707f, 0.07428174f, 0.10930189f, -0.17447613f, 0.11052125f, 0.06102674f, 
    0.03613029f, 0.11805858f, 0.10546037f, -0.02563969f, -0.35021758f, 0.15002456f, -0.14482290f, 0.21994556f, 
    0.04095128f, 0.13371001f, 0.22491544f, 0.04493930f, 0.16429633f, 0.03979601f, -0.07632858f, -0.04905868f, 
    0.34108216f, 0.06107894f, 0.05462051f, -0.14704604f, 0.09545631f, -0.00847944f, 0.04125397f, -0.03621606f, 
    -0.08983751f, -0.04506135f, 0.01541596f, 0.15266357f, 0.08209481f, -0.15284999f, 0.27552602f, 0.22851819f, 
    -0.00961043f, -0.04619966f, 0.07308181f, 0.06623945f, -0.08131249f, -0.02520655f, 0.04048948f, 0.19509722f, 
    -0.21647216f, -0.23817146f, 0.11365793f, -0.01267284f, -0.12150447f, 0.00787125f, 0.02099038f, 0.18830997f, 
    0.06481476f, 0.09801305f, 0.15895148f, 0.15109654f, -0.31716943f, 0.17870826f, -0.13493328f, 0.09433209f, 
    0.05989302f, 0.05107488f, -0.01375475f, 0.01342431f, -0.01155248f, 0.18376783f, -0.04568307f, -0.18119414f, 
    0.02211513f, -0.06443708f, 0.05595257f, -0.00196537f, -0.01426120f, 0.01051771f, -0.06938648f, -0.00421946f, 
    -0.02873877f, -0.02253126f, -0.05945664f, -0.04145113f, -0.03273978f, 0.00359530f, -0.00585730f, 0.02497214f, 
    0.02324806f, -0.01400555f, 0.05384792f, 0.05656765f, -0.05333999f, -0.04697617f, 0.02285105f, 0.03173656f, 
    -0.05406303f, 0.06180486f, 0.06577626f, 0.07007434f, -0.04250059f, 0.04271014f, 0.03157782f, 0.03402921f, 
    0.05017524f, -0.01344728f, -0.00170749f, -0.04636363f, -0.02881888f, -0.02145647f, 0.07025992f, 0.06626805f, 
    0.04583626f, -0.03760746f, -0.04485924f, -0.02333940f, -0.06298828f, 0.01462096f, -0.03099387f, -0.01616888f, 
    0.00562366f, -0.02753163f, -0.00931626f, -0.05205807f, 0.06603859f, -0.00495979f, 0.04807655f, 0.03745845f, 
    -0.04873820f, 0.03993647f, -0.01287361f, -0.06394486f, -0.00247000f, -0.06610010f, -0.02937115f, -0.02445458f, 
    -0.03445592f, -0.03806628f, -0.03338238f, 0.07150164f, 0.00746229f, -0.04137978f, -0.02169301f, -0.02723682f, 
    0.05535574f, 0.04414500f, 0.02341207f, 0.02244866f, 0.03119456f, -0.06804215f, -0.04534128f, -0.07103181f, 
    -0.02819445f, -0.02105554f, 0.02803125f, -0.06906690f, -0.01810206f, 0.07033419f, 0.03510564f, 0.01130323f, 
    -0.03268100f, 0.01159352f, -0.03859521f, -0.00226685f, -0.00573797f, -0.02997692f, 0.06894244f, 0.02161001f, 
    0.03515076f, -0.04661492f, -0.06904564f, 0.05174423f, 0.01383796f, 0.01838667f, -0.03012425f, 0.06240561f, 
    -0.03995916f, -0.01615648f, -0.06219908f, -0.01321273f, -0.07214350f, -0.05363174f, 0.04828005f, -0.06248365f, 
    0.01065108f, 0.01680655f, 0.06370813f, 0.03040662f, -0.03684631f, -0.02057227f, -0.04845681f, -0.02687597f, 
    -0.03040946f, -0.05394861f, -0.01314869f, -0.00484105f, -0.04653608f, 0.00684682f, 0.01764075f, 0.00483320f, 
    -0.04009978f, -0.01655469f, -0.06555090f, -0.06999200f, -0.03265519f, 0.06254574f, -0.04877001f, -0.03316654f, 
    -0.04809947f, 0.01778751f, -0.04867625f, -0.00181427f, -0.02406362f, 0.00832434f, -0.05312070f, 0.02334619f, 
    0.03198557f, -0.02243384f, 0.03502694f, -0.05362953f, -0.06384128f, -0.03266367f, -0.03341666f, 0.07116853f, 
    -0.00367681f, 0.06903631f, 0.01383175f, -0.05254256f, -0.01394354f, -0.02728224f, 0.03158231f, 0.05559858f, 
    0.02020803f, -0.06745952f, 0.02814789f, 0.01512442f, 0.01063583f, -0.06796979f, -0.04948652f, 0.00467531f, 
    -0.05986618f, 0.03416909f, 0.00934752f, 0.00707436f, 0.01709091f, -0.05001302f, -0.05628268f, 0.01650586f, 
    0.07106482f, -0.06448830f, -0.00949748f, -0.03061878f, 0.02628708f, 0.05070976f, -0.01259274f, 0.02881568f, 
    -0.01061134f, 0.01476561f, -0.02207171f, 0.02121516f, 0.04336658f, -0.06914005f, -0.06662137f, 0.01839907f, 
    0.07986334f, 0.22833894f, -0.06402719f, -0.29079935f, -0.00726695f, -0.01814892f, -0.01186991f, 0.06883758f, 
    0.10068148f, 0.02964527f, 0.03960717f, 0.01223274f, -0.02270420f, 0.04063536f, 0.09568789f, 0.30806044f, 
    -0.11619732f, -0.10546491f, -0.04414696f, -0.01913885f, -0.01909037f, 0.17048058f, -0.13345011f, -0.02293705f, 
    -0.25943664f, 0.04521231f, 0.20991682f, -0.10895506f, 0.22281617f, 0.01599540f, -0.01294467f, -0.09763174f, 
    0.04099434f, 0.09315715f, -0.05047482f, 0.17011949f, -0.26933116f, 0.11921519f, 0.00824059f, 0.08158773f, 
    0.09577399f, -0.01894617f, 0.07379720f, -0.06865837f, 0.10187583f, -0.01404318f, 0.22103153f, -0.02622604f, 
    -0.32219318f, 0.09996333f, -0.25345719f, 0.22551879f, 0.18544041f, 0.14195043f, 0.00674663f, 0.07055990f, 
    -0.02547054f, 0.03546509f, -0.13709234f, 0.16642413f, -0.07283242f, 0.38445407f, 0.00674504f, -0.35103837f, 
    0.07747465f, -0.01509285f, 0.01056367f, 0.11086833f, 0.06701836f, 0.08933079f, -0.07302711f, 0.10529684f, 
    0.17006169f, -0.10395170f, -0.19061646f, -0.24959004f, -0.06633314f, 0.05464349f, 0.04561906f, -0.16025496f, 
    0.07317369f, 0.05221147f, -0.11782582f, 0.01734791f, 0.13391016f, -0.06929839f, -0.20247492f, 0.03556975f, 
    0.00772193f, 0.13164775f, -0.00482143f, 0.04104454f, 0.04718407f, 0.16973382f, 0.01362589f, 0.16050339f, 
    0.13773577f, 0.27104104f, -0.26905322f, -0.13142870f, -0.08214031f, 0.09514862f, 0.10451430f, -0.15637247f, 
    -0.07047272f, 0.11770257f, 0.13712442f, 0.00650513f, 0.41735005f, -0.10402485f, 0.06461678f, -0.06307643f, 
    0.06926204f, 0.13266113f, -0.00722474f, 0.14313513f, 0.02849884f, 0.10261574f, -0.07883576f, 0.00109912f, 
    -0.38438797f, 0.15944557f, 0.10682108f, 0.00542615f, 0.16093238f, 0.04221926f, -0.14078246f, -0.15431568f, 
    -0.09820285f, -0.20926003f, 0.00191858f, -0.03630127f, -0.03651359f, -0.38843518f, -0.09956668f, -0.03077836f, 
    -0.03442426f, 0.10082150f, 0.20456329f, 0.10328948f, 0.08326686f, 0.12140321f, 0.06341153f, -0.00703122f, 
    -0.19421248f, -0.25547561f, 0.11570104f, -0.19698870f, 0.00741875f, -0.03081075f, 0.00785907f, -0.05278651f, 
    -0.04574449f, 0.02944086f, 0.05012783f, 0.18189986f, 0.21433207f, -0.26795191f, -0.14819884f, 0.20594548f, 
    0.04008618f, 0.13678713f, -0.16519916f, -0.12583633f, 0.06502236f, 0.09160101f, -0.07394273f, 0.01763556f, 
    0.39964148f, -0.02405271f, -0.03920976f, -0.15539852f, -0.23988611f, -0.12357409f, -0.07764776f, -0.00580555f, 
    -0.16530979f, -0.02618350f, -0.13387167f, -0.03595029f, -0.52455032f, 0.09997717f, 0.08337596f, -0.02006105f, 
    0.10125706f, 0.05588682f, -0.10750388f, -0.00922796f, 0.04573086f, 0.04790755f, 0.24872085f, -0.02206316f, 
    0.16660930f, 0.14219749f, 0.01604060f, -0.31464788f, -0.06065759f, 0.06703942f, 0.01435699f, -0.01373608f, 
    -0.04772121f, 0.00562185f, 0.04354294f, 0.12315051f, -0.02684985f, -0.10662550f, -0.10239519f, 0.10580292f, 
    -0.17879984f, -0.06783377f, 0.06080560f, -0.11621572f, 0.14265575f, 0.21673231f, 0.00038496f, 0.13132411f, 
    -0.11104479f, 0.05167615f, 0.02433316f, -0.09364408f, 0.23834223f, -0.00149749f, 0.01283598f, 0.13372536f, 
    0.05757489f, 0.03767260f, 0.00867772f, 0.17156601f, 0.26934144f, -0.10202875f, -0.16546515f, 0.03210872f, 
    -0.03147602f, 0.02507871f, 0.10282233f, 0.02050260f, 0.13101169f, 0.02233190f, 0.09618555f, 0.03273079f, 
    0.27061495f, 0.06007534f, -0.22048287f, 0.08526237f, -0.00453465f, 0.03421199f, 0.02022336f, 0.10318510f, 
    0.12084727f, 0.01828341f, -0.10516123f, 0.09430686f, 0.25642219f, 0.12569833f, -0.11989652f, 0.14879723f, 
    0.05540916f, 0.01261866f, 0.00410748f, 0.07870276f, -0.03606704f, 0.00566181f, -0.00769329f, 0.02631914f, 
    -0.12172730f, -0.05433011f, 0.04785033f, -0.24512690f, -0.05649089f, 0.15675519f, -0.00445173f, -0.09982016f, 
    -0.07162974f, 0.16008362f, -0.02963218f, -0.10098048f, 0.31420776f, -0.09996357f, -0.14530431f, 0.14366350f, 
    -0.06303813f, 0.02528583f, -0.07684804f, 0.06772708f, -0.10804890f, 0.11403056f, 0.00087775f, 0.21090360f, 
    0.36422619f, 0.06295988f, -0.07378446f, -0.05955850f, -0.10679974f, -0.12062581f, 0.19140865f, -0.22477412f, 
    0.02991532f, -0.01838829f, -0.02702310f, -0.01901241f, 0.28581664f, 0.13180520f, 0.01215568f, -0.07390141f, 
    0.21348247f, 0.14983374f, 0.11876314f, 0.12107169f, 0.10985983f, 0.05640632f, -0.00427819f, -0.11387626f, 
    0.01283927f, 0.31874666f, 0.03927588f, -0.13794777f, 0.13751067f, 0.02052318f, -0.01713383f, -0.11041808f, 
    0.13580540f, 0.03511906f, 0.02393271f, 0.07665160f, -0.35916758f, -0.30934936f, -0.01239033f, 0.03024368f, 
    0.05658664f, -0.08448920f, 0.14773954f, 0.00355944f, -0.00295136f, -0.08553001f, 0.08866885f, -0.01768581f, 
    -0.24317710f, -0.40605012f, 0.00862486f, -0.06527884f, -0.07130614f, -0.07010321f, -0.10446249f, 0.13353834f, 
    -0.10389766f, -0.02331529f, -0.02488305f, 0.09061770f, 0.18593527f, 0.08827863f, -0.16907538f, 0.30798471f, 
    -0.14775787f, 0.13739869f, 0.02274837f, 0.05752221f, 0.02917307f, 0.09175037f, 0.10243448f, 0.01998106f, 
    0.53241229f, -0.04814944f, 0.09938685f, -0.19255695f, -0.07524619f, 0.05425077f, 0.01952187f, 0.02548653f, 
    0.09855010f, 0.08026052f, -0.00215490f, 0.02698917f, -0.13066660f, -0.01324509f, -0.01822279f, 0.03039192f, 
    0.17236173f, -0.08540136f, -0.01345542f, 0.06025477f, 0.02719486f, 0.09828017f, 0.09068669f, 0.03127829f, 
    -0.06371389f, -0.06341291f, -0.05802120f, -0.07035974f, -0.00998471f, -0.01601387f, -0.06608645f, 0.03661072f, 
    -0.00971978f, -0.02771246f, -0.04003554f, 0.04975643f, 0.06165369f, -0.02851184f, 0.06232985f, 0.01128212f, 
    0.01438612f, 0.04416463f, -0.01281445f, 0.00009033f, -0.07249058f, 0.04712773f, 0.06179271f, -0.04718517f, 
    0.06585336f, -0.04708104f, -0.05598076f, -0.02270745f, -0.06949528f, -0.03081533f, -0.01600382f, -0.00016381f, 
    -0.01003785f, -0.02427208f, -0.04062892f, 0.04302946f, 0.05508833f, 0.02275489f, 0.02286943f, -0.06732759f, 
    0.06046528f, -0.04685566f, 0.00694562f, 0.05248969f, 0.04074482f, 0.03635895f, -0.01056021f, 0.02946411f, 
    0.03287261f, 0.02303462f, 0.02722319f, 0.06400263f, -0.02628564f, -0.01348478f, -0.05155961f, 0.00296168f, 
    -0.07628889f, -0.06906110f, -0.01772552f, -0.06409352f, -0.06041831f, 0.01573102f, -0.05210407f, -0.01756638f, 
    -0.07342879f, 0.04710085f, 0.06102259f, -0.02724940f, 0.03643052f, -0.05321349f, -0.05481328f, 0.01055641f, 
    -0.01610767f, -0.04968569f, -0.07718845f, -0.01834129f, -0.07188378f, -0.03102833f, -0.01229796f, -0.06931187f, 
    0.01014301f, 0.02814779f, 0.05007403f, 0.04873784f, -0.01860639f, -0.03839749f, -0.04922805f, -0.00376866f, 
    0.05775616f, -0.05325665f, -0.00201616f, -0.05319519f, 0.00010440f, -0.06786760f, -0.00315177f, 0.06563553f, 
    -0.06507576f, -0.02756876f, 0.03723376f, -0.03816337f, -0.04165031f, 0.03020409f, 0.03747507f, 0.03333435f, 
    -0.03352455f, -0.05093331f, -0.06955324f, 0.00232775f, 0.00403167f, -0.02882721f, 0.02554767f, -0.04500081f, 
    0.03202898f, -0.02513155f, 0.04755164f, -0.05654691f, -0.02350664f, 0.03263116f, -0.07315251f, -0.05416942f, 
    0.04850568f, -0.05172111f, -0.02692304f, 0.00825523f, 0.02105284f, 0.03749454f, -0.01714585f, -0.00145216f, 
    -0.05243168f, 0.04486926f, -0.05918596f, -0.03220602f, -0.05332745f, -0.07663921f, 0.01602367f, 0.05670450f, 
    -0.02013518f, -0.00268220f, -0.06764425f, -0.03569392f, -0.04186065f, 0.04168347f, -0.06911062f, -0.03913767f, 
    0.03413670f, 0.00026060f, -0.02403938f, -0.03508279f, -0.05369818f, -0.03961045f, 0.04928009f, 0.03586486f, 
    0.02112314f, 0.06260050f, -0.03766999f, -0.03300523f, -0.03863645f, -0.03256477f, 0.03255467f, 0.04323770f, 
    -0.01286254f, -0.03257271f, -0.04402491f, 0.02939728f, -0.01103090f, 0.01856184f, -0.00520715f, -0.06799455f, 
    -0.05156497f, 0.01091542f, 0.04325239f, -0.04349841f, -0.02047356f, -0.00514413f, -0.07124738f, 0.05189564f, 
    0.04443198f, 0.03795315f, 0.00301688f, -0.05085766f, 0.00498436f, -0.04672673f, 0.04620257f, -0.02761314f, 
    -0.06543939f, -0.02159812f, -0.00006877f, 0.06221448f, 0.04081203f, 0.05860148f, 0.06455337f, -0.03285376f, 
    0.04855557f, -0.50624460f, -0.24105650f, 0.16953352f, 0.06754700f, -0.26943269f, -0.05078397f, 0.07016310f, 
    -0.02268812f, 0.01054411f, -0.02235262f, -0.05940501f, -0.10993966f, 0.02905959f, -0.02626666f, 0.16086017f, 
    0.05029624f, 0.04419095f, -0.02824469f, -0.00934427f, 0.02894863f, -0.14045060f, 0.12402602f, -0.08959799f, 
    0.01233563f, 0.10357096f, 0.01808368f, -0.10066208f, 0.02343751f, 0.01539191f, 0.10233228f, 0.04107789f, 
    -0.08308388f, -0.08991233f, 0.08139946f, 0.00557768f, 0.25299966f, 0.09014288f, -0.01141453f, -0.25563052f, 
    -0.05708351f, 0.03007716f, -0.00316734f, 0.04650635f, 0.09536833f, -0.04803949f, 0.06004366f, 0.03346171f, 
    -0.18507563f, -0.04838545f, -0.23061466f, 0.23773998f, 0.07004301f, -0.06082472f, 0.15032780f, 0.13284396f, 
    0.11907919f, -0.01029840f, 0.14494340f, -0.05070786f, 0.29261780f, 0.07280754f, 0.16057117f, 0.00541371f, 
    0.09787747f, 0.08607229f, -0.04129567f, -0.02637753f, -0.07229429f, 0.07531448f, 0.13386604f, 0.14046656f, 
    -0.24283510f, 0.06138041f, -0.02375020f, 0.36112884f, 0.05533120f, -0.35821038f, -0.32142416f, -0.25581884f, 
    0.11576343f, 0.12045702f, -0.03943719f, 0.07047807f, 0.11541708f, 0.04887497f, 0.03449732f, 0.26500496f, 
    0.04722150f, 0.05204459f, -0.06943912f, -0.20513155f, -0.07857271f, -0.24111928f, -0.23269694f, -0.06383912f, 
    0.02224679f, -0.03797191f, -0.31013978f, 0.21221289f, 0.03008204f, 0.00190295f, -0.40809655f, -0.22380434f, 
    0.01077136f, -0.31211820f, 0.01459244f, 0.00979788f, 0.13944584f, -0.16045277f, 0.11952277f, 0.27658197f, 
    -0.03549195f, -0.11615102f, 0.02927919f, 0.02378526f, -0.04465108f, -0.07349550f, 0.06696781f, 0.07107069f, 
    -0.06515655f, 0.07348955f, -0.21238025f, 0.13867506f, 0.04147312f, 0.35933492f, 0.06770834f, -0.04360786f, 
    0.15737045f, 0.03172922f, 0.15245935f, 0.13612850f, -0.02678690f, 0.05551681f, 0.24157470f, 0.04440218f, 
    -0.01355400f, 0.14213042f, -0.13686126f, -0.06551165f, 0.02382223f, -0.14874703f, 0.05162953f, 0.11689350f, 
    -0.19622765f, 0.10272323f, 0.22311467f, -0.22997157f, 0.02226977f, 0.07709336f, -0.05379615f, -0.00809585f, 
    -0.02263564f, -0.03686855f, 0.00512063f, 0.09294384f, -0.69693923f, -0.01660546f, 0.01063023f, -0.02601697f, 
    0.14069545f, -0.01602500f, 0.19787832f, 0.21757972f, -0.03514239f, 0.18410370f, -0.05798064f, -0.02042996f, 
    -0.39853907f, -0.17243448f, -0.13725276f, 0.07196409f, -0.09933004f, 0.01063865f, -0.03693142f, -0.08612419f, 
    0.09175162f, -0.08117499f, 0.00743462f, -0.16867870f, 0.01582965f, 0.17865030f, 0.13147692f, -0.16845384f, 
    0.10349997f, 0.19397043f, 0.00777138f, -0.00853071f, 0.15544336f, -0.16969380f, 0.03699623f, 0.07299075f, 
    0.05779803f, -0.06280950f, 0.04766518f, 0.03992456f, -0.02925280f, 0.05445359f, 0.02521163f, 0.04360748f, 
    -0.06643551f, -0.03179944f, 0.00981403f, -0.04219382f, -0.07369515f, -0.00324359f, -0.05097566f, 0.06501693f, 
    -0.01214991f, -0.03591399f, -0.02672672f, 0.01932969f, -0.06784812f, 0.03038305f, -0.06359170f, -0.02309539f, 
    0.00807644f, 0.05501410f, 0.00571053f, -0.05219757f, -0.02319345f, 0.02498464f, -0.06769338f, -0.03127006f, 
    0.05835029f, -0.06749837f, -0.05966113f, -0.05909225f, 0.02055215f, -0.03858200f, 0.03660547f, -0.01433721f, 
    -0.04804757f, 0.04006828f, -0.04878739f, 0.02317600f, -0.02117285f, -0.06007054f, 0.01268117f, 0.01426673f, 
    -0.04146327f, 0.00120170f, 0.03506515f, -0.06541862f, -0.04103530f, 0.02054813f, -0.04820454f, -0.06500465f, 
    -0.03255653f, -0.02133260f, -0.00825006f, -0.04334144f, -0.06181932f, -0.04124099f, 0.02531520f, -0.03754440f, 
    0.05723849f, -0.03449007f, -0.00915415f, -0.01178721f, 0.04937421f, 0.05227346f, -0.02554367f, -0.03641291f, 
    0.00107383f, -0.00615227f, 0.01685158f, 0.02110534f, -0.03349617f, -0.01642216f, 0.03123540f, -0.02020796f, 
    -0.06705792f, -0.02393837f, -0.04083520f, 0.03440882f, 0.03882641f, -0.04371580f, -0.02124241f, 0.00953286f, 
    -0.04593890f, -0.00033170f, 0.02359147f, 0.01364011f, -0.01235928f, -0.02526711f, 0.02523197f, -0.00980842f, 
    -0.07633357f, 0.00105679f, 0.03203469f, -0.06544738f, -0.04186905f, -0.01196464f, -0.00532672f, -0.04119127f, 
    -0.04808984f, -0.04918755f, -0.05694119f, -0.06895790f, 0.00913349f, 0.01042851f, -0.06486886f, 0.06259646f, 
    0.01214295f, -0.02303905f, -0.05799382f, -0.04883792f, 0.03051168f, -0.04984495f, -0.00934909f, -0.04189080f, 
    0.01124837f, 0.02019615f, 0.03582568f, -0.00089964f, 0.04347666f, -0.00750591f, -0.00955749f, -0.03097343f, 
    0.04665042f, 0.04698297f, 0.01160125f, 0.00558347f, -0.03623130f, 0.03640809f, 0.03236065f, 0.02266265f, 
    -0.01048868f, -0.06833098f, -0.05362786f, 0.00581593f, -0.04854051f, 0.04828605f, -0.03996040f, -0.03407154f, 
    -0.03335335f, 0.03533276f, 0.02594488f, 0.04606887f, -0.03352367f, -0.02938626f, -0.00393841f, -0.04545520f, 
    -0.05453465f, -0.00335746f, 0.06660165f, 0.00136922f, 0.01339598f, -0.05318173f, -0.04942825f, -0.01079542f, 
    -0.07660705f, -0.00237399f, -0.05297872f, 0.05394636f, 0.00920025f, -0.05620328f, 0.01862467f, 0.04686564f, 
    -0.06881294f, -0.05889698f, -0.05733964f, 0.05840219f, 0.02516675f, 0.06041851f, 0.06422132f, -0.00750257f, 
    -0.03974305f, 0.05191653f, 0.02288086f, -0.05229056f, -0.00227969f, -0.02277067f, -0.05736840f, 0.05568827f, 
    0.05950595f, -0.04718433f, -0.00924001f, -0.02592969f, 0.05394644f, 0.02349774f, 0.00517696f, -0.07016822f, 
    0.17201740f, 0.07334927f, -0.02717168f, 0.19163410f, 0.10703924f, -0.10544300f, 0.15637466f, 0.12101325f, 
    0.11147048f, 0.11101613f, 0.21713142f, -0.12510574f, 0.06430741f, -0.04350469f, -0.06828281f, -0.23805261f, 
    0.05438133f, 0.05163108f, 0.05574445f, 0.09537083f, -0.09623212f, -0.01676526f, -0.15421145f, 0.01841040f, 
    0.09403636f, -0.14422052f, 0.16466257f, 0.08784404f, -0.09151319f, -0.08347439f, 0.11455529f, 0.05963269f, 
    0.08066437f, 0.05409719f, 0.19997165f, -0.04063197f, 0.16363558f, 0.07027900f, -0.01098545f, 0.19136189f, 
    -0.13792989f, 0.04201276f, -0.06764457f, 0.13420328f, 0.05685055f, -0.25141677f, 0.10183123f, -0.01287762f, 
    0.34751016f, 0.06739351f, -0.22599766f, -0.05209782f, -0.14256750f, -0.06815478f, -0.01186039f, 0.07183854f, 
    0.12060983f, 0.00594303f, 0.03308244f, -0.12282004f, 0.00454822f, -0.10052364f, 0.16615765f, 0.38861477f, 
    -0.08469856f, 0.11815152f, -0.04336116f, -0.01831044f, 0.03549501f, 0.08949967f, -0.02686116f, 0.12304481f, 
    -0.15011437f, 0.04251943f, -0.04500557f, 0.15268500f, 0.00516114f, -0.01412391f, 0.00863289f, -0.08873389f, 
    0.12458080f, 0.13809088f, -0.02808113f, 0.11902028f, -0.09935691f, 0.14817306f, -0.14866246f, -0.24630672f, 
    0.01307778f, 0.16459933f, 0.09031919f, -0.04187742f, 0.05519851f, -0.15117849f, -0.06213384f, -0.00017511f, 
    -0.10283812f, 0.24119797f, 0.06629994f, 0.02548231f, -0.00634486f, 0.09139015f, -0.00165087f, 0.19764432f, 
    0.10875612f, -0.06904025f, -0.00089148f, 0.00872881f, -0.11763471f, -0.18995142f, -0.14508832f, 0.21281923f, 
    -0.07552975f, 0.00113287f, -0.11523207f, 0.08525851f, 0.03640764f, -0.21190375f, -0.01833428f, 0.10743754f, 
    -0.04747440f, -0.01259432f, -0.18522279f, 0.02424116f, -0.03006717f, 0.16538553f, 0.17518903f, -0.04428988f, 
    0.00581404f, -0.14711447f, 0.01364009f, 0.15109435f, 0.08157215f, 0.00819804f, -0.09264840f, 0.14343320f, 
    -0.15170138f, -0.02557993f, -0.09654947f, -0.19472654f, -0.05873189f, -0.11749112f, -0.00324097f, 0.00382156f, 
    0.14802121f, 0.13762139f, 0.37565893f, -0.01147734f, 0.08670551f, -0.05100521f, -0.03339528f, -0.07440305f, 
    0.13897663f, -0.00062076f, 0.25341314f, 0.01225638f, -0.77628076f, 0.36984733f, 0.14985201f, -0.05519098f, 
    0.09793480f, 0.06220169f, 0.02979665f, -0.01461503f, -0.02034858f, 0.01463675f, 0.00835793f, -0.02712096f, 
    -0.27826351f, -0.05086897f, -0.10706588f, 0.05114867f, -0.01406108f, 0.03395164f, 0.01088084f, -0.07445525f, 
    0.00717182f, 0.12551522f, 0.05017057f, -0.18228880f, 0.26260096f, 0.03063539f, -0.03298055f, 0.16569735f, 
    -0.07470249f, -0.13976897f, -0.02521153f, -0.09795081f, -0.01473357f, -0.03929110f, -0.15178080f, 0.01077270f, 
    -0.05606703f, 0.25619605f, 0.04782274f, 0.06032749f, -0.06136117f, 0.20853247f, -0.04711786f, -0.06634682f, 
    -0.06909222f, -0.10415757f, -0.05366076f, 0.02857608f, 0.15269583f, -0.15742992f, 0.00366641f, -0.12779391f, 
    0.02743370f, -0.18127374f, -0.04503673f, -0.03847413f, 0.09332898f, 0.20883930f, 0.10487427f, 0.08537697f, 
    -0.38045144f, 0.07124182f, -0.04404364f, -0.10578639f, -0.03246066f, 0.15192816f, -0.05872814f, -0.18027475f, 
    0.10115088f, 0.11033638f, 0.03533352f, -0.04224826f, -0.18977721f, 0.25104505f, 0.03525148f, -0.11954434f, 
    0.20206909f, 0.09272099f, -0.07970966f, 0.06212643f, -0.03785120f, 0.19388412f, -0.01862413f, 0.08346665f, 
    -0.23511223f, -0.11922457f, 0.34600735f, -0.07688718f, 0.11844574f, 0.07925838f, -0.02630202f, -0.00441623f, 
    -0.09718914f, -0.00238176f, -0.18658507f, -0.01958548f, -0.21032961f, 0.03595188f, 0.04038331f, -0.04495692f, 
    0.09995618f, -0.07556402f, 0.01202753f, -0.03926258f, 0.10453354f, -0.09130828f, -0.04048458f, -0.13535847f, 
    0.09555681f, 0.11238237f, 0.09300602f, 0.12759744f, -0.07950673f, 0.07787874f, 0.07395114f, 0.14083521f, 
    -0.08047013f, -0.12805705f, 0.06991366f, 0.00190392f, 0.05017615f, 0.10410570f, 0.03170728f, 0.15557286f, 
    0.07626297f, -0.14836358f, -0.12660709f, 0.12910081f, 0.00569170f, 0.12901236f, 0.20594455f, 0.09657096f, 
    -0.09183363f, -0.12423649f, 0.29679132f, -0.06613371f, -0.01662782f, -0.09320303f, 0.09402569f, 0.07130865f, 
    -0.08651190f, 0.27563921f, -0.12556148f, 0.07911494f, -0.03458188f, 0.13838734f, 0.11263217f, -0.27129310f, 
    0.11820997f, 0.05010703f, 0.09986620f, -0.07085913f, 0.03830977f, 0.21811348f, -0.03568158f, -0.09166404f, 
    -0.20571020f, -0.06306186f, 0.16547512f, -0.17150719f, -0.02309545f, -0.29132405f, 0.01006876f, 0.07868446f, 
    -0.04033940f, 0.04294305f, 0.06202475f, -0.10690053f, -0.03093562f, 0.24857363f, -0.05350564f, 0.01522196f, 
    0.19356370f, 0.01266066f, 0.13719216f, 0.08872544f, -0.00687871f, 0.14124797f, -0.02474590f, -0.05113212f, 
    0.11519570f, 0.19019507f, -0.30466741f, -0.03996519f, 0.19899672f, 0.12975919f, 0.18141131f, 0.07880870f, 
    -0.01658988f, 0.02133436f, 0.02701292f, -0.01961442f, 0.72859049f, -0.23440172f, 0.14771390f, 0.11608513f, 
    -0.18377453f, -0.06380963f, 0.04458861f, 0.02027350f, -0.03358756f, -0.03338100f, -0.08309132f, 0.13585642f, 
    0.10357093f, -0.08108699f, 0.20984273f, 0.28638574f, 0.04346137f, -0.04462425f, -0.02594991f, 0.25817969f, 
    0.00931258f, 0.01789727f, -0.01775058f, 0.18888684f, -0.03585343f, 0.09352487f, -0.03734593f, -0.01599627f, 
    0.07782537f, 0.01643908f, 0.04741634f, 0.06986850f, 0.04789814f, 0.19892927f, -0.06247963f, -0.15757614f, 
    -0.20614979f, -0.30533701f, 0.02014909f, 0.15417434f, 0.05198798f, 0.01629041f, 0.11658157f, -0.02656358f, 
    0.13239427f, -0.09873777f, -0.12721120f, -0.07672416f, -0.21805264f, -0.24285050f, -0.26662287f, -0.33089933f, 
    -0.03125399f, 0.24440925f, -0.05627006f, -0.06153663f, -0.06441319f, -0.14835761f, 0.04814024f, -0.19446220f, 
    -0.15894622f, 0.07999149f, 0.14020155f, 0.01510428f, -0.05150416f, 0.02065439f, 0.01338747f, -0.12590383f, 
    0.08818144f, 0.10352895f, 0.06320369f, -0.01700821f, 0.12953889f, -0.02581894f, -0.01069670f, 0.05756124f, 
    0.14988841f, 0.18143073f, -0.06572086f, -0.17720909f, 0.04752081f, -0.00167547f, -0.01852396f, 0.15162790f, 
    0.07402910f, 0.13075234f, 0.07406768f, -0.12219962f, -0.04155012f, 0.04348795f, 0.01669212f, -0.18196550f, 
    0.14758183f, -0.00714898f, 0.08818335f, 0.10139140f, 0.10097206f, 0.08632701f, -0.04338367f, 0.22289650f, 
    0.17536658f, 0.03217587f, 0.00167309f, 0.02978375f, -0.02473098f, 0.10922102f, 0.11290126f, 0.17757326f, 
    0.19400160f, -0.09905905f, 0.07037634f, 0.27102476f, -0.12922975f, -0.12860888f, 0.05545271f, 0.15211368f, 
    -0.07834677f, -0.01274431f, -0.10775413f, -0.03030503f, 0.21739545f, -0.20906155f, 0.10980299f, 0.17768252f, 
    0.02003433f, 0.13659820f, -0.08447737f, 0.03846324f, 0.02520819f, -0.07570457f, -0.06799371f, -0.02509600f, 
    -0.24354605f, -0.17882082f, 0.07662211f, 0.10998780f, 0.09910290f, -0.05661897f, -0.01274696f, 0.04264361f, 
    0.00500136f, -0.07674339f, 0.06008411f, -0.15117286f, -0.27422255f, 0.16880937f, 0.00617983f, -0.17817320f, 
    -0.05952325f, 0.05975705f, 0.09779981f, -0.03988191f, 0.05793347f, 0.04481534f, 0.09159013f, 0.02781543f, 
    0.28942147f, 0.09651168f, 0.14823684f, -0.14690119f, -0.01811317f, 0.07663862f, 0.02725068f, -0.01714327f, 
    0.14823286f, 0.10947186f, -0.04253211f, 0.13663392f, 0.02014557f, 0.40638381f, 0.15285254f, 0.01863224f, 
    -0.04705336f, 0.00949171f, 0.03826302f, -0.11299857f, -0.05662969f, 0.05965002f, 0.17685226f, -0.00323928f, 
    -0.40494454f, 0.22569020f, -0.08716655f, -0.12286700f, 0.05769973f, -0.06124875f, -0.19385931f, -0.08514596f, 
    0.06493047f, 0.16180611f, 0.05100549f, -0.14826012f, -0.00771853f, 0.03701879f, -0.09537781f, -0.06256157f, 
    0.12911037f, 0.08272652f, 0.01621476f, 0.02497400f, 0.15307085f, 0.12111297f, 0.08380877f, -0.03893277f, 
    0.00618739f, -0.19850340f, 0.26788530f, 0.17627898f, -0.03749447f, 0.02952874f, 0.05243737f, 0.11443476f, 
    -0.01252918f, 0.00239581f, -0.05219323f, -0.06376375f, 0.00420156f, -0.01050218f, -0.23495533f, -0.00128644f, 
    0.13690941f, 0.07847746f, 0.10223540f, -0.18848322f, 0.08093865f, -0.07089471f, 0.02088444f, -0.05898759f, 
    0.08618932f, -0.02702640f, -0.01818520f, -0.00593200f, -0.06525078f, 0.08054839f, 0.07353085f, 0.04468023f, 
    -0.05528080f, -0.06268087f, -0.15900330f, 0.08559584f, 0.04436802f, 0.16652028f, 0.34508508f, 0.20074387f, 
    0.08408722f, -0.06314094f, 0.02256618f, -0.16645013f, 0.06286060f, 0.05391827f, 0.10901236f, 0.15302162f, 
    0.33207175f, 0.07528987f, -0.14757958f, 0.20186365f, 0.10558058f, 0.08592276f, -0.16762328f, -0.00479751f, 
    0.05583131f, -0.14917076f, -0.03153137f, 0.13835949f, -0.04051259f, -0.25670928f, -0.18016784f, -0.01860112f, 
    0.10273004f, -0.18181884f, -0.09717605f, -0.05595457f, -0.11589861f, 0.14494289f, -0.19239058f, 0.06199508f, 
    0.00707464f, -0.17114280f, 0.22653481f, 0.06334891f, -0.09545653f, 0.01099929f, -0.01298725f, 0.03987944f, 
    0.05527944f, 0.04383319f, -0.06344121f, 0.09769381f, 0.01055497f, -0.15057679f, -0.16351396f, -0.00286932f, 
    -0.05720834f, 0.00602284f, 0.07355644f, 0.06191051f, -0.02480440f, 0.00054564f, -0.01708159f, -0.12887819f, 
    0.24151635f, 0.23739253f, 0.18901706f, -0.12317153f, -0.05625167f, 0.14343958f, 0.00585868f, -0.05019084f, 
    0.00088491f, 0.09606546f, 0.08369910f, -0.00720086f, 0.13483672f, 0.07478727f, 0.11318652f, -0.07501365f, 
    -0.01383546f, 0.00032751f, 0.15269318f, -0.04608569f, 0.00947685f, -0.00593710f, 0.06127999f, 0.04265734f, 
    0.03116032f, 0.13923161f, 0.03826733f, -0.08950341f, 0.02352445f, 0.02853028f, -0.01503071f, -0.01276875f, 
    0.05161213f, 0.06846450f, -0.12669134f, 0.02475489f, -0.01931261f, 0.01116760f, 0.14053051f, 0.48836526f, 
    -0.08598236f, -0.08766843f, 0.22316870f, 0.06386698f, -0.10922014f, 0.09307071f, -0.14254297f, -0.02237892f, 
    0.17798688f, -0.00730377f, 0.06043836f, -0.00318951f, -0.10291104f, -0.18440208f, -0.10363868f, -0.03491012f, 
    0.06580932f, 0.06347647f, 0.10557729f, -0.02320776f, -0.03379750f, -0.20297658f, -0.15541938f, -0.17153917f, 
    -0.02692334f, -0.00949008f, 0.10284686f, 0.01522726f, 0.11992019f, 0.10364249f, -0.14412457f, 0.01234815f, 
    0.19177765f, -0.13345158f, -0.11507003f, 0.14910059f, -0.12892212f, 0.10706354f, 0.04858678f, -0.02954699f, 
    -0.13253522f, -0.06992259f, -0.03023182f, -0.14000906f, -0.12284504f, 0.25049722f, 0.23957470f, 0.01344795f, 
    0.05922038f, -0.14160217f, -0.03389112f, 0.06033655f, 0.01605108f, 0.09022251f, 0.08271728f, 0.07553498f, 
    0.14630127f, 0.13567396f, 0.02139358f, -0.01170567f, 0.08753655f, 0.08102359f, 0.15660863f, 0.11815109f, 
    0.03223413f, -0.03954507f, 0.02139774f, 0.11704966f, -0.20831393f, -0.21404697f, -0.07864563f, -0.14178503f, 
    -0.05092136f, -0.04732973f, -0.01997634f, 0.17337242f, -0.05383715f, 0.06771787f, -0.10286740f, -0.09313817f, 
    -0.19024165f, -0.07042351f, -0.06503879f, 0.01900020f, 0.07034751f, -0.03644546f, -0.18334162f, -0.08100990f, 
    0.08112217f, 0.01756601f, -0.04701230f, 0.03546398f, -0.08227703f, 0.19619337f, 0.24760558f, 0.28468794f, 
    0.13711435f, 0.03106911f, -0.11823729f, -0.13031904f, -0.05540437f, -0.08880167f, -0.00580053f, -0.13904117f, 
    0.27097782f, -0.04318294f, -0.06214495f, 0.15318255f, 0.06895342f, -0.01978574f, -0.03774096f, -0.00781214f, 
    0.04884201f, 0.15597649f, -0.05151877f, -0.01532004f, -0.15822499f, -0.34167594f, -0.17114040f, 0.09824908f, 
    0.25200167f, 0.04862029f, -0.08685870f, -0.14265306f, -0.03344149f, -0.08859057f, -0.01465576f, 0.04018800f, 
    -0.08393579f, 0.16709340f, 0.07656235f, 0.05286737f, 0.07765060f, 0.01135477f, -0.03379309f, -0.08094168f, 
    0.10245076f, -0.00827455f, 0.03747617f, 0.16440216f, -0.16373129f, -0.05507726f, -0.22091226f, -0.08842167f, 
    0.15185528f, 0.02096395f, -0.01760751f, 0.10336010f, -0.05951827f, 0.13355544f, 0.00212814f, 0.16044337f, 
    0.23147145f, 0.00236034f, 0.17330471f, 0.04743428f, 0.10983476f, 0.09382944f, -0.01568334f, 0.01062829f, 
    0.06018006f, -0.10193443f, 0.01120422f, 0.07334370f, -0.03452184f, -0.06053289f, 0.16238759f, 0.18879269f, 
    -0.02000802f, 0.09990450f, 0.11601846f, -0.00564101f, 0.14507636f, -0.04570739f, 0.06071195f, 0.16367403f, 
    -0.07304005f, 0.12997021f, 0.04088682f, 0.00113108f, 0.08663169f, 0.05141928f, -0.20667446f, -0.10870203f, 
    0.01280685f, -0.00845633f, 0.16581669f, -0.00734412f, -0.06834402f, 0.07596001f, -0.12306169f, 0.10973295f, 
    -0.10110137f, -0.00259744f, 0.10893426f, -0.02062840f, 0.02485245f, 0.02799216f, 0.10507531f, -0.01087456f, 
    0.07275093f, 0.05782388f, 0.04099120f, 0.13189507f, 0.07462221f, -0.05755200f, -0.15431894f, 0.02772444f, 
    0.02489478f, 0.03572359f, 0.03532031f, 0.09170409f, 0.10907406f, 0.27410617f, 0.02318969f, -0.09189125f, 
    -0.05252980f, 0.03819336f, -0.09341466f, 0.01439800f, 0.10309707f, 0.06767298f, 0.00831045f, 0.04203772f, 
    0.00408954f, 0.09513921f, -0.13746256f, 0.19186622f, -0.08159404f, -0.10854976f, -0.05511593f, -0.06770027f, 
    -0.01122731f, 0.03250819f, 0.13899498f, -0.07994425f, 0.19944085f, -0.16057311f, 0.09179036f, -0.04290356f, 
    0.14125198f, -0.03923492f, -0.02303512f, -0.05101764f, -0.01413761f, 0.08172888f, 0.06230741f, -0.06910210f, 
    -0.08946371f, 0.04741027f, 0.15751487f, 0.01674066f, 0.11113063f, -0.05691007f, 0.03450990f, -0.01960359f, 
    -0.06290942f, -0.08846621f, -0.10722868f, -0.19676653f, -0.46960378f, -0.14255349f, -0.19551533f, 0.05085427f, 
    0.16204946f, 0.02273189f, -0.02424965f, -0.14208640f, 0.06548157f, -0.00963422f, 0.15593225f, 0.05209530f, 
    -0.07744776f, 0.01494581f, 0.01766199f, -0.03063312f, 0.06314147f, -0.04044985f, -0.04014796f, -0.02018870f, 
    0.03501391f, 0.01046802f, -0.05990517f, -0.06092513f, -0.06468705f, -0.06923915f, 0.04757623f, 0.03712824f, 
    -0.04608897f, -0.03198555f, -0.06039682f, 0.02686373f, -0.05742016f, 0.01470984f, 0.00231363f, -0.01183392f, 
    0.01930525f, 0.00418972f, -0.04611398f, -0.07647757f, -0.07052992f, -0.05344020f, -0.04556661f, -0.01827893f, 
    0.03252765f, -0.07107795f, -0.07246115f, -0.01010466f, -0.02671545f, -0.02872309f, 0.04541319f, -0.05760881f, 
    -0.07596274f, -0.04511742f, 0.04052376f, -0.00639463f, -0.01188324f, -0.06200642f, -0.01901904f, -0.07505428f, 
    0.04124330f, -0.06737947f, 0.03642307f, -0.01683582f, -0.02406492f, -0.05306902f, -0.06438968f, 0.01810095f, 
    -0.07440040f, -0.01572359f, -0.07603526f, 0.03347423f, 0.05721310f, 0.00542987f, -0.06168823f, -0.00824500f, 
    -0.00524779f, -0.03851238f, -0.05369953f, 0.01813320f, 0.04357192f, 0.05369983f, -0.06889495f, -0.03302252f, 
    -0.03159253f, -0.04319837f, 0.03031191f, -0.04712454f, 0.02885031f, 0.03062777f, -0.05494888f, 0.02559679f, 
    -0.06189186f, 0.02442269f, 0.05572364f, 0.05375917f, 0.03394326f, -0.00009072f, 0.06289668f, 0.06126742f, 
    -0.00274129f, 0.03579745f, 0.00418828f, 0.02604587f, -0.05328119f, 0.01552309f, 0.04314027f, -0.04246812f, 
    0.00794631f, 0.04065575f, 0.02329857f, -0.02120129f, 0.03977039f, -0.03282316f, -0.00556276f, 0.02554376f, 
    0.03328536f, -0.06696783f, -0.02356696f, 0.03238373f, -0.00092243f, -0.07087909f, 0.05199743f, -0.07433086f, 
    -0.00794561f, -0.06182431f, 0.00990824f, -0.07023071f, -0.02937077f, -0.03942563f, 0.01453497f, 0.01099464f, 
    -0.03770504f, -0.03678978f, 0.02542417f, -0.07550621f, 0.06122367f, 0.05069815f, -0.07133848f, -0.07683040f, 
    -0.08062056f, -0.06010669f, 0.05024587f, -0.02399425f, 0.01524696f, -0.03963318f, -0.04270092f, -0.05869121f, 
    -0.02361702f, 0.03321509f, 0.00528541f, -0.06102020f, 0.00060652f, 0.05504787f, 0.05144462f, 0.00961714f, 
    0.01587965f, 0.04558673f, 0.04873400f, 0.04290376f, -0.06181495f, 0.03031849f, 0.04754607f, 0.04020145f, 
    0.04000347f, 0.04198945f, 0.03925108f, -0.01203528f, 0.05444551f, -0.00869333f, -0.06513829f, 0.03730753f, 
    -0.04432786f, 0.05348586f, -0.01600897f, -0.00597581f, -0.05841698f, 0.00426364f, 0.04319609f, -0.04254936f, 
    -0.05817382f, 0.05209842f, -0.01314949f, -0.04337798f, 0.03914835f, -0.07760157f, -0.07676584f, -0.01058321f, 
    -0.00482147f, -0.00553257f, 0.06178888f, -0.07338128f, -0.01576108f, 0.01306788f, -0.00700606f, -0.06282578f, 
    0.03813811f, 0.01575864f, -0.07248131f, -0.02369732f, 0.02165655f, 0.06298325f, -0.04255727f, -0.04086934f, 
    -0.05295774f, -0.15307300f, -0.16436933f, 0.12315558f, 0.00460796f, -0.02783350f, -0.03412656f, 0.12234484f, 
    0.06472002f, -0.09513417f, -0.02678278f, 0.17561603f, 0.20257947f, 0.17478392f, 0.47941223f, 0.12923825f, 
    0.08989076f, -0.04666497f, -0.13307910f, -0.06342462f, 0.00159363f, -0.09347583f, 0.09577296f, 0.10606928f, 
    0.25849771f, 0.12486861f, -0.01771784f, -0.04906105f, 0.05137445f, -0.05599152f, 0.08128946f, 0.01568009f, 
    0.03468543f, -0.10758144f, 0.03083122f, 0.15210880f, -0.25871158f, 0.02035672f, 0.11067972f, -0.11107452f, 
    0.10594461f, -0.16344143f, 0.00357791f, 0.03668726f, 0.05295357f, 0.18324025f, -0.06091368f, 0.04622052f, 
    0.13669354f, -0.15095559f, 0.25617743f, 0.49423185f, 0.15861058f, -0.03643662f, -0.04836058f, 0.13348979f, 
    0.07972378f, -0.02290143f, 0.01969174f, -0.01540314f, -0.01430819f, 0.16942917f, 0.07464874f, -0.51589119f, 
    -0.07834145f, 0.09370957f, -0.00939478f, 0.10677540f, -0.00834659f, -0.09704337f, -0.11265521f, -0.10796440f, 
    -0.02757225f, -0.04169521f, 0.01840035f, 0.06596499f, 0.12948416f, 0.01464607f, -0.06814632f, -0.01062222f, 
    -0.00037918f, -0.03837150f, 0.20943409f, 0.03112232f, -0.02712326f, -0.01157056f, 0.08031823f, 0.16009252f, 
    -0.06254570f, 0.00825063f, 0.17222534f, 0.00433012f, 0.03284828f, -0.16953328f, 0.11036012f, -0.07624339f, 
    -0.01527477f, 0.07167292f, -0.12646019f, -0.09184784f, 0.05449752f, 0.04506956f, -0.14457408f, -0.02935466f, 
    0.02230323f, 0.12560201f, -0.18165720f, -0.05716621f, -0.00707632f, 0.05188200f, -0.00338838f, 0.11730433f, 
    -0.13546564f, -0.06641389f, 0.09628372f, -0.03645578f, -0.02733737f, -0.03685639f, -0.00720060f, -0.01679817f, 
    0.19739424f, -0.13678935f, 0.13080873f, 0.17442352f, -0.06535622f, -0.05440385f, 0.06517317f, -0.03142881f, 
    0.09153801f, -0.00304687f, 0.09265079f, -0.04804651f, -0.03645068f, 0.01018318f, -0.01043252f, 0.19865438f, 
    -0.03267051f, 0.19032811f, 0.18975729f, 0.11014461f, 0.12500963f, 0.11722483f, -0.19020343f, 0.07151003f, 
    0.37509191f, -0.04534300f, -0.14109218f, -0.08605602f, -0.00437025f, 0.00038067f, 0.06525049f, -0.05806541f, 
    0.00491989f, -0.16365258f, -0.01621157f, 0.16278966f, -0.13623999f, -0.22997822f, 0.22232606f, 0.03645525f, 
    0.06291357f, -0.11176520f, -0.00137145f, 0.08375049f, -0.02355237f, 0.00455718f, 0.03501298f, 0.14658941f, 
    -0.42014229f, -0.17664135f, -0.12688145f, -0.18147172f, -0.03168470f, 0.01018413f, 0.09440468f, 0.04681799f, 
    0.04509280f, 0.04624252f, 0.13998285f, 0.08726882f, -0.39199054f, 0.05205279f, 0.02909510f, -0.05691146f, 
    0.01242149f, 0.15736134f, 0.00829390f, 0.14838699f, 0.08948942f, 0.10876379f, -0.02066816f, -0.01645781f, 
    -0.54097813f, -0.45520771f, -0.16027553f, -0.03060013f, 0.06392230f, 0.09190834f, -0.12664917f, 0.01797804f, 
    0.05092289f, -0.11046018f, -0.18856977f, -0.05769621f, -0.14426285f, 0.09172036f, -0.11429301f, 0.07994878f, 
    0.01460013f, 0.19438834f, -0.07981712f, 0.13200712f, -0.07078750f, -0.00086643f, 0.23783061f, -0.06437220f, 
    -0.24414860f, 0.31225342f, -0.09116071f, 0.11474565f, -0.09329924f, -0.09725448f, 0.14727682f, -0.09962536f, 
    -0.06969091f, -0.01590228f, -0.07066435f, 0.00306891f, 0.09328872f, -0.01413483f, 0.18467763f, -0.04442573f, 
    0.09374362f, 0.11238477f, -0.06382903f, -0.10214017f, -0.22026312f, 0.23923591f, -0.02136406f, -0.04418434f, 
    -0.22412229f, 0.17600992f, 0.24062584f, -0.25235936f, 0.10657991f, 0.07056216f, 0.15153182f, 0.06242594f, 
    0.13457870f, -0.07240906f, 0.03995460f, 0.08168694f, 0.10338003f, 0.14721757f, 0.07564960f, 0.06078979f, 
    0.10560762f, -0.07688291f, 0.00501676f, -0.24581759f, -0.16411558f, 0.00692175f, 0.01689492f, 0.06396808f, 
    0.10540192f, -0.14357638f, -0.10025401f, 0.15714177f, 0.15599310f, 0.00390293f, 0.12968436f, 0.25842771f, 
    -0.04409603f, -0.07215279f, -0.03564590f, -0.00742231f, -0.13163517f, -0.17958243f, 0.34414729f, 0.03594824f, 
    -0.00973893f, 0.01016275f, 0.08364309f, -0.09802864f, -0.04959135f, -0.05374041f, 0.18388210f, -0.07305474f, 
    -0.26207936f, -0.49341291f, 0.00278465f, 0.06454085f, 0.10672247f, 0.12962383f, -0.00610698f, 0.13409421f, 
    0.08004805f, 0.00427170f, 0.15480065f, 0.00487085f, -0.20193097f, 0.19589441f, 0.10659461f, -0.24181253f, 
    -0.07025460f, -0.01025285f, 0.04448625f, -0.17140298f, -0.10508158f, 0.10742808f, 0.08602699f, -0.06931804f, 
    -0.04884882f, -0.03434812f, 0.17344354f, 0.21400300f, -0.08116647f, -0.11242195f, -0.02011708f, 0.09694071f, 
    0.18827303f, 0.16533132f, 0.08454991f, -0.03106705f, 0.24904628f, 0.35367385f, 0.14982970f, -0.08542467f, 
    0.22020268f, 0.02889028f, -0.04169852f, 0.20933914f, -0.07110259f, 0.07514668f, -0.00239746f, 0.10484061f, 
    -0.07614959f, 0.14839901f, -0.17543420f, 0.24761641f, 0.12793347f, -0.12655385f, -0.02400271f, -0.16595462f, 
    0.08576575f, -0.02373873f, -0.24540259f, 0.00890800f, 0.53461015f, -0.33108267f, -0.38759449f, -0.16275543f, 
    0.18686540f, 0.08587892f, 0.02207306f, 0.07408231f, 0.03884787f, 0.02083874f, -0.00332683f, 0.05977571f, 
    -0.05921781f, 0.08255527f, -0.01297595f, 0.01558649f, 0.13967398f, 0.17448583f, 0.06281935f, 0.18983731f, 
    -0.05978205f, 0.17890953f, 0.00359080f, -0.01515671f, 0.26717436f, 0.16205281f, 0.08695712f, -0.01193197f, 
    0.06904792f, 0.06696971f, 0.05413047f, -0.12441476f, 0.01120954f, -0.09282349f, 0.03192670f, 0.06095973f, 
    0.14194044f, 0.12721917f, 0.13642588f, -0.22198755f, -0.11035894f, 0.08254830f, 0.10620353f, 0.04579248f, 
    -0.07465499f, 0.10258763f, 0.08626477f, 0.01335485f, -0.26519814f, -0.01726612f, -0.22598515f, -0.04221339f, 
    -0.08144337f, 0.02584897f, 0.07667568f, 0.05764832f, 0.04169979f, 0.10837274f, -0.14524893f, 0.02454145f, 
    0.14739496f, -0.18673284f, -0.12347088f, 0.11877562f, 0.16420348f, -0.03076156f, -0.11911472f, 0.06502456f, 
    0.11245576f, -0.04825134f, 0.00086000f, 0.03478598f, 0.41125992f, -0.13246970f, 0.01644039f, 0.03401333f, 
    -0.04952979f, -0.06359456f, 0.05610852f, -0.00612937f, -0.04799354f, -0.00362581f, 0.03277164f, -0.07805713f, 
    0.37174067f, 0.17675743f, -0.16963637f, -0.37879622f, -0.11786782f, 0.01005639f, -0.03678513f, -0.08030307f, 
    0.07149910f, 0.03091812f, 0.06693103f, 0.09663756f, 0.22045733f, -0.16229099f, -0.04910003f, 0.45444199f, 
    0.03621487f, -0.02738895f, 0.04383983f, -0.03784392f, 0.01734314f, -0.01592753f, 0.04195382f, -0.03663774f, 
    -0.14208856f, 0.11740755f, 0.08821502f, -0.35665455f, -0.11358131f, 0.08211536f, 0.03481049f, 0.10387177f, 
    -0.02442127f, 0.02675681f, -0.09648207f, -0.05688199f, 0.05745000f, -0.12772220f, 0.03126647f, -0.12773581f, 
    -0.09335043f, -0.06638580f, -0.10251205f, 0.05377355f, -0.04099676f, -0.03834942f, 0.05452434f, 0.05531451f, 
    0.18888170f, -0.10220420f, 0.12747909f, -0.08848076f, -0.05191075f, -0.02776410f, 0.19871332f, 0.01633710f, 
    0.10218418f, -0.07183737f, 0.06587303f, 0.04850639f, 0.09711295f, 0.03394043f, 0.00432126f, 0.02549933f, 
    0.03469197f, 0.01613673f, 0.08214051f, 0.05478048f, 0.02119512f, 0.10192082f, -0.02862131f, -0.04060987f, 
    0.05267458f, 0.20802924f, -0.11587820f, -0.27311119f, -0.01072366f, 0.03779488f, 0.06063275f, 0.04667840f, 
    0.08397041f, 0.01024029f, 0.00880583f, 0.00906935f, 0.04459550f, -0.23681253f, -0.07313025f, -0.13394246f, 
    0.11943848f, -0.02851355f, -0.11617038f, 0.07034497f, -0.17655811f, 0.05480526f, 0.06341787f, -0.04273847f, 
    0.01365447f, -0.26646301f, 0.08400980f, 0.26233628f, -0.07990191f, 0.03671038f, 0.01932144f, 0.18578751f, 
    0.03110876f, 0.01887470f, 0.05349367f, -0.06802318f, -0.01583302f, 0.31067967f, -0.09805011f, 0.04017764f, 
    -0.05029424f, 0.06608515f, -0.02421894f, -0.03450793f, -0.08458581f, 0.03430318f, 0.02907946f, -0.01924787f, 
    0.23495294f, 0.00133010f, 0.02215224f, -0.09593889f, 0.09350319f, -0.00397818f, -0.08871353f, 0.02554086f, 
    0.00465684f, 0.01829177f, 0.03648018f, 0.02640013f, 0.35994449f, 0.03645478f, 0.04859349f, 0.15887448f, 
    0.14855722f, -0.13759540f, -0.09888863f, 0.05560669f, 0.03106822f, 0.03150664f, -0.05809829f, 0.11735278f, 
    0.24076746f, -0.27312613f, -0.01475982f, -0.06992798f, 0.00137715f, 0.00728083f, -0.01342991f, 0.05930501f, 
    -0.02273687f, 0.12785558f, 0.10639714f, 0.05692449f, -0.26067936f, 0.32335261f, 0.01704545f, 0.22083054f, 
    0.05071980f, 0.00188040f, -0.07888120f, -0.03401966f, -0.08886902f, -0.10414926f, -0.07191232f, -0.10593596f, 
    0.49882504f, -0.08043541f, -0.13766232f, 0.24591789f, 0.01761872f, 0.01796178f, -0.02941226f, -0.07830679f, 
    0.01337124f, -0.02531868f, -0.03043948f, 0.04195507f, 0.05226195f, -0.20153005f, 0.09972462f, 0.00036403f, 
    0.05885988f, -0.03356818f, -0.05900479f, -0.02303217f, -0.02436476f, -0.09557340f, -0.06228141f, -0.01243476f, 
    0.28411189f, -0.09395295f, 0.32681367f, -0.22581838f, -0.02388477f, -0.05934238f, 0.07242505f, -0.03791453f, 
    -0.09512938f, 0.02101983f, 0.17472492f, 0.15688308f, 0.00708298f, -0.23265550f, -0.06598200f, 0.22960292f, 
    -0.02670880f, 0.01729127f, 0.00672522f, 0.12857221f, -0.02889534f, 0.13228771f, 0.02435601f, 0.02737268f, 
    -0.19249389f, 0.09210868f, 0.03535372f, -0.36149815f, -0.00517347f, 0.03606523f, -0.03165297f, -0.01007438f, 
    0.11981361f, 0.08954962f, -0.08277581f, 0.14045204f, -0.31153965f, -0.13189338f, 0.10496254f, -0.26724240f, 
    -0.07182294f, -0.11084031f, 0.11940547f, 0.03414314f, 0.17387551f, -0.04676784f, 0.06082211f, -0.03828436f, 
    0.07807578f, -0.01217720f, 0.00112199f, -0.04755408f, 0.12012857f, 0.04364377f, -0.12383115f, 0.07010733f, 
    0.07061573f, -0.11017282f, 0.12255535f, 0.10871208f, -0.02812118f, -0.17932098f, 0.13168022f, 0.28083873f, 
    -0.08172216f, -0.12579152f, 0.03649441f, 0.10438640f, -0.03347173f, -0.02059072f, -0.05485392f, 0.08954465f, 
    0.18769360f, 0.03938302f, 0.10865884f, 0.03144098f, -0.06899720f, 0.00225836f, 0.07875635f, 0.04275970f, 
    -0.00739320f, 0.19121246f, 0.01357796f, 0.10683264f, 0.36364400f, -0.07472371f, 0.15135391f, -0.18337950f, 
    0.10380283f, 0.04694041f, -0.19839752f, 0.09344412f, -0.08961063f, -0.00804975f, -0.05709473f, 0.08239665f, 
    0.26611203f, -0.07136075f, 0.02195442f, 0.28715065f, -0.05788961f, 0.04649200f, 0.12054142f, -0.02710733f, 
    -0.03409110f, 0.06383128f, 0.05810120f, 0.02395667f, -0.25444725f, 0.38026229f, -0.03978895f, -0.04030881f, 
    0.01565880f, -0.12755050f, -0.03057622f, 0.04446954f, -0.07961155f, 0.08294452f, -0.04736272f, 0.00356289f, 
    -0.14615253f, 0.20477723f, -0.27531248f, -0.11405784f, 0.12013495f, -0.07173523f, 0.01559400f, -0.13981573f, 
    0.02009989f, -0.12386419f, 0.07580996f, -0.09439269f, 0.11412595f, -0.22356620f, 0.22234717f, 0.07246182f, 
    0.15871683f, -0.07113954f, -0.00988621f, 0.01446759f, 0.07643343f, -0.00286203f, -0.04656756f, 0.14242679f, 
    -0.06004864f, 0.01776764f, -0.04930399f, 0.01717397f, -0.05155359f, 0.02679080f, -0.04431421f, -0.06234103f, 
    -0.01068589f, -0.03103715f, -0.03734553f, 0.01824883f, 0.01301084f, 0.05893612f, 0.00884305f, 0.01072050f, 
    0.02424257f, -0.07406605f, 0.04057598f, -0.03824792f, -0.01959096f, 0.01758561f, -0.06137048f, -0.05768840f, 
    0.05451014f, 0.04816625f, -0.03376240f, -0.00407467f, -0.03781800f, 0.06287691f, 0.05791878f, 0.02834871f, 
    0.00998588f, -0.05869849f, -0.08294068f, 0.04901494f, -0.04006612f, -0.04963669f, 0.01063824f, 0.02022523f, 
    -0.01885302f, 0.04496995f, -0.00712240f, -0.05565952f, -0.02401863f, -0.01440192f, 0.01289785f, -0.00026625f, 
    -0.00886885f, -0.05682314f, -0.01549216f, 0.04122960f, -0.05444975f, -0.09045201f, -0.03563310f, -0.07064412f, 
    0.01910632f, -0.01992421f, -0.00940310f, -0.03780739f, 0.04865088f, -0.05504454f, -0.05614295f, -0.05868300f, 
    0.03159821f, 0.01174093f, 0.00214439f, 0.05155161f, 0.01991469f, 0.02672340f, -0.00095231f, 0.03297101f, 
    0.04446801f, -0.03170583f, 0.04128467f, -0.07554467f, 0.02925290f, -0.04887402f, -0.00901599f, -0.07375855f, 
    0.04377371f, 0.04822731f, -0.02848157f, 0.00636242f, -0.04288714f, -0.00647135f, 0.02107369f, 0.02149213f, 
    0.04355326f, -0.04734743f, -0.04916110f, 0.05440655f, 0.01812302f, -0.02017376f, -0.02599820f, -0.07037438f, 
    -0.03648373f, -0.00943351f, -0.01608763f, -0.00360174f, -0.02527935f, -0.00836414f, -0.06225874f, -0.01152614f, 
    0.04585056f, -0.03040643f, 0.00496461f, 0.00305020f, -0.05198963f, 0.03591105f, -0.03288694f, 0.03249385f, 
    -0.06139250f, -0.04640144f, 0.01962380f, -0.05807616f, 0.00796646f, -0.01836607f, 0.03024199f, -0.04585024f, 
    -0.06588901f, -0.00102233f, -0.05881038f, -0.01393027f, 0.01982503f, 0.02840249f, 0.03522013f, 0.03713999f, 
    0.03933645f, -0.05559611f, -0.00020536f, -0.01150910f, -0.02133507f, -0.00241434f, 0.04164690f, -0.03583565f, 
    -0.02257288f, -0.06800713f, -0.01916014f, 0.04378389f, 0.02904736f, 0.06826746f, 0.00832085f, 0.02386458f, 
    -0.00412121f, 0.04471453f, -0.08709275f, -0.05819854f, 0.01499919f, 0.07258309f, -0.04821887f, 0.01537596f, 
    -0.02180629f, -0.05653084f, -0.05564394f, -0.03651868f, -0.06423104f, -0.03866003f, 0.05078851f, -0.07783293f, 
    -0.01304296f, -0.07325989f, 0.05652982f, -0.05162562f, -0.06194413f, 0.01890790f, 0.02190047f, -0.07629564f, 
    0.01896327f, 0.00937499f, 0.04788624f, -0.02557908f, 0.05178941f, 0.00034474f, -0.04415405f, -0.02102624f, 
    0.02538397f, 0.01038810f, 0.01990031f, 0.05095519f, 0.03026514f, 0.07118049f, 0.04563827f, 0.00499740f, 
    0.02451193f, -0.02027988f, -0.04234552f, -0.05119646f, -0.04359990f, 0.04662559f, 0.00756232f, -0.03945512f, 
    -0.02801589f, -0.14946909f, -0.02871072f, 0.04970684f, 0.04330795f, 0.10532057f, 0.01386525f, 0.05641265f, 
    -0.01153404f, 0.05419467f, 0.01537666f, 0.07138161f, -0.01000208f, -0.00375150f, 0.07205689f, -0.19173844f, 
    0.08329679f, 0.09779967f, -0.00447084f, 0.04432433f, -0.04639120f, -0.09599951f, 0.00677744f, -0.08363745f, 
    -0.19396211f, -0.13943884f, 0.16938117f, 0.10631497f, 0.05265851f, -0.04217144f, 0.02829413f, -0.15428524f, 
    0.12459718f, 0.03198140f, -0.06378369f, 0.03933786f, -0.39639127f, -0.01893830f, 0.02924735f, 0.14952429f, 
    0.04052168f, 0.05002801f, -0.04696375f, 0.05628924f, 0.08325140f, 0.07413787f, 0.07750100f, 0.04589009f, 
    -0.42420459f, 0.19600505f, 0.30360436f, -0.16310512f, 0.13196474f, 0.17643210f, 0.14351453f, 0.02068650f, 
    -0.09253771f, -0.11570491f, -0.06786340f, 0.02328650f, -0.32715112f, 0.09829196f, 0.02221905f, -0.32897577f, 
    0.03225518f, -0.05647566f, 0.06355492f, 0.12805548f, 0.10656492f, 0.05215277f, 0.04464434f, 0.07859813f, 
    0.33499625f, -0.17941740f, 0.05708159f, -0.02094409f, 0.02356774f, -0.01994897f, 0.01444472f, -0.00829178f, 
    -0.06994825f, -0.00774319f, -0.07903097f, 0.04612366f, 0.16502479f, -0.11351151f, -0.04514315f, -0.07960089f, 
    0.03935705f, -0.00783044f, -0.00220883f, -0.05831310f, 0.08218315f, -0.07863937f, 0.04111919f, 0.09964507f, 
    -0.17744742f, -0.00790925f, 0.03453480f, 0.05795737f, 0.04463116f, 0.07462556f, -0.07243247f, 0.07353183f, 
    0.05771848f, 0.04472897f, 0.09332242f, 0.09506704f, 0.02175469f, -0.01069252f, 0.25624466f, -0.09463592f, 
    -0.02464250f, 0.03848851f, 0.13850880f, 0.05994331f, 0.05588138f, -0.00918556f, 0.03715111f, 0.12641324f, 
    -0.14484899f, 0.03430336f, 0.35163659f, -0.15699551f, 0.02711133f, 0.03500059f, -0.08571963f, 0.01648991f, 
    0.12577666f, 0.02948654f, 0.03280259f, -0.04767087f, 0.15520847f, 0.27561000f, 0.04600262f, -0.01589234f, 
    0.10341713f, 0.12709090f, 0.02352347f, 0.10138008f, 0.15179178f, 0.03264069f, 0.04362926f, 0.07392514f, 
    0.00089648f, 0.32369459f, -0.21317220f, -0.14783412f, 0.00167847f, -0.10414145f, -0.04647371f, -0.07682081f, 
    0.04271008f, 0.05055885f, 0.07322510f, 0.02017422f, 0.12884884f, -0.18509860f, 0.02685411f, 0.06456544f, 
    -0.01460483f, -0.06168787f, 0.10623071f, 0.01469171f, -0.01826564f, 0.07300974f, 0.02891080f, 0.07112787f, 
    0.03428736f, -0.14961714f, 0.08224487f, 0.08164483f, -0.12077794f, -0.02762699f, 0.13484477f, 0.11227827f, 
    -0.07006492f, 0.02770766f, -0.09194780f, 0.06195157f, -0.00563586f, -0.13082583f, -0.21686126f, -0.15772006f, 
    -0.06613229f, 0.05509650f, -0.00752934f, -0.07358160f, 0.09051341f, 0.01380791f, 0.05680539f, -0.01584895f, 
    0.07751837f, -0.13239476f, -0.08028813f, 0.17871116f, 0.15446031f, -0.11825962f, 0.03634603f, 0.09800106f, 
    0.12339251f, 0.11689064f, 0.12326989f, -0.01091185f, 0.12556811f, 0.30788404f, 0.25988519f, 0.11988685f, 
    0.10299082f, 0.06785133f, 0.07955411f, 0.12223923f, 0.04427188f, -0.04789472f, -0.03534552f, -0.04160931f, 
    0.10776371f, -0.08528476f, 0.11729667f, 0.08200143f, -0.05666232f, -0.07382291f, 0.03704628f, 0.03014394f, 
    -0.02969380f, -0.03095936f, -0.00681601f, 0.10486978f, -0.34878004f, -0.21869086f, -0.08227075f, 0.00030058f, 
    -0.08493506f, 0.00389894f, -0.08769596f, 0.08646082f, 0.08987114f, -0.05876419f, 0.01898540f, 0.08920076f, 
    -0.64551514f, -0.03097626f, 0.02849586f, 0.09239733f, 0.02770547f, 0.04733348f, 0.16074862f, 0.19229330f, 
    -0.07400001f, -0.06272697f, 0.05423117f, -0.02821223f, -0.31782490f, -0.08137868f, 0.11914854f, -0.20519578f, 
    -0.05426385f, 0.12104353f, 0.02689742f, 0.02793552f, 0.03542634f, 0.00030568f, -0.03975032f, 0.16551119f, 
    0.26703742f, 0.00141050f, -0.03284254f, -0.04318120f, 0.13667683f, -0.08648103f, -0.10835214f, -0.13639942f, 
    0.11067623f, 0.01360811f, -0.10234054f, 0.15136206f, 0.25453350f, 0.23039214f, 0.01826285f, -0.18173020f, 
    0.05033642f, 0.05480422f, 0.09920976f, -0.04411676f, 0.10174220f, -0.01475784f, 0.11513346f, 0.01430721f, 
    -0.07232191f, 0.19559337f, -0.06663147f, 0.08397458f, 0.05258108f, 0.13796717f, -0.21138079f, 0.01223065f, 
    0.06162607f, -0.04479276f, 0.02295227f, 0.00153453f, 0.13410768f, -0.13192236f, 0.17341536f, 0.39382926f, 
    -0.09515575f, -0.00530625f, 0.05287037f, -0.02354679f, -0.13808945f, -0.13319711f, 0.10113728f, 0.07241661f, 
    -0.21742819f, -0.00062961f, 0.10249334f, 0.25435731f, 0.09758321f, 0.19198370f, -0.00439422f, -0.10509667f, 
    -0.00871022f, -0.08906343f, 0.10716254f, 0.10049437f, 0.02647984f, 0.10390686f, 0.05945821f, -0.16060323f, 
    -0.03380210f, 0.11828540f, -0.06128316f, -0.09652132f, 0.16098428f, -0.05631664f, 0.02886450f, -0.00376372f, 
    -0.03139433f, 0.08437792f, 0.21716878f, 0.01322513f, -0.00800893f, -0.02589124f, -0.07180783f, -0.06952140f, 
    -0.02888930f, 0.05477068f, 0.08601330f, -0.07343723f, -0.34159467f, 0.07934459f, 0.06764261f, 0.04339822f, 
    0.13122357f, -0.01046410f, 0.03571281f, 0.14904717f, 0.13299471f, 0.05144820f, 0.05278815f, 0.01667535f, 
    -0.02361491f, 0.12477624f, -0.11876605f, 0.01492627f, -0.06224865f, 0.00834356f, 0.16996422f, 0.02391115f, 
    -0.07849022f, -0.08510009f, -0.01276421f, -0.10026418f, -0.26187500f, -0.23554337f, 0.07207395f, -0.19353278f, 
    -0.27582467f, 0.11760146f, -0.02766404f, -0.03112928f, 0.05329620f, -0.07583071f, 0.06378932f, 0.05976778f, 
    -0.00754145f, 0.26004604f, 0.24167706f, -0.31014857f, -0.01839070f, 0.14757705f, 0.20876963f, 0.06500741f, 
    -0.05988377f, -0.03765908f, -0.01674525f, -0.07341905f, -0.17594843f, -0.33217624f, -0.31350195f, -0.28136775f, 
    -0.00315289f, 0.02360880f, 0.17077073f, 0.11300698f, 0.16495867f, 0.19648969f, -0.06682213f, 0.02678798f, 
    -0.28192699f, -0.24615037f, -0.17077933f, 0.18323340f, 0.03332231f, 0.25731239f, -0.20153815f, -0.00274911f, 
    -0.00497450f, 0.01835952f, 0.10606696f, 0.01664811f, 0.30279917f, 0.21879712f, 0.06293862f, 0.36017874f, 
    0.00116787f, -0.07420053f, 0.02087508f, 0.05464325f, -0.13668920f, 0.12640829f, -0.09638143f, -0.10152312f, 
    -0.20868836f, 0.15398619f, -0.15861899f, -0.41720197f, -0.12684211f, -0.00911500f, 0.14493886f, -0.02638575f, 
    -0.05114813f, -0.04858666f, -0.02372668f, 0.00586775f, 0.10947345f, -0.01158465f, 0.06075025f, 0.44885468f, 
    0.00818133f, -0.10868858f, 0.00851041f, -0.07946372f, 0.10485435f, -0.07446298f, -0.01110922f, -0.09910324f, 
    0.11896368f, 0.40768555f, 0.03177294f, -0.19421713f, -0.14241110f, 0.01919561f, 0.06015725f, 0.11497822f, 
    -0.01706034f, 0.00753555f, 0.05469776f, -0.14359356f, 0.25713304f, 0.07438102f, -0.16794609f, -0.28387719f, 
    0.01053098f, -0.09328909f, -0.22425911f, 0.05541559f, -0.08796876f, 0.01960978f, 0.08824190f, -0.05256935f, 
    -0.20020069f, -0.11635588f, 0.25258532f, -0.25655669f, -0.07852580f, -0.12407117f, 0.08833481f, 0.21384133f, 
    -0.01769002f, 0.07121057f, -0.01106694f, 0.11125273f, 0.10093837f, -0.32410648f, 0.11290923f, -0.08262514f, 
    0.12898688f, 0.05092884f, 0.04777741f, 0.08253236f, 0.05143506f, 0.15980010f, -0.07566928f, -0.08598130f, 
    -0.34512508f, 0.01393935f, -0.24978675f, -0.27292404f, -0.01265446f, -0.13116278f, 0.01230975f, 0.03395933f, 
    -0.13376711f, -0.02019156f, -0.00441548f, -0.08292377f, 0.14893386f, -0.00330129f, -0.04340484f, -0.08193599f, 
    0.11250935f, -0.08303053f, 0.13774072f, -0.07151865f, -0.02696884f, 0.02347091f, 0.09280697f, -0.11822138f, 
    -0.03897583f, 0.25798744f, 0.08451933f, 0.22464943f, -0.06983168f, 0.18769687f, 0.06985398f, 0.14750870f, 
    -0.08263726f, 0.05096668f, 0.01210925f, -0.11002441f, 0.23434952f, 0.19301923f, 0.11724699f, -0.12606801f, 
    -0.04755701f, 0.14740168f, 0.04685789f, -0.15861097f, -0.03334491f, -0.04130141f, 0.03997730f, -0.01459529f, 
    0.68664718f, -0.02676889f, 0.18775429f, 0.27027169f, 0.01532400f, 0.10402398f, -0.04614832f, 0.14282534f, 
    -0.13980459f, -0.01852678f, 0.00149148f, 0.01552739f, 0.38561606f, 0.07049990f, 0.00203130f, 0.06889056f, 
    -0.12143043f, -0.16660975f, -0.03337588f, 0.09976232f, -0.12144917f, 0.11927433f, -0.11360291f, -0.15866709f, 
    0.06124502f, 0.05218818f, -0.03249679f, -0.21019396f, -0.07923399f, 0.13241526f, 0.02561088f, 0.11476772f, 
    0.02302479f, 0.00525358f, 0.16493100f, -0.00474857f, 0.17570327f, 0.08839169f, 0.24410814f, -0.01757797f, 
    -0.01473020f, 0.05679512f, 0.07653101f, 0.10476348f, 0.08417636f, 0.09273152f, -0.08347173f, 0.15942661f, 
    0.27693591f, -0.32780907f, 0.00337134f, 0.19569252f, -0.02234003f, -0.02342719f, -0.19485877f, 0.12915681f, 
    0.02328882f, -0.15552896f, -0.01417584f, 0.11117545f, -0.17132616f, -0.09614315f, -0.05157780f, 0.20466042f, 
    -0.15522431f, -0.26786548f, -0.05193583f, 0.15027498f, 0.04187984f, 0.12626229f, -0.01336551f, -0.08028503f, 
    -0.17115335f, 0.14858007f, -0.08009519f, 0.01536055f, -0.09577525f, -0.02044508f, -0.01032401f, 0.27306381f, 
    0.00123804f, 0.03157105f, 0.06497483f, -0.09387090f, -0.05873534f, -0.01272515f, 0.11224210f, -0.14021109f, 
    -0.10932313f, 0.04549977f, -0.01535418f, 0.12751460f, 0.03598886f, -0.11271396f, -0.12968166f, -0.15070130f, 
    0.07173677f, 0.15687431f, -0.02673177f, -0.19931079f, -0.04246862f, 0.10616181f, -0.02466539f, -0.18380374f, 
    0.12411565f, 0.11119767f, 0.04378610f, 0.21261394f, 0.21374905f, 0.25476637f, -0.01590941f, -0.32745397f, 
    0.00573552f, 0.01811963f, 0.17753482f, -0.03172876f, -0.00156381f, -0.10109370f, 0.08610249f, -0.05000854f, 
    0.04293286f, 0.08118773f, 0.04274542f, -0.16125099f, -0.04561526f, 0.14483549f, 0.00490660f, -0.04574698f, 
    0.04207661f, -0.00390154f, -0.16963175f, 0.09849507f, 0.35752282f, 0.04634686f, 0.26668125f, 0.40415895f, 
    -0.10275868f, 0.11889907f, 0.06208108f, 0.07126400f, 0.04040235f, -0.21453221f, -0.01698000f, 0.05720994f, 
    -0.15178010f, 0.04776764f, -0.12635674f, 0.02211308f, 0.07252830f, 0.03032146f, -0.06209582f, 0.01179206f, 
    -0.01640000f, -0.11311278f, 0.16182838f, -0.09596982f, -0.07250118f, -0.16278140f, -0.26635846f, -0.05521088f, 
    -0.05138566f, 0.04315652f, 0.01764948f, 0.08842789f, 0.12232933f, 0.00082540f, -0.04297692f, -0.00752844f, 
    0.47003731f, -0.16368677f, 0.30526578f, 0.16317774f, -0.06294789f, 0.03852056f, 0.10971706f, 0.17221509f, 
    0.04304231f, -0.04835599f, 0.08048475f, 0.04767066f, -0.45631781f, 0.21870859f, 0.22271039f, 0.14723757f, 
    0.03691502f, -0.05426500f, 0.05702141f, -0.03656844f, -0.00293471f, -0.11293253f, 0.02986125f, 0.17581515f, 
    0.13062443f, 0.01242507f, -0.03458770f, -0.22562853f, -0.12476123f, 0.14395641f, 0.01233594f, 0.00619814f, 
    0.05018428f, 0.07320949f, 0.17541668f, -0.00642778f, 0.06128075f, -0.13429528f, 0.05047314f, -0.06785303f, 
    -0.27063471f, 0.06997409f, -0.14071676f, 0.12847339f, 0.01293425f, 0.02997636f, 0.13845833f, -0.02855075f, 
    0.30175078f, -0.07696927f, -0.02842425f, 0.02958306f, -0.01811396f, -0.08204570f, -0.02837216f, 0.06339296f, 
    0.01844716f, 0.10601756f, 0.08252685f, 0.10037884f, -0.23155497f, -0.00208059f, -0.08434918f, -0.16034091f, 
    -0.07412812f, -0.05429005f, 0.02716511f, -0.02992648f, -0.12271165f, -0.05622684f, 0.08475199f, -0.05405844f, 
    0.05823489f, -0.07119538f, 0.17133322f, -0.10802818f, -0.11685158f, 0.06089485f, 0.26375908f, -0.09304608f, 
    0.02036070f, 0.06786054f, 0.08602928f, 0.04222739f, -0.17298058f, 0.04271333f, 0.03041836f, -0.13981101f, 
    0.07810306f, 0.19613022f, 0.08387362f, 0.02270654f, 0.15714377f, -0.16537778f, 0.13422853f, -0.01363766f, 
    0.36754754f, -0.16133693f, 0.26718667f, 0.10042134f, 0.12465825f, -0.00534048f, 0.03629454f, -0.10889199f, 
    0.03804218f, 0.09302177f, 0.20612977f, 0.13058120f, -0.14435735f, -0.00064876f, -0.00478464f, 0.07260678f, 
    0.10283367f, -0.02536451f, -0.02851094f, -0.02893401f, 0.02003856f, 0.13033956f, 0.19610195f, 0.08305240f, 
    -0.29438889f, -0.40487811f, -0.07987551f, -0.09902745f, -0.10515132f, 0.00858717f, -0.00793039f, 0.06974287f, 
    0.04249936f, -0.00856445f, -0.06050861f, -0.05333934f, -0.33967358f, -0.28581008f, -0.04415358f, 0.17065935f, 
    0.10672416f, 0.01378806f, 0.00426408f, -0.00060477f, 0.17279056f, -0.02871350f, -0.01106577f, 0.01055870f, 
    0.07687461f, -0.12344450f, -0.03754248f, 0.01643692f, -0.04022380f, -0.01981172f, 0.16042566f, 0.16340186f, 
    0.09788027f, 0.11240783f, 0.22536705f, -0.00274123f, -0.15125224f, 0.04430692f, -0.01822324f, -0.18383703f, 
    0.12546133f, 0.06332646f, -0.08168145f, 0.08770299f, 0.08401576f, 0.05527788f, -0.00336710f, 0.16635615f, 
    0.20903470f, 0.08863487f, 0.23043291f, -0.09760811f, 0.05638326f, 0.04543481f, 0.22876427f, 0.10035457f, 
    -0.01311142f, 0.18985379f, -0.06259748f, 0.24366020f, 0.06929801f, 0.16177176f, 0.15449028f, 0.12025031f, 
    -0.05582626f, 0.19122544f, -0.04912257f, 0.15611960f, -0.07643361f, -0.03464103f, -0.04253604f, 0.06555520f, 
    -0.05747539f, 0.12638254f, -0.14544415f, -0.12187047f, 0.11789263f, -0.05878136f, 0.04584993f, -0.04053745f, 
    0.04356618f, 0.08221840f, -0.02140157f, 0.10473520f, 0.12740874f, -0.06695203f, -0.21420194f, 0.12154081f, 
    0.02431095f, 0.01783684f, 0.06616936f, -0.04618052f, 0.00028806f, 0.05226864f, -0.02804004f, -0.01146868f, 
    -0.31585598f, -0.02478893f, -0.06127961f, -0.02190738f, -0.02067743f, -0.07048676f, 0.02380837f, -0.13703558f, 
    0.06666110f, -0.03215756f, 0.02765730f, 0.02915267f, -0.04083849f, -0.14994620f, -0.04529082f, 0.20083869f, 
    0.20157982f, 0.08733775f, -0.02353549f, -0.24249861f, 0.04076704f, 0.04270447f, -0.04780009f, 0.04466438f, 
    -0.13884354f, 0.24730591f, -0.03024962f, 0.04103472f, 0.06072890f, -0.08475032f, 0.02215189f, 0.02324751f, 
    0.11870136f, -0.02574986f, 0.14507277f, -0.13754645f, 0.25495529f, 0.03704336f, 0.00011744f, 0.02154353f, 
    0.06859726f, -0.10402741f, 0.07524079f, 0.15750031f, 0.04148488f, -0.04277164f, 0.07289355f, -0.01445552f, 
    -0.23699412f, -0.04057977f, 0.19867103f, -0.11031605f, -0.06027329f, -0.01108691f, 0.30138049f, -0.13491635f, 
    -0.03670894f, 0.17686345f, 0.17153507f, -0.06291807f, -0.05133582f, 0.18631235f, 0.01335607f, 0.04873828f, 
    0.01528888f, 0.05154975f, 0.02562465f, 0.00762666f, 0.03642844f, -0.12365472f, 0.24430569f, -0.11694343f, 
    -0.00175117f, 0.08536116f, -0.20245744f, 0.24227694f, 0.18320544f, 0.02955642f, -0.08309843f, 0.00223828f, 
    0.09716428f, 0.04964642f, -0.08399829f, -0.08295295f, -0.30831495f, 0.02225212f, 0.06622387f, -0.01372961f, 
    0.20227212f, -0.01948809f, -0.04855242f, -0.01724533f, 0.04334443f, 0.04760782f, 0.03912543f, 0.06598698f, 
    -0.19947764f, -0.10713148f, -0.16570860f, 0.39020759f, 0.02237152f, -0.00734065f, 0.09792572f, -0.05139019f, 
    0.09598817f, -0.08024468f, -0.01775518f, -0.02627353f, -0.25703341f, 0.21921188f, -0.04830498f, 0.12086067f, 
    0.06512491f, 0.02135073f, 0.06251779f, 0.00328401f, 0.02892567f, 0.12246421f, -0.05424296f, -0.00624917f, 
    -0.09198815f, 0.16732718f, -0.04759761f, -0.01243740f, -0.08242854f, 0.12973675f, 0.10836504f, 0.03512138f, 
    -0.07354658f, 0.07052967f, 0.14190029f, -0.05309794f, -0.02764594f, 0.02459719f, -0.17423786f, -0.22373632f, 
    0.03123712f, 0.06764921f, -0.23741005f, -0.01536490f, 0.16124724f, -0.03209079f, 0.09304117f, 0.05097875f, 
    -0.25536859f, 0.00871295f, -0.21851149f, 0.19024175f, 0.14520127f, -0.00255989f, -0.01289793f, 0.12408458f, 
    -0.08129470f, -0.06714074f, -0.08068530f, 0.00617196f, -0.04940933f, 0.17283668f, -0.12902175f, 0.13248797f, 
    -0.04415724f, -0.01418284f, -0.03286079f, 0.00354793f, 0.04620897f, -0.06328969f, 0.02182193f, -0.03067796f, 
    -0.05883871f, 0.09294974f, 0.28032908f, -0.07387235f, 0.13318953f, -0.03967993f, -0.01577078f, -0.04168268f, 
    0.12373500f, 0.05192990f, 0.16626902f, 0.18664663f, 0.14315517f, -0.12045850f, 0.01995303f, 0.15075952f, 
    0.07243951f, 0.09176318f, -0.02730659f, -0.03495165f, 0.00546517f, 0.06038679f, -0.06546292f, 0.04652445f, 
    -0.18355821f, -0.03082914f, 0.15985206f, 0.12044866f, 0.02497336f, -0.05448053f, 0.01964544f, -0.00945979f, 
    -0.11548770f, 0.08563316f, 0.04094511f, -0.01426435f, -0.12960061f, 0.18153021f, 0.00685810f, 0.19128796f, 
    0.07593422f, 0.13834764f, -0.14434381f, -0.08572608f, -0.03249370f, -0.05033163f, 0.10884216f, -0.02719742f, 
    0.03957495f, -0.08178906f, -0.07979093f, 0.01001795f, 0.03482341f, 0.04975152f, -0.03758518f, 0.00381262f, 
    -0.02090947f, 0.02804796f, 0.01337297f, -0.04810421f, 0.00535750f, -0.06591192f, -0.06098722f, -0.06073403f, 
    0.02650098f, -0.01076018f, -0.02832274f, -0.03841750f, -0.03418367f, -0.07010306f, -0.05815570f, -0.06621835f, 
    0.02467980f, -0.00342411f, -0.02207525f, -0.07670020f, -0.05473544f, -0.04580249f, 0.06222724f, -0.06870875f, 
    -0.06749364f, -0.03530234f, 0.02743276f, -0.06161273f, -0.03918963f, -0.00797213f, 0.05730487f, -0.08554091f, 
    0.02814816f, 0.05269418f, 0.05494868f, 0.04543562f, -0.04922325f, 0.03458847f, -0.04127131f, 0.00161510f, 
    -0.03075135f, -0.02000229f, 0.02026119f, 0.04067649f, -0.06733117f, -0.06293627f, -0.06169823f, -0.04682833f, 
    -0.03216818f, -0.07932705f, 0.04362091f, -0.06124410f, -0.05351945f, 0.04529148f, -0.02482883f, -0.03176104f, 
    0.00771348f, 0.00461371f, -0.02837718f, 0.02934187f, -0.00616325f, -0.06485628f, -0.05418078f, -0.02618238f, 
    0.01772659f, 0.05086686f, -0.02016073f, 0.04794263f, -0.01155070f, 0.05992320f, -0.03753721f, 0.02226555f, 
    -0.05355692f, 0.03420241f, 0.01762955f, -0.05102539f, -0.00343656f, 0.01801085f, 0.01152278f, -0.04520290f, 
    0.00399186f, 0.01417943f, 0.05222397f, 0.01784580f, 0.05216768f, 0.03883180f, 0.01674009f, -0.04217216f, 
    0.03380828f, -0.06769384f, 0.02492736f, -0.04474640f, 0.03700837f, 0.05355586f, -0.07837993f, -0.01057004f, 
    -0.00121229f, 0.05606795f, -0.04197259f, 0.04685071f, -0.05182738f, 0.05116103f, -0.01419468f, 0.02653977f, 
    -0.02777410f, -0.02483364f, 0.04148144f, 0.04179488f, -0.03662590f, -0.04317656f, -0.02567541f, -0.05659515f, 
    -0.07649901f, 0.04503622f, -0.04146320f, -0.00254228f, 0.05238374f, 0.05084283f, -0.06528243f, 0.01416613f, 
    -0.03198726f, 0.03871465f, -0.00657800f, 0.06171854f, 0.01118532f, 0.04678744f, 0.05094079f, -0.07494690f, 
    0.05949882f, -0.00163766f, -0.01880210f, -0.07572440f, -0.01493338f, 0.06514198f, -0.03572496f, 0.00361494f, 
    0.05463810f, -0.04171357f, -0.09518721f, 0.05642217f, -0.03123370f, -0.04431666f, -0.05120059f, -0.00373863f, 
    0.05406142f, 0.02049947f, -0.01776267f, 0.04609777f, -0.04202703f, -0.02806919f, -0.01578710f, 0.02148335f, 
    0.05848439f, -0.05736764f, 0.04242972f, 0.01486686f, 0.01913972f, 0.04121454f, -0.05452914f, -0.07913607f, 
    -0.04740731f, 0.01693260f, -0.06578771f, 0.00291683f, 0.03964361f, 0.05573377f, -0.07689680f, 0.00221653f, 
    -0.02036715f, 0.01799523f, 0.03899984f, 0.02320050f, -0.01127556f, 0.03899752f, -0.02956150f, 0.01743660f, 
    -0.07501945f, 0.02060930f, -0.04872303f, -0.05368047f, 0.00448087f, -0.05579584f, 0.04535346f, -0.02170248f, 
    0.52026206f, 0.11232220f, 0.03951613f, 0.20896614f, -0.00785022f, 0.06246695f, 0.28396612f, -0.02029918f, 
    0.00965698f, 0.06312622f, -0.03914177f, 0.01766781f, 0.07166499f, -0.08126464f, 0.12197437f, -0.11513887f, 
    0.01125213f, -0.00162931f, 0.06945378f, 0.04950860f, 0.02004605f, 0.11411170f, 0.00182506f, 0.09780309f, 
    -0.05534417f, -0.16150354f, 0.14657949f, 0.02892199f, 0.05339934f, 0.32547581f, -0.01178124f, -0.09786530f, 
    0.07036983f, 0.11476005f, 0.00856802f, 0.04254189f, -0.26120338f, -0.19437706f, -0.26618028f, -0.26715523f, 
    0.08900144f, 0.19517602f, -0.03502433f, 0.09698793f, 0.21512227f, -0.19679219f, 0.17741202f, 0.01491410f, 
    0.16082244f, -0.29804644f, 0.11844543f, -0.01836622f, -0.04550214f, 0.04466363f, 0.02444566f, -0.00650400f, 
    0.06152123f, -0.01887636f, 0.05120139f, -0.00617482f, -0.24524723f, -0.22692874f, -0.08447777f, 0.30519900f, 
    0.19769475f, 0.09713961f, -0.14900358f, -0.09116884f, -0.08203525f, -0.02580541f, 0.09557408f, -0.11119425f, 
    -0.02901683f, 0.03050353f, 0.21553616f, 0.02493229f, -0.22219110f, -0.16396752f, 0.02246806f, 0.02166184f, 
    -0.14678732f, 0.04695802f, -0.06078584f, -0.02657990f, 0.32805127f, 0.23417653f, 0.01558325f, 0.01581513f, 
    0.03279642f, -0.17017023f, -0.11354791f, 0.03694977f, 0.00549072f, 0.02760541f, -0.00340369f, -0.11181127f, 
    0.24039578f, 0.07695196f, 0.05361602f, 0.23034254f, -0.24335383f, -0.07469240f, 0.13554239f, 0.19963913f, 
    0.08078557f, -0.04538120f, -0.02618136f, -0.04458672f, 0.10700188f, -0.13576941f, 0.09971292f, 0.22919323f, 
    0.28021714f, 0.10631717f, 0.00845015f, 0.05821281f, -0.00825837f, 0.05975895f, -0.01250655f, -0.06698560f, 
    0.06474817f, 0.11611990f, 0.08318237f, -0.25140315f, 0.10008196f, 0.13379160f, 0.25902295f, -0.04654766f, 
    0.03224294f, 0.11379395f, -0.03826498f, 0.15755048f, -0.36550781f, -0.08983120f, -0.10000728f, -0.02869722f, 
    -0.14452328f, -0.07164180f, 0.21090938f, -0.02811684f, -0.09617664f, -0.01386884f, 0.01563819f, -0.12545167f, 
    -0.26270357f, -0.23641805f, -0.02648028f, -0.32347158f, 0.19372009f, 0.02966286f, -0.05004102f, 0.08922803f, 
    -0.03097964f, 0.02504440f, 0.10632510f, -0.06896865f, -0.29109207f, 0.31746155f, -0.12461685f, 0.24847211f, 
    -0.03280777f, 0.04131152f, 0.14361309f, 0.25047284f, -0.09942662f, 0.13050804f, -0.01552339f, -0.02128976f, 
    0.16774940f, -0.01191215f, -0.03222059f, 0.11247744f, -0.17427535f, -0.13874222f, 0.09523198f, 0.15133983f, 
    0.15810478f, -0.07361480f, 0.04455055f, -0.02124564f, -0.09895452f, -0.40401375f, -0.16045479f, 0.09579787f, 
    0.09940699f, 0.01793289f, -0.00809619f, -0.05661252f, -0.11157893f, -0.10805105f, -0.09379790f, 0.05416466f, 
    0.02286137f, -0.04797263f, -0.05575352f, 0.08982398f, -0.02529319f, -0.01372717f, 0.12929387f, 0.15049940f, 
    0.14181916f, 0.00877595f, 0.04303610f, 0.07918669f, 0.30227914f, 0.14662074f, 0.35750502f, -0.04958182f, 
    0.16529144f, -0.04979470f, -0.00947437f, -0.02587464f, 0.07800228f, 0.02127703f, 0.06390148f, 0.23670149f, 
    0.30951220f, -0.29971790f, 0.08478688f, 0.04791052f, -0.00117699f, 0.04804263f, -0.05257436f, -0.14250660f, 
    0.20086385f, 0.01181549f, -0.03387848f, -0.02779389f, -0.44311142f, -0.14835849f, -0.03821246f, 0.00910340f, 
    -0.01836140f, -0.12901904f, -0.09006941f, -0.05577180f, 0.09001378f, -0.00118545f, -0.08514922f, 0.15388405f, 
    -0.30838892f, -0.24746972f, 0.11784956f, 0.10531024f, -0.01617267f, 0.04261904f, -0.07756799f, -0.00391283f, 
    0.00860417f, 0.04828072f, -0.01155972f, -0.04267398f, -0.34934068f, -0.16919346f, -0.02008723f, -0.08266969f, 
    -0.12343889f, 0.06326614f, -0.01928026f, 0.03103678f, 0.02372465f, 0.06474949f, -0.12925310f, -0.22374989f, 
    -0.02632852f, -0.00495822f, 0.18087532f, -0.05334432f, 0.02953636f, 0.02340449f, -0.02608656f, -0.03452077f, 
    0.02550573f, -0.02178529f, 0.02087768f, 0.33066654f, 0.16528535f, 0.25431100f, -0.02988416f, -0.11478015f, 
    0.16363357f, -0.11526942f, 0.33865798f, -0.01666208f, 0.08674832f, -0.05067226f, 0.04982731f, -0.00536653f, 
    -0.24260721f, -0.00278165f, -0.02844926f, -0.02299124f, -0.06199233f, 0.04913628f, -0.13069379f, 0.06013703f, 
    0.03641693f, 0.08437908f, -0.05458200f, 0.09496068f, 0.00563946f, 0.03564336f, 0.25692880f, 0.32919189f, 
    -0.07309099f, 0.15272929f, 0.09774677f, 0.10763647f, 0.05195183f, 0.00685520f, 0.03873461f, -0.03219690f, 
    -0.05826455f, -0.12998939f, -0.02881539f, 0.21153095f, -0.00170787f, 0.04005801f, 0.00979605f, 0.05405147f, 
    0.01192303f, 0.07865406f, 0.08263580f, 0.06813885f, -0.17755266f, 0.08211182f, -0.13133438f, -0.11228200f, 
    -0.10466681f, 0.12806179f, 0.01987593f, 0.07824051f, 0.03698345f, 0.05604210f, -0.04983483f, 0.07354090f, 
    0.42232218f, 0.07127476f, 0.07922710f, 0.09508077f, -0.08199940f, 0.04109830f, 0.00489492f, -0.10453808f, 
    0.05215428f, -0.10232685f, 0.08820590f, -0.01153080f, -0.38039923f, 0.17451087f, 0.24737389f, 0.11508482f, 
    0.08688597f, -0.05497793f, 0.09537783f, -0.02773085f, -0.11802359f, 0.08531063f, -0.11264549f, 0.02717018f, 
    -0.12742876f, 0.08577554f, -0.13342038f, -0.11140459f, -0.05159291f, 0.05884309f, 0.10665705f, 0.07848223f, 
    0.05728924f, 0.11249229f, 0.09972917f, 0.06567273f, -0.21172109f, -0.35305932f, -0.08567940f, -0.11124944f, 
    -0.20704584f, 0.04338468f, -0.04755852f, 0.09437314f, 0.09610168f, 0.11580391f, 0.01433680f, -0.01445959f, 
    0.13080251f, 0.05535631f, -0.03268628f, 0.27516356f, 0.22190201f, 0.10031823f, -0.02680983f, -0.14871980f, 
    0.11633780f, 0.01917312f, -0.13446574f, -0.04702505f, 0.28232202f, 0.14186275f, 0.03791504f, 0.04442555f, 
    0.19203487f, 0.11684420f, 0.00735080f, -0.01079367f, -0.07459542f, -0.19634892f, -0.08020918f, -0.11461968f, 
    0.42468876f, 0.08263887f, 0.28567061f, 0.11702833f, -0.07272881f, -0.11199183f, 0.03367721f, 0.04164506f, 
    -0.07500470f, -0.00761650f, -0.09492309f, -0.02636094f, -0.78935343f, -0.50566030f, -0.11986173f, -0.19206618f, 
    -0.05673787f, 0.10805146f, -0.10155053f, -0.08152365f, -0.17039140f, 0.03741901f, 0.03893831f, 0.00103381f, 
    -0.25612965f, 0.03329533f, -0.03245794f, 0.24157800f, -0.16404743f, -0.04783738f, -0.15523331f, 0.14203639f, 
    -0.02826240f, 0.07013321f, -0.14749807f, -0.09093329f, -0.21904144f, -0.10642004f, -0.13441889f, 0.10126242f, 
    -0.25851673f, 0.02110157f, -0.01365916f, -0.03250831f, -0.07095834f, 0.02515074f, 0.09250978f, -0.07471605f, 
    0.15750735f, -0.07306881f, 0.16603650f, 0.08872993f, 0.19654532f, 0.22149922f, 0.06086262f, -0.07381543f, 
    -0.04525047f, -0.06266738f, 0.09564223f, -0.01170487f, 0.00174966f, 0.14495887f, -0.07341579f, -0.01635805f, 
    0.12298851f, 0.03967549f, 0.09212612f, -0.01617086f, 0.11256479f, 0.10790236f, 0.10714258f, -0.02454381f, 
    0.17884091f, 0.12837584f, -0.02765375f, 0.07329802f, 0.31087708f, 0.17345648f, 0.00004246f, -0.06951826f, 
    0.04252288f, -0.08601730f, 0.04985827f, -0.01623275f, 0.22704192f, 0.41296905f, 0.11765000f, 0.06698820f, 
    -0.06826023f, -0.00527879f, -0.02284375f, 0.01971925f, -0.04913484f, -0.07914847f, 0.09785400f, 0.00536909f, 
    0.20736037f, 0.08441460f, 0.12644537f, 0.06879450f, -0.05287739f, 0.01234051f, 0.03558285f, 0.13561019f, 
    -0.16241470f, -0.02910123f, -0.16580589f, 0.09878136f, -0.19719408f, -0.22452861f, -0.02769658f, -0.03263658f, 
    -0.06658623f, -0.06832963f, -0.11678264f, 0.10380925f, -0.10162450f, 0.03095076f, 0.00553550f, -0.04486791f, 
    -0.01341062f, -0.06188498f, 0.15985586f, 0.10294936f, -0.10808292f, 0.01637449f, -0.07793862f, -0.13579416f, 
    0.02479156f, 0.01372056f, -0.06124933f, -0.30697051f, -0.00520684f, 0.31498796f, 0.21363641f, -0.15340652f, 
    0.03852175f, 0.14016053f, 0.14235219f, -0.06152008f, 0.08548712f, 0.00740124f, -0.09009901f, -0.03828361f, 
    -0.01610676f, 0.40571630f, -0.08387754f, 0.02013081f, 0.33052269f, -0.00075814f, 0.25461718f, -0.05630113f, 
    -0.05354453f, -0.13009739f, 0.00472427f, -0.14378251f, -0.51387894f, -0.44363713f, -0.11693579f, 0.15303193f, 
    -0.07248072f, -0.01614753f, -0.02951254f, -0.08456065f, -0.07266891f, 0.03339945f, -0.04153294f, 0.06677869f, 
    0.26142982f, -0.07153875f, -0.01192199f, -0.04096528f, -0.10656547f, 0.14275543f, 0.15142915f, 0.03492367f, 
    -0.11366373f, 0.00141248f, -0.09983140f, 0.04287820f, -0.08921377f, -0.19209588f, -0.16792805f, -0.22932611f, 
    -0.25068495f, 0.06610726f, 0.10158715f, 0.06893872f, 0.04349680f, 0.23018986f, 0.04774015f, 0.06063958f, 
    -0.27749315f, 0.12031899f, 0.26745293f, -0.05749952f, 0.02118935f, 0.10259836f, 0.07882813f, 0.02667912f, 
    0.13002439f, 0.03403959f, -0.08742427f, 0.03293258f, 0.13604850f, 0.18653780f, 0.05265110f, -0.11697099f, 
    -0.10496097f, 0.04909399f, 0.11503193f, 0.03313975f, 0.11462224f, 0.10901983f, 0.14702557f, 0.05246237f, 
    0.05962496f, 0.01721836f, -0.05505100f, 0.02043672f, 0.02807203f, 0.04043868f, 0.06419549f, 0.04953692f, 
    0.02756030f, 0.02491097f, -0.07139339f, 0.06573662f, 0.29893091f, 0.37728617f, 0.09632689f, 0.13690794f, 
    0.08519758f, 0.02785573f, -0.00817871f, -0.01422865f, 0.02502923f, -0.02833931f, 0.02514422f, -0.00462844f, 
    0.09211104f, -0.12300908f, -0.08432492f, -0.04412055f, -0.12101837f, -0.15528440f, -0.05599687f, 0.01100454f, 
    -0.19922026f, 0.10245320f, -0.01147678f, -0.07491558f, 0.46866813f, -0.16466205f, -0.11704618f, 0.01947899f, 
    0.00008794f, 0.11535020f, -0.25288826f, 0.06362796f, -0.06468948f, 0.06922025f, 0.05269182f, 0.14232516f, 
    0.14071579f, -0.12783931f, -0.10585351f, 0.14133914f, -0.04102866f, -0.10925855f, 0.16887267f, -0.00865089f, 
    -0.00808238f, 0.03220972f, -0.05213722f, 0.03646113f, 0.17062515f, 0.11391749f, 0.20173283f, -0.20213850f, 
    0.14480886f, 0.19564027f, 0.21769239f, -0.06972201f, 0.08806679f, 0.09159892f, -0.02219932f, -0.02221636f, 
    0.11408897f, 0.12029488f, 0.31673038f, -0.26614797f, 0.04422926f, 0.05019061f, 0.16001633f, -0.03872456f, 
    0.09901806f, -0.03421215f, -0.03155132f, 0.11340010f, -0.28134620f, -0.16019294f, 0.08575627f, 0.08035100f, 
    0.02106101f, 0.04328835f, 0.22191440f, -0.02472128f, -0.08828559f, -0.02106171f, 0.15079318f, -0.00616660f, 
    -0.32854435f, -0.04921399f, -0.05365515f, -0.43301469f, 0.14852017f, -0.01880634f, -0.06068930f, 0.15183128f, 
    -0.06134329f, 0.01683532f, -0.18314157f, 0.02786661f, 0.02096756f, 0.02358377f, -0.25451940f, 0.15817097f, 
    -0.02997152f, 0.17736566f, 0.01843586f, 0.11958979f, 0.03827147f, 0.07175798f, 0.08149306f, 0.11789901f, 
    0.37785459f, -0.20522489f, -0.06364883f, 0.00320472f, -0.26838505f, 0.04462625f, 0.01669893f, 0.19371586f, 
    0.09604873f, 0.10474647f, -0.02910595f, 0.13452944f, 0.09403442f, -0.05918973f, 0.00785407f, -0.06712150f, 
    0.00100034f, -0.04700514f, 0.13800433f, 0.01738220f, 0.08492673f, 0.11510157f, 0.02135351f, -0.09602254f, 
    0.03213120f, -0.09223115f, -0.15266372f, 0.21266112f, 0.13410433f, -0.04702347f, -0.04323166f, 0.09580930f, 
    0.14649554f, 0.02127596f, -0.08343374f, 0.10513486f, 0.30347300f, 0.13946889f, 0.34057739f, 0.16707294f, 
    -0.05736369f, 0.07402772f, -0.01210156f, -0.03884629f, -0.03506391f, 0.05522439f, 0.09185753f, 0.01958942f, 
    0.13614933f, 0.30269390f, 0.04266916f, -0.12202225f, 0.06697715f, 0.09163005f, 0.06624265f, 0.09803310f, 
    0.04586775f, -0.03052857f, 0.13000056f, 0.04999811f, -0.18327901f, -0.22965065f, -0.12155626f, -0.15022087f, 
    0.05819907f, 0.05961145f, 0.00423707f, 0.08204824f, 0.00432261f, 0.14745294f, -0.00017991f, 0.11884628f, 
    -0.16656268f, -0.11382405f, -0.08295573f, 0.59402376f, 0.01947016f, -0.03899789f, 0.02966656f, 0.22932860f, 
    0.19753896f, 0.01818820f, -0.03620788f, -0.08242195f, 0.13281383f, 0.03380347f, -0.04897152f, -0.19878812f, 
    0.10220377f, 0.08502819f, 0.07280546f, 0.04202999f, -0.11767886f, -0.11860497f, -0.02907717f, 0.01301449f, 
    0.08764620f, 0.00138260f, -0.01863742f, 0.26600248f, 0.06661768f, 0.03579122f, -0.14321497f, -0.05619000f, 
    -0.00781173f, -0.07574487f, 0.02315676f, 0.03935910f, 0.47833812f, 0.13595232f, 0.00862982f, 0.18059634f, 
    0.02895251f, 0.01919067f, 0.06828016f, -0.08718675f, 0.01409995f, 0.06067227f, 0.05214364f, 0.00420231f, 
    0.05594312f, 0.14925404f, -0.21969172f, 0.16820309f, -0.17729533f, -0.00712769f, -0.10990284f, -0.18390904f, 
    0.04138508f, 0.03001568f, -0.01781082f, -0.13699713f, 0.06929313f, 0.24637963f, -0.00141503f, 0.18964021f, 
    0.04985636f, 0.03661954f, 0.17123666f, -0.15103938f, -0.13040632f, -0.06431203f, 0.02187168f, -0.05027175f, 
    0.19625984f, 0.06242842f, 0.11828541f, 0.32632187f, 0.04405215f, 0.03793427f, 0.01052818f, -0.10523105f, 
    0.01204811f, -0.04036895f, -0.03061921f, 0.09283989f, -0.40313229f, 0.08965960f, -0.05997993f, 0.11376732f, 
    -0.13890412f, 0.06882527f, 0.16719413f, -0.09696659f, 0.24699673f, -0.10667950f, -0.07258128f, 0.01727794f, 
    -0.33700311f, -0.12913898f, 0.17113459f, -0.25900474f, -0.00906262f, 0.05060073f, -0.11633575f, -0.16850102f, 
    -0.06907293f, -0.11903120f, -0.00793829f, -0.01246849f, -0.23124181f, -0.10287085f, 0.07491446f, -0.03329777f, 
    0.15513062f, -0.06837186f, -0.06356802f, 0.08851931f, 0.08613759f, 0.05449319f, 0.10222884f, 0.03014914f, 
    -0.14011720f, -0.04250723f, -0.04204105f, -0.25731620f, -0.14108352f, 0.06554192f, 0.21091594f, 0.01268319f, 
    0.03099047f, -0.01305055f, 0.06958979f, -0.12297707f, -0.43338433f, -0.10815065f, -0.00154896f, -0.08170535f, 
    0.03159811f, 0.14559233f, 0.21950735f, 0.00832089f, -0.11039363f, -0.02484927f, 0.02991764f, 0.04025573f, 
    0.16148074f, 0.19208707f, -0.02544700f, 0.12604736f, 0.03122523f, 0.04999635f, -0.06769499f, 0.00267180f, 
    0.03959435f, -0.00152627f, -0.13546965f, 0.00309464f, 0.24487972f, 0.10157343f, 0.16325070f, 0.09295218f, 
    0.10503186f, -0.11129905f, -0.08329407f, -0.02455613f, 0.00237047f, 0.13349894f, 0.08655654f, 0.01119957f, 
    -0.20560043f, 0.27688956f, 0.09600796f, -0.25498930f, 0.01191247f, 0.07921404f, 0.20369783f, -0.08356404f, 
    -0.11625291f, 0.08261629f, 0.11534639f, -0.06410933f, -0.17084470f, 0.13078898f, 0.05577101f, -0.29978949f, 
    0.09098063f, 0.04761431f, 0.06763459f, -0.00773074f, -0.09462652f, -0.12033527f, 0.11254083f, 0.03997332f, 
    -0.03669247f, -0.29035133f, 0.09809200f, 0.49444255f, 0.19634625f, 0.03406164f, -0.02979546f, -0.05639012f, 
    -0.00212503f, 0.03681814f, -0.02291845f, -0.09732133f, -0.18058975f, 0.07042461f, -0.03210028f, -0.11101817f, 
    -0.03044303f, -0.01770766f, 0.00455393f, -0.04768121f, 0.06815793f, -0.11087383f, 0.07693742f, 0.00783384f, 
    -0.07847753f, -0.11092579f, -0.00414633f, 0.37197036f, 0.04372802f, 0.02147486f, 0.11271172f, 0.09600979f, 
    -0.05200278f, -0.01149850f, 0.20974797f, -0.12176770f, -0.17439111f, 0.19715229f, 0.07342882f, 0.16602975f, 
    0.00006505f, 0.12072816f, 0.01302941f, -0.02780363f, -0.06987801f, 0.12700747f, 0.10790786f, -0.07568974f, 
    0.21873194f, 0.09001209f, -0.18046837f, 0.04920617f, 0.05497330f, 0.12727888f, 0.16029392f, 0.05984874f, 
    -0.12549864f, 0.18329284f, -0.11789109f, -0.06971544f, -0.09087291f, 0.10215092f, -0.27953678f, -0.20695972f, 
    0.17003863f, -0.02247049f, -0.09545362f, -0.10241241f, -0.01135322f, 0.07096520f, -0.03630350f, -0.09815561f, 
    -0.08356338f, 0.00482761f, -0.00100212f, 0.05528526f, 0.14265364f, -0.01677010f, 0.19229662f, 0.01840017f, 
    -0.04511373f, 0.06468514f, -0.03538003f, 0.05604869f, -0.21564515f, -0.04695356f, -0.10712919f, 0.19675434f, 
    0.00311370f, 0.04420639f, 0.18593256f, 0.05694974f, -0.12677269f, -0.04084949f, -0.13760944f, -0.04786969f, 
    0.08085697f, -0.06143361f, -0.05783236f, -0.29292706f, 0.16271856f, 0.02878275f, 0.05704025f, -0.07435217f, 
    0.07768802f, -0.01051925f, 0.02667912f, 0.06383514f, 0.43878245f, -0.12265270f, -0.06642237f, 0.07699130f, 
    -0.06417077f, 0.01041459f, 0.14917400f, 0.09703287f, -0.10397667f, -0.09392442f, 0.06484427f, 0.04054333f, 
    -0.19272479f, 0.03495522f, -0.04696203f, -0.00618274f, -0.05692827f, -0.09935493f, 0.02238557f, 0.05200410f, 
    0.01872272f, 0.05104296f, 0.09156001f, 0.22195584f, -0.36302987f, 0.14658187f, 0.09596100f, 0.04313442f, 
    0.09131493f, 0.09528566f, 0.03023113f, 0.06567135f, 0.05133992f, -0.02355660f, 0.00811549f, -0.03366571f, 
    0.18022969f, 0.18209054f, 0.06667507f, 0.31378740f, 0.08858353f, 0.00093755f, -0.10554409f, -0.02524225f, 
    0.06419355f, -0.09253795f, -0.02753530f, -0.17628163f, 0.17494570f, 0.27050388f, 0.29184926f, 0.18329564f, 
    -0.03618911f, -0.07031680f, -0.27493417f, 0.27347067f, -0.05302163f, -0.12230221f, -0.05863127f, -0.04483129f, 
    0.18352650f, -0.06413172f, -0.02992772f, -0.12433428f, -0.26061246f, -0.15424880f, 0.00559460f, -0.04415638f, 
    -0.11069448f, 0.17676055f, -0.02525714f, -0.00578087f, -0.32163224f, -0.36266601f, -0.32530716f, -0.21656138f, 
    0.12452459f, -0.03203238f, 0.00935861f, -0.01256935f, 0.18140779f, -0.06896579f, 0.16878487f, 0.10469667f, 
    0.10919879f, 0.15263511f, -0.01011271f, 0.12961423f, -0.04107359f, 0.00873734f, -0.13215926f, -0.14713830f, 
    -0.04941939f, 0.09403054f, -0.03897461f, -0.12351184f, -0.27155441f, -0.25483197f, -0.14907308f, -0.17680004f, 
    0.09928835f, -0.07704949f, -0.04486220f, -0.12429475f, -0.08808264f, -0.13881071f, -0.10555021f, -0.02335038f, 
    0.18061382f, 0.06840463f, 0.19254628f, 0.30438900f, 0.23506504f, 0.07293959f, 0.28969258f, 0.09060276f, 
    0.05125798f, -0.03316880f, 0.03427036f, 0.16798110f, -0.14576098f, 0.22433335f, 0.21228807f, 0.20994148f, 
    0.35758129f, -0.06641675f, 0.19538982f, -0.02140918f, 0.01090616f, -0.07445090f, 0.06529628f, -0.16338386f, 
    0.18722014f, 0.27909222f, 0.15834202f, 0.29849103f, 0.11588027f, 0.19461893f, 0.12600474f, 0.17784207f, 
    -0.14273232f, -0.12245463f, 0.01053967f, -0.04950791f, -0.02122729f, 0.31443232f, -0.17098238f, -0.06456320f, 
    -0.06804546f, -0.11196937f, -0.20006703f, -0.08291139f, -0.03282689f, -0.09416183f, -0.00307283f, -0.15068389f, 
    0.07940195f, -0.22558877f, -0.14551736f, 0.08600426f, -0.06538584f, -0.01412538f, 0.06272753f, 0.16390048f, 
    -0.10538996f, -0.02406520f, -0.13744991f, 0.01325565f, 0.26034722f, 0.01262375f, 0.05423957f, 0.08857933f, 
    -0.02502502f, 0.04308769f, -0.15825102f, -0.04364647f, -0.00952994f, -0.02085289f, -0.10453108f, 0.13105714f, 
    0.21864261f, -0.18460724f, 0.18666247f, 0.03522226f, 0.01231796f, 0.00194267f, -0.02407150f, -0.03804682f, 
    0.10976457f, -0.03218608f, 0.04836300f, 0.11618381f, -0.09186072f, 0.10982092f, 0.06792976f, -0.15065594f, 
    -0.12624198f, 0.01451687f, 0.01725390f, 0.09146141f, -0.12578489f, 0.01911957f, -0.17057885f, 0.13087520f, 
    -0.13191481f, 0.31290245f, 0.15614769f, 0.18187886f, 0.07660001f, -0.02085268f, -0.01264051f, -0.09048739f, 
    -0.01100372f, -0.00181886f, 0.09397489f, -0.10805491f, -0.00609134f, -0.02538669f, 0.00154782f, 0.02845681f, 
    0.03564180f, -0.01337859f, -0.01165157f, -0.04964090f, 0.04326962f, -0.16125773f, -0.03900630f, 0.04687171f, 
    0.11207972f, 0.19630884f, 0.08050743f, 0.14656103f, 0.05099308f, -0.03212274f, 0.09716704f, -0.08228330f, 
    0.04080718f, -0.01988551f, -0.08375061f, -0.02782508f, 0.16484755f, -0.30888760f, -0.05594580f, -0.07581631f, 
    -0.06911618f, 0.10618319f, 0.03558415f, -0.07408059f, 0.01406885f, 0.13581020f, -0.05495787f, 0.09940168f, 
    -0.26122940f, 0.16584484f, 0.16716698f, -0.05622015f, 0.00364045f, 0.03653929f, -0.10075880f, 0.10927525f, 
    0.07672527f, -0.12437022f, 0.10209733f, 0.06385437f, 0.38793352f, 0.23211654f, -0.03462170f, -0.05361591f, 
    -0.04543243f, -0.10271998f, 0.00975272f, 0.05453979f, 0.05883733f, 0.09331516f, -0.02670702f, 0.01394873f, 
    0.21333133f, -0.03836629f, -0.27995348f, 0.24180199f, -0.11618598f, 0.02445199f, -0.04586538f, 0.11437379f, 
    0.06726944f, 0.01257326f, -0.01671123f, -0.01302300f, 0.40079197f, 0.18990958f, 0.02898694f, 0.08155341f, 
    -0.14881669f, -0.07744738f, 0.06964011f, -0.00988304f, 0.02115686f, -0.12291646f, -0.03990662f, -0.10684011f, 
    0.20735550f, 0.24112505f, 0.02224752f, 0.19921796f, -0.10294098f, -0.02296327f, 0.02824019f, -0.04229232f, 
    -0.09701154f, 0.21518862f, 0.21219644f, -0.18546800f, 0.20523763f, -0.14130944f, -0.13148025f, 0.10486839f, 
    0.06989989f, 0.19586051f, -0.16568744f, 0.02729117f, -0.14798395f, -0.02226789f, -0.10902996f, 0.02947742f, 
    0.10553203f, 0.13617916f, -0.04953508f, 0.17832059f, -0.00455982f, 0.09070949f, 0.04262709f, -0.13511610f, 
    -0.00734668f, -0.02982313f, -0.16595201f, -0.17294168f, 0.12386426f, -0.02567854f, -0.16843094f, 0.04639787f, 
    0.00154468f, -0.02456265f, 0.15358539f, 0.00442287f, 0.11635079f, 0.03747271f, -0.07117827f, 0.01556778f, 
    0.15898897f, 0.08076478f, -0.11120875f, -0.15755641f, 0.03835128f, 0.01123706f, 0.00328995f, -0.05271295f, 
    0.11435293f, -0.17134207f, 0.07044124f, 0.01394271f, -0.27890202f, -0.35759562f, -0.20464258f, 0.17950465f, 
    -0.14535071f, 0.01402479f, 0.18888108f, -0.20456636f, -0.03123217f, -0.03579697f, 0.06642889f, -0.12627006f, 
    0.02671476f, 0.08637053f, 0.10030308f, -0.34156209f, -0.05259779f, -0.01535528f, -0.04493944f, 0.07827995f, 
    0.01706376f, 0.00233663f, 0.02628586f, -0.07174718f, -0.36960596f, 0.04319836f, 0.09528909f, 0.04923223f, 
    0.00406982f, -0.05003441f, 0.04074353f, -0.05426843f, 0.02311016f, 0.04370148f, 0.17235544f, 0.06933055f, 
    0.19013338f, -0.34779111f, 0.04471067f, 0.07684918f, 0.06563757f, 0.19498271f, 0.03923203f, 0.09231675f, 
    0.00493545f, 0.06434248f, 0.08015145f, 0.15168773f, 0.01644143f, 0.26775333f, -0.11402699f, -0.04100638f, 
    -0.06542849f, -0.20668115f, 0.02552187f, 0.09622216f, -0.00009077f, 0.14113373f, -0.08367243f, -0.18790907f, 
    -0.17973815f, 0.05595932f, 0.05775034f, -0.04058395f, 0.04428339f, -0.06791107f, -0.07923727f, 0.00445260f, 
    0.03727230f, -0.02051288f, 0.07348988f, -0.06693403f, -0.12032339f, 0.17060612f, -0.06963407f, 0.23897757f, 
    -0.02717509f, 0.13595214f, -0.04742663f, 0.13332118f, 0.03605036f, 0.00722944f, -0.10861327f, -0.07909718f, 
    0.16882771f, 0.14096925f, -0.12378658f, -0.05711311f, 0.00007317f, -0.08739128f, 0.12316280f, 0.08884788f, 
    -0.14893445f, 0.02398973f, 0.04394748f, 0.01120340f, 0.26560596f, 0.02278998f, 0.07800320f, 0.07267201f, 
    -0.01611984f, 0.07177324f, 0.09511691f, -0.06682294f, -0.04103656f, -0.05201976f, 0.04811526f, -0.13746312f, 
    0.13892652f, 0.27790231f, -0.32110181f, 0.01002900f, 0.02237935f, -0.05718732f, 0.02877195f, 0.04495102f, 
    0.01305181f, 0.12485088f, -0.05452155f, 0.05467109f, 0.30814406f, -0.05607285f, -0.03970800f, 0.20609927f, 
    0.07297038f, 0.01850903f, 0.02527227f, -0.06278421f, -0.12474735f, -0.01144180f, 0.02316840f, 0.22799477f, 
    -0.19393711f, 0.09939453f, -0.12378223f, 0.08293580f, 0.17725584f, 0.09414151f, 0.06758743f, 0.03556145f, 
    0.10773261f, -0.02949328f, 0.00629981f, 0.00516452f, -0.17470774f, 0.07435466f, 0.04630962f, 0.06315283f, 
    -0.03464921f, -0.04506759f, -0.02344735f, -0.04239545f, -0.12711734f, 0.02521547f, -0.15445916f, -0.06675950f, 
    -0.00517138f, 0.07002514f, -0.08020215f, 0.06972204f, -0.01538631f, 0.10774804f, -0.02143103f, -0.03471510f, 
    -0.02769271f, -0.12608181f, 0.15287334f, -0.02983645f, 0.03889851f, 0.05819306f, -0.12912396f, -0.15937787f, 
    0.05715063f, 0.01439481f, -0.04506179f, 0.05736330f, -0.00128754f, -0.10060731f, 0.05539869f, 0.00973005f, 
    0.05944533f, 0.09029872f, -0.21004510f, 0.23032051f, 0.05435134f, 0.10156429f, -0.07710661f, 0.00128365f, 
    -0.03149745f, 0.01094832f, 0.01295051f, 0.03474044f, 0.14048633f, 0.08440597f, 0.07505062f, -0.02246960f, 
    -0.03746661f, -0.12399027f, -0.23857157f, -0.09256782f, 0.02447403f, -0.09968083f, 0.01499677f, -0.01215392f, 
    -0.16957527f, -0.14896832f, 0.28551695f, 0.22580378f, 0.01084271f, -0.07984691f, -0.07117362f, 0.00184100f, 
    0.13264239f, -0.05878049f, 0.01765203f, 0.04815285f, -0.06750467f, -0.03349341f, 0.03281379f, -0.13952327f, 
    0.15402868f, 0.13043132f, -0.00279644f, 0.07694007f, 0.10078816f, -0.06488522f, 0.01120341f, -0.05206968f, 
    -0.00236430f, 0.16684628f, -0.00848634f, -0.04175103f, 0.05515544f, 0.04712611f, 0.00077900f, -0.07664073f, 
    -0.03333411f, 0.06316552f, -0.02321082f, -0.24565430f, 0.16350265f, 0.26502517f, 0.10304380f, -0.01190858f, 
    0.03798934f, -0.03633558f, 0.06160761f, 0.03515272f, -0.10358980f, -0.12283161f, 0.02526340f, 0.13898809f, 
    0.15453629f, 0.09672676f, 0.10449525f, -0.23087497f, -0.07354318f, -0.07618656f, 0.14053318f, -0.04926790f, 
    0.01021030f, 0.18227790f, 0.00889180f, -0.04250828f, -0.34221947f, 0.12119099f, -0.25427249f, 0.02556874f, 
    0.04008638f, -0.05618163f, -0.07432016f, 0.02991380f, -0.04104054f, -0.11650129f, -0.11536814f, 0.03753168f, 
    -0.06165909f, -0.06374551f, -0.08307820f, 0.21422024f, 0.04227370f, -0.00781023f, 0.06870223f, -0.02286896f, 
    -0.05894610f, 0.00897176f, 0.00966338f, -0.05114590f, 0.33186331f, 0.19547582f, 0.23928158f, 0.16730614f, 
    0.03854485f, 0.03846635f, 0.09088531f, -0.04375795f, -0.00210880f, -0.14530337f, 0.04761819f, 0.01539487f, 
    0.21894811f, 0.17675613f, 0.08704416f, -0.47687146f, 0.00575131f, -0.05668904f, 0.06505210f, -0.08808251f, 
    -0.14093708f, 0.01141496f, 0.04413864f, 0.14168765f, -0.00353934f, -0.01719593f, 0.06060079f, 0.21224955f, 
    0.01621750f, -0.04261683f, -0.00100336f, 0.00903767f, 0.02921044f, 0.10714809f, 0.08965086f, 0.19698445f, 
    0.08266515f, 0.19498022f, -0.05909003f, -0.28285939f, -0.12615076f, -0.01438114f, 0.15080720f, 0.04426569f, 
    0.13847300f, 0.00282757f, -0.15305302f, 0.03311649f, -0.54784864f, 0.02107973f, 0.10460114f, -0.11647820f, 
    -0.08992223f, -0.13356811f, 0.01418664f, 0.10676366f, 0.07045918f, 0.10845085f, -0.00682432f, 0.00850049f, 
    -0.01117381f, 0.13089199f, 0.10127140f, -0.19938421f, 0.09007910f, -0.01818946f, 0.13317338f, 0.14988008f, 
    0.05548719f, -0.12237770f, 0.08112134f, -0.09137375f, -0.26429555f, -0.35630527f, -0.27327144f, -0.18056048f, 
    0.00487081f, -0.14495088f, -0.19147530f, 0.18136960f, 0.05381727f, 0.07268111f, 0.04938292f, 0.18251137f, 
    -0.17668559f, -0.08709805f, -0.32385293f, -0.19465037f, 0.00224666f, -0.05828799f, -0.03814600f, -0.06727618f, 
    -0.13480069f, 0.04186931f, -0.10791013f, 0.11170233f, 0.51628238f, 0.03179199f, 0.18899401f, -0.03581521f, 
    0.12259731f, -0.10872199f, -0.19426265f, -0.06367123f, 0.01939371f, 0.09492784f, 0.08936545f, 0.02347777f, 
    0.05327023f, 0.16492191f, 0.00498702f, 0.26339099f, -0.01612368f, -0.03495599f, 0.06257758f, 0.02902088f, 
    0.06750597f, 0.12850037f, 0.24134555f, 0.02958788f, 0.03173188f, 0.19917384f, 0.09402564f, -0.10344571f, 
    -0.02403320f, -0.03964653f, 0.02234207f, -0.08409259f, 0.08267992f, 0.00074234f, -0.02374516f, -0.06326701f, 
    0.02910866f, 0.20880032f, 0.10894369f, 0.11348254f, 0.10892076f, -0.16162369f, -0.19703163f, -0.06011793f, 
    0.02660301f, -0.06240477f, -0.10726603f, -0.14455500f, 0.38361177f, 0.22146416f, 0.20998821f, 0.29435170f, 
    0.06408145f, 0.04903900f, 0.01203598f, 0.01719214f, -0.02115826f, 0.02184170f, -0.02863576f, 0.09185387f, 
    -0.19609053f, -0.11872766f, 0.08074644f, 0.00003485f, 0.07796116f, 0.05495529f, 0.02416541f, 0.07235613f, 
    -0.00983148f, 0.05297623f, 0.00570121f, -0.02169483f, -0.18657163f, -0.12813903f, -0.18205163f, -0.18443134f, 
    -0.00640759f, 0.03952597f, -0.06181231f, 0.16837636f, -0.14404389f, 0.02412369f, 0.15578315f, 0.03815414f, 
    -0.09724654f, 0.24074861f, 0.09652480f, -0.14607882f, -0.03223014f, -0.08291622f, 0.18509887f, 0.06115389f, 
    -0.13990805f, -0.09092833f, -0.03939286f, -0.02317323f, 0.17313488f, 0.26090437f, 0.28539777f, 0.05359937f, 
    -0.05475473f, 0.06857852f, 0.07974723f, -0.02173785f, 0.03151753f, 0.06605272f, 0.09871260f, 0.01362183f, 
    0.32903165f, 0.06725182f, 0.05398958f, -0.04653632f, 0.07761215f, 0.03166876f, 0.08497166f, -0.06845663f, 
    0.02900435f, -0.00280051f, 0.04658104f, 0.00197350f, 0.30897751f, 0.18865389f, 0.21400692f, -0.01215066f, 
    -0.02677632f, 0.02607910f, -0.03526547f, -0.01312114f, -0.11176962f, 0.01221522f, 0.11278915f, 0.00453396f, 
    -0.16726391f, -0.17099141f, -0.14038116f, 0.14778343f, 0.11927117f, -0.08484233f, 0.06004089f, 0.19117706f, 
    -0.03796706f, -0.00054576f, 0.06414236f, 0.00714854f, -0.16284095f, -0.33264458f, 0.03733410f, 0.05495968f, 
    0.05759353f, 0.03609817f, -0.01910276f, -0.01231513f, 0.00445811f, -0.06215280f, -0.08780793f, -0.01819323f, 
    -0.00709025f, -0.24971363f, 0.01611328f, 0.06672852f, 0.11246055f, 0.03724054f, 0.06614564f, 0.10683114f, 
    0.11193787f, 0.08450937f, 0.06077972f, 0.05542683f, -0.18802708f, 0.14103852f, -0.05757304f, -0.38773760f, 
    0.04813415f, 0.05585958f, -0.01552373f, -0.04327533f, 0.05333458f, -0.00164033f, 0.15234995f, 0.06466828f, 
    0.23163156f, -0.12564793f, 0.13080265f, -0.03632857f, -0.09835154f, 0.11601922f, 0.13092233f, 0.07461431f, 
    -0.00885512f, 0.11959936f, 0.08272677f, -0.02166986f, 0.13607113f, 0.19588512f, 0.21401399f, 0.12902589f, 
    0.19247967f, -0.02356194f, -0.01949228f, 0.02454967f, -0.13928135f, -0.04381174f, 0.08819833f, 0.01630883f, 
    -0.02790557f, 0.16180962f, -0.12393275f, 0.01107570f, 0.13999188f, -0.05910899f, 0.02402249f, 0.10930143f, 
    0.01764051f, 0.01287451f, -0.28218776f, 0.15261246f, 0.10493416f, -0.08645064f, -0.19606179f, -0.12230095f, 
    0.01989220f, 0.05043475f, 0.00046821f, 0.05296431f, 0.02662229f, 0.02097323f, 0.08225798f, 0.06443225f, 
    0.01239167f, -0.03322794f, 0.04813911f, -0.00058481f, 0.09311893f, 0.06338400f, -0.10418683f, -0.00460048f, 
    0.00222189f, 0.04749002f, -0.03129437f, 0.07740659f, 0.46023026f, 0.25266689f, 0.09386398f, 0.01774098f, 
    -0.02086094f, 0.02129192f, 0.09487053f, -0.01358996f, 0.09310061f, -0.08776799f, -0.00569574f, 0.00033865f, 
    -0.00585321f, 0.02042434f, 0.04905537f, 0.03727021f, -0.01207173f, 0.03136505f, -0.00736590f, -0.04352452f, 
    0.02492707f, 0.01353034f, 0.05634957f, -0.05461258f, 0.03393468f, -0.03887313f, -0.04963088f, -0.02275420f, 
    0.01022282f, -0.07503219f, -0.00929091f, -0.03581434f, -0.00173580f, 0.02135093f, -0.04456544f, 0.04593340f, 
    -0.07585875f, -0.04731358f, -0.01861750f, -0.06459344f, 0.01209136f, -0.01835825f, -0.00127992f, -0.01674323f, 
    0.01229649f, 0.05486710f, 0.03550534f, 0.05865097f, -0.00360965f, 0.06033245f, -0.07271162f, -0.07533566f, 
    -0.07788721f, -0.02747026f, -0.02107256f, -0.01635453f, 0.02310565f, -0.01917550f, -0.01480362f, 0.00479870f, 
    -0.04894932f, -0.06509189f, 0.00603062f, 0.01512968f, -0.00645077f, 0.02868872f, 0.06217160f, -0.06472680f, 
    0.03969561f, -0.01327728f, 0.00187757f, 0.05552078f, -0.00848126f, -0.03204815f, -0.04078044f, 0.01359607f, 
    0.04998916f, 0.05339402f, -0.00696188f, 0.04319990f, -0.03708445f, 0.01563334f, -0.06086040f, -0.03026667f, 
    -0.00722763f, -0.00760602f, -0.05154775f, -0.01572874f, 0.04914924f, -0.05276718f, 0.01588943f, 0.01039875f, 
    -0.00842996f, -0.03963093f, -0.05130198f, -0.02004456f, -0.07581577f, 0.04777891f, -0.02664221f, -0.04284663f, 
    0.03754793f, -0.03691537f, -0.01490660f, -0.05824284f, -0.05605968f, 0.05106575f, -0.01621771f, -0.04263957f, 
    0.04251997f, 0.05749295f, -0.05487792f, -0.03833611f, 0.06661869f, -0.02470672f, -0.00180035f, -0.02666256f, 
    -0.07322157f, -0.06642769f, -0.00177387f, -0.08111747f, -0.04523070f, 0.02887661f, 0.01304142f, -0.02284422f, 
    -0.03924054f, -0.05877933f, -0.03165594f, -0.00081469f, 0.03326453f, -0.06045639f, 0.03769691f, -0.05791732f, 
    -0.01349535f, -0.01689048f, 0.01513291f, 0.06115654f, -0.04580068f, -0.02879299f, 0.00610699f, 0.04369794f, 
    -0.02190746f, 0.04136859f, -0.05820409f, -0.04576994f, 0.05309160f, -0.01608935f, 0.05510965f, -0.05105450f, 
    0.02289371f, 0.01548017f, 0.00342244f, -0.02732439f, -0.04023130f, -0.00037904f, -0.00515711f, -0.01008643f, 
    0.04637646f, 0.04711622f, -0.02776341f, 0.00979607f, -0.05361232f, 0.00637735f, 0.00244943f, 0.02800655f, 
    -0.07815109f, -0.00007177f, 0.04168389f, -0.06884415f, -0.02467998f, 0.04285014f, 0.01267992f, 0.01989440f, 
    0.03270731f, 0.02124659f, 0.02642278f, 0.05500645f, -0.03671129f, -0.04726289f, 0.01056388f, -0.03787213f, 
    0.00150999f, -0.03555491f, 0.04846466f, 0.04553315f, -0.01675933f, 0.02613094f, 0.01938562f, -0.02914682f, 
    0.00067620f, -0.00188093f, -0.05726277f, -0.03160438f, -0.05970796f, -0.04978617f, 0.01482835f, -0.07758392f, 
    -0.05229893f, 0.01947453f, -0.04995135f, 0.01004804f, -0.07828367f, 0.05799026f, -0.08460856f, -0.01797215f, 
    -0.01031717f, 0.00727245f, 0.13711795f, 0.06279482f, 0.14572039f, -0.10716158f, 0.18228655f, -0.07297600f, 
    -0.06862399f, 0.11132592f, 0.08986708f, -0.08718439f, -0.09998659f, 0.09929603f, -0.21008281f, 0.08905364f, 
    0.07475147f, 0.23576143f, 0.01281194f, 0.01749476f, -0.03601121f, -0.09080737f, -0.11331303f, -0.22276118f, 
    -0.13948539f, -0.08667443f, 0.03835677f, 0.36753869f, -0.15810469f, -0.11366825f, -0.14298527f, 0.00778379f, 
    -0.10283175f, -0.01906372f, 0.01902869f, 0.08302204f, 0.20065546f, 0.13315772f, 0.15395981f, 0.20548834f, 
    -0.09143318f, 0.02940737f, -0.06215599f, 0.07976164f, -0.03305181f, 0.07963675f, -0.02056789f, -0.01141687f, 
    -0.33774120f, 0.17004956f, -0.08757344f, -0.40385747f, -0.09087858f, 0.03147356f, 0.19956157f, -0.01002747f, 
    -0.12999302f, -0.09876719f, 0.08729914f, -0.02901199f, 0.13572915f, -0.00237540f, 0.08473951f, 0.01345086f, 
    -0.20976773f, 0.03325714f, 0.19428407f, 0.05822723f, -0.04699795f, 0.01548404f, -0.05153167f, 0.22607270f, 
    0.46686745f, 0.27647188f, 0.09375788f, 0.01322217f, 0.15151374f, -0.04537985f, 0.04472476f, -0.00276405f, 
    0.17126653f, 0.00728657f, -0.10407375f, 0.00696652f, 0.04527986f, 0.01543427f, 0.05168743f, -0.28678924f, 
    0.03373570f, 0.09435702f, -0.05402413f, -0.06191248f, 0.04888299f, -0.00244980f, -0.11146800f, 0.03578011f, 
    -0.16038390f, 0.04535726f, 0.21463549f, 0.09168585f, 0.18339224f, 0.05487546f, 0.02454113f, 0.11695813f, 
    -0.05466763f, -0.12732635f, 0.17607461f, 0.09554368f, 0.12416175f, -0.19004291f, 0.19065823f, 0.10937031f, 
    -0.09782312f, -0.05621417f, 0.00070685f, 0.01784370f, 0.00282458f, -0.10407011f, 0.12714221f, 0.12896833f, 
    -0.21271445f, 0.01563368f, -0.00139268f, 0.00557831f, -0.17647061f, 0.05897571f, -0.10643087f, -0.09638517f, 
    0.00282192f, -0.16636302f, 0.08357511f, -0.07614392f, 0.40590870f, 0.05438300f, 0.10735070f, -0.21530594f, 
    0.09966473f, -0.09929533f, -0.15668514f, -0.21330224f, 0.00505223f, 0.00891627f, 0.11969871f, 0.01203748f, 
    -0.10484003f, 0.20849119f, 0.11527321f, 0.16295277f, -0.12185068f, -0.00142827f, -0.12075515f, 0.06179001f, 
    0.11877976f, 0.04472881f, -0.06145373f, -0.10201487f, -0.08495742f, 0.21150175f, 0.12400968f, -0.29178518f, 
    0.10153731f, 0.07603046f, -0.04150100f, -0.01216776f, 0.16215512f, -0.02069308f, 0.05124419f, -0.18146501f, 
    0.25310376f, 0.31475264f, 0.07924404f, 0.19944713f, 0.16618578f, 0.16423942f, -0.01525757f, 0.05481454f, 
    -0.05094463f, 0.10019412f, -0.19468027f, -0.10449028f, 0.43284032f, 0.05862041f, 0.10100122f, -0.10656215f, 
    -0.30318430f, -0.08928937f, 0.01365426f, -0.00643862f, -0.04879247f, -0.00959286f, 0.04168245f, -0.00892503f, 
    0.13482936f, 0.01107651f, -0.00462378f, 0.20310348f, -0.14334871f, 0.03419334f, 0.09959885f, 0.06454469f, 
    0.04322931f, -0.10256469f, -0.19457939f, -0.07715001f, 0.21054006f, -0.06757260f, 0.18310240f, -0.32458487f, 
    0.04538160f, -0.01366268f, -0.12580119f, 0.13005589f, 0.06402364f, -0.03525070f, 0.08199524f, 0.21812047f, 
    0.10280165f, -0.20269188f, -0.00314875f, 0.10898056f, -0.14347738f, 0.13069141f, -0.02399290f, -0.12323414f, 
    0.10733458f, 0.10617132f, 0.07582247f, -0.09079429f, -0.25903970f, 0.12287189f, -0.13416940f, -0.16099359f, 
    0.09077361f, -0.00174817f, -0.24472390f, -0.14072248f, 0.14725497f, 0.00760431f, -0.00900850f, 0.31548077f, 
    0.16025142f, -0.34894091f, 0.19765389f, -0.16121295f, -0.17176133f, 0.09157483f, -0.12627970f, -0.01206002f, 
    0.06634118f, 0.08756549f, -0.05717759f, -0.22826955f, -0.39774475f, -0.22059232f, 0.18611561f, 0.14542618f, 
    0.00380177f, -0.05564961f, -0.06121312f, -0.16325058f, 0.07997704f, -0.00851733f, 0.12803918f, -0.27296874f, 
    -0.17037851f, 0.12467594f, 0.21261562f, 0.12013044f, -0.02262558f, -0.06681128f, 0.06023367f, 0.11373206f, 
    -0.09576787f, -0.15009537f, 0.02448586f, 0.12889475f, 0.00337761f, 0.33517629f, 0.12369861f, 0.00169036f, 
    0.26685598f, -0.11728892f, 0.14436211f, 0.07940344f, -0.12508035f, -0.23316082f, -0.04438779f, -0.05743383f, 
    -0.14971524f, -0.11648621f, 0.32620993f, 0.20183347f, 0.02177372f, -0.11464587f, -0.03483747f, 0.15204409f, 
    -0.05961950f, 0.08219833f, -0.37717623f, -0.00662722f, -0.11011243f, 0.07327447f, 0.14865626f, 0.24950361f, 
    0.03291878f, -0.02656416f, 0.09973827f, 0.03611668f, 0.12740277f, 0.03142937f, -0.00918191f, 0.04900573f, 
    0.10994512f, -0.17244761f, 0.02616222f, 0.03313916f, -0.09327048f, -0.02895475f, 0.15104432f, 0.05086448f, 
    0.11687749f, 0.15107869f, 0.10517385f, 0.13697833f, -0.33133540f, 0.02785424f, -0.14326692f, -0.05679881f, 
    0.02563745f, 0.06753526f, 0.06171563f, 0.10663369f, 0.04776008f, -0.03236304f, 0.06595261f, -0.01631167f, 
    0.28907713f, 0.21097618f, -0.04611657f, -0.12430320f, 0.21562964f, -0.00057832f, -0.01471268f, -0.07410903f, 
    -0.04429865f, 0.01279161f, 0.07345174f, 0.08704025f, -0.49611917f, 0.13825598f, 0.29839605f, 0.06624348f, 
    0.01025870f, -0.13504918f, 0.12133367f, 0.06100924f, -0.03087857f, -0.01182530f, -0.11809742f, 0.21260713f, 
    -0.25238246f, -0.19301800f, -0.07936192f, 0.09607320f, 0.05782362f, 0.03260743f, 0.10037333f, 0.17874251f, 
    0.10232237f, 0.13294955f, 0.27246624f, 0.26822394f, 0.11668635f, -0.21186878f, -0.16458300f, 0.05058117f, 
    -0.19057867f, -0.07083897f, -0.04342026f, -0.02503837f, 0.08689164f, 0.06605299f, -0.15003537f, -0.06961273f, 
    0.02257532f, -0.02890203f, -0.04707929f, -0.04348176f, -0.07932454f, -0.04215737f, -0.05300262f, 0.03954729f, 
    0.02576676f, -0.03787906f, -0.05576142f, 0.00344758f, -0.01883484f, -0.00574579f, 0.01702613f, 0.06459212f, 
    -0.02181855f, -0.00355477f, -0.07528038f, 0.00085967f, -0.05975293f, -0.01528889f, -0.06878628f, -0.00663271f, 
    -0.03241480f, -0.02798094f, 0.01701837f, -0.08625121f, -0.01652045f, -0.05703590f, -0.08236047f, -0.02073208f, 
    0.04665627f, -0.05830865f, 0.02437211f, 0.00562256f, -0.08313449f, 0.03191454f, -0.04436699f, -0.01526211f, 
    0.01459553f, -0.04856388f, -0.08191036f, -0.02658188f, 0.02041354f, 0.00160241f, 0.04926044f, -0.08685231f, 
    0.02608466f, 0.02286162f, -0.04858623f, -0.03751966f, 0.03945412f, 0.01131611f, -0.01351750f, 0.04667558f, 
    -0.01249018f, -0.03063609f, 0.01950154f, 0.05237629f, 0.01607908f, -0.05454893f, -0.01103599f, 0.04955193f, 
    -0.02102428f, 0.01046412f, -0.06998076f, 0.04872982f, -0.05374476f, -0.08019813f, 0.01843529f, -0.00465860f, 
    0.03269496f, -0.07031943f, -0.07546261f, -0.07755591f, -0.02511368f, 0.01314043f, -0.05704224f, 0.00511929f, 
    -0.00208642f, -0.00939980f, -0.03760386f, -0.02993422f, -0.02736859f, -0.07697801f, -0.06511993f, -0.05769615f, 
    -0.06180951f, -0.04345608f, -0.04690037f, -0.06908447f, -0.04423061f, -0.04927156f, 0.02008666f, 0.00305738f, 
    -0.01787496f, -0.03390118f, -0.03052382f, 0.00409238f, -0.06665191f, -0.01868977f, -0.04592114f, 0.02049776f, 
    0.01257671f, -0.01325746f, -0.04204831f, 0.00627732f, -0.06352353f, -0.07365473f, -0.06601682f, -0.03593703f, 
    0.03113290f, -0.04981954f, 0.04353209f, -0.01464437f, -0.01599855f, -0.08445102f, -0.05885096f, -0.08060537f, 
    0.04049901f, -0.01986164f, 0.00325013f, 0.00717273f, -0.08519964f, 0.01157442f, -0.08399586f, -0.03321743f, 
    -0.08106565f, -0.04098295f, -0.05253438f, 0.05636287f, -0.07080355f, -0.04857137f, -0.01050971f, -0.01410046f, 
    -0.06272251f, 0.05419489f, -0.02456817f, 0.04836987f, -0.04707151f, 0.05103812f, -0.05631415f, -0.07001273f, 
    0.01182946f, -0.01421136f, -0.07109998f, -0.03216311f, -0.02284024f, -0.00668690f, 0.03444587f, 0.01124185f, 
    -0.05221931f, 0.00999586f, 0.02331157f, 0.01879797f, -0.06002359f, -0.05260616f, 0.02815523f, -0.05340285f, 
    -0.07090919f, -0.06430115f, -0.06701439f, -0.08031433f, -0.03630126f, -0.01990177f, -0.03883574f, -0.04814454f, 
    -0.00172442f, 0.05375589f, -0.05260061f, -0.06374168f, 0.04812737f, -0.00060744f, 0.02308653f, -0.05951776f, 
    -0.04113001f, 0.05267680f, 0.04996056f, 0.03331849f, 0.05240935f, -0.06640371f, -0.03075588f, -0.08486886f, 
    -0.04006690f, 0.05494991f, -0.03673193f, -0.01041146f, -0.04970526f, -0.01648528f, 0.04532144f, -0.06173771f, 
    0.01856006f, 0.05022101f, -0.06316664f, 0.00598448f, 0.05929729f, 0.00541645f, -0.00110136f, -0.05774968f, 
    -0.05478148f, -0.03266459f, -0.06255429f, 0.01860268f, 0.04590715f, -0.04153529f, -0.02125241f, -0.06426609f, 
    0.01807970f, 0.04957901f, -0.06576407f, 0.02617672f, -0.03510127f, -0.02811727f, 0.00755177f, 0.02335622f, 
    0.01422981f, -0.00776240f, -0.06956631f, -0.03409440f, -0.03437461f, -0.01292758f, -0.00872791f, -0.02120325f, 
    -0.00368342f, -0.04298818f, 0.02049396f, 0.04970664f, -0.01360532f, -0.07213953f, -0.05931532f, 0.04450953f, 
    0.01673635f, -0.07271358f, -0.06929947f, 0.02689755f, 0.03586498f, -0.06640562f, -0.05837679f, -0.00831481f, 
    -0.03209415f, -0.01555381f, -0.04536318f, 0.04289958f, 0.00554890f, -0.02288548f, 0.01475807f, -0.04596573f, 
    0.02300289f, -0.02086659f, 0.05184731f, 0.05774090f, 0.05811060f, 0.03465192f, -0.06296206f, 0.01080695f, 
    -0.05668493f, -0.06775746f, 0.03354580f, -0.05695217f, 0.06162793f, -0.05112481f, 0.00018617f, -0.02530860f, 
    -0.06621028f, 0.06070792f, 0.01916732f, -0.07457972f, -0.04101866f, -0.03261302f, 0.03934445f, -0.06934270f, 
    0.02937284f, 0.03335708f, -0.05102449f, -0.01920830f, -0.01706169f, 0.00643192f, -0.07129730f, -0.02896744f, 
    -0.06422490f, -0.07810124f, -0.02558720f, -0.02322481f, -0.01028103f, 0.03568166f, -0.05581459f, 0.05184089f, 
    -0.01547685f, -0.05252181f, -0.06302878f, 0.05803778f, -0.04554210f, -0.07899321f, 0.01586624f, 0.01043623f, 
    0.01784495f, -0.03828730f, -0.03841659f, -0.05718463f, -0.06223143f, -0.06618670f, -0.07745195f, -0.00044206f, 
    0.02562582f, 0.02784495f, -0.06196003f, -0.05613247f, 0.01465071f, 0.04484431f, 0.03758243f, -0.02663257f, 
    0.01835383f, -0.07019503f, -0.02262111f, 0.00228187f, -0.06462104f, -0.04518148f, -0.01601427f, -0.00437688f, 
    0.06428224f, -0.03901857f, 0.02129284f, -0.05365321f, -0.02579363f, 0.03676653f, -0.06919564f, 0.01002826f, 
    -0.01403235f, -0.00621581f, -0.04984663f, -0.05827123f, -0.05459516f, -0.01106788f, -0.04575180f, 0.03374119f, 
    0.04054029f, 0.01959186f, 0.02902381f, 0.00356928f, -0.01956906f, -0.00146647f, -0.07151482f, -0.04470406f, 
    0.04030735f, -0.00877819f, 0.00408658f, -0.05946653f, 0.02196244f, 0.06146376f, -0.04399494f, -0.02537342f, 
    -0.05580387f, -0.01431085f, 0.04483018f, 0.00794688f, 0.00577568f, 0.04238275f, -0.05923942f, -0.00990527f, 
    0.03171979f, -0.03706937f, -0.02201702f, 0.03624588f, -0.03730521f, 0.01684417f, -0.01215038f, -0.00656706f, 
    0.02345997f, -0.00805541f, -0.02106094f, -0.06189252f, 0.03126105f, -0.05898325f, -0.00771162f, 0.04008576f, 
    -0.07068398f, 0.02840606f, -0.04102363f, 0.05112150f, 0.06311972f, -0.02325267f, -0.01429011f, -0.01822201f, 
    0.05564479f, 0.01574173f, 0.06735361f, -0.00116500f, 0.00878145f, 0.04407261f, -0.06070623f, -0.04598669f, 
    0.00057679f, -0.04377604f, 0.00063922f, 0.04040574f, -0.04885231f, -0.02447366f, 0.05998859f, 0.01481493f, 
    -0.02451745f, -0.02061850f, 0.00470779f, 0.01786732f, -0.06717226f, -0.02271596f, 0.04951356f, -0.02565911f, 
    0.05328523f, -0.06912281f, -0.05393273f, -0.04365880f, -0.00062683f, 0.02381997f, 0.05696968f, -0.03513369f, 
    -0.07718790f, -0.02090464f, 0.02069896f, -0.04428202f, -0.05568591f, -0.03720185f, -0.07841343f, 0.02254250f, 
    -0.03579558f, -0.05472436f, -0.00394514f, 0.02034729f, 0.03926177f, -0.05176130f, -0.02631725f, 0.01300365f, 
    -0.07071332f, -0.00563597f, 0.02391757f, 0.05054083f, -0.05628051f, 0.00337110f, -0.06377994f, -0.07483872f, 
    -0.05705400f, 0.00867653f, -0.05603812f, -0.04785973f, 0.02270966f, 0.03157980f, 0.02305212f, -0.04875353f, 
    -0.00452303f, 0.01034459f, -0.02992637f, -0.00693782f, 0.04580209f, -0.07431234f, -0.05032104f, -0.06059748f, 
    -0.07059813f, -0.03029001f, -0.05199805f, 0.04986287f, -0.04871285f, 0.04728539f, 0.00323402f, 0.01815878f, 
    -0.02031289f, -0.06917103f, 0.01989093f, 0.00943491f, -0.01851950f, -0.06668928f, 0.00516070f, -0.00212609f, 
    -0.05384213f, -0.05714720f, -0.02428991f, -0.01048759f, 0.01666012f, -0.02203937f, -0.06016843f, 0.01819353f, 
    0.01870078f, 0.04153531f, -0.07155707f, 0.01078728f, -0.00466838f, 0.05373397f, 0.00001704f, 0.05378049f, 
    -0.06059982f, -0.03872437f, -0.07794041f, -0.04430177f, -0.00741507f, 0.01455442f, 0.03063180f, 0.04995165f, 
    -0.04894920f, -0.03987063f, -0.07027378f, -0.01673646f, 0.00054386f, -0.04486436f, 0.00946872f, 0.06388797f, 
    0.03259506f, -0.04319908f, -0.01078155f, -0.05287605f, -0.04448508f, 0.02323464f, -0.04323892f, 0.02133870f, 
    0.04574831f, -0.00238880f, -0.07482672f, 0.00995142f, -0.02941281f, 0.03777142f, 0.00448270f, -0.06166859f, 
    0.03919435f, 0.01279432f, 0.05915288f, -0.05246455f, 0.02927151f, -0.00806636f, 0.06724748f, -0.05192295f, 
    -0.00716414f, 0.06142705f, 0.03880067f, -0.04810893f, 0.02526641f, -0.04296328f, 0.02020587f, 0.05569636f, 
    -0.02822493f, 0.05153376f, 0.01841803f, -0.07091210f, -0.04129231f, -0.00915927f, 0.06553376f, -0.00649008f, 
    -0.01329833f, 0.04239150f, -0.00032825f, 0.02566663f, 0.03910558f, 0.06039152f, 0.03486248f, 0.00156947f, 
    0.06144978f, -0.04630792f, 0.02102761f, -0.04035969f, -0.01951503f, -0.04831632f, 0.05478102f, -0.01166370f, 
    0.03752307f, -0.06248423f, -0.04330269f, -0.01620312f, -0.01007017f, 0.00106096f, -0.01931817f, -0.00021328f, 
    -0.00461211f, 0.01707996f, -0.06303556f, -0.02136430f, -0.01763620f, 0.03761752f, 0.01231177f, -0.04056518f, 
    0.21014300f, -0.24525733f, -0.05097364f, 0.34084311f, 0.07536069f, -0.17563465f, 0.12010115f, 0.07709324f, 
    0.19787426f, 0.01158540f, 0.05183162f, 0.05231752f, -0.05727487f, -0.04114044f, -0.18354951f, -0.01487409f, 
    0.01053148f, 0.10816181f, 0.05480926f, -0.09475553f, -0.16642965f, -0.16093785f, -0.08408888f, -0.10080649f, 
    0.03943358f, 0.20338549f, 0.26645702f, 0.01787143f, -0.09856516f, 0.00323158f, 0.04787898f, 0.01396415f, 
    0.08697703f, 0.12498545f, 0.15911205f, -0.01388710f, 0.14591612f, -0.14386743f, -0.00108991f, -0.02673066f, 
    -0.03147680f, 0.09331560f, 0.07471982f, 0.03665576f, 0.02325039f, -0.19912899f, -0.11399140f, 0.05566230f, 
    0.23705137f, -0.00470749f, -0.10525279f, 0.14374556f, -0.00587986f, -0.01508825f, 0.01390072f, -0.06892726f, 
    0.15051997f, 0.07418543f, 0.17360063f, 0.00367143f, 0.07907084f, -0.06477828f, 0.01318857f, 0.20304723f, 
    -0.05973958f, 0.13450032f, 0.02820224f, 0.04100114f, 0.03152116f, 0.10436792f, 0.05128212f, 0.10750285f, 
    0.12918530f, -0.11123178f, -0.09693179f, 0.11701502f, -0.02748588f, -0.10598677f, 0.01420305f, -0.08597072f, 
    0.09235750f, 0.04244151f, -0.06428875f, -0.07113160f, -0.03279174f, -0.19824031f, -0.00612816f, 0.01430797f, 
    0.06165517f, 0.19006003f, 0.01618022f, -0.00253269f, 0.13419998f, -0.00059542f, -0.10052416f, -0.04150505f, 
    -0.02696769f, 0.20156652f, -0.04276001f, 0.17611071f, 0.12915067f, 0.03345790f, -0.12082385f, 0.09601392f, 
    0.10479760f, -0.05584974f, 0.10829233f, -0.11418983f, -0.10282183f, -0.08871170f, -0.19025753f, 0.15813348f, 
    -0.03797988f, -0.01468989f, -0.06042690f, -0.02859453f, -0.02710692f, -0.03408221f, 0.00126105f, 0.12184890f, 
    0.18415236f, 0.01531876f, 0.10212128f, 0.00279642f, -0.00494154f, 0.18619950f, 0.04601990f, -0.07086004f, 
    0.04241180f, 0.04295307f, -0.04537665f, 0.18225646f, -0.01973988f, 0.06323528f, 0.05700007f, -0.02357906f, 
    -0.16834167f, 0.08842787f, -0.05455214f, -0.15705252f, -0.00817945f, -0.11261596f, 0.12293646f, 0.03287229f, 
    -0.19844648f, 0.23980652f, 0.00412150f, -0.18829697f, 0.08686956f, -0.04979044f, -0.10487343f, -0.15735829f, 
    0.10039637f, 0.14391544f, 0.05268874f, -0.06348661f, -0.59571975f, 0.16197106f, -0.15411505f, -0.07938791f, 
    0.16210721f, -0.03956131f, 0.02852390f, 0.06069856f, 0.09385931f, 0.18467146f, 0.14869520f, -0.01058621f, 
    -0.32624337f, -0.05763092f, -0.12564673f, 0.02659497f, 0.08743132f, 0.08317343f, 0.11031996f, -0.01353464f, 
    0.04370846f, -0.08652066f, -0.05273409f, -0.11040346f, -0.06629814f, -0.17069075f, -0.11079889f, 0.04949149f, 
    0.03659927f, -0.05588966f, 0.14255339f, -0.23900524f, -0.01904675f, -0.05438686f, -0.05625581f, -0.09494952f, 
    -0.14399539f, 0.13339126f, 0.11054972f, -0.04643328f, 0.01872923f, -0.02352475f, -0.06796388f, 0.00463839f, 
    -0.02589516f, -0.10981793f, 0.05156932f, 0.02465042f, -0.00257503f, 0.07730512f, 0.06711407f, 0.29980549f, 
    0.05182043f, -0.04087967f, -0.05974190f, 0.06388795f, 0.05521348f, -0.04702356f, -0.05558401f, 0.07502187f, 
    0.35558611f, -0.00691861f, -0.18397187f, -0.00081224f, 0.18861781f, -0.08129366f, -0.01363540f, 0.12888210f, 
    -0.09832477f, -0.02241804f, 0.10750134f, -0.07642987f, 0.40060997f, -0.20251650f, -0.24203099f, 0.02605112f, 
    0.00764787f, -0.01591767f, 0.07740519f, -0.07971227f, -0.06817979f, 0.05432070f, 0.08964769f, -0.07814687f, 
    0.35649559f, 0.19233724f, -0.37095085f, 0.12592445f, -0.06293698f, 0.02673387f, -0.08753999f, 0.06589489f, 
    0.02567662f, 0.04558482f, 0.09972973f, -0.04934704f, 0.30505878f, -0.16081756f, -0.11806274f, 0.13238023f, 
    0.05735790f, 0.08436488f, 0.04898464f, 0.02229117f, 0.00258280f, 0.00285112f, -0.03214820f, -0.04477402f, 
    -0.10292122f, 0.26338592f, 0.06596594f, 0.01542986f, 0.09381051f, 0.14887258f, 0.00042557f, -0.06686319f, 
    -0.01888490f, -0.00865068f, 0.17370993f, 0.05658072f, -0.14156434f, 0.14877109f, 0.22203918f, 0.17678638f, 
    -0.03154643f, -0.01271934f, 0.12465126f, -0.03650238f, -0.02636244f, -0.07685877f, -0.06649838f, 0.03691185f, 
    0.07724652f, 0.18399231f, -0.10559783f, -0.12335040f, -0.14891803f, 0.14942780f, -0.04236408f, -0.05999192f, 
    -0.01406680f, -0.09043545f, -0.00694429f, 0.02656959f, -0.00782833f, 0.16384606f, -0.16363640f, -0.00727812f, 
    -0.16566975f, -0.00273181f, -0.04212943f, 0.06118397f, -0.11505452f, -0.06276629f, -0.01898104f, -0.05564502f, 
    0.09757884f, 0.11417586f, -0.26146859f, 0.19428045f, 0.07744538f, 0.02359374f, -0.10442801f, 0.01128352f, 
    -0.00399911f, 0.05440202f, 0.14939363f, 0.02102659f, 0.00373075f, -0.09992164f, -0.10015710f, 0.07924765f, 
    -0.08347544f, 0.00721129f, -0.13558716f, -0.06562667f, -0.01337098f, -0.03540630f, 0.00403702f, 0.01991720f, 
    0.00536465f, -0.39892295f, 0.21633498f, 0.37824130f, -0.19580749f, -0.00919239f, 0.03400930f, -0.03180100f, 
    0.07463544f, -0.05349607f, 0.13281126f, 0.05687749f, -0.07245423f, 0.07297223f, 0.17913857f, 0.03198666f, 
    0.00374905f, 0.13410270f, -0.05315977f, -0.07684735f, 0.00034289f, -0.00658649f, -0.00123007f, -0.06165577f, 
    -0.05762714f, 0.10783320f, 0.13039467f, -0.02332900f, 0.07094729f, 0.11411475f, -0.00976855f, -0.04556038f, 
    -0.03270219f, 0.05294368f, 0.12388497f, -0.11515120f, -0.19894671f, 0.32880682f, 0.01588558f, 0.10549692f, 
    0.25636503f, -0.00509477f, -0.11130010f, 0.14859228f, -0.15005712f, -0.01027517f, 0.07854402f, 0.06035830f, 
    0.08719264f, 0.00527338f, 0.05234139f, -0.03726459f, 0.10637625f, 0.09562368f, 0.14566334f, -0.02639584f, 
    0.02470941f, 0.07790832f, 0.02872385f, 0.08744788f, 0.12933430f, 0.15361609f, 0.08130116f, 0.07834998f, 
    0.05055121f, -0.04478246f, 0.02984981f, 0.13544109f, -0.02607285f, 0.08132849f, -0.08429391f, -0.00907856f, 
    -0.18654841f, -0.10924796f, 0.04426023f, 0.14539912f, -0.12297858f, 0.06349717f, -0.15083236f, -0.02975311f, 
    -0.13908270f, -0.01755919f, -0.03595831f, 0.08811016f, -0.26388291f, 0.39547554f, 0.21092868f, 0.03111685f, 
    -0.14501576f, 0.01443532f, 0.02594996f, 0.10109277f, 0.04003729f, 0.03066969f, -0.03475205f, 0.07049929f, 
    -0.50752711f, 0.01663517f, 0.14434645f, 0.00361173f, 0.00827495f, 0.03602238f, 0.11980125f, 0.03936601f, 
    -0.20373599f, -0.10136779f, -0.06446670f, -0.10690513f, -0.21745256f, 0.03280938f, 0.21368520f, -0.34457302f, 
    -0.20717824f, 0.00807928f, 0.02034654f, 0.02865051f, 0.02262694f, 0.04925122f, -0.00606378f, 0.08637922f, 
    0.25903878f, -0.09400062f, -0.09408731f, -0.00899606f, 0.11105451f, -0.11862741f, 0.04401666f, -0.08179761f, 
    0.00672072f, 0.04580542f, 0.01327896f, -0.01373958f, -0.10643667f, 0.11318670f, -0.13911168f, -0.19664429f, 
    0.15303899f, 0.02052359f, -0.02923544f, 0.00466753f, 0.07428824f, 0.10564241f, -0.00152732f, -0.09194560f, 
    -0.01964331f, 0.09097866f, 0.07947372f, 0.03823072f, 0.20783919f, 0.13016784f, 0.04759264f, -0.01320254f, 
    -0.08827779f, 0.13486642f, 0.03660745f, 0.16237970f, 0.24698892f, -0.19738321f, 0.30711782f, 0.16025984f, 
    0.05450954f, 0.10407916f, 0.02242375f, -0.06552391f, -0.02321743f, -0.01060482f, -0.00873720f, 0.02607987f, 
    -0.29190770f, -0.15152757f, 0.04914097f, 0.07656215f, -0.04530139f, -0.06306201f, -0.06384305f, -0.02577489f, 
    0.01985781f, -0.09787936f, 0.01033585f, -0.11361350f, 0.12921682f, -0.25249293f, 0.04708773f, -0.01617962f, 
    0.21606676f, 0.04334825f, 0.08721389f, 0.08112889f, 0.07794677f, 0.04941177f, -0.03361427f, 0.09022032f, 
    0.27669626f, 0.13429095f, -0.08333842f, -0.05710532f, 0.04505685f, 0.17225979f, 0.02160435f, 0.08883652f, 
    0.06624032f, -0.01364733f, -0.06961099f, 0.01612487f, 0.00033608f, -0.06570876f, 0.09859902f, -0.00311866f, 
    0.02858191f, 0.05269475f, 0.07212203f, 0.09583890f, -0.05377986f, -0.02311542f, 0.02740175f, 0.01081568f, 
    0.18127409f, 0.17323282f, -0.16164327f, 0.11397274f, 0.01749050f, 0.06647384f, -0.05079586f, 0.05471318f, 
    0.02484393f, -0.02121340f, 0.06126189f, 0.22295541f, 0.12637369f, -0.08374925f, 0.22108564f, -0.12080541f, 
    -0.33254391f, 0.00737733f, -0.07453651f, 0.13063511f, 0.02818661f, 0.03280547f, 0.06965283f, 0.01053504f, 
    0.38220185f, 0.16409691f, 0.19509219f, 0.25480232f, -0.11958384f, 0.02267854f, 0.14981958f, -0.00256915f, 
    -0.19971344f, -0.01393616f, -0.19142903f, -0.05414912f, -0.21521096f, -0.06505559f, -0.02587699f, 0.35557973f, 
    -0.01661923f, 0.12063605f, -0.01310285f, -0.05153538f, 0.07832804f, 0.05552154f, -0.03050802f, -0.07997535f, 
    0.19308770f, -0.03211177f, -0.03060314f, 0.07805815f, -0.12562314f, 0.05182582f, -0.22254349f, 0.05035368f, 
    0.23941070f, -0.02924908f, 0.04417544f, -0.00863090f, 0.21382187f, -0.13639289f, -0.28519145f, -0.26788938f, 
    0.00640425f, -0.18397802f, -0.09016267f, 0.06699628f, 0.15326498f, 0.06581997f, 0.06251497f, 0.13893990f, 
    0.45259359f, -0.20180807f, 0.10087268f, -0.09122248f, -0.06269478f, -0.01844705f, -0.03999561f, -0.13395348f, 
    0.09062679f, 0.05954487f, 0.16498102f, 0.07137735f, 0.29953560f, -0.08704650f, -0.16246465f, 0.22493088f, 
    -0.05862018f, -0.00517112f, -0.09078635f, -0.07448607f, -0.01521831f, -0.11549573f, 0.04953730f, -0.02509191f, 
    -0.07675587f, 0.21250649f, 0.27105051f, 0.06553836f, -0.06452812f, 0.04796814f, 0.16231166f, 0.05819046f, 
    0.09323242f, 0.00353334f, -0.01273311f, -0.04186353f, 0.01997755f, -0.10195515f, 0.06399009f, 0.14479604f, 
    0.03466175f, 0.14712770f, -0.11417005f, -0.00510084f, -0.09989428f, -0.18482260f, 0.00942330f, 0.02943166f, 
    0.18722026f, 0.14623827f, 0.16076349f, 0.35880601f, 0.04240986f, -0.09706894f, 0.14918044f, 0.04669723f, 
    -0.16656904f, -0.20838091f, -0.09842933f, -0.17011152f, 0.00489988f, -0.03511420f, -0.16176297f, 0.21489827f, 
    0.04479905f, -0.09262294f, 0.09282788f, 0.06386453f, 0.06614845f, 0.04845082f, -0.04714815f, -0.07834966f, 
    0.37982342f, -0.01297888f, 0.01722408f, -0.16615896f, -0.17055868f, -0.02542904f, 0.03757857f, -0.13524504f, 
    0.15810755f, 0.01715779f, -0.04209580f, -0.07183100f, -0.07984875f, -0.53793943f, -0.02216001f, -0.03435449f, 
    0.04074516f, -0.01905478f, 0.04205755f, -0.05571589f, -0.04521513f, 0.11100177f, 0.04621654f, 0.00065892f, 
    0.03122769f, -0.20023376f, -0.07079514f, -0.24213512f, -0.02053357f, -0.04851217f, 0.00089711f, -0.02484060f, 
    0.08536077f, 0.02286398f, 0.09268776f, -0.12902814f, -0.45344946f, 0.27550462f, -0.04198752f, -0.00269351f, 
    -0.08206349f, -0.06369514f, 0.01846004f, 0.14775755f, 0.01773056f, 0.19779164f, 0.04696501f, 0.09410341f, 
    -0.02190377f, 0.05331285f, -0.09761592f, 0.05274865f, 0.10152514f, -0.13427895f, -0.04021823f, 0.01445332f, 
    0.14578848f, -0.12835696f, 0.06870618f, 0.11273814f, 0.20952775f, -0.11255781f, -0.10918191f, -0.04153924f, 
    0.01212683f, 0.00313840f, -0.10466919f, 0.02792980f, 0.06629342f, -0.02056767f, -0.06487267f, 0.06899956f, 
    -0.24703526f, -0.06855277f, -0.11159793f, -0.41540569f, 0.19492364f, 0.10964421f, 0.17171386f, 0.15479784f, 
    0.04711960f, 0.10203010f, 0.09981494f, -0.14152583f, -0.20925589f, -0.02288307f, -0.19665308f, 0.15754175f, 
    0.05160272f, 0.06518693f, 0.15916327f, -0.15035798f, -0.13355006f, 0.13064708f, -0.24695782f, -0.02834948f, 
    -0.25006217f, 0.23851146f, 0.29463497f, 0.32481393f, -0.14183336f, -0.23949344f, -0.09102357f, -0.08260372f, 
    -0.08398394f, 0.02944407f, 0.01276984f, 0.12160120f, 0.35623297f, 0.22787693f, 0.29865465f, 0.08825473f, 
    -0.25689626f, -0.02719316f, 0.19845016f, -0.11394379f, -0.07231741f, 0.14016320f, 0.03229681f, -0.07665858f, 
    -0.13140963f, 0.28111303f, -0.23361823f, 0.05199621f, -0.02958730f, -0.10465836f, 0.04021622f, -0.02670202f, 
    0.04738383f, -0.04954127f, 0.06737293f, 0.02264444f, 0.38122565f, 0.21388523f, 0.30437985f, 0.17975964f, 
    -0.38553432f, -0.06023556f, 0.09564159f, -0.08111156f, 0.01291655f, 0.22567947f, 0.03337436f, 0.23567796f, 
    -0.30013362f, -0.15025334f, -0.44263706f, -0.39899701f, 0.11392259f, 0.23577645f, 0.15046750f, -0.02061930f, 
    0.20374471f, 0.09222073f, -0.18753318f, -0.08559313f, -0.40107891f, -0.33554396f, -0.15290456f, -0.34672478f, 
    -0.13469568f, 0.33254722f, 0.07272010f, 0.17636338f, 0.04911862f, 0.20721240f, -0.04819577f, 0.01723699f, 
    -0.24739145f, -0.09812691f, -0.28791720f, -0.22179592f, 0.37573960f, 0.12924375f, 0.05506920f, 0.02290471f, 
    0.13991964f, 0.06120279f, 0.15582468f, 0.00604008f, 0.19973755f, -0.08489135f, 0.31069565f, -0.10263443f, 
    0.01798125f, -0.04229823f, -0.04390871f, 0.15784648f, 0.23947814f, 0.13534123f, -0.00437286f, 0.02625709f, 
    -0.46640605f, 0.18807484f, -0.08134832f, 0.20499246f, -0.03654863f, -0.14517750f, -0.08905968f, -0.06062142f, 
    0.12219154f, -0.06287669f, 0.01460180f, -0.05381873f, 0.12271590f, -0.20187084f, 0.06665474f, -0.21157317f, 
    0.09792399f, -0.09343223f, -0.05580629f, 0.11264277f, -0.18134716f, 0.20892978f, 0.04859124f, 0.03220997f, 
    0.20589191f, 0.07293804f, 0.42975688f, 0.38513699f, -0.12869902f, 0.02943687f, -0.17442062f, -0.10507735f, 
    0.02582844f, -0.01034433f, -0.08800486f, 0.24072282f, -0.28954765f, 0.07123639f, -0.51180357f, -0.04440719f, 
    0.22219950f, 0.13112815f, -0.14128715f, -0.00006115f, 0.12078072f, 0.00010415f, 0.00839666f, -0.17724897f, 
    0.06468249f, 0.01966812f, -0.43827292f, -0.21672520f, 0.28759071f, 0.23039854f, -0.01208061f, 0.07898368f, 
    0.08449873f, -0.03770929f, -0.16194017f, -0.15081288f, 0.29106507f, 0.25357813f, 0.40683284f, 0.08693803f, 
    -0.24348919f, -0.10426424f, 0.03524117f, -0.03693289f, -0.03296355f, -0.06793580f, 0.14555909f, 0.22894259f, 
    0.32959658f, 0.07581135f, 0.05928442f, 0.08249035f, -0.03066871f, -0.04296273f, 0.18670318f, 0.12614305f, 
    0.02981645f, 0.06145911f, 0.02719966f, -0.04899865f, 0.03546035f, -0.14656393f, -0.26743996f, -0.34915894f, 
    -0.15244554f, -0.06143405f, 0.13279060f, 0.18695909f, -0.01133235f, 0.15286455f, 0.04955813f, 0.02486280f, 
    -0.18325391f, -0.04193804f, 0.15639985f, 0.06075383f, -0.09435524f, 0.04509706f, 0.10983511f, 0.05717279f, 
    0.03835090f, -0.07772381f, 0.14440893f, -0.06283211f, 0.09072123f, 0.17572783f, 0.14278977f, -0.02836136f, 
    -0.17896767f, 0.05264652f, 0.06278757f, 0.07775284f, 0.13312024f, -0.13979839f, 0.05913326f, 0.05316051f, 
    0.09134775f, -0.04900890f, -0.13874009f, -0.03806063f, -0.11888620f, -0.03626405f, 0.11687262f, 0.09121148f, 
    0.09795547f, 0.11631884f, -0.04032206f, -0.13227844f, 0.01745793f, -0.04648649f, 0.25238398f, 0.41443139f, 
    0.04392535f, -0.04734791f, -0.03219956f, -0.10178120f, -0.01047412f, -0.03534373f, 0.06866834f, -0.04777867f, 
    -0.23043512f, -0.16601743f, -0.10319446f, 0.11858410f, -0.07853671f, -0.12830880f, 0.01823526f, 0.08082724f, 
    -0.01340946f, 0.11621598f, -0.01864487f, 0.03780496f, 0.13172047f, 0.01638732f, -0.18522967f, -0.12276234f, 
    0.10099536f, 0.05606141f, -0.15103944f, 0.00634247f, -0.06594844f, 0.08122710f, -0.12544753f, -0.05446124f, 
    0.13994412f, -0.07109709f, -0.01989735f, 0.14214234f, -0.07997871f, -0.02142138f, 0.07476152f, 0.10784988f, 
    -0.06385635f, -0.00011844f, 0.00126598f, 0.08989768f, 0.02715769f, 0.00277805f, 0.00367539f, 0.01783998f, 
    0.24083003f, 0.10095694f, -0.08207700f, -0.07846929f, 0.06006639f, -0.08596377f, 0.03578883f, -0.01413896f, 
    0.01291163f, -0.00041108f, -0.07329948f, 0.05989482f, 0.00956450f, 0.12430159f, 0.18670399f, 0.11537190f, 
    -0.01619076f, -0.05590145f, -0.03095800f, -0.06353400f, -0.26400590f, -0.10722575f, 0.05461519f, 0.10831262f, 
    0.06223925f, 0.03344521f, 0.08397555f, 0.02017965f, -0.06149185f, -0.01043545f, 0.05409520f, 0.03526900f, 
    -0.10785306f, 0.03932340f, 0.38551185f, -0.09768191f, 0.26668820f, 0.03138801f, -0.04695993f, 0.11548106f, 
    -0.02056674f, 0.04055699f, -0.10525208f, 0.14623676f, -0.34120217f, 0.30136970f, -0.16790336f, 0.04205840f, 
    -0.03707543f, 0.03224826f, 0.06169193f, 0.04272630f, 0.02683433f, -0.09676711f, -0.05141451f, 0.04747576f, 
    0.11142971f, -0.03271989f, -0.17455499f, 0.11133648f, -0.16020589f, 0.03565204f, -0.06040537f, 0.01416202f, 
    -0.01660429f, 0.13721107f, 0.03449433f, 0.09097342f, 0.40475425f, -0.04295284f, 0.19464715f, 0.12599191f, 
    -0.06401487f, -0.02805898f, -0.01483555f, -0.00452299f, -0.01550209f, 0.04839332f, -0.18554693f, 0.07096387f, 
    0.31472310f, -0.08381747f, -0.01447983f, -0.01262571f, 0.04545112f, 0.05039372f, 0.13299999f, 0.03098645f, 
    0.01983248f, 0.21126653f, 0.05739178f, 0.19281130f, -0.12469039f, 0.09800738f, -0.13215140f, 0.14918016f, 
    -0.00083998f, 0.00538487f, 0.06102518f, -0.07492099f, -0.00898062f, 0.01007774f, -0.08910955f, -0.20983054f, 
    -0.17017166f, 0.28212541f, 0.18282890f, 0.09914026f, -0.08122610f, -0.12045740f, -0.05106004f, 0.00512253f, 
    -0.04128292f, -0.08295602f, -0.10141195f, 0.20543256f, 0.07527415f, 0.31163481f, 0.32383278f, -0.09119555f, 
    -0.12817782f, -0.11385252f, 0.09267700f, 0.14872375f, -0.00343590f, -0.03864048f, -0.02752091f, 0.03920203f, 
    -0.15665390f, -0.08077981f, 0.07684638f, 0.19582388f, -0.05541931f, -0.01009845f, 0.24068318f, 0.01166551f, 
    -0.08069336f, -0.00479607f, 0.06921785f, 0.12316027f, 0.34709886f, 0.27802724f, 0.13841601f, -0.30258858f, 
    -0.26605505f, -0.06830291f, 0.06112437f, 0.16510423f, 0.00549461f, 0.01095166f, -0.01915518f, 0.17628518f, 
    0.21080114f, -0.14306439f, -0.07683828f, -0.24313971f, 0.11482225f, -0.05662517f, -0.05809524f, -0.04145436f, 
    0.00613966f, 0.22086197f, -0.00143030f, -0.06859849f, 0.03390549f, -0.23161864f, -0.14656788f, -0.14965366f, 
    0.01466991f, 0.15294968f, -0.06403913f, -0.03188941f, -0.01083035f, 0.06903653f, -0.09374028f, 0.03128761f, 
    0.26858309f, 0.12971359f, -0.19137260f, 0.16626932f, 0.34139383f, 0.04748249f, 0.10088379f, -0.06115859f, 
    0.03264391f, 0.01798487f, 0.03679606f, -0.01095991f, 0.30548036f, -0.32833412f, 0.21518344f, 0.13883542f, 
    0.08511615f, 0.03853242f, 0.11411009f, 0.14319974f, 0.02419608f, 0.12199543f, -0.02462923f, 0.11278661f, 
    -0.06587635f, -0.03264823f, 0.14771424f, -0.05690702f, -0.02683323f, 0.05251575f, 0.09628102f, -0.12704845f, 
    0.04292950f, -0.11212825f, 0.06734388f, 0.07044490f, 0.11690316f, -0.35939655f, 0.10815533f, -0.12444568f, 
    0.08285911f, 0.00955574f, 0.21706478f, -0.06632973f, -0.01714093f, 0.00462292f, -0.07266220f, 0.07369559f, 
    0.03487807f, -0.09598149f, -0.07189850f, -0.26059538f, -0.01408366f, 0.00650981f, -0.03943077f, 0.06982332f, 
    0.01851128f, -0.07422760f, -0.20629017f, 0.00359447f, -0.25440979f, 0.01995462f, -0.16593525f, 0.04422862f, 
    0.11885175f, -0.00582114f, 0.07297822f, 0.16897389f, 0.01447859f, -0.06972145f, 0.16306031f, 0.04620650f, 
    0.27160129f, 0.11704295f, -0.25351968f, -0.11988387f, 0.07834440f, 0.05365733f, 0.11259627f, 0.02174910f, 
    0.05261297f, -0.01800330f, 0.03979635f, 0.13374186f, 0.02241140f, 0.02562239f, 0.23815134f, -0.23984438f, 
    -0.19367571f, -0.00722436f, 0.01864061f, 0.09516513f, 0.10322043f, -0.00690043f, 0.01720088f, 0.12966244f, 
    -0.20170076f, -0.41010022f, -0.22431353f, -0.13817798f, 0.09896653f, 0.06630862f, 0.06708515f, 0.24569924f, 
    0.02345991f, 0.09003717f, 0.08573130f, 0.12804683f, -0.16590297f, 0.27367237f, 0.15933783f, -0.03953388f, 
    0.01910536f, 0.08672374f, -0.13301165f, -0.02993003f, -0.10567179f, -0.18011521f, -0.02232541f, 0.02282809f, 
    0.45000803f, 0.02628941f, 0.05506502f, 0.16572911f, -0.10351478f, -0.15576918f, 0.00680557f, 0.10774375f, 
    -0.04177206f, -0.13851713f, -0.06765705f, 0.05642453f, -0.07929210f, 0.12606464f, 0.26082191f, 0.13842517f, 
    -0.07607818f, -0.15340403f, -0.01848770f, 0.10292161f, 0.03420837f, 0.06989665f, -0.08923844f, 0.08243718f, 
    0.07179990f, -0.06389762f, 0.31324720f, -0.01318798f, -0.06492162f, 0.03374480f, 0.10758419f, 0.14862910f, 
    -0.14310366f, -0.06901293f, 0.12566689f, -0.03683644f, 0.08057614f, -0.02073240f, 0.13490199f, -0.29433152f, 
    -0.21074732f, 0.05278672f, 0.07633245f, 0.12622006f, -0.06019309f, 0.03718080f, -0.03158233f, -0.04276732f, 
    -0.04839422f, -0.12998641f, -0.19066913f, -0.33334139f, 0.14912987f, 0.04788800f, -0.10981683f, -0.02671781f, 
    0.08320247f, 0.03758937f, 0.04324879f, 0.21882974f, -0.25899169f, -0.23910029f, 0.09362884f, -0.28484362f, 
    0.05962663f, 0.06969646f, 0.24283880f, -0.03473221f, 0.00341211f, -0.06386974f, 0.05617432f, -0.13421199f, 
    -0.11614013f, -0.08002445f, -0.21033619f, -0.23714578f, 0.16487616f, 0.11619082f, -0.11014977f, 0.07815888f, 
    0.16931783f, 0.01701663f, -0.11622521f, 0.06927925f, -0.02208770f, -0.00785264f, 0.19440417f, 0.28138793f, 
    -0.21922870f, -0.03066515f, 0.07994535f, 0.13033745f, 0.03853343f, -0.08721849f, -0.06688379f, 0.03742824f, 
    0.19754520f, -0.19108193f, 0.19709978f, 0.15910639f, -0.13993493f, 0.04826072f, 0.03537980f, 0.05224641f, 
    0.09272894f, 0.08419412f, 0.06266677f, 0.13268657f, 0.34861624f, 0.02339882f, 0.17587508f, -0.07752134f, 
    0.11979249f, 0.13676380f, 0.00437976f, 0.07265772f, 0.09833691f, 0.09267630f, -0.03679767f, 0.19328772f, 
    0.53584498f, 0.11221614f, -0.09885890f, 0.09000141f, -0.07881204f, 0.15132670f, 0.08214676f, -0.01710943f, 
    -0.07051326f, 0.00839968f, -0.01017376f, 0.09247782f, -0.46757859f, -0.00850232f, 0.11960287f, -0.05420842f, 
    0.14200066f, -0.03886933f, -0.06053555f, 0.10169110f, 0.09181295f, -0.06583811f, 0.00669879f, -0.00577433f, 
    -0.38672379f, 0.06837535f, -0.25417703f, -0.22238016f, 0.14802887f, 0.03192878f, 0.10575449f, -0.02247180f, 
    0.05581964f, 0.06003096f, 0.16756739f, 0.12864800f, 0.13454875f, -0.02477682f, 0.12033059f, -0.08450184f, 
    -0.17182411f, 0.00218500f, -0.01041594f, 0.12689860f, 0.19273117f, -0.08086009f, 0.05414861f, 0.05900118f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08174858f, 0.05356563f, 0.09840066f, -0.07323837f, -0.16453083f, -0.04159879f, 0.03942710f, 0.03702449f, 
    -0.05782608f, -0.05770741f, 0.15306787f, 0.01264160f, 0.04203088f, 0.07113416f, 0.00762993f, -0.02605705f, 
    0.16345814f, 0.13302568f, -0.02284554f, 0.11301382f, -0.02134919f, 0.05363849f, 0.06484980f, 0.03230366f, 
    -0.00552363f, -0.05910427f, 0.03295364f, -0.02057644f, 0.03125349f, -0.03028554f, -0.07114190f, 0.04400930f, 
    0.18711761f, 0.11033926f, -0.15098621f, -0.02964616f, 0.16361888f, 0.11464569f, -0.06284409f, 0.10504440f, 
    0.00569575f, -0.02939432f, 0.14389092f, -0.02258269f, 0.01963486f, -0.01299048f, -0.06199522f, -0.08376972f, 
    -0.07899857f, 0.04919016f, 0.02585586f, -0.09625965f, 0.04821618f, 0.02999724f, 0.04454979f, 0.02108454f, 
    0.11876229f, -0.11004626f, 0.01140401f, 0.06032173f, 0.05139209f, 0.11682741f, 0.07569760f, 0.03471987f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06122821f, 0.46991152f, 0.02282889f, -0.02435364f, 0.28155422f, 0.05492063f, 0.22217229f, -0.29861242f, 
    -0.48998016f, -0.02914249f, -0.02402939f, -0.03822932f, -0.26469409f, -0.10594329f, -0.18858904f, -0.02929053f, 
    0.02346566f, -0.02152888f, -0.02387055f, -0.19992848f, 0.11700142f, -0.19393402f, 0.00451942f, -0.20897549f, 
    0.34380335f, 0.09304067f, 0.01191232f, 0.00325789f, 0.04809002f, 0.14092927f, 0.13714992f, 0.07439692f, 
    0.16086425f, 0.09837585f, 0.36193317f, 0.32507148f, -0.46842611f, -0.45977035f, 0.00325685f, -0.48112690f, 
    0.07767018f, -0.48222089f, -0.05479972f, -0.22148779f, -0.48894891f, -0.80167276f, 0.01340536f, -0.08981411f, 
    0.01815699f, -0.13346237f, 0.02468846f, 0.37530139f, -0.31601289f, -0.01186229f, 0.09675672f, 0.03801763f, 
    -0.42457613f, 0.03505307f, 0.22801895f, 0.10582118f, 0.09353656f, -0.29192656f, 0.21683571f, 0.20082889f, 
    0.06172550f, -0.50339353f, -0.15084423f, -0.05865667f, -0.02902091f, -0.12983152f, -0.03282963f, -0.29738405f, 
    0.38925782f, 0.15341476f, 0.18053688f, -0.14675023f, -0.03973905f, 0.06231794f, -0.56130546f, 0.04664856f, 
    -0.03894732f, -0.00802851f, 0.05921432f, -0.14682840f, 0.05263340f, 0.15012172f, -0.14404130f, -0.10798267f, 
    -0.26964015f, -0.36874408f, 0.02263059f, -0.33554566f, 0.01339355f, 0.25156802f, 0.17141531f, 0.07042087f, 
    -0.16907005f, -0.24631287f, 0.20709133f, -0.10990468f, 0.13523468f, 0.00024532f, 0.09639407f, 0.11173247f, 
    -0.42190248f, -0.45051673f, 0.01256421f, -0.62567693f, -0.09350812f, 0.42134896f, -0.10253401f, 0.18320006f, 
    0.34494114f, 0.14212942f, -0.02056459f, 0.18824479f, -0.20792900f, 0.09439632f, -0.09343535f, -0.07126048f, 
    -0.02195464f, -0.03840440f, 0.12429997f, 0.40457681f, 0.55798960f, 0.24853680f, 0.19049406f, 0.04259071f, 
    0.03635927f, 0.24887632f, -0.01489425f, 0.08673746f, 0.18407546f, -0.00931076f, 0.22596970f, 0.15832390f, 
    -0.48309004f, 0.07292101f, -0.36384413f, 0.35877842f, -0.01778889f, -0.14709917f, -0.09713666f, -0.03955784f, 
    -0.11357925f, 0.09902374f, -0.06426789f, -0.16915545f, -0.01381701f, -0.41667128f, 0.32955325f, 0.29745200f, 
    -0.29448971f, -0.29469448f, 0.06994348f, -0.44961020f, 0.38268873f, -0.03265178f, -0.71820277f, 0.07459246f, 
    0.04114218f, -0.15055077f, 0.37852517f, -0.48532996f, -0.26280200f, 0.01426365f, -0.02348606f, 0.12949127f, 
    -0.59883720f, -0.36546084f, 0.25139967f, 0.16955049f, 0.03431564f, -0.61316705f, 0.10158768f, 0.12958166f, 
    -0.30279180f, 0.14036566f, -0.11137164f, 0.24226682f, -0.29716635f, -0.08210698f, 0.07331157f, -0.02271213f, 
    -0.31132323f, -0.23314902f, 0.02464958f, -0.44966942f, -0.31484222f, 0.22911114f, -0.07966221f, -0.59973961f, 
    0.03067661f, -0.09942448f, -0.04664375f, -0.08227389f, 0.25634211f, 0.07907532f, 0.37340143f, -0.21981062f, 
    -0.42859146f, 0.12593247f, -0.33118701f, -0.20764591f, 0.23200494f, -0.62948060f, 0.07500600f, 0.06666036f, 
    -0.25478992f, 0.03973146f, 0.03071586f, 0.41891465f, 0.10667183f, 0.17061290f, -0.17250635f, -0.45870206f, 
    0.16998188f, -0.05140424f, 0.09156855f, -0.04076139f, -0.65652573f, 0.20202419f, 0.25827482f, -0.09198878f, 
    -0.21935147f, 0.16081382f, -0.16088220f, 0.39931336f, -0.04074674f, -0.05683660f, 0.00486784f, 0.30914378f, 
    0.40269238f, 0.09947088f, -0.09739675f, 0.10126007f, -0.11716641f, 0.13865922f, -0.43884036f, 0.04599519f, 
    -0.51630163f, -0.37884852f, 0.10759952f, -0.32172585f, 0.22861190f, -0.04492228f, 0.02695274f, -0.06654482f, 
    -0.21288295f, 0.18368395f, -0.07302482f, -0.03627538f, -0.83607078f, 0.24071382f, -0.23928599f, 0.04863091f, 
    0.06646060f, 0.14457352f, -0.02136856f, 0.07795960f, -0.16498576f, 0.08335500f, 0.17958799f, 0.00161746f, 
    0.21934600f, -0.65367317f, -0.01927408f, -0.64559561f, -0.13942954f, -0.07574930f, 0.11399803f, 0.08643144f, 
    -0.60123897f, -0.29004997f, -0.00197220f, -0.01962505f, -0.03661498f, 0.32558000f, 0.07226459f, 0.12089184f, 
    -0.05435995f, -0.26942426f, -0.04058566f, -0.01409282f, -0.27627409f, -0.20197263f, -0.09837192f, 0.10843551f, 
    0.18757446f, 0.07213809f, 0.28244627f, 0.03302488f, 0.09227112f, -0.00652740f, -0.09393740f, 0.13911000f, 
    0.25328630f, 0.06810231f, 0.06167679f, -0.10209911f, 0.01218880f, -0.02579041f, 0.14785317f, -0.33708414f, 
    -0.02846310f, -0.03442310f, 0.06714316f, 0.04668084f, 0.52269930f, -0.10692748f, 0.01123331f, -0.09359550f, 
    0.23366079f, -0.47191587f, 0.17340823f, -0.01372190f, -0.25380030f, 0.25999784f, 0.09048651f, 0.08232146f, 
    -0.07837842f, -0.51818222f, 0.28113645f, -0.07156650f, -0.14247403f, 0.11629763f, 0.07328891f, 0.02356921f, 
    -0.51398462f, 0.00142648f, 0.37477210f, -0.20340326f, 0.14460778f, 0.01759274f, -0.24820481f, 0.01958227f, 
    -0.16135743f, -0.24296403f, -0.03502570f, 0.64945793f, -0.08811989f, 0.14146917f, -0.44772631f, 0.13345803f, 
    -0.10675727f, 0.14455177f, 0.08385439f, 0.07645135f, 0.16384012f, -0.29819769f, 0.03997952f, 0.02358711f, 
    0.07415306f, 0.26327223f, -0.87306780f, -0.04979601f, 0.06771038f, -0.00039322f, 0.06827289f, -0.61841947f, 
    0.06344058f, 0.37117016f, -0.06327363f, 0.21708918f, -0.12169615f, -0.00383413f, -0.18700077f, 0.21830611f, 
    -0.12972876f, 0.09989125f, 0.00788164f, 0.11429422f, -0.49905828f, -0.11409760f, -0.05987106f, -0.11791169f, 
    0.34540918f, 0.04134708f, 0.01320749f, -0.46220329f, 0.05904689f, -0.06467128f, 0.15499854f, 0.23650186f, 
    0.01776921f, 0.19249666f, -0.02433204f, -0.12331785f, -0.44485775f, 0.06439823f, -0.78042620f, 0.32822192f, 
    -0.39712316f, -0.11747139f, -0.24424696f, -0.25130776f, 0.20132704f, 0.08000018f, 0.32910696f, 0.06809628f, 
    0.56431872f, 0.20648761f, -0.01461784f, 0.05816163f, 0.08396150f, -0.00988814f, 0.04014366f, -0.34087110f, 
    -0.18922977f, -0.35908225f, 0.04093779f, 0.15907136f, -0.21005830f, -0.20319936f, -0.53427476f, -0.07558176f, 
    -0.08103265f, -0.13622403f, -0.04634801f, 0.25270680f, -0.13738133f, 0.26583061f, -0.09398080f, -0.26192725f, 
    -0.04352685f, -0.85088199f, 0.10209974f, 0.14850473f, 0.25556263f, -0.40712914f, 0.30778855f, 0.05900238f, 
    -0.74042636f, 0.02969259f, -0.01277024f, -0.35438746f, -0.22235641f, -0.08013974f, -0.07533111f, 0.11830298f, 
    -0.37849164f, 0.12807046f, 0.15824203f, -0.62253684f, 0.16749731f, 0.13122959f, 0.14726242f, -0.01813029f, 
    -0.06276506f, 0.18298453f, -0.35836414f, -0.10878600f, 0.16659057f, -0.08437110f, -0.00265599f, 0.14466448f, 
    0.34423867f, 0.09544005f, -0.17611001f, 0.04174385f, -0.50061083f, -0.09493060f, 0.10160781f, 0.04929480f, 
    -0.23932560f, -0.42527732f, -0.08189933f, -0.38941267f, 0.00411957f, 0.07450511f, 0.09511355f, -0.37676397f, 
    0.16511585f, 0.25101900f, -0.12008841f, 0.06394633f, -0.16605386f, -0.42950517f, -0.02268789f, -0.07665054f, 
    -0.35111576f, 0.08219227f, 0.02922205f, -0.13755092f, -0.21660110f, 0.26451713f, -0.12218516f, -0.15534216f, 
    0.09998967f, 0.25064421f, -0.50951993f, 0.05298713f, 0.31103566f, 0.31619766f, -0.09709257f, 0.14768541f, 
    0.32443240f, -0.35100114f, -0.00407189f, 0.02291942f, 0.09114949f, -0.12636963f, 0.01851423f, 0.10104956f, 
    0.02286863f, 0.22330475f, 0.06938844f, -0.04120477f, -0.29044330f, -0.43958056f, -0.19590467f, -0.12348768f, 
    0.01251870f, -0.46298397f, 0.31855497f, 0.01761500f, -0.41440541f, -0.07456452f, 0.13346073f, 0.09096545f, 
    -0.08173338f, 0.15886910f, 0.25755370f, 0.07343762f, 0.13138819f, 0.33716470f, -0.11165168f, -0.08798945f, 
    -0.14468989f, 0.00090188f, 0.06408378f, -0.35007101f, 0.00569862f, 0.31924587f, -0.09062333f, 0.33094725f, 
    -0.35420194f, 0.34705877f, -0.06408412f, -0.41560584f, 0.00804848f, 0.20833652f, -0.19109687f, -0.05063556f, 
    0.07148811f, -0.36084363f, 0.26029408f, -0.15881748f, 0.04225429f, 0.30545643f, -0.08880101f, -0.15613049f, 
    -0.22011782f, -0.19468567f, -0.13080716f, -0.41764125f, -0.37912521f, 0.01561369f, -0.03488006f, 0.22397447f, 
    0.21881005f, -0.02548632f, -0.02637949f, 0.06664829f, -0.33710924f, 0.00102563f, -0.11918469f, 0.03808302f, 
    0.06233393f, 0.28049985f, -0.53135020f, -0.29210797f, -0.34112719f, -0.12873976f, -0.60949683f, -0.44028667f, 
    -0.10843424f, 0.22547543f, -0.65148795f, -0.00723814f, 0.20638344f, -0.05202859f, -0.43135214f, 0.23733336f, 
    -0.05653122f, -0.23990239f, -0.42615911f, 0.12332151f, 0.05768850f, 0.40530565f, 0.21039838f, -0.07041743f, 
    -0.28960961f, -0.17957741f, -0.07884262f, -0.68203360f, 0.04316230f, -0.56802797f, 0.38104153f, 0.07624705f, 
    -0.05337833f, 0.16114901f, -0.05052153f, 0.19270198f, 0.27083915f, -0.16966191f, 0.03603805f, 0.09367342f, 
    0.16955298f, -0.35828844f, -0.44626042f, -0.39871702f, 0.37876362f, -0.00841808f, 0.08326002f, -0.31859228f, 
    -0.00835023f, 0.17170289f, -0.02044825f, -0.16414261f, 0.23435871f, 0.25588831f, -0.39663383f, -0.24475491f, 
    -0.02051038f, 0.19511008f, -0.00613093f, -0.51943892f, 0.07514836f, -0.01103605f, 0.01685904f, -0.06235183f, 
    -0.32650462f, -0.18749698f, -0.01187564f, -0.34044996f, -0.41125318f, -0.24659334f, -0.07957527f, 0.11995257f, 
    0.05468730f, -0.19810058f, 0.19399370f, 0.02362197f, -0.17439969f, 0.10896712f, 0.04562720f, -0.31742674f, 
    -0.19779228f, 0.24981433f, 0.35231912f, 0.44978103f, -0.18205895f, -0.43369630f, -0.23283246f, -0.05286098f, 
    0.68204540f, 0.22886108f, -0.00660339f, -0.25620577f, -0.07151048f, -0.40969869f, 0.07617737f, -0.06606309f, 
    -0.04955195f, 0.27827519f, -0.04008558f, -0.09724960f, -0.65281558f, -0.22630806f, -0.13588469f, -0.11623033f, 
    0.36685213f, 0.24898578f, -0.18681014f, -0.15534221f, 0.27593482f, 0.10232358f, 0.02735694f, 0.31199753f, 
    -0.02208319f, 0.16065864f, 0.16525690f, 0.09751219f, 0.19213846f, -0.05962138f, -0.16972370f, -0.30784518f, 
    -0.23200952f, -0.34547400f, -0.08535372f, -0.18566349f, -0.50836825f, -0.08438808f, -0.06066211f, 0.02052152f, 
    0.10782325f, -0.34554920f, 0.15906274f, -0.09626622f, -0.67210764f, -0.18964349f, 0.27594045f, -0.43851978f, 
    -0.01373979f, 0.33391872f, 0.18422359f, -0.02786998f, -0.12491056f, 0.03952266f, -0.33226642f, -0.09176596f, 
    -0.37539604f, -0.11704660f, -0.35148668f, 0.12477679f, 0.19327658f, -0.00412765f, 0.05965462f, 0.10559776f, 
    -0.27596143f, 0.32311606f, -0.03528824f, 0.25286487f, 0.07022683f, 0.07814997f, -0.31567690f, 0.17340527f, 
    0.21810251f, -0.07782587f, -0.10542776f, 0.04746922f, -0.41459897f, 0.24852398f, 0.03800795f, 0.00563721f, 
    -0.46662197f, -0.42729479f, -0.21696456f, -0.23634247f, 0.08856461f, -0.31686321f, -0.01583461f, 0.19991001f, 
    -0.26790008f, -0.29264107f, 0.19705918f, 0.23056774f, 0.06534459f, -0.42320871f, 0.52244091f, 0.03043992f, 
    -0.24237528f, -0.01508153f, -0.11748443f, -0.47777623f, -0.15811221f, -0.08796062f, -0.01635776f, -0.03845246f, 
    0.39546391f, 0.23384540f, -0.50592881f, 0.47861233f, -0.50764680f, 0.08258629f, 0.14036766f, -0.08955535f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01250761f, -0.02861175f, -0.09736380f, 0.00937060f, -0.09407463f, -0.05254531f, 0.06477775f, -0.11084763f, 
    0.00820636f, 0.03577912f, 0.06767767f, -0.00813915f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
