#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.71060985f, 0.69685870f, 0.70848900f, 0.07556102f, 0.52365583f, -0.50300151f, 0.43673003f, 0.15733546f, 
    -0.25308236f, 0.75597590f, 0.17738792f, 0.42453423f, 0.50915635f, 0.24028565f, 0.07571004f, -0.28987932f, 
    0.19536562f, -0.26758471f, -0.24745415f, -0.29573926f, 0.78870362f, 0.61577290f, 0.28238484f, -0.08454150f, 
    -0.35960069f, -0.29285762f, 0.38306561f, -0.81112838f, 1.02690971f, -0.37344798f, -0.18416519f, -0.01943859f, 
    -0.48658615f, -0.26464742f, -0.02366406f, 0.29684305f, -0.18528236f, 0.18591987f, -0.28988424f, -0.70410448f, 
    -0.16197696f, 0.65564668f, -0.30834502f, 0.14681421f, -0.22200875f, -0.80977464f, -0.77595007f, -0.64691716f, 
    -0.59436560f, -0.43191212f, 0.11742904f, -0.21801235f, 0.03061604f, -0.02099241f, -0.64299285f, -0.09224658f, 
    -0.80670792f, 0.58929557f, -0.37095228f, -0.39403576f, -0.00326409f, -0.09144077f, 0.50571942f, 0.76727360f, 
    0.73698759f, 0.17815508f, -0.50628823f, -0.63887507f, -0.01589687f, 0.41229144f, 0.04749841f, 0.07314666f, 
    -0.93591291f, -0.75142223f, -0.47945660f, -0.21997674f, 0.42364693f, 0.67977726f, 0.41033974f, -0.11193131f, 
    0.35246363f, 0.36934340f, 0.51519114f, 0.71778190f, -0.34432992f, 0.65094376f, 0.30611879f, -0.43466899f, 
    -0.46049362f, -0.57953107f, 0.23206493f, 0.14711402f, 0.01751820f, 0.45252913f, -0.46907142f, -0.52712601f, 
    -0.59514970f, -0.44573310f, -0.49664432f, 0.02335498f, -0.58773440f, 0.02335701f, -0.02594039f, -0.79755008f, 
    0.79602182f, -0.30868337f, -0.15670337f, -0.40482327f, 1.00933039f, -0.22154492f, 0.92751253f, -0.55138600f, 
    -0.33856741f, -0.21252856f, -0.32712179f, -0.29350156f, 0.10494734f, -0.33750895f, 0.63065040f, -0.44294912f, 
    0.95846754f, 0.72664571f, -0.12056226f, -0.04790125f, 0.06866351f, -0.32506931f, 0.24405032f, 0.77224952f, 
    0.57086784f, -0.41406366f, -0.21940036f, 0.53625107f, 0.00688583f, 0.00618026f, -0.47560522f, -0.20754573f, 
    -0.74207145f, -0.51024961f, 0.43017164f, 0.02846596f, 0.26751554f, -0.57755041f, 0.09579023f, -0.18901147f, 
    0.55592310f, -0.80659592f, -0.76992583f, -0.81138933f, -0.42629933f, 0.30864242f, 0.20918211f, -0.05697855f, 
    0.49789554f, 0.50359720f, -0.06605421f, 0.15805826f, -0.74218446f, -0.92008799f, -0.94467741f, -0.14088881f, 
    0.04771961f, 0.23709890f, -0.95033997f, 0.03473859f, 0.04720820f, -0.25986654f, -0.48224655f, -0.76038754f, 
    0.17782369f, -0.14328814f, -0.02702975f, 0.64223421f, -0.45667991f, 0.51080829f, -0.38774246f, 0.33197927f, 
    -0.31311989f, 0.51114237f, 0.27713066f, 0.05751243f, 0.72721678f, -0.61527586f, 0.49672180f, 0.87037909f, 
    0.17896444f, 0.13530342f, -0.05278216f, -0.27666828f, 0.04903233f, -0.39730072f, 0.63105708f, -0.68930465f, 
    -0.16126139f, 0.47694185f, -0.69911486f, 0.03121717f, -0.35780802f, -0.25999492f, -1.01758456f, 0.45453066f, 
    -0.02363147f, 0.42007655f, 0.66497964f, 0.55239093f, 0.15121098f, 0.07086764f, 0.38938025f, -0.10904120f, 
    -0.60558486f, -0.08444362f, 0.11760270f, -0.76460034f, 0.37907284f, -0.43004996f, 0.03941933f, 0.42730138f, 
    0.66905683f, 0.49170470f, 0.38414568f, -0.20732187f, -0.04746501f, 0.40546671f, -0.56147087f, 0.42976317f, 
    0.38315544f, 0.40643668f, -0.03868582f, 0.72550184f, 0.32203269f, -0.86463523f, 0.08060373f, 0.20969954f, 
    0.00533161f, -0.27837756f, -0.52655190f, -0.41553909f, -0.42123654f, 0.10398828f, 0.67207199f, -0.77431983f, 
    -0.28932893f, 0.43033016f, 0.31096080f, -0.34596059f, -0.85228693f, -0.60636795f, 0.40880415f, 0.34741926f, 
    -0.10919351f, 0.48868203f, -0.39489827f, -0.39707682f, 0.50555789f, 0.28501743f, 0.48033309f, 0.41493896f, 
    -0.48741475f, 0.00985169f, 0.17153862f, 0.58589137f, 0.11065473f, -0.21258667f, -0.76042873f, -0.59579325f, 
    -0.49960211f, 0.61885124f, 0.63912690f, -0.32635418f, -0.20899025f, -0.43628255f, -0.55249947f, -0.44000480f, 
    -0.56781083f, 0.02722304f, 0.32598445f, 0.69764107f, -0.20793763f, -0.24165858f, -0.01721152f, -0.30272767f, 
    -0.21131191f, -0.36777145f, -0.34322006f, 0.98744690f, -0.43235698f, -0.09069320f, -0.44513994f, -0.03157204f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.41287854f, 0.16606930f, -0.06939327f, -0.03932427f, 0.14431602f, 0.10157378f, 0.16599506f, 0.21439414f, 
    -0.09252281f, 0.02706334f, -0.00499275f, -0.16380377f, -0.04561478f, -0.21797317f, 0.17530373f, -0.32415178f, 
    0.05648427f, 0.30651045f, 0.24158600f, 0.06584852f, -0.02241919f, 0.12896074f, 0.18881790f, -0.10640428f, 
    -0.20881350f, -0.06196356f, 0.01777136f, 0.23926051f, -0.38503304f, -0.16448343f, 0.00485923f, -0.26504040f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03393464f, 0.02349306f, 0.00872929f, 0.02052821f, 0.01436208f, -0.01662306f, 0.04584188f, -0.04774087f, 
    0.01459207f, 0.02255353f, -0.01002452f, -0.01797307f, -0.03667976f, -0.01389282f, -0.02079981f, -0.02490378f, 
    -0.02313588f, 0.00550620f, 0.00184408f, -0.00150146f, 0.01251878f, -0.02521846f, -0.03326961f, 0.01960758f, 
    0.02933471f, -0.00088951f, 0.04991795f, -0.02542309f, 0.00822596f, 0.00911961f, 0.02160203f, -0.06269898f, 
    0.02310030f, 0.04989271f, -0.03613564f, 0.00806206f, 0.02225359f, 0.04521931f, -0.00005284f, 0.01182821f, 
    -0.02212230f, -0.03651581f, -0.03382153f, -0.01863275f, 0.00970381f, -0.00831362f, 0.04998849f, 0.00714814f, 
    -0.03218286f, 0.04659852f, -0.00867323f, 0.00204634f, -0.02326830f, -0.04321811f, -0.04405531f, -0.01140724f, 
    -0.00080714f, -0.02146257f, 0.03902629f, -0.00273662f, -0.04454077f, -0.05350118f, 0.03188279f, 0.01737443f, 
    -0.04537174f, -0.06474312f, -0.00589461f, -0.04591335f, 0.03154985f, -0.03115295f, -0.04970400f, -0.02158083f, 
    0.02042717f, 0.05704440f, -0.02947234f, 0.05111251f, -0.03550480f, -0.00272092f, 0.01873563f, -0.03417247f, 
    -0.01421170f, 0.02711437f, -0.05198102f, -0.01598786f, 0.00675439f, 0.03308075f, 0.04631740f, -0.03262821f, 
    -0.03152409f, 0.01001096f, 0.02885033f, 0.01571875f, -0.04395908f, -0.04617457f, -0.03391527f, -0.04521279f, 
    -0.03962541f, -0.03836084f, 0.03657544f, 0.00658842f, 0.01680883f, 0.05245315f, 0.00290806f, -0.02014722f, 
    -0.03104562f, 0.04664198f, -0.04597435f, 0.03391481f, 0.00442361f, -0.05956197f, -0.00919791f, 0.00340741f, 
    0.02902554f, 0.02271215f, 0.02140083f, -0.05562859f, -0.02523511f, -0.01483438f, 0.03368286f, -0.05120600f, 
    0.04443892f, 0.04977810f, -0.01402416f, -0.06556173f, -0.05838760f, 0.03105673f, 0.02536996f, 0.01248242f, 
    0.01726882f, -0.03981172f, -0.02508545f, -0.04578955f, -0.06273082f, -0.01227523f, 0.02202978f, -0.02820238f, 
    -0.04626102f, 0.03724331f, -0.02101747f, -0.00811866f, -0.02406686f, 0.01774455f, 0.00861090f, 0.00747674f, 
    -0.02095362f, 0.01422940f, 0.03706289f, 0.04698585f, 0.05284173f, 0.04285081f, 0.00984138f, 0.02045264f, 
    -0.02469039f, -0.05793493f, 0.01271663f, 0.04914388f, 0.03823429f, -0.04228200f, -0.06067219f, -0.03322240f, 
    0.00514387f, -0.00679690f, 0.00757727f, -0.01094939f, 0.02105375f, -0.03019816f, -0.04008421f, 0.04383799f, 
    0.00299214f, 0.04658340f, 0.01990390f, -0.03917614f, 0.00294736f, -0.06225027f, 0.02281166f, 0.01061187f, 
    -0.05750282f, -0.06557300f, 0.02166878f, -0.01887499f, -0.01345529f, 0.03220067f, 0.03356760f, -0.04096223f, 
    0.02067904f, -0.04686304f, -0.01505158f, -0.01329411f, 0.03246526f, 0.04486197f, -0.01699010f, 0.05145938f, 
    -0.03149992f, 0.01058613f, -0.03391326f, -0.04320588f, 0.03989119f, -0.02444848f, -0.02658394f, 0.00138783f, 
    -0.00627304f, -0.05040044f, -0.05047644f, 0.05076626f, 0.04586468f, 0.02374010f, 0.02432490f, -0.00607435f, 
    -0.05871198f, -0.00005625f, -0.02875372f, 0.02175563f, -0.00710813f, -0.00516222f, 0.03285667f, 0.02421534f, 
    0.04157824f, -0.02497340f, -0.04373112f, -0.04055714f, -0.02791886f, 0.04865696f, -0.04558169f, -0.04548401f, 
    0.04024246f, -0.00138879f, -0.03599172f, 0.01059069f, 0.00360597f, 0.02738952f, -0.01059760f, -0.00016965f, 
    -0.04600471f, 0.03639487f, -0.03208651f, 0.03996435f, -0.06080921f, 0.04617332f, 0.03102627f, -0.03369093f, 
    -0.04484815f, 0.04875491f, -0.03794741f, -0.05196711f, 0.04839662f, 0.00007329f, -0.05897865f, -0.06136192f, 
    -0.06160436f, -0.03505708f, 0.02005147f, 0.00559056f, -0.01834637f, -0.02035063f, -0.06217355f, -0.06183713f, 
    -0.01724931f, -0.04080798f, -0.05857661f, -0.04643892f, -0.06316003f, 0.01365050f, 0.02026755f, 0.00320433f, 
    0.03564496f, 0.00355252f, -0.01318499f, 0.01089508f, 0.05263472f, 0.02853681f, -0.02907929f, 0.01632450f, 
    0.02283845f, 0.03187749f, 0.02799086f, 0.00503395f, -0.04496391f, -0.01951601f, -0.02714408f, -0.01237386f, 
    -0.06181583f, -0.05792041f, 0.02974070f, -0.02503734f, 0.04310644f, -0.01731279f, -0.04374033f, 0.00370468f, 
    -0.05994526f, -0.00186047f, 0.01733771f, -0.06017590f, -0.04136383f, 0.04273951f, -0.03419007f, 0.00654588f, 
    0.02815734f, -0.05190761f, -0.04438798f, -0.01475625f, -0.00086471f, 0.02563250f, -0.05234291f, -0.03753538f, 
    0.00346396f, 0.04985349f, -0.06126158f, 0.03206330f, -0.05727814f, -0.06465207f, 0.03750030f, 0.00201904f, 
    -0.05538384f, 0.04087768f, 0.02842713f, -0.00406615f, 0.01221044f, -0.02311483f, 0.02629456f, -0.04926483f, 
    0.03596241f, -0.05747728f, -0.06504086f, 0.02750957f, -0.05998163f, 0.02095025f, -0.04109998f, 0.04722645f, 
    -0.04160989f, 0.02270412f, -0.01091987f, -0.00373109f, -0.01742219f, -0.00557855f, -0.03595337f, -0.05765241f, 
    0.00251282f, 0.01424501f, -0.06513966f, -0.03128167f, 0.01121479f, 0.03827019f, -0.04987618f, -0.00258159f, 
    -0.05372332f, 0.01439535f, -0.06595057f, 0.03031040f, -0.02776985f, -0.01384756f, -0.06206175f, 0.04264409f, 
    -0.02190638f, -0.02006271f, -0.06111664f, 0.04600856f, 0.00132335f, 0.04049280f, -0.02030048f, 0.01494470f, 
    -0.02429386f, -0.02237489f, 0.01927204f, 0.01814074f, -0.00010763f, 0.03781501f, -0.02001262f, -0.00257364f, 
    -0.04640429f, 0.03192631f, 0.01414536f, 0.01395566f, 0.00084458f, -0.02723179f, 0.00227988f, 0.03964917f, 
    0.00590766f, 0.02713580f, -0.03445096f, -0.00960667f, -0.04321957f, 0.00372838f, 0.03133311f, 0.00353926f, 
    -0.00265970f, 0.01749493f, -0.00584766f, -0.03321498f, -0.04770885f, 0.00233585f, -0.02891542f, -0.03139058f, 
    -0.06522080f, 0.02993404f, -0.02383158f, -0.04792231f, -0.05638384f, -0.01156049f, 0.05339022f, -0.00845712f, 
    -0.01616459f, 0.01739700f, 0.03422863f, -0.06079873f, -0.01903215f, -0.03688775f, 0.01371507f, -0.04335313f, 
    0.03189180f, 0.01660915f, -0.00375970f, 0.04248664f, -0.00246019f, -0.05856286f, 0.00089425f, 0.02270721f, 
    0.00672986f, -0.02511134f, -0.01111152f, -0.04546371f, 0.02832279f, 0.03428026f, -0.03832757f, 0.02121907f, 
    -0.00360783f, -0.06583969f, 0.01457930f, -0.00661068f, 0.04486118f, -0.04155971f, -0.02868743f, -0.05756205f, 
    -0.05090902f, 0.02874226f, -0.06175029f, 0.00149274f, 0.01780767f, -0.00311826f, 0.01399901f, -0.00161992f, 
    -0.04496024f, -0.05553200f, 0.01324602f, -0.05758583f, -0.05310141f, -0.00784182f, 0.03836362f, -0.00630226f, 
    -0.00208397f, -0.03972643f, -0.02700617f, 0.04814886f, -0.06089760f, -0.03007068f, -0.06213027f, 0.03117274f, 
    -0.01388586f, -0.03346082f, 0.00053586f, 0.03906548f, 0.03692596f, -0.05568120f, -0.03795952f, -0.01277329f, 
    -0.02076883f, -0.06274763f, 0.01114231f, 0.04334588f, -0.05897375f, 0.04461806f, 0.04983742f, -0.05688843f, 
    0.02559191f, -0.00868860f, -0.03221567f, 0.00776450f, 0.00763472f, 0.00119022f, -0.01747671f, 0.00706490f, 
    -0.06614561f, 0.04254760f, 0.04672506f, 0.04219721f, -0.04655237f, -0.05860959f, 0.04520650f, 0.03174626f, 
    0.03609265f, 0.00781608f, -0.02936438f, -0.05242809f, -0.01647068f, 0.03633782f, -0.05637005f, -0.03215253f, 
    -0.01349504f, -0.04062506f, -0.00351481f, 0.03225745f, 0.04081054f, 0.00685854f, -0.06108512f, 0.00671476f, 
    -0.02918822f, -0.04234925f, 0.02417129f, -0.00456040f, 0.04021566f, 0.00974311f, -0.05607659f, -0.05132641f, 
    -0.04355553f, 0.04103590f, 0.01436237f, -0.04494085f, -0.01543144f, -0.01570402f, -0.00785984f, -0.02629401f, 
    -0.02747404f, -0.04127063f, -0.06760410f, 0.01281111f, 0.00299998f, 0.02150477f, 0.04482293f, -0.01765276f, 
    -0.06763726f, 0.00484041f, -0.04787893f, -0.04357278f, -0.06370585f, 0.04314735f, -0.02028145f, -0.01339431f, 
    0.04338986f, -0.06300535f, -0.01608526f, 0.00313367f, 0.00628453f, 0.02346343f, 0.04305599f, 0.03353072f, 
    0.01707839f, 0.03164961f, 0.03831879f, -0.03346025f, -0.05495199f, 0.02604061f, 0.04606282f, 0.04744876f, 
    0.01018525f, -0.04530722f, 0.01697944f, -0.01465084f, -0.03922490f, -0.01632765f, 0.02450581f, 0.03331161f, 
    -0.04342710f, 0.04518598f, 0.00408595f, 0.00155729f, -0.00201032f, -0.02814986f, 0.04861729f, 0.00192443f, 
    -0.02906214f, 0.01535834f, 0.03910194f, -0.03957846f, 0.02999675f, -0.06033038f, -0.05409245f, -0.01658089f, 
    -0.00572134f, -0.06543040f, 0.03858521f, 0.00666953f, -0.04654057f, -0.06256577f, 0.04384661f, 0.03877473f, 
    -0.00198797f, 0.03342393f, 0.00558157f, -0.00738727f, -0.04062427f, 0.03227593f, 0.02667421f, 0.00219390f, 
    0.02063108f, 0.03744005f, 0.03888570f, 0.04409884f, 0.03815473f, 0.02469293f, 0.00615340f, 0.05713194f, 
    -0.06075537f, 0.02480473f, 0.03013431f, -0.03638986f, 0.01786161f, 0.04445694f, -0.01763099f, -0.05236144f, 
    0.00757116f, -0.04924657f, -0.04106063f, 0.00979632f, 0.02983373f, -0.05388596f, -0.01001850f, -0.03563846f, 
    0.02828052f, -0.01747120f, 0.02980277f, 0.00538639f, -0.04584378f, -0.01413158f, -0.02423559f, -0.06023490f, 
    -0.00365443f, 0.01920218f, 0.00014745f, 0.00112847f, -0.03045893f, -0.03418272f, -0.05527351f, -0.05048487f, 
    -0.01384756f, -0.00912482f, -0.02073572f, -0.00779045f, 0.02725928f, -0.01511400f, -0.00382388f, 0.02873422f, 
    0.04784998f, 0.01676857f, 0.04227917f, 0.02419034f, 0.00486403f, -0.06242376f, -0.01005016f, -0.05015643f, 
    0.03131071f, -0.02140740f, 0.03484805f, 0.00264549f, 0.01760353f, 0.03580872f, -0.05641936f, -0.01009868f, 
    -0.05586733f, 0.02601804f, -0.05697497f, 0.01385873f, 0.04751044f, 0.00692297f, -0.02902301f, 0.01944247f, 
    0.00499152f, -0.02382993f, -0.01303632f, 0.03060579f, -0.02341571f, 0.02042306f, -0.00935862f, 0.04693840f, 
    -0.00378040f, 0.00648299f, 0.04670745f, -0.00810757f, -0.01220403f, 0.02747524f, 0.00543667f, -0.04376277f, 
    0.03590368f, -0.00449047f, -0.00947055f, 0.02834838f, -0.06110899f, -0.06369397f, -0.00281183f, -0.02920490f, 
    0.01230341f, 0.03414806f, -0.00462669f, 0.04228117f, -0.02007646f, -0.05388704f, -0.00009239f, 0.04954239f, 
    -0.02012207f, -0.01396338f, -0.05108123f, 0.00322301f, -0.01704353f, -0.02098759f, 0.02957321f, 0.00463609f, 
    -0.01464180f, -0.03879718f, -0.00030695f, -0.05205273f, 0.04312972f, 0.00963065f, -0.06549925f, -0.00753446f, 
    -0.03208862f, -0.05850258f, -0.00760995f, 0.01690496f, -0.01666362f, -0.04856681f, 0.01323477f, -0.06405367f, 
    -0.04973024f, -0.05288982f, 0.02598277f, -0.04426942f, -0.01674021f, 0.01411825f, 0.01944613f, 0.02074191f, 
    0.03534835f, -0.05915196f, 0.00865739f, -0.05264988f, 0.03739939f, -0.02544546f, -0.02777866f, 0.04533131f, 
    -0.01377365f, -0.01025500f, -0.02899106f, -0.01615450f, 0.01186417f, -0.02672486f, -0.06517372f, -0.01861603f, 
    -0.00172819f, -0.02189718f, -0.03597366f, -0.06768923f, -0.06548212f, 0.01668518f, -0.01157235f, 0.01051930f, 
    -0.05890051f, 0.03837527f, 0.05068243f, 0.04316685f, 0.01146603f, -0.01634758f, 0.05069951f, -0.02301043f, 
    -0.01773295f, -0.05922873f, 0.04152892f, 0.00848819f, 0.02106635f, 0.01595778f, -0.00975112f, 0.01534010f, 
    -0.00805796f, -0.06015730f, 0.03849260f, -0.05286498f, -0.05444479f, 0.01634565f, 0.01539121f, -0.05919294f, 
    -0.01958617f, -0.05408949f, -0.06218439f, 0.04091690f, -0.02301879f, 0.04608867f, -0.01602346f, -0.02600183f, 
    -0.01544307f, 0.01111287f, 0.04509155f, -0.04642430f, 0.03370266f, -0.01631625f, -0.00715848f, 0.01519817f, 
    -0.03736951f, -0.03411756f, -0.01676758f, -0.05342376f, 0.05106077f, -0.03840698f, -0.01683288f, 0.02251935f, 
    -0.01131602f, 0.03433497f, 0.03619221f, -0.01975717f, -0.04704845f, -0.04141745f, 0.00587207f, -0.05590317f, 
    -0.01358078f, -0.03259365f, -0.03182453f, -0.03688416f, 0.02463883f, 0.03371284f, -0.05492649f, 0.01270258f, 
    0.02911809f, -0.03563077f, -0.00399574f, 0.00336993f, 0.00686859f, -0.01134242f, 0.00295089f, -0.02972826f, 
    0.04921670f, -0.02344548f, -0.00539779f, 0.01076561f, -0.02273018f, -0.02364380f, 0.00695372f, -0.00748460f, 
    0.04187669f, 0.04768413f, -0.01996286f, 0.00054927f, -0.05819481f, -0.05574322f, 0.05410686f, 0.01420173f, 
    0.04277593f, -0.00574413f, -0.04377654f, 0.04120002f, -0.01666569f, 0.01642501f, -0.01973982f, -0.01946296f, 
    -0.01275556f, -0.02973550f, -0.02758611f, -0.05845929f, 0.03335594f, -0.03390150f, 0.04415271f, -0.07474645f, 
    -0.01222393f, 0.00341761f, -0.06076693f, -0.06213300f, 0.00267849f, 0.02600300f, 0.02432340f, -0.01667062f, 
    0.04408557f, 0.00219645f, 0.01351335f, 0.02317458f, -0.01536776f, -0.01477163f, 0.02248615f, 0.02086397f, 
    0.01718640f, 0.01453326f, 0.05096566f, -0.03312864f, -0.04847445f, -0.05667410f, 0.00454463f, 0.03916162f, 
    0.00555735f, 0.02224399f, -0.02124017f, -0.04790313f, -0.02735249f, -0.03258082f, 0.04000669f, -0.03283903f, 
    0.03851492f, -0.06137218f, -0.03161330f, 0.04095483f, 0.03729971f, -0.02033404f, 0.01964473f, 0.02942869f, 
    0.02827694f, 0.02622875f, -0.00792549f, -0.03381475f, -0.05233546f, 0.01285996f, 0.04981328f, 0.01765687f, 
    0.00900490f, 0.01418653f, -0.05537954f, -0.00794248f, 0.00351780f, 0.00779774f, -0.04949746f, -0.02424132f, 
    -0.05068861f, -0.03916863f, -0.03543854f, 0.00216410f, 0.02614291f, -0.00701715f, -0.06020175f, 0.00811645f, 
    0.02920308f, 0.01730764f, 0.00873291f, 0.02639494f, 0.03757599f, -0.01811661f, -0.04063029f, -0.05702111f, 
    -0.05534095f, 0.00609259f, -0.03927714f, -0.06131709f, -0.01252647f, 0.00544726f, -0.05981071f, 0.03081913f, 
    -0.05346206f, 0.00325534f, -0.03845998f, 0.04564821f, 0.01130797f, 0.02836316f, -0.02518565f, -0.03867542f, 
    -0.03684241f, -0.05485637f, 0.04368518f, -0.04361784f, -0.02003509f, -0.04642252f, 0.01689468f, 0.00084906f, 
    -0.03234645f, 0.01720956f, -0.01045988f, 0.04598711f, 0.00070710f, 0.01479497f, 0.05038632f, -0.01754892f, 
    -0.00972102f, 0.05440487f, -0.06219802f, -0.03444806f, -0.05589251f, 0.03603830f, -0.03401669f, -0.04814450f, 
    -0.00073825f, -0.01783251f, 0.04352713f, -0.06571235f, -0.00089838f, 0.03785187f, 0.01013431f, -0.01097587f, 
    0.03070889f, -0.01869252f, 0.04624500f, 0.04995516f, -0.02916867f, 0.00822209f, 0.04931300f, -0.00976179f, 
    -0.05106284f, -0.00612597f, -0.06397732f, -0.00221403f, 0.01376972f, -0.03516182f, 0.03390719f, -0.03466371f, 
    0.01163470f, 0.01065627f, -0.04669922f, -0.03069156f, 0.04863639f, -0.01320997f, -0.01571717f, -0.02486616f, 
    0.03058010f, -0.03114131f, -0.01356139f, 0.03401015f, -0.05656398f, -0.05557682f, 0.01319194f, -0.00739309f, 
    -0.00860384f, 0.00042115f, 0.00969309f, -0.03776891f, -0.00712616f, -0.01487401f, 0.00210117f, -0.05808794f, 
    -0.02434186f, 0.00414479f, 0.03317849f, 0.01545649f, 0.03264141f, -0.00575391f, 0.03034267f, 0.04016040f, 
    -0.04660727f, 0.02329460f, -0.04255215f, -0.04366101f, -0.04683018f, 0.00343320f, -0.03180686f, -0.00800406f, 
    -0.00055063f, -0.03460288f, -0.01942784f, -0.00530512f, 0.01298163f, -0.02131413f, 0.02347042f, -0.03172212f, 
    0.01287392f, 0.02462220f, 0.02083769f, -0.05415315f, 0.00743031f, -0.00952900f, 0.03533248f, -0.04310783f, 
    0.02230893f, -0.03749819f, 0.01628585f, 0.02703805f, -0.06519307f, 0.04922512f, -0.01665210f, -0.05105158f, 
    -0.05384077f, -0.04053812f, -0.05719484f, -0.04717903f, 0.01090494f, -0.02672517f, -0.03577199f, -0.00816176f, 
    0.03167727f, 0.04178382f, 0.01366928f, 0.05346660f, -0.02547690f, -0.05512814f, 0.01101580f, 0.01550028f, 
    -0.03692566f, 0.04157698f, -0.00904380f, 0.04933050f, 0.01684608f, 0.04495328f, -0.06293433f, 0.04094339f, 
    -0.06128117f, 0.04689530f, 0.03135745f, -0.03916209f, -0.06253892f, 0.01569588f, 0.02081990f, -0.04954898f, 
    -0.06847186f, -0.03829667f, 0.02378276f, -0.02487553f, 0.03669460f, 0.03709152f, 0.04923454f, 0.01862339f, 
    -0.02001221f, -0.05488151f, -0.06506473f, -0.01477148f, -0.04681759f, 0.02452391f, -0.00461362f, 0.02769581f, 
    -0.03999165f, -0.03144696f, 0.04224854f, -0.00149547f, -0.06713118f, 0.00893391f, 0.01503332f, -0.04072053f, 
    0.01198214f, 0.00510875f, -0.06168531f, -0.03559266f, -0.04801346f, 0.00937621f, -0.05971619f, -0.06529279f, 
    0.04854596f, -0.01307812f, -0.03734774f, -0.02518353f, -0.01826019f, 0.01631474f, -0.03099478f, -0.05617388f, 
    0.03263315f, 0.01183196f, -0.04487205f, -0.04088463f, -0.04643286f, 0.00092586f, 0.01214044f, -0.03044397f, 
    0.05034107f, -0.00930780f, -0.00452021f, -0.04062656f, 0.02046557f, -0.04805037f, -0.01120179f, -0.03506659f, 
    0.05028406f, -0.01915037f, 0.02007062f, -0.04016284f, -0.05358061f, -0.00654852f, 0.04935530f, -0.01424899f, 
    -0.04763345f, -0.05385585f, -0.05128812f, 0.05184109f, 0.05789369f, 0.08710154f, 0.00820358f, 0.06839757f, 
    0.08311003f, -0.04639363f, 0.05880489f, 0.08524904f, 0.08508146f, 0.02599897f, -0.12138437f, -0.04451903f, 
    0.14620650f, -0.04650742f, -0.20356664f, -0.06327017f, 0.06846392f, -0.13876094f, 0.03139729f, 0.04831107f, 
    -0.04179810f, 0.10134196f, 0.23472410f, -0.06767661f, -0.28045112f, -0.02720251f, -0.02397220f, 0.01967801f, 
    0.17095394f, -0.12873371f, -0.05309489f, -0.09387133f, -0.04619995f, 0.03083372f, 0.06142566f, 0.20897189f, 
    -0.08844172f, 0.06574486f, 0.10507473f, 0.03918185f, -0.04060614f, -0.10701445f, 0.05861111f, 0.10084194f, 
    0.08882900f, 0.19158652f, -0.00048678f, -0.05881216f, 0.01415608f, -0.12380280f, -0.08988879f, 0.11717509f, 
    -0.00641676f, 0.08836602f, 0.06058901f, 0.08541931f, -0.00751697f, -0.19983573f, -0.05426577f, 0.17754243f, 
    0.09190456f, 0.03540128f, -0.02763385f, -0.05362037f, 0.17921397f, -0.05214073f, 0.08294690f, 0.03161940f, 
    0.05385286f, -0.07126891f, -0.12103206f, -0.26099151f, 0.07353906f, -0.00351312f, 0.12803949f, 0.03378268f, 
    -0.19295713f, -0.08024725f, -0.15543512f, -0.01867893f, 0.14555170f, 0.00457689f, -0.05306003f, -0.04484377f, 
    0.15764913f, -0.17146245f, -0.02840461f, -0.01571758f, 0.05843291f, -0.05034192f, 0.07607675f, 0.08700841f, 
    0.07557496f, 0.03585344f, 0.04081237f, -0.10463887f, 0.29319158f, 0.17106757f, 0.03598822f, 0.01343801f, 
    -0.16012864f, 0.15678796f, 0.07630139f, 0.03470511f, -0.11042742f, -0.11127613f, -0.09299387f, -0.07618108f, 
    0.00865299f, 0.03813512f, -0.19871023f, -0.20484433f, 0.06392080f, -0.15280099f, -0.14131750f, 0.00945031f, 
    0.01504879f, 0.01486936f, -0.37183478f, 0.05042572f, -0.04073114f, 0.05869268f, 0.03468896f, 0.06010462f, 
    -0.05738903f, -0.01533195f, -0.20564812f, -0.00035648f, -0.00592751f, -0.00806711f, 0.07293347f, 0.18347153f, 
    0.08479576f, -0.23219129f, 0.00609789f, 0.14557242f, -0.17753898f, -0.08993074f, -0.02990137f, -0.04615708f, 
    -0.27140999f, -0.14127132f, 0.22717234f, 0.16606019f, 0.02499373f, 0.12176009f, 0.07382499f, 0.00523171f, 
    0.02430205f, 0.07441292f, 0.05258617f, -0.04371902f, 0.00842674f, 0.10402807f, 0.27837607f, -0.13533065f, 
    -0.08977284f, -0.00875420f, 0.10315177f, -0.11147777f, -0.03904187f, 0.00234453f, 0.10891760f, 0.30229175f, 
    0.00084577f, 0.08192521f, -0.30362228f, 0.02663331f, 0.01201872f, -0.02937320f, 0.21806732f, -0.16411927f, 
    0.09703094f, -0.02885681f, -0.08744652f, 0.05069907f, -0.01710954f, 0.06809149f, 0.29942480f, -0.05620769f, 
    0.05289249f, -0.07440631f, 0.16003804f, 0.11727113f, 0.13101749f, -0.03803614f, -0.02725681f, 0.17327976f, 
    0.09060652f, 0.00215667f, 0.16569406f, 0.11264910f, -0.07015371f, -0.03432105f, -0.20301114f, 0.04391341f, 
    -0.14479697f, -0.06908713f, 0.04772227f, -0.16226040f, 0.08375490f, 0.05390330f, 0.02739154f, -0.04865813f, 
    0.06390116f, 0.15165770f, 0.01843516f, 0.14217095f, 0.00549937f, -0.02899228f, 0.05965932f, 0.16382606f, 
    0.03831573f, -0.03387800f, -0.17463262f, 0.04253766f, 0.02696876f, -0.18620920f, -0.05029936f, 0.08456132f, 
    0.13826060f, 0.03449219f, 0.11573318f, 0.23957257f, -0.06430148f, -0.05898260f, 0.15693173f, 0.01999693f, 
    0.15790379f, 0.12358826f, -0.16545901f, 0.08709180f, -0.03361599f, -0.04805044f, 0.13798152f, 0.16047575f, 
    0.06522017f, -0.03048100f, -0.13518003f, 0.11092450f, 0.05487856f, -0.18283482f, 0.00866580f, -0.00293155f, 
    0.01323872f, 0.21754156f, -0.00390914f, -0.05838603f, 0.06730495f, 0.12607221f, 0.06766710f, -0.18616898f, 
    -0.14512920f, 0.13266285f, -0.02013526f, 0.16760111f, -0.00550758f, -0.02144488f, 0.05866515f, -0.15210199f, 
    0.07030630f, -0.12212655f, -0.16241510f, 0.06476329f, -0.00832975f, -0.34960628f, 0.15281911f, 0.16822110f, 
    -0.11407985f, -0.11498790f, -0.01537818f, -0.18898447f, -0.00343126f, -0.04595135f, -0.10047345f, 0.06223076f, 
    -0.11782775f, -0.10342253f, 0.20056519f, 0.10237860f, 0.02528033f, 0.17863618f, -0.11588947f, -0.19177477f, 
    0.17752929f, -0.05163718f, 0.23714070f, -0.15397811f, -0.09793410f, 0.01711252f, -0.02924879f, 0.11854430f, 
    -0.12653334f, -0.05857840f, 0.18198347f, 0.15422681f, 0.03849256f, 0.10530836f, -0.04977004f, 0.02385058f, 
    0.18387404f, -0.08268867f, -0.26719603f, -0.03198356f, 0.12422120f, -0.08825446f, 0.04781489f, 0.08888312f, 
    0.02632753f, 0.01531055f, 0.08411385f, -0.06591500f, -0.05486911f, -0.23606662f, 0.19214337f, 0.07128055f, 
    0.15157223f, -0.19192198f, -0.00594724f, 0.13391413f, -0.19374780f, -0.16511542f, -0.31802687f, 0.04593665f, 
    -0.04538536f, -0.02204914f, -0.03688788f, -0.03497503f, 0.01942380f, 0.15855052f, -0.16257513f, 0.16908757f, 
    0.09664203f, -0.04132603f, 0.05405825f, -0.17946790f, -0.07330558f, 0.08660167f, 0.04907157f, 0.15497336f, 
    -0.19020835f, 0.10930613f, 0.13360249f, -0.11467913f, -0.04688679f, 0.01512773f, -0.04543456f, 0.15667935f, 
    -0.03826967f, -0.11894523f, -0.02755858f, -0.20448594f, 0.04156649f, -0.02045426f, -0.05388842f, 0.14537376f, 
    0.46271062f, 0.22854012f, 0.14373395f, -0.01880872f, 0.05299560f, -0.01512056f, -0.04544456f, -0.13478704f, 
    -0.12100112f, 0.04391141f, 0.23678781f, -0.20653899f, 0.09515775f, 0.06060958f, 0.08431377f, -0.09702664f, 
    0.11295876f, -0.04306512f, -0.04987283f, 0.01696439f, 0.00191855f, 0.06872636f, 0.04268622f, 0.07498853f, 
    0.01114385f, 0.02905702f, -0.09323753f, -0.30530551f, 0.16539006f, -0.09666213f, 0.13174613f, 0.02643960f, 
    0.02401408f, -0.02743168f, -0.22567970f, -0.02582805f, -0.18829690f, 0.06684548f, -0.07624536f, 0.03536605f, 
    -0.01045414f, 0.05223706f, -0.04806906f, -0.17016640f, -0.04729877f, -0.16998014f, -0.40543020f, 0.09254927f, 
    -0.09624785f, -0.05347775f, -0.09067898f, 0.02236781f, -0.05628559f, -0.05396909f, -0.05031819f, 0.17087236f, 
    -0.21897794f, -0.01749367f, 0.01557297f, 0.02553138f, 0.03472650f, 0.12390427f, -0.07328442f, 0.18341386f, 
    -0.26323938f, 0.00955292f, -0.11365052f, -0.05906973f, -0.11378288f, 0.14284495f, 0.02642885f, 0.09784229f, 
    -0.02841652f, -0.35378259f, 0.14752148f, -0.03029952f, 0.05142538f, 0.11587531f, 0.08740220f, 0.00764527f, 
    -0.14243807f, -0.03854821f, 0.04254863f, -0.21552156f, -0.04580902f, 0.07052683f, 0.08691660f, 0.07584392f, 
    0.10954416f, 0.11194082f, -0.05656080f, 0.15120739f, -0.20460321f, 0.10238287f, 0.00500367f, 0.19968392f, 
    -0.06762023f, 0.05676262f, 0.02561612f, 0.08463092f, -0.10120039f, -0.02341802f, -0.00691151f, -0.06728627f, 
    -0.00378577f, -0.08408727f, 0.01619524f, -0.07207154f, -0.15765965f, -0.11864369f, 0.25432682f, -0.01732452f, 
    0.14310211f, -0.13364409f, 0.20981306f, 0.00723484f, 0.04622071f, 0.22814940f, -0.37895975f, -0.47662619f, 
    -0.03506559f, 0.01268463f, 0.02850692f, -0.10083789f, 0.07073113f, 0.05349743f, 0.02676241f, 0.10265301f, 
    -0.16756226f, -0.03239195f, 0.06801724f, 0.04099628f, 0.01957903f, -0.05068197f, -0.01262830f, -0.36213961f, 
    0.10496815f, 0.07951576f, -0.08726054f, 0.08427012f, 0.05674943f, -0.04623705f, -0.02833011f, -0.04084646f, 
    0.07546019f, 0.17853391f, -0.00861601f, -0.06021775f, 0.02866480f, 0.02859655f, -0.08734050f, -0.15374601f, 
    0.11342515f, -0.05473579f, 0.30440915f, 0.25722405f, -0.20111127f, 0.03505815f, -0.14110841f, -0.05665021f, 
    0.10470048f, 0.01553537f, -0.06183434f, -0.21652012f, -0.29660341f, 0.16689885f, 0.07314634f, 0.10930820f, 
    0.09670562f, 0.09828945f, 0.07032186f, 0.22416319f, -0.04884499f, -0.09556789f, 0.05782980f, -0.09348078f, 
    -0.11326636f, 0.18420874f, -0.06101163f, -0.12535855f, -0.14931320f, 0.09159680f, 0.07865408f, -0.32112193f, 
    0.01001894f, -0.06893977f, -0.00420224f, 0.09503224f, -0.08314922f, 0.13586606f, -0.26736897f, -0.06826628f, 
    0.08517421f, -0.03237322f, 0.03304631f, 0.13888934f, -0.08086976f, 0.02807960f, 0.40058428f, 0.03456132f, 
    -0.22050825f, 0.03540945f, -0.04928797f, -0.06754521f, 0.06216026f, 0.07302090f, 0.01102229f, 0.15635085f, 
    -0.37198773f, -0.30588242f, 0.08361736f, 0.11118529f, 0.14596957f, 0.00612608f, -0.00474764f, -0.23940994f, 
    0.07169624f, 0.15513964f, -0.02406000f, 0.11063250f, 0.10207646f, 0.10014440f, 0.08785594f, 0.10516743f, 
    0.07920516f, 0.08335317f, 0.07286017f, -0.10022620f, 0.08320083f, 0.02138050f, 0.02274807f, 0.05576005f, 
    0.18912308f, 0.07554313f, 0.14703982f, -0.02102370f, 0.04561579f, -0.13930681f, -0.04151766f, -0.03899935f, 
    0.09726162f, -0.02194427f, 0.20109306f, -0.00778047f, -0.17724369f, -0.26783186f, 0.10729720f, 0.07927477f, 
    -0.05230090f, -0.00317526f, 0.12364540f, -0.09723863f, 0.04866014f, -0.00249049f, -0.05354074f, 0.16867615f, 
    -0.00869313f, 0.01805986f, 0.17559826f, 0.07675719f, 0.08514611f, 0.31291148f, -0.00580701f, 0.00882941f, 
    0.01305037f, 0.06802507f, -0.01821940f, -0.03788367f, -0.02968209f, 0.11389624f, -0.11699802f, 0.06357505f, 
    0.28779519f, 0.09932613f, 0.09801939f, -0.07306919f, 0.05303479f, 0.18013749f, -0.00260938f, -0.04495561f, 
    0.23651713f, -0.14035486f, 0.03831078f, 0.02341601f, 0.09903102f, -0.05444155f, -0.08535401f, -0.08386366f, 
    0.30212128f, 0.05685027f, 0.06513531f, -0.06080642f, 0.03499474f, 0.08695195f, -0.03177537f, 0.00749492f, 
    0.06205078f, -0.14214338f, -0.03842623f, -0.23736663f, 0.12504964f, -0.13968483f, 0.11427278f, -0.12389074f, 
    0.11604017f, -0.13007630f, -0.17258765f, -0.01489642f, 0.14362429f, 0.09502541f, 0.09683028f, -0.12873213f, 
    -0.09207438f, -0.08088715f, 0.06810874f, -0.11246368f, 0.04198630f, -0.03522474f, 0.09719153f, 0.12600195f, 
    -0.20605198f, 0.05812299f, -0.06905654f, 0.08184924f, -0.79810584f, 0.15309493f, -0.07354955f, 0.24322395f, 
    0.00275870f, 0.09469952f, -0.21731417f, 0.05660439f, -0.10517944f, 0.53016150f, -0.03331384f, -0.05442529f, 
    -0.08871811f, -0.09697816f, 0.03812662f, -0.07304686f, -0.14679691f, -0.00648035f, -0.17219791f, 0.06305581f, 
    -0.18673049f, -0.03281776f, 0.14700654f, -0.03236868f, 0.05281460f, 0.13162607f, 0.10559826f, -0.11293977f, 
    0.09321258f, 0.22913280f, -0.08785252f, 0.09036984f, 0.02549023f, 0.01958445f, 0.02305710f, -0.22148830f, 
    0.33112580f, -0.20389342f, -0.16324614f, 0.00719018f, -0.01557632f, 0.01102862f, -0.02972836f, 0.10262680f, 
    0.03004036f, -0.28647107f, -0.00613922f, -0.09073211f, 0.10400219f, 0.10816289f, 0.07266539f, -0.01536085f, 
    0.05037035f, -0.05069970f, 0.03918960f, -0.00749935f, -0.17337720f, 0.00924438f, 0.03689752f, 0.00422693f, 
    0.15166140f, 0.03141908f, -0.03064027f, -0.02214930f, 0.05526247f, -0.04415351f, 0.08558740f, 0.04926198f, 
    0.09961134f, 0.05930927f, 0.06336055f, -0.13786586f, -0.25158027f, 0.26957625f, 0.10778622f, -0.14615095f, 
    -0.04099594f, -0.01063177f, -0.03543845f, 0.14789245f, -0.05757097f, -0.01340124f, 0.10581967f, -0.08864354f, 
    -0.04816385f, 0.02914834f, -0.13515721f, 0.02624005f, -0.00681455f, 0.04673726f, 0.44526982f, 0.16133317f, 
    0.06283896f, 0.01261475f, -0.11686181f, 0.06086660f, 0.08317314f, 0.10673954f, 0.10366464f, -0.37678307f, 
    0.05777771f, -0.04601300f, -0.00659581f, 0.05770202f, -0.08324946f, 0.10272349f, -0.02131853f, 0.09637156f, 
    -0.22160514f, 0.08771408f, -0.13046184f, 0.19318816f, -0.17756258f, 0.08260858f, -0.01818872f, 0.07303806f, 
    0.17731738f, -0.22980624f, 0.21969277f, -0.04076432f, 0.05465664f, 0.03412300f, -0.04084367f, -0.03175985f, 
    -0.05464415f, 0.13674971f, 0.11358323f, -0.16158102f, -0.06828544f, -0.04424954f, -0.03888952f, 0.02305808f, 
    0.07740665f, 0.00551176f, -0.01615599f, 0.12210113f, 0.10118797f, 0.21507977f, -0.02202755f, 0.04571434f, 
    0.01840662f, 0.05350037f, -0.12312882f, 0.10061903f, -0.27440125f, 0.15184334f, -0.03945780f, 0.13700266f, 
    -0.05506083f, -0.07072506f, -0.07081553f, 0.14519815f, -0.00124291f, 0.33042017f, 0.12550996f, -0.29898348f, 
    0.01266016f, -0.09153050f, -0.10193393f, -0.01762209f, -0.01977589f, 0.04166085f, 0.12725607f, 0.05717885f, 
    0.08125100f, -0.13529253f, 0.07493880f, 0.02110053f, 0.11516919f, -0.03962114f, 0.02466997f, 0.04593132f, 
    -0.05040014f, -0.31679899f, 0.01685823f, -0.05752503f, -0.04818031f, -0.09932178f, -0.00922703f, -0.02837003f, 
    0.09789381f, 0.29799196f, 0.05147868f, 0.09273123f, 0.06565632f, 0.04823473f, -0.06435548f, 0.01851357f, 
    0.02241648f, -0.21299471f, 0.06404465f, 0.01573569f, 0.12869802f, -0.07157001f, 0.21687624f, -0.16401942f, 
    0.00442010f, 0.01206353f, 0.03567811f, 0.02426508f, 0.03396292f, -0.02558256f, -0.12273409f, 0.08526768f, 
    0.14677362f, 0.20971209f, -0.14964661f, 0.15816228f, -0.03237112f, -0.04128901f, 0.14835013f, -0.03192830f, 
    -0.00639405f, 0.16823767f, 0.15282086f, -0.06378709f, -0.08931269f, -0.08028970f, -0.10700446f, -0.17530073f, 
    0.16328111f, 0.17345841f, 0.10228918f, 0.19857368f, 0.16253488f, -0.14799592f, 0.07929799f, 0.03504921f, 
    -0.08666872f, -0.06058070f, 0.22955045f, 0.11490687f, -0.04579768f, -0.00561249f, 0.21643008f, 0.03170963f, 
    -0.16308445f, 0.00472775f, -0.05195511f, -0.00308146f, 0.01816232f, 0.14065078f, -0.07802764f, -0.01803185f, 
    0.32350582f, -0.06392181f, 0.23066127f, 0.09854586f, -0.09810285f, -0.06924752f, 0.09550220f, -0.06526120f, 
    0.09920357f, 0.01415031f, 0.05180508f, 0.02744667f, 0.02345293f, 0.04624259f, -0.05350968f, -0.10304648f, 
    -0.23070341f, -0.08896940f, 0.12783286f, 0.02635970f, 0.09554319f, -0.07555526f, 0.16050610f, 0.20244583f, 
    0.12633270f, -0.03198143f, 0.05256421f, 0.10702448f, 0.07505234f, -0.09036580f, -0.00492622f, 0.02884200f, 
    0.26271164f, 0.00545196f, 0.24402280f, 0.05326707f, -0.23956601f, 0.00587648f, 0.04509555f, 0.12923895f, 
    0.10261670f, -0.02026310f, -0.06796721f, 0.05546714f, 0.08485655f, 0.31205416f, 0.10548803f, 0.01420850f, 
    0.14261852f, -0.08381011f, 0.00054518f, 0.15294398f, -0.14249240f, 0.49260297f, 0.02368692f, -0.10419235f, 
    -0.21064667f, -0.01716101f, 0.07981576f, -0.21147071f, 0.13002370f, -0.07494888f, 0.02064064f, 0.25135583f, 
    0.12506035f, 0.06328227f, 0.03658106f, -0.02127837f, 0.14796743f, 0.05830062f, -0.04448658f, -0.06747954f, 
    -0.19473468f, -0.07634395f, -0.17614134f, -0.16009963f, 0.00320470f, 0.01297704f, 0.03772110f, 0.23292135f, 
    0.17157143f, -0.10560706f, -0.06683078f, 0.02890347f, 0.14145367f, 0.13848644f, -0.04041318f, -0.10207192f, 
    0.02094554f, 0.27309605f, 0.22379346f, 0.18104155f, 0.13235906f, 0.16538389f, -0.17233823f, 0.03967988f, 
    0.07270867f, 0.05003203f, 0.15806940f, -0.07480136f, -0.12836494f, 0.06972905f, -0.06936786f, 0.01539468f, 
    0.07799469f, -0.10480005f, -0.02901485f, 0.15108010f, -0.06975254f, -0.03125994f, 0.13651931f, 0.02378751f, 
    0.01046285f, -0.03138144f, 0.13423225f, 0.07866115f, -0.03856728f, -0.21378894f, -0.15865976f, 0.01446177f, 
    -0.23452547f, 0.05277602f, -0.14118904f, -0.00718613f, 0.07227519f, 0.15868160f, -0.00635487f, 0.03861860f, 
    0.01023284f, 0.15685579f, -0.00939728f, -0.10476151f, 0.18550499f, 0.11726220f, 0.51327020f, -0.09771620f, 
    -0.22018951f, -0.10220938f, -0.04732689f, 0.13398026f, -0.10312792f, 0.04010482f, -0.27981883f, -0.09837675f, 
    -0.16814479f, -0.12778261f, -0.00871662f, 0.07651499f, 0.02345248f, 0.09854183f, -0.10257555f, 0.09556296f, 
    -0.17225946f, 0.22295001f, -0.00639487f, -0.12605420f, 0.07060635f, -0.08432799f, -0.14163859f, 0.03040036f, 
    -0.12653343f, -0.04906991f, 0.11185332f, 0.18594383f, 0.01400221f, 0.21601292f, -0.01643126f, -0.05436970f, 
    0.03438012f, 0.01755664f, 0.17087877f, 0.06198934f, 0.22639397f, -0.03241731f, 0.03950952f, -0.25834015f, 
    -0.05047621f, -0.00566881f, -0.06868836f, 0.02101430f, 0.21624841f, 0.07114540f, -0.14876659f, -0.14354002f, 
    0.00792789f, -0.05576526f, 0.12077748f, 0.15542240f, -0.04220571f, 0.13915543f, 0.05177153f, -0.01832288f, 
    0.08522488f, -0.21045485f, -0.18056567f, -0.18827200f, -0.18694651f, -0.13258207f, 0.07285587f, -0.35186237f, 
    -0.14723034f, -0.03958024f, 0.21234475f, 0.00407977f, 0.10470324f, 0.20473938f, 0.01923263f, -0.04731968f, 
    -0.12064210f, -0.14570533f, 0.02350687f, 0.03497903f, 0.11124195f, -0.02131034f, 0.03041567f, 0.08031808f, 
    -0.12089007f, 0.07386851f, 0.02152563f, -0.06301054f, 0.12634429f, -0.12253870f, -0.05628593f, 0.29400414f, 
    0.06712450f, 0.11809145f, -0.14829302f, 0.20131819f, -0.07865388f, -0.07428113f, 0.09476780f, 0.09631070f, 
    0.02316429f, 0.13216294f, 0.00999776f, -0.06516998f, 0.02026640f, 0.22804292f, 0.12263479f, 0.15330569f, 
    0.11142338f, -0.13248803f, 0.13501732f, -0.00910103f, -0.43103373f, 0.10077772f, -0.13232487f, 0.16195302f, 
    -0.03277647f, -0.07374091f, 0.08293948f, 0.00703343f, 0.13231170f, 0.22841516f, -0.18164466f, 0.18459730f, 
    0.05434621f, -0.07518951f, -0.07996522f, -0.01279826f, -0.16677493f, -0.00056407f, 0.15986717f, -0.21858132f, 
    0.19095115f, -0.08234745f, 0.04376007f, 0.02430379f, -0.15042718f, -0.00680138f, -0.00666200f, 0.24707511f, 
    -0.14582765f, 0.01920558f, -0.03830659f, -0.01410190f, 0.11392307f, -0.13294908f, -0.08289441f, 0.03713011f, 
    0.19981563f, -0.02488941f, 0.00412139f, -0.04021138f, 0.00346813f, 0.02887378f, -0.08492891f, -0.08272383f, 
    0.06639475f, 0.03747486f, 0.01005392f, -0.01684603f, -0.11960468f, 0.02902094f, -0.02263478f, -0.06054481f, 
    -0.13403429f, -0.06232970f, 0.05592903f, 0.02068727f, 0.12826425f, -0.16366071f, -0.06165746f, -0.11714457f, 
    -0.02320343f, -0.24586906f, 0.27536157f, -0.30982196f, 0.05168239f, 0.08150947f, 0.01383710f, 0.12317351f, 
    0.09735709f, 0.19568571f, 0.12249339f, -0.11110039f, -0.03007873f, -0.05565050f, -0.07646532f, 0.08915363f, 
    -0.07760978f, -0.01021083f, 0.11031497f, -0.04285368f, -0.20950569f, -0.19901456f, -0.22693902f, 0.13771456f, 
    0.02443519f, 0.07127376f, -0.03378691f, -0.07449730f, -0.12192648f, 0.33303174f, -0.09916231f, 0.12330322f, 
    -0.03422328f, -0.09720633f, 0.12930256f, 0.05306543f, 0.05787547f, 0.07840747f, 0.10076487f, -0.05114466f, 
    -0.03810591f, -0.15927653f, 0.18912606f, 0.16553412f, -0.06798722f, -0.01545137f, -0.04606162f, 0.10505416f, 
    -0.30776125f, 0.18436724f, 0.08248870f, -0.07121913f, 0.09139165f, 0.00207084f, 0.02275424f, -0.15160680f, 
    -0.23386250f, -0.06038141f, -0.14630941f, -0.09389582f, 0.14277846f, -0.08503866f, 0.06413352f, 0.06853218f, 
    -0.12179110f, -0.00323582f, 0.08170447f, -0.14965667f, 0.11422244f, -0.02553185f, 0.18421499f, 0.01471324f, 
    -0.08461487f, 0.03388392f, 0.03722945f, 0.03348889f, -0.07061383f, -0.10581431f, -0.10136934f, 0.12218054f, 
    0.06218091f, 0.06768408f, 0.00421087f, 0.18537509f, 0.01016925f, -0.01123504f, 0.00521454f, 0.05730144f, 
    -0.02995099f, 0.14446294f, -0.07145740f, -0.10435759f, 0.01480230f, -0.17756416f, 0.04502148f, -0.14870463f, 
    -0.10822995f, 0.05958804f, 0.16217794f, -0.05453318f, 0.11279787f, -0.05003762f, -0.07751275f, -0.11775539f, 
    0.12590152f, 0.17786439f, -0.08977264f, 0.07424805f, 0.09720597f, 0.12975535f, 0.28829083f, 0.10569368f, 
    -0.06162750f, 0.09588721f, -0.00489149f, 0.07716388f, 0.05866290f, 0.14130950f, -0.14598168f, 0.06405534f, 
    0.11491688f, 0.10243500f, 0.11220649f, 0.13722299f, 0.03989406f, 0.04595050f, -0.12444951f, -0.14609663f, 
    -0.21086873f, -0.13075428f, 0.07327587f, 0.05858868f, -0.01500919f, 0.21363664f, 0.11865010f, -0.10569002f, 
    -0.03877858f, -0.18027049f, -0.09410017f, 0.11941229f, 0.02095720f, -0.01250969f, 0.01110837f, -0.27109551f, 
    -0.17951581f, 0.05723339f, -0.01840379f, -0.19271286f, 0.03783292f, 0.28363156f, 0.11529432f, -0.05472009f, 
    -0.00640241f, 0.09539625f, -0.00024321f, -0.17054754f, 0.20863277f, 0.02798649f, -0.14226551f, -0.00393742f, 
    0.03375943f, -0.04009180f, 0.02968898f, -0.15063089f, 0.00393043f, 0.09404624f, -0.03364487f, 0.04670474f, 
    0.21900870f, -0.12140978f, 0.10208434f, 0.09882461f, 0.03922477f, -0.15470418f, -0.05606705f, -0.03549425f, 
    0.12496533f, 0.04550866f, -0.08667827f, -0.01729640f, -0.15558018f, -0.34439754f, -0.12638219f, -0.10813370f, 
    -0.11689151f, -0.01701308f, -0.05244468f, -0.11582956f, 0.09252174f, 0.12023407f, -0.16347474f, -0.07463557f, 
    0.02411445f, 0.07904678f, 0.03843920f, 0.06404150f, -0.01370030f, 0.06453938f, 0.07763042f, -0.15761121f, 
    -0.16384465f, -0.06175512f, -0.11479241f, 0.00030652f, 0.11785094f, -0.13740878f, 0.07585250f, 0.18742253f, 
    -0.54654521f, 0.09218777f, 0.03723653f, 0.17155720f, -0.03693158f, 0.00098656f, 0.11570664f, 0.03760562f, 
    0.03995432f, -0.19930679f, -0.10421031f, -0.28450239f, 0.16264693f, -0.02571131f, 0.07971277f, 0.10583207f, 
    -0.00539348f, -0.02043276f, -0.00820122f, 0.03174841f, -0.28888208f, -0.07384747f, -0.13011950f, -0.06178981f, 
    0.01975493f, 0.10384279f, 0.02255278f, 0.20575228f, 0.14338729f, -0.26338851f, -0.02992035f, 0.10922925f, 
    -0.15817997f, 0.16547249f, 0.10398785f, -0.17171937f, -0.07311681f, -0.09222709f, -0.06219246f, 0.02945361f, 
    0.20014444f, -0.10486840f, -0.03851831f, -0.02729649f, 0.08804154f, -0.14910111f, -0.23363958f, 0.07465877f, 
    0.03437516f, 0.01502868f, 0.00058179f, -0.09955642f, 0.02205751f, 0.03576912f, -0.05420971f, -0.02609270f, 
    -0.13318865f, -0.21346225f, -0.00304077f, 0.16617835f, 0.04673425f, 0.07330632f, 0.08399765f, -0.16712257f, 
    -0.09925543f, -0.00017086f, 0.01129356f, 0.04199231f, -0.17766020f, -0.02890576f, 0.13668135f, 0.04447775f, 
    0.06830930f, -0.05719741f, -0.01478692f, 0.10576247f, -0.10909367f, 0.03998732f, -0.08870597f, 0.05673429f, 
    0.14368211f, -0.26062983f, 0.30116704f, 0.08994291f, -0.03443678f, -0.03875248f, 0.05410114f, 0.01816776f, 
    0.01703691f, -0.13368316f, -0.13598998f, 0.25262308f, 0.13274698f, 0.10449007f, -0.15083079f, 0.05045080f, 
    -0.00728827f, -0.03827599f, 0.09192619f, -0.07169385f, -0.18945746f, 0.26131994f, 0.18393168f, 0.04487014f, 
    -0.15854256f, -0.07250448f, -0.01341729f, -0.10731725f, -0.30206475f, 0.02807973f, 0.14123826f, 0.17475274f, 
    0.03621185f, 0.03566745f, 0.03485259f, 0.10985663f, -0.02810907f, 0.05011178f, 0.09430045f, -0.17613053f, 
    -0.02121738f, 0.10537476f, 0.19289775f, 0.09532341f, 0.22975785f, -0.01047980f, -0.26890463f, -0.24722856f, 
    0.01719872f, -0.03524756f, -0.00385444f, 0.01425589f, 0.12320419f, -0.23565008f, -0.22345427f, -0.03028675f, 
    -0.00568573f, 0.15392448f, -0.02064683f, 0.11844885f, 0.18068624f, 0.02307354f, -0.06835509f, -0.03502392f, 
    0.15827303f, -0.17723697f, -0.03219310f, 0.00655889f, 0.11950368f, -0.16784061f, -0.13418144f, 0.06247882f, 
    -0.01760712f, 0.25172180f, 0.00477653f, 0.15282266f, 0.12044898f, 0.14456120f, -0.09900939f, -0.08126260f, 
    0.13330173f, 0.02264575f, 0.25539079f, -0.02999775f, -0.04496871f, 0.11906952f, -0.02386218f, -0.07011420f, 
    0.02442394f, -0.08925505f, -0.06055989f, -0.41515276f, 0.01658762f, -0.02725350f, 0.05751162f, 0.09630370f, 
    -0.12807803f, 0.02450041f, -0.02398166f, 0.08995136f, -0.07965786f, 0.13873503f, -0.51308364f, 0.14796795f, 
    -0.14424577f, -0.03408630f, 0.20342362f, -0.05647150f, 0.01378779f, 0.08247468f, 0.16608164f, 0.01664123f, 
    0.13445272f, -0.11025151f, 0.08642671f, -0.03815173f, -0.02923894f, 0.16495697f, 0.06754520f, 0.13107276f, 
    -0.13253123f, 0.06202675f, 0.05144044f, 0.07094621f, 0.13531712f, 0.10922147f, -0.05050318f, 0.12774594f, 
    0.03698958f, 0.09641098f, -0.01870516f, -0.16105080f, -0.40541810f, 0.20397665f, 0.03515099f, -0.02325840f, 
    -0.56643200f, -0.09045727f, -0.09480026f, 0.11955477f, 0.10988148f, 0.00154965f, 0.22918026f, 0.07061115f, 
    0.24826132f, 0.02080041f, -0.01166457f, 0.02630712f, 0.11471043f, -0.08417664f, -0.13610186f, -0.16143867f, 
    0.07645550f, 0.02067338f, -0.14894439f, 0.10267157f, 0.25687763f, -0.11645755f, -0.13021554f, -0.05292259f, 
    0.02910572f, -0.10238808f, 0.19744691f, 0.01410568f, 0.02287664f, -0.20766443f, 0.11655986f, 0.02658610f, 
    0.13198675f, -0.09560063f, 0.05479487f, 0.09009096f, -0.28031892f, -0.04059633f, -0.21945703f, 0.12144960f, 
    -0.18083394f, -0.04449881f, 0.01420406f, -0.05144813f, -0.10805096f, -0.00871209f, -0.33604786f, 0.17138679f, 
    0.20953082f, 0.09125805f, -0.01513786f, 0.00342421f, 0.11791164f, -0.07314409f, 0.04249090f, -0.13828011f, 
    -0.03380385f, -0.10621654f, 0.15698285f, 0.07787912f, 0.03115940f, 0.05533029f, -0.17848721f, -0.15185927f, 
    0.15391855f, 0.10576158f, 0.03960568f, -0.10911015f, -0.14010963f, -0.17870396f, -0.08399294f, 0.23555632f, 
    -0.01156888f, -0.05773045f, -0.01300510f, 0.02221015f, -0.02943217f, -0.01384406f, -0.03670098f, -0.01920916f, 
    -0.03399711f, 0.05425883f, -0.05892529f, -0.00339481f, -0.00927405f, 0.00911715f, 0.03639447f, -0.00483068f, 
    0.01070844f, 0.02550993f, -0.01449169f, 0.00382271f, 0.05155898f, -0.02207036f, -0.04572296f, 0.04875217f, 
    -0.01560741f, 0.01880518f, 0.01415186f, 0.02864884f, 0.04961549f, -0.04830717f, 0.04638457f, 0.03568055f, 
    -0.05305355f, 0.05660527f, 0.01852895f, -0.03986432f, -0.00570927f, -0.01729482f, -0.05656660f, 0.04527814f, 
    -0.04312256f, 0.01612662f, 0.00874563f, -0.03589955f, 0.05785901f, -0.01721569f, -0.03213621f, -0.02660214f, 
    -0.03987710f, -0.04414933f, -0.02385894f, 0.04386611f, -0.02635501f, -0.04987727f, 0.02809312f, -0.05177900f, 
    -0.04268849f, 0.05180205f, -0.01328603f, 0.02487088f, 0.03636231f, 0.03185092f, -0.05088096f, -0.01391734f, 
    -0.03245742f, 0.00247892f, -0.05753433f, -0.03038382f, -0.03065641f, 0.00635919f, -0.03548015f, 0.00606043f, 
    -0.02589151f, 0.03253716f, -0.02723248f, 0.04505713f, -0.04647380f, -0.03468892f, 0.00549676f, 0.01351789f, 
    -0.02282116f, 0.01500472f, 0.05375996f, -0.01956214f, 0.05336678f, -0.01898040f, -0.03928702f, -0.02478516f, 
    0.05589388f, -0.00474074f, -0.02454968f, 0.03397046f, -0.02199420f, 0.00272890f, 0.05419333f, 0.05399743f, 
    0.00078101f, 0.04982204f, 0.05464144f, 0.02180494f, -0.05127722f, 0.01708979f, -0.01850579f, 0.04009610f, 
    0.04574073f, -0.05007065f, -0.05189285f, -0.03999885f, -0.03753327f, 0.05404362f, 0.02592656f, -0.01845224f, 
    0.05481788f, 0.00277734f, 0.05576418f, -0.05659171f, -0.05210184f, 0.00497533f, -0.02194458f, 0.01539241f, 
    0.00543102f, 0.05240699f, -0.02765763f, 0.02129399f, -0.01501581f, -0.02235859f, 0.05818271f, 0.02128974f, 
    0.01553623f, -0.05364708f, 0.03296126f, 0.00020016f, -0.01240633f, 0.05029772f, -0.00967949f, -0.00398141f, 
    -0.01424143f, 0.03996094f, -0.01071773f, -0.01489708f, -0.01340922f, -0.03685142f, 0.00603988f, 0.02220321f, 
    0.05876523f, 0.05575002f, 0.02461883f, -0.01765683f, -0.01608912f, -0.03000322f, -0.02745364f, -0.00055135f, 
    -0.01098283f, -0.02691947f, 0.03636803f, 0.03348763f, -0.05233131f, -0.05259015f, -0.03651061f, -0.00801368f, 
    0.01193853f, -0.00462074f, -0.02553816f, 0.01082875f, -0.05659161f, -0.04027951f, -0.03691128f, -0.05628017f, 
    -0.00269693f, -0.01645183f, -0.00655996f, -0.04731062f, -0.05170862f, -0.03037925f, -0.02732984f, -0.04913124f, 
    -0.03912281f, -0.03514803f, -0.00787558f, 0.00943484f, 0.01457104f, 0.03224062f, 0.05567269f, 0.02487470f, 
    -0.00771155f, 0.04269619f, 0.04218081f, 0.04693897f, -0.04756080f, -0.02333215f, -0.04247227f, 0.01045425f, 
    -0.02894621f, -0.01839860f, 0.02778912f, -0.03809652f, -0.01757209f, 0.04529335f, 0.00154671f, -0.02475723f, 
    -0.04619374f, -0.05550793f, 0.01015579f, 0.05463164f, -0.05827330f, 0.03928683f, -0.02709435f, 0.01210914f, 
    0.01078353f, 0.00273369f, -0.05035645f, 0.02350118f, -0.05472612f, -0.01823215f, 0.05592117f, 0.04599268f, 
    0.00276683f, 0.02591882f, -0.05457076f, -0.03497031f, -0.04521950f, 0.02267869f, -0.01131416f, -0.02609976f, 
    0.00804449f, 0.02330667f, -0.02597118f, -0.01701258f, -0.00676628f, 0.01219579f, -0.01871046f, 0.05275520f, 
    -0.03102714f, -0.01203985f, 0.03446681f, 0.05381182f, -0.04577172f, 0.04853012f, 0.01185450f, 0.01363713f, 
    -0.03136896f, -0.05822320f, 0.01080430f, -0.02370635f, 0.00329553f, -0.00679690f, -0.04559391f, -0.00153769f, 
    0.02845492f, -0.02781788f, 0.00806878f, -0.02002768f, -0.01790650f, 0.01529282f, -0.05416268f, 0.01032025f, 
    -0.02749966f, -0.03557835f, -0.05111166f, -0.05638481f, 0.05149505f, 0.02171589f, -0.02521391f, -0.00035168f, 
    0.01577387f, -0.02430793f, 0.00261708f, 0.00247333f, -0.04429277f, -0.04620775f, -0.00604445f, -0.04169950f, 
    0.00116207f, -0.01084132f, -0.03845009f, 0.00242786f, -0.02611632f, -0.00394317f, -0.02612820f, -0.00099001f, 
    -0.00908647f, -0.02569953f, -0.00951951f, 0.00267989f, 0.00488141f, -0.01905528f, 0.02538925f, 0.01914800f, 
    -0.16519368f, 0.06014877f, 0.12410298f, 0.00564808f, -0.02212400f, 0.14914870f, 0.10608521f, -0.00320146f, 
    0.03687069f, -0.01070564f, 0.02347120f, 0.02293267f, -0.17026198f, -0.00901386f, 0.11552639f, 0.07091725f, 
    0.14469592f, 0.08509238f, 0.13702731f, -0.11081971f, -0.12470872f, -0.02905742f, 0.07846931f, 0.03940753f, 
    0.14436424f, 0.10276444f, -0.19536066f, 0.29192883f, 0.21924707f, -0.13757254f, 0.03597389f, 0.13399604f, 
    0.12956402f, -0.07321842f, 0.05601507f, -0.02502175f, -0.09108765f, -0.01480521f, -0.03490344f, 0.08883913f, 
    -0.09658825f, 0.00003901f, -0.07510941f, 0.06735284f, 0.09121821f, 0.15366618f, -0.02045425f, 0.32002118f, 
    0.13233672f, -0.11484193f, 0.12774183f, 0.11799335f, 0.13192564f, 0.00183943f, 0.21553451f, 0.15738544f, 
    0.39635700f, -0.02140854f, -0.00783328f, 0.01950087f, -0.06438874f, 0.25249922f, -0.27558303f, -0.41394511f, 
    -0.23590066f, -0.03853482f, -0.08840971f, 0.08023173f, 0.04517304f, -0.08816089f, -0.16882876f, 0.07225356f, 
    0.28762817f, -0.00926514f, 0.22969528f, -0.16518039f, -0.04805970f, 0.02089539f, 0.17748630f, 0.04771821f, 
    0.04976626f, 0.14270173f, 0.26083648f, 0.26612014f, 0.03987087f, 0.04033645f, -0.00469192f, -0.13481641f, 
    0.17809488f, 0.21280746f, 0.02583638f, 0.11707959f, 0.22362386f, 0.02934038f, 0.03057293f, 0.21232364f, 
    -0.14896689f, 0.14242317f, -0.07522034f, -0.00689435f, -0.01134443f, 0.02476925f, 0.10401936f, 0.12382040f, 
    0.01630281f, -0.05962317f, -0.05166516f, 0.17973143f, 0.10871211f, 0.08938682f, 0.31960231f, 0.11112688f, 
    -0.00674664f, 0.07775380f, -0.01111700f, -0.12287356f, -0.09988386f, 0.19744141f, 0.02501984f, -0.08388220f, 
    0.19376796f, 0.09032649f, 0.16707033f, 0.15505527f, 0.01919657f, 0.14381272f, -0.19333750f, -0.05013511f, 
    0.25817317f, 0.04469298f, -0.00429963f, -0.08336065f, -0.01465843f, -0.03060839f, 0.14117035f, 0.14475656f, 
    0.16919619f, -0.00607219f, -0.01771244f, 0.29895142f, 0.02620408f, 0.00222242f, -0.13666154f, 0.10868717f, 
    -0.00454806f, -0.02264554f, 0.22352183f, 0.14134678f, 0.06028793f, -0.12411553f, -0.07431792f, 0.16910279f, 
    0.00255628f, -0.08225546f, -0.08406238f, 0.09178368f, -0.09600592f, 0.04834464f, 0.25184026f, -0.06397770f, 
    -0.10040248f, -0.08608772f, 0.14045686f, 0.07998931f, 0.13508868f, 0.05320755f, 0.03808239f, 0.07836160f, 
    0.09686649f, -0.02390864f, 0.03550678f, -0.21433769f, 0.04586104f, 0.06993756f, 0.01160554f, -0.01200352f, 
    0.00871167f, -0.05173713f, 0.03406298f, -0.03169103f, 0.20814700f, -0.03155268f, -0.13340555f, -0.11009008f, 
    -0.01745747f, 0.19001074f, 0.19727203f, 0.19140725f, 0.09748205f, 0.19792373f, 0.10774934f, 0.17040247f, 
    -0.00381818f, 0.19094233f, 0.00514346f, 0.07571913f, -0.03194254f, 0.17316590f, 0.11098005f, 0.09593923f, 
    -0.09156398f, 0.11712885f, -0.03967825f, 0.02474940f, 0.02667448f, 0.07673358f, 0.10132047f, 0.21606126f, 
    0.03250862f, 0.20657378f, -0.00813104f, 0.03549441f, 0.02456162f, 0.07763628f, 0.17483176f, -0.12244812f, 
    -0.06898884f, -0.01802905f, 0.10977406f, -0.02081645f, 0.04584035f, 0.11982575f, 0.09089754f, 0.11177950f, 
    -0.06945860f, -0.19089545f, 0.02939299f, 0.15779091f, 0.08143843f, 0.02057522f, 0.06703505f, -0.04438863f, 
    -0.03230985f, -0.04272427f, -0.04624939f, 0.08752196f, 0.12789461f, 0.02147614f, -0.13352492f, 0.11857849f, 
    -0.02392461f, 0.11070114f, -0.13485493f, 0.05538964f, 0.01888408f, 0.09554279f, -0.04974843f, 0.00985438f, 
    0.10936014f, 0.15275201f, 0.07012726f, -0.04301072f, -0.43694609f, 0.05335134f, 0.16310133f, -0.06039286f, 
    -0.15669183f, -0.04216583f, -0.17863847f, -0.04350634f, -0.05876659f, -0.13416789f, 0.08750855f, 0.06919348f, 
    0.17972894f, 0.02389156f, -0.01956789f, 0.02690090f, -0.04290838f, 0.17217682f, 0.11466178f, 0.05753559f, 
    -0.01782881f, -0.05720378f, 0.22549236f, 0.08051325f, 0.10519116f, -0.14087133f, 0.16654016f, -0.02241635f, 
    0.03299679f, 0.01925644f, 0.06085125f, -0.13058853f, 0.31419280f, -0.00275527f, 0.00597211f, 0.02233090f, 
    0.04049627f, 0.01878053f, -0.03316005f, -0.06364235f, -0.01997480f, 0.00100797f, 0.02735699f, 0.03320683f, 
    -0.05467227f, -0.00297171f, -0.03715626f, -0.07485235f, -0.03687000f, -0.03067030f, 0.00658874f, 0.02602674f, 
    -0.04492833f, -0.03003540f, 0.00846342f, -0.00489325f, -0.00599115f, 0.03633637f, -0.02598501f, 0.03834828f, 
    0.00632229f, -0.00131408f, -0.03127462f, 0.01353761f, -0.03092975f, 0.01698258f, 0.01108915f, -0.05681296f, 
    -0.02287248f, 0.04772703f, -0.04097112f, 0.02767936f, -0.01605518f, -0.03017092f, -0.05031337f, -0.04379866f, 
    -0.05927448f, -0.05999238f, -0.03462448f, 0.03144820f, -0.06007454f, -0.03130497f, 0.03951333f, -0.05522514f, 
    -0.02347289f, -0.01559578f, 0.01489026f, -0.01612832f, -0.02282315f, 0.01264516f, -0.04705082f, 0.04133977f, 
    -0.01976428f, -0.00746309f, 0.03343011f, -0.02117972f, -0.01683051f, -0.00455956f, -0.02608818f, 0.00741816f, 
    0.00267124f, 0.01033935f, -0.02075905f, -0.05645010f, -0.04316423f, -0.02814717f, -0.05244999f, -0.06529023f, 
    0.03093703f, -0.00129497f, -0.00943729f, 0.01144125f, -0.06191143f, 0.05790198f, -0.02659304f, -0.03844338f, 
    0.01017014f, -0.03143662f, -0.03856190f, 0.03516332f, -0.05190741f, 0.03615308f, -0.00950497f, -0.00903947f, 
    -0.01051127f, -0.06209167f, -0.01926323f, -0.00995615f, 0.01198709f, -0.04459726f, 0.04687025f, 0.02244146f, 
    0.00344723f, -0.07037946f, -0.06260037f, 0.01248127f, 0.02624041f, -0.05512054f, 0.04252911f, -0.02885954f, 
    0.03639363f, 0.01865428f, -0.02512178f, 0.04065448f, 0.01720838f, 0.00628987f, -0.05298533f, -0.03284469f, 
    -0.05810082f, -0.01730828f, -0.04592807f, 0.02146352f, -0.03306261f, 0.02790662f, -0.01426721f, 0.00666893f, 
    0.03328725f, -0.03946330f, -0.03347117f, -0.00251036f, 0.03728822f, -0.06039984f, 0.00328647f, 0.01437727f, 
    -0.03225305f, -0.04700822f, 0.01545313f, -0.06583128f, -0.06015800f, -0.05681714f, -0.05403038f, -0.04507953f, 
    -0.06588504f, 0.00590607f, 0.01721029f, 0.03004890f, -0.05479705f, -0.06265362f, 0.01042624f, -0.02969865f, 
    -0.04696188f, -0.01909594f, -0.02501367f, -0.03245911f, -0.01733290f, -0.03205601f, -0.00709324f, -0.03789164f, 
    -0.06627198f, -0.06364705f, 0.00795431f, 0.01138124f, -0.01646430f, -0.00133362f, -0.03578445f, -0.05031792f, 
    0.00164109f, 0.00261986f, -0.01722201f, -0.04857345f, -0.01507229f, 0.00341430f, -0.05391831f, -0.02907254f, 
    -0.05242940f, 0.02194341f, 0.04330295f, -0.01027081f, 0.03619104f, -0.07445385f, -0.01662069f, 0.01738438f, 
    -0.00579467f, -0.03633991f, -0.01995848f, -0.01020532f, 0.00182805f, 0.02072040f, 0.00551810f, -0.04970115f, 
    0.01002994f, -0.07338814f, 0.04017609f, -0.04635312f, -0.02719048f, -0.03752496f, -0.01739774f, -0.00334148f, 
    0.04945311f, 0.04795228f, -0.07017653f, -0.01295202f, -0.03209596f, 0.01837031f, -0.00040942f, -0.03349873f, 
    -0.03985907f, 0.01938226f, 0.02527235f, -0.04613659f, -0.06070767f, -0.00228101f, -0.04760865f, 0.04740959f, 
    0.02355165f, 0.03854746f, -0.01334910f, 0.00461241f, -0.01268082f, 0.02643272f, -0.05092772f, -0.01955733f, 
    0.03097801f, 0.02337031f, 0.01566158f, -0.00386062f, 0.03163048f, 0.02922056f, -0.03705751f, -0.03668346f, 
    -0.02309537f, -0.05145162f, 0.02699838f, -0.03690005f, -0.03360121f, -0.01072457f, -0.00006719f, -0.00760780f, 
    -0.01637460f, -0.04502426f, 0.01875907f, 0.02221242f, 0.03289541f, 0.01906490f, 0.04051074f, 0.01662276f, 
    0.04159518f, -0.03247591f, 0.04213162f, 0.01838858f, -0.03010177f, -0.01675529f, 0.03211670f, -0.06725894f, 
    0.02399105f, 0.01019797f, 0.02372219f, 0.00581681f, -0.03196829f, 0.03775295f, -0.04736763f, -0.05934254f, 
    -0.04934366f, 0.02727433f, 0.00296301f, -0.03721048f, -0.02782260f, -0.06386568f, -0.01960545f, -0.04492690f, 
    0.03639632f, -0.02448902f, 0.04965482f, -0.04985485f, -0.03274709f, 0.00061058f, 0.01394807f, -0.02558880f, 
    0.02597725f, -0.06257343f, -0.03482014f, -0.01490779f, -0.00097737f, -0.03453539f, -0.02930275f, -0.02011355f, 
    -0.01657697f, -0.00835704f, -0.02861017f, -0.02539596f, 0.01221523f, -0.00808524f, -0.03203431f, -0.03619639f, 
    -0.03793632f, 0.01178128f, -0.05608718f, -0.04560278f, 0.00978294f, 0.03940132f, -0.05304303f, 0.00695949f, 
    0.05151271f, 0.02195889f, -0.06150110f, 0.00826795f, -0.01360977f, -0.03519749f, 0.04285653f, 0.02040261f, 
    -0.01746975f, -0.06025082f, 0.05258869f, -0.03517238f, 0.04065539f, -0.00869952f, 0.02564734f, -0.00312826f, 
    -0.03452215f, 0.00926558f, -0.01460436f, -0.04987716f, 0.02502183f, 0.02895952f, -0.01599245f, -0.01826581f, 
    -0.01617137f, -0.06092184f, -0.04577490f, 0.01025869f, -0.00040399f, 0.00236324f, -0.00284371f, -0.01436161f, 
    -0.05185951f, -0.04847572f, -0.01388996f, -0.05091776f, 0.05192213f, 0.02403090f, -0.06390458f, 0.01023297f, 
    -0.05206508f, 0.00051342f, -0.05224572f, -0.03237117f, -0.01669246f, -0.00121733f, -0.03206328f, -0.01893144f, 
    -0.04168965f, -0.04460461f, 0.00099444f, -0.06192654f, -0.01770342f, 0.00790984f, 0.03131089f, -0.00863632f, 
    0.00715054f, -0.03252318f, 0.04110562f, -0.03058176f, 0.01295110f, -0.02873432f, -0.04696766f, -0.00972930f, 
    -0.02935411f, -0.03695759f, -0.01829015f, -0.05188739f, -0.01515852f, -0.06176398f, -0.04372773f, 0.01410601f, 
    0.03263658f, -0.02807438f, 0.03552980f, -0.02147168f, -0.01137332f, -0.03039254f, 0.04963382f, 0.04763804f, 
    0.02671037f, -0.05304829f, -0.03108119f, 0.03654923f, 0.04574205f, 0.01130071f, 0.04016668f, -0.02920854f, 
    -0.00561372f, -0.04565354f, -0.05045569f, -0.04249975f, 0.02234174f, 0.01319726f, 0.03561895f, 0.04915955f, 
    0.03000633f, 0.03624564f, 0.00620356f, 0.05755023f, 0.03311690f, 0.01183055f, 0.01459901f, 0.04611811f, 
    -0.04181515f, 0.04614764f, -0.01696571f, -0.04061409f, 0.00578432f, 0.00294543f, 0.00146965f, 0.04158089f, 
    0.00612673f, 0.05138594f, -0.04331858f, -0.03724432f, -0.03777875f, 0.02729542f, -0.05119031f, 0.04528854f, 
    -0.02575423f, 0.02619722f, 0.02380599f, 0.03531017f, -0.03557561f, 0.01071329f, 0.01391675f, 0.02863632f, 
    -0.01261439f, 0.03438661f, -0.04927976f, -0.04661365f, -0.00614446f, -0.03733614f, -0.05151393f, 0.01644069f, 
    0.02194294f, 0.03337214f, -0.00096097f, -0.04159156f, -0.05662178f, -0.03167743f, -0.00328759f, -0.01431629f, 
    -0.01179668f, -0.04005655f, -0.01885270f, -0.00723100f, -0.02709952f, -0.02674001f, 0.04710320f, -0.01494099f, 
    0.01866816f, -0.01901544f, 0.03544265f, -0.05182922f, -0.01548752f, -0.06160546f, -0.05555330f, -0.00210392f, 
    -0.01882572f, -0.02216571f, -0.05155833f, -0.04105167f, 0.00252126f, 0.04176222f, 0.02117941f, -0.03742126f, 
    -0.05035128f, -0.02983313f, -0.03067276f, -0.00993830f, -0.04311717f, -0.01280668f, -0.02998403f, -0.01610324f, 
    -0.02820416f, -0.06178440f, -0.03502304f, 0.04387144f, -0.04536055f, 0.01947350f, 0.02093886f, 0.00206089f, 
    0.03581652f, -0.01435409f, -0.04991698f, 0.01339292f, 0.02545160f, -0.00908555f, -0.00140734f, 0.01182326f, 
    -0.06171792f, -0.06262899f, 0.00393790f, -0.02331071f, -0.03215047f, -0.02702305f, 0.03886048f, 0.02946344f, 
    -0.02442721f, 0.03798644f, 0.00061445f, -0.03936867f, 0.02627254f, -0.01018151f, 0.03716607f, 0.00086918f, 
    0.03180066f, -0.03918106f, -0.06362660f, -0.02298699f, 0.01355288f, 0.02077549f, 0.02793309f, -0.02290219f, 
    -0.01940578f, -0.04790398f, 0.02542126f, 0.02946990f, -0.02199270f, 0.03855684f, -0.03279391f, -0.05762596f, 
    -0.03914155f, 0.03670231f, -0.02441566f, 0.04009190f, -0.05069192f, -0.02363536f, 0.02137364f, -0.01957744f, 
    -0.03999497f, 0.04572044f, -0.00737433f, -0.03478659f, -0.02854910f, 0.04049252f, -0.00140337f, 0.00890468f, 
    0.01940089f, -0.06001588f, 0.04819129f, -0.03737778f, -0.05224129f, -0.01726249f, -0.06171076f, -0.01626490f, 
    0.03735111f, -0.00030899f, -0.05367633f, -0.01712969f, -0.05019099f, 0.02903780f, -0.06368693f, -0.04915093f, 
    -0.06005900f, 0.03582247f, -0.01744238f, -0.04269562f, -0.05963961f, 0.02093342f, -0.00735567f, 0.01728201f, 
    0.04246096f, 0.03804111f, 0.03816882f, -0.02021227f, 0.00174743f, 0.02548913f, 0.02128363f, -0.03086282f, 
    0.00123576f, -0.02816762f, -0.00048384f, -0.03420806f, -0.05867732f, -0.05839147f, -0.05473757f, 0.05894748f, 
    -0.00181848f, 0.03733350f, 0.02804951f, -0.04306389f, 0.15316324f, 0.10754275f, -0.01484719f, 0.03177361f, 
    0.03526080f, 0.20173927f, 0.07510716f, -0.00819335f, -0.03581214f, 0.11300877f, -0.04505736f, -0.02422491f, 
    0.05413314f, 0.06778808f, -0.06831039f, 0.19591947f, 0.28447723f, -0.16297279f, 0.02262589f, -0.09583226f, 
    -0.03767167f, 0.21940255f, 0.04761710f, 0.07696015f, -0.28502733f, -0.20118758f, 0.01287473f, -0.11525622f, 
    0.14630422f, -0.13984676f, -0.07489223f, -0.12693483f, -0.18812500f, -0.30750290f, 0.06688748f, 0.12692054f, 
    -0.09890458f, -0.11239944f, 0.13800883f, 0.04443173f, -0.03368780f, -0.41283476f, -0.04819512f, 0.03128269f, 
    -0.01431773f, 0.12721746f, -0.05951028f, 0.10233118f, -0.03679070f, 0.07766602f, -0.65502262f, -0.06657206f, 
    0.25070253f, 0.13779929f, 0.08942843f, 0.05236927f, -0.08359402f, 0.02536413f, -0.12863138f, 0.02444141f, 
    0.22311802f, 0.08499483f, -0.16982964f, 0.02794052f, -0.04175963f, -0.13660960f, 0.18368456f, 0.11376213f, 
    0.15568736f, -0.08035795f, -0.05012387f, -0.05707883f, -0.05005069f, -0.01290388f, -0.01049302f, -0.03490358f, 
    -0.00138672f, 0.09598219f, -0.16675605f, 0.01556825f, -0.01328410f, -0.04519901f, 0.06331873f, 0.31326270f, 
    0.11092804f, 0.00639342f, -0.25403607f, 0.09792808f, 0.10544877f, 0.09626058f, -0.11313225f, 0.05451406f, 
    0.23719113f, 0.17870335f, 0.03519925f, 0.22769883f, 0.08347788f, -0.02786906f, -0.01095562f, 0.04181372f, 
    -0.00655927f, -0.14828761f, 0.07729523f, -0.09152044f, -0.05273470f, -0.38091362f, 0.04126522f, -0.00381375f, 
    0.12568074f, 0.10789739f, 0.13998185f, -0.08367585f, -0.09858532f, -0.10676776f, 0.24885595f, -0.49573410f, 
    -0.02571581f, -0.06717815f, -0.10996659f, 0.02287269f, 0.06330387f, 0.03393815f, 0.09938372f, -0.04683029f, 
    0.16659144f, -0.03667600f, 0.00642804f, -0.06924339f, 0.14396006f, -0.04385696f, 0.03254179f, 0.11200909f, 
    -0.01417855f, -0.26993230f, 0.12626809f, -0.13285197f, -0.14084621f, -0.10186110f, 0.19464275f, -0.08547150f, 
    -0.28369382f, -0.14977773f, 0.16195193f, -0.00107949f, -0.00332919f, -0.05360800f, -0.08784299f, -0.09899224f, 
    -0.01857886f, -0.09132957f, 0.02722465f, 0.06618148f, 0.02116996f, 0.10417011f, 0.06044833f, 0.10978709f, 
    0.13813859f, 0.08078905f, -0.35664493f, -0.36174187f, 0.13828133f, -0.02220377f, 0.07897431f, 0.07447433f, 
    -0.03818372f, 0.14161535f, 0.19790056f, -0.02558380f, -0.18062988f, -0.03791507f, 0.17326197f, 0.15792099f, 
    0.07818069f, 0.11539734f, 0.02697725f, -0.00969050f, 0.28414616f, -0.08786299f, 0.06012510f, -0.05779681f, 
    0.08780956f, -0.09006972f, -0.06102498f, 0.03562455f, 0.19027963f, 0.02779714f, 0.02885970f, -0.01663391f, 
    0.07045381f, -0.06616826f, 0.19840240f, 0.03999048f, -0.03682519f, 0.07578057f, 0.16184376f, 0.11633606f, 
    -0.37146953f, 0.13108647f, -0.08561223f, -0.12854667f, 0.06014212f, -0.08019754f, 0.09408163f, -0.02657796f, 
    -0.06190876f, -0.05561146f, -0.10004509f, 0.01532375f, -0.14371611f, 0.04473698f, 0.14413525f, -0.02264160f, 
    -0.03130678f, -0.08490662f, -0.21490759f, 0.03137314f, -0.04705395f, 0.18050127f, -0.07752515f, 0.09521274f, 
    -0.03020527f, 0.00162520f, 0.04785801f, 0.02801361f, -0.04938687f, -0.09303247f, 0.03354961f, -0.03985069f, 
    0.09614475f, 0.10109785f, -0.00175514f, -0.26652110f, 0.02968673f, -0.00662989f, -0.01101555f, 0.19990405f, 
    0.01200020f, 0.12292379f, -0.06119587f, 0.01500454f, -0.17043751f, 0.11558406f, 0.11650921f, 0.01693988f, 
    0.06957001f, -0.07251583f, 0.02497574f, -0.04321443f, -0.13972832f, 0.24591449f, -0.17174444f, -0.11485642f, 
    0.08488639f, 0.01409430f, -0.11491118f, 0.24183425f, 0.12480926f, 0.06418423f, -0.08360108f, -0.44459900f, 
    -0.00947718f, -0.08504013f, -0.15046598f, -0.02031237f, 0.02239020f, -0.05628967f, 0.33657521f, -0.00161138f, 
    -0.43313742f, -0.12782761f, -0.10726824f, 0.03763518f, 0.00373359f, 0.14386308f, -0.07314713f, -0.10307580f, 
    -0.34126294f, -0.12378184f, 0.23033054f, -0.07711174f, -0.00753975f, -0.06767271f, 0.00949350f, -0.11544206f, 
    0.01391223f, -0.04314246f, -0.04307236f, 0.01950271f, 0.01684386f, 0.03760798f, -0.06350101f, 0.00310595f, 
    -0.04377434f, 0.03673704f, -0.06375836f, -0.00174771f, 0.04261225f, -0.02491278f, -0.00339005f, 0.02681100f, 
    0.01426831f, 0.03433229f, -0.00597939f, -0.05294298f, -0.02419531f, -0.04003025f, 0.04654723f, 0.00174680f, 
    0.01416419f, 0.04990781f, -0.01991134f, -0.00846720f, -0.03751024f, -0.00518462f, -0.00621048f, -0.00427532f, 
    0.02426295f, -0.01180432f, -0.03866277f, -0.01624736f, -0.00662672f, -0.03767220f, 0.04139327f, -0.02988647f, 
    -0.06602311f, -0.06917869f, -0.03562088f, 0.00247057f, -0.05875252f, 0.01763340f, 0.03816811f, -0.01320536f, 
    -0.03155522f, 0.03204201f, -0.00385828f, 0.02112216f, -0.03856365f, -0.05974828f, 0.00034951f, 0.00211678f, 
    -0.03567702f, -0.05988324f, 0.02087002f, -0.03298261f, -0.02738410f, -0.04383318f, 0.04665159f, -0.00062161f, 
    0.04970051f, -0.01478500f, -0.05437272f, 0.01637070f, -0.04940829f, 0.04136837f, -0.01342932f, -0.05037334f, 
    -0.02380331f, -0.02338129f, 0.03573360f, -0.04072301f, -0.04689744f, -0.01500227f, 0.05322751f, 0.04563344f, 
    0.01263386f, 0.03647603f, 0.04028191f, -0.06093512f, -0.02840932f, -0.02640800f, -0.05055298f, -0.06052583f, 
    -0.01289466f, 0.00273704f, 0.02029384f, 0.04644878f, 0.00193738f, -0.01122593f, 0.02877553f, -0.05404208f, 
    0.00818170f, -0.05597383f, 0.00893288f, -0.06942689f, -0.05266372f, -0.00606342f, -0.00576077f, 0.02970662f, 
    0.02620757f, -0.00618110f, 0.03755166f, 0.02774891f, 0.02362860f, -0.00665947f, 0.03136262f, 0.00726142f, 
    0.00616611f, 0.03421135f, -0.05605823f, 0.02322262f, -0.01643440f, 0.01658172f, -0.00802515f, 0.02709641f, 
    0.00957627f, 0.02969147f, -0.05566057f, 0.01964687f, -0.02539807f, -0.02784793f, -0.02083695f, -0.05973978f, 
    0.04808882f, -0.04224694f, 0.04629187f, 0.04773109f, -0.01915147f, 0.01291480f, -0.06448121f, 0.04312784f, 
    -0.01371106f, -0.03073896f, -0.05719105f, -0.01827756f, -0.01298031f, 0.02427829f, 0.01169517f, -0.05398031f, 
    0.00777062f, 0.04378803f, 0.00707568f, -0.01682599f, 0.03119977f, -0.02856162f, -0.04919975f, -0.03545009f, 
    0.00510687f, -0.04903275f, -0.03827633f, -0.02686604f, -0.05940088f, -0.00753485f, 0.02476432f, -0.05133641f, 
    -0.05384457f, -0.05221501f, -0.03166815f, -0.02460092f, 0.00398833f, 0.03729487f, 0.00650501f, 0.03943817f, 
    0.02924696f, -0.03692741f, 0.01192594f, -0.02048679f, -0.00026734f, 0.03243279f, 0.01911798f, -0.00762428f, 
    0.02353181f, -0.01044007f, -0.01760017f, 0.02770170f, 0.01814928f, -0.03585543f, -0.06390592f, 0.03846198f, 
    -0.00939757f, -0.05710053f, 0.01190402f, -0.02734362f, 0.01582617f, 0.04338374f, 0.01613194f, 0.01322552f, 
    0.01633529f, 0.02092955f, -0.00969885f, 0.03197852f, -0.03515265f, 0.03882683f, -0.06014867f, 0.02398030f, 
    0.02412803f, 0.03014170f, -0.05284496f, -0.02413397f, -0.02418217f, 0.01865067f, 0.02220734f, 0.02711976f, 
    0.03482731f, -0.04269823f, 0.00467180f, 0.01102681f, 0.02627381f, -0.03315045f, 0.03704125f, 0.00687792f, 
    -0.02370350f, -0.03165106f, -0.04379795f, -0.02084290f, -0.04642363f, 0.01293481f, -0.03883632f, -0.04089281f, 
    -0.03301755f, -0.02830952f, 0.02062428f, 0.01918793f, 0.04786650f, 0.03153691f, 0.04059929f, 0.03984728f, 
    -0.04327932f, 0.02146609f, 0.00770363f, 0.01476916f, -0.01450125f, -0.02000719f, -0.05483686f, -0.01653929f, 
    0.02627755f, 0.00358327f, 0.01266282f, -0.02977818f, -0.06863747f, -0.01071005f, -0.01295621f, -0.06063789f, 
    -0.04308099f, 0.01546741f, -0.03427508f, -0.00647855f, -0.03513034f, 0.04575574f, -0.02333166f, -0.01786651f, 
    -0.00711584f, 0.02507622f, -0.00318773f, -0.02794001f, -0.06194975f, -0.00533117f, 0.02064486f, -0.04511070f, 
    -0.01669081f, -0.05836043f, 0.02240924f, 0.02444020f, 0.04050941f, 0.02337698f, -0.02447312f, 0.01495366f, 
    -0.02677484f, -0.00452061f, 0.01784766f, 0.00877576f, -0.05645679f, 0.03022288f, -0.03322517f, -0.05481425f, 
    -0.00278484f, 0.00556580f, -0.06236364f, 0.01218188f, 0.03610119f, -0.00943640f, -0.05094660f, 0.03374335f, 
    -0.08123485f, 0.22234149f, -0.03690579f, -0.06547422f, -0.05808632f, 0.08403364f, -0.12599677f, 0.12850818f, 
    0.09692845f, 0.09020661f, 0.17441121f, 0.01981187f, -0.11731196f, -0.00299939f, 0.09648420f, 0.06536022f, 
    0.13237689f, 0.05606336f, -0.34104705f, 0.04667810f, 0.34186706f, -0.07604492f, 0.14217328f, -0.07201543f, 
    0.05639378f, 0.12070870f, -0.03439356f, 0.25506082f, -0.11855707f, -0.07884728f, -0.19157043f, -0.12869726f, 
    -0.23603204f, -0.03607543f, 0.04256893f, -0.16067426f, -0.28390422f, -0.16059397f, -0.03204392f, -0.03864330f, 
    -0.06248703f, -0.03722730f, -0.07554870f, 0.10744844f, 0.21525292f, -0.38632542f, 0.09405810f, -0.29692423f, 
    -0.00312065f, -0.05498301f, -0.03012633f, 0.11081101f, 0.04423797f, 0.06652009f, 0.11428623f, -0.01986209f, 
    -0.19418530f, 0.19087674f, 0.00655396f, -0.15086840f, -0.18507534f, -0.07431491f, 0.05649019f, 0.37330088f, 
    0.18964143f, 0.10885130f, 0.03035132f, -0.09331009f, -0.04956847f, -0.08848818f, -0.01826349f, 0.01462549f, 
    -0.24168000f, 0.53936523f, 0.24786149f, 0.12021237f, 0.12438729f, 0.15479480f, -0.11982179f, 0.01061842f, 
    0.00371622f, -0.03400869f, 0.11281565f, -0.09688361f, -0.29183722f, 0.03090687f, -0.20332341f, 0.14102362f, 
    0.02511654f, 0.10900617f, -0.01353757f, -0.04258063f, 0.22181883f, 0.12740685f, -0.04613826f, 0.06631802f, 
    0.13967620f, 0.19069444f, -0.09547767f, 0.31746221f, -0.00574088f, -0.23791857f, -0.03439472f, 0.03433742f, 
    0.02355443f, -0.14416824f, -0.02907043f, 0.12328137f, 0.13778119f, -0.01298996f, -0.01064668f, -0.27313814f, 
    -0.21862949f, -0.11545134f, -0.22456956f, 0.09167316f, 0.08179306f, 0.20497775f, -0.19996226f, 0.22622444f, 
    -0.00450080f, -0.02629852f, 0.02447187f, -0.11126076f, 0.01855041f, -0.10570788f, 0.03053219f, 0.23022974f, 
    -0.02308480f, -0.04312060f, -0.17650171f, -0.33518875f, -0.04802832f, -0.01718670f, -0.01925059f, 0.25370491f, 
    -0.16946423f, -0.62090379f, 0.25266603f, 0.10657116f, 0.26472995f, 0.08646473f, 0.04880334f, 0.08081820f, 
    -0.16371174f, -0.08028512f, 0.03501869f, 0.07520817f, 0.12323780f, -0.06971480f, -0.11045713f, -0.01937460f, 
    -0.05606535f, 0.22964266f, -0.05651774f, 0.06006467f, -0.02869995f, 0.11963314f, 0.07227123f, 0.01227436f, 
    -0.00112073f, 0.15595365f, -0.42735991f, -0.31279007f, -0.11815554f, 0.00859210f, -0.23777048f, 0.04505338f, 
    -0.01963703f, 0.09991535f, 0.07448354f, 0.33881029f, -0.15076849f, 0.03409424f, 0.01792133f, 0.04157628f, 
    -0.01585246f, 0.09866194f, 0.00256696f, -0.03724324f, 0.17692114f, -0.16342188f, -0.05404482f, -0.04430494f, 
    0.09695538f, 0.08718833f, 0.06810223f, 0.18024442f, 0.04534286f, 0.33283311f, -0.08876021f, 0.04868692f, 
    -0.09976549f, 0.08885874f, -0.10624242f, 0.00742456f, 0.00147320f, -0.10089352f, 0.38921317f, -0.27595028f, 
    0.20258389f, -0.01109468f, 0.10995641f, -0.03666401f, -0.06264587f, 0.04331356f, -0.04244502f, -0.23439422f, 
    -0.16567917f, -0.16503994f, 0.02082483f, 0.05994601f, -0.02412175f, 0.12080239f, 0.17863074f, 0.11032446f, 
    -0.00202535f, 0.06822351f, -0.01613159f, -0.03265747f, -0.17113025f, -0.05331121f, 0.12929440f, -0.04195493f, 
    -0.05765836f, -0.27583477f, 0.10297439f, -0.01600076f, -0.03682831f, -0.06605197f, -0.02111168f, -0.06508332f, 
    0.09944932f, -0.05415586f, 0.18499123f, -0.08117237f, 0.12806503f, -0.03902046f, 0.05749199f, 0.00808015f, 
    -0.05695051f, -0.02210464f, -0.01290136f, 0.04071294f, 0.18035957f, -0.06763343f, 0.06904333f, 0.20482349f, 
    0.18724272f, 0.06529183f, -0.06244641f, -0.11491970f, 0.06310029f, 0.22671618f, 0.01064744f, 0.08218634f, 
    -0.19273265f, -0.13530132f, 0.08742014f, 0.09103943f, -0.00105028f, -0.18143149f, 0.38149637f, -0.37380344f, 
    0.01569766f, 0.03549998f, 0.04468109f, -0.11279132f, 0.03719826f, -0.05173818f, -0.01748530f, 0.33156872f, 
    -0.12216236f, 0.12775616f, 0.09700593f, 0.08331264f, -0.09459185f, 0.17804803f, -0.02589187f, 0.17506894f, 
    0.06953297f, -0.15526354f, 0.07325684f, 0.13844725f, 0.00364408f, -0.11117012f, -0.19775806f, -0.24400114f, 
    -0.29721513f, -0.37241462f, -0.16059040f, 0.01220851f, 0.01982726f, 0.07107960f, 0.14949453f, -0.06843763f, 
    0.00669311f, -0.21588399f, -0.29412532f, -0.07680321f, -0.11950757f, -0.08758920f, 0.04387407f, -0.09113418f, 
    -0.04987429f, -0.02934041f, -0.23024526f, -0.06005948f, -0.10637861f, 0.02482704f, -0.00786178f, -0.00606767f, 
    0.06242649f, -0.08176120f, 0.04258037f, 0.45174590f, -0.03335096f, -0.08593182f, 0.08198287f, -0.14261673f, 
    -0.11577284f, -0.02575051f, -0.08044464f, -0.16075864f, -0.23150876f, 0.02014317f, -0.02725589f, -0.02419759f, 
    0.14147867f, -0.08653616f, 0.04879484f, -0.09831925f, -0.02744047f, -0.09674782f, 0.07923336f, -0.02955675f, 
    0.00970952f, -0.16787872f, 0.03074143f, -0.01173752f, -0.06757142f, -0.03553810f, 0.17335398f, 0.18775474f, 
    0.02683872f, -0.17611410f, -0.03071556f, 0.09298164f, 0.01880277f, 0.16404958f, -0.04864582f, 0.13555814f, 
    -0.13542615f, -0.04542350f, 0.10801001f, 0.02115316f, 0.01970710f, -0.01038508f, 0.01446582f, -0.09878331f, 
    0.27726915f, 0.19079858f, 0.01219201f, 0.06056897f, -0.18476008f, -0.11750223f, 0.16020077f, -0.02526037f, 
    0.07581831f, 0.19189800f, -0.19039775f, -0.03482012f, 0.07827336f, 0.06175022f, 0.08253584f, -0.19655570f, 
    0.09352742f, 0.01699191f, 0.01514895f, -0.07700124f, -0.06239985f, -0.02188959f, 0.10015057f, -0.02226589f, 
    -0.25875261f, -0.16264656f, -0.11067186f, -0.10240522f, 0.02181959f, 0.09573080f, 0.00073470f, 0.07243017f, 
    -0.02458026f, -0.07927408f, 0.02235910f, -0.03632135f, 0.03674189f, 0.07320984f, 0.13936645f, 0.03188766f, 
    0.11282489f, 0.02361496f, -0.05836195f, -0.22269715f, -0.09867300f, 0.29385060f, 0.05065778f, -0.22345130f, 
    0.07203588f, 0.15244950f, -0.13744426f, 0.10204425f, -0.03464378f, 0.01346677f, -0.34853536f, -0.15217344f, 
    -0.11226805f, 0.01220879f, -0.04006594f, 0.03028512f, -0.12132947f, -0.10649100f, 0.08110390f, 0.30424479f, 
    0.23041365f, -0.04663191f, 0.20657422f, -0.01773613f, 0.05119878f, -0.13771361f, 0.33169165f, 0.00707621f, 
    0.15486376f, -0.01570618f, -0.39601171f, -0.09374639f, 0.04763899f, -0.01426770f, -0.02158334f, -0.07673805f, 
    0.00336751f, 0.25641501f, 0.04561738f, 0.18061133f, 0.09769839f, 0.02367220f, 0.02369649f, -0.08145072f, 
    -0.06984033f, -0.08918448f, 0.15147622f, 0.21750444f, 0.08529413f, 0.04326877f, -0.09769323f, 0.04480739f, 
    -0.15919478f, -0.07535187f, -0.03412818f, -0.13802630f, -0.10627925f, 0.01442239f, -0.10053708f, -0.11703970f, 
    -0.11404511f, -0.00688641f, 0.09625664f, 0.04175192f, -0.06149407f, 0.08618778f, -0.25713307f, 0.01555534f, 
    0.04553545f, -0.13253058f, 0.02059905f, 0.06686425f, 0.09498359f, 0.03892430f, 0.11148171f, 0.02268467f, 
    0.06478762f, 0.10753225f, -0.01437024f, -0.05653186f, -0.08011819f, -0.05858602f, -0.00446490f, -0.01756665f, 
    0.04429871f, 0.01673546f, -0.02689886f, -0.19087753f, 0.04150155f, -0.00179644f, 0.07442066f, 0.29009116f, 
    0.09648763f, 0.02313860f, 0.01439497f, 0.05525239f, 0.09355624f, 0.01366859f, 0.11754681f, 0.00928340f, 
    -0.30401787f, -0.38135353f, 0.07298326f, 0.15455692f, 0.02581294f, -0.03909262f, 0.00503302f, -0.06181183f, 
    0.04679521f, -0.19077003f, -0.33801731f, -0.31252337f, 0.09454112f, -0.04961501f, 0.24474311f, -0.05175183f, 
    0.16711120f, -0.10114151f, -0.06582154f, 0.20178764f, 0.01384504f, -0.13918896f, -0.01044481f, 0.13977763f, 
    -0.06618259f, 0.15329462f, -0.04518769f, 0.19517328f, 0.14629449f, -0.07145430f, 0.02681753f, 0.04124789f, 
    0.03443552f, -0.01542775f, 0.08405332f, -0.01734494f, -0.36482713f, -0.66963375f, -0.06874317f, -0.06625783f, 
    -0.03397746f, 0.18125007f, -0.03907909f, 0.11833588f, -0.02312220f, 0.16751915f, 0.00571907f, 0.07192201f, 
    0.12551582f, -0.06869597f, -0.17236796f, 0.17174797f, 0.23341131f, -0.13322271f, 0.24652784f, 0.10836071f, 
    0.06878290f, 0.00752105f, 0.00896818f, 0.01429532f, 0.07797824f, 0.16537821f, 0.05976042f, 0.11697988f, 
    -0.02145915f, 0.02067914f, 0.17183277f, -0.00804440f, 0.17490751f, 0.04477238f, -0.05310242f, -0.25100234f, 
    -0.04947121f, -0.13846876f, 0.08022527f, 0.12164891f, -0.07603103f, 0.02019549f, 0.02655997f, 0.04525572f, 
    -0.04132485f, -0.19031300f, -0.06373053f, -0.19881825f, 0.02464935f, -0.01826097f, 0.12318878f, -0.10371165f, 
    0.02132305f, -0.25083134f, 0.31962714f, -0.06736323f, -0.02344903f, 0.15945230f, -0.07947903f, 0.20130569f, 
    0.05927680f, 0.07278451f, -0.15739629f, 0.27240962f, 0.13568307f, 0.13710402f, 0.09588853f, -0.05495002f, 
    -0.10460543f, -0.06352775f, -0.01250922f, 0.02091362f, 0.05810345f, 0.16108669f, -0.02474162f, -0.03857999f, 
    0.10579989f, -0.00826505f, 0.17270108f, -0.01109050f, -0.04793824f, 0.08182144f, 0.00169925f, 0.01751575f, 
    -0.00502765f, 0.11874899f, -0.07379885f, -0.10428867f, -0.00695811f, 0.11131922f, 0.03034370f, -0.25713477f, 
    0.22994414f, 0.03085634f, 0.04406114f, -0.16043654f, -0.13934809f, -0.00293342f, 0.09285957f, 0.02130808f, 
    -0.08344463f, 0.00724954f, 0.00379775f, 0.10890611f, 0.00624492f, 0.10409793f, 0.03019788f, -0.16481450f, 
    0.01559300f, -0.09892408f, -0.04087384f, 0.03116875f, 0.09214022f, -0.06723792f, 0.03799448f, -0.05588766f, 
    -0.07650451f, -0.09281596f, 0.08385745f, -0.08632883f, 0.09647848f, -0.10605588f, 0.20450415f, 0.05657244f, 
    -0.06036916f, -0.17253885f, 0.13088676f, -0.05352064f, -0.10026007f, 0.07070864f, -0.08046424f, -0.00087643f, 
    0.15732488f, 0.11301851f, -0.16941454f, 0.20672204f, 0.02513822f, -0.00420589f, -0.16708966f, -0.04010319f, 
    0.06742763f, 0.03958025f, -0.05395651f, 0.06843881f, 0.18230262f, 0.09914771f, -0.13943845f, -0.03368271f, 
    -0.06064057f, -0.03290197f, -0.02364095f, 0.02056165f, 0.11341562f, -0.06926811f, 0.04439117f, 0.15242550f, 
    0.01876345f, -0.02665196f, 0.31526753f, -0.09223540f, -0.00153510f, -0.18647279f, 0.01777662f, -0.07234111f, 
    -0.15261583f, -0.00494916f, 0.13660896f, 0.02855662f, 0.13963830f, -0.11272756f, -0.16975129f, -0.19817479f, 
    -0.23038593f, 0.23198406f, 0.00059542f, -0.05685811f, 0.12691998f, 0.00406687f, -0.12498435f, 0.25694773f, 
    -0.01317029f, -0.00309229f, -0.06140858f, 0.02428293f, -0.07770547f, 0.03113834f, 0.10863414f, 0.11452741f, 
    -0.11511862f, 0.19039531f, -0.03102024f, 0.00894920f, -0.09066920f, 0.17296144f, -0.33065382f, 0.18237007f, 
    0.00366276f, -0.08977044f, 0.01082117f, 0.11652534f, -0.04604469f, 0.02933953f, 0.13546517f, -0.05320374f, 
    0.13631512f, 0.00013436f, -0.11370376f, -0.17187312f, 0.11379689f, -0.10496120f, -0.11776714f, 0.02237036f, 
    -0.13276145f, 0.06565035f, -0.05632401f, -0.08606458f, -0.09403101f, 0.01446482f, -0.20641537f, -0.10959856f, 
    0.01318701f, 0.09920417f, -0.12479181f, 0.10740314f, -0.38651022f, 0.17006461f, 0.06838966f, -0.04596085f, 
    -0.11569747f, 0.00565854f, 0.07943859f, 0.04658638f, 0.04389214f, 0.03672250f, 0.02455783f, -0.02972270f, 
    0.11472978f, 0.00799138f, 0.03984977f, 0.04800322f, 0.04328941f, 0.08560580f, -0.11966108f, 0.33292818f, 
    -0.05922660f, -0.14839798f, 0.09207305f, 0.11666062f, 0.01658389f, -0.01022330f, -0.05249877f, 0.06915688f, 
    0.08812118f, -0.10506190f, 0.01481316f, 0.17500979f, 0.07075634f, -0.13362187f, -0.13673489f, -0.11217184f, 
    -0.17342721f, -0.03495757f, -0.07127489f, -0.27359754f, -0.02008943f, 0.09917233f, -0.05384711f, 0.07413179f, 
    -0.06001719f, -0.13294671f, -0.11347448f, 0.11594293f, 0.18651140f, 0.22347113f, -0.07909215f, -0.10775143f, 
    0.01093165f, -0.04686606f, 0.01557968f, -0.05247309f, -0.11438214f, 0.10069180f, 0.02538730f, 0.04315636f, 
    -0.10983240f, -0.06266083f, 0.01715980f, 0.11196378f, -0.02941554f, -0.07929340f, 0.05816399f, -0.10376763f, 
    0.10603977f, -0.20113675f, 0.09475503f, -0.05242136f, -0.18982497f, -0.03319995f, -0.03945111f, 0.09363166f, 
    0.02461008f, 0.12591614f, 0.10410915f, -0.02627417f, -0.05584082f, 0.09823957f, -0.03380140f, -0.01879589f, 
    0.15658981f, 0.11807061f, 0.00645768f, -0.01680420f, 0.02984589f, -0.10185973f, -0.03179777f, -0.13277191f, 
    0.14297754f, 0.08609468f, 0.01321267f, -0.20100327f, -0.00355783f, -0.02916277f, 0.06466491f, 0.22397055f, 
    -0.19861498f, -0.14840220f, 0.06129901f, 0.02865924f, 0.12994052f, 0.11782157f, 0.00209180f, -0.12720075f, 
    0.17211019f, -0.38156506f, -0.26657221f, -0.05729919f, 0.23291609f, 0.03733858f, 0.08189481f, -0.04168821f, 
    0.02627812f, 0.04793124f, 0.03414040f, 0.02175789f, -0.03476618f, -0.27619362f, 0.05721722f, 0.10798447f, 
    -0.03787017f, -0.01103502f, -0.12622567f, 0.19022599f, -0.19339943f, -0.17406136f, -0.02610369f, -0.05664927f, 
    0.20710728f, 0.10052649f, -0.14595558f, -0.02262426f, 0.09114572f, -0.12442499f, 0.13209777f, -0.09565792f, 
    0.03045039f, 0.07314302f, 0.11047225f, -0.00997131f, -0.02215115f, -0.07583807f, -0.20232491f, -0.05987581f, 
    -0.14572248f, -0.04738961f, 0.01535910f, 0.00018386f, -0.07374438f, 0.13867363f, 0.05027145f, -0.01856863f, 
    0.20738973f, -0.09821510f, -0.11402325f, -0.06423350f, -0.01407545f, 0.12947862f, 0.08124824f, 0.22313800f, 
    0.11684831f, -0.03047648f, 0.08728035f, 0.04586316f, 0.07233080f, -0.16672690f, 0.04239645f, -0.02968393f, 
    0.16817786f, 0.11780490f, -0.06217954f, -0.20431454f, -0.03535867f, -0.29214752f, 0.01400022f, 0.02158540f, 
    -0.00467873f, -0.19233045f, -0.04457850f, -0.08788122f, 0.02252603f, -0.03382166f, 0.12947561f, -0.27881077f, 
    -0.20884378f, 0.02344987f, -0.00048976f, -0.20596029f, 0.19281001f, 0.17598727f, 0.06973311f, -0.03372160f, 
    -0.16171212f, 0.03887182f, -0.00707182f, -0.00042777f, 0.03488301f, 0.14485703f, -0.09987916f, 0.03664911f, 
    0.04110880f, -0.09825128f, -0.06904395f, 0.07119372f, -0.33867362f, 0.21636552f, -0.22660127f, 0.08888631f, 
    0.20153008f, 0.14685400f, -0.06360286f, -0.04796902f, 0.02285603f, 0.42267382f, 0.05578132f, -0.05349961f, 
    -0.02285583f, -0.04758130f, -0.09763677f, -0.11857422f, 0.01943851f, 0.09034647f, -0.01892130f, -0.06781685f, 
    -0.09647603f, 0.16417630f, 0.06225063f, 0.02146779f, -0.05533161f, -0.16782968f, -0.16420688f, 0.18792123f, 
    0.09018014f, 0.20348740f, 0.00479600f, -0.18420146f, -0.00413462f, -0.02286945f, 0.04693225f, 0.08567333f, 
    0.17406796f, -0.21701224f, -0.01540544f, -0.22547743f, 0.07278270f, -0.23898903f, 0.04713728f, 0.09250141f, 
    -0.00563582f, 0.33668303f, 0.23246883f, 0.13918535f, 0.04878172f, 0.02282979f, -0.19486302f, 0.12263097f, 
    0.01415980f, 0.12071995f, 0.22116502f, 0.03109671f, -0.05503180f, 0.11223126f, -0.01679668f, -0.16450982f, 
    0.00719967f, 0.00314001f, 0.04470695f, -0.15931413f, 0.17621830f, 0.02765797f, 0.02239995f, 0.06270388f, 
    0.05429051f, 0.00397322f, -0.06556275f, -0.09539327f, -0.42995831f, -0.01045502f, -0.01385094f, 0.05525834f, 
    0.14595471f, 0.14012229f, 0.01745300f, 0.04335279f, -0.21060693f, 0.14955652f, -0.07903841f, 0.16141723f, 
    -0.04872296f, 0.03181844f, -0.01083202f, 0.04383950f, -0.00949434f, -0.05077197f, 0.12178002f, 0.08891866f, 
    -0.04484504f, -0.18379354f, 0.06913024f, 0.02620678f, 0.06356005f, 0.01009975f, -0.00195864f, -0.14440410f, 
    -0.02090791f, 0.12275572f, 0.03071876f, -0.00028439f, -0.15865813f, 0.09922632f, 0.08941197f, 0.15810654f, 
    -0.61604577f, -0.04816864f, -0.08929969f, 0.18078165f, 0.17039683f, 0.17028430f, -0.00923382f, 0.07471459f, 
    0.03282392f, -0.11582918f, -0.08515567f, -0.05263400f, 0.09310703f, 0.15072663f, 0.02266470f, -0.11112988f, 
    -0.02380637f, 0.15614787f, 0.15140884f, -0.07824814f, -0.03975290f, -0.05178384f, -0.33077183f, 0.02739009f, 
    0.17258963f, 0.05953683f, -0.06727594f, 0.11327178f, -0.06315510f, 0.13674261f, -0.04960402f, -0.12456264f, 
    -0.01212325f, -0.07539789f, 0.04707544f, -0.01161712f, -0.39821202f, -0.19883333f, -0.02380352f, 0.05037476f, 
    -0.05380661f, 0.00067485f, -0.08188339f, -0.00713130f, -0.02232691f, 0.24646640f, -0.00367520f, 0.02431176f, 
    -0.09855988f, -0.04161097f, -0.07865264f, -0.12348177f, 0.08630380f, 0.00793900f, 0.08736476f, 0.07114004f, 
    0.09105077f, -0.07683977f, 0.02802796f, -0.10047840f, -0.04424156f, -0.07296541f, 0.07304291f, -0.04552996f, 
    0.01760461f, 0.18914822f, -0.14882088f, -0.31317446f, 0.08116401f, 0.13122636f, -0.10640961f, -0.05191486f, 
    0.02057159f, -0.01848986f, -0.05941464f, -0.03531580f, 0.01897634f, -0.02347936f, 0.00694124f, -0.00898255f, 
    -0.01961746f, -0.04905597f, 0.04157183f, 0.04673592f, 0.02063772f, -0.02929078f, -0.00351617f, -0.01508959f, 
    -0.00055867f, -0.06221184f, 0.02119203f, 0.01964003f, 0.04789280f, 0.04660367f, -0.01915701f, -0.03838033f, 
    -0.01857621f, -0.01956442f, -0.02340906f, -0.05968840f, -0.03133626f, -0.00164801f, -0.01530322f, 0.01246587f, 
    0.04616307f, 0.00217602f, -0.01623301f, -0.02434496f, -0.06733187f, -0.00652049f, -0.05701271f, 0.02685607f, 
    -0.04910634f, -0.00609037f, -0.00209013f, 0.00721156f, 0.00105425f, 0.01764239f, 0.02989091f, -0.04018830f, 
    0.01316376f, -0.04052286f, 0.05272002f, 0.00116374f, -0.02591044f, 0.03459191f, 0.04078169f, 0.01165772f, 
    -0.05462698f, 0.02254011f, 0.02648032f, -0.04935280f, -0.02464762f, -0.00432665f, 0.03820825f, -0.06154135f, 
    0.02607646f, -0.01558045f, -0.00172149f, 0.02400625f, -0.01458508f, -0.06577664f, -0.00158652f, 0.01297417f, 
    0.02959086f, -0.05530653f, -0.05518942f, 0.04195379f, 0.00351274f, 0.00152380f, 0.02577137f, 0.01131069f, 
    -0.02119997f, 0.03004319f, 0.04904422f, 0.01027700f, -0.00562517f, -0.05627337f, -0.02225852f, -0.00482724f, 
    -0.02044370f, 0.00939308f, 0.00336739f, -0.03659675f, 0.01856687f, -0.00908041f, -0.04984394f, -0.04346167f, 
    0.03859231f, -0.02997589f, -0.06456029f, 0.01191540f, -0.01719751f, -0.05683017f, 0.04226211f, 0.04823544f, 
    0.04439578f, -0.05118874f, -0.04156089f, -0.05531406f, 0.04334454f, -0.04865466f, 0.03838131f, 0.05720866f, 
    -0.02506162f, 0.04034473f, 0.02285581f, 0.00033123f, -0.02382195f, 0.00255261f, 0.04224714f, 0.02338686f, 
    -0.04205603f, -0.06558993f, -0.04974307f, -0.04517820f, -0.05698122f, 0.01277071f, -0.05977261f, -0.00453420f, 
    -0.02574166f, -0.01710811f, 0.00454061f, 0.01059740f, 0.01907328f, -0.06310248f, -0.02129438f, 0.03442475f, 
    -0.01011181f, -0.00880420f, 0.03672406f, 0.03975879f, -0.01113715f, 0.05630962f, -0.01988192f, 0.01029416f, 
    -0.03830967f, -0.06310564f, -0.01213149f, 0.05186257f, 0.02132677f, -0.01342669f, -0.03912879f, 0.04788608f, 
    -0.04025215f, -0.01299395f, 0.01918322f, 0.04645368f, -0.03634668f, 0.04590296f, 0.02111058f, 0.01280984f, 
    -0.05266921f, 0.04008088f, -0.03797591f, 0.01853421f, 0.03268890f, -0.02174019f, 0.00677248f, 0.00606321f, 
    -0.04220317f, -0.03341631f, -0.00546206f, 0.04221628f, -0.02020676f, -0.00951519f, 0.02402009f, 0.03345039f, 
    -0.05401750f, -0.03941167f, 0.01546493f, -0.02327694f, -0.00569611f, -0.06768875f, -0.04191103f, 0.04028410f, 
    -0.03187868f, -0.03142986f, 0.01098565f, -0.04880608f, 0.00634324f, 0.04248154f, -0.01975597f, 0.02419337f, 
    0.01402734f, -0.03856261f, -0.03570495f, 0.03568643f, -0.05579667f, -0.00000953f, -0.00993976f, -0.03227177f, 
    -0.00591791f, -0.04393532f, 0.03381294f, 0.01933939f, -0.02655129f, -0.04648356f, -0.06117825f, 0.02737819f, 
    -0.00514020f, 0.00537405f, -0.02357520f, 0.05228151f, -0.04905733f, -0.06200299f, -0.01287847f, 0.04314843f, 
    -0.06461284f, -0.01759539f, 0.02052812f, 0.04445045f, 0.02080254f, -0.04408135f, 0.00990139f, -0.06341581f, 
    -0.03848656f, -0.04291061f, -0.02830656f, 0.04852041f, 0.01420168f, 0.00751432f, -0.01660704f, -0.00880791f, 
    0.04520933f, -0.00892097f, 0.04649876f, -0.04084365f, -0.03233442f, 0.00167990f, 0.02696145f, 0.03112657f, 
    0.00203186f, 0.00403459f, 0.03173165f, -0.06724375f, -0.03897769f, -0.04793993f, -0.04141750f, -0.02954154f, 
    -0.04126575f, -0.00538763f, -0.03562128f, -0.00713537f, 0.03228785f, 0.02403807f, -0.04780201f, 0.03292088f, 
    -0.05373674f, -0.05395863f, -0.05933235f, -0.06191822f, -0.02167111f, -0.02992984f, 0.01816149f, 0.02692798f, 
    0.00746903f, -0.01511919f, -0.02710886f, -0.01782925f, -0.01911564f, -0.04426055f, -0.06117532f, -0.00622515f, 
    0.03545867f, -0.04492678f, -0.01339359f, -0.06316534f, 0.01181304f, -0.06752575f, -0.01245581f, -0.03186773f, 
    0.02733233f, -0.03492862f, 0.05612702f, -0.03633146f, -0.04283706f, -0.04023628f, 0.02112493f, 0.01134272f, 
    0.03935089f, -0.07236856f, -0.06101663f, -0.05869136f, -0.04102246f, 0.01505801f, -0.07018951f, 0.03472016f, 
    -0.04460824f, -0.00557128f, 0.01130089f, 0.04591945f, -0.02540106f, -0.06400462f, -0.00924120f, 0.03233328f, 
    0.03245946f, -0.03778491f, -0.04010184f, -0.06115089f, -0.00755187f, 0.03154911f, -0.01244702f, -0.01247757f, 
    -0.07015893f, -0.08031625f, 0.01994989f, -0.00133562f, -0.01499667f, -0.00750056f, -0.00362759f, -0.04156324f, 
    -0.06527576f, 0.04942707f, -0.04121971f, -0.01566528f, -0.02196571f, -0.00548589f, -0.04950367f, -0.02460380f, 
    0.03869738f, -0.00516952f, -0.02548469f, -0.00216020f, -0.01919457f, 0.05104019f, 0.00442586f, 0.05973529f, 
    -0.03050768f, -0.03358555f, -0.04802620f, -0.00948669f, -0.05974763f, 0.03064763f, -0.01631181f, -0.00278930f, 
    0.05616655f, 0.00171878f, 0.01989655f, -0.00856308f, 0.00441905f, 0.03935333f, 0.02460878f, 0.01185768f, 
    -0.00843741f, -0.00970942f, -0.06724600f, 0.01445041f, -0.03375436f, -0.07071575f, 0.02582231f, 0.02357878f, 
    -0.03966515f, -0.05136740f, 0.02327515f, -0.02122982f, -0.01686865f, 0.02468911f, 0.02272009f, -0.00845107f, 
    0.01965710f, 0.00601321f, -0.02123924f, -0.08229563f, -0.06779609f, -0.04399598f, 0.03837068f, -0.02064738f, 
    -0.06330958f, -0.01661399f, -0.01652588f, 0.01507152f, -0.00230921f, -0.04573262f, -0.05051509f, -0.02884471f, 
    -0.04924386f, -0.07089970f, -0.04558039f, 0.03369085f, -0.01561090f, 0.00392748f, -0.01461322f, 0.01785781f, 
    -0.02910465f, 0.02287539f, -0.01432028f, 0.01791193f, -0.06389934f, -0.06385113f, -0.00256447f, 0.04559351f, 
    -0.04377313f, 0.01047707f, -0.06572729f, 0.01718067f, -0.07912053f, -0.06009929f, 0.01388790f, -0.03502335f, 
    0.00227756f, -0.03027670f, 0.04603697f, -0.01784156f, -0.00544745f, -0.03402711f, -0.03907638f, 0.04871209f, 
    0.01960775f, -0.07165992f, 0.02347283f, -0.05703891f, -0.02174998f, 0.03364915f, -0.01829210f, 0.02645055f, 
    0.01657858f, 0.01537575f, -0.02927583f, -0.01586314f, -0.07812768f, -0.00702872f, -0.01019245f, -0.04807563f, 
    -0.03717514f, -0.02787002f, -0.06393201f, 0.03424252f, -0.05430779f, 0.02945158f, 0.01105010f, -0.04952289f, 
    -0.04734091f, 0.03105090f, 0.02291802f, -0.04783543f, -0.03455177f, 0.02928950f, 0.00403116f, -0.02506841f, 
    -0.04967595f, -0.03522337f, -0.04745850f, 0.04017382f, -0.05240782f, 0.02963835f, -0.01254452f, 0.00184613f, 
    -0.02931368f, 0.00807459f, 0.04642095f, -0.01708466f, -0.04569459f, -0.03993526f, -0.08206350f, -0.06242787f, 
    -0.00259376f, -0.07244977f, 0.01789598f, -0.02809972f, -0.06260318f, -0.06853391f, -0.00317798f, -0.01345242f, 
    -0.06105928f, -0.04923063f, -0.02580116f, 0.01367082f, 0.01154460f, 0.00573510f, -0.05564712f, -0.07155235f, 
    0.04172546f, -0.02993301f, -0.00912182f, -0.05817537f, 0.04610949f, 0.01023445f, -0.06715413f, 0.02005536f, 
    -0.04955703f, 0.02331307f, -0.07123130f, -0.04832635f, 0.01148025f, -0.08008968f, 0.01643752f, -0.04583449f, 
    -0.06193253f, 0.03612086f, 0.00169155f, 0.04011708f, -0.03138432f, -0.02843323f, 0.01762875f, 0.04565252f, 
    0.01747081f, -0.04311632f, 0.00011611f, 0.02286485f, 0.00889682f, -0.03541729f, -0.05674722f, -0.08726878f, 
    0.03272009f, -0.04717783f, -0.01080951f, -0.08208948f, -0.02096776f, -0.02692420f, -0.03238415f, 0.01876410f, 
    0.01117046f, 0.01748014f, -0.05127205f, -0.03077278f, 0.01595582f, 0.04616631f, 0.00250246f, -0.01510659f, 
    -0.04597398f, -0.04291762f, -0.02347633f, 0.00281812f, -0.03871799f, 0.02018679f, -0.00645973f, 0.03501843f, 
    -0.01647413f, -0.05714978f, -0.04527095f, -0.01588274f, -0.06540094f, 0.00597881f, -0.05713982f, -0.01100317f, 
    -0.02351829f, 0.00157914f, -0.04150955f, 0.03565744f, -0.07627761f, -0.05147627f, -0.04917329f, -0.03387427f, 
    0.01780296f, -0.06015003f, -0.00662892f, 0.00325186f, -0.05621741f, -0.05357954f, -0.06082320f, -0.06962952f, 
    -0.04468870f, -0.01850585f, -0.02662971f, -0.06042377f, -0.04182934f, -0.01717913f, 0.01194580f, -0.01021208f, 
    0.03001016f, -0.01559495f, 0.04151619f, -0.04154979f, 0.00485355f, -0.04520380f, -0.03584960f, -0.05836251f, 
    -0.26149160f, -0.11794858f, 0.09360497f, 0.03982438f, 0.06561361f, 0.04697280f, 0.00011603f, -0.00759163f, 
    0.14359841f, -0.01201202f, 0.18558939f, 0.08986044f, 0.07882359f, 0.11857064f, -0.13194720f, 0.11119664f, 
    0.00119200f, 0.08145439f, -0.07530525f, 0.10112663f, 0.00798087f, -0.13047266f, -0.05979004f, -0.04711875f, 
    0.07753180f, -0.01300784f, 0.06078856f, -0.11199547f, -0.12460580f, -0.25471765f, 0.01049700f, 0.09785835f, 
    0.00801584f, -0.25352037f, -0.08252563f, 0.02260051f, -0.05879818f, -0.12059013f, 0.02094830f, 0.01468787f, 
    -0.00258140f, -0.07995845f, -0.04747947f, -0.01352144f, 0.00058480f, -0.17084181f, 0.19024490f, -0.02183617f, 
    0.29243916f, 0.05961776f, 0.05226680f, 0.02133473f, 0.10584249f, -0.01389581f, 0.04685608f, 0.10512231f, 
    -0.10626164f, -0.10947607f, 0.08579266f, 0.18315683f, 0.05507646f, 0.04418693f, 0.02067750f, -0.02332365f, 
    -0.22901171f, -0.03054546f, 0.00755881f, -0.07730695f, 0.06733975f, 0.02615919f, 0.01433043f, 0.02665469f, 
    0.04584396f, 0.30968970f, 0.00798645f, -0.05377814f, 0.06125443f, -0.03242507f, -0.08122681f, -0.03453409f, 
    0.00200846f, 0.13991623f, 0.03740051f, 0.10797928f, 0.04502461f, 0.00337490f, 0.07851662f, -0.06628652f, 
    0.00656583f, -0.04813033f, -0.12629555f, 0.05893870f, 0.04163795f, 0.09958817f, 0.11808378f, 0.14758217f, 
    -0.09722737f, -0.15853947f, 0.00377141f, -0.39267197f, 0.07810182f, -0.21589144f, 0.15931977f, -0.15235192f, 
    -0.15470140f, 0.04078818f, -0.00151148f, 0.03939144f, -0.21176046f, -0.04694085f, 0.07114796f, 0.22195821f, 
    0.04369498f, -0.06477955f, -0.04105700f, -0.11429381f, 0.01468299f, -0.11037946f, -0.10987592f, 0.01120588f, 
    -0.01416146f, -0.01009441f, 0.02089542f, 0.09595887f, -0.03722440f, -0.00662056f, 0.02635220f, -0.02801155f, 
    0.01454733f, 0.05233987f, -0.17289375f, -0.10095832f, -0.09678504f, -0.00972761f, 0.08504411f, 0.08436745f, 
    0.20604061f, -0.09234507f, 0.06557483f, 0.16663888f, -0.02593422f, -0.11679700f, 0.22944655f, -0.06302951f, 
    -0.09913066f, -0.10060916f, -0.26500091f, 0.14578010f, -0.08436630f, 0.21349987f, -0.01341412f, 0.01845125f, 
    -0.03602126f, -0.04282602f, -0.10518876f, 0.09897875f, 0.00510734f, 0.03254196f, 0.05500004f, 0.06046889f, 
    -0.01152318f, 0.07557079f, 0.04944792f, 0.13781808f, -0.40985364f, -0.05587789f, 0.00155345f, 0.14474790f, 
    -0.08912203f, 0.05469814f, 0.01911847f, -0.40399328f, -0.09805507f, -0.03878413f, 0.13990666f, 0.08939047f, 
    -0.07238206f, 0.01108074f, 0.01947458f, -0.01211356f, -0.11849456f, 0.12536037f, 0.27072755f, 0.04455398f, 
    0.18694824f, -0.30173063f, 0.11166117f, -0.08801182f, 0.09430112f, -0.20953636f, -0.26524374f, -0.07913945f, 
    0.00899682f, 0.10281691f, 0.17933923f, 0.02466193f, -0.16085982f, 0.01543924f, -0.06775882f, 0.14750351f, 
    0.15137246f, 0.04422101f, 0.00144520f, 0.00504442f, -0.08894375f, 0.02721229f, -0.03669771f, -0.11273341f, 
    0.12046044f, -0.17988385f, -0.03471929f, -0.02966234f, 0.16346902f, 0.03410833f, 0.07725110f, 0.01810846f, 
    0.11971718f, -0.13854480f, 0.04951219f, 0.13142028f, 0.03931522f, -0.18080610f, 0.19775109f, -0.00426484f, 
    0.16857375f, -0.24642743f, -0.00629104f, 0.10530766f, 0.05495973f, 0.03243326f, -0.10875271f, -0.01516616f, 
    0.20844960f, 0.14346901f, -0.13846193f, -0.06143088f, -0.16483054f, -0.10192349f, -0.09611828f, -0.01593580f, 
    0.07763062f, 0.13021013f, 0.10718745f, 0.20238212f, 0.31064117f, 0.14415570f, -0.06135143f, -0.06040928f, 
    0.00501104f, 0.07016222f, -0.04000057f, 0.00914730f, -0.28822216f, -0.15662065f, 0.02560065f, 0.11902288f, 
    0.05985665f, -0.07601313f, -0.00760354f, 0.00553253f, 0.16095661f, -0.05078577f, 0.02177922f, 0.20325150f, 
    0.13354072f, 0.00465232f, -0.15086879f, 0.04429194f, -0.02708760f, -0.05983845f, 0.00634256f, 0.17346483f, 
    0.05298466f, 0.01626336f, 0.12071551f, -0.04196147f, -0.03440082f, 0.00276001f, 0.04098432f, -0.12956986f, 
    -0.22813490f, -0.10842977f, 0.07146276f, 0.24490884f, -0.03058527f, -0.02196538f, -0.35243440f, -0.28816107f, 
    0.07078067f, 0.26251221f, 0.25233933f, 0.09139375f, -0.06184438f, 0.01032524f, 0.18187796f, -0.05319811f, 
    0.01035173f, -0.13693050f, 0.28517780f, 0.15758280f, 0.09977196f, 0.04725739f, 0.00937296f, 0.13995367f, 
    0.09957422f, -0.01631439f, -0.01646560f, -0.09536713f, -0.17172977f, -0.01095383f, -0.07894887f, -0.02303257f, 
    0.11453049f, 0.13750154f, -0.06593320f, -0.17790817f, -0.23615135f, -0.03883738f, -0.06284370f, -0.01383700f, 
    0.04148733f, -0.12987806f, 0.16515711f, 0.02250093f, -0.16381752f, -0.03817897f, -0.05345479f, -0.01162956f, 
    0.11531364f, -0.00930601f, -0.11420084f, -0.01466598f, 0.02326605f, -0.10854032f, 0.11734036f, -0.04335596f, 
    0.24558879f, 0.20066360f, 0.08721828f, 0.01154939f, 0.00479899f, -0.22988801f, -0.29825166f, -0.01846147f, 
    0.06494501f, 0.12218793f, 0.14558756f, -0.10998246f, 0.09359621f, -0.03396586f, 0.06508960f, 0.11102863f, 
    0.19611937f, 0.17374441f, -0.11968968f, 0.00433501f, 0.15421042f, 0.07902078f, 0.10867360f, 0.00812865f, 
    -0.56983870f, -0.30668095f, -0.32836726f, 0.25978705f, 0.08734801f, 0.10301168f, 0.07545916f, -0.10163803f, 
    -0.05046942f, 0.12283883f, 0.15115622f, 0.13619320f, -0.01023121f, 0.04627576f, -0.03586350f, -0.00054794f, 
    0.10863928f, 0.08095846f, 0.04234080f, 0.10751273f, -0.04922637f, 0.13206480f, -0.07262347f, -0.01639946f, 
    0.15640348f, -0.02384377f, 0.21555366f, -0.08676428f, -0.02685148f, -0.30533043f, -0.04565343f, 0.05183826f, 
    -0.05544914f, -0.05764460f, -0.22125570f, 0.07551049f, 0.07520011f, 0.06862215f, 0.16260517f, 0.01722662f, 
    -0.00024282f, -0.00478621f, -0.01270404f, 0.02043698f, -0.00110603f, -0.40880617f, -0.18637893f, 0.28653166f, 
    0.28582919f, 0.03946688f, -0.19391772f, 0.09412284f, -0.09648450f, -0.07584911f, 0.03991605f, 0.04324459f, 
    0.30617318f, -0.01395131f, -0.11180236f, -0.08933073f, 0.12349387f, 0.04804412f, 0.11843899f, -0.17570719f, 
    0.11395011f, -0.24488734f, 0.11374004f, -0.10109660f, 0.02452365f, -0.06580956f, 0.05709307f, -0.16056883f, 
    -0.29775754f, -0.24639209f, -0.33775944f, 0.10160042f, 0.05293194f, -0.06202893f, -0.00794190f, -0.07217903f, 
    -0.02435585f, 0.22730137f, 0.12954161f, -0.03822232f, 0.02079192f, 0.04898252f, 0.18547915f, 0.07175004f, 
    0.16437100f, 0.17595407f, 0.35561135f, 0.08705977f, -0.24013823f, 0.13098392f, -0.06021925f, 0.00139089f, 
    0.09135009f, 0.28297293f, 0.15814330f, 0.00256644f, -0.20762336f, 0.02640858f, -0.25303715f, 0.05393042f, 
    0.07186923f, -0.00343453f, -0.12465902f, 0.04347108f, -0.01396977f, -0.19772254f, -0.28997305f, 0.02308431f, 
    0.10279489f, -0.09439420f, -0.08832553f, 0.14296654f, 0.03825129f, -0.25102565f, -0.19242354f, 0.03607935f, 
    -0.06295951f, -0.03953941f, 0.08085503f, 0.03316372f, 0.11991772f, 0.04071677f, -0.31311268f, -0.29082185f, 
    -0.08230345f, 0.12641627f, 0.01545974f, 0.03930856f, -0.01290123f, -0.08080200f, 0.07531638f, -0.13699895f, 
    -0.15579945f, -0.24977955f, 0.04378553f, -0.06451365f, 0.04637897f, 0.04233835f, 0.01692927f, 0.10291743f, 
    -0.00020482f, 0.12431531f, 0.10616513f, -0.05237022f, -0.08122895f, 0.21217908f, -0.01045259f, 0.02218717f, 
    -0.22154127f, 0.03143500f, -0.02645429f, 0.06837891f, 0.14515468f, 0.01271139f, 0.13851860f, 0.28014272f, 
    0.02127817f, -0.02344862f, -0.30772629f, -0.17651330f, -0.23955263f, -0.05000210f, -0.06637269f, 0.03510724f, 
    0.00816232f, -0.19883528f, -0.10406163f, -0.05028578f, -0.06253187f, -0.27467206f, 0.11126166f, -0.03361394f, 
    0.01563422f, 0.18334967f, 0.24901445f, -0.04863134f, 0.22093427f, 0.02532011f, 0.07079572f, -0.11489674f, 
    0.06506664f, 0.04057733f, 0.14462601f, -0.06646031f, -0.10779396f, 0.07775130f, 0.05521474f, -0.48742986f, 
    0.20617659f, 0.07357312f, -0.01564832f, -0.01548692f, -0.10018802f, 0.01798236f, -0.10300508f, -0.03467394f, 
    -0.19318415f, 0.20234737f, 0.04608256f, 0.07222774f, 0.03538404f, -0.01179510f, 0.02452026f, -0.40312913f, 
    -0.33539289f, -0.14690509f, -0.03924866f, 0.07982890f, 0.19631258f, -0.16032895f, -0.17169346f, -0.12448750f, 
    0.04986895f, -0.02704450f, -0.11838506f, 0.18030156f, 0.00355069f, 0.01318299f, -0.15318842f, -0.01855331f, 
    0.11641328f, 0.14785899f, 0.10633777f, 0.17539476f, -0.02770591f, -0.04356150f, -0.01895630f, 0.01834080f, 
    0.00112499f, 0.08100282f, 0.07618845f, -0.04611755f, -0.14993347f, -0.11569368f, -0.10147398f, 0.00062919f, 
    0.04075173f, -0.06157217f, 0.01651113f, -0.43178248f, 0.05414718f, -0.45023963f, 0.19085255f, -0.11368924f, 
    0.08253540f, 0.04110600f, 0.04944830f, 0.01924838f, -0.36158541f, 0.03529739f, -0.00630635f, 0.07638585f, 
    0.01728315f, -0.02939149f, 0.14678697f, 0.09744934f, 0.03563483f, -0.42946807f, 0.07792415f, 0.39640373f, 
    0.10689136f, -0.03224004f, -0.19571131f, 0.05092921f, 0.02986624f, 0.11463267f, -0.34202057f, -0.03052023f, 
    0.19936527f, 0.05547340f, 0.02891510f, 0.06635719f, 0.05736955f, -0.16545935f, 0.20450290f, 0.14060406f, 
    0.10826202f, -0.11983207f, 0.17241769f, -0.00198732f, 0.03044094f, -0.04437145f, -0.05540958f, -0.05645319f, 
    -0.08119140f, -0.00001680f, 0.40850073f, -0.19307446f, -0.02757989f, 0.01810522f, -0.17092527f, -0.04880647f, 
    0.12612370f, -0.21596621f, -0.09639315f, -0.15650247f, 0.01444871f, 0.04935424f, -0.03733145f, -0.07353546f, 
    0.17451182f, -0.02996238f, 0.10695037f, -0.28125370f, -0.03379419f, -0.13776487f, 0.01273341f, -0.09765659f, 
    0.01486786f, 0.02526881f, 0.10304569f, -0.03093851f, -0.04334822f, -0.05277827f, -0.15909982f, -0.01701270f, 
    -0.03625923f, 0.02939156f, 0.15031241f, 0.09899185f, -0.41009837f, -0.02279500f, -0.13701314f, 0.22101238f, 
    0.05722893f, -0.02674028f, 0.11138815f, -0.02783533f, -0.09575114f, 0.09084597f, -0.05593459f, -0.38535020f, 
    0.07650275f, -0.33744702f, -0.06326624f, 0.08626903f, -0.07291680f, 0.14915429f, -0.13908371f, -0.02176846f, 
    0.20887032f, 0.04676453f, 0.09868801f, -0.14853764f, -0.03720612f, 0.11139017f, 0.01423067f, 0.03617487f, 
    0.04549611f, 0.10306331f, 0.03670358f, -0.12423200f, -0.04463207f, -0.01828270f, -0.02942703f, 0.02537181f, 
    0.00909687f, 0.08955845f, 0.05487456f, 0.07834806f, -0.01567368f, -0.06061841f, -0.07600457f, 0.02938174f, 
    -0.03729235f, -0.06530558f, -0.12321249f, -0.54799992f, 0.12751754f, 0.01017935f, 0.06007188f, -0.03154057f, 
    0.01592498f, -0.01031554f, -0.25514844f, -0.27241185f, 0.15707068f, 0.18486823f, 0.03798353f, -0.03796114f, 
    -0.03439975f, 0.01034177f, 0.13316621f, 0.22157109f, 0.11277735f, -0.15024333f, 0.05760618f, -0.03518370f, 
    -0.12675102f, 0.11432798f, -0.01978399f, 0.05677276f, 0.18632318f, 0.10239378f, 0.24438776f, -0.05602369f, 
    0.02762354f, -0.03598861f, 0.08417491f, 0.17348649f, 0.02325196f, -0.06451856f, -0.00553288f, -0.36808738f, 
    0.09004075f, 0.09369619f, -0.03799424f, 0.00655106f, 0.05008563f, -0.07486477f, 0.06426761f, 0.10983527f, 
    0.19026726f, -0.10632451f, -0.01509148f, -0.05655444f, -0.05449930f, -0.10305932f, 0.12446161f, 0.11371720f, 
    -0.04531610f, 0.01245113f, -0.00024451f, -0.03007093f, -0.04918416f, 0.19580640f, 0.05448201f, 0.03294575f, 
    0.00674487f, -0.06910489f, 0.18712986f, 0.03195702f, -0.14477114f, -0.07794712f, 0.14507741f, 0.06139161f, 
    0.11740804f, 0.06286091f, 0.11007666f, -0.21066101f, -0.02546100f, 0.05813360f, 0.01170548f, 0.01960663f, 
    0.03661961f, -0.25891733f, 0.02887069f, -0.10720547f, 0.12791015f, 0.02506254f, -0.07308279f, 0.12151692f, 
    0.05710407f, -0.18587676f, 0.01909138f, -0.05130126f, 0.07343350f, 0.34721324f, -0.00355175f, 0.08529621f, 
    0.10186696f, -0.09704616f, -0.06816543f, 0.03619949f, 0.22328243f, 0.11359045f, -0.19994302f, 0.08161155f, 
    0.11810420f, -0.04828139f, 0.19012415f, 0.09769920f, -0.20125154f, -0.09942815f, 0.12931842f, 0.12956950f, 
    -0.07649138f, 0.05897325f, -0.06101638f, 0.16526008f, 0.11250050f, 0.04505958f, -0.10803390f, -0.04595919f, 
    0.29990175f, 0.00973124f, -0.08307573f, -0.05372422f, -0.07620770f, 0.06815566f, 0.06458581f, -0.08654885f, 
    0.03298173f, -0.05084462f, -0.08878731f, 0.11430090f, 0.13219833f, -0.05609700f, -0.16400653f, -0.03175360f, 
    -0.15164052f, -0.30740255f, 0.02609088f, -0.05725116f, -0.04645661f, 0.07834740f, -0.04612100f, -0.00282421f, 
    -0.09558021f, -0.19508614f, -0.05244319f, 0.06590966f, 0.01823925f, 0.02854271f, -0.15706545f, 0.03872541f, 
    -0.04042020f, -0.02565491f, 0.06840185f, -0.08237884f, -0.02127534f, 0.13624755f, -0.15416250f, 0.05301440f, 
    -0.09520431f, 0.01813831f, -0.10505015f, 0.16261907f, -0.10009108f, 0.09469102f, -0.01689990f, -0.18361460f, 
    -0.06692623f, -0.05706922f, -0.03914197f, -0.01572411f, -0.03118049f, 0.21815054f, -0.03265847f, -0.08735722f, 
    -0.08305350f, 0.02924045f, -0.11266202f, 0.00183610f, -0.07043439f, -0.07916444f, 0.21967548f, -0.07700625f, 
    0.11625685f, -0.10017252f, -0.12684715f, 0.07839526f, -0.07721065f, -0.17555195f, 0.07628041f, 0.11079339f, 
    -0.12009899f, 0.04464929f, -0.01403816f, -0.09468678f, 0.11552945f, 0.05854833f, -0.07181976f, 0.14052221f, 
    -0.12168469f, 0.05965115f, -0.15024364f, -0.15209232f, -0.05046386f, -0.03012137f, -0.02757061f, 0.02697218f, 
    -0.01931208f, 0.14526026f, 0.11161767f, 0.11155333f, 0.00950929f, -0.07469659f, -0.14275444f, 0.12918724f, 
    0.16347337f, -0.12973940f, -0.04163014f, 0.04192943f, -0.06986675f, -0.01179259f, 0.09004749f, 0.19680558f, 
    0.09490680f, -0.04140306f, 0.10373989f, -0.13989611f, 0.09733062f, -0.03120387f, -0.01439342f, -0.00344875f, 
    0.29723039f, 0.05303382f, 0.08662530f, 0.31886140f, -0.01004523f, 0.04931144f, 0.03642216f, 0.01407867f, 
    0.10939327f, -0.07325779f, -0.01029428f, -0.18680051f, -0.12965181f, -0.39109671f, 0.19749267f, -0.17030059f, 
    -0.07406680f, 0.05388100f, -0.00710827f, 0.07333535f, 0.10765892f, 0.33261159f, 0.08862993f, 0.08596385f, 
    0.10146077f, 0.00881545f, -0.11326740f, -0.15173526f, 0.16072944f, 0.11944234f, -0.24233763f, -0.30472425f, 
    0.03129176f, -0.01624405f, 0.06514049f, 0.06787622f, -0.00779267f, -0.08720243f, -0.04204719f, 0.14588504f, 
    0.07960461f, -0.14769921f, -0.03269402f, 0.05487786f, 0.20109384f, -0.01030953f, 0.08711302f, 0.11402062f, 
    0.08041731f, 0.13436174f, -0.24625199f, -0.19011649f, -0.11254467f, 0.08262965f, 0.17602979f, -0.01374722f, 
    0.05456483f, 0.14234492f, -0.23028703f, -0.01692647f, -0.21898358f, -0.06844187f, -0.22375451f, -0.01238973f, 
    -0.10539012f, 0.10847443f, -0.02122490f, -0.04689555f, 0.14993410f, -0.04275446f, 0.05384654f, -0.09614896f, 
    0.08113357f, 0.02291311f, -0.02175087f, -0.26791659f, -0.14331692f, 0.06075063f, -0.01576481f, -0.08243336f, 
    0.06663623f, -0.04097101f, -0.03510598f, 0.02464564f, -0.16031733f, -0.20891289f, -0.38050541f, 0.01651183f, 
    0.12204710f, -0.10475597f, -0.03058924f, 0.09011688f, 0.09299975f, 0.13260806f, 0.07687070f, 0.15319496f, 
    0.18359168f, -0.05452562f, -0.07614394f, -0.01411717f, 0.07427438f, 0.00716782f, -0.09888186f, 0.00551429f, 
    0.18141253f, 0.05149693f, 0.05645506f, -0.03829304f, -0.07432717f, 0.05242832f, 0.22288753f, 0.24897756f, 
    -0.12430748f, 0.07794290f, 0.07714429f, 0.02560357f, 0.00757601f, 0.08153435f, -0.08132120f, -0.04752588f, 
    -0.07937710f, -0.07531972f, 0.21392033f, -0.12227123f, 0.11811145f, -0.09702947f, -0.07109085f, -0.08962389f, 
    0.12380308f, -0.02269591f, -0.31005085f, -0.03451302f, 0.10509157f, 0.02992668f, 0.18467146f, -0.02574606f, 
    0.04036583f, -0.11193608f, -0.20165640f, 0.19093008f, 0.01606455f, 0.07473722f, 0.08650263f, -0.02013312f, 
    -0.11093894f, 0.00628448f, 0.05320854f, 0.00393411f, 0.21198185f, -0.08362366f, 0.12817270f, -0.00881345f, 
    0.05241672f, -0.00815781f, 0.06899958f, 0.07384259f, 0.03958109f, -0.19961537f, 0.16294670f, -0.08592449f, 
    0.03527751f, 0.05914673f, -0.12593433f, 0.01055637f, 0.15694483f, -0.02183598f, 0.26880878f, 0.01582820f, 
    0.00537160f, -0.01545783f, -0.02215266f, 0.10121172f, 0.08010940f, 0.10149555f, 0.03606272f, 0.21718965f, 
    0.01564017f, 0.02436834f, 0.05897596f, 0.03767408f, -0.00695453f, 0.10370604f, -0.05828803f, 0.08389956f, 
    0.28394818f, 0.16404122f, 0.04157769f, -0.04777266f, 0.13390739f, -0.02750135f, 0.09343899f, -0.12992598f, 
    0.01875727f, -0.03704327f, 0.02926500f, -0.04774529f, -0.01765055f, -0.04198859f, 0.04109288f, -0.03845752f, 
    -0.02890788f, -0.05359552f, -0.01718643f, 0.00596321f, -0.02428606f, 0.02284785f, -0.01548100f, -0.01132989f, 
    -0.02712151f, -0.01470286f, -0.00699716f, 0.00417413f, 0.03248800f, 0.04654368f, 0.03947252f, 0.00857143f, 
    0.00099818f, 0.02129345f, -0.05796568f, 0.01465422f, -0.05056688f, 0.03918856f, -0.05902717f, 0.03694368f, 
    -0.01568520f, 0.01773138f, -0.01516689f, -0.04625923f, -0.00988356f, -0.01256163f, 0.02542476f, -0.06077595f, 
    0.04540313f, -0.06819154f, -0.01656136f, -0.02271635f, 0.04271316f, -0.06591364f, -0.02473543f, -0.01883771f, 
    -0.05610578f, -0.04914129f, 0.03154698f, 0.01846839f, 0.04321316f, 0.03166962f, 0.04434893f, -0.06598073f, 
    0.01708267f, 0.05031699f, 0.00083358f, -0.01405325f, -0.03570388f, 0.01654725f, 0.00069860f, -0.06504255f, 
    0.02035046f, -0.01183971f, -0.06107853f, -0.01648363f, 0.03715276f, 0.00511964f, -0.00720597f, -0.03914806f, 
    -0.01781577f, 0.02246289f, -0.05426090f, -0.06719819f, -0.03241508f, -0.01082614f, 0.00926942f, 0.04576619f, 
    -0.00526295f, -0.02295380f, -0.03263652f, -0.02517400f, 0.05518476f, 0.04165389f, -0.00708583f, 0.00906121f, 
    -0.00132541f, -0.04033307f, 0.02180721f, 0.00653529f, 0.01781278f, -0.04317315f, -0.03086382f, 0.00015709f, 
    0.01731155f, 0.04408276f, 0.00038016f, -0.00425272f, -0.02054536f, 0.00837375f, -0.02476338f, 0.02496705f, 
    0.01894700f, -0.03186587f, 0.01467445f, -0.02949320f, -0.00461392f, 0.03502459f, -0.01022637f, 0.00951027f, 
    0.04451096f, -0.01559311f, -0.04832334f, 0.03542863f, -0.06692144f, -0.06863734f, -0.06195470f, 0.04171744f, 
    0.03354410f, -0.00153044f, -0.01134332f, -0.01972825f, -0.04546707f, -0.04948468f, 0.02650999f, -0.03513656f, 
    -0.03563254f, -0.00089797f, -0.05956598f, 0.00217247f, 0.00955131f, -0.03747992f, -0.04434285f, -0.03805408f, 
    0.04411399f, -0.00396770f, -0.02934533f, 0.04818993f, -0.03533810f, -0.04101240f, -0.01329309f, -0.01928376f, 
    -0.04792069f, -0.05430207f, -0.00963693f, 0.01264999f, -0.03386356f, -0.03749292f, -0.01133534f, 0.00221028f, 
    0.00052420f, -0.00570692f, -0.00198977f, 0.01292085f, 0.03368212f, 0.02881989f, 0.00361939f, 0.00530076f, 
    -0.03714167f, -0.02298420f, 0.00401079f, -0.00642751f, 0.01729264f, 0.03230905f, -0.01907314f, -0.06930069f, 
    0.00004156f, -0.02349191f, -0.05115591f, -0.02667893f, -0.02032349f, 0.02341617f, 0.04235718f, -0.01686299f, 
    0.01069928f, 0.03789290f, -0.01187395f, -0.04485443f, -0.01166505f, 0.04625785f, -0.05065069f, 0.00876267f, 
    0.01083068f, -0.01642403f, -0.03882833f, -0.00250050f, -0.02361939f, 0.03321988f, -0.01712522f, 0.00807919f, 
    0.00756494f, 0.02315723f, -0.05808751f, 0.03627841f, -0.02721537f, -0.04897062f, -0.01974864f, -0.03295630f, 
    -0.04552832f, 0.01185153f, -0.05997950f, -0.01660892f, -0.00351305f, -0.00163335f, -0.02864569f, -0.03053862f, 
    -0.01984463f, 0.02689846f, 0.04429850f, 0.05443211f, -0.01679516f, 0.04773790f, -0.04453187f, -0.01375272f, 
    0.02913334f, -0.01556502f, 0.01350514f, 0.03839077f, -0.03958326f, -0.05912878f, -0.02015598f, -0.06797315f, 
    0.03397473f, -0.00750429f, 0.03081467f, 0.00510849f, 0.00267749f, -0.01971160f, 0.04391633f, -0.01287000f, 
    0.00394904f, 0.03907589f, 0.02201029f, 0.00106494f, -0.03712877f, -0.02401885f, -0.01563258f, 0.03948451f, 
    -0.04463120f, 0.00784058f, -0.02545936f, 0.02527342f, 0.04854914f, -0.04093144f, 0.00988262f, 0.00149114f, 
    -0.06140593f, 0.02202090f, -0.01572361f, 0.04573986f, -0.05572562f, 0.02366909f, -0.02254389f, -0.06105352f, 
    0.04098310f, 0.01816782f, -0.00202763f, 0.02913973f, -0.00452891f, 0.01040964f, -0.03834696f, 0.01542627f, 
    -0.05723872f, -0.05440382f, 0.04799074f, -0.02945315f, -0.03243573f, -0.01828437f, 0.03101001f, -0.02530233f, 
    0.00089311f, 0.00598797f, 0.04439651f, -0.04178034f, -0.00862278f, -0.04506285f, -0.04482546f, 0.00246059f, 
    -0.05065504f, -0.04664432f, 0.02611042f, 0.01091926f, 0.00584127f, -0.05523076f, 0.04513166f, -0.00505123f, 
    0.04824244f, 0.03310799f, 0.00423141f, 0.02291974f, 0.04620434f, 0.05186937f, 0.03383624f, -0.02764870f, 
    0.02377518f, 0.00861946f, -0.01903378f, 0.02602453f, -0.06699886f, -0.02658196f, -0.00465307f, -0.01704341f, 
    0.00904608f, 0.03366266f, 0.04407220f, -0.02089936f, -0.00621688f, -0.02444628f, 0.04782780f, 0.04547556f, 
    -0.00160417f, -0.02347617f, 0.00634760f, -0.02757324f, 0.01765801f, -0.04207002f, 0.02865339f, 0.02799383f, 
    -0.03664897f, 0.00090870f, 0.04401623f, -0.06868795f, -0.00753419f, 0.00384510f, -0.06059280f, 0.02016268f, 
    -0.01101492f, -0.06507286f, -0.05200549f, -0.02033076f, -0.01337892f, -0.05114875f, 0.01460555f, -0.01934419f, 
    0.03451515f, -0.02869832f, -0.01001134f, 0.03928993f, -0.03617601f, -0.03902021f, -0.04755337f, 0.02065155f, 
    0.02111118f, 0.03204928f, 0.02996924f, -0.00016065f, 0.03992390f, -0.00626600f, -0.01458154f, 0.02763294f, 
    0.03814411f, 0.04333915f, -0.06981477f, 0.00297764f, -0.04059020f, -0.01673874f, -0.02747760f, -0.04940925f, 
    0.04110591f, -0.01911516f, -0.04401819f, -0.06020306f, -0.02588559f, 0.02668550f, -0.02892716f, 0.00403277f, 
    -0.02708421f, -0.03833362f, -0.01766347f, -0.02551550f, 0.03746919f, 0.03146294f, -0.03721811f, -0.05468699f, 
    0.03566215f, -0.04830285f, 0.01268567f, -0.04253820f, -0.05369001f, 0.00456869f, 0.01619098f, -0.00765275f, 
    0.03102207f, -0.02185911f, -0.04382993f, -0.05166965f, -0.00019855f, -0.07172728f, -0.01291087f, 0.02183020f, 
    -0.03937431f, 0.02689799f, 0.01667343f, -0.01142693f, 0.01358122f, 0.01471810f, 0.04500452f, 0.01473101f, 
    -0.02146407f, 0.00750388f, -0.01701547f, 0.01530701f, -0.00684745f, 0.02868362f, 0.00356853f, 0.02569846f, 
    -0.00588668f, -0.05242120f, 0.00342061f, 0.02625545f, -0.05378115f, 0.00889068f, -0.01321536f, 0.05021449f, 
    0.00735154f, 0.01490379f, 0.02288990f, -0.03466595f, 0.02527216f, -0.00911006f, -0.03512095f, -0.00478378f, 
    0.04264066f, 0.05752115f, -0.05882186f, 0.04299676f, 0.01611763f, -0.01544685f, 0.00410535f, -0.01815644f, 
    0.04288558f, -0.06519591f, 0.00294231f, -0.00919348f, -0.04492224f, 0.02563364f, 0.00412109f, -0.02569783f, 
    -0.05349995f, -0.04771674f, 0.00032649f, -0.00340252f, 0.04050835f, -0.00782283f, 0.01986611f, -0.04171225f, 
    0.01193494f, -0.04697355f, -0.00032667f, -0.06545352f, -0.02256242f, -0.00401468f, -0.00893495f, 0.04578848f, 
    -0.03261498f, -0.01799310f, -0.03122624f, 0.04801765f, 0.00793821f, -0.02598755f, 0.02017284f, -0.02045631f, 
    -0.05107385f, -0.07400428f, -0.05827799f, -0.00476483f, -0.03242438f, 0.04346984f, -0.04001052f, -0.05224929f, 
    0.04843651f, -0.01035524f, -0.06677664f, 0.04952149f, -0.05492007f, -0.03399600f, 0.03552891f, 0.02763969f, 
    0.03826958f, 0.00514238f, 0.00403459f, -0.06025868f, 0.01258288f, -0.04126018f, -0.00365966f, 0.00288869f, 
    0.03631987f, -0.01169294f, 0.01104028f, -0.01037480f, -0.01004923f, -0.02765519f, -0.07552214f, -0.04306436f, 
    0.02468218f, -0.00514987f, -0.04551033f, -0.01065295f, -0.02111967f, 0.00060716f, -0.05014731f, -0.05377849f, 
    -0.03370014f, -0.01836415f, 0.04089652f, 0.02235310f, -0.02597962f, -0.03610349f, -0.01098860f, 0.04776744f, 
    -0.05151759f, 0.02711956f, -0.04200972f, -0.00399381f, -0.01359778f, 0.04768416f, 0.01491182f, -0.07071993f, 
    -0.00633047f, 0.03205247f, -0.01519217f, 0.03976560f, 0.01536780f, 0.00690402f, 0.03210484f, -0.03908570f, 
    0.03347949f, -0.01479849f, -0.06822903f, -0.00476810f, 0.01661959f, 0.02126256f, 0.01678888f, 0.03189038f, 
    -0.00947436f, 0.01951353f, -0.06141673f, -0.03382207f, 0.00217302f, -0.02661379f, -0.03623299f, -0.03263969f, 
    0.02513760f, -0.04885749f, 0.02745910f, -0.00990947f, -0.02052389f, -0.02814835f, 0.01075239f, -0.07739834f, 
    0.02407928f, -0.04047706f, -0.04198037f, 0.01787377f, 0.03761116f, 0.04972617f, -0.00505008f, -0.06516629f, 
    -0.05710396f, -0.06939993f, 0.01780090f, -0.02759551f, 0.00449388f, 0.00658206f, -0.02634919f, -0.01801929f, 
    -0.05422346f, -0.04786202f, -0.06496473f, -0.04530961f, 0.01097249f, -0.06569998f, 0.02806846f, 0.02257036f, 
    0.25924474f, -0.03648242f, -0.13966134f, -0.01338309f, -0.03241739f, 0.12841977f, 0.07275739f, -0.09039427f, 
    0.13717522f, -0.09688003f, -0.23758405f, -0.06208814f, 0.12024178f, 0.06489421f, -0.03863258f, 0.17239705f, 
    -0.12365636f, -0.04891312f, -0.00923128f, -0.03691921f, -0.14592549f, -0.02282779f, 0.08757031f, -0.14340298f, 
    0.07369236f, -0.06408028f, 0.12889549f, -0.31420401f, -0.15887414f, 0.06150503f, 0.06131998f, 0.06059908f, 
    -0.00602201f, -0.05830105f, -0.20360895f, -0.11270764f, 0.11896055f, 0.16554973f, 0.07513607f, -0.01601131f, 
    0.05486902f, -0.08939984f, -0.08677669f, -0.06306767f, -0.03690886f, 0.20371759f, 0.21397382f, -0.01626183f, 
    0.00275707f, 0.04273247f, 0.03732819f, -0.08697028f, 0.00224818f, 0.07475725f, 0.23197399f, 0.03669507f, 
    -0.13188002f, -0.10538561f, 0.15535331f, -0.12657405f, 0.01949981f, 0.22380304f, -0.00432100f, 0.28033698f, 
    0.15115778f, 0.03595912f, 0.01762603f, -0.06564000f, 0.02979771f, 0.07423187f, 0.05360963f, -0.06225780f, 
    -0.12024078f, 0.10323390f, -0.02811440f, 0.22881579f, 0.07338566f, -0.03848997f, 0.01905359f, -0.07586783f, 
    0.03690236f, -0.13650037f, -0.21246105f, -0.34777609f, 0.03516670f, -0.02976718f, 0.06392132f, -0.14293791f, 
    0.14482164f, -0.10863584f, -0.13137694f, 0.01428689f, 0.02074137f, 0.08875329f, -0.02449073f, 0.00362810f, 
    -0.14221145f, -0.05040469f, -0.00273888f, 0.19827899f, 0.33085594f, -0.18401338f, -0.03202000f, -0.12546565f, 
    0.05137580f, -0.02842763f, 0.01389153f, -0.11398844f, -0.17613572f, 0.30452308f, -0.00966612f, 0.02803404f, 
    -0.09744105f, 0.14563408f, -0.08834138f, -0.03575972f, 0.05467141f, 0.18155912f, -0.13502878f, -0.34288406f, 
    0.10363614f, 0.10927251f, 0.00358424f, -0.11757702f, 0.06121850f, 0.30164596f, 0.20582466f, 0.03996366f, 
    -0.23737901f, 0.04551776f, -0.04959589f, 0.04361651f, -0.16840494f, 0.12062062f, 0.14571677f, 0.27102956f, 
    0.05889867f, -0.00792612f, -0.04034423f, 0.06260537f, 0.03821195f, -0.12304252f, -0.01523549f, 0.03033199f, 
    -0.03339208f, -0.00432576f, 0.06997116f, 0.15599604f, -0.28393081f, 0.13701348f, 0.15077323f, 0.00698926f, 
    -0.16683763f, -0.06496191f, -0.06405013f, -0.25550792f, 0.01982014f, 0.06349435f, 0.02014536f, -0.04372402f, 
    -0.01729484f, -0.10786126f, -0.26408827f, -0.08892907f, 0.03882423f, -0.10719065f, 0.06651917f, 0.17147498f, 
    -0.08276325f, -0.07777404f, 0.06541265f, 0.17227848f, 0.07037370f, 0.03047900f, 0.07975697f, 0.06867347f, 
    -0.07644442f, 0.07936770f, 0.01298627f, -0.01575709f, -0.32071590f, -0.31509581f, 0.01356874f, 0.22351812f, 
    0.13274552f, -0.02358472f, 0.01135518f, -0.22115420f, -0.15071416f, -0.03437083f, -0.06929387f, 0.02593214f, 
    0.09338999f, -0.00120782f, -0.01502287f, -0.02664162f, -0.04265685f, -0.02813442f, -0.17524143f, -0.03360972f, 
    -0.07866984f, 0.08625161f, -0.04413286f, 0.03434360f, -0.07726280f, -0.03400169f, -0.00030468f, 0.15270051f, 
    0.01771540f, -0.15703151f, -0.00568820f, 0.03545797f, 0.29907200f, 0.05913320f, 0.03813520f, -0.17482398f, 
    0.05395153f, 0.12501740f, -0.23841824f, 0.04645093f, 0.00255690f, 0.07861452f, 0.16434963f, -0.21780758f, 
    0.18255420f, 0.29186618f, -0.05956887f, -0.08231397f, -0.02157971f, -0.11883119f, -0.08930757f, 0.11706381f, 
    0.04131852f, 0.06235918f, 0.09485891f, -0.09252285f, -0.12417775f, -0.10578459f, 0.00711915f, 0.11058430f, 
    -0.15193616f, -0.08238705f, 0.00244095f, -0.02335426f, 0.09569553f, 0.02641625f, 0.17520492f, -0.01966926f, 
    -0.15165955f, 0.09554996f, 0.04158390f, -0.08726192f, 0.20043242f, -0.06177502f, -0.01439732f, -0.11417212f, 
    0.02005626f, -0.08528098f, 0.30430564f, -0.18177162f, 0.18561475f, 0.10517590f, -0.06660192f, 0.10457540f, 
    0.01817217f, -0.05588267f, -0.27273354f, -0.22547002f, 0.08729314f, 0.12605873f, 0.03361900f, 0.06976745f, 
    0.05148219f, 0.08533495f, -0.01902769f, -0.12363679f, -0.00777682f, 0.13584234f, -0.01460570f, 0.14196384f, 
    0.06350030f, 0.16883448f, 0.27818742f, 0.15419525f, -0.04366769f, -0.18051167f, 0.07876980f, -0.14016031f, 
    -0.17646451f, 0.00258891f, -0.18345939f, -0.06915256f, -0.05924513f, 0.05516743f, -0.01519916f, 0.01420073f, 
    0.06419273f, 0.17552142f, 0.16389373f, -0.03163587f, -0.04774213f, 0.02023565f, -0.01399439f, -0.09760807f, 
    0.03506644f, -0.06356452f, 0.16792160f, 0.03797878f, -0.32317480f, 0.12208103f, -0.00671715f, -0.07668857f, 
    -0.02400935f, 0.00201990f, -0.06271805f, -0.26857656f, -0.09611410f, -0.00390262f, -0.02670609f, -0.11419168f, 
    -0.13190851f, -0.08918604f, -0.06044978f, 0.08089396f, 0.00126117f, -0.16347647f, 0.10207500f, -0.06509625f, 
    -0.11300574f, -0.25000337f, -0.07701729f, 0.00862530f, -0.01895474f, 0.02582137f, 0.00935217f, 0.27966791f, 
    0.16386537f, 0.05320936f, 0.08850864f, -0.11305992f, 0.07003057f, 0.05962261f, -0.22759534f, 0.03478142f, 
    0.18415985f, -0.06207627f, 0.01001403f, 0.02570935f, 0.08022232f, -0.03372638f, 0.09593024f, -0.43601665f, 
    0.22736187f, -0.09164733f, -0.03503807f, -0.09068584f, -0.19850007f, -0.05012489f, 0.02513112f, 0.04665836f, 
    0.17667440f, -0.10602367f, 0.04377237f, 0.03098966f, -0.03477354f, 0.13368145f, 0.03203900f, 0.08105309f, 
    0.07648021f, 0.09459729f, 0.08026069f, 0.20347013f, -0.20133272f, -0.05361721f, 0.16990149f, -0.01280239f, 
    0.04318908f, -0.00156689f, 0.33765200f, 0.06949980f, -0.06245061f, -0.09688237f, -0.10322609f, 0.11882605f, 
    -0.19417071f, -0.10863484f, 0.03037896f, 0.25722674f, 0.06240439f, 0.03109636f, 0.10412405f, -0.04241017f, 
    0.08328801f, -0.08179018f, 0.00112660f, 0.09087674f, 0.35933176f, 0.05980830f, -0.13745187f, -0.16110235f, 
    -0.02229364f, 0.04502801f, -0.03961874f, -0.00013166f, -0.04921889f, -0.10769396f, 0.13238972f, 0.08911449f, 
    0.04928044f, 0.12924293f, 0.13867393f, -0.02113817f, 0.16519168f, 0.02972153f, 0.04685343f, -0.02592636f, 
    -0.00901773f, -0.15000737f, -0.06083047f, -0.08124981f, 0.06914337f, 0.06549735f, -0.11855477f, 0.29997137f, 
    -0.04772043f, 0.50122261f, -0.00003796f, 0.21004532f, 0.10266506f, -0.02681671f, -0.02447367f, 0.06120622f, 
    0.20399642f, -0.07397705f, 0.09639914f, -0.00892280f, 0.04524827f, 0.07715441f, -0.17126346f, -0.11702632f, 
    -0.01407777f, 0.19639009f, 0.05725081f, -0.29727480f, -0.00546330f, -0.12741058f, -0.15890722f, -0.00463858f, 
    -0.00537184f, -0.01513877f, -0.06730615f, 0.02046653f, -0.07444280f, 0.07486061f, -0.07810038f, 0.13248023f, 
    -0.05870287f, 0.07029715f, 0.10399332f, 0.11575691f, 0.02468163f, -0.19319686f, -0.15365276f, -0.12046495f, 
    -0.06943288f, -0.14380355f, -0.18308212f, 0.01014238f, 0.12446686f, -0.08161485f, -0.15701325f, 0.01534396f, 
    -0.14271037f, 0.05938309f, 0.03832690f, -0.08543001f, -0.09757431f, -0.30195203f, 0.02293739f, -0.19588663f, 
    -0.06361441f, 0.00184297f, -0.06832823f, 0.04412419f, -0.10681167f, -0.00125115f, 0.26314446f, -0.12446710f, 
    -0.00510597f, 0.11452687f, -0.04030333f, 0.02337878f, -0.04631819f, -0.03954453f, -0.09760138f, 0.27444977f, 
    -0.05542171f, 0.02296894f, -0.05178611f, -0.10126154f, 0.00092721f, 0.13492109f, -0.08269576f, 0.06567140f, 
    -0.19684622f, 0.35931492f, 0.14541259f, 0.02868176f, 0.08570816f, 0.05605880f, -0.07539684f, -0.28688559f, 
    0.10132080f, 0.08282936f, -0.00234372f, -0.28453475f, -0.01349602f, -0.00996375f, -0.04582620f, -0.01278691f, 
    -0.09321444f, -0.17823914f, -0.17012477f, -0.17694728f, 0.31653440f, 0.06503957f, 0.01128145f, 0.05077375f, 
    0.00869897f, 0.04602339f, -0.09697816f, -0.17602308f, 0.09508321f, 0.21974176f, 0.12356365f, -0.04481421f, 
    -0.05577393f, 0.17147602f, 0.00831352f, 0.07499348f, -0.10222933f, -0.00192062f, 0.12398618f, 0.14606015f, 
    0.13792558f, -0.09621216f, -0.04808427f, 0.07538718f, -0.04101213f, 0.33014339f, -0.09820917f, 0.32145989f, 
    0.08590847f, 0.01456288f, 0.07065696f, 0.03082159f, 0.15701105f, 0.01895988f, 0.16456838f, -0.05682667f, 
    0.17490391f, 0.14088520f, 0.12056408f, -0.04697826f, 0.01672318f, 0.03731311f, 0.05623460f, -0.05623619f, 
    -0.03408620f, 0.32717758f, -0.09689522f, 0.05266507f, -0.02735973f, 0.01941943f, -0.02134870f, -0.00567460f, 
    0.51004839f, -0.19576333f, -0.02339125f, -0.08925267f, -0.02264852f, -0.03209808f, -0.00955324f, 0.01034941f, 
    0.15045911f, -0.21870600f, -0.27003747f, 0.06139836f, 0.01353418f, 0.07203282f, -0.11254340f, 0.03569942f, 
    0.05964914f, 0.01825424f, -0.58786172f, -0.17395531f, 0.14720799f, -0.05022255f, 0.11150294f, 0.14112531f, 
    0.06606188f, -0.00883399f, -0.15036772f, 0.17527109f, 0.01193369f, -0.07670128f, -0.01245190f, 0.00999259f, 
    -0.03983878f, 0.04059878f, -0.22897166f, -0.05043421f, -0.22765426f, -0.02373776f, 0.04835017f, -0.00860141f, 
    -0.04609805f, -0.01054513f, 0.04421956f, -0.01139590f, 0.06600492f, -0.13868675f, 0.15582919f, -0.20421861f, 
    -0.21716444f, -0.06687525f, -0.13748133f, -0.11046830f, 0.08863107f, 0.08385269f, 0.17964320f, -0.22464950f, 
    -0.03990050f, -0.15228768f, 0.06773333f, 0.03798041f, 0.21007654f, -0.07749745f, -0.03518242f, 0.46848959f, 
    -0.04330674f, -0.06794144f, 0.05216458f, 0.03180077f, -0.01892741f, 0.08303759f, 0.14235185f, 0.00955718f, 
    -0.18851340f, 0.27831116f, -0.04883673f, -0.09204962f, 0.09412510f, -0.07365037f, -0.13116738f, 0.03905473f, 
    0.01520626f, 0.22366790f, 0.09017655f, 0.02424240f, 0.03172967f, 0.10779670f, 0.08837973f, 0.03325516f, 
    -0.03126716f, 0.16019528f, 0.08127663f, -0.14078330f, 0.09181813f, 0.07491772f, 0.00625884f, 0.02779661f, 
    -0.02042821f, -0.03109717f, 0.20022331f, -0.09031489f, 0.00986650f, -0.16684662f, 0.16166179f, 0.05262320f, 
    0.06003122f, -0.14596911f, -0.09953275f, -0.03762017f, 0.28963584f, 0.14167203f, -0.02784724f, -0.13653314f, 
    0.10260286f, 0.07774881f, 0.04139339f, 0.11762045f, 0.16757272f, 0.00552831f, -0.06645192f, -0.00040606f, 
    0.03616869f, 0.06827816f, -0.04387412f, -0.24035786f, -0.04250603f, 0.10884307f, 0.30294979f, -0.10557823f, 
    0.05350892f, 0.08472168f, 0.03760276f, -0.05514490f, 0.10235705f, 0.01777574f, 0.07504170f, 0.16647063f, 
    -0.13671495f, -0.00797846f, -0.14451386f, 0.05279312f, -0.00994848f, 0.07581263f, 0.17471372f, 0.14869548f, 
    0.08112804f, 0.13988057f, -0.33680496f, 0.09065888f, -0.04004839f, -0.14307652f, 0.03881231f, 0.04434203f, 
    0.09999520f, 0.16076387f, 0.20602584f, 0.01006795f, 0.14168708f, -0.06085959f, -0.11286939f, 0.08197550f, 
    -0.03532441f, 0.01400784f, -0.24237914f, 0.03010721f, 0.06085743f, -0.12343810f, 0.01287276f, 0.00691241f, 
    -0.01331843f, -0.11027399f, -0.08003787f, 0.15486647f, -0.05754776f, 0.03175209f, 0.15367256f, -0.02371065f, 
    -0.07312378f, -0.16942662f, 0.01891788f, 0.02919428f, -0.47817957f, -0.43722928f, -0.25713801f, -0.00285017f, 
    0.06593338f, 0.08808528f, -0.02800825f, 0.11892135f, -0.10532737f, 0.09821857f, -0.12119687f, 0.02826298f, 
    -0.19406250f, 0.04230748f, -0.17050155f, -0.07689898f, 0.07368449f, -0.10854378f, -0.25077170f, 0.09570009f, 
    -0.00282117f, -0.01501878f, -0.03170412f, 0.02700373f, -0.02178733f, -0.03889764f, -0.00432000f, -0.00187771f, 
    0.02373875f, -0.18174192f, 0.00541709f, 0.01432647f, 0.07928967f, 0.15629882f, -0.08801418f, -0.07462349f, 
    -0.07101890f, -0.08392646f, 0.23808931f, 0.10998669f, -0.02114811f, 0.01293031f, 0.20322533f, 0.23486272f, 
    0.08438072f, 0.17108180f, -0.35474983f, 0.06029764f, 0.19122718f, -0.03594659f, -0.06173563f, -0.07207399f, 
    0.17295574f, 0.01848804f, -0.02632529f, 0.23553112f, -0.09742007f, -0.07087004f, -0.01651247f, -0.03244052f, 
    0.13905416f, -0.09454861f, -0.19599453f, 0.11055122f, -0.11675915f, -0.10969859f, -0.22505105f, 0.06609438f, 
    0.00078268f, -0.10907092f, 0.08621527f, 0.05540374f, 0.08021959f, -0.27316535f, 0.03743308f, 0.19815207f, 
    -0.03154855f, 0.06578537f, 0.10708874f, 0.09769771f, -0.04785922f, -0.30097833f, 0.18527460f, -0.15368883f, 
    -0.14183530f, -0.05194335f, 0.09017657f, -0.02271661f, 0.14546126f, 0.04959856f, -0.10362069f, 0.06104413f, 
    -0.01998240f, -0.04546758f, 0.02068371f, -0.02025575f, -0.03101769f, 0.07760949f, 0.06617048f, -0.13812266f, 
    0.14151143f, 0.08397767f, -0.02104901f, 0.06712028f, 0.27801606f, -0.16684590f, 0.10282644f, -0.20027444f, 
    -0.01023115f, -0.01330520f, -0.02734907f, -0.05275449f, -0.05364664f, -0.05823736f, 0.02011699f, -0.04103723f, 
    -0.03417847f, 0.01757427f, -0.02181393f, -0.05360773f, -0.03721417f, -0.02133615f, 0.00072202f, -0.03466840f, 
    0.00581171f, -0.06323989f, 0.00811678f, 0.02723220f, -0.06111592f, -0.01580001f, 0.02958875f, -0.07010400f, 
    0.03858672f, -0.05907273f, -0.03156515f, 0.03348896f, -0.03430898f, -0.01200529f, -0.03696591f, 0.00650094f, 
    0.02754087f, -0.00715953f, -0.06318990f, -0.03980596f, -0.06348910f, -0.02377320f, -0.04250149f, -0.00207845f, 
    0.04333650f, 0.00826293f, 0.03310020f, -0.00563865f, -0.02501613f, -0.00836126f, -0.00215638f, -0.03016126f, 
    0.01511341f, -0.05005684f, -0.00615751f, -0.02250005f, -0.06485777f, 0.01316455f, -0.02241789f, 0.03481402f, 
    0.02457627f, 0.00892715f, -0.04179328f, -0.00506823f, -0.00076456f, -0.03891556f, -0.06671267f, -0.03269704f, 
    -0.05246188f, -0.04936392f, 0.04722712f, -0.03818862f, 0.00263585f, 0.03876622f, -0.06953871f, 0.03111488f, 
    -0.06142041f, 0.04299063f, -0.03139386f, -0.02807190f, -0.04378857f, 0.03119517f, 0.03815379f, -0.03092398f, 
    -0.03125707f, -0.04885281f, 0.00166959f, -0.07398540f, 0.03035314f, -0.04569948f, -0.06156134f, -0.06898826f, 
    0.04270210f, 0.02899040f, -0.01635219f, -0.00631410f, -0.01103348f, 0.03199481f, 0.02576214f, 0.02760319f, 
    -0.05243249f, 0.01789346f, -0.01958256f, 0.04306456f, -0.00635507f, -0.01839895f, 0.02343413f, -0.05165786f, 
    -0.04214005f, -0.02189298f, -0.04565340f, -0.07025684f, 0.02857582f, -0.01523244f, 0.01393356f, 0.00986792f, 
    -0.06113219f, 0.04109168f, -0.07255759f, -0.03337828f, -0.05382975f, 0.01504478f, -0.01437942f, 0.01693976f, 
    0.04426115f, -0.00631663f, -0.02887780f, -0.03847625f, -0.05750746f, -0.04830670f, -0.00780382f, 0.03285860f, 
    -0.02144768f, -0.01600011f, 0.00835334f, -0.05088747f, 0.04683839f, 0.04058276f, 0.03724090f, 0.01520099f, 
    0.02634271f, -0.04529479f, 0.01091782f, -0.07544862f, 0.04244662f, -0.03928745f, -0.01592317f, 0.00310816f, 
    0.02384659f, 0.03372196f, -0.00016939f, -0.03387714f, -0.01381481f, 0.02106040f, -0.04240873f, 0.01695201f, 
    -0.02744023f, 0.03171160f, 0.03636584f, -0.02883814f, 0.02778419f, -0.00657465f, -0.04347243f, -0.02966511f, 
    0.02852701f, -0.02427318f, -0.01281243f, 0.03765469f, 0.01382870f, -0.01828253f, -0.00655061f, -0.04584497f, 
    -0.02046201f, -0.00140060f, 0.01354160f, -0.05899926f, 0.02259480f, -0.02811239f, 0.02940372f, 0.02860269f, 
    -0.05381955f, -0.04507028f, -0.04566724f, -0.05242419f, -0.06582668f, 0.03738865f, -0.01836357f, -0.05712057f, 
    -0.05566746f, 0.00196907f, 0.04991810f, 0.01211668f, -0.02015891f, -0.00664770f, 0.02251186f, 0.02089398f, 
    -0.01012631f, -0.03251326f, 0.03873930f, -0.05546731f, 0.03510447f, 0.04516592f, 0.00249611f, -0.02294048f, 
    0.02615065f, 0.00714317f, 0.03700237f, -0.05661004f, -0.00000080f, 0.01738232f, 0.03516723f, 0.02511445f, 
    -0.05205463f, -0.05431024f, -0.06206773f, -0.02317427f, -0.02438276f, 0.03796114f, 0.00746668f, 0.01962477f, 
    0.00296310f, 0.03295815f, 0.01662008f, -0.05827089f, -0.01805559f, -0.00020160f, -0.06948221f, 0.03983975f, 
    -0.03431505f, -0.03655906f, -0.05349568f, -0.04965735f, -0.02259935f, 0.03254045f, 0.03325547f, 0.00188855f, 
    0.03904429f, -0.05022181f, -0.04862157f, -0.03178624f, -0.06260365f, -0.02055520f, -0.06673927f, -0.04425947f, 
    -0.03265001f, -0.00725688f, -0.06077636f, 0.04570001f, 0.02722032f, 0.04063211f, 0.00331062f, 0.04162686f, 
    0.02713923f, -0.00442297f, -0.05246024f, -0.03520149f, -0.01907336f, -0.04481700f, 0.00363531f, 0.04696840f, 
    0.00836646f, -0.03846597f, -0.06437608f, -0.07206339f, 0.00870356f, 0.04788779f, 0.04077474f, -0.03986439f, 
    -0.03138537f, -0.01141659f, -0.00328925f, 0.01256349f, -0.04302574f, -0.06914946f, -0.01590494f, -0.00666316f, 
    0.04039309f, 0.02572831f, -0.02797775f, 0.00671786f, -0.05723749f, 0.02133102f, 0.00499500f, -0.04439871f, 
    -0.02560738f, -0.04060433f, 0.04871707f, -0.03031804f, -0.00667631f, 0.01233245f, 0.01913534f, -0.03871678f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04723165f, 0.02043090f, -0.04047401f, 0.04328286f, 0.10770522f, 0.02920057f, 0.14365543f, 0.12867419f, 
    0.11990033f, 0.03255736f, 0.03940938f, 0.11791249f, 0.03111904f, 0.04615717f, 0.08356259f, -0.03263856f, 
    0.02358185f, 0.05146679f, -0.07851273f, 0.07627184f, 0.03748134f, -0.00518827f, 0.14058010f, 0.17727861f, 
    0.04211890f, -0.05696290f, 0.03453959f, -0.05150221f, -0.11058394f, -0.09388149f, -0.06926882f, -0.03010938f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03159414f, -0.01355864f, -0.00204152f, -0.15817350f, -0.11211125f, 0.01085400f, -0.06863460f, -0.14735284f, 
    0.00004687f, -0.09276801f, -0.04105767f, 0.07611495f, 0.10558792f, 0.03395268f, 0.09277145f, -0.15528512f, 
    -0.09012750f, -0.12014174f, -0.09370697f, -0.09715512f, 0.01200703f, -0.01791400f, -0.10903408f, -0.14031279f, 
    -0.10320163f, 0.12077367f, -0.09335975f, -0.16713500f, -0.02543995f, 0.01433241f, 0.14460696f, -0.14337996f, 
    -0.17124911f, 0.05853099f, -0.05582609f, -0.06548719f, -0.08971985f, 0.48094520f, 0.27530333f, 0.14933440f, 
    -0.11567184f, 0.19892018f, 0.01698845f, 0.15127130f, 0.14124121f, 0.03932775f, -0.31449419f, 0.08872443f, 
    -0.48927629f, 0.28623605f, -0.03262377f, 0.30578721f, -0.07238051f, -0.25292423f, 0.54418737f, -0.55985105f, 
    -0.07036591f, -0.18619281f, 0.15499280f, -0.12252130f, 0.35259852f, -0.13352400f, 0.68741798f, -0.00467125f, 
    0.10949323f, 0.01484960f, 0.16145496f, -0.06468345f, -0.10114398f, 0.45789057f, -0.10568639f, 0.06959265f, 
    -0.10059766f, 0.43188265f, -0.17387779f, 0.25570771f, -0.02086383f, -0.04400500f, 0.26437673f, 0.10723905f, 
    -0.14085823f, 0.40683070f, -0.20964110f, -0.05480746f, 0.08786108f, 0.01487374f, 0.11312257f, 0.21844493f, 
    -0.29128581f, -0.30210683f, 0.06328803f, -0.04892605f, -0.38280219f, 0.26555139f, 0.02229463f, 0.07829714f, 
    0.02606217f, -0.05509843f, -0.06382886f, 0.04899456f, 0.11804620f, -0.10007223f, 0.23771301f, 0.28070837f, 
    0.29934353f, 0.02471345f, -0.11356296f, -0.09707534f, -0.12727231f, 0.10539152f, -0.42759696f, 0.10481101f, 
    -0.06238352f, 0.14085110f, -0.00698666f, 0.11234387f, -0.01046557f, 0.11192302f, 0.07190169f, 0.28394538f, 
    -0.59793603f, -0.12048873f, -0.16242567f, -0.14192124f, 0.29955763f, -0.49261627f, 0.53158748f, 0.10268048f, 
    0.10538122f, -0.06293991f, -0.01577812f, -0.13172425f, 0.16643195f, 0.43468156f, 0.33206314f, -0.15733516f, 
    -0.45329762f, 0.08042759f, -0.06209333f, -0.04347777f, -0.01351343f, 0.07446028f, 0.34626645f, 0.03747153f, 
    0.35506910f, -0.08799931f, 0.08005748f, 0.22264896f, 0.15630431f, 0.16414171f, 0.06306222f, -0.49829707f, 
    0.28678373f, 0.12129938f, -0.11201167f, 0.11873577f, 0.50715852f, 0.37053898f, -0.01980282f, -0.09232660f, 
    -0.15209945f, -0.14031228f, 0.12367138f, 0.10823302f, 0.08350329f, -0.11038237f, -0.08742325f, -0.14380425f, 
    -0.09596850f, 0.05143779f, 0.17414936f, -0.11004779f, 0.15036337f, -0.13545421f, 0.09872386f, 0.09417234f, 
    -0.05167057f, -0.12339414f, 0.02280127f, -0.11393579f, 0.03407894f, 0.11176752f, 0.16002597f, 0.00800845f, 
    0.02608553f, -0.00391520f, 0.09325145f, 0.11742307f, 0.16542633f, -0.06970254f, -0.02158228f, 0.07925289f, 
    -0.07955609f, -0.02717838f, 0.02048211f, -0.11099856f, -0.16304454f, 0.09980837f, -0.04155534f, -0.18688697f, 
    -0.06094405f, 0.23049967f, 0.15476829f, 0.16960613f, 0.12480336f, -0.14461011f, -0.18607271f, 0.11160984f, 
    -0.37488908f, 0.25213793f, 0.05382881f, -0.02690868f, -0.09190884f, 0.04840484f, -0.05025939f, 0.07970744f, 
    -0.13000315f, 0.48415047f, 0.01768258f, -0.04945726f, 0.23241179f, 0.60343170f, -0.23396258f, -0.00314358f, 
    0.04667440f, 0.12360600f, -0.01558313f, 0.04301650f, -0.14476055f, -0.29443675f, -0.22723344f, -0.09009805f, 
    0.01450532f, 0.10719818f, 0.03274981f, 0.18182342f, 0.08990703f, -0.02405753f, 0.27890864f, -0.16400433f, 
    0.20570721f, 0.43914002f, 0.37746301f, -0.05206545f, -0.04105413f, 0.05686003f, -0.14182653f, -0.41644743f, 
    0.68803537f, 0.46468988f, 0.16010185f, -0.08271451f, -0.30791011f, 0.36104038f, 0.03326494f, 0.10910033f, 
    0.16305646f, -0.09254013f, -0.07547352f, 0.06202695f, -0.28299668f, 0.01978434f, 0.28833434f, 0.29192555f, 
    0.13639075f, 0.16582979f, 0.11871602f, -0.13207051f, -0.11511031f, -0.14504631f, -0.54162824f, -0.07418469f, 
    -0.06596339f, -0.02140092f, 0.30344078f, 0.48047677f, 0.11448058f, 0.00330457f, -0.04145876f, -0.17760459f, 
    0.15359466f, 0.00996179f, 0.10275528f, 0.05855915f, 0.30848476f, -0.27740520f, 0.53800833f, 0.15679897f, 
    0.03489402f, -0.15834606f, -0.03831999f, 0.02248036f, 0.06022356f, -0.15905425f, -0.05525845f, -0.23233829f, 
    0.03019283f, -0.01509161f, -0.08389619f, 0.07304180f, -0.13714856f, 0.13427702f, -0.09641755f, 0.15780275f, 
    -0.07451582f, -0.12307193f, 0.12934393f, -0.10523236f, 0.04418383f, -0.03981296f, 0.03356392f, 0.05374099f, 
    -0.07686747f, -0.05438037f, -0.11697770f, 0.03489528f, -0.02744099f, -0.04131151f, 0.05846944f, -0.14631017f, 
    -0.15342371f, -0.02638648f, 0.16079806f, -0.08069172f, 0.01304187f, 0.41671154f, -0.13348868f, 0.21179339f, 
    0.08322615f, -0.23576567f, 0.00554648f, 0.09636053f, -0.09496661f, 0.01897953f, 0.00287427f, 0.04428873f, 
    0.51990616f, -0.17604497f, 0.12517487f, -0.38354948f, -0.01706623f, -0.01088451f, -0.24184059f, 0.30107114f, 
    -0.18446623f, 0.20753558f, -0.15939733f, -0.14272153f, -0.18830571f, -0.07305033f, 0.35952243f, -0.00339041f, 
    -0.15564486f, -0.03840969f, 0.13206145f, -0.08821852f, 0.11818448f, 0.29803413f, -0.08593109f, 0.21856503f, 
    -0.26732042f, 0.52247423f, 0.07587790f, 0.31764811f, 0.13727358f, -0.13486345f, 0.12943512f, -0.01338137f, 
    0.33288169f, 0.12973450f, -0.16623342f, 0.01760773f, 0.02334662f, -0.11815862f, -0.05661425f, -0.13511272f, 
    -0.66970205f, 0.00423753f, -0.16859598f, 0.09169935f, -0.23220724f, 0.03170398f, -0.22725004f, -0.03795754f, 
    -0.02055940f, 0.07537293f, -0.10873926f, -0.14387268f, 0.41020215f, -0.26176837f, -0.27165025f, 0.00690736f, 
    0.39491427f, -0.23903939f, 0.01822234f, -0.05051738f, -0.12744467f, -0.13275836f, 0.10425169f, -0.17240435f, 
    0.38337862f, 0.23963451f, -0.15542234f, -0.13115613f, 0.09717036f, -0.08462626f, 0.14265664f, 0.14603142f, 
    0.49199370f, 0.44397619f, 0.12270568f, -0.14649874f, 0.16845441f, -0.28423208f, 0.25460908f, -0.05404111f, 
    0.03247434f, 0.03503323f, -0.15194538f, -0.03814201f, 0.24846277f, 0.29788297f, 0.32690093f, -0.02906369f, 
    -0.18186755f, 0.24906853f, -0.07332920f, -0.05791930f, 0.07014144f, 0.05903197f, 0.49997762f, 0.15573698f, 
    0.38016284f, -0.00931407f, -0.09165732f, 0.00872589f, 0.07310591f, -0.17981759f, 0.40074623f, -0.17047504f, 
    0.25132477f, -0.22855313f, 0.12674847f, -0.11834010f, 0.09383918f, 0.00163959f, -0.56413090f, 0.16345042f, 
    0.08057707f, 0.16128184f, 0.01474728f, -0.02337236f, 0.01399466f, 0.10771199f, 0.22498061f, -0.14716986f, 
    0.06379016f, -0.08990037f, 0.14034085f, 0.04121068f, -0.10765822f, -0.17464779f, 0.15366440f, 0.16029029f, 
    -0.15537556f, 0.33881649f, -0.01637399f, 0.27299199f, -0.03084147f, -0.10375766f, 0.72551054f, -0.26105472f, 
    0.23493034f, -0.07047813f, -0.01121591f, 0.04132183f, 0.57485217f, -0.29040849f, 0.58641171f, 0.12128794f, 
    -0.07583164f, -0.14341974f, 0.15734567f, -0.03924514f, 0.11711849f, 0.15197565f, -0.14056188f, -0.12802200f, 
    0.03134251f, -0.16683064f, -0.06779499f, -0.14527792f, -0.07370236f, -0.02260382f, -0.14953294f, -0.07699449f, 
    -0.00254099f, 0.15803666f, 0.01748635f, 0.03300357f, 0.01446655f, -0.00783135f, 0.09908898f, -0.09579307f, 
    -0.14037040f, -0.11214210f, 0.03609037f, 0.03991065f, 0.00659979f, -0.05218178f, 0.12042814f, -0.13382478f, 
    0.15022233f, -0.12624747f, 0.02438352f, 0.04931842f, -0.15359266f, -0.54344738f, -0.04378167f, 0.16002975f, 
    0.15534215f, 0.00474399f, 0.15407902f, 0.10972553f, -0.06740966f, 0.00697825f, 0.31008831f, 0.09379385f, 
    0.27151161f, 0.06978416f, -0.01357844f, -0.17282340f, -0.15128264f, 0.06890912f, -0.01446219f, -0.04290381f, 
    -0.45089284f, 0.46914461f, 0.09472004f, -0.06714100f, 0.15182073f, 0.04502017f, -0.22718079f, 0.06094185f, 
    -0.11651254f, 0.13408762f, 0.03069303f, -0.06808016f, -0.07553829f, -0.00676253f, -0.01050568f, -0.10377339f, 
    0.07097317f, 0.03760636f, 0.15942436f, -0.00773120f, 0.05271177f, -0.01625249f, -0.21067227f, 0.00068575f, 
    -0.04503625f, -0.12058537f, 0.09674182f, 0.04002034f, 0.14230005f, 0.03345140f, -0.07403019f, 0.07319844f, 
    0.07856866f, -0.09215828f, 0.00053680f, 0.09723803f, -0.17995846f, -0.10233545f, 0.04538563f, 0.14984791f, 
    -0.06122106f, -0.02020728f, 0.02230396f, -0.16762714f, -0.08059403f, -0.43959886f, 0.30672064f, 0.17802666f, 
    0.42898074f, -0.08166430f, -0.05479094f, -0.19600821f, 0.13627183f, 0.03082991f, 0.02951352f, -0.08295874f, 
    -0.13398339f, -0.15567060f, 0.45074096f, 0.05649461f, -0.12182184f, 0.02727309f, -0.44846556f, 0.11146836f, 
    0.09817161f, 0.23582940f, -0.11138433f, 0.13086887f, 0.49219799f, 0.28545594f, -0.02577515f, -0.04069763f, 
    0.03709358f, -0.06405595f, -0.17631398f, -0.00761319f, -0.09784374f, -0.06001711f, 0.05879818f, -0.19277072f, 
    -0.05606730f, -0.14962301f, -0.15001965f, 0.23947495f, 0.15181766f, 0.01294444f, -0.31755057f, 0.10123266f, 
    -0.42680728f, 0.17345034f, -0.08575349f, 0.35540819f, -0.06705737f, 0.10083719f, 0.36363453f, -0.26653132f, 
    0.44937888f, 0.03284349f, 0.12931249f, 0.00052384f, 0.27117899f, 0.52432388f, 0.12021199f, -0.16483667f, 
    0.16100807f, 0.05860864f, -0.05586747f, -0.05619478f, -0.27751461f, 0.26949295f, 0.09235542f, 0.32401216f, 
    -0.25000420f, 0.32093570f, 0.15655504f, 0.11173479f, 0.04045426f, -0.02082884f, -0.68825305f, 0.07009258f, 
    -0.05672344f, -0.53278613f, 0.17755817f, 0.44019905f, -0.02896002f, 0.06651780f, 0.01195566f, -0.00903202f, 
    -0.24939449f, -0.10879640f, 0.01150006f, 0.03229521f, -0.54119551f, 0.03730762f, 0.44378322f, 0.07032286f, 
    -0.16015242f, 0.09496535f, -0.02591058f, 0.11359917f, -0.06446950f, 0.50277013f, -0.15838772f, 0.08580764f, 
    -0.34004483f, 0.34262720f, 0.03953981f, -0.02075310f, -0.06243947f, -0.02282538f, 0.55616444f, 0.04560636f, 
    0.47220835f, 0.24522699f, 0.10893733f, -0.01223565f, -0.06390255f, 0.16385677f, -0.10443761f, -0.52648669f, 
    -0.04178308f, 0.09965828f, 0.03406891f, 0.16070151f, 0.11621498f, 0.45813650f, -0.12146299f, -0.04789113f, 
    0.15775867f, -0.08098911f, 0.16658933f, 0.01218785f, 0.18057625f, -0.27520946f, -0.11357670f, 0.24670629f, 
    0.11798793f, 0.48515221f, 0.11713155f, 0.08600219f, 0.14169914f, 0.16827264f, -0.32927582f, -0.14977099f, 
    -0.02156433f, 0.42350683f, -0.12804237f, 0.18665040f, 0.14414422f, 0.03866503f, 0.23998141f, -0.12626877f, 
    -0.44681734f, 0.28167167f, 0.11121629f, -0.00004316f, -0.19583586f, -0.26345697f, 0.25932804f, 0.06325664f, 
    -0.03496533f, 0.14865476f, -0.09949370f, 0.07944694f, 0.06998775f, -0.37982222f, 0.24009253f, 0.13738011f, 
    0.11661435f, 0.12488390f, 0.12450200f, -0.21501434f, -0.17666782f, -0.17027518f, -0.24339324f, -0.12727469f, 
    0.17222343f, -0.32177469f, 0.17006876f, -0.14323005f, 0.09640966f, 0.08726306f, -0.09272645f, 0.31891987f, 
    0.63831359f, 0.05012217f, 0.05002400f, -0.04485765f, -0.15755987f, 0.36996946f, -0.18229887f, 0.03007262f, 
    0.02209898f, -0.15922976f, 0.04668088f, -0.02801309f, -0.12130234f, -0.08558822f, -0.01561210f, -0.12368937f, 
    -0.15945864f, 0.06728255f, -0.02447204f, -0.08177049f, -0.16432163f, -0.01223919f, -0.05679878f, 0.06817933f, 
    0.16579166f, -0.10319148f, -0.03755828f, 0.11648786f, 0.01284581f, 0.00951440f, -0.04445249f, -0.07312438f, 
    0.06366532f, -0.02799286f, 0.13000569f, -0.14491123f, -0.17471702f, 0.09539770f, 0.01818185f, 0.02662482f, 
    0.14547785f, -0.00177233f, -0.16963704f, -0.09904662f, -0.00465540f, 0.01104399f, -0.06945281f, -0.03651855f, 
    -0.08979974f, 0.10150769f, 0.12149274f, -0.13232401f, -0.01900551f, 0.15070294f, 0.07793877f, -0.06215840f, 
    0.01755094f, -0.17295593f, 0.10029799f, -0.01222904f, -0.01791275f, 0.04505528f, 0.10502822f, -0.07306767f, 
    -0.17158818f, -0.04671069f, -0.04659524f, -0.06668808f, 0.14303565f, 0.02717672f, -0.09371854f, 0.03362769f, 
    -0.07153638f, 0.13935061f, -0.03338117f, 0.12543766f, 0.18034880f, 0.51630783f, 0.35607466f, -0.11405799f, 
    0.01141322f, -0.03559347f, 0.16644786f, -0.05822050f, -0.05243491f, -0.02067611f, 0.26614901f, -0.00669771f, 
    -0.12343540f, -0.18359829f, -0.07081268f, 0.24066059f, -0.15671192f, -0.11573350f, -0.00998502f, 0.01032556f, 
    0.52757561f, -0.32313436f, 0.04507764f, 0.02259871f, 0.30637014f, 0.33421892f, 0.04046023f, 0.03397813f, 
    0.13432281f, -0.15328307f, -0.13195647f, 0.08037935f, -0.07969940f, -0.11442125f, 0.07883366f, -0.11402088f, 
    -0.13799393f, 0.13811173f, -0.09771911f, -0.04832863f, 0.04557731f, -0.01256269f, -0.04306687f, 0.12483178f, 
    -0.16455498f, -0.07601723f, 0.01358262f, -0.15752296f, 0.11402518f, 0.12722667f, 0.07371711f, -0.14526993f, 
    -0.02675617f, 0.13299841f, -0.13113813f, -0.00452198f, -0.06953154f, -0.15667941f, 0.11403558f, -0.10772461f, 
    -0.11749370f, 0.04360285f, 0.17135607f, -0.09593990f, -0.12200688f, -0.28163466f, -0.15087795f, 0.14031503f, 
    -0.01200900f, -0.41096127f, 0.01601536f, 0.12378881f, 0.04861596f, 0.17354228f, -0.06145281f, 0.09962866f, 
    0.26426378f, -0.40718213f, 0.30779332f, -0.30643129f, -0.08813595f, -0.07112978f, -0.20208269f, 0.39917523f, 
    -0.06253050f, 0.45294145f, 0.08499133f, -0.09823789f, 0.28219777f, 0.42112476f, 0.16750319f, 0.15700434f, 
    -0.12775913f, 0.04634172f, -0.03772059f, 0.04319493f, 0.06255326f, -0.09994768f, 0.13382889f, -0.13327864f, 
    0.05351296f, 0.13728654f, 0.17020056f, -0.18293191f, -0.01732935f, 0.09100697f, -0.07968301f, -0.06282011f, 
    -0.05211074f, -0.13126107f, -0.14819621f, 0.12037060f, -0.16355580f, 0.06908020f, -0.08136226f, -0.04621682f, 
    -0.06791400f, 0.01950047f, -0.02430628f, -0.04299383f, -0.14786771f, 0.01466405f, -0.04750324f, -0.03562913f, 
    -0.02599316f, -0.08690379f, -0.03366366f, -0.13147107f, -0.07573551f, -0.16066310f, -0.01937866f, 0.01966201f, 
    -0.15692516f, 0.02607022f, -0.07168654f, 0.09081811f, 0.08758195f, -0.10980919f, -0.15140522f, 0.08154363f, 
    -0.07623062f, 0.04652933f, 0.04991622f, -0.11817867f, 0.04647145f, -0.09823234f, -0.16951086f, -0.16064636f, 
    -0.18513632f, -0.17423446f, -0.03381233f, 0.10617733f, -0.19775587f, -0.10716414f, 0.07856066f, 0.09413151f, 
    0.15731880f, 0.08652519f, -0.10134651f, -0.13187964f, -0.03300120f, 0.11871088f, -0.01324905f, 0.05197374f, 
    0.34062070f, -0.59148568f, -0.00700938f, 0.06472810f, -0.09965645f, -0.01590947f, 0.01074282f, -0.12822020f, 
    -0.24779972f, 0.07118900f, 0.24000841f, -0.16791154f, -0.13794775f, -0.12653831f, -0.27270296f, 0.23958951f, 
    0.08068949f, -0.06748855f, -0.17088406f, 0.07868009f, 0.49217570f, 0.25938216f, 0.10781224f, -0.02226807f, 
    -0.01698963f, -0.05245413f, 0.03983987f, -0.11219430f, -0.24209203f, 0.48493958f, -0.08949690f, 0.16035971f, 
    -0.10932142f, -0.02693770f, 0.01409473f, 0.26999071f, -0.13923906f, -0.09976432f, -0.22619969f, -0.06066781f, 
    0.39380449f, -0.04253069f, 0.32062531f, 0.14979833f, -0.01766341f, 0.06235325f, -0.51676381f, -0.24960817f, 
    -0.17738691f, -0.09087462f, 0.09496350f, 0.12738773f, -0.47711572f, 0.22838676f, 0.44558376f, -0.15038925f, 
    -0.14574848f, 0.15528265f, -0.08328938f, 0.13669769f, 0.12856789f, 0.30614746f, 0.23990901f, 0.13722192f, 
    -0.02333424f, -0.14310670f, 0.03599960f, 0.00442087f, -0.06093760f, 0.11431196f, -0.40798548f, -0.09143461f, 
    -0.17422159f, -0.01553460f, -0.07318332f, 0.21761377f, -0.02912737f, -0.16074504f, -0.00347165f, 0.25099966f, 
    -0.21397460f, -0.24370053f, -0.01757521f, -0.10168114f, 0.35384524f, -0.28100166f, 0.26709148f, -0.04109206f, 
    0.06005380f, -0.11313284f, -0.03283185f, -0.02719467f, 0.05126626f, -0.37409306f, 0.26563883f, -0.16068760f, 
    0.10820380f, 0.19558474f, 0.15948872f, 0.08361442f, 0.08533271f, -0.03722085f, -0.01570819f, -0.13531947f, 
    -0.45652241f, 0.23176911f, -0.16532451f, 0.09529772f, -0.15380394f, 0.11489175f, 0.60175717f, -0.05590026f, 
    0.71521789f, 0.21405672f, -0.04221059f, 0.01374859f, 0.09268878f, 0.30417585f, 0.01432646f, 0.14394572f, 
    -0.15759610f, -0.00336832f, -0.10695907f, 0.15137365f, 0.02676418f, -0.42255092f, 0.07233173f, 0.24677533f, 
    0.21124251f, -0.30568191f, -0.13874239f, -0.12225911f, -0.08857135f, 0.00524024f, 0.31219447f, 0.07395007f, 
    0.26660320f, -0.29587600f, 0.32555524f, -0.03195463f, 0.16039170f, 0.08221690f, -0.51415473f, -0.08062675f, 
    -0.17787601f, 0.12763782f, 0.02359782f, 0.02201313f, 0.68487906f, 0.24735017f, 0.05007228f, 0.01588017f, 
    -0.06700897f, -0.03195776f, 0.17102692f, 0.08066435f, 0.10390795f, -0.18702736f, -0.07798191f, 0.09574164f, 
    -0.05176576f, -0.15956320f, 0.15038849f, -0.16201878f, -0.04247260f, -0.02446178f, -0.17376116f, 0.02998392f, 
    -0.14186551f, -0.05208056f, -0.07347179f, -0.03547372f, 0.00704209f, -0.05270498f, 0.11606205f, 0.10126562f, 
    0.02492598f, 0.10907219f, -0.05232939f, 0.02197888f, -0.14470491f, 0.01234992f, 0.09515674f, -0.14914267f, 
    -0.13207494f, -0.14872739f, -0.07074150f, -0.06638892f, -0.07978113f, 0.58344084f, 0.33848193f, 0.21864197f, 
    -0.13910246f, 0.53485870f, -0.10636187f, 0.02603883f, 0.03391106f, -0.13200447f, -0.00636850f, 0.12371753f, 
    -0.18286143f, 0.01752581f, 0.17667957f, 0.63829690f, -0.07995894f, 0.11614811f, -0.03916236f, -0.28145510f, 
    0.40348893f, -0.59303111f, -0.03272990f, 0.06228343f, -0.28309706f, -0.08716774f, -0.15045977f, -0.08992655f, 
    0.17122950f, 0.02456033f, 0.04317407f, -0.10889789f, 0.43169874f, 0.47117427f, 0.18735312f, -0.08884259f, 
    -0.00162484f, 0.02404432f, -0.08950705f, 0.33689356f, -0.02966330f, -0.00610049f, 0.05532688f, 0.07682670f, 
    -0.08018792f, -0.03469381f, -0.44934511f, -0.16068023f, -0.12791279f, -0.16738261f, -0.05115194f, 0.63485312f, 
    -0.31028745f, -0.33887655f, 0.12570558f, -0.00464787f, -0.06083304f, -0.13735889f, -0.33748677f, 0.04029369f, 
    0.12691525f, -0.11702829f, 0.01869122f, 0.11626943f, -0.05314416f, -0.11254030f, -0.06838539f, -0.09904943f, 
    0.14529960f, 0.13670518f, -0.12656310f, -0.00403921f, 0.04717345f, 0.03004975f, -0.12142774f, -0.16236083f, 
    0.06598544f, -0.06007462f, -0.10739632f, -0.10779598f, 0.14630544f, -0.13608150f, -0.02111001f, -0.11750484f, 
    -0.02978650f, -0.16095495f, 0.11675872f, 0.02221613f, 0.05262607f, 0.05172959f, -0.01224939f, 0.13914146f, 
    -0.11153858f, 0.12208448f, 0.00776255f, -0.08072525f, -0.42422232f, -0.31238163f, -0.05933849f, 0.38899100f, 
    0.29683793f, 0.45386377f, -0.14960971f, 0.20993751f, -0.14673358f, 0.08876860f, -0.16203409f, 0.05094374f, 
    -0.21172522f, -0.19952169f, 0.39764225f, -0.01143744f, 0.10418793f, -0.05554825f, -0.22895809f, 0.45017415f, 
    -0.32568100f, 0.10324557f, -0.14247729f, 0.02982048f, -0.64617842f, 0.47134984f, -0.36219022f, 0.03005642f, 
    0.17926723f, -0.01583108f, -0.16657348f, 0.04852235f, -0.19900683f, -0.36910063f, 0.20265688f, 0.12262493f, 
    0.27019355f, 0.27337179f, -0.12457395f, -0.10054155f, 0.04004189f, 0.01660999f, 0.20287050f, -0.03277140f, 
    0.29000878f, -0.11689247f, 0.42161345f, 0.22118978f, -0.12243557f, 0.07768410f, -0.47421148f, -0.22622782f, 
    0.16545227f, 0.32384199f, -0.03048878f, 0.05506794f, -0.16077074f, 0.29467186f, -0.21475032f, -0.01279954f, 
    0.08663832f, -0.17832439f, -0.10179394f, -0.06380562f, -0.26263514f, -0.37964213f, 0.10325319f, -0.02484357f, 
    0.57598817f, 0.32463628f, 0.08499580f, 0.09490412f, 0.02788539f, 0.04308842f, 0.04561368f, -0.10283813f, 
    -0.36774126f, 0.17285998f, 0.48804769f, 0.00636086f, -0.12472421f, 0.01562492f, 0.00561423f, -0.08634268f, 
    -0.08308348f, 0.13888818f, -0.12387025f, 0.05329414f, 0.00491355f, 0.22172758f, 0.23581961f, 0.12648271f, 
    0.17003755f, -0.12127601f, -0.05789110f, 0.12560831f, 0.05199679f, 0.16918312f, -0.00115499f, 0.12430055f, 
    0.21518579f, 0.13631132f, 0.13349496f, 0.13837893f, -0.04070683f, -0.14658637f, 0.41715381f, -0.07964746f, 
    0.27214247f, -0.37490362f, 0.03721986f, -0.34897602f, 0.00324826f, 0.10450080f, 0.28525668f, 0.31379989f, 
    0.01229830f, -0.04714746f, -0.13138555f, -0.06661202f, -0.39455861f, 0.09762257f, -0.62298781f, 0.13843243f, 
    -0.15310729f, 0.02807447f, 0.04378252f, 0.13809811f, 0.17014213f, -0.04269206f, 0.15277764f, 0.08846542f, 
    0.12092128f, 0.28191677f, -0.06830542f, 0.04268895f, -0.14776346f, -0.01690955f, -0.40324980f, 0.09601886f, 
    -0.07481120f, 0.15269367f, -0.04458710f, 0.03776912f, -0.08498531f, 0.10707925f, -0.26522937f, -0.07756948f, 
    -0.18498115f, -0.10226373f, 0.07666868f, -0.15116157f, 0.11289033f, -0.49435157f, 0.24368365f, -0.17808263f, 
    -0.04119582f, -0.00549522f, 0.14815679f, 0.15792505f, -0.05892104f, -0.18791711f, -0.11094064f, 0.12678239f, 
    0.37345001f, -0.18750167f, -0.11297092f, 0.27254584f, -0.14788106f, -0.14327060f, -0.19613449f, -0.11347089f, 
    0.23903526f, -0.21251191f, 0.22769304f, -0.49613234f, -0.03292932f, 0.04674453f, 0.02592855f, 0.43819535f, 
    -0.60984510f, 0.22951259f, 0.16025177f, 0.07269856f, -0.12585837f, -0.40846133f, 0.55643940f, 0.11558015f, 
    -0.02964837f, 0.04988898f, 0.10706962f, -0.03216097f, -0.03466123f, -0.15034127f, -0.02108871f, -0.12139264f, 
    -0.13812365f, 0.09626970f, 0.10926760f, -0.11998116f, -0.09015796f, 0.14666224f, 0.03203043f, -0.16625117f, 
    -0.06919691f, 0.04543519f, -0.12232859f, -0.14517580f, 0.15974309f, -0.07396139f, -0.13773710f, 0.15626626f, 
    -0.02387245f, 0.16503704f, -0.05022837f, 0.11006191f, 0.00479159f, -0.08157535f, 0.15124106f, -0.13019802f, 
    -0.05942756f, -0.16431367f, -0.10417397f, -0.01669971f, -0.07924729f, 0.00854782f, 0.00010897f, 0.12370500f, 
    -0.09683731f, -0.18790051f, -0.07128193f, -0.15975904f, -0.08783595f, 0.02456202f, -0.17769536f, -0.05833206f, 
    -0.08949312f, -0.03096280f, 0.01017852f, -0.08525538f, 0.04804637f, 0.00241655f, 0.11473417f, -0.15908317f, 
    -0.12798297f, 0.04430648f, 0.00534616f, 0.16220957f, 0.02790613f, -0.04847384f, 0.03336254f, 0.08153851f, 
    0.01097308f, 0.09426095f, 0.11239610f, -0.00951420f, 0.22174777f, 0.60335898f, 0.36878172f, 0.20806600f, 
    -0.18705286f, -0.09849614f, -0.17635843f, 0.13600706f, 0.03115302f, -0.14241064f, 0.06767122f, 0.04909886f, 
    0.24120368f, -0.08446052f, -0.33069605f, -0.05776251f, -0.00846306f, -0.06216434f, -0.13507245f, 0.01922259f, 
    0.20565650f, -0.59258533f, -0.15661685f, -0.03487429f, -0.07822531f, 0.02338395f, -0.49489900f, -0.11460476f, 
    -0.14186220f, 0.14902666f, -0.04182347f, 0.13977614f, 0.07340628f, -0.13108316f, -0.16891316f, -0.08600802f, 
    -0.06621219f, 0.15418911f, 0.08366122f, -0.14299145f, -0.06983612f, 0.04562510f, -0.04984339f, 0.03577978f, 
    0.08055138f, -0.14617400f, -0.08826057f, 0.12010961f, -0.01405812f, -0.11202975f, -0.04928615f, 0.06872771f, 
    0.10637813f, 0.02618368f, -0.03735663f, 0.02143397f, -0.17077939f, -0.11975534f, -0.00871374f, 0.03101058f, 
    -0.13975117f, -0.15024070f, 0.04516132f, 0.05181520f, 0.03619509f, -0.52766496f, 0.14007135f, -0.15826575f, 
    0.23185177f, -0.06855949f, 0.01225044f, 0.08307803f, -0.02815146f, 0.17580673f, 0.28927687f, 0.14768462f, 
    0.19095986f, -0.03273285f, -0.01905068f, -0.11456487f, -0.17733340f, -0.01738124f, -0.02360677f, -0.05055455f, 
    0.06878702f, 0.40042233f, 0.13825729f, 0.09316712f, 0.13240273f, 0.59756875f, -0.46450710f, -0.04291622f, 
    -0.11966090f, -0.10188798f, -0.03128227f, -0.04267797f, -0.20952715f, -0.01104612f, -0.04300353f, -0.24391626f, 
    0.02882116f, -0.17125160f, -0.11666258f, 0.15845364f, 0.14228176f, -0.09909251f, -0.27752134f, 0.16662259f, 
    -0.17873144f, 0.33290976f, 0.16238330f, 0.02544966f, 0.13161759f, 0.06927481f, -0.09522183f, 0.08030666f, 
    0.09730470f, 0.49804679f, -0.11779346f, -0.08422749f, 0.30514750f, 0.35188133f, 0.20235829f, 0.07930328f, 
    -0.12294795f, 0.00080404f, 0.12623397f, -0.14817530f, 0.37979040f, 0.25507212f, 0.05590032f, -0.00333973f, 
    -0.22008531f, 0.02875008f, -0.11529624f, 0.22118014f, 0.16950777f, -0.10448529f, 0.12172961f, -0.03322632f, 
    0.27009684f, -0.11945873f, -0.39629775f, -0.04788645f, 0.06597120f, 0.04930044f, 0.43470749f, 0.27953151f, 
    -0.63232422f, -0.10306923f, -0.13619108f, 0.06046235f, 0.18019545f, -0.45117477f, 0.30660430f, 0.03195579f, 
    0.13135771f, 0.01487042f, 0.13332991f, -0.04018954f, 0.04796011f, -0.36945266f, -0.25667340f, 0.08977324f, 
    0.50060004f, 0.21179448f, -0.16782740f, 0.24973691f, 0.14297006f, -0.04594361f, -0.17499858f, -0.09364793f, 
    -0.16793944f, 0.52180529f, -0.09538244f, 0.14970563f, 0.12866470f, -0.00505732f, 0.15728176f, 0.29093379f, 
    -0.07179050f, 0.30592531f, -0.06086673f, 0.05764704f, -0.34385997f, -0.14572698f, 0.01208713f, 0.02121728f, 
    -0.16314286f, -0.16232805f, 0.07750089f, -0.05074645f, 0.16002858f, -0.23896566f, 0.36023006f, 0.12301671f, 
    0.16681555f, -0.48410043f, 0.14452723f, -0.07966875f, -0.04919786f, -0.08267543f, 0.16131203f, 0.16410038f, 
    0.11472442f, -0.41724077f, 0.15232562f, -0.26493117f, 0.14883524f, 0.00681628f, -0.05134460f, 0.48340937f, 
    0.41135123f, -0.04915188f, -0.15305239f, -0.07179464f, 0.11284013f, 0.12234728f, -0.33484915f, -0.12839292f, 
    0.10374952f, -0.17878875f, -0.13436541f, 0.13528143f, 0.48241681f, 0.22628868f, 0.16496870f, -0.20801409f, 
    -0.34392291f, -0.38600552f, -0.16927601f, 0.22145179f, 0.02473084f, -0.05783221f, 0.60879409f, 0.15457949f, 
    0.10123166f, 0.29572210f, -0.54534751f, -0.36520538f, 0.08189196f, -0.06204633f, 0.37086004f, -0.01139958f, 
    0.09399162f, 0.09804711f, 0.02970213f, 0.14720376f, 0.15189104f, -0.03119075f, -0.32980368f, 0.06102859f, 
    0.06913495f, -0.13216144f, 0.02279216f, 0.14329284f, 0.66825652f, 0.33240533f, 0.12133654f, 0.17335363f, 
    -0.09400650f, 0.02247978f, 0.17463034f, -0.12684140f, 0.10159349f, -0.00815758f, -0.02968523f, -0.02159166f, 
    0.49007824f, 0.16295858f, -0.33499718f, 0.10021674f, 0.02616516f, -0.02536674f, -0.39251542f, 0.15974484f, 
    0.09555627f, 0.01048344f, 0.12310083f, 0.16448258f, 0.21706928f, -0.30983233f, -0.17935336f, -0.12652092f, 
    -0.15071727f, 0.12592673f, 0.10017341f, 0.10195712f, -0.20881259f, 0.46884537f, -0.12017006f, 0.00512768f, 
    -0.12351474f, -0.05323705f, 0.00014010f, 0.17219752f, 0.00655845f, 0.16138111f, -0.14804089f, 0.09287152f, 
    0.31930491f, 0.08785602f, 0.15317947f, 0.11275353f, 0.03955839f, -0.06113996f, 0.53414339f, 0.05050265f, 
    0.16704436f, -0.17278767f, -0.12714730f, -0.11969134f, 0.21791151f, -0.46654630f, 0.41609567f, -0.09164752f, 
    0.07657403f, 0.11058427f, 0.16534865f, -0.07967988f, -0.13951658f, -0.15039033f, -0.05861700f, 0.03180566f, 
    0.06249671f, 0.05209669f, 0.11653759f, -0.02066818f, -0.05160832f, -0.09633163f, -0.09109358f, -0.12163594f, 
    0.06165153f, -0.19845249f, 0.02276212f, -0.09867087f, 0.08574446f, -0.12898661f, -0.14456047f, -0.12045424f, 
    0.03465777f, 0.09502896f, -0.16346668f, 0.07444768f, -0.06974798f, 0.03915531f, -0.07293335f, 0.10723843f, 
    0.10474648f, -0.03460190f, 0.01386288f, -0.11105698f, 0.33853903f, 0.18007982f, 0.16578680f, 0.06755939f, 
    -0.28354523f, -0.69890654f, 0.01817326f, -0.00374661f, -0.11754343f, 0.03765259f, 0.28333452f, 0.07535362f, 
    0.35350326f, -0.20768446f, -0.20794156f, -0.38692245f, 0.00158615f, -0.04842091f, 0.25585392f, 0.33894438f, 
    0.25126803f, 0.10337579f, 0.14047605f, -0.01896746f, 0.52792859f, 0.06003900f, 0.09493860f, 0.06136289f, 
    -0.05095087f, 0.06912599f, -0.09891052f, -0.06341398f, -0.06333701f, -0.04679417f, 0.36955315f, 0.36977801f, 
    0.39386821f, 0.04970666f, -0.03371670f, 0.02517953f, 0.11675027f, -0.07622076f, -0.16448615f, 0.03957015f, 
    -0.02506849f, -0.46157894f, 0.25101593f, 0.03706815f, 0.06777503f, 0.04400533f, -0.29521784f, 0.25160331f, 
    -0.06721364f, -0.23437592f, -0.05447211f, -0.03340546f, -0.08143164f, -0.15320215f, -0.30883092f, 0.00271622f, 
    -0.02996808f, 0.14318159f, 0.02915133f, 0.09811773f, -0.51467955f, -0.31285363f, -0.10508975f, 0.30113536f, 
    0.33242846f, 0.18103163f, -0.16416435f, 0.05373486f, 0.16841683f, 0.10995360f, -0.17573495f, -0.03097499f, 
    0.08589913f, 0.09287116f, 0.53196430f, 0.16596761f, -0.02166129f, -0.00718832f, -0.32535726f, -0.26377726f, 
    0.29808351f, 0.12750408f, -0.13546723f, 0.14845778f, -0.19141896f, 0.24896298f, 0.02247355f, -0.02343927f, 
    0.09394095f, 0.16844992f, 0.10526582f, 0.12482685f, -0.08178091f, 0.05083576f, -0.00229039f, -0.08081707f, 
    0.05584100f, -0.16504347f, 0.09501041f, -0.02828690f, -0.09997549f, 0.10025258f, 0.07516013f, -0.10206373f, 
    0.07597034f, -0.05036274f, -0.15358195f, 0.09068658f, -0.17136140f, -0.08100999f, -0.19446591f, -0.17873281f, 
    0.03818514f, -0.13777263f, -0.01750055f, -0.05999772f, 0.07253180f, -0.17241205f, -0.11850953f, -0.02965957f, 
    -0.13802136f, -0.03363207f, 0.18200274f, 0.15141194f, 0.50451028f, 0.24218842f, 0.32837555f, -0.23363861f, 
    -0.07298981f, -0.16923676f, 0.05322698f, 0.18839358f, -0.08436714f, -0.07951444f, 0.43056077f, -0.07361371f, 
    -0.07651344f, 0.24332912f, -0.18979044f, 0.04211214f, -0.00550882f, 0.15577394f, -0.06223334f, 0.08980578f, 
    -0.26634356f, -0.18850160f, -0.01447449f, -0.01393016f, 0.39451090f, -0.02839408f, -0.55578715f, 0.05645917f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07252014f, 0.00412652f, -0.05796061f, 0.26838017f, -0.17633338f, 0.03000799f, -0.18365826f, 0.08222486f, 
    0.05185691f, -0.06090501f, -0.07770322f, -0.04353894f, 0.33022702f, 0.10983068f, -0.07238601f, -0.04060724f, 
    -0.01904946f, -0.18951431f, 0.07041939f, 0.04241007f, 0.08925403f, -0.20706974f, -0.00697604f, 0.05782326f, 
    0.04905076f, -0.11656345f, -0.01653539f, -0.15294454f, -0.14864063f, -0.16357394f, -0.12951718f, 0.25044066f, 
    0.02324933f, 0.13317078f, -0.01356449f, -0.02440579f, 0.04973004f, 0.19065298f, 0.37135431f, -0.13135248f, 
    0.15939684f, -0.16182594f, 0.23485747f, -0.06635721f, 0.07760392f, 0.20582375f, 0.02272818f, -0.13640481f, 
    0.18346320f, -0.09995068f, -0.00258592f, -0.02529994f, 0.18892001f, 0.29494104f, 0.18131658f, 0.17216276f, 
    0.16691236f, 0.23234077f, -0.20217596f, 0.07373959f, 0.25025001f, 0.12893519f, -0.05209218f, 0.16191766f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04805497f, -0.39470500f, -0.13514160f, -0.25459459f, 0.34189904f, -0.12230726f, -0.31176668f, 0.26640603f, 
    -0.12614907f, 0.02863465f, 0.11718803f, 0.37652597f, 0.08297531f, 0.30669010f, -0.40864018f, 0.01671305f, 
    0.41608772f, -0.09909929f, -0.17717491f, -1.02736437f, 0.09125807f, 0.69446045f, -0.00748270f, -0.05721635f, 
    -0.05661207f, 0.02114496f, -0.37608162f, 0.07030381f, 0.01576420f, 0.12132572f, -0.04402396f, -0.51460487f, 
    0.20199890f, -0.76023626f, -0.58525491f, 0.31275740f, -0.06452914f, -0.04443252f, -0.25284025f, -0.10778461f, 
    0.05377069f, 0.39092758f, -0.16721924f, 0.17658690f, 0.13741936f, -0.00676876f, 0.08677752f, 0.01648524f, 
    -0.06124203f, -0.11469287f, 0.14713362f, -0.61576515f, 0.02716797f, -0.21526061f, -0.28086102f, -0.01909196f, 
    0.20972219f, 0.07044033f, -0.01292513f, -0.06570495f, 0.01409926f, 0.15620670f, -0.02163638f, -0.17447621f, 
    0.04987800f, 0.10139696f, 0.32225251f, -0.25999185f, 0.12839238f, 0.10730354f, 0.06480620f, 0.01292702f, 
    -0.50686312f, -0.02900141f, 0.09556004f, 0.22157833f, -0.14855696f, 0.23342654f, 0.05652592f, 0.10280146f, 
    -0.52017021f, -0.04349101f, -0.88267499f, 0.20762981f, -0.08816118f, 0.34909418f, -0.33659720f, -0.50468475f, 
    0.04727332f, 0.09545241f, 0.30357480f, -0.08131048f, -0.28649190f, -0.06993834f, -0.08789463f, 0.01578126f, 
    0.18907973f, -0.02219548f, -0.24691387f, -0.50791317f, -0.02739733f, 0.26137149f, 0.26954857f, 0.06677344f, 
    -0.31990901f, -0.48712447f, -0.27730447f, 0.14246273f, -0.51445937f, -0.11198544f, -0.03151076f, -0.01605055f, 
    0.24984598f, 0.01618304f, -0.29739904f, -0.19392696f, 0.14994282f, -0.22880757f, -0.11749555f, 0.36215878f, 
    0.15659313f, 0.16496535f, 0.02090250f, 0.05466625f, -0.18816586f, -0.39138141f, -0.09237985f, 0.29379168f, 
    -0.12153375f, 0.28479844f, -0.15900955f, 0.08072401f, 0.39032021f, 0.10151868f, -0.72196943f, -0.61553502f, 
    0.35785243f, -0.10285756f, -0.19364965f, -0.08485569f, -0.90970176f, 0.09124754f, -0.05184708f, 0.01199268f, 
    -0.48124582f, 0.02264728f, 0.23594023f, -0.18003407f, 0.42063820f, 0.04354411f, -0.43902516f, 0.07142187f, 
    0.07053129f, -0.06421562f, 0.42440999f, 0.02208932f, -0.26519424f, 0.08730223f, 0.06848768f, -0.01276532f, 
    0.11491568f, 0.31442893f, -0.25549027f, 0.18696085f, 0.00693598f, 0.51979434f, -0.01172821f, 0.04919754f, 
    0.01928462f, 0.24106675f, -0.17465037f, -0.18324853f, 0.06504179f, -0.64574426f, -0.08035894f, 0.10171510f, 
    0.28120488f, -0.00631657f, -0.53254944f, -0.67362070f, -0.18077189f, -0.71889359f, 0.06764254f, -0.24026214f, 
    0.14495228f, -0.10568350f, 0.05120000f, -0.03803839f, 0.22186936f, 0.01941502f, -0.01071711f, 0.13972545f, 
    0.00431343f, 0.26093087f, 0.15735860f, 0.02624915f, -0.32316232f, 0.09671254f, -0.06582791f, 0.41495484f, 
    0.15674625f, -0.15027823f, -0.10895558f, 0.04906484f, 0.09325611f, -0.52224833f, 0.28637537f, 0.06338610f, 
    0.08379600f, -0.00155646f, -0.19773164f, -0.00643346f, 0.07662224f, -0.00298284f, 0.27823928f, -0.74758583f, 
    -0.00472338f, -0.08353060f, -0.46801794f, -0.11705779f, -0.40349454f, 0.05112073f, -0.02715340f, -0.14418420f, 
    0.27097264f, -0.21519782f, 0.00502011f, -0.29809153f, -0.03585706f, 0.14228351f, -0.47009709f, 0.02053449f, 
    0.09057644f, 0.15056477f, 0.27243772f, -0.30493730f, 0.08260486f, 0.08766307f, 0.06682284f, -0.04780993f, 
    -0.43785539f, 0.06140541f, -0.45245692f, 0.13051201f, -0.17546012f, 0.31903660f, -1.23598206f, -0.30222115f, 
    -0.17122301f, 0.19060540f, 0.00028333f, -0.52708918f, -0.32784283f, 0.39046335f, -0.09588373f, -0.38898230f, 
    -0.06732687f, -0.04352051f, 0.06102845f, -0.01277762f, -0.49890491f, -0.11330543f, 0.32524538f, -0.06025112f, 
    0.04117284f, 0.00240086f, -0.08213154f, 0.00164039f, -0.28066561f, -0.15614901f, -0.16136292f, -0.01294257f, 
    -0.04716402f, -0.07454727f, 0.04666103f, 0.05015199f, 0.43920594f, -0.64721704f, -0.08580161f, 0.20311576f, 
    0.08888514f, 0.02995273f, -0.07419045f, -0.03405944f, 0.02681853f, -0.03974587f, -0.09879027f, -0.05066635f, 
    -0.11498978f, -0.17218959f, 0.15607138f, -0.29999110f, -0.06433547f, 0.13088991f, -0.02357368f, 0.10076201f, 
    0.44985056f, 0.04215103f, 0.31580597f, 0.21038665f, -0.22868118f, 0.07218228f, 0.04284719f, -0.00415660f, 
    -0.17584209f, -0.03544670f, 0.00822434f, 0.14619085f, -0.15121377f, 0.12676129f, 0.06444990f, -0.52176219f, 
    -0.46719563f, 0.00906715f, -0.03287528f, -0.27553979f, 0.17516972f, 0.18327254f, -0.00491483f, -0.40196025f, 
    -0.04962794f, -0.18855420f, 0.04523514f, 0.15451677f, -0.20539516f, -0.04111680f, 0.39473784f, -0.33988959f, 
    -0.55630511f, -0.02273819f, -0.01159599f, 0.14006694f, -0.03544211f, -0.04802490f, 0.03737654f, 0.02001573f, 
    0.33647257f, 0.05889947f, -0.14401980f, -0.12006620f, -0.54408205f, -0.26687908f, -0.05763767f, -0.31527427f, 
    -0.02116697f, -0.12805925f, -0.17046180f, -0.11259665f, 0.09714452f, 0.01467548f, -0.02709721f, 0.11075977f, 
    -0.45317325f, -0.02418489f, -0.19385950f, 0.13413043f, -0.02983812f, -0.50327492f, 0.26481780f, -0.05335324f, 
    0.00425535f, -0.38237768f, -0.05158539f, 0.05553949f, -0.13029936f, 0.24681751f, -0.02156847f, 0.08919200f, 
    -0.03465031f, 0.07381438f, 0.12494981f, 0.17006278f, 0.27776733f, 0.05605635f, 0.18587950f, 0.39766541f, 
    0.02329301f, -0.05748745f, -0.07257723f, 0.17616259f, -0.09914592f, -0.86020243f, 0.04637107f, 0.39824653f, 
    0.00691921f, -0.28322765f, 0.11465531f, 0.31579790f, -0.71618974f, -0.06199805f, -0.28299183f, -0.42207953f, 
    0.02558198f, 0.11154665f, 0.20344304f, 0.16569985f, 0.11717090f, -0.42960066f, -0.61559916f, 0.07377456f, 
    -0.13343810f, -0.07855731f, -0.04547750f, -0.95061135f, 0.49520788f, -0.69999927f, 0.17663030f, 0.02407156f, 
    -0.11116040f, 0.03813325f, -0.34401447f, -0.03739418f, 0.12056473f, 0.09415770f, 0.01222276f, 0.01435458f, 
    0.27997044f, 0.18493117f, -0.60188222f, -0.06326674f, 0.09514445f, -0.09675045f, 0.20685363f, -0.00411418f, 
    0.25417429f, -0.12978163f, -0.10885176f, -0.02663800f, 0.34614494f, 0.42199913f, 0.01797384f, -0.00148184f, 
    -0.00020552f, -0.10312324f, -0.56275469f, -0.22564809f, 0.16578880f, 0.17879596f, -0.09550578f, -0.46194702f, 
    0.30795977f, -0.00712036f, -0.10154553f, -0.07755825f, 0.18281174f, -0.15412959f, -0.01415646f, -0.23799017f, 
    -0.00179640f, 0.05472184f, 0.09074959f, -0.59313321f, 0.24942216f, -0.07231826f, 0.32307446f, 0.28230014f, 
    -0.25781664f, -0.08572689f, -0.29276115f, 0.08633831f, -0.27837068f, -0.30542892f, -0.07203478f, -0.10265017f, 
    0.09056379f, 0.04507874f, 0.06519574f, 0.28763425f, 0.06311060f, 0.36838040f, 0.02293796f, 0.27237612f, 
    0.11447474f, 0.07978477f, 0.03693501f, -0.08600286f, 0.19249114f, -0.12370217f, -0.04921300f, -0.00370946f, 
    0.15744708f, -0.49121049f, 0.17043974f, 0.04891430f, -0.06446826f, -0.36001593f, -0.56165624f, -0.12446089f, 
    0.06419253f, 0.19431742f, 0.11438675f, -0.32505333f, -0.28658202f, -0.55174917f, -0.01972783f, -0.05194553f, 
    -0.36379749f, 0.03373707f, 0.40233701f, 0.28554043f, -0.43454844f, -0.05487994f, 0.11737581f, -0.08893021f, 
    -0.32259253f, -0.56886089f, -0.03243480f, -0.13079952f, -0.59532404f, 0.07598092f, -0.01059322f, -0.11629140f, 
    0.07657531f, -0.20356023f, -0.59129995f, -0.22009507f, 0.19738349f, 0.07865353f, -0.22750032f, 0.16666064f, 
    0.00296440f, 0.02845644f, -0.01960266f, -0.67175025f, 0.58272737f, 0.17460963f, 0.28477067f, 0.02381885f, 
    -0.45092294f, -0.06334841f, -0.22013205f, 0.16216856f, -0.44698304f, -0.37472832f, -0.41190326f, 0.43291590f, 
    0.08278888f, 0.06662616f, 0.20414983f, 0.06075905f, -0.00849420f, 0.03524512f, 0.05940241f, -0.10602257f, 
    -0.67601806f, -0.07383005f, 0.43736154f, -0.37988970f, 0.03979068f, -0.16991520f, -0.09808910f, -0.00194103f, 
    -0.80808979f, -0.25721505f, -0.50572717f, 0.00361708f, -0.09358095f, -0.31944379f, 0.09122054f, 0.09076891f, 
    -0.06337553f, -0.00106805f, 0.19509210f, 0.00774841f, 0.01268443f, -0.14051603f, 0.26938638f, 0.33025950f, 
    0.27026191f, 0.20022577f, -0.09382914f, 0.31241027f, -0.10621636f, -0.35639337f, -0.11685777f, -0.18051837f, 
    -0.01649804f, -0.87556112f, -0.19671215f, -0.21537103f, -0.26876578f, -0.02193680f, 0.17276989f, 0.17134024f, 
    -0.30616769f, 0.02129751f, -0.04172533f, -0.28125891f, 0.20793886f, -0.05748028f, -0.44624677f, 0.08373283f, 
    0.07605466f, 0.09180222f, 0.44344306f, -0.28145635f, -0.72522050f, -0.24291329f, -0.39678410f, 0.23378304f, 
    0.02670380f, 0.05219074f, 0.07052895f, -0.13490880f, 0.14106628f, 0.02292835f, -0.06613635f, 0.31705657f, 
    -0.17826870f, -0.35923195f, -0.06821119f, 0.48407364f, 0.04786761f, -0.07281812f, -0.10947377f, -0.00267996f, 
    0.10032212f, 0.38157749f, 0.22287756f, 0.09870676f, -0.61902183f, -0.11011482f, -0.10354438f, -0.09115690f, 
    -0.00483224f, -0.13314189f, 0.35383663f, 0.16165550f, -0.36783689f, 0.02961351f, 0.30334267f, -0.13301960f, 
    0.13276613f, -0.32072151f, -0.02245460f, -0.04713828f, 0.12321312f, 0.16185851f, -0.06733865f, 0.16555050f, 
    -0.00867484f, 0.37655604f, 0.02936739f, 0.25392169f, 0.03565438f, 0.03080179f, -0.10566171f, -0.18685922f, 
    0.15304336f, 0.02452038f, -0.62322974f, 0.09687083f, -0.02783263f, 0.22794907f, 0.36535132f, -0.06576337f, 
    -0.08515394f, -0.01274052f, -0.04395932f, 0.19675007f, -0.04193265f, -0.23530291f, 0.28819147f, -0.37007523f, 
    0.07042129f, 0.08891985f, 0.08734584f, 0.02952791f, -1.11207342f, 0.09523364f, -0.02333820f, -0.23459862f, 
    -0.50894219f, 0.21178061f, 0.34263155f, -0.28090292f, 0.07058228f, 0.31494316f, 0.02306627f, 0.06224552f, 
    -0.30795056f, -0.13944267f, 0.11800308f, -0.25703889f, 0.28247550f, -0.57647592f, 0.09567822f, 0.03530627f, 
    -0.03323421f, -0.10398476f, -0.16759436f, -0.22718298f, 0.11003876f, 0.18557097f, -0.61024690f, -0.00946096f, 
    0.24356946f, -0.02391926f, -0.10128608f, -0.35245648f, -0.06229358f, -0.23246679f, 0.06198738f, 0.32153496f, 
    -0.01919092f, 0.34981036f, -0.53210050f, 0.31784487f, 0.03715500f, -0.11930928f, -0.22599815f, -0.17621328f, 
    0.42727539f, -0.03029856f, 0.08363765f, -0.25973547f, 0.11958835f, -0.44728994f, 0.40034908f, 0.04593520f, 
    -0.06237040f, -0.02795844f, 0.27612105f, -0.05125752f, 0.13905883f, -0.06918322f, -0.07072634f, -0.32343093f, 
    -0.10865286f, -0.03295322f, -0.04061408f, 0.03178611f, 0.23817666f, -0.10189527f, -0.10241691f, 0.31794810f, 
    0.03129535f, 0.28742900f, -0.23289132f, 0.44651791f, 0.06337634f, -0.17732854f, -0.52572048f, 0.03557718f, 
    -0.47291595f, -0.09987302f, 0.17751183f, -0.34483215f, 0.04192158f, 0.32166544f, -0.09701092f, -0.00469905f, 
    -0.35812140f, 0.08778559f, -0.47733498f, 0.10561105f, 0.05377670f, -0.24857916f, -0.18908410f, -0.44898486f, 
    -0.10876999f, 0.24788968f, 0.00741953f, 0.03958394f, -0.02278109f, -0.02600564f, -0.00058566f, -0.37273237f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19791837f, -0.02638518f, -0.21870685f, -0.06794621f, 0.04625620f, 0.10370707f, 0.20490353f, -0.31716433f, 
    0.01217731f, -0.00109534f, 0.01704035f, 0.00768912f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
