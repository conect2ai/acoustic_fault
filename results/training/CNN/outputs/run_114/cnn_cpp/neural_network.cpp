#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.99487150f, -0.40923840f, -0.83720750f, -0.30211207f, 0.67911637f, -0.12263994f, 0.00546573f, -0.16889940f, 
    0.11886960f, -0.57586533f, -0.49690884f, -0.58083653f, 0.57139212f, 0.00434500f, 0.43438381f, -0.44749656f, 
    -0.25610983f, -0.17987138f, 0.34529805f, -1.06676579f, -0.53285533f, 0.61897451f, 0.52579540f, 0.31051090f, 
    -0.46440056f, 0.14372006f, 0.01164287f, -0.60523677f, -0.95757592f, -0.93068945f, -0.31139618f, -0.47889379f, 
    0.04623735f, 0.50395089f, 0.28096667f, 0.23241459f, -0.57765448f, 1.10523427f, 0.28236118f, 0.01498756f, 
    0.98940974f, 0.69523132f, 0.20643151f, -0.07021241f, -0.19810818f, -0.27357066f, -0.30391651f, -0.62069482f, 
    -0.07236455f, 0.26682889f, 0.37492439f, -0.35619673f, -0.32512778f, -0.72338313f, -0.30031231f, -0.65372252f, 
    -0.42483667f, -1.06656539f, -0.94239485f, 0.17092569f, -0.19955270f, 0.15234184f, 0.27142873f, 0.95026588f, 
    0.29809010f, 0.75327939f, 0.64013541f, -0.49407396f, 0.58530283f, -0.23623547f, 0.33289617f, -0.17422557f, 
    0.40326899f, 0.74427950f, 0.01187602f, -0.73805308f, -0.70927024f, -0.88192564f, 0.19333464f, 0.22181538f, 
    0.16207121f, 0.72146970f, 0.75180101f, 0.97228664f, -0.31208715f, 0.25246453f, -0.23810208f, 0.17329498f, 
    -0.29947051f, -0.14707296f, 0.69839191f, 0.36584508f, 0.48411614f, -0.37761131f, -0.67054123f, 0.60578656f, 
    -0.08207635f, 0.18676081f, 0.23437214f, -0.92305100f, 0.04672410f, 0.26988515f, 0.88511753f, 0.84248579f, 
    0.14703079f, 0.68538278f, 0.01575640f, 0.49672514f, -0.23251018f, -0.39080548f, 0.23196547f, 0.79174876f, 
    1.09905434f, -0.00436163f, -0.22062552f, 0.17001310f, -0.67176080f, 1.09199274f, 1.15099025f, -0.18666178f, 
    0.45992124f, 0.29923928f, -0.12735096f, 0.21976061f, -0.08952208f, -0.13979350f, -0.43305644f, -0.39316288f, 
    0.86829484f, -0.49573776f, 0.83306295f, -0.77429277f, 0.01579251f, 0.09830825f, -0.35965797f, 0.74630892f, 
    0.18161693f, -1.13028562f, -0.05690850f, 0.56964314f, -0.44411549f, 0.04432621f, 0.38635495f, 0.16333950f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28909355f, -0.30019289f, -0.16968744f, 0.25385571f, -0.06178574f, 0.03327764f, 0.24291804f, 0.37937224f, 
    0.15651260f, 0.25635332f, 0.13507494f, 0.27052149f, -0.12456200f, 0.09173664f, -0.11597644f, 0.28176713f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.41902149f, 0.41876316f, 0.06036238f, -0.14802265f, -0.19660808f, -0.11235737f, 0.04062468f, 0.01407288f, 
    0.04590564f, 0.32633463f, 0.35569012f, 0.32187250f, 0.05013501f, 0.12334014f, 0.12237271f, 0.12174998f, 
    -0.08645599f, 0.02849180f, 0.05055422f, -0.08638383f, 0.09519083f, -0.04440797f, -0.08275539f, -0.00898713f, 
    0.15060091f, 0.03947437f, -0.30005544f, -0.11363953f, -0.10366064f, -0.24468437f, -0.00336609f, -0.00979010f, 
    -0.20760596f, -0.06771143f, -0.04653892f, 0.06978914f, 0.27110243f, 0.22558200f, -0.23680179f, 0.09610965f, 
    0.16762878f, 0.13756365f, 0.04175334f, -0.24720930f, 0.17241129f, 0.05981873f, 0.17796494f, 0.14075983f, 
    -0.13987656f, -0.19026914f, 0.12189369f, 0.12442479f, 0.12750253f, 0.13543890f, -0.17313173f, -0.16803378f, 
    -0.24196909f, 0.12245938f, -0.03515686f, -0.08175138f, 0.01636088f, 0.27973706f, -0.06335607f, -0.15150660f, 
    0.04676563f, -0.10485265f, 0.05965208f, 0.07045583f, -0.13628827f, -0.01986091f, -0.04834447f, 0.02057133f, 
    -0.51827204f, 0.15133977f, 0.06150397f, -0.19755550f, -0.13529728f, 0.01258563f, 0.00440488f, -0.09474616f, 
    -0.12317327f, 0.25249591f, 0.30711526f, -0.25014278f, -0.01138663f, 0.00695072f, -0.05032257f, 0.00458391f, 
    -0.10063079f, -0.02472993f, -0.28043833f, -0.14740352f, -0.43983331f, -0.10319902f, 0.03843650f, 0.02203557f, 
    0.03553288f, 0.13502367f, -0.01299729f, 0.54236150f, 0.24123919f, 0.01300887f, 0.06213444f, 0.08492526f, 
    0.11362507f, 0.12661615f, -0.04453480f, -0.06864589f, -0.01711217f, 0.37793726f, -0.10684580f, -0.07301063f, 
    -0.09708239f, -0.00493269f, -0.11741786f, 0.18891852f, 0.00216557f, 0.25488082f, 0.13855511f, 0.05931189f, 
    -0.02465688f, -0.08830827f, 0.21582884f, 0.06265856f, 0.16095506f, 0.19278948f, -0.02151790f, -0.09737986f, 
    -0.22654110f, 0.05292078f, 0.11301299f, 0.10347351f, 0.03358438f, 0.14053155f, -0.11947223f, -0.39639488f, 
    -0.20538947f, -0.19055647f, 0.17710167f, 0.02897589f, 0.00013941f, 0.06710713f, 0.01093202f, -0.02459837f, 
    -0.81449741f, -0.28093261f, -0.09696071f, 0.34745333f, 0.06722889f, 0.12209827f, -0.16295797f, -0.01409647f, 
    0.08406509f, -0.60592151f, -0.01959675f, -0.13033783f, 0.30772236f, -0.07320671f, 0.00980913f, 0.05016173f, 
    0.01733398f, -0.15443696f, -0.41258976f, 0.24273285f, 0.21765350f, -0.02118800f, -0.24496894f, 0.00411072f, 
    -0.13355117f, 0.19409284f, -0.03502704f, -0.29601860f, -0.14056249f, -0.04265549f, 0.32293037f, -0.00494500f, 
    0.16326457f, 0.08886282f, -0.28624758f, -0.00865919f, 0.33895123f, -0.42468858f, -0.22231787f, -0.52820355f, 
    -0.05484379f, 0.05148972f, 0.07563154f, 0.11703174f, -0.03221418f, 0.10816376f, 0.08700906f, 0.20730118f, 
    0.41642058f, -0.04095707f, -0.05533888f, 0.03100260f, 0.14854990f, 0.09670070f, 0.25327209f, -0.02942652f, 
    -0.01002349f, 0.28706843f, 0.15150788f, 0.10059825f, -0.12869884f, 0.19582894f, 0.22368923f, 0.00079666f, 
    0.16266191f, 0.21555288f, 0.09796064f, 0.04547802f, 0.02893071f, 0.03337277f, 0.01979889f, -0.00459841f, 
    0.14436923f, 0.24000213f, 0.06907626f, -0.17382213f, 0.03200805f, 0.22686148f, 0.30351225f, 0.12032554f, 
    -0.14668509f, -0.06207668f, 0.16360992f, 0.29075378f, 0.23343489f, 0.21784544f, -0.13487703f, 0.22976647f, 
    0.05220472f, 0.03528796f, -0.12620389f, 0.03418477f, 0.20417956f, 0.01254810f, 0.14440896f, -0.07045895f, 
    -0.06862997f, 0.04359737f, -0.02616871f, -0.38931003f, 0.02476285f, -0.25142521f, 0.11697806f, -0.00396833f, 
    0.03455318f, -0.07236780f, -0.01077029f, -0.06340830f, -0.06151175f, -0.14147358f, -0.09833725f, -0.05260646f, 
    -0.24058877f, -0.08446707f, 0.17767759f, -0.11510383f, -0.13197510f, -0.25122550f, -0.01032355f, -0.10338248f, 
    -0.05263718f, -0.14886303f, -0.15582348f, -0.21152031f, 0.03173575f, 0.05959024f, -0.14260946f, -0.05629221f, 
    -0.16280298f, 0.01181150f, 0.12247734f, 0.01151229f, -0.06464293f, -0.11723563f, 0.09165522f, -0.08198458f, 
    0.01893120f, 0.00003740f, -0.12122157f, -0.21486199f, 0.06400967f, 0.16434641f, 0.04372443f, -0.01354522f, 
    -0.34204286f, -0.35572681f, -0.39311272f, -0.21756609f, 0.01133529f, 0.09326459f, 0.21885991f, -0.04713633f, 
    -0.01973261f, 0.14325947f, -0.09054304f, -0.21938899f, -0.00351733f, -0.04440334f, 0.00842201f, 0.08628489f, 
    -0.05391570f, 0.07340690f, -0.44802794f, -0.21552645f, -0.30473217f, -0.03408336f, -0.05086979f, -0.12872033f, 
    -0.26666978f, -0.06148181f, 0.13915356f, -0.36203119f, 0.14460543f, -0.12716550f, 0.16984758f, 0.11198474f, 
    0.11549035f, 0.09140989f, 0.02662185f, -0.07234860f, -0.09956052f, 0.17381318f, 0.00375608f, 0.21491365f, 
    -0.01553384f, 0.15799215f, 0.14522609f, 0.01822885f, -0.00210867f, 0.23924114f, -0.09309321f, -0.23803475f, 
    0.04616846f, 0.00211152f, 0.02750876f, 0.02138807f, -0.01554056f, -0.11546693f, -0.04569563f, -0.24999253f, 
    -0.13993381f, 0.08886395f, 0.01809889f, -0.13683954f, -0.00375569f, 0.18866859f, 0.11583976f, -0.12653765f, 
    0.03148135f, 0.29770911f, 0.28288910f, 0.23382512f, 0.15821093f, 0.29070920f, -0.07367976f, -0.11462817f, 
    0.29959148f, 0.08610514f, 0.05677031f, -0.07360985f, -0.01536307f, 0.16704957f, -0.02113659f, -0.03533197f, 
    0.22454062f, 0.10356692f, 0.22421585f, 0.35475463f, 0.07982646f, 0.24366638f, -0.00866113f, 0.08266430f, 
    0.06813007f, 0.10557854f, 0.03168282f, 0.11170465f, 0.04312609f, -0.19950277f, 0.00214362f, -0.01431044f, 
    0.11514501f, -0.16073701f, 0.06625788f, -0.31254900f, 0.26008308f, -0.08103880f, 0.12469371f, 0.01544566f, 
    -0.12683035f, 0.10216395f, -0.16226266f, -0.25878340f, -0.02911565f, -0.08402329f, 0.19365431f, 0.07546396f, 
    0.17738897f, 0.17082280f, -0.21734934f, 0.00453517f, -0.15196662f, 0.27704191f, -0.23725456f, 0.05525586f, 
    -0.00144702f, -0.14768347f, -0.07070336f, 0.00322303f, 0.06303889f, -0.05066229f, -0.04755740f, -0.02192812f, 
    -0.46377841f, -0.15496263f, 0.09579191f, 0.14687282f, -0.19871861f, 0.08350603f, -0.12434310f, -0.19387467f, 
    -0.29718465f, 0.22150628f, 0.02662077f, -0.01719522f, 0.02594997f, -0.13075590f, -0.10500403f, -0.04893091f, 
    -0.00308149f, 0.06777252f, 0.05823915f, 0.20873997f, -0.10978143f, 0.19822061f, -0.09332851f, 0.05278466f, 
    -0.12546052f, 0.38604903f, 0.16058622f, 0.47735688f, 0.24037801f, 0.07191767f, 0.01589037f, 0.20143621f, 
    -0.06802645f, 0.15906104f, -0.01949476f, 0.15690075f, -0.18747120f, -0.03537773f, 0.04407582f, -0.21339177f, 
    0.01685227f, 0.15859860f, 0.13156787f, 0.01890475f, 0.23387866f, 0.13443871f, -0.08241963f, 0.00345734f, 
    -0.23846807f, -0.05402171f, 0.01391403f, -0.00631150f, -0.17519905f, -0.34874824f, -0.05834790f, 0.07466514f, 
    0.09487484f, -0.09815664f, -0.09347454f, -0.00342879f, -0.09607544f, 0.22036332f, 0.19249380f, -0.05974396f, 
    0.04715240f, 0.13404839f, -0.04337380f, 0.22835778f, -0.15315604f, -0.36006293f, 0.18858615f, 0.18694568f, 
    0.09385022f, 0.08888832f, -0.05726881f, 0.01120850f, -0.01029084f, -0.03776693f, -0.09335572f, 0.38595581f, 
    -0.06371409f, 0.05418788f, -0.08490079f, 0.06855950f, -0.19655123f, -0.00707006f, 0.06262183f, 0.01344340f, 
    -0.57482404f, 0.12064932f, -0.08097453f, -0.23209907f, -0.23395391f, -0.01131491f, -0.09748264f, 0.04789694f, 
    0.03234367f, -0.67540419f, -0.19280054f, 0.01472540f, -0.14146589f, 0.06005211f, -0.13580880f, -0.18556237f, 
    -0.05585030f, 0.07971267f, 0.04826384f, -0.03731611f, -0.27426633f, -0.10624725f, -0.08264076f, -0.18096142f, 
    -0.04668326f, 0.13984816f, 0.09690145f, 0.33125040f, -0.08043410f, 0.11199085f, -0.11367080f, -0.01806236f, 
    0.05907477f, 0.16139290f, -0.09883694f, 0.24432945f, 0.21972130f, 0.39488974f, -0.13459823f, 0.14576714f, 
    0.01137471f, -0.00511112f, 0.03559402f, 0.00498910f, 0.02389186f, -0.20028709f, 0.27748692f, 0.02596275f, 
    -0.02622960f, -0.14519830f, -0.10027172f, 0.10453076f, -0.02259505f, 0.01036563f, 0.00472202f, -0.00115480f, 
    0.24235898f, 0.04150147f, -0.07416386f, -0.10153898f, -0.09171312f, 0.00636415f, 0.13354161f, -0.56193852f, 
    0.05502112f, -0.00706076f, -0.14047216f, -0.09233717f, 0.06655984f, -0.10464289f, 0.10717802f, 0.01240326f, 
    -0.01573891f, 0.00909613f, -0.09199161f, -0.04919914f, -0.02983671f, -0.02380138f, -0.02686321f, -0.02504432f, 
    -0.06881690f, -0.00342604f, -0.07204559f, 0.06740018f, -0.07638571f, -0.08510274f, -0.04187853f, -0.07540715f, 
    0.07145628f, -0.00127576f, -0.00335856f, 0.00517003f, 0.06403843f, -0.02551925f, 0.03141225f, 0.01412291f, 
    -0.01274296f, -0.07912460f, 0.07307297f, 0.01585075f, 0.03822079f, -0.03687439f, -0.05514051f, -0.05937058f, 
    -0.07398549f, 0.06163529f, -0.08003984f, 0.00848873f, -0.03829999f, -0.05061544f, -0.07739460f, 0.07261434f, 
    0.04694038f, -0.00823280f, 0.02577939f, 0.02666517f, -0.04435153f, -0.09291318f, -0.03596406f, -0.06266091f, 
    -0.08722228f, -0.02029677f, -0.05165995f, -0.07381079f, -0.09265170f, 0.03385981f, -0.05584525f, -0.03022715f, 
    -0.01410468f, 0.06580925f, 0.04305451f, -0.01824609f, -0.06692985f, 0.01814163f, -0.04832668f, 0.06198732f, 
    0.06745049f, 0.07105970f, -0.00213693f, -0.03294252f, -0.04692190f, 0.03160556f, -0.02873498f, -0.07880253f, 
    -0.08294730f, -0.07962517f, 0.02507115f, 0.03859347f, -0.00997015f, 0.05661350f, -0.05258527f, -0.01084294f, 
    0.04347296f, -0.07447369f, -0.00755859f, 0.04531188f, -0.08199149f, -0.04267507f, -0.04285331f, 0.01291506f, 
    0.00429552f, 0.06703042f, -0.04413042f, -0.06239484f, -0.05206219f, -0.04672764f, -0.03397399f, -0.06440837f, 
    -0.03391516f, -0.06013376f, -0.04770032f, 0.02060627f, -0.05709434f, -0.00894069f, 0.04423420f, -0.02822665f, 
    0.05779506f, 0.05031180f, 0.01218451f, 0.04216129f, 0.00593472f, -0.07469726f, 0.00680024f, 0.06312715f, 
    0.04697385f, 0.06741929f, -0.03742596f, 0.05501097f, -0.06517384f, 0.06835069f, 0.02522265f, -0.03520039f, 
    -0.04512046f, 0.05267180f, -0.06033400f, -0.03187035f, 0.01789802f, 0.06087170f, -0.04874258f, 0.05848574f, 
    -0.06002235f, -0.04382226f, 0.06842177f, -0.06474321f, 0.03232409f, -0.00004773f, -0.00845253f, -0.06918234f, 
    -0.04788875f, -0.06094664f, 0.06010205f, 0.00984411f, -0.07904555f, -0.01612090f, 0.03913130f, 0.06924284f, 
    0.25329599f, 0.30935919f, 0.23032171f, 0.06008833f, -0.23852760f, 0.21812275f, -0.18448861f, -0.16839504f, 
    0.21503149f, 0.29516259f, 0.14130054f, 0.22256204f, 0.27328444f, 0.27953142f, 0.28384763f, 0.06471441f, 
    -0.00838683f, 0.10601464f, 0.01359359f, 0.17060080f, -0.12312537f, 0.21463062f, 0.24387376f, 0.03881323f, 
    0.11810646f, 0.13740730f, -0.35695001f, 0.17211789f, -0.01742810f, 0.29616213f, 0.23131573f, 0.25667417f, 
    -0.15167266f, 0.09801837f, 0.01655701f, 0.03844098f, -0.49216047f, 0.23130396f, 0.26312736f, -0.01588101f, 
    0.01703246f, -0.02450707f, 0.13019717f, 0.16778611f, 0.22800440f, 0.06603681f, -0.02231837f, 0.20635341f, 
    0.30587184f, 0.09813141f, 0.07585964f, 0.11030567f, -0.07103185f, 0.32713008f, 0.40085122f, 0.00539865f, 
    0.16081227f, 0.12300883f, 0.04857845f, -0.13243139f, -0.07009749f, 0.19682503f, -0.00094271f, 0.15004516f, 
    -0.27572447f, -0.17814741f, -0.19744977f, -0.01788988f, -0.07160985f, -0.02149983f, 0.15626566f, -0.01744070f, 
    -0.09621155f, -0.23018566f, -0.25272185f, -0.05056086f, 0.10723317f, -0.14344427f, -0.32231125f, 0.01818232f, 
    -0.13882591f, -0.41406557f, -0.03058396f, 0.35219532f, -0.05523802f, -0.07401809f, 0.22859925f, 0.03692833f, 
    -0.04036045f, 0.15768111f, 0.25340664f, -0.36466891f, -0.00131325f, -0.04439885f, 0.07452394f, -0.11929282f, 
    0.04353309f, -0.03234330f, -0.20999666f, 0.31744918f, 0.25264710f, 0.19559380f, 0.12188391f, -0.04270899f, 
    0.10229423f, 0.07589372f, 0.15061638f, -0.10104261f, -0.23064519f, 0.07510170f, -0.25098011f, 0.23359463f, 
    -0.10578800f, -0.07115969f, 0.02726199f, 0.06026645f, 0.41655707f, 0.03384077f, 0.13474804f, -0.30337775f, 
    0.03404256f, -0.34253398f, 0.15794648f, -0.08323897f, 0.16295046f, -0.02473619f, -0.11794265f, 0.49367028f, 
    0.00098481f, 0.03116055f, -0.06631123f, 0.03483874f, -0.06641354f, -0.05273080f, 0.01484949f, 0.01222964f, 
    0.07716367f, -0.06183808f, -0.17162846f, -0.06090156f, -0.06499590f, 0.01062969f, 0.09781972f, -0.13330941f, 
    -0.08982356f, 0.19686684f, 0.09573331f, -0.15558127f, -0.02180573f, -0.04812433f, 0.12717260f, 0.25836140f, 
    -0.04415983f, 0.17933235f, 0.05253688f, -0.14227633f, -0.09191984f, 0.06913204f, 0.23577918f, 0.00701963f, 
    0.03974084f, -0.07080736f, 0.05410200f, 0.30525249f, -0.13618281f, 0.07224926f, 0.04218975f, -0.13215205f, 
    -0.11156996f, 0.14950678f, 0.01195847f, 0.05991638f, 0.05402115f, -0.03623814f, 0.17912146f, -0.20981057f, 
    -0.09416140f, -0.13665733f, 0.07744807f, -0.12460184f, -0.50341934f, -0.18180704f, -0.27422407f, 0.21585698f, 
    -0.03398041f, -0.07262357f, 0.02718301f, 0.06123798f, -0.17151073f, 0.00900307f, -0.15793967f, 0.21447667f, 
    0.03277842f, 0.13338546f, 0.18071118f, 0.02470885f, -0.24627830f, 0.00208354f, 0.42582864f, 0.23721680f, 
    -0.08004788f, 0.15377128f, -0.17228121f, 0.16015299f, 0.36088625f, 0.07571908f, 0.05232811f, -0.57638478f, 
    -0.74830866f, -0.11523346f, 0.16840096f, 0.18708871f, 0.03597476f, 0.07328266f, 0.02843840f, 0.02403421f, 
    0.63360918f, 0.14211036f, 0.24295253f, 0.19646566f, -0.14517227f, -0.03240434f, -0.04084760f, 0.11238837f, 
    0.23174827f, -0.36911884f, -0.38634089f, 0.20666544f, 0.21722350f, 0.26505402f, 0.06966744f, -0.19856989f, 
    0.00793919f, 0.09810380f, -0.29011622f, -0.54510498f, 0.11512512f, 0.12785898f, 0.12277231f, 0.10935518f, 
    0.11603893f, 0.04487083f, -0.17154278f, 0.31367064f, 0.23236006f, 0.00511917f, 0.11914872f, -0.00529426f, 
    -0.01355334f, 0.01223495f, 0.25779310f, 0.16014853f, -0.15224800f, -0.03274362f, -0.26304847f, -0.00502412f, 
    -0.08725403f, -0.00482376f, 0.03575880f, 0.01976600f, -0.11624441f, -0.56430030f, -0.43983871f, -0.30641282f, 
    0.00686721f, -0.02722140f, -0.00030970f, -0.02416738f, -0.04816669f, 0.02556712f, 0.40055314f, 0.28380215f, 
    0.14434169f, -0.18136643f, -0.13212419f, 0.17440066f, 0.00930209f, 0.04418297f, 0.03632219f, -0.07342292f, 
    -0.15460759f, 0.03452909f, 0.06278522f, 0.03340219f, -0.04681500f, 0.07890167f, 0.24840978f, 0.22307847f, 
    0.21997742f, 0.02065917f, -0.04831312f, 0.02461667f, -0.02120917f, 0.07269503f, 0.17562565f, 0.01819920f, 
    -0.11182802f, 0.03550360f, 0.31390184f, 0.04815030f, -0.04008842f, -0.09319904f, -0.14033249f, -0.08410047f, 
    0.11601786f, 0.16344734f, -0.02502845f, 0.13617392f, 0.05010357f, -0.11843103f, 0.08104984f, -0.07138535f, 
    0.12291863f, -0.11368027f, 0.07131131f, 0.11740569f, -0.24961323f, 0.15916817f, -0.33244261f, 0.17865290f, 
    -0.07492728f, -0.11462110f, -0.01538322f, 0.04100953f, 0.12083853f, 0.13345820f, -0.28062403f, 0.13661794f, 
    0.06562448f, -0.01656722f, -0.06599684f, -0.08265913f, 0.22534126f, 0.09819917f, -0.18599521f, -0.41537759f, 
    0.02585884f, -0.07311860f, 0.02775513f, 0.08291645f, 0.06887322f, 0.12565395f, 0.35620520f, -0.76624805f, 
    -0.06411452f, 0.04309891f, -0.04924574f, 0.18337126f, -0.17339122f, 0.13902408f, 0.08542247f, -0.67661607f, 
    0.07608370f, -0.00987154f, 0.02418977f, 0.11854734f, 0.00995063f, -0.02934803f, 0.15288760f, 0.17713143f, 
    0.25027663f, 0.20659098f, -0.10573497f, 0.11209234f, 0.15445246f, 0.15665795f, -0.12738681f, 0.00869856f, 
    -0.10152504f, -0.33598340f, 0.03020182f, -0.05904385f, 0.05953018f, 0.19516927f, -0.01715712f, -0.14286043f, 
    -0.04289457f, -0.04400443f, -0.75883013f, 0.09362037f, -0.41990754f, -0.00784374f, 0.21422374f, 0.08442973f, 
    -0.03330505f, -0.04876650f, 0.03060051f, 0.33898100f, 0.26145238f, 0.10812049f, 0.05985224f, -0.16731964f, 
    -0.09714042f, 0.15147650f, 0.03580383f, 0.06714339f, 0.33278027f, -0.04642234f, 0.23263286f, 0.18571530f, 
    0.19755833f, -0.03141382f, -0.01356075f, 0.12491482f, -0.10941444f, 0.17724347f, -0.63596618f, 0.21132661f, 
    -0.51506895f, -0.15493618f, 0.13003820f, -0.02904143f, 0.06826204f, -0.03408570f, 0.04327928f, 0.04154935f, 
    -0.73470247f, 0.19703266f, 0.06247132f, 0.12855726f, -0.08033066f, -0.13248888f, -0.07885167f, 0.13349068f, 
    -0.20092684f, -0.05000212f, -0.00991591f, -0.04173284f, 0.15153904f, -0.09836149f, -0.09642568f, -0.21603750f, 
    0.01424599f, 0.00032583f, 0.03078077f, 0.03754755f, 0.02943047f, 0.00783461f, -0.05957452f, -0.07175057f, 
    0.01425116f, -0.07398768f, 0.05396947f, 0.02355548f, -0.04760379f, -0.02423298f, 0.04205884f, -0.00502206f, 
    -0.04394309f, -0.03158762f, -0.10320167f, 0.04205932f, 0.00930034f, -0.08994439f, -0.10758420f, -0.09819771f, 
    -0.09838022f, -0.02230378f, -0.05852758f, -0.08790128f, -0.06296862f, -0.08548331f, -0.11191455f, -0.00038660f, 
    0.01707743f, -0.00024986f, -0.03407843f, -0.02520377f, 0.03793724f, 0.03686847f, -0.07956656f, -0.05073003f, 
    0.03509148f, -0.05037042f, -0.06735063f, 0.01426650f, -0.08718938f, -0.08637644f, -0.02961440f, 0.01597757f, 
    -0.03402700f, -0.06290223f, -0.08190235f, -0.06313648f, -0.05501607f, -0.00338812f, -0.02887300f, 0.02084795f, 
    -0.08925027f, 0.02700798f, 0.00383946f, 0.03054853f, -0.03309185f, -0.02425447f, -0.02881231f, 0.01132213f, 
    0.00140792f, -0.07634610f, -0.03291918f, 0.05181644f, -0.04272522f, 0.02904405f, -0.01693270f, -0.06731986f, 
    0.02044166f, -0.06990755f, 0.02361137f, -0.03492956f, -0.07066416f, 0.04474081f, 0.01868260f, 0.01787028f, 
    0.04323104f, -0.07849072f, 0.01708975f, 0.01995663f, -0.03630520f, -0.10010388f, -0.02910719f, 0.00937965f, 
    0.01224082f, -0.02620542f, -0.01759731f, -0.10397720f, -0.01846125f, -0.05386081f, -0.05404038f, 0.04095318f, 
    -0.08917946f, -0.08322856f, -0.04289402f, -0.03470355f, -0.08848111f, -0.05475445f, 0.02083242f, -0.10876996f, 
    -0.07476501f, -0.08433974f, -0.05452778f, -0.01000044f, -0.06481506f, 0.01482481f, 0.05173575f, -0.05609093f, 
    -0.09608793f, 0.02048153f, 0.03397894f, -0.02329300f, -0.05759994f, -0.07156897f, 0.07218584f, 0.06177828f, 
    -0.04260910f, -0.05366463f, 0.05139156f, -0.04152146f, -0.03709082f, -0.03258956f, 0.00121080f, 0.04889188f, 
    0.04701215f, -0.09095370f, 0.00025347f, -0.10042153f, -0.09558557f, 0.00554484f, -0.01961088f, -0.01336672f, 
    0.01315765f, -0.04904990f, -0.06443915f, -0.01487433f, -0.04697298f, -0.07239591f, -0.05583244f, -0.02134069f, 
    0.44750383f, 0.09114908f, -0.36988619f, 0.05357159f, -0.02040618f, 0.11630193f, -0.06371048f, 0.12356407f, 
    -0.22884564f, -0.09369311f, 0.14772066f, -0.45061812f, 0.10793149f, 0.05533114f, 0.08388447f, 0.03768861f, 
    -0.11391317f, 0.09145451f, 0.10013725f, -0.09623197f, -0.52850521f, -0.05819256f, 0.07723297f, -0.08218774f, 
    -0.06373768f, -0.00820731f, 0.05140486f, -0.82603598f, -0.21811497f, -0.16975948f, -0.03333194f, 0.13678470f, 
    0.04979412f, -0.01388238f, -0.09855562f, -0.03975401f, 0.30714583f, -0.01498114f, -0.12640561f, -0.17046063f, 
    -0.14026646f, -0.11104386f, 0.05564112f, 0.10467891f, -0.06019175f, -0.27827075f, 0.28903329f, -0.24218875f, 
    -0.15812157f, -0.07217015f, -0.01875869f, 0.20071833f, -0.01916765f, 0.06140102f, -0.27528882f, 0.04053815f, 
    -0.20690624f, -0.08070569f, 0.03015970f, -0.16065693f, 0.00178956f, 0.17366691f, 0.12361734f, 0.22195210f, 
    0.14614789f, 0.07217146f, -0.05152797f, -0.09841254f, -0.01672336f, -0.00712715f, 0.04169341f, 0.03638089f, 
    0.40963021f, 0.11544518f, 0.37286511f, 0.06364701f, 0.04910207f, 0.01520638f, -0.20141946f, 0.08929971f, 
    0.15808231f, -0.28324202f, -0.03911679f, -0.03805542f, 0.05289122f, 0.12190133f, -0.17015311f, -0.02722608f, 
    0.05540356f, 0.11379620f, 0.22136569f, 0.02408299f, -0.18456711f, -0.14323285f, -0.13208742f, -0.07146461f, 
    -0.02780105f, 0.13023168f, 0.06116426f, 0.03148266f, -0.20247339f, 0.46864334f, 0.05937024f, 0.02340702f, 
    -0.03327101f, 0.07500073f, -0.05045640f, -0.10040452f, -0.11063930f, -0.06334721f, -0.30617532f, 0.37276989f, 
    -0.03379819f, -0.03562617f, 0.10743118f, -0.00992901f, -0.07345099f, -0.27237263f, 0.22954085f, 0.09252710f, 
    0.01218555f, 0.01905690f, -0.05674895f, -0.12710088f, 0.10713630f, 0.04874497f, -0.22895098f, -0.23421314f, 
    0.10516473f, 0.07528237f, 0.05664819f, -0.01722549f, -0.05588729f, -0.02183861f, 0.02875940f, -0.59420842f, 
    -0.18360855f, 0.77780873f, 0.17510962f, -0.03885864f, 0.03324603f, 0.03393392f, 0.11534110f, 0.02263862f, 
    -0.31484821f, -0.24144779f, 0.38435018f, 0.00754645f, -0.06179351f, -0.04515329f, 0.16343510f, 0.01513768f, 
    0.15483160f, -0.55894738f, -0.38985112f, 0.36995104f, 0.06776227f, 0.11594928f, 0.12995273f, -0.19799291f, 
    -0.07150532f, 0.04162516f, 0.46103194f, 0.01532781f, 0.35780200f, -0.08922777f, 0.12125890f, -0.06188269f, 
    0.01842808f, -0.06805924f, 0.09788624f, 0.17175469f, -0.18527408f, 0.21900043f, 0.20755713f, -0.07711386f, 
    0.03616631f, -0.19136426f, 0.02236896f, -0.14950971f, -0.32543981f, -0.00537508f, 0.05136818f, -0.01889772f, 
    0.00150708f, 0.18613732f, -0.00879131f, 0.06806094f, -0.21525097f, 0.00482288f, -0.19522911f, 0.19513777f, 
    0.00417416f, 0.11983443f, 0.10132815f, -0.09777249f, 0.15834641f, 0.32496569f, 0.01002019f, -0.14326377f, 
    0.08470873f, 0.13445292f, -0.02942167f, -0.02010246f, 0.11740933f, 0.04606890f, -0.03855264f, 0.21485712f, 
    0.03010397f, -0.16838060f, 0.09296414f, 0.42956325f, 0.06018827f, -0.09935761f, 0.00482911f, -0.11834579f, 
    0.09363280f, 0.37267882f, -0.55137348f, 0.04591394f, -0.00256248f, -0.16858461f, -0.02734340f, 0.12027140f, 
    -0.16197570f, -0.01231309f, 0.20807834f, -0.01981350f, 0.14684168f, -0.09438324f, -0.11729115f, 0.03857668f, 
    0.11582435f, 0.02601991f, -0.28258008f, 0.04878389f, -0.06000532f, 0.08022333f, 0.21177875f, -0.02341776f, 
    0.08217386f, -0.01168001f, -0.18827134f, 0.16903557f, -0.16968971f, 0.07494967f, 0.06459279f, -0.18450680f, 
    0.17000468f, -0.01624054f, -0.17788604f, 0.04420421f, -0.18270390f, -0.38712734f, 0.02279914f, 0.02829556f, 
    -0.14511459f, -0.02385160f, 0.07026023f, 0.02011339f, 0.01847214f, 0.07685329f, 0.53899181f, 0.04992849f, 
    -0.13754018f, -0.32573229f, 0.01125011f, -0.03040078f, -0.00099229f, -0.01084312f, -0.28180471f, 0.32804722f, 
    -0.40917978f, -0.17671029f, 0.10248485f, 0.08970660f, -0.09485745f, -0.04295788f, -0.00255927f, 0.18478505f, 
    -0.07125116f, -0.10383081f, -0.00394567f, 0.00071959f, 0.04498960f, 0.08848853f, -0.03681321f, -0.00883051f, 
    -0.02495145f, -0.20694239f, 0.01872546f, -0.02118657f, 0.11435138f, 0.09384178f, -0.13029455f, -0.07331516f, 
    0.02386467f, -0.09000826f, 0.05751470f, 0.02349859f, -0.02553675f, 0.01888302f, 0.19461101f, -0.29890010f, 
    -0.06989133f, 0.33613667f, 0.18512063f, -0.20275906f, 0.07741515f, -0.29886180f, 0.08619238f, -0.35156855f, 
    0.09226209f, -0.16664882f, -0.06336051f, 0.26687333f, 0.08040762f, -0.13019638f, 0.01608136f, 0.15802753f, 
    -0.10543260f, 0.08124460f, -0.08149809f, -0.07124685f, -0.31104001f, -0.01089654f, -0.22213119f, -0.03314561f, 
    0.04386836f, -0.18771735f, -0.12224894f, -0.01313664f, -0.15629008f, 0.14275089f, -0.11260737f, 0.09475469f, 
    0.04225229f, 0.08168090f, 0.17722119f, -0.09045844f, -0.07487512f, -0.12273718f, 0.08617775f, -0.02772006f, 
    -0.48561534f, 0.06384902f, 0.06281297f, -0.02980413f, 0.05665833f, 0.00303844f, 0.14200266f, 0.19859299f, 
    0.09538715f, 0.14285164f, 0.19877557f, -0.03188239f, 0.06345468f, -0.01899457f, 0.19394191f, -0.08130600f, 
    0.72420090f, 0.12076075f, -0.61397481f, 0.22745197f, 0.19685382f, -0.15747592f, -0.02263120f, -0.08783349f, 
    -0.18288383f, 0.46662807f, 0.29042071f, -0.06718452f, -0.05530921f, 0.01975664f, -0.08412243f, 0.10338479f, 
    -0.08810046f, -0.08178324f, 0.17517050f, -0.05840602f, 0.07876847f, 0.20501058f, -0.08777298f, -0.23771732f, 
    0.07042442f, -0.07322625f, 0.12183779f, -0.06832687f, 0.02384776f, 0.17106903f, 0.08351888f, -0.00500502f, 
    0.22993131f, -0.21403019f, 0.10250056f, -0.41050881f, -0.25558722f, -0.41075835f, 0.19974081f, -0.00576081f, 
    0.03457135f, 0.37677217f, -0.13616519f, 0.01661824f, -0.13925554f, 0.62731427f, 0.01237488f, 0.24798919f, 
    0.08393671f, 0.01673246f, 0.07791234f, 0.24310464f, 0.04289260f, -0.00717301f, -0.06635071f, -0.16692023f, 
    -0.07847019f, -0.02037181f, 0.06510674f, 0.30764145f, -0.05971620f, 0.06790528f, 0.07276253f, 0.03763774f, 
    -0.13327931f, 0.16657619f, -0.07317844f, 0.04450130f, -0.02052752f, 0.00997333f, -0.00841016f, -0.00466979f, 
    -0.19186866f, -0.17879412f, 0.21053275f, -0.26831463f, 0.04202140f, 0.20441188f, -0.00075584f, -0.07015932f, 
    -0.17575014f, 0.13413182f, -0.22090136f, 0.29748580f, 0.03377280f, -0.19056699f, -0.38658297f, -0.12221351f, 
    -0.18776022f, 0.03840993f, 0.01955500f, 0.17490292f, 0.14264178f, -0.18533921f, 0.02891217f, 0.12786064f, 
    0.06377718f, -0.03663803f, 0.12430924f, -0.36252609f, 0.35736972f, 0.49315104f, 0.05634492f, -0.12183081f, 
    -0.15221941f, -0.11560568f, 0.12913865f, 0.06609620f, 0.09011105f, 0.05029396f, 0.06346010f, 0.08179843f, 
    0.04687554f, 0.10033134f, 0.09281085f, 0.33611661f, 0.09056669f, 0.14191642f, 0.09439429f, 0.10887589f, 
    0.02816234f, 0.17714275f, -0.35610420f, -0.16805126f, 0.07406429f, 0.20215890f, -0.16767319f, -0.13941079f, 
    0.09535622f, -0.05564824f, -0.04853956f, -0.01407896f, -0.00350640f, 0.03503219f, 0.02838231f, -0.06176065f, 
    0.23825543f, -0.03025602f, 0.22381820f, 0.22595875f, -0.09499735f, 0.18684125f, 0.21304385f, -0.16249451f, 
    -0.01885231f, -0.02300050f, -0.75805902f, 0.10027973f, 0.12069052f, -0.16767441f, 0.06238294f, -0.14582206f, 
    0.03270884f, -0.15333107f, -0.09429964f, -0.22116268f, 0.23373948f, 0.00343814f, 0.02158535f, 0.17796637f, 
    0.04443228f, 0.16804445f, -0.36718222f, -0.10629561f, 0.10141435f, 0.45957735f, 0.08074811f, -0.02292698f, 
    0.07855032f, -0.18595695f, 0.13672417f, 0.21803293f, -0.07574344f, 0.23862496f, -0.11558852f, -0.07279956f, 
    0.04116781f, 0.13694116f, -0.02079459f, 0.31537476f, 0.34329203f, 0.01898975f, -0.07179936f, -0.04009554f, 
    0.07295800f, -0.02896276f, -0.19140832f, -0.14350581f, -0.18840162f, 0.06341297f, -0.03453812f, -0.28159133f, 
    0.11023028f, 0.01801929f, -0.09622400f, 0.02382945f, 0.06796624f, -0.02872086f, -0.14410117f, -0.60484564f, 
    -0.43488628f, 0.10904499f, -0.10394242f, 0.15017413f, 0.20529243f, -0.17280161f, 0.08058326f, 0.17830361f, 
    0.31222421f, -0.14516485f, 0.05740044f, -0.11840153f, -0.11913893f, 0.06271150f, -0.05879460f, 0.01010249f, 
    -0.39333165f, -0.20898135f, 0.05197163f, 0.08921555f, 0.06309398f, -0.07768171f, -0.14841133f, 0.06772113f, 
    0.05319786f, -0.15751761f, -0.04703334f, 0.09045070f, -0.01642923f, 0.14991640f, -0.12168141f, 0.04617162f, 
    -0.00295843f, 0.02329393f, 0.10372396f, 0.20396487f, -0.50369692f, 0.04499599f, 0.08341620f, 0.07972319f, 
    -0.00856633f, -0.10304514f, 0.02358952f, -0.21173203f, -0.03020512f, -0.23401475f, -0.08053339f, 0.20721756f, 
    -0.11130685f, 0.04597706f, -0.18790071f, -0.15580495f, -0.27822414f, -0.30389115f, 0.07193739f, 0.02685747f, 
    0.01705298f, -0.07569294f, -0.14798458f, 0.21461245f, -0.04736652f, -0.02270759f, -0.30110493f, 0.17212828f, 
    -0.06770859f, 0.38995495f, -0.08809520f, -0.14803346f, 0.08089854f, -0.11824246f, -0.32050851f, -0.03297748f, 
    -0.16717836f, -0.11067142f, 0.04734773f, 0.15692391f, -0.01804470f, 0.01404472f, -0.00208777f, 0.41430247f, 
    -0.01481711f, 0.21221523f, 0.15485847f, 0.07018366f, 0.19889899f, 0.11939587f, -0.06936827f, 0.21107699f, 
    0.36189124f, 0.16806774f, -0.26649275f, -0.03360197f, -0.12769733f, 0.04052350f, 0.06558914f, -0.13890043f, 
    -0.19210759f, 0.27674037f, 0.22929801f, 0.03267630f, 0.11451060f, 0.02979564f, 0.03911811f, 0.00265126f, 
    -0.09444396f, -0.15303114f, 0.30299032f, 0.16603437f, 0.24085183f, 0.10586187f, 0.15038767f, -0.08471327f, 
    0.20376085f, -0.01154140f, 0.26222256f, -0.50981581f, -0.36894032f, -0.09037342f, -0.00349806f, -0.07833482f, 
    -0.14951360f, 0.06311300f, 0.09425474f, -0.16649011f, -0.43141964f, -0.38949665f, -0.01310549f, -0.07222564f, 
    0.08815017f, 0.06300780f, 0.13837948f, 0.06030761f, 0.19956055f, 0.22368895f, -0.12810399f, 0.04031157f, 
    -0.00614874f, 0.16717426f, -0.02661227f, -0.20201094f, -0.12905198f, 0.04381169f, -0.01744072f, 0.09161440f, 
    -0.21425812f, 0.04932409f, -0.11077341f, -0.14455956f, 0.11394863f, -0.06853371f, 0.04128462f, -0.05558079f, 
    0.07272016f, 0.49110997f, 0.16416183f, -0.05710445f, -0.08257690f, 0.07588092f, -0.07285593f, 0.01770031f, 
    0.44484001f, -0.20001034f, -0.19601589f, 0.16534592f, 0.15007289f, 0.02400883f, 0.00153314f, -0.02002804f, 
    -0.10455177f, -0.25850743f, 0.41582114f, -0.03030833f, 0.01857189f, -0.03137235f, -0.13606061f, 0.26143068f, 
    0.01238164f, 0.05276331f, 0.30489585f, -0.40024054f, 0.02805614f, 0.13206822f, 0.17701535f, -0.12012453f, 
    -0.04585348f, 0.00897926f, 0.12369692f, 0.11310562f, 0.29911253f, 0.17008018f, 0.11237955f, -0.01895586f, 
    0.00919668f, -0.03300005f, -0.03277086f, 0.07402718f, 0.14245169f, 0.06065208f, -0.32118911f, -0.24193086f, 
    0.12276912f, -0.06662826f, 0.12366952f, 0.03811335f, -0.25745273f, -0.25418687f, -0.04205015f, -0.10777389f, 
    -0.01951462f, -0.08622751f, 0.06967764f, 0.24021041f, 0.27910215f, 0.00825803f, -0.43684152f, -0.32732096f, 
    0.00420307f, 0.11806335f, 0.12321363f, 0.03814619f, 0.06499204f, 0.01048895f, -0.06062930f, 0.08190762f, 
    0.14466308f, 0.10736442f, 0.05947651f, -0.12956735f, 0.07736039f, 0.13826606f, 0.03625278f, -0.00702300f, 
    -0.16274594f, -0.16885772f, -0.20961820f, -0.15162274f, -0.20248802f, 0.24570772f, -0.11357707f, -0.08374192f, 
    0.00602915f, 0.05784664f, 0.19632193f, 0.12316196f, -0.09482878f, -0.28807497f, -0.13863622f, 0.07511615f, 
    0.03271802f, 0.09376819f, 0.04934094f, 0.05453439f, -0.02003276f, 0.22320318f, -0.39488116f, -0.04959852f, 
    0.05064807f, 0.06855968f, 0.21956255f, -0.37434003f, 0.29350680f, 0.10521059f, 0.10859270f, 0.03029683f, 
    -0.10124663f, -0.02687288f, -0.04434172f, 0.08890872f, 0.24353908f, 0.25073582f, 0.11877075f, -0.00764863f, 
    -0.16832905f, -0.32196298f, -0.05728192f, 0.09904794f, -0.12750225f, -0.03273052f, -0.26306602f, 0.20649354f, 
    -0.10175268f, -0.09983882f, 0.01743112f, -0.18932839f, -0.03697166f, -0.01755637f, -0.48095655f, -0.50414157f, 
    -0.30436739f, 0.22565588f, 0.17516564f, 0.28217223f, -0.10391343f, -0.12495789f, 0.22015233f, 0.24746181f, 
    -0.60933757f, -0.05862970f, -0.04333571f, -0.05428489f, -0.06152778f, -0.00042192f, -0.08465553f, 0.10184299f, 
    -0.13372685f, 0.11231564f, -0.03506793f, -0.02655259f, 0.15926781f, -0.04685802f, -0.05885751f, -0.21944469f, 
    -0.05740464f, 0.36173967f, 0.18717086f, 0.21839328f, 0.01641030f, 0.28260294f, -0.12217008f, 0.13848244f, 
    0.06026781f, 0.01647038f, -0.06497907f, -0.58717483f, 0.12337449f, 0.29671305f, -0.11143693f, 0.10109634f, 
    0.33879501f, -0.04322167f, 0.05495624f, 0.06490252f, 0.31079030f, -0.13806339f, 0.15889518f, 0.05659819f, 
    -0.14328790f, 0.11729181f, 0.23841579f, 0.14729488f, -0.18724959f, -0.31022954f, -0.08761390f, 0.16667984f, 
    -0.00986828f, -0.08318401f, -0.07819386f, 0.19812439f, 0.15340424f, 0.04814212f, 0.03334929f, 0.12140691f, 
    0.04425742f, -0.06600715f, -0.15092365f, -0.26300120f, 0.10036089f, -0.35905123f, -0.16029681f, 0.09481312f, 
    -0.22421919f, 0.26938009f, -0.25690109f, 0.27806982f, -0.16929610f, 0.05228350f, -0.33612639f, 0.13014835f, 
    0.02399590f, -0.12937851f, 0.13127506f, -0.06651303f, -0.10769249f, -0.05232661f, 0.16892588f, 0.24306418f, 
    0.15499631f, 0.21796601f, -0.24383299f, -0.00309341f, 0.12961227f, 0.43468130f, 0.06569013f, -0.11088511f, 
    0.08948742f, 0.60868573f, 0.15509376f, -0.03443166f, -0.10281846f, 0.02398914f, 0.19908921f, 0.01621061f, 
    -0.00546231f, 0.02726729f, 0.18064083f, 0.28941026f, 0.05820133f, 0.21307996f, 0.06726725f, 0.12301137f, 
    -0.08598384f, -0.00896818f, 0.30270845f, -0.30020833f, 0.12266012f, 0.16796431f, -0.00224122f, 0.15260024f, 
    -0.06214880f, 0.21139951f, 0.03172695f, 0.12924990f, -0.21901105f, -0.24585466f, -0.14006302f, 0.01391429f, 
    -0.04059203f, -0.09808147f, -0.04156991f, -0.16317229f, -0.13171212f, 0.34152621f, -0.17750390f, -0.16256502f, 
    0.12348150f, -0.07794312f, -0.08726678f, -0.09090367f, 0.02747357f, -0.05272624f, 0.34791425f, 0.02171216f, 
    -0.17262597f, -0.03747572f, -0.09297590f, 0.07237753f, -0.02295417f, -0.15955040f, -0.03842584f, 0.06482903f, 
    0.08682864f, -0.06584081f, 0.09740321f, -0.04274404f, -0.18888915f, 0.05864378f, -0.15515746f, -0.02032212f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.07044945f, 0.17076495f, 0.22580963f, -0.13072382f, -0.01428094f, -0.04229905f, 0.22667630f, 0.20494272f, 
    -0.10068201f, 0.24478863f, 0.13457856f, -0.04178191f, 0.16507380f, 0.05344143f, 0.13355945f, 0.03789711f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05076930f, 0.02761804f, -0.28643185f, 0.00577563f, 0.02182707f, -0.03134878f, 0.00467831f, -0.20129701f, 
    -0.21735242f, 0.17150876f, 0.02739613f, -0.08137753f, -0.24401103f, 0.10819814f, -0.27911890f, -0.01003439f, 
    -0.17872719f, 0.04867482f, 0.48515952f, 0.05793597f, -0.19499905f, 0.53313118f, -0.19390205f, -0.26593870f, 
    -0.12977438f, -0.01107482f, 0.10135075f, -0.02165241f, -0.06140335f, 0.21988802f, 0.36649942f, -0.17326415f, 
    -0.18874739f, -0.00704547f, 0.21872474f, 0.18929844f, 0.17204662f, -0.23562093f, -0.00811589f, -0.15436415f, 
    0.17793833f, 0.12894490f, -0.13098453f, -0.23788160f, -0.14163080f, 0.17600980f, -0.08000426f, 0.12719789f, 
    0.50107205f, 0.72041011f, -0.07897557f, 0.84612232f, -0.22163428f, -0.31349769f, -0.09080998f, -0.04435883f, 
    -0.12629737f, 0.35695994f, 0.27545571f, -0.09693960f, 0.37178093f, -0.48046234f, -0.10373112f, 0.13185258f, 
    -0.16084629f, -0.36418590f, -0.49233466f, 0.32906881f, -0.17004648f, 0.03927123f, 0.28348187f, -0.49799672f, 
    -0.18933564f, -0.89448225f, -0.02544741f, 0.27000797f, -0.16446236f, -0.41181749f, 0.46324754f, 0.26628318f, 
    0.02507654f, 0.00426447f, -0.22598431f, 0.96555883f, 0.22495542f, -0.04483622f, 0.19075094f, 0.10635041f, 
    -0.08362252f, 0.62987721f, 0.22439435f, -0.00678876f, 0.22346205f, 0.62780619f, 0.03380954f, -0.35467875f, 
    -0.31673071f, 0.71777242f, 0.14754187f, -0.53271914f, 0.17597890f, 0.24689549f, -0.13871509f, -0.62999398f, 
    0.06163095f, 0.49698767f, 0.53085536f, 0.19560440f, 0.13682653f, 0.23359026f, -0.47257286f, -0.07231721f, 
    -0.39365867f, 0.24619034f, 0.20217118f, 0.45221230f, 0.10390854f, 0.02230721f, -0.28329581f, -0.36222529f, 
    0.00426266f, 0.21571288f, 0.08326747f, -0.32255870f, 0.72445935f, -0.24710752f, 0.75242114f, 0.34381193f, 
    0.07799077f, -0.03714818f, -0.19028413f, 0.02504387f, -0.17174140f, -0.17535540f, -0.24126306f, -0.17850712f, 
    0.23905882f, -0.23364055f, 0.15214559f, -0.02950963f, -0.08926177f, 0.13065368f, -0.13981783f, -0.09417036f, 
    -0.30685604f, -0.19796127f, 0.55632871f, 0.03580597f, 0.05929753f, 0.29543191f, 0.65902543f, 0.44220069f, 
    -0.07064418f, -0.92801183f, 0.08834336f, -0.28616479f, -0.12329511f, 0.06395569f, -0.76843125f, 0.23188385f, 
    -0.11975829f, -0.46539852f, -0.53434640f, 0.27279231f, 0.16177385f, 0.42141441f, 0.51945186f, 0.01473719f, 
    -0.21853322f, 0.13201858f, 0.65716892f, -0.23393600f, 0.26468790f, -0.40281710f, -0.56236470f, -0.19238940f, 
    -0.04124925f, -0.01991546f, -0.04620147f, -0.11709035f, 0.19755927f, -0.07540464f, 0.08464238f, -0.08124575f, 
    -0.21275234f, 0.14645195f, 0.04280044f, -0.18985467f, -0.13463566f, -0.17039275f, -0.20068908f, -0.12204294f, 
    0.43571874f, -0.27883917f, -0.42446986f, -0.30764306f, 0.12777707f, -0.20807230f, 0.03108193f, 0.10301064f, 
    0.04900350f, 0.79540986f, -0.12519416f, 0.46831304f, 0.05596302f, -0.43034756f, -0.53219879f, 0.53063732f, 
    0.74997002f, 0.37748638f, 0.02876841f, 0.44971320f, 0.01422420f, 0.40230089f, 0.25363320f, -0.01518917f, 
    -0.12087016f, 0.22256631f, 0.04414947f, -0.28620395f, -0.04665928f, -0.56977373f, -0.02248014f, -0.44896570f, 
    0.37543771f, 0.40853232f, 0.46777692f, 0.15002824f, -0.04954863f, 0.47650972f, -0.46099705f, -0.16336928f, 
    -0.16757610f, 0.47204185f, -0.26705635f, 0.36715037f, -0.09208502f, 0.40975043f, 0.56367111f, -0.23625392f, 
    -0.32658958f, -0.02621306f, 0.32767102f, 0.48622432f, 0.14379030f, -0.04982416f, 0.14439201f, -0.00745438f, 
    -0.19910507f, -0.01922262f, -0.78594619f, -0.23793359f, 0.38803515f, 0.19917585f, 0.18872075f, 0.39377823f, 
    -0.07094582f, 0.02681956f, -0.46187106f, -0.18969892f, 0.09976075f, -0.11869317f, 0.21422566f, 0.47654808f, 
    0.11193969f, -0.11162913f, 1.09467828f, 0.29109955f, 0.15681674f, 0.17009233f, -0.39597037f, -0.20612237f, 
    -0.47862741f, -0.31089145f, 0.03127600f, -0.01663151f, -0.02586076f, -0.03310038f, 0.26685467f, 0.30852899f, 
    -0.10673890f, 0.66340017f, -0.20273314f, 0.51276118f, -0.38970011f, 0.58489823f, 0.41575336f, 0.15537828f, 
    -0.24298713f, -0.28136712f, 0.05742343f, -0.17331322f, 0.10481325f, -0.23024631f, 0.48099792f, -0.03137824f, 
    0.23916690f, -0.53450608f, 0.57139105f, 0.40949339f, 0.22667900f, 0.63390934f, -0.56579489f, 0.11858955f, 
    -0.23862639f, 0.07004540f, 0.12353183f, -0.07262030f, 0.09675366f, -0.11610729f, 0.06308611f, -0.06665742f, 
    0.09773403f, -0.04000264f, 0.11655111f, -0.26060671f, 0.08835319f, -0.29258054f, -0.06318898f, -0.16014124f, 
    -0.30212519f, 0.07902376f, 0.01572781f, -0.66881084f, -0.25468516f, 0.15234730f, 0.08798298f, 0.43111226f, 
    0.12607339f, 0.03424653f, -0.60662842f, 0.14480035f, 0.07984550f, -0.09394073f, 0.50314623f, 0.38781327f, 
    -0.13705981f, 0.41869241f, 0.27094489f, 0.40865329f, 0.22707908f, 0.03339357f, 0.18202144f, -0.92804050f, 
    -0.13237968f, 0.20961697f, 0.52213842f, -0.01824659f, -0.04541799f, 0.38579008f, -0.38038510f, -0.02697097f, 
    0.10051914f, 0.38857391f, 0.22904888f, -0.22956462f, -0.00183611f, -0.33890831f, 0.02199914f, 0.65850085f, 
    -0.09662001f, -0.86484522f, 0.36536786f, 0.29433903f, 0.27100328f, 0.00390356f, 0.26543117f, 0.30097625f, 
    -0.19966140f, -0.02653012f, -0.05198073f, -0.23134428f, 0.12210518f, -0.04302219f, -0.22508511f, 0.20142010f, 
    0.02118990f, 0.00244564f, -0.09793285f, -0.09486401f, -0.05717149f, 0.06753924f, -0.00655025f, -0.15853971f, 
    -0.35335314f, 0.23001435f, 0.38922915f, 0.15653764f, -0.16661917f, -0.20383106f, 0.22755294f, 0.22677867f, 
    0.10542805f, -0.35510355f, -0.51390141f, 0.30382916f, 0.20594423f, 0.76340473f, -0.14729477f, 0.24844351f, 
    -0.20934939f, -0.11902346f, 0.22350647f, -0.69041198f, -0.15006177f, -0.15299404f, 0.21088338f, -0.38984135f, 
    0.01272420f, -0.45822516f, -0.12764587f, 0.44961864f, 0.36261714f, 0.32391974f, -0.43190205f, 0.50485587f, 
    0.52922499f, 0.02662781f, 0.25099894f, 0.07850573f, -0.00725698f, -0.19543234f, -0.59205341f, 0.15883465f, 
    -0.04617009f, 0.04606771f, -0.42553511f, -0.09228534f, -0.06418454f, 0.22765216f, 0.04148857f, 0.17822553f, 
    -0.58024246f, 0.30770665f, -0.18875314f, 0.06165089f, -0.05800149f, -0.13526565f, 0.16321604f, -0.24183583f, 
    -0.12002163f, 0.57983953f, -0.10323601f, 0.02201224f, 0.37483221f, 0.36686593f, 0.14516374f, 0.50240648f, 
    0.04901199f, -0.23204486f, 0.18001373f, -0.02402891f, 0.02993527f, -0.20147574f, 0.17751688f, -0.24472091f, 
    0.04901003f, -0.20948754f, 0.19909494f, -0.25769377f, -0.10929086f, -0.03493083f, 0.12933120f, -0.19201373f, 
    0.34497586f, -0.28499725f, 0.54186833f, -0.15606831f, 0.14143127f, 0.41827002f, 0.26281881f, -0.72152960f, 
    -0.21189503f, 0.26412535f, -0.03096937f, 0.23430248f, -0.42181069f, -0.40022093f, -0.65299177f, 0.23919129f, 
    0.55878139f, 0.60855234f, 0.12007426f, 0.27340144f, -0.07855458f, 0.02348002f, -0.67518586f, 0.23403482f, 
    0.02322726f, -0.22740972f, -0.14570647f, 0.32127342f, 0.32430580f, -0.54328328f, 0.65146667f, 0.29667214f, 
    -0.39438933f, 0.16347243f, -0.45025694f, -0.71579474f, 0.19492927f, -0.04503708f, 0.26379874f, 0.19076873f, 
    0.12748083f, -0.42698374f, 0.39776725f, 0.20079434f, 0.33897871f, -0.44827420f, 0.87635070f, 0.29254547f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25142074f, -0.09230867f, 0.16530436f, 0.38252312f, -0.26619747f, -0.16739324f, 0.07410447f, 0.13135543f, 
    -0.04020962f, 0.25153255f, 0.04048921f, -0.21789651f, 0.28722048f, 0.64308316f, -0.06437829f, -0.14117427f, 
    0.25283352f, 0.39900163f, -0.09806775f, 0.13380934f, 0.47960857f, 0.10036582f, -0.08033278f, -0.02085483f, 
    0.31585845f, 0.12409957f, 0.00015771f, 0.05833652f, 0.09938329f, 0.20149173f, -0.49757361f, 0.39893547f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03139130f, -0.00034772f, 0.08595461f, 0.25282353f, 0.07963610f, 0.05818284f, -0.08469071f, -0.11097778f, 
    -0.05850906f, -0.54582137f, 0.18420880f, -0.13790394f, 0.42946976f, 0.51572609f, 0.23568451f, -0.17776476f, 
    -0.29370672f, 0.15327476f, -1.02399409f, 0.04466769f, 0.15520938f, -0.34575599f, -0.63681686f, 0.00459734f, 
    -0.72578645f, -0.41522682f, -0.00880538f, -0.22896987f, 0.09898957f, 0.20813650f, -0.06968660f, 0.15007144f, 
    0.02074282f, 0.45183468f, -0.03680052f, -0.44817090f, 0.06693806f, -0.25187898f, -0.09756640f, 0.34934294f, 
    -0.06663408f, -0.15797493f, -0.21626411f, 0.01984151f, -0.42298588f, -0.12354208f, 0.47493288f, 0.04946745f, 
    -0.20742725f, 0.37060362f, -0.89289868f, 0.16860415f, 0.27866927f, -0.57153004f, 0.04595758f, 0.08489570f, 
    -0.16227813f, -0.16987050f, 0.51381391f, 0.00717520f, -0.08411533f, -0.32298335f, 0.23532563f, 0.38929892f, 
    -0.05936006f, -0.57703280f, -0.06054465f, 0.34808242f, -2.03924274f, -0.14929847f, 0.02472619f, -1.11342967f, 
    0.16332188f, -0.16401894f, -0.37223935f, 0.03293380f, 0.35493147f, -0.06308268f, -0.04030788f, -0.50068396f, 
    0.52119464f, -0.12957519f, 0.02628464f, -0.15225703f, -0.01316360f, -1.12937224f, 0.65012598f, 0.09189027f, 
    0.01771178f, 0.05661706f, -0.10406952f, -0.53613615f, 0.01370905f, -0.68103558f, 0.36105776f, 0.04193991f, 
    0.04183389f, 0.17434537f, -0.09942547f, -0.98626709f, -0.06674303f, -0.08367293f, -0.02338323f, -0.37558734f, 
    -0.05429587f, 0.52136236f, 0.52574849f, 0.05699734f, -0.28083912f, -0.05704573f, -0.59185159f, -0.32750425f, 
    0.46223879f, 0.11313938f, 0.29946777f, 0.03873673f, 0.06802447f, 0.12237430f, -0.31451890f, -0.14685485f, 
    -0.23631182f, -0.16627119f, -0.03139019f, -0.22532347f, -0.13657863f, 0.08138068f, -1.13381124f, 0.01664682f, 
    -0.13127859f, 0.24425250f, 0.15443891f, 0.17795213f, -0.63940632f, -0.47690141f, 0.26584616f, 0.16235787f, 
    -0.06419437f, 0.21680063f, -0.03645310f, 0.16255160f, -0.65583456f, 0.28283176f, 0.01076768f, -0.33553424f, 
    0.11859462f, -0.76446187f, -0.13498598f, -0.09339210f, -0.19603568f, 0.25470519f, 0.11363567f, -0.02345430f, 
    -0.20772560f, -0.03086029f, 0.05132786f, -0.29124242f, -0.09190354f, 0.05565452f, -0.07338915f, 0.23451205f, 
    -0.13116960f, 0.06206787f, -0.11542753f, 0.14374363f, -0.68490738f, -0.32233053f, 0.13476686f, 0.08941929f, 
    0.04241494f, 0.08179104f, -0.52646106f, -0.02216654f, 0.07777296f, 0.08886415f, 0.20499772f, 0.31504902f, 
    -0.95963085f, -0.07566918f, -0.71024901f, 0.08408051f, 0.20880955f, 0.36451867f, -0.26103589f, 0.05984581f, 
    0.20963624f, 0.02353920f, -0.30963731f, 0.06225109f, 0.09422170f, 0.19454210f, -0.03164195f, -0.61919963f, 
    -0.06938967f, 0.33448100f, -0.05238418f, -0.75166368f, -0.44489864f, 0.13224572f, 0.35739562f, -0.73202133f, 
    0.08166070f, -0.26587597f, -0.50550795f, -0.11197351f, -0.26109436f, -0.15374351f, 0.44412068f, -0.03064733f, 
    -0.19431384f, 0.29527026f, 0.18107353f, -0.03963756f, -0.10633050f, 0.36371380f, -0.28101468f, -0.04206279f, 
    0.39938822f, 0.32075781f, -0.30786481f, -0.09253664f, -0.05517863f, 0.03362863f, -0.28093666f, -0.31533429f, 
    -0.07286943f, 0.21786465f, 0.01279315f, 0.29670185f, 0.45581135f, 0.24292138f, -0.69091082f, 0.21615098f, 
    0.17148629f, 0.29013953f, 0.24716026f, -0.00895067f, -0.31457520f, 0.38041088f, 0.01185388f, 0.15945494f, 
    -0.44954512f, -0.55478656f, -0.44029552f, -0.15561390f, -0.80116791f, 0.25064546f, -0.39790806f, 0.01357588f, 
    -0.55920553f, -0.96652186f, 0.16944401f, -0.90389466f, -0.00814024f, 0.33478397f, 0.16884682f, -0.98828453f, 
    -0.18947335f, -0.19424123f, -0.03656643f, 0.29371601f, -0.09415499f, 0.09144014f, 0.08994371f, 0.94715947f, 
    -0.05423579f, -0.74147487f, -0.10298424f, -0.13541935f, -0.25778043f, -0.47443128f, -0.26755771f, 0.70856142f, 
    -0.21161896f, -0.53243595f, -0.02118384f, -0.14067730f, 0.02542109f, -0.15754698f, 0.04836484f, 0.07862516f, 
    0.16315150f, 0.27561808f, -0.76602232f, 0.40502653f, -0.06818815f, -1.09949887f, 0.20963390f, 0.20390695f, 
    -0.20097978f, -0.03798084f, -0.11479876f, 0.48439652f, -0.39423752f, 0.27140269f, 0.47675228f, 0.14145805f, 
    -0.15918899f, -0.51682937f, 0.01866647f, -0.00876041f, 0.19031438f, -0.14253083f, -0.03861057f, -0.77455664f, 
    0.38021368f, -0.04945082f, -0.12190501f, -0.12289148f, -0.54272282f, 0.47355026f, -0.30149010f, -0.06016376f, 
    -0.46815166f, -0.19439234f, -0.47187641f, 0.26453409f, -0.14453577f, -0.06670294f, -0.09365138f, -0.20298445f, 
    -0.00394224f, -0.70461410f, -0.05733477f, 0.00138792f, 0.16451643f, 0.17866090f, -0.87142986f, -0.27209327f, 
    -0.11053853f, 0.42852163f, 0.05659458f, 0.06735829f, -0.00720839f, -0.05431765f, -1.04936206f, 0.28520367f, 
    0.19003074f, 0.36183760f, 0.48673424f, -0.04075391f, 0.03945498f, -0.30637655f, 0.08118980f, 0.16175467f, 
    0.48271200f, -0.15406160f, -0.85617912f, 0.18709646f, -0.07999256f, -0.38839889f, -0.84926373f, 0.07428139f, 
    -0.19738771f, -0.38211691f, -0.12264629f, -0.38243192f, 0.18132758f, -0.97941512f, -0.00715315f, -0.47263920f, 
    -0.08178640f, 0.02593938f, -0.12483489f, 0.03348526f, 0.52334702f, -0.44101489f, -0.51230788f, 0.12883438f, 
    0.01892825f, 0.16638561f, 0.22760443f, 0.02711824f, 0.13457319f, -0.32342920f, 0.07497159f, 0.14179234f, 
    -0.06458493f, 0.46408808f, -1.35515320f, 0.05115539f, 0.04038092f, 0.36790529f, -0.07469477f, 0.28713185f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.54095089f, 0.01813853f, -0.14956160f, -0.04811095f, 0.51765609f, 0.15534954f, -0.30560789f, -0.53895611f, 
    -0.68825978f, 0.06703562f, 0.27581531f, -0.31180909f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
