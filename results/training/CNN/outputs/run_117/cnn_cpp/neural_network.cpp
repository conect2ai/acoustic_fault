#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.11491263f, -0.19330283f, -0.23744303f, 0.32647571f, 0.71299374f, 0.17130105f, -0.04725233f, -0.22634482f, 
    -0.03346547f, 0.69389349f, -0.07125320f, 0.52213860f, 0.01203595f, 0.48817322f, 0.11495335f, -0.11732488f, 
    -0.15093419f, 0.36591065f, -0.16214712f, -0.15154952f, -0.15960081f, 0.38632512f, -0.72566158f, 0.61033469f, 
    0.59974951f, -0.08407130f, 0.40748119f, 0.88749105f, 0.43950772f, 0.78668565f, 0.38878947f, -0.46267188f, 
    0.12555209f, -0.42250615f, -0.48925337f, -0.53277600f, 0.38220868f, 0.39839995f, 0.23231864f, -0.97551781f, 
    -0.14019638f, -0.82820076f, -0.22155192f, 0.24000947f, -0.16109340f, 0.79309911f, 0.70002413f, 0.15453859f, 
    -0.36788324f, 0.32731718f, -0.16788663f, 0.65609163f, 0.23049314f, -0.09533190f, 0.23959021f, -0.56452578f, 
    0.36289570f, 0.54605246f, 0.47710556f, 0.61663908f, -0.46748346f, -0.11609327f, -0.16374965f, -0.88827121f, 
    0.75995988f, 0.05004429f, 0.31610605f, 0.33889309f, -0.48418924f, -0.02374451f, 0.06530409f, -0.15440680f, 
    -0.18998264f, -0.47981873f, -0.72168344f, -0.05505995f, 0.12657610f, 0.90830898f, -0.34920764f, 0.20789015f, 
    -0.19898802f, -0.65807045f, -0.73914230f, -0.52388382f, 0.10802841f, -0.49930590f, -0.24527933f, -0.35187817f, 
    0.25505278f, 0.38941154f, 0.23268399f, -0.05832870f, 0.42779773f, -0.59695035f, 0.26752636f, 0.89737302f, 
    0.01537887f, 0.04001185f, 0.51615703f, -0.07261854f, 0.51522446f, -0.39438567f, -0.42178094f, -0.89408118f, 
    -0.48530382f, 0.22147004f, 0.49820343f, 0.24353631f, 0.79896092f, 0.45866010f, -0.87710613f, 0.83111066f, 
    0.09075005f, -0.25873426f, 0.02552743f, 0.00874414f, -0.09198867f, -0.55055326f, -0.56859320f, -0.95450890f, 
    0.21548915f, 0.85565501f, 0.25891840f, 0.01220454f, -0.20616625f, -0.29610363f, 0.26744837f, -1.04909492f, 
    -0.61430544f, -0.89405578f, 0.08628045f, 0.20986941f, -0.01276150f, 0.09067499f, 0.33283567f, 0.73902583f, 
    0.70172638f, 0.36077514f, 0.20920847f, -0.01561881f, -0.10775081f, -0.13516913f, 0.57954788f, 0.37446922f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14577334f, 0.43660390f, -0.01748939f, 0.00383576f, 0.35563567f, -0.26217639f, 0.33721805f, 0.08430681f, 
    -0.33726183f, -0.16856734f, 0.28434807f, -0.09673168f, -0.11239713f, -0.12123726f, 0.05997600f, -0.13736053f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.09411054f, -0.25067621f, 0.08551534f, -0.14982831f, -0.07239021f, 0.02857580f, -0.02127635f, -0.04234143f, 
    -0.00104978f, 0.01303477f, -0.02168031f, -0.13387270f, -0.04699289f, 0.09101702f, -0.06551388f, 0.20768906f, 
    -0.07247229f, -0.13307598f, 0.20985427f, 0.28030640f, 0.01868258f, -0.24499424f, -0.00707965f, 0.17170320f, 
    0.02368565f, 0.11283568f, -0.00621803f, -0.10434449f, 0.05088955f, 0.08751135f, -0.01352823f, 0.06363262f, 
    -0.00736207f, -0.00569571f, 0.08204631f, -0.03218025f, -0.06319750f, -0.13758388f, -0.31296527f, 0.26289696f, 
    0.23213479f, -0.04418011f, 0.13173158f, 0.08238647f, -0.13880341f, 0.04745281f, 0.18174255f, -0.04170158f, 
    0.05895579f, -0.05104534f, 0.05680241f, 0.00616122f, -0.22216056f, -0.02748772f, 0.37682611f, 0.11247326f, 
    0.32025859f, 0.05679940f, 0.00287278f, 0.10605168f, 0.03812506f, 0.10900636f, 0.03281987f, -0.22173046f, 
    -0.14459553f, -0.67508811f, 0.14708900f, 0.07174484f, -0.09846625f, 0.07030926f, 0.03673255f, 0.07984185f, 
    -0.70690507f, 0.15060976f, 0.10712412f, -0.09914675f, -0.09246386f, 0.14801908f, 0.04136549f, 0.23455115f, 
    -0.23470420f, -0.49682096f, 0.04204877f, 0.07784306f, 0.02611845f, -0.27988076f, -0.04576479f, 0.10631726f, 
    0.14054660f, 0.23440084f, 0.42075831f, -0.14017428f, 0.21083809f, -0.01341541f, 0.01445570f, -0.02886031f, 
    -0.08198356f, 0.03153863f, 0.29055735f, -0.30022249f, -0.02377772f, -0.48618180f, 0.18374936f, 0.15738262f, 
    -0.01918568f, 0.07392024f, 0.20646298f, 0.06090419f, -0.12111792f, 0.21868080f, -0.35644743f, -0.06257620f, 
    -0.03045623f, -0.00556487f, -0.12118551f, 0.06726501f, 0.13311316f, 0.00826450f, 0.02008560f, 0.33985206f, 
    -0.16144978f, -0.05124970f, -0.04630872f, -0.10039777f, -0.01270521f, -0.01699048f, -0.27417636f, 0.51077640f, 
    0.00644950f, -0.06024069f, -0.10361464f, -0.04781842f, -0.16481730f, -0.08252676f, -0.06409515f, 0.04214298f, 
    0.08031335f, -0.12405119f, 0.04942621f, -0.09954960f, -0.12250075f, -0.12591508f, 0.07485157f, 0.03111914f, 
    -0.25351536f, 0.23623060f, -0.04624875f, 0.00405039f, 0.10147820f, -0.10983907f, 0.00447554f, -0.11115968f, 
    -0.06566375f, 0.00884298f, -0.11373466f, -0.11981253f, 0.15346552f, -0.10839418f, 0.00573198f, 0.07933195f, 
    0.08134251f, 0.19789645f, 0.00430068f, 0.24509722f, 0.06909837f, 0.10123827f, -0.29465622f, 0.04579421f, 
    0.24237972f, 0.02205964f, -0.16088963f, -0.01598892f, 0.11717314f, 0.07567687f, 0.05390444f, 0.07343873f, 
    -0.06730227f, -0.27414048f, 0.13768326f, -0.16696946f, 0.08587382f, 0.02622045f, -0.17572241f, -0.00134817f, 
    0.04204732f, 0.37633806f, -0.00991493f, -0.17260788f, -0.01358419f, 0.12164225f, -0.16726717f, 0.11291928f, 
    0.18389973f, -0.14973269f, -0.01855960f, -0.03104946f, 0.05364279f, 0.17235637f, 0.08304118f, 0.22374654f, 
    0.06622680f, -0.08701070f, 0.07355626f, -0.21042994f, -0.04901010f, 0.37531608f, 0.03855078f, -0.42010903f, 
    -0.09506966f, -0.19445415f, 0.00085723f, 0.01959750f, -0.02260871f, 0.06888229f, 0.06689741f, 0.15473400f, 
    -0.01225639f, 0.12439737f, -0.10081193f, 0.09548913f, -0.09763607f, -0.21451294f, 0.06690560f, 0.00936421f, 
    0.07709154f, 0.11211190f, 0.19718099f, -0.19820297f, 0.00783670f, 0.08310119f, 0.11038031f, 0.03190186f, 
    -0.00305403f, 0.04878531f, 0.04038671f, 0.29890633f, -0.03579931f, 0.05482396f, -0.14841597f, 0.05772089f, 
    0.08427431f, 0.13567153f, 0.11475292f, -0.07965323f, -0.27464753f, -0.23881908f, 0.21434663f, 0.10264812f, 
    0.29794100f, 0.01024710f, -0.19830190f, -0.04363433f, -0.04839955f, -0.58861542f, -0.38628691f, -0.05535588f, 
    0.03437966f, -0.03294798f, 0.18083388f, -0.24656272f, -0.15874499f, 0.28073239f, -0.05121434f, -0.26126122f, 
    -0.16406000f, -0.01850845f, -0.00219835f, 0.14892015f, -0.05208180f, -0.34618339f, -0.24060100f, -0.18511918f, 
    0.06921051f, 0.19132121f, 0.01604380f, 0.01225463f, 0.03179091f, -0.04670840f, 0.11968411f, -0.05587677f, 
    0.20591135f, 0.10632723f, 0.13885491f, 0.08655450f, -0.26839641f, 0.00361167f, -0.11121889f, 0.18216066f, 
    0.00414027f, 0.05887419f, 0.03793218f, -0.05966692f, 0.00762576f, -0.00230397f, -0.03787014f, 0.03346124f, 
    0.02366309f, -0.00050990f, -0.07190813f, -0.00973670f, -0.01781095f, 0.00998870f, -0.00044767f, 0.01626069f, 
    -0.04921001f, -0.07828220f, -0.03243052f, 0.02835434f, 0.07881744f, -0.01192930f, -0.04931196f, -0.00883605f, 
    0.05840946f, 0.06043142f, -0.02730798f, -0.07352748f, -0.02620634f, 0.02437956f, -0.02869783f, -0.02089546f, 
    -0.08211124f, -0.00583297f, 0.00273081f, 0.04092454f, 0.05699207f, -0.06340867f, -0.01219931f, -0.03335746f, 
    -0.02749349f, 0.01003769f, -0.03106100f, 0.01287474f, -0.00514360f, -0.01901770f, -0.04695919f, -0.04655595f, 
    -0.07717888f, -0.00944051f, -0.07961481f, 0.04243984f, -0.03946431f, 0.05597780f, 0.05704280f, 0.06468236f, 
    -0.03018135f, -0.03086401f, 0.06910570f, -0.05527590f, 0.03109075f, -0.03980837f, 0.05916771f, 0.05323385f, 
    0.02335485f, 0.01608053f, -0.05855664f, 0.06644624f, -0.06575085f, 0.00646727f, 0.00906761f, 0.01869869f, 
    0.05479320f, 0.03902994f, -0.06643477f, -0.05095853f, -0.05678707f, 0.03549423f, -0.06223077f, 0.07094198f, 
    -0.04717296f, -0.08059558f, 0.01575207f, 0.07724231f, 0.01764133f, 0.00373686f, 0.01317937f, 0.05555433f, 
    -0.05561181f, -0.01647215f, 0.06185571f, 0.03084128f, 0.02348258f, -0.01657773f, 0.01485094f, -0.02293764f, 
    0.01340458f, -0.03759032f, -0.04464763f, -0.03163473f, -0.06690881f, -0.02764320f, 0.06582087f, -0.08130311f, 
    0.00598598f, -0.04759759f, 0.02411887f, -0.04208156f, -0.03543282f, 0.03177844f, 0.00511639f, -0.02699019f, 
    -0.05179077f, -0.00015809f, -0.02102236f, -0.00156040f, 0.02436009f, -0.05881458f, -0.02072179f, 0.02321135f, 
    -0.04053503f, -0.04720315f, -0.08231241f, -0.04270801f, -0.03598683f, -0.00790417f, -0.07138032f, 0.06918028f, 
    -0.03568324f, -0.08035122f, -0.00525897f, -0.05522939f, -0.05618751f, -0.08059349f, -0.03461234f, 0.05254284f, 
    -0.03601629f, -0.05249071f, -0.01515373f, -0.01862833f, -0.04481402f, 0.06522347f, -0.06112622f, -0.08188515f, 
    -0.03496743f, 0.39490193f, 0.17488599f, -0.00339385f, 0.20389886f, 0.01727100f, -0.02791643f, 0.20185822f, 
    0.07640409f, -0.15828273f, -0.16451733f, 0.05487181f, -0.07685678f, 0.18255252f, -0.13774660f, 0.04054269f, 
    0.03781530f, -0.00319639f, -0.02849286f, 0.17828937f, -0.18153095f, -0.08504622f, -0.01609566f, 0.11921442f, 
    0.19949976f, -0.18890496f, 0.15397769f, 0.07510900f, -0.17313050f, -0.00576065f, 0.03703825f, 0.07508795f, 
    0.15952185f, -0.13684432f, 0.08415893f, 0.10240436f, 0.10654273f, -0.57135850f, 0.03978695f, 0.04000965f, 
    -0.02896594f, 0.03064267f, -0.27514872f, -0.27752134f, -0.09415820f, -0.33289242f, -0.57743531f, -0.04052014f, 
    0.14330722f, 0.00176232f, 0.00654574f, -0.01411516f, 0.01563315f, -0.01330333f, -0.17346594f, -0.21021160f, 
    -0.14968184f, 0.08425024f, 0.10863456f, -0.16902392f, 0.01316319f, -0.01337008f, -0.04672608f, 0.06687593f, 
    -0.04886653f, -0.17991783f, 0.03159297f, -0.11866189f, -0.03901035f, -0.23258209f, 0.08344845f, -0.11041691f, 
    0.19621117f, -0.14924119f, 0.39641115f, 0.25980598f, 0.13272616f, -0.09383015f, -0.05952264f, 0.23452453f, 
    -0.02668775f, 0.16233145f, 0.16665500f, 0.16889022f, -0.07458337f, -0.12563151f, 0.02325259f, -0.13997042f, 
    0.09319074f, -0.04098224f, -0.04435061f, -0.03851909f, 0.09643670f, -0.22750996f, 0.03400764f, 0.04458328f, 
    -0.01191993f, 0.07501976f, 0.22219862f, 0.15472914f, -0.37413305f, -0.06713428f, 0.09958043f, -0.02956228f, 
    0.08374173f, 0.02674475f, -0.00389461f, -0.04047665f, 0.11255184f, 0.31321657f, 0.22646475f, -0.21614082f, 
    0.13977610f, 0.02240860f, 0.00424176f, -0.00512924f, -0.01835672f, 0.30626255f, 0.38263297f, 0.18892440f, 
    -0.05455896f, -0.08307564f, -0.01407973f, 0.19819205f, 0.11119835f, 0.03512750f, 0.20864007f, 0.31387892f, 
    0.11192466f, 0.01987620f, -0.16547003f, -0.10360718f, -0.12969522f, 0.20729874f, -0.16111010f, -0.11229011f, 
    -0.13270916f, 0.06192301f, 0.15868931f, 0.03830400f, 0.10738493f, 0.12500092f, 0.08153007f, 0.09131212f, 
    0.44292262f, 0.17589188f, 0.19289993f, 0.02468706f, -0.04855546f, -0.02919517f, 0.01886135f, -0.02260315f, 
    -0.12348459f, -0.07413453f, -0.04116473f, 0.06264954f, -0.13189204f, 0.13668604f, 0.20835711f, 0.04878071f, 
    -0.02609825f, -0.00215063f, -0.11618459f, 0.10885494f, -0.04611315f, 0.00633221f, 0.26961464f, 0.07331046f, 
    -0.20385812f, 0.05104019f, -0.08074088f, -0.04329539f, -0.03315832f, 0.17665417f, -0.03247939f, 0.05477816f, 
    0.08663474f, -0.04805776f, 0.15556811f, 0.08344823f, 0.02572402f, 0.16408041f, -0.29889312f, 0.10724477f, 
    -0.00594148f, -0.04374320f, -0.01952490f, 0.03326426f, -0.08375008f, 0.42472219f, 0.22059339f, -0.18300931f, 
    -0.01191158f, -0.04578280f, 0.26860854f, -0.07397684f, -0.06432823f, -0.02270072f, 0.02116652f, 0.11985514f, 
    0.03006406f, 0.10093772f, -0.10802277f, -0.06112638f, 0.13989015f, 0.02711092f, 0.07301192f, 0.45736262f, 
    -0.21213262f, -0.00232155f, -0.18679711f, 0.12820363f, 0.01130747f, -0.00250013f, 0.14542365f, -0.03909501f, 
    0.02638121f, 0.10707794f, -0.18275079f, -0.06644049f, -0.10809753f, 0.03444965f, -0.13396300f, -0.09936107f, 
    0.08339284f, -0.45834115f, -0.33754542f, -0.19213495f, -0.15080579f, -0.02454179f, -0.07502430f, -0.03999178f, 
    0.02359092f, -0.04008926f, -0.15601915f, 0.05721131f, -0.48754588f, 0.09219798f, -0.05480712f, 0.01427533f, 
    0.01356134f, 0.00583835f, 0.02318658f, -0.40004981f, -0.12638602f, 0.06644020f, 0.08689433f, 0.10332187f, 
    -0.06712274f, 0.03098444f, 0.04966308f, 0.08070891f, 0.33159083f, -1.05257750f, 0.08244906f, -0.30176774f, 
    -0.08607655f, -0.09555463f, -0.12965043f, 0.11870044f, -0.10661063f, 0.12903872f, 0.31309474f, -0.40702242f, 
    -0.03305795f, 0.04357747f, -0.03116420f, 0.13070075f, 0.09081029f, 0.13738441f, 0.45003355f, -0.38454860f, 
    0.03856039f, -0.12236833f, 0.17431344f, 0.01157226f, 0.01813367f, 0.05501463f, -0.09668803f, -0.12041142f, 
    0.25601223f, 0.04198226f, -0.07280324f, -0.08925524f, -0.08883834f, -0.12207828f, -0.07440299f, -0.09181724f, 
    0.12169069f, -0.05353022f, -0.00725415f, 0.08136717f, 0.10236440f, 0.21377704f, 0.15899965f, -0.03667086f, 
    -0.05623765f, 0.08412359f, 0.16056265f, -0.03638677f, 0.02811977f, 0.44471660f, -0.00698124f, -0.07016387f, 
    -0.14621659f, 0.07918032f, -0.42994109f, -0.18732475f, -0.31338444f, 0.01033235f, -0.04869803f, -0.02060325f, 
    -0.00953699f, -0.08366171f, -0.04602623f, 0.09478521f, -0.00366067f, 0.22122772f, 0.01807852f, 0.07120001f, 
    -0.11775699f, 0.29029891f, 0.12722689f, -0.06233612f, 0.00577622f, -0.01257234f, 0.02619577f, -0.06079621f, 
    0.08775659f, 0.05823396f, 0.01986334f, 0.09681171f, 0.18341976f, -0.23797593f, 0.11209370f, -0.08692119f, 
    -0.07991466f, -0.02448680f, -0.02216906f, -0.13889948f, -0.13512875f, 0.04954517f, 0.31013682f, 0.11273503f, 
    -0.04331652f, -0.05837873f, -0.07538175f, 0.21015655f, 0.04155331f, 0.12801014f, -0.10382601f, 0.16747987f, 
    -0.24494676f, 0.31760240f, 0.09291328f, -0.10433748f, -0.06970777f, 0.10304324f, 0.07174352f, 0.08258504f, 
    -0.15174983f, -0.12596616f, -0.12760220f, 0.04640128f, 0.14755324f, 0.02173107f, -0.10872022f, -0.00298357f, 
    0.02830419f, -0.37834403f, -0.22078542f, -0.37506500f, 0.12431498f, 0.11081393f, -0.05933882f, 0.06358915f, 
    0.10419514f, 0.30697539f, -0.16959098f, 0.23899029f, -0.00805521f, 0.07255666f, -0.18048501f, 0.26529795f, 
    -0.05704385f, 0.04528802f, 0.05314462f, -0.04636956f, 0.06432806f, 0.11460751f, -0.43713176f, 0.07816937f, 
    -0.07809008f, -0.11412381f, 0.04519745f, 0.29955208f, -0.12678832f, -0.11398648f, 0.13663115f, 0.04675909f, 
    -0.07199772f, -0.01251882f, 0.20593193f, 0.08295566f, -0.05663876f, -0.10100277f, 0.04074045f, -0.46625659f, 
    0.28631854f, 0.12501305f, -0.14466839f, 0.04003844f, -0.16294818f, -0.11722557f, -0.37498412f, -0.25678295f, 
    -0.06904342f, -0.05530635f, 0.07923777f, -0.18278709f, -0.00390245f, -0.17450322f, -0.00629215f, 0.12999488f, 
    0.18202147f, -0.11165711f, 0.21014516f, 0.14386247f, 0.16807503f, -0.05664819f, 0.09100165f, -0.20640519f, 
    -0.08055656f, -0.03450220f, 0.04541453f, -0.01392470f, -0.08359355f, -0.01728645f, -0.01600615f, 0.05568964f, 
    0.06442536f, -0.07696071f, -0.04487947f, -0.02248650f, -0.02247616f, -0.02336772f, 0.01213815f, -0.03656317f, 
    -0.04442974f, -0.06882903f, 0.04430202f, 0.02763871f, 0.03930068f, 0.03120724f, -0.04981161f, 0.06935845f, 
    0.01565246f, -0.02602572f, -0.01569931f, -0.05006104f, -0.09098701f, 0.06329463f, -0.01912634f, 0.05570263f, 
    -0.09934377f, -0.03036491f, -0.06930271f, 0.05151276f, -0.07359952f, 0.04757621f, 0.01206500f, 0.00867763f, 
    -0.03214624f, 0.04674198f, 0.01823907f, -0.02906397f, -0.02073313f, -0.04720490f, -0.09214412f, -0.09614240f, 
    0.06552532f, -0.03328963f, 0.08041000f, 0.02403593f, 0.00222956f, 0.00386472f, -0.10062560f, -0.08306435f, 
    -0.00678432f, -0.05769264f, -0.00863533f, -0.07114372f, 0.02365515f, -0.07245502f, 0.02061800f, 0.03928345f, 
    -0.05129004f, -0.01356839f, 0.02008130f, -0.03646161f, -0.06773674f, 0.06328946f, -0.04467195f, -0.07961625f, 
    0.00421093f, 0.03205358f, -0.08484652f, -0.01124599f, -0.06207208f, -0.05661166f, -0.01888238f, -0.00965675f, 
    -0.00441732f, 0.00787848f, -0.05396222f, 0.06907110f, -0.08300217f, -0.02583105f, -0.01341067f, 0.00249376f, 
    -0.03592928f, 0.00883057f, 0.04801239f, 0.00300060f, 0.04053459f, -0.02730227f, 0.02468157f, 0.04101467f, 
    0.00557966f, -0.00741902f, -0.09272227f, -0.09065396f, 0.03324704f, 0.07028569f, 0.01309727f, -0.04278998f, 
    -0.09107015f, -0.06278103f, -0.01577769f, 0.03799665f, 0.01743504f, 0.03530143f, -0.02643330f, 0.00102395f, 
    -0.03351947f, -0.07624891f, -0.07964620f, 0.04276250f, -0.08389132f, -0.11543901f, -0.08214677f, 0.03959057f, 
    -0.08555692f, 0.04816613f, -0.05612834f, -0.02914649f, -0.01198669f, 0.04606427f, -0.06704234f, 0.07512696f, 
    -0.01911336f, -0.10424291f, -0.08611026f, 0.01550936f, 0.01310295f, -0.02537628f, -0.03793501f, 0.00609430f, 
    0.02445624f, -0.02295035f, 0.05581784f, 0.05489669f, -0.02723723f, -0.08398725f, 0.00898962f, -0.01961459f, 
    -0.02840309f, -0.06089173f, -0.04873223f, 0.01288052f, 0.00648178f, 0.02012587f, -0.00481856f, 0.03207444f, 
    0.01279605f, -0.05885248f, -0.01831563f, 0.03455265f, -0.08715298f, 0.01108862f, -0.08530284f, -0.06887539f, 
    0.04258805f, -0.03334963f, 0.00317445f, -0.02213347f, -0.01429683f, 0.05918675f, 0.02026100f, -0.07522343f, 
    0.00771527f, 0.04275428f, -0.06646264f, -0.01425888f, 0.02806948f, -0.03482739f, 0.03716588f, 0.04143813f, 
    -0.08392643f, 0.05019766f, -0.08427625f, 0.05860081f, -0.05568761f, 0.03028936f, 0.04477231f, -0.08479113f, 
    -0.01315116f, -0.02588716f, -0.04816553f, -0.04678888f, 0.01722240f, 0.06634690f, -0.07973757f, 0.01949153f, 
    0.06388001f, -0.05791710f, 0.00563855f, -0.04882264f, -0.01013871f, 0.03059350f, -0.01082822f, 0.02884090f, 
    -0.05596112f, 0.00269295f, -0.00360823f, -0.06427192f, -0.08161032f, 0.00648259f, 0.05695774f, -0.08357319f, 
    0.03234051f, 0.03779059f, 0.01615068f, 0.00423582f, -0.02215594f, -0.02861491f, 0.06094704f, -0.07188822f, 
    0.02052933f, 0.02657678f, 0.01113521f, -0.07505834f, -0.04141790f, -0.00424085f, -0.02698912f, -0.06555362f, 
    -0.06141480f, -0.07422805f, 0.04775676f, -0.03476791f, 0.03197047f, 0.06171090f, 0.00133383f, -0.00329133f, 
    0.04168323f, -0.03117882f, 0.05392987f, -0.08981525f, -0.07407141f, 0.05710529f, -0.08471501f, -0.00176292f, 
    0.06202585f, 0.01939685f, 0.05978352f, 0.01539026f, -0.04979157f, -0.01625963f, -0.06166497f, -0.07451650f, 
    0.04347688f, 0.02984638f, -0.00400329f, 0.04460790f, -0.03746067f, -0.01973234f, -0.00108011f, -0.01693841f, 
    -0.06750962f, -0.05208375f, -0.05890927f, 0.07367424f, -0.02276133f, -0.08283746f, 0.00123650f, 0.07509812f, 
    -0.00262849f, 0.04300164f, -0.05213002f, 0.06308721f, 0.05463146f, -0.07833369f, -0.04435886f, -0.04400380f, 
    -0.06709415f, -0.01342205f, -0.07496713f, -0.03073694f, -0.03446208f, -0.06893661f, 0.05978838f, 0.00859065f, 
    -0.03065008f, -0.05334239f, 0.06105954f, -0.07714606f, 0.06408773f, -0.07038747f, -0.05464435f, -0.07311434f, 
    -0.11650325f, -0.07738553f, -0.33300716f, -0.03329473f, 0.02672424f, -0.05550379f, -0.02156744f, 0.01332070f, 
    -0.03460889f, 0.18491812f, 0.20577854f, 0.04214716f, 0.12025268f, 0.10178818f, 0.22812170f, -0.07705504f, 
    0.16232575f, 0.20408516f, -0.08409003f, -0.06062211f, -0.53331095f, 0.18200611f, -0.10115419f, -0.08458249f, 
    -0.12495405f, -0.16817586f, -0.17253023f, -0.12562700f, 0.20457619f, 0.35776958f, 0.07078101f, 0.32585198f, 
    -0.05650495f, 0.19747971f, -0.07878043f, 0.04114053f, 0.10030920f, 0.10572254f, 0.26627535f, 0.02190758f, 
    0.24637955f, -0.07390727f, -0.13151002f, -0.07627333f, 0.07565210f, -0.29281539f, 0.09291553f, 0.11247697f, 
    -0.18820214f, -0.00548736f, -0.01822156f, 0.11235459f, -0.05824571f, -0.14432608f, -0.42025208f, 0.04657133f, 
    -0.08262259f, 0.15572600f, -0.10410294f, 0.03003851f, 0.16575396f, 0.19682163f, -0.12215668f, 0.19679742f, 
    0.37020981f, 0.17737149f, -0.05220533f, 0.14651297f, 0.02601930f, 0.07967442f, 0.06718308f, 0.12099180f, 
    -0.14615528f, -0.08423641f, -0.05128126f, -0.11943010f, 0.15930031f, -0.02912083f, 0.05189260f, -0.18012960f, 
    0.10681275f, -0.07580680f, 0.08320847f, 0.10748500f, 0.06946132f, 0.06056259f, 0.00187330f, 0.17230250f, 
    0.01255062f, 0.01048470f, -0.02202369f, -0.09687921f, 0.05017771f, 0.03819260f, 0.11904076f, -0.05033472f, 
    -0.01604334f, 0.00812344f, -0.13334545f, -0.13244805f, -0.17483437f, -0.13160975f, -0.10639774f, 0.02978661f, 
    -0.03279802f, -0.03059773f, 0.02034312f, -0.00599063f, -0.03220942f, -0.58129388f, -0.45766407f, -0.00239944f, 
    0.04121349f, -0.06684132f, -0.17371069f, -0.20784196f, -0.02741525f, -0.11322743f, 0.03736496f, 0.00870605f, 
    0.10814831f, -0.09051397f, -0.03696869f, 0.00022110f, -0.04077094f, 0.05422176f, -0.09228966f, -0.20077890f, 
    -0.11403120f, 0.14659889f, -0.06252031f, 0.15471259f, -0.04485672f, -0.13323453f, 0.18727732f, -0.08905148f, 
    -0.05522393f, 0.38665017f, -0.15136448f, -0.09135070f, 0.17334741f, 0.14245829f, -0.03845435f, 0.07167818f, 
    -0.05621752f, -0.06835543f, -0.04986978f, -0.05357980f, -0.06313202f, -0.03803162f, -0.05584417f, 0.00020078f, 
    -0.10866518f, 0.04035135f, 0.03214216f, -0.07601558f, -0.02368598f, -0.01682554f, 0.04133665f, 0.00993989f, 
    0.01857303f, -0.11596342f, 0.03092145f, -0.06717490f, 0.03616734f, 0.05880621f, 0.01623544f, -0.01122283f, 
    -0.07340774f, -0.07293695f, -0.11242276f, 0.04842661f, 0.04141006f, -0.01940674f, 0.02164237f, -0.02605086f, 
    0.02104515f, -0.08118878f, -0.10091585f, -0.06875674f, -0.10180541f, 0.01201206f, -0.09929556f, 0.00281437f, 
    0.04208849f, -0.01090744f, -0.07283992f, 0.04266696f, 0.01745085f, 0.01809348f, 0.04076630f, -0.08653217f, 
    -0.04903328f, 0.03126843f, 0.04561897f, 0.03134414f, -0.02106560f, 0.03859433f, -0.09578317f, -0.07232895f, 
    -0.09137294f, 0.03465533f, 0.04289830f, -0.02207358f, -0.03489126f, -0.01487984f, 0.02584853f, -0.09784076f, 
    -0.09565543f, -0.10131472f, -0.00556161f, -0.05675746f, -0.11028939f, -0.07133979f, -0.02483685f, -0.03461297f, 
    -0.00569952f, -0.07227769f, 0.04623411f, -0.10244001f, -0.04935860f, 0.03692703f, -0.01981960f, -0.08241924f, 
    0.01692802f, -0.01986811f, -0.04584512f, 0.01973134f, -0.09127068f, -0.00024363f, 0.01950557f, -0.01841834f, 
    -0.06344776f, -0.05168219f, -0.05222185f, -0.05637536f, -0.04302046f, -0.09700716f, -0.01308374f, -0.09729673f, 
    -0.09510659f, -0.07807545f, -0.08349572f, -0.05857886f, -0.03394566f, 0.00768526f, -0.00746401f, 0.03622544f, 
    -0.09528097f, -0.05004367f, -0.00383573f, 0.03889012f, -0.03835180f, -0.01777173f, -0.11291255f, -0.00991892f, 
    0.01291931f, -0.03471602f, -0.01280162f, -0.01663252f, 0.00956615f, -0.03592519f, -0.07786425f, -0.11362227f, 
    -0.06187078f, -0.02246626f, -0.04881635f, -0.08843762f, 0.03585514f, -0.12095501f, 0.00697058f, -0.03127421f, 
    -0.08717499f, 0.05883174f, 0.04538908f, 0.01155325f, 0.03549984f, -0.02718635f, 0.01376211f, -0.02133342f, 
    0.01841888f, -0.07870574f, -0.03959971f, -0.07694450f, -0.07644646f, -0.03546113f, -0.08111278f, -0.00838788f, 
    -0.28686944f, 0.00837414f, 0.22055958f, 0.15942940f, -0.02675651f, 0.03821102f, -0.22959624f, 0.16026409f, 
    -0.06952982f, 0.04372955f, -0.14992014f, -0.27354485f, -0.02029351f, 0.14746726f, 0.37343222f, 0.03318245f, 
    0.08472473f, 0.19509870f, 0.03981279f, 0.00418825f, -0.12091848f, 0.11663871f, 0.22882214f, 0.06845010f, 
    -0.08530374f, -0.14116625f, -0.14375973f, 0.26120532f, 0.00073865f, -0.23197795f, 0.00019604f, 0.17711040f, 
    0.20750389f, 0.15536125f, 0.04980486f, -0.05904793f, 0.25462914f, 0.12173087f, -0.23850831f, -0.04879518f, 
    0.02116332f, -0.21868096f, 0.01798236f, 0.15953159f, 0.19357750f, -0.14161623f, -0.07314884f, -0.10553477f, 
    0.14516935f, -0.02575741f, -0.15506525f, 0.02426817f, 0.01205794f, -0.12257513f, -0.11697093f, -0.08533064f, 
    -0.14347392f, -0.03424505f, 0.13385336f, 0.17892702f, 0.06303204f, 0.08026872f, 0.05547597f, 0.28649426f, 
    0.03646914f, -0.03964452f, -0.06866679f, -0.03833106f, 0.08829169f, 0.03095466f, -0.15973805f, 0.12844476f, 
    0.10929129f, -0.37627926f, 0.11724556f, 0.17660756f, 0.13382775f, 0.03394605f, -0.06657761f, 0.01773582f, 
    -0.08234023f, 0.07449891f, -0.08744507f, 0.42358130f, 0.13564681f, -0.04995031f, -0.07259731f, 0.22520784f, 
    0.03483451f, 0.13549814f, 0.05541824f, -0.15355520f, -0.24968159f, -0.08984809f, 0.06864242f, 0.13338774f, 
    0.08455618f, -0.22982290f, -0.13953947f, 0.33229512f, 0.18396932f, -0.15760121f, -0.00361998f, 0.12268483f, 
    -0.23593536f, 0.16958065f, 0.13151780f, 0.22677708f, 0.14704061f, 0.46090901f, 0.26582739f, -0.04730203f, 
    -0.23443756f, -0.17383698f, -0.14907652f, 0.20830373f, -0.03154187f, -0.11441605f, -0.04408638f, 0.29587334f, 
    0.05678031f, -0.09659612f, -0.11643197f, -0.12565665f, 0.03513597f, 0.31278923f, 0.36483175f, -0.07680237f, 
    0.24783544f, -0.20070685f, 0.19316128f, -0.13811389f, 0.02187051f, 0.03061454f, -0.00666521f, 0.07564745f, 
    -0.06019574f, 0.02473723f, 0.11442170f, 0.08445565f, -0.12688695f, 0.09443671f, -0.17026669f, -0.23516457f, 
    0.13580637f, 0.12489168f, -0.03741820f, -0.26654398f, -0.06600659f, -0.08605108f, 0.03666163f, 0.05396787f, 
    0.00825802f, -0.31643635f, 0.16479506f, -0.08131252f, 0.06736525f, 0.04407803f, 0.14493793f, -0.11489871f, 
    -0.02508419f, -0.13015482f, -0.00262838f, -0.11400297f, 0.13983162f, 0.11097611f, -0.30036822f, -0.01345216f, 
    -0.10966019f, -0.04176826f, -0.20099480f, -0.08571324f, -0.03370030f, -0.21263587f, 0.36705917f, 0.16545455f, 
    0.10194468f, -0.07236043f, 0.28849915f, -0.00007505f, 0.07898396f, -0.09928597f, 0.16803987f, -0.06023782f, 
    0.24961606f, -0.00932091f, 0.06871495f, -0.19556293f, -0.05901130f, -0.07662242f, 0.00998404f, 0.21631323f, 
    0.19963107f, 0.04284707f, 0.17129342f, -0.11703529f, -0.08778443f, -0.01678546f, -0.17370471f, 0.15019307f, 
    0.02781062f, -0.05397781f, -0.01479135f, 0.00827827f, -0.20772767f, 0.12981459f, -0.02406024f, 0.05449672f, 
    -0.22839168f, -0.16465910f, -0.16698594f, -0.05103726f, 0.03527312f, 0.01893489f, 0.05717561f, 0.02250868f, 
    0.53033751f, -0.01435546f, 0.28675923f, -0.17237158f, -0.04127501f, 0.05088825f, -0.11134207f, -0.08665273f, 
    -0.14667837f, -0.32444283f, -0.64296448f, -0.00494755f, 0.14181447f, 0.17038913f, -0.14226514f, -0.06400259f, 
    -0.01989859f, -0.10431773f, 0.14315790f, 0.02944438f, -0.01034922f, 0.01316347f, 0.05019635f, 0.17690031f, 
    -0.10475213f, 0.06619896f, 0.14210185f, 0.20024906f, -0.06732369f, 0.20844612f, 0.12129264f, -0.12424795f, 
    -0.03466479f, 0.11511641f, 0.06061222f, 0.00213403f, 0.34605375f, -0.26699954f, 0.05793009f, 0.01635038f, 
    -0.06187946f, -0.03955087f, -0.06084724f, 0.01970878f, -0.03994474f, -0.26754278f, 0.07913794f, 0.35625267f, 
    -0.05003206f, -0.11616465f, -0.09591920f, 0.12996046f, -0.07332967f, 0.18531662f, 0.53051007f, -0.16922382f, 
    -0.43344411f, -0.05992400f, -0.02518601f, 0.05197297f, 0.00576619f, 0.09905281f, -0.00237540f, -0.03533536f, 
    -0.01947845f, -0.07113700f, 0.28573832f, -0.12146716f, 0.15293787f, 0.05474355f, 0.20768927f, -0.00594187f, 
    0.36154154f, 0.05284359f, -0.10817766f, -0.15460418f, 0.06636658f, -0.09336846f, 0.07263514f, 0.03966936f, 
    -0.19849536f, -0.12065726f, -0.55794150f, 0.11395645f, 0.05091959f, 0.28006148f, 0.14983779f, 0.21516214f, 
    0.09675367f, 0.13562228f, -0.04189299f, -0.07145420f, -0.15000948f, -0.06295742f, 0.19484216f, -0.14145055f, 
    -0.09371601f, 0.02873703f, -0.07938745f, -0.78436977f, -0.22194040f, 0.14308955f, 0.17921549f, 0.03237171f, 
    0.11203865f, -0.03322012f, -0.07844393f, -0.06250064f, 0.45956323f, 0.39529225f, 0.22846153f, 0.30901292f, 
    0.03532724f, 0.11857988f, -0.03362564f, -0.04384749f, 0.05316165f, -0.60563725f, -0.19839793f, 0.13225551f, 
    0.10229565f, -0.09809746f, -0.11395478f, -0.00217379f, 0.00804382f, -0.05009754f, -0.07940411f, 0.13471472f, 
    0.01466384f, 0.13845210f, -0.02520398f, 0.07164474f, -0.04248079f, 0.19467986f, 0.00786186f, 0.09897894f, 
    -0.12562725f, -0.21735454f, 0.01227076f, 0.08921988f, 0.01385098f, -0.02484991f, -0.02384915f, 0.11678772f, 
    -0.07272536f, -0.09610981f, 0.04304130f, -0.07892038f, -0.19911268f, -0.00095307f, -0.18350658f, -0.02361802f, 
    0.08637472f, 0.00416937f, -0.03105416f, -0.01996664f, -0.17757800f, -0.16633385f, 0.13993712f, -0.06823565f, 
    0.26240861f, 0.05158722f, -0.34201548f, -0.22895826f, 0.03768897f, -0.08164986f, 0.09512923f, -0.04785140f, 
    0.17212981f, 0.07249541f, -0.01594062f, 0.35015124f, -0.00450534f, 0.16949941f, -0.16103935f, 0.04925965f, 
    0.00287253f, -0.01684583f, 0.18869069f, 0.10267762f, 0.04339291f, 0.03201021f, -0.16426122f, -0.01648744f, 
    -0.04218149f, 0.00123935f, 0.01739237f, 0.06895951f, -0.03667441f, 0.08222178f, -0.05345582f, -0.19295403f, 
    -0.23031257f, 0.00157518f, 0.09666900f, -0.01187280f, 0.10937189f, 0.06863029f, -0.06298319f, -0.02362523f, 
    0.07193886f, 0.13821316f, -0.09275173f, -0.03674820f, 0.18283360f, 0.03768895f, -0.04814037f, -0.77646285f, 
    -0.09693633f, -0.09178967f, -0.09136169f, 0.18069983f, -0.00270791f, -0.11851741f, 0.05294493f, -0.01851971f, 
    0.03299382f, 0.01537638f, 0.01959793f, -0.07769524f, -0.05463779f, -0.06174253f, -0.06408167f, 0.05451883f, 
    -0.07539093f, -0.02687404f, -0.07833400f, 0.01282453f, -0.02241029f, 0.04938181f, -0.07464847f, -0.02726268f, 
    0.03616656f, -0.06126638f, -0.04340933f, 0.02136569f, 0.00913452f, 0.01628241f, -0.05232705f, -0.01356582f, 
    -0.07409496f, 0.01195686f, -0.08727511f, 0.05386905f, 0.02451327f, -0.02914231f, -0.05995914f, -0.02955403f, 
    0.00590563f, -0.07386085f, -0.06501421f, -0.05958135f, -0.07107675f, 0.00478813f, 0.02323091f, -0.03954527f, 
    0.05809094f, 0.04565065f, 0.02008479f, -0.04738935f, 0.01181514f, 0.02803161f, 0.07477289f, -0.01395965f, 
    -0.01696377f, 0.04888412f, -0.01442220f, 0.04663753f, -0.04304286f, 0.06219406f, -0.03603562f, -0.03002097f, 
    -0.07866889f, 0.01999535f, -0.03370341f, -0.03948769f, -0.06318552f, 0.05351802f, -0.05314982f, -0.00826072f, 
    -0.02688288f, -0.04624690f, -0.05355364f, 0.02337893f, -0.03573090f, -0.00109472f, -0.00365459f, 0.07670083f, 
    0.07213637f, 0.04999092f, 0.01616576f, 0.03315913f, 0.05651128f, 0.07653406f, 0.00815129f, -0.07486863f, 
    0.05222005f, -0.06162735f, -0.00988110f, 0.01337490f, -0.03329353f, -0.02268605f, -0.01705406f, 0.05820373f, 
    -0.04011145f, -0.05666453f, -0.01078734f, 0.00382895f, 0.01948829f, -0.04934308f, 0.05119138f, 0.01085559f, 
    0.06293934f, 0.05526518f, -0.06234340f, 0.06336629f, -0.04099842f, -0.07167032f, -0.00466873f, -0.08749449f, 
    0.06401326f, -0.01757408f, -0.01090397f, -0.06882042f, -0.02865745f, 0.06788783f, -0.05777721f, 0.00786759f, 
    -0.00476988f, -0.06240778f, -0.09375961f, 0.06929778f, -0.00700209f, -0.05543025f, 0.02558871f, -0.03129967f, 
    0.05730648f, 0.04685537f, 0.00276200f, 0.03705001f, -0.01156200f, -0.06858433f, -0.02750477f, -0.02538051f, 
    0.05953559f, -0.06117454f, -0.04377992f, -0.07373429f, -0.01790001f, 0.04764170f, 0.02494022f, 0.00542330f, 
    -0.03981862f, -0.00289380f, 0.02471631f, 0.02330675f, 0.03665649f, 0.06144466f, -0.06431913f, 0.01548518f, 
    0.40505174f, -0.00104141f, 0.22386439f, 0.17356506f, 0.07338295f, 0.03743076f, -0.02106716f, -0.07251886f, 
    -0.02814858f, -0.01540810f, -0.12438697f, -0.08394801f, 0.12227651f, -0.15166955f, 0.02305275f, 0.11098035f, 
    -0.02239076f, 0.04161335f, -0.15835626f, -0.21177457f, 0.06139599f, 0.21569812f, 0.08576051f, 0.16370495f, 
    0.01608606f, 0.03198994f, 0.01561156f, 0.28258595f, 0.06134802f, 0.17877354f, -0.20788407f, -0.10477894f, 
    0.01142290f, 0.07101857f, 0.17221023f, -0.07228312f, -0.15995169f, -0.20199525f, 0.23903957f, -0.11533739f, 
    0.03759521f, -0.13434350f, -0.14048518f, 0.07666687f, -0.01357263f, -0.17818205f, 0.05252811f, -0.15680932f, 
    -0.14400795f, -0.43033147f, -0.00261632f, -0.17971461f, 0.05248461f, 0.30233902f, 0.39893651f, 0.12583660f, 
    -0.06428508f, 0.10060219f, -0.11207832f, -0.31141761f, -0.13168749f, 0.05413754f, 0.08734563f, -0.09507909f, 
    0.15500151f, -0.12599948f, -0.01461163f, 0.08620077f, -0.06417451f, -0.05353441f, 0.02491903f, -0.03790323f, 
    -0.10796886f, 0.17317010f, 0.08930067f, -0.09903252f, -0.03908677f, 0.03213419f, 0.03982214f, 0.00617184f, 
    -0.00619944f, -0.14919005f, 0.20193885f, 0.28324583f, 0.29373243f, -0.13100813f, 0.13265242f, 0.14524183f, 
    -0.02814499f, 0.02609204f, -0.07708012f, -0.23130447f, -0.48955154f, -0.06260684f, 0.07536786f, 0.03441248f, 
    0.01539601f, 0.25710621f, 0.20541455f, -0.24285823f, -0.32633120f, 0.02876297f, -0.35148492f, -0.12750512f, 
    0.11695588f, 0.01919571f, 0.32612681f, -0.20166716f, 0.04643466f, -0.14317398f, 0.38386652f, -0.21283084f, 
    -0.04731657f, -0.07748904f, 0.09466181f, 0.03308098f, 0.02064784f, 0.01753139f, 0.37110677f, -0.03919903f, 
    0.10150730f, 0.04022079f, 0.05809412f, 0.16851704f, -0.10648343f, -0.07692480f, -0.05806397f, -0.11723196f, 
    -0.08017369f, -0.02028210f, 0.24413642f, -0.11024059f, -0.15494847f, -0.06740908f, 0.13372429f, -0.18582532f, 
    0.13327073f, -0.13942274f, -0.19686422f, -0.08587884f, 0.02254238f, 0.17397138f, 0.05952422f, 0.05032528f, 
    -0.52090496f, -0.38352636f, -0.00067640f, -0.06063332f, -0.07150266f, -0.01660929f, -0.08574659f, 0.03559649f, 
    -0.11590542f, -0.03774553f, 0.07484818f, 0.12333713f, 0.04555972f, 0.10866938f, -0.05563802f, -0.03695473f, 
    -0.04928724f, 0.02490962f, -0.19285139f, -0.15747365f, 0.17672990f, 0.10623860f, 0.28775257f, 0.04019329f, 
    -0.11336159f, -0.11785882f, -0.04920722f, 0.52382219f, -0.08157675f, 0.13496716f, 0.01034949f, 0.08523368f, 
    0.10233087f, 0.05196963f, 0.13983503f, 0.07705276f, 0.28697330f, 0.03128496f, -0.23673904f, 0.12633500f, 
    0.00111307f, -0.05356654f, -0.01383273f, -0.01384329f, 0.02497370f, 0.59659022f, 0.36223370f, 0.14005542f, 
    -0.11357120f, -0.00971437f, 0.07191189f, -0.00414398f, 0.01733044f, -0.04401715f, -0.08495534f, -0.24672633f, 
    -0.03811200f, 0.07899602f, -0.03332825f, 0.07252584f, -0.04799138f, 0.02772753f, 0.11506765f, -0.51669705f, 
    -0.06791612f, 0.18754496f, -0.12710112f, -0.14097545f, 0.04507218f, -0.08275960f, -0.02020697f, 0.18184079f, 
    -0.15670028f, 0.04561445f, -0.32598418f, -0.09507742f, 0.01269225f, 0.00656076f, -0.06321976f, -0.03750010f, 
    0.02952161f, 0.00526963f, 0.13582768f, -0.06264697f, -0.03833716f, -0.05924333f, 0.19107372f, 0.07849389f, 
    -0.03531822f, 0.08681058f, -0.15719680f, -0.16667193f, 0.50588650f, -0.00478442f, 0.06262692f, -0.01296045f, 
    -0.01508864f, -0.05110031f, 0.10962339f, 0.01501732f, 0.04216268f, -0.19208924f, 0.05391303f, 0.12784038f, 
    0.00105095f, 0.13113225f, -0.05330156f, -0.00939978f, -0.09204642f, 0.09655491f, 0.36785981f, 0.21900940f, 
    -0.02532678f, 0.03713552f, 0.04385513f, 0.03726039f, 0.11877770f, -0.27774206f, 0.05471315f, 0.01396873f, 
    0.02944239f, 0.06845643f, 0.06183182f, -0.03142240f, -0.18093985f, -0.08030698f, 0.00125999f, 0.14452319f, 
    -0.26399258f, 0.03827557f, 0.14504932f, -0.02924314f, -0.04564381f, 0.17025362f, -0.07505792f, 0.49083614f, 
    0.02272931f, 0.03133893f, -0.08611771f, -0.07251649f, -0.20447253f, 0.02830131f, 0.25124624f, -0.12151323f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.18318895f, 0.22894801f, -0.06808620f, -0.13169791f, -0.06805432f, 0.10336536f, -0.02464256f, 0.05762831f, 
    0.10052640f, 0.02917018f, 0.13905078f, -0.00397417f, 0.19507195f, -0.08972502f, -0.02681320f, 0.09202449f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08104752f, 0.33039463f, -0.22384164f, -0.43548200f, -0.17318977f, 0.30712944f, -0.12771249f, -0.17518651f, 
    0.11159979f, 0.22348471f, -0.00604470f, -0.19887862f, -0.05583922f, 0.23505417f, 0.42617938f, 0.49279961f, 
    -0.05028211f, -0.34469837f, -0.03584117f, -0.04896759f, -0.55128467f, 0.37201104f, 0.22885367f, 0.22485100f, 
    0.12408203f, -0.09237268f, 0.18531518f, 0.39512470f, -0.11959660f, 0.06763566f, 0.15163492f, -0.20952721f, 
    0.52799362f, 0.37314928f, 0.15707335f, -0.88839495f, 0.39632964f, -0.13979070f, 0.06041235f, -0.16293657f, 
    -0.03151697f, -0.16770148f, 0.18696433f, 0.44117630f, -0.28841659f, -0.10867229f, -0.27675292f, 0.03830976f, 
    0.05773112f, -0.00736680f, 0.21164343f, 0.07441455f, -0.62732345f, 0.14545465f, 0.04757735f, 0.03190199f, 
    -0.41108391f, -0.13982159f, -0.05182051f, 0.01487238f, 0.11320991f, -0.13674206f, 0.24007384f, 0.39159465f, 
    -0.17191957f, -0.21303456f, -0.18410915f, 0.53227568f, -0.23254238f, -0.55410695f, 0.00020795f, -0.08098412f, 
    -0.05771308f, 0.07869324f, 0.37622052f, 0.40042067f, -0.13285956f, 0.17809182f, -0.03601890f, -0.40155965f, 
    0.25826430f, 0.63688296f, -0.20370215f, 0.51124370f, 0.25413871f, -0.36717692f, 0.12926328f, -0.22736605f, 
    -0.16452830f, 0.20061386f, -0.23884295f, 0.28962925f, 0.15223019f, -0.00567993f, -0.72255385f, 0.24460550f, 
    0.11554069f, 0.17733201f, -0.04473209f, -0.21942113f, 0.18705024f, -0.12722006f, 0.15404508f, -0.02292847f, 
    -0.33590266f, 0.14169648f, -0.02768467f, 0.45380068f, 0.19803721f, -0.10216278f, -0.01970190f, 0.24155115f, 
    0.53234977f, 0.18924174f, 0.11482161f, 0.20777272f, -0.29876220f, -0.32730234f, -0.17261274f, -0.05444830f, 
    0.37021112f, 0.00467413f, 0.25270563f, -0.24262705f, -0.26029497f, -0.04785022f, -0.07247323f, -0.00310106f, 
    0.09548325f, 0.07622696f, 0.01505566f, 0.23572658f, 0.34983939f, 0.08722208f, 0.10678030f, -0.09385217f, 
    -0.01793229f, -0.11521634f, -0.02311694f, 0.16672440f, -0.33570245f, -0.19356225f, 0.52432412f, -0.21118267f, 
    -0.36043248f, -0.08690646f, -0.01089555f, -0.20124720f, -0.51083410f, 0.38775843f, -0.13662449f, 0.17355752f, 
    0.26540312f, -0.02691081f, 0.30963531f, 0.41859645f, -0.26853541f, -0.05984539f, -0.20586710f, 0.03839946f, 
    0.09398355f, 0.49980435f, -0.00277999f, -0.14830048f, -0.33525634f, 0.40971550f, -0.06355108f, -0.12304583f, 
    -0.32148916f, -0.17531849f, -0.14673764f, -0.33073097f, 0.13098148f, -0.02435429f, 0.33889335f, 0.12658826f, 
    -0.21051387f, -0.25837740f, -0.04640713f, 0.45713615f, -0.12518078f, 0.24935062f, 0.08262644f, -0.15020342f, 
    0.26360860f, 0.10024174f, 0.37977093f, -0.20575185f, 0.35298744f, -0.10396390f, 0.03044343f, -0.59368026f, 
    0.56307954f, 0.59495372f, -0.21166432f, 0.07678513f, 0.01612554f, -0.08147129f, -0.12220421f, -0.19526456f, 
    0.00049138f, -0.15687335f, -0.10236339f, 0.36335716f, -0.54252303f, 0.18053506f, -0.00233685f, -0.18097681f, 
    -0.08154225f, -0.19324556f, 0.07232448f, -0.23736003f, 0.07885826f, -0.20926014f, -0.14071891f, 0.11812252f, 
    -0.19385394f, 0.24788064f, -0.00386181f, 0.07910779f, -0.18199968f, 0.10352910f, -0.10489058f, -0.08087301f, 
    0.13533296f, 0.10315628f, 0.04758790f, -0.35215256f, -0.20516403f, -0.31345209f, 0.24027151f, 0.22563884f, 
    0.20667867f, 0.11527477f, 0.13245428f, -0.25649482f, 0.61207312f, 0.10157976f, -0.37867230f, 0.38982877f, 
    -0.14429019f, 0.53514344f, -0.00090221f, 0.57479799f, -0.31043962f, -0.09699051f, 0.08450306f, 0.00056647f, 
    -0.40179336f, -0.11784562f, 0.30246967f, -0.09180422f, 0.05220981f, -0.04129518f, -0.42507392f, 0.15538877f, 
    0.37148905f, -0.29116556f, 0.14366445f, -0.05868209f, 0.49349034f, -0.21696898f, -0.14167717f, 0.19328476f, 
    -0.67963040f, 0.11309648f, 0.38291985f, -0.09886874f, 0.04158242f, -0.13352723f, -0.10789000f, -0.11686492f, 
    -0.10073423f, 0.40097511f, -0.04658782f, 0.03104037f, 0.23315254f, 0.29369229f, -0.20763163f, -0.17524274f, 
    0.04102968f, 0.10629109f, -0.36335072f, -0.15811312f, 0.40583473f, -0.14461097f, -0.17600231f, 0.25765401f, 
    0.44500190f, 0.37966916f, 0.06177646f, 0.17125386f, -0.07884439f, -0.27747086f, -0.06859738f, 0.22224584f, 
    -0.57875210f, 0.20356578f, -0.25541309f, -0.22085619f, 0.14061250f, 0.13494368f, 0.37531623f, 0.52546805f, 
    0.04989462f, -0.32418320f, 0.21022570f, 0.20070279f, -0.01255339f, -0.30463254f, -0.12401967f, 0.06672366f, 
    -0.56141835f, -0.10549185f, 0.23688205f, 0.25440088f, 0.43573290f, 0.21837527f, 0.23047481f, -0.26247531f, 
    0.16102801f, 0.42098027f, 0.01782292f, 0.23736197f, 0.35085580f, 0.07510681f, -0.10790171f, 0.00804499f, 
    0.43091515f, -0.14116976f, -0.25378785f, -0.28901973f, 0.04445682f, -0.21907414f, 0.09635899f, -0.31654173f, 
    0.02389997f, -0.13903904f, 0.09659305f, 0.11075840f, 0.52665591f, -0.28578585f, 0.03135162f, -0.16740231f, 
    -0.28641501f, 0.01548358f, 0.33085623f, 0.05232612f, -0.32592055f, 0.20988451f, 0.10353760f, 0.34286803f, 
    0.51647002f, -0.18963607f, 0.04008672f, 0.35117161f, -0.24056983f, -0.24521486f, 0.10895420f, -0.16003974f, 
    -0.09973272f, -0.04283066f, -0.02408486f, 0.26550785f, 0.25845298f, -0.09449549f, -0.04586986f, 0.17180163f, 
    -0.21778964f, -0.00732724f, 0.24245855f, -0.11007047f, -0.75256175f, 0.21385553f, -0.20284456f, 0.14929692f, 
    -0.13314721f, -0.19240499f, 0.23385948f, 0.30294925f, 0.27956447f, 0.05646104f, -0.28046322f, 0.02857311f, 
    -0.41295844f, -0.41727304f, -0.17389598f, -0.09374822f, 0.15766369f, 0.39632171f, 0.04576038f, -0.17135350f, 
    0.04709992f, -0.20811990f, 0.25771391f, -0.31595293f, -0.19964650f, 0.18822132f, -0.04090462f, 0.53150392f, 
    -0.25914609f, -0.03309080f, 0.04742336f, -0.02191075f, 0.32920465f, 0.45134941f, 0.05765118f, -0.20169665f, 
    0.52816170f, 0.01460341f, 0.18889990f, -0.68174583f, -0.41894791f, 0.19189219f, 0.44550276f, 0.18432654f, 
    -0.03104817f, 0.05904905f, 0.05279103f, 0.49219850f, 0.07758495f, -0.20744553f, -0.15919045f, 0.22190401f, 
    0.46724546f, -0.15353437f, -0.10169376f, -0.37733698f, -0.28454149f, 0.10475625f, -0.46978921f, 0.08093309f, 
    -0.07954005f, 0.37535775f, 0.08942094f, 0.01177692f, 0.21594435f, -0.30019695f, -0.10246774f, 0.24091123f, 
    0.39202401f, 0.08714701f, -0.04094209f, 0.15399891f, 0.08820431f, -0.10230500f, -0.26645452f, 0.30553171f, 
    -0.02772973f, -0.66630876f, -0.02251840f, 0.24509215f, 0.01550728f, 0.05723086f, -0.10948435f, 0.19018780f, 
    -0.15460177f, 0.20906956f, 0.44989723f, -0.68743306f, -0.13235201f, 0.05596942f, 0.20789212f, 0.10644257f, 
    0.42306885f, -0.11073399f, 0.13318825f, -0.79191977f, 0.60255992f, 0.00619669f, 0.19160034f, 0.21405543f, 
    -0.05548131f, 0.05531224f, 0.15160401f, 0.06707971f, -0.40495449f, 0.13079642f, -0.66596740f, 0.07592853f, 
    0.01247964f, -0.64629382f, 0.03195715f, -0.36781314f, 0.34865844f, -0.19621377f, 0.13920373f, -0.24139987f, 
    -0.04366637f, 0.13280641f, 0.53125477f, 0.06651321f, 0.38039339f, 0.12760454f, -0.25419948f, -0.02510213f, 
    0.16469425f, -0.60882026f, 0.14323616f, 0.00463750f, 0.18322074f, 0.08683359f, -0.20419466f, -0.08245265f, 
    0.19971028f, 0.00193906f, 0.15076336f, 0.54521251f, -0.21619688f, 0.03959306f, 0.24489385f, -0.24401660f, 
    -0.60009277f, -0.31591058f, 0.09468052f, 0.05440850f, 0.48881310f, 0.48061806f, 0.14866541f, -0.02700913f, 
    0.15530711f, 0.21008790f, 0.14018442f, -0.42323431f, -0.08232094f, -0.10835632f, -0.08275595f, 0.31320530f, 
    0.03451959f, -0.02569262f, -0.07002717f, -0.13351999f, -0.49275509f, -0.07140112f, -0.00335426f, -0.17940375f, 
    0.12123010f, -0.03499862f, 0.31764570f, -0.16409855f, 0.34153047f, -0.11785083f, -0.27067605f, 0.29663086f, 
    0.45196083f, 0.26903296f, 0.13519806f, -0.22473806f, -0.46098420f, 0.17940052f, 0.11252657f, -0.08401725f, 
    -0.38125584f, 0.16521880f, 0.04803497f, 0.20781599f, -0.05653777f, 0.16743127f, 0.28952658f, 0.15945643f, 
    0.14651203f, 0.06411427f, -0.21087617f, 0.38814446f, 0.35850462f, -0.42147824f, -0.09742838f, 0.07469906f, 
    -0.07536203f, 0.15664677f, 0.22781669f, 0.22010519f, 0.14370532f, 0.18237354f, 0.07775725f, -0.11928929f, 
    0.38682410f, 0.35323361f, 0.03063107f, -0.55309701f, 0.51647216f, 0.07924464f, 0.01384879f, -0.09186837f, 
    -0.32830310f, -0.07057854f, -0.11260155f, 0.19927025f, 0.11252354f, 0.19284640f, 0.25092641f, 0.00442787f, 
    -0.16126794f, -0.32212591f, -0.00231287f, -0.29928592f, -0.18159629f, -0.07244986f, 0.09226700f, 0.18956497f, 
    0.02462102f, -0.23647265f, 0.42071190f, 0.20273855f, 0.20450662f, 0.02210174f, -0.52484483f, 0.10494671f, 
    -0.15269379f, -0.10531923f, 0.09267282f, -0.22492388f, 0.54665178f, 0.25332308f, 0.02653078f, -0.06131861f, 
    0.55509949f, -0.23569120f, -0.05368999f, 0.10949853f, -0.07821956f, 0.19173080f, 0.41332391f, 0.17034632f, 
    -0.05444964f, -0.12521730f, -0.11474633f, -0.33997560f, 0.50001049f, 0.84925377f, 0.05447332f, -0.00811902f, 
    -0.26294151f, -0.05311738f, -0.02143618f, -0.32113713f, -0.33613870f, -0.11691282f, 0.39697704f, 0.10482691f, 
    0.01610464f, 0.24512884f, -0.16223603f, 0.24585746f, -0.75267762f, 0.23328264f, 0.16907318f, -0.00610939f, 
    -0.26896545f, -0.20017646f, 0.30187330f, 0.15702504f, -0.26653764f, 0.17853829f, 0.12273771f, -0.08748163f, 
    0.65332371f, 0.27337697f, 0.18362841f, 0.16515046f, 0.27663487f, -0.18038003f, -0.13996395f, 0.22959897f, 
    0.31765151f, 0.21518265f, -0.35033980f, -0.06797767f, 0.07963981f, 0.04942127f, -0.14088485f, 0.33394259f, 
    0.05832656f, 0.11497042f, -0.06494612f, -0.06559710f, 0.08985330f, -0.15215328f, 0.05129946f, 0.06891985f, 
    -0.15559347f, 0.21567649f, -0.14485532f, 0.40092680f, 0.57385796f, -0.05153035f, -0.10718865f, 0.43924633f, 
    0.10901064f, -0.24867950f, -0.16112667f, 0.40415880f, -0.35996762f, 0.05382792f, 0.15878406f, -0.22518164f, 
    0.49512666f, 0.01170617f, -0.00130014f, -0.11053260f, 0.38009679f, 0.09858008f, -0.22108437f, -0.44233096f, 
    -0.41202998f, -0.38941035f, 0.02786249f, -0.00874432f, -0.37365285f, 0.36895841f, -0.14807455f, 0.08767618f, 
    0.15227048f, -0.01037627f, -0.06325498f, -0.16799782f, 0.08108843f, 0.07128473f, 0.50498325f, 0.00211965f, 
    0.26684383f, 0.42750376f, -0.18240499f, 0.04571199f, 0.29848123f, -0.04698322f, -0.23675814f, 0.17308930f, 
    0.09820508f, -0.13243361f, -0.30095723f, -0.13017629f, -0.18195999f, -0.14834978f, 0.00983586f, 0.51308280f, 
    -0.31786048f, -0.29359871f, -0.22193861f, -0.11617313f, 0.42047012f, 0.30851471f, 0.23630044f, 0.12520605f, 
    0.28168166f, 0.00702965f, -0.15808241f, 0.49254727f, 0.26007062f, -0.05117787f, 0.32527253f, -0.05571435f, 
    -0.37290049f, 0.34475800f, -0.23092437f, 0.29483655f, 0.52283835f, 0.27813533f, -0.02410384f, 0.09965938f, 
    -0.26362118f, 0.10947019f, -0.18953036f, 0.39196372f, 0.36728203f, 0.22250976f, -0.16496849f, -0.08922388f, 
    -0.23807533f, -0.23539080f, -0.13734436f, 0.48438010f, -0.19884361f, -0.51289409f, -0.23220438f, -0.07273817f, 
    0.09332820f, 0.20865405f, 0.36258623f, 0.32400006f, -0.18924905f, 0.00644982f, -0.03466714f, -0.37990215f, 
    0.09708973f, -0.17955835f, 0.21158642f, 0.09894336f, -0.41854095f, 0.10215678f, 0.06753267f, 0.12921526f, 
    0.43285295f, -0.02707773f, 0.25603920f, -0.20485952f, 0.17598633f, 0.23268747f, 0.07508862f, -0.22623053f, 
    -0.28193706f, 0.13423176f, 0.16964296f, -0.35188872f, 0.56432408f, 0.51021463f, 0.05455825f, -0.04987574f, 
    0.33518240f, 0.03351520f, -0.00506414f, -0.62032962f, -0.03622371f, 0.05227974f, -0.16113269f, 0.28470001f, 
    -0.24737878f, -0.49901155f, -0.07635397f, -0.19427918f, 0.19786499f, 0.03696706f, -0.24098650f, -0.04450974f, 
    0.08435495f, -0.17678268f, 0.51740533f, 0.36317044f, 0.15966573f, -0.02272173f, 0.02294409f, -0.33199695f, 
    -0.24993011f, -0.19587833f, 0.05624723f, -0.20501225f, -0.18232875f, 0.07712813f, -0.10703480f, -0.20378309f, 
    -0.09317688f, -0.24460790f, -0.12572300f, -0.11613610f, -0.05766457f, 0.03433473f, 0.14472714f, 0.09335504f, 
    0.01483589f, -0.37271860f, -0.17489505f, -0.04206192f, -0.08738358f, 0.63318717f, 0.05336747f, 0.05884543f, 
    0.48715857f, 0.22463942f, 0.06585236f, -0.47970319f, -0.17692661f, -0.12818080f, 0.22807421f, 0.18365760f, 
    -0.84176755f, -0.06768735f, -0.12014583f, 0.36451259f, 0.05348405f, 0.49868432f, -0.18458742f, 0.01871347f, 
    0.34679395f, 0.08987962f, 0.04173956f, -0.58581054f, 0.07182680f, 0.23498124f, -0.35421216f, -0.26097479f, 
    -0.02726746f, -0.12263554f, 0.09472260f, -0.15206186f, 0.13688049f, 0.35204467f, 0.24670622f, -0.14184962f, 
    -0.47343352f, -0.01516133f, 0.32952380f, -0.50742048f, 0.21507235f, 0.02077108f, 0.52279127f, -0.53787148f, 
    0.33796823f, 0.48512197f, -0.22654563f, -0.35232580f, -0.02701876f, 0.20619456f, 0.03117068f, -0.13335644f, 
    -0.23706996f, -0.00836954f, -0.21153623f, 0.34068167f, 0.44934151f, 0.20120190f, 0.16413517f, 0.19106512f, 
    -0.31838140f, -0.43079525f, 0.16475797f, -0.18277246f, 0.48873514f, -0.35020229f, 0.03554956f, -0.22108227f, 
    0.28372949f, -0.20223418f, 0.26964778f, 0.69432062f, 0.24801975f, -0.21825427f, -0.37575260f, 0.13255756f, 
    0.51089418f, -0.29643741f, -0.12760365f, -0.36745676f, -0.01659429f, 0.47823632f, 0.25419545f, -0.19389376f, 
    0.54065138f, -0.11110457f, 0.11649805f, -0.36167017f, -0.47896817f, 0.15833712f, 0.55783606f, 0.27922988f, 
    0.61660057f, 0.33816969f, 0.13467601f, 0.14662963f, -0.26085019f, -0.01781957f, 0.20921126f, -0.13724880f, 
    0.10944464f, 0.10795409f, -0.17034429f, -0.29059562f, -0.09951864f, -0.04995103f, 0.38943714f, 0.24985151f, 
    0.68069541f, -0.01679890f, 0.09014347f, 0.51930231f, 0.11609223f, 0.05139889f, -0.10359749f, -0.19518995f, 
    -0.20689376f, -0.26719093f, -0.03020659f, -0.32818964f, -0.26167294f, 0.07439300f, -0.55424494f, -0.01519082f, 
    -0.11219574f, -0.05945912f, 0.04929611f, -0.05032095f, -0.22411345f, 0.16316780f, 0.23001519f, 0.11471888f, 
    -0.02270096f, 0.17291802f, -0.24121299f, -0.07390153f, -0.25123078f, -0.15508854f, -0.23241296f, 0.13758290f, 
    -0.32882050f, 0.23938163f, -0.24247304f, -0.42907122f, -0.33724067f, 0.11317562f, 0.00281033f, 0.06665799f, 
    0.09170964f, 0.23513615f, 0.18720846f, 0.05672188f, 0.13604531f, 0.15826927f, -0.35013562f, 0.52889055f, 
    -0.06167701f, -0.04097078f, 0.21184286f, 0.09636252f, -0.02983699f, -0.22461852f, -0.02369693f, -0.14648136f, 
    -0.05560724f, -0.07477544f, 0.51691616f, -0.20759255f, 0.02999284f, 0.02846817f, -0.01310822f, -0.35086295f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.88516760f, -0.12745622f, 0.52237993f, -0.45040384f, -0.15747702f, 0.35320821f, 0.64551002f, 0.22137135f, 
    0.09331870f, 0.41369930f, 0.29526979f, -0.03706114f, 0.10636742f, -0.14400491f, 0.36431706f, 0.14598826f, 
    0.07167361f, -0.17910346f, 0.17625219f, -0.00574334f, 0.40066376f, -0.37649673f, -0.57730019f, 0.35476848f, 
    0.37948665f, 0.06098009f, -0.16737758f, -0.05441207f, -0.07690175f, 0.26252675f, 0.12974787f, -0.41712576f, 
    -0.34598443f, 0.43034437f, 0.32106164f, -0.19551463f, 0.18810146f, 0.58452493f, 0.16239251f, 0.51760691f, 
    0.04756871f, -0.35782751f, 0.14473121f, -0.00429842f, 0.11919053f, -0.25590578f, 0.05554876f, 0.16970786f, 
    0.14960158f, -0.10043316f, 0.21515188f, 0.24531832f, 0.12958838f, 0.20346953f, -0.10442273f, 0.39434102f, 
    0.63655645f, -0.25610596f, 0.12964940f, 0.63518739f, -0.20545544f, -0.14479722f, 0.66048825f, 0.31115240f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04626304f, 0.01724189f, -0.39911857f, -0.43321925f, -0.74051917f, -0.16843985f, -0.05836711f, -0.35133028f, 
    0.37045217f, -0.10386365f, -0.16840813f, 0.10001821f, 0.14222619f, -0.03994617f, -0.72905356f, -0.58361351f, 
    0.16566582f, -0.01925845f, -0.27501124f, 0.17691283f, 0.14766273f, 0.03581759f, -0.15075332f, -0.20836683f, 
    -0.09775189f, 0.21903519f, -0.30909395f, -0.19128934f, 0.33754745f, -0.63101226f, -0.00775559f, 0.16649316f, 
    0.21007949f, -0.32834455f, -0.17963429f, 0.15377790f, 0.14193244f, -0.34774342f, 0.23812345f, 0.41202238f, 
    -0.24562837f, -0.16252905f, -0.20328811f, -0.35070682f, 0.04868945f, -0.03801165f, 0.28019625f, 0.16438533f, 
    -0.74998116f, 0.05900230f, 0.13273120f, 0.11017662f, -0.00081839f, -0.08605863f, -0.26763332f, 0.69436711f, 
    -0.10959012f, -0.12654978f, 0.07173289f, -0.25400087f, 0.42256325f, -0.04353888f, -0.42219672f, 0.13236757f, 
    0.10290462f, -0.83814347f, 0.36085632f, -0.54785234f, 0.26385981f, 0.16561228f, -0.02653793f, 0.05694067f, 
    -0.00348566f, -0.48467752f, 0.16642861f, 0.05045285f, 0.10628927f, 0.02464433f, -0.14649028f, -0.12936230f, 
    -0.24870753f, 0.30755132f, 0.15295097f, -0.07602530f, 0.32468772f, -0.03979654f, -0.15074520f, -0.89450634f, 
    -0.08889259f, 0.21204221f, 0.85478044f, 0.14727928f, 0.06520224f, 0.09585392f, -0.58323002f, -0.50011039f, 
    0.06867670f, -0.05978633f, 0.06146979f, -0.14939070f, 0.44864589f, -0.83001316f, 0.04951711f, 0.01719211f, 
    -0.42117047f, 0.25239104f, -0.02344737f, 0.13759553f, -0.69864959f, 0.25083017f, -0.08453324f, 0.01406171f, 
    0.37663019f, -0.11062207f, 0.27794454f, -0.50525594f, -0.01967089f, 0.10286994f, 0.32368147f, -0.08493257f, 
    0.20900209f, -0.46053696f, 0.14461036f, 0.28690267f, 0.00690606f, 0.00551677f, -0.04558033f, 0.21614853f, 
    -0.20737308f, -0.16249262f, 0.23808099f, 0.23043360f, -1.43851280f, 0.10334955f, 0.22931381f, -0.40221563f, 
    0.25016582f, -0.23616587f, -0.64001960f, -0.67909324f, 0.09806367f, 0.03763106f, -0.17125711f, -0.58618259f, 
    0.26042300f, -0.33310646f, -0.14367057f, 0.17415272f, -0.44629458f, 0.37150863f, 0.16078648f, -0.20532422f, 
    -0.07088876f, -0.23526403f, -1.12537861f, 0.11309338f, -0.59787655f, 0.41176379f, 0.42106953f, 0.45153743f, 
    -0.11923569f, -0.53445584f, -0.05313310f, 0.16417608f, 0.29795322f, 0.06307359f, 0.22903563f, -0.22397088f, 
    -0.60767388f, -0.12671612f, 0.30510980f, -0.95933104f, -0.15229285f, 0.04112259f, 0.24911872f, 0.19099255f, 
    -1.36166048f, -0.73984450f, -0.17534851f, 0.19217904f, -0.10633366f, -0.50525838f, -0.90039253f, -0.67951339f, 
    0.10276077f, 0.36402199f, -0.13128394f, -0.26235282f, -0.62909603f, -0.08011937f, -0.14095171f, -0.12054444f, 
    -0.71834695f, -0.13305742f, -2.50423741f, -0.23610185f, -0.06576773f, 0.22283550f, -0.10634873f, 0.01358510f, 
    -0.40143314f, -0.24885535f, -0.57144779f, 0.22775979f, 0.38726333f, 0.01634166f, 0.38123155f, 0.05241750f, 
    0.22193052f, 0.23798905f, -0.09351741f, 0.27964121f, 0.22938034f, -0.15227373f, 0.22377628f, 0.03939575f, 
    -0.18308544f, -0.33840615f, -0.24610129f, 0.03105368f, 0.18946552f, 0.30239123f, 0.51086003f, 0.27210581f, 
    -0.19595961f, 0.22958088f, -0.45694217f, 0.07040227f, -0.53762132f, 0.41247189f, -0.26468715f, -0.65322185f, 
    -0.47074527f, 0.45596614f, 0.18746406f, 0.36555982f, -0.31311142f, 0.11521006f, 0.09643839f, 0.11886048f, 
    -0.28070831f, 0.09769733f, -0.30889079f, 0.16129920f, 0.04666561f, -0.20996663f, 0.05917992f, 0.17794594f, 
    -0.13411817f, 0.19334725f, -0.43319786f, -0.32992378f, -0.19438431f, -0.00688492f, -0.17960092f, 0.10214335f, 
    0.07733379f, 0.37876952f, 0.19253467f, -0.57348716f, -0.10683078f, -0.27503508f, -0.18398523f, 0.22356306f, 
    -0.05549219f, 0.30944979f, -0.41070899f, 0.22737840f, 0.05968688f, -0.04366988f, 0.00181022f, -0.46272495f, 
    -0.33100498f, -0.33643270f, -0.81424356f, -0.16602309f, 0.06550945f, -0.21298982f, 0.01022820f, 0.10875316f, 
    -0.14661358f, 0.18452182f, -0.50367957f, 0.08170249f, 0.10085159f, -0.55692512f, 0.12635158f, 0.28167638f, 
    -0.23118928f, 0.12123337f, -0.01715166f, -0.09524972f, 0.08849668f, 0.27423471f, 0.20742236f, -0.44301328f, 
    0.09666952f, -0.10746265f, -0.21411642f, 0.15562107f, 0.37093961f, -0.59174883f, 0.17345786f, -0.41206017f, 
    0.08879690f, 0.24387185f, -0.30333564f, 0.24405991f, -0.04510185f, 0.23876823f, -0.22784096f, -0.17611901f, 
    -0.13701196f, 0.00351079f, 0.33861339f, 0.04510729f, -0.71157688f, 0.07025673f, -0.00547911f, 0.10761005f, 
    0.09750774f, 0.07754148f, 0.32430404f, -0.03498236f, 0.58656472f, -0.16391942f, -0.11925222f, -0.08776369f, 
    0.07862528f, 0.24354602f, 0.20186172f, 0.14051831f, 0.12809598f, 0.02361841f, -0.22205798f, -0.00795180f, 
    -0.89152002f, 0.10238680f, -0.17084652f, -0.06639063f, 0.03065761f, -0.35750625f, -0.29100111f, -0.03885610f, 
    0.07444012f, 0.15568440f, -0.30732071f, -0.06462763f, -0.44419140f, 0.49724448f, -0.86995363f, -0.16092794f, 
    0.16563565f, -0.06359648f, 0.05252448f, -0.52326429f, -0.13245045f, -0.45893985f, 0.13746288f, 0.45373383f, 
    0.24794289f, -0.27934217f, -0.09584323f, 0.21614988f, 0.22909512f, 0.01207110f, 0.07462732f, 0.17409794f, 
    0.55570489f, -0.06477323f, 0.30307934f, -0.21335842f, -0.00673366f, 0.24988675f, 1.04911005f, -0.16338590f, 
    0.03314106f, -0.27216038f, 0.09581543f, 0.05455328f, -0.70009708f, -0.03180212f, 0.09274214f, -0.39768425f, 
    0.25817162f, -0.28954938f, -0.47776163f, 0.43519711f, -1.57497430f, -0.30667171f, 0.00772370f, -0.15950057f, 
    -0.31522316f, 0.00803057f, -0.08185734f, -0.24810129f, -0.92361212f, 0.08722244f, 0.44890869f, -0.02475274f, 
    -0.22073300f, 0.19355205f, 0.11624981f, -0.89205539f, -0.52628583f, 0.19173679f, -0.09969727f, 0.03040839f, 
    0.52230424f, 0.27721453f, -0.18913414f, 0.24026859f, 0.14595032f, -0.92989379f, 0.14786558f, -0.08374370f, 
    0.40691689f, 0.28124943f, -0.16813332f, -0.25397441f, -0.15183982f, 0.08840966f, 0.25365067f, 0.03989826f, 
    -0.32600760f, -0.07226177f, 0.19943202f, -0.44550845f, -0.41753244f, 0.26277533f, 0.03716574f, -0.05306783f, 
    -1.41539443f, -0.02107044f, 0.33657348f, -0.06444904f, -0.02249236f, 0.11555824f, -0.71640068f, -0.67547911f, 
    -0.09820575f, 0.13593739f, 0.09472580f, -0.17210944f, -0.01833685f, 0.00415716f, 0.23742048f, -0.26053017f, 
    -0.68130332f, 0.00402400f, -1.22215068f, -0.17492323f, 0.48460287f, 0.09921179f, -0.74271989f, 0.10540830f, 
    0.04040350f, -0.16316019f, -0.23667797f, 0.20505401f, 0.30469406f, -0.11552398f, -0.86859900f, 0.22945978f, 
    0.23975773f, -0.61066949f, -0.34988731f, 0.16651113f, -0.36362565f, 0.23792192f, 0.02862416f, -0.12974642f, 
    -0.20542212f, 0.09036454f, 0.26547867f, -0.13237825f, 0.25174281f, -0.13431507f, -0.12139316f, 0.19188929f, 
    0.15251325f, -0.06915040f, -0.49527243f, 0.26954743f, -0.41568223f, -0.22089379f, -0.49762091f, -0.63345575f, 
    0.24950756f, 0.36692122f, -0.61908120f, 0.16340657f, -0.01354569f, 0.21242133f, -0.25772783f, -0.14719273f, 
    0.18631719f, 0.19254853f, -0.50650287f, 0.01389530f, -0.00340109f, -0.26289481f, -0.43883511f, 0.47610193f, 
    -1.00725818f, 0.09538531f, -0.23713949f, -0.49288923f, 0.42988133f, -0.11768629f, -0.42724615f, 0.26034945f, 
    -0.03868406f, -0.42164293f, -0.30697495f, 0.04338602f, -0.37082255f, 0.27381536f, -0.06832211f, 0.33460984f, 
    0.15153798f, -0.41022751f, 0.08660924f, -0.45813414f, 0.43672964f, -0.11244889f, -0.19920410f, 0.06653088f, 
    0.32519946f, -0.08388451f, 0.32589239f, -0.14187689f, 0.17538874f, 0.18311638f, 0.40384308f, -0.69680649f, 
    -0.40965411f, 0.00435978f, -0.68524700f, 0.04188827f, -0.36441568f, 0.33404222f, -0.38856667f, -0.22635074f, 
    -0.64842999f, -0.03234894f, 0.34998235f, -0.05826971f, -0.00654205f, -0.36559170f, -0.23372746f, -0.50463194f, 
    0.22603817f, 0.55696219f, -0.01109919f, -0.56446391f, -0.48533672f, 0.35697216f, -0.57154381f, -0.59695411f, 
    -0.64074147f, 0.02342207f, -0.33394668f, -1.14319086f, -0.01470677f, -0.08088066f, -0.59836167f, -0.69766027f, 
    -0.00192350f, -0.54480839f, 0.27633920f, 0.45086250f, 0.72035128f, -0.05308662f, -0.24338984f, -0.28328121f, 
    0.15161197f, 0.14093581f, 0.28397173f, 0.15976319f, -0.43474638f, -1.06354606f, -0.03984180f, -0.06115641f, 
    -0.09653475f, 0.11176968f, 0.32717258f, 0.07014309f, -0.14542891f, -0.06260848f, -0.06082387f, 0.00129457f, 
    0.14008713f, -0.34934887f, 0.07216679f, 0.12552194f, -0.82662666f, 0.11422697f, 0.06147079f, 0.15260001f, 
    0.38084903f, 0.03676021f, -1.31025887f, -0.35624608f, 0.27380994f, 0.85567081f, 0.04926578f, 0.01133556f, 
    -0.04438370f, 0.16184172f, 0.17511545f, -0.26837695f, -0.01372937f, 0.07856668f, -0.15661147f, 0.27603659f, 
    0.25265417f, -0.58240700f, -0.07446745f, -0.28589106f, 0.17052796f, -0.30593592f, -0.05472438f, -0.29450840f, 
    -0.68475735f, 0.05977903f, -0.03837248f, 0.03522384f, -0.00934907f, 0.12545656f, 0.13710542f, -0.22569369f, 
    -0.08169943f, -0.09463322f, 0.24754553f, 0.00662698f, -0.88487870f, -0.04045944f, 0.04198994f, -0.17960471f, 
    0.03993237f, -0.15674473f, -0.88579679f, 0.29549333f, -0.00655619f, 0.46577635f, 0.20542511f, -0.22847423f, 
    -0.30712000f, -0.27708423f, 0.32738888f, -0.00945655f, -0.98704618f, 0.09492579f, 0.28034329f, 0.24183179f, 
    0.11548592f, 0.47252679f, 0.30267438f, 0.22227633f, -0.00836235f, -0.48147771f, 0.19294767f, 0.40371618f, 
    -0.81879687f, -0.89780009f, -0.01878952f, 0.14523780f, -0.51738000f, -1.62502754f, -0.24422742f, -0.78660935f, 
    -0.54917777f, 0.24707121f, 0.19023523f, 0.10032882f, -0.07403735f, -0.02832786f, -0.37751576f, -0.84685272f, 
    0.02134799f, -0.03839561f, 0.31451902f, 0.26631156f, -0.76175308f, 0.40156767f, 0.07289620f, 0.36232677f, 
    -0.04822831f, -0.03131254f, -0.49761873f, -0.20006114f, -0.05750924f, -1.10383725f, -1.02122760f, 0.46625143f, 
    0.29623988f, -0.09988613f, -1.06865180f, 0.06847405f, -0.29906756f, 0.00985064f, 0.13763461f, -0.11188502f, 
    0.13655581f, -0.27393347f, -0.57612103f, -0.20276874f, -0.16830419f, 0.36766717f, 0.22381340f, 0.02684430f, 
    -0.10452385f, 0.39023370f, 0.09342050f, -0.16214740f, -0.05610998f, 0.01191054f, 0.10894009f, 0.33430296f, 
    0.08410218f, -0.36133116f, -0.11441989f, -0.01648413f, 0.26651385f, 0.25901341f, -0.03453936f, 0.25735325f, 
    0.29146099f, -0.11464379f, -1.05096030f, 0.19858789f, -0.14866185f, -0.90797818f, 0.14888544f, -0.18410788f, 
    0.00865501f, 0.21718983f, 0.00609965f, 0.12881607f, -0.43794137f, 0.47348157f, -0.10640683f, -0.20640472f, 
    0.11733997f, -0.74954307f, 0.06857027f, -0.33869314f, -0.91687644f, -0.14993097f, -0.13832609f, 0.10561366f, 
    -0.01925845f, -0.24170700f, 0.11367791f, 0.13736904f, 0.03399642f, -0.36510971f, -1.82362092f, -0.70312238f, 
    -0.06720690f, 0.16326091f, -0.50456011f, -0.19301040f, 0.40752047f, -0.05440515f, 0.26482573f, 0.11281262f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02272999f, 0.19246887f, -0.47470972f, 0.01428351f, 0.12789044f, 0.37450269f, -0.09106485f, -0.72509736f, 
    -0.47298512f, 0.04062854f, 0.19536932f, 0.37527099f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
