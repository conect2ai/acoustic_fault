#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.82075948f, -0.55201036f, 0.25451756f, 0.54512638f, -0.00281071f, -1.24522030f, -0.07588612f, -0.42606828f, 
    -0.97370642f, -0.68015414f, 0.27925363f, 0.56949109f, 0.35998967f, 0.26419118f, -0.21287100f, -0.03772028f, 
    0.04405605f, 0.18206282f, -0.04107635f, -0.34198689f, -0.24871473f, -0.34548134f, -0.23229671f, 0.01383205f, 
    -0.06065677f, -0.98706800f, -1.13038564f, -0.95471787f, -0.42761102f, -0.24594961f, -0.64686465f, -0.35853761f, 
    0.17407578f, 0.03354195f, 0.09474185f, 0.21133208f, 0.53600574f, 0.12254427f, 0.30143178f, 0.14377056f, 
    -0.04242977f, 0.06548006f, -0.39917791f, 0.23233059f, -0.10142363f, -0.18446253f, -0.40736237f, 0.43260628f, 
    -0.19327261f, -0.16512299f, 0.07216173f, -0.58337301f, -0.95351493f, -0.66077459f, -0.20206110f, -0.13884017f, 
    0.05240137f, 0.38253313f, 0.14299718f, -0.19229622f, -0.50905573f, 0.05380841f, 0.08359289f, -0.02051978f, 
    -0.49567610f, 0.56226534f, 0.47351944f, 0.12188393f, 0.04490180f, 0.30574748f, 0.23679648f, 0.14795218f, 
    0.05469793f, 0.06356642f, 0.02981422f, -0.86751604f, -0.32339483f, -0.51711589f, -0.50853443f, -0.02037342f, 
    0.62299967f, 0.01812201f, -0.10382034f, 0.36472744f, 0.71466237f, -0.25079691f, -0.17870511f, 0.14650866f, 
    -0.31735399f, 0.28454959f, -0.36018696f, 0.04657447f, 0.01719616f, -0.23620071f, -0.12769125f, 0.02862688f, 
    -0.51185507f, -0.56944060f, -0.15870011f, -0.18068328f, -0.97664839f, 0.30235326f, -0.15997447f, -0.09346476f, 
    0.07176341f, -0.04976196f, 1.33742368f, 0.59864992f, -0.07929104f, 0.62779504f, -0.34362814f, 0.09130849f, 
    0.44991276f, -0.17137548f, 0.10307579f, 0.03028343f, -0.13938347f, -0.37721574f, 0.12799990f, 0.11491373f, 
    0.11970019f, 0.00034713f, 0.08643587f, -0.02088499f, 0.07738757f, 1.02974522f, 0.68862194f, -0.45273852f, 
    -0.65662295f, -0.71487486f, -0.03098522f, 0.30562586f, 0.60321224f, 0.63159674f, 0.60554171f, -0.45162347f, 
    0.44657847f, -0.05341604f, -0.29325736f, 0.00046371f, 0.08528759f, 0.22272772f, 0.30199683f, 0.02533883f, 
    -0.16553941f, 0.42001492f, -0.15247273f, 0.01253937f, 0.13174440f, 0.11222655f, -0.70275778f, -1.07200372f, 
    0.27938297f, 0.65165979f, 0.58554095f, 0.24927929f, 0.77768397f, 0.09701867f, -0.20652646f, 0.31899092f, 
    0.10502990f, -0.15341133f, -0.27590966f, 0.34642205f, 0.45058152f, 0.15053341f, 0.31915268f, 0.07890376f, 
    -0.14450787f, 0.07929242f, -0.22111747f, -0.01641501f, 0.32323778f, -0.27440375f, -0.26534024f, 0.23823103f, 
    -0.53976631f, -0.51812148f, -0.60338527f, -0.11754760f, 0.24210803f, -1.03447497f, -0.66472620f, -0.47481841f, 
    -0.76465368f, 0.21289270f, 0.57736313f, 0.11677895f, 0.09028810f, 0.28358689f, 0.15426739f, -0.28773028f, 
    0.21818031f, 0.31850114f, 0.33465064f, -0.01434253f, 0.23870081f, 0.01609248f, 0.00882281f, 0.06361733f, 
    -0.35957730f, -0.40513915f, -0.64991450f, 0.41426992f, 0.10200184f, 0.82179272f, 0.99301100f, -0.92853683f, 
    0.57091886f, 0.55979013f, 0.13446973f, -0.37972340f, -0.23786850f, 0.07650722f, -0.46910146f, -0.11031140f, 
    0.00049690f, 0.09224622f, 0.10287321f, -0.47745985f, 0.23685595f, -0.28358707f, -0.23937550f, -0.19884391f, 
    0.00404505f, -0.58530349f, -0.62660742f, -0.58045310f, -0.64792478f, -0.64403826f, 0.26915842f, 0.00753549f, 
    0.28259897f, 0.58096713f, 0.51743984f, -0.05915466f, -0.54355949f, -0.00123738f, -0.01691680f, 0.04660640f, 
    0.26971173f, 0.06664923f, -0.02719872f, 0.37619400f, 0.30313161f, -0.00225291f, 0.44623855f, -0.07692450f, 
    0.23979010f, 0.39581075f, -0.61351502f, -0.16571374f, -0.20120782f, 0.10883460f, 0.36093825f, -0.33468091f, 
    0.81899202f, 0.65825665f, 0.41886857f, 0.07884604f, -0.28519735f, -0.17265850f, 0.13696416f, 0.26633197f, 
    0.40525782f, 0.34831560f, 0.39356348f, 0.33068731f, 0.53302425f, -0.22918576f, 0.34241572f, -0.16658798f, 
    -0.60504484f, -0.04486439f, 0.30880001f, 0.83535844f, 0.32894674f, -0.46763772f, -0.52728128f, -0.42989150f, 
    0.77279210f, 0.43352813f, 0.11977495f, 0.67695218f, 0.36697429f, -0.26228681f, -0.46598643f, -0.58678848f, 
    -0.37269783f, -0.13393597f, -0.25507179f, -0.25118363f, -0.48892689f, 0.06531243f, 0.10520887f, -0.42645317f, 
    0.01340391f, -0.23547827f, -0.20347579f, -0.20242424f, 0.10378342f, 0.92306870f, -1.11874950f, -0.30019021f, 
    -0.80849618f, 0.87550455f, -0.18722542f, -0.09082329f, -0.32309198f, -0.50647718f, 0.14410080f, 0.33761823f, 
    0.63230044f, 0.43587154f, -0.17189415f, -0.44062588f, -0.42536363f, -0.10463325f, -0.06563544f, -0.21378317f, 
    0.12711093f, 0.22686101f, -0.02477086f, 0.07237814f, 0.21491967f, 0.29063925f, -0.63684213f, 0.24871524f, 
    0.87256896f, 0.75429839f, 1.03226984f, 0.82723677f, -0.54318786f, -0.23647889f, -0.12088428f, 0.08563521f, 
    0.71013612f, -0.07488086f, 0.28658426f, 0.01849728f, -0.10452770f, 0.09233916f, -0.16544960f, 0.03756524f, 
    -0.06077220f, 0.25695026f, 0.23459078f, 0.21458063f, -0.03113063f, 0.25345093f, 1.57549644f, 0.97083688f, 
    1.25797832f, 0.26361942f, 0.91556579f, 0.13027647f, 0.10332788f, -0.35055092f, 0.18953228f, 0.22857156f, 
    -0.12447423f, 0.27589086f, -0.00473282f, -0.05772353f, 0.26936531f, -0.14598472f, 0.00980464f, 0.09182401f, 
    -0.01190367f, -0.22808318f, 0.23307425f, 0.07934650f, 0.07648871f, -0.08968251f, 0.10709303f, 0.64677989f, 
    -0.28659889f, -0.44932458f, -0.76348257f, 0.68853927f, -0.15400226f, -0.91241086f, -0.87082082f, -0.35355684f, 
    -0.14227760f, 0.12078463f, -0.34946829f, 0.03914791f, -0.02432610f, 0.07050619f, -0.34987745f, -0.04806343f, 
    -0.74396580f, -0.35350338f, 0.06500299f, 0.13664290f, 0.17811514f, 0.25241452f, 0.41392541f, -0.30543339f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.42717159f, 0.19014299f, 0.25122544f, -0.11706848f, 0.22932357f, 0.07955876f, 0.01004595f, 0.43131566f, 
    0.07544989f, 0.19827747f, 0.20774060f, 0.07825170f, -0.07559688f, 0.30976444f, 0.53631186f, 0.33617553f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19429000f, -0.26069495f, 0.32326248f, -0.01403485f, 0.05127587f, 0.00708784f, 0.01762673f, -0.05357393f, 
    0.04506256f, -0.04877705f, -0.07872639f, 0.06307117f, -0.01322070f, -0.03493530f, 0.12127755f, 0.17721204f, 
    0.11281260f, -0.00256953f, 0.13312389f, 0.19781552f, -0.11411484f, 0.07404950f, -0.01134053f, 0.22561206f, 
    0.03103781f, -0.25366369f, 0.12995401f, -0.35982570f, 0.03020526f, 0.06517889f, 0.07710920f, 0.34214193f, 
    0.10945664f, 0.16844973f, -0.13310175f, -0.04123400f, -0.34950083f, 0.18468158f, 0.10110179f, -0.09326290f, 
    0.20767812f, 0.12456737f, -0.28283539f, -0.18774310f, -0.16465466f, 0.03537900f, 0.10213537f, 0.22297251f, 
    0.06138425f, -0.06095175f, 0.01932235f, 0.01757577f, 0.09483591f, 0.00695640f, 0.03948573f, -0.20053378f, 
    0.16505995f, 0.00832577f, -0.01473070f, -0.00430686f, 0.39750272f, -0.45237640f, 0.14107260f, 0.11040902f, 
    -0.07905348f, -0.10799226f, -0.00969353f, 0.06040091f, 0.04964095f, -0.00090091f, 0.08373291f, 0.09040636f, 
    0.23951618f, -0.09186058f, 0.06076797f, -0.00936862f, -0.01350943f, 0.13958961f, 0.00217905f, 0.00263463f, 
    -0.02138877f, 0.18406866f, 0.04124541f, 0.04401561f, 0.09043286f, 0.10781007f, 0.00230108f, 0.08082940f, 
    -0.04132666f, 0.12469403f, 0.06060437f, 0.08691604f, -0.02986405f, 0.09476083f, 0.05034355f, 0.10618883f, 
    -0.08915839f, 0.03383210f, -0.20928557f, -0.04998071f, 0.06595887f, 0.08036585f, -0.18309261f, 0.00502074f, 
    0.12897347f, -0.10968442f, 0.16300605f, 0.00414823f, -0.06785088f, -0.14219162f, 0.09638148f, -0.32766008f, 
    0.11964504f, 0.09367713f, 0.08054862f, -0.08880466f, -0.04503151f, -0.07316978f, 0.07246535f, 0.01642695f, 
    -0.08549539f, -0.20630375f, -0.12366135f, -0.01384945f, 0.28480160f, 0.02546120f, -0.02437427f, -0.12013151f, 
    0.02432177f, -0.02324223f, -0.02368263f, -0.12066089f, 0.23181696f, 0.21072850f, -0.04583708f, 0.11395746f, 
    -0.10423317f, -0.03815804f, -0.19487268f, 0.01340623f, -0.05186862f, 0.08129936f, -0.00720360f, -0.04499330f, 
    0.45566958f, 0.25645819f, 0.17055699f, 0.31507364f, -0.09977978f, 0.07748235f, -0.07255714f, 0.21701387f, 
    -0.10310664f, 0.08457112f, -0.21526608f, -0.01394883f, -0.00355599f, -0.13384140f, 0.03752017f, 0.08691747f, 
    -0.04333383f, 0.03787420f, -0.03526287f, 0.11826319f, -0.07330009f, -0.13093664f, -0.01056634f, -0.00080145f, 
    -0.17380410f, 0.23240140f, 0.39088646f, 0.59111547f, -0.26505026f, -0.11451114f, 0.09090437f, 0.04685457f, 
    -0.05571757f, -0.04891001f, 0.00491193f, -0.00125867f, -0.03577957f, 0.04830304f, 0.10420018f, -0.39383268f, 
    -0.11411200f, -0.05089818f, -0.13335131f, -0.01392249f, -0.08661938f, 0.11978059f, 0.06345325f, 0.09791500f, 
    0.44473517f, -0.11973680f, -0.17279671f, -0.30765656f, -0.04575539f, 0.09313107f, 0.07452859f, 0.10704453f, 
    0.02408780f, -0.17344892f, 0.29472026f, 0.15512471f, -0.27110454f, 0.01122526f, 0.07993533f, -0.01173204f, 
    0.03885787f, 0.09405067f, 0.11225496f, -0.12427819f, 0.12372364f, 0.03338605f, -0.05618265f, 0.06627133f, 
    -0.14711222f, 0.01956535f, -0.02409132f, 0.13463257f, 0.09383934f, -0.08199437f, -0.20802145f, -0.02587378f, 
    0.19455978f, -0.01663942f, -0.02888951f, -0.05036930f, -0.33507249f, 0.07806461f, -0.05468135f, -0.09545776f, 
    -0.09780839f, 0.14610776f, 0.02591737f, -0.09388711f, 0.00646735f, 0.05876007f, -0.02206392f, -0.12424298f, 
    -0.02582924f, -0.48738486f, -0.01309148f, 0.10209855f, -0.05879183f, -0.01755994f, 0.19390510f, -0.01979232f, 
    -0.07420069f, 0.08775589f, 0.22340599f, 0.07310793f, 0.03646375f, 0.25960231f, -0.00237049f, 0.41178036f, 
    0.08343195f, 0.12542851f, 0.16280469f, 0.12237124f, 0.09616075f, 0.00262514f, 0.10226510f, -0.09189207f, 
    0.34202158f, -0.00556660f, -0.27053830f, -0.29279634f, 0.07880614f, -0.13464738f, 0.00427297f, 0.00448933f, 
    0.01100449f, 0.07972253f, -0.07509875f, -0.10565599f, -0.05082460f, 0.10902883f, -0.28877661f, 0.10962004f, 
    0.11604683f, -0.04496174f, 0.06032009f, 0.08774186f, -0.03861748f, 0.14909777f, -0.02817338f, 0.13991264f, 
    -0.34538648f, -0.15587848f, 0.06498403f, -0.08524341f, 0.07474177f, 0.10917576f, 0.09665778f, -0.01797411f, 
    0.03372842f, -0.08862562f, 0.02571050f, 0.00065492f, -0.33226436f, -0.05884753f, -0.09570540f, 0.26201925f, 
    0.01565366f, -0.12679340f, -0.17254692f, 0.06736750f, -0.07635732f, 0.13083257f, 0.05754922f, 0.07258743f, 
    0.25509644f, -0.32375383f, 0.21372633f, 0.12711839f, 0.03797997f, 0.12237500f, 0.00103422f, 0.00029318f, 
    0.06684639f, -0.08622313f, 0.07743434f, -0.08977377f, 0.11698128f, 0.18672159f, -0.00557947f, 0.21342963f, 
    0.06860237f, 0.00707440f, -0.10752641f, -0.19168024f, -0.00586029f, -0.07770783f, -0.15597814f, 0.01218766f, 
    -0.18156970f, 0.14398585f, 0.38588217f, 0.31195474f, -0.01895663f, 0.09348031f, -0.02950102f, 0.04241704f, 
    0.04850401f, -0.02044498f, 0.14176817f, -0.15898661f, 0.17940308f, -0.01222760f, -0.05820259f, -0.24367276f, 
    0.04615920f, 0.05345272f, -0.04929414f, -0.01470296f, 0.16592115f, 0.09209783f, 0.10577209f, -0.05376254f, 
    0.03204669f, 0.41838485f, 0.15056445f, -0.00425478f, 0.19358759f, 0.10936081f, -0.19613047f, 0.00099799f, 
    0.00895449f, -0.05938384f, 0.06928623f, -0.01644038f, -0.08204746f, -0.03895776f, -0.20209609f, 0.13140489f, 
    0.07351059f, 0.00671515f, 0.13491316f, 0.04118515f, 0.22517148f, 0.10009023f, -0.22479290f, 0.11335131f, 
    -0.05253038f, 0.04453272f, 0.03296585f, 0.02468745f, -0.07024858f, 0.03734517f, -0.07050079f, -0.06572416f, 
    -0.04523430f, -0.07135961f, -0.01550482f, -0.03768114f, -0.03483009f, -0.04095929f, 0.03492627f, 0.05871468f, 
    0.04799479f, 0.06281857f, -0.01527436f, -0.04477427f, 0.05982879f, -0.04847581f, 0.05796014f, -0.06803318f, 
    -0.04197896f, 0.01173400f, -0.05496721f, 0.02745025f, -0.04967402f, 0.02009106f, 0.05921681f, -0.01337391f, 
    0.02871227f, -0.03110102f, 0.04558625f, -0.04697945f, -0.02501939f, -0.04196735f, -0.04354216f, 0.05720106f, 
    0.05753444f, 0.06177462f, -0.06877870f, 0.00386095f, 0.06364255f, -0.03036127f, 0.01171934f, 0.04444699f, 
    -0.07062505f, -0.04277747f, -0.02559175f, 0.05415009f, -0.04487208f, -0.06991395f, -0.03364965f, -0.04732543f, 
    0.04289169f, 0.06553024f, 0.02344855f, -0.04392681f, 0.01279594f, -0.03750115f, 0.02031474f, -0.07190279f, 
    -0.05025236f, -0.04805170f, -0.01328913f, 0.02095465f, 0.06215144f, -0.06460923f, -0.03005428f, -0.02016063f, 
    -0.01975863f, -0.06454697f, -0.06544352f, -0.06138841f, -0.04722397f, 0.03386152f, -0.00221409f, -0.02693459f, 
    -0.04795674f, 0.01898900f, 0.00752997f, -0.05741594f, -0.04300403f, -0.01171189f, 0.02285265f, -0.04036332f, 
    -0.02247258f, 0.05108162f, 0.05670034f, -0.02979912f, -0.04325550f, -0.03054368f, -0.02878832f, 0.01554554f, 
    -0.00574702f, 0.06614517f, -0.04636058f, 0.06694458f, 0.02640270f, -0.05361153f, -0.06619422f, 0.03045833f, 
    0.03498828f, -0.07138562f, -0.04476563f, -0.00231554f, -0.04694825f, 0.05759932f, 0.04030427f, 0.07167462f, 
    -0.00511639f, -0.05335152f, 0.02720086f, 0.03313612f, 0.02901492f, -0.03809999f, 0.02985634f, 0.05830009f, 
    -0.01370621f, -0.04694336f, 0.04196649f, -0.07168709f, -0.02414014f, -0.07206591f, -0.07076573f, 0.01279391f, 
    0.06873171f, -0.05629943f, -0.06194264f, -0.01998435f, 0.02421079f, 0.03239403f, 0.00683129f, -0.06250672f, 
    0.06330097f, 0.04532854f, 0.01525940f, -0.03842166f, -0.00763222f, -0.04363656f, -0.06913611f, 0.01482613f, 
    -0.04835761f, -0.07124864f, -0.06803504f, 0.07189772f, -0.05179239f, -0.01784404f, -0.03369338f, -0.02391675f, 
    -0.04243714f, 0.04785040f, 0.06249556f, -0.01815024f, 0.01792126f, -0.05446396f, -0.01494143f, -0.04640595f, 
    -0.04130631f, -0.00482530f, -0.05241155f, -0.06361865f, 0.04578295f, -0.01902743f, 0.01916444f, 0.00192024f, 
    0.04470011f, 0.04308322f, 0.02527414f, 0.00634341f, 0.00402202f, 0.06749434f, 0.05064791f, 0.02383723f, 
    -0.00924148f, -0.06948000f, 0.06347439f, 0.05690138f, 0.01943799f, 0.02531137f, -0.07177069f, -0.03104643f, 
    -0.01796818f, 0.01323503f, 0.02781166f, -0.02717457f, -0.04459886f, 0.03947125f, 0.05113101f, -0.05034119f, 
    0.29096889f, 0.31272477f, -0.24524884f, -0.19747591f, -0.18349715f, 0.07187844f, 0.02378142f, 0.06870164f, 
    0.17113219f, -0.05604727f, 0.23488618f, -0.02762810f, 0.24190496f, 0.21915880f, 0.17797612f, -0.23049140f, 
    -0.15651877f, 0.11396534f, 0.10059988f, -0.13282487f, -0.03361826f, -0.17975838f, -0.00191302f, -0.05638231f, 
    0.12132409f, 0.22106747f, 0.20936471f, -0.01533091f, 0.00065982f, 0.12571730f, -0.08203334f, -0.25430724f, 
    -0.13683078f, -0.21626474f, -0.07543880f, -0.03900960f, -0.02696629f, 0.16283682f, 0.06965479f, -0.12713440f, 
    -0.14730792f, -0.03833885f, 0.02217800f, -0.02270530f, 0.12850752f, -0.16373540f, -0.10302610f, -0.05518848f, 
    0.38769308f, -0.34176180f, -0.14366075f, 0.03251781f, 0.05692328f, 0.08825707f, 0.02999215f, -0.07854228f, 
    0.01005662f, 0.13190751f, 0.10529029f, 0.21089484f, -0.08941245f, 0.49554914f, 0.10714711f, 0.12559813f, 
    0.19542788f, 0.12003908f, 0.19137749f, 0.12206196f, 0.08292384f, 0.01439565f, 0.06291663f, 0.02323996f, 
    0.41947243f, -0.23035006f, -0.16146062f, 0.00670569f, -0.07377753f, -0.32114679f, -0.08998028f, 0.01418925f, 
    -0.09700821f, 0.11350618f, 0.01125946f, -0.06241242f, 0.28937030f, 0.25534600f, -0.31486589f, -0.04928814f, 
    0.23212802f, 0.00189724f, 0.07389056f, -0.05849700f, -0.17933233f, 0.35706803f, -0.10555879f, -0.06764182f, 
    0.01979470f, -0.09530573f, -0.16283381f, -0.04130900f, 0.01913127f, -0.08882368f, -0.05553222f, 0.25196627f, 
    -0.08062483f, -0.07833675f, -0.03817750f, -0.01423136f, -0.01939090f, 0.27770600f, 0.19302344f, 0.04889232f, 
    -0.08893214f, -0.28108144f, -0.04560393f, -0.03755024f, 0.07512459f, 0.11542236f, 0.02632639f, -0.02816311f, 
    0.43587008f, -0.27009204f, 0.02168814f, -0.00650766f, -0.15357809f, 0.03901725f, -0.16846544f, -0.03321977f, 
    -0.01668434f, 0.19636002f, 0.06419475f, -0.01373985f, 0.17129791f, 0.02778254f, 0.06638493f, -0.01695465f, 
    -0.07662587f, -0.02164799f, -0.13464944f, -0.08713104f, 0.03553539f, 0.04838677f, -0.14818229f, -0.16468708f, 
    0.03608485f, -0.03092781f, 0.19430330f, 0.06228742f, -0.09897209f, 0.06027558f, 0.10867776f, 0.09074696f, 
    0.01459975f, 0.18341188f, 0.09307487f, -0.21505205f, 0.46424437f, -0.17133389f, -0.28602758f, -0.00500330f, 
    -0.04296947f, -0.11249117f, 0.08460024f, -0.04031393f, 0.09969236f, 0.11974471f, 0.13248214f, 0.09513453f, 
    -0.17262428f, -0.13381609f, -0.62701452f, -0.15071446f, 0.24607590f, 0.20948832f, -0.02460746f, -0.19460267f, 
    -0.01287029f, 0.04536819f, 0.16254164f, 0.02047206f, 0.14285539f, 0.03366974f, -0.29415327f, 0.01547095f, 
    0.04027947f, 0.00304906f, 0.10138880f, 0.04172664f, 0.19402514f, 0.08997355f, -0.02744520f, 0.11213537f, 
    -0.15597165f, -0.05247255f, 0.14830375f, -0.13322844f, -0.06829656f, 0.07473704f, -0.15206563f, 0.06058377f, 
    0.02128073f, -0.05242048f, -0.18452018f, -0.11664469f, 0.55921370f, 0.42866200f, 0.09480487f, 0.19988596f, 
    0.02834936f, 0.03383550f, -0.00800708f, 0.18145765f, -0.02744851f, 0.04043592f, 0.07489153f, -0.00680044f, 
    0.10618950f, -0.06992535f, 0.18993776f, 0.10363677f, -0.14344527f, -0.12654857f, -0.04476463f, 0.04209621f, 
    0.11869982f, -0.13836157f, 0.05849043f, -0.10289167f, 0.05106112f, 0.24316698f, 0.23927887f, 0.17053762f, 
    0.02715921f, -0.08074139f, 0.12335914f, 0.17022464f, -0.03949851f, 0.01118281f, 0.10912792f, 0.10580584f, 
    -0.15912157f, 0.09632702f, -0.13618408f, 0.16270725f, 0.16518366f, 0.04289580f, 0.15866435f, -0.05378405f, 
    -0.06803960f, -0.04081098f, 0.03240451f, 0.04522783f, -0.33776817f, 0.20824140f, 0.20337176f, 0.09454475f, 
    0.07396078f, -0.06330480f, 0.16681960f, -0.03770156f, -0.02251484f, -0.09358792f, 0.04733252f, -0.11702403f, 
    0.18633905f, -0.14226207f, -0.31416282f, -0.23387100f, 0.07797185f, -0.07480860f, 0.00517647f, 0.19103770f, 
    0.11028342f, 0.16890547f, 0.14010964f, 0.00036942f, -0.11782810f, 0.16131115f, -0.02927762f, 0.06202288f, 
    0.28021437f, 0.07289844f, 0.06103673f, 0.00732435f, -0.03954563f, -0.02892451f, 0.04599900f, -0.01118201f, 
    -0.18872097f, -0.37635949f, -0.07440051f, -0.08360252f, 0.07978518f, 0.01693172f, 0.05431788f, 0.08547360f, 
    -0.05035672f, 0.13371901f, 0.02998426f, 0.01314638f, -0.12823410f, 0.10119352f, 0.04482658f, 0.11631842f, 
    0.11760394f, -0.01140889f, -0.14079468f, -0.00027820f, -0.02602775f, -0.02010807f, 0.13602883f, -0.05878908f, 
    -0.05390213f, -0.22388899f, -0.08193736f, -0.10661314f, -0.09743068f, -0.10952676f, 0.13848130f, 0.10875326f, 
    -0.14883125f, -0.06578955f, -0.06128005f, -0.10093734f, -0.15702745f, -0.13675515f, 0.00708876f, 0.35512078f, 
    0.14829729f, -0.01474883f, 0.00526466f, 0.25073171f, 0.14685196f, -0.00433611f, 0.12390366f, 0.10215990f, 
    0.27962607f, -0.30418041f, -0.13765144f, -0.00524736f, 0.07397033f, -0.01753204f, -0.02527018f, -0.06696096f, 
    -0.04111563f, 0.08727543f, -0.09566155f, -0.15357317f, 0.54284781f, -0.13943386f, -0.04698794f, -0.27466664f, 
    -0.03045084f, 0.08201128f, -0.09757200f, -0.07445367f, -0.11970647f, -0.12759565f, -0.12381361f, -0.11392864f, 
    0.26124236f, 0.18081346f, -0.08180989f, 0.40290853f, -0.07620332f, 0.00136252f, 0.03282684f, 0.03507308f, 
    0.09315106f, -0.06142329f, 0.06568353f, -0.03526285f, -0.02893384f, -0.30451304f, -0.35025376f, -0.20075594f, 
    0.12610164f, -0.02376764f, -0.09053911f, -0.05239946f, -0.11629166f, 0.11892520f, -0.08060469f, 0.21282215f, 
    0.71072191f, 0.41221026f, -0.18703949f, 0.12506260f, 0.09976085f, 0.28342614f, 0.07383462f, -0.08520795f, 
    0.00753909f, -0.03770044f, 0.20371629f, 0.02219096f, -0.28835341f, -0.23812053f, -0.03794095f, -0.43370450f, 
    0.13356873f, 0.11557521f, -0.00926977f, -0.17614232f, 0.06575384f, 0.05996876f, 0.04232091f, 0.08379677f, 
    0.06944642f, -0.19000652f, -0.05914302f, 0.13090274f, 0.03496775f, -0.07521123f, 0.08572633f, -0.22097990f, 
    -0.06372160f, -0.08734791f, 0.05923624f, -0.02250829f, -0.13174614f, -0.13227522f, -0.19148929f, 0.01233150f, 
    -0.09354314f, 0.20118482f, -0.15081432f, -0.12258030f, -0.16345727f, 0.00630254f, -0.04444238f, -0.06135619f, 
    -0.31318575f, -0.08619326f, -0.14509816f, -0.17696460f, -0.19394737f, 0.07506996f, 0.18916075f, 0.06502278f, 
    0.13615583f, 0.05263966f, 0.01863289f, 0.11686923f, -0.16274129f, 0.00425513f, -0.17238303f, 0.16133474f, 
    -0.00694902f, 0.15776730f, 0.01809789f, -0.13127390f, -0.02743698f, -0.00252856f, 0.11221265f, -0.01166484f, 
    0.12817419f, -0.04434932f, 0.08309297f, -0.00915938f, 0.03201279f, 0.01778288f, 0.22175039f, 0.20408231f, 
    -0.05891958f, 0.00837063f, -0.10359482f, -0.03833709f, 0.16186735f, -0.36003369f, -0.21858403f, 0.15925385f, 
    0.12919952f, -0.22183289f, -0.07256705f, -0.03031594f, -0.04014006f, -0.00521601f, 0.06460737f, 0.21276566f, 
    0.47132254f, -0.20377535f, 0.10211919f, -0.23601429f, 0.04561152f, 0.00008558f, 0.10275221f, -0.06828736f, 
    0.04941906f, -0.27378780f, -0.05308042f, -0.04111317f, 0.18853603f, 0.16308387f, -0.28617504f, 0.15504533f, 
    -0.11412828f, 0.05079248f, 0.00668851f, -0.00687623f, 0.06749079f, 0.12522255f, -0.12278776f, 0.24964082f, 
    -0.08089178f, 0.08511709f, 0.07705946f, -0.02203959f, 0.18096638f, 0.20132793f, -0.29988080f, -0.04462924f, 
    0.11915880f, -0.00033014f, 0.08822542f, -0.09115478f, 0.07599489f, -0.21928890f, -0.10208955f, -0.09673583f, 
    -0.07720535f, 0.09318318f, 0.02477902f, -0.14235646f, -0.18949622f, 0.04904855f, -0.13120452f, -0.07549428f, 
    -0.30940193f, 0.05067645f, 0.13089120f, 0.36927822f, -0.12790625f, 0.13151833f, -0.07197575f, 0.32821250f, 
    0.10745655f, -0.12201912f, 0.09565853f, -0.02352347f, 0.15703289f, -0.42880303f, 0.44717309f, 0.25952092f, 
    0.06525172f, 0.09738795f, -0.00092616f, 0.07123404f, 0.25168651f, 0.03168534f, 0.20446585f, 0.14122318f, 
    -0.07394097f, 0.05478710f, 0.10730829f, -0.22998352f, 0.02110710f, 0.09982269f, 0.05697238f, 0.05300261f, 
    0.08356141f, 0.05440730f, 0.11815145f, 0.16816920f, 0.20215759f, 0.18324602f, 0.28140292f, -0.05540372f, 
    0.01974568f, -0.09807599f, 0.14839815f, 0.07154564f, 0.20774648f, 0.15995343f, 0.01607791f, -0.08614875f, 
    0.05762954f, 0.14724053f, -0.21960786f, 0.07739965f, -0.10031306f, 0.06902952f, 0.03899176f, 0.05906067f, 
    -0.01155866f, -0.16989663f, 0.27477127f, 0.26335579f, 0.16353345f, -0.12874343f, 0.13180420f, -0.07223872f, 
    -0.02495473f, 0.02433045f, 0.08733805f, -0.05695416f, -0.10150545f, -0.09562134f, 0.06343465f, 0.28404725f, 
    -0.05894838f, -0.38208455f, 0.04469625f, -0.34406829f, -0.05621836f, 0.05451855f, 0.01975480f, 0.02405832f, 
    0.11048271f, -0.11659902f, -0.09731439f, 0.01446196f, -0.21379280f, 0.04646152f, -0.06488529f, -0.10851739f, 
    0.03613692f, 0.09461094f, -0.29266569f, -0.11430545f, -0.00331052f, 0.00210153f, -0.05428140f, -0.34247929f, 
    -0.14697310f, 0.06359643f, -0.16076612f, -0.15500890f, -0.11785714f, -0.05009051f, 0.12991552f, 0.02775092f, 
    -0.00045094f, 0.21663231f, 0.08303551f, 0.03112640f, 0.40757349f, -0.09364967f, 0.04599006f, -0.11586438f, 
    0.01055424f, 0.11343989f, -0.00300417f, -0.07260621f, -0.00814930f, -0.10126849f, 0.09073791f, 0.03813893f, 
    0.11973582f, 0.05097713f, -0.11313376f, 0.13876687f, -0.07553424f, -0.18412970f, 0.04844085f, -0.05676050f, 
    -0.08391977f, 0.10484128f, -0.02654968f, 0.03965043f, 0.23570794f, -0.03178112f, -0.03774686f, -0.10846590f, 
    0.19901088f, -0.02366949f, -0.05048114f, 0.18681845f, -0.05320247f, 0.39159814f, 0.19656742f, 0.15862156f, 
    0.30786633f, -0.26051587f, -0.18989462f, 0.04563567f, 0.03424732f, 0.05793057f, -0.06874856f, 0.11201806f, 
    0.18749779f, -0.25571397f, 0.06099046f, -0.36563066f, -0.12670489f, 0.01570584f, -0.03943113f, 0.06035182f, 
    -0.03784611f, -0.09207224f, 0.03408945f, 0.11536473f, -0.00767987f, 0.21175043f, 0.03211597f, 0.11629383f, 
    0.19790621f, -0.01242492f, -0.07505400f, 0.03836711f, 0.22322826f, 0.25283259f, -0.39239839f, 0.16371170f, 
    0.19069587f, 0.22858405f, 0.11585690f, -0.09379062f, 0.39148122f, -0.24922599f, 0.07393368f, -0.19812287f, 
    -0.01983680f, -0.14484212f, -0.12613055f, -0.31599545f, -0.21932049f, 0.07801297f, -0.28677288f, -0.37460229f, 
    -0.00306745f, -0.13921875f, -0.02508053f, -0.17254037f, -0.06772775f, 0.16092943f, -0.04393080f, 0.29253224f, 
    0.03777301f, -0.09095745f, 0.00681289f, -0.26887196f, 0.11043894f, -0.20128618f, 0.21626949f, 0.17327188f, 
    -0.02700933f, 0.17902857f, -0.03144722f, 0.11531358f, 0.00428464f, 0.06284048f, 0.08157071f, 0.12681104f, 
    0.28396228f, -0.11788967f, 0.05760432f, 0.37957489f, -0.01524527f, 0.04369941f, 0.02926067f, 0.11106785f, 
    0.11673191f, -0.04165149f, 0.08759077f, 0.03850074f, 0.14794685f, -0.09558466f, 0.15143868f, -0.24858542f, 
    0.10401437f, -0.11053548f, 0.21919838f, -0.01703004f, 0.08971825f, 0.10674501f, -0.24369699f, 0.14681397f, 
    -0.03759467f, -0.07342619f, 0.04542994f, -0.05800703f, 0.02072090f, -0.00865267f, -0.04952019f, -0.06892776f, 
    0.04460608f, -0.03090746f, 0.00616905f, 0.04012686f, 0.01930281f, 0.04673757f, 0.03444851f, -0.02205076f, 
    -0.00009546f, 0.02988761f, -0.04163905f, -0.01331509f, -0.02632931f, -0.06730485f, -0.07014389f, 0.05801529f, 
    0.05271904f, 0.02784297f, -0.02092380f, -0.02475621f, -0.07264400f, -0.02657335f, -0.01465527f, 0.02112379f, 
    -0.05175743f, 0.02959988f, 0.05144953f, 0.03661570f, 0.02287888f, 0.00156608f, -0.01481706f, -0.03698988f, 
    -0.04152774f, -0.04777785f, -0.03741943f, -0.04312898f, -0.01447823f, 0.04758410f, -0.04988019f, 0.02833652f, 
    0.05047020f, -0.06570965f, -0.07455532f, 0.03226210f, -0.06980909f, 0.01518054f, -0.01309003f, 0.00582190f, 
    -0.00489564f, 0.00659704f, -0.08096652f, -0.07126223f, -0.03031503f, -0.07803562f, -0.01085060f, 0.00354368f, 
    0.03492813f, -0.07774375f, 0.00340085f, -0.00280370f, -0.03751168f, -0.04980287f, 0.04851810f, 0.05199968f, 
    -0.07376155f, -0.02210155f, -0.00168671f, 0.00926356f, -0.04860768f, 0.00289999f, 0.03023703f, -0.04844930f, 
    0.03723954f, 0.02486280f, -0.00894463f, -0.01106299f, 0.05296699f, 0.02060844f, -0.04199871f, -0.06108586f, 
    0.03786314f, -0.06733046f, -0.04025803f, 0.04080090f, -0.01501542f, 0.04869043f, 0.04224943f, -0.06264140f, 
    -0.00338483f, 0.04367762f, 0.01928735f, -0.03057440f, -0.05196310f, -0.01794308f, -0.07176726f, 0.03759361f, 
    0.06235236f, -0.05649600f, -0.07742987f, 0.04251466f, -0.02674403f, 0.04417234f, 0.04060535f, 0.04991123f, 
    0.03602887f, -0.02391850f, 0.01352411f, 0.00477244f, -0.00612003f, 0.01873188f, -0.07249866f, -0.05632138f, 
    -0.03228532f, 0.00230489f, -0.06837393f, 0.03562227f, 0.06084529f, -0.01670299f, -0.07198971f, 0.03214632f, 
    -0.00505145f, -0.02223730f, -0.00536615f, -0.07115563f, 0.01883902f, -0.02087794f, -0.01883692f, 0.06330148f, 
    0.04406666f, 0.01767478f, 0.05110909f, -0.03816997f, -0.07789212f, 0.03977467f, 0.03131060f, 0.01483488f, 
    -0.01916673f, 0.01749430f, 0.00037886f, 0.01121674f, -0.04469410f, 0.04918287f, 0.01189024f, -0.00714406f, 
    -0.01187700f, -0.00384310f, 0.01070119f, -0.04607908f, -0.04305961f, -0.05674012f, -0.02232719f, 0.05800980f, 
    -0.06749193f, -0.05380926f, 0.00974892f, -0.03011990f, -0.06834847f, -0.01143658f, 0.00119230f, 0.00403183f, 
    -0.04775421f, -0.01794628f, -0.01073318f, -0.00865875f, -0.06655716f, -0.04752077f, -0.06879646f, 0.03093665f, 
    -0.04215006f, -0.05510316f, 0.00824628f, 0.02434855f, -0.07670610f, -0.02966060f, 0.04389572f, -0.05829301f, 
    0.02467863f, -0.02629679f, 0.03791104f, 0.02103988f, -0.02143977f, -0.04292173f, -0.01245260f, 0.02248623f, 
    -0.37932822f, -0.21871156f, -0.19239858f, 0.03338360f, -0.10426369f, -0.10671095f, 0.13836834f, -0.17013665f, 
    0.01228421f, -0.11978807f, 0.14332162f, 0.13539042f, -0.19861452f, 0.28566617f, 0.26266256f, -0.26227385f, 
    0.20374204f, 0.08879522f, 0.18579912f, -0.13507389f, -0.07740001f, 0.09269640f, 0.07484445f, 0.11998602f, 
    -0.09353418f, 0.31526253f, 0.10722909f, -0.21834244f, 0.02617971f, 0.00649485f, 0.04649169f, -0.05887807f, 
    0.15631616f, -0.12865792f, -0.16277453f, -0.11066927f, 0.01445520f, -0.27050072f, 0.03219704f, 0.16802567f, 
    0.06868657f, 0.27453983f, -0.05405608f, 0.08761025f, 0.00873598f, -0.01237298f, 0.00331573f, -0.29690132f, 
    -0.48538750f, 0.17575558f, 0.13160388f, -0.05274748f, 0.09081543f, 0.14483574f, -0.00921907f, 0.06856252f, 
    0.04467582f, -0.03289132f, 0.05072392f, 0.02163929f, 0.14170724f, 0.30246833f, -0.33110958f, -0.29935774f, 
    0.22169946f, -0.07798050f, -0.26872137f, -0.05030465f, 0.01677434f, -0.02981920f, -0.05676847f, -0.07452134f, 
    -0.45999804f, 0.47934759f, 0.05789326f, 0.13536802f, 0.05106715f, 0.00638460f, 0.10736383f, -0.04977285f, 
    -0.16798636f, 0.13913158f, 0.08866072f, 0.24293177f, 0.16629045f, 0.03545491f, -0.04640333f, 0.08053286f, 
    -0.00884986f, -0.06969671f, -0.10711069f, 0.13934134f, 0.03340906f, 0.03578646f, 0.14665212f, 0.01462470f, 
    0.33742613f, 0.08048598f, -0.04512794f, 0.09354239f, -0.05009342f, -0.06468108f, 0.12710369f, -0.04912258f, 
    -0.06935469f, -0.18913560f, -0.03169873f, -0.14978929f, 0.01853682f, 0.07543570f, -0.02364771f, 0.11877830f, 
    0.16433309f, 0.15750889f, 0.12738846f, 0.09141640f, 0.17295042f, 0.12723254f, -0.09986106f, 0.05886934f, 
    -0.25778651f, 0.10782087f, 0.03883164f, -0.11824844f, 0.12823717f, 0.21925692f, -0.29430223f, 0.05079878f, 
    0.09633288f, 0.04747788f, 0.11337188f, -0.10996090f, 0.34690663f, -0.14150929f, -0.09213349f, -0.16326712f, 
    -0.05679725f, -0.06114565f, -0.19197989f, -0.33259898f, -0.11888915f, 0.07801095f, -0.09497079f, 0.03812935f, 
    -0.16507022f, -0.18184212f, -0.33401507f, -0.18233940f, -0.03203042f, 0.11350264f, 0.10274249f, 0.02008306f, 
    0.22193244f, -0.21123010f, 0.09537417f, 0.06445187f, 0.07336068f, 0.12410950f, 0.22703505f, 0.27541909f, 
    -0.09336843f, 0.05846005f, 0.12005881f, 0.02539357f, -0.00160471f, 0.16112429f, -0.07032700f, 0.14282702f, 
    0.72960311f, -0.12711661f, -0.14606030f, 0.27855366f, 0.01685752f, -0.04531178f, 0.02028663f, 0.12354810f, 
    0.19970763f, -0.04972499f, 0.02732583f, 0.02740972f, 0.36978531f, 0.22418234f, 0.11330626f, 0.18776251f, 
    -0.14649665f, -0.27478120f, 0.18181421f, 0.11677966f, -0.04471305f, 0.14699920f, -0.10092004f, 0.08892987f, 
    -0.12122958f, 0.10562415f, 0.10632835f, 0.30311555f, -0.05703145f, 0.08582696f, -0.01904919f, -0.02429996f, 
    0.03229891f, 0.07001871f, -0.03672890f, -0.05371181f, 0.64732319f, -0.06605964f, 0.11419334f, 0.06872647f, 
    -0.21952584f, -0.15068808f, 0.02758129f, 0.01869800f, -0.13442363f, -0.06191368f, 0.06918912f, 0.09479631f, 
    0.22221479f, -0.06242098f, 0.22166912f, -0.01789855f, -0.18845423f, 0.10361585f, 0.24732621f, 0.00253142f, 
    -0.07593125f, 0.09129471f, -0.12806517f, 0.06753442f, 0.31608406f, 0.05044193f, 0.03744099f, 0.09409259f, 
    0.20165464f, -0.01175389f, -0.01613225f, 0.17009336f, 0.20392510f, -0.01292577f, -0.24247746f, -0.12768197f, 
    0.08922519f, 0.61146098f, -0.06690107f, -0.28075993f, 0.06783456f, -0.08022416f, -0.13502549f, 0.11367599f, 
    0.06944643f, 0.06828205f, -0.12545650f, -0.07931281f, 0.35142094f, 0.05107060f, -0.08117086f, -0.46588939f, 
    0.10212679f, -0.11758946f, -0.11229096f, -0.07281411f, -0.09448246f, -0.07057390f, -0.09085982f, 0.10528673f, 
    0.05192900f, -0.04572694f, 0.29281086f, 0.12080836f, -0.09016808f, 0.11732461f, -0.03312740f, -0.14924462f, 
    -0.07851934f, 0.03971506f, 0.07652885f, 0.10309522f, 0.18429394f, -0.16248897f, 0.21672645f, -0.00446516f, 
    0.06690536f, 0.05970668f, -0.05555479f, 0.09243435f, -0.01563372f, 0.08130791f, 0.00110984f, -0.12232556f, 
    0.55935216f, 0.04804059f, -0.18533584f, 0.15046361f, 0.04135066f, -0.11279383f, 0.00219738f, 0.18849722f, 
    0.02693104f, 0.04098829f, -0.07675231f, -0.18633988f, 0.16166228f, 0.29864851f, 0.07458600f, 0.15731595f, 
    0.19110464f, 0.02546092f, 0.20663036f, 0.17335898f, 0.00816644f, 0.04020686f, -0.01947803f, 0.02081638f, 
    0.05689235f, 0.36126867f, -0.27439907f, -0.00228401f, 0.00425971f, 0.06759981f, -0.13205199f, 0.08772009f, 
    0.02802521f, 0.16159689f, -0.04690501f, -0.03161584f, 0.33656320f, -0.12640467f, 0.09761821f, -0.13156904f, 
    0.11946946f, 0.09244879f, -0.09236927f, -0.00052030f, -0.15851019f, 0.20014423f, 0.05410182f, -0.11937138f, 
    0.23569518f, -0.14970438f, -0.16699958f, -0.28116262f, -0.01127762f, -0.02490905f, 0.14654753f, 0.14834656f, 
    0.01946004f, -0.03079726f, -0.09554605f, -0.09400682f, -0.02896928f, -0.35593709f, 0.34789521f, 0.32083338f, 
    -0.11964189f, 0.16259484f, -0.04372448f, 0.11933681f, -0.17319946f, -0.00072360f, -0.08367692f, 0.10083264f, 
    0.26268491f, -0.40826738f, -0.29122174f, 0.18091707f, -0.11525746f, -0.05646085f, 0.17835070f, -0.09153283f, 
    0.03822849f, -0.06916978f, -0.07582033f, 0.03512433f, 0.15507692f, 0.04822602f, 0.16406047f, -0.01442771f, 
    0.02367716f, -0.00532030f, 0.09885284f, -0.07680114f, -0.12563348f, 0.07012930f, 0.12795179f, -0.05085582f, 
    0.05402451f, 0.02787592f, -0.01961120f, 0.06182836f, -0.06617343f, 0.06257936f, -0.05609691f, -0.06126875f, 
    -0.06600225f, -0.01489885f, -0.04291866f, -0.05660740f, -0.03088578f, -0.06002626f, 0.03348713f, 0.05166955f, 
    0.00805652f, -0.06867841f, -0.00083013f, -0.07374657f, -0.04603560f, -0.03787751f, -0.06713506f, -0.02210591f, 
    0.00995158f, 0.02541795f, -0.05055292f, -0.03776669f, 0.02654891f, -0.07819858f, 0.03919689f, -0.07284515f, 
    -0.07240994f, 0.04746541f, -0.03865514f, 0.06484188f, -0.01797799f, -0.04347310f, -0.04045602f, -0.01059044f, 
    -0.06463787f, 0.03245657f, 0.03863170f, 0.03825836f, -0.06084168f, -0.04476152f, -0.04554169f, 0.04261588f, 
    0.01913133f, -0.05953511f, -0.05338475f, -0.00461144f, -0.01158297f, 0.06617483f, 0.05534782f, 0.04951738f, 
    -0.06297538f, 0.02017655f, 0.06681305f, 0.05095992f, -0.04320467f, -0.04506959f, 0.05590690f, 0.02708150f, 
    -0.05430759f, 0.00677792f, -0.07437096f, -0.07669872f, -0.03922259f, -0.01771377f, -0.03890561f, 0.05718076f, 
    -0.03529035f, -0.02112131f, 0.05943276f, 0.04693354f, 0.04101362f, 0.05662809f, -0.00958097f, 0.03714228f, 
    -0.01114850f, -0.04695691f, 0.04892988f, 0.05920742f, -0.03008828f, 0.02989519f, 0.00367927f, -0.02029919f, 
    -0.06757027f, 0.01335660f, 0.00723468f, -0.03643155f, -0.01818278f, -0.05483245f, -0.02045885f, 0.03191600f, 
    0.03980634f, -0.06584401f, -0.00529307f, -0.00383100f, 0.06444899f, -0.06596139f, 0.03355605f, 0.02091845f, 
    0.03672120f, -0.02503508f, -0.00156523f, 0.02490733f, -0.03070574f, 0.01987533f, -0.05019969f, -0.06701605f, 
    -0.04152274f, -0.03731168f, 0.03728065f, -0.04505061f, 0.01908441f, 0.04153835f, 0.03096602f, 0.03790408f, 
    0.04169530f, -0.02320871f, 0.04237475f, 0.00860309f, -0.07015845f, -0.06973533f, 0.02559151f, 0.02535844f, 
    -0.04782950f, 0.02900833f, -0.04065526f, -0.01508893f, 0.00113286f, -0.05674582f, 0.05235285f, -0.07356542f, 
    0.03991470f, 0.05838031f, 0.01285680f, 0.00844964f, -0.01669167f, -0.06387344f, -0.01246390f, 0.03329958f, 
    -0.08009953f, -0.04568977f, 0.01012483f, 0.02035697f, -0.06934682f, -0.06547336f, -0.00302068f, -0.05282361f, 
    0.01340677f, 0.04168885f, 0.03095050f, -0.01371740f, -0.03046636f, -0.00334951f, 0.04084511f, -0.06327289f, 
    -0.04439275f, 0.03688156f, -0.04032946f, -0.06670328f, 0.02496311f, -0.06365421f, 0.01213291f, -0.03131819f, 
    0.01255795f, -0.03171834f, -0.01729570f, -0.01055120f, -0.00527457f, -0.00271102f, -0.00799653f, -0.04630843f, 
    -0.06883943f, 0.01427516f, 0.02001794f, 0.00053133f, -0.01525798f, 0.02452415f, -0.07770716f, -0.07790162f, 
    -0.04984210f, -0.02814040f, 0.00196580f, 0.04506287f, 0.03215689f, 0.02980970f, 0.02557568f, -0.06881364f, 
    0.04449312f, -0.05903589f, 0.05144881f, -0.07968315f, -0.07236204f, -0.05215015f, -0.00675685f, -0.07785826f, 
    0.04847871f, -0.00849867f, -0.03640722f, -0.00664182f, -0.07144444f, 0.04786237f, 0.01732307f, -0.01735570f, 
    -0.02322955f, 0.04482142f, 0.03866312f, 0.05678290f, -0.05274883f, -0.05088718f, 0.05829296f, 0.01829949f, 
    -0.03514347f, -0.03555420f, -0.02042633f, -0.06578419f, 0.05141077f, -0.08211039f, 0.02236008f, 0.02885646f, 
    0.04194150f, 0.04476930f, 0.01201316f, 0.01741274f, 0.02085920f, -0.05290912f, 0.02313895f, 0.03896395f, 
    0.06076323f, -0.07067533f, -0.05311698f, 0.04474905f, -0.03752718f, 0.00732202f, 0.00690235f, -0.02065967f, 
    -0.05873057f, -0.05647443f, 0.01890611f, -0.06875240f, -0.04489798f, 0.01365432f, 0.01105007f, 0.03416334f, 
    0.04018770f, 0.02173642f, 0.03251056f, -0.04983161f, 0.04748144f, -0.03317596f, -0.01692603f, -0.00487602f, 
    -0.05009509f, 0.04149115f, 0.03806705f, 0.00483666f, -0.05009225f, -0.01950544f, -0.07056621f, 0.02160399f, 
    -0.06228118f, -0.04739609f, 0.03493091f, -0.04628619f, -0.01049689f, 0.05849349f, 0.00819888f, 0.02984584f, 
    0.03984862f, -0.07923559f, 0.01288896f, -0.04880769f, 0.05312386f, 0.04492848f, -0.05941088f, -0.01208922f, 
    -0.01694507f, -0.07035830f, 0.05321359f, 0.01195688f, 0.00089892f, -0.03811548f, 0.02899506f, 0.00432832f, 
    0.01194282f, 0.00795865f, 0.02513374f, -0.07152901f, 0.03497138f, -0.03273660f, 0.01688391f, -0.04181304f, 
    -0.06933904f, -0.05656394f, 0.02831390f, -0.02106623f, -0.01838379f, -0.05148060f, 0.03184412f, 0.04250169f, 
    0.02740875f, -0.01183250f, 0.04845770f, 0.05933829f, 0.00011253f, -0.05892245f, -0.00036908f, 0.00170005f, 
    -0.07066974f, -0.06883180f, -0.06512833f, -0.07896516f, -0.07585749f, -0.02281048f, 0.01578608f, 0.05224687f, 
    -0.01481273f, 0.00291310f, 0.02387478f, -0.03699322f, -0.07267271f, -0.00375373f, -0.00020112f, 0.05286739f, 
    -0.04340328f, -0.03083725f, -0.03375142f, -0.01725175f, -0.07770587f, -0.06662438f, 0.00468367f, -0.05913657f, 
    -0.05483754f, 0.06142914f, 0.02179020f, -0.02272531f, 0.00686804f, 0.00737018f, 0.01285874f, 0.05084504f, 
    -0.07090115f, -0.02721616f, -0.03609222f, -0.03785394f, -0.00261259f, -0.07844156f, -0.03795914f, 0.03130573f, 
    -0.02879801f, -0.02483036f, -0.06790034f, 0.05873148f, 0.01898217f, -0.00703633f, -0.01754044f, 0.04341338f, 
    -0.03040463f, -0.03256774f, 0.00557760f, 0.04761276f, -0.03715776f, 0.01218874f, 0.03999164f, -0.01175441f, 
    -0.01908706f, -0.03087696f, -0.01493251f, 0.03359444f, -0.06175310f, -0.06273056f, -0.00036256f, -0.01632829f, 
    0.02506777f, -0.07777347f, 0.04780910f, -0.01781312f, -0.05490141f, 0.04218870f, 0.03419517f, -0.07685941f, 
    0.45286733f, -0.14317042f, 0.07098939f, -0.24839112f, -0.02722177f, -0.02640950f, 0.00216823f, 0.02328750f, 
    0.04963318f, 0.09819840f, 0.04980759f, -0.02443108f, -0.30054674f, -0.16809018f, 0.07167748f, 0.03895649f, 
    -0.06719211f, 0.03704598f, -0.29551491f, -0.03759386f, 0.26198682f, -0.07455451f, -0.01060785f, -0.08137605f, 
    -0.06501079f, 0.27059919f, 0.09441199f, 0.19180146f, 0.16126278f, 0.10693792f, -0.11747248f, 0.07978410f, 
    -0.03122902f, 0.09358207f, -0.11008788f, 0.12906605f, -0.01280406f, -0.03164972f, 0.01810528f, -0.09589683f, 
    0.00623328f, 0.18001628f, 0.22317247f, 0.08448163f, 0.10813167f, 0.15492114f, 0.00304564f, 0.20515710f, 
    0.58929431f, -0.47456503f, 0.20968896f, 0.07237656f, 0.03594703f, -0.05558532f, -0.12160335f, -0.08280008f, 
    0.09894067f, 0.00248261f, 0.06575482f, 0.07675233f, 0.36393455f, 0.25331214f, 0.00989667f, 0.33572099f, 
    -0.04885206f, 0.01331970f, 0.20066158f, 0.14245833f, 0.06395833f, 0.11230458f, 0.14837341f, 0.13352242f, 
    0.34837070f, -0.25780374f, 0.15401882f, -0.09393144f, 0.09574559f, -0.00544245f, -0.12252983f, -0.25973701f, 
    0.06379236f, -0.07143534f, -0.07782885f, -0.10587215f, -0.39140055f, 0.21812239f, -0.14738998f, -0.14682473f, 
    -0.19508021f, -0.11131335f, -0.08322138f, -0.09092152f, 0.07217357f, -0.03496701f, -0.27973041f, -0.12720163f, 
    -0.31165496f, 0.12584184f, 0.26569614f, -0.07716440f, 0.04226493f, 0.05430067f, -0.08896370f, -0.08205938f, 
    0.03006855f, -0.02711529f, -0.02551274f, 0.16347550f, -0.20376883f, -0.03696667f, 0.11601826f, 0.15355052f, 
    0.02157476f, -0.02962717f, -0.09153229f, -0.06224228f, -0.00388065f, -0.13927574f, 0.14935003f, -0.04192913f, 
    0.15334792f, -0.18999025f, 0.15382953f, 0.11370190f, 0.08035623f, -0.01761259f, 0.12095697f, -0.26211128f, 
    -0.02101887f, -0.30318984f, -0.18933098f, 0.09357616f, 0.26842684f, 0.44130173f, -0.03956411f, 0.11201701f, 
    -0.08052885f, -0.00329751f, -0.05142924f, 0.06532002f, 0.06700877f, 0.06898565f, 0.17221093f, 0.04742729f, 
    -0.09102219f, 0.69612491f, 0.47533205f, 0.20742145f, 0.07957605f, -0.02740290f, -0.09235388f, 0.00513795f, 
    -0.03416410f, 0.11139767f, 0.22112101f, 0.14505418f, -0.15919684f, 0.02200322f, -0.31438521f, 0.08839698f, 
    0.13386458f, -0.06989445f, 0.00124509f, -0.15752597f, 0.00365141f, -0.10876852f, 0.00327721f, 0.01983866f, 
    -0.12319596f, 0.31674752f, -0.13513584f, -0.41138455f, 0.12340273f, 0.10287889f, 0.00272730f, -0.24398360f, 
    -0.19938159f, 0.08162875f, 0.11344205f, -0.16144538f, -0.37598494f, 0.21716908f, -0.31072658f, 0.10769733f, 
    -0.12211277f, 0.06593157f, 0.02177677f, 0.04616930f, 0.16082491f, -0.14500986f, 0.32123199f, -0.00471778f, 
    0.00654445f, 0.05026758f, 0.02723861f, 0.04963964f, -0.03722181f, -0.04827287f, -0.01159353f, -0.07795045f, 
    -0.00181393f, -0.06572369f, -0.07612174f, -0.01092511f, -0.05925981f, 0.04869793f, 0.02105127f, -0.08216183f, 
    -0.05538509f, -0.01922560f, -0.07242631f, 0.04645760f, 0.04744666f, 0.04592393f, -0.01917968f, 0.01020279f, 
    -0.00541877f, 0.03007754f, 0.00725472f, -0.02316909f, 0.00106083f, -0.06598430f, -0.02987614f, -0.03378583f, 
    -0.04319228f, 0.04066723f, 0.06225723f, -0.00326457f, -0.05120927f, -0.04238474f, -0.00408511f, 0.03165592f, 
    0.06809645f, 0.06781152f, -0.07663206f, -0.07323352f, -0.06883915f, -0.04911830f, -0.04361298f, -0.03502040f, 
    -0.04060240f, 0.01031313f, 0.02063814f, -0.01781409f, 0.00539989f, -0.01621967f, -0.04912243f, 0.06304882f, 
    -0.07955882f, -0.00117023f, -0.04727420f, -0.01184290f, 0.02808772f, 0.02972744f, -0.02715083f, 0.02246437f, 
    -0.03711290f, 0.04861838f, -0.06510428f, -0.00672605f, -0.03964453f, -0.04771207f, -0.06185265f, 0.06416471f, 
    -0.04581530f, 0.00151799f, -0.01455977f, 0.04401686f, -0.01803238f, 0.04287243f, 0.01231973f, 0.03764999f, 
    -0.00544042f, -0.02990281f, -0.06838568f, 0.00710351f, 0.05247224f, -0.00949170f, 0.00379270f, 0.03949143f, 
    -0.06395641f, 0.04659806f, -0.02607431f, 0.03219302f, -0.07632466f, -0.01549971f, -0.07491712f, 0.02428693f, 
    -0.07670517f, -0.06567969f, -0.06283601f, -0.02432393f, 0.01408244f, 0.03668689f, 0.06172966f, -0.07444547f, 
    0.02461892f, -0.05465645f, 0.02952444f, -0.05338816f, 0.03943449f, -0.06322633f, 0.05625331f, 0.00037200f, 
    0.02969628f, -0.07495717f, -0.03523716f, -0.07878286f, 0.02711041f, -0.05038555f, 0.06018442f, 0.04557059f, 
    0.03585656f, 0.01071056f, 0.04297264f, -0.02616498f, -0.00992693f, -0.01772007f, -0.06459199f, 0.01864422f, 
    -0.05421434f, -0.02752881f, 0.06152279f, -0.03136657f, 0.02795707f, -0.07183761f, -0.06818901f, -0.04050586f, 
    -0.07924370f, 0.04075135f, -0.05765060f, 0.03820956f, -0.02483023f, 0.02101408f, -0.08066750f, -0.03869018f, 
    -0.03469168f, 0.01189073f, 0.02040460f, -0.05658055f, 0.06232312f, -0.01051216f, 0.01047970f, -0.04520958f, 
    0.02570341f, -0.01947271f, 0.02550415f, -0.05163018f, -0.07453101f, 0.00696451f, -0.06014533f, -0.05066671f, 
    -0.04986200f, -0.02033958f, -0.04497215f, 0.00697656f, 0.02933719f, 0.03869540f, -0.05788324f, -0.01425157f, 
    -0.01203308f, 0.03360474f, -0.00394720f, -0.06471403f, 0.02340640f, 0.01979152f, -0.05413259f, -0.06456614f, 
    -0.06887309f, -0.05984811f, -0.06496879f, 0.01469431f, -0.02750308f, -0.04333142f, -0.03794858f, -0.07728767f, 
    0.00348990f, 0.03861954f, 0.04648917f, 0.03367234f, 0.04014927f, 0.04652263f, 0.05618086f, -0.05082783f, 
    0.46121177f, 0.00435255f, 0.01372076f, -0.02224501f, -0.02910210f, -0.05029898f, -0.01413933f, -0.08330665f, 
    -0.12771431f, 0.01136203f, 0.03501510f, -0.05951248f, 0.38407695f, 0.11551592f, 0.19767308f, 0.23181549f, 
    0.34679243f, 0.26920885f, 0.02197972f, -0.08683594f, -0.19727615f, -0.11371411f, -0.24598202f, -0.09408409f, 
    0.20678286f, 0.17756997f, 0.24658072f, 0.19315930f, 0.41637981f, 0.22810103f, -0.11101452f, 0.06516691f, 
    -0.04404106f, 0.12042299f, -0.02043725f, -0.12465636f, 0.16228454f, 0.17900863f, -0.05273192f, 0.19258375f, 
    0.16958758f, 0.17095536f, 0.16105916f, -0.03675608f, -0.18408188f, -0.20126314f, 0.06281247f, 0.06023742f, 
    0.20697187f, -0.30411151f, 0.03902876f, -0.09983554f, 0.11053846f, 0.08703264f, 0.15854876f, -0.03524242f, 
    0.03953842f, 0.04442219f, -0.01636159f, 0.16606422f, -0.10787587f, -0.16934615f, -0.09483095f, -0.11002205f, 
    0.04611684f, -0.17084695f, 0.02399210f, 0.08085488f, 0.16827354f, -0.09035425f, -0.02693523f, 0.00817050f, 
    -0.03129943f, 0.25289345f, -0.09771394f, -0.42848635f, -0.21244600f, -0.17503777f, 0.08007228f, -0.05235880f, 
    -0.13773550f, 0.01993863f, 0.07384072f, -0.01246949f, 0.14722246f, 0.22460017f, -0.11969397f, 0.30423063f, 
    0.00024749f, -0.06562752f, -0.05557779f, 0.04585626f, -0.11347059f, 0.11961406f, -0.03024795f, -0.08901759f, 
    -0.83168399f, 0.44643253f, 0.21281025f, -0.10271581f, 0.13790125f, 0.03816204f, 0.02310909f, 0.02214557f, 
    -0.11622098f, -0.05619174f, -0.06054072f, -0.00200204f, 0.05814133f, 0.26467258f, -0.01426894f, 0.41344991f, 
    0.33335072f, 0.09193882f, 0.09126351f, 0.08659767f, -0.11677473f, 0.06800761f, 0.22434533f, 0.02219934f, 
    0.08368140f, -0.30474204f, 0.14278702f, -0.17257570f, 0.11020298f, 0.13579974f, 0.11225323f, 0.00190240f, 
    -0.06619380f, 0.05566666f, 0.00819343f, 0.14911763f, 0.18261705f, 0.27669731f, -0.20328715f, 0.01252917f, 
    -0.01828040f, -0.01362358f, 0.00575312f, -0.15096498f, 0.06325773f, -0.06131912f, -0.17779955f, -0.15788364f, 
    -0.38301504f, 0.02457530f, 0.11348719f, 0.13130286f, -0.09327333f, 0.08631159f, 0.03733173f, -0.00052653f, 
    0.01849651f, 0.09274317f, 0.15336782f, -0.11848209f, -0.57793337f, 0.16702665f, -0.38203558f, -0.32140437f, 
    0.05333662f, -0.09358492f, -0.06457462f, 0.18672477f, 0.05257941f, -0.02455237f, -0.07281140f, -0.13168249f, 
    -0.81344253f, -0.02380053f, 0.02402868f, -0.37573418f, -0.04154492f, -0.09517569f, -0.16404526f, -0.02214227f, 
    0.06137905f, -0.07125676f, -0.09956351f, 0.11987355f, 0.12341184f, -0.03056411f, -0.14843957f, 0.06851774f, 
    0.08151759f, -0.09456638f, 0.05024332f, -0.04554673f, -0.00854407f, -0.06679998f, -0.23309778f, -0.04213829f, 
    0.23998505f, -0.18373543f, 0.17815521f, -0.12221998f, 0.06029268f, 0.04702156f, 0.11645015f, -0.08878025f, 
    0.06411567f, 0.11261029f, -0.18229350f, -0.15247795f, 0.31204262f, 0.17353666f, 0.25420123f, -0.06649803f, 
    -0.03727449f, 0.02049431f, 0.10595904f, 0.06550148f, 0.02992014f, -0.10341710f, -0.10279839f, -0.00414556f, 
    -0.31386921f, 0.28156725f, 0.22490908f, 0.12067227f, -0.11876006f, -0.11160069f, 0.05695728f, 0.05446383f, 
    0.07199654f, -0.16970719f, 0.12059012f, 0.04727132f, 0.38142908f, 0.07352703f, 0.10064296f, 0.44122547f, 
    0.00901463f, -0.20347643f, 0.07326715f, 0.21695484f, -0.11138421f, 0.11093993f, -0.02940269f, -0.01239045f, 
    0.18602762f, 0.36196840f, 0.10503251f, 0.30193216f, -0.02944832f, 0.07051283f, 0.04092377f, 0.05783762f, 
    0.01003535f, 0.02023889f, 0.07981749f, 0.05850936f, -0.32505792f, 0.02299975f, -0.03596701f, 0.11603804f, 
    -0.02800786f, 0.11191618f, -0.03008650f, -0.06902554f, -0.03706752f, 0.05243879f, -0.00893845f, -0.00254876f, 
    -0.05094123f, -0.27527592f, -0.00393826f, 0.11983541f, 0.05988820f, -0.08280104f, -0.02760706f, 0.15723513f, 
    -0.00042020f, -0.05296524f, 0.01208706f, 0.11969841f, -0.15167896f, 0.14318728f, 0.07564644f, -0.35198608f, 
    -0.05477386f, 0.15596987f, 0.07641487f, -0.02437673f, 0.08956399f, -0.14442977f, 0.09835082f, 0.04889026f, 
    0.63470989f, -0.03917764f, 0.07589540f, 0.34187388f, -0.18261638f, 0.07564892f, -0.00214922f, 0.06975029f, 
    0.09809316f, 0.11883935f, 0.11352478f, 0.02535066f, 0.17066781f, 0.18045297f, 0.23038904f, 0.31584591f, 
    -0.04423290f, 0.00026708f, 0.12028436f, -0.01028450f, -0.00563137f, -0.00775557f, 0.10709994f, -0.05188840f, 
    -0.04090791f, 0.12753630f, -0.11644837f, -0.10623416f, -0.17469002f, 0.01066101f, 0.10628848f, 0.24731150f, 
    0.04651675f, 0.19199964f, 0.03064238f, -0.01819114f, -0.11436928f, -0.05440548f, -0.09069844f, 0.11580256f, 
    -0.09237892f, 0.14680345f, 0.14213847f, 0.22581530f, 0.03620171f, -0.06560763f, 0.12771146f, 0.06110938f, 
    0.29576451f, 0.11443534f, -0.42123988f, -0.39182514f, 0.02128135f, -0.12601091f, 0.02938763f, -0.01276038f, 
    0.02242194f, 0.02619271f, -0.07017560f, 0.14576265f, 0.29112425f, -0.17971021f, -0.01609404f, -0.10045527f, 
    -0.10948384f, -0.03516789f, 0.08515231f, -0.12719922f, 0.15155517f, -0.19511726f, 0.02876739f, 0.01197709f, 
    -0.08227876f, -0.15306164f, -0.12088931f, 0.11294340f, 0.15018171f, -0.06936712f, 0.01856256f, -0.01408083f, 
    0.15758504f, 0.23269428f, -0.00175567f, -0.08712844f, -0.27826664f, -0.10842474f, 0.00469964f, -0.40938956f, 
    0.21193987f, -0.00403783f, -0.05367800f, -0.05994578f, -0.05293106f, 0.09588668f, -0.16265164f, -0.13628229f, 
    -0.03896554f, -0.09411083f, 0.02068073f, 0.04690530f, 0.03727832f, 0.07522267f, -0.03963485f, 0.02988765f, 
    -0.01109146f, -0.00115695f, 0.04228206f, -0.00942711f, -0.02973579f, -0.03831789f, 0.01272836f, -0.01749060f, 
    0.05494736f, 0.07581118f, -0.06764706f, -0.05576463f, -0.00222251f, -0.09952271f, -0.02880583f, -0.03632516f, 
    0.01819466f, -0.07121541f, -0.01044422f, 0.03299921f, -0.03309373f, -0.04486528f, -0.06929715f, 0.00831409f, 
    -0.04300772f, 0.05773059f, -0.06410922f, 0.02302620f, 0.06906457f, -0.04936531f, -0.02599095f, -0.07638925f, 
    0.01624615f, -0.02147161f, 0.03026529f, -0.02829190f, -0.04511092f, 0.02815576f, -0.05941327f, -0.05934053f, 
    -0.04341133f, 0.03509805f, -0.03437433f, -0.03760928f, -0.01374596f, 0.05620572f, -0.05073135f, -0.06361264f, 
    -0.08813111f, -0.08043864f, -0.05084972f, -0.04530084f, 0.01587044f, -0.02406702f, 0.02729269f, 0.00331663f, 
    -0.02591781f, 0.01271403f, 0.01277159f, -0.02446930f, -0.07386400f, -0.07019655f, -0.01310197f, 0.04656424f, 
    -0.01210546f, 0.00051000f, -0.03641246f, 0.01014008f, 0.01010605f, 0.03369936f, -0.04553377f, 0.01167023f, 
    -0.00248822f, 0.03038241f, 0.01265287f, -0.06939266f, -0.08218507f, 0.04573413f, -0.00941416f, -0.04430735f, 
    -0.03861308f, -0.00678356f, -0.04270858f, 0.00044862f, 0.02254809f, -0.00857163f, 0.01929915f, 0.02009845f, 
    0.02287531f, -0.04892379f, 0.01345850f, 0.04141119f, 0.01763319f, -0.09778123f, 0.05487667f, -0.03815838f, 
    0.02434517f, -0.02667066f, -0.05134420f, 0.00148501f, -0.03887369f, 0.00972828f, -0.05954379f, -0.09534000f, 
    0.05106763f, -0.00231674f, -0.06761715f, 0.01652815f, 0.04607116f, -0.07182108f, -0.05495875f, -0.07374250f, 
    -0.07958885f, -0.01866444f, 0.00078790f, 0.00848309f, 0.05265746f, -0.03228115f, 0.03329428f, 0.03217433f, 
    -0.04890662f, -0.06900455f, 0.00969365f, 0.03666667f, -0.04639848f, 0.02592035f, 0.03081953f, -0.04842018f, 
    -0.07770425f, -0.03947044f, -0.04979035f, -0.03697514f, 0.00921575f, -0.08294265f, -0.02655056f, 0.02656806f, 
    -0.02918471f, -0.03258220f, 0.08351608f, 0.00364263f, -0.04099603f, -0.05320570f, 0.02923462f, -0.01584542f, 
    0.00730860f, 0.00596904f, -0.06846640f, 0.06088715f, -0.00764909f, -0.03163254f, -0.05512103f, -0.04578374f, 
    -0.01924771f, 0.04089500f, -0.00971788f, -0.07205745f, 0.02189357f, 0.00743104f, -0.01127428f, 0.03115726f, 
    0.03197374f, -0.02486707f, -0.03756926f, -0.02856480f, 0.02250739f, -0.04668859f, -0.05185689f, -0.01172964f, 
    -0.00651599f, 0.02694291f, -0.04635264f, -0.05641377f, -0.03154534f, -0.03780940f, -0.04502320f, -0.07655709f, 
    0.01930247f, -0.03177432f, 0.04537139f, 0.01494628f, -0.07287142f, -0.04307771f, 0.03540426f, -0.00009690f, 
    -0.43839356f, 0.46049508f, 0.23461263f, 0.21419603f, 0.14336640f, -0.05569618f, -0.12853931f, 0.17683882f, 
    0.19836988f, 0.12586717f, -0.14399165f, -0.10058030f, 0.07997308f, 0.26465794f, -0.16061455f, 0.24283530f, 
    0.11654317f, -0.01824505f, -0.13176170f, 0.07782832f, 0.07760264f, 0.14791322f, 0.04956771f, -0.13346197f, 
    0.38718763f, -0.05774133f, -0.02604167f, 0.09333918f, 0.10424472f, -0.03424156f, -0.06028114f, -0.12065150f, 
    -0.12240002f, 0.18554221f, 0.12907843f, 0.01839878f, 0.20089562f, 0.01104737f, 0.15870678f, -0.12240318f, 
    0.02629157f, -0.14131394f, 0.09020609f, -0.10539808f, -0.00178226f, -0.02029271f, 0.24717733f, 0.59487116f, 
    -0.35240683f, 0.07154942f, 0.01823696f, -0.08572706f, 0.36651471f, -0.00824411f, 0.03422423f, 0.00864676f, 
    -0.03109286f, -0.03996770f, -0.11166163f, 0.06201919f, -0.51907408f, -0.21885684f, 0.30102548f, 0.03891959f, 
    -0.01390649f, -0.09472410f, -0.08024800f, 0.09510500f, 0.04204624f, 0.17281356f, 0.05116589f, 0.01995099f, 
    -0.14366119f, 0.11023230f, 0.06264534f, -0.09449569f, 0.23671076f, 0.22962603f, 0.06246985f, 0.29348180f, 
    0.19918500f, 0.04303032f, 0.16418353f, -0.01979947f, 0.28813624f, 0.01662347f, 0.23803215f, 0.48448730f, 
    0.25901332f, 0.05022090f, 0.13669480f, -0.07496496f, -0.00767751f, -0.16717935f, -0.06475640f, -0.11143577f, 
    -0.08417648f, -0.00730202f, -0.09140048f, -0.04610538f, -0.03580350f, 0.12103058f, 0.25575811f, 0.10058375f, 
    0.08416384f, 0.30889186f, -0.01051647f, 0.36498263f, 0.23015495f, -0.13619798f, -0.19000129f, -0.52831119f, 
    0.05003956f, 0.04490087f, -0.24504799f, -0.13607983f, 0.12597404f, -0.09032817f, -0.03439309f, 0.02755076f, 
    -0.12874822f, 0.07994011f, 0.06360572f, -0.03101538f, -0.04244526f, -0.13502471f, 0.29496703f, -0.01933904f, 
    -0.09975228f, 0.03891101f, 0.00470716f, 0.15912302f, -0.62892765f, -0.04376656f, 0.20253089f, 0.09417604f, 
    0.03340223f, 0.03322813f, 0.07590692f, 0.28912562f, 0.30590135f, -0.06145259f, 0.40051180f, 0.33342478f, 
    0.37498060f, -0.39496446f, -0.08904632f, 0.31583002f, 0.04565494f, 0.08324465f, -0.09007960f, -0.13607903f, 
    -0.03747629f, -0.02291800f, -0.19546388f, 0.17452249f, 0.04317004f, 0.09163788f, -0.00368869f, -0.10740568f, 
    0.11209112f, 0.02916221f, 0.09154617f, 0.04454462f, 0.01145571f, 0.04382728f, -0.12100226f, -0.07672939f, 
    -0.16334282f, 0.07736043f, 0.07700723f, -0.10306215f, -0.26172271f, -0.11191551f, 0.08172463f, 0.26055652f, 
    0.06498434f, -0.02605191f, -0.11374753f, -0.06220523f, 0.43036804f, 0.11916067f, 0.16832407f, 0.30518275f, 
    -0.02894705f, 0.16839987f, -0.16600598f, 0.15265980f, -0.01234467f, -0.12176847f, 0.21961559f, 0.22578967f, 
    0.04532149f, 0.03615196f, -0.26936674f, 0.31031609f, -0.06459355f, -0.00866056f, -0.02798712f, -0.02921889f, 
    0.19009139f, 0.01136438f, 0.14892039f, -0.00544794f, 0.20805477f, -0.13222393f, 0.10244696f, -0.01804536f, 
    -0.23940012f, -0.12766717f, -0.00590717f, 0.11872109f, -0.24403211f, -0.11400019f, -0.08564471f, 0.11411817f, 
    -0.09651554f, -0.20899037f, 0.07753559f, -0.63997227f, 0.11985961f, 0.24225600f, 0.10846388f, 0.09340842f, 
    -0.04162310f, -0.03706240f, 0.05692698f, -0.03352666f, 0.28552896f, 0.12068562f, -0.04962822f, -0.35974082f, 
    0.03882433f, -0.22442898f, -0.21905063f, 0.01315527f, -0.03421469f, -0.03211330f, -0.07018341f, -0.04261102f, 
    0.60189009f, -0.04511381f, -0.09760893f, -0.20095405f, -0.03110276f, 0.14115195f, -0.23517789f, -0.05054820f, 
    0.08364445f, 0.08013880f, -0.08768187f, 0.14598897f, 0.25701249f, -0.08903679f, 0.03032732f, -0.27737045f, 
    0.20616940f, -0.05127049f, 0.02682167f, -0.24242406f, 0.09347544f, -0.03990371f, 0.05710310f, 0.20389663f, 
    0.20557536f, -0.16323437f, 0.12124817f, 0.30220389f, -0.12767616f, -0.06057759f, -0.02288491f, -0.30371621f, 
    -0.08085313f, 0.07494920f, 0.01197077f, 0.04925238f, 0.19858234f, -0.11012185f, 0.13862976f, -0.26053995f, 
    0.08577638f, 0.13616243f, 0.16637291f, 0.04969522f, -0.08287657f, 0.17615864f, 0.14067587f, 0.15809055f, 
    0.20441386f, 0.12863463f, -0.16549581f, 0.07509538f, 0.12421685f, -0.13891976f, -0.11246159f, 0.16715662f, 
    0.20849432f, 0.11550640f, -0.00955516f, -0.01948183f, 0.32818797f, 0.06538629f, -0.01269068f, -0.46666563f, 
    0.04065140f, -0.14352718f, 0.13680737f, 0.23590900f, 0.11196651f, 0.22056107f, 0.13843812f, 0.22916147f, 
    0.24636739f, 0.02086886f, -0.11524314f, 0.02619166f, 0.11784883f, 0.09256899f, -0.30342141f, 0.11341436f, 
    0.16243987f, 0.20021477f, 0.06095132f, 0.07297871f, 0.26353195f, -0.08164562f, 0.17020725f, -0.22911496f, 
    0.13717476f, -0.00139954f, -0.07039227f, -0.23588525f, 0.02462934f, -0.03418128f, -0.33377481f, -0.11082034f, 
    -0.03801597f, -0.25299823f, 0.26659030f, -0.06659751f, -0.24326296f, -0.10810249f, 0.17094634f, 0.02143510f, 
    0.16886948f, -0.03282426f, -0.18826693f, -0.03275394f, -0.13365525f, 0.14584322f, -0.10694923f, 0.24624993f, 
    0.01193621f, -0.13083649f, -0.00809485f, 0.15461621f, 0.02280727f, 0.07401109f, 0.16472618f, 0.13178319f, 
    -0.27022564f, -0.04686973f, 0.10159219f, -0.04271454f, -0.04706897f, -0.10837625f, 0.01449576f, 0.00277631f, 
    -0.03253574f, 0.05181389f, 0.00372272f, 0.06031270f, 0.08742212f, -0.02919845f, 0.39814264f, -0.46735287f, 
    0.14571387f, 0.12807243f, 0.05012644f, -0.05419684f, 0.10573359f, -0.03338169f, -0.13846014f, 0.06536280f, 
    -0.07520875f, 0.01992794f, 0.03448293f, -0.00721543f, -0.06817779f, -0.07319036f, -0.03567258f, 0.04698494f, 
    0.05045007f, -0.05445972f, 0.01928161f, 0.04427041f, -0.04125193f, -0.05799316f, 0.03076365f, 0.04837783f, 
    0.02608000f, -0.06032514f, -0.02945759f, 0.01267901f, -0.06841269f, 0.03327260f, -0.02006637f, -0.07623432f, 
    -0.05439339f, 0.00747690f, 0.03021711f, 0.06600142f, 0.04280204f, 0.05423404f, 0.03550948f, 0.00204221f, 
    0.00177239f, -0.04226791f, -0.05534444f, -0.03755180f, 0.00359467f, 0.00001381f, -0.00305384f, -0.00381390f, 
    -0.03939410f, -0.01107269f, 0.00313903f, 0.01825839f, -0.00998636f, -0.00829708f, -0.02291887f, 0.06194881f, 
    -0.05065778f, 0.00684190f, -0.06472164f, -0.00563957f, -0.07265668f, -0.01875433f, -0.05537730f, 0.04658597f, 
    0.05075193f, -0.04236396f, 0.02989163f, 0.04281292f, 0.03308135f, -0.04779272f, -0.02862834f, -0.03585346f, 
    0.03923821f, -0.06890748f, -0.03953622f, -0.04651145f, 0.03411975f, -0.05390554f, 0.04004024f, -0.04820846f, 
    0.05470834f, 0.02386662f, -0.01127944f, -0.04546808f, 0.00098991f, -0.03464796f, -0.03341983f, -0.04044177f, 
    0.05189722f, -0.04371725f, -0.07672826f, -0.07023211f, -0.07017940f, -0.06668098f, 0.05913025f, 0.03945273f, 
    -0.02893030f, 0.06118880f, -0.02943167f, -0.05834020f, 0.00829622f, 0.02506737f, -0.00600398f, 0.04601677f, 
    0.06028401f, -0.03019148f, -0.04337477f, -0.02989528f, -0.05459375f, 0.03960209f, -0.03902003f, -0.02297268f, 
    0.02005444f, 0.04990291f, -0.07458912f, 0.01477280f, -0.01541523f, -0.02823722f, -0.02048703f, 0.01873532f, 
    0.06315952f, -0.00966176f, -0.07496676f, 0.01307845f, 0.01912314f, -0.03486208f, -0.01764419f, -0.01937628f, 
    0.02651068f, 0.00901394f, -0.03315161f, 0.02846836f, 0.04528350f, -0.02360383f, -0.02997247f, -0.02716713f, 
    0.04337207f, -0.02380086f, -0.01318613f, -0.05143927f, 0.04445331f, -0.05704712f, -0.05988399f, -0.02428165f, 
    0.01026841f, -0.01466858f, 0.03069528f, -0.06526589f, -0.04461171f, 0.06249563f, -0.01618676f, -0.07325321f, 
    -0.06363516f, 0.02677133f, 0.04141898f, -0.05674551f, -0.01454836f, 0.03673532f, -0.02957075f, 0.05462388f, 
    -0.03313960f, 0.02354571f, -0.04632146f, -0.06416901f, 0.01977892f, -0.04651063f, -0.07038826f, 0.02427843f, 
    0.03618606f, -0.01450485f, 0.05082027f, 0.05057983f, -0.04104025f, 0.03774803f, 0.02861769f, -0.01169375f, 
    0.01845398f, -0.01363781f, -0.00290063f, 0.02380191f, 0.02259445f, -0.03452301f, 0.03431465f, -0.05397437f, 
    -0.07139068f, -0.06044000f, -0.01191283f, 0.01925744f, 0.01030316f, 0.01288131f, 0.02361226f, -0.03380099f, 
    -0.04177772f, -0.03346140f, -0.07252166f, 0.01716939f, -0.01152957f, -0.01204022f, -0.01921193f, -0.02293130f, 
    -0.03904263f, 0.00582297f, -0.04112763f, 0.00247588f, -0.06915312f, -0.01149877f, -0.04634430f, 0.02975822f, 
    0.06463936f, -0.06340268f, 0.01223027f, 0.00040241f, -0.05859344f, -0.02880696f, 0.04768142f, -0.00060718f, 
    -0.02107967f, -0.06406160f, -0.00534737f, 0.00827751f, -0.00244721f, -0.03865889f, -0.03574360f, 0.01795846f, 
    -0.05378413f, 0.01159880f, 0.02123426f, 0.03884075f, -0.06268591f, -0.04500547f, 0.00702133f, 0.00301502f, 
    0.01156797f, -0.02349271f, 0.00742732f, 0.00004575f, 0.04826219f, -0.02830280f, 0.06802634f, 0.02711952f, 
    0.01515232f, 0.06292292f, 0.02841081f, -0.00592159f, -0.01209180f, -0.01965908f, 0.01318812f, 0.03501572f, 
    -0.01686542f, 0.05554512f, 0.05849393f, -0.01543853f, -0.02702627f, -0.00451369f, 0.04296264f, -0.03577259f, 
    0.00764244f, -0.06051217f, 0.01226384f, 0.04362930f, -0.04425626f, -0.06493704f, 0.02178895f, -0.04534764f, 
    -0.07190739f, -0.04678442f, -0.01610996f, 0.00305115f, -0.02416969f, -0.07735736f, 0.01035754f, -0.02904492f, 
    -0.07456055f, -0.02301299f, -0.02823066f, -0.03142631f, 0.01171057f, -0.04482165f, 0.03667591f, -0.02108328f, 
    -0.03941012f, 0.06731341f, 0.05847303f, -0.06129123f, -0.02509493f, 0.01998913f, 0.03605646f, 0.03256191f, 
    0.00189475f, -0.06055080f, -0.01484389f, -0.04183828f, -0.04999226f, -0.07489061f, -0.04460376f, 0.03442695f, 
    -0.06175568f, -0.02521364f, -0.04837921f, -0.03644157f, -0.06648723f, -0.01803576f, 0.02666001f, 0.01712078f, 
    0.06768946f, -0.07043113f, 0.00747407f, 0.02515640f, -0.03571282f, 0.06101015f, -0.06888708f, 0.00325420f, 
    -0.04627619f, 0.01136256f, -0.02472430f, 0.03255590f, 0.06096454f, 0.02058208f, -0.07106744f, 0.02614258f, 
    -0.01279453f, 0.06108165f, -0.02645318f, -0.02955901f, 0.02366953f, 0.02321244f, 0.06092395f, -0.05506425f, 
    -0.07994725f, -0.04416406f, 0.00086797f, -0.07610950f, -0.04448625f, -0.05008161f, -0.06050461f, -0.05122877f, 
    -0.05430255f, -0.05539383f, 0.02790195f, 0.03911528f, 0.04320142f, 0.00120871f, 0.04033495f, 0.01089461f, 
    -0.04494272f, -0.04555141f, -0.06368750f, 0.01748760f, 0.02540590f, -0.03332372f, -0.00116182f, -0.02830491f, 
    -0.08157200f, 0.04148678f, -0.06766114f, -0.03590098f, 0.06418413f, 0.06202999f, -0.06628619f, 0.03191455f, 
    0.05770193f, 0.06136319f, -0.07259564f, 0.04071090f, -0.00465145f, 0.02849663f, -0.05330839f, 0.04810973f, 
    -0.01077703f, 0.02488028f, -0.07753514f, -0.06528424f, 0.02638661f, -0.05855704f, -0.04931137f, 0.06404789f, 
    0.02910732f, -0.04675607f, -0.00129947f, 0.02378510f, -0.01233190f, 0.06212712f, 0.04231915f, 0.05954555f, 
    0.01553422f, 0.00630889f, 0.00647065f, 0.05216675f, -0.00818516f, -0.05207992f, -0.07376615f, 0.03387091f, 
    -0.14575960f, -0.52143842f, -0.15517649f, -0.15247548f, -0.00069690f, -0.13837366f, -0.05820507f, 0.11950996f, 
    -0.11831622f, -0.10917073f, 0.03651561f, 0.13274236f, -0.15754783f, 0.17435239f, 0.12220761f, 0.15041134f, 
    0.20190187f, 0.08803498f, -0.01171503f, 0.21508101f, 0.01807046f, 0.02015865f, -0.09391011f, 0.09992386f, 
    -0.21540202f, 0.05559210f, -0.19309650f, 0.02580188f, -0.04178948f, -0.12272052f, 0.02332661f, 0.30638385f, 
    0.35190240f, 0.08738618f, -0.01463528f, 0.13383816f, -0.11808663f, -0.07477508f, 0.13746920f, 0.26347986f, 
    0.02037422f, 0.09842639f, 0.12296674f, 0.06578915f, 0.02323051f, 0.00693205f, 0.13350748f, -0.17478791f, 
    -0.14969280f, 0.24140027f, 0.04869319f, 0.18093224f, -0.11570924f, -0.05354134f, 0.15180674f, 0.01992736f, 
    0.00647629f, -0.08529105f, 0.36087322f, -0.06757046f, 0.47120610f, -0.00374435f, -0.06472638f, 0.00397312f, 
    -0.15292682f, -0.08147797f, 0.07358956f, -0.00299312f, -0.01852440f, -0.03895743f, -0.03429842f, -0.03705813f, 
    -0.29846901f, 0.23496588f, -0.05808891f, -0.01969626f, 0.01363636f, -0.13271959f, -0.08000711f, -0.07074650f, 
    0.06761841f, -0.14295633f, -0.01715797f, 0.15586558f, -0.45529416f, 0.01621926f, 0.06579381f, -0.18558943f, 
    -0.18841366f, -0.06596188f, -0.00290782f, 0.30328032f, 0.17999119f, 0.11693145f, 0.21365438f, 0.15214789f, 
    -0.24726331f, -0.17786595f, 0.27085912f, 0.03319406f, -0.04368540f, -0.06942281f, -0.00173909f, -0.24627575f, 
    -0.01980174f, 0.02210687f, -0.02537028f, -0.12039252f, -0.28032345f, -0.06839149f, 0.10990615f, 0.48589793f, 
    0.17951705f, 0.10542018f, -0.03651706f, 0.08386081f, -0.12062807f, 0.00498169f, 0.05256720f, 0.11646140f, 
    -0.01352711f, 0.10442989f, 0.12320527f, 0.10911009f, 0.08388930f, -0.02114527f, 0.00445744f, 0.07055410f, 
    0.24168199f, -0.01359199f, 0.14903043f, 0.02088597f, 0.41129115f, 0.08937421f, -0.00918326f, 0.19714209f, 
    0.06912935f, -0.10302467f, 0.08268543f, -0.04993342f, -0.01758878f, 0.09150138f, -0.00883915f, 0.04224512f, 
    -0.23004103f, 0.05592901f, -0.21788824f, -0.39817718f, 0.21079893f, -0.00615963f, -0.04951790f, -0.05202956f, 
    -0.00241087f, -0.21703754f, 0.19324051f, -0.02298110f, -0.10539795f, 0.33723211f, 0.11603758f, -0.06151221f, 
    0.05792916f, 0.00545317f, -0.09861044f, -0.12324312f, 0.02244030f, 0.00774398f, 0.02960499f, -0.01848776f, 
    0.86892343f, 0.25522441f, 0.36399165f, 0.38917133f, 0.21748605f, 0.06029219f, -0.08903403f, -0.01568823f, 
    0.17286974f, -0.05967491f, 0.02429014f, 0.05008662f, -0.29926825f, -0.25074041f, -0.15045382f, -0.01198957f, 
    0.08957428f, -0.14179973f, 0.07366180f, -0.11262651f, -0.09874021f, 0.12139964f, -0.33133331f, 0.05559567f, 
    0.31776151f, 0.04195179f, 0.08131302f, -0.28516549f, -0.08252266f, 0.00415874f, -0.02932602f, -0.16944523f, 
    0.16819046f, 0.01769688f, -0.06191543f, 0.05519543f, -0.46010429f, -0.22471859f, -0.15197685f, -0.39644417f, 
    0.03136840f, 0.07489596f, 0.15302700f, 0.11683991f, 0.11035386f, 0.06980644f, 0.02715431f, -0.02720461f, 
    -0.31835392f, -0.36870524f, -0.17019176f, -0.36226153f, 0.12958653f, -0.02139401f, -0.05164342f, 0.12483876f, 
    0.22917061f, 0.03194033f, -0.03503020f, 0.14984490f, -0.31415278f, 0.09942199f, -0.25054744f, -0.18703303f, 
    0.17654249f, 0.11813710f, -0.00100482f, 0.10239482f, -0.07471838f, 0.20634243f, -0.14696695f, -0.09896597f, 
    0.08365953f, -0.13185516f, -0.20372531f, -0.11049910f, 0.13610129f, 0.16809233f, 0.04932829f, -0.16883346f, 
    0.16874914f, 0.03849464f, 0.03176830f, -0.03484201f, 0.25172141f, 0.16478831f, 0.03193794f, 0.09232598f, 
    -0.11256472f, 0.08669142f, 0.27846512f, 0.21239696f, -0.00832951f, -0.10753702f, 0.10817310f, 0.09415323f, 
    0.60926586f, -0.34887019f, -0.09619074f, -0.07928155f, 0.01747182f, -0.02291536f, -0.05978674f, 0.21905406f, 
    0.04242488f, 0.16835184f, 0.10259110f, 0.06575939f, -0.41235423f, 0.07101113f, -0.38134164f, -0.34645239f, 
    0.02851770f, 0.12604618f, -0.02320380f, 0.00842746f, 0.06045695f, 0.07555944f, 0.10471493f, -0.00103375f, 
    0.27604550f, -0.43948755f, 0.01860652f, -0.30272159f, 0.10687260f, 0.18215381f, -0.04998566f, 0.14872651f, 
    -0.07021071f, -0.03247979f, 0.02358290f, 0.00121374f, -0.24986944f, 0.01601036f, -0.14235826f, -0.23027465f, 
    0.07038876f, -0.05593685f, 0.12502177f, 0.02397349f, -0.00889316f, 0.09402172f, 0.07015805f, 0.10290176f, 
    0.12240477f, -0.18544222f, -0.17933804f, 0.05696278f, 0.17675999f, 0.09533686f, 0.03382550f, 0.02969683f, 
    -0.01660555f, -0.19395214f, -0.09137300f, -0.06868386f, 0.24491487f, -0.15956399f, -0.12737909f, 0.21616977f, 
    -0.08154433f, 0.08955263f, -0.10158650f, 0.16942868f, -0.07701793f, 0.14851914f, 0.00383669f, -0.01161038f, 
    0.29782510f, -0.06155569f, 0.01376383f, 0.10598639f, -0.09689807f, -0.04757442f, -0.26820984f, 0.20084479f, 
    -0.03105906f, 0.07989598f, -0.15549089f, 0.00824261f, 0.63610619f, -0.55829668f, 0.20288408f, -0.00588692f, 
    -0.10377634f, 0.08736472f, -0.03624243f, -0.00448762f, 0.01334800f, 0.01650567f, 0.23085551f, 0.03575003f, 
    0.16338685f, 0.45726496f, 0.25307187f, 0.53496122f, -0.06998611f, 0.24463680f, 0.19453958f, -0.00951645f, 
    0.14870399f, -0.02150069f, 0.09909444f, 0.05726541f, -0.39166781f, 0.06746943f, 0.05570682f, -0.50081134f, 
    -0.05992868f, -0.05075771f, -0.23516047f, -0.19623293f, -0.04547093f, 0.04446711f, 0.09276751f, 0.03671913f, 
    0.01115991f, -0.05155978f, 0.28844538f, 0.09855454f, 0.21917772f, -0.07858648f, 0.26897222f, -0.12577133f, 
    0.04354320f, 0.15737706f, -0.00915001f, 0.02069950f, -0.25304809f, -0.05592934f, 0.01892614f, 0.03032017f, 
    0.15793419f, 0.16138296f, 0.07551214f, 0.10218670f, 0.01847618f, 0.00570694f, -0.02274012f, -0.01173974f, 
    -0.02643758f, 0.21522528f, 0.12349283f, -0.07507785f, 0.20264481f, 0.17235929f, 0.14921732f, -0.00437662f, 
    0.00793528f, -0.04940713f, 0.07900887f, -0.02892769f, 0.14409177f, -0.01347551f, -0.08169638f, 0.06011775f, 
    0.17500260f, 0.04616133f, 0.07511656f, 0.13211231f, -0.17707548f, -0.04057834f, -0.02844407f, 0.11051758f, 
    0.04878031f, -0.01489983f, 0.14580329f, -0.08744139f, -0.17350723f, 0.13750455f, 0.05990064f, 0.03762763f, 
    0.16302904f, -0.01464739f, -0.15009037f, 0.07233912f, -0.18763165f, -0.33598849f, -0.25471142f, -0.07997271f, 
    -0.10596818f, 0.06893419f, -0.30178612f, -0.12408852f, 0.06390975f, 0.14802392f, 0.09435283f, -0.04866086f, 
    -0.33956921f, 0.00775898f, 0.13817447f, 0.17463520f, -0.05762427f, 0.08160755f, -0.01079438f, -0.07494149f, 
    0.04829451f, -0.00679584f, 0.04799293f, 0.03351912f, 0.09406512f, -0.05232190f, 0.11045569f, -0.05571643f, 
    -0.20435715f, 0.15511023f, 0.08037426f, 0.02194653f, 0.09657860f, -0.26831648f, -0.03240924f, 0.10059365f, 
    0.16096735f, 0.61965925f, -0.04542154f, 0.21251506f, -0.08236372f, 0.08649477f, -0.05004604f, 0.07697684f, 
    -0.03507939f, -0.07178342f, 0.11168191f, 0.18521449f, 0.30408168f, -0.07507893f, 0.02660706f, -0.10033667f, 
    -0.05440112f, 0.30866185f, 0.28826356f, -0.03636200f, 0.15071544f, 0.06722339f, 0.02360702f, 0.05994910f, 
    -0.25924319f, 0.08127250f, 0.14235254f, -0.16256395f, 0.04017735f, 0.07424413f, 0.02358166f, 0.02246644f, 
    0.00610212f, 0.02786173f, -0.04493354f, 0.09499683f, -0.02802435f, 0.05691819f, -0.19355193f, -0.19862103f, 
    -0.21715581f, 0.21436916f, 0.08040959f, -0.03788106f, 0.13122621f, -0.00403084f, -0.06383211f, 0.14161804f, 
    0.04274000f, 0.21530052f, -0.18673068f, 0.17191994f, -0.06446996f, -0.01593090f, 0.19883707f, 0.12195146f, 
    0.12085843f, 0.11230176f, 0.05229506f, 0.19104511f, -0.38543287f, 0.41579813f, -0.04757247f, 0.21888082f, 
    -0.14178237f, -0.13935940f, -0.04209200f, 0.10612790f, 0.12282491f, 0.01732248f, 0.11476494f, 0.07821623f, 
    -0.67602265f, -0.01012469f, 0.15629393f, -0.19605570f, -0.20520133f, -0.15995279f, -0.18599150f, -0.11832298f, 
    -0.05909326f, 0.16655917f, -0.06612586f, 0.04605738f, 0.06832898f, 0.16982345f, 0.42322600f, -0.02154194f, 
    0.00416682f, 0.14298148f, 0.00534893f, 0.05163459f, 0.07802539f, 0.05109474f, 0.06059909f, -0.11199951f, 
    0.11658429f, -0.06983930f, -0.22597696f, 0.16176628f, -0.08086482f, -0.01962108f, 0.00707896f, 0.06167227f, 
    0.16453709f, -0.00709056f, -0.05921187f, -0.15931287f, -0.30308157f, 0.05054303f, -0.03313525f, -0.00725389f, 
    0.09516831f, 0.12532417f, 0.01134375f, 0.16952634f, -0.00157853f, 0.09510247f, 0.02855241f, -0.28379542f, 
    -0.18717434f, 0.00031638f, -0.27486205f, -0.13155736f, 0.17984834f, 0.05782393f, 0.11243638f, 0.04558006f, 
    0.03484550f, -0.08874258f, 0.14800711f, 0.05098157f, 0.33930373f, -0.09477024f, 0.03452267f, -0.00827479f, 
    0.19539525f, 0.03357201f, -0.02624950f, 0.06624478f, -0.01547781f, 0.05334236f, 0.16474436f, 0.24976927f, 
    0.03115779f, -0.02684014f, -0.09995794f, 0.02244918f, 0.11404713f, 0.17819326f, 0.01217613f, 0.05406816f, 
    -0.00722731f, -0.13120072f, 0.09806786f, 0.05469560f, -0.24744576f, 0.26367664f, 0.02128856f, -0.05909753f, 
    0.14944644f, -0.11338603f, -0.09966846f, -0.09873436f, -0.05607432f, 0.05162477f, 0.09181384f, -0.16827284f, 
    -0.24751656f, 0.16962931f, 0.02374981f, 0.12838791f, 0.12436255f, 0.20279458f, 0.01293600f, 0.10368953f, 
    0.10241828f, -0.15654629f, 0.14563097f, 0.00343467f, -0.25268352f, -0.29289523f, 0.18182811f, -0.15091521f, 
    0.09878618f, -0.03775577f, 0.15737861f, -0.17663287f, -0.00350092f, -0.20542458f, 0.04037187f, -0.03637805f, 
    0.19745001f, -0.22507368f, 0.15232448f, 0.01204023f, 0.13768230f, 0.08600990f, 0.01657927f, -0.11453555f, 
    -0.08623580f, 0.27736306f, 0.00790037f, 0.11817258f, 0.15452808f, -0.03229390f, -0.11383387f, -0.13719767f, 
    0.21022360f, 0.10228572f, 0.04926730f, 0.18220527f, 0.05217870f, 0.09164327f, -0.09864575f, 0.06749086f, 
    -0.16218957f, 0.20746477f, -0.00271639f, 0.07677642f, 0.07396255f, 0.07597288f, 0.04110391f, 0.14179260f, 
    0.04403159f, -0.18322456f, -0.08886348f, 0.11311770f, 0.00507076f, -0.28177723f, 0.07023324f, 0.16150635f, 
    0.10518820f, 0.03192706f, 0.18980381f, 0.23413783f, -0.00780868f, 0.14797731f, 0.23561399f, 0.12400953f, 
    -0.24587378f, -0.35348862f, 0.08608277f, -0.18845208f, 0.08381120f, -0.03023495f, -0.09748527f, -0.34586325f, 
    0.13072613f, -0.13273308f, -0.03476312f, 0.22909418f, 0.23765606f, 0.02855018f, -0.05543113f, -0.02516713f, 
    -0.08281475f, 0.03835230f, 0.04388620f, -0.09129778f, 0.11524435f, 0.09324418f, 0.00568192f, -0.23181823f, 
    0.58477187f, 0.38068202f, 0.12938336f, -0.17408668f, 0.00158980f, -0.12458919f, 0.10787207f, 0.15862209f, 
    0.21342430f, 0.08209027f, -0.03682567f, -0.08110297f, 0.15014395f, -0.10015322f, 0.15878128f, -0.16609216f, 
    -0.09745931f, -0.14070517f, -0.01456674f, 0.10776086f, -0.05197069f, -0.25075337f, 0.06841619f, -0.07527754f, 
    0.02737182f, -0.01896253f, -0.02656117f, -0.01519796f, -0.00425009f, -0.04493005f, 0.02711569f, 0.03886793f, 
    -0.00420704f, 0.03640428f, -0.01805325f, -0.07249770f, -0.02534943f, 0.00127846f, -0.07007892f, -0.01034910f, 
    -0.00447444f, -0.07192679f, -0.02665982f, -0.04450076f, -0.05473418f, -0.02553503f, 0.04841613f, -0.03431980f, 
    0.06931348f, -0.07102272f, -0.06442294f, 0.04466923f, -0.05860113f, -0.02629123f, -0.06194718f, -0.06964253f, 
    0.05285214f, 0.02166482f, 0.03312887f, -0.04037685f, 0.00206303f, -0.07242540f, 0.03648212f, -0.02683734f, 
    -0.06643397f, -0.01414087f, 0.01336793f, 0.05073228f, 0.04127923f, 0.01557809f, 0.05914148f, 0.04714517f, 
    0.00500133f, -0.04645322f, -0.00498068f, -0.02000915f, 0.03775029f, 0.01396865f, -0.02706175f, -0.02996143f, 
    -0.05668825f, 0.06273171f, -0.02174963f, 0.04876130f, -0.07246748f, -0.07328884f, -0.02232331f, 0.04765566f, 
    -0.01044368f, -0.00878530f, 0.04684170f, -0.01770671f, 0.05986574f, -0.02924052f, 0.01188397f, 0.00794672f, 
    0.04010669f, -0.05443801f, -0.05258057f, 0.01081453f, -0.02506677f, -0.01974304f, 0.01744932f, 0.00683660f, 
    -0.06692491f, -0.02510277f, -0.01954316f, -0.02362710f, -0.01912470f, -0.03128726f, 0.04416745f, 0.04649285f, 
    0.07103955f, -0.03643416f, -0.03252757f, -0.05033156f, -0.03891862f, 0.00379219f, 0.06305668f, -0.03740561f, 
    -0.05461599f, -0.03962633f, -0.05937561f, -0.04049013f, -0.00413111f, 0.04039946f, -0.06805738f, -0.03408755f, 
    -0.05289669f, -0.02412854f, 0.04779658f, 0.00760665f, -0.03099041f, -0.06304378f, -0.03320543f, 0.04836391f, 
    -0.05274149f, 0.04851064f, -0.02208344f, 0.05125639f, 0.03318189f, 0.05469391f, -0.00138383f, 0.05072565f, 
    -0.03539202f, 0.06347673f, -0.03256500f, 0.02595533f, -0.05998951f, 0.06411120f, 0.02219670f, 0.06092035f, 
    0.04604248f, -0.02123590f, -0.00137525f, -0.01859631f, -0.02283469f, -0.03479116f, -0.00203468f, -0.05501493f, 
    -0.07132357f, 0.02766040f, -0.01266663f, -0.02812458f, -0.05254193f, -0.06489781f, -0.06098790f, -0.00085268f, 
    -0.05911497f, 0.05970837f, 0.05443912f, -0.00183410f, -0.04330561f, -0.07043239f, 0.03486663f, 0.06981628f, 
    0.05929205f, -0.03369730f, -0.05099279f, 0.04732589f, 0.02163579f, -0.03682296f, -0.05733940f, 0.06355146f, 
    -0.02627329f, -0.00310455f, 0.00812473f, -0.06674904f, -0.00575927f, -0.04487837f, 0.02909301f, 0.03648069f, 
    -0.03735246f, -0.00903308f, -0.02676659f, -0.01285076f, 0.00109939f, 0.02961363f, -0.03702912f, 0.02144665f, 
    -0.05185659f, -0.05093224f, -0.03536592f, 0.03323163f, 0.06080367f, 0.01509580f, -0.05630632f, -0.07628052f, 
    -0.04724734f, -0.01997339f, 0.01913242f, -0.03518739f, 0.04172654f, -0.06956679f, -0.03054907f, -0.00335443f, 
    -0.42734787f, 0.52249527f, 0.24734545f, -0.19425493f, 0.19596329f, -0.03874601f, 0.01676224f, 0.21081038f, 
    -0.09675169f, -0.09901942f, 0.02698766f, 0.28966412f, -0.28881186f, 0.00753224f, -0.14822091f, -0.08178342f, 
    0.19564208f, -0.06377538f, -0.09821297f, 0.05166970f, 0.20946532f, 0.13494056f, 0.14752913f, 0.08362909f, 
    -0.01490542f, -0.03685690f, -0.21181622f, 0.28699553f, -0.01555332f, -0.08134837f, 0.05249522f, -0.01788947f, 
    0.18549202f, 0.14914094f, -0.04999202f, -0.08139408f, -0.46967933f, -0.18226260f, 0.07882252f, -0.11585056f, 
    -0.16471560f, 0.08648920f, 0.13103122f, -0.03498851f, 0.21185331f, 0.06530639f, 0.22103648f, -0.11802845f, 
    -0.60027689f, 0.06813010f, -0.04802754f, -0.00293391f, -0.02319275f, 0.01670019f, 0.14920636f, 0.25409007f, 
    0.00742699f, 0.14080715f, 0.04733644f, -0.02489945f, -0.27090594f, -0.38855633f, 0.04021963f, 0.10161067f, 
    -0.16172707f, 0.31788859f, 0.16665865f, 0.16089237f, 0.05952900f, 0.17825858f, -0.10305092f, 0.24872418f, 
    -0.48205751f, 0.28993237f, -0.10150740f, 0.08273548f, 0.13368773f, -0.12451380f, 0.07546345f, 0.01011086f, 
    0.15270093f, -0.00462143f, 0.03630430f, 0.05512435f, 0.31197500f, 0.31556615f, 0.06453760f, 0.14986131f, 
    -0.07367710f, -0.02052138f, -0.15520929f, 0.27569142f, 0.15113264f, 0.07323726f, -0.00571150f, -0.04362477f, 
    -0.21263216f, -0.17888460f, -0.14449047f, -0.05848191f, -0.02202451f, -0.00400712f, 0.25100315f, -0.02443988f, 
    0.08049666f, -0.04490194f, 0.12546824f, 0.03692431f, -0.24909830f, -0.35037887f, 0.11461346f, -0.08399406f, 
    -0.12034828f, 0.20757726f, -0.20713525f, 0.07432362f, 0.08103617f, -0.18242550f, -0.02280733f, -0.17091610f, 
    0.02315210f, -0.01387504f, -0.04190211f, 0.17711993f, -0.02684252f, -0.07972690f, 0.15129812f, 0.04176229f, 
    0.04525077f, 0.16709206f, 0.31883210f, -0.06953759f, -0.56250846f, -0.03681841f, 0.15193418f, -0.12001911f, 
    0.04254681f, -0.11450218f, 0.12295668f, -0.00921620f, 0.08056890f, -0.09416652f, 0.05682942f, -0.02660524f, 
    0.05530998f, 0.22560504f, -0.20818307f, 0.11113692f, 0.40990326f, 0.15699387f, 0.01477037f, -0.00758985f, 
    0.10421002f, -0.02318328f, 0.28495744f, -0.08844882f, -0.25500706f, 0.42472312f, 0.03671888f, -0.09826822f, 
    0.21078974f, 0.09606494f, -0.01490245f, 0.06226325f, 0.01876540f, 0.12392382f, -0.11629315f, 0.26895714f, 
    -0.04248667f, -0.23791069f, -0.05008922f, -0.07001299f, 0.26366985f, 0.26065728f, -0.14001524f, 0.00674325f, 
    0.09867945f, -0.00944221f, 0.03654266f, 0.19761239f, 0.29591253f, 0.33376229f, 0.08647777f, 0.68888927f, 
    0.13727650f, 0.10617145f, 0.09649649f, 0.09647550f, 0.18696858f, 0.15306155f, -0.08744787f, 0.23338053f, 
    -0.32915807f, -0.18051225f, -0.18301992f, 0.14866802f, -0.21635582f, -0.21406147f, -0.05050222f, 0.07197230f, 
    0.07847461f, 0.05977901f, 0.15836103f, -0.00269853f, -0.74733156f, -0.19730504f, -0.28704688f, 0.14517549f, 
    0.06560996f, 0.06194134f, 0.05983973f, 0.01232824f, 0.05622962f, 0.15680373f, -0.06753970f, -0.33155066f, 
    -0.38947231f, -0.04845167f, -0.13554364f, -0.22120327f, 0.18398318f, 0.23572525f, -0.12249660f, 0.05646474f, 
    0.09346931f, -0.01358413f, -0.08490263f, -0.04444260f, -0.03583756f, -0.38288668f, -0.03125668f, -0.43264052f, 
    0.38308606f, 0.29408267f, 0.22493824f, 0.07164126f, 0.18205816f, -0.04624331f, 0.01250289f, 0.23750928f, 
    0.38058856f, -0.45493260f, -0.16727780f, -0.10338099f, 0.37292412f, 0.25634357f, -0.00552489f, 0.01109570f, 
    0.06125445f, -0.11377326f, -0.02694667f, -0.02069201f, 0.40080696f, 0.09147210f, 0.21785510f, -0.14940470f, 
    0.19650595f, -0.04820360f, -0.01066352f, 0.21194336f, -0.10090759f, -0.06506221f, 0.10942982f, 0.11901641f, 
    0.13276117f, 0.18541168f, 0.05312938f, 0.24873553f, 0.16239032f, 0.09901098f, -0.04826165f, 0.02134640f, 
    0.05072835f, -0.02784893f, 0.04066244f, 0.10519730f, -0.14313087f, -0.05972434f, 0.27698603f, -0.18403403f, 
    -0.01473596f, 0.01391706f, 0.07002421f, -0.12018564f, 0.22621463f, 0.06389622f, -0.10657094f, -0.12940119f, 
    -0.18701048f, -0.09881206f, -0.11350947f, -0.04688471f, 0.17415929f, 0.10548908f, 0.05673581f, 0.03731327f, 
    -0.02144323f, 0.36941078f, -0.08645570f, 0.03677647f, -0.17544256f, -0.33413276f, -0.05413892f, -0.57911867f, 
    0.29567254f, -0.00682512f, 0.21888864f, 0.20523453f, -0.02733753f, -0.01738097f, -0.13523519f, -0.02128175f, 
    0.09702275f, 0.07672177f, -0.01232110f, 0.26969233f, 0.15965277f, 0.07484882f, 0.19560099f, 0.02938677f, 
    0.11673366f, -0.12615108f, -0.09309820f, -0.01531796f, 0.12918910f, 0.06495620f, 0.12587310f, -0.12511748f, 
    0.11020053f, 0.16645813f, -0.07181521f, 0.08775488f, 0.10437956f, 0.01981676f, 0.05236978f, 0.09052201f, 
    -0.06438377f, -0.15118399f, 0.35830930f, -0.14396402f, 0.04064097f, 0.08996230f, -0.03960373f, -0.09514055f, 
    0.13661151f, 0.01847633f, -0.09103694f, 0.14393996f, -0.17940670f, 0.35826659f, -0.26986691f, 0.14418890f, 
    0.01645745f, -0.10213467f, -0.07805572f, 0.03084035f, -0.05580042f, 0.07533833f, 0.07384873f, -0.07812888f, 
    0.42271924f, 0.39160401f, 0.25569528f, -0.05867631f, -0.11790122f, 0.07516115f, 0.08145774f, 0.02148632f, 
    -0.14479858f, -0.06326284f, 0.14199610f, 0.08291165f, 0.02453587f, 0.12491760f, 0.21478951f, -0.15490770f, 
    -0.16373287f, -0.06636527f, 0.06073591f, -0.01599620f, 0.06581099f, -0.14531125f, 0.23688370f, 0.22240491f, 
    0.49534002f, 0.24231623f, 0.29027453f, -0.06288591f, 0.08247542f, 0.15522002f, 0.13107452f, -0.01519578f, 
    0.15239646f, 0.16117115f, -0.12259720f, -0.21690734f, 0.02776998f, 0.08551065f, 0.02537188f, -0.14309070f, 
    -0.03298365f, 0.17913091f, -0.00642974f, -0.05318982f, 0.20367192f, 0.06593975f, 0.07930721f, -0.19382185f, 
    0.06506666f, 0.36059949f, 0.10182676f, 0.34948412f, 0.07244118f, 0.00291339f, -0.03268648f, -0.12483660f, 
    -0.10456766f, 0.01875453f, 0.05878101f, 0.09530193f, 0.39845589f, 0.01972229f, -0.09087849f, 0.14740473f, 
    -0.10777178f, -0.13444126f, 0.23944817f, 0.20020773f, -0.10440316f, 0.07641289f, -0.02731366f, 0.22728285f, 
    0.31017587f, -0.26606321f, 0.04007031f, 0.16189893f, 0.10615264f, 0.02979391f, -0.05228272f, 0.16488922f, 
    -0.01402597f, -0.03934897f, -0.01346745f, 0.10009537f, -0.58972174f, 0.15847687f, -0.22505888f, 0.24149506f, 
    0.09621044f, 0.19455245f, 0.05969635f, 0.13088980f, 0.05002377f, 0.14882952f, -0.00084899f, -0.11535867f, 
    0.19255291f, -0.31805247f, 0.20387539f, -0.02724365f, 0.05631907f, 0.09151206f, -0.01371001f, 0.13046700f, 
    0.09461704f, 0.05469741f, 0.07768356f, -0.01477503f, -0.04373933f, 0.02779913f, -0.08026390f, -0.08175173f, 
    0.01141405f, -0.04887908f, 0.17221306f, -0.07004536f, 0.01594557f, -0.17535329f, -0.19075449f, -0.19276747f, 
    0.19967023f, 0.21945643f, 0.10873607f, -0.02895792f, -0.03722006f, 0.08209635f, 0.16255212f, 0.03269628f, 
    -0.06857733f, 0.15450202f, 0.05757811f, 0.29930651f, 0.27942482f, 0.26647222f, 0.04121275f, 0.02713780f, 
    -0.13712528f, 0.05741042f, 0.09491637f, -0.11499564f, -0.02493811f, -0.12059151f, 0.03156819f, -0.17310709f, 
    0.05739129f, 0.06120852f, 0.02238248f, -0.11207322f, -0.20089266f, -0.04328015f, 0.27049217f, 0.03722383f, 
    -0.17450942f, -0.11152276f, -0.12002436f, 0.06425102f, -0.29917747f, 0.14292066f, -0.20944752f, 0.13744605f, 
    -0.11571716f, 0.17043960f, 0.29402912f, 0.25495878f, 0.26249865f, 0.01050734f, 0.08983541f, 0.21452767f, 
    0.11038123f, 0.37123567f, -0.04471444f, 0.22231162f, 0.02909707f, -0.16669688f, -0.04804843f, -0.14026545f, 
    0.00466673f, 0.15652564f, -0.00001119f, 0.27475658f, 0.17245907f, -0.18832673f, -0.23187636f, -0.06625998f, 
    -0.07026806f, -0.06277739f, 0.01082930f, -0.19280912f, 0.11967056f, -0.18384863f, 0.01361439f, -0.04254087f, 
    -0.54633462f, 0.08067173f, -0.33731315f, -0.43873128f, 0.10222138f, -0.05762845f, 0.00616860f, -0.02838647f, 
    -0.05502436f, 0.16051938f, -0.04777060f, -0.02967435f, -0.08559604f, 0.17161469f, -0.20661694f, 0.08152783f, 
    0.00973175f, 0.13795547f, -0.12395258f, 0.01984762f, -0.01735952f, -0.01901780f, 0.23807386f, -0.11798771f, 
    0.01941470f, 0.21336010f, -0.22916786f, 0.14801478f, -0.00726487f, -0.08321504f, -0.13193807f, 0.20435935f, 
    0.03312054f, 0.04651470f, -0.20512050f, -0.00723447f, 0.32476360f, -0.06049050f, -0.20657863f, 0.29335514f, 
    -0.08433678f, 0.07477964f, -0.08714944f, 0.11857838f, -0.08822317f, -0.16277684f, -0.17612541f, -0.21816066f, 
    -0.10071938f, 0.08469030f, 0.11573665f, -0.00384438f, 0.10280369f, 0.04260829f, -0.07546150f, 0.15019938f, 
    0.00028511f, -0.04378289f, 0.14639290f, 0.08830661f, 0.47719085f, 0.14493905f, 0.16163149f, 0.03796087f, 
    0.00896026f, -0.25864667f, 0.14877291f, 0.12694155f, 0.01615934f, -0.13308240f, 0.00934239f, 0.08232968f, 
    0.44165671f, 0.02450332f, -0.08141480f, 0.02318177f, -0.05949424f, 0.12174126f, -0.10452306f, -0.00931056f, 
    -0.20648135f, -0.08443602f, 0.05468812f, -0.05289514f, -0.15400524f, 0.14698841f, 0.33203456f, -0.10504092f, 
    -0.00332251f, 0.00757601f, 0.12642358f, -0.04785756f, -0.12476710f, -0.01243642f, 0.01680014f, 0.04152884f, 
    0.20033655f, -0.17205065f, -0.17652604f, 0.19559933f, 0.02228514f, 0.02640379f, -0.19313999f, 0.01206532f, 
    0.23348042f, -0.11826058f, -0.04122823f, -0.04211139f, -0.08611426f, -0.10609654f, 0.37340820f, -0.22787793f, 
    0.22040269f, 0.21860397f, 0.31775215f, -0.08479988f, -0.04973643f, 0.09189584f, 0.01733055f, -0.10223523f, 
    -0.08264426f, -0.15091112f, 0.03698550f, 0.29794511f, 0.09290164f, -0.08320424f, -0.09343667f, 0.14516361f, 
    0.00388850f, 0.25902659f, -0.07141469f, 0.06915186f, 0.05609980f, 0.14507051f, 0.18340923f, 0.03137499f, 
    0.07846668f, -0.16474164f, -0.03712863f, 0.09831245f, -0.05421312f, 0.01056047f, 0.08740457f, -0.00097505f, 
    0.36904189f, 0.17463350f, -0.17725472f, 0.24638820f, -0.15859084f, -0.20223880f, 0.24845842f, 0.05393613f, 
    -0.10345511f, 0.05942034f, -0.12541969f, 0.04203777f, -0.02074894f, -0.11571471f, 0.27127859f, 0.05245900f, 
    0.29018295f, -0.10066596f, 0.20767979f, 0.25437427f, -0.05900766f, -0.00754593f, 0.20191194f, 0.02799973f, 
    -0.18607594f, -0.37284234f, 0.15902129f, -0.56206924f, 0.09917522f, -0.18965237f, 0.08267412f, -0.22274067f, 
    -0.03180949f, 0.14294252f, -0.05056708f, -0.06868500f, 0.06937420f, 0.21165694f, -0.31528500f, -0.07126866f, 
    0.04950768f, -0.15110454f, -0.00853964f, -0.08100261f, -0.01721053f, 0.06493151f, 0.00892297f, -0.02271480f, 
    -0.03116902f, 0.00687979f, -0.00566615f, -0.20372066f, 0.10829503f, 0.08545168f, 0.04352485f, 0.00174964f, 
    0.02249762f, 0.12364741f, 0.01458470f, 0.01367933f, -0.07829374f, -0.17673607f, 0.02493234f, -0.12723117f, 
    0.09454817f, 0.29042467f, 0.02429796f, 0.02328839f, -0.01982823f, -0.23580219f, -0.06084885f, -0.03658294f, 
    -0.18291417f, -0.11850768f, 0.36113849f, 0.19012751f, 0.14532888f, -0.10257434f, 0.02214554f, 0.04080958f, 
    -0.04898394f, 0.03641780f, 0.01258191f, 0.13485542f, -0.05659245f, -0.23351459f, -0.29579511f, 0.20211223f, 
    0.17503762f, 0.06891437f, -0.00328978f, 0.09462819f, 0.05634540f, 0.04219168f, -0.17049381f, -0.14946166f, 
    0.23440938f, -0.01738705f, -0.03405139f, 0.32822424f, 0.08644353f, 0.07120495f, 0.05946483f, 0.22638480f, 
    0.01856604f, 0.12376892f, 0.11817695f, 0.05066741f, -0.02783399f, 0.00610904f, -0.06703603f, 0.14353296f, 
    0.09192725f, 0.02114091f, 0.27491331f, -0.03744885f, 0.04221236f, -0.05932854f, -0.04415513f, 0.06349266f, 
    -0.07846148f, 0.17941386f, -0.07829540f, -0.20739172f, -0.01669204f, -0.03779060f, -0.00071882f, 0.19061883f, 
    -0.04149073f, 0.04300980f, 0.08247740f, -0.16985635f, 0.00959078f, -0.34673634f, 0.11970732f, -0.04533676f, 
    -0.19319661f, -0.02546151f, -0.05301729f, -0.04008558f, -0.03672489f, -0.12216479f, 0.06399273f, 0.14211120f, 
    -0.27956784f, 0.28442132f, 0.05133135f, -0.16474536f, 0.06976765f, -0.01214145f, 0.04143456f, -0.18396427f, 
    0.05568839f, -0.02076834f, -0.14275466f, -0.09549431f, -0.10627174f, -0.12086620f, 0.25972342f, 0.31385812f, 
    -0.08787595f, -0.02829622f, -0.12573780f, 0.20625092f, 0.06133951f, -0.08071640f, 0.01637192f, -0.00366681f, 
    -0.65610379f, 0.48732662f, 0.21221651f, -0.17003132f, 0.00238518f, -0.06012569f, 0.10191949f, -0.04997596f, 
    -0.01447783f, 0.11393966f, -0.08788434f, 0.08399808f, -0.09771851f, -0.05349531f, -0.10855318f, 0.27610818f, 
    0.03018311f, 0.15831722f, -0.02791112f, 0.04863973f, -0.01008687f, -0.10053742f, 0.04437460f, 0.05777577f, 
    -0.01811676f, 0.11946259f, 0.07761814f, 0.02009627f, 0.09049388f, -0.03287249f, 0.08290544f, -0.05835719f, 
    0.02601692f, 0.10934909f, 0.09752639f, 0.14222099f, -0.05798076f, 0.28570023f, 0.15359581f, -0.06909918f, 
    0.03790236f, -0.00718996f, 0.19848740f, 0.10107536f, -0.01743767f, -0.03338940f, 0.01805737f, 0.10056179f, 
    -0.31145748f, 0.22689268f, -0.06832729f, -0.04050187f, -0.04154525f, 0.13816100f, 0.26859063f, 0.23418882f, 
    -0.06124358f, -0.01420566f, 0.13252875f, -0.01318462f, -0.45076448f, 0.46463472f, 0.21169619f, -0.00770690f, 
    0.18968572f, -0.06136558f, -0.14055963f, 0.11914973f, -0.03075054f, 0.12070162f, -0.09672868f, 0.04044498f, 
    -0.16832225f, -0.00732768f, 0.41721681f, -0.12719287f, 0.04407218f, -0.04820031f, -0.05736358f, -0.07760309f, 
    -0.04327227f, -0.02648736f, 0.02077055f, 0.11805023f, -0.08156888f, -0.13307838f, 0.34415677f, 0.45907894f, 
    0.22600545f, 0.06287546f, -0.08236593f, 0.05205906f, -0.00571449f, -0.04016980f, -0.04524953f, 0.01930124f, 
    -0.07218160f, 0.11049636f, 0.27980652f, 0.25348642f, 0.07096580f, -0.00165307f, 0.06846373f, -0.04548272f, 
    0.06255291f, 0.11282878f, -0.18974610f, -0.14383021f, 0.06466444f, 0.10864221f, -0.00716483f, -0.11324110f, 
    0.14391239f, 0.04360273f, -0.02739900f, -0.11512030f, 0.21568513f, 0.22530919f, 0.14597639f, -0.02270026f, 
    0.29473281f, 0.13549289f, -0.00348282f, 0.22038367f, -0.10304358f, 0.12532020f, 0.15924628f, -0.16158193f, 
    -0.11958081f, 0.13573715f, -0.10151895f, 0.06176476f, 0.09428708f, -0.15487903f, -0.03086059f, 0.09052947f, 
    0.12201522f, 0.30887902f, 0.25645375f, 0.09218989f, 0.08791094f, 0.16555648f, -0.03659932f, 0.07655739f, 
    -0.58858502f, 0.31957340f, 0.08610654f, -0.24976093f, -0.09564038f, -0.10841653f, -0.08343786f, 0.08355276f, 
    0.07011490f, -0.04858837f, 0.01105106f, -0.11609669f, 0.16974677f, 0.06636031f, -0.37783912f, -0.17526793f, 
    0.02260751f, -0.02564074f, -0.12747991f, 0.04364588f, -0.10585184f, 0.10406617f, -0.19655715f, 0.01841868f, 
    -0.12461502f, 0.16845937f, 0.33105889f, -0.16956024f, 0.10278725f, 0.22991101f, 0.13361993f, 0.04344967f, 
    -0.20162122f, 0.10154157f, 0.14793454f, 0.04838898f, 0.00431155f, -0.09733256f, -0.00847027f, 0.38739249f, 
    -0.11163287f, -0.19469160f, -0.08761003f, -0.00954292f, 0.01773705f, -0.27019027f, -0.23034541f, -0.11390003f, 
    0.15372889f, 0.06445224f, 0.15677248f, -0.27354532f, -0.10522071f, -0.12493580f, 0.26949230f, -0.16872197f, 
    -0.13258965f, 0.04663185f, -0.09783002f, -0.05464550f, 0.03663855f, 0.17751075f, 0.00675961f, 0.21570665f, 
    0.13532506f, 0.20582642f, 0.02488455f, 0.02191033f, 0.08302844f, -0.15909563f, -0.01280234f, -0.02343218f, 
    -0.28076276f, 0.20411299f, 0.06768831f, -0.11483606f, 0.09942839f, -0.05055881f, 0.03542648f, -0.11000195f, 
    -0.06091563f, -0.19135985f, -0.07897338f, -0.05570668f, 0.16344999f, 0.08605185f, -0.07430020f, -0.08882886f, 
    -0.03410842f, 0.02190067f, -0.03515184f, 0.12017444f, -0.00179257f, 0.23144053f, 0.23360883f, 0.06395081f, 
    0.07621041f, 0.26979545f, -0.09595092f, 0.24993569f, 0.07237929f, 0.14099537f, -0.07334871f, 0.05023603f, 
    -0.00780553f, -0.05478101f, -0.09753977f, 0.19531815f, -0.16203776f, -0.36003926f, 0.53219765f, 0.16926283f, 
    -0.02036725f, 0.23589392f, 0.00250846f, -0.14431919f, -0.30047545f, -0.05042150f, -0.10734355f, 0.07923484f, 
    0.65844291f, -0.05637790f, -0.17323443f, -0.02849561f, -0.09510045f, -0.01075268f, -0.01058746f, -0.08771525f, 
    0.02336745f, -0.00080714f, 0.00272284f, 0.00170217f, 0.09953946f, 0.26959479f, 0.07559604f, 0.54596120f, 
    -0.12278746f, -0.19280063f, 0.06615809f, -0.00636779f, -0.15806876f, 0.01406794f, 0.30472955f, -0.11056858f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01700657f, 0.06936044f, -0.00103268f, 0.17855775f, 0.04271647f, 0.14637676f, 0.10243998f, -0.03139064f, 
    -0.01007298f, -0.10526337f, 0.06370610f, -0.06498213f, -0.17305449f, 0.04316447f, 0.04502768f, -0.12937780f, 
    0.01419200f, 0.07873928f, 0.06846176f, -0.00286843f, -0.00161879f, -0.05895437f, 0.07392253f, -0.01956394f, 
    0.01241285f, 0.04588123f, 0.20598938f, -0.02295363f, -0.06745864f, -0.00991935f, -0.00580375f, -0.09871891f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07324211f, -0.58931005f, -0.02569969f, -0.74620551f, -0.60548639f, -0.13013579f, -0.13866654f, -0.07592057f, 
    0.29228011f, 0.28226224f, -0.00809523f, -0.04652556f, -0.31229529f, -0.06979034f, -0.76266116f, 0.08830584f, 
    0.04627505f, 0.02135454f, 0.33172160f, 0.01299819f, 0.13028993f, 0.03538221f, -0.32724175f, 0.35247543f, 
    0.36833939f, 0.03250517f, -0.38770783f, 0.36876285f, -0.11746565f, 0.11481781f, 0.05239160f, 0.03862277f, 
    0.33475676f, 0.01902142f, -0.08508857f, 0.08500925f, 0.42906818f, -0.22967525f, 0.39353046f, -0.16479252f, 
    0.11096832f, 0.27721873f, 0.07310189f, -0.00886093f, -0.52798921f, -0.06431164f, 0.34890068f, -0.09750453f, 
    -0.13450930f, -0.03607506f, 0.31092393f, 0.16724691f, 0.14536850f, 0.07910258f, 0.50333267f, -0.33829707f, 
    -0.02459598f, 0.07016943f, -0.24581680f, 0.18793364f, -0.66407877f, 0.06644554f, -0.17790046f, -0.18313138f, 
    -0.38781491f, 0.10763454f, -0.03335647f, 0.15482631f, 0.28791195f, 0.17872508f, 0.00211617f, -0.07268275f, 
    -0.66813439f, 0.24994418f, -0.04779382f, -0.04419601f, 0.40258250f, -0.04287862f, -0.64121133f, 0.48809800f, 
    -0.05755793f, -0.34957933f, -0.01386357f, -0.03449794f, -0.05369832f, 0.12029808f, 0.33406061f, -0.66827232f, 
    0.13803482f, 0.10721169f, -0.56211668f, -0.30062956f, 0.28223574f, 0.53370023f, -0.23841989f, -0.14509520f, 
    0.26681444f, -0.68392581f, 0.12733370f, -0.24656096f, -0.35750431f, 0.00076657f, -0.19789034f, -0.16819167f, 
    -0.24330905f, 0.35938510f, -0.12816848f, -0.13429891f, -0.01649403f, -0.07887270f, -0.63598692f, 0.06367505f, 
    -0.07420376f, 0.25218439f, -0.10406286f, -0.01663452f, -0.11345258f, -0.73453844f, -0.67171842f, 0.25782838f, 
    -0.57583123f, -0.12552367f, 0.33501548f, -0.74940348f, 0.18672185f, -0.31838742f, 0.13378596f, 0.32728240f, 
    -0.06112745f, 0.04327176f, -0.12508932f, -0.60485029f, 0.36880457f, -0.39467937f, -0.30383343f, 0.01277163f, 
    -0.11205190f, -0.25794995f, 0.03039706f, -0.07001757f, -0.31478828f, 0.10238389f, 0.26731119f, 0.16382062f, 
    -0.08976052f, 0.17444284f, -0.55795813f, -0.08632256f, -0.06867102f, 0.38758835f, -0.54165488f, 0.03826931f, 
    0.07127644f, 0.04477493f, 0.30309376f, -0.07869915f, -0.13389692f, 0.19294690f, 0.39021087f, -0.08515208f, 
    0.08673456f, 0.41398898f, 0.08197663f, -0.24374241f, -0.77913743f, 0.51704782f, 0.34099159f, 0.02966194f, 
    0.18895061f, -0.15698932f, 0.05742953f, 0.04997905f, 0.09600034f, 0.16409931f, 0.06760354f, -0.64196527f, 
    0.01278857f, -0.19331260f, -0.16676727f, -0.11882661f, 0.12963398f, 0.23072509f, 0.00587145f, -0.03189412f, 
    -0.06292997f, -0.02501015f, 0.15446520f, -0.00592148f, -0.61123276f, -0.59656006f, 0.29484469f, 0.25195810f, 
    0.40639946f, 0.35569140f, -0.15828085f, -0.05873942f, 0.32048297f, 0.32256365f, -0.41886768f, 0.04385456f, 
    -0.37657183f, -0.65040463f, -0.07325198f, -0.12428178f, 0.23238084f, -0.00959916f, -1.24495125f, -0.01113851f, 
    0.08385103f, 0.25609270f, -0.23689859f, 0.06868486f, 0.14905804f, -0.41013700f, 0.54707372f, 0.12805764f, 
    0.17191258f, -0.05597331f, -0.26659599f, -0.03240690f, 0.44683146f, -0.41553795f, -0.36114672f, -0.13459790f, 
    0.03238931f, 0.11693202f, 0.17615829f, 0.17491880f, 0.05422451f, -0.37914625f, -0.42145836f, -0.12496375f, 
    -0.04574718f, 0.13631490f, -0.17917882f, -0.17805617f, 0.42990264f, -0.03597169f, 0.64436907f, 0.03866606f, 
    -0.00222193f, -0.17822415f, -0.25831822f, -0.08530365f, 0.12292559f, -0.13928135f, 0.08116207f, 0.11397834f, 
    -0.59652948f, -0.00184545f, -0.45483634f, -0.67735803f, 0.24601722f, -0.27167508f, 0.27074540f, 0.26529345f, 
    0.18194512f, 0.28302714f, -0.12542573f, 0.23755191f, -0.23109011f, -0.22356677f, 0.20700762f, -0.02843831f, 
    0.37370008f, -0.12110680f, -0.04162533f, 0.01314889f, 0.41223741f, 0.10770585f, -0.38149148f, 0.49086967f, 
    -0.03059760f, -0.66695637f, -0.08793291f, 0.02006726f, -0.00401286f, 0.40947407f, 0.31525931f, 0.06093160f, 
    -0.29517660f, 0.04034553f, 0.05365860f, -0.25861621f, -0.00354409f, -0.50257087f, -0.68560016f, -0.35817215f, 
    -0.02465643f, 0.34740442f, 0.06815921f, 0.35648441f, -0.18827349f, -0.50582474f, -0.39196268f, 0.08390886f, 
    -0.54797727f, -0.39738438f, -0.10222720f, -0.12501805f, 0.75541145f, 0.13338003f, 0.32528794f, -0.56412238f, 
    -0.17560303f, 0.07889056f, 0.13532327f, 0.03730821f, -0.10782796f, -0.09250184f, -0.21817872f, -0.17284107f, 
    -0.01263232f, -0.06747252f, 0.13500977f, 0.44740951f, 0.05241750f, 0.44636026f, 0.10886451f, -0.40331078f, 
    -0.56123734f, 0.24977081f, -0.14275435f, 0.55618238f, -0.30511618f, 0.42407364f, 0.23598999f, -0.07993498f, 
    -0.13956088f, -0.01999420f, 0.17155538f, 0.04952020f, -0.72872889f, 0.03401661f, 0.34635651f, 0.16724125f, 
    -0.16137886f, -0.00202119f, 0.35840294f, 0.11572330f, 0.05059923f, -0.59702396f, -0.73214787f, 0.20198062f, 
    -0.23502880f, 0.08635348f, 0.13646139f, -0.80583209f, 0.16354731f, 0.23941387f, -0.02006996f, -0.53175145f, 
    -0.78315610f, 0.03560654f, -0.01688685f, 0.30084610f, 0.28226355f, 0.17194141f, -0.08812518f, 0.11540300f, 
    0.48603353f, 0.17477940f, 0.15732713f, 0.07957099f, -0.36018586f, -0.03090179f, -0.99348980f, -0.00943299f, 
    0.10751455f, 0.17888577f, -0.58184588f, 0.10198529f, -0.00407212f, -0.14127462f, -0.58763093f, -0.36661074f, 
    0.18997259f, 0.15566640f, 0.18498784f, -0.22653848f, 0.15612173f, -0.20757793f, -0.32124493f, 0.52460837f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.24689491f, 0.19701728f, -0.00898776f, 0.10696182f, 0.11800314f, -0.08163473f, -0.11516783f, -0.06808666f, 
    0.01289134f, 0.04203036f, 0.06373570f, 0.06828764f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
