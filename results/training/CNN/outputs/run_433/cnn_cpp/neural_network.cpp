#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01888073f, -1.09238613f, -0.36044165f, -0.10024899f, -0.43218359f, -1.10185957f, 0.71857750f, 0.10378189f, 
    -0.30069193f, -0.72018856f, -0.96171689f, -0.74852043f, 0.15998319f, 1.49449682f, -0.32644671f, -0.14488146f, 
    -0.61272013f, -0.54617840f, 1.38348222f, -0.17388265f, -0.11350220f, -0.44596186f, 0.33690342f, -0.84082210f, 
    -1.00263679f, -0.57239705f, -0.64899516f, 1.33624291f, 1.04690468f, 1.45238876f, -0.21057610f, 0.55013645f, 
    0.02363833f, 0.26178166f, 0.18289812f, -0.19813187f, -1.47670794f, -1.33438313f, -1.32488477f, 0.12882002f, 
    0.42927617f, 0.97414917f, 0.18334621f, -0.06102644f, 0.11794144f, 0.66678679f, 0.91879171f, -0.16646601f, 
    0.19241774f, 0.88568938f, 0.91493934f, -0.64732039f, -0.40521106f, -0.92106098f, 0.05199715f, 0.90438145f, 
    -0.90152502f, -0.04541755f, -0.71837556f, -0.96068579f, 0.73900104f, -0.12537464f, -0.53957844f, -1.67265952f, 
    0.72327471f, 0.09839860f, 1.16662776f, 1.35088289f, 0.43180469f, 0.12016108f, -0.11426631f, 0.05151406f, 
    0.42779246f, -1.30428338f, -1.10826039f, -0.32001704f, -0.95259494f, -0.33043995f, -0.40648019f, 0.18357420f, 
    0.56671560f, -0.64345032f, -0.90261424f, -0.84911752f, 0.72637969f, -1.01278913f, -0.12347914f, -0.90327823f, 
    -0.09511637f, 0.09924070f, -1.41739082f, -0.00568150f, 1.05839717f, 0.28834748f, 0.98075283f, -0.76815438f, 
    -0.56348002f, 0.42651683f, 0.65190339f, -0.36365443f, 1.34158969f, 1.20934701f, -0.68866688f, -0.20744947f, 
    -0.81847167f, 0.14549270f, 0.48208150f, -0.23511773f, 0.57368714f, 0.17504269f, -0.78100908f, -1.39750862f, 
    -0.15371065f, -0.97328746f, 0.59658587f, 0.10849240f, 0.64128417f, 0.64696741f, 0.17135745f, 0.66214514f, 
    -1.15126526f, -1.44589305f, -0.75069445f, -0.50060165f, 0.35914159f, 0.38288781f, 0.17090032f, -0.62088633f, 
    0.19072986f, -1.21479261f, 0.05405786f, 1.11676383f, 0.52847761f, 0.01051717f, 0.72533566f, 1.33137715f, 
    1.38684452f, 0.55919296f, 0.63525611f, 0.10724319f, 0.10464054f, -0.42211461f, 0.67616260f, 0.64393800f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.33402967f, -0.07409024f, 0.04710710f, 0.54014099f, 0.42594436f, -0.17768456f, 0.15296151f, 0.04328756f, 
    0.16661571f, 0.07435842f, -0.07620953f, -0.08885011f, 0.48944560f, 0.23292358f, 0.42870578f, 0.33918220f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.10566910f, 0.12304477f, -0.14071698f, 0.04979850f, -0.05825544f, 0.28511474f, 0.15646556f, 0.13227142f, 
    -0.22008888f, 0.43445620f, -0.46010846f, -0.32306424f, 0.00257662f, 0.18164745f, 0.17223297f, 0.21186262f, 
    0.09830227f, -0.26685745f, 0.08414858f, -0.44023642f, -0.09438606f, 0.06327701f, 0.21978272f, 0.17105390f, 
    -0.27218634f, -0.20016564f, -0.27777755f, -0.12022732f, -0.03037727f, 0.13521491f, -0.02837732f, -0.07220817f, 
    0.01195007f, -0.00491645f, 0.18117604f, 0.05946443f, 0.66162974f, 0.50741839f, 0.11415465f, 0.04267136f, 
    -0.06080323f, -0.15723503f, -0.01543278f, 0.21657881f, 0.16499093f, 0.19305034f, 0.08308639f, 0.16442135f, 
    0.03393993f, -0.39594063f, -0.10023662f, 0.03482185f, 0.30896243f, -0.06813341f, -0.07625744f, -0.42801842f, 
    -0.52119410f, 0.04699285f, -0.08079385f, 0.06577694f, -0.08525471f, -0.03301882f, -0.01515914f, -0.45117447f, 
    0.04163351f, -0.02671801f, 0.11653116f, 0.24378252f, -0.14982235f, -0.08075083f, 0.09259547f, -0.27872786f, 
    -0.46257886f, 0.25445744f, 0.28374234f, 0.00041845f, 0.28899792f, 0.11898154f, -0.04950456f, -0.14555021f, 
    0.25649935f, -0.39094889f, -0.01215867f, -0.10766017f, 0.01257924f, 0.14237325f, 0.10592514f, -0.01737473f, 
    0.36379752f, 0.10159269f, -0.51265997f, -0.05754752f, -0.12907305f, -0.12162126f, -0.00260025f, 0.04772507f, 
    0.00730888f, -0.12325347f, 0.30987245f, -0.06222293f, -0.08578707f, -0.08251455f, -0.08401512f, 0.21288647f, 
    -0.01684253f, 0.12725668f, -0.11270943f, -0.05989066f, 0.56959635f, -0.63647246f, -0.34526747f, 0.00938630f, 
    -0.07905947f, 0.19542822f, 0.15600595f, 0.03102223f, -0.15388228f, -0.36765823f, -0.15283795f, -0.13861743f, 
    0.00746305f, 0.00986969f, 0.05279075f, -0.07051554f, -0.19297773f, 0.03533652f, -0.20619798f, 0.09556241f, 
    -0.22622116f, 0.38545179f, -0.05666668f, -0.09064967f, -0.02032955f, -0.07252245f, -0.00854080f, 0.00399876f, 
    0.27622154f, 0.25321528f, -0.11807943f, 0.30467439f, -0.02937678f, -0.01225947f, -0.15270050f, 0.49544007f, 
    -0.02902916f, 0.01301769f, 0.07006164f, 0.05076689f, 0.01904421f, 0.04015170f, -0.08677872f, -0.03287325f, 
    -0.02308563f, -0.07188789f, 0.05148146f, 0.02264388f, 0.06814279f, -0.07912339f, -0.07201394f, -0.07275048f, 
    -0.09639230f, 0.04740667f, 0.03910618f, 0.00602273f, -0.06215739f, -0.01517494f, -0.08535025f, -0.04455506f, 
    -0.05163724f, 0.06619950f, -0.07143012f, 0.00353048f, -0.03335778f, 0.05347039f, -0.08985230f, 0.00409157f, 
    -0.05358238f, -0.07111710f, -0.03542287f, -0.04951447f, -0.00753715f, -0.09864476f, -0.01988699f, 0.03304612f, 
    -0.08259915f, -0.06447461f, -0.07810003f, -0.08697698f, 0.04785150f, -0.00449264f, -0.08738627f, -0.01645189f, 
    -0.03593830f, 0.04224147f, -0.05508878f, 0.07317565f, -0.06592011f, -0.08280303f, 0.05088800f, 0.01706919f, 
    0.07168253f, -0.03294585f, -0.05257951f, 0.06927915f, 0.03134152f, 0.06415933f, 0.05760570f, -0.04877286f, 
    -0.01471798f, 0.01270689f, 0.00578135f, -0.04741481f, 0.03604370f, -0.05927207f, 0.01970973f, -0.01669897f, 
    0.00435835f, -0.06217561f, -0.00812337f, 0.04967411f, 0.06952556f, 0.00387604f, 0.00705697f, 0.04895657f, 
    -0.01824541f, -0.02862881f, -0.04244443f, -0.05683197f, 0.06872709f, 0.06648643f, 0.02534536f, -0.08624129f, 
    0.04658678f, 0.06335736f, -0.02083723f, 0.04119357f, 0.07541408f, 0.06146098f, -0.04809685f, -0.07614046f, 
    -0.04900882f, 0.04711667f, -0.06648559f, -0.05497383f, -0.03087796f, -0.02786031f, -0.05737454f, -0.08982584f, 
    -0.00934678f, -0.06427140f, -0.02937387f, -0.08688847f, 0.05339639f, -0.00199216f, 0.01146399f, -0.00398731f, 
    -0.01284337f, 0.03493588f, -0.05592053f, -0.03176223f, -0.08621691f, -0.02700715f, 0.06239836f, 0.00698501f, 
    0.05417065f, -0.05296742f, -0.07122516f, 0.05679025f, -0.01493496f, 0.02427128f, -0.05544471f, 0.00548560f, 
    0.03894530f, -0.07363082f, -0.05343003f, 0.04634626f, 0.06673155f, -0.03087453f, -0.08164606f, 0.03097877f, 
    0.00686608f, -0.01444608f, -0.03797758f, -0.07309285f, -0.02400143f, -0.06719025f, -0.00118867f, 0.07170362f, 
    0.16986848f, -0.36241743f, 0.03358788f, -0.09451125f, 0.10084736f, 0.00685271f, 0.22955087f, -0.11850928f, 
    -0.15242438f, -0.09643215f, 0.00001941f, 0.31997633f, -0.03132616f, 0.08594781f, -0.23685044f, 0.04658046f, 
    0.05495832f, 0.07372931f, -0.15265614f, -0.37660697f, 0.03821026f, 0.04296132f, 0.05267669f, 0.08232070f, 
    -0.05596409f, -0.05252948f, 0.01197527f, -0.21184418f, 0.15328248f, 0.08712087f, 0.00952695f, 0.08928629f, 
    0.16700029f, -0.14302880f, 0.05522690f, 0.11700223f, 0.16703443f, 0.32286972f, 0.51691628f, -0.07295914f, 
    0.04606021f, 0.03671898f, -0.06792793f, 0.04190895f, -0.06443197f, 0.28053609f, -0.25468233f, -0.37811702f, 
    0.00172473f, 0.04924262f, 0.00992059f, -0.06739394f, 0.13788141f, 0.08494438f, -0.02297099f, -0.43189487f, 
    -0.01646225f, 0.17273086f, -0.07843763f, 0.03102620f, 0.09348311f, 0.23194815f, -0.03250429f, 0.67070103f, 
    0.32801768f, 0.09787595f, -0.12191864f, -0.24477613f, 0.28357136f, 0.01739931f, 0.23308921f, -0.10583662f, 
    0.06483442f, -0.45459774f, -0.19799247f, -0.00308228f, -0.03612014f, -0.29564336f, -0.06921363f, 0.15356030f, 
    -0.11609995f, -0.63737822f, 0.14622399f, -0.08060877f, 0.06666712f, 0.08161110f, -0.04037117f, -0.17314783f, 
    -0.06257753f, -0.05335340f, 0.24749139f, -0.18065289f, -0.14051057f, -0.05323587f, -0.07639910f, -0.01922733f, 
    0.02301186f, 0.06968996f, -0.08628182f, 0.09227930f, -0.10895692f, -0.27685815f, 0.03443466f, 0.17814139f, 
    0.08075462f, -0.15062843f, -0.30411384f, -0.08785196f, 0.12139312f, -0.01489051f, -0.15466174f, 0.11466772f, 
    0.04705063f, 0.10462537f, -0.01252123f, -0.03423426f, -0.28092355f, -0.58331877f, 0.20477371f, -0.51380014f, 
    0.04504389f, -0.10869356f, 0.16151202f, -0.06588268f, 0.00325139f, 0.23122181f, 0.91400355f, 0.02551870f, 
    -0.41586995f, -0.04116319f, -0.04107805f, -0.04370647f, 0.03632536f, 0.03440472f, 0.12755099f, -0.12328769f, 
    -0.38806775f, 0.02354979f, 0.10406375f, -0.07834470f, 0.14843492f, 0.01446695f, 0.09015216f, 0.22597544f, 
    -0.09465507f, 0.12887247f, -0.07136423f, -0.23060827f, -0.25816402f, -0.08625764f, -0.47626162f, -0.15688071f, 
    0.04109337f, -0.21662870f, 0.32337096f, 0.08726224f, -0.34131941f, 0.17173742f, 0.10558151f, -0.14316946f, 
    0.14721854f, -0.12872913f, -0.28381833f, -0.18205130f, 0.04911559f, 0.31437144f, 0.29592636f, 0.00187995f, 
    -0.10460417f, -0.06377105f, -0.04565441f, 0.27811113f, -0.41949135f, -0.09895770f, 0.08321091f, 0.05672384f, 
    0.16601597f, -0.06525635f, 0.00525403f, -0.21199237f, -0.22037563f, 0.32915255f, -0.02132533f, -0.23043120f, 
    -0.07641622f, -0.10391847f, 0.00147529f, 0.40176803f, 0.17440520f, -0.26676241f, -0.38017413f, 0.24071361f, 
    0.09671860f, 0.01233336f, 0.05142864f, 0.01673898f, -0.11359266f, 0.26735234f, 0.40828097f, -0.14025113f, 
    -0.30453798f, -0.25757703f, 0.04825687f, 0.04461972f, 0.25152549f, 0.04131236f, 0.14661127f, -0.02439431f, 
    0.02111224f, 0.12366638f, -0.22795960f, -0.16504863f, -0.21419077f, -0.01940191f, -0.00348250f, 0.03563479f, 
    0.62488312f, 0.27484167f, -0.28875485f, 0.08236295f, -0.34890002f, -0.15773675f, 0.15491210f, 0.11204209f, 
    -0.23899007f, 0.21894255f, -0.05376960f, -0.15938228f, -0.13229653f, 0.00335269f, 0.03687132f, -0.03891024f, 
    -0.07938079f, 0.04594910f, -0.19822824f, 0.17839943f, 0.20455845f, -0.22457674f, -0.04313014f, 0.00759668f, 
    0.01428660f, 0.01997504f, -0.02500047f, 0.55233407f, -0.20729208f, -0.11470079f, -0.07108983f, 0.31887478f, 
    0.04587508f, -0.16178861f, -0.10391303f, 0.00476604f, 0.19872658f, -0.05265548f, -0.31703883f, 0.07930724f, 
    0.23238353f, -0.03018294f, 0.07098028f, -0.01470120f, 0.10360795f, 0.47965989f, -0.06116659f, 0.23376317f, 
    0.34139583f, -0.06052717f, 0.07867089f, 0.14189677f, -0.07089213f, 0.02463955f, -0.28025785f, 0.12131957f, 
    -0.22191826f, -0.06248699f, -0.03607969f, -0.08708832f, 0.02436845f, 0.31156099f, 0.06492609f, 0.04091289f, 
    -0.43686306f, 0.08419150f, 0.22304672f, 0.22918987f, 0.05705716f, 0.02441707f, -0.10282367f, -0.07814294f, 
    0.42618543f, 0.32648423f, 0.01952477f, 0.09480433f, -0.22852810f, -0.01854016f, -0.01361852f, 0.05770251f, 
    -0.01781536f, 0.16381402f, 0.45823357f, 0.20419529f, 0.06212088f, 0.18139458f, 0.06498722f, -0.06381405f, 
    0.12338579f, 0.14802691f, -0.25322151f, 0.05833903f, 0.29995173f, -0.11743710f, 0.05214906f, -0.03527026f, 
    -0.12435322f, -0.40326104f, -0.09714876f, -1.11513042f, -0.32443380f, -0.08785161f, -0.18086645f, 0.01785425f, 
    0.20304348f, 0.11633274f, 0.15946859f, 0.05646468f, 0.10946565f, 0.12966329f, 0.24732414f, 0.25932974f, 
    -0.04037938f, 0.04391433f, 0.07224882f, 0.10795303f, 0.17663155f, 0.10605510f, -0.14103307f, -0.21349184f, 
    -0.09986442f, -0.18704075f, -0.54124558f, 0.00913458f, -0.05704936f, 0.13827685f, 0.18250123f, -0.04241030f, 
    -0.01337310f, -0.14540401f, -0.00514503f, 0.09675360f, -0.03875504f, 0.03521493f, -0.26296368f, 0.24962045f, 
    0.08929642f, -0.03067560f, -0.05314130f, 0.00278348f, -0.23210353f, 0.10071828f, 0.33000058f, 0.13866794f, 
    0.47816408f, 0.43944281f, 0.14023912f, -0.13338976f, -0.35069481f, -0.15338817f, 0.13024880f, -0.00167944f, 
    -0.20093355f, 0.30239227f, 0.26201037f, 0.13161728f, 0.12009688f, 0.18474640f, -0.05920964f, -0.06167145f, 
    0.00626216f, -0.15638769f, -0.02002045f, 0.23753905f, 0.01039922f, 0.08300711f, -0.14275105f, 0.19905125f, 
    -0.21148600f, 0.01922995f, -0.04778278f, 0.10352135f, -0.35521436f, -0.01887848f, 0.14321595f, 0.12614036f, 
    -0.00117530f, -0.03467965f, -0.13235518f, 0.11591232f, -0.12662886f, -0.11461829f, -0.23655793f, -0.13669655f, 
    0.00281749f, -0.07709425f, -0.36020410f, 0.02072112f, -0.28302705f, 0.13678789f, -0.03932672f, 0.14488788f, 
    -0.03413108f, -0.11516625f, -0.11632811f, -0.23293287f, -0.27177632f, 0.05988604f, -0.26955432f, -0.21940678f, 
    -0.05677491f, -0.34939474f, -0.10430817f, -0.33127734f, -0.05513895f, 0.31761101f, 0.02359908f, -0.06907761f, 
    -0.20933861f, -0.30495280f, -0.31972870f, 0.06715741f, 0.11685005f, 0.06912548f, 0.31074199f, -0.14167690f, 
    0.18307678f, -0.04956652f, -0.39209732f, 0.10704210f, -0.08201621f, 0.16270833f, -0.21250476f, 0.27441037f, 
    -0.02668293f, -0.69518989f, -0.09441985f, 0.19701460f, 0.02027536f, -0.09734111f, 0.10451684f, -0.22087248f, 
    0.01297351f, 0.05863275f, 0.23267640f, 0.33131534f, -0.05392721f, 0.15755257f, -0.17365782f, 0.26451251f, 
    0.13463189f, 0.07299483f, -0.10717952f, 0.25881800f, -0.08265961f, -0.03318354f, 0.34523103f, 0.37743756f, 
    0.02533396f, 0.08743673f, 0.15065163f, 0.12902401f, -0.06877786f, 0.27092645f, -0.14843503f, 0.04764098f, 
    0.12450833f, -0.02804362f, -0.12969260f, -0.02961289f, 0.05874045f, -0.09222008f, 0.06751005f, -0.31059363f, 
    0.12763406f, 0.15019064f, 0.13900207f, 0.00274420f, -0.46072796f, 0.00637227f, 0.52557606f, 0.29635635f, 
    0.14034764f, -0.08771711f, -0.26651999f, -0.25736064f, 0.09914336f, 0.00700395f, -0.04163417f, -0.07620095f, 
    -0.22285713f, -0.18838456f, -0.15722108f, 0.02464221f, 0.04947777f, -0.16747539f, -0.06841230f, -0.18578823f, 
    0.19719531f, -0.12008254f, -0.21798371f, -0.49043092f, -0.05006711f, -0.19241551f, 0.37204349f, 0.05341479f, 
    -0.01518114f, -0.12395003f, -0.18565232f, -0.06468229f, -0.08009345f, -0.01578723f, 0.03901387f, -0.19341312f, 
    0.10413025f, -0.00563569f, -0.31655529f, 0.06891893f, 0.18905790f, -0.30601555f, -0.07896526f, 0.30271950f, 
    0.18350662f, -0.03670739f, -0.15397990f, 0.17689373f, 0.19098057f, -0.05768798f, -0.07038792f, -0.10179820f, 
    0.02739132f, 0.08871813f, -0.02046340f, 0.02135864f, 0.11670135f, 0.39527124f, -0.01835615f, 0.20291734f, 
    -0.13013230f, -0.24777891f, 0.18457612f, 0.22751155f, -0.12237895f, 0.21961680f, -0.16927260f, 0.04703995f, 
    0.10019594f, -0.11406925f, -0.05841380f, -0.02275713f, 0.11904330f, 0.16018669f, -0.21819521f, -0.00582037f, 
    0.19547002f, 0.06424646f, 0.08249021f, -0.10156050f, 0.27882290f, 0.35734311f, -0.21237093f, -0.12345379f, 
    -0.69948488f, 0.02883536f, 0.21875839f, 0.33569247f, 0.06312255f, 0.15875010f, 0.07413562f, -0.04082133f, 
    0.32556474f, -0.21017303f, -0.34021586f, 0.04169217f, 0.22222312f, 0.20712650f, 0.05812674f, -0.14114596f, 
    -0.04976708f, 0.21581101f, -0.31557354f, -0.47547150f, 0.23703250f, 0.11983711f, -0.03121506f, -0.01405062f, 
    -0.06580073f, 0.10367047f, -0.25270110f, -0.23886506f, 0.04601421f, 0.18690379f, 0.06594744f, 0.04605607f, 
    -0.11566221f, -0.09895907f, 0.12802500f, -0.35571805f, 0.21112077f, 0.33942690f, -0.03000958f, 0.13537985f, 
    0.02362143f, -0.09006310f, 0.15061878f, 0.03242275f, 0.12580828f, 0.05380760f, -0.01518348f, -0.03238331f, 
    -0.06359634f, 0.11005840f, -0.15480144f, -0.06274372f, -0.12331517f, -0.53435409f, 0.03277792f, -0.36449012f, 
    -0.22279383f, 0.02610187f, 0.00378845f, 0.26600739f, 0.04328764f, -0.04406229f, -0.08134280f, 0.02693913f, 
    0.18486212f, -0.03949757f, 0.00363987f, 0.02690453f, -0.07834800f, 0.09574711f, -0.07188491f, 1.12951112f, 
    -0.33932745f, -0.30220243f, 0.04897140f, -0.16781026f, 0.08172292f, -0.05024707f, -0.07906538f, 0.03354494f, 
    -0.07592423f, -0.31262940f, -0.26459140f, 0.06198283f, 0.10694837f, 0.05289750f, -0.04972506f, -0.00972627f, 
    -0.08933932f, -0.70170581f, -0.03416726f, 0.01740038f, -0.02584314f, -0.04118004f, -0.03184061f, 0.01815271f, 
    -0.04510356f, 0.15537795f, 0.54244214f, -0.32167748f, 0.09330950f, -0.11249060f, -0.03620912f, 0.14095142f, 
    0.04479930f, -0.03230628f, 0.04086568f, 0.56424487f, 0.09241949f, 0.18573076f, -0.12043709f, -0.07007732f, 
    -0.05159267f, -0.13375849f, -0.09632644f, -0.02230014f, -0.14057933f, 0.28730857f, -0.29185989f, 0.27787489f, 
    0.04849663f, -0.14437427f, -0.20504548f, 0.10853557f, -0.12378512f, 0.14585626f, 0.38640803f, 0.10001655f, 
    -0.17122012f, 0.13008872f, -0.03928932f, -0.11674666f, 0.19077687f, 0.07297179f, 0.27259269f, 0.10956473f, 
    0.15841417f, 0.12719569f, -0.13991734f, -0.10054120f, 0.09733426f, 0.24445447f, 0.04246763f, -0.52415878f, 
    0.04291754f, 0.07415566f, -0.38979548f, 0.24735655f, 0.09352002f, -0.03473670f, -0.01486451f, -0.18043047f, 
    -0.20994790f, -0.48210740f, 0.31134167f, 0.18529439f, 0.22498254f, -0.13139623f, 0.08495262f, 0.27604619f, 
    0.14261331f, -0.25222552f, -0.10091804f, -0.32765925f, -0.00135819f, -0.00843352f, 0.19174460f, -0.14774966f, 
    -0.21131428f, -0.12042975f, 0.37842858f, -0.09446079f, -0.04830867f, -0.04815141f, -0.19274585f, 0.29234350f, 
    0.47981477f, 0.46489796f, 0.25420782f, -0.31935793f, 0.28927392f, 0.51619667f, 0.13606329f, -0.11752617f, 
    0.12293924f, 0.14757001f, 0.01332333f, -0.02981848f, -0.34212857f, -0.16864446f, -0.56679767f, 0.61358994f, 
    0.38204524f, 0.15239605f, 0.29063421f, -0.17660297f, 0.07125453f, 0.33683228f, 0.06705258f, -0.13947809f, 
    -0.34430757f, -0.22930849f, -0.31047964f, 0.34807414f, 0.43453655f, 0.38361302f, 0.19641759f, 0.00495699f, 
    0.30105737f, -0.34274748f, 0.21654986f, -0.05131382f, -0.30670339f, 0.02742763f, 0.00398672f, 0.79076493f, 
    0.18679491f, 0.18028291f, 0.16351652f, 0.20284162f, 0.09523337f, 0.11473070f, -0.13554510f, 0.04591278f, 
    -0.22519974f, -0.32116055f, 0.22429295f, 0.32669073f, 0.07643344f, -0.22566953f, 0.15460807f, -0.07198772f, 
    0.04815963f, -0.55688375f, -0.32169396f, -0.20767476f, 0.29335290f, -0.07480495f, 0.05473167f, 0.10865127f, 
    -0.24492802f, 0.00978819f, -0.61098367f, -0.60436690f, 0.16464446f, -0.11966985f, 0.14612344f, 0.10109988f, 
    -0.12216134f, 0.25496909f, 0.06604100f, -0.14661147f, 0.08555257f, 0.30014941f, 0.06848588f, -0.06806453f, 
    -0.18293107f, -0.13245498f, 0.23028113f, 0.15238847f, -0.24069025f, -0.00128021f, 0.26189587f, -0.08942153f, 
    0.00829732f, 0.02679165f, 0.04824422f, -0.22624536f, 0.17216554f, 0.00948233f, 0.20263243f, 0.33438116f, 
    -0.27901280f, -0.07905676f, -0.04652165f, 0.12068141f, 0.31992295f, 0.37017143f, -0.33792615f, -0.54172635f, 
    -0.29379332f, 0.04963544f, -0.12092866f, -0.07048649f, 0.14869608f, -0.03932930f, -0.18609683f, -0.14494646f, 
    0.17280297f, 0.29652908f, -0.15023354f, -0.03676741f, 0.15473299f, 0.17921923f, -0.05974141f, -0.24184887f, 
    0.05182878f, -0.05278244f, -0.04288267f, -0.02557990f, 0.02040935f, -0.01730953f, -0.08562461f, 0.00305056f, 
    -0.05443991f, -0.07836264f, 0.04533066f, 0.07955126f, -0.04166742f, -0.00128318f, -0.00705530f, 0.04603220f, 
    0.03849642f, -0.00905998f, -0.03958640f, 0.07722219f, 0.04738964f, 0.01734831f, -0.04884338f, 0.05817585f, 
    0.04352815f, 0.02882743f, 0.02344562f, -0.00869638f, -0.06951191f, -0.07428407f, -0.00057275f, 0.02378784f, 
    0.05982757f, 0.01311461f, 0.04547185f, -0.07467322f, -0.04518763f, 0.00324286f, -0.08198784f, 0.03291057f, 
    0.05050600f, 0.02884486f, -0.00211401f, 0.03851267f, 0.03474651f, 0.03500913f, -0.05977767f, 0.04969177f, 
    0.00695402f, 0.01156870f, -0.03464381f, -0.01667411f, -0.06231153f, 0.02255930f, 0.05899811f, -0.05799922f, 
    -0.03808705f, -0.06712246f, 0.01826372f, 0.06344241f, -0.01065776f, -0.00655735f, 0.02495512f, 0.05000991f, 
    0.02473175f, 0.03936880f, 0.03545474f, -0.07667147f, -0.02389277f, 0.04711276f, 0.02753301f, -0.05664395f, 
    -0.03285304f, -0.06827968f, -0.05862328f, -0.04918492f, -0.05093655f, -0.01725646f, -0.06590914f, -0.03279501f, 
    -0.08392214f, 0.01262212f, -0.00235844f, 0.03111163f, -0.07875492f, 0.07358609f, -0.06748712f, 0.00896469f, 
    -0.07345331f, -0.00675632f, -0.07534357f, -0.03788693f, -0.04724628f, 0.03325533f, -0.03244470f, 0.05540642f, 
    -0.07269873f, -0.04691796f, -0.04580978f, -0.04596682f, -0.08584671f, 0.06978868f, -0.01231989f, -0.01043299f, 
    -0.03466107f, 0.01128395f, -0.04976929f, -0.07899252f, -0.01724386f, -0.05454496f, 0.00460257f, 0.02415042f, 
    -0.07824115f, -0.04784817f, -0.03038510f, -0.04059174f, 0.07487061f, -0.05697611f, -0.03131277f, 0.02875502f, 
    0.04789640f, -0.08169492f, -0.02197599f, -0.04012062f, -0.04814829f, 0.00808864f, -0.01396028f, -0.00819343f, 
    0.02504039f, -0.02487852f, 0.06890588f, 0.00146384f, -0.02164836f, -0.08115780f, -0.03829006f, 0.04058030f, 
    -0.06794011f, 0.00761804f, -0.04419056f, 0.01381757f, 0.04001186f, 0.04910543f, -0.01083845f, 0.03780478f, 
    0.39968181f, -0.03356512f, -0.21111630f, -0.06349149f, -0.23683448f, 0.26889259f, -0.04816779f, 0.00476773f, 
    -0.15043536f, 0.32770857f, 0.48765320f, 0.11285315f, 0.34296969f, 0.11394472f, -0.11357018f, -0.26548928f, 
    0.04846162f, -0.08406860f, -0.15319248f, -0.36047524f, 0.02794808f, 0.03764149f, 0.05724018f, 0.02613401f, 
    -0.39390832f, -0.00642591f, 0.13919543f, 0.31254026f, -0.43194780f, -0.16852580f, -0.17780447f, -0.17328529f, 
    0.09935991f, 0.05420416f, 0.16122970f, 0.04118096f, -0.11237741f, 0.09183113f, 0.18701388f, 0.30064058f, 
    0.17505527f, -0.09710885f, 0.10379543f, 0.18860930f, 0.03886109f, -0.12075041f, -0.16502336f, -0.48230395f, 
    0.21144751f, 0.14875683f, -0.20645927f, 0.06107349f, 0.17837261f, -0.05715685f, -0.17985713f, -0.07374260f, 
    0.09117491f, 0.01199392f, -0.03005654f, -0.10110302f, -0.07044959f, 0.10890985f, -0.30020157f, -0.52846819f, 
    0.15071537f, -0.01919302f, 0.11365490f, 0.23976374f, -0.05029795f, 0.05777751f, 0.05824816f, 0.30687231f, 
    0.25974131f, 0.08916458f, -0.00328381f, -0.01190161f, -0.08986315f, -0.16124789f, 0.16017501f, 0.05700688f, 
    0.00628189f, 0.90586889f, 0.18926501f, 0.21172407f, -0.00006831f, 0.37356195f, 0.25261325f, 0.09460997f, 
    -0.09738833f, 0.11908347f, 0.05312308f, 0.05154710f, -0.33181798f, -0.14237396f, -0.15040065f, -0.25041589f, 
    -0.21793140f, -0.10367601f, -0.08141877f, 0.45249498f, -0.61011380f, -0.12240812f, -0.14295228f, -0.13897611f, 
    0.20843436f, 0.00606944f, 0.07249248f, -0.04593482f, -0.11941444f, -0.06063720f, -0.04143365f, 0.11403603f, 
    -0.23555753f, 0.09885237f, 0.01214867f, -0.20514205f, -0.00686761f, 0.13567668f, -0.04786824f, -0.10028359f, 
    -0.50810021f, -0.19417545f, 0.05999847f, 0.02851495f, -0.03527543f, 0.04254575f, -0.32764518f, 0.11385129f, 
    -0.22925538f, -0.16849910f, -0.01812777f, -0.11066307f, 0.11341701f, 0.21275121f, -0.09222691f, 0.49710128f, 
    0.16542773f, 0.09142708f, 0.11250173f, -0.10124496f, -0.06967182f, 0.39489263f, -0.03547511f, 0.23051868f, 
    0.09339372f, 0.18237501f, 0.15441377f, -0.30152032f, 0.15478654f, 0.30113539f, -0.10085781f, -0.04581736f, 
    -0.04987752f, -0.64459646f, -0.11295345f, 0.36649537f, 0.02773216f, -0.02225134f, -0.07895737f, -0.09494410f, 
    0.12427431f, 0.55720711f, 0.35178772f, 0.19299720f, 0.07134779f, -0.03419000f, -0.08514779f, 0.20156384f, 
    -0.06601164f, -0.07276793f, -0.16397974f, 0.21622929f, 0.25505632f, 0.11053446f, 0.25295582f, -0.09378634f, 
    0.17382088f, -0.07132632f, -0.05695112f, -0.41045251f, 0.16214649f, -0.07244384f, 0.30034739f, -0.05965932f, 
    -0.07663062f, 0.11689188f, -0.10354126f, -0.11967320f, -0.03953952f, -0.44259673f, -0.07123606f, 0.22909018f, 
    -0.09357162f, 0.04442015f, 0.33489966f, -0.26075932f, -0.09746899f, -0.05374902f, 0.29950866f, 0.03520333f, 
    -0.39159158f, -0.09932613f, 0.07949202f, -0.36183381f, -0.05959787f, 0.14719445f, -0.09607913f, 0.05465937f, 
    -0.52986497f, 0.05910824f, 0.06576174f, 0.20945801f, 0.15542391f, -0.28041059f, 0.14578223f, -0.04504255f, 
    0.55638641f, 0.00972259f, 0.12820201f, -0.01359926f, -0.15689912f, -0.23224729f, 0.18209356f, 0.17744589f, 
    -0.14609443f, -0.27117494f, 0.08494454f, 0.28577483f, -0.11536703f, -0.14314130f, 0.05379943f, -0.05542481f, 
    0.05263769f, -0.08350357f, 0.13732100f, -0.14315018f, -0.70107687f, -0.27679768f, 0.11975987f, -0.06421266f, 
    0.06110003f, 0.03491285f, -0.07400879f, 0.52985507f, 0.28891903f, 0.05283986f, -0.28807563f, 0.07878602f, 
    -0.16228139f, 0.01626420f, 0.12550710f, 0.13420103f, 0.21093088f, -0.15477014f, -0.01149263f, 0.38518173f, 
    0.12258714f, -0.14529505f, -0.01707496f, 0.01683052f, 0.01705587f, -0.21744005f, 0.10122127f, 0.07700102f, 
    0.09493789f, 0.09377149f, -0.33136871f, 0.04653778f, 0.11678036f, -0.48310000f, -0.22170220f, -0.09929390f, 
    0.01264929f, -0.16097565f, 0.12414994f, -0.08829368f, -0.00733050f, -0.39034060f, -0.07583228f, -0.14867567f, 
    0.23427086f, 0.11902253f, 0.16866329f, 0.01961866f, 0.19989403f, -0.08562117f, 0.12302928f, -0.12376200f, 
    -0.27721494f, -0.17142697f, 0.07569346f, 0.09903788f, 0.02760644f, -0.12232002f, -0.16492547f, 0.07526511f, 
    -0.04573016f, 0.26834559f, -0.04168947f, -0.49438196f, -0.16439840f, 0.03370868f, 0.08894429f, 0.35174099f, 
    -0.11816785f, -0.36841020f, 0.23845246f, -0.27085853f, 0.06260528f, -0.07196230f, 0.11065660f, 0.22497803f, 
    0.07934137f, 0.17723171f, 0.08998067f, 0.47321004f, 0.22708966f, -0.10769812f, -0.09878333f, -0.24887896f, 
    -0.06613952f, -0.10431677f, 0.13343197f, -0.04882008f, 0.16519670f, 0.70592624f, -0.21636203f, -0.07523178f, 
    0.15244308f, -0.00638530f, 0.15102376f, -0.06524358f, -0.02085970f, 0.25134534f, 0.06160880f, -0.10724115f, 
    0.06588855f, -0.35089990f, -0.28923643f, -0.06524938f, 0.24109904f, -0.08773765f, -0.25582212f, -0.20939031f, 
    -0.32401603f, 0.00060770f, 0.04602133f, 0.34603897f, 0.26948273f, -0.25046486f, -0.01136999f, 0.23586798f, 
    0.13820289f, 0.09437171f, -0.00358647f, -0.25025690f, -0.30677047f, 0.03219961f, -0.15470338f, 0.12538205f, 
    -0.54776245f, 0.08026955f, 0.18206967f, -0.12869360f, 0.20210449f, -0.12627932f, -0.13308369f, -0.07381725f, 
    -0.42299458f, 0.28466880f, -0.10609214f, -0.32800257f, -0.25866571f, 0.10950511f, -0.14004171f, 0.17044680f, 
    -0.02074700f, -0.11712803f, -0.52895564f, 0.02336031f, 0.32948861f, -0.00565450f, 0.04383923f, -0.01462674f, 
    0.04708937f, -0.22081622f, 0.03080483f, -0.06050716f, 0.09370271f, -0.46232939f, 0.05150001f, -0.07826135f, 
    0.00608451f, 0.09361235f, -0.14797273f, 0.02138077f, 0.07061259f, -0.01116027f, 0.17752948f, 0.14790936f, 
    0.07086326f, 0.29246309f, -0.15231599f, -0.22122912f, 0.26838353f, 0.25843686f, -0.04185082f, 0.17063124f, 
    0.15529643f, -0.01021761f, -0.01461556f, -0.14712091f, -0.07411081f, 0.29466248f, -0.17102487f, 0.09599859f, 
    -0.16736378f, 0.08521367f, -0.25114939f, 0.14515805f, 0.03644259f, -0.00571859f, 0.13473852f, 0.25527927f, 
    0.39342314f, 0.11074910f, 0.08074432f, -0.13850448f, -0.16905299f, -0.06321133f, 0.41910118f, 0.17826803f, 
    0.11956590f, -0.06692713f, -0.19739333f, 0.21464074f, 0.02803852f, 0.25100112f, -0.26143366f, -0.01595215f, 
    0.10996759f, 0.10714830f, -0.11950875f, -0.46490163f, -0.25710014f, -0.25395367f, 0.08102915f, -0.02620568f, 
    -0.03574530f, -0.16219686f, -0.69329417f, -0.11924925f, 0.15824546f, 0.07894389f, 0.06322736f, 0.27719378f, 
    -0.22548760f, -0.02260313f, -0.39816830f, -1.40504098f, -0.29028106f, -0.24487413f, 0.25441393f, 0.21522695f, 
    0.00216327f, 0.05671671f, 0.04510131f, 0.10711284f, 0.38340583f, -0.03721073f, 0.05679538f, 0.07208823f, 
    -0.02869010f, -0.14397112f, -0.20377439f, 0.19080515f, -0.03616344f, 0.05746439f, -0.56272417f, 0.26892003f, 
    -0.12218732f, -0.07160763f, -0.09190086f, -0.07412626f, 0.02875883f, 0.07015780f, 0.00769250f, 0.11988647f, 
    0.14867273f, -0.11022652f, 0.25649154f, 0.14036018f, 0.05024483f, 0.06779456f, -0.03053346f, 0.17841794f, 
    0.09772573f, -0.14865667f, 0.21500959f, 0.14926378f, -0.04385887f, 0.06330895f, 0.07658314f, -0.01179658f, 
    -0.08025529f, -0.13254189f, -0.13728638f, -0.03519704f, 0.05786114f, -0.08379374f, 0.16626664f, 0.14975528f, 
    0.08402879f, -0.19103034f, 0.23724870f, 0.20500650f, -0.02229447f, -0.03307346f, 0.16564198f, 0.08893386f, 
    0.06855577f, 0.19941525f, -0.25139526f, -0.11822840f, -0.54778767f, -0.03939113f, 0.11216973f, 0.06962994f, 
    0.30725563f, 0.32239494f, 0.14179866f, -0.17689975f, 0.45544377f, -0.25374264f, 0.07868107f, -0.07904056f, 
    0.00970128f, -0.19359341f, -0.19371247f, -0.10878993f, 0.19970782f, 0.16779852f, 0.41460925f, 0.40524226f, 
    -0.14878856f, -0.03220677f, -0.22727218f, -0.05728871f, 0.38869467f, 0.12711668f, 0.30261052f, 0.18582758f, 
    0.18744139f, 0.07178720f, 0.01326821f, -0.18901798f, 0.07458772f, -0.12125493f, 0.17680290f, -0.14138381f, 
    0.16241130f, 0.00849427f, 0.19485258f, 0.14193006f, 0.23181619f, 0.07712682f, 0.05722541f, -1.33806002f, 
    -0.44450483f, -0.42130485f, 0.07838032f, 0.12716307f, -0.01474432f, 0.22730282f, -0.14307727f, 0.19495116f, 
    0.10034978f, 0.04622501f, 0.03152611f, 0.11888729f, 0.16286604f, -0.22299084f, 0.08248196f, 0.00508204f, 
    -0.10895714f, -0.17932294f, 0.48231623f, 0.38920414f, 0.06527279f, -0.11141400f, 0.03518176f, -0.07966383f, 
    0.35138351f, 0.18071191f, -0.13168263f, 0.27325779f, -0.33832818f, -0.48824668f, 0.24925873f, 0.22374015f, 
    0.18656521f, 0.03731737f, 0.15199167f, -0.07642689f, 0.03447401f, -0.44573808f, -0.07298148f, -0.04753914f, 
    0.10296604f, 0.04658996f, -0.01066929f, 0.03951471f, -0.06048780f, -0.26291287f, 0.06842421f, 0.45246843f, 
    0.19912823f, 0.14692062f, 0.34977433f, -0.24052444f, 0.13987713f, -0.23418021f, 0.24783733f, -0.35522562f, 
    0.04350516f, 0.27101240f, 0.31358171f, 0.18835428f, -0.13450678f, -0.27320549f, -0.23126447f, 0.44800016f, 
    0.23331220f, -0.02287656f, -0.24676341f, 0.00737229f, 0.08466955f, -0.00065796f, 0.29504311f, 0.33112717f, 
    0.28322038f, 0.25914666f, -0.19199614f, -0.15361707f, 0.38274199f, -0.01321858f, -0.02550828f, -0.31015831f, 
    0.41223985f, 0.10283935f, -0.12978326f, 0.09731817f, 0.05717681f, 0.16463161f, -0.08891232f, 0.23215324f, 
    -0.27345034f, 0.31090164f, 0.06825393f, 0.05099037f, -0.06504606f, -0.02768205f, -0.14621881f, 0.02194334f, 
    -0.06587876f, 0.20709145f, 0.04174910f, -0.06674803f, -0.08313601f, 0.14385678f, -0.21964876f, -0.01008615f, 
    -0.02712891f, 0.10393587f, -0.30011666f, -0.24764103f, 0.18650584f, -0.04418842f, -0.22499238f, -0.09353899f, 
    -0.02673745f, 0.02756783f, 0.02392484f, -0.05221613f, -0.13794422f, 0.19119194f, 0.03136459f, -0.09297008f, 
    0.03529639f, -0.17710602f, -0.13507819f, 0.17925966f, 0.17120685f, 0.05709529f, 0.02485975f, -0.16762994f, 
    -0.24204506f, -0.08023565f, -0.17989692f, -0.15638342f, -0.00445004f, -0.14522254f, -0.00765019f, -0.16604123f, 
    -0.43938598f, -0.19903354f, 0.05004001f, -0.24641766f, 0.09591109f, -0.19785830f, -0.27750731f, -0.15705132f, 
    0.16293885f, 0.00926849f, 0.07574893f, 0.10572393f, 0.02275199f, -0.04711690f, 0.00613765f, -0.15451634f, 
    -0.04600935f, 0.10701725f, 0.35186654f, 0.11905194f, -0.13335903f, -0.16960840f, 0.05786933f, 0.08014315f, 
    0.04273369f, 0.10565614f, -0.22376107f, 0.15506552f, -0.06905216f, -0.30772203f, 0.06026919f, 0.08617423f, 
    -0.00085360f, -0.02189243f, 0.54696918f, -0.05833764f, 0.13749687f, -0.21473657f, 0.05876069f, 0.13336760f, 
    -0.05850281f, -0.02486538f, 0.20095035f, -0.13544732f, 0.38636968f, -0.10854129f, 0.49142030f, -0.11611277f, 
    -0.03068592f, -0.07729990f, 0.10195319f, 0.04588937f, -0.41978133f, -0.34768060f, 0.75577825f, -0.18856092f, 
    0.01264731f, 0.01581951f, -0.17840873f, 0.15248974f, -0.00981461f, 0.24100880f, 0.02222224f, 0.17581576f, 
    0.06398652f, 0.01183300f, -0.12853071f, 0.08471753f, 0.04299007f, -0.02951769f, -0.02526182f, 0.26858416f, 
    -0.34383669f, -0.05022556f, 0.17230202f, -0.07124465f, -0.10857286f, 0.26822662f, 0.05252072f, -0.18502221f, 
    0.14883572f, -0.06881801f, -0.08668422f, -0.21470654f, 0.11818957f, -0.15223478f, -0.11909845f, 0.08086328f, 
    0.03183484f, 0.30325124f, 0.02960062f, 0.01452133f, -0.03284797f, -0.12698479f, 0.13291724f, -0.08176911f, 
    -0.03649555f, -0.32218042f, -0.18918587f, 0.14754684f, -0.07277720f, -0.01998647f, -0.03456701f, -0.00666243f, 
    -0.06159111f, 0.20192343f, -0.41743055f, 0.14206412f, -0.01994679f, 0.01068586f, -0.10242885f, -0.03093681f, 
    0.04115857f, -0.20434205f, 0.12600434f, -0.26745149f, 0.30325782f, -0.65194285f, -0.15822555f, -0.24940841f, 
    -0.05834772f, 0.20165387f, -0.05365913f, -0.17392956f, 0.10195318f, 0.10996418f, -0.76178443f, 0.22482842f, 
    -0.15047592f, 0.02822571f, -0.17836408f, -0.16164136f, 0.02520371f, -0.12581572f, 0.21522844f, -0.43491039f, 
    0.20669763f, 0.05252289f, -0.05266318f, 0.22143179f, -0.00967342f, -0.10681124f, 0.04984348f, -0.19309585f, 
    0.36657095f, -0.13874997f, 0.04838015f, 0.00380679f, 0.11865672f, 0.05595377f, 0.17898948f, 0.27564320f, 
    0.10043807f, -0.13632731f, 0.23277327f, -0.19643091f, -0.01687120f, -0.07078846f, 0.05062066f, 0.01410828f, 
    0.11201799f, -0.15215306f, -0.60072672f, -0.24610804f, 0.24678835f, 0.03139651f, -0.08727582f, 0.04813493f, 
    0.05434657f, -0.41459146f, -0.35472983f, -0.66530031f, -0.07955407f, 0.06779915f, 0.17186928f, -0.24775253f, 
    -0.07974949f, -0.05689974f, 0.11817834f, -0.12733448f, -0.05875409f, 0.07578006f, 0.09797392f, -0.10060480f, 
    -0.18345925f, 0.14732607f, 0.17284721f, 0.57205075f, 0.35277009f, 0.34177825f, 0.03274466f, -0.09017615f, 
    0.07709339f, 0.12152713f, -0.01177615f, -0.15752156f, -0.40259513f, 0.05358950f, -0.08979974f, 0.04437301f, 
    0.01282202f, 0.23106627f, -0.04974996f, -0.16913064f, -0.05876294f, 0.27542824f, 0.03724848f, 0.34844229f, 
    -0.10091817f, -0.05567203f, 0.10431775f, -0.26114771f, 0.10473175f, 0.12445228f, -0.01529228f, -0.04934083f, 
    0.23677360f, 0.15754318f, 0.06074204f, 0.07385191f, 0.23887035f, -0.13441753f, 0.17788514f, -1.24209678f, 
    -0.26579821f, 0.08052164f, -0.01154987f, 0.06803087f, -0.08723312f, 0.07373097f, -0.02971868f, 0.01550651f, 
    -0.16654371f, -0.06575537f, -0.44104171f, -0.06212757f, -0.01160029f, -0.25808817f, -0.05378910f, -0.03627259f, 
    0.02102665f, -0.13881183f, 0.18457620f, -0.26743680f, -0.14130814f, -0.18128963f, -0.11138513f, 0.24218762f, 
    0.13882932f, -0.03000627f, -0.53494203f, -0.37339324f, -0.23592430f, -0.02878193f, -0.04039400f, 0.18213840f, 
    0.14461358f, -0.02394723f, 0.21289150f, 0.44105309f, 0.13979638f, -0.32786271f, -0.08314984f, 0.01088763f, 
    -0.14249703f, 0.07963709f, -0.08563837f, -0.05911851f, 0.13936771f, -0.07965553f, 0.23841526f, 0.23850949f, 
    -0.02551586f, 0.09979254f, 0.15419456f, -0.24370593f, -0.04068332f, 0.32953390f, 0.36848953f, -0.14123131f, 
    -0.01322797f, 0.11522569f, 0.15587074f, 0.07182194f, 0.21197790f, 0.24278940f, -0.13011971f, 0.19267394f, 
    0.08674812f, 0.05861926f, 0.09968001f, -0.08887590f, 0.10338400f, -0.12091800f, 0.17675504f, 0.59286678f, 
    0.02787365f, 0.11983562f, -0.23212783f, 0.06349247f, -0.12205165f, 0.12303250f, -0.01087918f, 0.06523106f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.23445056f, -0.04714921f, -0.05280913f, -0.22816145f, -0.28579462f, 0.16378535f, 0.00673305f, 0.37885284f, 
    0.05909047f, -0.05917950f, -0.00361152f, -0.00540741f, 0.36983767f, -0.01346348f, 0.02677885f, 0.00588804f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21499281f, 0.16572398f, -0.08797035f, -0.39120752f, -0.19505423f, -0.51327074f, -0.32519221f, 0.41827565f, 
    0.19318810f, -0.13414052f, -0.42731428f, 0.80066806f, -0.03811772f, 0.51905441f, -0.47168601f, -1.05253458f, 
    1.06876528f, -0.00968372f, -0.31482360f, -0.31185398f, 0.06735110f, -0.46370730f, -0.35577711f, 0.11572354f, 
    -0.22462058f, -0.10990720f, -0.07978944f, 0.57384211f, -0.12931597f, -0.52014554f, -0.37638840f, 0.02797202f, 
    -0.60798639f, 0.23757471f, 1.16607726f, -0.20689502f, -1.42709970f, -0.42945623f, 0.63702464f, -0.35893950f, 
    -0.10619985f, -0.75489199f, 0.33233112f, 0.09433192f, 0.06566732f, 0.13682668f, 0.10269190f, -0.12535740f, 
    -0.18855561f, 0.06954671f, -0.39403304f, 0.77164423f, 0.31441930f, 0.47117835f, 0.18606065f, -0.41408744f, 
    -0.22335765f, -0.41023770f, 0.34942472f, -0.64437819f, 0.17177354f, 0.09430158f, 0.07754749f, -0.48855379f, 
    -0.16382599f, -0.13200420f, 0.05706221f, -0.53318352f, -0.09801984f, 0.28032643f, -0.63986117f, 0.36156112f, 
    0.08499064f, -0.31772482f, 0.74951810f, -0.67126751f, 0.07489448f, 0.27401739f, -0.05023915f, -0.39319634f, 
    0.20054761f, -0.01637214f, -0.22639431f, -0.71224993f, 0.53026551f, 0.15570801f, -0.33228558f, 0.39719090f, 
    0.13441782f, 0.09645473f, -0.65656340f, 0.07680313f, -0.45475313f, -0.24394578f, -0.83393282f, 0.32104704f, 
    -0.37483895f, -0.04357653f, -0.74306750f, -0.16524331f, -0.25904566f, 0.37253973f, 0.74821502f, -0.09609859f, 
    0.05903722f, -0.19430156f, -0.06972895f, -0.20638466f, -0.31267706f, -0.07276849f, -0.44122058f, 0.81559318f, 
    -0.23523295f, -0.16242629f, 0.29744866f, 0.27659759f, 0.75698030f, -0.92747724f, -0.48266479f, -0.48149046f, 
    0.03371372f, 0.37535647f, 0.12662800f, 0.24616516f, -0.46352935f, 0.66653645f, -0.52883279f, -0.30438840f, 
    0.47834259f, -0.00536657f, 0.24507463f, 0.66297710f, 0.08973315f, -0.13601649f, -0.59249187f, -0.23722206f, 
    0.22040641f, 0.18673451f, -0.58727705f, -0.05018877f, -0.88609195f, -0.81216884f, 1.09096527f, 0.18342121f, 
    -0.71077877f, 0.05144042f, -0.27708840f, -0.41317064f, -0.01135099f, 0.24545278f, 0.43551224f, 0.13839395f, 
    -0.18468659f, -0.03391308f, -0.18343218f, -0.27545393f, -0.34291747f, 0.27252105f, 0.91227448f, -0.08885628f, 
    0.33351895f, -0.15272583f, 0.44425085f, 0.08217619f, 0.00326071f, 0.17533238f, -0.29573023f, -0.61522728f, 
    -0.21240649f, -0.37053534f, -0.20138064f, 0.00965750f, 1.15660512f, -0.38643453f, -0.24868293f, -0.23935519f, 
    -0.24478602f, -0.07089347f, -0.14116980f, 0.70722181f, -1.07828355f, 0.60639107f, 0.02682151f, -0.67022204f, 
    0.06514549f, 0.89584267f, 0.23580441f, -0.26285586f, -0.25370112f, -0.13005108f, -0.57221013f, 0.04915140f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.22620074f, 0.35291865f, -0.35872790f, -0.00460030f, 0.06079491f, 0.35268587f, -0.14085612f, -0.33037007f, 
    -0.52547956f, 0.00762949f, 0.03641785f, 0.05133879f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
