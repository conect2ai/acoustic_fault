#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.27664661f, -0.57795668f, 0.54212451f, 0.67502135f, 0.18528882f, -0.20232558f, -0.31754228f, -0.67732930f, 
    0.37306526f, -0.74329132f, -0.64345568f, -1.14627135f, 0.54651070f, 0.66698158f, -0.34299615f, -0.49969536f, 
    -0.66457099f, -0.84536475f, 0.16755454f, 1.06817770f, -0.41372669f, -0.95210642f, 0.44924182f, 0.43384886f, 
    -0.29360089f, 0.28119701f, -0.32635555f, 0.80449933f, -0.81744230f, -0.75275660f, -0.48070118f, 1.05658770f, 
    0.40457895f, -0.09974919f, -0.03641811f, -0.67583483f, 0.69934565f, 0.81198782f, -0.81576329f, -0.80037415f, 
    -0.33598515f, -0.61487025f, -0.63861501f, -0.59123033f, -0.58121508f, 0.76880741f, -0.23010273f, 0.41281024f, 
    0.30463722f, 0.27161482f, 0.33214021f, -0.37956825f, 0.44756904f, -0.11154654f, 1.10359514f, -0.48486853f, 
    0.57634813f, 0.21317743f, -0.51000333f, -0.44984299f, 0.13603005f, -0.14250389f, -0.05874806f, -0.25802895f, 
    -0.72575957f, -0.05424129f, -0.54570884f, -0.98185217f, -0.57737565f, 0.53963155f, 0.88830084f, 0.48764244f, 
    1.36713648f, -1.30127740f, -0.13894379f, 0.77882254f, 0.45278767f, -0.67295825f, -0.31052756f, -0.11984965f, 
    -0.03283979f, 0.06492215f, -0.46281335f, -1.02607572f, 0.60977596f, 0.24819113f, 0.42753536f, -0.34847006f, 
    0.85681105f, 0.14461692f, 0.24082036f, -1.31840885f, 0.29413241f, -0.26800910f, -0.35000768f, -0.55998272f, 
    0.77247941f, -0.85527849f, -0.58430314f, -0.13858631f, 0.48353577f, 0.14926496f, 0.27193320f, 0.98786932f, 
    0.58066326f, -0.21209197f, -0.11232173f, 0.00019267f, -0.12674616f, -0.71371526f, 1.07744348f, -1.09915912f, 
    -0.95584321f, -0.43845549f, 0.25619626f, -0.39160240f, 0.70669597f, -1.37223136f, -1.15572357f, 0.74489188f, 
    0.66165376f, 0.54943866f, 0.00593154f, 0.15856150f, -0.16450399f, 0.47931260f, 0.51506674f, 0.38193014f, 
    0.78923512f, 0.11841637f, -0.50334346f, 0.24736840f, 0.20035279f, -0.04134813f, 0.59756410f, -1.01682448f, 
    -0.64937973f, -0.80608195f, 0.23729460f, -0.84660441f, -0.68895137f, 0.19861834f, -0.09557182f, 0.14071819f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20793784f, -0.17909366f, 0.37133583f, 0.28866670f, -0.06319041f, 0.22724934f, 0.43417102f, 0.33038023f, 
    0.40448540f, 0.17974405f, 0.29164937f, -0.09928109f, 0.44287872f, 0.02577851f, 0.22332174f, 0.34400496f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12527566f, 0.13945501f, 0.27068979f, 0.08824950f, 0.09044182f, -0.05925797f, 0.00974497f, 0.01406285f, 
    -0.06780232f, -0.01751271f, -0.00779491f, 0.04904857f, 0.04420673f, -0.07219299f, 0.03457918f, 0.18967631f, 
    0.11438450f, 0.02453864f, 0.11318112f, -0.08876665f, -0.76811582f, 0.14930873f, -0.63882548f, -0.18938826f, 
    -0.63739890f, 0.07998662f, 0.07975947f, -0.24139693f, -0.09913215f, 0.21739987f, -0.00410616f, -0.08896334f, 
    0.04600748f, 0.17459771f, 0.08470476f, 0.19140899f, 0.09870502f, -0.06040524f, 0.20338096f, 0.22444554f, 
    0.42389169f, -0.00521349f, 0.25842854f, 0.27451310f, 0.35453442f, 0.00081557f, -0.07826234f, -0.02211600f, 
    0.05640826f, -0.01673391f, -0.04897641f, -0.05989747f, -0.08852531f, 0.04833423f, 0.02210305f, -0.04271486f, 
    0.11402948f, 0.02141810f, 0.04850898f, 0.08674771f, 0.36622441f, -0.07971235f, -0.39783573f, -0.18376948f, 
    -0.22600040f, 0.15877907f, -0.03534133f, -0.14721531f, 0.20835024f, 0.01397335f, -0.08724149f, -0.13273031f, 
    0.06997737f, -0.14085725f, -0.09963256f, 0.02403311f, 0.03320836f, -0.09979156f, 0.22367960f, 0.26373407f, 
    0.63761353f, 0.12491025f, -0.19041716f, -0.13346088f, 0.02531471f, 0.01302159f, 0.09617486f, 0.11161241f, 
    0.21866208f, 0.31320953f, -0.03377331f, -0.02180495f, -0.04926205f, -0.07622994f, 0.02034581f, -0.05938428f, 
    0.26638913f, -0.20197338f, 0.22798133f, 0.06291968f, 0.27285123f, 0.13578169f, 0.10571002f, 0.17936879f, 
    0.24978353f, 0.01403243f, 0.03127442f, 0.03580659f, 0.05281920f, 0.03068939f, -0.00539230f, -0.04491453f, 
    -0.01601381f, -0.05331083f, 0.00990515f, -0.01901283f, 0.03177484f, 0.00934489f, -0.13200650f, -0.12515716f, 
    0.32878247f, 0.34322685f, 0.05736929f, 0.29676756f, 0.05991869f, -0.05879539f, 0.04745122f, -0.07283714f, 
    0.06946071f, -0.15232405f, -0.05354567f, 0.06751501f, -0.01025352f, 0.09687426f, 0.06563778f, 0.03917269f, 
    0.16773449f, 0.14846635f, 0.11568452f, -0.03374925f, 0.04995953f, 0.27321693f, 0.06745016f, -0.39651519f, 
    -0.07519260f, 0.15611230f, 0.06603406f, 0.06404455f, 0.06535087f, 0.00126337f, 0.00527333f, 0.10461703f, 
    -0.06604988f, -0.05558433f, -0.06105725f, 0.03440670f, -0.11732545f, -0.09205111f, -0.15162535f, -0.00263061f, 
    0.46831417f, 0.21134423f, -0.14306772f, 0.12691265f, -0.16319524f, -0.04784593f, 0.11800078f, -0.15820584f, 
    0.08094851f, 0.05495405f, -0.05269433f, 0.13655885f, -0.05430837f, 0.02216125f, -0.11883710f, 0.17294142f, 
    0.10938125f, 0.08928870f, 0.28726518f, 0.16865388f, 0.13885790f, -0.15398274f, -0.26162902f, 0.06795504f, 
    -0.04228591f, 0.03235041f, -0.05813691f, -0.04343385f, -0.01792975f, 0.08913942f, -0.03532467f, 0.13493498f, 
    -0.14671706f, 0.02678117f, -0.10447254f, -0.11769190f, -0.00445340f, 0.01156848f, -0.03411525f, -0.01275185f, 
    -0.18268956f, 0.22081853f, -0.25997359f, -0.10274085f, -0.32247448f, 0.03660357f, -0.10747673f, 0.04245891f, 
    -0.07716873f, -0.07302977f, -0.06018419f, 0.02935910f, 0.14859390f, 0.05293069f, 0.10620888f, -0.00723067f, 
    -0.14351244f, 0.10547066f, 0.00164711f, -0.12331303f, 0.07233563f, 0.04997578f, 0.10294545f, 0.15881486f, 
    0.26434484f, -0.03349903f, -0.04845579f, -0.02908574f, -0.00072597f, 0.00238668f, 0.02220221f, -0.02669977f, 
    0.00087030f, 0.04968442f, 0.02563384f, -0.04738470f, -0.03151104f, -0.04449590f, -0.09404612f, -0.04618420f, 
    -0.03297873f, 0.42605805f, 0.53063613f, -0.33077171f, -0.12999286f, 0.19876592f, -0.19378206f, 0.02134312f, 
    0.03053853f, -0.04112678f, -0.07505991f, -0.03476986f, -0.02554892f, -0.04136981f, 0.09270675f, -0.09756978f, 
    -0.13594873f, -0.06252340f, -0.14778821f, -0.00748221f, -0.21801320f, -0.13403493f, -0.16010125f, 0.13518032f, 
    -0.09641483f, 0.05236739f, -0.10292774f, 0.09135618f, -0.01057020f, -0.04492867f, -0.13151315f, -0.03215173f, 
    -0.13069814f, -0.04333335f, -0.17938115f, -0.05111848f, -0.08803050f, -0.03122557f, -0.08729134f, -0.05000741f, 
    0.16025913f, 0.05336417f, 0.20365992f, 0.07917414f, 0.04692799f, 0.06007378f, -0.05856382f, -0.02661343f, 
    0.00443489f, 0.02562221f, -0.04789016f, -0.04645769f, 0.04102019f, 0.00483224f, -0.02995629f, 0.04496947f, 
    -0.00043423f, -0.08685947f, -0.10167668f, -0.09363499f, -0.63725007f, -0.12737660f, -0.62692493f, -0.42500892f, 
    -0.15665528f, 0.11071002f, -0.11068625f, -0.01341297f, -0.14347564f, -0.00922129f, -0.00102211f, -0.04310870f, 
    0.03475473f, -0.04243125f, 0.02251071f, -0.08911715f, -0.00115772f, -0.02068140f, -0.01643552f, 0.05659248f, 
    0.03663550f, 0.03537232f, -0.12039225f, -0.21232693f, -0.10585498f, -0.04976773f, 0.02754188f, 0.04423160f, 
    -0.13430099f, 0.04647474f, 0.00818513f, 0.02060475f, -0.02695726f, -0.01981229f, 0.07187115f, -0.06087375f, 
    -0.09369478f, -0.01978929f, 0.16801138f, 0.16879697f, -0.50915045f, -0.05391796f, -0.02420055f, 0.17069508f, 
    -0.01233130f, -0.11623299f, 0.06961932f, -0.09579531f, -0.00348523f, -0.00434034f, -0.14424779f, -0.01063095f, 
    0.15351011f, 0.10936469f, -0.02659325f, -0.08111584f, 0.23610331f, 0.12743922f, 0.06835914f, 0.14109646f, 
    0.28402504f, 0.06159928f, -0.51541287f, 0.04420064f, 0.27603245f, 0.02401119f, -0.11924367f, 0.03730576f, 
    -0.01340962f, -0.00540735f, -0.04404046f, 0.04217493f, 0.07665760f, -0.04922046f, 0.02247421f, 0.13300429f, 
    -0.07466342f, 0.20553774f, -0.05895796f, 0.08185285f, -0.42512143f, -0.07037488f, -0.01509506f, -0.07996624f, 
    0.14785178f, 0.12811309f, 0.13426641f, -0.11044382f, 0.09095587f, -0.20030341f, -0.17096277f, -0.04753881f, 
    0.19154476f, 0.08845134f, 0.06197677f, -0.12363144f, 0.11295835f, 0.02800122f, 0.03198517f, 0.11862176f, 
    0.13720968f, -0.07081401f, -0.09434903f, 0.30457547f, 0.57583165f, 0.14370711f, 0.06165501f, 0.07612561f, 
    0.17310770f, 0.12106068f, 0.08399935f, 0.16634794f, 0.00667279f, -0.06101179f, -0.04527694f, 0.18051238f, 
    0.16588098f, 0.08545803f, 0.02539734f, 0.11946087f, -0.34050402f, -0.11585620f, -0.26701844f, -0.11950453f, 
    -0.05562920f, 0.09404828f, -0.07146388f, 0.00580896f, 0.13356511f, -0.14622574f, -0.01259180f, 0.11377402f, 
    -0.03012465f, 0.10782407f, -0.00127861f, 0.18890703f, 0.01505117f, 0.04242426f, -0.01155159f, 0.09500775f, 
    0.36066085f, -0.06253446f, 0.25008371f, 0.14184970f, 0.14688496f, 0.10207433f, -0.02539562f, 0.16656959f, 
    0.15539856f, -0.06059787f, -0.01253565f, -0.05566645f, -0.14197871f, -0.06552646f, 0.00271636f, 0.07864992f, 
    -0.00035700f, -0.03242551f, -0.04877316f, 0.08467535f, 0.10334372f, -0.11774240f, 0.37825045f, 0.27325374f, 
    0.14867052f, 0.21468846f, -0.09584611f, 0.13859297f, -0.11676167f, 0.08579465f, -0.02601611f, 0.11784074f, 
    -0.10852665f, -0.20493169f, -0.02789968f, 0.08241163f, -0.02542168f, -0.02864744f, 0.00429094f, -0.21084464f, 
    -0.40929306f, 0.17086923f, 0.31019557f, -0.23811699f, 0.01587155f, -0.04080849f, 0.16922909f, -0.00317090f, 
    0.18057738f, 0.02338003f, -0.05166867f, -0.03572993f, 0.00920134f, -0.00698325f, 0.01968350f, 0.07044710f, 
    -0.12318926f, -0.04748818f, 0.14091146f, -0.04238128f, -0.15421666f, 0.15443626f, 0.34627527f, 0.00187559f, 
    0.04636763f, -0.02020171f, -0.09248087f, -0.17735711f, 0.08184312f, 0.03216213f, 0.08393053f, -0.13704768f, 
    0.02280620f, 0.00995611f, 0.12597673f, 0.20652731f, -0.22434726f, 0.14180619f, -0.17928082f, -0.08072671f, 
    -0.08096322f, -0.17260988f, 0.20997296f, 0.56558859f, -0.20438556f, -0.23418203f, -0.15937626f, 0.17164017f, 
    0.08163343f, 0.08266173f, 0.00450846f, 0.03230404f, -0.00437392f, -0.00229999f, -0.18058796f, 0.16380283f, 
    0.11993837f, -0.00431906f, 0.21757421f, 0.09300058f, -0.10850269f, 0.06400216f, -0.24111813f, -0.04181950f, 
    -0.08338042f, 0.12804762f, 0.02197174f, 0.00250943f, -0.06814735f, 0.13428470f, -0.00847732f, 0.03981505f, 
    0.01984176f, -0.00454672f, 0.08214374f, 0.01659846f, 0.07407043f, 0.08391082f, -0.07384543f, 0.15202871f, 
    -0.00396315f, -0.15942763f, 0.14280826f, 0.59025520f, 0.11142709f, 0.05104686f, -0.03286780f, 0.09894833f, 
    0.08903524f, 0.10100176f, 0.05939986f, 0.00579846f, -0.05148670f, 0.00481796f, 0.03831783f, -0.01953891f, 
    0.01708421f, -0.05053922f, 0.01028910f, 0.02703474f, -0.04685663f, -0.02991106f, -0.21193303f, 0.37926933f, 
    -0.10397130f, 0.01883485f, -0.00274416f, -0.25593334f, -0.16832988f, 0.08893695f, 0.01652918f, -0.03627029f, 
    -0.02656899f, -0.03710189f, 0.04374106f, 0.00160215f, -0.29913247f, -0.05470606f, -0.12734224f, 0.06331317f, 
    -0.14521198f, 0.01986479f, -0.10573648f, -0.07739159f, -0.29646021f, 0.14089616f, 0.15269513f, -0.02776961f, 
    0.01972376f, -0.03849633f, -0.01073044f, -0.02124389f, 0.07167203f, -0.09562723f, 0.12851438f, 0.21477078f, 
    -0.03441789f, -0.10362957f, -0.11909906f, -0.14291348f, -0.16437408f, -0.18415302f, 0.21923889f, 0.16451676f, 
    -0.05027728f, -0.11692655f, -0.16592216f, -0.11236690f, -0.00691667f, 0.04432116f, 0.07562745f, 0.06652889f, 
    -0.07518836f, 0.00883156f, -0.03645712f, 0.14350151f, 0.03672183f, -0.09143712f, 0.06090823f, -0.07544579f, 
    0.24526286f, -0.08903368f, 0.02590197f, 0.12602808f, 0.33013588f, -0.09620280f, -0.09957246f, -0.08397994f, 
    0.07358593f, -0.12778814f, -0.06253600f, 0.15847005f, 0.00678927f, 0.16913772f, 0.00958484f, 0.15565825f, 
    0.09401509f, -0.02283836f, -0.15163967f, 0.17052943f, 0.31955427f, 0.05093202f, 0.11395738f, -0.25105166f, 
    -0.20331728f, -0.04169049f, -0.09304652f, 0.10639682f, 0.22931173f, 0.09596487f, 0.05089428f, -0.08703235f, 
    -0.12175222f, -0.07987455f, -0.09460368f, 0.06733025f, -0.15787642f, 0.01564826f, 0.00895185f, -0.16916488f, 
    -0.52018970f, 0.15742207f, 0.03214468f, 0.11294618f, -0.31337729f, -0.14483009f, -0.03233378f, 0.21275857f, 
    -0.25126788f, 0.15210125f, 0.06551617f, 0.04504737f, -0.02284321f, 0.07341199f, 0.03022350f, 0.01266629f, 
    0.04976296f, 0.06759319f, 0.17993443f, -0.02469887f, 0.44356138f, -0.41894680f, 0.25290990f, -0.04781765f, 
    -0.12011492f, 0.09510610f, -0.18035500f, 0.27762231f, -0.19686393f, 0.12576620f, 0.04024431f, 0.00845405f, 
    -0.00935688f, -0.08382631f, 0.03999766f, 0.03325434f, -0.00707683f, -0.12000076f, 0.02242600f, 0.00670601f, 
    -0.07643522f, 0.19269308f, -0.07111916f, -0.35573018f, -0.47157463f, 0.20927030f, -0.00972792f, -0.04062810f, 
    -0.07611570f, 0.00677102f, -0.05974806f, -0.06207651f, 0.02259383f, 0.05366190f, -0.03671753f, -0.03246270f, 
    0.04510999f, -0.08788797f, -0.21095519f, -0.16424128f, 0.10222881f, 0.10366213f, 0.17650925f, 0.11352645f, 
    0.07287695f, 0.00706038f, 0.02318591f, -0.08285283f, -0.06538139f, -0.06757330f, 0.04845528f, 0.08304930f, 
    0.14500529f, 0.13260064f, 0.09283584f, -0.17228420f, -0.08221739f, 0.02038290f, 0.09329109f, 0.01797128f, 
    0.13135429f, -0.09331383f, -0.30402446f, -0.37950289f, 0.23477209f, -0.13745148f, 0.07165948f, -0.30826914f, 
    -0.01722394f, 0.01701532f, 0.05636889f, -0.01127042f, 0.06323751f, 0.03582817f, 0.00467174f, -0.02149418f, 
    0.05497184f, -0.00687153f, 0.04132918f, 0.08928756f, 0.08001120f, 0.13742749f, 0.13532799f, -0.05015856f, 
    -0.25352907f, -0.05976064f, 0.10823674f, -0.00398684f, 0.10529546f, 0.01859091f, 0.00901995f, -0.03364307f, 
    0.01846820f, 0.02418727f, -0.06059849f, -0.06528877f, 0.11759487f, -0.02671916f, 0.27360728f, 0.28757542f, 
    1.02447677f, -0.47283217f, 0.40814337f, -0.18702231f, 0.29727265f, -0.08622151f, -0.13292901f, -0.04525903f, 
    -0.03703129f, -0.02864770f, 0.20643020f, 0.02050387f, 0.05440981f, 0.13663614f, 0.05371889f, -0.06844535f, 
    0.14632748f, 0.01682780f, 0.09720910f, 0.35610816f, 0.18736503f, -0.05618852f, -0.03184877f, -0.16580452f, 
    -0.13546900f, -0.03340085f, -0.04417555f, 0.15273131f, -0.10005636f, 0.04164941f, -0.00063034f, 0.21227892f, 
    -0.12989536f, 0.05982931f, -0.08743779f, -0.08583978f, 0.02528892f, 0.02089965f, 0.08489874f, 0.11296043f, 
    0.30102116f, 0.06721993f, -0.00208377f, -0.30744508f, 0.13065472f, 0.12505832f, 0.11549861f, 0.01462034f, 
    0.12273344f, 0.05442468f, 0.01004728f, -0.09444553f, -0.06309715f, -0.11373457f, 0.18909852f, -0.00585183f, 
    -0.00011427f, 0.15851694f, -0.02424368f, 0.09898493f, 0.03419584f, 0.20086804f, 0.09080014f, 0.08573119f, 
    -0.05290202f, -0.24463743f, -0.10067705f, 0.08677238f, -0.02280375f, -0.08500643f, 0.30089700f, 0.10240657f, 
    -0.05066026f, 0.16241749f, 0.03325274f, -0.01514588f, -0.10424706f, 0.01689774f, 0.12279948f, -0.11833508f, 
    -0.10180506f, 0.21592648f, -0.16055954f, -0.02706278f, -0.21669573f, -0.07207775f, 0.16962974f, -0.01500185f, 
    -0.06649414f, 0.13355057f, 0.01236359f, 0.07872029f, 0.04002022f, -0.03020006f, 0.01928833f, 0.03732407f, 
    0.10590972f, 0.15310825f, 0.02410989f, -0.05949543f, 0.29064929f, -0.09150572f, 0.06334294f, -0.08739907f, 
    -0.10517270f, -0.21359628f, -0.01318354f, -0.01764943f, 0.12629049f, -0.06074997f, 0.08544713f, -0.07225451f, 
    -0.04482362f, -0.00926879f, -0.08203137f, -0.02312862f, 0.06375579f, 0.04419418f, 0.11947114f, 0.00229241f, 
    -0.12469904f, -0.03394756f, -0.19121052f, 0.11248445f, 0.15473048f, -0.06131432f, -0.08852509f, -0.06961706f, 
    -0.09826777f, -0.05234977f, -0.03936746f, -0.03311597f, 0.07597945f, 0.09440060f, -0.08948594f, -0.07074168f, 
    -0.09950507f, 0.00317219f, 0.17720698f, 0.03058807f, 0.06173537f, 0.16569632f, 0.05560588f, -0.11340543f, 
    -0.21901342f, 0.01553064f, 0.27370438f, 0.12584592f, 0.06227814f, 0.12023395f, -0.03127322f, -0.05852390f, 
    -0.06809475f, -0.03277745f, 0.07819809f, -0.10161300f, 0.07422831f, 0.12642130f, -0.04880100f, 0.12790763f, 
    0.28334799f, -0.06677983f, -0.02877357f, 0.29043892f, 0.08227842f, -0.06064037f, -0.01082893f, -0.11626159f, 
    -0.07537404f, -0.18474001f, -0.09119508f, 0.03495584f, 0.01439732f, 0.09143803f, -0.03459690f, -0.02487245f, 
    -0.04417554f, -0.05447302f, -0.12884441f, -0.00565831f, 0.13628042f, 0.21901619f, -0.08448872f, -0.23321128f, 
    -0.16316481f, -0.00945030f, 0.02994239f, 0.09991139f, 0.04742212f, 0.15014458f, 0.02926712f, 0.02647470f, 
    -0.03397733f, 0.09067943f, 0.17610736f, 0.08744068f, -0.08748858f, -0.07241144f, -0.05101772f, -0.08081010f, 
    -0.17628449f, 0.32757360f, 0.06975342f, 0.35874215f, -0.10286176f, -0.04584365f, 0.06819394f, -0.04962361f, 
    -0.02613318f, -0.00346422f, -0.02108679f, -0.01237349f, 0.04185722f, -0.04168909f, -0.00904219f, 0.03742300f, 
    -0.11164658f, 0.03497323f, 0.00371060f, -0.10304349f, 0.23262602f, -0.39254263f, -0.24142750f, 0.18963832f, 
    -0.15918823f, -0.01393239f, 0.00826284f, 0.11604279f, -0.03453846f, 0.00170532f, -0.02710150f, -0.03613605f, 
    -0.16038606f, 0.03603985f, 0.05255645f, 0.04067883f, -0.06645659f, 0.07973341f, -0.06234122f, -0.00279250f, 
    0.05197849f, 0.47782475f, 0.22144502f, -0.08463550f, -0.22308134f, 0.27436471f, -0.00658730f, -0.16983098f, 
    -0.00185188f, 0.17047040f, -0.06002792f, -0.00824352f, 0.03510988f, -0.07660577f, -0.02390843f, 0.09172703f, 
    0.00402710f, -0.17088136f, -0.11768974f, -0.18931121f, 0.21395710f, 0.18351415f, 0.14650488f, 0.27059141f, 
    -0.07398511f, -0.13494784f, 0.02498954f, -0.09372333f, -0.00186427f, -0.06512511f, -0.07852676f, 0.06370943f, 
    0.07380187f, 0.00223029f, 0.14983170f, -0.19122241f, -0.00476120f, -0.06508240f, -0.02304111f, -0.09682818f, 
    0.42380100f, 0.14226317f, 0.24858998f, -0.06549416f, 0.08156311f, -0.10844943f, -0.13950518f, -0.16089372f, 
    0.02251870f, 0.03083132f, 0.02162166f, -0.06461392f, -0.02946009f, -0.02124837f, -0.05685470f, -0.03623127f, 
    0.04377924f, -0.06663541f, -0.00471097f, -0.18947321f, 0.24553291f, -0.08903044f, 0.12795447f, 0.06204261f, 
    -0.08218778f, -0.11134695f, -0.00701362f, -0.06855868f, 0.02373024f, -0.00639488f, 0.01481054f, 0.10964980f, 
    0.07070280f, 0.01313672f, 0.05033512f, -0.02439468f, 0.06271160f, 0.00614955f, 0.15339629f, 0.21935737f, 
    0.58622330f, -0.58723956f, 0.22229882f, 0.09112669f, 0.27939510f, -0.14005150f, 0.06740669f, 0.09980391f, 
    0.00888313f, 0.12577754f, 0.07268915f, -0.04100992f, 0.06611151f, 0.15700659f, -0.08637218f, -0.23664932f, 
    -0.02732832f, -0.07471091f, 0.04002035f, 0.22577123f, -0.12178349f, -0.40100652f, -0.59557605f, -0.15842538f, 
    -0.29035470f, -0.09832950f, 0.12589772f, 0.08020753f, 0.04939792f, 0.11761564f, 0.06663910f, 0.02027101f, 
    -0.01320749f, -0.20260373f, -0.18682902f, -0.07774268f, 0.13787964f, -0.03908144f, 0.00814528f, 0.04595763f, 
    0.63336802f, 0.08792728f, 0.22832666f, -0.14479312f, 0.15786245f, -0.00196943f, -0.02157398f, 0.10075621f, 
    0.01039212f, -0.04931607f, 0.04764771f, 0.05526116f, -0.04041355f, 0.09356628f, 0.19220270f, 0.09043279f, 
    0.02392001f, 0.06637593f, 0.05414511f, 0.02238404f, 0.01937069f, 0.23398346f, 0.05255720f, 0.23406044f, 
    -0.15935270f, -0.15541410f, -0.00508137f, -0.08375902f, -0.03244644f, -0.15825564f, 0.07686025f, 0.16248900f, 
    0.09984078f, 0.23487104f, 0.11072827f, -0.07143775f, -0.11433202f, 0.11483773f, -0.01086812f, -0.05037361f, 
    0.22529459f, 0.36551160f, 0.42536166f, 0.16477510f, -0.15520604f, 0.02688891f, -0.04828569f, 0.09794375f, 
    -0.03343169f, 0.05064362f, -0.00975780f, 0.05806298f, 0.10786003f, 0.01050136f, 0.02410241f, 0.13986227f, 
    0.10362352f, 0.05388038f, 0.00657984f, 0.07475744f, 0.33950812f, -0.27028269f, -0.72975373f, -0.37951252f, 
    -0.32087824f, -0.17965904f, -0.06471255f, 0.14621432f, 0.04168581f, 0.00161711f, 0.33267152f, 0.05225097f, 
    -0.11586112f, -0.07812179f, -0.11844745f, 0.00321148f, 0.03240883f, 0.08144905f, 0.06735232f, -0.01670420f, 
    0.07989613f, 0.28693950f, 0.12039486f, 0.11165939f, -0.07609202f, -0.03701109f, -0.06010430f, -0.08715056f, 
    -0.01059975f, -0.14464287f, -0.11956462f, 0.09039257f, 0.08624683f, 0.07113190f, -0.01910707f, 0.00984270f, 
    0.10663112f, 0.04640653f, -0.04246096f, 0.03628378f, 0.45828527f, 0.21950653f, 0.03873036f, -0.18625826f, 
    -0.03109558f, 0.05327623f, 0.22887440f, 0.15604132f, 0.05804095f, 0.11591474f, -0.01713920f, -0.08728269f, 
    -0.01112375f, -0.09576929f, 0.06112581f, 0.00001961f, 0.01493726f, -0.00382768f, 0.00842933f, 0.18748496f, 
    0.03254505f, -0.03833979f, -0.00716931f, -0.00736326f, 0.05340938f, 0.01327728f, -0.04703831f, -0.02292951f, 
    0.03275157f, 0.01087193f, -0.00643429f, -0.01194692f, -0.05466289f, 0.00349803f, -0.00927083f, -0.01274538f, 
    -0.02530382f, -0.04886187f, -0.03607788f, -0.01808255f, 0.05096090f, -0.03008679f, 0.02576730f, 0.01632959f, 
    0.00514780f, -0.03757145f, -0.04217357f, 0.04058205f, 0.05254572f, -0.04962380f, -0.03626422f, 0.02933450f, 
    -0.03997576f, 0.05031639f, 0.01043350f, -0.04122699f, -0.02739566f, 0.02780868f, -0.01636607f, 0.03985491f, 
    -0.04294701f, 0.00495445f, 0.01218612f, 0.00353781f, 0.03625670f, -0.01975811f, -0.01539510f, 0.00328709f, 
    -0.04409797f, -0.05047887f, -0.03174835f, 0.03220787f, 0.02350817f, 0.04402222f, -0.03330604f, -0.01711170f, 
    0.02343276f, -0.00996785f, 0.04800541f, 0.02438312f, -0.00926998f, -0.02185828f, 0.04925150f, -0.03959100f, 
    -0.01184604f, 0.00304297f, -0.01845099f, -0.01960530f, -0.02675494f, -0.02697770f, -0.00114842f, -0.00771567f, 
    0.02020538f, 0.02411531f, 0.02941703f, 0.02962011f, -0.05179460f, -0.01844746f, 0.04173570f, 0.03878789f, 
    -0.01435708f, 0.03359343f, 0.01274848f, 0.04358720f, -0.03705556f, 0.04959574f, -0.04325331f, -0.01021173f, 
    -0.03281461f, 0.01543597f, -0.02021172f, -0.00079382f, -0.05446574f, 0.02680119f, -0.03744333f, -0.04966561f, 
    -0.00483695f, 0.00970405f, -0.00635439f, -0.05560894f, -0.04473916f, 0.04721975f, -0.01978488f, 0.02033770f, 
    0.04202273f, -0.05408354f, -0.03991850f, 0.01256324f, 0.04835948f, -0.01820761f, 0.01924187f, -0.03728345f, 
    -0.04112549f, -0.02112613f, -0.03041469f, -0.00532993f, -0.04394852f, -0.03978536f, -0.05328359f, -0.04000852f, 
    -0.01109400f, 0.01613693f, -0.03736654f, -0.02673341f, -0.00132322f, 0.00781670f, 0.03702407f, 0.04276649f, 
    -0.05433154f, -0.00547440f, 0.02971051f, -0.04757447f, -0.05083393f, 0.03275601f, 0.02837259f, 0.01058532f, 
    0.01565299f, -0.01380015f, 0.01606033f, -0.00335205f, -0.03251518f, -0.02771764f, -0.00541135f, 0.02562769f, 
    -0.01077175f, 0.02226106f, -0.03850747f, -0.04844855f, 0.04957755f, -0.05320388f, 0.03047801f, -0.04996912f, 
    0.00957538f, 0.01612177f, 0.02630769f, -0.02064187f, 0.00470045f, 0.01647038f, -0.01168893f, 0.02602509f, 
    -0.02696458f, -0.01199007f, 0.04338767f, 0.03124369f, -0.02713752f, 0.03345232f, -0.02378386f, -0.02420786f, 
    -0.00050413f, -0.01678849f, 0.02808888f, -0.05031710f, 0.00802567f, 0.02479903f, 0.01564386f, -0.03645470f, 
    -0.04981735f, -0.01272131f, -0.00067660f, 0.05129006f, -0.04775643f, 0.05542981f, -0.00956338f, 0.04111682f, 
    0.00367029f, -0.02517813f, -0.04131543f, 0.03368764f, 0.00123057f, -0.00747056f, 0.00891436f, -0.00809425f, 
    0.00756863f, -0.04016353f, -0.03863007f, -0.05265757f, -0.00423444f, -0.03628949f, -0.05582624f, 0.05260058f, 
    -0.01880251f, 0.04116147f, -0.05317571f, 0.03260326f, -0.05392096f, -0.03677635f, 0.02818475f, -0.00754851f, 
    0.01768729f, 0.03350327f, -0.05182560f, -0.04770316f, 0.03763297f, -0.01295111f, -0.04581827f, 0.04252045f, 
    -0.00972686f, 0.01974467f, 0.02789327f, -0.03642674f, -0.00145068f, 0.04248185f, -0.00335176f, 0.03014544f, 
    0.02647951f, 0.01203180f, -0.04030971f, -0.00904817f, -0.00199098f, 0.00019392f, 0.01843086f, 0.01777372f, 
    -0.01839925f, 0.05430382f, -0.02232581f, -0.05294271f, 0.00880172f, -0.03429968f, -0.04633063f, -0.05484802f, 
    0.05092882f, 0.02288257f, -0.03893721f, -0.05165320f, 0.00154107f, -0.00969590f, -0.03656369f, -0.01382491f, 
    -0.04856963f, 0.04934717f, -0.00636054f, -0.05049809f, 0.01894905f, -0.04705059f, 0.03412246f, -0.01237327f, 
    -0.05138572f, 0.01334833f, -0.04462647f, -0.03499059f, 0.05497247f, 0.02191687f, -0.03468569f, 0.02840535f, 
    0.03796522f, -0.00349056f, -0.00854532f, -0.00078806f, -0.02693745f, 0.02799257f, -0.00814645f, 0.04410406f, 
    -0.02131467f, -0.00145350f, -0.03062417f, -0.02691737f, 0.05064657f, -0.01924547f, 0.04242777f, -0.05118276f, 
    -0.00447786f, -0.03750196f, -0.02499956f, -0.04605424f, -0.00711023f, -0.02902206f, -0.03662015f, 0.05003124f, 
    0.02293238f, 0.05358846f, 0.01514331f, -0.01137353f, -0.03967000f, 0.01347665f, 0.01170664f, -0.03245005f, 
    -0.05465502f, -0.03966282f, -0.01687343f, 0.01191482f, 0.03315847f, 0.04549266f, 0.05454613f, -0.00717518f, 
    -0.00960353f, 0.03669063f, -0.02030909f, -0.02410039f, -0.04467197f, 0.02330819f, -0.02872707f, -0.05360926f, 
    -0.01628397f, 0.05146773f, -0.05125354f, 0.05484058f, -0.01677761f, 0.04527747f, -0.00210896f, -0.03039354f, 
    0.10664362f, -0.07564472f, -0.10015383f, -0.23275983f, -0.11958560f, -0.05515211f, -0.19519572f, -0.05303590f, 
    0.02109927f, 0.06183669f, 0.00915164f, -0.02935450f, -0.16328619f, 0.12698267f, 0.04257588f, -0.15019244f, 
    0.03273884f, 0.00284436f, 0.18137801f, 0.21025282f, -0.14095305f, 0.10872073f, -0.45211697f, -0.15734230f, 
    -0.06299219f, -0.10205574f, 0.09088279f, -0.06675030f, -0.05736664f, 0.11194446f, -0.14484605f, 0.08417460f, 
    0.09554707f, 0.23233439f, 0.01059109f, -0.09030045f, 0.29365146f, 0.27421436f, 0.15769958f, 0.23123492f, 
    0.07924156f, 0.10789411f, -0.53485006f, 0.10562568f, 0.24617834f, -0.00241263f, -0.26175663f, 0.21838672f, 
    0.03454247f, -0.02557141f, 0.05987164f, 0.14826931f, 0.02809395f, -0.21500596f, -0.09148814f, 0.09220941f, 
    -0.01273544f, 0.16915135f, 0.11490833f, -0.17710200f, -0.24803250f, -0.29966283f, -0.34685507f, -0.05865856f, 
    -0.01256630f, 0.06461607f, -0.02424390f, 0.04750327f, 0.00865217f, -0.21553998f, 0.00480402f, 0.10920659f, 
    0.01671251f, 0.05649301f, 0.14507824f, -0.10097837f, 0.16830248f, 0.18542716f, 0.22206934f, 0.20659518f, 
    0.30164236f, 0.32160747f, 0.06614773f, 0.07818459f, 0.38522679f, 0.12753764f, 0.04690326f, 0.22988862f, 
    0.24999718f, 0.03710920f, 0.01451306f, 0.16374101f, -0.03186838f, -0.03328403f, 0.00759986f, 0.31358141f, 
    0.14252862f, 0.33057109f, 0.09190995f, 0.08773857f, -0.30350652f, -0.07101899f, -0.13496296f, 0.00773676f, 
    0.10010166f, 0.13378574f, 0.08522566f, 0.05387527f, -0.04866359f, -0.26885059f, 0.02867939f, -0.00072836f, 
    0.04359683f, -0.00000915f, 0.00447479f, -0.02574142f, -0.01250479f, 0.09528293f, 0.03163945f, -0.04449363f, 
    0.23685232f, -0.40917534f, -0.04810256f, 0.06990247f, 0.22152327f, 0.14577700f, 0.16592449f, 0.29198244f, 
    0.03725408f, -0.07830544f, -0.03894282f, -0.15875323f, -0.12009965f, -0.10805075f, 0.02087354f, 0.01359755f, 
    0.11037324f, 0.06026982f, -0.08667628f, 0.15210763f, 0.28371617f, 0.35568488f, 0.60352343f, 0.03601724f, 
    -0.04566548f, 0.02070271f, -0.02620288f, 0.05250076f, -0.16644748f, -0.01457119f, 0.15262499f, 0.03282277f, 
    -0.14108895f, -0.19625020f, -0.08743939f, -0.07188071f, -0.11338787f, -0.17678343f, -0.00315515f, -0.34633315f, 
    -0.35399055f, -0.18966016f, 0.07483039f, -0.23851994f, 0.19709346f, -0.20141719f, -0.02924611f, -0.01551300f, 
    0.10677761f, 0.05860417f, 0.07139934f, 0.02813792f, -0.05137934f, -0.00375379f, 0.17702398f, -0.06652829f, 
    -0.13882408f, 0.00343669f, 0.03180740f, 0.02708455f, -0.26471767f, 0.35238987f, 0.27475324f, -0.07732181f, 
    0.18566202f, 0.04800261f, -0.12480698f, -0.18484135f, -0.11421334f, -0.16130686f, 0.01806645f, -0.05963428f, 
    0.16407886f, 0.06666926f, 0.04719072f, 0.08546922f, -0.24758963f, 0.07800771f, -0.29874811f, -0.13954803f, 
    0.29623121f, -0.21238290f, 0.39774472f, 0.16617288f, -0.22085212f, -0.03295733f, 0.04135778f, 0.24198024f, 
    -0.06605307f, 0.04670425f, -0.02240251f, 0.05800987f, -0.03684412f, 0.01837613f, -0.02613459f, 0.00254631f, 
    -0.02751576f, -0.01985760f, 0.37779468f, 0.22759058f, 0.09408819f, 0.19387396f, 0.05771537f, 0.16744886f, 
    0.14237039f, 0.09319816f, -0.10085837f, 0.03639005f, -0.10129142f, 0.14544113f, 0.04871513f, 0.18054800f, 
    0.07199882f, 0.13147482f, 0.05117861f, -0.12490050f, 0.08124769f, 0.28102389f, 0.00991025f, 0.08554025f, 
    -0.00051950f, -0.11168779f, 0.36169860f, 0.22618802f, -0.10727917f, 0.16523591f, 0.09823967f, 0.02531950f, 
    0.06578184f, -0.07784431f, 0.10795255f, -0.03946389f, -0.13518390f, -0.03088729f, -0.02634544f, -0.10082919f, 
    -0.10483224f, -0.04775371f, 0.13873841f, -0.08217533f, -0.17161170f, 0.30914083f, -0.01097136f, 0.10692723f, 
    -0.30732760f, -0.15155400f, 0.01165010f, -0.28823534f, -0.16110025f, -0.05356307f, 0.15163839f, -0.04422227f, 
    -0.09542547f, 0.05984140f, -0.04838280f, -0.08151677f, -0.12434475f, -0.01819343f, -0.01296597f, 0.20392577f, 
    -0.01341369f, -0.12154401f, -0.20749161f, 0.21063168f, -0.13409610f, 0.10719667f, 0.34800702f, 0.12674990f, 
    0.14619166f, 0.01853966f, -0.01804326f, -0.14479832f, 0.04800155f, -0.10818014f, 0.13329503f, 0.10922831f, 
    -0.12149792f, -0.18454611f, -0.19662747f, -0.25291371f, 0.02125418f, 0.05146366f, 0.35877198f, -0.13030972f, 
    -0.16507784f, -0.05458978f, 0.00484023f, -0.04058090f, -0.08666734f, 0.08127938f, 0.17668849f, 0.00538810f, 
    -0.10879167f, 0.03216002f, -0.02573826f, -0.01772975f, -0.13253874f, -0.05703802f, 0.21021949f, 0.01145643f, 
    -0.02969460f, -0.03882945f, 0.03390248f, -0.05153146f, -0.06194609f, -0.06069401f, -0.04482761f, 0.01155176f, 
    0.03942771f, 0.04697031f, -0.02162661f, -0.00364990f, 0.00678318f, -0.05482775f, -0.02605400f, -0.04678261f, 
    -0.02699933f, -0.01666131f, 0.03377405f, 0.04419792f, -0.01807652f, -0.01295870f, 0.00848236f, -0.02369700f, 
    0.02862292f, -0.03218249f, -0.03590782f, -0.00904069f, -0.03216585f, -0.03500958f, 0.00279495f, 0.01029798f, 
    0.03185489f, 0.01981535f, -0.02361061f, 0.03351317f, -0.01615141f, -0.05410118f, 0.05467879f, 0.00728452f, 
    -0.01465369f, 0.03988117f, -0.00793855f, -0.05966602f, -0.02459041f, 0.01196047f, 0.01956781f, 0.00052044f, 
    -0.04746917f, -0.05479765f, 0.00418051f, -0.05732406f, 0.04644872f, -0.00003260f, 0.03637472f, 0.02631089f, 
    0.00067366f, -0.04697952f, 0.00147121f, -0.03261945f, 0.04449987f, 0.00237355f, -0.00401657f, 0.02077678f, 
    -0.06021568f, -0.02614233f, -0.04638052f, 0.00189818f, 0.01547196f, -0.03374181f, -0.03093711f, 0.02102542f, 
    0.02050831f, 0.03474664f, -0.02450265f, -0.04970152f, 0.01462093f, 0.04036972f, -0.02517075f, -0.02621023f, 
    -0.03396558f, -0.05371289f, -0.03617775f, 0.01039605f, 0.01084772f, -0.01899607f, 0.04346669f, -0.02282446f, 
    -0.02847596f, -0.00300282f, 0.04608320f, -0.05454790f, -0.04862233f, 0.04669672f, 0.01903331f, -0.00675130f, 
    -0.01673387f, 0.01744588f, 0.02439834f, -0.03864355f, -0.06221250f, -0.05940904f, -0.04262027f, -0.02766393f, 
    -0.00266446f, -0.01269072f, 0.02812300f, -0.05448962f, -0.00530261f, 0.04413404f, 0.00886288f, -0.05074732f, 
    -0.06177574f, -0.04435791f, -0.01096344f, -0.01223767f, -0.00837375f, -0.00032615f, -0.02972346f, -0.04070411f, 
    -0.04013422f, 0.01272200f, 0.03874575f, 0.00827542f, -0.03463455f, 0.00587641f, -0.00981125f, -0.03316589f, 
    -0.02365190f, -0.04410912f, 0.02115057f, -0.01538896f, 0.02464504f, 0.00502844f, -0.04629112f, -0.04028332f, 
    -0.01299100f, -0.01414217f, 0.00268964f, -0.02706748f, 0.03853631f, 0.01715198f, -0.03820936f, 0.00629868f, 
    -0.00878396f, 0.03695425f, -0.03421700f, -0.01584571f, 0.02884831f, -0.02064959f, -0.02837274f, -0.00428578f, 
    0.03340961f, 0.01495946f, -0.04466458f, 0.00209306f, 0.04435185f, 0.04627254f, 0.01387040f, -0.00649606f, 
    0.00111609f, -0.04530193f, 0.02685189f, -0.00279361f, -0.03709755f, -0.00084351f, 0.01906594f, 0.00572956f, 
    -0.04826394f, -0.03933692f, -0.05083314f, -0.00037140f, -0.00878460f, -0.01978800f, -0.05805315f, 0.03902937f, 
    -0.04415705f, 0.04525106f, 0.02647055f, -0.05820460f, 0.04253875f, 0.00149306f, 0.02240293f, 0.02584261f, 
    -0.03802600f, -0.01810583f, 0.00085296f, 0.00801547f, -0.02134787f, 0.01527424f, 0.03895662f, -0.02662899f, 
    0.02741400f, 0.00813984f, 0.00224194f, 0.02880604f, -0.04075893f, -0.00761404f, -0.01853050f, -0.01553221f, 
    0.02416626f, 0.04486002f, 0.02138172f, 0.01273079f, 0.00123567f, 0.03294234f, 0.01598841f, -0.01272588f, 
    0.03258030f, 0.00313323f, 0.02113885f, -0.03360175f, 0.02710318f, 0.02055497f, 0.04754156f, 0.00841000f, 
    0.01578607f, 0.01233704f, 0.01180307f, -0.04002111f, -0.06038412f, 0.03364684f, -0.02588510f, -0.03413554f, 
    0.00193418f, 0.04190533f, -0.05589147f, -0.06130308f, -0.03758443f, 0.00269189f, -0.01687082f, -0.00732561f, 
    -0.06006724f, -0.00538189f, -0.03771457f, -0.06297054f, -0.03398756f, -0.06169917f, -0.05443806f, -0.03377534f, 
    0.04228799f, -0.04690969f, -0.03444723f, -0.01398604f, 0.00326125f, -0.05815299f, 0.03409392f, 0.00962807f, 
    0.03833578f, -0.04337310f, 0.00211329f, -0.05757600f, 0.01468010f, -0.01706091f, -0.03353838f, -0.04496757f, 
    -0.02884410f, 0.03265005f, -0.05506954f, 0.02065690f, 0.02002699f, -0.01348763f, 0.00462546f, 0.06178121f, 
    -0.00205648f, 0.02102561f, 0.04540482f, -0.01956385f, -0.00973446f, 0.03506924f, 0.00063418f, 0.00002229f, 
    -0.04878526f, -0.00139636f, 0.00707181f, -0.04531373f, 0.03062074f, -0.02816346f, -0.02700730f, 0.04678962f, 
    0.03274894f, -0.04933465f, 0.02712426f, 0.02054901f, 0.00542119f, 0.02015917f, -0.06261380f, -0.01008354f, 
    -0.04185157f, -0.01583043f, -0.03553135f, 0.03169443f, -0.03364344f, 0.03973301f, 0.00352211f, -0.03060725f, 
    0.02871751f, 0.05014647f, -0.00891894f, 0.04053560f, -0.04629313f, -0.06268784f, 0.01029396f, -0.04605980f, 
    0.01295801f, -0.00135814f, -0.04722100f, -0.05096074f, -0.00111806f, -0.06108857f, -0.04296770f, -0.02737715f, 
    -0.01732469f, 0.02702610f, 0.02320443f, -0.02107560f, 0.03321607f, 0.01853647f, 0.02823551f, -0.00635673f, 
    -0.04199740f, 0.02522174f, 0.02616864f, 0.05589633f, 0.36815053f, -0.04627754f, -0.08739170f, -0.05970109f, 
    -0.08298804f, -0.04846168f, 0.01027171f, -0.03462912f, 0.10845610f, -0.04588978f, 0.20327139f, 0.33073765f, 
    0.10082884f, 0.01266405f, 0.17515992f, -0.02686335f, 0.04614461f, 0.12791702f, 0.25185102f, -0.08951089f, 
    -0.15607157f, -0.01375364f, -0.08942624f, 0.11750107f, -0.01468967f, -0.12122802f, 0.05890327f, -0.13380113f, 
    0.12147292f, -0.05068834f, 0.14509176f, 0.19684203f, 0.01731294f, -0.07226536f, -0.00864782f, -0.00592053f, 
    0.47161043f, -0.20316577f, 0.21312150f, 0.23202619f, 0.50729853f, 0.01256023f, 0.05277229f, -0.18220054f, 
    0.11794977f, 0.07815966f, -0.02800153f, -0.01779878f, -0.04305688f, 0.10533607f, -0.08442404f, 0.22349963f, 
    0.03541218f, -0.07186442f, 0.43802023f, 0.04830940f, 0.46851662f, 0.21813901f, 0.03947141f, 0.18736763f, 
    0.11481091f, 0.09575055f, 0.06006866f, -0.04998450f, 0.01115390f, 0.15490615f, 0.29441944f, 0.00029304f, 
    0.23434681f, 0.03917707f, 0.20746426f, 0.15792184f, 0.01683788f, -0.04372612f, 0.17492229f, 0.17145601f, 
    0.23443574f, -0.29393703f, 0.07324545f, -0.16318752f, -0.15025958f, -0.02510161f, 0.07727857f, -0.13003033f, 
    0.03189809f, -0.21112621f, -0.02900151f, -0.00540309f, -0.06213301f, -0.10785030f, 0.10408413f, -0.05551631f, 
    -0.14339997f, -0.11983724f, 0.17064488f, 0.01348451f, -0.00178304f, 0.02074801f, -0.11359607f, -0.03677908f, 
    0.24717258f, -0.07888681f, 0.00488957f, -0.15473270f, -0.07741022f, 0.03562062f, -0.07461854f, -0.11027259f, 
    0.05989802f, 0.02759403f, 0.03315944f, -0.02924276f, 0.01033051f, 0.04916983f, -0.05622923f, -0.07899752f, 
    -0.12920584f, 0.20767243f, 0.20228119f, 0.22035259f, -0.21193558f, -0.00000998f, 0.19458714f, -0.00871770f, 
    -0.12785828f, -0.02994282f, -0.00542172f, -0.12216525f, 0.05045288f, -0.05398199f, 0.06713349f, 0.05650698f, 
    0.30095163f, 0.28484809f, 0.15307057f, -0.03478214f, 0.09725904f, -0.01508115f, -0.12283690f, -0.10391609f, 
    -0.21489751f, -0.23642141f, -0.04728083f, -0.12068556f, -0.09544197f, -0.28041235f, 0.06572118f, -0.14509985f, 
    -0.06073306f, -0.00874538f, -0.01813119f, -0.06350973f, -0.02938901f, 0.14596982f, -0.07639296f, 0.02232307f, 
    0.22473875f, 0.38415247f, -0.29106945f, -0.01260792f, -0.13823740f, -0.14051551f, 0.02520592f, -0.08372551f, 
    -0.09387033f, 0.06327297f, 0.24404925f, 0.12531646f, 0.10005240f, -0.12152135f, 0.23575708f, 0.24812447f, 
    0.14405297f, 0.37439802f, 0.24218130f, 0.18404771f, -0.00768869f, 0.10708621f, -0.03727956f, -0.03825187f, 
    0.08542560f, 0.00572028f, -0.01356751f, 0.05716626f, -0.04620115f, -0.14127630f, 0.05607376f, 0.12808423f, 
    0.00778008f, 0.12867217f, -0.00486268f, -0.09980075f, -0.03589565f, -0.00170697f, -0.02065484f, 0.00130150f, 
    0.17441353f, 0.05570583f, 0.08587927f, -0.19562671f, -0.13824572f, 0.07854091f, 0.14045121f, 0.10520640f, 
    -0.04079710f, -0.14678815f, 0.05596973f, -0.03158278f, 0.18988122f, 0.06013334f, 0.11876547f, 0.00210010f, 
    -0.09970496f, 0.38259628f, 0.04141153f, -0.13337527f, -0.19013873f, -0.21824434f, -0.22174722f, 0.02964338f, 
    0.43483251f, -0.08417027f, 0.01487374f, -0.11359819f, -0.00839749f, -0.06451363f, -0.02012809f, 0.15563284f, 
    0.10319339f, 0.21354830f, 0.07609437f, 0.06206118f, -0.05839426f, -0.03786300f, 0.09299643f, -0.10340190f, 
    0.40535519f, -0.10394069f, -0.18032771f, -0.35526183f, -0.20333646f, 0.27835777f, -0.03818835f, 0.01014042f, 
    -0.10115483f, -0.13493128f, 0.01810743f, 0.01607948f, 0.04142951f, -0.03306623f, -0.01228890f, 0.04539092f, 
    0.06186014f, 0.15757644f, 0.01556390f, 0.23728023f, -0.58831847f, -0.15901847f, 0.10717752f, 0.11111473f, 
    -0.08211289f, -0.02082286f, -0.15669768f, -0.13905491f, 0.06540626f, -0.01866044f, 0.15428434f, -0.15991479f, 
    -0.02994275f, -0.02298165f, -0.07235637f, -0.00208745f, -0.01492359f, -0.12892531f, -0.02651547f, -0.02325856f, 
    0.13521560f, -0.05619744f, 0.01883150f, -0.07843630f, 0.20592928f, -0.01280676f, 0.02898224f, -0.00278855f, 
    -0.03290079f, 0.07099646f, -0.06388356f, -0.14311135f, -0.04904769f, 0.00289956f, -0.12933010f, -0.02349526f, 
    0.04143087f, -0.13348383f, -0.11398496f, -0.01434717f, -0.36873409f, 0.00996034f, 0.13166076f, -0.06758859f, 
    -0.26362717f, 0.19315980f, -0.01082014f, 0.26543564f, -0.08143557f, -0.10221835f, 0.08315530f, -0.05169952f, 
    -0.03235417f, -0.09299036f, -0.10606322f, -0.07494124f, -0.00070961f, 0.19610137f, 0.01431882f, 0.10882796f, 
    -0.05423613f, 0.04037921f, -0.00248520f, 0.03805862f, -0.03429890f, 0.02747718f, -0.01618910f, 0.04423494f, 
    0.01811186f, -0.05576836f, -0.00009370f, -0.04376491f, -0.00658264f, -0.04447225f, 0.03915798f, 0.02427678f, 
    0.01535087f, -0.00477987f, -0.01291048f, -0.02455924f, 0.03257155f, -0.00080099f, -0.02621014f, 0.02793520f, 
    -0.03904013f, -0.02348729f, -0.01685665f, -0.00752681f, -0.01216758f, 0.03034724f, 0.00116152f, 0.01494933f, 
    0.01591532f, -0.04396781f, -0.02115612f, -0.00335679f, -0.05799565f, 0.00859581f, 0.00868900f, -0.05782868f, 
    0.01114146f, -0.04867059f, -0.03966205f, 0.01612123f, -0.01179611f, 0.01054254f, 0.04520414f, -0.01676550f, 
    0.04593075f, -0.03703918f, -0.01217685f, -0.05149849f, 0.03777565f, -0.00804020f, 0.00085484f, -0.05659741f, 
    -0.04090494f, -0.01767450f, 0.04153237f, -0.01648250f, 0.00880496f, 0.00107689f, 0.00158472f, 0.01710792f, 
    -0.02193576f, 0.00124824f, -0.05628566f, 0.04097543f, 0.04715084f, 0.00102241f, 0.03085582f, 0.02928542f, 
    0.04133245f, -0.01752687f, -0.05745114f, 0.04681842f, -0.03358416f, 0.02262181f, -0.05941097f, 0.00934002f, 
    -0.03243211f, 0.01972069f, -0.04502760f, -0.05555959f, -0.00263672f, 0.01513526f, 0.04539653f, 0.03355270f, 
    -0.02689975f, -0.01317604f, 0.00170833f, -0.04235862f, -0.00197442f, -0.01624004f, 0.04634473f, -0.01383499f, 
    -0.05170766f, -0.05103346f, -0.03735371f, 0.04788994f, -0.03897665f, 0.02450695f, 0.04393892f, -0.04779080f, 
    -0.02046249f, -0.04407734f, -0.01129102f, -0.02373707f, -0.05074027f, -0.05689776f, 0.00785224f, -0.00509833f, 
    -0.00020000f, 0.04392092f, -0.01769276f, 0.00807256f, -0.01962195f, -0.00623216f, -0.05554608f, -0.04862808f, 
    0.02758460f, 0.03917595f, -0.04050988f, -0.04577561f, -0.04748704f, 0.01735312f, 0.01307805f, 0.03989728f, 
    -0.02863674f, 0.01210292f, -0.03710395f, -0.05767152f, -0.03316301f, -0.02922926f, 0.02426402f, 0.01348405f, 
    -0.02644451f, 0.01721534f, 0.01361648f, 0.04356521f, -0.01841665f, 0.04198343f, -0.00241051f, 0.02617323f, 
    0.01983461f, -0.04493059f, -0.04797066f, 0.02453014f, -0.01474026f, -0.05411241f, -0.02802771f, 0.01980743f, 
    0.03729222f, -0.04265070f, 0.00258053f, -0.01204761f, 0.00955046f, 0.01291682f, -0.02237188f, -0.03828748f, 
    0.00140215f, -0.00622027f, 0.02369288f, 0.02742142f, 0.03406473f, 0.01201509f, -0.01187696f, -0.03784359f, 
    -0.02617512f, 0.01181685f, 0.03127244f, -0.05047968f, -0.02065720f, -0.03366324f, -0.03352820f, -0.02830148f, 
    0.04085995f, -0.02624707f, -0.01824930f, 0.00187126f, -0.03727087f, -0.01386245f, -0.04626354f, 0.00201774f, 
    -0.03804148f, 0.01057142f, 0.03128946f, 0.03345746f, -0.01483230f, 0.02493893f, 0.01112421f, -0.02121188f, 
    -0.05972908f, 0.04227144f, -0.00265979f, -0.04698672f, 0.00575803f, 0.04710297f, 0.02777061f, 0.03089329f, 
    -0.03692138f, 0.01097740f, -0.00124922f, -0.03937634f, 0.04700820f, -0.05009744f, -0.04531683f, -0.01121763f, 
    -0.02088957f, -0.05229931f, -0.03760593f, 0.02039568f, -0.00536318f, -0.01972215f, -0.03019907f, -0.01717016f, 
    -0.03996138f, -0.00769605f, 0.01974551f, 0.03987662f, 0.01358111f, -0.04635982f, 0.02551907f, 0.01266115f, 
    -0.02650186f, -0.02622880f, -0.01983376f, -0.04595211f, 0.03535948f, -0.02991844f, -0.01016435f, -0.05072881f, 
    -0.05429203f, -0.02447383f, -0.04782030f, -0.03126555f, 0.00417087f, 0.02597158f, 0.03227342f, 0.05433505f, 
    -0.00426018f, -0.04949283f, -0.05633184f, 0.04689318f, -0.05283472f, -0.06036287f, -0.05585165f, -0.00159919f, 
    0.00646309f, 0.00101818f, 0.01637266f, -0.01417205f, 0.04328531f, -0.04151145f, -0.00109922f, -0.01592240f, 
    -0.01628487f, -0.03729165f, 0.01642868f, -0.01426775f, -0.02457253f, -0.00755474f, -0.01228298f, 0.00937760f, 
    0.02005618f, 0.04564060f, -0.03749771f, -0.04633408f, -0.05723002f, -0.04366481f, -0.01780386f, 0.03250966f, 
    -0.02966857f, -0.03977304f, -0.05802558f, -0.02030226f, 0.03844554f, 0.00251921f, -0.05556509f, 0.05501569f, 
    0.02561435f, -0.01961052f, 0.04162496f, 0.04108412f, -0.05468193f, -0.04072831f, 0.03242397f, -0.02207381f, 
    0.01176542f, -0.04843992f, -0.02170534f, -0.05932802f, -0.04391283f, -0.02441628f, 0.03708658f, -0.04590252f, 
    0.03551942f, -0.00001797f, 0.01251840f, 0.00744678f, -0.01739999f, 0.01318337f, -0.01962871f, 0.04326298f, 
    -0.00117222f, 0.01495630f, -0.03909865f, -0.05126734f, -0.06018476f, 0.00278801f, 0.02472453f, 0.04135103f, 
    -0.04059616f, -0.04051390f, -0.05147043f, -0.02196520f, -0.02682783f, 0.04797212f, -0.05532705f, -0.04724957f, 
    -0.05216817f, -0.03339237f, -0.06353413f, 0.01072385f, -0.01063923f, -0.01092757f, -0.02511320f, -0.00099475f, 
    -0.05226222f, -0.01570396f, 0.02139897f, 0.00397540f, 0.03871333f, -0.03421827f, -0.01078734f, -0.02769314f, 
    0.03889748f, -0.06113839f, 0.01259351f, 0.01382243f, 0.06137385f, 0.03080247f, -0.01798530f, 0.01663389f, 
    -0.04014995f, -0.02082973f, -0.00057798f, -0.03449621f, 0.04656240f, -0.04226684f, -0.00545210f, -0.00341794f, 
    -0.05285066f, 0.03337550f, 0.04209750f, 0.02354973f, 0.03423121f, -0.04011511f, 0.01043235f, -0.00024180f, 
    0.01168064f, -0.03084620f, -0.02025317f, 0.01952608f, -0.01529122f, -0.05552260f, 0.03682635f, 0.03277953f, 
    -0.03949917f, -0.00996300f, -0.00213240f, 0.01022639f, -0.02392055f, 0.00829000f, -0.02685194f, -0.00054584f, 
    0.03950154f, 0.04847179f, 0.02477881f, -0.04556913f, -0.04910271f, -0.02247797f, -0.00687044f, -0.04386524f, 
    0.03681507f, 0.03353124f, 0.04522257f, -0.05824032f, -0.06164350f, -0.05981057f, -0.01403745f, 0.03884935f, 
    -0.00637727f, -0.05714908f, -0.03105511f, -0.04850220f, -0.06227402f, -0.00788914f, 0.02249679f, 0.02881384f, 
    -0.03314738f, 0.00886461f, -0.05611969f, 0.01409682f, -0.06367785f, -0.04931894f, 0.01655233f, 0.04234984f, 
    -0.04326170f, 0.00243239f, 0.03296157f, -0.00454156f, -0.02655670f, -0.03884191f, -0.03188625f, 0.00083822f, 
    0.02157229f, 0.02146981f, -0.00230888f, 0.04616681f, 0.01717314f, -0.03134800f, 0.01434439f, 0.03342783f, 
    -0.01345352f, -0.04175995f, 0.00117296f, -0.01472161f, -0.04741199f, -0.01111300f, -0.01845366f, 0.01880214f, 
    -0.00670526f, -0.02034966f, -0.05588752f, -0.06081549f, -0.03770095f, 0.04156531f, 0.02841561f, -0.03681789f, 
    -0.04231399f, -0.02703858f, 0.02822112f, -0.06324378f, -0.00030282f, 0.01345613f, 0.01689533f, -0.00898671f, 
    0.02097248f, -0.05539000f, -0.00534986f, 0.01974411f, -0.02242413f, -0.01638521f, 0.04563694f, -0.01744856f, 
    -0.05594980f, -0.01704480f, 0.03912075f, 0.04103913f, -0.03447323f, -0.03787681f, -0.00327771f, -0.04434684f, 
    -0.00595874f, 0.04102565f, -0.04628109f, -0.04702863f, 0.04362785f, 0.00275959f, -0.02925206f, -0.00027507f, 
    -0.00747982f, 0.04666010f, -0.00845531f, -0.01810939f, -0.02394471f, 0.01721802f, 0.02386040f, -0.05171130f, 
    0.05418174f, 0.02639440f, -0.05893423f, -0.00701660f, -0.05645234f, 0.02253201f, -0.02214544f, -0.05371436f, 
    -0.01874958f, -0.01763263f, -0.03517576f, 0.04329243f, -0.03457652f, 0.04283072f, -0.02675647f, -0.02269371f, 
    -0.05350624f, 0.02003106f, -0.05454487f, 0.01013896f, -0.03101760f, 0.00679398f, 0.02693208f, -0.00255088f, 
    -0.00857147f, -0.01493352f, 0.03594942f, -0.00409667f, -0.02798785f, 0.01026926f, 0.00080620f, -0.05511482f, 
    0.00036718f, 0.01128361f, -0.01914719f, -0.01475587f, -0.02783989f, 0.00203444f, -0.05374055f, 0.04194201f, 
    0.04522089f, -0.03672878f, -0.04642659f, 0.03577584f, -0.02358159f, -0.02803312f, 0.01053449f, 0.02187774f, 
    0.03348634f, -0.04576519f, 0.03668573f, -0.03398450f, -0.02112483f, -0.05597828f, 0.04837621f, 0.03870859f, 
    0.03224672f, 0.02752511f, -0.02053156f, -0.03930081f, 0.01002524f, 0.03277843f, 0.02949628f, -0.03411497f, 
    0.01186974f, -0.04253887f, -0.05030792f, -0.05813016f, 0.02980614f, -0.00521818f, 0.00208243f, -0.04342884f, 
    -0.02489481f, -0.06253883f, -0.02694298f, -0.00004692f, 0.01142912f, 0.03426121f, 0.04602044f, 0.04517429f, 
    -0.04611755f, -0.03700178f, 0.04206198f, -0.04669033f, 0.03674651f, 0.04144893f, 0.05209792f, 0.02616626f, 
    0.02272927f, -0.04773505f, -0.00264153f, -0.01537410f, 0.01306908f, -0.05972603f, -0.05613663f, -0.02160224f, 
    -0.04930274f, -0.00677986f, -0.02837639f, -0.04714693f, -0.00236877f, 0.00213193f, -0.04766712f, -0.04664803f, 
    0.01159530f, -0.04489477f, -0.02640889f, -0.02987317f, 0.03878855f, 0.03607393f, -0.03435887f, -0.05546444f, 
    0.00331132f, -0.00539281f, 0.01442187f, -0.01811241f, 0.05553626f, 0.04466571f, 0.02432191f, 0.00210578f, 
    -0.01626999f, -0.03859878f, -0.03622821f, 0.02355182f, 0.00016839f, -0.04113069f, 0.02386051f, -0.00325184f, 
    0.01925080f, 0.01085632f, -0.01785774f, -0.04212563f, 0.04378367f, -0.02824008f, -0.01240650f, -0.05458490f, 
    0.02248548f, -0.05437643f, -0.03696042f, -0.03409388f, 0.03344342f, 0.05699325f, -0.03774717f, -0.00920375f, 
    0.05452630f, 0.01370708f, 0.02897519f, 0.05047486f, -0.02519363f, 0.03146706f, 0.02158637f, -0.02855829f, 
    0.00501856f, -0.01036745f, -0.00544559f, -0.03211410f, -0.02143796f, 0.04547544f, -0.03774235f, -0.00497697f, 
    -0.01829707f, -0.00507452f, 0.21042728f, 0.17712334f, 0.06064106f, -0.03438331f, -0.00152051f, 0.08460119f, 
    0.09403126f, -0.11838146f, -0.04852219f, 0.07978038f, -0.02949994f, 0.28518605f, -0.07089936f, 0.14415988f, 
    -0.00165512f, -0.03414852f, -0.13270624f, -0.09045772f, 0.42080581f, -0.08608880f, -0.26344061f, 0.32286769f, 
    0.01594689f, -0.05384239f, -0.00351627f, -0.23257849f, 0.11069959f, 0.11448979f, -0.04823538f, -0.07663641f, 
    0.03248233f, 0.23942089f, 0.07780752f, 0.24004450f, 0.08766023f, 0.18093325f, 0.11723325f, 0.23493049f, 
    -0.28298452f, 0.06599879f, 0.28386077f, -0.11459640f, 0.20097637f, -0.05788648f, 0.06900365f, 0.06443677f, 
    0.21584216f, -0.01562321f, -0.00118741f, 0.02611985f, -0.05786940f, 0.00938496f, 0.00687109f, 0.06344090f, 
    0.25116423f, -0.15956071f, -0.04757581f, 0.16089579f, 0.14431891f, -0.05507858f, -0.00112835f, 0.01673038f, 
    -0.00869829f, -0.07342059f, -0.02683040f, -0.03312919f, 0.11632246f, 0.07407311f, 0.11196627f, -0.12251512f, 
    0.15705878f, -0.05122142f, -0.06694598f, 0.11683402f, 0.08076465f, -0.09472481f, 0.01255688f, 0.05055423f, 
    -0.29483631f, -0.06929747f, -0.32179412f, -0.28648603f, -0.25459215f, -0.05150297f, -0.11354204f, -0.10885648f, 
    0.10579876f, -0.01123232f, -0.18080126f, -0.09676022f, -0.12294586f, 0.05513458f, -0.00982537f, 0.23916540f, 
    0.16716407f, 0.13076161f, 0.06028277f, 0.23469691f, 0.18440039f, 0.18319109f, 0.21044475f, -0.13769367f, 
    0.13363127f, 0.05730255f, 0.01679132f, 0.10560181f, 0.04854850f, 0.07194887f, -0.05510743f, 0.02567499f, 
    0.01065607f, 0.02308866f, 0.09815501f, 0.11934619f, 0.02746430f, -0.10778107f, -0.14247271f, -0.00251120f, 
    0.45359722f, 0.15267929f, 0.02266685f, 0.21664086f, -0.02811334f, -0.06186720f, -0.10790146f, 0.03260108f, 
    0.05890807f, 0.02262751f, -0.17602137f, 0.04567100f, -0.06346656f, 0.04465897f, -0.00808795f, 0.04641305f, 
    0.06136553f, -0.09751967f, -0.09362552f, 0.14292231f, -0.17603219f, 0.04852045f, 0.01864451f, -0.00290880f, 
    0.02110594f, -0.13608435f, -0.08292078f, -0.08716423f, 0.04406814f, 0.00380289f, 0.02922550f, 0.03097191f, 
    -0.14040923f, -0.03864975f, -0.04843351f, -0.09925379f, -0.22147851f, -0.02177799f, 0.19633766f, -0.08947799f, 
    0.47517201f, -0.62133503f, -0.22214851f, 0.39840776f, -0.14234382f, 0.04482914f, 0.12655957f, -0.08409570f, 
    0.03985666f, 0.10881142f, -0.10758758f, 0.12009069f, 0.19311766f, 0.38341060f, 0.07867766f, 0.06432296f, 
    0.19317468f, 0.20677286f, -0.21780555f, 0.14615023f, 0.16725366f, -0.02306605f, 0.06107542f, 0.13587090f, 
    -0.14786041f, -0.14661731f, -0.05672689f, -0.16520640f, 0.08201288f, 0.06550626f, -0.01072846f, 0.10228165f, 
    -0.14803362f, -0.05513768f, 0.11173081f, -0.13661236f, 0.00068752f, -0.10198128f, -0.05481452f, 0.01290842f, 
    0.17654234f, -0.13224076f, -0.29192889f, -0.21202694f, -0.03509444f, 0.07334351f, -0.08440080f, -0.04079342f, 
    0.06905379f, 0.04992474f, 0.06582169f, 0.00710186f, 0.19998367f, -0.05266102f, 0.05516773f, 0.09262846f, 
    -0.00136627f, 0.24198923f, -0.03262825f, 0.18040648f, -0.12346138f, 0.04835283f, 0.29783195f, 0.00680621f, 
    0.13753720f, -0.17856644f, 0.02330743f, 0.09238648f, 0.06556589f, -0.08302358f, 0.06309678f, 0.18178077f, 
    0.20262688f, 0.15116405f, 0.16211712f, 0.00535536f, -0.05290242f, -0.24684599f, -0.09822408f, -0.00368683f, 
    0.33687821f, 0.41082832f, -0.37010059f, -0.26525018f, 0.23502249f, -0.11087818f, -0.16778938f, 0.07224679f, 
    -0.04298507f, -0.06549633f, 0.11745791f, -0.06055908f, 0.06468657f, -0.07592070f, -0.01483899f, -0.02193117f, 
    -0.06556550f, -0.02917120f, 0.28416392f, -0.08888726f, -0.41100010f, -0.05657429f, -0.08433019f, 0.26196414f, 
    -0.05542821f, -0.28066173f, 0.01029591f, 0.09754629f, -0.11796700f, 0.03447827f, -0.02476377f, -0.12290259f, 
    0.04214213f, 0.03017113f, -0.07190166f, -0.06839177f, -0.06099033f, -0.16499847f, -0.00379585f, -0.24413727f, 
    0.34350297f, 0.14892349f, 0.05270954f, -0.07349340f, 0.04371651f, -0.02023775f, 0.03515647f, 0.13548936f, 
    0.01420249f, -0.08798875f, 0.02459169f, 0.10781816f, -0.03982728f, 0.04682080f, -0.00988789f, -0.08786414f, 
    0.18052086f, -0.23341602f, 0.02164707f, 0.02385871f, -0.06415441f, 0.05992528f, -0.05553012f, -0.02196566f, 
    -0.15033652f, -0.09329347f, -0.02612301f, 0.04877888f, 0.01227516f, 0.19199032f, -0.03781049f, -0.16893229f, 
    0.07002521f, -0.06445401f, -0.08772961f, 0.03186629f, -0.03038618f, 0.20733857f, 0.04074814f, -0.04267758f, 
    0.02408029f, 0.21860123f, -0.18156448f, -0.06217574f, -0.00271506f, 0.01312908f, -0.11988150f, -0.20450670f, 
    -0.14646316f, -0.20007540f, 0.02195993f, 0.26344833f, 0.23597269f, -0.21117201f, -0.06762380f, -0.09312788f, 
    0.20373310f, 0.14708324f, 0.05510858f, 0.03221258f, 0.16278487f, 0.11151174f, 0.30238146f, 0.02778739f, 
    0.03486662f, 0.18952435f, 0.07483428f, 0.00004996f, 0.01535479f, 0.09341002f, 0.15375701f, -0.04997898f, 
    0.02325188f, 0.10528378f, 0.18272245f, 0.10223950f, 0.30655581f, 0.08994730f, 0.22635797f, 0.27939394f, 
    -0.08993615f, 0.12840538f, 0.00911534f, 0.03619548f, -0.20308951f, 0.03059707f, -0.05040449f, -0.09507283f, 
    -0.15214427f, 0.03415928f, 0.09498636f, -0.00240318f, -0.07740525f, 0.08586086f, -0.05095192f, 0.05108844f, 
    -0.01810382f, -0.00441564f, -0.14090271f, 0.10306931f, 0.27566352f, 0.02805175f, -0.10013244f, -0.04472082f, 
    -0.12811419f, -0.00617691f, -0.24120551f, 0.12752670f, -0.09576415f, 0.16220763f, -0.02242232f, 0.03587892f, 
    -0.22169207f, 0.18178441f, -0.02128611f, 0.22504281f, 0.02535270f, 0.02007090f, 0.14151150f, 0.11383783f, 
    -0.12019434f, 0.39995065f, 0.47408614f, 0.11820111f, -0.10471549f, 0.00648294f, 0.12570894f, -0.01488329f, 
    0.26076052f, 0.47676399f, 0.06085617f, -0.03866701f, 0.01091705f, -0.02215195f, -0.01333395f, -0.00166506f, 
    0.34393919f, 0.07512809f, 0.32014501f, 0.28855890f, 0.21120144f, 0.04552647f, -0.14501983f, 0.10481442f, 
    0.14061432f, -0.05165085f, -0.20788920f, -0.25202924f, -0.06140484f, -0.10791484f, 0.10738997f, 0.11479481f, 
    -0.03353535f, -0.12937987f, 0.04435712f, 0.02442895f, 0.12998571f, 0.02559970f, -0.06461740f, -0.16314204f, 
    -0.53157514f, 0.18335459f, 0.13369855f, -0.20924020f, 0.21370173f, -0.09637590f, -0.04095944f, -0.16648366f, 
    -0.18277732f, 0.00648553f, -0.02488159f, 0.03373294f, -0.06058512f, -0.06649476f, -0.23929878f, -0.02802245f, 
    0.18260206f, -0.13073017f, -0.02977350f, 0.10781247f, 0.19663148f, 0.20248054f, 0.16953748f, 0.13116360f, 
    0.11754520f, 0.10366392f, 0.05087662f, 0.12014719f, 0.07687714f, 0.09214542f, 0.13261868f, 0.18783049f, 
    0.01186373f, 0.01290238f, -0.08082327f, -0.05220524f, -0.26123688f, -0.17404532f, -0.15521906f, -0.07317696f, 
    0.02737714f, -0.19313473f, 0.02009529f, -0.23236962f, -0.16215517f, -0.02255980f, -0.15243164f, 0.06501240f, 
    -0.38908842f, -0.15265538f, 0.21018425f, 0.11214228f, 0.14189631f, 0.02679701f, -0.14359866f, -0.01665620f, 
    -0.03882513f, -0.05909918f, 0.12626855f, -0.10348517f, 0.34805954f, -0.34245124f, -0.41180778f, -0.08997396f, 
    -0.21450332f, -0.09183358f, -0.17636317f, 0.15570624f, -0.06760922f, -0.37103790f, 0.17118192f, 0.02386205f, 
    -0.04358821f, -0.07313884f, 0.13614556f, 0.03098087f, -0.12011109f, -0.01966765f, 0.07816345f, -0.21423827f, 
    -0.12361271f, 0.11804435f, 0.39608961f, -0.40656343f, 0.22153534f, -0.00043935f, 0.16833751f, -0.01398967f, 
    -0.07748093f, 0.01309547f, 0.02110726f, -0.00495840f, 0.09642949f, -0.02423535f, -0.09455805f, 0.02165931f, 
    0.10584839f, -0.13976051f, -0.06371660f, 0.18110554f, 0.27556553f, 0.17830873f, -0.37690115f, 0.33804366f, 
    -0.01806595f, 0.12596910f, -0.27029663f, 0.07379667f, 0.03535952f, 0.01355305f, 0.08421033f, 0.01785349f, 
    0.20531586f, 0.04600276f, -0.03247060f, 0.07901317f, 0.13048561f, -0.05076317f, 0.11545216f, 0.10021046f, 
    -0.15866421f, 0.43641078f, 0.25696620f, 0.03664803f, 0.09179471f, 0.10290415f, 0.24986076f, 0.06804585f, 
    -0.01203194f, 0.10570723f, 0.02367545f, -0.02896774f, -0.16969113f, -0.06778396f, -0.10034108f, -0.13735166f, 
    -0.02701350f, -0.13860899f, -0.32119936f, -0.09251129f, 0.88310748f, 0.22727869f, -0.32759774f, -0.21232565f, 
    0.43652737f, 0.02762849f, -0.02438097f, 0.00407035f, 0.15010811f, -0.25619695f, 0.11045936f, -0.04655605f, 
    0.07533946f, -0.05946578f, 0.12157154f, -0.22102635f, 0.10724270f, 0.06108110f, -0.16818480f, -0.31148320f, 
    -0.37370095f, 0.18603490f, 0.13142601f, -0.11435987f, 0.17043667f, -0.07312701f, -0.18237488f, -0.23475899f, 
    -0.22911026f, -0.05148045f, 0.02094447f, -0.05870270f, -0.05918841f, -0.13128355f, -0.09821851f, -0.07825144f, 
    -0.04232698f, -0.13433804f, -0.28221205f, -0.33371726f, 0.54552042f, 0.18363769f, 0.02554845f, 0.04528886f, 
    0.14603081f, 0.13378988f, 0.24921174f, -0.10829183f, 0.07540259f, 0.06048156f, 0.07175335f, -0.03498323f, 
    0.02599511f, 0.05508748f, -0.00372633f, 0.07791601f, 0.02775003f, 0.04375670f, 0.02378984f, 0.04842053f, 
    -0.02197875f, 0.13138554f, -0.03810193f, -0.03561103f, 0.13381256f, -0.02630683f, 0.04274430f, -0.20970640f, 
    -0.02699948f, 0.01664604f, 0.00671172f, -0.02252844f, 0.15318072f, 0.02647453f, 0.09629385f, 0.06725800f, 
    0.13463089f, -0.12237523f, 0.22330475f, 0.17538007f, 0.06686003f, 0.05526455f, 0.12325079f, -0.10556045f, 
    0.03592245f, 0.09823016f, -0.08504392f, 0.02330053f, 0.06981852f, 0.01184940f, 0.01660359f, 0.05591477f, 
    -0.06798831f, -0.09038775f, -0.04206963f, -0.01115503f, -0.01209735f, 0.06714591f, 0.06215694f, -0.07808974f, 
    0.19401404f, -0.12520573f, 0.15431181f, -0.06931616f, -0.00890622f, 0.00872969f, -0.27077910f, 0.20470792f, 
    -0.14985472f, 0.14456196f, 0.06391513f, 0.13711673f, 0.08871320f, 0.11050807f, 0.00508623f, 0.10125898f, 
    -0.02325631f, 0.21341138f, 0.20369314f, -0.09027386f, 0.12206815f, 0.44423983f, 0.21353570f, 0.12837535f, 
    -0.00734793f, 0.15270571f, -0.08585103f, 0.04268749f, -0.24802659f, 0.13153295f, -0.04291590f, 0.03076987f, 
    0.21055669f, -0.10527825f, 0.08278985f, -0.02904297f, -0.03581597f, 0.17537588f, 0.05462924f, 0.11253063f, 
    0.06582934f, -0.30205661f, 0.12794046f, 0.08873127f, 0.11031836f, -0.10491949f, 0.14648785f, 0.19537076f, 
    -0.10420935f, 0.01745799f, 0.04717248f, -0.02513553f, -0.14889199f, 0.01244743f, 0.06032502f, 0.07974567f, 
    -0.06795282f, 0.01699080f, -0.07850716f, -0.03672959f, -0.16244441f, -0.26654121f, -0.01293595f, 0.02730057f, 
    -0.19133034f, -0.14385137f, -0.18200591f, -0.06196049f, -0.18433212f, -0.03207156f, -0.04797082f, 0.00047282f, 
    0.08809069f, 0.06651597f, 0.00388758f, 0.03703468f, 0.00749923f, 0.00405700f, 0.22591685f, 0.02196429f, 
    -0.67084467f, -0.14492840f, -0.14077082f, 0.06654908f, 0.16200089f, -0.06013693f, 0.25984064f, 0.07273789f, 
    0.06912159f, 0.04946768f, -0.04740854f, -0.07800946f, 0.00597260f, 0.00328289f, 0.10616856f, 0.02712154f, 
    0.09169994f, 0.19886431f, 0.21317589f, 0.15109996f, -0.34147635f, -0.08928230f, -0.11166125f, -0.03204968f, 
    -0.03739476f, 0.11688454f, 0.13266563f, -0.01704523f, 0.02795799f, -0.03569277f, 0.20932679f, -0.18331850f, 
    -0.09225930f, -0.03327652f, -0.03927187f, 0.07033684f, 0.01981693f, -0.00910440f, 0.00794391f, 0.05798383f, 
    -0.32142383f, 0.92435014f, 0.23103996f, -0.21270236f, 0.32416987f, 0.04606428f, -0.18210408f, 0.02532744f, 
    -0.02970462f, 0.00998891f, 0.05680047f, 0.12507300f, 0.05467586f, -0.21145374f, 0.03179884f, 0.03370855f, 
    -0.02042772f, 0.04290542f, 0.21086109f, 0.21734314f, -0.09860408f, 0.40192771f, 0.36752290f, -0.16294789f, 
    0.25806862f, 0.13808817f, -0.06117944f, 0.10405450f, -0.04340784f, 0.07185686f, -0.04759701f, 0.07166398f, 
    0.10521368f, 0.21729307f, -0.09684137f, 0.02694302f, -0.13182412f, 0.12201232f, -0.05902964f, -0.05926724f, 
    -0.36666033f, 0.03449547f, 0.04220724f, 0.13325368f, 0.03487927f, 0.13401859f, 0.28222531f, 0.10272995f, 
    0.02011857f, -0.02530523f, 0.01593451f, -0.03397390f, -0.04865294f, -0.00155699f, 0.18224464f, 0.05169723f, 
    -0.04295979f, 0.12588130f, 0.17970747f, -0.04555549f, 0.20495786f, -0.26436990f, -0.14167048f, -0.19782494f, 
    -0.13233534f, 0.08446367f, -0.18648235f, -0.13927789f, -0.31088635f, -0.09899991f, 0.03468677f, -0.09569539f, 
    -0.12372877f, 0.02414306f, -0.08197413f, 0.02166229f, -0.01649237f, 0.04454846f, -0.06388659f, -0.01495269f, 
    -0.34229055f, -0.43635866f, -0.12892458f, 0.09392092f, -0.00110215f, 0.09560512f, 0.19109370f, -0.09712576f, 
    0.01570980f, 0.06143915f, -0.03347890f, 0.01571509f, -0.12589903f, 0.07816031f, 0.07746164f, 0.00690271f, 
    -0.09922786f, 0.12595865f, 0.04784935f, 0.16817529f, 0.28677276f, 0.35342956f, 1.05874741f, -0.21644083f, 
    0.16278702f, 0.21401131f, -0.13671270f, -0.40763113f, 0.14819564f, 0.01215251f, -0.03648065f, 0.05800999f, 
    0.01178895f, -0.07586346f, 0.09004579f, -0.09851443f, -0.03886940f, -0.09223858f, 0.04380500f, 0.13153724f, 
    -0.32850575f, -0.52046990f, -0.21411736f, -0.06432712f, 0.18942825f, -0.21974100f, -0.11878204f, -0.06080698f, 
    -0.04672554f, 0.07204892f, 0.04614595f, -0.17108326f, -0.06868147f, -0.05555662f, 0.01098347f, -0.05049010f, 
    -0.00369514f, 0.06492179f, -0.03851892f, -0.10359877f, -0.23435795f, -0.09419984f, 0.02170785f, -0.02052839f, 
    0.00753606f, 0.11046188f, 0.07897024f, 0.01720134f, 0.15769044f, -0.12271791f, 0.02571870f, 0.07172053f, 
    -0.05090173f, -0.00841374f, 0.01861858f, -0.05938930f, -0.02840226f, 0.05049649f, 0.09664995f, 0.13769159f, 
    0.00079101f, -0.04605629f, 0.01002059f, -0.06201664f, -0.02688249f, -0.05082986f, 0.04014722f, 0.02052137f, 
    -0.01108763f, -0.04787001f, -0.04637788f, -0.03031881f, 0.04254269f, -0.04656950f, 0.02468237f, -0.01260604f, 
    0.03797645f, -0.05861769f, -0.05317025f, -0.03831106f, -0.05094904f, -0.00016581f, -0.02495900f, 0.03524692f, 
    -0.03604249f, -0.01706526f, 0.00186711f, -0.00726694f, 0.00810956f, -0.02925037f, 0.03369324f, -0.05405964f, 
    -0.01223227f, 0.02225490f, -0.03217879f, 0.03793192f, -0.04210876f, -0.03495442f, -0.01876936f, -0.03664334f, 
    -0.04199444f, -0.05870856f, -0.01230008f, -0.00013474f, 0.02946489f, -0.05794951f, 0.02934872f, 0.04619721f, 
    -0.01525683f, 0.00768180f, 0.03460379f, 0.03960057f, -0.00307151f, -0.06114480f, -0.00194604f, 0.02283202f, 
    0.03164316f, -0.06295206f, 0.04588342f, -0.00904337f, 0.03428015f, -0.04660644f, 0.04737705f, -0.01321926f, 
    -0.05247345f, 0.02695304f, -0.02994640f, -0.01057881f, 0.03049362f, 0.02792258f, -0.02132700f, 0.01623010f, 
    -0.02336338f, 0.04075640f, 0.04754225f, -0.03513363f, 0.01990956f, 0.02577250f, 0.00139238f, -0.04678959f, 
    -0.02064966f, -0.03226858f, 0.03320291f, -0.00873382f, -0.04626469f, -0.03390683f, -0.03460842f, 0.04585618f, 
    -0.03256548f, -0.05673581f, -0.03569850f, 0.03131904f, 0.01898695f, 0.00649772f, -0.04231995f, 0.03301452f, 
    -0.04584796f, -0.04024429f, -0.05760897f, -0.03718962f, 0.03850057f, -0.02618230f, -0.05255050f, -0.01689482f, 
    0.03184602f, 0.05055336f, -0.05918108f, -0.00485460f, -0.01569353f, 0.02498125f, 0.01925332f, -0.03636785f, 
    0.02910500f, 0.03571374f, -0.04478449f, -0.01550495f, 0.04019390f, -0.05299817f, 0.02525183f, 0.01269123f, 
    -0.02638724f, 0.02168048f, -0.01322867f, -0.05866419f, -0.05051789f, 0.01600345f, -0.02686409f, -0.03838720f, 
    0.01872745f, -0.03316863f, 0.02801286f, -0.00540032f, 0.02530367f, -0.04676033f, -0.00583352f, -0.04044892f, 
    -0.04832449f, -0.01898643f, 0.03536598f, 0.02041020f, -0.05071978f, -0.01231654f, 0.00601709f, 0.04886526f, 
    0.03348999f, -0.00604542f, -0.02934889f, -0.00741630f, -0.00634387f, -0.03873643f, -0.05127697f, -0.01109556f, 
    0.04446676f, 0.02747964f, -0.04572422f, -0.03020822f, -0.01979619f, 0.04304997f, 0.02139085f, 0.01940797f, 
    0.04372538f, 0.01465976f, 0.03687017f, -0.05502684f, -0.04942912f, 0.00808036f, 0.00885469f, -0.03341379f, 
    0.03785375f, -0.06177362f, -0.01715351f, -0.02166264f, -0.00199226f, -0.02674485f, -0.02463990f, 0.03142371f, 
    -0.05797665f, 0.01421182f, -0.00733708f, 0.03993475f, -0.06057449f, -0.03515760f, 0.04107678f, 0.00356039f, 
    -0.01421533f, -0.00034821f, 0.04053642f, -0.03367100f, 0.03562676f, -0.04939297f, -0.02554722f, -0.06466180f, 
    -0.03038736f, 0.03024695f, -0.03013614f, -0.00553754f, -0.00833455f, -0.05097055f, 0.01912345f, 0.00238279f, 
    -0.05598268f, 0.00213334f, -0.00813566f, -0.01924122f, -0.00204885f, -0.03040113f, 0.00199421f, -0.01061478f, 
    0.03420450f, 0.01408440f, -0.04345309f, 0.01126420f, 0.00894603f, -0.01809916f, -0.01560587f, 0.03314735f, 
    -0.04271008f, -0.04468077f, -0.00847535f, 0.02143018f, -0.00705784f, 0.04738780f, -0.03959348f, -0.02118791f, 
    -0.02788448f, -0.04035265f, -0.01634517f, -0.01403393f, 0.04406230f, -0.01789765f, -0.02937698f, 0.01346510f, 
    0.04739782f, 0.01499598f, 0.04270771f, 0.02185046f, 0.02593156f, -0.00711767f, 0.03454898f, -0.03595193f, 
    0.02935369f, -0.00397178f, 0.03963986f, 0.01098628f, 0.03860452f, 0.00523094f, -0.02050602f, -0.01364084f, 
    0.02539854f, 0.01188042f, 0.01293635f, 0.00867517f, -0.00403665f, -0.05053511f, 0.04682401f, -0.00619243f, 
    -0.05878442f, -0.05900135f, -0.00791581f, -0.02797233f, 0.02724918f, -0.01917471f, 0.01451694f, 0.04035673f, 
    -0.00281298f, -0.00365643f, -0.00584469f, -0.06732158f, -0.05380433f, -0.04604333f, -0.04853273f, 0.04673917f, 
    0.03398735f, 0.04569636f, -0.01886807f, -0.01476794f, -0.01960890f, -0.01296925f, -0.04034127f, -0.05472467f, 
    -0.05177974f, -0.05167964f, 0.03468432f, 0.02897744f, -0.01392205f, -0.00294773f, 0.03657335f, 0.02742971f, 
    -0.06224544f, -0.03405744f, 0.01502356f, 0.03987311f, 0.02888190f, -0.01470016f, -0.02882686f, 0.01963140f, 
    0.00908187f, -0.04308489f, 0.02799637f, -0.03519697f, 0.01328978f, -0.05624336f, 0.04657844f, -0.04408607f, 
    -0.05457486f, 0.04312423f, 0.03239796f, -0.05602835f, -0.02490226f, -0.02592765f, 0.04150910f, -0.03342807f, 
    0.04491201f, 0.00749900f, -0.02451160f, 0.02364619f, 0.01221380f, 0.00006087f, 0.04483057f, 0.04537155f, 
    0.12750898f, 0.16977274f, 0.19586250f, 0.16420124f, 0.04774313f, -0.03312703f, 0.01909634f, 0.03418050f, 
    -0.10098338f, -0.04644478f, 0.03783590f, -0.09146961f, -0.02097150f, 0.00785414f, -0.12627123f, 0.18059053f, 
    -0.09274937f, -0.03731101f, -0.18617830f, 0.09298344f, 0.15222308f, 0.21575513f, -0.16200560f, 0.01165345f, 
    -0.09661704f, 0.02293919f, 0.06904799f, 0.03363263f, 0.27808404f, 0.12670660f, -0.01671908f, -0.01833043f, 
    -0.01265785f, 0.00497452f, 0.21804367f, -0.11631444f, -0.15705341f, 0.01842477f, 0.09888864f, 0.01686113f, 
    -0.08517303f, 0.29965621f, -0.12137568f, 0.03185377f, 0.06892319f, -0.08177390f, -0.01815639f, 0.07415018f, 
    -0.24903771f, -0.10431764f, -0.05005828f, -0.01656591f, -0.13772415f, -0.00271617f, 0.04150594f, 0.05895800f, 
    -0.08080209f, 0.08723002f, -0.04781336f, 0.13916914f, 0.14669980f, -0.17388982f, -0.13975248f, -0.15570951f, 
    -0.07763224f, 0.13535215f, 0.00088350f, 0.25267678f, 0.02993267f, -0.10819519f, -0.21758808f, -0.06702981f, 
    0.14704482f, -0.12686738f, 0.04130812f, -0.11317132f, -0.12950708f, 0.15067941f, -0.12161619f, 0.00570720f, 
    0.15509383f, -0.17051575f, -0.10260437f, 0.11592235f, 0.47400990f, 0.17406857f, -0.14363295f, 0.23227434f, 
    0.01013160f, 0.22663036f, 0.01653555f, 0.04408345f, 0.01761638f, -0.05440574f, -0.01184118f, -0.14910513f, 
    0.09371617f, -0.08563773f, -0.17130613f, -0.19220935f, 0.04051591f, 0.10297029f, 0.13063250f, 0.03853204f, 
    -0.08660899f, 0.05332901f, 0.04154128f, 0.02836765f, -0.13660917f, -0.14236702f, 0.12693539f, 0.10243480f, 
    0.05920268f, 0.06877353f, -0.17879128f, 0.00116377f, -0.06487837f, 0.02556618f, 0.00315091f, -0.05148208f, 
    0.29139581f, -0.24039826f, 0.19804950f, 0.05583249f, -0.00465496f, -0.10615976f, 0.05852178f, -0.01358326f, 
    -0.09322035f, -0.02281997f, 0.15018608f, -0.08008732f, -0.00325430f, 0.05160869f, -0.10685658f, 0.18228048f, 
    -0.03990404f, -0.00713783f, 0.02694013f, -0.16863286f, -0.07373251f, -0.18309487f, 0.09293386f, 0.25616303f, 
    0.06163950f, 0.35780704f, 0.10380470f, 0.23334208f, 0.27501309f, 0.25559330f, -0.12820491f, -0.02738385f, 
    -0.04739738f, -0.08074408f, -0.08626595f, 0.03813020f, 0.06814378f, 0.08217148f, 0.08736954f, 0.20915160f, 
    0.18389612f, -0.09041277f, 0.27732182f, -0.29765964f, 0.25087526f, -0.08488367f, -0.02728280f, 0.11664116f, 
    -0.14858043f, 0.03160486f, 0.09909373f, 0.06545920f, 0.01322315f, 0.02898047f, -0.19900796f, 0.02214350f, 
    -0.08312417f, 0.04789862f, 0.00389657f, 0.04626624f, 0.13921355f, -0.03122955f, -0.01756156f, -0.37276196f, 
    -0.23124765f, 0.05008802f, -0.04697337f, -0.02809205f, -0.07775471f, 0.00515400f, -0.00658537f, 0.13973509f, 
    0.03271956f, 0.00756714f, -0.10386097f, 0.05333467f, 0.05477885f, 0.15412426f, -0.00837792f, 0.07295343f, 
    -0.11810452f, -0.09320154f, 0.31347576f, 0.25276390f, 0.11861201f, -0.11423351f, -0.02579131f, 0.00297301f, 
    0.18409137f, 0.07543433f, -0.02163578f, -0.00413247f, -0.06176937f, -0.09154464f, 0.02397270f, -0.03443837f, 
    0.01349687f, -0.04909061f, 0.03009907f, -0.23103216f, 0.02608771f, 0.36785698f, 0.03877391f, 0.20803627f, 
    -0.15743007f, -0.07611980f, 0.07312232f, 0.08055491f, -0.11344887f, -0.14791170f, 0.14122595f, 0.05494146f, 
    -0.02036418f, -0.02401347f, -0.08051915f, 0.04840440f, -0.11051792f, 0.01824625f, -0.02548425f, 0.01723891f, 
    0.06843551f, 0.07106260f, -0.09044956f, 0.49503160f, -0.01506625f, 0.15767857f, -0.08060513f, -0.04437298f, 
    0.12038976f, 0.09547006f, -0.04152725f, 0.06516987f, 0.00013788f, -0.05758755f, 0.07992275f, 0.09221029f, 
    -0.04110163f, -0.00115292f, -0.05127274f, 0.02745885f, -0.18527368f, 0.31559777f, -0.37147740f, 0.02021505f, 
    -0.30006307f, 0.16598642f, 0.16233818f, -0.28770149f, 0.03941085f, -0.33714533f, 0.05411208f, -0.09799477f, 
    0.13447313f, 0.07787142f, 0.07699532f, 0.08445027f, 0.02362938f, -0.04907999f, 0.13105930f, -0.06915081f, 
    -0.02252260f, 0.13080297f, -0.12731278f, 0.03227077f, -0.30060443f, 0.06661569f, 0.14013417f, -0.00131238f, 
    -0.09035406f, -0.12380568f, 0.11212613f, 0.04159710f, -0.04379667f, 0.01425079f, 0.00355085f, 0.25312304f, 
    0.22469613f, 0.10211903f, -0.06087641f, -0.01584206f, -0.08979014f, -0.24129526f, 0.07388625f, -0.00022148f, 
    0.12017685f, 0.06291217f, -0.00576246f, 0.02356106f, 0.22123198f, 0.18030606f, -0.01136815f, -0.03984480f, 
    -0.02923388f, 0.03543774f, -0.06119358f, -0.08571458f, -0.00724173f, 0.07447461f, 0.03572267f, 0.01199432f, 
    0.00885631f, -0.00754187f, -0.01363763f, -0.00968956f, -0.05075352f, -0.04628980f, -0.02716804f, 0.00778699f, 
    -0.02493858f, 0.05351176f, -0.04171301f, -0.04243832f, -0.04572059f, -0.02935763f, -0.02031387f, 0.04898318f, 
    -0.03806476f, 0.03414892f, -0.04166258f, -0.02685643f, 0.03924301f, 0.04724859f, -0.02870889f, -0.05210305f, 
    -0.03101835f, -0.00128552f, -0.02236364f, -0.00208339f, 0.01173036f, 0.05303768f, -0.00783988f, -0.02347314f, 
    0.03943421f, 0.01083288f, 0.05526537f, 0.05581012f, 0.04651315f, 0.00333707f, -0.00495207f, -0.03242204f, 
    -0.04259507f, -0.01881760f, -0.04016612f, 0.01034828f, -0.05353575f, 0.01237526f, -0.00777183f, -0.00795648f, 
    0.01136270f, -0.04185586f, -0.03004517f, -0.03551782f, 0.00447498f, -0.03857402f, -0.01374464f, -0.04276629f, 
    0.01437442f, 0.03784889f, -0.05548321f, 0.00530602f, -0.01400285f, 0.01156926f, 0.01276362f, -0.01190455f, 
    -0.04037339f, -0.04913753f, -0.01168329f, 0.04749255f, 0.05018089f, -0.01352966f, 0.01697011f, -0.04407280f, 
    -0.04186855f, 0.04870254f, -0.03827816f, -0.01008009f, -0.05551214f, -0.05262148f, -0.03291149f, -0.02519530f, 
    -0.00986396f, 0.00805095f, 0.00356800f, 0.02564171f, -0.01819083f, -0.03511642f, -0.04589553f, -0.04387014f, 
    -0.03371801f, -0.02262441f, 0.03655875f, 0.00126847f, -0.01104596f, -0.03481334f, -0.00643320f, -0.03489214f, 
    0.00898260f, -0.04264335f, -0.02204581f, -0.04234571f, 0.00720101f, 0.02251586f, -0.05231449f, -0.02611189f, 
    -0.03519027f, -0.04357996f, -0.04379385f, -0.04030282f, -0.03096462f, 0.04118739f, 0.04684880f, -0.01196406f, 
    -0.00600269f, 0.01907010f, -0.03032706f, 0.02605710f, 0.03791870f, -0.00300518f, -0.04039357f, -0.05033388f, 
    0.04669693f, 0.03632739f, -0.02146741f, -0.04008931f, -0.03565382f, -0.03214119f, -0.02199270f, -0.02890948f, 
    0.05287570f, 0.02547565f, 0.00716136f, 0.00137671f, -0.02169381f, -0.01492651f, -0.01570981f, -0.01072703f, 
    0.02484168f, 0.00909350f, 0.01596756f, -0.02778975f, 0.03868129f, -0.00176110f, -0.04376096f, -0.02801009f, 
    -0.01124778f, -0.01217668f, -0.00809873f, 0.03060851f, 0.01178201f, 0.01856212f, 0.04814133f, 0.01902238f, 
    -0.01833411f, -0.04073509f, -0.02840979f, 0.03753528f, 0.02292696f, -0.00806296f, 0.04743596f, -0.04805185f, 
    0.01803032f, 0.00417512f, -0.03890566f, -0.02522694f, -0.04359319f, -0.02013433f, 0.01348036f, -0.00965413f, 
    0.00749702f, 0.03244348f, 0.05382479f, -0.01335353f, -0.03022779f, -0.02619695f, 0.01549898f, 0.03021860f, 
    -0.03010422f, 0.01389306f, -0.05191589f, 0.05587088f, 0.00775599f, -0.02553036f, -0.02595869f, -0.00736482f, 
    0.05381434f, -0.04446806f, 0.04180522f, -0.05409858f, -0.04134653f, -0.05322021f, 0.02625211f, -0.05575354f, 
    0.01574284f, 0.02602950f, 0.03792886f, -0.02300479f, -0.02427373f, 0.03759335f, -0.01913589f, -0.00208997f, 
    -0.00987730f, 0.03141409f, 0.02903137f, -0.01138018f, -0.03882961f, 0.01440921f, -0.03191211f, -0.00416127f, 
    0.01229906f, -0.04662300f, -0.00283946f, -0.03757149f, -0.03828041f, -0.01573550f, 0.04046040f, -0.04859298f, 
    -0.04853741f, -0.02399708f, -0.05203794f, 0.00873773f, 0.00967706f, -0.02544377f, 0.02886879f, 0.00857878f, 
    -0.04213267f, -0.03813276f, -0.01382936f, -0.02928840f, 0.01387931f, -0.00061132f, 0.00490882f, -0.02371012f, 
    0.03574355f, 0.00334955f, -0.03878470f, 0.02070929f, 0.05125954f, 0.03710144f, 0.03471763f, -0.02571593f, 
    -0.00693992f, 0.03430611f, -0.02499216f, 0.00353617f, -0.04469989f, 0.05279617f, -0.00988417f, -0.00958739f, 
    -0.04361855f, -0.05164969f, 0.02300539f, -0.00191151f, -0.02667457f, -0.01540000f, 0.04361763f, 0.03606734f, 
    0.05559867f, 0.03575039f, -0.04514210f, 0.01909115f, 0.02345623f, 0.04987674f, -0.04438848f, -0.02857323f, 
    -0.03041306f, -0.02583036f, 0.03754538f, -0.05062190f, 0.01925063f, -0.04755493f, 0.02360276f, 0.00272658f, 
    -0.02015455f, -0.01440382f, -0.01312645f, -0.02707315f, 0.00844631f, 0.04627124f, 0.03053336f, 0.05569871f, 
    -0.04569947f, 0.05363257f, 0.02438118f, 0.03695156f, -0.02872584f, 0.04518994f, 0.01753501f, 0.05157099f, 
    -0.04238795f, -0.02519415f, -0.00654269f, -0.01247293f, 0.03051851f, 0.03300592f, 0.02735985f, -0.00122635f, 
    -0.03634174f, -0.00448158f, -0.00781722f, -0.00351464f, -0.00298875f, -0.03731324f, -0.04948394f, -0.01945166f, 
    -0.01145850f, -0.01252920f, 0.03018277f, 0.01418489f, -0.02436049f, 0.05541023f, 0.01622949f, -0.03874889f, 
    -0.05309848f, 0.00331655f, 0.00137900f, -0.04068225f, 0.01563969f, -0.05463291f, 0.01775279f, 0.00261710f, 
    -0.07787180f, 0.02465300f, 0.00279459f, 0.13962124f, -0.16590187f, -0.01096499f, 0.04570015f, 0.20973033f, 
    -0.04920094f, -0.08218987f, 0.01472794f, 0.04934642f, 0.16757663f, 0.01811236f, 0.04270717f, 0.14640468f, 
    0.14323947f, 0.12174047f, 0.20229587f, -0.24918628f, 0.37197664f, 0.13971241f, 0.00208846f, 0.20459098f, 
    -0.04732355f, 0.29236880f, 0.13562122f, 0.14803672f, -0.09325445f, -0.02047870f, 0.11560108f, 0.06084058f, 
    0.12338153f, 0.10848853f, 0.11319163f, 0.15797806f, 0.12653604f, -0.06654626f, 0.12489894f, 0.27493441f, 
    0.20253499f, -0.38511452f, 0.44043231f, 0.06969508f, 0.12256891f, -0.03303255f, 0.07698357f, -0.17718793f, 
    0.05830859f, -0.16138723f, -0.06077767f, 0.07899591f, -0.01632388f, 0.16130398f, 0.05274999f, -0.04753314f, 
    0.06865610f, 0.08291922f, -0.05513294f, 0.07254893f, 0.01401728f, 0.48600960f, -0.27096108f, 0.38916412f, 
    -0.03400845f, 0.06567013f, 0.11009682f, 0.14804901f, 0.09678698f, 0.01374078f, -0.08966843f, 0.07255994f, 
    -0.06565917f, 0.07102295f, -0.02818078f, 0.12389129f, 0.04443204f, 0.10381960f, -0.02045831f, 0.23146695f, 
    -0.01325222f, -0.08698243f, 0.09133632f, 0.09374113f, -0.03957988f, -0.18509860f, -0.09210420f, -0.04509606f, 
    -0.00634233f, -0.06078447f, 0.02608186f, 0.02404639f, -0.05442831f, -0.02152471f, 0.01803508f, 0.12017394f, 
    0.03715997f, -0.00659687f, 0.10420022f, 0.14499088f, 0.17475869f, -0.04455680f, -0.10346360f, 0.07754385f, 
    -0.12890312f, -0.15443675f, -0.06108608f, 0.13936822f, 0.21980503f, -0.00006932f, -0.17221960f, 0.01267706f, 
    -0.02177114f, -0.03230913f, -0.04468220f, 0.04724570f, 0.07143414f, -0.00002222f, -0.03422390f, -0.16562955f, 
    -0.11682517f, 0.21699323f, 0.08607376f, 0.18184055f, -0.37385434f, -0.21370716f, -0.21484102f, 0.11390173f, 
    0.11780801f, 0.00654295f, -0.18121922f, -0.01698942f, 0.01989305f, 0.08129212f, 0.11624525f, 0.15457089f, 
    0.02691655f, 0.06581228f, 0.21981578f, 0.05269777f, -0.39507368f, -0.09213179f, -0.08035334f, 0.16009054f, 
    0.20120899f, 0.06730448f, 0.06404474f, 0.08116764f, 0.13381390f, 0.07763679f, 0.12748639f, 0.01468977f, 
    -0.07122830f, -0.01386100f, -0.02824897f, 0.08839891f, -0.11036844f, -0.03195700f, -0.06617785f, -0.01273926f, 
    -0.41851252f, 0.40828535f, -0.39591146f, 0.66426653f, -0.16116804f, 0.15103266f, 0.05524455f, 0.14319552f, 
    0.27580637f, 0.00704444f, -0.24731980f, -0.02370645f, 0.06618554f, 0.08107273f, 0.09922286f, 0.05078008f, 
    0.19362979f, 0.13053912f, 0.14562456f, -0.09206513f, -0.04805739f, -0.10583264f, -0.20973258f, 0.25353149f, 
    -0.13543771f, -0.08383768f, 0.02526095f, 0.01306814f, 0.11925822f, 0.08114573f, -0.05662620f, 0.03120193f, 
    -0.09775329f, -0.06038372f, 0.05514987f, -0.14880370f, -0.01148513f, -0.05233709f, 0.08725686f, -0.03555143f, 
    -0.28314251f, 0.25727707f, -0.22190437f, 0.25934532f, 0.18134323f, 0.03095586f, -0.07103066f, -0.14019291f, 
    -0.06321775f, 0.12586907f, 0.06666972f, 0.04825079f, 0.12678571f, -0.00678354f, -0.01074326f, 0.17135970f, 
    -0.07030655f, 0.16984130f, 0.08262199f, -0.05853112f, -0.04117135f, -0.38604382f, -0.03655075f, -0.21282949f, 
    -0.08442033f, 0.00422309f, -0.00235779f, 0.05525018f, 0.07450738f, -0.13415964f, -0.04046780f, 0.06946868f, 
    0.06020444f, -0.04306640f, 0.01602913f, 0.00933790f, 0.12966919f, -0.12539503f, -0.15996651f, -0.14692742f, 
    -0.18310103f, 0.09811053f, 0.47604042f, -0.19520156f, 0.38283235f, 0.03734743f, -0.21821643f, 0.18946904f, 
    0.09068973f, -0.01924969f, -0.07701705f, -0.01055081f, 0.02042771f, 0.06927738f, 0.00896229f, 0.08173875f, 
    -0.15857099f, -0.01503817f, 0.09754506f, -0.09450483f, -0.16187747f, 0.02686395f, -0.05281041f, -0.10735051f, 
    -0.01676269f, 0.23197481f, -0.02226628f, 0.24088894f, -0.17857413f, 0.09660914f, -0.10620663f, 0.03449214f, 
    0.03605029f, 0.06313109f, -0.08479451f, -0.11816981f, -0.03458721f, -0.03569447f, -0.03115127f, -0.16133766f, 
    0.24913056f, 0.00843858f, 0.25619057f, -0.20048532f, -0.30504417f, -0.06361234f, 0.02267569f, 0.08809898f, 
    -0.03715627f, -0.09161348f, 0.00452087f, 0.08321778f, 0.00098023f, 0.02278076f, 0.03522037f, 0.02506447f, 
    0.14481583f, 0.09090691f, -0.03180974f, -0.01085612f, 0.35100815f, 0.17040430f, -0.19077443f, 0.09550762f, 
    0.25109038f, -0.03729633f, -0.13520707f, -0.09789054f, -0.14540452f, 0.05165734f, -0.03878157f, 0.05496253f, 
    -0.01910068f, -0.15363760f, -0.10418940f, 0.15606642f, -0.02062567f, -0.05680971f, -0.00384497f, -0.05521185f, 
    0.25934249f, 0.09811237f, 0.00604962f, 0.13628606f, 0.14589457f, -0.05014157f, -0.07150386f, 0.02754845f, 
    -0.10567352f, -0.21061505f, 0.01253678f, 0.01610676f, 0.07015684f, 0.04618996f, 0.00967284f, 0.13354427f, 
    -0.01292551f, 0.09479286f, 0.09249575f, -0.08472624f, 0.08493540f, 0.00379170f, 0.38604844f, -0.09075177f, 
    -0.35471115f, -0.00291512f, -0.06003418f, 0.16807137f, -0.00395439f, -0.08291902f, -0.01684525f, -0.08589673f, 
    0.05915706f, -0.06988031f, 0.06166508f, 0.13051757f, -0.23870897f, -0.11443771f, -0.09246226f, -0.01888855f, 
    0.17854598f, 0.15927370f, 0.04313607f, 0.41459697f, 0.03120125f, -0.08815968f, 0.21118605f, -0.27873337f, 
    -0.10668516f, 0.15094391f, -0.15434971f, -0.01715469f, -0.10908423f, 0.28739613f, -0.01399169f, 0.05535819f, 
    -0.04612159f, -0.12728854f, 0.07091066f, 0.15036906f, 0.36906016f, -0.27432111f, 0.16963807f, 0.24758951f, 
    -0.08902918f, 0.16067024f, 0.05418745f, 0.08844634f, 0.07500332f, 0.17239116f, -0.24739918f, 0.09445586f, 
    0.12279363f, 0.08497511f, 0.15244851f, -0.02975969f, -0.15159550f, -0.07337818f, 0.07463174f, 0.27524018f, 
    0.15133230f, -0.12715012f, 0.26773742f, -0.14909230f, -0.32044175f, 0.10882053f, -0.21513467f, -0.09717231f, 
    -0.06492788f, 0.12836824f, 0.07540829f, -0.01751754f, -0.00024021f, -0.10486472f, -0.04632891f, 0.06312548f, 
    0.01951383f, -0.18074207f, 0.03166737f, -0.02191484f, 0.01423874f, 0.19888303f, 0.01763024f, 0.12576726f, 
    0.03043419f, -0.17415470f, -0.06380936f, -0.12059487f, -0.01792204f, -0.16966188f, -0.04961254f, -0.01821700f, 
    0.00672127f, 0.00131894f, 0.07365262f, -0.07817390f, -0.04835451f, 0.11358561f, 0.09694918f, -0.00195395f, 
    0.10352282f, 0.29104504f, 0.35132295f, 0.08722452f, -0.23294555f, -0.20827633f, -0.13299285f, -0.24817707f, 
    -0.03515378f, 0.13841633f, 0.11905153f, 0.04211827f, 0.12129378f, -0.02098393f, -0.09889616f, -0.04257159f, 
    0.14309198f, 0.07433665f, 0.12873763f, -0.19486870f, 0.20817442f, -0.38235569f, -0.26727346f, 0.00998324f, 
    -0.24792361f, 0.12580910f, 0.00102112f, 0.04216460f, 0.00275002f, -0.01382990f, 0.05225561f, 0.11708106f, 
    0.02222533f, 0.06029976f, 0.02014070f, 0.00064007f, 0.17484348f, 0.03995340f, 0.11301222f, 0.07104959f, 
    0.15003650f, -0.11599229f, 0.30823246f, 0.05538512f, 0.20834516f, -0.09110782f, 0.10170460f, 0.01127374f, 
    0.05105222f, 0.25863880f, 0.05926499f, 0.10755772f, 0.08663695f, -0.07122563f, -0.04718234f, 0.00670558f, 
    0.06419165f, 0.03477511f, 0.31608421f, 0.12582603f, -0.22756942f, -0.23885249f, -0.19860056f, -0.13339727f, 
    -0.09733479f, -0.05190269f, -0.04188809f, 0.05007163f, 0.13535111f, 0.02452154f, -0.00768965f, 0.01100437f, 
    0.04534324f, 0.03205399f, 0.12729074f, -0.08939951f, 0.00058161f, 0.02811051f, 0.13545735f, 0.18316524f, 
    0.51706034f, -0.01211604f, 0.19125535f, -0.00261785f, -0.11013516f, 0.06383006f, -0.09164211f, 0.15229963f, 
    0.06502906f, 0.09281269f, -0.01886619f, -0.03448044f, 0.09453472f, 0.01707701f, -0.07351053f, -0.00018586f, 
    -0.13770549f, 0.13801351f, 0.09283676f, -0.14724927f, -0.25665104f, 0.02769719f, -0.15685456f, 0.24992543f, 
    0.09092502f, -0.28948566f, -0.03770980f, -0.12098830f, -0.06923047f, -0.33821672f, -0.14849083f, -0.01725075f, 
    -0.05105026f, 0.17128122f, -0.08057844f, -0.00815339f, -0.12478317f, 0.10855193f, 0.11394115f, 0.07860573f, 
    0.47509095f, 0.07978794f, -0.04027490f, 0.08290191f, -0.38226554f, 0.26500487f, -0.20210122f, 0.14564694f, 
    0.00064691f, 0.11784437f, 0.15346831f, 0.09873198f, 0.10655537f, -0.11644683f, -0.10774138f, 0.15827276f, 
    0.06666064f, -0.02463738f, -0.05404701f, 0.15917480f, 0.22720411f, -0.24619342f, -0.44047913f, 0.22738235f, 
    -0.29111487f, -0.07704772f, -0.04701017f, -0.22259201f, 0.14949664f, -0.29548016f, 0.22785178f, -0.12380610f, 
    0.09520679f, -0.13457544f, -0.00162955f, 0.12403557f, -0.05850078f, 0.11203228f, 0.05485513f, 0.04356591f, 
    -0.04749263f, 0.29540408f, 0.26911470f, -0.01724940f, -0.21260327f, -0.16522041f, -0.21400444f, -0.12693377f, 
    -0.06785814f, -0.05969187f, -0.03069766f, 0.03516904f, 0.07963629f, 0.04390042f, -0.12173627f, 0.00883787f, 
    0.12465773f, 0.03028515f, 0.00793553f, 0.10862274f, 0.27398446f, -0.03141761f, -0.00320326f, -0.12967893f, 
    -0.23466103f, 0.08548333f, -0.09593228f, 0.13023540f, 0.03819874f, 0.10299522f, -0.06328487f, -0.12846218f, 
    0.05590028f, -0.10144007f, -0.04493932f, -0.07051462f, -0.06524870f, -0.00606945f, 0.06399551f, -0.02675946f, 
    -0.15574373f, 0.14744648f, 0.04376718f, 0.18923190f, -0.02425756f, -0.07933138f, -0.08404215f, -0.05807052f, 
    -0.02911805f, -0.00250787f, -0.02544421f, -0.10629454f, 0.05078229f, -0.09619766f, 0.31632286f, 0.00508739f, 
    -0.01061649f, -0.14994359f, 0.17291901f, -0.03037312f, -0.14755452f, 0.28891316f, -0.08478592f, 0.01720317f, 
    0.29334095f, -0.05126362f, 0.03475492f, 0.08985362f, -0.19802625f, 0.08584591f, -0.10547276f, -0.10804561f, 
    -0.07717987f, 0.08054064f, 0.19504170f, -0.04119691f, -0.10278239f, 0.12557238f, -0.18797813f, -0.08661096f, 
    0.54879922f, 0.12189953f, 0.29524177f, 0.24512181f, 0.39202166f, 0.10076983f, -0.00766244f, -0.13745540f, 
    0.14737214f, 0.10317583f, -0.05480583f, 0.01070606f, 0.09713596f, 0.04917652f, 0.14361845f, 0.19511537f, 
    0.08418863f, -0.05135030f, -0.02641322f, -0.17954341f, 0.15388909f, 0.27561700f, 0.13793437f, 0.16723642f, 
    0.45778558f, 0.05127190f, 0.10661504f, -0.23432465f, -0.02611195f, 0.04443767f, 0.06658562f, -0.03222019f, 
    0.12932210f, 0.14641453f, 0.24686216f, -0.18214755f, -0.06219967f, -0.04892738f, 0.09867609f, 0.00183041f, 
    0.33874479f, 0.03538685f, 0.45094961f, 0.45498875f, 0.39975870f, -0.20689903f, 0.10474427f, -0.00848763f, 
    0.05086852f, -0.00297382f, 0.02217990f, 0.01550566f, -0.03021789f, -0.10036183f, -0.05236057f, 0.27010164f, 
    0.11219724f, -0.04427652f, 0.09291812f, -0.13579172f, -0.22503774f, -0.10899724f, -0.09852847f, 0.02036412f, 
    -0.04703121f, -0.10425189f, -0.08548962f, -0.03861970f, 0.11108093f, 0.04675307f, 0.05454227f, 0.11357137f, 
    0.09027854f, 0.09194441f, 0.26368073f, 0.14750434f, 0.11741206f, 0.06281824f, 0.08645965f, -0.06365340f, 
    -0.25187659f, 0.18586883f, 0.34631157f, 0.52579212f, 0.07187060f, 0.03546347f, 0.00370260f, 0.02865919f, 
    0.17879330f, 0.02750021f, -0.04836303f, -0.00422532f, 0.02469466f, -0.09377412f, -0.02294958f, -0.13005684f, 
    0.07582059f, 0.14845863f, -0.03373410f, 0.07544000f, 0.43437275f, 0.03353375f, 0.00446936f, 0.03308435f, 
    0.21519296f, 0.12170501f, 0.12009859f, 0.04226993f, 0.05877094f, 0.04501277f, -0.05066685f, 0.02585945f, 
    -0.14023058f, -0.15028270f, -0.11091429f, -0.06702653f, -0.02313299f, -0.00438544f, 0.17103936f, 0.21312846f, 
    -0.34973824f, 0.64623910f, -0.13727979f, 0.07680094f, 0.18071279f, -0.06651169f, -0.05560652f, -0.07279288f, 
    0.07096635f, 0.21364665f, 0.11665133f, -0.05564141f, 0.05910471f, -0.05013312f, 0.23094223f, -0.04419847f, 
    -0.18038592f, 0.13067450f, 0.19619447f, 0.16832459f, -0.28862697f, -0.15937229f, -0.12839174f, 0.00473349f, 
    0.06650805f, 0.05082605f, 0.14169371f, 0.12035872f, 0.09258699f, 0.06725688f, 0.28494790f, 0.02283176f, 
    0.03317049f, -0.02770156f, -0.08898649f, -0.01190576f, 0.04374055f, 0.10754254f, 0.00064767f, -0.03888811f, 
    0.25911859f, 0.21361186f, 0.07177857f, 0.35578823f, 0.02840826f, 0.07179865f, 0.11700693f, 0.16362336f, 
    0.03755245f, -0.08512472f, 0.00847100f, -0.00785547f, 0.04067176f, 0.08475972f, 0.08375115f, 0.06080361f, 
    0.02771210f, 0.23649681f, 0.02054184f, 0.07117376f, -0.16437486f, -0.25441453f, -0.09172678f, -0.08659462f, 
    0.00285687f, -0.04197795f, -0.02075970f, -0.07514855f, 0.00655365f, -0.00114041f, -0.01655926f, 0.18331303f, 
    0.19459820f, 0.18281652f, 0.28792995f, 0.00984421f, 0.04587934f, 0.08454110f, 0.01184510f, -0.13034563f, 
    0.48958188f, 0.04785677f, 0.52309692f, 0.26642171f, 0.12847100f, 0.22144061f, 0.11198271f, 0.12932844f, 
    0.20728810f, 0.09605276f, 0.01209769f, 0.01004927f, 0.02182766f, 0.00854375f, 0.01896298f, 0.01181084f, 
    0.07253344f, 0.07801609f, 0.01981577f, 0.34667876f, -0.17062877f, -0.29370943f, -0.10574427f, -0.17009370f, 
    0.01069959f, 0.02643755f, -0.04638763f, 0.08421619f, 0.22081430f, 0.05301967f, 0.12507921f, 0.03426319f, 
    -0.19748791f, -0.10326757f, -0.02674288f, -0.16093054f, -0.06036734f, -0.03516172f, -0.02914881f, 0.12153044f, 
    -0.22661854f, -0.08838156f, 0.11026704f, 0.06356458f, -0.07311970f, -0.06698411f, -0.03211296f, -0.07535440f, 
    -0.00576986f, -0.00463229f, -0.05066213f, 0.07881452f, 0.12204716f, 0.03348469f, 0.12425806f, 0.27851379f, 
    0.17418440f, 0.06072056f, -0.00916098f, -0.04057746f, -0.04537386f, 0.07597400f, -0.04758581f, 0.02989831f, 
    0.33172885f, 0.27030608f, 0.00843470f, 0.24559483f, 0.09397419f, -0.04369836f, 0.04613340f, -0.00008817f, 
    -0.04300857f, 0.03703513f, 0.01262125f, 0.02261221f, 0.04348574f, -0.05841717f, 0.15249066f, 0.35908684f, 
    -0.13022515f, -0.07317013f, -0.03321508f, 0.22091731f, -0.10781463f, -0.01703837f, -0.16766913f, 0.00479654f, 
    -0.01869272f, -0.02393800f, -0.14808209f, -0.02047018f, -0.04029730f, -0.01902876f, 0.12700807f, -0.08834725f, 
    0.03523617f, -0.00408390f, -0.02427416f, 0.09208605f, -0.03644360f, -0.04195604f, -0.17042090f, 0.15999238f, 
    -0.08800903f, -0.06035262f, 0.04192543f, -0.13507473f, -0.16153340f, -0.03075658f, -0.01315277f, -0.04809276f, 
    -0.03327381f, -0.10261774f, 0.04759518f, 0.23603083f, 0.12194414f, 0.15902412f, -0.05367904f, -0.12120100f, 
    -0.16433553f, 0.08101158f, 0.05979113f, -0.00829375f, 0.20860040f, -0.05734188f, -0.00304603f, 0.06861368f, 
    0.02640667f, -0.04200482f, -0.08462004f, 0.00046083f, -0.03438940f, 0.14847608f, 0.07802603f, 0.05103850f, 
    0.20484130f, 0.29527599f, 0.18279190f, -0.16485785f, 0.00325111f, -0.20932102f, 0.41883051f, -0.32455692f, 
    -0.01641982f, 0.09773031f, 0.04885356f, -0.27462977f, 0.13308699f, -0.03831161f, -0.05876771f, 0.02489977f, 
    0.11896459f, 0.01495605f, 0.26781315f, 0.16672914f, 0.06611159f, 0.13855349f, -0.01654357f, -0.10518090f, 
    0.07667572f, -0.40915969f, -0.06329015f, 0.06612133f, 0.27108601f, 0.10876140f, -0.02663831f, 0.38199630f, 
    0.08439235f, 0.33816391f, 0.02389529f, 0.05590637f, 0.01699091f, 0.05455090f, -0.05925966f, 0.13738126f, 
    0.18206024f, 0.03578525f, -0.10543188f, 0.00474622f, -0.34613639f, -0.08318028f, 0.07346745f, -0.06207823f, 
    -0.03632721f, -0.02306700f, -0.11302583f, -0.05074444f, -0.01047144f, -0.15802565f, 0.00731360f, -0.18582974f, 
    -0.15448971f, -0.07006285f, -0.07694414f, 0.16127381f, -0.13711971f, 0.04003152f, 0.13725770f, -0.04576975f, 
    -0.33559394f, -0.16397695f, 0.02826278f, 0.44067213f, 0.02105020f, 0.07236080f, -0.07617556f, 0.05163205f, 
    0.26958188f, 0.10377457f, -0.03560720f, 0.01126113f, -0.15137140f, -0.04724812f, -0.10026835f, 0.08367598f, 
    0.06629519f, 0.02079731f, -0.09018437f, -0.08812474f, 0.20097527f, -0.01949383f, -0.07752977f, -0.07369345f, 
    -0.15004338f, 0.11606244f, 0.05009983f, 0.18030751f, 0.20763855f, 0.21457121f, -0.02066316f, 0.03283081f, 
    0.02714658f, -0.07138340f, -0.01482794f, 0.05788234f, 0.10114776f, 0.02173704f, -0.03841478f, 0.37184346f, 
    -0.38362226f, -0.03633159f, 0.10522760f, 0.03821684f, 0.12530984f, -0.06288264f, -0.16588765f, -0.30251506f, 
    0.09516139f, 0.21565723f, -0.01052543f, 0.11293731f, -0.03766995f, -0.05897824f, 0.11095269f, 0.13873951f, 
    0.22501609f, 0.05797890f, 0.28160608f, 0.12430505f, 0.00697955f, -0.03379347f, 0.37908861f, -0.06804063f, 
    -0.00454777f, -0.01370450f, -0.15032579f, -0.14116779f, 0.06352089f, 0.15091969f, 0.05072545f, 0.07232931f, 
    0.22791965f, 0.10028525f, 0.00393852f, -0.01856566f, 0.11889890f, 0.04540863f, 0.19676824f, 0.07833784f, 
    0.12303790f, 0.03874303f, -0.13240331f, 0.17836273f, -0.23852091f, 0.00267108f, -0.18921779f, -0.01993610f, 
    0.11369082f, 0.19954577f, -0.03879254f, 0.07385306f, 0.02487095f, 0.14391804f, 0.00597156f, 0.01819219f, 
    0.03646739f, -0.11292809f, 0.04322340f, 0.16189489f, -0.30058590f, -0.21304306f, 0.15412425f, -0.10271610f, 
    -0.02240196f, -0.10837743f, -0.13327073f, -0.08222306f, -0.07538597f, -0.10082339f, 0.10333794f, 0.10363889f, 
    -0.02416286f, 0.12488713f, -0.08758367f, 0.12977445f, -0.04307010f, 0.14442007f, -0.01499791f, -0.10134882f, 
    0.34434131f, 0.05861322f, 0.11127742f, -0.02986053f, -0.43747693f, 0.14949010f, -0.08214406f, 0.13587068f, 
    0.27850777f, 0.19348134f, 0.00301946f, 0.08637790f, 0.13226275f, 0.04299814f, -0.01112161f, -0.00832848f, 
    0.02977386f, 0.11609726f, 0.06889404f, 0.12440395f, -0.03818114f, 0.15574381f, 0.00807003f, 0.25700608f, 
    -0.18031079f, -0.05662113f, 0.01281010f, -0.16032369f, 0.00536960f, -0.13507025f, -0.05907371f, -0.23049118f, 
    0.03438791f, 0.05975452f, 0.10578419f, 0.02041410f, 0.01898624f, -0.01261473f, 0.05373983f, 0.08306865f, 
    -0.39358476f, -0.15693238f, -0.05704461f, 0.12314851f, -0.30004126f, -0.08110113f, -0.07376321f, 0.04146055f, 
    -0.10915808f, -0.19209842f, -0.01702933f, -0.14811541f, -0.07046130f, -0.06459226f, -0.00009114f, 0.09957968f, 
    0.00594384f, 0.10282265f, -0.05707372f, -0.05437469f, -0.18632884f, -0.20833205f, -0.34272504f, -0.16576858f, 
    0.03688763f, 0.08398851f, -0.08927722f, 0.08414649f, 0.08661902f, 0.05741272f, 0.04306928f, -0.01323596f, 
    0.06727656f, 0.12347683f, -0.06744810f, 0.01967406f, 0.00642943f, -0.00574180f, 0.05625064f, 0.16115709f, 
    -0.20783220f, 0.23030725f, 0.18289876f, -0.00903900f, 0.13548295f, -0.00981467f, -0.01577764f, 0.03371997f, 
    -0.04357372f, -0.04461853f, 0.00688304f, -0.05594420f, 0.12334030f, -0.00964570f, -0.06985320f, 0.44669962f, 
    0.14668120f, 0.11752456f, -0.15106091f, 0.02597438f, 0.14332661f, -0.29663712f, -0.12148914f, 0.04664925f, 
    0.22404134f, 0.04416463f, 0.09938269f, 0.06805042f, 0.30608320f, 0.09268661f, 0.05170951f, -0.05954549f, 
    0.10991989f, 0.09344081f, 0.20299982f, 0.32668707f, 0.17634460f, 0.14992708f, 0.31996465f, 0.22996254f, 
    0.14723848f, 0.03338683f, 0.19269572f, -0.14432928f, 0.22514838f, 0.01642278f, 0.16633679f, -0.03631663f, 
    0.08124543f, -0.06280969f, 0.02660978f, -0.00772140f, 0.02523542f, 0.02951081f, -0.04106040f, 0.13346496f, 
    0.07934397f, 0.00982475f, 0.30503261f, 0.20846128f, 0.06970815f, 0.35344991f, 0.11035917f, 0.24437770f, 
    0.26410291f, 0.10123658f, 0.13745019f, 0.18032432f, 0.04876892f, 0.08124934f, 0.15173097f, 0.14931025f, 
    0.28836530f, 0.05393900f, -0.02384010f, 0.19982132f, 0.17310560f, 0.13089782f, 0.21710046f, 0.07228769f, 
    -0.09823821f, -0.62647915f, -0.13390698f, -0.00774610f, 0.21185158f, 0.05194136f, 0.24210812f, 0.13014279f, 
    0.16170247f, -0.05866524f, -0.03035843f, -0.02793554f, -0.00083019f, -0.10776567f, 0.00617053f, 0.00164865f, 
    0.03364761f, 0.06063629f, 0.12230445f, -0.04005158f, -0.11804697f, 0.13725825f, 0.11491393f, -0.06161916f, 
    -0.05205227f, -0.07615178f, 0.00623353f, -0.04007179f, -0.14686380f, 0.00509817f, -0.15910399f, -0.13772960f, 
    -0.05363754f, 0.00988409f, -0.19287454f, 0.17985956f, 0.09970295f, -0.03524606f, -0.03546476f, 0.01910230f, 
    0.10423314f, 0.11823774f, 0.41500828f, 0.19239940f, -0.35275152f, 0.09018451f, 0.08296290f, 0.13659000f, 
    -0.09870806f, 0.04390251f, 0.02259269f, -0.03589029f, 0.06878608f, 0.04135084f, 0.03736713f, 0.14234409f, 
    0.09041974f, 0.15721038f, 0.15862373f, 0.13281174f, -0.24936895f, -0.36918542f, -0.34225106f, 0.32057709f, 
    0.17319395f, -0.14588991f, -0.09888963f, -0.05011556f, -0.01706213f, -0.05015267f, -0.01512340f, -0.03540426f, 
    -0.06351904f, -0.06422493f, 0.05222674f, -0.04393670f, 0.02791063f, 0.18322557f, -0.05321813f, -0.16000451f, 
    -0.17821604f, 0.32509139f, 0.03123947f, 0.34369549f, 0.12443531f, 0.14535980f, 0.06909740f, 0.09733499f, 
    -0.00985961f, -0.00609151f, 0.13873683f, 0.15764029f, 0.12453739f, 0.23606223f, 0.14272577f, 0.26287904f, 
    0.04470105f, 0.27312857f, -0.03114983f, 0.03387526f, -0.11735551f, 0.21145163f, 0.15746383f, 0.06379700f, 
    0.08119009f, -0.06869480f, -0.07400419f, -0.02463503f, -0.06213384f, -0.13369477f, 0.12669514f, 0.15384196f, 
    0.00722443f, 0.24489081f, 0.13559210f, -0.05774146f, -0.05201134f, -0.02196901f, 0.00327264f, -0.04053969f, 
    -0.23429127f, -0.20747080f, -0.22312482f, 0.11241022f, 0.09862515f, 0.08247498f, 0.07299447f, -0.05763973f, 
    0.05660900f, 0.09778807f, 0.08613079f, -0.08235668f, 0.06607725f, -0.01838668f, 0.00053542f, 0.03381948f, 
    0.15164755f, 0.32761666f, 0.03124069f, -0.05898898f, -0.23344046f, 0.06107330f, -0.09701046f, -0.02940097f, 
    -0.03459583f, -0.12980829f, -0.03192090f, -0.05494801f, -0.10618605f, -0.11418062f, -0.03371575f, 0.01052282f, 
    0.26270920f, -0.02373789f, 0.09496520f, 0.01465675f, 0.02600786f, -0.16322175f, 0.08000216f, -0.01783878f, 
    0.30010784f, -0.27911308f, -0.53765547f, -0.05506870f, 0.13654815f, 0.08954575f, -0.13240181f, 0.00007740f, 
    -0.04587083f, -0.04379172f, 0.04846868f, 0.13299283f, -0.01145581f, 0.00434154f, 0.06492895f, 0.09862291f, 
    0.08266132f, 0.10345649f, 0.10141557f, 0.20806700f, -0.36818045f, 0.16979343f, 0.03679898f, 0.00778563f, 
    -0.10652509f, -0.03827645f, -0.09048284f, -0.19071096f, -0.05671820f, -0.17618310f, 0.12756318f, 0.05991495f, 
    0.25477737f, 0.15081881f, 0.07452191f, -0.03180521f, 0.03719059f, -0.18889897f, 0.07520066f, -0.05516266f, 
    0.06398308f, 0.00527411f, 0.07719494f, -0.20316248f, -0.07342520f, -0.13765854f, -0.10905096f, -0.07047781f, 
    0.03967479f, -0.08473539f, -0.07103997f, -0.04680648f, -0.15586375f, -0.10931086f, -0.07165991f, -0.03697168f, 
    0.15665831f, -0.04352903f, 0.00910327f, -0.06035303f, -0.22816215f, -0.40045628f, -0.23156530f, 0.04801308f, 
    -0.02768797f, 0.03738235f, -0.07115997f, 0.00038975f, 0.09125820f, 0.03382865f, 0.01594110f, 0.05827973f, 
    0.06249239f, -0.04966883f, -0.04055179f, 0.04067592f, -0.00961270f, 0.17812885f, 0.01244839f, -0.00196531f, 
    0.04425970f, 0.03064817f, -0.10529731f, -0.16580124f, 0.03966904f, 0.02577944f, -0.10011432f, 0.04041480f, 
    0.04585158f, -0.10564036f, 0.00842329f, 0.13261095f, 0.03534862f, -0.13596602f, -0.05391974f, -0.11068594f, 
    0.21152103f, 0.15844987f, -0.07287019f, 0.01425497f, 0.05621478f, -0.29638028f, 0.25608557f, 0.29172590f, 
    -0.04409338f, -0.01893071f, 0.00055846f, -0.12236870f, 0.10310750f, 0.12573947f, 0.09448627f, 0.05737662f, 
    -0.00883299f, 0.05601852f, 0.08302978f, 0.18623129f, 0.29259282f, 0.21434541f, 0.26011208f, 0.37369058f, 
    -0.38904309f, 0.05100381f, -0.30789256f, -0.18561481f, -0.04383361f, 0.04893751f, 0.11552136f, 0.18105645f, 
    -0.03373596f, -0.02058173f, 0.15930673f, -0.01191311f, -0.14238504f, 0.06115595f, 0.00507605f, 0.05690297f, 
    0.15404603f, -0.05982705f, -0.20709343f, 0.14858964f, 0.00052149f, -0.23816851f, 0.19646546f, -0.12499408f, 
    -0.06620608f, 0.11215180f, -0.16328920f, -0.00620188f, 0.08570424f, 0.06821895f, -0.01086514f, 0.06318153f, 
    -0.17879994f, 0.07787999f, 0.09554504f, 0.20621939f, 0.16311398f, -0.16508900f, 0.10758713f, 0.06312664f, 
    -0.33548838f, 0.09164880f, -0.12864490f, -0.17479405f, -0.15957448f, 0.16185308f, 0.00610479f, 0.08202063f, 
    0.11802404f, 0.22044483f, -0.03791817f, -0.05521865f, 0.10033838f, 0.04843014f, -0.00523500f, 0.13452996f, 
    0.33332756f, 0.19895306f, 0.15651686f, 0.35751146f, 0.04201156f, 0.10265001f, 0.02979534f, -0.35254496f, 
    0.16966450f, 0.10221474f, -0.17793141f, -0.04601283f, 0.00168853f, -0.10763267f, 0.12702584f, -0.03867739f, 
    -0.02308819f, -0.01985513f, 0.04333041f, 0.13548942f, 0.04940993f, -0.04185103f, -0.09738754f, 0.01409463f, 
    0.05679526f, -0.01128238f, -0.07406595f, -0.08979946f, 0.23657145f, 0.11546299f, -0.06038391f, -0.05983473f, 
    -0.06009688f, -0.04993968f, -0.12973607f, -0.02807066f, -0.10356393f, -0.04785931f, -0.20339897f, 0.09672377f, 
    0.06642455f, -0.07674883f, -0.08609588f, 0.20830888f, 0.09446627f, 0.21974245f, 0.15440243f, 0.04391253f, 
    0.04760369f, -0.02023806f, -0.02355111f, 0.02134282f, 0.07636419f, 0.13359247f, 0.01835162f, 0.20253490f, 
    0.03875537f, -0.04323427f, -0.07068311f, 0.02694231f, -0.27294317f, -0.23621903f, -0.04328557f, -0.15266953f, 
    0.19491678f, -0.57001942f, 0.19074471f, -0.09057795f, -0.20796254f, -0.03359422f, -0.11447686f, -0.05413437f, 
    -0.05270200f, -0.22175750f, 0.03620510f, -0.05782888f, 0.19042262f, 0.15723678f, 0.08479791f, -0.01263088f, 
    0.06153091f, -0.00434180f, 0.01106770f, -0.07459484f, 0.46133465f, 0.17557561f, 0.46892756f, -0.00005463f, 
    -0.15755337f, -0.17273566f, -0.39527172f, -0.17145860f, 0.02569050f, -0.26879588f, 0.07258982f, 0.08876543f, 
    -0.07892273f, -0.01562824f, 0.31129575f, -0.00267482f, -0.18317762f, -0.06954222f, 0.02109148f, -0.14760837f, 
    -0.12828450f, -0.02405408f, 0.12760143f, -0.20736356f, -0.17210707f, -0.08297520f, -0.13915837f, -0.07311362f, 
    0.06053653f, 0.21167317f, -0.00959463f, 0.04955941f, 0.05135327f, -0.05643740f, -0.04454114f, 0.03679218f, 
    0.10605735f, -0.13572820f, -0.06483950f, 0.25668606f, 0.10921156f, 0.21318106f, 0.13895592f, 0.03575484f, 
    0.09682481f, -0.08027893f, -0.21046130f, 0.26811016f, 0.01053856f, 0.05311602f, 0.22967334f, -0.01502117f, 
    0.12378368f, 0.02172121f, 0.10267285f, 0.16348581f, 0.05234806f, -0.05791573f, -0.01304489f, 0.04532528f, 
    -0.03947648f, 0.29257223f, -0.21540256f, 0.05581346f, -0.07350342f, -0.07611421f, 0.16043761f, 0.06677409f, 
    -0.00249354f, 0.14810783f, 0.12489506f, -0.04046002f, -0.01370155f, -0.12109349f, -0.15636607f, -0.12552549f, 
    -0.09896965f, -0.13848485f, -0.01854691f, -0.16505674f, 0.76234007f, 0.25293782f, 0.11706582f, 0.61859745f, 
    0.57051021f, -0.41967529f, 0.17657542f, -0.28340787f, -0.03081988f, -0.27599755f, -0.09286305f, -0.03372280f, 
    0.07810209f, -0.01355730f, -0.01967136f, -0.07789260f, -0.24983962f, -0.30716866f, -0.23061661f, -0.16711946f, 
    -0.17820515f, 0.09158915f, -0.26052573f, -0.12457980f, 0.13170001f, 0.14696714f, 0.02256639f, 0.09065551f, 
    -0.05866874f, -0.09695278f, 0.02268220f, -0.02593030f, -0.04309367f, 0.01135810f, -0.04835618f, 0.01215384f, 
    -0.11444359f, -0.18841714f, -0.03678275f, -0.11971578f, 0.18905842f, 0.03153070f, 0.08780712f, 0.13281175f, 
    -0.04157424f, -0.11032225f, 0.00612363f, -0.12311784f, 0.11090151f, 0.11702275f, 0.02766273f, -0.04208425f, 
    0.15858185f, -0.02619790f, -0.01411815f, 0.09945568f, 0.02804753f, 0.00166447f, 0.12873276f, -0.06886068f, 
    0.03036713f, -0.38456190f, -0.18079136f, -0.42711714f, -0.30798358f, -0.00710997f, 0.00718719f, 0.05009649f, 
    0.08848970f, 0.07625344f, 0.03333063f, 0.25694388f, 0.11855192f, 0.02990239f, 0.03038420f, 0.01124428f, 
    -0.12028015f, 0.06007336f, -0.18114364f, 0.08718299f, 0.10708986f, 0.08333175f, 0.38564262f, 0.12199147f, 
    -0.12987496f, 0.05098377f, 0.12846331f, 0.14646684f, 0.05666647f, 0.04076825f, -0.03025828f, -0.03714870f, 
    -0.04154827f, 0.15253226f, 0.12805641f, -0.09666429f, -0.02091403f, -0.13661416f, 0.13774155f, -0.05749532f, 
    -0.33552867f, -0.19429424f, -0.29807091f, 0.04154088f, -0.32108292f, 0.05219727f, -0.05921065f, -0.10319187f, 
    0.05364619f, 0.10149609f, 0.11837063f, 0.11654080f, -0.01106012f, -0.00406519f, -0.01074330f, -0.13108964f, 
    -0.03437752f, 0.14856343f, -0.07544979f, 0.11678551f, 0.15670197f, -0.00542014f, -0.02201453f, -0.02500362f, 
    -0.28634346f, 0.08433563f, 0.03432675f, 0.07964808f, 0.09421405f, 0.06400475f, -0.08984032f, -0.06952287f, 
    -0.08382820f, 0.16881929f, -0.07022294f, -0.03522127f, 0.06082143f, 0.09254869f, -0.02262425f, -0.05312486f, 
    -0.02928875f, 0.32809412f, 0.10110079f, -0.10712414f, -0.20543160f, -0.06107838f, -0.27847320f, -0.44942772f, 
    -0.16359621f, -0.12297345f, -0.06429210f, 0.06966066f, 0.04438434f, 0.06452569f, 0.02340162f, -0.26284462f, 
    -0.16175081f, 0.09812532f, 0.14583252f, 0.09654246f, -0.07639552f, -0.28742996f, -0.33662310f, -0.13305195f, 
    -0.13873677f, 0.02978045f, 0.05711108f, 0.00513234f, -0.02120907f, 0.06544099f, -0.01512134f, 0.11672120f, 
    0.02315249f, 0.01607235f, 0.13320352f, -0.05104119f, 0.00649545f, 0.04682875f, -0.06977001f, 0.07709489f, 
    0.10807910f, -0.17703216f, -0.46794811f, -0.53434384f, -0.13061722f, -0.21631116f, -0.17881525f, -0.17631875f, 
    -0.16867851f, -0.01891762f, 0.06330973f, 0.00775942f, 0.07791524f, 0.06950713f, 0.07997972f, -0.02722469f, 
    0.07605910f, 0.00057866f, 0.09332516f, -0.21577106f, 0.15132228f, 0.37222546f, 0.31624147f, 0.14549361f, 
    0.14346386f, -0.00877304f, 0.06397109f, 0.10504145f, 0.12837443f, 0.12592055f, 0.24563797f, 0.00389753f, 
    -0.01540503f, 0.07039804f, 0.02793258f, 0.01508831f, -0.02754131f, -0.00694020f, -0.04478461f, 0.20526397f, 
    0.55211544f, -0.63414818f, -0.40636611f, -0.21066268f, -0.37378097f, -0.09967025f, -0.03022420f, 0.04845702f, 
    -0.00591674f, -0.21044776f, -0.07169277f, -0.00672724f, 0.10983688f, -0.01825802f, -0.06695110f, 0.02945547f, 
    -0.01906317f, 0.09581546f, -0.23699845f, -0.24206884f, 0.00831593f, -0.13455257f, -0.18315479f, 0.06322290f, 
    0.06438224f, 0.07422005f, 0.09552291f, 0.03488924f, 0.04638067f, 0.09503627f, -0.04024587f, 0.08707739f, 
    0.00396164f, -0.14901538f, -0.02592060f, 0.04248148f, 0.02460124f, -0.05827254f, -0.02097682f, 0.01017221f, 
    0.11163452f, 0.08400550f, 0.33562332f, -0.23229899f, 0.11609100f, -0.05242882f, -0.10255811f, -0.01441184f, 
    -0.00534987f, 0.02052883f, 0.10601127f, 0.01697999f, 0.03823860f, -0.04769832f, -0.08075416f, 0.05869184f, 
    -0.02208371f, 0.08592967f, 0.07702439f, 0.00615618f, -0.12580030f, -0.28289089f, -0.38743085f, -0.04682107f, 
    0.01993340f, 0.03298902f, 0.07581052f, 0.09266940f, 0.12905882f, 0.09298088f, 0.07758159f, 0.07355461f, 
    0.03281308f, 0.05397922f, 0.00335974f, -0.05298499f, 0.06292075f, 0.00653336f, 0.02647118f, 0.15530971f, 
    0.04077763f, 0.31091753f, 0.19003700f, -0.05175330f, 0.14288352f, -0.05403424f, 0.01344579f, 0.09052569f, 
    -0.09738784f, -0.00716601f, 0.06310216f, -0.07440324f, 0.01761719f, -0.05020785f, 0.05511481f, -0.03207181f, 
    0.00910156f, 0.06059776f, -0.06148452f, -0.04940045f, -0.27449450f, -0.00918076f, -0.11132129f, 0.11945837f, 
    0.16980185f, 0.08733892f, 0.04046711f, 0.23146208f, -0.06556103f, 0.14784154f, 0.00446371f, -0.00159519f, 
    0.01762525f, 0.12157880f, -0.08140278f, 0.05328537f, -0.05849545f, 0.13838819f, -0.12464944f, -0.08078554f, 
    -0.17969190f, -0.17754892f, -0.23225507f, -0.23711747f, -0.04439928f, 0.03998480f, 0.04290416f, -0.04737923f, 
    -0.00039133f, 0.09137968f, 0.05866796f, 0.14215174f, 0.08562733f, 0.16045710f, 0.05067245f, 0.00332543f, 
    0.07655071f, 0.03369111f, 0.00891806f, -0.02148424f, 0.29831403f, 0.24240653f, 0.25138241f, 0.18956165f, 
    -0.06682421f, -0.19166957f, -0.02128549f, -0.01198963f, -0.04102912f, 0.03630272f, 0.05604209f, -0.10481538f, 
    -0.01626188f, -0.02974654f, 0.03056500f, -0.01124936f, 0.01615691f, 0.02079620f, -0.13479608f, 0.00998170f, 
    0.33207139f, -0.33721480f, -0.02566189f, 0.04665406f, 0.19367142f, 0.01409810f, 0.00241849f, -0.07688157f, 
    0.02623786f, -0.06278519f, -0.03342647f, -0.00516910f, -0.26502398f, 0.16434096f, -0.04364914f, -0.10579547f, 
    -0.01435962f, 0.11062313f, -0.00578428f, 0.08057372f, -0.06655590f, 0.16815445f, -0.07254978f, -0.04304383f, 
    -0.19117692f, -0.03681910f, 0.08515716f, 0.04243819f, 0.08072402f, -0.03687012f, 0.03098392f, 0.01290164f, 
    0.00956755f, 0.06504583f, -0.01846212f, 0.14529577f, -0.04850184f, 0.06976115f, 0.01707072f, -0.01836708f, 
    -0.20238908f, 0.15447079f, -0.44385445f, 0.12393317f, 0.14185809f, 0.03244635f, -0.06536447f, 0.04944872f, 
    0.01810576f, 0.01570730f, 0.07574324f, -0.07608221f, -0.08770429f, -0.11671627f, -0.03992973f, 0.10439819f, 
    0.01619232f, -0.07394284f, 0.11646638f, -0.01278798f, 0.16690390f, -0.47373039f, -0.12831147f, -0.04521735f, 
    -0.17872116f, 0.02708800f, 0.04984782f, -0.10513854f, 0.10626066f, -0.07638530f, 0.02803670f, -0.04210200f, 
    -0.03344388f, 0.01687824f, 0.16058491f, 0.00328196f, -0.07459109f, 0.08948918f, -0.03296487f, 0.02918585f, 
    0.23785949f, 0.34188733f, -0.18236478f, -0.21913821f, -0.10109402f, 0.25543922f, -0.00185684f, 0.08555055f, 
    0.15390684f, 0.04083157f, -0.02378127f, 0.02636885f, -0.02309251f, 0.02911137f, -0.07634962f, 0.12177339f, 
    -0.02287330f, 0.12071405f, -0.06547561f, 0.02279651f, 0.06342923f, -0.00749442f, -0.03674278f, -0.03634059f, 
    0.19771683f, 0.07415807f, -0.01053214f, -0.10522517f, -0.10582832f, -0.07565001f, 0.05462220f, 0.02813634f, 
    0.01057908f, -0.08620954f, 0.02709300f, 0.01777205f, 0.01610731f, 0.06076149f, -0.08800617f, -0.02111206f, 
    0.67681038f, -0.28442395f, -0.34719950f, -0.13190724f, 0.25707009f, -0.04671452f, 0.16693915f, -0.01666020f, 
    0.06502052f, -0.02564498f, 0.04693498f, -0.05866491f, -0.06910522f, -0.15368854f, -0.14704756f, -0.08316366f, 
    0.00930841f, -0.01336505f, 0.01704484f, -0.01559505f, 0.21976765f, 0.22620465f, 0.43146023f, -0.05468225f, 
    -0.17587964f, 0.04901802f, 0.02063693f, 0.04599584f, 0.07175409f, 0.02410633f, -0.05765315f, -0.03372662f, 
    0.07682168f, -0.07337493f, 0.01612836f, -0.03082536f, 0.06323954f, -0.06176390f, 0.06441453f, -0.06434631f, 
    0.66910481f, -0.77077323f, 0.05255432f, -0.31446171f, 0.08217614f, -0.31359810f, 0.13458931f, -0.16531180f, 
    0.02399836f, 0.10042484f, 0.05310869f, 0.01854943f, 0.04963668f, -0.04975586f, 0.12818007f, 0.00136874f, 
    0.03652101f, 0.03018834f, 0.09652050f, 0.11201368f, 0.14844792f, -0.10342509f, -0.05948961f, -0.16407900f, 
    -0.18954316f, -0.01325962f, -0.02521748f, -0.15793279f, 0.02909660f, -0.00493439f, -0.05008301f, 0.14421071f, 
    0.12821843f, 0.00264847f, -0.06513055f, 0.03787601f, 0.05350028f, -0.06134862f, -0.09944322f, 0.08547629f, 
    0.53521281f, -0.00494063f, 0.27348527f, -0.11734524f, -0.11897953f, 0.00437703f, -0.03508159f, 0.15829860f, 
    -0.01567144f, 0.00561930f, 0.01546148f, -0.02393589f, -0.03102522f, 0.03615165f, -0.01129429f, 0.02659808f, 
    -0.06792871f, -0.16920495f, 0.13860020f, 0.06754594f, -0.07812556f, 0.17067644f, 0.04791565f, 0.20123532f, 
    0.16831131f, -0.11273113f, 0.00807706f, -0.01148793f, -0.12224740f, -0.10399783f, 0.19413331f, 0.15386289f, 
    -0.07484104f, 0.13536787f, 0.11572327f, 0.01136817f, -0.01606832f, 0.20018123f, -0.06947773f, 0.05774322f, 
    0.06663489f, 0.29191929f, 0.06756366f, -0.01747691f, -0.23639433f, 0.01340213f, -0.04610379f, 0.13161020f, 
    0.06053332f, 0.05050109f, 0.10133000f, 0.00658884f, 0.04923765f, -0.07696649f, 0.02944797f, -0.04166745f, 
    0.03173431f, -0.04414032f, 0.14652669f, 0.08261843f, -0.28022841f, -0.14270420f, -0.16169067f, 0.17745079f, 
    -0.22193520f, -0.23675668f, -0.01084508f, -0.08825557f, -0.08903480f, 0.02409713f, 0.26439279f, -0.11025645f, 
    -0.08037583f, 0.10403254f, 0.03861085f, 0.08471894f, -0.00701663f, -0.01977242f, -0.08102918f, 0.00844869f, 
    0.06302311f, -0.01087078f, -0.35023648f, 0.08185411f, -0.02515272f, 0.16180541f, 0.11922551f, 0.12119796f, 
    -0.04504557f, 0.00228884f, -0.07319290f, 0.02126242f, -0.03677305f, -0.05122084f, -0.00501899f, 0.11364245f, 
    -0.02578994f, -0.11771385f, -0.01837208f, 0.06453941f, -0.03371880f, 0.22000197f, 0.40769619f, -0.00522723f, 
    -0.27442834f, -0.10716293f, 0.08068304f, 0.15818682f, -0.04828427f, 0.22648720f, 0.04106019f, -0.11272124f, 
    0.03120847f, -0.01892174f, -0.01952376f, -0.03069923f, -0.00522583f, -0.03075120f, 0.08524193f, -0.02697066f, 
    0.05151789f, -0.02124410f, -0.03764356f, -0.00318637f, 0.05189924f, -0.02845402f, -0.02495052f, -0.02700594f, 
    -0.01229389f, -0.04355499f, 0.02346394f, 0.03805288f, -0.03229455f, -0.02787484f, -0.00079470f, -0.05918510f, 
    0.04252333f, -0.01484997f, 0.01019871f, 0.00567079f, -0.00724717f, -0.00201785f, -0.03239461f, -0.04813489f, 
    0.00123044f, 0.01360112f, 0.00991889f, -0.04738181f, -0.04655512f, -0.06107760f, -0.02830165f, 0.03479441f, 
    0.05382895f, -0.03172988f, 0.03107903f, 0.00304050f, -0.04726632f, -0.00461670f, 0.02133161f, -0.00487608f, 
    -0.00008292f, -0.05221168f, -0.00456183f, -0.03080692f, -0.02541381f, -0.04652923f, 0.04366493f, 0.03936048f, 
    0.02673814f, -0.01361896f, -0.03992623f, 0.04245301f, -0.05948737f, 0.04271130f, -0.05971656f, -0.06341932f, 
    -0.04751609f, -0.02890709f, -0.03181097f, 0.02580252f, -0.01074851f, 0.00311270f, 0.04656867f, -0.02523033f, 
    0.02078902f, -0.02696428f, 0.04590324f, -0.03735783f, -0.01355811f, 0.00157835f, -0.05514061f, -0.02848702f, 
    0.04516173f, 0.02824756f, -0.00676773f, 0.02001992f, 0.04100050f, 0.03956273f, -0.05459776f, -0.04821729f, 
    -0.00822069f, 0.02321380f, 0.04659208f, -0.01951692f, 0.00360031f, 0.00929663f, -0.06060765f, 0.05762016f, 
    0.04678581f, 0.00965438f, 0.00817781f, 0.03459974f, -0.05722626f, 0.00289148f, 0.02222783f, 0.00531020f, 
    -0.00556519f, -0.00100975f, -0.04387273f, -0.01815912f, -0.05277411f, 0.02073803f, -0.01130654f, -0.04293917f, 
    -0.01648800f, 0.02691217f, 0.03973465f, -0.02812299f, 0.00225430f, 0.03345461f, -0.00797154f, -0.04632737f, 
    -0.05492145f, -0.02075408f, 0.04916556f, -0.01703326f, -0.01607668f, 0.00390660f, 0.01859919f, -0.01600419f, 
    0.01197934f, 0.03486753f, 0.01721053f, -0.04278941f, 0.00825799f, -0.03655604f, -0.01025995f, 0.04196893f, 
    0.04962492f, -0.03735748f, 0.03117928f, -0.05926112f, 0.04061326f, 0.01075193f, -0.06132014f, 0.02529493f, 
    -0.04044516f, 0.02466573f, 0.04783003f, -0.03833438f, -0.04544659f, -0.05868619f, -0.01024265f, -0.06117742f, 
    0.03908844f, -0.00485547f, -0.05035245f, 0.00900366f, -0.02566419f, 0.00526828f, 0.02960354f, 0.03195391f, 
    0.01672528f, -0.02589022f, 0.04139557f, 0.03958469f, -0.04475267f, -0.02251932f, -0.01259430f, -0.01686787f, 
    -0.00884719f, 0.04382727f, -0.03819003f, -0.05523522f, -0.02182147f, 0.04624186f, -0.00206204f, -0.03952659f, 
    -0.02883968f, -0.02653469f, -0.02401182f, -0.06018903f, -0.04607423f, -0.02447257f, -0.04969045f, 0.04256267f, 
    0.04871823f, -0.05616645f, -0.00847063f, 0.04047608f, -0.00539285f, 0.04771775f, 0.00940793f, -0.02171310f, 
    -0.01111253f, -0.03482540f, 0.00265407f, 0.00718246f, -0.04996857f, -0.05778355f, 0.03062837f, -0.05280629f, 
    0.02901269f, 0.04059637f, -0.02078488f, 0.04821925f, -0.05955775f, -0.03952388f, -0.04046219f, -0.01652157f, 
    -0.04803823f, -0.04877031f, 0.04969114f, 0.03961852f, -0.02685689f, -0.02602542f, -0.05859182f, -0.00809191f, 
    -0.02002675f, 0.03194361f, -0.03248416f, -0.01213677f, -0.00865935f, -0.00420341f, -0.06460588f, 0.04104887f, 
    -0.02221869f, 0.01925972f, -0.01279166f, -0.06036298f, -0.03889668f, -0.02404197f, -0.01592911f, 0.03531906f, 
    -0.04808916f, -0.00479799f, 0.03855047f, 0.01846882f, 0.01581343f, 0.00083088f, 0.01859106f, 0.02499502f, 
    -0.00632903f, -0.00370838f, -0.01275663f, 0.02357110f, 0.01006430f, 0.00137071f, 0.01562077f, 0.02141827f, 
    0.04611529f, 0.03261446f, -0.05783226f, -0.00079677f, 0.01768671f, 0.03680936f, 0.04499521f, -0.00082420f, 
    0.00404712f, 0.02065961f, 0.04485625f, -0.01553169f, 0.02285733f, 0.03023508f, -0.03000724f, -0.02599983f, 
    0.04246337f, 0.01931677f, -0.02060860f, 0.00605281f, 0.03379259f, -0.02408109f, 0.01692288f, -0.05540407f, 
    -0.02375045f, -0.01877837f, 0.03520476f, -0.06269220f, -0.00076856f, 0.01573990f, 0.04179293f, -0.03156662f, 
    -0.00984318f, -0.05807756f, 0.04274906f, -0.05866430f, 0.01604115f, -0.02980592f, -0.04214522f, 0.01911924f, 
    0.03141167f, 0.03905385f, 0.05465737f, -0.02224976f, 0.03606479f, -0.03585736f, -0.02085529f, -0.05386537f, 
    0.03455595f, -0.01567921f, -0.02900604f, -0.00011048f, -0.01806742f, -0.02950100f, 0.03047881f, 0.01103226f, 
    -0.00296795f, 0.00976184f, -0.02117999f, 0.01877486f, 0.00305170f, -0.01767881f, 0.00246788f, 0.02270836f, 
    -0.00824090f, 0.02576039f, -0.04922924f, -0.03899829f, -0.05802951f, -0.03977725f, -0.02461854f, -0.03873606f, 
    -0.05425927f, -0.05812171f, 0.01000120f, 0.02513853f, 0.04069156f, 0.03251005f, 0.01812965f, 0.01444016f, 
    -0.06525333f, 0.28310573f, 0.24360058f, -0.08025316f, -0.24099706f, -0.09676056f, -0.00473230f, -0.15799983f, 
    0.12564209f, 0.10413045f, 0.05240707f, 0.02269388f, 0.09512553f, 0.10239822f, 0.12011149f, -0.00200512f, 
    0.04769414f, 0.00821948f, -0.17639300f, 0.12218419f, 0.43041253f, -0.09489198f, -0.64158338f, -0.13461918f, 
    0.61933726f, 0.01640790f, 0.27843103f, 0.10567224f, 0.08681127f, 0.09092861f, -0.19339709f, -0.01494725f, 
    0.03024503f, 0.21329454f, 0.11083760f, -0.08757617f, 0.19245464f, 0.15857351f, -0.03702960f, 0.02956153f, 
    -0.02220334f, 0.35604435f, 0.19768350f, 0.00471990f, -0.12024466f, -0.14051966f, -0.19951411f, 0.13295828f, 
    0.13811769f, -0.15601863f, 0.18032941f, 0.02189689f, 0.08816650f, -0.14437595f, 0.05318904f, 0.05230841f, 
    0.00403237f, 0.08923601f, 0.03990674f, -0.14961885f, -0.26299736f, 0.03414353f, -0.25545222f, -0.11454038f, 
    0.37852883f, -0.03910182f, 0.11244028f, 0.27026227f, -0.15782115f, -0.02575820f, 0.16654433f, 0.14523621f, 
    0.09102397f, 0.16634712f, 0.00007090f, 0.05222126f, 0.28879490f, 0.02322465f, 0.13322678f, -0.05254774f, 
    0.00585054f, 0.07466892f, 0.33315447f, 0.24275437f, 0.38843012f, -0.15880689f, 0.08328225f, -0.02441249f, 
    0.13788427f, -0.12458503f, 0.01437011f, -0.11582284f, -0.05285697f, -0.10944872f, -0.03631396f, 0.19220017f, 
    0.09171276f, 0.33339602f, 0.26656139f, 0.11246736f, -0.47798634f, 0.08592705f, 0.26190412f, -0.05491673f, 
    -0.33502987f, 0.07145899f, -0.08774023f, -0.01753689f, -0.10396366f, 0.00005091f, 0.01081541f, -0.04743391f, 
    0.05124763f, 0.17723989f, 0.05560391f, -0.02644362f, 0.04807933f, -0.15134595f, -0.12439483f, -0.03179070f, 
    -0.24591026f, -0.13669430f, 0.54976445f, 0.12688802f, 0.19074692f, 0.06994749f, -0.03700591f, 0.10725401f, 
    -0.17401356f, -0.09836788f, 0.08227391f, -0.08217678f, 0.00715368f, 0.03613024f, 0.10510430f, 0.02633297f, 
    0.15852292f, 0.03502920f, -0.25908157f, 0.12107630f, 0.22673644f, -0.10323188f, -0.05866371f, -0.14628899f, 
    0.19429062f, 0.14077672f, 0.11621009f, 0.02840465f, -0.05188534f, 0.14798443f, 0.22556125f, 0.14411458f, 
    -0.16581121f, -0.23047023f, -0.00438785f, -0.06864867f, -0.18882993f, 0.15283430f, 0.14521348f, -0.00844461f, 
    -0.62226546f, -0.04611540f, 0.09196179f, 0.31299558f, 0.32034963f, 0.09054004f, -0.06806289f, 0.35914004f, 
    -0.23331471f, -0.00682516f, 0.10471505f, -0.00136076f, 0.14048658f, 0.21887685f, 0.16938157f, 0.02158596f, 
    0.02698254f, 0.06251797f, -0.32853329f, -0.01283090f, -0.34512183f, 0.02511047f, -0.10743597f, 0.27237776f, 
    0.33403966f, 0.05206090f, -0.07491306f, 0.17779200f, -0.04496729f, 0.04586241f, 0.09016401f, 0.01401080f, 
    -0.01554891f, -0.05258211f, 0.02525470f, -0.00902207f, -0.15241517f, -0.01349114f, -0.10018269f, -0.15254581f, 
    0.08696317f, -0.16574219f, -0.05365049f, -0.24719335f, 0.21322410f, -0.00609722f, 0.24416673f, 0.04491840f, 
    -0.01889859f, 0.07912672f, 0.01009644f, -0.03202020f, 0.00377326f, -0.07567666f, 0.00952346f, -0.01239801f, 
    0.14949134f, 0.13279811f, 0.03429439f, 0.20955798f, -0.08482588f, 0.31095001f, 0.07764000f, -0.14068100f, 
    -0.45996216f, 0.06622365f, 0.03054691f, 0.07524011f, 0.30201176f, 0.18045302f, -0.07411256f, 0.02102051f, 
    0.27755836f, -0.03852877f, 0.12863624f, -0.19728851f, -0.03889305f, -0.29576796f, 0.15601794f, 0.07243912f, 
    0.32504651f, -0.17224860f, 0.17123656f, -0.05216609f, 0.41790539f, 0.05303378f, 0.21463189f, -0.10026038f, 
    -0.03713768f, -0.01482198f, 0.21368779f, -0.06318873f, -0.02114748f, -0.03480039f, -0.04242353f, -0.02536636f, 
    0.00763816f, 0.04583293f, 0.01613667f, -0.05329971f, 0.09354943f, 0.54597616f, -0.08859845f, -0.78999579f, 
    0.09949592f, 0.09112199f, -0.05237395f, 0.03808694f, -0.04680722f, 0.08639043f, 0.07334959f, 0.13519992f, 
    -0.05018206f, 0.11241004f, -0.09153134f, -0.16542239f, 0.09750769f, -0.15332229f, 0.08256872f, 0.04444343f, 
    -0.12303782f, -0.03167320f, 0.13674261f, 0.00130553f, -0.04751851f, -0.08201076f, 0.05301003f, -0.15206513f, 
    0.08964701f, -0.21040985f, -0.01661916f, -0.01380640f, -0.02552966f, -0.02957543f, 0.07522900f, -0.02745288f, 
    0.02843404f, -0.10823584f, -0.37990004f, -0.37733650f, 0.33622858f, -0.12751678f, -0.15577056f, -0.30898622f, 
    0.19500525f, 0.05948342f, 0.06312038f, -0.04215435f, 0.00351603f, -0.07901583f, 0.02974460f, 0.01904250f, 
    -0.17368400f, -0.04074308f, 0.08700121f, -0.01984061f, -0.12663037f, 0.20809929f, 0.14050600f, -0.06899798f, 
    0.20491010f, 0.03599890f, -0.04337442f, -0.13464732f, 0.14222246f, -0.04495156f, 0.10123538f, 0.00102156f, 
    -0.06977998f, -0.05013869f, 0.01723919f, 0.16985360f, 0.09906406f, -0.18068132f, -0.15877870f, 0.19225034f, 
    0.09135783f, 0.07347766f, 0.01073160f, 0.09417985f, -0.45065877f, -0.21736856f, 0.75189579f, 0.17615993f, 
    -0.21384443f, 0.01204146f, -0.16761732f, -0.18403172f, 0.14953077f, -0.18360557f, 0.18473274f, 0.00021286f, 
    -0.05714636f, -0.11952124f, 0.00054164f, 0.15228663f, 0.16358666f, -0.06599415f, 0.24404839f, 0.24518868f, 
    0.07740811f, 0.02265268f, -0.43552810f, -0.21258211f, 0.00202135f, 0.18184815f, 0.10066775f, 0.05725829f, 
    -0.03979726f, 0.16295245f, 0.06402641f, 0.07937860f, -0.01363874f, 0.02096137f, 0.09867118f, 0.11046600f, 
    -0.04118704f, 0.15278101f, 0.04363188f, 0.21848401f, 0.04148736f, 0.01431009f, 0.34433910f, -0.00605007f, 
    -0.09746435f, -0.08268571f, 0.05607805f, 0.06506406f, 0.04687802f, 0.08759245f, -0.02372995f, -0.04539385f, 
    0.16417366f, 0.02201943f, 0.02636284f, 0.24657179f, 0.11500505f, -0.08387604f, 0.04273908f, 0.11804119f, 
    -0.06892470f, -0.11643516f, -0.26660407f, -0.00323352f, -0.07981747f, 0.28992704f, -0.06625570f, -0.11872786f, 
    0.08693960f, 0.12245724f, -0.10646649f, -0.00127434f, 0.04185343f, -0.06739979f, -0.01355376f, 0.01249866f, 
    0.10979726f, -0.08703391f, 0.04393605f, 0.14370844f, 0.32450351f, 0.00817433f, -0.16988796f, -0.16730300f, 
    -0.00050666f, -0.05427776f, -0.07910644f, -0.00906423f, -0.07225294f, -0.03364593f, 0.04930274f, 0.14342365f, 
    -0.05875190f, -0.01591273f, -0.04993502f, 0.13955179f, 0.02310697f, 0.03750535f, -0.03380153f, 0.01437968f, 
    0.51754695f, 0.28183502f, -0.13784903f, -0.33428085f, 0.07228296f, 0.08909962f, 0.00718596f, -0.11047822f, 
    -0.21564940f, -0.01494082f, -0.01295148f, -0.12870407f, 0.00081028f, 0.08020986f, -0.08150452f, 0.26286250f, 
    0.01904562f, 0.03527488f, 0.07609133f, 0.00239382f, -0.19552334f, -0.09452806f, 0.18930492f, 0.52832407f, 
    0.10333181f, 0.07870229f, 0.03907230f, 0.08788221f, 0.10248499f, 0.04356954f, -0.05896844f, 0.02934122f, 
    0.02196100f, -0.02222042f, -0.14612667f, -0.07788359f, 0.01119682f, -0.02700031f, -0.09333652f, -0.04448137f, 
    0.62464660f, -0.07586683f, 0.29504463f, -0.43259203f, -0.17581850f, -0.06115480f, 0.17413767f, 0.00648117f, 
    -0.06671473f, -0.22852400f, 0.10109631f, 0.08028841f, 0.07530849f, 0.04469021f, -0.00161612f, 0.20888835f, 
    -0.09741043f, -0.01785518f, 0.12870663f, -0.08441408f, 0.33168706f, 0.12009999f, 0.19391717f, -0.19600102f, 
    -0.22907315f, -0.14415826f, -0.05807851f, -0.02661371f, 0.07777895f, -0.10401001f, 0.10070028f, 0.11979518f, 
    -0.13067588f, 0.05019077f, 0.07095775f, -0.06764948f, -0.14312834f, 0.17330566f, -0.02346409f, -0.12341309f, 
    -0.26154274f, -0.08260796f, 0.28816789f, 0.08625587f, -0.03940540f, -0.07732742f, -0.08965493f, 0.06441192f, 
    0.15735845f, 0.03181003f, 0.12604143f, -0.05455406f, -0.11362325f, -0.10094829f, -0.00921259f, -0.11016170f, 
    0.13901164f, 0.00587597f, 0.04324389f, 0.03324931f, -0.05250962f, 0.00556569f, -0.29585400f, -0.02992491f, 
    -0.05397833f, -0.04014358f, -0.04984701f, 0.00034454f, -0.23664087f, -0.00190238f, 0.08271001f, -0.00374057f, 
    0.07853531f, -0.02245712f, 0.01324710f, 0.13361648f, 0.13952243f, -0.08018851f, -0.01549157f, 0.07298317f, 
    -0.33649912f, 0.01506257f, -0.35480574f, 0.38687760f, -0.06314085f, 0.01984669f, 0.12770087f, 0.01589965f, 
    -0.03291589f, 0.07751435f, 0.06745727f, -0.04945112f, -0.07569496f, -0.04461933f, 0.05291189f, -0.03830630f, 
    -0.00136439f, -0.00930315f, -0.14892240f, 0.13908121f, 0.15154588f, -0.22966975f, 0.12518226f, 0.47080994f, 
    0.09871166f, -0.12335239f, 0.02723157f, -0.18461408f, 0.06986453f, -0.01753182f, 0.10152360f, 0.03372397f, 
    0.09065774f, -0.00677797f, 0.04342426f, -0.05612335f, -0.27482516f, -0.04243842f, -0.19235182f, -0.20239709f, 
    0.01162927f, 0.00362856f, -0.29814935f, -0.31901395f, 0.02469385f, -0.00383914f, 0.01315326f, -0.03464872f, 
    -0.07476954f, -0.00409021f, 0.07713010f, -0.02151530f, -0.03583484f, 0.07140607f, 0.00544152f, -0.02919281f, 
    -0.06691412f, -0.12429132f, -0.01138673f, 0.02269056f, -0.19135125f, -0.07610348f, 0.48778725f, 0.61832094f, 
    -0.20027298f, -0.06203149f, 0.06369473f, -0.10190787f, 0.14476107f, 0.15643117f, 0.11319370f, -0.04207800f, 
    0.00965640f, -0.16627988f, -0.10514580f, 0.05501708f, 0.14354420f, 0.10362059f, 0.00149185f, -0.04365252f, 
    0.30114716f, 0.21636948f, 0.07804430f, 0.14311507f, 0.05486649f, -0.00328153f, 0.04618232f, 0.01696540f, 
    -0.02130250f, 0.08218359f, 0.19898185f, 0.12940809f, 0.11304965f, 0.10230460f, -0.05180821f, 0.20124611f, 
    0.01080013f, 0.03019067f, -0.06524328f, -0.14518641f, -0.35144219f, -0.53259355f, -0.80102724f, -0.47915938f, 
    -0.04308603f, -0.05930195f, 0.03403091f, -0.03212981f, 0.06879277f, -0.10329372f, -0.23138434f, -0.00947807f, 
    -0.01809027f, -0.00235273f, -0.08838888f, -0.07862095f, -0.09346288f, 0.02999673f, 0.17244652f, 0.14843713f, 
    0.41571325f, 0.18348059f, 0.15044864f, 0.17378533f, 0.09791297f, -0.04635272f, -0.05880883f, -0.02577155f, 
    0.06086963f, -0.04923824f, 0.06172971f, 0.14357254f, 0.07532003f, 0.04903589f, 0.09013562f, -0.12666337f, 
    -0.04926164f, 0.14363705f, -0.00960828f, 0.26402891f, -0.23585990f, 0.02823973f, -0.48358288f, 0.23209006f, 
    -0.14042245f, 0.04729969f, 0.32029209f, 0.15199094f, 0.14337613f, -0.13651977f, -0.14193390f, 0.11295265f, 
    0.13330826f, 0.09111976f, -0.03279193f, 0.00873489f, 0.03001732f, 0.37201393f, 0.19557482f, 0.03471938f, 
    0.34000659f, 0.21490376f, -0.06687795f, 0.13152641f, 0.03315310f, -0.07574353f, -0.27113634f, -0.25262955f, 
    -0.02044318f, -0.21321498f, -0.05448110f, -0.04081298f, 0.04190269f, 0.01785010f, 0.01450997f, 0.02399516f, 
    -0.17514604f, -0.04873934f, 0.10343739f, 0.02850849f, 0.29766288f, 0.21594636f, 0.13414885f, 0.17256272f, 
    0.00102031f, -0.04118444f, 0.02032757f, 0.02911304f, -0.02523046f, -0.01575385f, 0.14848813f, 0.14943723f, 
    -0.07195397f, -0.03020157f, -0.06564894f, -0.04942134f, -0.09856866f, -0.01980837f, -0.02277525f, -0.11670092f, 
    0.57224953f, 0.28420866f, 0.32750461f, 0.17567068f, 0.20612186f, -0.00555496f, -0.17992474f, 0.15968470f, 
    -0.06079448f, 0.06560767f, 0.03988868f, 0.07848460f, 0.15664564f, 0.11975131f, 0.15607080f, 0.24648911f, 
    0.01521263f, 0.01201600f, 0.18189013f, 0.01925960f, -0.62011713f, -0.38056213f, -0.05003100f, 0.00177676f, 
    -0.11131550f, 0.02164813f, 0.05831762f, -0.14693233f, -0.13662964f, 0.09165666f, 0.03947517f, -0.15079378f, 
    0.05127539f, 0.08326513f, 0.01873835f, 0.06475492f, 0.06236497f, -0.07130705f, -0.27967685f, -0.01909340f, 
    0.04487065f, 0.20232224f, 0.03991870f, 0.30484033f, 0.21677038f, 0.21276179f, 0.13313989f, 0.19233011f, 
    0.16279848f, -0.00683061f, 0.13674627f, 0.22224554f, 0.21861047f, 0.06484822f, 0.00853335f, 0.11941904f, 
    0.03504243f, 0.06349418f, -0.14270388f, -0.09816915f, -0.12787494f, -0.01673528f, -0.23896040f, 0.01055701f, 
    -0.02958790f, -0.11302435f, 0.03286713f, 0.00222911f, -0.02052319f, 0.05495889f, -0.23120525f, -0.07337985f, 
    0.14722620f, 0.01293121f, -0.13158892f, 0.06080715f, -0.00012763f, -0.00614953f, -0.14646176f, -0.04285694f, 
    -0.24154624f, -0.18466346f, 0.06314558f, 0.25541189f, 0.18517621f, -0.00768970f, 0.19767158f, 0.08483762f, 
    -0.07256754f, -0.08176186f, -0.06106211f, -0.04276864f, -0.11416516f, -0.19551058f, 0.01529027f, 0.01460863f, 
    -0.07813092f, 0.05594426f, 0.18418176f, -0.08440859f, 0.17830506f, 0.21549067f, 0.02326451f, 0.07705006f, 
    -0.12408159f, 0.06229520f, 0.03910937f, -0.03578282f, 0.03086418f, 0.03260882f, 0.05830059f, -0.19685605f, 
    -0.13930814f, -0.03890193f, -0.05064754f, -0.12216162f, -0.02156527f, -0.03807777f, -0.07181805f, -0.05857633f, 
    -0.34323624f, -0.37539536f, 0.34581161f, 0.16350476f, 0.36628070f, -0.08483275f, 0.03840980f, -0.09287637f, 
    0.01647448f, 0.00770405f, -0.12582904f, -0.12811582f, 0.01206858f, 0.00484912f, -0.00412552f, -0.02694119f, 
    -0.05286279f, -0.05580173f, 0.27243739f, 0.00199672f, 0.18246388f, -0.02825010f, -0.22944039f, -0.20811094f, 
    -0.17372975f, 0.02596261f, -0.14843008f, -0.00681239f, -0.07342792f, -0.02185732f, -0.06642879f, -0.14609253f, 
    -0.05513836f, 0.11137597f, -0.00159518f, -0.02119814f, -0.02254725f, 0.02704926f, -0.05640656f, -0.07293262f, 
    0.25367501f, 0.10601133f, 0.14005528f, 0.05138310f, 0.05307208f, 0.03560384f, 0.03931587f, -0.03283694f, 
    0.02641051f, 0.00360685f, 0.00661275f, 0.05908035f, -0.01143799f, -0.00954822f, 0.02085160f, -0.10062079f, 
    -0.04482877f, -0.01765329f, -0.05189588f, -0.09802493f, 0.11169753f, -0.17226563f, 0.17836824f, -0.09002983f, 
    -0.18502644f, -0.03805570f, -0.01391459f, -0.08914141f, -0.04942973f, 0.09804731f, -0.13420293f, -0.05048324f, 
    -0.03536979f, -0.14449792f, -0.06181005f, -0.06354417f, -0.05592785f, -0.13556428f, -0.19467597f, -0.00930975f, 
    0.13344197f, 0.09230506f, -0.09275775f, -0.07803056f, 0.11833875f, -0.00651719f, 0.06146854f, 0.01917651f, 
    0.02169855f, -0.04369858f, -0.01198366f, 0.04633033f, 0.06369490f, -0.11232690f, -0.07918804f, 0.00954079f, 
    0.24923885f, 0.13456699f, 0.06794213f, 0.07622010f, -0.29730904f, -0.30048349f, 0.53224415f, 0.28839442f, 
    0.02814804f, 0.02647029f, -0.06761932f, -0.02398067f, 0.09054557f, -0.05837473f, 0.08639561f, 0.05844975f, 
    -0.01250702f, -0.09869820f, -0.11141452f, 0.04276884f, 0.05307668f, -0.01722398f, 0.08273041f, 0.26207918f, 
    0.11326205f, 0.01066320f, 0.06906869f, -0.27754125f, -0.15203376f, 0.03390476f, 0.07989396f, 0.11647087f, 
    0.04992861f, 0.03333947f, 0.14230514f, 0.04897252f, 0.06445986f, 0.09423735f, 0.07075276f, -0.10330856f, 
    0.08064301f, 0.10959458f, 0.03973031f, -0.01680308f, -0.18297224f, 0.31460142f, 0.48638320f, 0.21384196f, 
    0.26521301f, 0.10979798f, 0.08453973f, -0.00471329f, 0.14916436f, 0.26221088f, 0.13616039f, 0.05315740f, 
    0.04670256f, 0.12248977f, 0.00477471f, 0.19379671f, 0.03214177f, -0.15122858f, -0.00626251f, 0.02292681f, 
    -0.36081979f, -0.00799590f, -0.17020805f, -0.01630338f, -0.37518311f, 0.07793649f, 0.06150325f, 0.06471541f, 
    -0.10105494f, -0.04426762f, -0.05757495f, -0.04444177f, 0.05377343f, 0.04763772f, 0.01028105f, 0.08993960f, 
    0.03945227f, 0.04514096f, -0.07770909f, 0.08679992f, 0.30930099f, 0.13841595f, 0.10349612f, -0.03746270f, 
    -0.09686434f, -0.00340796f, -0.06516504f, 0.07271597f, 0.00410127f, 0.02156942f, -0.01993915f, -0.00505560f, 
    -0.12609810f, 0.00245844f, -0.10152992f, -0.05724572f, 0.01289228f, -0.00046630f, -0.01156075f, -0.03799606f, 
    0.30672172f, 0.40659332f, -0.37302762f, -0.25172755f, -0.03653520f, 0.17115459f, 0.00910653f, 0.13829447f, 
    0.16044222f, 0.10180052f, 0.01810911f, 0.02679988f, 0.08055994f, 0.00815280f, 0.07650959f, 0.11793527f, 
    -0.14685112f, -0.00104182f, 0.09840921f, 0.25446799f, -0.45191160f, 0.03174301f, -0.07173599f, 0.21113683f, 
    0.16523568f, -0.05698235f, 0.01300945f, -0.05558190f, 0.04836687f, -0.04104695f, -0.05163198f, 0.06530781f, 
    0.07981449f, 0.01586454f, -0.05023441f, -0.08049606f, -0.05226463f, -0.09427999f, -0.00791688f, -0.08113579f, 
    0.28520325f, 0.25171137f, 0.32725057f, 0.28481206f, -0.06133625f, 0.30939010f, -0.03174777f, 0.03781046f, 
    0.34596375f, 0.00181380f, 0.01694201f, 0.20398039f, 0.13993336f, 0.10125385f, 0.12349969f, -0.13844511f, 
    0.09718107f, 0.02054066f, 0.14417233f, 0.01223046f, 0.15538304f, 0.16054167f, 0.37465745f, 0.16962886f, 
    -0.06265128f, -0.10592601f, -0.08307220f, -0.03639347f, 0.07763781f, -0.14146608f, 0.02240079f, -0.11225273f, 
    -0.05468983f, 0.02703712f, 0.09928539f, -0.04494273f, -0.10749294f, -0.11558012f, 0.03585045f, -0.14155243f, 
    -0.31539536f, 0.06913240f, -0.22166818f, 0.24607836f, 0.06138773f, 0.04239092f, -0.07766137f, -0.18715781f, 
    0.08176335f, 0.03671660f, -0.11004651f, -0.08390867f, -0.04877150f, 0.06152633f, 0.04148629f, -0.07040322f, 
    0.01706603f, -0.13747038f, 0.02617408f, 0.08392639f, 0.31425810f, 0.01591213f, -0.00151559f, -0.10830926f, 
    -0.00546651f, -0.04607886f, -0.11238313f, 0.02774464f, -0.06873232f, 0.03163570f, 0.08323592f, -0.14068308f, 
    -0.01334745f, -0.07845063f, -0.01467038f, 0.00819005f, 0.04963555f, -0.09324636f, -0.03621772f, -0.16222507f, 
    -0.52791363f, -0.06674984f, -0.20283598f, 0.11502665f, 0.26691493f, -0.26550707f, 0.03701552f, 0.01134579f, 
    -0.03808312f, 0.06439146f, -0.14810389f, -0.01648674f, -0.03574320f, 0.04192046f, -0.08886412f, 0.03293895f, 
    -0.00988924f, -0.05640416f, 0.10358278f, 0.01111242f, 0.50828224f, -0.07658197f, 0.34473667f, 0.14127453f, 
    0.14905252f, -0.09975563f, -0.01148713f, 0.11947957f, -0.12597951f, 0.08683249f, -0.24170132f, 0.09170246f, 
    0.15081127f, 0.12179255f, -0.12030392f, -0.04213049f, -0.16852435f, -0.06485745f, -0.15560095f, -0.12623864f, 
    0.16206849f, 0.02481355f, -0.02404006f, -0.08299436f, 0.13892730f, -0.01547449f, 0.02030345f, -0.00937036f, 
    0.07329722f, 0.02655115f, 0.00740709f, 0.03796603f, 0.04598272f, 0.02078747f, -0.00762979f, -0.20370080f, 
    -0.17211108f, 0.04456938f, 0.02190597f, -0.00611655f, -0.00150773f, 0.10908654f, 0.07321276f, 0.37494105f, 
    -0.01462262f, -0.17065176f, -0.08665100f, -0.15496279f, 0.05315116f, 0.01609459f, -0.11167961f, 0.08493276f, 
    0.03762008f, -0.07520322f, -0.06284104f, -0.07470116f, -0.02257999f, -0.06589515f, -0.00177109f, 0.00085599f, 
    -0.27629596f, -0.19673508f, -0.11090109f, -0.14577010f, -0.05011310f, -0.00064701f, 0.09568600f, -0.01127068f, 
    -0.05861937f, -0.24163027f, 0.02615354f, -0.01558935f, 0.17481618f, -0.14920555f, -0.08396504f, -0.06383641f, 
    0.09238289f, -0.00265225f, -0.03245772f, 0.04779224f, 0.43168727f, 0.30465183f, 0.56911588f, 0.45280778f, 
    0.02868466f, 0.25423190f, 0.10656375f, 0.01132958f, 0.05170493f, 0.05877087f, 0.21827389f, 0.01193819f, 
    0.05100845f, 0.07653953f, 0.27391440f, 0.08968326f, 0.07885921f, 0.06382672f, 0.15403554f, 0.15652235f, 
    -0.45370680f, -0.32729512f, 0.07277891f, -0.19355132f, -0.20095283f, 0.06000006f, 0.06262522f, -0.02386964f, 
    -0.15495752f, -0.04137821f, 0.11579701f, 0.03242314f, -0.07465380f, 0.07157493f, 0.01342011f, -0.14017893f, 
    -0.10129800f, -0.04623981f, -0.06648637f, 0.08751140f, 0.33021995f, 0.36027208f, 0.16216493f, 0.22135198f, 
    -0.13392104f, 0.12257373f, -0.11505715f, 0.01883725f, -0.08971043f, 0.04951298f, -0.09179639f, 0.00171337f, 
    -0.00810357f, 0.01069895f, -0.05419696f, 0.04944649f, -0.08250485f, -0.04659909f, -0.09040937f, -0.05701447f, 
    -0.07572295f, 0.13859913f, 0.02860897f, 0.03630872f, 0.07132487f, -0.06190498f, -0.06806446f, 0.11275375f, 
    -0.00563518f, 0.18204430f, 0.03359545f, 0.04597428f, -0.05705574f, -0.00033516f, 0.01220785f, -0.06793043f, 
    0.20771877f, 0.10488141f, 0.05352355f, 0.04954204f, -0.00007973f, -0.31783250f, -0.42306191f, -0.35327637f, 
    -0.10734888f, -0.01351685f, -0.07164260f, 0.00171292f, -0.04514354f, -0.09765571f, -0.03618704f, 0.14968310f, 
    -0.03243202f, -0.11935266f, 0.00895340f, 0.06156770f, 0.11494169f, 0.02210453f, 0.06626501f, 0.00665810f, 
    -0.37876099f, -0.29021916f, -0.23550518f, -0.25280508f, -0.07685102f, -0.10362435f, -0.01739645f, -0.02768904f, 
    -0.05749775f, 0.10019064f, -0.07576905f, 0.09057203f, 0.01463895f, 0.00499932f, -0.13797291f, 0.05728778f, 
    -0.06993982f, -0.02812831f, 0.06686179f, 0.09286631f, 0.04401832f, 0.55655390f, 0.30232760f, 0.34808010f, 
    0.33115938f, 0.07825615f, -0.00157916f, 0.12434672f, 0.16815042f, 0.18200664f, -0.08233422f, -0.03409993f, 
    0.01510609f, 0.17926848f, -0.01279536f, 0.09112702f, -0.22115339f, -0.07881296f, -0.04158959f, -0.02069903f, 
    0.20653848f, -0.32874939f, -0.16973031f, -0.23573011f, -0.13656382f, 0.00559376f, -0.09372513f, -0.01195892f, 
    -0.21709697f, -0.17795748f, -0.00151177f, -0.03578994f, 0.05715106f, 0.08818588f, 0.01482199f, -0.12561685f, 
    0.07693449f, -0.05838123f, -0.00254817f, 0.03490407f, 0.29714099f, -0.16578564f, -0.20426476f, 0.01657318f, 
    -0.19082485f, 0.03486675f, -0.05290890f, -0.14085354f, -0.01027972f, 0.04412273f, 0.04271158f, 0.16012558f, 
    0.04066701f, -0.01908091f, 0.10083029f, -0.10694311f, 0.04503579f, -0.01773800f, 0.12898572f, -0.15444757f, 
    -0.20139189f, 0.29207787f, 0.28478414f, -0.06772209f, 0.25972468f, 0.04104785f, 0.01171005f, -0.04163428f, 
    0.03867723f, 0.19819133f, 0.06660139f, 0.04512518f, -0.00877226f, -0.01641018f, 0.00974128f, 0.01620986f, 
    0.12428690f, -0.15668963f, -0.19455358f, 0.03633750f, -0.08587908f, -0.28439072f, -0.32114431f, 0.00704269f, 
    -0.19032772f, 0.10775632f, -0.03338993f, 0.13495980f, -0.09498894f, -0.21466218f, 0.10797102f, 0.02693228f, 
    0.08870880f, -0.05530256f, 0.11489680f, -0.03071347f, 0.06777196f, -0.02451875f, -0.02640601f, 0.01456344f, 
    -0.00226936f, 0.56590086f, 0.09468406f, 0.21401140f, 0.20495911f, -0.09231661f, 0.09126969f, 0.11257317f, 
    0.18580014f, 0.17533876f, 0.05211712f, 0.00550854f, 0.07803705f, 0.03811399f, 0.05470831f, -0.05386889f, 
    -0.12381513f, 0.00742695f, -0.16832006f, -0.06519742f, -0.34311906f, 0.23663649f, -0.01278408f, 0.18490075f, 
    0.41855121f, 0.09148008f, 0.10481355f, 0.12535448f, -0.06108811f, -0.05293307f, -0.10669406f, 0.09582422f, 
    0.15075319f, 0.09604900f, 0.03477395f, 0.04219726f, -0.03628197f, 0.06774236f, -0.06082639f, -0.30857381f, 
    -0.28780428f, -0.34101868f, -0.44492680f, -0.32313672f, -0.13492131f, -0.03996874f, 0.03449500f, 0.02444066f, 
    -0.11490389f, -0.09756041f, 0.12405671f, 0.08582737f, 0.03677293f, -0.01044196f, 0.10733977f, -0.08013655f, 
    -0.00254925f, 0.11090405f, 0.03755575f, -0.10580306f, 0.23948863f, 0.39029971f, 0.23557834f, 0.28012401f, 
    0.25158662f, -0.02317319f, 0.09719662f, 0.06327217f, 0.12218417f, 0.12608598f, -0.02722833f, 0.09096545f, 
    0.09117904f, 0.01973578f, -0.08955609f, 0.03229334f, -0.00706367f, -0.00615353f, -0.05055358f, -0.11733792f, 
    0.30141333f, -0.11160891f, -0.08479438f, 0.02975905f, 0.11204795f, -0.06793772f, 0.06723830f, -0.18452010f, 
    -0.07617821f, 0.05572263f, 0.10929307f, -0.16509770f, -0.18869112f, 0.17595068f, 0.07030188f, -0.07380164f, 
    -0.14512384f, -0.09655913f, 0.17888579f, 0.14090468f, -0.69660747f, -0.04852146f, 0.13363990f, -0.15715456f, 
    0.06491719f, -0.12663664f, -0.11228675f, 0.01866471f, 0.03009106f, 0.00001974f, -0.11250456f, 0.10808276f, 
    0.01555334f, 0.04768045f, -0.15787774f, -0.22302759f, -0.21699713f, 0.14964953f, -0.09224375f, -0.08542309f, 
    0.23061061f, 0.32492715f, -0.33431661f, 0.06259628f, 0.16044737f, 0.16623323f, -0.04929254f, 0.15746309f, 
    0.01568167f, 0.04966991f, 0.10878340f, 0.00818595f, 0.14433335f, -0.13432854f, -0.00336194f, 0.06980728f, 
    -0.04663110f, -0.03584362f, -0.19410242f, -0.00177994f, -0.20445758f, -0.04271254f, 0.26668510f, -0.01479529f, 
    0.22656251f, 0.01492225f, 0.06887682f, -0.13724528f, 0.08960931f, 0.01796819f, 0.20832978f, -0.01236818f, 
    0.17314936f, 0.13497414f, 0.08315766f, -0.22405106f, 0.02692266f, 0.11884490f, 0.03091893f, 0.04372185f, 
    0.06614023f, 0.24272741f, -0.09755770f, 0.12649295f, -0.00198727f, -0.01329815f, 0.27448446f, 0.19942079f, 
    0.04325143f, -0.10264253f, 0.04365188f, 0.03623091f, 0.17325807f, 0.10536175f, 0.03809935f, 0.01259848f, 
    -0.09438074f, 0.09524484f, -0.12945865f, -0.08864256f, -0.11089199f, -0.01502972f, -0.17720014f, -0.05374556f, 
    -0.08413786f, 0.10496232f, -0.05270771f, -0.16512848f, -0.13380212f, 0.04676841f, 0.12564479f, 0.00987072f, 
    -0.06108646f, -0.06069347f, 0.05332620f, -0.05003875f, 0.00043221f, 0.01941501f, -0.05154465f, 0.06491241f, 
    0.56733686f, 0.05864535f, -0.19132169f, -0.12256698f, 0.43415925f, 0.15560468f, 0.16433470f, 0.15102103f, 
    0.04520839f, 0.04387407f, 0.11861887f, -0.04497327f, -0.05132692f, -0.15305455f, 0.06061845f, -0.03703236f, 
    0.07164653f, 0.00190115f, 0.01416990f, 0.20028374f, -0.05787344f, 0.07272691f, 0.32515061f, -0.02452023f, 
    -0.04769357f, 0.01660571f, 0.08197756f, -0.11158957f, -0.13629849f, -0.09091926f, 0.03674737f, 0.15407315f, 
    0.14952584f, -0.07922175f, 0.09461541f, -0.04709581f, 0.08100901f, -0.06347218f, 0.42684186f, -0.02134503f, 
    0.39495710f, 0.16326928f, 0.31072134f, -0.46582344f, 0.12646136f, -0.06078921f, 0.21839552f, 0.02925151f, 
    0.07414661f, 0.07198276f, 0.11102913f, 0.06547087f, 0.03863490f, 0.03088715f, 0.23872513f, 0.01116491f, 
    -0.32978740f, -0.10977352f, 0.02717787f, -0.03103463f, -0.12178764f, 0.03885989f, 0.11295514f, -0.14400566f, 
    -0.00510019f, -0.02859741f, -0.00040637f, -0.05063665f, -0.08091548f, -0.03207059f, 0.19647552f, 0.00067042f, 
    -0.05405257f, -0.05760797f, 0.12591447f, 0.07156321f, -0.03828754f, -0.03543722f, -0.14741503f, 0.06006527f, 
    0.14968421f, 0.00301766f, 0.02640885f, 0.20788719f, -0.14369418f, 0.06052315f, 0.02713775f, 0.17417254f, 
    -0.00567371f, -0.13899815f, -0.03229786f, -0.03274535f, 0.00659204f, 0.13847990f, 0.06214964f, 0.00825719f, 
    -0.01526571f, -0.10364643f, 0.12118987f, 0.05051190f, 0.23010559f, 0.09277648f, 0.02665864f, -0.16528338f, 
    -0.02519932f, 0.01970870f, -0.13897583f, -0.16355054f, -0.16484013f, 0.04348476f, 0.10553110f, 0.10774514f, 
    -0.04851880f, 0.15656848f, 0.19478367f, -0.07977158f, -0.00912618f, 0.15421772f, -0.21002014f, 0.01691790f, 
    -0.25900459f, -0.20378640f, 0.13957392f, 0.38675842f, 0.00072548f, -0.09777969f, 0.22766815f, -0.03059854f, 
    0.03113450f, -0.04422792f, -0.08319843f, 0.13838211f, -0.00209024f, 0.16972062f, 0.11939819f, -0.05302190f, 
    0.09489439f, -0.03731846f, 0.14043944f, 0.10136110f, -0.00290306f, -0.39082390f, 0.18680348f, -0.19669519f, 
    -0.05639916f, -0.15215589f, -0.10149452f, -0.12962641f, 0.02263737f, 0.17405316f, 0.13617216f, 0.29956347f, 
    0.01745041f, -0.13107318f, 0.00971580f, -0.05034359f, -0.10690055f, 0.04483008f, -0.04022473f, 0.14730185f, 
    -0.07595851f, -0.17318752f, -0.30501914f, 0.12215649f, 0.15563871f, 0.02487827f, 0.07530063f, -0.09191187f, 
    -0.07422805f, 0.14454831f, -0.08627428f, -0.09657883f, -0.11104344f, -0.05141422f, -0.02583705f, 0.08335268f, 
    -0.16730656f, -0.16462502f, 0.07084280f, 0.15261063f, -0.27067536f, 0.07657724f, 0.31791079f, 0.11990771f, 
    -0.14749220f, -0.07008800f, -0.01286279f, 0.02320682f, 0.00789090f, -0.04705586f, 0.01731952f, 0.01077814f, 
    -0.01045495f, 0.00177649f, 0.03533084f, 0.05143088f, 0.02934015f, -0.09970516f, 0.24771766f, 0.13452116f, 
    0.04777460f, -0.28544426f, -0.07165013f, 0.37921482f, 0.03379988f, -0.15071687f, -0.05263257f, -0.04963452f, 
    -0.02322966f, -0.19023730f, -0.05875604f, -0.03847838f, -0.04566903f, 0.14770147f, 0.08999404f, -0.01755506f, 
    0.04458332f, -0.06247486f, 0.09732910f, -0.04375914f, 0.33109507f, 0.35629439f, 0.02001712f, -0.06013332f, 
    -0.18202029f, 0.16113010f, 0.03299172f, 0.15020059f, -0.10073090f, -0.06355836f, 0.05691322f, 0.03721718f, 
    -0.16355288f, -0.11228853f, 0.00442234f, 0.05563981f, -0.24496752f, -0.04045480f, -0.16076031f, -0.28210783f, 
    -0.26209611f, 0.02294426f, 0.42310509f, 0.21101651f, -0.09626808f, -0.07840937f, -0.04062827f, 0.06287290f, 
    -0.09827970f, -0.05427604f, -0.03759493f, 0.00567354f, 0.05836445f, 0.13681591f, 0.00851718f, -0.06101735f, 
    0.14951862f, 0.04787429f, -0.03973363f, -0.06751372f, 0.37436360f, 0.18453786f, 0.17378272f, 0.24440156f, 
    -0.07942580f, 0.03123532f, -0.02873577f, -0.11189120f, 0.05912196f, -0.01737779f, 0.00517863f, -0.01607536f, 
    0.00882909f, 0.07772995f, 0.15371351f, -0.08086664f, -0.22372985f, 0.12731445f, -0.26097804f, -0.07607452f, 
    -0.02338992f, 0.31172737f, -0.10010266f, -0.01827673f, -0.32445958f, 0.03517918f, 0.11013448f, 0.19918610f, 
    -0.30047300f, 0.10548747f, 0.00072020f, 0.02530830f, -0.01572499f, 0.06627905f, -0.09924170f, 0.00738191f, 
    -0.12121977f, -0.13400994f, -0.34617555f, -0.30023590f, 0.12175534f, -0.25451785f, 0.00835371f, 0.18270598f, 
    -0.07493597f, -0.15776591f, -0.07546607f, -0.14511213f, -0.03703436f, -0.10734970f, -0.05737300f, 0.09535809f, 
    0.07971897f, -0.07037838f, 0.07006836f, -0.14141615f, 0.11097027f, 0.01311581f, 0.12379349f, -0.01107731f, 
    -0.16965531f, -0.08313699f, -0.47749710f, 0.07995907f, 0.10214817f, -0.17722948f, -0.02050421f, 0.01816139f, 
    0.22150332f, 0.14567794f, -0.07665286f, 0.04890239f, 0.01719934f, -0.08793769f, 0.01777019f, -0.01355407f, 
    -0.11105584f, 0.05919509f, 0.14362925f, -0.04524394f, -0.12441151f, 0.28849214f, -0.06865968f, -0.15182483f, 
    -0.05631649f, 0.07018617f, 0.18884411f, 0.15169586f, 0.23809129f, 0.17345588f, 0.00402305f, 0.06960709f, 
    0.03926661f, 0.11894271f, 0.04028395f, -0.01846139f, 0.13652225f, -0.09623244f, 0.28602043f, 0.42009062f, 
    0.54734921f, 0.11945234f, -0.02061457f, 0.22453441f, 0.17533927f, 0.00476582f, -0.14313585f, -0.12262569f, 
    0.24886435f, 0.18742415f, -0.08578231f, 0.15437585f, 0.06174882f, -0.10945018f, -0.00012219f, -0.21351923f, 
    0.12816535f, 0.00921200f, 0.16138385f, 0.24120012f, 0.13241366f, -0.37350854f, -0.28550643f, -0.09060033f, 
    -0.25707361f, -0.02729462f, 0.07567216f, -0.13048433f, -0.10057154f, 0.07314465f, 0.01088283f, 0.17513737f, 
    0.08581732f, -0.02691360f, -0.20650716f, -0.10871296f, 0.26794627f, -0.01604290f, 0.19405794f, 0.16858646f, 
    0.20945506f, 0.46837533f, -0.19216609f, 0.14269507f, 0.31603232f, 0.29583424f, 0.03429377f, 0.05567178f, 
    0.14563446f, 0.11234931f, -0.08960222f, -0.02416287f, -0.02620098f, 0.05841075f, 0.05795313f, 0.06695230f, 
    -0.06630656f, -0.06939910f, -0.13871694f, -0.17874120f, 0.07549845f, -0.23240189f, 0.20970395f, -0.08823924f, 
    -0.22135928f, -0.19960031f, -0.14628881f, -0.12026224f, -0.12973119f, -0.19243576f, 0.09824857f, 0.11769712f, 
    -0.22750852f, 0.14398074f, -0.02204672f, 0.01848792f, 0.07042403f, 0.03563341f, -0.21747759f, -0.12658988f, 
    -0.18728314f, 0.41703594f, 0.47171158f, -0.03394218f, -0.01767810f, 0.00028712f, 0.08686964f, 0.17729458f, 
    0.28627321f, 0.18346040f, -0.14154564f, 0.18668167f, 0.00589805f, 0.11070677f, -0.01499090f, 0.12517902f, 
    -0.04663829f, -0.01720187f, 0.24395810f, -0.01456924f, 0.03284951f, -0.14330381f, -0.08886647f, -0.38941625f, 
    -0.22324519f, -0.15886262f, -0.18581569f, 0.19413677f, -0.02834668f, -0.02385239f, 0.03523008f, 0.15037975f, 
    0.04126943f, 0.01499804f, -0.03009998f, -0.00809611f, 0.06731559f, 0.02384721f, 0.12461562f, 0.05028436f, 
    -0.27920160f, -0.31335995f, -0.07334714f, 0.12795779f, -0.12375069f, -0.13819009f, -0.19719112f, -0.07178047f, 
    -0.20364255f, -0.11864801f, -0.03905322f, 0.08851691f, 0.00173772f, 0.11136509f, 0.03622364f, 0.13883716f, 
    0.18108201f, 0.19474083f, 0.24251205f, 0.16549540f, 0.16809179f, 0.45462736f, -0.23827586f, -0.03162959f, 
    0.28073946f, 0.14233319f, 0.18808433f, 0.29091382f, 0.09507512f, 0.04883926f, -0.03796770f, 0.02116093f, 
    0.00141662f, -0.00038277f, -0.01577222f, 0.00054057f, 0.01529197f, -0.14603116f, -0.07019097f, 0.12661377f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07622895f, -0.04192028f, 0.09296698f, 0.00469047f, 0.01758206f, -0.00734446f, -0.03451077f, 0.14391221f, 
    -0.02818184f, -0.00739297f, 0.16682535f, -0.03257388f, 0.06452853f, -0.04421546f, 0.09450949f, 0.03560528f, 
    -0.00224109f, 0.08908679f, 0.05024673f, 0.05533583f, 0.13203803f, -0.01899447f, -0.04598464f, 0.06231439f, 
    -0.00199221f, -0.08227077f, 0.08740110f, 0.03115289f, 0.07400721f, 0.01800584f, 0.07906208f, 0.07412525f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.21665455f, -0.75152791f, 0.12150379f, 0.28317401f, -0.03315031f, 0.25089687f, -0.03755981f, -0.04446871f, 
    0.07132308f, 0.09465551f, 0.22077557f, 0.40393710f, -0.29969454f, -0.15741731f, -0.56650329f, -0.02866622f, 
    0.05471994f, 0.02206058f, -0.07355018f, -0.24091285f, -0.57594597f, 0.32600069f, 0.39917895f, 0.25942186f, 
    -0.12957598f, 0.28240758f, -0.60196328f, -0.65929478f, -0.17126852f, 0.19764774f, -0.36961600f, 0.00946257f, 
    0.46685749f, -0.71042591f, 0.28005654f, 0.27100369f, 0.00309345f, -0.96425897f, 0.17234825f, 0.15256791f, 
    0.12037411f, -0.06571348f, 0.23887002f, 0.01380102f, -0.10109907f, 0.07830951f, 0.09925482f, -0.12773910f, 
    0.09602901f, 0.08033207f, -0.07199203f, -0.21468174f, -0.01934493f, -0.18396397f, 0.24823998f, 0.11976140f, 
    -0.09269023f, -0.70068038f, 0.28434086f, 0.12112768f, 0.04492274f, 0.35005984f, -0.07176530f, 0.10555892f, 
    -0.39146787f, 0.01463885f, 0.03914826f, -0.69610989f, 0.07684814f, -0.54727662f, 0.14046010f, 0.24265219f, 
    -0.08105791f, 0.12875339f, -0.33974823f, 0.18742147f, 0.40018114f, 0.13514140f, -0.45625928f, -0.12726885f, 
    -0.22280911f, 0.38706049f, 0.12074401f, 0.17752405f, 0.00376753f, 0.40670645f, 0.09710246f, -0.50689852f, 
    -0.03928816f, -0.21981874f, 0.42689559f, -0.79969984f, 0.41812402f, -0.21393004f, 0.05806766f, -0.49296510f, 
    -0.12985167f, -0.03674709f, -0.53738189f, -0.31439391f, 0.10979473f, -0.10118607f, -0.04224433f, -0.05635718f, 
    0.06004716f, 0.12321807f, -0.30943382f, 0.18123689f, 0.20967287f, -0.08011890f, 0.30401331f, 0.07774799f, 
    0.24493968f, -0.40445581f, 0.25188258f, -0.01313819f, 0.13126460f, -0.20989275f, -0.09298500f, -0.87773639f, 
    0.13150498f, 0.54906493f, -0.37586641f, -0.35993743f, -0.49400693f, 0.22369979f, -0.57162315f, -0.14262450f, 
    -0.15883715f, 0.47335199f, -0.16907230f, 0.02874699f, 0.11750647f, 0.25953478f, 0.14091334f, -0.44453833f, 
    0.00864885f, -0.04232435f, -0.08134066f, 0.20301966f, -0.38062838f, 0.12919845f, -0.15030658f, 0.09807854f, 
    -0.14659083f, -0.57592613f, 0.02520326f, -0.20526782f, -0.36170146f, 0.34900191f, 0.09123773f, 0.10495133f, 
    0.03903250f, 0.03030301f, 0.23938614f, 0.35368964f, 0.09139192f, 0.24484646f, 0.22217076f, -0.22941665f, 
    0.25400928f, 0.08545978f, 0.18299498f, 0.22201052f, -0.11030035f, 0.28084886f, 0.13194075f, 0.25247052f, 
    0.04815401f, 0.06222019f, -0.77557862f, -0.11819911f, 0.17185341f, 0.12508632f, 0.14022538f, -0.06099260f, 
    -0.34827432f, 0.18887153f, 0.16504720f, -0.10273092f, -0.25800043f, -0.58122241f, 0.01789484f, 0.35298213f, 
    -0.04429784f, -0.37560135f, 0.04354141f, -0.29138640f, -0.44820014f, -0.03840246f, 0.26774016f, 0.00218905f, 
    -0.29363361f, -0.01116552f, -0.05993791f, -0.77830988f, 0.03064780f, 0.36989295f, -0.13935035f, 0.28319249f, 
    0.13354912f, -0.04642991f, 0.30589181f, -0.86149949f, 0.37208599f, -0.09965438f, -0.31293201f, 0.08558594f, 
    -0.13981816f, -0.53475916f, -0.10886211f, -0.27785242f, 0.29432502f, -0.19398692f, -0.46372011f, -0.02522705f, 
    0.10151739f, 0.39109141f, 0.11818883f, 0.00562762f, 0.25287682f, -0.78903663f, 0.26620668f, -0.52851546f, 
    -0.37552077f, 0.19476125f, 0.14168023f, 0.24279267f, 0.13580906f, 0.16185534f, 0.02926448f, -0.45799848f, 
    0.16499089f, 0.13287421f, -0.40871531f, 0.10720591f, 0.06986852f, 0.15983291f, 0.36622483f, 0.00768217f, 
    -0.14382209f, 0.25976649f, -0.31498864f, -0.36810553f, 0.04592939f, -0.02998415f, -0.34475970f, -0.07480559f, 
    0.15991057f, 0.33068442f, 0.27527019f, 0.29069722f, 0.28901452f, -0.73710155f, -0.05865731f, -0.25425476f, 
    -0.19911371f, -0.42263544f, 0.10432194f, 0.32766044f, -0.06282476f, -0.81963843f, -0.13212493f, 0.07675228f, 
    -0.02917290f, 0.16727853f, 0.38455281f, -0.75903100f, -0.54820484f, 0.04239498f, 0.07079172f, -0.08422335f, 
    -0.31639424f, 0.46640378f, 0.30101469f, 0.11194286f, 0.08999732f, -0.53600067f, -0.34683406f, 0.16128235f, 
    -0.15945144f, 0.35175601f, -0.56205505f, -0.27587673f, -0.24729559f, -0.62036920f, -0.03648615f, 0.08095100f, 
    0.03557222f, 0.33490154f, 0.07011213f, -0.49064088f, 0.11714712f, 0.41701937f, 0.01257748f, 0.02588077f, 
    0.03468124f, -0.03102989f, 0.42138636f, -0.35570541f, -0.19739832f, -0.02821463f, 0.38872755f, -0.01502573f, 
    -0.47682047f, 0.05054884f, -0.27414909f, 0.29966202f, 0.12164889f, 0.57539678f, -0.18027915f, 0.44789734f, 
    0.04067867f, -0.35757750f, 0.23847559f, -0.48634452f, -0.14022532f, 0.13263880f, -0.21487619f, -0.48696035f, 
    -0.24951266f, -0.02133080f, -0.01616418f, -0.22378333f, -0.12274797f, -0.30992800f, -0.16918838f, -0.27963200f, 
    0.09194562f, -0.05521166f, -0.33807600f, -0.68439782f, 0.48388860f, -0.14105441f, -0.17430721f, 0.02241633f, 
    0.43090117f, -0.22403729f, 0.23908877f, 0.17221960f, -0.21018632f, -0.35479888f, -0.45214066f, -0.52870411f, 
    -0.07104786f, -0.42967719f, -0.32625836f, -0.16561022f, 0.27695480f, 0.00418315f, 0.10577135f, 0.44547465f, 
    0.21940459f, 0.33027875f, -0.81484687f, -0.03556141f, 0.02143850f, 0.14338022f, -0.02016717f, 0.20391379f, 
    0.12878874f, -0.04064229f, 0.24814358f, -0.37353459f, -0.47385633f, 0.04866020f, -0.17810348f, 0.15060575f, 
    0.72679597f, 0.37818742f, 0.06606390f, -0.16987212f, 0.17871130f, -0.58034790f, -0.11540603f, -0.18007717f, 
    0.10234610f, -0.09808781f, -0.08309120f, 0.13020422f, -0.08886679f, -0.24706590f, -0.35890293f, -0.39192060f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.38474080f, 0.30706954f, 0.28585887f, 0.07942323f, -0.18965125f, 0.27901551f, 0.28557268f, -0.12449849f, 
    -0.23031162f, 0.02094229f, -0.12729424f, -0.07236826f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
