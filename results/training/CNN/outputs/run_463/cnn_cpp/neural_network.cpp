#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.60647511f, 0.12821414f, -0.47657317f, -0.00110117f, 0.72134542f, 0.49689677f, 0.50018686f, -0.43181315f, 
    0.56082243f, 0.62816590f, 0.09317360f, 0.17494898f, -0.25035655f, -0.15402859f, -0.01451158f, -0.09889854f, 
    -0.05291133f, -0.16708502f, -0.12814052f, -0.06914318f, -0.03248712f, 0.02526586f, 0.28342435f, 0.12676394f, 
    -0.12335660f, -0.81569576f, -0.19348334f, -0.37869036f, 0.12615547f, 0.32943651f, -0.84165758f, 0.48141354f, 
    0.90580517f, 0.02184141f, 0.09826037f, 0.14733063f, -0.08158062f, 0.39186639f, -0.25436532f, 0.10665952f, 
    0.33436322f, 0.24358885f, -0.12096202f, -0.12731999f, -0.17478444f, -0.19058499f, 0.02263087f, -0.03762909f, 
    0.23548386f, -0.09955615f, 0.87504143f, 0.62074184f, 0.79551697f, -0.09086797f, -0.14859933f, -0.17007604f, 
    -0.64269495f, 0.23341416f, 0.19303250f, 0.27654284f, 0.14975515f, 0.21291183f, -0.43253580f, -0.12790991f, 
    0.32740608f, 0.03214238f, 0.11694577f, -0.07505820f, -0.13813198f, 0.22718735f, 0.41258654f, 0.36630073f, 
    0.08754919f, 0.15206970f, 0.12884644f, 0.95290744f, 0.45396262f, 0.38301688f, 0.41187793f, 0.45065796f, 
    0.95703119f, 0.31270200f, -0.49198779f, 0.21561533f, -0.36425057f, -0.30593619f, 0.22225669f, -0.10467648f, 
    0.23230575f, -0.25959840f, -0.05315913f, 0.08910715f, 0.12260816f, 0.08375101f, -0.18007186f, 0.04901510f, 
    0.07608107f, -0.20336896f, -0.15085861f, 0.13467637f, 0.56434053f, 0.38277602f, 0.80398256f, 0.64157277f, 
    0.80373257f, -0.33270496f, -0.38616300f, -0.65535021f, -0.51554030f, -0.12727636f, 0.62557948f, 0.03980486f, 
    0.16619201f, 0.28560770f, -0.08925292f, -0.04828360f, 0.01125768f, -0.11473437f, 0.15159979f, 0.18958536f, 
    0.04588810f, 0.03206294f, 0.05218098f, 0.10241212f, 0.19226430f, 0.75874668f, 0.59951967f, -0.06805037f, 
    -0.59651655f, -0.19201905f, 0.19296636f, 0.17186970f, 0.56627411f, 0.56972617f, 0.46642002f, -0.62077802f, 
    0.12971598f, -0.49831542f, -0.30865052f, -0.39083877f, 0.13377255f, 0.08017610f, -0.16411914f, -0.19948660f, 
    -0.09082916f, -0.20541641f, -0.02327313f, -0.15703979f, 0.00349094f, -0.11896113f, -0.36118934f, -0.67778099f, 
    -0.56542003f, -0.46694335f, -0.33393180f, 0.05017655f, 0.87826556f, 0.71318507f, -0.09948180f, 0.25229126f, 
    -0.09710341f, -0.02522011f, -0.24634169f, -0.37621328f, -0.21632357f, 0.06020449f, 0.01211271f, 0.08972403f, 
    0.15481235f, -0.18747449f, -0.01903349f, -0.19098249f, -0.08328578f, -0.39607891f, 0.18401261f, -0.14862359f, 
    -0.23132889f, -0.48586914f, -0.77835202f, -0.74132121f, 0.03002127f, -0.35481894f, -0.13681065f, -0.04116297f, 
    0.04651281f, 0.19735819f, 0.06050809f, -0.06071866f, 0.07718927f, -0.15010050f, 0.33664808f, 0.03227579f, 
    -0.15874493f, 0.14951041f, 0.42600474f, 0.11578645f, 0.00170983f, -0.00137418f, 0.63716114f, 0.16916773f, 
    1.01341999f, 0.03249731f, 0.30347753f, -0.35671777f, 0.00590881f, 0.17634116f, -0.75393933f, -0.19554579f, 
    0.20191857f, 0.02608147f, -0.55108327f, -0.31932640f, -0.15378042f, -0.11237166f, -0.09165733f, 0.09116418f, 
    0.05460841f, -0.22166552f, -0.40732443f, -0.05201645f, -0.23773734f, 0.13261245f, -0.08603126f, -0.17355017f, 
    -0.02124715f, 0.98928118f, 0.83509910f, 0.44350910f, -0.07342041f, -0.25754711f, -0.08568498f, 0.31467834f, 
    -0.28646243f, -0.65571070f, 0.25846681f, 0.15490703f, 0.42055055f, 0.28213525f, 0.10079517f, -0.05424496f, 
    0.17397967f, -0.18440281f, 0.30933502f, 0.12536898f, -0.17524576f, -0.08044226f, 0.16940700f, -0.08979953f, 
    -0.10660301f, 0.08080870f, 0.40999380f, -0.41061264f, -0.49510363f, 0.66083866f, -0.27700594f, -0.36699474f, 
    -0.45672932f, -0.41878968f, 0.14246786f, -0.20958301f, -0.08312227f, 0.25090858f, 0.44091743f, -0.14660047f, 
    -0.26498675f, 0.05969653f, -0.07531542f, 0.51682532f, 0.07923800f, -0.18061164f, 0.04876159f, 0.32680643f, 
    0.05618635f, 0.15392973f, 0.07023356f, -0.41950431f, -1.22477078f, -0.66543543f, 0.15952149f, 0.26724991f, 
    -0.33211562f, 1.13366604f, -0.14479174f, -0.06955375f, -0.11670918f, 0.25318047f, 0.01473759f, -0.21608254f, 
    0.18063845f, 0.26354396f, -0.11558136f, -0.11193997f, -0.21583016f, -0.00812724f, -0.06045184f, 0.08140052f, 
    0.09322549f, 0.01389060f, 0.22337098f, -0.08784555f, -0.24656081f, 0.06507265f, 0.12677866f, -0.25851089f, 
    0.23707412f, -0.47840104f, -0.01868653f, 0.03227931f, -0.51386499f, 0.44031078f, 0.07904131f, 0.13483232f, 
    0.34497106f, 0.35386086f, 0.54303318f, -0.16637520f, -0.14589946f, 0.00622223f, -0.24949831f, 0.44685739f, 
    0.51100111f, -0.26571453f, -0.07399935f, 0.04183526f, -0.17730469f, 0.18181528f, -0.13382408f, -0.92449683f, 
    -1.00074315f, -0.37470415f, 0.51961464f, 0.23303033f, -0.16427277f, -0.38157693f, 0.23744982f, 0.06641517f, 
    -0.24813136f, 0.17528178f, 0.36757398f, 0.14102626f, -0.13487984f, 0.10726114f, -0.14628904f, -0.13648324f, 
    -0.09223226f, 0.03852625f, 0.03877960f, 0.27011490f, -0.22812961f, 0.05337306f, -0.73149133f, 0.16118048f, 
    0.27956441f, -0.42182359f, 0.09248347f, -0.83889002f, 0.32112867f, -0.03218950f, -0.75131929f, -0.40724140f, 
    -0.39468217f, 0.16757444f, -0.11317409f, -0.06860598f, -0.36722398f, 0.07108767f, -0.40585878f, 0.23407194f, 
    -0.11253041f, -0.32110444f, -0.10086424f, 0.04522169f, -0.06354891f, -0.01629734f, -0.00989383f, 0.57511568f, 
    0.27597958f, 0.43290439f, 1.25863445f, 0.36384806f, -0.21061309f, -0.12109253f, 0.26778662f, 0.47780821f, 
    -0.03182994f, -0.42210746f, 0.01094984f, 0.00962423f, 0.00747765f, -0.04991379f, 0.13562576f, -0.10327396f, 
    -0.29912186f, 0.27522570f, 0.26432100f, -0.19121639f, -0.13384841f, 0.16252224f, -0.16393486f, -0.12087760f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15370572f, 0.46142113f, 0.25748166f, 0.01447082f, 0.14040159f, 0.02121371f, 0.19064997f, 0.12830389f, 
    0.32109597f, 0.22930181f, 0.18181966f, 0.18621372f, 0.30906853f, 0.24720137f, 0.22865252f, 0.04488240f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07669686f, 0.05205068f, -0.00135115f, 0.00237234f, -0.00795427f, 0.03335528f, -0.02457330f, 0.03219961f, 
    -0.06415444f, 0.03668373f, 0.06273407f, -0.08094615f, -0.05426347f, 0.01708023f, -0.05248721f, -0.01888732f, 
    -0.04780320f, 0.02400183f, 0.02932986f, 0.05362312f, -0.05827546f, 0.05178070f, -0.00094763f, -0.07601152f, 
    -0.07462230f, -0.01788452f, -0.05218409f, 0.04638269f, 0.06009343f, -0.06910317f, -0.06336892f, -0.02727239f, 
    0.01898844f, 0.05500824f, 0.03343299f, -0.04280516f, -0.07588561f, -0.06141557f, 0.03509948f, -0.03537511f, 
    -0.02778115f, -0.02087663f, 0.05373033f, -0.05202744f, -0.02550097f, 0.01801156f, -0.00329270f, -0.03515551f, 
    -0.02082918f, 0.03326765f, -0.04582668f, -0.05344316f, -0.06637226f, 0.03065271f, 0.03104490f, 0.05624489f, 
    0.03876875f, 0.05188226f, -0.02525749f, -0.01291898f, -0.02548419f, -0.05060101f, -0.05867079f, 0.05949895f, 
    0.02887850f, 0.02487017f, -0.03924479f, 0.05897225f, 0.04132409f, -0.07463735f, -0.06180879f, 0.06035890f, 
    0.00478106f, 0.02317670f, -0.00581715f, 0.03037348f, 0.03152667f, -0.02984689f, -0.03184127f, 0.02019506f, 
    0.01898075f, -0.03006693f, -0.00283271f, 0.03749551f, -0.07189002f, -0.04125365f, -0.02449824f, -0.05563338f, 
    0.01611249f, -0.06880844f, -0.01466895f, 0.03267090f, -0.02011359f, 0.03387584f, -0.04184557f, 0.05192976f, 
    0.05597090f, -0.03341628f, -0.05460683f, -0.03613349f, -0.04381243f, -0.06424902f, -0.04854032f, -0.04027105f, 
    0.02321263f, -0.01421707f, 0.01231709f, -0.03585595f, -0.05491922f, -0.00332057f, -0.03661674f, -0.01705770f, 
    -0.06389506f, -0.05612042f, -0.01624455f, 0.06190365f, -0.00935295f, -0.07101372f, -0.00695725f, 0.01448140f, 
    0.00472963f, -0.02158897f, 0.03451123f, -0.08759569f, 0.04605063f, 0.03201937f, 0.00874098f, 0.02563146f, 
    -0.08154124f, -0.07278822f, -0.00297273f, 0.03327747f, -0.03044581f, -0.00902193f, -0.01149153f, -0.04246452f, 
    0.03535845f, 0.02639927f, -0.06230463f, -0.06644450f, -0.03865199f, 0.06705773f, 0.01882927f, -0.01255774f, 
    0.05093090f, -0.01368976f, -0.07243334f, 0.00274755f, 0.02431460f, 0.05297934f, 0.03309390f, 0.05709893f, 
    -0.03098500f, 0.05563388f, -0.01189174f, -0.04729094f, -0.07352824f, -0.03642318f, 0.05009181f, 0.05347337f, 
    -0.03409819f, -0.02213204f, -0.03151568f, 0.02183965f, 0.04150251f, 0.04082821f, -0.04684511f, -0.03619058f, 
    0.02775724f, -0.00196805f, -0.02585863f, 0.02028277f, 0.03683278f, -0.07530010f, -0.07380276f, 0.04935349f, 
    -0.07045961f, -0.06143573f, -0.02602787f, 0.01638688f, 0.01764545f, -0.05657094f, 0.05787889f, -0.02567640f, 
    -0.07133218f, 0.01035597f, -0.04468069f, 0.04166096f, 0.02867098f, -0.07896297f, -0.06663160f, -0.06432319f, 
    0.11773491f, 0.10629730f, -0.19463809f, 0.11535420f, 0.05093098f, -0.07920566f, -0.17677432f, -0.04345198f, 
    -0.06055973f, 0.00440151f, -0.09248596f, 0.05068394f, 0.54591262f, -0.38340354f, 0.19076486f, 0.23459435f, 
    -0.02794439f, -0.03713166f, 0.08270926f, 0.03324660f, -0.04686120f, -0.04821884f, 0.00620079f, 0.07968938f, 
    -0.34971094f, -0.13218303f, 0.03527428f, -0.00638310f, 0.08252439f, 0.07310238f, 0.01423635f, -0.16297370f, 
    -0.01495727f, 0.15308076f, -0.06978797f, 0.05128926f, 0.34132338f, 0.48766983f, 0.10543113f, -0.04944364f, 
    0.09550612f, -0.08662549f, 0.10867000f, 0.02217261f, -0.02283015f, 0.06368153f, -0.01059054f, 0.10648163f, 
    -0.47144628f, -0.10471264f, -0.03955715f, -0.06206864f, 0.11648906f, 0.13781759f, -0.06419031f, -0.10969547f, 
    0.01384042f, 0.12720044f, -0.00726079f, -0.12539959f, 0.15805013f, -0.12986426f, -0.06416371f, 0.20435305f, 
    -0.10442674f, 0.05250224f, 0.05602278f, 0.02835617f, -0.04151587f, 0.04983268f, -0.03077423f, 0.03064389f, 
    0.28550619f, -0.05136474f, 0.36306980f, 0.27047604f, 0.00755181f, -0.04108436f, -0.01337991f, 0.04641738f, 
    -0.01487261f, 0.00486344f, 0.00821819f, 0.16669260f, -0.08022880f, 0.24361093f, 0.29192030f, -0.06013788f, 
    0.29369730f, 0.05178048f, 0.11247925f, 0.07883327f, 0.08818830f, -0.10327733f, 0.00778954f, 0.07016353f, 
    -0.24887715f, -0.11696557f, 0.08333705f, -0.03532010f, -0.12946658f, 0.17918995f, -0.02332215f, -0.09547534f, 
    0.06138043f, 0.19311881f, -0.01336110f, 0.14412338f, -0.27109563f, -0.26046947f, -0.10610177f, 0.02321215f, 
    0.08561418f, 0.01523628f, 0.04536898f, -0.08205798f, 0.03389104f, -0.16046475f, 0.08516650f, -0.11280975f, 
    0.35449761f, -0.00980140f, -0.04898027f, -0.03380340f, -0.25268054f, -0.09011003f, 0.05425938f, 0.03260202f, 
    -0.05470223f, 0.01273387f, -0.02623686f, -0.03947764f, 0.43027747f, -0.02117977f, 0.02664134f, -0.05812519f, 
    -0.09274774f, -0.00740006f, -0.05300733f, 0.08211220f, -0.03511574f, 0.06244761f, -0.03980699f, -0.00885242f, 
    0.10557659f, -0.06377730f, 0.21604973f, 0.03700057f, -0.02465384f, 0.04059450f, -0.02898470f, -0.14851658f, 
    0.12613533f, 0.08583704f, 0.02241165f, -0.11271389f, -0.20184878f, 0.42984915f, 0.10401325f, 0.07948121f, 
    -0.00381211f, -0.15239033f, 0.03624229f, 0.04227543f, -0.01539239f, 0.06574423f, 0.04656465f, -0.10703027f, 
    0.16757016f, -0.16923949f, 0.18550612f, -0.05394874f, 0.15282175f, 0.04138989f, -0.02949688f, -0.17998806f, 
    0.06129622f, 0.15580487f, -0.16392459f, 0.16948058f, 0.12081310f, -0.15744135f, -0.00155032f, 0.28764024f, 
    0.12600702f, -0.02286801f, 0.04696570f, -0.03455809f, -0.00049485f, 0.16718996f, 0.12000407f, -0.01001246f, 
    0.04683699f, 0.04591769f, -0.08479176f, -0.03416348f, -0.07231992f, -0.00985553f, -0.04461364f, -0.06088094f, 
    -0.08924492f, 0.03826835f, 0.03351710f, -0.09002195f, -0.01173554f, -0.02140767f, 0.00264810f, -0.05812834f, 
    -0.09856538f, -0.01791726f, -0.05276676f, -0.00947808f, -0.01219911f, -0.03597213f, 0.01573332f, -0.07953281f, 
    0.02539275f, -0.04837181f, -0.03397761f, 0.02887631f, -0.04991454f, -0.05623534f, 0.05019111f, -0.07475075f, 
    -0.09111001f, -0.09431697f, -0.08445727f, 0.02363960f, -0.07904478f, 0.01753025f, -0.02875969f, 0.02596469f, 
    -0.00042002f, -0.05922940f, -0.05693271f, 0.03313078f, -0.05645338f, -0.02761630f, 0.01522483f, -0.00261616f, 
    -0.08755518f, 0.02534756f, -0.02654102f, -0.09799091f, 0.03977928f, 0.00686769f, -0.09092072f, -0.00567741f, 
    0.01178226f, 0.00486661f, -0.10032850f, 0.01344342f, -0.04232026f, -0.06029134f, -0.06946474f, -0.07146420f, 
    -0.05815424f, -0.04185875f, -0.08041068f, 0.02508483f, 0.02440411f, -0.04674447f, -0.08678693f, -0.03975993f, 
    -0.01625158f, 0.03046817f, -0.09460327f, -0.00869950f, 0.00366811f, 0.02223417f, -0.09873183f, -0.05041442f, 
    -0.08657262f, -0.08658006f, -0.02999702f, -0.04255934f, -0.04325227f, -0.06326131f, 0.02459154f, -0.04805642f, 
    0.03831797f, -0.07349413f, -0.07687156f, 0.00557486f, -0.01296620f, 0.02847223f, 0.03023393f, -0.06424113f, 
    -0.03463675f, -0.05210652f, -0.06000540f, -0.07824565f, -0.04362604f, -0.06069316f, -0.01506516f, -0.02424074f, 
    -0.09615453f, -0.08587260f, 0.00004525f, 0.01880162f, 0.04145254f, -0.08164172f, -0.08558115f, -0.00194043f, 
    0.02490474f, -0.06441230f, -0.07424854f, -0.07315218f, 0.03162086f, -0.00980417f, 0.06665570f, -0.00991362f, 
    -0.04046650f, 0.01876183f, -0.00763984f, -0.04066049f, 0.03740695f, 0.02970515f, -0.00879488f, 0.02921159f, 
    -0.07349000f, 0.03091455f, -0.06205523f, -0.06413709f, -0.07909651f, -0.08199067f, -0.00695252f, -0.00803794f, 
    0.04108420f, 0.03829834f, -0.05884531f, -0.07796177f, -0.08570217f, -0.06801378f, 0.03060153f, -0.02725161f, 
    -0.05892115f, -0.07705620f, -0.05982301f, 0.02378822f, -0.07188697f, -0.04478114f, -0.09307454f, -0.03074159f, 
    -0.00783630f, -0.04806030f, 0.02458734f, -0.04144104f, -0.02140635f, -0.06901653f, -0.06557991f, 0.00459349f, 
    0.01739869f, -0.09821649f, 0.02665719f, 0.00833092f, -0.04937291f, 0.03155852f, -0.00361965f, -0.07405338f, 
    0.01889548f, -0.02938755f, -0.04276120f, -0.08547816f, -0.05362555f, -0.03105276f, -0.08810294f, -0.06501862f, 
    0.04013148f, 0.02519909f, -0.07748718f, -0.06550269f, -0.02431668f, -0.09391331f, -0.06402637f, 0.01883283f, 
    0.07087744f, 0.01494679f, -0.09099647f, -0.08973017f, -0.01311842f, 0.04945624f, -0.06410906f, 0.00208232f, 
    0.04023962f, -0.07121853f, -0.01296055f, -0.04758305f, -0.02780875f, -0.02807132f, -0.04943600f, 0.05386608f, 
    -0.00942250f, -0.05173095f, -0.05269415f, 0.00038701f, -0.04610709f, 0.01359373f, -0.05937269f, -0.01900603f, 
    -0.03556636f, -0.05754225f, 0.05762786f, -0.05229346f, -0.08044462f, -0.08129095f, 0.04307111f, 0.05504503f, 
    0.01797065f, -0.07782860f, -0.05902594f, -0.04053261f, -0.02434297f, -0.06404243f, 0.02594667f, -0.00476516f, 
    -0.00272545f, -0.03780710f, 0.01022926f, -0.05009159f, 0.02944376f, 0.04283103f, -0.01180059f, -0.07002554f, 
    -0.08396485f, -0.01193326f, 0.05064836f, 0.01034626f, 0.00064590f, -0.07213083f, 0.06024916f, -0.05346571f, 
    0.05021695f, -0.02661773f, -0.00979963f, -0.04045723f, -0.05630371f, -0.01264562f, 0.00314923f, -0.03567905f, 
    -0.02506112f, -0.01867700f, -0.02208522f, 0.03280900f, -0.03105879f, 0.03399857f, -0.05224225f, 0.04887017f, 
    0.05434237f, 0.01086244f, 0.00942972f, 0.06209322f, 0.05396333f, 0.06665051f, 0.00902062f, 0.05449216f, 
    0.05270945f, -0.01406753f, 0.05385627f, 0.01968263f, -0.03031200f, -0.01766121f, 0.00099376f, 0.05768249f, 
    -0.04081085f, 0.05410331f, -0.00232536f, 0.01794304f, -0.04542550f, -0.00969670f, -0.01007430f, 0.01528223f, 
    -0.03946665f, 0.01983237f, -0.07805045f, 0.01867136f, -0.03423546f, -0.04506040f, -0.02113989f, -0.03353903f, 
    -0.05946033f, 0.01609168f, 0.03517703f, 0.03530634f, -0.01065903f, 0.05190159f, -0.02535178f, 0.00260199f, 
    -0.00215921f, -0.07398528f, -0.01548183f, -0.07612824f, 0.01987081f, -0.05425542f, -0.00146130f, -0.01346422f, 
    0.01350533f, 0.01604155f, -0.02257079f, -0.03918292f, 0.01773134f, 0.05808568f, -0.03733938f, -0.00321144f, 
    -0.07832592f, -0.01747145f, -0.06126126f, 0.02228099f, -0.01268744f, 0.03911688f, 0.03022407f, 0.00659546f, 
    0.00964392f, -0.07467693f, 0.03898167f, -0.02853786f, -0.02264645f, -0.04363599f, -0.02657153f, 0.04245280f, 
    -0.03427001f, 0.02904483f, 0.00201647f, -0.01550113f, -0.06510538f, 0.05276051f, 0.00805536f, 0.01641610f, 
    0.00387576f, 0.05799782f, 0.03655877f, 0.00661517f, 0.00330545f, -0.04860748f, 0.03780152f, -0.06294218f, 
    0.05507161f, 0.04531493f, 0.04559763f, 0.05681482f, 0.04723011f, -0.07153793f, -0.00902720f, 0.04249551f, 
    -0.03247700f, -0.04381796f, 0.05874060f, 0.06163798f, -0.07323477f, -0.03197386f, 0.01731985f, -0.07052814f, 
    -0.00456529f, -0.05068847f, -0.00361698f, 0.02176283f, -0.06499052f, 0.02197038f, -0.02172102f, -0.02554525f, 
    0.02717052f, -0.02076175f, 0.04735986f, -0.06245409f, -0.02736196f, -0.04594796f, -0.06841066f, 0.04935831f, 
    -0.04269432f, -0.00845242f, 0.05713072f, -0.03538326f, 0.03991332f, -0.05958967f, 0.04736314f, -0.03811157f, 
    0.02327939f, 0.01870174f, -0.02545235f, 0.05110219f, -0.00396793f, -0.03802861f, -0.04626831f, 0.05871953f, 
    0.01082365f, 0.02417172f, -0.02646506f, 0.00988933f, -0.07492902f, -0.04530591f, 0.06230701f, -0.07726237f, 
    0.03867127f, -0.03879472f, -0.05106304f, -0.03175867f, -0.07990316f, -0.00882340f, -0.01606265f, 0.03985791f, 
    0.00718143f, -0.06858186f, 0.02372404f, 0.03022995f, 0.06201022f, 0.04072494f, -0.02641619f, 0.02159219f, 
    -0.07714126f, -0.04779543f, -0.00534914f, 0.02095743f, 0.00504751f, -0.06302917f, -0.02429712f, -0.00447509f, 
    -0.03757090f, -0.05512263f, -0.01673045f, 0.03446129f, 0.06598689f, 0.00272417f, -0.03145096f, -0.01392791f, 
    -0.03945840f, 0.06153115f, 0.02162915f, -0.03940749f, -0.02507584f, -0.05511727f, -0.07587168f, -0.05426051f, 
    0.01351156f, 0.05899025f, -0.05586125f, -0.04074805f, -0.00412486f, 0.02053664f, 0.01416465f, 0.04824615f, 
    0.05130149f, 0.00486766f, 0.02266417f, -0.02327644f, -0.06721859f, 0.03219180f, -0.02157511f, 0.04665647f, 
    -0.04251212f, -0.05396307f, -0.02466812f, 0.02454092f, -0.06794237f, -0.00809829f, -0.04359637f, -0.03751709f, 
    0.05179795f, -0.04605685f, -0.00999697f, -0.06863795f, -0.02539663f, 0.04591759f, -0.06907208f, -0.01581671f, 
    -0.03671905f, 0.03821919f, 0.02352179f, 0.00448959f, -0.00839367f, -0.04538953f, -0.04393187f, -0.05226674f, 
    -0.01922899f, 0.02885400f, 0.03648239f, 0.04684684f, -0.03740121f, 0.04997087f, -0.07732101f, 0.02716027f, 
    -0.06350689f, 0.01827336f, -0.06972501f, -0.00008348f, 0.03694861f, -0.05670019f, -0.06415305f, 0.04716790f, 
    -0.06112026f, -0.01433745f, 0.02087451f, 0.04593033f, 0.00078877f, -0.03144182f, -0.05258008f, -0.04421886f, 
    -0.07972376f, 0.04898885f, -0.03013867f, 0.05244433f, 0.04218449f, 0.01568802f, -0.02033057f, 0.00221219f, 
    -0.08121102f, -0.05746628f, 0.05475073f, 0.04337810f, 0.05522676f, 0.05787234f, 0.03057871f, -0.01471663f, 
    -0.07803937f, -0.03227130f, -0.04696209f, -0.06790980f, 0.01708027f, -0.06845902f, -0.06899732f, 0.01266805f, 
    0.01496052f, 0.04842166f, -0.03576998f, -0.01749516f, 0.05152142f, 0.03319956f, 0.05359995f, 0.00682192f, 
    -0.04104698f, -0.08134340f, 0.05739964f, -0.08007443f, 0.05005810f, -0.01992281f, -0.05179521f, -0.08131021f, 
    0.04534271f, 0.01052012f, -0.04087503f, -0.05806000f, -0.00830626f, 0.00167543f, 0.01175035f, 0.02293796f, 
    -0.08054321f, -0.06247250f, -0.01622033f, -0.00725857f, -0.01309856f, 0.01112459f, -0.06092744f, -0.02445070f, 
    0.05406598f, -0.02920815f, 0.01393885f, 0.00129204f, -0.04262216f, -0.01324297f, -0.07134374f, 0.01161876f, 
    0.03439875f, 0.05193888f, 0.04544281f, 0.04691079f, 0.00271389f, -0.00650164f, -0.06084590f, -0.00294100f, 
    0.12090570f, 0.18955487f, -0.27278125f, 0.00604020f, -0.04774545f, -0.07347488f, 0.29275382f, 0.13156788f, 
    0.24174297f, -0.02409993f, 0.02949477f, 0.09026019f, 0.15924414f, -0.08288578f, 0.04480242f, 0.09062195f, 
    -0.04899567f, -0.05136003f, -0.04298160f, -0.04258704f, 0.13699105f, 0.08516622f, 0.12798026f, 0.01121447f, 
    0.33228838f, 0.14825717f, -0.21354374f, -0.16414802f, 0.16609357f, 0.15234640f, 0.05327286f, 0.08872801f, 
    -0.01711085f, 0.05063957f, 0.00315251f, 0.17862028f, -0.32204977f, -0.18116966f, -0.20746697f, -0.35573760f, 
    0.24302146f, 0.09556828f, -0.03056100f, -0.19849269f, 0.05338297f, -0.10781623f, 0.00457830f, -0.13647407f, 
    0.00462971f, 0.07080087f, -0.34096774f, -0.25616539f, 0.21987765f, 0.10212722f, 0.11517730f, -0.01040793f, 
    -0.12350930f, 0.13688976f, -0.10560048f, 0.19794235f, 0.00225428f, 0.07200668f, -0.15797041f, -0.03069133f, 
    -0.10004012f, 0.06054989f, -0.04573935f, -0.08484744f, 0.09375858f, -0.03887010f, -0.02981670f, 0.15727164f, 
    0.28175205f, 0.17129926f, -0.20451508f, 0.15680255f, -0.21971534f, -0.08282562f, -0.18558298f, -0.00751759f, 
    0.11829510f, -0.09990533f, 0.02183851f, -0.05795589f, -0.15485647f, 0.17632802f, 0.15022507f, -0.07690907f, 
    -0.23025194f, -0.25118044f, 0.02561311f, -0.01862399f, -0.00476865f, 0.00000734f, -0.01266519f, 0.18218601f, 
    -0.27313447f, 0.01552848f, 0.08464282f, 0.10518336f, 0.11597169f, 0.16837154f, 0.11795952f, -0.04880266f, 
    0.09690733f, 0.05685314f, -0.09524710f, -0.02755958f, 0.04418049f, -0.06719502f, -0.17211190f, -0.10417599f, 
    0.23022027f, 0.15099266f, 0.00072857f, -0.02323140f, -0.11995136f, 0.13646634f, 0.14397964f, 0.02973488f, 
    -0.31325299f, 0.05066492f, 0.24196905f, -0.10269376f, 0.06756888f, -0.05610949f, -0.11067162f, 0.04175283f, 
    0.09346751f, 0.07116709f, 0.16807368f, 0.14754486f, 0.34386724f, -0.15404353f, -0.04344285f, 0.02033513f, 
    0.01813990f, -0.20685776f, 0.03064997f, 0.02827318f, -0.02559858f, 0.01596074f, 0.02633018f, -0.01246952f, 
    0.39569077f, -0.01143449f, 0.00711521f, 0.01266844f, 0.02693501f, 0.07540166f, 0.15734388f, 0.15287237f, 
    -0.00989253f, 0.18784334f, -0.10037444f, 0.04272903f, 0.15935025f, 0.18493977f, 0.15058731f, 0.13688487f, 
    -0.11175392f, 0.05320032f, -0.04702710f, 0.07690427f, 0.26093578f, 0.00836000f, 0.13752587f, -0.04984706f, 
    0.31649652f, -0.02250640f, -0.30613685f, -0.01151391f, 0.03077375f, -0.06225653f, -0.01599550f, -0.02197673f, 
    0.17905484f, -0.02081181f, 0.08514347f, 0.03993476f, -0.39450642f, -0.24842978f, -0.33092442f, -0.22909614f, 
    0.04063816f, -0.06428551f, -0.02325537f, -0.06956192f, 0.08010133f, 0.29327962f, 0.04988077f, 0.12451850f, 
    0.23656477f, 0.01770435f, 0.06843901f, 0.06526920f, 0.19320650f, 0.14448543f, 0.12970246f, 0.08086135f, 
    0.01917993f, -0.03117936f, 0.03592302f, -0.01965033f, 0.15938255f, 0.43679780f, -0.31178617f, 0.06303604f, 
    -0.12872572f, -0.00295885f, -0.02543693f, 0.06598704f, -0.06968171f, -0.15178566f, 0.06343701f, -0.11980014f, 
    0.80474329f, 0.01434777f, 0.28965101f, -0.02702233f, -0.07528029f, -0.03183008f, -0.02483297f, 0.04802205f, 
    0.10996054f, -0.11373460f, 0.05948797f, -0.06123716f, 0.21464075f, 0.01903579f, 0.16816726f, 0.23181522f, 
    0.31274217f, 0.16179122f, -0.14000487f, 0.08071841f, -0.03211237f, 0.06922001f, -0.00970624f, -0.03056097f, 
    0.00285160f, -0.04663658f, 0.00110286f, 0.39271790f, 0.07111727f, -0.07739956f, -0.07605964f, 0.04381900f, 
    -0.00957365f, -0.05314819f, 0.06161135f, 0.20775418f, 0.31492805f, 0.06629654f, 0.19759992f, -0.00931691f, 
    0.08955009f, 0.04560700f, 0.02170772f, -0.03610435f, 0.01989380f, 0.01372762f, 0.06690069f, 0.01017161f, 
    -0.52681625f, 0.25396982f, -0.15346141f, 0.17904367f, -0.00848882f, -0.00659663f, -0.04297584f, -0.06603603f, 
    0.00685574f, 0.09292560f, 0.00402561f, -0.06083851f, -0.00015368f, -0.13546465f, 0.16540229f, -0.08327849f, 
    -0.10601529f, -0.11177323f, 0.07267497f, 0.14072195f, -0.01570034f, -0.10936295f, 0.07572628f, 0.19058433f, 
    0.19584218f, 0.06306110f, 0.00250044f, -0.30520076f, 0.05630318f, -0.09860367f, 0.12846878f, 0.06350996f, 
    0.03785903f, -0.19163688f, 0.11035317f, -0.16737498f, 0.39007109f, 0.35455525f, 0.07733255f, -0.08246208f, 
    0.06137269f, 0.01450334f, 0.19010495f, -0.04356386f, 0.07354596f, 0.01683362f, 0.06364423f, 0.01966690f, 
    -0.39128441f, -0.05939910f, -0.00559899f, -0.05335213f, 0.17074497f, -0.09754328f, -0.11937698f, -0.04126971f, 
    0.20828208f, -0.02381914f, 0.13164340f, 0.20657441f, -0.90628713f, -0.07073282f, -0.11742290f, -0.08704605f, 
    0.09846793f, -0.13693666f, -0.05151518f, 0.04870287f, -0.04033259f, -0.02252628f, 0.17511635f, -0.01326009f, 
    -0.16346025f, -0.14316837f, -0.08457707f, 0.07547441f, -0.15747565f, -0.04881426f, 0.10524117f, 0.10337343f, 
    -0.16771902f, -0.05691497f, -0.07484433f, -0.08261496f, -0.07949041f, -0.20826006f, 0.22080715f, -0.06512874f, 
    0.13506451f, 0.08608934f, -0.00913860f, 0.17126970f, 0.02155118f, -0.06805894f, 0.18403204f, 0.17656589f, 
    -0.07055845f, 0.15331452f, -0.27538633f, -0.17752449f, -0.10124067f, -0.05903619f, 0.08071569f, 0.00930804f, 
    -0.03490774f, 0.06330475f, 0.23171163f, -0.04040234f, -0.03497310f, -0.00768346f, -0.18027289f, 0.38988721f, 
    0.11733783f, 0.13846025f, -0.07235318f, 0.18248840f, 0.04440521f, 0.06203203f, 0.04556246f, 0.09572200f, 
    -0.02723241f, 0.01165392f, -0.06066381f, -0.04960616f, -0.01948919f, -0.08149412f, -0.06965975f, 0.04673805f, 
    -0.05892339f, -0.00639864f, -0.00311703f, -0.06664865f, -0.00725525f, -0.01850525f, -0.07587098f, 0.00776099f, 
    -0.07175002f, -0.00985228f, 0.01491273f, 0.00814780f, -0.05873742f, -0.05132564f, -0.01762890f, 0.00417141f, 
    0.02958469f, 0.03484570f, 0.03237449f, -0.03498166f, -0.08109829f, -0.03286561f, 0.05686651f, -0.02047283f, 
    0.04287333f, -0.01939683f, -0.05582903f, -0.00191247f, -0.02572680f, -0.03016458f, -0.00604135f, 0.04460789f, 
    -0.02747115f, -0.02385460f, -0.02628283f, 0.03793819f, -0.05829057f, 0.02719575f, -0.03004135f, 0.03193798f, 
    -0.05712361f, -0.00244855f, -0.01090233f, -0.04087485f, -0.07803842f, 0.01771495f, -0.02141801f, -0.03825214f, 
    -0.03302149f, -0.01887157f, -0.04368979f, 0.03328374f, -0.03183246f, 0.01594068f, 0.03424047f, -0.02965919f, 
    -0.00855945f, -0.00800813f, 0.03778314f, -0.02398337f, -0.01657898f, -0.01595292f, -0.07648355f, 0.00241955f, 
    0.03047891f, 0.02849285f, -0.06728246f, -0.02606072f, 0.01332065f, 0.02428581f, 0.00041415f, 0.05449929f, 
    -0.03223290f, -0.07501690f, 0.04040334f, -0.00744740f, 0.04072069f, 0.05436358f, 0.01690010f, -0.07363159f, 
    0.02284755f, -0.00160341f, 0.02950961f, 0.04686678f, -0.00689565f, -0.07550537f, 0.03332122f, 0.04025171f, 
    0.04058459f, 0.01506815f, -0.06168132f, -0.06883161f, -0.03106236f, 0.03526282f, 0.01988444f, 0.01426083f, 
    0.04060852f, 0.03350754f, -0.06435548f, -0.01508104f, 0.03531162f, -0.05330507f, 0.05126614f, -0.05773834f, 
    -0.04039725f, -0.00663203f, -0.07317408f, -0.04110979f, 0.05524207f, -0.07395723f, -0.02730702f, -0.06715211f, 
    0.03814180f, -0.07565105f, -0.02234821f, 0.05323507f, 0.00561357f, 0.00181204f, 0.01238627f, 0.00672459f, 
    -0.06857796f, 0.00156629f, 0.04787389f, -0.04443835f, 0.00399252f, -0.07634769f, -0.01260356f, 0.00642139f, 
    0.01746082f, -0.00551289f, -0.00709428f, -0.04417500f, -0.01960851f, 0.03034303f, 0.00173956f, -0.01375712f, 
    0.05650269f, -0.03178558f, -0.06873049f, -0.00623022f, 0.01518368f, 0.01066406f, -0.03683023f, -0.02749268f, 
    -0.03434319f, 0.02849873f, 0.03868650f, 0.02341861f, 0.01194496f, 0.02941892f, -0.02345170f, 0.00606075f, 
    0.02253716f, 0.00318622f, -0.01601958f, -0.07373460f, -0.01077586f, -0.04027247f, 0.04550502f, 0.04623450f, 
    -0.06019586f, -0.04714787f, -0.03567930f, 0.01852780f, 0.03704588f, 0.01752819f, 0.01669080f, 0.04318259f, 
    -0.01474217f, -0.05996801f, 0.04120260f, 0.04097431f, -0.00792696f, -0.01951581f, -0.06714417f, 0.02872204f, 
    -0.03725937f, 0.01213452f, 0.04811652f, 0.03477936f, -0.07745755f, 0.03731829f, -0.06264417f, -0.04015646f, 
    -0.16591606f, 0.09852423f, -0.05058303f, 0.21955706f, 0.23731920f, -0.05446981f, 0.05624659f, 0.06701829f, 
    -0.02126154f, -0.00083254f, 0.14158504f, 0.05532658f, 0.31019098f, -0.05102139f, -0.05098829f, 0.13296811f, 
    -0.07329070f, 0.10165820f, 0.06859987f, 0.20884988f, -0.02177060f, -0.09964018f, 0.08617719f, -0.10623447f, 
    0.26708287f, 0.08930831f, 0.17772007f, -0.18622376f, 0.03134010f, 0.06601394f, -0.05589295f, -0.19935371f, 
    0.04527231f, -0.01680964f, 0.10380129f, -0.00946154f, 0.01718089f, 0.59681183f, 0.07119351f, -0.28419694f, 
    0.08652868f, 0.11487067f, -0.04669997f, -0.02750041f, -0.07880177f, 0.05326188f, -0.07425661f, 0.04041410f, 
    -0.20053573f, 0.02279204f, -0.07090330f, 0.07690378f, 0.02936630f, -0.15058972f, -0.16682883f, -0.09879437f, 
    0.03700808f, 0.07619385f, -0.06077662f, -0.02540364f, -0.21333097f, 0.15814194f, 0.04536639f, 0.02379813f, 
    0.01438533f, -0.07511161f, 0.24535523f, 0.14103411f, 0.13408907f, -0.06419758f, 0.11163165f, 0.07466140f, 
    -0.07209665f, 0.06190204f, 0.30222556f, 0.35606268f, 0.06644697f, -0.05693942f, 0.20550214f, -0.00004406f, 
    -0.03705168f, 0.15553324f, 0.12350913f, -0.21581517f, 0.02593590f, 0.15030365f, 0.03710893f, 0.25631282f, 
    -0.00229438f, 0.06484578f, -0.15196502f, 0.15791360f, -0.06763089f, -0.06872785f, -0.05584834f, -0.08786264f, 
    0.01714259f, 0.07931043f, -0.02352918f, -0.08058017f, -0.17828093f, 0.19187957f, -0.13989110f, -0.04986697f, 
    -0.08095703f, 0.07809533f, 0.07934982f, 0.01983863f, 0.11958418f, -0.16080795f, -0.05998757f, -0.04030517f, 
    0.08963665f, 0.02111862f, 0.05977866f, -0.04372259f, -0.00652438f, 0.08069547f, -0.05343973f, -0.10189556f, 
    -0.44620740f, 0.21658456f, -0.27090132f, -0.08166506f, -0.08136208f, -0.04261405f, -0.02868992f, -0.11019540f, 
    -0.02128276f, 0.19912902f, -0.12535553f, -0.06615438f, -0.31615049f, 0.02979620f, 0.11313272f, -0.08910318f, 
    0.03616707f, -0.00097878f, 0.08198302f, 0.16196764f, 0.01528459f, -0.20177978f, 0.12009846f, -0.03161891f, 
    0.02174420f, -0.34346557f, 0.00196387f, 0.19497225f, -0.18342371f, 0.08531849f, 0.01533969f, 0.02432707f, 
    -0.02990865f, 0.06222200f, -0.23272789f, 0.02049004f, 0.02409239f, -0.05307990f, 0.19474609f, 0.25369188f, 
    0.26261151f, -0.09426183f, 0.00336709f, 0.07492580f, -0.06075411f, -0.11319391f, -0.09616239f, -0.05700864f, 
    0.01024596f, -0.13682291f, 0.01738483f, 0.00800944f, 0.06899623f, -0.11714116f, 0.02506622f, -0.21428435f, 
    0.05014142f, -0.03708262f, -0.05886408f, -0.05952135f, -0.14339347f, 0.10263845f, 0.14986767f, 0.01097978f, 
    0.00607739f, 0.09236385f, -0.03315801f, 0.00781201f, -0.00356022f, -0.01364497f, 0.13058852f, 0.00283375f, 
    -0.14745292f, 0.11234687f, -0.01456898f, 0.15794769f, 0.12204161f, -0.02204163f, -0.03758081f, -0.04207066f, 
    0.08448773f, 0.12489944f, 0.10037875f, 0.19501923f, -0.24829586f, 0.07310104f, 0.26292759f, -0.03215875f, 
    -0.04990363f, -0.10519272f, 0.17767404f, -0.00321277f, 0.01892856f, 0.30644381f, 0.03930765f, 0.08110719f, 
    0.37602508f, 0.06769354f, -0.04870562f, 0.33116445f, 0.10682017f, 0.09094545f, -0.00176428f, 0.06544333f, 
    0.01388928f, -0.05602000f, -0.11037461f, -0.08071432f, 0.36457273f, 0.09491374f, -0.09716308f, 0.10284869f, 
    -0.05413194f, 0.02059459f, -0.20163386f, 0.00068127f, 0.13134059f, -0.03903386f, 0.00358174f, -0.13262984f, 
    0.20929441f, -0.14359279f, 0.10581158f, -0.08788409f, 0.18913437f, -0.06831209f, 0.04231296f, -0.00314209f, 
    0.03552830f, 0.07885225f, 0.09334055f, -0.12567985f, -0.28018451f, 0.40658289f, -0.08251712f, 0.09582583f, 
    0.10620792f, 0.03037105f, -0.04850746f, 0.10140477f, 0.13100271f, 0.19480470f, 0.03334164f, 0.12281000f, 
    -0.49001223f, -0.38865733f, -0.36816642f, -0.26043823f, 0.09137814f, -0.06213032f, -0.00755863f, 0.16824202f, 
    0.11859473f, -0.00620071f, 0.09887946f, 0.12106868f, 0.06136857f, 0.09244826f, -0.17143682f, -0.12594520f, 
    -0.22824994f, -0.18548493f, 0.01875557f, 0.15143776f, -0.06989155f, -0.02079852f, 0.04984497f, -0.01640979f, 
    0.35654336f, 0.08240703f, -0.07791498f, 0.09887971f, -0.06911014f, 0.25290146f, -0.01064359f, 0.10737137f, 
    0.28545797f, 0.09621429f, 0.18972458f, 0.11809868f, 0.74162829f, 0.28607464f, 0.00553984f, 0.28576943f, 
    0.20808280f, -0.05539235f, -0.06925172f, 0.02655733f, 0.15338913f, 0.05841546f, 0.00323393f, 0.01295990f, 
    0.13854146f, -0.29673514f, 0.04970409f, -0.03370380f, -0.01135627f, 0.04789268f, 0.15140884f, 0.07144085f, 
    0.02427592f, 0.02540268f, 0.02500422f, -0.09841258f, -0.08090624f, -0.05432075f, -0.28674847f, 0.32030791f, 
    0.07507070f, 0.06871127f, 0.14022698f, -0.12124752f, 0.15741746f, -0.02828472f, 0.14463139f, 0.09340752f, 
    0.01432332f, -0.04069759f, 0.09062368f, 0.08052741f, 0.14084564f, 0.12609558f, -0.02993821f, 0.06250019f, 
    0.20980734f, 0.11811753f, 0.19135049f, -0.04652678f, 0.30619714f, -0.00278433f, -0.06690387f, -0.17510889f, 
    -0.07200371f, 0.01738297f, -0.10017090f, 0.07355244f, 0.02402386f, 0.21244033f, 0.09365365f, 0.18412118f, 
    -0.51086748f, 0.12403994f, -0.01043963f, 0.04360308f, -0.18510523f, 0.11300463f, -0.02796328f, 0.15353079f, 
    0.03259645f, 0.07996184f, 0.13737687f, 0.21070805f, 0.09357353f, 0.04725844f, 0.29244748f, -0.04450778f, 
    0.00239939f, -0.14070676f, 0.03095797f, 0.01343725f, 0.00534709f, 0.04392824f, -0.00566700f, 0.11207943f, 
    -0.00295670f, -0.05062380f, -0.00996711f, -0.00591442f, -0.03179429f, 0.00231384f, -0.05236731f, 0.04654691f, 
    0.00945988f, -0.01992043f, 0.05423130f, 0.06493279f, 0.05527413f, 0.00147770f, -0.02515635f, -0.06694486f, 
    -0.03387596f, 0.06639343f, -0.02126764f, -0.03533628f, -0.05902143f, -0.04996459f, -0.03659834f, -0.01178342f, 
    0.06786942f, -0.06829429f, -0.03766597f, -0.05720346f, -0.02983386f, 0.05173850f, -0.01069971f, -0.01792595f, 
    -0.06165643f, 0.06884212f, 0.05148488f, 0.03505317f, 0.06158586f, -0.04459142f, -0.04100855f, -0.02029436f, 
    -0.03761111f, 0.05194717f, 0.04505421f, -0.00174992f, -0.03853393f, -0.06955314f, -0.04672713f, -0.06005935f, 
    -0.03354417f, 0.03667228f, 0.01388702f, -0.06340950f, -0.03490106f, -0.05299732f, 0.04453810f, -0.04482692f, 
    0.06412517f, -0.01891372f, -0.00325883f, -0.03239690f, 0.04983197f, -0.00317870f, -0.05352745f, 0.01973477f, 
    -0.04858477f, -0.06435687f, -0.04014484f, 0.03963462f, 0.04690131f, -0.03701091f, -0.02526132f, -0.05674127f, 
    0.02856341f, -0.02003042f, 0.04450740f, -0.04718665f, 0.00428683f, -0.02636791f, -0.04081480f, 0.05371812f, 
    -0.02450330f, 0.03440798f, 0.03312702f, 0.04984283f, -0.04651285f, -0.05714773f, -0.01198824f, -0.04729042f, 
    0.04846517f, -0.05065547f, -0.00792418f, -0.02579534f, -0.06966680f, -0.04670600f, -0.01080374f, -0.04852255f, 
    -0.00383942f, -0.01747041f, -0.04648934f, -0.01084798f, -0.00323938f, 0.00468500f, -0.05535854f, -0.05772502f, 
    -0.05283179f, -0.00507129f, 0.06975973f, -0.03986586f, 0.03969811f, 0.05330887f, 0.05638242f, 0.03414885f, 
    0.00415790f, -0.02983110f, 0.02901089f, 0.02944240f, 0.02548259f, -0.03288854f, -0.05605018f, -0.04999605f, 
    -0.01776655f, -0.00910754f, 0.04589872f, 0.05303364f, -0.00965780f, 0.00931807f, -0.01846608f, 0.05658015f, 
    -0.04208912f, 0.04585478f, -0.00702413f, -0.04671238f, 0.01533622f, -0.04966076f, 0.05980678f, -0.02723667f, 
    -0.03008929f, 0.05948894f, 0.00557318f, 0.02170875f, -0.05359414f, 0.00179810f, 0.03705516f, 0.05035337f, 
    -0.00656410f, 0.04937821f, 0.01828663f, -0.05907451f, -0.00770876f, 0.06013173f, -0.05815817f, -0.01694279f, 
    -0.05979314f, -0.04848054f, 0.04559024f, 0.02505515f, 0.05150410f, 0.02276767f, -0.05755876f, -0.05118775f, 
    -0.00051776f, 0.02716192f, 0.03832391f, -0.04920999f, -0.03810373f, -0.03597326f, 0.01493875f, 0.01062183f, 
    -0.02355160f, -0.02920936f, 0.00917061f, -0.03376621f, -0.03430330f, 0.02143462f, 0.06946681f, 0.01860280f, 
    -0.06336455f, -0.02451751f, 0.03542024f, -0.07040251f, 0.04567961f, 0.03022152f, 0.03077003f, 0.06589371f, 
    0.04150217f, -0.00069927f, -0.03940734f, -0.06420916f, -0.06266049f, -0.02680550f, -0.03054527f, -0.03478863f, 
    -0.07871304f, -0.25634494f, 0.17204306f, -0.35743079f, -0.05996060f, 0.02125509f, -0.06762615f, 0.21474561f, 
    0.05520687f, -0.04860600f, 0.06303927f, 0.11827937f, -0.33741876f, -0.12440008f, -0.28070751f, 0.13728847f, 
    0.18427207f, 0.17772888f, 0.05873218f, 0.15861374f, 0.12226887f, -0.03089895f, 0.04810091f, 0.02626899f, 
    -0.52096885f, 0.32848394f, 0.19800967f, 0.34395790f, 0.02841962f, -0.17195129f, 0.07474197f, 0.02632985f, 
    -0.01391708f, 0.11791526f, 0.13941811f, -0.00910123f, -0.19131134f, 0.10060459f, 0.18656708f, -0.25719583f, 
    -0.10930091f, -0.03653884f, 0.11941714f, 0.12204051f, 0.11540350f, 0.00748511f, 0.14065389f, 0.07579120f, 
    0.21485132f, 0.23161203f, 0.42975637f, -0.34382266f, -0.12429019f, 0.05026902f, 0.05573859f, -0.08340450f, 
    -0.04384248f, 0.00452872f, 0.14814208f, 0.21079630f, -0.13417712f, 0.03114729f, 0.22036763f, 0.19084233f, 
    0.07623906f, 0.11840869f, 0.22999850f, -0.00820086f, 0.10766502f, -0.22678155f, 0.15043278f, -0.06254370f, 
    -0.17769755f, -0.07970022f, -0.10267093f, 0.00393272f, 0.02546822f, 0.02547446f, -0.12933043f, -0.03007196f, 
    -0.04651002f, 0.05336400f, 0.08927921f, 0.10634951f, 0.09715173f, -0.31813946f, -0.08513705f, 0.08500874f, 
    0.07151198f, 0.13518906f, -0.07054076f, -0.03115080f, 0.05188590f, 0.14619714f, 0.18037154f, 0.06956433f, 
    -0.15598798f, 0.15238903f, 0.19960080f, 0.22836348f, 0.13513456f, 0.09147895f, 0.20423271f, 0.01427440f, 
    0.08752666f, -0.05116759f, 0.09942964f, -0.10404193f, -0.21404831f, 0.17202047f, 0.43702978f, 0.04760564f, 
    -0.11078252f, 0.04697292f, 0.14792275f, 0.11345873f, 0.12309805f, -0.01166858f, 0.02048451f, 0.07508777f, 
    -0.33524555f, -0.13957278f, 0.12782674f, 0.02165871f, -0.00941947f, 0.20297749f, 0.00051156f, 0.06928213f, 
    -0.10581734f, -0.13881207f, 0.00500398f, 0.11342305f, 0.03312328f, -0.03729150f, -0.05779485f, -0.11775420f, 
    0.26966271f, 0.18005979f, 0.05086210f, 0.14082079f, 0.12006924f, -0.03868568f, 0.14007580f, 0.09601711f, 
    -0.04674619f, 0.14079437f, 0.00213091f, 0.10565054f, 0.18236130f, -0.00920824f, 0.06096940f, 0.09124004f, 
    -0.06672158f, 0.06797271f, 0.09320856f, 0.12213940f, 0.19658251f, -0.12237992f, -0.23538548f, 0.10583463f, 
    0.06428804f, 0.08245892f, 0.17164509f, 0.10997824f, 0.06260384f, 0.05208916f, -0.09899724f, -0.06105434f, 
    0.23333898f, 0.07017920f, -0.12779683f, 0.03065640f, 0.03212919f, 0.10059484f, 0.11202320f, 0.06263471f, 
    -0.09836860f, -0.16991073f, 0.00037185f, 0.19994231f, -0.11782737f, 0.27491617f, 0.27534491f, -0.30994558f, 
    0.04801597f, 0.13419908f, 0.07287992f, 0.01283700f, 0.13311428f, 0.12161789f, -0.09519991f, 0.06099726f, 
    0.09468657f, -0.03641455f, -0.12268066f, -0.08131159f, -0.02099007f, -0.00037177f, 0.15252098f, -0.05946819f, 
    0.00494213f, -0.12061625f, -0.14970821f, -0.11858360f, -0.37367383f, 0.14527720f, 0.03546432f, -0.08658570f, 
    0.06695974f, 0.07011960f, -0.08272431f, -0.07793626f, 0.03670407f, 0.03150016f, -0.18710290f, 0.00338177f, 
    0.34785447f, -0.29151958f, -0.07244822f, -0.17736737f, -0.00599149f, -0.03688008f, -0.12884305f, 0.01416229f, 
    0.11255686f, 0.11686731f, 0.02676777f, 0.09968328f, 0.13414496f, -0.18410712f, 0.06187338f, 0.28019291f, 
    0.05883342f, 0.09477142f, 0.09857275f, -0.02121761f, 0.03946013f, -0.00653135f, 0.11233956f, 0.14143842f, 
    0.04692278f, -0.23344755f, 0.10400404f, 0.39669406f, 0.04088501f, 0.03274949f, -0.00778088f, 0.06816065f, 
    -0.07999325f, 0.06106622f, 0.03707634f, 0.18178006f, 0.36023182f, -0.37523061f, -0.00277873f, -0.29731798f, 
    -0.08701330f, 0.16491865f, -0.19947073f, -0.07276320f, -0.11404452f, -0.04777339f, -0.18346623f, -0.03313128f, 
    -0.10227919f, 0.39074963f, 0.26754156f, 0.18461381f, 0.01047555f, 0.21145339f, -0.13719994f, -0.11158546f, 
    0.07880884f, 0.00145661f, -0.08011052f, -0.04675229f, 0.45721048f, -0.04209682f, -0.10870774f, 0.30548790f, 
    0.26507229f, 0.13419312f, 0.22120719f, -0.03399913f, -0.00400888f, -0.06442991f, -0.11105585f, 0.11458737f, 
    0.20028132f, -0.07855973f, 0.04757249f, 0.11918267f, -0.00369798f, -0.11442900f, 0.10571482f, -0.05593079f, 
    -0.05083215f, 0.00333727f, 0.01085789f, 0.10315555f, -0.14597395f, -0.30218941f, -0.02302240f, -0.00825860f, 
    -0.08551035f, -0.07266294f, 0.02834082f, -0.05661229f, 0.13757649f, -0.11376641f, 0.09770620f, 0.12602049f, 
    0.22513226f, 0.11477846f, 0.11860538f, 0.14758748f, 0.07880979f, -0.02654643f, -0.04635897f, 0.07829147f, 
    0.05290347f, 0.01709179f, 0.26204073f, 0.07272371f, -0.85512239f, 0.47266307f, 0.24242051f, -0.03684632f, 
    0.20307426f, -0.04866142f, 0.08133104f, 0.07055325f, -0.16960366f, 0.04533195f, -0.00388047f, 0.01826055f, 
    -0.13059671f, -0.03436733f, -0.00666129f, 0.16609588f, -0.19919354f, -0.05829642f, 0.12637922f, 0.02834414f, 
    -0.18210956f, 0.09440161f, 0.07573213f, 0.14789082f, -0.23502570f, -0.11619619f, -0.01919900f, 0.22483231f, 
    0.15322502f, 0.00501276f, -0.01909875f, 0.13292219f, 0.17447764f, 0.04790283f, -0.01591632f, 0.01585606f, 
    0.08771845f, 0.17046550f, 0.35867098f, 0.32324412f, 0.10110010f, -0.13730170f, -0.14614873f, -0.01998517f, 
    0.04054362f, -0.04680278f, 0.08855847f, -0.13155983f, 0.34987804f, -0.12289336f, -0.11997598f, 0.01883996f, 
    0.13976106f, -0.10292344f, 0.02799128f, -0.08857586f, -0.06700602f, 0.00516135f, 0.11310178f, -0.02173135f, 
    0.08613501f, 0.21795328f, 0.29285556f, -0.22792685f, 0.19637641f, 0.08009475f, 0.13038316f, -0.01701343f, 
    0.03330432f, 0.19602592f, 0.19481415f, 0.01989309f, 0.38321233f, 0.26261455f, -0.47804198f, 0.13159269f, 
    0.01298360f, -0.05098788f, -0.09613681f, 0.04866845f, 0.04055129f, 0.03424475f, 0.24987479f, -0.06784908f, 
    0.22386974f, -0.03636651f, -0.05719994f, 0.05500173f, -0.15340537f, -0.02921584f, 0.01165538f, -0.35261372f, 
    -0.02048651f, -0.21429695f, 0.01771924f, 0.07078392f, -0.07467002f, 0.29799980f, 0.11551363f, -0.16391486f, 
    0.07109328f, -0.16427183f, -0.07882889f, -0.06567822f, -0.05440327f, -0.12881938f, -0.14462665f, 0.22005311f, 
    0.12080067f, 0.20871393f, 0.02160333f, 0.01082704f, -0.17478165f, -0.21369234f, -0.14205743f, 0.00605779f, 
    0.08662233f, 0.01619480f, 0.01309182f, -0.11691325f, 0.31185123f, -0.24055824f, -0.05753483f, -0.11069557f, 
    0.13716634f, 0.07910760f, 0.05542565f, -0.01547923f, -0.12282795f, 0.14055984f, 0.17813256f, 0.08553935f, 
    0.12904032f, 0.14208652f, -0.01122705f, 0.00624474f, 0.11797298f, 0.13599227f, 0.34713250f, 0.30876303f, 
    0.10362767f, 0.04678754f, -0.02476591f, 0.12888511f, -0.20860526f, -0.06563891f, 0.14459682f, 0.04352322f, 
    -0.00216893f, -0.19900694f, 0.05920965f, -0.02775647f, -0.03426414f, -0.05521443f, -0.01299320f, -0.02807659f, 
    0.32192352f, -0.06839161f, 0.11711200f, -0.18290232f, 0.13322410f, -0.05218408f, 0.01076174f, -0.06749540f, 
    -0.13970040f, -0.13115181f, -0.01989520f, 0.02829550f, -0.21677667f, 0.22821625f, 0.07431534f, -0.08900681f, 
    0.04171890f, 0.05597208f, -0.03621925f, 0.02640702f, -0.11584799f, 0.02273243f, -0.13108818f, -0.17489606f, 
    -0.18038927f, 0.22916065f, -0.10634852f, 0.16692752f, 0.04422554f, -0.02844350f, -0.12619796f, -0.01328289f, 
    0.06416951f, 0.08171085f, -0.14302078f, 0.02211491f, -0.02991217f, 0.13317589f, 0.07050265f, -0.11899715f, 
    -0.00606380f, -0.05699389f, 0.03501388f, 0.04938355f, 0.09447789f, 0.06908267f, 0.14647104f, -0.01380995f, 
    0.06866065f, -0.26307660f, -0.28304046f, -0.07939194f, -0.02098255f, -0.03279032f, 0.03637793f, -0.17284337f, 
    0.12007645f, -0.39141405f, -0.10211737f, 0.09642936f, -0.19498724f, -0.13003233f, 0.34177697f, -0.08229920f, 
    -0.03559239f, 0.08566532f, -0.07918645f, 0.04938623f, 0.18741877f, -0.06905731f, 0.00761896f, 0.15213537f, 
    0.14473476f, -0.17784023f, -0.08385289f, 0.21233794f, 0.12527044f, 0.05628710f, -0.06856283f, 0.11456557f, 
    -0.00457960f, 0.24596716f, 0.12669508f, 0.03016339f, -0.02887122f, 0.13835542f, -0.21561407f, 0.31573293f, 
    -0.13019831f, -0.04348119f, -0.09722719f, -0.13729899f, 0.03611529f, -0.17727396f, 0.17588444f, -0.10603490f, 
    -0.24938631f, 0.10314602f, -0.17196183f, 0.07945464f, -0.00162508f, -0.08587072f, 0.07744589f, 0.07545847f, 
    -0.04700828f, 0.03684441f, -0.01157675f, -0.03998495f, -0.27678838f, 0.08648536f, 0.30471489f, -0.00653969f, 
    -0.04764259f, -0.10263427f, 0.19799872f, 0.06394631f, -0.03154044f, 0.25501966f, -0.09238731f, -0.07385825f, 
    0.04102815f, -0.24380988f, -0.19850568f, -0.00151483f, 0.04495755f, 0.19523817f, -0.05447342f, -0.06392147f, 
    0.08812667f, 0.07295246f, 0.03866637f, 0.00315045f, 0.02247047f, -0.02126226f, -0.21189950f, -0.05664982f, 
    -0.05906501f, 0.03407478f, -0.00117498f, -0.14410782f, 0.11690453f, -0.06367955f, -0.02598041f, 0.13135484f, 
    0.02106501f, -0.07913981f, -0.04340224f, 0.07227034f, 0.06940563f, 0.00613254f, -0.06619553f, -0.03905842f, 
    0.02298330f, -0.07363757f, 0.02280268f, -0.12592858f, -0.38722095f, -0.18352278f, -0.28965041f, -0.03289014f, 
    -0.15781166f, 0.20986557f, -0.09778092f, 0.02974378f, 0.08828184f, 0.06087023f, -0.05261391f, 0.14925665f, 
    -0.13754782f, -0.05215832f, 0.10927364f, 0.10773829f, -0.03002503f, 0.13530199f, 0.19389282f, 0.04948299f, 
    0.05588355f, -0.06384940f, 0.16278166f, 0.06613520f, 0.24678789f, 0.13828228f, -0.27585155f, 0.46812481f, 
    0.14100707f, -0.04671708f, 0.07264872f, 0.02531139f, 0.04973144f, -0.08770265f, -0.08848118f, -0.03187093f, 
    0.18260969f, 0.04837556f, 0.00709764f, 0.27921674f, -0.02158269f, 0.10019764f, -0.02725222f, -0.01506531f, 
    0.13318349f, 0.23981498f, 0.01391312f, 0.22662681f, -0.05403794f, -0.32259753f, -0.17316662f, 0.27167904f, 
    0.10520930f, -0.05641026f, -0.19988410f, -0.10072789f, -0.03421330f, -0.03707194f, 0.03213206f, 0.02631599f, 
    0.30521518f, 0.29149327f, 0.04248256f, 0.14304963f, 0.11787347f, 0.04209961f, -0.09698021f, 0.12703642f, 
    0.01861302f, 0.06873770f, -0.06180518f, -0.08011703f, -0.34788826f, 0.38151911f, 0.17773780f, 0.12916487f, 
    0.12510155f, 0.04505650f, 0.16009082f, -0.07189361f, -0.12594652f, -0.02464982f, 0.04859586f, 0.15205242f, 
    -0.01211375f, 0.04238493f, 0.09909536f, 0.25494507f, 0.15036617f, 0.12333437f, 0.04519922f, -0.07115160f, 
    0.09140061f, 0.07532601f, 0.01044504f, 0.14193656f, 0.07118943f, 0.12136112f, -0.00450636f, 0.21126576f, 
    -0.00612295f, 0.09942501f, -0.11089823f, 0.00261685f, 0.17931166f, 0.08545924f, -0.00634007f, 0.10810895f, 
    -0.03208001f, 0.31109393f, 0.50766152f, 0.47161713f, 0.11595128f, -0.16568960f, -0.03143859f, -0.05915368f, 
    0.06285536f, 0.01520040f, 0.09145498f, 0.13118459f, 0.19604385f, 0.03980296f, 0.18640864f, -0.24756089f, 
    -0.04923483f, -0.09602552f, -0.02262395f, -0.08737782f, -0.01756093f, -0.02518138f, 0.08210330f, 0.12702662f, 
    0.45818892f, -0.06167729f, -0.06848431f, 0.10015994f, -0.10981386f, -0.06314929f, 0.08863083f, -0.06368449f, 
    0.11622933f, -0.07755327f, -0.12912427f, -0.03409489f, 0.09773567f, -0.00445128f, 0.11120830f, -0.05054147f, 
    0.04097142f, 0.04336722f, -0.09974940f, -0.08381872f, 0.02464049f, -0.09289324f, -0.11567170f, 0.03101096f, 
    0.27593538f, -0.07487276f, -0.18054278f, 0.02059904f, -0.03946832f, -0.04862984f, 0.05857295f, 0.15563455f, 
    0.01519082f, 0.00945983f, -0.06883852f, 0.16872731f, 0.26148203f, -0.33436593f, 0.27165940f, 0.42285657f, 
    0.16205046f, 0.07669260f, -0.00158186f, -0.12856069f, -0.01551329f, 0.06228618f, 0.09132578f, -0.10254981f, 
    0.01065185f, -0.18456478f, 0.00679324f, 0.42651635f, 0.01296485f, 0.09126634f, 0.02086992f, 0.03064113f, 
    -0.08842796f, 0.13341625f, 0.00831498f, 0.14283761f, 0.60271472f, -0.03647370f, 0.05003752f, -0.08113086f, 
    0.01036798f, 0.06714797f, -0.08430654f, -0.14780766f, -0.08602516f, 0.07712599f, -0.14128499f, -0.04063034f, 
    0.34939188f, 0.28168622f, -0.03747679f, -0.01180672f, -0.17854850f, 0.03629974f, -0.07682753f, -0.10198448f, 
    0.02999302f, -0.08311640f, -0.23921824f, -0.08292790f, -0.08271948f, 0.02620038f, 0.08430609f, -0.18797067f, 
    0.12494167f, -0.00236784f, 0.21338996f, -0.07851032f, 0.03057777f, -0.05680419f, 0.08007883f, 0.22872148f, 
    -0.06399447f, -0.07656882f, 0.05011930f, 0.13390802f, 0.05697697f, -0.13582401f, -0.06355992f, -0.05613573f, 
    0.03899931f, -0.13555685f, -0.04776183f, -0.04758009f, 0.15002760f, 0.10374682f, -0.02527743f, 0.01120465f, 
    0.04496955f, 0.03382167f, 0.01485847f, -0.03981376f, 0.05170675f, -0.07275417f, 0.19843002f, 0.14771082f, 
    0.27698621f, -0.05634283f, 0.07114881f, -0.06666047f, 0.09402113f, -0.17452943f, -0.06993348f, 0.10126400f, 
    0.06185023f, -0.08223293f, 0.34577161f, 0.06041350f, -0.10510950f, -0.04443814f, -0.05304600f, -0.19426426f, 
    0.03753922f, -0.16960990f, -0.08042055f, -0.07665425f, -0.15273304f, 0.20086180f, -0.05241303f, -0.05059987f, 
    0.17797247f, 0.12926154f, -0.00107244f, -0.16171995f, -0.15724356f, 0.04454668f, 0.13543470f, 0.03038892f, 
    -0.14931303f, 0.14658257f, 0.08115926f, -0.14482318f, -0.33195600f, 0.06139164f, 0.12880947f, -0.09962086f, 
    -0.05177662f, -0.02049706f, 0.00034142f, 0.10046206f, 0.03889759f, 0.03999477f, 0.21286649f, -0.01430200f, 
    0.08991312f, -0.03199967f, 0.03498985f, -0.02837479f, 0.01283463f, -0.09589247f, -0.02715450f, 0.06597838f, 
    0.03475244f, -0.01110886f, 0.09918714f, -0.07003460f, 0.21776749f, -0.14417505f, -0.18136758f, 0.38477293f, 
    0.24492356f, -0.14476891f, -0.02729521f, -0.12027261f, -0.13619496f, 0.21923871f, 0.00151706f, -0.05566978f, 
    0.06354874f, -0.02401784f, -0.05105738f, 0.00578160f, -0.03230458f, 0.03198303f, -0.02233330f, -0.00329581f, 
    0.01643622f, -0.00962058f, -0.06074810f, 0.04653136f, -0.01369375f, 0.05144358f, 0.01272448f, 0.05653261f, 
    -0.03515185f, 0.01478070f, -0.04146872f, -0.01143152f, -0.07765346f, -0.06929802f, -0.04228221f, -0.03164378f, 
    -0.00837147f, -0.05847978f, 0.00967349f, -0.04332652f, -0.07127544f, -0.03831995f, -0.04302718f, 0.05812039f, 
    -0.05521390f, 0.03064930f, -0.01340941f, -0.00019952f, 0.05872529f, -0.02340190f, -0.03495511f, 0.00470416f, 
    -0.03676714f, 0.02988074f, -0.04165233f, -0.01155406f, 0.05604931f, -0.03801604f, 0.01399572f, 0.06001581f, 
    0.00866645f, -0.00605202f, 0.02007274f, 0.05362421f, -0.00396922f, -0.03133373f, -0.03378192f, -0.04269977f, 
    -0.03225839f, 0.02366790f, 0.03008076f, 0.03877753f, -0.04917440f, -0.03907109f, -0.06812494f, 0.05615002f, 
    -0.02943747f, -0.04889787f, -0.01500818f, -0.00921962f, -0.06204307f, 0.01177210f, 0.01217420f, -0.07318842f, 
    0.02652903f, -0.04347014f, 0.04937366f, -0.05299542f, -0.00436638f, -0.07878183f, -0.01829076f, 0.02164986f, 
    -0.06068587f, -0.00011767f, -0.02938599f, -0.01126547f, 0.03763548f, -0.03444476f, 0.03041593f, 0.05685157f, 
    -0.05195284f, -0.07969046f, -0.06914251f, -0.07209702f, -0.00246038f, 0.05563225f, 0.01874547f, -0.04608131f, 
    -0.06411077f, -0.01731982f, -0.03274534f, -0.04152755f, -0.02621599f, -0.06967384f, 0.02306801f, 0.00052387f, 
    -0.03516182f, -0.04645104f, 0.04424990f, -0.03251451f, -0.01483515f, -0.02431430f, 0.06397031f, 0.02372581f, 
    -0.02422311f, 0.02710891f, -0.00617864f, 0.05033756f, 0.01641929f, -0.05433650f, -0.05327526f, -0.02066188f, 
    0.03680292f, -0.03023977f, -0.05458658f, -0.04616748f, -0.01836100f, 0.06091349f, 0.02186525f, -0.04274032f, 
    -0.07277759f, 0.03484330f, 0.02315939f, -0.07169615f, 0.00085997f, -0.07419293f, -0.00642731f, -0.06192786f, 
    0.05553041f, 0.04921135f, -0.07490838f, -0.06825957f, 0.01228000f, 0.06125633f, -0.07168933f, -0.00375000f, 
    0.04701594f, -0.04199781f, -0.01111919f, 0.02270990f, 0.02140185f, -0.04209189f, -0.01634753f, 0.05637921f, 
    0.03482288f, -0.03188111f, 0.01008693f, 0.00271805f, -0.05713144f, 0.02482665f, 0.01440072f, -0.06525008f, 
    0.05269081f, -0.07375024f, -0.05443500f, 0.00197510f, -0.00813776f, 0.05610502f, 0.04435417f, 0.02981785f, 
    -0.05123081f, -0.03092872f, -0.03860352f, 0.06629878f, 0.05811223f, 0.00942953f, 0.06173794f, 0.05576989f, 
    0.01116134f, 0.04239302f, 0.01234804f, -0.04712797f, -0.04574409f, 0.02849837f, 0.02345296f, 0.06019585f, 
    -0.05899265f, 0.04667722f, -0.03652149f, -0.01624290f, -0.01243835f, 0.00566236f, -0.04961651f, 0.00606624f, 
    -0.05985259f, 0.02065874f, -0.00350005f, -0.02539584f, -0.05448843f, 0.04751112f, -0.00612071f, 0.00730715f, 
    -0.01003852f, 0.03376002f, -0.00584091f, -0.02084726f, -0.02768905f, -0.03426829f, 0.02947780f, -0.00494104f, 
    -0.05442203f, 0.04096575f, -0.03731009f, -0.01978147f, 0.02766661f, 0.01001163f, 0.00174078f, -0.01065541f, 
    0.03822700f, -0.04531868f, -0.06961168f, -0.01030747f, 0.01496151f, 0.04188653f, -0.00189330f, 0.05175414f, 
    0.01712968f, 0.01881440f, -0.00653889f, 0.05320266f, -0.05834476f, -0.06000824f, 0.03536525f, 0.03798658f, 
    -0.04588662f, -0.07920431f, -0.04349067f, 0.01131635f, -0.06756579f, 0.00805084f, -0.00299546f, -0.04738734f, 
    -0.03786859f, -0.02446328f, -0.03473016f, -0.01609800f, 0.02378853f, 0.05152908f, -0.00039855f, 0.04790213f, 
    -0.00686376f, -0.06448609f, 0.03781598f, -0.02483573f, -0.04196582f, -0.00019387f, -0.04208854f, -0.00077958f, 
    0.01515197f, 0.02713661f, -0.04116189f, -0.04307033f, 0.00596641f, 0.04877703f, 0.04666261f, 0.00879562f, 
    -0.05479415f, -0.05801946f, -0.05757386f, 0.01044853f, -0.04940355f, 0.01079534f, -0.01826392f, 0.04678590f, 
    -0.07127657f, -0.00126810f, -0.07918745f, 0.03571729f, -0.04858753f, -0.03907713f, -0.05756820f, -0.07363439f, 
    -0.06350315f, 0.03563336f, -0.06182291f, 0.02793403f, -0.01938060f, 0.04260046f, -0.04310383f, -0.02493330f, 
    -0.05380494f, -0.04865146f, -0.03673104f, 0.04299328f, -0.06563907f, 0.04112833f, -0.06872965f, -0.07155075f, 
    -0.03358176f, 0.05804215f, -0.05959855f, -0.05307236f, 0.05432201f, 0.00486316f, -0.05110134f, -0.01377536f, 
    0.05570170f, -0.06308331f, 0.05925640f, 0.01557452f, 0.03901971f, -0.01469548f, 0.00382405f, 0.02130842f, 
    0.00628272f, -0.00653447f, -0.06347093f, 0.05303732f, -0.04825174f, -0.06498071f, -0.01239495f, -0.01025733f, 
    0.00285228f, -0.00256317f, 0.03725516f, -0.03603589f, 0.03190027f, -0.07556684f, -0.02356069f, -0.03346328f, 
    -0.00681613f, -0.01901146f, -0.04557807f, -0.04575736f, -0.00199109f, 0.06152400f, -0.00955936f, -0.01108350f, 
    -0.00562451f, -0.05200610f, 0.01358438f, 0.06104177f, -0.00111274f, -0.06566928f, 0.04495370f, 0.03849798f, 
    -0.07626979f, -0.05786962f, -0.01638879f, -0.06711403f, -0.02040518f, -0.04404360f, -0.07519256f, -0.05440214f, 
    0.06226715f, 0.04026983f, -0.06140455f, 0.01371735f, 0.03434379f, -0.03110780f, 0.05584195f, 0.06279401f, 
    -0.05202791f, 0.04089928f, 0.02627441f, 0.00357708f, -0.02150705f, -0.02893995f, -0.01368495f, -0.05447377f, 
    0.04706203f, -0.06890784f, -0.03039747f, 0.02905825f, -0.04260955f, -0.05124828f, 0.02838798f, 0.00202754f, 
    -0.01238543f, -0.05936892f, 0.05805122f, 0.02887011f, 0.00426717f, -0.06394371f, -0.06426130f, -0.01757707f, 
    0.09921069f, -0.07074095f, -0.19499536f, -0.20977356f, 0.01344351f, -0.17817065f, -0.01354144f, 0.02211577f, 
    0.17597735f, -0.07336048f, -0.13557997f, 0.07535775f, 0.38191262f, -0.44310164f, -0.14584410f, 0.05274974f, 
    0.10672946f, 0.20422836f, 0.11670832f, 0.15577349f, 0.10523584f, -0.16987272f, 0.06981973f, 0.16032232f, 
    -0.36564812f, 0.07935846f, 0.09100767f, 0.17566425f, -0.02269978f, 0.06294837f, 0.02588815f, -0.04599420f, 
    -0.07028767f, 0.13618180f, 0.06462700f, 0.13179712f, -0.29531893f, 0.25338009f, 0.31147575f, -0.08441862f, 
    0.21815750f, 0.01122501f, -0.00875350f, -0.11155423f, -0.05585773f, -0.02793951f, -0.02142652f, 0.01026305f, 
    -0.18508969f, 0.13599595f, 0.13483775f, -0.15169242f, 0.08007538f, 0.13957083f, -0.00869278f, -0.08760509f, 
    -0.01709860f, 0.08781878f, 0.08672301f, 0.20279539f, 0.18787083f, 0.05215517f, 0.22866379f, 0.24567685f, 
    -0.12892596f, 0.14843921f, 0.01878739f, -0.12752615f, 0.20683788f, -0.24007598f, -0.09901510f, 0.04381176f, 
    -0.00177570f, -0.09464861f, -0.20351914f, 0.28645125f, -0.09846498f, -0.09221521f, -0.16379572f, 0.00390310f, 
    -0.05982067f, -0.00769990f, 0.07735178f, -0.02440349f, -0.20029107f, -0.05308382f, 0.06185313f, 0.00696252f, 
    0.32278579f, -0.08568356f, 0.04192606f, 0.08259851f, 0.08042245f, -0.02938956f, 0.10504137f, 0.30741477f, 
    -0.54574746f, 0.08166565f, 0.37505656f, 0.12503700f, 0.03337446f, 0.06278674f, 0.07577007f, -0.10707493f, 
    0.15552756f, -0.01592819f, -0.00489957f, -0.08757584f, -0.22069152f, -0.11545856f, 0.08453930f, 0.05254452f, 
    0.13706946f, 0.02212871f, 0.03520674f, -0.17251381f, 0.09740542f, -0.00175656f, 0.07297035f, 0.05272974f, 
    -0.12399995f, -0.01467959f, 0.08102904f, -0.28376645f, -0.13290694f, -0.02158651f, 0.06663280f, -0.01093391f, 
    0.00721184f, 0.03221142f, 0.20816958f, 0.08245046f, 0.07945419f, -0.45496184f, -0.29917786f, -0.11110606f, 
    0.14322954f, 0.00805016f, 0.07015663f, 0.04699344f, -0.05536102f, 0.04839227f, 0.11180066f, -0.01376028f, 
    0.27413982f, -0.04310453f, 0.12153682f, -0.03814978f, -0.19665471f, 0.01090491f, 0.21481846f, 0.12413256f, 
    -0.07355602f, 0.28130502f, -0.06118904f, -0.15005095f, -0.24561544f, 0.01363364f, 0.01383430f, 0.19508542f, 
    0.03893171f, 0.09922097f, -0.03608077f, 0.26883337f, 0.17838199f, 0.05048414f, 0.11879472f, -0.18140243f, 
    0.52685720f, 0.01149805f, -0.34226987f, -0.04864221f, 0.02278111f, 0.10495938f, 0.16354734f, -0.03797034f, 
    0.00422508f, -0.00519124f, 0.14071813f, 0.17078680f, -0.23593852f, 0.01173281f, 0.30719194f, -0.05062807f, 
    0.03547800f, -0.02719090f, 0.07928042f, -0.24229030f, -0.09335953f, 0.32584816f, -0.13917933f, 0.10842627f, 
    -0.02559915f, -0.01936818f, 0.00679724f, -0.02623593f, -0.04522650f, -0.07581520f, 0.02650212f, 0.04399999f, 
    -0.03457564f, 0.03148497f, -0.04770254f, 0.04214297f, -0.03410677f, 0.05076754f, 0.00241327f, 0.04910931f, 
    -0.00067314f, 0.00548988f, -0.06529405f, -0.01519892f, -0.03016891f, 0.04421679f, 0.01099464f, -0.00104918f, 
    -0.00125307f, -0.04703775f, -0.03453729f, -0.07778803f, -0.02103766f, -0.03969324f, 0.02081694f, -0.06382532f, 
    0.03511364f, -0.02262475f, 0.02650007f, 0.04468856f, -0.00646947f, 0.02797875f, 0.03503405f, -0.05609498f, 
    -0.05955424f, -0.00945078f, 0.00707088f, 0.04704293f, -0.05262953f, 0.06291296f, -0.01544635f, 0.06610021f, 
    0.05297031f, -0.04489224f, -0.03905392f, -0.06759395f, -0.07310167f, 0.02003585f, -0.05570155f, 0.06864143f, 
    -0.03502127f, -0.04488981f, -0.07343224f, 0.00394962f, -0.00375669f, 0.04515805f, -0.00954953f, -0.06051615f, 
    -0.04896474f, -0.06401685f, -0.01467535f, -0.07185938f, -0.03864155f, -0.07844032f, -0.00689418f, 0.02967978f, 
    0.03266567f, 0.04205456f, 0.02424853f, -0.02332824f, 0.05639311f, -0.06936488f, 0.02921247f, 0.03968994f, 
    -0.01004267f, 0.04457018f, -0.00604960f, 0.02387667f, -0.05771781f, -0.05042182f, 0.02343862f, -0.07967720f, 
    -0.06239615f, -0.04063701f, -0.06546508f, -0.06902984f, 0.03367346f, 0.02890463f, 0.01067029f, -0.06803402f, 
    -0.01159954f, -0.03153748f, -0.02199622f, 0.04484157f, 0.01480354f, -0.02469268f, -0.00888847f, 0.02237673f, 
    -0.05765365f, -0.07929868f, -0.06565488f, -0.00650510f, -0.06154533f, -0.00044270f, 0.05031247f, 0.06897092f, 
    0.03837043f, 0.02697561f, -0.07020781f, -0.00485083f, -0.00897430f, -0.00766329f, -0.07868610f, -0.05617735f, 
    -0.03781157f, -0.07485463f, -0.03175383f, 0.01385203f, -0.05874361f, -0.00867464f, -0.04055464f, 0.00978562f, 
    -0.05684736f, -0.05594498f, -0.02257645f, -0.05402908f, -0.05172871f, -0.04406239f, -0.04876366f, 0.06089348f, 
    0.06144281f, 0.04590322f, -0.01688217f, -0.03306588f, -0.01871901f, -0.04624001f, 0.03747071f, 0.00419552f, 
    -0.03983087f, 0.01123855f, -0.03956138f, 0.04802834f, 0.00759839f, 0.03074327f, 0.01417263f, -0.00997955f, 
    -0.06029922f, -0.05103535f, -0.00078038f, 0.06606398f, 0.00271522f, 0.05851823f, -0.03788523f, -0.02187894f, 
    -0.04347560f, 0.03730144f, 0.01239650f, 0.00601422f, 0.01680243f, -0.06790306f, 0.03237423f, 0.05944709f, 
    -0.00964911f, 0.05962623f, -0.07974574f, -0.08066025f, -0.03312824f, 0.04466549f, 0.04052633f, -0.03290343f, 
    -0.06374845f, -0.04089138f, 0.02122295f, -0.07238816f, 0.01815074f, 0.05641206f, 0.00245655f, 0.01397438f, 
    0.03025316f, 0.06271303f, 0.02952441f, 0.04865946f, 0.00694356f, 0.02739123f, -0.05248963f, -0.01975490f, 
    -0.39713052f, 0.53941292f, 0.06150298f, -0.13566361f, 0.19041577f, 0.13537627f, -0.08455735f, -0.03988408f, 
    -0.02711639f, 0.03500533f, 0.10362178f, -0.11501251f, -0.11333977f, 0.13498591f, -0.09992979f, 0.02526692f, 
    0.19013539f, -0.06088606f, -0.10918676f, 0.09750262f, 0.12669417f, 0.00678413f, 0.07681689f, 0.02559713f, 
    0.34299269f, -0.23479523f, 0.05090581f, -0.14954469f, -0.06863401f, -0.10041757f, -0.01065103f, -0.09865426f, 
    -0.09699177f, 0.00252500f, -0.05576944f, -0.04388152f, -0.08334871f, 0.42613035f, -0.18155284f, -0.09666505f, 
    0.05051634f, 0.09666511f, 0.17307836f, 0.17229792f, -0.07284273f, 0.16544701f, -0.00389561f, 0.09698879f, 
    -0.04413988f, -0.05876454f, 0.00382881f, -0.43575361f, -0.18116771f, -0.03583670f, 0.01920565f, 0.05464801f, 
    0.01374042f, -0.10805622f, -0.11233378f, -0.04011088f, 0.27596083f, -0.10407402f, 0.11685961f, -0.07800080f, 
    -0.03615533f, -0.03492326f, -0.17237286f, 0.10923939f, 0.00113100f, 0.04473775f, -0.02473851f, 0.04339209f, 
    -0.02000160f, -0.04495545f, 0.06751935f, -0.18643481f, 0.25118813f, 0.35211387f, 0.08305828f, 0.09631386f, 
    -0.12778036f, 0.00607915f, 0.07529234f, 0.04937933f, 0.19653372f, -0.08902660f, 0.04923533f, 0.12140446f, 
    0.11622324f, -0.02185085f, 0.16484086f, 0.10104308f, -0.13223659f, -0.02440869f, 0.03852911f, 0.01547819f, 
    0.67207485f, 0.02160606f, -0.01317548f, -0.04303844f, -0.08177631f, -0.03759694f, -0.02930064f, 0.18968825f, 
    -0.18165070f, -0.06211322f, -0.01500507f, 0.00916128f, -0.09040372f, 0.10356129f, 0.11115331f, -0.10731682f, 
    -0.18407854f, 0.09876531f, 0.10814754f, 0.18814866f, -0.04485420f, 0.10383845f, -0.07263729f, -0.02363844f, 
    0.10038834f, 0.27363724f, 0.06921638f, 0.13495159f, 0.02685466f, 0.07027995f, 0.05152071f, 0.01049501f, 
    -0.17272474f, -0.05397626f, -0.03249342f, -0.13558991f, -0.54398584f, 0.37964153f, 0.26847807f, 0.10156826f, 
    0.05704418f, 0.01723605f, -0.08186704f, 0.02235286f, -0.04574517f, -0.00790889f, 0.06750084f, 0.17031737f, 
    -0.25889993f, -0.11833848f, -0.07620396f, -0.03639983f, 0.12833384f, -0.07384813f, 0.10143850f, -0.12239073f, 
    0.06780121f, -0.11946615f, -0.06392416f, 0.10286022f, -0.32207450f, -0.18877761f, 0.33264557f, 0.12593277f, 
    -0.01107308f, 0.23071705f, -0.07238135f, 0.09082771f, 0.17525563f, 0.04271971f, 0.04663866f, 0.02649075f, 
    0.05249514f, -0.17390609f, 0.09382248f, 0.32230842f, -0.01363156f, -0.02730335f, -0.05230567f, 0.11052990f, 
    -0.04630595f, 0.03057887f, 0.04745200f, 0.05272041f, -0.07981058f, -0.03310982f, 0.09100109f, 0.06894766f, 
    0.07725819f, 0.07356764f, 0.07063032f, -0.09837451f, 0.18583930f, -0.19039229f, -0.03303701f, -0.01734559f, 
    0.06289513f, -0.18063685f, -0.11308334f, 0.07156771f, 0.05689131f, 0.10814244f, 0.09925490f, 0.03183971f, 
    -0.08420683f, -0.09119660f, 0.07071973f, 0.00671526f, 0.21987543f, 0.25210395f, 0.02404231f, 0.20292477f, 
    -0.17767549f, -0.06985865f, -0.00085589f, 0.24642597f, -0.13467340f, 0.08945295f, -0.15094964f, -0.08371494f, 
    -0.25328887f, -0.40653962f, 0.01363472f, -0.12671606f, 0.03332201f, 0.19376142f, -0.07788643f, -0.11990716f, 
    0.08121328f, 0.08704571f, 0.00529157f, -0.00739773f, -0.09579889f, -0.27355415f, -0.22508003f, -0.18768953f, 
    0.02909051f, -0.06342752f, 0.04213365f, 0.08066071f, 0.03858773f, -0.07093559f, -0.00820389f, -0.03824940f, 
    -0.16175617f, -0.35025346f, -0.00300821f, 0.12843505f, 0.22573884f, 0.06205423f, -0.02983939f, 0.03412194f, 
    0.00447644f, 0.01173164f, 0.01791313f, -0.25580662f, -0.43096888f, -0.36568904f, 0.10835952f, -0.06545567f, 
    -0.02731895f, 0.16434015f, 0.24712864f, 0.06174100f, 0.04996256f, 0.06636163f, 0.13302734f, 0.01930349f, 
    0.04980623f, 0.10076234f, 0.33442307f, 0.22048548f, -0.20492972f, -0.09326629f, 0.01222091f, 0.03939934f, 
    0.00776873f, 0.17037986f, 0.18915191f, 0.00567545f, 0.36482826f, -0.26850083f, 0.32050031f, 0.23232420f, 
    0.03824741f, 0.05004403f, 0.09834541f, 0.04232503f, 0.14336102f, 0.12521791f, -0.07709832f, 0.13759546f, 
    -0.10364733f, -0.22493125f, 0.04113480f, 0.00560311f, -0.01339696f, 0.10752133f, 0.17163303f, 0.02840407f, 
    0.06855895f, 0.14329396f, -0.03576515f, 0.18900932f, -0.45087996f, -0.50808054f, -0.04470709f, -0.11682972f, 
    -0.04838615f, 0.04713675f, -0.16756073f, 0.07947958f, 0.11988898f, -0.05801841f, 0.00555890f, -0.07056677f, 
    0.38891515f, -0.15836325f, -0.12453911f, 0.18861566f, 0.10957232f, 0.00021855f, -0.03610382f, -0.01524193f, 
    0.04512871f, 0.10008401f, -0.00155849f, 0.00490575f, 0.08011104f, 0.09028049f, 0.02910984f, 0.21603762f, 
    -0.00361232f, -0.07597860f, 0.06993061f, 0.08249468f, -0.05372563f, -0.07870971f, -0.03482302f, 0.09201696f, 
    -0.03362630f, 0.11590274f, -0.05010666f, 0.20756671f, -0.06299379f, 0.01423514f, 0.00085270f, -0.11223847f, 
    -0.13091531f, -0.06738788f, -0.08803996f, 0.20746469f, 0.41675389f, -0.10417680f, 0.11218133f, 0.39757237f, 
    -0.06822104f, -0.12823184f, 0.09830317f, 0.02585194f, -0.15175095f, -0.06351483f, -0.06117253f, 0.04417851f, 
    -0.05948699f, 0.44648176f, 0.37079719f, -0.11858958f, 0.08629806f, 0.08204222f, 0.12149406f, 0.09982701f, 
    0.01354451f, 0.17499745f, 0.00582956f, 0.21175165f, 0.11660674f, -0.21215999f, -0.25242135f, -0.08087597f, 
    0.12802346f, -0.01759439f, 0.03127297f, 0.17590800f, 0.17499813f, -0.09231825f, 0.00628644f, 0.00917568f, 
    0.04946074f, 0.02726096f, 0.00518779f, -0.06295635f, -0.03536794f, -0.06277993f, -0.01580230f, -0.02828887f, 
    0.01180475f, 0.02074592f, -0.02617170f, 0.05321667f, -0.03128101f, -0.04203178f, 0.06030807f, 0.05092757f, 
    -0.03424690f, -0.00744901f, 0.03880822f, -0.00659145f, -0.05255199f, 0.04825186f, 0.02790686f, -0.05485748f, 
    -0.02756756f, 0.02211240f, -0.05717010f, -0.07254682f, -0.02873505f, -0.05500461f, 0.03502019f, -0.01470524f, 
    0.01010185f, 0.05406333f, -0.06676658f, 0.01306346f, -0.01208040f, 0.00778889f, 0.01686864f, 0.04468276f, 
    -0.02057935f, 0.04181416f, -0.05443003f, 0.01140088f, 0.01358106f, 0.05636270f, -0.01324459f, 0.00702147f, 
    0.03727853f, -0.00740318f, -0.04360232f, -0.07595460f, 0.04577420f, 0.02901892f, -0.01280270f, -0.02937642f, 
    -0.00914413f, -0.01132793f, -0.03263692f, -0.02955517f, -0.05459268f, 0.00965225f, 0.02896542f, -0.01949883f, 
    -0.06387796f, -0.03433158f, -0.01295318f, -0.00000473f, -0.00507638f, -0.02548199f, 0.03553133f, 0.00538129f, 
    -0.00628474f, 0.04728344f, 0.00430117f, 0.02550463f, -0.07373403f, -0.07278589f, 0.03424948f, -0.00239446f, 
    -0.01755487f, 0.02677608f, -0.01256833f, -0.07345460f, 0.00417802f, 0.02907988f, -0.01554377f, -0.01567570f, 
    -0.01335183f, -0.00356961f, -0.05134954f, -0.07051106f, 0.02914154f, 0.03535956f, -0.05715837f, -0.01552041f, 
    -0.00073497f, 0.03492840f, 0.03467081f, -0.01727650f, 0.05988303f, 0.03200032f, -0.07261953f, 0.02326780f, 
    -0.03169168f, -0.06541521f, -0.00467528f, 0.02715006f, 0.01007102f, -0.02668905f, 0.02217199f, 0.05412611f, 
    0.02995409f, 0.02040098f, -0.00890487f, 0.02240981f, 0.02707563f, 0.01607108f, 0.00440582f, 0.02816980f, 
    -0.02372346f, -0.03914398f, 0.01987096f, 0.04274761f, 0.05922015f, 0.00806644f, 0.05410149f, -0.04055200f, 
    0.00271803f, -0.04976738f, -0.01149334f, 0.02755014f, -0.04428155f, 0.03917001f, -0.06999023f, -0.00368808f, 
    0.06283669f, 0.05556843f, -0.07228561f, 0.00622248f, -0.04671258f, -0.06856980f, 0.00369894f, -0.06838911f, 
    -0.06629413f, -0.06097355f, -0.04816838f, 0.03788310f, 0.03713056f, 0.01148173f, -0.04664053f, -0.02646086f, 
    0.06261663f, -0.01824727f, -0.02463147f, -0.04937492f, 0.03024014f, -0.00042194f, -0.03571130f, -0.07621652f, 
    -0.05446282f, -0.02629508f, 0.03931992f, 0.01697492f, 0.02019924f, -0.05568034f, 0.02241297f, -0.06392308f, 
    0.05595593f, -0.03893276f, 0.00173227f, -0.01970172f, 0.01615527f, 0.03712535f, 0.03377485f, -0.06774832f, 
    0.00675155f, -0.00856158f, 0.06351860f, -0.07812736f, -0.03381546f, -0.06356391f, 0.03163978f, -0.00064839f, 
    -0.05413553f, -0.04176008f, -0.01744827f, 0.03381262f, -0.07290351f, -0.01067560f, -0.04679523f, -0.07335967f, 
    -0.13374469f, -0.01401908f, 0.06870465f, 0.09959938f, 0.00292070f, 0.01249055f, 0.38778940f, 0.28673297f, 
    0.18324362f, -0.00863066f, 0.01706032f, -0.01385992f, -0.16655999f, 0.02317796f, 0.16980411f, -0.16753024f, 
    0.01867638f, 0.08949398f, 0.11828384f, -0.05068879f, 0.11827996f, -0.03448236f, 0.21336387f, -0.00252933f, 
    -0.08943807f, 0.55445880f, -0.05789246f, 0.00816273f, 0.16629460f, -0.01504458f, -0.11912140f, 0.05861246f, 
    0.00975817f, -0.08426486f, 0.07866431f, 0.05338823f, -0.75438768f, -0.38636738f, -0.21877369f, -0.29171371f, 
    0.12388601f, 0.08535986f, 0.02041853f, -0.15523334f, 0.05605939f, -0.06952933f, -0.02100673f, -0.05380924f, 
    0.50902367f, 0.39619678f, -0.12532954f, -0.15269242f, -0.08237764f, -0.06941000f, 0.06090225f, 0.05444489f, 
    -0.08960054f, -0.11926841f, -0.02191343f, 0.14920987f, -0.27889669f, 0.14570749f, -0.12353664f, 0.08706078f, 
    0.01876507f, -0.06469916f, 0.13083056f, 0.01419961f, 0.07271475f, -0.12760293f, 0.03871812f, -0.04702231f, 
    0.10948411f, 0.20668089f, -0.04468744f, 0.20260145f, 0.03533579f, -0.01480224f, -0.02872964f, -0.05819369f, 
    0.03146651f, -0.06467820f, 0.02841246f, -0.09666871f, 0.00547894f, 0.05974649f, -0.00883126f, 0.35956910f, 
    -0.15167673f, -0.03757600f, -0.17484905f, -0.31638232f, 0.04946132f, 0.08614457f, -0.11748097f, -0.23116662f, 
    -0.20810689f, 0.24524242f, -0.01218828f, 0.15550055f, -0.00786585f, 0.00135800f, 0.12263761f, -0.06503770f, 
    -0.05309000f, 0.09139640f, 0.07796248f, -0.07614732f, 0.01583562f, -0.01831295f, -0.11422939f, 0.05979959f, 
    0.15887059f, 0.05446968f, -0.03701363f, 0.01203211f, -0.04606878f, 0.22086774f, -0.06982730f, 0.04567065f, 
    -0.32971129f, 0.32000378f, 0.17309013f, -0.10548101f, 0.14556946f, 0.14090137f, -0.11581767f, 0.03465432f, 
    -0.03805768f, 0.06595384f, -0.01122198f, 0.05009169f, 0.42214277f, -0.01830024f, 0.31791857f, -0.01236015f, 
    0.06350628f, 0.07336318f, 0.06575094f, 0.06264891f, 0.01391062f, -0.10515736f, 0.17858565f, -0.06496162f, 
    0.29761520f, 0.12862520f, -0.03467838f, 0.00727092f, 0.10555609f, -0.02798737f, 0.02101618f, 0.15122916f, 
    -0.08689789f, 0.03203753f, -0.00268273f, 0.10604069f, 0.28060967f, 0.01628192f, -0.19037974f, 0.29825902f, 
    0.14162295f, 0.17277925f, -0.00282733f, -0.26743746f, 0.05350566f, -0.06329832f, -0.01940777f, -0.03744593f, 
    0.43331692f, -0.08525492f, -0.22358212f, 0.04994366f, -0.01724511f, 0.03407754f, 0.10251936f, -0.05169135f, 
    -0.06278645f, -0.02164510f, 0.08478779f, 0.01368004f, -0.42835495f, 0.10043319f, 0.18679677f, -0.51175117f, 
    -0.12655124f, 0.04566148f, -0.14432624f, 0.16307428f, 0.04501161f, -0.00214499f, 0.03140983f, -0.04542476f, 
    0.27934527f, -0.30951437f, 0.34299582f, -0.23970518f, -0.11170354f, 0.21010195f, 0.07690097f, 0.07767733f, 
    -0.07122091f, 0.00412788f, 0.02432416f, 0.09409741f, -0.12521073f, 0.35202342f, -0.31939510f, -0.00189813f, 
    0.00983213f, -0.00823891f, -0.00286350f, 0.09245261f, 0.05719800f, 0.06788088f, -0.11099163f, -0.04378891f, 
    -0.16469851f, -0.01654434f, -0.00264597f, 0.07930002f, -0.16451582f, -0.03194132f, 0.11070126f, 0.00507548f, 
    0.23237918f, 0.04039310f, 0.14672808f, -0.01215668f, 0.36367756f, -0.34115085f, 0.09856931f, 0.34354576f, 
    -0.08417149f, -0.12415330f, 0.09701052f, 0.00041283f, 0.06777906f, 0.08189655f, 0.10267232f, 0.11136122f, 
    0.31388268f, 0.04821643f, 0.40146190f, 0.50366467f, 0.00161848f, 0.02366878f, 0.03451042f, 0.03323699f, 
    0.15301888f, -0.07680205f, 0.11725961f, 0.01966549f, -0.23183486f, -0.18794581f, 0.06947405f, -0.22949453f, 
    -0.02141109f, 0.16542514f, 0.22001575f, -0.03520575f, -0.08608418f, 0.13983066f, 0.23808579f, 0.03305046f, 
    -0.14201687f, -0.02949155f, 0.16145036f, -0.20415084f, -0.04153231f, -0.06671643f, 0.13253726f, 0.10918558f, 
    0.10478591f, 0.12272688f, 0.09110956f, 0.10424282f, -0.02719727f, -0.54102755f, -0.02897227f, -0.05072966f, 
    0.05513256f, 0.16359583f, 0.11063918f, 0.09606154f, 0.02053133f, 0.06397796f, -0.08169141f, -0.06930313f, 
    -0.03567315f, -0.04672198f, 0.07722992f, 0.04936394f, 0.15650463f, -0.11533698f, 0.24219827f, 0.05375997f, 
    0.07668483f, -0.05537825f, 0.00767330f, 0.10615899f, -0.20816775f, 0.14518635f, 0.32232532f, -0.10444352f, 
    -0.22443059f, -0.07556194f, 0.05139123f, 0.10285363f, 0.07345875f, -0.06101782f, -0.03493233f, -0.00507916f, 
    0.05357514f, -0.06457223f, 0.02098243f, 0.21683852f, 0.10512637f, 0.14345416f, 0.06164851f, -0.00312789f, 
    0.20634364f, -0.00444586f, -0.17056327f, 0.15756802f, -0.10997046f, 0.07178457f, 0.07223829f, -0.09212276f, 
    0.05146532f, 0.02454788f, 0.12755693f, 0.13227981f, 0.01095966f, -0.04501253f, -0.03487472f, -0.05864938f, 
    -0.22109599f, 0.10188847f, -0.22099042f, 0.07050210f, -0.02870191f, 0.03105353f, -0.02711673f, 0.05742892f, 
    -0.07912916f, -0.15307006f, 0.02416091f, 0.05698580f, 0.18965638f, -0.25270808f, -0.27134565f, -0.26827586f, 
    0.00140300f, -0.17991073f, 0.34413999f, 0.03655843f, -0.06741812f, -0.02803311f, -0.02603026f, 0.03127567f, 
    -0.26499009f, 0.30612826f, 0.12529780f, 0.02289636f, 0.19529077f, 0.01140506f, 0.05574173f, 0.15710808f, 
    -0.04055766f, -0.00592427f, 0.10139988f, 0.11608349f, 0.39626163f, 0.23164897f, -0.27870503f, 0.12517884f, 
    -0.05118348f, 0.21208474f, 0.08637396f, 0.03311348f, 0.03168006f, -0.00837972f, 0.07610030f, -0.05680081f, 
    -0.07336642f, -0.05718231f, 0.05712359f, -0.06328252f, 0.00977738f, 0.02210218f, -0.01348768f, 0.02735218f, 
    -0.00456465f, 0.03303043f, 0.02132758f, -0.05753681f, 0.02041050f, 0.00715484f, 0.04772768f, -0.05119595f, 
    -0.04889474f, -0.04623580f, -0.00538680f, -0.01166192f, -0.00970274f, -0.01179137f, 0.03454204f, 0.00368066f, 
    -0.03925156f, -0.06710769f, -0.07662761f, 0.03284389f, 0.02984684f, 0.05041156f, -0.06493532f, -0.05895734f, 
    0.02830353f, -0.00605771f, -0.06407277f, -0.05810636f, -0.00908664f, 0.01431340f, -0.05516619f, 0.02683270f, 
    0.01328814f, -0.07162238f, 0.02085453f, 0.03439017f, -0.04234120f, -0.04644656f, -0.03830487f, -0.00240818f, 
    0.01651147f, -0.02133732f, 0.04918582f, -0.02142457f, 0.06885903f, 0.02948267f, -0.03676027f, 0.05188082f, 
    -0.01354510f, 0.02475677f, -0.06484149f, 0.02340858f, 0.04947077f, -0.02485413f, -0.00070825f, -0.08682792f, 
    -0.04081265f, -0.05752844f, -0.01278602f, 0.02619524f, -0.03752004f, 0.04983857f, -0.04130659f, 0.01474992f, 
    -0.01577820f, -0.00298740f, -0.07193269f, -0.05917336f, -0.06774049f, 0.05956317f, 0.01690640f, 0.05396391f, 
    -0.01723839f, 0.05414342f, -0.04988051f, -0.00184951f, 0.03653802f, 0.02338311f, -0.08180096f, -0.06451149f, 
    0.00234011f, -0.00618400f, -0.04021606f, 0.00771111f, -0.00212161f, 0.04282923f, -0.06859872f, -0.03031613f, 
    -0.00247402f, -0.06356536f, 0.01210456f, 0.06839682f, 0.01234056f, 0.06451245f, 0.05913959f, -0.06485359f, 
    -0.03861184f, 0.01236171f, -0.00838822f, -0.01530460f, 0.06236386f, 0.03257374f, -0.06765858f, -0.08488537f, 
    0.02935937f, -0.03550198f, 0.01823770f, -0.06404521f, -0.08281620f, 0.00725372f, 0.04787502f, 0.06642562f, 
    0.03081089f, -0.05497191f, -0.00900000f, 0.05843215f, -0.03560636f, -0.06463194f, 0.00481284f, -0.01877304f, 
    0.02987714f, 0.05081059f, -0.07047222f, 0.03046235f, 0.05438956f, -0.02382409f, 0.02803184f, 0.05387235f, 
    -0.07374566f, 0.03447739f, 0.00590974f, 0.02320693f, -0.00305911f, -0.01240221f, 0.05814343f, -0.06637441f, 
    -0.04172570f, -0.01517657f, 0.02797054f, -0.04794177f, 0.00612638f, -0.05592892f, -0.06051749f, -0.03609047f, 
    -0.05977103f, -0.04897942f, -0.00661586f, 0.02766796f, 0.00164554f, -0.01035999f, -0.06389692f, 0.02301660f, 
    0.04253163f, 0.02229763f, 0.00286068f, 0.05196180f, -0.05555138f, 0.05784446f, -0.00279854f, -0.00770497f, 
    -0.00160379f, -0.04722959f, -0.02151079f, -0.05635680f, -0.05529855f, -0.02155110f, 0.06452854f, -0.04292256f, 
    -0.06791572f, -0.01651493f, -0.00173331f, -0.07477788f, 0.03861228f, 0.02163720f, -0.01921672f, 0.04196137f, 
    0.02502620f, -0.03766873f, 0.00754753f, -0.01309609f, -0.05656951f, 0.00368757f, -0.05640906f, -0.01006769f, 
    -0.07436969f, 0.02192364f, -0.02625047f, -0.04986350f, -0.02372762f, -0.00157050f, 0.03747148f, 0.04424879f, 
    -0.04699560f, -0.04682687f, -0.05400169f, 0.01396238f, 0.04841309f, -0.03903249f, -0.06074745f, 0.06465434f, 
    -0.03266197f, -0.01954718f, -0.00529537f, 0.03813701f, 0.06287161f, 0.04359371f, -0.05031650f, -0.07308612f, 
    -0.01559906f, 0.02941825f, -0.02953940f, 0.05304035f, 0.00137442f, -0.02834876f, -0.03385243f, -0.07956189f, 
    0.01508793f, -0.05039670f, -0.04635633f, 0.04537094f, -0.02998382f, 0.02583645f, -0.07297754f, -0.00586505f, 
    -0.00652526f, 0.01800785f, 0.00226442f, -0.01118609f, 0.01359912f, -0.01634075f, -0.03720422f, -0.08070809f, 
    0.02716108f, 0.04011256f, -0.03559965f, -0.02103878f, -0.03508337f, -0.01680804f, 0.00434019f, 0.00930567f, 
    0.04076388f, -0.03112589f, -0.07765096f, -0.04024309f, -0.04526215f, -0.04497410f, -0.01247151f, 0.01707206f, 
    0.03925577f, 0.02444889f, -0.06623001f, -0.09076069f, 0.04603668f, -0.03382657f, -0.00914791f, -0.04747297f, 
    -0.06604337f, -0.03760345f, -0.01397685f, 0.02697707f, -0.05469259f, -0.06905740f, -0.01844545f, -0.02151962f, 
    -0.00939313f, 0.02534978f, -0.06954554f, 0.04671282f, -0.05816556f, 0.02679346f, -0.04601145f, -0.06382273f, 
    -0.02785974f, -0.00124495f, 0.04459337f, 0.00262756f, -0.04527022f, 0.03249551f, -0.03637452f, -0.00600263f, 
    0.01971187f, -0.06583075f, -0.00434321f, -0.01951875f, 0.02700342f, -0.00019024f, -0.02481730f, 0.02488408f, 
    0.01984006f, 0.05922524f, 0.01120075f, 0.03840793f, -0.06996792f, -0.05566172f, 0.02267972f, 0.00491494f, 
    -0.01165841f, -0.08913425f, -0.03763317f, -0.05224157f, -0.06251275f, 0.03525333f, 0.02938041f, 0.01938025f, 
    0.02262883f, 0.04859637f, 0.00398073f, -0.02701321f, 0.01819541f, -0.02182410f, -0.02403896f, 0.05969782f, 
    -0.02778671f, 0.00572857f, 0.03272266f, 0.02621244f, -0.03773391f, -0.06937475f, -0.07575933f, 0.02602692f, 
    -0.07599831f, 0.01989083f, -0.00119902f, -0.04130848f, -0.05283262f, 0.00287321f, 0.04596174f, -0.01231243f, 
    0.01421101f, -0.04243113f, 0.04096646f, 0.00012208f, 0.05386801f, 0.01369845f, -0.04502456f, -0.06250457f, 
    0.01982102f, -0.03197058f, -0.04654669f, -0.05322240f, -0.02563560f, -0.01056554f, -0.04839068f, 0.05598072f, 
    0.05978907f, 0.06253800f, 0.06102786f, 0.06142570f, 0.06269690f, 0.00845208f, -0.01937979f, -0.06059734f, 
    -0.06597004f, -0.06396460f, 0.06884068f, -0.02953115f, 0.06000284f, -0.01654167f, -0.05857877f, 0.05859436f, 
    -0.06832714f, 0.05963003f, 0.04368955f, 0.06026310f, -0.06318827f, 0.02107192f, 0.02849432f, -0.06280353f, 
    -0.02512665f, -0.02281169f, -0.00221470f, -0.05988574f, 0.01365075f, 0.03678454f, -0.03796157f, -0.05452526f, 
    -0.11337896f, 0.45928809f, -0.01858681f, 0.11722267f, 0.32709005f, 0.11000694f, 0.04565073f, 0.04283525f, 
    0.08155645f, 0.10648956f, 0.31918883f, -0.06115669f, 0.50230354f, -0.08236904f, -0.01605717f, 0.16358618f, 
    -0.01627309f, -0.04494589f, 0.00657467f, 0.09219491f, -0.05031448f, 0.06645391f, 0.12910992f, -0.05435520f, 
    0.01993835f, -0.04038509f, -0.01542696f, -0.19335051f, 0.02780333f, 0.06514026f, -0.03258617f, -0.25595483f, 
    0.02358406f, -0.02953157f, 0.07824932f, -0.00565184f, -0.06001068f, 0.45947587f, -0.29036188f, -0.29271862f, 
    0.26939049f, -0.12527099f, 0.09176450f, -0.00743599f, 0.00158710f, 0.13897301f, -0.08287521f, 0.05169101f, 
    -0.27475369f, -0.00398292f, -0.23558500f, -0.25705040f, 0.06985376f, -0.03908760f, -0.17006774f, -0.14060107f, 
    0.04524738f, -0.07554179f, -0.17196690f, -0.25335288f, -0.05430072f, -0.10381181f, -0.13240303f, 0.00283166f, 
    0.04932399f, 0.01046909f, 0.17057292f, 0.26819149f, 0.19693969f, 0.09197856f, 0.10761780f, 0.17929044f, 
    0.40221259f, 0.04806650f, 0.34615958f, 0.22030047f, 0.18361506f, 0.00737022f, 0.31415394f, 0.37527657f, 
    -0.14253402f, 0.10491585f, 0.07076368f, 0.04483025f, -0.11537038f, 0.02854872f, 0.25704202f, 0.15718704f, 
    0.07858977f, 0.03391718f, -0.17806180f, -0.04156145f, -0.12771505f, 0.01211902f, 0.03792964f, 0.01152414f, 
    0.17252696f, -0.02991005f, -0.08313887f, -0.05560662f, -0.03921745f, 0.04477650f, 0.06152695f, 0.10239466f, 
    -0.06767279f, 0.18390942f, -0.03714848f, 0.12282828f, -0.11362225f, -0.04777157f, -0.00178403f, -0.12205771f, 
    0.08994713f, 0.07548040f, 0.07607992f, -0.00783963f, -0.07385071f, -0.02347694f, -0.08160030f, -0.12929474f, 
    0.07568642f, 0.18605478f, -0.04902887f, 0.05035448f, -0.04399738f, 0.05268873f, 0.00957891f, -0.09485179f, 
    -0.09542792f, 0.16102597f, -0.26087332f, -0.13369600f, 0.50655639f, 0.15421659f, 0.21771100f, 0.17806450f, 
    -0.12971419f, -0.08099718f, -0.10413360f, 0.16758251f, -0.09665516f, -0.00781744f, 0.11634323f, -0.02087131f, 
    0.12175854f, -0.16073179f, -0.09120808f, -0.22209087f, 0.03588131f, 0.10040867f, -0.02882234f, -0.16188924f, 
    0.14422600f, -0.11143100f, -0.27474254f, -0.00686356f, 0.01606696f, 0.16400148f, 0.35434109f, 0.32077149f, 
    -0.00479783f, -0.03857959f, -0.05286650f, 0.00312741f, -0.02378584f, -0.09264044f, -0.07254183f, 0.01926319f, 
    0.27189746f, -0.20233661f, 0.11815098f, 0.09082895f, -0.01328988f, 0.11387344f, 0.03632302f, 0.02112181f, 
    -0.00171006f, 0.17266303f, -0.02269929f, 0.20401797f, -0.14871342f, 0.03139898f, 0.00291809f, 0.03038221f, 
    -0.00478010f, 0.11097358f, -0.00394052f, 0.13066009f, 0.10329011f, -0.21100725f, 0.12419883f, -0.02878843f, 
    0.21677631f, -0.21068367f, 0.02761140f, 0.16388261f, -0.02986070f, 0.03446797f, 0.18996142f, 0.07952763f, 
    0.16750102f, 0.05964315f, 0.13320337f, -0.01728346f, 0.13883710f, 0.36506122f, 0.03216162f, -0.01332156f, 
    -0.02656953f, 0.12914488f, -0.08296281f, 0.13159077f, -0.12455284f, 0.08654872f, 0.02161244f, 0.00983528f, 
    0.41594806f, 0.21489309f, -0.02785635f, -0.02486067f, 0.04054839f, -0.06508490f, -0.00564149f, 0.05778570f, 
    -0.02297459f, -0.05158287f, 0.01081401f, 0.29636556f, -0.14587925f, -0.45739046f, -0.09430626f, -0.07410378f, 
    -0.06657064f, -0.07027324f, -0.20794699f, -0.13748193f, -0.07696233f, -0.02331412f, 0.03764699f, -0.08655100f, 
    0.30490658f, -0.05821325f, -0.14008531f, 0.10952175f, 0.05716888f, 0.00092140f, 0.04582369f, 0.01796810f, 
    -0.04791077f, 0.15449809f, -0.02134883f, -0.04339387f, -0.05109325f, 0.22130738f, 0.20028368f, -0.32763994f, 
    0.14313994f, -0.08807820f, -0.06607019f, -0.08868320f, 0.01632840f, 0.02388870f, 0.00299788f, -0.02509074f, 
    0.33605418f, 0.19306354f, 0.05548973f, 0.01999600f, -0.03761106f, -0.05023456f, -0.01382409f, 0.05554080f, 
    0.10097498f, -0.06391535f, -0.06750715f, -0.12781471f, 0.16324642f, 0.10370018f, 0.32771286f, -0.18959245f, 
    -0.23096859f, 0.02339453f, -0.08249643f, -0.08670458f, -0.07796852f, 0.32443839f, 0.10143208f, -0.01058023f, 
    0.06750651f, -0.03837866f, -0.04876073f, 0.11478529f, -0.05293287f, -0.06302965f, -0.01935310f, 0.04331974f, 
    0.01753702f, -0.20177716f, 0.02328340f, 0.00425130f, 0.28880918f, -0.11737663f, 0.00744044f, -0.16273031f, 
    -0.01851035f, -0.12538880f, -0.04994118f, -0.02013369f, 0.07233453f, 0.09396548f, 0.06613022f, 0.12055806f, 
    0.01358937f, -0.19359092f, -0.00496902f, -0.09574193f, 0.19379532f, -0.09002459f, -0.03418427f, -0.00568622f, 
    0.16359003f, 0.04747792f, 0.12217137f, -0.03012250f, 0.59861839f, -0.29240680f, -0.16076393f, 0.33631632f, 
    -0.15901682f, -0.00824150f, 0.06950194f, 0.04190112f, -0.01687196f, 0.16354899f, -0.11968341f, -0.14042544f, 
    0.00096810f, 0.07923269f, -0.18235216f, -0.10597265f, -0.12422872f, 0.11601748f, -0.04795640f, 0.14968312f, 
    0.10396417f, 0.05020220f, -0.02929654f, -0.00082877f, 0.51011699f, -0.12195829f, 0.09903423f, -0.18746592f, 
    0.00377635f, 0.03845588f, 0.05817987f, 0.04473091f, -0.11096356f, 0.01084588f, 0.04236165f, -0.10787345f, 
    -0.25894764f, 0.29541290f, -0.11060814f, -0.19005033f, -0.05125312f, 0.13874279f, 0.01817585f, 0.27305898f, 
    0.04017621f, 0.09266672f, 0.07581306f, -0.12778202f, -0.03317678f, -0.27950498f, -0.24755663f, 0.00455739f, 
    -0.06891634f, -0.17368232f, -0.15309297f, -0.04438132f, -0.00960360f, -0.01189049f, 0.08004040f, 0.10884449f, 
    -0.01128783f, -0.04330456f, 0.03857771f, 0.06311671f, -0.03618064f, 0.05349091f, 0.01121267f, 0.03419721f, 
    0.02387845f, -0.00607190f, -0.04366795f, -0.04418567f, -0.03969192f, 0.04732421f, -0.06535903f, -0.01320748f, 
    -0.00506918f, -0.05908462f, -0.01253118f, -0.05851860f, 0.02933694f, 0.01155126f, -0.05065599f, -0.05551811f, 
    0.06558608f, 0.03962383f, 0.02195546f, -0.02253255f, 0.04067001f, 0.00642874f, 0.04660114f, 0.06519330f, 
    0.06014608f, -0.03322831f, -0.03209176f, -0.06740261f, -0.01230842f, -0.02266899f, -0.04073187f, -0.03949328f, 
    0.03517012f, 0.03822521f, -0.03616865f, -0.03660904f, -0.02570445f, -0.05645686f, 0.02248165f, -0.01172387f, 
    -0.03736128f, 0.01267031f, -0.05144088f, -0.05610137f, 0.03913207f, 0.03654978f, -0.05722193f, -0.04566854f, 
    0.03093270f, -0.01651374f, 0.02320585f, -0.03121337f, -0.01463416f, -0.01069578f, 0.05609008f, 0.05040468f, 
    0.02801283f, -0.02939375f, -0.05621112f, -0.06793308f, -0.04149073f, 0.00969931f, -0.05378720f, -0.05430915f, 
    -0.04519681f, -0.07807612f, 0.05511035f, 0.04675353f, -0.06095878f, 0.05770035f, 0.00208309f, 0.02745072f, 
    0.00063038f, -0.05264566f, -0.06825652f, -0.06750496f, -0.06789754f, 0.02085916f, -0.03960073f, -0.03164205f, 
    -0.01450376f, 0.03985743f, 0.00765795f, -0.06552684f, 0.06715421f, 0.04900517f, -0.05502265f, -0.06472535f, 
    -0.06295177f, -0.07016301f, -0.00094173f, -0.00450433f, -0.03548221f, 0.02964689f, 0.05032635f, -0.05104360f, 
    -0.02986626f, 0.03007178f, -0.05952130f, -0.05888592f, -0.02497847f, 0.05767322f, 0.06543665f, -0.03969209f, 
    -0.03141389f, 0.05751561f, 0.05869422f, -0.00325227f, -0.03142113f, -0.05537646f, 0.01764261f, 0.06311294f, 
    -0.02251594f, 0.02137443f, 0.03665960f, 0.05960290f, -0.07624887f, -0.01630084f, -0.01399655f, -0.03410034f, 
    -0.05885297f, -0.03069103f, 0.00161217f, -0.05044058f, 0.01653684f, 0.03218628f, 0.03781058f, -0.05678890f, 
    -0.04635252f, -0.07762375f, 0.04134776f, 0.05593594f, 0.04800948f, 0.01778417f, 0.03834899f, -0.07359886f, 
    -0.04250716f, -0.00630324f, 0.01427530f, -0.06168871f, 0.00936492f, -0.07452084f, -0.02441221f, 0.02315681f, 
    0.01218859f, -0.06292522f, -0.06726833f, -0.07184036f, -0.02679215f, -0.01466920f, -0.00973866f, 0.05381541f, 
    -0.00340666f, 0.02207723f, -0.02295914f, -0.02443114f, -0.06528397f, -0.05024390f, 0.00012021f, 0.02463594f, 
    0.00054269f, -0.03378111f, -0.05800296f, 0.04573107f, -0.04428940f, -0.00303119f, 0.05465951f, -0.01670024f, 
    -0.06666918f, -0.05598828f, 0.02246256f, 0.03270112f, -0.07796990f, -0.02871709f, 0.06235522f, 0.03038641f, 
    -0.02013688f, -0.00499036f, 0.05738654f, -0.03172571f, 0.02435319f, 0.04555037f, -0.01716409f, -0.05853239f, 
    -0.07456640f, -0.02485102f, -0.02043199f, -0.00053532f, 0.01697439f, 0.02657379f, -0.00083448f, -0.02721666f, 
    0.05749469f, -0.02141555f, 0.01977727f, -0.07533206f, -0.02340763f, 0.03057826f, -0.03021118f, 0.04088692f, 
    -0.02239096f, -0.01927272f, -0.01492211f, -0.01848723f, 0.01216910f, -0.00501386f, 0.05795902f, -0.05257536f, 
    -0.05643567f, -0.04109373f, -0.07731082f, 0.00617168f, -0.01268691f, 0.03518897f, -0.01324442f, -0.06150151f, 
    0.06099142f, -0.02240735f, -0.03033713f, 0.06162944f, -0.00915750f, -0.01287435f, -0.07672042f, 0.03446360f, 
    -0.01001900f, -0.02180528f, 0.03503773f, -0.01228911f, 0.05037962f, 0.04434219f, 0.01717991f, -0.01573414f, 
    -0.05470879f, -0.01211695f, 0.02750041f, 0.04150476f, 0.05831256f, 0.04751987f, -0.01491793f, -0.07076400f, 
    0.01107835f, -0.04355695f, 0.05386671f, 0.05009887f, 0.00154128f, -0.06128301f, -0.05745452f, 0.02469421f, 
    -0.05196207f, 0.01847173f, -0.00915453f, -0.04365779f, 0.02671541f, -0.01321643f, -0.01886132f, -0.07319935f, 
    -0.03851483f, -0.03331947f, -0.01056236f, -0.05668616f, 0.01393588f, 0.00237355f, -0.03488138f, -0.06180165f, 
    -0.05010940f, -0.06525895f, -0.00601987f, 0.01885015f, 0.00088878f, -0.02589782f, -0.03458371f, -0.00253194f, 
    0.02435197f, 0.03287190f, -0.06414828f, 0.05083365f, -0.06818490f, -0.00208498f, -0.06205435f, -0.04207005f, 
    -0.06656710f, -0.06249237f, 0.00444762f, -0.00285789f, -0.00262255f, -0.06721445f, -0.01282506f, 0.02816374f, 
    -0.02557322f, -0.06776492f, 0.02373924f, -0.03039264f, 0.03910593f, 0.04646185f, -0.00639635f, 0.06235118f, 
    -0.02836153f, -0.01458655f, -0.02614314f, -0.06736076f, -0.00344669f, -0.02880920f, 0.01724143f, 0.06319659f, 
    -0.03064843f, -0.07666681f, -0.00714628f, 0.02617686f, -0.02802635f, -0.07693064f, 0.05136584f, -0.02018123f, 
    -0.02348585f, -0.02939155f, -0.00943606f, 0.02495052f, 0.03709855f, -0.06767160f, -0.05338902f, -0.06252507f, 
    0.03069470f, 0.06443000f, -0.00580377f, 0.02090301f, -0.05067725f, -0.07516418f, 0.00482897f, 0.00903374f, 
    0.01294044f, 0.02290937f, 0.06439513f, 0.03943459f, 0.03784080f, -0.05752152f, 0.06439760f, 0.05644599f, 
    -0.04017980f, 0.02187954f, -0.01550678f, 0.03957980f, -0.03428731f, 0.00605395f, 0.05455792f, -0.05029771f, 
    0.00966132f, -0.05237859f, -0.00553071f, -0.03083872f, -0.04552648f, -0.04126652f, 0.00530157f, 0.00669771f, 
    -0.03752566f, -0.04063401f, 0.04225687f, -0.05319281f, 0.01375497f, -0.04860542f, -0.00526291f, -0.06628284f, 
    -0.02224836f, 0.01875382f, -0.06506196f, -0.04281780f, -0.06229784f, -0.00038395f, -0.02174985f, 0.00252205f, 
    0.05619776f, -0.01780302f, -0.05533478f, -0.02089942f, -0.00920406f, -0.01526523f, -0.07688680f, -0.04962093f, 
    0.40219706f, -0.06773127f, 0.24403188f, 0.19439051f, -0.00209385f, 0.11347710f, -0.06413079f, -0.00809703f, 
    -0.07779627f, 0.15105870f, 0.07883399f, 0.06400725f, 0.25554669f, -0.05312999f, 0.09286906f, 0.00887284f, 
    -0.07123639f, 0.10156520f, -0.16313674f, -0.13645977f, 0.02172517f, -0.03911544f, -0.00338912f, -0.00741972f, 
    -0.08310571f, 0.10379086f, -0.06259085f, 0.06772253f, -0.17941758f, -0.07551466f, 0.22953860f, 0.10219130f, 
    -0.06798435f, -0.04248232f, 0.02822562f, 0.02561232f, 0.31383398f, -0.06765489f, 0.09423057f, 0.26335895f, 
    -0.06803823f, -0.14166337f, -0.02488028f, 0.09024573f, -0.02681895f, 0.02310697f, 0.02140802f, 0.00218099f, 
    0.06803194f, -0.03051270f, -0.08837931f, 0.28244877f, -0.05860165f, -0.05766692f, -0.00974879f, 0.00016047f, 
    0.07350520f, 0.04072916f, 0.01995685f, -0.15125833f, 0.30558711f, 0.25054723f, 0.08524229f, -0.00111912f, 
    0.13486433f, -0.19684178f, 0.08099457f, 0.04925788f, -0.10164427f, 0.06422979f, -0.06189285f, -0.11764216f, 
    0.38566458f, -0.00003019f, 0.08848207f, -0.11332621f, 0.12561059f, -0.05616751f, 0.16147532f, 0.14472155f, 
    0.03971573f, 0.03313673f, -0.16415368f, 0.02167311f, -0.24222246f, 0.37334898f, 0.20699598f, -0.19846003f, 
    -0.07619822f, 0.15096055f, 0.03426556f, 0.06066692f, 0.00723279f, 0.13445978f, 0.05452522f, -0.07067008f, 
    0.01800036f, -0.13245361f, -0.33500147f, -0.07334230f, 0.01601959f, -0.00730000f, -0.14892280f, 0.10271160f, 
    -0.03983539f, -0.16073024f, 0.06688697f, 0.02029773f, 0.28077966f, 0.42455807f, -0.08046433f, -0.13223642f, 
    -0.08948302f, -0.00617385f, -0.00392677f, -0.05359233f, 0.10063209f, -0.04348679f, -0.02634453f, 0.04537253f, 
    0.06722736f, -0.24126233f, -0.09031739f, -0.15810712f, -0.07410065f, -0.04398923f, 0.11410417f, 0.02690329f, 
    0.05714910f, -0.01899481f, -0.00862434f, 0.01253247f, 0.92192310f, -0.14679798f, -0.00246562f, 0.03134555f, 
    -0.12345607f, 0.19756646f, -0.00834630f, 0.04314801f, 0.08682883f, 0.06982881f, -0.10844652f, -0.03283526f, 
    0.11015417f, 0.09865700f, 0.01169017f, -0.14010790f, 0.06778459f, 0.01470523f, -0.26846737f, 0.00750286f, 
    0.10841704f, -0.03322230f, 0.18494129f, -0.16659856f, 0.12673536f, 0.32708162f, 0.07702876f, -0.33988386f, 
    -0.03465841f, -0.11055650f, 0.13513967f, -0.09185097f, -0.06287008f, -0.05109746f, 0.02784664f, 0.04067420f, 
    -0.11063728f, -0.35148206f, -0.15585978f, -0.21190402f, -0.00414695f, 0.17693545f, -0.01906808f, 0.10938565f, 
    -0.02033989f, 0.10085644f, -0.08116936f, -0.10081985f, 0.20328389f, 0.00204240f, -0.12945949f, 0.49527341f, 
    -0.00745540f, 0.10078234f, -0.07147599f, 0.11419450f, -0.04859096f, 0.01437450f, 0.07068346f, -0.01074724f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05799881f, 0.06456169f, -0.01915056f, 0.05086155f, -0.00309616f, 0.10042413f, -0.00733699f, 0.03986689f, 
    0.05927766f, 0.18391405f, -0.01568465f, 0.13518336f, 0.06027311f, -0.06940871f, 0.10302025f, -0.04918215f, 
    0.02599972f, -0.03871805f, 0.12040886f, -0.02742885f, -0.15196300f, 0.19396351f, 0.02473538f, 0.16200945f, 
    0.05357794f, 0.06410187f, -0.06096352f, -0.01098978f, -0.02930186f, 0.05262930f, -0.05173502f, -0.15447122f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10521869f, 0.00352151f, -0.13098872f, 0.04016161f, 0.05813418f, -0.35140067f, 0.03461018f, 0.16277865f, 
    -0.00283614f, 0.22356185f, -0.09885514f, 0.28879309f, 0.09049977f, -0.13768369f, -0.29270542f, 0.02221143f, 
    0.14723799f, -0.11681635f, 0.36112443f, 0.05703478f, -0.40899837f, -0.44797102f, -0.12117822f, -0.24983522f, 
    0.23772085f, 0.05718612f, -0.07662427f, -0.50294530f, 0.27792612f, -0.17484534f, -0.00617047f, 0.28185454f, 
    0.16492155f, -0.36775702f, -0.15141398f, -0.12106363f, -0.06893822f, 0.19489564f, 0.25407907f, 0.12165993f, 
    0.11237255f, -0.06032531f, 0.09940467f, 0.27948895f, -0.12100238f, 0.45419538f, -0.29592082f, -0.24930075f, 
    -0.02017822f, -0.06378692f, -0.15046921f, 0.02729889f, 0.36384946f, -0.20941347f, -0.15471789f, 0.47729743f, 
    0.09463682f, 0.03909887f, -0.12888484f, 0.32073531f, 0.07990111f, -0.05475177f, -0.02570374f, 0.13299957f, 
    -0.06944615f, -0.01909517f, 0.14849713f, 0.03898013f, 0.05527104f, -0.05641191f, 0.02920030f, 0.04131223f, 
    -0.04687593f, 0.20624246f, 0.03201744f, -0.22370993f, 0.23802154f, -0.46380961f, 0.39868328f, 0.35884205f, 
    -0.08605740f, -0.14380336f, -0.09898183f, 0.09568401f, -0.44563946f, 0.12266625f, 0.07217512f, 0.27805862f, 
    0.28379127f, 0.03713233f, -0.09016212f, -0.08106644f, 0.09164920f, 0.13078287f, 0.05364186f, 0.05417744f, 
    0.11907624f, -0.00631843f, 0.06117769f, 0.10778040f, 0.02937758f, -0.04583319f, 0.40777594f, -0.11746699f, 
    0.02350181f, -0.05933046f, -0.09254971f, 0.23379873f, 0.00673882f, 0.35003048f, -0.29359412f, 0.43653169f, 
    -0.02270923f, 0.08671069f, 0.18042529f, 0.00108037f, 0.16299845f, -0.67302555f, -0.04769253f, -0.11635921f, 
    0.21063836f, -0.12670957f, -0.12702826f, -0.00672255f, -0.00355831f, -0.00358463f, -0.11005682f, 0.13286205f, 
    -0.09497856f, 0.30481169f, -0.10434446f, 0.00869057f, -0.08675701f, 0.06743541f, -0.16974409f, 0.09901267f, 
    0.16353378f, 0.22206374f, 0.12162021f, -0.07737854f, 0.25897667f, -0.56094497f, 0.44852844f, 0.05598295f, 
    -0.10446108f, -0.16961995f, -0.24367702f, 0.13386765f, -0.19371836f, 0.23692773f, 0.02873484f, 0.14755337f, 
    -0.29395792f, -0.04415794f, -0.09542254f, -0.01004271f, 0.22047983f, 0.09068758f, 0.12555458f, 0.09325286f, 
    0.06926959f, 0.45284483f, 0.03467270f, 0.13474847f, 0.13875678f, 0.25007626f, -0.03191291f, 0.09793277f, 
    0.01057501f, -0.30939043f, 0.07513367f, 0.01433919f, -0.17421481f, 0.08181754f, -0.24788763f, 0.14716659f, 
    -0.09886467f, 0.07325614f, 0.38810867f, 0.03090428f, -0.15049970f, 0.22467960f, -0.06637979f, -0.00562722f, 
    -0.00270963f, 0.10510300f, -0.07749522f, 0.29358414f, 0.40631980f, -0.00583317f, 0.13539183f, 0.24753137f, 
    0.17467977f, -0.05751130f, 0.12487211f, 0.17712779f, 0.06535532f, -0.15412065f, 0.05600264f, 0.13200571f, 
    0.22794390f, 0.17582874f, -0.11298721f, 0.06778335f, -0.06774437f, 0.11517150f, -0.02232013f, 0.07261802f, 
    0.04991171f, -0.05053664f, 0.23885928f, -0.03277776f, -0.03400749f, 0.11668185f, -0.09761614f, -0.23849685f, 
    -0.09522917f, -0.09398504f, -0.16816230f, -0.16020606f, 0.07521464f, 0.16346802f, 0.09963474f, -0.09674374f, 
    0.14762312f, 0.38263312f, -0.13363059f, -0.09514279f, -0.04673534f, -0.16012059f, -0.24229445f, 0.02211156f, 
    0.41793987f, 0.11372726f, -0.13723509f, 0.03983004f, -0.29101786f, 0.13091959f, 0.18595053f, -0.49544567f, 
    -0.10235136f, 0.01180955f, 0.06770739f, 0.18471871f, 0.40276381f, 0.03959835f, 0.01647649f, 0.16707937f, 
    -0.32330215f, 0.06811940f, 0.07928706f, 0.32800883f, -0.42189953f, -0.08408747f, 0.02240983f, 0.01533190f, 
    0.02967936f, -0.22816113f, 0.08030287f, 0.17417383f, -0.13767838f, 0.57974762f, -0.29762539f, -0.06162254f, 
    -0.21827008f, 0.29226151f, -0.14314248f, 0.39290470f, -0.22024177f, -0.36116582f, 0.30785507f, -0.34831622f, 
    0.12478620f, -0.13729148f, 0.25039333f, -0.05647004f, -0.18772389f, 0.03974988f, -0.15540791f, 0.52629179f, 
    -0.04824388f, -0.17922790f, -0.06343447f, 0.00694205f, 0.42523959f, 0.09923520f, -0.05978387f, -0.24120858f, 
    -0.14755049f, -0.00872009f, 0.11438523f, -0.06346030f, -0.03751752f, -0.22420202f, -0.05157328f, 0.12845919f, 
    0.15332760f, 0.12482231f, 0.09430425f, 0.25252211f, -0.47728559f, 0.12889551f, -0.01692664f, -0.23252162f, 
    0.00905179f, -0.03166145f, 0.32183322f, -0.12694404f, -0.33130670f, -0.20625824f, -0.10923377f, 0.02710493f, 
    0.00105772f, 0.07362363f, -0.13878836f, 0.14048806f, -0.24261770f, 0.12961410f, 0.12530178f, 0.05837401f, 
    -0.10176460f, 0.47987133f, -0.15251325f, -0.15975082f, -0.08654653f, 0.38824019f, 0.04221790f, -0.17529783f, 
    0.00724810f, -0.10753079f, -0.10128128f, -0.35011828f, 0.18404706f, 0.10663784f, 0.21247388f, 0.43247673f, 
    -0.11759035f, 0.06146392f, 0.34030718f, -0.03776073f, 0.11696172f, 0.06184585f, 0.13345473f, -0.19450505f, 
    -0.25980788f, -0.12844130f, -0.08017097f, 0.34639826f, -0.07637419f, 0.17058364f, -0.07190137f, 0.10997219f, 
    -0.07582525f, -0.06369869f, -0.14012428f, -0.02238014f, 0.12368919f, 0.13966650f, 0.57294464f, -0.07461322f, 
    0.14516324f, 0.23761657f, 0.00988948f, 0.16565326f, 0.40582529f, 0.00738671f, 0.14078501f, 0.05054500f, 
    -0.09716827f, -0.15757212f, 0.30881402f, -0.06258695f, 0.14474827f, -0.12353473f, -0.13735086f, -0.19644262f, 
    0.12498004f, -0.06542536f, -0.11443553f, -0.21105608f, -0.52534795f, -0.04356287f, -0.13191809f, -0.24012321f, 
    -0.00127987f, 0.14785604f, -0.03629126f, 0.02217415f, 0.08222846f, -0.47456068f, 0.19351287f, -0.02008970f, 
    0.50274676f, -0.09747899f, -0.08321512f, 0.07948808f, 0.18813358f, -0.04999617f, 0.03272834f, -0.19170091f, 
    -0.14608985f, -0.10274126f, -0.21110393f, 0.16281670f, -0.19923432f, 0.25645712f, -0.08791167f, -0.09488840f, 
    0.24437617f, -0.04877297f, 0.13690031f, 0.18117538f, -0.31249505f, -0.14245218f, -0.13317311f, 0.10432887f, 
    0.07523606f, 0.37160176f, 0.03412491f, -0.02771687f, 0.07690211f, -0.21833009f, -0.22003208f, -0.12981954f, 
    -0.42412999f, 0.16511224f, -0.10236580f, 0.27419072f, 0.07645708f, -0.18798931f, -0.08861665f, 0.10585447f, 
    0.06546430f, 0.13628258f, -0.17810103f, -0.17395955f, -0.03120409f, 0.21535285f, 0.00767923f, -0.26433885f, 
    0.39447999f, 0.06192759f, -0.10707914f, -0.01994038f, -0.10331991f, 0.13438320f, 0.15365392f, 0.40262458f, 
    -0.03984782f, 0.16852346f, 0.07491390f, 0.16730888f, 0.12500215f, 0.07540948f, 0.23651618f, -0.13701117f, 
    0.18850926f, 0.28903109f, 0.10658072f, -0.09740511f, 0.00944217f, 0.41080728f, 0.03290364f, -0.05148880f, 
    -0.13811149f, 0.03005481f, -0.03918581f, -0.13421772f, 0.54384381f, -0.42789808f, 0.04201350f, -0.00165365f, 
    -0.28936404f, -0.12352253f, -0.13888578f, 0.19769333f, -0.31985149f, 0.00067620f, -0.02816333f, 0.25993523f, 
    -0.15052146f, 0.18826628f, -0.06450793f, -0.04947874f, 0.04306645f, -0.15063681f, -0.06785792f, 0.06121901f, 
    -0.02499973f, -0.12941277f, 0.09330505f, 0.30025592f, 0.47956371f, 0.01588953f, 0.28548482f, 0.14525913f, 
    0.14493331f, 0.13210659f, 0.15256135f, 0.04333445f, 0.32424477f, -0.00236241f, 0.13861150f, 0.07206497f, 
    0.01576359f, -0.13798952f, 0.18867812f, -0.02913399f, -0.73150110f, -0.12870565f, 0.14546031f, -0.37091929f, 
    -0.13930893f, 0.32654652f, -0.08397216f, -0.02740234f, 0.07961980f, 0.00497803f, 0.06903633f, 0.04815871f, 
    0.33230305f, -0.02040387f, -0.00183314f, 0.15322685f, -0.44389981f, -0.08515175f, -0.37111679f, -0.14735505f, 
    0.17662497f, 0.11944827f, 0.17467965f, 0.04551923f, 0.01079640f, 0.13817246f, 0.08291922f, -0.26041642f, 
    0.04199626f, -0.13188151f, -0.10476336f, 0.22720453f, 0.09087306f, -0.00248911f, 0.17386611f, 0.19119264f, 
    0.06744577f, -0.27942929f, -0.06957604f, 0.12812905f, 0.16554548f, -0.10398285f, 0.34062231f, -0.01318329f, 
    -0.12553415f, 0.04748606f, -0.02823761f, -0.16092105f, 0.12867023f, 0.37997824f, -0.29776847f, 0.29546145f, 
    0.12047762f, -0.04037736f, -0.51709753f, -0.09914117f, 0.07541645f, 0.19514848f, -0.10250773f, 0.04170211f, 
    0.23216140f, 0.13016561f, 0.14183450f, 0.05795136f, 0.74031681f, -0.03861706f, -0.03895201f, 0.34174001f, 
    0.16974910f, -0.26329929f, 0.02339702f, 0.00438598f, -0.08925264f, -0.00622946f, 0.19155180f, 0.10843489f, 
    -0.22754487f, -0.06676918f, -0.11647575f, 0.11811703f, 0.39962545f, 0.05604054f, -0.02331893f, 0.37734553f, 
    -0.05821890f, -0.07875639f, 0.03424552f, 0.11863726f, -0.27695593f, 0.29182065f, 0.03738982f, 0.30527908f, 
    0.36344519f, 0.02427389f, -0.08364477f, -0.28586563f, 0.33267221f, 0.07716686f, -0.04980516f, 0.24392983f, 
    0.15537265f, 0.04690588f, 0.10107051f, 0.17799237f, 0.16253634f, -0.37240589f, -0.33703762f, -0.13096133f, 
    -0.08769677f, 0.22304760f, 0.05633442f, -0.03067752f, -0.27964553f, 0.40971118f, 0.28453648f, -0.20080091f, 
    0.03945141f, -0.00339140f, -0.38276130f, -0.03725368f, -0.08154923f, -0.20523633f, -0.05879669f, 0.18753394f, 
    0.27699700f, 0.11216462f, -0.17615996f, 0.21727365f, -0.07529268f, 0.15669522f, 0.12386496f, 0.48116088f, 
    -0.17030732f, -0.10044263f, -0.02162966f, 0.05285737f, 0.14918262f, 0.09310658f, -0.08216110f, -0.04453520f, 
    0.04174620f, -0.11634675f, 0.11683844f, 0.08525530f, -0.01004752f, 0.12921004f, -0.06782671f, 0.08175002f, 
    0.02726026f, -0.15233894f, -0.06335320f, -0.13938932f, 0.05010847f, -0.16179305f, -0.07728896f, -0.15526554f, 
    -0.14899218f, -0.12357778f, -0.12851141f, 0.07721391f, -0.14986070f, 0.03604645f, 0.11440298f, -0.16388416f, 
    0.01187295f, 0.25579256f, 0.11603397f, 0.10277474f, -0.05691636f, -0.02614935f, -0.31094792f, -0.10737354f, 
    -0.47214553f, 0.29082519f, -0.00734558f, -0.12576365f, 0.00063590f, -0.41183680f, 0.10607064f, 0.02034910f, 
    -0.01339110f, 0.00757330f, -0.12123888f, 0.01590109f, 0.08730312f, 0.56348944f, 0.06183557f, -0.31624097f, 
    -0.12343100f, -0.03341956f, -0.16834031f, 0.25694063f, 0.20728694f, -0.06208973f, 0.08977460f, -0.01466221f, 
    0.15412219f, -0.01586671f, 0.17378026f, 0.02951089f, 0.02379268f, -0.41180351f, 0.18372293f, 0.14742184f, 
    -0.24105735f, 0.24970229f, 0.13443479f, -0.00135225f, 0.10072959f, 0.53500789f, 0.25605765f, -0.10058333f, 
    -0.03207770f, 0.10382314f, -0.23659749f, -0.11775778f, 0.34472734f, 0.29098973f, 0.08858570f, -0.44867447f, 
    0.49769214f, 0.15984796f, 0.08561441f, 0.11744250f, -0.19192511f, -0.05762915f, -0.14330548f, -0.27877054f, 
    -0.00351340f, 0.08742389f, 0.08517476f, -0.06448150f, -0.12787484f, 0.35982612f, -0.02344826f, -0.00455852f, 
    0.11011921f, 0.25406232f, -0.17285250f, -0.21416591f, 0.38855255f, -0.16135783f, 0.03997643f, 0.41564053f, 
    -0.14894806f, -0.16545399f, 0.01258616f, 0.05290175f, 0.29873511f, -0.47249547f, -0.12915221f, -0.06195479f, 
    -0.29821515f, 0.14696653f, 0.13516773f, 0.14346603f, 0.23246554f, 0.05916435f, 0.13499759f, -0.01787269f, 
    -0.12025287f, -0.12416534f, 0.08846067f, 0.16407466f, -0.12387329f, 0.06839134f, 0.09587688f, 0.15499710f, 
    -0.05713156f, -0.17800765f, 0.12933534f, 0.00818743f, -0.14103302f, -0.10219415f, -0.03655516f, 0.05106094f, 
    -0.15663469f, -0.09246563f, 0.06560586f, -0.05428400f, 0.04799343f, 0.02273242f, -0.05364797f, -0.10160967f, 
    -0.02583503f, -0.01124809f, -0.06277352f, -0.19914085f, -0.09363458f, 0.15655658f, -0.06556994f, 0.03456477f, 
    0.00220378f, -0.48519236f, -0.09285408f, 0.03605446f, 0.14837614f, 0.05363784f, 0.11420912f, 0.00387541f, 
    0.19433525f, 0.24054226f, -0.01244329f, 0.29797447f, 0.25147396f, 0.06085570f, 0.36468259f, -0.34187159f, 
    -0.11660755f, 0.01241835f, -0.12322751f, -0.11271011f, 0.51108825f, 0.05682470f, -0.09762961f, 0.08395170f, 
    0.18435726f, 0.02070589f, 0.15516526f, -0.05711475f, 0.26577118f, 0.08960659f, 0.14267471f, -0.43400294f, 
    -0.05909352f, 0.36167449f, 0.02453825f, -0.13558275f, -0.18288676f, 0.35705754f, -0.18566944f, 0.09595013f, 
    0.41852397f, -0.35577413f, -0.02372876f, 0.24252403f, 0.06652343f, 0.23464423f, -0.00528839f, -0.13322186f, 
    0.05968516f, -0.04935583f, 0.38242185f, -0.04070143f, -0.11075547f, 0.19581048f, 0.02485771f, 0.30652592f, 
    0.21278389f, 0.06618242f, 0.03572595f, 0.35651082f, -0.30893967f, -0.11865561f, 0.08862536f, -0.27140573f, 
    0.15527791f, 0.23722066f, -0.13030347f, 0.12674162f, -0.08942991f, -0.06593385f, -0.40802473f, 0.02844691f, 
    -0.34639594f, -0.41143861f, 0.15460946f, 0.11549547f, 0.44076094f, 0.18995929f, 0.17127866f, 0.19488265f, 
    -0.08711770f, 0.11420805f, 0.08267339f, -0.09546128f, 0.16454871f, 0.24206096f, -0.11432705f, 0.07616076f, 
    0.12093152f, -0.09370697f, -0.07163630f, 0.01106413f, -0.18994121f, -0.17001209f, -0.17482488f, 0.03825787f, 
    -0.04574794f, -0.14353341f, -0.16464493f, -0.09846862f, 0.17791456f, -0.21151774f, -0.10112201f, 0.04700089f, 
    -0.03522193f, 0.09875458f, 0.09540521f, 0.08654915f, -0.08239562f, -0.11040745f, -0.22720072f, -0.22196756f, 
    -0.04427043f, -0.13622187f, -0.14697111f, -0.05000371f, -0.01036292f, 0.01685010f, -0.06821915f, -0.22989343f, 
    -0.17611730f, 0.18361337f, 0.00725981f, -0.18233573f, -0.04713224f, 0.16981867f, -0.04471302f, 0.07307555f, 
    0.06178722f, -0.11787838f, 0.12835810f, -0.04855536f, -0.14793546f, -0.43562254f, -0.01402568f, -0.02344166f, 
    0.31026223f, -0.14564978f, -0.13277450f, -0.11574273f, 0.35930407f, 0.14115815f, 0.25632530f, -0.10089422f, 
    -0.01588271f, -0.05755692f, -0.31793913f, -0.01735360f, 0.38435447f, 0.39841062f, -0.08672094f, -0.00586756f, 
    0.08504280f, 0.04737362f, 0.06008720f, 0.25977919f, 0.36008862f, 0.07389525f, -0.15138724f, -0.01904409f, 
    0.07478078f, 0.24379253f, 0.05661805f, -0.04954917f, 0.07030676f, 0.15695935f, 0.26021853f, -0.10306524f, 
    0.34967142f, 0.33906531f, 0.00095328f, 0.24636883f, -0.30332348f, -0.54090792f, -0.14234373f, 0.05854208f, 
    0.04578672f, -0.07450734f, 0.44388819f, -0.01692622f, -0.26668265f, 0.10582773f, 0.07764118f, 0.15821666f, 
    -0.03736474f, 0.05061813f, -0.01082692f, 0.09844404f, -0.03817428f, 0.12937483f, -0.13193232f, 0.04569754f, 
    -0.06708765f, -0.25883877f, 0.06049620f, -0.04227323f, -0.06666239f, 0.05412851f, -0.03316975f, -0.10132137f, 
    -0.61307043f, -0.00326455f, 0.15439823f, 0.37191084f, -0.09331165f, 0.18263774f, -0.20375840f, 0.14421457f, 
    -0.08418298f, 0.02991398f, 0.29933858f, 0.10715404f, 0.19561146f, -0.63186562f, 0.12359481f, 0.15397954f, 
    0.21941954f, -0.17063770f, -0.02917976f, -0.22335950f, -0.05428592f, 0.04914896f, -0.07235648f, 0.21493229f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01716120f, -0.06187266f, 0.22301413f, -0.05861124f, 0.23669900f, -0.14050157f, -0.10120845f, 0.12119842f, 
    0.39307880f, -0.00048271f, -0.00305251f, 0.22462791f, -0.14819616f, 0.21691929f, -0.23089232f, -0.12663223f, 
    -0.02481918f, -0.25304648f, 0.15567142f, 0.01883646f, -0.11648770f, 0.05033353f, 0.08648440f, -0.00466871f, 
    -0.16313414f, 0.11427999f, 0.19037499f, 0.10674077f, -0.10275565f, -0.15277730f, 0.28730199f, 0.03534194f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10595833f, 0.19031021f, -0.19898859f, 0.22830436f, -0.36810741f, -0.31294468f, -0.19612418f, -0.37253082f, 
    -0.74487132f, -0.50113893f, -0.29448012f, -0.18098158f, -0.01198748f, 0.17866136f, 0.15432717f, -0.28794140f, 
    -0.50546992f, 0.46641579f, 0.16913010f, 0.45869845f, -0.00393492f, -0.19280988f, 0.36272150f, -0.04366512f, 
    -0.18775281f, 0.07484168f, -0.48834294f, -0.15888508f, 0.02104513f, 0.27180204f, -0.37295556f, 0.32745323f, 
    0.64197981f, -0.12114569f, -0.04956503f, 0.23775868f, 0.25373927f, 0.10557046f, 0.12011887f, 0.17101786f, 
    -0.24000998f, 0.11108660f, -0.13244255f, -0.16101570f, -0.06439328f, 0.27012479f, -0.16182806f, -0.50660366f, 
    0.19407119f, 0.27086282f, 0.02194610f, -0.11948173f, 0.08577228f, 0.46518379f, -0.13550891f, 0.10533172f, 
    -0.10398173f, -0.17733903f, -0.50139952f, -0.28400919f, -0.06152796f, 0.20080750f, 0.11424731f, 0.25914350f, 
    -0.45789966f, 0.29033041f, -0.04057427f, 0.25453424f, -0.29937744f, 0.55150658f, -0.24503621f, -0.02064665f, 
    -0.30581906f, 0.11081330f, 0.18275326f, -0.23349537f, 0.13070898f, -0.02403257f, -0.17401898f, -0.55801141f, 
    0.16819337f, 0.24544807f, 0.20542216f, 0.09390828f, 0.11432990f, -0.82612073f, -0.55083752f, -0.35241246f, 
    -0.12224483f, -0.78205454f, 0.45430961f, -0.35836792f, -0.17652550f, -0.32569882f, 0.13908155f, -0.13707885f, 
    -0.66724992f, -0.65851116f, 0.31343955f, -1.00348759f, 0.12412202f, -0.06081209f, -0.24981648f, -0.21266474f, 
    -0.13979131f, -0.26830029f, 0.21355924f, -0.08886929f, -0.10871302f, 0.43228641f, -0.55996966f, 0.00946217f, 
    -0.50516230f, -0.04015503f, 0.00345697f, 0.34194994f, 0.10451972f, 0.36016095f, 0.46415281f, -0.11493509f, 
    0.00291462f, -0.07136624f, 0.03079016f, 0.08702475f, 0.09765309f, -0.01196412f, -0.17719498f, -0.76071000f, 
    -0.03957817f, -0.14938809f, -0.12881143f, -0.19727476f, 0.00217831f, -0.31488475f, 0.10998599f, 0.08467031f, 
    -0.50415891f, -0.16245949f, -0.19264828f, 0.25349647f, 0.63395840f, 0.05602815f, -0.08976324f, 0.35938486f, 
    0.14646871f, -0.25221387f, -0.00200211f, -0.22578105f, -0.08741238f, -0.20197520f, 0.27190492f, -0.34421980f, 
    0.11441134f, 0.04354661f, 0.16559589f, -0.05127701f, 0.00926854f, 0.20274436f, 0.11240603f, -0.69691217f, 
    -0.08932228f, 0.10443616f, -0.11070508f, 0.22177625f, -0.11001175f, -0.23021519f, -0.10506133f, -0.75001091f, 
    -0.03554696f, -0.01802046f, -0.06263988f, 0.28173527f, -0.48377076f, -0.02664400f, -0.00085244f, 0.42735031f, 
    -0.29657117f, -0.17647794f, 0.19250576f, -0.57986033f, -0.03172552f, -0.25582296f, -0.15293956f, 0.28555444f, 
    -0.22236168f, 0.12328675f, -0.02787437f, 0.22601296f, -0.14598428f, -0.25158244f, -0.09342699f, 0.34277248f, 
    -0.04101288f, 0.18690775f, -0.08234240f, -0.19992000f, 0.07173014f, -0.35723296f, -0.11403829f, 0.49904287f, 
    0.43993044f, 0.42224872f, -0.59043664f, -0.23319633f, -0.01707488f, 0.23273985f, 0.09491839f, -0.05802585f, 
    -0.00902184f, -0.61250573f, -0.19840077f, 0.69351333f, -0.11341493f, 0.23305508f, -0.16321799f, -0.27935341f, 
    -0.20114790f, 0.02772161f, -0.08962875f, -0.77516079f, -0.04315057f, -0.44473031f, 0.14426591f, 0.20725356f, 
    -0.31578928f, -0.34293789f, -0.14990655f, 0.21491006f, 0.16139133f, 0.12458073f, -0.26403198f, 0.40736869f, 
    -0.43969682f, -0.37925354f, 0.31329885f, -0.57251394f, 0.11935212f, -0.21870673f, 0.07217767f, 0.33827958f, 
    0.12621877f, -0.19711654f, -0.29483691f, 0.19012275f, -0.10290995f, -0.21806939f, -0.33400002f, 0.32889265f, 
    -0.14942007f, -0.17004041f, 0.26960310f, 0.45328382f, 0.11333925f, 0.21509221f, -0.55442202f, -0.40205187f, 
    0.24451624f, -0.59116274f, 0.38642079f, 0.15590453f, 0.38124758f, 0.13155125f, 0.15726072f, -0.23277178f, 
    -0.27741632f, -0.52728248f, 0.38767874f, 0.15483221f, -0.16675140f, 0.06796817f, 0.22446804f, -0.24708229f, 
    -0.24049453f, -0.02963788f, 0.08284990f, -0.12110906f, -0.09101579f, 0.09822983f, -0.46232745f, 0.51639968f, 
    0.00386040f, -0.70746213f, -0.64470947f, -0.33577853f, 0.02954178f, -0.71494782f, 0.25052661f, -0.35360163f, 
    -0.72809947f, 0.19844319f, -0.78421617f, 0.10844363f, -0.34396511f, -0.00235708f, 0.14895836f, 0.42790946f, 
    -0.04446140f, -0.01118670f, 0.16399299f, 0.00044312f, -0.29346704f, -0.50137782f, 0.42810249f, -0.11011963f, 
    0.23238309f, 0.03634274f, -0.49075359f, -0.21067110f, -0.16229141f, -0.52722037f, 0.11943928f, 0.27649269f, 
    0.10090829f, 0.16274458f, 0.14624673f, -0.53836823f, -0.12148324f, -0.08849666f, 0.07429615f, -0.28783014f, 
    -0.32086805f, -0.21606354f, -0.04317043f, -0.73097807f, 0.18722525f, 0.34475914f, 0.03303441f, -0.27799064f, 
    0.51836902f, -0.15567428f, -0.04501165f, -0.36675406f, -0.63560683f, -0.04004775f, -0.94574213f, -0.07590748f, 
    0.23198396f, -0.20032845f, 0.25538951f, -0.60381389f, 0.10732272f, 0.08639824f, -0.50272030f, -0.17456222f, 
    0.08931129f, -0.00795318f, 0.37612808f, 0.27906924f, -0.17043282f, -0.15289442f, 0.19317150f, -0.41858387f, 
    -0.42484310f, 0.18054517f, 0.30319846f, -0.40854448f, 0.19150585f, -0.46650696f, -0.11308938f, -0.49391207f, 
    0.38474515f, -0.33968979f, -0.24247831f, 0.01968636f, -0.01120323f, -0.59811628f, -0.17143239f, -0.34920633f, 
    -0.62161016f, 0.32557568f, 0.21717231f, 0.11062406f, 0.05174888f, -0.47206879f, -0.01467906f, 0.14156692f, 
    -0.13624926f, 0.45002598f, -0.20586978f, -0.91730982f, 0.13365822f, 0.14240851f, 0.01355235f, -0.43817756f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.01369736f, 0.03809227f, 0.00263021f, 0.14946844f, 0.13675851f, -0.00298336f, 0.16232665f, -0.11779069f, 
    -0.11271638f, 0.09305365f, 0.23433581f, -0.06916727f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
