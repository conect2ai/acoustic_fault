#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.05546010f, 0.61572599f, 0.45096415f, 0.04266517f, 0.30558655f, -0.45061898f, -0.02637624f, 0.46784577f, 
    -0.30195075f, 1.34602916f, -0.97483206f, -0.69231409f, 0.82208329f, -0.21072535f, 0.48821071f, 0.04021764f, 
    0.33048102f, -0.50556749f, 0.32679400f, -0.94218469f, -0.11376115f, -0.68976206f, -0.76350325f, -0.62638432f, 
    0.31418005f, 0.40260410f, 0.08887851f, -1.51200366f, 1.28570521f, -0.29304203f, 0.52905297f, -0.29864997f, 
    0.06482894f, -0.06433684f, -0.21631739f, 0.07328700f, -0.23924118f, -0.21992862f, 0.46619129f, 0.25982347f, 
    0.40453860f, -0.34736225f, -0.44748795f, -0.39956161f, 0.59315926f, -0.86082602f, -0.76123440f, 0.28761345f, 
    0.19121408f, -0.26528791f, -0.47700685f, -0.39545253f, -0.26112059f, 0.35317358f, 0.99711412f, 1.04839957f, 
    -0.87971449f, -0.49895847f, -0.55339146f, 0.01239617f, 0.05142269f, -0.06372605f, 0.25464270f, -0.29773849f, 
    0.18281132f, -0.07336938f, -0.04548862f, -0.15788412f, -0.33589709f, 0.29764333f, 0.56197089f, -0.16524924f, 
    -0.35791406f, -0.32624185f, -0.81284654f, -0.33715850f, 0.55928957f, 0.48278889f, -0.46714115f, -0.41934013f, 
    -0.63475418f, -1.11597860f, -1.07214546f, -0.37797105f, 0.82533520f, 0.60510224f, 0.08178767f, 0.17089419f, 
    -0.28796238f, 0.15093841f, -0.49417335f, -0.21145509f, 0.46839663f, 0.13847347f, -0.24509737f, -0.50169480f, 
    -0.07532987f, 0.60557127f, 0.26240844f, -0.67906928f, 0.87521112f, -0.23521459f, -0.82201028f, -0.41942421f, 
    -0.17268461f, 0.15351386f, -0.55223835f, -0.18765274f, -0.04293857f, 0.10275465f, -0.39825088f, -0.18491249f, 
    0.02795332f, 0.16522132f, 0.18624896f, 0.24330761f, 0.27170289f, 0.39934352f, -0.36712009f, 0.22194648f, 
    -0.12649925f, -0.24001244f, 0.43168226f, -0.56340688f, 0.39797378f, 0.19373351f, 0.51733249f, 0.52335578f, 
    -0.10571604f, -0.07419633f, 0.15958072f, 0.11690113f, -0.45280328f, 0.50276613f, 0.00903390f, 0.28289989f, 
    -0.20203684f, 0.05100056f, 0.48974398f, -0.27176937f, -0.23813809f, 0.85507786f, -0.56580496f, -0.24826053f, 
    -0.13473612f, 0.21944208f, 0.14745192f, 0.09720630f, 0.35741800f, 0.61495364f, -0.14373301f, -0.34020010f, 
    -0.57261199f, 0.35679689f, 0.28346014f, 0.08581860f, -0.50786996f, -0.00113524f, 0.12858248f, -0.47999427f, 
    -0.10060614f, 0.52563590f, 0.16144589f, -0.45197865f, 0.80400449f, 0.03556817f, -0.52476972f, -0.25122827f, 
    0.23440075f, -0.17507501f, 0.36299840f, -0.12481999f, 0.94094849f, -0.68111783f, -0.89592344f, -0.69399101f, 
    -0.19187784f, 0.40980151f, 0.05291735f, 0.06387697f, -0.13279963f, -0.42170849f, 0.00247129f, -0.64142078f, 
    -0.04312729f, -0.38804093f, -0.36975411f, -0.53231376f, -0.57768595f, -0.63644326f, -0.47326660f, -0.64100093f, 
    1.11749089f, -0.34622666f, -0.58578503f, -0.46875450f, -0.10576257f, -0.03733227f, -1.12129450f, 0.25994545f, 
    0.63177252f, 0.03287870f, 0.80522329f, 0.09427434f, -0.11988396f, -0.46832755f, -0.25860211f, -0.83203739f, 
    -0.03243277f, -0.65110946f, -0.19193029f, 0.62657160f, 0.38054627f, -0.18538645f, 0.26937559f, 0.31439263f, 
    0.06445578f, -0.37160459f, -0.49452287f, -0.17461501f, -0.10091113f, -0.37318757f, 0.45256338f, 0.45633689f, 
    0.38008362f, -0.94702339f, -0.71789879f, 0.36824730f, -0.53108686f, -0.64725268f, -0.12763311f, 0.42256656f, 
    -0.39379907f, -0.33023995f, 0.52778095f, -0.11479103f, 0.33723235f, 0.40312782f, 0.35615417f, -0.19690952f, 
    0.27383146f, 0.43985641f, 0.10917551f, 0.68812460f, 0.67293811f, 0.71391863f, -0.93430465f, -0.48967505f, 
    0.04488340f, 0.02042019f, -0.21156898f, -0.29084694f, 0.49418017f, -0.41686228f, -0.21376759f, 0.22379422f, 
    0.07041758f, 0.47813529f, -0.41403398f, -0.53743428f, 0.48558506f, -0.30161420f, -0.16526398f, -0.26385432f, 
    -0.38107732f, -0.42958915f, -0.38710660f, -0.37467787f, -0.20089062f, -0.47837013f, -0.67337024f, 0.44440854f, 
    0.54557097f, -0.84093595f, 0.06262350f, 0.25628591f, 0.21159621f, 0.27051488f, -0.02897969f, -0.65592897f, 
    -0.72697419f, 0.24018146f, -0.10126408f, -0.67727834f, 1.05020583f, 0.20272177f, -0.08257930f, 0.23310876f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04183322f, 0.06757649f, 0.24819835f, 0.00760328f, 0.23739488f, -0.17126752f, 0.19677371f, -0.14032078f, 
    0.15517519f, 0.36187008f, -0.12551372f, -0.06662210f, -0.09786979f, 0.28315398f, 0.24981712f, 0.14477390f, 
    0.03768821f, 0.15955181f, -0.09618773f, 0.07236092f, -0.16112982f, -0.23091720f, 0.03590005f, 0.25743335f, 
    0.13184105f, -0.28432006f, -0.23939569f, 0.29066634f, 0.28735974f, -0.25581107f, 0.01612758f, 0.16844831f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18996052f, 0.04714269f, -0.04813924f, -0.11414515f, -0.03638666f, 0.05096664f, -0.01271864f, 0.03810215f, 
    -0.21686697f, 0.13946643f, 0.18129723f, 0.09457083f, 0.16884245f, 0.03524621f, 0.20056581f, 0.20727275f, 
    -0.01446008f, 0.03541615f, -0.06402311f, 0.08844285f, -0.69783175f, -0.25201946f, 0.16068056f, -0.01730536f, 
    0.04190885f, 0.04164844f, 0.06379664f, -0.00223169f, 0.11165860f, -0.02238574f, -0.02147056f, 0.02200699f, 
    0.27363515f, 0.07732478f, 0.12971932f, -0.10613158f, 0.02267218f, 0.04759107f, 0.02509114f, 0.04300991f, 
    0.19139120f, -0.17046064f, 0.24069968f, 0.15211184f, 0.13034552f, -0.01985384f, -0.18211222f, 0.01024307f, 
    0.01896992f, 0.03764601f, -0.04346234f, 0.03173072f, -0.05150319f, -0.12200057f, -0.02869573f, -0.05525199f, 
    0.03212876f, 0.00691697f, 0.06043931f, 0.00487314f, 0.69814986f, -0.50802219f, 0.07011887f, 0.07390248f, 
    -0.12741415f, 0.05196008f, 0.21582504f, 0.15647683f, 0.10498822f, 0.38526031f, 0.19219682f, 0.00167913f, 
    -0.00274776f, 0.15042354f, 0.00003251f, 0.10321678f, 0.02422144f, 0.03978330f, 0.15418880f, 0.07565872f, 
    -0.04605210f, 0.07092015f, -0.09197220f, -0.04607200f, -0.17622393f, -0.01702851f, -0.02407316f, 0.00310273f, 
    -0.03503264f, -0.01142962f, 0.07043440f, -0.06612231f, -0.15519282f, 0.24606343f, 0.16499242f, 0.06763007f, 
    -0.07362348f, -0.03087004f, 0.06912370f, 0.10572342f, -0.29483545f, -0.18957298f, -0.08073314f, -0.20907244f, 
    -0.02677155f, -0.02351185f, -0.14605933f, 0.04949053f, -0.09849660f, 0.02884383f, 0.05252337f, 0.02018836f, 
    -0.05837079f, 0.11623423f, 0.03331610f, 0.11486376f, 0.03199129f, 0.01834728f, 0.20440736f, 0.14883809f, 
    0.40247852f, 0.09650449f, -0.18176751f, 0.12693824f, 0.26520607f, 0.07138396f, 0.14977889f, 0.32097116f, 
    0.31233141f, -0.02647541f, -0.06779952f, -0.00537891f, 0.05831842f, -0.17186376f, -0.01866339f, 0.02161292f, 
    0.02762599f, 0.18139541f, 0.00235748f, 0.12620439f, -0.11103382f, 0.02166180f, 0.25586107f, 0.19306859f, 
    0.15318480f, -0.11064667f, -0.12329042f, 0.17267531f, -0.20668104f, 0.03973706f, 0.02872088f, 0.16236296f, 
    0.03301093f, -0.20777525f, -0.04144014f, -0.07837968f, -0.00680667f, 0.09641660f, 0.00160625f, -0.01522733f, 
    -0.08736007f, -0.12646215f, -0.28070107f, 0.03930070f, 0.21088214f, 0.02044292f, 0.08556262f, -0.17278475f, 
    0.14735191f, -0.02019792f, -0.02951118f, -0.05215165f, 0.05064465f, 0.16551575f, 0.00964570f, -0.04865908f, 
    -0.01284636f, 0.13382275f, 0.11877122f, 0.05834736f, -0.30049077f, 0.11185792f, -0.10655142f, 0.13288888f, 
    -0.06225202f, -0.09587532f, -0.02138616f, -0.06854655f, 0.05969540f, 0.23041843f, -0.03072701f, 0.06366910f, 
    0.05249199f, 0.14461128f, -0.08217148f, -0.04311115f, -0.03532865f, -0.04930633f, -0.06628867f, -0.00040331f, 
    -0.11152456f, -0.09560465f, 0.01701893f, 0.11218186f, 0.05167711f, -0.05720794f, -0.05535281f, -0.12364824f, 
    -0.26100266f, 0.10315964f, 0.06811583f, 0.16344120f, -0.03872684f, -0.07873601f, -0.00112608f, -0.00865514f, 
    -0.02825941f, 0.05901301f, 0.01817955f, -0.08268801f, 0.28654051f, -0.02687257f, -0.21202333f, 0.33054844f, 
    0.20810966f, 0.10416691f, -0.16051131f, 0.08862557f, 0.09928038f, -0.11269034f, 0.06386352f, 0.06016865f, 
    0.03647117f, 0.00574964f, -0.05157851f, 0.16625501f, 0.08690254f, 0.04448742f, 0.19267488f, -0.01181423f, 
    -0.06582094f, 0.06914435f, 0.18064238f, 0.03097315f, 0.01570467f, -0.04396479f, -0.02070749f, -0.03838972f, 
    -0.00366204f, 0.01873931f, 0.09420217f, 0.08350533f, 0.03516449f, -0.13156636f, 0.03216696f, -0.01167116f, 
    0.07892048f, -0.01493070f, 0.03369090f, -0.06967515f, -0.08611287f, -0.01987787f, -0.03340609f, 0.00253226f, 
    -0.06893987f, 0.20497601f, -0.07849380f, 0.01934019f, 0.20834748f, -0.10812474f, 0.03479091f, 0.01891170f, 
    -0.00829623f, 0.03943356f, 0.05165185f, 0.18136074f, -0.03525393f, 0.04796401f, 0.04535085f, 0.02930531f, 
    -0.14819621f, -0.01625699f, -0.02019903f, -0.07796022f, -0.15816577f, -0.05031706f, 0.02827822f, 0.04718380f, 
    0.05839863f, -0.01539181f, -0.03258120f, -0.03547558f, 0.00215040f, 0.02054018f, 0.00482593f, 0.17558014f, 
    0.13178654f, 0.23656650f, -0.04676899f, -0.02865249f, 0.08334917f, -0.12006071f, 0.10859489f, 0.38463044f, 
    -0.17619623f, -0.07315607f, 0.02653044f, 0.00974574f, -0.09770747f, 0.20037843f, -0.13600233f, -0.19535552f, 
    -0.01907899f, -0.00813573f, 0.09195506f, -0.06502715f, 0.21184941f, 0.22594789f, -0.14090261f, 0.20026030f, 
    -0.09714296f, 0.25293669f, -0.05421421f, -0.02524739f, -0.10783035f, -0.06261232f, 0.01273164f, -0.04424815f, 
    -0.07477167f, -0.09948946f, -0.11094090f, -0.05024822f, 0.06818065f, -0.01161423f, 0.02005984f, -0.03848255f, 
    0.13419110f, -0.01222092f, -0.06920964f, -0.00460287f, -0.03262118f, 0.10489370f, -0.02944358f, 0.00666822f, 
    0.00730893f, 0.05553878f, 0.07482041f, 0.05779035f, 0.16544616f, 0.02815805f, -0.07593744f, -0.10502528f, 
    -0.04992294f, -0.05887296f, -0.03721240f, 0.11783875f, -0.00259861f, 0.30782157f, 0.05525810f, 0.06561605f, 
    0.31687239f, -0.16480523f, 0.13935623f, 0.35211262f, -0.25814077f, 0.11971275f, 0.09943327f, 0.17693983f, 
    0.05809158f, -0.11648552f, -0.05872627f, 0.07555910f, -0.07964012f, 0.02198987f, 0.15373118f, 0.08755331f, 
    -0.01303758f, 0.08601848f, 0.11721264f, 0.25007364f, 0.14579158f, 0.00184855f, -0.19711404f, 0.15542918f, 
    0.45778924f, -0.16550951f, -0.16145828f, 0.31688163f, 0.16140115f, -0.06004969f, 0.10168219f, 0.08975112f, 
    0.11368457f, -0.14552899f, -0.03035432f, -0.01745005f, 0.02905617f, 0.04899303f, 0.14064232f, -0.00139292f, 
    -0.17220119f, -0.13054132f, -0.19820721f, 0.18882866f, 0.11395631f, -0.08400245f, -0.00897719f, 0.08185997f, 
    0.06457657f, -0.14328760f, 0.02083535f, 0.01092224f, -0.03658744f, 0.10568919f, 0.04186133f, 0.35669598f, 
    0.29724088f, 0.05542544f, 0.03359660f, -0.00708959f, -0.24456631f, -0.25448194f, -0.23183864f, -0.14430769f, 
    0.06603234f, -0.11155473f, -0.01712053f, 0.03530870f, -0.13609959f, 0.30681390f, -0.03990273f, -0.01832378f, 
    -0.05329458f, 0.08778343f, -0.00010015f, 0.10609060f, 0.03370941f, 0.19905779f, -0.07333203f, -0.02822721f, 
    -0.34586897f, 0.39246756f, -0.10257877f, 0.22376318f, -0.36275950f, -0.01383760f, 0.03404829f, 0.00816501f, 
    -0.14080338f, -0.06755512f, 0.13182111f, 0.02387789f, 0.21145515f, 0.03771027f, 0.02637912f, -0.21151578f, 
    -0.04952908f, 0.01007591f, 0.00219139f, -0.04732120f, 0.08239228f, 0.21420626f, 0.08998085f, 0.07305295f, 
    0.04311809f, -0.00448971f, -0.01752694f, -0.16915244f, 0.07370462f, 0.33490270f, 0.13678552f, 0.04437026f, 
    -0.03978613f, -0.12734441f, -0.14881897f, -0.05483715f, -0.07863785f, 0.00388514f, -0.03299311f, -0.09680683f, 
    -0.00056898f, -0.04298316f, 0.27972364f, 0.11432344f, 0.09515183f, -0.03485816f, -0.07572232f, -0.08553929f, 
    -0.01978012f, 0.18245627f, 0.00959757f, -0.00669017f, -0.16523157f, -0.14873087f, -0.08086237f, -0.04949918f, 
    0.03537031f, 0.02800682f, -0.03951258f, -0.05366497f, -0.16168348f, -0.27782518f, -0.07167401f, 0.29262033f, 
    -0.26444507f, -0.08321578f, -0.27217680f, -0.00119899f, -0.19522409f, -0.00674579f, -0.00902631f, 0.02740365f, 
    0.01064228f, 0.09726586f, -0.04015548f, 0.05757035f, -0.03182315f, -0.01950820f, 0.43614927f, 0.02975866f, 
    -0.15998203f, -0.06947880f, -0.06583523f, -0.15363733f, -0.17939234f, -0.02642137f, -0.01312805f, 0.00308702f, 
    -0.07421325f, -0.06485463f, 0.07568199f, 0.14513853f, 0.11841922f, 0.20295575f, 0.27143925f, 0.09756897f, 
    0.14849791f, 0.03109261f, -0.03132564f, 0.08997059f, 0.07207423f, 0.02755183f, -0.32244560f, 0.12401780f, 
    0.05381117f, 0.04165982f, -0.00887963f, 0.20773362f, 0.02592687f, -0.07359153f, -0.09795674f, -0.06938117f, 
    -0.00746193f, -0.11686119f, -0.06868248f, -0.03301162f, -0.03635745f, -0.05370510f, 0.02912983f, 0.15548475f, 
    -0.26565251f, -0.01033487f, -0.08464415f, -0.14145656f, -0.09730215f, -0.00324648f, -0.04561601f, -0.02750667f, 
    0.07340008f, 0.00791097f, -0.03364203f, 0.26332331f, 0.05441346f, 0.27509987f, 0.14515153f, -0.01228300f, 
    -0.13718121f, 0.02268178f, 0.01921375f, 0.09134702f, -0.14769319f, -0.21148121f, -0.13067633f, 0.08225831f, 
    0.14528784f, -0.16228890f, -0.09557182f, -0.00631003f, 0.06868504f, -0.06934351f, 0.02110234f, 0.03774728f, 
    -0.02370789f, 0.10937226f, 0.02181355f, 0.32198930f, 0.17156225f, 0.08475569f, 0.21774071f, 0.00003463f, 
    0.00828649f, 0.11676998f, -0.15709814f, -0.02628829f, -0.02347738f, 0.12442338f, 0.00006603f, -0.00933082f, 
    -0.12608340f, -0.07292974f, 0.04043062f, 0.05017690f, 0.15568477f, -0.02985294f, 0.06214333f, -0.02347117f, 
    -0.02703791f, 0.01447768f, 0.08273701f, 0.01613710f, 0.34029028f, -0.20209935f, 0.22294487f, 0.27839220f, 
    -0.11584602f, 0.16147098f, -0.11580427f, -0.11605054f, 0.12692910f, 0.12465958f, 0.14976963f, 0.04361427f, 
    0.10104018f, 0.06581765f, -0.05727853f, -0.00548858f, -0.01548662f, -0.08937535f, 0.14021641f, -0.00526566f, 
    0.29134756f, 0.21213453f, 0.14699821f, -0.13600047f, 0.19443518f, 0.06013535f, -0.16236751f, 0.11153696f, 
    -0.22168688f, 0.12649715f, 0.04093335f, -0.03114296f, 0.18610023f, -0.03672801f, 0.13585888f, 0.01456108f, 
    -0.07408670f, -0.06779621f, -0.09631711f, 0.14673102f, -0.49240643f, 0.38733420f, -0.09961984f, 0.24684711f, 
    0.05257975f, 0.01778505f, 0.08770455f, 0.03915237f, -0.03588362f, -0.10514319f, -0.06302462f, -0.04947619f, 
    0.14987002f, 0.07165165f, 0.00878541f, -0.04267129f, 0.03388427f, -0.01761961f, -0.06792711f, -0.05072922f, 
    -0.23766367f, -0.02625158f, -0.03802933f, 0.15169744f, 0.26948273f, 0.05195374f, 0.06028527f, -0.00745656f, 
    0.08300418f, -0.07024059f, 0.01977412f, 0.00573289f, -0.07400380f, 0.01514839f, 0.01737717f, 0.04872563f, 
    -0.08356222f, -0.05589246f, 0.01854850f, 0.11426661f, 1.22072530f, -0.35541633f, 0.43562925f, 0.20456789f, 
    0.16645630f, 0.30909124f, 0.04913051f, 0.25626609f, 0.21722707f, 0.16012076f, 0.03267752f, -0.03357579f, 
    -0.03979493f, 0.01382883f, 0.02594080f, 0.05277520f, -0.03716822f, 0.07166100f, 0.23947318f, 0.00864976f, 
    -0.05042035f, 0.00232140f, 0.08650051f, -0.33678827f, -0.26465023f, 0.04532185f, -0.07558474f, 0.03081419f, 
    -0.00604736f, 0.08067747f, -0.05646306f, -0.06545999f, -0.09366101f, 0.07216315f, 0.11170364f, -0.09928308f, 
    -0.10541266f, -0.09915631f, 0.11359438f, -0.25565055f, -0.44069880f, 0.02053591f, 0.05818902f, -0.00301516f, 
    0.25216922f, 0.01424614f, -0.07378158f, -0.04139315f, -0.15635051f, -0.02982196f, -0.06726091f, 0.03127832f, 
    -0.02370806f, 0.11907125f, 0.01263550f, -0.03006622f, 0.01109430f, 0.00260009f, 0.00160316f, -0.01306967f, 
    0.13069558f, -0.31660900f, 0.17404455f, 0.24281844f, 0.43606821f, 0.06078661f, 0.19847460f, 0.22134057f, 
    0.05915520f, -0.10584102f, -0.00381914f, -0.03104566f, -0.00005244f, -0.09942943f, -0.01539900f, 0.05686091f, 
    -0.02488702f, 0.11293048f, 0.01426755f, 0.02651288f, -0.16741075f, 0.01926611f, 0.04502593f, 0.04339972f, 
    0.18602456f, 0.18018128f, -0.00395722f, 0.12187073f, -0.01348598f, 0.06222989f, 0.14759134f, -0.02114881f, 
    0.15234110f, -0.10043074f, -0.03722158f, 0.11038063f, -0.09155615f, 0.08584045f, -0.08461616f, 0.10799532f, 
    -0.07349886f, 0.08580054f, -0.06758538f, -0.07502712f, 0.24099328f, 0.08311518f, 0.11430028f, -0.04228924f, 
    0.12506284f, 0.04741561f, -0.06837204f, 0.02057664f, -0.05371805f, 0.01773516f, 0.02613332f, -0.03490578f, 
    0.07801813f, 0.01084847f, 0.00794440f, 0.05259088f, -0.28359601f, 0.33403033f, 0.25155923f, -0.03873473f, 
    0.38482055f, 0.13353932f, -0.03699485f, 0.00408293f, -0.19730794f, 0.13624260f, -0.24043936f, 0.12167994f, 
    -0.03067577f, 0.00354111f, 0.01820232f, -0.07616965f, -0.02404369f, -0.05602277f, -0.04225272f, -0.04583309f, 
    -0.23314112f, 0.04864381f, -0.08774942f, -0.02559221f, 0.29077545f, 0.22418295f, -0.08715062f, 0.03754424f, 
    -0.02140639f, 0.06230373f, 0.09670060f, 0.02780195f, -0.14152156f, 0.01324593f, 0.01874788f, -0.07582194f, 
    -0.08693784f, 0.08362584f, -0.17209277f, 0.09136720f, 0.22489779f, -0.13704711f, -0.13314128f, 0.08072739f, 
    0.37032777f, -0.10041055f, 0.17272739f, 0.10564572f, 0.21816096f, -0.04489949f, 0.03942117f, 0.03291248f, 
    -0.03329563f, 0.02158185f, 0.05743571f, 0.07167299f, -0.03812750f, -0.06619423f, 0.07446560f, 0.04567280f, 
    -0.06363171f, -0.05609928f, -0.00919665f, 0.04184578f, 0.02117380f, -0.10377263f, 0.04370696f, 0.00181139f, 
    -0.07508974f, 0.02068676f, 0.12804569f, -0.04537834f, 0.00978451f, -0.10806989f, 0.00956750f, 0.04580967f, 
    -0.00143895f, 0.04882358f, 0.01913341f, -0.01938777f, -0.15575890f, -0.13973367f, -0.05387841f, -0.12076666f, 
    -0.05383948f, -0.02380458f, -0.08070822f, -0.00201746f, 0.15865076f, -0.01013866f, -0.08793400f, -0.00197018f, 
    -0.11204703f, 0.01620741f, 0.07384790f, 0.00546396f, 0.04985993f, 0.17949620f, -0.02590088f, -0.06087396f, 
    -0.03028166f, -0.20925766f, 0.04034837f, -0.09823310f, -0.09992607f, -0.02726000f, -0.04868766f, -0.09309280f, 
    -0.07789158f, -0.04824520f, 0.00319657f, 0.00799959f, 0.01191272f, -0.08318811f, 0.00279656f, 0.08676518f, 
    0.08441783f, 0.10869089f, -0.10790662f, -0.06992685f, -0.02461978f, 0.16781196f, 0.07172216f, 0.26032552f, 
    -0.18995517f, 0.02397473f, 0.01376069f, 0.00780243f, -0.07876050f, -0.01650052f, -0.09448168f, -0.01227682f, 
    -0.14671513f, 0.09725638f, -0.08814307f, 0.06340203f, 0.21332487f, 0.02602174f, -0.06288186f, 0.15443939f, 
    0.24192566f, -0.06859303f, 0.00517709f, -0.21676199f, -0.37918288f, 0.08075491f, 0.01623411f, -0.02378622f, 
    0.03104524f, 0.09783898f, -0.01967380f, -0.02177508f, 0.02779050f, -0.07374111f, -0.07843286f, -0.01246262f, 
    0.05076453f, -0.04595662f, -0.11565879f, -0.04844762f, 0.20575786f, -0.23160207f, 0.17381053f, -0.15123086f, 
    0.15412849f, -0.14843942f, 0.01055717f, -0.01823252f, 0.09337831f, -0.04903796f, -0.07215527f, 0.02628835f, 
    -0.02263560f, -0.05175351f, -0.04687305f, 0.07860483f, 0.00876677f, 0.05651635f, 0.10805828f, -0.03770905f, 
    -0.32477477f, -0.21743715f, 0.39157617f, 0.25387031f, 0.13525748f, 0.04505521f, 0.17035180f, 0.01133163f, 
    0.11322767f, 0.02852923f, -0.03116513f, -0.03573614f, -0.08216629f, 0.07328606f, 0.18729067f, 0.06984965f, 
    -0.02353129f, 0.18204254f, -0.00669800f, 0.10544231f, -0.02512270f, -0.13465007f, -0.05633661f, 0.12033144f, 
    0.46179083f, 0.02984572f, 0.17466109f, 0.23947869f, 0.21161580f, -0.09011705f, 0.06413196f, -0.01836373f, 
    0.01407564f, 0.02512399f, 0.05832167f, -0.05036747f, -0.07712524f, -0.00265415f, -0.01577321f, -0.03194201f, 
    -0.41925961f, -0.01776743f, -0.23629948f, 0.14680599f, 0.19176692f, -0.14991778f, 0.24819551f, 0.04547330f, 
    -0.11863109f, -0.02949949f, -0.02838422f, 0.06303712f, 0.05230305f, 0.05213197f, 0.00424925f, 0.14847599f, 
    0.15504827f, 0.07614974f, -0.06860439f, 0.01902942f, -0.17525205f, 0.03948262f, -0.09189327f, 0.22133876f, 
    0.41113612f, 0.03068109f, -0.00500512f, -0.07312046f, -0.12730482f, -0.03266057f, -0.05498989f, 0.06839857f, 
    0.03248360f, 0.09796146f, -0.00501783f, 0.03812263f, 0.09139292f, -0.00887538f, 0.10601240f, -0.08716330f, 
    0.62032014f, 0.04931941f, 0.30079705f, -0.46027741f, -0.22884163f, 0.20062946f, -0.02594954f, 0.15589681f, 
    -0.17920744f, 0.15624866f, -0.07752938f, 0.08576466f, 0.08722645f, 0.00594292f, -0.01513660f, -0.17744353f, 
    0.06323041f, 0.00197837f, 0.03985804f, -0.03539118f, 0.16245738f, 0.14661352f, 0.25643900f, -0.02284192f, 
    0.23982359f, 0.01413201f, -0.02879607f, -0.03629794f, 0.04027579f, 0.10391251f, -0.09521174f, 0.09142108f, 
    -0.05497568f, -0.12843995f, 0.00906184f, -0.07090712f, -0.04638998f, 0.00122687f, 0.01314161f, -0.06820146f, 
    -0.16409227f, -0.00082101f, -0.06252066f, 0.11397887f, 0.11931854f, 0.06643746f, 0.07341880f, -0.01818457f, 
    -0.07584092f, 0.14281274f, 0.17948207f, -0.03605794f, -0.03088042f, -0.04567822f, -0.02025131f, 0.06358726f, 
    -0.06176633f, 0.04542563f, 0.01511595f, 0.01260859f, -0.30258167f, -0.05058806f, -0.26800260f, 0.05333253f, 
    0.18866780f, -0.12947123f, -0.03418683f, -0.15441741f, -0.19918290f, -0.02742769f, -0.11187585f, 0.02785630f, 
    -0.05224091f, 0.14947721f, 0.00990902f, 0.08458982f, 0.01087831f, -0.05803837f, 0.17325662f, 0.05023916f, 
    -0.20376454f, -0.15012915f, -0.15000208f, -0.22273216f, -0.18008940f, 0.01705136f, -0.04082168f, 0.04408108f, 
    -0.03403590f, 0.02787086f, -0.13550906f, 0.00970098f, -0.05456065f, -0.00821915f, 0.01056051f, 0.10616355f, 
    -0.04221850f, -0.02377528f, -0.10812954f, -0.12002397f, 0.26387620f, -0.49069905f, 0.27700561f, -0.10036603f, 
    0.06983058f, -0.07689491f, -0.06316617f, 0.09173515f, 0.01917861f, -0.03017479f, 0.00719593f, -0.01413686f, 
    -0.04412499f, -0.11733607f, 0.01525521f, 0.09801181f, -0.03201823f, -0.01695934f, 0.00880302f, 0.12544179f, 
    -0.20664282f, 0.15659343f, -0.08005547f, -0.18218307f, -0.23825309f, -0.00271373f, 0.02109454f, -0.15118797f, 
    0.08051393f, 0.10251075f, -0.06606428f, -0.05535392f, 0.03751341f, -0.02016799f, 0.18767102f, -0.02567417f, 
    -0.01152034f, -0.13730250f, -0.04436043f, -0.09018894f, -0.15844378f, -0.13420537f, -0.32814977f, 0.02815588f, 
    0.25452143f, -0.15396893f, 0.11816309f, -0.04758683f, -0.02011541f, 0.02476431f, 0.01135350f, 0.05628745f, 
    -0.04050079f, 0.03735717f, -0.00699795f, 0.14855899f, 0.10195662f, -0.04805058f, -0.01615533f, 0.06503303f, 
    0.14787535f, -0.11608583f, 0.03901152f, -0.24335568f, -0.00164405f, 0.00992012f, 0.00811440f, 0.00068200f, 
    -0.04305046f, 0.11348358f, 0.00720527f, -0.00060236f, 0.01748731f, 0.04776192f, 0.13647504f, 0.05462164f, 
    -0.11032131f, -0.00697624f, -0.00979623f, 0.04691166f, -0.02306450f, 0.09840450f, 0.26997516f, -0.09051840f, 
    0.26576629f, -0.02271448f, -0.01801668f, -0.07424574f, 0.19842128f, 0.02098234f, -0.11632391f, 0.04532681f, 
    -0.12370228f, 0.01753454f, 0.04076303f, -0.01493305f, -0.03411511f, 0.09296908f, -0.00418500f, -0.05762941f, 
    0.01914506f, 0.00218365f, 0.01574110f, 0.02048395f, -0.04062120f, 0.00285176f, 0.01766681f, -0.03157615f, 
    0.02580243f, -0.00647850f, -0.01806633f, 0.01924395f, -0.03188161f, 0.02186720f, 0.01088946f, -0.02292455f, 
    0.03527544f, -0.00402922f, -0.01652613f, -0.00363311f, -0.02721448f, 0.00051259f, -0.04568284f, -0.04320858f, 
    -0.00192769f, -0.03798376f, 0.01828305f, -0.03772181f, -0.02618733f, -0.02151749f, 0.02351881f, 0.00590833f, 
    -0.03299932f, -0.04692096f, 0.01001866f, 0.02135101f, 0.01066749f, 0.00062857f, 0.00328634f, -0.00097914f, 
    -0.00257988f, -0.01084381f, 0.02706044f, 0.00086592f, -0.02929576f, -0.01916876f, -0.03309422f, -0.00072489f, 
    0.02226067f, -0.02966661f, -0.03550690f, 0.03220311f, -0.03201939f, 0.02562629f, 0.03583658f, 0.03387182f, 
    -0.01235954f, 0.02139597f, -0.01848866f, -0.02725808f, -0.03989735f, 0.00361564f, 0.03891030f, 0.01341360f, 
    -0.01143001f, 0.03126268f, -0.04270980f, -0.00606743f, -0.01233630f, -0.03565159f, 0.02128823f, 0.00422602f, 
    0.00741364f, 0.01773098f, 0.02302672f, -0.00352503f, -0.00898198f, -0.00142218f, 0.02408889f, -0.00906002f, 
    -0.01727821f, -0.02143580f, -0.01661713f, 0.03330589f, 0.00332218f, -0.00174789f, -0.04052277f, 0.02939654f, 
    -0.04061190f, -0.01273897f, 0.02973386f, -0.02100931f, -0.00291332f, 0.00648280f, 0.00654373f, 0.02128966f, 
    -0.03341668f, -0.02634290f, 0.01537873f, -0.02907394f, -0.02029802f, 0.00328384f, -0.03148819f, 0.02895661f, 
    -0.03865685f, 0.00564930f, 0.00732611f, 0.01073944f, -0.04037954f, -0.02420647f, -0.03687388f, -0.02727465f, 
    -0.01783564f, -0.02743928f, 0.02180401f, -0.00013718f, -0.01243572f, 0.03050381f, -0.02269135f, -0.00909087f, 
    -0.04868571f, -0.01178474f, 0.02970175f, 0.00333250f, -0.01395671f, -0.03524423f, 0.02664654f, 0.02063308f, 
    -0.00202783f, -0.00937566f, -0.01070607f, -0.02761324f, 0.03411686f, -0.00271785f, -0.00038419f, 0.01795204f, 
    -0.01179039f, -0.01462323f, 0.03323884f, -0.01927109f, -0.02594789f, -0.01501232f, 0.02599624f, 0.01067457f, 
    0.01145194f, -0.03671907f, -0.04757691f, -0.03109903f, 0.00136021f, -0.00747838f, -0.03910507f, 0.01318658f, 
    -0.00951236f, -0.03279552f, 0.02528694f, -0.00961116f, -0.03622139f, -0.01764366f, 0.01863719f, 0.02961984f, 
    0.01737211f, -0.03142910f, 0.02461048f, -0.01935285f, 0.00250915f, -0.00316953f, 0.00989575f, -0.01497020f, 
    0.01457256f, 0.00194286f, 0.00509855f, 0.01617850f, 0.01401968f, 0.03121185f, -0.02380803f, 0.01964282f, 
    0.02742128f, 0.00271258f, -0.03509082f, 0.00724465f, -0.03735401f, 0.01803102f, -0.03241583f, -0.03176478f, 
    0.00551637f, 0.02885446f, 0.00190088f, -0.03817286f, 0.02769281f, 0.03280704f, -0.04007479f, -0.03772471f, 
    0.00373122f, 0.00185024f, -0.01362980f, -0.02717136f, -0.01780819f, -0.01717271f, 0.01769820f, -0.01450383f, 
    0.01869305f, -0.02042197f, 0.01987367f, 0.00180030f, -0.01241786f, 0.01745497f, -0.00655889f, 0.02699307f, 
    0.00142113f, 0.00823784f, -0.04066787f, -0.00033003f, -0.02790103f, -0.03051106f, -0.00519562f, -0.01293674f, 
    -0.01832718f, -0.03619128f, 0.00692547f, 0.02769830f, 0.01305778f, 0.03008165f, 0.00796671f, -0.00282629f, 
    0.02596227f, -0.01884932f, 0.01839854f, 0.03554183f, -0.03549999f, -0.03465697f, -0.02348044f, 0.00283792f, 
    -0.01221161f, 0.02455627f, -0.03093254f, -0.03108216f, -0.03424064f, -0.02765746f, 0.01461436f, -0.01938115f, 
    0.00509630f, 0.02306021f, 0.00492776f, 0.02038452f, 0.02046254f, 0.00862031f, -0.01001715f, 0.02359546f, 
    -0.02870460f, -0.03220296f, 0.01521708f, -0.04259552f, -0.03371572f, 0.01100538f, 0.02864044f, -0.01132548f, 
    -0.00643753f, 0.02272704f, -0.02086777f, 0.04049705f, -0.01151963f, -0.03512578f, -0.04324685f, -0.02681352f, 
    -0.01423454f, -0.02159290f, 0.01922081f, -0.01269755f, -0.03626577f, -0.04002376f, 0.02802977f, -0.02589256f, 
    0.01235222f, 0.00488327f, 0.02260544f, -0.02742708f, 0.00161161f, -0.02529554f, 0.02413560f, -0.01531310f, 
    -0.02886883f, 0.02651958f, 0.01092591f, 0.03714121f, 0.01234429f, -0.00343883f, 0.03696566f, 0.01853396f, 
    0.01513543f, -0.03182631f, -0.00404549f, 0.01748970f, -0.03746685f, 0.01605819f, -0.01704797f, 0.00441571f, 
    0.00802994f, -0.00390686f, -0.00360756f, -0.01684209f, 0.01793414f, -0.02665145f, -0.04033640f, -0.02146403f, 
    0.01939542f, 0.02236228f, -0.03351944f, 0.02136301f, 0.02154986f, -0.03224614f, -0.03834896f, 0.00282737f, 
    -0.03195732f, -0.02428048f, 0.01727728f, -0.02477045f, -0.00364201f, -0.02189297f, 0.01754282f, 0.01781751f, 
    -0.02352022f, 0.02727985f, 0.02104866f, -0.02152084f, -0.02247494f, -0.02525320f, 0.01193397f, 0.02338384f, 
    0.02045058f, 0.02574466f, 0.01530523f, -0.01134503f, 0.02494250f, 0.03169530f, 0.01575415f, -0.03954574f, 
    -0.01894622f, 0.00428281f, -0.03945964f, 0.00734852f, -0.03667285f, -0.02433440f, 0.01888283f, -0.02372429f, 
    -0.03100977f, 0.00178100f, 0.01980950f, -0.02762275f, 0.02730295f, -0.03268398f, 0.00076370f, -0.04482996f, 
    0.01013174f, -0.02776357f, 0.00199331f, -0.03220907f, -0.03800977f, 0.02690232f, -0.01321758f, 0.01905048f, 
    -0.01661095f, 0.01429798f, -0.02309717f, 0.02101648f, -0.00711636f, -0.01114995f, -0.00682591f, -0.00958551f, 
    -0.02406912f, -0.02165493f, -0.01360795f, -0.02703146f, -0.02297159f, 0.00872314f, 0.02821021f, -0.00627519f, 
    -0.03794564f, 0.00010408f, 0.01135171f, -0.01659283f, 0.02008906f, -0.02423447f, 0.00482320f, 0.02535013f, 
    -0.00944466f, -0.02260061f, -0.04251448f, 0.03675948f, -0.04579931f, 0.03334814f, 0.01197011f, 0.02991778f, 
    -0.03216486f, -0.00043914f, -0.01499799f, 0.03711023f, -0.02952941f, 0.02891022f, 0.00760894f, -0.02893240f, 
    0.01787164f, 0.02240024f, 0.00319401f, 0.03005733f, -0.02661427f, 0.02514206f, 0.02426576f, -0.02786947f, 
    0.03485248f, 0.00653884f, -0.02900109f, -0.03342317f, -0.01219336f, 0.03289305f, 0.00042954f, 0.00368284f, 
    -0.01518842f, -0.01482212f, -0.01887185f, 0.02883309f, 0.00303052f, -0.00021200f, 0.00685184f, -0.00244736f, 
    -0.03755159f, -0.00012034f, -0.02212454f, -0.03918651f, -0.00798713f, 0.00719022f, -0.00803933f, 0.01427448f, 
    0.00641244f, -0.01591817f, 0.02102775f, 0.02437837f, -0.01580445f, -0.02473950f, 0.03778330f, 0.01237215f, 
    0.01569226f, 0.02857501f, -0.02816032f, -0.03693698f, 0.02284210f, -0.01523343f, 0.02074745f, 0.02031339f, 
    -0.01438304f, 0.02753768f, 0.03294754f, 0.03265857f, 0.01889153f, 0.00357033f, 0.00606745f, 0.02752497f, 
    0.01765307f, 0.00550546f, 0.01298914f, -0.03787434f, -0.02180671f, -0.00550969f, -0.01581977f, 0.01271282f, 
    0.02741384f, -0.01854552f, 0.01123275f, 0.00763235f, 0.01998956f, 0.01746672f, -0.00626665f, -0.01262850f, 
    -0.02164801f, -0.02050995f, -0.02570762f, -0.02294656f, 0.02560362f, 0.00774845f, 0.00932758f, -0.03324035f, 
    -0.03365392f, -0.02249174f, 0.01240444f, 0.00011263f, -0.01345325f, -0.02680999f, 0.01142072f, 0.01325730f, 
    0.01690211f, 0.00861825f, 0.03440887f, -0.02242163f, -0.00721308f, -0.03584032f, 0.00289831f, 0.00212557f, 
    0.00492777f, 0.01188114f, -0.01076645f, 0.03288824f, 0.02903960f, -0.00696382f, -0.01101811f, -0.00032076f, 
    -0.01758557f, -0.01238658f, -0.01240403f, 0.01145099f, 0.03419485f, -0.02422449f, 0.01714702f, 0.02047196f, 
    -0.03835926f, 0.02737218f, -0.03803876f, 0.02859733f, 0.02971502f, -0.02638101f, 0.01206043f, 0.03211698f, 
    -0.02223013f, -0.01641902f, 0.01969311f, -0.01708112f, -0.03777266f, -0.00064460f, 0.00880655f, -0.03743608f, 
    0.01132524f, 0.00339618f, -0.00936719f, 0.01610256f, -0.02733798f, -0.02704297f, -0.03603862f, -0.04206090f, 
    -0.00938871f, 0.02763561f, 0.00748392f, 0.02485904f, -0.01149356f, 0.02502589f, 0.01262436f, -0.02639977f, 
    -0.01358098f, 0.02650305f, -0.01128904f, 0.01598872f, -0.01977122f, 0.03087570f, -0.01040455f, -0.02937192f, 
    -0.01323641f, 0.00460605f, -0.00220180f, -0.02248095f, -0.01183985f, 0.00249013f, -0.03457363f, 0.01572509f, 
    -0.03461434f, 0.00364402f, -0.02353434f, -0.00378824f, -0.03855534f, -0.02732943f, -0.02301011f, 0.02694675f, 
    -0.02082638f, 0.01551987f, 0.00752070f, -0.02341175f, 0.03160765f, -0.02046774f, -0.01093786f, 0.03227858f, 
    -0.02641809f, 0.01754405f, -0.03575840f, 0.02731981f, -0.01156013f, -0.03069779f, -0.01308446f, -0.04494878f, 
    0.03076914f, -0.01111733f, -0.00513389f, 0.02991918f, 0.01847076f, -0.04040486f, 0.03449951f, -0.02310725f, 
    0.00476784f, -0.00225491f, 0.00595476f, 0.03481575f, -0.03164914f, 0.02400479f, -0.00342953f, 0.03061307f, 
    0.02966942f, -0.00553568f, -0.02625156f, -0.03254837f, 0.01949176f, -0.04749563f, 0.00231109f, -0.03644818f, 
    -0.01867713f, -0.01988694f, 0.03120058f, 0.03291531f, 0.01265997f, 0.02178826f, 0.01229383f, -0.00968437f, 
    0.01045032f, 0.02959827f, 0.02410701f, 0.01618394f, 0.01182271f, 0.00561293f, -0.01109991f, -0.00231484f, 
    -0.01256318f, 0.02632720f, -0.03844674f, -0.01593399f, -0.03624828f, -0.00685106f, 0.01067667f, 0.03481756f, 
    -0.00286623f, 0.00916740f, -0.01545231f, 0.01926714f, -0.02070715f, -0.02927077f, -0.01545865f, -0.00442839f, 
    -0.08949138f, 0.18473524f, -0.20339082f, -0.05378406f, 0.26543441f, -0.22274056f, 0.25974241f, 0.07246550f, 
    -0.13363743f, 0.11391947f, -0.00312780f, -0.07424455f, 0.05096450f, -0.07868186f, 0.13849498f, -0.03885930f, 
    -0.02332490f, -0.19630703f, -0.14645922f, 0.02194158f, 0.43886036f, -0.15970649f, 0.23185149f, -0.05370380f, 
    -0.18983862f, -0.02911128f, -0.06973008f, -0.04512636f, 0.04212673f, -0.13996369f, 0.10719580f, 0.02535626f, 
    0.09434684f, -0.01421375f, -0.06163941f, 0.00428181f, 0.01533843f, -0.09313142f, -0.18548425f, -0.03041748f, 
    -0.13957211f, -0.02669785f, 0.12477615f, 0.11538201f, 0.17378715f, -0.00660907f, -0.08974712f, 0.16415155f, 
    0.16484393f, 0.14363515f, -0.00163742f, -0.04470547f, 0.06574290f, -0.04341176f, -0.04484225f, 0.05676430f, 
    0.01612707f, 0.05243656f, 0.01433123f, -0.16706318f, 0.10796814f, -0.43307781f, -0.05069070f, 0.24843802f, 
    -0.10234182f, -0.07039846f, 0.19484468f, 0.08249100f, -0.40592721f, 0.06353248f, 0.01403150f, -0.01896309f, 
    0.10828711f, 0.09056639f, -0.01844023f, 0.22327225f, 0.23954444f, 0.01866745f, 0.07264126f, -0.12544885f, 
    -0.09890922f, 0.21348038f, 0.09377836f, 0.11697848f, -0.02665772f, 0.09599151f, 0.21722160f, 0.09381124f, 
    -0.08937670f, -0.06310160f, -0.03099059f, 0.07800043f, -0.00306095f, 0.05895136f, -0.14903840f, -0.05218726f, 
    0.05954663f, 0.01571192f, -0.22656579f, -0.21564214f, -0.23096205f, -0.00387917f, -0.26852271f, -0.13111261f, 
    0.08375515f, -0.07017516f, 0.11715858f, 0.08089389f, 0.16208084f, 0.14088875f, -0.07388709f, -0.03405648f, 
    -0.01135256f, 0.03221087f, -0.07717433f, -0.00943913f, 0.07176216f, 0.12878239f, 0.02926148f, -0.02911365f, 
    0.04682571f, 0.37331834f, 0.17953682f, 0.10813951f, 0.01199560f, 0.03070533f, -0.11129314f, 0.16803637f, 
    0.19402230f, 0.09764516f, 0.01686175f, -0.03508262f, -0.17051400f, -0.04268962f, 0.01755753f, -0.08377071f, 
    0.10831784f, -0.00223120f, -0.03510357f, 0.01559001f, -0.22146539f, -0.23224112f, -0.14794901f, 0.02860413f, 
    0.14876585f, 0.12358837f, 0.11800458f, 0.05323368f, 0.06194535f, 0.33941445f, 0.01549202f, -0.02124845f, 
    -0.01939125f, -0.13542610f, -0.04343290f, -0.03258475f, -0.06904109f, -0.16540055f, -0.15591615f, -0.08408332f, 
    0.09263278f, -0.09322590f, -0.10903837f, 0.01529188f, -0.16453238f, 0.04615352f, -0.10100735f, -0.06701169f, 
    0.13322838f, 0.12277464f, -0.20508975f, 0.04538893f, 0.03697560f, 0.11360338f, 0.10198259f, 0.13575241f, 
    0.07874602f, 0.14668776f, 0.22088334f, 0.29282209f, 0.18361647f, 0.13288938f, -0.09146805f, 0.15486465f, 
    -0.23494589f, 0.04521061f, -0.04778913f, -0.20034069f, -0.06189866f, -0.12487251f, -0.06180596f, -0.15899816f, 
    0.13113376f, -0.00722246f, 0.17206854f, -0.04973792f, 0.06095820f, -0.13366725f, 0.10920326f, 0.10586597f, 
    -0.40446004f, 0.04787257f, -0.12635599f, -0.10856654f, 0.29450190f, 0.00509479f, 0.08939845f, 0.08210193f, 
    -0.00193803f, 0.12495930f, -0.19166605f, -0.02293668f, -0.09958064f, -0.08745968f, -0.13055052f, -0.13667259f, 
    -0.14001182f, 0.01024313f, -0.19270569f, -0.06859106f, 0.12342273f, -0.07687160f, -0.22722013f, -0.07322546f, 
    0.16937880f, -0.07386560f, 0.04242397f, 0.11737397f, -0.07413581f, 0.23565601f, 0.04196323f, 0.05375322f, 
    -0.06300665f, -0.02940939f, -0.03039921f, -0.07963321f, 0.05007565f, -0.05146153f, 0.13997032f, -0.00236551f, 
    -0.06337121f, 0.04002894f, 0.15343310f, -0.03580795f, -0.02686689f, 0.01635513f, -0.02397234f, -0.12533070f, 
    -0.01145049f, 0.04746914f, 0.01307423f, 0.11221083f, 0.01830895f, 0.02875722f, 0.04293931f, -0.10513341f, 
    -0.28155029f, -0.24876353f, -0.13958500f, -0.14166689f, -0.00896951f, 0.21868621f, 0.03797158f, -0.07995899f, 
    -0.03295281f, 0.01811267f, -0.03264294f, 0.14636491f, -0.13577119f, -0.09890880f, 0.03537315f, -0.06838934f, 
    -0.06068870f, -0.09036933f, 0.05662629f, -0.08572660f, 0.03165271f, 0.07894567f, -0.10451601f, -0.06592327f, 
    0.10955738f, 0.20631306f, 0.13152674f, -0.02350855f, -0.02831166f, 0.08507667f, -0.03472800f, 0.10404469f, 
    0.09713425f, 0.00944587f, 0.16197093f, 0.02756898f, -0.03025656f, 0.01310955f, 0.01670161f, 0.03064389f, 
    0.01838420f, 0.04264643f, -0.19800192f, -0.04180007f, 0.13280658f, -0.30685800f, 0.24203074f, 0.15034507f, 
    -0.23279652f, -0.05542105f, 0.11062370f, 0.09891514f, -0.04575088f, 0.02305534f, 0.04430591f, 0.06825330f, 
    0.00643727f, -0.01180095f, -0.04426937f, 0.14846544f, -0.03048147f, -0.02496277f, -0.07442842f, -0.11020216f, 
    0.08175436f, 0.09274133f, 0.07424447f, 0.07333715f, 0.04396343f, -0.08126954f, 0.08907011f, 0.03779819f, 
    0.05876989f, 0.06420676f, 0.07261675f, 0.21650442f, 0.19033623f, 0.04093827f, -0.07324686f, 0.08151666f, 
    0.00265490f, -0.22279976f, -0.01056464f, 0.18054941f, 0.13850561f, 0.38831970f, -0.04802692f, -0.19582877f, 
    -0.10686395f, 0.01905526f, -0.15141959f, 0.20864320f, 0.03842932f, -0.05996079f, 0.02641046f, -0.00337696f, 
    -0.03339778f, 0.01302828f, 0.09274207f, -0.01863430f, 0.01821549f, -0.09190531f, 0.02057865f, -0.02115832f, 
    -0.06740797f, 0.07618483f, 0.06452336f, -0.03900140f, 0.06954425f, 0.06460657f, 0.11078282f, 0.05545252f, 
    0.10261253f, 0.06918468f, -0.01226156f, -0.24500258f, -0.17899083f, -0.07901528f, -0.02467612f, -0.05883272f, 
    -0.01861043f, -0.17681675f, -0.14045250f, -0.19598870f, -0.02648283f, 0.07060550f, 0.11968053f, 0.02167766f, 
    0.24701850f, 0.12993480f, 0.00633864f, 0.00946848f, 0.03005925f, 0.26047823f, -0.02583176f, 0.00795832f, 
    -0.07060742f, -0.00380636f, -0.06379832f, -0.12520719f, -0.01980794f, -0.10486014f, 0.07782418f, -0.10897737f, 
    -0.20529622f, -0.06210867f, -0.29707021f, 0.04295022f, 0.04902602f, 0.14810044f, -0.00146325f, 0.07043920f, 
    0.15666275f, 0.19711587f, -0.03148229f, 0.07007930f, 0.02277859f, -0.01182504f, -0.03601896f, -0.02513019f, 
    0.10328520f, 0.20649450f, 0.19462287f, 0.41603011f, 0.06708207f, -0.10814489f, -0.29338753f, -0.14277434f, 
    -0.01876375f, -0.10060115f, 0.02450514f, -0.13322343f, 0.11870010f, 0.10778075f, -0.02100146f, -0.07396748f, 
    0.07359294f, 0.04234439f, 0.04937952f, 0.04334572f, 0.07164250f, 0.25420991f, -0.10126609f, 0.06035800f, 
    0.17987189f, 0.04443184f, 0.13444798f, 0.24748044f, 0.07320595f, -0.09568560f, 0.07944602f, 0.05785885f, 
    -0.13020256f, 0.12960269f, 0.02445964f, 0.05686428f, 0.20680042f, -0.02371917f, 0.03841689f, 0.06666006f, 
    0.11869887f, -0.15935701f, 0.11100771f, 0.07692187f, 0.09657431f, -0.01115818f, 0.02317861f, -0.01987453f, 
    -0.10271645f, -0.00764014f, -0.14713107f, -0.17468093f, -0.16293344f, -0.12815294f, -0.13122265f, 0.07449345f, 
    -0.00965401f, 0.01943402f, 0.09648752f, -0.13042469f, -0.18738452f, -0.03018509f, 0.02513204f, 0.02041506f, 
    -0.13254161f, -0.03736065f, 0.14563526f, -0.03226021f, 0.01662772f, 0.04769162f, 0.00824043f, 0.00662240f, 
    0.08975080f, 0.13302338f, 0.08839548f, 0.16786347f, 0.08176082f, -0.01033667f, -0.02404034f, 0.09068296f, 
    -0.20238078f, -0.10529934f, -0.12002157f, -0.21708706f, -0.15155011f, -0.05171672f, -0.08974189f, 0.18336956f, 
    -0.02828717f, -0.00591625f, -0.07535144f, -0.12819113f, 0.01845640f, 0.11264005f, -0.00595606f, 0.03859774f, 
    0.11401509f, -0.04944062f, 0.00763609f, -0.01002616f, 0.02933001f, 0.06868634f, 0.28575498f, 0.04255077f, 
    0.12672262f, 0.06720669f, 0.18373358f, 0.04606279f, 0.09481946f, 0.03415770f, 0.08910462f, 0.02247330f, 
    0.02016843f, -0.01970169f, 0.02572694f, 0.06660330f, -0.05523862f, -0.02235387f, -0.06532601f, -0.00910042f, 
    -0.19775343f, -0.21177857f, -0.18355355f, -0.10487973f, 0.60611266f, 0.13393274f, -0.01136194f, -0.05602658f, 
    0.12628941f, -0.15245844f, 0.02167388f, 0.21897927f, 0.06882629f, 0.04655867f, -0.04330556f, -0.11511651f, 
    -0.10282976f, 0.01172350f, 0.06887102f, 0.13291821f, 0.15282218f, -0.03250716f, 0.11035509f, 0.14310676f, 
    0.21109217f, 0.21876168f, -0.05763286f, 0.06260651f, -0.15852179f, 0.01277614f, -0.14548460f, 0.13334820f, 
    0.06673410f, -0.07297184f, 0.10570025f, 0.00378061f, 0.04202009f, -0.02332702f, 0.00610670f, 0.07493743f, 
    0.02107944f, -0.13040201f, -0.11697533f, -0.07202635f, -0.00824781f, -0.14646317f, -0.29171458f, 0.03201992f, 
    0.15176091f, 0.02753035f, 0.07010261f, -0.03612201f, 0.15069398f, 0.25318724f, -0.07052626f, -0.02450876f, 
    0.05107493f, 0.09165803f, 0.02862217f, -0.12930922f, 0.02861732f, 0.12132917f, 0.16628213f, 0.29525486f, 
    -0.09473553f, 0.11578839f, -0.05498284f, -0.13491428f, 0.07020596f, -0.05528806f, 0.06110393f, -0.02937021f, 
    -0.06598570f, 0.15449356f, -0.05612025f, -0.07818538f, -0.02652894f, -0.11827496f, -0.02921222f, 0.03064788f, 
    -0.21783715f, -0.24918178f, -0.08220968f, -0.01738220f, 0.03579498f, 0.17176813f, -0.02181828f, -0.08862590f, 
    -0.17381164f, -0.05667257f, -0.11068225f, -0.28041911f, -0.10592858f, -0.43916765f, 0.04850766f, 0.02649892f, 
    0.08996997f, 0.04258629f, 0.08443700f, -0.19136970f, 0.06845078f, -0.18710572f, 0.04966278f, -0.05702924f, 
    0.01138428f, -0.00358782f, -0.04480304f, -0.04017533f, -0.03491750f, -0.01287644f, -0.01281521f, 0.00023619f, 
    -0.00692889f, 0.02563224f, -0.00526258f, -0.03649295f, -0.01449804f, 0.00324450f, 0.00532305f, 0.00745562f, 
    -0.03817254f, 0.02931542f, 0.01631322f, 0.01895141f, 0.01322583f, -0.02157980f, -0.04878918f, -0.02010388f, 
    -0.04079127f, 0.02480550f, -0.00019719f, -0.03458263f, -0.02193081f, -0.02434990f, -0.04814120f, -0.01436833f, 
    -0.00981982f, 0.01969011f, 0.03296274f, -0.02388410f, -0.03646861f, 0.02289631f, 0.02969828f, 0.02644122f, 
    -0.03756556f, -0.01420182f, -0.04898746f, 0.01100311f, -0.00048140f, -0.03022833f, 0.01240609f, -0.00706111f, 
    0.02293434f, 0.01739119f, 0.01002791f, 0.00185731f, 0.03188685f, -0.03087796f, 0.00858593f, -0.02255115f, 
    0.01560216f, -0.03398050f, 0.02058296f, -0.00851597f, -0.03405685f, 0.04361793f, -0.00851779f, -0.00662681f, 
    0.03064980f, -0.01089437f, -0.00106203f, -0.02397631f, 0.03476281f, -0.04275644f, -0.01376389f, 0.00234490f, 
    -0.02152750f, -0.00858047f, 0.02489333f, 0.02071259f, -0.02605250f, -0.00323206f, -0.01816670f, -0.01930881f, 
    -0.00456870f, 0.00716996f, -0.00537377f, 0.02384148f, -0.01617942f, -0.01957052f, -0.02538738f, -0.03666036f, 
    -0.04681383f, 0.03145144f, -0.01996273f, -0.03553798f, -0.00868477f, -0.02334916f, -0.02455016f, -0.01852670f, 
    -0.04514534f, -0.03582317f, -0.02752721f, 0.00329062f, -0.00196064f, -0.01902836f, -0.02135930f, 0.01696809f, 
    -0.02535838f, -0.01313269f, 0.02010116f, -0.02785660f, -0.04198252f, -0.02185769f, 0.00594803f, -0.00310659f, 
    -0.03061224f, 0.00753814f, 0.02218431f, 0.03232738f, -0.02886863f, 0.01992596f, -0.01173042f, 0.01619168f, 
    -0.01628467f, 0.00615555f, 0.02912056f, -0.02480758f, 0.01688054f, -0.01321730f, 0.02865097f, 0.01831959f, 
    -0.02244279f, -0.02917683f, -0.00693684f, -0.04720585f, -0.03577583f, -0.02453457f, 0.01561980f, -0.02413766f, 
    0.02398610f, -0.04142433f, 0.01856564f, 0.01431627f, -0.01836948f, -0.02456975f, 0.01917718f, 0.00413365f, 
    0.00065699f, -0.00838656f, -0.00704155f, -0.02436108f, 0.03039310f, -0.03468893f, -0.03928795f, -0.01816738f, 
    0.01625149f, -0.02095373f, 0.02719139f, 0.00695316f, 0.02942176f, -0.02463644f, 0.01527390f, 0.02752554f, 
    -0.03004559f, -0.02444223f, 0.02007862f, 0.02675648f, -0.01924159f, -0.00848031f, 0.00190955f, 0.01915563f, 
    0.03114571f, -0.01753208f, 0.02367381f, -0.02106229f, -0.01205226f, -0.01869924f, 0.03123181f, -0.02056383f, 
    -0.03680769f, -0.02436006f, -0.03707516f, 0.02434554f, -0.02514588f, -0.02173080f, -0.01322543f, -0.00303913f, 
    -0.02928252f, -0.00804853f, -0.02620822f, 0.01563295f, 0.02662370f, -0.02930345f, -0.03376522f, 0.01704639f, 
    0.00207788f, 0.01743755f, 0.00020390f, 0.01139877f, -0.01927285f, 0.00956979f, 0.00154669f, 0.00203481f, 
    0.01345388f, 0.02239407f, 0.02269096f, -0.02432451f, -0.02025881f, 0.00704614f, 0.02945735f, -0.01424636f, 
    0.00334026f, 0.02011931f, 0.03103168f, -0.01429358f, 0.02479712f, -0.01275172f, -0.04624803f, -0.04066233f, 
    0.02824049f, 0.00879591f, -0.00937586f, -0.02103917f, 0.02020960f, 0.00476320f, -0.02468909f, 0.02957186f, 
    0.01251555f, 0.00526182f, 0.00515810f, 0.01582736f, 0.03064572f, 0.00687913f, -0.00019065f, 0.02455075f, 
    0.00315537f, -0.04057682f, -0.01816416f, -0.01027713f, 0.02720454f, -0.02889552f, 0.03056719f, 0.02172640f, 
    -0.01370228f, -0.01770741f, -0.01667117f, -0.01112834f, -0.00168216f, 0.02013326f, 0.01337322f, -0.01792203f, 
    -0.01507630f, 0.00132277f, -0.03969763f, -0.04841921f, 0.01721423f, -0.00624622f, 0.02197743f, -0.00891661f, 
    0.01587683f, 0.00544664f, 0.03411878f, -0.01842150f, -0.00557169f, 0.03560577f, -0.00915465f, -0.03331058f, 
    0.00738863f, 0.01964404f, 0.01694674f, 0.02267453f, 0.01255793f, -0.01158509f, -0.00043123f, -0.01553917f, 
    0.01086457f, 0.01370017f, 0.00362242f, -0.01230443f, 0.01890150f, -0.01981367f, 0.00213416f, -0.01764328f, 
    0.01999675f, -0.01373365f, 0.02248518f, 0.02261037f, 0.01535130f, 0.01358221f, -0.01630358f, -0.01673059f, 
    0.02507532f, 0.02443671f, -0.02638108f, -0.03419052f, 0.01651142f, -0.00424990f, 0.01521642f, 0.01372990f, 
    0.01732071f, -0.02118255f, -0.02427230f, -0.02484694f, 0.02356338f, 0.00048816f, 0.00565343f, 0.02721182f, 
    0.01772746f, 0.01028745f, -0.03203259f, -0.02406155f, -0.01704608f, -0.00917568f, 0.00586666f, -0.03694833f, 
    -0.03046770f, 0.01021194f, 0.00511340f, -0.04247586f, 0.00010504f, 0.03560710f, 0.02112679f, 0.04020962f, 
    0.02574123f, -0.04228114f, 0.03623703f, 0.01392630f, -0.02418634f, -0.01752316f, 0.01465695f, -0.04417200f, 
    0.02645185f, 0.01302168f, 0.02053848f, -0.04459562f, 0.00120352f, 0.02730930f, 0.02583847f, -0.01929372f, 
    0.02273151f, -0.03357090f, -0.01408343f, -0.00540285f, -0.02312368f, -0.00224048f, -0.01173192f, 0.00973476f, 
    0.02777286f, 0.00773323f, -0.02296097f, -0.01042910f, -0.02435775f, 0.01871095f, -0.01793159f, -0.00268291f, 
    -0.00436883f, -0.01189229f, -0.00016656f, -0.04002926f, 0.01951849f, -0.01478581f, -0.00454468f, -0.01000047f, 
    0.00171642f, 0.01864476f, 0.00194034f, -0.00162632f, -0.02960980f, 0.01889150f, -0.02805860f, -0.03308867f, 
    -0.04942811f, -0.04471752f, -0.00249234f, -0.03240851f, 0.00921131f, 0.02061856f, -0.01479616f, -0.03180223f, 
    0.01964345f, -0.02729759f, -0.01971671f, -0.00619263f, -0.00643574f, 0.00331897f, 0.00871099f, 0.02059118f, 
    -0.00725819f, -0.00918087f, -0.03674753f, -0.04414954f, -0.00663025f, 0.00964008f, 0.02436667f, -0.03440217f, 
    -0.00592141f, -0.00312001f, -0.03145573f, -0.01960847f, 0.00801551f, -0.02037744f, -0.02418034f, 0.00319336f, 
    0.00847989f, -0.04201806f, -0.02738613f, 0.00609319f, 0.01818679f, -0.01939557f, -0.03414182f, 0.00691062f, 
    -0.03735689f, -0.03735529f, 0.01079745f, -0.02642868f, 0.00906474f, 0.01997686f, 0.00096967f, 0.02078559f, 
    -0.04490604f, -0.00896947f, 0.01004674f, -0.03147419f, -0.00770520f, -0.02033294f, 0.01951847f, 0.02298376f, 
    0.02050417f, -0.00671713f, 0.03339348f, 0.00288864f, -0.00849831f, -0.03115708f, -0.03524725f, 0.00771585f, 
    -0.02596773f, -0.00132979f, -0.00375877f, 0.01561731f, -0.00473013f, -0.03761410f, 0.02477690f, -0.01250700f, 
    0.03563636f, 0.00559589f, -0.00711553f, -0.00870876f, -0.02365703f, -0.00245004f, 0.03038263f, 0.00154900f, 
    -0.01288782f, -0.01343154f, 0.02587192f, -0.03407134f, -0.02194957f, 0.01528688f, 0.01041603f, 0.00135260f, 
    -0.02719412f, -0.04466081f, -0.02186508f, 0.00915615f, -0.01275541f, 0.00706386f, 0.01856093f, -0.02300654f, 
    0.02189888f, -0.01481588f, -0.03493986f, 0.03324705f, 0.03415731f, -0.01333911f, -0.02658044f, -0.00418224f, 
    0.02089426f, 0.02023604f, 0.02606072f, -0.01182969f, -0.02687194f, -0.03591267f, 0.01561265f, -0.03786419f, 
    -0.00016647f, -0.02786867f, -0.03388564f, -0.01906800f, -0.01261187f, 0.00501601f, 0.00208247f, -0.01887356f, 
    -0.00559802f, -0.04222483f, -0.03736118f, -0.00477255f, -0.01266351f, 0.02209357f, 0.01560942f, 0.00788283f, 
    -0.04105284f, -0.01234545f, 0.01427237f, -0.04358599f, -0.02689856f, -0.03751092f, 0.01796544f, 0.01353586f, 
    -0.01336849f, 0.02639900f, 0.03220853f, -0.00862230f, -0.04396848f, -0.01509051f, -0.02070352f, -0.03587383f, 
    0.01672856f, -0.01259700f, 0.03190732f, -0.03913724f, -0.01408569f, 0.01613998f, -0.03713104f, -0.03284986f, 
    -0.00233510f, 0.01717412f, -0.04284280f, 0.04581903f, -0.02962635f, -0.02316526f, -0.02559299f, 0.03409744f, 
    -0.02377560f, 0.02061152f, -0.01886269f, 0.00135510f, -0.00603206f, -0.02702591f, 0.02229825f, 0.02134164f, 
    0.03397382f, -0.03552893f, -0.02861121f, -0.03585187f, -0.01505556f, 0.00717099f, -0.02584033f, -0.01114717f, 
    -0.00224299f, 0.01375301f, -0.01065650f, -0.03059297f, -0.01577109f, 0.01339563f, -0.04054984f, 0.01863124f, 
    0.00800516f, 0.00765799f, -0.03957816f, -0.01622123f, -0.01602123f, -0.02660470f, -0.03907663f, 0.02573780f, 
    0.02817071f, 0.02441252f, 0.02157520f, -0.04387396f, 0.00252617f, 0.00140282f, -0.01424130f, 0.02411525f, 
    -0.00336953f, -0.04219730f, -0.02840797f, -0.03641495f, -0.02367102f, -0.03192376f, 0.02227223f, 0.01190384f, 
    -0.02536144f, -0.04659873f, -0.02244949f, -0.00775566f, 0.01858750f, 0.01308318f, -0.00427340f, 0.02563232f, 
    -0.00640854f, 0.03088271f, -0.00355832f, -0.00863933f, -0.01960926f, -0.02272145f, 0.02550430f, 0.02086353f, 
    0.00370829f, -0.02471708f, 0.02278960f, -0.01978135f, -0.00336730f, 0.02266628f, -0.03517530f, -0.02450932f, 
    -0.03734189f, -0.04134408f, 0.00823312f, 0.01747340f, 0.01810814f, -0.03031659f, 0.00660387f, 0.00861592f, 
    -0.03267543f, 0.02597081f, -0.01204233f, -0.03213951f, 0.01941622f, -0.02652272f, -0.03471430f, -0.01156829f, 
    -0.02435325f, -0.03179665f, 0.00377319f, -0.02357925f, 0.01285356f, -0.01447201f, -0.03040261f, -0.03238997f, 
    0.03265867f, -0.02257566f, 0.01232600f, 0.01321689f, -0.01532863f, -0.00397385f, -0.03504424f, -0.01411969f, 
    -0.00816040f, -0.00910616f, -0.04224206f, -0.02991452f, 0.00604527f, -0.02693771f, -0.04512326f, 0.02132990f, 
    0.03205361f, 0.01372357f, 0.01469171f, -0.00337681f, -0.00591296f, 0.00573498f, -0.02147672f, -0.02090945f, 
    0.02840369f, 0.02427270f, 0.00464310f, -0.02015452f, 0.00705065f, -0.03586931f, 0.02234719f, -0.01459599f, 
    0.02154838f, 0.02968150f, -0.03960396f, -0.00458877f, -0.03865133f, 0.00744487f, -0.00261698f, -0.02666990f, 
    -0.00365507f, 0.02990217f, -0.00320883f, -0.02136963f, 0.02554608f, 0.02034776f, -0.00763841f, 0.01011906f, 
    0.02048529f, 0.02171101f, 0.02382412f, -0.02722651f, 0.02405051f, 0.02585733f, 0.01067816f, -0.00644895f, 
    -0.00300756f, -0.00265395f, -0.03312429f, -0.00229229f, -0.02384964f, -0.01157875f, 0.01303825f, 0.02896193f, 
    0.01045142f, -0.01812813f, 0.02245232f, -0.02136848f, -0.00275063f, -0.04392021f, 0.01358423f, -0.00105968f, 
    -0.02750067f, 0.00298943f, -0.01696253f, -0.02451570f, 0.00724629f, 0.01832004f, -0.00520632f, 0.02675368f, 
    -0.03782976f, -0.01889562f, -0.01895558f, -0.00602358f, -0.02401791f, -0.02726393f, 0.02272408f, -0.00838890f, 
    -0.04265654f, -0.03433355f, 0.00248098f, 0.00913696f, -0.01532120f, -0.03306403f, -0.02478962f, 0.02089718f, 
    -0.03161173f, 0.00344404f, 0.02042217f, 0.02609756f, -0.01298496f, 0.01386390f, 0.00008749f, 0.00609133f, 
    -0.03308958f, 0.03259765f, 0.01445191f, -0.03826053f, -0.03608511f, -0.02588457f, -0.01795029f, -0.00647235f, 
    -0.01150024f, 0.03153492f, -0.01983733f, -0.01687458f, 0.02538467f, -0.03189756f, 0.00797829f, -0.02358327f, 
    -0.02013722f, 0.01693790f, -0.01786992f, -0.00462539f, -0.03764712f, 0.02708828f, -0.00406818f, -0.00122676f, 
    -0.04437923f, 0.02359536f, 0.01336630f, 0.02031293f, -0.04095120f, -0.00013772f, -0.02669208f, -0.00147983f, 
    -0.00988835f, 0.00462990f, 0.02350773f, 0.01258698f, -0.01604776f, -0.03069245f, -0.04270036f, -0.03385951f, 
    -0.02445794f, -0.04243332f, -0.01021691f, -0.03568300f, -0.01016426f, 0.00096477f, -0.00794367f, -0.01597084f, 
    -0.00477565f, 0.02311425f, 0.02163802f, 0.00397589f, 0.00536795f, 0.00755609f, 0.03441205f, 0.03210010f, 
    0.03524385f, -0.03288284f, -0.01655388f, 0.03434841f, -0.01340467f, -0.03405283f, -0.01088514f, -0.00181370f, 
    -0.00875820f, 0.02065786f, -0.01881706f, -0.00581752f, 0.00101043f, -0.03902366f, 0.02269262f, -0.01426244f, 
    0.02904415f, -0.03544773f, -0.02116175f, -0.00687660f, -0.01606856f, 0.01489750f, 0.01007414f, -0.03352279f, 
    0.03286391f, -0.00765837f, 0.02476536f, 0.01375388f, 0.01123541f, -0.00505389f, -0.03148605f, 0.00489165f, 
    0.02437431f, -0.02889340f, 0.01760142f, -0.01553727f, -0.00423012f, 0.02859022f, -0.01182410f, 0.00547131f, 
    -0.00706868f, -0.03695618f, 0.00948961f, -0.00993967f, -0.03274393f, -0.00966050f, -0.03699277f, -0.00786051f, 
    -0.02011007f, -0.01279570f, -0.03639196f, -0.04242763f, 0.00411480f, -0.03785991f, -0.03424951f, -0.03548130f, 
    0.02594943f, 0.01742156f, -0.02392834f, 0.02014212f, 0.02208737f, 0.03398160f, -0.03285660f, 0.02372538f, 
    0.01696375f, -0.02605634f, -0.01140002f, 0.01356163f, -0.01427054f, 0.01256591f, -0.03232427f, -0.00466727f, 
    -0.03468985f, -0.00981818f, -0.02255479f, -0.01771642f, -0.02092651f, 0.01145426f, -0.00389120f, 0.02523574f, 
    -0.00689727f, -0.01199699f, -0.03670453f, -0.00324865f, -0.00784509f, 0.01064318f, 0.00161825f, -0.02707466f, 
    0.03529923f, -0.02386882f, -0.03637522f, -0.01514960f, -0.01070290f, 0.01708664f, 0.01875072f, -0.03700203f, 
    -0.02091963f, -0.01654619f, -0.00090307f, -0.00553077f, -0.03617398f, 0.01293780f, 0.01287875f, -0.02241834f, 
    -0.01174240f, 0.00815319f, 0.03122883f, -0.01914117f, 0.01412524f, 0.01327428f, 0.00322748f, -0.02441719f, 
    -0.03523990f, 0.01743498f, -0.01862933f, -0.04424686f, 0.03245824f, -0.04110078f, -0.02923456f, -0.02333207f, 
    -0.00838874f, 0.01795536f, 0.00888419f, 0.03348417f, 0.01315347f, -0.01021186f, -0.03671267f, -0.03314908f, 
    -0.03164614f, -0.03313359f, -0.01719247f, 0.00592973f, -0.02169792f, -0.04201430f, 0.00347532f, 0.02287569f, 
    0.00581736f, 0.02213886f, -0.02943964f, -0.01669428f, 0.02635023f, -0.00100836f, 0.03188670f, -0.00128982f, 
    0.02220640f, -0.02932543f, -0.03879080f, -0.01130093f, 0.01731518f, 0.00621389f, -0.02119340f, -0.00648541f, 
    0.03006079f, -0.03585013f, -0.02415544f, -0.02807524f, 0.00693302f, -0.03420698f, -0.03845676f, 0.02735860f, 
    0.01291613f, -0.02508454f, 0.00552196f, -0.00126139f, -0.00699856f, -0.02625124f, 0.00769596f, 0.01488006f, 
    -0.02252236f, -0.01284290f, -0.00342483f, 0.02783462f, -0.01129668f, 0.03398332f, 0.02391542f, 0.03560220f, 
    -0.00965625f, -0.04060263f, -0.00817649f, -0.02671186f, 0.00082047f, -0.03688015f, -0.03215740f, -0.00864025f, 
    -0.02085852f, 0.03386443f, -0.00994925f, 0.00621058f, -0.00662765f, 0.00021621f, -0.02203948f, 0.02374830f, 
    0.01910194f, 0.00797513f, 0.00427217f, -0.01181908f, -0.01581059f, -0.00556975f, 0.02737100f, 0.03439210f, 
    0.00459149f, -0.03349366f, -0.00817429f, -0.01374781f, -0.01991836f, -0.01326394f, 0.00957891f, 0.00695850f, 
    -0.01999389f, -0.01349820f, 0.03610540f, -0.01606714f, -0.03082097f, 0.01680763f, 0.01591745f, -0.04217219f, 
    -0.03396399f, 0.02051715f, 0.03284024f, -0.03664193f, 0.00780856f, -0.04367873f, -0.03961277f, -0.01272429f, 
    -0.04089836f, 0.00656639f, -0.00128601f, -0.00061066f, -0.04030144f, -0.01275810f, 0.01832674f, -0.04259286f, 
    0.00552399f, -0.01842930f, -0.01114734f, -0.04450960f, 0.03303720f, -0.03518907f, -0.01604597f, -0.02386737f, 
    -0.01232206f, 0.02212372f, 0.02788980f, -0.01115837f, 0.00067093f, -0.03136532f, -0.00553300f, 0.00209330f, 
    -0.02937123f, -0.01792212f, 0.01807960f, -0.00683887f, 0.00279115f, -0.03531665f, 0.00257505f, -0.03287952f, 
    0.01309504f, -0.02252883f, 0.00968929f, -0.00087853f, -0.00083112f, -0.03697410f, -0.03853469f, -0.01490806f, 
    0.02008366f, -0.00089354f, -0.03401837f, -0.02010584f, 0.01449535f, -0.01396999f, -0.02613798f, -0.00861006f, 
    -0.03031301f, 0.00980596f, -0.04433789f, -0.02812246f, 0.02968931f, 0.02910278f, -0.02644532f, -0.00993649f, 
    -0.00852914f, -0.00182080f, -0.02071862f, 0.00911921f, 0.01753211f, 0.03297533f, 0.00654461f, -0.03252031f, 
    0.00805275f, -0.00155516f, 0.01304683f, 0.02861332f, -0.03740928f, -0.02351921f, 0.02519831f, -0.01794024f, 
    -0.02108857f, -0.03234411f, -0.02258660f, 0.00211582f, -0.00707053f, 0.03320381f, -0.01644434f, -0.03196710f, 
    0.00502943f, -0.00120752f, 0.01264169f, 0.00535308f, -0.04420969f, -0.03615456f, -0.00741142f, -0.00037483f, 
    0.03007829f, -0.02876622f, -0.01174744f, 0.00307226f, -0.00490640f, 0.01492083f, -0.00992628f, -0.00814644f, 
    -0.01187909f, -0.04091786f, -0.03407125f, -0.03061426f, 0.00376493f, -0.03666681f, -0.03440133f, 0.00466750f, 
    -0.00058044f, 0.00357642f, 0.01106873f, 0.03315317f, -0.02582498f, -0.02934154f, -0.00738271f, 0.02031505f, 
    -0.04233641f, -0.02433037f, -0.02899989f, -0.03498418f, -0.03372275f, 0.03232570f, -0.00255021f, 0.00343472f, 
    -0.01520448f, -0.02908472f, -0.03550498f, 0.02660148f, 0.01004469f, -0.02166244f, 0.01841666f, -0.01451787f, 
    -0.02308145f, 0.02058149f, -0.02563575f, -0.04096252f, -0.03207564f, -0.02309907f, -0.01598221f, -0.00335147f, 
    0.02214223f, 0.00543803f, -0.02001652f, -0.02457168f, -0.02753984f, 0.01485775f, 0.00315166f, 0.02328202f, 
    0.00947366f, -0.03871016f, 0.02716006f, 0.03902810f, -0.04282188f, -0.00496694f, 0.01372946f, -0.00737561f, 
    0.01182234f, -0.02618361f, 0.01893237f, 0.02068997f, -0.01779065f, -0.02926441f, 0.01271144f, -0.01163378f, 
    0.03088218f, 0.00712962f, 0.01168537f, -0.00693223f, -0.02146540f, 0.01405174f, -0.04283746f, -0.03115229f, 
    -0.03013425f, 0.02258864f, -0.00026940f, 0.00250028f, -0.01436584f, -0.00050856f, 0.00800620f, 0.01512034f, 
    -0.00128000f, -0.03928817f, 0.01494153f, -0.01234820f, 0.01694180f, -0.00398569f, 0.00179299f, -0.04045817f, 
    -0.01674691f, 0.02354815f, 0.02072068f, 0.01260956f, -0.01660491f, -0.03010178f, -0.02522080f, -0.01352039f, 
    0.02230136f, -0.00160955f, -0.03618245f, -0.02455639f, -0.04097246f, 0.02213170f, -0.02168152f, 0.01526313f, 
    -0.04001149f, -0.02342828f, -0.00934825f, 0.01901992f, -0.03975360f, 0.01103417f, 0.00224140f, -0.02014719f, 
    0.02876290f, -0.03044838f, -0.02971886f, -0.03316334f, -0.01292772f, 0.03834686f, -0.03764559f, -0.00893906f, 
    0.03745870f, 0.00187718f, 0.02566441f, -0.02966891f, -0.01527923f, -0.04316197f, -0.00213829f, 0.00846061f, 
    0.00317125f, -0.02995594f, -0.00214435f, -0.01178896f, 0.00029105f, -0.01496931f, -0.03122813f, 0.00714351f, 
    -0.02946942f, 0.01486578f, -0.01678922f, -0.01026757f, -0.03649791f, 0.00472860f, 0.02627971f, -0.01359320f, 
    -0.01475158f, 0.01837978f, -0.03842691f, -0.00516648f, 0.02219690f, 0.01287410f, 0.01432926f, 0.00994992f, 
    -0.00592204f, 0.00789728f, 0.01183482f, 0.03352621f, -0.04117379f, 0.00299307f, 0.00181174f, 0.03916183f, 
    0.00005765f, 0.02327697f, 0.02151691f, -0.01900396f, -0.03268414f, -0.00861465f, 0.00057335f, -0.04213625f, 
    -0.01748153f, -0.00755318f, -0.02501455f, 0.03012267f, 0.02473308f, -0.00140846f, 0.02338034f, -0.01537588f, 
    0.17612077f, 0.07574145f, -0.13558137f, 0.04248862f, 0.14316289f, 0.16175444f, -0.04184962f, 0.01123824f, 
    0.10642610f, 0.13803513f, -0.02774960f, 0.11657330f, 0.20683762f, 0.27218503f, -0.24574010f, -0.09603892f, 
    0.02870687f, 0.00711380f, 0.18013492f, 0.04335079f, 0.41763890f, 0.25202525f, -0.03555521f, -0.05116708f, 
    -0.04996475f, -0.02978904f, 0.01470389f, 0.04351989f, 0.02501859f, 0.01970089f, 0.10953324f, -0.04939454f, 
    -0.17168260f, 0.15968825f, -0.14391214f, -0.02610983f, -0.06448932f, 0.08624636f, 0.03220703f, -0.03898507f, 
    -0.38990423f, 0.00710409f, -0.12205923f, 0.21075955f, 0.04150273f, 0.00140172f, 0.11366212f, 0.04103316f, 
    -0.04805877f, -0.03972498f, 0.07460862f, -0.00155302f, -0.01807514f, 0.00549980f, -0.03170250f, -0.01990641f, 
    0.01721394f, 0.06018728f, -0.28638673f, 0.00027712f, -0.23694652f, 0.11307857f, 0.08089909f, 0.07278694f, 
    0.17780080f, 0.19549698f, -0.00862698f, -0.31409752f, 0.08236774f, -0.24983738f, -0.15102468f, 0.20414381f, 
    -0.16874963f, 0.06596934f, -0.17996573f, 0.14886238f, -0.01525379f, -0.05523436f, 0.25975901f, -0.01414708f, 
    0.00164160f, 0.12785235f, 0.10855666f, 0.09895753f, 0.04453054f, 0.10848654f, 0.08139355f, 0.06645282f, 
    -0.01217836f, -0.13321963f, -0.11831848f, 0.11397191f, 0.19982031f, -0.27777132f, 0.08424154f, 0.16169696f, 
    0.07869944f, 0.06413187f, -0.09529077f, -0.03955588f, 0.00749375f, 0.05223969f, 0.10761765f, 0.40791807f, 
    0.02081468f, 0.07161980f, 0.08188350f, 0.02142883f, 0.13919556f, -0.08212136f, 0.01724217f, -0.04989143f, 
    0.00269501f, -0.03046538f, -0.06129084f, -0.12513007f, 0.04477786f, 0.15044676f, -0.28159019f, -0.05032379f, 
    -0.25617090f, -0.12887467f, 0.66763920f, 0.01473454f, 0.03992856f, 0.13782817f, 0.10327134f, -0.22140166f, 
    -0.06098209f, 0.03419248f, 0.02542731f, -0.04089293f, 0.03042476f, 0.07864350f, -0.07501743f, 0.08954611f, 
    -0.01811623f, -0.18498038f, 0.12719515f, -0.06382331f, -0.00696748f, -0.09974503f, -0.23171367f, 0.07262051f, 
    0.00673281f, 0.20511742f, 0.02853831f, -0.13429442f, 0.24970616f, -0.08623872f, 0.05918011f, 0.04905472f, 
    -0.17427669f, 0.12880874f, -0.02534634f, -0.01389862f, -0.05161810f, -0.06066469f, 0.00733314f, 0.07189569f, 
    0.02876564f, 0.22851084f, 0.47467357f, 0.05202775f, -0.02839034f, 0.10912231f, -0.09033061f, 0.14332876f, 
    -0.21440729f, 0.08552466f, -0.06709265f, 0.01276186f, 0.01864842f, -0.04123186f, 0.22354150f, 0.02827220f, 
    0.07711872f, -0.05561079f, -0.04355524f, 0.10072903f, 0.02600561f, -0.16626918f, 0.25964355f, 0.13237512f, 
    0.14663780f, -0.00231438f, 0.04351785f, 0.28722844f, 0.13059589f, -0.17899607f, 0.00114655f, -0.09431934f, 
    0.09180164f, -0.11432632f, -0.03255343f, -0.02487475f, -0.06058345f, -0.03038849f, -0.06034951f, 0.01114537f, 
    -0.02925618f, 0.02241799f, -0.02892858f, 0.03006663f, 0.09736195f, 0.33447510f, -0.28260109f, 0.16072677f, 
    0.18689056f, -0.04531668f, -0.06309016f, 0.13996038f, -0.01584685f, 0.11377271f, -0.09491883f, -0.05433650f, 
    -0.07701015f, 0.02892838f, -0.04490814f, 0.01010452f, -0.05462046f, -0.24774663f, -0.00259719f, -0.24695717f, 
    0.07086742f, 0.00968961f, 0.04140831f, -0.20815444f, 0.03436508f, 0.07373330f, -0.05635780f, 0.01223765f, 
    -0.08132620f, -0.06492680f, -0.06792862f, -0.02246856f, -0.15268292f, 0.04259493f, -0.03945103f, 0.10276899f, 
    -0.06822199f, -0.06039638f, -0.08462446f, 0.06621733f, 0.05931998f, 0.00498520f, -0.00088806f, 0.09538552f, 
    0.02100514f, -0.03154670f, -0.04781348f, 0.02623208f, 0.04115406f, 0.07062899f, -0.04132140f, -0.05879737f, 
    -0.09630287f, 0.02144877f, -0.01350436f, -0.02955063f, 0.12351961f, 0.19268933f, 0.03370854f, 0.01042306f, 
    0.11410405f, -0.07481737f, 0.14778988f, -0.03912946f, -0.02781448f, 0.04268415f, 0.07374505f, 0.05421081f, 
    0.05488651f, 0.06668784f, -0.03709487f, 0.03152434f, 0.03286836f, 0.15587729f, -0.03446260f, -0.04837862f, 
    0.16969222f, 0.08476910f, 0.12427875f, 0.03938561f, 0.17418295f, -0.05215769f, -0.04158391f, -0.02866941f, 
    0.02742804f, 0.04774720f, 0.02902249f, 0.04486769f, 0.04899563f, 0.06435265f, 0.01747998f, -0.05775276f, 
    -0.10441529f, -0.02214684f, 0.04553333f, 0.00400674f, -0.02511966f, 0.21750261f, -0.06624253f, -0.14725596f, 
    0.07132646f, 0.11859417f, 0.02041615f, 0.02227801f, 0.11436746f, -0.09140050f, 0.16339006f, 0.11718869f, 
    -0.00954187f, 0.09674889f, 0.02562451f, 0.09675456f, -0.13529707f, -0.11858199f, 0.23505852f, -0.16229132f, 
    0.05367317f, -0.15124737f, 0.11566798f, 0.02765185f, 0.23680671f, 0.03019354f, -0.02518065f, 0.10668623f, 
    0.00846819f, 0.08152466f, 0.03476677f, 0.10444725f, -0.01913842f, 0.07515571f, 0.17951207f, 0.05924394f, 
    -0.10471983f, -0.02212193f, 0.22855808f, -0.03101732f, 0.23961152f, 0.03103023f, 0.03949884f, -0.10559073f, 
    0.10374717f, 0.00521275f, -0.00111166f, -0.02303824f, -0.02615216f, -0.00494092f, 0.03208081f, -0.00771528f, 
    0.08623701f, 0.05317554f, -0.06253659f, -0.06441254f, 0.10306447f, -0.15473281f, -0.01107539f, -0.08198596f, 
    -0.13374038f, 0.20102669f, 0.07249331f, -0.19329704f, 0.17695835f, 0.01471660f, -0.16061804f, -0.20940012f, 
    -0.00825861f, 0.12590435f, -0.00881445f, -0.08830183f, 0.15813419f, 0.00003602f, -0.04063828f, -0.09823860f, 
    -0.02518344f, 0.12262055f, -0.23420677f, -0.15226021f, -0.17499340f, -0.29044214f, 0.29814678f, 0.16946140f, 
    -0.05398170f, 0.15874305f, 0.06424992f, -0.34739104f, -0.06650922f, 0.02764846f, -0.08951136f, -0.11442295f, 
    -0.06800565f, 0.15502411f, 0.03910531f, -0.05293128f, -0.09049122f, -0.10347334f, 0.02970752f, 0.02165490f, 
    -0.09084979f, 0.04117852f, -0.01659847f, -0.07093745f, 0.04967350f, 0.08513109f, -0.08662292f, -0.05098344f, 
    -0.01221671f, 0.11899074f, -0.00648379f, -0.04053226f, 0.01482409f, -0.12484829f, -0.06506322f, -0.31186706f, 
    -0.02224765f, 0.15765451f, -0.09193431f, 0.13284831f, 0.00192611f, 0.16599120f, 0.47988683f, 0.36336291f, 
    0.01663481f, 0.09867306f, 0.01811303f, -0.10445033f, 0.27627262f, -0.32142019f, 0.04961460f, -0.00633981f, 
    -0.05770226f, -0.05884256f, -0.05312908f, -0.01455191f, -0.04527939f, 0.12279445f, 0.14143765f, 0.03158787f, 
    0.17797434f, -0.07094752f, -0.12477447f, 0.02192432f, 0.60804898f, 0.01046241f, 0.03407584f, 0.08389943f, 
    -0.05178752f, -0.00702391f, 0.06842351f, -0.13265091f, 0.00234912f, -0.05919858f, 0.21099952f, 0.19732307f, 
    0.05959773f, 0.00228165f, 0.21464381f, -0.17054743f, -0.00238925f, -0.18040264f, -0.04665485f, 0.05405482f, 
    0.05141483f, -0.07629137f, 0.04021034f, 0.26521748f, -0.01781829f, -0.06505363f, -0.08188884f, -0.15321741f, 
    0.08717759f, -0.01370787f, 0.04648295f, -0.03567657f, 0.00063490f, -0.02471824f, 0.02533187f, -0.02021480f, 
    -0.19562726f, -0.11944807f, -0.15771315f, 0.12267623f, 0.07942116f, 0.07145093f, -0.02346802f, 0.14404400f, 
    0.07162969f, -0.06244601f, 0.13827983f, 0.17598332f, 0.09310859f, 0.04172324f, -0.02487146f, 0.01893746f, 
    -0.05040066f, 0.00203397f, -0.00318395f, 0.03589163f, -0.15952034f, 0.08169539f, -0.18169603f, 0.10528828f, 
    0.32345212f, -0.08953188f, 0.16112420f, -0.06151015f, 0.17201632f, -0.18904856f, 0.01556201f, -0.05927691f, 
    0.05864178f, -0.05047759f, -0.13139454f, -0.01237037f, 0.03172092f, 0.10965319f, -0.51615739f, 0.09436540f, 
    0.06203704f, 0.02904720f, -0.01746332f, 0.09181388f, 0.05220265f, 0.02205849f, -0.02667531f, 0.00146915f, 
    0.02652470f, 0.03013629f, 0.09483492f, 0.07448622f, 0.08927839f, 0.04138701f, -0.04626088f, -0.03955232f, 
    -0.12551360f, 0.04142170f, 0.06642789f, -0.11656425f, 0.30843446f, -0.31948346f, 0.46753445f, -0.02753506f, 
    -0.07392551f, -0.11142424f, -0.00144119f, -0.08277670f, -0.03361021f, 0.02977663f, 0.03810981f, 0.02825656f, 
    0.03197736f, 0.07213029f, -0.01144222f, -0.03707051f, 0.03355115f, 0.13964115f, -0.04569188f, -0.15862580f, 
    0.35746372f, 0.09074488f, -0.02174190f, 0.04501426f, -0.01645304f, 0.05446707f, -0.01684008f, 0.06888881f, 
    -0.00247052f, -0.03472445f, 0.02743303f, -0.17129709f, 0.18185061f, -0.21609190f, -0.01481990f, -0.07020099f, 
    0.05387882f, 0.08918229f, -0.01921897f, -0.08183544f, -0.03195990f, -0.05954561f, 0.09485368f, 0.06028322f, 
    -0.01582090f, 0.16623364f, 0.02984814f, 0.02089654f, 0.07057159f, 0.06337374f, -0.04870721f, 0.01096642f, 
    -0.03505158f, -0.07763331f, 0.03278380f, -0.13496514f, -0.00739403f, 0.08331650f, -0.29575238f, 0.12430272f, 
    0.14412414f, -0.00754198f, -0.00676297f, 0.02231357f, 0.10097372f, 0.04105862f, 0.04906930f, -0.03496952f, 
    0.02047772f, 0.10560308f, 0.03465601f, -0.02661227f, 0.05070255f, 0.16968907f, -0.11047643f, 0.04121828f, 
    -0.02774740f, 0.05032349f, 0.07056201f, -0.07582475f, -0.27973071f, 0.02388783f, -0.27201480f, -0.00859654f, 
    0.11316739f, -0.06819019f, 0.13313414f, 0.17007579f, -0.02352686f, -0.18145977f, -0.06631128f, 0.01612782f, 
    0.03225820f, -0.07337506f, -0.13040407f, -0.05725213f, -0.00880819f, 0.16302621f, -0.19382119f, 0.00432837f, 
    0.18446466f, 0.38155010f, -0.12111031f, 0.07799809f, -0.19099082f, 0.16484585f, -0.03280455f, -0.02657713f, 
    -0.00038487f, -0.22521819f, -0.01912134f, -0.04022865f, -0.22073138f, -0.09487956f, 0.23674561f, 0.02764276f, 
    -0.04705260f, 0.00790426f, -0.09082101f, -0.08704786f, -0.10897805f, -0.39125559f, 0.10641603f, -0.23490074f, 
    0.18666412f, 0.13626826f, -0.00545498f, -0.00281903f, -0.10465201f, 0.02091044f, 0.01171967f, -0.00819208f, 
    -0.03365034f, -0.08795507f, 0.03463223f, -0.01757617f, 0.08311953f, -0.03841662f, 0.08334429f, -0.02332657f, 
    0.59693539f, 0.21878143f, 0.54754823f, 0.08164257f, 0.12844387f, 0.15784380f, 0.03190248f, 0.12865756f, 
    0.08487254f, 0.40106651f, 0.03507355f, -0.00475677f, 0.03702994f, 0.02096505f, -0.03306498f, 0.02172403f, 
    -0.01637873f, -0.15578541f, 0.18426688f, 0.17678347f, 0.82105005f, 0.30523184f, 0.26287559f, -0.31600606f, 
    -0.36966395f, -0.08344349f, 0.00444660f, 0.12229622f, 0.02461695f, -0.18585028f, -0.03824784f, -0.21444756f, 
    0.09385979f, -0.01101890f, 0.17008929f, -0.14445461f, -0.16710447f, 0.08599049f, 0.11159641f, 0.04988935f, 
    0.16945675f, 0.14220455f, -0.12789185f, 0.07399532f, -0.01475108f, 0.00621488f, -0.08720315f, -0.01563650f, 
    -0.04991603f, 0.11531604f, 0.00407572f, -0.07419527f, 0.03582855f, 0.05547192f, 0.04840919f, -0.12528008f, 
    -0.08139873f, -0.09393049f, -0.00541370f, 0.11307491f, 0.09660260f, 0.10511112f, 0.13831508f, -0.28990084f, 
    0.07829468f, 0.14706412f, 0.03027316f, -0.08751856f, 0.18264645f, 0.19707820f, 0.03414468f, 0.04190417f, 
    -0.03428881f, -0.07069343f, 0.06406744f, 0.02983941f, -0.01775827f, -0.02971529f, 0.20879957f, 0.23508923f, 
    -0.22279970f, 0.24842998f, -0.21547163f, 0.25163221f, 0.32400680f, -0.14309274f, 0.07081373f, -0.12516110f, 
    -0.01523797f, 0.17869659f, 0.08815108f, 0.00086001f, 0.06858027f, -0.01396242f, -0.00741689f, 0.07527201f, 
    -0.04073006f, -0.04266663f, -0.05635300f, -0.03064396f, 0.19498181f, 0.24474789f, -0.03964211f, -0.09020284f, 
    -0.02212456f, 0.15255408f, 0.09471171f, 0.26796141f, -0.03618700f, 0.21784131f, 0.05215819f, 0.08190871f, 
    0.17642649f, -0.09634128f, -0.05116846f, -0.03761323f, 0.03422585f, 0.05628997f, 0.02164076f, 0.09130797f, 
    0.06130347f, -0.00053655f, -0.34804687f, -0.01890302f, -0.14459862f, 0.04459029f, 0.00093122f, 0.01344205f, 
    0.01520390f, 0.02833581f, -0.04773067f, -0.03447691f, -0.08459165f, 0.06839751f, 0.08100226f, -0.15519534f, 
    -0.15055358f, 0.12255784f, -0.11334462f, -0.10314875f, 0.30159584f, -0.25519231f, -0.68523002f, -0.15230811f, 
    -0.16103703f, 0.02925656f, 0.00719518f, -0.14510244f, 0.11066469f, -0.04499557f, 0.05618676f, -0.04234133f, 
    -0.11564267f, 0.04546222f, 0.08521511f, -0.05850859f, -0.02067439f, -0.01244877f, -0.02458522f, -0.02083177f, 
    0.30526462f, 0.00285589f, 0.02925846f, -0.13615888f, -0.09893110f, -0.11971656f, 0.31129792f, -0.07770398f, 
    0.07412335f, 0.17510991f, 0.00624869f, 0.01206950f, 0.09427886f, -0.13235921f, -0.00035366f, 0.07365256f, 
    0.02386839f, 0.02655661f, 0.00109622f, 0.05253855f, 0.32041851f, 0.35955307f, 0.40685293f, 0.51106495f, 
    -0.26424837f, 0.09086152f, 0.08240509f, 0.22113796f, -0.01668636f, 0.30551872f, -0.00807585f, 0.00360251f, 
    -0.02004164f, -0.00240132f, -0.06910141f, -0.06150965f, 0.08992720f, -0.02272179f, -0.11610310f, -0.07757938f, 
    0.10318889f, -0.08087080f, -0.13753435f, -0.01354901f, -0.05825969f, 0.13133527f, -0.03330895f, 0.03629560f, 
    0.00056976f, 0.10500180f, 0.01639405f, -0.05197528f, 0.08089411f, -0.00962165f, -0.12784670f, 0.08064358f, 
    0.10419977f, -0.00638867f, -0.05277820f, 0.04035461f, -0.04549559f, -0.15799847f, 0.02817952f, 0.18150756f, 
    -0.11252148f, 0.14071588f, -0.02189258f, -0.04290018f, -0.07189722f, -0.01307414f, 0.12919442f, 0.07988922f, 
    0.02990063f, -0.05505823f, 0.03529539f, 0.07279501f, -0.17512475f, -0.00112533f, 0.02114380f, 0.05747440f, 
    -0.09800372f, 0.10774706f, -0.12235818f, 0.19313599f, -0.06063823f, 0.02208997f, -0.01240271f, -0.01061143f, 
    0.00222790f, -0.05140809f, 0.14554931f, 0.04600294f, 0.12855966f, 0.01712779f, 0.08149797f, 0.12352307f, 
    -0.10637058f, 0.09054158f, -0.03169775f, -0.01652688f, 0.08395426f, -0.12275109f, 0.14858365f, -0.13108695f, 
    0.34885883f, -0.00095299f, -0.04096696f, 0.02662148f, 0.06328715f, -0.12984842f, 0.16574657f, -0.04846016f, 
    -0.04578733f, -0.03481788f, 0.01781892f, 0.01994412f, -0.03118160f, -0.05429118f, -0.03414068f, -0.03414473f, 
    0.07239712f, 0.14656128f, -0.02239847f, 0.12466826f, -0.17818843f, -0.00684404f, 0.00446670f, 0.03346550f, 
    0.04488455f, -0.08061133f, 0.01316043f, 0.08645643f, 0.01844551f, -0.04874287f, 0.10722496f, -0.02682317f, 
    -0.03562228f, 0.03917189f, -0.08137914f, -0.10142443f, -0.11656136f, 0.10659600f, -0.06069482f, 0.29809889f, 
    -0.15621050f, -0.02229675f, -0.04862052f, -0.11170753f, -0.02855962f, 0.18452200f, 0.14689437f, -0.01539719f, 
    0.06313636f, 0.01815603f, 0.00706860f, -0.06976348f, -0.15272853f, 0.08441372f, -0.07830301f, 0.04760076f, 
    0.02517367f, -0.02803155f, 0.09404156f, 0.13694732f, -0.06123852f, 0.09038426f, 0.03808649f, 0.14183703f, 
    -0.12725392f, -0.15148343f, 0.11194871f, 0.07701977f, -0.07744850f, -0.06672411f, 0.06205016f, 0.09478550f, 
    0.01136368f, 0.05439202f, -0.04528717f, 0.14239378f, 0.31747803f, 0.55555439f, 0.17886755f, 0.22247501f, 
    0.23840578f, -0.02950410f, -0.02411417f, 0.06692377f, -0.17654008f, 0.25688082f, 0.06670243f, 0.05613585f, 
    0.01652707f, -0.01603784f, -0.07066491f, 0.00041594f, 0.02022534f, -0.00086318f, -0.12336803f, -0.07918067f, 
    0.17353484f, 0.12815821f, 0.21585087f, 0.08184415f, -0.09377874f, 0.11505593f, -0.03971140f, -0.00773918f, 
    0.22314557f, 0.14017862f, -0.05860724f, 0.03763526f, -0.03516852f, -0.04146076f, -0.05985203f, 0.20754372f, 
    0.13994209f, -0.21876727f, -0.18979804f, -0.13834822f, 0.00251513f, -0.10274233f, 0.05249342f, -0.40949279f, 
    0.08043759f, 0.04929172f, 0.14357075f, -0.05044778f, 0.10408174f, 0.19249769f, 0.00912243f, -0.05117414f, 
    -0.03413180f, -0.03491315f, 0.10188700f, -0.03661191f, -0.01379542f, -0.19100641f, 0.01653413f, 0.10791251f, 
    0.19981690f, 0.66168153f, 0.00400722f, 0.29191706f, -0.70333821f, 0.03105240f, -0.03414128f, -0.00948758f, 
    0.16095518f, -0.08684358f, -0.05043523f, -0.07792640f, -0.08761608f, -0.11324476f, -0.03965684f, -0.12749089f, 
    -0.15619433f, -0.06019481f, -0.10950971f, -0.02667785f, 0.44051716f, -0.22937533f, -0.38893077f, -0.10657019f, 
    -0.13948345f, 0.06576011f, -0.09526028f, -0.07614619f, 0.09947672f, 0.06943465f, 0.07037354f, -0.09561353f, 
    -0.11143069f, -0.00627437f, -0.11991642f, 0.08049712f, 0.04340202f, 0.12446851f, -0.08107524f, 0.01402499f, 
    0.21910235f, -0.18226598f, -0.02242579f, -0.13905908f, -0.05266819f, 0.16171436f, 0.04842792f, 0.19293712f, 
    0.06864123f, 0.30619204f, 0.00688804f, -0.00887687f, 0.07518647f, -0.04929804f, -0.08024798f, 0.03754948f, 
    0.10368603f, -0.02233140f, 0.01812907f, 0.06651921f, 0.37338537f, -0.06734114f, 0.38037339f, 0.15369569f, 
    -0.22819778f, 0.28530541f, 0.24283633f, 0.10781225f, 0.26319426f, 0.23773211f, 0.05440021f, 0.02085350f, 
    -0.05961370f, 0.06339970f, 0.12414663f, -0.09963383f, 0.00869038f, -0.02095283f, 0.07963953f, 0.00042313f, 
    0.08614507f, 0.11376045f, 0.12918225f, 0.04427872f, 0.13999730f, 0.10314609f, 0.04393929f, -0.02597334f, 
    -0.03537403f, -0.07163370f, 0.16109866f, -0.00657840f, -0.02403433f, 0.10859212f, 0.10853063f, 0.09849950f, 
    0.13899437f, -0.02623910f, -0.01656903f, 0.08991431f, -0.41797581f, 0.34789708f, 0.13407364f, 0.38932070f, 
    0.07486334f, 0.03639131f, -0.04639792f, -0.21865033f, 0.07333729f, -0.00819433f, 0.12950678f, 0.00966476f, 
    0.02925600f, 0.00303561f, -0.03244995f, 0.02549273f, -0.09147079f, 0.12684761f, -0.03594245f, -0.09802753f, 
    -0.08159006f, -0.16433148f, -0.11117978f, 0.05434636f, -0.03111467f, 0.05816381f, 0.06145259f, -0.00088225f, 
    -0.13829392f, -0.01733937f, -0.03547350f, 0.05344053f, -0.06704746f, 0.05071651f, 0.03260990f, -0.15014593f, 
    -0.11781254f, 0.00345115f, 0.00159406f, 0.16384703f, 0.13747944f, 0.09146865f, 0.32044926f, 0.09049744f, 
    0.15225530f, 0.10127485f, 0.04309352f, 0.17082687f, 0.20131218f, 0.28158835f, 0.00314836f, -0.04835260f, 
    -0.03972216f, -0.07223455f, -0.13353769f, 0.07495765f, 0.16010368f, -0.13011551f, -0.07288203f, -0.10126554f, 
    0.02435911f, 0.18208137f, -0.12356501f, 0.25135970f, -0.32682070f, 0.20748794f, -0.14818165f, 0.05924245f, 
    -0.02916165f, -0.05254391f, 0.01212864f, 0.01976241f, 0.01026629f, -0.03778086f, 0.02311838f, -0.06885805f, 
    0.05717989f, 0.04720311f, -0.11496820f, 0.11699510f, 0.67060208f, -0.42879659f, -0.20949841f, -0.16624391f, 
    -0.19869213f, 0.30477491f, -0.11919708f, -0.03724252f, 0.08974190f, -0.23083679f, 0.22425006f, -0.01866656f, 
    -0.10245710f, 0.02626633f, 0.03830169f, 0.00423417f, -0.01015338f, 0.02562582f, 0.05923317f, -0.01785718f, 
    -0.03542712f, 0.00948553f, 0.00807922f, -0.03972977f, 0.03321012f, 0.00707170f, -0.02639421f, 0.00554763f, 
    -0.02716025f, -0.01191356f, -0.00651152f, -0.00684674f, -0.03176978f, -0.01896510f, -0.01102627f, 0.02601093f, 
    0.03143258f, -0.02825235f, 0.00318091f, 0.02056161f, 0.01984787f, 0.00608400f, -0.03036673f, 0.02130922f, 
    -0.02259430f, -0.04272440f, -0.03105574f, -0.02698348f, -0.01691032f, 0.00628655f, -0.04752156f, -0.02242156f, 
    -0.00132887f, 0.01069879f, -0.00521730f, 0.00652902f, 0.03225316f, -0.01578193f, -0.01979869f, 0.00631330f, 
    0.01191358f, -0.00954413f, 0.00349193f, -0.00869918f, -0.03789714f, 0.01405501f, -0.03855915f, -0.02485302f, 
    -0.00747850f, 0.01518818f, -0.04275592f, -0.02805150f, 0.00368263f, -0.02763009f, -0.01146699f, 0.01166695f, 
    0.00875720f, -0.01229362f, -0.03343349f, 0.00340754f, 0.01600578f, 0.01942466f, 0.00797295f, 0.00809682f, 
    0.01311717f, 0.00558277f, 0.02561023f, -0.02122374f, 0.01218505f, -0.03776715f, -0.01608198f, -0.04106994f, 
    0.00529764f, 0.01070590f, 0.01648997f, -0.02131494f, 0.00410037f, 0.01666465f, -0.01852797f, -0.02324609f, 
    -0.02269758f, 0.01627455f, 0.01748587f, -0.01420636f, -0.00153496f, -0.03450630f, 0.01614393f, 0.01393852f, 
    0.02636442f, 0.02543372f, -0.03863396f, -0.02636778f, 0.00133342f, -0.03991451f, 0.00777511f, -0.02930692f, 
    -0.01101897f, 0.02870168f, -0.04708660f, -0.03360502f, 0.03194912f, -0.03372151f, 0.01863745f, -0.03440758f, 
    0.01391413f, -0.01288507f, 0.00451545f, -0.04344980f, -0.01758055f, 0.02412922f, 0.01234934f, 0.02729867f, 
    0.02178390f, -0.02309789f, -0.01378198f, -0.00713321f, -0.00910197f, 0.02051476f, -0.00344518f, 0.02532231f, 
    0.02108544f, 0.04082016f, 0.00023474f, 0.04516589f, -0.02416296f, 0.04688575f, 0.02659643f, -0.03074622f, 
    0.02177946f, -0.00141060f, -0.01275182f, -0.02340845f, -0.02332493f, 0.00724973f, -0.03911296f, -0.00269743f, 
    -0.01297514f, -0.02505225f, -0.04125642f, -0.02024001f, 0.00564203f, 0.01497600f, -0.01827610f, -0.01281677f, 
    0.02583508f, -0.00287312f, 0.01454497f, 0.02297928f, 0.00254269f, 0.01249392f, -0.03438547f, 0.02071745f, 
    0.03090118f, -0.04605202f, 0.00745991f, -0.02065043f, -0.02632439f, -0.01019545f, -0.02938203f, -0.02921140f, 
    0.02972997f, 0.01753057f, 0.02621748f, -0.00699332f, -0.00003245f, -0.01593510f, 0.03230980f, -0.00589787f, 
    0.01494677f, 0.03073984f, 0.01219580f, -0.02830608f, 0.00079848f, -0.00197488f, 0.01715044f, 0.01787740f, 
    -0.03424667f, -0.00183340f, 0.01723890f, -0.01347416f, 0.00740788f, -0.00910423f, -0.02109797f, -0.02609780f, 
    0.00240203f, -0.02178164f, -0.01560689f, -0.04727759f, 0.00234647f, 0.02831000f, 0.00392799f, -0.01644778f, 
    0.02200031f, 0.00371133f, -0.02880357f, 0.02140730f, -0.00021194f, 0.02145546f, -0.02904375f, 0.02722360f, 
    -0.02310799f, -0.01977002f, 0.02478549f, -0.01556364f, -0.02849492f, 0.02927935f, 0.02699854f, 0.00175811f, 
    0.00107820f, 0.01467473f, 0.02189603f, 0.01599600f, -0.01386341f, -0.02860880f, -0.04127976f, 0.02443583f, 
    0.01203493f, -0.03856046f, 0.02138125f, 0.00200489f, -0.00773492f, -0.01527768f, -0.00014711f, -0.02493998f, 
    -0.00333948f, -0.03623098f, -0.02992200f, 0.01039975f, -0.02600176f, -0.01677976f, 0.02712771f, 0.03332929f, 
    -0.03937337f, -0.01610553f, 0.01398867f, 0.01590376f, 0.01479025f, 0.03511596f, -0.01826031f, 0.01546359f, 
    0.02238213f, 0.00163802f, -0.03252156f, -0.01278325f, -0.02560553f, 0.03179036f, -0.00228767f, -0.03681176f, 
    -0.00821188f, -0.00656780f, 0.01263041f, -0.02779825f, -0.03119254f, -0.02553868f, -0.02378274f, -0.02529756f, 
    0.01974130f, 0.01878720f, -0.03448706f, -0.03482541f, -0.03816491f, -0.02182993f, -0.01190575f, -0.03316678f, 
    0.02181815f, 0.03568495f, 0.00660044f, -0.02772477f, 0.00897954f, -0.04012474f, -0.03110479f, -0.02001552f, 
    -0.00967475f, -0.02164623f, -0.01372849f, 0.02297456f, -0.04304999f, -0.04383583f, -0.03925908f, 0.00987595f, 
    -0.02653820f, 0.01937457f, -0.00262135f, -0.03160046f, 0.02740377f, 0.01383008f, 0.00200813f, 0.00292820f, 
    -0.02044656f, -0.01887555f, -0.03855767f, -0.03367322f, -0.04475963f, -0.03319671f, -0.03110139f, -0.02348218f, 
    -0.02322268f, -0.00536457f, 0.02307644f, -0.02415148f, 0.00186330f, -0.01756713f, -0.00658482f, -0.00818129f, 
    0.04052764f, 0.03106363f, 0.02942987f, -0.00769691f, 0.00534963f, 0.02143812f, -0.01938151f, -0.00911876f, 
    -0.04113578f, 0.01780309f, -0.02263795f, 0.03845076f, -0.02536031f, 0.03240106f, 0.01330990f, -0.01885225f, 
    -0.01985797f, -0.01417178f, -0.02451073f, 0.00256423f, -0.02562930f, 0.00651712f, 0.00243375f, 0.00394887f, 
    0.02262899f, 0.02162597f, -0.03746593f, -0.03964803f, -0.01537527f, -0.03902399f, -0.03493437f, 0.01383962f, 
    0.03161923f, 0.03075502f, -0.01118173f, -0.04175838f, 0.01061950f, -0.02060886f, 0.00137418f, -0.00906671f, 
    -0.00547445f, -0.00403199f, 0.03376020f, -0.00852923f, -0.03777653f, -0.02317795f, 0.01978133f, -0.01500320f, 
    0.00551255f, -0.01699325f, -0.01191694f, 0.03246484f, -0.00911404f, -0.03565151f, 0.00741195f, -0.02544884f, 
    0.03183649f, -0.02108447f, -0.00375999f, 0.00201379f, -0.04969545f, 0.01895620f, 0.01025002f, -0.01692223f, 
    0.00025062f, 0.02189413f, 0.03257633f, -0.01977880f, 0.02937729f, 0.02919111f, -0.00849416f, 0.00361524f, 
    -0.00570182f, 0.00355532f, 0.00908928f, 0.00709862f, 0.01008238f, -0.03899009f, -0.00480818f, -0.02142678f, 
    0.00672422f, 0.01413674f, -0.02216514f, -0.02579852f, 0.00800148f, -0.02413428f, 0.00394972f, 0.02057694f, 
    0.00929718f, -0.01314211f, -0.03999786f, 0.04222182f, 0.01166006f, -0.03279433f, -0.00099120f, -0.00125375f, 
    -0.04376209f, 0.01361333f, -0.02712673f, 0.01812687f, -0.01453767f, -0.03379137f, 0.01689674f, 0.00270858f, 
    -0.02650489f, 0.02163581f, 0.01529227f, -0.01063217f, -0.02608925f, 0.02703401f, -0.03259758f, 0.01743874f, 
    0.00731948f, -0.03808476f, 0.00988276f, 0.03354938f, -0.02068520f, 0.00391715f, 0.00399515f, 0.00863679f, 
    -0.01934790f, -0.03357845f, -0.03029356f, 0.03583831f, 0.02979723f, -0.00600131f, -0.03310612f, 0.00167587f, 
    0.02309762f, -0.01403238f, 0.00308311f, -0.00917447f, -0.03355610f, 0.01554058f, 0.02215936f, 0.00301294f, 
    -0.02100988f, 0.00004936f, 0.00551464f, 0.00054700f, 0.01431168f, 0.00966528f, -0.01416362f, -0.02371740f, 
    0.01214043f, -0.03363825f, -0.04790062f, 0.00819012f, 0.01414227f, -0.01193906f, -0.02186581f, 0.01577409f, 
    -0.00419809f, -0.02084861f, -0.04243345f, 0.00018356f, -0.04612732f, 0.01152313f, 0.02681322f, -0.00672645f, 
    0.00738927f, -0.03267859f, -0.01319676f, -0.02350507f, -0.03609918f, 0.03933794f, -0.04415581f, -0.00060061f, 
    0.02132084f, 0.02263297f, 0.03175460f, -0.02862088f, -0.01887334f, -0.03156048f, 0.01292840f, -0.00933099f, 
    -0.01031440f, 0.00770253f, -0.02471646f, -0.01531767f, -0.01801972f, 0.04090204f, -0.01473607f, -0.00093326f, 
    -0.01392852f, -0.01080036f, -0.02092531f, 0.00097424f, -0.03092941f, 0.00204847f, 0.00250719f, 0.02619425f, 
    0.00210474f, -0.03255530f, 0.03264744f, -0.02827996f, -0.02610314f, -0.02377624f, 0.02427704f, 0.02482967f, 
    -0.02632849f, -0.01324567f, -0.03175106f, -0.02423937f, -0.02933584f, -0.01987332f, 0.00166214f, -0.03262267f, 
    0.00494597f, -0.00386365f, -0.03764527f, -0.02088673f, -0.01566648f, -0.01680757f, 0.01050215f, 0.01551184f, 
    -0.03182422f, 0.02076913f, 0.00332412f, -0.00168315f, -0.02547802f, 0.03487619f, -0.00140610f, 0.00173534f, 
    -0.00655898f, -0.02078334f, 0.02329965f, 0.03813515f, -0.03840695f, -0.00527418f, 0.01711552f, -0.00260873f, 
    -0.04166222f, -0.01345236f, -0.03173714f, -0.00773481f, -0.03684515f, 0.00217895f, -0.03250131f, -0.03630357f, 
    0.02198034f, 0.00076310f, 0.02773149f, 0.03261926f, -0.02097420f, -0.03500269f, 0.00465400f, -0.02512454f, 
    0.02790043f, 0.03806875f, -0.01786480f, -0.01711160f, -0.01072633f, -0.01699078f, -0.03281321f, 0.00335344f, 
    0.04408308f, -0.00657572f, -0.04668953f, -0.03022718f, -0.01738395f, 0.04478019f, -0.00966709f, 0.02467608f, 
    -0.04196349f, 0.00209906f, -0.01811524f, -0.03762407f, -0.02667953f, -0.03594958f, 0.02017561f, -0.01912477f, 
    -0.02211174f, -0.01150270f, -0.01085797f, -0.04337912f, -0.02343253f, -0.04633440f, 0.01459578f, -0.01611603f, 
    0.01321701f, 0.00041701f, -0.03820608f, 0.02921536f, -0.02846652f, 0.03149116f, 0.00357338f, -0.02870269f, 
    -0.00798149f, -0.00819716f, -0.00706892f, 0.00925203f, -0.04318764f, 0.02000863f, -0.03865764f, 0.01839400f, 
    -0.03451909f, -0.03698907f, -0.04103716f, 0.01976339f, -0.02936168f, 0.00744223f, 0.01790344f, 0.02610464f, 
    0.00914564f, -0.02032301f, 0.01454260f, -0.03612868f, 0.00283111f, 0.02662786f, 0.01932613f, 0.00250999f, 
    -0.02422288f, -0.01440213f, 0.03392097f, 0.00047417f, -0.04753510f, -0.03646977f, -0.02652877f, -0.01996250f, 
    0.00827822f, 0.03217020f, -0.00038931f, -0.00393443f, 0.00186541f, -0.01040631f, 0.00437617f, 0.02612082f, 
    -0.03446514f, -0.00420728f, 0.02191078f, -0.01206156f, -0.01868173f, 0.01480892f, -0.02054530f, 0.01581935f, 
    -0.01195455f, -0.04521614f, 0.03174748f, -0.03222526f, 0.00142904f, 0.01252993f, -0.00959131f, -0.01948910f, 
    0.00231997f, -0.01701437f, 0.00863347f, -0.00418259f, 0.00679500f, -0.04524934f, -0.00641707f, 0.01359495f, 
    0.02786153f, 0.00241599f, -0.03225855f, 0.01437781f, -0.01621744f, -0.01953131f, -0.01481822f, -0.00199693f, 
    -0.02868940f, 0.02569817f, -0.02406115f, 0.02883656f, -0.02646752f, -0.00161181f, 0.03732790f, -0.00902183f, 
    -0.02395982f, 0.00755305f, -0.01428994f, -0.03221460f, 0.02955209f, -0.01289780f, -0.03079124f, -0.02050785f, 
    -0.00571056f, 0.01963955f, 0.00643601f, 0.02341448f, -0.01579511f, 0.03320261f, 0.02440609f, -0.03049178f, 
    -0.03089315f, -0.03547680f, 0.00099396f, -0.00735059f, 0.01573785f, -0.00042881f, -0.03764886f, 0.01337195f, 
    0.02506633f, -0.01612318f, 0.03250009f, 0.00954438f, 0.02776310f, -0.01757743f, 0.02597530f, -0.02811556f, 
    0.00103582f, -0.03004977f, 0.02136849f, -0.01389412f, -0.00762342f, 0.00677199f, 0.01000440f, -0.02923195f, 
    0.02411538f, 0.00348617f, -0.01123162f, -0.00628118f, 0.00529699f, 0.03180778f, 0.01198250f, 0.00307003f, 
    -0.01559884f, -0.04465673f, -0.03828697f, 0.02769801f, -0.01576298f, 0.03358681f, -0.03039203f, 0.00075004f, 
    -0.03617721f, 0.01358542f, -0.01941306f, -0.03213632f, -0.00544937f, 0.00757316f, -0.03796477f, -0.00823296f, 
    -0.04252639f, 0.00523848f, -0.01288649f, 0.00440287f, -0.00741875f, 0.02678002f, -0.00525850f, 0.02847661f, 
    -0.01784200f, 0.03146688f, -0.02927279f, -0.03968951f, -0.03036949f, 0.01898300f, 0.03195808f, -0.00175791f, 
    -0.00470976f, -0.01441237f, -0.00302553f, -0.02888547f, 0.00762339f, -0.03094807f, -0.03253433f, -0.03879933f, 
    0.01067827f, 0.02108222f, 0.02633955f, -0.01069802f, -0.01139171f, -0.04052748f, -0.02230386f, -0.03208295f, 
    0.01949954f, -0.03543206f, -0.02829773f, 0.02975591f, -0.03827919f, 0.00068515f, -0.02071380f, -0.02726060f, 
    -0.01681177f, 0.00267749f, -0.04285780f, 0.02461135f, -0.02371914f, -0.00157588f, 0.01579334f, 0.00823537f, 
    -0.00685768f, -0.00093407f, 0.01782342f, -0.03151804f, 0.00472134f, -0.02758248f, -0.01419821f, 0.02386192f, 
    0.01945991f, 0.00158811f, -0.01528310f, 0.02722852f, -0.04031431f, -0.04677004f, -0.02799628f, 0.00724850f, 
    -0.03762336f, -0.03429847f, -0.03544407f, -0.02080731f, 0.03238526f, -0.02330908f, 0.03459880f, 0.00140705f, 
    -0.02315181f, 0.01955789f, -0.00397071f, -0.02738800f, 0.00306277f, 0.01457181f, 0.03767465f, -0.03027233f, 
    -0.00009414f, 0.02506118f, -0.00666857f, -0.01791578f, -0.03644630f, -0.00823981f, 0.00666704f, 0.03612123f, 
    0.02416867f, -0.01299202f, 0.00442896f, -0.02082718f, -0.03606308f, 0.00668471f, -0.02333019f, -0.04113076f, 
    -0.03980799f, -0.03466020f, 0.02717820f, -0.03158136f, 0.03748744f, 0.03465470f, -0.03904745f, 0.01756644f, 
    0.01766596f, 0.02596133f, -0.01525146f, -0.02567733f, 0.02572716f, -0.00994096f, 0.03228071f, 0.02426295f, 
    0.02997614f, 0.02554207f, -0.02746044f, -0.02572218f, -0.00224803f, -0.01785064f, -0.00729292f, -0.03357135f, 
    -0.00428433f, 0.02177547f, 0.02657731f, -0.00305878f, -0.03617267f, -0.01602639f, 0.02982127f, 0.00668532f, 
    0.02937034f, -0.04054593f, 0.00320376f, 0.00756960f, 0.03275744f, -0.01277479f, -0.00586933f, -0.00810331f, 
    0.01952787f, 0.01889086f, -0.01000239f, 0.01891050f, 0.01330088f, -0.00126883f, 0.01227942f, 0.03522890f, 
    0.02277645f, -0.00733810f, -0.01235299f, 0.01501123f, 0.00532191f, -0.03186259f, -0.03592044f, -0.02237688f, 
    -0.00494807f, 0.00754875f, 0.01421117f, 0.00249888f, -0.02062073f, 0.01693178f, -0.00431631f, -0.03976649f, 
    -0.03262159f, 0.01113846f, 0.02889533f, -0.01168841f, -0.01081308f, -0.02574899f, -0.02358330f, -0.04325685f, 
    -0.01070338f, -0.04068593f, -0.04045597f, -0.03583856f, -0.00296756f, 0.01789722f, 0.01171007f, -0.03164470f, 
    -0.01251548f, 0.00632276f, -0.02491061f, -0.04435733f, -0.01631249f, 0.01099104f, 0.00221129f, 0.02570395f, 
    -0.02583846f, -0.03361419f, -0.02014205f, 0.02856970f, -0.01325401f, -0.03551312f, -0.03112570f, 0.02881230f, 
    -0.01393319f, 0.00900392f, -0.02323396f, -0.01458872f, -0.03595634f, -0.00331796f, -0.02383066f, -0.01622278f, 
    -0.00975739f, 0.02121478f, 0.02794953f, 0.02080055f, -0.02083271f, 0.02640173f, -0.03798122f, 0.02475563f, 
    0.00513606f, -0.03186851f, -0.02986095f, -0.03125142f, -0.03044725f, -0.01119825f, -0.01558962f, 0.00031486f, 
    0.00811059f, 0.03366655f, 0.01486804f, 0.01730816f, 0.00385560f, -0.05011269f, 0.00797168f, -0.02541900f, 
    0.02920952f, -0.01470405f, -0.01568452f, -0.00044999f, -0.00528030f, -0.02212132f, -0.01440879f, -0.01482166f, 
    -0.00452727f, 0.02997486f, 0.03187052f, -0.01212157f, -0.04065773f, -0.03891882f, -0.00535832f, -0.01050943f, 
    0.02446370f, -0.01065798f, 0.00029251f, 0.02036679f, 0.01640661f, -0.03099295f, 0.02903039f, -0.01754157f, 
    0.01992602f, 0.02167638f, 0.01924268f, -0.01468168f, -0.03476160f, -0.04093377f, -0.02541844f, -0.01762395f, 
    0.02206381f, 0.02829693f, -0.02251101f, -0.01825009f, 0.02224636f, 0.00575777f, -0.00348845f, 0.02776323f, 
    -0.02931215f, -0.03912251f, 0.02893575f, -0.02037639f, 0.03496322f, -0.01697096f, -0.01894250f, 0.00479969f, 
    -0.01449927f, 0.02954087f, 0.01324695f, 0.01675894f, -0.03801726f, -0.01622529f, -0.02770935f, -0.02955100f, 
    -0.02698757f, -0.02826461f, -0.02157429f, -0.02542328f, -0.00808170f, -0.01985115f, -0.02248519f, -0.00178902f, 
    0.00275198f, 0.00169973f, 0.01431743f, -0.02248365f, -0.00545615f, -0.03124428f, -0.00074341f, 0.03547096f, 
    0.01392586f, 0.00238938f, -0.02033938f, -0.03164658f, 0.03255142f, -0.02281353f, 0.03037118f, -0.03014250f, 
    0.00655965f, 0.00146472f, 0.01991696f, -0.02234172f, -0.03708350f, -0.03533255f, -0.01973601f, 0.03630129f, 
    -0.02784144f, 0.00475216f, 0.03741061f, 0.01391405f, 0.00354800f, -0.02488884f, -0.02837071f, 0.02523334f, 
    0.02969456f, 0.01352635f, -0.01217087f, -0.01915785f, 0.02837550f, -0.03533632f, -0.01053369f, 0.02589283f, 
    -0.01085768f, 0.00984505f, -0.02351227f, 0.02431086f, 0.01367836f, 0.02952154f, 0.01616015f, 0.02636580f, 
    0.02689026f, -0.02297028f, -0.03497680f, -0.02299367f, 0.02267345f, -0.00639191f, 0.02309055f, 0.01725332f, 
    -0.01925009f, -0.02191267f, -0.04991439f, 0.03091393f, 0.00277163f, -0.01189827f, -0.01547961f, 0.01442648f, 
    0.00578310f, -0.03337504f, 0.00635623f, -0.02429299f, 0.01874014f, 0.00640420f, -0.03755424f, 0.00898056f, 
    -0.00755511f, 0.01650070f, -0.02653953f, 0.01602360f, -0.03304598f, 0.01826192f, -0.03840937f, -0.03572313f, 
    0.02762518f, -0.01335751f, -0.02496769f, 0.00254087f, -0.03603664f, -0.00834686f, 0.00955066f, 0.01522862f, 
    -0.00560724f, 0.03235957f, -0.03938345f, 0.02792951f, -0.03004826f, 0.01812454f, 0.02078819f, -0.03395932f, 
    -0.01383133f, -0.02934005f, 0.02342547f, 0.01497841f, -0.00919417f, -0.00225556f, 0.00700797f, -0.02798033f, 
    -0.01358075f, -0.00232000f, 0.01454434f, -0.01622534f, 0.01902552f, -0.02473884f, -0.00948078f, -0.01412387f, 
    -0.02385003f, -0.02898864f, -0.00671985f, 0.02846971f, -0.01694275f, 0.02343968f, 0.00372498f, 0.02907386f, 
    0.02371645f, 0.02513637f, -0.00510972f, -0.02963934f, -0.00262594f, -0.02722962f, 0.02877080f, -0.01294005f, 
    -0.02754189f, -0.01918812f, -0.03072528f, 0.02120446f, -0.01238819f, -0.01087341f, 0.02737947f, -0.00877991f, 
    0.02749312f, -0.02617299f, -0.00022524f, 0.01200188f, -0.02070413f, 0.00671877f, -0.00962591f, -0.02215813f, 
    -0.01402027f, -0.03281721f, 0.01991406f, 0.00400458f, -0.01024769f, -0.02836282f, -0.02303336f, 0.02526573f, 
    -0.04274361f, -0.03199855f, -0.02687782f, -0.00161289f, -0.03349419f, 0.02652900f, -0.04477315f, -0.00484912f, 
    0.01906907f, 0.02190887f, -0.01926048f, -0.03125411f, -0.03338599f, -0.04270230f, -0.00841361f, 0.01223411f, 
    0.00488292f, 0.01704043f, 0.03216479f, 0.00620877f, 0.01438786f, -0.02785988f, 0.02265605f, 0.01754369f, 
    -0.03891305f, -0.02430612f, -0.02516798f, 0.01117729f, 0.00896224f, 0.01273436f, 0.01694157f, 0.00048351f, 
    0.00346850f, 0.02666306f, -0.00706855f, 0.00339953f, -0.01061098f, -0.02383227f, -0.00663863f, -0.02126281f, 
    -0.00988554f, 0.02735424f, 0.02222140f, -0.03587169f, 0.02861831f, 0.02361874f, 0.03581790f, -0.03457376f, 
    0.02132682f, 0.00786593f, 0.01171773f, -0.00629060f, 0.02120363f, -0.00457711f, -0.00462184f, 0.04059013f, 
    0.01295070f, -0.00011209f, -0.03631706f, 0.02258950f, -0.02699877f, -0.03801662f, -0.01493954f, 0.03006920f, 
    0.01338972f, -0.02551452f, -0.01941519f, 0.03057691f, 0.01916436f, 0.01340412f, 0.01886078f, 0.00444306f, 
    -0.02595099f, 0.00482604f, -0.01819132f, -0.03103322f, -0.00519161f, 0.01856785f, -0.03667296f, -0.00897768f, 
    -0.02759669f, -0.00344641f, 0.00744946f, -0.00593081f, -0.02630379f, -0.02290191f, 0.02879318f, -0.00164837f, 
    0.02025031f, -0.02352043f, -0.03229714f, -0.00060311f, -0.00536299f, -0.03754583f, -0.02902916f, 0.00771304f, 
    -0.01257002f, -0.03293133f, 0.00295577f, -0.02143684f, 0.00597666f, 0.02364863f, 0.00304616f, -0.03926164f, 
    -0.30822805f, -0.10907774f, 0.01951366f, 0.08923992f, -0.03612760f, -0.02400430f, 0.16703942f, -0.13140824f, 
    0.13062629f, -0.00270335f, 0.13380413f, 0.10880902f, -0.07574493f, 0.15448064f, 0.11603208f, -0.04065001f, 
    0.13530676f, -0.00577351f, 0.15172984f, -0.16244105f, 0.66719216f, -0.15692620f, -0.16279651f, -0.01903022f, 
    -0.20678475f, -0.07942214f, 0.02945569f, -0.01398247f, 0.03490004f, 0.00209806f, 0.20699055f, 0.20226464f, 
    0.04850440f, 0.06674626f, 0.02815938f, -0.06135567f, -0.08094846f, -0.04880273f, -0.00940443f, 0.01857590f, 
    0.19449005f, 0.01082303f, 0.07667226f, 0.11056504f, -0.02191253f, -0.04739995f, -0.16414733f, 0.03087422f, 
    0.02486937f, 0.04664622f, -0.01261915f, -0.03006452f, -0.01114859f, 0.01822656f, -0.02279358f, -0.04955518f, 
    0.06255881f, 0.01528933f, 0.00413657f, 0.04590052f, -1.88982475f, 0.33402228f, -0.27549809f, -0.15247162f, 
    0.09672887f, 0.20502368f, 0.11127981f, -0.06316247f, 0.01590183f, 0.08816409f, 0.06926633f, -0.01196380f, 
    -0.10529408f, 0.13546886f, 0.14887999f, 0.20740238f, -0.05030784f, -0.18558744f, 0.02111838f, -0.05034086f, 
    -0.09262554f, -0.07294462f, 0.13713098f, 0.23474406f, 0.22605714f, -0.00438717f, 0.09146965f, -0.01295213f, 
    -0.00871842f, -0.05410584f, 0.14126271f, 0.01265097f, 0.10554490f, 0.09171613f, -0.02052289f, 0.32637453f, 
    0.18926744f, 0.05676515f, -0.06800549f, 0.01523893f, 0.15868889f, 0.06090388f, 0.12057939f, 0.19452603f, 
    -0.15145926f, 0.03918970f, 0.04849404f, 0.13483395f, 0.06049776f, -0.01444745f, 0.05954940f, -0.05882762f, 
    -0.00271944f, -0.02581756f, 0.08501764f, 0.03480872f, 0.05379171f, 0.03138183f, -0.10480222f, 0.11405215f, 
    0.31146356f, 0.08533158f, 0.17192294f, -0.03627438f, -0.33934358f, 0.15449581f, 0.10083339f, -0.03354134f, 
    0.06528591f, 0.09587044f, -0.10417930f, -0.09155011f, -0.00989575f, 0.03484296f, -0.03104974f, 0.04933786f, 
    0.08608975f, 0.00697857f, 0.23737602f, 0.07219394f, -0.17027342f, -0.02843180f, -0.13814305f, -0.01116499f, 
    -0.09338791f, -0.17937799f, -0.03604646f, -0.17828695f, 0.15783337f, -0.12209017f, -0.15813430f, 0.09361765f, 
    -0.25318861f, 0.03194830f, -0.01497118f, -0.07231484f, -0.00320508f, -0.08761736f, 0.10396719f, -0.03945893f, 
    0.04155539f, 0.11614207f, 0.09605683f, 0.03357164f, -0.37906393f, 0.12935622f, -0.10465256f, -0.00913676f, 
    0.01360697f, -0.00732138f, -0.03415343f, -0.05543050f, 0.04071547f, 0.06335617f, 0.02327195f, 0.24162307f, 
    -0.00694868f, 0.01872038f, 0.09692469f, 0.07006685f, 0.07991727f, -0.21035498f, -0.22964357f, -0.02240874f, 
    -0.54657120f, 0.07968761f, 0.14629984f, 0.06518207f, 0.12980387f, -0.06461593f, 0.17112355f, -0.14399025f, 
    0.05397170f, -0.01612050f, -0.07107671f, 0.05388759f, -0.07479283f, 0.03026343f, -0.02165646f, -0.08022702f, 
    -0.16436416f, -0.04265156f, 0.01661522f, -0.03911962f, -0.13154438f, -0.05706308f, -0.03556158f, 0.02000904f, 
    0.12428652f, -0.08527486f, -0.19110040f, 0.02122916f, -0.05307859f, -0.00489279f, -0.03334575f, -0.04126010f, 
    0.01939237f, -0.03934549f, 0.08463810f, 0.08159646f, -0.12424293f, 0.06765237f, -0.09879605f, -0.21500039f, 
    -0.11881803f, 0.10375982f, -0.40705335f, -0.19572966f, -0.13199921f, 0.08754567f, 0.01982730f, 0.11161031f, 
    0.01408323f, 0.01080359f, 0.11846238f, 0.10009997f, -0.00158902f, 0.13059446f, -0.27935648f, -0.18806863f, 
    -0.09077503f, -0.09213367f, -0.00818820f, -0.07897779f, -0.07131409f, -0.01264422f, 0.01047398f, -0.05159197f, 
    0.00651142f, -0.04637587f, 0.10703293f, 0.20535913f, -0.02882632f, 0.01805350f, -0.13681343f, -0.13064435f, 
    0.01540378f, -0.04627269f, 0.00506945f, 0.00688362f, 0.29133612f, 0.13460697f, 0.13343395f, 0.05539986f, 
    0.03423239f, 0.10202196f, 0.05127217f, 0.04466476f, -0.04971657f, 0.05862126f, -0.01743076f, 0.02513860f, 
    0.13920622f, 0.03189779f, -0.00093663f, 0.07496542f, 0.25545993f, -0.04564382f, -0.06195499f, 0.03126883f, 
    0.19510871f, 0.13078623f, 0.08891044f, 0.10077406f, 0.06694698f, 0.06206766f, 0.05106970f, 0.00225272f, 
    0.01709174f, -0.03191368f, -0.00588885f, 0.04682974f, -0.07138673f, 0.01693889f, -0.08311567f, -0.00881908f, 
    0.15508641f, -0.11422282f, 0.02991886f, 0.01961903f, 0.07867212f, 0.09676388f, -0.10022140f, 0.21573916f, 
    -0.00398398f, 0.00681043f, -0.00594865f, 0.15855324f, 0.01943835f, -0.10921843f, 0.12518091f, 0.01975465f, 
    0.17954747f, 0.02058920f, 0.17318515f, 0.13249679f, -0.01949104f, 0.28913531f, 0.08456401f, -0.20354782f, 
    -0.02288933f, -0.04116184f, 0.13518570f, 0.19846663f, 0.28079870f, -0.14090107f, -0.10291079f, -0.02850323f, 
    -0.08563957f, -0.12811320f, 0.11600638f, 0.08177380f, 0.01686558f, -0.01820940f, 0.11858955f, 0.15423723f, 
    -0.00574783f, -0.06049713f, 0.12803429f, -0.12630802f, 0.38755161f, 0.22340856f, -0.00794941f, 0.03179067f, 
    0.05245514f, 0.10402920f, -0.00618250f, 0.08403785f, -0.02829856f, 0.03271681f, -0.05291999f, -0.00568299f, 
    -0.01687809f, -0.02972169f, -0.07450841f, 0.10447816f, 0.17457069f, 0.05283418f, 0.01980228f, 0.05612552f, 
    0.17558518f, 0.30094111f, -0.12297183f, -0.14282636f, -0.12368554f, 0.04812782f, -0.16051252f, 0.09466512f, 
    -0.02339825f, -0.04786015f, -0.11655765f, -0.04309710f, -0.01963284f, -0.01835557f, -0.01763988f, -0.04297744f, 
    0.04178274f, -0.05437959f, 0.03826121f, 0.11326947f, 0.02353592f, 0.10981365f, 0.34537753f, 0.10257617f, 
    -0.15743242f, 0.12634371f, -0.36558166f, -0.29239100f, -0.12950858f, 0.21268961f, -0.16861968f, 0.00662491f, 
    0.04126323f, 0.06078109f, -0.00492693f, 0.05543897f, 0.02503320f, -0.00682819f, 0.03922045f, 0.13911368f, 
    0.36764541f, 0.11609066f, 0.13930012f, -0.04963382f, 0.02017077f, 0.18724103f, -0.30552325f, -0.00916704f, 
    0.14204359f, 0.01810882f, 0.03156918f, 0.03477784f, 0.10575866f, 0.04776283f, 0.08856170f, -0.15173700f, 
    -0.03818553f, 0.07152600f, -0.16382200f, -0.22657053f, 0.11198433f, 0.25538069f, 0.11454625f, -0.01209993f, 
    -0.23400140f, 0.05262017f, 0.05501089f, -0.03331869f, 0.08900526f, -0.03584253f, 0.10184380f, -0.10132009f, 
    -0.01101247f, -0.07664305f, -0.01180379f, 0.17570041f, 0.09851500f, 0.01325214f, 0.02675488f, 0.12472293f, 
    -0.39064035f, -0.26073065f, 0.06347051f, 0.29032388f, 0.40075341f, -0.07154898f, -0.08023048f, -0.03160920f, 
    -0.05006789f, -0.17239425f, 0.29127830f, 0.02389995f, 0.03269250f, 0.08261082f, 0.19066985f, 0.35941964f, 
    0.03018782f, -0.02985121f, 0.16834144f, -0.12441717f, -0.40426582f, -0.40326437f, -0.32751474f, 0.01699107f, 
    -0.30596185f, 0.07362866f, 0.10921142f, 0.02756636f, -0.00013686f, 0.02455843f, 0.14213784f, -0.01985813f, 
    -0.02425431f, 0.00930612f, -0.12119660f, -0.04456714f, 0.05967263f, -0.09427405f, 0.01503586f, 0.03630310f, 
    -0.05099303f, -0.10984802f, -0.02524343f, -0.04306601f, -0.12446393f, -0.05063989f, -0.02552351f, 0.04611439f, 
    0.11760566f, 0.00939096f, -0.08552799f, 0.09432004f, -0.03459211f, 0.00199804f, -0.02408792f, -0.07139634f, 
    0.02720732f, -0.01926176f, -0.00330116f, 0.01199148f, -0.03101575f, 0.07809622f, 0.11059146f, 0.22467366f, 
    0.03473037f, 0.04567844f, -0.28377804f, 0.13802184f, -0.15399462f, -0.10781027f, 0.05665031f, -0.01951819f, 
    0.09325301f, -0.03656339f, 0.09428465f, 0.01565946f, 0.04321517f, 0.13405162f, -0.14320913f, -0.03738207f, 
    0.13730119f, 0.02838770f, -0.00010864f, 0.09993115f, 0.02292776f, -0.07578100f, -0.02867827f, -0.05063954f, 
    -0.10074853f, -0.10284375f, 0.10510952f, 0.22341245f, 0.16004333f, 0.07065217f, 0.06588383f, -0.19164629f, 
    -0.00172508f, -0.02456368f, -0.04594259f, -0.05668176f, 0.67840481f, 0.40387219f, 0.02796123f, 0.22095411f, 
    0.00950112f, 0.01840926f, -0.02252138f, -0.08904512f, -0.02559577f, -0.09590589f, -0.06388658f, -0.04259093f, 
    -0.01864670f, -0.08825944f, -0.05206200f, -0.07062998f, 0.11780525f, 0.03675200f, 0.03291728f, -0.07479487f, 
    0.37237725f, -0.10691682f, 0.25750282f, 0.10547975f, -0.00012430f, -0.09449264f, -0.01591520f, -0.02453712f, 
    -0.00112975f, -0.07639926f, 0.10848551f, 0.05067939f, 0.07641703f, 0.09230869f, -0.02435116f, 0.16790293f, 
    0.00840917f, 0.04267316f, -0.05049415f, 0.02205254f, 0.18735369f, 0.16416237f, 0.16301559f, 0.06859916f, 
    -0.02290230f, 0.19506031f, -0.26908267f, 0.01082098f, -0.04067485f, -0.04664182f, -0.02015160f, 0.04622071f, 
    0.06383121f, 0.09118167f, 0.10890102f, -0.03942375f, -0.03358969f, 0.12227499f, -0.13241212f, -0.19316716f, 
    -0.11582848f, 0.00854778f, 0.02632514f, -0.03395587f, 0.01119834f, 0.00856568f, -0.02260797f, -0.09400275f, 
    -0.00245166f, 0.00038104f, 0.09914451f, 0.01594638f, 0.01739947f, -0.02073389f, -0.03503731f, -0.00870090f, 
    0.08814247f, 0.01416235f, 0.07853650f, 0.10847288f, -0.51043302f, -0.35916677f, -0.26388666f, 0.06846335f, 
    -0.36696199f, 0.08089164f, 0.02152753f, 0.05329168f, -0.13906042f, 0.05578488f, 0.07959646f, 0.04963791f, 
    0.01319313f, -0.13311152f, -0.05339363f, -0.06697728f, 0.03873047f, -0.01671428f, -0.07908194f, 0.11439314f, 
    0.15663213f, 0.13876098f, 0.40251288f, -0.20236246f, 0.00431726f, -0.05174707f, -0.09836054f, -0.02347345f, 
    0.11627597f, -0.03984217f, 0.15288296f, 0.00583140f, 0.18685958f, 0.02082602f, 0.15970559f, -0.20444228f, 
    0.12778518f, -0.06054376f, 0.37313953f, -0.02535203f, 0.17380367f, 0.19594125f, 0.01458698f, -0.01441462f, 
    0.04708228f, -0.01441796f, 0.02704363f, -0.06573861f, -0.09489162f, -0.05022860f, 0.18776304f, 0.29395363f, 
    0.31996658f, -0.04854341f, 0.09330018f, -0.08164307f, -0.00021922f, 0.05185063f, 0.10082321f, 0.04530013f, 
    -0.28499693f, -0.20202537f, -0.38613257f, 0.10511017f, -0.02278714f, 0.06294060f, 0.06536573f, -0.08786350f, 
    -0.00430554f, -0.17322336f, 0.02079018f, -0.01388801f, 0.01461909f, 0.00273503f, 0.04189425f, -0.02836314f, 
    -0.01995839f, 0.14223629f, -0.01353150f, 0.15246989f, -0.13223282f, 0.78101653f, 0.46383315f, 0.11309745f, 
    0.34073937f, 0.04271165f, 0.14727987f, 0.11477187f, 0.02810022f, 0.02415588f, -0.00039787f, 0.09968602f, 
    -0.02225882f, -0.01152398f, 0.09760994f, 0.10073296f, -0.15789503f, -0.09207390f, 0.27162546f, 0.02589429f, 
    0.08271501f, 0.10352156f, 0.20197007f, 0.18282367f, 0.05626512f, -0.08694081f, -0.02814432f, -0.08552789f, 
    0.03943440f, -0.01547768f, 0.09068591f, 0.02887392f, 0.01873289f, 0.12823792f, 0.10356419f, 0.28778893f, 
    0.12630320f, -0.02770991f, -0.06209618f, 0.13030840f, -0.22369817f, -0.03694146f, 0.05615662f, 0.03220584f, 
    0.09405221f, 0.22484595f, -0.07962701f, -0.07246862f, 0.06436656f, -0.10978061f, 0.04658906f, 0.03757124f, 
    -0.04336601f, -0.00243966f, -0.00955283f, 0.07344237f, 0.04905453f, -0.01909911f, 0.06982464f, 0.03587312f, 
    0.19201782f, -0.00245440f, -0.14587016f, 0.13305160f, 0.14607617f, 0.01627295f, 0.12413573f, 0.21576016f, 
    0.03948679f, -0.01981147f, -0.01299771f, -0.07323918f, -0.03398582f, 0.00980507f, -0.04546646f, 0.06387266f, 
    -0.04976162f, 0.00612933f, 0.04030887f, 0.07305027f, -0.28914428f, -0.25975269f, -0.05718090f, -0.23658843f, 
    0.01016788f, -0.07873764f, -0.06098055f, -0.10554074f, 0.30093011f, -0.25457668f, -0.07907028f, -0.04037930f, 
    -0.02599961f, -0.03945220f, 0.05360235f, -0.03141183f, 0.05438066f, 0.12497704f, 0.21269834f, 0.08841899f, 
    0.11340045f, 0.03214207f, -0.05434383f, -0.02631795f, 0.22917926f, 0.09916922f, 0.09016819f, 0.19768006f, 
    0.09148826f, 0.01863402f, -0.00194888f, -0.02832721f, -0.02206058f, -0.00411769f, -0.06099954f, -0.00053765f, 
    -0.03618887f, -0.05918499f, 0.10764819f, -0.11818041f, -0.32265750f, 0.24779621f, 0.03991231f, -0.24523641f, 
    0.22580232f, 0.16185747f, 0.04513915f, 0.14524418f, 0.05148327f, -0.03395809f, 0.01006929f, 0.15685330f, 
    0.00859865f, -0.10040656f, -0.05902047f, -0.05267529f, -0.07724152f, -0.04444138f, 0.04791711f, -0.00808774f, 
    -0.22774968f, -0.18186583f, -0.09087273f, -0.06726072f, 0.05706222f, -0.07215922f, -0.01605450f, -0.02424122f, 
    0.22396377f, -0.10828426f, 0.08379705f, 0.05322515f, -0.06903556f, 0.00707329f, 0.02658799f, -0.04521058f, 
    0.12053701f, 0.02012929f, 0.18431944f, 0.17525773f, -0.09652660f, -0.24823490f, -0.21044289f, -0.24911055f, 
    0.14946170f, -0.04683910f, 0.04415260f, 0.19514699f, -0.12821084f, -0.06466118f, -0.02638298f, 0.09248400f, 
    0.03138867f, 0.01347384f, 0.13783650f, 0.16757122f, -0.14121343f, 0.08819613f, 0.01105337f, -0.09309482f, 
    -0.15485024f, -0.08590698f, -0.09144287f, -0.11846204f, -0.09710426f, -0.12862849f, -0.06252936f, -0.00437592f, 
    -0.08808614f, 0.00092840f, 0.15124629f, 0.08198764f, -0.07838585f, 0.01265039f, -0.07620486f, -0.06834438f, 
    0.04133455f, 0.04170491f, 0.08911143f, 0.06673870f, 0.09815411f, 0.12708603f, 0.02285213f, 0.08840608f, 
    0.01901161f, -0.03814827f, -0.02595775f, 0.04036663f, 0.00005313f, 0.09193204f, -0.00733902f, -0.03391718f, 
    -0.00977170f, 0.08334444f, 0.03584718f, 0.08726450f, 0.25472939f, 0.09124924f, 0.07931520f, 0.14468285f, 
    0.04957293f, 0.02352117f, 0.26213011f, 0.04241455f, -0.03026659f, -0.05692386f, -0.04716037f, -0.02597564f, 
    -0.06373164f, 0.00030033f, -0.07115146f, -0.09960575f, -0.05115239f, 0.06244610f, -0.02064921f, 0.04196355f, 
    0.15301552f, -0.03269427f, 0.09094254f, 0.02835951f, 0.02269438f, 0.18999322f, -0.06281852f, -0.04939392f, 
    0.14490217f, 0.10360678f, 0.09010354f, -0.06496850f, -0.08522485f, -0.02804984f, 0.06427630f, 0.08581347f, 
    0.08429605f, 0.13456567f, 0.21321543f, -0.01540759f, 0.04573031f, 0.15718378f, 0.15529080f, 0.05565158f, 
    0.05036092f, 0.15760444f, 0.32058489f, 0.22118892f, 0.20019574f, -0.09132156f, -0.09045840f, -0.12381326f, 
    -0.10896055f, -0.11676791f, -0.08546527f, 0.02087020f, 0.07575282f, 0.10124378f, 0.01321805f, 0.02192633f, 
    -0.06310172f, -0.19631545f, -0.03572328f, -0.31313500f, 0.27724749f, 0.03618426f, -0.08002543f, 0.21566387f, 
    0.07750994f, -0.07848864f, 0.06969813f, 0.08084994f, -0.08578195f, 0.02968850f, -0.04542234f, -0.02316280f, 
    0.00597575f, 0.00847008f, -0.04143722f, 0.01936276f, 0.12537409f, -0.06873876f, -0.02393030f, 0.01308314f, 
    0.06765300f, -0.16461651f, 0.04936668f, 0.02032924f, 0.04753697f, -0.01167989f, 0.01559876f, -0.12207012f, 
    0.18653853f, -0.00306629f, 0.05078479f, -0.02122561f, -0.01678454f, 0.03054315f, 0.03294511f, 0.00816699f, 
    0.14953212f, 0.20608814f, 0.12748225f, 0.02462289f, -0.09354766f, -0.34643564f, -0.23708029f, -0.05255383f, 
    0.13322902f, -0.01272573f, 0.01276138f, 0.15482812f, -0.02918324f, -0.23224020f, -0.11933584f, 0.08777821f, 
    0.05316152f, 0.08223616f, 0.12219678f, 0.05350486f, -0.01525470f, 0.08405879f, 0.07077295f, 0.18101853f, 
    0.04151087f, -0.02372409f, -0.11073992f, 0.05340806f, 0.02806458f, 0.05751657f, 0.06680763f, 0.06941099f, 
    0.09306229f, 0.12858166f, 0.02481926f, -0.04617296f, 0.03091473f, 0.07262291f, 0.16816236f, -0.05630629f, 
    -0.05864521f, -0.01344156f, -0.10371754f, -0.43570644f, -0.23173662f, 0.19498928f, -0.32640529f, -0.00468965f, 
    0.16714644f, 0.26779726f, 0.01060153f, 0.02510143f, 0.05294817f, 0.11855896f, 0.01205171f, 0.07815001f, 
    -0.02385448f, -0.06551980f, -0.00522009f, 0.03013172f, -0.02696198f, 0.03440239f, 0.13788141f, 0.17310186f, 
    0.36071542f, 0.58837032f, 0.29258537f, 0.00332896f, 0.07182517f, -0.11395960f, -0.05145666f, -0.12551071f, 
    -0.06302527f, -0.15225148f, -0.18756743f, 0.14475851f, 0.10225387f, 0.13290092f, 0.12600444f, 0.13602905f, 
    0.04667979f, -0.15667205f, 0.10819582f, -0.25167149f, -0.25259107f, -0.11798689f, 0.03764708f, -0.11113183f, 
    0.01198380f, -0.04322511f, 0.14666462f, 0.03379462f, -0.03644778f, 0.11831386f, 0.03378475f, 0.23986676f, 
    -0.09566776f, 0.03687118f, -0.05640682f, 0.01438967f, 0.03102006f, -0.07322606f, 0.09131244f, 0.05982611f, 
    -0.28125763f, -0.08604542f, -0.20821634f, -0.06477789f, -0.00722714f, -0.13413437f, 0.02177077f, -0.00441509f, 
    0.06576677f, -0.06862775f, -0.09960645f, 0.04713726f, -0.09289873f, -0.03795145f, -0.03757051f, -0.02624311f, 
    0.06396928f, 0.14608602f, 0.07827608f, 0.09480090f, -0.25454932f, -0.10698171f, -0.26744369f, -0.07652318f, 
    0.08154386f, 0.10651352f, -0.04288251f, -0.00916319f, 0.03361925f, -0.15391782f, -0.07429430f, -0.00607734f, 
    -0.01090089f, -0.02337894f, 0.07443747f, 0.09119626f, 0.04036762f, 0.07838012f, 0.05944248f, -0.03926484f, 
    -0.02343439f, -0.06484531f, -0.01997241f, -0.01113884f, -0.11692825f, -0.08321898f, -0.15376745f, -0.12363860f, 
    -0.11288881f, -0.09282041f, -0.02411227f, 0.10027242f, 0.04369253f, -0.05590170f, 0.09491701f, -0.20791382f, 
    -0.03535907f, 0.05865652f, 0.10415451f, -0.01233037f, 0.11520268f, -0.19531341f, 0.12265070f, -0.03450511f, 
    -0.00237528f, -0.00120536f, -0.02667435f, -0.01190804f, -0.16738433f, -0.03103948f, -0.08758256f, 0.00082901f, 
    -0.03334599f, -0.05511336f, -0.05292425f, -0.15950875f, -0.16393352f, -0.00588439f, 0.01095603f, -0.19223832f, 
    0.12459486f, 0.14526518f, 0.12642974f, 0.17207772f, 0.19034784f, -0.04817737f, -0.04929593f, -0.00396201f, 
    -0.04297619f, -0.05602682f, 0.20088625f, 0.11445665f, -0.00165965f, 0.14948252f, 0.06615830f, 0.10080338f, 
    0.03417038f, 0.05858768f, 0.06724473f, 0.08688220f, -0.03228380f, 0.00557059f, -0.20017506f, 0.01155742f, 
    0.00962588f, -0.04366494f, -0.05845994f, -0.07579622f, -0.01490016f, -0.11730067f, 0.05804302f, 0.01018606f, 
    0.04350953f, 0.08017098f, 0.15284075f, -0.02111439f, -0.07107373f, 0.06689896f, -0.12234289f, -0.32458425f, 
    0.18061261f, -0.10644080f, -0.03419389f, -0.10733877f, -0.03734023f, -0.05872891f, -0.11451894f, -0.01967933f, 
    0.06730400f, -0.00851933f, -0.08352561f, 0.13629723f, -0.02578636f, 0.01676311f, 0.04794910f, -0.02521285f, 
    0.13496849f, 0.15098161f, 0.36967552f, 0.05553972f, -0.41134161f, 0.03415162f, -0.32233924f, -0.08559070f, 
    -0.01573223f, 0.01757863f, 0.05328390f, -0.05299877f, 0.07559179f, 0.22572212f, -0.06530605f, 0.19150220f, 
    -0.06412397f, 0.01623894f, -0.07425112f, 0.08306241f, 0.07302258f, -0.03429544f, 0.02431664f, 0.11312032f, 
    0.51470017f, -0.00948507f, -0.11065013f, 0.02225088f, -0.15011327f, 0.22193046f, -0.09396786f, -0.08735106f, 
    -0.02772422f, -0.04644144f, -0.01617694f, 0.03994093f, 0.18695138f, 0.07210927f, 0.04946572f, 0.08486104f, 
    -0.10082499f, -0.05045109f, 0.00133285f, 0.00569939f, -0.33875987f, 0.00797202f, 0.32325095f, -0.35632673f, 
    0.11255955f, 0.09473725f, -0.15423365f, 0.03480656f, -0.06474499f, -0.09745223f, 0.19859414f, 0.07864371f, 
    0.06261986f, 0.11952619f, 0.26523638f, -0.00770973f, -0.00906614f, -0.08746848f, 0.09526224f, -0.00384742f, 
    0.05023670f, -0.19970112f, 0.09276988f, 0.20569414f, -0.03747253f, 0.11616781f, 0.23767874f, 0.07857362f, 
    0.07976250f, 0.05705551f, 0.02881002f, 0.03117887f, -0.06043326f, -0.14266105f, -0.02976014f, 0.00343617f, 
    0.07159477f, -0.04970128f, -0.01857993f, -0.07123420f, 1.54231215f, -0.38912174f, -0.30103007f, 0.41846862f, 
    -0.41103405f, 0.12916398f, -0.14591224f, -0.00352750f, -0.07462568f, -0.09131914f, 0.05890215f, 0.00631929f, 
    0.16166689f, 0.00195842f, -0.02725409f, 0.14056346f, 0.03652640f, -0.15045178f, 0.04622279f, 0.15977588f, 
    0.24202394f, 0.14435358f, -0.07282808f, -0.01160107f, -0.09768439f, -0.19393401f, -0.03216334f, -0.08978437f, 
    0.05869202f, -0.02480047f, 0.01001548f, 0.11794900f, 0.06083044f, 0.02285868f, 0.20618387f, 0.13596617f, 
    0.08713836f, -0.07418126f, 0.10452108f, 0.21734495f, 0.02463729f, -0.31476089f, -0.00857029f, 0.24210103f, 
    -0.07303660f, -0.08112377f, 0.14407605f, -0.02118522f, 0.17375182f, 0.09247846f, -0.04430304f, -0.00016025f, 
    -0.11861479f, 0.04914892f, 0.01637203f, 0.10198583f, 0.16046967f, 0.04811951f, 0.10859400f, 0.17625576f, 
    -0.62726188f, 0.24052317f, 0.19131123f, 0.11983901f, 0.25388008f, 0.05520694f, 0.06158455f, 0.07109351f, 
    -0.16509554f, 0.03610510f, -0.00835535f, -0.00474751f, 0.10781819f, -0.09253274f, -0.08315005f, 0.19156349f, 
    -0.06298257f, 0.00205701f, -0.19947112f, 0.01771940f, 0.10273081f, -0.37297887f, -0.07764098f, 0.05403814f, 
    -0.14138968f, 0.08286157f, 0.05515883f, 0.09444954f, -0.08607031f, -0.02738576f, -0.05860897f, -0.08525778f, 
    -0.00093792f, -0.14076209f, -0.04141521f, -0.11373125f, 0.09075539f, -0.11051056f, 0.17948757f, -0.08496438f, 
    -0.19250645f, -0.03311110f, 0.09250478f, 0.13583229f, 0.25909990f, 0.02496080f, 0.00167340f, 0.06207425f, 
    0.04467941f, 0.05603796f, 0.05028388f, -0.03346819f, 0.06074591f, -0.00565682f, 0.18418054f, -0.00844466f, 
    0.08688568f, -0.03075463f, 0.02234938f, 0.02597222f, 0.13092226f, -0.25095245f, 0.31057301f, 0.34007677f, 
    0.39588290f, -0.15804455f, -0.00568047f, -0.02394381f, 0.33308396f, 0.00771915f, 0.08581595f, 0.08857720f, 
    0.00352951f, 0.09164286f, 0.08427437f, -0.09970205f, -0.07102238f, 0.02037540f, -0.08499575f, 0.00682672f, 
    0.37173641f, -0.44534367f, -0.10667487f, 0.09421170f, -0.10505673f, -0.03573125f, 0.11556714f, -0.05410984f, 
    -0.03444033f, 0.17364745f, 0.01204561f, 0.10649339f, 0.01626065f, 0.01624276f, 0.09793394f, 0.13020386f, 
    -0.02270242f, -0.01882153f, 0.03248580f, -0.22642794f, 0.21268044f, -0.06223191f, -0.15854912f, 0.32396176f, 
    -0.32366779f, 0.22178553f, 0.08050364f, 0.10837457f, -0.06496415f, 0.01042177f, -0.00791892f, -0.02975885f, 
    0.02908919f, 0.00559571f, -0.06682491f, 0.10680322f, 0.08103910f, -0.03670739f, 0.11988001f, 0.18919466f, 
    0.05870998f, -0.01185657f, 0.01725681f, -0.05498155f, 0.10491228f, -0.06582545f, -0.16027927f, 0.03808600f, 
    0.07077911f, 0.00363122f, 0.03383394f, -0.00004209f, -0.05372198f, -0.03735520f, -0.04588965f, 0.01657477f, 
    -0.02615582f, -0.08935714f, 0.04737609f, -0.04236421f, -0.07227432f, 0.09130823f, -0.16292886f, 0.04334549f, 
    0.05945233f, 0.00106095f, -0.11474725f, -0.00767649f, 0.06404250f, 0.07311267f, 0.04781219f, 0.08088900f, 
    -0.08904286f, 0.10602742f, -0.03387515f, 0.10136367f, -0.16512290f, 0.00039693f, 0.06613171f, 0.11163926f, 
    -0.35350314f, 0.06636513f, 0.17111802f, -0.12923221f, -0.09428086f, -0.04712109f, -0.18773074f, -0.04882842f, 
    -0.01040779f, 0.04500727f, 0.01161472f, -0.08748045f, 0.05926134f, 0.05798070f, 0.05380752f, 0.14676031f, 
    -0.05867038f, 0.00508954f, -0.01326815f, -0.03924333f, 0.18240468f, -0.01986518f, 0.03268906f, -0.31284362f, 
    0.06807122f, 0.17801993f, -0.02924124f, 0.02247791f, 0.19054560f, 0.00509966f, 0.09166091f, -0.05324800f, 
    -0.14533001f, -0.16476607f, 0.01367697f, -0.05320661f, 0.04206481f, -0.04334972f, 0.02484249f, 0.12820937f, 
    -0.03955755f, 0.20546216f, -0.05762937f, 0.00292416f, -0.13062119f, -0.23441130f, -0.17746644f, -0.07813981f, 
    -0.12797947f, 0.00876000f, 0.06611927f, 0.13033840f, 0.00535966f, -0.02145131f, 0.18104850f, 0.00854927f, 
    0.04903311f, 0.12517560f, 0.11936226f, 0.14144735f, -0.40566781f, 0.20770638f, -0.08870845f, 0.19906867f, 
    -0.02459162f, -0.03541005f, -0.02228149f, -0.02972124f, -0.02504977f, 0.07571983f, 0.01004369f, -0.19748577f, 
    0.00162610f, -0.07855906f, 0.00487442f, 0.06291075f, 0.00436977f, 0.24009636f, -0.02777615f, 0.10841250f, 
    0.08263637f, -0.18473297f, -0.31078818f, 0.19423924f, -0.03433544f, 0.05660819f, 0.04259656f, -0.19816077f, 
    -0.04135137f, -0.03775510f, -0.01279508f, 0.08272544f, 0.08587297f, -0.17103283f, -0.10385434f, -0.09156749f, 
    0.05629011f, -0.02458335f, -0.04705430f, -0.01800093f, -0.07019647f, -0.06495638f, -0.27758235f, 0.18334945f, 
    -0.08408106f, 0.14068019f, 0.24072771f, 0.13118045f, -0.11371976f, -0.02663519f, 0.06156343f, 0.05117697f, 
    0.06351537f, -0.13961045f, -0.09811973f, 0.11879949f, 0.05599735f, -0.11142540f, 0.06090093f, 0.00053327f, 
    -0.19363202f, -0.14498264f, -0.10882806f, 0.20443821f, -0.12082035f, -0.02111286f, 0.06679849f, -0.09229401f, 
    0.09052283f, -0.00572865f, 0.03567877f, -0.05780028f, -0.01779222f, 0.01309204f, 0.03785743f, 0.18708004f, 
    0.23898256f, -0.00520163f, -0.04027241f, 0.23871422f, -0.04067703f, -0.60617107f, 0.30878511f, 0.10724693f, 
    -0.02977544f, -0.05636334f, -0.03908052f, 0.05388106f, 0.37216863f, -0.13560307f, 0.02925180f, -0.06043515f, 
    -0.06239516f, -0.01440888f, -0.01183007f, 0.00762875f, -0.06223314f, 0.06289228f, -0.02791917f, -0.01196704f, 
    -0.06627702f, 0.32882586f, -0.20233160f, 0.15319383f, -0.42002475f, -0.28008175f, -0.20715073f, -0.12611146f, 
    0.10645409f, -0.09028343f, 0.03006245f, 0.12659238f, 0.08647522f, 0.06880379f, 0.02074344f, -0.00897556f, 
    -0.03373783f, -0.12449074f, -0.04538498f, 0.06405695f, 0.33930528f, 0.13427874f, 0.24361268f, 0.07442892f, 
    0.29789016f, -0.02626960f, -0.06066908f, 0.08826425f, 0.16716698f, 0.01546789f, 0.03643300f, -0.03920647f, 
    0.02324390f, -0.00294519f, 0.14007838f, -0.03079722f, -0.05861717f, 0.05083404f, 0.02864964f, -0.03170572f, 
    0.13847443f, -0.32801956f, 0.01416590f, 0.02552749f, 0.02503881f, 0.11625074f, -0.06633890f, -0.04039300f, 
    0.05518844f, 0.00021795f, 0.01664353f, 0.02606980f, 0.03641796f, -0.10368823f, -0.15276746f, -0.03896105f, 
    0.05633036f, 0.00984540f, -0.01416141f, -0.00741819f, -0.18333857f, -0.28897122f, -0.21643899f, 0.29104468f, 
    -0.39224267f, 0.05076154f, -0.06940275f, 0.01306064f, 0.31653041f, 0.19720617f, -0.00036654f, 0.02063376f, 
    -0.08381121f, 0.19001299f, -0.02322395f, -0.01945265f, 0.08148128f, 0.03437874f, -0.03839579f, 0.17533174f, 
    -0.34610045f, -0.12663595f, 0.01958864f, -0.23101319f, -0.10080737f, -0.01107112f, -0.20422402f, -0.10775926f, 
    -0.07865463f, -0.09667232f, 0.21496680f, -0.01595711f, -0.06641219f, -0.04479791f, 0.10051559f, 0.01094438f, 
    -0.07315676f, -0.06925592f, -0.07906880f, -0.00574651f, -0.49615628f, 0.29446831f, 0.02701744f, 0.22338051f, 
    -0.01748013f, 0.00151910f, -0.01032692f, 0.00104765f, -0.10544644f, 0.13135339f, 0.10734933f, -0.14350568f, 
    -0.07466310f, -0.04220975f, -0.09215055f, 0.01295516f, 0.12773150f, 0.13572502f, -0.02105859f, 0.03261485f, 
    -0.14133635f, -0.04116879f, -0.10190199f, -0.00362545f, 0.05513469f, -0.05237232f, -0.03319710f, 0.13747306f, 
    -0.12001549f, -0.13028193f, 0.08167500f, 0.23405288f, 0.06704678f, 0.22797348f, 0.02619812f, -0.12148426f, 
    0.00070391f, 0.01986962f, 0.08426616f, 0.10520218f, -0.28394446f, -0.30075464f, -0.06408628f, 0.19074985f, 
    -0.15224622f, -0.07211271f, 0.00828669f, -0.05525010f, 0.10936311f, 0.04763417f, 0.03481479f, -0.06567099f, 
    -0.03942202f, 0.04259339f, 0.04969879f, 0.11031297f, 0.24830368f, 0.04003863f, 0.04646640f, 0.12510860f, 
    0.16757020f, 0.16649470f, -0.44914138f, 0.25580078f, -0.18028109f, 0.03123787f, 0.03668077f, -0.00573747f, 
    -0.07694551f, 0.05935206f, 0.12486390f, -0.03953049f, 0.12070593f, -0.00239938f, -0.12304215f, -0.08450571f, 
    -0.03953617f, -0.06013565f, 0.05147651f, -0.04878163f, 0.51420134f, 0.22820222f, -0.34807631f, 0.34928846f, 
    0.23362975f, 0.01254167f, -0.05411743f, 0.16068377f, 0.12469036f, 0.06302584f, 0.07671972f, 0.01852860f, 
    -0.03783351f, 0.10779077f, -0.20715468f, -0.16641633f, -0.08807670f, 0.03234625f, 0.02971022f, 0.07041018f, 
    -0.33729017f, -0.19986235f, 0.21664990f, 0.02954148f, 0.08282853f, 0.05954382f, -0.04335938f, -0.10337469f, 
    0.11405127f, 0.01824501f, 0.27755126f, -0.01684065f, 0.06633429f, 0.17450851f, 0.13337484f, 0.21246697f, 
    0.00904876f, 0.00070094f, 0.16482745f, -0.01076223f, 0.15327528f, 0.06135647f, -0.19494903f, -0.16011550f, 
    -0.08196267f, -0.05538094f, -0.12267465f, -0.30752352f, 0.10782073f, -0.12004910f, 0.04528401f, 0.07886111f, 
    0.10182969f, -0.14738473f, 0.04076665f, -0.00247172f, -0.11998810f, 0.02543383f, 0.10164359f, 0.05492200f, 
    0.05672937f, 0.21570356f, 0.38097379f, 0.00332473f, -0.21114771f, 0.19930363f, 0.11395632f, 0.00401526f, 
    0.04913450f, -0.01448146f, -0.08751637f, 0.04918952f, 0.01144700f, 0.02653231f, -0.07022775f, -0.07149969f, 
    0.00245098f, -0.23372056f, 0.03542323f, 0.18517111f, -1.21406269f, 0.24965763f, -0.09057331f, 0.45913774f, 
    -0.02069188f, 0.11292189f, 0.09078237f, 0.08443505f, 0.05277036f, 0.22668472f, 0.06902684f, -0.08497896f, 
    -0.15239219f, -0.17605460f, 0.00355305f, 0.16450745f, -0.07435764f, 0.02740614f, 0.30621108f, -0.02688367f, 
    -0.04314597f, -0.20203412f, 0.09240514f, 0.10783681f, 0.23739806f, -0.09257302f, -0.14588933f, -0.01261904f, 
    0.07215892f, 0.04051926f, 0.06036220f, 0.12131183f, 0.02109528f, 0.15066601f, 0.20563078f, 0.07162064f, 
    0.03555306f, 0.05149213f, 0.14305921f, 0.16748169f, -0.18371087f, -0.05311391f, 0.27651981f, 0.33955207f, 
    -0.11571299f, 0.01521513f, 0.06359480f, 0.02710199f, 0.01297499f, 0.14084661f, 0.01521763f, 0.00378315f, 
    0.06269164f, -0.08720667f, 0.03341952f, 0.01127617f, 0.10839017f, -0.08747658f, -0.10048594f, 0.17356727f, 
    0.61538094f, 0.06686541f, -0.50791162f, -0.24552302f, -0.30513695f, 0.07202337f, 0.12695444f, 0.06096232f, 
    -0.03481357f, 0.15995777f, -0.11416908f, -0.04352413f, -0.03082122f, -0.03311652f, 0.01541232f, 0.00172666f, 
    0.05810780f, -0.05349230f, 0.04499490f, -0.00541532f, -0.14714810f, 0.13930480f, 0.23375395f, -0.33375880f, 
    -0.05238432f, -0.10201743f, -0.05968870f, -0.09158303f, 0.01335826f, 0.02865421f, -0.02947192f, 0.04966789f, 
    0.01280251f, -0.00027340f, -0.02924984f, 0.01328365f, -0.07856063f, -0.08114613f, -0.02473769f, -0.00274802f, 
    -0.16482735f, 0.27269959f, 0.20665419f, 0.25914338f, -0.15541421f, 0.06417901f, 0.01727415f, -0.02261396f, 
    -0.01494168f, 0.04681142f, 0.01436396f, -0.05927344f, 0.03874306f, 0.01531192f, 0.10755208f, 0.05235460f, 
    0.04221589f, 0.11298765f, 0.04338374f, -0.05421141f, -0.12797695f, 0.28490776f, 0.31578639f, 0.37334925f, 
    -0.23342361f, 0.08755917f, 0.01045068f, -0.14303231f, -0.00888074f, -0.04339637f, 0.04905154f, 0.10299543f, 
    0.01674987f, 0.02305504f, -0.07130216f, -0.06473429f, -0.05607596f, -0.02149647f, -0.06285015f, -0.05369302f, 
    -0.00030430f, -0.04174548f, 0.13900574f, -0.04332779f, -0.02498391f, -0.02708874f, 0.14275570f, -0.04960949f, 
    0.08985312f, 0.04275690f, 0.05328659f, -0.02994768f, 0.11884031f, 0.05927174f, 0.00115495f, 0.07182162f, 
    0.00000529f, -0.06913210f, -0.02939344f, 0.06328890f, -0.30582467f, 0.30956718f, 0.06151769f, 0.13652407f, 
    -0.24696159f, 0.23559523f, 0.01007801f, 0.29684946f, -0.04759924f, 0.35378698f, -0.02099965f, 0.10807342f, 
    -0.06320128f, 0.09829935f, 0.01450866f, 0.17269547f, -0.06210188f, 0.23319809f, -0.10708646f, 0.08971547f, 
    -0.05328585f, -0.01511754f, 0.19431055f, 0.02619540f, -0.01819710f, 0.03169514f, -0.06268076f, -0.09944871f, 
    0.00185368f, -0.02151833f, 0.01656590f, 0.01304961f, 0.08117547f, 0.03207376f, -0.07399499f, -0.08691684f, 
    0.07664262f, -0.06790395f, -0.06221306f, 0.10438555f, -0.07461382f, -0.15819320f, -0.07234113f, 0.12516081f, 
    0.16076508f, 0.05076686f, 0.03334999f, -0.01188693f, 0.09236281f, 0.04629064f, 0.04083188f, 0.00236466f, 
    0.09344659f, 0.02052750f, 0.05582213f, 0.22258341f, 0.16790305f, -0.02209493f, 0.13503169f, 0.07993669f, 
    0.15578021f, -0.16732095f, -0.36441341f, -0.12211250f, 0.13638474f, -0.03060032f, 0.03920889f, -0.01218413f, 
    -0.06733755f, -0.02250000f, -0.02610666f, -0.02726596f, 0.02949862f, -0.02661430f, 0.05067163f, 0.04787846f, 
    0.09279909f, 0.04148751f, 0.13418660f, -0.02521373f, 0.09443426f, -0.01568748f, -0.46579140f, 0.27942625f, 
    0.11226205f, -0.01901911f, -0.08998440f, -0.10675633f, -0.18843457f, 0.06525149f, -0.07533388f, -0.05557732f, 
    -0.17281780f, 0.13974950f, 0.18856092f, 0.34940729f, -0.12985921f, 0.17956848f, 0.04047589f, 0.07014229f, 
    0.00113899f, -0.23894274f, -0.27151543f, -0.08080252f, 0.30459940f, -0.10778753f, -0.10044104f, -0.09885608f, 
    -0.11590465f, -0.11123844f, 0.06086489f, 0.04565070f, -0.15095082f, -0.00179389f, 0.03354146f, 0.03880285f, 
    0.11533457f, 0.29103801f, 0.04382719f, -0.06462945f, -0.04891768f, -0.10813332f, -0.19681863f, 0.08772014f, 
    0.18518306f, -0.03076595f, 0.05468358f, -0.02036981f, -0.02154381f, 0.17842098f, -0.04972452f, -0.07182422f, 
    0.01030963f, -0.05183835f, 0.02626757f, 0.05016901f, 0.03653935f, 0.16979872f, 0.06417210f, 0.12570597f, 
    -0.23936723f, 0.02157171f, -0.35241431f, 0.04020618f, -0.19803187f, 0.05299238f, -0.01333301f, 0.23933963f, 
    0.08467576f, 0.08480424f, -0.16857941f, -0.13385327f, -0.04973652f, 0.01525127f, 0.03863336f, -0.02480209f, 
    -0.04059074f, 0.03163127f, 0.09511533f, 0.19826810f, -0.10405714f, 0.45061457f, 0.22233482f, 0.04328575f, 
    -0.33330950f, 0.21166430f, -0.00332104f, 0.34669694f, -0.13141617f, 0.24735437f, -0.04072690f, 0.09644543f, 
    -0.00882643f, 0.11949789f, 0.00995036f, 0.10401952f, 0.01611115f, 0.06633106f, -0.00795538f, 0.18507041f, 
    -0.02149479f, 0.08433535f, 0.29506639f, 0.30831608f, -0.14767198f, 0.13365445f, 0.09462235f, 0.09416347f, 
    0.09596509f, -0.01175712f, 0.03508741f, 0.06956761f, 0.14328919f, -0.00220444f, 0.08821222f, 0.06618652f, 
    0.02835925f, -0.12946105f, -0.06773534f, -0.00328199f, -0.25894660f, 0.07994528f, 0.08581027f, 0.05707576f, 
    -0.30412462f, 0.10740220f, 0.04122293f, 0.01852006f, -0.17739582f, 0.16586395f, -0.02440411f, -0.04304117f, 
    -0.03283792f, -0.06337551f, -0.14909551f, 0.15482917f, 0.02240004f, -0.12782046f, -0.03145938f, 0.13007247f, 
    -0.47429290f, -0.20464356f, 0.18065868f, 0.23687367f, 0.37955117f, -0.04387099f, -0.19070497f, -0.05570979f, 
    0.08424909f, -0.17355014f, 0.08840083f, -0.05239202f, -0.21927857f, -0.09156568f, 0.06695472f, -0.01431154f, 
    -0.05555535f, 0.16588344f, -0.08553903f, -0.14394405f, -0.22567296f, 0.22580846f, 0.21965261f, 0.20617993f, 
    0.02101922f, 0.11576743f, 0.01511422f, -0.18594894f, 0.15918159f, 0.15769094f, 0.09504412f, 0.07282184f, 
    0.01444776f, 0.07640568f, -0.08924051f, -0.08404978f, 0.00978618f, 0.04371741f, 0.01696786f, 0.08839843f, 
    0.15812580f, 0.19387335f, 0.31870124f, -0.07856170f, -0.06081634f, 0.01871547f, 0.01393573f, -0.02185834f, 
    0.01351082f, 0.05492579f, 0.04311273f, -0.00578589f, 0.07741170f, 0.03634351f, -0.05468650f, -0.02943767f, 
    0.01233207f, -0.16996413f, -0.07403521f, 0.10795642f, -0.30163240f, 0.02069834f, 0.27271324f, 0.24451981f, 
    -0.27991724f, 0.04847015f, -0.04566060f, 0.17739673f, -0.08184987f, 0.04981983f, -0.02204725f, -0.00728415f, 
    0.02231593f, 0.06343687f, 0.07704428f, -0.01503240f, -0.00954239f, -0.00746867f, -0.09846818f, 0.04627037f, 
    0.06643791f, -0.18336824f, -0.18750273f, -0.09251880f, 0.01332401f, -0.02758279f, 0.00155349f, -0.12720087f, 
    -0.02740731f, -0.07330434f, 0.12790300f, 0.12667024f, 0.20369141f, 0.08857398f, -0.02772225f, -0.03776834f, 
    0.07640287f, 0.05223817f, 0.02009316f, -0.03418383f, 0.01972354f, -0.15340351f, -0.61063993f, 0.13168769f, 
    0.15183432f, 0.07700816f, -0.02853767f, 0.08249602f, 0.04733410f, 0.09957597f, -0.09964254f, -0.06479540f, 
    -0.12944756f, -0.09014007f, -0.06370983f, 0.04722093f, -0.03035372f, 0.16160984f, 0.01586185f, 0.00427052f, 
    0.11880381f, -0.03599597f, 0.09562556f, -0.02538597f, 0.03063443f, -0.06729982f, -0.21450016f, -0.07370741f, 
    0.03696905f, 0.02829943f, 0.12458795f, 0.23800708f, 0.06767081f, 0.08148126f, 0.09507333f, 0.10081373f, 
    0.04676373f, 0.17033540f, 0.23061402f, 0.26565215f, -0.13874680f, 0.11361733f, 0.26919696f, 0.29744306f, 
    -0.18339066f, 0.08254793f, 0.04376616f, 0.12141661f, 0.01921499f, 0.03026204f, -0.01720848f, 0.12644848f, 
    0.12544359f, 0.05995900f, 0.01086691f, 0.06559095f, -0.00492065f, -0.07366234f, 0.00480912f, -0.00750755f, 
    -0.41552562f, -0.13737993f, -0.00498378f, 0.14081024f, -0.01184712f, 0.03072014f, 0.01582379f, -0.00385556f, 
    0.10126508f, 0.10457379f, 0.06805865f, 0.13070711f, -0.12198617f, 0.02131071f, 0.05652613f, -0.03008806f, 
    0.00275800f, 0.11882715f, -0.04388769f, -0.09186860f, -0.27541786f, 0.09227509f, 0.33775109f, 0.53378671f, 
    -0.19047886f, -0.02841702f, -0.08619194f, -0.08016946f, -0.02126626f, 0.11101298f, 0.00698637f, 0.02413378f, 
    0.18897277f, 0.05200635f, 0.04449983f, -0.02438815f, 0.07178047f, 0.03679891f, -0.02970355f, 0.24528731f, 
    -0.43447503f, 0.18216714f, 0.04659802f, 0.18585503f, -0.06332118f, -0.01769165f, 0.13953432f, -0.08841753f, 
    0.06970698f, -0.11974872f, 0.21968782f, -0.14275269f, -0.08084350f, -0.31693158f, -0.02458452f, 0.09570160f, 
    0.05655224f, -0.04479286f, 0.13445963f, -0.11768439f, -0.00806539f, -0.03347264f, 0.08977271f, -0.38486126f, 
    0.10213095f, 0.12282639f, -0.02431216f, 0.03749235f, -0.17011870f, -0.12177045f, 0.06772950f, 0.07045054f, 
    0.24483202f, -0.04589920f, 0.07575240f, 0.09785066f, 0.00394732f, 0.02198841f, 0.01151313f, -0.00903289f, 
    0.14335236f, 0.03182417f, 0.21915309f, -0.11711339f, -0.03035035f, 0.07560196f, 0.20679688f, 0.06600991f, 
    -0.05522205f, -0.02533162f, 0.07346707f, -0.01492941f, -0.02195903f, -0.02928011f, 0.01033175f, -0.00772038f, 
    -0.01156155f, 0.04509874f, 0.21738933f, 0.02249039f, -0.89709127f, 0.80964345f, 0.65604949f, -0.30982122f, 
    -0.18321480f, -0.30466247f, -0.05804818f, -0.20310366f, -0.01162834f, 0.01648537f, 0.11627073f, -0.27509674f, 
    0.25827661f, -0.02635871f, -0.09183300f, -0.06483149f, -0.04663417f, -0.00467472f, 0.07306027f, -0.03784719f, 
    0.07681103f, 0.08384113f, -0.12843187f, 0.02668433f, 0.08884418f, -0.06566864f, -0.05116988f, -0.11809976f, 
    -0.03370120f, 0.06090256f, 0.16284798f, 0.11005934f, -0.09998171f, 0.08436202f, -0.04181011f, 0.03849410f, 
    -0.01954499f, -0.14117117f, 0.18543231f, 0.27632859f, 0.12213617f, 0.06014855f, 0.13590623f, -0.32930100f, 
    -0.16704623f, 0.27172765f, 0.11051233f, -0.13096388f, -0.06829731f, 0.01543068f, 0.03421809f, -0.00746440f, 
    -0.05506255f, -0.01537477f, -0.03558675f, 0.00247300f, 0.00292170f, 0.06415343f, 0.03759927f, 0.09294689f, 
    0.50795227f, 0.30405036f, -0.69927746f, -0.38617808f, 0.24593151f, -0.09019301f, 0.20413715f, 0.13554342f, 
    0.08892482f, 0.08730979f, 0.14215149f, 0.07675850f, -0.05033450f, -0.11018866f, 0.07959118f, -0.00015021f, 
    0.07262017f, 0.10616060f, -0.11217572f, -0.02451864f, 0.07702000f, 0.03542523f, 0.11541995f, -0.09622102f, 
    0.06387992f, 0.05454473f, 0.19917171f, 0.20837539f, 0.08697216f, -0.00472357f, 0.16263962f, -0.03065862f, 
    0.09913025f, -0.06925414f, 0.07789879f, 0.03550572f, -0.02781898f, -0.02239429f, 0.05922180f, -0.14941722f, 
    0.12052383f, 0.03975439f, -0.20237340f, -0.05801653f, 0.03376577f, -0.06288285f, -0.11614700f, 0.07997949f, 
    0.01407995f, -0.02402122f, 0.06402862f, -0.02243309f, 0.11519365f, 0.08371378f, 0.08950425f, -0.15104042f, 
    -0.06162759f, -0.03157169f, 0.09733059f, -0.09831429f, -0.15205877f, 0.28275436f, 0.10569508f, -0.25199944f, 
    -0.10137524f, 0.14824247f, 0.06917771f, -0.17388953f, -0.01419528f, 0.05611874f, -0.02622611f, 0.04865972f, 
    -0.01149102f, 0.07762569f, 0.08036519f, -0.04984210f, 0.03618842f, -0.00698568f, 0.04807249f, 0.08346674f, 
    0.05056491f, -0.05313722f, 0.09749480f, -0.07184784f, 0.06348499f, -0.19680148f, 0.38084793f, 0.01811944f, 
    0.06353214f, -0.18624802f, 0.35187691f, -0.06173711f, -0.01478467f, -0.01856819f, 0.03332293f, 0.08678248f, 
    -0.05427044f, -0.00293262f, -0.00941063f, 0.04385659f, -0.26560634f, 0.25305128f, 0.28228316f, 0.08270106f, 
    0.01707872f, -0.04425110f, 0.18490422f, 0.18132715f, -0.12497672f, 0.18718468f, 0.05267853f, -0.08856298f, 
    0.02467221f, -0.11944319f, 0.05638024f, -0.08347671f, 0.04586959f, 0.09151877f, 0.17730789f, 0.00530638f, 
    0.06102555f, 0.24207188f, -0.01224763f, -0.06388215f, -0.01582838f, 0.05700596f, -0.11712147f, -0.04755610f, 
    -0.11322003f, 0.02902255f, -0.13000789f, 0.00716830f, -0.04444180f, 0.02968368f, 0.01721491f, 0.05247560f, 
    -0.06602453f, -0.09806474f, -0.11413171f, -0.05978918f, -0.14536437f, -0.16784595f, -0.08947610f, 0.05420731f, 
    0.02321720f, -0.02170895f, -0.09606195f, 0.04978203f, -0.09667263f, -0.00305197f, 0.03431156f, 0.04276548f, 
    0.00322129f, -0.06956472f, -0.04021632f, -0.01624408f, -0.09448735f, -0.09070833f, -0.03571882f, 0.13025986f, 
    0.04795114f, -0.05194766f, -0.29324770f, 0.04165944f, 0.04223464f, 0.01250417f, -0.06869894f, 0.04779112f, 
    -0.11871071f, -0.07427027f, 0.08619841f, -0.12719090f, -0.01050822f, -0.01552498f, -0.01604984f, 0.03842623f, 
    -0.13060696f, -0.00180717f, -0.03255059f, 0.02132657f, 0.04540789f, -0.20268312f, 0.28136212f, -0.48747855f, 
    0.07843909f, -0.02189914f, 0.19683051f, -0.15367082f, -0.09977503f, 0.02720254f, 0.05076433f, -0.14965470f, 
    0.14247957f, 0.00974883f, -0.01412955f, -0.01664561f, 0.12285436f, -0.05554341f, -0.02506342f, -0.13896982f, 
    0.11292017f, 0.30173749f, -0.20077878f, 0.20526645f, 0.11360486f, -0.01319733f, 0.05130543f, -0.02196193f, 
    -0.02181813f, 0.01781197f, 0.08427273f, 0.03243608f, 0.11452487f, -0.01902198f, 0.08406848f, -0.04476710f, 
    0.17753631f, 0.14510098f, 0.06210852f, 0.13597038f, -0.11896185f, -0.05983202f, -0.34902850f, 0.14465034f, 
    -0.02909676f, -0.03906930f, -0.07042300f, 0.05375902f, -0.05026992f, 0.05816124f, 0.04810257f, 0.02469366f, 
    -0.06325329f, -0.09554518f, 0.05962152f, -0.07357325f, -0.04500698f, 0.15048173f, -0.16666505f, 0.15346119f, 
    0.01492054f, -0.31666675f, -0.09156961f, -0.04761169f, 0.18522030f, 0.05484384f, 0.51356632f, 0.10385071f, 
    0.16066346f, -0.11373723f, 0.22138166f, -0.07869937f, -0.13646775f, -0.05164438f, 0.00075687f, 0.05567572f, 
    0.10001650f, 0.00221878f, -0.02259415f, -0.11426830f, 0.14727409f, 0.29125068f, -0.03113599f, -0.15102585f, 
    0.01947864f, -0.16591918f, 0.07098223f, 0.11473806f, -0.08961660f, 0.14612712f, 0.04335076f, 0.01210544f, 
    -0.02550321f, -0.18472673f, 0.03928404f, -0.01642424f, 0.03804087f, 0.09602655f, 0.03773572f, -0.00457260f, 
    0.31450507f, 0.08364996f, 0.22264452f, 0.02844771f, -0.01493682f, 0.04893053f, -0.08877911f, 0.08137903f, 
    0.03084876f, 0.02687069f, 0.00124248f, -0.04176594f, -0.01898933f, 0.00673581f, 0.02919074f, -0.05619810f, 
    0.07051454f, 0.00499362f, 0.27113914f, -0.07617433f, -0.03464219f, 0.05622042f, 0.05989724f, -0.38817909f, 
    -0.09567837f, 0.16653876f, 0.10329220f, -0.09715127f, -0.08392982f, 0.24213651f, -0.00002834f, 0.09015599f, 
    -0.01219428f, 0.07809369f, 0.07962873f, -0.06554788f, -0.06931394f, 0.20551525f, -0.29502705f, 0.08510750f, 
    -0.26322979f, 0.64323384f, 0.11445344f, 0.17689098f, -0.32493195f, -0.02148538f, -0.05780302f, -0.02630032f, 
    0.12335832f, 0.08533130f, -0.11038352f, 0.04424559f, 0.02224885f, 0.08855455f, 0.04832894f, -0.04267882f, 
    0.18085317f, -0.13152497f, 0.22104496f, 0.18848586f, -0.11042003f, 0.44533700f, -0.03497465f, -0.03286154f, 
    -0.05101849f, 0.14471702f, -0.13111386f, -0.03171140f, -0.15105186f, 0.10611170f, -0.05008350f, 0.10697006f, 
    -0.03770886f, 0.13281463f, -0.03420912f, 0.02715812f, -0.09347793f, 0.02011726f, -0.09990925f, 0.08152854f, 
    0.08407994f, 0.22781695f, 0.23662047f, -0.13852561f, -0.04379955f, -0.01241810f, -0.00466068f, 0.09780968f, 
    0.02133532f, 0.02913226f, -0.13062786f, 0.04437670f, -0.04255598f, 0.03038788f, 0.02077488f, -0.04285838f, 
    -0.04330051f, 0.01255964f, -0.05617412f, -0.02588522f, 0.31739211f, -0.01605953f, 0.47605067f, -0.02817315f, 
    -0.12418684f, 0.25376493f, 0.24692842f, 0.15310292f, -0.03663395f, -0.03400014f, 0.06860449f, -0.02015779f, 
    0.04290271f, -0.13986762f, 0.09957478f, -0.14336818f, 0.08739458f, -0.03594693f, 0.19610658f, -0.03027581f, 
    0.14699177f, 0.00623684f, 0.01549164f, -0.03917040f, 0.06910967f, 0.01778191f, -0.00659645f, -0.10220046f, 
    -0.05836546f, -0.02861678f, -0.07389448f, -0.10121987f, -0.06745654f, -0.01250213f, -0.15221976f, 0.05120566f, 
    -0.02083451f, -0.03749471f, -0.09351430f, -0.03725763f, -0.27371120f, -0.22578636f, -0.44753227f, -0.14882334f, 
    0.06404617f, 0.08555035f, 0.14489485f, 0.00590264f, -0.01435141f, 0.12207186f, -0.02146393f, -0.01993595f, 
    -0.00376149f, 0.01241952f, 0.03798753f, 0.00810692f, 0.08652745f, 0.13413915f, 0.13789554f, 0.12650834f, 
    0.02882635f, 0.12855889f, -0.18433714f, -0.06058673f, 0.16545449f, -0.04713451f, 0.02176819f, -0.04873573f, 
    -0.03287005f, -0.00191686f, 0.10925040f, 0.28562820f, -0.08256365f, 0.01637500f, 0.00082160f, -0.06282941f, 
    -0.04501399f, 0.02060582f, 0.03216598f, 0.22615166f, 0.20493945f, 0.15270849f, 0.28792590f, 0.01665850f, 
    0.02387336f, 0.04658307f, -0.05974823f, 0.04048057f, 0.09490987f, 0.19393180f, 0.04332531f, -0.01484342f, 
    0.00913610f, -0.04602163f, -0.05664592f, -0.09318720f, 0.00457729f, 0.06538654f, 0.15044473f, 0.05887573f, 
    -0.23125565f, -0.00669095f, 0.00323676f, 0.18550375f, -0.05605261f, 0.05421384f, -0.14928311f, 0.18866864f, 
    0.01119642f, -0.00745103f, -0.03690986f, 0.18610586f, -0.04338031f, -0.20341189f, 0.07847900f, 0.03014578f, 
    -0.04610445f, -0.04651708f, -0.10054985f, -0.02055882f, 0.06319676f, 0.39252615f, -0.06307654f, 0.06287952f, 
    -0.14035378f, 0.19417208f, 0.01691970f, -0.12593575f, -0.00529530f, 0.20981166f, -0.14895925f, 0.08649168f, 
    0.11141256f, -0.00191398f, 0.09349700f, 0.04536268f, 0.06805333f, -0.12714170f, 0.11684703f, -0.03442220f, 
    -0.03035477f, -0.37506723f, 0.04748615f, 0.23427707f, -0.09699579f, 0.20137039f, -0.11271192f, -0.07344926f, 
    0.03523222f, 0.13319770f, -0.02132374f, 0.13290550f, 0.22147499f, 0.12060997f, -0.03357508f, -0.05632054f, 
    -0.01835532f, -0.00363127f, -0.01871875f, -0.08771205f, 0.38165298f, 0.44584033f, 0.07543572f, -0.08353658f, 
    -0.12831007f, -0.00321557f, 0.07043650f, 0.16808049f, 0.07900798f, -0.05740916f, 0.10759658f, -0.16421272f, 
    -0.08034228f, 0.20032868f, 0.03061492f, 0.04489427f, -0.04407312f, -0.09326280f, -0.01143265f, -0.06130637f, 
    -0.36845845f, -0.19768931f, 0.19542508f, 0.27421072f, 0.10089621f, -0.09863068f, 0.19175987f, -0.01748185f, 
    -0.10395782f, -0.18194093f, 0.06072078f, -0.00519671f, -0.06022774f, 0.01937340f, 0.07140691f, -0.04548451f, 
    0.02349944f, 0.02427168f, -0.06172891f, -0.21633542f, -0.20214722f, -0.43371999f, -0.22093429f, 0.16551404f, 
    -0.30575559f, 0.16972493f, -0.23894943f, -0.28276855f, 0.23223522f, 0.05081356f, 0.00973203f, 0.11725435f, 
    0.03185984f, 0.22482938f, 0.03120615f, 0.14992531f, 0.07692996f, 0.02363512f, 0.10305770f, 0.08185859f, 
    0.14267451f, 0.03613456f, -0.02790994f, 0.02757992f, 0.11290088f, -0.00616257f, 0.13880028f, 0.06380390f, 
    0.01992884f, -0.00621703f, 0.08363477f, 0.10562705f, -0.00066294f, 0.02001468f, -0.04243268f, 0.01786004f, 
    -0.03674630f, 0.05351831f, 0.03627900f, 0.04861341f, -0.00658397f, -0.25274372f, 0.22814177f, 0.32460797f, 
    -0.09525274f, -0.05922040f, 0.07832877f, 0.08170107f, -0.06527989f, -0.13982733f, -0.00062247f, -0.03120065f, 
    0.03017446f, 0.03332133f, -0.04728113f, -0.02666179f, -0.01509286f, 0.05145259f, 0.02670493f, 0.13454209f, 
    0.55871969f, -0.05991992f, 0.22443900f, -0.19871475f, 0.05691164f, 0.21250923f, 0.09126259f, 0.12617506f, 
    0.01472561f, 0.05997118f, 0.02553867f, 0.03431273f, 0.06447731f, 0.03690042f, 0.02987093f, 0.04253803f, 
    0.03157932f, -0.06960887f, -0.09608987f, 0.18618883f, -0.15610452f, -0.19834274f, 0.02926773f, 0.15264465f, 
    -0.16808780f, 0.15256462f, -0.09086550f, -0.09248843f, -0.07886093f, 0.07247887f, 0.17147250f, -0.02290989f, 
    0.07530593f, 0.01338223f, 0.12637731f, -0.01009212f, -0.07750462f, -0.09240548f, -0.09916790f, -0.28416499f, 
    -0.43203220f, -0.04534077f, 0.26401106f, -0.05779598f, 0.01733269f, -0.05721098f, -0.03538638f, 0.03852839f, 
    -0.00473720f, 0.18021694f, 0.08335195f, 0.06127585f, 0.03641174f, 0.02125101f, 0.01763611f, -0.07516149f, 
    -0.02702565f, 0.07261384f, 0.14379448f, 0.27398506f, 0.00082036f, -0.17465250f, 0.59197772f, 0.05981488f, 
    -0.12155548f, -0.31245923f, -0.21276751f, -0.01133181f, -0.06625012f, 0.14266457f, 0.08812280f, 0.14502801f, 
    0.12686111f, 0.02578570f, 0.03718916f, 0.01844147f, -0.01469547f, -0.04968439f, 0.00052308f, 0.01253860f, 
    -0.25704926f, -0.19549707f, 0.13641323f, 0.16934246f, -0.11214188f, 0.32496271f, -0.09657548f, 0.03741606f, 
    0.02439802f, -0.00223672f, 0.10155348f, 0.08538856f, 0.10005963f, 0.05563824f, 0.08284092f, 0.00095040f, 
    -0.14580989f, 0.06898735f, -0.07329612f, -0.15117797f, -0.10763440f, -0.09797445f, -0.14912276f, 0.29935414f, 
    -0.08735494f, 0.13387328f, -0.04043743f, -0.16937490f, 0.09249669f, 0.02740698f, 0.08323389f, -0.04178435f, 
    -0.04109703f, -0.05488175f, -0.07043689f, -0.01122055f, 0.08008254f, -0.08666900f, 0.07098826f, 0.15915473f, 
    0.07839167f, 0.11468447f, -0.04646255f, -0.08576836f, -0.00333621f, -0.06097558f, -0.02634313f, -0.04496498f, 
    -0.02140348f, -0.08658956f, -0.10598285f, -0.09083452f, 0.06345306f, 0.08451641f, 0.07815393f, 0.05204544f, 
    -0.11009962f, -0.08829482f, -0.16340883f, -0.07780357f, 0.36771718f, 0.20604791f, -0.08008956f, 0.00310369f, 
    0.14258572f, -0.09742383f, -0.01577519f, 0.07750326f, 0.03678640f, 0.06386638f, -0.02024827f, 0.01689375f, 
    0.00454871f, -0.03493162f, 0.02823818f, 0.02064967f, -0.07776146f, 0.07064296f, -0.12301514f, 0.00754814f, 
    0.44196171f, 0.19915475f, 0.01389908f, 0.01157209f, 0.14088276f, 0.02791897f, 0.01121890f, 0.02620365f, 
    0.01941766f, 0.00765153f, 0.01052834f, 0.01392303f, -0.02143838f, -0.07621103f, -0.05091529f, -0.02347387f, 
    -0.18818131f, 0.01519470f, -0.02833677f, 0.01269848f, 0.15679653f, 0.19733371f, 0.30431178f, -0.12233537f, 
    -0.11984152f, 0.26494783f, 0.02287822f, 0.07650229f, 0.01200877f, 0.15757392f, 0.15769251f, 0.09633043f, 
    -0.00407007f, -0.03665719f, -0.07873221f, 0.13170776f, 0.05047798f, -0.24134663f, 0.08255688f, -0.11579209f, 
    0.06973349f, 0.12792197f, 0.01837828f, 0.02849359f, 0.20652355f, 0.03399314f, -0.00683437f, 0.00779878f, 
    -0.04720304f, 0.10524981f, 0.12963529f, -0.01776985f, -0.04718601f, -0.03374306f, -0.02662033f, -0.06457728f, 
    0.12226343f, -0.02491844f, 0.07253090f, 0.20935929f, 0.44604361f, 0.08689151f, -0.10129162f, -0.05530605f, 
    0.35596988f, -0.09387565f, 0.08045907f, 0.07184364f, 0.02113787f, -0.08961471f, -0.00325682f, 0.01637754f, 
    0.01090556f, -0.04936792f, -0.01347616f, -0.06747348f, -0.09831312f, -0.00413112f, -0.04778725f, 0.17672874f, 
    -0.16646688f, 0.07081207f, -0.14295144f, 0.05797693f, 0.14084616f, -0.04457010f, 0.12556037f, 0.00404410f, 
    0.13787264f, 0.26394808f, -0.01210386f, -0.03859957f, 0.03635959f, 0.10062550f, -0.00067904f, -0.05497847f, 
    -0.13912329f, -0.04073456f, 0.01908834f, 0.00441952f, -0.33048531f, -0.29280224f, -0.05867307f, 0.18065037f, 
    -0.10669176f, 0.07376816f, 0.05909284f, -0.05263952f, 0.12853329f, -0.00509158f, 0.11683217f, -0.04378469f, 
    0.01432512f, 0.03618988f, -0.05390810f, -0.04619847f, 0.05111172f, -0.12041535f, 0.13390872f, 0.02259336f, 
    -0.13829224f, -0.06008079f, 0.02286559f, 0.16734762f, 0.11221528f, 0.07141097f, 0.03343672f, 0.00262822f, 
    -0.10737934f, -0.10101756f, -0.01115622f, -0.05463185f, -0.09390686f, 0.04386286f, -0.00748694f, -0.08699857f, 
    0.14323391f, 0.08157768f, 0.07732930f, 0.24151063f, -0.07065029f, -0.18275540f, 0.65739429f, 0.26553345f, 
    -0.22252269f, -0.08941191f, -0.01532120f, -0.11848842f, 0.19171053f, -0.21160720f, 0.06334373f, 0.03629718f, 
    -0.00669448f, 0.01910815f, -0.06089905f, -0.00945883f, -0.02171604f, 0.04189276f, 0.03999054f, -0.05763789f, 
    -0.29731950f, -0.52556610f, -0.27324119f, 0.01253733f, 0.24585481f, -0.01743420f, 0.04446372f, 0.07187958f, 
    -0.11635511f, 0.16557021f, -0.09494591f, -0.02863206f, -0.02460802f, 0.08718697f, 0.04500090f, -0.02264445f, 
    0.14447808f, -0.03205225f, -0.02775301f, 0.10435460f, -0.14351621f, 0.05550902f, 0.12362240f, 0.04025784f, 
    -0.03308142f, -0.18270069f, -0.10363552f, 0.03608347f, 0.01472847f, 0.06268191f, 0.13240178f, 0.15595658f, 
    0.08218158f, 0.06422865f, 0.08602858f, -0.02028168f, -0.10741230f, 0.01446950f, -0.04145990f, 0.02700634f, 
    -0.13255416f, -0.09706247f, 0.05423025f, 0.04170056f, -0.04764194f, 0.01693174f, -0.04230002f, -0.13880762f, 
    -0.10490403f, -0.12099075f, 0.03891344f, 0.06229836f, 0.07685110f, 0.01722774f, 0.04827411f, 0.00048326f, 
    -0.07384153f, -0.04308648f, -0.09916551f, -0.19989799f, -0.13603255f, -0.05660031f, -0.04352390f, 0.50004536f, 
    -0.00535615f, -0.24512491f, -0.09207084f, 0.05515766f, -0.18312129f, -0.07732809f, -0.05033397f, -0.02171254f, 
    -0.03204939f, -0.03862372f, -0.06981155f, -0.03826581f, -0.00710543f, -0.08275463f, 0.04814606f, -0.11662265f, 
    0.09538686f, 0.17057955f, 0.12092394f, -0.04367745f, 0.02287870f, 0.08895017f, 0.01737706f, 0.06615151f, 
    -0.03668161f, -0.00010762f, 0.02603802f, 0.02691837f, -0.03003170f, -0.07603476f, -0.04402854f, 0.05576050f, 
    -0.12286682f, -0.02366002f, -0.08444874f, -0.11400080f, 0.67891437f, -0.00993134f, -0.12680888f, -0.15045451f, 
    -0.00682218f, 0.05001569f, 0.09202266f, 0.07362910f, -0.06012811f, 0.06562704f, 0.03110307f, 0.00205334f, 
    0.02532191f, 0.00576199f, 0.02421508f, -0.05302256f, 0.08409593f, 0.08803214f, 0.01708334f, 0.25559866f, 
    0.25661352f, 0.20274009f, 0.05847324f, -0.03915370f, 0.04161808f, -0.03771029f, -0.02547547f, 0.05292998f, 
    0.06687690f, 0.03867850f, 0.05289688f, -0.01964014f, 0.05206463f, -0.05237309f, -0.01163686f, -0.02502444f, 
    0.02642963f, -0.06540333f, -0.06765784f, 0.09727738f, -0.18847060f, -0.03559448f, 0.09682132f, 0.20667191f, 
    0.01549484f, -0.02206961f, 0.01542714f, -0.13082114f, 0.00679793f, -0.12388901f, -0.00357337f, 0.00397193f, 
    -0.09045883f, 0.08845221f, 0.13132666f, 0.02194015f, 0.13146077f, -0.00331242f, 0.06422868f, 0.15185559f, 
    -0.05013615f, -0.07058373f, -0.15455005f, 0.09582990f, 0.08250018f, 0.07377434f, 0.08696268f, -0.10424329f, 
    -0.02901163f, 0.15792114f, -0.01410959f, 0.05260509f, 0.12134825f, 0.08371302f, -0.03326426f, 0.01225659f, 
    -0.14567429f, -0.11254860f, -0.08990657f, -0.01907462f, -0.04849409f, 0.09696583f, -0.08246661f, 0.24369194f, 
    -0.05309674f, -0.28215533f, -0.09471900f, -0.05389982f, -0.05577527f, 0.50588745f, 0.00845006f, 0.10802414f, 
    0.12369116f, 0.03052226f, -0.02182837f, -0.06013630f, 0.00105609f, -0.01057428f, -0.03578090f, 0.01191866f, 
    -0.03760447f, -0.00027405f, 0.01861544f, 0.01613129f, -0.04128128f, 0.01792408f, -0.01860362f, -0.02690742f, 
    0.00175843f, -0.01437585f, -0.02462173f, 0.03142684f, 0.01095037f, -0.03890568f, -0.01677170f, 0.00954823f, 
    -0.01310667f, -0.00104773f, -0.02420847f, -0.04614929f, -0.03298021f, -0.03686468f, 0.02114347f, -0.00829780f, 
    0.02048492f, -0.01270005f, 0.03831176f, 0.03371808f, -0.01838403f, -0.01922211f, 0.02520447f, 0.00883253f, 
    -0.03564929f, 0.01520002f, -0.00727814f, -0.03784538f, 0.02988196f, 0.02916679f, 0.00728322f, 0.01164823f, 
    -0.01051392f, -0.02762434f, 0.00277187f, 0.01670420f, -0.00471231f, -0.04468666f, -0.04197398f, -0.01968671f, 
    -0.03962059f, 0.03137234f, -0.02150524f, 0.02865780f, 0.02644342f, -0.00038782f, -0.00418742f, -0.00440784f, 
    -0.02924122f, -0.02241473f, -0.01486301f, 0.00692751f, 0.01869663f, 0.01015987f, 0.01197772f, 0.02066831f, 
    0.01606178f, 0.02142146f, 0.01022731f, -0.01421472f, -0.04305765f, 0.00999395f, -0.02437685f, -0.03787795f, 
    0.02787776f, 0.03100895f, -0.01315805f, 0.01041233f, 0.00761279f, -0.02898992f, -0.00803373f, -0.03184343f, 
    -0.01563349f, 0.00191870f, 0.01894295f, -0.03820752f, 0.02368193f, -0.01825931f, 0.01303319f, -0.02670942f, 
    0.02731910f, -0.04765474f, -0.02630940f, 0.01740933f, -0.03070691f, -0.01140608f, -0.02425820f, -0.02584902f, 
    0.03002170f, -0.01418766f, 0.00750299f, 0.01069150f, -0.02197572f, 0.03311003f, -0.02006546f, -0.00710667f, 
    -0.00630897f, -0.04095016f, 0.03211162f, 0.01099153f, -0.04031907f, -0.03243335f, -0.01783733f, 0.01781212f, 
    -0.02519230f, -0.03218170f, 0.00893891f, -0.03086239f, -0.03979860f, -0.00356621f, -0.03543025f, 0.02929335f, 
    -0.03350086f, -0.01126570f, -0.00046248f, -0.01260180f, -0.01961471f, -0.04420358f, 0.02922982f, 0.01888089f, 
    -0.04305573f, 0.01595926f, -0.04446536f, -0.03908892f, 0.02527168f, 0.01950105f, -0.03846243f, 0.03273336f, 
    0.01714195f, 0.00425589f, 0.02242612f, -0.03958990f, -0.04042296f, 0.04032944f, -0.01310221f, 0.00544115f, 
    0.02246938f, -0.03703764f, 0.00246128f, 0.03571308f, -0.01789019f, -0.03712000f, 0.00791433f, -0.04343678f, 
    -0.01733859f, 0.01122796f, -0.04457359f, -0.01740215f, 0.02048926f, 0.00045150f, 0.02078813f, 0.03337502f, 
    0.02610499f, -0.02951999f, 0.02145733f, -0.01722708f, 0.01329487f, -0.00319759f, -0.01420624f, 0.02202220f, 
    -0.00836450f, -0.03344769f, -0.00052694f, 0.00454211f, -0.00878050f, 0.01177009f, -0.00159282f, -0.04019676f, 
    -0.03866512f, -0.04056525f, -0.04408085f, 0.01468291f, -0.03445164f, -0.02244916f, -0.03107144f, -0.02814250f, 
    -0.00732825f, 0.01671091f, 0.01620236f, 0.01633400f, -0.00432893f, 0.00572027f, 0.02433910f, -0.03792375f, 
    0.03185764f, -0.01068134f, -0.01703221f, 0.01016271f, 0.02059775f, -0.00652219f, -0.00876875f, 0.02649499f, 
    0.00308006f, -0.01533420f, -0.02572251f, -0.01938110f, 0.02394487f, 0.02439324f, -0.03126221f, 0.01635590f, 
    -0.02174032f, 0.01951860f, 0.01704613f, 0.00334659f, 0.02766147f, 0.01334584f, 0.02677450f, -0.01921628f, 
    -0.03157120f, -0.01085858f, -0.03914380f, -0.04277724f, 0.01699833f, -0.03488998f, -0.01294720f, -0.03069300f, 
    0.03238953f, -0.02942598f, 0.03076723f, -0.03327101f, -0.01538541f, 0.02885701f, -0.00813527f, 0.02572232f, 
    -0.01088398f, -0.01655229f, -0.03362581f, 0.02262176f, 0.01593537f, 0.01955803f, -0.00061889f, 0.02912696f, 
    -0.00542696f, 0.00366997f, 0.01484912f, 0.03099331f, -0.00600415f, -0.04258134f, -0.02039411f, -0.02862915f, 
    -0.00470279f, -0.02453039f, 0.01550509f, 0.00865822f, -0.01686000f, 0.02655848f, 0.02290456f, 0.02082528f, 
    -0.00151105f, -0.00903425f, -0.01501329f, 0.01388376f, 0.00862273f, -0.02928221f, 0.00256306f, -0.04150905f, 
    0.00348585f, 0.01346022f, -0.00651022f, -0.03882152f, 0.01335131f, 0.00969177f, 0.02427799f, 0.01243714f, 
    -0.03210317f, 0.00809608f, -0.03513428f, 0.00877064f, -0.03658410f, 0.01808005f, 0.01536114f, -0.02498849f, 
    -0.04022833f, 0.01077196f, -0.01492975f, 0.00823705f, 0.00646278f, 0.01379146f, -0.03625607f, -0.00130674f, 
    0.00339600f, 0.02175717f, -0.03380900f, 0.01655225f, -0.03601832f, 0.02866324f, 0.03133971f, 0.00506629f, 
    0.00654702f, -0.03743688f, -0.02035962f, 0.02855660f, 0.03085236f, 0.02443102f, 0.02348528f, -0.00670371f, 
    -0.00691515f, 0.03078934f, -0.03146168f, 0.02067612f, -0.02171231f, -0.00625770f, 0.01135775f, -0.00749745f, 
    0.02914711f, -0.02231154f, 0.02837216f, -0.03096548f, -0.02003139f, -0.02410661f, -0.01121406f, 0.00773432f, 
    0.01684512f, -0.00338416f, -0.00236190f, 0.01570088f, 0.02122424f, -0.01898833f, -0.04140082f, -0.03981733f, 
    0.00914459f, 0.01820250f, -0.00723854f, -0.00639769f, 0.00912296f, 0.02112966f, -0.01716860f, -0.02318320f, 
    -0.03891893f, 0.02664661f, 0.01890998f, 0.03070162f, -0.04513411f, -0.03581523f, -0.04235145f, 0.02679704f, 
    -0.01972030f, -0.03976737f, -0.01988824f, -0.00782536f, 0.02370371f, -0.01587620f, -0.01695921f, 0.00453827f, 
    -0.00142142f, -0.02910306f, -0.01230716f, 0.01308717f, 0.02568163f, 0.00746161f, -0.01612139f, -0.03341911f, 
    -0.00133397f, -0.03279020f, -0.03366548f, 0.02561354f, -0.00420523f, -0.02877823f, -0.00553173f, 0.03332692f, 
    -0.00707452f, 0.03298076f, 0.02647022f, 0.04090917f, 0.00294088f, 0.01940023f, 0.00928492f, -0.04116384f, 
    -0.02641195f, -0.03796360f, -0.02195325f, -0.03140398f, 0.01493295f, 0.02690988f, -0.01103831f, -0.01610060f, 
    0.01253681f, -0.04201172f, -0.01619353f, -0.01172340f, -0.01444460f, -0.00318202f, -0.02137106f, 0.00104555f, 
    -0.04095795f, 0.00472421f, -0.02880129f, -0.03209952f, -0.04033609f, -0.04189422f, -0.02851188f, -0.01362897f, 
    0.02569032f, -0.03138940f, -0.01017044f, -0.00841276f, -0.02542984f, -0.03619919f, -0.00049163f, -0.00166498f, 
    -0.00158766f, -0.00215588f, 0.01585242f, -0.00979397f, -0.00433399f, -0.00495447f, -0.02435446f, -0.04138048f, 
    -0.03528477f, -0.02728130f, -0.01845930f, 0.02903953f, 0.02306791f, 0.00279222f, 0.00826797f, -0.00253146f, 
    -0.00825563f, 0.03045529f, 0.02270635f, -0.00963119f, -0.02990236f, 0.01093408f, 0.02638376f, 0.01771707f, 
    -0.01014755f, -0.00144983f, 0.01732220f, -0.00140054f, -0.02315219f, -0.03507516f, 0.00714863f, -0.02803276f, 
    -0.01744799f, -0.04304172f, -0.02168847f, -0.01147206f, 0.00981421f, -0.03503935f, -0.00313819f, -0.04059765f, 
    -0.04252690f, 0.02206936f, 0.03282672f, 0.01601597f, -0.01278367f, -0.02293421f, -0.02639912f, 0.03002113f, 
    0.01855819f, -0.01662651f, -0.01597770f, -0.00424668f, -0.02602570f, 0.01855350f, -0.00205703f, 0.00996149f, 
    0.01745013f, 0.02694834f, 0.03992114f, 0.02693759f, -0.02500059f, 0.01654019f, -0.01997174f, 0.03439546f, 
    -0.00957549f, -0.01648321f, -0.02339095f, -0.01313945f, -0.03100698f, -0.03730728f, -0.00852690f, -0.03947113f, 
    0.00497264f, 0.01539013f, -0.03300195f, -0.03741317f, -0.00326683f, -0.00628768f, -0.01322529f, 0.03347485f, 
    -0.00591104f, -0.01917019f, -0.01469091f, 0.02176393f, -0.03722531f, -0.02047481f, 0.00701608f, -0.01584350f, 
    -0.02681310f, 0.00720540f, 0.01308164f, -0.03555006f, -0.00997147f, -0.02100581f, 0.03241323f, 0.01651388f, 
    0.03348520f, 0.01645968f, 0.00312183f, -0.00110154f, -0.01215946f, 0.00006686f, -0.04323348f, -0.00961586f, 
    -0.04027741f, 0.01002302f, 0.00550941f, 0.01396597f, -0.03722141f, 0.02048633f, 0.00249661f, 0.01677051f, 
    0.00606758f, -0.01005115f, 0.02807858f, -0.02930749f, 0.00620624f, 0.01836260f, -0.02866972f, 0.03474999f, 
    0.04129300f, 0.01256775f, -0.00554126f, 0.00755033f, -0.00892247f, -0.00075060f, 0.00377163f, -0.01907055f, 
    0.01485119f, -0.02432507f, -0.01196924f, 0.02464406f, 0.02967147f, 0.00381522f, -0.02875814f, -0.02798636f, 
    -0.00997770f, 0.00305935f, -0.00443519f, 0.00136586f, -0.01000178f, 0.03154621f, -0.04287856f, 0.03360105f, 
    0.02638022f, -0.01841776f, -0.01184685f, 0.01271115f, -0.02144055f, 0.00872392f, -0.02437225f, 0.00431744f, 
    -0.01490317f, -0.04446367f, -0.00587971f, 0.02112867f, -0.03859418f, -0.01822345f, -0.00403281f, 0.00963478f, 
    0.02641187f, -0.03635791f, -0.00239999f, 0.02909227f, -0.03825932f, -0.04163520f, 0.02160577f, -0.04383498f, 
    0.00110278f, 0.00648992f, -0.01353429f, 0.02700585f, -0.03880393f, -0.04020257f, -0.02482070f, -0.03320957f, 
    0.02592425f, 0.02432207f, 0.01258938f, 0.03165096f, -0.03128584f, 0.00022394f, -0.00806384f, -0.03784415f, 
    0.01905220f, -0.02629453f, -0.00922982f, -0.03917417f, -0.03809354f, 0.01443577f, -0.00815085f, 0.03288613f, 
    -0.03087557f, 0.00142451f, -0.00108187f, -0.00224320f, 0.01102824f, -0.04123751f, 0.01352645f, -0.01916917f, 
    0.00424109f, 0.00636337f, -0.00438851f, -0.01656770f, 0.00399202f, -0.00586576f, -0.03064088f, 0.01008912f, 
    -0.00642166f, -0.01063985f, -0.01897004f, -0.00755818f, 0.00839845f, 0.01107899f, 0.00230127f, -0.04119365f, 
    -0.02164754f, -0.03476762f, 0.03746565f, 0.03109551f, 0.01918812f, -0.00802439f, -0.04050300f, 0.01519317f, 
    0.02405876f, 0.02865697f, -0.01655129f, 0.01077498f, 0.01050030f, 0.00127500f, 0.03016104f, 0.02214586f, 
    -0.01427385f, -0.04191143f, -0.02473039f, 0.00286229f, 0.00256221f, 0.00595346f, -0.04401559f, -0.00653333f, 
    0.02936916f, -0.01560388f, -0.00219535f, -0.00583875f, -0.01445179f, 0.02801559f, -0.03798055f, 0.00818555f, 
    -0.03939362f, -0.04078852f, 0.02607074f, -0.02486507f, 0.01055344f, 0.02648425f, 0.01706329f, -0.03991392f, 
    0.00562309f, -0.04512773f, 0.02377797f, 0.03070012f, -0.01707496f, -0.04522202f, -0.02313516f, 0.00653334f, 
    -0.00721576f, -0.02844253f, 0.00803589f, -0.00761820f, 0.03152708f, -0.03155756f, -0.01961623f, 0.03336648f, 
    0.02922822f, 0.00756054f, -0.04313431f, -0.01711609f, 0.02242618f, 0.00708237f, -0.02092116f, 0.01059025f, 
    0.03408366f, -0.01538907f, -0.00942487f, 0.01264476f, 0.02313903f, 0.00267708f, -0.03906797f, 0.01971953f, 
    0.02732357f, 0.03333907f, -0.02125189f, 0.01980351f, 0.02678774f, 0.04077899f, -0.03346798f, -0.00625659f, 
    -0.03434648f, 0.00178029f, 0.01395463f, 0.00306540f, -0.01332679f, 0.01243669f, 0.00373804f, 0.01696873f, 
    -0.00535763f, -0.00889538f, 0.01534007f, 0.02325274f, -0.01615882f, -0.04023349f, 0.03752832f, -0.03791330f, 
    0.03287590f, 0.01907177f, 0.00679337f, -0.03796320f, -0.02556843f, 0.01101583f, -0.00116127f, 0.00529584f, 
    0.03383106f, -0.02888857f, -0.03264945f, -0.04094042f, 0.01426260f, 0.02755798f, -0.03692136f, 0.00167988f, 
    0.01672575f, -0.03870486f, 0.02211876f, 0.02562270f, 0.02879848f, -0.02465238f, -0.03820447f, 0.03469777f, 
    -0.02344047f, -0.00339780f, -0.01666729f, -0.01028895f, -0.00831728f, -0.03800186f, 0.02728814f, -0.01389511f, 
    0.01909083f, 0.02331471f, -0.01360421f, 0.01514486f, -0.02412854f, -0.00526863f, 0.00704639f, -0.03196959f, 
    -0.02653943f, -0.02434453f, -0.03877219f, -0.01248812f, 0.00517269f, -0.02517095f, 0.03044805f, -0.02537568f, 
    0.01285756f, -0.00279563f, 0.02071458f, -0.02682643f, -0.02458700f, -0.01712491f, -0.02420516f, -0.01783995f, 
    0.03270453f, -0.00561967f, -0.01094840f, -0.02004568f, -0.03874630f, -0.00528462f, -0.00338900f, 0.00973858f, 
    -0.00315283f, 0.00102444f, 0.02699413f, 0.01503832f, -0.02786164f, 0.02382520f, -0.00855618f, 0.01677014f, 
    0.00785598f, -0.01060040f, -0.03281726f, 0.01444405f, -0.01380423f, 0.03126076f, -0.01765100f, -0.03460705f, 
    -0.01279044f, 0.01539681f, -0.02359173f, -0.02933510f, -0.00193551f, 0.00582264f, -0.01437859f, -0.03348466f, 
    0.00006708f, -0.04129640f, -0.03204300f, 0.02749876f, 0.03249072f, -0.03317680f, -0.02441107f, -0.00594409f, 
    0.01935911f, 0.02843009f, 0.01344603f, -0.03865613f, -0.03294316f, 0.02733374f, 0.00850273f, 0.03378148f, 
    0.00490851f, -0.00666951f, -0.01357372f, -0.03191380f, 0.01093099f, 0.01037780f, -0.01983111f, -0.02878402f, 
    0.01122859f, 0.00578441f, 0.02050532f, 0.01380631f, -0.00132099f, -0.02852371f, 0.02148995f, -0.00437186f, 
    -0.02772495f, -0.01235140f, 0.00241366f, 0.03169799f, 0.03530267f, 0.01754408f, 0.00488207f, -0.03248708f, 
    -0.03914942f, -0.04009793f, -0.01891802f, 0.01792087f, -0.03282579f, 0.01721771f, 0.02308933f, 0.00255022f, 
    -0.01270212f, -0.02008916f, 0.01002409f, -0.03072135f, 0.02337993f, -0.01274591f, 0.02251708f, -0.03863772f, 
    0.00501559f, -0.00406237f, -0.01899738f, 0.00163440f, -0.01912686f, -0.02758336f, 0.02524982f, -0.00422456f, 
    0.01215296f, 0.01048278f, 0.00888377f, 0.01398673f, -0.00937380f, 0.03215088f, 0.03569559f, -0.00631242f, 
    0.02805752f, -0.00793937f, 0.03004411f, -0.03122640f, 0.01423266f, 0.01937747f, 0.00426242f, -0.00666725f, 
    -0.03890379f, 0.02687557f, 0.04320888f, -0.01057235f, 0.01309815f, -0.00245568f, -0.02730596f, 0.02184127f, 
    -0.03306525f, -0.03193166f, 0.03683884f, -0.01089687f, -0.01783115f, -0.00014417f, -0.04301833f, -0.00743798f, 
    -0.01278910f, 0.01204443f, 0.00791298f, -0.03414622f, -0.01659948f, 0.00121120f, -0.01026009f, -0.01176081f, 
    0.02098075f, 0.00429517f, -0.00330586f, 0.03454511f, 0.00057178f, -0.02642596f, -0.01086321f, 0.01482523f, 
    0.02176411f, 0.00747819f, 0.00757055f, 0.00647880f, -0.03523264f, -0.04512165f, -0.00393061f, 0.01092343f, 
    0.00729884f, 0.00617155f, 0.02275385f, -0.01281412f, -0.04042640f, 0.01287229f, -0.00432366f, 0.00418667f, 
    -0.02030241f, 0.01865370f, 0.03930831f, -0.03203228f, -0.04171529f, 0.01114893f, -0.03590519f, -0.01491405f, 
    -0.01774736f, -0.03533388f, 0.02041359f, 0.00043766f, -0.02766784f, -0.02556070f, 0.01072871f, -0.01989358f, 
    -0.02682538f, 0.04215676f, -0.02268554f, 0.00634379f, -0.02886152f, -0.03127514f, -0.03021984f, -0.01162189f, 
    0.00980617f, -0.02115615f, -0.02399360f, 0.00385031f, -0.02402520f, 0.00980550f, -0.00841862f, -0.00447877f, 
    0.01543419f, 0.03312990f, 0.00848735f, 0.00222085f, -0.01782903f, 0.02302871f, 0.01129427f, -0.02848786f, 
    0.02100111f, -0.01538708f, 0.00063552f, 0.03337420f, -0.01335865f, -0.04108328f, -0.00424194f, -0.02586252f, 
    -0.00812616f, 0.01949584f, -0.03908101f, 0.00713802f, 0.01808847f, 0.01700105f, -0.00312052f, 0.02052871f, 
    -0.02782027f, 0.02492302f, -0.00907714f, 0.02777234f, 0.04050160f, 0.02768780f, -0.02272942f, 0.00603910f, 
    0.02927166f, 0.02304107f, -0.04325582f, 0.02442536f, -0.02329048f, 0.02054479f, -0.01413336f, -0.03477097f, 
    0.02212736f, -0.04295432f, 0.02455845f, -0.00804844f, 0.02530785f, 0.01550898f, -0.01858500f, 0.03730741f, 
    -0.03947318f, -0.02419598f, -0.03427016f, 0.00334120f, 0.04145311f, -0.00347112f, 0.02624102f, -0.02461451f, 
    0.03348110f, 0.01974662f, -0.04398746f, 0.02243245f, -0.01243363f, 0.02644253f, -0.02144692f, -0.01465136f, 
    0.01307222f, 0.03369451f, 0.00937401f, -0.01317766f, -0.02832686f, 0.02230468f, -0.01658433f, -0.03998590f, 
    0.01011770f, 0.01252936f, 0.02495697f, -0.00234702f, 0.03087006f, -0.00106920f, 0.03737019f, 0.01301939f, 
    -0.03339132f, -0.03865634f, 0.02701824f, -0.03842883f, -0.04328771f, 0.00987703f, -0.04068427f, -0.00306019f, 
    0.02368214f, -0.02212042f, -0.02794730f, 0.00928101f, -0.03980337f, 0.03790024f, 0.00065078f, -0.03540558f, 
    -0.03297054f, 0.02338329f, -0.03446023f, 0.02315073f, 0.01464691f, -0.00231799f, -0.03582228f, -0.02052863f, 
    0.01952984f, 0.01162033f, 0.00484614f, -0.00194419f, -0.00635576f, 0.00892320f, 0.00139410f, -0.02507672f, 
    0.00428560f, -0.03535961f, 0.00494185f, -0.03704340f, -0.02473298f, -0.00424122f, -0.02284954f, -0.02848172f, 
    -0.00798376f, -0.01600487f, 0.03378367f, -0.03230051f, -0.03859914f, -0.02248299f, -0.04836583f, 0.01694969f, 
    -0.03608277f, -0.01014587f, 0.02031683f, -0.02863181f, 0.01083626f, -0.01407338f, 0.03198398f, 0.01473492f, 
    0.00204260f, -0.03038058f, -0.03152489f, 0.00594940f, -0.03702826f, -0.02068616f, -0.03322610f, -0.03155369f, 
    0.01570995f, -0.01190030f, 0.01113845f, 0.02455150f, -0.03717458f, -0.03312431f, -0.03910781f, -0.01610749f, 
    0.02274247f, -0.01042201f, -0.00851347f, -0.01289485f, 0.00248865f, -0.00192571f, 0.01328075f, -0.00709938f, 
    -0.01411755f, -0.02761169f, -0.02434748f, -0.01858908f, -0.00830738f, -0.01634670f, -0.03474125f, -0.01582950f, 
    0.02753890f, -0.00381357f, -0.01029389f, -0.02057959f, 0.02566386f, -0.00795591f, -0.02262536f, -0.04703618f, 
    -0.02547279f, -0.01831228f, 0.02679842f, -0.03499744f, -0.03478339f, 0.03284260f, -0.03916457f, -0.01194131f, 
    -0.03176272f, 0.02650829f, 0.00766676f, -0.01478002f, 0.03322900f, 0.01449223f, -0.01650096f, -0.01069448f, 
    -0.04399258f, -0.02577671f, 0.02989988f, 0.01209526f, -0.02638476f, 0.02121479f, -0.04476001f, -0.02129998f, 
    -0.00667912f, -0.04237665f, -0.03716617f, -0.01730223f, 0.02250415f, -0.02216935f, -0.03619525f, -0.01033975f, 
    -0.00175671f, -0.03395819f, 0.02402236f, -0.00520381f, -0.02444614f, 0.00510333f, 0.00841957f, -0.03106256f, 
    0.01963136f, -0.00024895f, -0.00768177f, -0.03378664f, -0.00783321f, 0.03456132f, 0.02727940f, -0.00256590f, 
    -0.01893353f, -0.02479835f, 0.02531991f, 0.00796186f, 0.02397380f, 0.01363243f, 0.02695593f, -0.00119351f, 
    0.00650923f, -0.03021529f, -0.01652495f, -0.02228704f, 0.02986402f, -0.01803547f, -0.03590390f, -0.02918297f, 
    -0.01397706f, 0.03112342f, 0.01427399f, -0.00543860f, 0.01043520f, 0.01464332f, 0.02318639f, 0.02424356f, 
    0.01725204f, -0.02798543f, 0.02462199f, -0.01977761f, 0.03801651f, 0.03784122f, -0.02420969f, 0.00112527f, 
    -0.00154022f, 0.01737548f, -0.03047378f, 0.03346375f, 0.02831218f, 0.02617914f, 0.00065272f, 0.03353871f, 
    0.02283656f, -0.03050902f, 0.02314798f, 0.00864381f, 0.01517617f, -0.04235502f, -0.02060030f, -0.03585077f, 
    -0.01257962f, -0.00043496f, -0.03467036f, -0.00735613f, 0.02438134f, 0.00785141f, 0.03225408f, -0.03874846f, 
    -0.03354707f, -0.01345018f, -0.02096900f, -0.01616872f, -0.02755529f, 0.00891460f, -0.03645522f, 0.03524588f, 
    0.02008324f, 0.01259232f, 0.02653221f, 0.03094607f, -0.04327535f, -0.01319875f, 0.03010415f, -0.02387992f, 
    0.02134183f, 0.00952412f, 0.02260115f, 0.02566950f, 0.00879639f, -0.00233221f, 0.03272529f, -0.02143453f, 
    0.02267171f, 0.00114324f, 0.02759642f, -0.01333775f, -0.04024346f, 0.00498020f, -0.02896695f, 0.00718192f, 
    0.17340511f, 0.10151574f, 0.26385421f, -0.00212552f, -0.21320260f, 0.01827050f, -0.06714286f, 0.32400706f, 
    0.22519279f, 0.03998008f, 0.01681017f, 0.12180194f, 0.07474550f, -0.01062396f, -0.14599426f, -0.07447083f, 
    0.08337618f, 0.14176297f, 0.12748462f, -0.01992460f, 0.19577223f, -0.22969700f, -0.29194477f, 0.13649769f, 
    -0.04082422f, -0.02024203f, -0.03932751f, 0.00589072f, 0.02575846f, 0.09558913f, 0.02703638f, 0.14114062f, 
    0.00812958f, -0.07334130f, -0.06277309f, -0.12310203f, -0.08247982f, -0.00837821f, 0.26130760f, 0.06518807f, 
    -0.01976903f, 0.08969436f, -0.07367996f, -0.00985120f, 0.05912920f, 0.03215715f, 0.00738039f, -0.04888944f, 
    0.02285143f, 0.06592356f, -0.03238428f, -0.01232267f, 0.01506430f, 0.00951008f, 0.00285602f, -0.00321940f, 
    0.02467673f, -0.10036016f, 0.27843195f, 0.25110433f, -0.29450774f, 0.67512798f, 0.44950986f, -0.51138961f, 
    0.18775971f, -0.24499486f, 0.13509256f, 0.38600448f, 0.46288651f, 0.05584740f, -0.03150567f, 0.06631991f, 
    -0.07712112f, 0.13657838f, 0.11390721f, -0.17344931f, -0.14896710f, 0.02180997f, 0.05611532f, -0.07395148f, 
    0.11385580f, -0.05263587f, 0.02971216f, 0.01341822f, 0.07661372f, 0.01225879f, -0.06655058f, -0.02702269f, 
    -0.04380812f, -0.09219631f, 0.01393177f, 0.11195573f, 0.09101636f, 0.03632561f, -0.02454695f, 0.14050792f, 
    -0.00006868f, 0.01934461f, 0.01550785f, 0.13087067f, 0.32172635f, 0.29417577f, 0.18804210f, -0.19701774f, 
    0.06119808f, 0.23114423f, -0.05082102f, -0.05896350f, 0.17018366f, 0.04789907f, -0.03653565f, -0.01702587f, 
    0.05922394f, -0.06355233f, 0.01318013f, 0.04797762f, -0.00449507f, -0.07952826f, 0.06599163f, -0.00911032f, 
    0.19616070f, -0.21490858f, -0.07207974f, 0.05356227f, -0.33833662f, 0.06783844f, -0.14614347f, -0.02532216f, 
    0.21389705f, 0.12568335f, -0.05459163f, -0.06464051f, -0.00311642f, 0.03059473f, -0.02685721f, 0.09600405f, 
    -0.04073928f, 0.00183903f, 0.14320669f, 0.11241507f, -0.01667210f, -0.07063834f, -0.01222807f, -0.06633048f, 
    0.00423732f, 0.06357694f, 0.12578478f, -0.02925678f, 0.18840553f, -0.00812725f, -0.03947810f, 0.10943776f, 
    0.08138923f, 0.07578887f, 0.01343871f, -0.03653862f, 0.04910724f, 0.12824750f, 0.13697091f, 0.11758582f, 
    0.13989677f, -0.00916103f, -0.24759611f, -0.11675629f, -0.24237852f, 0.06401320f, 0.13975053f, 0.22664438f, 
    0.08128412f, 0.05849043f, 0.02916129f, 0.04167844f, -0.04368607f, 0.15178716f, -0.05879566f, -0.06848668f, 
    -0.10582939f, -0.03616313f, -0.15686440f, -0.15032899f, 0.35545328f, -0.14136642f, -0.72442591f, -0.44240481f, 
    -0.28095865f, 0.04824540f, 0.02017740f, 0.15318224f, 0.15157539f, -0.01329971f, 0.02265282f, 0.01568024f, 
    -0.02478514f, -0.01377146f, -0.10935608f, -0.03676573f, 0.00270632f, -0.02295418f, 0.02979855f, 0.00728227f, 
    -0.08357161f, 0.00254755f, 0.09621541f, -0.05722194f, -0.01456425f, 0.05316896f, 0.08561434f, 0.20796947f, 
    0.14687701f, 0.05691664f, 0.00592757f, 0.05873838f, 0.11821373f, 0.00537036f, -0.01833854f, -0.03735089f, 
    0.07953905f, 0.03778582f, 0.14152785f, 0.24141300f, -0.15808196f, 0.09200709f, 0.30790100f, 0.13809821f, 
    -0.03949714f, -0.11160682f, -0.05383906f, 0.10538466f, 0.18150683f, 0.19048892f, -0.00846351f, 0.05449403f, 
    -0.02171044f, -0.00365916f, -0.00485797f, 0.01641731f, -0.00841804f, -0.03760886f, -0.21071863f, -0.16228728f, 
    -0.09687471f, -0.24600716f, -0.29150635f, -0.04232052f, -0.10933697f, -0.01391671f, -0.02810813f, -0.02537411f, 
    -0.06440154f, -0.01059801f, -0.09752071f, -0.03424479f, 0.03105908f, 0.02773414f, -0.00777131f, -0.08234057f, 
    0.07460374f, 0.11099343f, 0.05082968f, 0.11216028f, 0.06100784f, -0.09653962f, 0.23766446f, 0.21067359f, 
    -0.04438701f, -0.10423906f, 0.03008981f, -0.09308977f, 0.04338008f, -0.04611835f, 0.03045603f, -0.00736880f, 
    0.12091047f, -0.03581611f, -0.05039846f, -0.07602958f, 0.25326622f, 0.06481852f, 0.13381794f, 0.12906721f, 
    0.08257559f, 0.04068596f, 0.03265723f, 0.27337307f, -0.10968351f, -0.12857281f, -0.14091121f, -0.03621002f, 
    -0.03774589f, -0.10718655f, -0.05298188f, -0.00532307f, -0.03292911f, -0.03911009f, -0.02083923f, -0.18855368f, 
    -0.00363740f, 0.10827684f, 0.02989773f, 0.03400104f, -0.00540729f, 0.09259499f, 0.14081061f, 0.36574709f, 
    0.24152610f, -0.13696261f, 0.09028832f, -0.06716404f, -0.03972108f, 0.01018645f, 0.02221986f, 0.12540179f, 
    -0.00272660f, 0.18302111f, 0.27977449f, 0.03874807f, -0.07313732f, -0.00567769f, 0.40910044f, -0.06979322f, 
    0.02638538f, -0.18471228f, 0.16980457f, 0.23900399f, -0.06468115f, -0.10731055f, -0.09593384f, -0.02658218f, 
    -0.12623283f, -0.12186322f, 0.05216427f, 0.01751917f, -0.12115401f, 0.07711792f, 0.01265134f, 0.05826893f, 
    -0.15621006f, 0.02428749f, 0.07437193f, -0.25443360f, 0.31956792f, -0.02415933f, 0.19029216f, 0.18129310f, 
    -0.15343416f, -0.06781494f, -0.05486077f, -0.12111969f, -0.02749754f, -0.04491286f, -0.05181349f, 0.04695798f, 
    0.07308357f, -0.02738487f, -0.07613903f, 0.02966739f, 0.07406093f, 0.03907032f, -0.06175235f, 0.06529207f, 
    -0.28681827f, -0.00074948f, 0.30910841f, -0.00301200f, -0.08164544f, -0.07871613f, -0.07411738f, 0.12981255f, 
    0.04679605f, -0.00840450f, 0.02447390f, -0.00786883f, 0.02636954f, 0.03162771f, -0.07682714f, -0.01289820f, 
    0.14409694f, 0.08774394f, 0.28798562f, 0.13951194f, 0.17851779f, -0.10363100f, 0.15655507f, 0.14999272f, 
    -0.02294282f, -0.12803707f, -0.12030707f, -0.02297426f, 0.00937848f, 0.09447205f, -0.08472922f, 0.01843585f, 
    -0.05938090f, 0.11900177f, 0.05812956f, 0.05514161f, -0.00969139f, 0.08134579f, -0.03619684f, 0.17880581f, 
    0.27829450f, 0.12763986f, 0.18670627f, 0.00676597f, -0.08704703f, 0.10906996f, 0.05661224f, 0.12035509f, 
    0.02386588f, 0.08614586f, -0.04589595f, -0.02692638f, -0.00374700f, -0.03929643f, -0.06525795f, -0.10369558f, 
    -0.19890557f, -0.15100485f, -0.05943068f, -0.41617927f, 0.15232240f, 0.40982407f, -0.10762642f, -0.15061767f, 
    0.03807250f, 0.12493491f, 0.08236946f, 0.16380422f, 0.09044581f, 0.23269796f, -0.09785841f, 0.01056894f, 
    -0.01048135f, -0.13651156f, 0.06840137f, 0.03101133f, 0.02075915f, -0.14934027f, 0.04140057f, 0.14325596f, 
    0.34879079f, -0.01806045f, 0.05500635f, -0.10336811f, -0.00853574f, -0.07987536f, -0.06444729f, 0.09464046f, 
    -0.01502431f, -0.12176189f, 0.02137455f, 0.19711959f, -0.11933316f, 0.23902309f, -0.04103607f, -0.02135256f, 
    -0.08230360f, 0.05757438f, 0.05679760f, 0.02211664f, 0.19988945f, -0.32678670f, -0.28412923f, -0.16993241f, 
    -0.24409388f, -0.05133686f, 0.08665413f, 0.09205154f, -0.00801105f, 0.06375153f, -0.00056870f, 0.00182843f, 
    -0.00481217f, 0.02447769f, -0.14261624f, -0.00243524f, 0.08744500f, 0.04470340f, -0.03814801f, 0.11692742f, 
    -0.17530505f, -0.21512404f, -0.24536753f, -0.04532026f, 0.03686240f, 0.00833303f, 0.10094133f, 0.07740781f, 
    0.09103583f, 0.06042796f, -0.09594471f, -0.00083324f, 0.00724552f, -0.00442365f, 0.00458949f, -0.00816188f, 
    0.08878120f, 0.00725179f, 0.06290182f, 0.11141250f, 0.37195182f, 0.26062962f, 0.17997502f, -0.20577259f, 
    0.21933043f, 0.14548218f, 0.21117632f, 0.16568035f, 0.20921880f, 0.08774450f, 0.00565203f, -0.03966999f, 
    -0.13654679f, -0.11625719f, -0.02976865f, -0.02924891f, -0.04480871f, -0.06315326f, 0.02953090f, -0.10454189f, 
    -0.04546385f, 0.02680498f, -0.02924990f, -0.01525789f, -0.13772343f, -0.12329841f, -0.11961509f, -0.08558340f, 
    -0.04308847f, -0.13053118f, -0.09229827f, -0.04162530f, 0.04966031f, 0.05861124f, -0.00255992f, -0.14822754f, 
    -0.03570497f, 0.08316268f, 0.15936986f, -0.00246201f, 0.28102171f, 0.06234365f, 0.38051471f, 0.03065231f, 
    -0.24033107f, -0.10939343f, -0.16431180f, -0.21659751f, -0.05319728f, -0.10825045f, -0.12171160f, 0.03418232f, 
    0.01931275f, -0.04657982f, -0.07711253f, 0.01513692f, -0.07164769f, 0.01738031f, 0.03815337f, -0.04923195f, 
    0.10980061f, -0.12017746f, 0.08862480f, 0.20973678f, 0.03957375f, -0.03738096f, 0.03388558f, -0.08961119f, 
    -0.02841664f, -0.13763967f, 0.14913763f, -0.01352528f, 0.03329460f, 0.02164997f, 0.02942756f, 0.06021251f, 
    -0.07524094f, 0.04876249f, 0.15543325f, 0.04206286f, 0.21838601f, 0.28408417f, 0.15819648f, -0.12789215f, 
    -0.08660821f, 0.14358775f, 0.01872141f, -0.00048936f, 0.00858925f, 0.02609503f, 0.01727971f, -0.07627960f, 
    -0.06293179f, -0.11460300f, -0.04502563f, -0.00250538f, -0.13809797f, -0.17775735f, -0.09650888f, -0.33806887f, 
    0.00318397f, -0.18504868f, 0.15522955f, -0.00497705f, -0.16185710f, -0.09425215f, -0.03486425f, 0.16749716f, 
    0.06720393f, -0.01866821f, -0.07195859f, 0.11158819f, -0.00463058f, 0.05504007f, -0.05241570f, -0.04991422f, 
    0.12091111f, 0.28114709f, 0.03965387f, 0.14447986f, 0.16794139f, -0.37444878f, 0.15508959f, -0.28347710f, 
    -0.09984960f, 0.10198245f, 0.19405150f, 0.06998794f, 0.03098233f, 0.11369309f, 0.03242950f, -0.11265978f, 
    -0.00270529f, -0.02453866f, -0.05402160f, 0.10616463f, 0.05944178f, 0.09047474f, -0.02168718f, -0.01585180f, 
    0.11734166f, -0.17488211f, -0.09603325f, 0.00428714f, 0.17690080f, -0.04859905f, 0.09572956f, 0.00590503f, 
    0.04137904f, 0.12414587f, -0.15924172f, 0.04573276f, -0.00033026f, -0.03291690f, -0.05888168f, -0.11763602f, 
    -0.00045020f, -0.12597126f, -0.05255593f, 0.01192813f, 0.46424389f, 0.25153494f, -0.09956208f, 0.24031040f, 
    -0.09267552f, -0.11617226f, -0.12430786f, -0.03626296f, -0.03583761f, 0.00672456f, -0.13397054f, -0.04517918f, 
    -0.15300778f, 0.01130132f, -0.04966573f, 0.05057459f, -0.07821548f, -0.01752842f, 0.01215199f, 0.05322945f, 
    -0.13844083f, 0.27835938f, -0.05607712f, 0.05341809f, 0.12267846f, -0.11982922f, -0.03791643f, 0.08995429f, 
    0.09642436f, 0.12319035f, 0.04106368f, 0.05816626f, 0.07149794f, 0.04815247f, 0.01680449f, 0.03302340f, 
    -0.07023818f, -0.09516314f, 0.02287818f, 0.12977339f, 0.20419595f, -0.01486342f, -0.11068261f, 0.22062156f, 
    0.47383666f, 0.18137775f, -0.09738452f, 0.02251201f, -0.15274376f, -0.14098713f, -0.07272677f, 0.04599632f, 
    -0.16188776f, -0.03962914f, 0.18496247f, -0.01681435f, 0.01776186f, 0.00286143f, -0.22601257f, 0.00721834f, 
    -0.17746152f, -0.08443157f, 0.11268567f, -0.20014262f, 0.00399415f, 0.07135060f, 0.05004651f, 0.04010467f, 
    0.05285227f, -0.07826717f, -0.06564565f, 0.02596131f, 0.11122550f, -0.18819943f, -0.12106339f, -0.10470287f, 
    0.07304692f, 0.04928748f, -0.13065171f, -0.18587197f, 0.13816138f, 0.29234093f, 0.00718543f, 0.33524057f, 
    0.24837779f, -0.18652865f, 0.17439196f, 0.22290345f, 0.16361505f, 0.01633363f, 0.01499871f, 0.03236054f, 
    0.02556778f, 0.00882461f, -0.09170333f, -0.06233162f, -0.03833766f, 0.03121716f, -0.19227326f, -0.27880517f, 
    -0.74658978f, -0.42692778f, 0.13263322f, -0.02975508f, -0.32092661f, 0.00877075f, -0.07326186f, -0.21267848f, 
    -0.25675243f, -0.06709206f, -0.04004211f, 0.02242736f, 0.08319091f, 0.08574679f, 0.03603152f, -0.08365019f, 
    -0.11121389f, -0.09848322f, -0.01491730f, -0.04707161f, 0.19373660f, 0.18728586f, 0.03608596f, 0.07018132f, 
    0.07664256f, 0.04433385f, 0.14705779f, -0.00783910f, 0.22856230f, 0.14898628f, -0.02942551f, 0.06251904f, 
    0.11079112f, 0.08204281f, -0.02709882f, 0.03492885f, -0.03984032f, -0.15601830f, 0.05127819f, 0.12370326f, 
    0.15064691f, 0.17443870f, 0.40908417f, 0.23926279f, -0.00493558f, 0.13828838f, 0.02416639f, 0.11428466f, 
    -0.00956244f, 0.01897668f, 0.05296872f, 0.03589667f, -0.03047696f, -0.00939935f, 0.07728551f, 0.18253636f, 
    0.03466470f, 0.07458464f, -0.07102336f, 0.12563397f, 0.41465518f, 0.22490476f, 0.42016110f, 0.28930077f, 
    0.25229856f, 0.11511554f, 0.09312056f, 0.11882669f, 0.04589208f, -0.08064563f, -0.03286026f, -0.06396294f, 
    0.07322261f, -0.17468297f, 0.05409504f, 0.04241363f, 0.01242376f, -0.01506522f, -0.01200298f, 0.03460575f, 
    0.09911750f, 0.39599282f, 0.01753454f, 0.08314448f, 0.19452271f, 0.11039934f, -0.04222815f, 0.27053884f, 
    0.08669928f, 0.13352957f, -0.05037414f, 0.00592585f, 0.01839843f, 0.11290862f, -0.06573080f, -0.09718505f, 
    -0.13602358f, -0.01900579f, -0.06357154f, -0.07659352f, -0.04396532f, -0.00298280f, 0.05828400f, -0.00063679f, 
    0.14381142f, 0.06754939f, 0.10031015f, -0.03382336f, 0.07636322f, 0.05494495f, -0.06101717f, 0.03104612f, 
    -0.06267769f, -0.02179984f, 0.03408610f, -0.05574362f, -0.00443450f, 0.00767985f, 0.01469878f, 0.06497291f, 
    0.05099343f, 0.03253372f, 0.03117852f, 0.09965514f, 0.02448658f, 0.01446260f, 0.07107995f, 0.02196334f, 
    0.04466929f, -0.03408838f, 0.01035346f, 0.09724493f, 0.03929399f, 0.04424202f, 0.09707583f, -0.08247043f, 
    -0.12089331f, -0.07149521f, -0.00308419f, 0.01685482f, -0.19316331f, -0.09568681f, -0.07699513f, -0.22392663f, 
    -0.06057771f, -0.07132580f, 0.02722148f, -0.04769782f, -0.13097028f, 0.02497957f, -0.09744453f, 0.00621773f, 
    -0.07518643f, 0.10841567f, -0.08158989f, -0.10702340f, 0.08283158f, -0.01844322f, -0.05282732f, -0.11289352f, 
    -0.20906097f, -0.32066664f, -0.10858052f, -0.34263492f, -0.10506256f, 0.00700844f, -0.01277568f, -0.08732811f, 
    -0.07691929f, -0.03511002f, -0.11276206f, 0.09969054f, -0.01389513f, -0.02017229f, 0.00175531f, -0.03491629f, 
    0.09194356f, 0.00367569f, 0.06670438f, 0.00144259f, -0.25394443f, 0.01452545f, -0.03632962f, -0.12397663f, 
    -0.10452012f, -0.16257884f, -0.13902588f, -0.00563448f, 0.04272659f, -0.12070173f, -0.07617287f, 0.10570624f, 
    -0.06123596f, 0.03029201f, -0.04573448f, 0.02540364f, -0.06497715f, -0.06306389f, 0.08032337f, -0.11064903f, 
    0.06435222f, -0.26681548f, 0.08416204f, -0.06688485f, -0.15955369f, 0.03874895f, 0.02033683f, 0.05970029f, 
    0.04766110f, -0.00750792f, 0.06451653f, 0.12760831f, 0.08778378f, 0.06923576f, -0.04977351f, 0.13937032f, 
    -0.12978731f, 0.01803558f, 0.15351996f, 0.30371884f, -0.22179133f, -0.39993668f, -0.01688120f, -0.25164187f, 
    -0.11199240f, 0.03659476f, -0.05334090f, -0.09882052f, -0.07590698f, -0.16666335f, 0.00567522f, 0.09788054f, 
    0.05227458f, 0.03509104f, -0.06069531f, 0.00432789f, 0.01763462f, -0.14015399f, 0.05553265f, -0.07182889f, 
    -0.29421613f, 0.19052242f, -0.20029813f, -0.25773105f, 0.17045310f, -0.01728021f, -0.11113823f, -0.03120688f, 
    0.07708903f, 0.16845116f, 0.03392874f, -0.03206137f, 0.11323033f, 0.15153553f, -0.09392571f, -0.06436806f, 
    -0.13824052f, 0.09114815f, 0.05890328f, -0.22403143f, -0.14821781f, 0.12397087f, 0.24928230f, 0.17872229f, 
    -0.04415387f, 0.10522029f, 0.16191198f, -0.11741295f, 0.03411811f, 0.05334418f, -0.03147069f, 0.00330918f, 
    -0.05194388f, 0.06568644f, 0.10393063f, -0.06910132f, -0.06587169f, -0.12160978f, -0.00897070f, 0.05859158f, 
    -0.06186987f, 0.14305153f, 0.16716912f, -0.05563372f, 0.08883285f, 0.03582149f, 0.04838248f, 0.12361959f, 
    -0.02104035f, 0.12184697f, -0.02396162f, 0.02800932f, -0.00119399f, -0.10106822f, -0.06742177f, -0.09116127f, 
    -0.01481282f, 0.26748252f, 0.16635382f, 0.35033482f, 0.33873194f, 0.26224348f, 0.18915913f, 0.29751232f, 
    0.20569621f, -0.09974160f, 0.19822377f, 0.14135356f, 0.10844338f, -0.19401351f, 0.03482759f, 0.00982112f, 
    0.09765417f, -0.05153229f, -0.09079392f, -0.03709329f, 0.06118875f, -0.07728333f, 0.12170646f, -0.09264450f, 
    0.57659101f, -0.48252416f, 0.27664125f, -0.24487095f, 0.37894419f, 0.05315606f, -0.00751097f, 0.03741163f, 
    -0.00964324f, 0.04372019f, 0.04976016f, -0.04941905f, 0.06275629f, -0.01372555f, -0.00049943f, 0.17809984f, 
    -0.03581375f, -0.05651706f, 0.06421978f, 0.16964212f, 0.22088000f, -0.00559376f, 0.26913574f, 0.04645914f, 
    0.11717290f, 0.01582611f, 0.06632871f, 0.06982074f, 0.05101819f, -0.20545313f, 0.00149094f, -0.00974482f, 
    0.07058227f, -0.09006552f, 0.03284770f, -0.01692886f, 0.04170259f, -0.01716433f, 0.05179277f, -0.08448072f, 
    0.02900946f, 0.23140976f, 0.00884125f, 0.15926290f, 0.03270769f, 0.01108215f, 0.11445281f, 0.07991725f, 
    -0.00106209f, -0.01691160f, 0.10739935f, 0.05182172f, 0.13779955f, 0.06904559f, 0.07791100f, -0.00761126f, 
    -0.06605271f, -0.03240480f, 0.00436894f, 0.03230140f, -0.01331826f, 0.29792213f, -0.02110705f, -0.06567269f, 
    0.47663280f, -0.05300132f, 0.02770440f, -0.08655909f, 0.13100289f, 0.03535485f, 0.01517477f, -0.04221353f, 
    -0.00931261f, -0.00639777f, -0.03835858f, 0.11655910f, -0.00213869f, 0.05908437f, -0.12762833f, 0.13194439f, 
    -0.10913845f, -0.13171144f, -0.04697960f, -0.06199184f, -0.06374014f, -0.08902757f, 0.00111313f, 0.04745131f, 
    0.04850633f, 0.02815204f, -0.16925775f, -0.07972083f, -0.07193393f, -0.13919157f, -0.18296532f, -0.06699205f, 
    -0.09422398f, -0.06739083f, 0.02427432f, -0.03759195f, -0.38707176f, -0.63062227f, -0.10648975f, -0.26466978f, 
    0.10254156f, -0.08951131f, 0.06452753f, -0.07902977f, -0.01062148f, -0.00318916f, 0.08132514f, 0.02983882f, 
    0.05880836f, 0.05480726f, 0.04931730f, 0.00246398f, 0.08069999f, -0.00510731f, 0.10364205f, 0.03355030f, 
    0.12472300f, -0.02092300f, -0.00615241f, 0.07748235f, -0.07760856f, -0.02903524f, 0.02651267f, 0.01835483f, 
    0.01718897f, -0.11842036f, 0.03382390f, -0.21221964f, -0.00441791f, -0.04687672f, -0.08346769f, -0.01166273f, 
    0.08818486f, -0.00376756f, 0.00411854f, -0.13223457f, 0.03359179f, 0.11935978f, -0.04078789f, 0.09560200f, 
    0.08071827f, 0.13440037f, 0.12405100f, 0.02841937f, -0.00932488f, 0.10929517f, 0.00579171f, -0.01816176f, 
    0.01788960f, -0.05565818f, -0.03633458f, -0.04675219f, -0.03531734f, 0.25598010f, -0.02412079f, 0.25414291f, 
    0.03652028f, -0.02887005f, 0.09342802f, -0.11315194f, 0.07210956f, -0.12503478f, 0.14276728f, -0.01514934f, 
    0.15037149f, 0.02791465f, 0.06612615f, -0.01389554f, -0.07327200f, 0.04882945f, -0.04667365f, 0.00565006f, 
    -0.04953746f, -0.04628448f, 0.01481220f, -0.05670562f, -0.29320958f, 0.51437932f, 0.10423687f, -0.03296784f, 
    0.27602994f, -0.18896855f, 0.07037865f, 0.16411266f, 0.00862911f, -0.17091139f, -0.02860350f, 0.00656850f, 
    -0.15857624f, -0.03236544f, -0.06871259f, -0.01010529f, -0.08733162f, 0.12768395f, -0.11206271f, -0.11996784f, 
    0.12745129f, 0.35875812f, -0.38820919f, -0.10106405f, -0.02823769f, -0.00714750f, -0.01656007f, 0.16720852f, 
    -0.10843975f, 0.02514856f, -0.08209264f, 0.05715950f, -0.00459906f, -0.09386894f, -0.23021300f, 0.20785102f, 
    -0.15412779f, 0.10487410f, -0.13785720f, 0.15030876f, -0.91443855f, -0.39659479f, 0.08987362f, 0.06535003f, 
    0.07873410f, -0.09152735f, 0.01582179f, 0.13695979f, 0.03492807f, -0.14725642f, -0.10116162f, 0.00134665f, 
    -0.01729291f, 0.11207254f, 0.07911780f, -0.03043953f, -0.18485129f, 0.14788556f, 0.02031918f, -0.11011419f, 
    0.32253474f, 0.14546408f, 0.36260748f, -0.00810803f, -0.03142229f, 0.08495925f, 0.02311180f, 0.20930159f, 
    -0.00462188f, 0.10596926f, 0.01339987f, 0.13340531f, 0.01544349f, -0.05823461f, 0.05120590f, -0.02326813f, 
    -0.08686247f, -0.00758933f, 0.06228660f, -0.08796697f, 0.71401006f, -0.21131259f, 0.22100115f, -0.33153784f, 
    -0.06187270f, -0.21899751f, 0.20742039f, -0.06821026f, 0.24638169f, -0.06720683f, -0.15273088f, 0.10694182f, 
    -0.00643425f, 0.07010894f, -0.17894879f, 0.00028678f, 0.06466167f, 0.07782067f, 0.17919622f, 0.04238547f, 
    0.00256885f, 0.08709785f, -0.10014775f, -0.07144448f, -0.13202737f, 0.09455594f, -0.14925529f, -0.01483274f, 
    -0.15721677f, -0.11283804f, -0.01172560f, 0.03697004f, -0.12914532f, -0.05603791f, 0.24023432f, -0.15521306f, 
    -0.04287462f, -0.03457800f, 0.21287069f, 0.00646660f, 0.28101072f, 0.19478442f, 0.04938740f, -0.26370165f, 
    0.09156714f, 0.07939883f, 0.06992295f, -0.04068273f, -0.01398620f, 0.12159491f, 0.02364386f, 0.00842860f, 
    -0.12988615f, 0.13419174f, 0.05868953f, -0.01871873f, -0.03956565f, 0.11913733f, 0.09974677f, 0.00852103f, 
    -0.01007793f, 0.05080365f, 0.54766691f, 0.25649694f, 0.15396518f, -0.01205354f, 0.09598271f, -0.17362826f, 
    0.13712946f, 0.16729502f, -0.09158160f, 0.11768777f, 0.02715129f, -0.02284698f, -0.09618567f, 0.03888696f, 
    0.08790185f, 0.05614042f, 0.01025626f, 0.01403746f, 0.60861892f, 0.37132013f, -0.31299156f, 0.14248791f, 
    0.15390070f, 0.04406618f, 0.01265900f, 0.08696881f, -0.13624708f, 0.16158932f, 0.31351832f, 0.15921855f, 
    -0.15971012f, 0.00284198f, -0.08716646f, 0.02210262f, -0.37564400f, -0.08389053f, -0.34049326f, 0.08760830f, 
    0.14554100f, 0.05942130f, -0.13076386f, -0.10486177f, -0.13417132f, 0.09557707f, 0.00463513f, 0.02906496f, 
    -0.04391881f, 0.04360060f, -0.08919703f, -0.06479479f, 0.10634284f, 0.14536104f, 0.17262444f, 0.06114930f, 
    0.15297627f, 0.11430585f, 0.05785147f, 0.29224017f, -0.04932041f, -0.13512312f, -0.28074688f, 0.06640682f, 
    -0.17474855f, 0.00250112f, 0.06730989f, -0.01069044f, -0.07652745f, 0.01784044f, -0.09654820f, -0.10003304f, 
    -0.02142280f, 0.12569040f, 0.01527636f, -0.04254793f, 0.06657070f, 0.09559040f, 0.04221584f, 0.17101268f, 
    0.52370340f, 0.23355719f, -0.00632993f, 0.00745449f, 0.04140005f, 0.02958221f, -0.02414967f, 0.12504883f, 
    -0.12554690f, 0.06377702f, 0.06733556f, 0.08333167f, -0.17156938f, 0.00017673f, -0.09994381f, 0.00374943f, 
    -0.34383520f, -0.13240871f, -0.28837308f, -0.15656124f, 0.36882344f, 0.19901451f, 0.44749451f, 0.33604071f, 
    0.04492520f, 0.06755775f, 0.09425639f, -0.06316294f, 0.23814590f, 0.15002637f, 0.10005858f, -0.19368079f, 
    0.02366003f, -0.08153950f, -0.09362326f, 0.01261729f, 0.03608423f, -0.09002387f, 0.08558973f, 0.16306821f, 
    0.18802862f, -0.12668982f, -0.18058072f, 0.17960536f, 0.10302017f, 0.03668549f, -0.12609525f, 0.05500294f, 
    -0.02944609f, -0.12596796f, -0.01771357f, -0.02142838f, 0.08183291f, -0.09121555f, 0.04271644f, -0.07994222f, 
    -0.26435128f, -0.14796367f, -0.23388702f, -0.32073033f, -0.21183729f, -0.20783141f, 0.10083785f, 0.23677848f, 
    -0.23957370f, -0.09232398f, 0.04739757f, -0.13523123f, -0.04064601f, -0.50834197f, -0.03822310f, 0.06489109f, 
    -0.05574109f, -0.03804577f, -0.09972896f, -0.01079213f, -0.15373099f, 0.04179452f, -0.01886050f, -0.26217613f, 
    0.00596228f, 0.04006258f, -0.18374845f, 0.31061515f, -0.04578759f, -0.04824849f, 0.01458169f, -0.15655549f, 
    0.10756587f, 0.00199494f, -0.01120734f, 0.02032853f, 0.05864327f, -0.00703308f, 0.01591746f, 0.00962633f, 
    -0.12492863f, 0.13241205f, -0.18883793f, -0.11910728f, -0.06124700f, -0.09229653f, 0.28650722f, 0.00075273f, 
    -0.10182910f, -0.20757253f, 0.08081596f, 0.00020913f, -0.22222614f, -0.01924364f, -0.00646871f, -0.08464910f, 
    0.04140877f, 0.09159805f, -0.00659399f, 0.02498316f, 0.02849931f, -0.05381174f, -0.06866219f, -0.11038297f, 
    0.13726930f, -0.19200413f, -0.14844514f, -0.06899947f, -0.09522109f, -0.01962467f, -0.05042098f, 0.04777547f, 
    -0.01816930f, 0.00348339f, -0.07998849f, -0.05362719f, 0.01804690f, 0.15986469f, 0.22042528f, -0.07498401f, 
    0.19938922f, 0.18395349f, -0.00251743f, 0.23631242f, -0.06030314f, 0.03375181f, 0.41139245f, 0.08787919f, 
    -0.18508270f, 0.11935039f, -0.08306409f, -0.25079581f, 0.10669742f, -0.07423402f, 0.04087725f, 0.01742201f, 
    0.02401022f, 0.02114791f, -0.00171296f, -0.00383990f, 0.04980415f, 0.07617101f, 0.06052695f, -0.08371083f, 
    -0.22649688f, 0.23274000f, 0.52999932f, 0.00428026f, -0.26982710f, 0.05473749f, 0.05705067f, 0.12210275f, 
    -0.26238033f, -0.08067585f, 0.09915746f, -0.00042256f, -0.00473812f, -0.09021302f, -0.09035164f, 0.07451289f, 
    -0.03970485f, -0.19148649f, -0.23967423f, -0.19428772f, 0.32568586f, 0.32343554f, 0.22778682f, 0.08815036f, 
    0.17688976f, -0.04098143f, -0.02108528f, -0.09420735f, 0.10077040f, 0.13543820f, 0.04668442f, 0.02150186f, 
    -0.00788019f, -0.00872590f, -0.04031933f, -0.11344065f, -0.10416304f, -0.14366677f, 0.01081965f, 0.03074124f, 
    0.09674291f, 0.07401099f, 0.09468410f, -0.06742357f, -0.08637575f, 0.07128371f, 0.04102686f, 0.21953988f, 
    0.04715246f, 0.07052077f, -0.02332346f, -0.00350084f, 0.01083051f, 0.00961195f, -0.08667585f, 0.11065243f, 
    0.11366881f, 0.12184773f, 0.04129646f, 0.24502799f, 0.11097597f, -0.03608638f, 0.19136812f, 0.04666271f, 
    0.07481854f, -0.02831239f, 0.08814105f, 0.08336584f, -0.02313174f, 0.03654011f, -0.10801913f, -0.05609536f, 
    -0.07363422f, 0.08850507f, 0.28611034f, 0.14359142f, -0.06384470f, 0.28211319f, 0.07532591f, 0.10027496f, 
    -0.05886526f, 0.00449291f, -0.26453772f, 0.16577089f, 0.08878489f, -0.02376432f, -0.02634296f, 0.26386711f, 
    0.01998938f, -0.01499468f, 0.00610122f, -0.01208454f, 0.07477207f, 0.06846240f, 0.10931175f, -0.11050163f, 
    0.20600604f, 0.15153451f, 0.27460164f, 0.34328616f, 0.39737898f, -0.00789838f, -0.26528221f, 0.18631293f, 
    -0.03047957f, 0.12668629f, -0.13563059f, 0.00453189f, -0.08019226f, -0.11323683f, -0.14655004f, -0.11014050f, 
    0.03661346f, -0.06136196f, -0.10094875f, -0.04187346f, -0.09734716f, 0.07583285f, -0.07662265f, 0.10557275f, 
    0.30505982f, -0.14034595f, -0.09192906f, 0.11939716f, 0.19149287f, 0.04483610f, -0.12378861f, 0.12061945f, 
    -0.02968383f, 0.10415710f, 0.13994575f, 0.11071122f, -0.04482623f, -0.11799929f, -0.00813743f, -0.08151507f, 
    -0.23580237f, -0.14742827f, -0.21505138f, -0.20912950f, 0.59804577f, 0.08295438f, 0.34600314f, -0.11372353f, 
    -0.07569585f, 0.15597968f, 0.28652966f, 0.01099644f, 0.08973179f, 0.17626084f, 0.22087036f, 0.00253099f, 
    0.04212989f, 0.02780706f, -0.10780705f, -0.05974473f, -0.01872511f, 0.02643673f, 0.02156701f, 0.08540233f, 
    -0.15071529f, 0.29422581f, -0.12298090f, 0.00714095f, 0.19879468f, -0.08713764f, 0.01014104f, 0.20269829f, 
    0.15677410f, 0.00736281f, -0.03340262f, -0.02415477f, 0.07391768f, 0.21267943f, -0.03294532f, 0.02611537f, 
    -0.10744252f, -0.09689704f, -0.46755773f, -0.27444977f, 0.03071762f, 0.13530008f, 0.58545351f, 0.24925536f, 
    -0.06155640f, 0.02540893f, -0.09646624f, -0.17383721f, 0.07760662f, 0.01889967f, -0.00107419f, -0.08700075f, 
    -0.05435772f, -0.05699801f, -0.11254165f, 0.19088601f, 0.14150019f, 0.16556023f, 0.13232924f, 0.21597618f, 
    -0.30413431f, -0.16668409f, -0.17555225f, -0.15880889f, -0.31804311f, 0.10157612f, 0.00753484f, -0.12185872f, 
    0.03029152f, -0.12232859f, -0.09860099f, 0.00514275f, -0.00296649f, -0.00478902f, 0.18818115f, -0.14180501f, 
    0.01324693f, 0.04878743f, -0.07598796f, -0.13740259f, 0.16448668f, 0.06253617f, 0.22860274f, -0.12556852f, 
    0.11751270f, 0.09516122f, 0.13888265f, 0.22059768f, 0.12533578f, 0.26905921f, 0.02737092f, -0.09724097f, 
    0.11521705f, -0.06276277f, -0.06495838f, 0.10648838f, 0.11843318f, 0.03259100f, 0.06473848f, 0.21328318f, 
    -0.05858150f, 0.22499315f, 0.08005312f, 0.19285543f, -0.20707630f, 0.09789645f, 0.01807142f, 0.01325042f, 
    -0.07358648f, -0.18177208f, 0.04787574f, -0.02962915f, -0.04403928f, 0.03682762f, -0.05600605f, 0.03750052f, 
    -0.14211707f, -0.21999745f, -0.29298490f, -0.00974340f, 0.63496292f, -0.40462375f, 0.50414640f, -0.26511869f, 
    0.11883762f, 0.33590949f, 0.15741648f, -0.02976247f, 0.02959257f, -0.42661086f, 0.17256808f, -0.09010781f, 
    0.01304672f, 0.00717482f, -0.03234050f, -0.01396135f, 0.00511921f, 0.02340386f, -0.10562287f, -0.25684866f, 
    -0.07481465f, 0.04816056f, -0.20991804f, -0.04933422f, 0.02905648f, 0.07063805f, -0.08599363f, -0.04317984f, 
    -0.16594228f, -0.09914138f, -0.15808512f, -0.10321592f, 0.10351237f, 0.09307678f, 0.19180568f, -0.05734098f, 
    -0.07439987f, -0.17746267f, 0.04075095f, 0.01397677f, 0.35720706f, -0.01505930f, -0.31486019f, -0.14123653f, 
    -0.09369978f, -0.05352367f, -0.00339212f, -0.18215688f, -0.08084700f, -0.19545858f, -0.03711490f, -0.07636584f, 
    0.00620170f, 0.01685206f, -0.03644058f, 0.09382459f, -0.04255605f, 0.04994299f, -0.01280556f, 0.01689793f, 
    0.07928163f, 0.42903805f, 0.31983197f, 0.35090655f, 0.30891481f, -0.01303526f, 0.00529661f, 0.05277480f, 
    0.12540320f, 0.32349044f, 0.00148498f, -0.01215276f, 0.00940800f, 0.05255716f, -0.02227259f, 0.02027708f, 
    -0.05014089f, -0.10320246f, -0.15021209f, 0.01273535f, 0.32404286f, 0.00752015f, 0.18816511f, 0.37161812f, 
    0.14420108f, 0.43105164f, -0.03010160f, -0.00766667f, -0.00522560f, -0.19070770f, -0.13525258f, -0.08247527f, 
    -0.01950818f, 0.03773165f, 0.06845442f, 0.14743365f, 0.00713045f, -0.03124729f, 0.03467582f, 0.02718838f, 
    -0.28007880f, -0.12541661f, 0.18078206f, -0.25131246f, -0.23227167f, 0.05271363f, 0.03290194f, 0.04713548f, 
    -0.05130332f, -0.03171247f, -0.11828364f, -0.02791297f, 0.01127915f, -0.12875973f, -0.02897230f, -0.01318504f, 
    0.07851407f, -0.04406172f, -0.10446578f, -0.11376382f, -0.27212963f, 0.25802425f, 0.14212346f, 0.35412130f, 
    0.26405647f, -0.26029482f, 0.08599140f, 0.12788261f, 0.12973648f, -0.06354094f, 0.04250641f, 0.03935429f, 
    -0.07665869f, -0.01108020f, -0.01741018f, -0.01746261f, -0.02302666f, 0.02361687f, -0.25033227f, -0.03805717f, 
    -0.63075405f, -0.26881295f, 0.14857668f, 0.09036871f, 0.27216566f, -0.07601034f, 0.14859086f, -0.12806153f, 
    -0.29473874f, -0.02734048f, 0.05320816f, 0.02598733f, 0.16545984f, -0.00346912f, 0.03077701f, -0.07768167f, 
    0.01949444f, -0.12677176f, -0.05039872f, 0.01665928f, 0.09844717f, 0.37554353f, 0.03931509f, 0.05687597f, 
    0.08763007f, 0.22698191f, 0.12055922f, 0.19094190f, 0.14250945f, 0.31964085f, -0.12917443f, 0.05929268f, 
    -0.01524931f, 0.06632780f, 0.02368777f, 0.12144208f, 0.01108609f, -0.01094309f, 0.06167953f, 0.05360931f, 
    0.14240484f, 0.42404234f, 0.43274060f, 0.30140570f, 0.00760008f, 0.15648741f, 0.01533867f, 0.06968983f, 
    -0.00755156f, 0.01528555f, -0.03237016f, -0.02249026f, -0.04747875f, -0.04304272f, 0.12557746f, 0.10888538f, 
    -0.08209752f, 0.00475430f, -0.04191400f, 0.11186076f, 0.24553092f, 0.41320074f, 0.29330689f, 0.33592680f, 
    0.24153283f, 0.17000048f, 0.17108905f, 0.18302962f, 0.02410599f, -0.02121515f, 0.02447546f, 0.04309811f, 
    0.12596032f, -0.08537287f, 0.12059132f, 0.06607641f, -0.00299904f, -0.00174202f, -0.06197916f, -0.05299026f, 
    0.08012166f, 0.40589955f, -0.02730405f, 0.08172395f, 0.16689211f, 0.21298280f, 0.01735640f, 0.20991367f, 
    0.21669509f, 0.08386914f, -0.14754896f, 0.05928840f, -0.06605341f, 0.09766149f, 0.09789388f, 0.03413664f, 
    -0.08451670f, 0.10390881f, -0.17522457f, -0.09706086f, 0.21709368f, 0.12647954f, 0.14034618f, 0.23846470f, 
    0.07397078f, 0.03864604f, 0.07116835f, 0.06113968f, 0.03123278f, 0.14912362f, 0.01810370f, 0.01414368f, 
    -0.14784965f, 0.09695072f, 0.08300389f, -0.07972873f, 0.00165664f, -0.02452298f, -0.02553594f, -0.09309226f, 
    -0.08317751f, -0.19367643f, -0.06912068f, 0.03787630f, -0.01656781f, 0.11304680f, 0.04277408f, 0.02622785f, 
    -0.08373600f, 0.05097868f, 0.18439367f, 0.10591849f, 0.08675644f, -0.02760727f, 0.02308033f, 0.06684367f, 
    0.02975182f, -0.01482906f, -0.01328376f, 0.10018757f, -0.11155666f, -0.31538367f, -0.24964008f, -0.27648097f, 
    -0.12233050f, -0.01139004f, -0.04142322f, -0.04679363f, -0.03481433f, -0.00520336f, 0.05023937f, 0.03088235f, 
    -0.02925058f, 0.04762610f, -0.00579101f, 0.02065615f, 0.17015816f, 0.10086408f, -0.04478570f, 0.04321598f, 
    -0.26606935f, -0.34327203f, -0.35996062f, -0.33692461f, -0.21796633f, -0.05580568f, -0.06684922f, -0.09045791f, 
    -0.07880111f, -0.10510811f, 0.07151441f, 0.06979656f, 0.09602924f, -0.01680063f, 0.01350096f, 0.10926857f, 
    0.10227530f, 0.02553386f, 0.03633927f, 0.05070368f, -0.26416311f, 0.10684177f, -0.28399637f, -0.21484299f, 
    -0.12703866f, -0.05892765f, -0.10017294f, 0.03462033f, 0.03540933f, -0.23969081f, -0.02939839f, 0.01278697f, 
    -0.11419817f, -0.02759056f, -0.03105900f, 0.26348206f, 0.23344485f, 0.04593439f, 0.10264450f, -0.03105952f, 
    0.00255730f, -0.11953968f, -0.21721381f, -0.15767211f, -0.36691436f, 0.04076510f, -0.11895856f, -0.01048613f, 
    -0.00144276f, -0.02066714f, 0.13070713f, 0.02080473f, -0.07938947f, -0.05729107f, -0.06366444f, 0.12747146f, 
    -0.00345452f, 0.02840395f, 0.13392462f, 0.14345732f, -0.13031219f, -0.31552240f, -0.24560429f, -0.27516913f, 
    -0.02450828f, -0.06301243f, -0.01438212f, -0.06205425f, -0.08354703f, -0.00730869f, 0.07474244f, -0.02055120f, 
    0.09006947f, -0.09530007f, 0.00569134f, 0.00160757f, 0.07053121f, -0.04113001f, 0.08255117f, 0.02576089f, 
    -0.23164985f, 0.21914734f, -0.26428476f, -0.09881459f, 0.01567359f, 0.00051000f, -0.03132455f, -0.09073165f, 
    0.05801521f, 0.02701577f, -0.10415857f, -0.06832154f, -0.01724208f, 0.11341492f, 0.12954441f, 0.15219231f, 
    -0.02463824f, 0.18752044f, 0.00977876f, 0.07270034f, -0.02952409f, 0.37409574f, 0.55493778f, 0.44517034f, 
    0.23506938f, 0.11428679f, 0.17617908f, 0.04971970f, -0.04030868f, 0.20158440f, -0.03384687f, -0.06893731f, 
    -0.15414497f, 0.12870716f, 0.03716841f, -0.10309792f, -0.06503491f, -0.14797193f, -0.10568029f, -0.04259043f, 
    -0.19253501f, 0.11406289f, 0.21747983f, 0.21733394f, 0.17151420f, 0.02411995f, 0.08732997f, 0.00800097f, 
    0.04076341f, 0.18821231f, 0.04252772f, 0.06085858f, 0.00907602f, -0.04576771f, -0.02513530f, -0.00163908f, 
    0.11926731f, 0.07842252f, -0.19684395f, 0.01834028f, 0.03758593f, 0.31598556f, 0.33623543f, 0.23452443f, 
    0.35567269f, -0.09233475f, 0.19597729f, -0.05976060f, 0.08243327f, -0.17150815f, 0.06346785f, -0.00515222f, 
    0.00276543f, -0.05457310f, -0.00980306f, 0.10501690f, 0.07127329f, -0.13699380f, 0.05943264f, -0.04542650f, 
    0.21250743f, 0.06717177f, 0.20280331f, -0.03880515f, -0.10136794f, 0.17082347f, -0.14712949f, -0.04350606f, 
    -0.14296074f, -0.02585325f, 0.08797128f, -0.08443772f, 0.05007074f, -0.17838299f, -0.05198063f, 0.23554693f, 
    0.01735945f, -0.07235330f, -0.07005383f, 0.08163612f, 0.19428737f, -0.13431393f, 0.05960887f, 0.05143752f, 
    0.09047528f, 0.09470208f, 0.05709166f, 0.00651875f, 0.02245118f, -0.01880187f, 0.03646920f, 0.12292535f, 
    0.01555133f, -0.03938252f, 0.02344792f, 0.08078279f, -0.02377126f, 0.03695579f, 0.07763647f, -0.03428129f, 
    0.06078720f, 0.09945931f, -0.00018355f, 0.13777494f, 0.10840126f, 0.15536088f, 0.16114052f, 0.12360372f, 
    0.07452876f, 0.22873800f, 0.09803922f, 0.06234779f, 0.09350379f, 0.06587202f, 0.02537583f, 0.12035064f, 
    0.03218191f, -0.00204801f, 0.04840551f, 0.09102034f, -0.27779672f, 0.19724496f, 0.06634111f, 0.26404577f, 
    0.28570017f, -0.15715933f, -0.09239175f, -0.18849505f, -0.04308877f, -0.02698192f, -0.03265056f, 0.02616932f, 
    -0.05899725f, 0.03203019f, 0.12740289f, 0.08977684f, 0.08724715f, 0.05573530f, -0.12630175f, 0.02212917f, 
    -0.23275909f, -0.36885697f, -0.28954762f, -0.28115392f, -0.16628283f, -0.00161450f, -0.05957412f, -0.05385798f, 
    -0.08198489f, -0.05808852f, 0.06730681f, 0.18643650f, 0.03531668f, -0.01363011f, 0.05714279f, 0.17415811f, 
    0.14399436f, 0.06264839f, 0.05435758f, -0.01258591f, -0.33470908f, -0.48754209f, -0.20245378f, 0.07251633f, 
    -0.05786284f, -0.14621259f, -0.07352597f, -0.19402514f, 0.07690450f, 0.01585840f, 0.04307536f, 0.00567367f, 
    -0.02345974f, -0.07146993f, -0.06608139f, -0.06622746f, 0.04611323f, 0.02690396f, 0.05526279f, 0.00686560f, 
    0.07574844f, -0.11188450f, -0.11989856f, -0.20036790f, -0.29345945f, 0.05138319f, -0.02877488f, -0.05608663f, 
    -0.06651987f, -0.05218592f, -0.00515480f, -0.15644203f, -0.01026321f, -0.04062148f, -0.01179601f, 0.04743630f, 
    0.08080488f, -0.00814732f, -0.03691998f, 0.05413857f, -0.07379525f, -0.00136426f, 0.11324197f, 0.29145604f, 
    0.28782785f, 0.04934606f, 0.14928485f, 0.03451817f, 0.03969583f, 0.18497230f, 0.00154978f, 0.05177164f, 
    0.04299542f, -0.02337540f, 0.01398145f, -0.00219579f, 0.08214687f, 0.12323356f, -0.14558168f, 0.04936277f, 
    -0.09125653f, 0.02123590f, -0.04735107f, -0.14438514f, -0.23222588f, -0.01779545f, -0.19168647f, -0.06418594f, 
    0.04101514f, 0.03762357f, 0.05499068f, -0.05875226f, -0.03184647f, 0.04260691f, 0.10725094f, 0.04356670f, 
    -0.01921257f, -0.02629562f, 0.11328889f, -0.01443639f, -0.35862905f, 0.26903668f, -0.07255035f, 0.02962585f, 
    0.24340843f, -0.00146097f, -0.00452402f, 0.02311171f, -0.01229929f, -0.13826342f, 0.10968538f, 0.13466015f, 
    -0.15119559f, -0.06100453f, 0.07717231f, 0.10037195f, 0.02495952f, 0.06646380f, -0.19926688f, 0.04454141f, 
    0.20366952f, 0.48534027f, 0.03712640f, -0.38685560f, 0.28519621f, 0.01277637f, 0.09930336f, 0.01938552f, 
    0.01268199f, 0.09039389f, -0.08182930f, 0.00377521f, -0.04064466f, 0.04438901f, 0.03168410f, 0.10555185f, 
    0.08361191f, 0.00354547f, 0.07560462f, 0.14836147f, -0.87843472f, 0.16898739f, 0.12074567f, -0.02506048f, 
    0.03508602f, -0.03229896f, 0.11246137f, -0.03889963f, 0.02706522f, -0.01233262f, -0.07469115f, 0.09847611f, 
    0.15047489f, 0.19399439f, -0.04069504f, 0.00282463f, -0.04285116f, 0.17275174f, 0.12938818f, -0.18603605f, 
    -0.08854625f, -0.24659663f, -0.37488103f, 0.16823049f, -0.05993341f, 0.08950665f, -0.00535718f, 0.03159010f, 
    0.05859719f, -0.05299115f, -0.03405414f, -0.07351768f, 0.06507980f, -0.00281679f, 0.02036702f, 0.04211019f, 
    0.03103651f, 0.12972462f, -0.05030683f, 0.06323262f, 0.43743154f, 0.30821440f, 0.60016948f, 0.04426035f, 
    0.38053989f, 0.27064726f, 0.26936793f, -0.07007740f, 0.15853298f, 0.11808418f, -0.12691346f, 0.06342255f, 
    0.09089275f, 0.13927206f, -0.13220206f, -0.05754304f, -0.10720588f, 0.05781231f, 0.34297821f, 0.15300219f, 
    0.02371550f, 0.39654568f, -0.00029717f, -0.00573537f, -0.06907480f, 0.17266838f, -0.02366523f, -0.01090761f, 
    -0.03850414f, 0.03973940f, -0.09513935f, 0.03882299f, 0.11488174f, -0.12100378f, 0.22008696f, 0.23450771f, 
    0.02295062f, -0.06501121f, 0.05971666f, 0.09425790f, -0.19909632f, -0.06549037f, -0.00025739f, 0.07204314f, 
    0.05801927f, 0.21747978f, -0.18269002f, -0.13771060f, 0.05437104f, -0.01006457f, -0.02238565f, -0.05388143f, 
    -0.08365110f, -0.00866228f, 0.00402195f, 0.05531675f, 0.04194596f, -0.02708676f, -0.06904641f, 0.06705247f, 
    0.04116309f, -0.01502019f, 0.70670569f, 0.27092421f, 0.35079852f, -0.04968854f, 0.16591492f, -0.21390492f, 
    0.20031640f, -0.06289054f, -0.06498590f, 0.05237369f, -0.01777645f, -0.05082772f, 0.01382643f, -0.05367466f, 
    0.05564274f, -0.01210656f, -0.01080152f, 0.04277991f, 0.00753871f, -0.26340738f, -0.43186793f, 0.10197660f, 
    0.10266163f, 0.02028686f, 0.07560914f, -0.06258798f, 0.01810476f, -0.10093476f, 0.08199364f, -0.08353295f, 
    -0.11328746f, -0.08747377f, -0.13957158f, 0.06805706f, -0.04117854f, -0.03254434f, 0.09395749f, 0.01229457f, 
    0.28704807f, 0.13280042f, 0.04832622f, -0.01787669f, 0.17875664f, 0.16514440f, 0.11300064f, 0.13692883f, 
    0.03435599f, -0.04841765f, -0.05276664f, 0.01858427f, 0.04706418f, 0.13301529f, 0.13642727f, -0.09782393f, 
    -0.00051683f, -0.03667197f, -0.00202276f, 0.00579042f, -0.48355630f, 0.11974573f, 0.12246709f, -0.02171356f, 
    0.14745660f, 0.16255994f, 0.05365094f, 0.07832837f, 0.04817018f, 0.03365519f, -0.10846341f, -0.01160392f, 
    0.12971799f, 0.10783353f, 0.06276886f, -0.02758075f, -0.03452053f, -0.05929441f, -0.05863623f, 0.06637728f, 
    0.11630683f, -0.20949948f, -0.33058485f, 0.01929641f, 0.01695512f, 0.05086971f, -0.01364603f, -0.25152242f, 
    0.07113209f, -0.04239608f, -0.06122194f, -0.03927158f, -0.13866641f, -0.06376459f, -0.08209822f, 0.06169247f, 
    -0.01614403f, -0.06261929f, 0.01201413f, 0.13034022f, 0.15876305f, -0.35198042f, -0.14055149f, -0.21680035f, 
    0.22978139f, -0.06007342f, -0.03940615f, -0.08208688f, 0.07960416f, -0.04928758f, 0.03209428f, -0.03326010f, 
    0.00260465f, -0.09270824f, -0.03293861f, -0.00645894f, -0.13973592f, -0.05475969f, 0.24008769f, 0.14086483f, 
    -0.18160559f, -0.18455853f, -0.18551421f, 0.01041181f, 0.06310757f, -0.07199986f, -0.01961882f, -0.05912976f, 
    -0.02307799f, -0.00362852f, -0.04729663f, 0.01793721f, 0.06153137f, -0.01374200f, -0.00943224f, 0.05325080f, 
    -0.05643699f, 0.04182409f, -0.04842090f, -0.05291900f, 0.01184879f, 0.16851117f, -0.00426416f, 0.13667619f, 
    -0.15793848f, -0.12725709f, 0.05855612f, -0.06227057f, 0.04188989f, -0.02495386f, 0.02413733f, 0.10092743f, 
    -0.00138367f, -0.10880126f, 0.23405224f, 0.11492927f, -0.04142867f, 0.17025945f, 0.03085418f, 0.10449722f, 
    -0.10500160f, -0.00258449f, 0.22601351f, 0.01069216f, -0.07950384f, -0.21887568f, -0.01823910f, -0.24632019f, 
    0.00427881f, -0.06849309f, -0.06647822f, -0.04968194f, -0.08277415f, 0.09069912f, 0.02915518f, 0.04443689f, 
    -0.02383256f, 0.07414878f, -0.07817605f, -0.10537081f, -0.31466827f, 0.22685875f, 0.10972034f, 0.03438502f, 
    -0.04570882f, -0.13929750f, 0.21966346f, 0.16842970f, -0.10922009f, -0.02109404f, 0.12276512f, 0.08743065f, 
    0.23729880f, 0.24242938f, -0.08250420f, 0.02791655f, 0.18624061f, 0.21954708f, 0.06275647f, -0.19302000f, 
    0.13815852f, -0.08849359f, 0.03667678f, -0.08375135f, -0.25463423f, 0.04823447f, -0.02579985f, 0.04997346f, 
    -0.04651895f, -0.03542604f, -0.12053899f, -0.14395261f, -0.03971723f, 0.07426016f, 0.07047451f, -0.03541674f, 
    -0.04996324f, 0.08263653f, -0.07001841f, -0.13277481f, 0.20098485f, 0.03347319f, 0.26117006f, -0.00615322f, 
    -0.02346371f, -0.04189231f, -0.07815417f, -0.05602826f, 0.02149103f, 0.02366610f, 0.02263925f, 0.08916517f, 
    0.00197957f, -0.01872446f, 0.04651469f, -0.11457926f, 0.04017490f, -0.06253675f, 0.04152879f, 0.09936071f, 
    0.29758036f, -0.16151422f, 0.36446565f, 0.02091155f, -0.21681130f, 0.17979839f, -0.10010073f, -0.10049518f, 
    -0.09671906f, -0.14552429f, 0.17940448f, 0.05801795f, 0.16835849f, -0.11701255f, 0.05208555f, -0.00702455f, 
    0.16654910f, 0.13550448f, -0.08304265f, -0.11756834f, 0.15771051f, -0.28465876f, -0.13138166f, -0.04809367f, 
    0.22213867f, 0.01048923f, -0.01936209f, -0.13589588f, 0.04580112f, -0.13253079f, -0.02504308f, -0.02558137f, 
    -0.00291410f, 0.02715424f, -0.02381435f, 0.05050110f, -0.04968777f, -0.05969893f, 0.13652973f, 0.23748069f, 
    -0.02420706f, -0.17241317f, -0.24788792f, 0.18614832f, -0.06492618f, -0.05423309f, -0.02876971f, 0.09644038f, 
    0.02963131f, 0.01035870f, -0.03622810f, -0.06555906f, -0.03691553f, -0.06127422f, -0.02303707f, 0.03902666f, 
    0.06067409f, 0.09330673f, -0.00956473f, -0.20626479f, -0.26805639f, -0.05432126f, -0.03976150f, 0.12452098f, 
    0.11955756f, 0.20845850f, -0.05418226f, 0.16655973f, 0.12718654f, -0.01072660f, -0.08655616f, 0.08964501f, 
    -0.11938964f, 0.03652066f, 0.02205136f, 0.11819418f, -0.11462402f, 0.15714699f, 0.21249136f, 0.00283448f, 
    0.35209176f, 0.78353757f, -0.20713983f, 0.01062905f, 0.12517083f, 0.10158308f, 0.11887321f, -0.07610993f, 
    -0.05720853f, -0.00471224f, -0.03951767f, -0.00516718f, 0.08622120f, 0.06402020f, 0.21312681f, -0.04474386f, 
    0.07312121f, -0.02169689f, 0.10406389f, -0.00571767f, 0.09239615f, -0.00211471f, -0.01922026f, 0.06040348f, 
    0.14106908f, 0.10783761f, 0.03479194f, 0.01482956f, 0.01865652f, 0.11164363f, -0.01820608f, 0.09417625f, 
    0.11888002f, 0.07188902f, 0.00828165f, 0.02288417f, -0.00725649f, -0.01864587f, -0.02585167f, 0.06091566f, 
    -0.20017323f, -0.30108136f, -0.28752276f, 0.10826249f, 0.05773200f, -0.02663988f, 0.00926652f, 0.08669008f, 
    0.07167223f, 0.01259163f, -0.07566478f, -0.06743708f, -0.01549782f, -0.09367107f, -0.06503431f, 0.01243548f, 
    -0.04135850f, 0.06142251f, -0.02772385f, -0.01909751f, -0.08591358f, -0.22992136f, -0.25035724f, -0.03287435f, 
    -0.07448407f, 0.00520008f, 0.02783090f, -0.11226819f, 0.15942737f, -0.04049608f, 0.01684550f, -0.05668061f, 
    -0.00891951f, -0.04409509f, -0.15993272f, -0.11570629f, -0.01930088f, 0.07884420f, -0.19618149f, 0.00680534f, 
    -0.33039165f, -0.03301120f, -0.17817041f, -0.09768705f, -0.17678161f, -0.15948173f, -0.07789678f, -0.10621388f, 
    -0.01322095f, -0.09160477f, -0.16721548f, -0.05331727f, -0.12716100f, -0.03296078f, -0.04308954f, 0.01030476f, 
    0.02288128f, -0.04099112f, 0.02243760f, -0.16252576f, -0.11210749f, -0.36367700f, 0.69770586f, -0.03200574f, 
    -0.22626619f, -0.06420625f, -0.14183949f, -0.09022526f, -0.01022220f, -0.00529755f, -0.05354290f, 0.00685100f, 
    -0.02406284f, -0.00255090f, -0.04231773f, -0.19783036f, -0.10492945f, 0.18743430f, -0.01887076f, -0.02022871f, 
    -0.14417307f, 0.18972062f, -0.19700097f, -0.01142806f, -0.04152384f, 0.06203743f, 0.07594391f, 0.03327302f, 
    -0.04363599f, 0.02564207f, -0.05104399f, 0.00523072f, 0.11040063f, -0.15642771f, 0.14722170f, 0.09068799f, 
    -0.07629498f, -0.06674353f, -0.01238034f, 0.02165123f, -0.02076767f, -0.19307826f, -0.11723155f, -0.06437490f, 
    -0.05528601f, -0.03517086f, -0.16359600f, 0.09056938f, -0.00131025f, -0.06621827f, 0.00723224f, -0.01781263f, 
    0.03704314f, -0.03194474f, 0.00070861f, 0.09715660f, 0.00705379f, -0.02149671f, -0.14844604f, -0.12097929f, 
    0.46597838f, 0.04413180f, -0.24236852f, -0.18948083f, 0.00732560f, 0.20474434f, -0.01880364f, 0.02556975f, 
    -0.08692068f, 0.06403358f, -0.05428472f, 0.00196013f, -0.00060186f, -0.05989323f, -0.05739839f, 0.00872672f, 
    0.14876202f, 0.04144367f, 0.02114620f, 0.24964182f, 0.25039455f, -0.10444442f, -0.25309926f, -0.21137837f, 
    0.16107385f, 0.30033538f, 0.08923963f, -0.07545713f, 0.07174987f, -0.09352061f, 0.07389519f, -0.01522364f, 
    0.13776615f, 0.00906656f, 0.09769206f, 0.00909705f, 0.06962876f, 0.16508968f, -0.20540589f, -0.05146005f, 
    -0.00545757f, -0.20019746f, 0.11948624f, 0.20637512f, -0.01606802f, -0.10370689f, 0.07344373f, 0.11651325f, 
    0.06050834f, 0.08384815f, 0.06478049f, 0.09163918f, 0.04768527f, 0.16199328f, 0.03328132f, -0.19097365f, 
    0.09399599f, 0.02091707f, 0.01941141f, 0.01449932f, 0.29109234f, 0.01965214f, -0.28610036f, 0.36309445f, 
    -0.12786831f, -0.03701023f, 0.09084064f, 0.07037849f, 0.06850731f, -0.00317633f, 0.11591262f, 0.04805367f, 
    0.00983487f, 0.05761819f, 0.04089779f, -0.07931442f, -0.03173378f, -0.00172266f, -0.06414463f, 0.02425561f, 
    0.15126897f, 0.10352195f, -0.17204490f, -0.06191855f, 0.16262531f, -0.14971471f, -0.04874730f, -0.13856947f, 
    -0.01752536f, -0.10306110f, 0.03433792f, -0.02983222f, 0.01062702f, -0.00688551f, 0.08076288f, -0.02233155f, 
    -0.02053903f, 0.10412190f, -0.05585315f, -0.02402166f, -0.64877695f, -0.07570239f, -0.21997939f, -0.31537837f, 
    0.30919716f, 0.11531841f, -0.10125657f, -0.01997381f, 0.38064736f, 0.01937585f, 0.10594989f, 0.11510539f, 
    -0.15083858f, 0.12276515f, 0.15557294f, 0.17158933f, 0.11180530f, 0.03486163f, -0.40041953f, 0.03673261f, 
    -0.12916377f, -0.15713836f, 0.18515022f, 0.09640019f, 0.06233678f, -0.04899322f, -0.00160866f, 0.10161240f, 
    -0.00389693f, -0.03561756f, 0.09274045f, 0.01245645f, -0.00209749f, 0.07575361f, 0.01510131f, 0.22837707f, 
    -0.02311742f, -0.01893040f, -0.02467429f, -0.08024035f, 0.26685792f, 0.17343983f, -0.02421227f, -0.07140376f, 
    0.04106968f, -0.01570971f, -0.13671228f, 0.23039439f, -0.08284719f, -0.10048237f, -0.02919588f, -0.07364350f, 
    -0.00175407f, 0.04723600f, 0.00256688f, 0.02975889f, -0.05689602f, -0.00742029f, -0.06493930f, -0.11347985f, 
    0.33432117f, -0.33217269f, 0.43585923f, -0.00468180f, -0.10471336f, 0.10870694f, -0.08363356f, -0.13508686f, 
    -0.01586833f, -0.12538412f, -0.11239848f, -0.02200776f, -0.00548011f, 0.05287686f, -0.01576388f, -0.06204436f, 
    -0.02841968f, 0.22379112f, 0.02937400f, 0.12126062f, 0.04048611f, 0.11576876f, 0.01486430f, 0.21309014f, 
    -0.09494086f, -0.22019358f, -0.01506764f, -0.03926800f, 0.03000868f, -0.10536624f, 0.04768392f, 0.01879822f, 
    -0.16296785f, -0.03218648f, -0.00896584f, -0.03286710f, -0.08439561f, 0.03367932f, -0.07304321f, -0.03175970f, 
    -0.01411629f, -0.12594923f, 0.05826648f, -0.14780709f, 0.12598740f, -0.12370082f, 0.18096365f, -0.03397940f, 
    -0.06485051f, -0.04615425f, -0.02494627f, 0.00903815f, -0.06204871f, 0.07877152f, -0.06386872f, 0.16563982f, 
    0.06957667f, -0.03441002f, 0.03520544f, 0.02527619f, -0.17133254f, -0.12264661f, -0.25821942f, -0.25842288f, 
    -0.02741252f, 0.04603450f, 0.03337179f, 0.41732824f, -0.07132822f, 0.15962571f, -0.07451867f, -0.14691170f, 
    -0.03920086f, -0.11704460f, -0.13080351f, 0.02773125f, -0.03925781f, 0.03340686f, -0.08208284f, 0.00176331f, 
    -0.16592965f, 0.18756652f, 0.12724310f, 0.01782836f, -0.05924341f, 0.06905464f, -0.15686011f, 0.22080161f, 
    0.02763149f, 0.00587978f, 0.05021311f, -0.04648696f, -0.10889106f, 0.05753242f, -0.01559780f, -0.13652442f, 
    -0.01348913f, -0.01631457f, 0.01271171f, 0.02656353f, 0.12484530f, 0.02782577f, 0.12888199f, -0.21048729f, 
    0.21510142f, -0.06188694f, -0.02583988f, -0.24633329f, 0.29766855f, -0.20543075f, 0.01176629f, 0.00521133f, 
    0.06570474f, -0.01368491f, 0.01642774f, 0.05863220f, 0.03951631f, 0.06714308f, -0.02492330f, 0.00374287f, 
    -0.04068518f, -0.08528740f, -0.06706482f, -0.05731015f, 0.00702068f, -0.07442795f, 0.05928809f, 0.02699452f, 
    0.12484752f, 0.08229497f, 0.13087174f, 0.14143685f, -0.09057947f, -0.04555589f, 0.05057558f, -0.12116599f, 
    0.01979817f, 0.00794584f, -0.01042609f, 0.04299293f, 0.20462508f, 0.02951575f, 0.16178696f, 0.01246847f, 
    0.06147767f, 0.02228658f, 0.06168289f, 0.01304518f, 0.09565074f, 0.12538517f, -0.09670974f, 0.09206300f, 
    0.09795218f, 0.06483742f, 0.08729020f, -0.10072998f, 0.24731299f, -0.03509840f, -0.06526561f, -0.02198271f, 
    0.10339317f, -0.00930984f, 0.07959891f, 0.11090969f, 0.07771553f, 0.07741836f, 0.07609910f, 0.00814849f, 
    0.02944266f, 0.03549058f, -0.11986372f, 0.14912194f, -0.03874799f, -0.02800082f, 0.04402418f, 0.01369874f, 
    0.15325846f, -0.09401843f, -0.01928937f, 0.04820821f, -0.02997051f, 0.34786108f, -0.05780141f, 0.48020074f, 
    -0.31769335f, 0.06883068f, -0.07524062f, 0.05576177f, 0.01560010f, -0.10083393f, -0.06752315f, -0.02955134f, 
    0.20653318f, -0.05724080f, 0.11250110f, -0.07948098f, -0.02946843f, 0.10994724f, 0.06972359f, -0.00743561f, 
    -0.00859734f, -0.05215923f, 0.24913877f, -0.03731603f, -0.17093566f, -0.02217067f, -0.02112413f, 0.01158603f, 
    0.02720105f, 0.04167785f, 0.08844086f, 0.08720841f, -0.00307269f, 0.08069505f, 0.10784340f, 0.00493234f, 
    -0.17177932f, -0.07798407f, -0.04427469f, 0.07446890f, 0.30862799f, -0.05197831f, 0.45317549f, 0.05807909f, 
    0.16416326f, 0.06445112f, 0.00424242f, -0.06154269f, 0.03133165f, -0.06271955f, -0.07172157f, 0.06790478f, 
    -0.03041948f, 0.00753506f, 0.02684558f, 0.13478275f, 0.21216488f, 0.04286775f, 0.13444959f, -0.01341250f, 
    0.09693905f, 0.22685780f, 0.18861333f, -0.07309934f, 0.05457433f, -0.10880892f, -0.16223294f, 0.02523271f, 
    -0.07528417f, 0.00117742f, -0.11701683f, 0.05313770f, 0.05687812f, 0.04178973f, 0.06571539f, -0.09210940f, 
    -0.01202230f, -0.16539435f, 0.13707674f, -0.14256826f, 0.19605650f, -0.16969757f, 0.19361676f, 0.02582947f, 
    0.04703168f, -0.04657022f, -0.05098069f, -0.09855768f, 0.23487794f, -0.08675838f, -0.07473350f, -0.03530583f, 
    0.03217970f, 0.04722343f, 0.08596986f, -0.04297226f, -0.02378333f, 0.00726298f, 0.12872757f, 0.14654042f, 
    0.17077419f, 0.10987638f, 0.01079952f, -0.26187545f, 0.13044150f, -0.00789302f, 0.18445189f, 0.08473777f, 
    -0.09570576f, -0.05705579f, 0.05093249f, -0.01478766f, -0.03789440f, -0.03731229f, 0.01642913f, 0.02730338f, 
    0.03742939f, 0.27536353f, 0.00391457f, 0.01398653f, 0.22810082f, 0.28910300f, -0.01125987f, 0.19067557f, 
    0.07878885f, 0.06672760f, -0.01381654f, 0.15618037f, -0.17467557f, -0.10651492f, -0.05960429f, -0.09021383f, 
    -0.03928632f, -0.03882237f, -0.04316732f, 0.21861878f, 0.14366540f, 0.03592755f, -0.04847561f, 0.00998926f, 
    0.01142392f, -0.59871113f, 0.11965720f, -0.29348186f, 0.16515802f, -0.01048359f, -0.06642540f, 0.11863009f, 
    -0.16690736f, 0.09444328f, 0.20212232f, 0.17343764f, 0.05099920f, 0.21733236f, 0.10665503f, 0.07293864f, 
    -0.06470919f, 0.05199152f, 0.03538468f, 0.07104235f, -0.34795105f, -0.17611857f, -0.08668717f, -0.05639669f, 
    0.11100493f, -0.06129498f, 0.18924540f, 0.20576057f, 0.21598476f, 0.05729294f, 0.01146036f, 0.02308821f, 
    -0.11871654f, -0.13013741f, 0.00947915f, -0.06965916f, 0.09044307f, -0.10837097f, -0.00775118f, 0.00773370f, 
    -0.05658479f, 0.02689837f, -0.15038449f, 0.11079621f, -0.02286652f, -0.10595518f, 0.08004799f, 0.09329443f, 
    -0.07872771f, -0.10026058f, 0.01331200f, 0.01695276f, -0.11086512f, -0.08455636f, 0.04736402f, -0.02307623f, 
    0.01377429f, 0.02013653f, 0.01797421f, 0.01231899f, 0.18150811f, 0.29446343f, -0.06386262f, -0.23182754f, 
    0.35840484f, -0.13637321f, -0.03778904f, 0.03570508f, -0.20284639f, -0.15972023f, -0.03883522f, -0.08868662f, 
    0.00489784f, -0.02961084f, -0.06324144f, 0.17556152f, -0.02584556f, 0.05478895f, 0.09340978f, 0.01227072f, 
    0.06199187f, 0.01667895f, -0.01616219f, 0.10312978f, -0.03718942f, -0.04479060f, 0.00955768f, 0.01244790f, 
    -0.01455720f, 0.03533958f, -0.01802166f, 0.10246857f, 0.04867735f, 0.05251052f, 0.11762232f, -0.13828354f, 
    -0.01052429f, -0.00385815f, -0.08079110f, -0.08137924f, 0.68594229f, 0.48392558f, 0.51817787f, 0.04692500f, 
    -0.00908709f, -0.05844503f, -0.13275355f, -0.05421261f, -0.06369334f, -0.01976816f, -0.01453828f, -0.01373325f, 
    -0.05044906f, -0.04746781f, 0.01239325f, -0.01670495f, 0.06600303f, -0.01279316f, 0.05081769f, 0.19828117f, 
    0.06865665f, -0.09422696f, 0.37703866f, -0.03090999f, 0.08241384f, 0.01337730f, 0.04400692f, -0.07037167f, 
    0.12745972f, 0.02132402f, 0.05448974f, -0.07261411f, 0.06105557f, 0.03719012f, 0.12597013f, 0.14066368f, 
    0.00446920f, -0.06285696f, -0.01479601f, -0.11565752f, 0.18272679f, 0.17735036f, -0.05738237f, -0.25536415f, 
    0.05547961f, 0.00604222f, 0.09140917f, -0.00260545f, -0.12554099f, -0.16023393f, -0.03308476f, 0.01596744f, 
    -0.00004041f, -0.04850204f, -0.01583279f, 0.05893089f, -0.03382121f, 0.22021948f, 0.06773584f, -0.06175235f, 
    0.05459979f, -0.11679068f, 0.25165504f, -0.11642320f, 0.16937399f, -0.14430124f, 0.14646228f, -0.01020432f, 
    0.02222680f, 0.11258834f, 0.10948125f, 0.00835639f, 0.05115021f, 0.05205251f, 0.09357359f, -0.09448552f, 
    0.04194926f, -0.05222991f, 0.02469079f, 0.13200997f, -0.43033084f, -0.33423379f, 0.28918993f, -0.25683725f, 
    0.14530975f, -0.14529851f, 0.12104354f, 0.33541927f, 0.10499640f, 0.22449668f, -0.10945845f, -0.05912934f, 
    -0.11215296f, -0.02585577f, -0.06267175f, -0.07946261f, -0.00031023f, -0.05610328f, 0.01036567f, -0.04768609f, 
    0.00525173f, -0.01685604f, -0.02287747f, -0.01597267f, -0.01033330f, -0.02610893f, -0.02183175f, 0.02018728f, 
    -0.01594055f, -0.03054919f, -0.01195009f, 0.00623475f, -0.00170650f, 0.01106208f, 0.00942635f, -0.02818907f, 
    0.02993973f, 0.01692460f, 0.03332663f, 0.01632364f, -0.02318082f, -0.00181140f, -0.04267834f, -0.03009427f, 
    0.01112175f, 0.01668032f, -0.02690580f, 0.02823237f, 0.01962764f, 0.01421102f, -0.02614038f, -0.03723335f, 
    -0.03806722f, 0.01938506f, -0.03408584f, -0.02202434f, -0.00210114f, 0.00643804f, 0.01382710f, -0.01254640f, 
    -0.00951475f, 0.03174503f, 0.02036377f, -0.02108824f, -0.01582635f, 0.02193241f, 0.01107203f, -0.04104710f, 
    -0.02310937f, -0.02672851f, 0.02796255f, 0.02567909f, -0.02148496f, 0.01582912f, -0.00270483f, -0.02614824f, 
    0.01681644f, 0.02730137f, 0.02304056f, -0.02316147f, -0.02230225f, -0.03712469f, -0.03330344f, 0.01475914f, 
    -0.01736173f, 0.01993055f, 0.02090423f, 0.01600917f, -0.00298515f, 0.02672390f, 0.01870547f, -0.02001868f, 
    -0.02662749f, -0.03741801f, -0.02707195f, 0.04080435f, -0.03505949f, -0.00512756f, -0.03388454f, 0.00381840f, 
    -0.00384319f, -0.00208885f, 0.01814225f, -0.04322210f, -0.00075503f, -0.02017795f, -0.03425183f, 0.00814437f, 
    -0.00537481f, 0.01566734f, -0.01871787f, 0.00073289f, -0.00143735f, 0.02221881f, -0.01752550f, -0.04429252f, 
    0.02053861f, 0.02640219f, 0.01022142f, -0.04482438f, -0.04302785f, -0.00488761f, -0.01421829f, -0.04394418f, 
    0.01183923f, 0.03315270f, -0.00984242f, 0.02200101f, 0.01997816f, 0.00357289f, -0.01342843f, -0.03793300f, 
    0.03502624f, -0.03415661f, 0.02950428f, -0.03885386f, 0.01014997f, -0.02701606f, -0.01975304f, -0.03066759f, 
    -0.03666726f, -0.00879223f, 0.01375397f, 0.01638766f, -0.02243637f, 0.02787996f, 0.01356742f, 0.00488717f, 
    0.02587320f, -0.02480008f, -0.00482899f, 0.02225131f, -0.00400322f, 0.00901513f, -0.02980878f, -0.01813061f, 
    -0.04436003f, -0.00522935f, 0.01298292f, -0.00572280f, -0.01677284f, -0.00269597f, 0.03680145f, 0.02871508f, 
    -0.03615648f, 0.02577670f, -0.01313404f, 0.02001385f, 0.02340135f, -0.01111175f, -0.02457915f, 0.01208153f, 
    -0.00380025f, -0.02384153f, -0.02848829f, -0.01921060f, -0.03442608f, -0.03759121f, 0.03383851f, -0.03015929f, 
    0.01555186f, 0.00931664f, -0.04356045f, -0.01482700f, 0.01537938f, 0.00029100f, 0.00635559f, 0.01156998f, 
    0.02751677f, 0.01813978f, 0.00252877f, -0.00291855f, -0.04060559f, -0.01580878f, -0.03054808f, 0.01083549f, 
    0.02583849f, -0.00727216f, 0.00933881f, 0.01455992f, 0.01529563f, -0.02994831f, -0.00884330f, 0.02236644f, 
    0.00696260f, 0.03199735f, -0.03784798f, -0.02621378f, 0.03320093f, -0.00760976f, -0.00773526f, -0.04242488f, 
    -0.03179541f, 0.01989745f, -0.00128548f, -0.00218610f, -0.02872117f, -0.03169422f, -0.00106276f, -0.02421748f, 
    0.03807252f, 0.00252760f, -0.00991129f, -0.03800116f, 0.01460311f, -0.00048830f, 0.01382960f, -0.02362111f, 
    -0.03446340f, -0.03413487f, 0.01442573f, -0.01403386f, -0.00505362f, -0.03918150f, 0.03292688f, -0.00380460f, 
    0.02941887f, -0.00866698f, 0.00198588f, -0.01707856f, -0.03408747f, -0.00006815f, 0.03271832f, 0.00256573f, 
    0.00460338f, -0.01755171f, 0.01694667f, 0.03131546f, 0.00928170f, 0.02388739f, -0.03347460f, 0.02401083f, 
    0.01446649f, 0.03154687f, 0.01959597f, 0.00562084f, 0.00219657f, -0.00863831f, 0.00100016f, -0.03216903f, 
    -0.03961750f, -0.02706218f, -0.02715508f, -0.03766269f, 0.00325323f, 0.00515752f, -0.03953886f, -0.03393306f, 
    0.02872577f, -0.01676019f, -0.00529171f, 0.00107893f, -0.02134026f, 0.01876057f, 0.00599400f, -0.00822625f, 
    -0.02802835f, 0.00434872f, -0.03836419f, -0.02104475f, 0.00237092f, 0.00519531f, 0.00518179f, -0.01099427f, 
    -0.01525334f, -0.03176690f, -0.03944414f, 0.02459731f, -0.01684163f, 0.00595447f, -0.00963766f, -0.03720112f, 
    -0.01242720f, -0.00531857f, 0.02935021f, 0.02770836f, -0.00914278f, -0.00514525f, 0.01674889f, 0.02040645f, 
    -0.01250488f, -0.03602136f, 0.02812235f, 0.01426012f, -0.02954868f, 0.01863560f, 0.03230331f, -0.02438251f, 
    0.01694510f, 0.00661853f, 0.00205515f, -0.01641667f, -0.03638449f, -0.04348418f, -0.01509290f, -0.01762491f, 
    0.01703105f, 0.02208795f, -0.03182720f, 0.01081619f, -0.00673762f, 0.01067571f, -0.00862524f, 0.01570345f, 
    0.02977763f, -0.02471835f, 0.01729634f, 0.03305327f, 0.02147793f, -0.03890568f, 0.00547744f, 0.02142069f, 
    0.00171319f, 0.01134103f, 0.00245491f, 0.00918227f, 0.01423572f, 0.01858639f, 0.02740933f, 0.00043293f, 
    -0.01244750f, 0.02701456f, -0.00920485f, 0.01877483f, -0.02112128f, 0.02829335f, -0.03038269f, -0.02863121f, 
    0.00530083f, -0.01476702f, -0.02636347f, -0.04276262f, 0.00661501f, -0.04106777f, 0.00577691f, -0.00927155f, 
    -0.03189344f, 0.02592657f, 0.03041468f, -0.01057793f, 0.02011068f, -0.00273738f, 0.00920822f, -0.01968996f, 
    0.00945059f, 0.02840128f, -0.01138231f, 0.00722666f, -0.00645094f, 0.03088819f, 0.00151308f, 0.02255165f, 
    -0.01897820f, -0.04485380f, 0.00966715f, 0.01753661f, -0.03559863f, -0.00025240f, -0.03328797f, 0.02722429f, 
    -0.00743335f, -0.02773815f, -0.03690261f, 0.01983091f, -0.02005011f, -0.00924267f, -0.02459727f, 0.00220327f, 
    -0.01809572f, -0.02669312f, -0.03683333f, 0.01518063f, -0.01143136f, 0.03377403f, -0.00364028f, -0.01545737f, 
    -0.02186067f, 0.00503972f, 0.01118100f, -0.02377996f, 0.01135864f, -0.03724924f, -0.01477643f, -0.02467434f, 
    0.00618446f, 0.01668956f, -0.03774693f, -0.03327812f, -0.04412101f, -0.01447449f, -0.00242439f, 0.00763942f, 
    -0.03106021f, -0.02270984f, -0.03874718f, -0.00640252f, -0.03716576f, -0.03919812f, -0.04389655f, 0.03159317f, 
    0.00743054f, 0.00251603f, -0.02714146f, -0.02170366f, 0.00480758f, 0.02757285f, 0.02945517f, -0.00834307f, 
    0.03283727f, -0.03147298f, -0.03194924f, -0.03765482f, -0.02950816f, 0.00222488f, 0.01670009f, 0.00245823f, 
    0.00033901f, -0.01235481f, 0.03394844f, -0.03397543f, -0.02247520f, 0.01205011f, -0.04535155f, 0.00575052f, 
    -0.02226374f, -0.01494002f, -0.00368894f, 0.00994803f, -0.00360969f, -0.00818744f, 0.02784521f, -0.03773807f, 
    -0.01280550f, 0.01384543f, -0.03260226f, 0.02941221f, -0.01004425f, -0.04174274f, 0.02425565f, -0.02906693f, 
    -0.02590054f, -0.04366411f, -0.02438921f, 0.01400186f, 0.01546523f, -0.03521780f, 0.01812865f, -0.01718350f, 
    0.00056888f, 0.00108307f, -0.03476291f, 0.01013100f, -0.01187078f, 0.00957514f, -0.03254413f, -0.00031474f, 
    0.00881860f, -0.02461177f, 0.00701836f, -0.03049903f, -0.01301010f, 0.03304550f, 0.01936801f, -0.03927711f, 
    -0.04173670f, -0.03628716f, -0.01821749f, -0.04065222f, 0.01651199f, -0.03969515f, 0.03004410f, -0.01326027f, 
    0.03169621f, -0.04559505f, 0.02718101f, 0.00120915f, 0.02238625f, 0.00199325f, 0.01212110f, -0.02957894f, 
    0.02805561f, 0.01388272f, 0.00245459f, 0.02912946f, 0.01549104f, -0.04329501f, 0.00229841f, -0.01605331f, 
    0.01840703f, -0.03144266f, 0.01601342f, 0.02227454f, -0.03885760f, 0.00331235f, -0.00510904f, -0.00929334f, 
    -0.02703645f, -0.02139580f, -0.02152169f, -0.04318616f, -0.02609812f, 0.00263219f, 0.02645322f, -0.01954979f, 
    -0.00394051f, 0.02265264f, 0.02850579f, 0.00210195f, -0.02614618f, -0.00520062f, -0.01173973f, 0.01449280f, 
    -0.03756452f, -0.01248759f, -0.03141759f, -0.00299010f, -0.00808662f, -0.04272178f, -0.01042170f, 0.01807197f, 
    0.03646255f, -0.03095069f, 0.01527556f, -0.04169593f, -0.01909974f, -0.01418191f, -0.00358850f, 0.01554504f, 
    -0.01289318f, -0.02077697f, -0.03266858f, -0.00275871f, 0.01547289f, 0.01633573f, 0.02415108f, 0.00973508f, 
    0.02869237f, 0.02227820f, 0.00334019f, -0.00997242f, -0.03225148f, -0.04110909f, 0.00246588f, 0.01441779f, 
    0.02467304f, 0.02537260f, -0.03805188f, 0.00142260f, 0.00695142f, -0.03854031f, -0.03609018f, 0.01787465f, 
    0.00778862f, -0.01589097f, -0.00387359f, -0.03278170f, -0.02633779f, -0.03926514f, 0.01885474f, -0.02239706f, 
    -0.02436533f, 0.01399750f, 0.02008053f, -0.03887224f, 0.03400169f, -0.02098162f, -0.04320777f, -0.00183246f, 
    -0.02967622f, -0.01696810f, -0.01300942f, 0.01669749f, -0.00898796f, -0.00628807f, 0.02290791f, 0.01889625f, 
    -0.01921508f, -0.00688853f, -0.00704678f, -0.02238774f, 0.01757011f, -0.00410998f, -0.04105595f, -0.04018292f, 
    -0.00018295f, -0.01907364f, 0.00490978f, 0.03465787f, -0.04063747f, 0.03443841f, -0.04133311f, -0.03160613f, 
    0.02551401f, -0.01998882f, 0.01284603f, 0.02828022f, 0.01525307f, -0.01096374f, -0.00849441f, 0.02171021f, 
    -0.01697215f, 0.00487730f, 0.00002078f, 0.02344435f, -0.00695741f, -0.01338666f, 0.02146891f, -0.00195486f, 
    0.02390522f, -0.03867416f, -0.00239901f, 0.00810325f, 0.01062389f, -0.01406015f, -0.00448877f, -0.02420238f, 
    0.03059226f, -0.01003009f, -0.00040814f, -0.01887706f, -0.01375676f, 0.03563387f, -0.02252668f, -0.00362218f, 
    -0.02364737f, 0.00659602f, -0.03316980f, -0.01175486f, -0.03437384f, 0.02449779f, 0.00208042f, 0.01201185f, 
    -0.02682181f, 0.03330781f, -0.00027953f, 0.03028170f, 0.00693063f, 0.01828795f, -0.03768441f, -0.00570110f, 
    0.26881599f, -0.19669586f, -0.02414878f, 0.12638599f, 0.14479814f, -0.15098056f, 0.25219047f, 0.17201835f, 
    -0.11861378f, 0.09402998f, -0.01629039f, 0.12554403f, -0.06553403f, -0.00599999f, 0.00178315f, 0.19329143f, 
    0.08082476f, -0.01176543f, -0.04087125f, 0.02287286f, 0.01634646f, 0.10301105f, 0.35163826f, 0.20106898f, 
    0.03526501f, -0.02850897f, -0.13218933f, -0.02161425f, 0.06522923f, 0.12697409f, -0.08697974f, 0.06581847f, 
    -0.07080714f, 0.05363135f, 0.08928170f, 0.08730805f, 0.02394016f, 0.00330858f, -0.06088195f, 0.09852483f, 
    -0.16808954f, 0.00881693f, -0.31281465f, -0.29280487f, -0.10723060f, -0.01724864f, -0.05213432f, 0.11089357f, 
    0.07747028f, 0.02207602f, -0.01907328f, 0.02244432f, -0.03516969f, 0.00890586f, -0.06444152f, 0.03328345f, 
    0.01219103f, -0.02539932f, 0.00182972f, -0.06122296f, 0.61062974f, -0.49360114f, -0.52430004f, 0.32864025f, 
    0.24876986f, -0.22211654f, 0.01695835f, 0.40072453f, -0.27305168f, 0.11515476f, 0.28125995f, 0.05714924f, 
    0.09197684f, 0.01479210f, 0.26488939f, -0.01045588f, 0.30027273f, 0.03181829f, -0.19280893f, -0.04263745f, 
    0.04279683f, 0.05080346f, 0.06140829f, -0.10778968f, 0.07398935f, 0.02540781f, 0.07773332f, 0.04819573f, 
    0.08757299f, -0.04661930f, 0.08579138f, 0.11286034f, 0.08248324f, -0.01833553f, -0.13446915f, -0.07787413f, 
    0.12012951f, 0.10271202f, 0.07518790f, -0.07825267f, 0.24838187f, -0.03675928f, -0.33941218f, 0.04082637f, 
    -0.00142689f, -0.24173161f, 0.17461891f, 0.08315343f, 0.10618630f, 0.09025718f, 0.00557696f, -0.03973810f, 
    0.02910794f, -0.04549443f, -0.03737538f, -0.02661234f, -0.04121685f, -0.05356481f, -0.00351768f, -0.17375667f, 
    -0.61732286f, 0.12386456f, -0.11744919f, -0.04888079f, -0.39032078f, 0.10380806f, -0.18073912f, 0.22410479f, 
    0.13904989f, 0.00509064f, 0.02719303f, 0.01742620f, -0.06348474f, -0.00940818f, 0.03886686f, 0.09866405f, 
    -0.01178635f, 0.00859138f, 0.18527041f, 0.06417739f, 0.07734017f, -0.16932353f, 0.08083512f, 0.13156785f, 
    -0.01029784f, 0.08053622f, 0.16853900f, -0.10502982f, -0.12284192f, 0.08292458f, -0.01785516f, 0.06550189f, 
    -0.04399693f, 0.03745953f, -0.01636765f, 0.01866046f, -0.00092596f, -0.02194840f, -0.04655503f, -0.06608151f, 
    0.04530551f, -0.11406624f, 0.08578024f, 0.09668880f, 0.02584719f, 0.09931149f, 0.09770446f, 0.03816621f, 
    0.24961969f, 0.10052770f, 0.09996074f, 0.07199563f, 0.02984275f, -0.06251639f, -0.10751514f, 0.16076156f, 
    0.16264226f, -0.04276646f, 0.05977639f, 0.05829250f, 0.63713580f, 0.04762374f, 0.39284495f, 0.41629189f, 
    0.21082963f, 0.00182951f, 0.02986259f, -0.03924565f, 0.12684636f, 0.01269019f, 0.07975449f, -0.02653128f, 
    0.00854953f, 0.11655042f, 0.11492459f, 0.07380530f, 0.03597576f, -0.00549620f, 0.04293735f, 0.01123165f, 
    0.11340825f, 0.08170143f, -0.09920408f, 0.15861546f, 0.03435185f, 0.08187891f, 0.11517365f, 0.07449803f, 
    -0.26464140f, 0.13705988f, 0.05175533f, 0.04173195f, -0.06462206f, 0.04255696f, -0.00461853f, 0.02940929f, 
    0.05797886f, -0.01874450f, 0.00308420f, -0.13122575f, -0.13376115f, -0.07636522f, -0.21200140f, -0.23726161f, 
    -0.12178379f, 0.00251611f, 0.04492367f, 0.09846622f, -0.05919944f, 0.01140139f, -0.07120800f, -0.05907142f, 
    -0.03123685f, 0.05610196f, -0.01582089f, -0.03096759f, 0.02218788f, -0.05540058f, 0.18529643f, 0.12463883f, 
    0.01009541f, 0.08676374f, 0.14645408f, -0.00731578f, 0.02209835f, -0.04084835f, 0.03556750f, -0.06100675f, 
    0.00766483f, -0.08595622f, 0.03308411f, 0.09559541f, 0.16873869f, 0.06178477f, 0.13827869f, -0.08590838f, 
    -0.10836213f, -0.05045484f, 0.04340887f, -0.09099265f, -0.16407120f, 0.23109527f, 0.09257037f, -0.09490991f, 
    0.01717857f, 0.09669378f, -0.07048048f, 0.11961647f, -0.01941508f, 0.01714653f, 0.01757531f, -0.05021449f, 
    0.00485922f, 0.13097309f, -0.01776369f, -0.00292906f, 0.07447337f, -0.01345932f, 0.06796867f, -0.00218283f, 
    -0.22487086f, 0.09934314f, 0.22692768f, -0.19210516f, -0.09251811f, 0.02768387f, -0.06247167f, 0.09008301f, 
    0.05287558f, 0.07457135f, 0.02636297f, 0.02868223f, -0.10887836f, 0.00147310f, 0.02418847f, -0.05142814f, 
    0.15953965f, -0.03961289f, 0.06189576f, 0.07114686f, -0.05534491f, -0.28943208f, 0.08461721f, 0.01367563f, 
    0.12147171f, -0.20650320f, -0.00752997f, 0.02409536f, 0.22022310f, 0.18253829f, -0.22809215f, 0.16806650f, 
    -0.10271042f, -0.10364197f, 0.03944276f, -0.01578260f, 0.11239623f, -0.00674965f, -0.16405201f, 0.17845003f, 
    -0.05361832f, -0.01489426f, -0.05117333f, 0.14537475f, 0.00646452f, -0.02840413f, 0.04127123f, -0.00987063f, 
    0.03180623f, -0.09539600f, 0.01644807f, 0.07525190f, 0.04604620f, -0.12545376f, -0.19446471f, 0.29656529f, 
    0.15215458f, 0.08461977f, 0.07089616f, 0.20473187f, -0.44200715f, 0.13892458f, 0.07464217f, -0.22171025f, 
    -0.18519610f, 0.11430661f, -0.06264605f, 0.09312918f, 0.10944448f, -0.05646179f, -0.02187175f, -0.06046700f, 
    -0.08201007f, 0.07164023f, -0.01124908f, 0.13933629f, 0.07336455f, -0.06352481f, 0.22715044f, 0.01876199f, 
    0.08237605f, -0.01187223f, -0.19540933f, -0.03917858f, 0.07853685f, 0.07639825f, -0.07969279f, 0.02111800f, 
    0.03004452f, 0.06325550f, 0.03781693f, 0.04544403f, -0.02100016f, 0.03903670f, -0.11833932f, -0.03817322f, 
    -0.00697360f, 0.04038328f, 0.04104136f, 0.02564660f, -0.12792964f, -0.08784278f, -0.25545046f, -0.18845671f, 
    -0.26673403f, 0.15589018f, 0.20363197f, 0.10471305f, 0.09911144f, -0.06290183f, 0.07624987f, 0.02834964f, 
    -0.01727585f, -0.10419487f, -0.01865977f, -0.00160452f, 0.05597684f, -0.01948522f, 0.09428496f, 0.01605422f, 
    -0.08129420f, -0.09246180f, -0.12185375f, -0.18530695f, -0.07334618f, -0.00054342f, 0.10103395f, 0.04174245f, 
    -0.04160462f, 0.02014169f, -0.04186645f, -0.06155721f, -0.02362199f, -0.00409872f, -0.08846311f, 0.01926288f, 
    -0.05751054f, 0.18410592f, 0.45134798f, 0.52339786f, 0.38260850f, -0.15285374f, -0.28740552f, 0.07117498f, 
    -0.14619887f, -0.23170130f, 0.07748415f, 0.05386796f, 0.24735858f, -0.02156773f, -0.04584853f, 0.01931865f, 
    0.06010694f, -0.00579914f, -0.08763397f, -0.06692582f, 0.06505442f, -0.00065867f, -0.08855729f, -0.14442272f, 
    0.27754459f, -0.38567552f, -0.05305654f, 0.02258021f, 0.21682981f, -0.05226399f, 0.00919452f, -0.06731953f, 
    0.01449522f, -0.06376340f, 0.15464221f, 0.03254805f, 0.14069259f, 0.09977861f, -0.22041643f, 0.15619123f, 
    0.06228691f, 0.10343129f, 0.12612996f, 0.24620289f, 0.34057078f, 0.25438571f, 0.48516321f, 0.09463622f, 
    0.03104370f, -0.07721212f, 0.01790482f, -0.08586493f, -0.12867887f, -0.11017963f, 0.11840974f, 0.06254496f, 
    0.14719088f, 0.03195804f, 0.13079618f, -0.03376162f, 0.01531614f, -0.04707506f, -0.00247670f, -0.12446924f, 
    0.03624535f, 0.10032879f, 0.01381549f, 0.09225100f, 0.05528368f, -0.02168101f, 0.06839826f, -0.16898574f, 
    -0.09696186f, -0.00539598f, 0.14162721f, 0.09057609f, 0.06593537f, 0.03213144f, 0.03178978f, -0.00937777f, 
    -0.06576948f, -0.02076735f, -0.03852284f, -0.10962349f, -0.01497318f, 0.04905200f, -0.15686905f, -0.30337444f, 
    0.01016954f, -0.08535204f, -0.10663418f, -0.04805968f, 0.05430027f, 0.21809746f, -0.08050995f, -0.07986965f, 
    -0.05987305f, -0.06429831f, -0.04808575f, 0.03907308f, -0.07690714f, -0.09664015f, 0.04883707f, 0.04988655f, 
    -0.12873451f, -0.09862257f, 0.03816690f, -0.06529072f, -0.02006444f, -0.08161718f, 0.01195581f, 0.03097410f, 
    0.05773437f, 0.03758374f, -0.09763704f, 0.01771689f, 0.05328417f, -0.02649911f, 0.01316767f, 0.02174369f, 
    -0.05821613f, -0.02242122f, 0.00788352f, 0.07028317f, -0.11331724f, 0.21426690f, -0.29449874f, -0.20461667f, 
    0.14747621f, -0.06821300f, 0.06736379f, 0.13002206f, 0.01746211f, -0.05889635f, -0.03758330f, -0.02023870f, 
    -0.01280641f, -0.00050213f, 0.00220338f, 0.20114022f, 0.11822328f, -0.20755504f, 0.10120428f, 0.19440679f, 
    -0.08347532f, 0.17021126f, 0.01734543f, 0.11703470f, -0.00440157f, 0.03847835f, -0.08323327f, 0.03370390f, 
    0.01161761f, -0.07228277f, 0.09225926f, 0.03492754f, 0.11847884f, 0.16981985f, -0.08653839f, 0.12295470f, 
    0.17399193f, 0.01694230f, 0.08253901f, -0.11926103f, -0.10118815f, -0.02094251f, -0.24008849f, -0.12612516f, 
    -0.18539213f, -0.05887340f, 0.11714835f, -0.02764997f, -0.06052253f, 0.03512847f, -0.04788104f, -0.06668235f, 
    -0.08225656f, 0.00017759f, -0.10732736f, -0.05670566f, -0.04432063f, 0.16830984f, 0.25895885f, 0.34578085f, 
    0.03368639f, 0.04608672f, 0.04875200f, -0.08862709f, 0.12851818f, -0.22140688f, 0.21103078f, 0.11014128f, 
    -0.02682018f, -0.08689354f, 0.20821266f, 0.05781309f, 0.10225923f, 0.03203904f, -0.00145567f, 0.05705235f, 
    -0.08225282f, -0.07017034f, 0.04615937f, -0.06587165f, 0.37164557f, 0.70518863f, 0.27741379f, 0.11090425f, 
    0.06765660f, -0.17957766f, -0.05548358f, 0.01338364f, -0.13738254f, -0.02656208f, 0.02608331f, 0.01321691f, 
    0.05958918f, 0.06956595f, 0.05484305f, -0.05433049f, -0.05443447f, -0.08600739f, 0.01656488f, -0.08106653f, 
    0.25450930f, 0.29909170f, -0.09003673f, 0.00607248f, -0.18729003f, -0.01986745f, 0.05374815f, 0.09043026f, 
    0.04509189f, -0.18826477f, 0.02242935f, -0.04487126f, -0.08887506f, -0.04274038f, -0.04754997f, -0.17756064f, 
    0.11895783f, -0.00550591f, 0.07223441f, -0.00750708f, -0.17258713f, -0.20907670f, -0.17858881f, 0.01351282f, 
    0.16447562f, 0.06964345f, -0.00203805f, -0.04017896f, -0.23355530f, 0.04762328f, 0.25629786f, 0.10747943f, 
    0.04627236f, 0.08080982f, 0.05666070f, -0.04680285f, 0.07677702f, 0.04132641f, -0.04834540f, -0.00454612f, 
    0.44520789f, 0.07239437f, -0.21883565f, -0.27948716f, -0.03631043f, 0.13516286f, 0.07946447f, 0.05237065f, 
    0.02845293f, 0.08776711f, 0.05827254f, -0.03833674f, 0.05629800f, 0.02246515f, 0.07734665f, -0.02081613f, 
    0.04970665f, 0.07387716f, -0.03697103f, 0.08185237f, 0.53627574f, 0.48750022f, 0.12257992f, -0.47250828f, 
    0.20848136f, 0.00198752f, -0.04270444f, -0.07949722f, 0.07483693f, -0.16188551f, 0.12552759f, 0.17656760f, 
    0.03866674f, 0.09499047f, 0.24561383f, -0.11685131f, 0.09071009f, 0.06804170f, -0.22393645f, 0.16747831f, 
    0.03557013f, 0.05944700f, -0.04449069f, 0.01757648f, -0.16818824f, -0.06806743f, -0.03977927f, -0.08079740f, 
    -0.11779264f, 0.01169948f, 0.01740200f, -0.00901855f, -0.00974721f, -0.00627006f, 0.03312510f, 0.07109153f, 
    0.05650936f, 0.04524657f, -0.00404627f, 0.05926342f, 0.23868982f, 0.25460967f, -0.14155503f, -0.34485808f, 
    0.08713742f, 0.12126993f, -0.08551265f, 0.03137315f, 0.02872398f, -0.03842783f, 0.03905937f, -0.05529725f, 
    -0.14812069f, -0.01404562f, 0.05966507f, -0.00418127f, -0.03536847f, 0.00493636f, 0.15572461f, 0.10893758f, 
    -0.56948817f, -0.10144935f, 0.09567305f, 0.11562654f, 0.25121060f, -0.11095169f, -0.00370240f, -0.09935480f, 
    0.02172436f, 0.01374794f, 0.03262854f, -0.06884154f, -0.05591687f, 0.00242208f, -0.04101510f, 0.01427274f, 
    0.00487431f, 0.12929361f, 0.10857384f, 0.06125481f, 0.12241204f, 0.16153161f, -0.14444768f, -0.06052929f, 
    -0.05702109f, -0.03567655f, 0.01684717f, 0.03604670f, -0.00993639f, -0.01731856f, -0.01789984f, 0.01832702f, 
    -0.10205266f, 0.08079190f, 0.03225382f, -0.10909544f, 0.07207267f, 0.04355783f, 0.01120193f, 0.05747673f, 
    0.30393341f, -0.12712613f, -0.12271208f, -0.18387629f, 0.31324577f, -0.05460211f, 0.06480844f, 0.09013592f, 
    0.07702588f, 0.06355252f, 0.02880287f, -0.00607326f, -0.04656103f, -0.03754898f, 0.00811461f, 0.06019863f, 
    0.06022783f, -0.05298077f, -0.01946401f, -0.09502356f, -0.01333782f, -0.08408553f, -0.48183623f, -0.43971002f, 
    0.34799853f, 0.05006112f, 0.16120110f, 0.34926352f, 0.02828158f, 0.06177571f, 0.07048424f, 0.04504366f, 
    -0.05380161f, 0.04675516f, 0.15115990f, -0.02647877f, 0.05616049f, 0.01031362f, -0.03273005f, 0.00102705f, 
    0.22455548f, 0.23289213f, -0.02449491f, -0.16561307f, -0.10558683f, -0.05129455f, -0.02549211f, -0.07931817f, 
    0.04900941f, 0.15216878f, 0.10599735f, -0.07705323f, -0.04027242f, 0.03686231f, -0.02473585f, -0.03127377f, 
    0.10116968f, -0.01253206f, 0.09831276f, 0.00919846f, 0.28168294f, 0.07379063f, 0.27853391f, -0.26479593f, 
    0.01537221f, -0.18083143f, 0.24161580f, -0.04998161f, 0.14507221f, -0.20947373f, 0.04996443f, -0.01832926f, 
    0.05524285f, 0.01216966f, 0.04163573f, -0.04393218f, 0.00379757f, 0.00469236f, -0.00429830f, -0.01410561f, 
    -0.13253312f, -0.17978273f, -0.21071018f, -0.02849697f, -0.00151286f, -0.12902060f, -0.06031846f, -0.00709471f, 
    -0.04432580f, 0.03352495f, 0.04769264f, -0.00646608f, -0.04960400f, 0.02798537f, -0.03641249f, 0.01605410f, 
    -0.02505994f, 0.04003384f, 0.05678156f, -0.10575872f, -0.05112814f, 0.02348777f, 0.10600682f, -0.10159101f, 
    -0.10507806f, -0.02265497f, 0.01189446f, -0.06583597f, -0.12225913f, 0.02615478f, 0.08561272f, 0.05660789f, 
    -0.02393086f, 0.06726150f, 0.04553763f, -0.10388811f, 0.08922403f, -0.02120100f, -0.01841715f, -0.04489281f, 
    -0.43956646f, 0.01761563f, 0.14111155f, 0.09299191f, -0.14441748f, -0.10127417f, -0.09330287f, -0.13554704f, 
    -0.05135851f, -0.06275135f, -0.06772754f, -0.08844105f, -0.14042746f, -0.01654805f, -0.01275254f, 0.03399792f, 
    0.13054001f, -0.13956422f, 0.00805098f, 0.03148866f, -0.14986172f, 0.14516769f, -0.14602068f, -0.22842743f, 
    0.19502136f, 0.22689053f, 0.08298092f, 0.02762311f, 0.19674262f, -0.21270065f, 0.03825703f, 0.04633699f, 
    0.26161090f, -0.13246672f, 0.00137062f, -0.16093673f, 0.10209417f, -0.00995336f, -0.13175097f, 0.08211506f, 
    -0.05880839f, 0.15996544f, 0.16027804f, -0.02752994f, -0.19171892f, -0.04574730f, -0.10928664f, -0.09245115f, 
    0.03920696f, 0.00988379f, 0.01851557f, 0.02008936f, 0.07915670f, 0.04674475f, 0.03722556f, 0.02350017f, 
    0.02188776f, -0.09912824f, -0.06408996f, -0.19399124f, -0.17332222f, -0.06705910f, 0.17715551f, 0.15624194f, 
    -0.12769377f, 0.02642106f, -0.04518036f, 0.01837541f, -0.02510267f, 0.04877299f, 0.08106270f, -0.05660256f, 
    -0.14638510f, -0.00053380f, 0.01959502f, 0.02797490f, 0.11722675f, -0.08854682f, 0.02046335f, -0.05220474f, 
    0.40705559f, 0.02390387f, 0.10931773f, -0.19374126f, 0.00299535f, -0.02912322f, -0.03836696f, -0.28081727f, 
    -0.07135799f, 0.03276337f, -0.00278528f, 0.07086761f, 0.05341649f, -0.12332855f, -0.00431304f, 0.07298366f, 
    0.21295445f, -0.05969596f, 0.04154911f, -0.07353280f, 0.28042951f, 0.05644476f, 0.08224493f, -0.22975981f, 
    0.00590431f, -0.10207315f, 0.15565963f, -0.10160209f, 0.07951035f, -0.05090138f, -0.00310270f, -0.05963051f, 
    0.04446670f, -0.06455436f, 0.04557452f, -0.06017544f, 0.03261740f, 0.14981261f, 0.07744027f, 0.11349044f, 
    0.27194530f, 0.05361965f, 0.08978403f, -0.37249610f, 0.00776723f, -0.00380046f, 0.12431607f, -0.00536668f, 
    0.16095249f, 0.24041000f, 0.02445502f, -0.07460711f, -0.03715322f, 0.04074097f, -0.02088568f, 0.03970300f, 
    -0.08213262f, 0.05475946f, -0.00635008f, -0.15878442f, 0.20911749f, 0.22710265f, -0.18709745f, -0.19719639f, 
    0.20427544f, 0.19907667f, -0.03482630f, 0.08730906f, 0.02106679f, 0.00674828f, -0.01555207f, 0.01395402f, 
    -0.00549927f, 0.06665140f, 0.12547739f, -0.04559096f, -0.01382932f, 0.06088147f, 0.14262122f, 0.07543723f, 
    0.46570736f, 0.27592316f, -0.00176920f, -0.34174845f, -0.32985777f, -0.08537396f, -0.08649413f, -0.18507163f, 
    0.04250006f, -0.02246367f, 0.04163840f, 0.16832942f, 0.03704148f, 0.17502531f, 0.09774800f, 0.08872808f, 
    0.07597670f, -0.12137283f, 0.03869128f, -0.04169416f, -0.06036237f, -0.19989444f, -0.32448280f, -0.22393821f, 
    0.13560860f, -0.07487139f, 0.21517490f, 0.30207556f, -0.02511391f, 0.02888370f, 0.07746375f, -0.01267001f, 
    -0.06653351f, 0.00258498f, 0.04670563f, 0.07499434f, 0.12436581f, -0.08925931f, -0.00001430f, -0.05487440f, 
    0.05266519f, -0.03763155f, -0.30111054f, -0.11931925f, 0.02649469f, -0.00852077f, -0.07174897f, -0.02730397f, 
    0.06806495f, 0.08722659f, -0.02096057f, 0.06450498f, 0.01801243f, 0.03601205f, 0.06282704f, -0.02702234f, 
    0.06171085f, 0.08947328f, 0.04442766f, 0.02251706f, 0.37894982f, 0.16413048f, 0.09772601f, -0.54553747f, 
    0.12056829f, 0.16745348f, 0.30126029f, 0.01058706f, 0.16891347f, -0.05750952f, 0.06753744f, -0.06050597f, 
    -0.08643162f, -0.07443742f, 0.01766975f, 0.00403613f, -0.02679011f, 0.02331112f, 0.07201509f, 0.01047307f, 
    -0.17064093f, -0.10008253f, -0.18843268f, 0.03726732f, -0.09857219f, -0.07615004f, -0.15692532f, -0.11715409f, 
    -0.11444446f, -0.06195546f, 0.08615304f, -0.07361892f, -0.01094792f, 0.00830731f, 0.06539936f, -0.16889174f, 
    -0.05646346f, -0.05190463f, -0.01345889f, -0.04828232f, -0.31845692f, 0.41517946f, 0.53008133f, -0.00708500f, 
    -0.05403005f, -0.04060117f, -0.12071853f, -0.08757194f, 0.00364689f, -0.01940142f, 0.01612301f, -0.02136555f, 
    -0.01799341f, -0.02894719f, 0.04385332f, 0.02823566f, 0.14254683f, 0.16657941f, 0.18262161f, -0.09285583f, 
    -0.13861984f, -0.10028641f, 0.11194723f, 0.00501909f, 0.08565200f, 0.03625082f, 0.12386738f, -0.06374712f, 
    -0.16110645f, -0.03660179f, 0.11373802f, 0.04217429f, -0.03422729f, 0.02070909f, 0.06698503f, -0.00458709f, 
    0.02684834f, 0.04443308f, -0.07340934f, -0.07861612f, 0.19182605f, 0.09242856f, 0.09663898f, -0.29256785f, 
    0.01947200f, 0.04762061f, 0.09909227f, 0.03193220f, 0.05189934f, -0.05670282f, -0.00791411f, -0.02923155f, 
    -0.10481146f, -0.02007322f, 0.03232574f, 0.05542587f, -0.02607000f, 0.18566391f, 0.03988152f, -0.12516150f, 
    0.23800100f, 0.03088391f, 0.15815800f, -0.16250896f, -0.16158690f, -0.12127127f, -0.09631964f, -0.04016070f, 
    -0.06425577f, -0.05211305f, 0.03932763f, 0.02866932f, 0.02390156f, -0.02514394f, 0.03300204f, -0.16733588f, 
    0.15710166f, -0.02823506f, 0.12547970f, -0.00768037f, 0.06688835f, -0.23943952f, -0.32334182f, -0.53751034f, 
    0.23448841f, 0.13026401f, 0.13974214f, 0.15754895f, -0.02407937f, 0.06517234f, 0.00420995f, 0.08612090f, 
    -0.09272777f, -0.01052898f, 0.07875913f, 0.08205861f, 0.02681815f, -0.11292106f, 0.06014871f, -0.08688492f, 
    -0.24584539f, -0.18487738f, -0.06603430f, 0.12474544f, -0.11169254f, 0.04193189f, -0.04989722f, -0.15939292f, 
    -0.10290927f, 0.09804019f, 0.20442155f, 0.06342573f, -0.02468247f, 0.11925288f, 0.04113417f, 0.23683116f, 
    -0.02417491f, 0.08716491f, -0.07842492f, 0.13810465f, -0.24429239f, -0.15254615f, -0.03508506f, -0.03926254f, 
    -0.00263650f, -0.07955267f, -0.01030542f, -0.05422562f, 0.03668177f, 0.03517088f, 0.14478368f, 0.00016471f, 
    -0.01072108f, -0.05924262f, 0.10825811f, 0.09502161f, 0.01434231f, 0.02870470f, -0.08568760f, -0.07405298f, 
    0.46368736f, 0.07304607f, 0.32378268f, -0.13129963f, -0.22836289f, 0.03048583f, 0.05069011f, 0.05916020f, 
    0.04147104f, 0.03567761f, -0.01450077f, 0.07175796f, 0.04397303f, 0.00811545f, -0.07633459f, -0.02647990f, 
    0.00948348f, -0.05482166f, 0.15516140f, -0.10102575f, -0.60419947f, -0.25567925f, -0.41161340f, 0.15773717f, 
    -0.28534403f, 0.11461059f, -0.09880826f, -0.09947724f, -0.07567459f, 0.18055326f, 0.19169775f, 0.01419267f, 
    0.09663254f, 0.07601611f, 0.00548466f, -0.00094842f, 0.07695935f, 0.08914343f, -0.03351168f, 0.19369709f, 
    -0.02654121f, -0.17506404f, -0.12399230f, 0.10889038f, 0.10673883f, -0.08896612f, -0.01671382f, -0.03039250f, 
    0.00225802f, 0.00034129f, 0.05406041f, 0.04525306f, -0.04755275f, 0.16018438f, 0.20613149f, -0.00408583f, 
    -0.09353153f, 0.02346376f, 0.12931362f, 0.14937414f, 0.14858104f, -0.12809300f, 0.06436644f, 0.07671492f, 
    -0.21976635f, -0.12366933f, 0.00599630f, 0.13012689f, -0.06796512f, 0.04304826f, 0.04546737f, -0.06325256f, 
    -0.00518812f, 0.04075090f, 0.05731343f, -0.03245761f, 0.02865373f, 0.02209221f, 0.12000346f, 0.14208731f, 
    0.20395538f, 0.03498709f, -0.10876440f, -0.13762167f, -0.10443399f, -0.03998017f, -0.01446440f, 0.10314354f, 
    -0.18487909f, 0.06258284f, -0.05174358f, -0.02326074f, 0.01137386f, 0.00618424f, 0.00169313f, -0.08354411f, 
    0.06097933f, -0.01236836f, -0.11158188f, -0.07599771f, 0.16368416f, 0.25234622f, 0.10674220f, -0.15066223f, 
    -0.14948647f, -0.21689463f, -0.13961112f, -0.17848800f, -0.29525310f, -0.01958528f, -0.06016038f, 0.05841313f, 
    -0.05021032f, -0.06404670f, -0.08545680f, -0.06153424f, -0.03033143f, 0.01277469f, -0.03545721f, -0.01791939f, 
    -0.06930982f, -0.02972765f, 0.08911204f, 0.05700420f, -0.03484563f, -0.06542843f, 0.05072723f, -0.03178517f, 
    0.02629339f, 0.04474749f, 0.03469812f, -0.04883269f, 0.06036159f, 0.05460360f, 0.07169761f, -0.05584397f, 
    0.08491101f, 0.07740972f, 0.02155841f, -0.09040499f, -0.11907237f, -0.09761164f, 0.11071002f, 0.22264388f, 
    -0.19209506f, -0.14758930f, -0.04826457f, -0.04113694f, 0.07447426f, 0.08708014f, 0.14841777f, -0.00970916f, 
    -0.01118403f, 0.14053021f, 0.02839517f, 0.01845651f, 0.00385898f, 0.04022668f, -0.05404421f, -0.04674739f, 
    0.31098318f, -0.00673862f, 0.10499649f, -0.00671263f, -0.16462779f, -0.15917189f, -0.01924662f, -0.27387860f, 
    -0.18793391f, 0.09649535f, 0.01771846f, 0.04081352f, 0.00037038f, -0.09095073f, 0.04285492f, 0.10810856f, 
    -0.01999231f, -0.06377525f, 0.18003491f, -0.04613934f, 0.01129079f, 0.25215313f, 0.11468832f, 0.10928375f, 
    -0.30750602f, 0.16081983f, -0.03964830f, -0.04707172f, 0.01769105f, 0.01003183f, 0.06562997f, -0.01494975f, 
    0.04369170f, 0.10419510f, -0.09502806f, 0.00440189f, 0.04693000f, 0.12117154f, 0.02753535f, 0.11314195f, 
    0.10066085f, 0.08725274f, 0.12683310f, 0.00237035f, 0.05842733f, 0.00978487f, -0.05110240f, -0.09272366f, 
    0.06048771f, 0.01478432f, 0.02128514f, -0.00356912f, -0.06113914f, -0.10034377f, 0.01870601f, -0.00499950f, 
    0.09364020f, -0.01307650f, 0.00700583f, -0.01842179f, 0.00578219f, -0.10173482f, -0.08855187f, -0.03414119f, 
    0.17782022f, 0.14501198f, 0.00090167f, 0.02050261f, 0.00834277f, -0.00141093f, 0.03796807f, 0.01060630f, 
    0.01827793f, 0.03553246f, 0.07105218f, 0.28377658f, -0.08821581f, -0.10602617f, -0.00266898f, 0.03186735f, 
    -0.04091428f, -0.06281526f, -0.18706082f, -0.01101510f, 0.11941276f, 0.05525747f, 0.07645497f, 0.05568266f, 
    0.04869647f, 0.07687955f, -0.01812433f, 0.00751280f, -0.00207445f, -0.07481646f, 0.09470835f, 0.15758918f, 
    -0.01848579f, -0.07193004f, -0.07351399f, -0.00259465f, 0.09769492f, -0.10077278f, -0.30005950f, 0.03050646f, 
    0.03574819f, 0.11824621f, 0.01210333f, 0.04357720f, -0.01975182f, 0.11524376f, -0.07033604f, -0.05235086f, 
    -0.00937925f, -0.08831204f, 0.04036903f, 0.19559297f, 0.07304773f, 0.02199997f, -0.29045469f, 0.03288459f, 
    -0.14875039f, 0.00943533f, -0.13995086f, -0.23064335f, 0.20980243f, -0.00456864f, -0.05267856f, -0.09815049f, 
    0.03544266f, -0.01028812f, -0.01522795f, -0.06187439f, -0.05235808f, 0.01773814f, -0.08095258f, -0.09390809f, 
    0.13436677f, 0.16895077f, -0.05311269f, 0.02555247f, -0.24785827f, -0.05713311f, -0.05474652f, 0.01800498f, 
    0.23276037f, 0.17206137f, 0.05110011f, 0.10429553f, 0.10425618f, 0.15998903f, -0.03986263f, -0.08795650f, 
    -0.04288498f, -0.04418117f, 0.12155486f, 0.00442847f, -0.09339276f, 0.14010151f, -0.07866644f, 0.00746226f, 
    0.20737083f, 0.15892725f, -0.24160510f, 0.01630138f, -0.24679737f, 0.05735412f, -0.04564745f, 0.07463498f, 
    -0.17629431f, 0.01189471f, -0.10098675f, 0.02293408f, 0.01407182f, -0.00249883f, -0.02152198f, -0.03690113f, 
    0.02343029f, -0.15558791f, -0.05525633f, 0.19568561f, 0.13407364f, 0.31131607f, 0.15990371f, -0.13975254f, 
    -0.26285970f, 0.03848109f, -0.02242086f, 0.14422470f, -0.04272063f, 0.14380307f, 0.02922034f, 0.09842527f, 
    0.05924579f, -0.04473850f, -0.07988615f, 0.01059226f, 0.04454145f, 0.00475098f, 0.04982343f, 0.06104651f, 
    0.10953756f, 0.03978085f, 0.16869429f, 0.09623653f, -0.10016411f, -0.02855476f, -0.01867778f, -0.00124056f, 
    0.09989005f, -0.08004636f, -0.01417369f, -0.00818500f, 0.03195557f, 0.11793704f, -0.02720611f, 0.00124949f, 
    0.01753591f, -0.10020350f, 0.03211034f, 0.12242673f, -0.03361869f, -0.18374754f, 0.22636713f, -0.02539823f, 
    -0.29385638f, -0.05104384f, -0.03313971f, 0.07988638f, -0.11542724f, 0.00636906f, -0.01484982f, -0.06817685f, 
    0.05359133f, 0.15353951f, 0.07762698f, 0.07320713f, 0.02670852f, 0.06419908f, -0.01798238f, -0.07864585f, 
    -0.66792828f, -0.28354841f, -0.02589162f, 0.14737031f, 0.18137692f, -0.06102918f, -0.02220935f, -0.06548733f, 
    0.07788160f, -0.08841039f, 0.14928088f, -0.05661470f, 0.03166362f, 0.01587543f, 0.09765857f, -0.16462712f, 
    -0.14142320f, 0.12968279f, -0.21173623f, 0.10700805f, -0.20232016f, 0.12298343f, 0.01553299f, 0.19882321f, 
    0.00209661f, 0.04645704f, -0.03561630f, -0.06651638f, 0.25861418f, 0.06095286f, 0.15893154f, -0.06035197f, 
    -0.03824256f, 0.02408780f, 0.08044729f, 0.02856158f, 0.02796930f, 0.02047289f, -0.02585804f, -0.01805933f, 
    0.37446514f, 0.17362837f, 0.21801117f, -0.09492614f, -0.09417493f, 0.00294703f, -0.08622681f, -0.18757759f, 
    -0.05004951f, -0.02133538f, -0.01431665f, -0.02789452f, 0.01612350f, -0.04159996f, -0.02418044f, -0.02948198f, 
    0.04858839f, -0.05673392f, 0.03759728f, -0.07758923f, 0.07085591f, -0.05737941f, 0.23707402f, 0.10848309f, 
    -0.36188877f, -0.04601029f, -0.05922685f, 0.19066894f, -0.02124548f, 0.04816911f, 0.08864447f, -0.01080147f, 
    0.05826228f, 0.14425717f, 0.00773050f, -0.04586478f, -0.00135598f, 0.02749204f, 0.02242161f, -0.01570808f, 
    -0.02714783f, -0.06685124f, -0.06420880f, 0.03808403f, 0.03220758f, -0.00386952f, 0.03433393f, -0.03476476f, 
    0.01092075f, 0.00629943f, 0.16531780f, 0.07106318f, 0.06806399f, 0.08646563f, 0.20206912f, 0.07092737f, 
    0.19447370f, 0.00836896f, -0.10397000f, 0.06248588f, -0.23603940f, 0.35698849f, -0.30529356f, 0.29647753f, 
    0.11632113f, 0.12277145f, 0.00595808f, 0.04639353f, 0.17907399f, 0.15439567f, 0.00013515f, -0.03401136f, 
    -0.03536784f, 0.00479477f, -0.01712873f, -0.08075508f, 0.03819269f, 0.12566654f, -0.10241254f, -0.05197990f, 
    -0.07461108f, -0.11326900f, 0.05094122f, -0.11990584f, 0.04936361f, 0.02137422f, -0.07434504f, -0.06800871f, 
    -0.01648344f, 0.03494506f, 0.06200562f, 0.22344998f, -0.05693012f, 0.15317030f, 0.04174514f, -0.03601692f, 
    0.01578385f, 0.13748451f, 0.02184678f, 0.05686194f, 0.02855379f, 0.02268799f, 0.21984242f, 0.09236044f, 
    -0.17576189f, 0.01491513f, -0.02124274f, 0.09231310f, 0.00685059f, -0.09928875f, 0.01322618f, 0.00604414f, 
    0.04187749f, 0.11637202f, -0.01979424f, 0.01488006f, 0.03705367f, -0.06452166f, 0.12647383f, 0.04532355f, 
    -0.13639916f, 0.11417317f, -0.04797764f, 0.10187704f, 0.02962556f, 0.03938440f, 0.08880375f, -0.13931996f, 
    -0.02850895f, -0.02250641f, 0.21096446f, -0.05025996f, 0.03145929f, 0.00157280f, 0.00874273f, 0.03304631f, 
    0.03356864f, -0.00231784f, -0.15414649f, 0.10584556f, 0.01241651f, -0.10073813f, 0.04887466f, 0.31812215f, 
    -0.09695598f, 0.02669328f, -0.05384645f, 0.14970885f, 0.03165989f, 0.16394043f, 0.16128196f, -0.00114687f, 
    0.14224795f, 0.10479174f, 0.07192110f, -0.08782662f, -0.04078367f, -0.05718856f, 0.08633755f, 0.11283066f, 
    -0.01307031f, -0.00184802f, -0.04627704f, -0.03589498f, -0.02207872f, 0.01414380f, -0.01527565f, 0.00683625f, 
    -0.03738855f, -0.04401270f, -0.00555722f, 0.00633614f, -0.02827984f, -0.00252751f, -0.04359279f, -0.03216730f, 
    0.01101498f, -0.02226840f, 0.01150016f, -0.00357687f, -0.01052572f, 0.01366825f, -0.01274962f, 0.02914644f, 
    -0.02509342f, -0.02626315f, -0.04560206f, -0.00874225f, 0.00166332f, 0.01607018f, -0.03943993f, -0.02310472f, 
    0.00308834f, -0.01855979f, 0.01209569f, -0.01415955f, 0.00513066f, 0.03071722f, -0.00982051f, -0.00060143f, 
    -0.00653289f, 0.02763596f, -0.01704293f, 0.02112784f, 0.02873927f, -0.02197689f, 0.00362204f, 0.00462022f, 
    -0.02078865f, -0.00205221f, 0.01826169f, -0.02773377f, -0.04023037f, -0.01132792f, 0.01552032f, 0.02117735f, 
    0.00240103f, -0.03636727f, -0.00271098f, -0.04343757f, 0.03150766f, -0.02653738f, -0.01132311f, 0.00064844f, 
    -0.03210375f, 0.02403458f, -0.01771895f, 0.01566722f, 0.00873886f, -0.02464053f, 0.02703348f, -0.03640460f, 
    -0.02394852f, 0.01697507f, -0.03595444f, 0.03043341f, -0.00698305f, -0.04382160f, 0.02520567f, -0.02788495f, 
    0.03187989f, -0.01979571f, -0.01345986f, 0.00628121f, -0.03424349f, 0.02322152f, -0.00169244f, -0.00097562f, 
    0.02570185f, 0.00638113f, 0.01482466f, -0.02471364f, -0.00893519f, 0.02886609f, 0.02692958f, -0.02447737f, 
    0.00806092f, 0.03055470f, -0.00961823f, -0.00480540f, -0.04275831f, -0.03033398f, -0.03820339f, 0.01922793f, 
    -0.00245707f, -0.04559505f, -0.02660771f, -0.03870902f, -0.03576587f, -0.01280520f, 0.01512191f, 0.03124411f, 
    -0.03631310f, -0.01501236f, -0.02489573f, 0.01578495f, 0.00393624f, -0.03250567f, -0.03822726f, -0.02771345f, 
    0.01258952f, -0.00125048f, -0.01389829f, -0.02470353f, -0.02518098f, -0.00811993f, -0.01352008f, -0.03067711f, 
    0.00734016f, -0.03378563f, 0.02711636f, 0.02394889f, 0.00310250f, -0.03335862f, -0.03177441f, 0.00328296f, 
    0.02378269f, 0.01806922f, 0.00904839f, 0.02345988f, -0.03914056f, -0.00249400f, 0.00426810f, 0.01468810f, 
    0.01956070f, 0.02469213f, -0.00388176f, 0.01628773f, 0.01900243f, 0.01899225f, 0.02337224f, 0.00057435f, 
    -0.01992006f, 0.02516521f, -0.02803483f, 0.00602806f, 0.00972666f, 0.01200002f, -0.00561037f, -0.02880458f, 
    0.00603228f, 0.02506813f, -0.02715785f, -0.02902642f, -0.00448544f, 0.02625703f, -0.00436627f, -0.03206930f, 
    0.01282983f, -0.01941613f, -0.00096759f, -0.01126882f, 0.02851679f, -0.02495122f, -0.02163321f, -0.02027032f, 
    0.02167701f, -0.04546715f, 0.02556579f, -0.02405753f, -0.00777234f, 0.00181879f, 0.01655482f, 0.02224452f, 
    0.02728743f, 0.02943989f, 0.01567595f, 0.02053800f, -0.01034692f, 0.01136480f, -0.02623374f, -0.02047175f, 
    0.00523915f, 0.01956651f, -0.02590992f, -0.04250920f, 0.01296114f, -0.04359011f, -0.02988671f, -0.03100270f, 
    0.01784433f, -0.00638214f, -0.01244970f, 0.02685361f, -0.02092276f, -0.02020659f, 0.00890431f, -0.01170582f, 
    0.02314314f, 0.00002805f, -0.02292923f, -0.01837511f, 0.01930446f, 0.03059529f, -0.00148292f, 0.00971999f, 
    -0.01954242f, 0.00547189f, -0.04553669f, 0.00833028f, 0.01302133f, 0.02067276f, -0.02459605f, 0.00596817f, 
    0.02090336f, -0.00152629f, -0.04288869f, 0.01898122f, -0.04215528f, -0.01844756f, -0.03879511f, -0.01368130f, 
    -0.02422563f, -0.03157922f, 0.00962830f, 0.00936753f, -0.03031456f, 0.03040171f, -0.03902154f, -0.02995575f, 
    -0.02003173f, -0.02407319f, 0.02581065f, -0.01422469f, 0.03267056f, -0.00480762f, -0.01265039f, -0.02880553f, 
    0.01289123f, 0.03263098f, 0.00625575f, -0.03172802f, -0.01070519f, -0.04261465f, -0.01537544f, 0.00931207f, 
    -0.01265210f, 0.01849204f, -0.03471236f, -0.03658296f, 0.02783238f, -0.03066495f, -0.01813551f, -0.00092991f, 
    -0.00314587f, -0.01878509f, -0.02398567f, 0.02588256f, 0.00336295f, 0.01269652f, -0.02014583f, -0.02327629f, 
    0.00613557f, -0.04158890f, -0.00296751f, 0.02289032f, -0.04158609f, -0.00401649f, -0.02312405f, 0.01618270f, 
    -0.01111932f, 0.01849010f, 0.00428307f, 0.00430231f, -0.00979535f, -0.01027256f, -0.02837984f, 0.02433078f, 
    0.02087180f, -0.01612494f, 0.02771069f, -0.00179313f, -0.02309466f, 0.00723840f, 0.01156572f, -0.00640237f, 
    0.02373778f, 0.01563357f, 0.00316124f, -0.01866780f, -0.00743518f, -0.01369652f, 0.01514865f, -0.00993771f, 
    0.00567237f, -0.00151892f, -0.01992703f, -0.00979362f, -0.00283586f, -0.01938434f, -0.01869678f, 0.01574696f, 
    0.01526088f, -0.02019170f, 0.01652128f, 0.02956471f, -0.02105204f, 0.01160611f, -0.00469716f, -0.00552380f, 
    -0.00198206f, 0.00511511f, -0.00971652f, -0.04361352f, -0.03742999f, -0.01149731f, -0.01293014f, -0.03247448f, 
    -0.03209792f, 0.02190319f, 0.00956435f, 0.02269057f, -0.01557341f, 0.00285410f, -0.01088386f, 0.01040196f, 
    -0.00927192f, -0.03207952f, 0.03242511f, -0.00819783f, -0.00662104f, -0.02831071f, 0.01431977f, 0.01823574f, 
    -0.00962603f, 0.02117743f, -0.00854151f, 0.01454354f, -0.04158095f, -0.01314978f, -0.03545080f, 0.00687745f, 
    -0.00013485f, -0.00896712f, -0.02864620f, -0.01748399f, 0.00373066f, 0.00041133f, -0.03153086f, 0.03028144f, 
    -0.02395280f, -0.02933874f, -0.00409145f, -0.03993067f, -0.01426027f, 0.02632680f, 0.02593585f, -0.02566315f, 
    -0.01971044f, -0.03852816f, 0.00236298f, -0.01873108f, -0.01054227f, -0.02338560f, 0.00951043f, 0.02016996f, 
    -0.02053710f, -0.04509246f, -0.02780912f, 0.01958161f, -0.00774944f, -0.03182731f, 0.01530713f, -0.02213806f, 
    -0.03833424f, 0.02477070f, -0.04069508f, 0.02405537f, -0.02647139f, -0.02253926f, -0.03270585f, -0.02551058f, 
    -0.04085772f, -0.03344000f, -0.00975222f, -0.02813195f, 0.03067769f, 0.01679302f, -0.00182488f, -0.04067027f, 
    -0.00159630f, 0.00957444f, -0.03120400f, -0.00670941f, -0.00810937f, -0.02536272f, -0.03394265f, 0.00521712f, 
    -0.01511838f, 0.02258655f, -0.04537871f, 0.01260787f, -0.00800518f, -0.03913105f, 0.00135197f, 0.01007481f, 
    -0.00790343f, -0.02697016f, -0.03460870f, -0.03819161f, 0.03089947f, -0.02953343f, 0.00863734f, -0.02417717f, 
    0.00650364f, -0.00222777f, 0.01652857f, -0.02883744f, -0.00616715f, 0.02569229f, -0.00115915f, -0.03581148f, 
    -0.00534637f, -0.04122926f, 0.00470525f, -0.04443078f, 0.01799214f, 0.02425763f, 0.02110420f, 0.01898688f, 
    -0.00800087f, 0.01850788f, -0.02607353f, 0.04236753f, 0.02997240f, 0.00381796f, -0.01235548f, -0.03625414f, 
    -0.00462331f, -0.03205343f, 0.02675707f, 0.02372410f, -0.01389427f, -0.00956349f, 0.02994315f, -0.03128868f, 
    -0.03787656f, -0.01045913f, -0.02422099f, -0.04080671f, 0.01036539f, 0.00234624f, 0.03251161f, -0.04071580f, 
    -0.01531010f, -0.02736981f, 0.00314698f, -0.04121486f, -0.00767744f, 0.00948802f, -0.03953521f, -0.02766803f, 
    -0.04239480f, -0.04175258f, -0.03179683f, -0.01038336f, -0.02959532f, 0.00611961f, -0.03358280f, -0.02730857f, 
    -0.02264655f, 0.00517920f, -0.01768070f, -0.04505879f, -0.00878309f, 0.00602310f, 0.02688776f, 0.01393214f, 
    0.01966262f, 0.01100807f, -0.02458042f, -0.02649532f, 0.01322835f, 0.02771827f, 0.00154770f, 0.02867396f, 
    -0.04033041f, 0.01666893f, 0.01596789f, -0.03830361f, 0.02827909f, 0.02935343f, -0.01204097f, -0.00508761f, 
    -0.01565989f, -0.04409831f, -0.03057904f, -0.00827753f, -0.02842269f, 0.00074808f, -0.02718684f, -0.00934302f, 
    0.00585398f, -0.02305114f, -0.01383219f, -0.01939342f, -0.02863020f, -0.00118934f, 0.00834817f, -0.04082229f, 
    0.02402699f, -0.00135739f, -0.02754056f, -0.01188680f, 0.03034992f, -0.02677377f, -0.02355535f, -0.02752632f, 
    0.03072695f, 0.00816953f, -0.03355701f, 0.00627989f, -0.04564306f, 0.02472536f, 0.01255675f, -0.01762101f, 
    -0.00588074f, -0.03181985f, 0.01704869f, -0.00416182f, -0.01971458f, 0.02244177f, -0.02414789f, -0.01492549f, 
    0.00194917f, -0.00162209f, 0.01919318f, 0.00456694f, -0.01099048f, -0.03316300f, -0.00242796f, -0.02144516f, 
    0.01791567f, 0.03104556f, 0.02723953f, 0.00352388f, -0.03396670f, -0.04281094f, 0.02249981f, 0.00886355f, 
    -0.03125766f, -0.02792080f, -0.02461598f, 0.02901665f, 0.01454089f, 0.00486410f, -0.03706022f, -0.03409303f, 
    -0.02066835f, -0.03638306f, 0.03134219f, 0.00984702f, -0.00991186f, -0.02612855f, -0.02697786f, -0.01653748f, 
    -0.00931696f, -0.03581008f, 0.02378671f, -0.03747297f, -0.00612461f, -0.01985482f, -0.02428424f, 0.00299995f, 
    -0.04282758f, -0.02674544f, -0.02554014f, -0.03863547f, -0.02896051f, -0.04561149f, 0.02740595f, 0.01397385f, 
    -0.03043432f, 0.03008575f, -0.03266832f, -0.02707507f, -0.00812091f, 0.01082419f, 0.00190132f, 0.02094884f, 
    -0.00357164f, -0.00857169f, 0.00087734f, 0.00431292f, -0.00486435f, 0.00439217f, 0.01163895f, -0.03949537f, 
    0.02103928f, -0.02940792f, 0.01666532f, -0.04518329f, -0.00830971f, -0.03724595f, -0.01600610f, 0.00094744f, 
    0.02362795f, -0.00698217f, -0.01673652f, -0.03841382f, 0.03087937f, 0.02004428f, -0.00630087f, -0.00805120f, 
    -0.01110058f, -0.03383125f, 0.00801156f, -0.01349638f, -0.02377066f, -0.02330176f, 0.01412549f, -0.02362985f, 
    -0.04093293f, -0.00481563f, -0.00905490f, -0.01010287f, -0.02235953f, 0.03273214f, -0.00282325f, -0.00701273f, 
    0.01202876f, 0.01467153f, -0.00051158f, 0.00179046f, -0.00151327f, -0.02306917f, -0.02372672f, 0.02809035f, 
    -0.03505845f, -0.01169279f, 0.03094047f, -0.00469865f, -0.02220160f, -0.01482700f, 0.01106724f, -0.00303795f, 
    -0.00049986f, -0.00105632f, 0.00998320f, 0.02689240f, -0.02373591f, -0.01086051f, -0.01183601f, -0.00404802f, 
    -0.03974773f, 0.00126495f, -0.03587684f, 0.02723187f, -0.04179563f, -0.02127718f, -0.02372098f, 0.03051819f, 
    -0.03234887f, 0.02712256f, 0.00275327f, 0.03325800f, 0.00556317f, 0.01989665f, -0.02973140f, -0.03266364f, 
    0.01995572f, 0.03222487f, 0.02301767f, -0.01371089f, 0.02222197f, -0.02081549f, -0.02218026f, 0.01118466f, 
    0.01689919f, 0.02394159f, 0.03050619f, 0.01869702f, -0.02133066f, -0.00961264f, -0.03015472f, -0.02771720f, 
    -0.04544995f, -0.01554141f, -0.03107762f, 0.01441718f, -0.01344667f, 0.01902825f, 0.01254746f, -0.00662084f, 
    -0.02231784f, 0.01936056f, -0.00845761f, -0.02818967f, 0.00883931f, 0.01060338f, -0.01924564f, -0.01904075f, 
    -0.02375574f, -0.01960544f, -0.01520821f, -0.01562435f, -0.03569673f, 0.02761063f, 0.02335347f, -0.04457591f, 
    0.00232373f, 0.00204630f, -0.00998600f, -0.02209586f, -0.02652774f, -0.00594824f, -0.03054344f, -0.03969808f, 
    0.00749306f, 0.03048405f, -0.02834037f, -0.01280592f, -0.04322075f, -0.00011597f, -0.00950755f, 0.02933086f, 
    -0.02234818f, 0.00638094f, 0.00700282f, -0.01659695f, 0.00466772f, 0.03111092f, 0.00535676f, 0.01548143f, 
    0.02996981f, -0.03347082f, 0.02136707f, 0.01562446f, 0.00186404f, 0.00746874f, -0.01120071f, -0.00279022f, 
    -0.00266550f, -0.03231196f, 0.00854932f, -0.00482659f, 0.02054478f, -0.00478706f, 0.00964385f, -0.04551053f, 
    -0.01001208f, -0.03007080f, 0.03288931f, -0.01030294f, -0.00003177f, -0.02122474f, -0.01127694f, 0.02811042f, 
    0.02650975f, 0.01597281f, -0.01527878f, -0.03087498f, -0.03332460f, -0.03753041f, -0.01653829f, -0.00664272f, 
    0.00282720f, -0.04290598f, 0.00385502f, 0.00936918f, -0.01357873f, -0.00881839f, 0.01622912f, 0.00125136f, 
    -0.01186915f, -0.00703769f, -0.04086055f, 0.00091195f, 0.00305510f, -0.00991645f, 0.02195050f, 0.02746038f, 
    -0.01370163f, -0.03604634f, 0.00901138f, -0.03420721f, -0.03501358f, -0.00855048f, -0.02802582f, 0.01840913f, 
    -0.02003958f, -0.03269644f, -0.04395421f, -0.03060743f, -0.04108289f, -0.00482687f, -0.00961835f, 0.01747249f, 
    -0.00590889f, -0.00541583f, -0.02095950f, 0.02097263f, -0.02251570f, 0.02425259f, -0.03655626f, -0.01186196f, 
    -0.00769654f, -0.02941852f, -0.01487146f, -0.03621956f, -0.02492424f, 0.01531004f, 0.03078956f, 0.00449515f, 
    -0.01131408f, 0.01370767f, -0.01066042f, 0.00773105f, -0.00324706f, 0.02704805f, 0.01916063f, -0.00436571f, 
    0.00088548f, -0.01604863f, 0.01397331f, -0.01754520f, 0.02888109f, -0.01924760f, 0.01358070f, 0.03348016f, 
    0.00554714f, 0.01041213f, 0.01235944f, 0.00466179f, -0.02897058f, -0.00251433f, -0.00110113f, -0.02066452f, 
    -0.02227710f, 0.00284165f, -0.00129726f, -0.04003652f, 0.01797967f, -0.03282120f, -0.04539137f, 0.01881749f, 
    -0.01445819f, 0.02490254f, 0.01338174f, -0.03020473f, -0.04359978f, -0.03294168f, -0.02959576f, -0.03708971f, 
    -0.00476929f, 0.01131650f, -0.03795217f, -0.03582732f, -0.04213806f, -0.00403039f, -0.02352775f, -0.03953245f, 
    -0.01564540f, -0.04383045f, 0.02117338f, -0.00434494f, -0.02783282f, -0.02232356f, 0.00519226f, -0.00913505f, 
    -0.00779648f, -0.03314729f, 0.01433916f, -0.01397898f, 0.03101227f, -0.02336822f, -0.00948213f, -0.00643984f, 
    -0.03739360f, 0.02021909f, -0.01031667f, -0.00425319f, 0.01822186f, -0.02150385f, 0.01943234f, -0.04033501f, 
    -0.00006225f, -0.03033883f, 0.00365376f, 0.00238986f, -0.03064881f, -0.01905369f, -0.03556184f, -0.00172403f, 
    -0.02601341f, -0.02668565f, 0.00524877f, 0.01095253f, 0.02454738f, -0.04419345f, -0.01498815f, -0.03786755f, 
    0.00828607f, 0.01263446f, -0.03027479f, 0.00169749f, -0.00188524f, 0.00566455f, -0.00020033f, -0.02249371f, 
    -0.00185682f, -0.01053694f, 0.01323602f, -0.02677226f, 0.02514180f, -0.00183974f, -0.00065480f, 0.03046552f, 
    -0.02887860f, -0.02551143f, -0.03117485f, -0.04039078f, 0.02031247f, 0.02807926f, -0.00292182f, 0.03137202f, 
    -0.01087000f, -0.00939135f, 0.03204272f, 0.02188800f, -0.00879379f, 0.02669727f, -0.03179661f, -0.02907683f, 
    -0.00985074f, -0.03653863f, 0.00385593f, 0.00256606f, -0.02366284f, -0.00455186f, 0.01122889f, -0.02836320f, 
    -0.02793645f, -0.02665646f, -0.03272760f, -0.02472735f, -0.01686426f, 0.01907113f, 0.02741353f, -0.01769322f, 
    0.03120853f, 0.02097996f, -0.00382746f, 0.01178685f, -0.02884560f, -0.01441905f, 0.02023084f, 0.03061959f, 
    -0.02817590f, -0.00016772f, -0.03348511f, -0.01111280f, -0.04420073f, 0.02696818f, -0.03421292f, -0.00967810f, 
    0.02273249f, -0.00833231f, -0.04505719f, 0.00129760f, -0.01047572f, 0.00298411f, 0.00731626f, -0.01527918f, 
    -0.04028622f, -0.02141933f, 0.03205482f, -0.03348244f, -0.02931535f, -0.00271222f, -0.02932338f, -0.04107638f, 
    0.02267318f, -0.03651636f, -0.00124577f, 0.02413442f, 0.01148217f, 0.00194170f, -0.00882701f, 0.00587218f, 
    0.02501979f, -0.02657990f, 0.02875000f, -0.04136182f, -0.04504040f, 0.00502652f, -0.00592344f, 0.02234568f, 
    -0.03693019f, -0.01714917f, 0.03193737f, -0.01223453f, -0.01797843f, -0.01763048f, -0.03060671f, 0.00066774f, 
    0.02193194f, 0.00434251f, -0.02165950f, -0.02246888f, -0.01855292f, 0.02007310f, -0.00375496f, 0.02094918f, 
    -0.02381208f, 0.00581156f, -0.00745841f, -0.00397548f, -0.03770122f, -0.04464634f, -0.00930916f, 0.00554273f, 
    0.01832144f, -0.00984582f, 0.02829575f, 0.02948510f, 0.00829571f, -0.02715713f, -0.01200660f, 0.02542736f, 
    -0.03061207f, 0.00030889f, -0.00102376f, 0.03248366f, 0.00834008f, 0.02564725f, -0.02343394f, 0.01810052f, 
    0.01665424f, -0.00182350f, 0.00860664f, 0.03011036f, 0.00033346f, 0.00886401f, -0.04099151f, -0.03241833f, 
    -0.02608107f, 0.01726708f, -0.03985972f, 0.03025382f, 0.00755561f, -0.01538778f, -0.02607905f, -0.00063517f, 
    -0.01937197f, -0.01382858f, -0.04234308f, -0.01560068f, 0.01859440f, -0.01260828f, -0.04424784f, -0.03963185f, 
    0.01060540f, -0.00707058f, -0.00832785f, -0.03716738f, 0.01698991f, 0.01880431f, -0.03175863f, -0.00732519f, 
    0.00140476f, -0.03237225f, 0.01351095f, -0.00146654f, -0.02858217f, 0.00580320f, -0.03118296f, 0.02205130f, 
    -0.02884966f, 0.02114781f, 0.00633826f, -0.03130973f, 0.00076555f, 0.00204262f, -0.04089569f, 0.01098843f, 
    -0.03337302f, -0.03046402f, 0.01512739f, 0.01712136f, -0.00651156f, -0.01260923f, -0.02558710f, 0.02612720f, 
    -0.02870256f, -0.00123170f, -0.02168907f, 0.00984280f, 0.00396228f, -0.03293864f, -0.01994612f, 0.01192435f, 
    -0.03732261f, 0.00397977f, 0.00075614f, 0.02521331f, -0.03770690f, -0.02783834f, -0.00087215f, 0.02010982f, 
    -0.02201704f, 0.00678119f, -0.01117522f, 0.01785289f, -0.03680791f, 0.01932575f, 0.00597937f, -0.03872764f, 
    -0.03988653f, -0.01446592f, -0.00997860f, -0.03929837f, -0.03865650f, -0.00815912f, 0.01005525f, 0.00623673f, 
    0.00875633f, -0.03701192f, 0.01540668f, -0.01418662f, 0.01933474f, -0.01032485f, 0.00261201f, -0.03204685f, 
    -0.02835869f, -0.00420472f, 0.00634339f, -0.00554036f, 0.02751075f, 0.01010023f, -0.03178431f, 0.00952522f, 
    -0.01879472f, 0.00961366f, -0.00655169f, -0.01513597f, -0.01336278f, -0.04513250f, -0.04322568f, -0.02961519f, 
    -0.01803210f, 0.00727264f, 0.00151878f, -0.00309235f, 0.02063891f, 0.03318300f, 0.03152734f, 0.01494646f, 
    -0.04467723f, 0.00506952f, 0.02473483f, -0.00083930f, -0.01095528f, -0.00086120f, -0.04371671f, -0.00471436f, 
    -0.03449719f, -0.03828514f, -0.03562293f, 0.01714603f, 0.02003703f, -0.04186617f, 0.00520963f, 0.02147508f, 
    0.00762915f, 0.02077411f, -0.04369232f, 0.00981551f, 0.00259607f, 0.02251558f, -0.02897254f, 0.01702011f, 
    -0.03418075f, -0.03170481f, -0.04485232f, -0.00217283f, -0.03217681f, -0.01032157f, -0.01797152f, 0.02142057f, 
    -0.02163106f, -0.02543091f, 0.01614237f, -0.03412117f, -0.03408516f, 0.00486060f, 0.01141453f, -0.03902823f, 
    -0.00177402f, -0.04157329f, -0.03330045f, -0.04132665f, -0.03667845f, 0.02976431f, -0.03877671f, 0.02018111f, 
    -0.04269584f, 0.01673366f, -0.04069435f, 0.00137817f, -0.00332220f, 0.00965416f, -0.03096706f, 0.02600915f, 
    0.02869849f, 0.00894809f, 0.02260506f, -0.01757000f, -0.01928568f, 0.02564069f, 0.01732926f, 0.01629735f, 
    -0.04253241f, -0.00558814f, -0.00056234f, -0.02919351f, 0.00630386f, 0.02172782f, 0.00598686f, 0.01447821f, 
    -0.00425235f, -0.00377391f, 0.03265401f, 0.01794324f, -0.02277282f, 0.03105740f, 0.02945888f, -0.01402246f, 
    -0.03351969f, -0.00873819f, 0.01802162f, 0.00150698f, -0.04061697f, -0.01569023f, 0.02662277f, -0.02557267f, 
    -0.02733522f, -0.00418603f, -0.00349676f, 0.02987022f, 0.00368504f, 0.01240567f, -0.04467744f, 0.00276112f, 
    -0.03508760f, 0.01810173f, 0.02138954f, -0.02199654f, -0.00229674f, 0.00564323f, 0.01711695f, 0.01922190f, 
    -0.02519451f, 0.02822432f, -0.01252242f, -0.03748183f, -0.02700599f, -0.03780741f, 0.02839574f, 0.01357049f, 
    -0.01320042f, 0.02284381f, 0.01699442f, -0.01130719f, -0.02321556f, -0.00567707f, -0.00498061f, -0.01944167f, 
    0.00809947f, -0.03195440f, -0.02196100f, 0.01840189f, -0.04980002f, -0.00512917f, 0.02626358f, -0.00629026f, 
    -0.03685093f, 0.00352765f, -0.01263744f, 0.02114704f, -0.04016255f, 0.01197130f, -0.01649122f, 0.02616685f, 
    -0.01911684f, 0.02069660f, -0.03546691f, -0.02172068f, -0.04555191f, 0.00696440f, -0.01204727f, 0.02750171f, 
    0.02555695f, -0.01923863f, -0.00610623f, -0.01440917f, 0.01808127f, 0.03473714f, -0.01539638f, 0.03105970f, 
    -0.01496274f, -0.04024448f, 0.02025421f, 0.03179684f, 0.00497792f, 0.01046850f, 0.01650940f, -0.00104515f, 
    0.01950860f, 0.03246367f, -0.02126564f, -0.03947099f, -0.00204190f, -0.02541174f, -0.00860712f, 0.02245074f, 
    0.00072461f, -0.04011364f, 0.00005057f, 0.02906765f, -0.00305161f, -0.03703548f, -0.03537437f, 0.00608282f, 
    0.02164646f, 0.00804481f, 0.00528035f, 0.01713058f, -0.02332641f, -0.02825565f, 0.00271311f, -0.01584623f, 
    -0.01764688f, 0.02968111f, -0.04747930f, 0.00050068f, -0.02780389f, -0.00614651f, 0.01561646f, 0.02635141f, 
    -0.03328660f, -0.01076468f, -0.01746094f, 0.01111614f, 0.00106990f, -0.00210562f, -0.02341448f, 0.00972315f, 
    0.02426790f, -0.02198165f, 0.01676036f, 0.00043159f, -0.01911607f, 0.02340303f, 0.00567591f, 0.02006360f, 
    -0.01082013f, -0.04590347f, -0.01849538f, -0.02141386f, 0.01428407f, -0.03156535f, -0.03648836f, -0.02844037f, 
    -0.03596449f, -0.01012046f, -0.02580115f, 0.01102328f, 0.01177487f, 0.01223994f, -0.00544423f, 0.00192637f, 
    0.02685421f, 0.00441026f, -0.02442810f, -0.02593153f, -0.03159401f, -0.00439743f, 0.00188778f, 0.00096588f, 
    -0.00842419f, -0.03356494f, 0.03212589f, -0.04038956f, -0.00554860f, -0.04484087f, 0.02205542f, -0.04124811f, 
    0.01695770f, -0.05089038f, -0.02601641f, -0.01500651f, 0.02833500f, -0.03484643f, -0.00464321f, -0.01995799f, 
    0.02514125f, -0.04512468f, -0.02613680f, -0.02514638f, 0.01975543f, 0.02287105f, 0.03084961f, -0.04067143f, 
    -0.04599967f, 0.00074812f, 0.00258434f, -0.01122554f, -0.03009456f, -0.00692578f, -0.03677852f, -0.04387919f, 
    -0.00321955f, -0.02176703f, -0.01072675f, 0.01552547f, 0.01788261f, -0.00014694f, 0.01549466f, 0.00405730f, 
    -0.02381240f, 0.02475374f, 0.00339745f, -0.00918697f, -0.03598125f, -0.01302114f, 0.02836752f, 0.00491430f, 
    -0.03671670f, -0.02978676f, -0.01230009f, 0.02629809f, 0.02789642f, -0.00478891f, -0.00496980f, 0.01253941f, 
    -0.03617129f, 0.01073099f, -0.01446127f, -0.02357305f, 0.03170566f, -0.01372312f, 0.01245415f, 0.00057036f, 
    -0.02615339f, 0.01117080f, 0.03069670f, 0.01275291f, -0.02812680f, 0.00961355f, -0.04342305f, -0.01765342f, 
    -0.03049111f, 0.02406077f, 0.01499227f, 0.02108542f, -0.00981592f, -0.03852814f, -0.03187323f, 0.02712873f, 
    0.01466411f, -0.04221928f, -0.00315279f, 0.01753141f, -0.01701614f, 0.02249270f, 0.01972151f, -0.01227846f, 
    -0.04796039f, 0.01274787f, -0.00183484f, 0.03699698f, -0.03350895f, -0.03181476f, 0.01505428f, -0.00722210f, 
    -0.00408817f, -0.01371440f, 0.00765393f, -0.02798778f, 0.00005165f, -0.02317637f, 0.03250615f, -0.01769890f, 
    -0.04055270f, 0.00079197f, -0.02771940f, 0.02808813f, -0.01816023f, -0.00948818f, -0.00433601f, -0.03420972f, 
    -0.00914357f, -0.03291272f, -0.03263247f, -0.01738286f, -0.01000689f, -0.03538286f, 0.02058599f, 0.00809514f, 
    0.00676346f, -0.03204081f, 0.00380908f, 0.02563402f, 0.02588006f, -0.02403937f, -0.00943327f, -0.02363450f, 
    0.01973983f, 0.02019373f, 0.01869405f, 0.00166401f, -0.02351787f, 0.03085490f, 0.00684381f, 0.00081035f, 
    -0.02915771f, -0.01045848f, 0.03355650f, -0.00838130f, -0.02636934f, 0.02889380f, 0.03442158f, -0.00087992f, 
    -0.04424397f, -0.03344531f, -0.00913145f, -0.01238498f, 0.00839295f, -0.01412494f, 0.00722001f, -0.00951390f, 
    -0.02987791f, -0.04147304f, -0.03932044f, -0.00337286f, -0.04494527f, -0.02009362f, 0.04118202f, 0.03716459f, 
    -0.02452808f, -0.00141644f, -0.00750407f, 0.00862418f, 0.00118563f, -0.02024089f, 0.02860875f, -0.00198796f, 
    0.00162747f, 0.01121327f, 0.01763059f, -0.01862011f, 0.02213169f, -0.02062832f, -0.02460258f, -0.03474063f, 
    -0.00375749f, -0.00729806f, 0.01828967f, 0.02235875f, -0.03994403f, 0.01243720f, -0.02273321f, -0.02990519f, 
    -0.01168060f, -0.02947858f, 0.00239147f, -0.00345373f, 0.01227761f, 0.01867471f, 0.00895562f, 0.02974906f, 
    -0.03808357f, 0.02266662f, -0.02212231f, 0.01204421f, -0.01962142f, 0.03418778f, -0.04812204f, -0.03132484f, 
    0.01911149f, -0.00655764f, -0.01438649f, -0.02505780f, -0.00416402f, -0.01508765f, -0.03604253f, 0.01761809f, 
    -0.03688974f, -0.01814100f, -0.01481698f, 0.02356948f, 0.01685837f, 0.03070436f, -0.02673747f, -0.04908459f, 
    -0.01864836f, -0.04180301f, 0.01970076f, -0.02914633f, -0.02091378f, 0.00700766f, -0.03821176f, -0.00400745f, 
    -0.01231750f, -0.00258900f, -0.03990703f, -0.02669145f, 0.02113113f, -0.02109927f, -0.03185252f, -0.00579097f, 
    0.00493622f, -0.04807114f, 0.00094528f, -0.01547593f, -0.03726454f, -0.01336007f, 0.00177655f, 0.01483287f, 
    -0.02121844f, -0.02762629f, 0.01760014f, 0.00065818f, -0.02974892f, -0.01591087f, -0.03684891f, -0.02342466f, 
    -0.02567594f, 0.01682565f, -0.01868493f, 0.01113979f, 0.01596946f, -0.01669454f, -0.03507886f, -0.03435519f, 
    -0.03152421f, 0.02896276f, 0.01175040f, -0.03035248f, 0.00285711f, 0.02792788f, 0.00516504f, 0.00192564f, 
    0.02049191f, -0.00675423f, -0.03093339f, 0.03184466f, 0.03135778f, -0.02927658f, -0.04044136f, -0.04038007f, 
    -0.00616234f, -0.04199132f, -0.02691261f, 0.01756702f, -0.02841431f, -0.01522148f, -0.04614075f, 0.02850949f, 
    -0.04135855f, -0.02098183f, 0.03235431f, 0.01440623f, -0.01303498f, -0.04179433f, -0.01181410f, -0.00442002f, 
    0.03366962f, -0.00005238f, -0.01514297f, -0.03142464f, -0.00913325f, 0.00740884f, -0.00716920f, -0.01957425f, 
    -0.02555367f, -0.03316688f, 0.03053323f, 0.01940350f, 0.01218222f, -0.00765222f, -0.01856168f, -0.00423853f, 
    0.01305021f, 0.01403018f, -0.02800819f, -0.03769666f, -0.03707430f, -0.03553711f, -0.01763027f, -0.04421256f, 
    -0.02410236f, 0.02892910f, -0.03501830f, -0.02420534f, 0.00625048f, -0.02054626f, 0.00772069f, -0.01742756f, 
    0.02915106f, -0.02511869f, 0.00216651f, -0.00068474f, -0.01369668f, -0.02046187f, -0.02929285f, 0.00959345f, 
    0.01890869f, 0.03459062f, -0.02057525f, -0.02108891f, -0.00251847f, -0.04193214f, -0.04861410f, 0.02437743f, 
    -0.02138744f, 0.03354820f, -0.03408924f, -0.03590330f, 0.00272007f, -0.00910485f, -0.03719135f, -0.00087673f, 
    -0.04504414f, -0.03007013f, 0.00899185f, -0.04660951f, 0.01352381f, -0.01228825f, -0.04600549f, -0.01535642f, 
    -0.01939850f, -0.03353453f, 0.02471484f, -0.00214293f, -0.01627100f, -0.01966435f, 0.00356581f, -0.01070180f, 
    0.00370531f, -0.03855669f, -0.00230364f, 0.00544754f, 0.02520772f, -0.05060823f, -0.04231121f, -0.04799956f, 
    -0.01725313f, -0.01634737f, -0.01054547f, -0.03274133f, -0.02135527f, 0.03650839f, -0.00172533f, 0.03204294f, 
    -0.00342272f, 0.00629407f, -0.02853034f, -0.03527527f, 0.00241283f, 0.01677620f, 0.00766560f, 0.03419230f, 
    -0.04298988f, 0.00651941f, -0.03502348f, 0.02823657f, 0.01324187f, 0.01029131f, -0.00903021f, -0.01406546f, 
    -0.03621417f, 0.03466887f, -0.00556170f, 0.01399221f, 0.02818223f, -0.01033204f, -0.03426458f, 0.03624644f, 
    0.01021193f, -0.01045747f, 0.00519578f, 0.02600770f, -0.04058849f, -0.00952384f, -0.03608390f, 0.03194879f, 
    0.02967242f, 0.01670235f, -0.02133573f, -0.02269101f, -0.02717214f, 0.01175533f, 0.02448769f, -0.00410026f, 
    -0.02015483f, -0.03591528f, 0.02055007f, -0.03372781f, -0.02131706f, -0.01316239f, -0.02766892f, 0.01289050f, 
    -0.05166668f, 0.01771550f, -0.03826856f, -0.00015031f, 0.01082044f, 0.00682857f, 0.01228886f, 0.02616337f, 
    -0.01952284f, -0.00240286f, 0.02651111f, -0.04687105f, -0.02149626f, 0.01949598f, -0.02326649f, -0.03643373f, 
    -0.03713365f, 0.01363548f, -0.03530202f, -0.03939678f, -0.00386538f, -0.00736854f, 0.00293560f, 0.01603624f, 
    -0.04211008f, 0.02720935f, 0.02349290f, -0.02945691f, -0.04729557f, 0.00099712f, -0.04118203f, 0.00989970f, 
    -0.00105005f, -0.03275064f, -0.03769744f, -0.01155766f, -0.03664580f, 0.02317731f, 0.02994494f, -0.04296043f, 
    -0.00114328f, 0.00118072f, 0.02514306f, 0.00628368f, -0.00257181f, 0.03035578f, -0.01897673f, 0.01448368f, 
    0.02547492f, 0.00248759f, 0.03447744f, -0.00682684f, 0.02856754f, -0.03372170f, -0.02549514f, -0.02299589f, 
    -0.01846520f, -0.01909177f, 0.01477266f, -0.03424320f, -0.04499917f, -0.01422108f, -0.01626814f, 0.00968100f, 
    -0.03342698f, -0.04833259f, 0.01291807f, 0.00251817f, 0.01076000f, 0.02152512f, 0.01292667f, -0.01182025f, 
    -0.03772933f, 0.02771321f, 0.01367973f, -0.02848580f, -0.03978975f, 0.00932604f, 0.02578712f, -0.03752803f, 
    -0.02102798f, -0.00943892f, -0.01573365f, 0.02933542f, -0.01355670f, -0.00912476f, 0.01469650f, -0.02741926f, 
    0.01998665f, 0.00214358f, -0.03106634f, 0.02765400f, -0.01819608f, 0.00263244f, 0.00929084f, -0.00015141f, 
    0.00338990f, 0.00081230f, -0.02734913f, 0.00570972f, 0.02335100f, 0.00524297f, -0.01342215f, -0.00054614f, 
    0.02828646f, 0.03151646f, 0.02380880f, 0.01767675f, -0.00810872f, 0.00525925f, -0.03224695f, -0.04361709f, 
    -0.00545022f, 0.00556202f, -0.00982768f, 0.02313713f, 0.00283991f, 0.01546610f, -0.01102981f, 0.00723077f, 
    -0.03400917f, 0.02070921f, 0.00360920f, -0.01571391f, -0.04002030f, 0.03060756f, -0.01198166f, 0.00456776f, 
    -0.03330166f, 0.01651682f, 0.00306455f, -0.03953201f, -0.02569649f, -0.03360699f, 0.03379427f, 0.01524130f, 
    0.02070167f, 0.01317976f, 0.01729836f, -0.03973743f, -0.04365195f, -0.00692828f, -0.00532433f, -0.00884816f, 
    0.01688138f, 0.02279820f, -0.02588880f, -0.03322761f, -0.02507001f, 0.02636842f, -0.00820795f, -0.01969353f, 
    0.00637540f, -0.00683206f, 0.01858960f, 0.02128321f, -0.02829575f, 0.01373560f, 0.00575997f, 0.03480323f, 
    -0.00066177f, 0.00032365f, 0.03109993f, -0.01712658f, 0.02087100f, -0.02589471f, -0.02272172f, 0.02714567f, 
    -0.02182870f, -0.00644016f, -0.03368373f, 0.02983070f, 0.02713401f, -0.01944365f, 0.01138409f, -0.03173330f, 
    0.01148472f, -0.04374903f, -0.01738115f, -0.01644552f, -0.00802075f, -0.02087393f, 0.01621396f, -0.00671609f, 
    -0.04312523f, -0.00925470f, -0.02960900f, -0.02125700f, 0.01433335f, 0.01174980f, -0.02569261f, 0.02538383f, 
    -0.00788847f, -0.02985305f, -0.01666967f, 0.01150488f, 0.02663289f, 0.03110100f, -0.00960107f, 0.02824645f, 
    0.01899653f, -0.01538482f, 0.00063750f, -0.01360227f, -0.03696670f, 0.00519044f, 0.02452095f, -0.00551165f, 
    0.02662188f, 0.02529151f, 0.00061898f, -0.01857062f, -0.02609639f, -0.00350576f, -0.03214394f, -0.00071006f, 
    0.01239353f, -0.00354008f, 0.01441847f, -0.01836045f, -0.03630487f, 0.02752216f, -0.00437548f, 0.00208822f, 
    -0.02709399f, 0.03348976f, -0.01232174f, 0.01562429f, 0.02447389f, -0.01701256f, 0.02259601f, 0.01429246f, 
    -0.02207204f, -0.02604099f, -0.04096938f, 0.02060237f, -0.00882771f, -0.02378914f, -0.04396541f, -0.02080128f, 
    0.01000288f, 0.02229678f, 0.01543872f, -0.03285578f, -0.03643879f, -0.01002334f, -0.00236515f, 0.01305090f, 
    0.01153229f, -0.02143192f, -0.04435885f, 0.00272687f, -0.02219887f, -0.00131448f, -0.02797480f, 0.01443013f, 
    -0.02502603f, -0.00736022f, -0.01614153f, -0.02901798f, 0.00080114f, -0.02482776f, -0.01852524f, -0.00738061f, 
    -0.00628731f, -0.00820772f, 0.00682403f, -0.02213806f, -0.00944843f, -0.02767527f, -0.02251965f, 0.00850368f, 
    -0.01381802f, 0.00669370f, -0.04240341f, 0.02034921f, -0.02016470f, 0.03285128f, -0.00647320f, -0.01434876f, 
    -0.00492621f, -0.00801627f, -0.03469159f, -0.03404831f, 0.02266394f, -0.02400487f, -0.03214592f, -0.02834602f, 
    -0.03515906f, 0.00064231f, 0.02617736f, -0.00405401f, 0.00128411f, -0.03306463f, -0.04300782f, -0.01861564f, 
    0.03232184f, -0.03807434f, 0.01268748f, -0.02110256f, -0.01431403f, -0.01247031f, -0.02386860f, 0.02515933f, 
    0.02461726f, -0.02208413f, 0.00833352f, 0.03101235f, 0.00299572f, 0.00555555f, -0.02342625f, -0.04494015f, 
    -0.03971647f, 0.02363659f, 0.00541843f, -0.01483485f, -0.00960166f, -0.04055537f, 0.03289272f, 0.03716835f, 
    -0.01139461f, 0.01574478f, 0.02486651f, -0.01368349f, -0.03708585f, -0.00564199f, 0.03129818f, 0.00528738f, 
    -0.00130081f, -0.01969724f, -0.02659233f, 0.00509453f, -0.04288916f, 0.00537946f, -0.02612042f, 0.00122585f, 
    -0.02530121f, 0.00108880f, -0.01989189f, 0.00181091f, 0.00868585f, -0.04114254f, -0.03443943f, -0.01705829f, 
    -0.03478430f, -0.02407453f, -0.02699947f, -0.00398084f, -0.04246849f, -0.04113112f, -0.00393943f, 0.00697007f, 
    0.03165526f, -0.04186230f, -0.03162592f, 0.03079908f, 0.03009180f, -0.01550994f, 0.00952112f, 0.02021720f, 
    -0.04424847f, 0.02432121f, -0.04292345f, -0.00941937f, -0.00433190f, 0.01855792f, -0.03142595f, -0.00716704f, 
    0.02463349f, 0.01364810f, 0.00127264f, -0.02499207f, -0.00429667f, -0.03158582f, -0.04137926f, -0.03506975f, 
    -0.02458719f, 0.03386481f, -0.00341162f, 0.02850686f, -0.02561797f, -0.00850290f, -0.01614793f, -0.00980413f, 
    0.00326978f, 0.02850889f, -0.00717363f, -0.01923051f, -0.04379221f, 0.03352793f, -0.01154955f, 0.00940413f, 
    -0.00075825f, 0.02274759f, 0.00952465f, -0.01496413f, 0.00422000f, -0.03617992f, 0.02793143f, 0.03001684f, 
    0.01358059f, 0.02636990f, -0.03916468f, -0.02520511f, 0.00396216f, -0.00032060f, -0.03324552f, 0.03272567f, 
    -0.02318827f, -0.00640475f, -0.01697970f, 0.00826806f, 0.03056387f, -0.02068999f, -0.01130136f, -0.00813817f, 
    0.02750687f, -0.01811471f, -0.01691452f, 0.02089121f, 0.01075694f, 0.01134534f, 0.00454275f, 0.02817416f, 
    0.03308587f, -0.00477817f, 0.01773586f, 0.02983184f, -0.03804787f, 0.02505669f, 0.01256672f, -0.03780682f, 
    -0.02461145f, -0.01728183f, 0.02252583f, -0.02234108f, 0.00091402f, -0.01836357f, 0.02232441f, -0.00418611f, 
    0.00058718f, -0.03311821f, -0.01792746f, -0.00364209f, -0.02495378f, -0.04088365f, -0.01598521f, -0.00034423f, 
    0.00234606f, -0.00915408f, 0.01453971f, -0.03479800f, -0.01822219f, -0.02616359f, -0.03145637f, -0.00003365f, 
    -0.00673272f, 0.00415687f, -0.00883100f, 0.00361778f, -0.03164473f, -0.00031048f, -0.00360727f, 0.02396994f, 
    -0.02136129f, -0.00796140f, -0.03748484f, 0.00305569f, -0.02638543f, 0.02118886f, 0.02837511f, -0.01008124f, 
    -0.03292544f, 0.00645171f, 0.01254318f, -0.00651019f, -0.00307903f, 0.00021667f, -0.01756551f, -0.01084186f, 
    -0.02155059f, 0.02243377f, 0.02496401f, 0.02121961f, -0.02460386f, 0.00559850f, 0.02269140f, 0.00100402f, 
    0.02409266f, 0.00698315f, -0.01959158f, -0.00885256f, -0.02437098f, 0.00378136f, -0.00351510f, -0.00846149f, 
    0.00875584f, -0.00793706f, -0.04199406f, -0.03206586f, -0.01218516f, 0.01967935f, 0.02648896f, 0.03587201f, 
    0.03415596f, -0.04450462f, -0.03866259f, -0.03625838f, 0.02671493f, 0.02603544f, -0.03938833f, 0.02555641f, 
    0.01952287f, -0.02631098f, -0.02050594f, -0.01311455f, 0.01910742f, 0.02442876f, 0.00574755f, -0.03375240f, 
    0.00762309f, -0.03128042f, 0.01317184f, 0.01601677f, 0.02443799f, 0.00441381f, -0.00289160f, -0.02455428f, 
    -0.02623885f, -0.03311979f, -0.02109642f, -0.01029198f, -0.03719292f, 0.02076150f, 0.00198083f, 0.00645454f, 
    0.00167941f, -0.03752950f, -0.02043284f, -0.02792358f, 0.03848356f, -0.02987255f, -0.02035175f, 0.02173122f, 
    0.00724131f, -0.01473773f, 0.01606653f, -0.03566476f, 0.00516430f, 0.02548175f, -0.00064628f, -0.04270911f, 
    -0.03422606f, -0.02350929f, -0.00209953f, -0.02879850f, -0.02566339f, 0.01044662f, -0.00718104f, 0.02529569f, 
    -0.00204179f, -0.03971872f, -0.02195259f, 0.00220277f, 0.01732280f, 0.01218641f, -0.01556232f, -0.01507442f, 
    -0.00975806f, -0.03370825f, 0.01394038f, -0.03631517f, -0.02937578f, 0.00352211f, -0.03904935f, -0.01472909f, 
    -0.02732490f, -0.00458582f, -0.02202073f, -0.03563417f, -0.01291419f, -0.02010791f, 0.00722362f, 0.01645290f, 
    -0.01468202f, 0.00575025f, 0.01295247f, -0.02729731f, -0.01604452f, 0.02614031f, -0.02772499f, -0.00555846f, 
    0.02792500f, -0.01511799f, 0.00544396f, -0.03477115f, -0.01655943f, -0.00396965f, -0.01652052f, -0.03548004f, 
    -0.03571421f, -0.01334560f, -0.02425544f, 0.01738611f, 0.01998800f, 0.01607081f, 0.02021765f, -0.03466592f, 
    -0.02666378f, -0.02210599f, 0.02737689f, 0.01007234f, -0.01194162f, -0.00297566f, 0.01325599f, -0.04051954f, 
    -0.02905162f, -0.00505775f, -0.01492879f, -0.04246777f, -0.02694042f, -0.02580246f, 0.01185912f, -0.02865306f, 
    0.01666423f, -0.01333199f, -0.02151152f, 0.01587613f, -0.00769327f, 0.00259724f, 0.00271360f, -0.02041866f, 
    -0.02706150f, 0.01740077f, -0.03244387f, -0.01300532f, -0.00406090f, 0.02359154f, 0.00805556f, -0.03026299f, 
    -0.01803421f, 0.01620802f, 0.02074154f, 0.02492488f, 0.02102221f, -0.03354574f, -0.00721118f, -0.03106811f, 
    -0.01653137f, -0.01606050f, -0.00338555f, 0.01830634f, -0.02218235f, -0.04241629f, -0.00100479f, -0.01778631f, 
    -0.03184943f, 0.02326018f, -0.03817403f, 0.01383602f, 0.02839151f, 0.01961707f, -0.01461349f, -0.03494500f, 
    0.02396528f, 0.01772430f, -0.02770989f, 0.02097033f, -0.03920073f, -0.03455595f, -0.01066855f, -0.04355223f, 
    0.03235762f, -0.03904473f, -0.01883073f, -0.04399507f, -0.01375543f, -0.01470940f, -0.02351026f, 0.01281228f, 
    0.00440168f, -0.01214865f, -0.03481214f, -0.03163813f, -0.02511924f, 0.00438143f, -0.01177194f, -0.03891092f, 
    0.03183313f, -0.03675968f, -0.03157419f, 0.00332232f, -0.00555795f, 0.02828395f, -0.03475422f, -0.01283742f, 
    -0.01044740f, -0.00896971f, 0.02963620f, -0.03986397f, -0.04252494f, 0.03356226f, -0.01678395f, 0.03352750f, 
    0.00337757f, 0.01565125f, 0.01715409f, -0.02560605f, -0.00210958f, 0.02445469f, -0.00704544f, 0.02689940f, 
    -0.02812702f, 0.00904925f, 0.02236585f, 0.00815090f, -0.02123668f, 0.02321028f, -0.00674117f, 0.03261775f, 
    0.03318336f, -0.03172378f, 0.00243666f, 0.00079098f, 0.02075036f, 0.00471864f, -0.01653687f, 0.01582943f, 
    0.01978037f, -0.03249144f, 0.00861177f, -0.00150594f, -0.02108376f, 0.03296209f, -0.04252401f, -0.00316358f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05195707f, -0.00456294f, 0.01071501f, 0.05688043f, 0.00570161f, -0.02110230f, 0.03068790f, -0.03023063f, 
    0.03265668f, 0.03062588f, 0.22379935f, 0.16264065f, 0.10890008f, 0.22899106f, -0.06594311f, 0.12009548f, 
    0.01818221f, 0.01376425f, -0.00268535f, -0.04827268f, -0.06627968f, 0.02581990f, 0.02505663f, 0.08979894f, 
    -0.03075316f, 0.02434110f, 0.00789728f, 0.11061779f, -0.03959176f, -0.03491939f, 0.01443356f, 0.02515848f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.53972781f, -0.37051186f, 0.05403392f, -0.32364044f, -0.03564711f, 0.09404043f, 0.04456175f, 0.17083041f, 
    0.08578497f, -0.06836997f, -0.20051023f, -0.26995122f, -0.40565559f, -0.09770746f, 0.20701201f, -0.41712585f, 
    0.10666732f, 0.08870943f, 0.24538542f, 0.31546870f, 0.31942320f, -0.09847353f, -0.61626512f, 0.17566332f, 
    0.01932806f, 0.20770550f, 0.29593155f, 0.07544535f, -0.04801169f, 0.02835260f, -0.15289693f, -0.13244624f, 
    -0.51051402f, -0.31073189f, -0.07237618f, 0.35278085f, 0.16106145f, 0.15189156f, 0.27134642f, -0.10894439f, 
    0.08974418f, -0.07277837f, 0.34518808f, 0.18792847f, -0.33482513f, 0.06339528f, -0.07985820f, 0.12866119f, 
    0.17138760f, -0.03319420f, 0.25124159f, 0.31388518f, -0.59856242f, 0.17624050f, -0.26247361f, 0.22571155f, 
    -0.11206380f, 0.00799781f, -0.01269012f, -0.06165551f, -0.16038850f, 0.13859393f, 0.00185805f, -0.10565943f, 
    -0.27326822f, -0.15745687f, 0.12633932f, -0.28678018f, -0.03809860f, -0.07956513f, 0.27783066f, -0.24821644f, 
    0.05523166f, 0.08545278f, -0.32811177f, 0.08369174f, 0.57230192f, 0.04815118f, -0.12624480f, 0.13897845f, 
    0.15526071f, 0.10656891f, -0.56438708f, 0.12738387f, -0.10994463f, -0.06292386f, 0.43261555f, -0.24321423f, 
    0.11326272f, 0.18644635f, -0.15113810f, 0.13657425f, -0.13792299f, -0.12155432f, -0.18029948f, 0.08543848f, 
    -0.02432235f, 0.39091754f, -0.00073777f, 0.22927652f, 0.14991641f, -0.11719106f, 0.16133983f, 0.12613110f, 
    0.11508254f, -0.06226842f, -0.59191835f, 0.09901991f, -0.12832181f, -0.29498428f, 0.08396436f, -0.41915569f, 
    -0.09916556f, 0.12745194f, -0.14357851f, 0.11639590f, 0.25016552f, 0.19174109f, 0.49403071f, -0.19479634f, 
    -0.08303059f, -0.16461937f, 0.15150100f, -0.46376511f, 0.10982180f, -0.06153884f, 0.01152427f, 0.05946067f, 
    0.16435641f, 0.19642250f, -0.16516228f, -0.12487610f, -0.14852677f, 0.16794381f, 0.01711371f, 0.16549407f, 
    -0.13617241f, 0.11633310f, -0.37530106f, -0.46593106f, 0.19584510f, 0.01821744f, -0.09438070f, 0.20074378f, 
    -0.15939814f, -0.14226936f, -0.29285970f, 0.06599141f, 0.20507495f, 0.17831120f, -0.75160134f, 0.07381862f, 
    -0.15630794f, -0.05907654f, -0.13993825f, 0.09634697f, -0.06987162f, -0.09034030f, -0.07488811f, -0.13356967f, 
    0.10510529f, -0.25812355f, 0.16087167f, -0.76754361f, -0.11932902f, 0.05899037f, -0.14430678f, 0.33314252f, 
    0.04110682f, -0.00869747f, 0.06338108f, 0.08018491f, -0.16294235f, 0.30211905f, 0.39962101f, -0.00048019f, 
    -0.01985402f, 0.04297561f, 0.18634023f, -0.42325616f, -0.06212740f, -0.02365461f, -0.08095443f, -0.10753608f, 
    -0.11208872f, -0.35711023f, -0.11162827f, 0.19802178f, -0.06262737f, 0.13474457f, -0.18304944f, 0.07308128f, 
    0.27602497f, 0.18771037f, 0.01777832f, 0.09247535f, -0.10189065f, -0.14436974f, -0.16385217f, -0.71818417f, 
    0.06551541f, -0.03478748f, -0.21829334f, 0.24261013f, -0.07165501f, 0.04298817f, 0.39750391f, 0.33005425f, 
    -0.16200507f, 0.12256034f, -0.46715489f, -0.42767873f, -0.85183609f, -0.95359766f, -0.04874355f, -0.03047046f, 
    -0.08137350f, 0.21873218f, -0.26231194f, -0.00656754f, 0.12520449f, 0.14980252f, -0.08219531f, -0.11792407f, 
    -0.01866372f, -0.12646616f, -0.03558242f, 0.09832624f, -0.00403409f, 0.00017146f, 0.07441602f, 0.32997951f, 
    0.12776521f, 0.04277621f, -0.22878753f, -0.04940610f, 0.33557546f, -0.62167215f, 0.14646691f, 0.15880276f, 
    -0.17377108f, -0.14734462f, 0.30143791f, -0.29443130f, 0.24609835f, -0.61077750f, 0.03426022f, -0.29034019f, 
    -0.00223099f, 0.09095796f, -0.17814673f, -0.35256147f, 0.11053105f, -0.04565250f, 0.05814727f, 0.06820837f, 
    0.30003050f, -0.24992429f, 0.16408686f, -0.49750173f, 0.14469582f, -0.10922741f, -0.17331620f, 0.15612461f, 
    -0.08983691f, 0.13258661f, 0.06419810f, 0.24867599f, 0.31058717f, -0.48314297f, -0.43271214f, -0.39613128f, 
    0.13451551f, 0.03097198f, 0.13809392f, -0.51782978f, -0.37100631f, -0.27922410f, 0.22044972f, 0.11894841f, 
    -0.01250202f, 0.12453397f, 0.44973099f, 0.09513527f, -0.04829140f, 0.08025917f, -0.04783086f, -0.00292085f, 
    0.23973572f, -0.59461564f, 0.09379620f, 0.47337210f, -0.11613797f, 0.05870360f, -0.27083358f, -0.01457993f, 
    0.10157794f, -0.11302774f, 0.22507183f, -0.13112451f, 0.06276718f, 0.30408087f, 0.14633961f, -0.07841667f, 
    0.05845660f, -0.01901279f, -0.57614106f, -0.19565804f, -0.07882254f, -0.06981403f, -0.34169093f, -0.60178328f, 
    0.12345445f, 0.29754788f, -0.72727430f, 0.24758260f, 0.11127971f, 0.09842636f, 0.15805571f, 0.12024535f, 
    0.24184009f, 0.55677640f, 0.16190913f, -0.30998784f, -0.05217645f, 0.08698044f, -0.45235148f, -0.12524462f, 
    0.05705637f, -0.08211641f, -0.38156173f, 0.33518249f, -0.14437535f, 0.22148941f, -0.50286055f, -0.35771659f, 
    0.12463417f, 0.08384602f, 0.25880486f, 0.13555652f, -0.50153029f, 0.08764018f, -0.04194890f, 0.02754863f, 
    0.03495422f, 0.16936857f, -0.29035595f, -0.31150609f, 0.05007739f, -0.00754173f, 0.14791326f, 0.07062167f, 
    0.31086230f, 0.15753517f, 0.07525524f, 0.10515241f, 0.10744186f, 0.03571983f, -0.01306468f, -0.42199790f, 
    -0.05013643f, 0.02420340f, 0.12026086f, -0.13904983f, -0.66087842f, -0.14500195f, -0.32547644f, 0.15774468f, 
    0.01563607f, -0.03468872f, 0.13465372f, -0.37160388f, 0.51265168f, -0.41431242f, 0.38573340f, 0.35921615f, 
    -0.06726547f, -0.06489959f, -0.41511780f, 0.04083891f, -0.14183444f, -0.01266716f, 0.00435735f, 0.10947050f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05478697f, 0.09763185f, -0.07683190f, -0.03779957f, -0.15426224f, 0.16927877f, 0.08013047f, -0.27361599f, 
    0.05877499f, 0.19950305f, -0.00529797f, -0.03084098f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
