#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.45741624f, 0.35135821f, 0.37970489f, 0.03715238f, 0.19306134f, 0.09072098f, 0.49528876f, 0.14050031f, 
    0.25755569f, 0.39833692f, 0.20261201f, 0.07804952f, -0.14422907f, -0.40318885f, -0.34577009f, -0.43350610f, 
    -0.24849761f, 0.00542732f, -0.19012739f, -0.48087740f, -0.01235794f, 0.41384172f, 0.15658775f, -0.15797146f, 
    0.06050732f, -0.01714822f, 0.60468018f, 0.80030560f, -0.64412981f, -0.56428659f, -0.36157355f, 0.18430611f, 
    -0.29376972f, -0.59938502f, -0.37864009f, 0.10355847f, 0.46034029f, -0.08037504f, 0.21942940f, 0.05687265f, 
    0.14648977f, 0.06760491f, -0.08409656f, -0.05632062f, -0.08782732f, -0.02790792f, 0.04419266f, 0.18919836f, 
    -0.01429546f, 0.32160372f, 0.15360905f, 0.64752060f, -0.72589093f, 0.57070351f, -0.69536924f, 0.45249683f, 
    -0.36456704f, -0.05228708f, 0.18375665f, -0.16779231f, -0.11378777f, 0.20473783f, 0.16119124f, -0.04521121f, 
    -0.17328732f, -0.01869749f, -0.08309130f, 0.10386838f, 0.22237380f, -0.13367993f, -0.14556831f, -0.03600341f, 
    0.07216229f, -0.23475450f, 0.03731723f, 0.82695794f, 0.63732141f, 0.06458098f, -0.19902524f, -0.52257931f, 
    0.02815727f, 0.24865998f, 0.13848495f, 0.11245032f, 0.71697468f, 0.10484080f, 0.08349254f, 0.16698785f, 
    -0.15613550f, -0.08900701f, 0.11476168f, -0.12721989f, -0.16994037f, -0.16304892f, -0.12254343f, 0.25376183f, 
    -0.14436491f, 0.22225866f, -0.05738775f, -0.10917905f, -0.93423134f, -0.39527899f, 0.02507676f, -0.24495178f, 
    -0.31939167f, 0.62275207f, 0.58829325f, 0.19789501f, -0.22648050f, 0.12476095f, -0.24389729f, -0.04324946f, 
    0.18933752f, 0.13747968f, 0.37165213f, -0.18911506f, 0.08308313f, -0.00816527f, -0.04190453f, -0.13446452f, 
    0.09106352f, -0.01637378f, -0.01258696f, -0.02604435f, 0.12900931f, 0.29570681f, -0.07541639f, -0.67989892f, 
    -0.56489050f, -0.56573433f, 0.00788757f, -0.10864353f, -0.11131838f, -0.07587671f, 0.35134593f, 0.22387269f, 
    -0.30652016f, -0.11705387f, -0.08750036f, 0.22386140f, 0.02641805f, 0.13234739f, -0.12760708f, 0.24883512f, 
    0.57994241f, -0.13906832f, 0.08772054f, 0.02151359f, -0.06015800f, -0.10888103f, -0.20448716f, -0.80148518f, 
    -0.07510921f, 0.52218348f, -0.39546868f, -0.21834855f, -0.09150106f, 0.19259307f, -0.36687449f, -0.00533767f, 
    -0.10620740f, -0.22129439f, -0.00916569f, 0.30363449f, 0.06899316f, 0.22196142f, -0.08318555f, -0.01795752f, 
    0.19371010f, 0.28213945f, 0.29118243f, 0.15868203f, 0.20524338f, 0.09966860f, -0.25292787f, -0.54477358f, 
    -0.18437810f, -0.58497828f, -0.05086108f, -0.03495099f, -0.47904772f, -0.56385881f, -0.28233376f, -0.58735287f, 
    0.12534608f, 0.27702084f, 0.15820359f, 0.00349580f, 0.10796140f, 0.26805887f, 0.26990366f, -0.30249023f, 
    -0.13691019f, 0.14889649f, 0.10944679f, -0.10576392f, -0.12248853f, 0.13638456f, 0.15339708f, -0.08291084f, 
    -0.82676029f, -0.09191658f, 0.50672454f, 0.42840001f, 0.30514786f, -0.06303543f, 0.74538547f, 0.22670111f, 
    -0.57109380f, 0.34843349f, -0.36059213f, -0.34394205f, 0.34781992f, -0.09432948f, -0.16947086f, -0.10855217f, 
    -0.05060753f, 0.01806979f, 0.05095679f, -0.14948398f, 0.18125857f, -0.05325333f, -0.38712305f, 0.00131168f, 
    -0.09028089f, 0.83547187f, 0.73562020f, -0.27963328f, -0.13808997f, -0.21942234f, -0.17831212f, 0.35593444f, 
    -0.46801490f, -0.21592805f, 0.07821512f, 0.02719443f, 0.30817759f, 0.08900156f, 0.19587997f, -0.06104271f, 
    0.04932715f, -0.08183860f, 0.04208315f, 0.35703883f, -0.02294078f, -0.33265722f, -0.10827074f, -0.13645658f, 
    -0.12337208f, 0.13342369f, 0.40726542f, 0.41317287f, 0.61027849f, 0.27114952f, 0.36881721f, -0.54441512f, 
    -0.25517172f, -0.02418674f, -0.53576201f, -0.44684559f, 0.07417063f, 0.04649808f, -0.15217516f, 0.13505934f, 
    0.33633035f, 0.11078572f, 0.07233964f, 0.28781977f, -0.12242045f, 0.25287387f, 0.03053264f, 0.20233475f, 
    0.11913820f, 0.28192151f, 0.23374188f, -0.33743045f, -0.39208129f, -0.46813715f, -0.55235869f, -0.08184613f, 
    0.48421976f, 0.67210841f, -0.30664983f, 0.20579238f, 0.37073013f, 0.12227457f, -0.04445949f, 0.01260651f, 
    -0.14298339f, -0.15801531f, 0.19054714f, -0.02876684f, 0.21956727f, -0.04331775f, 0.00231327f, -0.26978508f, 
    0.18856154f, -0.05455423f, 0.09354461f, 0.03878965f, -0.25479725f, -0.29784283f, -0.38140580f, -0.32370940f, 
    -0.14411898f, -0.30311355f, 0.67355180f, 0.27233905f, -0.66884428f, 0.08416030f, 0.41271588f, 0.25513178f, 
    -0.08037124f, 0.19939916f, 0.18986376f, -0.28740913f, -0.18958402f, -0.30950269f, -0.09127557f, -0.37811387f, 
    0.04438429f, 0.10551895f, 0.17579952f, -0.34720963f, 0.31545258f, 0.80969995f, -0.07852823f, 0.42137137f, 
    0.07437166f, 0.17031054f, -0.45685840f, -0.77721006f, -0.14444998f, -0.14444959f, 0.08542161f, -0.28005534f, 
    0.33715761f, 0.18793376f, 0.28400838f, -0.16109517f, -0.06957673f, 0.08715544f, 0.10643701f, 0.15884863f, 
    -0.17719914f, -0.19158097f, 0.03692535f, -0.03218674f, -0.26225531f, -0.22854784f, -0.28702587f, -0.37661406f, 
    -0.50424713f, -0.28650898f, -0.30238992f, 0.52822030f, 0.61480975f, -0.18230136f, 0.41745359f, 0.47222495f, 
    0.11450303f, -0.32614839f, -0.13998544f, -0.31093138f, 0.00335222f, -0.07877807f, 0.05525201f, 0.10780525f, 
    0.29620895f, -0.13820246f, 0.09524973f, -0.35963085f, -0.25311211f, 0.03260360f, 0.07582763f, -0.87049443f, 
    -0.02546895f, -0.39330503f, -0.31669030f, 0.13135600f, -0.00837989f, 0.53873861f, 0.38662484f, 0.00578744f, 
    0.58219671f, 0.10458855f, -0.16376054f, 0.38494891f, -0.34918579f, 0.14323734f, 0.08040178f, -0.07746715f, 
    -0.02868568f, 0.03152421f, -0.27504146f, 0.04456976f, 0.02752645f, 0.12143806f, 0.21064760f, 0.03770146f, 
    -0.37814212f, -0.39009866f, -0.52863181f, -0.26341295f, -0.02831350f, -0.10735077f, -0.71974874f, -0.14244840f, 
    0.36961919f, -0.49688083f, -0.26464391f, 0.04709568f, 0.34171638f, 0.21991870f, -0.01486769f, 0.31401190f, 
    0.13470994f, -0.12243865f, 0.04513303f, -0.04008873f, -0.03740554f, -0.04217532f, 0.07713176f, 0.06753820f, 
    -0.17104259f, 0.52506477f, -0.21476322f, -0.39174336f, -0.06939835f, -0.05813275f, -0.43686828f, -0.04678976f, 
    0.31152886f, 0.08513135f, 0.31437668f, -0.04748955f, 0.07400405f, -0.06526416f, 0.01859209f, 0.14841355f, 
    0.09087036f, 0.21720529f, -0.00438809f, -0.47536328f, 0.12935621f, -0.31162134f, -0.29991052f, 0.02543842f, 
    0.49471691f, -0.04430744f, -0.15546118f, -0.45889640f, -0.48042271f, 0.07466766f, -0.40736479f, -0.43469277f, 
    0.29197845f, 0.07145709f, 0.01789393f, 0.26176944f, 0.00829707f, 0.48037955f, 0.03728148f, 0.07533434f, 
    -0.08443035f, -0.25633362f, 0.11878896f, 0.32286033f, 0.01666468f, -0.07837995f, 0.24448813f, 0.10822595f, 
    0.06124571f, -0.02713949f, -0.00283586f, 0.97509444f, 0.30900133f, -0.37469244f, 0.06581943f, 0.44764009f, 
    0.57248819f, 0.24918260f, -0.63988757f, 0.02096821f, -0.08548195f, -0.18035385f, 0.09293725f, -0.15617476f, 
    0.11816189f, -0.21585761f, -0.00068351f, -0.13552858f, -0.21968578f, 0.01625453f, 0.15734470f, 0.05563451f, 
    -0.00020885f, 0.01683995f, -0.13213874f, 0.28814727f, 0.29747528f, 0.53569800f, 0.76730376f, 0.29909247f, 
    0.24402751f, -0.35766983f, 0.04561973f, -0.19728285f, -0.23946001f, 0.41733655f, 0.27186027f, 0.20129310f, 
    -0.05655912f, -0.10660437f, 0.21702059f, -0.13103618f, -0.25496811f, -0.00827412f, 0.13280086f, 0.13524644f, 
    -0.20393172f, -0.06110030f, 0.10548190f, -0.16631697f, -0.00977294f, -0.09228681f, -0.91468883f, -0.51978773f, 
    0.16274355f, 0.64503694f, 0.00157443f, 1.00468373f, 0.16135806f, 0.27268180f, 0.21010698f, 0.03610500f, 
    -0.12251904f, -0.40995601f, 0.04792447f, -0.19339038f, 0.07736062f, 0.01189617f, -0.00801035f, 0.07065833f, 
    -0.00069431f, 0.14184666f, 0.05678022f, 0.06862654f, 0.09885535f, -0.21036255f, 0.57670808f, 0.20845118f, 
    -0.89889300f, -0.51570767f, -0.65042669f, 0.17609879f, -0.10219958f, -0.21370241f, -0.40381372f, -0.18889593f, 
    -0.08995382f, 0.18585096f, 0.32884485f, 0.26678294f, -0.00402330f, -0.31456032f, 0.06931300f, 0.10008655f, 
    0.14988998f, -0.18729660f, -0.09119573f, 0.22983497f, -0.14791296f, -0.06381694f, 0.16960385f, 0.24844934f, 
    0.08284631f, 0.25314981f, 0.88029879f, 0.49216422f, 0.06959090f, 0.36951014f, -0.27805808f, 0.54621404f, 
    0.21030921f, -0.35862154f, -0.11569250f, -0.37146667f, 0.07988702f, -0.32675156f, -0.02184633f, -0.16243008f, 
    -0.12720908f, -0.25667840f, 0.25559649f, -0.11440138f, 0.19864680f, -0.00374770f, 0.01768048f, -0.23619966f, 
    -0.90523177f, 0.76482302f, 0.05696617f, -0.46121404f, 0.12609014f, 0.45933768f, -0.28784522f, -0.70119560f, 
    0.20007883f, -0.27760765f, -0.12926646f, -0.13509926f, -0.50392330f, 0.05174424f, -0.13413213f, -0.27223080f, 
    0.14408828f, -0.25098044f, -0.27253464f, -0.29468212f, 0.17106742f, 0.15570244f, 0.11744679f, 0.04325558f, 
    -0.05017198f, 0.65766668f, 0.20014103f, 0.19535485f, 0.25303298f, -0.11248323f, -0.23986170f, 0.28109181f, 
    -0.40095532f, -0.25075600f, 0.36322197f, 0.41268405f, 0.17064895f, 0.16150978f, 0.16720273f, -0.49593335f, 
    0.11520579f, 0.30272263f, 0.31245553f, 0.05613746f, -0.11696911f, -0.03387492f, 0.11050088f, 0.05075492f, 
    0.30389056f, -0.00509322f, 0.20928943f, 0.38708517f, 0.52912229f, 0.36412409f, 0.41276792f, -0.06156472f, 
    0.02462658f, -0.02757562f, 0.23505032f, 0.16402332f, 0.12670708f, -0.23454027f, -0.14230250f, 0.28286976f, 
    0.15381667f, 0.05117084f, -0.35263523f, -0.09731358f, 0.07971308f, -0.36683702f, 0.33613431f, 0.08076670f, 
    0.10494397f, 0.15085088f, 0.19263373f, 0.48449811f, 0.51915789f, 0.46965304f, 0.85434377f, 0.03121259f, 
    0.26667911f, 0.00106104f, -0.38485354f, -0.15714674f, 0.13573144f, -0.08822075f, 0.20224397f, 0.01585062f, 
    -0.07325106f, -0.10211021f, 0.16751894f, -0.10976540f, 0.11011848f, -0.02428474f, -0.26922217f, 0.05350382f, 
    -0.11540228f, -0.07469178f, 0.11423970f, 0.05612895f, -0.01069250f, -0.72579336f, 0.08230237f, 0.36374524f, 
    -0.27806619f, -0.91310388f, -0.07435053f, 0.53622085f, -0.30880761f, -0.13479987f, 0.35335287f, -0.00445397f, 
    0.10412050f, -0.21438292f, 0.23494098f, -0.11686821f, 0.20288672f, -0.00227197f, -0.19129208f, -0.31526306f, 
    -0.15186395f, -0.01252615f, -0.20991208f, -0.02978582f, 0.18521450f, -0.42937970f, -0.08272944f, 0.47374189f, 
    -0.37238044f, -0.40309188f, -0.05177569f, 0.14671129f, -0.00181743f, 0.24072331f, 0.17247084f, 0.61713469f, 
    0.06746858f, -0.50908953f, -0.29400656f, 0.02997127f, 0.11006244f, -0.12350474f, 0.23705080f, 0.04086546f, 
    0.15362355f, -0.08725885f, -0.08924937f, -0.33109787f, -0.17204717f, -0.30453530f, -0.59942222f, -0.31146097f, 
    -0.01304470f, 0.11757239f, 0.35757798f, 0.16655855f, 0.08858277f, 0.31680650f, -0.25915399f, -0.29869092f, 
    0.25998944f, -0.04360424f, 0.05202234f, 0.18589129f, 0.19472602f, 0.47659835f, 0.32063696f, -0.13679938f, 
    0.10881103f, 0.26929161f, -0.21619479f, -0.24251260f, -0.09282798f, -0.00534718f, 0.39532959f, -0.68227744f, 
    0.95294142f, -0.31893119f, -0.73018819f, 0.30783084f, -0.26810291f, 0.31558841f, 0.32742387f, -0.06380160f, 
    0.01800265f, -0.29300880f, -0.05394021f, -0.02538072f, -0.21485749f, -0.12253468f, 0.25784117f, -0.09693488f, 
    0.05130733f, 0.04997622f, -0.23618776f, 0.01101143f, 0.20605993f, 0.10760482f, -0.25932714f, 0.04434300f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16602325f, 0.12761699f, -0.02974836f, 0.18796401f, 0.02539894f, 0.14357822f, 0.04569931f, 0.28155756f, 
    0.06240112f, 0.15174121f, 0.07710662f, 0.13362992f, 0.13936166f, 0.07940541f, 0.13261153f, 0.08004376f, 
    0.18219101f, 0.22294354f, 0.30777961f, 0.29987022f, 0.03347867f, 0.19448315f, 0.01019958f, 0.04350308f, 
    0.10277636f, 0.17634121f, 0.27409077f, 0.14288847f, 0.00795450f, -0.02961883f, 0.23463479f, 0.19659901f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00394912f, 0.00127298f, 0.04024027f, -0.05218023f, -0.05195037f, -0.04139168f, -0.02239154f, -0.03181798f, 
    0.01794043f, -0.01798437f, 0.01718307f, -0.03188011f, 0.01447715f, 0.04385991f, -0.01564137f, 0.02789988f, 
    -0.04991983f, -0.05116656f, -0.02047938f, -0.04910671f, 0.02498414f, 0.01382140f, 0.02126608f, -0.03672004f, 
    0.03585985f, -0.01514903f, -0.03645958f, -0.03975196f, 0.00179439f, 0.00950759f, -0.04695547f, 0.01289267f, 
    -0.00301232f, 0.02031462f, 0.02162797f, -0.02727116f, -0.00515192f, -0.05227699f, 0.01183976f, -0.00446486f, 
    0.01498113f, -0.00414886f, 0.03772645f, -0.03707033f, -0.04001428f, 0.04474093f, -0.03577260f, -0.03450119f, 
    -0.01101180f, 0.03752542f, -0.04993563f, -0.03246334f, 0.01152822f, 0.04460051f, -0.05057421f, -0.01306158f, 
    -0.02410743f, -0.01619905f, -0.03176764f, -0.03097130f, -0.04289867f, -0.01079320f, -0.01785171f, 0.01555652f, 
    0.00205722f, -0.01019226f, -0.05580257f, 0.00069075f, -0.01743169f, 0.01544616f, 0.02635621f, 0.03577367f, 
    -0.04043224f, -0.05287208f, -0.05692967f, -0.03046381f, 0.03695922f, 0.01258050f, -0.03526518f, 0.01951260f, 
    -0.04176963f, -0.03335461f, -0.02476115f, -0.03266431f, 0.01089399f, -0.02000664f, 0.03030675f, 0.03682478f, 
    -0.00286839f, -0.05265915f, 0.00058141f, -0.00154976f, -0.02645653f, -0.00194698f, -0.05366711f, 0.03307424f, 
    -0.01513631f, 0.00877992f, -0.04214210f, -0.01245400f, -0.01738270f, -0.01597654f, -0.01421150f, -0.05561753f, 
    -0.02380107f, -0.01779836f, -0.01064164f, 0.02000913f, 0.01952826f, -0.04009204f, 0.02465412f, -0.04537848f, 
    0.00156067f, 0.00557732f, -0.04549396f, -0.02696959f, -0.00436286f, -0.01519570f, 0.00635948f, -0.04250479f, 
    -0.01554714f, 0.03901957f, 0.04293133f, -0.03322645f, 0.02124144f, 0.01460122f, -0.01714767f, -0.02245172f, 
    -0.05282354f, 0.01050879f, -0.01644502f, 0.01678382f, 0.02651380f, -0.03428581f, 0.00565521f, 0.03480925f, 
    0.03257180f, 0.04028870f, -0.04789832f, -0.01498197f, 0.01472979f, 0.03343071f, 0.02071572f, 0.02100121f, 
    -0.05432593f, -0.00935939f, -0.05430892f, -0.04745110f, 0.00318189f, 0.03916017f, -0.05317890f, -0.00509817f, 
    -0.03913125f, -0.00115889f, 0.04087001f, -0.05613856f, -0.02996681f, -0.03017035f, 0.00589416f, -0.00751275f, 
    -0.05328731f, 0.02948261f, 0.03949472f, 0.01684201f, -0.03845960f, -0.03778281f, -0.01826377f, -0.03362448f, 
    0.00552310f, 0.03573823f, 0.01821556f, -0.03084382f, 0.02559770f, 0.04066186f, -0.05079175f, -0.00055595f, 
    0.00188774f, 0.02088035f, -0.04717263f, -0.05272995f, 0.02285521f, -0.03261290f, 0.01262166f, 0.00774262f, 
    -0.04497520f, -0.01605211f, -0.03081558f, 0.03978011f, -0.02293786f, 0.03213993f, -0.01932080f, -0.02437744f, 
    -0.03269603f, 0.03020019f, -0.00885878f, -0.00153049f, 0.01828462f, -0.05402802f, -0.05700813f, -0.01768877f, 
    0.01877552f, -0.00101318f, -0.02881707f, -0.01996292f, -0.04310806f, 0.00430743f, 0.01117359f, -0.03198680f, 
    -0.02112552f, 0.02990861f, 0.03920725f, -0.03903792f, 0.00803408f, -0.01979844f, 0.04274133f, 0.01611739f, 
    0.02473504f, -0.03639647f, -0.03019183f, -0.01455915f, 0.02818498f, 0.02824865f, -0.03050469f, -0.05548257f, 
    -0.03131708f, 0.04090714f, -0.02125224f, 0.02248098f, 0.02093603f, -0.01309726f, 0.03251510f, -0.00464922f, 
    -0.02744719f, -0.01793331f, 0.01428663f, -0.05576907f, 0.00706070f, 0.00246702f, 0.02471844f, 0.03761497f, 
    0.02084165f, -0.01323566f, -0.01653997f, -0.04109539f, -0.01064229f, 0.01530877f, 0.01472387f, 0.00180730f, 
    0.01466157f, 0.00000485f, -0.01331640f, -0.03569431f, -0.03371254f, -0.00973789f, 0.00307497f, -0.00005947f, 
    0.00277226f, 0.02073448f, 0.03998989f, 0.02051761f, -0.03712908f, 0.04421728f, -0.00574876f, -0.05385835f, 
    -0.00349310f, -0.02047351f, -0.03668805f, -0.00476574f, -0.04997698f, 0.04283582f, -0.04523342f, -0.03532999f, 
    0.01457764f, -0.05068188f, -0.05174935f, -0.03369244f, 0.00351439f, -0.02669202f, -0.04349807f, 0.01649563f, 
    -0.03994433f, -0.04476813f, 0.01813565f, 0.01226745f, 0.03538185f, -0.03692403f, -0.00629154f, -0.04960267f, 
    -0.00597612f, -0.04139837f, 0.00114144f, 0.00972371f, 0.00286426f, -0.01502328f, -0.03272402f, -0.03744258f, 
    -0.05018978f, 0.04013539f, -0.04742676f, 0.02014709f, 0.01607544f, -0.05577768f, -0.00368339f, -0.02812312f, 
    0.03799299f, -0.00546447f, 0.03396969f, 0.03102031f, -0.01929217f, -0.02732970f, 0.02027292f, -0.02072961f, 
    -0.03749145f, 0.03143786f, 0.04198784f, -0.01649099f, 0.01845609f, -0.02336564f, -0.03383498f, -0.03717750f, 
    -0.04026901f, -0.02334915f, -0.04791873f, 0.03353790f, -0.02035435f, -0.03719839f, 0.03894369f, -0.02703363f, 
    -0.04003979f, 0.02969644f, 0.01895608f, -0.00950705f, -0.01563850f, -0.00695562f, -0.04853787f, 0.04307095f, 
    -0.02339634f, 0.03396912f, 0.00040845f, 0.01470276f, 0.00226285f, 0.00622881f, 0.01547050f, -0.00884084f, 
    0.03178592f, -0.03906902f, 0.04077255f, -0.00780072f, 0.03532281f, -0.01063192f, 0.02463408f, 0.02328573f, 
    -0.00364132f, 0.01670332f, -0.03016968f, -0.02147979f, 0.01001235f, 0.00887057f, -0.01387430f, 0.03088071f, 
    0.00088927f, -0.02426444f, 0.04050157f, -0.00931852f, -0.00791631f, -0.04909069f, -0.03630904f, 0.00917655f, 
    0.00708872f, 0.02114899f, -0.00182149f, -0.02466479f, 0.03354466f, -0.04426323f, -0.03300731f, 0.03833767f, 
    -0.01174668f, -0.00955357f, -0.03486484f, 0.00736765f, -0.01436567f, -0.01743002f, 0.01956559f, -0.02580474f, 
    0.00464408f, -0.00994026f, 0.04035149f, -0.03712036f, -0.03813738f, 0.02724612f, -0.04361904f, 0.03402694f, 
    -0.00129066f, 0.00369425f, -0.01745692f, -0.04474037f, -0.02132388f, 0.01846309f, -0.02745620f, -0.05431736f, 
    0.00743695f, -0.04937771f, -0.02007639f, 0.00251444f, -0.03804351f, -0.00798394f, -0.03218300f, 0.02534064f, 
    -0.02683379f, -0.01724178f, -0.01728141f, -0.01559404f, 0.03871945f, -0.05365552f, -0.02625097f, 0.01209114f, 
    -0.02946421f, -0.01129519f, -0.04082060f, -0.03472318f, -0.02427344f, -0.03809505f, -0.05208978f, 0.02427945f, 
    0.00454936f, -0.04321202f, 0.01114665f, 0.00872153f, -0.02136311f, 0.02128794f, -0.04219995f, 0.01929453f, 
    -0.03143830f, -0.01419542f, -0.00514723f, -0.04543967f, -0.03444637f, -0.01428301f, -0.04502926f, -0.00667459f, 
    0.01218846f, -0.05242734f, -0.03068401f, -0.04871724f, 0.04425151f, 0.02623370f, -0.03874313f, 0.01925870f, 
    0.00380551f, -0.00027801f, 0.00126985f, 0.00586547f, -0.05248421f, 0.01707127f, 0.01070514f, -0.04530062f, 
    0.00713118f, 0.04440176f, -0.04910259f, -0.05657029f, -0.00720883f, -0.03581927f, -0.02905013f, 0.01248087f, 
    -0.02305666f, 0.02696721f, -0.00935619f, -0.04166865f, 0.02992662f, 0.01384700f, 0.04007007f, -0.03969969f, 
    -0.02622236f, -0.02374768f, 0.01153168f, 0.03921185f, 0.03200191f, -0.01348656f, 0.03426591f, -0.04197609f, 
    0.00580849f, -0.00445950f, -0.00104037f, -0.01002705f, -0.03495510f, 0.00851511f, -0.03443191f, -0.00936248f, 
    -0.05054988f, -0.00332751f, -0.05493944f, 0.02442446f, -0.05341799f, -0.03657624f, 0.03239066f, 0.04246745f, 
    0.03496309f, -0.02306122f, -0.03298590f, 0.03511152f, 0.00221191f, -0.04577709f, -0.01363135f, -0.03882168f, 
    0.01705361f, -0.05603851f, -0.01592225f, -0.01758610f, 0.00972858f, -0.02207131f, -0.04726472f, -0.03890720f, 
    0.02508390f, -0.03106541f, 0.03775412f, -0.05296656f, 0.04758250f, -0.00680062f, -0.00040328f, 0.00240767f, 
    -0.04294317f, -0.04753063f, -0.00394049f, 0.03948480f, -0.02397310f, 0.03941932f, -0.04600510f, -0.01121718f, 
    -0.01855608f, -0.01946364f, 0.03844227f, 0.04174619f, -0.02869400f, -0.03774510f, -0.03490362f, 0.00265978f, 
    -0.04604432f, -0.02060759f, -0.00223813f, 0.02805703f, -0.03524193f, -0.02681561f, -0.03911908f, -0.01199611f, 
    -0.02189490f, 0.03192512f, -0.03141185f, -0.04461403f, -0.04490280f, -0.03044642f, -0.01052085f, 0.02223974f, 
    0.02111943f, -0.01493920f, -0.05463018f, -0.00494365f, 0.02122549f, -0.03296347f, -0.01147499f, 0.02282005f, 
    -0.03559226f, -0.00547308f, -0.02730469f, 0.01626329f, 0.02794286f, -0.03368080f, -0.00660009f, 0.01478412f, 
    -0.04384677f, 0.04187712f, -0.02307327f, 0.01941273f, 0.02149155f, 0.00449184f, 0.03700443f, 0.02069829f, 
    -0.05656994f, -0.01266349f, -0.02800237f, 0.01672569f, 0.04202830f, 0.02304116f, -0.01789069f, 0.03260719f, 
    0.02759911f, -0.03152668f, -0.03749137f, -0.04971397f, -0.04750960f, -0.03556906f, -0.01946141f, -0.04192322f, 
    0.00206964f, -0.02027950f, -0.00725370f, 0.01687833f, 0.03292294f, 0.02393775f, -0.02992086f, 0.00667466f, 
    0.03392945f, 0.02187663f, -0.00013052f, 0.01875166f, -0.04764135f, -0.05220919f, -0.05494364f, -0.02467466f, 
    0.00981863f, 0.01199408f, -0.03708927f, 0.04212520f, 0.01205022f, 0.03307525f, -0.04300516f, 0.00066644f, 
    -0.03908303f, -0.02362239f, 0.01399863f, 0.03083956f, -0.01674215f, 0.01417475f, -0.00502239f, -0.04772079f, 
    -0.03128980f, 0.00668752f, -0.00309762f, -0.01234745f, -0.01209634f, 0.00554098f, -0.05246266f, 0.01526217f, 
    -0.05290036f, -0.01311305f, 0.00129317f, -0.03011800f, 0.02141569f, -0.02370912f, -0.02387763f, 0.03241220f, 
    -0.04350890f, -0.02396312f, -0.00003729f, -0.02892473f, -0.03135328f, -0.03359579f, 0.00930991f, -0.04081854f, 
    -0.01195789f, -0.01104899f, 0.04197038f, 0.03803734f, 0.04446012f, -0.03233670f, 0.02901844f, 0.02747692f, 
    -0.04130604f, 0.03101527f, -0.00233176f, -0.02685650f, -0.03453679f, -0.05590063f, 0.03758357f, 0.00212648f, 
    -0.02528976f, 0.04093651f, 0.02754660f, -0.02185032f, 0.04328895f, 0.03324095f, -0.01571447f, 0.03339213f, 
    -0.01694476f, -0.02642416f, 0.02461621f, 0.02840776f, 0.02346871f, -0.03857707f, 0.03166045f, -0.05649383f, 
    -0.05588499f, 0.02462886f, 0.03706359f, 0.04293663f, 0.00981336f, 0.03407111f, -0.01612689f, 0.01431849f, 
    0.00098734f, -0.04401144f, 0.01313106f, 0.02837570f, -0.04284627f, 0.00226580f, 0.02128487f, -0.00229179f, 
    -0.00327388f, 0.02087993f, 0.05035596f, -0.02503962f, -0.02372802f, 0.00183624f, -0.00225571f, -0.05509945f, 
    -0.01493869f, -0.00037560f, -0.01824200f, -0.05406243f, -0.03199956f, -0.04933615f, -0.00291557f, -0.01415385f, 
    -0.02385873f, -0.02043055f, -0.03911798f, 0.00010112f, -0.04004093f, -0.01779986f, -0.05425828f, -0.01563764f, 
    0.01983377f, -0.01003965f, -0.00276147f, -0.04757372f, -0.04042827f, 0.00537952f, -0.04423943f, 0.00034055f, 
    -0.05685858f, 0.03672178f, -0.01178226f, -0.03443822f, 0.03498887f, -0.03486618f, 0.02548923f, 0.04275891f, 
    0.01440317f, -0.03815367f, -0.03470794f, -0.03892512f, 0.01395516f, -0.02210291f, 0.02556797f, -0.00008035f, 
    0.01911017f, -0.02793189f, -0.04440070f, -0.01861503f, -0.00510772f, -0.02990023f, -0.00973739f, -0.04856718f, 
    0.02767616f, -0.03724971f, 0.04146835f, 0.01310162f, -0.00412368f, -0.01682407f, 0.03433724f, -0.00517569f, 
    -0.01531328f, -0.01695963f, -0.04596681f, -0.04622773f, 0.04462643f, -0.04209954f, -0.00596579f, 0.04329902f, 
    0.32261622f, 0.14795625f, 0.18010378f, 0.14595540f, 0.09575956f, -0.03463263f, 0.16325717f, 0.07190903f, 
    0.02864962f, -0.16214982f, 0.00403838f, 0.04035421f, -0.11756667f, 0.11752304f, -0.09100871f, -0.33300334f, 
    0.00864910f, 0.08202440f, 0.02588996f, 0.07195948f, 0.02273258f, 0.04918234f, -0.02250636f, 0.17680426f, 
    -0.29330644f, -0.11662846f, 0.21499035f, -0.19754885f, 0.14806904f, -0.11042575f, 0.00179635f, -0.04640944f, 
    0.14783429f, 0.00576020f, 0.00671323f, -0.11917707f, 0.49888349f, 0.27461576f, 0.11390770f, 0.11298680f, 
    -0.16648901f, -0.09385305f, 0.26212835f, 0.00361792f, 0.04436450f, 0.05306603f, 0.03137077f, 0.05198624f, 
    -0.09724971f, 0.03396023f, -0.02864690f, 0.05370429f, -0.00449109f, 0.07005721f, 0.10128716f, -0.11341271f, 
    0.07352784f, 0.12410679f, 0.04958107f, -0.09316108f, -0.03112954f, 0.05802621f, 0.06686175f, -0.03868580f, 
    0.02912965f, -0.12707873f, 0.03229512f, 0.12381113f, -0.19695716f, 0.02955233f, 0.02997324f, 0.04863703f, 
    0.09361200f, 0.04427401f, -0.23540194f, 0.12046485f, -0.11373417f, 0.04832467f, 0.19638243f, 0.06361731f, 
    0.07350243f, 0.17753427f, 0.10649161f, 0.09896945f, 0.02119028f, 0.00114499f, 0.04375462f, -0.14686649f, 
    -0.01165740f, 0.08113714f, 0.00119525f, 0.02540714f, -0.09471721f, 0.17420614f, 0.09408650f, 0.15226226f, 
    0.69007272f, 0.05869848f, -0.16518006f, -0.07290842f, 0.08569994f, 0.06838559f, -0.15528266f, -0.09050538f, 
    -0.12781177f, 0.11884558f, 0.12421086f, -0.02563565f, 0.20130631f, 0.12949818f, 0.09178435f, 0.01966985f, 
    0.06739245f, -0.03041564f, 0.02455739f, -0.12880386f, 0.06900127f, 0.01399942f, 0.00157080f, -0.00085808f, 
    0.04087223f, 0.21627492f, -0.06783373f, -0.10116807f, -0.01237282f, 0.11621824f, 0.07539602f, 0.00356354f, 
    -0.00682620f, 0.18884274f, 0.03258796f, 0.29311934f, 0.12044852f, -0.16379462f, 0.04185625f, -0.09063721f, 
    0.06208212f, 0.05749652f, -0.01413040f, -0.00273306f, 0.11465069f, 0.08746368f, -0.03779523f, -0.02105919f, 
    0.08914446f, -0.04759471f, -0.10236733f, 0.01065934f, -0.09449941f, 0.05624068f, -0.02417785f, 0.03143017f, 
    0.09864160f, 0.03897171f, -0.00805389f, -0.14664617f, -0.11649567f, -0.01754326f, 0.17211208f, -0.05479000f, 
    0.09359404f, -0.16232169f, 0.07738002f, 0.07972122f, -0.05001537f, -0.05381198f, 0.07603534f, 0.07877009f, 
    0.01912779f, -0.03027723f, 0.00659941f, -0.01851558f, 0.08696417f, 0.01262301f, -0.12347560f, 0.00573117f, 
    0.08774836f, 0.05653680f, -0.09051007f, 0.00256555f, 0.25697392f, -0.20524254f, -0.03548901f, 0.09561598f, 
    0.10157555f, 0.16374686f, 0.08675883f, 0.06916627f, -0.02735484f, 0.01422755f, 0.17592676f, -0.04862433f, 
    -0.37039587f, -0.20164298f, 0.05623481f, -0.11657902f, 0.02775866f, -0.04864167f, 0.11641793f, 0.11532886f, 
    0.02671914f, 0.08676975f, 0.00589649f, 0.12604026f, 0.21867520f, -0.04392114f, 0.08324564f, -0.04168333f, 
    0.03459504f, 0.11389617f, 0.04679085f, -0.07924361f, 0.03063929f, -0.04831995f, -0.00638474f, 0.19688880f, 
    0.10489500f, -0.13216688f, 0.03325212f, 0.14085117f, 0.01975295f, -0.00692393f, 0.16939317f, 0.17553166f, 
    0.10735045f, -0.02742390f, 0.07991741f, 0.03828235f, -0.03477694f, 0.10951915f, 0.07934526f, 0.03498732f, 
    0.09142962f, 0.08935924f, 0.05094581f, -0.05500383f, -0.05971935f, 0.06376457f, 0.11752520f, 0.09824348f, 
    0.15173398f, 0.19707687f, 0.22094344f, -0.13042077f, 0.01543720f, 0.02668903f, 0.12700529f, 0.00537133f, 
    -0.00912439f, -0.00142354f, 0.03562929f, 0.11438756f, 0.42260122f, -0.21247850f, -0.03650918f, 0.03172281f, 
    0.10338115f, -0.02490252f, -0.08830006f, 0.07601047f, 0.13654196f, -0.05430838f, -0.09661161f, -0.02279785f, 
    0.01633775f, 0.14526646f, 0.10167991f, -0.23140590f, 0.12584175f, 0.00845655f, -0.04071437f, -0.00778193f, 
    -0.06880047f, -0.01663853f, -0.01881727f, -0.16237734f, 0.02634608f, -0.04349940f, 0.13882124f, 0.00478320f, 
    0.01969615f, -0.08915530f, -0.02130080f, -0.03239304f, 0.06793012f, 0.09915756f, -0.04094156f, 0.06011024f, 
    -0.74490207f, -0.21211931f, -0.06467000f, -0.07692988f, -0.01370087f, 0.00069941f, 0.12255482f, -0.00837592f, 
    0.08856676f, -0.04842802f, -0.01891869f, -0.06253277f, 0.28576612f, 0.28902873f, 0.21744470f, -0.01513819f, 
    0.08363343f, 0.00361288f, 0.17235851f, -0.07747477f, 0.07899438f, -0.00443222f, 0.12111581f, 0.05778776f, 
    0.16667011f, 0.09978564f, 0.21689241f, 0.16645733f, 0.15923499f, 0.20515463f, 0.09537796f, 0.15224119f, 
    0.06103419f, 0.09194006f, -0.01637546f, 0.07633060f, -0.03895357f, 0.19015303f, 0.33722869f, -0.06719057f, 
    0.04498154f, 0.15548429f, 0.03700901f, -0.00968149f, -0.01181926f, 0.03085938f, 0.04653571f, -0.02292370f, 
    0.19675033f, -0.04075244f, -0.05633904f, 0.08764578f, 0.01699647f, 0.10666074f, -0.05577982f, 0.15599179f, 
    0.04684021f, 0.18823163f, 0.10371129f, 0.18178880f, 0.00617932f, -0.30583107f, -0.15518826f, 0.12509030f, 
    0.08783451f, -0.13917992f, 0.07982054f, -0.09657118f, 0.03781309f, -0.09890025f, -0.16743007f, -0.07021994f, 
    0.08946229f, 0.00211682f, -0.13949020f, 0.02482717f, 0.01185474f, 0.16692123f, 0.00496584f, 0.05343767f, 
    0.02207489f, 0.02120065f, -0.06143346f, 0.24717486f, 0.22646162f, -0.16939549f, -0.17320785f, -0.18706582f, 
    0.08489753f, 0.05819460f, -0.11895528f, 0.05783832f, 0.08317953f, 0.08498205f, 0.08085892f, 0.06645244f, 
    0.10400792f, -0.02444198f, -0.08082040f, -0.09732049f, 0.10508145f, 0.05599790f, -0.00690119f, 0.01661003f, 
    0.10777924f, 0.04678634f, 0.10206335f, -0.14039463f, 0.38994840f, -0.11333672f, -0.00645793f, 0.12894300f, 
    -0.06125784f, -0.13624142f, 0.16441217f, -0.06392398f, 0.01756427f, -0.01582975f, 0.12703522f, -0.02848091f, 
    0.02353884f, 0.07627548f, -0.12713940f, -0.14599989f, -0.03058089f, 0.01104481f, -0.05982757f, -0.08006767f, 
    0.00090030f, -0.04250023f, 0.15673457f, -0.08572023f, -0.03506762f, -0.05549762f, -0.00998406f, -0.00685443f, 
    0.12600741f, 0.01658632f, -0.07218076f, 0.05867847f, -0.03234332f, 0.03164580f, -0.03069854f, 0.01631920f, 
    -0.16409360f, -0.18208635f, 0.01597091f, -0.06768426f, -0.12140173f, -0.02611211f, 0.01789549f, 0.01670430f, 
    -0.10936906f, -0.05843329f, 0.00031526f, -0.06715716f, -0.11572544f, 0.22503932f, 0.07023948f, 0.20410489f, 
    -0.03055853f, -0.13817181f, -0.06829220f, -0.16571268f, 0.16012579f, 0.06071888f, -0.10153291f, 0.04733204f, 
    -0.13875647f, 0.00594103f, 0.16419172f, -0.15570699f, 0.09161191f, -0.08193062f, -0.02433226f, 0.01648669f, 
    0.08013107f, -0.06953833f, 0.02651799f, -0.03298828f, 0.13017638f, 0.01530706f, -0.16543625f, 0.05838913f, 
    0.17030510f, -0.06820468f, 0.03662408f, -0.07300774f, 0.06177086f, -0.07429983f, 0.05125007f, -0.00205718f, 
    -0.20738463f, 0.08815905f, -0.01151138f, -0.18074612f, -0.03243201f, -0.06171824f, 0.01243835f, -0.00010274f, 
    0.03090392f, -0.02296244f, 0.01865138f, -0.03990404f, -0.06219755f, -0.05356636f, -0.16790031f, 0.06138392f, 
    0.11012679f, 0.05192746f, 0.02631566f, -0.07152503f, -0.06809998f, -0.00050818f, 0.01380216f, 0.04989734f, 
    0.10182953f, -0.10168243f, 0.20692597f, 0.17639387f, 0.11081748f, -0.08695114f, 0.00365870f, -0.01214935f, 
    0.12488845f, 0.08919367f, -0.03141868f, -0.13454802f, -0.00929950f, 0.19896446f, 0.12019050f, 0.21053116f, 
    -0.03151356f, -0.06933428f, 0.03285161f, 0.06534786f, -0.03462603f, -0.08689678f, -0.02131641f, 0.05421269f, 
    -0.00566266f, 0.08821044f, 0.07901234f, -0.05200996f, 0.15663180f, 0.02962616f, 0.09502514f, 0.00171970f, 
    -0.03538652f, -0.00770244f, 0.09868813f, 0.13032056f, -0.16362719f, -0.00418854f, -0.16990092f, -0.03282559f, 
    0.03438445f, 0.14359000f, -0.14304094f, -0.06587478f, 0.13720541f, 0.04510456f, 0.04306728f, -0.07670436f, 
    -0.07165309f, -0.05017063f, 0.10975389f, 0.26220533f, -0.28129140f, 0.00756305f, -0.02753303f, 0.03908626f, 
    -0.14172938f, -0.01910949f, 0.04741909f, -0.06130652f, -0.17528735f, 0.08893257f, 0.07452619f, 0.21533087f, 
    -0.09039576f, -0.04000123f, 0.15450539f, -0.13521607f, 0.05194501f, 0.02940401f, 0.01187045f, -0.10426037f, 
    0.28418177f, 0.10528595f, -0.23507112f, -0.06809514f, 0.07453460f, 0.04917432f, -0.07785081f, -0.00170243f, 
    -0.01237530f, -0.01097727f, -0.01135856f, -0.07711385f, -0.04903006f, 0.19150087f, -0.07022607f, 0.06740353f, 
    -0.02379426f, -0.03914693f, 0.22351061f, -0.05149097f, 0.02818481f, 0.09606854f, -0.00339390f, 0.02103378f, 
    0.00585822f, 0.31153840f, 0.12267863f, -0.02582865f, 0.02155137f, 0.03741132f, -0.09515865f, -0.00673900f, 
    0.10581460f, 0.02497314f, 0.00473475f, -0.08958042f, 0.07971247f, -0.09019607f, 0.00422185f, 0.13551287f, 
    -0.06240697f, 0.14959538f, 0.08302109f, -0.05418842f, 0.08107620f, -0.06924825f, -0.08409234f, 0.00629404f, 
    0.18265267f, -0.04986768f, -0.04300119f, 0.06318291f, 0.02440806f, 0.00351470f, -0.03537127f, 0.06745356f, 
    -0.00957647f, -0.02173689f, 0.08983971f, -0.05899668f, -0.24276468f, 0.23780169f, 0.00533780f, 0.02213745f, 
    -0.06878354f, -0.06284989f, 0.12052276f, -0.00045098f, 0.01322220f, -0.15338212f, -0.00414550f, -0.02357676f, 
    -0.23132111f, 0.20244342f, -0.36821476f, 0.09658480f, -0.08630737f, 0.04099083f, -0.07937655f, -0.14903271f, 
    0.08106167f, -0.02455535f, 0.07735584f, 0.10137478f, 0.16401011f, 0.07050649f, -0.01923639f, -0.01386743f, 
    0.03335040f, -0.03340797f, 0.01954645f, 0.08545956f, 0.06131871f, 0.02476703f, -0.08427051f, -0.02025579f, 
    0.34867752f, 0.04467971f, -0.13272901f, 0.05262115f, 0.02350385f, -0.02215463f, -0.09608639f, 0.04854758f, 
    0.06151371f, 0.11047615f, 0.00340979f, 0.01653439f, 0.05365723f, -0.14404878f, 0.07446357f, -0.03733681f, 
    0.08762699f, 0.08521704f, 0.04124916f, 0.00434399f, 0.00792646f, -0.12937738f, -0.01039863f, 0.06110079f, 
    0.17984332f, 0.03381486f, -0.11500155f, 0.13094719f, 0.08885252f, -0.04647514f, 0.06530959f, 0.08019251f, 
    0.05194819f, 0.01019568f, 0.08204052f, 0.05847872f, 0.26615867f, -0.05028867f, 0.04810072f, 0.00226586f, 
    0.08507001f, -0.05105362f, 0.07807671f, 0.00447462f, 0.04115065f, -0.01313466f, 0.06434212f, 0.03147618f, 
    -0.12577166f, 0.09845515f, 0.09033711f, -0.31244275f, 0.04629431f, -0.02055722f, 0.07065056f, 0.02965026f, 
    -0.08095594f, 0.00283525f, -0.07703929f, 0.00451252f, 0.22500187f, 0.10384814f, 0.01993310f, -0.18352745f, 
    0.01006005f, 0.14885440f, -0.01317468f, 0.10856788f, 0.04012180f, 0.09691338f, 0.05910187f, 0.14682260f, 
    -0.17799327f, 0.01286909f, 0.25232768f, -0.08626755f, -0.04819687f, -0.07807229f, 0.10531625f, -0.02580375f, 
    -0.12293173f, 0.07789337f, 0.10024496f, 0.00764007f, -0.07843412f, 0.25376955f, -0.02327569f, 0.38094917f, 
    -0.02172172f, -0.11900333f, -0.09478142f, -0.05788777f, -0.01285804f, -0.04360764f, 0.00110564f, -0.01137321f, 
    0.24891414f, -0.02455077f, 0.03081119f, 0.09737485f, -0.08303421f, -0.07694536f, -0.03169927f, -0.05502772f, 
    0.04725847f, -0.16535762f, -0.00855061f, -0.07811188f, -0.35020161f, 0.36644694f, -0.09997489f, -0.22066411f, 
    -0.04369687f, 0.04167359f, 0.08424441f, 0.04233412f, 0.10679502f, 0.02247118f, 0.03083307f, -0.06534702f, 
    -0.03683916f, -0.22316208f, -0.29197314f, -0.19975850f, 0.06659319f, -0.09936491f, -0.04363048f, 0.04246907f, 
    0.15040304f, -0.02348297f, -0.07747740f, -0.00135922f, 0.29008278f, -0.03319404f, -0.15296634f, -0.20512517f, 
    0.01218294f, -0.13172460f, -0.01867478f, -0.03993861f, -0.01766178f, 0.06096863f, -0.01368458f, 0.16324197f, 
    -0.20469698f, 0.10800673f, -0.11403055f, -0.05759055f, 0.01439403f, 0.10372759f, 0.03884132f, 0.11133149f, 
    -0.04850294f, 0.07400072f, -0.01381804f, 0.00306870f, 0.21553402f, 0.00704167f, -0.01336448f, -0.04608453f, 
    -0.10544282f, -0.00093984f, 0.09966861f, 0.02826311f, -0.04599944f, 0.02960067f, -0.02306500f, 0.16384995f, 
    -0.01776895f, -0.02568405f, -0.17593192f, 0.30136156f, -0.00614649f, 0.02631012f, 0.07523787f, 0.02666579f, 
    0.14474835f, 0.04285702f, 0.01857521f, 0.11874066f, 0.20705658f, 0.03945376f, 0.02655680f, 0.11576839f, 
    -0.00325714f, -0.07344099f, 0.08890192f, 0.05439862f, -0.13182378f, 0.18342808f, -0.01869166f, 0.17497447f, 
    -0.23816568f, 0.34493119f, -0.07679477f, 0.22527942f, 0.07420694f, -0.03836546f, -0.19021192f, -0.01135238f, 
    -0.04287904f, -0.01448059f, 0.10166625f, -0.26915962f, 0.16175985f, -0.09339643f, -0.02132561f, -0.12734622f, 
    -0.04146745f, -0.05488946f, -0.04055168f, -0.13093479f, 0.05158827f, 0.02118478f, 0.02379862f, 0.08619660f, 
    -0.08827371f, 0.19204164f, 0.08419052f, 0.27818152f, -0.08523708f, 0.02083712f, 0.00738898f, 0.02390112f, 
    0.03284686f, 0.15560380f, 0.05998993f, 0.16189395f, 0.16987787f, -0.00282071f, -0.04359836f, -0.07431427f, 
    -0.02300720f, -0.14800470f, 0.07923894f, 0.02149331f, 0.02759804f, -0.06718387f, 0.10793520f, 0.02662066f, 
    0.01835542f, 0.01388829f, -0.13973454f, -0.07838084f, 0.00997739f, 0.04333137f, 0.04144479f, 0.06042323f, 
    0.06079127f, -0.12361321f, -0.17408372f, -0.04777735f, -0.01632254f, -0.20929252f, 0.13206036f, 0.16802658f, 
    -0.00200827f, -0.21223474f, 0.00568364f, -0.03440679f, 0.24854846f, -0.17132507f, 0.07542741f, 0.05462378f, 
    0.24847198f, 0.07090055f, -0.04365034f, -0.05889359f, 0.07713263f, -0.00051641f, -0.04950187f, 0.08861673f, 
    0.09415383f, -0.05526867f, 0.04764465f, -0.07549012f, 0.08926445f, 0.25712281f, 0.01284841f, 0.04506962f, 
    0.11373328f, 0.13709511f, -0.05225401f, 0.06442580f, 0.05641747f, 0.01214529f, 0.10376151f, 0.00276378f, 
    -0.03646827f, -0.01709217f, 0.22568564f, -0.06224537f, 0.00769214f, -0.01126100f, 0.18507461f, 0.04253801f, 
    -0.01864396f, 0.09360944f, 0.13089630f, 0.10511684f, 0.19404845f, -0.18842308f, 0.03534804f, -0.08073194f, 
    -0.03964199f, 0.00390015f, 0.03918837f, -0.00228330f, -0.05610100f, -0.13164350f, 0.00015590f, 0.17848726f, 
    0.04187029f, -0.11297024f, -0.07816660f, 0.09614278f, 0.00052953f, -0.02049834f, -0.03236698f, 0.10598738f, 
    0.07701514f, -0.03383562f, 0.10649252f, 0.09493245f, 0.27498716f, -0.46333563f, 0.23857772f, -0.05630470f, 
    -0.06461699f, 0.02044688f, 0.06219792f, 0.01820498f, -0.04094962f, 0.04306001f, -0.06098371f, -0.00207494f, 
    -0.11630090f, -0.11312223f, 0.02473650f, 0.04072105f, -0.04081480f, -0.08415759f, 0.04453599f, -0.03213457f, 
    -0.03608706f, -0.00026151f, 0.06383345f, -0.02510536f, 0.20184010f, 0.05579281f, -0.07241791f, 0.06560401f, 
    -0.02072140f, 0.01786478f, 0.05132429f, -0.00675398f, 0.04797297f, 0.07801076f, -0.10806390f, -0.01434412f, 
    0.08955980f, -0.10068973f, -0.05125469f, -0.27829370f, -0.11067422f, -0.01075986f, -0.10934478f, 0.05995722f, 
    -0.03581576f, -0.05898745f, 0.07325669f, -0.10406286f, 0.28026941f, -0.11025273f, -0.01256353f, 0.35529721f, 
    0.05150432f, -0.16277872f, -0.01994796f, -0.03220918f, 0.03537446f, 0.09123924f, -0.05720347f, -0.07587404f, 
    -0.19542672f, 0.00714189f, 0.05551463f, -0.03810746f, 0.00809273f, -0.06140492f, 0.18768574f, -0.00975729f, 
    0.00168875f, -0.07015926f, -0.11089633f, -0.16643140f, 0.09734634f, -0.10131804f, -0.04325904f, 0.20101097f, 
    0.05358061f, -0.01822881f, 0.02717208f, -0.14218821f, 0.02345097f, -0.08912823f, 0.15049478f, -0.00759301f, 
    0.05050191f, 0.04462368f, 0.01954410f, 0.32466221f, 0.01185216f, 0.11993004f, 0.05635051f, 0.14451225f, 
    0.23733038f, 0.05773894f, 0.01172545f, 0.02805708f, 0.07860688f, -0.11992367f, 0.10899008f, 0.26517135f, 
    -0.01050410f, 0.03881710f, 0.00731624f, -0.02859705f, 0.01487565f, -0.14936264f, -0.01519933f, -0.02551652f, 
    -0.26424441f, -0.20632677f, -0.02845373f, 0.16119798f, 0.08187407f, 0.05621735f, -0.23434743f, 0.05506795f, 
    -0.07571896f, 0.04095905f, -0.03627980f, 0.14096089f, -0.17995773f, -0.13626148f, -0.03965518f, -0.02573658f, 
    0.07965469f, -0.11230667f, -0.02178068f, 0.03632339f, -0.00771056f, -0.09615707f, -0.16083138f, 0.14533721f, 
    -0.15729150f, -0.02293177f, 0.11192950f, -0.14001861f, 0.14601927f, 0.12838437f, 0.04862608f, 0.04071501f, 
    0.00018662f, 0.17281371f, 0.03559212f, 0.24101421f, -0.11484023f, 0.27732730f, 0.00873178f, -0.38707176f, 
    0.03800647f, 0.14674953f, -0.05417475f, -0.05397161f, 0.14184229f, 0.00953272f, 0.00260137f, 0.07885280f, 
    -0.04835588f, -0.00827014f, 0.03646277f, -0.03895643f, -0.03290965f, -0.03881840f, 0.01742063f, -0.04733633f, 
    0.01520822f, -0.02973672f, 0.03417149f, 0.03966027f, -0.03256367f, 0.00690214f, 0.02109257f, -0.01611734f, 
    -0.04707685f, -0.03547584f, -0.02253885f, -0.03813305f, -0.00627022f, -0.04734749f, 0.00640993f, -0.03564993f, 
    0.00799375f, -0.05338604f, 0.01901470f, -0.04387370f, -0.01955410f, -0.04929005f, -0.03477231f, -0.00057885f, 
    -0.03989784f, -0.01761797f, -0.05550784f, -0.01505811f, 0.01180678f, -0.01501193f, 0.03130575f, 0.02687526f, 
    -0.02710660f, -0.03936183f, -0.04992071f, 0.04425719f, 0.03711591f, -0.01822839f, -0.02958090f, -0.03047211f, 
    -0.00980100f, 0.00236708f, -0.05121077f, -0.03772968f, -0.01352290f, 0.03375502f, -0.04529139f, -0.03356457f, 
    -0.00532858f, 0.00788609f, 0.03982958f, 0.02064409f, -0.02328093f, 0.03874175f, 0.02236157f, -0.01438416f, 
    -0.00565497f, 0.01534245f, 0.00195844f, 0.01367313f, 0.04373979f, 0.02773534f, -0.02730541f, 0.01662321f, 
    -0.01167496f, -0.03893769f, -0.04794873f, -0.02196602f, -0.03709836f, -0.02293489f, 0.02852372f, -0.04303759f, 
    -0.00546538f, -0.04347927f, -0.02428902f, -0.03979411f, 0.01448549f, -0.04689707f, 0.01137841f, 0.02144549f, 
    -0.04855429f, 0.02965335f, 0.03349765f, 0.00476049f, -0.03717272f, -0.01549816f, 0.01026050f, -0.00779037f, 
    -0.03627504f, -0.00718325f, -0.00753181f, 0.01137047f, -0.03455016f, -0.01863956f, 0.04909587f, 0.04037927f, 
    0.02296666f, -0.03648100f, 0.00434105f, 0.01979121f, 0.01943702f, -0.04260046f, -0.02770664f, 0.03809933f, 
    0.03380832f, -0.03028389f, -0.01394963f, 0.02005600f, -0.04659548f, -0.05421691f, -0.03188802f, -0.05218619f, 
    0.02251565f, 0.02403928f, 0.01622896f, -0.03484504f, 0.02685176f, -0.01765056f, -0.01509895f, 0.02465044f, 
    0.01881883f, -0.05180310f, 0.04412489f, 0.01732321f, 0.00742599f, -0.02751141f, 0.03131878f, -0.03760818f, 
    -0.01487289f, -0.01119085f, 0.01011379f, 0.01141606f, 0.04255863f, -0.01271824f, 0.01651179f, -0.03065322f, 
    -0.05205829f, 0.01869530f, 0.00887999f, 0.03570071f, -0.04475612f, -0.01054564f, -0.02685182f, -0.02450419f, 
    0.04548659f, 0.02541434f, -0.05246619f, -0.05313423f, 0.04507262f, 0.04532062f, -0.04006945f, -0.04719955f, 
    -0.00086623f, -0.01185910f, -0.02484708f, 0.01033113f, 0.01098090f, 0.03345197f, -0.02515114f, 0.00929257f, 
    0.02914337f, -0.01866226f, 0.02907894f, -0.00498615f, 0.01087738f, 0.04637624f, 0.00052419f, -0.00052162f, 
    0.00476623f, -0.03685255f, 0.04120971f, 0.01541183f, -0.02441107f, -0.04209139f, -0.05264441f, -0.03410172f, 
    0.02638107f, -0.05140517f, 0.00508978f, -0.05350095f, 0.04121928f, 0.00210989f, -0.05445011f, -0.02969705f, 
    0.02763662f, 0.01915780f, 0.00805574f, -0.02156405f, 0.03945145f, -0.04351775f, -0.05313028f, -0.01513335f, 
    -0.02575248f, 0.02441388f, 0.01296685f, -0.00077704f, 0.03422711f, -0.02902965f, 0.00703464f, -0.00938036f, 
    0.01582483f, 0.00043104f, 0.02049251f, -0.00381048f, 0.03706337f, -0.05311030f, -0.04093768f, 0.01053413f, 
    0.03916886f, -0.04734204f, -0.04955675f, -0.00696806f, -0.00551007f, -0.04874163f, -0.02751718f, -0.03171277f, 
    0.01817576f, -0.04500895f, -0.03854284f, 0.03538359f, 0.03968285f, -0.00313048f, 0.01135104f, 0.01790715f, 
    0.00101270f, 0.01618665f, -0.01236020f, -0.00936017f, 0.02453071f, -0.00989725f, 0.01387387f, 0.00235287f, 
    0.03518371f, -0.00845756f, -0.03556110f, 0.00526862f, -0.00649361f, -0.04034859f, -0.03195903f, -0.02375866f, 
    0.00598361f, -0.00214340f, 0.03213234f, -0.03936487f, -0.05398373f, -0.00292836f, -0.00132057f, 0.03168298f, 
    0.03640157f, -0.03970283f, -0.04900553f, -0.04801883f, 0.03794793f, 0.00820784f, -0.03291887f, 0.02018900f, 
    -0.02583446f, -0.03375756f, -0.00980802f, -0.02442104f, -0.00652963f, 0.03756654f, -0.02180790f, 0.02810566f, 
    -0.01867549f, -0.04209358f, 0.04080318f, -0.01104763f, 0.02807882f, 0.02454775f, 0.02134415f, -0.05354516f, 
    -0.00999177f, 0.04439756f, -0.03121459f, -0.02451223f, -0.01831076f, -0.02655904f, -0.01791370f, -0.02327270f, 
    -0.04879252f, 0.01267969f, -0.03844519f, 0.04332850f, 0.02829847f, -0.00171467f, -0.02292791f, 0.02873521f, 
    -0.05128032f, -0.05485145f, -0.03747070f, -0.05029411f, -0.00338576f, 0.01768288f, -0.05318641f, -0.02736473f, 
    0.04874422f, 0.03169601f, 0.03605000f, -0.03520938f, 0.03028221f, -0.04577945f, -0.00979264f, 0.04021301f, 
    -0.01254067f, -0.02573029f, 0.00064139f, 0.02901739f, 0.01694272f, 0.01313017f, 0.03550277f, 0.04120890f, 
    0.01040926f, -0.04823273f, 0.02486593f, -0.05682965f, -0.02064705f, 0.03558036f, 0.01105837f, 0.03373286f, 
    0.01767268f, -0.00141395f, 0.00002830f, -0.02042390f, -0.00672484f, 0.01856220f, -0.05229302f, -0.04735595f, 
    -0.03561620f, -0.04139644f, 0.04037775f, 0.02182420f, -0.03719087f, -0.04104874f, 0.03488830f, -0.00982964f, 
    0.02236168f, -0.03334353f, -0.01919732f, -0.02429565f, -0.05452898f, -0.02961609f, 0.02883039f, 0.00650070f, 
    -0.04570499f, 0.01197244f, -0.05440908f, 0.01298277f, 0.00704599f, -0.02650553f, -0.04845302f, 0.02288502f, 
    -0.04747692f, 0.03974320f, -0.03003777f, -0.03344466f, 0.01280245f, 0.01475711f, -0.02491116f, 0.00285667f, 
    -0.00751256f, 0.02700382f, -0.05196981f, -0.04168968f, 0.01953118f, -0.03781269f, -0.00706118f, 0.01335835f, 
    0.00703044f, 0.04185223f, -0.02510498f, 0.02931918f, -0.01117510f, 0.03139192f, -0.03390523f, 0.00970419f, 
    0.25565678f, 0.08234016f, 0.01847764f, 0.10537156f, 0.17456909f, -0.02638593f, 0.11530455f, 0.20299916f, 
    0.06469094f, -0.02337894f, 0.11167235f, -0.07465027f, 0.14535221f, 0.05871720f, -0.25487968f, -0.13998638f, 
    -0.07191978f, 0.06048679f, 0.02299823f, -0.06111078f, 0.11093376f, -0.00211075f, 0.02124205f, 0.11388056f, 
    -0.15470932f, 0.04651308f, 0.21802121f, 0.01610598f, 0.15700111f, -0.06427383f, -0.03896460f, -0.15089148f, 
    0.05870315f, -0.00787252f, 0.09891093f, -0.05476132f, 0.36651966f, 0.36432645f, -0.03567086f, 0.25210834f, 
    0.01669699f, 0.05227418f, 0.03864408f, 0.13682425f, 0.08862341f, 0.00202128f, -0.05310653f, -0.05263362f, 
    -0.15954454f, -0.25176254f, -0.01914785f, 0.00370527f, -0.15500717f, 0.04229630f, -0.07495267f, -0.13678382f, 
    -0.03586302f, 0.04115538f, 0.08767913f, -0.01270662f, -0.07004818f, 0.02937609f, -0.10299549f, 0.07562143f, 
    0.03454638f, -0.09562958f, -0.02060764f, 0.10191888f, -0.00385122f, 0.02498619f, -0.00656175f, 0.01059785f, 
    -0.04517586f, 0.11508630f, -0.02273493f, 0.03736162f, 0.02450983f, -0.05627311f, 0.13237441f, 0.11900489f, 
    -0.06689765f, 0.06584088f, 0.06184186f, -0.02415844f, -0.01985322f, 0.01462295f, -0.11961055f, -0.20056893f, 
    0.04357268f, 0.20643011f, 0.01263456f, -0.00978121f, -0.00161162f, 0.11745763f, 0.07095226f, 0.05430480f, 
    0.47868276f, -0.24582656f, -0.09236114f, -0.00911727f, -0.00218563f, 0.06621518f, 0.00282856f, -0.05256164f, 
    0.04248513f, 0.17142016f, 0.16637103f, 0.04161916f, 0.29438847f, 0.23340406f, -0.10750229f, 0.11044113f, 
    0.18045962f, 0.11029616f, 0.03230029f, -0.08812623f, 0.08613820f, 0.07643893f, 0.08836704f, 0.11562022f, 
    0.15600929f, 0.35008052f, -0.04956895f, -0.05837151f, 0.08971820f, 0.10080983f, 0.02658838f, 0.00531700f, 
    0.08436655f, 0.13600414f, 0.02606663f, 0.19058087f, 0.07468506f, -0.26478359f, -0.04138295f, -0.06172181f, 
    0.01133699f, 0.09492043f, 0.05897057f, -0.01230371f, 0.05617470f, 0.01803208f, -0.05485451f, 0.01820097f, 
    0.01487928f, -0.11641387f, -0.14784169f, -0.00787189f, -0.03298236f, 0.00511516f, -0.02160597f, -0.07266568f, 
    0.07178611f, -0.01780111f, 0.12464110f, -0.19105466f, -0.05611373f, 0.23164587f, 0.13636349f, -0.14176041f, 
    0.14099567f, -0.12205722f, 0.06362652f, 0.07979243f, 0.07111755f, 0.07819945f, 0.01760018f, 0.08389455f, 
    0.05234256f, -0.23452105f, -0.01226263f, -0.00833927f, -0.06885227f, 0.09146997f, -0.13855761f, -0.06710986f, 
    0.04262781f, -0.00060040f, -0.00438883f, -0.06687082f, -0.04180075f, -0.28038391f, 0.01293709f, 0.07402994f, 
    -0.05086362f, 0.03773516f, 0.06912810f, 0.02843521f, -0.05642447f, 0.03275278f, 0.10087665f, 0.04038496f, 
    -0.32110608f, -0.20053716f, -0.04629128f, -0.21700312f, -0.00315138f, -0.09095584f, 0.04112186f, 0.06115121f, 
    -0.03368730f, 0.05511450f, -0.07707307f, 0.13324673f, 0.05047126f, 0.11362173f, 0.11796844f, 0.01466645f, 
    0.12569490f, 0.05839719f, 0.10251230f, -0.02535426f, -0.02506514f, 0.03784187f, -0.00992147f, 0.11633603f, 
    -0.05957149f, -0.03776833f, -0.00048939f, -0.00592328f, 0.03178950f, 0.00383267f, 0.14639397f, 0.00927254f, 
    -0.05700109f, -0.11240881f, -0.00975564f, 0.02174879f, -0.08751338f, -0.02668391f, -0.00733237f, 0.02608571f, 
    0.12671725f, 0.15184321f, 0.10177073f, -0.13037562f, 0.13257098f, 0.05103278f, 0.10630606f, 0.08141144f, 
    0.40598199f, 0.34964478f, 0.16795821f, 0.10710426f, 0.08967098f, -0.02010697f, 0.05538914f, 0.01797109f, 
    0.05607600f, 0.10762191f, -0.00882891f, 0.09761473f, 0.31187356f, -0.25051853f, 0.04178027f, 0.00064911f, 
    0.02736182f, -0.04336837f, -0.01887365f, 0.12731974f, 0.17975336f, -0.17837286f, -0.06620801f, 0.12737080f, 
    -0.06204514f, 0.08750734f, -0.21052156f, -0.11417735f, 0.09627189f, -0.00999909f, -0.11700010f, -0.08802842f, 
    0.10136308f, -0.01450203f, -0.00755210f, 0.00296205f, 0.11247750f, -0.04481433f, 0.16543092f, -0.14141455f, 
    0.04419446f, -0.05016602f, 0.10041799f, 0.03551014f, 0.01619520f, 0.11388811f, -0.02306712f, 0.01412933f, 
    -0.30422240f, -0.35977986f, 0.01163731f, -0.04524312f, -0.04699271f, 0.07323268f, -0.02169775f, 0.00705004f, 
    0.15734379f, 0.04567755f, 0.07173746f, 0.05200866f, 0.33407977f, 0.21397395f, 0.10653134f, 0.08303186f, 
    0.06007875f, 0.07402968f, 0.06774662f, 0.01457000f, 0.02193328f, 0.09777614f, 0.14111879f, 0.15084434f, 
    0.26407504f, 0.17589436f, 0.23960400f, 0.08729892f, 0.09017835f, 0.05362033f, 0.06021143f, 0.15998483f, 
    0.00837735f, 0.07084469f, 0.00989090f, 0.09810091f, 0.23221959f, 0.09540018f, 0.17644690f, -0.09812216f, 
    0.07454345f, 0.10566737f, 0.01530757f, -0.02896425f, 0.00962356f, 0.13950594f, 0.04597886f, -0.09944756f, 
    0.08688156f, -0.15180020f, 0.13206770f, -0.15524861f, 0.11031332f, 0.04467094f, -0.02131367f, 0.12921250f, 
    0.12695372f, 0.18139912f, 0.09075431f, 0.09140468f, -0.04245827f, -0.30737701f, -0.09010098f, -0.00838045f, 
    -0.00661391f, -0.06296880f, 0.03102055f, -0.03865426f, 0.05166524f, -0.03154615f, -0.11567479f, -0.02136255f, 
    -0.08177053f, 0.03323691f, 0.03029677f, -0.03155592f, -0.07417526f, 0.06279752f, 0.00061154f, -0.11588019f, 
    0.06662017f, -0.00894363f, 0.02748713f, 0.04823357f, -0.14719011f, -0.01964390f, -0.17312171f, -0.00396183f, 
    0.07186293f, -0.00132586f, 0.02138991f, 0.03953848f, 0.05074089f, 0.05461077f, 0.03127102f, -0.01559730f, 
    -0.03954712f, 0.03230814f, -0.02505545f, -0.03354106f, -0.00318100f, 0.02934061f, 0.01512963f, 0.05025752f, 
    0.04635313f, -0.03385848f, 0.04477119f, -0.00149042f, -0.00604386f, -0.02343738f, -0.00043545f, 0.00028711f, 
    0.04223454f, 0.03926069f, 0.04436097f, -0.02874364f, 0.03726343f, 0.02246525f, -0.02557273f, -0.03000976f, 
    0.03013558f, 0.00772112f, -0.01424296f, 0.02794541f, -0.04635475f, 0.01364623f, 0.01746009f, -0.00883044f, 
    0.04007106f, 0.03849931f, 0.00914243f, -0.00982437f, -0.02735065f, -0.01044523f, -0.05043836f, -0.00125782f, 
    -0.05641532f, -0.02832429f, 0.00095810f, 0.01933896f, -0.03695276f, -0.00563850f, -0.00327087f, 0.02342778f, 
    0.01469981f, 0.01467240f, 0.00284031f, 0.02067567f, 0.03528502f, 0.01926416f, 0.03005481f, -0.00835285f, 
    -0.01845286f, -0.03049201f, 0.02850573f, -0.02116522f, -0.04673311f, -0.02107309f, -0.04030415f, 0.03449206f, 
    0.00343043f, 0.00801764f, 0.02238805f, -0.04970573f, -0.02002234f, -0.05371063f, 0.03683963f, -0.03062299f, 
    0.03046780f, -0.02651443f, 0.04128115f, -0.05189925f, 0.04811647f, -0.04276789f, 0.05075737f, -0.02245541f, 
    -0.04474026f, -0.01833400f, -0.03258394f, 0.04070013f, -0.01479747f, -0.03607158f, -0.05798787f, -0.05899109f, 
    -0.00409256f, -0.02399204f, 0.00354483f, -0.05106222f, -0.04554180f, -0.05602891f, -0.00119825f, 0.02618588f, 
    -0.05858884f, -0.04489122f, -0.01159354f, -0.02540828f, 0.02048808f, 0.03531002f, -0.02921840f, -0.02393308f, 
    -0.03436844f, -0.00522501f, 0.03452043f, -0.02368601f, -0.02449596f, -0.01635436f, -0.05396279f, -0.04521480f, 
    0.04206942f, -0.04425579f, -0.03996195f, 0.03137024f, -0.04772542f, -0.01703772f, 0.03483138f, 0.03086548f, 
    0.00599050f, -0.04884757f, 0.04295113f, 0.01119053f, -0.02960144f, 0.02643372f, -0.02047398f, -0.03251970f, 
    0.05364377f, 0.01836681f, 0.00035685f, -0.01393265f, 0.00261716f, 0.03075395f, 0.03150807f, 0.02796509f, 
    0.01969467f, -0.00174561f, -0.01009493f, 0.01633512f, -0.03184560f, 0.03652240f, -0.00577233f, 0.03395335f, 
    -0.02287975f, 0.03014060f, -0.02203841f, -0.05427900f, 0.02297538f, 0.03444528f, 0.01924749f, -0.03613850f, 
    0.02940781f, 0.00101019f, 0.00536458f, -0.02568783f, -0.00627612f, 0.02259370f, 0.02940037f, 0.01875836f, 
    -0.02663005f, -0.03889102f, 0.01478943f, -0.04251017f, -0.05079592f, 0.03194574f, 0.01531722f, -0.03649799f, 
    -0.04379324f, -0.05094018f, -0.05668109f, 0.02392123f, -0.02203407f, 0.00699207f, 0.01844217f, -0.00462330f, 
    0.03563302f, -0.00539189f, -0.05454566f, -0.04583186f, -0.05535932f, -0.04581160f, -0.02884290f, 0.02780763f, 
    -0.01639657f, -0.05745264f, 0.00858158f, -0.04307247f, 0.00302616f, 0.00064180f, -0.03113827f, -0.00808255f, 
    -0.03156179f, -0.03942609f, 0.00917015f, 0.00982634f, -0.00523122f, 0.02286688f, -0.02727928f, 0.02860676f, 
    -0.01464317f, 0.04725614f, -0.03472577f, 0.03102876f, 0.01714807f, 0.04567207f, -0.04045704f, -0.02917470f, 
    0.00474568f, -0.01883851f, -0.03725923f, 0.02205456f, -0.01380648f, 0.00245154f, -0.04706940f, 0.02694165f, 
    -0.02926998f, -0.02839429f, -0.00435648f, -0.05283603f, -0.05760909f, 0.02586854f, 0.03530948f, 0.04017197f, 
    0.02418040f, 0.01582493f, -0.01153126f, -0.00382130f, 0.01775991f, 0.01229764f, 0.01187068f, 0.00801975f, 
    -0.01391391f, -0.01015976f, -0.02946018f, -0.01062431f, 0.01164953f, 0.03560691f, 0.02038449f, 0.00198569f, 
    -0.04911214f, -0.02449994f, -0.03972638f, -0.04827850f, -0.00592761f, -0.02037629f, 0.02632693f, -0.01986398f, 
    0.02313041f, 0.02453371f, -0.04079315f, -0.01188532f, 0.00527016f, -0.00481283f, 0.01858518f, 0.00809976f, 
    0.01200094f, 0.00473772f, 0.00458228f, 0.01760308f, -0.04145885f, -0.04424838f, 0.03555414f, -0.05303749f, 
    0.04521894f, -0.01732207f, 0.02300051f, -0.02073744f, 0.01701283f, -0.03882436f, -0.05449639f, -0.04348266f, 
    -0.02064988f, -0.03792256f, -0.05077471f, 0.05051450f, 0.00713882f, 0.04467849f, 0.04098234f, 0.02224743f, 
    -0.00418062f, -0.05570841f, 0.03744264f, -0.03208701f, 0.04599075f, -0.04282684f, 0.02012674f, 0.00716399f, 
    -0.01957027f, -0.01808387f, -0.03455175f, -0.04024760f, 0.01594402f, -0.02769447f, -0.03099362f, 0.03683135f, 
    -0.04196284f, -0.00171503f, 0.03891091f, -0.01190523f, 0.01447110f, 0.01935824f, -0.02793277f, -0.05819467f, 
    -0.04524145f, 0.04082448f, 0.00992201f, 0.01374261f, 0.00893225f, 0.00019897f, -0.03296209f, -0.04620563f, 
    -0.06554585f, 0.03474922f, 0.03828268f, -0.02206586f, -0.01023046f, 0.03261335f, 0.00137605f, -0.03807862f, 
    -0.01253194f, 0.02465757f, -0.03326101f, 0.00721793f, -0.04105520f, 0.00268894f, -0.05474512f, -0.04582844f, 
    -0.04520318f, 0.00995138f, -0.04426681f, 0.02181358f, -0.03029106f, 0.01665275f, 0.04171822f, -0.02471161f, 
    0.01168416f, -0.02575421f, -0.03646712f, -0.00359129f, -0.05406764f, -0.01621492f, 0.02104431f, 0.02890898f, 
    0.00979713f, 0.03614824f, -0.04652104f, -0.03942528f, -0.04207011f, -0.00946818f, 0.03591159f, 0.01997354f, 
    -0.00791716f, -0.02384740f, 0.03494949f, -0.00426277f, -0.04976082f, -0.02791873f, -0.00634338f, -0.00046093f, 
    -0.05151683f, 0.02751894f, 0.01119007f, -0.02682400f, -0.03647380f, 0.03930575f, -0.04429176f, -0.03452381f, 
    -0.00325812f, -0.02291488f, -0.03038484f, 0.04008228f, -0.01633527f, -0.02785456f, -0.01125636f, -0.03404376f, 
    -0.05209971f, 0.03007768f, 0.01483407f, 0.04195456f, -0.00058132f, 0.02520408f, -0.05951562f, 0.02052683f, 
    -0.00214896f, -0.01911746f, -0.01433476f, 0.01498579f, 0.03829067f, 0.03532812f, -0.02655504f, 0.00612261f, 
    0.01306922f, -0.05184243f, 0.03806600f, -0.05247660f, -0.02101014f, -0.00118120f, -0.03048451f, -0.02049133f, 
    -0.05311053f, -0.01507307f, 0.02446062f, -0.01485508f, -0.03522031f, 0.03243249f, -0.03644124f, 0.00424921f, 
    0.03491386f, 0.00588822f, -0.01384947f, -0.05528761f, -0.01889812f, -0.06400007f, -0.02644979f, -0.05029885f, 
    -0.01604399f, -0.04905463f, -0.05026768f, -0.05742335f, -0.03331102f, -0.06315068f, 0.01345768f, -0.06151590f, 
    -0.03667124f, -0.00388746f, 0.01566589f, -0.00695133f, 0.03481235f, -0.05056798f, -0.00067583f, -0.04387128f, 
    -0.04557790f, 0.00401534f, -0.05598231f, 0.00705317f, -0.03199652f, -0.04409756f, -0.03485083f, -0.04365668f, 
    -0.05673437f, -0.03551397f, -0.05025758f, -0.01576789f, -0.04327405f, -0.04415511f, 0.03008540f, 0.03571166f, 
    0.00870508f, -0.01861233f, -0.02503875f, -0.02791437f, 0.01409080f, 0.04015655f, -0.00776947f, 0.00558438f, 
    -0.05193916f, 0.04092700f, -0.03077053f, 0.03731681f, -0.05715898f, -0.01000529f, 0.03140585f, -0.04141144f, 
    0.04509744f, 0.01067158f, -0.01115005f, -0.00513665f, 0.03910238f, -0.03677091f, -0.01121548f, 0.02607958f, 
    0.02193719f, 0.00381055f, 0.00702657f, 0.00826424f, -0.03373659f, -0.02654994f, 0.01647962f, -0.04371006f, 
    -0.05226972f, -0.01451400f, -0.01099438f, -0.05372199f, -0.04814359f, -0.02543292f, -0.00309001f, 0.00827744f, 
    0.02505146f, -0.05004475f, 0.03502171f, 0.01070425f, -0.03262562f, 0.03796279f, -0.04692421f, 0.04630479f, 
    0.02836300f, -0.00090121f, 0.00787408f, -0.04895896f, -0.00014837f, 0.02976045f, 0.00399032f, 0.00150416f, 
    -0.05379369f, 0.02294352f, -0.05384686f, 0.01659145f, 0.02125988f, -0.01705943f, -0.02555745f, 0.01221925f, 
    -0.04295060f, 0.02860020f, -0.05531460f, 0.02373372f, -0.03290218f, -0.00617174f, -0.00820854f, 0.01799770f, 
    0.03550954f, -0.05589500f, -0.01081184f, -0.01757098f, 0.03147819f, -0.01361705f, 0.03404975f, 0.02731995f, 
    0.00958378f, -0.00686310f, 0.01907745f, 0.02516803f, 0.03892348f, -0.04474985f, 0.04413913f, -0.00725537f, 
    -0.05685801f, -0.00270567f, -0.00685637f, 0.04595247f, 0.04359455f, -0.00613713f, 0.00750924f, -0.00758636f, 
    0.02444583f, 0.03597985f, -0.04674033f, 0.02696548f, -0.05872762f, -0.03645074f, -0.01836207f, -0.04455549f, 
    -0.04897414f, -0.01953960f, 0.03084213f, -0.04667823f, -0.02805522f, -0.04436009f, 0.00689274f, 0.00107363f, 
    -0.03899387f, -0.01803092f, -0.04619712f, 0.04187039f, -0.04689261f, -0.01221060f, 0.00538450f, -0.02336363f, 
    -0.02756079f, -0.04201971f, 0.02674240f, 0.02700174f, -0.05533415f, 0.00756727f, -0.03510764f, 0.00090173f, 
    -0.00609997f, -0.04340843f, 0.01776472f, -0.04703268f, 0.00998573f, -0.00773473f, -0.04175957f, 0.02871421f, 
    0.00812256f, 0.00047812f, -0.00007868f, -0.03909736f, -0.02907253f, 0.00649122f, -0.04936033f, -0.01149268f, 
    0.02109275f, -0.03013005f, 0.02299277f, -0.01836267f, 0.02941271f, -0.03336504f, 0.02024459f, -0.01614721f, 
    -0.04476432f, -0.04551181f, -0.01755052f, -0.03008808f, -0.04323349f, 0.03678802f, 0.01327524f, 0.01086234f, 
    -0.02569834f, 0.03674874f, -0.01263173f, -0.03483989f, -0.00521652f, 0.03692029f, -0.04251470f, -0.01942211f, 
    -0.01034975f, -0.04845925f, 0.03681170f, 0.02455722f, 0.03554140f, -0.02169923f, -0.00668942f, 0.01242790f, 
    -0.00927131f, 0.02163410f, -0.05332313f, 0.02431193f, 0.02560581f, -0.01619816f, 0.04343240f, -0.04164777f, 
    -0.02315087f, -0.00657806f, 0.01574367f, -0.00775161f, 0.03599540f, 0.01006585f, 0.00228406f, -0.00125630f, 
    -0.02829378f, -0.05302132f, -0.02410822f, -0.01065569f, -0.00368907f, 0.02880074f, 0.00841179f, -0.00167494f, 
    -0.00593191f, -0.04676212f, 0.01311788f, -0.02692425f, 0.02834797f, 0.04409076f, 0.02306014f, 0.00808117f, 
    0.00034795f, -0.02351945f, -0.01532518f, 0.00566169f, 0.03290981f, -0.00294486f, -0.06182266f, 0.01755142f, 
    0.04152626f, -0.02004438f, -0.01321197f, 0.02470411f, -0.01572540f, -0.01005098f, 0.01193216f, 0.01814309f, 
    0.01866822f, -0.03016077f, -0.04799521f, 0.03447529f, -0.00961748f, 0.00852572f, -0.02765782f, -0.02509138f, 
    -0.03274029f, -0.03977064f, 0.00717258f, -0.03260920f, 0.02330237f, -0.03302542f, 0.01399812f, -0.01028534f, 
    0.04255085f, 0.04311593f, -0.04896493f, -0.04628964f, -0.03959352f, -0.06316295f, 0.03595802f, -0.05736933f, 
    0.02950587f, 0.01268097f, -0.04973572f, -0.05129939f, -0.03962004f, 0.02900028f, -0.05477326f, 0.02879555f, 
    0.01131724f, 0.04572235f, -0.04416253f, -0.04303289f, 0.03971136f, 0.01361783f, 0.03571464f, 0.01661114f, 
    0.01688805f, 0.04211249f, -0.01848396f, 0.04176912f, 0.00309501f, 0.03151403f, -0.00418379f, 0.02920913f, 
    0.00412525f, -0.02569060f, -0.00399691f, 0.01529131f, 0.04300681f, -0.02014175f, -0.01460387f, 0.01369129f, 
    -0.03150084f, -0.01715961f, -0.03949945f, -0.05544823f, -0.02020127f, 0.03665468f, -0.04519195f, -0.03577209f, 
    -0.02693398f, -0.05433147f, 0.01884638f, -0.02066536f, -0.03783401f, 0.02182945f, -0.02924221f, 0.04484416f, 
    0.03237468f, -0.01505217f, -0.04555193f, 0.04336620f, 0.02601008f, 0.02513677f, -0.04535503f, -0.02059666f, 
    0.04037643f, 0.03869963f, 0.00754092f, -0.03332717f, 0.02527028f, -0.05007338f, 0.00722607f, -0.02735790f, 
    0.03858157f, 0.00347348f, -0.04759197f, 0.01511467f, -0.04057031f, 0.01534580f, -0.05654895f, -0.01906851f, 
    0.12207200f, -0.14324251f, -0.10085296f, -0.13303702f, 0.08925722f, -0.06835669f, -0.06441424f, -0.13117926f, 
    0.06036926f, -0.06288221f, 0.00010070f, -0.11244243f, -0.16872008f, 0.20454268f, 0.26907441f, 0.12502141f, 
    -0.06317984f, 0.02559207f, -0.00823645f, 0.08920757f, -0.00817436f, -0.03161199f, 0.05788904f, 0.09107897f, 
    -0.02665766f, 0.21628261f, -0.13865592f, -0.43473753f, -0.05772140f, 0.04245825f, 0.00835487f, 0.01644905f, 
    -0.14277835f, -0.10941067f, 0.01133474f, 0.01455289f, 0.22825876f, -0.26896098f, -0.12661889f, -0.33772495f, 
    0.02746553f, -0.18423273f, 0.03860487f, -0.02834534f, 0.06812485f, 0.01127108f, 0.04225586f, 0.09177811f, 
    -0.44962603f, 0.11216467f, 0.06001571f, -0.04957333f, 0.21902764f, 0.10830103f, 0.04789175f, 0.10149059f, 
    0.08386881f, -0.01306980f, 0.05502963f, -0.20704354f, -0.10755789f, 0.05730597f, 0.13959566f, 0.05309778f, 
    0.05407784f, -0.11670000f, -0.02020654f, -0.20803642f, 0.09945830f, 0.11582260f, -0.09513015f, 0.05133943f, 
    -0.02037015f, -0.09556215f, -0.01179996f, 0.18281491f, 0.13853711f, -0.08007596f, 0.02571215f, 0.03411538f, 
    0.19152220f, -0.00098554f, 0.00282788f, -0.01169256f, 0.18362702f, -0.18683484f, 0.09158617f, 0.22935855f, 
    0.19939493f, -0.01188136f, 0.08430448f, -0.05398956f, 0.05383050f, 0.04983262f, 0.11587307f, 0.07948049f, 
    -0.21443565f, 0.40114936f, 0.12213447f, -0.16210522f, 0.14510943f, -0.15806554f, -0.12604633f, -0.10646410f, 
    -0.05528686f, -0.15574165f, 0.01867183f, -0.22068009f, -0.22453634f, -0.13413958f, 0.04733505f, -0.03216866f, 
    -0.17334045f, 0.04375178f, 0.01434013f, 0.04339376f, -0.04618371f, -0.08046851f, 0.01073675f, 0.04152230f, 
    0.31329489f, -0.09432104f, 0.12205692f, 0.09650158f, -0.23853025f, 0.00223435f, -0.00278954f, 0.00174011f, 
    0.00064939f, 0.04594887f, 0.07740794f, 0.04242572f, 0.06228461f, 0.19819376f, 0.04939070f, 0.08252719f, 
    0.16100702f, -0.04956149f, 0.15704279f, -0.05208601f, 0.07162427f, -0.08798377f, 0.01230397f, 0.01239901f, 
    -0.41489753f, -0.02411783f, 0.14155398f, -0.00305437f, 0.06957810f, 0.10788427f, 0.04195961f, 0.13090107f, 
    0.07107139f, 0.10784540f, 0.03652065f, 0.15314291f, 0.06166924f, -0.17306705f, -0.09042057f, 0.04703470f, 
    -0.13472617f, 0.02055049f, -0.03210365f, -0.11582918f, 0.02151334f, -0.06802534f, 0.05464781f, 0.01676457f, 
    0.16427194f, 0.18403007f, 0.09014826f, 0.12575762f, 0.08011279f, 0.09051309f, 0.00537993f, 0.02952193f, 
    0.01189774f, -0.09852207f, 0.00534541f, -0.02489993f, -0.21977568f, 0.09446592f, 0.00324586f, -0.06842794f, 
    0.03630067f, 0.10698220f, 0.15689504f, -0.02734530f, 0.10023844f, 0.01376066f, 0.08238869f, -0.08092829f, 
    0.25728980f, 0.01002213f, -0.11554740f, 0.13901101f, 0.10957342f, 0.04688030f, -0.04029422f, -0.07521038f, 
    0.07364292f, 0.00156541f, 0.15346056f, -0.01721808f, -0.04214127f, 0.01112438f, -0.09185987f, -0.04216443f, 
    -0.06242359f, 0.02819371f, 0.15140431f, -0.08269550f, -0.09030642f, -0.01032320f, 0.01056902f, 0.10594576f, 
    -0.09837513f, 0.03553282f, 0.05558765f, 0.12651338f, 0.07170076f, -0.14963259f, -0.04204149f, 0.17512226f, 
    0.19164227f, 0.12899728f, 0.06788769f, -0.09489434f, 0.03231736f, -0.11975539f, 0.03793804f, 0.01836688f, 
    -0.03779989f, 0.17141017f, 0.09110795f, -0.04845072f, 0.05305275f, 0.00500309f, -0.09316511f, 0.03924137f, 
    0.04176966f, -0.15335658f, -0.18785849f, -0.24864680f, 0.14881016f, -0.07123137f, -0.02052950f, 0.04108159f, 
    -0.00692545f, -0.07181889f, 0.09018000f, 0.06350511f, -0.37541586f, 0.55627060f, -0.00587656f, -0.11626428f, 
    0.07414290f, -0.00136861f, 0.10332265f, 0.01458250f, -0.06655198f, -0.03780802f, -0.04793510f, -0.06110515f, 
    -0.31488028f, 0.23378921f, -0.03113101f, -0.06794887f, 0.03107294f, 0.04135545f, -0.12038296f, 0.02740153f, 
    -0.04580316f, -0.06907132f, 0.06792583f, 0.03000853f, 0.02922118f, 0.08223513f, 0.03050312f, 0.18745999f, 
    0.10359311f, -0.20338430f, -0.00788501f, -0.08272245f, 0.13608968f, 0.14022569f, -0.18447842f, 0.07877925f, 
    -0.22174889f, -0.04000342f, 0.24539641f, 0.25342876f, 0.11198637f, -0.05997356f, 0.15723336f, 0.10230523f, 
    0.00196144f, 0.07418752f, -0.11843692f, -0.05266679f, -0.04751235f, -0.06287640f, -0.07612582f, -0.05169705f, 
    0.03230527f, 0.03791991f, 0.00268854f, 0.00113675f, 0.17166144f, -0.08889104f, 0.05922824f, 0.12155682f, 
    0.05124434f, -0.01414851f, -0.14755842f, 0.10451319f, 0.12294231f, 0.04246227f, 0.00216432f, -0.04181198f, 
    0.04665853f, -0.00306553f, -0.03073024f, -0.01523969f, -0.02384070f, -0.12871414f, 0.08566820f, 0.13028997f, 
    0.09815093f, -0.04510741f, -0.04064639f, -0.03956956f, -0.05600397f, -0.09212660f, -0.09401754f, 0.10865933f, 
    -0.31434885f, 0.13473895f, -0.14714092f, -0.02807428f, 0.06648637f, 0.01458929f, -0.05945427f, 0.08456127f, 
    -0.08102929f, -0.06233739f, 0.02633428f, 0.01356236f, 0.13538706f, -0.01098406f, -0.07442215f, -0.08589204f, 
    0.05642697f, -0.03604038f, -0.01777663f, 0.05751556f, 0.14206721f, 0.11779008f, 0.01378406f, 0.19641851f, 
    -0.24738657f, 0.08825676f, 0.14097393f, -0.04110402f, 0.21694161f, 0.01378160f, 0.11215799f, 0.07890172f, 
    0.09398366f, 0.19915172f, 0.09741863f, 0.20551071f, 0.16370723f, -0.10846811f, 0.12989347f, 0.21915363f, 
    -0.02978402f, 0.01496958f, -0.15550981f, -0.15585342f, 0.01850390f, 0.03820342f, 0.00588800f, 0.04167983f, 
    -0.21041709f, -0.11166328f, -0.01969298f, 0.08644442f, -0.17154481f, -0.06720698f, 0.03087012f, -0.00210977f, 
    0.03952344f, -0.10308768f, -0.02004512f, 0.00882812f, -0.29357532f, -0.19316323f, 0.22019841f, 0.32220030f, 
    -0.02392034f, -0.00103195f, 0.03241880f, 0.03717208f, -0.03611633f, 0.10019214f, -0.12249471f, 0.00168084f, 
    -0.08746003f, 0.19810943f, 0.23864251f, 0.02591305f, -0.03582029f, 0.14003307f, 0.09666412f, 0.11471344f, 
    0.00997229f, 0.04887936f, -0.11537655f, 0.07047710f, -0.04109478f, -0.08910686f, 0.03625941f, 0.09092378f, 
    -0.03705417f, -0.06399864f, 0.02182306f, 0.01411750f, 0.06176748f, -0.04564270f, -0.02309670f, 0.00881937f, 
    -0.20797051f, 0.04898977f, -0.27033937f, 0.19161104f, -0.02551129f, 0.08033215f, 0.05075644f, -0.05642939f, 
    -0.01212861f, 0.10813378f, 0.04992414f, 0.02446968f, 0.14663075f, -0.14189704f, -0.28293091f, -0.04224749f, 
    0.25849098f, 0.03276984f, -0.01613037f, 0.09246415f, 0.08351728f, 0.01501243f, 0.01464382f, -0.07839750f, 
    -0.11199411f, 0.08240588f, -0.10019857f, 0.09374267f, 0.23717523f, -0.13282610f, 0.01426844f, 0.00968513f, 
    0.02820908f, 0.09764170f, -0.02439688f, -0.07088220f, 0.02330216f, -0.12327101f, 0.13570887f, 0.25814018f, 
    0.08524269f, 0.04268119f, -0.06014746f, 0.02087706f, 0.03108345f, 0.02591981f, 0.12429985f, 0.14244805f, 
    -0.09597159f, 0.12080215f, -0.03642078f, -0.06538422f, 0.04098043f, 0.03993310f, -0.03467590f, -0.01914245f, 
    0.00326516f, -0.00133502f, -0.08072998f, -0.10495068f, -0.22593959f, -0.21663979f, 0.22920497f, 0.24603932f, 
    0.03758981f, 0.04069698f, 0.13045201f, 0.11997034f, 0.08989780f, -0.05125739f, 0.05401621f, 0.08149505f, 
    0.07543328f, 0.03041401f, 0.23143959f, 0.06210986f, -0.17041701f, -0.01704672f, -0.01487442f, 0.05602673f, 
    0.06917635f, 0.08600098f, 0.06996594f, 0.08668927f, -0.11155267f, -0.03994875f, -0.29984474f, -0.16076353f, 
    0.15392639f, 0.05308517f, 0.02795050f, -0.23094493f, -0.04544679f, 0.12948826f, -0.10153542f, -0.02299696f, 
    -0.23103502f, -0.18096365f, -0.16003390f, -0.00364797f, -0.01491561f, -0.00783537f, -0.01543041f, 0.02949315f, 
    0.08384847f, 0.01738531f, -0.07081565f, 0.01762436f, 0.35232902f, -0.09735192f, 0.26806304f, 0.34609413f, 
    0.05789259f, -0.09118008f, -0.02629947f, 0.02330185f, -0.04356191f, -0.11962751f, 0.03851196f, 0.13052382f, 
    -0.24147284f, 0.06513374f, -0.20249455f, -0.05347733f, 0.09268890f, 0.04258009f, -0.04646602f, -0.15798424f, 
    0.08028672f, 0.01854995f, 0.13372083f, 0.02416414f, -0.33148384f, -0.02590477f, -0.12507723f, -0.21556565f, 
    0.04607475f, 0.02588758f, 0.23089193f, -0.05109821f, -0.01809118f, -0.07968435f, -0.08327809f, 0.10237441f, 
    0.35390463f, 0.09235055f, -0.08550615f, 0.07163636f, 0.04506004f, 0.15933734f, -0.06061397f, -0.09269337f, 
    -0.00421257f, -0.01534263f, 0.00792007f, 0.02838019f, -0.02733257f, -0.05540449f, 0.06128236f, -0.11174376f, 
    -0.02203343f, 0.12353704f, -0.04621422f, -0.04925945f, 0.01830151f, -0.02412850f, 0.16853529f, 0.06364308f, 
    -0.06840241f, -0.00319721f, -0.01421983f, 0.01654946f, 0.13647139f, 0.05251510f, -0.04008953f, 0.02168947f, 
    0.01190136f, 0.17848498f, 0.06312899f, -0.11780857f, -0.10685374f, 0.01860056f, 0.05071645f, -0.01522044f, 
    0.01452243f, 0.00513231f, 0.07179222f, -0.03815255f, 0.11193748f, -0.13409160f, 0.04640082f, 0.06177779f, 
    -0.16367525f, 0.10542949f, 0.10740194f, -0.14334495f, -0.10930081f, -0.00176447f, 0.10328386f, -0.00220388f, 
    0.01507248f, 0.00593082f, -0.00875607f, 0.02776931f, 0.10477033f, 0.09386712f, -0.05874227f, -0.17532676f, 
    0.10834983f, 0.07669497f, -0.06625612f, -0.00074194f, -0.02852702f, 0.05923083f, -0.05771500f, 0.06356399f, 
    0.21857317f, -0.13577199f, 0.16470955f, 0.43521827f, 0.01051801f, 0.06021716f, 0.03469475f, 0.16077840f, 
    -0.01076992f, 0.01803650f, 0.12223550f, -0.02575895f, -0.00834128f, 0.22925223f, 0.21846411f, -0.11378191f, 
    0.01652915f, -0.01672032f, 0.05484439f, -0.06328265f, 0.04955413f, -0.00875415f, -0.04869903f, 0.00520862f, 
    0.02607694f, 0.19330662f, 0.13535610f, 0.33457682f, -0.04307899f, 0.04173171f, 0.10459062f, 0.17624144f, 
    -0.09147510f, 0.14370099f, -0.03153681f, -0.12817532f, -0.12662131f, -0.00493897f, 0.01051270f, -0.03878267f, 
    -0.10679700f, 0.01044170f, -0.01059348f, -0.02413232f, 0.14616303f, -0.06509574f, -0.00037677f, 0.07495292f, 
    -0.08884375f, 0.12669975f, 0.14426301f, -0.02463634f, 0.00624105f, 0.03341993f, 0.12021852f, 0.12071474f, 
    0.08495973f, 0.01401451f, -0.03767355f, 0.06318846f, -0.25190949f, 0.11851116f, 0.23004258f, -0.03217518f, 
    -0.05957396f, -0.00128724f, 0.10886290f, 0.11175077f, 0.03635088f, -0.06031903f, -0.01748754f, 0.06553030f, 
    -0.28889555f, -0.01810955f, -0.12827501f, 0.09550294f, -0.00460523f, 0.13189094f, -0.04243272f, 0.10632983f, 
    -0.02294051f, -0.02369540f, -0.00042586f, 0.01596203f, -0.13334070f, 0.23901279f, -0.02299680f, 0.10799721f, 
    0.12018412f, -0.22386879f, 0.00773928f, -0.11689348f, -0.03023226f, 0.00318692f, 0.05028382f, -0.05314983f, 
    -0.02711802f, 0.04608914f, -0.10717431f, 0.02811611f, 0.11832061f, 0.07066789f, 0.14635533f, 0.07697368f, 
    0.11542225f, 0.13656433f, 0.05233213f, 0.05580989f, 0.11034582f, -0.17717703f, 0.20336105f, 0.08933177f, 
    -0.00517008f, 0.10335185f, 0.03549882f, -0.04160097f, 0.10176536f, -0.03055102f, -0.09965253f, 0.03487925f, 
    0.00386007f, -0.04654139f, -0.04713005f, -0.02918403f, -0.01991258f, 0.02448260f, -0.01949916f, -0.03031058f, 
    -0.02924342f, -0.03362871f, 0.00948825f, 0.01273517f, 0.02582988f, -0.01277996f, 0.04738081f, 0.04623196f, 
    -0.00488986f, 0.02610368f, 0.02530879f, -0.01453228f, 0.01007187f, -0.00074596f, -0.05668082f, -0.03214625f, 
    0.04711810f, 0.02338095f, 0.01336061f, 0.00128656f, 0.04672050f, 0.00153740f, -0.00255361f, 0.02661478f, 
    -0.05621834f, 0.03236430f, 0.04921797f, -0.01231524f, 0.02295215f, -0.05193425f, -0.01065116f, 0.04200341f, 
    -0.03511497f, -0.02237456f, -0.00956668f, -0.00755897f, 0.02476661f, -0.00474338f, -0.02696142f, -0.01749933f, 
    -0.01755369f, 0.00013478f, 0.04573178f, 0.04240980f, -0.01437424f, 0.03321512f, -0.00784124f, -0.04439783f, 
    -0.05654255f, -0.02291405f, -0.02356784f, 0.00939723f, -0.02305821f, -0.01447002f, -0.03513470f, 0.03170345f, 
    -0.01691326f, -0.04870823f, -0.03709793f, 0.03041463f, -0.02861346f, -0.02071017f, 0.02744236f, -0.02551689f, 
    -0.00826525f, 0.03596505f, -0.04108956f, -0.03393866f, 0.00900384f, 0.00548239f, 0.00596306f, 0.00811994f, 
    -0.02858119f, 0.01120744f, -0.00943672f, 0.03273114f, 0.04686018f, 0.01673271f, 0.02336366f, -0.02036064f, 
    -0.01193243f, -0.03864515f, 0.00511162f, -0.04347266f, 0.01396783f, -0.04775844f, -0.01857683f, 0.00520604f, 
    0.02787640f, -0.01570762f, 0.00386192f, -0.02743915f, 0.01510015f, -0.04847214f, -0.00764751f, 0.03195735f, 
    -0.01442003f, 0.00093808f, -0.02032844f, -0.03148082f, 0.02309293f, 0.01704404f, -0.03232353f, 0.01746187f, 
    -0.00968964f, 0.02823540f, -0.01255336f, -0.01898291f, -0.04591434f, 0.00192766f, 0.02023602f, 0.03224076f, 
    0.03823702f, -0.04370958f, -0.04651933f, -0.02706800f, -0.04443571f, 0.01323123f, 0.04582710f, 0.00074795f, 
    -0.00412560f, 0.00099671f, -0.01092870f, -0.02845931f, -0.01489842f, 0.00490765f, -0.01556458f, -0.00266043f, 
    -0.03510509f, 0.03143196f, 0.03907368f, -0.01669237f, -0.00386876f, 0.01139051f, -0.03578696f, -0.00319599f, 
    0.01564823f, -0.04120569f, 0.01125740f, 0.02673211f, -0.03813712f, -0.01798134f, -0.01592164f, 0.01538057f, 
    0.04423824f, -0.04751025f, -0.00619076f, -0.02813350f, 0.01690414f, 0.04660530f, -0.01753568f, -0.05367154f, 
    0.03375201f, -0.03585753f, -0.04875041f, -0.00421220f, 0.02237943f, -0.01489290f, -0.00956778f, 0.01005447f, 
    -0.05095147f, -0.00044936f, -0.01860400f, 0.01084849f, -0.04049565f, -0.03175971f, -0.03654587f, 0.01328119f, 
    -0.02478272f, -0.05381826f, -0.00949588f, -0.03012387f, -0.03060626f, -0.05538440f, 0.01957682f, 0.04538474f, 
    -0.04648053f, 0.00980375f, 0.00022013f, 0.01916177f, -0.01557078f, -0.00438728f, 0.02606989f, 0.04562663f, 
    -0.03253940f, 0.01682438f, 0.04961808f, 0.00641061f, -0.05019201f, -0.00402534f, 0.03974802f, 0.02421877f, 
    -0.02679439f, -0.02997080f, -0.04378123f, -0.01959431f, -0.02759254f, 0.00124350f, -0.05845275f, 0.03485595f, 
    -0.01619446f, 0.03301594f, -0.03426502f, -0.00020046f, 0.02659681f, 0.03150462f, -0.05551818f, 0.00723814f, 
    0.03609703f, 0.00904125f, 0.00432959f, -0.04474321f, -0.01301484f, 0.02867524f, -0.01759848f, 0.01899720f, 
    -0.01565413f, 0.03189657f, 0.04871564f, 0.03754105f, -0.04740387f, -0.00864553f, 0.00881439f, 0.03867713f, 
    -0.00124457f, -0.01458799f, 0.01825638f, 0.03666004f, -0.01069162f, 0.02703889f, -0.01615709f, 0.01821460f, 
    -0.04548067f, -0.02300609f, 0.03981407f, -0.03276789f, 0.02283176f, 0.00121903f, -0.03723793f, 0.00077391f, 
    -0.00833518f, 0.00653494f, -0.04203905f, -0.01984878f, -0.04344644f, 0.00881101f, -0.05130354f, -0.04583329f, 
    -0.05174631f, -0.04226427f, 0.01159497f, -0.03666370f, -0.03260738f, -0.02989755f, 0.02139138f, -0.02456619f, 
    -0.03482917f, -0.03675630f, -0.03926654f, -0.01448435f, -0.02898438f, -0.03937796f, -0.03723261f, 0.02817248f, 
    -0.01500586f, 0.00439498f, -0.00544331f, -0.02439673f, 0.00583038f, 0.01058921f, -0.01685623f, -0.05250159f, 
    -0.02039464f, 0.01514137f, 0.00644626f, -0.04957880f, 0.02798734f, -0.03798165f, 0.00882407f, -0.01263965f, 
    0.03772430f, -0.01470577f, -0.00853453f, -0.01632854f, -0.03721053f, 0.02973455f, -0.03682991f, -0.01612046f, 
    0.01295188f, 0.02708370f, 0.02386568f, -0.00656089f, 0.03820460f, -0.06187693f, -0.02181249f, 0.01304194f, 
    -0.00170449f, -0.00252384f, -0.02755600f, -0.05423428f, -0.05131700f, 0.03750456f, -0.01748433f, 0.02372719f, 
    -0.03761723f, -0.01102091f, 0.02972225f, 0.00539257f, -0.03215621f, -0.01092522f, 0.00829263f, 0.04885925f, 
    -0.04421617f, 0.01379685f, -0.00139559f, -0.02637204f, 0.03023806f, -0.00606315f, -0.02942317f, 0.02278620f, 
    -0.00181633f, -0.03834159f, -0.02861710f, 0.03953781f, 0.00178480f, 0.01552205f, -0.05336056f, -0.05575392f, 
    0.02606577f, 0.01350954f, -0.04763677f, -0.05958698f, 0.00892862f, -0.02089481f, -0.04899821f, 0.00840723f, 
    -0.03292965f, -0.03254689f, 0.01956043f, 0.04217208f, 0.03490655f, -0.01138166f, -0.01907807f, -0.01086807f, 
    -0.04281998f, -0.00369246f, 0.00820230f, 0.02624403f, 0.00796258f, 0.01163842f, -0.01433442f, 0.03918314f, 
    0.02913273f, 0.04523879f, -0.05192160f, 0.02964924f, -0.01069514f, -0.04900690f, -0.05627951f, 0.03605356f, 
    0.01814724f, -0.01554041f, 0.01623927f, -0.03629962f, -0.02490335f, 0.01083848f, 0.01063313f, -0.04104044f, 
    0.04603796f, -0.04343791f, 0.02525660f, -0.03782355f, -0.00197360f, -0.01003180f, 0.00407662f, -0.01282907f, 
    -0.02546778f, -0.04908526f, -0.02365045f, -0.03917053f, 0.01186992f, 0.04179224f, -0.03281778f, -0.01731786f, 
    -0.01880655f, -0.02821727f, -0.03116075f, -0.02877111f, -0.00711457f, -0.04355991f, 0.01820750f, -0.00832377f, 
    0.03737585f, 0.02970381f, -0.04057057f, -0.03476212f, 0.01999468f, -0.00850194f, -0.04681924f, -0.00179441f, 
    -0.02729237f, 0.02054438f, 0.04377896f, -0.02116053f, -0.02500739f, -0.05354238f, -0.02605552f, 0.03706657f, 
    0.00854914f, -0.04836746f, 0.02095514f, 0.02707513f, -0.05616284f, 0.04429040f, 0.02350551f, 0.05033042f, 
    -0.04232939f, -0.00616632f, -0.01100517f, -0.01920110f, 0.02882679f, 0.03396988f, -0.04137938f, 0.01541475f, 
    0.02255555f, 0.02019679f, -0.00510277f, 0.03147834f, 0.03730006f, -0.03196682f, 0.03351210f, -0.04303547f, 
    -0.05337349f, -0.02559300f, -0.04700990f, 0.03261074f, 0.03723796f, -0.03014710f, -0.04285577f, 0.02782900f, 
    -0.03239902f, 0.01557264f, -0.02550314f, 0.02640223f, -0.04116776f, -0.01167936f, -0.00481781f, -0.03360522f, 
    0.02292418f, -0.00617507f, -0.01558796f, -0.03408171f, 0.02312307f, 0.04116607f, 0.00107652f, 0.00974981f, 
    -0.02031479f, 0.05013391f, 0.03658959f, -0.01287596f, 0.00931285f, 0.00303316f, 0.03639384f, 0.02565401f, 
    0.02156385f, -0.04415231f, -0.03811781f, -0.02272627f, 0.03113763f, 0.02821452f, -0.02542374f, -0.03477644f, 
    0.00698937f, -0.04281612f, -0.00596911f, 0.02255303f, -0.01539865f, 0.00032141f, -0.05295829f, -0.03784349f, 
    -0.03900617f, 0.03867566f, -0.02309599f, 0.00057003f, 0.01177239f, -0.04233907f, -0.00052340f, -0.03654880f, 
    -0.05603610f, 0.00683686f, -0.01990294f, -0.02180273f, 0.02870717f, -0.05538959f, -0.00618911f, -0.03660182f, 
    -0.05253379f, -0.05237024f, 0.02337521f, 0.04455042f, -0.03905791f, 0.01296188f, -0.02452723f, -0.01062630f, 
    0.00396983f, 0.03194250f, -0.00191422f, -0.05025190f, -0.03998937f, 0.03248729f, 0.01105339f, -0.02660419f, 
    -0.02534400f, -0.02970793f, -0.05461409f, 0.00174303f, -0.02447605f, -0.03131982f, -0.04426859f, 0.01089362f, 
    0.00730371f, -0.03076306f, -0.04992736f, -0.02850821f, 0.01680408f, -0.01995547f, -0.00455617f, -0.01010743f, 
    -0.03156301f, -0.00178172f, -0.02941558f, -0.02263236f, 0.01257609f, 0.04235031f, -0.02314964f, -0.05209863f, 
    0.03051892f, -0.04184902f, 0.01243519f, 0.01270433f, 0.04305735f, -0.02916335f, 0.03655354f, -0.03992445f, 
    0.02505688f, -0.01539813f, 0.03522560f, 0.02370050f, 0.03131701f, -0.02021838f, -0.02225444f, -0.04772877f, 
    0.02965003f, -0.01167916f, 0.02290646f, 0.01388034f, 0.02859754f, 0.04372380f, -0.01278450f, -0.04660529f, 
    0.03145982f, 0.01065469f, -0.02751629f, 0.03836885f, -0.01619132f, 0.02308722f, 0.01755119f, 0.03523277f, 
    -0.00644689f, -0.02543513f, -0.02230563f, 0.01318377f, -0.01242817f, -0.03587257f, -0.05124277f, 0.01977357f, 
    0.00391965f, 0.00197645f, -0.03383122f, 0.01950409f, -0.01831860f, 0.01836339f, 0.01991968f, -0.00973663f, 
    0.04080302f, -0.00387547f, 0.03699942f, -0.02257575f, -0.01284231f, -0.00232363f, -0.05122063f, -0.03007414f, 
    -0.04824562f, -0.04869444f, 0.00811117f, 0.02110942f, 0.00466107f, -0.03470372f, -0.04648389f, -0.04150226f, 
    -0.02531737f, -0.05509603f, 0.00204457f, -0.00454827f, -0.04339574f, 0.00256006f, 0.02046128f, 0.02988610f, 
    0.02378909f, 0.01470499f, 0.02874728f, -0.00645649f, 0.03230318f, 0.00254384f, -0.02349621f, -0.02663291f, 
    -0.03045476f, 0.02279508f, -0.05138906f, -0.01841931f, 0.03302694f, -0.00523464f, -0.03593469f, -0.02946967f, 
    -0.03169331f, 0.04374072f, -0.04571499f, -0.03027146f, -0.01737513f, -0.02433290f, -0.04818629f, -0.04984399f, 
    0.01729853f, -0.01161673f, -0.03960581f, 0.03503222f, -0.03761274f, 0.02963870f, 0.02212774f, -0.01786123f, 
    0.02219087f, -0.02727220f, -0.05078369f, -0.01365628f, 0.01726802f, -0.02000911f, -0.02563830f, 0.00027014f, 
    0.00010450f, -0.00722295f, 0.01579121f, -0.00846451f, -0.00850471f, -0.05525028f, 0.00239712f, 0.03324611f, 
    -0.01644947f, -0.03444407f, 0.00503273f, 0.02967791f, 0.00599368f, -0.04448709f, 0.04082780f, 0.04193577f, 
    0.01172834f, 0.03805832f, -0.03906923f, -0.01990860f, -0.01166750f, -0.00694521f, 0.00975034f, 0.04095835f, 
    -0.04587081f, -0.03397978f, 0.03630912f, 0.02363709f, 0.04313101f, 0.02499428f, -0.00568774f, -0.00040110f, 
    -0.02248806f, -0.02517463f, 0.01203557f, 0.01169208f, -0.03271627f, 0.01196899f, -0.04389063f, -0.04555523f, 
    0.00467407f, -0.04318495f, -0.00480790f, -0.05237019f, -0.02075710f, 0.02856106f, -0.05553600f, -0.02107549f, 
    -0.03730551f, 0.01626861f, -0.00334351f, -0.03966848f, 0.02790857f, -0.04348756f, -0.01511418f, 0.02770820f, 
    -0.01338599f, 0.00321003f, -0.03153516f, -0.02475416f, 0.04132785f, 0.03982592f, 0.03403736f, 0.02761763f, 
    0.01777241f, -0.02939592f, -0.02851651f, 0.04238892f, -0.02816031f, -0.02804322f, -0.03827170f, -0.04855256f, 
    -0.03673822f, 0.04530152f, -0.05218332f, -0.02762562f, -0.03988570f, -0.04549633f, -0.01110944f, 0.02248190f, 
    0.02665831f, 0.01127784f, 0.00725196f, -0.03611483f, 0.04443077f, 0.00880377f, -0.05375011f, 0.00410909f, 
    0.04106135f, -0.01678459f, -0.00115605f, 0.01826033f, 0.03548181f, 0.03585379f, 0.03490974f, -0.02986082f, 
    0.01187551f, 0.00152001f, -0.02044133f, 0.02826784f, 0.01989092f, -0.04317599f, -0.03703380f, -0.02744717f, 
    -0.04456978f, 0.03812573f, -0.01218605f, -0.01652481f, -0.01056527f, -0.02943203f, -0.01640508f, 0.04228901f, 
    -0.09668587f, -0.12570399f, -0.05703844f, -0.07322881f, -0.07877868f, 0.08621772f, -0.02162957f, 0.00343982f, 
    0.08874116f, -0.04780453f, 0.16237035f, -0.00680509f, -0.09262425f, 0.05655702f, -0.02297504f, 0.27609834f, 
    0.02096990f, -0.03188078f, 0.23081537f, 0.04015293f, 0.05682712f, 0.00874054f, -0.09605081f, -0.08924361f, 
    0.12462953f, 0.07985891f, -0.18343379f, 0.15944102f, -0.04357400f, 0.02266314f, 0.11803925f, 0.11126076f, 
    0.08750869f, 0.01161769f, 0.03855713f, 0.09907752f, -0.29846013f, -0.16514909f, -0.03414769f, -0.03417131f, 
    0.00451356f, 0.10676519f, -0.05191649f, -0.04906293f, -0.10331418f, -0.01196555f, 0.00123851f, 0.17254440f, 
    -0.01932650f, 0.04905960f, -0.14847845f, 0.03629960f, -0.20072106f, -0.10470116f, 0.05706552f, 0.11521912f, 
    -0.11359470f, 0.16415693f, -0.04002026f, -0.01560082f, 0.12284838f, 0.08520330f, -0.03017719f, 0.06021355f, 
    0.07845719f, 0.06897097f, -0.03386268f, -0.02156164f, 0.21163981f, 0.12123857f, -0.13635364f, 0.06909347f, 
    0.02486121f, -0.15868001f, 0.03877262f, -0.01187552f, 0.01439051f, -0.03916634f, 0.03947800f, 0.01260964f, 
    0.15505242f, -0.07419378f, 0.08576835f, 0.08464266f, 0.32327768f, 0.10505812f, -0.01921307f, 0.16226506f, 
    0.12718955f, -0.00617741f, -0.02229258f, 0.06202721f, 0.02942065f, 0.02927864f, -0.00855209f, 0.10618650f, 
    -0.33501476f, 0.10889385f, -0.00375788f, 0.05724511f, 0.02664306f, -0.06759875f, 0.00032609f, 0.01163682f, 
    0.01445749f, 0.01419132f, 0.06680357f, -0.11489308f, -0.33326423f, -0.27630112f, 0.05351172f, -0.08146831f, 
    0.06189539f, -0.03284905f, 0.06969492f, -0.02928868f, 0.00167273f, 0.03800173f, 0.10525543f, 0.11387445f, 
    -0.29179677f, 0.05334876f, 0.23773000f, 0.29440847f, 0.03318766f, 0.02380369f, -0.00936785f, -0.04295538f, 
    0.08730720f, 0.05488115f, 0.06782283f, 0.04711324f, 0.06804164f, 0.32424831f, -0.22058332f, 0.07024001f, 
    -0.13907588f, -0.07174023f, 0.00500104f, 0.00557397f, 0.06048983f, 0.00519539f, -0.01100079f, 0.01432513f, 
    0.27359575f, 0.07143307f, 0.01128234f, -0.05748669f, -0.03674948f, -0.05354510f, 0.10057062f, 0.05736719f, 
    0.08577596f, -0.04069346f, -0.11332518f, 0.00048986f, -0.15801674f, -0.12375426f, -0.00618590f, 0.36682847f, 
    0.15303959f, 0.04899522f, -0.04808537f, 0.01027504f, 0.26822603f, -0.14685883f, 0.07945053f, -0.01098333f, 
    0.01012055f, 0.12016747f, -0.08869282f, 0.06761707f, -0.06287140f, 0.03447468f, -0.03613681f, 0.04445124f, 
    -0.03355382f, -0.02466466f, 0.05664611f, -0.07439397f, -0.23091727f, 0.31857583f, 0.00860546f, -0.04153530f, 
    -0.16678850f, -0.10808409f, 0.11842563f, -0.15188934f, 0.14209121f, 0.00078050f, -0.06133611f, 0.08095008f, 
    0.33436641f, 0.21670245f, 0.00485458f, -0.05897749f, 0.12779032f, 0.13733330f, -0.09714604f, -0.16362937f, 
    -0.01790367f, 0.06782398f, 0.05243377f, -0.03579825f, 0.05333938f, -0.08165143f, -0.00336293f, -0.05974846f, 
    -0.06065369f, 0.03773780f, 0.18373699f, 0.08498473f, 0.07040328f, -0.00332087f, -0.00277942f, 0.06578881f, 
    0.19155249f, 0.15377478f, 0.01084059f, 0.00151808f, -0.02222954f, 0.07258502f, -0.05758392f, -0.00714931f, 
    0.12208883f, 0.13512783f, 0.14582086f, 0.06969389f, 0.14577152f, -0.34011284f, 0.13807283f, 0.00890062f, 
    -0.07862722f, 0.05807462f, 0.07417636f, 0.02902147f, 0.11981501f, -0.13019538f, -0.05953993f, 0.03452926f, 
    -0.22298178f, -0.00823094f, -0.02459705f, 0.07848615f, -0.04746764f, 0.05268235f, -0.05036844f, -0.07855235f, 
    -0.03412264f, -0.04980195f, 0.05325391f, -0.08786840f, 0.06596267f, -0.01706015f, -0.08308022f, -0.12938035f, 
    -0.04942907f, 0.00549659f, 0.08882556f, -0.05568028f, 0.00951701f, -0.00049621f, -0.09170441f, 0.04687807f, 
    0.12896550f, -0.14774996f, -0.18167809f, 0.13286571f, -0.14845385f, -0.00973256f, -0.08482606f, 0.17269026f, 
    0.01575961f, 0.04653920f, 0.16984296f, -0.03896867f, 0.22763897f, 0.00428947f, -0.12431981f, -0.05132099f, 
    0.04764176f, -0.04602514f, 0.04556227f, -0.01709999f, 0.10659961f, 0.10269573f, 0.09557306f, -0.01205633f, 
    0.55923283f, 0.32019952f, 0.05591552f, 0.21447998f, 0.19469626f, -0.04427505f, 0.01084328f, 0.15857734f, 
    0.00554172f, 0.14760894f, -0.05911574f, -0.13661589f, -0.22769092f, -0.31657600f, 0.00421452f, 0.08182126f, 
    0.01350654f, 0.14898501f, 0.06675258f, -0.09771077f, -0.04863361f, -0.12638925f, 0.08863398f, 0.05398482f, 
    -0.08461453f, 0.05874961f, -0.18037531f, 0.11544343f, -0.05698157f, 0.10765313f, 0.07109722f, 0.08172030f, 
    0.13266206f, 0.11164263f, 0.12469077f, 0.00194190f, 0.03930931f, -0.17339556f, 0.09317088f, 0.14500594f, 
    0.00498225f, 0.03113301f, 0.02021941f, -0.00705922f, 0.00331332f, -0.09007792f, 0.05090002f, 0.12565117f, 
    -0.04286976f, -0.08433726f, 0.19346233f, -0.02508096f, 0.00739515f, 0.05066370f, 0.03420259f, 0.05835000f, 
    -0.12353671f, 0.01565519f, 0.01691851f, 0.02784503f, -0.04312694f, 0.38365948f, 0.11572910f, -0.08630602f, 
    0.11322400f, -0.12007023f, -0.12096553f, 0.04869474f, 0.00424838f, 0.07688800f, 0.02994229f, 0.20455225f, 
    -0.02542603f, -0.02484300f, 0.28445563f, -0.02895099f, -0.04417606f, -0.07877751f, 0.15659790f, -0.01363853f, 
    -0.02137332f, 0.08814377f, 0.04598321f, 0.10405391f, -0.28581271f, 0.40785256f, 0.17012659f, 0.16187011f, 
    -0.05014299f, 0.13142484f, 0.05305079f, -0.11845384f, 0.07883561f, -0.04413222f, -0.06637945f, 0.08971787f, 
    -0.03180281f, 0.02590854f, -0.11522880f, 0.02115058f, -0.00456903f, -0.04252297f, -0.06550468f, 0.15371253f, 
    0.01729016f, 0.11376330f, 0.08389322f, -0.07328184f, 0.18080047f, 0.03448788f, -0.07084437f, 0.15961827f, 
    -0.05094114f, 0.05343910f, 0.02125298f, -0.05228817f, 0.01863616f, 0.04555000f, 0.00327085f, 0.06417491f, 
    0.13647301f, 0.12691046f, 0.10253181f, 0.28999656f, 0.04483414f, -0.04323198f, -0.10430527f, 0.04301045f, 
    -0.01732090f, -0.00904277f, -0.05084711f, 0.01994068f, 0.29975277f, 0.22307691f, -0.13558675f, 0.15964851f, 
    0.20216057f, -0.00779380f, -0.26004148f, 0.03545816f, 0.03659723f, 0.04434591f, -0.02619967f, 0.01217983f, 
    -0.21856111f, -0.32665068f, -0.01242609f, -0.01178609f, -0.07864188f, 0.17515685f, -0.07274604f, 0.00142696f, 
    -0.10482141f, 0.11307276f, 0.10897070f, 0.10606077f, 0.12259855f, 0.03949407f, -0.21632555f, -0.04960471f, 
    0.07310282f, -0.00499634f, -0.12397502f, 0.06608985f, 0.07872898f, 0.02933541f, -0.04859555f, -0.03013344f, 
    -0.14396802f, 0.20394555f, 0.09968492f, 0.05776128f, 0.18685748f, -0.01665706f, 0.03669053f, 0.06514024f, 
    -0.01264749f, -0.13312094f, -0.02803751f, -0.10253078f, -0.14722273f, 0.10437172f, -0.07092615f, 0.02310168f, 
    0.02093844f, 0.05198473f, 0.04341536f, -0.05437271f, -0.00555601f, 0.10424499f, -0.00169263f, -0.06664585f, 
    -0.07725260f, -0.24611533f, -0.00184018f, 0.13995868f, 0.06806791f, 0.09343554f, -0.03360363f, -0.01947897f, 
    -0.03249538f, 0.05847211f, 0.00901296f, 0.13950050f, 0.36300462f, 0.18821336f, -0.12438019f, 0.22349885f, 
    0.21744584f, 0.08349536f, -0.08560668f, 0.03391383f, 0.06135139f, -0.02654095f, 0.02364483f, 0.16686343f, 
    0.18689096f, 0.19626398f, 0.00186556f, 0.07089530f, 0.09523010f, 0.08737024f, 0.07537837f, 0.05951666f, 
    0.08515091f, -0.04745889f, -0.04854505f, -0.03013496f, 0.11114231f, -0.25596765f, -0.23098807f, -0.24546212f, 
    -0.01117907f, 0.12843828f, 0.04699655f, -0.04090155f, -0.07622078f, 0.01944118f, -0.07287858f, 0.00664736f, 
    -0.02536564f, -0.03803732f, -0.18672749f, -0.00224231f, -0.03338993f, -0.06628668f, 0.02971905f, 0.02529882f, 
    0.02132213f, 0.04501107f, 0.16308083f, -0.11550560f, 0.39970541f, 0.23734723f, -0.03657869f, 0.07777145f, 
    0.07455247f, -0.05685265f, 0.10309582f, 0.05143367f, 0.08575850f, -0.04206892f, 0.06171862f, 0.07868346f, 
    0.07123136f, -0.22875434f, -0.23336703f, -0.27450410f, -0.06267949f, 0.11495902f, -0.10437601f, -0.06852002f, 
    0.06511662f, -0.00834451f, 0.09746655f, 0.04478858f, -0.30745989f, -0.12110550f, -0.04386440f, -0.09336645f, 
    -0.02638046f, 0.07427027f, 0.08862328f, 0.05656373f, -0.11465101f, -0.00347497f, 0.03350818f, 0.10333776f, 
    -0.01872380f, -0.01814764f, -0.00735732f, -0.16882759f, -0.08245680f, -0.02871620f, 0.08560118f, -0.02037267f, 
    0.01545781f, 0.08242911f, 0.00325287f, 0.01556886f, -0.06041050f, 0.05541887f, 0.16620106f, -0.02151788f, 
    0.11307092f, -0.03751290f, 0.04581823f, 0.01286372f, 0.03977781f, 0.14525557f, -0.01109889f, 0.09139346f, 
    -0.13755210f, 0.09909167f, -0.19658363f, 0.00646789f, 0.01747051f, -0.01838606f, -0.06624296f, -0.08754992f, 
    0.01508356f, -0.00579148f, -0.08710426f, -0.03011519f, -0.04988898f, -0.19275548f, -0.06865755f, 0.11761837f, 
    0.11369058f, 0.06676669f, -0.06330843f, -0.07781612f, 0.13646860f, -0.01962470f, 0.11872791f, 0.11735881f, 
    0.34358162f, 0.22224963f, -0.01968269f, 0.19819242f, 0.02958073f, -0.08163977f, 0.03345123f, 0.00954405f, 
    -0.00246089f, 0.01810170f, -0.05734176f, 0.03691544f, 0.18214439f, -0.09039485f, 0.06588017f, -0.06368175f, 
    0.09904130f, -0.02782381f, 0.04257615f, 0.11397006f, 0.02163066f, -0.00924028f, -0.05779424f, 0.12222438f, 
    0.23681906f, -0.12169567f, -0.02258344f, 0.17863993f, -0.06284945f, 0.02693806f, -0.09128548f, 0.11541068f, 
    0.21996213f, 0.03106976f, 0.00873373f, 0.01595333f, 0.07241621f, -0.09067009f, 0.04700851f, -0.05085391f, 
    -0.01907383f, -0.04373508f, 0.12082295f, -0.00395481f, -0.11557985f, 0.11050695f, 0.06619941f, -0.06936437f, 
    0.05123116f, -0.16763821f, 0.19006431f, 0.17109710f, -0.11006102f, 0.07943896f, -0.01801414f, 0.00627293f, 
    0.07250398f, 0.06327501f, 0.04180291f, 0.01171296f, 0.34255520f, 0.13694671f, -0.20585661f, 0.05517787f, 
    0.13324611f, -0.01676192f, -0.11369152f, 0.02240375f, -0.00485561f, 0.02107078f, 0.04131655f, 0.06281271f, 
    0.13096511f, 0.01200769f, 0.05892002f, -0.04201864f, -0.09327832f, -0.01728377f, 0.04839622f, 0.14774714f, 
    0.01288719f, -0.03091922f, -0.00715018f, 0.02140595f, 0.32648090f, -0.01888043f, 0.01360072f, 0.07915563f, 
    0.01821251f, -0.06710300f, 0.03451397f, -0.08310159f, -0.05548973f, 0.00714824f, 0.02133268f, 0.03768453f, 
    -0.33738762f, 0.04982597f, 0.22904897f, -0.00020661f, 0.08320299f, -0.04299587f, -0.04460643f, 0.08327892f, 
    0.11993448f, -0.05501023f, -0.00133040f, 0.08254907f, -0.25641307f, -0.15156814f, -0.00210446f, -0.03382046f, 
    0.05512879f, -0.00698156f, -0.03678118f, 0.02569929f, 0.07755628f, 0.03093419f, 0.02695977f, 0.00140867f, 
    -0.17340504f, -0.03542964f, 0.08580344f, -0.09024952f, -0.06899080f, 0.11130707f, 0.08563977f, -0.08531387f, 
    0.07427765f, -0.01656955f, 0.06142620f, -0.10988725f, -0.38948122f, 0.12892488f, 0.05302271f, -0.07463312f, 
    0.14760976f, -0.00392825f, 0.01241957f, 0.11742046f, 0.01594814f, -0.00980195f, 0.06018434f, -0.02147518f, 
    0.00344447f, 0.02173990f, 0.04015886f, 0.02259953f, -0.00455921f, -0.01872131f, 0.02291140f, 0.04006985f, 
    0.02892748f, 0.00158532f, 0.04303505f, -0.02384052f, 0.01639695f, -0.05055868f, 0.02686665f, -0.05545506f, 
    -0.02546001f, 0.01268938f, -0.05237099f, -0.01691177f, 0.02231559f, 0.03806345f, 0.04864193f, -0.05221138f, 
    -0.03059473f, -0.00098823f, -0.04998102f, -0.02541016f, 0.03298707f, -0.04864942f, -0.03561427f, 0.02611123f, 
    -0.05005211f, 0.01232524f, 0.01966671f, -0.00588322f, -0.01592581f, 0.03813871f, 0.01130973f, -0.00696927f, 
    -0.03476957f, 0.02761180f, -0.02513844f, 0.03337443f, -0.00123641f, 0.02858154f, -0.04780818f, 0.02506560f, 
    -0.04803507f, 0.01405308f, -0.03414103f, -0.04751639f, -0.03652667f, -0.00241264f, -0.03495587f, -0.04492082f, 
    -0.03447045f, 0.04081412f, -0.00808388f, -0.03018301f, -0.00301412f, -0.02600972f, 0.02208828f, 0.01562355f, 
    0.02021940f, 0.02376152f, 0.04010406f, -0.04052513f, -0.00345348f, 0.00442836f, -0.03007909f, -0.03899299f, 
    -0.03903198f, 0.03149339f, -0.00177554f, 0.00790277f, -0.00783847f, -0.03706950f, 0.01302759f, 0.00727966f, 
    0.03221624f, -0.01624470f, 0.02607121f, -0.05940530f, 0.02364627f, -0.04764471f, -0.02548416f, -0.03614200f, 
    0.00922719f, -0.03800234f, -0.01888699f, 0.02506479f, -0.03310344f, 0.03547549f, 0.03130505f, 0.03355633f, 
    0.02860444f, -0.04433498f, 0.00532835f, -0.01829366f, 0.04355426f, 0.00894804f, -0.01570007f, 0.00963426f, 
    0.02804210f, -0.02448720f, -0.03478503f, -0.01308300f, 0.00251866f, 0.04600188f, -0.04565795f, 0.02932042f, 
    -0.03357878f, 0.00683228f, -0.05284367f, -0.04718494f, -0.02141549f, 0.03384998f, 0.03213059f, -0.04942153f, 
    0.02182886f, 0.03941714f, 0.02406831f, 0.02506231f, -0.04551120f, 0.00362023f, 0.03819872f, -0.00190669f, 
    0.01599388f, 0.03943364f, -0.01232686f, 0.03084126f, -0.03043214f, -0.03530870f, 0.00891625f, -0.03718301f, 
    0.01234500f, 0.01258948f, 0.01495964f, 0.00516319f, -0.04701440f, 0.00161485f, 0.00015944f, 0.03501626f, 
    0.01528471f, 0.02430359f, -0.03411482f, -0.04034608f, -0.00342436f, -0.05286639f, 0.00557772f, -0.00095387f, 
    0.01689782f, -0.01121842f, 0.00023898f, -0.04808198f, -0.06184384f, -0.01995174f, 0.01853251f, -0.04474823f, 
    0.03968623f, 0.01364320f, 0.03280687f, 0.01534019f, 0.04135441f, -0.03992128f, -0.01944347f, 0.01477838f, 
    -0.02731700f, 0.03493793f, 0.01318622f, 0.03475131f, 0.00221437f, -0.00527285f, -0.01981876f, 0.04179602f, 
    -0.01197252f, 0.03452764f, 0.00574198f, 0.03505480f, -0.02870965f, -0.01682721f, 0.03503804f, 0.02459821f, 
    -0.03424752f, 0.02396565f, 0.02472824f, -0.00277564f, -0.02906195f, 0.01164528f, -0.03923449f, 0.01386916f, 
    -0.05747820f, -0.00141342f, -0.01516217f, -0.05003617f, -0.00851096f, -0.00894900f, -0.04242563f, 0.00384717f, 
    0.00193677f, 0.03139982f, -0.05575388f, -0.05627784f, 0.01467322f, 0.00987010f, -0.05301421f, -0.05811659f, 
    -0.05185048f, 0.05031237f, -0.01735838f, 0.01813536f, 0.00751893f, -0.05507823f, 0.01821379f, -0.00204626f, 
    -0.03415545f, -0.05441906f, 0.01235098f, -0.02861826f, 0.04586470f, -0.02085575f, 0.03989077f, -0.03858768f, 
    -0.05104285f, -0.03868309f, -0.02397845f, -0.02922111f, 0.03856554f, -0.03835390f, -0.00227648f, -0.02533562f, 
    0.03904716f, 0.02459105f, 0.01461228f, 0.02194999f, -0.00809342f, -0.01976084f, 0.02619573f, -0.01036215f, 
    -0.03033656f, 0.04815206f, -0.05122301f, 0.02105606f, 0.01657789f, 0.00103873f, -0.01887013f, -0.03317845f, 
    0.03376349f, 0.03113532f, -0.00588990f, -0.04816694f, -0.02105126f, 0.01066236f, 0.01151235f, -0.02377738f, 
    0.01767254f, -0.02865743f, 0.00003798f, -0.00334835f, -0.03768069f, -0.05676453f, 0.04475250f, 0.01067211f, 
    -0.00121756f, -0.00418606f, -0.02158273f, -0.03147854f, 0.04091512f, -0.05255517f, -0.04423333f, 0.00281875f, 
    -0.04079618f, -0.05459366f, 0.00948700f, 0.00835907f, 0.00371772f, -0.02399327f, 0.00126329f, -0.00570392f, 
    0.03591955f, 0.00999174f, 0.00115218f, -0.04617402f, 0.02264872f, -0.02133549f, 0.00956021f, 0.03132462f, 
    -0.04142341f, -0.06314421f, 0.04618507f, 0.03017127f, 0.03725665f, -0.00298456f, -0.01064273f, 0.03182475f, 
    0.02896030f, -0.01167046f, 0.03544579f, 0.02964255f, 0.05206602f, -0.04791005f, 0.01735700f, 0.00451603f, 
    -0.00871680f, 0.03463779f, -0.03675935f, 0.01238875f, -0.00451730f, -0.00879486f, -0.04333531f, -0.00325859f, 
    0.03774595f, -0.03544315f, -0.05392099f, -0.01193052f, 0.01074046f, -0.00687123f, -0.05198757f, -0.06252057f, 
    0.02759548f, -0.03782616f, 0.02596360f, 0.00085510f, -0.01663782f, -0.03606099f, -0.04071541f, -0.02680884f, 
    0.02090082f, 0.03466722f, -0.04048720f, 0.03410069f, 0.03337605f, -0.04176527f, -0.00133763f, 0.00031178f, 
    0.03059639f, -0.00415692f, -0.02060484f, -0.01907968f, 0.00176598f, -0.04118235f, 0.02418758f, -0.04468378f, 
    -0.03643219f, -0.03057835f, -0.00358058f, 0.03209727f, -0.01163899f, -0.03512530f, -0.02287389f, -0.04936560f, 
    -0.00562216f, -0.01613122f, 0.01136929f, 0.03740753f, 0.00625386f, -0.00939938f, 0.01621431f, -0.05146445f, 
    -0.01914641f, 0.02866619f, 0.00134287f, 0.03110323f, -0.02555164f, 0.00455377f, -0.02072152f, 0.01565327f, 
    -0.00345622f, 0.01189390f, 0.01437699f, 0.01690331f, -0.04182312f, 0.03180824f, 0.00337981f, -0.04442312f, 
    0.02816518f, 0.00942101f, -0.04620958f, -0.01737103f, 0.01484981f, 0.03151540f, -0.01191622f, -0.05110182f, 
    -0.02916533f, -0.00939854f, -0.09197111f, -0.08044989f, 0.13079524f, 0.18828544f, 0.00149069f, -0.10735077f, 
    0.03958485f, 0.00357344f, 0.07292455f, -0.03698513f, 0.35872617f, -0.21965332f, 0.05893426f, 0.15901294f, 
    0.14204510f, -0.09933523f, 0.17641792f, -0.05564806f, 0.15806346f, 0.06027889f, 0.08759533f, -0.05578031f, 
    -0.18666083f, -0.22872831f, -0.11382513f, -0.07403599f, 0.02479501f, 0.06884027f, 0.12115712f, 0.04686872f, 
    0.03975704f, -0.01460877f, 0.08222137f, 0.00270713f, -0.14818940f, -0.09827178f, 0.00829578f, -0.01406193f, 
    0.00937899f, 0.12703303f, 0.03243865f, -0.01209969f, -0.02333484f, -0.06681655f, -0.01060689f, 0.11066253f, 
    0.19469619f, 0.07931847f, -0.02303658f, 0.07751592f, -0.01387542f, -0.07744383f, 0.14866947f, 0.05568160f, 
    -0.03154052f, 0.07165867f, -0.07715313f, -0.01884067f, 0.11712670f, 0.24935515f, 0.19211979f, 0.12228543f, 
    -0.10725737f, 0.12260371f, -0.01215362f, 0.02060865f, 0.14748895f, 0.02589330f, 0.01127761f, 0.11285441f, 
    0.12155969f, -0.11857736f, 0.18985811f, -0.10306335f, -0.01990530f, -0.08291633f, 0.04990298f, 0.00637531f, 
    0.12834604f, 0.00503128f, -0.06847048f, 0.12273560f, 0.29089513f, 0.09587497f, -0.00690976f, 0.01666944f, 
    0.07580950f, -0.01118908f, 0.09753563f, 0.10706113f, 0.06559891f, -0.06954650f, -0.01898340f, 0.00848223f, 
    -0.02025193f, -0.07983541f, -0.02448589f, -0.03049449f, -0.10537476f, -0.06102526f, 0.05396087f, 0.04990763f, 
    0.08567695f, 0.06366040f, -0.00145907f, 0.08767317f, -0.22118755f, -0.25478646f, -0.12965475f, -0.11393113f, 
    0.12942563f, -0.09497189f, 0.02057587f, -0.01208411f, 0.01394349f, 0.10927011f, 0.01887839f, 0.02974281f, 
    -0.15975317f, -0.27711481f, 0.00503485f, -0.07372164f, 0.08347189f, -0.12235654f, 0.00661468f, 0.03416262f, 
    0.12626347f, 0.05351447f, -0.08909641f, -0.05809100f, -0.03889280f, 0.28858775f, 0.05225905f, 0.28303814f, 
    0.01704074f, -0.03127520f, -0.05123352f, 0.06470541f, 0.00954591f, -0.04211581f, 0.12227836f, 0.11828925f, 
    0.33869004f, 0.14932626f, 0.17153218f, 0.00611740f, 0.04281367f, 0.00381863f, 0.04596283f, 0.06015495f, 
    -0.06382260f, -0.06078405f, -0.06147460f, 0.01442805f, -0.14192519f, -0.17469080f, -0.12080410f, -0.09481832f, 
    0.11373796f, 0.14999692f, -0.08680952f, -0.00490778f, 0.09435266f, 0.11332306f, 0.03685309f, -0.16337968f, 
    -0.13745372f, 0.15627556f, 0.12675092f, 0.24464890f, -0.05256730f, -0.04915250f, 0.07455146f, 0.14097372f, 
    -0.05250845f, 0.05749476f, 0.05424625f, 0.01082317f, 0.02045856f, -0.01133552f, 0.15948075f, 0.19190538f, 
    -0.13326646f, -0.03451711f, 0.08814544f, 0.06270111f, 0.12059030f, 0.02842190f, 0.01185010f, -0.03628767f, 
    0.35071620f, 0.35106689f, -0.00058304f, 0.06796251f, -0.04457171f, 0.07933898f, 0.09333410f, 0.13008742f, 
    -0.02436510f, 0.03978360f, 0.03386769f, -0.01369575f, 0.02561849f, 0.09395841f, -0.05667551f, 0.11793522f, 
    0.07077084f, -0.09503172f, 0.04788312f, 0.01790983f, 0.18857203f, 0.02734153f, 0.01951144f, 0.03606801f, 
    0.25455451f, 0.16228844f, 0.05266703f, 0.01158214f, -0.01033895f, 0.17305309f, 0.02356893f, 0.04205080f, 
    0.03988634f, 0.12500697f, 0.17556149f, 0.11369803f, 0.06086231f, 0.04988903f, -0.07107753f, 0.11982813f, 
    -0.02079952f, 0.12825117f, 0.08218545f, -0.05605906f, 0.01120432f, -0.00668900f, -0.05904476f, -0.01241122f, 
    -0.15788376f, -0.29570550f, -0.18046516f, -0.14765210f, 0.10151187f, 0.08569083f, -0.09733432f, -0.04719403f, 
    0.02267491f, -0.08320940f, 0.05841504f, -0.05054460f, 0.12983999f, -0.10092923f, -0.01165218f, 0.17615262f, 
    -0.11024907f, -0.03504282f, 0.08205526f, -0.03090657f, -0.00493129f, 0.05570344f, 0.09020801f, -0.05551672f, 
    0.07150133f, 0.20970094f, -0.04813417f, 0.03733238f, -0.01810502f, 0.17170462f, -0.00600888f, 0.07279066f, 
    0.06871741f, 0.05977293f, 0.09196571f, -0.03312601f, -0.08336572f, -0.17382012f, -0.21950425f, -0.13336013f, 
    -0.00144492f, -0.00626506f, 0.03903729f, 0.02208292f, 0.11885285f, -0.13168819f, 0.07010019f, 0.06166717f, 
    0.03102802f, 0.25197980f, -0.18809031f, -0.07973225f, 0.09655140f, 0.09204233f, -0.02345775f, 0.08335466f, 
    0.04597912f, -0.04413747f, 0.00825817f, 0.03132436f, -0.18026726f, -0.25427496f, -0.03295182f, -0.19631708f, 
    0.12141256f, 0.04090917f, 0.01394652f, -0.02615291f, -0.11906601f, -0.01650768f, -0.01589177f, -0.02168461f, 
    -0.08814424f, -0.10702106f, -0.22731990f, -0.11605101f, 0.06526388f, 0.08198580f, -0.06547850f, -0.07014871f, 
    0.10512874f, 0.04706169f, 0.01610314f, 0.12482788f, -0.07769469f, -0.20722221f, -0.12903742f, -0.12771396f, 
    0.09566625f, -0.08197574f, -0.03143672f, -0.04806709f, 0.06243613f, -0.10299727f, 0.05932797f, 0.01329645f, 
    0.07996968f, 0.21498011f, 0.05679419f, -0.08062069f, 0.01204381f, -0.04697322f, 0.07524729f, 0.01342222f, 
    -0.10803965f, -0.01240593f, -0.01007755f, 0.02908133f, 0.03472831f, 0.26657915f, 0.15742499f, -0.09124439f, 
    0.02227006f, 0.23767096f, 0.03284504f, -0.01708943f, -0.12298861f, 0.09735692f, -0.02843965f, 0.17431228f, 
    0.23009858f, 0.04707029f, 0.18224967f, 0.02668603f, -0.10517248f, -0.12061904f, 0.05429881f, 0.04739697f, 
    -0.21487090f, -0.03903656f, 0.03142622f, 0.06009982f, -0.08016038f, 0.14878494f, 0.03498343f, 0.21763335f, 
    -0.01294719f, -0.00248701f, 0.02745289f, 0.16643167f, -0.02376066f, -0.02245476f, 0.08392620f, 0.01044771f, 
    -0.18986468f, -0.03413141f, -0.06893840f, -0.08997129f, 0.07625604f, 0.22655444f, 0.04056552f, -0.03058377f, 
    0.03714694f, 0.21872051f, 0.10134211f, 0.24832948f, 0.20344892f, -0.20199934f, 0.13306624f, 0.01997099f, 
    0.06009754f, -0.06273138f, -0.09319235f, 0.00626978f, 0.01624662f, 0.06957200f, 0.02792145f, 0.07049128f, 
    0.00636103f, -0.10702451f, 0.16407569f, 0.26438636f, -0.02459275f, 0.28611580f, 0.24446619f, 0.05460470f, 
    0.10831272f, 0.10170370f, 0.03782484f, 0.17101134f, -0.36612564f, -0.11672679f, 0.17056508f, 0.21995263f, 
    -0.01011404f, 0.34643281f, 0.16512392f, -0.04264924f, 0.07179891f, 0.03171287f, 0.12115493f, -0.00974179f, 
    0.45248154f, 0.03976919f, -0.06427843f, -0.02517428f, 0.01351910f, -0.21575066f, 0.02300390f, 0.07552011f, 
    0.01833007f, -0.10027784f, -0.08682061f, 0.09919463f, -0.04625468f, -0.03309776f, 0.13723356f, 0.16425963f, 
    -0.02857994f, 0.29016557f, 0.06419032f, 0.20902222f, 0.08403432f, -0.01763725f, 0.07652391f, -0.00747495f, 
    0.04975685f, 0.01485287f, 0.15919419f, -0.18976682f, -0.06195369f, 0.01676915f, -0.05226941f, -0.00416942f, 
    -0.10389090f, -0.01095567f, -0.01940240f, -0.03366691f, -0.03119428f, 0.07813921f, 0.01887073f, -0.01459857f, 
    0.04116724f, 0.05415530f, 0.06933234f, 0.05105330f, 0.20787793f, -0.11706029f, 0.11301102f, -0.05761216f, 
    0.07701083f, -0.13140908f, 0.00261125f, -0.05951594f, -0.02463103f, 0.07291836f, 0.16007914f, 0.24331047f, 
    0.10352969f, 0.09097483f, -0.03998812f, 0.21390098f, -0.17620225f, -0.00730729f, 0.12014676f, 0.02581922f, 
    0.07275990f, 0.03503198f, 0.15293771f, 0.08014711f, 0.13109609f, 0.04947861f, -0.04748071f, -0.08034027f, 
    -0.23577861f, -0.07313995f, 0.10384325f, -0.02759099f, 0.21580534f, -0.12380619f, -0.03402481f, -0.10069960f, 
    0.03428641f, -0.03174985f, 0.04866748f, -0.08050398f, -0.26744285f, 0.04632168f, 0.05017867f, 0.20151289f, 
    0.00114613f, 0.07564085f, 0.03278142f, 0.22540772f, 0.00096015f, -0.03035631f, -0.02875987f, 0.06481905f, 
    0.08248400f, -0.02837445f, 0.11414947f, 0.00715820f, 0.10137112f, -0.00375612f, 0.06892550f, 0.05629618f, 
    -0.02051264f, 0.02963637f, 0.15149716f, 0.14218032f, -0.13017616f, 0.00791804f, 0.12481874f, 0.10918872f, 
    0.07010177f, 0.30670637f, 0.01746218f, -0.04696029f, 0.01433059f, 0.12790829f, -0.06817552f, 0.03607485f, 
    -0.34921041f, -0.04826243f, 0.17425673f, 0.09613888f, 0.00631799f, 0.11799062f, 0.16242053f, 0.17913441f, 
    -0.03159667f, 0.06991556f, 0.11285032f, 0.12725158f, 0.11808030f, -0.07934147f, -0.10007651f, 0.08693766f, 
    0.00561424f, -0.14245979f, 0.06709099f, 0.14743015f, 0.02024774f, -0.01928700f, -0.04535325f, 0.10225487f, 
    0.13001905f, 0.08167084f, -0.08077783f, 0.27966097f, -0.01724915f, 0.05736822f, -0.05544306f, 0.03238488f, 
    0.12229594f, 0.04478379f, -0.03889708f, 0.06155046f, -0.10176774f, 0.05418711f, -0.05698973f, 0.24400783f, 
    0.10609577f, 0.03472229f, 0.07998435f, 0.14226562f, 0.14645289f, 0.13409840f, 0.12969923f, -0.10830776f, 
    0.01623352f, 0.13923624f, 0.14759640f, 0.00456341f, -0.02066538f, 0.15236233f, 0.13678825f, 0.01182175f, 
    -0.07550676f, 0.13340497f, -0.00494803f, 0.02186495f, 0.01803824f, 0.44090849f, -0.04246064f, -0.00801609f, 
    0.16532834f, -0.04583417f, -0.00581190f, 0.03165377f, 0.14236005f, 0.01163396f, 0.09804576f, -0.00352861f, 
    -0.30577627f, -0.10460526f, 0.05703007f, 0.07734061f, 0.13954867f, 0.15009792f, -0.07574858f, -0.05763797f, 
    0.14140087f, -0.00670750f, 0.03001511f, 0.01060390f, 0.00613758f, -0.10601163f, -0.11590371f, 0.11239450f, 
    -0.00271734f, 0.01197651f, 0.04215676f, -0.04218306f, -0.03875078f, 0.01315142f, 0.23780844f, 0.00917651f, 
    -0.01592960f, 0.07851247f, 0.17370860f, 0.31825963f, 0.09177450f, 0.00819863f, 0.19589651f, -0.03116212f, 
    0.08437253f, 0.11696448f, 0.01266389f, 0.09631403f, -0.03665277f, 0.15217286f, -0.08000835f, -0.15064043f, 
    0.09294815f, 0.15501447f, 0.01221095f, 0.08048749f, 0.02611453f, -0.08914922f, 0.19816317f, 0.18294159f, 
    0.57205749f, 0.28842935f, -0.06027919f, -0.10962597f, 0.01977810f, 0.10158917f, -0.10863564f, 0.09549204f, 
    0.02037339f, 0.08647300f, 0.12061440f, 0.12830456f, -0.24562433f, -0.09596709f, 0.10225689f, -0.02828864f, 
    0.08693425f, 0.05591504f, 0.04391543f, 0.08529974f, 0.05400870f, 0.09457543f, -0.08495507f, -0.01116782f, 
    -0.08113495f, -0.00948378f, -0.02130816f, -0.12374000f, 0.11530405f, 0.02473862f, -0.12352087f, -0.10828605f, 
    -0.04356596f, 0.01709086f, 0.13391061f, 0.08005634f, -0.21535020f, 0.06630256f, -0.10307872f, -0.15734859f, 
    0.13318570f, 0.12133771f, -0.04167835f, -0.04060976f, 0.21172427f, 0.04106164f, 0.06922730f, 0.11255112f, 
    0.19221930f, 0.05480525f, -0.06694162f, -0.03803533f, -0.02591085f, 0.06276336f, 0.28383166f, 0.04318591f, 
    0.04637846f, 0.12027995f, -0.01895998f, -0.11354015f, 0.14312488f, 0.20339221f, 0.13730113f, -0.04112616f, 
    -0.02736118f, 0.14082241f, 0.13477071f, 0.20757484f, -0.02662228f, 0.10617445f, 0.19687989f, -0.11588203f, 
    0.29516426f, 0.06687796f, -0.09346618f, 0.11654443f, -0.06949935f, -0.21910413f, 0.03868839f, 0.11613124f, 
    -0.07348874f, -0.14931138f, 0.02099239f, -0.24622387f, 0.27602243f, -0.06423212f, 0.01027413f, 0.25830722f, 
    -0.07568338f, -0.05186120f, 0.17985713f, 0.11086234f, 0.04124289f, 0.06065654f, 0.05643963f, 0.01031344f, 
    0.00615840f, -0.02937135f, -0.00617840f, -0.04745994f, -0.08511528f, -0.13621294f, -0.03406093f, 0.09902811f, 
    0.04926276f, -0.04137270f, 0.06729171f, -0.13224724f, 0.11040111f, -0.05576832f, 0.05623962f, 0.27170148f, 
    -0.12351002f, 0.01435930f, 0.12126342f, 0.01967981f, 0.01022406f, 0.01527555f, -0.07070635f, -0.00135159f, 
    0.21277182f, 0.34539643f, 0.14237255f, 0.02099649f, -0.06391169f, 0.00722342f, -0.07970557f, 0.03350320f, 
    -0.06356174f, -0.02328460f, -0.01948044f, 0.06380739f, 0.25071681f, 0.08781136f, -0.10052011f, 0.01130123f, 
    0.12034900f, -0.04371548f, -0.17085512f, 0.09696130f, 0.06854990f, 0.06823908f, 0.00027988f, -0.02416339f, 
    -0.39388412f, -0.21433158f, -0.11040244f, 0.01190687f, -0.09807263f, 0.23811516f, -0.03700368f, 0.00885255f, 
    -0.05970949f, 0.05653602f, 0.11390032f, -0.00034866f, 0.20666821f, 0.13695014f, -0.18898062f, 0.02211579f, 
    0.17994393f, -0.05639541f, -0.10219736f, -0.03734861f, 0.02917097f, 0.11440834f, -0.07494737f, -0.07947029f, 
    -0.13726415f, 0.19788614f, 0.01660878f, 0.12984729f, 0.23521863f, -0.14047854f, -0.00077831f, 0.05829729f, 
    0.00052336f, -0.11205181f, 0.02335761f, -0.10193049f, -0.13512392f, 0.01504859f, -0.01465727f, 0.19669041f, 
    0.01570938f, 0.10013562f, -0.01064575f, -0.05134828f, -0.08162761f, 0.08181825f, 0.03988675f, 0.00712674f, 
    -0.17952734f, -0.04802185f, -0.02389967f, -0.00250773f, 0.05826105f, -0.01206276f, -0.06963620f, -0.10373012f, 
    -0.03136288f, -0.04283264f, 0.00701744f, -0.00386543f, 0.27423483f, 0.04964665f, -0.02250499f, 0.19730267f, 
    0.10406449f, 0.08698957f, 0.11433757f, 0.00759096f, 0.02219326f, 0.02344220f, -0.01355055f, 0.20907657f, 
    0.32673246f, 0.12086878f, 0.10782096f, 0.18953778f, -0.02020405f, 0.09461767f, 0.07936028f, 0.06194251f, 
    0.01561356f, -0.04175061f, 0.05244842f, 0.06186925f, 0.10634535f, -0.15917520f, -0.28714389f, -0.17596026f, 
    -0.02984654f, 0.09977379f, 0.08255652f, -0.12418476f, -0.12165764f, 0.10244694f, -0.08786224f, -0.01496808f, 
    -0.21607676f, -0.03216324f, -0.07571671f, 0.02930194f, 0.02204410f, -0.02541586f, 0.03609226f, 0.09067568f, 
    0.02790845f, 0.06834610f, 0.03329379f, -0.12203433f, 0.39749569f, 0.16939430f, 0.00652509f, 0.12481694f, 
    0.07815056f, -0.11631240f, -0.03690806f, 0.02900529f, 0.05470088f, -0.10945921f, 0.05037500f, 0.16259255f, 
    0.02071428f, -0.10056601f, -0.22676216f, -0.11403835f, -0.06561297f, 0.01292607f, -0.10026964f, -0.12474154f, 
    0.05838349f, -0.06483307f, 0.01663546f, -0.07901358f, -0.47994661f, -0.02062921f, -0.02700780f, -0.13913012f, 
    0.03592159f, 0.01807398f, 0.18071803f, -0.03173384f, -0.08034674f, -0.06179472f, -0.05747157f, 0.00812562f, 
    0.23689701f, 0.09233242f, 0.05736668f, -0.14444421f, 0.03364535f, 0.04204238f, -0.01800669f, -0.11614787f, 
    -0.05045055f, -0.02437134f, 0.06036842f, -0.02982352f, -0.03238275f, 0.06247335f, 0.11024354f, -0.15040660f, 
    0.02524362f, 0.03111671f, 0.07444084f, -0.07188427f, -0.00580464f, 0.02968669f, -0.06456678f, 0.00957954f, 
    -0.10584439f, 0.14263947f, -0.12991931f, -0.03981815f, 0.08285601f, -0.05770208f, -0.10505129f, -0.03957294f, 
    -0.00765017f, 0.00090663f, -0.04876073f, -0.09690325f, 0.00026647f, -0.17341100f, 0.01527506f, 0.06789711f, 
    0.00384029f, 0.03341078f, 0.00770566f, -0.04494112f, 0.13493861f, -0.06202344f, -0.00664667f, 0.12066167f, 
    0.35499746f, 0.12462997f, -0.03040665f, 0.02257957f, -0.06878728f, -0.00464150f, 0.12769912f, 0.06691915f, 
    -0.00069573f, -0.00891400f, 0.02965094f, 0.01712423f, -0.03080820f, 0.13600388f, 0.06706518f, -0.19090056f, 
    0.13186787f, -0.01278154f, 0.00509347f, 0.11604764f, 0.03123905f, -0.07226863f, -0.17632620f, 0.01940344f, 
    0.25979307f, -0.09823236f, -0.14650284f, 0.19523345f, -0.01794760f, 0.00801409f, -0.03936693f, 0.11856548f, 
    0.04839633f, -0.00300288f, 0.07763587f, -0.00325974f, 0.08868402f, 0.03975451f, 0.13234451f, -0.09026491f, 
    -0.02339851f, 0.01542602f, 0.15410106f, -0.03900767f, 0.04922151f, 0.10825855f, -0.02417261f, -0.09480793f, 
    0.04935502f, -0.18351726f, 0.17975545f, 0.36333182f, -0.07479468f, 0.02922399f, 0.01969322f, 0.14350504f, 
    -0.00779809f, 0.16242872f, -0.01186987f, -0.05536859f, 0.27157187f, 0.06173352f, -0.03866905f, -0.06643669f, 
    -0.02362422f, -0.00732597f, -0.01726485f, 0.03160017f, 0.06054031f, -0.10837071f, -0.02678148f, 0.08373458f, 
    0.14705843f, 0.06165071f, -0.02503155f, 0.02551131f, -0.10168462f, 0.00936320f, 0.14412828f, 0.17902835f, 
    0.00331799f, 0.03837124f, -0.07901319f, 0.09533395f, 0.29856455f, 0.00424428f, 0.12674846f, 0.07961418f, 
    -0.04770533f, -0.01260883f, 0.07225680f, 0.04329414f, -0.03357025f, -0.00315245f, -0.02804357f, 0.12367127f, 
    -0.42422312f, 0.06951732f, 0.06679799f, 0.04321043f, 0.07823527f, 0.05655631f, -0.03310330f, 0.08866418f, 
    0.00140382f, -0.07169074f, -0.05539169f, -0.01578408f, -0.03770834f, 0.00898018f, -0.04485651f, 0.08955895f, 
    0.01891546f, -0.10933751f, -0.09268274f, 0.02005521f, 0.08413859f, 0.05775452f, -0.01257221f, -0.01264326f, 
    -0.25089505f, 0.00276188f, 0.11282139f, -0.05563613f, 0.06505628f, 0.09659466f, 0.06915653f, -0.06594803f, 
    0.06177803f, 0.09739762f, -0.04328600f, -0.01632049f, -0.31755543f, 0.10425306f, 0.18725838f, 0.04927427f, 
    0.04502507f, 0.07608242f, -0.01285569f, -0.12153587f, 0.07717358f, -0.01824253f, -0.03381545f, -0.00325407f, 
    -0.03919078f, 0.02398762f, 0.00796600f, 0.03264241f, 0.01579494f, -0.01430613f, -0.04396124f, -0.01666633f, 
    0.01447108f, 0.03014106f, 0.00218469f, 0.00078609f, -0.04911744f, -0.00913205f, -0.04185554f, -0.03217042f, 
    0.01136589f, -0.01650612f, 0.03232146f, 0.04689189f, -0.05232890f, -0.02986125f, -0.04471655f, 0.03331878f, 
    -0.00798444f, -0.02563636f, 0.03636230f, 0.02675556f, 0.02953983f, -0.00304739f, -0.01245239f, -0.00725163f, 
    -0.02276705f, -0.05344155f, 0.01321399f, -0.04937693f, 0.02243530f, 0.03558941f, -0.02073828f, 0.01368042f, 
    -0.05789971f, -0.00043703f, -0.01316266f, -0.03856289f, -0.05478737f, -0.00596222f, 0.03431190f, 0.01634482f, 
    -0.03200131f, -0.05508777f, -0.01552555f, 0.00928086f, 0.01967469f, 0.02371545f, -0.05148051f, 0.00378026f, 
    -0.03001609f, -0.03098832f, 0.00979484f, 0.03041967f, -0.03622741f, -0.03505021f, 0.01208901f, -0.00243182f, 
    -0.00690830f, -0.02599433f, -0.05273539f, -0.06120965f, 0.03041734f, -0.02019449f, 0.04055429f, 0.00153234f, 
    -0.03236922f, -0.03123077f, -0.00252324f, 0.02000382f, 0.00375837f, -0.02490315f, -0.02068081f, 0.00950371f, 
    -0.02656067f, 0.02051503f, -0.00443579f, 0.03167446f, -0.03479156f, -0.00230006f, -0.05276742f, -0.04142533f, 
    0.01789758f, 0.03260007f, -0.01607948f, 0.01444003f, 0.00891760f, -0.01798509f, 0.00296657f, 0.00631817f, 
    -0.05607003f, 0.00522330f, 0.00176006f, 0.02950869f, -0.00563309f, -0.00360721f, -0.01531444f, -0.04186512f, 
    0.02398341f, -0.05816062f, -0.02085182f, -0.01968554f, 0.00330525f, 0.03377514f, -0.02362069f, -0.02875910f, 
    -0.01742770f, 0.03395466f, 0.03147753f, -0.04914996f, -0.01873028f, -0.05358477f, -0.02089882f, -0.01863801f, 
    0.03708046f, -0.01171928f, 0.03177847f, 0.00807944f, -0.02915056f, 0.02990327f, 0.00020748f, -0.01770462f, 
    -0.04215062f, -0.03023046f, -0.04700742f, 0.01180855f, 0.01630816f, 0.03479990f, -0.02283211f, -0.02207932f, 
    0.02014723f, -0.00954891f, -0.04215949f, -0.02469486f, -0.02308126f, 0.04269399f, -0.00470279f, 0.00533367f, 
    0.04201633f, -0.01026813f, -0.01958537f, 0.01541332f, -0.01032913f, -0.02387988f, 0.00357686f, 0.04407068f, 
    0.01643940f, -0.04015927f, -0.04977856f, -0.04393259f, -0.01484246f, -0.05222364f, -0.00917495f, -0.03176470f, 
    -0.02652028f, 0.00221608f, 0.02568264f, -0.00856665f, 0.01380115f, 0.01609460f, -0.00202733f, -0.00953277f, 
    -0.00925738f, -0.00509111f, 0.00199625f, -0.03288609f, 0.02989633f, 0.01051170f, -0.01592737f, 0.01179045f, 
    0.04203488f, 0.03578022f, 0.02796433f, -0.03513442f, 0.00059882f, 0.04282322f, 0.01863017f, 0.01369700f, 
    -0.04565351f, -0.00719495f, 0.01805825f, 0.03064449f, 0.00893303f, 0.00271644f, 0.00415295f, 0.01882960f, 
    -0.03881396f, 0.01540439f, 0.03259546f, -0.00076252f, 0.01740794f, -0.04532816f, -0.00553281f, 0.04242768f, 
    0.01658122f, 0.03896917f, -0.05359072f, 0.04872540f, 0.02902863f, 0.01987878f, 0.03736519f, -0.00222890f, 
    -0.05433051f, -0.05086998f, 0.01959251f, -0.02308883f, -0.05612314f, -0.05403518f, 0.01817024f, 0.01748778f, 
    0.03175474f, -0.01843833f, -0.03209979f, -0.05370073f, -0.03111356f, -0.04395873f, 0.00717243f, -0.05538412f, 
    0.01685430f, 0.02902139f, 0.02016338f, -0.04344745f, -0.04150370f, 0.04014268f, -0.05552755f, 0.02643186f, 
    0.03813901f, 0.03853571f, 0.03107981f, -0.05734781f, 0.03824434f, 0.03026793f, -0.02062810f, -0.02786840f, 
    -0.01372920f, -0.04433684f, 0.02494291f, -0.06039060f, 0.03423101f, -0.00169283f, 0.02202054f, 0.00237895f, 
    -0.05036171f, 0.02236606f, 0.02103242f, -0.03358905f, 0.01538901f, 0.00364799f, -0.04700186f, -0.00867150f, 
    0.00083632f, -0.01155469f, 0.01587594f, -0.04577530f, -0.02534538f, -0.01131243f, 0.00265623f, -0.01767102f, 
    -0.00938935f, -0.05751377f, 0.00166298f, -0.03156986f, -0.01516328f, 0.03124285f, 0.03232310f, 0.04162743f, 
    -0.03046045f, -0.03614997f, 0.02588570f, -0.05303298f, -0.01038471f, -0.03934437f, 0.03351017f, -0.01950038f, 
    -0.00652584f, -0.04775837f, 0.01167278f, -0.03602334f, -0.02774307f, -0.00305864f, -0.01276455f, -0.05510013f, 
    0.03864563f, 0.04432648f, 0.02708214f, -0.00764179f, 0.01702702f, -0.03514599f, -0.01416424f, -0.03396372f, 
    0.00414040f, 0.00297602f, 0.00563273f, -0.00042522f, 0.03217744f, -0.02856732f, -0.04340761f, -0.04304111f, 
    0.01672766f, -0.02332162f, -0.03205620f, 0.01860712f, -0.00956608f, 0.03532314f, -0.04998451f, 0.04208236f, 
    0.04228046f, -0.03794051f, 0.01476455f, 0.03477155f, -0.04575539f, -0.02736096f, 0.01540753f, 0.02078322f, 
    -0.01528709f, -0.03515409f, -0.03675136f, 0.01789915f, 0.02852446f, -0.00649661f, 0.02990210f, -0.04140409f, 
    -0.02992375f, 0.01701882f, -0.05659153f, -0.04275314f, -0.02897742f, -0.04644171f, -0.00723715f, -0.00053818f, 
    0.03999886f, 0.03232359f, -0.05575245f, 0.03060747f, 0.03085980f, -0.00648924f, -0.04484143f, -0.02444518f, 
    -0.01258897f, -0.02427088f, -0.00069497f, 0.03537086f, 0.04205900f, -0.03429166f, -0.00910770f, 0.00807373f, 
    0.00411743f, -0.02316255f, -0.05827308f, -0.05828567f, -0.04304008f, 0.04023419f, 0.01578899f, 0.04054559f, 
    -0.04207254f, -0.04571453f, -0.01700888f, -0.05040829f, 0.02822097f, -0.04827021f, 0.01408779f, 0.03931750f, 
    0.02812117f, -0.01130128f, -0.04264993f, 0.01049480f, -0.00819231f, -0.03466594f, 0.02265627f, 0.01468690f, 
    -0.02482867f, 0.03466594f, -0.03559136f, 0.01264194f, 0.03993120f, 0.00935560f, 0.01980072f, -0.04879646f, 
    0.00089500f, 0.14744930f, 0.09504282f, 0.03166814f, -0.02615987f, 0.05510311f, 0.10804821f, -0.04150711f, 
    -0.00527888f, 0.13016050f, -0.08984366f, 0.16831236f, -0.33393914f, 0.24458164f, 0.10059961f, -0.25386381f, 
    -0.03288036f, 0.10349228f, -0.11484155f, 0.00187612f, 0.00162417f, -0.02760290f, 0.09870902f, -0.03490933f, 
    0.03250668f, -0.21501608f, 0.05791463f, -0.09865443f, -0.02066330f, 0.12588201f, 0.09866033f, -0.00241820f, 
    0.15075910f, 0.01482959f, 0.01360588f, 0.06637226f, -0.19773026f, -0.15265279f, 0.09491558f, -0.13476934f, 
    -0.03608986f, 0.11809025f, 0.09790455f, -0.04109710f, -0.00345945f, 0.04585136f, 0.12040593f, -0.15538149f, 
    0.13983582f, 0.11161729f, -0.02553122f, -0.14028352f, 0.18333769f, -0.08612026f, 0.00122548f, 0.08236630f, 
    0.07097016f, -0.04085588f, -0.11160446f, 0.11643488f, -0.15880480f, -0.35009664f, 0.15500474f, 0.03740911f, 
    -0.04101904f, 0.09737149f, 0.29846829f, 0.07177830f, -0.09993640f, -0.12274407f, 0.17552707f, 0.01309324f, 
    -0.07334550f, 0.06551465f, -0.16484465f, 0.09137370f, -0.05617456f, 0.12773798f, -0.10616481f, -0.08452000f, 
    -0.00791225f, 0.08113489f, -0.05272351f, 0.02098160f, -0.24288054f, -0.16557692f, 0.00610944f, 0.02816836f, 
    -0.09098990f, -0.06716623f, 0.11765943f, 0.04354126f, 0.12266694f, 0.01549992f, 0.06889145f, 0.00796658f, 
    -0.06297941f, 0.32984287f, -0.06159266f, 0.00503190f, 0.01135527f, 0.06000011f, 0.02391776f, 0.08128536f, 
    0.05563305f, 0.02381655f, -0.00705543f, 0.13517353f, -0.05906001f, 0.16409974f, 0.15727524f, -0.13313361f, 
    -0.25235751f, 0.07367378f, 0.03086776f, 0.03309659f, 0.11486881f, 0.05749953f, 0.02370382f, -0.09738581f, 
    -0.00661042f, 0.17781132f, 0.16853935f, 0.06122290f, -0.10478614f, -0.01490089f, -0.03322324f, -0.02457465f, 
    0.05135279f, -0.01525001f, -0.03587264f, 0.02385453f, -0.16055430f, -0.17650485f, 0.25918472f, -0.02276111f, 
    0.10318179f, 0.07391161f, 0.01019914f, 0.13229813f, 0.00442739f, -0.02027435f, 0.07500031f, 0.04317754f, 
    -0.51551914f, -0.14860380f, 0.01831503f, -0.09130127f, 0.08712588f, 0.04874924f, 0.04442251f, 0.06639034f, 
    -0.01288657f, -0.02557402f, -0.02122439f, 0.17309687f, 0.01559185f, -0.02256158f, 0.24652871f, -0.00614135f, 
    -0.09971048f, 0.10794691f, 0.08372248f, -0.08524539f, -0.06071563f, 0.15074189f, 0.01806151f, 0.07912035f, 
    -0.11389078f, -0.13264716f, 0.11974364f, 0.04687096f, 0.15647297f, 0.10106831f, 0.15350890f, 0.01186162f, 
    -0.00221813f, 0.04607387f, 0.04511773f, 0.12003508f, 0.26714575f, 0.05674316f, -0.16238458f, -0.15629655f, 
    0.12241755f, -0.03631431f, -0.10124115f, 0.15120044f, 0.01887729f, -0.05098683f, 0.01201446f, -0.07200795f, 
    -0.34711561f, -0.24207021f, 0.06817529f, 0.29564351f, 0.03386505f, -0.03838840f, -0.08392783f, 0.10391819f, 
    0.12592477f, 0.00947622f, 0.02021918f, 0.09996713f, 0.03777838f, -0.20724840f, -0.00614404f, 0.16267970f, 
    0.01974802f, 0.01396604f, -0.07646934f, 0.14052229f, -0.02719158f, 0.04310254f, 0.10708154f, -0.03337696f, 
    -0.29674938f, -0.21411656f, 0.09908859f, -0.01177061f, 0.08036218f, 0.00400423f, 0.16966866f, 0.06695015f, 
    -0.06179477f, 0.05637653f, -0.12892711f, -0.06072210f, 0.08346312f, 0.22993061f, 0.13688253f, -0.21229003f, 
    0.01108411f, -0.03638590f, 0.03433782f, 0.18448235f, -0.00675733f, 0.05713116f, 0.04766156f, -0.01706548f, 
    -0.25542748f, 0.03248015f, 0.15870304f, 0.16538447f, 0.00101652f, -0.08491711f, -0.02015610f, 0.01867696f, 
    0.11444537f, 0.09823688f, 0.04885088f, 0.05065377f, -0.22880843f, 0.05451437f, -0.03083508f, 0.14225820f, 
    -0.01650525f, 0.08144104f, 0.02480644f, -0.00364506f, -0.02492742f, 0.01689800f, 0.19351120f, 0.00449236f, 
    -0.17505097f, -0.05677937f, 0.24065538f, -0.13624246f, 0.16478932f, 0.06563138f, 0.29861981f, -0.09935044f, 
    -0.04378277f, -0.03094400f, 0.00450664f, 0.08794838f, 0.13643607f, 0.15149947f, 0.00148625f, 0.24198799f, 
    0.13993867f, 0.10835149f, -0.05009314f, 0.07712948f, 0.01536949f, -0.10039982f, 0.02381842f, 0.16314074f, 
    0.17165717f, -0.04982021f, 0.10973974f, -0.23007120f, -0.06250696f, 0.05283002f, -0.01488937f, -0.10368122f, 
    -0.02311723f, -0.05498612f, 0.02957293f, 0.12141837f, -0.09423033f, 0.14388457f, 0.11070842f, 0.05229750f, 
    -0.03606275f, -0.02144293f, 0.01379684f, 0.04052754f, 0.17128477f, 0.12189805f, 0.00866419f, -0.06484378f, 
    0.04960236f, 0.12343591f, 0.20201354f, 0.16473185f, 0.05194185f, 0.00612723f, -0.03891620f, -0.05949997f, 
    0.10973226f, 0.07946634f, 0.03650067f, -0.07080826f, -0.08360808f, 0.31419599f, 0.06302092f, 0.10382180f, 
    -0.02630614f, 0.10092046f, -0.02628942f, 0.10984241f, 0.11777706f, 0.10982554f, 0.08012528f, -0.01276056f, 
    -0.04054749f, -0.12494141f, -0.22836766f, 0.10386652f, 0.00399669f, 0.01993020f, -0.02162056f, -0.08700082f, 
    0.05089409f, 0.08351912f, 0.04239472f, -0.03312323f, 0.00058823f, -0.17867586f, -0.05691421f, 0.05527385f, 
    -0.04104636f, -0.01167483f, 0.09746441f, 0.10029182f, -0.00306433f, 0.01160310f, 0.08199262f, -0.08601658f, 
    -0.03544465f, 0.04369394f, -0.29015809f, 0.00593447f, 0.09141099f, -0.01922396f, -0.08973829f, 0.21694894f, 
    0.11688282f, 0.03126217f, 0.09824320f, -0.07044946f, 0.39420703f, -0.12753920f, -0.12106340f, -0.19864984f, 
    -0.05189278f, -0.01413556f, 0.22988255f, -0.02723097f, 0.08743485f, 0.14409962f, 0.03873294f, 0.03570766f, 
    -0.21041398f, -0.13767785f, 0.02990043f, -0.16539250f, -0.07768425f, -0.07387742f, -0.02411344f, 0.02393790f, 
    0.00083682f, 0.22333150f, -0.02266802f, 0.18474868f, -0.41482902f, 0.31511295f, 0.01601346f, 0.08858047f, 
    0.14697112f, 0.07441999f, -0.19210936f, 0.05556541f, -0.08792627f, -0.00331166f, -0.08177318f, -0.09771510f, 
    0.47268841f, 0.15814836f, -0.04456375f, 0.16000484f, -0.04491119f, 0.10611615f, 0.11292653f, -0.00260789f, 
    -0.19310021f, -0.00021078f, -0.04620895f, 0.11070913f, -0.33629608f, -0.05147800f, 0.03279721f, -0.09408630f, 
    0.07423554f, -0.04182877f, 0.03795883f, 0.05820749f, 0.04292539f, -0.00825003f, 0.09070309f, -0.04103954f, 
    0.48019281f, 0.23923942f, 0.27882785f, -0.03281232f, 0.13177113f, 0.09009302f, -0.04106716f, 0.07794742f, 
    0.13460156f, -0.03662286f, 0.05603020f, 0.16020291f, 0.03521819f, -0.27676183f, 0.03254414f, -0.24001624f, 
    0.00893614f, 0.10499309f, 0.05242992f, -0.10264303f, -0.10013272f, -0.14094149f, 0.15479258f, 0.00928794f, 
    0.31114557f, -0.01208602f, 0.08173878f, 0.14040211f, -0.03708685f, 0.14994344f, -0.23147239f, -0.15380555f, 
    0.01997004f, -0.01134968f, -0.01018000f, -0.02558945f, -0.01298796f, -0.00595303f, 0.11496836f, -0.04569476f, 
    -0.08506006f, 0.00713273f, 0.03657707f, -0.07481986f, 0.02906994f, -0.10792174f, -0.07394618f, -0.10012898f, 
    -0.19865030f, 0.02185547f, 0.26771790f, 0.19115664f, 0.04508829f, 0.08008877f, 0.08924311f, -0.00850935f, 
    0.18535712f, -0.05620362f, -0.09703098f, 0.07720227f, -0.08178779f, 0.23835208f, 0.22044203f, -0.01925581f, 
    -0.03520912f, 0.04320416f, 0.02581228f, 0.23503192f, 0.08721770f, 0.05174626f, 0.01833103f, -0.13512625f, 
    0.03032028f, 0.10106120f, -0.18461217f, -0.12334611f, 0.02714003f, -0.09508530f, -0.12221412f, 0.04220751f, 
    -0.15809445f, -0.14590321f, -0.03886774f, -0.04520435f, 0.34248453f, 0.03465032f, 0.09018120f, -0.22594282f, 
    -0.02485557f, 0.11023610f, 0.07699424f, 0.12214321f, 0.07309593f, 0.05025391f, 0.00665169f, 0.05266386f, 
    0.06260736f, 0.02413338f, 0.11169501f, 0.02577961f, 0.04234432f, -0.02351497f, -0.00997555f, -0.01047539f, 
    0.03140462f, 0.07901839f, -0.08507897f, 0.05585597f, 0.16585357f, 0.28188765f, -0.00306900f, -0.05292191f, 
    -0.04509877f, 0.11762843f, 0.13902739f, 0.07511486f, -0.16105519f, 0.03755277f, 0.00259259f, 0.02058449f, 
    0.47672626f, 0.08417083f, -0.02047787f, -0.30148345f, 0.16778049f, 0.06265157f, 0.15745290f, -0.00554754f, 
    0.13797171f, -0.04169023f, 0.02230125f, 0.10844203f, 0.31119978f, 0.22859649f, -0.00493564f, -0.17169917f, 
    0.05638935f, -0.01080436f, -0.16688627f, 0.10180558f, 0.02226954f, 0.05176686f, -0.15562959f, 0.07924555f, 
    -0.10965010f, -0.03056786f, 0.15341330f, 0.02844432f, 0.04240920f, 0.02280330f, -0.01711954f, -0.04422661f, 
    0.09280765f, 0.01226563f, -0.02064937f, -0.09927446f, 0.02394217f, -0.17783247f, 0.06328279f, 0.00683916f, 
    0.02277939f, 0.03896306f, -0.11239998f, 0.10742331f, -0.03962304f, 0.07281125f, 0.02174809f, -0.08921473f, 
    0.01384157f, -0.15755491f, 0.00482659f, -0.12441262f, -0.02081936f, -0.09359823f, 0.12618306f, -0.13639668f, 
    -0.06961206f, -0.12798318f, -0.08756405f, 0.00850255f, 0.03003125f, -0.11397502f, 0.01933422f, -0.19231644f, 
    0.09504541f, -0.21563852f, -0.16032946f, 0.19534332f, -0.02572889f, 0.02706761f, 0.12733200f, -0.06794533f, 
    -0.09996723f, 0.11199500f, -0.08121954f, 0.16122270f, 0.00809899f, -0.03653907f, 0.02416095f, -0.03354259f, 
    -0.00766975f, 0.10033949f, -0.04754607f, 0.03522385f, -0.19429801f, 0.15571968f, 0.22405246f, -0.06327709f, 
    0.02149025f, 0.08236222f, 0.04834332f, 0.03634124f, -0.05949556f, 0.18739457f, 0.12664582f, 0.00922090f, 
    -0.07914597f, -0.23048256f, 0.22023048f, -0.14292327f, 0.02584973f, -0.10717386f, 0.11163709f, -0.03389207f, 
    -0.04020992f, -0.07295314f, -0.06273624f, 0.12622327f, -0.13120531f, -0.10059042f, -0.06105179f, 0.09314712f, 
    -0.05872974f, -0.01087797f, -0.02113019f, 0.02838334f, -0.04105695f, 0.06556141f, -0.00366548f, -0.00817916f, 
    0.25405535f, 0.13382281f, 0.17704269f, 0.03587699f, 0.05438749f, 0.00942292f, 0.02914269f, 0.00079576f, 
    -0.08090761f, 0.06710642f, 0.03937230f, 0.15371984f, -0.10611276f, 0.25683552f, -0.00029568f, 0.20208769f, 
    -0.01045647f, -0.07196778f, -0.01347472f, 0.07905895f, -0.04179616f, 0.18207824f, -0.00273383f, -0.07125323f, 
    -0.04019761f, -0.05303812f, 0.02765659f, -0.16338186f, -0.14710373f, -0.05818848f, -0.09149595f, -0.12905818f, 
    -0.09406999f, 0.01213873f, -0.00634943f, -0.09818032f, -0.00110183f, -0.10502224f, -0.34180388f, 0.17215984f, 
    -0.05387323f, -0.09217255f, 0.05243582f, 0.10587178f, 0.03087771f, 0.11537599f, -0.03868905f, -0.01249724f, 
    0.28877321f, -0.04472381f, 0.04281056f, 0.21081474f, 0.02490266f, -0.00409938f, 0.14376721f, -0.18149029f, 
    0.10773538f, -0.02499304f, 0.05597848f, -0.04662203f, 0.14130542f, 0.12394559f, 0.16372757f, 0.10656919f, 
    -0.06337010f, 0.06761692f, 0.01922483f, 0.04835232f, 0.10422684f, 0.06923089f, 0.13151446f, -0.09793298f, 
    -0.01927058f, 0.07144733f, 0.03842182f, 0.16841133f, 0.11586073f, 0.03580310f, -0.11882813f, 0.09615362f, 
    0.24058492f, -0.05955916f, -0.02093704f, -0.17183591f, 0.02210513f, 0.02487849f, 0.04795010f, -0.07958283f, 
    0.09920862f, 0.04661886f, 0.04304349f, 0.02043358f, 0.01788872f, 0.04281376f, 0.02006750f, -0.02024749f, 
    0.00328905f, -0.01015907f, -0.03352573f, 0.00928553f, 0.00813816f, 0.00503215f, -0.00942166f, 0.03409594f, 
    0.01282618f, 0.02483860f, -0.00814267f, -0.03974887f, 0.03821968f, -0.02806376f, 0.04438409f, -0.03766025f, 
    0.03112892f, -0.01448196f, -0.01008165f, -0.04904703f, 0.03208221f, -0.04047122f, 0.03456403f, -0.04651617f, 
    -0.01329059f, 0.01047390f, -0.04916153f, 0.04544924f, 0.03779526f, -0.06072785f, -0.04352594f, -0.03555419f, 
    0.03353737f, -0.03561090f, 0.02973747f, 0.02537783f, -0.03491512f, -0.03032561f, -0.02815524f, -0.03744595f, 
    -0.01218062f, -0.01247383f, 0.02582271f, -0.04531281f, -0.02301533f, 0.04082799f, -0.02973115f, -0.02171629f, 
    -0.05437533f, -0.02128483f, -0.00078444f, 0.01961201f, 0.00670305f, -0.02210874f, 0.01626128f, 0.02682535f, 
    0.00825022f, -0.02775617f, 0.01552912f, 0.00296979f, 0.00714281f, -0.02010478f, -0.05047894f, -0.04120103f, 
    -0.01720002f, -0.01067927f, 0.04198377f, 0.02353813f, -0.05153292f, -0.03501849f, 0.00689607f, 0.02783921f, 
    -0.01567830f, 0.02302512f, 0.01911758f, -0.00269810f, -0.02304092f, -0.04956897f, -0.04846411f, -0.04232955f, 
    -0.01296846f, -0.01752581f, -0.03688369f, 0.03959995f, -0.05406526f, -0.02856026f, 0.00050573f, 0.03762496f, 
    0.03448372f, -0.01227241f, -0.04351978f, -0.05136557f, -0.05412204f, 0.00926851f, -0.02126989f, 0.01412277f, 
    -0.03674275f, -0.01094622f, -0.03155739f, -0.00491951f, -0.00890643f, -0.00826819f, -0.01353141f, -0.00362278f, 
    0.01824559f, 0.02645500f, -0.00170856f, -0.03661093f, 0.01480443f, 0.00509941f, -0.00458503f, -0.04129695f, 
    -0.05517889f, 0.04866205f, 0.00457220f, -0.02814373f, 0.03327833f, 0.04066918f, 0.00681235f, -0.04638643f, 
    0.03193419f, -0.03849632f, -0.03400022f, 0.03012018f, 0.03038221f, 0.03168707f, 0.02119212f, -0.02652044f, 
    -0.01364554f, -0.00562309f, -0.00115709f, -0.04965264f, 0.01722079f, -0.04081463f, -0.06381590f, -0.01216653f, 
    -0.02587934f, 0.00944445f, 0.02944626f, -0.05974008f, -0.00648807f, -0.04211470f, -0.05886757f, 0.04820406f, 
    0.03100024f, 0.01062260f, 0.03451491f, -0.02514938f, -0.04061580f, 0.03130734f, 0.03645290f, 0.00509712f, 
    -0.00892702f, 0.00733588f, 0.01533450f, -0.01581096f, -0.00602818f, 0.03725171f, -0.01946980f, 0.03695576f, 
    0.03568108f, 0.03232333f, -0.00530075f, -0.01479216f, -0.02973051f, 0.03876783f, -0.01113869f, -0.00021353f, 
    -0.01299908f, -0.02410947f, -0.00611510f, 0.00729656f, -0.01585422f, 0.02393914f, -0.04232386f, -0.03809391f, 
    0.00876327f, -0.04420684f, -0.04518147f, -0.02782283f, 0.00566586f, 0.00575156f, -0.00845776f, 0.01073098f, 
    0.02242435f, -0.03883841f, 0.03833065f, -0.02871017f, -0.02653826f, 0.00080556f, -0.05562827f, 0.00829620f, 
    -0.01820565f, -0.00652141f, 0.02664818f, -0.01994972f, -0.01440329f, -0.01006673f, 0.03460914f, 0.02570585f, 
    0.00947247f, -0.04453886f, 0.02173904f, -0.01386129f, -0.02428817f, -0.03337593f, 0.04179295f, -0.04393932f, 
    0.05166664f, 0.01330211f, -0.00354516f, 0.01685586f, 0.03806655f, 0.00010790f, -0.02861132f, 0.03875885f, 
    0.01532061f, -0.02081195f, -0.00278156f, 0.03104901f, 0.01466952f, -0.03972278f, -0.00367670f, 0.00769052f, 
    0.01090316f, 0.02834609f, -0.00286652f, 0.03520488f, 0.00621242f, 0.02698303f, -0.04502854f, 0.00977130f, 
    -0.00219103f, -0.01117230f, 0.03960728f, -0.01318585f, -0.03234573f, 0.02878300f, -0.01028842f, -0.01436820f, 
    -0.00647920f, -0.00969994f, -0.03822618f, 0.01820366f, 0.00793790f, -0.05492144f, -0.01721749f, -0.03648380f, 
    0.03118955f, 0.04197776f, 0.00911538f, -0.03252321f, 0.02447241f, 0.00763247f, -0.04720158f, 0.00171576f, 
    0.04845328f, -0.04283977f, -0.02271227f, -0.02492640f, 0.00815932f, -0.02003379f, -0.00374761f, -0.01393840f, 
    -0.03882626f, -0.03273855f, 0.03967511f, 0.04412157f, -0.02041027f, -0.01007535f, 0.02466333f, -0.05089726f, 
    0.00798239f, -0.06029095f, 0.04752272f, -0.00078115f, -0.04027420f, 0.00823717f, 0.01755823f, -0.03316803f, 
    0.03480045f, -0.00018795f, -0.02314175f, -0.02096200f, 0.02597631f, -0.02021286f, 0.03363213f, 0.01749221f, 
    -0.00783536f, -0.05551856f, -0.00835351f, 0.00197761f, -0.01027871f, -0.00951420f, -0.01569374f, 0.03084931f, 
    -0.03832018f, -0.03826613f, -0.01824616f, -0.01281222f, -0.02862949f, -0.02722001f, -0.04900707f, -0.00523479f, 
    -0.02069807f, 0.03433628f, 0.01925443f, -0.03584095f, -0.03660708f, 0.00995578f, -0.00269251f, -0.03362472f, 
    -0.03138630f, 0.03827030f, -0.03626134f, 0.04375109f, 0.01980281f, 0.01845475f, 0.00226356f, -0.00041030f, 
    -0.01828731f, 0.00955297f, -0.01316945f, -0.02364636f, -0.04160564f, 0.01955823f, -0.03652041f, 0.00363417f, 
    0.01937239f, 0.02513148f, -0.02030962f, 0.02348518f, 0.00420818f, 0.05251282f, -0.02087367f, -0.01294627f, 
    0.01491926f, -0.01719774f, -0.05865524f, -0.03599938f, 0.02148215f, 0.00233515f, 0.01850200f, -0.00753289f, 
    -0.02197136f, 0.02431822f, 0.02681445f, 0.01405850f, -0.05837212f, 0.01279920f, -0.01601884f, 0.02017774f, 
    -0.01119682f, -0.02104829f, 0.00504394f, 0.04707992f, -0.02377816f, -0.01641848f, -0.03454231f, 0.02068031f, 
    0.02963744f, 0.02841874f, -0.01961345f, -0.01970860f, 0.03814033f, -0.03526485f, -0.01226508f, 0.03639485f, 
    0.01373966f, 0.03346332f, -0.03470917f, -0.04292941f, 0.00366685f, 0.04181407f, -0.05157627f, -0.03817337f, 
    0.00336866f, 0.03400370f, -0.00038795f, 0.01267573f, -0.03209030f, -0.04809319f, -0.03855835f, -0.02761269f, 
    -0.04618765f, 0.00650022f, -0.01144361f, 0.02293724f, -0.01062101f, -0.02709588f, 0.00616844f, -0.01427567f, 
    -0.01273627f, -0.04510598f, 0.04617136f, -0.02435578f, 0.04065205f, -0.03340087f, -0.00122513f, -0.01033316f, 
    0.00597920f, 0.04561855f, -0.02102607f, 0.02517683f, -0.00723309f, -0.01529890f, -0.02173327f, 0.03505519f, 
    0.02308010f, 0.01931653f, 0.00469345f, 0.02509109f, 0.02832210f, -0.00895055f, 0.01985387f, -0.01931627f, 
    0.00228438f, 0.00461770f, 0.04645178f, 0.04135314f, 0.02870263f, 0.01751618f, 0.01551666f, -0.02823555f, 
    -0.05864025f, -0.03220671f, 0.00473323f, -0.03544337f, -0.03214745f, -0.02892816f, 0.03544814f, 0.02015031f, 
    0.03230568f, -0.06359652f, -0.01900439f, -0.04949395f, -0.03343979f, 0.00105932f, -0.04042232f, -0.05407019f, 
    -0.01224491f, 0.04536826f, -0.00331641f, 0.01038185f, -0.04587870f, -0.04673949f, -0.00389496f, 0.00653916f, 
    -0.01125311f, -0.04674358f, 0.00435624f, 0.00577649f, -0.01957668f, -0.05114894f, 0.05277393f, -0.02848061f, 
    0.02738732f, -0.00809508f, -0.01464706f, -0.01419688f, -0.00781071f, -0.00922532f, 0.01093126f, -0.04261909f, 
    -0.04378117f, 0.03850642f, -0.00382435f, -0.04256294f, 0.02783100f, -0.02093395f, -0.03952125f, -0.04010192f, 
    -0.00039633f, -0.04451669f, 0.04565893f, -0.05053017f, 0.00590587f, 0.03014498f, -0.00962470f, 0.00542725f, 
    0.03062840f, -0.00223230f, 0.03506285f, -0.03829881f, -0.02289408f, -0.03773636f, -0.01640170f, 0.00834309f, 
    0.00627468f, 0.01581183f, -0.03152841f, -0.05050289f, 0.03543156f, -0.02635423f, 0.02510794f, 0.02014502f, 
    0.03866260f, -0.03886214f, -0.03076203f, 0.02763774f, 0.03752569f, -0.03429594f, 0.03217073f, -0.01810073f, 
    0.00389937f, -0.00268376f, 0.03532526f, -0.01304209f, 0.01446526f, -0.01611110f, 0.01597615f, 0.04206375f, 
    0.04551832f, -0.03145529f, -0.01018123f, -0.04189872f, -0.01315028f, -0.02978420f, -0.01992662f, 0.01019969f, 
    -0.02754475f, -0.02302813f, -0.02987144f, 0.02693524f, -0.02688898f, -0.02734871f, 0.01526780f, -0.02768928f, 
    0.01926663f, -0.04108364f, -0.03338996f, -0.00833475f, -0.00278068f, -0.01867515f, 0.03369514f, -0.02311501f, 
    0.03412444f, 0.00272088f, -0.03315967f, -0.00658438f, 0.02936831f, 0.01745456f, -0.00818919f, 0.03036804f, 
    -0.05671415f, -0.00425689f, 0.04201796f, 0.04545042f, 0.00195701f, 0.02776728f, 0.01332898f, -0.04414560f, 
    -0.02115277f, -0.04960600f, -0.02754273f, -0.04347035f, -0.01832769f, 0.00030037f, -0.04742128f, -0.01704238f, 
    -0.00349190f, 0.00272107f, -0.03011224f, 0.02693391f, 0.01645506f, -0.05045445f, -0.03262652f, -0.02888924f, 
    -0.04309332f, -0.01091418f, -0.00114223f, 0.00603873f, 0.01899566f, 0.00134465f, -0.01479000f, 0.03851051f, 
    -0.00929579f, 0.02232101f, 0.00146412f, -0.00978524f, -0.01844772f, 0.05162191f, -0.01584151f, 0.04138357f, 
    -0.01129324f, 0.03279138f, -0.02441774f, -0.05275456f, -0.01962683f, -0.05488513f, 0.01689215f, 0.04786960f, 
    -0.04388615f, -0.03880313f, -0.05391524f, 0.03388805f, -0.04317983f, -0.03957476f, -0.00589815f, -0.05083326f, 
    -0.05896972f, -0.03164645f, 0.02432124f, 0.03898831f, -0.02831227f, 0.03506792f, -0.03267442f, 0.00822331f, 
    0.04482938f, 0.00267187f, -0.04962228f, -0.01269066f, -0.05731344f, -0.00651059f, -0.04757562f, -0.05441079f, 
    0.04394698f, -0.02841358f, -0.03711647f, -0.01000407f, -0.03693597f, 0.00864785f, 0.03910614f, -0.05612708f, 
    -0.01936250f, 0.04440484f, -0.01893643f, 0.03365768f, -0.05457044f, 0.03820464f, -0.03890146f, -0.00542485f, 
    0.04048451f, 0.02364744f, -0.03848687f, 0.03308811f, 0.03988453f, 0.03212353f, 0.03736903f, 0.03987887f, 
    0.03354251f, 0.03550741f, -0.01863770f, -0.00289273f, 0.03709200f, -0.01930085f, -0.03802965f, -0.00872747f, 
    -0.04480127f, -0.04995971f, -0.04694584f, -0.00556656f, -0.04394434f, 0.02208343f, 0.03577733f, 0.04081513f, 
    -0.04320163f, -0.05164195f, -0.04459058f, 0.04347812f, -0.00761838f, 0.03156943f, -0.01980185f, 0.03518846f, 
    0.03230959f, -0.00098301f, 0.02912650f, -0.03997539f, 0.03251595f, -0.02956157f, -0.00007071f, 0.00078836f, 
    -0.01557682f, 0.03222958f, -0.00065461f, 0.03627040f, 0.03168797f, -0.04750258f, -0.02798888f, -0.04836411f, 
    -0.00104646f, 0.00033452f, -0.00357289f, -0.00421871f, 0.01677505f, -0.00522663f, 0.02577834f, 0.03780662f, 
    -0.04580770f, 0.00221962f, -0.03696286f, -0.04012983f, -0.02108462f, 0.04510080f, 0.02901396f, -0.04654967f, 
    0.02283563f, 0.02248404f, -0.01875902f, -0.05625380f, -0.03307640f, 0.04538790f, -0.01132684f, -0.02717937f, 
    -0.00026826f, 0.04495531f, 0.03196920f, 0.01099204f, 0.02481968f, -0.03013730f, 0.00299883f, 0.02067928f, 
    0.03127627f, -0.03409924f, 0.01026952f, -0.03765203f, -0.03938630f, -0.00497133f, 0.02237853f, -0.04198927f, 
    0.00934512f, -0.03235986f, 0.01804725f, -0.03981150f, -0.02218028f, -0.02050055f, -0.03571633f, -0.03838865f, 
    0.04096771f, 0.04365679f, -0.01282859f, 0.04071537f, -0.05596017f, -0.03563728f, 0.01343819f, 0.03203134f, 
    -0.04190759f, 0.00173575f, -0.03522699f, -0.02157230f, -0.05103417f, 0.03171106f, 0.02401111f, 0.01183011f, 
    -0.04477013f, 0.03399182f, 0.02084068f, -0.05013275f, 0.04875787f, 0.04067953f, -0.03127266f, -0.02897419f, 
    0.01047166f, 0.02101457f, 0.00046793f, -0.02108708f, -0.02681561f, -0.03439657f, 0.00121850f, 0.02009147f, 
    -0.03244364f, -0.01064063f, 0.03098400f, -0.02374353f, -0.05131521f, 0.03303598f, 0.00213553f, -0.00199986f, 
    -0.15321931f, -0.03965498f, -0.07401352f, -0.16214190f, 0.14165351f, 0.08227706f, -0.02666407f, -0.05743698f, 
    0.02536521f, 0.15048018f, 0.05735162f, 0.07926644f, 0.31049529f, -0.31535304f, 0.30180424f, 0.16695768f, 
    0.01879727f, -0.01000649f, -0.15476318f, -0.05628379f, -0.04956610f, 0.05561652f, 0.05069719f, 0.01548904f, 
    -0.05248084f, 0.16018988f, 0.24306975f, -0.08645489f, 0.00281954f, 0.17319436f, 0.04220800f, -0.11636391f, 
    -0.15072544f, 0.02081838f, 0.07694137f, 0.05397281f, -0.09338570f, -0.03474385f, 0.11825218f, -0.01290104f, 
    0.09483748f, 0.05815653f, -0.03531038f, -0.02962343f, 0.08154235f, 0.05665534f, 0.08599326f, -0.04512026f, 
    0.02561763f, -0.05417257f, 0.08590797f, 0.06106981f, 0.15251614f, 0.02490695f, -0.04387482f, -0.03359072f, 
    -0.00523045f, -0.10305629f, -0.04259881f, 0.04814593f, 0.02192051f, 0.01198640f, 0.19074404f, 0.19162126f, 
    0.10377251f, 0.01681159f, -0.00634337f, -0.00921813f, -0.00032851f, -0.03115702f, 0.01680525f, -0.05899723f, 
    0.00836734f, 0.14413698f, 0.20301645f, -0.10435238f, 0.12577823f, -0.09533090f, -0.10330480f, -0.03122061f, 
    -0.03523068f, -0.05374280f, -0.04758143f, -0.11688931f, -0.09965635f, -0.08989330f, -0.03337515f, 0.09023931f, 
    0.15723673f, 0.01037390f, 0.15558365f, -0.01765726f, 0.16289862f, -0.19126078f, 0.00450559f, -0.06119622f, 
    0.07361341f, 0.01342470f, -0.03310698f, -0.24763978f, -0.07811522f, 0.06192573f, 0.17052473f, 0.05627491f, 
    0.05343125f, 0.00406983f, -0.04611396f, 0.22185658f, -0.08499295f, -0.01930370f, 0.04082279f, 0.13052596f, 
    0.03305873f, 0.02004071f, 0.01983702f, 0.00284990f, 0.10920613f, 0.04505503f, -0.06512802f, -0.06157726f, 
    0.28344047f, -0.15425467f, 0.02517345f, -0.20550856f, -0.03940206f, -0.10389741f, -0.01981113f, 0.01400891f, 
    0.02397254f, -0.13287736f, -0.05492992f, -0.17456524f, -0.12009524f, 0.03163743f, 0.07194790f, 0.12316956f, 
    0.15227957f, 0.10744949f, 0.04974700f, 0.05543544f, -0.12878484f, 0.04861020f, -0.02092162f, -0.01557532f, 
    -0.30772987f, -0.04964074f, 0.08267445f, 0.09666940f, 0.10974094f, 0.09884252f, 0.01808648f, 0.02992432f, 
    -0.02048864f, 0.06495852f, 0.16525187f, 0.14781484f, 0.11003948f, 0.10991032f, -0.05491386f, -0.13598317f, 
    -0.05914931f, 0.13117005f, -0.08972600f, -0.04524793f, -0.13173512f, 0.17899476f, -0.05094074f, -0.01690746f, 
    -0.13208838f, -0.10702135f, 0.13333040f, 0.20985158f, 0.00608585f, 0.01550250f, 0.12689720f, 0.04455075f, 
    -0.04812171f, 0.01946102f, 0.03103821f, 0.07891342f, -0.10477787f, -0.17070104f, -0.00816306f, 0.00543058f, 
    0.07965799f, -0.04929061f, 0.12516110f, 0.02873657f, -0.06847448f, -0.01316493f, 0.01435368f, -0.06149271f, 
    0.24967009f, 0.16367950f, -0.17715551f, 0.24528660f, 0.03340723f, 0.02301929f, -0.00867421f, 0.05629744f, 
    0.05282246f, -0.13660452f, -0.02079642f, -0.03201745f, -0.13617048f, 0.16911006f, -0.07071391f, 0.10751391f, 
    0.08440554f, -0.01255740f, 0.03003546f, 0.04249355f, 0.10510265f, 0.13364102f, 0.03526656f, -0.12498926f, 
    -0.07827067f, 0.15662783f, 0.13979560f, -0.07202623f, 0.15529186f, 0.09312997f, 0.10489038f, -0.01384390f, 
    0.01991475f, 0.11527470f, -0.02704335f, -0.14409730f, -0.11568657f, 0.44365865f, -0.18510738f, 0.02983150f, 
    0.04879232f, 0.00760820f, 0.04712933f, 0.04187029f, 0.14990850f, 0.05673331f, 0.03105427f, 0.05542250f, 
    0.14838359f, -0.00303823f, -0.11977722f, -0.19723354f, 0.03667851f, -0.00347304f, -0.06524956f, 0.05818816f, 
    0.07893398f, -0.03068729f, -0.03339306f, 0.06880623f, -0.24316323f, 0.11337351f, -0.02315859f, -0.02052400f, 
    0.09013836f, -0.00084226f, 0.02020161f, 0.00967567f, -0.11556043f, -0.05164587f, 0.13457476f, -0.00753754f, 
    -0.17144540f, 0.23104072f, 0.03726516f, 0.21206091f, 0.13141274f, 0.11102564f, 0.18345168f, -0.20023987f, 
    0.01298932f, 0.03380863f, -0.04463444f, 0.05809672f, -0.28988710f, 0.16329373f, -0.01614226f, -0.17466170f, 
    0.06744429f, 0.07890337f, 0.03324486f, 0.11132154f, 0.04923374f, -0.08557287f, -0.11464369f, 0.14043342f, 
    0.06040379f, 0.05446996f, 0.08533005f, 0.06279829f, -0.10762512f, 0.12803178f, -0.08996305f, -0.01905097f, 
    0.03939145f, 0.04169985f, 0.19456285f, 0.19357370f, 0.05225537f, 0.06529907f, -0.04220050f, -0.31431833f, 
    0.10811757f, 0.02269824f, 0.01425904f, 0.10456324f, 0.09409069f, 0.12703718f, -0.10880154f, 0.01012833f, 
    0.06192039f, -0.09015781f, -0.09864933f, -0.16072039f, 0.02896668f, -0.05002239f, -0.09565962f, -0.07367146f, 
    -0.10742867f, -0.11772855f, -0.05465410f, 0.06927003f, 0.05582818f, 0.17309386f, 0.00507504f, -0.31591606f, 
    -0.00155475f, -0.06122408f, 0.03337732f, 0.03413039f, 0.04329573f, 0.07486564f, -0.01766464f, 0.02134212f, 
    -0.17875099f, 0.25873253f, -0.17866999f, -0.14284828f, 0.11194353f, 0.04297147f, 0.18977736f, -0.01483903f, 
    0.00963893f, 0.02980932f, 0.07492056f, -0.08611374f, 0.21936622f, 0.03649197f, 0.07560951f, 0.00372750f, 
    -0.08919050f, 0.25657281f, 0.11161461f, 0.04710472f, -0.05288729f, 0.05345887f, 0.15802099f, -0.06328279f, 
    0.15749560f, 0.09317897f, -0.02600521f, 0.10195312f, 0.03362479f, 0.00330928f, 0.05265340f, 0.10159504f, 
    0.04286740f, -0.04158506f, -0.01465161f, -0.14569375f, 0.20591715f, -0.18898281f, 0.04979018f, 0.40457186f, 
    -0.00280895f, -0.06779837f, 0.06115486f, 0.03357923f, -0.14142315f, 0.00824554f, 0.10351793f, -0.06915054f, 
    -0.05877683f, -0.02740624f, 0.02920589f, -0.05889466f, 0.00023768f, 0.00253056f, -0.04254130f, 0.00176519f, 
    0.01452846f, 0.00047359f, -0.03555087f, 0.03397314f, -0.00055326f, 0.00658192f, -0.00825561f, 0.00280182f, 
    -0.00859949f, -0.02970587f, -0.00163497f, -0.05639920f, 0.01471399f, -0.03788987f, -0.02619018f, 0.00219208f, 
    -0.04966181f, 0.01797370f, 0.01275849f, 0.01091407f, -0.00847141f, 0.03095907f, -0.05185729f, 0.03892932f, 
    0.01741813f, -0.01649414f, 0.04209781f, -0.01388379f, 0.01643425f, -0.04138220f, 0.01476946f, -0.01916115f, 
    -0.05827969f, 0.02735421f, -0.02435577f, -0.02797714f, 0.04004363f, -0.00564165f, 0.02416902f, -0.04091946f, 
    0.01738266f, -0.02321266f, 0.02578280f, -0.03235642f, -0.01001138f, -0.01059044f, -0.04173153f, 0.02834823f, 
    -0.05685903f, -0.00902363f, 0.03791758f, -0.04640624f, -0.01650439f, -0.01854691f, 0.01686827f, 0.00033107f, 
    -0.03181174f, -0.04244902f, -0.03798435f, -0.04438416f, -0.05584524f, -0.03858267f, 0.00111089f, -0.02616046f, 
    0.01455528f, -0.00015052f, 0.01704905f, 0.00974602f, 0.00636401f, -0.03404557f, -0.02111555f, 0.04056539f, 
    0.00330911f, 0.04181686f, 0.00900536f, 0.03861577f, -0.00015936f, -0.05563579f, 0.02585558f, -0.01294960f, 
    -0.00973632f, -0.04559556f, 0.03980670f, -0.02875957f, 0.02082468f, -0.00125818f, 0.02175937f, 0.03429802f, 
    0.01963229f, 0.03847264f, 0.04061209f, -0.02335117f, 0.03888721f, 0.04173227f, 0.00111979f, -0.04725094f, 
    -0.02348189f, 0.01556977f, -0.00882843f, -0.02094179f, 0.01489920f, -0.03091994f, -0.00305415f, -0.03960713f, 
    -0.00518240f, 0.01031187f, 0.00269345f, 0.02493954f, 0.01176213f, -0.04859634f, -0.05082965f, -0.01175078f, 
    0.03262148f, 0.01032664f, -0.03439962f, -0.01981394f, 0.02635523f, 0.02290920f, -0.05051031f, -0.02120753f, 
    -0.04012996f, 0.02100891f, -0.02021150f, -0.03777380f, -0.02836760f, -0.04650035f, 0.03532704f, 0.00388757f, 
    -0.00333023f, -0.03663628f, 0.03632828f, 0.00257265f, -0.04623312f, -0.05261693f, 0.00255411f, 0.03904609f, 
    -0.01396228f, 0.01695443f, -0.05639804f, 0.02431903f, 0.03679558f, 0.02682699f, -0.03917067f, 0.00773455f, 
    -0.04002919f, -0.00230325f, 0.00750585f, 0.04035472f, 0.01049699f, 0.04063973f, -0.00288054f, -0.00088837f, 
    -0.03953755f, -0.00521155f, -0.05833376f, -0.05090822f, -0.00254039f, -0.03171922f, -0.03123554f, 0.03318894f, 
    -0.04433639f, -0.03038422f, -0.04020555f, -0.00487243f, -0.04661728f, -0.02840446f, 0.02095955f, 0.00191504f, 
    0.04211465f, 0.02940959f, 0.03150921f, 0.03585614f, 0.04198028f, -0.02989664f, -0.00416875f, -0.01589351f, 
    -0.05391940f, 0.02830971f, 0.02805017f, -0.02042424f, -0.02621778f, -0.05403934f, -0.02245284f, -0.04392114f, 
    0.03981514f, 0.00208083f, 0.03478668f, 0.00883104f, -0.00222827f, 0.02747294f, 0.01352772f, -0.03315576f, 
    0.01078510f, -0.04152756f, -0.01667173f, 0.00864708f, -0.03514119f, -0.04416939f, -0.00238785f, -0.04269974f, 
    0.04203761f, 0.00785382f, 0.02947462f, -0.04174653f, 0.01328037f, -0.03923994f, -0.02980992f, -0.02453369f, 
    0.00398036f, -0.00051864f, 0.00460784f, -0.01612427f, -0.04974937f, -0.03777797f, 0.02644197f, -0.01817712f, 
    -0.04586214f, -0.03296050f, -0.02921440f, 0.00001100f, -0.00056293f, -0.05150963f, 0.01455306f, -0.05785881f, 
    0.01203587f, 0.00934108f, -0.04715479f, -0.04367394f, 0.02801983f, -0.04786688f, -0.05208082f, 0.03124931f, 
    0.03879731f, -0.05221207f, -0.00006049f, -0.05011261f, 0.00747811f, 0.00711031f, -0.00650968f, -0.01816406f, 
    -0.05151655f, -0.01031807f, 0.03330305f, 0.02648731f, 0.00357826f, 0.01064078f, -0.02825820f, 0.00321858f, 
    -0.03865087f, 0.01553528f, 0.01412514f, 0.00756562f, 0.02332887f, -0.02003559f, 0.01862699f, -0.05477059f, 
    -0.00777447f, -0.00518667f, -0.04723915f, -0.00884251f, 0.01686373f, -0.00553086f, -0.02059266f, -0.00938765f, 
    -0.04657946f, -0.01595387f, 0.00447749f, 0.02764138f, -0.03453508f, 0.02307896f, -0.01514783f, 0.02747210f, 
    -0.04636548f, -0.05608903f, -0.01146992f, 0.02595109f, 0.01005952f, -0.03344119f, 0.02270650f, 0.00595142f, 
    0.00429212f, 0.01391692f, 0.04259287f, 0.03823980f, -0.04866292f, 0.01881747f, -0.03934795f, 0.02651295f, 
    -0.03032525f, -0.02311411f, 0.04520579f, 0.03422891f, 0.03163905f, 0.00667978f, -0.05295582f, -0.01971688f, 
    -0.04535039f, -0.00733619f, -0.02232410f, 0.02207601f, -0.04922374f, -0.01843488f, -0.03246974f, -0.04570035f, 
    -0.01627200f, -0.03633096f, -0.02348859f, -0.00959337f, -0.00124466f, 0.01310536f, -0.02801812f, -0.03689686f, 
    0.03889360f, -0.05608632f, 0.00969167f, -0.03453699f, 0.01826242f, -0.04396538f, 0.03419076f, 0.02866737f, 
    -0.03906117f, 0.01031730f, -0.01137935f, 0.04504500f, 0.02158276f, 0.00483095f, -0.03885632f, -0.01614131f, 
    -0.00392219f, 0.01112327f, 0.04070340f, -0.01400201f, 0.01069041f, -0.03619616f, 0.04740128f, -0.00900202f, 
    -0.00074794f, -0.05523205f, 0.01289429f, 0.02912605f, 0.03225025f, 0.00084626f, 0.02004202f, 0.01236050f, 
    -0.01011261f, -0.01717913f, 0.03716999f, 0.04892112f, -0.00017917f, -0.03809544f, 0.01271728f, 0.03104703f, 
    -0.00299161f, 0.03052090f, 0.01165664f, -0.02227469f, 0.01273422f, 0.03741338f, -0.03164994f, -0.03738540f, 
    0.03777403f, -0.03859780f, 0.04156286f, -0.04878869f, -0.02005567f, 0.02872694f, -0.02429277f, -0.00752613f, 
    -0.03737034f, 0.00225346f, -0.04659785f, -0.05053167f, 0.03225899f, -0.03373125f, 0.00538990f, -0.00535978f, 
    -0.09784065f, 0.13691346f, 0.15342812f, 0.11323547f, -0.14203012f, 0.04362107f, 0.10212356f, 0.10991863f, 
    -0.00109405f, 0.08938868f, -0.05914837f, 0.08794926f, -0.17616536f, 0.21393956f, 0.00451801f, -0.12560800f, 
    0.02398772f, 0.09077617f, 0.03709468f, -0.09795830f, 0.01016329f, -0.02430325f, -0.03476712f, -0.14967887f, 
    0.37139806f, 0.05638504f, -0.11591933f, 0.31886500f, -0.05840004f, 0.04490181f, -0.00515907f, 0.16301633f, 
    0.16612127f, 0.06665570f, -0.11363532f, 0.11172497f, -0.15679969f, -0.05897441f, -0.02720900f, 0.01707001f, 
    0.03100996f, 0.04505248f, -0.11430849f, 0.07551446f, -0.05991385f, 0.05302735f, 0.05217684f, -0.04989350f, 
    0.03658490f, -0.00259576f, 0.04285547f, -0.21574175f, 0.02255783f, 0.01913656f, -0.10059910f, 0.00713602f, 
    -0.08314490f, 0.03501680f, -0.00779795f, 0.12199648f, -0.01458735f, -0.11900476f, -0.16308799f, 0.03094063f, 
    -0.04375792f, 0.04989006f, 0.11871529f, 0.17374590f, 0.00126288f, 0.02510617f, 0.06582082f, -0.04779850f, 
    -0.25872847f, 0.03490068f, -0.09110874f, -0.00564057f, -0.00534945f, 0.15916227f, -0.03936614f, -0.02256513f, 
    -0.05204645f, -0.13947058f, -0.07040435f, -0.06902801f, -0.30773672f, -0.05740551f, 0.05177831f, 0.14847574f, 
    -0.11187750f, -0.07902526f, 0.02890299f, 0.03375258f, 0.05173899f, 0.14204225f, -0.06934610f, -0.05052726f, 
    -0.40593737f, 0.12431099f, 0.03662575f, 0.15384893f, -0.00217978f, 0.08060954f, 0.11560833f, 0.03124909f, 
    0.03323509f, -0.01897150f, 0.02223565f, 0.03520769f, 0.30972633f, 0.17421570f, 0.05291523f, 0.00851950f, 
    -0.12873918f, 0.03930316f, 0.01249840f, 0.03077952f, 0.09657415f, 0.03532122f, -0.06312833f, 0.04615437f, 
    -0.06617356f, 0.14966407f, 0.24292789f, 0.37116456f, 0.02017594f, 0.03208566f, 0.07286758f, -0.05627808f, 
    0.09249138f, -0.06656309f, -0.00776416f, -0.10156130f, -0.18237913f, -0.01605199f, -0.00699872f, -0.04286329f, 
    -0.06223415f, -0.00022625f, 0.03836563f, 0.10555996f, 0.00330277f, -0.01103427f, -0.04571274f, 0.09242312f, 
    -0.28028765f, 0.01919520f, 0.00064085f, -0.09571922f, 0.05883246f, 0.06388107f, 0.13942692f, 0.05817456f, 
    0.00355778f, -0.04275486f, -0.01932262f, 0.10328110f, 0.25015625f, -0.00389913f, 0.08352127f, 0.18590192f, 
    -0.05866715f, 0.08017760f, 0.06779137f, 0.04593351f, 0.06698751f, -0.10465784f, 0.01215702f, 0.09637392f, 
    -0.14222977f, -0.13512014f, 0.01976985f, -0.09129801f, -0.01397973f, 0.06342398f, -0.01967501f, -0.04924399f, 
    0.04305803f, 0.02198702f, 0.10412592f, 0.11469736f, -0.09593534f, 0.26084989f, -0.00184339f, -0.12195826f, 
    0.01580808f, -0.05525237f, -0.10621466f, -0.04054700f, 0.01160913f, -0.13061492f, -0.08912186f, 0.10728851f, 
    -0.17805126f, -0.15771821f, 0.12206946f, 0.03679178f, -0.05501773f, -0.07495371f, -0.08051949f, -0.03184970f, 
    0.05488160f, 0.13439463f, 0.04696810f, -0.02098244f, 0.01443631f, -0.15742189f, 0.07201438f, 0.09784986f, 
    -0.00537607f, -0.08709522f, -0.06086733f, 0.13995552f, -0.05748487f, 0.09198828f, -0.00985738f, -0.02659663f, 
    -0.22451666f, -0.06778670f, -0.08887121f, 0.03367154f, 0.05960492f, 0.01121171f, -0.06869988f, -0.05774435f, 
    -0.11240034f, 0.03979330f, -0.10404328f, 0.04289115f, 0.31036004f, -0.03405984f, 0.06882748f, -0.03042201f, 
    0.03425086f, -0.07976931f, -0.09070671f, 0.12894298f, -0.02634357f, -0.11165861f, 0.04016768f, 0.01744876f, 
    -0.14637892f, 0.04593854f, 0.11283098f, 0.45347592f, -0.14527345f, -0.06530607f, 0.02037179f, 0.04531686f, 
    0.06988338f, 0.11384855f, -0.04389448f, -0.06029183f, -0.20849429f, 0.03701230f, 0.03839473f, 0.02236759f, 
    0.03690742f, 0.06946637f, 0.08459988f, -0.04761643f, 0.04124818f, -0.02120881f, 0.08282687f, 0.09003794f, 
    0.21986154f, -0.22347830f, 0.10069939f, 0.02751011f, 0.02030854f, -0.05391157f, 0.15549846f, 0.02472225f, 
    0.05735430f, -0.02916889f, 0.14511600f, 0.08753965f, 0.41221333f, 0.22481406f, -0.00151950f, 0.38328391f, 
    0.04674477f, 0.20526882f, 0.05482491f, 0.09975582f, -0.11957783f, -0.03461424f, 0.17943953f, -0.06380374f, 
    0.66046488f, 0.08788840f, 0.05409896f, -0.10592330f, 0.05149691f, -0.05894857f, 0.01162833f, -0.01947285f, 
    0.05161883f, 0.06802659f, -0.08960503f, 0.04044319f, -0.01838274f, 0.01631745f, -0.09321542f, 0.28637770f, 
    -0.13768375f, -0.03078545f, -0.08045075f, 0.06045579f, 0.06101259f, -0.05318448f, -0.02043314f, -0.13425457f, 
    0.09970019f, 0.20150073f, 0.15094404f, 0.19726752f, -0.13193323f, -0.10666160f, 0.02117742f, -0.04269998f, 
    -0.01841643f, 0.04923527f, 0.08347949f, -0.18089832f, 0.17799780f, 0.21671875f, -0.02145710f, 0.40403917f, 
    -0.09198550f, -0.01198331f, 0.08104299f, 0.13449275f, 0.06289430f, -0.01636452f, -0.02672287f, 0.01687873f, 
    -0.23582143f, -0.27888137f, -0.02416205f, 0.20824534f, -0.04897160f, -0.01793604f, -0.05959887f, -0.12260395f, 
    0.07712258f, -0.03861643f, -0.16287327f, -0.04427466f, -0.10334042f, 0.04594659f, 0.04630724f, -0.00603162f, 
    -0.05648297f, -0.00734356f, -0.07242825f, 0.12218067f, 0.01161570f, -0.05574003f, 0.12011480f, -0.02834261f, 
    -0.29156643f, -0.16223547f, -0.11382952f, 0.01411659f, -0.00966943f, -0.01431793f, -0.08208756f, 0.01083977f, 
    -0.01877530f, -0.01230163f, 0.10180307f, -0.14330657f, -0.02746026f, 0.24920963f, 0.14315626f, -0.24883184f, 
    -0.05059119f, -0.03190775f, 0.19144122f, -0.10664802f, 0.10187005f, 0.00826773f, -0.06711507f, 0.00169893f, 
    0.04393475f, -0.00030361f, -0.01992892f, -0.01279361f, 0.04370678f, 0.03168634f, -0.04103693f, -0.04155612f, 
    0.02709464f, -0.04885646f, -0.02412757f, -0.04752228f, 0.04480353f, -0.03438177f, -0.05856113f, 0.03454555f, 
    -0.02827130f, -0.05763936f, 0.00421667f, -0.03400682f, -0.05644634f, -0.00214308f, 0.00738493f, 0.01354080f, 
    -0.01776575f, -0.02878156f, 0.03641689f, -0.04657419f, 0.00609032f, 0.00638139f, -0.01158485f, -0.04556219f, 
    -0.00066305f, 0.01852402f, -0.03141943f, -0.04727166f, 0.02570571f, -0.02567830f, 0.04183983f, 0.01355692f, 
    0.03411838f, 0.01240962f, -0.02802244f, -0.00306390f, 0.03788181f, 0.01732363f, -0.05067750f, -0.03151338f, 
    0.03554134f, 0.03211388f, -0.00453271f, -0.03366610f, -0.04021636f, 0.00621375f, -0.02209969f, -0.00868451f, 
    0.03443977f, 0.03041051f, -0.02101996f, 0.03944067f, -0.01776921f, -0.01159017f, -0.01738375f, 0.03249054f, 
    -0.04239368f, 0.01335471f, -0.00030018f, 0.04192366f, -0.03713712f, -0.05647931f, 0.03244460f, 0.04121686f, 
    0.00547567f, 0.03151958f, 0.02901996f, 0.02376162f, -0.05352981f, -0.04156663f, -0.01751926f, 0.02093509f, 
    -0.03159373f, -0.04644796f, 0.03598164f, -0.01076989f, -0.02779332f, -0.00961686f, -0.03874058f, -0.00102930f, 
    0.00674123f, 0.00157865f, 0.04420228f, -0.01353161f, -0.02694840f, 0.04147435f, -0.00249784f, 0.00196241f, 
    -0.01762264f, -0.03301129f, 0.04468090f, 0.03342141f, -0.01380005f, 0.03382285f, 0.00767547f, -0.00506678f, 
    0.03575653f, 0.01863150f, 0.01137361f, -0.01446037f, 0.01569508f, -0.03882392f, 0.02476253f, -0.00381573f, 
    -0.05262547f, -0.02588745f, -0.00807088f, -0.00094930f, -0.00311365f, -0.03954308f, -0.00633168f, 0.02328738f, 
    0.00653958f, 0.01889482f, -0.05727752f, -0.05483063f, -0.01402911f, -0.00058474f, 0.04894150f, 0.00180010f, 
    0.00638433f, -0.04758959f, -0.01957570f, 0.04926032f, 0.01421918f, -0.01622370f, -0.03260025f, -0.02588535f, 
    0.01802746f, 0.00127284f, -0.04156213f, -0.03713020f, -0.05653604f, 0.03851326f, -0.04185478f, -0.05055189f, 
    -0.01911096f, 0.05546216f, 0.01909115f, -0.00645855f, -0.01103722f, 0.00740616f, -0.04700281f, 0.04503512f, 
    -0.01108860f, -0.02181476f, 0.02545275f, -0.01729348f, -0.03591242f, -0.03295032f, 0.03987456f, -0.05775490f, 
    0.01502788f, -0.01870917f, 0.01477837f, -0.01949387f, 0.04324532f, 0.01079407f, -0.01017406f, -0.00771981f, 
    -0.01873640f, 0.02225567f, -0.04325638f, 0.02982206f, -0.05064610f, 0.01650493f, 0.00650135f, -0.00715650f, 
    -0.01642373f, 0.00829168f, 0.03401958f, 0.01201855f, 0.02802569f, 0.03104153f, 0.04339057f, -0.00252841f, 
    0.00681585f, -0.02904306f, -0.01563813f, -0.05202012f, -0.01514246f, -0.03218621f, -0.01162814f, -0.01304889f, 
    -0.05555398f, -0.04771592f, 0.00285311f, 0.03199458f, 0.02250196f, -0.01294714f, 0.01701791f, -0.01597705f, 
    0.00328728f, 0.02016074f, -0.02169853f, -0.04807364f, 0.00059241f, 0.02342397f, -0.04609963f, 0.03014422f, 
    0.00370652f, -0.03278753f, 0.03375686f, -0.04667972f, 0.02445827f, 0.01727924f, 0.00210939f, 0.02201766f, 
    0.02189216f, 0.02874757f, 0.01465398f, -0.00342962f, 0.00432858f, -0.05137460f, 0.04460222f, -0.04956588f, 
    -0.04923528f, 0.03044442f, -0.00004274f, -0.01589046f, -0.00256729f, 0.02695698f, -0.01859712f, 0.00003551f, 
    0.01924985f, -0.04172392f, -0.05145389f, -0.04515007f, -0.04614271f, -0.04838481f, 0.03862783f, 0.01816262f, 
    -0.03271353f, -0.03714422f, 0.01466177f, -0.00171212f, -0.04337342f, -0.01077472f, -0.04707078f, 0.00991719f, 
    0.02113324f, 0.04296400f, -0.02120727f, 0.04603696f, -0.01448017f, -0.02103650f, -0.00499417f, -0.03355061f, 
    0.02630733f, 0.02173023f, -0.02131535f, -0.03070082f, -0.04654805f, 0.02161042f, -0.03775033f, -0.00471669f, 
    0.01953634f, -0.00365193f, 0.00905336f, -0.03767449f, 0.03707973f, 0.00556695f, 0.03203382f, -0.01967251f, 
    -0.03040369f, 0.01094811f, 0.03998792f, -0.03807940f, -0.05178197f, 0.00505990f, 0.04409670f, 0.00357454f, 
    -0.02858314f, 0.00274860f, 0.00457039f, -0.04900137f, -0.04009600f, 0.03025041f, 0.03405356f, -0.01126058f, 
    0.01455104f, -0.02779637f, 0.04056163f, -0.04369994f, 0.00722789f, 0.02332148f, -0.01760010f, -0.00643245f, 
    0.02485214f, -0.02739189f, -0.04062738f, 0.02570095f, -0.03019046f, 0.03918532f, -0.04743555f, -0.02734667f, 
    0.03719337f, -0.00361301f, 0.02134198f, -0.02538115f, 0.04047595f, 0.01489680f, 0.04368263f, 0.00047067f, 
    -0.05115316f, -0.05426227f, -0.01186631f, 0.01529894f, 0.03377472f, 0.01441670f, -0.02359291f, 0.03846084f, 
    0.03606788f, -0.02511354f, 0.01866803f, 0.01985525f, 0.04885020f, -0.05737579f, -0.01488500f, -0.02727881f, 
    -0.00252160f, -0.00130051f, -0.04912854f, 0.03066875f, -0.02681497f, 0.03380125f, 0.02337947f, -0.02659521f, 
    0.00740919f, -0.02254886f, -0.00865702f, 0.00893692f, -0.03009670f, -0.04698185f, -0.01220982f, 0.02251413f, 
    0.00767146f, -0.00099555f, 0.01849541f, 0.03584459f, -0.03390284f, -0.03683297f, -0.02512893f, 0.01274458f, 
    -0.05090075f, 0.01442862f, 0.04080111f, -0.01391844f, -0.00351275f, -0.02674554f, -0.03904691f, -0.05281721f, 
    -0.02689322f, -0.04806106f, 0.01693342f, -0.00094817f, 0.04165356f, -0.00513584f, -0.05151913f, -0.00336185f, 
    0.04770179f, 0.04284916f, 0.01817014f, -0.00881352f, -0.03789204f, -0.02553330f, -0.05521854f, 0.01308458f, 
    -0.02436651f, 0.00408479f, 0.00917512f, -0.04545065f, 0.03077457f, -0.03861693f, -0.05123243f, -0.04232161f, 
    0.33672822f, 0.09287000f, 0.14751273f, 0.10989689f, 0.10638062f, 0.01727203f, 0.03321402f, -0.05578690f, 
    0.02415665f, 0.03041619f, -0.15911530f, 0.07697271f, 0.32490760f, -0.03778601f, 0.08694544f, -0.21902886f, 
    0.02556765f, 0.13897003f, -0.08797389f, 0.04300372f, -0.13833039f, -0.12233669f, -0.04536095f, 0.11758731f, 
    0.47826260f, 0.11794762f, -0.18534197f, -0.21677755f, -0.17357334f, -0.10411604f, -0.09319574f, 0.11536001f, 
    -0.14675888f, 0.02672275f, 0.04808465f, -0.14546369f, 0.60946387f, 0.08900051f, -0.05623259f, -0.22549139f, 
    -0.16663592f, -0.08867411f, 0.12497880f, -0.00406798f, -0.02924197f, -0.00363823f, 0.05686896f, -0.05850200f, 
    -0.02118786f, 0.14603376f, 0.29962704f, -0.06098128f, 0.33139145f, 0.05406290f, 0.08979943f, -0.08222386f, 
    0.08988492f, -0.08099473f, 0.04639820f, -0.00626831f, -0.02013707f, 0.23545524f, 0.24737096f, 0.04508525f, 
    -0.09341478f, 0.00139976f, 0.07968970f, 0.12982669f, -0.14981301f, -0.03281836f, 0.11140177f, -0.02162384f, 
    0.15156077f, 0.03162242f, -0.05235974f, -0.23726535f, -0.04531327f, 0.03951316f, -0.00463100f, 0.13259186f, 
    -0.11287196f, -0.08172631f, -0.12448829f, -0.03534533f, -0.35089830f, -0.02768090f, 0.15777324f, -0.03815253f, 
    -0.06007893f, -0.07022759f, -0.00512955f, -0.00716952f, 0.02732019f, -0.03378177f, 0.01808072f, -0.10049017f, 
    0.15465879f, 0.08141360f, 0.23484856f, 0.01584858f, 0.08914678f, -0.02088163f, 0.12045061f, 0.05391128f, 
    -0.13899036f, -0.03359381f, -0.05168763f, -0.01196253f, 0.40858069f, 0.26897076f, -0.18366846f, -0.05469739f, 
    -0.16692244f, -0.09874570f, -0.05782212f, 0.06950281f, -0.11766294f, -0.10166553f, -0.10534384f, -0.04933614f, 
    0.08241546f, -0.41113615f, -0.10906792f, 0.15608577f, -0.01221946f, 0.14580615f, 0.07079626f, -0.10680332f, 
    -0.09830451f, -0.14499713f, -0.05010022f, -0.05137837f, -0.13572392f, 0.17123879f, 0.30496657f, 0.19254187f, 
    0.19226353f, 0.17108291f, -0.03016115f, 0.13383271f, 0.00861358f, -0.05222759f, 0.04894130f, 0.01042013f, 
    -0.03436965f, 0.10102681f, 0.23891559f, 0.15121137f, 0.07930358f, 0.11031364f, -0.07967301f, 0.01319969f, 
    -0.10462365f, 0.10900201f, -0.04101147f, 0.22798248f, 0.19245398f, -0.17655632f, -0.21441510f, -0.13110875f, 
    -0.19879654f, 0.16225185f, 0.00985264f, 0.02854606f, -0.20609245f, -0.11573622f, -0.10185880f, -0.09972931f, 
    -0.09480696f, 0.27296460f, 0.32547909f, 0.15027836f, 0.22996634f, 0.03943809f, 0.01336395f, 0.23899575f, 
    0.09332935f, -0.01613992f, 0.08668929f, 0.04898028f, 0.23167704f, 0.07328621f, 0.23712523f, 0.18187852f, 
    0.21679214f, 0.18088421f, -0.03124228f, 0.17002526f, 0.04366720f, -0.06544895f, 0.13216546f, 0.00008296f, 
    -0.41732663f, -0.06063474f, 0.11186025f, 0.22620840f, -0.01688821f, -0.02678283f, -0.02083676f, 0.06127064f, 
    0.03020077f, -0.02957000f, 0.04080703f, 0.02704221f, 0.15776557f, 0.06558838f, 0.02476814f, 0.08312417f, 
    -0.06588798f, -0.05258420f, -0.05283286f, -0.00673233f, -0.10279446f, 0.01788473f, -0.06663110f, 0.04213718f, 
    0.05975247f, -0.06187388f, 0.17964098f, 0.15669510f, 0.03695413f, 0.03811270f, -0.03513815f, 0.12517522f, 
    -0.09769348f, -0.04459823f, -0.00981536f, 0.12715079f, 0.30939847f, 0.49847609f, -0.09700569f, 0.08749630f, 
    -0.02276123f, -0.10613708f, -0.10390520f, 0.06257295f, -0.23370242f, 0.06242263f, -0.05054834f, -0.06856634f, 
    0.04109055f, -0.36701459f, -0.03138132f, 0.05341308f, 0.05851200f, 0.02868556f, 0.12046112f, 0.03758169f, 
    -0.13073136f, -0.04130015f, 0.06151016f, -0.14928915f, -0.30607083f, 0.34861547f, 0.10427435f, 0.13857703f, 
    -0.01643460f, 0.13109472f, -0.00522158f, -0.11460557f, -0.01537704f, 0.02175033f, 0.12712069f, -0.01227240f, 
    0.07657776f, 0.28610817f, 0.19705057f, -0.16837516f, 0.11529676f, -0.00989213f, 0.07499218f, 0.03420346f, 
    -0.01782267f, 0.08123936f, 0.07443050f, 0.05501094f, 0.01036418f, 0.11369273f, 0.05838427f, 0.46441862f, 
    0.08855331f, 0.06524842f, 0.05174134f, -0.00350291f, -0.01799171f, -0.02800907f, -0.00953944f, -0.10390009f, 
    -0.17274868f, -0.04449437f, 0.03715819f, -0.14763457f, -0.02940436f, -0.12254083f, -0.03424212f, -0.05701007f, 
    -0.02175099f, -0.05317099f, -0.03076264f, 0.04735766f, 0.19372858f, 0.05568073f, -0.12002379f, 0.08009974f, 
    -0.05678628f, -0.09836832f, -0.01022890f, 0.05560247f, 0.00809409f, -0.13006355f, -0.11037482f, -0.09228917f, 
    0.00854380f, -0.15782644f, 0.03230336f, 0.16646998f, 0.04903329f, 0.02508807f, 0.05398514f, -0.20402583f, 
    -0.10887651f, -0.00903135f, 0.10618576f, -0.07849257f, 0.05459598f, 0.12166035f, -0.11394609f, 0.30468878f, 
    -0.09432597f, -0.04278784f, 0.04313696f, 0.12584710f, -0.09585931f, -0.00821939f, -0.06885939f, -0.05655259f, 
    0.28758094f, -0.04554353f, -0.02975733f, 0.09703702f, -0.05342935f, -0.13174619f, -0.13865185f, -0.00369938f, 
    0.00676719f, -0.02347568f, -0.07585714f, 0.12966390f, 0.11131804f, 0.00515557f, 0.03300477f, 0.14371443f, 
    -0.00438173f, 0.25986329f, 0.05164476f, 0.06998787f, 0.05546362f, 0.00515537f, 0.06180994f, -0.13034947f, 
    -0.06958995f, -0.11425165f, -0.04425817f, 0.07812177f, 0.10700218f, -0.04555606f, -0.09223253f, -0.16103326f, 
    -0.08414292f, -0.02637591f, -0.00164418f, 0.05473598f, 0.32142174f, -0.20198323f, -0.00774970f, -0.00135672f, 
    0.12848304f, 0.01251313f, -0.24619313f, 0.09950034f, -0.05467070f, 0.13276494f, 0.01178560f, 0.02014964f, 
    -0.04599816f, -0.04890619f, -0.00856796f, -0.02681946f, -0.03237979f, -0.03868206f, -0.02844977f, -0.05595089f, 
    0.04094969f, 0.01695709f, -0.05051460f, -0.01389454f, 0.02899724f, 0.03791150f, -0.00323787f, 0.02960966f, 
    0.01944666f, 0.04039659f, -0.04513891f, -0.00349687f, -0.05252947f, 0.00697809f, -0.04249787f, -0.01099479f, 
    -0.01006883f, 0.04381107f, 0.05555582f, 0.03897564f, -0.04222767f, 0.03336297f, -0.03988504f, -0.02766470f, 
    -0.05414754f, 0.05530473f, 0.03373716f, -0.01713756f, -0.05640846f, 0.01883228f, 0.01179084f, -0.04247813f, 
    -0.03603332f, 0.03368481f, -0.01832395f, -0.04629996f, 0.00373140f, 0.00055370f, -0.04446507f, 0.03737277f, 
    -0.04417317f, 0.00263291f, 0.04380667f, -0.03182056f, 0.02825510f, -0.05436369f, 0.03867552f, -0.04364739f, 
    -0.00567662f, -0.04419386f, -0.04677314f, 0.04121106f, 0.03014494f, 0.00492751f, 0.00429713f, 0.00544444f, 
    -0.02277116f, 0.01781032f, -0.00827098f, 0.01092355f, -0.01959934f, -0.03422079f, -0.05345361f, 0.05080559f, 
    -0.03167796f, 0.03534199f, -0.02870326f, 0.00889557f, 0.03730816f, -0.04517465f, -0.03098038f, -0.03306795f, 
    -0.03385570f, -0.01998466f, -0.00677778f, -0.02269651f, -0.00563090f, -0.04414742f, -0.01010483f, -0.03847287f, 
    -0.01532471f, -0.00640405f, 0.01123873f, -0.02073543f, 0.02861316f, -0.03862666f, 0.01471828f, 0.01982565f, 
    0.03288470f, -0.01307733f, -0.05133503f, -0.04204175f, -0.01195254f, 0.03832412f, -0.01595128f, -0.04034344f, 
    -0.01528929f, 0.04496781f, -0.01953121f, 0.00147202f, 0.03845472f, -0.01131141f, -0.01715810f, 0.04422458f, 
    0.02315799f, 0.01862112f, -0.05681334f, 0.03802365f, -0.01358378f, -0.03218022f, 0.05320003f, 0.00157236f, 
    -0.03182043f, -0.02648711f, -0.01202443f, -0.04517159f, -0.04773154f, 0.01085751f, 0.01684537f, -0.04371152f, 
    0.00689596f, -0.02816428f, -0.04891336f, -0.02120197f, -0.01996393f, 0.04497273f, -0.03563168f, -0.01168715f, 
    -0.00493360f, 0.03105043f, 0.02140117f, 0.02265094f, 0.02431313f, 0.04498746f, 0.02744750f, 0.02041822f, 
    0.02220780f, -0.04511977f, -0.02878985f, 0.04323073f, 0.02250282f, -0.01976690f, -0.05234737f, 0.00019028f, 
    0.00464127f, 0.02483344f, 0.02482091f, 0.04007776f, -0.05298279f, -0.01840162f, -0.02299800f, 0.00017400f, 
    -0.02178494f, -0.03824957f, -0.02244635f, -0.04210052f, 0.01349255f, -0.04101783f, -0.00498002f, -0.03668445f, 
    0.03582201f, -0.03582015f, -0.01580378f, 0.01004252f, -0.02774541f, -0.05665281f, 0.01197527f, -0.02953992f, 
    -0.02825275f, 0.01730989f, -0.02333489f, 0.02795702f, 0.02458149f, -0.01283585f, 0.01161079f, 0.02189153f, 
    -0.04028759f, -0.04256911f, -0.05416800f, -0.04744656f, -0.04214694f, -0.02820685f, 0.02896312f, 0.00844761f, 
    0.00819967f, 0.03236963f, -0.03442532f, -0.03334208f, -0.02427336f, 0.00888091f, -0.03524123f, -0.03206233f, 
    0.02384572f, 0.04084495f, 0.04454999f, 0.03876428f, -0.01487392f, 0.03022455f, -0.01444471f, 0.00350601f, 
    0.00318827f, -0.00255969f, -0.03899105f, -0.05094965f, 0.01794916f, -0.01940927f, 0.03795473f, -0.03888206f, 
    0.03381673f, 0.01958980f, -0.01142694f, -0.04041480f, 0.01535057f, 0.00666909f, 0.03229367f, -0.04374298f, 
    -0.05250974f, 0.01687022f, 0.04240993f, -0.04762013f, 0.00287995f, -0.04126005f, 0.01916324f, 0.01646434f, 
    -0.01928348f, -0.01965100f, 0.01410628f, -0.00016327f, 0.00018036f, -0.01457393f, 0.00563854f, 0.05372572f, 
    -0.05211530f, -0.04778662f, 0.00917792f, 0.00045281f, 0.03291775f, 0.01399194f, -0.04015526f, 0.01367880f, 
    -0.00222290f, -0.05446497f, 0.01588048f, 0.00642108f, -0.05523260f, 0.02789581f, 0.04187831f, -0.03759095f, 
    -0.05067587f, -0.02737763f, -0.01433058f, -0.05166905f, -0.01339543f, -0.00273085f, -0.02727797f, -0.04038158f, 
    -0.01896773f, 0.03591383f, -0.03366226f, -0.01960774f, 0.03886254f, -0.01974621f, -0.01803448f, -0.04450503f, 
    0.02146052f, 0.00184533f, 0.01762105f, 0.01617055f, -0.02796782f, 0.04132690f, -0.02657679f, 0.03054790f, 
    0.04412468f, 0.03957479f, -0.01212685f, -0.04363835f, -0.03671282f, 0.01393708f, -0.04050982f, -0.00346186f, 
    0.02119619f, 0.01631913f, -0.00423044f, -0.01762986f, -0.05213616f, 0.03334313f, -0.01371522f, 0.01463113f, 
    -0.00845614f, -0.04166465f, -0.02541323f, -0.01225276f, -0.04108540f, -0.03959304f, 0.03344247f, 0.03331538f, 
    -0.04854271f, 0.02140042f, -0.00307036f, 0.01934597f, 0.04337322f, 0.01090670f, -0.02895732f, 0.00403957f, 
    -0.03668347f, -0.02708553f, -0.04352736f, -0.00863011f, 0.03953423f, -0.04440718f, -0.04775487f, -0.05516610f, 
    0.01544564f, -0.01115277f, -0.05259608f, 0.03792347f, 0.00323776f, -0.01064758f, -0.02571248f, -0.01791635f, 
    0.01131578f, 0.02397021f, -0.00047235f, -0.01524493f, -0.01587098f, 0.00505430f, 0.03131909f, 0.02953360f, 
    -0.01755733f, -0.01171165f, -0.02861159f, 0.02108556f, 0.04160691f, -0.03366661f, -0.02330526f, -0.00503182f, 
    -0.01954233f, -0.04941497f, -0.00746795f, -0.00800181f, 0.03636298f, 0.00957339f, -0.01319911f, -0.03293227f, 
    -0.04013752f, -0.01159516f, -0.05443094f, -0.04123473f, 0.00461644f, -0.04174776f, 0.00234026f, -0.00197598f, 
    0.02849937f, 0.03499009f, -0.00558573f, -0.02750210f, -0.05677941f, -0.00558416f, -0.00096555f, 0.00015152f, 
    -0.00315570f, -0.02847408f, -0.01768845f, 0.02755314f, 0.02384590f, -0.04295146f, 0.03409686f, -0.03451829f, 
    -0.00520118f, -0.00466015f, -0.02979106f, -0.01940029f, 0.02165336f, 0.04849409f, 0.01011933f, 0.03555682f, 
    0.18501283f, -0.06938551f, 0.04621641f, -0.20773897f, -0.00028742f, 0.17170624f, -0.03054674f, -0.02659026f, 
    0.13272549f, 0.09532735f, 0.03494965f, -0.07559939f, -0.02889226f, 0.28176948f, -0.20578077f, -0.04867263f, 
    -0.02273697f, 0.00349380f, 0.06896378f, 0.10203911f, 0.14548069f, 0.01891577f, 0.06542335f, -0.10550387f, 
    -0.03791844f, -0.38860860f, -0.34675846f, -0.03284745f, 0.17911680f, -0.09762608f, 0.01270303f, -0.03182894f, 
    0.09668227f, -0.03673698f, 0.01668134f, -0.05300871f, 0.08397538f, -0.07360284f, 0.09724861f, -0.23228616f, 
    0.15078418f, -0.08636196f, 0.03569382f, -0.05618736f, 0.04897627f, 0.06734642f, -0.05442433f, 0.14907449f, 
    0.14054808f, 0.03628022f, 0.14632241f, -0.06352993f, -0.08122552f, 0.06397648f, -0.06781165f, 0.24290790f, 
    -0.01067060f, 0.05557951f, 0.02438353f, -0.00623450f, 0.29953629f, -0.14554062f, 0.23647672f, 0.02030247f, 
    -0.14023101f, -0.05713238f, -0.02188046f, -0.08227722f, -0.01091959f, 0.01652420f, 0.03884010f, 0.21571752f, 
    0.14603411f, 0.03618979f, -0.09173238f, 0.19722781f, -0.04748776f, 0.11078297f, -0.08796283f, -0.13717432f, 
    0.18593794f, -0.11257523f, 0.04674347f, 0.15136088f, 0.35575607f, 0.06791790f, -0.15530743f, 0.01249717f, 
    0.05466659f, -0.02354938f, -0.00308013f, 0.11589945f, -0.05735324f, 0.07004999f, -0.12342035f, 0.03617835f, 
    -0.20441981f, 0.18533520f, -0.08726846f, 0.18778303f, -0.04483877f, -0.01199513f, 0.00090891f, 0.06745856f, 
    -0.07403164f, 0.13665836f, 0.09741233f, -0.06805643f, 0.14538434f, -0.09800400f, 0.02852024f, -0.22002812f, 
    0.04349777f, -0.08005773f, -0.05175992f, -0.04771504f, 0.06360783f, 0.17094664f, 0.02272441f, -0.00148637f, 
    -0.01206341f, 0.16947767f, -0.03988217f, 0.12880926f, -0.02461136f, -0.00186786f, -0.03689951f, 0.06985795f, 
    0.01845038f, 0.01556800f, -0.05153117f, 0.05723948f, 0.46011874f, -0.10862743f, 0.12021445f, 0.07078432f, 
    -0.06738937f, -0.17710948f, 0.02436868f, 0.10675900f, -0.00397445f, -0.10026087f, 0.13502239f, -0.04381015f, 
    0.34201697f, 0.08148131f, 0.04416658f, 0.04126542f, 0.07720238f, -0.01880217f, 0.02767138f, -0.03714870f, 
    -0.06797668f, -0.10335989f, -0.15489252f, -0.18969744f, -0.25496966f, 0.08927339f, -0.19052066f, 0.00842507f, 
    -0.00045745f, -0.08584178f, 0.06015362f, 0.05383772f, 0.17279021f, 0.01954492f, 0.09722208f, -0.11703870f, 
    0.41098675f, -0.08463697f, 0.05904404f, 0.04028180f, 0.05256492f, -0.12761460f, 0.07970507f, 0.25671172f, 
    0.02860152f, 0.05522476f, -0.00867148f, -0.09929425f, 0.22241771f, 0.33412233f, 0.07901333f, 0.15115492f, 
    -0.03226354f, 0.03661013f, -0.19597389f, 0.06660254f, 0.10514487f, 0.14609596f, -0.00812537f, 0.03721862f, 
    0.29001507f, 0.04069247f, 0.01536431f, -0.16016653f, 0.02667049f, -0.01668893f, 0.14399906f, 0.05365913f, 
    -0.01254819f, 0.04747807f, 0.04874281f, 0.08290701f, 0.23327605f, -0.07525057f, 0.03144053f, -0.01424596f, 
    0.03485719f, -0.09061015f, 0.08149134f, 0.12189183f, 0.00856984f, -0.01258426f, -0.09992540f, 0.13807441f, 
    0.23171854f, 0.04479905f, -0.11821256f, 0.09693456f, -0.06006893f, 0.06131785f, -0.01385898f, -0.01069103f, 
    0.00710907f, -0.15168861f, 0.04498209f, 0.03131578f, 0.27445337f, -0.66004860f, 0.19208013f, 0.06081561f, 
    0.13705142f, -0.04680790f, 0.05149467f, -0.00061037f, 0.02841363f, 0.07947964f, -0.04770814f, -0.02103960f, 
    0.17446461f, -0.09329594f, -0.09734412f, 0.13864259f, -0.05302785f, -0.02157863f, -0.05089080f, 0.06385764f, 
    0.03054191f, -0.00760806f, 0.07489681f, 0.02097445f, 0.22078747f, -0.15442820f, -0.01511982f, 0.17770125f, 
    -0.02222296f, 0.01670656f, 0.17628568f, 0.08595327f, 0.01860633f, 0.09007089f, -0.04646998f, 0.00849791f, 
    -0.11171393f, -0.16769727f, -0.05307920f, -0.28304809f, -0.12125441f, -0.08309072f, -0.06407805f, -0.10075440f, 
    -0.00457244f, 0.08662120f, 0.02712998f, -0.02704827f, 0.34391576f, -0.25707620f, -0.31196558f, 0.02191539f, 
    -0.04576710f, 0.00600852f, 0.04862353f, 0.02676860f, 0.04572266f, 0.09770466f, 0.00731062f, -0.04463800f, 
    0.05489404f, -0.07760023f, -0.18412346f, -0.10494249f, -0.02765866f, 0.07768549f, 0.08053386f, -0.12056381f, 
    0.06634504f, -0.06165482f, 0.01809752f, 0.07873654f, 0.11606730f, -0.06724713f, 0.02134933f, 0.13775074f, 
    0.12717733f, 0.05031851f, 0.01184499f, -0.16621885f, -0.06326672f, -0.02482555f, 0.07278962f, -0.03513478f, 
    0.10304517f, -0.01195488f, -0.19777858f, -0.03241985f, -0.01068254f, 0.11048222f, 0.02278032f, 0.05222373f, 
    0.15443443f, 0.00216660f, -0.10619131f, 0.10922572f, 0.27486640f, -0.30794007f, -0.18997350f, -0.00763702f, 
    0.00185806f, -0.05621235f, 0.05077774f, -0.04925702f, 0.10491739f, -0.01326757f, 0.09126811f, -0.01465364f, 
    -0.12450743f, 0.16344534f, -0.03335971f, 0.10145439f, -0.00172390f, 0.00083711f, -0.01820989f, -0.06098740f, 
    -0.13851759f, 0.04111885f, -0.02289615f, 0.06952028f, -0.08702604f, 0.04552294f, 0.05422056f, -0.22186907f, 
    -0.06075919f, 0.11043066f, -0.09732911f, 0.07551083f, -0.01357933f, -0.00871841f, -0.13069744f, 0.11217082f, 
    -0.09145845f, 0.11770531f, 0.27089995f, -0.00895230f, -0.00055823f, 0.01901635f, -0.05186574f, 0.11461560f, 
    -0.14161830f, 0.04712237f, 0.03796804f, 0.05983481f, -0.21244709f, 0.42144606f, -0.11439331f, -0.29628366f, 
    0.08137581f, 0.06601043f, 0.03848883f, 0.02095958f, 0.01603605f, 0.02501659f, 0.08187551f, 0.06417983f, 
    -0.01598578f, 0.02210827f, -0.00998870f, 0.00591566f, 0.01983529f, -0.05818211f, -0.03055967f, -0.03178094f, 
    -0.01223469f, 0.02302787f, -0.04609520f, -0.04376839f, 0.04316589f, 0.03646928f, -0.01861321f, 0.03619277f, 
    0.00490646f, 0.02093085f, -0.03261602f, -0.01174998f, -0.01135838f, -0.03669753f, -0.02838077f, -0.00472921f, 
    -0.02016744f, 0.00066575f, 0.00807035f, 0.04217845f, -0.03914061f, 0.01748994f, 0.00439285f, -0.03939591f, 
    0.00344107f, 0.00607749f, -0.03144453f, -0.03090069f, 0.04615111f, -0.04090281f, -0.05600978f, -0.03488221f, 
    0.04624892f, 0.00251363f, -0.01906896f, -0.01886337f, -0.04581773f, -0.05863880f, -0.04174138f, 0.00888287f, 
    0.03847576f, -0.00018342f, 0.05026727f, -0.05012246f, -0.00945127f, -0.01302555f, -0.05506387f, -0.01983099f, 
    -0.01087255f, 0.01520661f, 0.02276791f, 0.04249934f, -0.02264571f, -0.03885830f, 0.01148883f, -0.04750456f, 
    -0.03002367f, -0.04344513f, -0.00757103f, 0.04115102f, 0.00913039f, 0.02075854f, -0.01709818f, 0.03726792f, 
    -0.02975274f, 0.03217350f, -0.02741306f, 0.04314431f, -0.02403482f, -0.05091867f, -0.04562990f, 0.00327243f, 
    -0.01588142f, -0.02807063f, 0.04671854f, 0.03942470f, -0.02067038f, -0.03764199f, 0.00851532f, 0.04261910f, 
    0.03221586f, -0.00131694f, 0.04216671f, -0.01671803f, -0.03667947f, 0.03388692f, 0.03587558f, 0.02559772f, 
    -0.00796277f, -0.01853588f, -0.03443469f, -0.02876919f, 0.01475956f, -0.03712618f, 0.03622831f, 0.02737878f, 
    0.00506207f, -0.03378581f, -0.05005699f, 0.01912994f, -0.01027975f, -0.00615591f, 0.04213916f, -0.04921931f, 
    0.02996030f, 0.00341508f, -0.05273051f, -0.02285404f, -0.00856985f, -0.01434211f, -0.02364898f, 0.02073403f, 
    0.03544560f, -0.03369888f, -0.01879908f, -0.03390389f, -0.02028449f, 0.04544251f, -0.03218396f, -0.05028159f, 
    -0.03728097f, -0.00082497f, 0.00577413f, 0.01122573f, 0.02033715f, 0.03248924f, -0.03669836f, -0.03361771f, 
    -0.01086949f, 0.02578204f, 0.01566322f, 0.00748651f, 0.03692512f, 0.02602097f, -0.00137682f, -0.02891165f, 
    -0.01678118f, 0.03500989f, -0.01243386f, -0.03502245f, 0.02280670f, -0.00129837f, -0.01620938f, 0.03923072f, 
    -0.01353370f, -0.02299672f, -0.02023668f, 0.00013692f, -0.02649108f, -0.02998505f, -0.00670512f, 0.02968856f, 
    0.03477849f, 0.04206932f, 0.00965083f, -0.02177240f, -0.04821188f, -0.04657689f, 0.03323849f, -0.03971048f, 
    0.01221171f, -0.05773172f, -0.04542020f, -0.02796886f, -0.01477790f, 0.02508184f, 0.04000199f, -0.04387278f, 
    0.00560649f, 0.00768594f, -0.00591557f, -0.01377952f, -0.03335261f, 0.01147794f, -0.04483082f, -0.03689272f, 
    -0.03539651f, 0.00059754f, -0.05514536f, 0.03604554f, -0.00847344f, -0.03749884f, 0.03623723f, 0.00505723f, 
    0.02074885f, 0.03693153f, -0.05136897f, -0.04993148f, 0.03118044f, -0.04509905f, -0.00324284f, -0.03302868f, 
    0.03853437f, 0.01459318f, 0.01924736f, -0.02869119f, -0.05105161f, -0.02274203f, 0.02781775f, -0.04679228f, 
    -0.03128425f, 0.01808392f, -0.03756425f, 0.00013014f, -0.00264217f, -0.01044617f, 0.03228401f, -0.03193232f, 
    -0.01366753f, -0.02014212f, -0.04627182f, -0.04472023f, 0.03723939f, 0.02312462f, -0.04308319f, -0.02122285f, 
    0.02798188f, 0.01185609f, 0.01443023f, -0.02094635f, -0.01763796f, 0.03534840f, -0.02237070f, -0.00496193f, 
    0.01305430f, 0.02920008f, 0.04286150f, -0.04517401f, -0.01540780f, 0.01520098f, -0.04563116f, -0.05513762f, 
    -0.03636552f, 0.01413758f, 0.04025576f, -0.01383805f, -0.03254018f, -0.03834103f, -0.00074633f, -0.00376591f, 
    -0.02305989f, -0.01172514f, 0.00196248f, -0.00755809f, 0.03219271f, 0.02288041f, 0.01838512f, 0.03635738f, 
    -0.00760532f, -0.03590137f, 0.01521466f, -0.03354761f, 0.02399132f, -0.00190236f, -0.05067334f, -0.04845807f, 
    -0.02916514f, 0.01080164f, 0.02414808f, 0.04264196f, -0.00967033f, 0.03967103f, -0.05205335f, 0.01123939f, 
    -0.04189233f, -0.02896776f, -0.02499217f, 0.01118219f, -0.00082603f, 0.04324174f, 0.00235282f, -0.00133121f, 
    0.04562446f, -0.04439213f, -0.00903368f, 0.02701455f, -0.02359183f, -0.04702223f, -0.01349417f, -0.01249249f, 
    -0.00512701f, -0.04803587f, 0.00977417f, -0.01669378f, -0.00390090f, -0.05015439f, -0.03598570f, -0.01846362f, 
    -0.00813601f, 0.02810300f, -0.04740360f, 0.00762324f, -0.04977319f, 0.02966481f, 0.05819456f, 0.03031799f, 
    0.03594534f, 0.03944945f, 0.01072281f, 0.01259620f, 0.02918400f, 0.00037214f, 0.03103104f, -0.02991775f, 
    0.00510550f, 0.02798239f, 0.00939886f, 0.02573102f, -0.01608279f, 0.04145009f, 0.01973542f, 0.00019373f, 
    -0.04422357f, 0.03576938f, -0.03481708f, 0.04411132f, -0.03315177f, -0.00551148f, 0.01053106f, 0.03909042f, 
    -0.02806810f, 0.02216095f, 0.00280454f, 0.04424710f, 0.03662473f, -0.01884304f, 0.00443204f, 0.00847608f, 
    -0.04045412f, -0.03525351f, 0.03730846f, -0.02039634f, -0.02484130f, 0.00613901f, -0.02209084f, -0.01754931f, 
    -0.04540825f, -0.04228543f, 0.03866507f, -0.04685666f, -0.04484569f, 0.01645488f, -0.01059067f, 0.00137991f, 
    0.01677524f, -0.00878803f, 0.02673973f, 0.00848274f, -0.01597569f, -0.03761368f, -0.02693841f, -0.05395054f, 
    -0.00844273f, 0.05891753f, -0.04628407f, -0.04001125f, -0.02697929f, -0.00543512f, -0.00835524f, -0.04784926f, 
    0.03803630f, -0.03362731f, -0.00001488f, 0.02522125f, 0.04098825f, 0.03728842f, -0.00882188f, 0.00758685f, 
    -0.00574971f, 0.03373964f, 0.03918036f, -0.04006637f, 0.00317834f, 0.00119742f, 0.01393857f, 0.03374877f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02281960f, -0.00845047f, 0.07861344f, 0.01584017f, 0.06486245f, -0.01648667f, 0.07357258f, -0.01905864f, 
    0.00651203f, 0.02549371f, 0.15294521f, 0.03394585f, -0.01027106f, 0.13958871f, 0.06099150f, -0.01167753f, 
    0.06383795f, 0.04770261f, 0.01882733f, 0.04149251f, -0.07415516f, -0.09988187f, 0.00716002f, 0.00938852f, 
    0.06221107f, 0.02317221f, -0.06965148f, 0.00804738f, -0.14415455f, 0.03584260f, -0.00044159f, 0.00404149f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05028473f, -0.17247282f, -0.13832231f, 0.23340636f, -0.01944201f, 0.15056881f, -0.03756730f, -0.17908150f, 
    0.16423976f, 0.04951560f, -0.21341936f, -0.14076202f, 0.12094723f, 0.05186583f, 0.24569285f, 0.04447959f, 
    0.18648471f, 0.02952327f, 0.08131993f, 0.15958455f, -0.32405269f, -0.10923846f, 0.03396800f, 0.00370630f, 
    0.00280313f, -0.09074863f, -0.00506467f, 0.03164574f, 0.51648724f, -0.10120803f, 0.02108216f, 0.07962205f, 
    -0.02593781f, -0.11692066f, -0.00352195f, 0.31197321f, 0.27555481f, -0.09512682f, 0.12548992f, 0.14030667f, 
    0.12941433f, -0.33919081f, 0.24801259f, 0.09895141f, 0.13261448f, 0.50992477f, 0.19332135f, 0.08933096f, 
    0.12873508f, 0.03041697f, 0.37268585f, 0.07924015f, -0.06622200f, -0.35752195f, 0.14897071f, -0.10888166f, 
    -0.20851208f, -0.07542932f, 0.35195073f, -0.10736619f, -0.36071387f, -0.08276454f, 0.10784123f, 0.05956915f, 
    -0.01501523f, 0.08015727f, -0.19793388f, 0.41413516f, 0.33006817f, -0.13400653f, 0.07646084f, -0.06098204f, 
    -0.11424051f, 0.28357452f, -0.52132046f, 0.08725360f, 0.01818795f, 0.00588104f, -0.00353483f, 0.13822621f, 
    -0.01502813f, 0.04956806f, -0.07381826f, -0.03252853f, 0.17237070f, 0.19873877f, 0.00147853f, -0.12688863f, 
    -0.11026857f, 0.11977804f, 0.18644240f, 0.13865802f, 0.09276041f, -0.10520008f, 0.55896431f, 0.01786570f, 
    0.03132290f, 0.13366176f, -0.12392698f, -0.21565385f, -0.29649556f, 0.11398147f, 0.18278855f, 0.00058999f, 
    -0.07776745f, -0.10557960f, -0.19396441f, -0.02566172f, 0.01643811f, 0.21878774f, 0.07444983f, 0.09479216f, 
    -0.22974937f, 0.12509018f, -0.22074991f, 0.02959109f, 0.18854007f, 0.55180579f, 0.03606931f, -0.03774250f, 
    -0.11537992f, -0.09050446f, 0.38084012f, 0.09008969f, 0.07157969f, 0.09118097f, -0.00029934f, 0.10328681f, 
    0.04487121f, 0.06035104f, 0.33374849f, 0.24006705f, 0.14105316f, -0.14731406f, 0.13306831f, -0.16940045f, 
    0.09133084f, 0.27719149f, -0.03663082f, 0.06479845f, 0.13175444f, 0.14587194f, -0.35057211f, 0.04870060f, 
    0.13160604f, 0.06294761f, -0.20457070f, -0.16274448f, -0.12808050f, -0.19419318f, 0.10645959f, -0.14918488f, 
    0.00318670f, -0.14060633f, -0.41269529f, -0.04901752f, -0.07309404f, 0.11857743f, -0.07422251f, 0.04176235f, 
    0.00614031f, 0.03704460f, -0.09750055f, -0.24857625f, -0.34511897f, -0.07705335f, 0.15531729f, 0.00485640f, 
    0.13307054f, 0.02096470f, 0.41814947f, -0.16838093f, -0.08720745f, 0.01518601f, 0.29769805f, -0.13914847f, 
    0.22352327f, 0.19599605f, 0.28640622f, -0.04254903f, 0.01350980f, -0.10548652f, 0.10772276f, 0.04987446f, 
    0.37017047f, -0.07130717f, -0.35623136f, -0.06882761f, -0.27739510f, -0.00559946f, -0.09936915f, 0.02294562f, 
    0.05286794f, -0.04078230f, 0.34528649f, -0.09634729f, 0.50779927f, -0.14894502f, 0.00257017f, -0.11760032f, 
    0.02601279f, -0.07339081f, -0.30579814f, 0.04045013f, 0.07228944f, 0.17567579f, 0.13275790f, -0.00639222f, 
    0.33349612f, -0.05133842f, -0.34877506f, -0.15591957f, 0.13517985f, -0.12323029f, 0.06046921f, -0.04283026f, 
    -0.23052073f, 0.06337584f, -0.19342129f, -0.14968708f, -0.00083284f, -0.15515226f, 0.43130139f, 0.09874637f, 
    -0.16791697f, -0.04184550f, 0.26090065f, -0.14034814f, -0.25244078f, 0.09041991f, 0.10010754f, -0.12063541f, 
    -0.14112592f, -0.69412833f, -0.04735295f, -0.03737284f, 0.01879720f, -0.00968274f, -0.16098440f, -0.09237780f, 
    -0.07555230f, 0.30897820f, -0.23876680f, 0.15376316f, 0.27362120f, 0.10098001f, -0.15529612f, -0.06369016f, 
    0.08961084f, 0.10829218f, 0.33542624f, -0.10480846f, 0.15401849f, -0.04021855f, -0.15311313f, -0.09790257f, 
    0.11691881f, 0.14113791f, 0.03493280f, -0.15980354f, 0.08040236f, -0.08110993f, -0.16425312f, -0.08529101f, 
    0.15526882f, 0.06682431f, -0.12893115f, 0.16634221f, 0.15684749f, 0.15225846f, -0.11614938f, 0.14804807f, 
    -0.15116061f, -0.07543357f, 0.10981418f, -0.02821367f, -0.17337734f, 0.00361525f, -0.02850048f, 0.05853392f, 
    -0.15163431f, -0.03654488f, -0.03316799f, -0.07125803f, -0.12765561f, -0.10086419f, -0.07558519f, 0.11233732f, 
    -0.15453219f, 0.13376190f, 0.13728556f, 0.01575308f, -0.45459718f, -0.15018068f, 0.05941033f, 0.00856796f, 
    -0.02186749f, -0.26810598f, 0.14790624f, -0.02416100f, 0.13169423f, -0.12355738f, 0.05621102f, -0.16347241f, 
    0.21565339f, 0.14342636f, -0.16080892f, -0.16654657f, 0.01746094f, -0.02921286f, 0.09417361f, -0.07718832f, 
    0.47421291f, -0.05836039f, -0.35779852f, 0.11923195f, -0.11957280f, -0.11281053f, 0.25850484f, 0.02163607f, 
    -0.05557562f, -0.12604354f, 0.20849036f, -0.21752664f, 0.17331353f, 0.09101905f, 0.25786382f, 0.04884094f, 
    0.07743043f, 0.40140423f, 0.30020249f, 0.11882571f, -0.03361599f, -0.35928163f, -0.09000769f, 0.12884964f, 
    -0.31466517f, 0.18599480f, 0.00321867f, 0.11991264f, 0.28492939f, -0.31495810f, -0.10853878f, 0.15092927f, 
    0.07822036f, 0.02525018f, 0.08853971f, 0.11402795f, 0.12408677f, -0.09204714f, -0.43706900f, 0.07533561f, 
    -0.02907820f, 0.07790958f, 0.25810644f, 0.05446950f, -0.14916833f, -0.10224209f, -0.14375727f, -0.08717734f, 
    -0.03265206f, 0.50698400f, 0.00930069f, -0.07968953f, -0.16303270f, 0.03319858f, -0.33593658f, 0.12252294f, 
    0.26426464f, 0.16601951f, -0.33440533f, -0.11332730f, 0.10325694f, -0.39738312f, -0.13700017f, -0.03925511f, 
    0.17904787f, 0.03365176f, -0.14498906f, -0.15364595f, 0.27351499f, 0.12336195f, -0.18238507f, -0.11308108f, 
    -0.03303505f, 0.07918754f, -0.27963531f, 0.28770673f, -0.19284911f, -0.09709837f, -0.22650829f, 0.15833652f, 
    0.13606073f, 0.37632868f, 0.36413333f, 0.09234425f, -0.12504484f, 0.25086159f, 0.25344339f, -0.13902417f, 
    -0.03398722f, 0.16576445f, 0.34515005f, -0.05279917f, 0.14918013f, 0.20885216f, 0.16184254f, 0.04420966f, 
    0.38247380f, 0.07926257f, 0.19950855f, -0.14404079f, -0.03765912f, 0.07765191f, -0.48394117f, -0.05201712f, 
    -0.00939944f, -0.00871508f, -0.00396612f, -0.03556796f, -0.01105328f, 0.12970252f, 0.08508212f, 0.11232710f, 
    0.06217181f, -0.13006993f, -0.01409094f, 0.04464496f, -0.01733820f, 0.01163952f, -0.16630556f, 0.11584427f, 
    -0.03370730f, -0.12593593f, -0.16419883f, -0.08514824f, -0.09023156f, -0.09545033f, 0.11248984f, -0.07029074f, 
    -0.01987040f, -0.08485745f, -0.09126742f, -0.09723796f, -0.12560646f, -0.01371347f, 0.08317523f, -0.01437642f, 
    -0.13425423f, -0.10488570f, 0.09439097f, -0.08962823f, 0.09456103f, -0.01078282f, -0.15384722f, 0.07284624f, 
    0.16286163f, -0.03797003f, 0.08134272f, 0.07072569f, 0.06203109f, -0.00570538f, 0.07110037f, -0.01570405f, 
    -0.15515067f, -0.10510264f, -0.16865379f, -0.10178026f, 0.06372733f, -0.06339099f, -0.13675575f, -0.12489249f, 
    -0.13121082f, 0.13966571f, -0.10035568f, -0.15790038f, -0.17474173f, -0.00188153f, 0.10656600f, -0.09471849f, 
    0.13105665f, 0.01593390f, -0.21966918f, 0.03978639f, -0.02812253f, -0.10086722f, -0.31238538f, 0.09144372f, 
    0.06138602f, 0.17112844f, 0.24873573f, -0.13452172f, 0.05953367f, 0.18331248f, -0.30165929f, -0.10445830f, 
    0.30824262f, 0.15056024f, -0.24762397f, 0.18819411f, 0.12543190f, 0.43987912f, 0.09759671f, 0.01816672f, 
    -0.07195114f, -0.09700558f, 0.21848242f, 0.10651527f, 0.11251413f, -0.10140801f, 0.21768400f, -0.16693532f, 
    -0.16163310f, 0.00057943f, 0.28308329f, -0.40165648f, 0.39501014f, 0.05013261f, 0.05085996f, -0.01649026f, 
    -0.05388431f, 0.15578784f, 0.40173030f, -0.02821703f, -0.07824939f, 0.27924192f, 0.04041255f, 0.02027106f, 
    -0.08277923f, -0.03225054f, -0.00915897f, -0.02297585f, 0.04062013f, 0.14777851f, -0.04846741f, -0.10350125f, 
    -0.29912937f, 0.11231019f, -0.27525562f, -0.14549899f, -0.29938036f, -0.08919679f, -0.04927657f, -0.05927242f, 
    -0.04201055f, 0.08910301f, -0.09426574f, 0.01217100f, -0.07925861f, -0.15117449f, -0.18188174f, 0.01603289f, 
    -0.01802798f, 0.00819600f, -0.11531431f, -0.09904523f, 0.00724816f, -0.05744843f, 0.14786853f, 0.09753821f, 
    -0.00323027f, -0.06367546f, 0.08125380f, -0.13467351f, -0.02840421f, -0.05233077f, 0.01276002f, 0.11179899f, 
    0.09951203f, -0.14089084f, -0.04152519f, 0.10474561f, -0.09800491f, -0.05683707f, -0.04340396f, 0.08203775f, 
    -0.15453081f, -0.16308297f, 0.15514259f, 0.12280566f, 0.10917454f, -0.04693203f, -0.16650234f, -0.17086019f, 
    -0.05652253f, -0.01129217f, -0.09820690f, -0.04756415f, -0.06984759f, 0.07134509f, 0.02592790f, -0.03781628f, 
    -0.12640841f, -0.08824749f, -0.02740879f, 0.13396133f, -0.06243849f, -0.11737790f, -0.13870028f, 0.12981139f, 
    -0.04328861f, 0.05861573f, -0.17378251f, 0.04178748f, -0.10041278f, 0.08978994f, -0.13551261f, 0.14156941f, 
    -0.11013632f, -0.01780948f, 0.11637572f, -0.42973235f, 0.39461252f, -0.16346839f, -0.21881846f, -0.15344660f, 
    -0.12151200f, 0.55185848f, 0.25962877f, 0.14623994f, 0.10321692f, -0.02259798f, 0.13910197f, 0.07410182f, 
    -0.24496204f, -0.23596865f, 0.48209772f, -0.03631445f, -0.00074437f, 0.38949880f, 0.14824794f, -0.10118931f, 
    0.13259798f, -0.09355458f, 0.11787792f, -0.15325202f, 0.13486528f, 0.01414215f, 0.14618136f, 0.14824966f, 
    -0.15984951f, 0.15715665f, 0.19881195f, -0.36467645f, 0.25273111f, -0.04645278f, 0.25224450f, -0.06536268f, 
    0.14503951f, -0.56561649f, -0.07222852f, -0.17134149f, -0.03383130f, -0.26428190f, 0.28272745f, 0.01873999f, 
    -0.01902038f, 0.15719070f, -0.02885570f, 0.05439390f, 0.25837460f, 0.09925388f, 0.06294013f, -0.00100574f, 
    0.13224076f, 0.12409911f, 0.28478447f, -0.01451949f, -0.01819635f, -0.04961831f, 0.34796265f, 0.05771562f, 
    0.03035461f, -0.10363073f, 0.16283461f, 0.29180652f, 0.57115173f, 0.06465906f, 0.15375888f, 0.14634232f, 
    0.18368801f, 0.54073352f, 0.16538674f, -0.05025813f, -0.05934404f, 0.26059791f, 0.08677491f, 0.08047197f, 
    -0.22368188f, -0.12370144f, 0.30870280f, 0.12795357f, 0.14520967f, -0.32416624f, -0.08515222f, 0.08655924f, 
    -0.34321395f, -0.15455562f, 0.33872759f, 0.05104769f, 0.00195784f, 0.17098714f, 0.33017433f, 0.00094392f, 
    0.00154303f, 0.06420279f, -0.33823580f, 0.47391629f, -0.34532839f, 0.14951657f, 0.10565760f, -0.02772236f, 
    0.00480102f, 0.26395693f, 0.16468643f, 0.14147040f, -0.04047285f, 0.23988931f, -0.00815017f, 0.11674847f, 
    0.25070962f, 0.12725683f, 0.24849330f, -0.14082289f, -0.14131030f, -0.23572741f, 0.10827507f, 0.03741906f, 
    0.39496207f, -0.11386987f, 0.14584850f, 0.11052966f, -0.10981250f, -0.02315033f, -0.02004460f, 0.17806883f, 
    0.12452508f, -0.12925346f, 0.24796776f, 0.10312849f, -0.02649488f, 0.12067153f, 0.15860564f, -0.00300301f, 
    -0.01746996f, 0.43771490f, -0.12749392f, -0.07623554f, -0.00057209f, -0.25049835f, -0.09521490f, 0.15493098f, 
    0.00367404f, -0.09147289f, -0.22087142f, -0.04466376f, 0.20034359f, 0.03971196f, 0.07322470f, 0.03384809f, 
    0.35327309f, 0.13479698f, -0.03843888f, -0.10650419f, 0.39071524f, -0.08238607f, -0.18964462f, -0.15143849f, 
    0.12550826f, 0.07281807f, -0.12516679f, 0.32470411f, -0.05051405f, -0.15349676f, -0.24701738f, -0.08869089f, 
    0.12953098f, 0.42647764f, 0.03484740f, 0.14811923f, 0.12748100f, 0.01641373f, -0.15327303f, 0.11989968f, 
    0.01630658f, 0.19825438f, -0.06956752f, 0.04944289f, 0.13751034f, 0.44109905f, -0.16734581f, -0.03473917f, 
    0.34614944f, 0.09970374f, -0.18934487f, 0.16686177f, -0.33918360f, 0.09365615f, 0.30767402f, -0.12237111f, 
    0.12337843f, -0.16993923f, -0.28979078f, 0.28266385f, -0.03811491f, 0.12913212f, -0.39507908f, -0.11244726f, 
    -0.05094829f, 0.28802598f, 0.06593181f, 0.09055746f, -0.16752312f, 0.35115156f, -0.45573249f, -0.09658077f, 
    0.24274291f, 0.20765564f, -0.16365118f, 0.14392233f, 0.26840806f, -0.10571551f, -0.08002348f, 0.15135077f, 
    0.29090807f, 0.02226140f, 0.03986599f, -0.15984100f, 0.13786285f, -0.09982892f, 0.01802116f, 0.09747697f, 
    0.07964443f, -0.01934620f, -0.23689456f, -0.16151084f, 0.06763258f, 0.17210183f, -0.31004733f, -0.11274301f, 
    0.10421451f, -0.34151891f, -0.01300655f, 0.06128613f, 0.08710080f, 0.38319963f, -0.19198696f, -0.07912321f, 
    0.32873338f, 0.28882086f, -0.18213710f, -0.06779782f, -0.28746250f, 0.34263703f, 0.17185469f, -0.05724987f, 
    -0.18859731f, -0.10445171f, -0.08670760f, -0.14317039f, 0.17278764f, 0.16526398f, 0.20632268f, -0.15934035f, 
    0.14668095f, 0.01612217f, 0.30315828f, 0.08736466f, 0.08298431f, -0.12744997f, 0.35021701f, 0.06645657f, 
    0.03026603f, 0.25539067f, -0.21642312f, -0.11370678f, -0.15820168f, 0.13480383f, -0.20148668f, -0.07354867f, 
    0.17491525f, -0.06763200f, 0.05033483f, 0.14151266f, -0.25219959f, 0.07790047f, -0.01997166f, 0.08234762f, 
    -0.01015637f, 0.07304810f, -0.61822379f, -0.04212277f, -0.10339424f, -0.13435422f, 0.35872245f, 0.10392774f, 
    0.03343945f, -0.12874575f, -0.00042305f, 0.44360369f, 0.34068456f, 0.15928514f, 0.07630475f, -0.08045805f, 
    0.16150407f, 0.32615244f, 0.20223078f, 0.11763873f, -0.10176035f, 0.35196114f, 0.24636261f, -0.09044188f, 
    0.04504016f, -0.10755695f, 0.26720446f, 0.18046255f, -0.24454065f, -0.46787280f, 0.14683470f, 0.00976346f, 
    -0.10536665f, -0.00507344f, 0.11146571f, -0.14040075f, 0.01831896f, 0.08397204f, 0.27402306f, 0.13344349f, 
    -0.06614743f, -0.04292359f, 0.24857004f, 0.43811613f, -0.41036949f, -0.02867399f, 0.40258443f, -0.02556700f, 
    -0.07291721f, -0.10867400f, -0.10219456f, 0.13537198f, 0.00507199f, -0.12598971f, 0.43794566f, 0.01829568f, 
    -0.02650275f, 0.05297105f, 0.42567343f, -0.02763766f, -0.23381370f, -0.17122792f, -0.11618022f, -0.03672184f, 
    0.32490844f, -0.11694627f, -0.28579459f, 0.00545117f, 0.09100652f, 0.08105330f, -0.22117324f, -0.07318713f, 
    -0.15421991f, -0.10611879f, 0.47048873f, -0.33472916f, 0.00476460f, 0.05582589f, 0.20095973f, -0.08476733f, 
    -0.16416422f, -0.13651606f, 0.26464021f, 0.14751330f, 0.05652398f, -0.26819825f, 0.08910650f, -0.07555234f, 
    -0.24550122f, -0.09913252f, 0.22874033f, -0.15893634f, 0.22607052f, 0.16358085f, 0.14844841f, 0.18842983f, 
    -0.21650162f, -0.18415792f, 0.10377360f, -0.06011061f, 0.26942223f, -0.07449771f, -0.06550412f, -0.13334982f, 
    0.01113018f, 0.09626150f, -0.06418613f, 0.11673433f, 0.00784043f, -0.05332969f, -0.18371874f, -0.15084466f, 
    0.09265883f, 0.08858570f, -0.18359208f, -0.16424750f, -0.04293296f, -0.15061601f, 0.09278342f, -0.04217749f, 
    -0.07917798f, 0.02139718f, -0.03652707f, 0.13529755f, 0.12405242f, 0.07130928f, -0.15078436f, -0.17261739f, 
    0.03588361f, 0.16774671f, -0.07257877f, -0.15517847f, -0.02787333f, -0.11095775f, -0.04388938f, -0.16117115f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.10849463f, 0.12618788f, 0.11709099f, 0.08545324f, 0.17619258f, 0.30599704f, 0.17485671f, 0.08189799f, 
    -0.16446510f, 0.18341246f, 0.18303850f, 0.06854990f, 0.11017148f, -0.06961225f, 0.14202952f, 0.09411887f, 
    0.01684777f, -0.17300029f, -0.17526938f, 0.15123732f, -0.01773150f, -0.08294525f, 0.15087686f, -0.17876503f, 
    0.05983728f, 0.00731534f, 0.10175530f, 0.16787687f, 0.08732387f, 0.20507434f, 0.10868311f, -0.01648339f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.35882840f, -0.42590886f, 0.33193669f, 0.29682419f, -0.78514999f, -0.38218141f, -0.05199222f, -0.08279662f, 
    -0.05823624f, -0.50881433f, 0.03915112f, -0.38941211f, 0.08706196f, -0.11884511f, 0.13257162f, 0.23788328f, 
    0.00327295f, 0.02042014f, -0.13361213f, 0.50180054f, 0.17855476f, 0.10176175f, -0.31259185f, 0.25498074f, 
    0.12548703f, -0.09161697f, -0.54191560f, -0.22369604f, -0.30003276f, -0.41841149f, 0.21520200f, -0.13950485f, 
    0.21583714f, 0.22226253f, -0.10381608f, -0.25012597f, -0.19195418f, -0.15801577f, 0.23998275f, 0.10140131f, 
    -0.02890585f, -0.29065254f, 0.14957584f, -0.20773551f, -0.54778826f, 0.15801568f, -0.15168984f, -0.25384581f, 
    0.32078606f, -0.09838399f, 0.03128818f, 0.24186671f, 0.25969782f, 0.18177836f, -0.42276108f, -0.18206833f, 
    -0.56335950f, -0.17820157f, 0.27453637f, -0.03606137f, 0.13652711f, -0.28401631f, 0.28829071f, -0.04577974f, 
    -0.36819246f, -0.37089640f, 0.24086890f, 0.38921207f, 0.13077305f, -0.37544250f, 0.28562954f, 0.38590533f, 
    0.00250224f, 0.17550693f, 0.00683688f, -0.06208282f, -0.71780682f, -0.04611645f, -0.03107304f, -0.08055577f, 
    -0.17689174f, 0.03648647f, -0.09974989f, -0.54263443f, 0.01850259f, -0.11810213f, -0.45002437f, 0.19299382f, 
    0.15595867f, -0.19467717f, 0.02798038f, 0.33849561f, -0.33797327f, -0.07333636f, 0.20466504f, 0.00200664f, 
    0.11989620f, 0.03027720f, 0.12048189f, 0.41460758f, -0.44783053f, 0.08523934f, 0.01337556f, -0.04483119f, 
    0.08889217f, -0.25687501f, -0.71402216f, -0.15804741f, 0.30446488f, 0.12558804f, 0.07583970f, 0.34688306f, 
    -0.27559513f, 0.00091162f, -0.09647953f, -0.17122436f, -0.09350802f, 0.00686231f, 0.13949969f, -0.52705961f, 
    0.18153603f, 0.05241755f, 0.34716117f, -0.31793591f, -0.02334619f, -0.43002978f, -0.59270144f, 0.01791650f, 
    -0.33229333f, 0.15169683f, 0.02837596f, -0.15839970f, 0.02135323f, -0.06623416f, -0.20265500f, 0.18024869f, 
    -0.07109103f, -0.09594606f, 0.19315001f, 0.13945803f, 0.21656214f, 0.07382397f, 0.12179153f, 0.04437947f, 
    -0.40335888f, -0.14562516f, -0.08637881f, -0.25626898f, 0.03722942f, 0.00883343f, 0.22451277f, 0.13080463f, 
    0.07859686f, 0.44523808f, -0.48336974f, -0.48954144f, 0.02767551f, -0.22202721f, -0.15223306f, -0.14024776f, 
    -0.07123036f, 0.00897762f, -0.41850463f, -0.19998649f, 0.40563813f, 0.12433133f, -0.39899299f, -0.35737532f, 
    0.17006828f, -0.31152090f, 0.32688874f, -0.04984968f, 0.25152925f, 0.06070433f, 0.11481235f, -0.35046184f, 
    0.24162388f, -0.13672487f, 0.04248111f, 0.32451916f, -0.28160927f, 0.24523638f, -0.04907266f, 0.12814529f, 
    -0.06637453f, -0.43145594f, -0.30085024f, 0.13436334f, 0.17312407f, 0.11966234f, 0.25462478f, 0.02237345f, 
    -0.16481477f, 0.29327595f, -0.51451272f, 0.28012189f, -0.55663162f, 0.23543824f, -0.49818704f, 0.38247690f, 
    -0.10723180f, 0.14033802f, 0.03328535f, -0.65525067f, 0.22957064f, -0.02113476f, -0.16387367f, -0.28300267f, 
    0.00713933f, -0.11760757f, 0.12769838f, -0.25828433f, 0.24612966f, -0.27464545f, 0.04222579f, -0.13248540f, 
    -0.21812633f, -0.53991085f, 0.35703048f, -0.35024473f, -0.31318933f, 0.30754328f, 0.18227689f, 0.06601943f, 
    0.35799024f, -0.41830534f, -0.34268215f, -0.40227592f, 0.17815128f, 0.02525532f, -0.27857846f, -0.16000605f, 
    0.16189085f, 0.20940049f, -0.26184303f, 0.37111503f, 0.14812715f, 0.03006977f, 0.13069853f, 0.29366389f, 
    -0.35674030f, -0.03131025f, 0.00672805f, -0.02332249f, -0.44144768f, -0.54212105f, 0.20253943f, 0.09230782f, 
    0.04079951f, 0.36067706f, 0.25638083f, 0.06377680f, -0.13082631f, -0.02837279f, -0.01577308f, 0.02947722f, 
    0.47821835f, 0.07274917f, 0.24456635f, -0.42315108f, 0.16625644f, -0.42981774f, 0.32217374f, -0.33464959f, 
    -0.06247061f, -0.46863297f, -0.03330128f, 0.06486487f, -0.18969494f, -0.01976961f, -0.02508399f, -0.53884256f, 
    -0.48789757f, 0.02167189f, 0.08594821f, -0.53851175f, -0.02044351f, 0.22872841f, 0.05541718f, 0.22717857f, 
    -0.60870934f, -0.36088732f, -0.23255281f, 0.22352165f, 0.22948597f, 0.39435795f, -0.03822673f, -0.06436437f, 
    -0.27108666f, -0.71300828f, -0.33066717f, -0.15066163f, -0.07890408f, 0.27221751f, -0.04142211f, 0.29866782f, 
    -0.09881569f, 0.31670615f, 0.37805504f, 0.35827056f, 0.04866169f, 0.06923625f, 0.13919258f, -0.23772389f, 
    -0.26393035f, 0.03220135f, 0.10593382f, -0.23000666f, 0.16244507f, -0.37695512f, -0.06144797f, 0.34733564f, 
    -0.01409582f, -0.10300558f, -0.34859586f, -0.07157164f, -0.60764813f, 0.12798271f, 0.17486303f, -0.12200511f, 
    -0.65564114f, 0.12552196f, -0.12541549f, -0.42803141f, 0.45789623f, 0.23142128f, 0.33959231f, -0.40872204f, 
    -0.09168395f, 0.13547829f, -0.35464314f, 0.01906515f, -0.21131255f, -0.10866529f, 0.13947889f, 0.09202818f, 
    0.62684178f, -0.07578651f, -0.12187288f, -0.25256059f, -0.14418153f, -0.04966661f, -0.00451111f, -0.30649564f, 
    0.29456085f, 0.06273416f, 0.11203144f, 0.42776728f, 0.15855150f, -0.24917407f, -0.53245407f, -0.07248986f, 
    -0.05401804f, -0.02085910f, 0.28026399f, -0.35579169f, -0.16326085f, 0.24730562f, -0.14313336f, -0.45500633f, 
    0.15133469f, 0.33336526f, -0.48555177f, -0.42040947f, -0.02267704f, 0.13474202f, 0.13176589f, -0.25756809f, 
    -0.61205029f, -0.01041885f, 0.13972653f, 0.10535040f, 0.09554461f, 0.03909935f, 0.26795098f, -0.09523955f, 
    0.24491350f, -0.20086734f, -0.45294434f, 0.23300773f, 0.25793099f, 0.37597582f, -0.27368614f, -0.15308212f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09657090f, -0.11039357f, 0.09640180f, -0.12486915f, 0.00095388f, -0.05245329f, 0.11299957f, -0.15745683f, 
    -0.04219744f, 0.07372238f, 0.05983673f, -0.07787167f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
