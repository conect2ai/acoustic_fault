#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.16579425f, 0.45976228f, -0.43621030f, 1.30882728f, 0.71156061f, 0.74242216f, 0.66082495f, 0.37746081f, 
    0.76676410f, 0.25664192f, -0.39674684f, -0.11292979f, -0.08288210f, -0.21515115f, -0.09811775f, -0.07731380f, 
    -0.06158439f, -0.01500001f, -0.15769129f, 0.04182322f, 0.05769062f, -0.10529798f, -0.02432713f, -0.10408271f, 
    -0.12065881f, 0.97639000f, 0.49533433f, 1.26270628f, 0.42194745f, -0.14232834f, 0.08784256f, -0.76742345f, 
    0.30687857f, 0.64740127f, -0.37750235f, -0.22655015f, 0.00061943f, -0.40790209f, -0.24075210f, 0.04560509f, 
    -0.12885725f, 0.01560757f, -0.05329851f, -0.17410466f, 0.08435882f, 0.12651867f, -0.12314019f, 0.44244173f, 
    0.22129712f, -0.05140854f, 1.16606247f, 0.84091878f, 0.70627344f, 0.04605315f, -0.15551302f, -0.77821851f, 
    -0.63824898f, -0.43740034f, -0.35206655f, 0.21637417f, 0.17741901f, 0.27260128f, 0.19748239f, 0.32101771f, 
    -0.03888679f, 0.25404546f, -0.14967582f, 0.29699972f, 0.28034836f, -0.00157572f, 0.02733766f, 0.50845927f, 
    0.14654538f, 0.10050850f, 0.20047593f, -0.37840995f, 0.49681878f, 0.20213225f, 0.32188019f, 0.79669279f, 
    -0.27050808f, -0.77918756f, -1.00355148f, -0.43680122f, -0.45700788f, 0.01928501f, 0.48716995f, 0.23150340f, 
    0.33967736f, 0.10565847f, 0.12789185f, 0.03516712f, 0.54926866f, -0.11508571f, 0.68866462f, 0.12302987f, 
    0.22740088f, -0.06986904f, 0.37620226f, -0.02971711f, 0.32858834f, 0.87531865f, 0.58594322f, 0.14469287f, 
    0.35155663f, -0.73504621f, 0.31751627f, 0.58870530f, 0.41033986f, 0.57406414f, -0.84138972f, 0.00299089f, 
    -0.03476338f, 0.24176690f, 0.15041809f, 0.37708992f, 0.20767230f, -0.28115967f, -0.11170954f, 0.09559619f, 
    -0.24017836f, -0.31886318f, -0.23439862f, 0.17724299f, -0.28387237f, 1.20974398f, 0.78854626f, 0.26429781f, 
    -0.14035627f, 0.56086129f, 0.22931881f, 0.23980699f, -0.35063121f, 0.55489528f, 0.32594243f, 0.17249030f, 
    0.57118666f, -0.51729912f, -0.12727474f, -0.21490216f, -0.01374135f, -0.11903653f, -0.35624638f, -0.03192310f, 
    -0.26002786f, -0.08773614f, 0.19326176f, 0.15649493f, 0.19915409f, 0.30309698f, -0.77295029f, 0.85749769f, 
    0.11042155f, 0.12677771f, -0.64390486f, -0.08876677f, -0.53283769f, 0.19520101f, -0.14719510f, -0.48700780f, 
    -0.49735299f, -0.09290752f, 0.35342002f, 0.23883121f, 0.09447471f, 0.27935421f, 0.40504795f, 0.30595124f, 
    0.09573469f, -0.08708362f, -0.34922865f, -0.45713216f, -0.43182793f, -0.28953782f, -0.21462080f, -0.41995972f, 
    -0.92486972f, -0.41403958f, -1.00284159f, -0.78862780f, 0.00307206f, 0.39432809f, 0.71863377f, -0.04025334f, 
    0.30021039f, 0.35212991f, 0.02206060f, -0.08662666f, -0.15362133f, -0.13988817f, 0.39390501f, 0.40538442f, 
    0.17455448f, 0.12840518f, -0.19120322f, -0.12127452f, 0.12573276f, 0.13400698f, 0.01868445f, 0.33655891f, 
    0.99026060f, 0.73959959f, -1.31497490f, -0.11627866f, -0.23926847f, -0.26363319f, -0.38556376f, 0.55721647f, 
    0.15128323f, -0.49476293f, -0.08347919f, -0.10298741f, 0.44473758f, 0.22718842f, 0.20138080f, -0.19395985f, 
    -0.38358760f, -0.16650493f, -0.12938321f, 0.25236735f, 0.04286468f, -0.01144031f, -0.12224803f, -0.13770488f, 
    -0.19544601f, 1.15319109f, 1.06170344f, -0.05711065f, -1.12176287f, -0.84047157f, 0.34773657f, 0.42688817f, 
    0.08586958f, -0.23401587f, 0.24423353f, 0.54373747f, 0.09766182f, 0.04624464f, -0.15640932f, 0.16949889f, 
    0.34003624f, 0.22276765f, -0.06849942f, 0.01746067f, 0.02291962f, 0.22894001f, -0.13126716f, -0.01718684f, 
    -0.16652487f, 0.13566452f, -0.20727625f, -0.29846245f, 0.30048332f, -0.70699728f, -0.48690346f, -0.32494396f, 
    -0.57856566f, -0.74875700f, -0.44376904f, 0.53414458f, -0.50918704f, -0.00503974f, 0.27602980f, 0.02925848f, 
    0.09335209f, -0.58456242f, -0.34190950f, 0.32185483f, -0.15529588f, 0.05846230f, 0.24598822f, 0.02644044f, 
    -0.33793405f, -0.29581812f, -0.45639923f, 0.19373973f, 0.37283754f, 0.93493670f, -0.42842358f, -0.51291037f, 
    0.85564905f, -0.44667503f, -0.64426553f, -0.44824007f, -0.35189781f, 0.17919846f, 0.19251749f, -0.36665252f, 
    -0.00102552f, -0.24843383f, -0.00178155f, 0.25867176f, 0.25906512f, 0.03679850f, -0.21880360f, 0.15656602f, 
    -0.27681363f, -0.27953595f, -0.17571966f, -0.22972086f, -0.44050464f, -0.82157636f, -0.79264861f, -0.24715544f, 
    -0.09297466f, 0.03568649f, 0.85358220f, 0.31585664f, -0.02004648f, 0.64868945f, -0.15890008f, -0.38816911f, 
    0.35864449f, -0.16940747f, -0.52102983f, -0.53213578f, -0.02500375f, 0.20591705f, 0.16728510f, -0.57064974f, 
    -0.08940008f, -0.11723397f, -0.17324820f, -0.25264940f, 0.07193010f, -0.75408739f, -1.44923413f, -0.50928968f, 
    0.45050019f, 0.59472901f, 0.09658590f, 1.27105105f, -0.21951696f, 0.43121415f, 0.35656923f, 0.15856513f, 
    0.13231160f, -0.16707094f, 0.41057411f, 0.37531841f, -0.09529976f, 0.10561529f, -0.10601569f, -0.20411754f, 
    0.03917995f, 0.01897537f, 0.09753740f, -0.02069555f, 0.04769702f, -0.00791021f, -0.73897153f, 0.31917900f, 
    -0.41027123f, -0.65786368f, -0.72434515f, 0.49108613f, 0.96111488f, -1.11067128f, -0.10935441f, 0.05080516f, 
    -0.09155740f, 0.45291424f, 0.13402635f, 0.17287639f, 0.23877014f, 0.19633736f, 0.14689666f, 0.12896216f, 
    0.15829238f, -0.08131547f, 0.12898687f, -0.13438323f, 0.12657757f, -0.00540630f, 0.13718367f, 0.62786877f, 
    -0.15607683f, -0.93510312f, -0.96432257f, -0.32916468f, 0.07383890f, -0.30392140f, 0.36754990f, 0.30504125f, 
    -0.18763261f, -0.34185493f, -0.19440462f, 0.20424259f, -0.20237727f, -0.41390505f, -0.02263208f, -0.00865794f, 
    0.01251199f, -0.16829459f, -0.31645191f, 0.04521893f, 0.28403124f, 0.32578006f, 0.04184024f, 0.05043084f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21518360f, 0.18804412f, 0.14123051f, 0.46142542f, 0.20471336f, 0.28640562f, -0.02025589f, -0.02010210f, 
    0.09564504f, 0.18926673f, 0.10924254f, 0.01279289f, 0.13376333f, 0.17441341f, 0.24108042f, 0.21199301f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.36948651f, 0.18875720f, -0.04654806f, -0.05353271f, 0.32825291f, -0.01150240f, 0.07410924f, -0.09209905f, 
    0.06801925f, -0.00157435f, -0.08204837f, 0.06183252f, 0.15204392f, -0.25203398f, 0.07074738f, 0.04218743f, 
    0.12645473f, 0.21545987f, -0.00581454f, -0.00960202f, 0.05675130f, 0.12711835f, -0.00618759f, 0.00133037f, 
    -0.67769897f, -0.24893466f, 0.22491397f, 0.06756125f, -0.06556923f, 0.22901489f, 0.20054556f, -0.10037226f, 
    -0.04235939f, -0.16294956f, 0.19185212f, -0.07974242f, 0.16506091f, 0.07812307f, 0.10125550f, 0.29223445f, 
    -0.00345072f, 0.05010659f, -0.04220623f, 0.07288403f, -0.20465307f, 0.13696568f, 0.17939496f, 0.16938776f, 
    0.42288098f, -0.45972684f, 0.00172591f, 0.28134286f, 0.01453402f, -0.02564209f, 0.05128118f, -0.22132212f, 
    -0.02253865f, 0.04847232f, 0.15671726f, 0.11181675f, -0.25575829f, 0.00768392f, -0.04315928f, -0.16818364f, 
    0.21991849f, 0.18157955f, 0.05378716f, -0.08264478f, -0.00759270f, 0.02222926f, -0.16333382f, -0.04083852f, 
    0.10779947f, -0.22350587f, -0.04805464f, -0.21591410f, 0.13047071f, 0.05201451f, 0.20864496f, 0.22480236f, 
    -0.19775859f, 0.10051240f, 0.08877693f, 0.16056706f, 0.59199697f, -0.25668293f, 0.20239805f, 0.31311890f, 
    0.02893827f, 0.00244979f, -0.02783677f, 0.10713795f, -0.01497659f, 0.06101202f, 0.01484920f, 0.26222956f, 
    0.20928991f, -0.08051962f, 0.08801961f, -0.11770723f, -0.03373626f, -0.06343874f, 0.20600988f, -0.14269349f, 
    -0.15895358f, 0.11534821f, -0.01393379f, -0.15067139f, -0.12907863f, -0.24633835f, 0.34969860f, -0.26579100f, 
    0.10818055f, -0.05077179f, 0.06497224f, -0.11133046f, 0.01963287f, -0.04872191f, 0.01036751f, 0.02412261f, 
    -0.01672240f, -0.04814064f, 0.21914750f, -0.24111652f, -0.00697256f, 0.08422581f, 0.11715584f, 0.12735149f, 
    0.01487382f, -0.01664395f, -0.17235716f, -0.03991195f, -0.38497022f, -0.06109692f, 0.25915140f, -0.21799178f, 
    0.20137915f, 0.12402717f, -0.06224154f, 0.16282216f, -0.06479985f, -0.00597842f, 0.11411676f, 0.09910618f, 
    0.06738911f, 0.03806626f, 0.16598591f, 0.36111793f, -0.13961107f, 0.10047597f, -0.01866974f, 0.08420102f, 
    -0.08529890f, 0.09676721f, 0.16386987f, -0.35217124f, -0.48880470f, 0.02543534f, 0.02394982f, -0.01855123f, 
    -0.19702213f, -0.06842978f, 0.01851073f, 0.05583382f, 0.05806562f, 0.04024331f, -0.12140759f, 0.03539458f, 
    -0.55382895f, -0.00936760f, 0.46558836f, -0.17998791f, -0.11558820f, -0.23254967f, -0.04705062f, -0.01924634f, 
    0.17277226f, -0.11377298f, 0.13010761f, 0.07673752f, -0.10121693f, -0.11254727f, 0.08054110f, 0.34994873f, 
    -0.12598467f, 0.21482204f, 0.05325687f, 0.31319776f, 0.16425984f, 0.14183140f, -0.11724798f, 0.22598019f, 
    -0.49638313f, 0.14732608f, -0.10949185f, -0.42739543f, 0.03054162f, -0.13999932f, 0.06139021f, -0.12107524f, 
    0.08161083f, -0.12780605f, 0.06426959f, -0.04067672f, -0.09892509f, -0.33013532f, -0.19056401f, -0.50158745f, 
    0.07878286f, 0.21666278f, -0.07716133f, -0.07105206f, 0.02849461f, 0.38542277f, -0.00073263f, 0.09239684f, 
    -0.34845111f, -0.35848632f, -0.21263383f, 0.16241546f, 0.13186096f, 0.14000362f, 0.03325687f, -0.21668667f, 
    0.00467815f, 0.09042699f, 0.06500188f, -0.01070867f, 0.08190742f, 0.12957129f, -0.01838709f, 0.08400105f, 
    0.24047278f, 0.06811984f, -0.04221536f, 0.17474034f, 0.12705925f, 0.07526843f, 0.06255837f, -0.14142510f, 
    -0.24997601f, -0.16807766f, 0.14560604f, 0.03427862f, -0.01053155f, -0.11205528f, 0.08016191f, -0.06719477f, 
    -0.07143383f, 0.00881479f, 0.02186786f, 0.27085927f, -0.69948936f, 0.16169600f, -0.38216642f, 0.01383452f, 
    -0.04322499f, 0.12857522f, -0.07320358f, -0.10345461f, -0.10937405f, 0.13542105f, -0.02514644f, 0.17136391f, 
    0.41522282f, -0.19441472f, 0.01348206f, 0.25587276f, -0.00515525f, -0.03485141f, 0.09734350f, 0.17112866f, 
    -0.08052775f, -0.03208787f, 0.16079022f, -0.08561593f, 0.41601393f, -0.10718291f, 0.07191340f, 0.08321711f, 
    0.11544261f, 0.05374719f, -0.03718649f, -0.10629619f, -0.20183222f, 0.00003476f, 0.21048410f, 0.00394340f, 
    0.31169730f, 0.41273886f, 0.07174545f, 0.16222616f, 0.20740166f, 0.21089587f, 0.15126018f, 0.07214334f, 
    0.09075703f, -0.00080402f, 0.08951931f, -0.04697940f, -0.28744221f, -0.10032245f, -0.00552374f, 0.53376514f, 
    0.03196367f, 0.18286109f, 0.03287812f, 0.05067804f, -0.07753733f, 0.01583988f, 0.00404119f, -0.23268278f, 
    0.44758049f, 0.45234793f, -0.07365928f, 0.01393584f, 0.07030667f, 0.16801642f, 0.00026580f, -0.25658000f, 
    0.09181932f, -0.04566904f, -0.09430663f, 0.25221393f, 0.43175665f, -0.10628726f, -0.25050887f, 0.41617429f, 
    0.11722739f, 0.00275881f, 0.13234782f, 0.18105495f, -0.10141482f, 0.06550802f, 0.03589973f, 0.11562922f, 
    -0.07824268f, -0.20609896f, 0.09661507f, -0.07999494f, -0.20128675f, 0.26592502f, 0.14926130f, 0.09934186f, 
    0.05755822f, 0.09821566f, 0.01112567f, 0.09150518f, 0.00938894f, -0.05216234f, 0.16444263f, 0.04130812f, 
    -0.09721374f, 0.01056397f, 0.16267255f, -0.04070770f, 0.09086998f, -0.04825693f, 0.05544278f, -0.00854160f, 
    -0.14158086f, 0.33356360f, 0.10933498f, 0.33078369f, 0.15940484f, -0.20831957f, 0.08302646f, 0.08867843f, 
    -0.27174196f, -0.04205583f, -0.14400603f, 0.13229428f, 0.14292221f, 0.25821659f, 0.22606833f, 0.54757154f, 
    -0.14682737f, 0.16402420f, -0.17284726f, 0.16287516f, 0.07663869f, 0.01737720f, -0.08296776f, 0.05478640f, 
    -0.52620727f, -0.09642325f, -0.28089088f, 0.10819697f, 0.19795702f, 0.11081530f, -0.01257959f, -0.13935983f, 
    0.14355062f, 0.21064009f, 0.08029836f, -0.04881803f, 0.49525702f, -0.46026045f, -0.17532453f, -0.04757683f, 
    0.14341193f, 0.18861467f, -0.08042051f, 0.09391039f, -0.04335134f, -0.21887138f, -0.08660740f, -0.13045681f, 
    0.40487045f, 0.02129705f, -0.20336504f, -0.21354185f, 0.11667943f, 0.07700293f, -0.01684899f, 0.03902105f, 
    -0.12984617f, 0.03573373f, -0.00238859f, 0.15811911f, 0.15986772f, -0.07799214f, -0.00646194f, 0.12060622f, 
    0.13426508f, -0.12608205f, 0.11575803f, 0.06658849f, 0.02076660f, 0.27918184f, 0.09227431f, 0.06672294f, 
    0.00343917f, -0.45717749f, -0.20762974f, -0.05971074f, 0.16301179f, 0.06629881f, -0.16082472f, 0.11450623f, 
    0.00155205f, -0.12063219f, -0.08039087f, 0.06548666f, 0.46079558f, -0.17050785f, -0.06062668f, 0.00545294f, 
    0.09490634f, 0.22729546f, 0.12326341f, -0.08972576f, 0.04850780f, -0.02506215f, -0.00595020f, 0.06529347f, 
    -0.14808629f, -0.04365304f, -0.21524441f, 0.02157841f, -0.08519217f, 0.32976049f, -0.14333440f, -0.21095379f, 
    -0.08676343f, -0.15403809f, 0.13958691f, -0.05584664f, 0.20813797f, 0.20866410f, 0.09857208f, -0.25252676f, 
    -0.07249255f, -0.02114259f, -0.00606813f, -0.06185801f, 0.16936967f, 0.14809014f, -0.00090010f, -0.05333922f, 
    -0.48908216f, 0.11374629f, 0.31401530f, -0.10247867f, 0.14853783f, -0.10857490f, -0.00330263f, 0.27059162f, 
    0.15333049f, -0.04628712f, 0.08341001f, -0.00002187f, 0.21318781f, 0.05541285f, 0.29842129f, -0.12709576f, 
    0.02644063f, -0.02899180f, -0.05914699f, 0.10630524f, 0.04652432f, 0.18463546f, 0.03708666f, 0.45115715f, 
    0.28286391f, 0.09926164f, -0.14759794f, -0.17327726f, 0.00137031f, 0.27295017f, 0.14238466f, 0.00495307f, 
    0.03151881f, 0.04548399f, -0.06271405f, -0.25044575f, -0.12377571f, -0.18634371f, -0.03345651f, 0.10248753f, 
    -0.13587666f, -0.04768144f, -0.17974256f, -0.06768217f, 0.12690520f, -0.04787803f, 0.19184224f, -0.07510979f, 
    0.41850621f, 0.12253209f, -0.09641259f, 0.01710898f, 0.04123845f, 0.05192504f, -0.05560150f, 0.04051574f, 
    0.01287906f, -0.05623940f, -0.03544289f, -0.15580553f, 0.13407232f, 0.28494340f, -0.02196091f, 0.10943879f, 
    0.08488741f, -0.15823317f, 0.16005832f, 0.08674016f, 0.04913671f, 0.17206644f, -0.04340354f, -0.05439768f, 
    0.18164586f, 0.07144746f, -0.13599627f, -0.04137355f, -0.23609433f, -0.15909937f, -0.07525061f, -0.04762707f, 
    0.04595545f, -0.12786302f, 0.22780910f, 0.06162921f, 0.15441181f, 0.24112509f, 0.25120154f, -0.03849579f, 
    0.06615814f, 0.08091384f, -0.06519717f, -0.02574300f, 0.09770256f, -0.03603284f, 0.07662404f, 0.11419012f, 
    -0.07140363f, 0.05478625f, -0.03037325f, -0.04052538f, -0.04594709f, 0.02213075f, 0.06747124f, -0.00400183f, 
    -0.06121945f, 0.01412212f, 0.01082631f, 0.06577823f, -0.00415981f, -0.05558399f, 0.03851173f, -0.03844056f, 
    -0.02224715f, 0.03044436f, 0.00963687f, -0.05351062f, 0.03351005f, 0.01468376f, -0.00132217f, -0.00004518f, 
    0.04113654f, -0.01418952f, 0.01846003f, -0.07231744f, -0.04841532f, -0.06620870f, -0.05972215f, -0.01670341f, 
    -0.04622088f, 0.05199872f, -0.05236015f, 0.05633226f, -0.02635186f, -0.05758309f, 0.04264222f, -0.06547435f, 
    -0.05944308f, -0.04723581f, 0.00902020f, -0.03638418f, 0.03887463f, 0.01392249f, -0.07629401f, -0.07089268f, 
    0.02378897f, -0.07072570f, -0.00521487f, 0.02975107f, 0.05928895f, 0.04078387f, -0.05056449f, 0.04985385f, 
    0.05439600f, 0.00396836f, -0.02798936f, -0.01624216f, 0.03082844f, -0.02120535f, 0.01291248f, -0.07891151f, 
    0.04449378f, 0.01751007f, -0.07477833f, -0.05662849f, -0.04455988f, 0.05454388f, -0.05171459f, 0.00642842f, 
    0.01858202f, -0.05250602f, 0.01421060f, -0.00541252f, 0.05834704f, 0.05504626f, -0.03480548f, -0.04739036f, 
    -0.01121182f, -0.03369756f, -0.01114976f, -0.04250669f, -0.06720303f, -0.04400935f, 0.04261212f, 0.01945972f, 
    -0.07503703f, -0.00142295f, 0.00645318f, -0.04624383f, -0.03145277f, -0.06397447f, 0.03743232f, -0.06673154f, 
    0.01135389f, 0.00658092f, -0.03869086f, -0.06629454f, 0.05480255f, -0.02856288f, -0.00526274f, -0.03667811f, 
    -0.02746709f, -0.03514520f, -0.03308535f, 0.05980445f, -0.07686419f, 0.06377208f, -0.06962890f, -0.07042857f, 
    0.04545666f, -0.04768155f, 0.05853812f, 0.05084990f, -0.00815589f, -0.05586364f, 0.00351168f, -0.04971625f, 
    -0.01754279f, -0.06370836f, 0.06258357f, -0.06153723f, -0.06497389f, 0.00416590f, 0.00605778f, -0.00769721f, 
    -0.06183423f, -0.05975430f, -0.03872326f, 0.06144801f, 0.01900653f, 0.01844394f, 0.06158060f, -0.05580390f, 
    -0.03224488f, -0.05169938f, 0.01451063f, -0.05632048f, -0.06751906f, 0.06240889f, 0.00244053f, 0.03177687f, 
    0.05335170f, -0.05188657f, 0.04678927f, 0.05646855f, 0.05911994f, 0.04837288f, 0.03554779f, 0.02445748f, 
    0.06197430f, -0.03743510f, 0.03047855f, -0.04163031f, 0.04673099f, 0.03200859f, 0.05616081f, -0.02259082f, 
    -0.03581951f, -0.01095667f, -0.04475749f, -0.04672121f, -0.03807108f, 0.01693332f, 0.02705018f, 0.02017805f, 
    -0.02839775f, -0.05548265f, -0.06074800f, -0.00303196f, -0.06551846f, -0.04635740f, 0.03476088f, -0.02273419f, 
    0.01333624f, 0.05437459f, -0.06105663f, -0.01622744f, -0.00313621f, -0.04221221f, 0.01241772f, -0.06154954f, 
    -0.05290917f, 0.03981471f, 0.01082755f, -0.03167193f, -0.01454444f, -0.03048756f, -0.05428578f, 0.02648879f, 
    0.02218353f, -0.01442051f, -0.05099460f, 0.04342028f, 0.01681317f, -0.02290359f, -0.01901199f, -0.07141327f, 
    0.06346878f, 0.06035556f, 0.01084283f, 0.05261506f, -0.00492750f, 0.00487670f, -0.04212685f, -0.00272111f, 
    -0.07062609f, 0.02833494f, -0.07162310f, 0.05389275f, -0.00825447f, 0.04354141f, 0.01351885f, 0.06420834f, 
    -0.04912062f, -0.02412083f, 0.02325131f, 0.01620413f, -0.07710176f, 0.03312942f, -0.06486886f, 0.05871258f, 
    0.05919703f, 0.05457171f, 0.02617811f, -0.06525402f, -0.04356649f, -0.06215749f, 0.00621576f, -0.04371815f, 
    -0.04482550f, 0.04338161f, -0.07742386f, -0.02085825f, -0.05796880f, -0.04239463f, -0.03825888f, -0.01633298f, 
    0.00531875f, -0.00681147f, -0.05956143f, -0.02972308f, 0.01238414f, -0.06722772f, -0.01334716f, -0.03532342f, 
    -0.00609204f, -0.02076300f, 0.02786177f, 0.05586617f, 0.03904583f, 0.04401043f, -0.07715172f, -0.05012736f, 
    -0.05027387f, -0.02090924f, 0.05775903f, 0.01674861f, -0.05559504f, -0.02051448f, -0.01856753f, 0.02889251f, 
    -0.00965587f, -0.04983488f, 0.04405346f, 0.06533514f, -0.05945069f, -0.02400591f, -0.03840970f, -0.00617620f, 
    0.01575528f, -0.04328307f, 0.05026324f, -0.01110468f, -0.04998085f, -0.02569578f, 0.00246252f, 0.00567227f, 
    -0.02301695f, 0.00241784f, -0.05301344f, 0.03082418f, 0.05145349f, -0.03004190f, -0.00396412f, 0.04145774f, 
    0.06014034f, -0.00015449f, 0.00505760f, -0.07251599f, 0.04650291f, -0.00775460f, -0.04575713f, -0.03291430f, 
    -0.07343076f, -0.04397258f, 0.01101967f, 0.03120583f, -0.05241932f, -0.04193406f, -0.01551768f, 0.01564629f, 
    0.02306929f, -0.06723773f, -0.05108882f, -0.00074601f, -0.00438875f, -0.03711375f, 0.02336136f, -0.02295821f, 
    -0.03319852f, -0.06332716f, -0.04425496f, -0.00194253f, -0.04386523f, -0.06424705f, 0.03476919f, -0.03183146f, 
    0.04706637f, -0.01043733f, -0.00324551f, -0.04699579f, 0.02992122f, 0.05666474f, -0.01950765f, -0.07394736f, 
    0.02798753f, -0.05116071f, 0.01535819f, 0.00033481f, -0.05728620f, -0.01730108f, -0.07058050f, -0.00814082f, 
    -0.02994012f, 0.00553719f, 0.01058695f, -0.07322234f, 0.04721806f, 0.02593752f, 0.06181678f, 0.04894960f, 
    0.03379788f, 0.00124993f, 0.06240585f, -0.04641413f, -0.05342874f, 0.04000413f, 0.02262653f, -0.01801772f, 
    0.01912279f, -0.04813819f, -0.04413740f, -0.06372577f, -0.07286730f, -0.05636118f, -0.07744738f, 0.05641824f, 
    -0.01265909f, -0.05970764f, -0.01780454f, -0.05233581f, 0.05122212f, 0.04252924f, 0.03285770f, 0.03571161f, 
    0.01352881f, -0.01206821f, -0.06588649f, 0.02070875f, -0.03876345f, -0.02769304f, 0.01507523f, 0.01369140f, 
    0.05942054f, 0.05107734f, 0.04219345f, 0.05284518f, -0.07435137f, -0.00675714f, 0.05579690f, -0.01725290f, 
    0.03268033f, -0.20118628f, 0.17286712f, -0.33273911f, 0.05774366f, -0.09820231f, -0.02542077f, -0.06247293f, 
    0.09131067f, -0.05208763f, -0.01443987f, 0.16181336f, -0.35961682f, 0.05788767f, 0.00204597f, 0.09287401f, 
    0.13292335f, 0.14086165f, 0.05984651f, 0.14460126f, 0.05909871f, 0.09339788f, -0.00486915f, 0.08885946f, 
    0.13664992f, 0.28259170f, 0.11095529f, 0.08177213f, 0.13124393f, -0.08788277f, 0.16264582f, -0.01176160f, 
    0.02287029f, 0.06525264f, 0.19587596f, 0.03999702f, 0.22284575f, -0.06922586f, -0.21562441f, 0.12853512f, 
    -0.12900706f, -0.00782062f, 0.11106278f, 0.08603331f, -0.07572881f, 0.18702637f, 0.33981296f, 0.36054018f, 
    0.03368874f, 0.26509595f, 0.15830588f, -0.09707684f, 0.08009433f, 0.03617452f, -0.09179783f, -0.04484133f, 
    0.09128443f, -0.06654096f, -0.11961070f, -0.12978245f, 0.18687366f, -0.30716196f, -0.13176219f, 0.26378137f, 
    -0.01989944f, -0.02482616f, 0.23147678f, -0.12754454f, 0.05005676f, -0.18151899f, -0.15550812f, 0.04072741f, 
    -0.32370776f, -0.11261068f, -0.00829181f, -0.10202403f, -0.01896169f, 0.18209445f, -0.18776612f, -0.32319108f, 
    -0.17359661f, 0.06302506f, 0.23922287f, -0.15597609f, -0.25976115f, 0.18015745f, -0.17819473f, 0.21477939f, 
    -0.07935815f, 0.05854416f, 0.09302676f, -0.01013273f, 0.19144052f, 0.04245362f, -0.00009134f, -0.07137816f, 
    -0.16985694f, -0.04158262f, -0.04360922f, 0.14905462f, 0.12259563f, -0.10664549f, 0.15456258f, -0.22613382f, 
    -0.01078883f, 0.04418325f, -0.06132003f, -0.15953903f, 0.73375916f, 0.12581602f, -0.23629904f, 0.15909155f, 
    0.07078421f, -0.07780357f, -0.10682862f, -0.08190189f, -0.05640111f, 0.22482213f, 0.08945341f, 0.19383495f, 
    0.24491081f, 0.13814583f, 0.05876999f, 0.22044206f, 0.14433183f, -0.02553158f, -0.11345404f, 0.08759683f, 
    0.04477186f, 0.01908721f, 0.07862526f, -0.32812688f, -0.19751015f, -0.13567674f, -0.08300056f, 0.01898055f, 
    0.02661111f, 0.05522952f, -0.25352257f, -0.11054933f, 0.13566439f, -0.07410343f, 0.05214936f, 0.02239751f, 
    0.17700300f, -0.09526262f, -0.12405681f, 0.10886396f, -0.01443211f, 0.08250066f, -0.13275637f, 0.00298922f, 
    0.06393177f, -0.32874545f, 0.13669163f, -0.24046758f, 0.30045244f, -0.05853279f, -0.16019246f, -0.02905997f, 
    0.07710234f, -0.06288362f, 0.22222817f, 0.08664348f, -0.11032794f, 0.06097838f, -0.05800305f, -0.11688308f, 
    -0.38489720f, -0.07556582f, -0.51625913f, 0.03013608f, -0.05542281f, 0.12313698f, 0.04251188f, -0.01685059f, 
    0.03853367f, 0.06696026f, 0.37816820f, -0.04334887f, -0.17704238f, -0.07606342f, -0.01670553f, -0.13298574f, 
    0.23234665f, -0.00657908f, -0.07725617f, 0.11988228f, 0.21632963f, -0.26582745f, 0.15150993f, -0.10925043f, 
    -0.00722421f, -0.00377103f, 0.00842948f, -0.03373355f, -0.01604740f, 0.00796674f, -0.01170750f, -0.06759490f, 
    -0.07930721f, -0.01425433f, -0.00061548f, 0.04139236f, -0.04861082f, -0.06473961f, -0.01499277f, -0.04212384f, 
    -0.01510670f, -0.05919466f, 0.02934387f, -0.05611429f, -0.05462579f, 0.00800578f, 0.02670782f, -0.02327649f, 
    -0.04331907f, 0.03356536f, 0.05646681f, 0.05441374f, -0.01544047f, -0.06258316f, -0.05864493f, -0.02930958f, 
    -0.00034484f, 0.02263463f, -0.01412150f, -0.01884421f, -0.01626335f, -0.04258335f, 0.01371839f, 0.01695275f, 
    -0.05480012f, 0.00648513f, -0.06349614f, -0.07646981f, 0.02719278f, 0.04523839f, -0.04432375f, 0.03015993f, 
    0.01757717f, -0.01435276f, -0.04721024f, 0.06400176f, -0.07474663f, -0.00137588f, -0.02696913f, 0.02519556f, 
    0.00470057f, 0.05579118f, -0.03423876f, 0.05319571f, -0.00931457f, -0.02413895f, -0.05167199f, -0.00982525f, 
    -0.04487274f, 0.00982963f, -0.00333259f, -0.03838818f, -0.04852220f, 0.06029561f, -0.05201416f, -0.07201304f, 
    -0.02901918f, -0.00174749f, -0.03749996f, 0.06421519f, -0.05701166f, -0.07789326f, 0.05063567f, 0.01992316f, 
    0.00769133f, 0.01529893f, 0.04598789f, -0.07423143f, 0.06363855f, -0.03930831f, -0.05774349f, -0.00190217f, 
    0.04160013f, -0.07116362f, -0.00922306f, -0.00138964f, 0.01055372f, 0.02642453f, -0.00791892f, -0.07624801f, 
    0.05674982f, -0.04864721f, -0.00844321f, -0.05672721f, 0.00750716f, 0.01279341f, 0.00691256f, -0.05785504f, 
    -0.01869235f, 0.02599978f, -0.01656866f, 0.01476420f, 0.00194502f, 0.00366474f, 0.06443986f, 0.06313033f, 
    -0.06755354f, 0.00086816f, 0.00601664f, 0.02175123f, -0.07966945f, 0.00513934f, 0.00854845f, -0.02023390f, 
    -0.05690617f, -0.06764616f, 0.02113027f, 0.00577893f, 0.04408363f, -0.06841751f, 0.01396059f, -0.05573817f, 
    -0.02990940f, -0.05876023f, 0.00390613f, 0.04717530f, 0.03163211f, 0.02736970f, 0.02427471f, 0.00256445f, 
    -0.01187617f, -0.07359082f, -0.03615842f, -0.07306436f, -0.03431575f, 0.01902350f, 0.06271128f, -0.03039538f, 
    0.03013814f, 0.06646451f, -0.07832825f, -0.05445015f, 0.00960440f, 0.05304255f, 0.03594597f, 0.05162207f, 
    -0.03054605f, -0.06619845f, 0.05437069f, 0.04578274f, 0.03091925f, 0.04990790f, 0.06484308f, 0.04075221f, 
    0.00631024f, -0.02145772f, 0.04834527f, 0.01991514f, 0.02086447f, 0.04087017f, -0.07785205f, 0.02252965f, 
    0.00420366f, -0.06033215f, -0.06950226f, -0.00374359f, -0.03785052f, 0.05553611f, 0.04159934f, 0.05128460f, 
    0.01896294f, 0.03047084f, 0.06015697f, -0.07307757f, -0.07077979f, -0.07149611f, -0.02361803f, -0.00838852f, 
    -0.00695254f, -0.01296327f, -0.01123222f, 0.03265624f, 0.01705577f, 0.03045494f, -0.03683479f, -0.07511090f, 
    -0.13768280f, 0.27409229f, -0.07234877f, -0.00337166f, 0.11041281f, -0.04846688f, 0.07493911f, 0.22237758f, 
    -0.04273672f, -0.09252743f, -0.05471175f, 0.16693805f, -0.05056584f, 0.50573403f, 0.13948129f, -0.00542104f, 
    0.02725621f, -0.01890543f, 0.07884561f, 0.02980859f, 0.03033998f, 0.05160452f, -0.02357064f, -0.05224861f, 
    -0.24962382f, 0.27590638f, 0.61309749f, -0.09865336f, 0.07712035f, 0.21189637f, 0.04785287f, -0.07726950f, 
    0.01418132f, 0.07705114f, -0.12541977f, -0.08027472f, -0.23857629f, 0.17957573f, 0.09288668f, -0.43970323f, 
    0.10219235f, 0.23338413f, 0.00937358f, -0.02050355f, 0.07349348f, -0.14260243f, 0.08259915f, -0.01879321f, 
    0.36596575f, -0.01183489f, 0.24167055f, 0.20469673f, 0.15354270f, 0.11278357f, 0.21811956f, 0.02293529f, 
    0.23467943f, -0.04410909f, 0.29138324f, -0.12132251f, -0.02793129f, 0.76142424f, 0.29466823f, -0.00309354f, 
    0.13308015f, 0.04634939f, -0.13948843f, -0.00112201f, 0.02680354f, 0.10483529f, -0.01058189f, -0.09330643f, 
    0.18043058f, -0.16999015f, 0.17522822f, -0.09704225f, -0.00899360f, -0.18125975f, 0.04148310f, -0.03559744f, 
    0.10865694f, -0.01065917f, 0.04083737f, 0.01829800f, -0.21676365f, -0.23366021f, -0.16231669f, 0.01017471f, 
    -0.00324438f, -0.13271536f, -0.16544096f, 0.08968928f, -0.05653276f, -0.13221194f, 0.23019186f, 0.03135200f, 
    -0.19067691f, -0.20369478f, 0.16113548f, 0.11423650f, 0.10760662f, -0.20199032f, -0.00305826f, -0.22922625f, 
    0.11091844f, -0.09588541f, 0.04479668f, 0.11313637f, 0.61202091f, 0.17563373f, -0.10115334f, 0.43651971f, 
    -0.06444284f, 0.12541389f, 0.03506207f, -0.11215540f, 0.06190052f, 0.00453949f, 0.05495413f, -0.10445938f, 
    -0.37555051f, -0.32261312f, 0.12876463f, -0.15189046f, 0.16749696f, -0.17537564f, 0.11089911f, -0.05650612f, 
    -0.00416567f, 0.14801030f, 0.06580457f, 0.19192068f, 0.09365550f, 0.25828815f, 0.17533876f, -0.62145472f, 
    0.11419723f, 0.14143211f, -0.02729147f, 0.15113118f, 0.09779885f, 0.01590008f, 0.15475769f, 0.04716860f, 
    0.08125421f, -0.25449193f, 0.15205172f, 0.06948748f, 0.00049235f, -0.05199000f, 0.12274521f, 0.12128133f, 
    0.10671706f, 0.15787306f, 0.13425034f, 0.27490529f, 0.32826152f, -0.57706338f, -0.03979984f, 0.00309150f, 
    0.18292078f, 0.02790869f, -0.14112785f, -0.21441844f, 0.22455506f, -0.05299666f, 0.11710309f, 0.10639450f, 
    -0.28898630f, -0.27502641f, 0.12114307f, -0.12930317f, 0.12332901f, -0.12085032f, 0.02192697f, -0.06753560f, 
    -0.02914941f, -0.08149181f, -0.14242975f, -0.17976102f, -0.31119514f, -0.10089289f, -0.02526547f, 0.03370185f, 
    0.04875890f, -0.21920136f, 0.00834097f, 0.08696734f, 0.09922144f, -0.11294450f, 0.12735879f, 0.15677845f, 
    0.38633561f, -0.72358668f, -0.30694547f, 0.19554023f, -0.09591856f, 0.00481283f, 0.04360696f, 0.17404267f, 
    0.16696362f, 0.18469323f, 0.09261186f, 0.00568072f, -0.36008611f, 0.01294607f, -0.06560072f, 0.22850819f, 
    -0.17516793f, -0.17267847f, 0.02301953f, 0.05959376f, 0.08573284f, 0.04123978f, 0.06495428f, 0.08001808f, 
    -0.22683479f, -0.20837085f, 0.03016920f, 0.08491918f, 0.06729032f, 0.05919454f, -0.00561160f, 0.04174596f, 
    0.17302209f, 0.16867033f, -0.00581147f, 0.13491972f, 0.43449309f, 0.34944940f, 0.19727924f, 0.28557318f, 
    0.10777593f, 0.10167988f, 0.04105110f, -0.06710631f, 0.02190476f, -0.02049078f, -0.00963773f, -0.01534297f, 
    -0.19347699f, -0.00855711f, -0.30146721f, 0.11871821f, -0.22448997f, -0.03030181f, 0.05799451f, 0.07058819f, 
    -0.09725508f, 0.03854042f, 0.06901387f, 0.09964076f, 0.17111760f, -0.52606010f, -0.01132520f, -0.13332783f, 
    -0.02652695f, -0.08603190f, 0.09757222f, 0.14279525f, 0.21033658f, 0.15393415f, 0.22799878f, -0.05275198f, 
    -0.18513198f, 0.41703597f, -0.20476995f, 0.09395469f, -0.01523776f, 0.24100538f, 0.18029366f, -0.06220568f, 
    0.02977293f, 0.06482839f, -0.12750348f, 0.14074102f, 0.21179833f, -0.32104617f, 0.05643508f, -0.14795072f, 
    -0.16457143f, -0.02995018f, 0.03603143f, 0.22764730f, 0.01347010f, 0.16647844f, 0.04923171f, -0.04534866f, 
    0.38569430f, -0.45570180f, -0.03094298f, -0.05586667f, -0.18848583f, -0.08268444f, 0.12611903f, 0.13962975f, 
    0.04837939f, 0.14648627f, -0.04306120f, 0.08884056f, -0.46787745f, -0.31912628f, 0.25214693f, -0.41865948f, 
    -0.04087905f, -0.18755291f, 0.12460680f, 0.06978709f, -0.16524482f, -0.03109174f, 0.00574779f, -0.06260796f, 
    0.00190098f, 0.22594018f, 0.24246138f, -0.00630886f, -0.20056474f, 0.14582542f, 0.02931264f, 0.17965195f, 
    0.16208570f, 0.23476082f, -0.14540635f, 0.17906265f, -0.36233309f, -0.01663689f, 0.17908926f, 0.19796868f, 
    0.06806231f, 0.12959667f, 0.03028596f, -0.10722275f, -0.03059098f, -0.03696012f, -0.15827669f, -0.21835032f, 
    0.23462535f, 0.22566231f, 0.11848832f, 0.04114081f, 0.06992925f, -0.14873452f, 0.18827477f, 0.00576225f, 
    0.04088932f, 0.08207602f, -0.07460167f, 0.19568458f, 0.58549708f, -0.03182571f, -0.09831855f, 0.23904623f, 
    -0.16374564f, 0.05432409f, 0.13665096f, 0.08974884f, -0.00725362f, -0.12515876f, 0.11108044f, 0.16871123f, 
    0.34275717f, 0.15042153f, -0.03279853f, -0.35398838f, -0.03091285f, 0.18800130f, 0.02569476f, 0.11235616f, 
    0.01880725f, 0.06796489f, -0.06271858f, 0.03959588f, -0.05261899f, -0.34900123f, 0.10254357f, -0.17512394f, 
    0.03285305f, -0.07115813f, 0.16345717f, -0.25378430f, -0.14150366f, 0.16732287f, 0.11685552f, 0.04071955f, 
    0.35328162f, -0.17096044f, 0.19514383f, 0.04383079f, 0.04544510f, -0.04033267f, -0.15854608f, -0.13626130f, 
    0.10323487f, 0.08769677f, -0.02702021f, -0.07178870f, -0.23815137f, -0.30784455f, 0.01984476f, 0.15649982f, 
    0.06215127f, 0.06267122f, 0.13214158f, -0.00851951f, -0.02925147f, 0.10715965f, -0.00251426f, 0.07305846f, 
    0.25161740f, -0.09624290f, -0.21285981f, 0.31282678f, 0.04694077f, -0.17147848f, 0.10545370f, 0.12077516f, 
    0.18679774f, 0.02187766f, 0.21232614f, 0.13421294f, 0.14819191f, -0.13078298f, -0.09093250f, 0.22741343f, 
    -0.02940414f, -0.03322829f, 0.00283385f, 0.06098211f, 0.08057594f, 0.28518596f, 0.15264773f, 0.27937198f, 
    0.05886686f, 0.21354012f, 0.07304113f, -0.12333837f, -0.04513847f, 0.00945809f, -0.03229214f, -0.07540219f, 
    0.06229283f, 0.07650544f, -0.19273274f, 0.03151722f, 0.10645827f, -0.49149400f, -0.19845437f, 0.30517790f, 
    0.08122595f, -0.04800704f, 0.09147722f, -0.10888558f, -0.11507186f, -0.16925190f, -0.15581843f, 0.16614999f, 
    -0.15217671f, -0.17798774f, 0.08892981f, -0.08705077f, 0.09872116f, 0.11529149f, -0.21850082f, -0.28148115f, 
    0.00464749f, 0.15878178f, 0.31324223f, 0.03715605f, -0.01004652f, 0.25262102f, 0.02985509f, -0.07819343f, 
    0.01869841f, 0.17298025f, 0.03966919f, -0.06543168f, 0.15073365f, 0.01442759f, -0.02744805f, 0.12728043f, 
    0.19347952f, 0.02909964f, -0.02838654f, 0.08917718f, 0.01707814f, 0.11736476f, -0.03212823f, 0.03752889f, 
    -0.10682908f, 0.10867068f, -0.09488686f, -0.24123931f, 0.26874715f, 0.07996109f, -0.28361759f, -0.17258896f, 
    0.04701209f, -0.01876710f, -0.11224433f, 0.03474370f, -0.08551345f, 0.17828529f, 0.08072849f, 0.19540173f, 
    0.28559408f, 0.36435929f, -0.00103339f, 0.40894532f, -0.02335709f, 0.02176815f, -0.06209785f, 0.02970312f, 
    -0.05961920f, -0.04553045f, 0.14531027f, -0.33406314f, -0.05483223f, -0.14320378f, -0.07903682f, 0.37371391f, 
    0.02190789f, -0.02807491f, -0.10448113f, -0.01065594f, 0.06240205f, -0.08275741f, -0.03524802f, 0.12844025f, 
    0.07202972f, 0.11328919f, -0.17386512f, -0.02883695f, -0.06799374f, 0.17553692f, -0.16007338f, -0.14653023f, 
    0.05094211f, -0.37594184f, 0.11198618f, -0.20236045f, -0.28053722f, 0.47112361f, -0.13479984f, 0.13648383f, 
    -0.03714925f, 0.00292632f, 0.14641933f, -0.00377272f, -0.04885606f, 0.00524085f, -0.05799986f, 0.01553921f, 
    -0.28079790f, 0.25514427f, -0.27738819f, 0.12092553f, -0.06345595f, 0.00623649f, 0.15266357f, -0.08017875f, 
    0.11277463f, 0.12226176f, 0.19507562f, 0.07793172f, 0.28510919f, -0.15565287f, 0.11738953f, -0.37956652f, 
    0.07120974f, 0.22172265f, -0.05109429f, 0.08951055f, 0.14348429f, -0.21158963f, 0.08622783f, -0.10846873f, 
    0.00012134f, 0.02693911f, -0.04803199f, -0.03209752f, 0.05508498f, 0.01845085f, -0.01402085f, 0.00237393f, 
    0.04300566f, 0.03109055f, -0.05610770f, -0.00830538f, 0.00662777f, 0.06475817f, -0.01009855f, -0.06726933f, 
    -0.05789635f, -0.05274109f, -0.01408316f, 0.04960625f, 0.02845741f, -0.06378713f, 0.01359234f, -0.05871893f, 
    0.04406376f, -0.00199519f, -0.02633355f, -0.02193557f, 0.06413037f, 0.00478657f, -0.05019969f, -0.01994910f, 
    0.00547975f, 0.06352510f, 0.02445343f, -0.06886413f, -0.03575103f, -0.03983493f, -0.00135945f, -0.04462119f, 
    0.03268119f, 0.04816569f, 0.01172871f, 0.01034108f, -0.02812448f, 0.00031172f, -0.06855039f, -0.03956912f, 
    -0.03166776f, 0.03582837f, -0.06264950f, 0.01339510f, 0.00824039f, 0.04665903f, 0.06064815f, 0.02643399f, 
    0.00291154f, -0.05541847f, -0.02458487f, -0.06265463f, 0.02885969f, -0.00092274f, -0.03440797f, 0.00281232f, 
    -0.04485982f, -0.07446789f, 0.05442609f, -0.01836392f, -0.07892443f, -0.05743178f, 0.02444535f, -0.04339283f, 
    -0.06511893f, 0.05012174f, 0.03410134f, -0.00997309f, -0.02992811f, 0.00495122f, -0.02960343f, -0.04547220f, 
    -0.06837006f, -0.02273022f, -0.01778401f, -0.03162917f, 0.01664135f, -0.02029879f, -0.03492646f, -0.06084393f, 
    0.01087698f, -0.07180479f, -0.00706777f, 0.05842232f, -0.04586061f, -0.01713943f, -0.04411639f, 0.04114332f, 
    -0.06063312f, 0.04057478f, -0.06882718f, 0.04627992f, 0.01039701f, 0.04153344f, 0.04931965f, 0.05068354f, 
    -0.03054763f, -0.02725536f, -0.03109189f, 0.03700107f, -0.06481902f, -0.06860949f, 0.03009297f, 0.05505805f, 
    0.01098000f, -0.06473275f, -0.02111470f, -0.06764776f, 0.02519808f, -0.01984906f, -0.03282245f, 0.03848270f, 
    0.06350268f, -0.06147549f, -0.00624346f, -0.02389247f, 0.06092987f, 0.04909825f, 0.04412167f, -0.05739444f, 
    -0.03301913f, 0.02667875f, -0.00208946f, -0.07735994f, 0.02795813f, 0.04052544f, 0.02862696f, -0.06376717f, 
    0.02854307f, -0.01141503f, 0.05567900f, -0.05775578f, 0.06009573f, -0.06923756f, 0.06104490f, 0.03034244f, 
    -0.03090076f, 0.00928547f, 0.04110241f, -0.06678934f, 0.03138324f, -0.07166462f, 0.02079341f, -0.03102808f, 
    -0.07172164f, -0.02037952f, -0.01343919f, 0.00503043f, 0.06269823f, 0.00114154f, 0.01177292f, -0.06697735f, 
    -0.04067525f, 0.05969052f, 0.05833447f, -0.07067294f, -0.05650358f, -0.07334683f, 0.03956319f, -0.00616917f, 
    -0.06248691f, 0.01286170f, 0.04186371f, -0.00966069f, 0.05239097f, -0.04831505f, -0.04160471f, -0.05761824f, 
    -0.01349253f, -0.01088053f, 0.01346202f, -0.02761156f, -0.05505308f, -0.04737072f, -0.06095493f, 0.04613835f, 
    0.00438882f, 0.01850600f, 0.03379078f, 0.06279546f, -0.08006863f, -0.04214576f, -0.04517730f, 0.04248584f, 
    -0.14324406f, -0.48656583f, -0.10752835f, -0.45384431f, -0.04705979f, 0.01295071f, 0.20770733f, 0.19695456f, 
    0.05729182f, 0.02419025f, 0.07512221f, 0.07190496f, -0.29645106f, 0.41458824f, -0.03835014f, -0.41573456f, 
    -0.10078512f, -0.11503626f, 0.03709256f, 0.03242902f, -0.02253430f, 0.09008127f, 0.06169820f, 0.02019065f, 
    0.13369441f, 0.05572141f, 0.06733857f, 0.08548199f, 0.07606625f, -0.20742689f, 0.04937888f, -0.05269710f, 
    0.17053418f, 0.20920059f, -0.00754245f, -0.00832797f, 0.19473384f, 0.24393103f, -0.07981356f, 0.17308496f, 
    0.06322002f, 0.17317319f, 0.09133618f, 0.04155551f, 0.09418803f, -0.10017612f, 0.10552691f, -0.10515695f, 
    -0.45532346f, 0.40758118f, 0.00187332f, -0.16966788f, -0.07418392f, 0.04533639f, 0.05367400f, 0.22804260f, 
    0.05312119f, 0.07983976f, -0.00662829f, -0.03765228f, 0.05856962f, -0.04371166f, 0.00625123f, 0.20861381f, 
    -0.09056615f, -0.12221301f, -0.03096254f, 0.08969626f, 0.13021809f, 0.07603560f, 0.14296821f, -0.15866625f, 
    -0.03561150f, 0.25095338f, 0.14295070f, 0.13515247f, -0.16361369f, 0.20232502f, 0.16720632f, -0.15481035f, 
    0.05950087f, -0.10747238f, -0.14565158f, -0.04863479f, -0.13824092f, 0.08400558f, -0.12547608f, 0.20003124f, 
    -0.24930821f, -0.09004915f, -0.06668533f, 0.17722724f, -0.04434279f, 0.09100267f, 0.17831239f, -0.26785174f, 
    0.13810736f, -0.11358726f, -0.15815076f, 0.35259572f, 0.00712621f, 0.08193298f, 0.13733092f, -0.07251032f, 
    0.02449628f, 0.04540882f, -0.11969469f, 0.00989146f, -0.01100925f, -0.38779861f, -0.02842680f, 0.20380081f, 
    -0.05698613f, 0.08767203f, 0.13843577f, 0.05280813f, -0.04031061f, 0.04615877f, 0.16317637f, -0.16733281f, 
    0.18961319f, 0.21964461f, 0.21520849f, 0.36067620f, -0.12143146f, -0.00843413f, -0.06065586f, 0.02543378f, 
    0.24515782f, 0.13747491f, 0.02341877f, 0.19700448f, 0.18651114f, -0.22565135f, 0.07093405f, -0.06551218f, 
    0.02873283f, 0.10117826f, 0.16936253f, -0.06617074f, 0.08937731f, -0.09237286f, -0.03799230f, 0.01341172f, 
    -0.16532867f, -0.16367622f, -0.08948573f, 0.19885662f, -0.04042327f, -0.22814381f, 0.21510041f, 0.02349750f, 
    0.09359994f, -0.02918657f, -0.01996231f, 0.24587770f, 0.60620016f, -0.25713336f, -0.05672792f, 0.01482742f, 
    0.04451437f, -0.06011370f, 0.13129598f, 0.21653265f, -0.21245115f, -0.03368025f, 0.16990426f, 0.05684970f, 
    0.14874981f, -0.13421775f, -0.23435359f, 0.20985374f, 0.17012669f, 0.05942275f, 0.11161230f, 0.04283464f, 
    -0.04848289f, 0.20486711f, -0.11672088f, -0.17686670f, -0.04427258f, -0.14359553f, -0.03315818f, 0.13969013f, 
    0.01011816f, -0.23092270f, -0.00546674f, -0.39385957f, -0.08628329f, -0.07726864f, 0.15069555f, 0.05919970f, 
    -0.09566954f, -0.02192459f, -0.06281083f, -0.10261288f, -0.14520492f, -0.06101698f, 0.10235637f, 0.01471541f, 
    -0.08421353f, -0.07495855f, 0.12329571f, 0.02564245f, -0.51131380f, 0.00671475f, 0.12028627f, -0.13247681f, 
    0.23274513f, 0.02212172f, 0.03235866f, -0.07575668f, 0.07709295f, 0.37201986f, -0.11770270f, 0.23885462f, 
    -0.26888114f, -0.41686681f, 0.15630162f, 0.19179861f, 0.22369798f, 0.11782897f, -0.00054809f, 0.00636439f, 
    0.31623387f, 0.12920316f, 0.04465194f, -0.05917071f, 0.20784292f, 0.08882250f, 0.20294064f, 0.00611198f, 
    0.08441544f, 0.31749222f, -0.03798376f, 0.26454383f, 0.28375223f, 0.10016517f, 0.03987071f, 0.09879004f, 
    -0.28809252f, 0.33676669f, 0.17317566f, 0.23312715f, -0.05984496f, 0.08209525f, -0.06711441f, 0.02028573f, 
    0.12349311f, 0.11764158f, 0.08979026f, 0.12387523f, -0.39533681f, -0.06300037f, 0.05054308f, 0.16683783f, 
    0.02414019f, 0.01219594f, -0.13435596f, -0.01845678f, 0.08238228f, 0.23145026f, 0.00536634f, 0.09768648f, 
    0.33800414f, -0.27933756f, 0.28214362f, -0.13633370f, -0.14201547f, -0.17577012f, -0.05465880f, 0.15960214f, 
    0.02416590f, 0.14098746f, 0.17307626f, 0.01549308f, -0.04060112f, -0.37365091f, -0.30115893f, -0.40001193f, 
    -0.23515430f, -0.03235843f, -0.20532791f, -0.06039655f, -0.06249799f, -0.13769343f, 0.14637269f, 0.08999708f, 
    0.26364610f, -0.15225130f, -0.12298217f, 0.28248519f, 0.15767461f, 0.10242265f, -0.13763171f, -0.20262174f, 
    0.11876129f, -0.07094564f, 0.00231969f, 0.16016196f, 0.20059372f, 0.20769763f, -0.30890590f, 0.49639907f, 
    0.01728853f, 0.17654100f, -0.04931902f, -0.03830414f, 0.03995191f, -0.05622316f, 0.15620543f, -0.09218752f, 
    0.13472068f, 0.18806264f, 0.04957923f, 0.06949396f, -0.05493763f, -0.07074676f, -0.09794141f, -0.09191903f, 
    0.19185843f, 0.14973682f, 0.05644079f, 0.42316058f, 0.27442679f, 0.30010712f, -0.07387409f, -0.14534488f, 
    0.01931582f, -0.04129374f, 0.11868203f, 0.21928521f, -0.00006738f, 0.08555428f, -0.07562474f, 0.21017592f, 
    -0.43213058f, -0.05504315f, 0.04951041f, -0.15855943f, -0.13482885f, -0.11032339f, 0.15044427f, -0.01464697f, 
    0.14835243f, -0.04077091f, 0.04342659f, 0.13820796f, -0.09687542f, -0.13443932f, -0.18454741f, 0.37651923f, 
    0.13096930f, -0.14626454f, 0.03588440f, -0.14778866f, 0.10836371f, -0.11992563f, 0.10680576f, -0.01732514f, 
    -0.14051126f, -0.01642907f, -0.11315838f, -0.03362378f, 0.14180155f, 0.08498818f, 0.08386498f, -0.01878354f, 
    -0.14289059f, 0.03214685f, 0.06539007f, 0.07931459f, -0.38008446f, -0.02050989f, -0.02612457f, -0.08814076f, 
    -0.23376052f, -0.04083570f, -0.08490076f, 0.09435254f, 0.05337334f, -0.04208631f, -0.00825696f, 0.22161062f, 
    -0.02408665f, 0.04319011f, -0.03091440f, -0.02128961f, -0.03650529f, -0.01396376f, -0.01533140f, 0.04739635f, 
    -0.05032452f, -0.03385003f, -0.06958854f, -0.02417522f, 0.03736246f, -0.01274797f, 0.03875820f, 0.05275653f, 
    0.01135378f, -0.00213109f, 0.05391746f, -0.03591471f, 0.02967525f, 0.04722823f, 0.01034447f, -0.05522449f, 
    -0.05209184f, 0.05743629f, -0.03813177f, 0.01731441f, 0.04153332f, 0.02401563f, -0.02315469f, -0.00481777f, 
    -0.03807274f, -0.06892845f, 0.05406754f, 0.04368969f, 0.00384018f, 0.00026016f, -0.06902255f, 0.04330586f, 
    -0.03821916f, -0.06277584f, 0.00300138f, -0.06239945f, -0.02639093f, -0.06913240f, -0.06014797f, 0.02429890f, 
    0.01774072f, 0.05990089f, -0.03060647f, 0.01646636f, -0.07615019f, 0.00149820f, 0.04759822f, -0.05647020f, 
    -0.07110950f, -0.04050563f, -0.00385623f, -0.04349589f, 0.01140920f, 0.02457012f, 0.03871120f, 0.04183564f, 
    -0.04161493f, 0.00658700f, -0.06085499f, -0.04452593f, -0.06214130f, 0.02690120f, 0.04729837f, 0.05234706f, 
    -0.05359468f, 0.02212736f, -0.02185420f, -0.04641774f, 0.04453776f, -0.06690643f, 0.06984758f, 0.00126927f, 
    0.00584369f, 0.00965752f, 0.05290979f, 0.02586705f, -0.06347073f, 0.05772064f, 0.06128473f, 0.05582000f, 
    -0.00642762f, 0.03519901f, 0.00899804f, 0.05700776f, -0.03878115f, 0.05706479f, 0.02146499f, -0.07811698f, 
    -0.06041103f, -0.00257223f, -0.01843334f, 0.00044486f, 0.05379609f, 0.01804004f, -0.05139396f, 0.01398613f, 
    -0.02591612f, -0.03544699f, -0.06600223f, -0.02301744f, 0.00083232f, -0.04706707f, -0.02177525f, -0.06879020f, 
    -0.05301774f, -0.01303047f, -0.02982182f, -0.03200057f, -0.00418659f, -0.04623748f, 0.03311472f, -0.03573257f, 
    0.01216883f, -0.06241979f, 0.06156690f, -0.00185720f, -0.04664239f, -0.03356811f, -0.01193037f, -0.06415928f, 
    -0.00487327f, -0.06256259f, -0.02500786f, 0.00913622f, -0.04784061f, 0.03522661f, -0.02930908f, 0.04779464f, 
    0.05154554f, 0.01591645f, -0.00650449f, -0.06417140f, -0.00937362f, 0.04228790f, 0.00446891f, 0.03072381f, 
    0.01312415f, -0.06070199f, -0.00294888f, -0.04405956f, -0.02730418f, -0.04457416f, -0.06716798f, -0.04837498f, 
    -0.01713596f, -0.07739719f, -0.02533886f, 0.02701564f, 0.05872997f, 0.04710466f, 0.05540292f, 0.02086534f, 
    -0.07370572f, -0.01066769f, 0.00827499f, -0.07247043f, -0.06804516f, -0.03772620f, -0.05530951f, 0.02863126f, 
    0.02026492f, -0.05844817f, 0.03170099f, -0.01097473f, 0.04401558f, -0.01281325f, -0.01389092f, 0.00118634f, 
    -0.07643373f, -0.04052543f, 0.04977417f, 0.02744197f, -0.03000488f, 0.02476737f, -0.01614812f, 0.00120617f, 
    -0.07456964f, 0.05646759f, -0.03926027f, -0.01756607f, -0.05197184f, -0.03092202f, 0.03177818f, 0.01378415f, 
    0.25246841f, 0.20809527f, 0.23023884f, 0.16219972f, -0.20842811f, 0.06063652f, -0.07630518f, -0.07041734f, 
    -0.05225531f, 0.02973062f, 0.01146356f, 0.14892121f, -0.04915077f, 0.23699121f, 0.10706259f, 0.47171849f, 
    -0.03147849f, -0.00549299f, 0.04124513f, -0.09613539f, -0.09673513f, 0.02114135f, 0.01094973f, 0.13353407f, 
    0.15118545f, 0.38674617f, 0.33999744f, 0.07481772f, -0.14668982f, 0.01724336f, -0.07084130f, 0.18294737f, 
    -0.02400599f, -0.18341291f, 0.11900150f, 0.11806467f, 0.23806062f, 0.08619270f, 0.29560554f, 0.11383042f, 
    -0.16021819f, 0.12641363f, 0.17330848f, -0.10641974f, 0.05737227f, 0.00291262f, 0.10700899f, 0.35333037f, 
    0.29367521f, 0.19808601f, 0.11716989f, -0.15884571f, 0.18398528f, 0.18488495f, 0.08560594f, -0.01537378f, 
    0.12968251f, 0.20708595f, 0.20263632f, -0.06067151f, 0.11621512f, -0.06833430f, 0.24656518f, -0.13179253f, 
    -0.01541529f, -0.03144644f, 0.18803716f, 0.19404720f, 0.06063042f, -0.02363966f, -0.00520937f, 0.07951769f, 
    -0.13639414f, 0.20043930f, 0.17185508f, -0.05220527f, 0.21004106f, -0.11878230f, -0.04169166f, 0.02150692f, 
    0.16766638f, 0.08779029f, 0.02007101f, 0.00537496f, -0.39307746f, 0.11222343f, -0.33452421f, -0.42874390f, 
    0.07305454f, 0.09317365f, 0.06280906f, -0.06645120f, 0.14735478f, -0.03315908f, -0.25839609f, 0.11999967f, 
    -0.49420640f, 0.03636435f, 0.14109749f, -0.06677214f, -0.02382493f, -0.05821689f, -0.24061394f, -0.03391000f, 
    0.07535100f, -0.04473343f, 0.00859467f, 0.07806989f, 0.02472079f, 0.26112601f, -0.10661141f, -0.15046778f, 
    0.03464615f, -0.02250209f, 0.12166252f, -0.03851487f, 0.11592080f, 0.01918167f, 0.10895562f, 0.12971577f, 
    -0.54876572f, -0.35444397f, -0.07352588f, 0.02414561f, 0.27951524f, -0.17545255f, 0.00418261f, 0.10737986f, 
    -0.09877159f, 0.02496967f, 0.10656571f, -0.09262922f, -0.44250819f, 0.29517603f, 0.28638926f, 0.00547322f, 
    -0.09491823f, 0.12217078f, -0.03199348f, 0.00584902f, -0.02305470f, 0.01758055f, 0.11014330f, 0.06298392f, 
    -0.05917379f, 0.25415978f, -0.17987202f, -0.14693363f, 0.27344412f, 0.01702789f, -0.06888941f, 0.06850114f, 
    -0.03951250f, -0.05473923f, 0.18651317f, 0.00114409f, -0.63443619f, 0.21562877f, -0.12581243f, -0.10054145f, 
    0.28134137f, 0.09739538f, -0.03167087f, -0.05052821f, 0.06931282f, 0.10225583f, -0.05219028f, -0.00607999f, 
    0.03465382f, -0.39608741f, -0.06408110f, -0.39952895f, -0.19597669f, 0.19879146f, -0.00632894f, -0.02255040f, 
    0.10678596f, -0.00081083f, 0.22134021f, -0.06080706f, -0.28768516f, -0.11569326f, -0.28222799f, -0.38029620f, 
    0.20013621f, -0.00885039f, 0.27134964f, -0.03392240f, 0.08055966f, -0.09508452f, 0.04682948f, -0.07776402f, 
    -0.24686441f, 0.18696550f, -0.00779193f, 0.01756402f, -0.33517620f, 0.04368668f, -0.16160055f, -0.10879330f, 
    -0.02764239f, -0.00877200f, -0.07715824f, -0.08635484f, -0.24280086f, -0.11594787f, -0.27300903f, 0.37771291f, 
    -0.03096167f, -0.15672053f, 0.08383247f, -0.07677715f, -0.15372691f, 0.00274156f, -0.11220349f, 0.10497536f, 
    -0.16063321f, 0.21038036f, -0.10021634f, -0.00670774f, 0.09488129f, 0.03121953f, -0.19943731f, 0.30425188f, 
    -0.15526395f, 0.02520650f, 0.01042132f, 0.13787407f, 0.38427082f, 0.06072591f, 0.06306656f, -0.17386359f, 
    0.09101033f, 0.04553574f, 0.02498793f, -0.08274966f, 0.08377304f, -0.07957692f, -0.08331741f, 0.01334264f, 
    -0.17353803f, -0.03431551f, -0.15819776f, -0.12048095f, 0.06734798f, -0.02405499f, 0.11337098f, -0.02131320f, 
    -0.07168645f, -0.01046385f, 0.13014345f, -0.05805191f, -0.33615446f, -0.12899004f, -0.06653725f, -0.19014832f, 
    -0.08286256f, -0.07630311f, -0.02976999f, 0.12810023f, -0.00780707f, 0.12435457f, 0.23696330f, 0.14545073f, 
    0.01937423f, 0.30427819f, -0.02659595f, 0.40145472f, 0.22325470f, -0.26135528f, 0.03517194f, 0.09527829f, 
    0.13674966f, 0.06644867f, -0.00913831f, 0.01304320f, 0.16360386f, 0.07785740f, 0.08332852f, -0.50836194f, 
    0.12238221f, 0.08394741f, 0.00399972f, -0.14228329f, 0.04388119f, -0.07033198f, -0.10773709f, 0.08527996f, 
    0.03250450f, 0.12893455f, 0.01440204f, -0.05730426f, 0.06380285f, 0.09187379f, -0.11928465f, 0.25882348f, 
    0.17620613f, -0.08164171f, 0.03385349f, 0.16080482f, -0.72300231f, 0.31878576f, -0.05579204f, -0.04228732f, 
    0.14954001f, -0.00499978f, 0.01367630f, -0.00910036f, 0.06340627f, -0.09082595f, -0.07187677f, -0.05707567f, 
    -0.13384892f, 0.17353572f, -0.09506675f, -0.02706047f, 0.17509009f, -0.07334433f, -0.03002708f, -0.07510569f, 
    -0.19422305f, -0.01024551f, 0.02850714f, 0.02357964f, -0.30896834f, 0.16812479f, -0.01312161f, 0.43141177f, 
    0.06129664f, -0.09500570f, 0.17397469f, 0.17834482f, -0.05809432f, 0.10733256f, -0.08678591f, 0.00266733f, 
    0.18548562f, 0.34312212f, 0.05893964f, -0.34305564f, 0.02691687f, 0.04429216f, 0.07959169f, -0.06193474f, 
    0.04420280f, 0.13537827f, -0.05936666f, 0.24683717f, 0.19224463f, 0.11658085f, 0.13170183f, 0.04290693f, 
    -0.18468538f, 0.16040726f, -0.01265710f, -0.06550132f, 0.14713456f, 0.03405470f, 0.14668167f, 0.01002313f, 
    0.71663737f, 0.26838121f, 0.00679057f, -0.18257263f, 0.00562911f, 0.08000756f, -0.01788306f, 0.09377170f, 
    -0.08443537f, -0.03362912f, 0.06390995f, 0.08464944f, 0.18162793f, 0.14842908f, -0.01333303f, -0.06907134f, 
    0.09700759f, 0.16437444f, 0.01774559f, -0.12154782f, 0.02346098f, 0.07052563f, -0.14413455f, -0.16974621f, 
    0.36159602f, -0.10251322f, -0.05156411f, 0.60252106f, 0.02263820f, 0.11816244f, -0.15254989f, 0.06855284f, 
    0.02692719f, 0.20111425f, 0.09604490f, -0.03867095f, 0.70742834f, -0.05995549f, 0.18247598f, 0.26459306f, 
    -0.14979418f, -0.02093297f, -0.11960522f, 0.04112982f, 0.15933856f, -0.26712254f, 0.05989047f, -0.18083115f, 
    0.58579278f, -0.16757889f, -0.08334725f, -0.02320611f, -0.05037311f, -0.12801921f, 0.04991921f, -0.01645308f, 
    0.15576109f, 0.05983488f, -0.08214972f, 0.07806178f, -0.40862414f, -0.08153080f, 0.06453931f, -0.10267878f, 
    -0.02726951f, -0.18261196f, -0.00189326f, -0.04458061f, 0.10659582f, 0.04100287f, -0.05312103f, -0.15852371f, 
    0.18315902f, -0.16501501f, -0.09900884f, 0.03643382f, -0.04234183f, -0.03451853f, -0.19489297f, 0.08938317f, 
    0.09479963f, 0.08468156f, -0.07333728f, -0.02333123f, 0.58902782f, 0.01369516f, 0.14341560f, -0.00686726f, 
    0.06249848f, -0.09363022f, -0.06257559f, -0.02080485f, -0.00456261f, -0.13426730f, -0.08349134f, 0.04258918f, 
    -0.18512760f, 0.03961246f, -0.03917998f, -0.11145583f, 0.03607235f, 0.26444343f, 0.00106255f, -0.09807590f, 
    0.07170174f, -0.05924986f, -0.09147157f, 0.11639247f, -0.09051664f, 0.24224034f, 0.16492899f, 0.13925190f, 
    -0.01124147f, 0.19059774f, 0.10521765f, 0.11365214f, 0.10945918f, 0.13510834f, -0.01469867f, -0.01487389f, 
    0.07379302f, -0.19594306f, 0.02273575f, -0.24907254f, -0.02714266f, -0.02830265f, -0.12686424f, 0.22252162f, 
    -0.05207197f, 0.00377600f, -0.06379357f, -0.01501400f, 0.26378632f, 0.03936690f, 0.23555698f, -0.48785511f, 
    -0.11479314f, 0.03811618f, -0.10122472f, -0.00739480f, -0.08505291f, 0.09519398f, 0.02009319f, 0.21480310f, 
    -0.13593447f, -0.12539253f, 0.15366836f, -0.07255188f, -0.10695719f, 0.14530705f, 0.06397489f, 0.19061810f, 
    0.05295591f, 0.00471440f, -0.04295947f, -0.11104165f, 0.22536011f, 0.14753570f, -0.04579575f, -0.20045011f, 
    -0.05154073f, 0.11137083f, -0.06545594f, -0.24654873f, -0.03218594f, 0.01258204f, 0.12592672f, -0.10286380f, 
    0.00800290f, 0.07016160f, 0.01491402f, 0.02579789f, 0.13821845f, -0.01609141f, -0.04313193f, 0.05892381f, 
    0.07155600f, -0.07445602f, -0.06666154f, -0.10088570f, -0.27805576f, 0.40282974f, -0.15242863f, -0.03021151f, 
    0.03894478f, 0.17229815f, -0.00480159f, -0.04459881f, -0.06779538f, 0.15977606f, -0.01877998f, 0.22394799f, 
    0.08468501f, 0.08159602f, 0.27435541f, -0.13076226f, 0.04837431f, -0.06986414f, 0.04074411f, -0.08538420f, 
    0.11125100f, 0.03832322f, -0.09070630f, 0.07825448f, 0.25879902f, -0.06021921f, 0.01762529f, -0.43296516f, 
    0.04014832f, -0.05265939f, 0.00138802f, 0.03001566f, -0.12303525f, 0.03524086f, 0.13018048f, 0.02286438f, 
    -0.14466898f, 0.01361361f, 0.13380870f, -0.18842731f, 0.00271971f, 0.00722771f, 0.14772043f, -0.03573100f, 
    0.04446679f, -0.00040849f, -0.09661110f, -0.01413974f, 0.22753310f, -0.12460623f, 0.02205135f, -0.08950391f, 
    0.01514641f, 0.12261262f, -0.17130588f, 0.03405171f, 0.11715943f, -0.00154514f, 0.05444236f, 0.01519481f, 
    0.27546462f, -0.11777020f, -0.19484575f, 0.14239904f, -0.34651184f, -0.05303691f, -0.10843558f, 0.00329239f, 
    0.15039144f, -0.06252291f, 0.02331695f, -0.12114596f, 0.04270603f, -0.04110462f, 0.22245015f, 0.64794040f, 
    -0.09596846f, 0.05821456f, 0.04480318f, 0.05432314f, 0.02082437f, -0.14153270f, -0.06326666f, -0.03548712f, 
    -0.24863699f, 0.22911917f, 0.21661262f, -0.23208062f, -0.06434704f, 0.03120993f, 0.03353962f, 0.03174751f, 
    -0.07440197f, 0.02667921f, 0.15455481f, 0.08235713f, 0.08042089f, -0.17853257f, -0.05431326f, -0.10284272f, 
    -0.07700109f, -0.07231340f, -0.11251552f, 0.08641877f, 0.17122450f, 0.03820862f, 0.09004412f, 0.01710233f, 
    0.09522010f, 0.15151367f, 0.08072072f, 0.04627393f, -0.14212205f, 0.16183271f, 0.19333605f, 0.24726282f, 
    0.19257586f, -0.11566206f, -0.12087425f, 0.12389269f, 0.08689735f, -0.22042514f, 0.02729668f, -0.07359657f, 
    0.03836699f, -0.05535845f, -0.00969572f, 0.01435886f, -0.05275744f, 0.14813931f, -0.07281788f, -0.04904276f, 
    0.47222698f, 0.65580404f, -0.12293253f, 0.06060254f, -0.13529778f, 0.17219734f, 0.11239798f, -0.21146636f, 
    -0.10064984f, 0.07429196f, 0.13197552f, 0.17165585f, -0.24081092f, -0.43180797f, 0.16934954f, 0.08703168f, 
    0.00132537f, 0.19802965f, 0.15224899f, 0.04644348f, 0.00299683f, 0.00842240f, 0.03756707f, -0.09333394f, 
    0.13603005f, 0.03200072f, 0.05384364f, 0.11930802f, -0.00834987f, 0.07031035f, -0.11989931f, 0.08448941f, 
    0.19699217f, -0.12736981f, 0.15553734f, 0.21784493f, 0.22383042f, -0.30332947f, 0.29277551f, 0.26957485f, 
    -0.05582453f, 0.03710634f, 0.12721670f, 0.09206616f, 0.02345913f, 0.16152345f, 0.02160398f, 0.01218174f, 
    -0.44172928f, 0.05375339f, -0.27040085f, 0.08569057f, 0.04121263f, -0.08930976f, 0.13672605f, 0.05293026f, 
    -0.00490239f, 0.11719911f, -0.03263848f, -0.06225321f, -0.85442328f, 0.41893545f, -0.01619018f, -0.18790834f, 
    0.04947959f, -0.06754947f, 0.11694861f, 0.10155805f, -0.14718787f, -0.02144506f, -0.05364067f, 0.01715824f, 
    0.05663175f, -0.13675812f, 0.16252770f, 0.14859585f, -0.06629318f, 0.14606878f, -0.07924482f, -0.06755858f, 
    0.11526415f, 0.01253471f, -0.13202582f, 0.07574704f, 0.16734490f, -0.04479079f, -0.24176322f, 0.28476450f, 
    0.04295213f, 0.07809127f, 0.11222796f, -0.11289174f, -0.10245889f, 0.28765228f, -0.08727350f, -0.01437570f, 
    0.70109135f, 0.06840301f, 0.40084511f, 0.36372486f, -0.13565758f, 0.09365330f, -0.03915435f, -0.01326061f, 
    -0.06369824f, 0.02226639f, -0.00090152f, 0.04426978f, 0.09473887f, -0.01089998f, 0.10923146f, 0.30613023f, 
    -0.03055824f, -0.14032196f, 0.10518746f, -0.04590047f, 0.07464840f, -0.04416155f, 0.20179331f, 0.04998300f, 
    0.04679673f, -0.17783989f, -0.18994002f, 0.30063504f, -0.28760719f, -0.11188644f, -0.08644602f, 0.12810127f, 
    0.16838966f, -0.12280605f, 0.15634015f, -0.07985859f, -0.20742646f, -0.17321721f, 0.13212353f, 0.21827911f, 
    -0.15304869f, -0.00619924f, -0.13068283f, -0.13757211f, 0.13605301f, 0.07553517f, -0.13670929f, 0.18055809f, 
    0.19324267f, 0.19472668f, 0.05386585f, -0.08142741f, -0.09890807f, -0.05273381f, 0.03471734f, -0.09010643f, 
    -0.01574779f, 0.22931476f, 0.05418034f, 0.00893687f, -0.05407619f, -0.33983627f, 0.11878607f, -0.07709688f, 
    -0.05333056f, -0.17949805f, -0.09403722f, 0.15412623f, 0.03328289f, -0.16548553f, -0.14104946f, 0.07250474f, 
    0.21451081f, 0.05530317f, 0.30130067f, -0.09113240f, 0.14948687f, -0.06415097f, 0.07568867f, 0.24482648f, 
    0.15334299f, 0.23866831f, 0.06388931f, 0.12209135f, -0.02281022f, 0.00461927f, 0.07204971f, 0.07094394f, 
    0.21618116f, 0.24564657f, 0.14000541f, 0.05209196f, 0.04780104f, 0.04401444f, -0.19610533f, 0.28437471f, 
    0.46127039f, 0.27250984f, -0.30467370f, -0.11776226f, -0.20778356f, 0.07199094f, -0.24320379f, -0.16970131f, 
    -0.19694787f, 0.08057445f, 0.01420336f, 0.10479911f, -0.26261732f, 0.08747656f, -0.13000391f, -0.42885259f, 
    0.01520127f, 0.05549299f, 0.05672730f, -0.06651394f, -0.05976765f, 0.04282562f, 0.04758874f, 0.03530240f, 
    -0.10200265f, -0.03369528f, 0.17910779f, 0.20885359f, -0.02387142f, -0.11024543f, -0.06410661f, 0.11256974f, 
    -0.08714830f, -0.19911417f, 0.19324805f, 0.12645851f, 0.07205606f, 0.14669490f, 0.12520677f, 0.16931923f, 
    -0.07016943f, 0.03276469f, 0.15656766f, 0.14102659f, -0.14477775f, 0.22868232f, -0.07476459f, 0.17371733f, 
    -0.37577102f, 0.17100908f, -0.07232586f, -0.15707991f, 0.02269560f, 0.02922598f, -0.14211033f, -0.11829928f, 
    -0.09238626f, -0.00539138f, 0.07214446f, -0.10993690f, -1.01684082f, 0.58602226f, -0.00685947f, -0.06625521f, 
    0.04588475f, 0.14667673f, -0.04104054f, 0.03988260f, -0.13192998f, 0.10875525f, -0.14836471f, 0.09966956f, 
    -0.19201636f, 0.00932014f, 0.29683059f, 0.00518085f, 0.03159807f, 0.04050878f, 0.13063106f, 0.07521245f, 
    0.23990937f, 0.07159881f, -0.08764394f, 0.12193473f, 0.28691292f, -0.16916847f, -0.19301346f, -0.12757178f, 
    0.02746960f, 0.00004349f, 0.20774879f, 0.11002681f, -0.06813075f, 0.08011070f, -0.00590805f, -0.00457318f, 
    0.44913289f, -0.16124648f, 0.22008757f, 0.03278071f, 0.16353600f, 0.04148011f, 0.04339918f, 0.04275494f, 
    0.05443205f, 0.11198342f, 0.06177752f, 0.03532584f, -0.30673426f, 0.23164293f, -0.00385231f, 0.15278770f, 
    0.03132105f, -0.07666654f, 0.13375637f, 0.11814664f, -0.02329682f, 0.08490981f, 0.14697875f, -0.00479435f, 
    0.11885635f, 0.30134207f, -0.15841170f, 0.08681062f, 0.12533057f, 0.19682114f, 0.24869390f, 0.00067804f, 
    0.03398226f, 0.10271616f, 0.22578736f, 0.08307151f, -0.14347373f, -0.16184923f, -0.36585999f, 0.07051335f, 
    0.06908360f, -0.02083705f, -0.09748753f, -0.13940810f, -0.07865132f, -0.04140492f, 0.10078709f, -0.00037252f, 
    0.10747929f, 0.38871676f, 0.05613838f, 0.15235686f, 0.10326282f, -0.02996225f, 0.10067113f, -0.05073494f, 
    -0.05268484f, 0.00142392f, -0.22879013f, -0.04265061f, 0.23305427f, 0.11553001f, -0.06685665f, 0.32559180f, 
    0.11044473f, -0.00162929f, 0.22892782f, -0.00982090f, -0.16288191f, -0.18935990f, -0.07425142f, 0.09678341f, 
    -0.25530493f, 0.01281637f, -0.12823504f, -0.22979383f, 0.10779731f, 0.12558830f, -0.14590876f, -0.20892772f, 
    -0.04427313f, 0.07281347f, 0.12645070f, -0.00010615f, -0.20514420f, 0.22431360f, 0.12941208f, 0.41971028f, 
    -0.12947670f, -0.12831421f, 0.08029994f, 0.05257377f, 0.03125765f, -0.14578412f, 0.06500241f, 0.08070704f, 
    0.06394976f, 0.07736408f, -0.44291338f, 0.11794603f, 0.18298720f, 0.01921613f, 0.18704192f, -0.06441355f, 
    0.03590995f, 0.17107379f, 0.00672479f, -0.26629889f, 0.55953872f, 0.50198454f, -0.50198567f, -0.01216091f, 
    -0.13525979f, -0.03551945f, -0.04995046f, -0.04147470f, -0.14998418f, -0.00161857f, -0.00823067f, -0.00551738f, 
    -0.02545318f, 0.03235190f, -0.04709890f, -0.15475616f, -0.10080470f, -0.04114245f, 0.01402397f, 0.03338195f, 
    0.04195583f, 0.05420893f, -0.00757722f, -0.13976856f, 0.18440267f, -0.17379723f, -0.26751730f, 0.14069819f, 
    0.15428486f, 0.00438416f, -0.06251670f, 0.04483317f, 0.22248778f, -0.13768907f, -0.11481681f, 0.01955843f, 
    0.14454012f, -0.16036740f, 0.07942846f, 0.09547671f, 0.02237652f, 0.07784420f, -0.05129658f, -0.16015299f, 
    0.09003829f, -0.28685424f, 0.04238490f, 0.06504556f, 0.66127491f, -0.25751725f, 0.22656003f, 0.06583575f, 
    -0.07631543f, 0.08821143f, -0.03458477f, -0.08896166f, -0.01600269f, -0.04498760f, 0.04179515f, 0.00062988f, 
    0.02064605f, 0.15066217f, -0.43923500f, -0.03956906f, 0.00871692f, -0.04319125f, -0.03080676f, 0.01177245f, 
    -0.05829462f, 0.04333237f, -0.05583477f, 0.06864735f, -0.06012577f, 0.01092716f, -0.09108242f, -0.10900127f, 
    0.13843241f, -0.17469864f, -0.11321735f, 0.04608352f, 0.19436406f, -0.04022482f, 0.07971024f, -0.02778009f, 
    -0.05218564f, 0.00636327f, -0.18844131f, 0.47610906f, 0.14785185f, 0.08056446f, 0.13560922f, 0.09744135f, 
    -0.05061102f, 0.16516353f, 0.10758752f, -0.05552574f, 0.43751448f, -0.05231291f, -0.04100860f, 0.29043290f, 
    -0.15842775f, -0.00536577f, 0.02831824f, 0.18712226f, -0.07277763f, -0.12566908f, 0.09177079f, -0.14031696f, 
    0.37753251f, 0.10204162f, 0.13024247f, -0.30764988f, 0.15682681f, 0.07269374f, 0.12053584f, 0.00702720f, 
    -0.17057711f, -0.02228810f, -0.16516392f, -0.01452764f, -0.11363815f, 0.11081289f, -0.02026200f, -0.23880780f, 
    0.15532292f, 0.00384621f, -0.01245214f, -0.15338917f, 0.01626784f, -0.16037937f, -0.16283029f, -0.26748106f, 
    0.25261158f, -0.24700275f, -0.14895473f, 0.25119159f, 0.07581073f, -0.03251632f, 0.02068538f, 0.15942349f, 
    -0.00631350f, -0.08031859f, 0.02313656f, 0.03768715f, 0.57001102f, 0.35216385f, 0.13291532f, -0.09323253f, 
    0.05936799f, 0.03125821f, -0.06421311f, 0.02325417f, -0.06575870f, 0.05918616f, 0.14688317f, -0.07105453f, 
    -0.18307008f, 0.15943937f, -0.34694237f, -0.09857415f, -0.06303319f, 0.28765035f, 0.06861223f, 0.03363540f, 
    0.13816790f, -0.13648196f, -0.07026783f, 0.14080302f, 0.11935101f, -0.12328655f, -0.02093002f, -0.03330820f, 
    -0.04140541f, -0.19688521f, -0.17154796f, 0.15743925f, -0.04483293f, 0.09812835f, 0.07899213f, -0.04730449f, 
    -0.10553311f, -0.12663750f, 0.24654959f, -0.25447753f, 0.07832036f, -0.05880227f, 0.15923312f, 0.31169370f, 
    0.07561730f, -0.05386585f, 0.07641840f, -0.03852782f, 0.39378682f, 0.12023669f, 0.25090575f, -0.13952762f, 
    -0.07930594f, -0.03024247f, 0.13095939f, 0.07882453f, -0.03950265f, 0.00795440f, 0.02446370f, 0.03708446f, 
    -0.25187838f, -0.14053984f, -0.07314218f, -0.40049705f, -0.04721775f, 0.13948734f, 0.08161676f, 0.15766387f, 
    0.08835044f, 0.17160821f, -0.06065775f, 0.10097738f, 0.27807742f, 0.21541879f, 0.03946670f, -0.18912081f, 
    -0.03691051f, -0.01843907f, 0.05179303f, -0.10331271f, 0.10386375f, -0.00292247f, 0.12875812f, -0.20971230f, 
    0.24453905f, -0.02839738f, 0.02192814f, 0.02939243f, 0.04843161f, -0.03403577f, 0.16356471f, 0.13509217f, 
    -0.09308812f, 0.15036917f, -0.13185346f, 0.21105339f, 0.55347520f, -0.30970931f, 0.00860268f, 0.19751649f, 
    -0.05122657f, 0.09007173f, -0.07369281f, -0.07474008f, 0.09124767f, -0.00420823f, 0.06183157f, 0.21989138f, 
    0.06878226f, -0.01013700f, 0.10788635f, -0.15777099f, -0.05395388f, -0.06108631f, -0.04348303f, 0.06326648f, 
    0.00878348f, -0.14790885f, -0.14724462f, 0.15149334f, -0.07319093f, 0.05845015f, 0.14195256f, -0.06307943f, 
    -0.01267568f, -0.17072706f, -0.04694070f, 0.02959984f, 0.02102682f, 0.17562640f, 0.10905859f, 0.06801949f, 
    0.20399192f, 0.14558193f, 0.12037238f, 0.13413933f, -0.11008064f, 0.11368249f, -0.08789282f, 0.04871186f, 
    0.10998470f, 0.04202175f, -0.00279480f, 0.11556114f, -0.44830045f, 0.15838362f, -0.19826126f, 0.30370796f, 
    -0.18933214f, -0.05319471f, 0.14872831f, 0.10580572f, -0.05090066f, 0.04138684f, -0.03763227f, 0.03909717f, 
    -0.04758659f, 0.42188567f, 0.26586479f, -0.10954386f, 0.12397670f, -0.02574568f, 0.08789017f, 0.17663573f, 
    -0.17616148f, 0.08080009f, -0.01322561f, 0.15509301f, 0.27742675f, -0.08935376f, -0.18668273f, -0.27684325f, 
    0.00104198f, -0.13583626f, 0.07525129f, -0.02446272f, -0.07083037f, 0.19734371f, 0.19626454f, 0.21859665f, 
    0.27237499f, 0.10863186f, 0.03576467f, -0.09174205f, 0.11920584f, 0.09000096f, 0.04977311f, -0.04515822f, 
    0.06591283f, -0.05905170f, -0.10001972f, -0.06304893f, 0.10124843f, -0.03300009f, 0.14906797f, 0.16012406f, 
    0.01654790f, -0.09369592f, 0.25887689f, -0.09233738f, -0.01299960f, -0.12036185f, -0.11242816f, 0.07429186f, 
    -0.32059819f, 0.17629151f, 0.12499548f, 0.18218489f, 0.18373229f, 0.01272653f, -0.16765569f, -0.32916695f, 
    0.01102094f, 0.03181295f, -0.02044425f, 0.00603954f, -0.05650070f, 0.30055988f, -0.18123007f, -0.00782063f, 
    0.02099862f, 0.02934498f, 0.03928683f, 0.08169027f, 0.16262843f, 0.02881192f, -0.06549328f, -0.07890347f, 
    -0.19077031f, -0.49246359f, 0.14315885f, -0.01116790f, -0.10215332f, -0.01331200f, 0.02392149f, 0.06406191f, 
    -0.08568156f, -0.05734756f, -0.20320848f, -0.05606518f, 0.33411571f, 0.13146985f, -0.08162040f, -0.21568556f, 
    -0.03484529f, -0.15333328f, -0.07599793f, -0.17812343f, 0.03832859f, 0.01261501f, -0.00795654f, 0.18615778f, 
    -0.14031801f, -0.04469039f, 0.04385511f, 0.18387823f, 0.16491945f, -0.14108527f, -0.04616942f, 0.07080213f, 
    -0.21666913f, 0.12257591f, 0.11210614f, -0.24616897f, -0.54561722f, 0.06659551f, -0.07244813f, 0.11973988f, 
    0.04526518f, 0.08503715f, -0.23614293f, -0.04506643f, 0.13114950f, -0.13829027f, 0.00337362f, -0.04667481f, 
    0.51077503f, 0.16942060f, -0.06500261f, -0.12424697f, 0.16955632f, 0.12697922f, -0.12622067f, -0.08363993f, 
    0.11446734f, -0.21037371f, 0.14116411f, -0.08207089f, 0.56344175f, -0.02058483f, 0.00428758f, -0.04735244f, 
    0.09295886f, 0.11653735f, -0.05587078f, 0.08109512f, 0.07897513f, 0.13750035f, 0.00350828f, -0.13302468f, 
    -0.13896340f, 0.03735828f, -0.15570378f, -0.16618651f, -0.02458499f, -0.04488433f, -0.02675701f, 0.09340818f, 
    0.20623639f, 0.11255220f, 0.18290102f, -0.02977935f, 0.08368842f, -0.21303767f, 0.10725117f, -0.31021848f, 
    0.12224672f, -0.00234837f, -0.03886027f, 0.04176370f, 0.26899043f, -0.11923879f, 0.09292381f, -0.13168593f, 
    -0.03169316f, -0.05823318f, -0.04849620f, -0.05346859f, -0.06999040f, -0.07592117f, -0.02682640f, -0.04823184f, 
    0.03921498f, 0.02483574f, 0.01302612f, -0.01176254f, 0.03943689f, -0.02015388f, 0.04854689f, 0.05962569f, 
    0.03673500f, -0.09715196f, 0.04657190f, -0.01824438f, -0.03667489f, -0.02711436f, -0.03426980f, 0.03154568f, 
    0.00756233f, -0.01391729f, 0.02489797f, 0.02177455f, 0.06070385f, -0.04531943f, -0.01196053f, -0.06660630f, 
    -0.04155434f, -0.04323467f, -0.00478766f, -0.07750955f, -0.07505189f, 0.00556241f, 0.02300575f, -0.06112975f, 
    0.04661617f, -0.01885249f, 0.04783784f, 0.01515623f, 0.03318160f, -0.02421324f, -0.01280947f, 0.06113534f, 
    -0.04434888f, -0.07488655f, -0.06415300f, 0.02455763f, -0.04921072f, -0.03899300f, 0.02226597f, 0.02857373f, 
    0.04957698f, 0.03754232f, 0.03845431f, 0.05563582f, 0.04063411f, 0.04338016f, 0.04527536f, 0.05322535f, 
    0.05212824f, -0.06772278f, 0.01702533f, 0.01127504f, -0.02072413f, -0.05968917f, -0.07515161f, -0.00995989f, 
    0.03913827f, -0.06074855f, -0.03280275f, -0.07091519f, -0.04327563f, 0.06031648f, -0.06564186f, -0.01596656f, 
    0.01498783f, -0.00721043f, 0.02347260f, 0.00447494f, -0.08460563f, -0.02388089f, 0.05929740f, -0.05621055f, 
    0.04808591f, 0.00142096f, -0.01639524f, -0.07863346f, -0.06941026f, -0.01237088f, -0.02637894f, -0.04158566f, 
    -0.02894437f, 0.01380784f, 0.05749021f, -0.07160836f, -0.01958589f, -0.02237318f, -0.06180711f, 0.01664594f, 
    -0.05588266f, 0.04325272f, 0.05027747f, -0.04930308f, -0.01253591f, 0.01319680f, -0.00982154f, -0.00229735f, 
    -0.05112568f, -0.07348498f, -0.00480693f, -0.04137453f, -0.02156303f, -0.04421145f, 0.06571830f, 0.04512372f, 
    0.05295763f, 0.06176927f, -0.04366747f, -0.03082359f, -0.06332116f, 0.02786448f, 0.03902276f, -0.05608050f, 
    -0.06805187f, -0.02961922f, -0.01844360f, -0.08429026f, -0.02511319f, 0.04631419f, 0.01335378f, -0.00959471f, 
    0.03794260f, -0.00883267f, 0.04604499f, -0.07759392f, 0.02852536f, 0.03479098f, -0.01411983f, 0.01857461f, 
    -0.06979220f, 0.00032440f, -0.06213041f, -0.00318363f, -0.02075148f, 0.02288277f, 0.05404757f, -0.08159814f, 
    0.04417784f, -0.02289532f, 0.03750792f, -0.00878190f, -0.01904762f, -0.00564556f, -0.00067024f, -0.03707493f, 
    0.06344973f, 0.02859134f, -0.03676685f, -0.00227083f, -0.03231419f, -0.07760203f, -0.02976129f, -0.00198783f, 
    -0.05262248f, -0.07547593f, -0.03273688f, -0.06715313f, -0.02686093f, -0.08155425f, 0.02672318f, -0.04608779f, 
    -0.01436446f, -0.04651999f, 0.04510543f, -0.05577763f, 0.04587384f, -0.06595076f, 0.02699374f, -0.01703970f, 
    -0.03210035f, 0.01600194f, -0.06966126f, -0.00616849f, 0.00723023f, -0.07914332f, 0.03511500f, -0.00967583f, 
    -0.01308575f, -0.06544045f, -0.04430665f, 0.03575080f, 0.04527802f, 0.01848830f, -0.00149753f, -0.07783309f, 
    -0.08257517f, 0.00940735f, 0.06884823f, -0.06911104f, -0.00427813f, 0.05082667f, -0.07440999f, -0.04424934f, 
    -0.03140930f, -0.04744239f, -0.03463264f, 0.02534169f, -0.05722761f, -0.02739877f, 0.01997900f, -0.04101139f, 
    -0.08225316f, -0.01156854f, 0.00859680f, 0.04045989f, 0.02641358f, -0.00719840f, 0.03873333f, 0.03193531f, 
    -0.04436189f, 0.02886811f, -0.05933967f, -0.02337945f, -0.07709745f, -0.00468858f, -0.03722985f, -0.07223888f, 
    0.04549168f, -0.00151914f, 0.03501300f, -0.02566125f, -0.02649224f, 0.00222154f, 0.01483607f, -0.06406825f, 
    -0.07393902f, 0.00823494f, -0.06408195f, 0.06930710f, -0.02174365f, -0.00785322f, 0.01444209f, 0.01758894f, 
    -0.06386068f, 0.03478654f, 0.01163956f, -0.08480413f, -0.07494418f, -0.03053293f, -0.08137183f, -0.01704569f, 
    0.04955214f, -0.04754930f, -0.04149938f, -0.09056881f, 0.00785005f, -0.06144946f, 0.03538221f, -0.04705527f, 
    -0.04224886f, -0.00931620f, 0.04073386f, -0.06991288f, 0.06481350f, 0.01096466f, -0.04489591f, -0.03397364f, 
    -0.02454246f, -0.03315887f, -0.09745199f, -0.04556083f, 0.01004749f, -0.00598062f, 0.04529025f, -0.05371999f, 
    -0.07953271f, -0.03279775f, -0.02432661f, 0.02143290f, 0.07425117f, 0.03596189f, -0.08495311f, -0.05209985f, 
    0.05301424f, -0.04467158f, -0.09718952f, -0.02283113f, 0.03915887f, 0.02267923f, 0.05133664f, -0.00548926f, 
    -0.02747297f, 0.03322029f, -0.00356837f, 0.05136778f, 0.02671989f, -0.05898021f, 0.04100420f, -0.07061327f, 
    -0.03355698f, 0.04783788f, 0.03581398f, 0.00336727f, 0.02945901f, -0.06190699f, -0.02153047f, 0.04598776f, 
    -0.01888179f, -0.07959008f, -0.01569804f, -0.07342933f, 0.00950103f, -0.00435869f, -0.05305799f, 0.00676698f, 
    0.04522713f, -0.00210869f, -0.05212922f, -0.04083440f, 0.02209193f, -0.04072431f, -0.03345409f, -0.02390448f, 
    -0.02355099f, -0.05853398f, 0.04939268f, -0.01913527f, -0.01821011f, 0.03668749f, 0.02168429f, -0.09420598f, 
    0.07319215f, 0.03819633f, -0.00924896f, 0.03886423f, -0.08401204f, 0.02008829f, 0.05365217f, -0.08006707f, 
    -0.01184584f, -0.01166296f, -0.02301161f, -0.07678692f, -0.03474289f, -0.01160056f, -0.05143557f, -0.04534582f, 
    -0.02854376f, 0.01029391f, 0.00192569f, -0.04775240f, 0.04687487f, -0.05332584f, -0.03960948f, 0.05846186f, 
    0.07948559f, -0.01721377f, 0.03337548f, 0.01822657f, 0.01111321f, 0.05729324f, -0.05632130f, 0.06280506f, 
    0.06373695f, -0.05951039f, -0.05661330f, 0.00270228f, -0.06390997f, -0.04137751f, 0.01827988f, -0.09267874f, 
    0.02964790f, 0.04703650f, -0.06813217f, 0.05510200f, -0.00232691f, -0.02279333f, 0.06718126f, 0.04086209f, 
    0.18819600f, -0.08996967f, -0.01112413f, -0.04563490f, 0.05528686f, -0.04591857f, 0.08517215f, 0.06269806f, 
    -0.04468175f, -0.07670649f, -0.08060708f, -0.12507914f, -0.03457583f, 0.12217222f, 0.18090008f, -0.18054645f, 
    0.28261033f, 0.01913685f, -0.18576647f, -0.11365511f, 0.08413070f, 0.02976303f, 0.01735663f, 0.07180120f, 
    -0.00950868f, 0.27140561f, -0.22846189f, -0.11659297f, -0.00164089f, 0.12863180f, -0.08817016f, 0.00804703f, 
    0.08055501f, -0.02443967f, 0.12804589f, 0.00367221f, -0.14259914f, 0.02666536f, 0.00017181f, 0.27229220f, 
    -0.08359092f, 0.00479276f, -0.04887580f, -0.00882173f, 0.03315999f, -0.17520866f, -0.08423310f, 0.06016320f, 
    -0.24430376f, 0.08498845f, -0.08572103f, -0.08115108f, -0.13024880f, 0.17225622f, -0.01666551f, 0.09549792f, 
    0.12639658f, -0.01557367f, -0.00523408f, -0.10392887f, -0.01736806f, -0.04164125f, -0.03187256f, 0.00966828f, 
    0.08476534f, 0.09689698f, 0.02924028f, 0.18277974f, 0.11672083f, 0.10460253f, 0.19198571f, 0.01834546f, 
    -0.09026324f, 0.03192980f, -0.07397493f, -0.10980903f, 0.03386610f, -0.22368892f, 0.06413196f, 0.25284964f, 
    -0.06454038f, 0.04741239f, 0.09677096f, -0.16832107f, -0.06758527f, 0.38668835f, 0.40465808f, 0.23941840f, 
    0.02512435f, -0.02838684f, 0.11938356f, -0.10976564f, 0.02766498f, -0.00586424f, 0.05020426f, -0.02122888f, 
    -0.30884656f, 0.67637908f, -0.38411582f, -0.25473458f, 0.13575485f, 0.09012824f, -0.06569674f, -0.01412156f, 
    0.22793247f, -0.02045229f, 0.23382275f, 0.08798906f, -0.45538688f, -0.02011429f, -0.06613574f, 0.03498736f, 
    0.17317881f, 0.04309350f, 0.16327286f, -0.00861310f, 0.16453321f, -0.13878001f, -0.12768224f, 0.04749247f, 
    0.17639899f, -0.25576860f, -0.13718815f, -0.11758658f, 0.07374277f, -0.02950951f, 0.03872449f, -0.05793129f, 
    0.14595644f, -0.12101218f, 0.01436889f, -0.05880868f, -0.06469239f, -0.29475269f, 0.14955083f, -0.16275163f, 
    0.03069177f, -0.05161544f, 0.10677560f, -0.03817335f, -0.05111651f, 0.02695078f, -0.02240550f, -0.01374952f, 
    -0.10319452f, 0.19495948f, 0.22130391f, 0.26040658f, -0.07634152f, -0.00437888f, 0.05636514f, -0.02551788f, 
    -0.06001531f, -0.01335599f, -0.06019364f, 0.01682692f, -0.22637117f, 0.18118419f, 0.32280138f, -0.08212239f, 
    -0.08584606f, -0.05784564f, -0.02524431f, 0.22825171f, 0.05797601f, -0.03913597f, 0.08829119f, 0.06284660f, 
    0.88472271f, 0.01783976f, -0.08910925f, -0.04225568f, -0.02693483f, 0.06033610f, 0.02266971f, -0.02393040f, 
    0.10042489f, -0.02187114f, 0.05367085f, -0.14727284f, -0.13412535f, 0.45614693f, -0.24234428f, 0.26636982f, 
    0.02595918f, 0.14659545f, 0.07504404f, -0.16706723f, -0.07766859f, 0.21915516f, 0.00541658f, -0.09054973f, 
    -0.20558877f, 0.37397823f, -0.10234158f, -0.01199664f, 0.00993881f, 0.04747885f, 0.06385823f, 0.04385092f, 
    0.03710945f, -0.12950276f, 0.06798819f, 0.09239338f, 0.31010896f, -0.00511173f, 0.21076170f, -0.14330639f, 
    -0.16570652f, -0.07085847f, -0.03393496f, -0.20931913f, 0.11570197f, -0.00207901f, -0.01050129f, 0.05340742f, 
    -0.36594212f, -0.23440725f, 0.35351172f, 0.07642357f, -0.13833079f, -0.10241028f, 0.03177858f, 0.00027697f, 
    0.04012426f, 0.04812235f, -0.04587120f, -0.03399874f, -0.18693237f, 0.10134003f, 0.19612359f, -0.16064695f, 
    -0.16848901f, -0.08917674f, -0.11950061f, 0.09509657f, 0.15167695f, 0.08648646f, 0.10033946f, 0.17289156f, 
    0.30735794f, -0.34820035f, 0.12670010f, -0.02121666f, 0.07089734f, 0.21277650f, 0.03203754f, -0.08376928f, 
    0.14652979f, 0.13310874f, 0.32194102f, 0.15978684f, -0.45518839f, 0.15318547f, 0.20036450f, -0.16743571f, 
    0.03493092f, 0.02143538f, -0.12173848f, -0.00413169f, 0.12121589f, -0.06266665f, -0.11694635f, -0.00475526f, 
    0.34682333f, -0.20131949f, 0.39762759f, 0.26393634f, 0.01641302f, -0.05814542f, 0.07827695f, -0.01996126f, 
    0.05805233f, 0.05376788f, -0.12454087f, 0.08277199f, 0.25389886f, 0.04988644f, -0.00535990f, 0.12149806f, 
    0.35378265f, 0.30045184f, 0.03182420f, 0.22644962f, -0.02652639f, 0.11669856f, -0.00292457f, 0.05071159f, 
    0.08053987f, -0.25549009f, 0.50200862f, 0.07305029f, -0.10948527f, -0.06475791f, -0.14370073f, -0.11935259f, 
    -0.11278260f, -0.00283461f, -0.05501477f, 0.09481083f, -0.07996245f, -0.34530985f, 0.28179547f, -0.12505001f, 
    0.04141458f, 0.14182563f, -0.04960431f, -0.16097330f, 0.02410248f, 0.04006340f, 0.10076445f, -0.12747373f, 
    -0.08177194f, -0.13277586f, 0.24548498f, 0.40101552f, 0.12171085f, -0.04765050f, 0.05205967f, 0.08133356f, 
    -0.15697668f, -0.07174639f, 0.04447952f, 0.01842681f, -0.29529256f, 0.37162903f, 0.29414514f, -0.36113361f, 
    -0.03967947f, 0.04387620f, -0.09908870f, -0.06413230f, -0.18502250f, 0.11710940f, 0.12178500f, 0.14324249f, 
    -0.10831581f, -0.02875702f, -0.00274234f, -0.02170996f, -0.07354282f, 0.05485507f, -0.06148806f, 0.14799649f, 
    0.07972369f, 0.12801141f, 0.19703980f, -0.07602915f, -0.69948179f, 0.08972347f, -0.20594545f, -0.14970262f, 
    0.07321419f, 0.05281718f, -0.15244068f, -0.02846959f, 0.02355567f, 0.02923000f, -0.02839933f, -0.03560679f, 
    -0.58923668f, -0.04970809f, 0.58626169f, 0.16339476f, 0.22542702f, -0.10028733f, 0.13783193f, -0.04046925f, 
    0.18089318f, -0.00390787f, -0.02831303f, -0.18930030f, 0.26416570f, -0.00061948f, 0.18432577f, 0.04419934f, 
    -0.15001293f, 0.16464178f, 0.09294417f, 0.19897299f, 0.00618512f, 0.10936116f, 0.05364407f, 0.05887822f, 
    0.31308925f, 0.06251743f, 0.04122382f, 0.39765823f, -0.02763716f, 0.14777780f, 0.02731447f, 0.01624028f, 
    0.04300655f, 0.05512930f, -0.01014739f, -0.11986346f, -0.35741937f, 0.10807713f, 0.03915067f, 0.01796169f, 
    0.00644566f, 0.00745311f, -0.02736644f, -0.01669136f, 0.09471264f, -0.00844331f, -0.12308404f, 0.08149423f, 
    -0.52633232f, -0.17556342f, -0.19297169f, 0.26728719f, 0.11814373f, 0.00112000f, 0.22033313f, 0.03102581f, 
    -0.00804384f, 0.06025521f, 0.00624434f, -0.07253022f, -0.07037094f, 0.02200943f, 0.00383929f, -0.09888670f, 
    0.21296158f, 0.12663727f, -0.05840274f, -0.09500852f, 0.16404122f, -0.09698807f, -0.04772321f, -0.22993386f, 
    -0.11492460f, 0.26287776f, -0.09087876f, 0.32635951f, -0.04153559f, 0.11758707f, 0.06521329f, -0.06574563f, 
    0.00718554f, 0.05782824f, -0.01151078f, -0.16860557f, -0.11132371f, 0.09890401f, 0.16019860f, 0.46140724f, 
    -0.09101609f, -0.15782315f, -0.02651006f, 0.04960338f, 0.04979969f, 0.12129726f, 0.03523998f, 0.02100451f, 
    0.11599247f, -0.00984999f, -0.13058478f, 0.11191194f, -0.08623125f, -0.00802199f, 0.09740921f, -0.10617953f, 
    -0.15368955f, -0.12537383f, -0.04827401f, -0.00295781f, 0.30410764f, 0.16108011f, -0.11740629f, 0.07334173f, 
    -0.17636289f, 0.01522172f, -0.20979665f, 0.09113547f, 0.03679232f, 0.10101017f, 0.20198837f, -0.09303329f, 
    0.26984519f, -0.29976332f, -0.16051283f, -0.28049824f, -0.04602428f, 0.16945958f, -0.02872462f, 0.08239435f, 
    -0.14986260f, 0.16716783f, -0.01610282f, 0.07256118f, -0.17876668f, 0.08983269f, 0.10003689f, -0.06757090f, 
    -0.01783255f, 0.10042752f, 0.15474364f, 0.00443179f, 0.00187121f, -0.23875867f, -0.22616063f, -0.03482988f, 
    0.06047852f, -0.05692546f, -0.21714652f, -0.06388108f, -0.14355648f, -0.19360979f, -0.13631222f, 0.10635107f, 
    0.04796744f, 0.03203657f, -0.01778095f, 0.16200358f, -0.16054490f, 0.13344084f, -0.26073170f, -0.19952920f, 
    -0.08288559f, 0.24767783f, 0.09004991f, -0.05791106f, -0.12859330f, -0.15207091f, -0.28541875f, 0.05413726f, 
    0.35555550f, 0.12819755f, 0.17620236f, 0.18133603f, -0.02814261f, -0.20988142f, 0.23747864f, 0.07910503f, 
    0.04964970f, 0.11157920f, -0.05242894f, 0.05710424f, 0.66497260f, 0.15164053f, -0.16792035f, 0.16692618f, 
    -0.19357665f, -0.06512173f, -0.03485002f, -0.09483287f, -0.21868965f, -0.02428332f, -0.01617663f, -0.05201252f, 
    -0.05587796f, -0.13087881f, -0.18505129f, -0.17447637f, 0.15086105f, -0.08867122f, -0.04282762f, 0.01238890f, 
    0.25343713f, 0.29323164f, -0.11140374f, 0.05567543f, 0.16168958f, -0.21270923f, -0.07046870f, -0.38184714f, 
    0.01045819f, 0.03176862f, -0.05099479f, -0.03538770f, -0.23862484f, 0.02674657f, 0.29453292f, -0.06234534f, 
    -0.80865562f, 0.34386760f, -0.18641001f, -0.37585628f, -0.04603322f, 0.01860398f, 0.03464551f, -0.01996179f, 
    -0.03825124f, -0.21558976f, 0.01788360f, -0.01370734f, 0.15600060f, 0.12032039f, 0.12877332f, -0.68095839f, 
    0.23979856f, 0.14818740f, -0.09273653f, -0.07248304f, 0.08506692f, 0.02818455f, -0.12571152f, 0.14499785f, 
    -0.15078008f, 0.10882855f, -0.05357046f, -0.29059577f, 0.18654716f, 0.09915674f, -0.10603283f, -0.06099618f, 
    -0.00749454f, 0.06789902f, -0.09253524f, -0.01634492f, -0.19328694f, 0.08766800f, -0.14214811f, -0.09789269f, 
    0.02720008f, -0.03050882f, 0.03849318f, 0.24771996f, 0.20857462f, -0.03621241f, -0.00863865f, -0.08075740f, 
    -0.23489743f, -0.02666874f, 0.07837570f, -0.16343334f, -0.02185990f, 0.16106889f, -0.09518007f, 0.03172697f, 
    0.14831391f, -0.11056934f, 0.10836180f, 0.02461595f, -0.41424569f, 0.47831386f, -0.06463098f, 0.02303671f, 
    -0.04169824f, 0.22986476f, -0.07399838f, -0.00660583f, 0.11899692f, 0.15167129f, 0.22866495f, 0.15769385f, 
    0.24357334f, -0.13080546f, -0.07614619f, 0.22779050f, -0.04198038f, -0.28449214f, 0.04350848f, 0.15212394f, 
    -0.14727618f, -0.08077423f, 0.12629955f, -0.19545670f, 0.00130651f, 0.36715269f, 0.19551133f, 0.22376086f, 
    0.04600827f, 0.02905901f, 0.05648388f, -0.21602766f, -0.15099047f, -0.04378138f, 0.14406903f, -0.12134352f, 
    -0.39005035f, 0.55241621f, 0.07216047f, 0.08640881f, 0.18903649f, 0.26721233f, -0.05153358f, -0.01449655f, 
    0.19934370f, -0.13024524f, 0.15886313f, 0.11662050f, -0.32864520f, -0.17537145f, 0.08261167f, 0.55611342f, 
    0.13915783f, 0.22204682f, 0.01148523f, 0.08319023f, 0.17921637f, 0.00459577f, -0.03895513f, -0.06371627f, 
    0.31073380f, -0.12167659f, -0.18334447f, 0.09758181f, 0.22990575f, 0.07926263f, 0.04093428f, -0.21030836f, 
    0.13395315f, -0.09352702f, -0.01736107f, -0.00364232f, 0.08853923f, -0.11944272f, -0.03638665f, -0.12836516f, 
    -0.02439244f, -0.12776889f, 0.14577883f, -0.02950109f, -0.08800454f, 0.09399143f, 0.24310972f, 0.12499238f, 
    0.09368683f, -0.01331504f, 0.11753491f, 0.14266206f, -0.03077086f, 0.14643797f, 0.03896261f, 0.22202650f, 
    0.02845727f, 0.21479578f, 0.07061604f, 0.20407207f, -0.01636211f, -0.08875969f, 0.24184081f, -0.08072650f, 
    0.04425567f, -0.06414030f, 0.11123512f, 0.13883629f, 0.06805956f, 0.00048610f, 0.11633723f, -0.13482951f, 
    0.36254829f, 0.08852960f, -0.07338397f, 0.31884170f, 0.18864296f, -0.09975599f, 0.02895883f, -0.03240577f, 
    -0.07011393f, 0.05259559f, 0.10356849f, -0.20449480f, -0.02185458f, 0.49831343f, 0.10002732f, 0.49165031f, 
    -0.09347967f, 0.18576853f, -0.00880986f, 0.00510724f, -0.01264817f, 0.08374193f, 0.02244511f, -0.07814907f, 
    -0.01477038f, 0.02001284f, -0.04853080f, 0.05116232f, 0.05398985f, 0.04084300f, 0.01491204f, -0.08176378f, 
    -0.02081565f, -0.08175611f, -0.07203399f, -0.07045902f, -0.02547795f, -0.03374522f, -0.07656986f, 0.04747492f, 
    -0.07032339f, 0.00497980f, -0.05368209f, -0.01468038f, -0.00763479f, 0.00538142f, -0.00242384f, -0.06069325f, 
    -0.06082544f, 0.02452006f, 0.04722436f, 0.02351070f, -0.06783610f, -0.00842792f, 0.04825604f, -0.00067634f, 
    -0.05968391f, 0.00936843f, 0.04087163f, -0.02121114f, -0.01333103f, -0.03639397f, -0.02030143f, 0.01453084f, 
    0.04775157f, -0.08273052f, -0.04997805f, -0.03406088f, 0.02842223f, -0.02067154f, -0.01756534f, 0.04380925f, 
    0.02182651f, -0.02425292f, -0.01344411f, -0.06134115f, -0.05917998f, 0.01479911f, 0.01384039f, -0.05624634f, 
    -0.07473744f, -0.02940471f, 0.00203879f, 0.00721707f, -0.02286955f, -0.05606651f, 0.03400607f, 0.02097535f, 
    -0.01646825f, -0.03797152f, 0.02639071f, 0.05178866f, 0.03444022f, 0.05739050f, -0.06964153f, 0.00324334f, 
    0.03397582f, -0.04272675f, -0.08085300f, -0.05305775f, -0.04963220f, 0.05280421f, -0.03256162f, -0.02545373f, 
    -0.02794472f, -0.01176228f, -0.05689831f, -0.06000142f, -0.07842837f, -0.07718160f, -0.02893638f, 0.06226316f, 
    -0.00388212f, 0.00187045f, 0.05073405f, 0.04620351f, -0.04320424f, 0.00621516f, -0.03449289f, 0.03760663f, 
    0.04085070f, -0.07980952f, -0.02382215f, 0.05746054f, -0.03812570f, 0.00609573f, 0.01036795f, -0.03907152f, 
    -0.05188571f, 0.04233725f, -0.05878777f, -0.04636392f, 0.04441807f, -0.04146532f, 0.03898485f, -0.06406793f, 
    -0.06008140f, 0.03206040f, 0.04944912f, -0.07078723f, 0.01965111f, -0.01048692f, -0.05293967f, 0.05189392f, 
    -0.00837911f, -0.07836447f, -0.01881663f, -0.02429063f, -0.01627154f, -0.00218597f, -0.02150713f, -0.02430864f, 
    0.02631509f, 0.04622703f, -0.06139766f, -0.07412058f, -0.01763784f, 0.00769687f, 0.00304708f, 0.06199571f, 
    -0.01170528f, 0.02444197f, 0.00637881f, 0.03959415f, -0.06294101f, 0.02230553f, -0.07594870f, -0.05812678f, 
    0.00035862f, -0.04883066f, -0.05135396f, 0.03927163f, 0.03373328f, 0.05479712f, 0.02671295f, -0.06496539f, 
    -0.02690973f, 0.06277066f, -0.08110067f, -0.00956266f, 0.01323928f, -0.03169341f, 0.00756181f, 0.02634884f, 
    -0.05882636f, -0.06216055f, -0.01710537f, 0.03938738f, -0.07011262f, 0.03467708f, 0.03239787f, 0.06444918f, 
    0.05388450f, -0.07779422f, -0.07323984f, 0.05875497f, -0.01073324f, -0.07416473f, -0.01967658f, -0.04179098f, 
    -0.07304893f, -0.02538435f, -0.03691089f, -0.05460265f, 0.02463791f, 0.05203646f, -0.06721466f, -0.02930340f, 
    -0.03711337f, -0.03752070f, 0.02167057f, -0.03668146f, -0.04020203f, 0.01851074f, 0.03007944f, -0.07459860f, 
    -0.75273776f, 0.31568342f, -0.02693501f, -0.04071380f, -0.10132425f, 0.11970626f, 0.01846896f, -0.00007854f, 
    0.01378325f, -0.10405854f, 0.02534248f, 0.08087152f, 0.19332945f, -0.19399172f, -0.24521033f, 0.04134873f, 
    -0.02111441f, 0.03712045f, 0.09592222f, 0.06828617f, -0.06628726f, -0.07111196f, -0.17616194f, 0.01140137f, 
    0.18405262f, -0.27822554f, 0.04856561f, -0.04798228f, 0.11337299f, -0.02379941f, -0.03917660f, 0.09444980f, 
    -0.15247940f, -0.07945206f, -0.22097319f, 0.15242687f, 0.26222989f, -0.01697131f, 0.17399651f, -0.15557033f, 
    0.16137840f, 0.06656047f, 0.12998426f, 0.11947370f, 0.00448911f, 0.02901611f, 0.03333749f, 0.05718787f, 
    -0.22500457f, 0.02638100f, 0.09142319f, -0.07512057f, 0.16596343f, 0.03922474f, -0.02061113f, 0.07967965f, 
    -0.10743289f, -0.03961888f, 0.11209466f, 0.05785678f, -0.12851870f, 0.07569976f, 0.06058387f, -0.04459726f, 
    0.03770305f, 0.05404385f, -0.03828241f, -0.03778043f, 0.19860764f, 0.10710318f, -0.04658793f, -0.01080402f, 
    0.03297942f, 0.06814498f, 0.03502968f, 0.41940755f, -0.21778944f, 0.10987908f, 0.04880932f, -0.01121951f, 
    0.15202484f, -0.05907867f, -0.04697124f, 0.08790081f, 0.19829060f, -0.22774889f, -0.35606340f, -0.74165386f, 
    0.03024617f, -0.06122685f, -0.14887720f, 0.02059713f, 0.03307736f, -0.01710636f, -0.01697740f, -0.17202879f, 
    0.11162834f, -0.18492606f, 0.58370686f, 0.11551658f, -0.01014853f, 0.17752367f, -0.05810470f, 0.26562652f, 
    -0.04877574f, -0.15971775f, -0.08933057f, 0.15916273f, 0.07995970f, -0.14235008f, 0.28005192f, 0.30448371f, 
    0.02331551f, 0.09107191f, 0.11585319f, 0.17891580f, 0.08539042f, 0.17930026f, -0.04401999f, -0.02753170f, 
    -0.01998418f, 0.35592467f, -0.13106337f, 0.05806826f, 0.12850358f, 0.05600023f, -0.04258438f, -0.02242543f, 
    -0.07493016f, 0.20752320f, 0.02913219f, 0.30953798f, 0.12708719f, 0.09209630f, -0.03374531f, 0.25624540f, 
    -0.12768698f, -0.07216401f, -0.05748473f, 0.09636693f, 0.00463494f, 0.04674576f, 0.01669409f, 0.08091626f, 
    0.05452792f, -0.04243432f, -0.22535071f, -0.47481918f, 0.02017625f, -0.05765707f, 0.07399193f, 0.11360850f, 
    0.11695789f, 0.24926217f, 0.09024452f, 0.08796074f, 0.17254946f, 0.05565075f, -0.31056571f, 0.07717600f, 
    0.04986902f, -0.12221962f, 0.14000496f, -0.03923054f, -0.04220210f, 0.03410318f, -0.00640524f, -0.08813968f, 
    -0.21001910f, 0.05940698f, 0.15402748f, 0.11048604f, -0.02141834f, 0.18292299f, -0.08332720f, 0.13004389f, 
    -0.06025729f, -0.09173650f, -0.12700039f, 0.10581416f, 0.20011751f, -0.18479389f, 0.22225010f, -0.17129202f, 
    -0.01889949f, 0.01220066f, 0.02812457f, -0.02547853f, -0.05076981f, -0.04191169f, -0.01745955f, 0.03269946f, 
    -0.38838509f, 0.44273868f, 0.34820420f, -0.33067811f, 0.09254134f, -0.09565827f, 0.04372035f, -0.08978445f, 
    -0.01358037f, 0.08782137f, -0.11970251f, 0.01723746f, 0.14598002f, 0.24035507f, -0.16336274f, 0.33841285f, 
    0.02420911f, 0.17573030f, 0.12889630f, 0.13578637f, -0.15943594f, -0.02534743f, 0.06040598f, -0.16185144f, 
    0.31181961f, 0.37941563f, 0.00464292f, -0.06180318f, -0.13317057f, 0.04969968f, 0.03685031f, 0.14915088f, 
    -0.20876284f, -0.21802321f, 0.00768642f, -0.02655414f, 0.06148084f, -0.08240826f, -0.04095779f, 0.07268053f, 
    0.01933098f, -0.00398066f, 0.09893224f, 0.01168924f, -0.17782032f, -0.08399029f, -0.05377668f, 0.02736069f, 
    0.12901680f, 0.24975654f, 0.28690448f, -0.10067714f, 0.23763694f, 0.01462783f, 0.19616693f, 0.00390022f, 
    -0.02320561f, 0.00387151f, 0.11516420f, 0.01439974f, 0.15117979f, 0.45141068f, 0.20937055f, 0.05916339f, 
    0.02681770f, -0.06613450f, -0.03205949f, 0.01266652f, -0.05935080f, -0.05402097f, 0.00033093f, -0.04196535f, 
    -0.00198314f, 0.16665787f, 0.08751577f, 0.15006422f, -0.07266301f, -0.04308896f, 0.06927657f, -0.01386193f, 
    0.16598269f, -0.00759507f, -0.11140071f, 0.07000567f, -0.08396331f, 0.00915692f, -0.48692334f, -0.07347871f, 
    0.12475552f, -0.23767464f, -0.00863154f, 0.00175240f, 0.05869981f, -0.09722302f, -0.03269381f, -0.01454330f, 
    0.16968730f, 0.37217417f, 0.10668215f, 0.22020298f, 0.15204114f, -0.05565261f, 0.21163191f, -0.01592581f, 
    -0.02024561f, -0.03218668f, 0.21236779f, -0.01267912f, 0.64673936f, 0.13849863f, -0.07950258f, 0.29458365f, 
    -0.09423190f, 0.03243001f, 0.18166056f, -0.06440496f, 0.10535609f, 0.18854046f, 0.15689988f, -0.19735593f, 
    -0.21844797f, -0.05576736f, -0.00953793f, -0.13986519f, 0.20350224f, -0.16563036f, 0.00410602f, 0.00745327f, 
    -0.06480641f, 0.08580545f, 0.13728230f, 0.24614578f, 0.36467177f, -0.02532885f, -0.06448533f, 0.08118661f, 
    0.02063032f, 0.09510477f, 0.09037399f, 0.15784457f, 0.13247028f, 0.01573647f, 0.09943345f, -0.03809102f, 
    -0.17881501f, -0.27904633f, -0.18711199f, -0.27960557f, 0.08657928f, 0.06292620f, 0.05690243f, 0.01677809f, 
    0.01014414f, 0.16858074f, 0.06100936f, 0.13409922f, 0.02556601f, -0.07523060f, 0.01046720f, -0.21845935f, 
    0.20236170f, 0.08524424f, 0.06285402f, -0.05114809f, 0.08548626f, 0.11500794f, 0.01502056f, -0.00953139f, 
    -0.27701238f, -0.20570043f, -0.01527071f, -0.06495442f, -0.07900392f, 0.07655026f, -0.13811687f, 0.02973415f, 
    -0.08154991f, -0.10809810f, -0.17754030f, 0.16994657f, 0.10840801f, -0.08885744f, -0.10810988f, 0.12492640f, 
    0.17259407f, -0.11738313f, -0.01844021f, 0.07593834f, 0.18725263f, 0.11090504f, -0.08668909f, 0.01897930f, 
    -0.01385115f, 0.06330084f, 0.02129745f, -0.03403332f, -0.01797256f, 0.04997704f, 0.03359859f, -0.00482468f, 
    -0.02900975f, 0.01108837f, -0.06709687f, 0.01054951f, 0.02995762f, -0.04472530f, -0.06366414f, -0.00744677f, 
    -0.05883005f, -0.07357608f, 0.01338952f, -0.01415677f, -0.04530514f, 0.02493817f, 0.05367979f, -0.04941922f, 
    0.00705866f, -0.06831307f, 0.05191827f, -0.04181505f, -0.00909596f, -0.05795189f, -0.07620686f, 0.04864404f, 
    0.02174720f, 0.04270317f, 0.01379158f, 0.00784429f, -0.03029915f, 0.05828834f, -0.05162601f, 0.04278893f, 
    -0.04874415f, 0.01142036f, 0.01859828f, 0.04873725f, -0.01722023f, -0.01667088f, -0.00973764f, 0.00175135f, 
    0.03776310f, -0.04446974f, -0.06232292f, 0.01967625f, -0.08024039f, -0.01186270f, -0.00219109f, -0.05123032f, 
    -0.03274453f, -0.07072557f, -0.07026089f, 0.02822964f, -0.05205281f, 0.05884723f, 0.03709656f, 0.03270009f, 
    0.00080794f, -0.04371191f, -0.03930166f, -0.04954742f, 0.02308566f, -0.02305007f, -0.05378001f, 0.04514612f, 
    -0.04452229f, 0.03656645f, -0.03661138f, 0.01818875f, 0.00192532f, -0.04685002f, -0.00024914f, -0.05767268f, 
    -0.03048475f, 0.05468312f, -0.04870068f, 0.04505375f, 0.02886716f, 0.03154872f, -0.04574475f, 0.04331471f, 
    -0.03844462f, -0.00660959f, 0.03674653f, -0.02731094f, -0.07833576f, -0.05857537f, -0.04573033f, -0.06523491f, 
    -0.07093703f, -0.01784900f, 0.05641207f, -0.00008380f, -0.05155018f, -0.03919247f, 0.01827117f, 0.00690137f, 
    -0.01105061f, 0.03864073f, -0.07583897f, -0.00661090f, 0.05146044f, -0.05908064f, -0.07113601f, -0.05974230f, 
    0.03404887f, 0.00605609f, -0.01544099f, -0.01173582f, 0.02036192f, 0.00804150f, -0.05571030f, -0.05743475f, 
    -0.03945003f, 0.04081269f, -0.03374933f, -0.04048470f, -0.00597672f, 0.00333650f, -0.01231827f, 0.02340174f, 
    -0.00131274f, -0.05349454f, -0.03947774f, -0.02993162f, -0.04449480f, -0.01752137f, 0.05499130f, -0.04100662f, 
    0.03944870f, -0.05151692f, 0.04807901f, -0.04985663f, -0.07280481f, 0.02624281f, -0.03011020f, 0.04779972f, 
    0.05537525f, -0.03637641f, 0.01737090f, -0.01784780f, 0.00999233f, 0.02717892f, -0.07062782f, -0.03806798f, 
    -0.04405537f, -0.00533253f, -0.01715120f, -0.01150443f, -0.05147166f, 0.05972906f, -0.05124978f, -0.05166371f, 
    -0.04751697f, -0.06449541f, -0.03644522f, -0.01969302f, 0.03792120f, -0.00817686f, -0.06016607f, 0.05321367f, 
    -0.02789185f, -0.01093816f, 0.01943234f, -0.06030854f, -0.07921640f, 0.05648408f, 0.06226521f, 0.02565434f, 
    -0.01690589f, 0.02139098f, -0.04211539f, -0.03643294f, -0.04877810f, 0.05489990f, -0.05570026f, 0.01577480f, 
    -0.04498674f, -0.02811733f, -0.00629305f, 0.04781877f, -0.05748995f, 0.06194784f, -0.06938179f, 0.03336546f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01642481f, 0.03885312f, 0.00443059f, 0.00379872f, 0.04138711f, 0.20131475f, -0.07798772f, 0.11051749f, 
    0.03648290f, 0.06362661f, 0.04563576f, 0.07845742f, 0.21486697f, -0.01882917f, -0.02425493f, -0.02853326f, 
    -0.13657884f, -0.04245507f, -0.09921548f, 0.02410870f, -0.08479319f, 0.03935522f, 0.02156090f, 0.02859827f, 
    -0.13932581f, 0.04063267f, 0.00249036f, 0.02454385f, -0.00397909f, 0.12449452f, -0.02152528f, -0.05766856f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.20655394f, -0.71725577f, 0.09899388f, 0.01941716f, -0.00245553f, -0.61474037f, 0.12704693f, -0.07843476f, 
    0.24920803f, -0.21676111f, -0.15789354f, -0.41732222f, -0.40950659f, -0.04494229f, 0.49705338f, 0.56586647f, 
    0.38666341f, -0.05906936f, 0.33882484f, -0.41977543f, 0.24620539f, 0.10027540f, 0.12900473f, 0.05828707f, 
    0.19837390f, 0.06639373f, -0.15527661f, -0.29829389f, 0.11391543f, 0.11444870f, -0.13008700f, 0.06325059f, 
    -0.08331648f, -0.29266402f, -0.01420865f, 0.04746390f, -0.14810115f, 0.31619483f, -0.06630713f, 0.05365181f, 
    0.14983538f, 0.24870525f, -0.11224392f, 0.03242680f, -0.24217170f, 0.13453536f, 0.06306344f, -0.38324285f, 
    0.31257725f, -0.42713439f, 0.01764961f, 0.20693134f, 0.21164340f, 0.40671608f, 0.13921259f, -0.07939754f, 
    -0.63606197f, 0.00521176f, 0.28698352f, -0.66808438f, 0.10239272f, 0.03827317f, 0.03259172f, -0.09599071f, 
    0.33093992f, -0.18475360f, -0.14628839f, 0.10030419f, -0.13980973f, 0.01173486f, -0.05343591f, 0.19710234f, 
    0.48199743f, -0.63425297f, 0.15592219f, 0.14382444f, -0.59295124f, 0.10745730f, -0.15449727f, 0.09930267f, 
    -0.29969618f, -0.31071985f, -0.61654258f, 0.40435216f, 0.35200351f, 0.11872812f, -0.08211137f, 0.05326860f, 
    0.50258255f, -0.53013581f, 0.14923464f, -0.02353350f, 0.00344998f, -0.72427785f, -0.03140850f, -0.01407294f, 
    0.23379037f, 0.41081333f, 0.11971477f, 0.16068798f, 0.03893310f, -0.41613498f, 0.14807606f, -0.63953847f, 
    0.47869909f, 0.14123593f, 0.13125680f, -0.05777482f, 0.26611963f, 0.09830739f, -0.86388832f, 0.33684972f, 
    -0.29364449f, 0.27427256f, 0.01762276f, -0.22151503f, 0.02535905f, -0.68188852f, -0.04945426f, -0.01969128f, 
    -0.20377900f, -0.29339841f, -0.19324753f, -0.22060482f, 0.03600889f, 0.43392313f, -0.11974832f, 0.03569788f, 
    0.37234366f, 0.00092694f, -0.58688313f, -0.14700145f, -0.04949297f, -0.28790700f, -0.18166718f, 0.10040992f, 
    0.07439138f, -0.10449100f, 0.14397974f, 0.10325913f, 0.25158381f, -0.01611715f, -0.05843357f, -0.59720123f, 
    0.05745068f, 0.27893284f, 0.48380700f, -0.25721693f, -0.23567508f, -0.58586591f, -0.04788410f, 0.00898300f, 
    0.15973927f, 0.41077641f, 0.58845305f, -0.05018562f, -0.05476168f, -0.24188165f, -0.19246580f, -0.16986513f, 
    0.26512811f, -0.17284392f, -0.08965214f, -0.07758061f, -0.02541548f, 0.40178266f, -0.11618251f, 0.00090427f, 
    -0.41899669f, 0.28342703f, -0.11259772f, -0.28139099f, -0.11898664f, 0.06349050f, 0.36903387f, 0.01365761f, 
    -0.30701756f, 0.13591406f, 0.27738532f, -0.03479515f, -0.40179229f, 0.23482454f, 0.09268355f, -0.00164083f, 
    -0.12335546f, 0.11986473f, -1.18403101f, -0.22035226f, 0.04322810f, 0.01049121f, 0.31834731f, 0.16005906f, 
    -0.53513318f, 0.12715793f, -0.73869097f, 0.06976176f, -0.10814784f, -0.02350836f, 0.09007452f, 0.34790576f, 
    -0.23411094f, -0.39747947f, -0.12148368f, 0.25020161f, 0.45218045f, -0.07250649f, 0.07632885f, 0.38714257f, 
    -0.69696486f, -0.18420455f, -0.24837503f, 0.07389902f, -0.14391784f, -0.00949920f, 0.15232626f, 0.04483216f, 
    -0.07286224f, -0.12031882f, -0.13916659f, 0.23424613f, -0.04357674f, 0.24897495f, 0.30700165f, 0.00325028f, 
    0.03138994f, 0.42304477f, -0.01326101f, -0.17453526f, 0.08286405f, -0.65211564f, -0.16484532f, -0.49561009f, 
    -0.33300272f, 0.08286376f, 0.14863864f, -0.14606927f, -0.75792891f, -0.11824317f, -0.63460112f, 0.33495864f, 
    -0.01887680f, 0.04448375f, 0.26302162f, -0.11566883f, -0.35989791f, -0.04921863f, -0.03455185f, -0.03078318f, 
    0.32323408f, 0.30912158f, 0.28481677f, 0.51383376f, -0.15689655f, -0.08773097f, -0.20366733f, -0.06270848f, 
    -0.01592040f, -0.09379434f, 0.21062063f, -0.05405127f, -0.01346800f, 0.29208609f, 0.14409389f, 0.01048960f, 
    -0.49619815f, 0.38546482f, 0.15792526f, -0.66408926f, 0.18390414f, 0.00717259f, 0.05035590f, -0.31459951f, 
    0.23686580f, -0.68339533f, 0.06248766f, 0.48720223f, 0.09623767f, -0.04608170f, 0.14615524f, -0.00450504f, 
    0.35000250f, -0.66782290f, -0.13593248f, -0.04890830f, -0.15815122f, -0.73845947f, -0.29072726f, -0.12231354f, 
    0.34824905f, 0.17583743f, 0.27219662f, 0.06475778f, -0.06806400f, -0.30424511f, 0.06770176f, 0.38058344f, 
    -0.53795546f, -0.69939721f, -0.15591219f, -0.30856085f, -0.07286493f, 0.06780797f, -0.14651446f, -0.44023651f, 
    0.02461741f, -0.15640496f, -0.48378801f, -0.42953116f, 0.40170118f, -0.33680692f, -0.16511323f, -0.15389456f, 
    -0.31002417f, 0.45467082f, -0.71081150f, 0.34234038f, 0.11852341f, 0.34173730f, 0.21313319f, -0.16301806f, 
    0.10723560f, 0.12537314f, 0.25756985f, -0.16730775f, -0.08351943f, 0.46614844f, 0.02773238f, -0.16518128f, 
    0.35593796f, 0.22323260f, 0.06880580f, 0.20803002f, 0.24329467f, 0.01256593f, -0.35788193f, 0.17830908f, 
    -0.60299510f, -0.46005502f, -0.70631659f, -0.36117724f, -0.51145887f, 0.35733369f, 0.12939680f, -0.00487855f, 
    -0.01772427f, 0.22224560f, 0.48581332f, 0.32449606f, -0.04592482f, 0.22661036f, -0.88398588f, -0.00840182f, 
    -0.60030073f, -0.07633450f, 0.39790031f, 0.03753570f, 0.10256007f, 0.31106681f, 0.15776494f, -0.21107879f, 
    -0.10284576f, 0.00515458f, -0.10155505f, 0.45032889f, -0.20064038f, -0.13818011f, -0.21485893f, -0.40162623f, 
    0.11056069f, 0.39249250f, -0.32314694f, -0.01941248f, 0.07436320f, -0.43349335f, 0.12000819f, -0.07562438f, 
    0.35266924f, -0.47368169f, -0.57777417f, 0.34017733f, -0.03434673f, 0.13863024f, 0.13464436f, 0.13928922f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21792766f, 0.10659179f, -0.05679978f, -0.07161716f, 0.17398439f, -0.11937341f, -0.14585590f, -0.11946581f, 
    -0.00962779f, -0.02392696f, 0.17130356f, 0.19418564f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
