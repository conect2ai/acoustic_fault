#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.59421170f, 0.26378870f, -0.12358567f, -0.13078725f, -0.47268757f, -0.52038932f, -0.08060197f, 0.28462493f, 
    0.06062344f, -0.13596040f, -0.38237655f, -0.56788141f, 0.43994224f, 0.12562340f, -0.15595539f, 0.00438487f, 
    0.11633903f, 0.25009868f, 0.70614046f, -0.12576190f, 0.75037980f, -0.60059112f, -0.10137031f, 0.14560144f, 
    -0.21804506f, -0.10825376f, -0.16382711f, -0.37472537f, -0.07904688f, 0.50889713f, -0.64552164f, -0.41567320f, 
    0.06144268f, -0.00206930f, 0.28663671f, 0.46067870f, -0.05592252f, 0.25738138f, 0.25831166f, 0.58806539f, 
    -0.53508711f, -0.48228854f, 0.06975870f, 0.02509132f, 0.17268544f, -0.06434242f, -0.14446151f, -0.28938639f, 
    0.83885157f, 0.11702678f, 0.12203089f, -0.02923434f, 0.44025812f, -0.41132355f, 0.22922049f, -0.29464489f, 
    -0.07955603f, 0.19930261f, -0.17529887f, 0.51110440f, -0.10712439f, -0.17948948f, -0.23869748f, -0.70607483f, 
    -0.47140935f, -0.06339503f, 0.72127479f, -0.37633619f, 0.00216968f, -0.18354428f, -0.31432214f, -0.39239839f, 
    0.26524311f, 0.06002530f, 0.09703497f, 0.31556240f, 0.04478326f, 0.37262955f, -0.22693509f, 0.39072469f, 
    0.27635586f, 0.04073714f, 0.80899948f, -0.39919096f, -0.15155269f, -0.23117773f, 0.19693068f, -0.45463777f, 
    0.24731870f, 0.32872403f, -0.48613274f, -0.42393368f, 0.05711168f, -0.14752112f, -0.00225942f, -0.50518501f, 
    0.19211374f, 0.04908128f, 0.11876961f, -0.30082867f, -0.32474312f, 0.61494565f, -0.09280896f, 0.12041606f, 
    0.23169141f, 0.03327790f, 0.05595686f, 0.54000372f, -0.09298607f, -0.04855209f, -0.61259651f, -0.30267394f, 
    0.31343597f, 0.51704043f, 0.03428526f, -0.02895713f, -0.31169185f, -0.03612422f, -0.47646236f, -0.49845204f, 
    -0.11658772f, 0.06223239f, -0.01288345f, -0.08631823f, 0.54953980f, -0.23361668f, -0.10693228f, -0.27520508f, 
    -0.06707323f, -0.26332462f, -0.47081617f, 0.34987417f, -0.26828709f, 0.02797997f, 0.00180420f, -0.44574511f, 
    0.19055758f, 0.44138750f, -0.18575536f, -0.13839076f, 0.47048977f, 0.33667380f, -0.34586790f, -0.27227727f, 
    0.58094472f, -0.69379777f, -0.18922825f, -0.33792847f, -0.13694079f, -0.57538259f, -0.23833558f, -0.24007310f, 
    -0.18037462f, 0.30532542f, -0.13014132f, 0.58582389f, 0.59401166f, -0.66283703f, 0.00929971f, -0.18518090f, 
    -0.14818585f, -0.07383200f, 0.09112918f, -0.47849420f, 0.79302979f, -0.34359133f, -0.46936700f, 0.53008527f, 
    0.21989560f, 0.10984535f, 0.24974383f, 0.26370659f, -0.57525086f, -0.35577735f, -0.15180384f, 0.02266565f, 
    0.27017242f, 0.23501974f, 0.26237890f, 0.33461434f, -0.23752183f, -0.08578980f, -0.21706644f, 0.03035127f, 
    0.18542978f, -0.40064266f, 0.56031954f, -0.39542422f, 0.45404789f, 0.63099486f, 0.61866003f, 0.33555260f, 
    -0.35740876f, -0.31296256f, -0.02148359f, 0.20995465f, -0.09964933f, 0.39581436f, -0.10467322f, -0.10762870f, 
    0.36790892f, -0.54536802f, 0.33991989f, -0.32599282f, -0.03917084f, 0.11718144f, -0.09841336f, 0.46087143f, 
    -0.41794667f, -0.20776664f, -0.21605419f, -0.23232621f, -0.53345585f, 0.37319469f, 0.37594470f, 0.50200915f, 
    -0.24611345f, -0.28340888f, 0.78083986f, -0.05792481f, 0.21883954f, 0.49328667f, 0.15423809f, -0.05804526f, 
    -0.27856359f, 0.33889470f, 0.22059856f, 0.02341232f, 0.20534652f, -0.19980446f, -0.10505821f, 0.36592942f, 
    0.40013951f, -0.57337248f, -0.31691337f, -0.03268269f, 0.49444407f, 0.51254636f, 0.35432437f, -0.30202723f, 
    0.06197690f, 0.28229025f, 0.04620930f, -0.02958133f, -0.32334045f, -0.02022116f, 0.31791022f, 0.57765937f, 
    -0.26924250f, 0.40601867f, 0.20144425f, -0.50617534f, -0.25395665f, 0.55729717f, -0.58338606f, -0.50442702f, 
    0.91609323f, -0.47643936f, -0.03343673f, -0.06208465f, 0.23333158f, -1.12855101f, 0.32543573f, -0.04697026f, 
    -0.23119384f, 0.49508625f, 0.69928527f, -0.17590493f, 0.18841532f, -0.22414757f, 0.66314864f, -0.69412553f, 
    -0.71685469f, 0.38741368f, 0.00852093f, 0.26483321f, -0.08288462f, 0.02264858f, -0.08810798f, -0.21380313f, 
    0.93991655f, -0.71128953f, -0.13483833f, 0.26342142f, -0.21840782f, -0.10715798f, 0.06640962f, 0.30912963f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09732939f, 0.07474647f, -0.34919617f, -0.12595555f, 0.13193935f, -0.31331736f, 0.21874237f, -0.28909415f, 
    -0.29170123f, 0.00367342f, -0.04719185f, 0.25435835f, -0.11327525f, 0.12590443f, -0.30584681f, 0.11115102f, 
    -0.17379725f, 0.00713889f, 0.13461162f, 0.00614758f, 0.13886733f, -0.31224671f, 0.27798545f, -0.12591101f, 
    -0.27585569f, 0.19783145f, -0.47248140f, -0.23600973f, -0.12117064f, -0.17343910f, -0.06297242f, -0.21743204f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.46934465f, -0.03855339f, 0.24430974f, 0.07691228f, -0.04236796f, -0.26277900f, 0.05568463f, 0.05401952f, 
    0.08298176f, -0.02034364f, -0.08889582f, 0.21247870f, 0.04081588f, 0.05574312f, 0.01316467f, 0.14229305f, 
    0.00407612f, -0.09790386f, 0.15560786f, 0.06776228f, -0.14400926f, -0.28011337f, -0.01964951f, -0.07907077f, 
    0.07867499f, 0.00766496f, -0.01165207f, 0.12973936f, -0.64800692f, -0.36736706f, -0.13699082f, -0.04358313f, 
    -0.22339371f, -0.01841274f, 0.10397623f, 0.03046322f, -0.22020106f, -0.19138560f, 0.06177702f, 0.06299770f, 
    0.01033983f, -0.11799273f, 0.06295427f, 0.08181962f, 0.18840542f, -0.50008643f, -0.14468592f, 0.31244814f, 
    -0.12041812f, -0.03589633f, 0.07912233f, 0.11962812f, -0.06146822f, -0.18872800f, 0.17522544f, 0.08400733f, 
    0.21834338f, 0.12861066f, 0.05605491f, 0.05699924f, -0.07622351f, -0.06780443f, 0.11642622f, -0.15855117f, 
    -0.06535792f, 0.10170764f, -0.24016498f, -0.23831235f, 0.10310894f, -0.00857731f, -0.00114898f, -0.10219078f, 
    -0.19354399f, 0.07106274f, 0.09865159f, -0.22310416f, -0.07824614f, 0.07633768f, -0.05291150f, -0.03375396f, 
    -0.00300206f, 0.09426042f, -0.24502556f, 0.08579611f, 0.01672558f, -0.07720327f, -0.02898168f, 0.13077368f, 
    0.04450030f, 0.03014849f, 0.02645031f, -0.16159667f, 0.16768529f, -0.08207675f, 0.04888417f, -0.09097664f, 
    -0.05753053f, -0.01220596f, 0.08256561f, 0.27064213f, 0.01879456f, -0.22108898f, -0.05356867f, -0.00266880f, 
    0.14877607f, 0.08419483f, 0.07294989f, 0.13785000f, 0.00117724f, 0.23756258f, 0.20010935f, 0.10023282f, 
    -0.01833089f, 0.05664725f, -0.12576650f, -0.02624875f, 0.04747309f, 0.10685132f, -0.04516717f, 0.00704754f, 
    0.03347479f, -0.00096963f, 0.13068883f, 0.05179648f, 0.05897509f, -0.10085412f, -0.26502264f, -0.03854211f, 
    -0.26740593f, -0.26763371f, -0.08413438f, 0.03319696f, 0.08578200f, 0.02113187f, -0.00775770f, 0.16298537f, 
    -0.02634690f, -0.11610298f, 0.14804636f, 0.02143372f, -0.03173462f, 0.04035100f, 0.07748086f, 0.10256080f, 
    0.00014493f, -0.13365135f, -0.25640118f, -0.15966167f, -0.07452855f, 0.08998247f, 0.16274826f, 0.11683054f, 
    -0.04511175f, -0.11900330f, -0.02308870f, -0.18015605f, 0.04240776f, -0.12794623f, -0.06684025f, 0.11212570f, 
    0.18301828f, 0.05647860f, 0.32927400f, -0.02681834f, -0.46015880f, -0.10843254f, 0.10639035f, 0.10304564f, 
    0.15727527f, 0.12529160f, 0.01778533f, 0.04070591f, -0.15476359f, -0.20321338f, -0.00803821f, 0.22325210f, 
    0.21417852f, 0.12694225f, 0.12965120f, 0.04440617f, -0.01422117f, -0.15560539f, 0.29198846f, 0.07532433f, 
    0.05090981f, 0.03350293f, 0.02382679f, -0.00327261f, 0.19046329f, -0.14186049f, 0.08200043f, 0.08233614f, 
    -0.19405693f, -0.11056920f, -0.10097262f, -0.05573940f, 0.07380849f, 0.05245611f, 0.13479389f, 0.11536142f, 
    0.08377139f, 0.15375522f, 0.11818317f, 0.02274638f, 0.06933446f, 0.07743128f, 0.10740779f, -0.34480727f, 
    -0.37200990f, -0.21850878f, -0.05825329f, 0.03778797f, -0.06622875f, 0.03310587f, -0.02405633f, 0.12224007f, 
    0.26756528f, 0.08191488f, -0.23205011f, 0.06832145f, -0.03991849f, -0.19164483f, 0.07258596f, -0.05139863f, 
    0.12633973f, 0.00131300f, 0.10775603f, 0.02659856f, -0.05512518f, 0.03523820f, -0.15328509f, -0.00094082f, 
    0.06445877f, 0.16064173f, 0.05376799f, -0.12644276f, -0.22215816f, -0.23523833f, -0.13695489f, 0.07943109f, 
    -0.02203357f, 0.03595209f, -0.18535958f, -0.25020435f, -0.13948460f, 0.17558220f, 0.03516099f, -0.00075159f, 
    -0.01016247f, 0.04593955f, -0.05945837f, -0.04769574f, 0.08188774f, -0.66089553f, -0.03619613f, 0.08845107f, 
    -0.15751810f, 0.03549292f, -0.15693113f, -0.06613652f, 0.04021099f, -0.41044462f, -0.22064874f, -0.20974739f, 
    -0.05756588f, -0.05694171f, -0.13456149f, -0.03910945f, -0.07260885f, -0.03001914f, 0.27430025f, 0.06638481f, 
    -0.01858322f, -0.15515871f, -0.04891193f, 0.07968162f, -0.01436078f, -0.02958804f, -0.05655571f, 0.15263282f, 
    -0.74899286f, -0.28854993f, 0.08416658f, 0.01307803f, -0.03627536f, -0.08308481f, -0.23043637f, 0.01208810f, 
    -0.03609040f, -0.04691456f, -0.01153608f, 0.02573677f, -0.00786965f, 0.01406519f, 0.02126301f, 0.00773889f, 
    0.00459974f, -0.05190105f, 0.04425057f, -0.05114501f, -0.05131710f, -0.00608561f, -0.04831037f, -0.01404451f, 
    0.02312494f, 0.01468721f, -0.06471035f, 0.04259183f, -0.03337164f, -0.03713727f, -0.02145963f, 0.03909800f, 
    -0.05545954f, -0.02037110f, -0.02958309f, -0.01067045f, -0.02541021f, -0.02900794f, -0.04425704f, -0.05210758f, 
    -0.02237925f, 0.03498084f, 0.04020498f, -0.01423004f, -0.04843519f, -0.04392254f, -0.04416287f, -0.00588407f, 
    -0.04829352f, 0.01412312f, -0.04927867f, 0.04006154f, -0.04835962f, -0.03221010f, 0.03130689f, -0.02442355f, 
    0.01420914f, -0.05275512f, -0.01544131f, -0.01863844f, 0.03733980f, -0.01748323f, 0.04952340f, -0.03134096f, 
    -0.01438931f, -0.03949523f, 0.01868964f, 0.04786744f, 0.03315719f, 0.04458301f, -0.05585267f, 0.00471933f, 
    -0.05211117f, -0.00062764f, -0.00909661f, -0.01490552f, 0.04761347f, 0.01794531f, -0.01810751f, -0.02493769f, 
    0.05107005f, 0.03949889f, -0.04718960f, 0.03013805f, 0.02185378f, 0.00815556f, -0.04293202f, 0.01668075f, 
    -0.04281566f, -0.05175707f, -0.05195692f, 0.04999520f, 0.00111551f, 0.03587297f, -0.05470592f, -0.04995468f, 
    -0.03249456f, -0.02212673f, 0.05334576f, -0.05071827f, -0.04346339f, 0.00735132f, 0.01498136f, 0.04963151f, 
    0.02922302f, -0.05500453f, 0.00685848f, -0.06109028f, 0.03655313f, -0.06164858f, 0.01615973f, -0.05155031f, 
    0.00611827f, -0.01435443f, -0.04163275f, 0.02182026f, 0.05536914f, 0.02268903f, -0.00926140f, -0.00188708f, 
    0.05281651f, 0.02723386f, 0.01344943f, -0.02759668f, -0.02206047f, -0.02236778f, -0.00727091f, 0.03642758f, 
    -0.04691935f, -0.03270588f, -0.05684844f, 0.02272280f, -0.05898370f, -0.01987826f, -0.04705064f, -0.04092996f, 
    0.03486360f, 0.02859959f, -0.06161911f, -0.05290718f, -0.04771114f, -0.02826492f, 0.00292138f, 0.02706695f, 
    0.03540696f, 0.00380158f, -0.02302493f, 0.04001718f, -0.02733324f, -0.03969596f, -0.01816651f, 0.00820843f, 
    0.04348718f, 0.02095815f, -0.01487547f, 0.05686937f, 0.01559887f, 0.01092526f, 0.04931044f, 0.04179245f, 
    0.00827461f, 0.03671277f, 0.00104801f, -0.01561449f, -0.02512203f, 0.04987665f, -0.04138435f, 0.00328337f, 
    -0.04503587f, 0.02440139f, -0.04869542f, -0.04214191f, -0.05024289f, 0.01340496f, -0.02548635f, 0.00952475f, 
    -0.00457651f, -0.03455555f, -0.02641729f, 0.04972975f, 0.00765894f, -0.03282299f, -0.01789370f, 0.00211849f, 
    0.00223808f, 0.02711743f, -0.00247517f, 0.04485808f, -0.05131040f, 0.02696687f, -0.04452289f, -0.00025723f, 
    -0.05317502f, -0.05334027f, -0.02869109f, -0.06488524f, 0.00949485f, -0.05131532f, -0.03232399f, 0.04793134f, 
    -0.00044614f, -0.00515964f, 0.02278891f, -0.04541433f, 0.00858016f, 0.01056570f, -0.02109138f, 0.00462228f, 
    0.00166618f, -0.03298652f, -0.04176139f, 0.01023798f, 0.00901042f, -0.01529323f, -0.01420045f, -0.02034377f, 
    0.03574268f, 0.03272993f, 0.02398317f, -0.01971832f, -0.05591629f, 0.00220544f, -0.04975071f, 0.01286655f, 
    0.03811759f, -0.01341793f, -0.05611986f, 0.01684998f, -0.03512381f, -0.01955187f, 0.01823194f, -0.01737962f, 
    -0.03328776f, -0.03871315f, -0.01255078f, 0.02640432f, -0.02607433f, -0.03473260f, 0.01806863f, 0.00500858f, 
    -0.00747088f, -0.04359576f, 0.03058214f, 0.03316575f, 0.05080141f, 0.02250058f, -0.02220395f, 0.00022242f, 
    0.03382909f, -0.02858174f, 0.02788732f, 0.00342560f, -0.03436515f, -0.03762386f, 0.00932169f, 0.03445601f, 
    0.05259528f, -0.00333407f, -0.00999458f, -0.05708080f, -0.05607359f, 0.00489203f, 0.03583569f, -0.03751481f, 
    -0.00975591f, 0.01897154f, 0.03219707f, -0.01394217f, 0.00070416f, 0.04658274f, -0.00774146f, -0.04121418f, 
    0.03791860f, 0.02351023f, 0.02127812f, -0.02457973f, -0.04160239f, -0.02379315f, 0.00413971f, -0.00524861f, 
    0.03022241f, -0.04017274f, 0.02077821f, 0.04794279f, -0.06190921f, -0.03412903f, 0.02115401f, 0.04579618f, 
    -0.00544925f, -0.05475101f, -0.03551805f, -0.02130829f, -0.05215195f, 0.03073412f, 0.04213012f, -0.05676910f, 
    0.37699741f, 0.06657566f, 0.05373746f, -0.02054785f, -0.00917636f, -0.18026258f, 0.09151606f, -0.00786460f, 
    -0.08841537f, -0.28986847f, -0.00101778f, 0.12875029f, 0.01498161f, 0.08574350f, -0.01702081f, 0.04872734f, 
    -0.00500207f, 0.07340082f, -0.03129682f, -0.20064776f, -0.26170272f, 0.06097764f, -0.10014100f, -0.04797043f, 
    -0.18620351f, -0.31620517f, -0.15706362f, -0.18563472f, -0.11498903f, -0.12941501f, -0.08663210f, -0.12576328f, 
    -0.00238164f, 0.23006538f, -0.03339699f, -0.09533032f, -0.08085720f, 0.07823227f, 0.02716237f, -0.12437717f, 
    0.06598255f, -0.15427297f, 0.13289495f, 0.01634334f, -0.06392013f, -0.28997633f, -0.04979167f, -0.09202283f, 
    -0.02250790f, 0.00579848f, -0.08998116f, 0.00714866f, 0.10090335f, 0.19127128f, 0.03138468f, -0.07953010f, 
    -0.00468558f, 0.09420478f, -0.05732998f, 0.08113283f, 0.11728171f, 0.05078981f, 0.23917180f, -0.29336396f, 
    -0.23249303f, -0.01735212f, -0.08334187f, -0.13478088f, -0.06062659f, 0.02928875f, 0.01776938f, 0.22324596f, 
    -0.09110617f, 0.00823336f, -0.00611421f, -0.04147349f, -0.12461459f, -0.00935332f, -0.01804641f, 0.11697301f, 
    0.16259667f, 0.37825540f, 0.19695938f, -0.28763118f, 0.05139063f, -0.11312491f, -0.00001930f, 0.13968666f, 
    0.05819682f, 0.05765691f, -0.10828389f, -0.16586673f, 0.07381213f, 0.04038048f, -0.00909716f, -0.07295506f, 
    0.08416376f, -0.04834176f, -0.04303122f, -0.02870927f, -0.02829023f, -0.07686904f, 0.00626146f, -0.03427074f, 
    0.01075539f, 0.05931799f, 0.09987782f, 0.06612547f, -0.07236170f, -0.26439273f, 0.01037230f, 0.01157161f, 
    0.01241013f, 0.01051791f, -0.00019641f, 0.01433353f, 0.16814943f, -0.12497077f, 0.06154898f, 0.21386877f, 
    0.10315496f, 0.03257574f, 0.13794476f, -0.06381109f, -0.02648271f, 0.06665661f, -0.06466189f, -0.29993433f, 
    0.02734538f, 0.04393770f, -0.12729928f, -0.05818713f, 0.22085592f, 0.04480820f, 0.07081027f, -0.00395095f, 
    -0.08948085f, -0.07385822f, 0.00889771f, 0.07801286f, -0.01220155f, 0.05226386f, 0.03702266f, 0.11985803f, 
    0.05711872f, -0.13750741f, 0.14062029f, -0.00924684f, -0.14472355f, -0.01182181f, 0.23820575f, 0.10889332f, 
    -0.02765694f, 0.04437472f, -0.21373160f, 0.08530838f, -0.11847465f, -0.05847803f, -0.08921954f, 0.09621664f, 
    -0.07108159f, -0.07237896f, 0.16830315f, -0.26634049f, -0.18557109f, 0.09498142f, -0.07641701f, 0.14605542f, 
    0.04235428f, 0.18729615f, 0.16461661f, -0.00092508f, 0.07377450f, 0.16759370f, -0.09971859f, 0.03935529f, 
    0.09857089f, 0.06705491f, 0.09098034f, 0.05335950f, -0.05092845f, -0.17508398f, 0.23078665f, 0.14040443f, 
    -0.00111917f, -0.03824868f, 0.00954698f, -0.01226006f, -0.08388163f, 0.21113259f, 0.05341220f, -0.17581068f, 
    0.00074233f, -0.13064499f, 0.02602387f, -0.06317145f, 0.02051815f, 0.03181450f, -0.12133541f, -0.22558349f, 
    -0.01878912f, 0.10975086f, 0.04951683f, -0.02474566f, 0.15625727f, -0.00248947f, 0.05447647f, 0.12732667f, 
    0.03751922f, 0.14418943f, -0.14215307f, -0.02742428f, 0.00490169f, -0.07567730f, -0.07126777f, -0.07862030f, 
    0.05163080f, -0.00220394f, -0.00620547f, -0.15180005f, -0.06536742f, -0.18546481f, 0.21269414f, 0.01840705f, 
    -0.02558511f, 0.15254565f, -0.11273548f, -0.09848773f, 0.09158044f, 0.09511520f, -0.18393067f, 0.12317973f, 
    0.00659274f, 0.31627518f, -0.17029183f, -0.04201856f, -0.08011932f, -0.15073958f, -0.09254852f, -0.19124179f, 
    0.16105056f, 0.03428581f, 0.12976815f, -0.01214446f, -0.28356397f, 0.18423307f, -0.10421436f, 0.30625442f, 
    -0.12462005f, 0.07215439f, -0.03273275f, 0.02631722f, -0.28262037f, -0.19436632f, 0.04658083f, -0.11492923f, 
    -0.00611238f, 0.14892298f, -0.04599452f, 0.08283824f, 0.05663374f, 0.13848497f, -0.11828040f, -0.08119134f, 
    -0.13173756f, 0.00116768f, -0.36873588f, 0.18824086f, 0.05550479f, 0.10389856f, -0.11935529f, -0.06231523f, 
    0.09725810f, 0.01275472f, -0.05500054f, 0.04706449f, -0.04983119f, 0.01053545f, 0.19076139f, 0.18269540f, 
    0.12743349f, -0.18694599f, -0.24205366f, -0.01095667f, -0.08791152f, -0.02515752f, -0.00434195f, -0.13403720f, 
    0.00254594f, 0.01138496f, -0.13111083f, -0.19900385f, -0.15000142f, -0.17088424f, 0.03920579f, -0.02156564f, 
    -0.08795166f, 0.12003641f, 0.15585279f, 0.06466432f, 0.07975329f, 0.07394966f, 0.09725638f, -0.04439741f, 
    -0.08586233f, 0.08700307f, 0.23251837f, 0.01926650f, -0.06769972f, 0.16975729f, -0.30521691f, -0.27328619f, 
    -0.04615885f, -0.06388444f, 0.01574216f, -0.00176412f, 0.10156597f, 0.07874773f, -0.04587873f, 0.03437360f, 
    0.08852077f, -0.07438386f, -0.07930757f, 0.11241263f, -0.14548376f, 0.05788414f, -0.10765493f, -0.01678204f, 
    -0.09098303f, -0.04240653f, -0.00616224f, 0.05876127f, -0.01389572f, -0.21953402f, -0.13413912f, -0.04996386f, 
    -0.05688817f, -0.17143838f, 0.11153343f, -0.02225105f, 0.12740947f, 0.01603476f, 0.46865991f, 0.12666829f, 
    0.10726412f, -0.13379033f, 0.05832014f, 0.04902507f, 0.14837679f, 0.00560069f, -0.01009191f, 0.33301651f, 
    0.17360510f, 0.25728121f, 0.04617357f, 0.06793423f, 0.09747080f, 0.15337923f, 0.10415695f, 0.00906184f, 
    -0.00982028f, -0.42370582f, -0.25494576f, 0.02599281f, 0.04200857f, -0.02526915f, 0.00083278f, 0.00121270f, 
    0.04534737f, -0.19697815f, -0.38715208f, -0.21366197f, -0.03828295f, -0.04773054f, 0.09027791f, 0.06187458f, 
    0.02834634f, -0.05143824f, 0.28577402f, 0.22034347f, 0.25943717f, 0.05630962f, -0.09182484f, 0.03294553f, 
    0.01167686f, -0.10570661f, 0.00712233f, -0.21382384f, -0.06668354f, -0.03182363f, 0.09364133f, 0.08866355f, 
    0.02548002f, 0.02336997f, 0.02829592f, 0.03632030f, 0.07140064f, 0.09120539f, 0.18225665f, 0.07630935f, 
    0.09258965f, 0.14506507f, 0.10964481f, 0.13986793f, 0.01276986f, 0.07632323f, 0.11053926f, -0.03136823f, 
    0.03436735f, 0.11527697f, 0.16252892f, 0.07438565f, -0.03613835f, -0.03209501f, 0.13841726f, 0.25641197f, 
    0.13722144f, -0.03069873f, 0.05861306f, 0.11984608f, -0.00493523f, 0.06334703f, 0.04145627f, -0.39201719f, 
    -0.42499116f, 0.10327554f, 0.01798899f, 0.07527472f, 0.02274541f, 0.06370920f, -0.01350297f, 0.05891030f, 
    0.14330593f, 0.04333287f, -0.02256388f, -0.13075134f, -0.18338475f, -0.10084973f, 0.06327204f, -0.00855597f, 
    0.09813488f, 0.22208187f, -0.07917648f, -0.27419850f, 0.02381850f, -0.02997603f, -0.13581437f, 0.13228685f, 
    0.01564785f, 0.04678348f, -0.17150594f, -0.07249300f, 0.12463319f, -0.06915498f, 0.10333944f, 0.00877965f, 
    0.12145268f, -0.14187212f, -0.15894279f, -0.17299168f, 0.06321402f, -0.31563807f, 0.08746206f, -0.03229787f, 
    0.12847158f, -0.05359938f, -0.02147495f, -0.02788310f, -0.11025127f, 0.14819404f, 0.13059017f, -0.10459833f, 
    0.03327766f, 0.11030684f, -0.02889536f, 0.00748194f, 0.09433350f, 0.20825928f, -0.09865770f, -0.13692652f, 
    -0.03182998f, -0.25164276f, -0.10565082f, -0.07666437f, 0.04796966f, -0.08835111f, 0.10976368f, -0.05841929f, 
    0.03540487f, -0.08272598f, -0.13112292f, 0.00662623f, -0.03511865f, 0.04939926f, 0.00086260f, 0.07590050f, 
    0.15343265f, 0.07073287f, -0.12947421f, 0.06430066f, -0.06117716f, 0.04004726f, -0.00559932f, -0.00985909f, 
    0.07875394f, -0.61599720f, -0.38167882f, -0.11162693f, -0.05097618f, 0.08237875f, -0.01337373f, 0.14515615f, 
    0.11752108f, 0.07094003f, 0.00539934f, 0.13771755f, -0.09251060f, 0.11963217f, -0.10748233f, -0.08918776f, 
    0.08736020f, -0.01899018f, -0.14607833f, -0.31347594f, -0.52935469f, -0.21066360f, -0.16252927f, 0.10192323f, 
    -0.15720183f, 0.11926857f, -0.12574387f, -0.08166379f, -0.28549802f, -0.11749526f, -0.00382968f, -0.03321232f, 
    0.09433067f, 0.06455487f, 0.00814004f, -0.06626178f, -0.37953249f, -0.57987779f, -0.24936554f, -0.01341915f, 
    -0.06679658f, -0.12363431f, 0.13784602f, 0.08503984f, -0.10616874f, -0.95622295f, -0.61505425f, 0.23332611f, 
    0.04052668f, 0.18310422f, 0.06040106f, 0.02378481f, 0.01571939f, 0.10188645f, 0.62515479f, 0.01401578f, 
    -0.02536600f, -0.00296958f, 0.02334408f, 0.04317572f, 0.14518532f, 0.00834890f, 0.03582587f, -0.40416619f, 
    -0.69168007f, -0.48096246f, 0.12547992f, -0.19498292f, -0.05865699f, 0.12681776f, 0.13861832f, -0.15293266f, 
    -0.44252026f, 0.31472835f, 0.00485303f, -0.06295427f, -0.10531186f, -0.06494483f, 0.10320371f, 0.03931912f, 
    0.01892396f, -0.14091198f, 0.09869715f, -0.31331119f, -0.09492695f, 0.03202902f, 0.08042397f, 0.02322778f, 
    0.07304627f, -0.00158637f, 0.15862420f, -0.15654044f, 0.08053851f, 0.09973204f, 0.20486243f, -0.02342834f, 
    0.03701054f, -0.02177927f, -0.20951630f, -0.25683793f, -0.13822657f, 0.46811804f, 0.00664654f, -0.01068477f, 
    -0.04835211f, 0.04478086f, 0.05502508f, 0.01039069f, 0.16438261f, 0.27971217f, -0.20261079f, 0.14194600f, 
    -0.11475075f, 0.16529952f, 0.17291252f, 0.21096876f, -0.01404764f, 0.10412492f, 0.29147896f, -0.13143623f, 
    -0.30864924f, -0.13265124f, -0.00690721f, 0.00394131f, -0.02761864f, -0.14297456f, 0.05296117f, -0.14505444f, 
    -0.08865129f, -0.07063989f, 0.09794293f, -0.11131293f, 0.06231494f, 0.04222397f, -0.17186359f, -0.46989483f, 
    -0.10572035f, -0.62634206f, -0.07306156f, -0.15176611f, 0.14735390f, 0.02249566f, 0.05869133f, -0.12934549f, 
    0.21264237f, 0.07541923f, 0.08723214f, -0.28484181f, -0.16130540f, -0.11758002f, 0.02128438f, 0.01643205f, 
    0.09397088f, 0.13888359f, -0.02648346f, -0.13680120f, 0.04790786f, 0.25241983f, 0.12127738f, -0.15936534f, 
    -0.08867709f, 0.02421359f, -0.31136051f, -0.13114388f, -0.32982326f, 0.02690087f, 0.03029640f, 0.07577545f, 
    0.04393340f, -0.03587517f, -0.19293807f, 0.17331161f, -0.14462988f, 0.02745318f, -0.10386645f, -0.05438069f, 
    -0.04616547f, 0.11297433f, 0.03357792f, 0.03434726f, -0.46141762f, -0.33859786f, -0.37586305f, -0.07081030f, 
    -0.01796276f, -0.01497435f, -0.02425293f, -0.03644385f, 0.02321760f, -0.29507542f, -0.67492115f, -0.37953380f, 
    -0.08722776f, 0.12180521f, 0.03758540f, 0.02100890f, -0.08887657f, 0.06429650f, -0.00241440f, -0.13781831f, 
    -0.13524352f, 0.09857941f, -0.07643235f, 0.05123013f, 0.11334518f, -0.14488222f, -0.03700205f, 0.15224998f, 
    0.19926700f, 0.09887765f, 0.22630383f, 0.00179667f, 0.04416143f, 0.11824921f, -0.10640684f, 0.04594235f, 
    -0.28806317f, 0.18668999f, 0.12016427f, -0.05683443f, 0.18907852f, 0.00960186f, 0.12802114f, -0.05814745f, 
    0.01280168f, 0.13870880f, 0.06090779f, -0.02944082f, 0.00070936f, -0.15386906f, -0.03592949f, 0.18233190f, 
    -0.03557396f, 0.00848798f, -0.03954276f, -0.14458165f, -0.00910215f, 0.13121055f, -0.10070141f, -0.13863868f, 
    0.02916368f, 0.07597987f, 0.03894325f, -0.31243861f, -0.25792745f, 0.13589920f, 0.05887785f, 0.08789581f, 
    -0.09910618f, 0.02424581f, -0.00113539f, -0.07500422f, -0.03835356f, 0.20932312f, -0.27878246f, 0.09154560f, 
    -0.04035144f, 0.07600227f, 0.12450013f, 0.01591089f, -0.15341836f, 0.16163799f, -0.04319123f, -0.02467571f, 
    0.10853645f, 0.02325366f, 0.01810451f, -0.04327844f, 0.01937126f, 0.09005696f, -0.27358848f, 0.25158378f, 
    0.15218572f, -0.07447024f, 0.04046041f, 0.01980855f, 0.18505034f, 0.06138450f, -0.03311028f, -0.26527667f, 
    0.29286513f, 0.23272234f, 0.11160455f, 0.17983703f, 0.01431989f, 0.00706564f, -0.03444854f, -0.00741134f, 
    0.17113686f, 0.14803557f, 0.07542042f, 0.05248887f, -0.13862588f, -0.18549965f, -0.07145368f, -0.18297398f, 
    -0.22215608f, -0.06351206f, 0.42585966f, 0.00648225f, 0.17649648f, -0.06551022f, 0.08685709f, 0.03143310f, 
    0.16050415f, 0.02481375f, 0.26587233f, 0.12240046f, -0.06366954f, -0.28067777f, -0.25553650f, -0.09032820f, 
    0.06762291f, -0.10769612f, 0.00556102f, 0.12956622f, 0.24513894f, -0.11087310f, -0.15851386f, -0.02889968f, 
    -0.05117095f, -0.02015904f, -0.08959496f, -0.16315465f, -0.15848058f, 0.55262703f, -0.16279513f, -0.08102252f, 
    0.27782658f, -0.13415365f, 0.07749888f, -0.10694369f, 0.18931539f, 0.30413470f, -0.15724461f, 0.00284408f, 
    -0.21182323f, -0.19391337f, -0.35263947f, 0.07156253f, -0.18409207f, -0.08620230f, 0.12692074f, -0.30338365f, 
    -0.51921606f, -0.00448109f, 0.12404211f, 0.10314225f, 0.15509667f, -0.01983183f, -0.03419819f, 0.32109314f, 
    0.06220058f, -0.41088271f, -0.14900327f, 0.23421505f, -0.05460199f, -0.01189183f, -0.04018543f, 0.09816507f, 
    0.15591235f, -0.10673903f, -0.08350274f, 0.13409634f, 0.08576015f, -0.11955880f, 0.06403939f, -0.01569835f, 
    -0.12120909f, -0.14213841f, 0.08869673f, 0.24575219f, 0.04457743f, 0.03757400f, -0.00427483f, 0.02472850f, 
    0.07968288f, 0.08407450f, -0.05924662f, -0.09653723f, -0.25448015f, -0.12804298f, -0.11553778f, 0.03451116f, 
    0.03259975f, 0.02699839f, 0.18628792f, 0.00394548f, -0.45803556f, -0.57979912f, -0.25907898f, -0.03252386f, 
    -0.10429234f, -0.07926022f, -0.10152820f, -0.00820020f, -0.06876000f, -0.18151650f, 0.10618348f, 0.01274828f, 
    0.05768843f, 0.00732339f, 0.11904696f, 0.02522565f, 0.00130641f, -0.22554027f, -0.09126818f, 0.20305809f, 
    -0.02498632f, -0.12246899f, -0.04850838f, 0.06291664f, 0.09779935f, 0.09904930f, 0.03990194f, -0.06914113f, 
    0.09044555f, 0.19872931f, 0.04106894f, 0.13113464f, 0.11233664f, 0.06655409f, 0.18188405f, 0.18143487f, 
    -0.23136140f, 0.11799910f, -0.19379264f, -0.12125900f, 0.02220620f, 0.00300784f, 0.07891998f, 0.06136554f, 
    -0.13110305f, 0.04377973f, 0.01725526f, -0.06531347f, -0.10352255f, -0.10348324f, -0.10400884f, -0.02799492f, 
    0.03457284f, 0.09675217f, -0.02320663f, -0.04841265f, 0.06689863f, -0.10271893f, -0.01811928f, 0.04797876f, 
    -0.09236104f, -0.03678471f, -0.22015749f, -0.25106025f, -0.10407767f, -0.01971943f, 0.02518214f, -0.23316064f, 
    -0.01967670f, -0.01367405f, -0.07409227f, 0.10299197f, 0.07279510f, 0.10656775f, 0.03199381f, 0.12636334f, 
    0.06123270f, 0.05851208f, -0.02863294f, 0.11029579f, 0.00005777f, 0.11636569f, 0.15192132f, -0.10843964f, 
    0.04407233f, -0.01947446f, 0.14414534f, 0.12560198f, -0.03549707f, 0.03500347f, 0.13633418f, 0.47930837f, 
    0.05688769f, -0.03437654f, 0.00159485f, -0.15768728f, 0.05741785f, 0.00710577f, -0.33151436f, -0.54421085f, 
    -0.37058091f, -0.27387092f, -0.09676313f, -0.03791760f, -0.07171231f, -0.00199182f, 0.07187553f, 0.13396077f, 
    0.11918931f, 0.00532168f, 0.03228729f, 0.08181249f, 0.09983049f, -0.05263265f, 0.15891677f, 0.19510463f, 
    -0.10852715f, -0.35218793f, -0.38790104f, -0.03623180f, -0.11505815f, 0.02874873f, 0.06464799f, -0.08671378f, 
    0.10423723f, 0.03719692f, 0.18871561f, 0.25753674f, -0.03627340f, 0.14974447f, 0.05397633f, 0.09011762f, 
    -0.03428463f, 0.04861039f, 0.24791597f, -0.11854666f, -0.14000067f, -0.06485844f, 0.05935378f, 0.14021558f, 
    -0.15110032f, 0.04233383f, -0.11001746f, 0.11811471f, 0.36444637f, 0.13012384f, -0.12227707f, 0.09410451f, 
    0.10974743f, 0.00051902f, -0.08972048f, -0.15249626f, -0.31730250f, -0.04417115f, 0.20167793f, 0.04658020f, 
    -0.06227775f, -0.05635070f, 0.04024449f, -0.01287951f, -0.05228803f, 0.16215725f, -0.20174553f, 0.05361986f, 
    -0.05570598f, -0.02596634f, -0.01376554f, 0.02263267f, 0.09473049f, -0.18005390f, -0.04747472f, -0.27469304f, 
    -0.27047107f, 0.11281295f, -0.00894001f, -0.01518950f, 0.12853646f, 0.02234307f, -0.00237163f, 0.10284762f, 
    0.16502930f, -0.36629978f, 0.02516803f, -0.05310658f, -0.04100575f, -0.06829093f, -0.10061743f, -0.23025542f, 
    0.16551258f, -0.01969724f, -0.12926939f, -0.11563535f, -0.16609481f, -0.16699444f, 0.08800302f, 0.01155419f, 
    0.02089034f, 0.10071494f, -0.14188680f, -0.05071350f, -0.01388035f, 0.05628813f, 0.04690141f, 0.11353547f, 
    -0.06742479f, -0.06231636f, -0.17350511f, -0.18559666f, -0.03234841f, -0.14547507f, -0.06160765f, 0.01768665f, 
    0.08807915f, -0.04865415f, 0.05913172f, -0.14119689f, -0.00098634f, 0.30113485f, -0.13673429f, -0.02494088f, 
    -0.18452892f, 0.00543418f, -0.05578245f, 0.05383992f, -0.21315597f, -0.49057046f, -0.09746810f, 0.05344272f, 
    -0.15391269f, -0.01834690f, -0.03736442f, -0.03683178f, -0.00167739f, -0.27722302f, -0.21554998f, 0.22748151f, 
    -0.13261165f, -0.15722595f, -0.02066148f, 0.03144705f, 0.00545146f, 0.01454263f, 0.03371235f, 0.21196853f, 
    0.07580151f, -0.20508510f, -0.09421968f, 0.08451209f, -0.02463611f, -0.00589010f, 0.18866698f, 0.21088377f, 
    -0.48194361f, -0.06910811f, 0.23848332f, -0.03159047f, 0.04940982f, -0.19327271f, -0.15327305f, -0.06055127f, 
    0.10430968f, 0.09506782f, 0.10797714f, 0.00486030f, -0.06560413f, 0.07327864f, 0.07204308f, 0.09632044f, 
    0.08475059f, 0.10820568f, 0.07559664f, 0.11428462f, -0.19555864f, 0.04970480f, -0.12902866f, 0.08835635f, 
    0.14153625f, 0.06920885f, 0.08622070f, -0.05910247f, -0.30300695f, -0.12459110f, 0.06698914f, -0.03393913f, 
    0.07221206f, 0.17475820f, -0.06004522f, -0.35405678f, 0.34682062f, 0.02720525f, -0.06627350f, 0.07991348f, 
    -0.11692904f, -0.08919023f, -0.11322370f, 0.01172441f, -0.18372737f, -0.03944175f, 0.10149878f, -0.16914223f, 
    0.12566286f, -0.10128860f, 0.15061705f, 0.09558550f, 0.01841652f, 0.23965757f, 0.03785888f, 0.08666614f, 
    -0.06708152f, -0.06838066f, -0.30859327f, -0.02799670f, 0.06023435f, 0.01303325f, -0.10817584f, 0.17157096f, 
    0.12006783f, 0.00565126f, -0.03158513f, 0.11535657f, -0.00726124f, 0.03940558f, 0.07372565f, -0.59071761f, 
    -0.24779785f, 0.27636388f, -0.16699325f, 0.13460834f, -0.14505483f, -0.03525790f, -0.12818478f, 0.00643983f, 
    -0.09326829f, -0.22312216f, 0.14391442f, 0.07498404f, -0.05816809f, 0.16536348f, 0.11325168f, 0.00462802f, 
    0.06438693f, -0.12085796f, -0.30710056f, -0.32693315f, 0.02138242f, 0.06502388f, 0.05552686f, 0.03782139f, 
    -0.15785719f, 0.13173813f, 0.01039670f, 0.12050432f, 0.21407188f, -0.19384651f, -0.07494110f, -0.37359226f, 
    0.06674611f, 0.12345354f, 0.07658525f, -0.14524363f, 0.05479002f, -0.20637880f, -0.02339418f, 0.21772501f, 
    -0.10286357f, -0.07680918f, -0.03924859f, 0.08190219f, -0.27056432f, 0.05438883f, -0.14002621f, 0.14123821f, 
    -0.06017089f, 0.12250470f, -0.04819578f, -0.10842643f, 0.03500640f, 0.04632984f, 0.29813498f, 0.16679996f, 
    0.03295828f, -0.10857935f, 0.02233322f, 0.02557326f, 0.03611218f, -0.08860452f, -0.25897190f, 0.06376732f, 
    0.21860638f, -0.08725441f, -0.02050593f, 0.04752129f, 0.14731595f, -0.01834654f, 0.09480035f, -0.35853064f, 
    0.02112840f, 0.14302148f, 0.00948721f, -0.12942713f, 0.06637648f, -0.01323188f, 0.10572170f, 0.19641058f, 
    0.19179347f, 0.09977210f, -0.02077629f, 0.00320306f, -0.01647822f, 0.24659704f, 0.05305776f, -0.10420144f, 
    0.05904267f, -0.47902274f, -0.51438028f, 0.14592935f, -0.28801513f, 0.06811739f, -0.12728782f, 0.10093138f, 
    -0.02885343f, -0.01697972f, -0.21943901f, -0.11145448f, -0.14783743f, 0.09375163f, 0.10876593f, -0.00471089f, 
    -0.15120995f, 0.07666397f, 0.00545548f, -0.30808109f, 0.16742097f, 0.15743349f, 0.06458008f, -0.06200706f, 
    0.05515449f, -0.12234536f, -0.01852428f, 0.01590061f, 0.08975041f, 0.13729240f, 0.35627440f, 0.01236053f, 
    0.00344549f, -0.22996899f, 0.07908483f, 0.05733700f, 0.10953318f, 0.31348190f, 0.35368112f, -0.18198200f, 
    0.02737611f, 0.00802081f, -0.07843241f, 0.01837610f, -0.04493107f, 0.03297284f, -0.14884375f, 0.20161463f, 
    0.30246273f, 0.00623020f, 0.01813445f, -0.13118765f, -0.03844792f, 0.19422799f, -0.02997854f, -0.19412084f, 
    0.21371566f, 0.02878463f, 0.01808191f, 0.00751297f, 0.06138612f, 0.05930658f, -0.10108257f, -0.12919952f, 
    -0.56115067f, 0.09037057f, -0.18637714f, 0.02060768f, 0.01181853f, -0.12552090f, 0.04444790f, 0.08015168f, 
    -0.08414449f, 0.09127329f, 0.12396726f, 0.01456832f, 0.03170776f, 0.18051010f, -0.08176383f, -0.05862078f, 
    0.24799515f, -0.00608831f, -0.05451073f, -0.25007141f, -0.30326569f, -0.27594894f, 0.16300760f, -0.12360023f, 
    0.11299346f, -0.20947745f, -0.10863700f, 0.18707530f, 0.13062923f, 0.13319850f, 0.06386773f, -0.11557076f, 
    -0.02921626f, -0.00343960f, 0.02692071f, -0.10775051f, -0.34427914f, 0.24857114f, 0.47787452f, 0.00494896f, 
    -0.05392820f, -0.01624231f, -0.13400973f, -0.01255255f, -0.00362628f, -0.47554454f, -0.02019669f, -0.45693064f, 
    -0.03493963f, -0.32160047f, -0.10479511f, 0.07015882f, 0.00325323f, -0.08944099f, -0.09917971f, -0.33035654f, 
    -0.10246067f, -0.01647233f, -0.08442278f, 0.17689431f, -0.00051954f, -0.08310483f, 0.09972869f, -0.29900199f, 
    -0.03791056f, -0.03217411f, 0.04014228f, 0.03990904f, 0.11632945f, -0.09896697f, -0.11073327f, 0.04776795f, 
    0.02704282f, 0.05055398f, -0.00424909f, -0.04045410f, -0.02363458f, -0.06322800f, -0.06505686f, -0.00064633f, 
    -0.05332826f, 0.01193039f, 0.02266498f, 0.04685158f, -0.05451202f, -0.02648406f, 0.00747183f, 0.01667565f, 
    0.00858019f, 0.01733525f, -0.03970575f, -0.01204149f, 0.00792065f, -0.06324168f, -0.00456043f, 0.00342928f, 
    0.02931202f, -0.00871230f, 0.01392797f, 0.00944133f, -0.03528566f, -0.03386388f, 0.01051731f, -0.03569048f, 
    -0.00709905f, -0.02494276f, -0.04430511f, -0.06188171f, -0.04739689f, -0.04320817f, -0.01228095f, -0.00707720f, 
    0.05202523f, -0.04218789f, -0.01070731f, 0.02341527f, 0.02935407f, 0.00271409f, -0.04357756f, -0.04764459f, 
    -0.02633175f, 0.02158277f, 0.04505770f, -0.04262685f, -0.05818998f, -0.04598817f, 0.01962801f, 0.04426850f, 
    -0.02507528f, -0.05955584f, 0.00274679f, 0.02038635f, -0.01803310f, -0.01891777f, 0.01021343f, 0.04837660f, 
    0.02528156f, -0.02216030f, -0.00962399f, -0.03958499f, -0.00422053f, 0.00056142f, 0.00997946f, -0.04366620f, 
    0.00164796f, -0.01701950f, -0.01200069f, 0.05306843f, 0.00984129f, -0.03744884f, 0.04770928f, 0.03490714f, 
    -0.06038907f, 0.03704684f, 0.03318872f, -0.00653921f, -0.02998803f, 0.00431040f, -0.02466487f, 0.00715737f, 
    0.04126383f, -0.05415425f, -0.05340239f, 0.00233500f, -0.05655059f, -0.02896721f, -0.01522276f, -0.02911703f, 
    -0.00089115f, 0.03895826f, 0.01462113f, -0.02397650f, -0.03187640f, -0.06013460f, -0.01062438f, -0.05834572f, 
    0.02611282f, -0.01178642f, 0.02491420f, 0.02707939f, -0.03997703f, 0.00535208f, -0.01336140f, -0.04692400f, 
    -0.04010578f, -0.03035332f, 0.04948302f, -0.02017674f, -0.00277033f, 0.02777964f, 0.03937799f, -0.02601852f, 
    -0.00523835f, -0.04745135f, 0.00799392f, -0.05170471f, -0.03591733f, -0.02859303f, 0.01262471f, -0.04592793f, 
    -0.03485492f, -0.05797088f, -0.02735115f, 0.00875977f, -0.03465262f, -0.01261903f, 0.01946361f, -0.02498600f, 
    0.01826712f, 0.03330839f, 0.00588189f, 0.03716147f, 0.00021773f, 0.03731666f, -0.03379949f, -0.02156141f, 
    0.02915752f, 0.02825338f, 0.01530567f, 0.04685206f, 0.02473843f, 0.00733339f, -0.03416348f, -0.02234940f, 
    -0.04995518f, -0.06481585f, 0.03389602f, 0.01981121f, 0.02334380f, 0.05679495f, 0.04241094f, -0.01559976f, 
    0.03118385f, -0.01315291f, -0.05681097f, 0.02999131f, -0.05033824f, 0.02453736f, 0.02253599f, -0.04566227f, 
    -0.00748566f, 0.02881326f, -0.03044818f, -0.05464640f, -0.02965215f, -0.04265669f, -0.03913051f, -0.00606329f, 
    -0.02074775f, -0.00548714f, 0.01108563f, 0.02615185f, -0.03110692f, 0.05309171f, -0.06086200f, -0.05811850f, 
    0.03189575f, -0.04555454f, -0.03314366f, 0.03756411f, -0.00467788f, -0.04390102f, -0.00169949f, -0.00256055f, 
    0.03909155f, 0.03338199f, -0.03287084f, 0.03870776f, -0.00952533f, 0.04492919f, 0.03441624f, -0.02408513f, 
    0.01215304f, -0.01787093f, 0.04957531f, 0.03432874f, -0.02307018f, 0.02167298f, 0.02968626f, 0.05926519f, 
    0.02067428f, -0.04887030f, -0.00767498f, -0.05543656f, -0.04005619f, -0.03347936f, -0.02078840f, 0.00749702f, 
    -0.05932511f, 0.00390981f, -0.06120512f, 0.05065647f, -0.04006943f, 0.04192740f, -0.03950768f, -0.02737614f, 
    0.02139753f, -0.05935363f, 0.04670415f, -0.00504202f, -0.00934335f, -0.02893239f, -0.00590912f, -0.01555701f, 
    -0.00851066f, -0.04117317f, -0.02463744f, -0.05739322f, 0.03076186f, -0.05893087f, 0.05172686f, -0.03694907f, 
    0.00035847f, -0.03217414f, 0.04469312f, -0.04473056f, -0.05013285f, 0.02577472f, -0.02310254f, 0.00537451f, 
    0.00701184f, 0.02272285f, 0.03953806f, -0.00048612f, 0.02962379f, -0.00708702f, 0.03187111f, 0.04257711f, 
    0.00085069f, 0.00999871f, 0.00237754f, 0.03307228f, -0.02553213f, 0.04030035f, -0.02081011f, 0.03063017f, 
    -0.05193802f, -0.06193121f, 0.01621760f, 0.01033446f, -0.00461689f, -0.03485086f, -0.00218406f, 0.01223269f, 
    -0.06107796f, -0.04126782f, -0.00993767f, 0.04740829f, -0.04748758f, -0.02894539f, -0.05793616f, 0.00634973f, 
    -0.06107914f, 0.04177833f, 0.01198304f, -0.02208413f, 0.04125687f, -0.04250482f, -0.00677320f, -0.03086285f, 
    -0.03080485f, -0.04936188f, 0.04386402f, 0.02806782f, -0.02219927f, -0.00917866f, 0.01613421f, -0.00060863f, 
    -0.03972152f, -0.05118766f, 0.03123090f, 0.02808609f, -0.00446066f, -0.03167059f, 0.01697391f, 0.03734675f, 
    0.01815874f, 0.04023214f, 0.05565372f, -0.01178914f, -0.05087914f, -0.02271570f, 0.03809011f, -0.00036202f, 
    -0.03141310f, 0.05573284f, -0.00254475f, 0.01413203f, -0.02233513f, -0.04325236f, 0.04886061f, -0.02734385f, 
    0.02882442f, -0.04514097f, -0.03773290f, -0.06569197f, 0.02305569f, -0.04291625f, -0.00026134f, 0.01292540f, 
    -0.05306000f, 0.03925774f, 0.01459290f, 0.00193700f, -0.06725811f, -0.01495839f, 0.03984676f, 0.01819856f, 
    -0.05177392f, 0.01215056f, -0.03394675f, -0.03472120f, -0.06659641f, 0.01749072f, -0.03492649f, 0.00292903f, 
    -0.02975354f, 0.02135916f, -0.03330465f, 0.03395434f, 0.02695466f, -0.06860962f, -0.07326017f, 0.01890113f, 
    0.01276368f, 0.00985125f, 0.03038559f, 0.01021063f, -0.02742481f, 0.04230040f, -0.01701482f, -0.02699059f, 
    0.02827585f, -0.01032178f, 0.04697953f, 0.01650611f, -0.00964280f, -0.02535664f, 0.03478995f, -0.01874664f, 
    -0.04326901f, -0.03448812f, 0.02123998f, 0.03246234f, -0.01609961f, -0.05222443f, 0.00082510f, -0.05305566f, 
    -0.02736787f, -0.01009801f, -0.00801568f, 0.01098253f, -0.01697728f, -0.00140253f, 0.00143141f, -0.02228937f, 
    -0.04924568f, 0.03448654f, 0.00374545f, -0.00538786f, -0.02835720f, -0.01037619f, -0.02949409f, -0.00609289f, 
    0.02487044f, -0.05631614f, -0.00341366f, -0.06319762f, 0.04515737f, -0.01433641f, -0.05157759f, 0.00895257f, 
    0.02155448f, 0.00879420f, -0.06849560f, 0.00047109f, -0.00975438f, -0.02728020f, -0.06727964f, -0.03430356f, 
    -0.06236880f, -0.06312595f, 0.01452767f, -0.01305168f, -0.00605835f, -0.05577195f, -0.00150554f, 0.00138938f, 
    0.04812142f, 0.03747606f, -0.03846712f, -0.05817379f, -0.02448714f, -0.04101184f, -0.03658794f, -0.02359583f, 
    -0.02442762f, -0.04413691f, -0.00603609f, -0.04192095f, -0.05529943f, -0.02571181f, -0.04776505f, -0.01819073f, 
    0.04616936f, 0.03636325f, -0.05519811f, -0.02795063f, 0.00731521f, -0.04876660f, 0.00594645f, 0.03084753f, 
    -0.01752652f, -0.00566519f, 0.02196880f, 0.05446883f, -0.04439709f, 0.00899337f, 0.02551043f, -0.05429446f, 
    -0.04400223f, -0.01954522f, 0.03609512f, 0.01466538f, -0.04054292f, -0.06331183f, 0.00486987f, 0.00654907f, 
    -0.05146291f, -0.05353581f, -0.04557654f, 0.02719743f, 0.02890895f, 0.04368480f, -0.00863557f, -0.04384134f, 
    -0.05937197f, -0.06379828f, -0.04265420f, -0.03847760f, -0.05113932f, -0.04169168f, 0.02709639f, 0.01252029f, 
    0.01478468f, -0.05041983f, -0.00337034f, -0.02052306f, -0.00864878f, 0.01674740f, -0.01254761f, 0.03228555f, 
    -0.04111480f, 0.04095721f, 0.04315813f, -0.00626960f, -0.00460660f, -0.04557800f, 0.02491512f, 0.02559596f, 
    0.02075994f, -0.05641215f, -0.06637119f, 0.01797478f, 0.00588342f, -0.01998711f, 0.01890331f, -0.01552829f, 
    -0.05720144f, 0.02451509f, 0.04483113f, -0.01892440f, 0.00681784f, 0.04607181f, 0.00052924f, -0.03889520f, 
    0.04248485f, 0.04962045f, -0.04859062f, 0.03741862f, -0.01456382f, -0.04281895f, 0.04297393f, 0.02155881f, 
    0.02692091f, 0.04114307f, -0.05719037f, 0.00165613f, 0.01473800f, -0.03399846f, 0.04170160f, -0.06804033f, 
    -0.05867976f, -0.05769147f, 0.01311621f, -0.03853932f, -0.00862728f, 0.02482601f, 0.05497891f, 0.01603766f, 
    -0.02474116f, -0.02034192f, -0.00428901f, 0.05021465f, 0.00848474f, -0.01114888f, 0.04874475f, -0.00404293f, 
    0.01923551f, -0.04432416f, -0.04458205f, 0.00505711f, 0.04597038f, -0.04822522f, 0.02847911f, -0.01434210f, 
    0.03839023f, -0.04043779f, -0.03161752f, 0.03578363f, 0.00510877f, -0.02379635f, 0.01578335f, -0.02462940f, 
    -0.06494831f, -0.04098487f, -0.05597610f, 0.03056275f, 0.03696234f, -0.02955747f, 0.00069332f, 0.00091029f, 
    -0.04270362f, -0.06962018f, -0.04253304f, -0.01551594f, 0.03496331f, -0.05633534f, -0.06521118f, -0.00764452f, 
    -0.02865522f, -0.04219402f, -0.04285389f, 0.04244776f, 0.01174010f, -0.02233046f, 0.02361990f, 0.02709075f, 
    -0.02938802f, 0.01802245f, 0.00145418f, 0.02351844f, -0.01224713f, -0.05132256f, 0.04726660f, -0.01181449f, 
    0.03846670f, 0.03094808f, 0.02861181f, 0.02759896f, -0.01647153f, 0.00648329f, -0.07014241f, -0.02511370f, 
    0.04202211f, 0.02086988f, 0.05146713f, -0.04790917f, -0.06541440f, 0.00479899f, 0.03121133f, -0.03128898f, 
    0.03116187f, 0.03181715f, -0.03120743f, -0.03516199f, 0.01695225f, -0.03024651f, -0.01484131f, -0.03224690f, 
    -0.00067374f, -0.01829105f, -0.03276096f, -0.05270752f, 0.01753688f, -0.02531111f, 0.00867181f, -0.03759997f, 
    -0.01987832f, -0.02685473f, -0.02800580f, -0.00072995f, 0.01502845f, 0.04554662f, -0.05433427f, 0.01927926f, 
    -0.01406039f, -0.05445939f, -0.06490349f, 0.01745139f, 0.01599263f, -0.05330880f, -0.06283411f, -0.00231553f, 
    -0.01913380f, -0.06352621f, -0.06988987f, 0.02944939f, -0.03866690f, -0.07032049f, -0.02590684f, -0.02975912f, 
    -0.05835146f, -0.03879680f, -0.01157883f, 0.02996387f, 0.01334381f, -0.06592875f, 0.03465058f, -0.00578548f, 
    -0.04221077f, -0.02458343f, 0.03418836f, -0.05637230f, 0.03578740f, -0.04487586f, 0.02352010f, -0.00254953f, 
    -0.02158681f, 0.01731549f, -0.03358357f, -0.00234308f, -0.00435264f, -0.04916933f, -0.03974829f, -0.02937185f, 
    0.01684002f, -0.03189398f, 0.05374444f, 0.00647084f, -0.00819941f, 0.00620939f, -0.06278645f, -0.06235295f, 
    0.03956233f, 0.02940651f, -0.05341975f, -0.05487898f, -0.04542576f, 0.00504166f, -0.03296547f, 0.02853847f, 
    -0.03433718f, 0.01345872f, 0.03193862f, 0.02200984f, -0.02525673f, 0.04972491f, 0.04130184f, 0.02070225f, 
    0.02970942f, -0.02016310f, -0.04658452f, -0.02583751f, 0.03213324f, -0.05722543f, -0.04538907f, 0.04541355f, 
    0.02758567f, -0.03732530f, 0.03921727f, 0.04086399f, 0.03650324f, 0.02106545f, -0.04875877f, -0.03481429f, 
    -0.00814992f, -0.00332345f, -0.03738926f, 0.03691933f, -0.00784298f, -0.03393358f, 0.03443234f, -0.02600956f, 
    -0.04525790f, -0.01236918f, -0.01334569f, 0.02452665f, 0.00926866f, -0.05195010f, -0.03906922f, 0.02231320f, 
    -0.02148102f, -0.04385395f, 0.04527202f, 0.02070259f, -0.00455385f, 0.01325966f, 0.04118140f, -0.01483040f, 
    -0.00113106f, 0.04666808f, 0.00873890f, -0.06723013f, -0.01535111f, -0.00645585f, 0.02129993f, -0.03616844f, 
    0.03343244f, -0.02112877f, 0.01745549f, -0.06068604f, 0.04158635f, 0.03778062f, -0.06238402f, -0.05580099f, 
    -0.05240995f, 0.01624084f, -0.01318841f, -0.04233073f, 0.00669924f, 0.03459202f, 0.03588020f, 0.04868278f, 
    -0.06126910f, -0.03490832f, -0.03572235f, -0.02371112f, -0.04138118f, 0.02098492f, 0.03794333f, 0.01627381f, 
    0.02067085f, 0.00582343f, -0.00969537f, -0.03254249f, -0.00783274f, -0.05672822f, -0.03063606f, -0.06136419f, 
    -0.00129325f, -0.03405920f, -0.04635731f, 0.04026604f, -0.04408151f, 0.01859316f, -0.04967940f, 0.01215479f, 
    -0.04884904f, 0.00239654f, 0.04512994f, -0.02707459f, -0.02124255f, -0.06273110f, -0.02705447f, -0.02114485f, 
    0.04338105f, -0.03360668f, -0.02663111f, -0.02700894f, -0.02142663f, -0.01629382f, 0.03395560f, 0.04288939f, 
    -0.00412091f, 0.03126765f, -0.00255802f, 0.03014589f, 0.04340992f, 0.00764453f, -0.01231872f, -0.05722179f, 
    -0.06128406f, -0.06208814f, -0.03446686f, 0.03890920f, -0.01265223f, 0.02257014f, 0.02116255f, 0.03943919f, 
    -0.01569255f, 0.04780267f, -0.01052269f, 0.03572083f, -0.00947148f, 0.02357568f, 0.00401795f, -0.01164394f, 
    -0.01244040f, 0.04764246f, -0.03728855f, 0.03748689f, 0.02538964f, -0.05957103f, -0.04260329f, 0.00963882f, 
    0.01292557f, 0.00530168f, -0.00014624f, -0.01242133f, 0.02358243f, -0.01650349f, 0.02723729f, -0.03284984f, 
    -0.04434323f, 0.03922839f, -0.06089122f, -0.05851788f, -0.01175513f, 0.02603906f, -0.02736336f, 0.02617395f, 
    -0.01720441f, -0.02361965f, -0.04047994f, 0.03343082f, -0.06392294f, 0.04219686f, -0.05397790f, -0.01721677f, 
    -0.01030917f, -0.03292848f, -0.06134951f, -0.03681367f, -0.06257431f, 0.02789954f, -0.01427613f, 0.04683395f, 
    -0.04344664f, -0.05743962f, -0.05908871f, 0.00116291f, -0.03620316f, -0.02376554f, 0.02607021f, -0.04686589f, 
    -0.02371231f, -0.05336932f, 0.03501297f, -0.00756201f, -0.04627411f, -0.06650360f, 0.02370763f, -0.04129593f, 
    0.00309223f, -0.06171577f, 0.03590130f, -0.00258065f, -0.04794657f, -0.05871383f, 0.00873608f, -0.01516761f, 
    -0.02800691f, -0.01385446f, 0.01119630f, -0.02949106f, 0.03373047f, -0.07353070f, 0.01670014f, -0.02164673f, 
    -0.05616825f, -0.00654994f, -0.03402006f, 0.03409500f, -0.03371655f, 0.04976961f, -0.03621933f, -0.05873291f, 
    -0.05884917f, 0.01229040f, -0.06784268f, -0.04190153f, 0.02000275f, -0.02697410f, 0.02093503f, 0.02985876f, 
    -0.06618480f, 0.00203870f, -0.00688155f, -0.00328758f, 0.00456939f, -0.04483762f, 0.01159565f, -0.04075274f, 
    0.04179554f, -0.05038084f, -0.00055351f, 0.02669269f, -0.00922290f, 0.01023915f, -0.05445362f, -0.07441808f, 
    0.01265793f, -0.03447717f, 0.01343990f, 0.01860395f, -0.05768953f, -0.01513705f, 0.03749852f, -0.04243433f, 
    -0.02071380f, -0.02316663f, -0.04259231f, -0.03279592f, -0.07563927f, -0.03870375f, -0.03381583f, 0.02150876f, 
    -0.07589787f, -0.05391638f, -0.01605540f, 0.03262098f, 0.03283964f, -0.01439755f, -0.05655919f, -0.00350233f, 
    0.04406802f, -0.03742581f, 0.04488264f, 0.01921965f, -0.03991530f, 0.03878099f, -0.05813935f, 0.05079949f, 
    -0.04466077f, -0.00330756f, -0.02281547f, -0.00303452f, -0.03086264f, 0.01724735f, 0.02400659f, 0.00288710f, 
    -0.02151961f, 0.03260349f, -0.00692806f, -0.06095092f, -0.03547870f, -0.05967462f, 0.05012552f, -0.04689680f, 
    0.00550645f, 0.01264059f, -0.00854640f, -0.04444579f, 0.00805428f, -0.06087838f, -0.03591661f, 0.03798449f, 
    0.00832408f, -0.03515115f, -0.03361309f, -0.07797195f, 0.00447546f, 0.02069175f, -0.04395968f, -0.04401782f, 
    -0.07828131f, 0.01618771f, 0.01747437f, -0.02583256f, 0.01359912f, -0.04795788f, 0.06002420f, 0.01908809f, 
    -0.03642936f, 0.03401477f, -0.07266033f, 0.02222737f, 0.02893852f, -0.02680415f, -0.05512463f, -0.05955959f, 
    -0.07963130f, -0.06929997f, 0.03718969f, 0.00459117f, 0.02120031f, 0.03720000f, 0.04595449f, 0.03928563f, 
    0.00230158f, 0.05255383f, 0.05290634f, -0.05186728f, 0.00007533f, -0.07054432f, 0.01285091f, -0.06302524f, 
    -0.06432455f, -0.06558370f, 0.00976369f, -0.07768477f, -0.02839931f, 0.01022191f, -0.03574887f, 0.01674221f, 
    0.00703095f, -0.03421796f, -0.03188655f, -0.00098849f, -0.00881284f, 0.05244659f, -0.04851852f, -0.06035036f, 
    -0.03372083f, -0.01447880f, -0.04059825f, -0.08935124f, -0.04178927f, 0.01107649f, -0.00208348f, 0.02954140f, 
    0.02187116f, -0.05926917f, 0.03805519f, -0.08719140f, -0.06987000f, -0.05803384f, -0.05134036f, 0.04704295f, 
    -0.04662789f, 0.00877546f, 0.01000353f, 0.03311064f, -0.00444680f, -0.07107160f, -0.05021144f, 0.01787666f, 
    0.02342619f, -0.08550369f, 0.00391503f, -0.04513265f, 0.02648199f, 0.03720368f, -0.01020733f, -0.04880693f, 
    -0.00400620f, 0.01215809f, 0.02704177f, -0.05080775f, 0.01422482f, 0.01052476f, -0.01573550f, 0.02539605f, 
    0.03019646f, -0.05793114f, 0.00154148f, 0.02026695f, -0.06612296f, 0.02463892f, -0.02316649f, -0.06154778f, 
    0.02158862f, 0.00762811f, -0.07713511f, 0.02669397f, -0.00731992f, 0.04844842f, -0.05792445f, -0.04980725f, 
    -0.06843735f, -0.01472050f, 0.04672823f, 0.03883979f, -0.06570098f, 0.01586546f, 0.00293854f, -0.02097583f, 
    -0.03528261f, 0.01999576f, 0.01000424f, -0.04515645f, 0.01999521f, -0.01750441f, 0.02255503f, -0.03189825f, 
    -0.01245685f, 0.02180680f, 0.00234947f, -0.07197207f, 0.02346215f, -0.01618928f, -0.05758061f, 0.00488027f, 
    -0.01984834f, -0.03504144f, -0.01548845f, -0.02002680f, -0.01609160f, 0.03548347f, -0.05255247f, 0.02263375f, 
    0.03193630f, 0.00442869f, -0.02585650f, -0.02361601f, 0.01532643f, -0.02810268f, -0.00782117f, 0.02668460f, 
    -0.03481357f, 0.01014514f, -0.05299744f, -0.03658209f, 0.02236306f, -0.08131666f, -0.02408885f, 0.03887235f, 
    -0.04644721f, -0.04338371f, 0.01672656f, 0.01994047f, 0.01392024f, 0.00826900f, -0.05867451f, -0.06392784f, 
    -0.04938285f, 0.04403302f, 0.02202955f, -0.01781301f, -0.00264513f, 0.02223264f, 0.02453955f, 0.01641639f, 
    0.01890811f, -0.15070052f, -0.20613828f, 0.13265108f, 0.06389284f, -0.11834317f, -0.04042304f, -0.08668669f, 
    0.15883669f, 0.13282581f, 0.08713824f, -0.06964728f, -0.02153361f, -0.00763068f, -0.12446892f, 0.00460044f, 
    0.01511970f, 0.12037165f, 0.17450191f, -0.14532419f, -0.11549486f, 0.00351097f, 0.03297935f, -0.04709516f, 
    -0.26391390f, -0.00880693f, -0.31916240f, -0.28558472f, 0.15200210f, 0.28606778f, 0.25127596f, -0.02035735f, 
    -0.13103211f, -0.07344840f, 0.11944403f, 0.11340083f, 0.11892358f, -0.21892567f, -0.16240942f, 0.00534046f, 
    -0.14194950f, 0.00668848f, 0.00371247f, 0.10444064f, 0.06138267f, -0.01128228f, -0.10433613f, 0.01774551f, 
    -0.17881978f, 0.18975952f, 0.02209353f, -0.04561606f, -0.07174602f, -0.10200813f, -0.10106112f, -0.15355964f, 
    0.00528479f, 0.07167426f, -0.03452653f, -0.08557177f, 0.02315543f, 0.00218644f, -0.00552061f, -0.09179150f, 
    -0.07007690f, 0.11179805f, 0.02637772f, 0.16277210f, -0.15097359f, 0.14385211f, -0.10552932f, -0.17525634f, 
    -0.07880400f, -0.10000562f, -0.09990206f, 0.00937563f, -0.16202030f, -0.04141178f, 0.08371850f, 0.06204068f, 
    -0.03866871f, 0.05243072f, -0.39848167f, -0.33419693f, 0.00515744f, 0.25297406f, 0.03840213f, -0.17125466f, 
    0.02865546f, 0.13187586f, 0.15701875f, 0.20739101f, 0.22628708f, -0.10449964f, -0.04700392f, 0.03583901f, 
    -0.05555594f, 0.06617824f, -0.02893722f, -0.07014077f, -0.19321962f, 0.03532609f, 0.07518470f, -0.02721102f, 
    0.02337365f, 0.01009084f, 0.13447812f, 0.04176295f, -0.05485577f, 0.11139045f, 0.00270829f, 0.05435561f, 
    -0.08328666f, -0.16495530f, 0.11037720f, 0.08873585f, 0.03860623f, 0.05923500f, 0.08831123f, 0.18299718f, 
    0.02155073f, 0.04466836f, -0.04206607f, -0.00701885f, 0.07306524f, 0.11707848f, -0.05505200f, 0.14940658f, 
    0.18263423f, -0.00005829f, 0.03198974f, 0.01897936f, 0.09669767f, 0.24242266f, -0.04590562f, -0.27975416f, 
    -0.19649476f, 0.15572585f, 0.01092476f, -0.08701976f, -0.11078456f, -0.04327165f, -0.14903578f, 0.03445357f, 
    0.19543968f, 0.26932332f, 0.07605851f, 0.05403696f, 0.13692234f, -0.05876506f, 0.07565249f, -0.08453999f, 
    -0.18270001f, 0.18955120f, -0.49369466f, -0.09036026f, -0.02010685f, -0.18061705f, 0.04561038f, -0.07978914f, 
    0.01338842f, -0.26416022f, -0.29466519f, -0.05005314f, 0.14256847f, 0.03106249f, -0.22841756f, 0.06927858f, 
    0.01896029f, 0.08872617f, 0.02429534f, 0.05586936f, -0.11343104f, 0.00672287f, -0.05697914f, -0.07534670f, 
    -0.05011215f, 0.04367177f, -0.05463659f, 0.11354807f, 0.16777854f, 0.16991280f, 0.15717629f, -0.18794340f, 
    0.00057628f, 0.04375707f, -0.00048735f, 0.12258838f, 0.02344580f, -0.06355718f, -0.25673646f, 0.03434206f, 
    0.02703026f, -0.06795584f, -0.03194487f, -0.15080243f, -0.06434356f, 0.01881376f, -0.10872672f, -0.02490197f, 
    0.19036117f, 0.09082694f, 0.08897594f, 0.02000073f, -0.00979758f, 0.18159348f, -0.14851908f, 0.11418979f, 
    0.07079601f, 0.01057736f, -0.09974752f, 0.05376877f, 0.02122513f, 0.09867596f, -0.00216999f, 0.11019226f, 
    -0.07272907f, -0.24370976f, 0.06123902f, -0.03962212f, -0.09583521f, -0.08190177f, 0.12019611f, -0.12158556f, 
    0.17638297f, 0.05287390f, -0.02160573f, 0.05143071f, -0.11596694f, 0.05550693f, -0.10117812f, -0.09142246f, 
    -0.12986046f, 0.11619920f, 0.12685262f, -0.05700912f, 0.04523137f, -0.00154321f, -0.11249474f, 0.15031779f, 
    -0.11540333f, 0.05348164f, -0.03247272f, 0.04919828f, 0.01981979f, 0.00196216f, -0.06837186f, 0.09868326f, 
    -0.22817956f, -0.21102120f, -0.04893762f, -0.06362309f, -0.12462942f, -0.16375978f, 0.44274804f, -0.04302381f, 
    0.03684417f, 0.15170927f, -0.01575604f, 0.11073954f, 0.01942228f, -0.18715066f, -0.12620279f, 0.07703906f, 
    -0.13729669f, 0.07905819f, 0.03548221f, 0.08826750f, 0.07072911f, 0.09032778f, 0.02294783f, -0.04448341f, 
    -0.22893861f, 0.05457539f, 0.04024794f, -0.02098551f, -0.00006777f, -0.02021130f, -0.11785299f, 0.28864908f, 
    -0.19735502f, -0.10906316f, 0.00607786f, -0.10008104f, 0.24569570f, 0.00516910f, -0.01141427f, 0.17913978f, 
    0.20938545f, 0.08335277f, -0.06706512f, 0.13508932f, -0.08901500f, -0.12973854f, -0.04417211f, 0.00908981f, 
    0.07687604f, 0.01800326f, 0.00102010f, 0.03372034f, -0.03550316f, 0.06931291f, 0.01507592f, -0.03296749f, 
    0.12378039f, 0.01836527f, 0.31778818f, 0.27300051f, 0.09706669f, -0.06405337f, -0.07027905f, -0.00882715f, 
    -0.01956112f, -0.10321167f, -0.06340489f, -0.14684434f, -0.14818449f, -0.11554755f, 0.13919036f, -0.10544660f, 
    0.07803512f, -0.14109650f, -0.05630848f, -0.10550375f, 0.32137853f, 0.16182341f, -0.09580884f, -0.00680165f, 
    0.05627332f, 0.00641521f, -0.01333779f, -0.04513631f, 0.01863411f, -0.09345151f, 0.03823205f, -0.05405224f, 
    0.02843245f, 0.02946825f, 0.10606157f, 0.15734670f, 0.00355401f, 0.04907653f, -0.13657829f, -0.01907510f, 
    -0.01295380f, 0.15281974f, 0.05760641f, 0.14929236f, 0.12932698f, 0.12785493f, 0.22544599f, -0.17154050f, 
    0.01403926f, 0.02162429f, 0.06225802f, -0.00325326f, 0.11656401f, 0.09822090f, 0.03189482f, 0.23051739f, 
    0.12547189f, -0.03105811f, -0.06278688f, 0.00462590f, 0.05805046f, 0.09756824f, -0.10714721f, -0.01726278f, 
    -0.20829511f, 0.11955909f, -0.11912200f, -0.09095474f, 0.15578949f, -0.03319219f, -0.05701552f, 0.04044061f, 
    -0.14554568f, -0.18372622f, -0.03236987f, -0.01750618f, -0.06109831f, 0.18568368f, 0.13993189f, 0.00043178f, 
    -0.00466787f, -0.05556659f, 0.00034970f, -0.05731403f, -0.18521807f, -0.04676646f, 0.07900164f, 0.04836912f, 
    0.00512911f, 0.03144693f, 0.00909263f, -0.43803874f, 0.09029494f, -0.05471085f, -0.11409330f, 0.02987118f, 
    0.19663225f, 0.09028342f, 0.02422438f, 0.15542825f, 0.18904763f, 0.08750893f, -0.08002180f, -0.05795311f, 
    0.00150499f, -0.01894226f, 0.16226363f, 0.08892865f, 0.05161454f, 0.08416220f, 0.03765171f, -0.02766296f, 
    0.17567265f, 0.13516112f, 0.04615316f, 0.11636499f, 0.04773090f, -0.07822342f, 0.12073347f, -0.01314916f, 
    0.14764896f, 0.01231596f, 0.13070999f, 0.01026712f, -0.00078391f, 0.01824190f, 0.02073183f, -0.02551526f, 
    -0.05326656f, 0.23027435f, 0.13119256f, 0.13864137f, 0.00625193f, -0.10153223f, 0.09587840f, 0.01174524f, 
    0.11311070f, 0.32761490f, 0.27191168f, 0.09691960f, 0.03143574f, -0.05239340f, 0.04135222f, 0.07888027f, 
    -0.02850959f, 0.05265284f, 0.04629209f, 0.00256781f, -0.04075722f, -0.01058871f, 0.00292082f, 0.04665104f, 
    -0.04905704f, 0.06671666f, -0.27426261f, -0.03617137f, -0.07735317f, 0.01729797f, 0.01085681f, -0.00679737f, 
    -0.02570059f, -0.03431793f, -0.08875570f, -0.26088616f, 0.10649476f, -0.12001333f, -0.13387950f, 0.07804931f, 
    -0.00238780f, -0.04578406f, 0.11064346f, -0.11196404f, -0.19786122f, 0.35081393f, 0.20452517f, 0.03996798f, 
    -0.14483592f, -0.15563069f, -0.11219648f, -0.10954677f, -0.01800391f, -0.05315707f, 0.17418793f, 0.07423007f, 
    0.02225364f, 0.14255680f, -0.05756066f, 0.03105428f, 0.19730373f, 0.03696242f, 0.18406884f, -0.08994482f, 
    -0.05039481f, -0.05424109f, -0.02879047f, -0.04412163f, -0.02539849f, -0.06442967f, -0.07783420f, -0.25685754f, 
    0.10972993f, -0.11444959f, -0.04154579f, 0.20943104f, -0.02279755f, 0.00725009f, -0.00003202f, 0.02530629f, 
    -0.05104200f, -0.01463323f, 0.20853408f, -0.05832458f, -0.01310438f, 0.01527736f, 0.10710440f, 0.06583911f, 
    -0.00934508f, 0.07142296f, -0.12695889f, 0.02719527f, -0.13209938f, 0.00954074f, 0.07112465f, 0.01440489f, 
    -0.04322267f, -0.02599206f, 0.03124843f, 0.03182184f, 0.02622748f, -0.04254161f, 0.03277751f, 0.09575360f, 
    0.15383457f, 0.03593282f, -0.02333875f, 0.08246280f, 0.17865677f, 0.09188666f, 0.07393647f, 0.14942284f, 
    -0.02949949f, -0.13631016f, 0.14769430f, -0.03832750f, 0.08444564f, 0.04746145f, -0.01201801f, -0.16607381f, 
    0.18080802f, 0.08314549f, 0.00285916f, -0.15445563f, -0.11490422f, -0.22818023f, -0.10826472f, 0.04449550f, 
    0.24805166f, 0.00457073f, 0.04880356f, 0.10967395f, 0.04192744f, 0.08277277f, 0.20995022f, -0.03311420f, 
    -0.06448168f, -0.08262968f, 0.09638393f, -0.10436939f, -0.04768774f, 0.01506160f, -0.09826265f, -0.05745336f, 
    0.04013218f, 0.27019107f, 0.32668057f, -0.07049294f, 0.11958651f, -0.04754343f, 0.01765489f, -0.05618782f, 
    -0.02747268f, -0.12366100f, -0.12584075f, 0.19082110f, -0.08419623f, -0.05861213f, -0.15245372f, 0.11441619f, 
    0.03829479f, 0.05104282f, -0.69267571f, -0.01803689f, -0.25780818f, -0.03235184f, 0.02035286f, -0.01713931f, 
    -0.07748231f, 0.01102796f, -0.02860435f, 0.15723066f, 0.06570260f, -0.15062068f, -0.17434472f, 0.03279278f, 
    -0.15298370f, 0.13572770f, -0.08962514f, 0.06756760f, 0.04393210f, 0.24512810f, 0.04416383f, 0.13448755f, 
    0.01693717f, -0.13488606f, 0.03536675f, 0.12929358f, 0.01712218f, 0.03530208f, -0.38143027f, -0.15749347f, 
    0.13244651f, 0.03064230f, -0.12265124f, -0.09624145f, 0.08337981f, -0.01828014f, 0.01080783f, 0.08333631f, 
    0.01221605f, 0.14479029f, -0.01587608f, 0.05981030f, -0.05350728f, 0.01308249f, -0.01538054f, -0.18367408f, 
    -0.07857564f, 0.02892130f, -0.04393607f, -0.03024790f, -0.09881110f, -0.02834207f, -0.03577914f, 0.04683867f, 
    0.08148151f, -0.03903186f, 0.16920139f, -0.01978037f, -0.04520083f, 0.24002534f, 0.15214917f, -0.04345924f, 
    0.01131245f, 0.23009968f, 0.40975302f, -0.29495594f, -0.03857939f, -0.09523155f, 0.02453522f, 0.12069900f, 
    0.15300527f, 0.05858785f, -0.21185429f, -0.13865775f, 0.18111870f, 0.07479835f, 0.04080317f, -0.03815129f, 
    0.02470368f, -0.01482594f, 0.10764779f, -0.02396039f, -0.09760979f, 0.01121871f, -0.16759090f, -0.06714360f, 
    -0.07179146f, 0.05221963f, 0.04428147f, 0.15316132f, -0.13455863f, -0.03190956f, 0.13312478f, 0.01424023f, 
    -0.18066156f, 0.15264347f, -0.03279138f, 0.14402798f, -0.04054490f, -0.01155912f, 0.10593183f, 0.27250820f, 
    0.00798704f, -0.04578511f, 0.09270062f, 0.16904575f, 0.00466975f, -0.05911259f, 0.06912895f, -0.03750915f, 
    0.11881196f, 0.06568753f, -0.11786934f, 0.02996011f, 0.06108682f, -0.02483925f, -0.22510947f, -0.08144077f, 
    -0.02142911f, -0.17769009f, 0.04218055f, 0.03496883f, 0.01390135f, -0.11843494f, 0.05705310f, -0.05438500f, 
    0.22157565f, -0.14026226f, 0.47367108f, -0.13266429f, 0.04869122f, 0.13516082f, 0.04964034f, 0.00014032f, 
    -0.21934871f, -0.47862980f, 0.00610653f, 0.11973468f, -0.09178223f, -0.02727808f, -0.18555900f, 0.11452692f, 
    -0.16842148f, -0.03491745f, 0.11573866f, -0.02406128f, -0.13862093f, -0.15025294f, -0.05911922f, 0.09209090f, 
    -0.09224872f, 0.00826384f, 0.22219762f, -0.09940819f, 0.05540841f, 0.30095050f, -0.01259375f, -0.16684155f, 
    0.04709761f, 0.20423569f, 0.06801683f, 0.19077288f, 0.08124451f, 0.01670909f, 0.15745127f, 0.12763146f, 
    -0.02034307f, -0.06532193f, -0.03915153f, 0.13094379f, 0.05010819f, -0.24733031f, 0.28846872f, -0.24243429f, 
    -0.04345034f, 0.02536903f, -0.14149891f, -0.06079020f, 0.13906103f, -0.08060484f, 0.16114712f, 0.11917440f, 
    0.32542104f, -0.03308163f, 0.15168767f, 0.00997628f, 0.09538615f, 0.05524277f, 0.11186853f, -0.10201568f, 
    -0.09996711f, 0.30187261f, -0.11140788f, 0.06600206f, -0.07144421f, 0.01008945f, -0.12432948f, 0.20050165f, 
    -0.16185550f, 0.05408317f, 0.20591347f, -0.10845020f, 0.00811069f, -0.08192024f, -0.19025646f, 0.01951879f, 
    -0.12661329f, 0.13510260f, 0.17024739f, 0.05154151f, -0.04986135f, 0.09203135f, -0.02605142f, 0.13329196f, 
    0.03006975f, -0.03120826f, 0.19989610f, -0.26293954f, -0.22135399f, -0.01777865f, -0.12887783f, -0.25304154f, 
    0.13336554f, 0.04827245f, -0.03712590f, 0.18534362f, -0.29693255f, 0.04457928f, 0.06078105f, 0.01830821f, 
    -0.09328611f, -0.00701692f, -0.00176805f, -0.01190384f, -0.04579366f, 0.27088869f, 0.02079605f, 0.04425117f, 
    0.20877774f, 0.01766552f, -0.03693658f, 0.16277845f, -0.08042291f, -0.01684613f, -0.25181744f, -0.08766308f, 
    -0.10546114f, -0.18081558f, -0.03834116f, 0.00924119f, 0.02144399f, -0.10793307f, 0.05599570f, -0.03784739f, 
    0.31695214f, -0.07220829f, -0.05975989f, 0.07273313f, -0.00311098f, 0.01232693f, 0.05200365f, -0.05289494f, 
    0.33360159f, -0.28336909f, 0.00211573f, 0.10387250f, -0.06732757f, 0.09719107f, -0.02395448f, -0.03440164f, 
    -0.01156454f, -0.09545108f, -0.09271184f, 0.02265231f, 0.02703981f, 0.10682232f, 0.03696720f, -0.01601563f, 
    0.10892058f, -0.29079774f, 0.06903433f, -0.05101668f, -0.16638313f, 0.14636996f, -0.03518491f, 0.09208307f, 
    0.04339284f, 0.07561953f, 0.28595912f, -0.13486511f, -0.18161182f, -0.16526119f, 0.02679143f, -0.04376061f, 
    -0.08259740f, 0.00497600f, 0.04579481f, -0.21201171f, 0.07518415f, 0.08337546f, 0.11224139f, 0.04724797f, 
    0.04158189f, 0.04096757f, 0.01743609f, 0.23197426f, -0.26333296f, -0.01266973f, 0.04516660f, 0.08732687f, 
    0.00890979f, 0.06135558f, 0.04748131f, 0.02454457f, -0.01404811f, -0.09238131f, -0.37205717f, -0.03045432f, 
    0.01535104f, -0.03408994f, -0.11160944f, 0.17356372f, 0.09558108f, 0.04572128f, 0.00178152f, 0.19377968f, 
    -0.02983912f, 0.03388767f, -0.03062867f, 0.02314178f, 0.01037105f, -0.08928244f, 0.02510723f, -0.25400755f, 
    0.15989558f, -0.08278643f, -0.04543562f, -0.04754137f, 0.03008462f, 0.09690969f, -0.05102589f, -0.15576363f, 
    -0.01415023f, 0.05810941f, 0.01000282f, 0.06592907f, -0.05086091f, -0.01448161f, -0.08229627f, 0.03335395f, 
    -0.11242607f, 0.27759203f, -0.01074239f, 0.09902520f, 0.15442488f, -0.08156474f, 0.27042857f, 0.05117629f, 
    -0.12938806f, 0.02082583f, -0.35060990f, 0.03875050f, 0.17297721f, -0.11806299f, -0.05524046f, -0.03632214f, 
    0.02644787f, 0.08984740f, -0.15138507f, 0.05931260f, 0.23891975f, 0.13365577f, 0.07911205f, 0.12247867f, 
    0.13785572f, -0.01510687f, 0.09465067f, 0.13906185f, -0.38478753f, 0.06565455f, -0.20796864f, 0.09286931f, 
    -0.11105540f, -0.03149686f, -0.09817182f, 0.12841369f, -0.03536908f, -0.14909667f, 0.06917150f, -0.03516628f, 
    0.08575556f, -0.01643958f, -0.05938058f, 0.00958601f, -0.14291802f, 0.03142147f, -0.21841641f, 0.11734755f, 
    -0.09017763f, -0.08156161f, -0.07075718f, -0.05499443f, 0.06661085f, 0.04886369f, -0.02291907f, 0.11099461f, 
    -0.02394113f, 0.01027597f, -0.07475224f, -0.17947474f, 0.04395531f, -0.08492108f, 0.08342823f, 0.06439687f, 
    -0.10049818f, -0.07005584f, -0.43465409f, 0.18493107f, 0.06979261f, -0.02120452f, 0.07546017f, 0.05002184f, 
    -0.00453065f, 0.11499339f, -0.00330453f, 0.15968402f, 0.14428844f, 0.01529665f, -0.06393649f, 0.20321102f, 
    0.22265370f, 0.04331380f, 0.10438783f, 0.24991830f, -0.04697305f, -0.11260434f, -0.04262913f, 0.17131028f, 
    -0.01474507f, 0.14618520f, 0.09043334f, 0.02011111f, -0.03953347f, -0.24778111f, -0.02512185f, 0.08681871f, 
    -0.00491654f, 0.03711654f, 0.06789317f, 0.00156011f, -0.26257154f, 0.15652931f, 0.15596071f, -0.12429971f, 
    0.02721555f, 0.08182157f, 0.02350931f, 0.02537601f, 0.04914549f, 0.25195557f, -0.17754471f, 0.06280429f, 
    -0.08637767f, 0.00507258f, 0.05880315f, 0.00950793f, 0.01009476f, -0.06371100f, -0.03281098f, 0.05243735f, 
    0.24756873f, 0.11791146f, 0.04403111f, -0.07083172f, 0.04342987f, -0.06122402f, -0.06621665f, -0.08365274f, 
    0.00808804f, -0.49439839f, 0.16152711f, -0.05041956f, 0.08639548f, -0.08359320f, -0.05968972f, 0.24035703f, 
    0.02972544f, 0.00977753f, -0.03396507f, -0.01784714f, -0.08903668f, -0.14155984f, -0.04103382f, -0.32146868f, 
    -0.03998490f, 0.12184075f, -0.01622005f, 0.02800395f, 0.08814028f, 0.01842741f, -0.02136973f, 0.03123993f, 
    0.09492330f, 0.15830746f, -0.13362549f, -0.05444274f, 0.10558335f, -0.02032834f, 0.10785490f, -0.03563137f, 
    0.02987172f, -0.16296881f, 0.01251628f, -0.05791200f, -0.20512715f, -0.02071423f, -0.05472481f, -0.10415106f, 
    0.05794770f, -0.07985823f, 0.03901557f, -0.05993538f, -0.19705044f, -0.49503106f, 0.37033752f, 0.15389480f, 
    0.20956802f, -0.00201669f, 0.04312827f, 0.10611071f, -0.16996224f, -0.51542366f, -0.28123522f, -0.09372205f, 
    0.10220248f, -0.06179157f, -0.18453737f, 0.06016833f, -0.14684032f, 0.01265291f, 0.07827874f, 0.17028530f, 
    -0.39379218f, -0.04001158f, -0.05509347f, -0.13221852f, 0.00549113f, -0.08920486f, -0.06923681f, -0.10445645f, 
    -0.31456050f, -0.02973836f, 0.07014511f, 0.13384706f, 0.10896751f, 0.05707718f, 0.06075462f, -0.20755009f, 
    -0.06437033f, -0.05906664f, -0.06278097f, -0.05780790f, -0.01259847f, -0.01165363f, -0.05890261f, 0.03960068f, 
    -0.04458968f, -0.02271883f, -0.02576497f, 0.01555623f, 0.03155603f, -0.05749173f, -0.00123761f, 0.03100718f, 
    -0.01851974f, -0.02222848f, 0.02910576f, 0.02121405f, -0.05352350f, 0.01090325f, 0.05053701f, -0.00706408f, 
    0.00122186f, 0.01627992f, -0.01523370f, -0.01038525f, -0.01749624f, 0.01492681f, 0.02899798f, -0.00133256f, 
    -0.03897823f, -0.03502554f, 0.03004380f, -0.00397845f, -0.03757641f, -0.06035445f, 0.01534214f, -0.03397126f, 
    0.01899942f, -0.00110417f, -0.00649392f, -0.03030125f, -0.01679575f, 0.01453444f, -0.04040439f, -0.03776422f, 
    0.03588875f, -0.00926354f, 0.02963077f, -0.01663820f, 0.04174343f, -0.06050184f, -0.04837076f, -0.04080907f, 
    -0.00748651f, 0.00550660f, 0.00859075f, 0.00456899f, -0.00463123f, -0.06505480f, 0.01451551f, -0.03896149f, 
    -0.00744295f, -0.02308940f, -0.04951591f, 0.02774299f, -0.01068819f, -0.02031903f, 0.00048009f, 0.00045405f, 
    -0.05351829f, -0.02626785f, -0.00673394f, 0.03204778f, -0.02965776f, 0.02134530f, 0.01307479f, -0.04772806f, 
    0.02167103f, -0.00036535f, -0.04129636f, -0.00426011f, -0.00275989f, -0.02243686f, -0.01725924f, -0.03478968f, 
    0.00521465f, -0.06372226f, 0.03659864f, -0.03194948f, -0.02196125f, 0.01681152f, 0.00998154f, -0.03346850f, 
    0.01434070f, 0.03892235f, -0.01536699f, -0.01359437f, -0.00531017f, 0.00372822f, -0.03407912f, 0.03505786f, 
    -0.01636864f, -0.03126210f, -0.01618423f, 0.01944871f, -0.03312995f, -0.04604036f, -0.03322046f, 0.02582076f, 
    -0.05438289f, -0.02513382f, -0.00765465f, 0.02777125f, -0.03333860f, -0.01918490f, -0.00405680f, -0.03583521f, 
    0.01452941f, 0.00955992f, 0.01875441f, 0.04839021f, 0.01853933f, 0.03153951f, -0.02367235f, 0.03819289f, 
    0.06199785f, 0.04573319f, -0.06544545f, -0.05608218f, 0.04940306f, -0.05160869f, 0.03597352f, -0.02722536f, 
    -0.00132618f, 0.01474950f, 0.02758094f, 0.00453370f, 0.01998988f, -0.04580100f, -0.02622514f, 0.01226940f, 
    0.03781032f, -0.01707209f, -0.00923345f, -0.03359572f, 0.01313479f, 0.00580731f, -0.00878307f, -0.00292706f, 
    0.02915673f, -0.00901837f, 0.01281266f, -0.03811694f, -0.00385088f, 0.02035922f, 0.03023650f, -0.04097453f, 
    0.05025154f, -0.04882617f, -0.01235652f, 0.04711570f, -0.05922382f, -0.01499973f, -0.01764803f, 0.00317888f, 
    0.02736347f, 0.03324944f, -0.05766626f, 0.03680411f, -0.05275254f, 0.01762346f, -0.04910506f, 0.04352153f, 
    -0.03470659f, -0.00545256f, -0.03328710f, -0.01372317f, -0.05602049f, 0.02701176f, -0.03241388f, -0.00786806f, 
    -0.05731346f, 0.03552144f, -0.01143279f, -0.01397860f, -0.00035120f, 0.03437675f, 0.00748883f, 0.01678589f, 
    0.01785917f, -0.05165838f, -0.04186075f, 0.00618159f, -0.03558778f, -0.01256742f, 0.02342186f, -0.06630482f, 
    -0.00408503f, -0.00431972f, 0.04121778f, 0.02466267f, 0.02876421f, 0.03816150f, 0.04415752f, -0.03089207f, 
    -0.02823406f, 0.03169455f, 0.00900007f, -0.03745550f, -0.03967849f, -0.00074649f, -0.03549403f, 0.00651094f, 
    0.00101008f, -0.01861212f, 0.03366667f, -0.03495290f, -0.01078980f, -0.02920120f, -0.05127151f, -0.03305291f, 
    0.05091978f, 0.01604435f, -0.05285726f, -0.05310010f, -0.06619167f, 0.04983278f, -0.04023528f, -0.01231187f, 
    0.00471655f, 0.00041496f, -0.04560026f, -0.02022049f, -0.01943538f, 0.00506738f, -0.02978247f, 0.05009758f, 
    -0.02167070f, -0.02074341f, -0.00181802f, 0.01156180f, 0.04583265f, -0.00191582f, -0.03141732f, 0.04431042f, 
    -0.00335924f, -0.03996661f, -0.05243560f, -0.00013176f, -0.00774461f, -0.04585188f, 0.03574379f, -0.00514608f, 
    -0.05487227f, 0.03067051f, -0.03587142f, -0.02215561f, -0.01526697f, 0.01737673f, -0.05610926f, 0.01023056f, 
    0.01751065f, -0.01553131f, 0.06248338f, -0.04885983f, -0.01034758f, -0.04625211f, 0.06394719f, 0.00697362f, 
    -0.00955181f, -0.06044067f, 0.01745099f, -0.05276394f, 0.02815112f, -0.04807450f, -0.02111275f, -0.05853631f, 
    0.05286520f, -0.03224317f, -0.02816966f, -0.04577401f, 0.00801667f, 0.02882691f, -0.00098403f, -0.00846515f, 
    -0.00004452f, -0.07622997f, -0.06390849f, 0.02540557f, -0.00715814f, -0.07674495f, -0.06137770f, -0.07592499f, 
    0.01909508f, -0.06371389f, -0.07611655f, -0.08516600f, -0.07078999f, 0.01570185f, -0.02469060f, -0.05149055f, 
    -0.03890149f, -0.06624041f, 0.01464887f, -0.05371229f, -0.01335256f, -0.04537880f, -0.03031993f, -0.04547366f, 
    0.04162921f, -0.01420461f, 0.00994212f, -0.04795320f, -0.03218193f, -0.02480333f, -0.04035257f, -0.07899915f, 
    -0.04315225f, -0.00614974f, -0.07722238f, -0.05976913f, -0.07068738f, -0.06291226f, -0.03503461f, -0.05375557f, 
    0.01967844f, -0.01454771f, -0.02170802f, -0.07437239f, 0.00646004f, -0.02567306f, -0.03922120f, 0.02496279f, 
    0.05183553f, -0.06460562f, -0.06555349f, -0.04310435f, -0.04940680f, -0.04795475f, -0.05098335f, -0.00574010f, 
    -0.03690482f, -0.07810640f, -0.00342534f, -0.07678015f, 0.00165177f, 0.01365098f, -0.05483212f, -0.07394643f, 
    -0.02975380f, 0.01556429f, -0.01243560f, 0.02382134f, -0.02652548f, -0.07874962f, -0.07536331f, -0.04399755f, 
    -0.04949494f, -0.05453725f, -0.04305529f, -0.05161830f, -0.03890302f, -0.05293766f, 0.00665844f, -0.00826873f, 
    -0.02948321f, -0.07883521f, -0.06700062f, -0.00482423f, -0.02736675f, -0.02303196f, -0.07514144f, -0.07595590f, 
    -0.08614652f, -0.03744943f, -0.00442685f, -0.05389497f, -0.07376914f, -0.00634797f, 0.00514722f, 0.01452562f, 
    -0.04179538f, -0.08853748f, 0.00254799f, 0.05198686f, 0.01157709f, -0.01282334f, -0.04406831f, -0.08533985f, 
    -0.05987300f, -0.05430024f, -0.03529840f, 0.00728172f, -0.00287178f, 0.02149639f, -0.06533627f, -0.08622418f, 
    0.00211172f, -0.02040604f, -0.06185658f, -0.01611774f, -0.08131038f, -0.02802002f, -0.02908943f, 0.01856785f, 
    -0.06958015f, -0.08243357f, -0.07367679f, 0.01173489f, 0.00085456f, -0.08490352f, -0.04843064f, -0.08303458f, 
    -0.04759479f, -0.04257765f, -0.07900969f, -0.00164040f, 0.01314924f, -0.06854724f, -0.01046179f, -0.02201170f, 
    -0.02428674f, -0.06649014f, 0.02688988f, 0.00927366f, -0.01664372f, 0.00583992f, -0.03612963f, -0.04987111f, 
    -0.01044599f, -0.08352137f, -0.07235872f, -0.01694187f, -0.05415258f, 0.02601680f, -0.05539132f, -0.02539987f, 
    -0.00522472f, -0.04348433f, 0.02359455f, -0.05230387f, -0.05413935f, -0.00980650f, -0.05491134f, -0.02407962f, 
    -0.07891519f, -0.03408647f, 0.04274540f, -0.07655318f, 0.00377314f, -0.07311738f, 0.02648299f, -0.04602316f, 
    0.00786969f, -0.08939628f, 0.00207984f, -0.01834435f, -0.08395706f, 0.02378370f, -0.03971285f, 0.01623541f, 
    -0.01604924f, -0.01415018f, -0.07470968f, -0.02533205f, -0.01428285f, 0.00005228f, -0.01946829f, -0.01788265f, 
    -0.07623920f, -0.05871389f, 0.00470552f, -0.07037019f, -0.05781574f, -0.03886532f, -0.01834711f, -0.07142828f, 
    0.01523127f, -0.00575715f, -0.00741074f, 0.00536176f, 0.00753522f, 0.00421033f, -0.03862422f, 0.00611139f, 
    -0.05033585f, -0.04208231f, -0.01306120f, -0.08077886f, -0.03096429f, -0.03031122f, -0.04567597f, 0.01941387f, 
    -0.00187100f, -0.04440605f, -0.08584870f, 0.01291736f, -0.02467897f, -0.04842721f, 0.02230055f, -0.03866926f, 
    -0.05560471f, -0.06863635f, -0.03443082f, 0.01270903f, -0.02652248f, -0.03747702f, -0.01099997f, -0.00634435f, 
    0.02072086f, 0.02385030f, -0.04749163f, -0.08797769f, -0.04739898f, -0.04623742f, -0.05009041f, -0.03443079f, 
    0.01139471f, -0.01216775f, -0.03051102f, 0.02117352f, -0.00093015f, -0.01938330f, -0.07749373f, -0.04012237f, 
    -0.01730900f, -0.01476323f, 0.01128737f, -0.01780654f, -0.00612848f, 0.01042138f, -0.05302488f, -0.02137013f, 
    -0.01329447f, -0.00480029f, 0.00859663f, 0.00862650f, -0.06031347f, -0.01948603f, 0.01161387f, -0.03709637f, 
    -0.00258701f, 0.01034871f, -0.04750042f, -0.06558630f, -0.07879076f, -0.03032987f, 0.00142308f, 0.01762741f, 
    0.02545056f, 0.01847539f, -0.02355575f, -0.03632915f, -0.02287610f, 0.00310286f, 0.01926491f, -0.01852127f, 
    0.00548372f, -0.04665958f, -0.05052322f, -0.01666996f, -0.00141433f, -0.07572695f, -0.01164630f, -0.02302024f, 
    -0.06395414f, -0.03055589f, -0.01883063f, -0.08094493f, -0.07188142f, -0.00191111f, -0.00944502f, -0.06594999f, 
    0.04885604f, 0.09132116f, -0.07795296f, 0.00086003f, 0.03741253f, -0.06087722f, 0.08311919f, 0.08530427f, 
    -0.02187984f, 0.00691774f, -0.18493135f, -0.04988330f, -0.00337929f, -0.11897667f, 0.05552220f, -0.04416462f, 
    0.08625118f, 0.00288042f, -0.00626550f, 0.18026574f, -0.08339230f, -0.05319427f, -0.01247724f, 0.13252044f, 
    0.24330713f, 0.06762816f, 0.03438246f, -0.05645331f, 0.11288694f, -0.17481922f, -0.05578041f, 0.07968137f, 
    -0.10810950f, -0.04818590f, -0.12938510f, -0.15117748f, 0.20234965f, 0.06861599f, -0.02739745f, -0.06329546f, 
    0.00798068f, 0.03573447f, -0.04326559f, 0.03825080f, -0.12254473f, 0.01366245f, -0.34013051f, 0.26265848f, 
    0.09874842f, 0.06880701f, 0.05826785f, 0.16805205f, -0.05874138f, -0.09798933f, -0.12129162f, 0.00938397f, 
    0.02698262f, 0.05100271f, -0.03891698f, 0.07229359f, 0.17976406f, 0.20796408f, 0.13883412f, 0.00834341f, 
    -0.08422244f, -0.12617889f, -0.09262823f, 0.04353233f, 0.06659674f, 0.05160795f, 0.24516271f, 0.15692067f, 
    0.05271780f, 0.01401124f, 0.01226970f, 0.03713497f, 0.01024230f, 0.14765105f, -0.09532775f, -0.15032446f, 
    -0.07281751f, -0.20997670f, 0.03843093f, 0.01101340f, 0.10283570f, -0.03837926f, -0.04079071f, 0.14389643f, 
    0.14249080f, -0.16524455f, 0.02359321f, -0.15144615f, -0.33423066f, 0.03124401f, 0.08510499f, 0.00188096f, 
    0.11338233f, -0.05710193f, -0.13309480f, -0.02592313f, 0.05102466f, 0.01567504f, 0.09112933f, -0.02323447f, 
    -0.01129336f, -0.07274625f, -0.12822507f, -0.29287165f, -0.08641591f, -0.13437533f, -0.00121739f, 0.03580593f, 
    0.10551440f, 0.02601661f, 0.11342940f, 0.19343510f, 0.25848803f, -0.08144886f, -0.15092979f, -0.05678199f, 
    -0.04168957f, 0.05376900f, 0.05020694f, 0.08392178f, 0.10557920f, 0.08729745f, 0.09697361f, -0.04448267f, 
    -0.06718308f, 0.10729329f, -0.06809848f, -0.01479234f, -0.05598442f, 0.10858213f, 0.05143944f, 0.05427080f, 
    -0.01299935f, -0.02893508f, 0.02034792f, 0.04151100f, 0.01145892f, 0.05633705f, -0.10898445f, 0.01159139f, 
    -0.15069745f, -0.00848558f, 0.08760087f, 0.13685715f, 0.00301867f, 0.01357227f, -0.03099272f, 0.10970719f, 
    -0.00551819f, 0.15097235f, 0.28788981f, -0.03420042f, -0.06876131f, 0.04385676f, 0.10174283f, 0.06838942f, 
    0.14530559f, -0.15343867f, 0.08247543f, 0.03666791f, 0.04392127f, -0.02241684f, 0.14861839f, 0.03133281f, 
    -0.02327196f, -0.11005155f, -0.03124838f, -0.11983499f, 0.04955022f, 0.13468710f, 0.11304986f, -0.03866178f, 
    -0.07673158f, -0.06698717f, -0.27473968f, -0.22438471f, -0.00921857f, -0.10676923f, -0.11507972f, -0.08266966f, 
    -0.00817350f, -0.05278094f, -0.00809592f, -0.13695465f, -0.25590563f, 0.06062064f, 0.21085215f, -0.10218187f, 
    -0.04922666f, 0.01210440f, -0.07943238f, 0.09365860f, 0.13833053f, -0.00955843f, 0.01619742f, 0.01947167f, 
    -0.10692561f, 0.01701892f, -0.08039145f, -0.00177648f, 0.01588630f, 0.12572132f, 0.11299514f, -0.05882289f, 
    0.01623573f, 0.07979973f, 0.15025012f, -0.03526918f, -0.18781963f, -0.22939520f, -0.19469561f, -0.36865768f, 
    0.04186011f, -0.11974081f, 0.00441002f, -0.05746955f, 0.09462592f, 0.08119606f, -0.00421165f, -0.05366720f, 
    0.14711928f, 0.07422818f, 0.06352692f, 0.07702441f, -0.01530419f, 0.10518851f, 0.02264735f, -0.09491606f, 
    -0.00896431f, -0.06829704f, -0.00259759f, -0.01192521f, 0.08113464f, 0.10514424f, -0.02219240f, 0.03276899f, 
    -0.23716170f, -0.16004796f, 0.10161647f, -0.08927642f, 0.02546467f, 0.06709230f, -0.15252273f, 0.18229277f, 
    0.03792045f, 0.12187138f, -0.01259065f, -0.03820329f, 0.13683327f, 0.24825343f, 0.16184957f, 0.05281310f, 
    0.04081337f, 0.04912535f, 0.02744777f, 0.06586925f, 0.13619980f, -0.05215314f, -0.00556882f, 0.06454948f, 
    -0.07414109f, 0.13418086f, 0.08340276f, -0.09965317f, 0.07153193f, 0.10982969f, -0.20847797f, -0.02624748f, 
    -0.06645449f, 0.02270689f, 0.12404479f, 0.04163354f, -0.03979723f, 0.15799353f, -0.00563996f, -0.11979836f, 
    0.30488926f, 0.06377116f, 0.13866353f, 0.00785622f, 0.03803397f, -0.03445099f, -0.06166482f, 0.02391622f, 
    0.04514820f, -0.01021749f, -0.06072053f, -0.05211847f, -0.05397801f, 0.04824606f, -0.00067429f, -0.01363622f, 
    -0.01890057f, 0.01394047f, 0.02119934f, 0.02575262f, 0.03582426f, -0.05993076f, -0.01840309f, -0.01873562f, 
    -0.04203669f, -0.00541080f, -0.04473451f, 0.03227118f, 0.03180653f, -0.05405739f, 0.03773981f, -0.04625970f, 
    -0.02875687f, -0.04747437f, -0.04260096f, 0.05532143f, -0.05556167f, -0.03948237f, -0.06518215f, -0.03858544f, 
    -0.04230284f, -0.05062393f, -0.00308533f, 0.03087328f, -0.05748207f, -0.01427519f, 0.04049897f, 0.03430334f, 
    0.04251269f, -0.02221868f, -0.04958816f, 0.04676727f, 0.02120518f, 0.00124786f, -0.00458236f, -0.04074004f, 
    0.02804327f, -0.05682212f, 0.01553428f, -0.03923085f, -0.01095308f, 0.02944972f, 0.03273047f, -0.03368577f, 
    0.04169135f, 0.03125296f, -0.05060153f, 0.03188732f, 0.02156046f, 0.01509799f, -0.05492987f, -0.03945166f, 
    -0.06812277f, 0.03768234f, -0.05295866f, 0.00032849f, -0.05701660f, 0.02609997f, 0.05219018f, 0.04142033f, 
    0.04029452f, -0.05509386f, 0.03412656f, -0.03861890f, 0.03788297f, 0.02937802f, 0.01767755f, 0.04437454f, 
    0.03266031f, 0.01647872f, -0.03480289f, 0.03215181f, 0.02979741f, 0.03739963f, -0.05943930f, 0.02619750f, 
    0.04428208f, 0.03622367f, 0.05433626f, 0.04782452f, -0.06730580f, -0.06427054f, 0.00397806f, 0.01586144f, 
    -0.02512027f, -0.00526522f, 0.03698039f, -0.05877381f, 0.04194034f, 0.04678428f, -0.03790217f, -0.03743701f, 
    0.03616742f, 0.00314632f, -0.03955894f, -0.01181012f, -0.03148391f, 0.03580846f, 0.03085524f, -0.00440752f, 
    -0.02951658f, 0.02426817f, 0.02459364f, -0.02846577f, 0.04430908f, -0.01179240f, -0.01839544f, -0.01542150f, 
    -0.04797221f, -0.05153733f, -0.03903168f, -0.03326400f, -0.00892095f, 0.04365310f, 0.00893198f, -0.06377938f, 
    0.02999848f, -0.04137519f, -0.00543081f, 0.01798526f, 0.05148621f, 0.01727378f, -0.01575828f, -0.04519202f, 
    -0.03787202f, -0.04106403f, 0.03162479f, -0.03421990f, 0.02157478f, 0.01798297f, -0.03438295f, -0.01623066f, 
    -0.04866099f, 0.03786707f, -0.03328945f, -0.04239682f, 0.03628194f, -0.06272840f, 0.03112213f, 0.01612955f, 
    -0.01383302f, 0.02215688f, -0.02261566f, -0.03677925f, -0.01858139f, -0.00513845f, -0.01240457f, -0.04016184f, 
    -0.05400996f, -0.00053544f, -0.01503119f, -0.04258242f, -0.06374409f, -0.01711195f, -0.05118427f, -0.06960132f, 
    -0.02635709f, 0.03642656f, 0.02486067f, 0.02010653f, -0.04210503f, -0.00742464f, -0.01169752f, 0.04024452f, 
    0.00747265f, -0.02648362f, -0.00157270f, -0.00297332f, 0.00491051f, -0.04413650f, -0.04273779f, -0.03357590f, 
    -0.02509692f, -0.04082552f, -0.01954251f, 0.02938658f, 0.02268845f, -0.03500735f, -0.04172772f, -0.04704547f, 
    0.04271593f, -0.02038089f, -0.02894697f, 0.01090513f, -0.05931710f, -0.04675730f, 0.00321133f, -0.05614097f, 
    -0.01880130f, 0.00701461f, 0.00346111f, 0.00234782f, -0.05875964f, -0.02662468f, -0.03082606f, -0.06200089f, 
    -0.04377922f, 0.01274357f, 0.01358969f, 0.02744385f, -0.00531351f, -0.06384920f, -0.05052788f, 0.00136482f, 
    0.02872211f, -0.03923536f, 0.03096226f, 0.04789023f, -0.01021470f, -0.03880771f, -0.02612659f, 0.00146429f, 
    -0.02066419f, -0.00288312f, 0.00014337f, 0.02992024f, 0.03966345f, 0.03454353f, -0.04232605f, -0.03947773f, 
    -0.04849724f, -0.06848398f, -0.01167628f, -0.05859724f, 0.03236458f, 0.00514815f, 0.01014210f, -0.01261629f, 
    -0.02372881f, -0.05951934f, -0.01142702f, 0.04107875f, -0.06248071f, 0.04805882f, 0.04334215f, -0.02055644f, 
    -0.05674278f, -0.06123439f, 0.01798629f, 0.02031464f, -0.05682585f, -0.05922287f, 0.04122265f, -0.01255934f, 
    -0.02940713f, -0.05390157f, -0.00773816f, -0.02934782f, 0.03752431f, 0.03927136f, 0.03532399f, 0.04336631f, 
    0.05593902f, -0.05455883f, -0.03448131f, -0.06771474f, -0.01670292f, -0.02888607f, 0.04951778f, -0.03264824f, 
    0.03282755f, -0.05158595f, 0.01066403f, 0.04936861f, 0.03189489f, -0.05846711f, 0.04688372f, 0.05001016f, 
    -0.00406971f, -0.05847408f, 0.01690656f, -0.03956497f, -0.01353887f, -0.04487110f, -0.01819852f, -0.01161077f, 
    0.17966953f, 0.22101970f, 0.32558295f, -0.00843846f, 0.09333191f, -0.07851117f, -0.02097593f, -0.11398086f, 
    -0.16104443f, -0.05720983f, -0.03899681f, 0.01545149f, 0.10615467f, 0.07542806f, 0.03420269f, -0.06625307f, 
    0.13192217f, -0.01594131f, -0.14305493f, -0.22210561f, -0.16663446f, -0.27485684f, -0.08959167f, -0.25980815f, 
    0.10467032f, 0.04118428f, 0.02904736f, 0.16452782f, -0.13864493f, -0.16929817f, -0.05436418f, 0.11481812f, 
    0.03488164f, -0.01197764f, -0.10374107f, -0.12009078f, 0.03864127f, 0.05915533f, 0.27995229f, 0.02858635f, 
    -0.01400495f, 0.09673518f, 0.08263207f, -0.09909993f, -0.21546537f, -0.16232999f, -0.00685804f, -0.05414857f, 
    -0.02108923f, 0.09308955f, 0.09227210f, 0.02733533f, 0.00278540f, 0.11352108f, -0.17696112f, 0.06030915f, 
    0.09746134f, 0.19359481f, 0.11237182f, 0.07785678f, 0.07371762f, 0.06297623f, 0.03979180f, -0.20703927f, 
    0.08875819f, -0.03030220f, 0.18259659f, -0.04847043f, 0.14140975f, -0.14868483f, 0.09848905f, 0.10953462f, 
    0.27989873f, 0.07886790f, 0.06691878f, -0.10082725f, -0.09758959f, -0.06589453f, -0.04899067f, 0.12171292f, 
    0.01397120f, -0.13735510f, 0.00201927f, 0.21640277f, 0.01100386f, -0.01894883f, -0.19597030f, 0.05136011f, 
    -0.02926757f, -0.12081933f, 0.01605052f, 0.02404058f, 0.05985733f, 0.22694194f, 0.13231793f, 0.12737587f, 
    -0.09433192f, -0.02325805f, -0.12496168f, -0.01640177f, -0.40349528f, -0.33162972f, -0.02863891f, -0.00376534f, 
    0.00701235f, -0.02636813f, -0.07436798f, -0.05993538f, 0.02028101f, -0.06968517f, 0.04900939f, -0.08491022f, 
    0.02517127f, 0.01977370f, -0.11598133f, 0.05834340f, 0.05167821f, 0.05466990f, 0.11888121f, 0.15160607f, 
    0.05382943f, 0.10363249f, 0.13778357f, -0.03984686f, 0.08921292f, 0.06180426f, 0.14718807f, -0.03457481f, 
    0.13927487f, 0.00335232f, 0.02672761f, -0.00243379f, 0.05886260f, 0.02076502f, -0.07340489f, 0.32553801f, 
    0.03835755f, -0.28241065f, 0.09858555f, -0.09087148f, 0.01415663f, 0.06295818f, -0.04422190f, 0.09528250f, 
    0.05941771f, 0.25522876f, 0.10053671f, -0.10130630f, 0.11912430f, 0.02385221f, 0.17313762f, 0.05651018f, 
    -0.08117468f, -0.27938572f, 0.07198974f, 0.01331163f, -0.12200641f, 0.06957690f, -0.20416327f, 0.15108906f, 
    0.06432549f, -0.01942083f, 0.15347005f, -0.39018315f, -0.18043995f, -0.04479731f, 0.06631716f, 0.09979057f, 
    0.07737271f, -0.07619791f, -0.07036541f, -0.01878843f, -0.12947053f, 0.02272348f, 0.06894515f, 0.07364151f, 
    -0.07503682f, 0.01374934f, 0.02973764f, -0.08305483f, 0.10732212f, -0.03794537f, -0.07854550f, 0.15221477f, 
    0.03951613f, -0.13987911f, -0.01509287f, -0.08329559f, 0.08378368f, 0.04416059f, 0.14035009f, -0.08802087f, 
    -0.31039616f, -0.10008762f, -0.10571098f, -0.07747459f, -0.04388385f, -0.09475467f, 0.12990507f, 0.05962352f, 
    0.06656756f, -0.03546358f, 0.10564824f, 0.06599502f, 0.13527921f, 0.10334307f, 0.02529230f, -0.09664044f, 
    0.06468739f, -0.13243620f, 0.14874159f, 0.08608415f, -0.11061375f, 0.08452974f, -0.12629257f, -0.17328450f, 
    0.18877865f, -0.10684871f, -0.32495511f, 0.15484405f, -0.06546246f, -0.08734127f, 0.12668616f, 0.02873942f, 
    0.09602141f, -0.20579654f, 0.01329619f, -0.05619361f, 0.06192657f, 0.16455005f, 0.00138657f, 0.02426631f, 
    -0.07010120f, 0.15708017f, 0.02214644f, 0.08343593f, -0.09970883f, -0.08299904f, 0.12618740f, -0.14547499f, 
    0.04727950f, -0.19394299f, 0.03610850f, -0.35956189f, -0.02590567f, -0.03936207f, 0.10414913f, 0.01407377f, 
    0.17635010f, -0.19320142f, -0.07281388f, 0.16503653f, 0.34880510f, 0.03762237f, -0.07437331f, -0.09081998f, 
    -0.12830693f, -0.06793586f, 0.06548214f, -0.02013971f, 0.00219001f, 0.42074975f, -0.29724964f, -0.12458910f, 
    0.00084567f, -0.02417313f, 0.11543812f, -0.14166869f, -0.11643695f, 0.00789675f, -0.21549366f, 0.28323010f, 
    0.33605632f, -0.03218210f, 0.06682789f, 0.10967074f, 0.06252965f, 0.02584428f, 0.00822796f, -0.16462636f, 
    0.03618987f, -0.07657496f, -0.03512875f, -0.13503210f, -0.06720173f, -0.02473314f, -0.02366186f, -0.18890549f, 
    -0.06432729f, 0.09513843f, 0.05113901f, -0.05361405f, 0.03913046f, 0.13336512f, -0.06886350f, -0.02599677f, 
    -0.02787028f, -0.22091809f, 0.14201678f, 0.12973827f, 0.07651530f, 0.07354564f, 0.05644557f, 0.07408711f, 
    0.11082624f, 0.10297267f, -0.20284759f, -0.35746413f, -0.22968365f, 0.04637207f, 0.01669518f, -0.14459215f, 
    -0.10889439f, -0.01958773f, 0.06599638f, 0.40450177f, -0.17953560f, -0.29635531f, -0.15008073f, 0.06364086f, 
    -0.23448724f, 0.07520031f, 0.12458327f, -0.15032554f, 0.01057978f, -0.09366059f, 0.14141770f, 0.06031885f, 
    0.17328382f, 0.11814483f, 0.02825212f, 0.09671542f, 0.04611417f, -0.29331666f, -0.05444076f, -0.28759915f, 
    0.20085883f, 0.07381436f, -0.00340458f, -0.08677118f, 0.02467575f, 0.19657871f, 0.22244796f, 0.23954168f, 
    0.00050599f, 0.09440191f, 0.11275327f, -0.01062839f, -0.04226054f, 0.08448916f, -0.02349446f, -0.14392839f, 
    0.24638462f, -0.01251279f, -0.01061366f, 0.08058181f, 0.15133251f, 0.00591355f, -0.16968797f, 0.11254675f, 
    -0.38801953f, -0.09880654f, -0.39439079f, 0.06553345f, 0.07013280f, -0.29075503f, 0.08569718f, -0.09070090f, 
    0.00648639f, 0.23132250f, 0.16402106f, 0.23814437f, -0.11264534f, -0.07551593f, 0.06580231f, 0.01048578f, 
    0.02966671f, 0.12283298f, -0.08066210f, -0.08062769f, 0.12820727f, -0.02958769f, -0.10797156f, 0.05650471f, 
    0.08170435f, 0.07439403f, -0.14208823f, 0.04325731f, -0.06785995f, -0.12739323f, -0.03587646f, -0.08076646f, 
    -0.11561340f, 0.07467629f, 0.13572297f, 0.01545087f, 0.23025778f, 0.04712726f, 0.09292191f, -0.10621249f, 
    0.12825260f, -0.04086564f, -0.05287931f, 0.09319286f, -0.06022150f, -0.08907673f, 0.01464341f, 0.04283812f, 
    -0.01530268f, -0.03502239f, 0.04379566f, 0.12798996f, -0.06090659f, -0.15736699f, 0.04983824f, -0.04191538f, 
    -0.08367796f, 0.12123439f, 0.02148666f, -0.03272791f, -0.01414443f, 0.06827942f, -0.22977418f, 0.11889207f, 
    -0.04481173f, -0.16000482f, 0.08822154f, -0.15210895f, -0.02988877f, -0.07138418f, 0.05267246f, 0.02484945f, 
    0.00372627f, 0.06553763f, -0.01958330f, 0.03533215f, -0.07335050f, 0.08019430f, 0.06296947f, -0.02502105f, 
    -0.12510398f, 0.04797114f, -0.01286593f, -0.10043506f, -0.04317626f, 0.11014713f, -0.07059895f, 0.07267863f, 
    0.13145918f, -0.01436553f, 0.35832772f, 0.03952131f, -0.21894360f, -0.00546786f, 0.02931196f, -0.11579321f, 
    0.04440024f, 0.33062994f, -0.06902274f, -0.18701434f, -0.00343864f, 0.06614552f, 0.00565897f, -0.01599642f, 
    0.00529332f, 0.10124493f, 0.08728002f, -0.01181605f, 0.02958318f, -0.04392092f, 0.25242418f, -0.05898787f, 
    0.21770769f, 0.07124583f, 0.08401778f, 0.02603068f, 0.04897979f, -0.01997624f, -0.40376526f, -0.30669278f, 
    -0.14327514f, -0.03302974f, -0.00513009f, -0.07543476f, -0.14730859f, -0.07169537f, 0.23848997f, 0.14354381f, 
    0.19181824f, 0.22428367f, 0.04387620f, 0.14956330f, -0.00735829f, 0.00582917f, 0.20850688f, -0.20106982f, 
    0.01332669f, -0.09909458f, -0.13466227f, -0.01457888f, 0.12176712f, 0.07642563f, -0.08018113f, -0.14598358f, 
    -0.15329844f, -0.22195517f, -0.01214687f, 0.15803358f, -0.27339429f, -0.15475726f, -0.08225432f, 0.05683719f, 
    -0.22663766f, 0.06098035f, 0.14215729f, 0.12322003f, -0.02551468f, 0.05624826f, 0.06865538f, -0.03897917f, 
    0.09942029f, 0.19587232f, -0.18930361f, -0.20942762f, -0.24261877f, 0.00818120f, -0.19651002f, -0.10261380f, 
    0.00598965f, -0.00641121f, 0.05290266f, -0.24278401f, -0.14512195f, 0.00527162f, 0.02514298f, -0.01103972f, 
    0.02081469f, 0.06086913f, 0.07779698f, 0.22723864f, 0.34089166f, -0.18912478f, 0.21359742f, -0.05379258f, 
    0.11376449f, 0.27614677f, 0.15067708f, -0.14158377f, 0.18510927f, -0.29207221f, -0.26656520f, -0.25487980f, 
    0.15580289f, -0.04013336f, -0.08263239f, -0.15128878f, -0.00692717f, 0.00491878f, 0.13753036f, 0.32986587f, 
    -0.03830691f, -0.03689818f, 0.03745145f, 0.02995307f, 0.02079914f, 0.03219575f, 0.01297909f, -0.02975617f, 
    -0.09411540f, 0.13338664f, 0.03473771f, 0.00429564f, 0.10042232f, 0.07069178f, -0.16628070f, -0.09816273f, 
    -0.15168713f, -0.03927974f, -0.01224466f, 0.02427352f, 0.03738995f, 0.13109052f, 0.08828292f, 0.08548654f, 
    0.00714113f, 0.12443200f, 0.11854403f, 0.07234686f, -0.16271389f, -0.02615221f, -0.06535666f, 0.03733200f, 
    -0.12080388f, -0.06744100f, -0.27474555f, 0.06424921f, 0.21821025f, 0.14108418f, 0.12030096f, -0.11682395f, 
    -0.24162242f, -0.11342692f, -0.04548825f, 0.08952992f, 0.17230654f, 0.07440824f, 0.19733359f, 0.05992758f, 
    0.04740340f, 0.05928708f, -0.05911032f, -0.05175648f, -0.09808981f, 0.08995246f, -0.04559448f, 0.04745620f, 
    0.04436257f, -0.00575318f, 0.09932854f, 0.06795254f, -0.08584993f, -0.02436768f, 0.12191262f, -0.14193690f, 
    0.18169095f, 0.18030228f, 0.06931008f, -0.08667760f, 0.04897804f, -0.07531448f, -0.03362518f, 0.06194888f, 
    -0.09783369f, 0.04695854f, 0.02735294f, -0.08374871f, -0.32962638f, -0.19187503f, -0.21319614f, -0.00728740f, 
    0.11539636f, -0.08051321f, 0.17030370f, -0.06724615f, 0.03175967f, -0.36326978f, -0.13599887f, -0.22265314f, 
    -0.20676830f, -0.10646298f, -0.05268605f, 0.08827925f, 0.02345192f, 0.03947692f, -0.03079931f, -0.12051667f, 
    0.09944196f, -0.01970224f, 0.16538177f, 0.33045867f, -0.05501265f, -0.00726949f, 0.09591511f, 0.07426795f, 
    -0.05219159f, 0.04371532f, -0.10331164f, 0.07188790f, -0.08842753f, -0.16282888f, -0.06351147f, 0.04257942f, 
    0.03401164f, 0.13670580f, 0.08672136f, 0.03550291f, 0.17147903f, 0.04843962f, -0.02758011f, -0.14530280f, 
    -0.05963646f, 0.02220815f, 0.09355854f, 0.04730617f, 0.16204569f, 0.11336812f, 0.11054783f, -0.03122314f, 
    0.02595150f, -0.04438383f, -0.17189337f, -0.14895903f, -0.01340300f, 0.13116099f, -0.11045951f, 0.01549563f, 
    -0.13033229f, 0.02797447f, -0.10601239f, 0.07742205f, -0.16190696f, -0.05524552f, 0.08130945f, -0.17673621f, 
    0.06349928f, 0.07489302f, -0.08113424f, 0.12426561f, -0.13383004f, 0.05036758f, -0.14082059f, 0.09805733f, 
    -0.06982451f, 0.09671570f, 0.05209058f, -0.05396646f, 0.11886490f, -0.15992928f, 0.00721363f, -0.10379994f, 
    -0.13507766f, -0.01284091f, 0.08527482f, 0.07706279f, 0.02278850f, 0.06689368f, -0.12519510f, 0.01155631f, 
    -0.08179124f, -0.27697432f, -0.01409077f, 0.04784174f, 0.03231175f, -0.02714565f, 0.06101067f, -0.10935116f, 
    -0.01863375f, -0.23467018f, -0.05100619f, 0.08238078f, -0.03345869f, 0.15814292f, -0.08732279f, 0.03028353f, 
    0.05846638f, 0.07613358f, 0.05540361f, 0.05893505f, -0.03541360f, 0.24444848f, 0.04013834f, -0.11337588f, 
    0.05860659f, 0.06359969f, -0.09182315f, 0.04486440f, -0.00822434f, 0.19333577f, 0.01730247f, -0.12920614f, 
    0.01148890f, 0.06627081f, 0.00502193f, 0.15790644f, 0.09994610f, -0.12710659f, -0.01488529f, 0.08865879f, 
    0.05281471f, 0.10417711f, -0.01360562f, 0.01890571f, -0.02099868f, -0.11165038f, 0.08027121f, 0.18733747f, 
    0.00527090f, 0.05231985f, 0.06804533f, -0.03098770f, -0.03768932f, 0.15715608f, 0.01274963f, -0.11897382f, 
    -0.02682882f, 0.03619215f, -0.05598442f, -0.01431820f, -0.06240524f, 0.21319838f, 0.08424702f, 0.18003708f, 
    -0.02308565f, 0.06175079f, 0.04530020f, 0.03941552f, 0.11011313f, 0.13721925f, -0.11708799f, 0.10578368f, 
    -0.27659243f, 0.00230743f, 0.03185927f, -0.08972638f, -0.00012454f, 0.02941396f, 0.02000292f, -0.04663768f, 
    0.05225588f, 0.11089911f, -0.08238102f, -0.07715368f, -0.03055354f, 0.24428067f, 0.12555322f, 0.14518666f, 
    -0.20613275f, 0.08952827f, -0.04335463f, 0.04083945f, -0.06397199f, 0.06980886f, 0.08610982f, 0.15411456f, 
    -0.04765459f, -0.28736362f, 0.00719290f, -0.15535136f, 0.24567279f, 0.32443294f, 0.30143899f, 0.03944270f, 
    0.10787676f, 0.00815074f, 0.26801124f, 0.24467073f, 0.21386580f, 0.13261113f, -0.11123887f, 0.14281626f, 
    0.15850890f, 0.08006154f, 0.07538588f, 0.09528414f, -0.01329401f, -0.02244396f, 0.08604361f, 0.13482493f, 
    0.11789142f, -0.04951165f, 0.11918934f, -0.05254858f, -0.08479042f, -0.14120483f, -0.08150916f, 0.09386564f, 
    0.31827968f, 0.29014367f, -0.10466390f, -0.02272647f, -0.17820841f, 0.22307146f, 0.22489971f, 0.17681670f, 
    0.08711305f, -0.03757548f, 0.10589305f, -0.00907770f, 0.18711317f, 0.16075321f, -0.08746702f, 0.03318168f, 
    -0.11243217f, -0.01845935f, -0.12484764f, 0.06006879f, -0.14826170f, -0.24525055f, -0.06248048f, -0.06516937f, 
    0.10697098f, -0.07982292f, 0.04612345f, -0.12572879f, 0.29903379f, -0.09782531f, -0.00250495f, 0.04707395f, 
    -0.10717374f, -0.10785851f, -0.13249074f, -0.17774318f, -0.13076034f, -0.08979485f, 0.12207483f, -0.00925791f, 
    -0.03802783f, 0.07331683f, -0.23299605f, -0.07554918f, 0.20141372f, 0.12281125f, -0.03801411f, 0.17691185f, 
    0.11714317f, 0.08814429f, 0.13410313f, 0.00458056f, -0.07070087f, 0.19650455f, -0.20767929f, -0.05353283f, 
    -0.08798420f, 0.04423794f, -0.06063494f, -0.27140191f, 0.07731153f, -0.09343978f, 0.27042377f, -0.06145331f, 
    0.04195725f, 0.18238673f, 0.15373671f, -0.00295444f, 0.03186829f, -0.15028156f, -0.00810551f, -0.14771201f, 
    0.34287903f, 0.11699473f, -0.12600112f, 0.09238890f, -0.34374359f, -0.06767876f, -0.10322834f, 0.05139847f, 
    0.09746392f, 0.06684854f, 0.08889280f, 0.06370045f, 0.03349662f, -0.01837956f, -0.05772509f, 0.01269328f, 
    -0.09872201f, 0.25703821f, -0.13106367f, 0.08425698f, 0.10819928f, 0.12891385f, 0.07937545f, -0.02994283f, 
    -0.04107096f, -0.07113331f, -0.27080876f, 0.11064190f, 0.11845196f, -0.03670998f, -0.08186953f, -0.21297476f, 
    -0.14987303f, -0.16968545f, 0.04539802f, 0.01815826f, 0.07414687f, 0.11627779f, 0.06657480f, -0.02426876f, 
    0.10032494f, -0.01927854f, -0.03322153f, -0.16223700f, -0.04865190f, -0.17916459f, 0.08561938f, 0.04619392f, 
    0.13872626f, -0.14311951f, -0.17095289f, -0.06353712f, 0.02395237f, -0.04792587f, 0.28433609f, 0.13690673f, 
    0.00990442f, -0.10622479f, -0.12919505f, -0.04639604f, 0.00268174f, -0.07051161f, -0.23239931f, -0.05980824f, 
    0.49512079f, -0.02087025f, -0.19138235f, -0.27863830f, -0.09192468f, -0.14838094f, 0.11282766f, 0.13996093f, 
    0.09489872f, 0.22616404f, 0.11926232f, 0.01714650f, 0.05785458f, -0.05146549f, 0.01550672f, 0.17412336f, 
    -0.09743705f, -0.10655645f, -0.08944527f, -0.01874563f, -0.34623814f, -0.20502812f, -0.03220814f, 0.05685710f, 
    0.22591186f, 0.05078478f, 0.12648992f, 0.14915743f, 0.04747936f, 0.10563228f, 0.12926693f, 0.06995163f, 
    -0.02700584f, -0.03954652f, -0.04270263f, 0.06826395f, 0.12629931f, 0.06147867f, 0.09348731f, -0.06338318f, 
    0.04752942f, -0.06521594f, -0.09019936f, 0.06283069f, -0.02737708f, -0.07482495f, -0.08614535f, -0.19539016f, 
    -0.05714491f, 0.08497287f, -0.03024644f, -0.10240437f, -0.17179745f, -0.07473165f, -0.05274313f, -0.13344799f, 
    0.06286108f, -0.12830375f, -0.11777351f, -0.05551627f, 0.04178729f, 0.16434388f, -0.06252178f, 0.19817135f, 
    0.08777172f, 0.14581761f, 0.01299100f, -0.08111825f, -0.12795691f, -0.19503534f, 0.04232349f, 0.09989116f, 
    -0.05670332f, 0.07655662f, 0.14386010f, 0.13220549f, 0.21057917f, 0.20072265f, 0.00227740f, 0.00664454f, 
    0.13642643f, -0.23451275f, -0.09113447f, -0.17943378f, -0.17152135f, -0.07663596f, -0.12962371f, -0.10523562f, 
    0.02890247f, 0.11599912f, 0.11811267f, 0.07518425f, -0.03739187f, 0.09767219f, -0.15797012f, -0.03617492f, 
    -0.08168069f, 0.20796824f, 0.14417636f, 0.16095605f, 0.21088400f, 0.18421964f, 0.08744558f, -0.08498505f, 
    -0.02310083f, -0.10922713f, 0.11782908f, 0.07379244f, 0.10786755f, 0.00939326f, -0.09525229f, 0.01756039f, 
    -0.13267958f, 0.01491393f, -0.05769173f, 0.10566768f, -0.04580929f, 0.13378395f, 0.02632369f, 0.06724072f, 
    -0.08519520f, -0.13197409f, -0.05865528f, -0.17745042f, 0.04924326f, -0.68882787f, 0.14171314f, -0.01679936f, 
    0.09734385f, -0.14092126f, 0.01930837f, 0.02265455f, -0.03998532f, -0.15584363f, -0.18465534f, 0.06293969f, 
    0.03956079f, -0.13783830f, -0.09559053f, -0.22508320f, 0.00895070f, -0.02729071f, 0.48990440f, -0.06295502f, 
    -0.11748006f, -0.06829719f, -0.12187207f, -0.04884205f, 0.00822584f, 0.02176070f, -0.07329095f, 0.04661009f, 
    -0.16338691f, 0.04108683f, -0.02379075f, -0.22040801f, -0.16086969f, 0.01776345f, -0.05633077f, -0.17352295f, 
    -0.04455324f, -0.02367607f, -0.09848499f, -0.14382552f, 0.12656328f, -0.10454808f, -0.11078209f, -0.09683412f, 
    0.01963037f, 0.04103252f, 0.03674254f, 0.11841550f, 0.05892807f, 0.06044095f, 0.09443124f, 0.05248681f, 
    -0.04431977f, 0.06188892f, -0.09077458f, -0.11186919f, 0.07967866f, 0.06067806f, -0.04780415f, -0.15573020f, 
    0.18689418f, -0.00821825f, -0.05257698f, -0.08481542f, 0.18018566f, 0.16938956f, 0.11921657f, 0.00341869f, 
    -0.11608220f, -0.04586393f, 0.05290848f, -0.04629149f, -0.10698394f, 0.10282701f, -0.28026369f, 0.00472083f, 
    -0.10821733f, -0.06036568f, -0.01069908f, 0.09355742f, 0.09512352f, -0.11419293f, -0.20893872f, -0.37581709f, 
    -0.00749556f, 0.05968760f, -0.08385399f, 0.01130208f, -0.08782486f, 0.04241886f, 0.17131688f, 0.00685126f, 
    -0.04021741f, -0.06262635f, 0.05223934f, -0.10003594f, 0.05494199f, 0.10000417f, 0.03980622f, 0.16708092f, 
    0.13392511f, 0.13232929f, -0.12760407f, 0.06404944f, -0.09580250f, 0.09968712f, -0.00672575f, 0.01484241f, 
    -0.06554490f, -0.31995606f, -0.41381875f, 0.04423919f, 0.14331928f, 0.05602124f, 0.12098819f, 0.09047703f, 
    0.07151906f, 0.01463385f, -0.51477212f, -0.50178027f, -0.05391528f, 0.17700160f, 0.02960665f, 0.12720419f, 
    -0.01881909f, -0.13611607f, 0.37607726f, 0.23375642f, 0.30652231f, 0.00739349f, -0.04347000f, -0.03491848f, 
    0.09337102f, -0.01347002f, 0.02988860f, -0.05536355f, 0.07293332f, -0.08302158f, 0.09602419f, 0.09102271f, 
    0.07345865f, 0.02523081f, 0.14252593f, 0.02781817f, -0.02091136f, -0.07676486f, 0.03355165f, 0.03953795f, 
    -0.05537972f, 0.14813763f, 0.16018520f, 0.19646807f, -0.10555784f, 0.15932238f, 0.15226200f, 0.12298889f, 
    0.01623225f, 0.04559765f, 0.08159222f, 0.03091125f, -0.02855054f, -0.04995123f, -0.00533836f, 0.20917407f, 
    0.19461639f, 0.07741845f, 0.12201419f, -0.00463750f, 0.04068483f, 0.08760460f, -0.07803505f, -0.32091102f, 
    -0.16555491f, 0.15672000f, 0.09938812f, -0.09672993f, -0.03024843f, 0.00301573f, 0.08922756f, 0.17155306f, 
    0.16495149f, 0.03279594f, 0.18445656f, -0.06207234f, 0.13555901f, -0.02018658f, 0.08076776f, -0.09132741f, 
    -0.11335018f, -0.37125224f, -0.05857990f, -0.19607048f, -0.24245830f, 0.13669236f, 0.00069219f, 0.06454833f, 
    -0.06691802f, 0.00732838f, -0.19047503f, 0.03511299f, 0.15739308f, 0.10526325f, 0.27683270f, -0.20666333f, 
    -0.01142312f, 0.03705749f, 0.04513121f, 0.00784893f, -0.06175284f, -0.01915717f, 0.08402598f, 0.04617173f, 
    0.12689883f, 0.10038422f, -0.03273655f, -0.11523353f, 0.04255213f, 0.30119887f, 0.15318182f, -0.11798115f, 
    -0.01445177f, 0.10065598f, 0.09493899f, 0.08592313f, 0.06106181f, -0.05852973f, -0.32592839f, -0.04574410f, 
    -0.07539297f, -0.10046778f, -0.15507169f, 0.04215795f, -0.05440667f, 0.13204019f, 0.07805894f, -0.00338388f, 
    0.12187406f, -0.01822992f, -0.03066578f, 0.01653698f, -0.00816298f, 0.05285190f, -0.00460627f, 0.06866826f, 
    0.24658199f, 0.13584021f, -0.04698739f, 0.07882899f, 0.08527313f, -0.03730097f, -0.13312618f, -0.00208259f, 
    -0.07350163f, -0.28215960f, -0.19730148f, -0.06072647f, -0.16461954f, -0.08813871f, 0.12164730f, 0.09194049f, 
    0.08764973f, 0.00370111f, 0.09558912f, 0.06702352f, 0.04264737f, 0.16909163f, -0.12698758f, -0.14852440f, 
    -0.06726144f, 0.07515104f, -0.15043812f, -0.22391002f, -0.26921669f, 0.15390114f, -0.19806543f, 0.16008200f, 
    0.09671984f, 0.10864366f, 0.03139829f, 0.25154138f, -0.27142841f, -0.13734439f, 0.13574930f, 0.00800630f, 
    -0.06651881f, 0.02317597f, 0.09596027f, 0.01941042f, -0.64864916f, -0.29635516f, -0.19031554f, -0.12412842f, 
    -0.01384810f, 0.11297835f, 0.04317577f, 0.06249465f, -0.06422748f, -0.33598608f, -0.47597435f, -0.09813710f, 
    -0.13165629f, -0.04389055f, 0.16765885f, 0.02268568f, 0.10817348f, 0.06815332f, 0.29667169f, -0.04286897f, 
    0.00851632f, -0.14190193f, 0.08546870f, -0.08929011f, 0.06237753f, 0.04517995f, -0.04845307f, -0.00281252f, 
    -0.36528257f, -0.53179485f, 0.06376356f, 0.08162401f, 0.07397144f, -0.01981679f, 0.06971347f, -0.00707466f, 
    -0.09675933f, -0.07647294f, -0.01133410f, -0.04872526f, -0.01954625f, -0.03756781f, -0.04125082f, -0.02952430f, 
    -0.05643134f, -0.02108212f, -0.05318723f, -0.06057217f, -0.01239951f, -0.07232285f, -0.04340536f, -0.05058406f, 
    -0.00691308f, -0.06608514f, -0.05328491f, -0.00656682f, -0.03652082f, 0.04355339f, 0.01090783f, -0.02976313f, 
    -0.04775653f, -0.06966405f, -0.01630664f, -0.09061644f, 0.03163968f, -0.03379430f, -0.02785812f, 0.00177222f, 
    -0.02090849f, 0.03099634f, 0.02687326f, -0.03971520f, -0.08867214f, -0.07686190f, 0.00955845f, 0.02172078f, 
    -0.00848594f, -0.04688006f, 0.01893838f, -0.06729893f, -0.07119893f, -0.02101688f, -0.07907249f, -0.04193122f, 
    0.03869206f, -0.07404827f, -0.00378902f, -0.05544838f, -0.07368539f, -0.02784044f, -0.00707742f, 0.01777248f, 
    0.00269870f, -0.08606402f, -0.04798771f, -0.08762747f, -0.00084164f, -0.05156282f, -0.00460718f, 0.03349641f, 
    0.01558600f, 0.04175175f, -0.01561328f, -0.04100651f, -0.05611512f, -0.00368844f, -0.07606050f, 0.01219899f, 
    -0.03091609f, -0.00256747f, -0.05531882f, -0.01816915f, 0.07085017f, -0.02615089f, -0.02893331f, -0.02619256f, 
    -0.05462982f, -0.08811362f, -0.08345328f, -0.02739796f, -0.06715191f, 0.03429378f, 0.01542379f, -0.07373663f, 
    -0.09730040f, 0.01516723f, -0.01186094f, -0.03156762f, 0.01919496f, 0.00260771f, -0.02676553f, 0.04319803f, 
    -0.00266752f, -0.04836510f, 0.00006585f, -0.02137341f, 0.03513272f, 0.00333152f, -0.03639505f, -0.09371621f, 
    -0.08428784f, -0.05134796f, -0.07307765f, -0.04306103f, -0.07338762f, -0.05746556f, 0.01060949f, 0.01790142f, 
    0.01431730f, 0.00653865f, -0.00352753f, -0.05741003f, -0.04908193f, 0.01581200f, -0.00060320f, -0.07628915f, 
    -0.02074032f, -0.02362690f, -0.00653234f, 0.00169411f, -0.01812526f, -0.04146781f, -0.02392860f, -0.02282664f, 
    -0.02821121f, -0.02244215f, 0.02859692f, -0.00123275f, -0.01465250f, -0.00930549f, -0.03873450f, -0.05905969f, 
    -0.00016195f, 0.01494992f, -0.01414306f, -0.04013961f, -0.00263168f, -0.01495373f, -0.03150632f, -0.00041342f, 
    0.00047155f, 0.02514854f, -0.07139961f, -0.02478871f, -0.09165293f, -0.01109925f, 0.04904904f, -0.01566761f, 
    -0.06053963f, 0.00559116f, -0.00731250f, 0.03669195f, 0.01545545f, -0.03880645f, -0.00142354f, 0.02124391f, 
    -0.10412218f, -0.05146013f, -0.03932737f, -0.00808307f, -0.08164834f, 0.02005650f, -0.05961393f, 0.00289921f, 
    -0.08979767f, -0.05378920f, 0.02937393f, -0.02333423f, -0.01221155f, -0.08104028f, -0.02688536f, -0.04225088f, 
    -0.01731068f, -0.08060776f, 0.02687833f, 0.00889308f, 0.03820056f, -0.04989652f, -0.08080699f, 0.02018365f, 
    -0.05791074f, 0.01140747f, -0.05537245f, -0.07487687f, 0.00827193f, -0.02992654f, -0.08017663f, -0.01870529f, 
    -0.01361327f, 0.03081234f, -0.04839971f, -0.04549602f, 0.00513391f, -0.05985497f, -0.02572478f, 0.01739414f, 
    -0.04959749f, -0.06397779f, -0.01147371f, -0.00130586f, -0.07774070f, -0.08632817f, -0.03359396f, -0.06536266f, 
    -0.06587090f, -0.03010512f, -0.08082926f, -0.04220201f, -0.03204442f, 0.02253224f, 0.02236897f, -0.01287572f, 
    -0.03299356f, 0.03300889f, 0.00324289f, 0.01329528f, -0.01587148f, -0.02723105f, -0.03484258f, 0.02139458f, 
    -0.00245048f, -0.02078121f, -0.05825168f, -0.03437296f, -0.03554904f, -0.07788480f, -0.04816520f, -0.03440454f, 
    0.00248990f, -0.09565035f, -0.05502632f, 0.02524319f, 0.04113058f, 0.02022111f, -0.02491502f, -0.02357693f, 
    -0.04659876f, -0.06613299f, 0.00800991f, 0.06139605f, -0.05598295f, -0.06237504f, -0.05400300f, -0.03378541f, 
    -0.04732053f, 0.04767612f, -0.02251131f, -0.08681756f, -0.04233754f, -0.07426436f, -0.03939678f, -0.07576198f, 
    0.01877028f, 0.01287510f, -0.03655031f, -0.00636953f, 0.06003382f, -0.08563589f, 0.01497358f, 0.03625878f, 
    0.00340895f, -0.02204623f, -0.05691471f, -0.01671631f, -0.02355031f, -0.00145264f, 0.02252510f, 0.01184688f, 
    -0.03849309f, -0.01717546f, -0.07305162f, -0.03772286f, -0.00246924f, -0.06812447f, -0.03362218f, -0.07482187f, 
    0.01848595f, 0.02305985f, -0.08313630f, -0.06441260f, -0.05878698f, -0.07225616f, -0.09477275f, 0.01853521f, 
    -0.01025276f, -0.15770967f, -0.18251821f, 0.03051261f, 0.04148969f, 0.00190308f, 0.13224691f, 0.04405140f, 
    0.10326999f, -0.22413301f, 0.13309799f, 0.22862202f, 0.00617225f, 0.12288295f, 0.06803280f, -0.03303360f, 
    -0.05581507f, 0.04753337f, 0.15976128f, -0.27667984f, -0.21622336f, 0.04505568f, -0.01634942f, 0.05640109f, 
    -0.23102877f, -0.12523448f, -0.11865021f, -0.03722998f, -0.19744752f, -0.24530578f, 0.09938464f, -0.04777681f, 
    -0.05136370f, 0.11014882f, -0.00561400f, -0.04303437f, -0.12511480f, 0.09416966f, -0.04285384f, 0.01507115f, 
    0.10616609f, 0.09913755f, 0.08815865f, 0.13944568f, 0.09860390f, -0.36190239f, 0.08705019f, 0.11543017f, 
    -0.01009162f, 0.15041141f, -0.02985973f, -0.08941166f, 0.17354332f, 0.03644160f, -0.05958882f, 0.04906741f, 
    0.12719408f, 0.01405571f, 0.03803552f, 0.11651789f, 0.01539659f, -0.11864188f, 0.13791420f, -0.01452921f, 
    -0.14502418f, -0.13041180f, -0.18704692f, -0.11090439f, 0.02900984f, -0.19844648f, -0.07661517f, -0.11383551f, 
    -0.04285110f, 0.01810080f, -0.08348887f, 0.06709023f, 0.12826303f, 0.01832926f, -0.07013147f, 0.01774659f, 
    -0.07621989f, 0.13283320f, 0.08445423f, 0.18516336f, -0.03012373f, -0.05853244f, 0.09128743f, 0.07445197f, 
    -0.05335199f, 0.05361380f, -0.19055018f, -0.27269101f, -0.06701750f, 0.01811623f, -0.06419181f, 0.07018712f, 
    -0.00793201f, 0.05673533f, 0.06234299f, 0.13330644f, -0.00004110f, 0.04793325f, 0.04063635f, 0.00827664f, 
    0.22605695f, 0.11255478f, -0.03461459f, 0.11454515f, -0.01991208f, 0.12462395f, 0.02560220f, -0.01934749f, 
    -0.10936466f, -0.16411147f, -0.09883706f, -0.05370842f, 0.08832280f, -0.06311988f, -0.07915728f, 0.21847574f, 
    0.00507001f, 0.10169341f, -0.06938645f, -0.04835350f, -0.08059107f, 0.09801203f, -0.26157060f, -0.09407762f, 
    0.01846946f, -0.14903091f, 0.00945942f, -0.07884822f, 0.04627090f, -0.06530929f, 0.06951670f, 0.19724303f, 
    0.09605392f, 0.05770010f, 0.10328653f, 0.11906472f, 0.00355367f, -0.21854842f, -0.18259116f, 0.03511730f, 
    -0.37726712f, -0.27159241f, -0.24900474f, 0.04716047f, -0.02439510f, -0.16395244f, 0.02953626f, -0.10812081f, 
    0.03519724f, -0.02294453f, -0.00889624f, -0.02336688f, -0.02709400f, 0.11418020f, 0.08575889f, -0.02539012f, 
    -0.12360734f, -0.06695860f, 0.23554075f, -0.01792613f, -0.05610013f, 0.13325626f, 0.00080928f, -0.01131442f, 
    0.11630913f, 0.02077988f, 0.15675789f, 0.03005886f, 0.07126638f, -0.00765978f, -0.14354651f, 0.07181278f, 
    -0.01836707f, 0.00640410f, 0.07660370f, -0.06210628f, -0.14721213f, -0.08808502f, 0.08898348f, 0.00352024f, 
    -0.03352578f, 0.02760151f, -0.01337644f, 0.02313387f, -0.02000066f, 0.29302332f, 0.04704684f, -0.07417252f, 
    -0.04176997f, -0.09100579f, 0.01696436f, -0.09289867f, 0.11000905f, 0.06787916f, 0.09256459f, -0.09135117f, 
    0.14720789f, 0.04017946f, 0.09737930f, -0.02622158f, 0.21202773f, 0.02537408f, 0.07424377f, -0.02732076f, 
    -0.07820679f, -0.25766975f, -0.26771149f, -0.03707746f, -0.13905182f, 0.08449427f, 0.05710774f, -0.01292656f, 
    0.14428209f, 0.06042959f, -0.13488251f, 0.07005300f, 0.03612940f, 0.01078296f, -0.07828098f, -0.29708990f, 
    0.01944725f, -0.04752580f, 0.11460532f, -0.17432384f, 0.07849661f, 0.02981395f, -0.16071312f, 0.05891776f, 
    -0.06136510f, 0.17924967f, -0.15025419f, -0.05019430f, -0.03350693f, 0.01276143f, 0.19259582f, 0.03106366f, 
    0.01713074f, -0.07455695f, 0.05259909f, -0.28168550f, 0.10446274f, 0.14804320f, 0.01464619f, 0.13441829f, 
    0.04153679f, -0.24168925f, -0.01488755f, 0.10893005f, -0.13113490f, 0.06115777f, 0.16173607f, -0.02915355f, 
    -0.01920029f, 0.08301312f, -0.05313483f, 0.16421628f, -0.04744585f, -0.02762737f, -0.17790532f, 0.02232256f, 
    -0.01328568f, 0.09696886f, -0.02805850f, -0.01605192f, -0.06352109f, 0.12058293f, -0.28494424f, 0.17581239f, 
    0.18673944f, -0.09743474f, 0.13487187f, 0.04167710f, -0.01006768f, -0.04310736f, 0.10213400f, -0.01817285f, 
    0.11281777f, -0.05412130f, -0.04969157f, 0.05346384f, 0.07755818f, 0.07524431f, 0.13054903f, -0.01652707f, 
    -0.08032285f, 0.24849340f, 0.11385223f, 0.17759131f, 0.05111863f, 0.03578653f, -0.05315465f, -0.10838390f, 
    -0.00877697f, 0.10885946f, -0.12130576f, 0.15639655f, 0.01846091f, 0.11610967f, -0.12128069f, 0.05263104f, 
    0.02195518f, 0.11890647f, -0.39558929f, -0.17679644f, -0.20960276f, 0.16109493f, 0.05395327f, 0.13547356f, 
    -0.06421421f, 0.00092270f, 0.06823759f, 0.15362054f, 0.31959370f, 0.09856191f, 0.05391451f, -0.09728193f, 
    -0.08451179f, 0.00321704f, -0.08274800f, -0.12920691f, 0.05746120f, 0.11946890f, -0.05282475f, 0.05864446f, 
    -0.02065727f, 0.03694329f, -0.05304913f, -0.00411434f, 0.01298597f, 0.15089767f, 0.07152611f, 0.08993449f, 
    -0.24839981f, -0.16863178f, -0.32454228f, -0.00482450f, -0.22674918f, 0.22499236f, 0.09141272f, 0.15003967f, 
    0.01250852f, -0.08700360f, -0.15126321f, -0.01234100f, 0.00032001f, 0.13421129f, 0.09330089f, -0.03612641f, 
    -0.10020556f, -0.01395774f, -0.19055137f, -0.11722538f, -0.09820817f, -0.03674876f, -0.02970018f, 0.01852736f, 
    0.05538022f, 0.01492242f, 0.31347865f, -0.19635960f, -0.22923051f, 0.08106979f, 0.09091859f, -0.02023708f, 
    -0.03495498f, -0.27278143f, 0.03784745f, -0.33554336f, 0.33236298f, -0.09787463f, 0.16760801f, -0.00919200f, 
    0.02497427f, -0.13388948f, 0.20608135f, 0.06278098f, 0.25418743f, 0.07527618f, -0.08487123f, -0.09770886f, 
    -0.09970941f, -0.18794167f, -0.06827562f, 0.03631445f, 0.08803883f, 0.12297711f, 0.02990045f, 0.02715956f, 
    -0.08277299f, 0.05489636f, 0.09969984f, -0.10504933f, 0.00220186f, -0.14620985f, 0.04412051f, 0.07590631f, 
    -0.17410292f, 0.09198771f, -0.08420573f, -0.02619280f, 0.01598636f, -0.04441492f, 0.12012033f, 0.28554642f, 
    0.12066396f, 0.05995425f, -0.05509551f, -0.09507474f, 0.03797442f, -0.05742245f, -0.06610544f, 0.03725520f, 
    0.10540988f, -0.07227415f, -0.06291200f, -0.05194060f, -0.02255197f, 0.08648743f, -0.02843255f, -0.03822590f, 
    -0.03170390f, -0.05782548f, -0.08592445f, -0.03783456f, 0.10466672f, -0.02488700f, 0.09578475f, 0.03886572f, 
    -0.01868991f, 0.21696432f, 0.17963845f, -0.09226532f, -0.10386168f, -0.07657870f, -0.03814686f, -0.05746664f, 
    0.24316765f, -0.26330999f, -0.13810688f, 0.01939786f, 0.03486896f, 0.01015191f, 0.06287631f, 0.04858854f, 
    0.23434246f, -0.07957882f, -0.00393533f, 0.08391169f, -0.10129917f, 0.00551109f, 0.04080997f, -0.03025534f, 
    0.03393859f, 0.05582172f, -0.29587781f, -0.00948670f, 0.21161312f, 0.21516477f, 0.15456986f, 0.01952386f, 
    0.14289653f, 0.10540746f, 0.05897464f, -0.26269433f, 0.13184869f, 0.01180185f, 0.05817687f, -0.00317198f, 
    0.09857550f, -0.07070923f, 0.10939720f, -0.05114337f, -0.05344051f, -0.16391160f, 0.03079129f, -0.31555524f, 
    0.24889722f, 0.03510718f, -0.06411871f, -0.11893231f, -0.03769630f, 0.00028924f, -0.00016534f, 0.01729032f, 
    0.00727942f, -0.05203100f, 0.03234686f, 0.06604294f, 0.01764747f, 0.02034956f, 0.06138051f, 0.24904142f, 
    0.24290647f, 0.23842785f, 0.02140376f, -0.01671336f, 0.10555730f, 0.07216219f, -0.24525259f, -0.09400248f, 
    0.09198588f, -0.01777902f, -0.15107448f, -0.26280957f, 0.00893183f, 0.01577844f, -0.01901114f, 0.17317711f, 
    -0.00975178f, -0.00727903f, -0.01804907f, 0.09519380f, -0.03148818f, 0.23508982f, 0.07695946f, 0.10612531f, 
    -0.15677689f, 0.12492949f, 0.24015442f, 0.03711710f, -0.07023727f, -0.31799611f, -0.08252728f, -0.25989637f, 
    0.23144002f, -0.03802468f, -0.11212197f, 0.17866303f, 0.01772979f, 0.02807154f, -0.09727235f, 0.14913853f, 
    -0.10223845f, 0.15558703f, -0.01207814f, 0.04190774f, -0.21010134f, 0.03798915f, -0.15023977f, -0.20959519f, 
    -0.09390246f, -0.27320510f, -0.19519165f, 0.11149670f, -0.04215866f, 0.06131213f, 0.21107563f, -0.03922533f, 
    -0.17151059f, -0.07270228f, -0.05064569f, 0.12468495f, -0.13414007f, 0.08891750f, 0.07660354f, -0.00844592f, 
    0.13885428f, 0.09697121f, -0.23970555f, -0.01147554f, -0.03369731f, 0.00052439f, -0.00883900f, -0.26181594f, 
    0.12864895f, -0.27931684f, -0.07200313f, 0.05013636f, -0.12230688f, 0.02730703f, -0.01168206f, 0.05449500f, 
    0.02418650f, -0.02755324f, 0.03699160f, -0.00011107f, 0.02987836f, -0.01651332f, 0.02120916f, -0.05708717f, 
    -0.01039897f, -0.05203987f, -0.02408381f, 0.04428370f, -0.01473668f, 0.03096661f, -0.05579953f, -0.06489132f, 
    -0.01090323f, 0.04554791f, -0.02492705f, 0.01177934f, 0.03218864f, 0.03369864f, -0.03198703f, -0.03305310f, 
    -0.01661527f, -0.05868798f, 0.01975635f, -0.05761098f, -0.00884531f, -0.00425913f, 0.01111044f, -0.01606268f, 
    -0.06546067f, 0.03125195f, 0.02670429f, -0.06256333f, -0.02934916f, -0.02663918f, 0.02207532f, 0.04142728f, 
    -0.01891110f, 0.03592405f, -0.01817963f, -0.01756880f, -0.05927080f, -0.01488295f, 0.02076203f, 0.04176521f, 
    -0.02730185f, -0.05616293f, -0.05983830f, 0.00319496f, 0.01526485f, -0.00494835f, 0.02892639f, -0.04034856f, 
    -0.02002476f, 0.04768997f, -0.00374903f, -0.02771702f, -0.01099100f, -0.00315295f, -0.02307657f, 0.00665299f, 
    -0.01172698f, 0.03663539f, 0.02273672f, -0.01644305f, 0.04955523f, 0.04705295f, -0.06211329f, 0.04825534f, 
    0.04992364f, 0.02432331f, 0.03536453f, -0.06640972f, -0.04768948f, -0.00397854f, 0.00209534f, -0.05869491f, 
    -0.03214148f, 0.04517438f, -0.03806282f, 0.01633013f, 0.04189649f, -0.05649756f, 0.00477671f, 0.01725942f, 
    -0.00881272f, 0.04549979f, 0.05416220f, 0.00707680f, -0.05580248f, 0.04463397f, 0.05127355f, -0.00444601f, 
    -0.03291355f, 0.03113891f, 0.03125447f, -0.01841322f, -0.02924606f, -0.01937082f, -0.04849476f, -0.01835265f, 
    0.00302423f, -0.04497845f, -0.04762003f, 0.04440273f, 0.04255990f, -0.06041439f, 0.00796087f, 0.02257591f, 
    -0.04721659f, -0.03503536f, -0.03030152f, -0.02814101f, -0.05203376f, 0.00932227f, 0.01548820f, 0.03283025f, 
    -0.01111071f, 0.03628285f, 0.02502328f, 0.01139306f, -0.01985100f, -0.00658985f, -0.05028626f, -0.00303632f, 
    -0.02028063f, 0.03582135f, -0.03663394f, 0.01504703f, 0.04873592f, -0.02946317f, -0.04409232f, -0.06175533f, 
    0.04700414f, -0.02110033f, -0.00935402f, -0.06299847f, -0.06132487f, -0.01030755f, -0.00058869f, -0.01074235f, 
    0.00048653f, 0.03545802f, -0.01260146f, -0.03405263f, 0.04069685f, -0.05546513f, 0.00307583f, 0.00342412f, 
    -0.00141828f, -0.05106970f, -0.01790623f, 0.03059481f, -0.02037926f, -0.01475012f, 0.00121185f, -0.03770862f, 
    -0.03511633f, 0.01975490f, -0.04542012f, 0.03565825f, -0.04086499f, 0.04917363f, -0.01704289f, -0.04634936f, 
    -0.01374772f, -0.04317454f, 0.03440699f, -0.04067931f, -0.02242240f, 0.00920641f, 0.02852780f, -0.04811510f, 
    0.04832668f, -0.01382352f, 0.03738689f, -0.01516209f, -0.04400963f, 0.02614616f, -0.02011285f, 0.04891262f, 
    0.04630320f, 0.03856304f, 0.01216990f, 0.02620527f, -0.01177855f, 0.02642092f, -0.03941170f, -0.03697677f, 
    -0.02757009f, 0.02375076f, -0.03993178f, 0.02678228f, 0.01230062f, -0.05403320f, -0.03315028f, 0.03205923f, 
    0.03495096f, -0.04030634f, 0.02627372f, -0.00228426f, -0.04464728f, -0.05741237f, -0.01154977f, 0.03638507f, 
    0.02331510f, -0.04393386f, -0.01533076f, 0.03992463f, 0.03345871f, -0.02400720f, -0.04585515f, 0.02949562f, 
    0.00414165f, 0.00318050f, -0.03299839f, -0.00000132f, -0.04000255f, -0.04868549f, 0.02871989f, 0.04936210f, 
    -0.01217774f, -0.03782021f, -0.01750620f, -0.01166151f, -0.02804401f, -0.02667728f, -0.05229333f, -0.04521736f, 
    0.01030147f, -0.02279948f, -0.04721885f, -0.05312846f, 0.02050953f, 0.01990944f, 0.02655566f, -0.03966887f, 
    -0.03635267f, -0.00860932f, -0.00249630f, 0.02941525f, -0.03860760f, 0.03719915f, -0.02248619f, -0.04447534f, 
    0.00117238f, 0.04542270f, -0.06520807f, -0.00615422f, 0.03668519f, -0.04117224f, -0.06026147f, -0.04528534f, 
    -0.03932173f, -0.02808464f, -0.00703702f, -0.05330648f, -0.01764113f, -0.02348690f, -0.04926556f, -0.04560299f, 
    -0.05669637f, 0.01024679f, -0.05582098f, 0.02129247f, 0.03178422f, -0.06332910f, 0.05376085f, 0.05246591f, 
    0.02530730f, -0.01867454f, -0.05355674f, 0.00849232f, 0.01439218f, 0.00974525f, -0.06571321f, -0.01893784f, 
    -0.00814479f, 0.02563098f, 0.01904144f, -0.02496416f, 0.04906698f, -0.02654184f, -0.04300372f, 0.05219721f, 
    -0.20790797f, -0.13782103f, 0.26527730f, -0.06181778f, -0.08522957f, 0.04890973f, -0.00885608f, 0.03469149f, 
    0.07844158f, -0.10605032f, -0.00954992f, 0.10994095f, -0.11413650f, 0.10895193f, 0.04124551f, -0.13185182f, 
    -0.02386771f, -0.18087229f, 0.19433942f, 0.07271523f, -0.16087426f, -0.07939579f, 0.10428058f, -0.06540973f, 
    -0.00905267f, 0.01963044f, -0.04728428f, -0.34628820f, -0.21494830f, -0.10392544f, 0.22706434f, -0.00547453f, 
    -0.16981483f, 0.05043019f, -0.08091801f, 0.12697507f, -0.18025370f, 0.24196666f, 0.35832870f, -0.04092587f, 
    -0.04697401f, -0.22810960f, -0.01061034f, 0.11758025f, -0.01886456f, -0.18802790f, -0.27242202f, 0.24695510f, 
    0.06062612f, 0.00607066f, 0.03860088f, -0.08323579f, -0.00350881f, 0.10991845f, -0.11722336f, 0.14728403f, 
    -0.00982274f, 0.04551346f, -0.02605553f, -0.06520896f, -0.14934923f, 0.03001804f, 0.12336457f, -0.22302316f, 
    -0.10592864f, -0.04074598f, 0.05296779f, 0.01018494f, -0.17446195f, -0.23148978f, 0.09778961f, 0.12913190f, 
    0.11798235f, 0.01555879f, 0.08168989f, -0.07006807f, 0.01259950f, 0.04445272f, -0.04460428f, -0.03702055f, 
    -0.27107337f, 0.03163816f, 0.15207517f, -0.02349221f, -0.11520588f, 0.09183642f, 0.30360729f, 0.19710334f, 
    0.10600173f, 0.06517780f, 0.05704846f, -0.03436688f, 0.07047492f, -0.15019567f, -0.01834883f, -0.28659010f, 
    0.05733046f, 0.09322663f, -0.06619092f, -0.13104740f, 0.05544213f, -0.18477476f, 0.06718909f, 0.09985232f, 
    -0.01309842f, 0.16655591f, -0.11579181f, -0.11189211f, -0.11294354f, 0.10481695f, -0.35893539f, 0.05045276f, 
    -0.14081946f, 0.09924696f, -0.05985694f, 0.02694346f, 0.12894247f, 0.19074674f, 0.04829749f, -0.20147248f, 
    0.09339945f, 0.00338874f, 0.12815082f, 0.04009482f, -0.03273036f, -0.07088190f, -0.27590874f, 0.38893467f, 
    -0.24328938f, -0.22061044f, -0.41487452f, 0.00243089f, 0.12928532f, -0.01409808f, 0.15002768f, 0.16106993f, 
    0.16769242f, 0.14025937f, 0.00401349f, -0.08014131f, 0.16266003f, -0.10955471f, 0.05910750f, -0.00357629f, 
    -0.13894217f, -0.74101073f, -0.17915797f, -0.01056431f, -0.04493541f, 0.32440475f, 0.06208240f, 0.06929032f, 
    0.06901751f, 0.15314996f, 0.18530744f, 0.24345116f, -0.15336157f, 0.22690746f, -0.24769747f, 0.16071700f, 
    0.03685279f, -0.04563774f, 0.07909462f, -0.01911976f, -0.14732115f, 0.00657074f, 0.12404089f, -0.06963836f, 
    0.06456726f, -0.07383335f, -0.18735017f, -0.06177886f, -0.29405108f, -0.28368041f, -0.13359568f, 0.17489187f, 
    0.10425526f, 0.01436025f, -0.08920109f, -0.06928856f, 0.04937813f, 0.06380603f, 0.25413612f, -0.07461673f, 
    0.06381787f, -0.15459798f, 0.10259514f, 0.07803331f, -0.05929564f, 0.20346929f, 0.31256554f, -0.25780740f, 
    0.05947833f, -0.08475506f, -0.08773306f, -0.05810707f, -0.02481418f, -0.14548387f, -0.20434408f, -0.25090617f, 
    0.20826294f, -0.03148762f, 0.13512219f, -0.11211808f, -0.00124906f, 0.02507419f, -0.05566687f, -0.21246932f, 
    -0.36805606f, -0.03428315f, 0.00781424f, -0.02535638f, -0.09779172f, -0.03311712f, -0.02657596f, 0.01621416f, 
    0.06830117f, 0.05480075f, 0.05320322f, 0.02036189f, 0.01745269f, -0.17937200f, -0.05865631f, -0.07628571f, 
    -0.00789226f, 0.01775413f, 0.10938364f, 0.24844666f, 0.03224238f, 0.04468114f, -0.19638038f, 0.02572574f, 
    0.12657003f, 0.04261744f, -0.08108416f, 0.03404762f, 0.17453796f, -0.01702080f, -0.06639682f, -0.01416595f, 
    0.15688671f, -0.02884343f, 0.05034665f, -0.05590421f, -0.19988970f, 0.03988913f, -0.01607795f, 0.11827743f, 
    -0.04693378f, -0.10717465f, 0.02957300f, 0.08421750f, -0.28783247f, -0.19065803f, 0.55593324f, 0.03925240f, 
    0.13728049f, 0.04996204f, 0.05259121f, -0.00839886f, -0.20814246f, 0.20937853f, 0.22589098f, -0.46210957f, 
    -0.04741783f, 0.02595108f, -0.08545949f, -0.20651546f, 0.00145682f, 0.09015121f, -0.09453553f, -0.30577940f, 
    -0.38629919f, -0.01186494f, 0.04054419f, 0.12463292f, -0.10582996f, 0.04772566f, 0.06348203f, 0.04892471f, 
    0.16526969f, -0.08064492f, -0.03945429f, 0.04138695f, 0.21415596f, 0.23008120f, 0.06822955f, -0.26694727f, 
    -0.26127237f, 0.02490937f, -0.39863819f, -0.09494407f, -0.03817664f, 0.01983112f, 0.08537070f, -0.04087784f, 
    0.03853498f, 0.27076808f, 0.15751633f, -0.16987231f, -0.02537922f, 0.10416712f, 0.07731527f, 0.08554635f, 
    0.04641502f, 0.12558174f, -0.09620831f, -0.25862622f, 0.09317970f, 0.19874021f, -0.08432674f, 0.12639010f, 
    -0.03978746f, -0.09039637f, -0.12821406f, 0.09346529f, 0.11615463f, 0.18558766f, 0.06355885f, 0.05758848f, 
    -0.13631587f, 0.06348250f, -0.03216362f, -0.00321974f, -0.07177152f, -0.09835974f, -0.25333142f, -0.09037828f, 
    -0.04793421f, 0.00746414f, 0.00768424f, 0.03644473f, 0.05258029f, -0.16395377f, -0.20966500f, 0.07781269f, 
    0.20618199f, 0.00193753f, -0.02612280f, 0.05788250f, 0.03658162f, 0.10097720f, 0.10822065f, -0.13518113f, 
    0.05195522f, 0.07700940f, 0.03477203f, -0.14588712f, 0.00599943f, -0.06690816f, -0.11319276f, 0.43750060f, 
    0.11198904f, 0.01882018f, 0.03898492f, 0.06587137f, 0.02273639f, -0.03530139f, 0.07313298f, -0.15399864f, 
    -0.06358884f, -0.01046356f, -0.03427830f, 0.01029360f, -0.07561963f, -0.32357147f, -0.10776746f, 0.10666130f, 
    0.00585212f, -0.19335335f, -0.25453195f, -0.00802580f, -0.03117060f, -0.00041694f, -0.06459462f, 0.20943263f, 
    0.03718873f, 0.09980660f, 0.31947720f, 0.21096444f, -0.05760617f, -0.02138391f, 0.07065551f, 0.12785274f, 
    -0.04547469f, -0.03060004f, 0.06295650f, 0.10539571f, 0.00676027f, 0.02978844f, -0.06792599f, -0.13609403f, 
    -0.07293289f, 0.14380299f, 0.16178630f, 0.04648232f, 0.23405476f, -0.01883318f, 0.05287273f, 0.12341437f, 
    0.09511721f, -0.17341277f, 0.00598845f, 0.05310068f, -0.12749030f, 0.26327518f, -0.04856743f, -0.11387250f, 
    -0.05567184f, -0.08297116f, -0.00234339f, 0.02092895f, -0.00256776f, 0.07233536f, 0.30836955f, 0.14715730f, 
    0.17070247f, 0.07347850f, 0.04702357f, -0.03273380f, -0.04571641f, -0.06579317f, -0.20888722f, -0.12014232f, 
    -0.03036810f, 0.20118912f, -0.00159759f, -0.06153281f, -0.06661348f, -0.06196163f, 0.02230618f, 0.09097179f, 
    0.18117540f, 0.04490414f, -0.01870054f, 0.04535627f, -0.01323557f, 0.05763549f, -0.07612421f, 0.04452416f, 
    -0.12721100f, -0.22582960f, -0.27507937f, -0.11472505f, -0.04462447f, 0.02668349f, 0.10896853f, 0.08182351f, 
    -0.08026703f, -0.14066425f, 0.03880562f, 0.04036449f, 0.25156310f, -0.01422443f, 0.02067564f, -0.04234547f, 
    -0.06699462f, 0.07126640f, 0.07164614f, 0.04343621f, -0.04808728f, -0.05915758f, -0.02801407f, -0.02471590f, 
    -0.06107404f, -0.10579289f, 0.11667945f, -0.02723693f, 0.21144201f, 0.19593929f, -0.03924070f, -0.08032588f, 
    0.11448778f, -0.02703793f, 0.00150400f, 0.18094733f, 0.14818810f, -0.18317266f, -0.11030954f, -0.02082309f, 
    0.08646031f, -0.05564377f, -0.03244484f, -0.03881006f, -0.01786936f, 0.12910110f, 0.15301819f, 0.00903738f, 
    0.12795323f, -0.03662174f, 0.05657369f, 0.03517141f, -0.06155766f, 0.08374350f, -0.03660134f, 0.03375360f, 
    0.03176514f, -0.20778911f, -0.07828317f, 0.05384963f, 0.00251501f, 0.09752596f, 0.08283659f, 0.06179754f, 
    -0.21078074f, -0.01395295f, 0.15356830f, 0.04208332f, -0.01484498f, 0.03197449f, -0.10748631f, -0.26888099f, 
    -0.09462763f, -0.03322206f, 0.06477803f, 0.05570041f, 0.00904908f, -0.01160848f, -0.09901359f, -0.07421060f, 
    0.15122709f, 0.06285515f, 0.00986695f, 0.10724825f, 0.06475909f, -0.15933928f, -0.02770346f, -0.21050787f, 
    -0.08464144f, -0.01920384f, -0.05364781f, 0.05717499f, -0.26678964f, -0.02024510f, 0.00382974f, -0.03466542f, 
    -0.12258592f, -0.01222698f, -0.15566050f, -0.03313905f, -0.23927388f, -0.13926642f, 0.09801468f, 0.01871368f, 
    0.10310197f, 0.10814334f, 0.17122655f, 0.05345748f, 0.11011394f, 0.07865198f, 0.00810668f, 0.14294180f, 
    0.08132148f, 0.05387343f, -0.20430899f, -0.05787611f, -0.13643526f, -0.06704646f, 0.44529945f, -0.02288328f, 
    -0.22327560f, -0.02194302f, 0.07065157f, 0.00638880f, 0.00219620f, -0.07199584f, -0.03527315f, -0.14687732f, 
    -0.22254641f, 0.13078184f, -0.01535841f, -0.11032638f, 0.21120967f, 0.12256687f, -0.04145152f, -0.00021753f, 
    -0.16956064f, 0.05626744f, 0.11537164f, -0.14817172f, -0.04637829f, 0.01107291f, -0.06101459f, 0.01315085f, 
    0.22213571f, -0.04556557f, -0.27045634f, -0.25875267f, -0.19081298f, 0.06144945f, 0.05951441f, 0.15382071f, 
    -0.16716361f, -0.12327372f, 0.17315413f, 0.10115742f, 0.06126772f, -0.11161164f, -0.09817452f, -0.00126043f, 
    0.05569014f, 0.07666845f, -0.05412330f, 0.16475804f, -0.06869618f, 0.23266903f, 0.01765908f, -0.05521355f, 
    -0.03594957f, 0.02920151f, 0.08963566f, 0.08407153f, -0.07207027f, 0.15245906f, 0.02314900f, -0.03632604f, 
    -0.08987144f, 0.05255869f, 0.09075217f, 0.14827345f, -0.00910471f, -0.16381417f, 0.04562003f, -0.11179195f, 
    -0.11634231f, -0.01523787f, 0.00511384f, -0.00287374f, -0.10559018f, -0.06159721f, -0.02651557f, -0.26448718f, 
    0.02795535f, 0.04379477f, -0.00683829f, -0.02072766f, -0.11827399f, -0.04101904f, 0.07491723f, 0.16791926f, 
    -0.09787980f, -0.21654026f, -0.13046436f, -0.16439949f, 0.08650330f, 0.05838712f, 0.03207462f, 0.00301656f, 
    -0.04644240f, -0.02134789f, 0.00149187f, -0.12125275f, 0.08882640f, 0.06925995f, 0.06253241f, -0.13703240f, 
    -0.12681113f, -0.04410482f, 0.04007457f, 0.13081500f, 0.04259759f, 0.20493849f, 0.08154167f, -0.07975854f, 
    0.04929015f, 0.05928314f, 0.38036504f, -0.04886715f, -0.07626751f, -0.18523674f, -0.05795305f, -0.03005024f, 
    0.00159373f, 0.05322351f, 0.02233251f, 0.19011557f, 0.04999313f, -0.08356511f, -0.02623115f, 0.12901948f, 
    0.11487900f, 0.11696956f, 0.06813804f, 0.04033140f, 0.10465454f, -0.34052759f, -0.12067591f, 0.04097697f, 
    -0.03867581f, -0.07915076f, -0.01704518f, -0.02790529f, -0.04411205f, 0.05909083f, -0.41891795f, -0.39844292f, 
    0.01383908f, 0.10792200f, -0.10227824f, -0.04792717f, -0.14375402f, -0.06222830f, -0.21324636f, -0.22173192f, 
    -0.17364193f, -0.03914882f, -0.13466971f, -0.18659440f, -0.01769055f, 0.02953462f, -0.07487557f, 0.07565202f, 
    0.16336437f, -0.01843122f, 0.19857909f, 0.05842229f, -0.02435495f, -0.04955731f, 0.03110810f, 0.22396380f, 
    0.28175583f, -0.12522097f, -0.42449087f, -0.09390016f, 0.01295919f, 0.06649948f, 0.09958535f, -0.03108708f, 
    0.00835519f, 0.04989076f, 0.07089674f, 0.00860361f, -0.10824117f, -0.10066093f, -0.01203903f, 0.06063475f, 
    0.15263650f, 0.03751405f, 0.10949509f, 0.07441495f, -0.01359299f, 0.08874284f, 0.10422729f, 0.03066910f, 
    0.07672814f, -0.02060636f, 0.11639290f, -0.24528515f, -0.53477395f, -0.18440416f, -0.01007395f, 0.17430103f, 
    0.02909533f, 0.17851365f, -0.05379979f, -0.02405640f, 0.19618210f, -0.02673430f, -0.10621388f, 0.02126881f, 
    -0.02112957f, 0.07248935f, 0.10889857f, 0.22120437f, 0.04529206f, -0.07514364f, 0.09203020f, 0.15076095f, 
    0.00312608f, -0.04422788f, -0.14611225f, -0.04749255f, 0.16199683f, 0.01056636f, -0.08767847f, 0.05108960f, 
    0.01050395f, 0.02899220f, 0.16275804f, 0.05762243f, 0.01926026f, -0.02731828f, -0.07625356f, -0.28525373f, 
    -0.12327761f, 0.08180621f, -0.17272344f, 0.17594595f, -0.04312421f, 0.02648847f, -0.05165087f, 0.06588729f, 
    0.05346670f, 0.08375347f, -0.14372979f, -0.03919091f, 0.10147324f, -0.06863102f, -0.08462320f, -0.16890134f, 
    0.08139917f, -0.04354269f, 0.31999379f, 0.25171542f, 0.02532331f, 0.07092711f, 0.07266680f, 0.01867087f, 
    0.13657777f, 0.24685553f, -0.00489832f, 0.09178273f, -0.18107334f, -0.22347251f, 0.05314124f, -0.06249005f, 
    0.13316607f, -0.13100579f, -0.06629204f, -0.11624423f, -0.03637485f, -0.18735145f, 0.03916658f, -0.00688671f, 
    -0.10022794f, -0.01694059f, -0.12232903f, 0.06906800f, -0.26393998f, -0.06194635f, -0.23189385f, 0.15192117f, 
    0.16465145f, -0.21433900f, 0.14443274f, 0.12610757f, -0.08764092f, 0.70517671f, -0.17067169f, -0.56062818f, 
    -0.11790988f, 0.08840857f, -0.20898393f, 0.00068567f, -0.06708468f, -0.06682038f, -0.32880077f, -0.45935369f, 
    -0.28806275f, -0.19574508f, 0.11030726f, 0.04136264f, 0.07557828f, -0.09287219f, -0.05408214f, 0.07559443f, 
    -0.10755765f, -0.22228494f, -0.10748007f, 0.03802264f, -0.07170305f, 0.10209671f, 0.11513575f, -0.16116269f, 
    0.23223984f, -0.15070026f, 0.16756061f, -0.06722804f, -0.02111212f, 0.10282739f, 0.14087148f, 0.15485503f, 
    0.05455266f, -0.01159866f, -0.06780433f, -0.08337402f, -0.15121679f, 0.17846391f, -0.07302587f, 0.08086622f, 
    0.09259474f, -0.14811729f, 0.23290618f, 0.15935545f, 0.12160628f, 0.01177293f, -0.01358516f, 0.00792911f, 
    -0.03703924f, -0.03356282f, -0.09095327f, 0.00050172f, 0.12025540f, 0.12346863f, 0.02896103f, -0.02602242f, 
    -0.06896465f, 0.08056563f, 0.03785354f, 0.05979724f, 0.01102544f, -0.11587682f, 0.28337717f, -0.15926899f, 
    0.07519220f, -0.11061068f, 0.14203471f, 0.11056396f, 0.11497706f, -0.03568828f, -0.15193604f, 0.04818716f, 
    0.09259155f, -0.11194900f, -0.06771313f, -0.03288491f, -0.02786454f, -0.17312950f, -0.04520645f, -0.02171967f, 
    0.00144757f, 0.06377999f, -0.14191324f, 0.01639658f, -0.18775666f, -0.23186632f, -0.04791051f, -0.40709206f, 
    0.25581819f, 0.08683084f, -0.08550549f, 0.19720216f, -0.09152884f, -0.12150456f, -0.15567967f, -0.08562730f, 
    -0.13065305f, -0.02262209f, 0.07547817f, 0.02876683f, 0.17008315f, -0.08552253f, 0.04976172f, 0.18132079f, 
    0.01322100f, 0.20454845f, 0.06415273f, 0.10646321f, 0.00400589f, 0.05429295f, -0.02261779f, -0.05400398f, 
    -0.05830940f, -0.08980835f, -0.09842806f, -0.09938397f, 0.16744296f, -0.16349202f, -0.11763624f, -0.01050341f, 
    0.13835220f, 0.02591123f, 0.07333963f, -0.11317365f, 0.00692086f, -0.18724328f, -0.01413465f, 0.08703496f, 
    -0.06811688f, -0.00270541f, 0.08658652f, -0.02919676f, -0.12378906f, -0.02527558f, 0.07348815f, -0.01083182f, 
    -0.02964670f, 0.11746339f, -0.12695634f, -0.15582615f, 0.04497581f, 0.12867515f, -0.10209267f, -0.06624740f, 
    -0.07303246f, -0.00014436f, 0.07023499f, 0.01270448f, -0.02074443f, 0.02654614f, -0.09059235f, 0.12196197f, 
    0.14948052f, -0.02707092f, -0.00262183f, 0.10755282f, 0.01752259f, 0.07011891f, 0.15178080f, -0.15938815f, 
    0.13851441f, 0.07405340f, -0.00010140f, -0.16569793f, 0.02695528f, -0.15231271f, -0.05757884f, 0.02381738f, 
    0.21225674f, 0.08857950f, -0.03159489f, 0.04963839f, 0.05151960f, 0.09198701f, -0.03195684f, 0.09254345f, 
    -0.00158588f, 0.15997475f, -0.07165644f, 0.20812468f, 0.00990094f, -0.01020803f, -0.25604081f, -0.14107458f, 
    -0.12579149f, 0.07425248f, 0.02519523f, 0.03716620f, -0.07867547f, -0.05853442f, -0.03916352f, -0.05733785f, 
    0.02476040f, 0.09479728f, 0.07641415f, 0.10367908f, -0.22034264f, -0.15139715f, -0.18426682f, 0.10382876f, 
    -0.09753640f, 0.09360949f, 0.11347743f, 0.05638896f, 0.06676248f, 0.08451418f, 0.11637249f, -0.10110202f, 
    -0.08263362f, 0.04835432f, 0.00963913f, 0.05484724f, -0.16458851f, 0.18436228f, 0.25673845f, 0.12952369f, 
    -0.07007290f, 0.04540902f, -0.18878847f, 0.12721062f, 0.02799998f, -0.02902575f, -0.11315256f, 0.04141496f, 
    0.09816557f, -0.00276034f, 0.01879389f, -0.07545886f, -0.00018034f, -0.01135019f, 0.02757100f, 0.03097113f, 
    -0.13843657f, -0.04435073f, -0.04397209f, 0.11107289f, -0.10977349f, 0.14875489f, 0.10408468f, 0.02801984f, 
    -0.01563279f, 0.22594982f, -0.00330314f, -0.03088566f, -0.04850308f, -0.02726303f, -0.19775893f, -0.10871222f, 
    -0.08912954f, 0.30255121f, -0.12844259f, 0.10588839f, 0.07416182f, -0.00432053f, 0.06372415f, 0.04773558f, 
    0.12435869f, -0.02406830f, -0.12458001f, -0.07894572f, -0.03685632f, -0.00170004f, -0.00443563f, 0.05298505f, 
    -0.03410623f, 0.04553693f, 0.01296628f, 0.19857050f, -0.08322907f, 0.10433954f, 0.00316092f, -0.13653433f, 
    -0.08050168f, -0.04237726f, 0.05411116f, -0.12648894f, -0.05385880f, 0.10432515f, 0.28652313f, 0.11445998f, 
    -0.06043683f, 0.08501161f, -0.08330949f, 0.26198554f, -0.01573388f, -0.23883173f, -0.01610329f, -0.22416797f, 
    -0.10290632f, -0.05979801f, -0.15629539f, 0.15699054f, -0.15186466f, -0.01164899f, 0.12114903f, -0.13335118f, 
    -0.25387663f, 0.06178210f, 0.08370067f, 0.07094416f, -0.04422398f, -0.16270818f, -0.06952191f, 0.18553211f, 
    0.16812241f, 0.10486923f, -0.08723158f, -0.15996101f, -0.05803123f, -0.01588122f, 0.25622407f, 0.03322558f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.16758507f, -0.02435892f, 0.15584901f, 0.04100348f, 0.03935617f, 0.17317103f, 0.09857657f, 0.01647118f, 
    -0.01898575f, -0.04975369f, -0.05051434f, 0.05149468f, 0.06135322f, 0.16312245f, 0.17190874f, -0.05174061f, 
    -0.06070720f, -0.07159781f, 0.02307022f, 0.18169914f, 0.11379498f, -0.08902882f, 0.25844109f, 0.07058523f, 
    -0.09306132f, 0.13589160f, 0.08859141f, -0.04943977f, 0.06865287f, -0.05155573f, 0.08819987f, -0.03923571f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04932212f, -0.07510689f, 0.40862864f, 0.15926477f, 0.02335255f, -0.25703228f, 0.10506100f, -0.15539210f, 
    0.00403674f, -0.13370155f, -0.03716246f, -0.13417394f, 0.26196298f, -0.10435253f, -0.16169561f, 0.02213943f, 
    -0.02212673f, -0.03230081f, -0.09772003f, 0.16716649f, 0.06880201f, 0.09416793f, -0.33220622f, -0.15022893f, 
    0.10489650f, 0.17469701f, -0.34629962f, -0.15153624f, 0.37046716f, -0.14324270f, 0.28296575f, 0.25233227f, 
    0.52379131f, 0.00364644f, 0.19652604f, -0.10566293f, -0.12994049f, 0.21334316f, -0.15983596f, 0.03944715f, 
    0.14125381f, 0.09893224f, 0.00913840f, -0.03376976f, -0.02375250f, 0.05061896f, 0.27092442f, -0.13637348f, 
    0.06802493f, -0.24888492f, 0.06107340f, -0.06574580f, 0.17332874f, 0.10680745f, 0.42309934f, -0.00254105f, 
    -0.02628024f, 0.25641099f, -0.41482028f, 0.09345496f, -0.28913108f, 0.14630492f, -0.21243915f, 0.17956263f, 
    0.41723701f, -0.15931137f, 0.22828311f, -0.08755645f, -0.15007438f, -0.58392924f, 0.20164356f, 0.11754005f, 
    0.01178162f, -0.03930746f, -0.08597225f, -0.10824066f, -0.05399973f, 0.31149414f, -0.20281424f, -0.17256592f, 
    0.17063923f, -0.10875600f, -0.05549567f, 0.01212678f, 0.28486332f, 0.26565629f, -0.30879939f, -0.13721058f, 
    0.00458673f, -0.21634108f, 0.01814285f, 0.00376230f, 0.00935679f, -0.13217433f, -0.15027802f, 0.00477803f, 
    0.48465627f, -0.04320366f, -0.20803159f, -0.16096990f, -0.34136149f, -0.37397456f, -0.20220397f, -0.04223605f, 
    0.00726310f, -0.15937117f, -0.04454012f, -0.05202490f, -0.25633073f, 0.24758559f, 0.07841623f, 0.11426950f, 
    0.12198260f, -0.24665409f, -0.13278040f, 0.11400456f, 0.14799459f, 0.31759629f, 0.39605203f, 0.00872294f, 
    -0.07997409f, 0.21606718f, -0.23777612f, -0.00021775f, 0.17628476f, 0.28467950f, 0.26131368f, 0.12424516f, 
    -0.27772242f, 0.07741114f, -0.05860021f, 0.08238971f, 0.32167760f, -0.13500465f, -0.15924160f, -0.17466080f, 
    0.02407376f, -0.17443180f, -0.07345068f, -0.06809834f, 0.10123696f, -0.16145775f, -0.14194438f, -0.01828314f, 
    -0.01295617f, 0.16541360f, 0.05704327f, 0.02463034f, -0.01522856f, 0.08387613f, 0.05333503f, 0.08569794f, 
    0.03432643f, 0.04924663f, 0.08978340f, -0.11169355f, 0.10033556f, 0.05286031f, 0.45012879f, 0.12939702f, 
    0.00289963f, 0.09316295f, -0.00009002f, -0.15621586f, 0.10019921f, -0.12289881f, -0.34625804f, 0.12492825f, 
    -0.13651496f, 0.07266515f, 0.02527680f, 0.13706869f, -0.22696972f, 0.07167962f, 0.21634990f, -0.05290042f, 
    0.00905222f, 0.06186791f, 0.01932469f, 0.10309868f, -0.02782420f, -0.19362035f, 0.46056867f, -0.03803944f, 
    0.12457401f, -0.02260876f, -0.12917809f, 0.17466235f, 0.11594432f, -0.15023543f, -0.06155469f, 0.07048684f, 
    -0.25768620f, -0.13580507f, -0.21969202f, 0.13578597f, -0.12987211f, -0.66639763f, 0.13201855f, -0.02583288f, 
    0.06142395f, -0.11486475f, -0.05256099f, 0.20021549f, 0.04239943f, 0.10462996f, -0.39141810f, 0.14225414f, 
    -0.07275861f, 0.34009272f, 0.09261612f, 0.40062901f, -0.09582496f, -0.16573456f, 0.15635689f, 0.02764089f, 
    0.03591507f, -0.61926800f, 0.11681301f, 0.06742771f, -0.06061920f, 0.17124915f, 0.16282603f, -0.36277691f, 
    0.07521976f, 0.10084794f, 0.09869330f, -0.35955206f, -0.35654959f, 0.49640086f, -0.00320041f, -0.17817353f, 
    0.12042483f, 0.16765285f, 0.10910029f, 0.22075073f, 0.21158834f, 0.30194047f, -0.27955073f, -0.16799134f, 
    0.03565828f, 0.14822729f, -0.04108927f, 0.34404802f, 0.09733520f, -0.12719692f, -0.06148995f, -0.16105524f, 
    -0.01515071f, -0.00328783f, 0.10380509f, -0.10180692f, -0.42674622f, 0.13846256f, 0.12841935f, -0.20650850f, 
    -0.01829972f, -0.14329782f, -0.25658152f, 0.12259245f, -0.31663769f, -0.31027371f, 0.28094614f, -0.05104204f, 
    0.07419024f, -0.08586248f, -0.11791830f, 0.28176388f, -0.06004541f, 0.04252458f, 0.27505913f, 0.16785437f, 
    -0.05553551f, -0.23829681f, -0.00165093f, -0.33916095f, 0.11337097f, 0.12810697f, 0.31402200f, 0.14518519f, 
    -0.06090190f, -0.02672940f, -0.16606301f, 0.08210437f, 0.32743075f, -0.11253961f, 0.21361038f, 0.21295555f, 
    -0.12483286f, 0.13140215f, 0.19909340f, 0.10031329f, -0.29732767f, 0.22534062f, 0.34557450f, -0.16847925f, 
    0.13080098f, 0.12691565f, 0.10280848f, 0.16232292f, -0.06075876f, 0.09257364f, 0.10525407f, -0.02117516f, 
    -0.14666830f, -0.12869775f, -0.00910993f, 0.15703879f, -0.15128076f, -0.00094263f, 0.11963284f, -0.28937793f, 
    0.11837949f, 0.21540348f, 0.13147049f, -0.07674944f, 0.55699456f, -0.25843176f, 0.27321249f, 0.06453971f, 
    -0.16314468f, -0.03269628f, -0.14518355f, 0.14039879f, -0.03893791f, 0.09436138f, -0.00864666f, 0.15676594f, 
    -0.09518408f, 0.07812200f, -0.09568652f, -0.04419984f, -0.03551397f, -0.12030002f, 0.02884471f, 0.17050213f, 
    -0.10173532f, -0.03323374f, -0.05513760f, -0.01551152f, -0.07726124f, -0.14721142f, -0.12582253f, 0.05271850f, 
    0.02983729f, -0.03613420f, -0.02292864f, -0.14076306f, -0.11577176f, -0.07302757f, -0.14558432f, 0.04066846f, 
    -0.01406733f, -0.12717301f, 0.02873378f, 0.02001004f, -0.43395498f, 0.68570387f, 0.30607921f, 0.15133493f, 
    -0.16987243f, -0.06511766f, 0.05316997f, -0.14591664f, 0.25577909f, -0.18175535f, 0.17318751f, 0.09293769f, 
    0.02229649f, 0.10397421f, 0.13675989f, 0.16273226f, 0.00661197f, -0.18571676f, 0.06521479f, 0.05770780f, 
    0.10351595f, 0.02178613f, 0.02116096f, 0.05737836f, 0.08801409f, -0.27204919f, -0.06986032f, -0.04183425f, 
    -0.07196166f, -0.16575404f, 0.36786696f, 0.03646589f, -0.43805271f, 0.03161029f, 0.38563457f, 0.16779664f, 
    0.15020420f, -0.01856059f, 0.05020503f, 0.04291429f, -0.01257169f, -0.01478323f, 0.17942096f, -0.04683850f, 
    -0.08767689f, -0.06346098f, -0.02186480f, -0.17017029f, 0.15263034f, 0.06862774f, 0.44205377f, 0.25186387f, 
    -0.10684323f, 0.13303877f, -0.09904078f, 0.04296311f, 0.12393277f, -0.31100306f, -0.31571442f, 0.06190929f, 
    -0.06207183f, 0.05782373f, -0.01324237f, -0.02665756f, -0.07183660f, 0.14647061f, -0.17484783f, -0.05217887f, 
    0.12555453f, -0.10552403f, 0.06230124f, -0.14976726f, -0.02528199f, -0.00897751f, -0.18432525f, 0.04434152f, 
    -0.02986635f, -0.17879835f, 0.09936271f, -0.19032511f, -0.00967798f, -0.19812988f, 0.01106641f, -0.08450776f, 
    0.09020825f, 0.10891566f, 0.08348809f, -0.13854423f, 0.08535678f, 0.07800880f, -0.02640802f, -0.07985843f, 
    -0.28162056f, 0.16368908f, -0.05974060f, 0.16257688f, -0.18140100f, -0.30497548f, -0.24467894f, -0.13457720f, 
    0.07726583f, -0.00833042f, -0.04138221f, -0.16843073f, 0.19544587f, 0.02474254f, -0.01719056f, 0.01864392f, 
    0.17714508f, 0.12449858f, 0.09374487f, 0.09529709f, 0.21946779f, -0.30920759f, 0.33528939f, 0.43774751f, 
    0.03023227f, -0.02671484f, 0.28538340f, 0.12594643f, -0.14659040f, 0.00280708f, -0.28713611f, 0.22323388f, 
    -0.15040715f, -0.02374402f, -0.12063784f, 0.11435042f, -0.01307021f, 0.06400647f, 0.04860889f, 0.13386728f, 
    -0.03740332f, -0.03132915f, 0.02341598f, -0.06829944f, -0.12213523f, -0.04720801f, -0.02604656f, -0.02834959f, 
    -0.12954223f, -0.04398395f, -0.09888926f, 0.01925556f, -0.05643490f, -0.07236519f, 0.08315648f, 0.06078437f, 
    0.15037362f, -0.07910671f, -0.00495635f, 0.12981172f, -0.04187055f, -0.13900422f, 0.08522266f, 0.04986064f, 
    -0.30958030f, 0.14987665f, 0.35497430f, -0.26070061f, -0.14383890f, -0.36702999f, 0.35356557f, 0.13440132f, 
    0.12272905f, 0.05933916f, 0.02438122f, 0.22937697f, 0.15142950f, 0.25116804f, -0.31815228f, 0.17436773f, 
    -0.02117189f, -0.00237593f, -0.09131513f, 0.04476612f, -0.06844646f, 0.07832149f, 0.08489975f, 0.19841026f, 
    0.03757697f, -0.18834870f, 0.27382323f, -0.07955260f, -0.28805313f, -0.14222857f, -0.04424860f, 0.12078089f, 
    0.66726953f, 0.08276729f, -0.05645212f, 0.07607743f, -0.31400368f, 0.11272575f, -0.40860549f, 0.10834289f, 
    0.10127392f, 0.02061009f, -0.03711044f, -0.05670229f, -0.12790304f, 0.10360972f, 0.20346799f, 0.08428838f, 
    -0.11308141f, -0.28765723f, 0.10388338f, 0.04623673f, 0.19033580f, 0.11212926f, 0.11572836f, -0.04310464f, 
    0.09995651f, 0.29880327f, -0.24410167f, -0.04697816f, 0.03880562f, 0.28757930f, -0.06749630f, -0.05923571f, 
    0.05701729f, 0.11011370f, -0.36885944f, 0.29416174f, -0.55789059f, -0.31153810f, 0.07789178f, 0.11258297f, 
    -0.08271409f, -0.07699557f, -0.04476970f, 0.32599205f, 0.04499085f, -0.10325720f, 0.13349751f, 0.11201342f, 
    -0.11419958f, -0.14037859f, 0.02422481f, -0.25291052f, 0.01375878f, -0.14460576f, 0.45321599f, 0.39087662f, 
    0.14640926f, -0.23818289f, 0.07583085f, -0.07518810f, -0.63229841f, 0.18142866f, -0.12094020f, -0.16425586f, 
    -0.24832936f, 0.11677010f, 0.18072392f, 0.13082729f, -0.07653932f, 0.07339804f, 0.25799185f, -0.03563998f, 
    0.10802481f, -0.01345911f, 0.08930611f, 0.39954737f, -0.01164482f, -0.08318626f, 0.23245008f, -0.15873019f, 
    -0.10329721f, -0.11703886f, -0.03780377f, -0.36253121f, -0.07641868f, 0.15444514f, -0.04012787f, -0.04277667f, 
    0.02608717f, 0.07925943f, -0.02244850f, 0.15571703f, -0.30264643f, 0.23552515f, -0.16955829f, 0.19157632f, 
    0.24698918f, 0.11006417f, 0.00997976f, -0.08425205f, 0.08382647f, 0.12049538f, 0.29714268f, -0.13736211f, 
    0.09012974f, 0.06833921f, 0.17513958f, 0.47972921f, -0.17566742f, -0.03148214f, 0.07571677f, -0.00719064f, 
    0.06784247f, -0.28815416f, -0.01287623f, -0.06237542f, 0.03324528f, 0.21764295f, -0.17590813f, 0.13457838f, 
    -0.07219670f, -0.06092413f, 0.03722575f, 0.09539148f, -0.11958269f, 0.10499238f, 0.32399541f, 0.25677705f, 
    0.59135705f, 0.03693113f, -0.05259332f, 0.35572967f, -0.02262055f, 0.36346921f, -0.58907074f, -0.01824409f, 
    -0.09675909f, 0.12598024f, 0.05909330f, -0.04156162f, -0.20710406f, -0.11177026f, 0.31160820f, 0.00104750f, 
    0.15946144f, -0.11210802f, 0.08686635f, -0.06281874f, 0.24036027f, 0.21083902f, -0.10019236f, 0.11033358f, 
    0.01895006f, 0.12192412f, -0.24664196f, -0.14035407f, -0.17306806f, 0.17260861f, -0.06913978f, -0.26928598f, 
    -0.14675602f, 0.01734326f, 0.07420272f, -0.15488721f, -0.15341179f, 0.06146701f, -0.08782422f, 0.07540809f, 
    0.08184560f, -0.06240116f, 0.15682082f, 0.00084972f, -0.09989054f, -0.18540539f, 0.13462706f, 0.06340957f, 
    -0.06466144f, -0.12866160f, -0.09635959f, 0.00203672f, 0.05420265f, -0.19709598f, 0.02035591f, -0.13330060f, 
    -0.03370413f, -0.04860725f, 0.10932944f, 0.04474459f, 0.00168151f, 0.11479561f, -0.10197959f, -0.04302784f, 
    -0.03161510f, 0.18244673f, 0.01316090f, -0.07832252f, -0.45294306f, 0.15932131f, -0.10537262f, 0.01149949f, 
    0.00679261f, 0.07531720f, -0.03759592f, -0.28275546f, 0.04077660f, 0.19288780f, -0.41749170f, 0.00897864f, 
    -0.09499522f, 0.28859243f, 0.00238934f, 0.31748992f, 0.16538474f, -0.17942223f, -0.22135484f, -0.13917196f, 
    -0.13644812f, -0.31972665f, 0.35794610f, -0.08787505f, 0.05246945f, -0.00444094f, -0.14261211f, -0.50378340f, 
    0.48395979f, 0.00820389f, -0.16241945f, 0.36515898f, -0.06654499f, -0.27603611f, -0.21175927f, -0.15342484f, 
    0.14099763f, 0.03742646f, 0.02696200f, 0.05681338f, -0.15139519f, -0.01536448f, 0.29386523f, 0.06623158f, 
    -0.03117754f, -0.30455241f, 0.01114549f, -0.04457410f, 0.16336980f, 0.10529371f, 0.24591926f, 0.09340788f, 
    -0.13846996f, -0.11092734f, 0.05299367f, 0.14174053f, 0.15265225f, 0.11918364f, 0.21941534f, -0.22297500f, 
    0.47708231f, -0.08244043f, -0.35759014f, 0.25071847f, -0.37909764f, -0.10890614f, -0.35436127f, -0.09842845f, 
    0.01380354f, -0.08774224f, -0.04246045f, 0.02126412f, 0.00369935f, 0.15204860f, -0.23260534f, -0.11227380f, 
    0.08626510f, 0.16373169f, 0.03363639f, 0.11703797f, 0.21386813f, -0.06327035f, 0.07348911f, -0.05287737f, 
    0.03958417f, -0.04379978f, 0.10568126f, -0.07417373f, -0.27764598f, 0.23684016f, -0.26142591f, -0.29985866f, 
    0.29823613f, 0.05257874f, 0.08123350f, 0.22987552f, 0.08623215f, -0.27783540f, -0.08093629f, -0.13582703f, 
    0.10938237f, -0.16329989f, -0.12348199f, -0.13176264f, -0.09051585f, 0.09088320f, 0.13357034f, 0.07549678f, 
    0.09841995f, -0.12083420f, -0.14590459f, 0.16675672f, 0.22642303f, 0.02211138f, 0.13680454f, -0.11603060f, 
    -0.20109907f, -0.06149175f, -0.18263464f, -0.11599569f, 0.47501355f, -0.06697880f, 0.43003795f, 0.19001377f, 
    -0.14172627f, 0.13518120f, 0.15395188f, -0.02101759f, -0.08292834f, -0.09875244f, 0.03248155f, -0.04647558f, 
    0.01371005f, 0.10428352f, 0.03981201f, -0.08910320f, -0.15933013f, 0.00809557f, -0.07078335f, -0.03564250f, 
    -0.08217499f, -0.01501407f, 0.07265344f, 0.00091034f, -0.12066256f, -0.06547321f, -0.06160616f, -0.10802110f, 
    0.05102295f, -0.16283482f, 0.03840067f, 0.08327617f, -0.03850215f, -0.13557959f, -0.10771865f, 0.11833878f, 
    -0.59481949f, -0.01921046f, -0.00263131f, 0.19057052f, 0.19120310f, 0.01968899f, 0.03110098f, 0.14971559f, 
    0.17229800f, -0.04711650f, 0.07185467f, -0.09261326f, 0.14168930f, 0.03621284f, 0.21227330f, -0.17635678f, 
    -0.02722759f, 0.26379636f, 0.00069221f, -0.18325038f, -0.17551619f, 0.19527616f, 0.06502884f, 0.00817966f, 
    -0.01960891f, 0.02804699f, -0.11186889f, 0.06741124f, -0.24991693f, -0.02691320f, -0.18272743f, 0.17233755f, 
    0.21806692f, 0.04462108f, 0.12559405f, 0.44671831f, 0.16854429f, -0.19477411f, -0.19556449f, 0.03799853f, 
    0.08046958f, -0.03757019f, -0.03299595f, 0.07980277f, -0.17375666f, -0.13956743f, 0.24983369f, 0.13468444f, 
    -0.12169487f, -0.28730118f, -0.13720851f, -0.06060834f, 0.09690846f, -0.11125840f, 0.24103914f, 0.39779472f, 
    -0.08173379f, -0.14593537f, -0.01727881f, -0.10531700f, 0.21920903f, 0.11450645f, 0.13354091f, -0.01380407f, 
    0.30922502f, -0.09834094f, -0.06733216f, 0.10282093f, -0.02300559f, 0.66797096f, 0.08386502f, 0.02189830f, 
    0.14011323f, 0.08076409f, -0.04001196f, -0.03839919f, 0.02638696f, -0.05965448f, 0.54527295f, 0.01758025f, 
    0.13589509f, -0.06734161f, 0.14028554f, -0.22151582f, 0.27277696f, -0.11212783f, -0.05996550f, 0.27126721f, 
    -0.06434546f, -0.00050297f, -0.02569298f, -0.03372909f, -0.17915384f, -0.15668380f, -0.61276948f, 0.02224783f, 
    0.06997029f, -0.06621013f, -0.15454070f, -0.48734331f, -0.14924425f, 0.03032978f, 0.24746549f, 0.07003484f, 
    -0.14171901f, 0.00899088f, -0.04983272f, 0.24321730f, -0.09691169f, 0.09985182f, 0.14720100f, 0.11882840f, 
    0.17527489f, 0.19809741f, -0.08426168f, -0.27692702f, 0.01820152f, 0.15563922f, -0.07527169f, -0.09193029f, 
    -0.14669205f, 0.05214467f, 0.04405183f, -0.16677286f, -0.01241933f, -0.05622209f, -0.15988480f, 0.23722714f, 
    0.39709085f, -0.06195227f, 0.29165730f, -0.15741645f, -0.23420732f, 0.44530356f, -0.08601161f, -0.09949850f, 
    -0.10267281f, -0.16378041f, 0.07734067f, -0.21834317f, 0.03260070f, 0.10110492f, -0.24370500f, -0.14552210f, 
    -0.14758290f, -0.04960206f, 0.00623471f, 0.34848130f, 0.15846829f, 0.18326133f, -0.11189692f, -0.21219468f, 
    0.08024718f, 0.18781918f, 0.17522816f, -0.11949036f, 0.17618297f, -0.14158209f, 0.12606651f, -0.11841395f, 
    0.12362538f, -0.07675471f, 0.19514863f, -0.24108115f, 0.00915193f, -0.27012092f, 0.33929357f, -0.10853674f, 
    0.15443791f, 0.10880571f, 0.06825776f, 0.25530964f, 0.22858375f, -0.02365103f, -0.06126520f, -0.02297005f, 
    0.17110670f, -0.01275187f, 0.01280227f, 0.31554443f, -0.07390895f, 0.15295202f, -0.03353323f, -0.25609335f, 
    -0.16506629f, -0.01825428f, -0.27316362f, 0.13732019f, -0.03501060f, 0.01200039f, 0.29130879f, 0.22705799f, 
    0.14463526f, -0.17071927f, -0.06538696f, 0.01826836f, -0.10671443f, -0.00588831f, -0.08367857f, 0.00600961f, 
    -0.06593647f, 0.00444725f, -0.00496180f, 0.07949730f, -0.01400255f, -0.17411706f, -0.02804228f, 0.14551125f, 
    -0.08139496f, -0.04202646f, -0.05446570f, -0.10965678f, 0.08712319f, -0.14431100f, -0.09130377f, -0.03693531f, 
    -0.16302431f, 0.03809999f, 0.07028878f, -0.13793917f, -0.05395779f, -0.17593023f, -0.00716581f, 0.06998568f, 
    0.51074928f, 0.09655164f, 0.16535881f, -0.18241207f, -0.57631165f, 0.39459300f, -0.05967095f, 0.01438091f, 
    0.08337027f, -0.06975158f, 0.13630895f, -0.21412794f, -0.05325256f, 0.28309676f, -0.24014184f, 0.01273722f, 
    -0.14737663f, -0.06668470f, -0.04041385f, 0.15224680f, 0.18391740f, 0.18565066f, -0.15414654f, -0.14639522f, 
    0.02983121f, 0.12170233f, 0.09497842f, 0.01113846f, 0.21462914f, -0.03608995f, 0.00255252f, -0.16910820f, 
    0.42354634f, -0.11704452f, 0.01423689f, -0.03483014f, 0.24141653f, -0.18293265f, -0.27932301f, 0.11482500f, 
    -0.04688727f, 0.04144084f, 0.08577729f, -0.08012587f, -0.03499167f, 0.01143380f, -0.10021224f, -0.11676043f, 
    -0.04701517f, -0.07107221f, -0.15617211f, 0.07020467f, 0.26054162f, -0.10173849f, -0.04324463f, 0.40115735f, 
    -0.05628556f, -0.09297288f, 0.21158019f, -0.05522082f, -0.13695240f, 0.04721860f, 0.21315479f, -0.15573686f, 
    0.30846581f, -0.06953743f, 0.20251659f, -0.22617702f, -0.19853774f, 0.51655877f, -0.15568870f, 0.08605839f, 
    0.02349084f, 0.16305487f, -0.13459218f, 0.01435651f, 0.22128972f, 0.08329155f, 0.01326738f, 0.02911862f, 
    0.05286908f, 0.09881723f, -0.00534988f, 0.30161193f, 0.23114981f, 0.01861776f, -0.00594567f, -0.10613827f, 
    0.09487538f, 0.14285134f, -0.13013002f, -0.08979314f, -0.09671073f, -0.24322532f, -0.28049409f, -0.07046096f, 
    0.02326962f, 0.05588510f, -0.08866923f, -0.20771652f, -0.00747507f, -0.33261669f, 0.37453836f, 0.11606186f, 
    0.17416014f, 0.02699822f, 0.15064982f, 0.24765247f, 0.02746667f, 0.23428652f, -0.02979011f, 0.15394291f, 
    -0.08825280f, -0.33359557f, -0.03457626f, 0.01010963f, -0.05009558f, 0.26622945f, 0.20495084f, 0.14464860f, 
    -0.12448224f, -0.05682218f, 0.00490357f, 0.00648146f, 0.00378799f, 0.16476616f, 0.33104554f, 0.19480653f, 
    -0.24047223f, 0.01093072f, 0.24292627f, 0.13476209f, -0.38770488f, -0.21072981f, 0.47345620f, 0.13211845f, 
    -0.11880177f, -0.16781598f, -0.02261221f, 0.09319274f, 0.12881853f, 0.06529458f, 0.23006067f, -0.15893090f, 
    -0.06444155f, 0.08610338f, -0.13207175f, -0.19319338f, 0.04313472f, -0.19646145f, 0.41366392f, 0.14465609f, 
    0.05547012f, -0.04064846f, 0.13801853f, 0.11485833f, 0.18786784f, -0.45219934f, -0.08573914f, 0.16252835f, 
    0.02462067f, 0.17528708f, -0.18980908f, 0.47532958f, -0.16274817f, -0.42181477f, 0.19157188f, 0.12520783f, 
    0.07319245f, -0.16835533f, -0.17565703f, -0.46448544f, 0.08092922f, -0.05941759f, 0.30823416f, 0.16530822f, 
    0.05362879f, 0.16937159f, 0.03492644f, 0.14883301f, -0.07098978f, -0.15017451f, 0.33761713f, 0.12933071f, 
    -0.01248158f, 0.08992669f, 0.04740569f, -0.08109518f, 0.43506357f, -0.33740017f, 0.26713187f, 0.14351623f, 
    0.26590511f, 0.06626711f, 0.19280198f, -0.11260051f, -0.29304537f, -0.41866201f, 0.14551263f, -0.10761700f, 
    -0.16986531f, 0.14557379f, -0.03099596f, -0.29606178f, -0.06018183f, 0.25177407f, -0.21817920f, -0.12416779f, 
    0.06857707f, -0.13614704f, 0.14472154f, 0.06169450f, 0.13720970f, 0.26550859f, -0.07498690f, 0.08492807f, 
    0.15366422f, 0.01349024f, 0.31824189f, -0.05828488f, 0.35189614f, -0.30939913f, -0.33434108f, 0.02099659f, 
    -0.16205089f, 0.06620425f, -0.41392446f, -0.07790087f, -0.18681207f, 0.05232156f, -0.30252972f, -0.03800400f, 
    0.11581595f, -0.08950464f, 0.01001995f, -0.23872153f, 0.19793069f, -0.04132497f, 0.14241706f, -0.07839653f, 
    -0.11246790f, 0.06401818f, -0.14131278f, -0.13621715f, -0.17255896f, 0.05412307f, -0.27603215f, 0.21088606f, 
    0.09511766f, 0.07756776f, 0.27602232f, 0.15079628f, 0.00653199f, 0.27414572f, -0.17472406f, -0.15252469f, 
    -0.31282705f, 0.16974613f, 0.26864898f, 0.00163772f, 0.11550608f, -0.30538392f, 0.34118477f, -0.09645766f, 
    -0.15728253f, 0.00799405f, -0.08469659f, 0.37496951f, -0.07922105f, 0.04217961f, -0.13995002f, 0.02117251f, 
    0.01559375f, -0.17546263f, 0.03229392f, -0.02412798f, 0.16262119f, 0.15192069f, -0.07218950f, 0.00491363f, 
    0.06888453f, 0.07450414f, -0.12706946f, 0.03978542f, -0.26561388f, 0.00744899f, 0.09057569f, 0.14372130f, 
    -0.26432106f, 0.08269060f, 0.24695751f, 0.12583405f, -0.39373463f, 0.72146350f, -0.05725486f, -0.01271931f, 
    -0.06114966f, 0.01285673f, -0.02283828f, -0.16173926f, 0.32879674f, 0.07391573f, -0.18135184f, -0.12337636f, 
    -0.05042043f, 0.28462648f, -0.04783783f, 0.16648780f, -0.07760642f, -0.35501552f, 0.20676285f, 0.12337867f, 
    -0.03127191f, 0.02703185f, 0.26056340f, 0.12471876f, -0.17499310f, -0.17663600f, -0.27635261f, -0.19324431f, 
    0.06777149f, 0.13491857f, 0.31656361f, -0.02073127f, 0.08879033f, 0.46580556f, -0.09046529f, -0.01708608f, 
    0.14899902f, -0.16870233f, -0.14635876f, 0.01650531f, 0.22451338f, 0.10104614f, -0.25754112f, 0.08629333f, 
    -0.09034416f, 0.08294647f, 0.15851590f, 0.42975909f, 0.24793527f, -0.20949699f, 0.16870764f, -0.11837231f, 
    -0.07779624f, -0.02951552f, -0.03113708f, -0.10917818f, -0.27822483f, 0.04840475f, -0.20741959f, -0.09247282f, 
    -0.01463318f, -0.10491188f, 0.14459465f, 0.19252804f, -0.01511209f, 0.50015742f, -0.21129754f, -0.17435949f, 
    0.04244662f, -0.09394048f, 0.02484602f, -0.25359967f, 0.05757307f, -0.06794044f, -0.18370257f, -0.00828972f, 
    0.06563195f, 0.17549816f, -0.17101102f, 0.28026393f, 0.12919869f, -0.13622496f, -0.07488879f, -0.16181871f, 
    -0.14307520f, 0.26236832f, 0.06350116f, -0.11667078f, 0.04627704f, -0.02674255f, 0.06849515f, -0.08046684f, 
    -0.10177112f, -0.09290449f, 0.15699551f, 0.22651276f, 0.02708518f, -0.03519384f, -0.02080191f, -0.04360393f, 
    0.01994558f, 0.12803313f, 0.08809435f, -0.40569553f, 0.10222960f, 0.02374172f, -0.00070965f, -0.04946501f, 
    -0.02968726f, 0.09623973f, -0.10149240f, 0.32417876f, 0.14322771f, -0.17397060f, -0.40869945f, -0.07031663f, 
    0.04573627f, 0.06462662f, 0.06574985f, 0.05910747f, 0.40478501f, -0.23177028f, 0.19612211f, -0.03769428f, 
    -0.47331706f, 0.03222896f, -0.19365811f, -0.00353047f, -0.06776515f, 0.16692135f, -0.14365312f, -0.07793036f, 
    0.12257077f, 0.00425392f, -0.06930020f, -0.00987905f, -0.26545855f, 0.09023730f, -0.27153111f, -0.12498846f, 
    0.13606392f, -0.02255144f, 0.02754530f, -0.48967716f, -0.05020563f, 0.10451205f, 0.08056559f, 0.01814088f, 
    -0.03126966f, 0.15855032f, 0.07864285f, -0.12411534f, -0.07716339f, -0.05283984f, 0.27975544f, -0.22442472f, 
    -0.18870279f, 0.15370327f, 0.21267718f, -0.12066336f, -0.11982862f, 0.51984829f, -0.00762233f, -0.00007968f, 
    0.11968265f, -0.17015912f, 0.11795159f, -0.36297548f, 0.23765633f, -0.07845710f, 0.24025412f, 0.14082249f, 
    0.13527870f, 0.26560256f, 0.02304231f, -0.06764017f, 0.01313643f, -0.15885381f, 0.02388289f, -0.10080030f, 
    0.15620846f, 0.27386189f, -0.11900470f, -0.06337763f, 0.05736186f, -0.07592373f, -0.34674039f, -0.10128120f, 
    -0.16711842f, 0.02086397f, -0.08071769f, -0.17526066f, 0.03366276f, -0.38981751f, 0.08491737f, 0.10152318f, 
    0.04300257f, -0.12855868f, 0.05235349f, 0.17205332f, 0.27077395f, 0.18253562f, -0.23651688f, 0.07315312f, 
    0.08199423f, -0.09472594f, 0.01896953f, 0.25392708f, 0.18035236f, 0.04400487f, 0.22104590f, 0.54337418f, 
    0.05690161f, -0.18511012f, 0.08398165f, 0.11901081f, -0.41714972f, 0.16209480f, -0.19894509f, 0.11330998f, 
    -0.17838585f, 0.11754920f, 0.15767995f, -0.07635750f, 0.20921610f, 0.02493153f, 0.42428496f, 0.12442312f, 
    0.07141098f, -0.07432657f, -0.00442798f, 0.42224613f, -0.08056776f, 0.17871539f, -0.25096282f, 0.00856507f, 
    -0.14425999f, -0.14245743f, -0.09902896f, 0.28491151f, 0.19717644f, -0.06195589f, -0.13969287f, 0.06445592f, 
    0.10914378f, 0.03201224f, 0.29070759f, 0.12659989f, -0.11775040f, -0.08810529f, 0.14615691f, 0.10964006f, 
    0.25742018f, -0.12260653f, 0.06804839f, -0.07220175f, -0.06275336f, -0.01509191f, -0.20876376f, -0.16013357f, 
    -0.07922713f, 0.02521871f, -0.11643470f, -0.18703775f, -0.16683474f, -0.07215961f, -0.03258254f, -0.02513623f, 
    0.17480008f, -0.14229093f, -0.07542240f, -0.10971719f, -0.05699357f, 0.17776920f, -0.25342920f, -0.02618538f, 
    -0.05555179f, -0.07395220f, 0.09502381f, 0.11749814f, 0.17470028f, 0.12438589f, 0.20603967f, -0.12288488f, 
    -0.04049871f, 0.06360514f, -0.08454676f, 0.19107285f, -0.12208977f, -0.35255265f, 0.21284407f, 0.14100705f, 
    0.11459275f, 0.00655980f, -0.05927079f, -0.32979691f, 0.01200479f, -0.10354546f, 0.26521188f, -0.10004830f, 
    -0.13175276f, -0.11516663f, 0.02860346f, -0.07657455f, 0.06384540f, 0.28249925f, 0.22115803f, -0.10322861f, 
    -0.00525782f, -0.03101758f, -0.18846719f, -0.05197423f, 0.07923751f, -0.14087911f, 0.33284548f, 0.10831370f, 
    -0.11665662f, -0.17946552f, 0.07834639f, -0.69368905f, 0.04098798f, 0.09215479f, -0.52968872f, 0.12092179f, 
    0.00167398f, -0.15918770f, 0.12146477f, -0.02779871f, 0.06548244f, -0.23704742f, -0.07642659f, 0.15350398f, 
    -0.08546894f, 0.08173268f, -0.04051384f, -0.36266053f, -0.23303559f, 0.11856475f, 0.48023587f, -0.11390425f, 
    0.12573686f, -0.05299051f, -0.50729561f, 0.05456841f, -0.09587961f, 0.02966899f, 0.31397668f, 0.06862986f, 
    0.16400473f, -0.03586405f, 0.25625062f, -0.13712816f, -0.06045421f, -0.54034257f, 0.29717511f, -0.08640947f, 
    0.00074496f, -0.13351184f, -0.01301857f, 0.19315466f, -0.08225241f, 0.26929352f, -0.36605185f, 0.16054092f, 
    -0.04271808f, 0.04522832f, -0.05277825f, 0.29074416f, 0.22756061f, 0.05664103f, 0.02680065f, 0.27145246f, 
    -0.09701286f, -0.08183505f, 0.14558184f, 0.12594479f, -0.19606730f, -0.06218268f, -0.17673324f, 0.21031715f, 
    0.01315817f, -0.16070232f, -0.25333732f, 0.04106635f, 0.21361658f, -0.44120324f, -0.13176928f, 0.02398563f, 
    0.03808999f, -0.03723064f, 0.12465825f, -0.09692180f, 0.14465824f, -0.06665906f, -0.06471451f, 0.05237725f, 
    -0.00749546f, -0.08078628f, 0.11063190f, 0.06225489f, -0.03940696f, 0.10708124f, -0.19263618f, 0.17214186f, 
    -0.08960683f, -0.30079517f, 0.21895878f, -0.00474446f, 0.31127053f, 0.21258728f, 0.48896217f, -0.02166557f, 
    -0.32311729f, -0.11491231f, -0.19080515f, -0.41440111f, 0.06355745f, -0.52509177f, -0.53234756f, 0.16184248f, 
    -0.09146193f, -0.03272827f, -0.03214967f, 0.16757886f, 0.26412746f, -0.45983616f, 0.00306354f, -0.04234051f, 
    -0.07415135f, 0.15336040f, -0.13880007f, -1.01777732f, -0.16234799f, 0.08775456f, -0.06516061f, 0.14168298f, 
    -0.09833440f, 0.19605637f, -0.28197294f, 0.12277514f, 0.05058856f, -0.01315611f, 0.15755974f, -0.03460785f, 
    0.34820262f, 0.10054864f, 0.22129865f, 0.02447087f, -0.36101753f, 0.10092545f, -0.30614623f, -0.03182471f, 
    0.15916775f, -0.13402176f, 0.06721082f, -0.13114037f, 0.16735604f, 0.17811781f, 0.20493913f, 0.16124035f, 
    -0.16243187f, -0.09323115f, 0.11067957f, 0.22242157f, 0.16426122f, -0.00665229f, 0.22955281f, -0.23231247f, 
    -0.19257285f, 0.25551391f, -0.23255478f, 0.06567509f, -0.07520314f, 0.07084171f, -0.13241118f, 0.15794426f, 
    0.12004939f, -0.05752754f, -0.63329166f, 0.00773236f, 0.09427655f, 0.10211221f, -0.47682720f, 0.06357203f, 
    0.00697107f, 0.15426619f, -0.12081961f, -0.60519671f, -0.36690137f, 0.23426408f, -0.19525485f, 0.08760049f, 
    0.11124871f, 0.02001701f, 0.07901607f, -0.32683501f, 0.08122531f, 0.22073442f, 0.09674746f, -0.23953517f, 
    0.10014319f, 0.14210103f, 0.30729672f, 0.01553807f, 0.19465634f, -0.36879918f, -0.00035523f, -0.08438648f, 
    -0.15723075f, 0.09912873f, 0.38646111f, 0.37478757f, 0.26389340f, 0.34793571f, -0.04717638f, 0.05744553f, 
    -0.03055176f, 0.01446935f, -0.16093025f, -0.11343317f, 0.20139393f, -0.26202619f, -0.00458306f, -0.01494691f, 
    -0.03420135f, -0.05799021f, 0.14335488f, 0.06210379f, 0.12114759f, -0.20061560f, -0.04503338f, 0.16689107f, 
    0.08226632f, 0.17976350f, 0.06712303f, -0.06321137f, 0.27351990f, -0.20279381f, -0.03803025f, -0.11559706f, 
    0.02828518f, 0.10956796f, -0.19711454f, 0.04274882f, -0.15428491f, 0.11556455f, 0.08319649f, -0.09309044f, 
    -0.05444703f, -0.08689484f, 0.14261273f, -0.15423289f, 0.11481663f, -0.17365286f, -0.12430103f, -0.13243267f, 
    0.16935225f, -0.18442227f, -0.03807523f, -0.21609312f, 0.01810965f, 0.06932656f, -0.14307094f, -0.19243637f, 
    0.11227722f, -0.04161637f, -0.10688011f, 0.02357069f, 0.09345090f, 0.02372004f, -0.08610303f, -0.14457713f, 
    -0.01811393f, 0.16651002f, 0.07326623f, -0.19121265f, -0.20848182f, 0.05343093f, 0.10537051f, 0.06519829f, 
    -0.13410854f, -0.04932906f, -0.13768172f, -0.28442708f, 0.28630465f, 0.24996154f, -0.22831421f, -0.00667500f, 
    -0.12153964f, 0.23920803f, 0.13981827f, 0.32509667f, -0.05890171f, -0.04594652f, 0.18376257f, 0.03428664f, 
    0.10147118f, -0.02443319f, 0.27994740f, 0.14886625f, -0.16594632f, -0.28394273f, -0.10920865f, -0.16137086f, 
    -0.19813183f, 0.04055098f, -0.06785755f, -0.34904167f, 0.18814483f, 0.06131492f, -0.35321167f, -0.15174155f, 
    -0.10567985f, -0.10191161f, 0.02305336f, -0.22879225f, 0.09329905f, 0.21027511f, 0.07089122f, 0.14043404f, 
    -0.03397192f, 0.02910156f, -0.15317881f, -0.26746267f, 0.01174019f, -0.01515591f, 0.18794297f, 0.08515032f, 
    0.13839775f, -0.04739058f, 0.19748949f, 0.13557845f, -0.05020064f, -0.11003241f, 0.12416236f, -0.01005169f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07520233f, 0.10934829f, -0.00928839f, 0.05672179f, -0.09915762f, 0.05406663f, -0.12134966f, -0.01085186f, 
    0.07448827f, 0.21824284f, -0.02020126f, 0.22958681f, 0.21785134f, -0.16756865f, 0.26970556f, 0.00879731f, 
    0.06811753f, 0.19890741f, 0.07001412f, -0.06863020f, -0.10153429f, 0.13137075f, 0.12894699f, 0.03610807f, 
    0.13521920f, -0.03190590f, -0.06527076f, 0.11968543f, 0.08334048f, -0.01888099f, 0.06205931f, 0.04363777f, 
    0.14767990f, 0.12277478f, -0.16020656f, 0.29279554f, 0.20581384f, 0.22566041f, 0.34259441f, -0.03086416f, 
    -0.05579294f, 0.15550360f, -0.03520613f, 0.17134224f, 0.10388440f, 0.28266680f, 0.18573821f, 0.10119678f, 
    0.05503602f, -0.03953077f, 0.31204614f, 0.31803554f, -0.25420466f, -0.15744093f, 0.26941738f, -0.05381842f, 
    -0.01978335f, -0.17001620f, 0.26622531f, 0.06427993f, 0.08804600f, -0.13647678f, -0.04832664f, 0.15820959f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05979644f, 0.01559015f, 0.17427239f, 0.34826773f, -0.04758983f, -0.17552359f, -0.16574378f, 0.04803088f, 
    0.11416210f, -0.12421911f, -0.11570407f, -0.09536867f, 0.00120376f, -0.10558838f, 0.17823952f, -0.07943366f, 
    0.04131910f, 0.13705179f, 0.03666653f, 0.01868369f, 0.11425290f, 0.05746227f, -0.13149491f, -0.12017428f, 
    0.04593940f, 0.06626581f, 0.15641123f, -0.04293454f, -0.06956165f, 0.10065972f, -0.08794522f, 0.02698432f, 
    -0.06579494f, 0.14035492f, 0.03611326f, 0.02362086f, 0.26168343f, -0.05017442f, 0.20362246f, -0.00420628f, 
    -0.12147273f, -0.07903802f, 0.09580541f, 0.01111022f, -0.21097706f, 0.17566480f, -0.11787511f, -0.01072928f, 
    0.11245447f, -0.04438602f, 0.43340844f, 0.09138298f, 0.04970787f, -0.08337238f, 0.15496129f, 0.21974613f, 
    0.14150046f, 0.16720234f, 0.15595855f, -0.13069357f, -0.01909936f, -0.09231469f, -0.03770081f, 0.09016394f, 
    -0.09425665f, 0.08202680f, 0.06841646f, -0.07183611f, -0.09525797f, -0.15568531f, -0.00001441f, 0.06256525f, 
    0.05334010f, -0.07601986f, 0.11478257f, -0.06499831f, -0.06571355f, 0.01204559f, -0.05992947f, 0.08354791f, 
    0.10105473f, -0.11067866f, 0.02453855f, -0.04466857f, -0.02265536f, -0.06070281f, -0.06636947f, -0.01804706f, 
    0.05249925f, -0.00306877f, 0.00191106f, -0.11305094f, -0.11098535f, -0.00590909f, 0.06926674f, 0.02409295f, 
    -0.09099511f, 0.07223817f, -0.05203417f, -0.10536812f, 0.05703007f, -0.13431185f, -0.10635246f, -0.15263757f, 
    0.03552366f, -0.06145921f, -0.10858451f, -0.10214393f, 0.07668832f, -0.09748743f, 0.05761416f, -0.05547101f, 
    0.08974508f, 0.04472358f, 0.01697405f, -0.12693793f, 0.03327736f, 0.02150858f, 0.00328368f, -0.06023321f, 
    0.01506107f, -0.06476092f, -0.11920317f, -0.03539131f, 0.00687247f, 0.00528616f, -0.03406341f, 0.02253169f, 
    -0.13403609f, 0.13917346f, 0.21193768f, -0.01835176f, -0.15209997f, 0.18228434f, 0.00457264f, -0.01738650f, 
    -0.00264123f, -0.09392884f, -0.02590014f, -0.05291974f, 0.15744174f, 0.08850975f, 0.34736398f, 0.06371567f, 
    0.29248762f, -0.11180549f, 0.08454131f, -0.06320978f, -0.03720110f, -0.08299123f, -0.10448574f, 0.29572672f, 
    0.10144832f, 0.14567888f, 0.09096808f, 0.12397514f, -0.18804383f, 0.13398844f, 0.25639185f, -0.15388788f, 
    -0.01433579f, -0.22044349f, 0.08884437f, -0.12260326f, 0.29931584f, -0.04726874f, 0.03923037f, 0.15850042f, 
    -0.06395002f, 0.46891326f, 0.03062361f, -0.07495876f, 0.01979310f, 0.08473345f, 0.00213321f, -0.04108932f, 
    0.07788488f, -0.28030235f, 0.23370716f, 0.08877370f, 0.04246966f, -0.06327891f, 0.13157912f, 0.17323230f, 
    0.03123667f, -0.03071006f, -0.04214637f, 0.25541499f, -0.00308579f, 0.06961593f, 0.07140794f, 0.12520637f, 
    -0.23666742f, -0.14664882f, 0.01477878f, -0.13066959f, 0.21136610f, 0.18251331f, 0.12798610f, 0.13455582f, 
    -0.39988858f, -0.26239181f, -0.11965160f, -0.14820613f, -0.04747022f, -0.07758196f, 0.23464923f, -0.07044676f, 
    0.16200413f, -0.38786846f, -0.02612851f, 0.10752472f, 0.09376501f, -0.10688207f, 0.00007945f, 0.35930714f, 
    -0.21673773f, 0.16675203f, -0.15595247f, -0.01485721f, 0.03714465f, -0.03633904f, 0.00489712f, 0.05253942f, 
    -0.10045204f, 0.09841730f, -0.02112281f, -0.05249602f, 0.25120342f, 0.10393555f, 0.12472477f, -0.27818689f, 
    -0.19311467f, -0.01063249f, 0.15931530f, 0.01488397f, 0.10388128f, 0.17693664f, 0.09849823f, 0.02436425f, 
    -0.14939551f, -0.15920347f, 0.33759391f, 0.20211729f, -0.09614312f, -0.03808120f, -0.08589660f, 0.14013229f, 
    0.18305194f, 0.06505335f, -0.21780150f, 0.42245388f, 0.08826441f, -0.08848777f, 0.14693682f, 0.32553294f, 
    0.04391688f, 0.03311674f, 0.02291645f, -0.11016778f, -0.05750035f, -0.04677978f, -0.12232715f, -0.06626903f, 
    -0.02197007f, -0.06932493f, -0.02885179f, -0.00492751f, -0.07429449f, 0.03212038f, -0.04185047f, -0.05875143f, 
    -0.01051174f, -0.07680160f, -0.07448241f, 0.00160560f, -0.07674057f, -0.05183515f, 0.01911369f, 0.10613939f, 
    -0.06203377f, -0.13845168f, -0.02761802f, -0.04790381f, -0.15863468f, -0.13762313f, 0.09933288f, -0.11775912f, 
    -0.09626310f, 0.06117581f, -0.09824121f, 0.09331082f, 0.05447359f, -0.01002909f, 0.02182908f, -0.03458945f, 
    -0.01685116f, 0.04703361f, -0.01989694f, -0.12966488f, -0.04251646f, -0.00398224f, -0.14720838f, -0.01927673f, 
    0.03339571f, -0.03913401f, 0.05057326f, -0.07614513f, 0.11224297f, -0.10323418f, -0.00103009f, -0.11357099f, 
    0.00610114f, 0.03532144f, -0.05524295f, -0.06610340f, -0.07019322f, 0.00284664f, 0.00618435f, -0.12000100f, 
    0.00439030f, 0.21504892f, 0.29714829f, 0.18707085f, -0.30595773f, 0.33554292f, -0.10789619f, -0.33570519f, 
    0.28333399f, 0.17212763f, 0.02384685f, 0.18250421f, 0.06760288f, -0.06877876f, -0.07981645f, 0.10183077f, 
    -0.13422085f, 0.18314722f, 0.01994077f, -0.00290558f, -0.02566067f, 0.13601245f, 0.02778629f, 0.09063963f, 
    0.30584243f, 0.12042977f, 0.25006679f, -0.12084036f, -0.16836698f, 0.06546237f, 0.26215205f, -0.09206985f, 
    0.06891348f, -0.14931372f, -0.12485568f, 0.22194277f, 0.01900631f, 0.08640656f, 0.07821035f, 0.25723189f, 
    0.22699510f, 0.45381409f, -0.09462464f, -0.18142782f, -0.21768804f, -0.11881879f, -0.12569918f, -0.03515581f, 
    0.19077449f, 0.02432777f, -0.12883390f, 0.01582551f, -0.08052921f, 0.09850290f, -0.12759788f, 0.03384572f, 
    -0.24419968f, -0.04192037f, 0.15555334f, 0.36985686f, 0.03962492f, 0.03968249f, 0.06225988f, 0.05632333f, 
    0.14084448f, 0.22375490f, -0.10954296f, -0.01702981f, -0.07806786f, 0.10017419f, -0.31302780f, 0.11731892f, 
    -0.17794026f, 0.07758035f, 0.11941339f, 0.09567609f, -0.02828447f, -0.05524397f, -0.16344620f, 0.10533727f, 
    -0.38227430f, 0.06502088f, 0.13045095f, 0.40290269f, 0.11774114f, 0.54457420f, -0.09984711f, -0.05078463f, 
    0.25613967f, -0.08425394f, 0.10162285f, 0.09333456f, -0.04003905f, 0.33003962f, 0.45650482f, -0.10676938f, 
    0.01707125f, 0.04397226f, -0.04595409f, -0.05867406f, 0.16081525f, 0.08591106f, 0.08053292f, -0.17960009f, 
    -0.15160514f, -0.18257000f, -0.19469343f, 0.13542654f, -0.02606666f, 0.16489644f, 0.08901111f, -0.12123596f, 
    0.06729538f, 0.13265547f, -0.12475314f, 0.13795185f, -0.01088290f, -0.13910481f, 0.32379457f, -0.09393424f, 
    -0.09044135f, -0.09993213f, 0.13667129f, 0.08758917f, 0.25853556f, -0.01674737f, -0.14351119f, 0.11366844f, 
    -0.00804423f, -0.04699989f, -0.38391888f, 0.01528688f, 0.17401038f, 0.16471553f, -0.47072086f, -0.32531855f, 
    -0.13790435f, -0.01856375f, -0.07859980f, -0.44269285f, 0.00629680f, 0.07987057f, -0.05938654f, 0.12785172f, 
    -0.10424186f, -0.19095765f, -0.04621299f, 0.03456549f, 0.08386450f, 0.06542658f, 0.05303000f, -0.25376916f, 
    -0.04423421f, -0.13287887f, -0.06578271f, 0.05820856f, 0.15306959f, 0.17868975f, -0.06230250f, -0.00961495f, 
    -0.04813723f, 0.11252590f, -0.01846275f, -0.38101104f, 0.14851503f, 0.14848819f, 0.04013992f, -0.01799137f, 
    0.07977945f, -0.42416662f, 0.01394599f, 0.24935718f, -0.48568147f, 0.03205008f, 0.16861241f, 0.00186234f, 
    0.21900789f, -0.00504504f, -0.11294641f, 0.06637263f, -0.01900595f, -0.03233838f, 0.08858016f, -0.17202076f, 
    0.09720241f, -0.08718722f, -0.25460932f, 0.29133543f, 0.15496452f, -0.02194341f, 0.07199278f, 0.19078274f, 
    0.20563011f, -0.24768513f, 0.08962469f, -0.08103326f, 0.00708174f, -0.11450525f, 0.08764145f, 0.35368040f, 
    -0.13043055f, 0.16454566f, 0.01031804f, 0.11753707f, -0.01524196f, 0.00882267f, -0.00941749f, -0.02583346f, 
    0.49020505f, -0.33449331f, -0.18603531f, -0.07093376f, -0.03496284f, -0.59489608f, 0.07963334f, 0.29810193f, 
    -0.08549272f, -0.19767898f, -0.03543207f, 0.11926925f, -0.16799256f, -0.18406747f, -0.17725918f, -0.09163573f, 
    0.10154250f, 0.11178085f, 0.11093408f, 0.11975948f, 0.01725292f, 0.11048881f, 0.10916381f, 0.11965337f, 
    -0.17998934f, 0.25545570f, -0.01143527f, 0.20819688f, 0.09936333f, 0.18697569f, -0.03506376f, -0.05361907f, 
    0.06991103f, -0.34930840f, 0.18787754f, 0.27551734f, 0.08600286f, 0.04066997f, -0.00008338f, 0.26002106f, 
    -0.03291229f, -0.35583219f, -0.04089253f, 0.08824755f, 0.17054877f, 0.05138659f, 0.22441730f, -0.05200152f, 
    0.10369481f, -0.33106437f, -0.04352700f, -0.14267758f, 0.11159142f, -0.19042264f, 0.28405049f, -0.09001741f, 
    -0.00157901f, 0.18632385f, 0.01232083f, -0.00285146f, 0.05430900f, 0.07942681f, 0.03040775f, -0.00960117f, 
    0.21222854f, -0.39361736f, 0.11908589f, 0.03093964f, 0.19054413f, -0.58900815f, 0.03773998f, -0.11250301f, 
    0.07607199f, -0.08224731f, 0.14921999f, 0.05243365f, -0.08996946f, 0.04646171f, -0.11722112f, -0.22918630f, 
    0.09963581f, 0.07223523f, 0.09698576f, -0.28488085f, 0.17128466f, -0.13485439f, 0.26288512f, 0.15677881f, 
    0.12106360f, -0.03657836f, 0.04329535f, -0.05822847f, 0.12687916f, 0.09858593f, -0.04453541f, 0.18398540f, 
    0.00593155f, -0.04745266f, 0.04077855f, 0.27855968f, -0.09129679f, -0.17868607f, -0.43404615f, 0.06489982f, 
    0.22913288f, -0.31183216f, -0.16764572f, -0.08087934f, 0.21413517f, 0.00268899f, 0.09172051f, -0.13722833f, 
    0.23703156f, -0.13252787f, 0.17921878f, -0.11324400f, -0.22940977f, -0.19281475f, -0.03068728f, 0.00912365f, 
    -0.19632456f, 0.19705780f, 0.08157273f, 0.10158502f, 0.10418441f, 0.00544737f, 0.02760139f, -0.06353711f, 
    0.21002753f, 0.01416930f, -0.22341394f, -0.24626815f, -0.02771002f, -0.23564419f, 0.05081631f, 0.04634199f, 
    -0.07566979f, -0.16546114f, 0.10769034f, -0.05922840f, -0.15008748f, 0.00793463f, -0.20852949f, -0.27570283f, 
    0.33005774f, -0.03827838f, 0.06920436f, 0.34362304f, -0.02055149f, 0.18824433f, -0.00607296f, 0.15194660f, 
    0.02343075f, 0.28375450f, -0.33475491f, 0.11416638f, 0.05833209f, 0.06726493f, 0.15828899f, 0.22933157f, 
    0.00990603f, 0.03230511f, -0.03102061f, 0.05004533f, 0.06250441f, -0.09302200f, -0.08366928f, 0.18983160f, 
    -0.00389616f, -0.18812498f, 0.10055549f, -0.00710463f, 0.24511248f, 0.08402998f, 0.26385739f, -0.23607264f, 
    0.08232780f, -0.06479667f, 0.11411429f, 0.11757787f, -0.00164752f, -0.13902098f, 0.50590819f, 0.14367603f, 
    -0.04732451f, 0.08261527f, -0.10806596f, -0.14014305f, -0.03726790f, 0.01790470f, 0.02026451f, -0.00634520f, 
    0.37706247f, -0.15203728f, -0.27484092f, -0.13241681f, 0.31845877f, -0.33315498f, 0.03760153f, 0.22472560f, 
    -0.09248418f, -0.14529389f, 0.06184660f, -0.03323134f, -0.08991442f, -0.04409235f, -0.31715488f, 0.11837158f, 
    0.16218947f, 0.17926039f, -0.01439829f, -0.05184858f, 0.31700993f, 0.06587586f, 0.33751619f, -0.08800559f, 
    -0.16461049f, 0.16710295f, -0.01400501f, 0.11522023f, -0.10405205f, 0.13743109f, -0.09472642f, 0.06410784f, 
    -0.18621655f, -0.17206694f, 0.23096634f, 0.26256040f, -0.02996333f, -0.10411476f, 0.01916222f, 0.27844706f, 
    0.21360935f, -0.34740180f, -0.02317860f, -0.29335865f, -0.05251956f, 0.00766199f, 0.10017809f, 0.02492448f, 
    -0.03903193f, -0.06167052f, 0.13253279f, -0.10571311f, -0.24132428f, 0.18157092f, 0.11957692f, 0.14266038f, 
    0.14823687f, 0.32296646f, -0.00829729f, 0.49066725f, 0.26480502f, 0.12053559f, -0.05437675f, 0.05285478f, 
    0.21444198f, -0.18318371f, 0.02120680f, 0.28368038f, 0.09909967f, -0.61527342f, 0.09262119f, -0.08392555f, 
    -0.23483206f, -0.26222610f, -0.14304653f, -0.05020955f, -0.05212245f, -0.30036908f, 0.12009060f, 0.33624393f, 
    0.13713084f, 0.23706168f, 0.04198997f, 0.07664766f, -0.12520649f, 0.16567543f, 0.11548022f, 0.43412560f, 
    0.02976729f, 0.06719608f, 0.24174002f, 0.14648640f, 0.26521978f, 0.01063319f, -0.14993218f, 0.01267739f, 
    0.15860218f, 0.11433031f, 0.07524765f, 0.15283781f, -0.23380166f, -0.18861061f, 0.06479110f, 0.19269969f, 
    -0.14074075f, -0.10437912f, 0.17336577f, 0.14103834f, -0.10722449f, 0.08110870f, 0.16671413f, -0.21911035f, 
    -0.00012344f, -0.08826640f, -0.03699808f, -0.04978982f, -0.11884126f, 0.04893473f, -0.10074484f, 0.00334617f, 
    -0.02854672f, -0.12969062f, -0.09732288f, -0.00084433f, 0.02378234f, 0.10640104f, -0.03428849f, 0.02070676f, 
    -0.03649358f, 0.08078782f, -0.10162488f, 0.01460895f, -0.10062861f, -0.07680433f, 0.10220151f, -0.07912441f, 
    0.08163164f, -0.11834937f, -0.12915897f, -0.03824539f, 0.05455156f, -0.13347347f, -0.08379234f, 0.03562669f, 
    -0.05346287f, 0.01831609f, -0.10413748f, 0.01302887f, 0.06755213f, -0.03554323f, 0.02904926f, 0.01134181f, 
    -0.14128844f, -0.07626687f, 0.06480034f, -0.15590349f, 0.01449054f, -0.03637549f, -0.02969041f, -0.03567368f, 
    0.07432918f, -0.02138831f, -0.10656147f, 0.05950683f, 0.07176018f, -0.11760452f, -0.06141813f, -0.11377666f, 
    0.00308308f, -0.02369421f, -0.11247396f, 0.00872138f, -0.12446667f, -0.06248319f, 0.01209222f, -0.01249107f, 
    0.14727798f, 0.16643995f, -0.44545561f, -0.05418250f, 0.11741692f, 0.16469659f, -0.32106596f, 0.26707748f, 
    -0.01301868f, 0.28888312f, 0.00975062f, 0.49944642f, -0.05559623f, -0.08610423f, -0.24737209f, -0.07403718f, 
    -0.30063888f, -0.02446838f, -0.28182206f, 0.06462582f, -0.03037709f, 0.08175136f, -0.07386514f, 0.20177728f, 
    -0.04882284f, -0.19412109f, 0.05121762f, -0.00417089f, 0.10864806f, -0.16899256f, 0.07464384f, 0.03294469f, 
    0.31734079f, 0.08559947f, 0.08678024f, -0.01158517f, -0.09766558f, 0.18061274f, -0.21848707f, -0.19252299f, 
    -0.19602145f, -0.11095866f, -0.25808775f, 0.03469875f, 0.47742677f, 0.20751905f, 0.38615218f, 0.07966444f, 
    0.26025859f, 0.27092057f, -0.37205061f, 0.05559181f, 0.02541928f, -0.18437314f, -0.19882651f, -0.08361904f, 
    -0.18788978f, 0.02194926f, 0.26948875f, 0.46105522f, 0.29290515f, 0.02886170f, 0.11703844f, -0.07493241f, 
    0.17553009f, 0.02892812f, 0.14676532f, -0.01686969f, 0.05083675f, 0.15560912f, 0.16532856f, 0.16841598f, 
    -0.08551487f, 0.11636151f, -0.08429544f, 0.03349569f, 0.13461964f, 0.05757948f, 0.24356745f, -0.00012127f, 
    -0.07810310f, -0.11204659f, -0.13067704f, -0.43102342f, -0.25245720f, -0.06792269f, -0.03982126f, 0.23785792f, 
    -0.20984375f, 0.02892740f, 0.15260728f, 0.06167938f, 0.06443176f, -0.13730037f, -0.25613660f, -0.27193746f, 
    0.12010202f, -0.00378425f, 0.04569253f, 0.27018335f, -0.00440274f, 0.11869704f, 0.00256471f, 0.06302402f, 
    0.34562799f, 0.20064884f, -0.23403633f, 0.04892631f, 0.43812940f, 0.18184288f, 0.28046244f, 0.28989115f, 
    -0.14727950f, 0.20412895f, 0.01974127f, -0.08607406f, 0.19044743f, 0.03178471f, 0.04569165f, 0.03018618f, 
    0.02833991f, -0.12349298f, 0.27495307f, -0.27963629f, 0.23186822f, -0.06984916f, 0.17895737f, -0.06860383f, 
    0.10211893f, 0.14040573f, -0.05855749f, -0.13691393f, 0.02579627f, 0.13255201f, -0.17590752f, -0.08167032f, 
    0.06323148f, 0.03143536f, -0.12206243f, -0.02571247f, 0.21959208f, -0.12428124f, 0.30066878f, 0.10571474f, 
    0.47938591f, -0.20208502f, 0.25078872f, 0.14635661f, 0.01165386f, -0.28086209f, 0.04882220f, -0.25671160f, 
    -0.16636467f, -0.22114347f, -0.07067142f, 0.05033400f, 0.17769684f, 0.04969437f, 0.26394564f, 0.07290115f, 
    0.03121827f, -0.10804834f, 0.01908636f, -0.05380378f, 0.02664728f, 0.00208109f, -0.02236009f, 0.39988160f, 
    0.04860795f, 0.18995957f, 0.19857955f, 0.09415992f, 0.06930661f, -0.10357570f, -0.19760861f, -0.02684017f, 
    -0.03485193f, -0.05769296f, 0.38326252f, 0.07267580f, 0.03532941f, -0.00193963f, -0.01608601f, 0.15659010f, 
    0.05866469f, -0.04445140f, 0.01472944f, -0.21938396f, -0.02842894f, 0.01497141f, 0.05765823f, 0.13145743f, 
    0.05491335f, 0.05791878f, -0.12675680f, -0.05287659f, 0.06119517f, 0.06615885f, 0.03717103f, -0.11404108f, 
    -0.06853359f, 0.03070574f, -0.00185044f, -0.03973231f, -0.10487124f, 0.00901328f, -0.09484941f, 0.04768947f, 
    -0.09118539f, -0.17775331f, 0.03735342f, -0.07881159f, 0.11845286f, 0.05916056f, -0.10316303f, 0.00958442f, 
    0.08693331f, -0.15531404f, -0.12447228f, 0.10038944f, -0.11664023f, 0.07123636f, 0.04967332f, -0.06425440f, 
    -0.05822951f, -0.09460451f, -0.07467507f, 0.04435460f, 0.04012626f, -0.10509828f, -0.06552195f, -0.10350512f, 
    -0.02639283f, 0.00213321f, 0.08867074f, 0.03487996f, -0.07475563f, -0.13605385f, -0.08066172f, -0.10456239f, 
    -0.10866152f, -0.07962845f, -0.08656360f, 0.00262009f, 0.03666295f, 0.09105346f, 0.07945561f, -0.07243516f, 
    -0.03357814f, -0.02060505f, -0.03046742f, -0.05103687f, -0.03233107f, 0.05395958f, -0.03959030f, -0.05291619f, 
    0.03406942f, -0.25524986f, 0.09392027f, -0.07465173f, 0.10953067f, 0.00113959f, 0.61649859f, -0.08608413f, 
    0.00946764f, -0.02910382f, -0.10105124f, -0.14566524f, -0.12752748f, -0.11200885f, 0.31541300f, 0.04641828f, 
    0.02121534f, -0.00065002f, 0.41004139f, -0.30751866f, -0.00240376f, 0.16367318f, 0.03719734f, 0.36120263f, 
    0.35371608f, 0.21603423f, 0.08856074f, -0.07028926f, 0.02765695f, 0.51006103f, 0.21164529f, -0.24882118f, 
    -0.05214634f, -0.22658518f, -0.04229397f, -0.13113646f, 0.40262777f, -0.04598995f, 0.01018066f, -0.09737971f, 
    0.16641591f, 0.20290545f, 0.25191787f, 0.04102197f, 0.11761709f, 0.07006728f, 0.05272956f, 0.06121583f, 
    0.14251997f, -0.12121728f, 0.16313384f, 0.00649637f, 0.25247297f, -0.09738272f, -0.16725029f, 0.16757041f, 
    0.28176579f, 0.05873351f, -0.15241410f, 0.25850052f, -0.06939232f, -0.04406529f, 0.17550580f, 0.11633905f, 
    -0.06588020f, 0.20943800f, 0.24953033f, 0.24727118f, -0.03153353f, 0.24025817f, 0.07558471f, -0.17614074f, 
    -0.11208596f, -0.23608856f, -0.06545764f, -0.19847085f, 0.01470227f, 0.04436561f, 0.13779622f, -0.11134717f, 
    0.00878553f, 0.36824423f, 0.17912851f, -0.22211052f, -0.04085815f, 0.55006826f, -0.05583256f, 0.02557500f, 
    0.32683241f, 0.22231196f, -0.01587346f, 0.03292051f, 0.00378200f, 0.38752031f, -0.01865939f, -0.24289954f, 
    0.02763584f, -0.17127037f, -0.06933236f, -0.04918665f, 0.31228563f, 0.03160740f, 0.16613941f, 0.02982581f, 
    -0.13748951f, 0.11625604f, -0.05573028f, 0.03966424f, -0.27202773f, 0.11206860f, -0.05803575f, -0.09247734f, 
    -0.18121360f, -0.21701668f, 0.29276344f, 0.00448641f, 0.10560615f, -0.12161878f, -0.11354221f, 0.20544258f, 
    -0.07390437f, -0.45708543f, 0.10035195f, -0.05014859f, -0.12213534f, -0.01761450f, 0.05491884f, 0.04006674f, 
    -0.10119710f, -0.20622940f, 0.19418623f, -0.05985719f, -0.12752773f, -0.14582366f, 0.14734535f, -0.11455804f, 
    0.00693116f, -0.12015537f, 0.00637457f, -0.08191625f, 0.16484596f, 0.04313064f, 0.20092495f, -0.03677191f, 
    0.36028633f, -0.27162945f, 0.47456098f, 0.28147933f, 0.13094035f, 0.06735013f, -0.08962628f, -0.04914888f, 
    0.08628644f, 0.09940597f, -0.17586756f, -0.09644575f, 0.11514588f, 0.23819290f, 0.30360129f, -0.05613472f, 
    -0.20244429f, -0.21966586f, 0.04348716f, -0.14672686f, -0.02360269f, -0.10519877f, 0.19780397f, 0.36127150f, 
    -0.27660707f, 0.24399400f, 0.20005886f, 0.25461257f, 0.11491053f, -0.04574136f, -0.28048092f, 0.05139043f, 
    0.50364339f, 0.11276277f, 0.28243694f, 0.24011488f, 0.11026242f, -0.19133364f, -0.41757089f, 0.15416943f, 
    -0.01343006f, -0.14540370f, -0.15351610f, 0.24944285f, -0.13214079f, -0.11629754f, -0.01102167f, 0.00632579f, 
    -0.03344711f, 0.09428553f, 0.08872160f, 0.21117659f, -0.05859118f, -0.26940331f, 0.11489224f, 0.24409735f, 
    -0.16930260f, 0.03983550f, 0.06125604f, -0.08105955f, -0.10463739f, 0.12083870f, -0.15470251f, 0.05605218f, 
    -0.27894446f, 0.41720685f, -0.12086856f, -0.32408980f, 0.10700925f, 0.47307953f, 0.03866443f, 0.22269979f, 
    0.27538860f, 0.37808654f, 0.08178006f, -0.11538249f, -0.34153935f, -0.01680909f, 0.13075130f, -0.05616770f, 
    0.28059027f, 0.03232488f, 0.06434236f, 0.39094105f, 0.07385076f, 0.08379105f, 0.02162046f, -0.37159517f, 
    -0.17006011f, 0.09328856f, 0.22628722f, -0.11591297f, 0.07016686f, -0.00687354f, 0.13910121f, 0.09593437f, 
    -0.12953076f, -0.00687824f, -0.19156545f, 0.08244062f, 0.06783689f, -0.13735136f, -0.14127697f, 0.03927752f, 
    0.01147811f, -0.25321931f, 0.08623599f, -0.28609449f, -0.15918434f, -0.09520280f, 0.03693207f, -0.32487434f, 
    0.03097854f, 0.13372450f, 0.11780984f, -0.23861176f, -0.00717359f, 0.05695142f, -0.06060015f, -0.11624795f, 
    -0.02550433f, -0.17400222f, -0.06223035f, 0.22580175f, 0.07251417f, 0.11602152f, 0.56562519f, 0.07207429f, 
    0.20798935f, 0.08911770f, 0.03875928f, -0.23996899f, -0.29153365f, -0.01661396f, 0.07734996f, 0.20440897f, 
    -0.13826792f, 0.11919120f, -0.13176580f, -0.00687821f, 0.08499783f, 0.07217220f, 0.41259071f, 0.10221167f, 
    0.09858109f, -0.05668687f, 0.07964313f, -0.09753896f, 0.06927226f, 0.07547037f, -0.22096421f, 0.30499014f, 
    0.14656059f, 0.28908676f, 0.12531036f, 0.00857114f, 0.36033946f, 0.11215456f, 0.13936456f, 0.12762493f, 
    -0.01865658f, 0.36751160f, 0.29665482f, 0.01375214f, -0.20435916f, -0.16094638f, -0.10859015f, 0.02894200f, 
    -0.14781395f, -0.04850678f, 0.26103598f, -0.14714943f, 0.16785064f, 0.06207920f, 0.18720816f, -0.06564777f, 
    -0.23904897f, -0.16501969f, -0.03122333f, -0.46476150f, -0.09758069f, 0.13418370f, 0.19640985f, 0.42773026f, 
    -0.25350258f, -0.00641539f, -0.01050252f, 0.23198348f, 0.08704755f, 0.07612972f, 0.11196052f, 0.05350095f, 
    0.21257876f, -0.32326087f, 0.14864117f, -0.32425880f, -0.05327312f, -0.40385309f, 0.16988720f, 0.63182622f, 
    -0.33395344f, 0.20363429f, -0.21730354f, -0.05566149f, -0.10828878f, -0.27579287f, 0.06338546f, -0.13777018f, 
    0.00567935f, -0.12397421f, -0.06300898f, 0.18949389f, 0.02803896f, 0.14471449f, -0.00773339f, 0.15322350f, 
    -0.07707868f, -0.06692882f, 0.09379174f, -0.15811026f, 0.52223861f, 0.34461677f, 0.24763365f, 0.10093065f, 
    0.12535940f, 0.29248628f, 0.13627388f, 0.15876107f, -0.10453732f, -0.26488182f, -0.08311297f, -0.03616095f, 
    -0.16400057f, -0.20104967f, 0.13228478f, 0.29303235f, 0.02809140f, -0.01235364f, 0.35264361f, 0.20173123f, 
    0.13280101f, 0.28904808f, -0.07833574f, -0.23447432f, 0.03284502f, 0.26638970f, -0.46453664f, 0.16986485f, 
    -0.29694828f, -0.09491567f, 0.03522889f, -0.20918988f, -0.03338987f, 0.00203912f, -0.08170148f, 0.05921284f, 
    0.15165344f, 0.01700855f, -0.26898640f, 0.03410859f, 0.02265049f, 0.05195911f, -0.08224002f, 0.02531966f, 
    -0.10427456f, -0.21144325f, 0.13575464f, -0.07507174f, -0.01075388f, -0.02528274f, 0.19442914f, -0.33029115f, 
    0.14799447f, 0.02510104f, -0.08823723f, 0.09120037f, 0.12578972f, 0.10426795f, 0.09505309f, -0.20089388f, 
    -0.35896841f, -0.04517450f, -0.38220537f, 0.17726614f, 0.08839326f, 0.29857838f, 0.23290581f, 0.00457808f, 
    -0.25261325f, 0.05115460f, -0.00761508f, 0.08990819f, -0.05647337f, -0.33510002f, 0.09614661f, 0.09860390f, 
    -0.10983551f, -0.30284131f, -0.01963251f, -0.24134338f, 0.13397405f, 0.12253600f, 0.06246026f, 0.08965871f, 
    -0.12741517f, 0.32821539f, 0.10780222f, 0.50373715f, -0.22932929f, 0.12880330f, -0.27433583f, -0.03930175f, 
    0.51426053f, 0.14657527f, -0.05823064f, -0.07460463f, 0.20787863f, 0.04286976f, 0.14440000f, -0.10862789f, 
    -0.02794653f, 0.56663847f, 0.27068993f, -0.01271909f, 0.10484757f, 0.35027865f, 0.08918565f, -0.26840800f, 
    0.36083812f, 0.03505621f, 0.05624910f, -0.01416551f, -0.13562098f, 0.14614177f, 0.09226093f, 0.02471809f, 
    -0.07091759f, -0.15652734f, -0.00288790f, 0.08064555f, 0.07560021f, -0.05135601f, 0.16938169f, 0.12162984f, 
    0.10875460f, 0.04341207f, -0.07867238f, -0.00036672f, -0.32049012f, -0.17732058f, -0.22541797f, -0.03937408f, 
    0.21770354f, -0.07726637f, 0.19011985f, -0.02955958f, -0.10166149f, 0.21017861f, 0.09422840f, 0.12829646f, 
    -0.05650530f, -0.16460517f, 0.25674772f, -0.03228015f, -0.08465130f, -0.00611318f, -0.13788986f, -0.02814063f, 
    0.10894249f, -0.03812912f, -0.07965890f, 0.17553429f, -0.07710485f, 0.03665286f, -0.36172006f, -0.20217675f, 
    0.26011309f, 0.18867025f, -0.01552069f, 0.21095110f, 0.02614186f, -0.10213792f, 0.03283680f, 0.10316548f, 
    -0.17048821f, 0.00586197f, 0.02730333f, -0.15413016f, -0.02983066f, -0.01868540f, 0.01321287f, -0.06141505f, 
    0.30245614f, -0.01564375f, 0.24706788f, 0.03313525f, -0.17853385f, 0.14637034f, -0.11403410f, -0.16289733f, 
    0.04170005f, -0.18434675f, -0.01433255f, 0.01081822f, -0.02878827f, -0.07845902f, 0.08269460f, 0.22574162f, 
    0.20300639f, 0.15174577f, -0.22302632f, -0.00888569f, 0.02381313f, -0.11924340f, -0.00853580f, 0.18434186f, 
    -0.10617016f, 0.01968959f, -0.09074817f, -0.13030347f, -0.02413660f, -0.08276813f, 0.02337618f, -0.09310360f, 
    0.08800329f, 0.01238899f, 0.01931646f, -0.02871596f, 0.16141239f, -0.02826284f, 0.05591290f, -0.13090418f, 
    0.04230742f, 0.09909806f, -0.02409077f, 0.34819487f, -0.01734314f, -0.00663376f, 0.09108745f, 0.08196847f, 
    0.10432430f, 0.02887254f, -0.09363820f, -0.04909953f, -0.09893358f, -0.04036735f, -0.13509360f, 0.02745461f, 
    -0.08863251f, 0.25481495f, 0.05451176f, 0.22493540f, 0.22539996f, 0.32121828f, 0.10760884f, -0.13256508f, 
    0.31797785f, 0.24041101f, 0.09527141f, 0.04568140f, -0.18262534f, 0.25198206f, -0.09696984f, 0.15176521f, 
    0.14329787f, 0.04439387f, -0.05530006f, 0.21643782f, 0.28003857f, 0.00964798f, 0.07744464f, -0.30210707f, 
    -0.16637799f, -0.14882213f, 0.16077523f, 0.14590919f, -0.17928936f, 0.06892400f, -0.02983954f, 0.05224136f, 
    -0.26428124f, -0.42427954f, 0.09620168f, 0.05759287f, -0.11664980f, 0.15011041f, -0.02374044f, 0.15979949f, 
    0.22021903f, -0.25611335f, -0.02040771f, -0.32968542f, 0.00856089f, 0.01557226f, -0.13971880f, -0.13963500f, 
    -0.02902862f, -0.02313071f, -0.07449081f, 0.04837391f, -0.00497914f, -0.01587512f, 0.07759273f, -0.01183021f, 
    -0.11806007f, -0.13349549f, 0.10256937f, 0.07231548f, 0.01132289f, 0.06995195f, -0.11625215f, -0.10958177f, 
    -0.05003314f, 0.06323195f, 0.02905099f, -0.06513885f, 0.08707558f, 0.05236240f, 0.09130533f, 0.03387765f, 
    -0.01241191f, 0.01329852f, -0.13592325f, -0.06044924f, -0.06750667f, 0.03750562f, -0.02262133f, 0.08151105f, 
    -0.09209426f, -0.06427257f, -0.01425362f, -0.03125293f, -0.06525274f, 0.07317028f, -0.05777757f, -0.03563082f, 
    0.04379318f, -0.07119340f, 0.01714431f, -0.02671459f, 0.01511680f, -0.08839645f, -0.09685475f, -0.04541598f, 
    -0.03667123f, -0.04298694f, -0.04374130f, -0.00739007f, 0.09491039f, 0.01823987f, -0.01444563f, 0.03013792f, 
    -0.05618034f, -0.13241661f, -0.04285612f, 0.05882309f, -0.10493314f, -0.08683686f, 0.07688711f, 0.03531248f, 
    -0.13189420f, -0.07534853f, -0.12108856f, -0.21233742f, -0.30803674f, 0.30561760f, 0.45103016f, 0.16083094f, 
    -0.07734441f, -0.20778783f, -0.05840573f, 0.39499414f, 0.09322765f, 0.06354187f, 0.37410280f, 0.10915112f, 
    0.16935955f, -0.04171986f, 0.13990544f, -0.32647821f, -0.09141351f, 0.03989974f, 0.07768321f, 0.29409939f, 
    0.07143759f, 0.16449250f, 0.03316450f, -0.01920424f, -0.31613255f, 0.12436120f, 0.55542624f, -0.10421996f, 
    0.09592603f, -0.06430563f, -0.04901192f, 0.01879480f, 0.21831994f, 0.15774940f, -0.15305617f, 0.16112883f, 
    0.01372362f, -0.13774619f, -0.02750013f, -0.04726193f, 0.55785781f, 0.38048422f, -0.01082736f, -0.03955742f, 
    -0.28449771f, 0.39533275f, 0.21726289f, 0.03542176f, -0.12226886f, -0.30918938f, 0.09621146f, 0.07315946f, 
    -0.13832942f, -0.03062412f, 0.02997727f, -0.10926941f, 0.15420410f, 0.05190134f, 0.21671081f, -0.13081436f, 
    0.05045690f, -0.09418828f, 0.06022664f, -0.04077770f, -0.00453485f, -0.16587541f, -0.08722331f, -0.13331905f, 
    0.38293245f, 0.11898620f, 0.06073076f, 0.22957943f, 0.25804964f, -0.01323972f, 0.02791215f, 0.08553275f, 
    0.19160166f, -0.14527659f, 0.20372649f, 0.18352818f, 0.09274619f, -0.10442707f, 0.04538629f, -0.27863032f, 
    0.08127061f, -0.13247988f, -0.00162034f, 0.05986268f, -0.03717329f, 0.15987173f, 0.12125913f, -0.03929184f, 
    -0.21179360f, 0.03553494f, -0.09609906f, -0.26217759f, -0.05143989f, -0.10554902f, 0.15223204f, 0.49895576f, 
    0.18605831f, 0.07405221f, 0.22452931f, -0.11784036f, -0.14664574f, -0.28475434f, -0.12871473f, -0.06079072f, 
    0.12401178f, 0.07503657f, 0.05863723f, -0.09058600f, -0.11475471f, 0.16753973f, -0.16082162f, 0.05465716f, 
    0.11377387f, -0.03117502f, -0.00837358f, -0.05976159f, -0.11852290f, 0.01424413f, -0.08018225f, -0.03160479f, 
    0.13912162f, 0.00598388f, -0.20581011f, -0.12328921f, 0.18902665f, -0.07315348f, -0.00079285f, -0.03958417f, 
    0.13724269f, 0.19194721f, 0.11588629f, -0.21994855f, 0.04770605f, -0.07149309f, -0.12084907f, -0.00130475f, 
    0.06222559f, 0.03759352f, 0.31816471f, 0.10493153f, 0.22070584f, 0.13272719f, -0.02133927f, -0.37311020f, 
    0.27784285f, 0.08454510f, 0.07078370f, 0.10946626f, 0.02689004f, 0.44802460f, 0.07709458f, -0.38538605f, 
    0.04304629f, 0.07503536f, -0.02979317f, -0.39895046f, 0.27241027f, -0.08347777f, 0.10359507f, -0.00293208f, 
    -0.05856211f, -0.46868828f, -0.10513504f, 0.12237319f, -0.24414261f, 0.16853118f, 0.00495015f, 0.05588638f, 
    0.16193220f, -0.21661958f, 0.08543701f, 0.24703945f, -0.05644928f, 0.10168820f, -0.21208748f, -0.08827191f, 
    0.21786340f, -0.24909332f, -0.00580630f, -0.05199360f, 0.17521581f, -0.00900094f, -0.18102902f, 0.03744727f, 
    -0.24300309f, -0.06100744f, 0.23248118f, -0.14122403f, -0.47722781f, 0.13641134f, 0.26617929f, 0.28387722f, 
    -0.03290295f, -0.31215954f, -0.07021561f, 0.06829746f, 0.07139073f, -0.05772997f, 0.18458012f, -0.05181958f, 
    0.04206003f, 0.02916604f, 0.16995494f, -0.34648973f, 0.17108843f, 0.09911580f, 0.10307372f, 0.40689996f, 
    0.13338837f, 0.29334384f, -0.24939206f, 0.09030378f, -0.71968400f, -0.02117867f, 0.26839739f, -0.20033205f, 
    0.11173705f, -0.04346012f, 0.09297273f, 0.04499050f, 0.35314921f, 0.19128630f, 0.06232005f, 0.12615111f, 
    -0.08835422f, 0.30474284f, 0.19199678f, -0.15557359f, 0.27512640f, 0.09166750f, -0.12593433f, -0.01493629f, 
    -0.35860464f, -0.26206237f, 0.29992524f, 0.03791817f, 0.00544204f, -0.47592378f, -0.24119657f, 0.07088461f, 
    -0.20265633f, 0.14155203f, -0.07366528f, -0.37881464f, 0.03994444f, -0.06106544f, 0.15025128f, -0.49011657f, 
    -0.04388829f, -0.04395114f, 0.18513042f, 0.34575582f, -0.12365136f, -0.09699753f, 0.17474087f, 0.23203653f, 
    -0.17217533f, 0.22734122f, -0.00737076f, 0.12647092f, -0.05233207f, 0.05456556f, -0.00751040f, 0.03524548f, 
    -0.01587912f, 0.29395330f, -0.22204722f, -0.42031217f, -0.18383253f, 0.07881048f, -0.13144666f, 0.37597108f, 
    0.12681644f, 0.11092232f, 0.20250344f, 0.09263834f, -0.08121831f, -0.37037304f, -0.28509191f, 0.12355196f, 
    0.31678256f, 0.03551932f, -0.10987543f, 0.48592442f, -0.14576672f, 0.04916867f, 0.00846405f, -0.14935668f, 
    0.04502368f, 0.23848003f, -0.12309133f, -0.03889163f, 0.03877966f, 0.18456301f, 0.12748879f, 0.15365563f, 
    -0.15768245f, 0.32265845f, -0.16509412f, 0.07116818f, 0.13155632f, 0.02824959f, 0.08449636f, -0.07196094f, 
    0.05168722f, -0.02680614f, 0.31087771f, -0.10410026f, -0.18566319f, -0.07433672f, 0.18866751f, -0.17072360f, 
    -0.10266109f, 0.06313882f, 0.04037700f, 0.04273568f, -0.12170175f, -0.09386092f, -0.02881772f, -0.12588787f, 
    -0.06354293f, 0.01766434f, -0.09244318f, 0.02606032f, 0.03525901f, 0.06431158f, 0.01997834f, -0.05259565f, 
    -0.18188958f, -0.01517938f, -0.08146901f, -0.00729769f, 0.03117799f, 0.08437112f, -0.03640245f, -0.06771573f, 
    -0.09415442f, 0.02406392f, 0.08161902f, 0.01237597f, -0.07734776f, -0.04939278f, 0.05725802f, -0.04591414f, 
    -0.04531957f, -0.10795312f, -0.03933255f, -0.14943543f, -0.03217376f, 0.07787690f, -0.16981736f, 0.01762079f, 
    -0.10133653f, -0.02732455f, -0.07804453f, -0.11898739f, -0.01080334f, 0.03953518f, 0.01000759f, -0.11548366f, 
    -0.05332316f, 0.01009313f, 0.04703163f, -0.12234551f, 0.08039117f, 0.00723582f, -0.07034586f, -0.16378801f, 
    -0.11496112f, -0.00516535f, -0.10365875f, 0.04491392f, 0.08615011f, 0.00793354f, -0.22768776f, -0.10661061f, 
    0.06357819f, 0.06053057f, -0.36309996f, -0.18182862f, -0.11233091f, -0.09665859f, -0.12978038f, 0.12822694f, 
    -0.01107219f, 0.19835989f, -0.04663637f, 0.39560673f, 0.08389216f, -0.09864176f, 0.09150033f, 0.07295673f, 
    -0.44791824f, 0.19661634f, 0.04884498f, 0.00561042f, -0.22850715f, 0.33025151f, -0.11455272f, 0.12490521f, 
    0.06796159f, 0.02519236f, 0.00087801f, 0.00553521f, -0.10792505f, 0.08045021f, 0.16314206f, -0.06740495f, 
    0.18258640f, -0.23947132f, -0.05655913f, -0.01864551f, 0.04541420f, 0.15460980f, -0.11595666f, -0.02485815f, 
    0.00630577f, -0.23072159f, 0.37339664f, -0.07998200f, 0.47025982f, 0.07991770f, 0.27578980f, 0.10418320f, 
    -0.07450227f, 0.11761950f, -0.21999311f, -0.02551028f, -0.11976444f, -0.14250740f, -0.39747077f, -0.18872596f, 
    0.05164781f, -0.07190071f, -0.00224081f, 0.36701113f, 0.22068377f, 0.06275813f, 0.04582248f, -0.12802373f, 
    0.08045241f, -0.02625684f, 0.12814668f, 0.28388375f, 0.02769129f, -0.05390223f, -0.42794472f, -0.24737583f, 
    0.16603267f, 0.11096231f, -0.07444689f, -0.10253178f, 0.03129124f, -0.05601452f, -0.10002635f, -0.09805383f, 
    -0.32700527f, 0.31877452f, -0.08513008f, -0.09450614f, 0.13944907f, 0.23371552f, 0.04875015f, -0.04526188f, 
    0.43388265f, 0.11837585f, 0.35471892f, -0.07928532f, -0.28985581f, 0.33163351f, 0.03881097f, -0.32350731f, 
    0.00315958f, 0.06925648f, -0.09326436f, 0.09840131f, 0.27603385f, 0.01526541f, 0.13379201f, -0.17440481f, 
    0.16701795f, -0.05911824f, -0.32201388f, 0.02799485f, -0.31863874f, -0.14002578f, 0.02347351f, 0.04731051f, 
    0.04180853f, -0.28498864f, -0.14804828f, -0.01646718f, 0.02994560f, 0.19560376f, -0.05605664f, 0.08844799f, 
    0.20557326f, -0.15877122f, -0.01483079f, -0.07931651f, 0.01384217f, -0.09504289f, -0.11275172f, -0.09613512f, 
    -0.13316500f, -0.04744360f, -0.01657501f, -0.03164595f, -0.05358061f, -0.04201346f, -0.08249018f, -0.01458592f, 
    -0.06987863f, -0.01490458f, 0.11710897f, -0.02686657f, 0.01055359f, 0.08932988f, 0.00720855f, -0.09141114f, 
    0.01765716f, -0.01292720f, 0.07820348f, -0.07668139f, 0.07389251f, -0.13197309f, 0.10329074f, -0.04363009f, 
    -0.07214816f, 0.09021432f, -0.09892614f, 0.08674416f, 0.02375603f, -0.09375360f, -0.05238235f, -0.02479143f, 
    -0.10323666f, -0.12473278f, 0.06076592f, 0.07455553f, -0.03240469f, -0.15334436f, 0.02063887f, -0.03241322f, 
    0.01571643f, 0.05934295f, -0.08310996f, -0.02965417f, -0.05479662f, 0.06959530f, -0.08906608f, -0.11420147f, 
    -0.14754124f, 0.02909784f, -0.12162627f, 0.04224161f, -0.09425627f, -0.08211929f, -0.02751387f, -0.13746515f, 
    0.00087240f, -0.01007153f, 0.05955546f, -0.08619979f, -0.01453202f, -0.07308355f, 0.04450813f, -0.10647679f, 
    0.04067909f, 0.33663431f, 0.23155493f, -0.15842469f, -0.16914032f, 0.11585276f, -0.11936370f, 0.33975124f, 
    0.00145324f, 0.14649481f, -0.01671655f, 0.37709087f, 0.20860380f, 0.00178010f, 0.04876983f, 0.07933146f, 
    0.20251305f, -0.08886416f, -0.22582790f, 0.14084230f, 0.03210246f, -0.36435550f, -0.04702254f, 0.03571248f, 
    -0.29346117f, -0.19447656f, -0.03706704f, -0.02999743f, -0.05546099f, -0.30959967f, 0.17551911f, 0.20353255f, 
    0.04805875f, 0.10674724f, -0.11407451f, 0.30666518f, -0.04098305f, 0.12378327f, -0.05371750f, 0.34982499f, 
    -0.08401787f, 0.25351000f, -0.04821068f, 0.15700914f, 0.24036454f, 0.16810997f, -0.11001284f, -0.05271965f, 
    0.05604079f, 0.28727999f, 0.00645671f, -0.00168190f, -0.23898616f, 0.07381376f, 0.24093413f, 0.15095474f, 
    -0.10335081f, 0.03864736f, 0.10147417f, -0.20505752f, -0.01633096f, -0.02643240f, 0.19524144f, -0.01906876f, 
    -0.04826976f, 0.08019762f, 0.11219286f, 0.00923650f, -0.10844131f, -0.03315710f, -0.08897202f, -0.05978900f, 
    -0.11909762f, 0.00578291f, -0.05831836f, -0.02822460f, 0.01937792f, -0.09154375f, -0.09460632f, 0.02860764f, 
    0.01897343f, 0.02452635f, 0.04026000f, -0.01539817f, 0.06575318f, -0.00567369f, -0.05924454f, -0.07273860f, 
    -0.09283761f, 0.01282153f, -0.10488845f, 0.11881185f, -0.06685463f, 0.10384293f, 0.05299124f, -0.06954634f, 
    -0.06547129f, -0.04807266f, 0.12119801f, -0.13345477f, 0.05224084f, -0.08907156f, -0.09366243f, 0.00651121f, 
    -0.01953564f, 0.00016532f, 0.00220809f, -0.11722643f, -0.04497214f, -0.04885613f, -0.00304856f, 0.09532672f, 
    0.08588965f, -0.09555908f, 0.07164069f, 0.00991005f, -0.08490662f, -0.00451564f, 0.07396317f, -0.08725361f, 
    -0.12848581f, 0.09027907f, 0.05016363f, -0.08403347f, -0.01936113f, 0.07607600f, -0.04977204f, 0.07756466f, 
    0.00100169f, -0.00455863f, 0.05335458f, -0.13862182f, -0.01559859f, -0.02178029f, -0.04381146f, -0.01570494f, 
    -0.10359480f, -0.00495260f, 0.08687210f, 0.00593753f, -0.10897546f, -0.06341036f, -0.06442283f, -0.10130550f, 
    -0.16730005f, -0.11313559f, 0.08990703f, -0.05324172f, -0.16449818f, 0.13420512f, -0.09003796f, -0.12140802f, 
    -0.05181133f, -0.06488488f, -0.08925092f, -0.12109272f, -0.04075726f, 0.04575128f, 0.01269847f, -0.07821558f, 
    -0.11883927f, 0.03617911f, 0.07453622f, -0.00139554f, -0.10706344f, -0.07467407f, -0.11534114f, 0.02587544f, 
    -0.01745709f, 0.06461277f, 0.05605850f, 0.07788307f, -0.03063957f, -0.11241514f, -0.08037221f, -0.04307117f, 
    0.12189758f, 0.01750553f, -0.00393446f, -0.16156048f, 0.07333392f, -0.04929506f, -0.02198951f, 0.01730012f, 
    -0.05234484f, -0.10534182f, 0.07044581f, -0.00976341f, 0.01898262f, -0.10181688f, 0.08295579f, -0.01672358f, 
    0.01515607f, 0.44479182f, 0.13369723f, 0.03522634f, -0.33038908f, -0.43043986f, -0.50692368f, -0.12033771f, 
    0.20045693f, -0.17924704f, -0.01291761f, -0.11506418f, 0.20810378f, 0.07446362f, -0.12264925f, 0.06788046f, 
    0.24603729f, 0.32994500f, 0.08094536f, 0.57285750f, 0.38207445f, 0.34845698f, -0.09690632f, -0.54536223f, 
    -0.01361661f, -0.19827010f, -0.17639312f, 0.11168872f, -0.02022620f, 0.12057090f, 0.37507179f, -0.05892492f, 
    0.06626821f, -0.11961469f, 0.03446889f, 0.19440794f, -0.11933514f, 0.02550917f, 0.19707927f, -0.10886298f, 
    -0.58577240f, 0.04185655f, -0.08981655f, 0.19522037f, -0.36684799f, -0.05016842f, -0.23469844f, -0.10365928f, 
    -0.22342892f, -0.18745823f, 0.12905562f, 0.12419660f, -0.11594272f, -0.26008967f, -0.44546229f, 0.19177669f, 
    -0.24373609f, -0.52963489f, 0.23298788f, 0.18895055f, -0.06791473f, -0.02261436f, -0.26230720f, -0.05396889f, 
    0.01143489f, -0.02221759f, 0.10535290f, 0.01875551f, -0.10612328f, -0.02178039f, -0.03220320f, 0.02913754f, 
    -0.00397073f, -0.03826090f, -0.10431518f, -0.07158634f, -0.06012356f, -0.12441242f, 0.01689899f, 0.09640651f, 
    0.09965558f, 0.04239989f, -0.03876241f, 0.00072458f, 0.10396736f, -0.03496248f, -0.12352309f, 0.07985855f, 
    0.03764781f, -0.12225626f, -0.14581266f, -0.00512560f, -0.01343004f, 0.04367985f, -0.13591635f, -0.04606884f, 
    -0.13131617f, -0.14454615f, -0.06192143f, 0.06462115f, 0.04486375f, 0.04968811f, -0.13006796f, -0.02967759f, 
    -0.14464940f, -0.10865584f, 0.01102277f, -0.15135355f, -0.07507866f, -0.01921404f, 0.02494456f, -0.03501493f, 
    -0.09200382f, -0.02090284f, 0.01173920f, 0.01803692f, -0.07983286f, -0.08033989f, -0.03525963f, -0.11367349f, 
    -0.01051691f, 0.07365483f, -0.02418046f, 0.04902821f, 0.07754751f, 0.09194176f, -0.04671749f, -0.04733771f, 
    0.14369406f, -0.11900713f, -0.08314626f, -0.18703973f, -0.04793787f, -0.17922333f, -0.23569964f, -0.10386825f, 
    -0.02516310f, 0.08121168f, 0.05977391f, -0.07572445f, -0.24035768f, -0.05969331f, -0.00955995f, 0.02992894f, 
    -0.11539117f, -0.10277127f, 0.02822471f, -0.04362936f, 0.07287716f, 0.07516871f, -0.01775494f, -0.06630104f, 
    -0.24785540f, -0.16924018f, 0.03135988f, 0.08094491f, -0.04092740f, -0.18358144f, -0.22472528f, 0.02874720f, 
    0.04220384f, 0.01262832f, 0.07437047f, -0.08178013f, -0.28467485f, -0.00272881f, 0.01300008f, -0.15618944f, 
    -0.13093185f, -0.12034099f, 0.08066084f, 0.09445437f, -0.20125240f, 0.09086668f, -0.01350916f, -0.01863737f, 
    0.04161649f, 0.00158269f, 0.03264851f, -0.22210394f, 0.03142153f, -0.14118518f, -0.02425454f, -0.03583004f, 
    0.05068356f, 0.16390397f, -0.08849610f, -0.22968900f, -0.01371381f, -0.02884156f, -0.16488953f, -0.10160916f, 
    0.26748264f, 0.15893067f, 0.12978582f, 0.28012195f, 0.19247441f, -0.00618045f, -0.43539390f, -0.22758561f, 
    0.07381751f, 0.07367033f, -0.04491536f, -0.43704268f, 0.01917853f, -0.12394522f, -0.06086555f, 0.05848691f, 
    -0.20475616f, 0.16272064f, -0.23606217f, -0.02711605f, 0.11163305f, 0.18082659f, -0.06171778f, -0.15705080f, 
    0.16464272f, 0.06738513f, 0.26503578f, 0.10782202f, -0.15078360f, 0.23500195f, -0.27342263f, -0.31361586f, 
    0.04304959f, 0.13567947f, 0.01071239f, -0.12408992f, 0.11198268f, 0.14786240f, 0.05235922f, -0.04922977f, 
    0.16614085f, 0.03606629f, 0.04842397f, 0.09515329f, -0.37341252f, 0.03918209f, 0.14868757f, 0.16757646f, 
    0.11625092f, -0.13414250f, 0.06513435f, -0.01961355f, 0.13808171f, 0.16812454f, 0.17708611f, -0.03394755f, 
    0.13356398f, 0.08714386f, 0.28724393f, -0.23727539f, 0.23064883f, 0.12032387f, -0.09749003f, -0.00939133f, 
    0.09823035f, -0.16216616f, 0.01306377f, 0.02168112f, 0.02931689f, -0.23213863f, -0.19955605f, 0.05790493f, 
    0.06025364f, -0.33466840f, -0.06129867f, -0.45255172f, -0.00486091f, 0.09854698f, -0.05405238f, -0.09033260f, 
    0.09719571f, -0.21982910f, -0.02653399f, -0.02442449f, -0.26805699f, -0.29614457f, 0.01252817f, -0.10370837f, 
    -0.16776830f, -0.02973785f, -0.19929248f, 0.03513341f, 0.08895355f, -0.10409616f, -0.42817739f, 0.00815918f, 
    -0.02464132f, 0.05802304f, 0.03867851f, -0.07183703f, -0.12948230f, 0.06682717f, -0.00934122f, -0.10944030f, 
    0.17461267f, -0.19999431f, -0.05046424f, 0.12391394f, -0.16589986f, -0.17925206f, -0.12403465f, -0.19891128f, 
    0.16591020f, 0.11412916f, 0.28934446f, -0.25484747f, -0.07242891f, 0.26573119f, 0.22305363f, 0.12072463f, 
    -0.06412166f, 0.18684594f, -0.10690426f, 0.30857995f, -0.10335208f, -0.04180713f, 0.24432021f, 0.13435191f, 
    -0.20050864f, -0.53175354f, -0.37775549f, -0.27009654f, 0.17006697f, -0.00973861f, 0.58336169f, 0.16405535f, 
    0.14869858f, -0.38506076f, -0.03885448f, 0.17548786f, -0.05023056f, -0.01677355f, 0.25925466f, 0.06854344f, 
    0.04270537f, -0.32621241f, 0.37151101f, -0.12596066f, 0.05699228f, -0.06955639f, -0.01064863f, 0.15740289f, 
    0.08083319f, 0.27158391f, -0.20626752f, -0.10622045f, 0.08578750f, 0.23818865f, -0.16779943f, -0.08929709f, 
    -0.59081101f, -0.17384981f, -0.07533325f, -0.69707066f, 0.11937816f, -0.35087258f, -0.02229050f, 0.08794205f, 
    0.15012313f, -0.36402670f, 0.12610988f, -0.00316480f, 0.26510832f, 0.06482351f, 0.06566011f, -0.15609887f, 
    -0.23257771f, -0.00490665f, 0.19732065f, -0.00462457f, 0.01549061f, 0.06337902f, -0.02084055f, 0.04979708f, 
    0.07290688f, 0.06946797f, -0.26214954f, 0.10547405f, -0.04229828f, 0.09499710f, -0.04621114f, 0.02741374f, 
    -0.01899447f, 0.08757661f, -0.39588761f, 0.01550793f, 0.04759563f, 0.00868706f, -0.45551333f, -0.19909020f, 
    0.02159875f, 0.37164211f, 0.03297850f, 0.40359750f, 0.24997053f, -0.08660164f, 0.26018322f, 0.03764020f, 
    -0.15413412f, -0.00682906f, 0.04960671f, -0.00397506f, -0.32816929f, 0.03369255f, -0.00485862f, 0.03059824f, 
    -0.16695981f, -0.38421014f, -0.12225152f, 0.12188292f, 0.00342390f, -0.02845532f, 0.36071843f, 0.23639244f, 
    0.09688738f, -0.09183550f, 0.02168338f, 0.19798425f, -0.18772027f, 0.22835441f, -0.14527433f, 0.61146581f, 
    0.22327566f, 0.15428770f, 0.49706447f, -0.13722496f, 0.37386006f, -0.07425814f, 0.27876055f, 0.17868659f, 
    0.11950580f, 0.44029799f, -0.23295631f, -0.11870635f, -0.02806198f, 0.12231191f, -0.02688714f, -0.14917135f, 
    -0.01999903f, -0.05254268f, 0.10338550f, -0.10166082f, 0.21853675f, 0.12320342f, 0.23164478f, 0.08846314f, 
    -0.10369315f, 0.09918796f, -0.15373042f, -0.06304655f, 0.01582554f, 0.05546292f, 0.00581047f, 0.04813186f, 
    0.07710658f, -0.15885265f, 0.00627215f, -0.01120399f, -0.11041057f, 0.12400958f, -0.02708641f, -0.04070726f, 
    -0.08805438f, -0.00095631f, -0.00159807f, 0.17333035f, 0.15919943f, 0.14374253f, 0.01245377f, -0.00874549f, 
    0.01431408f, -0.12454405f, -0.18259558f, 0.05457598f, 0.01463361f, -0.11162448f, -0.12451534f, 0.07383475f, 
    0.01219663f, -0.11525642f, 0.02053645f, -0.07921942f, 0.07725023f, -0.14572062f, -0.11140866f, -0.16269082f, 
    -0.23877230f, -0.08742545f, -0.05620622f, -0.09071197f, -0.05414511f, 0.00578271f, -0.09382328f, -0.00293587f, 
    0.07990654f, -0.03782357f, 0.13169715f, -0.05713849f, -0.05436291f, -0.04825037f, 0.03758824f, -0.00484131f, 
    0.04314357f, 0.05565142f, 0.00210945f, -0.08095394f, -0.09034661f, -0.11600834f, -0.10571005f, -0.06847312f, 
    -0.11811875f, 0.20558038f, 0.24724470f, 0.36335713f, -0.04869070f, 0.32065746f, 0.05758633f, 0.22800724f, 
    -0.16850039f, -0.23419562f, 0.11956026f, -0.12755978f, -0.08522191f, -0.09351406f, 0.19781338f, 0.04900872f, 
    0.01062446f, 0.15432885f, -0.17943226f, -0.35849664f, 0.01190731f, 0.40202907f, 0.03383322f, 0.28820387f, 
    0.16961420f, 0.29992181f, 0.09513775f, 0.04862849f, -0.06675591f, 0.01977195f, -0.29577795f, -0.04628677f, 
    0.04886167f, -0.07035045f, -0.02692717f, 0.10002846f, 0.39497805f, -0.00549901f, -0.04560226f, -0.27942947f, 
    -0.04154556f, 0.13782138f, -0.05138424f, 0.07282779f, -0.05114218f, 0.15281411f, 0.00832896f, -0.03773350f, 
    -0.17021139f, -0.05754216f, 0.22746733f, 0.07034997f, 0.03031844f, -0.01678356f, 0.09974249f, 0.18579338f, 
    0.13138196f, -0.53195649f, 0.19757059f, -0.15415919f, -0.17393169f, 0.10368147f, 0.21102500f, 0.05819476f, 
    0.20922153f, -0.15450159f, 0.27830070f, 0.13438536f, -0.08645389f, -0.43772501f, 0.02708405f, 0.18440671f, 
    0.17700186f, 0.26116750f, 0.07138701f, -0.10920163f, 0.00489694f, 0.00155222f, -0.20549940f, 0.07600029f, 
    0.31701320f, -0.19527975f, -0.31616032f, -0.10462601f, 0.24343184f, -0.57153654f, -0.13953465f, 0.05231521f, 
    -0.03077339f, -0.07758173f, 0.18652627f, -0.09229621f, -0.17217673f, -0.21334571f, -0.34534672f, -0.04317259f, 
    0.20022348f, 0.30186337f, 0.00430354f, 0.20760790f, -0.00088626f, -0.05375215f, 0.20300418f, 0.06586573f, 
    -0.05774871f, 0.26458871f, -0.17635365f, 0.13025367f, -0.23488995f, 0.05136400f, -0.11260951f, 0.20225342f, 
    -0.01890781f, -0.51526618f, 0.08199397f, 0.21334141f, -0.09532192f, 0.07225613f, -0.27735081f, 0.09767846f, 
    0.15758391f, -0.30058432f, 0.05839358f, -0.07106536f, 0.01900780f, -0.08708403f, 0.02344540f, -0.29662001f, 
    -0.09271219f, -0.06914637f, -0.12683448f, 0.03251807f, 0.00789946f, -0.11926587f, 0.09546043f, 0.04217089f, 
    0.02206501f, -0.14388499f, -0.06110597f, -0.09069882f, -0.08035409f, -0.03460492f, 0.06159334f, 0.10608025f, 
    -0.14555721f, -0.03483444f, 0.07011165f, 0.00385732f, -0.12427256f, -0.16999741f, -0.00210488f, -0.07586721f, 
    -0.04123652f, -0.14939702f, 0.00704862f, 0.08548104f, -0.05177694f, -0.01004591f, -0.04143528f, 0.01241580f, 
    -0.15771855f, -0.08689620f, 0.04862584f, 0.00395892f, -0.02269920f, -0.14569552f, 0.05367082f, 0.02076632f, 
    0.05039107f, -0.07664593f, 0.04227402f, 0.06231562f, 0.00341938f, -0.02782552f, -0.15058848f, -0.00025891f, 
    -0.08251990f, -0.01819954f, -0.15229033f, 0.06806701f, -0.00213792f, -0.06062792f, -0.01919517f, -0.11254892f, 
    -0.14212714f, -0.06492094f, 0.04903356f, -0.07498410f, -0.13283592f, 0.01753020f, 0.01936110f, -0.11860815f, 
    0.05401044f, 0.04802720f, -0.07746194f, 0.00389763f, 0.05366676f, -0.02088780f, -0.16348158f, -0.42965364f, 
    0.10451014f, 0.08957285f, -0.09477028f, -0.32885104f, 0.17949601f, -0.07966243f, 0.13626491f, 0.08198258f, 
    -0.21844988f, 0.02074495f, 0.30728385f, -0.02376444f, 0.03643607f, 0.46793202f, -0.08490175f, -0.19062862f, 
    0.35318264f, 0.12902530f, -0.03509451f, -0.05597011f, 0.09498237f, 0.48952639f, 0.27207685f, -0.15128277f, 
    -0.11814367f, -0.17491095f, 0.10624383f, -0.25465354f, 0.20598926f, -0.12932599f, 0.01404521f, 0.08944820f, 
    0.08076680f, -0.11005702f, -0.04243162f, 0.10434580f, -0.17018314f, -0.01430928f, 0.13232441f, 0.11805183f, 
    -0.21733326f, -0.08760803f, 0.11024521f, -0.06400910f, 0.03830129f, -0.06785781f, -0.06859834f, -0.04172157f, 
    0.15944001f, -0.06169832f, -0.13175742f, 0.02933255f, 0.24378967f, -0.05889123f, -0.20622082f, 0.12901159f, 
    0.01646004f, -0.03935178f, -0.09650635f, -0.01659919f, -0.16591647f, -0.00794621f, 0.08555856f, 0.08681053f, 
    0.00413371f, 0.01720308f, -0.12338054f, -0.08147335f, 0.00098909f, 0.04034670f, -0.03607852f, -0.00144990f, 
    -0.07437706f, -0.10988582f, -0.04288935f, 0.00237932f, -0.04514925f, 0.01923390f, -0.05052638f, 0.08161924f, 
    0.04756600f, 0.10991363f, 0.05034226f, 0.11955464f, -0.10618418f, 0.01378399f, 0.10528032f, -0.08475661f, 
    -0.01240837f, -0.14085911f, -0.02691524f, 0.06862572f, -0.12833554f, -0.16973452f, -0.03935222f, -0.07967438f, 
    -0.00962188f, 0.07074691f, -0.11725669f, -0.16092257f, -0.06126938f, 0.02258383f, -0.07991458f, -0.14439100f, 
    -0.10914956f, -0.16120335f, 0.02737497f, -0.17298280f, -0.04614566f, -0.07963470f, 0.11085246f, -0.11441036f, 
    -0.07849511f, -0.10544195f, -0.10147145f, 0.06509237f, 0.03847499f, 0.08721801f, 0.02064376f, -0.00645816f, 
    -0.19695757f, -0.17661658f, -0.19981079f, 0.03120190f, 0.00648521f, -0.11827079f, -0.07106663f, -0.09373654f, 
    0.03137479f, 0.00619053f, 0.07012855f, -0.01064809f, -0.17285934f, 0.10794386f, 0.11853082f, -0.03445580f, 
    0.04330281f, -0.03468001f, 0.04278281f, -0.16935866f, -0.06070315f, 0.05600180f, 0.06779438f, -0.11730579f, 
    -0.15204963f, 0.01832528f, -0.04289674f, 0.09442794f, 0.04111798f, 0.04989076f, -0.03442726f, -0.18622714f, 
    -0.07978952f, -0.10090166f, 0.11875249f, -0.03523498f, 0.12628520f, -0.18039240f, -0.10437606f, -0.08288659f, 
    0.07383928f, -0.09249125f, -0.07063618f, 0.03957613f, -0.11742152f, -0.20763676f, 0.05540272f, -0.02569550f, 
    0.04525916f, -0.07080386f, 0.03413302f, -0.08486255f, 0.02689242f, -0.10821916f, -0.14503548f, -0.11271631f, 
    -0.05724363f, -0.06677803f, -0.04327786f, -0.08233548f, 0.00228059f, 0.03111215f, -0.02160769f, 0.03929183f, 
    0.22250955f, 0.25583521f, 0.29873908f, 0.38950050f, -0.10348047f, -0.20985928f, -0.09956297f, 0.23029794f, 
    -0.10083433f, -0.09561298f, -0.10419475f, -0.31483015f, 0.07404713f, 0.04161811f, 0.04686355f, 0.05160006f, 
    0.16493019f, 0.29928529f, -0.28015646f, -0.28393680f, 0.02026167f, -0.11802005f, -0.11547855f, 0.26449734f, 
    0.04443659f, -0.02817162f, 0.01168942f, -0.11696842f, -0.05973371f, -0.18729174f, -0.40348750f, 0.07730749f, 
    0.19508553f, 0.21323758f, 0.02847183f, 0.47620279f, -0.09087021f, 0.29601100f, 0.12950191f, 0.01623650f, 
    -0.15916428f, 0.21125287f, -0.02370998f, -0.00176609f, 0.03404044f, 0.01953512f, 0.12241308f, -0.02456688f, 
    0.00879067f, -0.15320700f, 0.07260393f, -0.00679272f, 0.08473375f, 0.11268689f, 0.10474841f, 0.20739876f, 
    0.00286348f, 0.19052623f, 0.39123210f, -0.17834374f, -0.28872153f, -0.06169990f, 0.21681453f, -0.14822817f, 
    -0.05132833f, 0.17307311f, 0.13150848f, 0.18072431f, -0.21089800f, 0.13139072f, 0.03155252f, 0.00545343f, 
    0.45255896f, 0.32011014f, 0.07817845f, 0.05091351f, 0.21031819f, 0.01030475f, 0.00030103f, -0.12070668f, 
    -0.02441084f, 0.12008779f, 0.25330988f, 0.21354133f, 0.21847729f, 0.04513663f, 0.07756763f, -0.40188149f, 
    0.25147998f, -0.14584185f, 0.13461119f, 0.12408780f, -0.08655552f, 0.22065337f, 0.01028913f, 0.10063759f, 
    -0.09257738f, 0.05106515f, -0.00956938f, -0.17329349f, -0.18872546f, -0.02324456f, 0.28146479f, 0.31097114f, 
    0.08269281f, -0.05762368f, -0.42083368f, 0.17723578f, -0.29497603f, -0.14202017f, -0.19560854f, -0.07378218f, 
    0.11436159f, 0.02683377f, -0.11150181f, 0.05686608f, -0.16030641f, 0.14406124f, 0.07572089f, -0.02995788f, 
    -0.07887790f, -0.19642839f, 0.03293017f, 0.12882084f, -0.15280889f, -0.08034160f, -0.11989966f, -0.03760802f, 
    -0.01593208f, 0.00148175f, -0.04840519f, 0.02186626f, 0.04178949f, -0.04887927f, 0.03549424f, -0.08829258f, 
    -0.12276040f, -0.15961832f, -0.12187859f, 0.09015118f, -0.16718948f, 0.12237769f, 0.01229455f, 0.01412279f, 
    -0.00086036f, -0.03009901f, -0.07063273f, -0.18816668f, 0.03237218f, -0.05103609f, -0.01410938f, 0.05552611f, 
    -0.00019661f, 0.01849899f, -0.11963609f, -0.06369477f, -0.01848095f, -0.04026874f, -0.10140890f, -0.03558037f, 
    -0.11308684f, 0.03306778f, -0.05853535f, 0.08350777f, -0.05722704f, -0.09985166f, -0.09504456f, -0.10395136f, 
    -0.05618774f, -0.11296944f, -0.13986821f, -0.10124621f, -0.08122495f, -0.09876309f, -0.14933813f, -0.01986303f, 
    -0.02834398f, 0.04142508f, -0.02946887f, -0.14083660f, 0.03074003f, 0.03110952f, -0.06626080f, 0.01725772f, 
    -0.13183649f, -0.14657389f, -0.08375939f, -0.07798603f, -0.01811773f, -0.11219157f, 0.00659799f, 0.03743484f, 
    0.11389031f, 0.28317040f, 0.02770369f, 0.21403678f, 0.13641882f, -0.24657772f, -0.30023390f, -0.10362139f, 
    0.00309378f, -0.16415960f, -0.10067286f, -0.52864695f, 0.08569935f, 0.11021943f, 0.04451418f, -0.01688358f, 
    0.02707600f, 0.33632049f, -0.02853113f, 0.31908256f, 0.08954909f, 0.41319934f, 0.10100538f, -0.26219574f, 
    0.09812382f, 0.06492374f, -0.12902445f, -0.00133449f, 0.11990989f, 0.04567278f, 0.01335984f, 0.04397928f, 
    -0.15406226f, 0.20303197f, 0.01082283f, -0.13608640f, 0.00642248f, -0.05898289f, 0.21652241f, -0.15208468f, 
    -0.23091277f, -0.24645241f, 0.21761218f, 0.18988031f, -0.26538002f, -0.02583118f, -0.17479606f, 0.04062666f, 
    -0.25187337f, 0.11468436f, 0.14760591f, 0.15064831f, -0.16069610f, -0.03641132f, 0.01190883f, 0.11802192f, 
    -0.00147180f, 0.01195707f, 0.18594833f, -0.50226003f, -0.03062558f, -0.07105888f, -0.05399843f, 0.19844459f, 
    0.30115506f, 0.36667827f, 0.09751999f, 0.14831908f, -0.15416117f, -0.18411215f, -0.39811346f, -0.11467671f, 
    -0.08403867f, -0.10508721f, -0.06538580f, 0.25356090f, 0.19750839f, 0.01506917f, -0.01742625f, 0.02143054f, 
    -0.29397684f, 0.56729805f, -0.22771052f, -0.07015590f, -0.18585433f, 0.58623135f, -0.08659092f, -0.11309271f, 
    0.22171596f, -0.00411271f, 0.22572047f, -0.11573691f, -0.16144423f, 0.12488890f, 0.30855349f, -0.22886363f, 
    0.21524620f, 0.10894816f, -0.08334973f, 0.21265912f, 0.08484021f, 0.31274992f, -0.13956341f, -0.05949522f, 
    0.20832320f, 0.12689495f, -0.01968604f, -0.11071412f, 0.00611344f, 0.21284920f, 0.19762449f, 0.18455653f, 
    -0.18818994f, 0.11609159f, 0.00218011f, 0.03724022f, -0.15436567f, 0.11359823f, 0.17834222f, 0.08970845f, 
    -0.16958602f, 0.02843793f, 0.36522341f, -0.25963721f, 0.14104211f, 0.02825081f, 0.12292054f, -0.11555326f, 
    -0.07245789f, 0.26024264f, 0.28803399f, 0.18278046f, -0.42144039f, -0.44183889f, -0.23096281f, 0.20078728f, 
    -0.13556921f, 0.09236998f, 0.04172800f, 0.16305751f, 0.11859425f, -0.04546881f, -0.16611657f, -0.10680767f, 
    0.06622902f, 0.35296237f, 0.00478132f, -0.13841704f, 0.17737038f, 0.20388862f, 0.04055479f, 0.25893983f, 
    -0.01242623f, 0.02840298f, -0.12299842f, 0.03841787f, -0.45687494f, 0.01792601f, 0.39412856f, 0.27108002f, 
    0.31026974f, -0.16220295f, 0.01677127f, 0.39061275f, 0.12497333f, 0.19323385f, -0.15708104f, -0.09468691f, 
    -0.51512474f, 0.46437097f, -0.16243616f, 0.09568562f, 0.10703430f, 0.21388967f, 0.09898345f, -0.05356503f, 
    -0.00735161f, 0.08266736f, -0.13431580f, 0.14337076f, 0.01839457f, -0.32868207f, -0.14864911f, -0.04485431f, 
    -0.19426607f, -0.13416769f, 0.20467077f, 0.21792985f, -0.16797675f, 0.05225547f, 0.04304978f, -0.35008749f, 
    0.21753268f, 0.24933344f, 0.23008904f, 0.15517491f, 0.09289407f, 0.10437137f, -0.03135246f, 0.37029129f, 
    -0.16970508f, -0.15980299f, -0.02441806f, -0.06549223f, 0.15098681f, -0.06697141f, 0.07443538f, -0.04402884f, 
    0.17782719f, 0.03200196f, -0.24704857f, -0.15214539f, -0.04288008f, -0.16400668f, 0.05612154f, 0.25455329f, 
    -0.27589133f, 0.02642046f, -0.07873245f, -0.03481735f, 0.07828537f, -0.29387039f, -0.07196300f, 0.04774244f, 
    0.15038751f, 0.08771171f, -0.08257313f, 0.24568902f, 0.15967639f, 0.25437325f, 0.13072045f, -0.12403607f, 
    0.09210037f, 0.10410337f, -0.15799925f, -0.01260343f, 0.19383639f, 0.29827476f, 0.04717359f, 0.00704095f, 
    0.11599831f, -0.19046116f, -0.02330144f, 0.04940088f, 0.03189575f, -0.04673361f, 0.21363452f, 0.13879433f, 
    -0.09813359f, 0.17526518f, 0.22089271f, -0.06497118f, -0.01751121f, -0.01557760f, 0.13664047f, 0.09689226f, 
    0.17652461f, -0.06023075f, -0.12824565f, -0.05309974f, 0.17564927f, 0.26411387f, -0.25906944f, -0.33537424f, 
    -0.00300411f, 0.08416827f, -0.03667231f, 0.19569235f, 0.25180069f, 0.05397913f, 0.07088985f, 0.05818407f, 
    -0.13355531f, -0.22833958f, 0.15000787f, 0.01033281f, 0.00532955f, -0.36225644f, -0.09993225f, -0.27979812f, 
    -0.02145900f, -0.18376520f, 0.32421681f, 0.11670597f, -0.14603437f, 0.43121016f, 0.16366160f, -0.17749636f, 
    -0.15259010f, 0.10534589f, -0.10573529f, -0.10294076f, 0.23382415f, -0.11002436f, -0.08407890f, 0.31600660f, 
    0.40886506f, 0.03810365f, -0.38338748f, 0.07882060f, -0.02645395f, -0.05765329f, 0.10509335f, 0.24264856f, 
    0.08031036f, -0.14774823f, -0.08452675f, 0.18208444f, 0.04183794f, 0.10365254f, -0.03905082f, 0.12159079f, 
    0.03853037f, -0.08932184f, -0.07685339f, -0.04412900f, 0.31666449f, 0.09372407f, 0.03483061f, -0.04950786f, 
    -0.25018415f, -0.15942098f, 0.20177960f, 0.23529644f, -0.04816991f, 0.31428725f, -0.21963538f, -0.21009822f, 
    0.17772618f, 0.19479570f, 0.11804885f, -0.08158043f, -0.10176997f, 0.10245402f, -0.16761634f, -0.05642064f, 
    -0.10946660f, 0.03375921f, -0.05416985f, -0.03408414f, 0.02407210f, -0.07581431f, 0.03365693f, -0.08873003f, 
    0.30803037f, -0.00342284f, -0.05892297f, 0.09204648f, -0.09086872f, 0.08124307f, -0.05157359f, 0.11024934f, 
    0.02841965f, -0.21328695f, 0.11936219f, 0.00448230f, -0.03488430f, -0.19221228f, 0.19856183f, -0.01249199f, 
    0.17787252f, 0.29055071f, 0.11023653f, -0.17985988f, -0.25883374f, -0.26708794f, -0.14917892f, -0.21342012f, 
    0.35765770f, -0.33656755f, 0.02691078f, 0.10393447f, 0.07692461f, 0.13411561f, 0.21145412f, -0.04922208f, 
    0.08551317f, -0.17567202f, -0.09357867f, 0.30012256f, -0.17767459f, 0.03250730f, -0.00322450f, 0.05272103f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10999211f, -0.09230796f, 0.18186839f, 0.17797150f, 0.04213882f, -0.01136835f, 0.25411934f, 0.12141757f, 
    -0.01014198f, 0.12000983f, 0.03669508f, 0.08018404f, 0.07523258f, -0.03667063f, 0.16920859f, -0.10262588f, 
    0.08850850f, -0.13156655f, 0.11772009f, -0.00835401f, 0.07983056f, 0.00629495f, 0.18809877f, 0.11524615f, 
    0.33130342f, 0.01742524f, 0.22888844f, -0.02700546f, -0.00404785f, 0.17963280f, 0.06907852f, 0.04618570f, 
    0.14220335f, 0.18803608f, -0.12284472f, 0.01492334f, 0.04587281f, -0.06678136f, 0.15583608f, -0.09543068f, 
    -0.16442606f, 0.09927163f, 0.05525693f, -0.17794776f, 0.06441413f, -0.22311759f, -0.03434918f, 0.10717339f, 
    0.02854433f, 0.15100858f, 0.10172004f, -0.13240179f, 0.06002583f, -0.07027165f, -0.14881510f, 0.03664301f, 
    0.04019554f, -0.03638796f, 0.25603908f, 0.18243256f, 0.18098061f, 0.16326958f, -0.10542449f, 0.27304831f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.05093460f, 0.05136209f, 0.07495295f, 0.09287709f, 0.06972146f, -0.32645756f, -0.04927225f, -0.08524274f, 
    -0.29938605f, 0.13887432f, -0.54038286f, 0.05923264f, -0.17642972f, -0.01802495f, 0.04585364f, -0.30631754f, 
    0.07545973f, 0.07675438f, 0.19109370f, 0.11930907f, 0.15140630f, -0.15302934f, 0.04388328f, -0.12076259f, 
    -0.53837585f, 0.11293297f, -0.19466840f, 0.16867884f, -0.01874858f, 0.09825404f, 0.09657814f, 0.11466693f, 
    0.03134883f, -0.25608525f, -0.19731580f, 0.35822195f, -0.11234958f, -0.09730536f, -0.35959208f, -0.09708336f, 
    0.00522219f, -0.03823883f, -0.02389533f, -0.13803793f, -0.31722975f, -0.13658066f, 0.35476232f, 0.06231256f, 
    -0.01537365f, -0.00644181f, -0.31442943f, 0.05118508f, 0.27801365f, -0.02920935f, -0.01197908f, -0.53481257f, 
    0.04769997f, -0.07671721f, 0.09366991f, -0.25807190f, -0.77743661f, -0.49421361f, -0.16621128f, -0.35246077f, 
    0.08168556f, -0.02707661f, 0.09640394f, -0.13850798f, -0.07239159f, 0.23092030f, 0.21126507f, 0.01807938f, 
    -0.84544420f, -0.06431940f, -0.23287682f, -0.19327950f, -0.61460435f, -0.04654386f, -0.06054230f, -0.19184354f, 
    0.01061951f, 0.09484132f, 0.16285908f, 0.21084677f, 0.13430867f, -0.06726063f, 0.02481716f, -0.41629180f, 
    -0.06437196f, 0.17045671f, 0.12534213f, -0.03255970f, 0.08219122f, -0.12568194f, 0.10712818f, 0.11201395f, 
    -0.01449507f, -0.28113165f, 0.00601424f, -0.04950543f, 0.24508063f, -0.01557018f, -0.13093878f, -0.08622041f, 
    0.00534216f, 0.09814683f, -0.07397587f, 0.07014672f, 0.12686542f, -0.07263870f, -0.55111259f, 0.18712217f, 
    -0.14002006f, 0.03749560f, -0.30449682f, -0.01865367f, 0.29509231f, -0.03674938f, -0.12821430f, -0.28667685f, 
    0.17150222f, -0.08828019f, 0.15274796f, 0.11108043f, -0.12101170f, -0.24797188f, 0.16936618f, 0.21290122f, 
    -0.05072359f, 0.06057180f, -0.02252095f, 0.13695592f, 0.08518148f, 0.02606850f, 0.17775191f, 0.21566536f, 
    -0.21593744f, -0.63399041f, -0.12685032f, -0.11362920f, -0.11966968f, -0.11505149f, 0.08948966f, -0.12909451f, 
    -0.14420615f, -0.07939115f, -0.06781654f, -0.02359783f, -0.46808237f, 0.27667540f, 0.06844811f, 0.20772007f, 
    0.03814888f, 0.09154101f, -0.11886650f, 0.07714365f, 0.03407962f, 0.23440312f, -0.36856890f, -0.30424759f, 
    0.46713126f, 0.01857307f, -0.15899029f, 0.09710973f, -0.12640069f, -0.07209583f, 0.11771856f, -0.02680290f, 
    -0.15161952f, -0.00487328f, -0.10206289f, 0.11542308f, -0.29299414f, 0.16140077f, -0.14705208f, -0.17525712f, 
    -0.14001164f, 0.04910731f, -0.36845660f, 0.06022289f, -0.08983862f, -0.08665590f, -0.03185677f, 0.03670016f, 
    -0.18126741f, -0.06973982f, -0.10993221f, 0.18905285f, 0.34983432f, 0.15960586f, -0.48982722f, -0.19160943f, 
    0.03706397f, -0.04821015f, 0.12280890f, 0.17545061f, 0.07640684f, -0.05471049f, -0.39366943f, -0.03235829f, 
    0.10716846f, -0.04980476f, 0.04717518f, 0.14719059f, -0.21584524f, -0.05866816f, -0.69609672f, 0.07444847f, 
    -0.12654501f, 0.03546016f, 0.19262207f, 0.14443173f, -0.01675362f, 0.13660775f, 0.14768842f, 0.16007428f, 
    -0.17982440f, -0.11822118f, -0.12951618f, -0.02715398f, 0.05762027f, 0.12784386f, -0.27913445f, -0.22946611f, 
    0.08220189f, 0.36442813f, 0.03118432f, -0.19935566f, -0.02925271f, 0.11777418f, -0.11167912f, 0.00256664f, 
    -0.01167391f, -0.45516750f, 0.02385521f, -0.09959229f, 0.01577546f, -0.68848550f, 0.00509285f, -0.90372527f, 
    -0.13380171f, 0.23155665f, 0.09681772f, -0.11588325f, -0.09973384f, -0.01404206f, 0.04505948f, 0.22102672f, 
    -0.47027031f, 0.07173584f, -0.12849811f, -0.11117192f, 0.02078885f, 0.07339467f, -0.32101893f, 0.14659157f, 
    0.09399609f, 0.00515031f, 0.14842813f, 0.09349727f, -0.11078978f, -0.17087097f, -0.42271811f, 0.07564790f, 
    0.25853285f, 0.10480267f, -0.11909883f, 0.12509599f, 0.31912205f, -0.05621179f, -0.12394579f, -0.10690086f, 
    0.13714416f, -0.01858620f, 0.16265865f, -0.08324476f, 0.15451236f, -0.62812203f, 0.01367984f, 0.12134521f, 
    -0.20124300f, -0.07125303f, -0.18852714f, -0.13555172f, -0.11309837f, 0.20692636f, 0.17099506f, 0.02819855f, 
    0.16944374f, -0.66596061f, -0.02859779f, -0.42224041f, -0.17319758f, -0.03043071f, 0.08995011f, -0.09367824f, 
    -0.17556681f, -0.18691835f, -0.09158259f, -0.09421080f, -0.15800975f, 0.02374600f, 0.11363083f, -0.11853869f, 
    -0.04260175f, -0.09383519f, 0.13822186f, -0.09749588f, -0.12724358f, -0.09852541f, 0.05404745f, -0.15521309f, 
    -0.03070181f, -0.12553851f, -0.19429606f, -0.56021941f, -0.25656942f, -0.07825495f, 0.26307142f, 0.13546190f, 
    0.12545078f, 0.07659271f, 0.12844856f, 0.08092624f, -0.05661003f, -0.13061969f, -0.07585841f, -0.04165151f, 
    -0.05710519f, -0.05558376f, 0.04933381f, 0.07002646f, -0.09973279f, -0.03528745f, -0.54096425f, -0.00994933f, 
    0.20335875f, -0.08232147f, 0.01226848f, 0.15228540f, 0.03003622f, -0.14711869f, 0.14838241f, -0.35507232f, 
    0.12629268f, 0.04325067f, -0.17361747f, 0.01358472f, 0.01659971f, -0.09804622f, -0.00916535f, -0.00407283f, 
    -0.08036016f, -0.28318372f, -0.08704638f, -0.33404881f, -0.04307042f, 0.08076122f, 0.10513440f, -0.04653722f, 
    -0.00518281f, 0.28698832f, -0.03610641f, 0.04877436f, 0.14134167f, 0.01892865f, -0.15640475f, -0.19049926f, 
    -0.08954583f, 0.05584807f, -0.01294386f, -0.10728942f, 0.11205134f, -0.11531074f, 0.00747891f, 0.07911875f, 
    -0.10360811f, -0.10619304f, 0.20892349f, 0.09531447f, 0.03767874f, 0.12174062f, 0.06435083f, -0.60277545f, 
    -0.65026486f, 0.11464805f, -0.76506788f, -0.38713750f, 0.00988412f, 0.03650983f, 0.12897976f, -0.09914246f, 
    -0.27347299f, -0.41190910f, 0.15678653f, -0.77442473f, 0.12156253f, -0.01116461f, 0.28045109f, 0.24456519f, 
    -0.33308971f, 0.03208920f, -0.70056927f, -0.81156808f, -0.63323838f, 0.17212449f, 0.17280798f, 0.17046985f, 
    -0.00946291f, -0.42969888f, -0.00000426f, -0.51813579f, 0.04094112f, 0.10724925f, -0.12889147f, -0.33859557f, 
    -0.63713068f, 0.24771589f, -0.01696817f, 0.34722137f, -0.43031761f, -0.03272971f, 0.16715147f, -0.05792761f, 
    0.04065758f, -0.26796558f, -0.01961401f, -0.17529079f, -0.16254388f, 0.13790995f, -0.09049167f, 0.23296428f, 
    -0.18992363f, -0.65196729f, -0.33646408f, -0.02270642f, -0.09142653f, -0.08450486f, -0.08141009f, -0.09810383f, 
    -0.13687608f, 0.04757540f, -0.02744574f, 0.25474676f, 0.27425241f, 0.03446563f, -0.10278533f, -0.49193481f, 
    -0.15839647f, -0.00885444f, -0.30253226f, 0.04629543f, -0.02216133f, -0.36265212f, 0.12461866f, 0.01207423f, 
    0.34064990f, 0.40786043f, 0.09706433f, 0.27560800f, -0.13302085f, 0.05732384f, 0.03399107f, -0.06751536f, 
    -0.28556275f, -0.09036390f, 0.17471783f, -0.76845837f, -0.45385918f, 0.00706049f, -0.48589772f, -0.29909202f, 
    0.05502877f, -0.47753045f, 0.04985255f, 0.26122648f, -0.03818014f, -0.60244781f, -0.10967478f, 0.22690192f, 
    -0.19079381f, -0.15723829f, 0.09967688f, 0.05218939f, 0.31209046f, 0.02458355f, -0.31977201f, 0.10575446f, 
    0.05278863f, -0.22237045f, 0.09848935f, -0.13087228f, 0.15834512f, -0.05212310f, -0.13041434f, -0.24395685f, 
    -0.01181350f, -0.55558735f, 0.39381173f, -0.07863824f, 0.17257124f, 0.03765125f, -0.00752665f, -0.38783011f, 
    -0.18364778f, -0.04736837f, -0.30411658f, 0.00798492f, -0.19842179f, -0.12873712f, 0.28851685f, 0.00080249f, 
    0.13770583f, 0.04033379f, -0.50287527f, -0.23890020f, -0.03256437f, -0.13218197f, 0.15348428f, -0.05382349f, 
    -0.30336523f, -0.27735022f, -0.09968592f, 0.07648581f, -0.14390720f, 0.09784071f, 0.13789603f, -0.08594232f, 
    -0.42060900f, -0.05476752f, -0.39479819f, -0.03189959f, -0.65025890f, 0.28591740f, -0.69805318f, -0.10745999f, 
    0.10017227f, 0.18738011f, -0.00554943f, 0.22536695f, -0.09895273f, -0.76509923f, -0.16122581f, 0.02877124f, 
    -0.57840508f, 0.27110925f, 0.01233277f, -0.03358442f, 0.23535757f, 0.02982326f, 0.05531085f, 0.08231328f, 
    0.13049521f, -0.00605447f, 0.03388680f, 0.02886299f, 0.27645048f, -0.06927261f, -0.60375965f, -0.37236682f, 
    -0.11555313f, 0.14104185f, 0.18778260f, -0.08859453f, -0.21838945f, -0.11937323f, -0.03225293f, 0.30511099f, 
    0.23024340f, 0.07348301f, 0.22926152f, 0.11390329f, -0.07953326f, 0.13815069f, -0.34857816f, 0.01452252f, 
    -0.15749739f, -0.11905952f, -0.10297234f, 0.22432791f, -0.03895535f, -0.40124196f, 0.10646906f, -0.05347024f, 
    0.33387333f, 0.12297142f, 0.09940059f, -0.05546573f, 0.13359682f, -0.00682079f, 0.09870592f, 0.11249170f, 
    0.12099972f, 0.03345659f, -0.22961794f, -0.31246442f, 0.08537424f, -0.27403802f, 0.27908552f, 0.36155811f, 
    0.27121428f, -0.42015660f, 0.02680957f, -0.52715766f, -0.05402918f, 0.13190527f, -0.25865546f, -0.07502085f, 
    -0.11731976f, -0.00210588f, 0.03683150f, 0.01142172f, -0.44538918f, 0.10819708f, 0.20736521f, -0.12399839f, 
    -0.10399196f, -0.08035119f, -0.05810934f, -0.14644594f, -0.15632218f, -0.57494849f, -0.63834673f, -0.03782044f, 
    0.08639111f, -0.16952263f, -0.13730700f, -0.09520689f, -0.12169815f, -0.07793548f, -0.11692989f, -0.11927896f, 
    -0.14785402f, -0.12231106f, -0.09348539f, -0.03265852f, -0.12553282f, 0.14946866f, -0.08012985f, -0.24131981f, 
    -0.05021855f, -0.05975447f, -0.02296890f, -0.06523519f, -0.03505906f, 0.20150484f, -0.13484630f, -0.48380277f, 
    0.16853468f, 0.01973341f, -0.05971752f, 0.22852024f, 0.39957091f, -0.01384573f, -0.25963542f, -0.45847693f, 
    0.20154929f, 0.10059483f, -0.37346330f, -0.14438261f, 0.06594027f, -0.04804125f, -0.43226644f, -0.06469173f, 
    -0.11779168f, 0.15183283f, -0.12341275f, 0.06584984f, -0.12371473f, -0.65825939f, 0.22265348f, -0.24411659f, 
    -0.51622534f, 0.09548655f, -0.17504328f, -0.35240576f, -0.17083989f, -0.02313484f, 0.23359041f, -0.06244001f, 
    -0.18604060f, 0.38060746f, 0.03279787f, -0.19516242f, -0.33522040f, -0.37446269f, -0.05986305f, -0.19487026f, 
    0.09654551f, -0.20337093f, 0.29181111f, -0.05933511f, -0.31969988f, -0.00250272f, 0.08434114f, 0.04286174f, 
    0.36402661f, -0.06356894f, 0.22818737f, -0.20805876f, 0.22939023f, -0.10088281f, -0.57766944f, 0.32816222f, 
    -0.11264348f, -0.00746931f, 0.03333362f, -0.44500658f, -0.09464071f, 0.24503289f, -0.31610918f, -0.53405297f, 
    0.02849314f, 0.02901612f, 0.21233886f, -0.13104981f, 0.24033657f, -0.12472456f, 0.01437714f, 0.11267700f, 
    0.07062183f, 0.02072218f, -0.01205180f, -0.20476680f, -0.56659919f, -0.22291070f, 0.11298651f, -0.24103275f, 
    -0.25765049f, 0.14780419f, 0.28400046f, -0.33094844f, 0.07828023f, -0.19976884f, 0.25748792f, -0.39466870f, 
    -0.27300823f, 0.14921369f, -0.03657493f, 0.02321046f, 0.00169134f, -0.01763093f, 0.16671488f, 0.05191184f, 
    -0.05126348f, -0.33002278f, 0.07166608f, 0.02579668f, 0.05249207f, -0.11800092f, -0.09478342f, 0.19234468f, 
    -0.13062586f, -0.30176097f, 0.25252441f, 0.07709860f, -0.17548934f, -0.00669693f, 0.05276494f, 0.10409181f, 
    0.18669426f, -0.11722408f, -0.63572377f, 0.17077275f, -0.27092159f, 0.06257701f, 0.10774948f, -0.21296641f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.12135125f, 0.15482415f, -0.01270773f, 0.06420335f, -0.00734703f, -0.08697716f, -0.10463627f, 0.06976473f, 
    -0.01587123f, 0.14777571f, 0.03071870f, -0.07669320f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
