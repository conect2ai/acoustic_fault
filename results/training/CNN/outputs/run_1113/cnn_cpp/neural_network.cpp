#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.09514908f, -0.27387801f, -0.25214088f, -0.33820859f, -0.66855007f, -0.17880376f, -0.19716190f, -0.31289670f, 
    -0.16693167f, -0.01085673f, -0.12593272f, -0.17903686f, -0.33801642f, -0.23480490f, -0.03737936f, -0.33427584f, 
    -0.37679595f, 0.07133530f, 0.22647101f, -0.30322108f, -0.03108604f, -0.45864323f, -0.14000110f, 0.01226776f, 
    0.25343573f, 0.13569960f, 0.50107849f, 0.24061409f, -0.34992731f, -0.29129463f, 0.09813506f, -0.24344422f, 
    0.07262823f, -0.00723563f, -0.05520928f, 0.08714218f, 0.01531867f, 0.02466065f, -0.00221751f, 0.21703081f, 
    0.03979926f, 0.07095879f, 0.07212678f, 0.11150040f, 0.03278755f, 0.16035931f, 0.34208035f, 0.20302203f, 
    0.28827253f, 0.55668867f, -0.37736705f, -0.26508400f, 0.06879934f, -0.33200580f, -0.56221074f, 0.49449944f, 
    -0.02881780f, -0.48446110f, -0.46402192f, -0.09672426f, 0.01335992f, 0.09759492f, 0.42259941f, 0.38158777f, 
    0.38848743f, 0.12889121f, -0.27598748f, -0.06268656f, 0.13878913f, -0.34145054f, 0.04682732f, 0.01549959f, 
    0.14563654f, 0.06098928f, 0.18002827f, 0.18948273f, -0.48508498f, -0.44121635f, -0.33443618f, 0.49958172f, 
    0.28096601f, 0.25262278f, -0.22238128f, -0.01443893f, -0.15978917f, 0.21340582f, 0.07014401f, 0.44411936f, 
    -0.31124589f, -0.32110661f, 0.26200008f, 0.00057209f, -0.11688307f, -0.04020961f, 0.09355758f, -0.21844772f, 
    -0.03806560f, -0.13060516f, -0.33066365f, -0.48048061f, -0.00495707f, -0.30262411f, -0.45888162f, -0.33139560f, 
    0.09822010f, -0.23895006f, -0.24882472f, 0.19093519f, -0.16085342f, -0.65644622f, 0.60776514f, -0.18665799f, 
    0.20755246f, 0.07370209f, -0.14948855f, -0.18357255f, 0.12515222f, -0.04957509f, -0.19773471f, 0.01843629f, 
    0.11567983f, 0.07508723f, 0.14936329f, 0.03354166f, 0.43735024f, 0.39062259f, -0.44813156f, -0.16458394f, 
    0.31856748f, 0.48396802f, 0.35887730f, -0.45730415f, -0.15722074f, -0.14605387f, 0.23798078f, 0.27646413f, 
    0.14816017f, -0.09715802f, -0.37642583f, 0.33460703f, 0.11651013f, -0.05586402f, 0.25142774f, -0.00910228f, 
    -0.36307642f, -0.15903841f, -0.20260945f, 0.36373919f, 0.06322820f, 0.20713623f, -0.13759202f, -0.21104561f, 
    -0.14543769f, -0.15841419f, 0.24318288f, 0.58466506f, 0.13160482f, -0.18202759f, 0.57354832f, 0.41293168f, 
    -0.16670644f, 0.20378296f, -0.16905220f, 0.19643305f, 0.16608228f, -0.40942165f, 0.06407648f, 0.27945846f, 
    -0.10676680f, 0.13459556f, -0.16027910f, 0.14125079f, 0.15496020f, -0.01026725f, 0.01517697f, -0.16767198f, 
    -0.63352877f, 0.21581009f, 0.05588409f, 0.59342676f, 0.67452729f, -0.04592313f, 0.28638741f, -0.67474657f, 
    -0.20772946f, -0.30696490f, -0.10574984f, 0.34077224f, -0.31672034f, -0.02336959f, -0.31604069f, -0.11664776f, 
    0.06690456f, 0.35475695f, 0.27130875f, 0.22718115f, -0.10012277f, -0.42327988f, 0.38689873f, 0.00317544f, 
    -0.83711416f, -0.69002128f, -0.54858005f, 0.48667747f, 0.78765935f, 0.25673532f, 0.08461789f, -0.21575791f, 
    -0.13311948f, -0.01027331f, -0.21512768f, -0.34377265f, -0.23731774f, 0.01864409f, -0.02598117f, 0.07402501f, 
    -0.05384043f, 0.14106594f, -0.25672123f, 0.28351337f, 0.10155424f, -0.13162629f, 0.04308831f, -0.05962251f, 
    -0.36197755f, -0.19278456f, -0.41928434f, 0.43883061f, 0.91365963f, -0.71525729f, -0.47378388f, -0.34250718f, 
    -0.62827098f, -0.34032637f, -0.18721336f, 0.18937480f, 0.00849010f, 0.30686945f, -0.20180587f, -0.03545872f, 
    0.20216805f, -0.07909972f, 0.22756431f, -0.10460849f, 0.16781692f, 0.14829281f, -0.29072520f, -0.15855137f, 
    0.02872395f, 0.24049090f, -0.42313698f, 0.43056130f, 0.32186976f, 0.39240170f, 0.46094131f, 0.01064515f, 
    0.16941732f, 0.31463557f, 0.13949578f, 0.10017687f, -0.07491068f, 0.02824664f, -0.01821294f, -0.20858313f, 
    0.01595170f, 0.03206387f, -0.20047028f, -0.13243203f, -0.05417055f, 0.01354361f, -0.33313790f, -0.04153334f, 
    -0.07386731f, 0.09624863f, -0.29317477f, -0.51269680f, 0.46125707f, 0.33465925f, 0.30880848f, 0.35037661f, 
    -0.18548591f, -0.22521421f, -0.06323428f, 0.30252221f, 0.37295094f, -0.01903321f, -0.12163803f, 0.01721146f, 
    0.15167817f, 0.13100377f, 0.16661000f, 0.48151538f, -0.16005102f, 0.10613854f, -0.42863071f, 0.02906919f, 
    -0.22388397f, -0.25837231f, 0.05131308f, 0.03583142f, -0.11831604f, -0.30046436f, -0.39686519f, 0.23637307f, 
    -0.39828613f, -0.00854095f, -0.16365217f, 0.35740057f, 0.90787190f, 0.34194604f, 0.13360751f, -0.21455954f, 
    -0.16270022f, 0.18069917f, 0.01827241f, -0.18516073f, -0.22954214f, 0.08500954f, 0.15080565f, -0.01578664f, 
    -0.21535572f, -0.05030221f, 0.11289902f, -0.11431640f, 0.42698246f, 0.61071110f, 0.74878103f, 0.05953378f, 
    0.40909928f, -0.36498535f, -0.57566011f, -0.42613351f, 0.03663048f, 0.09231226f, -0.33110553f, 0.19237353f, 
    0.08264388f, 0.14230664f, -0.19454256f, -0.30387422f, -0.04548060f, 0.36747378f, -0.15970258f, 0.19713712f, 
    -0.13768995f, 0.01104974f, 0.15452635f, -0.16172327f, -0.10168462f, 0.05826540f, 0.13522026f, 0.22958942f, 
    0.42109412f, -0.15652534f, -0.20001075f, -0.09688053f, 0.31226537f, -0.07131125f, -0.06739502f, 0.07386026f, 
    -0.02611255f, 0.17014071f, -0.05891266f, -0.33673659f, 0.10671600f, -0.04688144f, 0.01047906f, -0.39613187f, 
    0.11554350f, -0.35808063f, -0.14567260f, 0.25533393f, 0.38687736f, 0.11569830f, 0.27262911f, 0.45225629f, 
    0.30531564f, 0.78949851f, -0.88828713f, -0.87777281f, 0.27172983f, 0.13260631f, -0.07351168f, -0.13636710f, 
    -0.01439640f, 0.22208342f, -0.22072601f, 0.05949943f, 0.25142813f, -0.01709869f, -0.03363592f, 0.10095973f, 
    -0.06853134f, 0.17825532f, -0.36085066f, -0.02055254f, 0.10966426f, 0.05137735f, 0.14802164f, -0.00503445f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02240991f, -0.00247448f, -0.00613803f, 0.20373490f, -0.10238101f, 0.36694014f, -0.24580000f, 0.04756572f, 
    -0.13353296f, 0.22905590f, 0.01512671f, 0.03431946f, 0.21954817f, 0.07018480f, 0.14225776f, 0.20088196f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15385522f, -0.01063367f, 0.05659592f, -0.14878926f, 0.04027673f, -0.06677470f, 0.18705539f, 0.01936400f, 
    0.06055810f, 0.03386131f, -0.04934819f, 0.06871939f, -0.10990707f, -0.00034400f, -0.10898976f, -0.01339821f, 
    0.08177823f, -0.01671057f, 0.12905522f, 0.14724873f, 0.15185200f, -0.01464545f, -0.00937751f, 0.04471016f, 
    -0.13741945f, 0.03830787f, -0.05495305f, -0.22746764f, -0.07219612f, -0.07680890f, 0.03233671f, 0.10597520f, 
    0.06471073f, -0.04089276f, -0.03300738f, -0.03199010f, -0.08336975f, -0.02303655f, 0.29178295f, -0.19555722f, 
    -0.04225214f, -0.00365657f, -0.07839169f, 0.01633194f, 0.01364606f, 0.00920953f, -0.08644807f, -0.09401073f, 
    -0.02724089f, -0.02179496f, 0.02849505f, -0.11059286f, 0.14286079f, -0.20222715f, -0.09982816f, 0.05193364f, 
    0.08844689f, -0.04178071f, -0.02555110f, 0.05396267f, 0.20233698f, -0.30819935f, 0.20155700f, -0.25279203f, 
    0.11205842f, 0.05764440f, 0.04087567f, 0.01215622f, 0.01916126f, -0.01009794f, -0.02023531f, 0.07843552f, 
    0.13053818f, -0.11186928f, 0.08190496f, -0.13760038f, -0.02101710f, -0.06076949f, -0.02279047f, -0.00526837f, 
    0.07962133f, -0.25419143f, 0.05594075f, 0.12479372f, -0.19419006f, -0.10378984f, -0.06015934f, -0.31157619f, 
    0.08634634f, 0.09499190f, -0.10332022f, 0.11707875f, -0.05113732f, 0.02943532f, 0.08968768f, 0.10217823f, 
    -0.15919824f, -0.09717515f, -0.02944875f, -0.00125342f, 0.01742662f, -0.06262338f, -0.03608870f, 0.10940026f, 
    0.06449977f, -0.06707504f, 0.01538800f, 0.09393667f, 0.07754583f, -0.06235142f, -0.10587569f, 0.09582467f, 
    0.08727864f, -0.00383506f, 0.09269206f, 0.01151228f, 0.03601352f, 0.03286225f, -0.04360411f, -0.00253907f, 
    -0.03584945f, 0.08240665f, 0.14048240f, 0.21005952f, 0.00725181f, -0.03052017f, -0.09890454f, 0.03781690f, 
    0.11664855f, -0.00260667f, 0.03774627f, 0.06711773f, -0.01978067f, 0.10794125f, -0.10847446f, 0.14241202f, 
    -0.05581957f, 0.03700144f, 0.10179718f, 0.06101309f, 0.01131395f, -0.00629621f, 0.08369737f, 0.07967646f, 
    0.21618906f, -0.12374438f, 0.13783166f, 0.12530729f, 0.06786488f, -0.03065331f, -0.09795160f, -0.00732405f, 
    0.04510055f, 0.09655625f, 0.12977225f, 0.06521627f, 0.20212919f, -0.04881969f, -0.66162181f, 0.10279232f, 
    0.12256312f, 0.14548115f, 0.18078779f, 0.02440437f, 0.05076487f, 0.05372995f, 0.02113159f, 0.12691060f, 
    -0.00452608f, 0.10782620f, -0.17523681f, 0.04182977f, -0.12504034f, -0.13902248f, -0.06011501f, 0.13513140f, 
    0.14143388f, 0.01377639f, 0.03257642f, -0.02368966f, -0.10548918f, 0.23451087f, -0.39506701f, -0.25571218f, 
    0.03224759f, -0.09180612f, -0.11994886f, 0.10632510f, 0.08146143f, 0.06834111f, -0.07842968f, -0.08645823f, 
    -0.23078269f, -0.23917842f, -0.07530623f, 0.02161075f, -0.08371623f, 0.01896446f, 0.10565073f, 0.09420338f, 
    0.12191725f, 0.10604177f, 0.08675364f, -0.02124021f, -0.00117063f, -0.12996021f, -0.09912705f, -0.04488828f, 
    -0.01207818f, -0.01585152f, 0.07273531f, -0.03920289f, 0.02527377f, -0.01511445f, 0.01248636f, -0.06947087f, 
    -0.16785346f, -0.20824574f, 0.02473024f, 0.05936309f, 0.00373692f, -0.23879947f, 0.03026414f, -0.09857537f, 
    -0.15238754f, 0.06483718f, 0.10663342f, 0.12293330f, -0.04189064f, 0.16663527f, 0.17658338f, 0.00882259f, 
    0.12177881f, -0.04667379f, -0.01547531f, 0.08444697f, 0.14684899f, 0.07733567f, 0.01743346f, -0.08116464f, 
    -0.21817888f, -0.18224432f, -0.13003623f, -0.05317903f, 0.06184472f, -0.07622444f, -0.17132817f, 0.07336193f, 
    0.05537347f, -0.00418015f, -0.00722100f, 0.06561449f, -0.01477773f, 0.02598770f, 0.04754028f, 0.08686762f, 
    0.19799034f, 0.01174873f, 0.02724841f, 0.13206376f, -0.07786269f, 0.07212476f, -0.08257694f, -0.03738428f, 
    -0.04877094f, 0.04298271f, -0.06549370f, -0.12089060f, -0.00004602f, -0.07907207f, -0.00483693f, -0.02899859f, 
    0.07149231f, 0.06571542f, 0.03140276f, 0.26347661f, -0.29389778f, 0.17329876f, 0.11523067f, 0.04913903f, 
    0.20749682f, 0.05678545f, -0.05410437f, -0.09099190f, -0.06161103f, -0.07561850f, 0.10835008f, 0.06115880f, 
    -0.06904867f, 0.04926087f, -0.22614536f, 0.11064458f, 0.02470328f, 0.08790998f, 0.00194557f, -0.03370322f, 
    -0.02925128f, 0.05212853f, 0.12606946f, -0.05858348f, -0.23097710f, -0.40584069f, -0.06603979f, 0.36408237f, 
    0.10314751f, 0.03957783f, 0.10138435f, -0.07276145f, -0.01872827f, -0.04110483f, 0.05912740f, -0.02140896f, 
    0.15198410f, 0.26696005f, 0.09445092f, 0.00124371f, -0.04328007f, -0.04538876f, -0.00874028f, -0.02387085f, 
    0.04754383f, -0.10691160f, -0.18533596f, 0.06370787f, 0.21470556f, 0.05613070f, -0.22346567f, -0.13845825f, 
    -0.04880298f, -0.05648604f, 0.04237685f, -0.06832093f, 0.04046280f, 0.07089259f, 0.12934840f, -0.14398120f, 
    -0.11809702f, 0.39622059f, -0.02976663f, 0.23833817f, -0.06953391f, -0.04533009f, 0.07243925f, 0.01421147f, 
    0.03598350f, 0.13013655f, -0.01266570f, 0.06636068f, 0.04135348f, -0.07365141f, -0.04613293f, -0.11175774f, 
    -0.08967502f, 0.03036176f, 0.35975376f, -0.01095214f, -0.03961357f, 0.03605656f, -0.01184719f, -0.01014309f, 
    -0.05841180f, -0.03464959f, 0.12145192f, 0.03610619f, -0.04839631f, -0.03250792f, 0.04702556f, 0.11706036f, 
    0.14397550f, 0.14255315f, 0.00652206f, -0.10963402f, 0.31877068f, 0.25406945f, 0.12540890f, 0.02560301f, 
    0.15607262f, -0.01464064f, 0.05561121f, 0.12528671f, 0.06083563f, 0.00517739f, 0.07329489f, 0.19099829f, 
    0.12780517f, 0.20160240f, 0.16196766f, -0.27262905f, 0.17128199f, 0.06664407f, 0.06642997f, -0.08247598f, 
    0.12971842f, -0.09892035f, 0.12962802f, 0.05216639f, -0.03823061f, -0.06298719f, 0.03033352f, -0.06827404f, 
    0.17753044f, -0.00268762f, -0.01100269f, 0.10330713f, -0.04064427f, 0.04167070f, 0.01027702f, 0.08971725f, 
    -0.27952388f, -0.24482778f, 0.06604929f, -0.09304773f, 0.11200367f, 0.06457686f, 0.02640181f, 0.00063617f, 
    -0.02831384f, -0.06430502f, 0.02759589f, -0.09112369f, 0.06219175f, -0.06046238f, -0.07566688f, 0.01037165f, 
    0.02559596f, -0.09322455f, 0.06186795f, 0.14575160f, 0.07652932f, -0.00680363f, -0.06998690f, -0.07755715f, 
    -0.06720557f, 0.07035438f, -0.07708752f, -0.21194497f, 0.03972798f, -0.06966592f, 0.21082965f, -0.08550646f, 
    -0.04687713f, 0.01123817f, -0.07446709f, -0.01059927f, 0.23309574f, -0.03397488f, 0.14146161f, 0.01337643f, 
    -0.08705746f, -0.01988986f, -0.02670734f, 0.01240499f, 0.17748025f, -0.00275741f, 0.07548268f, 0.13324194f, 
    -0.13330548f, -0.03317713f, -0.05372508f, -0.14791849f, -0.06740469f, -0.19159278f, -0.10848429f, -0.02675018f, 
    0.02918903f, -0.03694462f, 0.05586237f, 0.02315620f, 0.36310038f, -0.22613795f, -0.18347895f, 0.02632383f, 
    0.04819344f, -0.01862567f, 0.11771457f, 0.04408179f, 0.19686060f, 0.14383158f, -0.03352035f, 0.18656075f, 
    0.10153998f, -0.01174776f, 0.34529102f, 0.06131645f, 0.07024058f, -0.07885736f, 0.09773213f, -0.04024167f, 
    0.24549648f, -0.00137599f, -0.03410145f, -0.15315980f, 0.03382936f, 0.36693653f, -0.08719824f, -0.39253891f, 
    -0.07683320f, 0.05546577f, -0.01613960f, -0.08436558f, 0.10061412f, -0.06118421f, 0.04775406f, 0.03226843f, 
    0.10414427f, -0.04666267f, 0.00788491f, 0.07215863f, 0.02365459f, -0.16970880f, -0.10342956f, -0.14109582f, 
    -0.15483306f, -0.02710478f, 0.10201690f, 0.03098660f, -0.00508303f, 0.02573679f, 0.02462494f, 0.04190150f, 
    -0.05127767f, -0.15247588f, -0.06023457f, -0.08931198f, 0.00812726f, -0.14924678f, -0.09939591f, 0.03702704f, 
    -0.14313765f, 0.17161144f, 0.03254953f, -0.15885264f, -0.11176321f, 0.02658083f, 0.08675686f, -0.04524793f, 
    0.12372243f, 0.05550000f, 0.19689955f, 0.22711968f, 0.17929824f, 0.02603903f, 0.00830390f, -0.12407016f, 
    0.04782484f, -0.03292988f, -0.07769239f, -0.21224295f, -0.03019419f, -0.18458447f, -0.03327140f, 0.14834221f, 
    0.08373430f, -0.09033618f, 0.00889601f, -0.01447224f, -0.22866927f, -0.03512330f, 0.00733768f, 0.00053211f, 
    0.20542040f, 0.24626473f, 0.03771929f, 0.08232037f, 0.35657531f, -0.31488025f, -0.19667394f, -0.29179066f, 
    0.03531716f, -0.22472410f, -0.04260926f, 0.21716258f, 0.18872024f, 0.05019797f, 0.09045636f, -0.12255469f, 
    0.04820738f, 0.12988608f, 0.07158306f, -0.18590650f, 0.04410857f, 0.24217764f, -0.05578367f, 0.05128027f, 
    0.09619652f, -0.05055491f, -0.05521646f, -0.03801977f, 0.08711556f, -0.13862227f, 0.01698351f, -0.02256990f, 
    0.04176211f, -0.00108644f, 0.03058312f, -0.08456209f, -0.10954311f, -0.08386039f, -0.03390435f, 0.03615592f, 
    0.12938352f, 0.16477038f, 0.19204929f, 0.01742800f, -0.09174699f, -0.19987088f, -0.01571952f, 0.06163102f, 
    -0.03535668f, 0.06849275f, 0.10809755f, 0.05174783f, 0.03807368f, 0.08967330f, 0.01244910f, 0.12201034f, 
    0.03880465f, -0.10750362f, 0.08222362f, 0.08038994f, 0.00782880f, 0.10816200f, 0.07444163f, 0.10072550f, 
    -0.01763706f, 0.16882582f, 0.17622431f, 0.05935561f, -0.10064863f, -0.06704874f, 0.01483080f, -0.00991824f, 
    -0.00539793f, -0.03208081f, 0.07152814f, -0.09375726f, -0.20479150f, 0.14890550f, -0.21958420f, 0.29736084f, 
    0.11470369f, -0.05032331f, -0.08876332f, 0.08835683f, 0.01253840f, 0.05677347f, -0.05343626f, -0.01987757f, 
    -0.13589649f, 0.06237058f, -0.04651286f, 0.15176867f, -0.11450858f, -0.02677908f, -0.00122653f, 0.04570289f, 
    -0.20533146f, 0.10741436f, -0.03582597f, -0.02455246f, 0.02323715f, -0.32610196f, 0.13435073f, 0.26061156f, 
    0.05624576f, 0.01112400f, 0.09615052f, 0.09355775f, 0.18741257f, 0.00824918f, -0.12753735f, -0.02059571f, 
    -0.07360362f, -0.26036170f, 0.31522557f, 0.01989111f, -0.05778072f, 0.07250693f, 0.05572614f, -0.11988837f, 
    -0.01248032f, 0.02547771f, 0.12723808f, -0.00000942f, -0.17730142f, 0.11946375f, -0.00609059f, -0.20033434f, 
    -0.01040984f, 0.13866180f, 0.02985200f, 0.01945842f, 0.03379827f, 0.06740085f, 0.01540405f, 0.02568960f, 
    -0.07962818f, -0.19688311f, -0.05801985f, 0.05058038f, 0.05074918f, -0.03133279f, -0.06673659f, -0.07061709f, 
    -0.07892475f, -0.04324875f, -0.07397112f, -0.03594246f, -0.13826674f, -0.12090144f, -0.06241952f, 0.01085848f, 
    0.14352615f, -0.10348582f, -0.09596152f, 0.00605087f, -0.00598521f, 0.06509304f, -0.16900808f, -0.06255078f, 
    -0.09364942f, 0.51561183f, 0.01856641f, 0.27035987f, -0.18484017f, 0.02065320f, 0.08969112f, 0.03368893f, 
    0.08810805f, 0.05818553f, -0.11267032f, 0.03585374f, -0.03974137f, 0.08937423f, 0.06124544f, -0.05983388f, 
    0.07005239f, 0.10817854f, 0.05961686f, -0.11933774f, -0.19727509f, -0.05422351f, 0.03520846f, -0.04104519f, 
    0.15317191f, -0.18306614f, 0.05275322f, -0.17156844f, 0.15338083f, 0.10113259f, 0.22259593f, -0.00966315f, 
    -0.00699057f, 0.05247937f, -0.08310088f, -0.10901594f, 0.51427037f, -0.12969972f, -0.04624336f, -0.15152599f, 
    0.18947443f, -0.02427755f, 0.03716205f, 0.11660176f, -0.15214126f, -0.04806128f, -0.02503562f, 0.05683088f, 
    0.10070810f, -0.14383812f, -0.31030232f, -0.34421983f, -0.07493773f, -0.29309112f, -0.00987746f, -0.07494826f, 
    -0.06854822f, -0.03327188f, 0.11909171f, 0.14828843f, 0.12959599f, -0.08522096f, 0.10845314f, -0.07019424f, 
    -0.02789121f, 0.05325723f, -0.25298807f, 0.07232028f, -0.06332689f, 0.02347719f, -0.11710048f, -0.07556386f, 
    -0.09174715f, 0.14860001f, -0.35404807f, -0.10701690f, -0.06511782f, -0.04225019f, 0.03673303f, -0.28317422f, 
    0.05860766f, 0.07324547f, -0.09635527f, 0.02047055f, -0.07113478f, 0.01272811f, -0.13388903f, -0.00999772f, 
    -0.14385878f, 0.06820411f, 0.14716081f, 0.02499981f, -0.15831336f, 0.10505294f, 0.24822985f, -0.01659834f, 
    0.07711609f, -0.19359715f, 0.18206739f, -0.28552604f, -0.09441634f, 0.03624114f, -0.11326109f, -0.09058107f, 
    0.22055253f, 0.19850500f, 0.07996716f, 0.00118704f, -0.10520836f, 0.18850105f, -0.18557499f, 0.20192274f, 
    0.03148799f, -0.10539890f, -0.05372727f, 0.05385077f, 0.08466481f, -0.18916485f, -0.07090969f, -0.05666150f, 
    -0.24368498f, -0.14507528f, -0.16580778f, 0.24128954f, 0.01884807f, 0.05984659f, 0.09609445f, 0.04347477f, 
    0.10831077f, 0.03906809f, -0.10210732f, 0.06839481f, 0.23385273f, 0.02471412f, 0.00324447f, 0.13052852f, 
    -0.11678380f, -0.06665614f, 0.22324446f, 0.09999093f, -0.09390789f, -0.17651440f, -0.33315855f, 0.05617461f, 
    -0.17013998f, -0.12761340f, 0.05359757f, -0.01791631f, -0.04674315f, -0.04872119f, 0.15367214f, -0.18575142f, 
    -0.12031641f, -0.05252096f, 0.19655469f, 0.05332309f, 0.00663802f, -0.01274102f, 0.08927026f, -0.02783796f, 
    0.04193369f, -0.09455768f, 0.22619809f, -0.11091346f, 0.04059124f, -0.01119104f, 0.11086542f, -0.03410370f, 
    0.00638590f, 0.04250007f, -0.19013909f, 0.08059050f, 0.13317925f, 0.00914927f, 0.12875313f, 0.10894696f, 
    -0.01041663f, -0.09859464f, -0.01157360f, 0.11266904f, 0.12184932f, -0.01792548f, 0.01971343f, -0.02776532f, 
    0.26166075f, 0.02433882f, 0.03047082f, 0.09158093f, -0.10194495f, 0.10694799f, -0.02611611f, -0.08011705f, 
    -0.11178271f, -0.54764390f, -0.20125586f, 0.21789913f, 0.22199740f, -0.09459112f, 0.09857763f, 0.18350469f, 
    0.10865937f, -0.17852738f, 0.10585731f, 0.16530965f, 0.59226531f, 0.11934576f, 0.36066961f, 0.03284152f, 
    0.00558617f, -0.16641678f, 0.03289526f, 0.16270125f, 0.06791587f, 0.09329977f, 0.08009861f, -0.05372918f, 
    0.07713921f, 0.07232416f, -0.09177323f, 0.12658858f, 0.25749198f, 0.18301067f, -0.10925777f, -0.02147161f, 
    -0.03255735f, 0.03801344f, 0.11033104f, -0.12855689f, 0.00960557f, 0.04463790f, 0.19268571f, 0.09948984f, 
    0.17893693f, 0.13237943f, -0.06981644f, -0.21302964f, -0.13493443f, -0.14384983f, 0.18926223f, -0.10692903f, 
    -0.01423005f, 0.04719228f, 0.00204141f, 0.08499533f, 0.07495155f, 0.12992093f, 0.07353190f, -0.08903189f, 
    0.14618646f, -0.01881809f, 0.01558385f, 0.11479759f, -0.17700581f, -0.09528141f, -0.10349485f, 0.07971696f, 
    0.02103936f, 0.06048488f, -0.21393110f, 0.00856372f, -0.03998908f, 0.09570760f, -0.01313540f, 0.18291873f, 
    -0.39179900f, -0.24378496f, 0.06724660f, -0.12212550f, 0.00664839f, 0.01931153f, -0.13840495f, -0.08228610f, 
    0.00102334f, -0.09302751f, -0.05781016f, -0.01010783f, 0.02576730f, -0.02447594f, -0.04795074f, -0.31847948f, 
    -0.00080888f, 0.00726129f, 0.04121564f, 0.16464975f, -0.03883330f, -0.14435761f, -0.22739294f, -0.11015297f, 
    -0.08468561f, -0.02778177f, -0.04898328f, 0.12809935f, -0.07499619f, 0.14140120f, 0.09449904f, -0.09993982f, 
    0.04222331f, -0.01619651f, -0.05211368f, 0.25023276f, 0.04935822f, 0.29111955f, 0.16679616f, 0.14365880f, 
    0.02717796f, -0.09762004f, 0.06793976f, -0.01277380f, 0.25957775f, -0.07770584f, 0.04410022f, 0.16832048f, 
    -0.24654150f, -0.18733637f, -0.15110984f, 0.01605898f, -0.05153666f, -0.26888743f, -0.12884291f, -0.14325455f, 
    0.04871645f, 0.11510228f, 0.06505007f, 0.09770287f, 0.12627307f, 0.16210911f, 0.03530283f, 0.10437882f, 
    -0.13951379f, 0.01811862f, -0.02323801f, -0.03996276f, 0.09340148f, 0.02077650f, 0.10186653f, 0.00394809f, 
    -0.23003232f, 0.08105700f, 0.04101001f, 0.04001581f, -0.15772562f, -0.05963248f, 0.00209522f, 0.10166645f, 
    -0.02130171f, -0.00738863f, -0.08891076f, -0.09253033f, -0.03268877f, -0.01353926f, 0.14428535f, 0.11511190f, 
    0.01439665f, 0.15257736f, 0.02911997f, -0.03003865f, 0.10724436f, -0.00342231f, 0.00701704f, 0.02860588f, 
    0.37613007f, 0.15606822f, -0.01315973f, -0.02875339f, 0.05307297f, -0.06959563f, -0.02737332f, 0.02226286f, 
    -0.08312239f, -0.06276684f, -0.08003440f, -0.07404463f, -0.01028486f, -0.09678891f, 0.19215082f, -0.17948709f, 
    0.01890946f, -0.10777378f, -0.12643521f, 0.17889050f, -0.04986177f, -0.11658858f, 0.08505171f, 0.04808970f, 
    -0.03953385f, -0.03594288f, -0.23120283f, -0.10532333f, -0.05171078f, 0.08677657f, 0.00509422f, 0.09921917f, 
    0.06894269f, 0.13923341f, -0.04947584f, 0.13011493f, 0.13002655f, -0.02076132f, -0.13315074f, 0.02433097f, 
    0.27915809f, -0.07686231f, -0.12515682f, -0.12881443f, -0.03142197f, -0.12074736f, -0.11025175f, 0.09063665f, 
    0.03319287f, 0.17396797f, -0.00288021f, 0.08249304f, -0.05409706f, -0.13748057f, -0.06038774f, -0.09172111f, 
    0.18274182f, 0.15967315f, 0.16642234f, 0.28395170f, 0.10043909f, 0.05259143f, -0.05699176f, -0.03604130f, 
    0.06552416f, 0.01617296f, 0.06957234f, 0.14835344f, 0.17847434f, -0.05061061f, 0.11497769f, -0.12591474f, 
    0.02700788f, 0.02847536f, 0.00271863f, -0.05406100f, -0.00799459f, -0.06377818f, 0.02917294f, 0.01174090f, 
    -0.05549840f, 0.05813963f, -0.04471746f, -0.06742409f, -0.05125903f, 0.03653192f, -0.00797639f, 0.05199005f, 
    0.04184552f, 0.03444774f, -0.06983471f, -0.04416123f, -0.03307907f, 0.04180296f, -0.03207948f, -0.06914667f, 
    0.02426155f, -0.04017052f, -0.00937628f, 0.05599470f, -0.05494166f, -0.05274586f, -0.00894915f, 0.05511016f, 
    -0.06057750f, -0.03888094f, 0.04255402f, -0.06767198f, -0.04779663f, 0.04787228f, -0.07553208f, 0.04864405f, 
    0.02021347f, 0.01646809f, -0.00015457f, 0.05089660f, 0.04955588f, 0.04590997f, -0.02339458f, 0.02276042f, 
    -0.00376940f, -0.07549705f, 0.02227781f, -0.01662280f, 0.05171031f, -0.04318029f, 0.02646803f, -0.02690594f, 
    0.03108674f, 0.02072735f, 0.05784044f, -0.03111036f, -0.01919881f, 0.03500748f, -0.04955369f, 0.01128822f, 
    0.00038098f, -0.04711179f, -0.06730276f, -0.02427121f, 0.05449369f, 0.02488474f, 0.04262136f, 0.05761141f, 
    0.05072040f, -0.02285452f, -0.03938654f, -0.07688319f, -0.00026662f, -0.07335223f, -0.05566476f, -0.03427533f, 
    -0.07135899f, -0.05714210f, 0.02969335f, -0.04022824f, -0.00943751f, 0.03521580f, -0.06675770f, 0.00921648f, 
    0.02341191f, -0.06599761f, -0.05939496f, 0.03690412f, -0.03878593f, -0.01909050f, 0.05240365f, 0.04642166f, 
    0.01446168f, -0.03820876f, 0.02685690f, 0.02459929f, -0.06643752f, -0.02927161f, 0.01801911f, -0.05845488f, 
    -0.03730769f, -0.07907730f, 0.02307112f, -0.07886514f, -0.00613445f, 0.02697479f, 0.02193640f, -0.08055281f, 
    0.00591548f, 0.03305477f, 0.00081339f, -0.04222932f, 0.01453224f, -0.06301559f, -0.01509995f, -0.01800029f, 
    0.05726021f, -0.01425962f, 0.06168418f, -0.00020013f, 0.00520651f, -0.03219339f, 0.05038751f, -0.07560795f, 
    -0.04561016f, -0.01636457f, -0.00343939f, -0.05122085f, -0.07861076f, -0.06405319f, -0.00349603f, -0.05178738f, 
    0.00038408f, -0.02545512f, -0.00599459f, 0.02195595f, -0.00537338f, 0.01033904f, -0.00579734f, -0.08298104f, 
    -0.03734438f, 0.01382258f, -0.03745580f, 0.03373758f, -0.04176930f, -0.00696550f, 0.02607578f, 0.00689682f, 
    -0.02833467f, 0.04718703f, -0.06579964f, 0.05755552f, 0.02326675f, -0.01506126f, -0.06401169f, -0.01437431f, 
    0.04005058f, 0.06669848f, 0.02167319f, -0.02689498f, 0.00891301f, -0.01440572f, 0.04046528f, -0.04417477f, 
    -0.07504857f, 0.01739399f, -0.01081167f, -0.06867724f, 0.02292358f, -0.04607910f, 0.01799256f, -0.05233397f, 
    -0.07037864f, -0.01498536f, 0.03753917f, 0.00273365f, -0.06780437f, -0.05875652f, -0.01934687f, 0.01092649f, 
    0.04025237f, -0.05660679f, -0.05372179f, -0.01035715f, 0.00400773f, 0.05901306f, -0.06995327f, -0.00513752f, 
    0.00333925f, -0.00629680f, 0.01681501f, 0.02498998f, 0.01120860f, 0.00733215f, -0.00065395f, -0.05990290f, 
    -0.01808102f, 0.00994539f, -0.00203386f, 0.02497160f, 0.01425233f, 0.02501637f, 0.05444603f, 0.00071214f, 
    -0.05586378f, 0.03311130f, -0.04021797f, -0.01235175f, 0.05790121f, 0.01434225f, 0.01467597f, 0.04639962f, 
    -0.04380804f, 0.03228301f, 0.02356656f, 0.04244833f, -0.03190629f, -0.01813502f, -0.07517825f, 0.02469847f, 
    -0.06493111f, 0.02537360f, 0.03654165f, 0.04478521f, 0.02468470f, -0.06850071f, -0.01716697f, 0.04195455f, 
    -0.07249012f, 0.04472502f, 0.06268014f, -0.01467235f, -0.03248473f, -0.03628627f, 0.01379690f, 0.00848597f, 
    -0.00832957f, -0.03104403f, -0.01694123f, 0.04679383f, -0.03780683f, 0.01235911f, -0.00909940f, 0.01888386f, 
    0.00710301f, -0.04756185f, 0.06680874f, -0.02608469f, -0.04706404f, -0.04443607f, -0.06786503f, 0.05956435f, 
    -0.04684943f, -0.05404830f, -0.05506001f, -0.06584625f, 0.01349549f, -0.06368143f, 0.02779399f, -0.03188886f, 
    0.01407848f, -0.02930112f, -0.00303321f, -0.03251445f, -0.02118551f, 0.05229969f, 0.02636204f, 0.03109884f, 
    0.01224110f, 0.00856069f, 0.00142056f, -0.04785948f, 0.01844489f, -0.07299099f, -0.02166243f, 0.06850169f, 
    -0.07397264f, 0.05468079f, -0.04635515f, -0.02820792f, -0.00469229f, 0.00529139f, -0.06972460f, -0.06156605f, 
    -0.01727627f, -0.00695301f, 0.01640420f, 0.03121349f, 0.04196180f, -0.00317161f, 0.03324231f, 0.05841126f, 
    -0.05835188f, -0.07374420f, -0.05120670f, -0.07474910f, -0.01236316f, -0.00812762f, -0.07355504f, -0.04657103f, 
    -0.08404791f, -0.01566569f, -0.01333564f, 0.01515787f, 0.04088949f, -0.02217820f, -0.00083603f, -0.01708753f, 
    0.03582502f, -0.02339989f, -0.00290697f, -0.04400948f, 0.03203621f, 0.01970027f, -0.03046396f, -0.04483441f, 
    -0.07058411f, -0.03014204f, 0.02171470f, 0.05197574f, -0.01647256f, 0.06553341f, -0.04484036f, 0.03383086f, 
    -0.00808297f, 0.01886152f, -0.00008966f, 0.03142589f, -0.04852840f, -0.01550901f, -0.07165851f, -0.05404475f, 
    -0.04492272f, -0.05330311f, -0.04734923f, -0.00311855f, -0.06198305f, -0.05838564f, 0.02749506f, -0.05324529f, 
    0.00950322f, 0.02178992f, -0.00348881f, 0.00592069f, -0.06530344f, 0.05320978f, 0.06383373f, 0.02425607f, 
    0.02544298f, 0.05359245f, 0.04101038f, 0.06020177f, 0.01803369f, 0.05241812f, -0.07066399f, -0.04550764f, 
    0.01807210f, -0.02026964f, -0.01765805f, -0.05523365f, -0.05131723f, 0.00648747f, 0.00908124f, -0.05241250f, 
    0.05567251f, 0.06151156f, -0.01781865f, 0.04953984f, -0.01731999f, 0.03510717f, 0.05717010f, 0.02995138f, 
    -0.07058078f, -0.07050424f, -0.05787221f, -0.02297043f, 0.02463698f, -0.06226743f, 0.04868247f, -0.06303101f, 
    -0.15771627f, -0.19062340f, -0.04712426f, 0.27908531f, -0.06254755f, 0.05444405f, 0.11284094f, 0.00911132f, 
    0.10661343f, 0.03574284f, 0.23592517f, 0.15982617f, -0.02408289f, -0.03274336f, 0.05892788f, 0.03833115f, 
    -0.00554002f, 0.02791917f, -0.06730654f, -0.14813139f, -0.02528336f, 0.07082687f, 0.08888067f, 0.08133640f, 
    -0.05212628f, 0.02540331f, 0.05705286f, 0.32689238f, 0.07396790f, 0.10977190f, 0.09055611f, 0.12226306f, 
    -0.16682126f, 0.04173778f, -0.04643223f, -0.08050125f, -0.09921418f, 0.15373205f, -0.13201982f, -0.01947239f, 
    0.11889138f, 0.07250048f, 0.16153346f, 0.04225048f, -0.01048879f, -0.01978429f, -0.24466468f, -0.12694299f, 
    0.05584710f, -0.07800770f, 0.09233668f, 0.40171063f, -0.04394609f, 0.12633790f, -0.00546422f, 0.03322665f, 
    -0.02030258f, 0.03485974f, 0.01473763f, 0.10508247f, -0.18324773f, 0.24343790f, -0.27576321f, 0.07749383f, 
    0.05848327f, -0.13244563f, -0.05678676f, 0.02239923f, 0.00666690f, 0.16545889f, -0.01315868f, 0.04793637f, 
    -0.17185324f, 0.07722078f, -0.15227516f, -0.04265442f, 0.01540136f, -0.02676120f, 0.03348278f, -0.08386946f, 
    0.01072425f, 0.09697904f, 0.00346885f, 0.12561914f, -0.25081685f, 0.25316966f, 0.25204605f, 0.19690271f, 
    0.14059243f, -0.03962794f, -0.09006637f, -0.13497838f, -0.07075822f, -0.17572749f, 0.01566956f, -0.01458433f, 
    -0.12844616f, 0.21446286f, -0.43022361f, -0.00947246f, 0.10541368f, 0.18468000f, -0.06067533f, -0.00083195f, 
    -0.10529465f, 0.10655098f, -0.02902687f, 0.12992103f, 0.08110018f, -0.20741145f, 0.19531694f, 0.48439047f, 
    0.06060768f, 0.02852135f, 0.03544001f, -0.15421404f, 0.00401447f, 0.06973116f, 0.06141375f, 0.03606727f, 
    0.06197455f, 0.01307348f, -0.01065641f, -0.31785211f, -0.11630948f, -0.07813060f, -0.03543948f, 0.07626546f, 
    -0.00278607f, -0.08608636f, -0.16779876f, 0.03637838f, 0.03554410f, 0.11620478f, -0.06756316f, -0.41455960f, 
    -0.08132521f, -0.04759306f, -0.06536093f, -0.07867075f, -0.01090190f, 0.13807976f, 0.03912236f, 0.04012131f, 
    0.00805571f, 0.09429278f, -0.15159884f, 0.04294167f, 0.13884096f, 0.09669825f, 0.01160113f, 0.11035458f, 
    -0.14339416f, 0.06078419f, -0.02765030f, -0.06062260f, -0.12766127f, 0.01254088f, 0.24278225f, 0.15465055f, 
    -0.13188638f, 0.09546146f, 0.05450884f, -0.03969835f, -0.01924788f, 0.15939264f, -0.00533018f, -0.18340014f, 
    0.06673122f, 0.16059010f, 0.14963034f, 0.07127311f, 0.11078224f, 0.01537276f, -0.11688614f, -0.06441513f, 
    -0.00962850f, 0.17645048f, 0.04494317f, 0.12088977f, -0.26495698f, -0.02573761f, 0.36235821f, 0.53789085f, 
    0.03465260f, 0.02268063f, -0.02761718f, -0.06208295f, 0.05776531f, 0.02921226f, 0.12465765f, 0.11407804f, 
    0.00296385f, 0.01247410f, 0.01826827f, 0.00335183f, 0.10285408f, 0.10386563f, -0.07701173f, -0.07710275f, 
    -0.00172258f, -0.02317289f, -0.06358178f, 0.12273547f, -0.07507333f, 0.10496921f, -0.02520039f, -0.04204072f, 
    -0.08421617f, -0.06665647f, -0.08580761f, 0.01172635f, -0.27557048f, 0.06747738f, 0.06888407f, -0.06535578f, 
    -0.40944046f, -0.35590035f, 0.28178087f, 0.06844780f, 0.18528268f, 0.19985999f, 0.00738363f, -0.03850007f, 
    0.11322709f, 0.05335092f, 0.00768973f, -0.10987561f, 0.02560876f, -0.04103665f, -0.23596548f, -0.13815573f, 
    0.01071418f, 0.03815546f, 0.21643312f, 0.09645393f, 0.05129889f, -0.12238177f, 0.01882764f, -0.03377843f, 
    -0.19944237f, 0.04723151f, -0.09537100f, 0.03638568f, -0.03493068f, 0.14724912f, 0.19622773f, -0.13873121f, 
    -0.14569817f, -0.00055400f, -0.03181338f, 0.07084367f, 0.09732690f, 0.14725912f, 0.18941541f, -0.04390151f, 
    -0.00869177f, 0.05169391f, -0.02370653f, 0.09477206f, 0.01359327f, -0.01402461f, 0.07012712f, 0.06101307f, 
    0.04295877f, -0.05053308f, 0.09046824f, -0.01561385f, -0.09603408f, 0.03746020f, -0.11593315f, 0.05160164f, 
    -0.03008014f, 0.00666878f, 0.02323439f, -0.24146448f, 0.31773835f, 0.10712580f, -0.23152310f, 0.23158652f, 
    -0.14851564f, -0.08448211f, 0.10901213f, -0.01217658f, 0.01752677f, 0.22532400f, 0.04623197f, -0.15171205f, 
    0.33685064f, -0.04764095f, 0.06029657f, -0.16773792f, 0.01030474f, -0.10496761f, 0.07392973f, 0.04434182f, 
    0.08798199f, 0.00027470f, -0.12099955f, -0.05882123f, -0.23214224f, 0.06234694f, 0.10637412f, 0.01200046f, 
    0.01724863f, 0.08688307f, -0.04183638f, -0.07309325f, 0.07808497f, 0.10708775f, 0.00032550f, 0.00063961f, 
    0.30504987f, 0.09381419f, 0.05471553f, -0.16821410f, -0.02884803f, -0.15309663f, 0.00855576f, -0.04446528f, 
    0.00850774f, 0.15507327f, 0.17222086f, -0.02842780f, 0.10593209f, 0.09080438f, 0.20559286f, -0.04406696f, 
    0.00214838f, 0.11122809f, 0.00138842f, 0.06397761f, -0.01820347f, -0.03375484f, -0.09589754f, 0.00767722f, 
    -0.09427242f, 0.03022384f, -0.02037031f, -0.34913346f, -0.00164829f, 0.27582127f, 0.12730081f, 0.00870789f, 
    -0.04672901f, 0.01106423f, 0.00142476f, 0.03829556f, 0.05137859f, 0.01862645f, 0.12223675f, -0.12547496f, 
    0.01765276f, -0.31061378f, -0.30024233f, -0.01047882f, -0.06063019f, -0.04419028f, -0.00340846f, 0.00895773f, 
    0.07737059f, 0.21072976f, 0.21379687f, -0.00020953f, -0.06016253f, -0.10812222f, -0.00293068f, -0.08349185f, 
    -0.07746646f, -0.01645233f, 0.13312317f, 0.08046161f, 0.01429060f, -0.09729499f, 0.23894189f, 0.09341370f, 
    -0.01709949f, 0.11548851f, 0.24771681f, 0.02477498f, 0.04267393f, 0.05587482f, 0.01278021f, -0.07266802f, 
    0.21599373f, 0.20186119f, 0.17077650f, -0.09268419f, 0.15649465f, 0.04515190f, -0.00265368f, -0.02660689f, 
    -0.04192502f, -0.04996566f, -0.04120154f, 0.04984950f, -0.18245341f, 0.02894142f, -0.15204631f, -0.10973219f, 
    0.05840700f, 0.12338945f, 0.11998333f, 0.17552996f, 0.10747773f, -0.01012739f, 0.00408671f, -0.13912146f, 
    0.26140496f, 0.14102569f, -0.14329909f, -0.22608028f, 0.01154377f, -0.01008103f, 0.04570546f, 0.02759074f, 
    0.11161721f, -0.04423609f, 0.00549156f, 0.05109229f, 0.14673196f, -0.16857499f, -0.01985719f, 0.12390514f, 
    0.10077801f, 0.04552042f, -0.02388882f, 0.17380407f, 0.09271815f, 0.12062130f, 0.22106636f, 0.25142685f, 
    0.21627712f, 0.19478759f, 0.02328858f, -0.14404590f, 0.11707402f, 0.12520958f, 0.11013167f, -0.05725143f, 
    -0.04851991f, -0.06509539f, 0.04855087f, -0.06056439f, 0.13119769f, -0.27139363f, 0.24250223f, -0.22900014f, 
    0.00916478f, 0.04698465f, -0.04483902f, -0.14883412f, 0.05032619f, -0.02757799f, -0.03261485f, -0.09978706f, 
    0.29115906f, -0.07009616f, 0.15964755f, -0.14361382f, -0.08817721f, 0.00775616f, -0.02159446f, -0.03261552f, 
    0.12145024f, -0.00739687f, 0.02917996f, -0.10035576f, 0.15645079f, -0.02394038f, -0.24361923f, -0.34375715f, 
    0.07094702f, 0.01360711f, -0.03000130f, 0.13468722f, 0.05384055f, 0.09180204f, 0.01544864f, 0.03334362f, 
    0.11139145f, 0.06423014f, 0.17415485f, -0.06685742f, 0.10853375f, 0.00372599f, 0.14256108f, 0.03179257f, 
    0.16615541f, -0.00341979f, -0.09643710f, 0.00203920f, 0.26137581f, 0.19203083f, -0.09709007f, -0.28823069f, 
    0.13065042f, 0.01405240f, 0.07321506f, 0.15482911f, 0.11652074f, 0.04059446f, 0.01977274f, 0.06194887f, 
    -0.06962977f, -0.05142077f, 0.00538521f, 0.29345000f, 0.14212464f, -0.04199979f, -0.04293434f, -0.07623409f, 
    -0.10751222f, 0.13060193f, 0.18639943f, -0.00634168f, -0.19184010f, -0.13902621f, 0.08517888f, 0.32292768f, 
    -0.12252040f, -0.00804963f, -0.03567633f, -0.03342842f, 0.05333404f, -0.04016098f, 0.05761514f, -0.04132076f, 
    0.18268134f, -0.07294343f, 0.01003354f, -0.19645095f, -0.16680789f, -0.02110770f, -0.01813273f, -0.04080104f, 
    0.04166208f, 0.05730531f, 0.02286132f, -0.05132564f, -0.28082907f, -0.15099286f, -0.23802076f, 0.11546463f, 
    0.02223170f, 0.06841937f, -0.08508588f, 0.10373517f, 0.10259061f, -0.10864158f, -0.03581094f, 0.07609008f, 
    -0.07594708f, -0.18225887f, -0.17776264f, 0.07780083f, 0.16300277f, 0.00204332f, 0.03274708f, 0.04212166f, 
    -0.16049643f, -0.11201613f, -0.11458112f, -0.07063087f, -0.05498777f, -0.14245504f, -0.29813457f, -0.27172077f, 
    -0.04765418f, 0.03132146f, -0.15134497f, -0.00133071f, 0.01763047f, -0.14057223f, 0.02711283f, 0.01989155f, 
    -0.06440398f, -0.04937829f, -0.01634683f, -0.04168800f, -0.06651858f, 0.06867057f, 0.06607440f, -0.01405824f, 
    0.05380614f, 0.01359054f, 0.03532103f, 0.05162580f, 0.05081000f, 0.01848411f, -0.08185417f, -0.06389533f, 
    -0.06258298f, -0.02581193f, -0.05885679f, -0.07725548f, 0.04330982f, 0.03345361f, 0.00400812f, 0.02810144f, 
    -0.05588670f, 0.01179555f, -0.03203962f, -0.00472144f, 0.01648017f, 0.03481804f, -0.00650119f, 0.01967837f, 
    -0.07949626f, 0.01557777f, -0.06967586f, -0.05763169f, -0.00455660f, -0.05145105f, 0.05458111f, -0.02618096f, 
    -0.03788134f, -0.01675489f, -0.03813311f, -0.03051302f, -0.02237629f, 0.00676501f, -0.05277864f, 0.04746063f, 
    -0.05915210f, -0.02009604f, 0.06141095f, 0.06997443f, -0.02221778f, 0.05691519f, 0.01286386f, -0.03619346f, 
    -0.02355928f, -0.06432033f, 0.03170329f, -0.05307912f, -0.01280792f, -0.07632791f, 0.04101146f, 0.05752496f, 
    0.02270891f, -0.07333811f, -0.06474038f, 0.04481067f, 0.05757735f, -0.02835615f, 0.00105434f, -0.00345319f, 
    -0.06347445f, -0.04861699f, -0.02321190f, -0.04901937f, 0.01225652f, -0.03856134f, 0.04454567f, -0.03630364f, 
    -0.06043484f, 0.01856805f, 0.00737314f, 0.03354934f, -0.08337387f, 0.03794190f, 0.00015871f, 0.03211960f, 
    -0.05695912f, 0.00006297f, 0.03451481f, -0.05212733f, 0.02419683f, 0.00496800f, 0.02512128f, -0.01878108f, 
    -0.06295124f, 0.05462915f, 0.00851829f, -0.02333402f, 0.05204013f, -0.04465918f, -0.05302490f, -0.07301605f, 
    0.01063085f, 0.03557643f, 0.00880092f, 0.07518803f, -0.02752685f, -0.01852533f, 0.03711016f, -0.06695619f, 
    0.04453230f, -0.04401329f, -0.02621538f, -0.05646050f, -0.05866036f, -0.01885657f, 0.02728798f, 0.02455697f, 
    -0.03898202f, -0.08003122f, 0.00201640f, 0.06389967f, -0.01772300f, -0.02585601f, -0.04569817f, -0.03549941f, 
    0.03113774f, 0.05518934f, 0.00460339f, -0.03828728f, -0.05613352f, -0.05923445f, -0.01881700f, -0.06934959f, 
    0.04305631f, 0.00953820f, 0.05746598f, 0.04826873f, 0.02280669f, -0.03322319f, 0.03550605f, 0.01732902f, 
    -0.00249396f, 0.02989695f, 0.03493213f, 0.00547738f, -0.02093312f, -0.02131165f, -0.04344660f, -0.01158710f, 
    -0.02583309f, -0.00614659f, -0.01831685f, 0.03635369f, -0.00515937f, -0.04031301f, -0.08334817f, -0.03902459f, 
    0.02306251f, -0.00567043f, -0.07792751f, 0.02711974f, 0.02140717f, -0.01206537f, -0.03384279f, 0.05456502f, 
    0.04723264f, -0.03662334f, -0.01378925f, 0.06453808f, -0.07776064f, -0.05658593f, -0.05583810f, -0.05231478f, 
    -0.01024330f, -0.04105132f, 0.05493213f, -0.03266522f, 0.04065444f, -0.05196541f, 0.01237587f, 0.02054832f, 
    -0.07535128f, 0.04907170f, -0.03613502f, 0.05661004f, 0.03733511f, 0.01828666f, 0.00838324f, 0.01981821f, 
    0.11643427f, -0.13582362f, 0.04909932f, 0.26424274f, 0.04519957f, -0.04329055f, 0.08098008f, 0.06837261f, 
    -0.10709618f, 0.01336371f, 0.08555754f, 0.10038815f, -0.07359756f, 0.07699368f, -0.32188049f, 0.00825153f, 
    -0.05240224f, 0.10538406f, 0.00195549f, 0.03109346f, 0.00013023f, 0.01033359f, 0.00468781f, -0.23632009f, 
    -0.00126510f, -0.00372718f, -0.31546417f, 0.11487304f, 0.10146897f, 0.18704991f, 0.17197901f, 0.03579850f, 
    0.13641523f, 0.11325563f, -0.08882898f, 0.07422542f, -0.00902840f, 0.13318817f, -0.20787250f, -0.03839078f, 
    -0.05429189f, 0.07040061f, 0.00751692f, 0.01337051f, 0.09169157f, -0.00997702f, 0.08910143f, -0.02517643f, 
    0.17198129f, -0.01017582f, -0.10813074f, 0.06494610f, 0.21457919f, 0.26668543f, 0.09829903f, 0.17719322f, 
    0.02119706f, 0.06345318f, -0.00660243f, 0.08562235f, 0.01537766f, -0.13356511f, 0.06682454f, -0.31130990f, 
    0.00991629f, -0.04270080f, 0.04693453f, -0.22683425f, -0.12187297f, 0.01490706f, 0.01700518f, -0.19491497f, 
    0.25164354f, -0.10673551f, 0.08663746f, -0.38229686f, 0.12920368f, 0.08183245f, -0.25132972f, -0.16411270f, 
    0.13757476f, -0.01396150f, 0.09542264f, 0.02742630f, -0.09530535f, 0.45088401f, -0.14624508f, -0.31783140f, 
    0.14383028f, 0.02322700f, -0.03862225f, 0.02694250f, -0.17382255f, 0.03576474f, 0.02099656f, -0.03090590f, 
    0.20736943f, 0.29941443f, -0.31784010f, -0.14346838f, 0.15709189f, 0.12930135f, 0.09237873f, 0.07861665f, 
    0.03949105f, 0.17764613f, -0.05344729f, 0.10088288f, 0.23587826f, -0.08453258f, 0.25753194f, 0.30797842f, 
    0.13301620f, -0.10978005f, 0.04644484f, 0.08721124f, 0.03584405f, 0.04628406f, -0.02466308f, 0.03727186f, 
    0.04867284f, 0.24293844f, 0.17179060f, 0.03116734f, -0.12362081f, 0.02004034f, 0.08493615f, -0.03400502f, 
    0.03861085f, -0.01899578f, 0.01156695f, -0.01359668f, 0.14103964f, 0.15254846f, 0.28008351f, -0.15144889f, 
    -0.42211503f, 0.14142345f, -0.05916630f, -0.22112717f, -0.05961071f, -0.01441719f, 0.08171991f, -0.07703274f, 
    0.19490054f, -0.49652395f, -0.01276180f, -0.17856546f, 0.00070648f, -0.03011567f, -0.22674768f, -0.10125769f, 
    -0.05344127f, 0.11475673f, 0.11133851f, -0.04702064f, -0.05023870f, -0.16426279f, 0.09141774f, 0.17971347f, 
    -0.02546116f, -0.01721929f, -0.09847230f, 0.12884761f, 0.21070531f, 0.02415150f, -0.09315114f, 0.04505297f, 
    -0.04243623f, 0.14197044f, -0.07531027f, 0.17685319f, -0.05811893f, 0.03992445f, -0.23363595f, -0.11165471f, 
    -0.17957491f, -0.13249341f, -0.14103913f, 0.04225006f, -0.34161934f, -0.02270908f, 0.11574782f, 0.39802036f, 
    -0.24702910f, 0.07065189f, -0.18851797f, -0.25163540f, -0.06423197f, 0.04779168f, 0.03075650f, -0.00581605f, 
    -0.02881221f, 0.00764804f, 0.05190495f, -0.06317662f, -0.07496680f, -0.06569625f, 0.08276208f, 0.15806471f, 
    0.01668756f, 0.14284357f, -0.04534415f, 0.04653495f, 0.08556063f, -0.00187420f, -0.05488440f, -0.10231441f, 
    0.07321469f, -0.04188486f, 0.10976157f, -0.04806998f, 0.00596059f, -0.10556257f, -0.17465244f, -0.17979787f, 
    -0.07160098f, 0.15141219f, 0.20559311f, -0.02849920f, -0.05305999f, -0.06325168f, 0.13977917f, 0.00665804f, 
    0.05933066f, -0.06612457f, -0.17067091f, 0.01493398f, -0.05997318f, -0.05523998f, 0.33060625f, 0.00030902f, 
    -0.03221562f, 0.10028180f, -0.09131680f, 0.13400865f, 0.07085217f, 0.09262047f, 0.12319686f, 0.02890639f, 
    -0.19845869f, -0.06594811f, 0.12772885f, 0.00140449f, -0.07972074f, -0.20433404f, -0.22356644f, 0.05980763f, 
    0.06792391f, -0.15101679f, -0.04118125f, -0.15767632f, 0.23160498f, -0.13379556f, -0.11879445f, 0.04998949f, 
    0.04835577f, 0.02873642f, 0.03031189f, 0.17158529f, -0.07463963f, 0.07047168f, 0.00597380f, -0.03591931f, 
    0.01150930f, -0.09858955f, -0.00657243f, 0.05870369f, -0.03312834f, -0.06626315f, -0.07456750f, -0.06374677f, 
    0.04592879f, -0.13212340f, -0.05625496f, -0.00558930f, -0.26006868f, -0.39172742f, 0.21234104f, 0.05509853f, 
    0.12340505f, 0.02402825f, 0.06076640f, 0.04834403f, -0.02611875f, 0.16457964f, -0.12041467f, -0.01713075f, 
    -0.32423699f, -0.44865841f, 0.14130056f, 0.22527583f, -0.11149940f, 0.04141805f, -0.26223409f, 0.01884952f, 
    -0.01995769f, -0.02508504f, 0.27737021f, 0.01604412f, -0.23337156f, -0.05341895f, 0.02535661f, 0.06047221f, 
    -0.07291615f, 0.05768865f, 0.09940203f, 0.03260618f, 0.02968726f, 0.01818008f, -0.03374010f, -0.11638273f, 
    -0.13065290f, 0.00737541f, -0.01753828f, 0.06242928f, 0.02136073f, 0.13252991f, -0.07734950f, -0.05288291f, 
    0.11186062f, 0.08264825f, 0.08544795f, 0.03050602f, -0.04177483f, 0.10823765f, -0.18445033f, 0.14370036f, 
    0.24898247f, 0.05280060f, 0.13578463f, 0.04885659f, 0.19073816f, 0.12878637f, 0.09965149f, 0.07133851f, 
    0.15952267f, 0.22161950f, 0.09462137f, 0.25122321f, -0.00158764f, -0.17916809f, -0.04188792f, -0.01938473f, 
    0.15390752f, -0.03609425f, 0.00661190f, 0.14326978f, 0.40757510f, 0.05241004f, -0.09532038f, -0.07875737f, 
    -0.03535862f, -0.03557350f, 0.23684044f, -0.03743086f, 0.00399013f, 0.08133559f, 0.02005329f, -0.11894706f, 
    0.11705737f, 0.00018533f, -0.04523717f, -0.06514267f, 0.01536433f, 0.06811897f, 0.15658395f, 0.11428048f, 
    -0.01407893f, -0.10851932f, 0.02238441f, -0.29628468f, 0.30598664f, 0.32745260f, -0.07893758f, -0.31567338f, 
    0.14625904f, 0.09777058f, 0.19539130f, -0.01060052f, -0.02615175f, 0.01700464f, 0.09284648f, 0.06098125f, 
    -0.12278732f, 0.00234849f, 0.10574145f, 0.21402469f, -0.03689235f, 0.01440762f, 0.08984207f, 0.19670883f, 
    -0.01073131f, 0.19791843f, 0.09848201f, 0.17145714f, -0.05346043f, 0.22705895f, 0.02891703f, -0.02118694f, 
    0.04425625f, -0.04217048f, 0.14813617f, -0.12407098f, -0.01572749f, -0.27115035f, -0.11297476f, -0.46609873f, 
    0.14042059f, 0.36774728f, 0.06054918f, 0.19771500f, 0.05336988f, -0.08678386f, 0.03654990f, 0.18098617f, 
    0.12555794f, -0.11372992f, -0.24668729f, -0.15814124f, -0.09101373f, -0.26808935f, 0.27787638f, 0.10080119f, 
    -0.14799090f, -0.01912471f, -0.07908922f, 0.05498243f, 0.12718363f, -0.00231892f, 0.14224109f, 0.04829564f, 
    0.01486920f, -0.18065378f, 0.30722836f, 0.08980330f, -0.01598713f, -0.19739757f, -0.14437778f, 0.11362954f, 
    0.00833992f, -0.02973939f, 0.00265444f, -0.11596087f, 0.17976162f, -0.23383029f, -0.07570504f, -0.19405419f, 
    -0.00843648f, 0.07797936f, 0.03164384f, 0.05961823f, -0.12517829f, 0.10681555f, -0.04190264f, -0.11973543f, 
    0.26083589f, -0.10022276f, 0.03580054f, -0.32463107f, -0.12430536f, 0.11467964f, 0.05793953f, -0.18819761f, 
    0.04455270f, -0.25705707f, -0.03131397f, -0.01972886f, -0.27943087f, -0.36848205f, 0.24168758f, -0.20857552f, 
    0.06502751f, -0.00906141f, -0.08163622f, 0.01606635f, -0.10325604f, 0.02473959f, -0.27188355f, -0.11465522f, 
    -0.07767951f, -0.34238470f, 0.17536843f, 0.17293473f, -0.08441930f, 0.08644744f, -0.22458401f, 0.07614887f, 
    0.08560736f, 0.17039578f, 0.11842450f, 0.08076452f, 0.05077916f, 0.08388464f, 0.23813112f, 0.22965875f, 
    -0.00197421f, -0.11044819f, 0.02952474f, 0.06927777f, -0.09983534f, 0.03906221f, -0.02168575f, -0.00614570f, 
    -0.29224896f, -0.09650412f, -0.09947105f, 0.15290648f, -0.08567282f, 0.16489188f, 0.06456598f, -0.04414893f, 
    0.15913233f, 0.18518282f, 0.04616808f, 0.23833163f, 0.01559638f, -0.02774201f, -0.36721411f, 0.18791020f, 
    0.21654433f, 0.05049025f, 0.13670573f, -0.14412108f, 0.08686673f, 0.14886774f, 0.10223947f, 0.11258367f, 
    0.16207036f, 0.08211450f, 0.20173857f, 0.05592212f, -0.06077139f, -0.16252171f, -0.03630159f, -0.01842522f, 
    -0.11753803f, 0.07047763f, -0.01082314f, -0.11778713f, 0.29974338f, 0.26668155f, 0.22431660f, 0.27617192f, 
    0.04404339f, -0.04914717f, 0.17812946f, 0.28579903f, 0.17326885f, -0.00566623f, 0.01227512f, -0.18241443f, 
    -0.09888631f, 0.11983026f, -0.14799079f, 0.12739606f, 0.09310865f, -0.00973982f, 0.09319039f, -0.08671760f, 
    -0.14750862f, -0.29996064f, -0.15764491f, -0.40489453f, -0.46513250f, 0.46624914f, -0.24219938f, -0.09428078f, 
    0.23689203f, 0.15768133f, 0.09749218f, -0.24222033f, -0.12394445f, 0.04165996f, 0.02961553f, -0.09763905f, 
    0.18902200f, 0.18435128f, 0.08933741f, 0.01525274f, 0.05462850f, 0.01853796f, -0.17945506f, 0.02748580f, 
    0.02762268f, -0.04557118f, -0.05684066f, 0.02446789f, 0.14397202f, -0.11511783f, 0.05354126f, -0.03296096f, 
    -0.06866946f, 0.07042023f, 0.19501923f, 0.08345726f, -0.00360985f, -0.05300404f, 0.14050250f, 0.05181716f, 
    0.25178438f, 0.22438177f, -0.03478920f, -0.09992678f, -0.00345111f, 0.00288566f, 0.11136258f, 0.16287056f, 
    0.02221554f, -0.14804944f, -0.09265291f, 0.05892673f, 0.19998169f, -0.13737729f, 0.03191017f, 0.10039582f, 
    -0.03462688f, -0.02767819f, -0.03557222f, -0.14048538f, 0.07510476f, 0.06245844f, 0.10294510f, 0.00669903f, 
    0.22252151f, 0.16244912f, 0.09395534f, 0.13229063f, 0.05132965f, 0.12033077f, 0.08707159f, 0.08852228f, 
    -0.04085507f, -0.06524412f, -0.01879269f, -0.11213461f, -0.02686184f, 0.19093692f, -0.11457042f, -0.08874009f, 
    0.01043031f, 0.07028679f, -0.05927136f, -0.13732521f, -0.11055508f, 0.02722858f, -0.04299771f, -0.03377373f, 
    0.36126992f, 0.32166359f, 0.28848350f, -0.00867897f, -0.14227667f, -0.17241806f, 0.11388961f, -0.06950518f, 
    0.02992085f, 0.15858026f, 0.11254434f, -0.16154128f, 0.24159567f, -0.53037798f, 0.06391927f, 0.07362594f, 
    -0.07053456f, 0.10054097f, 0.10185958f, 0.21951289f, 0.07466439f, -0.01781610f, -0.13556151f, -0.06576987f, 
    0.18044542f, -0.03795424f, 0.24837619f, -0.10275997f, 0.10902963f, 0.07462414f, 0.12056998f, -0.11118647f, 
    0.02653868f, -0.06396421f, 0.09246276f, 0.05896818f, 0.04596169f, 0.21900292f, 0.11882050f, -0.26786739f, 
    0.05701265f, 0.15425311f, -0.01547844f, 0.11100859f, -0.00411231f, -0.10286408f, -0.10960846f, -0.04214673f, 
    -0.06600870f, -0.14880839f, 0.31718802f, 0.29637149f, 0.02417248f, 0.07462355f, 0.04866861f, -0.29029772f, 
    -0.13619705f, 0.06760367f, 0.06339720f, 0.03744392f, -0.24726997f, 0.01524310f, 0.12575591f, 0.37687132f, 
    -0.02194922f, -0.04294886f, -0.14062494f, -0.13059613f, -0.03747132f, -0.09171756f, -0.04050593f, -0.15379243f, 
    -0.01580312f, 0.03432342f, 0.02940484f, -0.19015786f, -0.18793102f, 0.01440721f, -0.12129351f, -0.11297688f, 
    0.05918897f, -0.07541269f, -0.02902253f, -0.04319743f, -0.13139515f, 0.07797880f, 0.05171334f, 0.15655372f, 
    -0.01065641f, 0.13938826f, 0.12269970f, 0.10645007f, -0.08286432f, -0.09541816f, 0.00568944f, -0.10930558f, 
    0.01106275f, -0.24755186f, 0.01630508f, 0.04500658f, 0.07065284f, 0.09059585f, 0.13321570f, 0.03469014f, 
    -0.15885067f, -0.05310633f, 0.03939488f, -0.11077478f, -0.11128772f, -0.35414118f, -0.30251002f, 0.09525378f, 
    -0.14409342f, 0.12603143f, 0.04403853f, -0.05341435f, -0.09642692f, 0.03617692f, -0.04702977f, 0.03375670f, 
    -0.06408043f, -0.16493095f, -0.02822919f, 0.05710152f, -0.01968877f, -0.05941132f, 0.08103769f, 0.06194279f, 
    -0.03770588f, -0.00540079f, 0.04406908f, 0.06381663f, -0.11235192f, -0.10507684f, 0.00686970f, -0.07296360f, 
    -0.02690735f, 0.11817691f, -0.00323666f, 0.09311982f, -0.13793579f, 0.05527188f, -0.15480781f, 0.01851147f, 
    -0.31219462f, 0.16450506f, -0.12357102f, 0.12371761f, 0.09691115f, -0.00863755f, 0.08756812f, -0.13909860f, 
    -0.05751332f, -0.05307253f, -0.16014339f, 0.00820551f, -0.08319432f, 0.14300913f, -0.10214032f, -0.12797414f, 
    -0.02802960f, 0.06807160f, 0.01793775f, -0.12306806f, -0.04463559f, 0.06055058f, 0.05367216f, -0.01507610f, 
    0.00594780f, -0.03548666f, 0.21412835f, 0.15771368f, -0.03437768f, 0.19000234f, -0.16400588f, -0.09945048f, 
    -0.04052687f, 0.00806138f, -0.03190849f, -0.04877038f, -0.06143233f, 0.34821776f, -0.18480015f, 0.16370282f, 
    -0.01125712f, 0.10547508f, 0.04508233f, 0.04800105f, -0.05063188f, 0.00626712f, -0.07740116f, 0.00660397f, 
    -0.17481713f, -0.04168462f, -0.17185497f, 0.08798178f, 0.09074800f, 0.10720662f, 0.05572024f, -0.08050632f, 
    0.06480281f, 0.04621225f, -0.00047707f, 0.03736417f, -0.33904186f, 0.42465883f, 0.11744779f, -0.01002913f, 
    -0.05855319f, 0.11738570f, 0.19464095f, -0.12524463f, -0.11928158f, -0.01621468f, -0.11995997f, -0.00561934f, 
    -0.26326275f, 0.15406804f, -0.11544257f, 0.03868951f, 0.03401662f, 0.03399159f, 0.12747577f, -0.04059951f, 
    -0.13963443f, 0.02096033f, 0.14984421f, 0.10862146f, -0.03357767f, -0.20755814f, 0.39248765f, 0.45265293f, 
    0.12405683f, -0.08256042f, 0.12733288f, -0.09352777f, -0.03479737f, -0.03419407f, 0.02461334f, -0.09715954f, 
    0.11242267f, 0.15997136f, -0.05101754f, -0.14542522f, -0.04168572f, -0.03093737f, -0.09051712f, 0.08821689f, 
    0.08966943f, -0.01515233f, -0.17241535f, -0.01949318f, 0.04023321f, 0.20102184f, 0.17836440f, -0.18065815f, 
    0.09900967f, -0.03024341f, -0.00246104f, 0.08557218f, 0.08262132f, 0.09921049f, 0.18425670f, 0.10063924f, 
    0.09041735f, -0.65337461f, 0.01101299f, 0.27740332f, 0.14116277f, -0.04315531f, 0.04498735f, -0.05416046f, 
    -0.06459368f, -0.02065047f, 0.08314188f, 0.00993471f, 0.48799649f, -0.11459283f, 0.45983720f, -0.01550699f, 
    -0.05299701f, -0.18174088f, 0.02079538f, 0.09774480f, 0.02537060f, 0.00768792f, -0.05220810f, -0.10991047f, 
    0.03688061f, 0.22156285f, -0.30115712f, 0.01025270f, -0.01599487f, 0.02457708f, -0.02816462f, -0.06827305f, 
    -0.08262906f, -0.03018767f, -0.05873148f, -0.05377534f, -0.16677015f, 0.09582806f, 0.32669634f, 0.23459828f, 
    0.03458190f, 0.13593653f, 0.17415796f, -0.06352965f, 0.01058479f, -0.03802875f, 0.14433828f, 0.11950625f, 
    -0.09759016f, 0.04531709f, -0.00019668f, -0.02519519f, 0.00984409f, -0.02073403f, -0.10517103f, 0.06217871f, 
    0.01529652f, 0.03305015f, -0.00143448f, 0.03939454f, 0.02434020f, -0.08173662f, -0.03243623f, -0.02028908f, 
    0.03777463f, -0.05583968f, 0.10882748f, -0.02651125f, 0.00553749f, 0.13722387f, -0.00475540f, 0.08712168f, 
    0.26030758f, 0.28366956f, 0.04365598f, 0.12054736f, -0.08498468f, -0.01724650f, 0.04467981f, 0.26401043f, 
    0.10337782f, -0.03037996f, -0.04762658f, 0.01821044f, -0.03229751f, -0.16026504f, 0.20037392f, 0.03702148f, 
    -0.00720476f, -0.02886959f, -0.01598188f, 0.04859784f, 0.04778103f, 0.01293281f, 0.03146818f, 0.09513103f, 
    0.06490693f, 0.06821620f, 0.17865893f, 0.14341368f, -0.03391285f, 0.00332026f, 0.07798745f, 0.17327224f, 
    0.09837847f, -0.04019806f, 0.12028641f, -0.09494436f, -0.08189163f, -0.02423332f, -0.18164004f, -0.02656217f, 
    0.07398584f, -0.00723103f, -0.03158918f, 0.14885505f, 0.08860707f, 0.05036385f, 0.01985579f, 0.07925300f, 
    -0.04702423f, -0.05201428f, -0.05251843f, -0.05992128f, -0.04155341f, -0.08999339f, 0.05443126f, -0.03825324f, 
    -0.01818839f, 0.03680348f, 0.06958619f, -0.08970794f, -0.06395802f, -0.50427854f, 0.09305002f, 0.09898093f, 
    0.14047284f, 0.00920891f, 0.01105816f, 0.01958770f, 0.12505905f, -0.06340028f, -0.19079125f, -0.08434869f, 
    -0.12663935f, -0.24294940f, 0.13065581f, 0.14933726f, 0.02445120f, 0.08126633f, -0.16683562f, -0.01569042f, 
    -0.17532778f, -0.13553225f, -0.06125018f, 0.13265091f, -0.06680252f, 0.12820941f, -0.03332608f, -0.09201688f, 
    0.03031448f, 0.21376519f, -0.00911618f, 0.17484798f, 0.06557758f, 0.00998943f, 0.02051205f, 0.03497389f, 
    -0.24712291f, -0.33073026f, -0.07743390f, -0.04890647f, -0.06248643f, 0.05407418f, -0.03258352f, -0.07165031f, 
    0.05159986f, 0.09757509f, -0.10807823f, 0.13563479f, -0.27921346f, -0.28363720f, -0.39627168f, -0.04348444f, 
    -0.02913030f, -0.09854110f, -0.12605487f, 0.01765302f, 0.16275756f, 0.05158003f, 0.01297890f, 0.07755686f, 
    0.11019209f, 0.54462385f, 0.00546819f, -0.00470302f, -0.10795028f, -0.05460971f, -0.08406633f, 0.12845457f, 
    0.10732459f, 0.01586027f, -0.01719921f, 0.02529357f, -0.27602744f, 0.12500860f, -0.07478640f, 0.14412807f, 
    -0.11103437f, 0.11173347f, 0.18705513f, -0.04692685f, 0.07890576f, -0.01027276f, -0.03354173f, -0.11667823f, 
    0.09797763f, -0.17273565f, -0.00340064f, -0.11482944f, 0.22275753f, 0.06579878f, 0.04350776f, 0.03290020f, 
    0.02868268f, 0.12205783f, 0.01266863f, -0.02582512f, -0.12167432f, 0.07561224f, -0.16612342f, 0.01340626f, 
    0.05333487f, 0.05125361f, 0.11302485f, 0.00797370f, -0.07780699f, 0.15343173f, 0.05525089f, 0.03904213f, 
    -0.04868792f, -0.03064750f, 0.03086281f, -0.00813736f, 0.02214176f, 0.02261207f, -0.02915954f, -0.04331612f, 
    0.02183974f, -0.04459467f, 0.08738851f, -0.05566800f, -0.04463533f, 0.04638519f, -0.02110217f, -0.08836123f, 
    0.02762755f, -0.01482076f, 0.01003741f, 0.01022024f, -0.07666511f, -0.04555627f, 0.03775468f, 0.04213681f, 
    -0.04794665f, -0.01811607f, 0.03342348f, -0.01754985f, -0.05447966f, 0.05292010f, 0.00527604f, -0.05242489f, 
    0.05106379f, -0.00610726f, -0.05611924f, -0.02689204f, 0.03295078f, -0.05258387f, -0.02100720f, 0.03129514f, 
    -0.05378762f, -0.03213877f, -0.05121666f, -0.05695717f, -0.05547218f, -0.00027642f, -0.05134458f, 0.03955480f, 
    0.05174116f, -0.00769143f, -0.04497584f, -0.00731415f, -0.03517162f, 0.03144001f, 0.03108441f, 0.04297154f, 
    0.00073561f, 0.04788677f, 0.05656106f, 0.04928609f, -0.07895569f, -0.08931540f, -0.08227827f, -0.05335442f, 
    0.03331404f, -0.04524829f, -0.08648757f, -0.02410561f, -0.07848940f, 0.03923906f, -0.06378113f, -0.06124653f, 
    -0.04057669f, 0.01041612f, 0.00811218f, -0.04903418f, 0.02462366f, 0.03213000f, -0.06964137f, 0.01677813f, 
    -0.05055479f, -0.01202741f, -0.06689519f, 0.01906215f, -0.08421507f, -0.01453350f, -0.07523137f, -0.08088850f, 
    -0.01825831f, -0.04954229f, 0.00821674f, 0.02588098f, -0.06841018f, -0.09140893f, -0.06649923f, 0.04492734f, 
    -0.07610556f, -0.03471128f, -0.01694348f, -0.00691519f, -0.04534969f, -0.05190628f, -0.05984602f, 0.04556767f, 
    -0.06110893f, 0.01605286f, 0.06534667f, 0.06842715f, -0.01491953f, 0.01832601f, 0.03182757f, -0.06100759f, 
    -0.06216055f, 0.00102245f, -0.08552963f, -0.02217942f, 0.05762828f, 0.04118036f, 0.04305285f, 0.06053218f, 
    -0.03869807f, -0.07294986f, -0.02714357f, 0.06500048f, -0.02281650f, 0.02860961f, -0.06385044f, 0.06319732f, 
    0.02859443f, -0.02991967f, 0.01544557f, -0.09610365f, 0.02973389f, -0.03307372f, 0.01788650f, 0.05577795f, 
    -0.04468240f, -0.04117713f, -0.03792631f, 0.00358483f, -0.02781576f, -0.09412637f, 0.01803574f, -0.07214530f, 
    0.01375486f, -0.00440025f, 0.02871033f, 0.07169338f, -0.08666427f, -0.03872607f, 0.03725857f, 0.03082322f, 
    -0.05634315f, -0.01583077f, -0.05983580f, 0.04185184f, -0.01236767f, -0.05897219f, 0.01275062f, 0.01729580f, 
    0.02342548f, -0.04786391f, 0.02487085f, -0.08264830f, -0.00231826f, 0.04191460f, 0.03940174f, -0.01376906f, 
    -0.01357929f, -0.01728534f, -0.02999151f, -0.04700776f, 0.03541971f, -0.02801295f, 0.01395962f, -0.04954099f, 
    -0.06518984f, -0.01813590f, -0.01828561f, -0.03010630f, 0.00429208f, -0.03331885f, -0.09647487f, -0.08214968f, 
    0.01297758f, -0.08901324f, -0.02020635f, 0.03007445f, 0.03491596f, -0.00417543f, 0.00595927f, 0.02727627f, 
    0.19275331f, 0.16396689f, 0.07911297f, -0.20992540f, 0.03007862f, -0.12408046f, 0.00009417f, 0.04904709f, 
    0.10243683f, 0.05937624f, 0.06796552f, 0.04911334f, 0.03262402f, 0.13534351f, 0.05888967f, -0.07789104f, 
    0.20258807f, 0.09948687f, 0.13551793f, 0.15256457f, -0.11624917f, 0.11642067f, 0.01499667f, -0.02013607f, 
    -0.22557656f, 0.07943824f, 0.15533277f, -0.20953204f, -0.11606135f, 0.17448707f, 0.14666419f, -0.07701644f, 
    0.10325793f, -0.12351913f, 0.04064441f, -0.00626405f, 0.09394835f, -0.18539605f, 0.00242378f, -0.15559268f, 
    -0.16674732f, 0.04791966f, 0.00574886f, 0.06912213f, -0.15577972f, -0.08397384f, -0.10362586f, 0.02769706f, 
    0.05715426f, 0.18751533f, 0.15292720f, 0.00843986f, -0.03144379f, -0.04961545f, 0.25340596f, -0.07417049f, 
    -0.05579321f, 0.01943664f, -0.09601790f, 0.08934299f, 0.26858455f, 0.01229806f, 0.09442475f, -0.06549750f, 
    -0.16859894f, -0.02012354f, -0.02877581f, -0.00619440f, 0.10231713f, -0.07056009f, -0.05011902f, 0.12942864f, 
    0.10575658f, -0.04355024f, -0.07993902f, 0.06439994f, -0.00099566f, -0.03678573f, 0.01841184f, -0.03165726f, 
    0.13922149f, -0.05621332f, -0.05701527f, -0.20070092f, 0.35771438f, -0.22184055f, -0.32778448f, -0.22839026f, 
    -0.07635748f, 0.03068328f, 0.21444476f, 0.08794010f, 0.21121849f, 0.04035497f, -0.05702060f, -0.07411695f, 
    -0.05609522f, -0.03047808f, 0.42719701f, -0.07377255f, -0.09773047f, -0.17744373f, 0.14371136f, 0.05540366f, 
    0.13586803f, -0.08543373f, 0.04047408f, -0.04176967f, 0.05970005f, 0.47557464f, -0.00887625f, -0.24265692f, 
    -0.13325801f, -0.22783315f, 0.06994841f, 0.03167148f, 0.06906256f, -0.08718172f, 0.05339846f, -0.04248255f, 
    0.06933159f, -0.09004515f, -0.01581288f, 0.11497555f, 0.03346295f, -0.00488432f, -0.06013997f, -0.03585435f, 
    -0.05925025f, 0.06813308f, -0.11760271f, -0.05579663f, 0.03294216f, 0.06325865f, 0.12343615f, 0.13680655f, 
    0.25489545f, 0.03313933f, -0.05311131f, -0.07474992f, 0.03016915f, -0.19335642f, 0.06223716f, 0.04193834f, 
    0.13742083f, -0.55293763f, 0.14498751f, -0.10516337f, 0.12423806f, 0.07469691f, -0.02858070f, -0.22722535f, 
    0.05681434f, -0.09823854f, -0.01299287f, 0.03082654f, 0.14008865f, 0.21846506f, 0.14665844f, 0.11937159f, 
    0.10608362f, -0.05344840f, -0.27352381f, 0.13222772f, 0.02656307f, -0.07228187f, 0.07122003f, 0.04987439f, 
    -0.12472296f, 0.17547356f, -0.06851520f, 0.00398952f, -0.07142174f, 0.20803623f, 0.03791250f, -0.02634112f, 
    0.05093540f, 0.10590543f, -0.03124353f, 0.00789791f, -0.42728096f, -0.00824193f, 0.07541206f, -0.24072753f, 
    -0.14308245f, 0.07212338f, 0.21937715f, 0.18718122f, -0.05958948f, 0.02980042f, 0.02204374f, 0.00922590f, 
    0.10197875f, -0.07700694f, -0.01431604f, 0.09765399f, 0.10887400f, -0.06179591f, 0.14724329f, -0.05708095f, 
    -0.06701814f, -0.15450932f, 0.08227057f, -0.06259762f, -0.01713532f, 0.03736200f, -0.08332840f, -0.01057885f, 
    0.06925140f, -0.04265703f, -0.12144323f, 0.05421580f, 0.02502682f, 0.10480203f, 0.12108297f, 0.03577281f, 
    0.10769102f, -0.16528955f, -0.04121608f, 0.11428476f, 0.11614282f, 0.28077802f, 0.02451428f, 0.04826921f, 
    -0.19732752f, 0.05074480f, -0.00175824f, 0.03183589f, 0.06669628f, 0.14361516f, -0.19054632f, 0.08000872f, 
    -0.01253662f, 0.05246989f, 0.11517651f, -0.08874043f, -0.07223645f, 0.05350250f, -0.20010804f, 0.02437190f, 
    0.19788584f, 0.20108458f, -0.06337803f, 0.03986902f, 0.08013412f, 0.14786872f, 0.18516995f, 0.02733451f, 
    -0.11319060f, 0.12311719f, -0.02411616f, 0.09652700f, -0.02226801f, -0.12248100f, 0.13258469f, -0.30060062f, 
    -0.15980825f, -0.12673549f, 0.06359550f, -0.07650213f, 0.16157126f, 0.07044194f, 0.09496369f, 0.00607112f, 
    -0.00928978f, 0.06609880f, -0.04604521f, -0.15160668f, 0.12269698f, 0.09923696f, -0.10629985f, 0.00971320f, 
    0.04361379f, 0.08544210f, 0.03215769f, 0.09345619f, 0.08263647f, 0.42462674f, -0.25098756f, -0.06327552f, 
    -0.03670467f, -0.13219056f, 0.07428398f, -0.11959202f, 0.02175363f, -0.13874780f, 0.08303946f, 0.08371407f, 
    0.21871555f, 0.47963896f, -0.16428840f, -0.10421684f, 0.12893397f, -0.00705382f, 0.19636500f, 0.04115121f, 
    0.14897722f, 0.01875219f, -0.17988835f, 0.14903173f, 0.16171978f, 0.12152791f, -0.07337420f, 0.17515650f, 
    0.09293488f, -0.09525444f, 0.02123713f, -0.02447212f, 0.02798497f, 0.05673444f, 0.02730278f, 0.10807267f, 
    0.07600733f, 0.14921632f, 0.06216586f, -0.22516266f, -0.03940736f, -0.03572666f, -0.03744799f, 0.05111056f, 
    -0.05274469f, 0.14966515f, 0.05523091f, -0.11748735f, 0.12730063f, 0.17370515f, 0.15535128f, -0.24934795f, 
    -0.06186925f, 0.01422772f, 0.07925822f, -0.16865166f, -0.06159787f, -0.08466629f, 0.03861241f, -0.02182685f, 
    0.14745545f, -0.26026639f, -0.01526972f, -0.08800033f, 0.23819894f, 0.11168556f, -0.05409870f, -0.22927386f, 
    -0.03355818f, 0.12396292f, 0.06121622f, -0.05335716f, -0.52516228f, 0.02835659f, 0.00252107f, -0.02532447f, 
    0.06510165f, 0.06293168f, -0.21194401f, -0.01029674f, -0.01247416f, 0.18501897f, -0.12515981f, -0.01685136f, 
    -0.20275043f, 0.09707066f, 0.12390655f, -0.03940513f, -0.15758109f, 0.02618049f, -0.25802112f, -0.08755842f, 
    0.01644421f, 0.15268272f, 0.03159470f, 0.24720961f, -0.44028714f, -0.16056292f, 0.26708815f, 0.44617715f, 
    -0.25697505f, -0.01059124f, -0.13948324f, 0.12836066f, 0.13378938f, 0.07485047f, 0.00409681f, 0.06481612f, 
    -0.02884734f, 0.06125359f, 0.01295683f, -0.01125454f, -0.00617136f, -0.01254340f, -0.00547834f, -0.05829693f, 
    0.00242748f, -0.03103550f, -0.01557180f, -0.02343099f, -0.03672046f, -0.01382620f, 0.00808744f, 0.03283992f, 
    0.03801682f, 0.00064991f, -0.02885045f, 0.04600336f, -0.02260396f, -0.03248223f, -0.06986398f, 0.03140413f, 
    -0.04989870f, -0.07390748f, 0.02754904f, -0.03939516f, -0.06979277f, 0.06115690f, -0.06138899f, 0.04249641f, 
    -0.05349920f, -0.00511067f, 0.04852492f, -0.02545583f, 0.05161475f, -0.07869817f, -0.04904536f, -0.04680391f, 
    -0.03730716f, -0.05158248f, 0.00422640f, 0.03051372f, -0.07545500f, -0.06980436f, 0.02630227f, 0.03581902f, 
    0.02876083f, -0.04625563f, 0.06073603f, 0.00758442f, -0.03324188f, -0.05527178f, -0.00058783f, -0.07517805f, 
    0.05827641f, 0.06248199f, 0.00564386f, 0.01563739f, -0.01661160f, -0.05674167f, -0.01875379f, 0.00143176f, 
    0.04299310f, -0.05828527f, -0.03873900f, 0.04483321f, -0.04688223f, 0.05501770f, -0.02827473f, -0.07452057f, 
    0.02591196f, -0.04038304f, 0.00454089f, 0.01474955f, 0.02545480f, -0.06830136f, -0.03446205f, 0.02160139f, 
    0.00112071f, -0.03169743f, -0.01718767f, 0.04928019f, 0.01573005f, 0.05109717f, -0.04966037f, -0.06100062f, 
    0.06231016f, 0.04968178f, -0.04459688f, -0.02584391f, -0.02113193f, 0.02205225f, -0.02877378f, -0.05564876f, 
    0.03746857f, -0.00937862f, -0.01458650f, -0.06412222f, 0.05110158f, -0.06678805f, 0.02639116f, -0.01680705f, 
    -0.05595763f, 0.04632648f, 0.04865506f, -0.06103417f, -0.02257481f, 0.02801393f, -0.02068217f, -0.01890584f, 
    -0.05327236f, 0.02087042f, -0.06174568f, -0.04332921f, -0.03842429f, -0.01772570f, -0.01713386f, -0.01384532f, 
    0.01615521f, 0.04069730f, -0.06302508f, 0.02863079f, -0.02193415f, 0.00579384f, -0.03500459f, -0.05088357f, 
    0.06221625f, 0.01286771f, 0.04457705f, -0.05933708f, -0.06293873f, 0.00213756f, 0.04347689f, 0.00909304f, 
    0.01824835f, -0.01057460f, -0.00224856f, 0.02464460f, 0.01741363f, 0.03417414f, -0.01936341f, 0.02890413f, 
    0.01396249f, 0.02112499f, 0.03606183f, -0.02704074f, 0.01534607f, -0.01303370f, -0.05971330f, 0.05434030f, 
    0.06151709f, -0.02296567f, -0.08282238f, -0.06114861f, -0.05266133f, 0.01961141f, -0.03034590f, 0.07120180f, 
    0.03487227f, -0.03769350f, -0.05919598f, 0.01859094f, -0.03007378f, -0.05229485f, -0.00279844f, 0.00863769f, 
    -0.01768834f, 0.03513127f, 0.02013090f, -0.06900667f, 0.03063898f, 0.04135516f, 0.01812275f, -0.04402234f, 
    -0.03287883f, 0.00624523f, 0.05595094f, -0.06192420f, 0.00354004f, 0.05543965f, -0.00452374f, -0.01443711f, 
    -0.08191708f, 0.00415774f, -0.04186124f, -0.06270973f, 0.02964882f, -0.03746425f, -0.04531959f, 0.04951886f, 
    -0.09350947f, 0.12892379f, 0.23316474f, 0.04976182f, 0.13943952f, 0.24967991f, -0.06283195f, -0.02737734f, 
    -0.03562044f, -0.01715326f, 0.02530099f, -0.11002312f, 0.12973104f, 0.01688638f, -0.00555212f, -0.03266260f, 
    -0.04920683f, -0.04371820f, 0.01698494f, -0.08520464f, 0.04957499f, 0.03124664f, 0.10783459f, 0.03664443f, 
    0.28100142f, 0.10346062f, 0.10264657f, 0.21388128f, 0.07013524f, 0.03523105f, -0.01449494f, -0.00082241f, 
    -0.11701968f, -0.07291809f, 0.13912106f, -0.02322408f, 0.16302466f, -0.07015402f, -0.04293467f, 0.10438512f, 
    0.05240697f, -0.05514296f, 0.07430466f, -0.06187561f, -0.05694555f, -0.03073091f, 0.02029441f, 0.09113143f, 
    0.08109584f, 0.29039562f, 0.12868135f, 0.31616476f, -0.05025094f, 0.14599682f, 0.17834164f, 0.06949397f, 
    -0.01300988f, -0.07135059f, 0.08125873f, -0.01920516f, -0.19742845f, 0.15127733f, -0.14475654f, 0.07764897f, 
    0.00104293f, 0.10435269f, -0.03642650f, 0.05675298f, -0.05577773f, 0.15871081f, 0.01479428f, 0.07766607f, 
    -0.05838373f, -0.00613210f, 0.00272698f, 0.05635709f, 0.05856996f, -0.06838591f, -0.00701696f, -0.02781933f, 
    -0.07317451f, 0.15181443f, 0.04846647f, -0.21365255f, 0.08307850f, -0.15714630f, 0.13936478f, 0.02173124f, 
    0.01021242f, -0.05811216f, -0.04390037f, 0.08389568f, 0.07264120f, 0.02704761f, -0.05099173f, 0.04635924f, 
    0.09827418f, 0.10756651f, 0.37354240f, 0.06303480f, 0.09862003f, 0.06582010f, 0.05985867f, -0.03854935f, 
    -0.00437214f, -0.14106178f, -0.06236156f, -0.04231931f, 0.13846722f, 0.27480736f, 0.23135409f, -0.13248618f, 
    0.10103270f, 0.16722256f, -0.15534100f, 0.10368144f, 0.06464077f, 0.02472353f, 0.06575906f, 0.08585544f, 
    -0.13078126f, -0.29955795f, -0.06501643f, -0.11281585f, 0.01127554f, 0.00071384f, -0.00022783f, -0.05073011f, 
    -0.07938956f, -0.00219460f, -0.05862325f, 0.02475244f, -0.30779418f, -0.19319797f, -0.07683878f, 0.09426955f, 
    -0.02580001f, -0.04635009f, -0.06157365f, -0.03247576f, 0.03108619f, -0.19618337f, -0.11412060f, -0.02951671f, 
    -0.19750635f, 0.29675984f, -0.04037741f, -0.07631035f, -0.03093529f, 0.04334694f, -0.03986196f, -0.04448080f, 
    0.05987044f, -0.04928692f, -0.04232800f, -0.00568387f, -0.41471481f, 0.04893662f, 0.16820090f, 0.14509402f, 
    -0.06677752f, 0.15473272f, -0.10561676f, -0.07271033f, -0.04359850f, -0.07426997f, -0.00082435f, -0.07812030f, 
    0.05626798f, -0.21757945f, 0.00077196f, -0.11143790f, 0.03352286f, 0.11338151f, 0.08990433f, -0.10213580f, 
    0.04823484f, -0.01550238f, -0.00746001f, 0.07148459f, -0.14011957f, -0.16189198f, -0.04619710f, 0.10720482f, 
    0.01779661f, -0.12725496f, 0.10856265f, -0.10457018f, 0.02135866f, 0.17378508f, -0.00679989f, 0.03372777f, 
    0.09510668f, 0.18486930f, 0.14813186f, 0.12459093f, 0.01877007f, 0.12929088f, 0.04804576f, 0.08465524f, 
    -0.10026649f, -0.08697254f, 0.08267404f, -0.04157947f, 0.04941582f, -0.02185315f, 0.03111391f, 0.00811154f, 
    0.02953747f, -0.02963981f, 0.14564969f, 0.09748865f, 0.05786281f, 0.04551065f, -0.03334107f, -0.04417981f, 
    0.39445528f, 0.42112753f, 0.17545551f, 0.18730398f, 0.21914601f, 0.11887211f, 0.08399169f, 0.07425880f, 
    0.10281196f, -0.10231107f, 0.01112150f, -0.01726202f, 0.19731721f, -0.06121665f, 0.11023696f, 0.07195361f, 
    -0.01542631f, -0.09002931f, -0.04440137f, -0.03715623f, 0.06627875f, -0.00724289f, 0.05661764f, 0.33392307f, 
    0.24047820f, 0.27142873f, 0.23840256f, 0.16905849f, 0.03806046f, 0.09972741f, 0.05510855f, 0.06071145f, 
    0.02727928f, -0.02861351f, 0.08925039f, 0.01079350f, -0.14515927f, -0.06843527f, -0.24129783f, -0.10490647f, 
    0.02052356f, 0.02649156f, 0.05901720f, -0.06016057f, 0.09002917f, 0.08231833f, 0.07689297f, 0.04495016f, 
    -0.06116081f, -0.06146324f, 0.05887982f, -0.01579458f, 0.03474112f, 0.08756324f, 0.07008383f, 0.09461996f, 
    0.01457791f, -0.01152414f, 0.04549720f, -0.16217974f, 0.07089753f, -0.14691347f, 0.03073696f, -0.02213242f, 
    0.01139109f, 0.15443450f, 0.12475983f, 0.14849101f, 0.00292824f, 0.04219862f, -0.13867991f, -0.08278643f, 
    -0.00606964f, 0.01084518f, 0.41035369f, 0.01955613f, -0.06516214f, 0.04964992f, 0.01316634f, 0.04300868f, 
    -0.12878937f, 0.01875836f, -0.07044996f, 0.07917215f, 0.08542186f, 0.37419409f, 0.20424056f, -0.13278976f, 
    0.13880821f, -0.04941326f, 0.08080488f, 0.00939102f, -0.07716865f, -0.00712162f, -0.02046717f, 0.03145487f, 
    -0.49267873f, -0.31498775f, -0.11721639f, 0.10007982f, 0.05887941f, 0.00667334f, 0.03045096f, 0.00073813f, 
    -0.13134728f, 0.00701073f, -0.06412586f, 0.02175047f, -0.34768060f, -0.16150892f, 0.03920386f, 0.14535643f, 
    -0.08512259f, -0.03023403f, -0.10828166f, -0.07609025f, 0.04280592f, -0.07661173f, -0.10440426f, 0.11818016f, 
    -0.05204731f, -0.05064676f, 0.08688641f, -0.14596562f, -0.07703904f, 0.12071145f, -0.08789276f, 0.06221591f, 
    -0.03439016f, 0.03646977f, -0.02602011f, -0.06718028f, -0.12040555f, -0.14971295f, -0.01267339f, -0.01599091f, 
    0.00057542f, 0.13495728f, 0.00517093f, 0.17687842f, 0.11520626f, -0.00370058f, 0.10830645f, 0.05801202f, 
    0.06742761f, -0.14327469f, -0.21507968f, -0.03653825f, 0.16126968f, 0.06582469f, 0.17696899f, -0.07310638f, 
    -0.01674405f, -0.16582239f, -0.13240395f, -0.02828767f, -0.13633277f, -0.27239564f, -0.19082677f, -0.00307225f, 
    0.09203850f, -0.05897202f, -0.09626698f, -0.06517672f, 0.03413374f, 0.12313210f, 0.06460494f, 0.01152033f, 
    0.20045698f, 0.16702864f, 0.04979423f, -0.05024111f, 0.09264566f, 0.14079134f, -0.07796691f, 0.11630540f, 
    0.07426760f, -0.11787592f, 0.00435492f, 0.03140436f, -0.11043955f, -0.03181112f, -0.04460497f, 0.06558089f, 
    0.13184270f, 0.03037827f, -0.03637992f, -0.01733280f, -0.08466543f, 0.10508931f, 0.11851365f, 0.16219720f, 
    0.22140773f, -0.06994686f, 0.29739541f, -0.01758477f, -0.01410402f, 0.14000127f, 0.01571791f, 0.13571815f, 
    -0.05014527f, -0.00974563f, 0.08923572f, 0.06887403f, 0.28177533f, 0.02061719f, -0.10697734f, 0.05818514f, 
    0.16040683f, -0.02552066f, 0.16175473f, 0.00255514f, -0.02327776f, -0.03015348f, -0.05661547f, -0.08947203f, 
    0.09122926f, 0.18301764f, -0.09925763f, 0.05862080f, -0.01218266f, 0.13652168f, 0.23734736f, -0.03259916f, 
    0.04282679f, -0.06498595f, 0.04063184f, 0.11260658f, -0.10647952f, -0.02419411f, -0.07997774f, 0.02580579f, 
    -0.08152438f, 0.04843162f, -0.13320401f, 0.00651132f, 0.28668293f, -0.04995156f, 0.16632853f, 0.19965294f, 
    -0.25808421f, -0.13165966f, -0.06184603f, 0.06100241f, -0.07586245f, -0.03721546f, -0.04488702f, 0.00572364f, 
    -0.01065667f, 0.12726557f, 0.05736560f, -0.12198757f, 0.19837002f, -0.24613395f, -0.07246906f, 0.16884468f, 
    -0.16366363f, -0.12139775f, -0.05474423f, 0.09157438f, 0.31414193f, 0.20616212f, 0.18979460f, 0.11820477f, 
    0.13131277f, 0.17950167f, 0.22616608f, -0.07895375f, -0.05100513f, -0.09049790f, 0.09196272f, 0.13989136f, 
    0.16802031f, -0.10929642f, -0.09095118f, -0.07600013f, 0.06185247f, 0.22210890f, -0.13263080f, -0.26165050f, 
    0.02187767f, 0.30792919f, -0.01512441f, 0.00417920f, 0.11898985f, 0.07209466f, 0.08512840f, 0.14009552f, 
    -0.08184895f, -0.15789858f, -0.01087849f, -0.07527435f, -0.02936157f, -0.10932288f, -0.00795605f, 0.06542534f, 
    -0.21775782f, -0.04055883f, 0.02628934f, -0.10229025f, -0.21479908f, -0.11960438f, 0.02289177f, -0.05920892f, 
    -0.03655092f, -0.15169388f, 0.01438798f, 0.11892170f, 0.01394659f, -0.17343910f, -0.20182692f, -0.10717244f, 
    -0.25834852f, 0.25801712f, -0.21659920f, -0.02258142f, -0.09632809f, 0.12867133f, -0.03174198f, -0.05297816f, 
    0.12753607f, 0.04805417f, -0.12222781f, 0.11386359f, -0.35068664f, 0.03341816f, -0.18632391f, -0.15762058f, 
    0.19077432f, 0.11587276f, -0.12249015f, -0.22613208f, -0.18250787f, -0.12883522f, 0.06928066f, 0.06651524f, 
    -0.10615944f, -0.14961419f, 0.18884888f, 0.03074076f, -0.05243998f, -0.06072387f, 0.10748195f, -0.02415106f, 
    0.22017592f, 0.17025660f, 0.20707121f, 0.25852183f, 0.16813496f, -0.27545440f, -0.21608658f, -0.19261600f, 
    -0.00567362f, -0.07772440f, 0.02953888f, 0.05651619f, 0.04836216f, -0.01476151f, -0.07856771f, -0.05211683f, 
    -0.14382091f, -0.14634015f, -0.03115807f, 0.05178719f, -0.08169836f, 0.08509938f, 0.07258126f, 0.08626549f, 
    0.17390302f, 0.16814207f, -0.13045245f, 0.02257536f, 0.01881768f, -0.03562102f, -0.03723312f, -0.00568475f, 
    -0.13218646f, 0.06689919f, 0.13069707f, -0.12960438f, -0.04415244f, -0.09030932f, -0.13499698f, -0.00351316f, 
    -0.05022353f, 0.18576071f, 0.11254274f, 0.02951873f, -0.08584343f, -0.15485890f, -0.05383509f, 0.15044715f, 
    -0.01706896f, 0.00853756f, -0.19383582f, -0.03726980f, -0.13765040f, -0.10308516f, 0.21559525f, -0.15190172f, 
    -0.02676249f, 0.03904877f, -0.01660051f, 0.11968143f, 0.14086768f, 0.03645515f, -0.07073925f, 0.01918934f, 
    -0.04785154f, -0.21532145f, 0.16778916f, 0.19607750f, -0.14081034f, -0.11514173f, -0.28288996f, -0.00591479f, 
    0.10716580f, -0.05009040f, -0.01850827f, -0.00908282f, 0.01998581f, 0.05228220f, -0.21658500f, 0.17251745f, 
    0.12306480f, -0.01172800f, 0.16493478f, 0.20762567f, -0.03967661f, -0.00222894f, 0.00706802f, 0.06800254f, 
    0.00473802f, -0.03813919f, 0.04130170f, 0.01416936f, -0.13955259f, -0.11469950f, 0.09022875f, -0.15028293f, 
    -0.01558887f, -0.06607393f, 0.10943882f, 0.17653225f, -0.43555939f, -0.39778519f, 0.35075745f, 0.14544015f, 
    0.05853958f, 0.16219321f, -0.15845808f, -0.05029087f, 0.05382163f, -0.04456237f, -0.07738933f, -0.14159591f, 
    -0.29642603f, -0.23366834f, -0.04367371f, 0.10405654f, 0.04659944f, 0.11959316f, -0.22384414f, -0.05403455f, 
    -0.13998838f, 0.11961218f, 0.12073319f, 0.09417139f, -0.06353746f, -0.29231289f, 0.21693352f, 0.30848125f, 
    0.05048158f, 0.12104113f, 0.03299651f, 0.14080185f, -0.12294294f, 0.01195541f, 0.03345952f, -0.04176863f, 
    -0.30023283f, -0.15773657f, 0.00120097f, -0.11857741f, -0.01596820f, 0.14782420f, -0.08256236f, -0.04877324f, 
    0.19593440f, 0.09241010f, 0.00099263f, 0.04404554f, -0.09716199f, 0.00048446f, -0.39484420f, -0.11620883f, 
    0.11913705f, 0.06306319f, 0.05715542f, -0.05853250f, 0.08891857f, 0.15257381f, 0.05943091f, 0.12830748f, 
    0.30815464f, 0.40817270f, 0.14796039f, 0.30306044f, -0.13969001f, -0.17658560f, -0.00268278f, 0.03150862f, 
    0.03804278f, 0.07309487f, 0.00258484f, 0.01478739f, 0.23122551f, 0.06883849f, -0.10026486f, 0.09125202f, 
    0.10339839f, 0.20850581f, 0.42893744f, -0.07651436f, -0.09768842f, 0.13408545f, 0.08982199f, -0.17523696f, 
    -0.05567716f, 0.05233505f, -0.05719500f, -0.03922661f, 0.11090306f, -0.08424030f, 0.11455595f, 0.00355774f, 
    0.05883589f, -0.06787953f, 0.03575668f, 0.03872516f, 0.13518649f, 0.37497306f, -0.07815007f, -0.11964756f, 
    0.03161880f, 0.10846024f, 0.26738593f, 0.04994513f, -0.09016882f, 0.11740609f, -0.09178451f, 0.14914106f, 
    -0.04105806f, -0.04235797f, -0.01700480f, -0.02866825f, 0.03132538f, -0.01488563f, -0.05932364f, 0.01079965f, 
    0.00651264f, -0.01395524f, 0.04704801f, -0.08120780f, -0.02030917f, -0.06758783f, -0.01664589f, -0.02263837f, 
    -0.05877971f, -0.06992118f, -0.03989083f, 0.03787595f, 0.05655456f, -0.08369104f, -0.00520372f, 0.00882742f, 
    0.00396323f, 0.06409278f, -0.01940018f, -0.05374059f, -0.08189477f, -0.01580339f, -0.04598710f, 0.04033610f, 
    -0.09426994f, -0.05644768f, -0.06085814f, 0.06400922f, 0.04221750f, -0.01769201f, -0.06837343f, -0.07267531f, 
    -0.05626678f, 0.00121013f, -0.04311385f, 0.03570551f, 0.05489175f, 0.01710711f, -0.01271202f, -0.01570638f, 
    0.00939686f, 0.01728312f, 0.01463732f, -0.09558758f, -0.01140071f, 0.02856087f, -0.04426021f, 0.00553956f, 
    0.03441130f, -0.02639697f, -0.07054838f, -0.03659721f, -0.02128040f, -0.06868849f, -0.07155054f, -0.05132278f, 
    -0.10856862f, 0.04037781f, 0.02086052f, 0.01446710f, 0.02578891f, 0.01904399f, 0.02086094f, 0.00575276f, 
    -0.04434707f, 0.02732563f, 0.05011586f, 0.03504702f, -0.02905112f, -0.03766076f, -0.02159459f, 0.06713577f, 
    -0.01425152f, -0.04946289f, -0.01169727f, -0.01570112f, 0.04985863f, -0.07033042f, -0.04030835f, 0.01786411f, 
    0.03935745f, 0.04358893f, 0.00023733f, -0.01634031f, -0.03116930f, 0.03805882f, -0.04416000f, 0.02366973f, 
    -0.08613972f, 0.00946377f, 0.02084236f, -0.09484679f, -0.01433573f, 0.01792969f, 0.04133574f, -0.04535395f, 
    0.04901957f, 0.01352445f, 0.01496429f, -0.00813369f, -0.08462784f, -0.04238267f, 0.03778083f, -0.02355387f, 
    -0.09159651f, -0.09337203f, -0.03211835f, -0.04634384f, 0.06001525f, 0.03260498f, -0.01757033f, 0.04904138f, 
    -0.01826202f, 0.01312003f, -0.07878926f, -0.08271567f, -0.00347618f, -0.04955555f, 0.05408922f, 0.01277700f, 
    -0.06454541f, -0.04154443f, -0.02614178f, -0.05927440f, -0.00406237f, 0.04849389f, -0.02248822f, -0.02247022f, 
    0.05880632f, 0.00385212f, -0.03611664f, -0.01374426f, -0.09417242f, 0.01435258f, -0.05897783f, -0.01824641f, 
    -0.01310095f, 0.04352797f, -0.03990411f, 0.02371826f, -0.07509286f, -0.05141655f, -0.02145760f, 0.00336833f, 
    0.02298635f, -0.07600153f, 0.02371579f, 0.01234846f, -0.04107251f, -0.04858337f, -0.00523810f, -0.03766027f, 
    0.01605218f, -0.07901302f, -0.04456981f, 0.03938027f, -0.03232646f, -0.00721407f, -0.04318272f, 0.05128086f, 
    0.00925313f, 0.04177362f, 0.00810581f, 0.01282659f, 0.01987010f, 0.01826409f, -0.01346064f, 0.00223947f, 
    0.04474885f, 0.04070350f, -0.01039364f, 0.03387082f, 0.01031452f, -0.03943166f, -0.05764931f, -0.01983810f, 
    0.00884131f, 0.01831603f, -0.09284005f, 0.05578849f, 0.01891498f, -0.04498592f, -0.04270637f, 0.01219657f, 
    -0.40350109f, -0.07012736f, -0.09352526f, -0.02712551f, -0.10229847f, 0.16980863f, -0.00991492f, 0.05154013f, 
    0.02140322f, -0.01652438f, -0.12245600f, 0.01752032f, -0.01841676f, 0.02526038f, -0.12531409f, -0.03843546f, 
    0.10033036f, -0.02599424f, 0.03252551f, -0.11413801f, 0.11139003f, -0.09611919f, 0.07342853f, -0.03551219f, 
    -0.05396469f, -0.37499887f, 0.02150750f, -0.09128837f, 0.42044073f, -0.10598999f, -0.12526904f, -0.03210507f, 
    0.04124542f, 0.02643394f, 0.05793387f, -0.00645854f, -0.09596661f, 0.05674211f, -0.02184215f, 0.04958247f, 
    0.17726366f, 0.07873079f, 0.05573614f, 0.00774326f, 0.29912701f, -0.03669310f, 0.06024824f, 0.08072492f, 
    -0.60871363f, -0.10126159f, -0.33508423f, -0.33954403f, 0.07188281f, 0.14392103f, -0.02154946f, -0.10447351f, 
    0.04139100f, -0.08141249f, 0.09418664f, -0.08152000f, 0.09616711f, -0.07175468f, 0.22006319f, -0.01747410f, 
    0.16224931f, -0.06941710f, -0.03593083f, -0.02712566f, 0.02541933f, 0.15509859f, 0.02217576f, 0.03937080f, 
    0.18878439f, -0.01339513f, 0.13273846f, -0.08938844f, -0.03879953f, -0.06617406f, -0.07174806f, 0.09355576f, 
    -0.04265002f, -0.04752748f, 0.14751102f, 0.02212345f, -0.09479640f, 0.17126001f, -0.06144423f, 0.23150231f, 
    0.08715979f, -0.06123628f, -0.10849119f, 0.04854258f, 0.05959738f, 0.16367221f, 0.17680486f, -0.05157741f, 
    -0.05420457f, -0.64939094f, -0.13127077f, -0.11019204f, -0.00215326f, -0.05215900f, -0.11960406f, 0.11595903f, 
    0.05241614f, 0.03538496f, -0.04270769f, -0.08037677f, -0.54275990f, -0.23866805f, -0.08171530f, -0.07811674f, 
    0.13694020f, 0.35446355f, -0.19545034f, -0.08380440f, -0.09562047f, 0.01339672f, -0.03777862f, 0.07098022f, 
    0.18541715f, 0.02741403f, 0.15651317f, 0.11479551f, -0.05629453f, -0.15176149f, -0.05513828f, 0.05588913f, 
    0.09438845f, 0.04268135f, 0.18170112f, -0.13033447f, 0.05085030f, -0.04829230f, 0.06959170f, 0.15395750f, 
    -0.16346596f, 0.03790258f, -0.04542583f, 0.07963932f, 0.04182676f, 0.10419606f, -0.12956357f, 0.02561614f, 
    -0.14558394f, 0.64389676f, 0.02109750f, -0.02968647f, -0.24059008f, -0.02093353f, 0.02105985f, 0.02540838f, 
    0.07201663f, 0.05760410f, 0.06873466f, 0.03953231f, -0.02283671f, -0.17303397f, -0.01737744f, -0.14053412f, 
    0.05963908f, -0.01779176f, 0.15221925f, -0.25201502f, 0.09911546f, -0.00110239f, -0.00335529f, 0.18618660f, 
    0.33779833f, 0.01202626f, 0.19560987f, -0.06317686f, -0.11503329f, -0.13089310f, 0.06869710f, -0.07324097f, 
    -0.00293833f, -0.11828952f, 0.02611734f, -0.00089640f, 0.80481148f, -0.04567426f, -0.16926469f, -0.23905748f, 
    0.18261878f, -0.09498020f, -0.10538949f, 0.01638005f, 0.25967157f, 0.00972056f, -0.03868284f, -0.16535200f, 
    0.05557701f, -0.08748543f, 0.01906017f, 0.18074696f, 0.01244817f, 0.00089596f, -0.13344732f, 0.11501461f, 
    0.14306916f, 0.18739423f, 0.17862692f, 0.06599604f, 0.03816286f, -0.03135489f, 0.00267204f, 0.07897266f, 
    -0.12250238f, 0.11295615f, -0.01665322f, -0.15359487f, 0.07800861f, -0.12816781f, 0.02675502f, 0.05021444f, 
    0.50667334f, 0.33755276f, -0.20517083f, -0.00984728f, -0.02566619f, 0.18507460f, 0.06112489f, 0.15432563f, 
    0.19754633f, -0.04716763f, -0.01672361f, 0.10121683f, 0.15918820f, -0.00392258f, 0.09735920f, -0.09082242f, 
    0.10902578f, 0.17727262f, -0.00887912f, 0.01146489f, -0.11516080f, 0.01809187f, -0.10758069f, 0.09303751f, 
    0.45936823f, 0.01726237f, 0.20995881f, 0.29463944f, 0.15881650f, 0.09578611f, 0.03377413f, 0.17146824f, 
    0.01430697f, 0.07977814f, 0.07505933f, 0.05224917f, -0.11873837f, 0.08399630f, -0.32480520f, -0.04028426f, 
    0.00641262f, -0.13287511f, -0.02305674f, -0.07360811f, -0.13542385f, 0.00401258f, 0.01438503f, -0.06528976f, 
    0.16917342f, 0.12688473f, 0.02536129f, 0.09971695f, -0.05702338f, 0.03945622f, 0.04216311f, -0.10037721f, 
    -0.08871327f, 0.15095870f, 0.07512952f, -0.03743911f, -0.18790798f, -0.42311463f, 0.28879130f, 0.09165008f, 
    -0.11989382f, 0.05063239f, 0.03174841f, 0.19936764f, -0.03838669f, -0.16832052f, -0.16405562f, -0.01586584f, 
    0.00156022f, 0.06149686f, -0.08375178f, -0.15606193f, 0.01300613f, 0.19010857f, -0.03969479f, -0.05254645f, 
    -0.00459322f, 0.17052042f, 0.11558117f, 0.15974984f, 0.27221835f, 0.11137468f, 0.07445059f, -0.00588829f, 
    0.02016324f, 0.14335629f, 0.00447873f, 0.05378203f, 0.04102457f, 0.05614127f, 0.15562880f, -0.00147773f, 
    -0.43405724f, -0.20148621f, 0.18447889f, 0.10884377f, -0.01164148f, 0.11479049f, 0.03259354f, -0.00238328f, 
    0.08452732f, 0.01478509f, 0.12432963f, 0.01112305f, -0.23363762f, 0.09208064f, -0.01901846f, 0.09101647f, 
    -0.10231125f, -0.04617662f, 0.01292457f, -0.07946929f, -0.21396042f, -0.02446218f, -0.09095479f, -0.13865288f, 
    0.12072989f, -0.06203625f, 0.10925262f, -0.05661819f, 0.04487325f, -0.14522028f, -0.14047678f, 0.09626812f, 
    -0.08880567f, -0.05093918f, -0.08415691f, -0.18138616f, -0.20701650f, 0.11856411f, -0.04687549f, 0.21912475f, 
    0.01894881f, 0.16979282f, -0.01738570f, -0.10051930f, 0.09885244f, 0.18377507f, 0.10036292f, -0.04978069f, 
    0.04848556f, -0.09402700f, 0.10575962f, 0.04540461f, 0.20830011f, 0.08667854f, -0.04441201f, 0.00118824f, 
    -0.14476453f, -0.05744454f, 0.04871298f, 0.00858453f, -0.18369368f, -0.24708118f, -0.22819036f, 0.30694708f, 
    -0.12814161f, 0.04820266f, -0.16497642f, -0.28160530f, -0.13347097f, -0.14871778f, -0.20006911f, -0.02720671f, 
    -0.10770348f, -0.19075452f, 0.06174538f, 0.18982908f, 0.04243668f, -0.07649126f, 0.14217424f, 0.02184101f, 
    0.07160106f, 0.11022015f, 0.08846959f, 0.07398462f, -0.16402249f, -0.10850573f, -0.13368995f, -0.09095667f, 
    0.08076060f, 0.03902435f, -0.08832946f, -0.01619072f, -0.23865551f, 0.00367498f, -0.14357845f, -0.04422913f, 
    -0.35886499f, 0.00772049f, -0.01410691f, 0.03698321f, 0.03952682f, 0.14767937f, 0.05208246f, -0.01314695f, 
    -0.04022573f, -0.07769996f, -0.17247231f, 0.06363737f, -0.13250080f, 0.00784867f, -0.02070946f, -0.13288149f, 
    -0.09038257f, 0.12711884f, 0.08114667f, 0.13319410f, 0.01112727f, 0.04216474f, 0.01837526f, 0.08379391f, 
    0.01209696f, -0.02987409f, 0.06890004f, 0.24200071f, -0.00893479f, 0.22135419f, 0.00390802f, -0.06515627f, 
    -0.09836438f, 0.04609741f, -0.03389869f, 0.12733580f, -0.04962520f, 0.23544578f, -0.11216247f, 0.19321112f, 
    0.02062320f, 0.07494186f, 0.04124933f, 0.04810579f, -0.01674170f, 0.06467721f, 0.04099196f, 0.13755631f, 
    -0.26943246f, -0.14550267f, -0.20156577f, 0.08525226f, 0.01466517f, -0.01901633f, -0.03066863f, -0.19065943f, 
    0.08014139f, -0.04485893f, -0.04375809f, 0.02354081f, -0.14766145f, 0.36239797f, 0.00198387f, -0.06309132f, 
    0.01641950f, 0.16198675f, 0.07970171f, -0.01913977f, 0.00946656f, -0.10184331f, -0.02912956f, -0.02537685f, 
    -0.17548871f, 0.17121397f, -0.07873325f, 0.05587860f, 0.03730293f, 0.03646627f, 0.12885255f, 0.01689421f, 
    0.05376660f, 0.10037363f, 0.08904888f, 0.14013651f, 0.05693207f, -0.07414522f, 0.34568405f, 0.45874378f, 
    0.12928773f, -0.10893743f, 0.19326082f, 0.02233159f, 0.06221965f, 0.07345380f, 0.10932191f, 0.02492394f, 
    0.07394508f, 0.08527539f, -0.17431122f, -0.16209328f, -0.10849415f, -0.02904991f, -0.11551943f, -0.03560450f, 
    -0.04365831f, 0.01927234f, -0.11476640f, 0.10994069f, 0.03495029f, 0.09226038f, 0.14453827f, -0.30267298f, 
    0.07163204f, -0.03698209f, -0.08747583f, -0.08085784f, 0.06138121f, 0.03615642f, 0.18707222f, 0.13343923f, 
    0.03351346f, -0.54206449f, 0.02270599f, 0.27052239f, 0.15282808f, -0.00386080f, -0.07817785f, -0.02584277f, 
    -0.01924716f, 0.13005920f, 0.11993675f, 0.06180499f, 0.30987900f, -0.02228341f, 0.30704793f, 0.12233914f, 
    -0.07702019f, -0.03408601f, -0.06826318f, 0.25708705f, -0.07360914f, -0.03198161f, -0.06475538f, 0.06441099f, 
    -0.09152566f, 0.25798908f, -0.11776493f, 0.13199434f, 0.06906313f, 0.06383601f, -0.06821486f, -0.05795372f, 
    -0.00395513f, 0.12434538f, 0.09038007f, 0.17088321f, -0.38735190f, 0.06338032f, 0.29161587f, 0.19029370f, 
    -0.03872747f, 0.06384403f, 0.09848431f, -0.04371179f, 0.06644455f, -0.01568845f, 0.07514815f, 0.12461068f, 
    0.05314043f, -0.02453110f, 0.00716303f, 0.02840381f, -0.00555023f, 0.05112958f, -0.03195503f, -0.06811172f, 
    0.05989203f, -0.06048638f, -0.01192366f, 0.02844342f, -0.04898255f, -0.00243910f, 0.05802789f, -0.04477709f, 
    0.01948515f, -0.02249676f, -0.06642236f, -0.06958704f, 0.00157271f, -0.04946974f, -0.03893619f, -0.05325518f, 
    0.02111622f, 0.04822361f, 0.01431430f, -0.01662380f, 0.03153272f, -0.02802857f, 0.06601469f, 0.01153509f, 
    0.04087982f, -0.05265934f, -0.03810337f, -0.04247972f, -0.01693321f, -0.05150049f, 0.04979489f, -0.03339339f, 
    -0.03375109f, -0.06999819f, -0.01735335f, -0.06498930f, -0.01727320f, 0.04897185f, 0.02704258f, 0.03563230f, 
    0.02257811f, -0.00086326f, -0.01030346f, -0.04187076f, -0.04997009f, -0.06987783f, -0.01267652f, -0.04061277f, 
    0.00752526f, -0.01734649f, -0.06179568f, -0.05787523f, -0.02966353f, 0.00493564f, 0.04640549f, -0.03406690f, 
    0.03791807f, 0.04814833f, -0.02842252f, 0.02999018f, -0.06309537f, -0.05255657f, 0.01396862f, 0.05739608f, 
    0.01514133f, -0.01480410f, 0.06407074f, 0.02561872f, 0.06302289f, -0.03140097f, -0.03847511f, -0.01808946f, 
    -0.02270919f, 0.03547466f, 0.03204405f, 0.02665897f, 0.05075251f, -0.03883841f, 0.02627119f, -0.06260076f, 
    0.04604700f, -0.04697609f, 0.02937907f, -0.07187197f, -0.00250599f, -0.06753337f, 0.05115904f, 0.02184764f, 
    -0.01627855f, -0.06888705f, -0.03169664f, 0.03887866f, 0.05964043f, -0.07723656f, -0.07233738f, 0.05599729f, 
    -0.02411698f, 0.05149676f, 0.00715176f, 0.04414432f, 0.00111366f, -0.06026514f, 0.06179507f, 0.00751402f, 
    0.02383592f, 0.01868184f, -0.02319729f, -0.03779033f, -0.01164402f, -0.01143413f, -0.03160996f, -0.07787863f, 
    0.03883557f, -0.01238673f, -0.03237092f, -0.01197732f, -0.02428376f, -0.05914741f, -0.07976384f, 0.04588246f, 
    0.01504873f, 0.04677556f, -0.03011983f, 0.05590668f, -0.05618284f, -0.00637493f, -0.05214438f, 0.04698480f, 
    0.04917650f, -0.02365390f, 0.03629518f, -0.07820352f, -0.05195522f, -0.00522782f, -0.01984042f, 0.06386600f, 
    0.02290421f, -0.02191294f, 0.00577066f, -0.05348800f, 0.02401249f, -0.01107537f, -0.06194917f, -0.06493029f, 
    0.00854087f, -0.01789672f, 0.04848882f, 0.05726872f, -0.02441011f, -0.03769397f, -0.00818494f, -0.01390653f, 
    -0.06080211f, -0.01285217f, -0.01615324f, -0.05362706f, -0.02611638f, 0.00038797f, 0.00992909f, -0.01305303f, 
    -0.04553186f, 0.01449434f, -0.03025638f, 0.02341501f, 0.04407058f, -0.07664227f, 0.02162981f, -0.07083375f, 
    -0.03651017f, 0.01155664f, -0.03155411f, -0.06439463f, 0.05380454f, -0.05504812f, -0.06345266f, -0.01210868f, 
    -0.07477854f, -0.07022311f, -0.02765691f, 0.04346329f, -0.02776343f, -0.05719750f, 0.02616891f, -0.06763857f, 
    -0.04789289f, -0.07427410f, 0.05480148f, -0.06037586f, -0.07027046f, -0.01754987f, -0.06107119f, -0.02195351f, 
    -0.02712940f, 0.02764056f, 0.05865787f, -0.02485830f, 0.00561466f, -0.06630366f, -0.07873790f, 0.04579188f, 
    -0.07640994f, 0.00408776f, 0.04252874f, -0.00714692f, 0.00701302f, 0.00671675f, -0.07887450f, 0.03660303f, 
    0.01699424f, -0.02836012f, 0.00372350f, 0.05365967f, -0.05317729f, 0.05273554f, -0.04874044f, 0.05753862f, 
    0.00462727f, -0.07292214f, -0.02498984f, -0.03354451f, 0.02145794f, -0.06925196f, -0.06844739f, 0.05392671f, 
    -0.02183124f, -0.06976997f, -0.05514224f, 0.00183099f, -0.06007724f, 0.01892811f, 0.06214727f, -0.00280064f, 
    -0.03104499f, 0.00224078f, -0.01283925f, -0.00443071f, 0.05014282f, -0.06539612f, -0.01727110f, 0.04090235f, 
    -0.01038045f, 0.00674093f, -0.02331716f, 0.01960324f, 0.06078525f, -0.06510455f, 0.00793351f, 0.05874355f, 
    -0.04705195f, -0.08154838f, 0.00395409f, -0.04107402f, -0.00482554f, -0.05834369f, -0.02239313f, -0.01327453f, 
    0.00782661f, 0.02262371f, 0.02430959f, 0.04374522f, -0.04182975f, 0.04352651f, -0.03942497f, 0.03406848f, 
    -0.06305321f, 0.02792338f, -0.06315189f, 0.02222859f, -0.02330209f, -0.02446658f, 0.00567722f, -0.01949837f, 
    0.02242160f, -0.03834938f, 0.03349153f, 0.04378444f, -0.02386728f, 0.01115738f, 0.02504115f, -0.00045634f, 
    -0.07686576f, 0.04695759f, 0.05767864f, -0.01951996f, 0.03325059f, -0.00747618f, 0.01352603f, -0.01697284f, 
    0.02506589f, 0.04776328f, -0.04209485f, -0.02829312f, 0.00285586f, 0.04018473f, -0.04292812f, 0.05514241f, 
    -0.01369215f, 0.00872855f, -0.00554291f, -0.04542118f, -0.03340938f, 0.05849712f, -0.00940400f, -0.01746234f, 
    -0.06883884f, -0.03038269f, 0.04563005f, -0.04063784f, -0.06829052f, -0.07464420f, -0.03696997f, 0.02463403f, 
    -0.06593080f, -0.06931617f, -0.04670425f, -0.02351242f, -0.04305292f, -0.01955284f, -0.01017083f, -0.06407086f, 
    0.03184382f, 0.00760259f, 0.03670379f, 0.06326258f, -0.03074449f, 0.02752748f, -0.06052970f, 0.02562999f, 
    -0.01785451f, 0.02132651f, 0.06680989f, -0.04527783f, 0.04120105f, 0.03177334f, -0.02163602f, 0.04313979f, 
    0.04632572f, 0.03932620f, -0.06632932f, 0.04614730f, -0.02650868f, -0.01036483f, -0.01761479f, 0.00712070f, 
    -0.01153122f, -0.05191660f, 0.05108050f, 0.03060487f, -0.04819268f, -0.00896882f, 0.02555058f, -0.03916388f, 
    -0.02210920f, -0.01827613f, -0.05415200f, 0.04494238f, -0.05484096f, -0.07978237f, 0.02428870f, 0.04443333f, 
    0.02007987f, 0.05184266f, -0.00403546f, -0.05247660f, -0.03033332f, 0.06267159f, 0.03442948f, -0.01423242f, 
    0.06302419f, -0.01423306f, 0.02096828f, -0.05275172f, -0.00226859f, -0.03863287f, 0.00939885f, 0.04802354f, 
    -0.11020599f, -0.10485824f, 0.15375477f, 0.20884374f, -0.14277899f, 0.06345866f, 0.10092008f, 0.02668756f, 
    0.06780915f, 0.03743984f, 0.21025620f, -0.10633188f, 0.09504563f, 0.17088407f, 0.05340109f, -0.18108606f, 
    0.18753186f, -0.01128263f, -0.01424592f, -0.05336132f, -0.20841961f, 0.14247449f, 0.06855606f, -0.11215321f, 
    0.12915048f, -0.12004864f, 0.22146988f, 0.46574718f, 0.15820169f, 0.29115054f, 0.17316321f, 0.16092786f, 
    -0.09816430f, 0.04049821f, 0.16156472f, -0.03065672f, 0.06103452f, -0.00696026f, -0.07061710f, 0.26792270f, 
    -0.06598497f, -0.07875355f, 0.01155661f, -0.10366242f, 0.05393653f, 0.00618406f, -0.14023779f, 0.17910229f, 
    0.02344940f, 0.04843366f, 0.07062103f, 0.36730382f, 0.01608843f, 0.10288455f, 0.16264988f, 0.13916458f, 
    -0.04690624f, 0.07687511f, 0.00489253f, -0.04725454f, -0.06712974f, 0.15284553f, -0.05414867f, -0.09213453f, 
    -0.12288602f, -0.05202204f, -0.00187526f, -0.10580433f, -0.12560686f, 0.24922584f, -0.07649016f, 0.02209434f, 
    0.13374051f, 0.15858324f, 0.02408062f, -0.17233011f, 0.11269778f, 0.06836186f, -0.03193192f, -0.00812081f, 
    0.00863160f, -0.01939189f, -0.03718213f, -0.12720709f, -0.15571840f, 0.07985118f, -0.16966927f, -0.15881391f, 
    0.07071546f, -0.09015555f, -0.06120276f, 0.02887715f, 0.04848786f, -0.07269620f, 0.22855243f, 0.03406210f, 
    -0.00742605f, 0.17196250f, -0.24584894f, -0.01113970f, 0.04921635f, 0.03678656f, -0.00438527f, 0.07373416f, 
    -0.00085105f, 0.15276651f, -0.15527751f, -0.00352881f, -0.00506563f, 0.03420509f, 0.01257161f, 0.22002068f, 
    -0.00455415f, -0.19973460f, 0.09522653f, -0.00939020f, -0.07026011f, 0.05934115f, -0.03687707f, -0.06234118f, 
    0.15110739f, 0.11391508f, 0.05377474f, 0.05010420f, -0.03887407f, -0.07748247f, -0.01507704f, -0.02535498f, 
    -0.08641071f, 0.13457240f, -0.03297256f, 0.19478206f, 0.04478949f, 0.02362670f, 0.01552705f, 0.07712274f, 
    -0.08285146f, -0.14459229f, -0.06706826f, -0.24362005f, 0.05727706f, -0.00589563f, -0.04191822f, 0.18825056f, 
    0.06347217f, 0.17263174f, 0.13653056f, -0.18287098f, 0.13650182f, 0.09201860f, 0.00306806f, -0.18562166f, 
    -0.22432166f, -0.06762728f, 0.04454258f, -0.08820363f, -0.52474606f, 0.11642557f, 0.27205178f, 0.02602923f, 
    0.01328455f, 0.12198652f, -0.20872378f, 0.14606227f, 0.11024512f, 0.00014036f, -0.00971190f, -0.01179269f, 
    0.18392409f, 0.01145974f, 0.28282797f, 0.11339664f, 0.04272230f, 0.18275465f, -0.09323353f, -0.05885010f, 
    -0.12305825f, 0.03093671f, -0.17829145f, 0.01958671f, -0.21748362f, -0.01173302f, 0.37511650f, 0.27449647f, 
    -0.14422834f, -0.00025328f, -0.11773892f, -0.04631428f, -0.01732543f, 0.12798189f, 0.05794246f, 0.01338048f, 
    0.09838621f, -0.15516718f, 0.13051714f, 0.17609923f, 0.03677117f, -0.00976107f, 0.10734934f, 0.12066805f, 
    0.02389681f, 0.00814970f, 0.05200871f, 0.14766462f, -0.13278137f, 0.03865505f, -0.19131584f, 0.01267745f, 
    0.00206395f, 0.14433870f, 0.25651020f, 0.09308141f, 0.22542907f, 0.09198010f, 0.07141498f, 0.19826458f, 
    -0.13630243f, 0.16590382f, 0.15709642f, -0.18374483f, -0.13530411f, -0.01919315f, 0.00937627f, 0.12693863f, 
    0.11716416f, 0.02960149f, -0.12519503f, -0.06384365f, -0.07577222f, -0.02029231f, 0.23153056f, -0.42687133f, 
    -0.08933938f, -0.07209853f, -0.02664716f, 0.01140612f, 0.03304340f, -0.02559554f, -0.12459087f, -0.08352090f, 
    -0.05149446f, 0.03202416f, 0.07837869f, 0.18375082f, 0.04366037f, -0.12142754f, 0.01734912f, -0.02684717f, 
    0.00173780f, -0.04669149f, -0.03100440f, 0.18768090f, 0.23055556f, -0.19617820f, 0.10270324f, -0.28920412f, 
    0.14371754f, -0.02070940f, 0.14389226f, 0.06263014f, 0.10040559f, -0.00494187f, 0.03940289f, 0.09883302f, 
    0.22337733f, -0.05256394f, 0.05311002f, -0.17986535f, -0.13307619f, -0.08313788f, -0.10818872f, -0.10309525f, 
    0.10212897f, -0.09858835f, 0.20702814f, 0.00336143f, -0.19222385f, -0.17021400f, 0.21030799f, -0.21005149f, 
    0.04528536f, 0.12926996f, -0.12402282f, 0.09885150f, -0.00664478f, 0.09838077f, -0.03765060f, 0.06679241f, 
    -0.23812577f, 0.06806633f, -0.00371044f, -0.05844496f, 0.07571391f, 0.01958272f, -0.05348558f, 0.13546328f, 
    -0.03077713f, -0.06309219f, 0.02659152f, 0.06490340f, 0.01389214f, -0.10485817f, 0.16730931f, 0.30300778f, 
    0.02333305f, 0.10646831f, 0.06434793f, 0.18068866f, 0.01671116f, -0.05296024f, -0.01334664f, -0.01445050f, 
    -0.04251590f, 0.13196348f, 0.25880179f, 0.15484564f, -0.05846630f, 0.05085930f, -0.01675322f, -0.08788197f, 
    0.09501045f, 0.01710952f, 0.04848050f, -0.06019197f, 0.03182499f, 0.13214725f, 0.03235320f, 0.02610307f, 
    -0.19389488f, 0.07786547f, 0.07504461f, -0.05273305f, -0.13066603f, 0.02273771f, 0.23035736f, 0.01192011f, 
    0.39921004f, -0.39279547f, 0.03878246f, -0.02428847f, -0.05818003f, 0.00564506f, -0.15264124f, 0.05035228f, 
    0.05469710f, 0.13721280f, 0.01896690f, -0.01807863f, 0.23948887f, -0.04066704f, -0.70753908f, 0.24086419f, 
    0.01276153f, 0.09245677f, 0.20139290f, 0.04395383f, 0.06740826f, 0.07605226f, -0.06752019f, -0.06139930f, 
    -0.05750285f, 0.17987092f, -0.15545183f, 0.06287451f, -0.15555090f, -0.16588576f, -0.09508200f, -0.02960805f, 
    0.15950686f, -0.03949383f, 0.04858449f, 0.10266219f, -0.31607211f, 0.29353467f, -0.36930633f, -0.10708439f, 
    -0.10036834f, 0.05111063f, 0.04458109f, 0.03551794f, 0.14915700f, 0.10086973f, -0.10729357f, -0.02634503f, 
    -0.01436688f, 0.21106373f, 0.23430164f, 0.06962188f, -0.05447701f, 0.23496735f, -0.08248854f, 0.09045126f, 
    0.08246981f, 0.12334746f, 0.01640621f, -0.23947071f, 0.05641755f, 0.00556282f, -0.01893497f, -0.14971618f, 
    0.02480454f, 0.00958825f, 0.19432034f, 0.02564436f, -0.04163891f, 0.16282371f, 0.07025450f, 0.11825929f, 
    0.02737976f, 0.09290957f, 0.60324460f, 0.24199550f, -0.07531980f, 0.14000781f, -0.01083226f, 0.07904614f, 
    0.14017679f, -0.02800771f, 0.16673456f, 0.01020371f, 0.03860528f, -0.01296584f, 0.23441236f, 0.08952792f, 
    -0.00993217f, -0.23267029f, -0.04702555f, -0.00321266f, -0.03016599f, -0.06539574f, -0.11279866f, 0.11380795f, 
    -0.09849761f, 0.18967845f, 0.25040829f, 0.39413086f, -0.19680262f, -0.02232605f, 0.18461557f, 0.11226264f, 
    0.01135749f, 0.02752156f, 0.07340743f, -0.07518186f, -0.10998616f, 0.04854396f, -0.17136772f, 0.14447112f, 
    0.09317563f, -0.04651668f, 0.06328069f, -0.03002632f, -0.08531814f, 0.11379278f, 0.08834371f, 0.11705104f, 
    -0.00904525f, 0.00751371f, 0.00994769f, -0.06505216f, -0.11777725f, -0.10685180f, -0.11184873f, -0.10601949f, 
    -0.04568344f, 0.11796893f, 0.01735018f, -0.12390950f, -0.21434790f, -0.70228332f, 0.15567178f, 0.07492401f, 
    0.03878082f, 0.01420359f, 0.03021820f, 0.14944036f, 0.32886672f, 0.06953491f, 0.12713926f, -0.05976411f, 
    -0.20372643f, -0.11367483f, 0.20513421f, 0.10504249f, 0.04341716f, -0.06417471f, -0.18556514f, 0.11554342f, 
    0.10747531f, 0.03964973f, 0.07706288f, -0.11239094f, -0.23748325f, 0.08353879f, -0.00254447f, 0.05277838f, 
    0.00162605f, 0.06483819f, -0.03201596f, 0.25470272f, -0.03647832f, 0.03105314f, 0.12830967f, 0.07827125f, 
    -0.11809462f, -0.28125036f, 0.04207278f, -0.06896922f, -0.16886052f, 0.03454521f, -0.03163917f, -0.12237693f, 
    -0.05758199f, 0.06168856f, -0.18997334f, 0.06536614f, -0.35191017f, -0.18488419f, -0.26298991f, -0.02344512f, 
    0.05079314f, -0.07735080f, -0.13157503f, -0.11482827f, -0.01107471f, 0.08346367f, -0.09128585f, 0.08418801f, 
    -0.04079273f, 0.38714719f, 0.10910423f, 0.02978597f, -0.18399845f, -0.00773903f, 0.04936668f, -0.17546460f, 
    0.11827088f, -0.02994458f, -0.19867256f, 0.06478988f, -0.50132251f, 0.19111468f, -0.11330964f, 0.06387565f, 
    0.07007852f, 0.17261927f, -0.02202970f, 0.02296279f, -0.10777382f, -0.05876901f, 0.06754378f, -0.03707521f, 
    0.10755908f, -0.18431491f, 0.01679139f, -0.27770516f, -0.04172292f, -0.01654427f, 0.13128038f, -0.07811469f, 
    -0.02021115f, 0.06881236f, -0.06374565f, -0.01461232f, 0.11404302f, 0.06970739f, 0.00384034f, -0.34895104f, 
    -0.05695262f, -0.03619180f, 0.10719386f, 0.07254513f, -0.07637183f, 0.12766296f, -0.05813050f, 0.04995671f, 
    0.07429816f, 0.19503707f, 0.19199827f, 0.08982375f, 0.02660659f, 0.00095049f, -0.01738076f, 0.02963132f, 
    -0.08912698f, 0.10507262f, 0.10661582f, 0.12747516f, -0.07388733f, -0.00831640f, 0.02731187f, -0.10287466f, 
    0.10063300f, -0.08172072f, 0.02796311f, 0.04696257f, 0.02190765f, -0.14062887f, -0.07670499f, -0.28332040f, 
    0.25791597f, 0.11561709f, -0.11815065f, 0.04691581f, 0.02635570f, -0.00855302f, -0.04448511f, 0.04685198f, 
    0.03279737f, -0.13797460f, -0.15688331f, 0.09163991f, 0.07246125f, 0.00593909f, 0.00953625f, 0.34219772f, 
    0.14145793f, 0.11115588f, 0.10733745f, 0.13767789f, 0.12343237f, 0.13014980f, 0.30363208f, 0.12109033f, 
    0.18756786f, 0.15169814f, -0.01093379f, -0.11483674f, 0.08047520f, 0.15674056f, 0.06262346f, 0.02721268f, 
    -0.08460262f, -0.06904250f, -0.05591646f, -0.15253212f, -0.17247927f, -0.30118036f, 0.08983126f, -0.11103518f, 
    -0.03378283f, 0.14627044f, -0.03592077f, -0.00859243f, 0.03442563f, 0.03903218f, -0.07295685f, -0.09147156f, 
    -0.04456118f, -0.08862644f, 0.03797958f, -0.04192261f, -0.08719701f, -0.03907526f, 0.04812225f, 0.07234656f, 
    0.02662749f, -0.01564530f, -0.06981786f, -0.11318608f, -0.01168038f, 0.15369903f, -0.20689669f, -0.17606285f, 
    0.04724986f, -0.03121706f, 0.02341911f, 0.04189983f, -0.01428781f, 0.09116386f, -0.07005401f, -0.09749887f, 
    0.10900457f, -0.04174498f, 0.25667173f, 0.20952830f, -0.02986799f, 0.00922649f, 0.16268112f, 0.07101266f, 
    0.14389989f, -0.01992080f, -0.09508444f, 0.01757847f, 0.27201217f, 0.32127759f, 0.08081423f, -0.09554421f, 
    0.04448355f, -0.08882114f, 0.04495427f, -0.00010679f, 0.00828636f, 0.06486267f, -0.07144815f, 0.06732114f, 
    -0.15368320f, -0.28398865f, -0.30930224f, 0.08884530f, -0.08596667f, 0.06763901f, -0.08276503f, -0.00175789f, 
    -0.10042626f, 0.20403948f, 0.19342585f, 0.10784005f, -0.24340571f, -0.43668243f, -0.26118061f, 0.21812569f, 
    0.01786834f, -0.05780123f, -0.15125655f, -0.06789483f, 0.02763437f, 0.08244538f, 0.01508643f, 0.14456446f, 
    -0.07925035f, 0.10983148f, 0.11549282f, -0.10443415f, -0.10917736f, -0.03892870f, 0.05835398f, 0.00827526f, 
    0.10037010f, 0.05737348f, 0.12415460f, 0.09155948f, -0.27581543f, -0.00775012f, 0.16541241f, -0.03234711f, 
    -0.14371370f, -0.05241787f, -0.19222215f, 0.12308829f, 0.18881080f, -0.05260362f, -0.04164062f, 0.13879013f, 
    0.08637474f, -0.15283316f, -0.09501512f, -0.02457131f, 0.16703089f, 0.19887671f, -0.05720464f, 0.04704572f, 
    -0.11594167f, -0.27028900f, -0.20259261f, -0.19378383f, -0.11640842f, 0.09928285f, 0.03245639f, -0.08708319f, 
    0.14384237f, -0.00744873f, -0.09818454f, -0.16435172f, 0.07862866f, 0.07750615f, 0.01257077f, 0.01866432f, 
    -0.01602907f, -0.05154331f, -0.04588433f, 0.02974875f, -0.05312226f, 0.00461813f, 0.06007514f, -0.05987000f, 
    -0.06387381f, 0.01773154f, -0.07317605f, -0.07648525f, -0.03753398f, -0.04929658f, 0.01567241f, -0.03096477f, 
    -0.03195979f, -0.02369870f, 0.04482930f, -0.05091721f, -0.02849323f, 0.00598744f, 0.01740587f, -0.00642477f, 
    0.03110299f, -0.00936579f, -0.02539720f, -0.03298901f, -0.07420472f, -0.00222588f, -0.00509965f, -0.05117307f, 
    0.00809094f, 0.04792987f, -0.04806466f, 0.07191685f, 0.01091479f, -0.06031518f, -0.04386329f, 0.00853266f, 
    0.05049532f, 0.00530322f, -0.00637218f, 0.00221304f, 0.06046049f, -0.05908762f, -0.04917284f, 0.04227942f, 
    -0.01218262f, -0.04552415f, -0.06333993f, 0.05285869f, 0.01600288f, 0.00938692f, 0.00368549f, 0.05358045f, 
    0.04106525f, -0.00734122f, 0.02691250f, -0.02656442f, -0.03781431f, 0.00977489f, 0.01965004f, -0.00304678f, 
    -0.02027844f, -0.00142844f, -0.02544430f, -0.05714135f, -0.03899903f, 0.00926202f, -0.05014822f, 0.04964552f, 
    -0.01686630f, -0.04930590f, -0.04659032f, -0.02432781f, -0.00172133f, 0.04318107f, -0.06803056f, 0.03446250f, 
    -0.01486328f, 0.00695418f, 0.03980863f, 0.06000806f, -0.03080702f, -0.03612970f, -0.05860080f, 0.04478085f, 
    0.04936600f, 0.03733532f, 0.04163268f, -0.04497994f, -0.06612989f, 0.06128220f, 0.00565022f, -0.03248277f, 
    0.03963463f, -0.04787958f, -0.01019749f, -0.04600901f, 0.01898677f, -0.00684519f, -0.00546218f, -0.01535718f, 
    -0.03076459f, -0.03701895f, -0.00869082f, -0.04435396f, -0.06991237f, -0.02285544f, 0.01606060f, 0.03394402f, 
    0.02458942f, 0.00154448f, -0.03890423f, -0.00461768f, 0.06172558f, -0.00530355f, 0.02019195f, 0.00804932f, 
    0.02615145f, -0.07299820f, -0.05610045f, -0.02726701f, 0.04681041f, 0.01814880f, 0.04094911f, 0.06545115f, 
    -0.04801408f, -0.02608163f, -0.01960336f, 0.04533789f, -0.06182374f, -0.06544743f, -0.03739939f, 0.00907653f, 
    0.01371519f, -0.04865962f, 0.05493155f, 0.03803940f, 0.04357289f, -0.07720716f, 0.00490200f, -0.07270077f, 
    -0.02789646f, -0.00541588f, -0.06501919f, -0.06969903f, -0.05979943f, -0.03395237f, 0.00553841f, 0.03252959f, 
    -0.01573603f, -0.06498712f, 0.02556576f, -0.06236892f, -0.07265362f, 0.01819440f, -0.01052139f, -0.04526888f, 
    -0.06436052f, -0.04466566f, -0.02604482f, 0.01533254f, 0.01827078f, 0.04683559f, -0.06613549f, 0.00147023f, 
    -0.04709057f, -0.06554502f, 0.03097162f, 0.03087460f, 0.01633856f, -0.01004477f, -0.01588907f, 0.01662787f, 
    0.02586354f, -0.04692870f, -0.02369137f, 0.00210141f, -0.02627797f, 0.02856805f, -0.02261544f, 0.06386562f, 
    0.03859143f, 0.05536302f, 0.01722687f, -0.06029432f, -0.01459406f, -0.02251574f, -0.03413110f, -0.03069354f, 
    -0.09770555f, 0.05135376f, 0.23443642f, 0.02551330f, 0.01476482f, 0.23682109f, 0.05575788f, -0.23181142f, 
    -0.06665515f, -0.05603625f, 0.02976208f, -0.18570563f, -0.00517523f, 0.05589915f, -0.04727501f, -0.21131343f, 
    0.04845779f, 0.03537316f, -0.01444845f, 0.09162140f, -0.12138804f, 0.24021465f, 0.01986006f, 0.18248171f, 
    -0.32413170f, -0.38649821f, 0.45440647f, 0.12042300f, 0.00761378f, 0.17171739f, 0.00269730f, 0.05627787f, 
    -0.23307589f, 0.02999218f, 0.17014876f, -0.15599616f, 0.03586799f, 0.10014729f, 0.00703005f, 0.07849551f, 
    0.08760004f, -0.09233466f, 0.09346009f, 0.06683406f, 0.01691166f, -0.07562204f, -0.17663170f, -0.00362819f, 
    -0.25501063f, 0.19907561f, -0.06520413f, 0.12316403f, -0.09697092f, 0.25808242f, 0.18383595f, -0.02454815f, 
    -0.03508149f, 0.01398979f, -0.15664554f, 0.08556468f, -0.03184957f, 0.18310851f, 0.06885760f, 0.24461858f, 
    -0.12534434f, -0.03387422f, 0.05157087f, 0.01449967f, 0.12887289f, 0.15579161f, 0.14103413f, 0.08864850f, 
    -0.36276567f, -0.14614516f, -0.14522830f, -0.00692371f, 0.01552107f, -0.20069388f, -0.05477910f, -0.12435810f, 
    -0.07802336f, 0.12476445f, 0.08545478f, 0.02788932f, 0.07610849f, -0.02776698f, -0.08448764f, -0.10190549f, 
    -0.10322670f, 0.08561648f, 0.01899780f, 0.18439412f, 0.18083459f, -0.11790971f, 0.21658508f, -0.07504418f, 
    -0.14769123f, 0.21615517f, 0.20413974f, 0.13080150f, -0.03759268f, -0.15796620f, 0.11409917f, 0.08040281f, 
    0.04110782f, -0.00999133f, -0.05577187f, -0.12174468f, -0.18482761f, 0.23286104f, 0.08311474f, 0.14004326f, 
    -0.01780228f, 0.01225990f, -0.09234709f, 0.12412918f, -0.01827253f, -0.01289802f, 0.17906183f, 0.10342339f, 
    0.41377673f, 0.11154225f, -0.01771027f, -0.09336509f, -0.13453405f, -0.14000541f, -0.21830614f, -0.20670208f, 
    -0.04649897f, -0.07371536f, -0.21535349f, -0.04172951f, -0.06262785f, 0.05432704f, 0.08220429f, -0.02286166f, 
    0.06332336f, -0.16250624f, -0.26556516f, -0.08288658f, 0.00303843f, -0.06335860f, -0.17188343f, 0.03874414f, 
    -0.16308086f, 0.06501893f, 0.03864666f, -0.00225866f, -0.09529387f, 0.07935595f, -0.03267147f, -0.30520043f, 
    -0.04834687f, -0.06784585f, 0.03808821f, 0.13319449f, -0.28450608f, 0.28668773f, 0.15612563f, 0.04113566f, 
    0.17138681f, 0.07505796f, -0.19490600f, -0.06333244f, 0.00245435f, -0.18406706f, -0.04144134f, 0.09490082f, 
    0.17064075f, 0.02944157f, 0.20223403f, -0.03892528f, -0.10979952f, -0.00019906f, -0.12140830f, -0.12829839f, 
    0.16353084f, 0.32095537f, 0.03350051f, 0.31725296f, -0.04742493f, -0.01509200f, 0.40960068f, -0.20366018f, 
    -0.04973259f, -0.06575483f, 0.08186734f, 0.17524548f, 0.18734592f, 0.07694697f, 0.02373389f, 0.11797866f, 
    0.04018122f, 0.03237129f, -0.07903396f, 0.05223899f, -0.01294354f, 0.01345157f, -0.03076317f, -0.05839881f, 
    0.01996792f, 0.06056375f, -0.01126698f, 0.03947684f, 0.05736375f, -0.00044402f, -0.03939521f, -0.02477149f, 
    0.00907658f, -0.08229919f, -0.07977454f, -0.04930921f, 0.00834717f, -0.02831053f, 0.00167116f, -0.07170362f, 
    -0.00798072f, 0.05003855f, 0.06214713f, -0.06407037f, 0.02443945f, 0.02369901f, -0.05250799f, 0.01806949f, 
    -0.01625225f, -0.05568286f, 0.04823665f, 0.00283689f, -0.05449121f, -0.04729070f, -0.05405712f, 0.06408767f, 
    -0.06515339f, -0.05918095f, 0.03558036f, -0.05246698f, -0.06137741f, 0.04363724f, -0.02096472f, 0.01972671f, 
    0.01738876f, 0.04546563f, 0.06869598f, 0.02834985f, -0.04134641f, -0.03708786f, -0.01365051f, -0.01391155f, 
    -0.02296909f, 0.05354308f, 0.00553684f, 0.01508808f, -0.01144385f, 0.04124508f, -0.02553926f, -0.00354288f, 
    -0.02851394f, 0.04483325f, 0.04837430f, -0.07340166f, -0.07575863f, 0.05801226f, 0.05514567f, 0.02284947f, 
    -0.06043205f, 0.00553002f, 0.02562571f, -0.04366757f, -0.01698172f, -0.01753191f, -0.04818607f, 0.06072211f, 
    -0.04816472f, 0.02048298f, 0.03858599f, -0.00526379f, 0.07166117f, 0.01813580f, 0.04789830f, 0.00399931f, 
    0.05166573f, -0.01866906f, -0.05309742f, -0.01614539f, -0.04351368f, 0.06917236f, -0.02335472f, 0.03254210f, 
    0.03925332f, -0.05107842f, 0.02945744f, -0.00957866f, -0.05848764f, 0.03512938f, 0.02730612f, -0.01651484f, 
    -0.05332008f, 0.04985010f, -0.03355533f, -0.02758745f, -0.05872899f, -0.01971886f, -0.07515110f, -0.00637536f, 
    0.03299005f, -0.01903678f, -0.02988407f, -0.07654291f, -0.02643468f, -0.05880283f, -0.04324682f, -0.06943552f, 
    -0.07214246f, 0.00541990f, -0.02874358f, -0.03273042f, -0.04131668f, -0.00756684f, 0.06159913f, 0.05572645f, 
    -0.04368022f, 0.05170376f, -0.05429203f, -0.00934372f, 0.03474636f, 0.01578791f, 0.00627497f, -0.04221858f, 
    -0.01532593f, -0.05256444f, 0.01261422f, 0.01954783f, 0.03681184f, 0.03260837f, -0.03243666f, 0.03813867f, 
    0.00248709f, 0.02450591f, -0.01240041f, 0.05090830f, -0.01750280f, 0.00587802f, -0.00707647f, -0.03770617f, 
    -0.06420564f, -0.03227837f, -0.02426411f, -0.02178576f, -0.02961734f, 0.00660782f, 0.06758144f, -0.01606118f, 
    -0.00335763f, -0.05597257f, -0.04813943f, 0.03010148f, -0.06327305f, -0.00716361f, -0.00231023f, -0.03825998f, 
    -0.03183893f, 0.06319352f, -0.01727702f, -0.02699694f, -0.02622140f, -0.00194141f, -0.06448146f, 0.05607866f, 
    -0.03639651f, -0.07694812f, 0.03882504f, 0.04540131f, -0.00052433f, 0.06562088f, 0.03674021f, 0.03515448f, 
    0.05011884f, 0.04172617f, 0.03923645f, 0.04081627f, -0.05002937f, -0.05374511f, -0.07467748f, -0.01073038f, 
    -0.06016413f, -0.24531205f, -0.11658330f, 0.11452395f, 0.03772016f, 0.06567275f, 0.08256028f, 0.02658843f, 
    0.06562627f, -0.10830151f, 0.08818361f, 0.08251912f, -0.12922238f, -0.02293540f, -0.13452902f, 0.03451745f, 
    0.20636880f, 0.04564524f, -0.03451065f, -0.02996624f, -0.01720374f, 0.10275100f, 0.04109260f, 0.09834697f, 
    -0.25430897f, -0.15282571f, 0.01072234f, 0.12453863f, 0.10706668f, 0.06346789f, -0.08009638f, -0.00255806f, 
    -0.17219768f, -0.01344916f, 0.01739406f, -0.03014695f, -0.05996526f, -0.03854122f, -0.07338238f, -0.08653942f, 
    0.05580056f, 0.05784928f, 0.03706930f, -0.02285226f, -0.10533344f, -0.09201000f, -0.20478038f, -0.17304991f, 
    0.02009123f, -0.12657985f, -0.05290727f, 0.20298658f, 0.00382673f, 0.15126728f, 0.00153180f, 0.00650657f, 
    -0.00925727f, 0.05242651f, -0.02624685f, 0.19211002f, -0.05426778f, 0.19992124f, -0.12652928f, 0.07769370f, 
    0.00138769f, -0.10345294f, 0.08525617f, 0.15284669f, 0.13924767f, 0.12961060f, 0.06505201f, 0.22372065f, 
    -0.26763150f, 0.07388508f, -0.20826271f, -0.01176933f, 0.02287089f, 0.02724501f, 0.03759907f, -0.06101468f, 
    0.06042829f, 0.17756984f, 0.05049784f, 0.14469510f, -0.13103211f, 0.33427987f, 0.08171406f, 0.03763071f, 
    -0.04981957f, 0.01992526f, 0.01704133f, -0.11924248f, 0.03042963f, -0.06315853f, 0.12286727f, -0.02153404f, 
    -0.15460683f, 0.34133175f, -0.16179097f, 0.00864419f, -0.05770059f, 0.03543752f, 0.10572477f, 0.06518175f, 
    -0.14648582f, -0.01402837f, -0.12458031f, 0.10433500f, 0.11031981f, -0.14074704f, 0.11020691f, 0.36467540f, 
    0.11677721f, 0.06270392f, -0.01361947f, -0.03106656f, 0.01332690f, -0.00404580f, 0.15888782f, 0.10394973f, 
    0.14374264f, 0.03820175f, -0.10595799f, -0.17546739f, -0.11717767f, -0.10889240f, -0.09975620f, -0.03402831f, 
    0.06892177f, -0.09008747f, -0.19408828f, 0.06035865f, 0.02572287f, 0.07947086f, 0.00020829f, -0.22917880f, 
    -0.03246120f, -0.16467099f, -0.01800743f, -0.05354926f, 0.04579127f, -0.00291136f, 0.08876038f, 0.09803442f, 
    -0.02785474f, -0.11028457f, -0.18028249f, 0.08205638f, 0.08233955f, 0.09839194f, -0.07756454f, -0.00020005f, 
    0.02101569f, 0.09388270f, -0.10624735f, 0.04734334f, -0.07316273f, 0.09373163f, 0.18123245f, 0.18398118f, 
    0.07874628f, 0.13690230f, -0.04009366f, -0.02829370f, -0.16213468f, 0.00829810f, -0.12643377f, -0.13101141f, 
    -0.08930536f, 0.19215919f, -0.00043811f, 0.08982350f, -0.09495986f, -0.11346983f, -0.15773933f, -0.14478880f, 
    0.18587889f, 0.16171533f, 0.21690606f, 0.28824723f, -0.27817068f, -0.07404967f, 0.12618110f, 0.25822330f, 
    -0.04292275f, -0.07115472f, 0.01975400f, 0.09746700f, 0.16975397f, 0.00520479f, 0.03903317f, 0.00213450f, 
    -0.02550531f, -0.04406521f, 0.00100930f, 0.15640838f, -0.06545753f, -0.07621953f, 0.17069562f, 0.07737943f, 
    0.04608391f, 0.10395578f, -0.05890454f, 0.25955883f, -0.26428008f, 0.05377155f, -0.20406964f, 0.07362711f, 
    0.09443332f, -0.00210028f, 0.00876058f, 0.02182971f, 0.11266731f, -0.21617636f, -0.12996380f, -0.27712655f, 
    -0.07279368f, 0.12824115f, -0.05473119f, -0.14612751f, -0.05472784f, -0.03030946f, -0.01632249f, -0.01459963f, 
    0.09956606f, -0.04765204f, -0.22311863f, -0.14247462f, -0.22419015f, 0.01758397f, 0.24025699f, -0.06417379f, 
    0.01966346f, 0.19730581f, 0.19382457f, 0.23468320f, 0.17328812f, 0.04033711f, 0.13159995f, 0.03161610f, 
    -0.12177479f, -0.06004285f, 0.02464432f, -0.04782128f, 0.00179996f, -0.11151963f, -0.11842109f, -0.09385318f, 
    -0.06826548f, -0.26607236f, -0.02828512f, -0.14215000f, 0.09046647f, -0.27948952f, 0.13837317f, -0.00461489f, 
    0.10377181f, 0.05902765f, 0.08646197f, 0.04328642f, 0.04762517f, -0.03170682f, 0.02758773f, 0.04734596f, 
    0.13321474f, -0.24857113f, -0.04818360f, -0.17278360f, -0.08186199f, 0.11722055f, -0.09337970f, 0.03931063f, 
    0.19827965f, -0.22844732f, -0.06201416f, 0.21352202f, -0.37784323f, 0.27401382f, 0.03849198f, -0.25427231f, 
    0.00836615f, 0.08079190f, -0.14669430f, 0.03838211f, -0.11325312f, -0.01144430f, -0.17411406f, -0.02311520f, 
    -0.14145365f, -0.11536398f, -0.08656721f, 0.12267026f, -0.05362152f, 0.04089393f, -0.06337721f, 0.17199257f, 
    -0.00890676f, -0.00678204f, 0.06007986f, 0.02525956f, 0.05413371f, -0.23182875f, 0.05225369f, 0.36729431f, 
    0.16142714f, -0.09134832f, 0.03777798f, 0.07505067f, -0.02333576f, 0.20236722f, 0.00762323f, -0.05069590f, 
    -0.05288978f, 0.05593149f, -0.07668992f, 0.02594829f, 0.03670224f, 0.15537812f, -0.04951710f, 0.06942027f, 
    0.10015279f, 0.18313429f, 0.26061025f, 0.15503164f, 0.01197205f, -0.04301812f, -0.19144869f, -0.15338032f, 
    0.13788584f, 0.13521890f, 0.13658977f, 0.22711022f, 0.06350221f, 0.09582280f, 0.06278935f, 0.12382974f, 
    0.15819703f, -0.06882986f, 0.08359203f, 0.20503661f, 0.00402968f, -0.02225314f, -0.11495992f, 0.08262546f, 
    0.03205124f, 0.14218216f, 0.15227000f, 0.05570678f, 0.18509121f, -0.23255140f, -0.17059159f, 0.01611096f, 
    0.06890845f, 0.07335803f, 0.14598136f, 0.07335583f, 0.13931862f, 0.10751647f, -0.08844743f, 0.00142573f, 
    -0.12056168f, 0.04905221f, -0.13895383f, 0.03435369f, 0.03971564f, 0.03585272f, -0.24023625f, 0.00539183f, 
    -0.10019751f, -0.18916929f, -0.01926708f, 0.04574805f, 0.10130647f, 0.53075159f, -0.04709837f, -0.31644014f, 
    0.01648204f, 0.15601797f, 0.00317726f, -0.10960419f, 0.09020418f, -0.09087995f, -0.04440286f, -0.05258270f, 
    0.09199151f, 0.22362904f, 0.10221152f, 0.07204988f, -0.01347065f, -0.00631457f, 0.06217140f, -0.00603913f, 
    0.00156007f, 0.15621296f, 0.04547642f, 0.13976409f, -0.09863800f, -0.06605463f, 0.06609897f, -0.02858981f, 
    0.06423672f, 0.05569930f, 0.03613681f, -0.04156593f, -0.24714966f, -0.26109591f, -0.06714530f, -0.02904142f, 
    0.28440100f, 0.20106730f, -0.37478289f, -0.02040983f, 0.07597519f, -0.05415319f, 0.03471892f, 0.04721743f, 
    0.12283906f, -0.04921838f, -0.20179807f, -0.06094039f, -0.00380752f, -0.25056985f, -0.10180793f, 0.05765128f, 
    0.09665592f, 0.13864665f, -0.00733815f, 0.04720093f, 0.20356409f, 0.05755794f, 0.21318021f, 0.06518845f, 
    0.24516088f, 0.03317232f, 0.15896717f, 0.02616196f, 0.06592356f, 0.11330070f, -0.03356715f, 0.06180611f, 
    -0.14239018f, -0.13965213f, 0.07094796f, -0.06001672f, -0.11517652f, -0.23993658f, 0.09789961f, -0.22681375f, 
    -0.01234048f, 0.19028951f, -0.04364389f, -0.08905588f, -0.02114980f, -0.01382615f, -0.10761386f, 0.01090834f, 
    0.14992629f, -0.02220610f, 0.13287893f, 0.17987612f, -0.11091969f, -0.09617568f, 0.08095527f, 0.01338518f, 
    0.14311768f, -0.01162193f, 0.04364053f, -0.04101771f, 0.13817373f, 0.05174154f, -0.19501646f, -0.14840078f, 
    0.05292882f, -0.09612594f, 0.00359638f, 0.10641845f, -0.14178170f, 0.20973156f, -0.06759038f, -0.26594654f, 
    0.15010254f, -0.10386357f, 0.23871793f, 0.03303462f, -0.06953943f, 0.01463387f, 0.06707282f, 0.04686698f, 
    0.13633735f, 0.03575562f, 0.02415313f, 0.16240059f, 0.27093652f, 0.09050275f, 0.16246754f, -0.09076375f, 
    0.09206378f, 0.08684007f, -0.00256205f, 0.06357360f, 0.12497260f, 0.17101733f, -0.06221602f, 0.02244529f, 
    -0.17126071f, -0.26434666f, -0.08203749f, 0.08374806f, -0.10393414f, 0.00491877f, 0.10537852f, 0.03211624f, 
    0.03092552f, 0.04313693f, 0.19367443f, 0.07764636f, -0.17204243f, -0.40472910f, -0.01675358f, 0.26286140f, 
    -0.01710269f, 0.11080585f, -0.06734843f, -0.01537201f, -0.05410910f, -0.09296392f, 0.05425473f, -0.00253217f, 
    -0.04720686f, -0.05568010f, 0.02074727f, -0.16065070f, -0.21313709f, 0.05945070f, 0.04913717f, 0.04422186f, 
    0.09880739f, -0.05495337f, -0.04349886f, 0.09343813f, -0.00008261f, -0.11234403f, 0.24091676f, 0.17140844f, 
    -0.02808015f, 0.01494763f, -0.13290003f, 0.22344138f, 0.19423625f, -0.06323279f, 0.07025030f, -0.03935114f, 
    -0.12162914f, -0.03141046f, -0.22711740f, 0.10897990f, 0.26388812f, 0.10410101f, -0.08802631f, -0.12514772f, 
    -0.18850797f, -0.23180978f, -0.04308257f, -0.16115206f, -0.35061657f, 0.09850632f, -0.38575199f, 0.04482528f, 
    0.23111221f, 0.12290461f, -0.15670636f, -0.28698877f, -0.16700351f, -0.11343748f, 0.06231145f, -0.11370122f, 
    0.03607412f, 0.03314666f, 0.01584529f, -0.02119569f, -0.00991494f, -0.00224788f, 0.02657339f, 0.04341434f, 
    0.05695360f, -0.05337638f, -0.05199806f, -0.03052932f, -0.05373798f, 0.06595688f, -0.05726290f, 0.05402715f, 
    0.01367025f, 0.05689690f, 0.03588620f, -0.02583282f, -0.04197100f, 0.03096481f, -0.06872306f, -0.00731675f, 
    -0.02823853f, -0.01383684f, -0.05604596f, 0.03154318f, -0.05637572f, 0.06118435f, -0.04489232f, -0.06162786f, 
    -0.04647638f, -0.05191344f, -0.00694837f, -0.01777629f, -0.00517151f, -0.03359324f, -0.04594176f, -0.06855189f, 
    0.05050127f, -0.01875691f, -0.01394934f, 0.00696581f, 0.04552951f, -0.05125888f, 0.01847004f, -0.00527560f, 
    0.00308404f, 0.00994986f, 0.01941190f, -0.01506377f, -0.00245311f, -0.04717824f, -0.03960461f, 0.02777040f, 
    0.02748653f, -0.03602802f, 0.03571427f, -0.06865586f, 0.05856897f, -0.01961173f, -0.04298118f, -0.02575338f, 
    0.03156495f, -0.00660233f, -0.03802859f, -0.06663051f, -0.00351019f, -0.03017861f, -0.02447265f, 0.07187887f, 
    0.02903182f, -0.02465232f, -0.03034723f, 0.02267953f, -0.02201335f, 0.00554089f, 0.04906924f, -0.06895588f, 
    0.02114579f, -0.04492891f, 0.02304766f, -0.05108790f, -0.02536027f, 0.06925910f, -0.00465409f, -0.06792551f, 
    -0.04266230f, 0.00029152f, 0.02290697f, 0.03032715f, -0.03323201f, 0.06649932f, -0.07108378f, -0.05315917f, 
    0.03619050f, -0.04165655f, -0.06682520f, -0.04478654f, 0.00432879f, -0.04888644f, 0.03440289f, 0.04959390f, 
    -0.05435008f, 0.04150816f, 0.06864487f, -0.02393572f, 0.00705564f, -0.00638905f, -0.02045247f, 0.02899111f, 
    -0.07065595f, 0.02653289f, 0.03936227f, -0.05391941f, -0.04562324f, 0.02206857f, -0.03024312f, 0.06856955f, 
    -0.02736487f, -0.05127523f, 0.01972224f, -0.05346990f, -0.05197889f, -0.00638343f, 0.01272450f, 0.04697898f, 
    -0.00723168f, -0.06602534f, 0.03784599f, -0.04806546f, 0.03279394f, -0.06294173f, -0.02714290f, 0.01362323f, 
    -0.05753421f, -0.06235979f, 0.01209762f, -0.06060559f, -0.02004463f, 0.03129528f, 0.04824496f, 0.03366831f, 
    -0.03442306f, -0.04244998f, -0.06350788f, 0.04754166f, 0.05930942f, -0.03271328f, -0.03166622f, -0.06064807f, 
    -0.05900417f, -0.00675639f, -0.02837874f, 0.03356616f, 0.04286097f, 0.03316850f, -0.05287457f, -0.06046415f, 
    0.04047595f, -0.01613598f, -0.04596692f, 0.02122313f, -0.06163819f, -0.02221001f, -0.00626637f, -0.05987920f, 
    -0.06914540f, -0.01000206f, 0.01766923f, -0.06702776f, 0.00735676f, -0.01309254f, -0.03521395f, 0.06207618f, 
    -0.00662069f, -0.05036462f, 0.00851040f, 0.05922689f, -0.04969484f, -0.06371258f, 0.06649836f, -0.03658991f, 
    -0.05898618f, -0.03287373f, 0.02124971f, -0.05577423f, 0.05883823f, -0.05661627f, -0.03411081f, 0.06560441f, 
    -0.01937994f, 0.02947636f, 0.03635477f, -0.00083629f, 0.05896722f, -0.00908142f, -0.03301087f, 0.01994698f, 
    0.00060058f, -0.01123867f, 0.03097052f, 0.00265327f, -0.02533343f, -0.04188656f, 0.02312202f, 0.02473202f, 
    0.00030269f, -0.03229931f, -0.02556856f, -0.00437419f, 0.03882262f, 0.03240933f, -0.02497673f, 0.04452778f, 
    -0.06739250f, -0.07015219f, 0.04398888f, 0.01328592f, 0.02461486f, 0.01420313f, 0.00766599f, 0.03243449f, 
    -0.00958442f, 0.04999630f, -0.07132935f, -0.03067969f, -0.05368766f, 0.00789467f, -0.05873416f, -0.09008654f, 
    -0.05340871f, 0.01672958f, -0.08714624f, -0.06156379f, 0.01477585f, -0.01251900f, 0.01653720f, 0.02199043f, 
    -0.01255196f, -0.07010502f, -0.07453135f, -0.08013562f, -0.02301579f, 0.03181619f, -0.07447384f, -0.01617944f, 
    0.03004264f, -0.03822988f, -0.04729063f, -0.06798719f, 0.02324218f, 0.05231573f, -0.01420508f, -0.06983636f, 
    0.04889069f, -0.08033007f, 0.03514761f, -0.02087814f, 0.02558657f, -0.05622839f, -0.03352858f, -0.01547130f, 
    0.03563978f, -0.06422669f, -0.03156872f, 0.01512415f, -0.05093813f, 0.06045040f, 0.03547654f, -0.03345141f, 
    -0.05161220f, -0.02492888f, -0.08232042f, -0.00363646f, -0.04814234f, -0.02720958f, -0.03629248f, -0.03494961f, 
    -0.05200011f, 0.01421508f, -0.05479362f, 0.03549954f, 0.04364759f, -0.02170783f, 0.05205620f, -0.07697995f, 
    0.01982189f, 0.01891926f, 0.01615315f, -0.06673472f, -0.05440301f, 0.04560910f, -0.06950060f, -0.03228861f, 
    0.00893811f, 0.03215262f, -0.07670514f, -0.07289909f, -0.07764396f, 0.02357003f, 0.02679815f, 0.03378210f, 
    -0.00191972f, -0.07980686f, -0.01829373f, 0.04892107f, -0.07740185f, -0.03381777f, 0.03819719f, 0.01307160f, 
    -0.05123607f, -0.02445828f, -0.05176084f, 0.04915237f, -0.02467650f, 0.04724254f, -0.05372328f, 0.00836637f, 
    -0.00337799f, -0.07626557f, -0.00386980f, -0.00178703f, -0.05688034f, 0.06690150f, -0.03148735f, -0.00299723f, 
    0.00475498f, -0.07304031f, 0.00183749f, 0.01381431f, -0.02868896f, -0.01540575f, 0.03221064f, 0.00066906f, 
    0.02418620f, -0.00557256f, -0.00538631f, -0.04070957f, 0.03000937f, -0.06698287f, 0.01328749f, 0.00940749f, 
    0.03668585f, -0.05188999f, -0.00761283f, -0.05242398f, 0.05445971f, 0.03119256f, -0.05834955f, -0.02740878f, 
    -0.07817207f, 0.06097344f, -0.02603687f, -0.04986088f, -0.05494621f, -0.04060932f, 0.03809218f, -0.07690196f, 
    -0.04541946f, -0.07907731f, 0.03324990f, 0.00172040f, -0.04202220f, -0.00053511f, 0.02967007f, -0.01461153f, 
    0.02274640f, -0.07253662f, 0.00767722f, 0.02345145f, -0.05345957f, -0.07960515f, 0.05843356f, -0.04146335f, 
    -0.01226466f, -0.08493705f, -0.01974350f, 0.01743174f, 0.01520246f, -0.04098153f, -0.06807014f, -0.07084361f, 
    0.02681217f, 0.00617492f, 0.01137329f, 0.02205370f, 0.18886955f, 0.14033213f, 0.05584329f, -0.14078565f, 
    0.05959487f, 0.00926724f, -0.16676052f, 0.11833540f, -0.02954951f, -0.14910483f, -0.18311766f, 0.11016276f, 
    -0.06252442f, 0.10903588f, 0.02048320f, 0.06189320f, 0.02909912f, 0.17519794f, 0.05801043f, 0.24754317f, 
    -0.31541455f, 0.06360531f, 0.00264100f, -0.21115905f, 0.05957443f, 0.09731511f, -0.03015117f, 0.09631342f, 
    0.06249385f, -0.11681626f, -0.07807080f, -0.05581876f, -0.03922787f, -0.06749263f, 0.03151196f, -0.42836347f, 
    0.04134576f, -0.01715994f, -0.21180686f, 0.06419548f, -0.11486818f, -0.05925830f, -0.13554136f, -0.05356789f, 
    -0.00941034f, -0.03757832f, 0.03662657f, 0.19455390f, -0.03154504f, 0.10525662f, -0.03225153f, -0.17716838f, 
    -0.02547785f, -0.05801224f, -0.16076504f, 0.37329772f, 0.15654755f, 0.18538736f, 0.05941340f, -0.03006479f, 
    0.08097037f, 0.06158151f, 0.15569998f, 0.06381220f, 0.21517925f, -0.06320263f, -0.00487236f, 0.19736312f, 
    -0.05465631f, -0.12725604f, -0.18426460f, 0.09384473f, -0.15017189f, -0.33727294f, -0.11654101f, -0.31516013f, 
    0.04591259f, -0.03333876f, 0.20165612f, -0.10227750f, 0.08734477f, -0.03503212f, 0.12961996f, 0.13281821f, 
    -0.18033841f, 0.12301280f, -0.04092865f, 0.03338094f, 0.06954331f, 0.11761777f, -0.09567926f, -0.07559638f, 
    -0.23721150f, 0.03288519f, 0.07021170f, 0.02451422f, 0.07415535f, -0.00937396f, 0.05304893f, -0.02270616f, 
    0.05359599f, -0.07027248f, -0.13887434f, -0.14958793f, 0.00767433f, -0.12478796f, 0.30465740f, 0.06027268f, 
    0.09593964f, 0.14117706f, 0.02542828f, 0.07577388f, 0.09732585f, -0.01833376f, 0.11501241f, 0.04779349f, 
    0.07437817f, 0.06758746f, 0.16908805f, 0.17275640f, -0.08567873f, -0.09868895f, -0.18922777f, -0.06956508f, 
    0.08834031f, -0.07895753f, -0.11727537f, -0.12146585f, -0.07959219f, 0.14727826f, 0.16172308f, -0.05937679f, 
    -0.17471126f, -0.12924440f, -0.11061620f, 0.03624943f, -0.01177429f, -0.02866178f, 0.10762640f, -0.01211618f, 
    0.05709515f, -0.20706047f, -0.03077720f, -0.09665415f, -0.07073629f, 0.09315768f, -0.02844750f, 0.01456212f, 
    0.10602611f, 0.05904834f, -0.05080191f, 0.04647287f, 0.41720489f, -0.22914723f, -0.20971251f, 0.10283925f, 
    0.06678996f, -0.11917577f, -0.04120620f, -0.03630765f, -0.04747422f, -0.12699690f, -0.06910960f, 0.09104491f, 
    0.03297354f, 0.14806384f, -0.05031038f, 0.17621011f, -0.08708455f, -0.32968110f, 0.02335449f, 0.03142816f, 
    0.18889157f, 0.04989459f, 0.16123380f, 0.30420455f, -0.04585888f, -0.07068283f, -0.29965422f, -0.01744913f, 
    -0.09390760f, -0.09582807f, 0.01284530f, 0.13838236f, 0.02441783f, 0.07589401f, -0.04831016f, 0.06456080f, 
    -0.12214960f, 0.09341238f, 0.22208861f, 0.15497293f, -0.01377296f, -0.05675659f, 0.15006003f, -0.07395770f, 
    0.00213095f, 0.00764694f, 0.05038666f, 0.04632147f, -0.17777579f, 0.03391341f, -0.09851882f, -0.15148412f, 
    -0.01176074f, 0.17028148f, -0.01412761f, 0.21587901f, -0.16295616f, -0.01905271f, -0.13793655f, 0.00213043f, 
    -0.09809137f, -0.04580519f, 0.04381794f, -0.13381849f, -0.15411980f, 0.05775272f, -0.02885295f, -0.15246564f, 
    -0.02359935f, -0.07209312f, -0.11505701f, 0.00080197f, -0.14900222f, -0.11309378f, 0.14645739f, 0.08588320f, 
    0.07749915f, 0.14664637f, 0.11627249f, 0.05846354f, 0.15006518f, 0.07148777f, 0.31234306f, 0.33474183f, 
    -0.03157013f, 0.10177221f, 0.01017449f, -0.03627874f, 0.05759195f, 0.06088169f, -0.08952813f, -0.03931924f, 
    -0.09387172f, -0.01813343f, -0.14889157f, -0.03602564f, 0.08938546f, -0.10224042f, 0.18533696f, 0.04529080f, 
    -0.11776425f, 0.10279460f, 0.05892609f, -0.10253301f, 0.05175690f, 0.00644227f, 0.03001684f, -0.04992097f, 
    -0.04166113f, -0.22470587f, 0.09184182f, -0.05020078f, -0.08938201f, 0.04824864f, -0.08880852f, -0.07670718f, 
    0.23852031f, -0.09648600f, -0.12326709f, 0.05884301f, -0.12991947f, 0.36927286f, -0.27096453f, -0.39247027f, 
    0.02759810f, 0.10068005f, 0.02179571f, 0.14067961f, -0.04829844f, 0.11589562f, 0.10619136f, -0.24169645f, 
    -0.25301337f, 0.05817617f, 0.05001932f, 0.27876398f, 0.07454532f, -0.16673219f, 0.11971466f, 0.21943551f, 
    0.21040392f, 0.00567083f, -0.08386020f, -0.07390042f, 0.12815335f, 0.06930009f, 0.22300997f, 0.21693096f, 
    0.10891944f, -0.08424702f, 0.06655051f, 0.07432151f, 0.01289936f, 0.03973229f, 0.02192960f, 0.02407927f, 
    0.09576982f, 0.15366115f, -0.07959968f, 0.19066438f, 0.09096961f, 0.05667030f, 0.01697452f, 0.06360839f, 
    0.04501938f, 0.22115321f, -0.01298076f, 0.10017932f, 0.02715053f, -0.07125489f, 0.03514964f, 0.10751297f, 
    0.15012753f, 0.10739812f, 0.02910340f, 0.04442582f, 0.07759601f, 0.05274737f, -0.02805889f, 0.07820380f, 
    0.29035518f, -0.38069403f, 0.11680698f, 0.14308354f, -0.02490959f, 0.05169160f, -0.06453490f, -0.11835624f, 
    0.02917902f, 0.00165809f, 0.09141374f, -0.03957887f, 0.00683760f, -0.05229656f, 0.21673830f, 0.19110467f, 
    0.13747643f, -0.01133556f, -0.15334207f, 0.35472429f, 0.15960240f, -0.20535401f, -0.18320149f, 0.21035954f, 
    0.01296592f, 0.15189157f, -0.28570828f, 0.01571608f, -0.03728916f, 0.02746891f, -0.01586807f, 0.10201812f, 
    -0.08746323f, -0.17351891f, -0.00018744f, -0.04686840f, -0.33932593f, 0.32787085f, 0.37214541f, -0.17092000f, 
    -0.08835746f, 0.05704060f, -0.02688789f, 0.01400218f, 0.05233225f, -0.12086808f, 0.16426432f, 0.16633077f, 
    -0.07026790f, 0.02342716f, -0.19755727f, -0.13925326f, 0.04905966f, 0.12589596f, 0.02025982f, 0.03465712f, 
    -0.00661490f, 0.00804704f, -0.02896083f, -0.00127558f, 0.08567956f, -0.06819305f, 0.10224117f, 0.06028811f, 
    0.21649565f, 0.02742969f, -0.03155500f, -0.01767942f, -0.20915365f, 0.00573323f, -0.01336765f, -0.07598682f, 
    -0.32777268f, -0.17272347f, 0.05997484f, 0.17074566f, 0.28809208f, -0.06050565f, 0.04068733f, -0.19941539f, 
    -0.05271997f, 0.08514499f, -0.01576911f, -0.02539647f, -0.06901073f, -0.00483192f, -0.12740125f, 0.00409148f, 
    0.01950390f, -0.00368096f, 0.00083076f, -0.12580281f, -0.04356531f, 0.07122917f, -0.00716624f, -0.03294846f, 
    -0.02981952f, 0.08270767f, 0.15090254f, -0.04451923f, -0.07426739f, 0.12852353f, 0.06207182f, -0.11023648f, 
    -0.03075768f, -0.00133026f, 0.08011414f, -0.07254324f, -0.11727400f, 0.46287420f, -0.22843786f, 0.40318280f, 
    0.07231767f, 0.01506149f, -0.05260092f, 0.07416686f, -0.04875442f, 0.03130762f, -0.01935963f, 0.04828463f, 
    -0.29278696f, 0.12521133f, 0.00946312f, 0.27852228f, -0.02230254f, -0.07929081f, -0.03881109f, 0.08645595f, 
    -0.05753136f, 0.12411279f, -0.05745803f, -0.13045625f, -0.25630423f, 0.24443103f, 0.00020923f, 0.34812948f, 
    0.00563756f, 0.11848754f, 0.21223195f, -0.12629619f, 0.07502139f, 0.05742962f, -0.02420495f, -0.04359942f, 
    -0.22326219f, 0.10266066f, 0.09067136f, 0.16428110f, 0.09775182f, 0.09532356f, 0.02866585f, -0.06044539f, 
    -0.12025188f, -0.02232090f, 0.17790763f, 0.04551449f, -0.26283300f, 0.03274160f, 0.19799495f, -0.02235796f, 
    -0.07319830f, -0.06368588f, 0.11445260f, -0.11944515f, 0.03570623f, 0.01405443f, 0.14817998f, 0.03129220f, 
    0.10610351f, -0.08765952f, -0.07359734f, -0.04834662f, -0.00880731f, -0.08601033f, -0.01880487f, -0.01569988f, 
    0.02648734f, 0.00501319f, -0.09456325f, -0.10582975f, -0.05535350f, -0.04338419f, 0.11778083f, -0.09336093f, 
    0.03445015f, -0.06910636f, -0.08628023f, 0.06386080f, 0.19711582f, 0.13715117f, 0.00340914f, 0.17383100f, 
    -0.29375783f, 0.29516792f, -0.00445091f, 0.17202267f, 0.08540288f, 0.07211829f, 0.02333706f, 0.06032192f, 
    0.08690181f, 0.03287245f, 0.01050519f, 0.07820380f, 0.24017249f, -0.09475923f, 0.52057481f, -0.14261054f, 
    -0.03589918f, -0.17927700f, -0.00297064f, -0.13963421f, -0.19589116f, -0.06867982f, -0.00022991f, 0.00599827f, 
    0.21801096f, 0.04616813f, 0.11703504f, -0.06890827f, -0.01627576f, 0.00675106f, 0.05492042f, -0.00361781f, 
    -0.11822347f, 0.13363214f, -0.02657478f, 0.01130419f, 0.43389487f, -0.26266328f, 0.16144447f, -0.02698195f, 
    0.06636583f, -0.11450180f, 0.05971343f, 0.08784760f, 0.09645472f, 0.06736436f, 0.14920732f, 0.00797111f, 
    0.14393885f, 0.11285882f, -0.09451961f, -0.21904068f, 0.21030469f, -0.04848826f, -0.01863779f, -0.02399047f, 
    -0.02278507f, -0.10784225f, -0.09398796f, 0.01203384f, -0.05873474f, -0.10739636f, -0.01775227f, 0.04625186f, 
    0.08939750f, 0.01216609f, -0.15423651f, 0.02544989f, -0.20557132f, 0.02818743f, -0.10325831f, 0.04078102f, 
    -0.20413832f, -0.15886521f, 0.03578325f, -0.07386786f, 0.03751747f, -0.10064089f, -0.09020149f, -0.18286639f, 
    -0.03233030f, -0.12649995f, -0.09883631f, -0.03080461f, -0.06051049f, -0.01751857f, -0.22715420f, -0.08570582f, 
    0.01021792f, 0.04768313f, 0.15473169f, 0.00029176f, -0.06461625f, 0.01535057f, 0.06029395f, -0.12388049f, 
    -0.00875633f, 0.11654626f, 0.00800117f, -0.16759041f, -0.13325036f, 0.12522066f, -0.00325410f, -0.22735463f, 
    -0.06695064f, -0.07428089f, 0.00010783f, 0.01932306f, -0.05946911f, 0.27212772f, 0.00769089f, 0.32334638f, 
    0.00212619f, 0.12932721f, 0.03566723f, 0.03486415f, 0.10080694f, -0.10609143f, 0.04704696f, 0.05732063f, 
    -0.24088469f, 0.07391620f, -0.01544387f, 0.29119486f, -0.03936367f, 0.06714695f, -0.04034468f, 0.18731746f, 
    0.01834756f, 0.14856951f, -0.07612156f, -0.01464810f, 0.11906004f, 0.25514352f, -0.01671885f, 0.35865226f, 
    -0.21833900f, 0.08276848f, 0.25118229f, -0.25524428f, 0.12540489f, 0.07062408f, 0.03644677f, 0.02138500f, 
    0.24917860f, 0.12005129f, 0.16870578f, 0.00120122f, -0.00006933f, 0.00875460f, 0.29311213f, -0.08062135f, 
    0.08417461f, -0.12035871f, 0.06143032f, -0.04352454f, 0.03043617f, 0.16320014f, 0.01636564f, -0.21823788f, 
    0.05877675f, 0.03726842f, -0.00298201f, -0.10584646f, 0.03537412f, 0.03156456f, 0.03679303f, 0.04929068f, 
    0.12021045f, -0.08493923f, -0.12982218f, -0.02298925f, 0.01392312f, -0.09703187f, -0.00416053f, 0.07748059f, 
    0.00078685f, 0.10207164f, 0.06304725f, -0.04876260f, -0.03726562f, -0.04171615f, 0.22116087f, -0.07585420f, 
    0.10625386f, 0.04368348f, 0.04492003f, 0.04248527f, 0.18690787f, 0.10245129f, -0.00890517f, 0.02866197f, 
    -0.19710016f, -0.11129892f, -0.08227224f, 0.20554228f, 0.00768968f, 0.05631233f, 0.08106168f, 0.04161055f, 
    0.22398709f, 0.06401990f, 0.09463282f, 0.12041634f, 0.36692709f, -0.10923792f, 0.25827810f, -0.16431619f, 
    0.03812885f, -0.20633854f, 0.03113649f, -0.02897694f, -0.15103854f, -0.17016719f, -0.02700769f, 0.08309484f, 
    0.11023036f, -0.05869883f, -0.10253135f, 0.07171541f, -0.02566348f, 0.02190956f, 0.13026333f, -0.01983988f, 
    -0.07157382f, 0.09807701f, 0.14882283f, 0.10555651f, 0.28400123f, -0.39444694f, 0.05317669f, 0.00164532f, 
    0.09645903f, -0.02659471f, 0.02945836f, -0.01124838f, 0.08224174f, 0.02117933f, 0.08229011f, -0.11258832f, 
    0.19048235f, 0.16125883f, 0.19164303f, -0.13605277f, 0.14368528f, 0.00085682f, 0.01195623f, -0.02279481f, 
    0.06059111f, -0.02133178f, 0.02723507f, 0.05458526f, -0.19524837f, -0.03878581f, -0.13518082f, -0.05604763f, 
    0.00951222f, 0.17407198f, 0.15818676f, 0.19646952f, 0.04720818f, 0.09150063f, -0.00993278f, 0.16155127f, 
    0.20453423f, 0.35843772f, -0.01594483f, -0.40278006f, -0.19016644f, 0.16091438f, -0.09380311f, 0.17816533f, 
    0.18288867f, 0.00759864f, 0.02871178f, 0.11758192f, 0.16376799f, -0.19033539f, 0.17436977f, -0.18664928f, 
    0.03950361f, 0.03121366f, -0.07658107f, 0.02489956f, 0.01083591f, 0.00544233f, 0.08699318f, 0.02511752f, 
    0.17822333f, 0.15109181f, 0.12074819f, -0.01908935f, 0.00134696f, 0.04808586f, 0.12833409f, -0.02721669f, 
    0.09520117f, -0.02257400f, -0.00201198f, 0.04282156f, 0.16501036f, -0.26793340f, 0.22529167f, -0.21953604f, 
    -0.06549688f, 0.13536265f, 0.05953638f, -0.06885476f, 0.01280011f, -0.12149996f, 0.07459585f, 0.12308145f, 
    0.10707603f, -0.25375330f, -0.03337990f, -0.05991451f, -0.07809041f, -0.08187557f, -0.09280865f, -0.00791205f, 
    0.13681997f, -0.10722199f, 0.04173299f, -0.00040903f, 0.15821083f, -0.29683021f, -0.02989238f, -0.26011878f, 
    -0.00832879f, 0.12156199f, -0.01550333f, 0.28469020f, 0.14026026f, 0.15509725f, -0.06838958f, 0.02829951f, 
    0.01732577f, 0.03078542f, 0.33376276f, -0.06959501f, -0.05597603f, -0.12340566f, 0.06602227f, 0.05400600f, 
    0.17240696f, -0.09056435f, -0.08713751f, 0.14117150f, 0.37819138f, 0.32823306f, 0.10761594f, -0.20570727f, 
    0.05485409f, 0.06362883f, -0.01621742f, 0.18794343f, 0.06071115f, 0.08844416f, 0.03921869f, 0.07496154f, 
    -0.37102774f, -0.26953003f, -0.05732910f, 0.23767270f, 0.12089840f, 0.08670934f, -0.11489210f, 0.04669316f, 
    -0.11811529f, -0.01561415f, -0.03315891f, 0.07032089f, -0.23028398f, -0.19198935f, 0.03105860f, 0.24251629f, 
    -0.06250247f, 0.01173869f, -0.03385035f, 0.02055637f, -0.04830194f, -0.07370903f, -0.02871058f, 0.05061876f, 
    0.23342378f, -0.39791998f, 0.11511371f, -0.06538560f, -0.05046724f, -0.05701646f, -0.04292319f, 0.01817254f, 
    0.07256555f, 0.11807107f, -0.02101831f, 0.03739022f, -0.10846431f, 0.05262488f, -0.43411341f, 0.27418190f, 
    0.28849217f, 0.10532662f, -0.05532784f, 0.13450427f, 0.08723626f, -0.08975533f, -0.10060651f, -0.10019661f, 
    -0.17491183f, -0.04963621f, -0.37090474f, 0.12178237f, 0.10941999f, -0.03152582f, -0.01950187f, 0.06756846f, 
    0.15606494f, 0.01044164f, -0.10502769f, 0.17031227f, -0.33406001f, 0.16706139f, -0.45719853f, -0.37416559f, 
    -0.01738097f, 0.00340287f, -0.12227985f, -0.01051989f, -0.05203506f, 0.01285554f, -0.07520423f, -0.07635123f, 
    -0.07814214f, 0.27245063f, 0.12410200f, -0.22805689f, -0.06179887f, 0.17375831f, 0.06932490f, 0.01594190f, 
    -0.14379472f, 0.03559796f, 0.06078744f, -0.14359246f, 0.06794937f, -0.11376176f, 0.01182509f, -0.14143345f, 
    0.12207606f, -0.05203531f, 0.06243195f, 0.24459450f, -0.03153619f, -0.00492153f, -0.07620332f, -0.12975018f, 
    0.16881643f, -0.05006767f, 0.24934629f, 0.24138147f, 0.01367551f, -0.15860808f, 0.04382771f, -0.03074927f, 
    -0.07018663f, 0.01899984f, 0.06157703f, 0.02212337f, -0.04438187f, 0.00007059f, 0.08736151f, 0.42475387f, 
    0.00725933f, -0.17940255f, -0.00246325f, 0.05655294f, 0.13280901f, 0.21711130f, 0.17014848f, 0.19544955f, 
    -0.24965777f, 0.13543253f, -0.01404407f, -0.33248976f, -0.00804795f, -0.00456741f, 0.08019949f, 0.11012385f, 
    0.01370561f, -0.02225943f, 0.00540525f, -0.13903253f, -0.19290625f, -0.20430978f, -0.15990333f, 0.29815426f, 
    0.10638606f, 0.09650277f, 0.01383561f, 0.02704635f, -0.05397797f, 0.03517935f, 0.09037475f, 0.01918588f, 
    -0.18235992f, 0.07806936f, 0.02160815f, 0.12335109f, 0.06124305f, -0.03001599f, 0.03970028f, 0.15712719f, 
    -0.10980624f, 0.02977348f, 0.05497392f, 0.13258818f, -0.14867671f, 0.02110527f, -0.20271225f, -0.19544823f, 
    0.18045400f, 0.06336419f, 0.20334800f, -0.08865990f, 0.07123089f, 0.02535921f, 0.00538637f, 0.01550615f, 
    -0.05716633f, -0.29219410f, 0.23833914f, 0.28823540f, 0.06957655f, -0.15619890f, -0.05464170f, 0.00237746f, 
    0.11656020f, -0.04063777f, 0.15557092f, -0.12037097f, -0.26325765f, 0.11455525f, -0.24131040f, -0.26395690f, 
    -0.00189221f, -0.22008090f, 0.07535272f, -0.02192535f, -0.00012993f, 0.03069721f, -0.02891555f, -0.07588357f, 
    -0.03239757f, -0.01126324f, -0.16766761f, 0.09188868f, 0.09003023f, 0.00427357f, -0.04959819f, 0.08186325f, 
    -0.13315460f, 0.01152377f, 0.02168262f, 0.08518146f, -0.05112605f, -0.18100314f, -0.10525736f, 0.13021475f, 
    0.06756396f, 0.01512060f, -0.01281684f, 0.01668928f, 0.22319783f, 0.17898391f, -0.07610062f, -0.03045455f, 
    -0.20715655f, 0.52896428f, 0.09317198f, 0.30690062f, -0.02971752f, -0.03029731f, 0.07930004f, -0.05832860f, 
    -0.00252997f, 0.01053679f, 0.13330215f, 0.06200427f, -0.21924816f, -0.16029792f, 0.12478570f, -0.24838856f, 
    0.03101324f, 0.17145996f, 0.01412506f, 0.00177691f, -0.01042746f, -0.11323079f, 0.02785724f, 0.12174170f, 
    0.03387495f, -0.22266875f, -0.15955909f, -0.25127313f, 0.06933499f, 0.18136959f, 0.02860704f, 0.04751951f, 
    -0.06241234f, -0.03423394f, -0.07385380f, -0.24177758f, 0.45697439f, 0.01910339f, 0.19808373f, -0.23760086f, 
    0.15105733f, -0.08667266f, -0.07324507f, -0.00392935f, 0.11177390f, 0.05027150f, -0.01915289f, 0.07104848f, 
    0.04452708f, -0.34762487f, -0.53998232f, -0.50300801f, 0.17428507f, 0.06941142f, 0.09050807f, 0.11508256f, 
    0.11613384f, 0.08305796f, 0.26427409f, 0.16117799f, 0.03610184f, -0.10704190f, -0.08910462f, -0.00641869f, 
    0.22488467f, 0.16250896f, -0.06246671f, -0.03905081f, -0.14334132f, 0.04940475f, -0.08560253f, -0.12666591f, 
    -0.33522084f, -0.01031598f, -0.52696621f, -0.24065541f, 0.16866359f, 0.12524697f, 0.16805257f, 0.08026718f, 
    0.02608129f, -0.05820896f, -0.09394513f, -0.16800980f, -0.03811044f, -0.42272305f, 0.02689880f, -0.02151538f, 
    -0.03144524f, 0.06689616f, 0.03353539f, -0.05675486f, -0.01008810f, 0.08221295f, -0.12865487f, 0.19057958f, 
    0.00721485f, -0.40531209f, -0.14501216f, -0.01460877f, 0.12884875f, 0.14955178f, 0.02066490f, 0.04434821f, 
    -0.07698534f, -0.11655665f, 0.00863981f, 0.02326851f, 0.16704200f, 0.32261977f, -0.13245428f, 0.22638237f, 
    -0.00851775f, 0.00451804f, -0.07761798f, -0.09173811f, -0.03280524f, 0.15554819f, -0.10923374f, 0.14218174f, 
    -0.00330410f, 0.11639112f, -0.00572855f, 0.22651035f, -0.00543569f, 0.05139375f, -0.06522898f, -0.13348508f, 
    -0.06393360f, 0.00888905f, 0.03732653f, -0.09097192f, -0.13138986f, -0.05221839f, -0.12331039f, -0.06880619f, 
    -0.02060777f, 0.11322227f, 0.08605976f, -0.01773064f, 0.12194021f, -0.09529395f, 0.04181629f, -0.04453688f, 
    -1.12934470f, 0.31253472f, -0.52740312f, -0.40609708f, 0.32984439f, 0.38759923f, 0.08692684f, -0.00667467f, 
    -0.02714865f, -0.01945970f, -0.03446557f, -0.04182155f, 0.06292859f, 0.37803683f, -0.13618936f, -0.48861042f, 
    -0.01285284f, -0.11336483f, -0.06776068f, 0.15613829f, 0.03517834f, 0.03621211f, 0.08670683f, 0.00131098f, 
    0.06074221f, 0.06264689f, 0.21046245f, 0.22762586f, -0.00334948f, 0.03595132f, -0.05870813f, -0.05414695f, 
    0.10302604f, 0.03932622f, 0.09471237f, 0.19852205f, -0.05867736f, 0.26851541f, 0.14408484f, 0.32323989f, 
    -0.04615609f, -0.17299382f, -0.01570625f, 0.00936144f, 0.14695418f, 0.15474878f, 0.12747934f, 0.18371631f, 
    -0.05929185f, 0.10373523f, 0.23263453f, -0.01768080f, 0.14673705f, -0.06185044f, -0.03016415f, -0.01251201f, 
    -0.20057206f, -0.19216278f, 0.09395833f, -0.00757802f, 0.34205639f, 0.23517497f, 0.36324555f, 0.33455142f, 
    0.05653309f, -0.05174962f, -0.08190301f, -0.02248356f, -0.07733271f, -0.21173878f, -0.18977752f, -0.01671899f, 
    0.24787891f, 0.05717210f, 0.12086607f, 0.15487510f, -0.08334284f, 0.01087217f, 0.05346090f, -0.03589343f, 
    -0.12878171f, -0.06945295f, -0.10967363f, -0.10415764f, 0.18249545f, -0.11752895f, 0.11183693f, -0.13753822f, 
    -0.00685956f, -0.08212598f, 0.02564159f, 0.14756219f, 0.22667712f, -0.03641698f, 0.12605394f, 0.01642010f, 
    -0.05097901f, 0.09895839f, 0.06225557f, -0.20630702f, 0.11152330f, 0.09222320f, 0.08552653f, -0.04798241f, 
    0.14473474f, -0.11096986f, 0.14533819f, 0.15562783f, -0.11773048f, -0.00351853f, -0.00584550f, -0.03029392f, 
    0.22443776f, 0.06057869f, -0.16584837f, -0.04180769f, -0.16554132f, 0.06940177f, 0.02657963f, 0.00611666f, 
    -0.12635846f, -0.42612755f, 0.00216694f, -0.03992237f, -0.13215843f, -0.03725378f, -0.17592360f, -0.06146495f, 
    -0.04361882f, -0.00569495f, -0.04888369f, -0.05679685f, 0.09206787f, 0.02239342f, -0.06792465f, 0.05520295f, 
    0.10375384f, -0.00957009f, 0.20943245f, 0.25858897f, 0.12856400f, -0.08218644f, -0.10666576f, -0.06242645f, 
    -0.13139658f, 0.02568456f, -0.12211074f, -0.27871996f, -0.15294966f, -0.04750345f, 0.05939137f, -0.01655545f, 
    -0.03141059f, -0.06001760f, -0.10102008f, 0.09752520f, 0.00778367f, -0.03102472f, 0.08600017f, 0.18322432f, 
    -0.08731333f, -0.07585109f, -0.09263825f, 0.08048037f, 0.32673720f, -0.03665608f, 0.00400682f, 0.04901100f, 
    -0.25867632f, 0.05521354f, -0.01208014f, 0.10942850f, -0.00198058f, -0.08138405f, 0.01407770f, 0.00280729f, 
    0.06671061f, 0.12260622f, -0.01053717f, 0.21846291f, 0.31369489f, 0.16394775f, -0.09097359f, -0.02716591f, 
    0.00070632f, -0.12945405f, -0.01311974f, -0.01839180f, 0.18854183f, 0.06775076f, 0.12967788f, 0.11788271f, 
    -0.01363805f, 0.12459998f, 0.34561253f, 0.08118656f, -0.06720006f, -0.23394233f, 0.13733108f, -0.03539133f, 
    0.01351244f, -0.10228419f, -0.13591975f, 0.06060858f, 0.05781879f, 0.18385433f, -0.08384714f, -0.03346647f, 
    0.08762434f, 0.04742075f, 0.01409171f, -0.04401712f, 0.06454253f, 0.01678963f, 0.11302478f, -0.02654422f, 
    0.32272956f, 0.07269060f, -0.19281650f, -0.07486758f, 0.00490726f, -0.12900427f, -0.08781890f, -0.03538949f, 
    -0.18106689f, -0.02834993f, 0.05870475f, 0.01400861f, 0.13610242f, -0.19670254f, -0.04272990f, -0.01442411f, 
    0.10303422f, -0.20652439f, -0.16827980f, -0.01160394f, 0.06217325f, -0.07825616f, -0.11877265f, 0.08854923f, 
    -0.19688860f, 0.42105833f, -0.12077345f, 0.11443515f, -0.09368524f, 0.03638259f, 0.07679947f, 0.03196137f, 
    0.10271364f, 0.13078687f, -0.04325425f, 0.23800249f, -0.04832770f, 0.07023203f, 0.00029772f, 0.01609310f, 
    0.14803009f, 0.02429317f, -0.11439812f, -0.22461067f, -0.02296844f, -0.08657562f, -0.13155930f, -0.01211149f, 
    -0.00466368f, 0.00512035f, 0.06099794f, 0.11294320f, -0.02123944f, -0.05474586f, -0.09588691f, -0.06238812f, 
    0.17751583f, 0.15327686f, 0.05337825f, 0.19617243f, 0.19127914f, 0.11240644f, -0.00901611f, -0.18462892f, 
    0.20618877f, -0.08177773f, -0.06061851f, 0.17596297f, 0.20122635f, 0.07098322f, 0.07114469f, -0.10840455f, 
    -0.03914825f, -0.04608016f, 0.01007912f, -0.05151622f, -0.02626742f, -0.05319870f, -0.06747111f, -0.00108006f, 
    -0.02567699f, -0.06258600f, -0.01820712f, -0.02747096f, -0.06368026f, -0.01722498f, 0.06608367f, 0.05544730f, 
    0.01779882f, -0.00546615f, -0.04948639f, 0.02386608f, -0.04995601f, -0.02627534f, -0.03372715f, 0.03954411f, 
    0.01961488f, -0.00015447f, 0.02645160f, -0.02371127f, 0.05264901f, 0.05209767f, -0.03393855f, -0.02987195f, 
    0.01113678f, 0.04800474f, -0.05771462f, 0.00810469f, 0.04244037f, -0.07757541f, -0.03390063f, -0.07468121f, 
    -0.05112779f, -0.00522828f, 0.06116587f, 0.00134650f, -0.01947634f, 0.03926226f, 0.01305818f, -0.00595353f, 
    0.01705085f, 0.01867166f, -0.02798138f, -0.07671502f, 0.06401557f, -0.03391092f, 0.06250670f, -0.06144670f, 
    0.02912119f, -0.03973318f, -0.04246785f, -0.06142681f, 0.00251959f, -0.01786586f, -0.07843333f, 0.03794322f, 
    -0.07419982f, 0.03475995f, -0.01291721f, -0.00862911f, -0.04318698f, 0.06305572f, -0.04161951f, -0.05941242f, 
    -0.04819482f, -0.02318940f, 0.00450486f, 0.05649090f, -0.05034251f, 0.04938475f, -0.00229575f, -0.04119454f, 
    -0.01033307f, 0.01871381f, -0.02040487f, -0.00245296f, 0.06367642f, -0.05294213f, -0.01227802f, -0.02174626f, 
    -0.03020563f, 0.00083294f, 0.05176634f, -0.01409274f, -0.00756212f, -0.05646419f, 0.03479696f, 0.01971586f, 
    0.00252850f, -0.06323003f, 0.02405036f, 0.00605662f, 0.01892740f, 0.03566621f, -0.05197663f, -0.01907703f, 
    0.03433313f, -0.03632767f, 0.01733010f, -0.00743546f, -0.04258635f, -0.05028311f, -0.03712949f, -0.00573144f, 
    0.00238575f, -0.01924560f, -0.00332369f, -0.05789460f, -0.03771754f, -0.04216943f, 0.05734847f, -0.07657092f, 
    -0.00351158f, 0.04569403f, 0.00070295f, 0.05960557f, 0.05411512f, -0.01242131f, 0.05457251f, 0.04767102f, 
    -0.02226041f, 0.00162161f, 0.03245771f, 0.06599959f, -0.04979492f, -0.05143946f, -0.01839674f, -0.00768442f, 
    -0.01340381f, -0.07836667f, -0.05639260f, 0.01525633f, 0.01674345f, 0.03536511f, -0.04406974f, 0.01935585f, 
    -0.01484444f, 0.06519879f, -0.02649268f, -0.04628797f, -0.02750361f, 0.05180980f, -0.00850240f, -0.01343627f, 
    -0.01243747f, -0.02134123f, 0.00847573f, -0.07326567f, -0.05681258f, 0.05181262f, -0.01237341f, -0.05917383f, 
    0.01436947f, -0.07699982f, -0.04790703f, 0.02850666f, -0.03903535f, -0.06786172f, -0.00918798f, -0.00231797f, 
    -0.04154884f, -0.06408215f, -0.05221646f, 0.00437404f, 0.01002096f, 0.00870488f, 0.05171578f, 0.01031324f, 
    0.01939311f, 0.03976258f, 0.00299680f, -0.02410339f, -0.04928517f, -0.04834221f, -0.02615844f, -0.06143620f, 
    0.00653766f, 0.03760390f, 0.01754121f, 0.04591589f, 0.02312204f, 0.00853141f, 0.04513310f, 0.02418513f, 
    -0.09375629f, -0.17726968f, -0.03424902f, 0.09007693f, 0.01078237f, 0.05660872f, 0.10796992f, 0.09164429f, 
    0.14773299f, 0.20408891f, 0.05210564f, 0.03749052f, -0.04187652f, -0.00785463f, -0.14759651f, -0.13211484f, 
    -0.15240788f, -0.01696513f, 0.16676030f, 0.06586635f, -0.02328596f, -0.09364560f, -0.02881847f, -0.06944513f, 
    -0.21061374f, -0.08646417f, 0.10980681f, 0.01669105f, -0.09230619f, 0.04817407f, 0.12204856f, 0.07078560f, 
    0.04416259f, 0.07458857f, -0.05437884f, 0.02410800f, -0.11282679f, -0.02721512f, 0.28952342f, -0.06581468f, 
    -0.00155288f, -0.01610889f, -0.02467117f, 0.07228981f, 0.20428450f, 0.00051026f, -0.08529721f, 0.00783417f, 
    -0.21168026f, -0.08644174f, 0.07734670f, 0.10569198f, -0.10514349f, -0.12567092f, -0.10040906f, 0.12598504f, 
    0.02998911f, -0.00142551f, -0.02588919f, 0.03967547f, 0.16952521f, -0.15123951f, 0.13702604f, -0.15294534f, 
    0.15782252f, 0.03137123f, 0.07047480f, 0.03265409f, -0.08746215f, 0.08467354f, -0.03438513f, -0.05552379f, 
    0.20453849f, -0.10851746f, 0.05446618f, -0.20399317f, -0.11132044f, -0.06024058f, -0.06772701f, -0.12665452f, 
    0.00590182f, -0.29280677f, 0.01008703f, -0.01458627f, -0.19565482f, -0.06406403f, 0.03823366f, -0.10310685f, 
    0.12807584f, 0.14489894f, -0.07262670f, 0.05202494f, -0.06618458f, 0.08111219f, 0.01890600f, -0.06415630f, 
    -0.21279909f, -0.11209231f, -0.18655367f, 0.03883548f, 0.02784686f, 0.09512904f, -0.15520053f, 0.07151488f, 
    -0.00840012f, 0.19522484f, 0.13696569f, 0.13304873f, -0.12390317f, -0.21866013f, 0.18525399f, 0.40538383f, 
    0.03364731f, -0.03512778f, 0.08007897f, 0.09078134f, 0.01364448f, -0.00135828f, 0.06080660f, 0.01657185f, 
    0.12708671f, 0.21447261f, 0.17910329f, 0.06064189f, -0.07775965f, -0.00511222f, 0.00533400f, -0.00629996f, 
    0.16949932f, 0.11379760f, -0.04844441f, 0.02991480f, 0.20477086f, 0.17266488f, -0.02309505f, -0.02635993f, 
    -0.05586367f, 0.04718132f, 0.06504477f, -0.12498522f, -0.08372388f, 0.13164365f, 0.13706893f, 0.08526928f, 
    0.36762807f, 0.10430694f, 0.26619744f, 0.07172868f, -0.07139920f, 0.00629062f, 0.00853058f, -0.11739556f, 
    -0.03094810f, 0.04334116f, -0.02697619f, 0.02044571f, 0.12508409f, 0.08617904f, -0.07739078f, 0.21132590f, 
    -0.06444562f, -0.04522643f, 0.12641801f, 0.07539257f, 0.15827528f, 0.12569289f, 0.06706259f, -0.01629951f, 
    -0.07216100f, 0.20955296f, -0.02068035f, 0.07208020f, -0.14762416f, 0.04442176f, -0.03599560f, 0.11574255f, 
    0.06207606f, -0.09302081f, -0.14242405f, -0.09992667f, -0.25598878f, 0.42603114f, 0.02126464f, -0.13571763f, 
    -0.03638635f, 0.02738165f, 0.30468324f, 0.06570013f, -0.02482895f, 0.11271335f, 0.02182923f, 0.07756004f, 
    0.02269499f, -0.02728832f, 0.01626131f, -0.02941659f, 0.05856086f, -0.04722387f, -0.00694695f, 0.04625646f, 
    -0.01637105f, 0.01481541f, 0.02806388f, 0.01808793f, -0.05617222f, 0.01388011f, 0.06016469f, 0.03718295f, 
    -0.04725711f, -0.05415218f, 0.05069292f, 0.06146471f, -0.06104609f, 0.04463887f, 0.03442247f, 0.01721951f, 
    0.04880023f, -0.01224805f, 0.00912589f, 0.00244201f, 0.02019128f, -0.03677048f, 0.05521096f, -0.02213698f, 
    0.03906066f, -0.01436304f, -0.04731541f, -0.04934227f, -0.07526030f, -0.00990619f, -0.02338308f, -0.06298538f, 
    0.02102323f, -0.06406035f, -0.03061445f, -0.01997825f, -0.00574540f, -0.06825079f, 0.02659687f, -0.01102317f, 
    -0.04569065f, 0.05351919f, -0.08027054f, -0.00903784f, 0.06071750f, 0.02905904f, 0.02969842f, 0.01756624f, 
    0.00517425f, 0.05362865f, -0.02169558f, 0.04207528f, 0.01220071f, -0.07939706f, -0.03676591f, -0.01731057f, 
    -0.02169728f, -0.04429572f, 0.05955219f, 0.00610395f, -0.03491564f, 0.03442155f, -0.03024632f, -0.05445272f, 
    -0.03597966f, 0.00802226f, -0.05320433f, -0.06579240f, -0.02000798f, -0.05485573f, -0.07726677f, 0.05177476f, 
    0.00532278f, -0.07840880f, -0.08013129f, -0.07269749f, 0.05347076f, 0.00253156f, 0.05789533f, -0.05570564f, 
    0.00543531f, 0.02207920f, 0.02235034f, 0.02179242f, -0.07221004f, -0.06114662f, 0.04420985f, -0.01944011f, 
    -0.02240063f, -0.03043815f, 0.06014343f, 0.04185147f, -0.05094896f, -0.05113580f, -0.02697957f, -0.00760515f, 
    -0.05836276f, -0.02813884f, -0.02137539f, -0.00680695f, 0.02909563f, -0.07172357f, 0.03267665f, -0.01211237f, 
    -0.06786214f, -0.00663640f, -0.00499575f, -0.07210392f, -0.05092094f, 0.05426459f, -0.07944270f, -0.00103323f, 
    -0.03495578f, -0.05731443f, -0.06882722f, 0.04178957f, 0.03214378f, 0.03830021f, 0.00276089f, -0.00201922f, 
    0.02975336f, -0.04650612f, 0.06371021f, -0.03668130f, -0.00506108f, -0.00231633f, 0.00946167f, -0.02743337f, 
    -0.03202944f, 0.01424171f, 0.02822986f, 0.04993088f, 0.01167925f, 0.04736308f, 0.00749953f, 0.06107872f, 
    -0.04720492f, -0.04416839f, 0.04383917f, -0.06395296f, -0.00823531f, -0.05102791f, -0.06742780f, -0.05426557f, 
    -0.03617131f, -0.05528167f, -0.06347143f, 0.02383146f, -0.06336741f, -0.00804299f, -0.04885672f, 0.03071512f, 
    -0.08051978f, -0.00380088f, 0.01135578f, 0.04795855f, 0.01014720f, -0.02596265f, -0.01626577f, -0.05669351f, 
    0.04848117f, 0.00395600f, 0.01247746f, -0.02471153f, 0.01080756f, 0.02637056f, 0.05100542f, 0.03530705f, 
    0.05217241f, 0.01524969f, -0.01596067f, -0.07366011f, -0.00748984f, 0.00468565f, -0.04695481f, 0.04716188f, 
    0.04670017f, -0.03562130f, -0.04770907f, -0.06944081f, -0.04440028f, 0.01917421f, -0.06868070f, 0.02594047f, 
    0.08632129f, 0.02786659f, 0.07826015f, -0.19213159f, 0.02463490f, -0.05356024f, 0.13534299f, 0.10548281f, 
    0.03480942f, 0.11848215f, -0.06641289f, 0.03875507f, 0.02031817f, -0.13313687f, -0.11299261f, 0.02110715f, 
    -0.03898387f, 0.00720761f, 0.06780355f, 0.17560308f, 0.24916883f, -0.03573228f, -0.05344277f, -0.04200535f, 
    0.01632021f, 0.21718140f, -0.10612417f, -0.26834792f, -0.08429527f, -0.16943501f, -0.05458325f, -0.00229830f, 
    0.08711359f, -0.06730998f, -0.16509487f, 0.07142780f, -0.09528930f, -0.08320662f, 0.25764206f, -0.19615950f, 
    -0.07337727f, 0.09465717f, 0.03735622f, 0.16419786f, 0.06540436f, 0.15221988f, 0.13427946f, -0.04932215f, 
    -0.09821635f, -0.00976073f, 0.19635409f, -0.16061650f, -0.03002591f, -0.16815008f, -0.18824352f, -0.09543064f, 
    0.11053558f, -0.06871650f, 0.02179421f, -0.13689764f, 0.14165694f, -0.22628304f, -0.01544940f, -0.09131165f, 
    0.17917438f, 0.00431405f, 0.02677150f, 0.10781201f, 0.01747000f, -0.08767343f, -0.04285137f, -0.10017721f, 
    -0.08605533f, -0.18969072f, -0.08996265f, 0.12888899f, -0.05646404f, -0.00202877f, 0.00413880f, -0.04127285f, 
    -0.02192904f, -0.09796830f, 0.00891383f, 0.03620405f, -0.11915185f, -0.28704071f, 0.18164745f, -0.09060061f, 
    0.11050580f, 0.20616195f, -0.04604445f, 0.17991002f, -0.08749805f, 0.05953453f, -0.24581252f, 0.03372214f, 
    -0.39983591f, -0.36084706f, 0.22481214f, 0.12217610f, -0.03374232f, 0.02119058f, -0.05685620f, 0.01426547f, 
    0.02082472f, 0.02784383f, 0.15562879f, 0.18265046f, -0.03911290f, -0.10148423f, 0.04402399f, 0.05105520f, 
    0.13189468f, 0.11752251f, 0.15646328f, 0.11617865f, 0.09372701f, -0.01488547f, 0.09289004f, 0.00809440f, 
    -0.31585512f, -0.07918078f, -0.12178338f, 0.13094370f, 0.01189081f, 0.09369693f, -0.05361259f, -0.00566786f, 
    0.10662638f, -0.04209165f, 0.04688005f, -0.08050089f, -0.03659624f, -0.12556833f, -0.23873848f, 0.11233384f, 
    0.04636899f, -0.06679523f, -0.02608250f, 0.11517183f, 0.04229079f, 0.15611658f, 0.00932093f, -0.13559921f, 
    0.13244063f, -0.07356296f, 0.01144858f, 0.24754392f, -0.09516466f, -0.16723664f, -0.05069621f, 0.21430656f, 
    0.17456958f, 0.09682585f, 0.10394533f, 0.11586823f, 0.46373191f, -0.09431320f, -0.49997982f, -0.00329525f, 
    -0.04947719f, 0.10542314f, 0.22470060f, 0.01339228f, 0.07843573f, 0.06071660f, -0.01568921f, -0.01182101f, 
    0.10527672f, -0.04846964f, -0.31008279f, -0.14238113f, 0.06919565f, -0.07262743f, 0.07504518f, 0.06631972f, 
    0.11635978f, 0.03141657f, 0.04432825f, -0.07775851f, 0.21299508f, 0.23406152f, -0.56024861f, -0.42636067f, 
    0.09043313f, -0.12349249f, 0.15029678f, -0.01369082f, -0.01456194f, 0.07227088f, -0.05263878f, -0.04626387f, 
    -0.22394864f, -0.15483552f, -0.08455493f, 0.09237233f, 0.08955606f, 0.04160725f, 0.20427088f, -0.07703751f, 
    0.05955791f, 0.00561277f, 0.13997434f, -0.02073684f, -0.16942123f, 0.00602397f, -0.02959321f, -0.05792836f, 
    0.18833849f, 0.13515490f, -0.11632798f, 0.05012348f, -0.18395124f, 0.08988412f, 0.01979844f, 0.04021002f, 
    -0.21919873f, -0.35022143f, 0.06767440f, 0.13323914f, -0.09742223f, 0.00212591f, -0.04616348f, -0.05134515f, 
    -0.16520955f, -0.01709132f, -0.01020186f, -0.10427772f, -0.03095402f, 0.00748934f, -0.02225338f, 0.08058332f, 
    0.09233896f, 0.07651268f, 0.05843629f, 0.01155460f, 0.05200383f, -0.01894157f, -0.10819755f, -0.07750703f, 
    -0.17549515f, -0.14250803f, -0.10519457f, 0.08668529f, 0.00242199f, 0.06966482f, 0.05666526f, -0.00577899f, 
    -0.10262311f, 0.04080792f, -0.03751988f, 0.10600048f, 0.04632756f, 0.03263574f, -0.01515624f, 0.19169515f, 
    -0.07141149f, 0.06044806f, -0.01362969f, 0.03849680f, 0.13852286f, 0.07427888f, -0.01043917f, 0.08015948f, 
    -0.23642930f, -0.02883619f, -0.18338908f, 0.01248908f, -0.03353748f, 0.01282226f, 0.00154164f, -0.08417210f, 
    0.09892112f, 0.15786374f, 0.09914397f, 0.21706396f, -0.08441220f, 0.40818498f, -0.15226419f, -0.21259232f, 
    0.10596047f, -0.04151942f, 0.10047609f, -0.00962594f, -0.02429659f, -0.19109443f, 0.15185685f, -0.08111193f, 
    -0.03999290f, 0.26281458f, -0.30648211f, 0.11326446f, 0.12830120f, -0.01615049f, -0.01853999f, 0.03572019f, 
    0.08672438f, 0.08361032f, -0.09496256f, 0.14310789f, 0.02953776f, -0.08170311f, -0.01226288f, 0.30648804f, 
    0.10974587f, -0.11600288f, -0.03014068f, -0.02248320f, -0.01155264f, 0.07967871f, 0.11285106f, -0.06629894f, 
    0.30950910f, 0.19796285f, -0.09458776f, -0.22434428f, -0.05751074f, -0.01520555f, -0.05829327f, -0.07344181f, 
    0.04528254f, 0.05770283f, -0.10794286f, 0.10327481f, 0.18107377f, 0.15315172f, -0.00991319f, -0.28052881f, 
    -0.03784472f, -0.00830916f, -0.02936615f, -0.00072533f, 0.04282296f, 0.03554296f, 0.13364691f, 0.08453971f, 
    -0.05120419f, 0.18953824f, -0.03826211f, 0.09128708f, 0.08530094f, 0.09809759f, -0.01421445f, -0.17803982f, 
    -0.05520364f, 0.11019441f, -0.01906761f, 0.01871228f, -0.22475740f, 0.08969316f, 0.29295942f, 0.05123505f, 
    0.01226620f, 0.17599061f, -0.02027950f, 0.15548736f, -0.08949779f, 0.04172699f, -0.13444750f, -0.03540979f, 
    -0.09376679f, 0.16519296f, 0.13909364f, 0.07161759f, -0.13401812f, 0.01007524f, -0.18756673f, -0.02464513f, 
    0.13983528f, 0.09713207f, 0.06938869f, 0.10818919f, -0.40296054f, 0.08045391f, 0.48158884f, 0.22995162f, 
    -0.04179884f, -0.00354575f, 0.05995857f, 0.10533600f, 0.17890818f, 0.08747321f, 0.07535179f, 0.09158752f, 
    0.02159152f, 0.01973960f, 0.00944081f, 0.02238305f, -0.07712951f, 0.00796229f, 0.04875888f, -0.05257624f, 
    0.03278583f, -0.02869027f, -0.04831411f, 0.01972942f, -0.05329857f, -0.06055523f, 0.03514389f, -0.01235565f, 
    0.06132733f, -0.00471483f, -0.04166772f, -0.07082635f, 0.01646394f, 0.00385042f, 0.06418467f, -0.04257119f, 
    0.02861922f, -0.02650138f, -0.00960036f, -0.02931029f, -0.00528449f, -0.05519941f, 0.01489368f, -0.07315372f, 
    -0.04820686f, -0.03594095f, 0.03182982f, 0.02960140f, -0.07631850f, -0.01390854f, 0.03881672f, -0.04350138f, 
    -0.06172507f, 0.02028069f, -0.07533823f, -0.04285871f, 0.03713429f, 0.01707546f, 0.02933883f, -0.07542858f, 
    -0.05822742f, -0.01518782f, -0.01619264f, 0.06323285f, -0.05570345f, 0.03039583f, -0.07238865f, 0.01055892f, 
    -0.02878161f, -0.00732251f, -0.04393828f, -0.03001333f, -0.07762814f, -0.05067902f, 0.02717023f, 0.02454818f, 
    -0.00346000f, -0.05885348f, -0.00509948f, -0.07149086f, 0.04836370f, 0.00222403f, -0.01607015f, -0.07435137f, 
    0.01960111f, -0.01460310f, -0.01163646f, -0.05968543f, -0.04008031f, -0.05140217f, 0.02468523f, -0.05805821f, 
    -0.01071264f, 0.00258282f, 0.00423920f, -0.00515604f, -0.01452807f, 0.04993548f, -0.07396538f, -0.07794888f, 
    -0.07265641f, -0.01574914f, -0.04393899f, 0.06231468f, -0.01429876f, -0.04088931f, -0.07046928f, -0.03172386f, 
    -0.05002240f, -0.05553274f, 0.02801085f, -0.06642164f, -0.04827054f, 0.01598358f, -0.02247115f, 0.00415664f, 
    0.03173623f, -0.02032072f, 0.03201475f, -0.00178528f, -0.06403513f, 0.02462959f, 0.00144842f, 0.04138716f, 
    0.06380437f, 0.05383430f, 0.00026024f, 0.02732096f, 0.04876315f, 0.02480747f, -0.05399406f, 0.02843904f, 
    -0.05034091f, 0.00581182f, -0.04297237f, 0.04663548f, 0.06042698f, 0.05187162f, -0.00706727f, -0.01947439f, 
    -0.04544367f, 0.00459961f, -0.00350334f, -0.06431730f, -0.06146607f, 0.04214556f, 0.03887800f, -0.06695461f, 
    0.00999219f, 0.05624648f, -0.07481214f, -0.01941823f, -0.03234319f, -0.00873327f, -0.04745897f, 0.05799770f, 
    0.03006690f, -0.05265614f, 0.05037413f, -0.04548771f, 0.04022533f, 0.01869297f, -0.02596872f, -0.05946515f, 
    -0.07020157f, 0.00198169f, -0.02587054f, 0.02182827f, 0.05461757f, -0.02998532f, 0.05441437f, 0.03049202f, 
    -0.01393150f, -0.01562330f, -0.03711586f, 0.05558700f, -0.03719313f, -0.01577899f, -0.00923365f, 0.05541141f, 
    0.01203072f, 0.04457622f, 0.01566125f, 0.06499273f, -0.05245158f, 0.04350504f, 0.04229588f, -0.02542254f, 
    0.03513252f, -0.07730828f, -0.00350485f, 0.06193659f, 0.04739738f, -0.01103126f, 0.05028464f, -0.02388046f, 
    0.05720406f, -0.02581018f, 0.02024512f, 0.05303430f, -0.02062353f, 0.06281438f, -0.06393993f, -0.05505588f, 
    -0.23471406f, -0.08626771f, -0.21519171f, 0.03812014f, -0.07885454f, 0.15089907f, 0.03929425f, 0.02951888f, 
    -0.06497617f, 0.04966639f, -0.11685264f, 0.05923893f, -0.04675422f, -0.10951325f, -0.05025046f, -0.05903395f, 
    -0.18496038f, 0.07815889f, 0.09941152f, 0.10386921f, 0.04790879f, -0.09009477f, 0.00053583f, 0.05549642f, 
    -0.28658569f, -0.42380700f, 0.04023622f, -0.12729192f, -0.11494584f, -0.15908445f, -0.09602281f, -0.14709119f, 
    0.10646950f, 0.10547226f, 0.02196708f, -0.00973887f, -0.06413728f, 0.19703479f, 0.13570251f, 0.04578942f, 
    0.07698436f, -0.08805323f, 0.04463418f, 0.10776835f, 0.16330686f, 0.06089544f, 0.13736852f, -0.10871283f, 
    -0.36237431f, -0.20623825f, -0.36888891f, -0.27160427f, -0.03324921f, 0.03459959f, -0.05683263f, 0.07552056f, 
    0.05957973f, 0.06006728f, -0.04681761f, 0.06935013f, -0.09648654f, 0.03279324f, 0.31689143f, -0.03285896f, 
    0.10387301f, 0.07455996f, 0.04643950f, 0.13520880f, -0.00368869f, 0.06697740f, 0.01182578f, -0.05031884f, 
    -0.01502185f, 0.01187911f, -0.01332951f, -0.02532257f, -0.01376298f, -0.06934500f, 0.06405453f, -0.03499448f, 
    0.09909031f, -0.01849740f, 0.08747655f, 0.03743050f, 0.11220607f, 0.09819038f, 0.02049007f, 0.05524578f, 
    0.20025659f, -0.01046236f, 0.02579510f, 0.12431201f, -0.04740630f, 0.09331596f, 0.06355708f, -0.16548295f, 
    0.02391301f, -0.24382110f, -0.21914813f, 0.02418519f, 0.06950354f, -0.12641397f, -0.02149209f, 0.19304578f, 
    0.00167798f, 0.00366888f, 0.09133459f, 0.00851823f, -0.22090441f, -0.41605935f, -0.00742334f, 0.05651300f, 
    0.13468231f, 0.28306192f, -0.01086651f, 0.12561135f, 0.10468259f, -0.03976068f, -0.02826652f, 0.01040452f, 
    0.23774531f, 0.30322531f, 0.10440083f, -0.10481450f, -0.11962971f, -0.01018875f, -0.00169389f, -0.08482976f, 
    -0.03989843f, -0.17942804f, -0.13809170f, 0.00739099f, 0.27384016f, 0.01872429f, -0.09457036f, -0.06678254f, 
    -0.00815281f, 0.03868807f, -0.02071570f, -0.01388297f, -0.16660517f, 0.01667584f, 0.05794030f, -0.07227345f, 
    0.12789303f, 0.31031406f, 0.09445082f, 0.04861172f, -0.06324457f, 0.10301010f, 0.10591029f, 0.04242707f, 
    0.16282605f, 0.13044944f, 0.01941594f, 0.03454395f, -0.00158618f, -0.01575850f, -0.09883359f, -0.12393391f, 
    0.13536087f, 0.15630093f, 0.21916765f, 0.07745034f, 0.09684765f, 0.07531390f, 0.00851999f, -0.08099215f, 
    -0.08774257f, 0.12158005f, 0.18078840f, -0.08409657f, 0.08557353f, 0.06112719f, 0.00856270f, -0.00262985f, 
    -0.01632287f, -0.04505927f, 0.08242806f, -0.02992893f, 0.15297510f, 0.22039936f, 0.22661264f, 0.13550404f, 
    0.05517580f, 0.08515758f, 0.28873929f, 0.16264604f, 0.06667051f, 0.08699695f, 0.07110023f, 0.17916563f, 
    0.13213526f, -0.08308263f, -0.16943413f, -0.08816054f, 0.05735916f, -0.13398887f, 0.16717350f, -0.03740939f, 
    0.07762913f, -0.09840673f, 0.21566838f, 0.16063410f, -0.18747282f, -0.06947330f, -0.07029059f, 0.05176320f, 
    0.13463114f, 0.06538003f, -0.07945599f, -0.01480140f, 0.08257097f, -0.05555054f, 0.05905348f, -0.01303172f, 
    0.27307770f, -0.18491556f, -0.33656439f, -0.11256314f, -0.03990465f, -0.09647356f, 0.05456900f, 0.06852570f, 
    -0.05058891f, 0.02809225f, -0.20048282f, -0.15650091f, -0.01202834f, 0.03300333f, -0.13875477f, 0.15754639f, 
    0.14492057f, 0.02733878f, 0.15254137f, 0.13392079f, 0.01841496f, 0.22150330f, 0.04755944f, -0.08960508f, 
    0.03042145f, 0.02431938f, -0.19046202f, -0.35898232f, 0.05011806f, -0.17707197f, -0.04379949f, 0.05503407f, 
    0.09879325f, 0.06176069f, 0.01406854f, -0.05057975f, 0.00151778f, -0.18878986f, 0.13881660f, -0.09344146f, 
    -0.02300951f, -0.14731391f, -0.00191083f, 0.04151588f, 0.19705917f, 0.06337833f, -0.00425301f, -0.00425030f, 
    -0.12609778f, 0.18196946f, -0.10520791f, -0.06877779f, -0.01855043f, 0.01683178f, 0.02016236f, 0.08017459f, 
    0.13553628f, 0.14539982f, -0.05584865f, 0.20505011f, 0.26464552f, 0.37232587f, -0.10070220f, 0.01429753f, 
    0.08449727f, -0.26342711f, 0.09938497f, -0.13250662f, 0.01681402f, -0.19881852f, 0.17477299f, 0.24918003f, 
    0.34805956f, 0.29263192f, -0.29120001f, -0.05762741f, 0.07974625f, -0.02280324f, 0.13775396f, -0.11590973f, 
    0.01573928f, -0.01029544f, -0.17775783f, 0.27483889f, 0.25602022f, 0.02886561f, -0.30981219f, -0.07565694f, 
    0.03395506f, 0.03155706f, 0.05375562f, -0.05685252f, 0.07655365f, 0.00917067f, 0.00749525f, 0.04028776f, 
    0.18154314f, 0.09300273f, -0.15515293f, -0.12364703f, 0.00478774f, -0.02915180f, 0.04801200f, -0.09903429f, 
    0.02928602f, 0.06970270f, 0.12653479f, 0.07053364f, 0.21791160f, -0.03340250f, -0.08977917f, -0.09296299f, 
    -0.00561832f, 0.01786127f, 0.00543151f, -0.00335489f, 0.06724633f, 0.07838441f, 0.10177834f, 0.00804151f, 
    0.03453301f, 0.23111989f, 0.01586073f, 0.03804262f, 0.11019725f, -0.11846883f, -0.03649560f, 0.09351257f, 
    0.03022827f, 0.08972169f, 0.06249461f, 0.03767914f, -0.45056868f, 0.02434513f, -0.22042567f, -0.07752407f, 
    -0.11808492f, 0.23565115f, 0.10855430f, -0.16820943f, -0.07441139f, 0.14059524f, -0.14020817f, -0.03026660f, 
    -0.24623616f, -0.02565038f, 0.16598324f, 0.18702108f, -0.12497222f, 0.04642298f, -0.31305566f, 0.03110295f, 
    0.04175677f, 0.19790609f, 0.06057302f, 0.17583896f, -0.04311009f, 0.05535464f, 0.00082466f, 0.27920654f, 
    -0.00850609f, -0.01914573f, -0.07330091f, 0.20715334f, 0.19144544f, 0.06723972f, 0.04723732f, -0.01132726f, 
    -0.02482290f, -0.02547595f, -0.06892311f, 0.03503505f, 0.06266833f, -0.01695348f, 0.04978609f, -0.06287258f, 
    -0.03280695f, -0.06208092f, 0.01481772f, 0.01613005f, 0.00159651f, 0.00327133f, -0.01537823f, -0.03527272f, 
    0.05289651f, 0.04450024f, -0.01773191f, 0.05515036f, -0.02697137f, -0.00409195f, -0.05208622f, 0.03340390f, 
    0.05649460f, -0.00384746f, 0.03400122f, 0.01647234f, 0.01638742f, -0.02861995f, -0.01623886f, -0.01278585f, 
    0.00824535f, 0.05546101f, 0.06405745f, -0.05136570f, -0.03131511f, -0.06198718f, 0.01388334f, -0.04100215f, 
    -0.01375040f, 0.06691568f, -0.03763076f, 0.05107992f, -0.02209015f, 0.02161280f, 0.02860888f, -0.06636975f, 
    -0.05634192f, 0.05857480f, 0.01396323f, 0.03274222f, 0.03441186f, -0.03483462f, 0.07169365f, -0.03532225f, 
    -0.05700437f, -0.02078013f, 0.06029668f, -0.01644660f, 0.02207786f, 0.02772616f, -0.05357017f, -0.01294546f, 
    0.04087185f, -0.07091811f, -0.05118278f, -0.07207283f, 0.06008777f, 0.05540314f, -0.00504601f, 0.02864983f, 
    -0.06430168f, 0.01897972f, 0.01463402f, 0.05252792f, -0.00776939f, -0.06241263f, -0.05593812f, -0.02762371f, 
    0.03264663f, 0.04797810f, 0.01966326f, -0.03793371f, 0.04409671f, -0.04455796f, -0.02433429f, 0.07084055f, 
    -0.04593037f, -0.03262829f, 0.03245205f, -0.05185034f, -0.04415643f, -0.05313540f, -0.01492208f, -0.06361679f, 
    0.03222011f, 0.03654606f, -0.05932553f, -0.00123300f, -0.04444784f, -0.05345259f, 0.00612020f, -0.05763548f, 
    -0.00769861f, -0.06469293f, 0.06878721f, 0.01133886f, -0.05271928f, 0.04019177f, 0.06418969f, -0.02598451f, 
    -0.03319329f, 0.00759759f, 0.04356984f, -0.02939257f, -0.05381939f, -0.01684090f, -0.00998970f, -0.07000003f, 
    -0.05893504f, 0.04467195f, -0.01252617f, 0.07026987f, -0.00129470f, 0.03495751f, -0.05008725f, 0.00038347f, 
    0.00228503f, -0.01507269f, 0.06137398f, 0.00087447f, 0.06159064f, -0.05958586f, 0.00445969f, -0.03508412f, 
    -0.06566504f, -0.03554643f, -0.07195862f, -0.00250971f, -0.06165500f, -0.01921931f, -0.05239808f, -0.00088326f, 
    0.02681545f, 0.01785419f, 0.01744361f, 0.04724309f, 0.03042495f, -0.01878054f, -0.03839323f, 0.05400085f, 
    -0.04685467f, -0.07003717f, -0.03098529f, -0.03917246f, 0.02435317f, -0.00906934f, -0.01256080f, 0.05717818f, 
    0.05374122f, 0.03867949f, -0.07129354f, -0.01132054f, -0.05630323f, -0.05934884f, -0.01456457f, -0.06860793f, 
    -0.05894488f, 0.00738208f, 0.03620813f, -0.02841539f, -0.06982984f, -0.00359365f, -0.03606664f, 0.06080992f, 
    -0.06126899f, -0.01960254f, -0.01320624f, -0.05565789f, -0.05613487f, -0.05796129f, 0.00740102f, -0.01675709f, 
    -0.06714632f, 0.02833967f, -0.02060848f, -0.07034867f, -0.05714599f, -0.03353077f, 0.01850928f, -0.02997377f, 
    -0.12767085f, -0.03630129f, -0.00319149f, 0.19559461f, -0.11454632f, -0.11765316f, 0.14966783f, 0.12681869f, 
    -0.12122550f, 0.13122746f, 0.01620456f, 0.00367253f, -0.21445930f, 0.02864312f, -0.13272069f, -0.20850891f, 
    0.03274441f, 0.06228758f, -0.05493218f, -0.04144607f, -0.17408477f, -0.37202996f, -0.27863148f, -0.70298493f, 
    0.27330256f, 0.01966937f, -0.01954520f, 0.13755082f, 0.01726390f, -0.02798856f, 0.01055519f, 0.04436724f, 
    -0.01093392f, 0.06162903f, -0.08180333f, 0.06250554f, -0.06542557f, 0.07367142f, 0.01755898f, 0.37930205f, 
    0.09662275f, 0.16128136f, 0.16623363f, 0.13813034f, 0.19613241f, 0.16118222f, 0.25212440f, 0.19908172f, 
    0.01183882f, -0.08211888f, 0.04375153f, -0.05842335f, 0.01157345f, 0.00671940f, -0.01178594f, 0.07215974f, 
    -0.09343465f, 0.00576435f, -0.05937713f, -0.29876983f, -0.06240650f, -0.21893436f, 0.12783939f, -0.01866638f, 
    -0.05935642f, 0.12191065f, -0.00914455f, -0.13034904f, -0.08376531f, 0.13219261f, -0.16143821f, -0.22154815f, 
    0.12494920f, 0.09353101f, 0.12997973f, -0.26424846f, -0.02322569f, -0.01086581f, -0.05315825f, -0.09103163f, 
    0.05193840f, -0.06376275f, 0.02438777f, 0.03705302f, -0.25793096f, 0.37021556f, -0.12841383f, -0.33218277f, 
    0.20526139f, -0.05394813f, -0.05871357f, -0.01854205f, -0.25033808f, -0.15588966f, -0.02403106f, -0.27507603f, 
    0.15265395f, 0.02076865f, -0.14568147f, 0.12607048f, 0.06726283f, 0.07465809f, -0.03456521f, 0.14516027f, 
    0.07750902f, 0.02596213f, -0.04227880f, 0.11983512f, 0.07070027f, -0.10665535f, 0.12414239f, 0.24971409f, 
    0.03451810f, -0.10841502f, 0.12321526f, 0.08775511f, -0.05832902f, 0.09138879f, 0.01926160f, -0.05048605f, 
    0.03892240f, 0.16688140f, -0.08745188f, -0.09212242f, -0.10832683f, 0.03178203f, 0.10329157f, -0.03540603f, 
    0.10475998f, 0.08148401f, 0.06483451f, 0.22914763f, 0.27521801f, -0.08945671f, -0.04511391f, -0.00703609f, 
    -0.05440826f, 0.12518823f, -0.02778541f, -0.16492870f, 0.06709594f, 0.13606705f, -0.05208936f, 0.05355900f, 
    0.05023221f, 0.11174081f, 0.21474253f, 0.06138999f, -0.00410637f, 0.01032619f, -0.04729950f, -0.09723216f, 
    0.03206725f, 0.09469336f, 0.16612051f, -0.03143479f, -0.33441976f, -0.03976730f, 0.24095853f, -0.01088916f, 
    -0.11931664f, 0.21240009f, 0.01769299f, 0.35592785f, 0.06368036f, 0.07936422f, -0.04726711f, -0.00508391f, 
    -0.09861708f, 0.08632651f, 0.09568395f, 0.05700805f, 0.10363359f, 0.17848398f, -0.18635373f, -0.14054263f, 
    -0.32458740f, -0.27195385f, -0.23578027f, -0.26049134f, -0.10819270f, 0.36454517f, 0.29901028f, 0.14985305f, 
    -0.13418621f, 0.07946216f, -0.05111709f, -0.17566998f, -0.02633845f, 0.02744284f, 0.09813368f, 0.00119843f, 
    -0.15930067f, -0.13613598f, -0.06251420f, -0.00313389f, -0.06866430f, 0.04236262f, -0.01362817f, -0.14312872f, 
    -0.10726902f, -0.06716546f, -0.13607953f, -0.06924675f, 0.11190537f, 0.13109298f, 0.01071088f, 0.16340978f, 
    -0.02663252f, -0.07393102f, 0.17156291f, -0.08615307f, 0.09883246f, 0.06200537f, 0.05368594f, 0.10965080f, 
    0.30237156f, 0.26821020f, -0.15965250f, -0.19245288f, 0.28707704f, 0.17238119f, 0.01084887f, 0.18475085f, 
    -0.06503563f, -0.13056573f, -0.06679735f, -0.10923288f, -0.09958984f, -0.23053837f, 0.00225954f, -0.11416928f, 
    0.00775234f, -0.02425586f, -0.06878819f, -0.05993803f, 0.07702519f, -0.13375501f, -0.16666311f, 0.02903595f, 
    0.15848878f, -0.01799927f, -0.01552660f, -0.00299772f, -0.00406865f, -0.03101507f, 0.07941774f, -0.00497038f, 
    -0.13451882f, -0.22462612f, -0.07943368f, 0.10097182f, 0.21424253f, -0.06815435f, 0.13473083f, -0.10057240f, 
    0.07279842f, -0.00752567f, 0.18744504f, -0.05988544f, 0.09764279f, -0.00706528f, 0.03760647f, 0.11315250f, 
    0.22356687f, 0.11171483f, 0.19016120f, 0.05426469f, -0.00708141f, 0.02051480f, 0.04516650f, 0.16497220f, 
    0.00761929f, -0.00253334f, 0.06986735f, -0.07261878f, 0.12491488f, -0.20292757f, 0.18603683f, 0.15838757f, 
    -0.06531215f, 0.15674612f, -0.21098195f, 0.03670827f, 0.15156114f, 0.05216696f, -0.08230668f, -0.04852511f, 
    -0.20317040f, 0.01435819f, 0.10039221f, -0.23763879f, -0.18757714f, -0.15364997f, -0.13939178f, -0.02215474f, 
    -0.10567069f, -0.14051130f, -0.36623034f, 0.01287597f, 0.14596689f, 0.16501048f, -0.03585289f, -0.16224922f, 
    -0.09424384f, 0.01911585f, -0.10857640f, 0.08380347f, -0.10354149f, -0.12207701f, -0.11558934f, -0.01295929f, 
    -0.13987328f, -0.13452104f, 0.22237080f, 0.32836312f, 0.08197809f, 0.01006918f, 0.00968970f, 0.00211897f, 
    0.15355748f, 0.05961467f, 0.09590704f, 0.20109430f, -0.14483911f, 0.04782636f, 0.04870160f, 0.28057018f, 
    -0.09628373f, -0.07718500f, -0.00048026f, 0.05664233f, 0.21617746f, -0.09381910f, 0.12543894f, 0.16128492f, 
    0.03337238f, 0.20303439f, 0.07874759f, -0.16012950f, -0.04748277f, 0.00253244f, -0.02723711f, 0.09454819f, 
    -0.16474110f, -0.03368516f, 0.03571900f, -0.07763489f, -0.05663187f, -0.00524542f, -0.16029908f, 0.29350346f, 
    0.04661078f, -0.01938065f, 0.03936110f, 0.13744757f, 0.18430273f, 0.16835751f, -0.05318583f, 0.07502639f, 
    0.25318497f, -0.03615551f, -0.02386172f, 0.14222269f, -0.06240897f, -0.16528091f, 0.08267822f, -0.10023447f, 
    0.00083023f, -0.14045225f, -0.03358950f, 0.18385872f, 0.20004174f, 0.17529924f, -0.31260327f, -0.05278599f, 
    -0.02614922f, -0.06384515f, -0.17212629f, -0.05151330f, 0.17704524f, 0.07253576f, 0.04280233f, -0.20556757f, 
    -0.10971355f, -0.01079543f, 0.12574063f, 0.08884598f, 0.01231941f, -0.04031399f, 0.13566467f, -0.05683360f, 
    -0.07807577f, 0.12540048f, -0.03575310f, 0.11567988f, -0.40068951f, -0.02885691f, -0.35388204f, 0.07077923f, 
    -0.08098653f, 0.05151624f, -0.12771177f, 0.04593835f, 0.11308016f, -0.12188488f, -0.00355698f, 0.01151943f, 
    -0.03811894f, 0.08504336f, 0.06728148f, -0.14975515f, -0.01555622f, -0.02745985f, -0.20136249f, 0.08649155f, 
    0.01872040f, -0.11142492f, -0.26499721f, -0.06756937f, -0.05154882f, 0.06294942f, 0.13194992f, -0.17571329f, 
    0.06824448f, 0.06672668f, 0.06344540f, 0.13796513f, 0.09219093f, 0.10245693f, 0.10582794f, 0.01712500f, 
    -0.07638222f, 0.04000202f, -0.01422245f, -0.02747163f, -0.00299317f, -0.02402326f, -0.04326731f, -0.13326198f, 
    0.06201505f, -0.03501205f, -0.03661809f, 0.14102726f, 0.10011023f, -0.32889521f, 0.26764357f, -0.15340921f, 
    0.12697048f, 0.01964924f, 0.03161264f, 0.06454191f, 0.07257092f, -0.07772288f, 0.10672422f, 0.15465029f, 
    -0.04500311f, -0.37186942f, -0.02270632f, -0.14755353f, 0.04964297f, 0.02014198f, -0.08291693f, -0.01322555f, 
    0.19643660f, -0.12824984f, -0.04958427f, 0.20178163f, -0.28102475f, 0.36724734f, 0.11888556f, -0.26661244f, 
    -0.00786803f, 0.17077060f, -0.13216665f, 0.04050094f, -0.11491987f, 0.01552144f, 0.06272074f, 0.06819316f, 
    -0.21338160f, 0.05416602f, -0.06876178f, 0.08517925f, -0.15533960f, -0.06196266f, 0.07499591f, 0.20154391f, 
    -0.02999590f, 0.09396507f, -0.07607506f, -0.00917225f, -0.01185115f, -0.21618694f, 0.06990218f, 0.37749061f, 
    0.20086843f, 0.11237577f, 0.07467627f, 0.07378128f, -0.01166604f, 0.06037356f, -0.06496661f, -0.03880429f, 
    -0.02109454f, 0.15698849f, -0.11170892f, 0.03564557f, 0.07365137f, -0.02871734f, -0.09060083f, 0.21082346f, 
    0.11975104f, 0.06483725f, 0.20609210f, 0.08939455f, 0.01188415f, -0.14943732f, -0.06741676f, -0.08376817f, 
    -0.05619098f, -0.02008383f, 0.07395127f, 0.14122176f, -0.04779562f, 0.08495498f, 0.04565279f, 0.03989914f, 
    0.28670835f, -0.21660145f, -0.05684363f, 0.18683919f, 0.01144294f, -0.05702620f, 0.01011240f, 0.19881512f, 
    0.05909150f, 0.16643372f, 0.06697065f, 0.04245132f, -0.07974575f, -0.25993815f, -0.43692535f, 0.03642479f, 
    0.26356307f, 0.15606424f, 0.09243244f, 0.17850593f, 0.18588632f, -0.11604073f, -0.04887885f, 0.05713938f, 
    -0.12233718f, 0.18024361f, -0.25040340f, -0.04260897f, 0.01954360f, -0.15599316f, -0.15233535f, -0.01562331f, 
    0.07660703f, -0.08223145f, 0.17052661f, 0.23648317f, -0.10018269f, 0.44147196f, -0.08130205f, -0.24053338f, 
    -0.06534841f, 0.18470658f, -0.15483433f, 0.04481402f, 0.17952529f, -0.07503314f, -0.06647561f, 0.04834443f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12428721f, 0.10301334f, 0.28606504f, 0.21414599f, -0.01003347f, 0.18920693f, -0.03738635f, -0.00444200f, 
    0.00322627f, 0.05176678f, -0.03707069f, 0.02656214f, -0.12355992f, 0.19836654f, -0.04568193f, -0.08903234f, 
    0.06035016f, 0.11967053f, -0.09647114f, 0.01222559f, -0.17613530f, 0.03878123f, 0.13638110f, -0.00005569f, 
    0.04678323f, 0.08744799f, -0.07997952f, 0.06232309f, -0.19976386f, 0.08678643f, 0.03205786f, 0.05795366f, 
    0.06133017f, 0.02362097f, 0.11458847f, 0.12925637f, 0.02070861f, 0.24555172f, 0.01569627f, 0.02787945f, 
    0.06193201f, -0.05185774f, -0.05939740f, -0.03836162f, 0.08192337f, 0.18823151f, 0.13292390f, 0.03639473f, 
    0.01657480f, 0.21331906f, 0.19744876f, 0.22154228f, 0.02165950f, 0.09780224f, 0.00901765f, 0.09099984f, 
    0.12444838f, -0.00745240f, 0.10921077f, -0.00178159f, 0.00284507f, 0.04979423f, 0.02908417f, 0.08699322f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14420384f, 0.11310901f, 0.17582829f, 0.31147864f, 0.02990362f, 0.01577412f, -0.07359016f, -0.02596290f, 
    0.01271717f, -0.00578438f, -0.14882679f, 0.00229633f, -0.31819537f, 0.35632184f, 0.17162764f, 0.09689613f, 
    0.08397719f, 0.15711720f, -0.10143416f, 0.01819771f, -0.20999084f, -0.12722175f, 0.07120600f, -0.06068972f, 
    0.00929093f, 0.44290441f, 0.10548270f, -0.00824377f, 0.13014455f, 0.06576291f, -0.06542506f, 0.03829857f, 
    -0.10484345f, -0.02441307f, 0.17774044f, -0.21605828f, -0.07418174f, -0.03065719f, -0.07986035f, 0.08035251f, 
    -0.13809745f, -0.17352901f, 0.05951336f, 0.08442717f, 0.11879835f, -0.04092508f, 0.13241699f, 0.06136778f, 
    0.01104046f, 0.07413448f, 0.33589926f, 0.09882469f, -0.11402425f, 0.17666921f, -0.06544516f, 0.32805005f, 
    0.11666179f, 0.01024409f, -0.03539453f, 0.12148204f, -0.02799837f, -0.28874779f, -0.21981026f, -0.27457377f, 
    -0.11913415f, 0.00818771f, -0.04499472f, 0.05356965f, -0.01564321f, 0.08737656f, 0.08387470f, -0.06868886f, 
    0.04201711f, -0.02335932f, -0.26101977f, -0.06548019f, -0.24070030f, 0.03661241f, 0.12151180f, 0.08158330f, 
    0.23567094f, 0.08727764f, -0.00921945f, 0.14077696f, -0.10319789f, -0.03898758f, 0.16457842f, 0.05977543f, 
    0.01875991f, 0.18537623f, -0.09233857f, -0.31160492f, 0.09709122f, 0.22034420f, 0.10693859f, -0.08459319f, 
    0.16479535f, 0.03144233f, 0.15458935f, -0.25081578f, 0.08612499f, 0.09349646f, -0.02073612f, 0.10716101f, 
    -0.14027917f, -0.21943839f, 0.09784892f, 0.01839980f, 0.11047380f, 0.06799361f, 0.14740995f, -0.02311835f, 
    0.12669034f, -0.15807511f, 0.41772351f, 0.02330433f, -0.03568830f, 0.05590444f, 0.00147401f, 0.05030875f, 
    0.29754934f, -0.04162795f, -0.11025229f, -0.12428817f, -0.03118947f, -0.35495609f, -0.16039082f, -0.21570590f, 
    -0.06233052f, 0.11097997f, -0.01651023f, 0.16352290f, 0.01906247f, 0.08818320f, -0.08032687f, 0.03755498f, 
    -0.05120558f, -0.02135134f, -0.00875985f, 0.04441534f, 0.05505629f, -0.07690652f, -0.17838700f, -0.07507563f, 
    -0.14371327f, 0.17503721f, 0.06418488f, -0.18260337f, 0.01957912f, 0.01600758f, 0.05088279f, 0.08201067f, 
    0.24146828f, -0.04338953f, 0.06221194f, 0.08857488f, -0.09397358f, 0.03102553f, 0.10142751f, 0.11321898f, 
    -0.06041246f, -0.29683498f, -0.02447575f, 0.24086717f, 0.07311051f, -0.15615994f, 0.01747511f, -0.04198876f, 
    0.25281724f, 0.23108293f, 0.08416484f, 0.05501845f, -0.26694244f, -0.00956813f, 0.01626550f, 0.02264656f, 
    -0.08249493f, 0.14441130f, -0.16326047f, 0.26728514f, -0.02469332f, -0.11824392f, 0.00335702f, 0.15179189f, 
    -0.05206653f, 0.02345565f, 0.07999594f, 0.30045646f, -0.04369703f, 0.14126125f, 0.13404034f, 0.23326367f, 
    0.06600498f, 0.06397905f, 0.07029603f, -0.03057006f, -0.00583411f, 0.06704956f, -0.11848399f, 0.07632763f, 
    -0.03324957f, -0.03554170f, 0.09216426f, -0.09946958f, -0.05385416f, 0.00491609f, -0.06446487f, -0.09489517f, 
    0.06927375f, -0.02291338f, -0.06028584f, -0.14705454f, -0.09971949f, 0.04934644f, -0.11304075f, 0.04435563f, 
    -0.11592743f, -0.08217268f, -0.07301655f, 0.06631657f, -0.04679879f, -0.12147539f, -0.11410791f, -0.01485186f, 
    -0.12940769f, -0.06756442f, 0.07992007f, -0.00563093f, -0.11109274f, 0.04925679f, 0.11431407f, 0.09762456f, 
    -0.02582700f, -0.11688944f, 0.00524010f, 0.01969886f, 0.02789906f, -0.10449763f, 0.04654836f, -0.13679163f, 
    0.03937683f, 0.00532285f, -0.13185348f, -0.00515289f, 0.02407680f, -0.04167335f, 0.06072132f, -0.12474009f, 
    -0.06337972f, 0.09842782f, -0.04248106f, -0.10264156f, -0.07086402f, 0.00492550f, -0.04909097f, -0.14747833f, 
    -0.04899785f, 0.01939216f, -0.01953881f, 0.05845807f, -0.08667836f, -0.01585222f, 0.10501192f, 0.00128996f, 
    -0.04732915f, -0.00215058f, -0.12401161f, -0.06147307f, 0.02512289f, -0.04905878f, -0.05192501f, -0.02778289f, 
    0.09657714f, -0.09775016f, 0.00231419f, -0.10178115f, 0.08491842f, -0.11684580f, -0.11106848f, -0.09467033f, 
    -0.11569717f, 0.09073039f, 0.03795785f, -0.12461025f, -0.05601534f, -0.05668534f, -0.08811568f, 0.09205593f, 
    -0.08670385f, -0.01858172f, 0.07455404f, -0.12186701f, -0.12247680f, 0.10867541f, -0.04928150f, -0.01177151f, 
    -0.00539914f, -0.05769426f, -0.05551282f, -0.07594001f, 0.08232871f, -0.08241801f, 0.07192545f, 0.02172465f, 
    -0.13143520f, -0.01162753f, -0.09844804f, -0.13574423f, -0.00862508f, -0.08985721f, -0.08512045f, -0.06850197f, 
    -0.00411107f, -0.12525202f, 0.02634524f, -0.03088275f, 0.05794728f, -0.07152459f, 0.03121909f, -0.08994152f, 
    -0.15878655f, -0.08947006f, -0.28600580f, -0.11469286f, -0.22576021f, -0.05394989f, -0.11289541f, 0.05914954f, 
    0.06778727f, 0.27633548f, 0.24421228f, -0.09278142f, 0.44052953f, -0.23959093f, 0.29194006f, 0.29262537f, 
    0.18498553f, -0.08701377f, -0.06655497f, -0.29784152f, 0.17359371f, -0.08524852f, 0.10795503f, 0.10818353f, 
    -0.06990936f, -0.04896208f, 0.06630766f, 0.22312698f, 0.28451145f, 0.02322185f, 0.12117596f, -0.06579513f, 
    0.04282983f, 0.01109671f, -0.18857953f, 0.22554471f, 0.07384157f, -0.00479768f, 0.08674980f, -0.02564391f, 
    0.15107182f, 0.31115144f, 0.02483548f, -0.08896676f, -0.00076572f, 0.19038963f, -0.19753353f, -0.00415133f, 
    -0.11071530f, -0.14677683f, -0.31253174f, -0.12432940f, -0.10534422f, 0.04836643f, -0.04755147f, -0.32352501f, 
    0.09727474f, -0.03975859f, 0.07889748f, -0.16221234f, -0.09959392f, 0.40088040f, -0.07364009f, 0.00511369f, 
    0.10253616f, -0.01499800f, -0.10814569f, -0.34381121f, -0.14538422f, -0.06230000f, -0.00223328f, 0.07707789f, 
    0.17121029f, 0.11359930f, 0.09225158f, 0.06090012f, 0.42550033f, -0.24786890f, 0.00157029f, -0.11635929f, 
    -0.04465694f, -0.13095008f, -0.05006703f, 0.14588267f, 0.23125207f, -0.06133961f, -0.13573869f, 0.00996795f, 
    -0.21105921f, -0.11864228f, -0.04350256f, -0.01493461f, -0.00272704f, 0.03685874f, 0.08138442f, -0.07255977f, 
    0.19583251f, 0.30925593f, -0.03232084f, -0.16330491f, 0.03529277f, -0.00256686f, -0.01309252f, 0.14833952f, 
    0.00764448f, 0.07984959f, 0.03159988f, -0.04708638f, -0.05874201f, 0.11476990f, -0.12845440f, -0.25615096f, 
    0.06208913f, -0.16128841f, 0.01943486f, 0.09216690f, 0.01277928f, 0.14545244f, 0.02583254f, -0.20462486f, 
    0.21232735f, 0.06644255f, 0.00169954f, 0.13775189f, 0.12377933f, 0.28479147f, 0.06970263f, 0.08016244f, 
    0.03019072f, -0.01104697f, 0.23218617f, 0.02342746f, 0.06663181f, 0.17516689f, -0.11600652f, -0.02409463f, 
    0.19183157f, 0.04020410f, 0.05372161f, 0.11282785f, -0.11610384f, 0.02953906f, -0.29762545f, -0.08912943f, 
    -0.16635689f, -0.05097304f, -0.04621870f, 0.02812641f, -0.12233420f, 0.08712377f, 0.13105360f, 0.06037858f, 
    0.07301771f, -0.10037579f, -0.10613394f, 0.01172325f, -0.04229497f, 0.00254825f, -0.01714642f, -0.10812162f, 
    -0.15575789f, 0.17990199f, 0.07188845f, -0.49493253f, 0.01671574f, -0.20655234f, 0.07697217f, 0.03741976f, 
    -0.47809553f, -0.26310864f, -0.09438270f, -0.12461576f, 0.15575567f, -0.20152898f, 0.06680973f, 0.08391619f, 
    0.06009442f, -0.01073736f, 0.21729118f, 0.10245859f, -0.09284584f, 0.19581866f, -0.07070652f, 0.08953208f, 
    -0.13407320f, 0.11696355f, 0.08250418f, -0.22672677f, 0.08025640f, -0.11364727f, 0.09396705f, -0.24040702f, 
    0.16603881f, -0.05633192f, -0.17802143f, -0.26527029f, -0.29956740f, -0.11989235f, 0.12548184f, 0.04477628f, 
    0.11446066f, 0.14949444f, 0.10820386f, -0.06374805f, 0.46428177f, 0.14174516f, 0.52195024f, 0.08158997f, 
    -0.08010915f, -0.12359847f, -0.12252346f, -0.00432848f, -0.00380198f, -0.09943313f, -0.07282392f, -0.00458003f, 
    -0.22825974f, 0.00867825f, 0.06174251f, 0.02827879f, 0.25261521f, 0.11052662f, 0.09373213f, -0.09272292f, 
    0.33203000f, 0.17750378f, 0.08747072f, 0.00046979f, -0.04819299f, -0.03177154f, -0.10985401f, -0.18867633f, 
    0.24359877f, 0.14750557f, -0.06619388f, 0.03812604f, -0.23385605f, 0.18482061f, -0.35445276f, -0.56593972f, 
    0.13779949f, -0.16081901f, -0.13341704f, -0.17490461f, 0.03389280f, 0.26346645f, 0.10227524f, -0.16417576f, 
    0.05146892f, -0.09431557f, -0.03325830f, -0.12554549f, 0.10359201f, 0.36994442f, 0.03059013f, 0.11877291f, 
    0.00137675f, 0.09610039f, -0.06730297f, 0.07568726f, -0.21265800f, 0.01090707f, -0.08555737f, -0.08262720f, 
    -0.25014368f, -0.18529660f, 0.18160781f, -0.00366570f, -0.02507433f, -0.01466450f, -0.19611154f, 0.14458531f, 
    -0.07516610f, -0.15456101f, -0.07828118f, -0.09470706f, -0.09921400f, -0.00561416f, -0.17380005f, -0.01024322f, 
    -0.09552559f, 0.05569327f, -0.05187115f, -0.10525656f, 0.05018756f, 0.07402448f, -0.07562614f, 0.00680038f, 
    0.01400019f, 0.10298608f, 0.11326838f, 0.05477370f, 0.00544010f, 0.02166619f, -0.11398077f, -0.12538503f, 
    -0.07098869f, -0.21741489f, 0.12346882f, 0.12968156f, 0.14101586f, 0.16103792f, -0.12034147f, -0.08791480f, 
    0.13612355f, 0.05733082f, 0.15926136f, 0.01433429f, -0.04207220f, -0.00100071f, 0.02317612f, -0.02633081f, 
    0.11243236f, 0.06628255f, -0.01858451f, -0.05300743f, 0.00349556f, -0.00099759f, 0.07591394f, -0.09448244f, 
    -0.09887543f, -0.08537833f, 0.23173508f, 0.18778518f, -0.40979666f, 0.10216494f, 0.06492071f, 0.07656925f, 
    0.02599650f, -0.05501932f, 0.08429290f, 0.11099438f, -0.20190702f, 0.04831303f, -0.20222507f, 0.35517022f, 
    -0.09074483f, 0.19920258f, -0.05627208f, -0.07025669f, 0.00231415f, -0.02952949f, 0.11066715f, 0.05764357f, 
    0.21393399f, 0.23845327f, 0.12200677f, 0.07828129f, 0.10581529f, -0.05672948f, 0.10488546f, -0.07226498f, 
    0.09449611f, 0.27834484f, 0.22444664f, -0.12984467f, 0.07082134f, 0.23469174f, -0.05523753f, 0.10134674f, 
    -0.29845142f, -0.18699381f, 0.09282340f, -0.11253385f, 0.38647056f, 0.01042417f, 0.05969901f, -0.06711131f, 
    0.24959467f, -0.16642249f, 0.24326533f, 0.01148143f, -0.09902883f, -0.00025229f, -0.02942980f, 0.03925151f, 
    -0.06882895f, -0.12233153f, 0.01917947f, -0.20821604f, 0.04683718f, -0.57934940f, 0.02285954f, -0.03927777f, 
    0.29693177f, 0.14296910f, 0.16156808f, -0.16199684f, -0.04810283f, 0.00061541f, -0.09253064f, 0.02961819f, 
    -0.01513836f, -0.07720419f, -0.06227116f, -0.06817480f, 0.06136721f, 0.22773907f, 0.31619659f, -0.28526145f, 
    -0.17685404f, 0.12938511f, 0.12910476f, -0.10679118f, 0.18579912f, 0.05946347f, -0.13387585f, -0.16013063f, 
    0.10576826f, 0.07982646f, -0.00218335f, -0.05041118f, -0.19806132f, -0.09148539f, -0.04307348f, 0.09090702f, 
    0.23131147f, 0.21258417f, -0.02557706f, 0.09625194f, 0.06261925f, -0.00820167f, -0.02372058f, 0.12525521f, 
    0.38342431f, -0.15758997f, -0.01135682f, -0.08235372f, -0.38594267f, 0.08108228f, -0.22099674f, -0.14941001f, 
    0.14191951f, 0.25165614f, -0.29477665f, 0.16104811f, 0.09902123f, 0.25761035f, 0.08955898f, -0.08228984f, 
    0.33007431f, -0.08481646f, 0.06106479f, 0.23413368f, 0.04296501f, 0.32259455f, -0.20616682f, 0.22828540f, 
    0.19897413f, -0.25903547f, 0.14736922f, -0.01251394f, -0.13887581f, 0.15810919f, -0.10786600f, 0.05428834f, 
    0.05708779f, -0.32516420f, 0.26134238f, 0.01467826f, 0.22390890f, 0.03833129f, -0.05262781f, -0.01302715f, 
    0.19277699f, 0.12059850f, -0.00453631f, 0.08482505f, 0.21508539f, 0.10443494f, 0.00670580f, 0.20363006f, 
    0.07235213f, -0.06970238f, -0.09924362f, -0.33853289f, 0.16901214f, 0.10635474f, -0.04954522f, 0.03811410f, 
    -0.05732712f, 0.27506724f, -0.10650098f, 0.11828066f, 0.03241454f, -0.11796372f, 0.10498993f, 0.09368172f, 
    0.18430392f, -0.02026706f, 0.04789969f, 0.14053510f, 0.31182194f, 0.15883143f, 0.03552295f, 0.16117102f, 
    0.11344276f, -0.10502444f, 0.26377496f, -0.06633815f, 0.01954031f, -0.08908666f, -0.12127833f, 0.00475058f, 
    -0.14427926f, -0.10249601f, -0.29717055f, 0.07786756f, 0.08430290f, -0.25693494f, 0.06257375f, 0.05657818f, 
    0.14094561f, -0.05626028f, -0.27700618f, -0.20763870f, -0.17373560f, -0.40870672f, 0.08129534f, -0.08419430f, 
    0.07680292f, -0.31361303f, 0.18997362f, -0.02082168f, 0.33350608f, -0.11177531f, 0.34656465f, 0.17455648f, 
    -0.09022396f, -0.01557265f, -0.00228795f, -0.04672957f, 0.07296143f, -0.00468377f, 0.13915214f, 0.15548190f, 
    -0.10946246f, 0.00306053f, -0.07937088f, -0.21516542f, 0.40369019f, -0.03473031f, 0.12071511f, -0.01784527f, 
    0.09705750f, 0.12546237f, -0.08670048f, 0.29382923f, 0.11439059f, -0.11308078f, 0.11370222f, -0.13833885f, 
    0.12690511f, 0.22579122f, 0.08371864f, -0.06643279f, -0.19560483f, 0.14900777f, -0.23727047f, -0.36035097f, 
    0.14755005f, -0.03596034f, 0.30677742f, -0.18083434f, -0.06964290f, 0.09233768f, -0.10036531f, 0.09364124f, 
    0.04632914f, -0.07461499f, -0.00750617f, 0.13267443f, -0.10083763f, 0.27346706f, 0.17372987f, 0.06034768f, 
    -0.00971882f, -0.23507975f, -0.06637077f, -0.09659575f, 0.09259538f, -0.07303000f, 0.06088575f, 0.10720224f, 
    0.22202684f, -0.13166103f, 0.02736564f, -0.11254821f, 0.49120536f, -0.07042134f, 0.25385416f, 0.16774826f, 
    0.45542365f, -0.03499519f, 0.14368813f, -0.13719000f, 0.14931887f, -0.04118857f, -0.05090049f, 0.21937974f, 
    -0.01690356f, -0.06800044f, 0.00523986f, -0.40922138f, 0.18324752f, 0.16166078f, 0.03593676f, 0.00427246f, 
    -0.03036452f, 0.21849336f, -0.17925932f, 0.17122307f, 0.08951367f, -0.17296839f, -0.07718685f, 0.25253505f, 
    0.01258900f, 0.26155677f, 0.11205488f, -0.10199060f, 0.19487786f, -0.00684093f, 0.12738119f, 0.09768685f, 
    0.09313963f, -0.24224389f, 0.23807114f, 0.02891965f, -0.06049949f, -0.08362066f, 0.03051314f, 0.23358619f, 
    -0.17696387f, 0.08224562f, -0.28561264f, 0.21945715f, 0.00432783f, -0.02785370f, -0.10470700f, -0.06800946f, 
    0.04063377f, -0.16241078f, 0.10633369f, -0.04654000f, 0.21705022f, 0.23639964f, -0.07198837f, 0.03515511f, 
    -0.14474505f, 0.28612146f, 0.11927265f, 0.07521551f, -0.12322224f, 0.13232675f, 0.04873525f, -0.02330672f, 
    0.32757509f, -0.17645007f, -0.10123679f, 0.22490780f, -0.03773120f, 0.01573752f, -0.04312640f, 0.04970095f, 
    0.00095405f, -0.22275488f, -0.04032029f, -0.09267922f, -0.14714825f, 0.12991217f, 0.12211604f, 0.10888201f, 
    0.17593329f, -0.21091172f, -0.07577706f, 0.03682176f, -0.10576626f, 0.23402874f, 0.03928245f, -0.02808967f, 
    0.15313686f, 0.18137030f, -0.11562137f, -0.05042383f, 0.30103606f, 0.31222320f, 0.13969441f, 0.10254662f, 
    0.08407103f, -0.00108298f, 0.24141879f, 0.08387135f, 0.05614124f, 0.09120738f, 0.05768754f, -0.01248962f, 
    0.10324950f, -0.05519764f, -0.01173911f, -0.40250215f, 0.01212923f, -0.15733340f, -0.17382453f, 0.09583911f, 
    -0.07447451f, 0.07804134f, -0.12580031f, -0.04686058f, 0.12617330f, 0.15945749f, 0.11560924f, -0.06695430f, 
    0.42484736f, 0.07002306f, -0.20109650f, -0.11992022f, 0.10657211f, -0.11246706f, 0.13701883f, 0.03945637f, 
    0.23460922f, 0.21024531f, -0.03152410f, -0.14227995f, -0.07196945f, 0.03999803f, 0.14822266f, 0.09091733f, 
    -0.14270927f, 0.25371471f, 0.02269608f, -0.20784184f, 0.25898957f, 0.21538684f, 0.09646149f, 0.09050454f, 
    0.21725479f, 0.23762193f, 0.06245896f, -0.16984206f, -0.08389931f, -0.04454312f, -0.07770503f, 0.33781761f, 
    -0.11306237f, 0.13498341f, -0.09974840f, 0.11173520f, 0.31417504f, -0.02950466f, 0.03539643f, -0.07604744f, 
    -0.00367368f, -0.35315713f, 0.08803760f, -0.21085738f, 0.09315184f, 0.22470985f, -0.04079973f, -0.13061899f, 
    0.08514254f, -0.03040865f, -0.00748491f, -0.17949423f, -0.08953050f, -0.09632053f, 0.13268571f, 0.09107261f, 
    0.18876985f, -0.25163424f, 0.16039170f, 0.07650995f, -0.14706723f, -0.03225556f, -0.03247497f, -0.00188220f, 
    0.00790535f, -0.15952814f, 0.17943513f, 0.10911782f, 0.04817249f, 0.21403021f, 0.34507385f, 0.35476044f, 
    0.06494786f, 0.20656915f, 0.05170914f, 0.08791537f, -0.01677234f, 0.00343187f, 0.21628614f, 0.26777554f, 
    0.06702235f, 0.21951957f, 0.06120052f, -0.20359333f, 0.13480905f, 0.12441368f, 0.11861292f, -0.03869393f, 
    0.06747373f, 0.17011717f, 0.19996178f, 0.09704173f, -0.10705002f, -0.05856296f, -0.04643859f, -0.08131496f, 
    0.02578426f, 0.29524603f, 0.01594955f, 0.01960910f, 0.32544789f, 0.05811280f, 0.08917319f, -0.13216440f, 
    0.23760892f, 0.05045814f, 0.12032241f, -0.12043837f, 0.07678981f, -0.00273768f, 0.04558804f, 0.30641860f, 
    -0.07625982f, -0.00174028f, -0.28755960f, -0.19388045f, 0.06741382f, -0.10261244f, 0.13307950f, 0.00762676f, 
    -0.23002945f, -0.06889848f, -0.11539982f, 0.13693938f, 0.01600365f, -0.08192329f, 0.08684868f, 0.09803754f, 
    0.21212983f, 0.12018828f, -0.20230277f, -0.08505757f, -0.09584554f, 0.04672021f, -0.03640854f, 0.15886511f, 
    0.23969890f, 0.23034152f, 0.13839872f, -0.08158630f, 0.08487402f, -0.06968027f, 0.17091799f, -0.01153603f, 
    0.13410942f, 0.05101191f, 0.10140467f, -0.19422621f, -0.10459131f, 0.20708986f, -0.05491382f, -0.05505830f, 
    0.11693633f, -0.45589647f, 0.06830253f, 0.02484700f, -0.04077317f, 0.30506754f, -0.02671175f, 0.14297543f, 
    -0.19622315f, 0.00874925f, 0.09034431f, -0.01327588f, -0.17754175f, 0.21354899f, 0.28823262f, 0.12815017f, 
    -0.16441183f, 0.21344922f, -0.03435412f, 0.23840123f, -0.01914009f, -0.01504799f, 0.11578286f, -0.19647053f, 
    0.21682517f, -0.02513555f, -0.03393251f, 0.05731604f, -0.01368739f, 0.13164805f, -0.34625739f, -0.21383686f, 
    0.33496258f, 0.18727055f, -0.17551067f, -0.06615271f, 0.12489332f, -0.04231513f, 0.02970673f, 0.06398495f, 
    0.00068893f, -0.14246474f, -0.07664151f, -0.06581099f, -0.05297173f, 0.26492241f, 0.68163317f, -0.21437082f, 
    0.01296419f, 0.03515537f, -0.00614059f, 0.13450420f, -0.00382668f, -0.07673554f, -0.19571428f, -0.14954562f, 
    -0.14608693f, 0.45880485f, -0.03348315f, 0.11974710f, 0.02084233f, 0.11706540f, 0.05490611f, 0.08868913f, 
    -0.07679956f, 0.32291159f, -0.06256482f, 0.14419211f, 0.01862280f, -0.14971751f, -0.04142356f, -0.07288405f, 
    0.49314445f, 0.15256445f, -0.11856721f, 0.10579295f, 0.04142982f, 0.11461165f, -0.18834013f, -0.08431201f, 
    0.22254121f, -0.09379228f, -0.33448851f, -0.10300564f, -0.07427738f, 0.26962149f, -0.07348861f, 0.43765143f, 
    -0.15925123f, -0.11100099f, 0.15342830f, -0.07463266f, -0.09945314f, 0.22557564f, -0.07422978f, 0.41182452f, 
    0.05179288f, -0.10549160f, 0.06300627f, 0.06160082f, 0.01315968f, 0.02216344f, 0.03371762f, 0.03557979f, 
    -0.01180170f, 0.03751982f, -0.11384981f, -0.12549487f, 0.07666386f, 0.01253225f, -0.13432656f, 0.07669345f, 
    0.03535927f, 0.04723596f, -0.11849304f, -0.04733829f, -0.12208581f, -0.09448805f, -0.16783281f, 0.01463194f, 
    -0.07383668f, 0.06528487f, -0.04995850f, 0.01073908f, 0.06529833f, -0.08935293f, 0.01263719f, 0.04548712f, 
    0.06266020f, -0.08940925f, -0.16791649f, 0.10090251f, -0.06525710f, -0.01529193f, -0.12495314f, -0.08993979f, 
    -0.00278329f, -0.16283876f, -0.05853909f, 0.07715853f, 0.04377917f, 0.02238886f, -0.07987445f, 0.08271191f, 
    0.02860776f, -0.12297231f, -0.03465663f, -0.04300867f, 0.02914363f, -0.06533083f, -0.01214246f, -0.09646607f, 
    -0.04334713f, -0.10991153f, -0.01503295f, -0.14648414f, -0.11875235f, 0.01194348f, -0.08925623f, -0.05524958f, 
    -0.12352646f, -0.07811531f, -0.02872872f, 0.28820443f, -0.03826161f, 0.14513201f, -0.01218486f, -0.00177768f, 
    0.19468108f, 0.03456186f, -0.10104453f, -0.12939000f, -0.15578283f, 0.08172560f, 0.16376461f, -0.13519438f, 
    0.27637756f, 0.07576092f, 0.08414721f, -0.16101268f, -0.24343564f, -0.03915631f, 0.08140468f, 0.13468178f, 
    -0.19897355f, 0.10848857f, 0.06041235f, 0.32830048f, -0.27254412f, 0.15625398f, 0.06652970f, -0.02938695f, 
    0.12895936f, -0.29902342f, 0.11804947f, 0.20366281f, -0.09077923f, 0.05850215f, -0.09689928f, 0.08556743f, 
    -0.05345330f, 0.11140870f, 0.08026476f, 0.07915922f, 0.00371335f, 0.12291618f, 0.34574208f, 0.17590788f, 
    -0.23558497f, 0.28699455f, 0.16749592f, 0.19950373f, -0.07845323f, -0.12928757f, -0.03972235f, -0.07676826f, 
    -0.02217442f, 0.07522523f, -0.02562595f, -0.31393567f, -0.06816076f, -0.05599413f, 0.09952868f, 0.02062676f, 
    0.07629699f, -0.06979128f, 0.23100947f, -0.27508730f, -0.07729107f, 0.05972823f, 0.08600701f, -0.05925388f, 
    0.13149819f, 0.05610057f, -0.26577803f, 0.04300368f, 0.32566199f, -0.00642610f, 0.06710276f, -0.08615002f, 
    0.02891829f, -0.15978941f, -0.05845506f, -0.12773307f, -0.10419928f, 0.09910111f, -0.27644768f, -0.20804740f, 
    -0.11770310f, 0.05964484f, 0.11690244f, 0.00670253f, -0.13617358f, 0.00371256f, -0.09691791f, -0.11442402f, 
    0.09680992f, 0.13473596f, -0.25753173f, -0.65494323f, 0.01624638f, 0.11290777f, -0.04627663f, 0.21943951f, 
    -0.11709570f, -0.23318042f, -0.05849901f, 0.09833734f, 0.05687323f, -0.08779150f, -0.17684795f, -0.03932784f, 
    -0.18141247f, -0.25266731f, 0.26382139f, 0.18185633f, 0.00305749f, 0.25955531f, 0.04354425f, -0.20941047f, 
    0.17110284f, -0.11175926f, 0.09875397f, 0.24539328f, -0.08808924f, 0.17214230f, 0.00316941f, -0.12454060f, 
    -0.05656628f, -0.16894093f, -0.02981496f, -0.10859686f, -0.02035306f, -0.19307107f, 0.03277540f, -0.05600700f, 
    0.14433433f, -0.06270234f, -0.14490724f, -0.07787883f, -0.00690564f, -0.19017069f, -0.17116615f, -0.16024120f, 
    -0.03076277f, 0.25680068f, 0.00880975f, -0.08194432f, 0.16969354f, -0.03449656f, 0.24170338f, 0.25021514f, 
    0.01186444f, -0.29875496f, -0.10395060f, -0.24527830f, 0.00639160f, -0.11814643f, -0.01364714f, 0.03883792f, 
    0.10940991f, -0.00066283f, -0.10469663f, -0.07667907f, 0.00346699f, -0.06757084f, 0.00346226f, 0.29370487f, 
    -0.40646741f, -0.12861857f, 0.09754723f, 0.07037218f, -0.04288877f, -0.18850030f, 0.09184557f, -0.10106578f, 
    -0.10541335f, 0.00395359f, -0.21677439f, -0.04590831f, 0.07889943f, -0.35660580f, -0.11504962f, 0.09476154f, 
    -0.17487563f, -0.10043149f, -0.23725766f, 0.08094184f, 0.03967980f, -0.28563249f, 0.13415533f, -0.06934280f, 
    0.20264895f, -0.21097970f, 0.09657066f, -0.08302129f, -0.08993532f, 0.03960398f, -0.04531546f, 0.06821579f, 
    -0.32418782f, -0.08764609f, 0.27973241f, -0.11269140f, -0.06494958f, -0.02417704f, -0.03857764f, 0.19266188f, 
    -0.09049357f, 0.01218267f, 0.01625354f, 0.06525567f, -0.13537163f, 0.01786418f, 0.10045004f, 0.25756955f, 
    0.04029683f, -0.15475668f, -0.05575892f, 0.09452768f, 0.00012209f, -0.03013290f, 0.10403274f, 0.08839692f, 
    -0.08455794f, 0.27223736f, -0.04784029f, 0.15289916f, -0.04238015f, -0.10294190f, -0.10840881f, -0.07994417f, 
    0.09697249f, 0.16333194f, -0.11888301f, -0.10775944f, 0.21427394f, 0.25690520f, -0.13964233f, 0.02064263f, 
    0.42099765f, -0.07673614f, 0.46655318f, 0.07655752f, -0.03611252f, 0.09964740f, -0.03607607f, 0.18848728f, 
    -0.14015017f, -0.12360130f, 0.00300621f, -0.01821019f, -0.01303454f, -0.21169779f, 0.01595201f, 0.22380936f, 
    0.04418654f, -0.04334352f, 0.05583286f, 0.04259908f, -0.30258042f, -0.02223491f, 0.00564047f, -0.03532274f, 
    -0.22197437f, 0.19042341f, 0.22524935f, -0.08253194f, 0.24180183f, 0.04987257f, 0.10822488f, 0.25256509f, 
    -0.27962562f, 0.08614334f, -0.02053710f, 0.16394144f, 0.04315047f, 0.07973363f, 0.26178372f, 0.30883548f, 
    0.14980082f, 0.03664999f, -0.11277457f, 0.33481812f, -0.05200553f, -0.12934983f, -0.11588833f, 0.11027120f, 
    0.19653057f, 0.21287911f, 0.30568191f, 0.26776710f, -0.09244394f, 0.21099122f, -0.11739225f, -0.08854824f, 
    0.05196931f, 0.15490203f, -0.09991692f, 0.12914863f, 0.09232796f, 0.17458537f, -0.30452439f, -0.17976454f, 
    0.22592968f, -0.03845487f, 0.07619670f, -0.17566100f, 0.06904513f, 0.15289599f, 0.01462933f, 0.04494115f, 
    -0.05696200f, 0.02906001f, -0.02153160f, -0.25823790f, 0.08042689f, -0.07691666f, 0.22600725f, 0.04313832f, 
    -0.10435486f, 0.11254685f, -0.31515929f, 0.09901087f, 0.14408779f, 0.11516533f, -0.03952621f, 0.00409543f, 
    0.38407093f, -0.06450344f, -0.05195575f, 0.06340142f, -0.01531999f, 0.06986088f, -0.08543193f, -0.14518844f, 
    0.44740474f, 0.11741499f, -0.05983116f, -0.07000862f, 0.08800226f, 0.03903352f, 0.13798934f, 0.22783211f, 
    0.02712712f, 0.05641949f, 0.07856601f, -0.05764958f, 0.26966298f, 0.15361911f, 0.10724621f, -0.09943317f, 
    0.25929686f, -0.13005653f, 0.06675614f, 0.08130890f, -0.07798344f, 0.16730186f, 0.11466409f, 0.23865944f, 
    -0.19225256f, -0.01466941f, 0.02846980f, -0.04261827f, 0.12053767f, 0.02180560f, 0.29822785f, 0.04372492f, 
    -0.25107247f, 0.11661139f, 0.21365303f, -0.08941051f, 0.12634714f, 0.01526582f, 0.02554398f, -0.16405736f, 
    0.03600667f, -0.06321168f, -0.10352187f, -0.04751449f, 0.02633286f, -0.01982798f, -0.13687563f, -0.18383053f, 
    -0.10345209f, 0.10555188f, 0.10481213f, 0.01031153f, 0.14302668f, 0.18788056f, 0.03381698f, -0.00456523f, 
    -0.00317298f, 0.36379319f, 0.10139371f, -0.10365158f, 0.40977377f, -0.08699591f, -0.16361533f, 0.06747532f, 
    -0.05783860f, -0.22732204f, -0.13059488f, 0.06442387f, -0.06234831f, 0.02693665f, -0.11700347f, -0.33602875f, 
    0.01213372f, -0.15430966f, 0.07020275f, 0.21800412f, -0.13499807f, 0.06993122f, 0.07095661f, 0.07113805f, 
    0.04696886f, -0.10170676f, -0.40568304f, -0.28403127f, 0.05845621f, -0.06198961f, -0.10910624f, -0.09114128f, 
    0.06067754f, -0.12785676f, -0.07906528f, 0.07713155f, 0.09906709f, 0.19178139f, 0.01268324f, -0.01970191f, 
    -0.12310008f, -0.24690114f, -0.14463048f, 0.13123235f, -0.10252010f, 0.18338943f, 0.09157331f, -0.07118909f, 
    -0.02427218f, -0.12025779f, 0.24116877f, -0.16495895f, -0.02723907f, -0.05207119f, -0.02704618f, 0.09499400f, 
    -0.05000436f, 0.14215849f, 0.01500657f, -0.06527801f, -0.06537127f, 0.21618991f, 0.07705475f, -0.06671282f, 
    0.04703392f, 0.01964504f, -0.22981460f, 0.07839325f, -0.15256314f, -0.06958620f, -0.20131524f, -0.21675581f, 
    0.04235395f, 0.07357299f, -0.02088266f, 0.08921356f, 0.14960769f, 0.07222856f, 0.15972196f, -0.03800596f, 
    0.20932868f, 0.18083839f, 0.01473450f, -0.18704282f, 0.10617927f, 0.14907926f, -0.01524316f, -0.11031021f, 
    0.01391838f, 0.09469315f, 0.17188047f, -0.21702074f, 0.12470929f, 0.32381445f, 0.06068977f, 0.25928834f, 
    -0.04988622f, -0.12846006f, -0.05052945f, -0.01627895f, 0.26374051f, -0.01658144f, -0.09994643f, -0.02701109f, 
    -0.02976723f, -0.16412582f, -0.01543723f, 0.15176803f, 0.10570071f, 0.14904095f, -0.00462368f, -0.17719448f, 
    0.31570664f, -0.11391034f, 0.16555522f, -0.04801853f, -0.12176518f, -0.16601770f, -0.18999562f, 0.15373887f, 
    0.23148495f, 0.10331155f, 0.00577175f, 0.26517487f, -0.04478439f, -0.07295344f, -0.03527968f, 0.01311559f, 
    -0.14846389f, -0.14671603f, 0.06405897f, 0.09286852f, -0.18448575f, 0.31590241f, 0.12251502f, 0.00140452f, 
    -0.01835153f, 0.07463026f, 0.09691458f, -0.06999450f, -0.18636264f, 0.11391304f, 0.02457763f, 0.07873882f, 
    0.06506909f, 0.23976752f, -0.08688604f, 0.10243978f, 0.01499956f, 0.01090483f, 0.12287612f, -0.08886327f, 
    -0.19644302f, -0.12372579f, 0.04413617f, 0.26232865f, 0.01540614f, -0.07859392f, -0.08373202f, -0.03029694f, 
    0.23341815f, 0.23475587f, -0.03065160f, -0.07133629f, 0.02898478f, 0.21189927f, 0.12960424f, 0.07686067f, 
    0.20806742f, 0.32302999f, 0.35249704f, 0.19424331f, -0.11047297f, -0.10328047f, -0.03047276f, 0.41025835f, 
    -0.06974456f, 0.04327747f, -0.15406875f, 0.00288181f, 0.01913549f, -0.08397187f, 0.11882307f, 0.12824583f, 
    0.27739897f, -0.11883851f, -0.00444702f, -0.00907790f, -0.04562069f, 0.14302219f, 0.09677849f, 0.07214788f, 
    -0.15240775f, 0.11868481f, 0.15064022f, -0.08005428f, 0.11013524f, 0.22279720f, 0.13595453f, 0.01730359f, 
    0.17030419f, 0.05515387f, 0.09923770f, -0.10758282f, -0.20838813f, -0.13194333f, -0.07790771f, -0.02317762f, 
    -0.18770052f, 0.16355610f, 0.00009135f, -0.09234054f, -0.06142587f, 0.15590465f, 0.05075071f, -0.07288904f, 
    -0.26778817f, 0.45152783f, 0.12294576f, -0.09843259f, -0.08082730f, 0.09060588f, 0.00223707f, -0.11328635f, 
    0.18209873f, -0.01195004f, 0.09521231f, -0.05964754f, 0.41680726f, 0.14911120f, -0.13748123f, 0.00342767f, 
    0.30671141f, -0.20417947f, 0.11378808f, -0.16170698f, 0.10808825f, 0.13704912f, 0.09348221f, 0.43692213f, 
    -0.15307352f, -0.10760349f, -0.01593262f, -0.19802885f, 0.10964170f, -0.27901018f, -0.02209531f, 0.31579286f, 
    -0.18728033f, -0.11101927f, 0.07219075f, -0.03498580f, -0.10011569f, 0.07065364f, -0.06772147f, -0.09407195f, 
    0.05754997f, -0.02288315f, 0.09357855f, 0.07356501f, 0.01966742f, -0.12294385f, 0.20143989f, 0.06602972f, 
    -0.17062937f, 0.27597049f, 0.01961529f, -0.05491119f, 0.02034750f, -0.00582691f, 0.31421140f, 0.19270104f, 
    0.20850138f, -0.16182153f, 0.00877804f, -0.08126627f, -0.05091544f, 0.05284599f, 0.12587953f, 0.03364874f, 
    0.09287676f, -0.13439953f, 0.20100522f, 0.32426819f, 0.01161333f, 0.13506365f, 0.11155326f, 0.13719089f, 
    0.00882305f, 0.26589197f, 0.05332938f, 0.04591194f, -0.14849532f, -0.02572140f, 0.14127451f, 0.00741169f, 
    0.27981979f, 0.07974835f, -0.02546692f, 0.22848390f, 0.07503515f, -0.14050332f, -0.10638203f, -0.13428670f, 
    0.08075771f, -0.07521893f, -0.01331335f, 0.13773176f, -0.00657573f, 0.24645090f, 0.00209973f, 0.13147205f, 
    0.07545029f, -0.08183520f, -0.11939526f, 0.06925283f, -0.00840124f, -0.01878675f, 0.08906136f, -0.03102094f, 
    -0.22867344f, -0.20135576f, 0.02452238f, 0.12192235f, -0.01821447f, -0.08438347f, 0.15340215f, -0.19889316f, 
    0.13903382f, 0.08083896f, 0.06671776f, 0.07779680f, -0.13153636f, 0.09236845f, -0.11978060f, 0.12537484f, 
    -0.10245627f, 0.00991620f, -0.10733710f, -0.10968981f, -0.14428775f, -0.13510668f, -0.11916749f, 0.11260042f, 
    0.04186183f, 0.10369943f, -0.15857834f, -0.05121557f, -0.10469089f, 0.11638040f, -0.01805207f, -0.09611122f, 
    0.17210558f, 0.00296701f, -0.10039179f, -0.09618831f, 0.07424176f, 0.09649567f, 0.06194197f, 0.05905347f, 
    -0.03976470f, 0.15695274f, 0.02959285f, -0.04490694f, -0.10725480f, 0.02643413f, 0.07163493f, -0.07913207f, 
    -0.16565560f, 0.00945105f, -0.02934822f, 0.10865501f, -0.11230019f, 0.09735991f, 0.05635511f, -0.09051941f, 
    -0.12434406f, -0.09256077f, -0.11025694f, -0.06033677f, -0.15338349f, -0.05280043f, 0.03952402f, 0.06913558f, 
    -0.07999514f, -0.00141277f, -0.06492217f, 0.06491143f, 0.05518146f, -0.04071289f, 0.10802040f, -0.03420703f, 
    -0.01459490f, -0.12531918f, -0.02200144f, 0.07621363f, -0.06405212f, 0.07594519f, 0.05577156f, 0.08232891f, 
    -0.14069179f, -0.08094998f, -0.13536878f, -0.11956947f, 0.07850280f, -0.09386698f, -0.00359740f, -0.02266086f, 
    0.07759407f, 0.00300251f, 0.00605598f, -0.01907071f, 0.03098907f, 0.05002605f, -0.02987657f, -0.07054786f, 
    -0.05867027f, 0.06144407f, -0.07480292f, 0.11283710f, -0.00729203f, -0.12874766f, -0.08828331f, -0.07837728f, 
    -0.11452536f, -0.01543513f, 0.07420862f, -0.11086755f, 0.07818901f, -0.13194217f, -0.08362408f, -0.11189593f, 
    -0.06478964f, -0.07328422f, 0.00219109f, -0.06858301f, 0.00633104f, -0.06326133f, -0.01817224f, 0.11462504f, 
    0.08530355f, -0.23425592f, 0.12621349f, -0.01871727f, 0.20602131f, 0.18431944f, 0.00310311f, -0.00029387f, 
    -0.10422880f, 0.30225965f, 0.29185286f, 0.08471056f, 0.25150791f, -0.28011280f, -0.27258930f, 0.22549038f, 
    -0.14216097f, -0.00064104f, 0.04008842f, 0.04139842f, 0.09427806f, -0.00023306f, 0.12677076f, 0.11940639f, 
    0.26662371f, -0.20478943f, 0.07835001f, 0.22406974f, 0.06279928f, 0.09987719f, 0.08333203f, 0.12941954f, 
    -0.10680627f, -0.11628193f, -0.15368335f, 0.01809367f, 0.01192553f, 0.12596105f, -0.07253946f, -0.00887923f, 
    -0.03723879f, 0.25745454f, -0.08873481f, -0.05985527f, 0.20556061f, 0.07631770f, -0.11049873f, 0.18389267f, 
    0.24017380f, -0.20888306f, -0.00971134f, 0.25818980f, -0.02942287f, -0.20885855f, 0.08650322f, -0.06608067f, 
    -0.09095975f, 0.02423456f, -0.00716351f, 0.14484948f, 0.01186584f, -0.14511532f, 0.20040153f, 0.14878048f, 
    -0.10554164f, 0.08509256f, -0.18166536f, 0.00926015f, -0.26697558f, 0.32411221f, 0.09265018f, -0.06058796f, 
    0.25972372f, 0.19342756f, -0.18896015f, 0.05437172f, 0.12356964f, -0.10633957f, -0.24067408f, 0.06735333f, 
    0.42519432f, -0.04393163f, 0.08626582f, -0.18934374f, 0.06718373f, 0.03864057f, 0.07039117f, -0.03890622f, 
    0.05865683f, 0.17673035f, -0.06812700f, -0.09689517f, -0.00541167f, 0.23025618f, -0.04210158f, -0.07812449f, 
    0.03559989f, 0.22449124f, 0.10656952f, -0.11405689f, -0.08425751f, 0.31204042f, -0.07098813f, 0.37285945f, 
    -0.11615244f, -0.26890862f, 0.08715175f, 0.11690733f, 0.57822776f, 0.13508038f, 0.29040042f, 0.13695243f, 
    -0.12927642f, -0.28830731f, -0.25407788f, -0.00084362f, 0.03966656f, -0.03816993f, 0.10165817f, 0.00516289f, 
    0.17986108f, -0.05893835f, 0.21931636f, -0.18668169f, 0.09808493f, -0.13496043f, -0.40862060f, 0.07343943f, 
    0.07934944f, -0.06095884f, -0.02608312f, -0.02513477f, 0.01345145f, -0.01448215f, 0.11990620f, 0.01252705f, 
    0.00843399f, -0.08231522f, 0.08146593f, 0.01020908f, -0.05185295f, -0.15567484f, 0.09372889f, -0.08857401f, 
    -0.11700092f, -0.06108143f, -0.07797293f, 0.06027843f, -0.14049433f, 0.08480959f, 0.02926639f, -0.03145072f, 
    -0.07559262f, -0.07721281f, 0.01992887f, -0.01436710f, -0.05580969f, 0.00411854f, 0.09807049f, 0.06335659f, 
    -0.08879939f, 0.03918917f, -0.08351830f, -0.05637132f, 0.11118810f, -0.01821845f, 0.02410868f, 0.01311822f, 
    0.02559093f, 0.07875468f, 0.06637950f, -0.08588143f, 0.07708420f, -0.07207973f, -0.10261782f, -0.05585678f, 
    -0.09610692f, -0.16154084f, -0.07318163f, 0.03402659f, -0.09952681f, -0.13028949f, -0.08639851f, -0.00664904f, 
    -0.12663886f, 0.00013122f, -0.03158369f, 0.06589939f, -0.10151319f, -0.02109350f, -0.08599781f, 0.06304113f, 
    0.21426524f, 0.15621454f, 0.14666386f, -0.17581062f, -0.07836444f, -0.00684240f, -0.02116911f, 0.08856487f, 
    0.11850520f, 0.16173276f, -0.26639807f, -0.02046120f, -0.05058528f, 0.28049833f, -0.00371175f, -0.10211601f, 
    0.37280041f, -0.00688387f, 0.07131461f, 0.10600113f, 0.06937276f, 0.03264910f, -0.28854531f, -0.40051860f, 
    -0.12601738f, 0.20676485f, 0.08915986f, 0.26122853f, -0.45471400f, 0.11417746f, 0.09303634f, 0.04883094f, 
    -0.05473003f, -0.00114560f, -0.54604274f, -0.41101557f, 0.07690887f, -0.16817670f, -0.07060224f, -0.00716344f, 
    0.31946993f, -0.41840017f, 0.00438797f, 0.04967400f, 0.03905056f, 0.07808701f, 0.08780340f, 0.13971892f, 
    -0.44806206f, -0.18481670f, 0.24348164f, -0.00618725f, -0.08682847f, 0.17742264f, 0.07355013f, 0.14074014f, 
    0.07958180f, 0.05317583f, 0.08971325f, 0.06943858f, 0.05512305f, -0.03340179f, 0.11034485f, 0.11011644f, 
    0.10350413f, -0.04005662f, 0.03045793f, -0.10488283f, -0.06986288f, -0.00290318f, -0.04447193f, 0.10199974f, 
    -0.00259340f, 0.08725998f, -0.03249327f, -0.11120693f, -0.11967193f, 0.02606628f, -0.04785633f, -0.09704985f, 
    -0.14550711f, -0.15610994f, -0.04787588f, 0.07428636f, -0.07963405f, -0.01225655f, -0.07588331f, -0.05016977f, 
    -0.06099457f, -0.01835020f, 0.02871354f, 0.11224377f, 0.14063166f, 0.01376961f, -0.10080670f, -0.09928648f, 
    -0.10446052f, 0.07495856f, 0.04144992f, 0.02656995f, 0.08027387f, 0.00657124f, 0.08340859f, 0.09617186f, 
    -0.07474688f, -0.11309075f, -0.09216365f, 0.00657493f, -0.10838342f, -0.07229274f, -0.14459842f, 0.05538348f, 
    0.01133849f, -0.18111062f, -0.06716969f, -0.15767145f, -0.06578176f, 0.07617187f, -0.00686264f, -0.20080063f, 
    0.00844282f, -0.01932572f, 0.11951059f, -0.06898300f, -0.11940402f, -0.11186215f, 0.08398927f, 0.08036340f, 
    -0.21172650f, 0.08396836f, -0.16426684f, 0.11241795f, -0.08948885f, 0.15934467f, -0.05545202f, 0.06115980f, 
    0.19302367f, -0.00291216f, -0.25823131f, -0.13595003f, 0.07910454f, 0.17893557f, -0.02993699f, -0.07350212f, 
    0.41277245f, -0.02441147f, 0.08795881f, -0.25461349f, 0.10782068f, 0.01566811f, 0.02727579f, 0.00285429f, 
    -0.21157672f, 0.17631821f, -0.08163051f, 0.00800436f, -0.08170239f, 0.19899525f, -0.11721700f, 0.11594816f, 
    -0.00385113f, -0.17977746f, 0.16082522f, 0.00531108f, -0.00537077f, 0.20116378f, -0.12325580f, 0.07033756f, 
    0.11505871f, -0.22850393f, -0.05463053f, -0.02633070f, -0.13667323f, 0.13941744f, 0.22554131f, -0.00074579f, 
    -0.34456840f, 0.14676277f, -0.29455364f, -0.07589791f, -0.11527687f, 0.22377421f, 0.12963064f, -0.10942089f, 
    0.22179507f, 0.06334893f, 0.29119658f, -0.27179974f, 0.00918329f, 0.17167892f, -0.45500395f, 0.16485251f, 
    -0.39901185f, -0.15086660f, -0.07669892f, 0.11866274f, -0.05848427f, -0.36137977f, 0.10801975f, 0.11927097f, 
    -0.00752620f, 0.02843065f, 0.08356465f, -0.00899985f, 0.37818909f, -0.14462049f, -0.14717861f, 0.25042337f, 
    -0.11451238f, 0.06604706f, -0.00234764f, -0.43331364f, 0.12860262f, -0.02336732f, 0.17329574f, 0.12924194f, 
    -0.06137390f, -0.10562187f, -0.07791904f, 0.28408778f, 0.16704018f, 0.09682735f, -0.11333141f, -0.00373908f, 
    0.06442263f, -0.48473167f, 0.02093987f, 0.06532679f, 0.01586566f, -0.13942386f, -0.04368361f, -0.07122253f, 
    -0.03741150f, 0.13513176f, 0.03717873f, -0.12473465f, -0.33200687f, 0.17565395f, -0.02716183f, 0.10626733f, 
    0.16102825f, 0.00272983f, -0.10760652f, -0.13338301f, -0.00983985f, -0.06909381f, -0.09854304f, -0.33021384f, 
    0.07569537f, 0.11263444f, 0.14240582f, 0.31830809f, -0.03767021f, 0.39799425f, -0.06609520f, 0.02279486f, 
    0.06184426f, 0.06599144f, -0.31960773f, 0.10531104f, -0.28968725f, 0.09319684f, -0.00950697f, -0.07053936f, 
    0.13983157f, -0.10380755f, 0.05777470f, 0.04090147f, -0.14612104f, 0.27061951f, 0.41488642f, -0.14752525f, 
    -0.14834718f, 0.18764833f, -0.06663960f, -0.36547640f, -0.30892646f, -0.08490302f, 0.06939742f, 0.03240839f, 
    0.03588428f, 0.50689095f, -0.05524850f, 0.28069407f, -0.02342274f, -0.04232000f, 0.09601575f, -0.07177614f, 
    -0.03435589f, 0.36619735f, 0.08028382f, -0.06208058f, 0.08559211f, -0.10024920f, 0.05218504f, -0.06698397f, 
    0.20273481f, 0.12996592f, -0.11217465f, -0.04897324f, 0.22966708f, 0.12479633f, -0.20315023f, -0.16093844f, 
    0.00762130f, -0.12018309f, -0.49636328f, 0.04885224f, -0.09406096f, 0.25016236f, 0.05243759f, 0.23850575f, 
    -0.11449196f, 0.10082423f, 0.18454097f, -0.01068581f, -0.01567949f, 0.21915188f, 0.29085296f, 0.32982099f, 
    0.14343217f, 0.12215161f, 0.13717756f, -0.14746924f, -0.06086474f, 0.13024805f, -0.03611065f, -0.11590842f, 
    -0.04806389f, 0.09958956f, -0.10705512f, -0.00257361f, -0.09928550f, 0.04863698f, 0.04082095f, -0.29732558f, 
    0.21275148f, -0.05838637f, 0.03591102f, 0.18846281f, 0.11445410f, -0.01875345f, -0.08731312f, -0.00500641f, 
    -0.14433767f, -0.06039044f, -0.04872301f, -0.32514647f, -0.19852753f, 0.20493273f, 0.05287119f, 0.00115782f, 
    0.22922333f, 0.19514742f, 0.00652285f, 0.05725761f, -0.03145451f, 0.34979716f, 0.09209137f, 0.17082040f, 
    0.13380635f, -0.18696325f, -0.00089322f, 0.05896352f, -0.15586939f, 0.23800565f, -0.03432107f, -0.08145704f, 
    -0.03282002f, 0.34579971f, 0.24010541f, 0.21325892f, -0.05468683f, 0.22598524f, 0.07914186f, -0.13846543f, 
    0.35009548f, -0.07938726f, 0.14422865f, -0.06383213f, 0.10206412f, 0.05740244f, -0.12101090f, 0.18793984f, 
    0.05237867f, -0.13580228f, 0.37630677f, -0.07926489f, -0.12712826f, 0.37010556f, -0.08835998f, -0.03732325f, 
    0.05360146f, 0.01617023f, 0.10491184f, 0.09974764f, -0.14918067f, -0.16431612f, -0.38332906f, -0.08202684f, 
    -0.04976778f, -0.12569545f, 0.00048723f, 0.08356558f, 0.06889066f, -0.11981376f, 0.01517429f, -0.16951221f, 
    0.25292754f, -0.00791213f, -0.10871289f, 0.15486431f, -0.13727170f, 0.08832537f, 0.11894778f, -0.06503464f, 
    -0.14451070f, 0.14094719f, 0.00107052f, -0.06462410f, 0.05833861f, 0.26408806f, -0.00521947f, 0.11603665f, 
    0.07117569f, -0.17274672f, 0.09280457f, -0.10079710f, 0.35960415f, 0.06391258f, -0.10350814f, 0.18130873f, 
    0.14040996f, 0.03244235f, -0.18722613f, 0.31766176f, 0.07369060f, -0.13622420f, 0.08762722f, 0.08751401f, 
    0.18247211f, 0.07317520f, 0.12523526f, 0.16425097f, -0.11249684f, -0.17958298f, -0.04874890f, 0.33440802f, 
    -0.12123683f, -0.07483406f, 0.26322630f, 0.20379426f, -0.15368102f, 0.11075272f, 0.00182418f, -0.09018678f, 
    0.18160678f, 0.12732051f, 0.10501519f, 0.08462720f, -0.01641433f, -0.05667904f, -0.49922332f, 0.11565202f, 
    -0.25544307f, -0.02257229f, 0.00678460f, 0.03713179f, 0.18691777f, -0.08292072f, 0.16776249f, -0.02993334f, 
    0.30435294f, -0.04554382f, -0.07687555f, 0.06835412f, 0.10469366f, 0.02897681f, -0.06697925f, -0.06787504f, 
    0.19791858f, -0.30038750f, 0.11698809f, -0.01119923f, 0.11653277f, 0.20427807f, -0.10034373f, 0.00880607f, 
    -0.30014175f, -0.12825325f, -0.03479360f, -0.00308819f, -0.03374475f, 0.01716921f, 0.18316616f, 0.20547096f, 
    -0.06580675f, 0.09806823f, 0.11243553f, 0.22660379f, -0.08458628f, 0.00176685f, 0.06261290f, -0.37188938f, 
    0.07325231f, 0.06657399f, -0.06085207f, 0.28702509f, 0.03174227f, -0.10621870f, 0.06732049f, -0.15609923f, 
    -0.01491445f, 0.15461910f, -0.13810147f, 0.05316161f, 0.03393327f, -0.09903336f, 0.04129590f, 0.07582968f, 
    -0.01127846f, -0.13289861f, 0.03572638f, -0.10834394f, 0.11393052f, 0.31904453f, 0.34821898f, -0.19934884f, 
    0.23890854f, -0.11541300f, 0.09857585f, -0.14092743f, 0.01920214f, 0.03034887f, -0.13843545f, -0.20133083f, 
    -0.33530989f, 0.20844804f, -0.06283390f, -0.01195387f, -0.23681085f, 0.19225703f, 0.06634164f, -0.08002107f, 
    0.02091199f, -0.24302745f, -0.16367899f, 0.23652853f, 0.03726378f, 0.02054546f, 0.11275593f, -0.04552296f, 
    0.46906477f, 0.03030011f, -0.01981190f, -0.13211237f, -0.39559802f, 0.19134872f, -0.00547686f, 0.13265872f, 
    -0.30374950f, 0.40859693f, -0.22102103f, 0.08850835f, -0.02321035f, 0.11633615f, 0.02483512f, 0.10353877f, 
    0.14115572f, 0.11149929f, 0.11142727f, 0.13429722f, 0.08043988f, 0.47226653f, -0.17770275f, 0.25323680f, 
    -0.10162397f, -0.09088193f, 0.01889989f, -0.16390724f, 0.06378371f, -0.07919315f, 0.03589775f, -0.03942579f, 
    -0.01536700f, 0.03581113f, 0.08976760f, 0.10832520f, -0.09046755f, -0.04514183f, -0.07427883f, 0.07280197f, 
    -0.00011840f, -0.15454863f, -0.13139693f, -0.17860220f, -0.09058907f, -0.07408678f, 0.04683419f, -0.14187737f, 
    0.00568376f, 0.00194167f, -0.11438601f, 0.03008823f, 0.00396582f, 0.00571086f, -0.03277769f, 0.08890145f, 
    0.10511184f, 0.09218153f, -0.01526913f, -0.03646035f, 0.01261849f, -0.10270008f, -0.04096662f, -0.12030671f, 
    -0.03933660f, 0.08669095f, 0.03765270f, -0.05549891f, -0.11476687f, -0.11585635f, 0.07389849f, -0.00761056f, 
    0.06278682f, -0.03700144f, 0.07490271f, -0.06241863f, 0.04585496f, -0.07667172f, -0.00934929f, 0.07099192f, 
    -0.00058948f, 0.04923327f, -0.13988608f, 0.03739661f, -0.09554303f, -0.08699867f, -0.10252009f, 0.03970922f, 
    -0.13779858f, 0.01141650f, -0.13657603f, -0.02509669f, -0.11842774f, -0.08971642f, -0.01009263f, 0.06273361f, 
    0.00455424f, 0.09467635f, -0.07873180f, 0.11256899f, 0.06402010f, -0.12666336f, -0.04931501f, 0.02512960f, 
    -0.00110319f, 0.02167230f, 0.10104378f, -0.09773172f, -0.02386493f, -0.02096869f, -0.11777131f, -0.04720838f, 
    -0.11988746f, -0.10121953f, -0.10933025f, -0.01277707f, -0.07665592f, 0.00508482f, -0.07961078f, -0.05017847f, 
    -0.01582090f, -0.01835845f, 0.05610547f, -0.02254545f, 0.10202703f, -0.10948257f, -0.04664107f, 0.05103500f, 
    0.06644269f, 0.08939917f, -0.07226869f, -0.02417329f, -0.10870744f, 0.01219822f, -0.13466839f, 0.01643881f, 
    -0.03460909f, -0.10961907f, -0.16162553f, -0.05695619f, -0.11308528f, -0.06878630f, 0.02551998f, 0.07612470f, 
    0.04577311f, -0.00172897f, -0.12668656f, 0.04393953f, 0.05651020f, 0.09852517f, 0.09127793f, 0.04182173f, 
    0.22393139f, 0.23832299f, -0.36162895f, 0.04197077f, -0.07526204f, -0.01490559f, -0.07401651f, 0.11580466f, 
    0.33127734f, -0.20098418f, -0.17347755f, -0.07394494f, 0.18277997f, -0.01191802f, 0.27955884f, -0.17111476f, 
    0.19286673f, 0.17232895f, 0.00539017f, -0.17752467f, 0.01291142f, -0.04145962f, 0.01840757f, -0.03788642f, 
    -0.06125299f, 0.34169891f, 0.11575461f, -0.24370833f, 0.09400958f, 0.09979749f, -0.03258026f, -0.08348601f, 
    0.07616990f, 0.32253727f, 0.05062946f, -0.17977768f, 0.05778267f, 0.06116981f, -0.05823863f, 0.20952088f, 
    0.13935852f, -0.04707294f, -0.11320052f, 0.08122833f, 0.06630664f, -0.05956190f, -0.03483030f, -0.16925301f, 
    0.11480214f, -0.28482941f, -0.28017619f, -0.05943654f, -0.07304970f, 0.13658591f, 0.00888677f, -0.09768887f, 
    0.15929291f, -0.09552269f, 0.17083056f, 0.07123420f, -0.04990323f, -0.04770789f, 0.24007805f, 0.26075655f, 
    0.12282301f, 0.03726896f, 0.24803342f, 0.01748194f, 0.04025464f, -0.22886270f, 0.07568864f, 0.11030187f, 
    -0.18629701f, -0.01965332f, 0.23528814f, 0.00625365f, -0.27735373f, 0.16146438f, -0.01872210f, -0.09789439f, 
    -0.28421772f, 0.09990773f, -0.08858345f, 0.14994821f, -0.04909931f, -0.07412560f, -0.02055106f, 0.15987851f, 
    -0.00178315f, -0.18147691f, 0.09613308f, -0.13063113f, -0.05185322f, 0.02052789f, -0.10766469f, 0.01388366f, 
    0.05769790f, -0.28755403f, 0.09244797f, 0.25278521f, -0.02800155f, 0.15157107f, 0.07668964f, -0.25313374f, 
    0.04958145f, 0.11224418f, -0.09424429f, -0.08174615f, -0.51251626f, 0.23717329f, -0.03143742f, 0.03566478f, 
    0.22505526f, 0.51139104f, 0.09116866f, 0.02144863f, 0.08258022f, 0.01860760f, 0.08143737f, 0.08398913f, 
    -0.00812218f, -0.01358583f, -0.00436176f, 0.20039359f, 0.10076490f, 0.31421489f, 0.10053357f, -0.14441557f, 
    0.18788761f, 0.13049023f, 0.14422938f, 0.06273416f, -0.11527592f, 0.05825957f, -0.04566020f, 0.03997319f, 
    -0.05631129f, 0.03324389f, -0.08950508f, 0.06706300f, -0.21810889f, 0.14441079f, -0.21138881f, -0.09656159f, 
    -0.10571462f, 0.03529728f, 0.04222544f, -0.07767914f, 0.18337639f, 0.03373173f, -0.11242367f, -0.05288182f, 
    0.30252171f, 0.09601450f, 0.06539477f, 0.15068333f, -0.02543870f, -0.05212865f, 0.02217398f, -0.00604992f, 
    0.00309860f, 0.26899227f, 0.21880057f, -0.11981382f, -0.09725256f, 0.10446493f, -0.12274078f, 0.13521764f, 
    0.05970094f, -0.34919709f, 0.04823095f, 0.03781645f, 0.02679375f, 0.03029318f, 0.03295400f, -0.06456608f, 
    -0.09077459f, 0.07058535f, -0.04382225f, 0.23105045f, -0.06611490f, 0.02487543f, 0.01035840f, -0.15856054f, 
    0.25926542f, -0.10966850f, 0.07392632f, 0.25309846f, -0.04722336f, -0.17045625f, -0.14768575f, 0.13194473f, 
    -0.10908223f, -0.24769442f, 0.09043846f, 0.19491263f, -0.07824246f, -0.01584898f, 0.04859122f, -0.05373821f, 
    0.03608045f, 0.10501229f, 0.06195410f, -0.03716198f, -0.03425673f, 0.12878627f, 0.08389066f, 0.14140609f, 
    -0.18942735f, 0.09267951f, -0.12707327f, 0.13359338f, 0.00070750f, -0.02871660f, 0.05271130f, 0.22960816f, 
    0.05388822f, -0.12331287f, 0.05417557f, -0.42887789f, -0.11905922f, 0.08754522f, -0.04761085f, -0.06012871f, 
    -0.00901390f, 0.08171493f, 0.24046497f, 0.11476547f, 0.03732916f, 0.08764929f, 0.08418498f, -0.12427016f, 
    -0.03010909f, 0.13115977f, -0.01134281f, 0.09354836f, -0.14773206f, 0.01933487f, -0.02872413f, 0.00574345f, 
    0.13023816f, -0.01398894f, -0.03165272f, 0.00479341f, 0.11284776f, -0.20554736f, 0.08162817f, -0.07276108f, 
    -0.15136299f, 0.00642710f, -0.41721541f, -0.08068014f, 0.00650732f, -0.12372987f, -0.13998348f, 0.01850244f, 
    0.12171935f, 0.17922227f, -0.05538132f, -0.20842569f, -0.05130074f, 0.22255218f, -0.10084173f, 0.00240146f, 
    0.17734006f, 0.01572370f, 0.01344492f, -0.03538612f, 0.28031367f, -0.17473164f, -0.23278271f, -0.27204248f, 
    0.08383012f, -0.07409658f, 0.14328788f, -0.18055406f, 0.30345771f, 0.00284371f, -0.05517981f, -0.19360523f, 
    0.01737517f, -0.01418147f, 0.04292580f, -0.08549299f, -0.08034669f, 0.17629515f, -0.06322171f, -0.03771051f, 
    0.08091131f, -0.00445849f, -0.21398476f, -0.08821426f, -0.04287692f, -0.03049246f, -0.11923785f, 0.30430114f, 
    0.24364011f, -0.04880835f, -0.04536775f, 0.05271476f, 0.12675007f, 0.10826722f, 0.06916446f, -0.00377794f, 
    0.03069172f, -0.17207216f, -0.36451405f, 0.15947349f, 0.07104880f, 0.10683744f, -0.04962862f, -0.09529711f, 
    0.19749320f, -0.08715802f, 0.06605034f, 0.34888315f, -0.11401710f, 0.14100395f, -0.28197062f, 0.31340644f, 
    -0.04161231f, 0.15202194f, 0.27013990f, 0.28834397f, -0.15967871f, 0.04714434f, 0.01708431f, 0.01521543f, 
    0.01249536f, 0.02974254f, -0.02592293f, -0.12586100f, -0.48756212f, 0.14964527f, -0.02761283f, -0.09594680f, 
    -0.26314053f, 0.19438681f, -0.08303626f, -0.33015606f, -0.21819001f, -0.01342797f, 0.10576453f, -0.00728087f, 
    0.06168623f, 0.18846352f, 0.03027430f, 0.16421275f, -0.17908046f, -0.02620457f, -0.08046547f, 0.11798313f, 
    -0.12325067f, -0.20529063f, 0.01735195f, -0.10972454f, 0.08010577f, 0.20886846f, 0.05346166f, -0.00838554f, 
    0.22334459f, -0.16296981f, 0.00317682f, -0.00706367f, -0.06550270f, 0.12338394f, 0.00608201f, -0.14497976f, 
    -0.00365960f, 0.26763850f, 0.12049036f, 0.16055065f, 0.09540376f, -0.04420007f, -0.08566916f, 0.12319706f, 
    0.15530452f, 0.08227144f, 0.05328956f, 0.12875237f, -0.00522503f, -0.13302355f, -0.09078506f, 0.04459270f, 
    0.11418823f, 0.05235308f, 0.23332500f, 0.21799557f, -0.13187250f, 0.15150717f, 0.06479958f, -0.11889991f, 
    -0.11922604f, -0.11385155f, 0.00783738f, 0.01013339f, -0.46544397f, 0.29832712f, 0.02130232f, 0.04905621f, 
    -0.29561874f, 0.17684701f, -0.08588251f, -0.12695234f, -0.16847195f, 0.06892093f, 0.01415350f, 0.01468340f, 
    0.19138785f, 0.23919851f, 0.02272987f, 0.32054362f, 0.05954562f, -0.12401415f, -0.07985801f, -0.07339248f, 
    0.11710211f, 0.01635110f, 0.35425562f, -0.02789805f, 0.05117787f, 0.23271188f, -0.05984614f, 0.01080454f, 
    0.02756135f, 0.04177313f, 0.11309813f, 0.07571725f, 0.00556886f, -0.07909056f, -0.02127939f, -0.18994346f, 
    0.13500701f, 0.29851797f, 0.07487339f, -0.01301244f, -0.04627709f, 0.06073879f, -0.06489913f, 0.17079489f, 
    -0.13276908f, -0.06025942f, 0.10101852f, -0.08170900f, 0.09406713f, -0.14876899f, 0.03611410f, -0.02550101f, 
    0.09945612f, -0.13763730f, 0.27569219f, -0.08696953f, -0.04449445f, 0.23012614f, 0.02136016f, 0.01402341f, 
    0.02652539f, -0.03892500f, 0.22819810f, 0.07415214f, 0.04633379f, -0.36134183f, -0.35751382f, -0.04625047f, 
    -0.18663825f, 0.14424238f, -0.03334935f, 0.13390186f, 0.27882519f, 0.11030435f, 0.02187840f, -0.06943391f, 
    0.37151319f, -0.21552862f, -0.04674844f, -0.06272978f, 0.15491812f, -0.02554759f, 0.11417913f, 0.05963663f, 
    -0.01874443f, 0.20868452f, -0.11686169f, 0.01411160f, 0.11276515f, -0.01460441f, -0.03713266f, 0.17642985f, 
    0.05094282f, -0.07571332f, 0.04965378f, -0.06105157f, 0.11312072f, 0.01843328f, -0.26123300f, -0.01939556f, 
    0.25980616f, -0.17443129f, 0.06460815f, 0.21236169f, 0.11948983f, -0.08340207f, -0.07511789f, -0.24087374f, 
    0.20128800f, -0.07269090f, -0.14623120f, 0.36903796f, -0.11418323f, -0.09144703f, 0.02395172f, 0.11382054f, 
    -0.06614403f, -0.10059869f, -0.07530176f, -0.11143932f, -0.09403974f, -0.05701786f, 0.10829165f, -0.02906895f, 
    0.01909725f, 0.07138195f, 0.04983060f, 0.05370584f, -0.06606195f, -0.10848464f, -0.04214364f, 0.08498211f, 
    0.03133876f, -0.01546558f, 0.08128375f, -0.10897088f, -0.04022349f, 0.01682322f, -0.07208601f, -0.04787189f, 
    -0.02809571f, 0.11902508f, -0.04826371f, 0.09448792f, 0.02804294f, -0.09491469f, 0.11886346f, 0.03290246f, 
    0.00878577f, -0.09949110f, 0.02060502f, -0.01923468f, 0.05958317f, -0.02813262f, -0.03917992f, 0.00396906f, 
    -0.09162059f, 0.10445392f, 0.11956353f, -0.02718465f, -0.01152807f, 0.07958107f, -0.00506886f, 0.05679414f, 
    -0.11056306f, -0.04880241f, -0.08763529f, -0.06201084f, -0.00966625f, -0.06392431f, -0.05188702f, 0.00952469f, 
    0.08785603f, -0.04583974f, -0.07243088f, 0.00296547f, 0.00074421f, 0.07594123f, -0.12325462f, 0.10815879f, 
    0.04350304f, 0.10496492f, 0.16086760f, -0.02579587f, -0.40150887f, 0.14990076f, -0.00683513f, 0.04860237f, 
    0.20382403f, 0.24149705f, -0.09586462f, -0.05467420f, -0.16326891f, -0.16571604f, -0.15850058f, -0.00923702f, 
    -0.26479736f, -0.02987189f, -0.13796073f, -0.07089278f, 0.06142415f, -0.09448478f, 0.17415696f, 0.16876970f, 
    0.13806616f, 0.06001689f, -0.11470313f, 0.38024899f, -0.23237418f, 0.06633337f, -0.03740489f, 0.05267081f, 
    0.23009200f, 0.25679296f, 0.35065243f, -0.15349188f, -0.12019840f, 0.36680788f, 0.11727086f, 0.09340458f, 
    -0.13152471f, -0.29164994f, 0.10875691f, -0.05136899f, 0.14836153f, 0.04908351f, -0.10045275f, -0.20481896f, 
    0.05828259f, -0.09953070f, -0.03711691f, 0.13318174f, -0.09084146f, 0.05198775f, -0.11501887f, -0.33506206f, 
    0.10520653f, 0.05954041f, 0.11596234f, -0.12287954f, 0.03093918f, -0.20455515f, 0.05193571f, 0.05319399f, 
    -0.16722584f, -0.22312057f, 0.02558042f, 0.22604984f, -0.45232844f, -0.21472768f, -0.09479500f, -0.09551049f, 
    0.16589962f, -0.10420738f, 0.16047285f, -0.11204398f, 0.09476363f, -0.30362293f, -0.25569749f, 0.19362183f, 
    -0.13582484f, 0.16982570f, -0.02491383f, -0.05389474f, 0.27695027f, -0.09512824f, 0.23929313f, 0.25797030f, 
    0.18777481f, -0.06345706f, 0.04113593f, -0.22349493f, 0.16249080f, -0.01646787f, 0.06752570f, -0.07973472f, 
    0.39820334f, -0.38715309f, 0.34464732f, 0.23731312f, 0.05862688f, 0.09186995f, -0.09108330f, -0.05256543f, 
    -0.36553359f, -0.07009591f, -0.04841794f, -0.08086923f, -0.43704087f, 0.02988779f, 0.03734216f, 0.02605941f, 
    0.04916232f, 0.37641212f, -0.24378416f, -0.03252189f, -0.09731524f, -0.17457955f, 0.07464822f, -0.65314758f, 
    -0.18896428f, 0.02294548f, -0.46873191f, 0.06125687f, 0.05416359f, 0.08650484f, -0.36838368f, -0.02092532f, 
    -0.00306553f, 0.05338270f, 0.02907266f, 0.13027686f, -0.30136439f, -0.20488250f, 0.06851888f, -0.09187380f, 
    0.01193023f, -0.21475382f, 0.22006150f, 0.09864608f, -0.19971970f, -0.07188876f, 0.23663874f, -0.04609507f, 
    -0.15321638f, 0.09620693f, 0.01526209f, -0.25945657f, -0.03107272f, -0.09695850f, 0.07053281f, 0.02755637f, 
    -0.02091672f, 0.16128033f, -0.04003639f, 0.12654173f, -0.01012511f, -0.06041677f, -0.01382261f, -0.10706846f, 
    0.20403284f, -0.26218769f, 0.23610806f, 0.32591963f, -0.04310893f, 0.09295246f, -0.09098687f, -0.03873320f, 
    0.02973461f, 0.22156389f, 0.01473251f, 0.00102499f, -0.26641026f, 0.08754037f, 0.06956038f, -0.25705224f, 
    -0.12558465f, 0.46467119f, 0.11982925f, 0.22333381f, -0.07042701f, 0.09875910f, -0.04286313f, -0.07630014f, 
    0.15767938f, 0.09129580f, -0.00059792f, 0.15635696f, -0.01651433f, 0.38996929f, -0.11542092f, -0.01609329f, 
    -0.04508394f, -0.17664485f, -0.04513112f, -0.20720161f, -0.00304414f, 0.03161325f, 0.00893295f, 0.07190499f, 
    -0.00686378f, 0.12405554f, -0.15843369f, 0.12853597f, 0.13865736f, 0.00641162f, 0.22470932f, -0.20234184f, 
    0.45357543f, -0.02988403f, 0.02738767f, 0.25214577f, 0.13360392f, -0.05499848f, -0.05577874f, 0.01835237f, 
    -0.26240560f, -0.13661726f, 0.14005731f, -0.34348366f, -0.20966774f, 0.18733105f, -0.08081071f, 0.04640323f, 
    0.08544855f, -0.02999017f, 0.06672991f, -0.10369558f, -0.06210712f, 0.07954563f, -0.10558496f, 0.20708039f, 
    0.29191685f, 0.03108147f, -0.10528584f, -0.00227411f, 0.05089845f, 0.24567907f, -0.04638657f, 0.07259991f, 
    -0.00058460f, 0.07793293f, 0.10573423f, 0.04605594f, -0.03044054f, 0.03797145f, 0.06211160f, 0.00502186f, 
    0.24343790f, 0.08601674f, 0.09851602f, -0.01050001f, -0.08836886f, 0.15744133f, -0.04198879f, 0.25188720f, 
    0.11234089f, 0.03957751f, 0.23042189f, -0.15374117f, -0.07792754f, -0.01383363f, -0.13165770f, -0.01919691f, 
    -0.10984191f, 0.17327572f, -0.13021603f, 0.09791450f, -0.16053811f, 0.19752079f, -0.03320817f, 0.09815997f, 
    0.29101443f, 0.12562202f, -0.01291986f, 0.10186543f, -0.07865983f, 0.04857388f, 0.16207808f, -0.03067047f, 
    -0.11339015f, 0.03783519f, 0.00870558f, 0.15884680f, -0.34789625f, -0.08619276f, -0.02652452f, -0.08555655f, 
    -0.20505445f, 0.14660756f, -0.07916764f, -0.18406311f, 0.05135222f, -0.06678331f, 0.04296532f, 0.12728924f, 
    -0.16568495f, -0.33604795f, 0.04606716f, 0.03935919f, 0.25249255f, -0.22369151f, 0.17611144f, 0.16054362f, 
    -0.02915793f, -0.26353708f, 0.17758739f, -0.03163207f, 0.12868953f, 0.00348967f, -0.04817952f, 0.05290840f, 
    -0.02980642f, -0.03635148f, 0.06722007f, 0.05528890f, 0.05189908f, -0.16719076f, 0.24323793f, -0.41729757f, 
    0.01927164f, -0.17561063f, -0.00870331f, 0.02505745f, -0.04215113f, 0.03457268f, -0.04227824f, 0.06750168f, 
    0.15111890f, 0.00955586f, 0.11804139f, 0.12679844f, 0.26130384f, -0.05453025f, -0.15347157f, 0.04265104f, 
    0.08429289f, -0.01458380f, 0.06964108f, 0.10396404f, 0.15837753f, 0.05545738f, 0.15205851f, 0.15607971f, 
    -0.01063824f, -0.03858165f, -0.00549946f, -0.22427306f, -0.00734921f, 0.15787341f, -0.07463828f, -0.08119171f, 
    0.23956554f, 0.18142025f, -0.00352869f, -0.04187549f, -0.02807876f, 0.30381471f, -0.09866978f, 0.13528988f, 
    0.01479388f, -0.00812953f, -0.08025202f, 0.11551582f, 0.12158524f, 0.12087236f, 0.01217261f, 0.03741165f, 
    0.00300418f, -0.16661949f, 0.35684013f, -0.02142879f, -0.02655999f, -0.03037919f, 0.10468957f, -0.31146437f, 
    0.15739357f, -0.01735708f, -0.06888555f, 0.05698949f, 0.06651275f, 0.01177768f, 0.02331422f, 0.06026790f, 
    0.01434991f, 0.13380310f, 0.10708106f, 0.00234087f, -0.07415383f, -0.01923074f, -0.06085993f, 0.09874324f, 
    0.21306977f, 0.12517092f, -0.15307413f, -0.09357677f, 0.19876352f, 0.21344933f, 0.08882513f, -0.04876993f, 
    0.22760424f, -0.09472332f, 0.04257230f, -0.23681398f, -0.18277591f, 0.00649566f, -0.46337360f, -0.21660541f, 
    -0.16392630f, 0.12143631f, 0.05372804f, 0.17838228f, -0.15303509f, 0.16994984f, 0.06995223f, -0.13270396f, 
    -0.05219918f, 0.25616959f, -0.19662823f, -0.48219100f, 0.10787103f, -0.23860757f, -0.12371470f, 0.02577150f, 
    0.23050641f, -0.39363784f, -0.05035117f, -0.07614785f, 0.20697053f, -0.10120529f, 0.17550902f, 0.01585333f, 
    -0.46430793f, 0.06686150f, 0.39638802f, -0.13342899f, 0.01888667f, 0.13003105f, 0.11682553f, 0.25498259f, 
    -0.02415413f, -0.08664902f, 0.06967562f, 0.23507473f, -0.10486980f, 0.04221154f, -0.07615766f, 0.06181571f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.19374734f, 0.16221520f, -0.05086374f, -0.06206746f, -0.10987049f, -0.07632645f, -0.12714936f, 0.19858798f, 
    -0.13511534f, 0.04686567f, -0.03548330f, 0.21858968f, -0.08794980f, -0.08239345f, -0.18536058f, 0.06095004f, 
    0.10963368f, -0.02118224f, 0.24914396f, 0.15182793f, -0.01401557f, 0.15307352f, 0.13420027f, -0.08150784f, 
    -0.05599191f, 0.05780864f, 0.05987971f, -0.08971875f, 0.13055132f, 0.26133290f, -0.09408940f, 0.11115219f, 
    0.01282734f, 0.05670971f, -0.11108577f, 0.08519831f, -0.09325770f, 0.04597241f, -0.07082970f, -0.02957411f, 
    -0.00992748f, -0.06870425f, 0.27799368f, 0.22167023f, 0.22350794f, 0.07681762f, 0.03485303f, -0.10960305f, 
    0.03880244f, 0.22759111f, 0.22012901f, -0.01313630f, 0.00417786f, 0.31074595f, 0.21971542f, -0.06018594f, 
    -0.01889754f, 0.06134508f, -0.02656293f, 0.05492226f, 0.11462390f, 0.11920003f, 0.03728563f, 0.13826212f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.19604211f, -0.26388025f, 0.18813844f, 0.07542573f, -0.07615609f, 0.22528806f, -0.05389353f, -0.04634240f, 
    -0.00401230f, 0.11212879f, -0.04910788f, -0.45106059f, 0.05219452f, 0.08894879f, 0.11046068f, -0.04808482f, 
    -0.11760875f, 0.07895499f, 0.10596590f, -0.45941147f, -0.12529412f, -0.09705073f, -0.04866024f, -0.09946189f, 
    0.07450847f, 0.05971882f, 0.00482896f, -0.04863856f, -0.45041457f, 0.08537372f, -0.35286251f, 0.18296896f, 
    -0.04673241f, 0.02072492f, 0.27285233f, -0.32345957f, 0.01403342f, -0.37200680f, -0.01457445f, -0.39996126f, 
    0.39408359f, -0.36940113f, -0.48498264f, -0.09662019f, 0.14723304f, -0.23735982f, -0.05235866f, -0.05614417f, 
    -0.54604799f, 0.18974622f, -0.39567465f, 0.11151264f, -0.28299588f, -0.10875833f, -0.16283351f, 0.14467943f, 
    0.01990021f, -0.41556606f, 0.23574002f, 0.09311382f, -0.24210912f, -0.27079424f, 0.11373834f, -0.26308501f, 
    0.16037092f, 0.11814832f, -0.08344588f, 0.01662477f, -0.03559050f, -0.55122244f, -0.20291090f, 0.03540448f, 
    -0.41227615f, -0.12439892f, 0.23056388f, -0.17712086f, 0.06014713f, -0.66809368f, -0.18853022f, 0.17863484f, 
    -0.06427684f, -0.05479982f, 0.05703004f, -0.38873920f, 0.04422350f, 0.13395719f, 0.25426856f, -0.31419793f, 
    0.01018825f, 0.11760905f, 0.05825704f, 0.02511386f, 0.01704186f, 0.03771125f, -0.06792957f, 0.05193580f, 
    0.01021349f, -0.03191780f, 0.04360480f, -0.10572964f, -0.08022543f, 0.19455846f, -0.10250627f, -0.11937238f, 
    -0.45549569f, -0.62712598f, 0.08407852f, 0.09161913f, 0.15517575f, -0.47602138f, -0.02124227f, 0.00233906f, 
    -0.37202460f, 0.01237462f, 0.07274932f, 0.27844965f, -0.46974927f, 0.07609624f, 0.09944203f, 0.09391906f, 
    0.08649192f, 0.33374828f, 0.45442405f, 0.06398626f, -0.09490731f, 0.17018600f, 0.07562480f, 0.35228920f, 
    -0.16259857f, -0.12029429f, 0.18543446f, 0.02030862f, -0.07258464f, 0.09319782f, -0.20423369f, -0.03412700f, 
    -0.16880322f, -0.01002967f, -0.34704196f, 0.09889352f, -0.55642956f, -0.29739639f, -0.66443151f, 0.09944122f, 
    -0.27564093f, -0.11989706f, 0.17012677f, -0.09291770f, 0.05654794f, 0.26529998f, -0.31297529f, -0.22876416f, 
    -0.03565716f, 0.06782344f, 0.06626298f, -0.39457777f, 0.05909146f, 0.18975940f, -0.21707344f, 0.24637270f, 
    0.09501600f, -0.03084655f, -0.05354404f, -0.16999497f, 0.03060096f, -0.25421089f, -0.10651015f, 0.19730306f, 
    -0.25006771f, 0.04203848f, 0.14391032f, 0.17865126f, 0.02662178f, 0.21791759f, -0.12649710f, 0.01214619f, 
    -0.16180433f, 0.26787600f, -0.01055685f, -0.36603668f, -0.04386730f, 0.24804516f, 0.19600895f, -0.00579129f, 
    -0.05284961f, 0.02187533f, -0.48902160f, 0.28211293f, 0.13240817f, -0.10497138f, -0.05254349f, -0.74609667f, 
    -0.40437111f, -0.10637473f, 0.00664152f, 0.00318760f, 0.01325206f, 0.20781134f, 0.25778231f, -0.29709071f, 
    0.20028713f, -0.00738922f, -0.20439661f, -0.01037223f, 0.11147334f, 0.05758612f, 0.15690218f, -0.08864795f, 
    0.19179486f, -0.13431348f, -0.02303719f, -0.08947441f, -0.07784078f, 0.05155354f, -0.11795957f, 0.33175445f, 
    -0.15760897f, -0.03939470f, 0.20512499f, -0.16512521f, -0.03455382f, -0.11614566f, -0.31841859f, 0.09639491f, 
    -0.05544914f, -0.12254926f, -0.03378377f, 0.01764245f, -0.03932546f, -0.47976568f, -0.22108169f, 0.13117072f, 
    0.04776216f, -0.10266473f, -0.02845779f, -0.17057280f, -0.03797164f, 0.01858172f, 0.06939819f, 0.04818505f, 
    0.25579765f, -0.21156485f, -0.09154704f, -0.09810098f, 0.30982095f, -0.47882769f, -0.35672623f, 0.09761939f, 
    -0.01237000f, 0.00918357f, 0.09433456f, 0.09000982f, 0.08716201f, -0.22672248f, 0.16279304f, -0.27524602f, 
    0.09435572f, 0.04262535f, -0.01931268f, 0.05858358f, 0.00919767f, 0.14089511f, -0.13848528f, 0.07917695f, 
    0.23636332f, 0.02441561f, -0.14537382f, -0.11457984f, 0.03051801f, 0.10892533f, 0.14048329f, -0.01571870f, 
    0.20880325f, 0.19437522f, -0.02308705f, 0.17461959f, 0.02185622f, 0.07347468f, -0.27619633f, 0.17474192f, 
    -0.01343428f, 0.13508110f, 0.06466044f, -0.00304328f, -0.20398206f, 0.14851984f, 0.00408271f, 0.11606842f, 
    -0.02711297f, -0.09048221f, -0.02703251f, -0.34151912f, 0.05735581f, 0.16605110f, -0.02885766f, -0.21991713f, 
    -0.06248978f, 0.23033351f, -0.28245685f, -0.62715930f, -0.19977851f, -0.11677076f, -0.03490361f, -0.12309257f, 
    0.08091827f, -0.07167014f, -0.41165355f, 0.12410829f, -0.53241682f, -0.17391001f, 0.01987571f, -0.06042675f, 
    -0.07086395f, -0.28532794f, 0.03172315f, 0.12072738f, -0.07880985f, 0.07887404f, -0.08365621f, -0.55838794f, 
    -0.00936738f, 0.03762629f, -0.03456988f, 0.09531327f, -0.05314494f, -0.01948620f, -0.05650314f, -0.19949844f, 
    -0.28397492f, 0.13810726f, 0.16529737f, -0.15605478f, 0.25666657f, -0.13128468f, 0.15154949f, 0.22006989f, 
    0.06103986f, 0.11344726f, -0.22109887f, 0.12121671f, -0.05045846f, -0.01689910f, -0.38579503f, -0.25036746f, 
    0.30224940f, 0.10608245f, 0.00191062f, 0.14397289f, -0.01373770f, 0.13000377f, 0.40765536f, 0.04407519f, 
    -0.06298618f, 0.08186280f, 0.17163727f, 0.06227415f, -0.14743553f, -0.16197535f, 0.07111015f, -0.19143119f, 
    -0.36897653f, 0.07744436f, -0.06469870f, 0.19571701f, -0.11204648f, -0.49132547f, -0.00677790f, -0.04240083f, 
    -0.04900862f, -0.23520610f, -0.09966020f, 0.06816234f, 0.00577307f, -0.09831231f, -0.05215592f, 0.13300854f, 
    0.10120299f, 0.02333797f, -0.31446344f, -0.24773626f, 0.04989389f, -0.60225832f, 0.08925003f, -0.37976557f, 
    0.21670136f, -0.30107361f, 0.18522027f, -0.05716847f, -0.08669069f, -0.18871862f, -0.57283258f, -0.03276277f, 
    -0.51608694f, -0.10899440f, -0.36570337f, 0.18957846f, -0.49733272f, -0.53545797f, -0.25382861f, -0.11789516f, 
    -0.50198400f, -0.58663797f, -0.37417954f, 0.23440066f, 0.01532952f, 0.04612277f, -0.12997998f, -0.03338667f, 
    -0.35073072f, -0.41356844f, -0.12056339f, -0.04732951f, -0.11001758f, 0.20784061f, 0.00646552f, -0.58670664f, 
    0.06352986f, -0.01859960f, -0.22345816f, -0.23041365f, 0.01662738f, 0.28274143f, -0.07218398f, 0.07250353f, 
    -0.40433764f, 0.20253852f, -0.00546999f, 0.08936223f, 0.03195193f, 0.28345555f, -0.08603343f, -0.03378082f, 
    0.00266457f, 0.04998864f, 0.23431490f, -0.00238056f, 0.18916190f, 0.32490936f, 0.11947238f, -0.29052538f, 
    -0.11996879f, -0.22039226f, -0.19090657f, 0.07181440f, -0.17896324f, -0.24520031f, -0.78433812f, 0.30812493f, 
    -0.33059397f, -0.41510692f, -0.20950606f, 0.08542950f, -0.14169130f, 0.42845419f, 0.23859988f, 0.05975326f, 
    0.42385438f, -0.17181404f, -0.22005053f, 0.10915110f, -0.44308609f, -0.19915535f, -0.31446922f, 0.14549643f, 
    0.00540569f, -0.21701869f, -0.16723858f, 0.10497058f, 0.07546301f, -0.34838846f, 0.16541906f, -0.20028743f, 
    -0.23753999f, 0.17424446f, -0.34954050f, 0.14635792f, -0.15579511f, -0.49569306f, 0.17737162f, -0.33126220f, 
    -0.01659085f, -0.09005699f, 0.02164849f, 0.07385826f, -0.03226905f, 0.13240035f, 0.03001219f, 0.12187740f, 
    0.38730267f, 0.08196464f, 0.07720356f, 0.00576475f, -0.12946539f, 0.02096406f, 0.04385084f, -0.05840310f, 
    0.02735352f, -0.11484873f, -0.06987188f, -0.02666005f, 0.21332379f, -0.48409083f, -0.25160742f, -0.20729236f, 
    0.05290001f, 0.21318600f, -0.18503344f, -0.43186462f, 0.13622007f, 0.09689496f, -0.10539358f, 0.07264683f, 
    0.04458795f, 0.18627906f, -0.06616320f, 0.04459188f, -0.13141526f, -0.27502802f, 0.22475481f, -0.15869108f, 
    -0.18890224f, -0.12486688f, -0.25408915f, 0.16683927f, -0.15582678f, -0.14119262f, -0.10340426f, -0.11181573f, 
    0.07052437f, -0.76048368f, 0.14893968f, -0.25384504f, 0.04372790f, -0.27535069f, 0.31188381f, -0.46170902f, 
    -0.17716257f, -0.49377945f, -0.06249845f, -0.11597741f, 0.17040960f, -0.23319454f, -0.14565088f, 0.09250682f, 
    -0.01761994f, 0.07381420f, 0.00242898f, 0.00835480f, -0.08547099f, 0.07463335f, -0.15439169f, -0.26873699f, 
    -0.37050843f, -0.40701687f, 0.16559321f, 0.27772135f, 0.13108824f, -0.17996766f, 0.05331768f, -0.07808826f, 
    0.17679816f, -0.22870624f, 0.14908352f, -0.43831539f, 0.33299795f, 0.04302464f, -0.23917089f, 0.33267781f, 
    -0.06763029f, 0.10656653f, -0.24884157f, -0.38265786f, 0.16876562f, 0.07576840f, 0.10717342f, -0.04792070f, 
    0.06025975f, -0.16081539f, -0.09150267f, -0.00294570f, 0.05647077f, -0.21941839f, -0.03955508f, 0.04789007f, 
    0.23576640f, 0.13709714f, -0.09863289f, 0.20033728f, 0.05262336f, 0.28604478f, -0.23649052f, -0.31083012f, 
    -0.35118294f, 0.12933448f, -0.58093524f, 0.13939442f, -0.04880182f, -0.35437143f, 0.00706777f, -0.22817755f, 
    0.17117369f, 0.26682651f, -0.36526313f, -0.34977135f, -0.05270124f, 0.12690134f, 0.08123972f, -0.12581919f, 
    0.10972762f, 0.03287888f, -0.20380139f, -0.63833016f, 0.03602614f, -0.06844372f, -0.39766788f, -0.16863982f, 
    -0.48032713f, 0.18300103f, 0.09109864f, -0.14140847f, -0.35204226f, 0.09530773f, 0.10231426f, -0.03573570f, 
    0.10946177f, 0.26027602f, 0.13508587f, -0.24271755f, -0.17193432f, 0.01465233f, 0.22911100f, -0.00219575f, 
    -0.13067807f, -0.08533069f, -0.42082796f, 0.16430183f, -0.06065064f, -0.01354113f, -0.14604263f, -0.08858534f, 
    0.25139028f, 0.21746263f, -0.11335096f, 0.02336454f, 0.04950199f, 0.01682667f, -0.33137053f, -0.09893464f, 
    -0.38693449f, -0.27581489f, 0.35918120f, -0.45484710f, -0.15960599f, -0.33241132f, -0.17170013f, -0.46277854f, 
    0.32461622f, -0.12159050f, 0.22899881f, -0.44293061f, -0.00059294f, 0.01574620f, -0.20898262f, -0.34599274f, 
    -0.54740864f, -0.12362952f, 0.14823844f, -0.29336756f, 0.17644358f, -0.15243612f, -0.13275671f, 0.00010387f, 
    0.11358873f, -0.03476785f, -0.16511263f, 0.34213006f, -0.02402795f, -0.31833869f, 0.00760253f, 0.21847236f, 
    0.08129647f, 0.20078026f, -0.26539361f, -0.09051915f, 0.15800588f, -0.30399081f, -0.00265542f, -0.09119251f, 
    0.34049416f, -0.72454202f, 0.15866898f, -0.21168168f, -0.20508412f, 0.13373582f, 0.20279376f, -0.12996581f, 
    -0.06618358f, 0.25754598f, 0.09421781f, -0.14663607f, -0.40000269f, 0.03745399f, 0.03268133f, -0.20069100f, 
    0.19548403f, 0.26392785f, -0.36057761f, 0.05683821f, -0.13089462f, -0.23420720f, -0.20196980f, -0.57482320f, 
    -0.26583529f, -0.04784973f, -0.30923465f, -0.10695182f, 0.07726648f, -0.22904165f, 0.22695725f, 0.26313558f, 
    0.03812264f, 0.02751869f, 0.34612119f, 0.12813017f, -0.04898516f, 0.09402110f, -0.03004724f, 0.05092838f, 
    -0.28082061f, -0.49704143f, 0.20470589f, -0.14252251f, 0.01661864f, 0.04442950f, 0.13737658f, -0.15427753f, 
    0.10146216f, 0.04337897f, -0.41741878f, 0.15416291f, -0.10849497f, 0.14398777f, 0.09233008f, 0.29086915f, 
    -0.51060718f, -0.45210204f, 0.25227210f, -0.19457632f, -0.33108881f, 0.23459734f, 0.02035773f, -0.02323044f, 
    -0.04693021f, 0.01164099f, -0.12233549f, -0.26781607f, -0.07460256f, -0.12317026f, -0.35449880f, -0.44472891f, 
    -0.10098431f, -0.36693528f, -0.45599291f, -0.22352868f, 0.35389066f, -0.10557185f, 0.03874432f, 0.07346155f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00228423f, 0.14874886f, 0.02004720f, -0.07864953f, -0.13511580f, 0.07071556f, 0.04423641f, 0.01000725f, 
    -0.08658400f, -0.03264461f, 0.07023662f, 0.07186231f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
