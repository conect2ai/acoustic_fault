#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.34881088f, -0.92796105f, -1.12601960f, 0.01730255f, 0.84825456f, 0.57207328f, 0.65403187f, -0.02447188f, 
    0.66137326f, 1.36153126f, -1.38335955f, -0.88940281f, -0.65833873f, -0.51110274f, -0.22054495f, -0.40474254f, 
    0.11496660f, 0.39576879f, 0.43849343f, -1.03012455f, 0.56545907f, 1.04744494f, -0.10286442f, 0.96324337f, 
    -0.08788571f, 0.24594773f, 0.67307520f, -0.05359684f, -0.03584395f, -1.14701688f, -0.07521629f, -0.50711745f, 
    1.06663764f, -0.73327178f, 0.04972842f, 0.48877606f, 0.63935262f, -0.09897565f, -0.82890069f, -1.20909286f, 
    0.95435786f, -1.02260101f, -0.07952486f, 0.71243048f, 0.06693050f, -0.84705305f, 1.06688201f, 0.98095262f, 
    -1.15169418f, 0.26175791f, 0.07005086f, -0.36480114f, 0.24602251f, -0.53409821f, -0.10006906f, -0.79112858f, 
    -1.12662184f, -0.81436497f, 0.45375744f, 0.47100544f, -0.36332116f, -0.55176264f, 0.91175067f, -0.90892828f, 
    -1.25872886f, -0.88607758f, -0.83466649f, -0.89925778f, -0.36069587f, 0.35624501f, 0.14787892f, -0.13144147f, 
    -1.07394171f, -0.19476949f, 0.54942757f, -0.85628527f, 0.77083915f, -1.04181480f, 0.17271106f, 0.61179227f, 
    0.24542253f, -1.41767395f, -0.12663738f, -0.23941161f, 0.37387377f, 1.38356209f, -0.00467961f, -0.32008401f, 
    -0.52642369f, -0.56151050f, 1.01259518f, 1.14829004f, 0.50970471f, 0.30169287f, -0.79510474f, -0.77630877f, 
    0.73559761f, 0.92936605f, -0.23908690f, -1.03276980f, -1.21000266f, -1.00932860f, -0.29826197f, 0.15533413f, 
    -0.38225871f, -0.53857672f, 0.27017987f, -0.18477342f, 1.34944963f, 0.92210495f, 0.08585176f, 0.39941871f, 
    0.65660906f, 0.55040109f, -0.71276939f, 0.17966595f, -0.43071669f, -0.74312651f, -0.67364770f, 0.74028283f, 
    1.18190551f, 0.99463236f, 0.85844952f, -0.50596964f, -0.36431652f, 0.16193356f, 0.89120996f, 0.18484503f, 
    0.84749562f, 1.00408185f, 0.74642527f, -0.68622178f, -0.15620315f, 0.54068148f, 0.27441800f, 1.23128724f, 
    1.15091503f, 0.89310980f, -0.83778214f, 0.77338517f, -0.72387755f, 0.47481704f, -0.16950479f, -0.22244713f, 
    1.23778057f, 0.61057538f, 0.37811005f, -0.68589854f, -0.44810784f, 0.07305370f, -0.51702678f, 0.72688669f, 
    -0.47151136f, 0.83769262f, -0.42655936f, 0.83879316f, 0.86678201f, -1.01063192f, 0.48856434f, 0.44762462f, 
    -0.47097477f, -0.75409555f, 1.07301104f, 0.97879660f, 0.89725512f, -0.31252778f, -0.80875701f, 0.47244138f, 
    0.28876498f, -0.29957202f, 0.41974878f, 0.86014205f, 0.93734580f, 0.85204583f, 0.07827710f, 0.51190358f, 
    1.00560749f, 0.38773069f, 0.87021118f, 0.81461805f, -0.02860487f, 0.60846502f, 0.09520839f, -0.41973969f, 
    -1.21118569f, -0.95745176f, -0.11666645f, 0.26867881f, 0.92329854f, 1.10042858f, -0.63898355f, -0.74420726f, 
    0.66121799f, 0.03528002f, -0.86563694f, 0.16078445f, -0.54942334f, -0.64103490f, 1.09306574f, -1.09836590f, 
    0.75980049f, -0.29067394f, 1.11421168f, -0.26446038f, 0.33725429f, -0.46792197f, 0.02707707f, 0.61415213f, 
    0.75751907f, 1.20192194f, 0.24486849f, -0.15694919f, 0.24881887f, -0.72373652f, -0.54469603f, -0.02411639f, 
    0.22685136f, -1.01017714f, 0.47546700f, -0.80104876f, -0.17876694f, 1.31584871f, 0.44825432f, -0.57961082f, 
    -0.15871567f, 0.41657335f, 0.10643198f, -0.35065669f, 0.18038025f, 1.02853072f, 1.26417208f, 0.81193769f, 
    0.34117633f, -0.65608126f, 0.46527895f, -1.00056398f, -0.73199272f, 1.15113974f, -0.18652675f, 0.82095522f, 
    -0.57168543f, 0.03772031f, -0.44549152f, 0.89009362f, 0.25435671f, 0.45949054f, -1.33746183f, -0.95458049f, 
    0.05848432f, -0.15183674f, 0.37922606f, -0.07809591f, 0.98673958f, 1.21803367f, -1.08358908f, 0.74187928f, 
    -0.01469532f, -0.18541308f, 0.93480301f, 0.34279424f, 0.22263883f, 0.17879298f, 0.64608592f, 0.69830590f, 
    -0.03353097f, -0.95366472f, 0.80802739f, -0.60651404f, 0.34522527f, -1.03591180f, -1.20208895f, -0.96330452f, 
    -1.19749022f, 0.33828333f, 0.05919972f, 0.74087679f, 0.02979568f, -0.52110517f, -0.03836195f, 0.21857257f, 
    0.28132400f, 0.24491189f, -1.28919220f, -1.13909829f, -1.05442107f, 0.09252447f, -0.51618427f, -0.13326919f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17102633f, -0.11627566f, 0.25039256f, -0.18105043f, 0.10246954f, 0.37291890f, 0.01349013f, 0.14403783f, 
    0.14450793f, -0.04872643f, 0.16756609f, 0.13857234f, 0.08685687f, 0.02644269f, 0.45139784f, -0.18330121f, 
    -0.40070486f, 0.25449017f, 0.21218255f, 0.23105164f, -0.10016982f, 0.40270233f, -0.49062821f, 0.46062151f, 
    -0.29323357f, 0.16490506f, -0.31854704f, 0.08746089f, 0.17944327f, 0.07292991f, 0.11824252f, 0.45814353f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.05803826f, -0.12156307f, 0.30937278f, 0.04612419f, -0.09708552f, 0.13183349f, -0.07073873f, 0.09115554f, 
    0.22003751f, -0.22406660f, 0.08650672f, -0.18429144f, 0.34310916f, 0.00862612f, -0.05210340f, -0.04548801f, 
    -0.09588992f, -0.12737858f, -0.03264455f, 0.03111096f, -0.02163812f, 0.07896343f, 0.01417842f, 0.00101014f, 
    0.01154503f, 0.01945979f, 0.04384134f, -0.27075893f, 0.01388701f, -0.18657963f, -0.36891809f, -0.15221138f, 
    0.01505925f, -0.08201741f, 0.19052260f, -0.29715157f, 0.06812761f, 0.06970862f, -0.75793922f, -0.13566127f, 
    0.14596833f, 0.14312011f, -0.02824694f, -0.13959344f, -0.00301214f, 0.17772515f, -0.36049485f, -0.31489033f, 
    0.09702751f, -0.01721869f, -0.03368600f, -0.04230440f, -0.03866253f, -0.07852079f, -0.34560207f, -0.16853502f, 
    0.12187970f, -0.12786938f, -0.12587082f, 0.02987436f, -0.17291322f, -0.00393681f, 0.10327161f, -0.23418741f, 
    -0.05505691f, 0.20575583f, 0.03561275f, 0.03458179f, 0.23918140f, 0.17692801f, 0.27236560f, 0.20395842f, 
    -0.02967193f, -0.73217440f, -0.50385630f, -0.06492150f, 0.14106600f, 0.03829596f, -0.00842867f, 0.03709727f, 
    -0.04184024f, 0.08375677f, -0.15055524f, -0.24569231f, -0.03255748f, 0.00915120f, -0.07321678f, 0.22712231f, 
    -0.09458859f, -0.23329534f, 0.05450433f, 0.21903613f, 0.04425002f, 0.09404696f, 0.14267151f, -0.13552892f, 
    -0.02811547f, 0.06064391f, 0.10526764f, -0.43796790f, 0.06077940f, 0.14025749f, -0.03185641f, 0.13237925f, 
    0.10969365f, 0.09592424f, 0.19281772f, 0.05085601f, 0.31664953f, 0.05400836f, 0.10317177f, -0.13906798f, 
    -0.08715392f, -0.04876298f, -0.07483424f, 0.21508591f, 0.00292063f, 0.28705284f, -0.05818265f, 0.24845041f, 
    -0.12339552f, -0.05539749f, -0.16313647f, 0.10855594f, -0.01674822f, -0.03024403f, -0.09815037f, 0.13986932f, 
    -0.01532894f, 0.02757161f, -0.03805800f, -0.04760679f, -0.00933642f, 0.03733645f, 0.07825649f, -0.10962984f, 
    -0.25176653f, -0.09602901f, 0.09329856f, 0.15788190f, 0.12233459f, 0.18660004f, 0.00829395f, 0.03651953f, 
    -0.30560520f, -0.04736499f, 0.13919045f, -0.03879778f, 0.18281086f, 0.01623179f, -0.03335021f, -0.20747584f, 
    -0.02267886f, 0.26037914f, 0.30749896f, 0.06204205f, -0.04369105f, 0.10584275f, -0.02525955f, 0.14051270f, 
    0.04176416f, -0.00361509f, -0.16266905f, 0.17138906f, 0.30964747f, 0.11966437f, 0.14848240f, 0.04525151f, 
    -0.27685452f, 0.12182525f, 0.05799060f, 0.28978395f, 0.31354243f, 0.13501355f, -0.01681253f, -0.05675416f, 
    0.06107106f, 0.11857040f, -0.01359017f, -0.01627562f, -0.08866984f, 0.05399938f, -0.32256284f, 0.03566326f, 
    0.15474637f, -0.17100438f, -0.00802699f, 0.19014603f, 0.06191351f, -0.21143706f, 0.05213614f, -0.39275217f, 
    -0.03567502f, 0.00153945f, -0.18150952f, -0.01845314f, -0.14832218f, 0.17662042f, -0.81896615f, -0.32051972f, 
    -0.52311957f, 0.26908773f, -0.04552366f, 0.14044054f, 0.23631875f, -0.10420557f, 0.18733902f, -0.13978307f, 
    -0.02047042f, 0.10079151f, 0.03452773f, 0.13139561f, -0.01321340f, -0.07759316f, 0.15542223f, 0.05422831f, 
    -0.28393129f, -0.17419285f, 0.20460728f, 0.00053484f, -0.06663779f, 0.01273936f, -0.24873285f, 0.06767128f, 
    0.12434824f, -0.07053750f, -0.03666528f, 0.13882422f, -0.22773078f, 0.01456762f, -0.03239756f, 0.18514366f, 
    0.17610908f, 0.11114717f, -0.05035675f, 0.22111094f, -0.07995240f, 0.24394824f, 0.02415025f, 0.02193413f, 
    0.17476048f, -0.14185348f, -0.15305759f, -0.20594648f, -0.01102330f, -0.22197783f, -0.02624357f, -0.01673064f, 
    0.00303493f, 0.09961598f, -0.12727521f, 0.12136076f, -0.34560502f, 0.29358536f, -0.29516524f, -0.10515144f, 
    -0.13113014f, -0.15709344f, 0.06159618f, 0.05666691f, 0.09785579f, -0.03217424f, -0.23979971f, 0.24585952f, 
    -0.13254040f, 0.15754279f, -0.01343382f, 0.32284948f, -0.13500589f, 0.06389144f, 0.44800273f, -0.14175862f, 
    0.48211128f, -0.08202047f, -0.02939667f, 0.01808834f, -0.08111066f, 0.08394177f, -0.07214663f, -0.30627203f, 
    -0.33580956f, -0.17455682f, -0.07228340f, -0.08715933f, -0.04615823f, 0.16740595f, 0.24683708f, 0.18766129f, 
    -0.81730306f, -0.26080817f, 0.03737814f, 0.06005226f, -0.11269838f, -0.03232247f, 0.15539859f, -0.29191178f, 
    0.02282783f, -0.48890761f, -0.24982569f, -0.60950679f, -0.04257762f, 0.01709958f, -0.09035656f, -0.04078937f, 
    -0.06542938f, 0.09293412f, -0.41981125f, 0.05708279f, 0.13540316f, 0.00623860f, 0.05372740f, -0.04550949f, 
    0.04477271f, -0.08863667f, 0.04016333f, -0.23339660f, -0.33268633f, 0.02730368f, 0.16223772f, 0.05289271f, 
    -0.08700206f, -0.10326650f, -0.18974316f, -0.07719523f, -0.25739568f, -0.26339552f, 0.09893261f, -0.01894038f, 
    -0.04423414f, 0.05872919f, -0.27625740f, -0.19275264f, 0.11875670f, -0.01680902f, -0.00481803f, -0.04347456f, 
    0.12831146f, 0.11484767f, 0.09190055f, 0.08621860f, 0.07534349f, 0.12054069f, -0.68169421f, -0.58080751f, 
    -0.12647583f, -0.03828333f, -0.08632123f, 0.24295296f, 0.24779701f, -0.13471529f, 0.03847232f, -0.53324419f, 
    -0.07243150f, -0.42539796f, 0.41297761f, 0.37830335f, 0.05759527f, 0.06980495f, 0.15174882f, -0.18451959f, 
    0.25243989f, -0.33040997f, -0.29053470f, 0.26780257f, 0.05634087f, 0.15633214f, 0.16516587f, -0.05596391f, 
    0.20461893f, -0.12179673f, -0.25839353f, -0.63911057f, -0.09450443f, 0.15267625f, 0.02785679f, 0.03063390f, 
    -0.10546439f, -0.21674523f, 0.32120147f, 0.06231011f, 0.04500037f, -0.12584454f, 0.06826212f, 0.07883102f, 
    0.04003340f, 0.12978907f, -0.03424766f, -0.26195216f, -0.12060057f, -0.33601990f, 0.14279523f, 0.04694034f, 
    0.26162106f, 0.02441891f, 0.06672677f, -0.19909029f, -0.27025193f, 0.07352994f, 0.10000712f, 0.30952784f, 
    0.08921162f, 0.13647901f, 0.12611820f, -0.03882725f, 0.09433093f, 0.02286823f, -0.19855358f, -0.23395081f, 
    0.20515797f, 0.11375425f, 0.08965377f, -0.25328961f, -0.05260417f, 0.00402157f, -0.09206606f, 0.03917671f, 
    0.21465211f, -0.01290879f, 0.27781999f, 0.15277953f, 0.09768788f, 0.11440620f, 0.17758738f, -0.03423682f, 
    0.27516094f, 0.29033273f, 0.10389150f, -0.05576492f, 0.13782667f, -0.16558704f, -0.03201188f, 0.06559089f, 
    -0.05443219f, 0.44273487f, 0.01925431f, -0.07831599f, -0.07524214f, 0.14364357f, 0.28018546f, -0.15121712f, 
    0.16980076f, -0.08561055f, -0.09666675f, 0.14553958f, 0.07391115f, 0.09375265f, 0.36938617f, 0.12820430f, 
    -0.02818748f, -0.04023178f, -0.06806730f, 0.33376750f, 0.17034939f, -0.03735299f, -0.02193663f, 0.12246591f, 
    -0.11246352f, 0.04282391f, 0.09577838f, 0.17290376f, 0.37415856f, 0.36237752f, 0.21613543f, 0.18495899f, 
    0.05891728f, 0.13946192f, 0.01625864f, 0.00310519f, 0.21829914f, 0.11851297f, -0.11960466f, -0.27985552f, 
    0.02480856f, 0.08739107f, -0.05887156f, 0.05302193f, 0.38961527f, -0.09686864f, -0.53288561f, -0.27251551f, 
    0.12878108f, 0.19155493f, 0.26185179f, 0.30958802f, 0.15430960f, 0.09053846f, 0.25480250f, 0.01593990f, 
    -0.20999175f, -0.06480754f, 0.01642517f, 0.01163966f, 0.06083979f, -0.02344025f, -0.09507845f, 0.07993661f, 
    0.33416843f, 0.39961031f, 0.30461231f, 0.11167308f, 0.04358928f, 0.12908363f, -0.13938820f, 0.23328924f, 
    -0.38924491f, -0.23819791f, -0.32636926f, 0.10227640f, -0.08692811f, 0.22725528f, 0.08101007f, -0.01890871f, 
    0.21228412f, -0.15039009f, 0.14210962f, -0.02678414f, 0.30417222f, 0.02240337f, 0.00239263f, 0.38076630f, 
    -0.00725782f, 0.01643211f, -0.13773301f, -0.24256882f, -0.32680428f, 0.03182004f, -0.05176999f, -0.01854333f, 
    -0.18643573f, -0.21403921f, -0.18894190f, 0.23917061f, 0.45711425f, -0.18646152f, -0.07237119f, -0.12852588f, 
    0.11761509f, 0.00412601f, -0.10107496f, 0.25293526f, -0.31040695f, 0.08196256f, 0.26730192f, -0.12022154f, 
    -0.02870890f, -0.29808661f, 0.04930015f, -0.13902111f, -0.10702556f, -0.51787889f, 0.29131627f, 0.11975595f, 
    0.12617901f, 0.08762436f, -0.12149622f, 0.38870931f, 0.04582960f, 0.16131760f, -0.44834948f, -0.15529664f, 
    -0.48291191f, 0.05261286f, 0.11140092f, 0.15322596f, 0.22728071f, -0.01587491f, -0.01154897f, 0.09339327f, 
    0.21435708f, 0.12959702f, 0.08747486f, 0.14840768f, 0.15942998f, -0.09573986f, -0.03567443f, 0.22507288f, 
    -0.00813673f, -0.05824226f, 0.03665916f, -0.01918706f, -0.04236050f, -0.00180379f, -0.04244303f, 0.00052823f, 
    -0.01289553f, -0.06321502f, -0.04860981f, -0.06707366f, 0.00194190f, -0.02184927f, 0.03482828f, 0.01050179f, 
    -0.04179756f, 0.01002876f, 0.01448000f, -0.02741936f, 0.03589139f, 0.04674755f, 0.02788096f, 0.00900857f, 
    -0.05236334f, -0.04845330f, 0.04980095f, 0.03022017f, -0.00246923f, -0.00657054f, -0.02942765f, -0.02655223f, 
    -0.00075595f, 0.01378321f, -0.05309540f, -0.05728935f, -0.04435175f, 0.00041276f, -0.00685786f, 0.00676735f, 
    -0.05568320f, -0.02465411f, 0.01561561f, -0.03007507f, 0.04182212f, 0.02771173f, 0.03944478f, 0.04414573f, 
    -0.03513668f, 0.03425040f, -0.04074908f, 0.00183575f, 0.03094512f, -0.00871695f, 0.01002977f, 0.02240046f, 
    0.02481840f, 0.03565389f, -0.01317402f, 0.02605838f, 0.00870897f, -0.02841896f, -0.02420153f, 0.01250790f, 
    -0.04477802f, 0.03446558f, 0.00033416f, -0.03155398f, -0.03574727f, -0.02557025f, 0.03312609f, -0.05135547f, 
    0.04552311f, -0.03097137f, -0.00532552f, -0.03590651f, 0.04805398f, 0.00565340f, 0.00228471f, -0.04555233f, 
    -0.01394637f, 0.00978208f, -0.04155574f, -0.00972953f, -0.05976241f, -0.04112114f, -0.00329870f, 0.00651046f, 
    0.04673044f, -0.05346136f, -0.05491169f, -0.06375402f, -0.03975480f, -0.05544187f, -0.01932925f, 0.01814623f, 
    -0.03536569f, 0.04289988f, 0.04469407f, -0.05110899f, 0.00459530f, -0.01335889f, 0.04304573f, -0.04276455f, 
    -0.00244338f, -0.03083385f, -0.03462444f, 0.01038738f, 0.01901273f, 0.01724787f, 0.02543444f, 0.04272884f, 
    -0.00013426f, 0.00989566f, -0.00604655f, 0.03515280f, 0.02956855f, -0.01883561f, 0.04966075f, -0.06177163f, 
    0.00082531f, -0.04692771f, 0.02744802f, 0.03792659f, 0.03834840f, 0.03234916f, -0.01678175f, -0.02235105f, 
    -0.02642722f, -0.04867142f, 0.01330672f, -0.00300988f, 0.02714492f, 0.01937645f, 0.04502004f, 0.00169158f, 
    -0.06172603f, -0.05271319f, 0.00161186f, 0.04054881f, -0.04084438f, -0.05862248f, -0.03168692f, -0.03110758f, 
    0.04172595f, 0.00105226f, 0.01323873f, 0.01100504f, -0.06969153f, -0.03374033f, 0.02179814f, 0.00015971f, 
    0.00407986f, -0.00498602f, 0.03150432f, 0.01195384f, -0.06513230f, -0.01657447f, -0.02057256f, 0.02372208f, 
    -0.01991193f, -0.05712423f, 0.04346382f, -0.06043434f, 0.05064799f, -0.03409240f, -0.06307602f, 0.04016629f, 
    -0.00086496f, -0.04328258f, -0.02883459f, 0.02790224f, -0.06238850f, -0.02225191f, -0.06038073f, -0.03069353f, 
    -0.04491354f, 0.01300125f, -0.04970740f, 0.04584485f, 0.00251392f, 0.01846205f, -0.06276698f, 0.03805402f, 
    0.03004937f, 0.02806836f, 0.04058430f, 0.00390664f, -0.01259284f, -0.05000108f, -0.01716998f, -0.00575709f, 
    -0.02471844f, 0.04994573f, 0.01858580f, -0.04331034f, 0.04423774f, -0.01068726f, -0.03308278f, -0.03707439f, 
    -0.05659012f, -0.02146161f, 0.00875852f, -0.04204159f, -0.06482293f, -0.04568034f, 0.01717258f, 0.05040823f, 
    0.04716352f, -0.05091988f, -0.06007352f, -0.04618101f, 0.02069922f, 0.00383602f, 0.03123652f, 0.00975056f, 
    -0.05413490f, 0.02657574f, 0.00218131f, -0.00015766f, 0.00031983f, 0.03296535f, -0.00806247f, -0.05297358f, 
    -0.03900151f, 0.03502774f, -0.04339137f, -0.02875882f, 0.03259782f, -0.05969141f, -0.05510700f, 0.02577091f, 
    0.01346956f, -0.01043951f, -0.02645028f, -0.01593692f, 0.04586861f, -0.01032659f, -0.00383507f, -0.01792975f, 
    0.02676389f, 0.00124088f, -0.03008879f, -0.00775845f, -0.00448395f, 0.00829834f, 0.03920167f, -0.01217449f, 
    0.00307970f, 0.04004796f, -0.01786109f, 0.05126655f, -0.06298725f, 0.00339558f, 0.00286040f, -0.03177154f, 
    -0.01243708f, 0.00595310f, -0.05769674f, 0.03583660f, 0.04862618f, 0.03086173f, -0.04756107f, -0.05614381f, 
    0.01982785f, -0.04331246f, 0.03733997f, -0.04887640f, -0.05586687f, 0.03006265f, -0.01203168f, 0.00089376f, 
    -0.03245961f, 0.03768272f, -0.03761712f, -0.05060851f, -0.02996276f, 0.00669003f, -0.00552099f, -0.00296358f, 
    0.00476290f, 0.00826024f, 0.03369494f, 0.02091072f, -0.03412739f, 0.00669756f, -0.04743834f, 0.04832292f, 
    0.01928797f, -0.03020773f, -0.04684187f, 0.04163938f, -0.00668672f, -0.05664582f, -0.03780493f, -0.02736355f, 
    0.03771605f, 0.00281399f, -0.03512873f, 0.02697316f, -0.00995028f, 0.02533292f, -0.04367769f, -0.05183596f, 
    -0.01266508f, -0.02004826f, -0.01019518f, 0.02781847f, -0.01175268f, -0.00003181f, -0.05674382f, -0.04964714f, 
    -0.05247764f, 0.00970599f, -0.03875342f, -0.00294951f, -0.04030850f, 0.02499774f, 0.04929380f, -0.00426942f, 
    -0.01689218f, -0.05139586f, -0.06366172f, 0.03894345f, 0.03151042f, -0.03441761f, -0.04701108f, 0.01816880f, 
    0.01053202f, 0.03432765f, -0.01434614f, 0.04834379f, -0.01634888f, 0.05225863f, -0.00584367f, 0.02774563f, 
    0.05260580f, 0.04252793f, -0.01354498f, 0.02031577f, -0.02047440f, -0.01806198f, -0.04825591f, -0.01670974f, 
    -0.04166780f, 0.05208571f, -0.03011147f, 0.00571281f, 0.00826287f, 0.05056578f, 0.04247675f, 0.05220583f, 
    -0.05694967f, -0.00111576f, -0.00881788f, 0.03666260f, -0.06573132f, 0.00042923f, -0.01580336f, -0.03029701f, 
    -0.00925433f, 0.03071673f, 0.02634051f, 0.00227985f, -0.03614216f, -0.04469148f, -0.04442763f, -0.01000950f, 
    -0.00455187f, -0.04570512f, -0.02864807f, -0.00947342f, 0.03831762f, -0.00894102f, -0.03200831f, -0.03313486f, 
    0.03247575f, -0.04999325f, -0.06270552f, -0.04369474f, 0.01318669f, 0.02320970f, -0.04829894f, -0.05896562f, 
    0.02056349f, 0.01010167f, -0.04836943f, -0.00172149f, -0.06899103f, 0.04889689f, 0.05750697f, -0.05234470f, 
    0.00950093f, -0.00305621f, -0.01103311f, 0.04343239f, -0.01521189f, 0.03402000f, -0.02317777f, 0.00599367f, 
    0.01381701f, 0.04569452f, 0.04533030f, -0.02711319f, 0.04905092f, -0.01989998f, -0.03647624f, -0.01230246f, 
    -0.06045929f, 0.03151442f, -0.06321202f, 0.03720193f, 0.04435400f, 0.04530422f, -0.00062329f, 0.00200839f, 
    0.04331587f, 0.04324446f, 0.01849611f, -0.04807699f, -0.00814672f, -0.05618140f, 0.01198770f, 0.01690390f, 
    -0.03067401f, -0.04488961f, 0.00498013f, -0.04312396f, -0.03333259f, 0.04530267f, -0.05562925f, 0.03068052f, 
    -0.03619295f, 0.01688578f, -0.04763036f, -0.01393249f, -0.05312734f, -0.06606160f, 0.03985589f, -0.05485714f, 
    0.00285585f, -0.03404163f, -0.04113759f, -0.03857051f, -0.00558811f, -0.05313321f, 0.03753660f, 0.00818050f, 
    0.02640249f, 0.05463761f, -0.04613187f, -0.02285737f, -0.04268092f, 0.04485925f, -0.01320467f, -0.04863714f, 
    0.00020998f, -0.00920660f, -0.01917985f, -0.00802054f, -0.03708138f, -0.01160124f, -0.06163388f, -0.00977541f, 
    -0.04761319f, -0.00584190f, -0.00384851f, -0.03358037f, -0.00547373f, -0.04083101f, 0.02618166f, -0.04682758f, 
    -0.06070137f, 0.01517768f, 0.03846050f, -0.01776038f, -0.02355107f, -0.01667416f, 0.02621097f, 0.05087131f, 
    -0.05824497f, 0.01480906f, -0.01167193f, 0.01156578f, -0.01050316f, 0.03256458f, 0.02532863f, 0.02455561f, 
    -0.05918197f, -0.06777233f, 0.01063593f, -0.05588688f, -0.02531325f, -0.04505169f, 0.05620303f, 0.01333689f, 
    0.02091446f, -0.01282744f, 0.00869001f, 0.03483507f, -0.04263506f, -0.02642337f, 0.05187515f, 0.00683541f, 
    0.04153559f, 0.03506829f, -0.06727048f, -0.01962145f, -0.00559906f, 0.02183891f, -0.05005360f, 0.00801792f, 
    0.00115794f, -0.03811891f, 0.03716193f, 0.02918747f, -0.00410764f, -0.02415614f, -0.06163329f, 0.04058433f, 
    0.05197959f, 0.05415290f, 0.00878991f, -0.04820997f, 0.00195442f, 0.00538311f, 0.02572369f, 0.04475841f, 
    -0.04751715f, 0.05272230f, -0.01116958f, 0.04297388f, 0.03251588f, -0.04788839f, -0.00880912f, -0.04541403f, 
    0.02633691f, -0.03673697f, -0.01483074f, -0.01507952f, -0.01242774f, 0.00929194f, -0.03727676f, 0.04839980f, 
    -0.00596738f, 0.00140217f, -0.04416718f, -0.03468529f, -0.02361838f, -0.02345528f, -0.03101600f, -0.04905336f, 
    -0.04730983f, -0.03115675f, -0.06516637f, -0.04697751f, 0.02673521f, 0.03651889f, 0.02843859f, -0.03939243f, 
    0.03580330f, -0.04951302f, 0.01165146f, -0.01796818f, 0.05881742f, -0.00201428f, -0.02100598f, 0.01459169f, 
    -0.03739518f, -0.01572257f, -0.01266384f, -0.05264450f, -0.05491480f, 0.03697639f, -0.00699966f, -0.02995061f, 
    0.00891651f, -0.01396407f, 0.00666311f, -0.00354640f, 0.03277192f, 0.01404140f, 0.03687387f, 0.02699747f, 
    -0.00403046f, -0.04961256f, 0.00165213f, -0.06119278f, -0.00131842f, -0.01550998f, -0.03476064f, -0.04059309f, 
    0.04976642f, 0.00216070f, 0.03754110f, -0.01710200f, 0.04875695f, 0.01928698f, -0.06583543f, 0.03432960f, 
    0.02523875f, 0.05372995f, -0.01095500f, 0.01034675f, -0.02908681f, -0.06501580f, -0.05574729f, 0.02730225f, 
    -0.02367849f, -0.00139646f, 0.03325977f, 0.01959609f, 0.00696503f, 0.02386226f, 0.02440683f, 0.04800714f, 
    0.01667832f, -0.02151871f, 0.02780906f, -0.04224801f, -0.06887592f, -0.01088995f, -0.05444068f, 0.03408593f, 
    -0.04497303f, 0.05075644f, 0.00938160f, -0.01843418f, -0.05793110f, -0.03467517f, -0.00880602f, -0.01599660f, 
    -0.02495730f, -0.03461951f, 0.03452453f, -0.06123228f, -0.00475842f, -0.00008889f, 0.02512656f, -0.03476453f, 
    0.00352860f, -0.01941942f, 0.01637700f, -0.06287556f, 0.00717552f, -0.02901256f, -0.02435052f, 0.02591434f, 
    0.01167514f, 0.00009536f, -0.02364152f, 0.04238138f, 0.04005638f, 0.03114669f, 0.04113112f, -0.05249123f, 
    -0.02229062f, 0.04634873f, -0.03745758f, -0.03577400f, -0.06036317f, 0.02718851f, -0.04585900f, -0.02929058f, 
    0.01905981f, -0.04622224f, -0.04260802f, 0.03447579f, 0.00656519f, 0.01016930f, 0.04234225f, -0.03352303f, 
    0.01990236f, -0.00667988f, -0.02374966f, -0.01395508f, -0.00442420f, 0.04048685f, 0.02871460f, -0.05085661f, 
    -0.03610534f, 0.02330403f, 0.02994127f, 0.02150775f, 0.03121356f, -0.02497103f, -0.02997600f, -0.04783936f, 
    0.00817682f, 0.02760900f, -0.03695275f, 0.05123815f, -0.02051143f, -0.03746399f, 0.02470077f, -0.02171376f, 
    -0.05732743f, -0.05690549f, -0.06252522f, -0.06038010f, -0.03849805f, -0.05822102f, -0.00510163f, -0.00458072f, 
    -0.04082931f, 0.03267471f, 0.04465209f, -0.03674765f, 0.04179751f, -0.02962383f, 0.04821167f, 0.04451675f, 
    0.01389586f, 0.00803749f, 0.02485492f, -0.05830427f, -0.02215636f, 0.01461071f, -0.02196322f, -0.03816868f, 
    -0.01808643f, 0.00809719f, -0.02696284f, 0.04773000f, -0.04191695f, -0.01761538f, 0.02832210f, 0.02895110f, 
    -0.02503306f, -0.02327412f, -0.00807561f, 0.01992102f, 0.02820932f, -0.05918897f, 0.02375261f, 0.03306402f, 
    -0.05273834f, 0.03333896f, 0.02160156f, 0.05487955f, -0.06256246f, -0.05860585f, 0.03542200f, -0.03474356f, 
    -0.05280377f, 0.04450155f, -0.02905514f, -0.04290251f, -0.03598925f, 0.00202128f, 0.04499952f, 0.02215550f, 
    -0.03814394f, 0.02749154f, 0.04970335f, -0.02032055f, -0.06402085f, -0.04983979f, -0.05597181f, 0.05015108f, 
    -0.03806263f, -0.01517269f, 0.01746819f, -0.05138127f, -0.05566816f, -0.02452467f, -0.04782395f, -0.05716750f, 
    0.00363556f, -0.00271710f, -0.04233507f, -0.00291834f, -0.02107920f, -0.06645450f, 0.02048109f, 0.04194358f, 
    0.01464341f, 0.02962897f, -0.04912861f, 0.02582713f, -0.01461564f, -0.04784626f, -0.03625510f, 0.01035648f, 
    0.05298654f, 0.01814439f, -0.05332546f, 0.00385124f, 0.03830160f, -0.04152388f, -0.06254678f, -0.00086350f, 
    0.00467330f, 0.01246751f, -0.01931044f, -0.02309136f, 0.00919810f, 0.01951711f, 0.04203090f, -0.00685844f, 
    -0.01018317f, 0.00835140f, 0.00151126f, -0.03199203f, -0.02723335f, -0.06509188f, -0.04467374f, -0.03973455f, 
    0.00957204f, 0.03831568f, 0.00739651f, 0.04402389f, -0.01396601f, -0.01808137f, 0.00147369f, 0.04248522f, 
    0.01513788f, -0.02764149f, -0.03277523f, 0.04791712f, -0.00746954f, 0.01168229f, 0.01692832f, 0.04668101f, 
    0.03798417f, -0.02548499f, 0.02362185f, 0.04608579f, -0.05199962f, 0.00322655f, 0.02755282f, -0.01069534f, 
    0.00089305f, -0.03604175f, 0.01524001f, 0.04705309f, -0.05575778f, -0.05746014f, -0.01508511f, 0.03849436f, 
    -0.04921859f, 0.02903375f, -0.04448024f, 0.01740450f, -0.00705190f, 0.03213959f, -0.01731710f, -0.01752824f, 
    0.01888861f, -0.03584075f, -0.06567058f, 0.02447816f, 0.00528408f, 0.04870441f, 0.03733594f, -0.06388455f, 
    -0.06363359f, 0.04830294f, -0.02413057f, -0.04092110f, 0.03127262f, 0.02827161f, -0.01110888f, 0.02579222f, 
    -0.00607329f, -0.36750063f, -0.00203991f, -0.13076682f, -0.11039103f, 0.09891826f, -0.08783840f, 0.11606293f, 
    -0.05889546f, 0.22364925f, -0.37315792f, -0.00463359f, 0.07097328f, -0.18452111f, -0.11660060f, 0.19338964f, 
    0.01723776f, -0.19618292f, 0.06208270f, -0.26120844f, 0.10439385f, -0.22225422f, -0.03657617f, -0.03516419f, 
    0.08600609f, -0.22104532f, 0.17958358f, -0.04702726f, -0.05261772f, 0.19610697f, 0.08238953f, -0.13333373f, 
    0.10310426f, -0.02785164f, -0.01350608f, -0.14133407f, 0.18174347f, -0.02570500f, 0.00548429f, 0.04229150f, 
    0.01791970f, 0.11213471f, -0.12899390f, 0.10802144f, 0.10122962f, -0.35995850f, 0.29335615f, -0.05063800f, 
    -0.04623890f, -0.13714679f, -0.09201515f, 0.05802308f, 0.04311707f, 0.02988433f, 0.08978587f, -0.35018510f, 
    0.15800910f, -0.19989125f, -0.03585695f, -0.06763994f, 0.16068800f, -0.04389340f, 0.08813173f, 0.12858449f, 
    0.07050806f, -0.24669152f, 0.21174751f, -0.02873674f, -0.03218911f, -0.11244888f, -0.11294044f, 0.13266599f, 
    -0.07741903f, 0.30239782f, -0.23704268f, -0.08097006f, 0.12507896f, 0.33604559f, -0.18175265f, -0.09455570f, 
    -0.14238587f, -0.69159544f, -0.18288992f, -0.06877733f, -0.32646996f, -0.16506857f, -0.02169052f, -0.25271791f, 
    0.21625729f, 0.10980889f, 0.37516806f, 0.14725487f, -0.28780901f, 0.17731632f, -0.00295669f, 0.10237364f, 
    -0.01570857f, 0.20305353f, -0.20181786f, -0.13274635f, -0.15189245f, 0.12059341f, -0.01296128f, -0.09678105f, 
    -0.00861902f, -0.18729390f, -0.04043137f, 0.27796799f, 0.15528774f, -0.11574449f, 0.26708663f, 0.09674253f, 
    0.02185635f, -0.04788807f, 0.04803210f, -0.02725590f, -0.03617185f, 0.07789509f, -0.16203354f, -0.28576344f, 
    -0.17981121f, -0.10247102f, 0.05151300f, -0.02472593f, -0.09061889f, 0.12092263f, 0.24194975f, -0.17836849f, 
    -0.20365252f, 0.11562233f, -0.05266583f, 0.19331582f, 0.21364668f, 0.23310865f, 0.08130131f, 0.09909732f, 
    0.04846828f, -0.17318414f, 0.14360173f, -0.08307069f, -0.02174071f, -0.04368234f, 0.13552064f, -0.11179832f, 
    -0.13849673f, 0.09467019f, -0.01867153f, 0.18991673f, 0.13185063f, -0.10651905f, 0.22427970f, -0.12740664f, 
    -0.19933893f, 0.19832672f, -0.07416067f, -0.34331760f, 0.18897201f, 0.07900835f, 0.10255636f, -0.04369557f, 
    -0.17738803f, 0.08811510f, 0.20057644f, 0.24909939f, 0.02221273f, 0.25684905f, 0.02596393f, 0.14589253f, 
    -0.19068222f, 0.03332700f, -0.12607536f, -0.01746006f, 0.15483649f, 0.18846442f, 0.27330741f, 0.09357478f, 
    -0.22463080f, 0.02780134f, -0.07283163f, -0.12924379f, 0.23144385f, 0.25419685f, -0.13741714f, 0.09457619f, 
    0.18479480f, -0.10186773f, 0.18365432f, -0.10346983f, -0.30858788f, 0.33798358f, 0.09102489f, 0.00063980f, 
    0.14952157f, 0.06663172f, 0.16754521f, 0.04633544f, -0.06319640f, 0.07900093f, -0.12088450f, -0.08677208f, 
    0.05492218f, 0.05609519f, -0.05236445f, 0.14090015f, 0.06007781f, 0.31992474f, 0.09149916f, -0.18054166f, 
    0.18434718f, -0.39880264f, 0.08749142f, -0.07008301f, 0.21617591f, -0.09611350f, -0.28706795f, 0.28692061f, 
    -0.08425955f, -0.03155218f, 0.18077208f, -0.09205124f, 0.13209507f, 0.08571253f, -0.15722357f, 0.33682293f, 
    -0.35147294f, 0.04494393f, -0.04032259f, 0.37663969f, -0.07465974f, 0.01468503f, 0.01322924f, 0.04510891f, 
    0.05372627f, -0.10539480f, 0.20084316f, -0.21664405f, 0.32739249f, -0.04182043f, -0.08316286f, -0.07441573f, 
    -0.16480273f, -0.18259084f, -0.10214391f, -0.05838019f, 0.23398675f, -0.06063575f, 0.03961975f, 0.02227111f, 
    -0.09225068f, 0.10190357f, 0.00015228f, -0.20517100f, 0.04256089f, 0.36138833f, 0.00090232f, 0.21058635f, 
    0.03437047f, -0.05824148f, 0.02739248f, -0.04060635f, 0.12738003f, -0.02310014f, -0.12468327f, -0.15280880f, 
    0.00165726f, 0.26425147f, 0.00151912f, -0.09779378f, -0.13392763f, 0.22822802f, -0.36060408f, -0.31684789f, 
    0.16297060f, 0.02725010f, -0.09891263f, 0.15283009f, -0.09099715f, 0.11069555f, -0.02222024f, 0.16867213f, 
    0.26719067f, -0.17879473f, 0.09604688f, -0.11277460f, 0.08847698f, -0.04388520f, 0.15070835f, -0.00188664f, 
    -0.22274318f, -0.21677388f, 0.17841931f, 0.28030127f, -0.02783795f, -0.02962015f, -0.13329400f, 0.09499057f, 
    -0.14456022f, 0.23309879f, -0.41133735f, 0.21986452f, -0.11590239f, 0.09891339f, -0.01054850f, 0.06145333f, 
    -0.04020812f, 0.08819026f, 0.18836138f, -0.06736178f, -0.11489114f, 0.10429253f, -0.01715482f, -0.02429543f, 
    -0.05034262f, 0.07388607f, -0.24535176f, -0.46760929f, 0.11535380f, -0.27838197f, 0.43156517f, -0.03624672f, 
    0.09684531f, 0.00007681f, -0.23391171f, 0.04989160f, -0.06661800f, -0.01982195f, 0.05142508f, -0.11095818f, 
    -0.08859847f, -0.16353332f, -0.01497674f, -0.17960592f, 0.24042192f, -0.03247835f, 0.10512058f, 0.12872273f, 
    0.03767094f, -0.05300574f, 0.00906449f, 0.12165644f, 0.16696106f, 0.00691846f, -0.04501883f, -0.18253493f, 
    0.15104420f, 0.18164079f, -0.07930259f, 0.23048709f, 0.25857180f, -0.17339316f, 0.11968072f, -0.08104093f, 
    -0.07198492f, 0.41167149f, 0.33341789f, 0.24229333f, -0.10514188f, 0.11327326f, 0.09337991f, -0.02707379f, 
    -0.53198314f, -0.20041294f, -0.04611458f, 0.39408690f, -0.13441667f, 0.23996450f, -0.04419364f, -0.01855258f, 
    -0.05448852f, -0.06028146f, -0.16709733f, 0.19551517f, 0.14881761f, 0.17188846f, 0.08576071f, -0.15130471f, 
    -0.05297399f, 0.13333508f, -0.11656477f, 0.24281245f, -0.12132040f, -0.28391126f, 0.03801143f, -0.11884225f, 
    -0.13447872f, -0.01032801f, 0.03189661f, -0.15750119f, -0.14475492f, 0.56875551f, 0.17990260f, 0.02209091f, 
    0.02533661f, -0.03742788f, -0.07342575f, 0.13047935f, 0.25383934f, 0.18319750f, 0.19774465f, -0.04934935f, 
    0.09927467f, 0.00264854f, 0.17559299f, 0.15656498f, -0.11872210f, 0.36784384f, 0.04855711f, -0.39739287f, 
    -0.01908442f, -0.10040119f, -0.06307506f, -0.09707545f, -0.00008104f, -0.04353860f, 0.12173480f, 0.07685222f, 
    -0.22837223f, 0.06670022f, -0.16720694f, 0.18260190f, 0.11552344f, 0.12729046f, 0.13898018f, -0.33979884f, 
    0.15722652f, 0.03667141f, -0.27969554f, -0.21972376f, 0.34761488f, -0.06444352f, -0.21099690f, 0.03965452f, 
    0.02661640f, 0.13554429f, 0.29647061f, -0.11056385f, 0.01663701f, -0.04958775f, -0.11365190f, -0.03884387f, 
    -0.13594721f, 0.06538758f, -0.22916752f, 0.12276097f, -0.19305265f, 0.23009747f, 0.03439026f, -0.10625380f, 
    -0.10238506f, 0.06825960f, -0.32015735f, 0.00365544f, 0.08980567f, -0.14673485f, 0.06720805f, 0.14131746f, 
    0.05974135f, -0.23590825f, 0.03157917f, -0.25735831f, 0.13496816f, -0.12340180f, 0.24290055f, -0.15751068f, 
    0.06438294f, 0.06898045f, -0.02111397f, 0.03188253f, 0.00538709f, -0.13659820f, -0.23381838f, -0.10132769f, 
    0.09830099f, -0.16360214f, -0.07306493f, -0.11549157f, 0.00124339f, 0.62252301f, -0.06526336f, -0.19057751f, 
    -0.05608509f, -0.05508405f, 0.05585055f, 0.18389431f, 0.08739264f, 0.19951269f, -0.14747486f, -0.02217113f, 
    0.01749811f, -0.18659033f, -0.07784846f, 0.05375042f, 0.04221850f, -0.12686138f, -0.09904422f, 0.00066581f, 
    0.17003883f, -0.09403621f, 0.19831121f, 0.09384426f, 0.12457893f, 0.05998141f, 0.06484082f, 0.12989035f, 
    -0.33210397f, -0.18271123f, -0.31098810f, -0.15649980f, 0.24830210f, -0.05854587f, 0.27162802f, 0.14882261f, 
    0.02832181f, -0.19034415f, 0.03216197f, 0.09304459f, -0.00711019f, 0.05919460f, -0.05609962f, 0.23845467f, 
    0.19475816f, -0.04152305f, 0.05391936f, 0.04368050f, 0.26374781f, 0.14673595f, -0.07975383f, 0.11977463f, 
    -0.07322208f, -0.14345950f, 0.00755389f, -0.13168359f, -0.02520358f, 0.02705601f, -0.29397789f, 0.06725182f, 
    -0.09181849f, -0.05679021f, 0.07482326f, 0.06792135f, -0.08212670f, 0.28754613f, -0.13946091f, -0.18801807f, 
    0.08347475f, -0.20386520f, -0.15942518f, -0.11577700f, -0.08367071f, 0.18800354f, 0.03524595f, 0.14823700f, 
    0.04468165f, 0.14780502f, 0.03380904f, 0.01060549f, 0.21220557f, -0.03721903f, -0.25062504f, -0.23944841f, 
    0.23412038f, 0.30278438f, 0.30327570f, -0.00953817f, 0.05600047f, -0.10716271f, 0.21301872f, 0.04867505f, 
    -0.00269951f, -0.11327757f, -0.12750867f, 0.08739045f, -0.12546164f, 0.07617051f, 0.22078982f, 0.18915528f, 
    0.01013290f, 0.00841080f, -0.04282634f, 0.03793427f, -0.02345916f, -0.03511135f, -0.00222470f, 0.05267158f, 
    -0.03918448f, -0.03929092f, 0.05374988f, 0.03072019f, 0.03380659f, 0.01897848f, 0.01954202f, -0.02910342f, 
    -0.02245513f, 0.04741780f, 0.01577242f, 0.00387736f, 0.03212598f, 0.05117406f, 0.00400366f, 0.00067920f, 
    -0.02804649f, -0.05415932f, 0.03496375f, 0.05548965f, 0.00596738f, 0.04439789f, 0.02325361f, -0.00972410f, 
    0.02199612f, -0.01558361f, 0.01365344f, -0.00877349f, 0.02551367f, -0.00639621f, -0.00505009f, -0.00324851f, 
    -0.04608763f, 0.04275271f, -0.05092538f, -0.05629458f, -0.00164112f, -0.00161428f, -0.01004022f, -0.03063971f, 
    -0.00489682f, -0.03920603f, -0.00826406f, -0.04466264f, 0.01751206f, 0.03917526f, -0.03428766f, -0.05736880f, 
    -0.01753507f, -0.02136134f, 0.03116310f, 0.04486017f, -0.00345001f, -0.02768822f, -0.03667095f, -0.04141630f, 
    -0.01343316f, 0.03055975f, -0.02005200f, -0.02684339f, 0.00105191f, 0.00449988f, 0.03424524f, -0.04713164f, 
    0.03225642f, 0.01750339f, 0.00496541f, 0.01951778f, 0.00880268f, -0.02995052f, -0.00610097f, 0.04829055f, 
    0.02044018f, -0.03240345f, -0.03656380f, 0.03592929f, 0.00583095f, -0.02069850f, -0.04778640f, -0.05652093f, 
    -0.01285576f, -0.03209750f, -0.01050602f, 0.02840648f, 0.00320890f, 0.00126174f, -0.03154859f, -0.04341486f, 
    -0.00925294f, -0.04169650f, 0.04907998f, -0.04912252f, 0.00903787f, 0.05024364f, 0.04430065f, -0.00873661f, 
    -0.00265908f, -0.04716565f, -0.01476194f, 0.04778114f, -0.00368710f, 0.00632520f, 0.01165261f, -0.05137622f, 
    0.05697374f, -0.04727061f, -0.05669936f, -0.02758991f, -0.00350965f, 0.03570824f, -0.00993332f, 0.02877753f, 
    -0.04416830f, -0.01722183f, 0.03238817f, -0.04441884f, -0.00035777f, -0.02284924f, 0.03888206f, 0.00776321f, 
    0.05049958f, 0.04839749f, -0.02154317f, -0.01511131f, -0.05257971f, 0.01900661f, -0.00610481f, -0.04813355f, 
    -0.00389797f, 0.00734136f, 0.00027620f, 0.03810709f, -0.03683179f, 0.01919921f, -0.00707287f, 0.00173162f, 
    -0.02362525f, -0.01699199f, 0.03388294f, -0.01736794f, -0.01568488f, -0.01268331f, -0.00834136f, -0.02876832f, 
    0.00789893f, 0.02428974f, -0.01063562f, -0.02382129f, 0.02512138f, 0.05134182f, 0.05448269f, -0.05824937f, 
    -0.04572724f, -0.01171418f, 0.03277309f, 0.01307323f, -0.00683137f, -0.00589324f, -0.00727716f, 0.02799346f, 
    -0.02103982f, 0.04451745f, -0.00808010f, -0.00252442f, -0.04440720f, -0.02586648f, -0.02977834f, 0.03260846f, 
    -0.00182050f, -0.05217300f, 0.03129650f, -0.03553441f, 0.04761656f, 0.00690250f, 0.04463659f, 0.05190168f, 
    -0.01755961f, -0.04031501f, -0.00673214f, -0.02020604f, 0.00873227f, -0.00411701f, -0.00843103f, -0.05746404f, 
    -0.01382752f, -0.04360249f, -0.02088205f, 0.00599765f, 0.04874473f, 0.02402794f, -0.03138851f, -0.04325419f, 
    -0.04126287f, -0.02224526f, -0.01904367f, -0.05175835f, 0.05268525f, 0.00413617f, 0.03618775f, -0.04346625f, 
    -0.00229029f, 0.01985431f, -0.00967418f, -0.02850623f, -0.00039521f, -0.00001913f, 0.02153541f, 0.03216370f, 
    -0.02398715f, 0.00300319f, -0.03065506f, -0.02863292f, 0.01970678f, 0.00434018f, 0.00902414f, -0.05511876f, 
    0.05173506f, -0.00809325f, -0.00301671f, 0.02496017f, -0.02869256f, -0.02474683f, -0.02045416f, 0.04637370f, 
    -0.04177009f, 0.05664579f, -0.01062462f, 0.01622407f, -0.03628238f, -0.00886444f, -0.00613761f, -0.05221922f, 
    -0.03086816f, 0.01541370f, 0.00567678f, 0.01090571f, -0.04100269f, -0.03390757f, 0.00399551f, -0.00183713f, 
    -0.02107122f, -0.00525771f, -0.03545949f, -0.01289703f, 0.03793768f, -0.03823408f, -0.02845129f, -0.02350651f, 
    -0.00673224f, -0.02618947f, 0.01321410f, -0.05176042f, -0.01834423f, -0.01332785f, -0.01627966f, -0.04637209f, 
    -0.01939162f, -0.02636274f, -0.00604963f, 0.02256620f, 0.04658148f, 0.01775678f, 0.00582106f, 0.05833790f, 
    0.00099131f, -0.00352152f, 0.01973521f, -0.03661236f, -0.05440994f, -0.01950280f, -0.00882525f, -0.01510089f, 
    -0.03282609f, 0.01197038f, -0.05797359f, 0.00598770f, -0.02048303f, -0.01525533f, -0.02004612f, -0.05430857f, 
    -0.07893436f, 0.04447124f, 0.19094834f, -0.17325392f, -0.21998534f, -0.07637357f, 0.16606112f, -0.03573103f, 
    0.14668719f, -0.33095145f, 0.35648853f, 0.06168628f, 0.13303088f, -0.08495566f, -0.12256824f, -0.17533073f, 
    -0.17134258f, -0.25355828f, 0.16265377f, 0.03484488f, -0.05995828f, 0.01144843f, 0.07275288f, 0.03132159f, 
    -0.03213377f, 0.00842119f, 0.01294147f, -0.25283018f, 0.08225156f, -0.23589249f, 0.06431843f, 0.08876313f, 
    -0.07832287f, 0.03733405f, 0.13487893f, 0.00775624f, -0.38603267f, -0.12063021f, -0.32586899f, 0.00331258f, 
    0.03136624f, 0.04004784f, -0.08689430f, -0.24149053f, -0.10387238f, -0.54465568f, 0.06571042f, 0.17702261f, 
    -0.23423055f, -0.19540800f, 0.21650074f, -0.07671982f, -0.00772368f, 0.01077490f, -0.16620032f, 0.10797429f, 
    -0.21039662f, -0.00991353f, -0.13315475f, 0.03860074f, 0.07814648f, 0.16878016f, -0.03397976f, 0.24008584f, 
    0.24572347f, 0.15178102f, 0.04739044f, -0.10880168f, 0.06543458f, -0.07038348f, 0.10561315f, 0.17955534f, 
    -0.18250404f, -0.16443688f, -0.16130465f, 0.05172154f, 0.27224356f, 0.10096283f, 0.01157818f, 0.03090960f, 
    0.14137504f, -0.04739008f, -0.06005659f, 0.26932415f, -0.06904738f, -0.08674913f, -0.15859991f, -0.02875859f, 
    -0.35768166f, -0.20959543f, 0.04619498f, -0.00537027f, 0.27910888f, 0.10451137f, -0.22820035f, -0.00449100f, 
    0.08709407f, 0.11305831f, 0.21716785f, 0.31001392f, 0.45080164f, 0.28454742f, -0.07759278f, 0.00107872f, 
    -0.13071197f, 0.24947140f, 0.02003167f, -0.19292454f, 0.20658951f, 0.07877053f, -0.08173823f, 0.23635891f, 
    -0.01683228f, -0.20370564f, 0.02421233f, 0.17188495f, -0.01872505f, 0.22294730f, 0.14559741f, 0.10472690f, 
    0.02550929f, 0.05930138f, -0.17653956f, 0.00253816f, -0.08492983f, -0.08348523f, 0.21916544f, 0.18161112f, 
    0.18224972f, 0.23493339f, -0.05526207f, -0.01313884f, -0.00665782f, 0.15354146f, 0.24659662f, -0.30830568f, 
    -0.07975793f, -0.32500803f, 0.18955088f, 0.14080322f, -0.05755520f, -0.09604098f, 0.01325568f, 0.25759163f, 
    -0.18300825f, -0.38822362f, -0.00184841f, 0.10500115f, 0.15865904f, -0.14956340f, 0.01779522f, -0.13746677f, 
    -0.03058209f, -0.07665795f, -0.09520417f, 0.17798133f, 0.20178640f, -0.05379933f, 0.05887839f, 0.03969429f, 
    0.02555735f, -0.02989682f, 0.10586976f, -0.09891514f, 0.13049674f, 0.21422653f, -0.09012288f, 0.01356301f, 
    -0.06335201f, 0.11800681f, 0.04639433f, 0.34071764f, 0.12112808f, 0.08473146f, 0.19909412f, -0.15543121f, 
    0.00788210f, 0.23837915f, 0.18732786f, 0.34272343f, -0.25558600f, -0.57871503f, -0.05385118f, 0.02248819f, 
    0.06122890f, 0.16774711f, 0.17159630f, -0.04465152f, 0.18474245f, -0.22694249f, 0.07222675f, -0.03257361f, 
    0.12287892f, 0.18109335f, -0.07943256f, 0.09037225f, -0.01726544f, 0.01742053f, -0.08811757f, -0.09704097f, 
    -0.15517238f, 0.32321948f, 0.03896263f, -0.34249052f, -0.05995502f, 0.06376373f, -0.06718030f, -0.18653622f, 
    -0.02783838f, 0.12801167f, 0.04900096f, 0.02814428f, 0.00668622f, -0.07945613f, -0.05337628f, 0.03440929f, 
    -0.02658215f, -0.24030638f, -0.27736562f, 0.14222795f, -0.15423179f, -0.22884856f, -0.07954412f, 0.01878798f, 
    0.27546212f, 0.10392702f, -0.06098536f, -0.02203421f, 0.12893623f, 0.01422531f, -0.25330654f, 0.24469805f, 
    -0.15928523f, 0.08670690f, -0.15682305f, 0.41068479f, -0.44197616f, 0.04739253f, 0.02919148f, -0.10629606f, 
    0.15454611f, -0.16306438f, -0.12239058f, -0.42238083f, -0.71407408f, -0.43821248f, 0.08680662f, -0.03241866f, 
    -0.04390490f, -0.21988545f, 0.08303449f, 0.05575310f, 0.04277083f, 0.21103902f, -0.05663905f, 0.09787634f, 
    -0.23031938f, 0.02367421f, 0.18784934f, 0.10042584f, 0.23955512f, -0.13957097f, -0.01995352f, 0.22823380f, 
    -0.14020732f, -0.15278329f, 0.06231963f, 0.25071254f, 0.17492037f, 0.10399498f, -0.02104846f, 0.12740433f, 
    0.36255831f, 0.20030057f, -0.03561793f, 0.04458550f, 0.04427915f, -0.25361440f, 0.06318273f, -0.32188955f, 
    -0.71157491f, -0.19534273f, 0.02428812f, 0.09598383f, 0.07082852f, -0.04397690f, 0.05609658f, 0.07581445f, 
    -0.03039997f, 0.02672403f, -0.02732375f, -0.01620653f, 0.01965703f, -0.02781570f, -0.01448524f, 0.02052653f, 
    0.01982163f, -0.04072597f, 0.02643933f, 0.02192736f, -0.04106430f, -0.00691332f, -0.01109900f, -0.05064027f, 
    -0.01831905f, -0.00601569f, -0.04788444f, 0.03518967f, -0.02915822f, -0.06382855f, 0.01844549f, -0.03812647f, 
    -0.05079295f, 0.01297061f, -0.00828264f, -0.00653293f, 0.01044822f, -0.02536939f, -0.00343128f, -0.01577783f, 
    0.05300717f, -0.02169765f, 0.03583600f, -0.06657746f, 0.02375666f, 0.02740644f, -0.02425877f, 0.00239542f, 
    0.03766730f, 0.02049575f, -0.02649091f, -0.00491677f, -0.03087473f, 0.00069980f, -0.00099961f, -0.02115603f, 
    -0.00916831f, -0.05465802f, -0.02225166f, 0.03046627f, 0.01697977f, -0.01849425f, 0.00017373f, -0.02163026f, 
    -0.02614195f, -0.05676728f, -0.02054434f, 0.03663010f, 0.04855248f, -0.01707547f, -0.05820273f, 0.02262864f, 
    0.03666223f, -0.02518167f, -0.01873935f, -0.04276284f, -0.01808618f, 0.01667235f, -0.01165584f, 0.00611459f, 
    0.00131493f, -0.05532779f, 0.02447821f, 0.02487444f, -0.03472643f, 0.00163568f, 0.04664646f, 0.04808521f, 
    0.02366078f, 0.02788415f, -0.01601593f, 0.05494486f, 0.02115684f, 0.05446915f, 0.02279253f, -0.01066539f, 
    0.03743030f, -0.06643039f, -0.02444614f, 0.01678829f, 0.03258742f, -0.02861330f, 0.03470164f, -0.01224932f, 
    -0.00348556f, -0.06087056f, 0.01249964f, 0.02493216f, -0.02066113f, -0.00350433f, -0.05329617f, 0.03668289f, 
    -0.06376622f, -0.05764282f, 0.04325088f, -0.05885525f, 0.01209866f, 0.00422341f, -0.01930574f, -0.00760480f, 
    -0.05801971f, 0.00120740f, -0.02290634f, -0.02523801f, -0.01391312f, -0.02172569f, 0.04423672f, -0.01043554f, 
    -0.01591669f, 0.03292742f, -0.02468852f, 0.00371551f, -0.00889849f, 0.02277607f, 0.03994426f, -0.00280966f, 
    0.01220020f, -0.00022233f, -0.03654524f, 0.02844181f, -0.03408509f, 0.00336335f, -0.00935754f, 0.03609561f, 
    0.01084073f, 0.00490434f, -0.00139403f, -0.05460187f, -0.00289667f, -0.02687401f, 0.00236209f, -0.05038199f, 
    -0.00296177f, 0.00614729f, -0.03333363f, -0.01740777f, -0.05168482f, -0.04637924f, 0.00538534f, 0.04260374f, 
    0.03930807f, -0.02126034f, -0.03865065f, -0.03998573f, 0.01450243f, -0.05209510f, 0.03631618f, 0.01324616f, 
    -0.01786689f, -0.03433741f, 0.03748783f, 0.03938184f, -0.01208379f, 0.01527775f, -0.05710590f, 0.03265131f, 
    -0.01631678f, -0.06070370f, -0.00756974f, 0.02342737f, -0.01164002f, -0.04199097f, 0.03598366f, 0.04030469f, 
    0.04818511f, -0.00542126f, 0.00805009f, 0.03001071f, 0.03261540f, -0.00684202f, -0.05881786f, -0.02475029f, 
    -0.01219994f, -0.01778592f, -0.00204630f, -0.01244489f, -0.04297092f, -0.02724676f, -0.01547047f, 0.01405756f, 
    0.04747114f, -0.02495523f, -0.02644689f, 0.04260354f, 0.01226200f, 0.01272163f, 0.02445311f, 0.04505527f, 
    0.04602202f, -0.03857417f, -0.02198944f, -0.01111406f, 0.00535789f, -0.00317690f, -0.01172911f, -0.04443787f, 
    -0.03958062f, -0.00897755f, -0.04582336f, -0.05332439f, -0.01255114f, 0.01928735f, 0.04476793f, 0.01073657f, 
    0.04109497f, -0.03884813f, -0.02976208f, -0.05218616f, -0.04136504f, -0.05343935f, 0.01892200f, -0.01793356f, 
    -0.01442256f, 0.02199337f, 0.03274859f, 0.02411565f, 0.01578044f, 0.03907433f, -0.05674876f, 0.05237443f, 
    -0.03534725f, -0.01084928f, 0.02699050f, 0.03906322f, -0.06292132f, -0.06525691f, -0.05685256f, 0.05418415f, 
    0.02399558f, -0.00813372f, -0.01641791f, -0.04481712f, 0.00268625f, -0.06458621f, -0.00218303f, -0.04874270f, 
    0.01631134f, -0.02119063f, 0.02987436f, 0.04863041f, -0.00947954f, 0.01497259f, -0.05788665f, -0.02157728f, 
    0.02256862f, 0.02433592f, 0.01739228f, -0.01148674f, -0.03123980f, 0.02933260f, 0.05139241f, 0.03811638f, 
    -0.04081950f, 0.01200241f, -0.03547597f, -0.00607360f, 0.04051708f, -0.02949131f, -0.05558581f, -0.03549921f, 
    -0.03949650f, 0.01100522f, 0.03010723f, -0.02900441f, 0.03615494f, -0.04873203f, 0.02245746f, 0.01185973f, 
    -0.03145299f, 0.03052936f, 0.01292995f, 0.00840138f, -0.03731525f, -0.04840989f, -0.03753575f, -0.06003424f, 
    -0.05635472f, 0.04349072f, 0.01861649f, 0.02844446f, 0.01741854f, 0.00473728f, -0.05389701f, -0.04838769f, 
    0.01060713f, -0.01653658f, -0.02127636f, 0.04697559f, -0.02096849f, 0.00582486f, 0.02967935f, 0.02302215f, 
    -0.01291086f, -0.02864287f, -0.04510655f, 0.01117585f, -0.04618392f, -0.03702128f, -0.04341551f, 0.00375363f, 
    0.04142597f, 0.01341632f, -0.01754425f, -0.02270402f, -0.01099672f, 0.00017696f, -0.00181688f, -0.00037554f, 
    0.04924098f, -0.03452956f, 0.00366041f, -0.04429474f, -0.04477544f, 0.00687969f, -0.04251936f, -0.02293689f, 
    0.04378597f, -0.02236120f, -0.06477034f, -0.05671361f, -0.00728343f, -0.06196767f, -0.03167867f, 0.02297274f, 
    -0.00411837f, 0.03151149f, -0.01452760f, -0.05368493f, -0.04401959f, -0.01373405f, -0.04965676f, -0.04004116f, 
    0.03429116f, -0.03711425f, 0.02355562f, -0.03304385f, -0.00656648f, -0.03414534f, 0.05281216f, -0.04677594f, 
    -0.04537539f, -0.01496332f, -0.03298467f, 0.02211579f, -0.01033057f, -0.05899416f, -0.00104492f, 0.00862574f, 
    0.02928371f, 0.03417597f, -0.02199318f, -0.00917074f, -0.04870306f, -0.01490484f, -0.05937152f, -0.01801445f, 
    -0.04204835f, -0.02992414f, -0.03753803f, -0.00132203f, -0.01670077f, 0.04492622f, -0.03064704f, -0.01001415f, 
    0.05125682f, 0.02674033f, 0.00073713f, -0.01539890f, -0.00517324f, 0.04914813f, -0.02035443f, 0.01067354f, 
    0.03780571f, 0.05180753f, 0.04892043f, -0.05748844f, -0.05448744f, -0.00610347f, -0.05670243f, 0.03036546f, 
    -0.02008338f, 0.03705107f, 0.01699085f, 0.03082410f, -0.05931697f, 0.03330785f, -0.05383865f, -0.06220249f, 
    0.04361417f, -0.01377304f, -0.05894366f, -0.03197372f, 0.02496165f, 0.03680881f, 0.02042621f, 0.01018221f, 
    0.03748668f, -0.02172615f, 0.03925261f, 0.03878701f, 0.03902423f, 0.00041619f, 0.03468196f, -0.03425842f, 
    0.00059804f, -0.06024659f, -0.00153791f, -0.00934071f, 0.03358358f, -0.00627286f, -0.00277389f, -0.05791305f, 
    -0.03839786f, -0.05576109f, -0.03925514f, -0.00701469f, -0.04559355f, -0.01497236f, -0.01643640f, -0.05280758f, 
    -0.01919853f, -0.04531489f, 0.04931764f, 0.04144693f, 0.01623310f, 0.00158555f, 0.01860573f, -0.02077134f, 
    -0.00031938f, -0.00277603f, 0.04775714f, 0.00203014f, -0.02542622f, -0.02357949f, -0.06375720f, -0.02552994f, 
    -0.03244869f, -0.02914791f, -0.00298931f, 0.01287160f, 0.00721566f, -0.05977626f, -0.05665874f, 0.03552796f, 
    -0.00694444f, -0.00024935f, 0.05217490f, -0.05560309f, 0.04222662f, 0.02195992f, 0.01241657f, 0.02291538f, 
    0.02135053f, -0.04305653f, 0.02029710f, -0.03537571f, -0.05382813f, -0.05453134f, -0.02784253f, 0.00134071f, 
    -0.01872332f, 0.00247934f, -0.02417304f, -0.05364601f, -0.04121256f, 0.04211840f, 0.00706882f, -0.06368904f, 
    -0.01925932f, -0.03625819f, -0.00303055f, -0.00038788f, 0.05043245f, -0.01556994f, 0.00079133f, 0.01000367f, 
    0.05279082f, -0.03741595f, -0.05430696f, -0.03181613f, 0.04148034f, -0.00955640f, 0.01459354f, -0.05621811f, 
    -0.04320654f, 0.04555225f, -0.00915131f, -0.03665904f, -0.04102014f, -0.04538418f, 0.03181617f, -0.02463081f, 
    -0.01784241f, -0.05532661f, 0.02725849f, 0.05173067f, -0.03886567f, 0.01786777f, -0.04741225f, -0.02574103f, 
    -0.03840342f, 0.03844332f, 0.01156044f, -0.01226043f, 0.02143886f, 0.02404382f, 0.00166498f, 0.03680627f, 
    0.00904466f, -0.06109706f, -0.01252874f, 0.01285445f, 0.00870840f, -0.03218656f, -0.06479413f, 0.00014474f, 
    -0.01594771f, 0.03808542f, 0.03559883f, -0.03053278f, 0.04319819f, 0.04401477f, -0.02776812f, -0.04515932f, 
    0.05122576f, -0.04927931f, 0.02741828f, -0.00180296f, -0.04343875f, 0.01896228f, 0.04634622f, -0.04613990f, 
    -0.05332655f, -0.05661980f, 0.00946672f, -0.00565404f, 0.04823705f, 0.00535163f, -0.06200213f, -0.00384997f, 
    0.01075870f, 0.05142926f, -0.04941769f, 0.03876203f, -0.04903923f, -0.05954910f, -0.04088362f, -0.05063288f, 
    -0.03960100f, -0.04725445f, -0.02950665f, -0.02116769f, 0.02791238f, 0.01050157f, 0.04376930f, -0.06000616f, 
    0.01145057f, -0.02285433f, -0.02969247f, 0.03752900f, 0.04298186f, 0.02964356f, -0.03607455f, -0.01205954f, 
    0.03784822f, 0.00603264f, -0.02017870f, 0.01629161f, 0.02585826f, 0.01634467f, 0.03448123f, -0.05651463f, 
    -0.04064814f, 0.02681208f, -0.04996036f, 0.02446619f, 0.02116118f, -0.02505930f, -0.03666805f, -0.00041265f, 
    -0.05441575f, -0.05493549f, 0.01579342f, -0.00852690f, 0.01935384f, 0.01234905f, -0.05498870f, -0.02837682f, 
    -0.03782442f, 0.02460213f, 0.00402841f, -0.02889777f, 0.02114518f, -0.01798050f, 0.02508641f, -0.02280619f, 
    -0.05798539f, 0.00911203f, 0.01220145f, 0.03740823f, 0.03917308f, -0.06104653f, 0.02681784f, -0.03481025f, 
    -0.00557456f, -0.01955505f, 0.03785485f, 0.01868271f, 0.02687584f, 0.04434286f, -0.01856750f, -0.05573857f, 
    0.03490666f, -0.04911095f, -0.06235499f, 0.01818182f, 0.05024705f, -0.00987980f, -0.02956506f, 0.02919152f, 
    0.02578302f, 0.00181049f, 0.03063235f, 0.02874338f, -0.02477374f, -0.05044273f, 0.02089196f, 0.04291938f, 
    -0.02883844f, -0.05255691f, -0.00893502f, -0.03068429f, 0.00256234f, 0.05175542f, 0.01566854f, 0.05516502f, 
    0.02126977f, -0.05520402f, 0.02327978f, -0.05133341f, -0.03839340f, -0.06722997f, 0.03437398f, 0.05026286f, 
    0.03757180f, -0.05042674f, -0.03685883f, 0.02646939f, 0.00875573f, 0.01876200f, -0.02251457f, 0.01238620f, 
    0.01096449f, 0.01282342f, 0.04186703f, -0.04231691f, 0.00458331f, 0.00619500f, 0.03739373f, -0.05458813f, 
    0.03801193f, -0.05386692f, 0.05020791f, -0.02333074f, 0.02943466f, -0.02295566f, 0.03679708f, -0.00408701f, 
    -0.02548258f, 0.00517809f, -0.00338348f, 0.00502446f, 0.01276927f, 0.04933703f, -0.04587689f, -0.01729364f, 
    0.05137078f, -0.05254936f, -0.06494549f, -0.04095244f, 0.05181817f, 0.01568543f, 0.05104337f, 0.04358609f, 
    -0.02991028f, -0.03788775f, 0.04440799f, 0.02238619f, 0.04087440f, -0.03987090f, -0.06277165f, 0.01367724f, 
    0.03665458f, -0.03120460f, 0.04868247f, 0.03490176f, -0.05675403f, -0.05355727f, -0.01824031f, -0.00407385f, 
    -0.05248743f, 0.04639271f, -0.00518665f, 0.01205840f, -0.01718793f, 0.02558210f, 0.04717441f, 0.03409725f, 
    0.03017522f, 0.02411506f, -0.03864875f, -0.01616750f, -0.05839754f, 0.03043263f, -0.01698731f, -0.00690481f, 
    0.01590850f, -0.04308686f, 0.01721347f, 0.01301081f, -0.05437973f, -0.02621445f, -0.04610539f, -0.02337543f, 
    -0.03725228f, -0.04098945f, -0.00617231f, 0.01537752f, -0.06511813f, 0.00107777f, -0.06022390f, -0.01210316f, 
    0.01073654f, 0.00946894f, -0.00211556f, -0.05101179f, -0.01434433f, 0.02842467f, 0.00176656f, -0.02418600f, 
    0.03027375f, -0.03674863f, -0.03632184f, 0.02340988f, -0.06216999f, 0.01226489f, -0.03696639f, -0.02346133f, 
    -0.04226481f, -0.05437653f, 0.03406771f, -0.00521009f, -0.06063736f, -0.06606196f, 0.02441479f, -0.02166852f, 
    -0.02148018f, -0.06101844f, -0.05640404f, -0.04216794f, -0.03968270f, 0.01023895f, -0.00882265f, -0.01744143f, 
    0.04195382f, 0.04206738f, 0.04480635f, 0.01597668f, -0.01698847f, 0.04977598f, -0.04957928f, -0.02448298f, 
    0.02918500f, 0.03586454f, -0.05707604f, 0.02097858f, 0.01926097f, 0.04297842f, 0.02983517f, -0.01517037f, 
    0.05176830f, 0.04755242f, 0.00841329f, -0.04623783f, -0.01437437f, 0.00378164f, 0.00996291f, 0.03338191f, 
    0.04627895f, -0.00944875f, -0.02709077f, -0.01858886f, -0.05702936f, -0.04631448f, 0.02270636f, -0.05718222f, 
    -0.01936138f, 0.00712094f, 0.00374956f, -0.02757515f, 0.02285846f, -0.01518550f, -0.05833288f, -0.06230984f, 
    -0.01255894f, 0.01354346f, 0.00591080f, -0.02970610f, 0.03225140f, 0.02034857f, -0.06371740f, -0.05891927f, 
    -0.06629819f, -0.00620313f, -0.02856175f, 0.00947618f, -0.04662764f, 0.03893274f, -0.01863196f, -0.01056530f, 
    0.04650637f, 0.02358331f, 0.01608219f, -0.02223324f, -0.06767242f, -0.04201535f, -0.00941781f, 0.04304853f, 
    -0.06314179f, 0.03845562f, -0.01194802f, -0.03435992f, -0.04977094f, -0.02293879f, -0.00002725f, -0.03037855f, 
    0.01932848f, -0.06127917f, 0.03466589f, -0.03593346f, 0.00494796f, 0.00203562f, -0.04688166f, -0.06256467f, 
    0.03919180f, -0.05899795f, 0.05068308f, 0.00531507f, -0.01080546f, 0.00203437f, -0.05860133f, 0.03970325f, 
    -0.03957333f, -0.02135472f, 0.27830267f, -0.30790922f, -0.10793199f, 0.05082571f, 0.10405599f, 0.12667257f, 
    0.08283016f, -0.29402733f, 0.22057150f, 0.30567557f, 0.00965872f, -0.09789810f, -0.20073098f, 0.05897403f, 
    -0.02553725f, 0.11557540f, 0.05108948f, -0.10456792f, 0.18579154f, 0.02498341f, 0.14362212f, -0.21343519f, 
    0.08689898f, 0.09445637f, 0.07748374f, -0.27087203f, -0.16053522f, 0.16795941f, -0.08953074f, 0.05531223f, 
    0.01925430f, 0.06917347f, -0.03058574f, 0.06802262f, 0.22036058f, 0.39838162f, -0.17844957f, -0.08613697f, 
    0.02105332f, -0.10793226f, 0.10378527f, -0.00292863f, -0.15891653f, -0.00139472f, 0.48618692f, -0.17864230f, 
    -0.00507268f, 0.08195319f, -0.02500284f, -0.05333003f, -0.11601656f, -0.01683558f, 0.12446038f, -0.12865308f, 
    0.46530941f, -0.17506839f, -0.10465255f, 0.02090222f, 0.12306010f, 0.04952536f, 0.08116422f, -0.14348441f, 
    -0.28665009f, 0.31070152f, 0.13755064f, -0.10289063f, -0.21064588f, -0.22256617f, 0.16480185f, -0.04207131f, 
    0.02243562f, -0.04580485f, -0.02215436f, -0.00568015f, 0.07113253f, 0.07574271f, -0.13536125f, -0.03693892f, 
    0.02940760f, -0.10309954f, 0.06201570f, 0.01131731f, 0.04018242f, -0.37783021f, 0.08197349f, 0.24028294f, 
    -0.03308517f, 0.06971213f, 0.18906905f, 0.22893846f, 0.09473205f, -0.06059638f, 0.10443462f, 0.03216679f, 
    0.03565696f, 0.11375330f, -0.14086160f, -0.25385532f, -0.31242043f, 0.46683079f, -0.16756389f, -0.26076165f, 
    -0.18096414f, 0.03907099f, 0.15152736f, 0.10869141f, 0.21164665f, 0.02826684f, -0.16867775f, -0.12631600f, 
    -0.15610668f, -0.05599134f, -0.04774929f, -0.05822917f, 0.03038762f, 0.36807668f, -0.15772636f, 0.28722289f, 
    -0.07881261f, -0.22874258f, -0.03443884f, 0.09243062f, -0.07095925f, -0.09100579f, 0.07614754f, -0.23955904f, 
    -0.12257043f, 0.12176239f, -0.10992347f, 0.08973283f, 0.00253153f, -0.00255273f, 0.07194257f, -0.18245590f, 
    0.31584117f, -0.14906277f, 0.09226894f, 0.11012140f, 0.14060925f, -0.13258070f, -0.04812845f, -0.04255881f, 
    -0.20924465f, 0.30677199f, -0.09586737f, 0.26280236f, 0.05356047f, 0.08810262f, -0.06879862f, 0.12447958f, 
    -0.25646931f, 0.09025913f, 0.09502962f, -0.24312109f, -0.01988952f, 0.11336242f, -0.03815040f, -0.00312532f, 
    -0.06282655f, -0.21432117f, -0.23690017f, -0.00422716f, 0.05946214f, -0.09788760f, 0.06472924f, -0.10705048f, 
    0.10004503f, 0.00206447f, -0.12391344f, -0.13535966f, 0.04968444f, 0.01280596f, 0.05468464f, 0.13907672f, 
    0.10024757f, -0.02089510f, -0.11498229f, 0.11962377f, -0.17383602f, 0.08091327f, -0.12846221f, 0.32518980f, 
    0.09632873f, -0.18314122f, 0.08277894f, -0.01096211f, 0.00734865f, 0.40749174f, 0.10164431f, 0.15643698f, 
    -0.03352734f, 0.11438183f, 0.05191556f, -0.10263225f, -0.02872327f, 0.18256356f, -0.10487128f, -0.09697276f, 
    -0.56995118f, 0.09602584f, 0.10786285f, 0.09418051f, -0.09936300f, -0.13969742f, 0.33438101f, -0.03339708f, 
    -0.07295761f, -0.10871382f, -0.05730223f, -0.01395569f, 0.04617333f, 0.13958617f, 0.08312768f, -0.07911883f, 
    -0.18321118f, -0.14224784f, 0.22789536f, 0.18643637f, -0.12789243f, 0.02639065f, 0.25088325f, 0.00893532f, 
    0.07611309f, -0.16236447f, 0.01533930f, 0.18052223f, -0.31448886f, -0.03469276f, 0.17682891f, 0.01009396f, 
    -0.07598890f, 0.16334848f, 0.08521165f, 0.16867241f, 0.22515017f, -0.08243993f, 0.17699392f, 0.13075605f, 
    0.13913982f, -0.13471653f, -0.13902418f, -0.20619081f, 0.16586533f, -0.01683449f, 0.14824347f, 0.04956857f, 
    -0.05557070f, 0.00101871f, 0.09127277f, -0.18049608f, -0.06546869f, 0.31859604f, -0.23421417f, -0.17918301f, 
    0.01768184f, 0.00683929f, -0.16161418f, 0.06548067f, 0.02272146f, -0.14439641f, -0.07532773f, -0.19185194f, 
    -0.05602448f, 0.30533415f, 0.18611124f, 0.25137529f, -0.11990964f, -0.16169509f, -0.21100943f, -0.29389170f, 
    0.38913864f, -0.17758821f, 0.04387382f, -0.05481081f, -0.06636947f, 0.01289243f, 0.12092929f, -0.18564992f, 
    0.00074087f, -0.10906927f, 0.10746819f, 0.07932624f, -0.20478489f, -0.06836544f, 0.16001919f, -0.12774225f, 
    -0.02048239f, 0.05885681f, -0.01492109f, -0.01690320f, 0.03809609f, 0.01432282f, 0.05219223f, -0.03643806f, 
    -0.01409274f, -0.00579091f, -0.05705373f, 0.02207577f, -0.03332508f, 0.01726300f, -0.01294340f, -0.01014324f, 
    -0.01045350f, -0.03308776f, -0.03261766f, 0.03621062f, -0.00875703f, -0.04522761f, 0.03925137f, -0.01158008f, 
    -0.02450192f, -0.05579038f, -0.04647477f, -0.00446119f, 0.03058063f, -0.01462935f, -0.04732095f, -0.02171567f, 
    -0.00854803f, -0.01366431f, 0.02450300f, -0.04419601f, -0.03703661f, 0.01193893f, -0.03419456f, 0.00044604f, 
    0.03313892f, -0.02964973f, 0.00662840f, 0.04343004f, -0.00405328f, -0.02677924f, -0.02486177f, 0.04631806f, 
    0.04793651f, -0.01318172f, -0.05761444f, -0.05880692f, -0.00685009f, 0.04391871f, -0.05680126f, 0.00057788f, 
    -0.01185721f, -0.05728268f, -0.05371667f, 0.00122732f, -0.02901747f, 0.02323244f, -0.01773299f, 0.05878076f, 
    -0.03449557f, -0.01147797f, -0.02131877f, -0.00780356f, 0.03278522f, 0.03117966f, -0.03368394f, -0.02364927f, 
    -0.01192510f, -0.05514538f, -0.00848288f, -0.03330594f, -0.04736672f, -0.04646929f, -0.02741039f, 0.01416332f, 
    0.04991873f, -0.05497224f, 0.01611538f, 0.04924186f, -0.01818027f, -0.02576778f, 0.00018769f, -0.00111093f, 
    0.00992872f, 0.00161059f, -0.04356739f, 0.01118575f, 0.04480418f, 0.04067685f, -0.02943165f, -0.00167348f, 
    -0.05648887f, 0.04470828f, -0.00046259f, -0.00847871f, -0.05849959f, -0.00483969f, -0.00189171f, -0.01407162f, 
    0.00762482f, -0.01708370f, -0.01527169f, -0.04091764f, 0.03103721f, 0.04220439f, -0.03930781f, 0.00094533f, 
    0.04672145f, -0.01129271f, 0.03141335f, -0.00891633f, 0.04017435f, 0.04927807f, 0.02737008f, 0.00351867f, 
    -0.03515001f, 0.01000115f, -0.05776189f, -0.01606978f, -0.01502805f, -0.04286749f, 0.00010278f, -0.02149026f, 
    0.04702075f, 0.04386816f, 0.00124297f, -0.04916594f, -0.03073619f, -0.02928951f, -0.00722317f, -0.01812925f, 
    0.04911254f, -0.02625483f, -0.05410138f, 0.02243725f, -0.04426565f, -0.03982395f, -0.01402573f, 0.01857566f, 
    -0.01762001f, -0.01690912f, 0.02741711f, -0.05093200f, -0.00167844f, -0.04212599f, 0.03424616f, -0.00312700f, 
    -0.04513087f, 0.05653946f, -0.05834756f, -0.01801486f, -0.04719381f, -0.01243910f, 0.01872977f, -0.00621426f, 
    -0.04937893f, 0.00767735f, 0.03762984f, 0.00957449f, -0.00177224f, -0.03989819f, -0.04850387f, 0.05156955f, 
    -0.04457624f, -0.02596741f, -0.01362750f, -0.00823030f, 0.04237051f, -0.05069023f, 0.01352961f, 0.01531789f, 
    0.03434379f, 0.02490230f, 0.00204022f, -0.02825937f, -0.02249906f, -0.01102064f, 0.04795174f, -0.01608638f, 
    0.05562138f, -0.05471542f, -0.04309739f, 0.01476800f, 0.04906827f, 0.00657638f, -0.05089770f, 0.02227665f, 
    -0.04430701f, 0.00038810f, -0.00955109f, 0.04120970f, 0.01097349f, 0.01926927f, -0.01701413f, -0.04609196f, 
    -0.05379246f, -0.03543968f, 0.02630617f, 0.04756454f, 0.00893822f, 0.05198748f, 0.02823927f, -0.05446027f, 
    0.01280352f, 0.01743137f, -0.02471977f, -0.04471892f, 0.05053402f, -0.04948047f, -0.02909527f, 0.02336762f, 
    0.01598242f, -0.01226541f, -0.04125119f, -0.02822997f, 0.01556561f, 0.02360337f, -0.00802537f, -0.02280771f, 
    -0.05843568f, 0.01833221f, -0.04325643f, -0.03955825f, -0.03663798f, -0.03277144f, -0.04709838f, 0.05382080f, 
    0.05616681f, 0.01212263f, -0.02130309f, -0.05494082f, -0.03177282f, -0.02038896f, 0.05257489f, -0.03684168f, 
    0.05128150f, 0.05149468f, 0.00766253f, -0.01266212f, -0.03913185f, -0.00807820f, -0.00790933f, -0.05400378f, 
    0.05389251f, 0.00607468f, -0.02894949f, -0.00804296f, -0.01075772f, 0.00487788f, 0.00769415f, 0.00518670f, 
    0.03549253f, -0.00804935f, 0.05518262f, 0.04102498f, 0.04461998f, -0.02843713f, -0.02426018f, 0.05862981f, 
    -0.05037927f, -0.05781667f, -0.01676632f, -0.00752174f, -0.04250808f, 0.03583591f, 0.01904378f, 0.05824183f, 
    0.00548119f, -0.04986807f, -0.04486590f, -0.03391004f, 0.02615382f, 0.02138112f, -0.05752656f, 0.00476703f, 
    -0.04695766f, 0.02268819f, 0.01449576f, 0.05752782f, -0.03460201f, -0.05130192f, -0.00158715f, 0.04424458f, 
    0.05794360f, 0.04394144f, 0.30098003f, -0.07310881f, 0.22200739f, -0.02861997f, 0.03586323f, 0.09071051f, 
    0.01701717f, 0.66796809f, 0.19681337f, 0.29574108f, -0.36582506f, 0.16672307f, -0.03379757f, -0.25103837f, 
    0.27956861f, -0.09194013f, -0.10923573f, -0.42338848f, -0.29514620f, -0.03563092f, -0.08626723f, 0.00552173f, 
    0.05447135f, -0.28756100f, -0.03183897f, 0.41748443f, -0.25648558f, 0.25492194f, -0.02358294f, 0.15159121f, 
    -0.00926930f, 0.03225714f, 0.06100699f, -0.06003179f, 0.18757202f, -0.11220101f, 0.03485829f, 0.02321992f, 
    0.12878397f, 0.05072983f, -0.12404892f, 0.09301380f, -0.17644347f, 0.35645014f, -0.53300440f, 0.19012693f, 
    -0.12855577f, -0.09295603f, -0.04215127f, -0.16578180f, 0.04335076f, -0.14852916f, 0.29069924f, -0.27506265f, 
    0.24528965f, 0.13656822f, 0.04198582f, -0.06022632f, -0.03846452f, 0.00958052f, -0.01128493f, 0.13138899f, 
    0.10338570f, 0.26900563f, 0.03046198f, -0.03338322f, 0.08877917f, 0.08325423f, -0.20331278f, -0.04856345f, 
    0.03350787f, -0.36999208f, -0.05221121f, 0.01370823f, 0.02327296f, 0.15749127f, -0.12954733f, -0.06245777f, 
    -0.17842156f, -0.28513694f, 0.34875676f, 0.52790314f, 0.02736454f, -0.04246842f, 0.11066882f, -0.17603247f, 
    0.18258367f, 0.15395044f, -0.28381401f, 0.34989244f, -0.12315222f, 0.10131740f, 0.02199616f, 0.06820415f, 
    0.16110231f, 0.09370920f, -0.04834852f, -0.18719722f, 0.00762161f, 0.47291926f, 0.01704195f, -0.01791830f, 
    0.17291114f, 0.00983064f, -0.09287320f, 0.16955902f, 0.03477047f, 0.16404873f, 0.11029344f, -0.39077652f, 
    0.01812897f, 0.11663830f, -0.02898145f, 0.01344902f, 0.06025790f, 0.07977311f, -0.17597666f, 0.18895286f, 
    -0.12540454f, 0.06683808f, 0.04244206f, 0.24773547f, -0.27230352f, 0.21375820f, 0.06393130f, 0.05424575f, 
    -0.32097712f, 0.09213286f, -0.20092846f, 0.15452921f, -0.18395585f, -0.00075346f, -0.01283330f, -0.12996936f, 
    -0.15574336f, 0.08360565f, 0.02151783f, 0.05708171f, 0.01801444f, 0.01172341f, -0.09555704f, 0.26265237f, 
    0.01292339f, 0.05170712f, 0.09525326f, -0.16273178f, 0.10419833f, 0.00698287f, -0.03765338f, 0.01057631f, 
    -0.04585930f, 0.19406946f, 0.27914679f, -0.38269141f, 0.03515474f, -0.10737009f, -0.05949053f, -0.30528602f, 
    -0.02436591f, -0.00946076f, -0.26230508f, 0.07746025f, -0.29561204f, -0.02059926f, -0.05305613f, -0.09311312f, 
    -0.23474960f, -0.01246695f, 0.26356056f, 0.03711068f, 0.04977318f, 0.29795352f, -0.00074137f, 0.08156633f, 
    0.04496032f, -0.01857416f, -0.17089511f, -0.07090811f, -0.11380237f, 0.04431764f, -0.20884830f, -0.02382007f, 
    0.09154537f, -0.38986987f, -0.01488394f, 0.00909660f, -0.06803105f, -0.17042282f, -0.03599628f, -0.24773060f, 
    -0.18728383f, -0.09377452f, -0.02470176f, -0.14682753f, 0.00396309f, 0.08939881f, 0.23433845f, 0.07821639f, 
    -0.11381090f, 0.04733575f, -0.19275454f, 0.24751039f, 0.16857038f, 0.04076776f, -0.31878313f, 0.40026274f, 
    0.01143355f, 0.04022738f, -0.00867726f, -0.17538711f, -0.04998482f, 0.00653143f, 0.21808220f, -0.10739731f, 
    -0.07553844f, -0.00171319f, -0.11744357f, -0.17130768f, 0.02906500f, 0.13716236f, -0.16260886f, -0.00185694f, 
    0.04469571f, 0.08139852f, 0.09296437f, 0.26281518f, -0.27548650f, 0.17847897f, -0.17682710f, -0.08346614f, 
    0.08424675f, 0.08197666f, 0.43874967f, -0.06739709f, 0.51075792f, -0.24859379f, 0.06052079f, 0.01498205f, 
    -0.01105197f, -0.30164748f, 0.07671136f, 0.11258487f, 0.09010855f, -0.21988043f, -0.10336191f, -0.01616214f, 
    -0.17664053f, -0.30134469f, 0.09425747f, 0.00328221f, -0.22476156f, 0.17118062f, 0.07117498f, 0.15760738f, 
    0.12538588f, -0.10818575f, -0.11291966f, 0.02368858f, -0.00011314f, 0.08471013f, 0.32905516f, -0.10208616f, 
    0.18528448f, -0.03440479f, -0.21709614f, -0.04091448f, 0.17711125f, -0.00834307f, -0.13285327f, -0.07882775f, 
    0.23716967f, 0.07170536f, 0.07827072f, -0.02981311f, -0.06855201f, -0.02937305f, 0.17415880f, -0.14366999f, 
    -0.07898135f, -0.29072675f, -0.07364420f, -0.20447564f, -0.24212673f, 0.04587121f, 0.02919917f, 0.07840636f, 
    0.03209857f, -0.10589246f, 0.00928101f, 0.11610380f, 0.29548472f, -0.08665631f, -0.15841642f, -0.12530120f, 
    -0.03425644f, 0.31451312f, -0.07914732f, -0.05912925f, -0.00287762f, -0.26164901f, 0.08659683f, 0.26716378f, 
    0.29834995f, 0.33562049f, -0.38271895f, -0.15494654f, -0.20218420f, 0.21707006f, 0.10132661f, -0.25200012f, 
    -0.08661550f, 0.06088464f, -0.10541709f, 0.25855204f, 0.09164589f, -0.04967406f, -0.06454140f, 0.13569334f, 
    -0.13422248f, -0.17736132f, 0.01052926f, -0.02182049f, -0.05062024f, 0.12692340f, 0.20015219f, -0.07333600f, 
    0.03873184f, 0.02384481f, -0.10105760f, 0.00719928f, -0.17458095f, 0.47506338f, 0.06860249f, 0.25743920f, 
    -0.11795782f, -0.13973202f, 0.41427141f, -0.03034794f, 0.02422942f, 0.15767880f, 0.12525570f, -0.12929872f, 
    0.13910347f, 0.08957183f, -0.04839651f, 0.03080095f, 0.03113686f, -0.18982381f, -0.01485955f, -0.17359208f, 
    -0.15609938f, -0.07397726f, -0.06061807f, -0.14920558f, -0.11835875f, 0.16300523f, 0.07506438f, 0.10954925f, 
    0.17334449f, 0.11542148f, -0.24626353f, -0.16845688f, -0.09671316f, 0.07710864f, 0.12863716f, -0.02728541f, 
    -0.34855542f, 0.19444588f, 0.32291108f, 0.10630691f, -0.20355716f, -0.06885620f, 0.00570151f, -0.26811251f, 
    0.16255599f, 0.23674691f, 0.05677563f, -0.03082399f, 0.57207125f, 0.05950127f, 0.03479239f, -0.05265266f, 
    0.04625836f, -0.00482122f, -0.11914144f, 0.00624539f, 0.02477600f, 0.18734318f, -0.20938179f, -0.16708082f, 
    0.11720464f, 0.13903296f, 0.15675740f, 0.09695572f, 0.00181221f, -0.06147211f, -0.04855805f, 0.22525848f, 
    -0.01778992f, 0.14555974f, -0.01239503f, -0.04741329f, -0.06655605f, -0.39203683f, -0.07183435f, -0.08819617f, 
    0.02333594f, -0.10978234f, -0.10334998f, -0.10708101f, -0.02782473f, -0.03305708f, -0.22523446f, -0.31982374f, 
    0.09537219f, 0.14270467f, 0.04053910f, 0.09482858f, 0.21891391f, -0.05795989f, 0.02830233f, 0.46230629f, 
    -0.07961611f, 0.42765859f, 0.09182398f, -0.14380869f, 0.17773312f, -0.02513778f, 0.15128271f, -0.19330379f, 
    0.12247929f, -0.09195925f, 0.21196677f, -0.06105383f, 0.07607155f, -0.01710406f, -0.03836601f, -0.11319666f, 
    -0.00893178f, -0.05146155f, -0.38613844f, -0.32188809f, 0.05363773f, 0.02090449f, 0.21912882f, -0.22482166f, 
    0.05563464f, -0.18814769f, 0.07883746f, 0.13831384f, 0.06507087f, 0.04877026f, -0.03816858f, 0.17029202f, 
    0.19825251f, -0.07255848f, 0.07503917f, -0.19232507f, -0.11072119f, 0.01594229f, -0.11763455f, -0.05938912f, 
    0.25169557f, 0.22971793f, 0.11305807f, -0.09722649f, -0.08066072f, -0.00403198f, 0.11195152f, 0.35557684f, 
    0.01558178f, -0.01636226f, 0.13745686f, -0.26153842f, 0.05778816f, 0.16642816f, -0.30842525f, 0.18322150f, 
    -0.05296398f, -0.03144258f, -0.03109967f, -0.19789396f, 0.04458441f, -0.01041461f, 0.23855039f, 0.07548358f, 
    0.23763780f, -0.16143765f, -0.09421135f, 0.20244268f, 0.00946296f, 0.12292916f, 0.06125315f, 0.08860750f, 
    0.28211737f, -0.10553753f, -0.18397382f, 0.11592180f, 0.21703607f, 0.19011781f, -0.00312354f, 0.27444011f, 
    -0.40822744f, -0.03635767f, -0.37108842f, -0.00747057f, 0.17515267f, -0.23547722f, -0.03133364f, -0.20172168f, 
    -0.24853969f, -0.55122727f, 0.09075814f, -0.01949808f, 0.07021624f, -0.00247430f, 0.13759577f, -0.00145342f, 
    -0.01233560f, -0.19884899f, -0.04787122f, -0.40246749f, 0.07751337f, 0.00185260f, 0.00077072f, -0.07389797f, 
    -0.16590510f, -0.01691323f, -0.06092709f, 0.06463697f, -0.08540497f, 0.04238495f, 0.07184589f, 0.00190162f, 
    -0.11075813f, 0.01949363f, -0.02547429f, -0.05550926f, 0.09681616f, -0.21001112f, 0.08038411f, -0.07676601f, 
    -0.03924589f, -0.05376130f, -0.17035976f, -0.07997555f, 0.06411605f, -0.22904743f, -0.39784917f, -0.16311689f, 
    -0.07679308f, 0.07153451f, 0.23874390f, 0.09850989f, -0.28947175f, 0.12493389f, 0.17630805f, -0.03275367f, 
    -0.05483701f, 0.04231932f, 0.18172897f, -0.07194283f, 0.02316236f, 0.19792150f, 0.13562313f, 0.22324342f, 
    -0.12987369f, 0.18181475f, 0.11594379f, -0.15645459f, -0.05426326f, 0.02598868f, -0.00307080f, 0.01307243f, 
    0.19570668f, 0.11416920f, 0.06429616f, 0.08026010f, 0.01464684f, 0.09044267f, 0.10281090f, 0.17473426f, 
    0.02700853f, 0.02291816f, -0.06337385f, 0.13579077f, -0.00761622f, -0.08708505f, -0.03025771f, -0.19511122f, 
    0.18093106f, 0.14778051f, 0.21101820f, 0.11702091f, -0.13801894f, 0.12724780f, 0.08294380f, 0.01204414f, 
    -0.07230390f, 0.20412087f, 0.35843155f, -0.08943432f, -0.27023295f, 0.14609046f, 0.21662842f, 0.18577181f, 
    -0.19716945f, -0.15797666f, 0.02173540f, 0.15530029f, -0.27682024f, -0.25558960f, 0.16608417f, 0.38866770f, 
    -0.03144188f, 0.15192501f, -0.03567453f, -0.02403108f, 0.00668806f, -0.18387583f, 0.41016659f, -0.09903162f, 
    0.10499848f, -0.10719597f, -0.03542585f, 0.05796865f, -0.03729450f, 0.06102375f, 0.03012031f, -0.04041906f, 
    -0.15514661f, 0.16487433f, 0.24248409f, 0.08017805f, 0.08100470f, 0.22791986f, -0.10932673f, 0.17506978f, 
    0.05592994f, 0.23488280f, 0.02770014f, 0.01651380f, -0.01507983f, -0.25336212f, -0.00765218f, 0.05905822f, 
    -0.07028816f, 0.26991504f, -0.13412806f, 0.09778246f, -0.19904476f, -0.02961824f, -0.34940600f, -0.03042311f, 
    -0.06477918f, 0.17669185f, 0.27339917f, -0.27266216f, -0.04138939f, 0.03644236f, -0.02215435f, 0.04863188f, 
    0.11519352f, -0.34122911f, -0.24556425f, -0.34389764f, -0.51629084f, -0.02649596f, 0.02714371f, 0.16500047f, 
    -0.07689027f, 0.21539991f, -0.02562790f, 0.09511737f, 0.06534445f, 0.15209137f, -0.01276783f, -0.10884894f, 
    -0.01383872f, 0.00501983f, 0.08293200f, -0.03195488f, -0.59631723f, -0.37642786f, -0.12259152f, 0.02846717f, 
    0.04718684f, -0.01220570f, -0.03244596f, -0.34324703f, -0.16463320f, 0.25554809f, 0.07604582f, -0.33922145f, 
    0.02533652f, 0.24400681f, -0.13473146f, 0.05566258f, 0.06766744f, 0.08036361f, -0.46668267f, -0.42340484f, 
    -0.25538749f, 0.15165180f, 0.06028960f, 0.10883737f, 0.23497677f, 0.06619509f, 0.32786193f, -0.80877650f, 
    -0.34913021f, 0.03293039f, -0.03537130f, 0.17186296f, -0.08482660f, -0.06401766f, -0.17489167f, 0.03477778f, 
    -0.72632021f, -0.30461341f, -0.00395935f, 0.20328452f, 0.02789951f, -0.17244934f, 0.06730784f, -0.03472511f, 
    0.03873542f, -0.48534024f, -0.42544472f, 0.18920773f, 0.12073710f, 0.23647390f, 0.19335715f, -0.13907310f, 
    0.04591454f, 0.21333921f, -0.53463465f, -0.30405253f, -0.11721725f, 0.02255811f, -0.04902303f, 0.03452185f, 
    -0.11024655f, 0.00109110f, 0.02342924f, -0.59648514f, -0.39724246f, -0.01076162f, 0.10242202f, -0.00402396f, 
    0.05067097f, -0.03397943f, 0.13162667f, 0.16343480f, 0.36485302f, 0.21180566f, -0.13451901f, 0.07201930f, 
    -0.19359973f, 0.11214940f, -0.30684027f, 0.11474728f, 0.04714044f, -0.17594303f, -0.09088156f, 0.28032008f, 
    0.18357503f, 0.11583579f, 0.22150542f, 0.05620378f, 0.01550474f, -0.00490696f, -0.31459773f, -0.52496397f, 
    -0.25005573f, 0.12325204f, 0.21595608f, -0.41792339f, -0.00147714f, -0.20445016f, -0.00393528f, -1.04783547f, 
    -0.37164384f, 0.24735855f, 0.18233868f, 0.13912974f, 0.17882799f, -0.05873794f, -0.06336827f, 0.03548709f, 
    -0.18356895f, -0.51931643f, 0.10531912f, -0.11388583f, -0.00241771f, -0.27324569f, 0.01080301f, 0.22692758f, 
    0.18111779f, 0.26874387f, -0.11267532f, 0.00071920f, -0.02872896f, -0.12285785f, 0.02143578f, 0.28487441f, 
    0.14400114f, -0.01420824f, 0.18647400f, -0.01186578f, -0.01529489f, 0.19733427f, 0.12349682f, -0.14198619f, 
    -0.06313248f, 0.08064560f, 0.23390442f, 0.19714934f, 0.19081208f, 0.12287485f, 0.17082466f, 0.03130913f, 
    -0.11087608f, -0.04511026f, 0.09130406f, -0.03492099f, -0.33939314f, -0.20684843f, -0.39529064f, 0.11366075f, 
    -0.16006447f, -0.08883212f, -0.05289868f, 0.02840383f, 0.03292837f, -0.29671356f, -0.01106885f, 0.17629957f, 
    0.02443921f, 0.08958013f, 0.02187840f, 0.08106463f, -0.12299500f, -0.08455808f, 0.15167500f, 0.10201915f, 
    0.20246316f, -0.05445025f, -0.02977232f, 0.05375033f, -0.08742291f, 0.25388169f, -0.14970018f, 0.46983269f, 
    0.21084014f, 0.43917900f, 0.16031444f, 0.03995201f, 0.18494417f, -0.11233221f, -0.01577847f, -0.11300508f, 
    0.26648137f, 0.10423397f, -0.00599296f, -0.06229465f, -0.09796861f, -0.14887697f, 0.21952879f, 0.20070334f, 
    0.12816975f, 0.30347046f, 0.19924515f, 0.10933250f, 0.13720238f, 0.03486128f, 0.01619233f, -0.23923890f, 
    -0.16626598f, -0.10668302f, 0.07170394f, -0.21660620f, 0.05803158f, 0.06867637f, 0.23655662f, -0.07823292f, 
    0.14771904f, 0.11671036f, 0.14716743f, 0.06909417f, 0.27102318f, 0.06274943f, -0.26163661f, -0.14652090f, 
    -0.03189076f, -0.03818888f, 0.07181204f, 0.20265283f, 0.16650446f, 0.02179290f, -0.05488961f, 0.09819544f, 
    0.00619652f, -0.08248638f, -0.08846533f, -0.04113611f, -0.09413586f, -0.22818716f, 0.20012274f, 0.00501666f, 
    0.18090878f, 0.04032874f, -0.11278019f, -0.18835223f, 0.10449796f, 0.07080989f, 0.06873962f, 0.14743908f, 
    0.03878755f, 0.28295803f, 0.08735767f, -0.06608006f, -0.09802237f, 0.12505537f, 0.15516862f, 0.05784665f, 
    0.32138875f, 0.10467121f, 0.00323855f, -0.05568774f, 0.17883030f, -0.07366712f, 0.01448101f, -0.10417018f, 
    -0.17761590f, 0.22898464f, 0.18143493f, 0.06076599f, 0.11916025f, -0.04636313f, -0.06029324f, 0.01708764f, 
    0.03723213f, 0.12822859f, 0.25395787f, 0.16485819f, 0.14525475f, 0.18195926f, -0.03112678f, 0.04256318f, 
    0.12890449f, -0.21844371f, -0.13134639f, -0.50877857f, -0.27068046f, -0.05742747f, -0.16704780f, 0.19220905f, 
    -0.16475533f, 0.05189861f, -0.37301859f, 0.24201182f, 0.25280407f, 0.13082144f, 0.01113721f, 0.23349112f, 
    0.02270845f, 0.19940729f, -0.01412015f, -0.13226819f, -0.03869452f, 0.01868115f, 0.05056908f, -0.19499174f, 
    -0.09313631f, -0.09829984f, 0.07334916f, -0.04060068f, 0.31910747f, -0.26144662f, -0.36144820f, -0.03894089f, 
    0.05190698f, 0.22608638f, 0.02395453f, 0.29630664f, 0.12250870f, 0.05353384f, -0.06387168f, 0.02514745f, 
    -0.07982840f, 0.03497152f, -0.16514869f, 0.00613693f, 0.05980232f, 0.05432318f, 0.12043589f, -0.32720771f, 
    -0.25304109f, 0.01055094f, 0.11145528f, 0.02851191f, 0.27406499f, -0.07069828f, -0.03569498f, 0.11575183f, 
    0.10437469f, -0.18073268f, 0.45460290f, -0.26966006f, -0.08596665f, -0.06104214f, 0.13602276f, -0.34711522f, 
    -0.03547937f, 0.01134367f, -0.01840845f, 0.00558985f, -0.16158248f, 0.42772919f, -0.01937146f, -0.28703862f, 
    0.00370453f, -0.06937091f, -0.13422391f, -0.62066221f, 0.09673023f, 0.20483635f, 0.22148719f, -0.02402711f, 
    -0.27632377f, -0.08061665f, 0.16607116f, -0.26361638f, -0.20152199f, -0.08152976f, -0.06763766f, -0.21104890f, 
    -0.04407260f, 0.12443922f, 0.14217597f, 0.20089312f, -0.06319557f, -0.07338820f, -0.03742634f, -0.10143005f, 
    -0.19585150f, 0.30691284f, -0.04759843f, 0.01727964f, -0.18793778f, 0.32807782f, -0.16774015f, -0.14751467f, 
    -0.16583057f, 0.03848296f, -0.06462982f, -0.11801197f, 0.01583137f, -0.11647956f, 0.17677169f, -0.08559632f, 
    0.17445566f, 0.28452760f, 0.23440100f, 0.17216006f, -0.06977496f, -0.13217402f, -0.08153527f, -0.25984231f, 
    -0.10042351f, 0.02304352f, 0.02235613f, 0.07067477f, 0.08196577f, -0.08188954f, -0.10682109f, 0.09896816f, 
    -0.06367341f, -0.19879638f, 0.07624161f, 0.08719175f, -0.00008721f, -0.04786272f, -0.03991001f, 0.10322936f, 
    0.11865230f, 0.01685879f, -0.33941969f, 0.13749184f, -0.02139034f, -0.07713016f, -0.12993939f, 0.14260654f, 
    -0.07834312f, 0.11611199f, 0.05892184f, 0.34787837f, -0.03211731f, 0.09035166f, 0.19878855f, -0.07044308f, 
    0.02710240f, -0.03789851f, -0.17514212f, 0.26927140f, -0.06224424f, 0.35520834f, -0.07449181f, -0.10179825f, 
    -0.06037363f, -0.17834954f, -0.11146063f, 0.02248078f, 0.12278643f, -0.03394720f, -0.28547344f, -0.26289871f, 
    -0.17209761f, 0.08226053f, -0.02597796f, -0.03439194f, -0.13206273f, -0.25756407f, 0.08891155f, 0.24915677f, 
    -0.05811127f, 0.08529703f, 0.01735132f, -0.04769198f, -0.08576520f, 0.07787410f, 0.38622087f, 0.24764165f, 
    0.04719794f, -0.06931225f, 0.08800272f, -0.00287638f, -0.06088576f, 0.16732980f, 0.04706144f, 0.08812065f, 
    -0.25568330f, 0.04300614f, -0.07098985f, -0.16306947f, 0.06890372f, -0.16371073f, 0.03756378f, -0.28312877f, 
    0.03709510f, 0.00623178f, 0.02101185f, -0.01222613f, -0.05656551f, -0.00886019f, 0.02976683f, 0.04129519f, 
    -0.02794829f, 0.04003259f, 0.04548100f, -0.04057196f, -0.02632499f, -0.02941957f, -0.01480767f, 0.02009168f, 
    0.02326583f, -0.00754927f, 0.03278342f, 0.03620631f, -0.05808122f, 0.03966134f, 0.04002780f, -0.03101781f, 
    0.03709566f, -0.00434190f, -0.00344874f, -0.02616931f, -0.04112801f, -0.05740120f, 0.00146962f, -0.02961462f, 
    -0.02300451f, 0.00530517f, -0.03800869f, 0.03559775f, 0.03485041f, -0.01469943f, -0.00436079f, 0.04558011f, 
    -0.01956409f, 0.01244733f, 0.04893072f, 0.04642532f, -0.05456652f, -0.03968230f, -0.00154104f, 0.05256799f, 
    0.02995952f, -0.02776951f, 0.03915694f, -0.00808219f, -0.00194429f, -0.00599264f, -0.03627079f, 0.04483751f, 
    -0.03371239f, -0.01864072f, 0.02404597f, -0.03114665f, 0.05040281f, 0.04548644f, -0.02179025f, -0.04954540f, 
    -0.00739116f, -0.05120161f, -0.04308070f, -0.05080971f, -0.05215883f, -0.04765029f, -0.05259144f, 0.05568035f, 
    0.03344532f, 0.04834643f, -0.02840262f, -0.05783917f, 0.01915969f, 0.01263223f, -0.01320548f, 0.04349557f, 
    -0.05349728f, 0.02041598f, -0.02508907f, -0.01066593f, -0.05089413f, 0.01280276f, -0.01736491f, -0.05179417f, 
    -0.04752361f, 0.04336279f, -0.06056549f, -0.00821669f, -0.06121910f, -0.01925319f, -0.02428728f, 0.00216910f, 
    0.04679513f, -0.06149988f, 0.04336573f, -0.04990595f, 0.02462138f, -0.03876584f, -0.03785193f, 0.01267660f, 
    0.02858595f, 0.03704375f, -0.05217820f, -0.05219749f, -0.06223903f, -0.05664601f, 0.04772824f, -0.03261032f, 
    -0.04613573f, 0.01805841f, -0.00769326f, -0.05165471f, 0.03439873f, -0.02124744f, 0.02516476f, -0.04275461f, 
    -0.02773372f, -0.05302443f, -0.05118978f, -0.01048736f, -0.04606406f, 0.02004973f, -0.04919278f, 0.01688592f, 
    -0.00607251f, -0.01545081f, 0.05170700f, 0.00376684f, 0.02667412f, 0.03853922f, 0.00145649f, -0.05859987f, 
    0.00514583f, -0.00122900f, -0.03966698f, 0.01939731f, -0.01028727f, 0.02551279f, -0.00726986f, -0.01544981f, 
    0.01208425f, -0.01022494f, 0.04374534f, 0.02322675f, -0.05912004f, -0.03604568f, -0.05618729f, -0.06599762f, 
    -0.04387736f, 0.01963997f, -0.06029875f, 0.02615219f, 0.02076120f, 0.01510376f, 0.05601118f, 0.00732566f, 
    -0.05785813f, -0.00622675f, 0.02127038f, -0.02385133f, -0.03123796f, 0.05375392f, 0.00388711f, 0.05394882f, 
    -0.02792881f, 0.01740718f, -0.05466813f, -0.04378880f, -0.03131085f, -0.05781199f, 0.01925966f, 0.00687443f, 
    -0.00562556f, -0.03135447f, -0.04667914f, 0.02180387f, 0.00816261f, -0.00305691f, 0.03302233f, -0.06150284f, 
    -0.00655349f, -0.01650007f, -0.04265756f, 0.04821916f, -0.03002514f, 0.02819242f, 0.03692115f, 0.04095414f, 
    -0.00547275f, -0.02201635f, 0.05287882f, 0.04360603f, 0.00265712f, 0.04618112f, 0.01894946f, -0.06225587f, 
    -0.05372163f, -0.01701361f, 0.03601010f, -0.04295829f, -0.01206170f, 0.02738247f, 0.00140010f, 0.04878374f, 
    0.03625968f, -0.04931678f, -0.02735561f, 0.04924965f, 0.05056331f, -0.05629256f, -0.01360983f, -0.03631748f, 
    -0.00414512f, -0.01277616f, -0.04910526f, -0.04239151f, 0.01782987f, 0.06418123f, -0.02985593f, -0.02965336f, 
    0.00780743f, 0.05023263f, -0.02622540f, -0.02356639f, -0.05017505f, 0.01185721f, -0.03514784f, 0.01638000f, 
    -0.00627392f, -0.01854147f, -0.01317189f, 0.01674379f, -0.03803413f, -0.00789808f, -0.02010942f, -0.05932767f, 
    -0.05527031f, 0.01448120f, -0.06048236f, -0.05746997f, -0.00116582f, -0.00140546f, -0.00486591f, -0.06226766f, 
    -0.05757637f, 0.01052551f, 0.04742532f, -0.02371601f, 0.02437056f, -0.05816577f, -0.01183443f, -0.05171128f, 
    -0.01506767f, -0.00967791f, -0.00064866f, -0.01795316f, 0.02423388f, 0.00335166f, 0.04510039f, 0.03046917f, 
    -0.02593625f, 0.00832218f, 0.04240100f, -0.05389820f, -0.03922722f, -0.05529670f, 0.00212319f, -0.04745533f, 
    -0.02993286f, -0.03918874f, -0.01875487f, -0.00402687f, 0.05288504f, -0.01385936f, 0.05044678f, 0.01574852f, 
    -0.03274661f, -0.05412302f, 0.02090574f, -0.05472267f, -0.02063785f, -0.01227679f, -0.02650414f, -0.03302408f, 
    0.06701861f, 0.13181609f, 0.11071652f, 0.08075975f, 0.05841744f, 0.03341252f, -0.02241709f, 0.03517579f, 
    -0.01552271f, 0.25611398f, 0.12880564f, -0.27234703f, -0.01423333f, 0.15320770f, -0.01337895f, 0.09392318f, 
    -0.20661421f, -0.03301279f, -0.14219891f, -0.12905683f, -0.04013636f, 0.10470623f, 0.09873591f, 0.16334297f, 
    0.07446667f, -0.14423940f, 0.16219148f, -0.61365974f, 0.04184185f, -0.01848941f, -0.33098325f, -0.17968282f, 
    0.06820762f, 0.02917516f, -0.13806115f, 0.05609376f, 0.33130679f, -0.25188890f, -0.30213526f, 0.18620250f, 
    -0.00703451f, 0.12196964f, -0.06478368f, -0.04901876f, 0.13856158f, -0.14648281f, -0.04153666f, -0.39978296f, 
    0.11604093f, -0.04801745f, -0.07091870f, -0.00853485f, 0.14878836f, -0.09258634f, -0.27026114f, 0.21511322f, 
    0.03104221f, -0.12478945f, -0.02826417f, -0.00759299f, -0.12212121f, -0.00861857f, 0.04773493f, 0.23773371f, 
    0.13612145f, -0.12889235f, -0.12955599f, 0.07060529f, 0.00687958f, -0.09682064f, -0.11454275f, -0.02449711f, 
    -0.51609397f, -0.03490274f, -0.06500435f, -0.06379379f, 0.05175651f, -0.16740797f, 0.00333890f, 0.23465006f, 
    -0.07068730f, -1.00878084f, -0.60302174f, -0.24440090f, -0.03182167f, -0.05961389f, -0.17545755f, 0.18899384f, 
    -0.01716868f, 0.18514560f, 0.39625460f, 0.26336008f, -0.15701450f, 0.00231009f, -0.11878937f, -0.12572381f, 
    0.18019164f, -0.13641742f, 0.05696118f, 0.27496719f, 0.02490809f, -0.15906957f, -0.15656567f, -0.07608432f, 
    0.12283046f, 0.07943266f, 0.19198045f, 0.15172039f, 0.38947111f, 0.01954308f, 0.21530904f, -0.22358426f, 
    0.04508080f, -0.03821261f, -0.05988370f, -0.06146909f, -0.05864262f, -0.52259398f, -0.19664852f, 0.03589729f, 
    -0.11086565f, 0.05461550f, -0.12114829f, -0.04560354f, 0.03300042f, -0.02540276f, -0.06659796f, 0.03403992f, 
    -0.29390791f, -0.06013046f, -0.05320137f, -0.06200625f, 0.04860846f, -0.13042691f, -0.01263039f, 0.52089828f, 
    0.33923399f, -0.11444273f, -0.07724945f, -0.15527177f, 0.13745140f, -0.10883591f, -0.07148691f, -0.07879464f, 
    0.38240126f, 0.03991697f, -0.01857501f, -0.04103595f, -0.02908451f, 0.08264082f, 0.18366174f, -0.02112932f, 
    0.03512011f, 0.37366727f, 0.26951957f, 0.14091590f, 0.10725886f, 0.14793329f, 0.08035427f, 0.03061906f, 
    0.09055983f, -0.04548662f, 0.31683025f, 0.27832088f, 0.20157598f, -0.13615917f, 0.09479110f, 0.05346348f, 
    0.11040759f, 0.09671105f, -0.12299249f, 0.58618528f, 0.11312716f, 0.21120547f, 0.14800255f, -0.08039807f, 
    -0.21583024f, 0.01619660f, 0.10213257f, -0.16868390f, 0.01228993f, -0.05918114f, -0.45144951f, 0.41830289f, 
    -0.06855486f, -0.12063679f, 0.14087100f, 0.02367928f, 0.05712783f, 0.30765012f, 0.03854681f, -0.31222248f, 
    -0.12330069f, -0.01667720f, -0.05557782f, 0.06203544f, -0.02716755f, -0.09149151f, 0.11374493f, -0.35774910f, 
    -0.04097761f, -0.12789981f, -0.14351356f, 0.05387558f, 0.15322062f, 0.23972726f, 0.01827812f, 0.28622612f, 
    0.04144546f, 0.08311632f, -0.08673284f, -0.04517520f, 0.02281792f, 0.06894048f, -0.06639563f, -0.18969639f, 
    -0.09886193f, -0.20407169f, 0.21833542f, -0.09954749f, -0.08397529f, -0.14514387f, -0.00321522f, 0.01396790f, 
    0.09551840f, 0.04132921f, -0.31532374f, 0.20212835f, 0.02125258f, -0.07532199f, -0.02150184f, -0.16679183f, 
    0.13989194f, -0.16602008f, -0.26796538f, 0.19866838f, -0.08964417f, 0.02981561f, -0.07032894f, -0.01809523f, 
    -0.06056868f, -0.18709317f, -0.05376250f, 0.17856891f, -0.07859120f, -0.04543602f, 0.16535608f, -0.10139431f, 
    0.20916367f, 0.20314415f, 0.06126916f, 0.11809544f, 0.12911643f, -0.03347699f, 0.12840556f, -0.21284892f, 
    -0.08853409f, 0.14766324f, -0.01819373f, 0.25558391f, -0.00703235f, 0.12526336f, -0.07824489f, 0.06563625f, 
    -0.02388072f, 0.04525557f, 0.15360899f, 0.17688312f, 0.22131658f, -0.00974917f, 0.15146840f, 0.16814195f, 
    0.08652627f, -0.07055841f, -0.05353799f, -0.01471778f, -0.02921090f, -0.05175871f, -0.06052391f, -0.01455757f, 
    -0.06560042f, -0.32203999f, 0.14887451f, -0.10174053f, -0.10373752f, 0.00276290f, -0.04111576f, -0.03365957f, 
    -0.10118648f, -0.07155886f, 0.37095693f, 0.12814397f, 0.00315725f, -0.10745299f, 0.00745187f, -0.16930701f, 
    -0.08112507f, 0.13020158f, 0.00146460f, 0.22418356f, -0.34433913f, -0.18715855f, -0.02752494f, 0.00212169f, 
    0.19281103f, -0.03617293f, -0.26903957f, -0.28625378f, -0.24482198f, 0.15733723f, -0.15531306f, 0.24217841f, 
    0.11151415f, -0.04483663f, -0.19882278f, 0.26122886f, 0.39259818f, -0.04857994f, -0.06552706f, 0.14453436f, 
    0.28982481f, 0.02782735f, 0.15972859f, -0.18775965f, -0.04952688f, -0.16642563f, 0.03722934f, 0.00454707f, 
    0.12745126f, -0.04921585f, -0.09937207f, -0.04527814f, -0.05494836f, -0.05468071f, -0.10989369f, -0.13114730f, 
    0.17331964f, -0.31431630f, 0.00570088f, 0.03746333f, 0.11108066f, 0.17601274f, 0.18748854f, 0.10720537f, 
    0.23630534f, 0.01858003f, 0.13302785f, -0.20891102f, 0.10836609f, -0.04853607f, 0.11684529f, 0.21751586f, 
    0.12024597f, -0.06703047f, -0.01024463f, -0.04961538f, -0.04612783f, 0.20460895f, -0.12728491f, -0.06907435f, 
    0.34805223f, 0.04258839f, -0.04260589f, 0.14268576f, -0.22446088f, -0.10010261f, -0.01792479f, 0.13943274f, 
    -0.15527700f, -0.15897588f, 0.15689310f, 0.27030811f, 0.11988251f, 0.10072493f, -0.27643645f, -0.36188781f, 
    0.36131316f, 0.34792045f, 0.02529347f, 0.03751897f, -0.07963556f, -0.04311267f, 0.01881668f, 0.03597685f, 
    0.19824938f, 0.08367647f, 0.01323485f, 0.23970783f, 0.05955169f, 0.27821001f, 0.11078049f, -0.07011254f, 
    -0.17613228f, -0.08180907f, 0.02432152f, 0.03733584f, -0.10538145f, -0.25166255f, -0.06056637f, 0.09573215f, 
    0.21397434f, -0.00810480f, 0.09645833f, -0.03950752f, -0.03811421f, -0.15649360f, -0.12518421f, -0.10476030f, 
    0.30791989f, 0.04685909f, 0.04455728f, -0.16452853f, -0.09092198f, 0.21564320f, 0.21323191f, -0.19274722f, 
    -0.13784029f, 0.18284667f, 0.04543402f, 0.13351937f, -0.04608367f, -0.02679515f, 0.10967572f, 0.32942548f, 
    -0.10033030f, -0.25482419f, -0.09433321f, 0.03485428f, 0.07971802f, 0.14674610f, -0.01147398f, -0.02353720f, 
    0.15302257f, -0.16641268f, -0.37869355f, -0.10084964f, 0.05825461f, -0.13318434f, 0.02740422f, 0.05741699f, 
    0.09323242f, -0.16352004f, -0.19992194f, -0.33197668f, -0.02871867f, 0.03375305f, 0.06491755f, 0.02798578f, 
    0.08114983f, -0.07314891f, 0.43221191f, -0.08454140f, -0.39227462f, 0.14438124f, -0.18721916f, 0.26690817f, 
    0.15225331f, -0.00990276f, 0.10079431f, -0.14779128f, 0.00202800f, -0.19298945f, 0.01316998f, 0.12325162f, 
    0.16933057f, 0.22314081f, -0.32388926f, 0.05521276f, 0.15246969f, -0.07769098f, 0.09634246f, 0.00371998f, 
    0.00400712f, -0.08705799f, 0.11681189f, -0.10824239f, -0.24025775f, 0.01614519f, -0.02634144f, 0.10636672f, 
    -0.16461501f, -0.01997833f, 0.23494841f, -0.05400077f, -0.01346249f, -0.13385771f, -0.10097000f, -0.14302681f, 
    0.07661073f, 0.05721400f, 0.13322902f, 0.27542859f, -0.06803811f, -0.23932134f, 0.15741545f, 0.33585945f, 
    0.10750820f, -0.39519820f, -0.01746268f, -0.09345554f, 0.13274218f, -0.02694446f, -0.23381200f, 0.24979626f, 
    0.00768928f, 0.14407450f, -0.31242493f, -0.05512043f, 0.01682937f, -0.09322996f, 0.14222024f, -0.02923653f, 
    0.10383308f, -0.36568904f, -0.07022602f, 0.10238593f, 0.10268340f, 0.17163809f, -0.22576331f, -0.03186893f, 
    0.01790536f, -0.10463881f, 0.29903892f, 0.00059925f, 0.29447952f, -0.00518367f, -0.20377448f, -0.01548799f, 
    -0.05464029f, 0.10863058f, 0.04642045f, 0.03030648f, -0.00438907f, -0.35798496f, 0.04661328f, 0.02627745f, 
    -0.09984948f, 0.13340014f, 0.07810872f, 0.08843166f, 0.04194626f, 0.12484156f, 0.13745832f, 0.09700760f, 
    -0.06805313f, -0.19400567f, 0.06745993f, 0.01737843f, -0.08606463f, 0.02567890f, -0.13403022f, -0.21923824f, 
    0.01022145f, 0.00791624f, 0.08563668f, 0.01701457f, -0.09539544f, 0.09952111f, 0.11248320f, -0.09926520f, 
    0.30847928f, 0.15356801f, 0.14694472f, -0.03728078f, 0.12902559f, 0.08819447f, 0.07758626f, 0.14207853f, 
    0.12256517f, -0.00697853f, -0.03496606f, -0.13968873f, 0.26348656f, 0.13662110f, 0.04090980f, -0.02068123f, 
    -0.02192732f, -0.04929364f, -0.00403576f, -0.04721205f, 0.04467572f, -0.04265901f, 0.00408923f, -0.05294928f, 
    0.05126622f, -0.02236456f, -0.06417958f, -0.01584645f, -0.03051853f, -0.00236527f, -0.04962026f, -0.06302873f, 
    -0.04767399f, 0.00369749f, 0.03748062f, -0.01271125f, -0.00769240f, 0.05387927f, -0.04681791f, 0.04193026f, 
    0.05818041f, -0.00874999f, -0.02833455f, 0.00124475f, 0.04525793f, -0.03443615f, 0.00510506f, 0.03633010f, 
    -0.01645177f, -0.01542494f, 0.04626449f, -0.04099093f, 0.00216814f, 0.03086398f, -0.05538000f, 0.01197998f, 
    -0.04149454f, 0.00742821f, 0.02098815f, -0.03012007f, -0.00811581f, 0.02931966f, -0.01467432f, -0.03894936f, 
    -0.02653925f, -0.05518257f, 0.02547466f, -0.05103609f, -0.03225916f, 0.01844293f, -0.03027868f, 0.04469883f, 
    -0.06127571f, 0.03096425f, 0.03095376f, -0.04063276f, 0.02444684f, -0.04811728f, -0.00398819f, -0.00186170f, 
    -0.04401215f, 0.02979964f, 0.03703123f, 0.04474416f, 0.02446830f, 0.02162915f, 0.01831966f, 0.03996962f, 
    0.03789715f, -0.02475118f, -0.06213269f, 0.04422913f, -0.00505638f, -0.06358489f, -0.02683548f, 0.02862054f, 
    -0.04302056f, 0.04417986f, -0.00754531f, 0.00592479f, -0.05271947f, 0.02604871f, -0.05465335f, 0.04801927f, 
    0.02196011f, 0.02066365f, -0.03421350f, 0.00420360f, -0.01116290f, -0.05537173f, -0.04975197f, -0.03156916f, 
    0.01954192f, -0.03659673f, 0.02689823f, -0.05960377f, -0.03679210f, -0.05760905f, 0.04731015f, 0.01104399f, 
    0.05585628f, -0.05320036f, -0.04791707f, -0.02474477f, 0.01236657f, -0.01222783f, -0.06019492f, -0.02476239f, 
    -0.05513459f, 0.02554505f, 0.03039905f, 0.03373866f, -0.03268619f, 0.00397431f, -0.05875918f, -0.03892374f, 
    -0.02522121f, -0.00368330f, 0.03786495f, -0.04245612f, -0.05393884f, -0.00223778f, 0.02959108f, 0.00807616f, 
    -0.00762804f, 0.04144841f, -0.04068612f, -0.03201388f, -0.03301688f, -0.01905985f, -0.05950030f, 0.04862908f, 
    0.02095388f, -0.03788978f, 0.05969078f, 0.00826341f, 0.03469390f, 0.01412072f, 0.02139921f, -0.04116169f, 
    -0.01570798f, -0.06038319f, 0.05211085f, -0.02198882f, -0.05002616f, 0.02242333f, -0.02325436f, 0.00085096f, 
    0.05191009f, -0.04684648f, -0.00326202f, -0.00089434f, 0.00742872f, -0.02623351f, -0.00947540f, -0.05027233f, 
    -0.03227757f, -0.02889246f, 0.02635018f, 0.01998635f, -0.02552637f, 0.01557796f, -0.00325606f, -0.05809006f, 
    -0.03947691f, -0.03494483f, 0.00224826f, -0.00456959f, 0.05158078f, -0.05898608f, -0.02753246f, -0.04107057f, 
    -0.01626967f, -0.02030665f, 0.01738826f, 0.04964326f, -0.02011278f, -0.02935263f, -0.00744852f, 0.01214375f, 
    -0.03828799f, -0.06019857f, -0.04858433f, -0.01863436f, -0.06024396f, -0.05293921f, 0.03446774f, -0.00379434f, 
    0.01121110f, 0.04441874f, -0.05725554f, 0.05442129f, 0.03153016f, -0.00674419f, -0.03316527f, -0.04541789f, 
    -0.00032190f, -0.01288720f, -0.02612158f, -0.01271092f, 0.03917000f, -0.04526445f, -0.02446333f, -0.04189429f, 
    -0.02699366f, 0.02243536f, -0.01536702f, -0.01788442f, 0.03459911f, -0.02252009f, 0.03170195f, -0.01323270f, 
    0.00776520f, -0.00547042f, -0.04074565f, 0.00603918f, 0.04627864f, -0.06180351f, -0.05432484f, 0.01716617f, 
    -0.03445872f, 0.01863796f, 0.00746343f, -0.05970701f, 0.01506597f, -0.00383203f, -0.05970107f, -0.03622009f, 
    -0.04189407f, -0.02993130f, 0.01311425f, -0.03848264f, 0.05107450f, 0.01563003f, 0.04918804f, 0.05020566f, 
    -0.05450906f, -0.00657053f, 0.01082328f, -0.00509780f, -0.05863942f, 0.03314130f, 0.04744255f, -0.02571323f, 
    -0.00230102f, 0.01050884f, 0.04815815f, -0.04819841f, 0.04159041f, 0.03936847f, -0.03843209f, 0.04370499f, 
    -0.00117587f, 0.04457423f, 0.01490963f, -0.04077865f, -0.01827832f, -0.00953892f, 0.04187539f, 0.01101651f, 
    0.02144903f, -0.05730643f, 0.04069872f, -0.05844703f, 0.03603231f, 0.04416920f, -0.01684671f, 0.04936134f, 
    -0.02034394f, -0.05623343f, 0.02468790f, 0.03772147f, 0.03425903f, -0.01694297f, 0.00022427f, -0.03380518f, 
    -0.00484442f, 0.04389229f, 0.00105161f, -0.04724318f, 0.01915700f, -0.00096027f, 0.01348402f, -0.03234565f, 
    0.02078539f, -0.05034807f, -0.03346100f, 0.04113390f, -0.03996560f, -0.03101687f, -0.00305133f, 0.04234091f, 
    0.03547566f, -0.02351939f, -0.01455069f, 0.02375436f, -0.01720612f, -0.06189525f, -0.03681861f, -0.02836495f, 
    0.02009879f, -0.05983166f, 0.01665691f, 0.00231831f, -0.00136980f, -0.02146028f, -0.02200486f, 0.01558542f, 
    0.02880389f, 0.00795252f, 0.05004468f, -0.04122319f, 0.03360128f, -0.02002689f, 0.04898383f, -0.03713565f, 
    0.00647840f, 0.04653249f, -0.06131694f, 0.04451736f, -0.02127291f, -0.03631761f, -0.01942571f, 0.00754581f, 
    -0.05704652f, -0.02967858f, 0.04936639f, 0.02977871f, -0.02810011f, 0.02429945f, 0.02739528f, -0.02216344f, 
    0.02680016f, -0.01754985f, -0.00008206f, -0.00520703f, 0.01709850f, -0.01829786f, -0.03696145f, -0.01291361f, 
    -0.06221591f, 0.00542056f, -0.02905160f, 0.00732708f, -0.06308969f, -0.02239876f, -0.00456916f, -0.00076450f, 
    -0.02377249f, 0.01391709f, -0.04966897f, -0.05735365f, -0.03837486f, -0.02473415f, -0.02884275f, -0.05733778f, 
    -0.01135749f, -0.05948001f, -0.01295698f, 0.04374161f, -0.02842779f, -0.00124390f, 0.03889639f, -0.03472694f, 
    -0.02949627f, 0.00300721f, 0.00992878f, 0.04242320f, -0.00945536f, 0.02599073f, 0.03892826f, -0.06350403f, 
    -0.03450106f, 0.05012754f, 0.03608922f, -0.00463537f, 0.02169735f, 0.03718342f, -0.00359588f, 0.03008158f, 
    0.02614758f, -0.00224210f, -0.00250181f, -0.00662862f, 0.02568285f, -0.04510954f, -0.02585305f, 0.01402725f, 
    0.00336593f, 0.03002289f, 0.04002941f, 0.01836336f, 0.03880559f, -0.00821115f, 0.04038369f, -0.02938062f, 
    0.04852434f, -0.04417785f, 0.03365393f, -0.06438327f, -0.01321158f, -0.03002248f, 0.02233885f, -0.03097640f, 
    -0.03336953f, -0.03197796f, -0.01377611f, -0.03175851f, -0.02809764f, 0.00570033f, 0.04213678f, 0.04546583f, 
    -0.02863932f, -0.02951159f, 0.02101396f, 0.04321095f, -0.04982974f, -0.05275122f, 0.04763426f, -0.04618906f, 
    -0.05658245f, -0.06301153f, -0.01048589f, 0.02237503f, -0.05791948f, -0.01315262f, 0.04592785f, 0.00604570f, 
    0.00355905f, 0.04619192f, 0.02489401f, 0.04798165f, -0.02191218f, 0.04506988f, -0.05320026f, 0.05185147f, 
    0.01085169f, 0.02885694f, 0.01836861f, -0.05839516f, -0.06384746f, 0.03889099f, -0.06415552f, -0.01805362f, 
    -0.03967250f, -0.06657518f, -0.06560428f, -0.06286614f, -0.00137074f, -0.00210012f, 0.03751740f, -0.00355172f, 
    0.04827007f, 0.02375324f, 0.04820918f, -0.03265355f, 0.04010813f, 0.01426475f, -0.02763340f, -0.02138793f, 
    0.01329717f, 0.03469949f, -0.02981685f, -0.01643632f, -0.01611906f, 0.00706214f, 0.00345066f, 0.04621936f, 
    -0.04889877f, -0.04297246f, -0.00031831f, 0.03610365f, 0.03788523f, -0.03108557f, 0.02184506f, -0.03626896f, 
    -0.02447282f, -0.03269999f, -0.05360271f, 0.04486389f, -0.02765753f, 0.02436919f, -0.06401952f, -0.00943797f, 
    -0.01622121f, -0.06388081f, -0.05954821f, -0.01089985f, -0.05340008f, -0.05005760f, 0.01503998f, -0.02786168f, 
    0.01926006f, 0.01503582f, 0.01306819f, -0.03620855f, -0.00173566f, 0.03390315f, 0.00679851f, 0.00487180f, 
    -0.01369978f, 0.03363254f, 0.06592058f, 0.00320429f, 0.02429300f, -0.01999377f, 0.02729381f, -0.00517105f, 
    -0.05609041f, -0.06011882f, -0.02046725f, -0.00436335f, 0.05399415f, 0.02856369f, 0.04393860f, -0.00514273f, 
    -0.06466823f, 0.04093360f, 0.03691275f, -0.05128673f, -0.02230556f, -0.00263797f, -0.00484434f, -0.05669647f, 
    -0.04365372f, 0.04036289f, -0.06361645f, -0.02516044f, 0.01708800f, 0.00844443f, 0.00336279f, -0.05940348f, 
    0.01224971f, 0.01218332f, 0.00767903f, -0.00901809f, -0.01332109f, -0.02259076f, 0.00715090f, 0.04708839f, 
    -0.05584424f, -0.04757925f, -0.00371938f, -0.05247280f, -0.00042700f, -0.03826228f, 0.00477879f, -0.02750689f, 
    -0.05169388f, 0.04428861f, 0.04502039f, -0.00249919f, -0.00500938f, -0.04789614f, 0.00941165f, 0.03224517f, 
    -0.00181168f, -0.02175788f, -0.05566655f, -0.00317686f, 0.04394291f, -0.01440011f, -0.02933082f, -0.02123603f, 
    0.04392438f, -0.01564058f, -0.04001737f, 0.01369322f, 0.04266777f, 0.03980447f, 0.02482268f, -0.01390096f, 
    0.54791278f, -0.12812488f, -0.42104709f, 0.30528152f, -0.04693574f, -0.13968310f, 0.00484553f, -0.17790057f, 
    0.16860771f, -0.18423603f, -0.17047474f, -0.09270130f, -0.04509202f, 0.08438084f, -0.06454873f, -0.08607891f, 
    -0.08169381f, 0.10273261f, -0.07038743f, -0.14587210f, -0.10868951f, 0.32680675f, 0.01076294f, 0.09018236f, 
    0.03557428f, 0.08036548f, -0.12532720f, 0.23326597f, -0.25282270f, -0.62075132f, 0.27111202f, -0.01354168f, 
    0.10060006f, -0.14058210f, 0.24656235f, -0.19793937f, -0.16864389f, -0.13370153f, -0.18253005f, 0.17537783f, 
    0.07240552f, 0.21442279f, -0.09847588f, -0.09211431f, 0.02770267f, 0.12976530f, 0.21819533f, 0.15183353f, 
    0.03230664f, 0.31876305f, 0.04063277f, -0.02718638f, 0.09243204f, -0.06497656f, 0.46832207f, 0.20146812f, 
    -0.43222591f, 0.00241385f, -0.08452492f, 0.04045728f, 0.01891071f, -0.02069775f, 0.04667284f, -0.17739952f, 
    -0.10090884f, 0.06604508f, 0.08944354f, 0.06604572f, -0.04790980f, 0.26507995f, 0.00357633f, -0.10440034f, 
    -0.64418423f, -0.29118630f, -0.03149433f, 0.11557252f, 0.14973851f, 0.06734673f, 0.17447330f, -0.01701041f, 
    -0.01015515f, 0.31615856f, 0.12960082f, -0.26849657f, 0.19073382f, 0.08132370f, 0.12284744f, 0.01993607f, 
    -0.05107538f, 0.07927082f, -0.39721131f, 0.17615053f, 0.25105041f, -0.08871976f, -0.17342116f, -0.21166126f, 
    0.00155051f, -0.03109761f, 0.11028522f, -0.14993104f, 0.17598124f, 0.16619916f, -0.00305010f, 0.05934009f, 
    -0.06199659f, 0.12180394f, -0.12811965f, 0.08117522f, 0.42974576f, 0.09991196f, -0.15825942f, 0.00958150f, 
    0.11975968f, -0.01869061f, -0.00465639f, 0.05511498f, 0.06891336f, 0.18975468f, 0.26788947f, 0.34235805f, 
    0.17186742f, 0.06943000f, -0.10004676f, 0.02325222f, 0.08293670f, -0.00600154f, -0.02753649f, 0.10648565f, 
    -0.07841250f, 0.01451487f, 0.06467051f, 0.07745831f, 0.05765813f, 0.10004673f, 0.23336166f, -0.11427633f, 
    0.12621474f, 0.19554813f, -0.10492726f, 0.03763046f, -0.01733647f, 0.02345753f, -0.16211247f, -0.14149056f, 
    0.01504245f, 0.12057973f, 0.25968337f, -0.20499212f, 0.00153308f, -0.11740717f, 0.06409880f, -0.08796532f, 
    -0.16722013f, -0.17371665f, 0.13003252f, 0.03927310f, 0.10822184f, -0.07020510f, 0.10187600f, -0.00055136f, 
    -0.05331106f, 0.09125907f, -0.03585086f, 0.02054157f, 0.31289750f, -0.23604488f, -0.20458369f, -0.05303835f, 
    -0.06369255f, -0.02724332f, -0.07388363f, 0.17487791f, -0.26452672f, -0.02832428f, 0.01914687f, -0.09131549f, 
    -0.03880178f, 0.22530456f, -0.02819080f, -0.18200557f, -0.24613719f, -0.17903571f, 0.24136421f, -0.28122559f, 
    -0.05801427f, -0.07785632f, -0.07978929f, -0.02758755f, 0.20424056f, -0.10957011f, -0.01411077f, 0.08022174f, 
    -0.05427523f, 0.08756207f, 0.05364672f, 0.11936222f, 0.02870012f, 0.15924299f, -0.95229447f, -0.08817291f, 
    0.07316681f, -0.06907952f, 0.17192382f, -0.04967153f, -0.02415363f, 0.02089986f, -0.19032642f, 0.30486435f, 
    0.14646013f, 0.41113788f, 0.09567721f, -0.04424527f, -0.12978552f, 0.29583225f, -0.01298548f, 0.23938639f, 
    -0.75969672f, -0.74052858f, -0.18343543f, 0.22623475f, -0.14685990f, -0.12598877f, -0.17273119f, -0.05750991f, 
    0.04278796f, 0.11412455f, -0.02040235f, -0.19174407f, 0.16052021f, 0.07440384f, 0.00952423f, 0.27236909f, 
    0.16713162f, 0.25089362f, -0.44231975f, -0.21472026f, -0.35395405f, 0.03979651f, -0.03101494f, 0.34006941f, 
    0.10316570f, -0.05547259f, 0.04075206f, -0.36690715f, -0.35472298f, 0.13446212f, -0.37753642f, 0.07798882f, 
    -0.19625694f, 0.03487778f, 0.13451141f, 0.10042392f, -0.38250130f, -0.06018507f, -0.66759348f, 0.03885083f, 
    0.05790619f, -0.04924145f, 0.03565317f, -0.19137061f, -0.16605741f, 0.16667923f, -0.11944972f, 0.26431635f, 
    -0.23799218f, 0.24107055f, -0.06614787f, 0.14724372f, 0.10385371f, 0.04579964f, 0.22542265f, -0.15304431f, 
    -0.27973634f, 0.27597690f, -0.08700602f, 0.10849984f, 0.23488173f, -0.09716953f, 0.07431497f, -0.16259143f, 
    -0.20736581f, 0.36321813f, -0.09550437f, -0.07415453f, -0.18386181f, 0.12167897f, 0.13608843f, 0.13451223f, 
    0.58072138f, 0.27173474f, 0.16319355f, -0.40350938f, -0.04145067f, -0.04161775f, -0.10471354f, 0.06131297f, 
    -0.10010525f, 0.22102809f, -0.50463361f, -0.16937174f, -0.16471790f, 0.01907023f, 0.11216563f, -0.07171905f, 
    -0.04000332f, 0.02434726f, -0.09046919f, 0.17386717f, 0.31951243f, -0.13184799f, 0.05309938f, 0.09631740f, 
    0.01902181f, 0.13225989f, 0.09044979f, 0.08981588f, -0.27744666f, 0.08273438f, -0.08848559f, -0.05423661f, 
    -0.32152370f, 0.10578731f, -0.03157990f, 0.02896719f, 0.33211002f, 0.42062119f, -0.21859309f, 0.08621630f, 
    0.06178343f, 0.13702931f, -0.23156519f, 0.05571066f, 0.04288432f, 0.45601079f, -0.05839878f, -0.67569625f, 
    -0.01625176f, 0.16427742f, 0.21344934f, -0.46848682f, -0.20935559f, -0.10424089f, 0.45421186f, 0.03100018f, 
    -0.38530520f, 0.06331104f, -0.14984998f, -0.01167701f, 0.09407924f, 0.07756917f, -0.18265179f, 0.31623212f, 
    -0.11491115f, -0.11533005f, -0.27658758f, 0.16479759f, -0.06475007f, -0.09304914f, 0.02533654f, 0.06424786f, 
    0.64609599f, -0.04405627f, -0.22480831f, -0.13918322f, -0.01275470f, 0.09075081f, -0.04299714f, -0.01827135f, 
    0.10317015f, 0.93540084f, -0.18530083f, -0.31764272f, -0.34724060f, -0.27837375f, -0.05817491f, -0.04690622f, 
    -0.16582802f, 0.02409500f, 0.02017982f, -0.11430416f, 0.01655957f, 0.10165089f, 0.05568873f, 0.08771259f, 
    -0.05482475f, -0.00216631f, 0.05499691f, -0.06135252f, -0.27391100f, -0.09491521f, -0.48155257f, -0.13342898f, 
    -0.11757527f, -0.02238519f, -0.07892758f, 0.12267633f, 0.15080781f, -0.36367664f, -0.16121016f, 0.05480069f, 
    -0.20659743f, 0.10300070f, -0.10385182f, 0.04421769f, 0.00044469f, 0.74881011f, 0.24598482f, 0.14533809f, 
    -0.38823429f, -0.27893460f, 0.17722023f, 0.20322341f, 0.08552346f, -0.10922411f, -0.39621162f, -0.30966049f, 
    -0.03324110f, 0.10777049f, 0.28589302f, -0.12968397f, -0.06983885f, 0.11941001f, -0.07154271f, -0.00068365f, 
    0.22829857f, 0.09487813f, 0.08633056f, 0.12284363f, 0.28121427f, 0.04106244f, -0.16310281f, -0.00498990f, 
    -0.37309614f, 0.29059172f, -0.02691549f, 0.15345164f, 0.09183723f, 0.21199162f, -0.17337970f, 0.15977076f, 
    -0.13380533f, -0.71051991f, 0.27452397f, 0.05370423f, 0.00399446f, 0.07195384f, 0.02868905f, 0.13447788f, 
    -0.06481039f, 0.08994729f, -0.47525454f, 0.07665626f, -0.19604218f, 0.15270980f, 0.27331275f, 0.17048849f, 
    -0.07788593f, -0.08266781f, 0.09520049f, -0.42235467f, -0.10473732f, 0.11604574f, -0.12750939f, 0.15126728f, 
    0.18427739f, -0.13821693f, -0.07064229f, -0.00499729f, 0.01777756f, 0.19453169f, -0.08030053f, 0.31101260f, 
    -0.01453487f, -0.21104808f, -0.13186805f, 0.20158933f, 0.05504309f, -0.33406982f, -0.08922766f, -0.05131871f, 
    -0.10549957f, 0.13250476f, 0.14050852f, 0.00434274f, 0.02309844f, -0.09565215f, -0.16686620f, -0.30792010f, 
    0.03387762f, -0.25868952f, -0.06623597f, 0.00001907f, 0.00461947f, 0.14610676f, -0.01179572f, -0.48688021f, 
    -0.32577521f, 0.02716191f, 0.06509206f, 0.24200827f, 0.16011062f, -0.05467232f, -0.01446652f, -0.01317284f, 
    0.34750009f, 0.08920106f, -0.19600160f, -0.15587331f, -0.40696597f, 0.13704866f, 0.02737935f, 0.10024790f, 
    -0.01860291f, 0.10891677f, -0.03106345f, 0.06676226f, -0.18715942f, -0.11437773f, 0.03907569f, 0.08287739f, 
    -0.07639500f, 0.18855220f, -0.07338862f, 0.28752100f, 0.20044692f, -0.04097934f, -0.13272385f, 0.04553280f, 
    -0.03404984f, -0.17354664f, -0.00655025f, 0.08405400f, 0.28810507f, -0.17465630f, 0.17305501f, 0.13998896f, 
    0.19411446f, -0.01216361f, 0.09755351f, 0.03170124f, 0.54953027f, -0.33804342f, -0.01537038f, 0.16140866f, 
    0.02184874f, 0.22850023f, -0.10267931f, -0.02889522f, 0.05282883f, -0.15039742f, 0.03941123f, -0.30213824f, 
    -0.02359439f, 0.00387414f, -0.03016357f, 0.09070099f, -0.32496470f, 0.16546200f, 0.20641962f, 0.14945433f, 
    0.03266457f, -0.54004735f, -0.01938291f, -0.18805473f, -0.03211048f, -0.00160693f, 0.02816143f, 0.23516120f, 
    0.31429753f, 0.15182200f, 0.06642018f, 0.17017524f, -0.10707667f, -0.13223964f, 0.10875245f, 0.11145566f, 
    -0.05843192f, 0.09898140f, 0.14649460f, 0.18733083f, 0.23297985f, 0.06326295f, -0.03992150f, -0.05011537f, 
    0.17877506f, -0.08868457f, 0.28332466f, -0.13010126f, -0.02787605f, -0.01963160f, -0.20068212f, 0.14736558f, 
    0.03024618f, 0.00165134f, 0.12641276f, -0.21259652f, 0.16201699f, 0.19747010f, 0.09935910f, 0.09131860f, 
    0.10066766f, 0.15752211f, -0.22181015f, -0.13366395f, -0.04398650f, -0.10935427f, 0.24847934f, -0.12487417f, 
    -0.20622283f, 0.01564740f, 0.08476018f, -0.13943642f, -0.08010057f, 0.26724774f, 0.09213981f, 0.08681743f, 
    -0.09292819f, -0.37661719f, 0.07411687f, 0.10231066f, 0.27937418f, 0.03730426f, 0.02677923f, 0.08515778f, 
    0.12826000f, -0.17499815f, 0.10089821f, -0.20544471f, -0.01587867f, -0.00211212f, -0.05878330f, 0.24011126f, 
    0.12594108f, -0.20756367f, 0.09891377f, -0.09659881f, 0.06755882f, 0.05107319f, -0.05057099f, 0.07556257f, 
    0.24588087f, -0.12350123f, -0.02611250f, -0.05045585f, 0.09789953f, -0.03400583f, 0.00191297f, 0.15335314f, 
    -0.03998239f, 0.12132340f, 0.15648727f, -0.18511085f, -0.13612510f, -0.00338867f, -0.10289533f, -0.03415504f, 
    -0.10180338f, -0.41211876f, -0.21078956f, -0.07192670f, 0.09195634f, -0.15245011f, 0.18586154f, 0.03011107f, 
    -0.07610743f, 0.20294362f, -0.13446911f, -0.07112972f, 0.09516765f, -0.12082124f, -0.15862322f, -0.05733528f, 
    0.15217516f, -0.07444699f, 0.32641283f, 0.00408687f, 0.13389176f, -0.01916459f, -0.14885871f, -0.13262768f, 
    -0.02185654f, 0.02674555f, 0.13113555f, 0.05769370f, -0.31962994f, 0.05000735f, -0.16386299f, 0.26536891f, 
    -0.02703670f, 0.06379624f, 0.20794855f, -0.15096149f, -0.12351698f, 0.13019456f, -0.05649859f, -0.03935396f, 
    -0.10393316f, 0.09653620f, 0.30987301f, 0.10919379f, 0.00233522f, 0.04829250f, -0.19535831f, -0.45002812f, 
    0.15607826f, 0.11240058f, 0.01962825f, 0.07219924f, 0.16181687f, 0.30054563f, 0.04711279f, -0.00143513f, 
    -0.07448635f, 0.13127139f, 0.20625708f, -0.30565363f, -0.06742543f, 0.02386442f, 0.03943907f, -0.15357772f, 
    -0.07755472f, -0.14937846f, -0.03436493f, 0.05288682f, -0.36372259f, -0.11244389f, 0.16506886f, 0.12528788f, 
    0.17691447f, -0.13086392f, 0.17451306f, 0.13730086f, 0.01185652f, 0.05941891f, 0.12358622f, 0.04687855f, 
    0.13627149f, -0.04040739f, 0.06788366f, -0.27271262f, -0.04053557f, -0.01206389f, -0.11192425f, -0.07592455f, 
    0.12970391f, 0.01502982f, -0.07861954f, -0.33015490f, -0.40560567f, -0.16934556f, 0.21862531f, 0.13179369f, 
    0.06006092f, 0.07521565f, 0.18690474f, -0.20992930f, 0.11736502f, -0.05794765f, 0.14400142f, -0.10112467f, 
    -0.22461507f, -0.20589460f, 0.08297389f, -0.09067798f, -0.07096414f, -0.11701490f, 0.24259728f, 0.17244823f, 
    0.12866816f, -0.02237482f, -0.17977552f, 0.13445358f, 0.10051099f, 0.31975290f, 0.05233917f, -0.11860017f, 
    0.13475172f, 0.16703334f, -0.23606126f, 0.10257599f, 0.04645263f, 0.09685268f, 0.07683968f, 0.10745564f, 
    0.13927026f, 0.21601284f, 0.28499520f, -0.10572636f, 0.11104424f, 0.27392268f, 0.06270899f, -0.04856623f, 
    -0.17752346f, -0.08035938f, 0.04079915f, 0.11299843f, -0.13449900f, 0.04853512f, -0.16928221f, -0.12094562f, 
    -0.09710697f, -0.28240669f, 0.02801822f, -0.26039118f, 0.18030956f, 0.16415522f, 0.25069577f, 0.02502836f, 
    0.08021066f, -0.16915375f, -0.06298731f, -0.11786845f, -0.19497581f, 0.03398906f, -0.08400768f, -0.01935571f, 
    0.07604880f, 0.12995398f, 0.09721489f, 0.04092778f, -0.22316892f, -0.10373883f, 0.03647460f, -0.16663681f, 
    -0.00365360f, 0.11404538f, 0.16798525f, -0.03378746f, 0.01216080f, -0.22299515f, -0.00970237f, 0.16593048f, 
    0.10991112f, -0.06104949f, 0.02723741f, 0.09115707f, -0.18697160f, 0.14081411f, -0.07698306f, -0.02969807f, 
    0.11649587f, 0.09215365f, 0.06812087f, 0.14101337f, 0.31055421f, -0.38779601f, -0.14058460f, -0.02630619f, 
    0.04541801f, -0.15979254f, -0.02381147f, 0.12368758f, 0.04003539f, 0.25182268f, 0.12236080f, 0.17699645f, 
    0.15600450f, 0.13596718f, -0.00713559f, -0.10569581f, -0.00401420f, 0.08070270f, -0.01945204f, 0.29948375f, 
    0.00515491f, -0.01499144f, 0.03399999f, -0.04820147f, -0.02105124f, 0.03880495f, -0.01416968f, -0.03683947f, 
    -0.04278761f, -0.05547525f, -0.04381608f, -0.00892459f, -0.03013243f, 0.04984879f, -0.04966174f, 0.04313902f, 
    0.00004052f, 0.03778248f, 0.00158519f, 0.05705547f, -0.02071394f, 0.01562954f, -0.01075850f, -0.04563475f, 
    0.03227104f, -0.05127513f, 0.01490533f, -0.01994230f, -0.01677577f, -0.01555319f, -0.02664267f, -0.00283756f, 
    0.04327883f, -0.05023475f, -0.05526687f, -0.03135716f, -0.02296416f, 0.01053474f, -0.06358196f, 0.00819533f, 
    -0.01083230f, -0.00501800f, -0.03539624f, -0.01955121f, 0.05080699f, 0.02538617f, 0.04099220f, -0.04686391f, 
    0.04206771f, 0.04402215f, -0.00446550f, -0.03307864f, 0.03879496f, -0.04565224f, -0.01064679f, -0.04917159f, 
    -0.05319008f, -0.01496831f, 0.01424652f, -0.02763541f, -0.02825712f, 0.00489423f, -0.05947831f, 0.04756726f, 
    -0.06088484f, 0.03434247f, -0.00395588f, -0.00059025f, -0.01182294f, -0.00579715f, 0.04724593f, -0.01154805f, 
    -0.05973044f, 0.01537961f, 0.02363723f, 0.00218437f, -0.05598287f, -0.03324659f, -0.04369179f, 0.02691869f, 
    0.04555873f, -0.06931362f, 0.03691083f, 0.01271128f, 0.02330980f, -0.00278447f, -0.01204923f, 0.00264837f, 
    -0.04717736f, 0.03884830f, -0.02838563f, -0.03290899f, 0.04326776f, 0.03110029f, -0.05043201f, -0.01568371f, 
    0.04089266f, 0.01624717f, -0.00647576f, 0.02134374f, 0.03183189f, -0.04710743f, 0.01493665f, 0.03430308f, 
    -0.05326917f, -0.04812758f, -0.04151837f, -0.05800108f, -0.03391226f, 0.02996213f, 0.05256090f, -0.06525835f, 
    0.00896569f, 0.04151779f, -0.00825872f, -0.06190397f, -0.00428137f, 0.03975755f, -0.03179843f, 0.03310477f, 
    0.00076006f, 0.01581053f, -0.02346646f, 0.01099046f, -0.05534227f, -0.04726435f, -0.03661627f, -0.03058413f, 
    -0.01473335f, 0.02161567f, 0.04628596f, -0.05211106f, -0.01150580f, 0.00376910f, 0.03290516f, 0.03379432f, 
    0.03783693f, -0.02254760f, -0.03137121f, -0.02804727f, -0.03478518f, -0.03511617f, -0.05608029f, -0.03286335f, 
    0.03531053f, -0.05003574f, 0.04150855f, -0.00297799f, -0.06237350f, -0.04943167f, -0.02795760f, 0.04136259f, 
    -0.02816754f, -0.01724638f, 0.02432100f, 0.00017358f, 0.03783562f, -0.05761809f, 0.04464614f, 0.01140369f, 
    -0.05928831f, 0.01375875f, -0.02175561f, -0.04705996f, 0.04468754f, -0.00683018f, 0.01092285f, -0.02005923f, 
    0.00712438f, -0.05289223f, -0.00255691f, -0.01226489f, -0.01989376f, 0.03485616f, -0.00231685f, -0.05488888f, 
    0.04747884f, 0.01174711f, 0.03266923f, -0.04694629f, -0.05508809f, -0.00430344f, -0.01021695f, 0.04536832f, 
    0.03024418f, 0.01229481f, 0.01697576f, -0.04155209f, 0.01051380f, 0.02905991f, -0.02567381f, 0.03554435f, 
    -0.03222207f, 0.04523342f, 0.04654817f, -0.01506332f, -0.06134649f, 0.03327044f, -0.00040276f, -0.01632445f, 
    0.04704068f, 0.00400412f, 0.02364667f, 0.02916923f, -0.06263305f, -0.04717866f, 0.04878742f, 0.03680230f, 
    0.00105441f, -0.05450519f, -0.00399151f, 0.03432613f, 0.02332202f, -0.04655956f, -0.04327385f, -0.00298163f, 
    -0.04784078f, 0.02673857f, -0.06217702f, -0.05404582f, -0.00209441f, -0.00230549f, -0.01289549f, -0.03700341f, 
    0.02065080f, -0.01726360f, -0.04724607f, -0.00276812f, -0.02030755f, 0.02466577f, -0.04666549f, 0.00102358f, 
    0.01931167f, 0.00497769f, 0.01812782f, -0.06196593f, 0.04702775f, 0.00459004f, -0.00546686f, -0.05302779f, 
    -0.05978981f, 0.00616207f, -0.05513299f, -0.06514905f, -0.04650773f, -0.01228972f, -0.06674634f, -0.00883561f, 
    0.02510391f, -0.04983190f, 0.04828059f, 0.01964001f, 0.05489112f, -0.02223083f, 0.02293914f, -0.02272113f, 
    -0.02320836f, -0.03007377f, 0.01960968f, -0.01375856f, -0.04837969f, 0.02535435f, -0.02638708f, 0.04006194f, 
    0.01148512f, 0.03274658f, 0.00877960f, 0.02779014f, 0.02213128f, 0.05012910f, 0.03393137f, -0.04235631f, 
    -0.05962949f, 0.03489433f, -0.00270800f, 0.01012664f, 0.03195661f, -0.04732301f, 0.04582522f, -0.04288476f, 
    0.03416737f, -0.06087002f, -0.00401456f, -0.03676641f, -0.06452203f, -0.02631640f, -0.04540001f, -0.04735644f, 
    0.28044993f, 0.09341702f, 0.10505249f, -0.34228194f, 0.00854312f, -0.19438136f, 0.06893194f, -0.08904327f, 
    -0.10805398f, -0.29506716f, -0.09643342f, -0.03830647f, 0.11499000f, 0.20521291f, 0.27959812f, -0.07953275f, 
    -0.19552393f, -0.04199223f, -0.32962459f, 0.12443677f, 0.24531935f, -0.14410785f, 0.10450526f, 0.11479343f, 
    0.11502150f, 0.07160392f, 0.04304338f, 0.30308834f, 0.12728502f, 0.02403831f, 0.10088785f, -0.20459718f, 
    -0.22937781f, 0.00836978f, -0.05274353f, 0.21260695f, 0.26697290f, -0.19102614f, -0.01052396f, -0.04277899f, 
    -0.05150510f, 0.14562578f, 0.09893076f, -0.01058269f, -0.16246334f, 0.23564872f, -0.00128849f, -0.41624731f, 
    0.03386294f, 0.00702270f, 0.16739526f, -0.11383217f, 0.06830937f, -0.03554620f, 0.30545568f, 0.06405619f, 
    -0.19132794f, 0.16869919f, -0.10386053f, -0.07167436f, 0.02572322f, -0.01449732f, 0.16662461f, 0.04453894f, 
    -0.02465116f, 0.02397240f, 0.16166601f, 0.09024467f, 0.32436195f, -0.12373596f, 0.26687256f, -0.27613917f, 
    0.00811170f, -0.27619040f, -0.17628303f, -0.20657195f, 0.13400672f, 0.19639023f, 0.12916896f, 0.09162045f, 
    -0.22402215f, 0.18316339f, 0.11173136f, -0.27667224f, 0.09867540f, 0.08808096f, -0.50411302f, 0.25347626f, 
    -0.17476515f, -0.32249296f, 0.00946126f, -0.00927133f, 0.14631812f, 0.05620123f, 0.02238925f, 0.02622231f, 
    0.04275148f, -0.10642289f, 0.16084783f, 0.14941426f, -0.02017888f, -0.10059553f, 0.07126632f, -0.12188496f, 
    0.11935735f, 0.07943757f, -0.11125289f, -0.15641513f, 0.27804589f, -0.06289486f, -0.14247029f, -0.01624656f, 
    -0.09710104f, -0.14061026f, -0.22267701f, 0.41712353f, -0.08092949f, 0.05709220f, 0.40182728f, 0.09148372f, 
    -0.26283020f, 0.08653682f, -0.31459826f, -0.09754219f, -0.03098746f, 0.22896968f, -0.04828658f, -0.03818772f, 
    0.38656810f, 0.09508120f, 0.04931002f, 0.04723605f, 0.08738700f, 0.00154487f, 0.22888146f, 0.56597519f, 
    -0.13612027f, 0.02831857f, 0.12041056f, -0.13642499f, -0.00172097f, -0.36731291f, 0.04906347f, 0.10653324f, 
    0.08568297f, -0.00064182f, -0.17721556f, 0.02422956f, -0.29277804f, 0.16251151f, -0.06032717f, 0.13324147f, 
    0.12839445f, -0.31348246f, 0.21672846f, 0.34085962f, 0.08093081f, 0.08861629f, -0.00384270f, -0.00089212f, 
    0.10030685f, -0.01866458f, 0.24571525f, 0.21871208f, -0.12064333f, 0.12043968f, -0.30644855f, 0.16666220f, 
    0.02452302f, 0.03521665f, -0.02327635f, 0.19139877f, 0.08165386f, 0.09365132f, 0.07634475f, -0.13095489f, 
    -0.15557136f, 0.01717789f, 0.02697225f, 0.25260115f, 0.03436375f, -0.02891968f, -0.24398719f, 0.05863525f, 
    0.07257228f, 0.32966638f, -0.02385855f, -0.11312667f, -0.04650610f, -0.23836879f, -0.06637730f, 0.01452355f, 
    0.13568427f, 0.09561654f, 0.00880706f, 0.12894270f, 0.05036834f, -0.08551312f, -0.03994648f, -0.21660767f, 
    0.09011932f, -0.05382347f, -0.15763971f, -0.03702567f, 0.05718544f, 0.12037186f, 0.25935018f, 0.13403809f, 
    0.20891528f, -0.03607997f, -0.09784945f, 0.01355415f, 0.00345641f, -0.12423892f, 0.27917546f, 0.02778302f, 
    -0.38018391f, 0.13119663f, -0.08203086f, 0.27868313f, -0.27902976f, 0.00798167f, 0.13659063f, 0.15505932f, 
    0.08178269f, 0.09987095f, -0.02981984f, 0.03889770f, -0.01446482f, -0.06505512f, 0.00748897f, 0.23663214f, 
    0.06051658f, -0.04746011f, 0.08459567f, -0.26712987f, -0.00849105f, -0.03888558f, 0.08215862f, 0.04171164f, 
    0.10950893f, -0.11803497f, -0.17682756f, -0.08813129f, 0.08358742f, -0.13955244f, 0.16071273f, -0.19200064f, 
    0.34008682f, -0.08911946f, -0.19609450f, 0.15410146f, 0.08103420f, -0.32230228f, -0.04968095f, 0.10023341f, 
    0.04578993f, 0.01997899f, 0.11700716f, 0.05025578f, 0.30617529f, 0.08561497f, -0.00536242f, 0.03485491f, 
    0.06997327f, -0.03980096f, 0.04854638f, -0.00441509f, 0.12595013f, 0.05863430f, 0.45497727f, 0.39599040f, 
    -0.18945560f, 0.12727268f, 0.05529965f, -0.24804309f, 0.09428204f, -0.11412349f, -0.25169760f, 0.07548968f, 
    -0.02112263f, 0.04197567f, 0.06577809f, 0.06953888f, 0.23102529f, -0.08852129f, -0.10894315f, -0.12506333f, 
    0.01464653f, 0.02531765f, 0.02720052f, 0.02207096f, -0.03364829f, 0.00717943f, -0.01345491f, -0.01159966f, 
    0.03300034f, 0.04105290f, 0.02599820f, -0.03752286f, 0.00982985f, 0.02257327f, 0.03136706f, -0.04987803f, 
    -0.05731640f, -0.04620939f, 0.01412351f, -0.01360501f, 0.05232389f, -0.02368485f, 0.00656784f, -0.03122905f, 
    -0.00165979f, -0.00284945f, 0.03802600f, -0.05409029f, 0.01280170f, -0.04376245f, -0.03330193f, -0.01694571f, 
    -0.01222142f, 0.03751932f, 0.04664788f, -0.05039138f, 0.01849578f, -0.04001402f, -0.04449595f, -0.04509145f, 
    -0.03962453f, -0.05870584f, 0.03330360f, 0.01867770f, -0.05529497f, -0.03430032f, 0.03850385f, 0.00443362f, 
    -0.00592535f, 0.02512932f, 0.03517578f, 0.02299098f, -0.04426547f, 0.03257636f, 0.03742710f, 0.01416598f, 
    -0.04427844f, 0.00357994f, -0.02127179f, -0.01212800f, -0.05908510f, -0.03878164f, -0.05593865f, -0.01459687f, 
    -0.01725842f, -0.05555822f, -0.02628724f, 0.04741399f, -0.01926978f, -0.03125896f, 0.00252447f, 0.00957509f, 
    -0.04802140f, -0.05949562f, 0.00223466f, -0.06430276f, -0.04043385f, 0.01094122f, -0.02663055f, 0.00058040f, 
    -0.05210987f, 0.03433458f, -0.05559250f, -0.05667198f, -0.02905283f, -0.01185089f, 0.02353861f, 0.02752562f, 
    0.01163795f, -0.06745275f, -0.03695320f, 0.03088785f, 0.06511828f, -0.01470754f, -0.04635097f, 0.02505970f, 
    -0.05674182f, -0.02060429f, -0.01501095f, -0.07059560f, 0.03946014f, 0.02796534f, 0.00181539f, -0.04605392f, 
    -0.03276875f, 0.00801539f, -0.05953434f, -0.02731754f, -0.02086598f, -0.00900221f, 0.03267364f, 0.01614523f, 
    0.02016482f, 0.03907947f, -0.01830876f, 0.03054403f, 0.04888776f, -0.03220933f, 0.00846846f, 0.04935626f, 
    -0.04278634f, -0.00855409f, 0.01827408f, 0.01432613f, -0.03733578f, 0.05675940f, 0.01823094f, 0.05471824f, 
    -0.05568842f, 0.00838145f, 0.02509814f, 0.05067484f, -0.03381743f, -0.03021174f, -0.04597048f, -0.05405021f, 
    -0.00246191f, -0.02335546f, 0.04430334f, -0.00501260f, -0.06088778f, 0.00465859f, 0.01674048f, 0.02703465f, 
    0.01740443f, -0.06369855f, 0.01235987f, 0.01817451f, 0.01274794f, 0.02615021f, -0.02410341f, 0.00982477f, 
    0.04370569f, 0.05140722f, 0.02378994f, -0.02702316f, -0.01746379f, 0.00700324f, -0.00417008f, -0.01084570f, 
    -0.04721623f, -0.02023266f, 0.00194267f, -0.00702735f, 0.00651954f, 0.00560213f, 0.02807314f, -0.04261458f, 
    0.04746295f, -0.04412744f, -0.01031284f, 0.01155175f, 0.01085007f, -0.01099235f, 0.02374325f, -0.01361537f, 
    0.00052016f, -0.04165648f, -0.00344972f, -0.01556225f, 0.00621336f, 0.00406794f, 0.02270099f, -0.04141143f, 
    -0.00717408f, 0.00441494f, 0.02958873f, 0.00687990f, 0.03510381f, 0.00575949f, 0.01308224f, 0.02461657f, 
    -0.01618578f, 0.01094672f, 0.03024280f, -0.05780219f, 0.01769513f, 0.02272548f, -0.00397221f, 0.01011076f, 
    -0.01469237f, -0.00833777f, -0.02814697f, -0.03665621f, 0.04819169f, 0.00576103f, -0.04495067f, -0.06393564f, 
    -0.01072062f, -0.04979136f, -0.03750692f, -0.01980706f, 0.02154988f, -0.02000005f, -0.00223091f, -0.04330330f, 
    0.00053235f, 0.00862539f, -0.04786651f, -0.00738779f, 0.04635099f, -0.00993688f, -0.01456631f, 0.01992077f, 
    -0.02864944f, -0.01506463f, -0.06068537f, 0.01853959f, 0.03796491f, -0.04869987f, -0.01992131f, -0.02108919f, 
    -0.02307326f, -0.05499013f, -0.04242286f, -0.05913491f, -0.04669032f, 0.02169584f, -0.03540680f, 0.00986703f, 
    0.02854848f, -0.03675411f, 0.01519812f, -0.06487220f, 0.03878516f, -0.03187624f, -0.05425812f, 0.00779334f, 
    0.01842552f, -0.04720842f, 0.01306969f, -0.00784406f, -0.03068179f, 0.01083475f, 0.04344964f, 0.05166233f, 
    -0.01328434f, 0.03032923f, 0.04090859f, 0.04456028f, 0.01696550f, -0.00043914f, -0.04535633f, 0.04432096f, 
    -0.01106735f, -0.05746432f, -0.07381995f, 0.04336193f, 0.01202565f, -0.02155866f, -0.03660388f, -0.00642827f, 
    0.03965003f, 0.01488701f, -0.01148566f, 0.00532611f, -0.05587733f, -0.06439832f, -0.01717735f, 0.03933597f, 
    -0.03899965f, 0.01397778f, 0.01036060f, 0.04399542f, -0.04392814f, -0.04232123f, -0.05383877f, -0.03035219f, 
    0.01289592f, 0.02454809f, -0.00425269f, -0.05944019f, -0.05657759f, -0.01287571f, 0.00462328f, -0.05264809f, 
    -0.07209329f, 0.02738130f, 0.01953904f, -0.07118998f, -0.06993460f, -0.01625091f, -0.01548899f, 0.02757855f, 
    -0.05612378f, 0.04164254f, -0.03457337f, 0.05276269f, 0.00942462f, 0.02358850f, 0.00446999f, -0.03455866f, 
    0.02751295f, 0.04081469f, 0.03800708f, 0.02815788f, 0.02773942f, -0.05620109f, 0.00994532f, -0.02784741f, 
    0.01822101f, 0.01753430f, -0.00120840f, -0.04747706f, 0.03631170f, 0.04535293f, 0.00193884f, -0.02062162f, 
    0.03063441f, -0.02010123f, -0.06441631f, -0.00195132f, -0.06954020f, -0.01481892f, 0.01376785f, -0.05957409f, 
    0.01627937f, 0.01988202f, 0.04201259f, -0.04979286f, -0.03331248f, 0.01639961f, -0.06940819f, -0.06009953f, 
    -0.06374123f, 0.03902681f, 0.01246649f, -0.06517672f, -0.06597620f, 0.01726916f, -0.05422009f, 0.01627648f, 
    0.00512606f, 0.03611043f, -0.05571732f, 0.00844400f, -0.04814732f, 0.00765503f, 0.01577948f, -0.04355959f, 
    -0.01490206f, -0.03814597f, -0.02351232f, 0.03756732f, -0.01018598f, -0.04199235f, -0.00637537f, -0.03308853f, 
    0.01874321f, 0.02793987f, -0.04090007f, 0.02299395f, 0.00862809f, -0.05703530f, 0.02418900f, -0.01496103f, 
    -0.07075463f, -0.00642428f, -0.01212947f, -0.00642355f, 0.05396194f, -0.06236326f, -0.05433639f, 0.01518866f, 
    -0.02853084f, -0.01695937f, 0.01210984f, -0.05343466f, -0.04116986f, 0.02279351f, -0.02274816f, 0.00549970f, 
    0.03819682f, -0.02032147f, -0.00017279f, 0.02799834f, -0.05281309f, -0.03794072f, 0.04702597f, 0.02389809f, 
    0.05019834f, -0.03087038f, -0.05378096f, 0.04158677f, 0.01193477f, 0.00623291f, -0.05743993f, -0.01250298f, 
    0.03912420f, -0.06099727f, 0.00916338f, -0.00744521f, 0.00589799f, 0.01715933f, -0.00529906f, 0.03655204f, 
    0.04529390f, -0.05442214f, 0.00401012f, 0.04857983f, 0.03981381f, 0.01825422f, -0.06403557f, -0.01463204f, 
    0.06350668f, 0.03600303f, 0.01873873f, 0.02266673f, 0.04262611f, 0.01011504f, -0.00537988f, -0.04667316f, 
    -0.04798337f, 0.01212806f, 0.01370085f, 0.00505277f, -0.04929849f, 0.03887973f, -0.00452450f, -0.00428957f, 
    -0.01148782f, -0.02402068f, -0.01916184f, 0.01936682f, -0.04320033f, 0.00962195f, -0.06464627f, 0.04070947f, 
    -0.00622685f, 0.00369771f, -0.00922466f, 0.00729035f, 0.00522697f, -0.02419123f, 0.04007429f, 0.03529566f, 
    -0.06302393f, 0.01378730f, -0.03033324f, -0.00211813f, 0.02892659f, 0.05157590f, -0.06295308f, 0.02463324f, 
    0.01248244f, -0.05933122f, -0.01349381f, -0.03475189f, -0.04690243f, -0.00502439f, -0.07427466f, 0.00586171f, 
    -0.02453369f, 0.02661987f, 0.01332462f, -0.07188032f, -0.00117756f, -0.01816477f, -0.07066505f, -0.01038428f, 
    -0.05938515f, 0.03849600f, 0.00753924f, -0.01648098f, -0.02543774f, 0.01179176f, -0.06290986f, 0.00400974f, 
    0.01552575f, 0.01408065f, 0.03056796f, -0.04875348f, -0.06136898f, 0.03753066f, -0.03821655f, 0.02966207f, 
    -0.01534729f, -0.00844337f, -0.01445508f, 0.02237757f, 0.00678782f, 0.00765123f, 0.04068239f, -0.02393681f, 
    -0.03953825f, -0.00572136f, 0.00575173f, 0.01586018f, 0.02922734f, 0.01001447f, 0.00057334f, -0.03970001f, 
    -0.02331875f, 0.02833632f, -0.03611249f, 0.03968119f, 0.02742198f, -0.02648619f, 0.01733163f, 0.02811953f, 
    0.00120959f, -0.04936246f, -0.06637808f, -0.01326333f, -0.03320128f, 0.00647524f, 0.03869074f, -0.03253066f, 
    0.04093280f, 0.03426624f, -0.01949969f, 0.03414096f, -0.01065715f, -0.04073768f, -0.07384705f, -0.01596315f, 
    -0.01490032f, -0.02859107f, 0.04638179f, 0.00880613f, -0.06214784f, -0.01449732f, -0.02257438f, 0.00305704f, 
    -0.01641317f, 0.04267523f, -0.04119917f, 0.00716582f, -0.06143354f, 0.05097004f, 0.01252203f, 0.03426734f, 
    0.00632644f, -0.06308486f, 0.01405976f, -0.05230383f, 0.00368866f, -0.03169208f, -0.03569136f, -0.01680098f, 
    0.03043507f, 0.01403869f, 0.02317176f, -0.02889741f, -0.02154283f, 0.01544314f, 0.02886535f, -0.05670581f, 
    -0.04204442f, -0.02209656f, -0.01633274f, -0.02287676f, -0.04538299f, -0.05618943f, 0.04436499f, -0.02715787f, 
    -0.04631183f, 0.05701078f, -0.36905700f, 0.18450107f, 0.08089996f, -0.20222831f, -0.00330907f, -0.11254984f, 
    -0.30763093f, -0.23583707f, -0.60501826f, 0.18889067f, -0.18745771f, 0.16298254f, -0.00008946f, -0.20477000f, 
    0.08296572f, -0.30317235f, 0.65324765f, 0.11375885f, -0.24279767f, 0.13723236f, 0.06099256f, 0.10030835f, 
    0.03846329f, 0.00633466f, -0.05924476f, -0.55549043f, 0.13156661f, -0.12944554f, -0.02302108f, -0.01092297f, 
    -0.06912022f, 0.07696120f, -0.05592296f, 0.09903756f, -0.37540072f, -0.38545886f, 0.05558192f, 0.03030399f, 
    0.04061915f, -0.14054108f, 0.02955064f, 0.07440449f, -0.09806525f, -0.15244372f, -0.16971451f, -0.31970328f, 
    -0.03901846f, -0.02075540f, -0.18995371f, 0.06774643f, 0.05707400f, 0.08392879f, -0.23686235f, 0.24357449f, 
    -0.07114834f, 0.05038609f, 0.04524114f, -0.02298034f, -0.10055880f, 0.15168858f, -0.02635651f, -0.58975941f, 
    -0.23337740f, -0.04939667f, -0.14733230f, -0.03650667f, -0.04797602f, 0.13340326f, 0.04038534f, -0.02529409f, 
    -0.16395637f, -0.07169309f, 0.21663031f, 0.11474152f, 0.00643455f, 0.02367884f, -0.01967346f, -0.04291437f, 
    -0.21563739f, 0.75934422f, -0.04975017f, 0.08533692f, 0.15307011f, 0.18457618f, -0.01890626f, 0.00505364f, 
    -0.09099707f, -0.19387631f, 0.26401305f, 0.14381653f, 0.14022891f, -0.09196538f, 0.04626937f, 0.01865681f, 
    -0.03000059f, 0.00393801f, -0.03864564f, -0.46562609f, -0.09279850f, -0.21016097f, -0.00881912f, -0.13421659f, 
    0.12265421f, 0.21990816f, 0.09027245f, -0.03296690f, 0.10486102f, 0.24355373f, 0.07916951f, -0.23602350f, 
    0.14270990f, -0.26801431f, 0.08862932f, 0.02397547f, 0.11318685f, 0.15394080f, 0.35846534f, -0.04038805f, 
    0.26210275f, -0.05489587f, 0.03756062f, 0.13156649f, -0.03191660f, -0.01182123f, 0.04524802f, 0.12002162f, 
    0.18071760f, -0.06967347f, 0.02287324f, -0.04159939f, 0.20973073f, 0.20769751f, 0.05495112f, 0.01733584f, 
    -0.00529976f, -0.15452826f, -0.03710127f, -0.13555813f, -0.07758729f, -0.24279168f, -0.20413828f, -0.01820598f, 
    0.27255085f, -0.05816159f, 0.06717894f, -0.23924299f, 0.00549333f, -0.05750120f, -0.32067776f, -0.05754676f, 
    0.20060115f, 0.26894912f, 0.11664662f, 0.07568145f, -0.13863379f, -0.11431578f, 0.11808372f, -0.10833470f, 
    0.14362043f, 0.12930320f, -0.08319861f, 0.09239776f, 0.18368660f, -0.08136450f, -0.04848858f, 0.07451331f, 
    -0.08559583f, 0.02993506f, -0.04524528f, -0.10108227f, 0.15772019f, -0.09624556f, 0.08998287f, 0.03583215f, 
    0.04513021f, 0.16151111f, -0.09831908f, -0.29082289f, -0.14435059f, 0.07804398f, -0.02589750f, -0.29518366f, 
    -0.16454187f, 0.01884828f, -0.05737632f, 0.10685398f, -0.17186338f, 0.14140242f, -0.10440696f, -0.00446779f, 
    0.12511081f, -0.19149446f, -0.13176411f, 0.01356971f, 0.12277066f, 0.14273882f, 0.20672850f, -0.58018559f, 
    -0.06031208f, -0.21139295f, -0.15016520f, 0.05255182f, 0.16016090f, -0.01649885f, 0.08409507f, -0.15295556f, 
    0.02438408f, 0.20055954f, -0.11382874f, -0.02321223f, -0.11461826f, 0.12704726f, -0.01527821f, 0.06329082f, 
    0.23205453f, 0.05947148f, -0.24841703f, -0.24066202f, 0.10669066f, -0.13268512f, 0.40621528f, 0.15911201f, 
    0.18934093f, -0.28985864f, -0.21932006f, -0.47087145f, 0.10725365f, -0.02400384f, 0.22734267f, -0.04780631f, 
    -0.08582213f, -0.08063589f, 0.78421068f, -0.14024718f, -0.20920987f, 0.05089047f, 0.15655507f, -0.05633306f, 
    -0.02946483f, -0.32110801f, 0.11522688f, 0.07329793f, -0.19110407f, 0.22888017f, -0.10865020f, -0.09557991f, 
    0.04986446f, -0.11456464f, 0.06967001f, 0.24720955f, -0.01956316f, -0.06637861f, 0.59554374f, 0.04901555f, 
    0.10428804f, 0.12881236f, -0.21268828f, 0.08391991f, 0.06537112f, 0.08498456f, 0.16603854f, 0.11448016f, 
    0.13449138f, -0.04985875f, -0.01142094f, -0.08383783f, -0.01564477f, 0.08078939f, 0.22859670f, 0.49697441f, 
    -0.68394059f, 0.02126365f, -0.01174950f, -0.02641088f, 0.01240815f, 0.01713242f, -0.01625123f, 0.03478879f, 
    0.03187072f, 0.00640228f, -0.11934689f, -0.02172352f, 0.13979276f, -0.08075316f, 0.31225452f, 0.14814198f, 
    0.07376014f, 0.25613496f, -0.07358409f, 0.02629352f, -0.03156820f, -0.13997813f, -0.08955816f, 0.20208830f, 
    0.08838768f, 0.55357444f, 0.47672382f, -0.20014584f, -0.03650326f, -0.26244533f, 0.08353129f, 0.08441506f, 
    0.04135885f, 0.01743999f, 0.21050528f, -0.00106794f, -0.12745206f, -0.07995950f, -0.04668158f, -0.01401320f, 
    -0.09631637f, 0.03880926f, -0.18503453f, 0.24739350f, 0.00342700f, -0.09751606f, 0.15687554f, 0.10977802f, 
    -0.10829765f, 0.04152321f, 0.17967720f, 0.03922042f, 0.23889628f, 0.18615440f, -0.26447189f, -0.04941637f, 
    -0.12288893f, -0.07585132f, -0.14269552f, -0.10052020f, 0.04585583f, 0.26344830f, 0.18989116f, 0.29136840f, 
    -0.27073532f, 0.00999651f, -0.00231013f, 0.06458107f, -0.15025567f, 0.19767332f, 0.22580320f, 0.19802582f, 
    -0.30966839f, -0.11575248f, -0.00443817f, 0.11414573f, 0.05033324f, 0.07271840f, -0.21610424f, -0.33564162f, 
    0.48806408f, -0.07666380f, -0.02205136f, -0.28665185f, -0.05648796f, -0.04175575f, 0.09196541f, 0.07078369f, 
    -0.29165158f, 0.25669631f, 0.04768575f, -0.19872296f, -0.12174409f, 0.13309678f, 0.01257758f, 0.07790090f, 
    0.00773855f, -0.27995408f, 0.43163967f, 0.31623968f, -0.12829667f, 0.02805887f, 0.04169605f, -0.05243823f, 
    0.00434855f, 0.34709689f, 0.57617390f, -0.54027534f, 0.08487418f, -0.03006642f, 0.10946214f, -0.06747777f, 
    -0.07487427f, 0.07455446f, 0.00009587f, -0.16411330f, 0.40944541f, -0.10549323f, -0.05451830f, -0.06887250f, 
    -0.12080674f, -0.01827319f, 0.08745465f, -0.11723648f, -0.24883564f, 0.01633859f, 0.12315772f, 0.12191807f, 
    0.02396535f, 0.10135558f, -0.19547945f, -0.11241625f, 0.08719158f, -0.05604840f, 0.27937478f, 0.00191764f, 
    -0.18519221f, -0.04454354f, -0.06552450f, -0.15638062f, 0.07801493f, -0.00827625f, -0.01746323f, -0.24186881f, 
    0.01774837f, -0.19303392f, -0.02251931f, 0.10825527f, -0.06884956f, 0.14798394f, -0.04710054f, -0.18403722f, 
    -0.85328203f, 0.02980940f, 0.03583959f, 0.26475656f, 0.01623059f, -0.07604566f, -0.19513260f, -0.06985631f, 
    -0.13698377f, -0.66530991f, 0.31967720f, 0.12191050f, 0.00706627f, 0.08151716f, -0.02706646f, -0.30328518f, 
    0.02286302f, 0.13806641f, -0.41218910f, -0.23019101f, 0.08623082f, 0.01525541f, 0.11106901f, -0.10211293f, 
    0.08895358f, -0.00245237f, 0.30986178f, -0.56657434f, -0.03096027f, -0.01624941f, 0.03879878f, -0.04376549f, 
    -0.12675270f, 0.02864276f, -0.15308623f, -0.06199779f, -0.12219518f, -0.09368495f, -0.04238377f, -0.00543900f, 
    0.18248956f, -0.03031629f, 0.33744991f, 0.06046343f, 0.40553430f, -0.15900524f, 0.06911474f, 0.13543539f, 
    0.13336319f, -0.01045013f, 0.18008640f, 0.23938584f, 0.03175078f, 0.16683617f, 0.33026472f, -0.15122350f, 
    -0.15440419f, 0.09048043f, -0.20419177f, -0.06942549f, 0.18431753f, 0.21596153f, -0.34196472f, -0.21607342f, 
    -0.17367658f, -0.23713443f, 0.30832711f, -0.19637010f, -0.04619836f, -0.04178683f, -0.04491859f, -0.09207439f, 
    -0.04938722f, 0.13290098f, 0.06335177f, 0.16556562f, -0.13919185f, 0.05915280f, 0.12402036f, 0.16667232f, 
    0.07097390f, 0.28063881f, -0.30564237f, -0.07278464f, -0.05665758f, -0.02533307f, -0.06333882f, 0.02310438f, 
    -0.09643962f, -0.01805265f, 0.09472930f, 0.01332274f, -0.00326616f, -0.24516881f, -0.03220798f, 0.06448915f, 
    0.00913663f, -0.02409578f, 0.25612426f, 0.02472555f, -0.21564734f, -0.09155793f, -0.07003668f, -0.11830380f, 
    -0.12578712f, -0.04437461f, 0.12535037f, 0.15268598f, -0.24916582f, -0.05343697f, -0.05725065f, -0.04400361f, 
    0.18509857f, 0.19196758f, -0.21358453f, 0.15482453f, 0.40034533f, -0.09263267f, 0.12232003f, -0.01093946f, 
    -0.00436350f, -0.04837418f, 0.08723932f, 0.07728071f, 0.31253499f, -0.46726856f, -0.19053027f, -0.00327230f, 
    -0.02853067f, 0.01546977f, 0.03197574f, -0.00907732f, -0.08500703f, 0.16815689f, -0.01269432f, 0.25943211f, 
    -0.21828477f, 0.01731954f, -0.05554928f, 0.03853470f, 0.05091941f, -0.01756981f, 0.22807118f, 0.22829680f, 
    0.04474527f, -0.10129364f, 0.07150279f, 0.04829843f, -0.04034957f, 0.03931127f, 0.02294082f, 0.20261203f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03526774f, 0.31837878f, -0.00641896f, -0.02484372f, -0.03158601f, 0.11466182f, 0.10716984f, -0.02379612f, 
    0.09494171f, 0.00209032f, -0.06437674f, -0.03727648f, -0.02109034f, -0.03318675f, -0.27578628f, 0.14938934f, 
    0.18868297f, -0.06725334f, 0.05251619f, -0.02502636f, 0.12724493f, 0.04177634f, 0.05011311f, 0.23354778f, 
    -0.02416234f, 0.13507518f, -0.00395312f, 0.01447640f, 0.02428454f, 0.04610170f, 0.06535331f, -0.06349652f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.39926443f, -0.31120551f, -0.01675965f, -0.09836390f, 0.16592260f, -0.82937998f, 0.08561281f, 0.12070830f, 
    -0.27604944f, 0.04615921f, 0.08770167f, -0.07956510f, 0.11049102f, 0.10414408f, 0.04755935f, -0.11025439f, 
    -0.01309156f, -0.44416407f, 0.07413466f, -0.43161008f, -0.32724744f, -0.10451650f, 0.07517785f, 0.62783712f, 
    -0.14749141f, 0.29840973f, -0.09977653f, 0.16910096f, -0.15134963f, 0.02314267f, 0.91081345f, -0.03774578f, 
    0.68662077f, -0.01784555f, 0.11522093f, -0.00381806f, 0.09528553f, -0.32327011f, -0.26527607f, -0.02338233f, 
    0.06921246f, -0.13002010f, 0.07673755f, 0.04776987f, -0.46085489f, 0.01483245f, 0.13417007f, -0.08902001f, 
    -0.04344182f, 0.39446488f, 0.14220551f, 0.54776257f, -0.31642476f, 0.09030589f, 0.05869864f, 0.40618828f, 
    -0.10189962f, -0.38156229f, 0.09131610f, 0.31316954f, -0.14775528f, 0.03902923f, 0.20479801f, -0.37057287f, 
    0.29194105f, -0.26596493f, -0.11244830f, -0.15384746f, 0.02327413f, 0.14141907f, -0.10887413f, 0.10989948f, 
    -0.56292963f, -0.12852591f, 0.12588373f, -0.01888443f, 0.29280651f, -0.12837814f, 0.23787622f, -0.15414977f, 
    -0.76970994f, -0.53784591f, -0.08386998f, 0.39103770f, 0.06046815f, 0.03358387f, -0.13306132f, -0.50153738f, 
    0.81631666f, -0.23626214f, -0.00343127f, 0.32816479f, 0.17063376f, 0.07340890f, -0.36678299f, -0.63119704f, 
    0.12209157f, -0.26239052f, -0.05404368f, -0.16110356f, 0.02458093f, 0.29064941f, -0.36971477f, 0.08624876f, 
    -0.58813030f, -0.14263168f, 0.10649794f, 0.17057763f, 0.41588399f, -0.06506529f, -0.61902124f, 0.56029296f, 
    0.27850646f, 0.35113317f, 0.00958591f, -0.25733560f, -0.20578749f, -0.04645606f, 0.15402484f, -0.62856305f, 
    0.06529091f, 0.22699623f, 0.07254046f, -0.55819744f, -0.01759734f, 0.02369690f, -0.12227412f, 0.64963531f, 
    -0.24402651f, -0.02335985f, -0.08096295f, -0.06656304f, -0.05125581f, 0.08484153f, 0.38126239f, -0.00792763f, 
    0.09040207f, -0.12134708f, 0.07146586f, 0.12525895f, 0.38274875f, -0.06181166f, 0.16731539f, 0.47931880f, 
    -0.05288626f, -0.44694814f, 0.17061971f, -0.58989727f, 0.00686654f, 0.05047997f, 0.16015896f, 0.69336563f, 
    -0.03462546f, 0.04418733f, -0.00634831f, -0.42356369f, -0.08030669f, -0.08745920f, -0.77016079f, -0.12013739f, 
    -0.26624662f, 0.60451519f, 0.15780073f, 0.04881348f, 0.15809311f, -0.21413648f, 0.18528359f, -0.12362575f, 
    0.44959113f, 0.16166984f, 0.13067316f, 0.16428110f, -0.56973624f, 0.05741294f, -0.61339563f, -0.10315042f, 
    -0.14665501f, 0.22900143f, 0.04757314f, -0.76615459f, 0.06074056f, 0.03963026f, 0.10884034f, -0.01672517f, 
    -0.37767300f, -0.23969214f, -0.13034244f, 0.29094738f, 0.10126904f, -0.15210830f, -0.15739349f, -0.26391706f, 
    -0.95865405f, 0.59139776f, 0.16196732f, -0.15355739f, 0.07762719f, -0.20605968f, -0.07674160f, 0.11934133f, 
    -0.82411957f, -0.13173918f, -0.14642957f, 0.04137348f, -0.23402341f, 0.10093734f, -0.20982522f, 0.01684785f, 
    -0.36385864f, -0.11907636f, -0.05405769f, 0.82255173f, -0.28290144f, -0.01538792f, 0.07930581f, -0.31099862f, 
    0.03869161f, 0.54334825f, -0.00384013f, -0.24901068f, 0.06904285f, 0.09561189f, -0.04985474f, -0.11721557f, 
    -0.03228245f, -0.17086805f, 0.03861782f, -0.03576645f, -0.01573665f, -0.21020806f, -0.11806874f, -0.11335890f, 
    0.29498354f, 0.04914091f, 0.06396002f, 0.11407273f, -0.10410734f, -0.14363247f, 0.99666864f, -0.07649478f, 
    0.01532658f, 0.09055509f, -0.00947210f, -0.58189136f, 0.18856871f, -0.08339405f, -0.05277907f, -0.27950338f, 
    -0.13441885f, -0.26920000f, -0.12253506f, -0.37742478f, -0.06638250f, -0.12951986f, -0.08731838f, 0.20378746f, 
    0.83095586f, -0.26887757f, 0.04230188f, -0.03462010f, 0.12795711f, -0.45741370f, -0.38440886f, 0.16204435f, 
    0.78302401f, 0.16125366f, 0.01866843f, 0.00442967f, 0.39877263f, 0.06223639f, -0.32951251f, -0.58112264f, 
    -0.52653152f, 0.02489000f, -0.05284482f, 0.34689063f, -0.29841861f, -0.10779957f, -0.00043601f, -0.26946071f, 
    -0.06832877f, -0.09989133f, 0.00925924f, 0.16062053f, 0.14911772f, -0.11807645f, -0.32465366f, 0.46596220f, 
    -0.32150319f, 0.00307703f, 0.03072622f, 0.05910567f, -0.05708077f, 0.65737909f, 0.86860234f, -0.10273399f, 
    -0.00236985f, -0.16715068f, 0.12184025f, 0.11000655f, 0.23884259f, -0.01763844f, -0.07518559f, -0.70445108f, 
    -0.24668616f, -0.20031101f, 0.14716528f, 0.06349802f, 0.26479471f, 0.07409208f, -0.12450124f, -0.56633842f, 
    -0.07237345f, 0.07271551f, -0.02362699f, -0.51919967f, -0.16337685f, 0.00482507f, 0.44397101f, -0.31526104f, 
    -0.09418142f, -0.20748499f, -0.15753397f, -0.03411011f, 0.02222015f, 0.17381021f, -0.60352212f, -0.11160317f, 
    0.27405190f, 0.13043307f, -0.14839675f, -0.14865179f, -0.05577195f, 0.02929758f, -0.49396548f, -0.57381308f, 
    0.89811325f, -0.14692308f, 0.06073085f, -0.26429564f, -0.18274486f, 0.03587107f, 0.03516656f, -0.37444630f, 
    0.58105797f, 0.20480815f, -0.07494941f, 0.43108138f, 0.15932707f, -0.02936823f, -0.64762849f, -0.31087333f, 
    -0.62166601f, -0.16574822f, 0.08557936f, -0.15645184f, 0.02616905f, 0.49348176f, -0.57625794f, 0.11894673f, 
    -0.09739636f, 0.09623913f, 0.14736097f, -0.11250175f, -0.63135904f, -0.14531732f, -0.47491246f, 0.56772792f, 
    -0.57022083f, -0.39830551f, 0.14919521f, 0.19213991f, 0.68477082f, -0.02472806f, 0.16591071f, -0.54101890f, 
    0.14228866f, 0.26362365f, -0.06050428f, 0.05079283f, 0.07658646f, 0.14579244f, -0.54848570f, 0.38514563f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19489829f, -0.15820242f, 0.00158222f, -0.03603246f, -0.08947712f, 0.28800038f, -0.00111011f, -0.29451662f, 
    -0.52826875f, -0.12629102f, 0.06147299f, 0.13659957f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
