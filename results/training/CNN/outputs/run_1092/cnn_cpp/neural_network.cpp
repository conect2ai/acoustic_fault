#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.07734723f, 0.10310700f, -0.30540854f, 0.22441116f, 0.54549515f, 0.03332197f, 0.14029096f, -0.58820033f, 
    -0.20098384f, 0.11563788f, 0.12612912f, -0.60159761f, -0.58691913f, -0.43850070f, -0.07126450f, -0.32196021f, 
    -0.66302723f, -0.23718169f, -0.80146790f, -0.66043085f, -0.42191696f, 0.99965781f, 0.48187670f, 0.17252938f, 
    -0.17851111f, -0.35823584f, 0.06462867f, 0.41317973f, -0.00956835f, -0.63915628f, 0.06333634f, -0.40224278f, 
    -0.68131495f, -0.20748320f, -0.26429829f, -0.08045030f, 0.07471574f, 0.04613892f, 0.20230968f, -0.23575087f, 
    -0.07280059f, 0.76154703f, 0.27430388f, -0.64371312f, -0.37324354f, -0.08390290f, 1.02565515f, -0.74714237f, 
    -0.36824936f, 0.20727913f, -0.14755403f, 0.27614245f, 0.20317188f, 0.51225710f, -0.44640344f, -0.64302105f, 
    -0.53399247f, 0.13073784f, -0.21460518f, 0.18928032f, 0.25234112f, 0.22201803f, -0.63614118f, 1.10853779f, 
    -0.75149274f, 0.05780072f, 0.50208437f, 0.22088650f, 0.18560572f, -0.14638554f, -0.10140419f, 0.10192306f, 
    -0.42530161f, -0.09205816f, 0.04213196f, -0.57792681f, -0.93478477f, -0.62979323f, 0.45910275f, 0.58676779f, 
    0.62935793f, -0.00478624f, 0.46416149f, 0.72072196f, 0.36278155f, -0.23259069f, -0.04940513f, -0.40404204f, 
    -0.53895223f, -0.45107138f, 1.02684033f, 0.51154780f, 0.91625404f, -0.82506305f, -0.20917407f, 0.35622033f, 
    0.30588534f, 0.27216384f, 0.07682701f, -0.98878306f, -0.43632418f, 0.13387285f, -0.09765441f, -0.37199777f, 
    -0.55259222f, -0.36913759f, 0.16179781f, -0.27946025f, -0.84192562f, 0.82211876f, -0.37270007f, -0.20082305f, 
    -0.26636633f, -0.58364910f, 0.11143340f, -0.04561514f, -0.25218597f, -0.65267408f, 0.11208899f, -0.06944873f, 
    0.88328797f, 0.48419210f, 0.54229021f, 0.20574349f, 0.45726308f, 0.18347232f, 0.23038486f, 0.43524382f, 
    0.10763066f, 0.15524071f, 0.30691174f, -0.11702813f, 0.56591451f, 0.01868360f, -0.38987753f, -0.24844922f, 
    -0.38065875f, 0.92480588f, 0.53241962f, -0.34719706f, -0.41701260f, -0.20724407f, -0.05393325f, 0.16172527f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.43895710f, -0.35952774f, 0.02840471f, 0.27209231f, 0.18749666f, 0.25653094f, 0.50260150f, 0.42626068f, 
    0.00227185f, 0.25551116f, 0.32975379f, -0.53252178f, 0.38391241f, -0.16489473f, 0.61225688f, -0.12951499f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.37176198f, 0.13574256f, 0.32696810f, 0.21000075f, 0.09626199f, 0.05289423f, 0.03069935f, -0.04740641f, 
    0.15717900f, 0.11324804f, -0.20573753f, 0.17910174f, 0.13254964f, 0.07741764f, -0.20510350f, -0.08467023f, 
    -0.20921180f, 0.30630037f, -0.02206604f, 0.26844400f, 0.40339747f, -0.01189313f, 0.10542844f, -0.15636732f, 
    0.20335342f, 0.02327671f, -0.02757322f, 0.01200345f, -0.30159453f, 0.46895760f, -0.22450860f, 0.16699433f, 
    -0.04994988f, 0.19963393f, 0.19930360f, -0.03803952f, -0.15614098f, 0.24340546f, 0.04219463f, 0.05690463f, 
    -0.25820750f, -0.11998480f, 0.18356895f, -0.13958251f, 0.00152087f, -0.86652201f, -0.08058777f, 0.17998822f, 
    0.34172797f, 0.47587633f, -0.11065675f, -0.05559245f, -0.01874104f, -0.00089319f, 0.25204211f, 0.17777814f, 
    0.12518585f, 0.01945144f, 0.10679185f, 0.22141762f, 0.10820849f, 0.15028575f, -0.02456355f, 0.41724610f, 
    -0.10525145f, -0.05889731f, 0.00916768f, 0.03200275f, 0.42702207f, -0.05069432f, 0.14017110f, 0.09692070f, 
    -0.12414823f, -0.18460464f, 0.00569263f, -0.01653752f, -0.15744305f, 0.00797443f, 0.13197950f, 0.18570249f, 
    0.19268027f, -0.07517311f, 0.15234233f, -0.18237688f, -0.03658476f, 0.08644994f, -0.07718543f, 0.12156302f, 
    -0.01878636f, -0.05731778f, -0.71121985f, -0.11107127f, -0.11951311f, -0.09919192f, 0.05737719f, -0.06875789f, 
    0.06108392f, 0.01501112f, 0.14497568f, 0.64649379f, -0.29666236f, 0.54596442f, 0.01765534f, -0.19155544f, 
    -0.10625103f, -0.00910764f, 0.03352395f, -0.04223942f, 0.01137201f, 0.01773172f, 0.15432659f, -0.04773251f, 
    0.34983185f, 0.11040261f, -0.17651261f, -0.08414765f, 0.05995165f, -0.04305296f, -0.09175998f, 0.06742671f, 
    -0.31566969f, -0.03105334f, 0.06165335f, -0.04718210f, 0.03258548f, -0.06287634f, -0.30844957f, -0.01905994f, 
    -0.04477103f, -0.03525557f, 0.16410190f, 0.13904645f, 0.15448551f, -0.08681256f, -0.01823728f, -0.00859095f, 
    0.29528651f, -0.05508713f, -0.35999697f, 0.37440756f, -0.29141426f, -0.10949578f, 0.22280411f, 0.04298015f, 
    -0.20538875f, 0.01808003f, 0.18593182f, -0.23299785f, 0.14270979f, 0.02268004f, -0.03784703f, -0.06338330f, 
    0.01018721f, -0.61802268f, -0.13537757f, -0.07429364f, 0.02951089f, -0.19529817f, 0.06666334f, 0.09005113f, 
    0.08879357f, 0.07753885f, 0.15724666f, -0.70900685f, -0.76489222f, -0.16765760f, -0.26127228f, -0.29547155f, 
    -0.01023363f, -0.15055795f, -0.13702770f, -0.19282781f, -0.33072054f, 0.29957214f, 0.04098804f, -0.10826042f, 
    0.06130188f, -0.04922021f, -0.07060698f, -0.02354019f, -0.18353993f, 0.19045515f, 0.44664031f, 0.07910123f, 
    -0.06266776f, -0.11921519f, -0.22787632f, -0.00294978f, -0.02581650f, 0.08671007f, 0.05440257f, 0.03046281f, 
    0.00296911f, 0.09238832f, 0.14076193f, -0.19738221f, 0.15841673f, 0.02749550f, 0.39719141f, -0.30048701f, 
    -0.82108659f, -0.03502049f, -0.22384338f, -0.02527505f, -0.00271722f, -0.02303375f, 0.19570601f, 0.65029985f, 
    0.12593397f, 0.07961567f, -0.25526500f, -0.10359780f, -0.01364192f, 0.09431551f, 0.23591743f, -0.02916619f, 
    -0.04334918f, 0.14223537f, 0.12800492f, 0.01614724f, 0.03371701f, 0.03841199f, 0.06364242f, 0.07859980f, 
    0.36168829f, 0.17858416f, 0.07586920f, 0.00119988f, -0.06230871f, 0.03611289f, -0.03038689f, 0.15705279f, 
    -0.05154017f, 0.21563570f, 0.23697509f, 0.12977609f, 0.12824565f, -0.23317426f, 0.11302130f, -0.01341451f, 
    -0.01692554f, 0.07320580f, 0.16639836f, 0.36895856f, 0.14466168f, 0.76106250f, -0.09364238f, -0.19114341f, 
    -0.13243414f, -0.02151307f, 0.14497209f, 0.03034515f, -0.46066639f, -0.50027436f, 0.33157709f, 0.12049410f, 
    0.15512182f, 0.16414045f, -0.10453570f, 0.12420781f, -0.20057067f, 0.25321490f, 0.14993036f, -0.04292655f, 
    -0.21053874f, -0.01815195f, -0.16661398f, -0.00683885f, 0.01038759f, 0.04745006f, 0.35757247f, 0.05837372f, 
    0.41704309f, -0.05981451f, -0.13404104f, -0.12811384f, 0.14710507f, -0.01325351f, 0.09900026f, -0.20405166f, 
    -0.07990746f, 0.15897924f, -0.31046456f, 0.27466404f, 0.06090011f, -0.00582740f, -0.05496317f, -0.04979981f, 
    0.03058773f, -0.06190527f, 0.01590499f, -0.15285130f, 0.26200798f, 0.02968363f, 0.19100590f, -0.01656343f, 
    0.30484822f, 0.08418138f, -0.19099578f, 0.23675330f, 0.00541583f, -0.12316889f, -0.14694946f, -0.11901122f, 
    0.10830168f, 0.24371062f, -0.24308124f, -0.00143247f, -0.14788333f, -0.25042436f, -0.05232087f, 0.11648950f, 
    -0.17810002f, -0.21960784f, 0.10739756f, 0.15901799f, 0.16155286f, 0.44400883f, -0.00111152f, 0.11440926f, 
    -0.21993198f, 0.06150196f, 0.01844516f, 0.17610732f, -0.14801285f, -0.00375718f, -0.20157926f, -0.02687839f, 
    -0.27744085f, -0.02731076f, 0.12207352f, 0.10635285f, 0.12135661f, -0.01681744f, -0.04159228f, 0.38422245f, 
    0.01692034f, 0.05558760f, -0.07712560f, -0.06188621f, 0.04582166f, -0.16978458f, 0.23555359f, -0.14207782f, 
    0.17628440f, -0.06557238f, -0.14434327f, 0.02300817f, -0.17084254f, -0.02709378f, 0.12855679f, -0.37163186f, 
    -0.00233850f, 0.08790244f, 0.14612234f, -0.05274601f, 0.33558327f, 0.12125438f, -0.15147471f, 0.11113953f, 
    -0.39866325f, -0.00440972f, -0.04110742f, 0.40526459f, 0.29511970f, 0.06698620f, 0.26063183f, 0.10105508f, 
    -0.36400193f, 0.09282601f, 0.07949690f, 0.24932127f, -0.27555081f, -0.35182190f, -0.04517398f, 0.06483796f, 
    0.19305708f, 0.06639115f, 0.33528006f, 0.04266654f, -0.11830499f, 0.08298350f, -0.04572278f, 0.12039125f, 
    -0.13103217f, 0.13248692f, -0.13411081f, 0.04948062f, 0.08392214f, -0.10511994f, -0.14871626f, -0.27112234f, 
    -0.00771025f, -0.05081959f, 0.12657814f, 0.30434561f, 0.16202742f, -0.12606405f, 0.19517951f, 0.06165815f, 
    -0.07751434f, 0.03774919f, -0.17455903f, -0.07156064f, 0.30137101f, -0.02171081f, 0.30401403f, 0.16775565f, 
    -0.16110696f, 0.11737899f, -0.15044446f, 0.05227682f, 0.00717554f, -0.21486594f, -0.14187907f, 0.01987273f, 
    -0.29407135f, -0.11686112f, 0.07494796f, 0.14776601f, 0.10329940f, 0.37401262f, 0.07466269f, -0.41458672f, 
    0.06219262f, -0.28803879f, -0.03121404f, 0.01546851f, -0.10818012f, 0.06266385f, -0.20435047f, 0.07544315f, 
    -0.01154202f, 0.06431065f, 0.15276068f, 0.07609104f, -0.04886957f, 0.06327630f, -0.03693862f, 0.22563632f, 
    0.24585010f, -0.59254956f, -0.36220878f, -0.37961474f, -0.16189295f, -0.04723312f, 0.01530568f, 0.18459560f, 
    -0.03669011f, -0.14273368f, -0.35909188f, -0.21102856f, 0.42272201f, -0.01020245f, 0.20121454f, 0.15845633f, 
    -0.09890260f, 0.09190339f, 0.06995400f, -0.26239955f, -0.09299317f, -0.32261285f, -0.03327683f, 0.13482480f, 
    -0.13761838f, 0.03830041f, 0.02658061f, 0.10752407f, 0.08672297f, 0.20147707f, -0.08971704f, 0.08255905f, 
    0.06292221f, 0.13623454f, -0.00074114f, 0.19979838f, 0.23352896f, 0.28380501f, -0.43604383f, -0.36860076f, 
    0.01847772f, -0.06584901f, 0.09421287f, -0.07287019f, -0.30538687f, -0.17176278f, -0.15123692f, -0.21133868f, 
    0.13882875f, 0.02058795f, 0.12812248f, 0.16983239f, 0.08062612f, 0.04400171f, 0.19702508f, -0.09803752f, 
    0.36771891f, 0.06792819f, -0.08011471f, 0.02759255f, 0.21296211f, 0.08696037f, -0.06214396f, -0.09610482f, 
    -0.62465715f, -0.25104392f, -0.39238775f, -0.11453631f, 0.11701024f, -0.27495542f, 0.01828755f, 0.01155124f, 
    -0.06839406f, 0.13413718f, 0.30129170f, 0.08243551f, -0.05215756f, -0.00479993f, -0.12433097f, -0.03988213f, 
    -0.01730642f, 0.20105538f, 0.58223057f, -0.07431669f, -0.23692612f, -0.04372953f, -0.05749143f, 0.02890858f, 
    -0.01116151f, 0.08608723f, -0.05119187f, 0.60350221f, 0.14954190f, -0.08107775f, 0.01679573f, -0.01508256f, 
    -0.00277313f, -0.11613712f, -0.05638788f, -0.03200325f, -0.21157636f, -0.23077711f, -0.40428609f, 0.05584035f, 
    0.13085110f, -0.10246596f, 0.12025685f, 0.09211846f, 0.00632670f, -0.39861241f, -0.14211908f, -0.01531485f, 
    -0.19407809f, -0.12017639f, 0.04510918f, 0.19324625f, -0.13826856f, -0.05125197f, 0.20381491f, 0.06883680f, 
    0.20505415f, -0.00410608f, 0.04562337f, -0.04031793f, -0.00444233f, 0.06538705f, 0.21541961f, -0.12049235f, 
    -0.22667712f, -0.45689976f, 0.01265953f, -0.08016547f, -0.23374984f, 0.24974746f, -0.10287871f, 0.04482753f, 
    0.14806108f, 0.43360952f, -0.09102050f, 0.21478131f, 0.22421165f, 0.13150145f, 0.53195322f, 0.15410011f, 
    0.36677679f, 0.29836208f, -0.12999484f, 0.11487576f, -0.05346590f, 0.14900194f, 0.12550201f, 0.06072073f, 
    -0.05986780f, -0.13438097f, -0.59050030f, 0.04076171f, -0.27658948f, 0.13112767f, 0.00457517f, -0.06356099f, 
    0.05745855f, -0.04533926f, 0.05045934f, 0.41334167f, 0.24712060f, 0.39187330f, 0.01738799f, 0.25786987f, 
    0.07946371f, 0.08344436f, 0.14455819f, -0.00374313f, -0.02021644f, -0.17376277f, -0.17816384f, 0.10935310f, 
    0.08273548f, 0.12346764f, 0.48022735f, 0.21394475f, 0.39386821f, 0.20855168f, 0.06751280f, -0.01378064f, 
    -0.17364867f, -0.00157092f, -0.07465021f, 0.14529604f, 0.10561321f, 0.07743999f, -0.30843106f, 0.15144902f, 
    0.30411413f, 0.06535508f, 0.13651820f, 0.16085964f, 0.12747888f, 0.22785760f, 0.27024397f, 0.12893130f, 
    -0.03616895f, -0.07076766f, -0.03418620f, 0.33975142f, -0.02413273f, 0.23615426f, 0.18245032f, 0.32071128f, 
    0.24063711f, -0.02548989f, 0.32624176f, 0.02206988f, -0.08304755f, -0.33184564f, -0.23489723f, -0.14101107f, 
    -0.12923720f, 0.02412149f, 0.12022897f, 0.35584602f, -0.13664111f, 0.17837016f, 0.21687031f, -0.06994439f, 
    0.07487515f, 0.03330451f, 0.16828826f, -0.08718032f, -0.44753668f, -0.06360605f, -0.05194457f, -0.05515324f, 
    -0.20923001f, 0.20670256f, 0.01975765f, -0.24183968f, 0.31105673f, 0.29495326f, 0.28850868f, 0.04337842f, 
    0.05238397f, 0.03499766f, 0.15755519f, -0.32296735f, 0.19253498f, 0.34400827f, 0.52279681f, 0.22932337f, 
    0.27115369f, 0.40575477f, 0.03307485f, -0.17381138f, 0.50334328f, -0.17822032f, -0.30480552f, -0.32328489f, 
    -0.21653730f, -0.42566776f, 0.05187706f, -0.14675947f, 0.05361116f, -0.15906978f, 0.03704105f, 0.18474816f, 
    0.01831285f, 0.27042723f, -0.06934829f, 0.23720598f, 0.27227122f, 0.03431734f, 0.19092658f, -0.00430071f, 
    -0.34991425f, 0.38870689f, -0.28429952f, 0.03932465f, -0.15855007f, -0.10417103f, -0.15029356f, -0.20780095f, 
    -0.02759671f, -0.28029317f, -0.14906198f, 0.06059201f, -0.09087641f, 0.00531979f, -0.05250657f, 0.01910724f, 
    -0.00573641f, -0.07624725f, 0.31722191f, 0.23234273f, -0.10596663f, 0.10175689f, -0.04886500f, 0.07578780f, 
    -0.04842297f, -0.11659239f, -0.05226155f, -0.33082289f, 0.06437840f, -0.07657348f, -0.03581121f, 0.08024801f, 
    -0.00002807f, 0.06187554f, -0.03198438f, -0.03518266f, 0.14067186f, 0.26396236f, -0.02412561f, 0.07354804f, 
    -0.08825777f, 0.01166023f, 0.05369655f, -0.06945877f, -0.38231725f, -0.15865691f, -0.13415922f, -0.12875555f, 
    0.05013860f, 0.15715931f, -0.07206642f, -0.31360441f, -0.06285969f, 0.00657127f, -0.07076064f, -0.72377026f, 
    -0.07512343f, 0.06654625f, 0.02800836f, 0.29782194f, -0.01694634f, 0.10340026f, 0.19967400f, -0.16994527f, 
    0.08704099f, -0.05144771f, -0.04215647f, -0.00870615f, 0.02700367f, 0.11734947f, -0.00449132f, 0.30428839f, 
    0.06917812f, -0.22710425f, 0.06435136f, -0.13871837f, 0.00899868f, -0.01683421f, -0.01511248f, -0.10576564f, 
    0.18029013f, 0.27266151f, 0.25771943f, -0.04133446f, 0.12063226f, -0.04522308f, 0.25120804f, 0.15302411f, 
    0.09790131f, 0.18790145f, -0.05034315f, -0.17300625f, -0.00387805f, -0.13192855f, 0.09089540f, -0.00405259f, 
    -0.08225640f, -0.13302416f, -0.18302488f, -0.28816214f, -0.09793713f, 0.03381561f, -0.11318174f, -0.02161590f, 
    0.07953500f, -0.03361109f, 0.02202624f, 0.02070157f, -0.18427496f, 0.30506527f, -0.10520758f, 0.07721364f, 
    -0.03447961f, 0.12416530f, -0.07343831f, -0.21550828f, 0.07541870f, 0.04085489f, 0.01457989f, 0.16909969f, 
    -0.04175572f, 0.08711883f, 0.13149263f, 0.06367979f, 0.08055568f, 0.00059538f, 0.26562467f, -0.41533899f, 
    -0.06335060f, 0.12950458f, 0.36158946f, 0.03123982f, -0.06599703f, 0.04073280f, 0.06928626f, -0.04917753f, 
    -0.17253083f, 0.07325468f, -0.28293985f, -0.03589397f, 0.06486721f, 0.00985132f, 0.11191944f, -0.14166361f, 
    -0.48547342f, -0.54154277f, 0.06195092f, -0.01777221f, 0.42903197f, -0.02545478f, -0.00648550f, -0.27568287f, 
    -0.08010115f, 0.03623638f, 0.06329573f, -0.03479913f, -0.04971754f, -0.04622484f, 0.04761928f, 0.03354982f, 
    0.03356823f, 0.01823059f, -0.06091512f, 0.03343854f, 0.03331635f, -0.03577449f, -0.04928000f, 0.05943413f, 
    0.05676439f, -0.10067819f, -0.02152489f, 0.03735556f, 0.00512516f, 0.05729025f, 0.00957088f, -0.03069518f, 
    -0.02921674f, 0.03530955f, -0.01963543f, -0.01900765f, -0.02841719f, 0.05342291f, 0.00583395f, 0.07823896f, 
    0.00656298f, -0.02563696f, -0.06758803f, -0.01852597f, -0.03860389f, 0.01646414f, -0.02938207f, -0.00357637f, 
    0.01756895f, 0.00598529f, 0.06281079f, -0.04090253f, -0.08042464f, -0.02411824f, 0.00481041f, -0.02463764f, 
    -0.02891835f, 0.03356928f, -0.01557041f, -0.07667601f, 0.06621854f, -0.01186875f, -0.06816024f, 0.05075129f, 
    -0.00387440f, -0.08575118f, -0.06843218f, 0.04376747f, 0.00473011f, -0.01391755f, -0.07248536f, -0.09005989f, 
    -0.06959319f, -0.00075881f, -0.06006939f, -0.07583923f, -0.05524848f, -0.07960802f, -0.04562217f, 0.08190973f, 
    0.02628314f, -0.05925740f, 0.06571036f, 0.01310327f, -0.00276480f, 0.04280446f, -0.05011222f, -0.00348865f, 
    0.00866464f, -0.06553482f, 0.02216925f, 0.02757669f, 0.03845239f, -0.02859460f, -0.06664862f, -0.01507029f, 
    -0.06372093f, -0.09133157f, -0.03689366f, -0.08317967f, -0.04572314f, 0.00706615f, -0.05633615f, 0.04929554f, 
    -0.01115002f, 0.03824023f, -0.00733587f, 0.02982954f, -0.03179769f, 0.01056870f, 0.00759388f, -0.05143017f, 
    0.00749475f, 0.07223021f, 0.06854191f, 0.07671110f, -0.04669813f, -0.05719288f, 0.02010739f, -0.05941964f, 
    -0.07655666f, -0.05471909f, -0.06353704f, 0.00283719f, 0.06561378f, 0.07146993f, -0.06987654f, -0.02956655f, 
    -0.07787995f, 0.01926436f, -0.01113652f, -0.08555149f, -0.02401278f, -0.03717791f, 0.06039024f, 0.06281799f, 
    0.02879717f, -0.01392010f, -0.01094611f, -0.07943553f, 0.07737693f, 0.05539554f, 0.03390713f, 0.02571455f, 
    -0.06557130f, -0.06730109f, 0.04694554f, -0.01036009f, 0.07394405f, -0.08023148f, -0.00918251f, 0.03046824f, 
    -0.03985597f, -0.14047594f, 0.08161147f, 0.02546939f, 0.16086537f, -0.11224045f, -0.00715221f, -0.00852086f, 
    0.01933231f, -0.00272257f, -0.02185289f, 0.36580670f, 0.16829945f, 0.08668152f, 0.23403232f, -0.09260672f, 
    0.14094716f, 0.10885737f, -0.27945644f, -0.38522178f, 0.14756326f, 0.02908368f, 0.03299157f, 0.11397146f, 
    0.05405873f, 0.27666253f, 0.24137568f, 0.09336673f, 0.14631467f, 0.08497016f, 0.25360912f, -0.07150853f, 
    -0.09051741f, -0.09018291f, 0.07986663f, 0.05040744f, -0.02105785f, 0.17721651f, -0.28551066f, -0.02222886f, 
    0.19242771f, 0.08448119f, 0.00853002f, -0.01833828f, 0.11107766f, -0.15540339f, 0.22846234f, 0.02772714f, 
    0.04828962f, -0.02733442f, -0.08821574f, -0.00302110f, -0.18759288f, -0.24451379f, -0.15261081f, -0.15404820f, 
    -0.00283579f, 0.03455601f, 0.08361449f, -0.00326902f, 0.17222811f, -0.02104567f, 0.06787384f, -0.01574050f, 
    0.10426154f, -0.05042867f, 0.05388894f, 0.06942435f, 0.23759337f, 0.00284229f, -0.05109954f, -0.01295250f, 
    -0.01424552f, 0.01232314f, -0.02430406f, 0.20566739f, -0.04366510f, 0.22229123f, -0.10957091f, -0.19087313f, 
    -0.13507344f, 0.29996461f, 0.08295304f, -0.04425599f, -0.02229094f, -0.09385740f, 0.01491981f, 0.15341091f, 
    0.27067420f, -0.06418730f, 0.06681532f, 0.40069300f, -0.12954551f, 0.04136664f, -0.08861932f, 0.01791863f, 
    -0.00607264f, -0.02762904f, 0.07042706f, 0.08787476f, 0.17031825f, 0.17148460f, 0.16087992f, -0.02759920f, 
    0.25909039f, 0.26869917f, -0.04875670f, 0.06478576f, 0.09255190f, -0.09238179f, -0.03584725f, 0.12457080f, 
    -0.00754066f, -0.09693656f, 0.06770662f, 0.13753918f, 0.08686417f, -0.04120977f, -0.22089422f, 0.14821307f, 
    0.18156418f, 0.13840866f, 0.23074175f, -0.19256331f, -0.15584178f, -0.04217850f, 0.09157742f, 0.09184290f, 
    -0.06188012f, 0.04719846f, -0.00404284f, 0.10597544f, -0.08396072f, 0.03172463f, -0.06695355f, 0.58407998f, 
    -0.05315230f, -0.02412655f, -0.02488870f, -0.07051823f, -0.07777530f, 0.03222781f, -0.04495562f, -0.14216743f, 
    0.12317502f, -0.15733929f, 0.00114706f, 0.16979717f, 0.04021686f, -0.03900027f, -0.12003985f, -0.19911900f, 
    -0.34814286f, 0.20782894f, -0.02705407f, 0.01110942f, 0.05759613f, -0.00901268f, 0.27520689f, -0.03729752f, 
    -0.13724118f, 0.05996553f, -0.00714589f, 0.15029188f, -0.26255664f, 0.21454993f, -0.05504403f, 0.06216107f, 
    -0.12540670f, -0.14366974f, -0.08357058f, 0.16948415f, -0.02610929f, -0.08097090f, 0.12018324f, -0.01664039f, 
    -0.09311837f, 0.08694764f, -0.06223081f, -0.13816530f, -0.03217887f, -0.04273283f, 0.07425897f, 0.06427278f, 
    -0.18029633f, 0.10985024f, -0.08960965f, -0.04559151f, -0.18860711f, -0.12236983f, -0.20204151f, 0.07152419f, 
    -0.00405522f, 0.16200376f, 0.10642657f, 0.09887993f, 0.13719341f, 0.09915506f, -0.06719273f, 0.26053059f, 
    0.03438499f, 0.10603622f, -0.03397804f, -0.16982247f, -0.13632067f, -0.04650478f, -0.18418822f, 0.26758751f, 
    -0.01050046f, -0.25786281f, -0.03208974f, -0.08788856f, 0.11955499f, 0.01258697f, -0.14592373f, 0.05009018f, 
    0.02821038f, -0.20235863f, -0.04495608f, -0.00093577f, 0.15496577f, -0.00525091f, 0.19777820f, 0.19140068f, 
    0.06517217f, -0.25157565f, -0.11329993f, 0.02106578f, -0.01333858f, 0.06752781f, -0.03649659f, 0.00922081f, 
    -0.21678096f, -0.28944403f, 0.09198859f, -0.10239822f, 0.04881106f, 0.00770593f, 0.02295762f, 0.23159799f, 
    -0.17015535f, -0.02473070f, 0.17631556f, 0.01356035f, -0.01154430f, 0.14042713f, -0.04861724f, 0.14183319f, 
    0.21902809f, 0.25149003f, -0.01664957f, 0.03234159f, 0.05630437f, 0.30401826f, 0.24857411f, -0.02040442f, 
    -0.05723501f, -0.05850645f, -0.13709228f, 0.12295595f, -0.14443292f, -0.02395078f, 0.28764996f, 0.08718913f, 
    0.21977390f, 0.15855256f, 0.07351964f, -0.05771746f, 0.00922627f, -0.01989685f, -0.03495603f, 0.05220908f, 
    0.03989154f, -0.03067862f, 0.10441891f, 0.07436338f, -0.14984131f, 0.11969636f, -0.03965922f, 0.16368797f, 
    0.07036750f, -0.10935127f, 0.15269323f, -0.00417132f, 0.05271785f, -0.05189978f, -0.04764337f, -0.01324118f, 
    -0.05977589f, -0.19891471f, 0.01580537f, -0.13879997f, 0.14556369f, 0.02634031f, -0.10793480f, 0.04031363f, 
    -0.08238129f, 0.31912315f, 0.27145171f, -0.06181210f, -0.12051727f, 0.02781428f, 0.05725921f, -0.30219564f, 
    0.01113722f, -0.07507561f, 0.25084293f, -0.18430382f, -0.08519287f, 0.15940836f, 0.04066967f, -0.07011066f, 
    0.08179274f, 0.06075620f, 0.15967169f, 0.03320414f, 0.00668693f, 0.01003057f, -0.02231738f, -0.09384452f, 
    -0.00007055f, -0.00804995f, -0.05386506f, 0.08327423f, -0.01609516f, 0.06508202f, -0.15363285f, -0.28581461f, 
    -0.17702341f, 0.07643164f, -0.00010165f, -0.01359029f, 0.06236165f, -0.30260280f, -0.08100420f, -0.08153578f, 
    0.03163336f, 0.04987469f, -0.11142237f, 0.07150763f, -0.12141722f, -0.00679440f, 0.07148506f, -0.23151772f, 
    0.04316116f, 0.19926772f, 0.01654751f, 0.03921516f, -0.01655566f, -0.00045019f, 0.12959592f, -0.10991064f, 
    0.30324602f, -0.21094051f, -0.09685452f, 0.05175531f, -0.04449446f, 0.20745969f, 0.00074139f, -0.08444673f, 
    0.35814169f, 0.27402103f, -0.25183162f, -0.04023195f, -0.14425895f, -0.10575393f, 0.09327527f, 0.17477445f, 
    -0.12501927f, -0.18451777f, 0.05187479f, -0.05154620f, -0.01456103f, -0.05686941f, 0.08132278f, -0.13218702f, 
    0.22405323f, 0.04475830f, -0.17522629f, 0.07301904f, 0.14467584f, -0.10760051f, -0.03375341f, -0.08130877f, 
    0.09846448f, -0.07830413f, 0.03237117f, 0.80638760f, 0.28059307f, -0.34040788f, 0.15767999f, 0.05558412f, 
    -0.22976497f, 0.03497840f, -0.15057153f, -0.10587617f, 0.25272340f, -0.05680915f, -0.51801777f, 0.10992901f, 
    -0.07004079f, 0.10404562f, -0.11581536f, -0.19496024f, 0.17430182f, 0.18902087f, 0.14078522f, 0.16128148f, 
    -0.08748230f, -0.03259837f, -0.11753587f, -0.17004305f, -0.02337816f, -0.11738834f, -0.13526382f, 0.14862294f, 
    0.30685195f, -0.00356574f, 0.11146176f, -0.22838098f, 0.01658086f, -0.15684241f, 0.11920139f, 0.25705102f, 
    0.23918150f, -0.55185163f, -0.11119080f, 0.09937732f, 0.04579395f, 0.08219582f, 0.05427019f, -0.34749076f, 
    -0.31503567f, 0.13931440f, -0.01390496f, 0.16238528f, -0.00006543f, -0.11339456f, 0.03975047f, 0.11486404f, 
    0.39758182f, 0.14454952f, 0.19792420f, -0.17128843f, -0.22199340f, -0.18937021f, 0.15398178f, 0.11708995f, 
    -0.05922939f, -0.06005739f, -0.62222052f, -0.58984292f, -0.31283823f, -0.21196374f, 0.07478888f, -0.11774717f, 
    -0.02948305f, 0.18252483f, 0.04197100f, 0.24928562f, 0.00665977f, 0.05388651f, 0.06358025f, -0.01535700f, 
    -0.02137985f, 0.05964709f, -0.08732350f, 0.00974174f, 0.08036873f, 0.05875859f, 0.32009554f, -0.03311052f, 
    -0.05169387f, -0.06342073f, -0.29186732f, 0.01357889f, 0.09466577f, -0.00765490f, 0.14103892f, 0.07385668f, 
    0.01428934f, -0.04327117f, 0.12012359f, 0.12572572f, -0.03304628f, -0.19933981f, 0.24942942f, -0.11687282f, 
    0.12314409f, 0.01595676f, -0.09096082f, 0.05006498f, 0.04094977f, 0.11200590f, 0.13281101f, 0.17424412f, 
    -0.05222306f, 0.09012223f, -0.06148461f, -0.01447493f, 0.09685326f, -0.19755580f, -0.11943147f, -0.08488836f, 
    -0.28895870f, -0.13391781f, -0.01776884f, 0.02709271f, -0.07511649f, -0.20486772f, 0.02842278f, -0.07685512f, 
    -0.08899157f, 0.02382275f, 0.30161381f, 0.21746264f, -0.06052868f, -0.04638468f, 0.04308511f, -0.05451541f, 
    0.08026991f, 0.18992260f, 0.81297266f, 0.38434684f, 0.31473619f, 0.12734440f, -0.07608594f, 0.06431001f, 
    -0.05954738f, 0.13750091f, -0.15087196f, 0.24021304f, -0.07690087f, 0.23387124f, -0.12820759f, 0.13532877f, 
    -0.00386088f, 0.11509094f, 0.12111437f, 0.38746300f, -0.24979332f, 0.02669195f, -0.23904847f, -0.04501140f, 
    -0.11970326f, 0.09776753f, 0.16180953f, 0.13385348f, 0.04876782f, -0.54471654f, -0.10466471f, -0.07979050f, 
    -0.02429291f, -0.00150972f, 0.18603055f, 0.15468010f, -0.08097849f, 0.00484642f, 0.22483194f, 0.32228580f, 
    0.15030798f, 0.00064595f, -0.04421750f, 0.02739096f, -0.01571435f, 0.17609051f, 0.01230703f, -0.56645304f, 
    -0.52810085f, 0.05981281f, -0.04077616f, -0.07084551f, 0.27791417f, 0.07472569f, 0.03779801f, -0.22482873f, 
    0.17345531f, 0.01007207f, 0.11302910f, 0.19028583f, -0.35780516f, 0.03879213f, 0.05248066f, -0.02830644f, 
    0.01826967f, 0.09257647f, 0.26295179f, 0.15371484f, 0.18097776f, -0.12723552f, 0.10706066f, 0.09722433f, 
    -0.17013128f, 0.11101817f, 0.32220253f, 0.03466263f, 0.43258178f, -0.05132830f, -0.05735043f, -0.08586148f, 
    -0.12340706f, 0.01820551f, 0.00415565f, 0.06381634f, 0.27103373f, -0.10277293f, -0.03059176f, 0.06337910f, 
    -0.12242021f, 0.06102369f, -0.07519429f, -0.15041876f, 0.03081501f, 0.05007766f, -0.32157657f, 0.14498676f, 
    -0.03358331f, -0.04632425f, -0.01210937f, 0.10234460f, 0.10304906f, -0.03796153f, 0.20371015f, -0.13590634f, 
    -0.14375478f, -0.04033178f, -0.05091217f, 0.07183450f, 0.07081868f, -0.10451112f, 0.17645156f, 0.00428216f, 
    0.30098546f, 0.26200718f, 0.13368565f, 0.22718817f, 0.21124633f, -0.18286659f, 0.09425128f, 0.02852556f, 
    0.09166987f, -0.23735344f, 0.12960058f, -0.06525680f, 0.04503253f, 0.10802835f, 0.09321027f, 0.05195866f, 
    0.25838938f, 0.40134305f, 0.35610196f, 0.07467142f, -0.04071784f, -0.06679133f, -0.12043498f, -0.10039113f, 
    0.10818879f, -0.38591102f, -0.39221191f, -0.03212648f, -0.15606454f, 0.09853637f, 0.00911985f, 0.16712338f, 
    -0.14861943f, 0.06032161f, 0.04302959f, -0.00749385f, -0.14553410f, 0.19075334f, -0.08331722f, 0.10798949f, 
    0.05164360f, 0.01976708f, 0.07037575f, 0.01942940f, 0.11151831f, 0.16689038f, 0.07472204f, 0.00405322f, 
    0.00979152f, 0.07621661f, -0.02109896f, 0.05795025f, 0.06571128f, 0.03772176f, 0.14942405f, 0.04142294f, 
    0.11652325f, 0.07907491f, -0.01509812f, -0.03941560f, -0.10330518f, -0.23441623f, -0.05172074f, -0.39213839f, 
    -0.28736797f, -0.16756888f, -0.18667364f, -0.08780876f, 0.00888758f, 0.18613838f, -0.07333588f, -0.02267727f, 
    -0.02260295f, 0.06833909f, 0.13762620f, -0.02433947f, 0.19851778f, -0.01760256f, 0.01969356f, -0.37855735f, 
    -0.46451643f, 0.08463514f, -0.09025878f, -0.12728050f, -0.00632773f, 0.00891723f, 0.33573869f, -0.07079016f, 
    0.06243629f, 0.10674932f, 0.09623602f, 0.15664959f, 0.07084414f, 0.06856780f, -0.11499662f, -0.18996675f, 
    -0.25944349f, 0.08914296f, -0.11358232f, -0.39381525f, -0.02398206f, 0.07584459f, -0.04094500f, -0.02190526f, 
    -0.07936252f, -0.04845167f, 0.00505008f, -0.09433418f, -0.08400908f, 0.07385941f, -0.03791829f, -0.09215260f, 
    0.00456100f, -0.20525156f, -0.27533910f, 0.04831295f, -0.08445147f, -0.01412318f, 0.08904514f, 0.06926112f, 
    0.22774810f, -0.04167429f, 0.05624816f, 0.10329431f, 0.02331292f, -0.03375722f, 0.12669903f, -0.04073064f, 
    0.01328680f, 0.13608974f, -0.17697173f, -0.13621216f, -0.02161866f, -0.09080530f, -0.06558422f, -0.13881145f, 
    0.06819703f, -0.28331983f, 0.09601687f, 0.22588755f, 0.24673623f, 0.06411967f, -0.00997500f, 0.17048006f, 
    -0.11362009f, -0.10203888f, -0.01516496f, -0.05230612f, -0.06676745f, -0.04263306f, -0.04280929f, 0.07129230f, 
    0.01878412f, 0.11442252f, -0.05374325f, 0.01978220f, -0.05976482f, -0.10299969f, 0.07984019f, -0.07817730f, 
    0.13970092f, -0.26472163f, -0.03679916f, 0.00632552f, -0.05251497f, -0.05801955f, 0.12905607f, 0.17090097f, 
    0.44331732f, -0.22205015f, -0.30351174f, 0.04661860f, 0.18304357f, 0.01499492f, 0.08936381f, -0.13002963f, 
    -0.15709643f, -0.05819173f, -0.21609424f, 0.32178751f, 0.00929176f, 0.00096669f, -0.05018211f, -0.05473403f, 
    0.04496876f, 0.07305490f, 0.05235581f, 0.00695717f, -0.21368174f, -0.14952461f, -0.00138185f, -0.19754048f, 
    -0.09152985f, 0.05808232f, -0.18675348f, -0.38586310f, 0.18900327f, 0.23897433f, 0.01580034f, 0.32701921f, 
    -0.09480312f, 0.20011948f, 0.01021552f, 0.12310453f, 0.09292689f, -0.30997130f, -0.13211909f, -0.00178579f, 
    0.14080319f, 0.08143162f, -0.05883748f, -0.08793271f, 0.26137435f, -0.03833190f, -0.21182312f, 0.04199352f, 
    0.30707541f, 0.04360748f, 0.20020698f, 0.11898942f, -0.22723314f, 0.11310647f, 0.05863688f, 0.13226579f, 
    -0.24078746f, -0.07454085f, 0.01444719f, 0.16088481f, 0.18490954f, -0.06205670f, 0.09171173f, 0.03925493f, 
    0.04887098f, 0.01785840f, -0.03329097f, -0.02805535f, -0.05327527f, 0.06479642f, -0.06001827f, -0.05669106f, 
    -0.16692884f, 0.06042905f, 0.36980429f, 0.04795716f, -0.00616361f, 0.03546719f, 0.21328129f, 0.12960257f, 
    -0.05078299f, 0.00449463f, 0.34464309f, 0.16137767f, -0.16892743f, -0.02936433f, 0.03348472f, -0.09542742f, 
    0.09536643f, 0.06326146f, 0.03265156f, 0.06714799f, 0.21418217f, 0.01721830f, 0.11788147f, -0.01655908f, 
    -0.16896898f, -0.00841312f, 0.10895977f, 0.00690531f, -0.03787442f, 0.03877347f, 0.05890821f, 0.01402288f, 
    0.10490698f, 0.01007909f, -0.11852089f, -0.12514001f, -0.07414996f, -0.05430717f, -0.09515224f, 0.26372424f, 
    -0.13279302f, -0.20225649f, 0.19175445f, 0.04673915f, 0.07646412f, 0.13284074f, 0.10690773f, 0.02809855f, 
    -0.17555104f, 0.03870510f, 0.03791994f, 0.12607938f, 0.02451925f, -0.07608346f, -0.04179359f, 0.22341584f, 
    -0.26606381f, -0.23358260f, 0.02044713f, -0.03906567f, -0.29397422f, -0.13992049f, 0.08622299f, 0.16063680f, 
    -0.16595617f, 0.46180791f, 0.27128080f, 0.12971781f, 0.04500385f, 0.12751482f, 0.08854717f, -0.11852276f, 
    0.16102523f, 0.03838788f, -0.11795456f, 0.02341481f, 0.02152624f, 0.15073779f, -0.02027460f, -0.11603544f, 
    -0.12796758f, -0.19460411f, -0.10877605f, -0.45511195f, 0.13152592f, -0.04591043f, 0.00421422f, -0.04848368f, 
    -0.07174146f, 0.07535192f, 0.06872946f, 0.15139961f, 0.21121457f, 0.06084145f, 0.08458003f, 0.07855918f, 
    0.05550893f, 0.06473403f, -0.21262679f, -0.04980309f, -0.11343000f, 0.19472878f, 0.20112267f, -0.00349647f, 
    -0.06331027f, 0.09623228f, 0.05341677f, -0.03867564f, -0.05734585f, 0.20744325f, 0.07333785f, -0.09640957f, 
    0.05061278f, 0.05912917f, -0.09194273f, -0.10518867f, 0.11869425f, 0.04347434f, 0.06435166f, -0.33210263f, 
    -0.06233935f, 0.05586319f, 0.09912819f, -0.04097725f, -0.10509376f, 0.02046128f, -0.04060488f, 0.27014121f, 
    -0.02909478f, 0.04770167f, -0.05467748f, -0.01783308f, -0.03873356f, 0.02632324f, 0.17265603f, -0.12621711f, 
    -0.01382475f, -0.27731127f, -0.14521511f, 0.03295167f, -0.01560745f, -0.05281153f, 0.22874281f, 0.11152415f, 
    0.16573031f, -0.05499391f, 0.25235468f, 0.42272976f, -0.08828909f, 0.04045898f, 0.12372740f, -0.13868184f, 
    0.07901671f, 0.01163541f, 0.20885336f, -0.21544082f, -0.42479703f, -0.30621064f, -0.06917995f, 0.05349613f, 
    -0.00547250f, -0.01608699f, 0.05393267f, 0.08042643f, -0.03416511f, 0.11206764f, -0.02383114f, -0.00813200f, 
    -0.05389648f, 0.00295391f, 0.03480107f, 0.27394459f, -0.14529645f, -0.13623188f, 0.15507467f, -0.18222848f, 
    -0.08989052f, -0.09203499f, -0.07060540f, 0.12888496f, -0.13105564f, 0.17696884f, -0.42354921f, -0.61721689f, 
    0.07626014f, 0.15559743f, -0.07424199f, 0.03867200f, 0.14563721f, -0.02165991f, 0.39376578f, -0.07711081f, 
    0.05189414f, 0.06042844f, 0.03893203f, 0.15849024f, 0.11622413f, 0.09677459f, -0.03249417f, 0.46582597f, 
    -0.21274641f, -0.21722504f, -0.12084541f, -0.10134334f, -0.04244466f, 0.13797738f, 0.02969665f, -0.05256299f, 
    0.05964154f, 0.25983590f, 0.25650457f, -0.20547110f, 0.11096022f, -0.16703096f, -0.04403238f, 0.07060684f, 
    0.15200378f, -0.19409773f, -0.23683722f, -0.14538842f, -0.17769267f, -0.03002217f, -0.19723873f, 0.01544247f, 
    -0.01180723f, -0.02420566f, -0.41963720f, -0.08804543f, 0.30702242f, -0.16672477f, 0.03977968f, -0.15672636f, 
    0.01310750f, -0.04056706f, 0.08650704f, 0.11324458f, 0.10886702f, 0.16498154f, -0.18308008f, 0.05894392f, 
    -0.08053407f, -0.01047584f, -0.06956021f, 0.05524337f, -0.22550711f, 0.14962399f, 0.10103971f, -0.08162274f, 
    0.00564372f, 0.00029942f, 0.14577921f, 0.03521485f, 0.17913432f, 0.14620449f, 0.27871943f, -0.43346164f, 
    -0.03285274f, -0.04939525f, -0.06087091f, 0.10704800f, -0.02789629f, 0.06429061f, -0.01163383f, -0.29107261f, 
    0.18845901f, 0.07623062f, -0.06208050f, -0.02447047f, 0.06321715f, 0.04439651f, 0.11132199f, -0.13728702f, 
    -0.22678721f, -0.60965025f, -0.00429547f, 0.10138189f, 0.26105815f, 0.10905109f, -0.18554562f, -0.26300171f, 
    0.05172281f, -0.03764318f, 0.09193429f, -0.04198631f, -0.08118707f, 0.12449895f, -0.02664956f, 0.11698733f, 
    0.10159462f, 0.22886419f, -0.06336753f, 0.20831268f, 0.02833422f, -0.10036511f, 0.09289577f, -0.11190494f, 
    -0.04078203f, -0.13386902f, 0.42852584f, -0.11441782f, -0.60560721f, 0.16964857f, -0.13719031f, -0.06346433f, 
    -0.00848652f, 0.06252624f, 0.30618089f, -0.13115396f, -0.19927913f, 0.40021819f, -0.24946928f, 0.01189346f, 
    0.00324284f, -0.08739889f, 0.04566717f, -0.06417854f, 0.07855505f, -0.03870799f, 0.41702810f, 0.02128234f, 
    0.08124107f, 0.20786840f, 0.14686939f, 0.01576626f, -0.16161732f, 0.26614249f, 0.30074671f, -0.08139890f, 
    -0.07146354f, 0.13135618f, 0.18508723f, -0.24081175f, 0.05294373f, -0.06963810f, 0.29325089f, -0.17984992f, 
    -0.10235263f, -0.05130868f, 0.08287559f, 0.03114777f, 0.00883983f, -0.11156901f, 0.05039315f, 0.04353447f, 
    -0.14739615f, 0.01780177f, 0.08104719f, -0.05559515f, 0.27483186f, -0.10721883f, -0.08116502f, -0.23516738f, 
    0.05742764f, -0.49580151f, -0.05880309f, 0.13244162f, 0.09847298f, -0.16780767f, -0.12330718f, -0.12366812f, 
    0.09580746f, 0.05520770f, 0.25245604f, -0.07902411f, 0.03993027f, -0.09989601f, -0.14691578f, 0.03497946f, 
    -0.06053502f, -0.01087066f, 0.27905327f, 0.03609900f, 0.08968782f, 0.05718710f, -0.03812581f, -0.18407379f, 
    0.04788188f, -0.04055631f, -0.19492100f, 0.24839303f, 0.05587633f, -0.09312779f, 0.13578182f, 0.21699379f, 
    -0.03761051f, 0.30394727f, -0.12412732f, 0.26664376f, 0.01836199f, 0.06176503f, -0.12931432f, -0.13258742f, 
    0.03923314f, -0.13822381f, 0.17765309f, -0.08704389f, 0.20817713f, 0.05577943f, 0.46218067f, -0.43805462f, 
    0.12725644f, 0.02605478f, 0.03545603f, -0.11277594f, -0.19954871f, -0.06104171f, -0.13637388f, 0.12146519f, 
    0.19265515f, -0.14981925f, 0.02455163f, -0.14131355f, -0.07124598f, -0.10364470f, -0.10545500f, -0.22050309f, 
    0.56138235f, 0.11325824f, 0.02529302f, 0.39178047f, 0.04131291f, 0.16198766f, 0.02685085f, -0.02674178f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.19708653f, 0.11995819f, 0.07857767f, 0.22161764f, 0.62422895f, 0.03032364f, -0.04161671f, -0.06844755f, 
    0.00341721f, -0.06468301f, 0.02020703f, 0.05170514f, 0.16991453f, 0.04599731f, 0.05164113f, -0.18267244f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22352146f, -0.31570920f, 0.29480696f, -0.75533646f, 0.22267041f, 0.32013404f, -0.20548119f, 0.14706849f, 
    0.00945713f, -0.49418652f, 0.15335174f, -0.09699353f, -0.46600822f, -0.01724471f, -0.05763372f, -0.24160369f, 
    0.44685254f, -0.11240827f, 0.21747915f, 0.42387193f, 0.00228955f, -0.15092055f, 0.15532058f, -0.37888494f, 
    -0.22718717f, -0.01615083f, -0.11133792f, 0.07544021f, -0.11456801f, 0.03582280f, -0.31097236f, 0.43085369f, 
    0.32921466f, -0.42934445f, 0.22092195f, -0.78361821f, 0.29147094f, -0.23869413f, -0.23132269f, 0.18208946f, 
    0.05848015f, -0.62399042f, -0.50073963f, -0.07632858f, 0.11068833f, 0.05828014f, 0.08614542f, -0.40489015f, 
    -0.18131852f, 0.32705739f, -0.09308831f, -0.36734533f, 0.41495624f, 0.28034052f, 0.13421144f, -0.04917937f, 
    -0.37160143f, 0.60639292f, -0.30734754f, 0.38927051f, -0.17938159f, 0.17184588f, 0.53259212f, -0.27081773f, 
    -0.02248043f, -0.69682956f, 0.44890714f, 0.26137233f, 0.33819222f, -0.13737744f, 0.01135835f, -0.48268986f, 
    -0.01296610f, -0.06410326f, 0.29343054f, -0.21242385f, 0.32714725f, -0.10471594f, -0.21927506f, 0.06421929f, 
    -0.23733053f, 0.27092230f, -0.09201421f, 0.27260312f, -0.00009252f, 0.30364746f, 0.19482337f, -0.09597099f, 
    0.16238038f, -0.07320525f, 0.33702421f, 0.07592648f, -0.26324803f, -0.00850030f, 0.18153352f, 0.17230839f, 
    0.08086408f, -0.53212541f, -0.04827014f, -0.58419406f, 0.38821858f, 0.29177773f, 0.10354824f, -0.01612906f, 
    -0.02625947f, -1.24741280f, -0.15438545f, 0.15121314f, -0.18593611f, -0.09143244f, -0.23147798f, -0.24717237f, 
    -0.21874143f, -0.13789025f, 0.14859501f, 0.11105096f, 0.06374554f, 0.26645201f, -0.10580236f, -0.43711343f, 
    0.10499584f, -0.66223884f, 0.56196952f, 0.48580232f, 0.08639630f, -0.28617114f, 0.50386387f, -0.10109647f, 
    0.25385758f, 0.27929148f, 0.29807761f, 0.23453762f, -0.21566266f, -0.07481675f, -0.21246034f, 0.33020130f, 
    0.21267387f, -0.20504893f, -0.33697435f, -0.01702085f, 0.19318447f, -0.20618670f, -0.00138730f, -0.23745136f, 
    -0.38318026f, -0.17924573f, 0.28819299f, -0.16246411f, 0.02333639f, 0.84386021f, -0.14441694f, 0.21047591f, 
    -0.08192942f, -0.65458196f, 0.41980031f, 0.49100316f, -0.44451833f, -0.27001470f, 0.19843747f, 0.18811981f, 
    0.10192036f, -0.29914480f, 0.38207152f, 0.01081573f, 0.11463994f, 0.53216386f, -0.04092558f, -0.24176458f, 
    -0.27631119f, -0.81409925f, 0.05277736f, 0.21652825f, -0.36667675f, 0.11256840f, 0.21736212f, 0.16676709f, 
    -0.18273595f, -0.80451161f, 0.19104920f, 0.20578186f, 0.36291352f, -0.31603482f, 0.21375711f, 0.43362305f, 
    -0.38739076f, 0.24833164f, -0.05484181f, -0.12821867f, -0.52285117f, -0.36554262f, -0.43880096f, 0.02636679f, 
    -0.04187023f, -0.04910291f, -0.02111202f, 0.12078279f, 0.01625570f, 0.20608163f, -0.06170899f, 0.18249726f, 
    -0.35402042f, 0.87861127f, -0.11368080f, 0.44168085f, -0.66949058f, -0.42155439f, -0.19409321f, 0.37149382f, 
    0.19518566f, -0.06001773f, -0.14156516f, -0.69229144f, -0.12298624f, 0.42472202f, 0.03630053f, 0.26537654f, 
    0.19135165f, 0.43795186f, -0.02407686f, 0.55329686f, 0.27986383f, 0.14642724f, 0.40204763f, 0.24233566f, 
    0.43271595f, 0.22177613f, 0.11549265f, -0.29726711f, 0.16090579f, 0.30407235f, 0.13338766f, -0.30502903f, 
    0.10684195f, -0.37701657f, -0.22954907f, 0.39784440f, -0.30694535f, 0.30915326f, 0.26240727f, -0.00944874f, 
    -0.38158989f, -0.31817225f, -0.03283543f, -0.43159989f, 0.07477883f, 0.42745593f, -0.21368735f, 0.35528392f, 
    0.08322445f, 0.23466669f, -0.02076132f, 0.32835034f, 0.31404379f, -0.03165808f, 0.52022564f, 0.03916964f, 
    0.00110006f, -0.09380841f, -0.15940154f, -0.17435408f, -0.05089656f, 0.13118187f, -0.21910420f, -0.18816125f, 
    -0.14037576f, -0.14247331f, -0.09791425f, -0.08478343f, -0.04833612f, 0.15992033f, -0.04971722f, -0.17271850f, 
    0.20052363f, -0.07261891f, -0.20507036f, 0.15467569f, -0.30169100f, 0.55984443f, -0.19072816f, 0.18002941f, 
    -0.16991439f, 0.07338766f, 0.13043399f, 0.28987527f, 0.05642852f, -0.07177461f, 0.11007495f, -0.08061767f, 
    -0.16857257f, -0.03630044f, 0.13980117f, -0.14810744f, -0.13040628f, -0.21662703f, 0.09610650f, -0.25742203f, 
    -0.01110120f, 0.16235080f, -0.18472350f, 0.18661895f, -0.18849809f, 0.22033164f, -0.21566080f, -0.03046013f, 
    -0.02916018f, 0.13771152f, -0.01946567f, -0.23326339f, -0.00453220f, 0.01370676f, 0.07461238f, 0.10710914f, 
    -0.17978193f, 0.07175148f, -0.24480215f, -0.15255615f, -0.26089662f, -0.20334111f, -0.05189719f, 0.03731314f, 
    0.17189713f, 0.24816085f, -0.03689745f, 0.34172836f, 0.19948609f, -0.28632665f, -0.01777496f, -0.24591708f, 
    0.13726765f, -0.60771406f, 0.53294683f, -0.16257848f, 0.05476625f, 0.34137136f, -0.38807878f, 0.23204754f, 
    0.22480939f, -0.03854879f, 0.35256326f, -0.17922071f, -0.07247270f, 0.14719988f, -0.23470072f, 0.31616059f, 
    -0.61128038f, 0.54552126f, -0.16488279f, -0.00006825f, -0.59747571f, -0.24847405f, -0.12882206f, 0.49286807f, 
    0.32978529f, 0.11492804f, 0.36977968f, -0.41227105f, -0.02187998f, 0.27262950f, -0.18292816f, 0.04862136f, 
    -0.39365226f, -0.99102676f, 0.32089871f, 0.05688793f, -0.62564898f, -0.18472089f, -0.05077178f, 0.46360835f, 
    0.29177412f, -0.39922634f, -0.00629510f, 0.62928480f, 0.25198984f, 0.35589740f, -0.17561874f, -0.32746261f, 
    0.40649515f, -0.65644753f, -0.35362715f, -0.09598162f, 0.49839792f, 0.18813317f, 0.04862383f, -0.42164308f, 
    0.51641601f, 0.13253938f, -0.22958915f, -0.29742533f, 0.32217488f, -0.33118922f, -0.20538794f, -0.40420273f, 
    0.09963473f, 0.37446576f, -0.38934281f, 0.29856274f, 0.03070623f, 0.21080674f, -0.10882076f, -0.27081993f, 
    -0.29179710f, -0.07015642f, 0.35761777f, -0.52114820f, 0.08131848f, 0.52616405f, 0.22523396f, 0.35601491f, 
    0.24822110f, 0.81144178f, -0.23735048f, 0.19980392f, -0.04609109f, 0.16957268f, 0.33628124f, 0.03394501f, 
    0.39280251f, -0.36898473f, 0.35241830f, 0.65932310f, 0.28652239f, -0.16308405f, -0.03838474f, -0.15833007f, 
    0.00099972f, -0.26259500f, 0.42990744f, -0.36120665f, -0.04969496f, -0.29014763f, -0.43950957f, 0.25912777f, 
    -0.43642610f, -0.31838128f, 0.22612208f, -0.17332400f, 0.24785423f, 0.50266892f, 0.07148644f, 0.33293310f, 
    -0.35899875f, -0.30642706f, 0.06475780f, 0.07969561f, -0.00888547f, -0.45802832f, -0.04483336f, 0.46231422f, 
    0.02472338f, -0.07719693f, -0.22878122f, 0.16502836f, -0.12517384f, 0.10319978f, -0.02255353f, 0.08464518f, 
    -0.10195273f, -0.03516820f, 0.02045882f, -0.09913537f, -0.24199486f, -0.23922104f, 0.16518754f, 0.06152877f, 
    -0.08174965f, -0.17412806f, -0.22846675f, 0.00491911f, -0.19550335f, 0.16694799f, 0.08264315f, -0.14741108f, 
    -0.11111459f, -0.24848810f, -0.08729169f, -0.05769700f, 0.04088417f, 0.20292494f, 0.03183371f, 0.14556327f, 
    0.06705844f, -0.12424296f, -0.21072283f, -0.17614299f, -0.08565503f, -0.11199445f, 0.18689963f, 0.13700241f, 
    -0.13219538f, 0.22265664f, -0.10431102f, -0.19433656f, -0.16226852f, -0.20603606f, -0.09392542f, -0.21099693f, 
    -0.12327806f, -0.50392783f, -0.04660903f, 0.74010843f, 0.35203388f, 0.19382286f, -0.18370768f, 0.23699458f, 
    -0.11384817f, 0.17471671f, -0.47461715f, -0.17858057f, -0.17436481f, -0.32428664f, -0.37144795f, -0.25136894f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.28423190f, 0.05856584f, 0.34234634f, -0.08626604f, 0.11148237f, 0.18892358f, 0.53539270f, 0.37912720f, 
    0.17000577f, -0.05363210f, 0.14384243f, 0.33629036f, -0.10486510f, -0.25628123f, 0.02199917f, -0.31077817f, 
    -0.11232510f, -0.42169929f, -0.06774601f, 0.16374455f, 0.23514180f, -0.29066607f, 0.42294139f, 0.27248046f, 
    0.07196365f, -0.22921470f, 0.32958579f, -0.16974466f, 0.13170561f, -0.10532469f, -0.16481021f, 0.21786235f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.26771706f, 0.28353482f, 0.06972452f, -0.12490419f, 0.39191097f, -0.45479149f, 0.41873202f, 0.18468659f, 
    -0.52463388f, 0.25639337f, 0.27005994f, 0.84823960f, 0.33627588f, -0.25200236f, -0.06657228f, 0.11338452f, 
    0.02895014f, -0.26936415f, 0.08484819f, -0.04286098f, -0.03486357f, 0.35619849f, 0.33261782f, -0.18185475f, 
    -0.19921196f, -0.08271066f, 0.21503520f, 0.21487032f, -0.05459351f, -0.00937321f, 0.17118178f, -0.59882575f, 
    -0.06523480f, -0.15586770f, -0.21104088f, -0.14495896f, 0.02607194f, -0.19658738f, 0.11342901f, -0.15182485f, 
    0.03586492f, -0.16944841f, 0.02204576f, 0.01354912f, 0.09258150f, -0.11552899f, -0.03433618f, -0.10093500f, 
    0.08881228f, -0.12443115f, 0.03145925f, 0.17505847f, -0.08814093f, 0.06312785f, -0.19063778f, -0.09341131f, 
    -0.22932376f, -0.01064306f, 0.08209051f, -0.00121715f, -0.10214876f, 0.08028496f, 0.09736362f, 0.18529382f, 
    0.02733210f, -0.49614316f, 0.30237463f, 0.49073526f, -0.04983675f, 0.02071768f, 0.07491723f, -0.11007924f, 
    -0.24948138f, 0.27143171f, -0.03684825f, 0.32346287f, 0.27174255f, 0.14973398f, 0.10137984f, 0.29543355f, 
    0.01420180f, -0.69191176f, -0.15350172f, -0.13666360f, -0.14403214f, 0.14215027f, 0.12973920f, -0.19066823f, 
    -0.15707423f, 0.38317078f, -0.25301489f, 0.43045184f, 0.13866377f, 0.13304588f, 0.00616185f, 0.56784534f, 
    -0.01038822f, 0.18322320f, 0.12437912f, -0.11081387f, 0.30801582f, 0.11300233f, 0.12824062f, 0.31015512f, 
    -0.17949070f, 0.11393519f, 0.19141307f, -0.62100399f, -0.36392674f, -0.09469130f, -0.07944804f, 0.12310361f, 
    -0.10164741f, -0.46459320f, 0.02423269f, -0.14998585f, 0.14804769f, -0.77698487f, -0.10879532f, 0.24294057f, 
    0.42822707f, -0.16837464f, 0.12799188f, 0.10677788f, -0.08461631f, -0.01701003f, 0.05883656f, -0.62477422f, 
    0.09950458f, 0.20705055f, 0.19748366f, -0.03140225f, -0.16470657f, -0.05406192f, 0.45876804f, -0.27061313f, 
    0.22237909f, -0.06377861f, -0.00560240f, 0.13557407f, -0.23833670f, -0.17381905f, 0.20337914f, -0.35826153f, 
    0.12207670f, -0.01885315f, 0.16368584f, -0.07830817f, 0.11659063f, -0.37603882f, 0.25797451f, -0.00903696f, 
    0.38652432f, -0.10926811f, 0.13172849f, -0.16869310f, -0.10546604f, 0.06115615f, -0.14487992f, 0.83565360f, 
    -0.21077962f, 0.24660835f, -0.42984614f, 0.05580948f, 0.29499054f, -0.06395673f, -0.63451976f, 0.41449320f, 
    -0.02970340f, 0.17220341f, 0.33286631f, -0.34360522f, 0.46233535f, -0.19551191f, 0.08417635f, -0.23321366f, 
    0.14391254f, -1.06293678f, 0.03496486f, 0.03418993f, 0.02932027f, 0.40231973f, 0.21561483f, -0.05973575f, 
    -0.01611234f, -0.19312239f, 0.35129142f, 0.09729473f, 0.14581212f, -0.12410881f, 0.13303335f, -0.46393046f, 
    0.53863484f, -0.40737316f, 0.40488687f, 0.20515028f, -0.08894797f, -0.01088621f, 0.39823446f, 0.00518174f, 
    0.33789152f, 0.05175246f, 0.08289974f, 0.10247695f, -0.09063310f, 0.35565311f, 0.30392256f, 0.22748230f, 
    -0.14793904f, 0.11314082f, -0.01020787f, 0.08377512f, -0.26798186f, 0.23632069f, 0.10694724f, 0.14205286f, 
    0.35232711f, 0.21728767f, -0.31791073f, 0.04099403f, 0.16888383f, -0.04560647f, 0.03351850f, 0.02250635f, 
    0.12136866f, 0.22430424f, -0.03701887f, -0.05914631f, 0.06982722f, 0.01523304f, 0.22509037f, 0.65961421f, 
    -0.05809443f, 0.10365551f, 0.15088156f, -0.34575105f, -0.06919055f, -0.00514681f, 0.20539983f, -0.26065588f, 
    0.05828890f, 0.29186848f, 0.01735365f, 0.18551184f, 0.10885620f, 0.07500598f, 0.56934923f, -0.05284894f, 
    -0.01257627f, -0.10082686f, 0.06137013f, 0.08769416f, -0.04395379f, 0.03921572f, 0.14654352f, -1.05543077f, 
    0.09468284f, 0.49871284f, 0.12119211f, -0.22798277f, -0.21656200f, -0.10868704f, -0.08874524f, -0.15311332f, 
    0.26045746f, -0.07860310f, 0.04704037f, -0.00245736f, 0.12894152f, 0.40412846f, 0.30529806f, -0.24042846f, 
    0.15987448f, 0.89135414f, -0.03129100f, -0.07368674f, -0.02850962f, 0.93769854f, 0.27876174f, -0.19298553f, 
    0.12429993f, -0.12712076f, 0.13519433f, -0.23990986f, -0.12387262f, 0.14762323f, -0.16797137f, -1.06078064f, 
    0.06223363f, -0.15136898f, 0.05532974f, -0.50474048f, 0.47155517f, -0.21303719f, 0.12373444f, 0.30194211f, 
    -0.05307726f, 0.01155457f, 0.19259287f, 0.62531757f, -0.16117138f, 0.22091901f, -0.27211288f, 0.15730804f, 
    0.06685150f, -0.71444595f, 0.14816113f, -0.07621197f, 0.17126489f, 0.24398938f, -0.09213096f, 0.20550160f, 
    -0.40753403f, 0.13853432f, 0.35579848f, 0.37955788f, -0.10014161f, 0.13024278f, 0.02137709f, -0.24522419f, 
    0.24664646f, 0.12521547f, -0.17523263f, -0.19869713f, -0.08030936f, -0.07855801f, 0.06100975f, -0.01539233f, 
    -0.04671272f, 0.28765520f, 0.23762725f, 0.27773237f, 0.16477974f, 0.10745411f, 0.05946051f, -0.10851789f, 
    0.02661367f, 0.13012579f, 0.11592241f, 0.10686801f, 0.12918437f, 0.74429840f, 0.45570493f, -0.31966087f, 
    -0.40473536f, 0.13963281f, -0.01975921f, 0.06771185f, -0.04382773f, 0.09129203f, 0.11125004f, 0.11088736f, 
    -0.01173686f, -0.33369783f, 0.07613269f, 0.32260188f, -0.44808498f, 0.17193367f, 0.12815061f, -0.16934697f, 
    -0.06202847f, 0.15868108f, 0.12681866f, -0.15039527f, -0.54570514f, 0.16258150f, 0.13854603f, 0.38605320f, 
    0.08169351f, 0.15922092f, 0.01222497f, -0.07530031f, -0.16287701f, -0.29935694f, -0.27797735f, 0.22442214f, 
    0.12499127f, 0.36365917f, -0.63650280f, -0.17718686f, -0.16994265f, 0.07390144f, -0.01371273f, 0.29029113f, 
    0.08927784f, 0.27607703f, 0.02117559f, 0.01589452f, 0.18916968f, -0.30953348f, 0.23056780f, -0.30178642f, 
    -0.05025235f, 0.03084440f, 0.20748445f, 0.71769112f, 0.36738023f, -0.02147209f, -0.04147086f, 0.02137791f, 
    0.10407487f, 0.11837510f, 0.11423185f, -0.03546076f, -0.06091453f, 1.19747293f, 0.48947796f, -0.13287325f, 
    -0.27957404f, -0.01643444f, 0.01732651f, 0.25915521f, -0.10846055f, -0.07294784f, 0.13914992f, 1.09466076f, 
    -0.15941906f, -0.20587768f, 0.20835309f, -0.14265369f, -0.13221247f, 0.01176488f, 0.42813656f, 0.52752799f, 
    0.16829798f, 0.41945425f, -0.05198977f, 0.39181784f, 0.19964039f, -0.18562289f, -0.37876508f, 0.15698454f, 
    0.14075324f, 0.49216151f, -0.12461778f, -0.05470877f, -0.18107036f, -0.30251613f, 0.20898965f, -0.01743633f, 
    0.16931120f, -0.28736791f, 0.18035527f, 0.11344228f, -0.04189321f, 0.05685884f, 0.07126810f, 0.76253968f, 
    0.12790625f, 0.01198594f, -0.03969621f, 0.05736791f, 0.13695517f, 0.21011274f, 0.39104697f, 0.35805491f, 
    -0.17087856f, 0.15506947f, 0.08559103f, -0.46750128f, -0.38655916f, -0.22126806f, 0.17886829f, -0.08831833f, 
    -0.06265733f, 0.07085039f, 0.03654393f, 0.19107372f, 0.08014605f, -0.32346064f, 0.32271549f, 0.34021264f, 
    0.08390550f, 0.00577361f, -0.00656864f, -0.28018370f, 0.12501033f, 0.13334276f, 0.15375067f, -0.57511705f, 
    0.25365567f, -0.47052214f, 0.09134123f, 0.36838046f, -0.13796479f, -0.38576111f, 0.37315711f, 0.58338827f, 
    -0.22505210f, 0.56443161f, 0.19518580f, -0.23399678f, -0.21655199f, 0.39768097f, -0.02900314f, 0.46465772f, 
    -0.11969721f, 0.65031594f, 0.01079490f, 0.13521452f, -0.43613932f, -0.31735784f, -0.04673593f, 0.01022709f, 
    -0.11689661f, 0.31561977f, -0.33304319f, 0.30941981f, 0.01366072f, -0.13970460f, -0.11061569f, -0.80823511f, 
    0.16715348f, 0.14320239f, 0.08685650f, 0.10807490f, 0.61455399f, -0.17794523f, 0.06957176f, 0.15656313f, 
    -0.11716718f, 0.03274213f, -0.07184090f, -0.04388911f, -0.16017298f, 0.00797154f, 0.06790462f, -0.10549263f, 
    0.03668114f, -0.82500929f, -0.15066469f, -0.03567740f, 0.20001383f, -0.37532869f, -0.22488998f, -0.00224294f, 
    0.33193025f, 0.17843838f, 0.19370082f, -0.21118982f, 0.09438904f, -0.06353939f, -0.08212139f, -0.98356539f, 
    -0.06319896f, 0.15548074f, 0.13178365f, 0.05904655f, 0.14324862f, -0.19950886f, -0.01854392f, -0.16788881f, 
    -0.00243806f, -0.08318848f, 0.24504504f, -0.48517430f, -0.33825481f, 0.28993687f, 0.26181278f, -0.08668634f, 
    -0.16662832f, 0.08503330f, 0.05190606f, -0.11914264f, 0.02391313f, -0.38835421f, -0.07967408f, 0.53295803f, 
    0.55995786f, 0.15884282f, -0.16141453f, 0.06090188f, 0.11570956f, -0.02970801f, 0.06257676f, 0.18792596f, 
    -0.07724988f, 0.11143059f, 0.10992563f, 0.06616525f, -0.14351974f, -0.16122442f, -0.08937297f, 0.12950908f, 
    0.09304899f, 0.14356823f, 0.09660414f, -0.09144589f, -0.06563473f, -0.01857808f, -0.03871072f, -0.12838821f, 
    -0.02285798f, -0.11165809f, -0.04598720f, 0.06661239f, -0.17027177f, -0.08105503f, 0.05372795f, -0.11243207f, 
    -0.05669955f, -0.14184967f, 0.01453841f, -0.06958969f, 0.13330320f, 0.09007913f, 0.03665891f, 0.10214418f, 
    0.20159045f, -0.19782889f, 0.07393593f, -0.42058110f, 0.54240847f, -0.26176265f, 0.21332917f, 0.18810886f, 
    -0.26990834f, 0.27549255f, -0.04576891f, 0.76944041f, -0.17952512f, -0.27539223f, -0.31493825f, 0.12486881f, 
    0.05071115f, -0.84148121f, 0.13290510f, 0.10252477f, -0.03699325f, -0.28908437f, 0.13092825f, 0.32846153f, 
    -0.03324756f, 0.10165545f, 0.47475350f, 0.39147201f, 0.05671604f, 0.04587621f, 0.01112089f, 0.71449602f, 
    0.15824930f, 0.22101279f, 0.05968474f, -0.16127253f, 0.12243918f, 0.04221281f, 0.47592106f, -0.20774297f, 
    -0.49476349f, -0.12102382f, 0.29732886f, 0.03332245f, -0.05209083f, -0.07029866f, 0.10713879f, -0.33911672f, 
    0.08437203f, -0.03224196f, -0.21132471f, -0.12770051f, 0.01403484f, -0.29305065f, 0.13872358f, 0.38280922f, 
    0.29245743f, -0.17116459f, 0.23666753f, -0.09698156f, -0.12942471f, -0.05731390f, -0.08321632f, 0.54752249f, 
    0.24841224f, 0.11397643f, 0.27457130f, 0.32974005f, 0.39233810f, 0.08307628f, 0.24012068f, 0.43247744f, 
    -0.32760847f, -0.03834299f, 0.25207403f, -0.23162961f, -0.00503998f, 0.16307226f, 0.08924586f, 0.17255931f, 
    -0.07275619f, 0.03547816f, -0.02089325f, -0.16348815f, -0.10671023f, -0.29961509f, 0.19116089f, -0.17895442f, 
    0.42322031f, -0.08759551f, -0.05122811f, -0.09399097f, -0.03647561f, 0.06767003f, 0.04816611f, -0.45651934f, 
    -0.00387100f, 0.34730676f, -0.29963946f, 0.40497547f, 0.03356018f, 0.11691479f, -0.66654801f, 0.17809917f, 
    -0.15539698f, 0.07875077f, 0.24789368f, -0.15845129f, 0.42782894f, -0.45207059f, 0.22645693f, -0.46707010f, 
    -0.11049241f, -0.89165449f, -0.11197492f, -0.03098299f, 0.21570857f, 0.28131670f, 0.32259157f, -0.45531771f, 
    -0.05206493f, -0.17907542f, 0.34510827f, 0.29078290f, 0.11940685f, -0.14309897f, 0.05594585f, -0.67644095f, 
    -0.40702721f, 0.41071412f, -0.36374786f, -0.34322152f, 0.34663555f, 0.07088809f, -0.49423161f, 0.45440510f, 
    0.14966547f, 0.01292359f, -0.05958206f, 0.03773559f, 0.20108536f, 0.17162338f, -0.05810350f, 0.23824722f, 
    -0.03936448f, 0.76900643f, 0.00897812f, 0.05850054f, -0.08840674f, 0.11470060f, -0.48929432f, 0.55880803f, 
    -0.11537447f, 0.02216524f, 0.15310086f, 0.05683438f, -0.04822651f, -0.12354807f, -0.10485508f, 0.81169707f, 
    -0.05336501f, -0.15659332f, -0.15015429f, -0.12459103f, 0.12636262f, 0.05127940f, -0.05484634f, -0.00356278f, 
    -0.02331215f, 0.07969797f, 0.13079761f, -0.10010406f, -0.15629531f, 0.01658082f, -0.17508125f, -0.16009274f, 
    0.14339888f, -0.13836089f, -0.13623634f, -0.08729561f, -0.20137699f, -0.03945508f, -0.14966127f, -0.13400178f, 
    0.10466459f, 0.06710927f, 0.01846516f, -0.07188785f, 0.04442482f, 0.10172298f, -0.10314506f, -0.08744793f, 
    0.16744308f, 0.38140243f, 0.29515719f, -0.13153334f, 0.21019818f, -0.66887563f, 0.13098007f, -0.36391738f, 
    0.65709412f, -0.10445502f, 0.23821321f, 0.71104926f, 0.24373616f, -0.36191320f, -0.10101697f, -0.03769264f, 
    0.03832373f, -0.04240083f, 0.08063857f, -0.13006479f, -0.30454049f, 0.49548382f, -0.12452976f, 0.29038969f, 
    0.00999940f, 0.07297451f, 0.14631768f, 0.26189017f, 0.16502053f, 0.00973055f, 0.04955283f, 1.12016559f, 
    -0.06331620f, 0.00741990f, 0.03556000f, -0.03977605f, 0.21523711f, 0.09185630f, 0.26236433f, 0.28065264f, 
    -0.03687358f, 0.21521924f, 0.16256088f, -0.17780451f, -0.19220379f, -0.08420502f, 0.11209293f, 0.04488816f, 
    -0.15238233f, 0.40482140f, 0.02417181f, 0.09013016f, 0.36715624f, -0.64181429f, 0.07419489f, 0.51121128f, 
    -0.02186464f, -0.21545863f, 0.20096596f, -0.04569608f, -0.01232351f, -0.13011280f, 0.17297883f, 0.56492841f, 
    -0.03472817f, -0.05234914f, -0.05117739f, 0.27806005f, -0.14550616f, -0.09328517f, -0.19946358f, 0.17221926f, 
    -0.36689812f, 0.61870593f, 0.15926254f, -0.34476212f, 0.85425425f, 0.12427279f, 0.18571365f, 0.40323588f, 
    0.01461933f, 0.22895166f, 0.09860137f, -0.00939301f, -0.19638652f, 0.14646867f, 0.16038033f, -0.19751866f, 
    -0.12026964f, 0.32939312f, -0.18439935f, 0.50088632f, -0.10960714f, 0.03085779f, -0.08796614f, -0.31642365f, 
    0.15319678f, 0.14584810f, 0.28222334f, -0.35334697f, 0.00043779f, 0.02477554f, 0.35970896f, -0.03619302f, 
    -0.02090791f, 0.24797069f, 0.05314638f, 0.92414361f, -0.02554412f, -0.37918419f, -0.10746518f, -0.29849786f, 
    0.01332730f, 0.46676287f, 0.02394104f, 0.15948825f, -0.02392296f, 0.09452408f, 0.29973501f, -0.06697736f, 
    -0.15689799f, -0.46252835f, 0.12478487f, 0.31271529f, 0.09218009f, -0.13290553f, 0.13282652f, 0.65054297f, 
    -0.19918633f, -0.15676111f, -0.33980981f, 0.24905200f, -0.12426844f, 0.21479027f, -0.23381498f, -0.30456853f, 
    0.06690030f, 0.01768984f, -0.31896693f, 0.41723919f, 0.68369472f, 0.13293989f, -0.27541521f, 0.09952509f, 
    -0.06479549f, -0.19424275f, -0.16764854f, 0.14939991f, 0.33594546f, 0.20635875f, -0.05056520f, -0.51827788f, 
    -0.22636296f, -0.18936649f, 0.22213612f, 0.06554093f, 0.15105315f, 0.06890630f, -0.15354519f, 0.50340301f, 
    0.12165938f, 0.09753720f, 0.37550229f, 0.23212884f, -0.06199036f, -0.28334337f, 0.02694628f, -0.78429788f, 
    0.64185315f, -0.42861962f, -0.11254035f, 0.36231145f, -0.20714195f, -0.16247346f, 0.16859061f, -0.16358362f, 
    -0.16203250f, -0.35997579f, -0.02316825f, -0.10362355f, -0.07678691f, 0.00549514f, -0.25254911f, 0.37980756f, 
    0.58600473f, 0.31969029f, -0.12596221f, -0.43687025f, 0.14921921f, -0.05695563f, -0.06991861f, 0.66551775f, 
    -0.09417119f, -0.04072868f, 0.25933921f, 0.03261334f, -0.08056922f, -0.24994747f, -0.00353978f, -0.03275349f, 
    -0.08287382f, -0.51471144f, 0.07975366f, -0.67026526f, -0.79278886f, 0.05961756f, 0.12001272f, 0.05263240f, 
    0.10365025f, -0.45365629f, 0.10523977f, 0.06014881f, 0.28318432f, -0.68136925f, -0.09367462f, 0.33311385f, 
    0.47069356f, -0.09301415f, 0.06010250f, -0.08686213f, 0.02745854f, -0.16148755f, -0.06947918f, -0.30510184f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19851308f, -0.18971871f, -0.04677603f, 0.21747595f, 0.29244331f, -0.08755664f, 0.15478610f, 0.08536310f, 
    0.02854004f, 0.18216385f, -0.03132681f, -0.22267039f, -0.23550683f, 0.19357394f, 0.11341387f, 0.18400550f, 
    -0.14272539f, 0.22032619f, 0.00354343f, 0.24553867f, 0.23196264f, 0.26685947f, -0.02719007f, 0.07040524f, 
    0.07492135f, 0.02578593f, 0.33160529f, -0.05333089f, 0.10215704f, 0.00734381f, 0.19644204f, 0.42845905f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.64538491f, 0.05435270f, 0.11165980f, -0.47639084f, -0.75300580f, -0.05053997f, 0.23727895f, -0.41827264f, 
    0.25928262f, -0.03663747f, -0.22590467f, 0.12971947f, -0.06962194f, -0.40105060f, -0.32563713f, 0.28021201f, 
    -0.16926098f, 0.01037340f, -0.05001627f, -0.00162266f, -0.80323267f, 0.17093453f, 0.06520829f, 0.03010856f, 
    0.09719400f, -0.81130528f, -0.58858246f, 0.22568774f, -0.09475248f, -0.04770216f, 0.18171580f, -0.46134225f, 
    -0.33578211f, -0.08640113f, -0.18302268f, 0.21316855f, 0.28139222f, 0.12112449f, 0.01768646f, 0.22370099f, 
    -0.10153386f, -0.67424315f, -0.27296001f, 0.28222319f, -0.63303202f, -0.00675132f, 0.36896929f, 0.09216259f, 
    -0.10451598f, 0.16031131f, 0.17519271f, -0.41426951f, 0.12850818f, 0.05450888f, 0.44296741f, -0.33571151f, 
    -0.06348857f, -0.55172479f, 0.12638491f, -0.41252330f, 0.12851992f, 0.19198355f, 0.12093409f, 0.26100039f, 
    0.02445970f, -0.10813756f, -0.04703348f, -0.12472992f, 0.21897984f, -0.88122344f, 0.13367957f, -0.36421499f, 
    -0.15059397f, -0.02736107f, -0.12667769f, -0.16492859f, 0.19731596f, 0.02014009f, 0.09949722f, -0.77544284f, 
    -0.18173343f, 0.07212755f, -0.12166503f, 0.21851012f, 0.28650078f, -0.27395257f, -0.90050083f, 0.04684814f, 
    0.10431378f, 0.30930009f, 0.15320405f, -0.64891165f, 0.30653301f, -0.06995361f, 0.35111997f, -0.46477944f, 
    0.02744232f, -0.13981774f, 0.25738132f, -0.28150892f, 0.01839113f, 0.23388964f, 0.21779135f, -0.23725997f, 
    0.09181971f, -0.05946350f, 0.17850579f, 0.06605823f, 0.23674084f, -0.80862880f, -0.25854349f, -0.18505725f, 
    0.02227392f, 0.06549626f, 0.08962461f, -0.14281222f, -0.11481886f, -0.16652347f, 0.41279945f, 0.30525765f, 
    0.07785352f, 0.28039458f, -0.43014154f, -0.08622719f, -0.95421368f, -0.99587739f, 0.44310337f, -0.04682074f, 
    -0.08348381f, 0.12328139f, 0.13755059f, -0.12181211f, -0.29187170f, -0.89233869f, 0.05760579f, 0.40396625f, 
    0.18467496f, -0.66784400f, 0.31913605f, 0.00081889f, 0.13723651f, 0.04508975f, 0.30490321f, 0.19580291f, 
    -0.27851313f, 0.03327411f, 0.06659287f, -0.75386167f, -0.12855472f, -0.04578722f, -0.60541928f, -0.37932619f, 
    -0.06689263f, -0.09241596f, 0.18544625f, 0.30585980f, -0.12492041f, -0.26431212f, -0.31793195f, -0.99631125f, 
    -0.08783428f, -0.15779504f, 0.23241740f, 0.26031834f, -0.04922010f, -0.27629778f, -0.03621831f, -0.05237820f, 
    -0.53325331f, 0.08448420f, -0.18212779f, -0.03323264f, -0.18096097f, -0.48587683f, 0.27806598f, 0.15148571f, 
    0.26652181f, -0.00841083f, 0.16054866f, 0.20976390f, -0.10768498f, 0.18091005f, 0.02099403f, -0.66486627f, 
    -0.05653051f, -0.26181826f, 0.10436060f, 0.21863386f, -0.66237277f, 0.19502337f, 0.04796186f, -0.16287586f, 
    -0.02235945f, 0.05660024f, -0.18976480f, -0.06304208f, 0.04886027f, -0.21834019f, -1.25831199f, -0.09975331f, 
    -0.00295491f, 0.13635680f, 0.13610195f, -0.00286026f, 0.12667787f, 0.15624239f, -0.28013110f, -0.61455643f, 
    -0.59883106f, -0.38528991f, -0.08570239f, 0.36137992f, -0.02391516f, -1.04688227f, -0.19001351f, 0.55624795f, 
    -0.01282999f, 0.47530758f, 0.14998467f, -0.24435978f, 0.32726642f, 0.24865793f, -0.58528215f, 0.33207294f, 
    0.04740737f, -0.25243440f, -0.18923749f, -0.34199122f, 0.17427981f, -0.06023373f, -0.43160102f, 0.24381380f, 
    0.52587849f, -0.24580991f, 0.35041738f, -0.93878233f, 0.23395367f, -1.12864125f, -0.10970729f, -0.42006108f, 
    -0.34948093f, -0.73169303f, 0.03474836f, -0.64032555f, -0.75547802f, -0.16198054f, 0.19390960f, 0.05626374f, 
    -0.14019571f, -0.11473077f, -0.23300025f, 0.53214657f, -0.16144443f, 0.33333272f, -0.41580963f, 0.42238066f, 
    -0.09982690f, -0.06336300f, -0.51928300f, 0.33354354f, -0.27060020f, 0.17585683f, -0.44526353f, 0.05624269f, 
    -0.14292997f, 0.13850121f, -0.45139149f, -0.34457323f, -0.95015842f, 0.15617025f, -0.04717756f, -1.00039184f, 
    0.17759068f, 0.48318857f, 0.03830891f, 0.34469652f, 0.14576012f, -0.03108600f, -0.10885306f, 0.97642803f, 
    -0.01160166f, -0.15603098f, 0.27071553f, 0.08369412f, -0.50095183f, -0.35821328f, -0.18464805f, 0.06081988f, 
    0.14857197f, -0.27508277f, 0.14135696f, -0.20182571f, -0.06509095f, -0.35178599f, -0.08099713f, 0.02043493f, 
    -0.11833436f, 0.34776875f, 0.01356017f, -0.68230009f, 0.11609147f, 0.40857211f, -0.45399785f, 0.36149478f, 
    -0.15409912f, -0.22738233f, 0.05388718f, 0.21244356f, -0.31937394f, -0.08469950f, -0.33347532f, 0.12939936f, 
    -0.08714212f, -0.12136496f, -0.15503751f, 0.25720507f, 0.28470010f, 0.16007893f, -0.70289505f, -0.00022214f, 
    -0.21055366f, 0.10052516f, -0.43840986f, 0.21475090f, 0.31825152f, -0.56308413f, -0.01226699f, 0.09465249f, 
    0.79321629f, -0.34034982f, -0.23515999f, -0.44214088f, -0.07304815f, -1.78005028f, 0.11786290f, -0.97738820f, 
    0.18401262f, 0.16983834f, 0.10394588f, -0.22604997f, 0.27711505f, 0.19821586f, -0.35572550f, -1.20037603f, 
    0.13266833f, -0.28580198f, -0.04396653f, -0.86406976f, -0.51947647f, -0.90845835f, 0.37081081f, 0.48151499f, 
    0.43209034f, 0.02784190f, -0.54712135f, 0.10664026f, -0.05739508f, -0.06351283f, -0.11068594f, 0.34105435f, 
    0.26192835f, 0.24396278f, 0.05510966f, -0.39543888f, -0.14034288f, -0.37389368f, 0.30064562f, -0.17041576f, 
    0.33588633f, -0.54319906f, 0.08833168f, 0.19581795f, 0.15465671f, 0.01094699f, 0.05546800f, -0.37275094f, 
    -0.17786884f, -0.09768230f, -0.05298260f, -0.68534797f, 0.19490153f, -0.25148353f, -0.44554564f, -1.12043750f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10608663f, 0.21676037f, 0.07302452f, -0.01508579f, -0.18441398f, -0.01400679f, -0.14755109f, 0.05939804f, 
    -0.00023646f, 0.13751119f, -0.12276766f, -0.05875046f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
