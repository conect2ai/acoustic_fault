#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.25584972f, 0.51486605f, 0.05787213f, 0.74534750f, 1.50607657f, 0.89977318f, -0.53379166f, 0.09415368f, 
    0.59894282f, 0.95290726f, 0.66418898f, 0.29292446f, 0.15498097f, -1.03280890f, -0.19605748f, 0.55503833f, 
    -0.51204097f, 0.30865791f, 0.29354537f, 0.42256215f, 0.36153257f, -0.74192178f, 0.86939174f, 0.10819536f, 
    -0.13170771f, -0.64048165f, -0.65962875f, 1.03426600f, 0.93385017f, 1.18034279f, 0.10321783f, -0.39050850f, 
    0.18921313f, 0.47223371f, 0.20415623f, 0.57462722f, 1.01866901f, 1.01330078f, 0.88552493f, 0.44793552f, 
    -0.25577745f, -0.01502881f, -0.33147496f, -0.52588123f, -0.16704403f, -0.76334924f, -1.12608922f, 0.37961179f, 
    1.00257576f, -0.33217654f, 0.73793441f, 0.43995833f, -0.53825456f, 0.67321199f, 0.97954398f, 1.11746562f, 
    -1.38734281f, -0.03317563f, 0.76192850f, -0.34842294f, 0.04125947f, -0.20836741f, -0.06693767f, -0.65883183f, 
    0.57302850f, 1.02806091f, -0.95375401f, -0.52722573f, -0.84645700f, 0.47662526f, -0.34317139f, 0.44066042f, 
    -0.72006679f, -0.00424148f, -0.71415883f, -0.55723083f, 0.31729850f, 0.85085130f, -0.61618179f, 0.10829049f, 
    -1.10977447f, -1.01376295f, -0.82565457f, -0.09409180f, 0.43098783f, 0.18273091f, -0.38957626f, 0.44077578f, 
    0.88942069f, -0.31245643f, -0.94116980f, 0.02974067f, 0.02296525f, -0.45987755f, -0.13602629f, -1.11682296f, 
    -0.57935101f, 0.66279757f, 0.50060272f, 0.74165744f, 1.15305281f, -0.19314323f, 0.68306530f, -0.58878708f, 
    0.53948587f, 0.64716405f, 0.56089211f, 0.00571543f, 0.81174260f, -1.62775826f, 1.03316808f, 0.63758439f, 
    -0.61234391f, 0.75001144f, -0.05129910f, -0.23481958f, -0.47560734f, 1.14410853f, -1.17422378f, -0.19625263f, 
    -0.46260098f, -0.96139306f, -0.48364949f, 0.46625826f, 0.24929063f, 0.42362207f, -0.75932992f, -1.69518709f, 
    -0.91549665f, -1.01947939f, 0.01127697f, 0.73944718f, -0.21200077f, -0.55614007f, 0.44530955f, 1.14978838f, 
    -0.05222403f, -1.15613794f, 1.23492301f, -0.45410162f, 0.18679079f, -0.29822579f, 0.25311106f, 0.12124572f, 
    1.10043859f, 0.43633983f, -0.01254949f, -0.81243199f, -0.75594568f, 0.86881119f, 0.12119441f, -0.25220490f, 
    -0.07323936f, 1.19525409f, 0.68174863f, -0.10214762f, -1.10772908f, -0.78498769f, -0.84192550f, -0.35566148f, 
    0.38397059f, 0.28502947f, 0.46332315f, 0.66534084f, 1.18448102f, -0.92072892f, 0.09696560f, 0.29333058f, 
    -0.21095231f, -0.40616876f, -0.64650983f, 0.76013315f, 0.60489053f, 0.70512450f, 0.11461271f, -1.03569496f, 
    -0.06309275f, -0.83843529f, -0.03503694f, -0.28028786f, -0.67818844f, -0.87013876f, -0.56439626f, -1.24130762f, 
    -0.48159492f, 0.03034854f, -0.47235075f, 0.34879476f, -0.26057005f, -1.28937113f, 0.32063410f, -0.29953545f, 
    0.55244321f, 1.45302844f, -0.01978918f, 0.30211046f, -0.65741342f, -0.32827184f, 0.70290613f, -1.46036065f, 
    -0.74260086f, 0.19271542f, 0.58414161f, 0.57492781f, -0.45895243f, 0.00165689f, -0.60713077f, -0.71858460f, 
    -1.07296574f, -1.09273088f, 0.06669237f, 0.98891717f, -0.25755280f, -0.10094948f, -0.08003522f, -0.50836849f, 
    -0.49724227f, 0.80801028f, 0.78832245f, 0.40358377f, 0.46727544f, -0.77753592f, -0.25995317f, -0.31715328f, 
    0.67819721f, -1.25129247f, -0.89567882f, -0.75229871f, 0.19821985f, -0.44261342f, 0.91196764f, 0.56534380f, 
    0.34842429f, -0.02024469f, -0.55198753f, -0.52505255f, -0.81954277f, 0.61368394f, -0.46481198f, 0.90729737f, 
    -0.40767708f, -0.37739098f, -0.68148744f, 1.00913751f, 0.78703356f, 0.92809993f, 1.18254125f, 0.75077975f, 
    0.07153305f, 0.14111376f, 0.24901550f, -0.06475876f, 1.01762331f, -0.80457747f, -0.99321967f, -0.97278714f, 
    -0.55962920f, -0.10888766f, -0.38483387f, 0.15692253f, 0.74778724f, 1.22883534f, 0.34711146f, 0.42080995f, 
    -1.13793516f, 0.99523026f, -0.88634402f, 0.03655602f, -0.05130419f, 0.19540112f, -1.14696217f, 1.16475129f, 
    1.16101694f, 0.63050926f, -0.12693700f, 0.39734483f, -0.02237599f, -0.00848938f, -0.10012703f, 0.64378822f, 
    1.06062067f, 1.09902894f, -0.35418528f, 0.78890455f, 0.05958415f, -0.04284060f, 0.44040525f, 0.31624705f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05368590f, 0.24972464f, 0.41959125f, 0.09486493f, 0.15972689f, -0.00033538f, -0.06592952f, -0.09774429f, 
    0.43371606f, -0.12893517f, 0.05851791f, -0.17645735f, -0.06523844f, 0.37474415f, 0.19702479f, -0.19443002f, 
    -0.07958791f, -0.19071545f, 0.12380908f, -0.19005030f, 0.47630629f, -0.25167423f, -0.09955031f, -0.14102332f, 
    0.04732894f, -0.01356169f, -0.45168611f, 0.44832399f, 0.07893653f, 0.10915641f, -0.03561350f, 0.48826301f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03326171f, -0.00393686f, -0.04764337f, -0.03831836f, 0.04712190f, -0.05688946f, 0.04589431f, 0.03353501f, 
    -0.05022506f, -0.02579929f, -0.04460152f, -0.02870866f, 0.02822682f, 0.01603286f, 0.03267737f, -0.05183907f, 
    -0.02151689f, 0.02670031f, -0.00713641f, 0.03595456f, -0.02468246f, -0.05290262f, -0.02934766f, 0.04311115f, 
    0.03580602f, -0.05683649f, -0.00116163f, -0.00333843f, -0.03503964f, -0.00317610f, -0.00650134f, 0.02778850f, 
    0.00769961f, 0.02647495f, 0.02833047f, -0.03673093f, -0.02450174f, -0.02222667f, 0.05453613f, 0.04585995f, 
    -0.03868970f, -0.01729789f, -0.02316988f, 0.00074898f, -0.02643242f, 0.00493903f, -0.06361723f, -0.05803689f, 
    0.00620843f, 0.04473913f, 0.03194614f, -0.00892899f, -0.01084230f, 0.05663761f, -0.00117572f, -0.01864143f, 
    -0.05122409f, -0.01579006f, -0.05510524f, -0.03318782f, -0.03492645f, -0.05440735f, 0.01518448f, 0.02834264f, 
    -0.04067222f, -0.00577053f, -0.00295324f, 0.05113999f, -0.01059668f, -0.00438010f, 0.02957292f, -0.05562239f, 
    0.00998187f, -0.03618000f, -0.02496593f, -0.02606573f, -0.03892099f, 0.02731789f, -0.01810885f, 0.00806219f, 
    0.04915676f, -0.03016989f, 0.04690935f, -0.04723752f, 0.00629918f, 0.04106849f, 0.04585008f, -0.05219176f, 
    -0.06554540f, -0.04544799f, -0.03725527f, 0.00652675f, -0.00942358f, 0.04835604f, -0.00441924f, -0.00282757f, 
    -0.03894019f, 0.04425581f, -0.03872855f, -0.03872230f, -0.00332942f, 0.00466165f, 0.03082412f, 0.00682972f, 
    0.03154787f, -0.02076124f, -0.01949989f, 0.01954106f, -0.00161117f, 0.00179492f, 0.04265585f, 0.01205915f, 
    -0.06502277f, 0.00535707f, -0.01152459f, 0.00962310f, -0.02137966f, -0.05565858f, 0.01560128f, -0.04961450f, 
    -0.01832218f, 0.04094467f, -0.00637483f, -0.03506368f, -0.01787754f, -0.05036994f, 0.01099294f, -0.05871081f, 
    -0.03195155f, 0.03939897f, 0.02206400f, 0.01997758f, -0.05734009f, -0.01757070f, -0.03490048f, 0.05072146f, 
    0.01698390f, 0.04964929f, 0.04103044f, -0.03511292f, 0.03907127f, 0.04855957f, 0.03738342f, 0.04842373f, 
    -0.03278361f, -0.04235832f, 0.05255764f, 0.00674229f, 0.04611236f, -0.00119932f, -0.02400116f, 0.03440675f, 
    -0.05363318f, -0.02616623f, -0.00180378f, -0.05138448f, -0.01839887f, 0.00472688f, -0.03472722f, -0.06091820f, 
    0.04901969f, -0.04192837f, 0.03293966f, -0.03043728f, -0.00473139f, -0.01248154f, -0.02210807f, -0.02819644f, 
    0.01988703f, -0.05898128f, 0.00803399f, -0.03918941f, 0.04226029f, -0.04123772f, 0.05694752f, -0.03867038f, 
    -0.01881177f, -0.01680223f, -0.04459913f, -0.04590118f, -0.03379142f, -0.06422646f, 0.00649451f, 0.02575839f, 
    0.04414061f, -0.05229860f, 0.05546297f, 0.03348933f, -0.01348303f, -0.03499125f, 0.04920376f, -0.01680198f, 
    -0.01613639f, -0.01655241f, -0.03026858f, 0.06072462f, -0.04010328f, -0.02592631f, 0.01656444f, -0.04513294f, 
    0.01296483f, -0.03422809f, 0.00002002f, 0.04305348f, 0.03023181f, 0.02819841f, -0.06485707f, -0.03669828f, 
    -0.03420829f, -0.03044489f, 0.02172412f, -0.03013702f, -0.02158249f, -0.05815228f, -0.00791414f, -0.01217867f, 
    -0.02282852f, -0.04014259f, 0.04145603f, -0.03156433f, -0.03301597f, -0.02927030f, -0.04089281f, -0.01287353f, 
    0.00455483f, 0.02818784f, 0.03706698f, 0.01544802f, 0.03616758f, -0.03245031f, -0.05993694f, 0.03186077f, 
    -0.02073335f, -0.06027796f, 0.04382588f, -0.05507856f, 0.01559442f, -0.01434884f, 0.02960918f, -0.02592233f, 
    0.03585682f, 0.05068702f, -0.01573775f, 0.02718081f, 0.02160941f, -0.04478269f, 0.05010208f, 0.03582071f, 
    -0.04518786f, -0.05181685f, 0.03169948f, -0.01021154f, 0.04769563f, -0.01500159f, -0.02505343f, -0.04842788f, 
    -0.04138527f, -0.03252846f, 0.03243934f, -0.04701180f, -0.01297131f, 0.03571090f, -0.04397159f, 0.05748114f, 
    -0.05617500f, 0.02947008f, 0.00403805f, 0.02476177f, 0.00593780f, 0.03311178f, -0.03811061f, 0.05011692f, 
    -0.00170249f, -0.06143962f, -0.04152059f, 0.02668384f, 0.03482236f, -0.01495506f, 0.02875452f, -0.00009901f, 
    0.02178062f, 0.03092926f, -0.03162162f, 0.02665305f, -0.06486744f, -0.04358327f, 0.02013466f, 0.00777887f, 
    0.02153629f, 0.03626480f, 0.04457079f, -0.01959295f, 0.04549119f, -0.01769025f, 0.05574083f, -0.05025797f, 
    0.02528738f, -0.04129377f, -0.05766260f, 0.04346339f, -0.00644363f, 0.00133044f, -0.04735325f, -0.00618070f, 
    0.00498164f, 0.04156643f, -0.03767613f, -0.04514745f, 0.00753980f, 0.03031882f, 0.00154912f, -0.06217568f, 
    -0.03639224f, 0.01923450f, 0.01925315f, -0.05101334f, 0.01640130f, -0.05554062f, -0.01756482f, -0.04532529f, 
    -0.01142223f, 0.03623387f, -0.01384800f, -0.05133130f, 0.02803677f, -0.02520096f, 0.03827495f, -0.06170822f, 
    -0.03432475f, 0.03652250f, -0.06445648f, 0.02649024f, -0.06634697f, 0.02150636f, 0.04580200f, -0.06168614f, 
    -0.03244032f, 0.01145331f, 0.02126388f, 0.00184449f, -0.02041728f, -0.02568491f, -0.03852311f, -0.03590192f, 
    -0.03499670f, -0.05097627f, -0.02130816f, 0.02040476f, -0.00889584f, 0.00485081f, 0.04406888f, 0.01214298f, 
    -0.01935819f, -0.00803309f, -0.01480180f, 0.01280020f, 0.02006133f, -0.04679032f, -0.00363848f, -0.04356578f, 
    -0.02833717f, 0.00041300f, -0.00156987f, 0.02709972f, 0.01050763f, 0.01505745f, 0.02652423f, 0.02377330f, 
    0.00755107f, 0.02118560f, -0.05094453f, -0.05031057f, 0.03584989f, 0.03227559f, -0.01288189f, 0.02454804f, 
    0.03871167f, -0.00402141f, 0.03459905f, 0.02913544f, -0.01767608f, 0.05424758f, -0.03861252f, 0.03465086f, 
    0.03913376f, 0.03710490f, -0.05898074f, -0.04694399f, -0.00459857f, -0.04667060f, -0.02212869f, -0.05047095f, 
    -0.02632022f, -0.00374076f, 0.02055763f, -0.04663192f, -0.00190739f, 0.02020160f, -0.03374516f, -0.01193296f, 
    -0.02434042f, -0.05043644f, -0.05156538f, 0.02217760f, 0.01799186f, 0.01852795f, -0.00833613f, 0.04564644f, 
    -0.02496060f, 0.00704489f, -0.00548680f, -0.03240944f, -0.03231549f, 0.04116365f, 0.02033499f, -0.06159319f, 
    -0.05405805f, -0.01580978f, -0.02330486f, 0.03511165f, -0.06145162f, -0.02103723f, -0.03408550f, 0.02460741f, 
    0.05163062f, 0.04427511f, -0.03914322f, 0.02082057f, -0.01180629f, -0.00849325f, -0.04759573f, -0.05137447f, 
    0.02531398f, 0.02493490f, -0.00554980f, 0.00183149f, 0.04672829f, -0.00797512f, -0.06262981f, 0.00697003f, 
    -0.05619458f, 0.03015038f, -0.06607392f, -0.04490239f, 0.02637368f, -0.04618103f, 0.04736819f, 0.02568551f, 
    0.00271022f, 0.04455109f, 0.02136172f, 0.03102165f, 0.01064150f, 0.03573237f, -0.06472345f, 0.02786083f, 
    -0.01463555f, -0.05681916f, 0.04923071f, -0.01105190f, -0.05450286f, 0.00517739f, -0.06144638f, -0.02246541f, 
    -0.02493462f, -0.03949150f, -0.02439783f, -0.05603797f, -0.03527303f, -0.00756327f, -0.04831354f, 0.01687900f, 
    0.03888305f, -0.00577657f, 0.03130561f, -0.03471617f, -0.05076475f, -0.04567392f, 0.03665266f, -0.04506244f, 
    0.00348576f, -0.01699973f, -0.04346594f, -0.04460334f, -0.05754623f, -0.00591576f, -0.04145411f, 0.00213144f, 
    0.00710389f, 0.04687711f, 0.01435646f, -0.00865507f, -0.05721869f, 0.02466638f, 0.00111337f, 0.00356486f, 
    -0.05111584f, -0.05650437f, -0.04343196f, 0.05202296f, 0.01596690f, -0.04787666f, 0.01165239f, -0.03201368f, 
    0.02820641f, 0.01271967f, -0.01320599f, 0.00511723f, -0.00643794f, -0.05557189f, -0.03875993f, -0.00196802f, 
    -0.00867560f, -0.03445645f, 0.00711130f, -0.01805391f, -0.04587226f, -0.04867071f, 0.04626963f, -0.06490523f, 
    -0.04650284f, 0.04592270f, 0.04809262f, -0.05676539f, -0.04042702f, 0.03238712f, 0.03093137f, -0.04140178f, 
    0.03711673f, 0.04398340f, -0.04432087f, 0.00842522f, 0.04412787f, -0.02781366f, 0.01639627f, 0.04588335f, 
    0.04376755f, -0.04333908f, -0.04391041f, 0.00088488f, 0.04612469f, -0.05458387f, -0.04348896f, -0.05338500f, 
    0.04249419f, -0.03390903f, -0.04774083f, -0.02749315f, 0.05440652f, 0.02046208f, -0.03848741f, -0.02648057f, 
    -0.02627462f, -0.04005328f, 0.03162627f, 0.01330728f, 0.01074390f, -0.01624367f, 0.00480012f, 0.05018897f, 
    0.05062167f, 0.01093993f, 0.02536334f, 0.05669267f, 0.01309920f, 0.01694941f, -0.00498870f, -0.01999665f, 
    0.02808995f, -0.00637489f, -0.00869311f, 0.04354345f, 0.02410969f, 0.02161195f, -0.03059119f, -0.04621635f, 
    -0.24328770f, 0.06127987f, 0.08108737f, 0.34952667f, 0.15858899f, -0.10221986f, -0.00173748f, -0.01413076f, 
    0.07827767f, -0.36658132f, 0.01600624f, 0.13058002f, 0.04887798f, 0.13935669f, 0.04500986f, 0.00077035f, 
    -0.04672089f, 0.16412354f, -0.02037958f, 0.56638879f, -0.20046961f, 0.06832427f, 0.16207561f, 0.11681221f, 
    0.19863059f, 0.14995089f, 0.01827505f, -0.56157660f, -0.19749498f, 0.12515600f, 0.01395799f, -0.06705760f, 
    0.24580300f, 0.07240951f, 0.00200554f, 0.19629595f, -0.27711323f, 0.10068021f, 0.13690218f, 0.14558044f, 
    0.00512698f, 0.15735646f, -0.07222612f, -0.18185341f, 0.19435199f, 0.28196168f, -0.03930582f, 0.14097787f, 
    0.18562877f, 0.05546993f, 0.00306000f, 0.10193154f, 0.12738276f, 0.01754523f, -0.16047329f, 0.04571359f, 
    0.12983052f, -0.01503625f, -0.04313473f, 0.00484255f, -0.01767949f, 0.28469765f, -0.05121125f, 0.28124991f, 
    0.08134066f, 0.23357587f, -0.12596561f, -0.41558066f, 0.00202353f, 0.05966211f, 0.01877933f, 0.27545384f, 
    0.17183034f, 0.09094252f, -0.07356118f, 0.04434875f, 0.03118371f, -0.15312545f, 0.20469463f, 0.15580700f, 
    0.15778552f, 0.20361952f, -0.29232115f, -0.13100366f, -0.10496195f, 0.23941436f, 0.08728550f, 0.17728187f, 
    0.06920400f, -0.15854551f, 0.47585919f, 0.16799934f, 0.15055265f, -0.10863961f, -0.23821276f, 0.10610308f, 
    0.03936306f, 0.03690419f, 0.12204985f, -0.61453390f, -0.11673286f, -0.18730050f, 0.07503712f, -0.07936805f, 
    -0.19337219f, -0.05146028f, -0.05625282f, -0.04041537f, -0.03184397f, 0.02070213f, -0.19871320f, 0.04559641f, 
    0.13331409f, 0.08098086f, -0.17652664f, -0.14487983f, 0.02623560f, 0.06695897f, -0.28360975f, 0.40437868f, 
    -0.01571507f, -0.04195213f, 0.10961578f, 0.11529525f, 0.21908404f, -0.01609111f, 0.03288051f, -0.35199779f, 
    0.20232612f, -0.08430284f, -0.08677384f, 0.13383517f, 0.02111930f, 0.03524799f, 0.24813911f, -0.11101095f, 
    -0.04046458f, 0.15717611f, -0.07461771f, -0.09295888f, 0.03331862f, -0.18878253f, -0.03584567f, -0.06929015f, 
    0.08001372f, -0.00951555f, 0.02803987f, -0.02394900f, -0.04568383f, 0.01776223f, 0.10275149f, -0.15420680f, 
    -0.03413089f, 0.04314467f, -0.26868796f, 0.25631362f, -0.18792759f, -0.26333120f, -0.00963058f, -0.00273654f, 
    0.14865176f, 0.00565868f, -0.01984004f, 0.20272890f, -0.04070227f, -0.13734892f, 0.06672753f, 0.13650995f, 
    0.12028503f, -0.02335445f, -0.04887466f, -0.20272264f, -0.06050744f, 0.19150184f, -0.18892747f, -0.15521903f, 
    0.10329938f, -0.05733479f, -0.15072465f, 0.17115422f, 0.16489597f, -0.07914647f, 0.00081396f, -0.10987759f, 
    0.07159543f, 0.00157781f, 0.02679628f, 0.18567392f, 0.09553717f, -0.08821046f, 0.07238086f, 0.01268538f, 
    0.11449357f, 0.12247173f, -0.08407028f, -0.16128510f, 0.12638438f, -0.13908072f, 0.11096082f, -0.14873160f, 
    0.31928429f, -0.00371258f, -0.05185449f, -0.22778170f, -0.09288626f, -0.04033632f, 0.12648661f, 0.12280713f, 
    -0.41673028f, 0.21033546f, -0.06539235f, 0.11851609f, 0.27337173f, 0.15739077f, 0.12063987f, -0.02580045f, 
    -0.39932871f, 0.22627711f, -0.07186281f, 0.06657220f, -0.15963401f, 0.01443658f, -0.00471213f, -0.00746631f, 
    -0.01953991f, 0.26509219f, -0.33245912f, 0.07382926f, 0.26297206f, 0.35333741f, -0.16433141f, 0.14698802f, 
    -0.00386993f, -0.05911417f, 0.20053230f, -0.34410003f, 0.13812253f, 0.11445039f, 0.22088508f, -0.24547993f, 
    0.02669122f, -0.06744156f, 0.09791136f, -0.78457952f, -0.15090765f, 0.08441865f, 0.03536165f, 0.05553680f, 
    0.28371024f, 0.06533783f, -0.02235200f, 0.21650667f, 0.03483795f, -0.09338070f, 0.06822485f, -0.17558862f, 
    0.05687859f, -0.01875182f, 0.02121152f, 0.03808831f, -0.05202083f, -0.42004079f, 0.00531414f, 0.07408931f, 
    0.09382912f, 0.10363454f, 0.16720849f, 0.10385950f, -0.07384828f, 0.05661010f, -0.08064537f, -0.01940276f, 
    -0.23202835f, 0.19030800f, 0.00778538f, 0.17135172f, -0.03221572f, 0.03145533f, 0.08137538f, -0.40426397f, 
    0.14199464f, 0.12212284f, -0.04242129f, 0.12157562f, 0.27164632f, 0.08272823f, 0.07312900f, 0.20482624f, 
    0.02884873f, 0.38384452f, -0.05085200f, -0.14676370f, -0.06338121f, -0.09786083f, 0.10385665f, -0.01295103f, 
    0.25459549f, 0.20369610f, -0.05340405f, -0.38695118f, 0.31050557f, 0.19097546f, 0.08537968f, -0.16355981f, 
    0.14767958f, -0.22329794f, -0.24234825f, 0.03416454f, 0.14931312f, -0.21114272f, 0.07002047f, 0.15971062f, 
    0.21576513f, -0.05830892f, -0.13875236f, -0.52657801f, -0.66252363f, -0.03672570f, 0.21336605f, 0.25273004f, 
    0.07099100f, -0.05829377f, 0.03912200f, -0.04053371f, -0.28624639f, -0.47564974f, -0.39129248f, 0.18780495f, 
    0.17385039f, 0.21062204f, 0.04075773f, -0.09333903f, -0.11935034f, 0.46770304f, -0.20771785f, -0.00597681f, 
    -0.22851254f, -0.05746086f, -0.16553953f, -0.07772335f, -0.00896639f, 0.02425408f, 0.11266283f, 0.01650638f, 
    0.09662119f, 0.00409597f, 0.02728421f, 0.08074816f, -0.05259022f, 0.12931222f, -0.04056101f, 0.30519456f, 
    0.57854927f, 0.40870151f, 0.38291490f, -0.07825063f, -0.14203435f, -0.23236142f, -0.08860703f, 0.17363636f, 
    -0.33578008f, 0.20219448f, 0.00401909f, -0.20372474f, 0.02909082f, 0.09874436f, 0.04599035f, 0.05453104f, 
    0.23133123f, 0.21218911f, 0.14695294f, 0.19601981f, -0.24551801f, 0.05557666f, -0.13739987f, 0.01305494f, 
    -0.05444027f, 0.21686168f, 0.19481082f, 0.38677797f, 0.18422791f, 0.01929422f, -0.07673871f, -0.22849473f, 
    0.20042437f, -0.13437267f, 0.09544129f, -0.41362649f, -0.32023883f, -0.25983784f, -0.04119999f, -0.09893053f, 
    0.29531693f, -0.15726312f, 0.11921785f, 0.00511118f, 0.18198112f, -0.05693345f, 0.08848297f, 0.11820547f, 
    0.13332921f, -0.04716359f, 0.03675626f, 0.02354335f, -0.31613672f, 0.46720168f, 0.34266198f, 0.18268508f, 
    0.01346472f, 0.17954555f, -0.16456716f, -0.02984134f, 0.15141805f, 0.13635001f, -0.16535284f, -0.18650100f, 
    -0.08075816f, -0.09775158f, -0.01276613f, 0.00011248f, 0.00671148f, 0.01411470f, -0.17233692f, 0.17965259f, 
    0.39088297f, 0.31906310f, 0.07898924f, -0.01646469f, 0.01901283f, -0.24184802f, -0.14853580f, 0.04536889f, 
    -0.04841635f, -0.10108037f, -0.06916105f, -0.10491250f, 0.44918680f, 0.08230301f, 0.13708538f, 0.08635873f, 
    -0.27731287f, 0.20061111f, 0.26674092f, 0.23422699f, 0.22844978f, 0.05411436f, -0.02193191f, 0.12218332f, 
    0.16306087f, -0.06471727f, -0.30424565f, 0.05362643f, 0.20329654f, -0.05378745f, 0.40438193f, 0.00280325f, 
    0.04246323f, -0.08577016f, 0.03412270f, -0.41345128f, -0.52247810f, -0.03957189f, 0.27506131f, 0.23632772f, 
    0.05449335f, -0.10199516f, -0.15679432f, -0.11100221f, -0.24273276f, 0.19437933f, 0.11760966f, -0.10644263f, 
    0.10476420f, -0.12930268f, 0.00221286f, 0.04666609f, -0.10046058f, 0.05482085f, 0.42145923f, -0.00579289f, 
    0.03689198f, -0.14704357f, -0.08496593f, -0.12926912f, 0.40761399f, 0.33012137f, -0.05574984f, -0.12908728f, 
    -0.08258975f, 0.00969121f, 0.05363077f, -0.00676979f, -0.03937920f, -0.20273055f, 0.04138258f, -0.26669830f, 
    0.15464351f, 0.13509522f, -0.11521228f, -0.12304657f, 0.18923397f, -0.07182707f, -0.05387458f, 0.13898680f, 
    0.30832219f, 0.10991425f, -0.02076361f, 0.13131212f, -0.05105267f, 0.08556163f, -0.17618655f, 0.06530876f, 
    -0.26766017f, 0.24825166f, -0.21272525f, -0.15073994f, -0.25462982f, -0.00934325f, -0.10147035f, 0.08672612f, 
    0.05949726f, 0.32470694f, 0.01081390f, 0.04187217f, 0.19244544f, 0.09380070f, 0.04785887f, 0.16725558f, 
    -0.19057778f, -0.15525636f, 0.15724416f, -0.82609582f, -0.49144697f, -0.33547541f, 0.03703180f, -0.11597198f, 
    0.21111797f, 0.11984195f, -0.02770950f, -0.04882476f, 0.33251825f, 0.17704232f, -0.07041287f, 0.01347102f, 
    -0.01594244f, -0.25985932f, 0.30532983f, 0.17127843f, 0.05047224f, -0.72233450f, 0.15321101f, 0.14010242f, 
    -0.00525012f, 0.06844354f, 0.05822702f, 0.00756961f, -0.13418561f, 0.01035071f, 0.30657819f, 0.03870216f, 
    -0.19802342f, -0.09794371f, 0.01853487f, -0.14753824f, 0.04154775f, -0.14528106f, -0.22560167f, -0.77073729f, 
    -0.06407505f, 0.15205276f, -0.11599495f, 0.24017979f, 0.09911457f, 0.10451218f, -0.15137605f, -0.02235822f, 
    -0.00157614f, -0.00182818f, 0.03871792f, -0.04382632f, -0.00259951f, -0.05055548f, -0.05145345f, 0.01422783f, 
    -0.03885029f, -0.03784020f, 0.05425323f, 0.03449646f, 0.00741206f, 0.01485190f, -0.06607550f, 0.00040474f, 
    0.03381024f, -0.03044148f, -0.05070903f, 0.05120187f, -0.00890707f, -0.04473641f, -0.04163000f, 0.03935429f, 
    -0.03541274f, 0.04912484f, 0.00140806f, 0.02925768f, -0.03663069f, 0.04201872f, 0.02028840f, 0.01855817f, 
    -0.03039136f, -0.05562486f, 0.00250482f, 0.00418066f, -0.01879136f, 0.04408124f, 0.05801990f, 0.01547596f, 
    0.00998083f, -0.03831897f, -0.02665178f, 0.02531069f, 0.01422371f, -0.04654707f, 0.01709640f, -0.02953023f, 
    -0.04131984f, -0.01291969f, -0.04137259f, 0.02163191f, -0.04255402f, -0.05812794f, -0.05298165f, -0.05568296f, 
    -0.04246731f, -0.00438980f, 0.05054985f, -0.01242835f, -0.01028374f, -0.04164775f, -0.04808962f, -0.00553634f, 
    -0.00524095f, -0.04877034f, -0.01369011f, 0.03116406f, -0.03490138f, -0.06191224f, 0.03411856f, -0.05685367f, 
    0.03031211f, 0.05159128f, -0.01103741f, 0.03238272f, -0.04805905f, 0.04648462f, -0.05161284f, -0.03694204f, 
    -0.00237795f, -0.04126810f, -0.04234917f, -0.02432774f, 0.03997688f, 0.00487842f, -0.00690630f, -0.04674801f, 
    0.04989766f, 0.00046391f, -0.05257819f, -0.06422321f, 0.05109094f, -0.04448815f, -0.02349997f, 0.02066889f, 
    0.02497991f, 0.00986035f, -0.03271338f, -0.04682421f, 0.00522120f, 0.02466978f, -0.01810824f, 0.03477989f, 
    0.01712770f, -0.06150599f, 0.02149495f, -0.00577806f, -0.03126964f, -0.05450247f, -0.04843757f, -0.04487084f, 
    -0.04928441f, 0.01099405f, 0.01794397f, -0.04111056f, -0.04720333f, 0.00344225f, -0.05192202f, 0.04904788f, 
    0.05049055f, 0.02892864f, 0.01167086f, 0.05178738f, 0.01229841f, 0.04551793f, -0.00159263f, 0.02345944f, 
    0.05359945f, -0.03404698f, -0.05285770f, -0.05339849f, -0.03018911f, -0.01869540f, -0.02912154f, -0.01577984f, 
    -0.05117927f, -0.04198861f, 0.02920515f, 0.02980053f, 0.00941930f, 0.04849394f, 0.00353721f, 0.03249522f, 
    -0.05484767f, 0.04079638f, 0.04177864f, -0.02574394f, -0.01495154f, 0.04148312f, -0.01070458f, -0.04948804f, 
    -0.03768277f, 0.01755755f, -0.01134632f, -0.02711422f, -0.02393297f, -0.03786182f, -0.02646478f, -0.03009748f, 
    0.02298260f, 0.04223443f, -0.02486252f, 0.00960233f, -0.04642844f, 0.03041831f, -0.04292008f, 0.00861888f, 
    0.00348314f, 0.00615166f, -0.06406917f, 0.05704490f, -0.05635318f, 0.05009141f, -0.01130050f, -0.02842904f, 
    -0.01597645f, -0.00076015f, 0.02530010f, -0.06540001f, -0.02256718f, 0.03360700f, -0.06291852f, -0.04173519f, 
    0.01375194f, 0.03204086f, -0.01858882f, -0.00216046f, -0.03452110f, -0.04071013f, 0.03515238f, 0.04250072f, 
    -0.04028042f, 0.04639316f, -0.02811828f, -0.06316781f, -0.04537186f, 0.04723714f, 0.01892596f, -0.06168334f, 
    -0.02076806f, -0.02740730f, 0.00700215f, 0.03737380f, -0.04770338f, -0.00843902f, 0.03204691f, -0.05347298f, 
    -0.03309998f, 0.01233771f, -0.03333391f, -0.00396611f, 0.03655129f, 0.04873011f, 0.00061306f, 0.05919869f, 
    0.03121603f, 0.01497104f, 0.01686647f, -0.00833014f, 0.03402444f, -0.00400738f, -0.02507601f, -0.05064661f, 
    -0.03881526f, 0.00698006f, 0.02308126f, 0.02983361f, 0.05672303f, -0.03032853f, -0.03023706f, 0.05812581f, 
    0.03826424f, -0.02922316f, -0.02316707f, -0.06754432f, -0.06135400f, 0.00848893f, -0.04411338f, -0.02746733f, 
    0.03434615f, -0.04105033f, 0.03429706f, -0.04048845f, -0.04898932f, -0.02008165f, -0.05688670f, 0.03301045f, 
    -0.01762394f, -0.02303760f, 0.01596525f, 0.01574170f, 0.04064639f, -0.02817078f, 0.02556004f, 0.01240408f, 
    0.05010144f, 0.00873554f, 0.05004273f, 0.00830621f, 0.02087499f, 0.02841944f, -0.04428476f, 0.00298979f, 
    -0.02009363f, -0.02051333f, -0.04211260f, 0.01581549f, -0.01797818f, 0.05681090f, -0.05120768f, 0.03447805f, 
    -0.03581865f, 0.02525171f, -0.05211758f, -0.02324588f, -0.02755250f, -0.03205569f, 0.03762802f, -0.01199987f, 
    -0.04937717f, -0.04868302f, 0.01682822f, -0.01354073f, -0.02532283f, -0.04555501f, 0.01911284f, -0.00062577f, 
    -0.04392386f, 0.01689363f, 0.03931911f, 0.02763425f, -0.03586975f, 0.04063799f, -0.00585718f, -0.02842549f, 
    -0.04123111f, 0.00927630f, -0.02663714f, 0.00768339f, 0.04568271f, -0.02846903f, -0.02281887f, -0.04153789f, 
    -0.02551428f, -0.06179753f, 0.02240315f, 0.03548319f, 0.01342255f, -0.00099949f, 0.00702126f, -0.02707417f, 
    0.00869920f, -0.03783179f, -0.00032610f, 0.04535359f, -0.04181855f, -0.04207981f, -0.02878276f, 0.01784035f, 
    -0.03710475f, -0.02203974f, 0.02254790f, -0.06663502f, -0.01041720f, -0.06387342f, -0.00146702f, 0.02615275f, 
    -0.01814755f, -0.00559216f, 0.04990114f, 0.00773560f, -0.06584115f, 0.04874724f, 0.02340137f, -0.01744170f, 
    -0.02767393f, -0.02400690f, -0.04430711f, -0.00394063f, 0.02032079f, -0.03221090f, 0.01235348f, -0.05268475f, 
    0.04595152f, -0.05151428f, -0.02877647f, 0.04091270f, 0.01389540f, -0.04951318f, 0.00313985f, -0.00313140f, 
    -0.02624613f, 0.02883981f, -0.05235231f, -0.01436558f, -0.00011368f, 0.02373225f, 0.03948273f, -0.05813185f, 
    -0.02587410f, -0.02861439f, 0.02042200f, -0.01246526f, -0.05592474f, -0.00465019f, -0.01491275f, -0.06220992f, 
    -0.03873548f, -0.00589188f, -0.03166199f, -0.00940643f, 0.02719591f, 0.04427236f, -0.06628136f, -0.05536805f, 
    -0.01550326f, -0.04478009f, 0.03671413f, -0.02271750f, 0.01553609f, -0.04020282f, 0.00237350f, 0.01271572f, 
    -0.04400610f, -0.05404890f, 0.04222257f, -0.04323940f, -0.02725024f, -0.01910562f, 0.03112628f, -0.04347013f, 
    -0.02165138f, 0.04011239f, -0.05139277f, -0.06067335f, -0.02109885f, 0.01022737f, -0.05673753f, -0.03385152f, 
    0.01869883f, -0.04630963f, -0.05629901f, 0.01830209f, -0.06058010f, -0.03873656f, 0.02864141f, -0.00810866f, 
    0.00403905f, 0.00601312f, 0.02675164f, 0.04487411f, 0.03929956f, 0.00441264f, -0.00467941f, -0.04612472f, 
    -0.02158559f, 0.01711817f, -0.06580101f, -0.01013131f, -0.00917357f, -0.04449251f, -0.04886584f, 0.02215707f, 
    0.04790139f, 0.04258895f, 0.02442632f, 0.00416102f, -0.02597801f, 0.04379660f, -0.05372357f, -0.03698634f, 
    0.03537403f, -0.02151125f, 0.00888577f, 0.00063488f, -0.01521790f, 0.01190564f, -0.00430256f, 0.00296191f, 
    -0.03041364f, -0.06050230f, -0.01726663f, -0.04682844f, 0.05089747f, -0.04894456f, 0.00442641f, 0.01197566f, 
    -0.02821084f, -0.05053735f, -0.05758554f, 0.02635082f, -0.00119921f, -0.01079491f, 0.00920334f, -0.00454029f, 
    -0.04098048f, 0.01125694f, 0.02633304f, 0.02887421f, -0.03937330f, -0.00525825f, -0.05101314f, 0.01542493f, 
    -0.00657545f, 0.05251606f, -0.05792962f, -0.05996149f, -0.01397282f, -0.06142435f, 0.00049909f, 0.03711348f, 
    0.01570877f, -0.02659732f, -0.04707700f, -0.00110740f, -0.01631621f, -0.00376154f, 0.04395456f, -0.02366547f, 
    -0.02699947f, -0.00477261f, 0.04835132f, -0.02936589f, 0.00020375f, 0.01648549f, -0.01488736f, -0.04765005f, 
    0.00731695f, -0.00896427f, 0.01777024f, -0.03103136f, 0.03220237f, -0.05139109f, -0.04251090f, 0.03948309f, 
    -0.02902793f, -0.06908642f, -0.02013200f, 0.00261711f, 0.04589693f, -0.01305971f, 0.04632651f, 0.03843446f, 
    0.03757866f, -0.00628420f, -0.02679016f, -0.05005544f, 0.00963349f, 0.01582259f, 0.04031648f, -0.02815369f, 
    -0.01545938f, -0.03079463f, -0.01692504f, -0.01988635f, -0.00229062f, -0.05585501f, 0.04456116f, -0.05916427f, 
    -0.01209472f, 0.03914704f, 0.00600149f, -0.01133303f, 0.02119010f, -0.04721098f, 0.02316588f, -0.01140781f, 
    0.00059536f, 0.03761306f, -0.03514407f, -0.02476881f, 0.00714373f, -0.03041864f, -0.04054796f, -0.03734176f, 
    -0.04490314f, -0.05118034f, -0.01580229f, 0.01686756f, -0.05452018f, -0.05375112f, -0.01825976f, -0.06466384f, 
    0.00805543f, 0.03915961f, 0.02719904f, -0.02464154f, 0.00482645f, 0.00115449f, 0.04597686f, -0.02653690f, 
    0.01100024f, -0.02477359f, -0.00306843f, -0.04335131f, -0.03051456f, -0.05434030f, 0.03238181f, -0.04039106f, 
    -0.01822176f, -0.05486783f, 0.00240146f, -0.04204668f, 0.04103076f, 0.04559027f, -0.04532696f, 0.01262385f, 
    -0.00680025f, -0.00469589f, 0.04758756f, -0.05969568f, 0.04896734f, 0.01099441f, 0.04901060f, 0.01331252f, 
    -0.49220067f, -0.42234644f, 0.03093681f, -0.02310442f, 0.20958619f, 0.14535236f, -0.06510738f, 0.02712142f, 
    0.12250027f, 0.28706819f, -0.11081427f, 0.14832525f, 0.01312256f, -0.03114362f, 0.00163201f, 0.20272072f, 
    0.00696907f, 0.18217678f, -0.05644404f, 0.16761905f, -0.00567348f, -0.18297735f, 0.21694216f, 0.11486217f, 
    0.03040187f, -0.11242174f, 0.15475161f, 0.41952047f, -0.14760077f, 0.21822987f, 0.12067625f, -0.20562102f, 
    -0.08737908f, 0.29787365f, -0.01058563f, -0.03583705f, 0.21183144f, -0.02676205f, 0.16889153f, -0.04218866f, 
    -0.19205244f, 0.28955868f, -0.08684080f, 0.07038447f, 0.20921135f, 0.01570594f, -0.07404441f, -0.14174321f, 
    -0.02118251f, 0.00729940f, 0.13320424f, -0.22662909f, -0.02644005f, 0.13455683f, 0.15205768f, -0.25254270f, 
    0.13173823f, 0.03974583f, 0.11725377f, 0.04209156f, 0.03883433f, -0.33403149f, -0.10596111f, 0.13487917f, 
    0.13201262f, 0.19504149f, -0.05783951f, -0.08786654f, -0.21551943f, 0.20900707f, -0.26158652f, -0.25171760f, 
    -0.36335421f, -0.23170611f, 0.02624215f, 0.13180448f, 0.26450586f, 0.05527920f, 0.10456894f, 0.10429366f, 
    0.13382584f, 0.22947754f, -0.36693868f, -0.00129057f, -0.20914768f, 0.03434280f, 0.13250257f, 0.25008443f, 
    -0.27660409f, -0.31943753f, -0.05525047f, 0.28162101f, -0.28185108f, 0.18239114f, -0.07312537f, -0.03255089f, 
    0.06057400f, -0.24307339f, -0.03171622f, 0.02492423f, -0.20171662f, 0.03832528f, 0.23352489f, -0.05886446f, 
    -0.17378610f, 0.13025668f, 0.01695076f, -0.01951603f, -0.12564202f, -0.08808991f, -0.05687518f, 0.20440474f, 
    -0.05004634f, 0.06633092f, 0.11446813f, -0.07358473f, 0.05282876f, -0.14521113f, -0.08144332f, -0.05481520f, 
    -0.06206599f, 0.09568153f, -0.18486087f, 0.13321164f, 0.05815994f, 0.00619300f, -0.29996723f, 0.21005224f, 
    0.15614453f, -0.04684003f, 0.03621377f, 0.09314293f, -0.07842615f, 0.14547859f, 0.01609097f, -0.17998947f, 
    -0.42764908f, 0.01038994f, 0.05121092f, 0.16797319f, -0.22669263f, -0.19344950f, -0.24455914f, 0.00813249f, 
    0.09070366f, 0.07798377f, 0.00024672f, 0.09751615f, 0.04841341f, -0.20810282f, 0.01379733f, -0.13045198f, 
    0.12358553f, -0.20386462f, -0.06783863f, 0.15472178f, -0.19181809f, 0.05261050f, 0.10009625f, 0.06611113f, 
    0.00105376f, -0.09580415f, 0.21047910f, 0.08269337f, 0.01287186f, 0.10943919f, 0.10929577f, -0.19570029f, 
    0.06719851f, -0.19582497f, 0.02188142f, 0.10388942f, -0.00047981f, 0.14092572f, -0.06377698f, -0.00620007f, 
    0.22004344f, -0.14788136f, 0.08930305f, 0.06151421f, 0.28454217f, 0.01390513f, 0.05348846f, -0.06579421f, 
    0.04365147f, 0.04990543f, 0.02865706f, -0.03428733f, -0.17466465f, -0.45294753f, -0.22730090f, 0.04518704f, 
    -0.00071370f, 0.12393953f, 0.08777221f, -0.14497019f, 0.06291088f, 0.10349333f, -0.25393730f, 0.00588321f, 
    0.12657505f, -0.04551672f, -0.02027625f, -0.03257754f, 0.28617853f, 0.03485371f, 0.02581852f, 0.12112580f, 
    0.19673575f, 0.20661515f, -0.20351687f, -0.05360617f, -0.02034154f, 0.03418886f, 0.05334887f, 0.03838794f, 
    0.22521889f, -0.18409617f, -0.31890282f, 0.05878467f, -0.08770572f, 0.03221991f, 0.10613888f, -0.29242152f, 
    0.01180349f, -0.06991746f, -0.23826586f, -0.04443263f, -0.09894732f, -0.11209404f, -0.04333770f, 0.10915021f, 
    -0.10548382f, -0.05288132f, -0.55123580f, -0.33858958f, 0.16839825f, 0.06330282f, 0.01137876f, -0.16739047f, 
    0.01714455f, -0.10963804f, -0.02706507f, -0.11589129f, -0.03349235f, 0.01980495f, 0.02635833f, -0.11524836f, 
    0.02307423f, 0.04495084f, 0.22525510f, -0.14895566f, -0.25066289f, -0.06141888f, -0.31649259f, -0.08621662f, 
    0.11280838f, 0.23753043f, 0.10326243f, -0.10334747f, 0.12967654f, 0.15900362f, 0.49886358f, 0.10767929f, 
    0.03554226f, 0.01927742f, -0.01469486f, 0.21648863f, 0.04385833f, -0.22989754f, 0.26047969f, -0.32689241f, 
    -0.06157275f, -0.04997947f, 0.17319363f, 0.08411068f, -0.26017970f, 0.08355355f, 0.13840996f, 0.28933701f, 
    0.19589157f, 0.13770042f, -0.05154186f, -0.13019426f, 0.05772629f, 0.14231370f, -0.02504884f, -0.13866521f, 
    0.01110639f, -0.04263875f, 0.00118149f, 0.02099548f, 0.02005428f, -0.04275368f, 0.03085584f, -0.02816584f, 
    -0.01272547f, -0.05618330f, -0.05545232f, 0.02889834f, -0.05045301f, 0.00304043f, -0.03661444f, -0.00458870f, 
    -0.05567800f, 0.01906649f, -0.02863635f, -0.05958859f, -0.04227298f, -0.00752095f, 0.01343770f, -0.01841609f, 
    0.00691340f, -0.00040590f, 0.00067877f, -0.05607936f, -0.03325462f, 0.00050325f, -0.01365476f, -0.06572133f, 
    -0.03771536f, 0.01374894f, -0.04739184f, 0.05665895f, 0.03901060f, 0.00514742f, -0.01203280f, -0.01484707f, 
    -0.04736198f, -0.01088537f, 0.01775624f, -0.03237314f, -0.02321444f, 0.01710546f, 0.02106044f, 0.04879075f, 
    -0.00349699f, 0.00855998f, 0.03283029f, 0.03834714f, -0.02854197f, 0.02894850f, 0.01547081f, -0.04045724f, 
    -0.03919186f, 0.01173171f, 0.02012222f, 0.02830366f, -0.02477581f, 0.02530784f, -0.02671958f, -0.02923732f, 
    -0.00923300f, -0.02843433f, 0.05589474f, -0.03250134f, -0.06341500f, 0.01334261f, -0.05669047f, -0.00324560f, 
    -0.01994657f, 0.01238646f, -0.00056593f, 0.04246679f, -0.02695296f, -0.00754363f, 0.04684072f, 0.03979151f, 
    0.04352400f, -0.01095211f, -0.02520907f, 0.04168328f, 0.01568068f, 0.00712976f, 0.03996142f, 0.00111809f, 
    0.00829484f, -0.03219672f, -0.02346916f, -0.00099307f, -0.05247512f, -0.03092632f, -0.06032721f, 0.00019617f, 
    0.01239107f, -0.04196405f, -0.04643285f, 0.04629581f, -0.02474509f, 0.00619812f, -0.03301524f, -0.03520358f, 
    0.02470971f, 0.04424915f, -0.05475063f, 0.00552607f, -0.03762821f, 0.01252517f, 0.02762668f, -0.02483479f, 
    -0.05541056f, -0.03198010f, 0.03079387f, -0.01487537f, -0.02064648f, 0.02458349f, 0.04029952f, 0.02059724f, 
    0.02065799f, -0.03644305f, -0.02292775f, -0.04777699f, -0.00025978f, -0.05524715f, -0.01755854f, 0.03334334f, 
    -0.00199498f, 0.04201268f, -0.04061421f, -0.03065351f, -0.00215938f, -0.05933577f, -0.00510674f, -0.02986724f, 
    0.01233858f, -0.02741113f, -0.05722309f, -0.04499888f, 0.03926737f, -0.04941942f, -0.03772421f, -0.04491951f, 
    -0.06335443f, 0.04056500f, 0.01452482f, -0.05497107f, -0.06403168f, -0.00038230f, 0.03416446f, -0.02956149f, 
    -0.03678524f, -0.06573769f, -0.00210456f, -0.02656000f, 0.02795572f, -0.05558493f, -0.00806740f, -0.00566374f, 
    0.02858458f, -0.05090189f, -0.02121539f, -0.03851923f, -0.03697058f, -0.05916962f, -0.00388052f, -0.00258042f, 
    0.02080668f, -0.01394438f, -0.00388059f, -0.05631356f, -0.01972747f, -0.03628190f, -0.06408048f, -0.05772161f, 
    0.00477727f, -0.04573550f, 0.02876111f, -0.02899016f, -0.05494880f, 0.03866560f, -0.00476562f, 0.01059885f, 
    -0.01700885f, -0.03310999f, 0.04018913f, 0.01139628f, 0.04368197f, -0.02071575f, -0.01710274f, 0.04440708f, 
    0.03796106f, -0.02831092f, -0.02987456f, -0.01207753f, -0.05306100f, 0.00238221f, 0.05138630f, 0.04464744f, 
    0.03217405f, -0.01807550f, -0.05996251f, 0.01655112f, 0.04008035f, 0.02376628f, -0.06314432f, 0.03251562f, 
    0.02590267f, -0.03784376f, 0.01196793f, 0.04747531f, -0.05102859f, 0.01421062f, -0.00853376f, -0.05116973f, 
    0.01025603f, 0.00897880f, 0.04728631f, 0.04673385f, -0.05548071f, -0.02655994f, 0.02955065f, -0.01555164f, 
    -0.03493526f, 0.00546885f, 0.04803689f, 0.00327110f, -0.03600578f, 0.02256315f, -0.06141873f, 0.00320421f, 
    0.00262500f, 0.02549046f, -0.05087491f, -0.02102217f, -0.06186394f, -0.05163807f, -0.03899131f, -0.02995218f, 
    0.02240007f, -0.01594185f, -0.01294415f, -0.02745268f, 0.04363494f, -0.03087996f, -0.00871193f, -0.02824622f, 
    0.02573736f, 0.02724333f, 0.01211059f, 0.04637219f, 0.03128062f, 0.02754683f, 0.00741538f, -0.05015909f, 
    -0.01759994f, -0.00427605f, 0.00556994f, 0.03116081f, -0.02325365f, -0.02395842f, -0.00095796f, -0.06740671f, 
    0.04730412f, 0.03581515f, -0.02555029f, -0.01308546f, 0.00519998f, 0.04031796f, 0.03217760f, -0.03800583f, 
    0.01618691f, -0.05706467f, 0.02630337f, 0.04470761f, -0.01326297f, 0.04618289f, -0.03079007f, -0.02026771f, 
    0.02812111f, 0.03093092f, -0.05334684f, -0.01254713f, 0.00693252f, -0.04068470f, -0.05742346f, -0.06534988f, 
    -0.01792881f, -0.01841126f, 0.09579217f, 0.19137190f, -0.02627609f, -0.05369502f, 0.05610203f, 0.04771784f, 
    -0.11562647f, 0.02527302f, -0.40587035f, 0.27276272f, 0.23154308f, 0.05834826f, 0.11003648f, 0.12273624f, 
    -0.03255624f, -0.06746100f, -0.15855929f, -0.04708617f, -0.06860042f, 0.11149023f, 0.09919261f, -0.04357981f, 
    -0.16408940f, 0.05223480f, -0.00188301f, -0.18459581f, -0.42806435f, -0.01452579f, 0.26075920f, 0.10396966f, 
    0.00368924f, 0.04547981f, 0.06640692f, 0.03015254f, -0.01967626f, -0.03436489f, -0.02933982f, 0.05535988f, 
    0.05532210f, -0.04549992f, -0.16066666f, -0.06024909f, 0.06069861f, -0.06541888f, 0.39042705f, 0.24081150f, 
    -0.00851008f, -0.12737748f, 0.14678425f, 0.10667046f, 0.20155507f, 0.15713365f, -0.33170196f, 0.08747139f, 
    -0.02750508f, -0.05588196f, -0.07839116f, -0.07588840f, -0.05373649f, -0.06729221f, 0.03022865f, 0.18783589f, 
    -0.10597450f, 0.12134533f, -0.11295989f, -0.14994153f, 0.24077769f, -0.01055685f, 0.10799173f, -0.11211598f, 
    0.18642478f, 0.01386504f, 0.24915072f, 0.20284235f, -0.03714836f, -0.04539219f, 0.01725101f, 0.13836651f, 
    -0.07275230f, 0.00332706f, 0.34503666f, 0.19070017f, -0.14211065f, 0.13572583f, -0.09942427f, 0.14908710f, 
    0.13608699f, 0.04362346f, 0.16803387f, 0.09363757f, -0.15488300f, 0.00226052f, -0.15278275f, -0.08115556f, 
    -0.11759160f, 0.12579075f, -0.00212794f, 0.21534705f, -0.19922096f, 0.02218538f, 0.17276487f, -0.26706645f, 
    -0.10329693f, 0.21107377f, -0.11526524f, 0.21162303f, -0.03691562f, -0.07871419f, 0.28221956f, 0.17020898f, 
    -0.14877845f, -0.02507352f, 0.06396061f, -0.01892836f, -0.02299264f, 0.29358104f, 0.22587803f, 0.07721114f, 
    -0.20230851f, -0.17132761f, 0.09946617f, 0.08532794f, 0.00682404f, 0.13497239f, 0.12657642f, 0.37917927f, 
    -0.12843840f, 0.12855907f, 0.00674281f, -0.07688680f, 0.08964479f, 0.29280570f, -0.04919609f, -0.21425988f, 
    0.20745821f, -0.15090664f, 0.03783900f, -0.17367253f, 0.01213683f, 0.14392282f, 0.12796453f, 0.20301016f, 
    -0.25347796f, -0.30538398f, -0.03653481f, 0.10503465f, -0.17089620f, 0.00293493f, 0.11462194f, -0.04541115f, 
    -0.10458643f, -0.07421178f, -0.19406572f, 0.26081979f, -0.03911292f, -0.01370495f, 0.28119940f, -0.13704698f, 
    -0.11697108f, -0.03348661f, -0.36486039f, 0.14653869f, -0.08510009f, 0.06412405f, -0.03672078f, 0.02760676f, 
    -0.23143919f, -0.02831967f, -0.01682807f, -0.04414652f, -0.07331116f, 0.35775059f, -0.30504137f, -0.06685038f, 
    0.18425074f, -0.08203326f, 0.04463107f, 0.06679510f, 0.28673393f, 0.28959751f, 0.21029761f, 0.12618451f, 
    -0.08841532f, -0.02207843f, -0.19502790f, -0.03502136f, -0.14085647f, 0.14508547f, 0.14505374f, 0.05117029f, 
    0.00502588f, 0.17603393f, -0.09412678f, 0.07908244f, 0.06003748f, 0.19739480f, 0.38583860f, -0.00675544f, 
    0.03066015f, -0.01890295f, 0.13190569f, -0.20198002f, 0.07664102f, 0.06157278f, 0.13765326f, 0.50886196f, 
    0.30085552f, 0.20708217f, 0.00454684f, -0.13876390f, -0.06074845f, -0.02753124f, -0.08794206f, 0.05114323f, 
    -0.39631760f, 0.04575253f, -0.15884480f, 0.01826575f, -0.11945163f, -0.03208179f, 0.09313442f, 0.18963470f, 
    -0.10429947f, 0.05256128f, 0.43360314f, 0.14756396f, 0.05880819f, 0.04252005f, 0.00500262f, 0.15869072f, 
    0.20223023f, 0.10934999f, 0.40085146f, 0.39549708f, 0.15180627f, -0.11044741f, 0.23686281f, -0.12707281f, 
    0.14771764f, 0.25248098f, -0.18295377f, -0.12198064f, -0.10202195f, -0.10917304f, 0.01981075f, 0.05022992f, 
    -0.31421793f, 0.15431003f, 0.09303454f, 0.22482097f, 0.07353836f, 0.15404728f, -0.12355260f, -0.00695932f, 
    0.01737833f, -0.02033513f, -0.16022775f, -0.11305984f, -0.16720407f, -0.90020573f, -0.45758736f, 0.30270955f, 
    0.15799968f, 0.17305987f, -0.00628015f, 0.10445765f, -0.29464340f, -0.18340559f, -0.54373246f, 0.07272474f, 
    -0.24688499f, 0.12470254f, -0.27635211f, -0.30946261f, -0.06844579f, -0.12188224f, 0.00129350f, -0.53761470f, 
    -0.49449581f, -0.19200006f, 0.17605360f, -0.00503244f, -0.07958862f, -0.05773841f, -0.09113214f, -0.01448733f, 
    0.73592764f, -0.54689109f, -0.28046122f, 0.09558202f, -0.06070364f, 0.20039414f, 0.06565479f, -0.11170660f, 
    0.00067903f, -0.05644663f, 0.09539182f, 0.10686518f, 0.06130424f, -0.00300519f, 0.12464312f, 0.12036167f, 
    0.13125519f, 0.05080951f, 0.05857154f, -0.02164784f, 0.12356750f, -0.04898055f, -0.03402314f, -0.06767214f, 
    0.06324755f, -0.22104940f, 0.04388639f, 0.05907206f, 0.07169375f, 0.24986397f, -0.11311817f, 0.00751177f, 
    -0.10683023f, -0.03379883f, -0.06300849f, -0.10446434f, -0.25706291f, 0.16183971f, 0.13312078f, 0.09247572f, 
    0.00092359f, -0.06708401f, -0.15484452f, -0.11018377f, 0.00327553f, 0.27594489f, -0.10380913f, -0.02540068f, 
    0.31479651f, -0.10251316f, 0.09096038f, 0.05372382f, 0.08611553f, -0.04790134f, -0.34392703f, 0.27816811f, 
    0.29810172f, 0.08502968f, 0.05912572f, 0.08099379f, -0.00758647f, 0.12192415f, 0.17785853f, 0.33523229f, 
    -0.04445899f, 0.08288892f, 0.00013992f, -0.02350673f, -0.12093756f, -0.09141289f, -0.07165177f, -0.04333002f, 
    -0.36095768f, -0.22801791f, -0.27064604f, -0.07845835f, 0.01167731f, 0.20466639f, 0.33565009f, 0.06034415f, 
    0.07732760f, -0.22472714f, -0.15783526f, -0.29265857f, -0.01595963f, -0.01716503f, 0.02217566f, 0.05957035f, 
    0.05731389f, 0.00768355f, -0.21931967f, -0.00654350f, -0.27326053f, 0.04896452f, 0.02034955f, 0.15893804f, 
    0.05493274f, -0.00186787f, 0.05329924f, -0.08123390f, -0.01314047f, 0.28732872f, -0.18844721f, 0.03938953f, 
    0.08892597f, 0.10869122f, -0.01716354f, 0.09821624f, 0.88091803f, -0.11179738f, -0.30982444f, 0.01089500f, 
    0.03436980f, 0.05742258f, -0.11151413f, -0.01521830f, 0.21732597f, 0.35653850f, 0.00633802f, -0.31005612f, 
    -0.07994270f, 0.19255829f, 0.02721958f, 0.01864900f, 0.12187312f, -0.24536231f, 0.35974488f, 0.36486608f, 
    -0.13871473f, -0.21975736f, -0.01934243f, 0.11896139f, -0.07819040f, 0.17740929f, -0.05199374f, -0.44643849f, 
    -0.01066294f, 0.31634411f, 0.10891873f, 0.06595210f, -0.00687728f, -0.06892979f, -0.15961966f, 0.05147007f, 
    -0.26271462f, 0.14930405f, 0.05600569f, -0.06840086f, 0.01609788f, 0.22952056f, 0.04895148f, -0.03235132f, 
    -0.05492279f, -0.03332518f, 0.31891906f, -0.12931569f, 0.01910350f, 0.06581273f, 0.02692645f, -0.21257831f, 
    0.04294326f, 0.07346430f, 0.13243915f, -0.07083480f, 0.21606663f, -0.15325977f, 0.04509972f, -0.21465005f, 
    -0.04946163f, 0.14120571f, -0.10683871f, -0.10090741f, 0.24304911f, 0.01242807f, -0.10784402f, 0.05494754f, 
    -0.19323605f, -0.05923365f, -0.13643295f, 0.12783913f, -0.62811553f, 0.08052790f, 0.18835442f, 0.02871542f, 
    0.03146044f, -0.02492407f, 0.00406797f, -0.13795826f, 0.05031477f, 0.17389327f, -0.65124089f, -0.35759753f, 
    -0.04708163f, -0.07508972f, -0.18905845f, 0.01223051f, 0.10815538f, 0.05432688f, 0.49417430f, 0.13598083f, 
    -0.16676469f, 0.11542613f, 0.03390838f, -0.06851131f, -0.09032847f, -0.07332677f, 0.09870226f, -0.20910589f, 
    -0.16449238f, -0.17639013f, 0.04763417f, 0.12148666f, -0.06378766f, 0.20452929f, 0.06270447f, 0.02768240f, 
    0.33438152f, -0.07819290f, 0.01126145f, -0.10318197f, -0.02196578f, -0.04675794f, 0.22080666f, -0.01336218f, 
    -0.20890118f, -0.29822639f, -0.22266760f, -0.39049572f, 0.04023825f, 0.06898743f, -0.08045767f, -0.10866210f, 
    -0.01718114f, 0.13807550f, -0.01639071f, 0.27327204f, -0.39034504f, -0.25860843f, 0.12748152f, 0.12937120f, 
    -0.13591875f, -0.31342950f, -0.07490540f, -0.31218982f, 0.09941335f, -0.04675340f, 0.16451932f, 0.05096341f, 
    0.24700619f, -0.01743358f, 0.09964397f, 0.06998968f, -0.37736675f, -0.15127097f, -0.16814390f, 0.03033344f, 
    0.01209585f, 0.02962983f, -0.07520065f, 0.01966747f, -0.12624748f, -0.56730026f, 0.01723611f, 0.05235553f, 
    0.11461923f, 0.12628734f, 0.11453744f, -0.33729482f, -0.07648091f, 0.14972372f, 0.04119348f, -0.29895556f, 
    -0.51561338f, -0.04697706f, -0.10724100f, 0.00996883f, 0.04055474f, -0.00204541f, 0.04154574f, 0.20956698f, 
    -0.13583121f, 0.29973808f, -0.02940741f, 0.08155098f, -0.01710364f, 0.04738735f, 0.02646574f, -0.14942148f, 
    0.07014976f, 0.13632953f, 0.19963723f, -0.28879207f, -0.15570533f, 0.05188781f, -0.10181914f, 0.02886642f, 
    0.22390598f, 0.36681065f, 0.16175437f, -0.08631113f, 0.10586247f, -0.09728945f, -0.06311450f, 0.06521086f, 
    -0.11341861f, -0.41451156f, -0.27161819f, -0.27489761f, -0.46136817f, -0.02925301f, 0.11622089f, 0.18695441f, 
    -0.08434765f, 0.13020666f, 0.10507059f, 0.32861829f, 0.12697147f, 0.06816648f, 0.23422515f, -0.07480381f, 
    -0.13543740f, -0.04870181f, -0.12444130f, -0.25517046f, 0.23434377f, -0.05535915f, -0.26395676f, 0.15925899f, 
    0.20923619f, 0.06348070f, -0.05259100f, 0.04591957f, -0.18547256f, 0.17440265f, 0.05259263f, 0.23548061f, 
    -0.25271973f, 0.08880477f, 0.07403532f, -0.19654119f, -0.26853311f, -0.04721290f, -0.03260669f, 0.15906794f, 
    -0.24292928f, 0.17366889f, 0.12883008f, -0.22294943f, -0.14656000f, 0.12421966f, -0.08626663f, 0.15637660f, 
    0.18923438f, 0.08845148f, 0.12282990f, -0.01918635f, -0.12779716f, 0.02879027f, -0.03954664f, -0.19275782f, 
    -0.08611002f, 0.18335545f, -0.03119985f, -0.32216212f, 0.26796910f, -0.21068218f, 0.08592714f, -0.16454889f, 
    -0.13046843f, -0.05788609f, -0.34092772f, 0.28810865f, -0.26895070f, -0.19445302f, 0.08936839f, -0.01624166f, 
    -0.09498238f, 0.16966054f, -0.47579309f, -0.18629280f, 0.08350751f, -0.22497870f, -0.10824333f, -0.09402521f, 
    0.04717159f, -0.31842598f, 0.00363867f, 0.14525943f, 0.13877067f, -0.30540162f, 0.03503765f, 0.11583301f, 
    0.18427803f, 0.27940962f, -0.01818900f, -0.17977525f, -0.34089786f, 0.02072427f, -0.37894300f, 0.05446310f, 
    -0.10713547f, 0.03032893f, 0.09702408f, 0.12324010f, 0.00538971f, -0.01877262f, 0.08699983f, -0.03018510f, 
    -0.04229247f, -0.08397255f, 0.00517910f, 0.45209152f, 0.05145572f, -0.30262679f, 0.12732105f, -0.00739417f, 
    0.35566479f, -0.05097630f, 0.03335944f, -0.10104375f, 0.15619166f, 0.02133948f, 0.26083520f, 0.13573454f, 
    -0.11914715f, 0.36371183f, -0.05401969f, 0.18965627f, 0.11834527f, 0.30156034f, 0.00987648f, 0.00781513f, 
    0.03242872f, -0.13775942f, -0.29213580f, 0.04707709f, 0.16615200f, 0.00365310f, 0.02105421f, 0.24777557f, 
    -0.11558374f, -0.01926450f, 0.20701885f, -0.35994565f, 0.01868943f, 0.08847277f, -0.22682405f, 0.32400078f, 
    -0.05707096f, -0.13966191f, -0.37010735f, 0.05719074f, -0.40114817f, 0.36160675f, 0.17886738f, 0.05719088f, 
    -0.01120702f, 0.32225311f, 0.13856775f, -0.01754389f, -0.17230286f, -0.50107890f, 0.19189818f, 0.15127861f, 
    0.27006546f, 0.20017168f, 0.18467374f, 0.11560410f, 0.12148923f, 0.09177955f, 0.23218864f, -0.09287500f, 
    -0.02936556f, -0.11011077f, 0.01762186f, -0.05550877f, 0.14101793f, 0.08396487f, -0.06389450f, -0.09226684f, 
    -0.11188339f, -0.04718850f, 0.19913289f, -0.07681073f, 0.19201271f, -0.10358887f, 0.09037519f, 0.32758486f, 
    0.14631478f, -0.18088526f, -0.09467340f, -0.11638556f, 0.01210015f, 0.05886264f, 0.09376076f, -0.30684757f, 
    -0.00432380f, 0.38971552f, -0.30378222f, -0.30023062f, -0.05570672f, -0.26045272f, 0.28636032f, 0.17806315f, 
    -0.24232034f, 0.13763197f, -0.44604841f, 0.02225925f, -0.08906257f, 0.14967214f, 0.07820089f, -0.04765689f, 
    0.15439214f, -0.18018924f, -0.10118841f, 0.37630260f, 0.07860571f, 0.33463770f, 0.06845009f, 0.00294793f, 
    -0.02407115f, 0.06094482f, 0.17705373f, -0.25200054f, 0.05548709f, -0.14666991f, 0.21706872f, 0.24790880f, 
    -0.39767510f, 0.25590605f, 0.18965928f, 0.05018536f, -0.17419809f, -0.22902672f, 0.11648060f, 0.17500281f, 
    0.13639586f, 0.18120185f, 0.09181709f, -0.09660879f, -0.22550716f, 0.02535066f, -0.24133359f, 0.08053097f, 
    -0.07176884f, 0.00622628f, 0.45983064f, 0.15248635f, 0.00509016f, -0.02722224f, -0.09183209f, -0.40288556f, 
    -0.01277362f, 0.31534508f, 0.16961144f, -0.29294527f, -0.06648578f, 0.18058343f, -0.11959635f, 0.41154745f, 
    0.14581934f, -0.05877017f, -0.12681356f, 0.19155283f, 0.05640402f, -0.16454186f, 0.11936340f, -0.07408930f, 
    0.20601052f, -0.20518331f, 0.28274262f, -0.02596192f, 0.13900432f, -0.19382517f, -0.03354214f, 0.16716461f, 
    -0.02220555f, 0.02979108f, 0.02561083f, 0.01503353f, 0.03943691f, 0.02035451f, -0.02030076f, 0.02758123f, 
    -0.00304110f, 0.01294919f, 0.01900285f, -0.01401977f, 0.01357387f, -0.03333604f, 0.00107422f, 0.00816598f, 
    -0.00957530f, -0.05865218f, -0.01952883f, 0.03542759f, -0.04855836f, 0.03113813f, 0.00185812f, -0.02716550f, 
    0.02634265f, -0.04693781f, -0.00500668f, 0.02641494f, -0.03291905f, -0.05278045f, 0.03114666f, -0.01312812f, 
    -0.06118454f, -0.01289843f, 0.00080646f, 0.01552495f, 0.04653112f, 0.02748328f, -0.02875743f, -0.06654819f, 
    0.01561548f, -0.04361941f, -0.02968490f, -0.02242544f, -0.05211542f, 0.03049403f, -0.04942437f, 0.02602143f, 
    -0.04772699f, -0.00596094f, 0.01688999f, -0.05085411f, 0.03725267f, 0.01285629f, -0.02409066f, 0.01050602f, 
    -0.03489689f, 0.01686378f, -0.04467651f, -0.00045237f, 0.03150897f, -0.01500765f, 0.03769353f, 0.02594363f, 
    -0.05924770f, -0.03430348f, 0.02146409f, -0.02775061f, -0.05260827f, -0.02314262f, 0.01914830f, -0.02023959f, 
    0.01792081f, -0.06125439f, -0.04766586f, 0.04070704f, -0.04293937f, -0.06078043f, -0.04281121f, 0.03837927f, 
    0.05397480f, -0.05318940f, 0.03516596f, -0.01618193f, -0.02703723f, -0.05071872f, 0.04674364f, -0.03729095f, 
    -0.06792417f, 0.03677628f, -0.02106155f, -0.04183009f, 0.04494156f, 0.04136041f, 0.00585428f, -0.04684575f, 
    0.02053207f, 0.04290923f, -0.03809569f, -0.00102674f, 0.01635678f, -0.03238970f, -0.02846808f, -0.06795533f, 
    -0.02573962f, 0.04900528f, -0.05740574f, -0.02504020f, -0.00076340f, -0.02037170f, -0.02949617f, -0.03113837f, 
    0.02972383f, -0.01280775f, -0.04920696f, 0.03692294f, -0.05245825f, -0.01452188f, -0.00806467f, -0.04461244f, 
    -0.04304539f, -0.05804788f, -0.04121948f, -0.01062796f, -0.01166567f, -0.02076199f, -0.05016963f, -0.00613070f, 
    0.03703756f, -0.05187449f, -0.02746182f, 0.00456316f, -0.04108180f, -0.02053979f, -0.00717993f, -0.05169503f, 
    -0.02943281f, 0.01430119f, -0.03030679f, -0.03602760f, -0.00478176f, -0.05917281f, -0.02581734f, -0.02390905f, 
    0.00172826f, 0.04105107f, 0.04546998f, 0.02275170f, -0.00342371f, 0.05207292f, -0.06483660f, 0.03490873f, 
    0.00019127f, -0.01708266f, -0.05528815f, 0.03385149f, 0.02834971f, 0.02009890f, -0.01458890f, -0.06348495f, 
    -0.01116258f, -0.06361061f, 0.02286152f, -0.03166119f, 0.02754652f, 0.04493354f, -0.04960451f, -0.04946024f, 
    0.03223076f, 0.03753242f, -0.02910889f, 0.00559274f, 0.04081614f, -0.04942291f, 0.01059738f, 0.03495265f, 
    0.05001487f, -0.05533079f, -0.02414762f, 0.03301772f, -0.01363273f, -0.01957701f, 0.02607696f, -0.06106875f, 
    0.00525546f, -0.04435587f, 0.04039897f, -0.04910886f, -0.00843937f, 0.02760449f, -0.04073600f, -0.05862146f, 
    0.01882414f, -0.03290376f, -0.00849795f, 0.04603445f, -0.02611279f, -0.04217924f, -0.02822351f, 0.03963124f, 
    0.02959719f, 0.02709581f, 0.04181218f, -0.02808348f, -0.04340508f, -0.02378610f, -0.05414791f, -0.01079868f, 
    0.00517602f, 0.04885426f, -0.05717111f, -0.05139952f, -0.03935235f, 0.01479804f, 0.01010889f, -0.01728646f, 
    0.01907306f, 0.03442809f, -0.01834947f, 0.02239587f, 0.05063374f, 0.04883002f, 0.02903236f, -0.05242974f, 
    -0.05954891f, 0.03490425f, -0.02722254f, -0.02822052f, 0.00151602f, -0.00444764f, 0.03217383f, 0.01973231f, 
    -0.06625811f, -0.06144941f, -0.05433946f, 0.02842240f, 0.02018482f, -0.03278084f, 0.01036339f, -0.01340340f, 
    0.01277032f, 0.04325357f, 0.04075232f, -0.05066044f, -0.00126821f, -0.03708411f, -0.06174514f, 0.01112259f, 
    -0.00537178f, 0.03723257f, 0.00347892f, -0.01629537f, -0.06071108f, -0.00373118f, 0.02553055f, -0.00955540f, 
    0.03286767f, 0.00951314f, -0.03642065f, 0.02440830f, 0.04504284f, -0.04269762f, 0.02452799f, -0.02739630f, 
    -0.01718294f, -0.03766599f, -0.02164212f, 0.00091331f, 0.04453667f, -0.02696886f, 0.01527126f, -0.01298016f, 
    0.03327443f, 0.04683392f, 0.02422069f, -0.03595922f, 0.04209869f, -0.00479635f, 0.02719232f, -0.04635567f, 
    0.04047001f, -0.00440744f, -0.03503735f, -0.06883813f, 0.03898985f, -0.05960378f, 0.03748539f, 0.03205074f, 
    -0.88413358f, 0.03464450f, -0.11445878f, 0.07278289f, 0.22089294f, -0.14918736f, -0.17180535f, 0.03144640f, 
    -0.02958698f, 0.53070414f, -0.00247784f, -0.01428930f, 0.09783321f, -0.09871696f, 0.18339753f, 0.14250404f, 
    0.01728512f, -0.06100998f, 0.04572622f, 0.18999073f, -0.14593449f, 0.00862044f, -0.03283042f, 0.01902369f, 
    -0.19882751f, -0.02740532f, 0.08326031f, 0.58501256f, 0.07756342f, 0.31264666f, 0.08333859f, -0.19984855f, 
    -0.04782459f, 0.13927263f, 0.15608607f, 0.00292209f, 0.67903435f, 0.19999741f, 0.16512001f, 0.04088754f, 
    0.16154316f, 0.12753415f, -0.13687459f, 0.03812046f, -0.03163532f, -0.65742362f, 0.04936366f, 0.16374083f, 
    -0.14664456f, 0.09316608f, -0.04487822f, 0.12504281f, 0.00440158f, 0.17463212f, 0.36241111f, -0.10663413f, 
    0.36573476f, -0.06546715f, -0.00101758f, -0.11805475f, 0.00146564f, 0.12914295f, 0.08917396f, 0.07046010f, 
    -0.18308169f, -0.16705859f, 0.05936533f, 0.04490494f, 0.07148780f, 0.09626621f, 0.10116732f, -0.07811036f, 
    0.01399294f, -0.12790945f, -0.07353819f, -0.04449134f, -0.30357054f, 0.03997007f, -0.25326389f, 0.05147760f, 
    -0.20174283f, 0.36572793f, 0.04308430f, -0.40548432f, 0.05833131f, 0.06960369f, -0.02161949f, -0.06113954f, 
    -0.06623887f, -0.18840460f, -0.38571250f, -0.10033704f, -0.34860522f, -0.00836633f, 0.10068098f, 0.05544494f, 
    0.07489149f, 0.06572818f, -0.03826923f, 0.50634187f, -0.23822241f, -0.07238328f, 0.21408947f, 0.00807052f, 
    -0.17939477f, 0.20216933f, 0.13260235f, 0.11040231f, -0.65725213f, -0.03923582f, 0.05474928f, -0.30608493f, 
    0.17966031f, 0.08964748f, -0.19856769f, 0.18127570f, -0.20655823f, -0.13124412f, -0.12658384f, -0.36820924f, 
    0.11291290f, -0.11522225f, 0.06622074f, 0.04500628f, -0.02880760f, -0.00542842f, -0.13225585f, 0.15433824f, 
    -0.22187413f, 0.11050195f, 0.09555868f, -0.06189420f, -0.15412025f, -0.07984360f, 0.00695055f, 0.13263069f, 
    -0.24536894f, -0.35784572f, 0.03424061f, 0.27561864f, -0.22151993f, -0.13378473f, -0.15603235f, -0.01632388f, 
    0.31297657f, 0.26891032f, -0.00316735f, 0.11347006f, -0.17471059f, -0.00973665f, -0.07011116f, 0.08781520f, 
    0.11229826f, 0.25491828f, 0.14844596f, -0.09637953f, 0.18587172f, -0.13866161f, 0.20519699f, 0.15588199f, 
    -0.05093735f, 0.03117567f, 0.19900529f, -0.00075552f, 0.01960292f, 0.11965745f, 0.13593295f, 0.02586591f, 
    -0.04861833f, -0.02353663f, 0.00321811f, 0.35868919f, 0.31623489f, 0.03934177f, 0.06204128f, 0.29277959f, 
    0.42756996f, -0.07733007f, 0.05840913f, 0.19558915f, 0.34610203f, 0.15762030f, -0.25466132f, -0.03595454f, 
    -0.03308690f, 0.06748979f, -0.07348544f, 0.14382115f, -0.29919285f, -0.86962569f, 0.00105145f, -0.07960919f, 
    0.08504006f, -0.17049003f, -0.01909615f, -0.26016879f, 0.12223396f, -0.08086935f, -0.07952281f, -0.26958165f, 
    -0.10446837f, 0.15273678f, -0.19370832f, -0.09782115f, -0.31693080f, 0.11380144f, 0.15122089f, 0.19521773f, 
    0.14858641f, -0.30725190f, -0.02615791f, 0.01398828f, -0.00625665f, -0.16367567f, -0.17091385f, -0.11247284f, 
    -0.06831231f, -0.01756343f, -0.22871609f, -0.00001625f, 0.05834955f, 0.09459982f, 0.03845955f, 0.05188283f, 
    0.06260736f, -0.13028778f, 0.51731855f, -0.14664422f, 0.02319597f, 0.09303132f, -0.16488722f, 0.13965662f, 
    0.00562304f, -0.08888511f, -0.00635101f, 0.15885007f, -0.32694042f, -0.00224549f, 0.23540816f, -0.14239135f, 
    -0.26291186f, -0.12031670f, -0.19527808f, 0.51598239f, -0.21926363f, 0.08653577f, -0.09664808f, 0.06698172f, 
    0.04387620f, 0.09408248f, 0.07568669f, 0.00710586f, 0.00492769f, 0.10573862f, -0.29958969f, 0.21018235f, 
    -0.22242157f, 0.06881470f, 0.01172270f, 0.08161684f, -0.14099455f, 0.31570256f, 0.33275625f, 0.04891203f, 
    0.17236233f, 0.24529208f, 0.02893545f, 0.10318990f, 0.02080544f, 0.17895298f, -0.39070886f, -0.19888872f, 
    -0.09058344f, -0.08952788f, -0.18986902f, -0.05435591f, 0.01149823f, 0.06916710f, -0.00780365f, 0.60367292f, 
    -0.03011045f, 0.10764425f, 0.01758876f, -0.11583859f, 0.15161666f, 0.00612435f, 0.01043441f, 0.07573853f, 
    0.44848567f, 0.21925466f, 0.14648898f, -0.14667486f, -0.20057636f, -0.22070768f, -0.05645639f, -0.11318203f, 
    0.06794886f, 0.03993497f, 0.00972206f, 0.12423909f, -0.03508445f, 0.00186985f, 0.10012641f, -0.12921102f, 
    -0.04195530f, 0.01024060f, -0.26799193f, 0.11772636f, -0.27682009f, -0.02045288f, -0.08614022f, 0.07967329f, 
    0.05457144f, 0.02315797f, 0.00369639f, -0.07441850f, 0.10380007f, 0.10513960f, -0.01722714f, -0.00252231f, 
    0.06062047f, 0.05814299f, -0.07640932f, -0.26856023f, 0.06952168f, -0.07054800f, 0.11102517f, -0.25990814f, 
    -0.06756128f, 0.12377568f, 0.01276818f, 0.12089562f, 0.02256304f, -0.21734475f, 0.58176649f, 0.07334197f, 
    0.07111572f, 0.10004435f, -0.08002423f, 0.17398402f, -0.01618905f, -0.40990672f, 0.57935697f, -0.45180619f, 
    -0.39011317f, -0.10214778f, -0.15874670f, -0.06815369f, -0.21197316f, 0.00453053f, 0.02797593f, -0.22439282f, 
    -0.01907901f, -0.02464574f, -0.00326686f, -0.08749030f, 0.02142966f, 0.05773714f, 0.21685873f, 0.20635822f, 
    -0.10512859f, -0.12728786f, -0.07439484f, 0.25077939f, -0.09776054f, 0.04872132f, 0.19818521f, 0.20470290f, 
    0.18472323f, 0.15038896f, -0.15670110f, -0.16418460f, 0.03949858f, -0.18024716f, -0.06774747f, -0.23090070f, 
    0.06034436f, 0.06992178f, -0.43901634f, -0.08541668f, -0.34175351f, -0.13022862f, -0.01221596f, -0.06374157f, 
    0.19324762f, -0.02955365f, -0.04047239f, 0.21611704f, -0.40537971f, 0.29577494f, 0.22735271f, -0.15031111f, 
    0.20014660f, -0.20132211f, -0.09316912f, -0.00123743f, 0.16016425f, 0.17893574f, -0.31058621f, 0.23027435f, 
    0.16206637f, 0.00897102f, 0.00242185f, 0.01608188f, -0.03167377f, -0.23936258f, -0.27303329f, 0.04654600f, 
    0.04405121f, 0.31549510f, -0.05504715f, -0.00506551f, 0.24328335f, 0.09374519f, 0.35034975f, 0.01895424f, 
    0.20690323f, -0.15941328f, -0.19944386f, 0.05245319f, 0.07259746f, -0.18988666f, -0.06560489f, 0.06087105f, 
    -0.81889170f, 0.01221719f, -0.18666430f, -0.13227077f, 0.08521761f, -0.14046575f, -0.08637540f, -0.13623336f, 
    -0.29451033f, -0.17462288f, -0.24867545f, -0.08558960f, -0.27458480f, 0.09881499f, 0.04968087f, -0.06397428f, 
    0.13216566f, 0.04581493f, 0.07788564f, -0.20637277f, 0.03202827f, -0.10036819f, -0.01916533f, 0.16044669f, 
    -0.02027642f, 0.07383047f, -0.11201108f, 0.14712813f, -0.25214425f, -0.14364290f, -0.06941711f, -0.03106349f, 
    0.30073985f, 0.08121203f, -0.03574304f, -0.18836367f, 0.02328041f, 0.21948935f, 0.10995894f, 0.04551092f, 
    0.02660663f, 0.03241453f, 0.19453764f, 0.31684747f, -0.14140524f, -0.35993019f, -0.12721154f, 0.03315315f, 
    0.15511231f, 0.10564329f, -0.10557042f, -0.08959034f, 0.19128908f, 0.47963846f, 0.07035987f, -0.06441461f, 
    -0.28565019f, 0.10745556f, -0.28844425f, 0.09064440f, 0.09866577f, 0.01073681f, 0.39636621f, -0.38436320f, 
    0.11077237f, -0.02618143f, -0.08380453f, 0.08124585f, 0.05929479f, 0.08597085f, 0.09996260f, 0.15755719f, 
    0.12423792f, -0.25269020f, 0.26251918f, -0.07054936f, 0.10787088f, -0.04102210f, 0.05055688f, 0.01830701f, 
    0.15427949f, 0.00562249f, 0.19772853f, -0.17086083f, 0.03951269f, -0.03556191f, -0.03346675f, 0.11784702f, 
    0.02114475f, -0.00468781f, 0.37238872f, 0.01052563f, 0.05602011f, -0.16561918f, 0.27492344f, -0.09861565f, 
    -0.15220356f, 0.06584152f, -0.39633784f, 0.13690127f, -0.03634413f, 0.21220499f, 0.00786177f, 0.11526369f, 
    0.22427659f, 0.06786318f, -0.04515797f, -0.00461497f, -0.02375184f, 0.24439757f, -0.29213205f, -0.20982620f, 
    -0.05529229f, -0.10425131f, 0.01522858f, -0.15731135f, -0.01015239f, -0.65623105f, -0.10404000f, 0.02547831f, 
    0.14078395f, -0.13024350f, 0.02018338f, 0.05419537f, -0.05386890f, 0.36424696f, -0.00662082f, -0.32352591f, 
    0.00079341f, -0.25125915f, 0.06518196f, 0.07280837f, -0.00443492f, -0.07130849f, 0.56789678f, 0.13168347f, 
    -0.11020548f, -0.35594755f, 0.24944568f, -0.00988828f, 0.05184541f, 0.11455571f, -0.03937119f, -0.03371407f, 
    0.38810945f, 0.10871427f, -0.26655912f, -0.01913029f, -0.04756759f, -0.01382778f, -0.12286905f, -0.08791490f, 
    -0.03516884f, 0.03207478f, -0.00237208f, 0.02050752f, 0.04729575f, -0.02984257f, -0.01115509f, 0.00826930f, 
    0.00828981f, -0.01820721f, 0.04475253f, -0.01585918f, 0.02822935f, -0.04546375f, -0.02895446f, 0.00646449f, 
    -0.00753264f, -0.03804505f, -0.05835069f, -0.03742795f, 0.04815994f, 0.00550255f, 0.00558958f, 0.04597745f, 
    -0.00303630f, -0.02359922f, 0.00720741f, -0.04501654f, 0.02761156f, -0.06177422f, 0.05151004f, -0.01642637f, 
    -0.00523688f, -0.03636367f, -0.05593941f, -0.01806894f, 0.03592382f, 0.02203225f, -0.06265575f, -0.04914522f, 
    -0.04955115f, -0.04787138f, 0.04568070f, -0.01898943f, -0.05130304f, -0.03665099f, -0.04083351f, -0.00173976f, 
    -0.00297065f, -0.05751912f, -0.03883986f, 0.04350844f, -0.03058421f, -0.06772657f, -0.00087866f, -0.04475829f, 
    0.02281578f, -0.00786110f, -0.03165202f, 0.03107472f, 0.05254551f, 0.02936552f, -0.00528604f, 0.01428280f, 
    0.03273322f, -0.02418988f, -0.01624339f, 0.00346409f, 0.02568655f, -0.04259723f, -0.03635826f, 0.01921061f, 
    -0.02080964f, -0.01835314f, -0.04754514f, 0.01954753f, -0.06046529f, -0.02877089f, -0.04074707f, 0.02510453f, 
    -0.04960858f, 0.01966190f, -0.01453185f, 0.00261914f, 0.02610543f, -0.02105500f, -0.04734915f, -0.04924911f, 
    -0.03274338f, -0.01651213f, -0.00675761f, -0.01000398f, -0.01610870f, 0.03063869f, -0.04906403f, 0.05587909f, 
    0.00853255f, -0.04912091f, 0.04100883f, 0.01797765f, 0.05262021f, 0.00259019f, -0.00651819f, -0.04045726f, 
    0.04535953f, -0.06005456f, -0.04982837f, 0.04709369f, -0.00772098f, 0.03971516f, -0.02663743f, -0.05130885f, 
    -0.06141554f, 0.00196745f, -0.06688039f, -0.01665363f, -0.01780395f, -0.03578094f, -0.01734372f, 0.01793944f, 
    -0.02551866f, -0.02897975f, 0.05372469f, -0.03848160f, -0.02527945f, -0.05921638f, 0.01058616f, 0.01242632f, 
    0.03033879f, 0.03182433f, -0.01225936f, -0.04242753f, -0.05882711f, 0.03027064f, 0.00010782f, 0.00142254f, 
    0.03321992f, -0.04201117f, -0.05844766f, 0.00955788f, 0.03052047f, 0.01122118f, -0.01413806f, 0.01117110f, 
    -0.01795929f, 0.01810548f, -0.01972665f, -0.02150746f, 0.01208557f, -0.05496101f, -0.04747197f, -0.06046665f, 
    0.01709269f, 0.02307623f, 0.00725994f, 0.04511668f, 0.04538082f, -0.00642426f, -0.05624812f, -0.00475478f, 
    -0.04173254f, -0.04557338f, 0.00340196f, -0.05619471f, 0.01787921f, 0.03319896f, 0.02803931f, 0.00751351f, 
    -0.00635100f, 0.00038066f, 0.03872928f, 0.03135671f, -0.01053700f, -0.00372508f, -0.05208376f, -0.01318983f, 
    -0.02859589f, -0.05997001f, -0.04898609f, -0.01781245f, 0.04097495f, -0.00752598f, 0.01296498f, -0.01036771f, 
    -0.05444693f, -0.04096914f, 0.02592176f, -0.01339090f, -0.04051867f, 0.04066746f, 0.03021753f, -0.00004040f, 
    0.03749878f, -0.03885729f, 0.00790680f, 0.02176743f, 0.04095073f, 0.04595136f, -0.02776936f, 0.03147163f, 
    -0.01174559f, -0.02454977f, -0.03021708f, -0.05755505f, -0.06396805f, -0.00610452f, 0.02842517f, -0.06249501f, 
    -0.01163360f, 0.02823460f, 0.00148675f, -0.00079918f, 0.00252468f, -0.01546743f, 0.02523839f, -0.04893057f, 
    -0.04967430f, -0.00700207f, 0.02215950f, -0.05923708f, 0.03106046f, -0.06106629f, 0.01814499f, -0.00693441f, 
    0.01388914f, 0.00725904f, -0.01847588f, -0.02582998f, -0.03238467f, 0.04406363f, 0.04936643f, 0.03771593f, 
    -0.01960791f, -0.01192766f, 0.01276409f, -0.04177566f, -0.05296179f, 0.04721983f, 0.01123956f, -0.05814870f, 
    -0.01192399f, 0.02751778f, -0.02271912f, -0.03849342f, -0.06102045f, -0.05392040f, -0.02116768f, -0.03523073f, 
    -0.02120489f, -0.05145000f, -0.01096601f, 0.03047169f, 0.04628254f, 0.05192683f, -0.04463030f, 0.04875426f, 
    0.02369683f, 0.02682766f, -0.01641565f, 0.04104793f, 0.00659680f, 0.02380370f, -0.04374566f, 0.03710638f, 
    -0.05618234f, -0.04147429f, 0.03053221f, 0.04804979f, -0.02347735f, -0.05500110f, 0.01809598f, 0.04189643f, 
    0.00227272f, -0.01649096f, 0.01705314f, 0.02854609f, 0.01758175f, 0.04023133f, -0.02454761f, -0.03514097f, 
    -0.02542127f, -0.01771155f, -0.01638559f, 0.03453208f, -0.06511743f, 0.00052312f, -0.00266184f, 0.01419456f, 
    -0.09280072f, -0.51628309f, 0.22198832f, -0.02751233f, -0.13475557f, 0.05150591f, 0.02077242f, 0.03764561f, 
    0.02221360f, -0.55951786f, 0.14000611f, -0.21156958f, 0.02032760f, 0.11916099f, -0.03179134f, -0.33146694f, 
    0.01681368f, 0.02557369f, 0.14914140f, -0.34130138f, 0.36588365f, -0.16142286f, -0.28432572f, -0.02986225f, 
    -0.02861297f, 0.13377257f, -0.12612702f, -0.19095597f, 0.45552683f, -0.14285451f, 0.14164232f, -0.10565218f, 
    -0.01431132f, -0.08674998f, -0.16302323f, 0.09400587f, -0.04723885f, 0.39812991f, 0.08149812f, 0.21479873f, 
    -0.01173657f, 0.15318605f, -0.15389769f, -0.01107030f, 0.17781118f, -0.32742819f, -0.09181236f, -0.06843559f, 
    0.20058969f, -0.03813951f, -0.09554786f, -0.07362873f, -0.20133181f, 0.05807046f, -0.31731233f, 0.13314772f, 
    0.05996072f, -0.06719613f, -0.28098115f, -0.03901193f, -0.06456259f, 0.06589353f, 0.03077132f, 0.14566094f, 
    -0.08697495f, -0.12374082f, -0.11368922f, -0.26292312f, -0.27649263f, 0.00461256f, 0.06061907f, 0.04977986f, 
    0.16485073f, -0.23396552f, 0.41657597f, 0.03630143f, 0.10316662f, -0.10810444f, -0.04457882f, 0.04422487f, 
    0.13205883f, -0.14951840f, 0.11109569f, 0.16882835f, 0.14782049f, 0.05401463f, 0.06482248f, 0.08942932f, 
    0.03829131f, 0.00095021f, -0.30226040f, -0.20200343f, -0.01335246f, 0.04811570f, -0.05653971f, -0.09856731f, 
    0.06302381f, 0.19484828f, -0.23072718f, -0.32327959f, 0.21295065f, 0.13868333f, -0.09106115f, 0.04394481f, 
    0.07452828f, 0.12982471f, 0.10295652f, -0.23780033f, 0.08932385f, -0.26983324f, -0.30057797f, -0.27238932f, 
    -0.18500580f, -0.03629721f, -0.04094371f, 0.11920649f, -0.13835074f, 0.38050261f, 0.02117857f, -0.40530491f, 
    -0.25309855f, -0.16525878f, -0.11331514f, -0.23870723f, 0.04478987f, -0.06593641f, 0.18359913f, -0.12931462f, 
    0.33853936f, 0.00792236f, 0.15109473f, -0.08353749f, 0.01938806f, 0.10225140f, -0.10221060f, 0.45018402f, 
    0.06661820f, 0.24357803f, -0.11357074f, 0.08377874f, -0.16847768f, 0.05339050f, -0.07617361f, 0.02724369f, 
    -0.28779930f, 0.21130815f, -0.04909589f, -0.03924859f, 0.17342165f, 0.15102206f, -0.14092052f, 0.03008071f, 
    0.12960386f, -0.02630563f, 0.24117270f, -0.27899894f, 0.07993186f, 0.08810353f, -0.31581730f, -0.03796407f, 
    0.04876200f, -0.12152390f, 0.09843060f, -0.30160931f, 0.21503583f, -0.09702592f, -0.18627025f, 0.01816890f, 
    0.22055061f, 0.33281165f, -0.03529518f, 0.30079901f, 0.37728226f, -0.10709395f, 0.27333727f, 0.27097479f, 
    -0.00478035f, -0.25665298f, 0.09331398f, -0.20040652f, 0.12805562f, -0.15050931f, 0.43768835f, 0.24055585f, 
    0.05941373f, 0.02256309f, -0.08085883f, -0.08446851f, -0.06299030f, -0.48087066f, 0.15124591f, 0.30355880f, 
    0.18081348f, 0.03294156f, -0.12028888f, -0.04973327f, 0.04788008f, 0.16153547f, 0.27772987f, -0.10980716f, 
    0.63542753f, -0.35564044f, 0.02404476f, -0.29030022f, -0.13053015f, 0.10504697f, 0.09020055f, -0.13065602f, 
    0.17340337f, 0.65774310f, 0.38147905f, 0.10267031f, 0.09037936f, -0.03219954f, 0.00266180f, 0.19671704f, 
    0.07788672f, 0.01486959f, -0.37223709f, 0.27858603f, -0.10285974f, 0.04348660f, 0.06738354f, 0.01431117f, 
    0.05653524f, -0.33054829f, -0.11002283f, 0.13970050f, 0.06907176f, 0.14263867f, 0.04853466f, -0.10568608f, 
    0.09582850f, 0.01639626f, 0.03085753f, -0.01657922f, 0.57920039f, 0.30954885f, 0.10312837f, 0.16910349f, 
    -0.31599289f, -0.11025156f, -0.00452475f, 0.17269896f, 0.15081362f, -0.01648501f, -0.04086361f, -0.23305090f, 
    0.16539039f, -0.02573682f, -0.03671099f, -0.13638040f, 0.48928931f, -0.11564183f, 0.01717510f, -0.02295920f, 
    0.14858690f, 0.14728326f, -0.15873887f, 0.15877953f, -0.02772482f, 0.09857973f, -0.17307605f, -0.28162006f, 
    -0.36404836f, 0.07738817f, 0.04300443f, -0.08021478f, -0.22398275f, -0.09128401f, 0.55533558f, -0.35419416f, 
    -0.24686071f, 0.27727264f, 0.00459468f, 0.03379943f, -0.07334311f, 0.06715071f, -0.23021854f, -0.00042942f, 
    -0.08387114f, 0.11263327f, 0.15248360f, 0.15208799f, 0.08106949f, -0.04936187f, 0.05977170f, -0.10550141f, 
    -0.30806699f, 0.04716695f, -0.08108627f, -0.05238260f, 0.08101200f, -0.12136861f, -0.10505071f, 0.15153390f, 
    0.10992177f, 0.38179100f, -0.19618930f, -0.21821998f, 0.16948907f, -0.02977420f, -0.01574504f, 0.01421285f, 
    0.12922108f, 0.06011184f, 0.21790092f, -0.37545425f, -0.00311100f, 0.02596746f, -0.01172378f, 0.01222782f, 
    0.06329054f, 0.03735234f, 0.05428393f, -0.02838083f, -0.07224450f, -0.02896675f, 0.07956968f, 0.02668324f, 
    0.17266785f, 0.09342328f, 0.14174195f, -0.07230095f, 0.16940086f, -0.03425144f, -0.12726015f, -0.00381383f, 
    -0.10711258f, -0.00923777f, 0.08163702f, 0.04281485f, 0.17302458f, 0.12665910f, 0.01419361f, 0.02696955f, 
    0.14927083f, 0.26003587f, 0.23138396f, -0.06613605f, -0.02437946f, 0.25012740f, 0.63197660f, -0.24248405f, 
    -0.23580062f, -0.03805813f, -0.14018649f, -0.20436759f, -0.02498191f, 0.17035949f, 0.12025598f, -0.21596333f, 
    -0.27299559f, 0.13215297f, 0.31838772f, 0.06759502f, 0.10490842f, -0.06254219f, -0.42705393f, 0.21170458f, 
    -0.23641360f, -0.03138133f, -0.06770375f, 0.07290357f, -0.02550286f, -0.06744630f, 0.07258949f, -0.00215648f, 
    -0.09973948f, 0.11388659f, 0.21548329f, -0.06635924f, -0.20761251f, -0.03677881f, 0.10433763f, -0.07626352f, 
    0.13778187f, -0.00292646f, -0.13064848f, 0.11678615f, 0.04067984f, -0.10379267f, -0.04461306f, 0.21260223f, 
    -0.09597245f, -0.19628437f, -0.11388015f, 0.04296398f, 0.05998045f, 0.24614215f, 0.07624860f, 0.01615608f, 
    0.14728327f, 0.08747201f, 0.06553028f, -0.20430060f, 0.01161065f, -0.00887631f, -0.21626231f, 0.02546551f, 
    0.09952646f, -0.02858101f, 0.03804732f, -0.04364048f, 0.00974218f, 0.22859983f, -0.03288481f, -0.10454905f, 
    -0.15033422f, -0.11597795f, -0.06563959f, 0.01491700f, -0.08411730f, -0.01990173f, 0.18261133f, 0.31855631f, 
    -0.21773785f, -0.05586413f, -0.06356671f, 0.11362854f, -0.03904613f, 0.12313988f, -0.13351725f, 0.29894471f, 
    -0.15500158f, 0.24368307f, -0.01912698f, -0.11744382f, -0.03176225f, -0.02691029f, -0.25196218f, 0.15407459f, 
    -0.14045331f, -0.46503246f, 0.09903102f, -0.05785769f, 0.12913723f, 0.09449985f, -0.03938335f, -0.14324182f, 
    -0.21606323f, 0.44866616f, -0.00841289f, -0.16020383f, -0.18670972f, -0.15001352f, -0.00765893f, 0.13831265f, 
    -0.10908386f, 0.01706313f, 0.24152851f, -0.36578795f, 0.07582625f, -0.04897930f, -0.08403430f, -0.09527474f, 
    -0.03796354f, -0.07036016f, 0.13253210f, -0.09058145f, -0.36386731f, 0.04119185f, -0.05444976f, -0.04903821f, 
    0.19314942f, -0.00958455f, -0.18467472f, -0.07280198f, -0.41785192f, 0.39513761f, -0.27671948f, -0.10967797f, 
    -0.49299064f, -0.09043346f, 0.05392377f, -0.01266597f, 0.05920546f, -0.38591379f, 0.18590234f, 0.06739996f, 
    0.07868115f, 0.11681499f, -0.13257995f, 0.05845008f, 0.03395944f, -0.12335100f, 0.22497848f, -0.17358346f, 
    0.02308105f, 0.00177511f, 0.22260578f, -0.19282927f, 0.08460691f, 0.21372132f, 0.22726054f, 0.23768507f, 
    0.36576226f, -0.03659222f, -0.07894965f, 0.05540042f, -0.00327005f, -0.05532774f, 0.07939112f, -0.00197481f, 
    0.14764583f, -0.16335830f, 0.06580351f, -0.03291316f, 0.10571551f, 0.07217462f, 0.01808719f, -0.08659434f, 
    -0.03852650f, 0.14600475f, 0.21459074f, 0.04440792f, 0.12862597f, 0.32343465f, 0.05555125f, 0.06045466f, 
    0.08650668f, 0.11004882f, 0.04043063f, 0.18861358f, 0.04781289f, 0.31761113f, 0.27714145f, 0.21332152f, 
    -0.21824242f, 0.12826382f, -0.03596205f, -0.01195126f, -0.06281228f, -0.11533542f, -0.17502353f, -0.38287395f, 
    -0.01772099f, 0.09203782f, 0.05711243f, 0.08776913f, 0.14276475f, 0.29635319f, -0.14011672f, -0.13672234f, 
    -0.25712851f, -0.19638030f, 0.07021388f, -0.12097243f, 0.01865115f, 0.08542458f, -0.41202143f, -0.14770524f, 
    -0.06430292f, -0.01032248f, 0.08110233f, -0.15679520f, -0.16841374f, 0.03181809f, -0.04582626f, -0.21479264f, 
    -0.15457988f, 0.09152885f, -0.20567629f, 0.02576376f, -0.31831422f, 0.11007114f, 0.25397405f, 0.47681734f, 
    -0.27251914f, 0.05444046f, -0.09160972f, -0.37435690f, -0.04407967f, 0.07111499f, -0.08322772f, 0.06937854f, 
    0.21733274f, 0.34536210f, -0.40100145f, 0.09713947f, 0.11892516f, -0.16613509f, 0.08129702f, 0.06046262f, 
    0.02346440f, -0.00803038f, 0.12824966f, 0.14032131f, -0.10578326f, 0.07568834f, -0.06542548f, -0.01228063f, 
    -0.00181642f, 0.13016592f, 0.11330314f, 0.08280197f, 0.02496175f, -0.06359489f, -0.00409287f, -0.16074584f, 
    -0.01848445f, 0.10365664f, -0.09701392f, 0.15181731f, -0.19503185f, 0.00002343f, 0.01806797f, -0.16211522f, 
    -0.07808740f, 0.06661024f, -0.09708648f, -0.08419770f, 0.25937769f, 0.06536660f, 0.17894770f, -0.12100694f, 
    0.06206058f, 0.00813094f, 0.12947902f, -0.17403151f, 0.05010838f, 0.46663666f, 0.28238124f, -0.30487517f, 
    0.35999796f, 0.05945184f, -0.03331512f, -0.26024190f, -0.18874261f, -0.30557942f, -0.02796606f, 0.01598529f, 
    -0.16513844f, 0.11493940f, -0.10893258f, 0.01426260f, -0.09318160f, 0.23268929f, 0.08363397f, -0.15313065f, 
    0.18183690f, 0.08907583f, -0.17412379f, -0.09761614f, -0.04598175f, -0.05268309f, -0.04876849f, 0.15349217f, 
    0.17360358f, 0.00315950f, -0.20116161f, 0.11892265f, 0.28156763f, 0.15105838f, -0.09576559f, 0.18788539f, 
    0.20676823f, -0.24000503f, 0.29644006f, -0.04052547f, 0.10204075f, -0.06328379f, -0.08370800f, -0.21146576f, 
    -0.09123196f, -0.08258161f, -0.51187617f, 0.16838463f, 0.08219475f, 0.13179782f, 0.05003707f, 0.10530664f, 
    -0.15872045f, -0.24426198f, -0.09002837f, -0.03018525f, -0.20414732f, -0.40597266f, -0.05028021f, 0.11568308f, 
    -0.25767246f, 0.10473184f, -0.13387269f, 0.01042912f, 0.01408066f, -0.13943002f, 0.07873762f, 0.11871420f, 
    -0.01570208f, 0.16014183f, 0.02059384f, -0.10356439f, -0.05478379f, -0.18964580f, -0.04671938f, -0.08422679f, 
    -0.01578199f, 0.02058305f, 0.05998408f, 0.27787426f, -0.09827599f, -0.23678967f, 0.14119539f, 0.04386502f, 
    -0.10767226f, 0.10210807f, -0.09037977f, -0.02452720f, 0.07217043f, -0.19763032f, 0.09985857f, -0.15319012f, 
    -0.21211326f, -0.24841546f, -0.21090859f, 0.15977995f, -0.05933516f, 0.12824185f, -0.02316601f, -0.04628200f, 
    -0.13486239f, -0.12306468f, 0.03750173f, -0.38157716f, 0.01499527f, -0.00545568f, 0.04429189f, 0.10181838f, 
    -0.11125968f, -0.43762782f, 0.26750666f, 0.23876560f, -0.19239461f, -0.15770270f, -0.39235750f, -0.07350525f, 
    -0.00680843f, 0.06075398f, 0.10093912f, -0.08686842f, 0.20734398f, -0.11772395f, 0.01840756f, -0.15492526f, 
    -0.02541293f, 0.01784181f, -0.22256295f, -0.01473703f, 0.22446997f, 0.14117797f, -0.26205516f, -0.20517144f, 
    0.04777141f, 0.05812110f, -0.05671220f, 0.14884646f, -0.16397506f, -0.08822540f, 0.18653002f, 0.09614584f, 
    0.16547187f, 0.08613896f, 0.05332836f, -0.04971114f, 0.07130309f, 0.25157231f, 0.14036065f, -0.34758791f, 
    -0.06686778f, 0.06616703f, 0.01752296f, -0.04296935f, 0.08682635f, 0.19800350f, -0.30190232f, -0.11091971f, 
    0.11219556f, -0.28042153f, 0.06160676f, -0.01906085f, 0.03733421f, 0.07814658f, 0.13313724f, -0.06065605f, 
    -0.10918840f, 0.18794043f, 0.09934485f, 0.06320290f, -0.02155686f, 0.09156629f, 0.01288310f, 0.23775569f, 
    0.02597897f, 0.17291564f, -0.05622027f, -0.16599710f, -0.04640212f, -0.19023170f, -0.00475991f, 0.01037115f, 
    -0.29443043f, 0.33100891f, 0.13928325f, -0.27781123f, 0.22141151f, 0.20257971f, 0.08226918f, -0.05907376f, 
    -0.20655616f, -0.22209170f, -0.00753271f, -0.42831987f, -0.06909855f, 0.29930964f, 0.24988140f, 0.16113834f, 
    0.06854355f, -0.40017256f, 0.06680577f, 0.24945073f, 0.02029785f, -0.41425866f, 0.10132997f, 0.12620057f, 
    0.04613549f, 0.19555134f, -0.07789523f, 0.09144334f, -0.23188484f, -0.09167833f, -0.03164009f, 0.00480423f, 
    0.06865922f, -0.16295792f, 0.13954088f, 0.17271271f, -0.03314964f, -0.32056886f, -0.02577649f, 0.26544359f, 
    0.15854017f, 0.20138569f, -0.08416606f, 0.08287545f, 0.00536558f, -0.01968441f, 0.18025051f, 0.21733277f, 
    -0.03311960f, 0.09322810f, 0.08933482f, 0.01266505f, -0.00716944f, -0.08308499f, 0.15436819f, 0.19941847f, 
    -0.04257529f, 0.06087620f, 0.07833851f, 0.09401423f, -0.09462570f, 0.19463278f, 0.19294100f, -0.09718484f, 
    0.25610927f, -0.01983769f, -0.11289219f, 0.15836576f, 0.11332364f, -0.18085331f, 0.11575996f, 0.05934969f, 
    0.19603902f, -0.02066032f, -0.06545415f, 0.29825583f, -0.16869418f, 0.00487359f, 0.16524801f, -0.17223407f, 
    0.00810093f, 0.07455699f, -0.13616657f, 0.10513555f, 0.04585838f, -0.10504309f, -0.11645356f, -0.00704481f, 
    -0.03409398f, 0.05854772f, 0.04788524f, 0.03731152f, 0.01018616f, 0.17631164f, 0.01462865f, 0.03981787f, 
    -0.01517542f, -0.07246530f, 0.03435823f, 0.02264620f, 0.10581609f, 0.07559890f, 0.21020883f, 0.04442767f, 
    -0.11312535f, -0.29399452f, 0.02356545f, 0.08508201f, -0.00039755f, -0.28553253f, 0.11201736f, -0.13194786f, 
    0.25873381f, 0.05597327f, 0.08913421f, 0.13722727f, 0.23398377f, 0.07250009f, -0.04990570f, -0.21058738f, 
    -0.15951572f, -0.11237407f, -0.16761453f, -0.39588633f, -0.15846153f, -0.03779513f, 0.01207145f, 0.23585868f, 
    0.16069914f, -0.06871371f, -0.27166206f, -0.10004677f, 0.01545345f, -0.18917789f, 0.19103716f, 0.13797741f, 
    -0.07685991f, 0.24499379f, -0.15639956f, 0.06044647f, 0.20948140f, -0.02054944f, 0.17427514f, -0.13567096f, 
    -0.07060575f, -0.52088970f, -0.08071393f, 0.28526303f, 0.20887446f, 0.11878359f, -0.18484275f, -0.04903407f, 
    -0.01987605f, 0.31653839f, -0.12556618f, -0.15893686f, 0.05891122f, 0.27774328f, 0.04378891f, 0.18060678f, 
    0.05016338f, 0.14150223f, 0.13146301f, -0.11238945f, 0.04535475f, -0.02529928f, -0.10148647f, -0.15205449f, 
    0.14615272f, -0.17147101f, -0.07428994f, 0.21094701f, -0.13089816f, -0.02955409f, -0.10622686f, 0.35047388f, 
    0.16397752f, -0.06172349f, 0.10141502f, -0.04265873f, 0.28965062f, 0.03202244f, -0.37920156f, -0.13467228f, 
    -0.02074744f, 0.19926311f, 0.18892452f, 0.13365746f, -0.14143887f, 0.00378091f, -0.53380007f, -0.07737544f, 
    -0.07808354f, 0.12829682f, 0.13494341f, -0.01787015f, -0.26042479f, 0.16424400f, 0.15152037f, -0.03155241f, 
    -0.28626725f, -0.38810453f, -0.11583655f, -0.00710473f, 0.21088134f, -0.22724704f, 0.32625282f, -0.10538261f, 
    0.12331510f, -0.03239720f, -0.05085586f, -0.09845244f, 0.01789413f, 0.05296192f, -0.31070641f, 0.15895918f, 
    0.11842259f, 0.26268175f, -0.14574514f, 0.12511668f, -0.68222505f, 0.00659024f, 0.00802508f, -0.17445926f, 
    -0.03963684f, 0.23429760f, 0.00636241f, -0.07249234f, 0.15153374f, 0.01791823f, -0.21804872f, -0.19526520f, 
    -0.15245695f, 0.26081851f, -0.00586462f, 0.32784164f, 0.20087577f, 0.31155616f, -0.10949362f, -0.11177451f, 
    -0.39965311f, 0.18035693f, 0.29062748f, 0.14484397f, -0.46946484f, 0.07057954f, 0.19688900f, 0.30456093f, 
    0.15043235f, 0.01711743f, -0.23075306f, -0.10165030f, -0.36614436f, 0.35040125f, 0.21011920f, 0.01023298f, 
    0.01605687f, 0.18959560f, 0.04124239f, 0.35907146f, -0.17977142f, 0.02479857f, 0.23350327f, 0.04472855f, 
    -0.34419543f, -0.00604927f, -0.02872277f, -0.21897118f, 0.12182481f, 0.21067199f, 0.08432616f, -0.04805592f, 
    0.06424184f, -0.00445659f, 0.26824945f, 0.10782859f, 0.14394751f, -0.01763508f, -0.00489847f, -0.26372978f, 
    -0.11093140f, 0.24248292f, 0.27469131f, -0.05770583f, -0.02670563f, 0.06191245f, 0.04726725f, -0.02467771f, 
    0.05935221f, -0.38533530f, 0.01290304f, -0.08034322f, 0.00029273f, 0.04844946f, 0.08067702f, 0.00579080f, 
    0.06936978f, 0.14300838f, 0.14612150f, 0.12246589f, -0.19964683f, 0.16126181f, 0.15874602f, -0.06054126f, 
    0.31455207f, 0.04854258f, -0.03791156f, 0.22445653f, 0.21972582f, 0.24181777f, -0.21243584f, -0.09748242f, 
    -0.27615497f, 0.14450368f, 0.08722787f, 0.16922143f, -0.34451479f, -0.32054287f, -0.20831364f, -0.34983411f, 
    0.25226596f, 0.00394618f, -0.13330504f, -0.24097785f, 0.11668850f, -0.19131304f, 0.15304036f, 0.07831231f, 
    -0.08358188f, -0.12619723f, 0.07143014f, -0.04710864f, 0.02413763f, 0.13293460f, 0.08617348f, 0.11812776f, 
    0.02536612f, -0.02846067f, -0.17802189f, 0.00664009f, -0.30207980f, -0.02633987f, -0.04750491f, 0.06248420f, 
    0.10092650f, 0.13076961f, 0.07896985f, -0.10168584f, 0.02737265f, 0.08153060f, 0.32554847f, 0.13696460f, 
    0.76881492f, 0.21069635f, 0.06370305f, -0.18901175f, -0.21482499f, -0.01089230f, 0.16381496f, 0.14253125f, 
    0.13865358f, -0.25408658f, -0.00107317f, 0.18865578f, -0.00285515f, 0.00484711f, 0.22560993f, -0.00972675f, 
    0.00580555f, 0.13191208f, -0.35307348f, -0.03731760f, -0.12214538f, 0.09317879f, -0.00464599f, 0.01896441f, 
    -0.17119226f, -0.02814539f, -0.13368307f, -0.25905398f, -0.04248257f, -0.02957582f, 0.07097149f, 0.12631424f, 
    -0.05831077f, -0.04322588f, -0.10829109f, 0.00374422f, -0.10829446f, -0.23530822f, 0.07485141f, -0.01465776f, 
    0.03885763f, 0.02400124f, -0.23888768f, 0.04655689f, 0.12844260f, 0.32654339f, 0.40741694f, 0.24290156f, 
    -0.09986299f, -0.22391509f, -0.12111384f, -0.01994082f, 0.22471063f, 0.06956527f, 0.35347727f, -0.33878586f, 
    -0.26348823f, -0.18765885f, 0.02319448f, 0.08577359f, 0.02988423f, 0.09624779f, 0.03566557f, 0.18524490f, 
    0.17405529f, -0.55161482f, 0.08043703f, 0.19564092f, 0.26584297f, -0.27413025f, -0.00059057f, -0.00066674f, 
    0.22871543f, 0.04321147f, -0.30850521f, -0.01146126f, 0.04319559f, -0.16624564f, -0.04157891f, 0.09318455f, 
    0.03435379f, 0.26804620f, -0.27568287f, 0.15112436f, -0.16065833f, -0.19882886f, -0.17912893f, 0.05287186f, 
    0.25558054f, -0.21369314f, 0.14347811f, -0.30275512f, -0.44077826f, -0.06589925f, -0.12837246f, 0.04145556f, 
    0.02307523f, 0.13733925f, 0.06347381f, -0.25064504f, -0.18245272f, 0.14355062f, 0.05401343f, 0.09815972f, 
    -0.02542796f, 0.06287397f, 0.11503192f, 0.16726823f, -1.10990810f, 0.31322592f, 0.05354118f, 0.19057690f, 
    0.04385117f, -0.03356843f, -0.00093444f, 0.12310939f, 0.30471095f, -0.17849384f, 0.05740777f, -0.17877381f, 
    0.07841566f, 0.13146551f, 0.31945577f, -0.05237141f, -0.02144674f, 0.13741522f, 0.65692306f, -0.27729756f, 
    -0.00069555f, -0.14744081f, 0.06612255f, -0.06598244f, 0.00891968f, 0.09020693f, 0.28770483f, -0.46127823f, 
    -0.44221815f, -0.03586329f, 0.13898234f, -0.09538826f, 0.07994269f, -0.25614634f, 0.08798312f, -0.08568086f, 
    -0.41899166f, 0.19001675f, -0.35715127f, 0.03840024f, -0.08517118f, 0.08129619f, 0.10824950f, 0.02598419f, 
    0.34661010f, 0.18691096f, 0.28234351f, 0.05523725f, 0.02837211f, 0.16108303f, 0.21885425f, -0.31964913f, 
    0.10357376f, -0.28102413f, -0.03452665f, 0.03506038f, -0.31175247f, -0.06726418f, 0.00150775f, 0.09123773f, 
    -0.02150640f, -0.08305731f, -0.20662875f, -0.41537619f, -0.12711197f, -0.11424222f, 0.05190585f, 0.30793029f, 
    -0.18113834f, -0.39628640f, 0.20472768f, 0.27407825f, 0.34468484f, -0.60669827f, -0.52284110f, -0.11883825f, 
    0.11078307f, 0.13813202f, -0.26854545f, 0.02389382f, 0.13280259f, 0.60822618f, 0.04752618f, -0.11462029f, 
    0.06110662f, -0.23813070f, -0.34030634f, 0.20752510f, -0.05564291f, -0.08851704f, 0.24608667f, 0.05178468f, 
    0.07238395f, -0.08749426f, -0.06583537f, 0.08192137f, 0.13079622f, -0.10116232f, -0.01888250f, 0.12802728f, 
    -0.36355329f, 0.09763468f, 0.01570877f, 0.31034634f, -0.09219078f, 0.19393004f, -0.17266944f, -0.21442977f, 
    0.03595507f, -0.33367693f, -0.38520062f, 0.16293266f, 0.11742771f, -0.07107066f, -0.14073069f, 0.16330656f, 
    0.22900389f, 0.00929935f, 0.12161770f, 0.31750542f, 0.02104342f, 0.19360487f, 0.04837193f, -0.00884984f, 
    -0.03995987f, 0.08748829f, -0.03289821f, 0.09461976f, 0.07784419f, 0.03202584f, -0.00278773f, -0.06661250f, 
    -0.01681185f, -0.09534381f, -0.13032897f, -0.27458248f, -0.42688513f, 0.00064082f, -0.10428259f, 0.12453989f, 
    -0.14352019f, 0.03235823f, 0.09251720f, 0.04601346f, 0.28675810f, -0.39903411f, -0.01797344f, 0.05661997f, 
    -0.08367794f, 0.21902046f, -0.10359892f, -0.07741033f, -0.14169443f, -0.09971654f, 0.18086293f, -0.03705122f, 
    0.13850680f, 0.19300663f, 0.12281679f, 0.09894308f, 0.06598010f, -0.18021956f, 0.37249550f, 0.17164274f, 
    -0.50288689f, -0.04268261f, 0.19254851f, 0.37212572f, -0.02990381f, 0.08844435f, -0.02838463f, -0.16365886f, 
    0.01756271f, -0.10218947f, -0.07124935f, 0.14438350f, -0.03783022f, -0.03984626f, -0.03587223f, -0.00784233f, 
    0.24725786f, 0.22119774f, 0.06981855f, 0.07274990f, -0.15092941f, -0.10236607f, 0.03749543f, 0.09030642f, 
    -0.11313567f, 0.29999843f, 0.16181043f, -0.12423138f, 0.04910148f, 0.08484835f, -0.04335865f, 0.05856377f, 
    0.06426893f, -0.02508238f, -0.28510574f, 0.03352349f, -0.22927208f, 0.02584081f, 0.07820497f, -0.14017132f, 
    -0.00881910f, 0.11242981f, 0.00486948f, 0.23333135f, 0.25543740f, -0.10990738f, -0.02389115f, -0.10782953f, 
    -0.06439374f, -0.09665874f, 0.02377181f, -0.13809688f, 0.13958830f, 0.06537500f, 0.02317472f, -0.16804446f, 
    -0.02338239f, 0.14701876f, -0.02829478f, -0.02136615f, -0.01310445f, -0.48572463f, 0.02892284f, -0.11817256f, 
    0.12032444f, 0.31041130f, 0.05629351f, 0.02773005f, -0.20462121f, 0.07682303f, -0.33336180f, 0.29581839f, 
    0.00310729f, 0.02910469f, 0.01459201f, 0.05611788f, -0.05992315f, 0.05261227f, 0.00682569f, -0.17499015f, 
    0.01833073f, -0.10158316f, -0.05328573f, 0.09808963f, -0.04231318f, -0.13464245f, 0.11669664f, -0.20095812f, 
    -0.13073429f, 0.24036948f, -0.13229097f, 0.20984574f, -0.00818806f, -0.11785835f, 0.04498078f, -0.05295112f, 
    -0.01398547f, -0.14960282f, 0.01587833f, 0.16204742f, -0.07981873f, 0.16996557f, 0.00268818f, -0.07579638f, 
    0.10461596f, -0.04137727f, -0.36771646f, -0.08866435f, -0.05274441f, -0.10060354f, -0.05220009f, -0.03445666f, 
    -0.03388157f, 0.22569273f, -0.25590369f, 0.19477044f, -0.02810844f, -0.09271330f, 0.24376768f, 0.20831481f, 
    0.07387358f, 0.13596125f, 0.04209493f, 0.15295586f, 0.00807072f, -0.24962051f, -0.27918637f, -0.16364442f, 
    -0.09341567f, 0.05549021f, -0.02548199f, 0.15332901f, -0.17746913f, 0.11486474f, -0.54886329f, 0.11087705f, 
    0.08722012f, -0.05997641f, -0.07562812f, -0.10407081f, 0.06938942f, -0.16909200f, -0.36154988f, 0.41417515f, 
    -0.16634369f, 0.07856940f, -0.13955598f, -0.02773117f, -0.04142135f, 0.28425691f, 0.01991577f, 0.26596749f, 
    -0.87090743f, -0.14622515f, 0.01219934f, 0.04038707f, -0.02491706f, -0.08657272f, -0.02666674f, 0.08968147f, 
    0.31795770f, 0.23342319f, -0.21139246f, 0.13697404f, -0.04761709f, 0.01905666f, -0.04745310f, 0.12093893f, 
    0.19039534f, 0.33093494f, 0.23244199f, 0.26328957f, -0.13117643f, -0.02196532f, 0.07834379f, 0.14039955f, 
    -0.17505953f, 0.31847382f, -0.00112521f, 0.15630481f, -0.27179074f, -0.32706669f, 0.08106189f, -0.18901259f, 
    -0.06574561f, 0.10096662f, -0.00628018f, 0.08802366f, 0.11935885f, -0.01766494f, -0.07454127f, -0.04884810f, 
    0.11120615f, -0.06375958f, -0.06995593f, 0.00752671f, -0.36182413f, -0.09732649f, -0.01075694f, -0.00681672f, 
    -0.12909386f, -0.01100059f, 0.22768153f, 0.02029391f, 0.01547889f, 0.67582780f, 0.23514801f, 0.26159045f, 
    -0.13248777f, -0.01240032f, -0.15440291f, 0.16738507f, -0.10412161f, 0.13647543f, 0.03194857f, -0.09349262f, 
    -0.22069529f, -0.07994942f, -0.14019249f, 0.04297031f, -0.19824328f, 0.00289441f, -0.01717524f, 0.02678478f, 
    0.35758719f, -0.16347648f, 0.05432807f, 0.02541758f, 0.00361538f, -0.13137084f, 0.03607958f, -0.30470702f, 
    0.00252974f, 0.16343792f, 0.38595378f, -0.16802429f, -0.01460579f, -0.02319027f, -0.17778027f, 0.00958527f, 
    -0.10765222f, -0.20029777f, 0.27122605f, -0.02701835f, 0.13567676f, 0.14319700f, -0.00256654f, 0.18007264f, 
    0.03538568f, 0.17458983f, 0.23761486f, 0.15595572f, -0.24601641f, 0.50753778f, 0.29346555f, 0.14970225f, 
    0.01456369f, -0.07393235f, -0.13753115f, -0.01483159f, 0.10750075f, 0.06614745f, 0.04588151f, -0.04439557f, 
    0.03322979f, 0.01492070f, 0.11926162f, -0.01645458f, -0.16396849f, 0.11282031f, 0.20483264f, -0.09542440f, 
    0.23968552f, -0.02071462f, -0.05058654f, -0.00999228f, 0.15939966f, 0.08350266f, -0.11630552f, -0.09899090f, 
    0.13079807f, -0.06338593f, 0.02960064f, 0.02390955f, 0.20311125f, -0.03701630f, -0.55831248f, -0.11406035f, 
    0.34956536f, 0.02377729f, 0.12712845f, -0.45304984f, -0.09709138f, -0.10288823f, 0.16673303f, 0.09277453f, 
    0.23554862f, -0.17323054f, -0.11277738f, -0.08522879f, -0.23247539f, -0.05036365f, 0.05892279f, -0.04216852f, 
    -0.04242041f, -0.06170876f, 0.00126354f, 0.01819452f, 0.02402377f, -0.06384744f, 0.02310920f, 0.05282730f, 
    0.02082174f, -0.05008952f, -0.02784127f, -0.05093916f, -0.04819750f, -0.01909560f, 0.01759304f, 0.02962122f, 
    -0.03982851f, 0.00489320f, -0.05156809f, 0.02346263f, -0.03115156f, -0.04628626f, -0.04928365f, -0.00210305f, 
    -0.00095609f, 0.01550045f, 0.03877441f, 0.04817691f, 0.03194031f, -0.02000655f, 0.03185227f, -0.04747017f, 
    0.03965784f, -0.05851492f, -0.01820445f, -0.06461494f, -0.00807302f, 0.01681313f, -0.05652403f, -0.00154857f, 
    -0.02872828f, -0.05192276f, 0.00376991f, 0.03658430f, -0.03123621f, -0.02752049f, -0.04717574f, -0.02217988f, 
    -0.04206460f, -0.04679089f, -0.03985038f, -0.03116250f, 0.00690334f, -0.01471534f, 0.00815997f, 0.03040975f, 
    -0.00097908f, 0.03876022f, -0.03733363f, 0.01732835f, -0.02954174f, -0.05702439f, -0.04350310f, 0.00611379f, 
    0.03556256f, -0.01176716f, -0.03423196f, -0.04614323f, 0.02832931f, 0.04012706f, 0.02191388f, 0.00026342f, 
    -0.03617403f, 0.00762162f, -0.00937011f, -0.01735266f, 0.00277322f, -0.02441924f, 0.02790660f, 0.02686129f, 
    -0.00408487f, -0.05421479f, -0.03405597f, -0.00773544f, 0.03099687f, 0.04378065f, 0.04229078f, 0.01639406f, 
    0.04023566f, -0.02013962f, -0.05262178f, 0.00328825f, 0.03439520f, 0.03151425f, 0.05288736f, -0.04769993f, 
    0.04832035f, -0.00671026f, -0.05237930f, 0.03080040f, -0.05242534f, -0.02466127f, 0.01271954f, 0.01768381f, 
    -0.03902091f, 0.04579960f, 0.01072778f, -0.02963908f, -0.03562403f, 0.00949556f, -0.00718626f, -0.03359530f, 
    -0.06212065f, 0.00159480f, 0.04101133f, -0.00181121f, 0.00250038f, -0.03863034f, -0.04881971f, 0.00430556f, 
    -0.05524243f, 0.04550985f, -0.03618187f, -0.02705514f, -0.01800517f, -0.06302030f, -0.01112447f, 0.00156860f, 
    -0.00763623f, -0.06212479f, 0.05205992f, -0.05569517f, 0.02709097f, 0.01243320f, -0.01533831f, -0.04108853f, 
    -0.03477810f, 0.01520943f, 0.03181260f, -0.02013578f, 0.05031028f, -0.05731747f, -0.03003484f, 0.00937938f, 
    0.04382317f, -0.03142733f, -0.01956509f, -0.04408345f, 0.00586475f, -0.02080085f, -0.06561770f, 0.01532803f, 
    0.02586433f, -0.03136200f, -0.01920952f, -0.02488691f, -0.04759134f, -0.03948625f, -0.01693963f, 0.01396104f, 
    -0.01808628f, -0.01715115f, -0.06213015f, -0.00713931f, 0.03868014f, -0.01501841f, -0.00976511f, 0.02148322f, 
    -0.05881653f, -0.01912021f, 0.02028654f, 0.04942127f, 0.00197791f, 0.03935085f, 0.00575547f, -0.00812805f, 
    0.03763837f, -0.05187054f, -0.02206647f, -0.02173040f, -0.02340147f, 0.01299097f, 0.02319562f, 0.01976126f, 
    -0.01150741f, 0.04179452f, -0.01437072f, 0.03056619f, -0.04121283f, -0.06380466f, -0.02068885f, -0.01350073f, 
    -0.04646641f, -0.06392306f, -0.03176760f, 0.04993252f, -0.02396450f, 0.04764681f, 0.04269673f, 0.04003016f, 
    0.01934838f, -0.00711344f, -0.01828177f, 0.00603958f, -0.03769151f, 0.00707791f, 0.02252232f, 0.01606919f, 
    -0.02346326f, 0.01363681f, 0.04562246f, 0.05082799f, -0.02791744f, 0.03891305f, -0.04576049f, 0.03734952f, 
    -0.00905936f, -0.05634826f, 0.01649609f, 0.00019598f, 0.03960763f, -0.05057260f, -0.00149097f, 0.01967199f, 
    0.01478823f, -0.04162869f, -0.03109738f, 0.01619926f, -0.06320082f, 0.04993473f, 0.00980175f, 0.00054272f, 
    -0.02856410f, -0.05717332f, -0.04556303f, -0.00602654f, 0.03063532f, 0.01894343f, -0.03671317f, 0.03317546f, 
    -0.05011740f, -0.04123056f, 0.02396386f, -0.04199350f, 0.01510491f, -0.00182124f, 0.02186199f, 0.03412437f, 
    -0.02254128f, 0.02250818f, 0.02557411f, 0.02578141f, 0.04296836f, -0.02180573f, -0.05997509f, -0.05985950f, 
    -0.02420750f, -0.05726735f, 0.02567109f, -0.06183885f, 0.00604292f, 0.04461659f, 0.03150337f, 0.05275621f, 
    -0.00058828f, -0.00060524f, 0.00040833f, -0.00244353f, -0.02503811f, -0.02426589f, 0.03873091f, -0.03052993f, 
    -0.01917167f, 0.04196938f, 0.02090294f, -0.02682122f, -0.03188093f, -0.00994255f, -0.00213432f, -0.03040756f, 
    -0.01491795f, -0.05341360f, -0.03059167f, -0.03431593f, 0.01243958f, -0.02628457f, -0.03804108f, 0.00520825f, 
    0.02685248f, -0.01543366f, -0.01504881f, 0.01183226f, -0.02134774f, -0.00869484f, -0.00583137f, 0.03784626f, 
    -0.01410304f, 0.01426792f, -0.05595177f, -0.01912273f, -0.01371306f, -0.05132417f, -0.03537398f, -0.04218413f, 
    -0.01363344f, -0.01584576f, -0.03385458f, 0.03745827f, 0.00954422f, 0.03412214f, -0.02332939f, -0.04619660f, 
    -0.00958577f, 0.03958993f, 0.00629694f, 0.01744205f, -0.00047194f, -0.00853864f, 0.00029903f, -0.03297450f, 
    -0.00183948f, -0.03297716f, -0.03806590f, 0.03742841f, -0.02750665f, -0.05083275f, 0.01098558f, -0.03679558f, 
    0.03091480f, -0.01545322f, 0.01567425f, 0.04911293f, 0.04000136f, 0.00948260f, -0.00005353f, 0.00589134f, 
    0.02321723f, -0.01806557f, -0.04367302f, -0.03137265f, 0.02470515f, -0.01811308f, -0.05306635f, 0.00201618f, 
    -0.00444914f, 0.04186408f, -0.04579119f, 0.03928287f, 0.02398841f, -0.04967609f, 0.02103390f, -0.03885032f, 
    -0.02679460f, 0.03851275f, 0.03897597f, -0.01168188f, -0.01529388f, 0.05286048f, -0.05424988f, -0.01234098f, 
    0.02303709f, -0.05135283f, -0.03300254f, -0.04852566f, 0.02004193f, -0.05332980f, 0.00242490f, -0.04678728f, 
    0.04276211f, 0.04732609f, -0.04721931f, -0.04638246f, 0.03580650f, -0.02834333f, -0.04368883f, -0.00635897f, 
    -0.05511926f, 0.03070071f, -0.02124187f, 0.02745553f, 0.05233850f, -0.05220129f, -0.05918926f, -0.03927124f, 
    -0.04973200f, -0.03306838f, -0.01480147f, -0.04860428f, -0.04543320f, -0.06316819f, 0.00804954f, 0.00245801f, 
    0.02452568f, -0.05992646f, 0.01723948f, -0.00432004f, 0.01327779f, 0.02776092f, -0.01228801f, 0.00143228f, 
    0.01047866f, 0.03076819f, 0.00683088f, 0.03103621f, 0.01696550f, 0.01282147f, 0.01064924f, 0.00744387f, 
    0.01379351f, 0.05183339f, 0.05274180f, -0.05125410f, -0.03455161f, -0.00301012f, 0.03057962f, -0.01059919f, 
    0.02443553f, -0.04871573f, 0.02384632f, -0.01307140f, 0.00435448f, 0.02730726f, -0.03057432f, 0.04959944f, 
    -0.01564257f, -0.06292013f, 0.00998112f, 0.01770685f, 0.04941203f, -0.00149770f, -0.04133400f, -0.00286785f, 
    -0.04582155f, -0.05729395f, -0.02215744f, -0.00970836f, 0.03786033f, -0.04170362f, -0.06173294f, 0.04109427f, 
    -0.06456065f, 0.01765678f, -0.03186130f, -0.05330455f, 0.02935860f, 0.00339277f, 0.00082991f, 0.00450026f, 
    0.02649349f, -0.02439726f, 0.02520842f, -0.05815391f, -0.02964519f, -0.03928296f, 0.04298836f, 0.01261810f, 
    -0.06016351f, -0.04399331f, -0.03281697f, -0.05569644f, -0.05316444f, 0.04037345f, 0.00426691f, -0.05811514f, 
    -0.02841316f, -0.04124752f, -0.04628896f, -0.03323143f, 0.00423249f, -0.02875519f, -0.02361787f, -0.04216459f, 
    0.01916122f, -0.01962837f, -0.03016641f, 0.03223378f, -0.01367778f, -0.00401889f, 0.01188654f, -0.04335964f, 
    -0.06259818f, -0.01645351f, 0.00356092f, 0.01999093f, 0.05030778f, -0.04502119f, 0.00019904f, -0.00526798f, 
    -0.05709165f, -0.00549174f, -0.05862230f, -0.01732638f, -0.02811305f, -0.03131818f, 0.00999091f, -0.05011445f, 
    -0.02404200f, -0.02530576f, 0.03068618f, -0.01742089f, -0.05233136f, -0.06423807f, -0.05542115f, -0.01495250f, 
    -0.04451276f, 0.02894672f, 0.02304122f, 0.01364364f, -0.01691200f, 0.00012565f, 0.02897336f, -0.01927688f, 
    0.01806820f, -0.05967912f, -0.00916274f, -0.00094506f, -0.01447359f, -0.01098576f, -0.05543291f, 0.01507294f, 
    0.00121889f, -0.03028718f, -0.02784733f, -0.03424983f, 0.04432008f, 0.00635021f, 0.03211192f, 0.00185467f, 
    -0.01891070f, -0.03827932f, 0.03896081f, -0.01481384f, -0.01409295f, 0.00357164f, 0.03589994f, 0.04210656f, 
    -0.06116277f, 0.02386986f, -0.05387660f, -0.04493370f, -0.02894306f, 0.00420571f, -0.05892492f, -0.04130305f, 
    0.03451482f, -0.06072140f, 0.03792764f, -0.04953745f, 0.04213181f, -0.00887634f, 0.00133018f, 0.02629493f, 
    0.02909867f, 0.02485853f, 0.01309456f, -0.06279299f, -0.05272982f, -0.05423425f, -0.03463402f, -0.05889049f, 
    0.02975886f, 0.02831586f, -0.00997396f, -0.04716673f, 0.00322528f, -0.06008676f, -0.03484021f, -0.05378349f, 
    0.02471506f, 0.02096309f, 0.03505323f, -0.02194739f, -0.03979639f, 0.04912098f, 0.04584874f, -0.04660257f, 
    -0.05233202f, -0.04882074f, -0.02612937f, -0.05127081f, -0.05547223f, 0.00825074f, 0.01692621f, -0.02314477f, 
    -0.03057824f, -0.04987503f, 0.05145334f, 0.05090221f, -0.04719958f, -0.03952601f, -0.03482101f, 0.01787502f, 
    0.03184985f, 0.00812930f, -0.03328883f, -0.02442322f, -0.01320094f, 0.03443815f, 0.00401624f, 0.04229250f, 
    0.03751571f, -0.00053571f, -0.05388045f, 0.03729158f, 0.00232050f, -0.03854597f, 0.00467747f, 0.04762807f, 
    0.04390066f, -0.01211773f, -0.01804966f, 0.01216072f, -0.05000909f, 0.00434058f, -0.00593055f, -0.05774564f, 
    -0.05553431f, -0.05540657f, 0.03547422f, 0.00897191f, 0.02507227f, -0.02933144f, -0.05639753f, 0.03143171f, 
    -0.01694575f, 0.00530250f, -0.02218900f, 0.04002940f, 0.00293875f, 0.00598223f, 0.03117884f, -0.00252571f, 
    0.02913752f, -0.05830171f, 0.02783137f, 0.04484412f, -0.06125256f, 0.02248228f, 0.03762750f, -0.02742339f, 
    0.02162666f, -0.00991729f, -0.03070820f, 0.02385309f, 0.01094628f, 0.04540936f, 0.02813525f, 0.04743975f, 
    0.04176550f, -0.02494078f, 0.01022618f, -0.04912350f, -0.03292469f, -0.06560966f, 0.00819798f, 0.00013992f, 
    0.00798066f, -0.03988766f, -0.00690151f, 0.02310308f, 0.04196988f, -0.04448269f, -0.00708457f, -0.03150957f, 
    -0.03855723f, -0.05213129f, 0.02140543f, 0.05332565f, 0.02120226f, 0.05094183f, -0.05041884f, -0.01355912f, 
    0.05398237f, -0.05007594f, 0.02506709f, 0.01130812f, -0.04769804f, -0.05547615f, 0.00120065f, -0.03028078f, 
    0.00069475f, -0.06220662f, 0.02889001f, -0.06344251f, -0.02011351f, -0.05798383f, -0.03584503f, -0.00463417f, 
    0.04776286f, 0.00146591f, -0.03018725f, 0.02300962f, -0.00765375f, -0.05822687f, 0.00636646f, 0.01310416f, 
    0.00132171f, -0.01462514f, 0.00020583f, -0.04075963f, -0.02025124f, 0.00922170f, 0.04085680f, -0.04305503f, 
    0.01198138f, -0.06016637f, 0.03297170f, -0.02144360f, 0.04379975f, 0.02214510f, 0.00701039f, 0.00186547f, 
    0.02743299f, 0.03410184f, -0.06016636f, 0.02240649f, -0.03203297f, -0.02170685f, 0.00498056f, 0.02584617f, 
    0.02157094f, -0.05701092f, 0.03700405f, 0.04827560f, 0.03141412f, -0.05078322f, -0.03952898f, 0.03508363f, 
    -0.05234131f, 0.02803544f, 0.01715570f, -0.03008199f, 0.00263436f, -0.02605587f, 0.03366209f, -0.02372066f, 
    -0.05359514f, 0.00238255f, 0.04200251f, -0.02775816f, -0.05304024f, -0.00090295f, -0.01313483f, -0.04415308f, 
    -0.05321835f, -0.04717048f, -0.04006160f, -0.03266731f, -0.00001130f, -0.05866608f, 0.05090958f, -0.04594695f, 
    -0.05576387f, -0.04427150f, -0.05505535f, -0.03520069f, -0.00935885f, 0.03500870f, 0.00522033f, -0.05626747f, 
    0.00677193f, -0.05653214f, -0.01800633f, -0.03995866f, 0.01695253f, -0.02605606f, -0.01541079f, 0.00386224f, 
    0.02071376f, 0.04754659f, -0.04072668f, 0.03487598f, -0.04897338f, -0.02982508f, -0.01914176f, -0.00130264f, 
    0.04031809f, -0.00903479f, -0.00539671f, -0.04668265f, -0.00912300f, 0.04817974f, -0.01689061f, -0.00855177f, 
    0.03489626f, -0.03293624f, -0.04868125f, -0.00990747f, 0.01032938f, -0.02009862f, -0.02970579f, 0.00593614f, 
    0.00757658f, -0.05304188f, -0.04940610f, -0.05319405f, 0.02430201f, -0.00908713f, -0.01427047f, 0.01407760f, 
    -0.03504881f, -0.04695734f, 0.04872813f, -0.01592412f, 0.00240815f, 0.03916608f, -0.03372667f, 0.02849391f, 
    0.00417542f, 0.02646699f, 0.02973945f, -0.00963527f, 0.03393454f, 0.03681804f, 0.03995286f, -0.05460218f, 
    0.04002299f, -0.00841676f, -0.04176041f, 0.01870139f, -0.02918207f, -0.01690292f, -0.04036028f, -0.03340184f, 
    0.00032864f, -0.03555840f, 0.03258804f, 0.00532725f, 0.04147585f, 0.04632556f, -0.06119433f, -0.05364073f, 
    -0.06539354f, 0.00384632f, -0.01334683f, -0.00426993f, -0.00347345f, 0.05089860f, 0.05250377f, 0.00979353f, 
    0.02946907f, 0.01057110f, 0.05254490f, -0.01506123f, -0.04877109f, -0.06027755f, -0.05942269f, -0.02156044f, 
    0.01791481f, -0.04540247f, 0.04367052f, 0.05556829f, 0.02742230f, 0.04088510f, 0.04177055f, -0.00874175f, 
    0.03160349f, -0.00911043f, 0.00779774f, -0.03015931f, -0.03602513f, -0.05604023f, -0.01893869f, -0.00529669f, 
    -0.13509093f, -0.07313658f, -0.22122499f, 0.01654665f, -0.01431567f, -0.06378102f, 0.11581153f, -0.21296236f, 
    -0.06610662f, -0.05067518f, 0.11326474f, 0.11991571f, 0.09371328f, 0.14172077f, -0.00518934f, 0.13293660f, 
    0.16671279f, -0.06684782f, 0.13784710f, 0.28833935f, 0.15624757f, 0.07371289f, 0.06322429f, 0.18696637f, 
    -0.04318763f, 0.32383496f, -0.07956874f, 0.15473625f, 0.11758652f, 0.20249426f, 0.01981230f, 0.17673974f, 
    0.09907925f, 0.01089275f, -0.06474911f, -0.14677244f, -0.06340113f, 0.09275441f, 0.21539856f, 0.15480267f, 
    0.11660683f, 0.01760878f, -0.00718565f, -0.02178426f, -0.21398500f, -0.42621067f, -0.41447333f, -0.17403647f, 
    -0.08988585f, 0.04494272f, -0.15766591f, 0.15954669f, -0.34671399f, -0.09013651f, -0.32096693f, -0.32004371f, 
    0.22999273f, -0.09562657f, 0.10764816f, 0.02278881f, -0.13128108f, -0.03794275f, 0.04921242f, 0.58070892f, 
    -0.00239907f, -0.01564640f, -0.17951430f, -0.04611779f, -0.15408427f, 0.05621151f, 0.06721759f, -0.04588215f, 
    0.21430193f, -0.15437208f, -0.23936999f, 0.11972278f, 0.00257880f, 0.12450849f, 0.18692990f, 0.28295189f, 
    -0.02988956f, -0.20489970f, -0.14915870f, -0.42427179f, -0.21976125f, -0.01125420f, 0.01317762f, -0.04303998f, 
    0.06818381f, 0.04089755f, -0.03558823f, -0.21665585f, -0.26363558f, 0.13007690f, 0.14979626f, -0.08933550f, 
    0.00131989f, 0.41636622f, 0.34500319f, -0.10605552f, 0.12328596f, 0.04190810f, -0.23217405f, 0.12087018f, 
    -0.17629834f, -0.09785525f, 0.12438846f, -0.19098392f, -0.51410693f, -0.07065038f, -0.07115710f, -0.09926755f, 
    0.04287457f, 0.10607035f, 0.04572880f, -0.01063785f, -0.13763021f, -0.22519679f, 0.21437933f, -0.16510397f, 
    -0.11421154f, 0.00969238f, 0.13552792f, 0.31181067f, -0.05800189f, -0.01084870f, -0.28399938f, -0.28336939f, 
    -0.13622466f, 0.10793784f, -0.08057664f, -0.13945650f, 0.29276371f, 0.10460707f, 0.01091070f, -0.31327000f, 
    -0.40110472f, -0.00281318f, -0.13784927f, 0.05462743f, -0.21674167f, 0.31263065f, -0.18331282f, -0.05844535f, 
    -0.42083523f, 0.39931276f, -0.14878684f, -0.23383529f, 0.16344611f, 0.01443782f, 0.11405146f, -0.11677837f, 
    -0.06882516f, 0.21572150f, 0.08326954f, 0.03019556f, -0.14775363f, -0.11723415f, 0.17498682f, -0.15155095f, 
    -0.04038235f, 0.33751950f, -0.09879782f, 0.19889525f, -0.04752227f, -0.04344177f, 0.12785032f, 0.22137581f, 
    -0.00625447f, 0.04790774f, -0.03569177f, -0.31818637f, 0.21582963f, 0.09339133f, -0.20077720f, 0.14028932f, 
    -0.03067679f, 0.16669038f, 0.01958912f, -0.03710896f, -0.03094878f, 0.05019958f, -0.21778974f, 0.09674887f, 
    0.01819349f, 0.13269597f, -0.06797355f, 0.00746503f, -0.00855390f, -0.22964448f, -0.05662670f, -0.20144719f, 
    0.07035509f, 0.03645302f, -0.01524208f, 0.19423133f, -0.24461529f, -0.00195044f, 0.02538805f, -0.40307048f, 
    -0.41577840f, -0.06213256f, 0.19072801f, 0.20103398f, 0.06838936f, 0.02739118f, -0.17168753f, 0.05194159f, 
    -0.28026992f, -0.61485130f, 0.07668117f, 0.00572816f, 0.25825530f, -0.28490680f, -0.13087209f, -0.37719244f, 
    0.23251881f, 0.04243805f, 0.13491395f, 0.08967920f, -0.09814710f, 0.12827653f, 0.22943033f, 0.05336709f, 
    0.11441953f, -0.39186481f, -0.20214814f, -0.08541270f, 0.17961143f, -0.09721219f, 0.16653010f, 0.10127971f, 
    -0.24654530f, -0.20260620f, -0.01510554f, 0.15567544f, -0.13764299f, -0.02239756f, -0.15398303f, 0.01533606f, 
    0.04273804f, -0.17277072f, -0.30886418f, 0.25124276f, 0.06160400f, 0.26155663f, 0.05232573f, 0.03503468f, 
    0.05509114f, 0.07901181f, -0.15298164f, -0.10198470f, -0.16692841f, -0.19932383f, -0.27860701f, -0.01610798f, 
    -0.08845913f, -0.08354691f, -0.04592257f, 0.10917731f, 0.20899056f, 0.16174658f, 0.15772533f, 0.10191973f, 
    0.03121819f, 0.16698717f, 0.16459329f, -0.25361526f, -0.01114634f, 0.07450210f, 0.13610853f, -0.19218791f, 
    0.11486655f, -0.10401507f, -0.08214078f, -0.03594816f, 0.16621113f, -0.04015190f, -0.24513328f, 0.24167301f, 
    0.22148563f, 0.18215710f, 0.14814419f, 0.15071890f, 0.22550727f, 0.02551189f, -0.10337117f, 0.02813726f, 
    0.01093063f, -0.07605527f, -0.02383996f, -0.07048231f, 0.01162902f, 0.00909551f, -0.02472483f, 0.05914347f, 
    -0.05982206f, -0.03371562f, 0.02057508f, -0.02552309f, -0.02595152f, -0.07406176f, -0.01862186f, 0.00291159f, 
    -0.02305842f, -0.04558269f, 0.02639614f, 0.04303045f, 0.04361676f, 0.02946590f, -0.00468840f, -0.03597751f, 
    -0.05611587f, 0.00661450f, 0.00977222f, 0.02772854f, 0.03175575f, 0.02445637f, 0.01098338f, -0.01824723f, 
    -0.06655855f, -0.02606804f, 0.00278699f, 0.02965629f, -0.07568376f, -0.04006852f, -0.06045434f, -0.02009333f, 
    -0.01536234f, -0.04673860f, -0.01159283f, -0.01912374f, -0.04674581f, 0.02388689f, -0.06243578f, -0.00207373f, 
    -0.05114027f, -0.02844057f, -0.00994158f, -0.02079792f, -0.02969428f, 0.03010172f, -0.01865053f, -0.00980602f, 
    -0.05005584f, 0.01094244f, 0.00157172f, -0.04149260f, 0.00221534f, 0.02118258f, 0.02205007f, 0.02162203f, 
    -0.03921395f, 0.01366625f, -0.00865877f, -0.01353077f, 0.00768955f, -0.03814982f, 0.02690655f, 0.00593520f, 
    0.02511603f, 0.02681642f, -0.07243720f, 0.00500157f, -0.00573063f, -0.00424647f, -0.05237623f, -0.03031135f, 
    -0.02405961f, -0.06043987f, 0.00985252f, 0.02943579f, 0.00445566f, -0.01263396f, -0.06418689f, 0.04007444f, 
    0.01087655f, 0.03168066f, -0.00513957f, 0.00945920f, 0.03746599f, -0.03699411f, 0.00101825f, 0.00432530f, 
    0.00733015f, -0.05102951f, 0.03814061f, -0.00601735f, -0.00439744f, -0.05180947f, 0.02972933f, 0.04339556f, 
    -0.06682263f, -0.03373949f, -0.03121206f, -0.06377176f, -0.04847768f, 0.01448611f, -0.02918453f, -0.01969252f, 
    0.04161373f, 0.00938262f, -0.06404305f, 0.05048188f, 0.03442166f, 0.03578134f, 0.06649044f, -0.03032462f, 
    0.03712332f, -0.01705931f, -0.00768367f, -0.02875415f, -0.01117599f, -0.01764747f, -0.03396961f, -0.00646116f, 
    -0.04993190f, -0.01499875f, -0.02846530f, -0.04130104f, 0.05634220f, -0.07606581f, -0.03329127f, -0.03132003f, 
    0.02652181f, 0.02115321f, 0.04295721f, -0.05807421f, -0.01694547f, -0.00687676f, -0.01998481f, 0.03403044f, 
    0.00836243f, -0.04541441f, 0.05203364f, -0.01913681f, 0.02355139f, -0.06860851f, 0.01145639f, -0.00589503f, 
    -0.05463773f, -0.06905762f, 0.03103950f, 0.00826138f, 0.00661665f, 0.03439306f, -0.08218235f, 0.02603481f, 
    -0.04181455f, -0.05618376f, 0.04419314f, 0.03390668f, 0.03275942f, 0.05476390f, -0.07257264f, -0.02414851f, 
    -0.05550952f, -0.02487436f, -0.05532864f, -0.01285792f, 0.03025387f, -0.02844129f, -0.02638373f, 0.02978763f, 
    -0.01151586f, -0.05250583f, 0.03095473f, -0.04916007f, 0.02314557f, 0.05909212f, -0.03156473f, 0.02597263f, 
    -0.05293098f, -0.05023251f, 0.02250411f, 0.04252130f, 0.00704801f, 0.03251300f, 0.01342316f, -0.06276578f, 
    -0.04788703f, -0.03952375f, -0.07005371f, -0.05493217f, 0.00442940f, 0.01863811f, -0.03413487f, 0.00549682f, 
    -0.03506741f, -0.01274423f, -0.06715821f, -0.07233248f, 0.00440022f, 0.03646058f, 0.00452237f, 0.04008438f, 
    0.04328990f, 0.05298332f, 0.01748626f, 0.02248918f, -0.00388062f, -0.01020624f, -0.02417371f, -0.04472395f, 
    0.02713905f, 0.01806979f, 0.00280329f, -0.07374322f, -0.06999100f, -0.04212066f, -0.05791471f, -0.02959996f, 
    0.03677566f, -0.07191421f, -0.01656552f, -0.03378838f, -0.05876364f, 0.03274881f, 0.05126779f, 0.05609486f, 
    0.04620150f, 0.02034100f, -0.01779477f, 0.01548881f, -0.02075783f, -0.01187815f, -0.05883227f, -0.01042349f, 
    -0.01743690f, 0.02440659f, -0.02216793f, -0.02991272f, 0.00859220f, -0.04930182f, -0.01241921f, -0.02145623f, 
    -0.03047887f, -0.00950628f, -0.06168306f, 0.02078942f, -0.01606471f, 0.04531987f, 0.03386316f, 0.04380479f, 
    0.02732464f, -0.00584465f, 0.03808033f, -0.06023836f, -0.05660275f, -0.04314011f, -0.03932466f, -0.06044837f, 
    0.01829650f, 0.02200892f, 0.01216478f, 0.02798437f, -0.00124181f, -0.07026372f, -0.05563587f, -0.06706532f, 
    -0.00454222f, 0.02149798f, -0.02518908f, -0.07023934f, 0.02718168f, 0.01863264f, 0.01359552f, 0.04368664f, 
    0.00853534f, 0.03347074f, -0.03556130f, -0.05054183f, -0.04963493f, -0.01414586f, -0.06621236f, 0.01309270f, 
    0.06464015f, 0.01621583f, 0.22051604f, -0.01001418f, -0.07823277f, -0.24393694f, -0.13716859f, 0.02938371f, 
    0.18455182f, -0.10300341f, 0.22270589f, 0.08011572f, 0.10650431f, -0.01885279f, 0.20081423f, 0.09872105f, 
    0.00690502f, 0.01238742f, 0.10149907f, 0.08278193f, -0.09585842f, 0.17224641f, 0.10131970f, 0.08554728f, 
    -0.00612008f, 0.03948532f, 0.00310318f, 0.14106387f, 0.06606327f, 0.06882699f, 0.19319247f, -0.08512245f, 
    -0.03788096f, -0.27685201f, -0.01378859f, 0.28410470f, -0.14366089f, 0.06313609f, -0.02101271f, 0.10986079f, 
    0.04074863f, 0.01481094f, -0.00359422f, 0.19019370f, -0.11422051f, 0.47721320f, 0.04027313f, 0.25746959f, 
    0.06438840f, -0.30097923f, -0.06962358f, 0.17394808f, 0.06168507f, 0.09781965f, -0.16892506f, 0.00654189f, 
    -0.37451091f, 0.12936267f, -0.12613826f, -0.12574890f, 0.08742061f, 0.02895770f, -0.10774235f, -0.24509934f, 
    -0.39245060f, -0.48137602f, 0.17073962f, 0.07406807f, 0.16062857f, -0.17973267f, -0.17764989f, -0.09176143f, 
    -0.06629580f, 0.09299487f, -0.03203713f, 0.10037136f, 0.11101507f, -0.21182795f, 0.32437944f, 0.03030055f, 
    -0.15977268f, -0.23256207f, -0.68958092f, 0.30771580f, -0.00536619f, -0.10219279f, -0.00592557f, 0.12425740f, 
    -0.03274543f, 0.31786022f, -0.11019471f, -0.30677024f, -0.27551052f, 0.22394115f, 0.11447319f, 0.14470990f, 
    -0.00859675f, -0.09202751f, 0.05391107f, 0.04959857f, 0.16690882f, -0.11370730f, 0.02463133f, -0.17316025f, 
    -0.19001807f, -0.04687431f, -0.10904399f, 0.38131669f, 0.07099273f, 0.41287589f, -0.08735826f, 0.05699025f, 
    0.07459985f, -0.11877988f, -0.02020276f, -0.21055217f, 0.12501428f, -0.04494203f, 0.15538748f, -0.08583665f, 
    0.08115888f, 0.03157498f, 0.36000925f, 0.13065650f, 0.05135712f, 0.19282821f, -0.06774163f, 0.15630525f, 
    0.42752326f, -0.05485820f, -0.07408983f, -0.00923938f, -0.11292501f, 0.18673621f, -0.02412706f, -0.42956460f, 
    0.06917461f, -0.09614705f, -0.09553873f, 0.04212154f, -0.01528386f, -0.24802703f, 0.17418244f, -0.19340745f, 
    -0.15027800f, -0.06908111f, -0.09453753f, 0.23215201f, -0.12017698f, -0.03934336f, 0.04589109f, -0.10856810f, 
    0.31087372f, -0.32871252f, -0.54681426f, -0.01210968f, -0.02709436f, 0.04178995f, 0.10014972f, -0.15439376f, 
    0.04938903f, -0.03789760f, 0.05860539f, -0.16562454f, 0.04551553f, 0.14708824f, 0.02333618f, 0.12726638f, 
    -0.17521988f, 0.00298855f, 0.10191094f, 0.06115448f, -0.29511532f, -0.17795952f, -0.13162881f, 0.03098415f, 
    0.05004324f, -0.19114350f, 0.03170756f, -0.17424388f, -0.08917821f, 0.13372013f, 0.19341014f, 0.11302269f, 
    -0.10523880f, 0.23564260f, -0.03781742f, 0.00982887f, -0.08872870f, -0.19252604f, -0.18283175f, -0.03394061f, 
    0.01043158f, -0.00631798f, -0.24784707f, 0.19001073f, -0.29024354f, -0.04726083f, -0.17789510f, 0.32806736f, 
    0.03297406f, 0.24501573f, -0.16766870f, -0.13157210f, 0.11776870f, 0.04714830f, -0.01930989f, 0.25064340f, 
    -0.16328707f, 0.23354468f, 0.04730653f, -0.09083202f, 0.06590514f, 0.02694301f, -0.18194711f, -0.17828269f, 
    -0.21967137f, -0.03701724f, -0.10977019f, 0.18202917f, 0.08457218f, -0.04915341f, -0.10568413f, 0.05237515f, 
    0.02184033f, -0.15631002f, -0.22877884f, 0.24815933f, -0.15925208f, -0.06565347f, 0.07657972f, 0.09652831f, 
    0.23764305f, 0.16242364f, 0.16115038f, -0.02940450f, -0.07202973f, -0.20131004f, -0.03614420f, -0.24982417f, 
    0.14214671f, -0.09235226f, -0.13374974f, 0.15969703f, 0.20063454f, 0.04734665f, 0.10674193f, -0.17966050f, 
    -0.10196707f, 0.16059010f, -0.01386635f, 0.22194238f, -0.71575993f, 0.16434549f, -0.03851920f, 0.14512184f, 
    -0.11851410f, -0.10610176f, -0.00643250f, -0.03357061f, -0.02656815f, -0.36935651f, -0.20086871f, -0.19973610f, 
    0.05596185f, 0.07431673f, 0.12668283f, 0.09612773f, -0.06270506f, 0.08632604f, -0.27529931f, -0.01587652f, 
    -0.03068946f, 0.04356213f, 0.00693857f, -0.13563852f, 0.12164587f, 0.18771851f, 0.06232315f, -0.01124984f, 
    -0.17034443f, 0.08543485f, 0.03976991f, 0.20158125f, 0.10703955f, 0.13736145f, 0.06846315f, 0.29220885f, 
    0.43784675f, -0.37667203f, 0.05777018f, 0.07969589f, 0.23930797f, 0.28722432f, -0.16713959f, -0.28654370f, 
    -0.39158982f, -0.03447859f, -0.08429810f, 0.13383357f, -0.05116923f, 0.01324073f, -0.02561354f, 0.15607922f, 
    0.02641760f, -0.04382058f, -0.00955354f, -0.05940685f, 0.13562386f, 0.05496392f, 0.12714450f, -0.03423308f, 
    0.05030697f, 0.10060132f, 0.18138230f, -0.08079378f, 0.23156330f, 0.28670004f, 0.02466094f, -0.01922848f, 
    -0.09014800f, -0.03859597f, 0.04910470f, -0.20105012f, -0.06193791f, 0.25224489f, 0.37380782f, 0.20756602f, 
    0.08642435f, 0.05589601f, 0.25343496f, 0.12398358f, -0.05961917f, -0.23481135f, -0.30881509f, -0.15011285f, 
    0.30509263f, 0.02009803f, 0.31236300f, -0.20664692f, 0.07270730f, -0.24793099f, 0.02908565f, 0.12827626f, 
    0.36419147f, 0.09919050f, -0.05155205f, -0.14145008f, -0.02207546f, -0.05832357f, 0.09460548f, 0.27674711f, 
    0.18042383f, 0.09185380f, 0.26225755f, -0.21912360f, -0.09524705f, 0.14608850f, -0.10380968f, -0.11040613f, 
    -0.06460045f, -0.07946488f, -0.15925260f, -0.08276752f, 0.04075155f, 0.08125983f, -0.03267531f, 0.06068715f, 
    0.18422531f, -0.13559175f, -0.38799930f, -0.32258308f, 0.35061690f, 0.03893574f, 0.00678498f, 0.23916745f, 
    -0.04311812f, -0.38700810f, -0.09945297f, -0.03361467f, -0.09187886f, 0.31507355f, 0.02305515f, -0.07672906f, 
    -0.24797358f, 0.08156663f, 0.12571310f, -0.19517608f, 0.10340393f, 0.11362100f, -0.26444224f, 0.06381979f, 
    0.10506565f, -0.10997929f, -0.13810404f, -0.23998918f, 0.62866044f, -0.06628467f, -0.22113748f, -0.14952120f, 
    -0.26033282f, 0.07647004f, -0.15729077f, 0.00337773f, 0.10733879f, -0.03154299f, -0.03142103f, -0.26656249f, 
    -0.19729413f, -0.02271623f, -0.14385130f, 0.09710073f, 0.15476683f, 0.08339355f, 0.09389898f, -0.10950965f, 
    -0.08043342f, 0.19250603f, 0.09145132f, -0.04146410f, -0.02081234f, 0.10854311f, 0.27256334f, -0.15756191f, 
    0.02074629f, 0.24241531f, 0.20756739f, -0.13943286f, -0.06884196f, -0.06574475f, 0.01831315f, 0.12636644f, 
    -0.14630787f, 0.14843091f, 0.16326667f, 0.15311076f, -0.02177268f, 0.07437325f, -0.07766169f, -0.06452049f, 
    0.11243612f, 0.31486872f, 0.08954850f, -0.07471224f, -0.24865673f, -0.21459207f, -0.23884140f, -0.04404008f, 
    0.16818398f, 0.20213044f, -0.00665743f, 0.05455778f, 0.32685429f, -0.14875917f, -0.00338902f, -0.11382409f, 
    0.31443548f, 0.08571951f, 0.19941011f, 0.21729830f, 0.20443691f, 0.17982520f, -0.19652645f, 0.03312338f, 
    -0.02320787f, 0.09486849f, 0.28057438f, 0.03519705f, 0.00625011f, 0.14716414f, -0.02518724f, 0.33950835f, 
    0.24166596f, -0.12934041f, 0.25134632f, 0.06257104f, 0.39888045f, 0.04846380f, -0.14370281f, -0.05713518f, 
    -0.06275865f, 0.10630707f, 0.16331407f, 0.04349926f, -0.07659824f, -0.01579502f, 0.18085814f, -0.02198452f, 
    0.01186174f, 0.05038303f, 0.04487240f, -0.01052632f, -0.01125513f, -0.12381606f, 0.23072964f, -0.34475502f, 
    -0.11117193f, -0.23609346f, 0.01431031f, -0.04857627f, -0.07825436f, -0.04866033f, -0.05024052f, 0.39628506f, 
    0.25171602f, 0.08111365f, 0.08800292f, 0.03528333f, -0.14725210f, -0.11941534f, 0.28744543f, 0.06225093f, 
    -0.05714651f, -0.29666957f, -0.12187353f, -0.35151404f, 0.36515066f, 0.12461735f, 0.04651748f, -0.12428989f, 
    -0.04191184f, -0.11820291f, -0.23663686f, 0.11493842f, -0.34711820f, -0.01263384f, 0.17316908f, 0.19504930f, 
    -0.13828646f, 0.18224244f, 0.26015273f, -0.38450477f, 0.15388340f, 0.04081718f, 0.15451278f, 0.17128187f, 
    0.28362530f, -0.03037421f, 0.03964968f, -0.06207319f, 0.16913663f, -0.05897788f, -0.17517093f, 0.18091153f, 
    -0.04061562f, -0.03820446f, -0.11016515f, 0.21860595f, 0.25973800f, -0.07434825f, 0.16319175f, 0.03408239f, 
    -0.21576376f, -0.15999353f, -0.03308859f, -0.07355387f, 0.01579360f, -0.00426998f, -0.18851298f, -0.45778835f, 
    0.25362751f, 0.07903252f, -0.07539634f, -0.05591316f, -0.18611544f, -0.14505507f, -0.12831192f, 0.06329536f, 
    0.13983026f, 0.34767610f, 0.12710178f, 0.03041299f, 0.10283680f, -0.02826236f, -0.07669498f, -0.15077342f, 
    0.03616762f, -0.04457706f, 0.05332651f, -0.04937762f, 0.00341079f, 0.01979305f, 0.00703467f, 0.00995224f, 
    -0.05244264f, -0.00706274f, 0.00358284f, -0.02585553f, 0.02637459f, -0.02617057f, -0.06600773f, 0.01630018f, 
    0.01202247f, -0.03872782f, 0.03385884f, -0.01960047f, 0.05001783f, 0.00598123f, 0.01812674f, -0.00305905f, 
    -0.01919884f, -0.00773943f, -0.02159355f, 0.03540323f, -0.03843212f, 0.04548749f, -0.00683480f, 0.00136586f, 
    -0.01385699f, -0.06039356f, -0.02764035f, 0.01467981f, -0.06098178f, -0.04309866f, -0.02343643f, -0.05251563f, 
    -0.01857253f, -0.06607109f, -0.04048003f, -0.02965965f, -0.04573525f, -0.02378378f, -0.05076218f, -0.02863197f, 
    -0.05296746f, -0.02167895f, -0.04811239f, 0.04977801f, -0.02873472f, 0.04918711f, -0.01576439f, 0.00090693f, 
    0.02353097f, 0.00378001f, 0.00221605f, 0.00634904f, -0.05562518f, -0.05753379f, -0.05871663f, 0.00832898f, 
    -0.03758476f, 0.00904917f, -0.04693055f, -0.03552060f, 0.05238241f, -0.06366733f, 0.04252785f, -0.04191497f, 
    -0.05228307f, -0.00947948f, -0.04761828f, -0.02442905f, -0.04923709f, -0.03222756f, -0.03362336f, -0.01645761f, 
    -0.00483951f, -0.03566546f, -0.01713697f, -0.03417433f, -0.04368255f, -0.04712496f, -0.04294325f, -0.06148698f, 
    -0.04813724f, 0.00901606f, 0.03217905f, -0.04068145f, -0.05691151f, -0.02252172f, 0.03981327f, -0.05890100f, 
    0.00341102f, -0.05847679f, 0.05984208f, -0.03526279f, -0.05738211f, -0.01504174f, 0.02081561f, -0.00566283f, 
    -0.02344714f, 0.05215896f, -0.05902924f, 0.03544739f, -0.04991692f, -0.03228717f, 0.04205597f, -0.03178948f, 
    -0.04271197f, 0.05737137f, 0.01650903f, -0.04513863f, -0.01057001f, -0.04238444f, -0.03092151f, -0.01975464f, 
    -0.00165946f, 0.03266765f, -0.04718330f, 0.05416413f, 0.04008478f, 0.00691507f, -0.00433167f, -0.02274464f, 
    -0.02215610f, -0.01746411f, 0.04721533f, -0.00492063f, 0.03982724f, 0.02928435f, -0.04275981f, 0.02777292f, 
    0.04985648f, 0.00739462f, -0.02476195f, 0.04334633f, 0.01264187f, -0.06026535f, 0.03179912f, -0.01741086f, 
    -0.06311750f, -0.04446645f, 0.03111568f, -0.00455278f, 0.05094043f, -0.03081203f, -0.02155235f, 0.04124109f, 
    -0.02229078f, -0.02852101f, -0.01936299f, 0.04453505f, 0.01428037f, -0.01891205f, 0.01424766f, -0.01969267f, 
    -0.01996406f, 0.02980902f, 0.00270707f, 0.03974957f, 0.04879126f, -0.00696621f, 0.04623657f, 0.03838911f, 
    -0.01830678f, -0.04433379f, -0.01646645f, -0.02414028f, -0.04961321f, -0.02877296f, -0.04806539f, -0.04550420f, 
    -0.03386860f, -0.05488354f, -0.01719549f, -0.03389000f, 0.03154323f, 0.06247254f, -0.02729729f, -0.02160520f, 
    -0.01026956f, 0.04319251f, 0.05508962f, 0.00606041f, 0.00954353f, -0.02162125f, -0.01700391f, 0.04753172f, 
    -0.02640476f, -0.04626959f, 0.04560794f, 0.00236995f, -0.00131048f, 0.02987076f, 0.02973975f, -0.03332235f, 
    -0.01907765f, 0.02271383f, -0.05541777f, 0.00702250f, -0.00109810f, 0.00701128f, -0.04689780f, 0.01397614f, 
    -0.04231886f, 0.04760282f, 0.02655500f, 0.04876117f, 0.03221885f, -0.06037347f, -0.04492411f, -0.04467307f, 
    -0.06359513f, -0.02647174f, -0.05365969f, 0.05028145f, 0.02830814f, -0.01941264f, -0.04684065f, 0.04939145f, 
    0.02997760f, -0.01140629f, 0.00037662f, 0.03672373f, -0.03474384f, -0.02126778f, 0.02902983f, -0.03256864f, 
    -0.01932022f, -0.05846750f, -0.04009664f, -0.03512145f, 0.02022442f, 0.05292661f, 0.04759595f, 0.03237734f, 
    -0.01486094f, 0.02542249f, -0.06124042f, 0.01381367f, -0.00058192f, -0.02056439f, -0.00787764f, -0.05635325f, 
    0.02528549f, -0.05381324f, 0.05074769f, 0.04066056f, 0.04010215f, 0.00540029f, -0.03329173f, -0.03011142f, 
    0.01489454f, 0.01654985f, -0.03722958f, 0.01804885f, 0.01207771f, 0.00988577f, 0.00172578f, -0.03976315f, 
    -0.02987447f, -0.03228722f, 0.01691143f, 0.05306409f, 0.04222286f, -0.03051842f, -0.03945487f, 0.04531705f, 
    -0.02590925f, -0.02117867f, -0.03585156f, -0.02367218f, 0.04582768f, -0.05121997f, -0.03970822f, -0.02402752f, 
    -0.01242182f, -0.05854928f, 0.01930067f, 0.03352292f, -0.02651052f, -0.05611785f, 0.02681404f, -0.04216813f, 
    -0.03111284f, -0.01870684f, -0.02391918f, -0.01529690f, 0.00925835f, -0.02266617f, 0.03789811f, 0.00448490f, 
    0.03208243f, 0.03089767f, 0.01126809f, 0.01365811f, 0.02350367f, -0.00554226f, -0.05263976f, 0.04985664f, 
    -0.04911271f, 0.03754690f, -0.01612788f, -0.00822272f, 0.00207017f, 0.03379487f, -0.02298129f, -0.03394482f, 
    -0.03659451f, -0.05695796f, -0.03438362f, -0.04069024f, 0.01237689f, -0.00555817f, 0.03915506f, 0.04778343f, 
    -0.04153147f, -0.04726978f, -0.02272926f, -0.06455746f, 0.02550480f, 0.01836283f, -0.05536536f, -0.04976054f, 
    0.02659321f, 0.03105849f, 0.04013224f, 0.04440008f, 0.02727396f, -0.05546801f, -0.04966528f, -0.05575023f, 
    0.00036273f, 0.03343298f, -0.05684794f, -0.01107918f, -0.01962203f, 0.04555637f, -0.01083581f, 0.01479570f, 
    -0.04700965f, -0.03893830f, -0.05909789f, -0.06686299f, -0.01238452f, -0.01626914f, 0.01190183f, 0.01264631f, 
    0.01583393f, -0.03224738f, 0.03025004f, 0.02796325f, -0.05846676f, -0.01339766f, -0.05329970f, -0.02260248f, 
    0.01500058f, -0.00903234f, 0.02211557f, 0.03478854f, 0.03254311f, 0.01271537f, -0.05143346f, 0.00704636f, 
    0.00251166f, 0.03140559f, 0.04835986f, 0.03865561f, 0.03215952f, -0.05584000f, 0.02806297f, 0.00772066f, 
    0.00708278f, 0.02261201f, 0.01939071f, -0.02937757f, -0.01159104f, 0.04557701f, -0.04127117f, -0.05390956f, 
    -0.06305482f, 0.01762467f, -0.02120309f, -0.05381985f, 0.00077986f, 0.02489758f, -0.06489673f, -0.00197817f, 
    0.03203238f, -0.06353240f, 0.01711434f, -0.03964011f, 0.04270082f, -0.04770264f, 0.02883395f, 0.02115224f, 
    0.05356926f, -0.02621683f, -0.02222538f, 0.04344815f, 0.01165687f, 0.03991392f, -0.02941849f, -0.00935056f, 
    -0.05937451f, 0.04024407f, 0.01049826f, -0.05885760f, -0.00754497f, -0.04373392f, 0.02054575f, 0.02963217f, 
    -0.00575222f, -0.00030577f, -0.04910048f, -0.04299058f, 0.00846113f, -0.04808889f, -0.05009411f, -0.02117462f, 
    0.04075484f, 0.02205924f, -0.00773181f, -0.02646769f, -0.02448681f, -0.03570658f, 0.01661013f, 0.03342251f, 
    -0.06155304f, 0.00173781f, 0.04392249f, 0.01920364f, -0.05769199f, -0.06433231f, 0.03456442f, 0.05410606f, 
    -0.05461945f, 0.01225155f, -0.01879903f, 0.00481893f, 0.03901120f, 0.00635363f, 0.01626952f, 0.01987429f, 
    -0.01642379f, -0.01904306f, -0.00880207f, 0.02466357f, 0.01895778f, 0.00919657f, 0.04425971f, -0.02416800f, 
    -0.01803547f, -0.00326383f, 0.04452714f, -0.01145028f, 0.01618956f, 0.02313087f, -0.03913870f, -0.05655779f, 
    0.01355553f, -0.00560288f, -0.03279589f, 0.03840696f, -0.04911106f, -0.05378333f, 0.05426634f, -0.06115040f, 
    -0.01327309f, 0.03262357f, -0.04300530f, -0.01794576f, -0.01695476f, -0.01231537f, -0.05227433f, -0.04302434f, 
    -0.00944278f, 0.03583701f, 0.05420997f, -0.00411957f, -0.02714727f, -0.05545827f, -0.02423278f, -0.00779192f, 
    -0.03258620f, -0.04105516f, 0.02421260f, -0.00220558f, -0.02907136f, -0.02861351f, -0.05775540f, 0.00684734f, 
    -0.01905895f, -0.01370036f, -0.00360570f, -0.06264942f, -0.04847879f, -0.03837187f, 0.00834149f, -0.04427983f, 
    -0.03080897f, 0.00733644f, -0.02862379f, -0.03827164f, 0.05010188f, -0.04611435f, 0.00791960f, 0.02337779f, 
    0.03924962f, 0.04730164f, -0.06661933f, -0.01728732f, 0.03693919f, -0.00949759f, -0.02825487f, 0.00424136f, 
    -0.05373725f, 0.00619026f, -0.03678320f, 0.02301569f, 0.01080646f, -0.05459745f, 0.03166762f, -0.03113159f, 
    -0.00906659f, -0.04933613f, 0.03326882f, 0.02165517f, 0.03496916f, 0.01986186f, -0.01580675f, 0.04275773f, 
    -0.03612183f, 0.00941269f, 0.00498472f, 0.01011996f, 0.04372442f, -0.05951900f, 0.03478850f, 0.04838276f, 
    -0.04079100f, -0.00245956f, -0.02089100f, -0.01363482f, -0.00734277f, -0.00372622f, -0.04897373f, 0.04116715f, 
    -0.06734510f, -0.02587252f, -0.05926455f, -0.06273442f, -0.04310371f, 0.05316901f, 0.04779366f, -0.05360100f, 
    0.01911298f, -0.02084380f, -0.05546511f, -0.02194300f, -0.02240280f, -0.02962972f, -0.04449113f, -0.02796785f, 
    0.01118511f, 0.03645267f, -0.01502851f, -0.05036530f, 0.04081422f, 0.02541367f, -0.04448286f, 0.05148989f, 
    0.03979812f, 0.01944618f, -0.06063328f, 0.02870826f, 0.04840954f, 0.00008511f, 0.04094967f, 0.04775073f, 
    0.02238955f, -0.03939047f, -0.06286900f, 0.03282994f, -0.06341639f, 0.04791965f, 0.01556530f, -0.02946212f, 
    0.00739379f, -0.03809690f, -0.05086735f, -0.05981865f, 0.05016442f, 0.03766542f, -0.00036200f, 0.01690170f, 
    -0.00128737f, 0.02369301f, 0.04175614f, -0.01246650f, -0.01735529f, -0.00279910f, -0.01468825f, -0.02773976f, 
    -0.00586660f, -0.05682285f, 0.00475273f, 0.02952256f, 0.00623363f, 0.01559179f, -0.01857957f, 0.01128765f, 
    -0.01613854f, 0.04700847f, -0.05199290f, 0.04097281f, -0.02512882f, 0.05178083f, -0.00190364f, -0.00980867f, 
    0.00591788f, 0.04201988f, 0.01804708f, -0.04914760f, -0.00666425f, 0.04001449f, 0.03655643f, -0.04067734f, 
    0.01044195f, -0.01327949f, 0.03698672f, -0.02241375f, 0.05199838f, -0.03726674f, 0.01667037f, 0.00443408f, 
    0.02306499f, 0.00929011f, -0.04218055f, -0.02841764f, -0.01247658f, -0.03366664f, -0.01416401f, 0.02947652f, 
    0.02401953f, 0.01997093f, -0.03085009f, -0.03871535f, 0.02954202f, -0.05226530f, -0.05359696f, 0.02246036f, 
    -0.06780107f, -0.03239762f, -0.00382995f, -0.02630709f, 0.00163407f, -0.01261391f, -0.00234780f, 0.04284020f, 
    -0.01373788f, -0.00143963f, 0.01980957f, 0.03106925f, 0.04955764f, -0.02206754f, -0.00440253f, -0.00229996f, 
    0.05072345f, -0.00733478f, -0.03627870f, 0.02897032f, -0.01837469f, 0.00270992f, 0.00497465f, -0.01756978f, 
    -0.01942649f, -0.04374335f, -0.02163212f, -0.05870334f, 0.00834174f, -0.02890047f, -0.04373074f, -0.00177536f, 
    -0.06061877f, 0.03809009f, -0.05855776f, -0.06436895f, -0.00123630f, -0.00963117f, 0.03508633f, 0.00510263f, 
    0.03225611f, -0.02006623f, -0.01519529f, -0.06148168f, -0.04233580f, -0.01651768f, -0.02707478f, -0.01469070f, 
    -0.04923771f, 0.04267726f, 0.02270212f, -0.04359156f, -0.02241962f, -0.03818034f, 0.04706631f, -0.02024617f, 
    0.04362725f, -0.03835924f, -0.00689090f, -0.01687191f, 0.00204413f, -0.00250944f, 0.02792070f, 0.05029638f, 
    -0.05035966f, -0.06844364f, 0.00394076f, 0.04962753f, 0.00683129f, -0.02020334f, 0.02433204f, -0.05802324f, 
    -0.05387767f, -0.06128766f, 0.01992712f, -0.04066107f, 0.02859663f, 0.01582187f, 0.04299983f, -0.01833312f, 
    -0.04176703f, -0.05101523f, 0.02616704f, -0.01280487f, 0.00792788f, -0.04199709f, 0.03057098f, -0.03363631f, 
    0.00966557f, -0.02138370f, -0.03160551f, 0.03377295f, -0.02002634f, 0.04230877f, -0.03787181f, 0.04657399f, 
    0.02480824f, 0.04952227f, -0.05801267f, 0.00561128f, -0.05279275f, 0.00924143f, 0.03863480f, 0.01953082f, 
    0.02103101f, 0.04397306f, -0.00658087f, 0.04082005f, 0.01862941f, -0.02607427f, 0.00553643f, -0.02281944f, 
    -0.01838989f, 0.02344725f, -0.05884358f, -0.00514429f, -0.01447615f, -0.02139789f, -0.00869636f, 0.00161342f, 
    -0.04313560f, 0.03199925f, 0.01150800f, -0.03934471f, -0.05143759f, 0.00933833f, -0.05108072f, 0.05621180f, 
    0.03521344f, -0.05773433f, -0.04829364f, 0.04522230f, 0.02642590f, -0.04547326f, -0.00120855f, -0.06235057f, 
    0.00773405f, -0.06559744f, -0.04220618f, -0.05897247f, -0.04957565f, -0.05063884f, -0.00803694f, -0.06267858f, 
    0.04000636f, -0.00083218f, -0.01733212f, -0.04199833f, -0.02500234f, 0.01776236f, -0.02477531f, -0.02814604f, 
    -0.01700600f, 0.01775697f, 0.00076774f, -0.05820876f, 0.00333127f, -0.00098931f, -0.03287843f, -0.04315239f, 
    -0.02099275f, -0.04452857f, -0.02369361f, -0.01089058f, -0.04194937f, 0.00873777f, -0.00724778f, -0.06154770f, 
    -0.03467109f, -0.02780127f, 0.00237269f, -0.04339598f, -0.05909047f, 0.02753623f, -0.06343618f, 0.04472736f, 
    -0.02299281f, 0.00247692f, -0.06290291f, 0.04169912f, 0.02174903f, 0.00839014f, 0.02558377f, 0.03186424f, 
    0.02545287f, 0.04190346f, 0.04087306f, -0.02225169f, 0.04073828f, -0.05544494f, 0.00854892f, -0.00543160f, 
    0.04373845f, 0.00384171f, 0.01972588f, 0.00195824f, -0.01883442f, -0.04346775f, -0.03252160f, -0.01478183f, 
    -0.06516952f, -0.02791366f, 0.01257259f, -0.03404828f, -0.05437061f, 0.04109979f, -0.01134514f, -0.03633678f, 
    -0.02215213f, 0.02046457f, -0.02088504f, -0.05029628f, -0.02891264f, -0.01138002f, -0.04161927f, -0.04132372f, 
    -0.05241173f, -0.00440450f, 0.05155879f, 0.04390208f, -0.03910473f, 0.02329967f, -0.05009762f, 0.02080603f, 
    -0.00010617f, -0.04128008f, 0.00844910f, 0.04872308f, 0.02216323f, -0.00602799f, -0.01733989f, -0.03239219f, 
    0.04475555f, 0.01918273f, 0.02888536f, 0.00090104f, 0.01853896f, 0.04372253f, -0.03714551f, -0.05070795f, 
    0.02462818f, -0.01849050f, -0.00388217f, -0.02280477f, -0.05226221f, -0.02048948f, -0.00465630f, -0.03419201f, 
    0.03134916f, -0.05285793f, -0.03556731f, -0.04927438f, -0.04814341f, 0.04060557f, 0.04179361f, 0.04199206f, 
    0.03422887f, 0.04907348f, -0.03324464f, -0.04198733f, 0.00148967f, 0.02785411f, -0.02422126f, -0.00146764f, 
    0.04238687f, -0.03576609f, -0.05461354f, -0.05414468f, 0.02805836f, -0.05299253f, 0.01720219f, -0.05779997f, 
    -0.01261109f, -0.00130656f, 0.00833903f, -0.01632340f, 0.01819824f, -0.00891535f, -0.04379785f, -0.04495501f, 
    -0.00179848f, -0.01115432f, -0.04824691f, -0.04410516f, -0.03474103f, -0.05616637f, 0.01387617f, -0.00362758f, 
    -0.03516746f, -0.05523946f, 0.03867687f, -0.03049813f, -0.04490239f, 0.02584089f, 0.05371926f, -0.01299355f, 
    -0.05798265f, -0.05810665f, 0.00178363f, -0.03001043f, 0.03367274f, 0.01453929f, -0.05250210f, 0.02612279f, 
    0.02636244f, -0.06238768f, 0.03516578f, 0.05280182f, -0.00804451f, -0.03359751f, -0.00181812f, -0.03427418f, 
    -0.02099690f, 0.02571006f, -0.02280620f, -0.05840599f, -0.00487459f, 0.01012493f, 0.00187037f, 0.00491573f, 
    0.00902150f, 0.03083747f, 0.03661932f, -0.02750101f, 0.01823439f, -0.00982909f, 0.02672306f, 0.03465350f, 
    -0.05824048f, 0.01867555f, -0.06185688f, -0.00756172f, -0.01966495f, 0.04301435f, -0.00237701f, -0.04626377f, 
    -0.05803936f, 0.02196581f, -0.03751455f, 0.00149511f, 0.04743477f, 0.04440935f, -0.04124852f, -0.06461818f, 
    -0.04970954f, -0.05908539f, -0.01115597f, 0.01761615f, 0.00395834f, -0.03504242f, -0.02066127f, 0.03050436f, 
    0.00565867f, -0.05818712f, -0.03870743f, -0.05534798f, -0.02722303f, -0.06351867f, -0.03119746f, 0.02766086f, 
    0.03708887f, -0.03949116f, -0.05206308f, -0.01317478f, -0.04958338f, 0.04209956f, -0.01585101f, 0.01952450f, 
    -0.01758248f, -0.02347977f, 0.00388108f, 0.01221741f, -0.01825122f, -0.01609723f, -0.04240017f, 0.02725302f, 
    -0.02842613f, 0.00338556f, 0.03142555f, 0.00361638f, -0.00551214f, 0.02088937f, -0.04225375f, 0.04332551f, 
    -0.05176258f, 0.04672824f, 0.05425346f, -0.01545871f, 0.04775545f, -0.01679437f, 0.02719134f, -0.03147449f, 
    -0.01530378f, -0.02269447f, -0.00336059f, 0.04074166f, -0.04312799f, 0.00428309f, -0.01017925f, 0.01393635f, 
    0.00146274f, -0.01906611f, -0.03730213f, -0.01727142f, 0.01220788f, 0.02993413f, -0.04525115f, -0.01227023f, 
    0.03532335f, 0.04303474f, -0.05496028f, 0.03630028f, -0.03767572f, -0.00260041f, 0.05137336f, 0.04056106f, 
    0.03681495f, 0.01836013f, -0.05622876f, 0.02814971f, 0.00068272f, -0.02179248f, -0.00261869f, 0.02282964f, 
    0.00102766f, -0.02624335f, 0.00568335f, 0.00487422f, 0.03383893f, -0.02716536f, -0.00978736f, -0.06098604f, 
    -0.00406593f, -0.05272542f, 0.02963792f, -0.00511160f, -0.01925637f, 0.00466490f, -0.04637776f, -0.04782860f, 
    -0.05720277f, -0.01330862f, 0.04395455f, -0.06396944f, -0.04082251f, 0.05358665f, 0.00743424f, 0.05546604f, 
    0.02168744f, -0.04712312f, 0.02478058f, 0.02860786f, 0.02174780f, -0.06228539f, -0.01729361f, -0.01559870f, 
    -0.04677677f, 0.05080289f, 0.04537515f, -0.06382944f, 0.01215131f, 0.02572160f, 0.04088033f, -0.04659216f, 
    0.04800714f, -0.02823203f, 0.05525187f, -0.00966804f, 0.04390066f, 0.01750183f, 0.05212197f, -0.02992387f, 
    -0.04898497f, -0.04528721f, 0.01216061f, 0.05135554f, -0.01614427f, 0.01919034f, 0.04789079f, -0.05874282f, 
    -0.03778318f, 0.03103774f, 0.01045215f, 0.04163334f, -0.00298898f, -0.06031263f, 0.03305436f, -0.01652873f, 
    0.03956093f, -0.02856418f, -0.02920001f, -0.04458054f, -0.03963893f, -0.04937248f, -0.03711265f, 0.02141386f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00757055f, -0.00297290f, 0.23096016f, -0.04007880f, -0.01733926f, -0.02934956f, 0.06008092f, 0.02228522f, 
    0.08709007f, 0.16011217f, -0.01853595f, 0.01683038f, -0.09794934f, -0.02753840f, 0.04523843f, -0.25551692f, 
    -0.23536542f, 0.22246134f, 0.16107459f, 0.10323240f, -0.10343022f, 0.04194417f, 0.00037696f, -0.03954604f, 
    0.33666027f, -0.01077519f, 0.23814394f, 0.01655200f, 0.02971478f, -0.02687961f, 0.01086485f, 0.04812168f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16565634f, -0.05438389f, 0.17573294f, -0.15388705f, -0.09054682f, 0.08010087f, -0.50573885f, 0.10273556f, 
    -0.34190166f, -0.34184334f, -0.22017653f, 0.01172028f, -0.82130969f, 0.35681576f, 0.05520774f, -0.23863566f, 
    -0.13118967f, 0.53138590f, 0.30280626f, -0.17695709f, 1.05415034f, -0.07482554f, -0.12237395f, -0.13973902f, 
    -0.31118187f, 0.01932036f, -0.14972475f, 0.02295168f, -0.14413555f, 0.08148307f, -0.08072621f, 0.12590532f, 
    -0.10915276f, 0.04097838f, 0.01657823f, -0.31636700f, -0.13913845f, -0.13756658f, -0.01746387f, 0.13287401f, 
    -0.11426391f, 0.15531383f, -0.61534965f, -0.06658328f, -0.04740176f, 0.68514442f, -0.13568765f, -0.22420326f, 
    0.52734059f, 0.45758361f, 0.11743540f, 0.17431889f, -0.11712961f, 0.00043337f, 0.09067508f, -0.07894148f, 
    0.30737805f, -0.11149042f, 0.52190012f, -0.19012158f, -0.01556746f, -0.13704003f, 0.14765660f, 0.07688612f, 
    -0.15602401f, -0.09373059f, -0.36891204f, -0.04954300f, -0.08839264f, -0.04066934f, -0.06986844f, -0.05037276f, 
    -0.71891397f, -0.37193412f, 0.19833754f, 0.06348803f, 0.20093873f, 0.50872749f, 0.15594265f, 0.34229892f, 
    -0.44659650f, -0.14442210f, -0.00615040f, 1.06620777f, -0.23309013f, 0.07632089f, 0.00984276f, 0.02722754f, 
    0.03654378f, -0.08215639f, -0.48795417f, -0.00807352f, -0.02761331f, -0.04182357f, -0.12184847f, 0.03261256f, 
    -0.12778664f, 0.14547971f, 0.41581574f, 0.70277750f, 0.16612622f, -0.12598436f, 0.14007437f, -0.16344759f, 
    0.00853159f, -0.17946868f, -0.14682522f, 0.12904724f, -0.39155605f, -0.49461278f, 0.04740218f, -0.45102584f, 
    0.66065687f, -0.52338779f, -0.57255286f, -0.22513002f, -0.21791449f, 0.13495588f, 0.02283713f, -0.15683177f, 
    -0.14540443f, 0.09598901f, -0.42268258f, -0.03135325f, 0.10809857f, 0.07275473f, 0.15363815f, -0.06091122f, 
    -0.15115730f, -0.11284282f, 0.26739052f, 0.03736644f, 0.08266822f, -0.13842276f, 0.59070915f, 0.11564914f, 
    -0.24508274f, -0.53508765f, -0.01045228f, 0.01899235f, -0.19220011f, -0.02408273f, 0.16044125f, 0.39585567f, 
    -0.70233458f, 0.53758407f, 0.12315226f, -0.22069065f, -0.80755746f, 0.12592922f, -0.02314082f, 0.09709597f, 
    -0.27415258f, 0.08510298f, -0.13296080f, 0.06925631f, 0.15132287f, 0.01303065f, -0.15300643f, -0.13459440f, 
    0.01525185f, 0.17062551f, 0.22710910f, -0.53583741f, 0.13426895f, 0.01079664f, -0.65477097f, 0.10927599f, 
    0.26894107f, -0.44329989f, -0.19132811f, -0.17900978f, -0.00603759f, -0.74233067f, -0.08361674f, -0.37309939f, 
    0.03016222f, -0.23148932f, 0.43083620f, -0.29088923f, 0.11729211f, -0.02841757f, 0.13924935f, 0.03300606f, 
    0.91569811f, -0.15341578f, 0.00039865f, 0.10023154f, -0.04700782f, 0.02383558f, 0.05008071f, -0.15843858f, 
    -0.07784758f, 0.14096750f, -0.06825791f, 0.12556954f, -0.03980268f, 0.15485126f, 0.67161536f, -0.14586794f, 
    -0.18711728f, 0.67775720f, -0.52436149f, -0.00374494f, 0.46485090f, -0.18947819f, 0.14145502f, -0.20761193f, 
    -0.26906282f, -0.48010117f, -0.08115072f, -0.37736174f, -0.18186474f, 0.14456747f, -0.01267181f, -0.09158451f, 
    0.28000501f, -0.03538014f, -0.80095494f, 0.41709810f, -0.11918655f, -0.01797554f, -0.16619655f, -0.11198569f, 
    -0.12599048f, 0.05650144f, -0.36368537f, 0.21320173f, -0.17497808f, -0.05305094f, -0.46033093f, -0.04138312f, 
    0.30194446f, -0.36174822f, -0.22979051f, -0.17850150f, -0.16427438f, -0.35687089f, 0.06178486f, 1.04363012f, 
    0.14115675f, -0.36021584f, -0.12039919f, -0.18051979f, 0.14152613f, -0.09464537f, -0.03453727f, -0.09216334f, 
    0.22338913f, -0.02520880f, -0.13378136f, -0.27858597f, 0.07787028f, -0.13362353f, -0.05601499f, -0.01984177f, 
    0.02129053f, -0.12706405f, -0.68858331f, -0.60536188f, 0.06062286f, 0.09894556f, 0.36012623f, 0.03925832f, 
    0.32573348f, -0.19421369f, 0.24676625f, -0.03021423f, 0.37952739f, 0.38940167f, 0.00142183f, -0.23093468f, 
    0.00767511f, -0.67068970f, 0.39192188f, -0.13855556f, -0.31998473f, -0.10352520f, 0.04174156f, -0.09226615f, 
    -0.56607646f, 0.04053222f, 0.81559300f, -0.06627204f, 0.05560599f, 0.06274451f, -0.14602560f, -0.03468880f, 
    0.08725216f, -0.13295773f, -0.13897423f, -0.26481310f, 0.06013222f, 0.18332693f, -0.39112255f, 0.09853180f, 
    -0.39853275f, 1.18480349f, 0.44371814f, -0.15470450f, -0.33119124f, -0.60424936f, -0.00844683f, 0.40452978f, 
    -0.10241951f, 0.07450365f, -0.11231248f, -0.46760589f, -0.18414231f, -0.03229241f, -0.10324436f, -0.10771805f, 
    -0.42287090f, -0.15037388f, 0.02429017f, 0.47215444f, 0.05698464f, 0.15045051f, 0.00678695f, 0.10193061f, 
    -0.07053030f, 0.17231588f, 0.23675190f, 0.22617382f, -0.16408350f, -0.08364512f, 0.07120756f, -0.16701286f, 
    0.60421449f, -0.05081728f, -0.10799846f, -0.14926574f, 0.19661483f, -0.73188984f, -0.14317094f, -0.42065227f, 
    -0.96790028f, -0.17953156f, -0.38552949f, 0.64234722f, -0.30572912f, -0.13750541f, -0.15972000f, -0.15981172f, 
    -0.21716814f, 0.07267814f, 0.45941883f, -0.75675523f, 0.03597640f, -0.05562938f, -0.03131723f, -0.11642109f, 
    -0.11959914f, 0.03724346f, 0.24733838f, -0.09536447f, -0.04669797f, -0.04874730f, 0.28842887f, -0.09820543f, 
    -0.14050080f, -0.17393570f, 0.19779725f, -0.10938781f, 0.58982229f, -0.23215683f, -0.08509277f, -0.40258810f, 
    0.38773084f, -0.03618198f, -0.55324471f, -0.12426185f, 0.36540616f, -0.01935096f, 0.13375781f, -0.08840738f, 
    -0.75389767f, -0.13934901f, -0.56250691f, 0.05390075f, 0.04774335f, -0.06324556f, 0.11665823f, 0.04090173f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00694465f, -0.25571203f, -0.13453853f, -0.03882327f, 0.05889460f, 0.33538762f, 0.03243000f, -0.52444291f, 
    -0.07690119f, 0.04325116f, 0.40826294f, 0.02068304f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
