#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.58203429f, 0.12961277f, 0.20608394f, 0.36094442f, 0.33165482f, 0.29158613f, 0.03589478f, 0.18341842f, 
    0.09933195f, 0.23021655f, 0.11274531f, 0.24399473f, 0.42444950f, -0.12117901f, 0.17804131f, 0.00127705f, 
    -0.17726746f, 0.22477196f, 0.22552910f, -0.22229156f, -0.10173799f, -0.06772610f, 0.30375245f, 0.39700374f, 
    0.08723325f, -0.04069315f, 0.61325896f, 0.44599995f, 0.85942680f, 0.33143511f, -0.01483370f, -0.19038446f, 
    -0.59687144f, -0.91436023f, -1.02234316f, -0.17537734f, -0.06112989f, 0.24385916f, 0.38299891f, -0.04727245f, 
    0.43696409f, -0.24320991f, -0.00939784f, 0.06233148f, 0.33499566f, -0.44458783f, 0.21071236f, 0.38591409f, 
    0.14954787f, -0.18270014f, -0.48721924f, -0.19525005f, -0.28380865f, 0.74520886f, 0.26426706f, 0.44747943f, 
    -0.75055081f, -0.16658379f, 0.64796680f, 0.60549635f, 0.27901682f, 0.06161817f, -0.08667671f, -0.58223164f, 
    0.52409708f, -0.25325233f, 0.14004357f, 0.24106145f, -0.54408687f, 0.12789312f, -0.19067800f, 0.05282468f, 
    -0.15275122f, 0.02635927f, 0.43945724f, -0.25730723f, -0.05858748f, 0.18302213f, -0.11919938f, 0.26025569f, 
    -0.73069412f, -0.76696354f, 0.63071108f, 0.21706364f, 0.33743608f, -0.53532469f, -0.11097986f, 0.40917826f, 
    0.07353406f, -0.15989871f, 0.21717383f, 0.12273059f, -0.34123918f, -0.23843443f, 0.45440850f, 0.02746739f, 
    0.48273274f, 0.00476029f, -0.04769936f, 0.37681919f, -1.45308900f, -0.89323151f, -0.43908083f, 1.18405497f, 
    0.41418487f, -0.93790233f, -0.36520892f, -0.58580244f, -0.05580165f, 0.35699406f, 0.66137409f, -0.18105681f, 
    -0.14026785f, 0.50238758f, 0.67195672f, -0.02424061f, -0.17636736f, -0.22042815f, 0.03216368f, -0.14739889f, 
    -0.23053886f, -0.14786814f, 0.13307381f, 0.00880041f, -0.12214068f, 0.39306512f, -1.24575031f, -1.19278800f, 
    0.45155376f, 0.70606548f, 0.24360366f, 0.34143171f, -1.50584757f, -0.90169400f, -0.51488173f, -0.21752509f, 
    0.48146933f, -0.05189699f, 0.44229078f, -0.22538026f, -0.07007961f, -0.50381809f, 0.01524782f, 0.04076019f, 
    -0.41556725f, 0.15230636f, -0.10866286f, -0.18733904f, 0.23086259f, 0.05752025f, 0.18752767f, -0.41929263f, 
    -0.24008647f, 0.43239671f, -1.08827019f, -1.46428823f, -1.13017309f, -0.84815645f, -0.55651546f, -1.01403010f, 
    0.41148493f, -0.70722783f, -0.28927881f, 0.47247079f, 0.09946590f, -0.43661946f, 0.19365805f, -0.09889860f, 
    -0.20382872f, -0.22544481f, -0.38907915f, -0.15057120f, -0.25453088f, 0.20597994f, -0.13916261f, 1.54511106f, 
    -1.42339540f, -0.36039418f, 0.50721771f, 0.34729078f, 0.93377036f, 0.74414629f, 0.45610911f, -0.28942198f, 
    0.00911206f, -0.61866403f, 0.53392094f, -0.28914127f, -0.53699374f, -0.04514381f, -0.26234910f, -0.26010168f, 
    -0.13152432f, -0.30923411f, -0.15076166f, 0.25516513f, -0.11041740f, -0.31301877f, -0.00689521f, 0.21474178f, 
    1.18854713f, 0.46143308f, 0.14447290f, -0.16955183f, 0.24871027f, -0.00386520f, -0.34402072f, 0.01266291f, 
    0.88026386f, -0.99535215f, -0.45057526f, 0.51706564f, -0.01161713f, -0.44422081f, -0.20528787f, -0.44573191f, 
    -0.26826361f, 0.10044901f, -0.01241322f, 0.01684286f, 0.03639789f, 0.14221479f, -0.08466730f, -0.37347031f, 
    0.02831258f, 1.17185450f, 0.03729113f, -1.12128723f, -1.43008411f, -0.82310027f, 0.50574583f, -0.08672607f, 
    0.34459418f, -0.12669306f, 0.37886718f, 0.52688444f, 0.02175918f, 0.41055310f, -0.07472860f, 0.45291165f, 
    0.04453338f, 0.04627862f, -0.03686455f, -0.47918147f, -0.04175846f, 0.11841015f, -0.35927653f, -0.06379622f, 
    0.10088957f, 0.25686684f, -0.56755710f, -0.49012011f, 0.75234318f, 0.80551517f, 0.33571658f, 0.54145199f, 
    -0.59209383f, -0.93308622f, -0.74323612f, -0.17631450f, -0.08654913f, -0.55094987f, -0.49552983f, -0.53551805f, 
    -0.37649122f, -0.42324775f, -0.38413119f, 0.13417007f, 0.21014741f, -0.22039056f, 0.07757405f, -0.24172361f, 
    -0.07052165f, -0.18840349f, -0.00261814f, -0.89900786f, 1.12558079f, 0.66326237f, -0.52445489f, 0.12402778f, 
    -0.14229341f, 0.28573984f, -0.19250651f, 0.27646840f, 0.14033599f, 0.01438190f, -0.21200541f, -0.04415639f, 
    -0.57608068f, -0.04047098f, 0.28373095f, -0.15119278f, -0.09139367f, -0.31198153f, -0.09553222f, -0.28782445f, 
    -0.62974250f, -0.68440431f, -0.69462585f, -1.28871143f, 1.17685342f, 0.79807663f, 0.56435710f, -0.39537019f, 
    -0.87648940f, 0.29674074f, -0.20734163f, -0.42362773f, -0.38556600f, -0.28221098f, 0.44161883f, -0.62965995f, 
    -0.44142586f, 0.18864153f, 0.36610028f, 0.33653075f, 0.09685086f, -0.08626020f, -0.08027796f, -0.03855801f, 
    -0.05564760f, 0.48240438f, -0.08925063f, -0.24028984f, -0.25897318f, 0.65457004f, 0.10179404f, -0.48132610f, 
    0.15271065f, -0.29714918f, -0.89784116f, -0.27398813f, 0.25857294f, 0.64748359f, 0.30958039f, 0.10828368f, 
    -0.12535119f, 0.04758964f, 0.23538437f, 0.14849830f, -0.47936741f, -0.35726246f, 0.67845464f, 0.08817345f, 
    -0.56000233f, 0.12947899f, 0.19888896f, 0.08078495f, 0.03974302f, 0.05918786f, -1.25011110f, -0.97528046f, 
    -0.79567498f, -0.60044247f, -0.95603937f, -0.04466325f, 0.03944849f, -0.59922528f, -0.86254156f, -0.31179655f, 
    0.13505584f, 0.21435882f, -0.26751232f, -0.63424623f, -0.28498718f, 0.28254005f, -0.03901506f, -0.33583763f, 
    0.10012944f, -0.23478349f, 0.30272210f, 0.27013364f, 0.58399647f, 0.36737016f, 0.34835777f, -1.22900856f, 
    -0.45306468f, -0.95208782f, -1.21744215f, -1.01652479f, 0.72953326f, 0.21260981f, 0.59913337f, 0.58509558f, 
    0.81380230f, 0.33095005f, 0.21062702f, 0.17575397f, -0.00415471f, -0.10044673f, -0.12619935f, -0.03140608f, 
    -0.02208717f, 0.03379754f, -0.25738618f, -0.18115316f, -0.05009807f, 0.09638486f, -0.27054766f, -0.35617897f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03832146f, 0.26348007f, 0.74751210f, 0.58417821f, 0.48335734f, 0.46498421f, -0.25016162f, 0.56720698f, 
    0.74419922f, 0.80699790f, 0.18935184f, 0.15721563f, 0.62789106f, 0.37469602f, -0.45711288f, 0.20194553f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04054371f, 0.05535618f, 0.01580951f, 0.09673389f, -0.01250434f, 0.02273728f, 0.10638031f, -0.00914104f, 
    -0.11401835f, -0.03885463f, -0.07529631f, 0.03112383f, 0.10122592f, -0.30988365f, -0.17401725f, 0.10521930f, 
    0.28099340f, -0.22720683f, -0.19433230f, -0.07183079f, -0.04584678f, 0.06027295f, 0.02804877f, -0.03896222f, 
    -0.20347935f, 0.21715759f, 0.06190041f, -0.04714183f, -0.24859175f, 0.00818551f, 0.04994306f, -0.01369205f, 
    -0.18344341f, -0.07765482f, 0.09614190f, -0.15461120f, -0.19730620f, 0.15923086f, 0.33295226f, -0.07316931f, 
    -0.33761874f, -0.24758899f, -0.18736923f, -0.31573343f, -0.04655492f, -0.07192517f, 0.04896610f, -0.02761218f, 
    0.45418704f, 0.47474998f, 0.40480053f, -0.93682790f, -0.13870728f, 0.15234156f, -0.02892634f, -0.11235873f, 
    0.08032364f, 0.03218792f, -0.08857145f, -0.01847266f, 0.25905785f, 0.16756852f, -0.45858991f, -0.13258341f, 
    0.08029328f, -0.23433973f, 0.04169998f, -0.38381860f, -0.05621083f, -0.16885830f, -0.11898877f, -0.26149622f, 
    0.46488988f, 0.20236118f, 0.20409395f, -0.49650946f, 0.22113964f, 0.14505896f, -0.11981542f, 0.24853644f, 
    0.01510520f, -0.01850001f, -0.13334848f, -0.08633129f, -0.01496040f, -0.74763435f, -0.98953032f, 0.19063531f, 
    -0.01945991f, 0.06600682f, 0.15339872f, 0.01643307f, -0.03874249f, -0.09980737f, 0.03875278f, -0.10274442f, 
    -1.07524943f, -0.46143413f, -0.60407901f, 0.28012466f, 0.07924255f, 0.07783083f, -0.06779589f, 0.11966965f, 
    0.10312893f, 0.04206170f, 0.04413643f, -0.20759988f, 0.19768016f, -0.00565096f, -0.61390495f, 0.14593446f, 
    0.04663341f, 0.10062138f, -0.37391171f, -0.15341930f, -0.21822277f, -0.08942501f, -0.14126146f, -0.02526144f, 
    0.67796588f, 0.62578779f, -0.16901514f, -0.26841751f, -0.19064413f, -0.24141455f, 0.01062795f, 0.06939252f, 
    0.00990945f, -0.08500332f, -0.05911074f, 0.09647209f, -0.51356751f, 0.01098019f, -0.03304745f, 0.13432489f, 
    0.01458581f, 0.03216631f, 0.04098279f, 0.06980975f, -0.22841673f, 0.05833854f, 0.10157547f, 0.35648942f, 
    -0.32366693f, -0.58672667f, -0.25498948f, 0.05187573f, -0.08048627f, 0.11009955f, -0.07672186f, -0.15522715f, 
    -0.05729252f, 0.01432534f, 0.01841356f, -0.00230155f, -0.41196135f, -0.26515269f, -0.03059242f, -0.14391652f, 
    -0.08587227f, 0.02558159f, -0.08288075f, -0.03296668f, -0.04889512f, -0.21710652f, -0.09718703f, -0.14519478f, 
    0.46757695f, 0.28278619f, -0.20185532f, -0.13981891f, 0.26720712f, 0.25752902f, 0.14136317f, 0.16102462f, 
    -0.07420234f, -0.08806562f, -0.02490854f, -0.03110085f, 0.29167077f, -0.06935629f, 0.03251264f, 0.12941690f, 
    0.16577455f, 0.28305092f, 0.01175686f, 0.04120331f, 0.08480477f, 0.25229040f, -0.06877174f, 0.15041630f, 
    0.09107317f, 0.14546831f, 0.03883991f, 0.19492941f, -0.03177347f, -0.04555561f, 0.02177808f, -0.05862370f, 
    -0.14259292f, -0.02783075f, 0.09237822f, -0.01852587f, 0.11637837f, -0.11382329f, -0.10092142f, -0.05588768f, 
    -0.51499879f, -0.10400056f, 0.01630514f, -0.10985944f, -0.21207288f, 0.11906787f, 0.09814306f, 0.04358978f, 
    -0.22369125f, 0.21659173f, 0.02610826f, 0.08863346f, 0.07402455f, 0.09619948f, -0.06868710f, -0.03656874f, 
    -0.08462990f, -0.10088860f, 0.06158783f, 0.14171126f, -0.20459750f, 0.07514531f, -0.05752618f, 0.00912697f, 
    -0.00620269f, -0.03935536f, -0.16924202f, -0.08687761f, -0.12445616f, 0.03525470f, 0.10193881f, 0.02673731f, 
    -0.71593571f, 0.10673606f, 0.09953417f, -0.15263793f, -0.08644037f, 0.10969292f, 0.23479435f, 0.08645903f, 
    0.16157076f, 0.09997983f, 0.20563230f, -0.11197272f, -0.07839691f, -0.27192295f, -0.12852070f, 0.21408920f, 
    -0.15104888f, 0.13586804f, 0.11428028f, 0.16764759f, 0.11209251f, -0.14276069f, -0.05272238f, 0.24715164f, 
    0.01702430f, 0.26961887f, 0.07960550f, -0.36798799f, 0.06214381f, -0.46385258f, 0.13442835f, -0.07008204f, 
    0.05688884f, 0.00123483f, 0.09362339f, 0.10552408f, 1.47320294f, -0.00508471f, 0.05795516f, 0.10318570f, 
    -0.14396864f, 0.02149148f, -0.05286722f, 0.05985022f, -0.02574943f, 0.14189114f, -0.02293325f, 0.05432578f, 
    0.48565125f, 0.34832713f, 0.02946937f, -0.06414442f, -0.01520983f, -0.12759219f, -0.09104457f, 0.06626635f, 
    -0.04043774f, 0.06961014f, -0.08300919f, 0.03517969f, 0.29382867f, -0.65002024f, -0.00912849f, -0.39801151f, 
    0.04076669f, 0.06534979f, 0.13713677f, -0.33965087f, 0.20038122f, 0.08946825f, 0.09428377f, -0.10786548f, 
    -0.36465257f, -0.25706029f, -0.61011010f, -0.47909755f, 0.14874589f, 0.02217854f, -0.25834733f, 0.05334518f, 
    0.05199602f, -0.01594286f, 0.06863433f, -0.14668685f, 0.04091042f, -0.11527357f, -0.00495667f, -0.13284610f, 
    0.01495739f, 0.00653720f, -0.21410681f, 0.09542975f, -0.56586784f, -0.33475611f, -0.24522698f, -0.25751728f, 
    0.41159385f, -0.07328343f, -0.03220419f, -0.34006661f, -0.04426400f, -0.18696105f, -0.11211364f, 0.01688955f, 
    -0.05869948f, 0.08496224f, -0.07773633f, -0.12084531f, -0.27444986f, 0.23674442f, 0.36016604f, -0.26996553f, 
    -0.03263383f, 0.07342702f, -0.10215462f, 0.14578255f, 0.16625321f, 0.09502799f, -0.02313958f, -0.13028672f, 
    0.40841043f, 0.31572911f, 0.40983519f, 0.15333615f, -0.21174186f, 0.19722390f, 0.06871314f, 0.25941533f, 
    -0.02694850f, 0.03641957f, -0.12775114f, 0.00138782f, -0.08528899f, 0.03445238f, -0.09064966f, -0.08398588f, 
    -0.01874744f, 0.11495698f, -0.04899635f, -0.15328681f, -0.05850356f, -0.00949394f, -0.15021858f, -0.22517245f, 
    -0.29979482f, -0.08612273f, 0.00555295f, -0.04957210f, -0.11391710f, 0.01200585f, 0.05055029f, 0.05306232f, 
    -0.07578415f, 0.00352754f, 0.08202089f, -0.19760080f, -0.27311516f, 0.24317539f, -0.13811383f, -0.03290913f, 
    -0.26327932f, -0.64608502f, -0.04778508f, -0.06087724f, -0.00143617f, 0.09127000f, 0.01980240f, -0.08574048f, 
    -0.15595813f, -0.13400578f, -0.10249373f, 0.14443207f, 0.14967005f, 0.06947492f, -0.01450237f, 0.14168727f, 
    -0.08106907f, 0.11889952f, -0.07441465f, 0.34505156f, 0.29703230f, 0.01141925f, -0.19875716f, 0.16587974f, 
    -0.10188418f, 0.52040702f, 0.16627653f, -0.04853903f, -0.06736597f, 0.02969638f, -0.20728183f, 0.07692410f, 
    -0.00298745f, -0.45426711f, -0.26148370f, 0.55515206f, 0.07645845f, -0.17510732f, -0.34797737f, -0.00112317f, 
    -0.20041114f, 0.05391382f, 0.06979892f, 0.12207462f, 0.09774277f, -0.05281846f, 0.14755574f, -0.17655326f, 
    0.31640965f, 0.09433554f, 0.03296679f, 0.02903077f, -0.06964819f, -0.04080341f, -0.07612427f, -0.04092016f, 
    -1.74697602f, -0.48880482f, -0.27727875f, 0.00712681f, 0.12389278f, -0.00433682f, 0.01002376f, -0.29695788f, 
    -0.01570081f, -0.05834485f, -0.00789119f, 0.10019840f, -0.08019846f, -0.01510075f, -0.35279512f, -0.22893240f, 
    0.00526202f, -0.10109651f, -0.02664774f, 0.04189409f, 0.06148161f, -0.04311165f, -0.09091239f, -0.03890701f, 
    -0.20139678f, 0.08218398f, 0.40673441f, -0.17457223f, -0.11287986f, -0.01507531f, 0.14754958f, 0.14395133f, 
    0.01663396f, -0.00859689f, -0.05107980f, 0.09466023f, -0.07340112f, 0.47432777f, 0.46769455f, -0.01187688f, 
    -0.16427976f, 0.06981740f, 0.22995460f, -0.41841233f, 0.13136567f, 0.19538334f, -0.25837636f, 0.16476572f, 
    -0.15408999f, 0.92667532f, -0.28842822f, -0.39252239f, 0.05808381f, -0.04923403f, 0.07452005f, 0.05608615f, 
    -0.07100746f, -0.03366839f, 0.08227454f, -0.05549178f, 0.27512637f, -0.03715348f, -0.20271872f, -0.12139115f, 
    0.06248721f, -0.04986025f, 0.00147091f, -0.08157656f, 0.17055526f, 0.42324680f, 0.10881796f, 0.18039379f, 
    -0.49749810f, -0.21957812f, 0.07039620f, -0.60854101f, -0.03155378f, -0.07039893f, -0.15468840f, 0.18239017f, 
    0.06987271f, 0.08629492f, -0.21446112f, 0.26308557f, -0.98668003f, 0.03635022f, -0.07156400f, 0.27292153f, 
    0.06051500f, 0.25211501f, -0.15501092f, -0.11148334f, 0.05441007f, -0.00271604f, 0.22211941f, 0.00943786f, 
    -0.95496821f, -0.25870386f, 0.31954452f, -0.18288772f, 0.01572386f, 0.01653937f, 0.15232073f, 0.02255148f, 
    -0.04334967f, -0.04190991f, -0.15800922f, 0.01733839f, 0.24449135f, 0.70623475f, 0.36491251f, 0.40108794f, 
    -0.14993782f, -0.08750062f, 0.19445714f, -0.08133559f, -0.15490218f, -0.01080975f, -0.07837285f, 0.10525928f, 
    -0.60225052f, -0.35885173f, 0.00865545f, -0.05159469f, 0.07108841f, -0.25074980f, 0.02603960f, -0.22631165f, 
    0.24406657f, 0.23281352f, -0.22280549f, 0.05074375f, 0.11920496f, 0.51394397f, 0.08965588f, 0.32533926f, 
    -0.00706174f, -0.05191224f, -0.13440946f, 0.24148153f, 0.11338963f, -0.20463704f, 0.12290186f, 0.24881732f, 
    0.01942438f, -0.17658755f, 0.22048894f, -1.15971828f, 0.12783121f, -0.33310324f, -0.14726357f, 0.05771755f, 
    0.05644584f, 0.34206203f, -0.24619399f, -0.34210500f, 0.26729515f, -0.03021934f, -0.22103758f, -0.29845294f, 
    -0.18582398f, -0.29095808f, -0.18318212f, -0.00812950f, 0.21521811f, 0.22934809f, -0.14980701f, -0.16718808f, 
    0.23705848f, 0.35035217f, -0.44193655f, -0.22283217f, 0.29261896f, 0.03960105f, 0.00104118f, -0.14181998f, 
    -0.10251189f, -0.19504353f, 0.19929104f, 0.00458762f, 0.11665189f, 0.31513542f, -0.36245391f, 0.35612801f, 
    0.16738650f, -0.07081975f, -0.00966034f, -0.14047469f, -0.06490847f, 0.11706586f, 0.01769446f, -0.07751523f, 
    -0.04618168f, -0.26563099f, -0.06963482f, 0.36464220f, -0.15521222f, 0.06753991f, 0.13521019f, 0.25237241f, 
    -0.15397964f, 0.05365647f, -0.02777805f, -0.02132220f, -0.74384683f, 1.63973570f, -0.18021162f, -0.24983676f, 
    0.21244140f, -0.02789803f, 0.09816191f, -0.14955422f, -0.24016766f, -0.09314340f, 0.04788054f, 0.01520934f, 
    -0.44069710f, -0.59270608f, 0.50081009f, -0.29391727f, -0.26088250f, 0.06286370f, -0.27390712f, -0.06009551f, 
    -0.12792738f, 0.07923269f, -0.21204390f, 0.05027708f, -0.27270398f, -0.15222268f, -0.16664287f, 0.65573704f, 
    -0.06991450f, -0.12238303f, 0.03100858f, -0.01648666f, -0.02985559f, 0.14480245f, 0.16235124f, 0.06913958f, 
    -0.62628967f, 0.20369206f, -0.04004903f, 0.26094833f, -0.13850589f, 0.12442980f, 0.02061289f, 0.00586820f, 
    -0.07471413f, -0.00930484f, -0.04885720f, 0.02794638f, 0.59025604f, 0.02232692f, 0.15998718f, -0.38942909f, 
    -0.12443937f, -0.08762727f, 0.09852495f, -0.06357931f, -0.00074408f, 0.34893736f, 0.00840597f, 0.01466683f, 
    -0.79868740f, -0.24792202f, 0.63708782f, 0.05977608f, -0.21638155f, 0.18683684f, -0.27270779f, 0.15243736f, 
    0.06705466f, -0.07041985f, -0.03007270f, 0.00365600f, -0.10689119f, 0.28136137f, 0.03373665f, 0.04627749f, 
    -0.45063895f, 0.03121200f, -0.17029198f, -0.12643214f, -0.35881105f, -0.05075670f, 0.06445529f, -0.09787001f, 
    0.18292205f, -0.13057947f, -0.08881371f, 0.32381591f, 0.12259660f, -0.10421078f, 0.02407143f, -0.06324976f, 
    -0.03619123f, 0.13689739f, -0.02982894f, 0.14669248f, 0.45895836f, -0.53741860f, -0.18104415f, 0.22354937f, 
    0.36891288f, 0.17572926f, 0.03238966f, -0.05308056f, -0.17747253f, 0.02676621f, -0.06326225f, 0.12561695f, 
    0.14121555f, 0.10024118f, 0.04324595f, 0.04475560f, 0.19708590f, 0.00521607f, 0.11084051f, 0.06934513f, 
    0.02712714f, 0.10960557f, -0.02174161f, -0.01986210f, 0.18487982f, 0.06156648f, 0.36523226f, 0.25235030f, 
    0.12183234f, 0.36056086f, -0.29381832f, 0.23810633f, -0.02069341f, -0.14370163f, -0.12767027f, -0.09977507f, 
    0.12788014f, -0.02836762f, -0.22059691f, -0.13622466f, -0.06083364f, -0.12801494f, 0.11573952f, -0.04457998f, 
    -0.39204371f, -0.27406153f, -0.27488047f, -0.10841217f, -0.21257293f, -0.14105384f, -0.06496719f, -0.21493228f, 
    0.08049985f, 0.00874428f, 0.08243518f, 0.01755729f, 0.02335277f, -0.19258414f, -0.21309574f, -0.29549140f, 
    -0.02176579f, -0.06428895f, 0.09891587f, 0.36974531f, -0.19048937f, -0.21247074f, -0.18781152f, 0.02648619f, 
    -0.14923725f, 0.03043367f, -0.23509845f, 0.13309935f, 0.18394133f, -0.37703049f, 0.22871144f, 0.00348594f, 
    0.04930446f, 0.04409546f, -0.20045830f, -0.08948472f, -0.14437512f, -0.00054490f, -0.11291797f, -0.12719961f, 
    -0.07573005f, 0.32594135f, 0.23157468f, 0.17960595f, -0.07338861f, 0.05055304f, -0.07257267f, 0.17380740f, 
    0.06484303f, 0.05936762f, -0.14529650f, 0.07315749f, -0.18386903f, -0.68379986f, 0.00196869f, -0.51003599f, 
    0.10776576f, 0.04652391f, -0.00137266f, 0.14696535f, -0.04768513f, 0.05610063f, -0.12416209f, 0.02475595f, 
    0.09956500f, -0.29229817f, -0.40925300f, -0.29459271f, 0.01946746f, -0.00921600f, 0.11232291f, -0.08228774f, 
    0.06009828f, -0.04593503f, 0.08912327f, 0.00899837f, -0.06255455f, -0.10676038f, -0.04322718f, 0.01110665f, 
    -0.04185368f, -0.04552064f, -0.09194522f, -0.07903402f, -0.32712075f, -0.21023530f, 0.02008942f, 0.08147051f, 
    0.19534631f, -0.54439861f, -0.05367455f, 0.11070146f, 0.03459821f, -0.02406376f, 0.17559822f, -0.03725740f, 
    -0.05732661f, 0.01886261f, -0.03056694f, 0.01059624f, 0.37594435f, -0.12743343f, -0.19204673f, 0.21615885f, 
    0.06085161f, -0.16317993f, 0.07651690f, -0.18560779f, 0.18446688f, -0.04339372f, 0.40266588f, 0.58108974f, 
    0.07890964f, 0.53532076f, -0.44697717f, 0.42547709f, 0.29509938f, -0.00630352f, -0.10407139f, -0.19769977f, 
    0.10107166f, 0.09056082f, -0.15204027f, -0.18170476f, -0.50600886f, -0.16120316f, 0.11243402f, -0.02386340f, 
    -0.01359439f, 0.00161866f, 0.27217209f, 0.04386197f, -0.11217123f, -0.07171571f, -0.18271050f, -0.08722702f, 
    0.14830384f, 0.12246889f, 0.10503330f, 0.25368553f, -0.01317357f, -0.06158192f, 0.05992531f, -0.14606121f, 
    -0.02930238f, 0.12799947f, 0.07973406f, 0.01099708f, -0.05079439f, 0.21855259f, 0.17576857f, 0.04226153f, 
    -0.12588271f, -0.17571835f, 0.17101485f, 0.17190446f, 0.21411514f, -0.14622387f, -0.03465592f, 0.01006652f, 
    -0.05500261f, -0.22114030f, -0.08766225f, -0.00962319f, -0.07689556f, 0.00260185f, -0.22406082f, 0.02390858f, 
    0.16734967f, -0.09959781f, -0.00511446f, 0.19456334f, -0.19346635f, -0.18261422f, -0.30038702f, 0.11632855f, 
    0.07691430f, -0.14054602f, 0.32519320f, -0.08801572f, 0.15816914f, -0.15223236f, -0.04873098f, -0.07087176f, 
    -0.05632802f, -0.26791808f, 0.20786403f, 0.40327716f, -0.27011591f, -0.09886219f, -0.06461202f, 0.04629776f, 
    0.22744671f, -0.08717682f, 0.10475937f, 0.25138241f, -0.18881227f, -0.08036804f, 0.19198693f, 0.29887536f, 
    0.15639524f, 0.04957927f, -0.09556008f, 0.00788482f, 0.16660729f, 0.01486201f, -0.07411741f, 0.30865139f, 
    -0.00071636f, -0.08392348f, 0.60250860f, 0.08073365f, 0.04356581f, -0.03261098f, 0.24319249f, 0.17283344f, 
    0.18646836f, -0.11827879f, -0.28548950f, 0.01249636f, -0.06325028f, 0.49317983f, 0.10217259f, -0.76156610f, 
    0.04804325f, 0.01904457f, 0.05863624f, 0.03480582f, -0.02162078f, 0.02098616f, 0.00023880f, -0.01353001f, 
    0.22454102f, 0.01953535f, 0.23821434f, 0.12379254f, 0.06141590f, 0.23484805f, -0.25388652f, -0.20214629f, 
    -0.02060545f, 0.01629390f, -0.03015145f, 0.02892727f, -0.54535961f, -0.30167443f, 0.19555324f, -0.04412875f, 
    -0.05160781f, -0.04489766f, 0.00476605f, -0.04224968f, 0.19746137f, -0.14606875f, 0.09512051f, -0.03596414f, 
    0.35288617f, -0.36598435f, -0.42989379f, 0.29325640f, 0.02715006f, 0.16124943f, 0.11848758f, -0.00664685f, 
    0.00253641f, -0.14598086f, 0.11715925f, 0.09609491f, -0.21239205f, 0.03125222f, -0.22823486f, -0.40450430f, 
    0.03242067f, 0.00212939f, -0.17752290f, 0.14864039f, 0.06363425f, -0.12817195f, -0.20826980f, -0.02918107f, 
    0.04127465f, 0.20575589f, 0.56469202f, 0.11164528f, 0.00771057f, -0.07880893f, 0.06804691f, 0.01611201f, 
    -0.04366122f, 0.03077413f, -0.15221660f, 0.03681679f, -0.42593190f, 0.11858148f, -0.09991653f, 0.12869628f, 
    0.01942062f, 0.04666101f, -0.03037207f, 0.11783451f, 0.12024087f, -0.46891457f, -0.50886267f, -0.56268626f, 
    -0.09334222f, 0.05267097f, -0.43280131f, 0.02789396f, 0.22855146f, 0.18272512f, 0.29662636f, 0.09092441f, 
    0.16902812f, 0.02623763f, 0.05778362f, 0.01379660f, 0.64623266f, -0.71766651f, -0.24633902f, 0.42320764f, 
    0.00321597f, -0.36169603f, 0.02214820f, -0.00114676f, -0.05660471f, 0.22674337f, 0.06702193f, -0.01838174f, 
    -0.29925764f, 0.05289503f, 0.08203922f, -0.25702602f, 0.19501373f, 0.23214604f, 0.22796021f, -0.03792171f, 
    0.19680282f, 0.10976869f, 0.10917610f, 0.03462707f, -0.63756496f, -0.49398232f, -0.32105047f, -0.25885290f, 
    0.05344466f, -0.02766517f, -0.01460538f, -0.01561710f, 0.08238674f, -0.17746712f, 0.30067286f, -0.30739313f, 
    0.03450479f, -0.08424976f, -0.18986323f, 0.05434673f, -0.00834533f, -0.02226094f, 0.01555654f, 0.07772755f, 
    -0.09844254f, -0.10265858f, -0.33952370f, -0.22783886f, -0.65510464f, -0.53068292f, -0.17053454f, 0.08875638f, 
    0.25893134f, 0.27092472f, 0.13092360f, -0.26324931f, -0.03799071f, -0.10945936f, -0.01906826f, 0.04461952f, 
    -0.04273839f, -0.05555883f, 0.01505506f, 0.24729505f, 0.03080630f, -0.01588747f, 0.11315776f, 0.31749523f, 
    -0.00045357f, 0.01732122f, 0.00509715f, -0.28426579f, 0.06382774f, -0.05248573f, -0.21240471f, -0.06289453f, 
    -0.02394121f, -0.06602424f, 0.28626323f, 0.35481268f, -0.00292615f, -0.17234746f, 0.02655726f, -0.12490223f, 
    -1.18544555f, -1.11250448f, -0.43391418f, -0.06576011f, -0.18975797f, -0.15284850f, -0.27339208f, 0.07774720f, 
    -0.05476150f, -0.10662689f, 0.23216242f, -0.02213870f, -0.82598317f, -0.91190749f, -0.05997209f, 0.48398799f, 
    0.04441688f, 0.04273776f, -0.09980562f, 0.01994175f, 0.00799877f, 0.22739606f, -0.16395529f, -0.03107978f, 
    -0.64954734f, -1.56516051f, -0.92568761f, -0.41013902f, -0.07960705f, 0.03089200f, 0.03796769f, -0.41464686f, 
    -0.07102333f, -0.10077501f, 0.02137458f, -0.01907280f, -0.47210363f, -0.16912104f, -0.11079398f, -0.04340630f, 
    0.12648185f, 0.01938182f, -0.07331046f, -0.00561347f, 0.03941587f, -0.08045451f, 0.02462322f, -0.04114378f, 
    -0.41729152f, 0.15456070f, 0.23919384f, -0.43230543f, 0.02863634f, 0.04091074f, 0.13824373f, -0.15364107f, 
    -0.06768709f, -0.10682273f, 0.05201077f, 0.09644102f, 0.94637030f, 0.64421391f, -0.21499635f, 0.24595793f, 
    0.02963308f, -0.17904939f, 0.04881354f, 0.25925446f, 0.38644367f, 0.02014860f, 0.25830224f, -0.09853508f, 
    -0.09285895f, -0.53925478f, -0.34049830f, 0.13222553f, 0.21650599f, 0.17808184f, -0.06453348f, 0.01505871f, 
    0.04595318f, 0.00314662f, 0.12946969f, 0.16580068f, 0.00811707f, -0.05507078f, 0.02372373f, 0.00816918f, 
    0.07587489f, 0.14365645f, 0.15089986f, 0.08512854f, 0.21828169f, 0.51310736f, 0.31782654f, 0.05802121f, 
    0.53218627f, -0.26344773f, 0.02932097f, -0.27400541f, -0.06887002f, 0.13750462f, 0.22009422f, -0.30148548f, 
    0.04192913f, -0.10233036f, 0.29937306f, -0.10766554f, 0.65973961f, 0.15537283f, -0.41135749f, 0.00147168f, 
    -0.09475463f, -0.01005164f, 0.23195536f, 0.05072815f, -0.15321825f, 0.09270602f, -0.17450641f, 0.30106708f, 
    -1.00150478f, -0.99223697f, -0.48595196f, -0.31458831f, -0.41654280f, -0.57665509f, -0.32786262f, -0.32208490f, 
    -0.18356587f, 0.04273509f, -0.05420462f, -0.11727482f, -0.36294374f, 0.41473860f, 0.37314120f, 0.03815022f, 
    -0.12734541f, 0.05608085f, -0.13859323f, 0.00211470f, -0.05064468f, 0.04461841f, 0.04638555f, 0.14673738f, 
    0.10314416f, 0.10892582f, 0.06078659f, -0.06368554f, 0.13060339f, -0.05284050f, -0.07504455f, -0.02351595f, 
    0.05505687f, -0.05237848f, 0.02036288f, -0.01279420f, -0.13664354f, 0.12111086f, 0.10993534f, -0.19614005f, 
    -0.22769845f, -0.00968888f, 0.03431175f, 0.27090028f, -0.04447472f, 0.15793011f, -0.02347997f, -0.01432745f, 
    0.37359479f, -0.15716268f, 0.14070676f, -0.37051791f, 0.03701577f, 0.00537076f, -0.12619013f, -0.15403163f, 
    -0.06694172f, 0.03711042f, -0.19201604f, -0.30222562f, 0.12303744f, -0.15486133f, -0.04681329f, 0.08899417f, 
    -0.04817041f, -0.17220646f, -0.01405348f, -0.17711973f, -0.05512865f, 0.16449820f, -0.00617504f, -0.11296759f, 
    1.21918404f, -1.26458395f, -0.47363356f, 0.33756852f, 0.01745672f, 0.38271576f, 0.01268753f, -0.20658915f, 
    -0.08386683f, 0.16351229f, 0.08314835f, -0.09704908f, -0.92206216f, -0.39496768f, 1.19004464f, -0.47437730f, 
    -0.01300788f, -0.02524578f, 0.07982738f, 0.01665003f, 0.03682665f, -0.05707132f, 0.05950516f, 0.05651642f, 
    -1.01026988f, -1.12619340f, -0.01978664f, 0.82152987f, -0.02793058f, 0.14420691f, 0.11380631f, 0.20487219f, 
    -0.10869393f, -0.13123126f, -0.20193006f, -0.26867589f, 0.08743851f, -0.01993906f, 0.17339130f, -0.09615967f, 
    0.19649048f, -0.02797533f, 0.18615587f, -0.11526246f, 0.04736248f, 0.02138505f, -0.05601246f, -0.37941009f, 
    -0.18097289f, 0.13764447f, -0.15711644f, -0.33893955f, 0.06730691f, -0.12742265f, -0.06042033f, -0.00238306f, 
    0.10322902f, 0.02154288f, 0.05645509f, -0.21589243f, -0.66337651f, -0.22135000f, -0.16926615f, -0.15509585f, 
    -0.04087384f, -0.01252466f, 0.06909622f, 0.11511288f, -0.11360037f, 0.10522485f, 0.02911449f, 0.01534599f, 
    0.56201977f, -0.19503939f, 0.27373293f, -0.10344621f, 0.01041877f, -0.19850068f, -0.26987532f, -0.13358219f, 
    0.03606218f, 0.08143041f, 0.02928462f, 0.01555062f, 0.13473344f, 0.28944352f, 0.00913443f, 0.04866657f, 
    -0.02078373f, -0.14238127f, 0.11360578f, 0.00735420f, 0.01595165f, -0.10209865f, -0.09834550f, -0.04808261f, 
    -0.09824923f, 0.19280428f, 0.38607112f, 0.02124067f, -0.25738660f, 0.12776940f, 0.23253594f, 0.17217466f, 
    0.09755971f, -0.08111490f, 0.07578953f, -0.01949596f, 0.10398451f, -0.23943660f, 0.06433163f, -0.03846955f, 
    -0.01211191f, -0.01874004f, -0.19166155f, -0.13900308f, -0.02574499f, -0.05854117f, 0.05030764f, -0.13362931f, 
    -0.71276122f, -1.05671036f, -0.79653269f, -0.31287158f, -0.10453849f, -0.20191887f, -0.07071900f, 0.14638591f, 
    0.07086296f, 0.00274927f, 0.02643638f, -0.03112501f, 0.70654184f, -0.85600454f, -0.32320058f, -0.30763182f, 
    -0.09542874f, 0.00160987f, -0.04853061f, 0.01142519f, 0.19638853f, -0.21745893f, -0.03660703f, 0.25948438f, 
    -0.13473266f, -0.08319876f, -0.06790651f, -0.20633402f, -0.17606945f, -0.14460479f, -0.03542050f, -0.00263788f, 
    0.05562217f, -0.11737560f, -0.01721709f, 0.14718103f, 0.13736685f, 0.15107402f, 0.20730026f, -0.02047367f, 
    -0.00889149f, -0.07205336f, -0.00292673f, 0.01582696f, 0.10720785f, 0.05357365f, 0.00307224f, 0.06499697f, 
    0.20410030f, -0.04764368f, -0.14547613f, -0.31179428f, 0.24044183f, -0.21311529f, 0.20473616f, 0.05744523f, 
    0.05770987f, 0.14214423f, 0.20957471f, 0.36578572f, 0.31247354f, 0.11602809f, -0.23002881f, 0.15622087f, 
    0.24816726f, -0.38010266f, -0.04641629f, -0.09260055f, 0.03943028f, 0.23720720f, 0.39682567f, 0.33113524f, 
    0.64931595f, -0.10457633f, -0.46576607f, -0.76457334f, -0.03032877f, -0.13902719f, 0.20888673f, -0.11641145f, 
    0.03071840f, 0.00110076f, 0.06208160f, 0.00778927f, 0.50792092f, -0.59886265f, -0.29573953f, -0.02218550f, 
    -0.13791195f, 0.06487746f, -0.01902487f, -0.36840913f, 0.07336622f, 0.18596300f, 0.19555785f, 0.18376583f, 
    0.04623248f, -0.40762341f, -0.13570957f, -0.38893217f, 0.00784882f, -0.30380610f, 0.06596898f, -0.21522780f, 
    0.14123416f, -0.01064658f, 0.02541199f, 0.02503389f, -0.00779517f, -0.12126698f, 0.28881648f, -0.42660859f, 
    -0.32506400f, -0.02184485f, -0.09887600f, -0.24138772f, -0.02212533f, 0.06675375f, 0.19295113f, 0.39355296f, 
    -0.30255079f, 0.36361799f, 0.34961361f, -0.19606613f, -0.01750388f, -0.01613351f, -0.11198839f, -0.16968265f, 
    -0.15072490f, -0.03812367f, -0.20861310f, 0.05355155f, -0.91193104f, -0.45639992f, 0.23513740f, 0.26633370f, 
    0.01134271f, 0.07944964f, 0.06385885f, 0.21890083f, 0.00447523f, -0.10033904f, -0.06040070f, -0.02594822f, 
    0.49094915f, 0.60297316f, 0.59192050f, -0.45930105f, -0.02292201f, -0.17376341f, -0.12875000f, -0.00946204f, 
    -0.09081626f, -0.04076360f, -0.10061413f, 0.04961121f, -0.14220798f, 0.07376681f, -0.01643297f, 0.01231745f, 
    0.03441056f, 0.06806029f, -0.15713462f, 0.08188006f, -0.23754507f, 0.02648865f, -0.35385296f, -0.65835166f, 
    -0.99406731f, 0.11441293f, 0.37151194f, 0.32122040f, 0.14094844f, -0.08945671f, -0.22259049f, 0.06910285f, 
    -0.19938858f, -0.08946870f, 0.03642751f, 0.01046857f, -0.13119876f, 0.35038823f, 0.03103162f, -0.13965568f, 
    0.31468916f, 0.05874736f, -0.02590800f, 0.06600691f, 0.15477286f, -0.06234967f, 0.08251865f, 0.45302466f, 
    -0.52075368f, -0.96020991f, -0.67686576f, -0.15621890f, 0.00108368f, 0.04425966f, -0.12236834f, 0.01575816f, 
    -0.01363837f, 0.08175373f, 0.05570760f, 0.14449878f, -0.56196451f, -0.53890067f, -0.39105991f, 0.05103599f, 
    0.03855385f, 0.09305973f, 0.09702402f, 0.28951293f, -0.27043670f, 0.01201426f, -0.21857078f, -0.20788090f, 
    0.01940647f, -0.30162159f, -0.03743162f, 0.07081646f, 0.10841933f, 0.16476777f, 0.19460626f, 0.04716660f, 
    0.18213561f, -0.14641018f, 0.16795838f, 0.00196237f, 0.56731462f, -0.42685729f, 0.21719265f, -0.15729447f, 
    0.23073609f, 0.16526264f, -0.15401390f, 0.35383165f, 0.01970601f, -0.22726211f, -0.11533687f, -0.24420062f, 
    0.36970297f, -0.23420678f, 0.30474275f, 0.10327036f, -0.08611039f, -0.06254986f, -0.07288990f, -0.20016280f, 
    0.02613896f, 0.01806980f, -0.02420540f, -0.11596553f, -0.51782167f, 0.17728451f, -0.42450592f, 0.05523316f, 
    0.10549688f, -0.11022089f, 0.19648047f, -0.06745847f, -0.06765129f, -0.13676038f, -0.19429773f, -0.07901217f, 
    -0.05516672f, -0.79233396f, 0.36574170f, 0.51893383f, 0.24879937f, -0.01221721f, -0.01019870f, 0.06764171f, 
    -0.22344530f, 0.00622358f, -0.10231931f, -0.01388229f, -0.00744720f, -1.03821933f, 0.18277372f, -0.41860887f, 
    -0.13072063f, -0.20736456f, -0.13900618f, 0.03288150f, -0.19790018f, -0.03572675f, -0.07967593f, -0.00402582f, 
    0.38927040f, 0.08149475f, -0.66104484f, -0.04902700f, 0.11491399f, -0.05303417f, 0.04032596f, 0.32199988f, 
    -0.02732024f, 0.26274368f, 0.13342215f, -0.21882078f, -0.06097946f, -0.25131902f, 0.37605834f, -0.23642167f, 
    0.17232671f, 0.07882755f, -0.11693965f, 0.09307933f, -0.15815994f, -0.01557373f, -0.04138641f, 0.03328396f, 
    -0.05658159f, -0.55172414f, -0.43299830f, 0.18858537f, 0.19295222f, 0.10608876f, 0.11599379f, -0.03313936f, 
    0.06794544f, -0.09515039f, 0.19903594f, -0.00209851f, 0.03787107f, 0.52781814f, 0.76187223f, -1.22004879f, 
    0.00507897f, -0.29499459f, 0.01480051f, 0.08343330f, -0.18795732f, 0.10306757f, 0.12292840f, -0.06586755f, 
    -0.41655824f, -1.30869925f, 0.46153274f, 0.12790327f, -0.06741299f, 0.26380053f, 0.10889672f, 0.15614042f, 
    -0.03882987f, 0.13153863f, 0.14209999f, 0.02173683f, -0.34427929f, -0.02002257f, -0.03383893f, 0.15215904f, 
    0.03334134f, 0.18039557f, 0.10225287f, 0.07963397f, 0.16854174f, -0.07642905f, 0.30525979f, 0.17021668f, 
    0.26872858f, -0.03383970f, -0.56021798f, -0.28405532f, -0.06796230f, 0.08409743f, 0.05780997f, 0.02565982f, 
    0.03729070f, -0.18157749f, -0.11637788f, 0.03903698f, -0.21019560f, 0.36873662f, -0.07756025f, -0.10800263f, 
    -0.02368334f, -0.22761054f, -0.00416897f, -0.35934955f, 0.15306611f, -0.18178669f, -0.29794618f, -0.10466980f, 
    -0.49217197f, 0.10304711f, 0.26434675f, -0.61812711f, 0.06215361f, -0.10599843f, -0.27954108f, 0.29551038f, 
    0.12446088f, -0.04732011f, 0.06123168f, -0.11146185f, 0.23368296f, 0.25507623f, 0.54788512f, -0.17041074f, 
    -0.08320101f, -0.24814700f, -0.12220010f, -0.42864576f, 0.11771914f, 0.10113631f, 0.09922545f, 0.22187740f, 
    -0.29331052f, -0.28635225f, -0.50370592f, -0.51737636f, -0.31560060f, -0.10765866f, -0.52910167f, -0.21523912f, 
    -0.07847806f, 0.23909791f, 0.24802691f, 0.15831234f, -0.42145696f, 0.02914532f, -0.15510067f, -0.17027235f, 
    -0.08623456f, 0.48823345f, -0.01871944f, -0.14952421f, 0.13773388f, 0.18406780f, 0.11894640f, 0.12927641f, 
    -0.64828014f, 0.23364319f, -0.24640937f, -0.02302140f, 0.02926297f, 0.22909288f, 0.29773447f, -0.34144938f, 
    -0.04916508f, -0.05901612f, 0.25516653f, 0.04903518f, -0.03511126f, 0.02230630f, 0.54164386f, 0.38736615f, 
    -0.14407574f, 0.20454612f, 0.32678431f, 0.21584028f, 0.06569542f, 0.16648342f, 0.20385043f, 0.12355132f, 
    -1.04649651f, 0.38842165f, -0.60547537f, 0.17277409f, -0.01341756f, 0.33956882f, -0.06505945f, 0.11730593f, 
    -0.18160537f, 0.02617384f, -0.15306424f, 0.00165364f, -0.13661326f, 0.47620460f, 0.15624852f, 0.66609323f, 
    -0.05406041f, 0.23140697f, -0.09481738f, -0.07933781f, 0.12792028f, 0.19332552f, 0.23102443f, 0.02356154f, 
    -0.30318752f, 0.14536729f, -0.63385957f, -0.03337340f, -0.14517672f, 0.13454552f, 0.02112948f, -0.12519938f, 
    -0.17174970f, 0.18660547f, 0.08029460f, -0.18720737f, -0.73375201f, 0.12804717f, 0.23187341f, 0.37225866f, 
    -0.02564977f, -0.16076149f, 0.06800528f, 0.02956356f, 0.05711486f, -0.06787660f, 0.04937143f, 0.01429676f, 
    -0.35238385f, 0.89908832f, 0.08039898f, 0.09405620f, -0.24998134f, -0.21484670f, 0.06420597f, 0.20666800f, 
    0.09747211f, 0.15991457f, 0.23160028f, 0.11120285f, 0.27936012f, 0.31527624f, -0.00444207f, 0.68999326f, 
    0.09370449f, -0.09811548f, 0.05787571f, 0.05746230f, -0.05563306f, 0.02778389f, 0.19567636f, -0.07881172f, 
    -0.48463452f, -0.64503908f, -0.40738934f, 0.07173603f, -0.01601689f, -0.01166680f, -0.17515844f, -0.22577676f, 
    0.02813924f, -0.14063786f, -0.41492477f, -0.10992809f, 0.39938590f, -0.17756274f, 0.20717129f, -0.48624697f, 
    -0.09330148f, -0.17314093f, -0.06261383f, 0.02302921f, -0.19108732f, -0.35905337f, -0.56127292f, -0.30717644f, 
    0.34919852f, -0.55031729f, -0.26172757f, 0.44055840f, -0.13600861f, -0.38285515f, 0.18392554f, -0.09702494f, 
    -0.33935300f, 0.09601317f, -0.38744304f, -0.01941930f, -0.60276818f, 0.25411677f, -0.59230864f, 0.00504773f, 
    -0.26294827f, 0.08733939f, 0.16466439f, -0.06646062f, 0.02901455f, -0.10532017f, 0.17902283f, 0.04373817f, 
    -0.17786425f, -0.52901876f, -0.09279623f, 0.18424664f, -0.25750545f, -0.03584308f, -0.25452533f, 0.12997785f, 
    -0.04867872f, 0.09883930f, 0.21359295f, 0.21783443f, 0.30315438f, -0.23159039f, 0.09217259f, 0.01325307f, 
    0.17636819f, -0.23548596f, -0.05099190f, 0.11702560f, -0.26365495f, 0.14099610f, -0.38492668f, -0.42010641f, 
    0.21629578f, 0.09790378f, -0.11233708f, -0.13174559f, -0.02065077f, 0.07595318f, 0.13047896f, 0.04547020f, 
    -0.16934817f, 0.07544303f, -0.13921624f, -0.22309919f, 0.42902741f, 0.38054401f, 0.22100228f, -0.34054235f, 
    0.06813428f, 0.06322166f, -0.22948231f, -0.04091486f, -0.13405368f, -0.04000675f, -0.06061175f, -0.06560344f, 
    -0.31493291f, 0.29929048f, -0.12096933f, 0.28885636f, -0.07827761f, -0.23149534f, 0.12876995f, 0.09679759f, 
    0.23548751f, 0.01314552f, 0.08397951f, -0.38789922f, 0.52308995f, -0.20831889f, 0.62023479f, -0.39774665f, 
    0.06703768f, 0.38186920f, -0.07030086f, 0.12758434f, -0.11344089f, -0.12156674f, 0.11479630f, -0.18161321f, 
    -0.34213433f, 0.00900981f, -0.45815974f, 0.70534313f, -0.03032618f, -0.34808719f, 0.15108135f, -0.16007727f, 
    0.18134759f, 0.08783715f, 0.30248749f, 0.05805933f, -1.17583632f, 0.10514974f, -0.66972208f, 0.63395256f, 
    -0.23329078f, -0.13758020f, -0.10720168f, 0.55833113f, -0.02872280f, -0.02511376f, -0.01344547f, -0.22617428f, 
    0.59803545f, -0.47486338f, -0.14604123f, 0.35715148f, -0.30975324f, -0.48470441f, -0.12085760f, -0.07631027f, 
    0.09833752f, -0.02097744f, 0.08494250f, 0.20167395f, -0.81754714f, 0.19594866f, -0.80532646f, 0.56925631f, 
    -0.17603463f, 0.09431294f, -0.11501542f, 0.20103353f, -0.28424227f, -0.19157404f, -0.08565117f, 0.10890480f, 
    0.52748609f, -0.19458757f, 0.07459914f, 0.45775637f, -0.24365458f, 0.08717986f, -0.23320261f, 0.22403933f, 
    -0.20835246f, -0.00189340f, -0.16104840f, -0.03883968f, -0.52817720f, -0.13614230f, 0.48914266f, 0.09802717f, 
    -0.11177461f, -0.06979185f, -0.01261438f, 0.27047631f, -0.12651497f, -0.05163699f, -0.23631833f, 0.03049689f, 
    -0.38403508f, -0.05260118f, -0.06971261f, 0.13345340f, -0.01239709f, -0.07851248f, 0.27444914f, -0.35558978f, 
    0.05980416f, 0.02816107f, 0.08561803f, 0.29029366f, 0.03836863f, 0.02412623f, 0.00635488f, -0.10890839f, 
    0.01669764f, 0.11398937f, 0.04258072f, 0.00749912f, 0.16856571f, 0.18898761f, 0.21575055f, 0.02864033f, 
    0.20193671f, 0.11294281f, 0.47717488f, 0.26391131f, -0.03623451f, -0.13699323f, 0.06968255f, -0.19852646f, 
    0.11515723f, -0.19486599f, 0.09719594f, -0.07455644f, 0.56970042f, -0.13686152f, 0.03770046f, 0.37096825f, 
    0.04329232f, 0.04869551f, 0.08931421f, 0.28162861f, -0.02869254f, 0.15738922f, 0.13273296f, -0.09002247f, 
    -0.24232721f, -0.17298882f, -0.33290651f, -0.10742816f, -0.24909085f, -0.09872928f, -0.08698080f, -0.21399644f, 
    -0.00127446f, -0.04356179f, -0.09256034f, -0.29201916f, -0.28161275f, 0.02797963f, -0.26229438f, -0.41345462f, 
    0.05754631f, -0.04058548f, -0.01073528f, -0.15769415f, -0.06967338f, 0.16695681f, 0.08406742f, -0.00704502f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.31740668f, 0.04076733f, 0.30495539f, -0.20432791f, -0.10193524f, 0.07188581f, 0.06794498f, -0.24897566f, 
    0.18072434f, -0.07011072f, -0.03296608f, 0.00582104f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
