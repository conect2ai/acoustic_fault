#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.66881859f, 0.94398767f, 0.87757510f, 0.71603101f, 0.80719626f, 0.68493181f, -0.28056699f, -0.11456987f, 
    -0.02599085f, -0.42231008f, -0.24908210f, 0.75759119f, 0.91951013f, -0.34962660f, 0.46974728f, -0.69213241f, 
    -0.74342042f, -0.65136933f, 1.12842977f, 1.13786149f, 0.78938329f, -0.80664647f, 0.13442190f, -0.60546511f, 
    0.90621924f, 0.30321530f, 0.19124283f, -0.87337792f, 0.48132846f, 0.80235785f, -1.29078531f, 1.16104615f, 
    -0.17378449f, -0.54227811f, -0.52677107f, -0.10213850f, 0.97593856f, -0.65975213f, -0.98309499f, -0.61692983f, 
    -0.68961197f, -0.17782007f, -0.89518511f, -0.47577876f, -0.16170163f, -0.80948114f, -1.02811646f, 0.30546305f, 
    -1.27219605f, -0.77612525f, -0.20737700f, 0.53407055f, -0.13496116f, -0.17898962f, -0.87583697f, -0.72388101f, 
    -0.38752618f, 0.98713434f, 1.36839926f, 0.51522201f, -0.11278308f, -0.29335842f, 0.10765646f, 1.23515844f, 
    1.16976893f, 0.82015759f, 0.00465530f, -0.95336401f, -0.53245920f, -0.53661799f, -0.18671240f, 0.23584501f, 
    0.97057313f, 0.59510583f, -0.15727036f, 0.48378092f, 0.33529514f, -0.19169159f, 0.70110619f, 1.03675759f, 
    -0.40970185f, -1.56769717f, 0.58763641f, 0.90901589f, 0.93014562f, 0.70531344f, -0.34178180f, 0.06908556f, 
    0.43870664f, 0.34707835f, -0.91011286f, -0.82984746f, -0.93358964f, -0.52654082f, 1.13953400f, -0.43244630f, 
    0.43672377f, -0.10468614f, -0.00291529f, -1.72855628f, 0.75534034f, -0.54357928f, 0.57506466f, 0.85473716f, 
    0.72799337f, 0.59416610f, -0.30724117f, 0.63354832f, -0.06778155f, 0.49916437f, -0.16567460f, -1.19725418f, 
    -1.06834710f, -0.19877619f, 0.65987861f, -0.22212015f, 0.78481060f, -1.04473400f, 1.10804939f, -0.03865095f, 
    1.16853571f, -0.26275176f, -0.82330275f, -0.30096537f, -0.58717215f, -0.48114216f, -0.06206353f, -1.17708266f, 
    -0.69782573f, 0.87728983f, -0.31187889f, 0.95878875f, -0.19647139f, -0.23449595f, -0.29670841f, 1.24498606f, 
    -0.37128061f, 1.11370170f, 0.69162911f, -1.07855034f, 0.70208973f, 0.02326195f, -0.03210109f, -0.32098937f, 
    0.48596308f, 0.53558928f, 0.57834059f, 1.25078785f, 0.65746081f, -1.08326662f, 0.22519523f, 0.51362896f, 
    -0.39097187f, -1.24181879f, -0.39554310f, 0.97241640f, -0.00498648f, -0.17276187f, 1.07223558f, 0.32614174f, 
    -0.37683451f, -0.17129400f, 0.24277090f, 0.57366413f, -0.54927683f, -0.53232288f, -0.66936934f, -1.23558307f, 
    -0.23932931f, -0.36098593f, 0.29090840f, 0.41888407f, 1.44412911f, -1.12682068f, 0.91449761f, -0.41765735f, 
    -0.49167666f, 0.01024629f, 0.18079895f, -0.34832320f, 1.03134346f, 0.47647032f, 0.25620547f, 0.60716277f, 
    -0.19779003f, 0.82828397f, -0.63823366f, 0.76867485f, -0.74850756f, -0.81048137f, -0.65489209f, -0.53846312f, 
    -0.40216997f, 0.60060298f, -1.07063746f, -0.49552584f, -0.26328796f, -1.22308123f, -1.12729037f, -0.70806819f, 
    -0.54952061f, 0.59874344f, -0.30122328f, 0.42671248f, -0.61269921f, -0.18176796f, -0.46460792f, 1.37279212f, 
    0.18849608f, 1.38073540f, -0.28151891f, -0.07062177f, -0.02616204f, 0.14510913f, -0.69691002f, -0.46708471f, 
    -0.65854430f, -1.44644713f, -1.18987441f, -0.62028122f, -0.03673825f, -0.27436805f, 0.47430778f, 0.50166184f, 
    0.45186609f, 0.92142916f, 0.89549577f, 0.46622625f, -0.68123972f, -0.92911786f, 1.04529345f, 0.10015284f, 
    0.39291424f, 0.12729380f, -0.69601542f, -0.96173757f, -0.85932124f, -0.80280936f, 0.77966076f, 1.18315220f, 
    -0.36511299f, -0.17434759f, -0.23461051f, 0.03731081f, 0.65214330f, 0.51019973f, 0.73523432f, 0.77272278f, 
    0.95525712f, 0.40987891f, -0.68677062f, -0.72967428f, 1.09155715f, -0.99764079f, 0.43707103f, 0.76603591f, 
    0.22305168f, 0.51584846f, 0.07203057f, -0.60165912f, -0.18372191f, 0.74217021f, -0.92534548f, 0.07966045f, 
    -1.21092951f, 0.07318053f, 0.69677103f, 0.02899246f, 0.27546820f, 0.98553997f, -0.45442364f, -0.45179880f, 
    0.55809391f, -1.12487471f, 0.39003524f, -0.70342201f, 0.57486016f, 0.73199499f, -0.29101962f, 0.09271532f, 
    0.49617106f, 1.03899634f, 0.09342262f, -0.20462215f, -1.01295841f, -0.03406036f, 0.84888846f, 0.65459514f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27404797f, -0.40467274f, 0.16047090f, 0.40978679f, -0.14571917f, 0.14491706f, 0.02472643f, -0.01760195f, 
    0.05705601f, 0.32575294f, 0.29846168f, 0.18021449f, 0.15754707f, -0.09460255f, -0.16286965f, 0.04631658f, 
    0.18966208f, -0.21777564f, 0.39419425f, -0.00477795f, -0.02536168f, -0.30215284f, -0.25184149f, 0.16553634f, 
    0.31055763f, 0.07671904f, -0.00993731f, -0.04396885f, 0.09770010f, -0.28979999f, -0.02954928f, 0.17705815f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.09638991f, -0.20937778f, -0.18948297f, 0.02114011f, 0.04962128f, -0.04214671f, -0.09960210f, 0.03930813f, 
    0.07231853f, -0.41397914f, -0.24834792f, -0.16650076f, 0.08797048f, 0.07672347f, -0.14632569f, -0.32446545f, 
    -0.00360774f, -0.08428904f, 0.39291734f, -0.31043702f, -0.06714440f, 0.17192413f, 0.03402701f, 0.10857870f, 
    -0.03452640f, 0.09291515f, 0.02847630f, -0.27737582f, 0.13208206f, -0.00024016f, 0.12079901f, -0.08986255f, 
    0.15788890f, -0.34597975f, -0.06772849f, 0.08420929f, 0.15692511f, 0.17354855f, -0.20067704f, -0.09935587f, 
    -0.13376071f, 0.19071807f, -0.12496528f, -0.00601456f, 0.09481429f, -0.15276073f, 0.41505057f, -0.14308512f, 
    -0.14348823f, 0.07169855f, 0.07967302f, -0.22897339f, 0.01107923f, -0.17519663f, -0.14154249f, 0.12099864f, 
    0.08627351f, -0.29888654f, 0.05370291f, -0.25161541f, -0.12904508f, 0.11804708f, -0.04647962f, 0.58718812f, 
    -0.04242283f, 0.15188676f, 0.11837421f, -0.09622575f, 0.09138048f, 0.13973071f, -0.08809541f, 0.21198864f, 
    0.25066200f, -0.28476045f, -0.16547666f, -0.04445294f, -0.11948957f, 0.06884990f, 0.19778113f, -0.08583937f, 
    0.07476482f, -0.31173670f, 0.07000378f, -0.06475317f, 0.12966157f, -0.01689941f, -0.06585572f, -0.03230625f, 
    -0.04005635f, 0.09467565f, -0.08707417f, 0.21769232f, -0.00000844f, 0.08696357f, 0.10860971f, -0.09379233f, 
    -0.02577319f, -0.07459603f, -0.27483234f, -0.38261777f, 0.15254708f, 0.13544197f, -0.04240204f, 0.10495896f, 
    -0.14685637f, -0.08276322f, 0.05929529f, 0.04356555f, 0.25987881f, 0.11002219f, -0.25001657f, 0.04210067f, 
    -0.10003143f, 0.25640491f, -0.08780988f, 0.08169701f, -0.26529583f, -0.32850322f, -0.28367975f, -0.09651042f, 
    -0.00840949f, 0.03755719f, 0.12331001f, -0.00276903f, -0.12870023f, -0.15693763f, 0.17429353f, -0.03102869f, 
    -0.20129509f, 0.18385430f, 0.25589049f, -0.22185776f, 0.08845790f, 0.10883255f, -0.06073796f, 0.10717024f, 
    -0.24264212f, -0.10133842f, 0.13310193f, 0.02745053f, -0.07109623f, 0.23018500f, 0.06458650f, 0.01015620f, 
    0.20664461f, -0.17214680f, -0.14854427f, -0.05457907f, -0.05308350f, -0.03354951f, 0.04432638f, -0.00986566f, 
    0.13933894f, -0.24986413f, 0.04901599f, -0.03528112f, 0.05628610f, 0.08143903f, -0.08991230f, -0.12995186f, 
    0.21546824f, -0.11140501f, 0.13282360f, 0.02321113f, -0.06453456f, 0.05485816f, 0.05527004f, 0.04017762f, 
    -0.06455772f, 0.01646348f, -0.12175309f, 0.60573763f, -0.29726717f, -0.11362624f, 0.12273425f, -0.04755784f, 
    -0.02906846f, -0.02473435f, 0.08388124f, -0.01090461f, -0.02862954f, -0.05909906f, 0.15570597f, 0.08804510f, 
    0.00835951f, -0.13646962f, 0.06244807f, -0.04848251f, -0.17489851f, 0.04842030f, 0.28455868f, -0.08534406f, 
    0.10687654f, 0.09733976f, 0.19112276f, -0.12769228f, 0.01002929f, 0.06025979f, 0.21724552f, 0.18289711f, 
    -0.02145113f, -0.19256224f, -0.06103121f, 0.11493791f, -0.15892042f, 0.02452178f, 0.13363995f, -0.00727688f, 
    -0.16087294f, 0.05830512f, 0.23647310f, 0.17610362f, 0.20674315f, -0.06665232f, 0.00844274f, 0.18629570f, 
    0.00339527f, 0.35889214f, -0.21149012f, -0.02352748f, -0.25918800f, 0.19199289f, 0.07139944f, 0.12687100f, 
    -0.29739237f, 0.49743709f, -0.21765122f, -0.05492478f, 0.15670055f, -0.06683979f, 0.23172475f, 0.10864843f, 
    0.02318295f, -0.13313043f, -0.04269340f, 0.30716720f, 0.29720333f, -0.11680856f, -0.18499312f, -0.42421743f, 
    0.22155727f, 0.03122517f, 0.09967492f, -0.19833849f, -0.14600033f, -0.18806027f, 0.06024119f, 0.09307165f, 
    -0.23130807f, -0.10117564f, 0.09339151f, 0.13712774f, -0.32730630f, -0.19966410f, -0.13309798f, 0.31519750f, 
    0.14019288f, -0.09172799f, 0.03430133f, 0.19648302f, 0.05098491f, -0.45329806f, 0.16315135f, 0.08990294f, 
    -0.01454916f, -0.43489265f, 0.19142453f, 0.21874526f, -0.09496520f, 0.03692802f, 0.06434709f, 0.26195285f, 
    -0.40550619f, 0.02004262f, 0.08827388f, 0.23696065f, -0.18845332f, -0.00507245f, -0.04037489f, 0.27794608f, 
    -0.06056681f, -0.01713275f, 0.03685649f, 0.04680485f, 0.04324928f, 0.13671535f, -0.00880522f, 0.10272522f, 
    -0.03628324f, 0.01141872f, -0.00498570f, -0.03783444f, -0.04760711f, 0.04559003f, -0.06521486f, 0.04172644f, 
    0.01161175f, -0.02350496f, -0.06342452f, -0.02539016f, -0.05661843f, -0.05694116f, 0.01786892f, 0.04585582f, 
    0.02069611f, 0.01520312f, -0.03475735f, 0.02571035f, -0.03041007f, 0.02849054f, -0.00281728f, -0.01857680f, 
    0.01593354f, 0.04292450f, -0.05195842f, -0.05844804f, -0.04612761f, 0.04821057f, -0.06596387f, -0.00766198f, 
    -0.03390676f, -0.01080607f, -0.02722112f, -0.05701267f, 0.03680387f, -0.05518451f, -0.00943014f, 0.04554452f, 
    -0.00188399f, 0.03616778f, -0.06529632f, -0.05335795f, 0.03876286f, 0.03844945f, 0.01166936f, 0.01315601f, 
    0.01191840f, 0.01626959f, -0.03098099f, -0.02404281f, 0.01515221f, 0.00092993f, 0.02141852f, -0.01377107f, 
    -0.03032789f, 0.05021721f, 0.01272365f, -0.01699587f, -0.05885785f, -0.01587625f, -0.06130686f, 0.04698545f, 
    -0.00949216f, -0.03060538f, -0.05689988f, -0.02182839f, 0.03991156f, 0.01867291f, -0.02485655f, -0.03933743f, 
    -0.05726074f, 0.00647380f, 0.04012660f, -0.04749754f, -0.06258553f, -0.03161212f, -0.04010000f, 0.01912044f, 
    0.04621112f, -0.02670991f, 0.03701304f, -0.03245080f, 0.00947195f, -0.02660944f, -0.01606719f, 0.02747544f, 
    0.02066001f, -0.01274257f, 0.00553799f, 0.00739115f, -0.06854391f, -0.01284743f, -0.01399575f, 0.01077778f, 
    0.00101366f, -0.00347778f, 0.01443270f, -0.01756451f, 0.04694388f, 0.02347314f, 0.03216270f, -0.07009497f, 
    -0.06620522f, 0.00266753f, 0.00714998f, -0.04356977f, -0.01937509f, 0.00242777f, 0.01961166f, 0.01376751f, 
    -0.03909728f, -0.05825493f, -0.03364278f, -0.06271065f, 0.02005655f, -0.00487526f, -0.05296958f, 0.02161882f, 
    0.00889452f, -0.02557991f, -0.05092003f, 0.04043979f, -0.05420163f, -0.04434537f, -0.05138092f, -0.02989777f, 
    0.03964740f, 0.02348784f, 0.02314079f, 0.02186722f, 0.01162164f, 0.02471377f, 0.02805240f, -0.04298761f, 
    0.00262725f, 0.03646309f, -0.03425789f, -0.03122485f, 0.03881180f, 0.00210926f, -0.04481675f, -0.06713114f, 
    -0.01497911f, 0.03348998f, -0.04128675f, 0.00735699f, -0.05714768f, -0.00105895f, 0.02252251f, 0.00615624f, 
    0.03273677f, 0.04151158f, 0.03911140f, -0.01648259f, -0.05105717f, -0.02950892f, 0.03968314f, -0.04094225f, 
    -0.00797219f, -0.05150636f, -0.02106137f, -0.06381798f, -0.02731736f, 0.03397409f, -0.02380420f, 0.02224702f, 
    -0.04958378f, -0.01488615f, -0.01614002f, -0.03908470f, -0.05127425f, 0.00626665f, 0.00672778f, -0.03125528f, 
    -0.02026636f, -0.00329890f, 0.02390119f, -0.05640987f, -0.06499780f, 0.03947465f, -0.06752905f, 0.04292195f, 
    -0.05485255f, 0.02884763f, -0.03099785f, -0.02627773f, 0.04559106f, 0.01567690f, 0.04256933f, -0.02369592f, 
    -0.00774996f, -0.02831061f, -0.04824182f, -0.03689854f, 0.04448302f, 0.00792105f, -0.03930279f, -0.06164535f, 
    0.02827139f, 0.01225777f, 0.00180004f, 0.02877384f, -0.04459324f, -0.01271283f, 0.04908797f, -0.05059823f, 
    -0.00841202f, 0.04403307f, 0.01273202f, -0.04769207f, -0.00294700f, -0.02618408f, 0.02460874f, -0.01984873f, 
    -0.01872682f, 0.04152983f, -0.03723346f, 0.03326140f, 0.01295526f, 0.00461261f, -0.06793094f, 0.02415446f, 
    -0.06614237f, -0.01816908f, -0.00619668f, -0.01937430f, -0.00992001f, -0.00094194f, -0.01769086f, -0.03605143f, 
    0.04341785f, 0.04239797f, -0.04494896f, -0.01359399f, -0.00700066f, -0.05631227f, 0.03505599f, -0.03311227f, 
    0.00202202f, -0.06409445f, -0.06010787f, 0.02680091f, 0.01931569f, 0.01176220f, 0.03636285f, 0.00995610f, 
    -0.00615602f, -0.01705163f, -0.03922826f, 0.01195626f, -0.06101281f, -0.03230888f, -0.03488958f, 0.04023298f, 
    0.04143905f, 0.03663725f, -0.02191636f, -0.05732499f, -0.00505334f, 0.04337436f, 0.03805239f, -0.02411792f, 
    0.01029412f, -0.00896154f, -0.00151162f, -0.03110566f, -0.00490930f, 0.00809167f, -0.01293307f, -0.01912286f, 
    0.03424828f, -0.04983748f, 0.00486813f, -0.03497258f, -0.05414463f, -0.00594689f, -0.03340893f, -0.01415140f, 
    -0.01755285f, -0.04910889f, 0.03492453f, 0.00316962f, 0.01600615f, 0.01542309f, 0.01027302f, -0.06815492f, 
    0.04951094f, 0.03167462f, -0.05493902f, 0.04807355f, -0.04216499f, 0.02161944f, -0.06791162f, 0.03965593f, 
    0.00085800f, 0.03431264f, -0.06271933f, -0.02214069f, 0.00115639f, -0.05316077f, -0.05939602f, -0.05720112f, 
    -0.02215206f, -0.04967549f, -0.03516226f, -0.01788551f, -0.00101504f, 0.00635678f, -0.01926810f, -0.05850941f, 
    -0.01490256f, -0.00631408f, 0.04855465f, 0.01507753f, 0.00277182f, 0.04937135f, 0.05342545f, -0.05319494f, 
    0.04570191f, 0.03335577f, -0.05009862f, 0.03592676f, 0.04786820f, 0.01361447f, -0.05609874f, 0.04072275f, 
    -0.05975523f, 0.02791962f, -0.01724901f, 0.01378892f, -0.03926875f, -0.00998247f, -0.04393675f, 0.05575054f, 
    0.01246612f, -0.03223552f, -0.02049663f, -0.05685700f, -0.05561184f, -0.03816315f, 0.00689286f, 0.03049182f, 
    0.01725300f, 0.02654777f, -0.03353626f, -0.00163305f, 0.02942130f, -0.00803951f, -0.04057648f, 0.00614655f, 
    0.03585436f, 0.05128492f, 0.02239012f, 0.01551506f, -0.06178079f, -0.05161606f, -0.02819136f, -0.06221761f, 
    0.01312994f, 0.02479842f, -0.02133027f, 0.00723514f, -0.02936645f, -0.03421735f, -0.02806809f, -0.03890900f, 
    0.01119626f, -0.04232983f, 0.02102856f, 0.03154835f, -0.03320072f, -0.01641934f, 0.02886572f, -0.02221991f, 
    0.01424820f, 0.01064506f, -0.04678630f, -0.01080457f, -0.03236876f, -0.06277670f, 0.00098408f, -0.04707203f, 
    0.02781208f, 0.03974606f, -0.03923183f, -0.02855358f, -0.05142732f, -0.06254394f, -0.01389324f, 0.01544660f, 
    -0.02383381f, -0.01259759f, -0.03569526f, 0.04139379f, 0.04609234f, -0.00557049f, -0.01388012f, 0.01564127f, 
    -0.02437467f, 0.01294015f, -0.04099407f, -0.00653074f, 0.00648679f, -0.04778598f, -0.00643676f, 0.00184722f, 
    -0.06068816f, 0.01606222f, -0.00510287f, -0.01905553f, -0.00378336f, 0.00906489f, -0.01605553f, 0.01980211f, 
    0.01932813f, -0.01103337f, -0.01181144f, 0.04462785f, -0.02679393f, 0.02566992f, -0.01195174f, -0.06801012f, 
    0.03851805f, 0.00596421f, 0.04382583f, 0.03297215f, -0.00715130f, -0.00292796f, -0.06454820f, -0.03001579f, 
    -0.02534037f, 0.04162407f, -0.01607693f, -0.03565328f, 0.01502999f, -0.03220972f, 0.02595073f, 0.01746464f, 
    0.04351470f, -0.03208132f, -0.03294785f, 0.04718896f, -0.01559237f, -0.04942213f, -0.02869337f, -0.05661374f, 
    0.05653011f, 0.02537888f, -0.02762602f, -0.03583273f, -0.04764840f, -0.01947210f, -0.04428335f, -0.03543450f, 
    -0.04760795f, 0.00672965f, -0.02137339f, -0.04695834f, -0.06455753f, -0.03942989f, 0.03717791f, -0.04388958f, 
    -0.06461301f, 0.05167005f, -0.01026446f, -0.01737932f, -0.01229628f, -0.02358676f, 0.00181442f, 0.05162633f, 
    -0.01114846f, 0.02053339f, -0.04918541f, -0.05994932f, -0.02112590f, 0.00621876f, 0.03472042f, -0.00540143f, 
    0.02004432f, -0.05004026f, -0.04861470f, -0.04113792f, -0.01876477f, 0.00297008f, 0.00588733f, -0.04969570f, 
    0.00667375f, -0.05470587f, 0.00256720f, -0.01675533f, 0.00820287f, -0.03739753f, -0.02106008f, -0.02606034f, 
    -0.05165105f, -0.05457459f, -0.01614179f, -0.04614536f, -0.03323695f, 0.01735163f, 0.04283096f, -0.06159141f, 
    0.03397745f, -0.02711129f, 0.02895061f, -0.00762202f, -0.03003302f, 0.04647641f, 0.01525101f, 0.04523094f, 
    -0.05931007f, 0.00430378f, 0.00158179f, 0.02719940f, 0.03824144f, -0.04443660f, -0.01477327f, 0.02898392f, 
    -0.02674199f, -0.03958875f, -0.00784775f, -0.00771435f, -0.05010619f, -0.01800412f, 0.01625215f, 0.02762777f, 
    0.00820350f, -0.04407943f, -0.04480780f, 0.01163790f, -0.05026103f, -0.06034957f, 0.00203173f, 0.04662366f, 
    0.02650952f, -0.03259482f, -0.01971531f, -0.04166443f, 0.04585953f, 0.03896907f, -0.06136342f, -0.02910852f, 
    -0.01034798f, -0.05283185f, 0.04843378f, 0.03974186f, -0.00742113f, 0.00549732f, -0.05718995f, 0.05030465f, 
    0.01226426f, 0.04697151f, -0.04509722f, 0.04380713f, 0.00822515f, -0.02175135f, -0.02778473f, -0.01819380f, 
    -0.04860487f, 0.02438768f, -0.03695321f, -0.00509307f, -0.00925088f, -0.01167860f, 0.00326005f, -0.02330082f, 
    -0.00123803f, 0.01871776f, 0.00439812f, 0.00477140f, 0.02901617f, -0.04180126f, -0.03373395f, 0.02868182f, 
    0.19396754f, -0.02437769f, -0.00731943f, -0.06424808f, -0.17375115f, -0.08023140f, 0.10632222f, -0.04943266f, 
    -0.11858980f, 0.18694320f, 0.04997657f, -0.24814107f, -0.01438919f, 0.13672352f, -0.01162228f, -0.00389635f, 
    -0.02933460f, -0.24479014f, -0.35848609f, 0.13182501f, -0.06480514f, 0.11403910f, -0.15163453f, -0.00661026f, 
    -0.11797301f, 0.07213873f, 0.11791141f, -0.36037979f, -0.04943898f, 0.00751511f, 0.04223523f, -0.05647942f, 
    0.16986600f, 0.03978137f, -0.00298865f, -0.04291963f, 0.05447441f, 0.20016183f, 0.15363596f, -0.03722160f, 
    -0.20388892f, -0.01367851f, 0.00129766f, -0.09026989f, 0.02220224f, 0.03123880f, 0.19960462f, 0.07652002f, 
    -0.02308924f, -0.12764458f, -0.04649238f, 0.13415311f, -0.00082183f, 0.16604067f, 0.20732546f, 0.06585461f, 
    0.12377723f, 0.00531293f, -0.09585253f, 0.03282933f, -0.11678711f, 0.00571650f, -0.11169583f, -0.67598701f, 
    0.32372412f, 0.17872323f, 0.12065953f, -0.08054311f, 0.03834457f, -0.01268548f, 0.08500348f, -0.31577832f, 
    -0.15714894f, -0.25128961f, -0.07530198f, 0.11551528f, -0.16201197f, -0.08088248f, 0.15521833f, 0.10743659f, 
    0.12874195f, 0.01117455f, -0.00171773f, -0.04687707f, -0.10730779f, 0.11968604f, -0.16870333f, 0.23301324f, 
    -0.19644059f, 0.15842809f, 0.06581524f, 0.11323478f, 0.05068472f, 0.16217695f, -0.03778452f, 0.04137160f, 
    -0.05705252f, 0.23208979f, 0.06798475f, 0.09196478f, -0.15055040f, 0.20979616f, 0.09327032f, 0.02966345f, 
    0.23482265f, 0.04793566f, -0.02411598f, 0.22334193f, -0.00748841f, 0.22240214f, -0.41471517f, 0.08576091f, 
    -0.10715294f, 0.06515645f, -0.14157921f, -0.08597994f, 0.14635275f, -0.24749930f, 0.00770555f, -0.50145561f, 
    0.18033651f, -0.07702866f, -0.04937407f, 0.30327079f, 0.00476565f, 0.28779173f, -0.06415517f, 0.21595077f, 
    0.24167287f, -0.06418161f, -0.08131373f, 0.09360507f, -0.32297698f, -0.06549553f, -0.01070885f, -0.13913268f, 
    0.35193247f, 0.16313471f, 0.11701334f, 0.14021741f, -0.08923801f, -0.02624663f, 0.18390200f, 0.02589840f, 
    -0.24128656f, 0.00867428f, -0.21505199f, 0.10212152f, -0.12129004f, 0.13738313f, 0.08378673f, 0.00503951f, 
    0.17907941f, 0.16117992f, -0.12935863f, 0.16913496f, 0.04625383f, 0.07922405f, 0.10718713f, -0.10199756f, 
    -0.05117617f, -0.17572650f, -0.04090463f, 0.08204127f, -0.16351011f, 0.14626032f, -0.10073520f, 0.11035346f, 
    0.02659983f, 0.21322732f, 0.01818116f, -0.45366010f, -0.24093564f, -0.26069209f, 0.10176492f, 0.06067787f, 
    -0.02170024f, 0.09758493f, -0.02463727f, 0.13554057f, 0.28893855f, -0.11912716f, 0.14172892f, -0.00788183f, 
    0.04004343f, -0.01367736f, 0.02759796f, -0.03904756f, -0.07131138f, -0.12314642f, -0.17309310f, -0.09867840f, 
    0.27950668f, 0.12833910f, 0.04218099f, 0.00567475f, -0.05386087f, -0.22688851f, 0.19314945f, 0.22732206f, 
    0.15172099f, 0.20254348f, -0.08238808f, -0.07414446f, 0.02307400f, -0.12014452f, -0.16203466f, -0.21896286f, 
    0.26864517f, 0.01367610f, -0.03462024f, 0.04016200f, -0.00870702f, -0.06321137f, -0.07263834f, -0.07184285f, 
    0.23107977f, 0.36321068f, 0.32878131f, -0.09303507f, -0.25953054f, 0.09726601f, -0.11606121f, -0.02957209f, 
    0.02549360f, -0.40236446f, 0.17045777f, -0.11965829f, 0.17539883f, -0.07067695f, -0.20479839f, -0.03952324f, 
    -0.04375117f, 0.01645097f, 0.07838169f, 0.02915893f, 0.28121266f, 0.16775341f, -0.08117463f, 0.11915606f, 
    -0.21770005f, 0.09873836f, -0.11928732f, 0.15769899f, -0.15886529f, -0.02951508f, -0.00459570f, 0.01397368f, 
    -0.02824951f, -0.10389084f, 0.02775071f, -0.08642145f, 0.27725932f, -0.14479695f, 0.14135174f, -0.21013813f, 
    0.02264680f, 0.13448091f, -0.04689533f, 0.14778733f, 0.04728778f, -0.28151667f, 0.11560361f, -0.11975440f, 
    0.07492918f, 0.20527162f, -0.02774794f, -0.01118938f, -0.25329602f, 0.12035719f, -0.11643482f, -0.03091400f, 
    -0.00847104f, -0.04622293f, 0.05636307f, 0.04512626f, -0.02248204f, -0.10480595f, 0.20576452f, -0.12285545f, 
    -0.12283251f, -0.54220575f, 0.04886883f, 0.00497689f, -0.10423084f, -0.31125286f, 0.06544405f, 0.11302496f, 
    0.16555445f, 0.04427848f, 0.02297832f, -0.25544649f, -0.12143418f, -0.10764589f, -0.17483562f, 0.12218834f, 
    0.05794270f, -0.42363703f, -0.12182720f, 0.31691569f, 0.21500012f, 0.46502280f, 0.00944239f, -0.05546354f, 
    -0.04146185f, -0.09317322f, 0.64760482f, 0.25116348f, -0.15127209f, 0.05558593f, -0.25980523f, 0.01273490f, 
    0.12712035f, -0.14329726f, 0.02878181f, -0.23215732f, -0.00246385f, -0.21597356f, -0.00479090f, 0.14252701f, 
    -0.11716583f, -0.06831945f, -0.05716049f, 0.04933921f, -0.08449485f, -0.03072887f, -0.13218015f, 0.02659693f, 
    0.03656937f, -0.00426529f, -0.02682664f, 0.09084669f, -0.01098750f, 0.10401344f, -0.08125026f, -0.32781124f, 
    -0.23656757f, -0.07355255f, -0.03066399f, -0.02539002f, -0.03381812f, -0.06793600f, -0.21614878f, -0.00231653f, 
    -0.05225406f, -0.03479963f, -0.00475549f, -0.05982661f, -0.02489747f, -0.10845143f, -0.26497951f, 0.51230448f, 
    0.19959141f, -0.10199708f, 0.10410796f, -0.12235153f, 0.21615177f, -0.12512380f, 0.17760144f, -0.04776099f, 
    0.25818479f, 0.03745639f, -0.11581083f, -0.04992337f, -0.02089933f, -0.05566218f, -0.00205893f, 0.27854300f, 
    0.10152715f, -0.37316334f, -0.29690760f, 0.37830845f, -0.09609684f, -0.12567578f, 0.06439807f, -0.12895615f, 
    -0.04785279f, -0.01320768f, 0.29641467f, 0.28511700f, -0.02727035f, -0.02360644f, 0.15949447f, 0.11841714f, 
    -0.11626744f, -0.06232352f, -0.24350895f, 0.05461462f, -0.15396376f, 0.05863133f, -0.04802010f, -0.08548006f, 
    -0.10780544f, -0.07158832f, -0.01475884f, -0.10583237f, -0.00518061f, 0.10634392f, -0.15569910f, 0.02934735f, 
    0.04398065f, -0.01079191f, -0.08701569f, -0.08421832f, -0.01739254f, -0.03335672f, -0.22940175f, 0.02613338f, 
    0.16841012f, -0.13467418f, -0.00485139f, 0.02055726f, 0.14371254f, 0.09722974f, 0.04325920f, 0.20063314f, 
    -0.53026611f, -0.07254089f, 0.32785818f, 0.12122436f, -0.11545947f, -0.16864219f, 0.11239474f, 0.21297885f, 
    0.05581550f, 0.15401757f, 0.02683987f, 0.15048867f, 0.13431992f, -0.02232766f, 0.09531977f, 0.06126124f, 
    -0.25354567f, -0.02256181f, -0.01926167f, -0.07078390f, 0.05614910f, -0.15362579f, 0.10697566f, 0.05496609f, 
    -0.03617642f, -0.99840748f, -0.07407072f, -0.06871614f, -0.13730004f, -0.04566332f, -0.22801138f, 0.06770734f, 
    0.05601376f, 0.10081195f, 0.02022895f, -0.27533880f, 0.01839097f, 0.10983709f, 0.08129884f, 0.04520968f, 
    -0.09071023f, -0.14399706f, 0.03912369f, 0.18582049f, -0.30721700f, 0.25172099f, -0.10908892f, 0.00328089f, 
    -0.16094196f, 0.05651481f, -0.00746936f, 0.01034203f, 0.39210385f, -0.09141906f, -0.21389514f, -0.25496784f, 
    0.04656463f, -0.02093766f, 0.01817170f, -0.05829392f, 0.15555578f, -0.08890650f, -0.21250321f, 0.01741215f, 
    0.02328272f, -0.05786774f, 0.06951214f, 0.35976163f, -0.00111477f, -0.29741079f, -0.26012465f, 0.11024481f, 
    -0.26813316f, 0.01710869f, -0.05471262f, 0.08197424f, 0.16991676f, 0.20801440f, -0.09940557f, 0.38131487f, 
    0.03581737f, -0.03243443f, -0.00458366f, -0.06680233f, 0.13461542f, 0.21285334f, -0.01550227f, 0.12412055f, 
    -0.01149601f, -0.00499528f, -0.33129096f, 0.04654760f, 0.19760685f, 0.04412073f, 0.00418841f, -0.01661340f, 
    -0.07585692f, 0.69775623f, 0.23073949f, -0.17942032f, 0.11275500f, -0.23013435f, -0.00333003f, 0.16952103f, 
    0.07031065f, 0.29425535f, -0.36826292f, 0.26872331f, -0.52298331f, 0.14183126f, 0.05938794f, 0.04998714f, 
    -0.07077827f, 0.11747456f, 0.13771650f, 0.00764970f, -0.17679101f, 0.07452323f, 0.01056533f, 0.09017221f, 
    -0.11895320f, 0.00420850f, 0.31835872f, 0.00148817f, -0.13636525f, -0.08572645f, 0.12019554f, 0.15296809f, 
    -0.08546274f, 0.04633570f, -0.16681637f, 0.18004543f, 0.18134990f, 0.49725583f, 0.06032273f, 0.40652308f, 
    0.08362060f, -0.02384685f, -0.12703201f, 0.11756404f, 0.13491631f, 0.05803195f, 0.19364721f, -0.19287889f, 
    -0.13278189f, 0.17625828f, -0.17020425f, 0.00817193f, -0.07850842f, 0.00400622f, -0.19817317f, -0.13785185f, 
    0.16272621f, 0.08413700f, 0.03027453f, -0.13615881f, -0.13289443f, 0.02984916f, 0.04515935f, -0.19627826f, 
    0.01759487f, -0.02409990f, 0.02135536f, -0.01777981f, 0.05011363f, -0.00404353f, 0.02445418f, 0.00113747f, 
    -0.05468049f, 0.00144157f, -0.05566381f, -0.03384145f, 0.05294994f, 0.00650387f, -0.04255632f, -0.04936822f, 
    0.01003486f, -0.03180270f, -0.03344547f, -0.06236357f, -0.03946707f, 0.02055381f, -0.01357152f, 0.01949416f, 
    -0.06236395f, -0.04255787f, -0.01317606f, -0.05702514f, -0.05416072f, -0.02946600f, 0.00066613f, 0.02763514f, 
    -0.01266855f, -0.03868649f, -0.00667603f, -0.04461119f, 0.01616873f, -0.03226786f, -0.05800606f, -0.00995756f, 
    -0.06053568f, 0.00168827f, 0.00852381f, 0.00786293f, -0.01092158f, 0.02425213f, 0.01817760f, -0.05238762f, 
    -0.00601733f, -0.01099856f, -0.00469288f, -0.03181035f, -0.05657068f, -0.06435649f, -0.05953183f, 0.03211732f, 
    -0.05436128f, -0.03764685f, -0.03938549f, -0.04761284f, 0.04174394f, 0.03475493f, -0.04158375f, -0.00470108f, 
    0.03880740f, 0.01354428f, 0.04044890f, -0.06260443f, -0.02416150f, 0.01613620f, -0.06303308f, 0.04671381f, 
    -0.01343910f, 0.02115256f, 0.04408467f, 0.04525420f, -0.03575920f, 0.04456517f, -0.03899268f, -0.00311722f, 
    0.01488051f, -0.05549608f, 0.03885943f, 0.03640760f, -0.04273446f, 0.01564563f, -0.05024166f, 0.01954764f, 
    -0.01226178f, 0.04127740f, 0.01960488f, 0.03321481f, -0.02468060f, 0.05069794f, -0.00750975f, -0.05146291f, 
    0.00390531f, -0.02139143f, -0.05559947f, 0.01243010f, 0.03065101f, -0.02313659f, -0.02712418f, -0.01211430f, 
    0.02554666f, -0.03530338f, -0.01915321f, 0.02468891f, -0.03874297f, -0.00047127f, -0.00487274f, 0.04743724f, 
    0.00555026f, 0.04872378f, 0.02437800f, 0.00096743f, -0.04653501f, -0.02531155f, -0.05153415f, -0.01581176f, 
    0.01504061f, 0.03402411f, -0.04903516f, -0.00211358f, -0.06268641f, 0.02439152f, -0.05979016f, -0.05147243f, 
    -0.04031500f, 0.03619910f, 0.03310730f, 0.01090302f, 0.01063922f, -0.01070525f, -0.02729675f, -0.03658739f, 
    -0.03569259f, 0.04114379f, 0.04958798f, -0.06564397f, 0.02927572f, 0.00324018f, -0.06628069f, 0.02098972f, 
    0.00961540f, -0.03815265f, 0.01817866f, 0.05025283f, -0.02646357f, 0.01633378f, -0.01318253f, -0.02112408f, 
    -0.03160637f, -0.01725392f, 0.02913899f, 0.01294723f, 0.00608322f, 0.04801371f, -0.06177066f, -0.02287145f, 
    -0.03341098f, 0.02836109f, 0.03598481f, 0.01601512f, -0.04111034f, -0.01168543f, -0.01715994f, 0.01882502f, 
    -0.05209922f, -0.03978579f, -0.02286839f, -0.06627129f, -0.02863066f, 0.05291899f, 0.02891833f, 0.00688894f, 
    -0.01404339f, 0.05070636f, -0.05092493f, -0.05511205f, -0.04463280f, -0.04560585f, -0.00086960f, -0.03962108f, 
    0.00311704f, 0.04422741f, -0.04724511f, 0.03418879f, -0.05109924f, 0.01725856f, 0.04830435f, -0.05108821f, 
    -0.06222751f, -0.05890021f, -0.06195615f, 0.00917613f, 0.03395543f, 0.00792482f, -0.01344473f, -0.04110920f, 
    -0.00840906f, -0.05457688f, 0.04643987f, -0.05834218f, -0.03074779f, 0.02093551f, 0.03584617f, 0.04986559f, 
    -0.04445246f, 0.04380422f, -0.02293119f, -0.05085639f, -0.03609832f, -0.04841374f, -0.01926700f, -0.06116968f, 
    -0.01365199f, -0.05129226f, -0.00560458f, 0.02162094f, -0.05798048f, 0.00469090f, -0.00004358f, -0.00967659f, 
    0.04727803f, -0.04093878f, -0.04698674f, -0.04264642f, -0.03921647f, 0.02023941f, -0.06266075f, 0.01064878f, 
    0.00428953f, 0.00428596f, -0.03868842f, 0.01996346f, 0.00974943f, -0.01647974f, -0.03975798f, -0.02191564f, 
    -0.02516516f, 0.02312924f, -0.01232085f, 0.03129771f, 0.02264195f, 0.03902121f, -0.05799009f, -0.05754651f, 
    0.04595351f, 0.02965938f, 0.04704351f, -0.06368584f, 0.03726376f, -0.03067575f, -0.02168681f, -0.03269393f, 
    -0.01736694f, 0.02294367f, 0.02980281f, -0.06176001f, -0.06580076f, -0.00549927f, 0.04908961f, -0.03684523f, 
    0.03774813f, 0.02807500f, -0.01266481f, -0.04833406f, -0.01225066f, -0.00697830f, -0.04784804f, -0.02831665f, 
    0.03396139f, -0.06227631f, -0.00850213f, -0.02946216f, 0.04541293f, 0.04013848f, -0.04897261f, 0.01316341f, 
    0.04105780f, -0.02743873f, -0.04450462f, 0.04846600f, 0.00734339f, 0.02035896f, 0.01596625f, -0.00423206f, 
    -0.05723438f, -0.17221552f, -0.10164523f, 0.02223160f, -0.11000074f, -0.19222340f, -0.12191102f, 0.12053124f, 
    0.10412554f, -0.15978508f, -0.11990563f, 0.27369013f, 0.08378935f, -0.11444521f, -0.31725508f, -0.14582591f, 
    0.08688910f, -0.11712283f, 0.26842907f, 0.08033425f, -0.17046702f, -0.01319373f, -0.04092957f, 0.06730849f, 
    -0.23836829f, -0.00413521f, 0.01759766f, -0.13223647f, -0.00860161f, -0.11435785f, 0.12274965f, 0.10367206f, 
    0.01926565f, -0.01009185f, -0.13616404f, -0.20474158f, -0.42556474f, 0.02238063f, -0.14532627f, 0.07808328f, 
    0.00829691f, 0.30030414f, -0.21187949f, -0.33245212f, -0.15720393f, 0.15967776f, 0.10213541f, -0.12553488f, 
    0.13231230f, 0.00080809f, 0.16414566f, -0.16530238f, -0.00073589f, 0.11306488f, 0.47660005f, 0.07307119f, 
    0.29525882f, -0.37131581f, -0.19092776f, -0.04331186f, 0.03058946f, -0.01578303f, -0.10252659f, -0.02592103f, 
    -0.11455218f, 0.06091111f, 0.15627952f, -0.08364486f, 0.15838756f, -0.15944511f, -0.11302196f, 0.05398859f, 
    -0.00129547f, -0.11374889f, 0.12881939f, -0.05610527f, 0.12125368f, 0.07172137f, 0.05101284f, -0.00462362f, 
    0.32332522f, 0.04663765f, -0.13570085f, -0.06121967f, -0.20596310f, -0.06059430f, -0.01763186f, 0.00065171f, 
    -0.06098552f, 0.17747211f, 0.19463468f, -0.08528514f, 0.08937190f, 0.15367824f, -0.02708386f, 0.17288186f, 
    0.06247638f, 0.05780468f, -0.21365173f, 0.24303490f, 0.33867395f, 0.01872988f, -0.18326721f, -0.03750782f, 
    0.12615858f, 0.01805326f, -0.02782949f, 0.14960939f, 0.25824907f, -0.09027211f, -0.36377853f, 0.02045668f, 
    0.09750008f, 0.17105970f, 0.10978191f, 0.02645258f, 0.08553921f, 0.03721389f, -0.36069664f, 0.09339638f, 
    -0.04362433f, -0.05982417f, 0.13811292f, -0.04207584f, 0.04170462f, -0.20072196f, -0.14824203f, 0.17118774f, 
    0.07832618f, -0.12599476f, 0.28673336f, -0.23352930f, 0.14054984f, -0.02792922f, -0.09965504f, -0.67541581f, 
    0.03952825f, 0.08074587f, 0.07969126f, 0.03083679f, -0.12230438f, 0.00421098f, -0.10791335f, 0.27639335f, 
    -0.15747361f, -0.07688726f, 0.05305802f, -0.01698208f, 0.02298975f, 0.03989919f, -0.03360777f, 0.01717268f, 
    0.15968761f, -0.02368065f, 0.12596996f, 0.32174864f, 0.12093545f, -0.20765054f, -0.04019413f, 0.08501370f, 
    0.01427254f, 0.20319055f, 0.01837431f, -0.37963080f, -0.12974273f, -0.03052729f, 0.14409944f, 0.07076956f, 
    -0.13832647f, 0.06547362f, -0.19240251f, 0.04126938f, -0.60937148f, -0.04154544f, 0.13264333f, 0.00785894f, 
    -0.10161746f, 0.12072706f, -0.13994133f, 0.07226415f, 0.06193214f, -0.02304268f, 0.07264284f, -0.08608224f, 
    0.03216726f, -0.11999229f, -0.08809694f, -0.00395785f, 0.09571017f, -0.26164100f, -0.20962952f, -0.36778426f, 
    0.19614874f, 0.23558199f, 0.15999161f, -0.11411409f, 0.11785289f, -0.25885382f, 0.11336266f, 0.09482525f, 
    0.12907311f, -0.24026452f, 0.10471462f, 0.02748660f, -0.18374066f, 0.32305780f, -0.17643085f, -0.31410980f, 
    -0.02072085f, -0.10356708f, 0.05013563f, 0.01623249f, 0.13123176f, -0.01470087f, 0.13893102f, -0.02530086f, 
    0.21683675f, -0.10734790f, -0.19890618f, -0.10554059f, -0.13011831f, 0.02616463f, 0.00600324f, -0.01181810f, 
    -0.16588025f, 0.07401390f, 0.20146486f, -0.14903963f, 0.06370377f, -0.25717008f, 0.25377610f, 0.01642130f, 
    -0.16726974f, 0.14993854f, 0.22377068f, 0.12332411f, 0.28694427f, 0.05433718f, 0.10608736f, -0.23958194f, 
    0.08812993f, 0.01116932f, 0.07818596f, 0.22040923f, 0.14110297f, 0.02222624f, 0.03923568f, -0.21014656f, 
    -0.22229384f, 0.23242533f, 0.12284102f, 0.28569692f, -0.38782519f, 0.12881276f, 0.27796018f, -0.00896773f, 
    -0.07769229f, -0.18090461f, 0.23569404f, 0.19222152f, 0.06299950f, 0.31237704f, 0.08074841f, -0.11614037f, 
    0.17521247f, -0.14214620f, 0.10266612f, 0.12941928f, -0.04783596f, 0.25848702f, 0.26020071f, -0.02127185f, 
    -0.34183168f, 0.00071710f, 0.03257049f, 0.17292883f, 0.00067519f, 0.04185215f, 0.07764342f, 0.14291005f, 
    -0.11313749f, -0.10447923f, 0.02533151f, 0.18858421f, -0.10595296f, 0.04780602f, 0.00079184f, 0.18199459f, 
    -0.09712841f, 0.22445078f, -0.01685824f, -0.03766891f, 0.15559018f, -0.05053370f, 0.04163238f, 0.14131193f, 
    0.22768100f, 0.14761911f, -0.09950535f, -0.11803754f, 0.18242130f, 0.36904114f, 0.02980786f, -0.23326783f, 
    0.09815466f, 0.14132948f, -0.11675296f, -0.30473697f, 0.14396062f, 0.09558567f, 0.04634698f, 0.06455026f, 
    0.05018761f, 0.02606127f, 0.07333240f, -0.37610969f, 0.23975047f, -0.16656820f, 0.15424275f, 0.06054400f, 
    -0.05104201f, -0.10715063f, -0.01054167f, 0.05284109f, -0.29361358f, 0.25744247f, -0.08608036f, -0.13992088f, 
    -0.11120192f, -0.09128821f, -0.35796595f, -0.06561823f, -0.20001531f, -0.25719023f, -0.02110768f, 0.02924077f, 
    0.00765208f, -0.02056401f, 0.05936725f, 0.09978890f, 0.02389176f, -0.10931385f, 0.20437121f, 0.32997158f, 
    -0.07406616f, 0.04303785f, 0.13011220f, -0.14008854f, 0.25553700f, 0.19222884f, 0.03515436f, -0.07860725f, 
    -0.14594911f, 0.10647054f, -0.08439162f, -0.08038639f, 0.14123212f, -0.00582932f, 0.03604579f, 0.10378501f, 
    -0.30184031f, -0.19178288f, 0.22615322f, -0.08013361f, -0.12404928f, -0.11603718f, 0.19977279f, -0.03724594f, 
    0.17458858f, -0.26710537f, 0.28099167f, 0.15539573f, 0.05165096f, 0.04202493f, -0.22077715f, 0.12295223f, 
    -0.05376345f, 0.33575311f, 0.21661952f, 0.27861831f, 0.20682919f, 0.13052586f, -0.02670185f, -0.17423485f, 
    0.03010753f, -0.14740857f, -0.18313918f, 0.18279226f, 0.18688786f, -0.10458423f, -0.00864087f, 0.02374239f, 
    -0.17229697f, 0.07053863f, 0.04363445f, 0.15160811f, 0.07769668f, -0.28888848f, -0.15684555f, -0.05288431f, 
    0.00235709f, 0.30820107f, -0.08477969f, -0.21369119f, -0.45085442f, 0.21772400f, -0.02849329f, -0.07836933f, 
    0.28012940f, -0.05052812f, 0.01217941f, -0.02824882f, 0.00334081f, -0.07344721f, 0.27032346f, 0.19579595f, 
    0.05706303f, 0.16574906f, 0.30022445f, -0.02895790f, 0.11834280f, 0.04880613f, -0.12710127f, 0.01118069f, 
    -0.01611262f, -0.04019428f, -0.25082529f, -0.08859090f, -0.05223049f, -0.04470317f, -0.16228989f, 0.11160051f, 
    -0.21602768f, 0.00174542f, 0.16915452f, -0.06162662f, -0.15434638f, -0.14562258f, 0.08652778f, 0.22762759f, 
    0.10311746f, -0.39836884f, 0.23379184f, -0.04901464f, -0.07515616f, -0.03630885f, -0.27348694f, -0.05475479f, 
    0.10737272f, 0.16114293f, 0.08035708f, -0.28541076f, 0.08491126f, -0.34668103f, 0.16637956f, -0.02639523f, 
    -0.22285649f, -0.22082369f, -0.25802898f, 0.15828764f, -0.19897005f, -0.21648674f, -0.36012155f, -0.01925880f, 
    -0.02463206f, 0.13302165f, 0.11665802f, -0.32457927f, -0.10868649f, -0.01200562f, -0.02214770f, -0.06327584f, 
    -0.00388181f, -0.10732803f, 0.08464557f, -0.18005753f, 0.12464269f, 0.02205076f, 0.19603555f, 0.21930414f, 
    0.03356583f, 0.11827315f, 0.12881042f, -0.15530342f, -0.08785141f, -0.10088494f, 0.40189356f, 0.15092669f, 
    0.11261745f, 0.26829112f, 0.14871170f, 0.10902531f, 0.21550927f, 0.04211394f, 0.17229554f, 0.10811128f, 
    -0.07133017f, 0.23487246f, 0.11133403f, 0.04755067f, 0.00107270f, -0.02222675f, 0.13155048f, 0.11602614f, 
    -0.00126082f, 0.22159760f, 0.18161537f, 0.00188328f, -0.03722610f, 0.04456642f, 0.09256187f, -0.06760354f, 
    -0.03069036f, 0.24080861f, -0.36493883f, -0.17927602f, 0.01232431f, -0.08543295f, 0.13072111f, 0.12138946f, 
    -0.05225291f, -0.09601576f, -0.14621229f, 0.18928903f, -0.14217699f, 0.36062589f, -0.27146360f, 0.01848639f, 
    0.10640275f, 0.16855995f, 0.05465468f, 0.06067971f, 0.18815233f, -0.11447585f, 0.04662533f, 0.12947060f, 
    -0.26800928f, -0.03118226f, 0.11225212f, 0.15392040f, -0.08199130f, -0.18616731f, -0.16781171f, 0.11716384f, 
    0.19699413f, -0.21934471f, -0.01077745f, 0.04454584f, 0.13435601f, -0.38324878f, 0.04948770f, -0.31336489f, 
    -0.01878169f, 0.12817368f, -0.12962055f, -0.10024462f, -0.01464756f, 0.11605076f, -0.22686365f, 0.09189805f, 
    -0.06814326f, -0.10218366f, 0.09795734f, -0.10793220f, 0.08529975f, -0.12945934f, -0.21661809f, -0.25709370f, 
    -0.01122451f, 0.13767266f, 0.13326502f, 0.03829472f, -0.06051482f, 0.09962946f, -0.13499865f, -0.00493600f, 
    0.34638101f, -0.38339746f, 0.13458861f, 0.07510339f, 0.05892592f, 0.08172043f, 0.09250602f, -0.00179397f, 
    0.07296039f, 0.43648458f, 0.03548428f, -0.17825076f, -0.08986643f, 0.07683695f, -0.02097511f, -0.15270422f, 
    0.06476569f, -0.02442646f, -0.03997571f, -0.14761569f, -0.14449145f, 0.00950137f, -0.01841855f, 0.01408169f, 
    0.01090358f, -0.03167052f, -0.00632555f, 0.04392902f, -0.18986559f, 0.10064732f, -0.08813088f, 0.24524233f, 
    -0.04253731f, -0.34077612f, -0.13242285f, -0.12280858f, 0.41360062f, -0.03713769f, -0.06282096f, -0.13491096f, 
    0.00490965f, 0.00910743f, -0.22069332f, 0.06837798f, -0.10484406f, 0.26951984f, -0.19673486f, 0.03101536f, 
    -0.08215603f, -0.12757066f, 0.15982433f, -0.03691994f, 0.03035004f, -0.04811633f, -0.37871817f, 0.28794011f, 
    0.16758625f, 0.05067379f, 0.14418860f, -0.15398969f, -0.00155123f, 0.01877597f, 0.30637878f, 0.19587062f, 
    0.07708736f, -0.08773416f, -0.10686190f, -0.00636080f, 0.15659285f, 0.00787249f, 0.22819327f, 0.10714399f, 
    -0.53283244f, 0.00276763f, 0.19691309f, 0.02183827f, 0.13384652f, -0.25261587f, 0.02175388f, 0.11664359f, 
    0.00354422f, 0.42785564f, 0.11899756f, -0.37501901f, -0.00545680f, -0.11295296f, 0.16310677f, 0.11794489f, 
    0.09642311f, -0.12691210f, -0.02742167f, 0.03559969f, 0.32490230f, 0.02633291f, -0.05962473f, -0.01690030f, 
    -0.17476147f, -0.19450898f, -0.01655376f, 0.03230480f, -0.29930171f, 0.12015805f, 0.06197437f, -0.22915350f, 
    -0.01664610f, -0.08845899f, 0.02790238f, -0.04280002f, 0.02765211f, -0.19166793f, 0.03394872f, -0.14084105f, 
    -0.16186623f, -0.07657681f, 0.03166458f, -0.14150329f, -0.11078401f, -0.20876032f, 0.45847720f, 0.00607006f, 
    0.07022111f, 0.15465812f, -0.03718394f, -0.05750356f, 0.02466118f, -0.00604834f, 0.20127046f, 0.23143746f, 
    0.18222152f, -0.10485073f, 0.06238172f, -0.04045165f, 0.05948583f, -0.13587616f, -0.05354848f, 0.10238812f, 
    0.41828391f, -0.33651844f, -0.06518912f, -0.25388697f, -0.02420337f, -0.09192558f, -0.15330823f, -0.09386975f, 
    -0.39764458f, -0.08023217f, 0.10073581f, -0.03209036f, -0.00643561f, 0.07021919f, -0.03691658f, -0.03430846f, 
    -0.20409305f, -0.07122936f, -0.21470086f, -0.29078975f, 0.04968720f, -0.01190258f, -0.14823817f, 0.13170946f, 
    0.15073059f, 0.00229015f, -0.23501228f, 0.00109054f, -0.12036808f, -0.15908675f, -0.19905469f, -0.09203631f, 
    -0.03543447f, -0.18208151f, -0.18180203f, 0.06999516f, 0.12113935f, 0.35976180f, -0.07969971f, -0.01935863f, 
    -0.26919419f, -0.07469257f, -0.00654354f, -0.00497426f, 0.17878373f, -0.15868950f, 0.18451887f, 0.15306246f, 
    0.17043763f, -0.06967974f, -0.03767215f, -0.03891867f, -0.06837995f, 0.18734403f, 0.28798822f, 0.34083325f, 
    0.09711100f, -0.06173011f, 0.10629863f, -0.09814230f, 0.12995964f, -0.11660077f, 0.33565056f, 0.42337981f, 
    0.35930479f, 0.21781246f, 0.19073248f, 0.15351065f, -0.05006961f, -0.11079263f, 0.09764915f, 0.18777548f, 
    -0.19856621f, -0.07601045f, -0.36536598f, -0.12962432f, 0.19229636f, 0.17405275f, -0.08306096f, 0.00810542f, 
    0.32889688f, 0.00460559f, 0.38098103f, 0.05055033f, 0.00176826f, 0.10900050f, -0.07871227f, 0.03635975f, 
    -0.19178440f, -0.24760252f, 0.16550827f, -0.25547001f, 0.07417919f, -0.08955850f, -0.08558657f, -0.08711556f, 
    0.05110209f, 0.24429201f, 0.40263781f, -0.16348277f, 0.31187415f, 0.33395478f, 0.00782967f, -0.11320204f, 
    -0.13989644f, 0.05286889f, 0.06452145f, 0.26034304f, -0.36500528f, -0.03114901f, -0.10417629f, 0.19426191f, 
    -0.17770243f, 0.10648844f, -0.10381382f, 0.19657105f, -0.18047245f, -0.28290048f, -0.46496299f, -0.01295777f, 
    -0.17186922f, -0.09461166f, -0.14067084f, -0.05565097f, -0.03281885f, 0.57045054f, 0.02944249f, -0.00533147f, 
    -0.31940806f, -0.07152840f, -0.17763916f, -0.04758831f, 0.03149501f, 0.00994620f, 0.09785352f, -0.25942993f, 
    0.22690164f, -0.08632524f, -0.05678257f, 0.05967466f, -0.00606154f, -0.03282595f, 0.00746937f, -0.23321432f, 
    0.06415470f, -0.09809076f, 0.02641997f, -0.07097566f, 0.02832717f, -0.05300744f, -0.09118019f, -0.04615388f, 
    0.01405748f, 0.11452624f, 0.08035504f, -0.02044615f, 0.15908603f, -0.05682739f, 0.33013168f, 0.10934720f, 
    0.20392568f, 0.06797384f, -0.06947990f, 0.10146150f, -0.08481429f, 0.21762997f, -0.07707343f, 0.10858719f, 
    -0.06909710f, 0.06192605f, -0.39374590f, 0.01276768f, 0.23495576f, -0.31796086f, -0.17514513f, 0.21929337f, 
    -0.24102505f, 0.05378931f, -0.10842928f, -0.26038736f, 0.27695149f, 0.09196287f, -0.01352867f, -0.12196871f, 
    0.22207125f, -0.12586412f, 0.07297079f, -0.00704517f, 0.17120466f, -0.14670981f, 0.04819965f, -0.16431111f, 
    0.02762848f, 0.01918533f, 0.11016352f, -0.08498205f, 0.10081030f, 0.07719968f, -0.06430543f, 0.26488546f, 
    0.14829974f, 0.01464704f, -0.05745925f, 0.07861988f, 0.06267463f, -0.25422046f, 0.08950169f, 0.13004613f, 
    -0.18256156f, -0.03410020f, 0.00674182f, 0.15946816f, 0.26511753f, 0.12602305f, 0.14464848f, -0.18712698f, 
    0.04352410f, 0.25073355f, -0.31926021f, -0.02085199f, 0.19477445f, -0.00841445f, 0.19562900f, 0.09140597f, 
    -0.48091191f, -0.37219098f, 0.12026694f, -0.25788656f, 0.05626936f, -0.24370748f, -0.01160656f, 0.04298663f, 
    0.05385453f, -0.14348882f, 0.01259855f, 0.16856138f, 0.03791849f, -0.02491198f, 0.02567071f, 0.08553974f, 
    0.12613602f, 0.09469812f, -0.31159005f, -0.12342684f, 0.25917369f, 0.03282369f, -0.09058691f, 0.25436899f, 
    -0.10827268f, -0.20635828f, -0.06898366f, -0.11573219f, -0.04034754f, 0.12689328f, -0.12319925f, -0.16962609f, 
    0.05925167f, 0.09853921f, -0.06327404f, 0.21007244f, 0.11276022f, -0.14598884f, 0.09000357f, -0.30426109f, 
    -0.00296830f, 0.02796190f, 0.02869385f, 0.08491191f, -0.05261981f, 0.54916281f, 0.36100277f, 0.30017710f, 
    0.12162594f, -0.22820379f, 0.06655593f, -0.04270532f, -0.05826960f, 0.12742801f, 0.12786089f, 0.26321819f, 
    -0.25561500f, -0.03552947f, 0.01861332f, -0.15939382f, 0.01216929f, -0.05926249f, 0.10339398f, -0.03161474f, 
    0.13061790f, 0.09896836f, -0.04629100f, 0.16679190f, 0.05390406f, -0.06594066f, 0.04241944f, 0.03244274f, 
    -0.37464669f, -0.14240913f, -0.07196178f, 0.21537003f, 0.16045193f, -0.12470629f, 0.17909114f, 0.23091620f, 
    0.03436010f, -0.24236368f, -0.14626068f, 0.03821801f, -0.11041761f, 0.01880286f, -0.13612309f, 0.04804914f, 
    0.13928971f, 0.16638190f, -0.04178516f, 0.08348154f, 0.03126153f, -0.34261382f, 0.08726949f, 0.04006556f, 
    -0.06271490f, -0.18975674f, -0.10172553f, 0.07251391f, 0.10233497f, -0.13572645f, -0.09550675f, -0.02074739f, 
    0.15322889f, -0.20293593f, -0.16934630f, -0.31322938f, -0.01914003f, -0.07175933f, -0.14908168f, -0.09993283f, 
    0.06146045f, 0.00979802f, 0.01011929f, -0.02156050f, 0.10419424f, 0.08537783f, 0.42854151f, 0.20641845f, 
    -0.03187462f, 0.11851429f, -0.10645991f, -0.01008798f, -0.14577323f, -0.00755138f, 0.16439316f, 0.28654417f, 
    0.13564003f, 0.12137866f, 0.10507456f, 0.00011924f, 0.20945120f, 0.10259134f, 0.17348590f, -0.01719795f, 
    0.06700498f, 0.18456683f, 0.09229004f, 0.24300836f, 0.05150175f, -0.07033886f, -0.07332942f, -0.01727957f, 
    -0.20234488f, -0.03056779f, 0.30336902f, 0.13627008f, 0.03069745f, 0.16322628f, 0.31556648f, 0.00291738f, 
    -0.07223111f, 0.02392154f, -0.39382750f, 0.05109509f, -0.03785594f, -0.08653909f, 0.06623418f, -0.11628655f, 
    0.05600778f, 0.02669916f, -0.21858844f, 0.05915351f, -0.22688493f, 0.05073489f, 0.06071917f, 0.09449115f, 
    -0.03185539f, 0.00948791f, 0.30505699f, -0.03798272f, 0.00006091f, 0.01507542f, -0.25830290f, 0.01274168f, 
    -0.17402762f, 0.13723293f, 0.17362131f, 0.27991784f, 0.15392189f, 0.15963458f, -0.34655026f, -0.06245688f, 
    0.26017213f, -0.03369417f, 0.27694136f, 0.03423244f, 0.05751508f, -0.22520015f, -0.23258217f, 0.10638460f, 
    -0.00535511f, -0.18457876f, 0.01719476f, -0.06424869f, -0.14871794f, -0.11180355f, -0.59766620f, 0.22060779f, 
    0.25001031f, -0.02738570f, -0.09910382f, -0.10408835f, -0.13921995f, -0.00288555f, -0.02002279f, -0.11365639f, 
    -0.03912058f, 0.08371707f, -0.28697959f, 0.14881876f, 0.16040389f, -0.07306918f, 0.00123182f, -0.07362679f, 
    -0.14324242f, 0.01719493f, 0.05555924f, -0.05763854f, 0.06931585f, -0.01404946f, 0.02662104f, -0.10702597f, 
    0.01345492f, -0.03997516f, -0.19999278f, -0.44308442f, -0.10410115f, 0.14810866f, -0.19522990f, -0.17066908f, 
    0.08715027f, 0.24483347f, 0.08904626f, 0.19655237f, -0.16304260f, 0.14359842f, -0.10724323f, -0.02785502f, 
    0.14335217f, 0.04427135f, -0.08837871f, -0.41489667f, 0.46023548f, -0.39800385f, -0.07562779f, 0.02675631f, 
    -0.05776145f, 0.03489625f, -0.14305876f, 0.13293754f, 0.43648300f, 0.14678340f, 0.20339762f, -0.34148517f, 
    -0.11766896f, 0.00797387f, 0.11466409f, 0.07798833f, 0.07614237f, -0.00129880f, -0.15766922f, 0.02170998f, 
    0.06737331f, 0.09207495f, -0.16839153f, -0.11674739f, 0.02938791f, -0.05843600f, -0.51886362f, -0.41207033f, 
    0.43379092f, -0.16345643f, -0.05582366f, 0.16570379f, -0.18813320f, 0.17270194f, 0.14023219f, 0.33544165f, 
    0.26630938f, -0.22755356f, 0.15718147f, -0.21141791f, 0.05048690f, -0.08651593f, 0.06545711f, -0.15644862f, 
    0.43167090f, -0.24127610f, -0.08026265f, -0.05923946f, 0.04675706f, -0.07368197f, -0.11610402f, -0.01433071f, 
    -0.08477257f, -0.08889564f, -0.10287187f, 0.00404327f, -0.00988490f, -0.17051119f, 0.12956138f, 0.02912919f, 
    -0.18285914f, -0.04173879f, -0.10499977f, -0.13985926f, 0.28377557f, 0.01807211f, -0.15723504f, -0.06916892f, 
    0.03752865f, 0.19718292f, 0.06802998f, -0.29967776f, -0.27168807f, 0.23113379f, 0.07532525f, 0.10936569f, 
    0.12141066f, -0.26244596f, 0.05569126f, 0.03057557f, 0.12630595f, -0.04425675f, -0.29441079f, 0.09818976f, 
    -0.07699814f, 0.26098168f, 0.09432065f, -0.00125352f, -0.08271675f, -0.16989422f, -0.37123653f, -0.59133363f, 
    -0.01650710f, -0.16873285f, 0.10511332f, -0.08285545f, -0.09457397f, -0.05884193f, -0.15734455f, 0.11324422f, 
    0.29575694f, 0.10737512f, 0.19998558f, 0.18295072f, -0.14565837f, 0.01149467f, 0.08859238f, 0.41084406f, 
    0.07869121f, -0.34953040f, 0.17134000f, 0.31932777f, 0.00137376f, 0.05066640f, -0.08018997f, -0.03056610f, 
    0.49517444f, -0.26378980f, -0.33952120f, -0.28165576f, -0.04928225f, 0.04643346f, -0.10047296f, 0.04770117f, 
    0.12357646f, 0.27257395f, -0.02263312f, -0.07670420f, -0.04549906f, 0.07732991f, -0.14002271f, 0.00229060f, 
    0.03528834f, 0.13559042f, 0.13567723f, 0.08003727f, -0.33576003f, 0.03173881f, 0.02710327f, 0.06677578f, 
    0.26200467f, -0.10320416f, 0.00444441f, 0.13677931f, 0.46211645f, -0.17392404f, -0.02566995f, -0.02062855f, 
    0.01247833f, -0.18166432f, -0.03194663f, 0.05336268f, 0.32253397f, -0.03479324f, 0.24425188f, 0.22613470f, 
    -0.01354154f, 0.20708998f, 0.03183842f, -0.06434050f, -0.10637415f, -0.20784228f, -0.33692181f, 0.03815147f, 
    -0.02144520f, -0.21434970f, 0.05333662f, -0.06137774f, 0.04721277f, 0.15841091f, -0.36232460f, -0.51732486f, 
    0.28604862f, -0.18422289f, -0.07233245f, -0.03261883f, -0.14837784f, -0.08739376f, 0.03207187f, 0.26631203f, 
    0.54209030f, -0.04285460f, 0.30603051f, 0.06043973f, -0.12431183f, -0.03293756f, -0.17956947f, 0.11171617f, 
    0.07685740f, 0.03642557f, 0.46015185f, -0.03296955f, -0.08129899f, -0.09243221f, 0.00739667f, -0.00705685f, 
    -0.16331522f, 0.07966220f, 0.12532835f, 0.05317934f, 0.27626219f, -0.02397476f, -0.02732885f, 0.06016196f, 
    0.12178570f, -0.17568192f, -0.49507463f, -0.05431787f, 0.38975373f, -0.29574308f, 0.01656201f, -0.08828393f, 
    0.05368255f, 0.08343379f, -0.06537952f, -0.06636290f, -0.25709480f, 0.18442260f, 0.06511212f, 0.16434251f, 
    0.00301279f, -0.05798612f, 0.15114906f, -0.03038436f, 0.12656593f, -0.04064522f, 0.46129417f, 0.02687403f, 
    0.05185899f, 0.10130059f, 0.03113884f, 0.27750775f, 0.18092065f, -0.09247021f, -0.22908819f, 0.19925147f, 
    0.13195324f, -0.10395116f, 0.22670729f, 0.10541378f, -0.05617434f, 0.12969282f, -0.09548843f, 0.38436374f, 
    -0.35375306f, 0.23258485f, -0.09252863f, -0.07689948f, -0.03821497f, -0.02946640f, -0.02671171f, 0.13104175f, 
    0.00110211f, -0.53939927f, 0.09423582f, -0.14475670f, -0.01793109f, 0.16259757f, -0.15206438f, 0.04049482f, 
    -0.51478052f, 0.10347366f, 0.11588319f, 0.09612131f, 0.08909760f, 0.05450269f, -0.02338172f, 0.10371130f, 
    -0.17701876f, -0.06423551f, 0.10718031f, 0.05142996f, 0.17710526f, -0.20579682f, 0.21425657f, -0.02549618f, 
    -0.09505087f, 0.13688844f, 0.05363384f, -0.28804255f, 0.20801432f, -0.06131634f, 0.07982103f, 0.05325347f, 
    -0.05757314f, 0.11709131f, -0.15231870f, -0.06636056f, 0.04648716f, 0.41110420f, -0.21634935f, -0.15944336f, 
    -0.01825485f, 0.09649900f, -0.03169219f, 0.06648549f, 0.09112654f, 0.27277583f, -0.18698655f, -0.13621217f, 
    0.10523562f, -0.14881764f, 0.36126906f, -0.00874247f, -0.21843809f, -0.40400925f, 0.06634350f, 0.00327967f, 
    -0.05656371f, -0.10736591f, -0.07714553f, 0.14207108f, 0.01495590f, 0.04805528f, 0.00869026f, 0.34836179f, 
    0.20982966f, 0.02838102f, 0.15307623f, 0.12425211f, 0.01827378f, 0.08071217f, 0.14924334f, -0.09816723f, 
    -0.41299438f, -0.10353270f, 0.06901633f, 0.06581423f, -0.12083925f, 0.21072842f, 0.04975053f, 0.24316369f, 
    -0.22829798f, -0.42350405f, 0.17202389f, -0.04745722f, -0.02312969f, -0.05344608f, -0.19506270f, -0.02280536f, 
    0.13848530f, 0.15999569f, 0.16506484f, 0.23142640f, 0.01989617f, -0.01728597f, -0.02394102f, -0.13930719f, 
    -0.10334040f, -0.15834375f, -0.03815332f, 0.14023452f, 0.08346749f, -0.06959138f, 0.03101129f, 0.09668025f, 
    -0.21654695f, 0.08370660f, 0.10263827f, 0.02268412f, 0.24865903f, 0.00094025f, -0.02018199f, -0.05760897f, 
    -0.27144548f, 0.05697726f, -0.15907089f, 0.03115852f, 0.04481947f, -0.04287258f, -0.13306472f, -0.11578137f, 
    0.10982756f, -0.21808003f, 0.06084531f, 0.25712463f, -0.04276401f, 0.64576566f, -0.34940982f, 0.00836541f, 
    -0.01964153f, -0.32555163f, 0.08280938f, -0.03201748f, 0.05096087f, 0.00780832f, 0.43077046f, 0.06396049f, 
    0.07621964f, -0.06867389f, 0.28660473f, -0.04510669f, -0.03063839f, 0.08748762f, 0.09458573f, 0.03305602f, 
    -0.45794874f, -0.11825665f, 0.02827683f, 0.04345332f, 0.09671184f, -0.17201138f, -0.00630798f, 0.11492378f, 
    0.02522657f, -0.07501617f, -0.07254866f, 0.06645548f, 0.06692821f, 0.12799856f, -0.24346161f, -0.00741749f, 
    0.02987171f, -0.22490731f, 0.00149869f, -0.10309134f, -0.13489233f, -0.06173022f, -0.11719318f, 0.02853788f, 
    0.12548620f, 0.17864273f, 0.34066826f, 0.00886712f, -0.15306318f, -0.01916897f, 0.02786394f, -0.20747188f, 
    0.06966010f, 0.06223087f, 0.26315811f, 0.58995426f, -0.31784931f, 0.18551204f, -0.00244968f, -0.12699093f, 
    0.13891099f, 0.07495227f, 0.17011777f, 0.20155613f, -0.38513610f, -0.16966528f, 0.18623337f, 0.19591202f, 
    0.03774069f, -0.13375480f, -0.22192021f, -0.02063397f, -0.05517658f, -0.18415773f, 0.20334029f, 0.14420031f, 
    0.04997702f, -0.08610313f, -0.03651376f, 0.02143023f, -0.21405110f, -0.13597028f, -0.02549912f, 0.10567427f, 
    0.07018891f, -0.03399200f, -0.04444293f, 0.13616441f, 0.07931105f, -0.18200618f, 0.01713197f, -0.13510039f, 
    -0.45492533f, 0.05524123f, 0.00611540f, 0.06912132f, 0.13156846f, 0.15904005f, 0.11169368f, -0.01864840f, 
    -0.10821774f, 0.27369124f, -0.10522393f, 0.01755652f, 0.01512131f, -0.14018832f, -0.04235688f, 0.06750207f, 
    0.01639067f, -0.22656296f, -0.49315456f, -0.11662008f, -0.15743352f, 0.14550690f, 0.00256025f, -0.09408902f, 
    -0.05357960f, -0.22567947f, -0.10727736f, 0.26826879f, -0.00099248f, -0.05494745f, 0.00849269f, 0.18236053f, 
    0.04260040f, -0.05910615f, 0.16955274f, -0.55155355f, 0.09842236f, 0.10329382f, -0.04067919f, 0.18432869f, 
    0.14710824f, 0.04010078f, -0.11568650f, 0.12863599f, -0.28319898f, -0.24724786f, -0.31934500f, -0.22664353f, 
    -0.13334970f, 0.02046208f, -0.11947293f, 0.07385034f, -0.05251791f, -0.14368133f, -0.00027453f, -0.26768562f, 
    0.22391252f, -0.17199627f, -0.13643664f, 0.22771914f, 0.28475755f, 0.03536072f, 0.00217307f, 0.12132173f, 
    0.01398961f, -0.18584950f, -0.29889470f, -0.09732818f, -0.05673571f, 0.04644768f, -0.03141422f, 0.02794597f, 
    -0.29187399f, 0.34022638f, 0.05048212f, -0.05263964f, -0.12192246f, -0.00848106f, 0.10805063f, 0.01587646f, 
    0.02820034f, 0.00902312f, 0.04253951f, 0.04184784f, -0.05367624f, 0.01200148f, -0.03142791f, -0.04319211f, 
    -0.00599228f, -0.07499930f, -0.00136408f, -0.01380368f, 0.00091191f, -0.03505233f, -0.04604047f, 0.03299183f, 
    -0.04195460f, -0.05366823f, -0.01292423f, -0.01782704f, -0.03617888f, -0.02509001f, 0.01240767f, -0.05802888f, 
    -0.05574848f, -0.04504122f, 0.03139666f, -0.01314209f, -0.01692423f, -0.03371299f, -0.05012362f, 0.00324283f, 
    0.01225886f, -0.06925201f, -0.03534744f, 0.00942700f, -0.05907028f, -0.00029436f, 0.01743697f, -0.06699263f, 
    0.03734484f, 0.04428124f, -0.00656416f, -0.06595685f, -0.01502362f, -0.03009214f, -0.00436824f, -0.00826830f, 
    -0.02898078f, -0.00683944f, 0.02948421f, 0.04449565f, 0.03794753f, -0.04496126f, 0.02723370f, 0.00382329f, 
    0.04055641f, -0.00254688f, -0.05612856f, 0.03663212f, 0.02215973f, -0.03987281f, 0.00813244f, 0.05082107f, 
    0.00610364f, -0.01427846f, 0.04174281f, 0.02125887f, -0.00291521f, 0.01714731f, -0.05376069f, 0.03239425f, 
    0.03118473f, 0.01951297f, -0.04035340f, 0.05132465f, -0.00048508f, 0.01328329f, -0.06783739f, -0.01887278f, 
    -0.05855789f, -0.01727442f, 0.04237368f, -0.02890489f, 0.02454337f, -0.04713630f, 0.03613492f, -0.03716269f, 
    -0.04664458f, -0.00779307f, -0.05971308f, 0.00177979f, 0.02969809f, 0.00850123f, -0.03142915f, -0.03744926f, 
    -0.06433824f, 0.02318229f, -0.01935477f, 0.03673044f, -0.02926152f, 0.02391089f, -0.03650695f, 0.02689228f, 
    0.04020997f, -0.04820032f, 0.02219295f, -0.02471148f, 0.03349370f, -0.02126415f, -0.04394819f, -0.00495853f, 
    0.02092281f, -0.03136882f, 0.00816422f, -0.00285685f, -0.07398909f, -0.05899891f, -0.07042713f, 0.01752627f, 
    0.01055824f, -0.02358954f, 0.03214516f, 0.04269768f, -0.02882283f, -0.05351664f, -0.00635062f, 0.00598739f, 
    -0.00712960f, -0.02792319f, -0.05852971f, 0.00738647f, -0.06805373f, -0.01073536f, -0.05721665f, 0.00968946f, 
    -0.01075779f, -0.05436835f, 0.03060362f, 0.01407897f, -0.03366892f, 0.02898742f, -0.04587447f, -0.00318930f, 
    0.04782794f, -0.04530106f, 0.00599083f, -0.00666074f, -0.03651406f, -0.04678280f, -0.02316319f, 0.04559758f, 
    -0.02807846f, -0.05639961f, -0.05246229f, 0.03795127f, -0.00419697f, 0.00192426f, -0.02996992f, -0.04940020f, 
    -0.04759286f, 0.01950358f, 0.02092076f, -0.02449984f, -0.02442332f, 0.04236989f, 0.02507048f, -0.00505397f, 
    -0.00373277f, 0.01804465f, -0.06074004f, -0.00177172f, 0.02547365f, -0.02164667f, -0.02407576f, 0.05259719f, 
    -0.06713992f, 0.01967258f, -0.07260478f, -0.03571805f, -0.05494384f, -0.00487822f, 0.01051403f, -0.01137155f, 
    -0.02836695f, -0.06032524f, -0.03748317f, 0.02903634f, -0.04497434f, 0.04159995f, -0.01400768f, -0.00661004f, 
    -0.00550472f, 0.03883025f, 0.04178216f, 0.03475228f, -0.01673817f, -0.03425691f, -0.05718249f, 0.03488669f, 
    -0.02220672f, 0.01008713f, 0.03408067f, 0.03153870f, 0.03375074f, 0.01437297f, -0.04848491f, -0.00198223f, 
    -0.00103093f, -0.02676932f, 0.01556510f, -0.01959390f, 0.03951169f, 0.02755281f, 0.00918164f, 0.03429561f, 
    -0.01182705f, 0.01213101f, -0.05731443f, 0.00537781f, -0.05175358f, -0.01921207f, -0.04722832f, 0.02795064f, 
    0.02669552f, 0.01762473f, -0.01455460f, -0.04839114f, 0.01767476f, -0.06683058f, 0.03752252f, -0.02430006f, 
    0.03413340f, -0.06382205f, -0.00616473f, -0.05995406f, 0.00666156f, -0.07288902f, -0.00932960f, -0.02306367f, 
    -0.00928979f, -0.03754550f, 0.03847507f, 0.02865906f, -0.02967148f, 0.00469192f, -0.05061587f, -0.05509323f, 
    0.01911956f, -0.00068349f, -0.02956190f, -0.05498540f, -0.02860565f, -0.00940900f, 0.00688430f, -0.03079534f, 
    0.00895874f, -0.06687468f, 0.00727672f, -0.04482044f, 0.02405777f, -0.00834059f, -0.04379598f, 0.03587062f, 
    0.03694356f, 0.01595406f, 0.01895858f, -0.03455412f, -0.05409362f, 0.02509162f, -0.07275021f, 0.00526962f, 
    0.01093305f, -0.00663012f, -0.06361531f, 0.04144185f, -0.05018307f, 0.00318681f, 0.01066962f, -0.03920373f, 
    -0.05842327f, -0.05254154f, 0.02320958f, -0.05907899f, -0.03148411f, -0.04223986f, -0.00090519f, -0.07003172f, 
    0.06422248f, -0.02000696f, 0.17757355f, -0.06742774f, -0.11492188f, 0.01577939f, 0.11707830f, 0.20844105f, 
    0.03339722f, 0.29527828f, 0.19226438f, 0.01661463f, 0.11563478f, 0.03876109f, 0.16010591f, 0.00818558f, 
    -0.09163666f, 0.12134441f, 0.18236774f, -0.03682854f, -0.32068425f, -0.18929498f, -0.04672061f, -0.03227348f, 
    -0.02749605f, -0.08478344f, -0.17640190f, -0.01641373f, -0.32946041f, 0.07638078f, 0.08423819f, -0.03295729f, 
    -0.06892544f, 0.10298105f, 0.01492927f, -0.10706165f, 0.10130475f, 0.02025907f, 0.40055537f, 0.09221104f, 
    -0.29427102f, -0.07834070f, 0.07489943f, 0.13440984f, 0.03291952f, -0.19430335f, -0.32243082f, -0.09015868f, 
    0.09501936f, -0.12189290f, 0.04852119f, 0.06231555f, 0.01439949f, -0.13488947f, 0.01684120f, 0.07295649f, 
    0.29427645f, -0.09938841f, -0.19073631f, -0.01784591f, 0.16432048f, 0.00623268f, 0.21385580f, -0.29261595f, 
    0.20892908f, -0.15369666f, 0.16352695f, -0.06631359f, -0.10703444f, -0.09209972f, -0.02807336f, 0.05437452f, 
    0.16969803f, 0.19607840f, -0.01015947f, -0.12648506f, 0.11240567f, -0.04105917f, 0.13791244f, 0.12944303f, 
    0.12014937f, -0.05504077f, 0.26002383f, -0.09209473f, 0.16026832f, 0.13072029f, 0.00641241f, -0.00558361f, 
    -0.00672308f, 0.18943936f, -0.14227925f, -0.21381812f, -0.00389162f, -0.10498711f, -0.02673745f, 0.04926432f, 
    0.05518499f, -0.12581545f, -0.00378958f, 0.13189752f, -0.25880155f, -0.29847553f, -0.09398216f, 0.03587707f, 
    0.18744738f, 0.14281732f, 0.03718217f, 0.08052512f, -0.21357587f, 0.06533655f, -0.23318951f, -0.03692266f, 
    -0.16647932f, -0.06535270f, 0.01083369f, 0.08375763f, 0.02160951f, -0.66242820f, -0.04903579f, -0.55588478f, 
    0.07685724f, -0.04302902f, -0.01726681f, 0.09575981f, -0.21834998f, 0.16767067f, 0.37309542f, -0.18574905f, 
    0.24014619f, 0.12755416f, 0.08267024f, -0.05922313f, -0.08186232f, -0.06965622f, 0.06858322f, 0.24760908f, 
    0.18573108f, -0.23694579f, -0.08309455f, 0.14852613f, 0.07508695f, -0.19145711f, -0.10124362f, -0.06563657f, 
    0.10413237f, 0.22298376f, -0.18529715f, -0.16666690f, -0.10688644f, 0.12320950f, 0.31693316f, 0.01928213f, 
    0.25193185f, 0.15781601f, 0.34147689f, 0.20005573f, 0.01093984f, 0.00051100f, -0.12196484f, -0.09764420f, 
    -0.07891808f, 0.02429560f, -0.45447671f, 0.11549034f, -0.22687910f, 0.09915262f, -0.04246227f, -0.09848171f, 
    -0.08750028f, 0.26272845f, -0.08092410f, -0.34587127f, 0.19015552f, -0.50405663f, -0.39159992f, 0.06652647f, 
    -0.19577618f, 0.18535022f, 0.20518139f, 0.21169196f, 0.31776905f, -0.16635111f, -0.01196443f, 0.11562409f, 
    0.13989010f, 0.07922048f, -0.00772189f, -0.00345677f, 0.16921802f, -0.14603993f, -0.24052918f, 0.13285498f, 
    0.14032212f, 0.02756589f, 0.24141549f, -0.23097771f, 0.18706466f, -0.05901979f, 0.08440574f, -0.01575677f, 
    0.11621812f, -0.12264303f, -0.09257051f, 0.05565997f, 0.13038941f, -0.00403788f, 0.21525985f, -0.03037668f, 
    -0.21974891f, 0.12572393f, -0.21004421f, 0.06420841f, 0.03768319f, 0.13105302f, -0.05090645f, -0.05356657f, 
    -0.42153984f, 0.05512503f, 0.25964826f, -0.02114467f, 0.03622267f, 0.04614038f, -0.06484907f, -0.07745527f, 
    -0.22732399f, -0.01750528f, 0.10349394f, 0.03887919f, 0.14917940f, 0.08065730f, 0.12976737f, -0.06111104f, 
    0.12506957f, 0.05087848f, 0.23876403f, -0.28695127f, 0.42881837f, -0.06732135f, 0.09998354f, 0.04806967f, 
    0.09986613f, 0.25747374f, 0.06219746f, 0.00197015f, -0.08368412f, 0.21864428f, 0.15801975f, -0.11787966f, 
    -0.11670467f, -0.02036403f, 0.24617471f, -0.04143805f, 0.01377342f, -0.23882473f, 0.16126807f, -0.10887212f, 
    -0.15740122f, 0.14204052f, 0.10323432f, 0.08597872f, -0.00645536f, 0.18827857f, -0.47841996f, 0.07882392f, 
    0.04556398f, 0.35760304f, -0.10630382f, -0.01131171f, -0.06006709f, 0.02309068f, -0.35747719f, -0.26049900f, 
    0.06952609f, -0.03991701f, 0.04610147f, -0.02917277f, 0.00928728f, 0.06698514f, -0.06253245f, 0.03179436f, 
    0.15095012f, -0.42035466f, 0.05420297f, -0.01796525f, -0.21029145f, 0.01513873f, 0.13697691f, -0.01166760f, 
    -0.04914255f, -0.04017495f, -0.04608881f, -0.04666245f, -0.00142428f, 0.00591956f, 0.04799617f, 0.05613686f, 
    -0.03111699f, -0.03968476f, -0.02238866f, -0.04619444f, -0.03135049f, -0.04804835f, -0.01847145f, 0.03866514f, 
    -0.00190481f, 0.01936949f, -0.02562210f, -0.05058223f, -0.05416060f, -0.01159132f, -0.05202733f, -0.02474059f, 
    0.01402019f, -0.02738514f, 0.02700139f, 0.01545480f, -0.03738559f, -0.00011439f, 0.02402809f, -0.01153207f, 
    -0.01584653f, -0.03038064f, 0.01726111f, -0.04544830f, -0.02086237f, -0.03526340f, 0.02296156f, -0.03302225f, 
    -0.00653259f, 0.03636266f, 0.04026629f, 0.00657578f, -0.05674133f, -0.05738733f, 0.03164519f, 0.02482240f, 
    -0.02061453f, -0.00055094f, -0.00954656f, 0.05593026f, -0.01244209f, -0.04167779f, -0.04322146f, -0.01636807f, 
    -0.00595094f, 0.02957151f, 0.03030109f, 0.05088706f, 0.04638525f, 0.01083154f, 0.04070955f, -0.00360353f, 
    0.03249376f, -0.04572125f, 0.04751369f, 0.05170064f, 0.02952948f, -0.04442337f, -0.05735066f, -0.04198487f, 
    0.00806291f, -0.02576122f, 0.01693019f, 0.03230562f, -0.00335794f, -0.05786102f, 0.00501684f, 0.03476672f, 
    -0.05132579f, 0.00925966f, -0.04264979f, 0.04085298f, -0.05191923f, -0.02260557f, 0.02069150f, 0.05030083f, 
    0.00838486f, 0.02632139f, 0.04597640f, -0.05414441f, -0.01175521f, -0.02780666f, 0.00438249f, -0.02028613f, 
    0.02175920f, 0.02074294f, -0.05338814f, -0.05771349f, -0.05756371f, -0.03057571f, 0.03328191f, 0.04613788f, 
    -0.04855087f, -0.02481984f, 0.05780702f, -0.05308433f, -0.05352835f, -0.01554787f, 0.00431377f, 0.03720388f, 
    0.00349411f, -0.05223733f, 0.03700466f, -0.03890979f, -0.01548608f, -0.01939530f, 0.02960774f, 0.03332065f, 
    0.05698469f, -0.00686551f, -0.00107449f, -0.05126203f, -0.02407986f, -0.02052123f, -0.01303004f, -0.00296253f, 
    -0.03648874f, -0.01932453f, 0.00341151f, 0.02718678f, -0.00729719f, -0.04020046f, -0.03660183f, 0.04127103f, 
    -0.05147930f, -0.03385980f, -0.03940682f, -0.02728697f, 0.00063016f, 0.03490166f, 0.04674255f, -0.04389666f, 
    0.01493793f, -0.02722897f, 0.05295305f, -0.04201638f, 0.04339809f, 0.02379918f, -0.02635284f, -0.04263698f, 
    -0.03093970f, 0.04028642f, -0.02657826f, -0.02840356f, -0.03171332f, -0.00129730f, -0.00748255f, -0.00241062f, 
    0.05069058f, -0.01499401f, 0.02388873f, -0.03194696f, -0.00353787f, 0.05371356f, -0.05299414f, -0.03274862f, 
    -0.00855540f, 0.03107174f, 0.05420064f, -0.03281351f, -0.00393184f, -0.04660982f, -0.00469326f, 0.00377884f, 
    -0.04889031f, 0.02482228f, -0.02928172f, -0.03509944f, 0.00526822f, -0.00078702f, -0.00167879f, 0.01706465f, 
    0.03781870f, -0.01290033f, -0.01660429f, -0.04564752f, -0.01559400f, -0.04502651f, -0.05199081f, 0.01252482f, 
    -0.03799243f, -0.05525687f, -0.05037754f, -0.03284370f, 0.01087706f, 0.01887472f, -0.01346630f, 0.05682478f, 
    0.02404807f, -0.00255540f, 0.03490261f, -0.02731138f, 0.03938266f, 0.02374390f, -0.01494628f, 0.00688485f, 
    0.04465696f, 0.04454571f, -0.00332882f, -0.02112420f, -0.05439447f, 0.03379794f, 0.05218722f, -0.05540583f, 
    -0.03726282f, -0.02942874f, -0.02630408f, 0.04410524f, 0.03243494f, 0.05033406f, 0.03538074f, -0.00067400f, 
    -0.03988228f, 0.00487628f, -0.05511850f, -0.00760492f, -0.05013146f, 0.02590484f, 0.01939325f, -0.01609083f, 
    -0.03668255f, -0.02022955f, -0.00801186f, 0.03575236f, -0.02856297f, -0.04671669f, -0.01102308f, -0.02968169f, 
    -0.04757572f, -0.05121396f, -0.04650196f, 0.01941467f, 0.00105957f, 0.00933258f, -0.04803209f, 0.01337037f, 
    -0.04901116f, 0.01561936f, -0.00168452f, 0.03242615f, -0.05649231f, -0.00902875f, 0.00584736f, -0.03100069f, 
    0.03378394f, -0.02020632f, 0.02062134f, -0.02230781f, 0.03655666f, -0.04188262f, 0.01100343f, -0.05103863f, 
    0.03821796f, -0.04468690f, 0.02602107f, -0.03659832f, 0.02884034f, 0.00363542f, 0.02060977f, 0.01891315f, 
    0.02822917f, 0.05523429f, 0.03627614f, -0.02596060f, 0.00491419f, 0.04946932f, 0.01055070f, 0.05705063f, 
    -0.02515039f, 0.04105377f, -0.01221567f, 0.04177167f, 0.01272234f, -0.03909384f, -0.02413529f, -0.03747272f, 
    -0.25953850f, 0.12458334f, -0.04992851f, 0.00187951f, -0.05267155f, 0.05414532f, 0.14943813f, -0.15362307f, 
    -0.07516830f, 0.04163507f, -0.03392614f, 0.07079603f, 0.10339058f, 0.00353990f, 0.05928177f, 0.23813768f, 
    0.15615258f, 0.11739637f, -0.44776520f, 0.20308848f, 0.07917415f, 0.13512786f, 0.18486561f, -0.01665303f, 
    -0.24310370f, -0.22306924f, 0.14919832f, -0.43939447f, 0.23333459f, 0.11893316f, 0.01503393f, 0.07569280f, 
    0.06373073f, 0.01921845f, -0.14943577f, -0.07519667f, -0.04913743f, 0.04864534f, 0.30347702f, -0.20263505f, 
    0.02687849f, -0.19935168f, 0.15985163f, 0.00393980f, 0.09156312f, -0.12381305f, -0.15538967f, 0.17929396f, 
    -0.04546381f, 0.07253060f, -0.30880591f, -0.08853647f, -0.16116150f, -0.04960464f, 0.29210442f, 0.32095906f, 
    0.15012529f, -0.04095383f, -0.30382842f, -0.16475067f, 0.18035211f, 0.34472647f, 0.01222550f, -0.04588844f, 
    0.09476206f, -0.21807258f, 0.12850988f, 0.19982222f, -0.07868145f, -0.06184268f, -0.10381678f, -0.05698920f, 
    -0.01535505f, -0.10079197f, -0.00729739f, -0.24900077f, 0.08813602f, -0.12267812f, 0.10890675f, 0.01103440f, 
    -0.14844993f, 0.36145169f, 0.17112252f, 0.07838429f, -0.03475510f, 0.01568490f, -0.09495367f, -0.09858418f, 
    -0.09217805f, -0.09871139f, -0.17757268f, 0.17931320f, 0.00892760f, 0.05121892f, -0.09767984f, 0.00394361f, 
    -0.09537094f, 0.03920628f, -0.10627020f, 0.19213308f, 0.03195788f, 0.09193006f, -0.10393439f, -0.16271238f, 
    -0.12429498f, 0.06610782f, 0.10987765f, 0.21280997f, 0.04140316f, 0.15406829f, -0.09775042f, -0.02088630f, 
    0.13431837f, -0.26444811f, -0.09617557f, 0.19306004f, 0.05173052f, 0.72897166f, 0.08040525f, -0.05059167f, 
    -0.14043212f, 0.09210727f, 0.00916511f, -0.00583998f, 0.13330448f, 0.09026904f, 0.27927440f, 0.18978655f, 
    0.08211891f, -0.08083969f, 0.15179361f, 0.08593221f, -0.04674186f, -0.02186098f, 0.27958059f, -0.13491578f, 
    -0.03425091f, -0.21197996f, -0.12125579f, 0.10104634f, 0.05206120f, -0.14206089f, -0.06801590f, -0.23145963f, 
    0.19923934f, -0.09754340f, -0.07686442f, 0.03820775f, 0.19475889f, -0.21807407f, -0.02244771f, -0.00414447f, 
    -0.05531047f, 0.04060874f, -0.09186354f, 0.05537136f, -0.08099368f, -0.05747686f, -0.07231885f, 0.01668458f, 
    0.20528661f, 0.07761917f, -0.05167586f, 0.25619569f, -0.01100781f, 0.22810152f, -0.05746376f, -0.11492036f, 
    -0.18991499f, 0.06066829f, -0.00657773f, 0.41630927f, 0.26214859f, 0.08581934f, -0.22689869f, -0.00912884f, 
    0.01805329f, -0.15371431f, 0.11652341f, -0.17677960f, 0.10630224f, -0.04874756f, -0.21569528f, -0.10111006f, 
    -0.01935841f, 0.11371559f, 0.12411234f, 0.03020153f, -0.19851455f, -0.25033787f, 0.20837121f, 0.12303784f, 
    0.20347728f, -0.17421935f, 0.14601481f, 0.02788794f, -0.11281358f, 0.04358336f, 0.18331899f, -0.08393756f, 
    0.11847524f, -0.12855452f, -0.24510455f, 0.08914672f, -0.12663390f, 0.12516062f, -0.01109449f, -0.52435398f, 
    -0.01549128f, -0.12171739f, -0.06076336f, 0.24778110f, -0.03665386f, 0.05030932f, -0.10379415f, 0.05640663f, 
    -0.20155270f, 0.06444546f, -0.09847424f, 0.15923388f, -0.06194662f, -0.26826105f, 0.04120475f, -0.09940879f, 
    0.03207668f, -0.12680070f, 0.00147271f, -0.39063844f, -0.13418028f, 0.09566509f, -0.09348208f, -0.10170288f, 
    0.04684424f, -0.25738207f, -0.06905220f, 0.20597006f, 0.06541357f, -0.12757626f, -0.00456341f, 0.17042392f, 
    0.07318224f, 0.06096457f, -0.00849068f, -0.17383139f, 0.20228444f, -0.03468902f, 0.07559635f, -0.25791582f, 
    0.02071662f, 0.26612648f, 0.07163272f, 0.07784527f, -0.19099669f, -0.00830372f, -0.35207728f, -0.01953650f, 
    0.17680147f, -0.16335244f, 0.10606109f, -0.05489396f, 0.18210714f, 0.31091067f, 0.00059171f, -0.37480056f, 
    -0.19122152f, -0.16967079f, 0.10506034f, -0.05332815f, 0.09847351f, -0.03679699f, -0.23512448f, 0.19548236f, 
    -0.03394921f, 0.19106258f, 0.15758395f, -0.00162127f, -0.04351984f, -0.14832649f, -0.13693796f, 0.06321929f, 
    0.19523713f, 0.11213429f, 0.14813116f, 0.05943436f, -0.18981504f, -0.14303191f, 0.00708779f, 0.02044849f, 
    -0.03321566f, -0.03084079f, 0.01854919f, -0.02865409f, -0.03522424f, 0.01212131f, -0.04204855f, 0.03222467f, 
    0.04695272f, -0.01349912f, 0.03995289f, 0.04113676f, -0.05610036f, -0.01920428f, 0.01416815f, -0.05504820f, 
    -0.05296945f, -0.01048360f, -0.04261891f, 0.00993485f, 0.00152545f, 0.04752106f, -0.05314169f, 0.03358602f, 
    -0.06026930f, -0.03730636f, -0.00272517f, -0.03667244f, 0.02817889f, -0.00351368f, 0.00723333f, 0.00554590f, 
    0.00768527f, -0.04145800f, 0.03366338f, -0.03204625f, -0.00622117f, -0.03857062f, -0.01585441f, 0.04913535f, 
    0.00982833f, -0.04838121f, 0.02557880f, 0.00068286f, -0.01486143f, -0.05337601f, 0.01434069f, -0.03392800f, 
    -0.00306547f, 0.02851271f, -0.00142351f, -0.03206713f, 0.03569299f, 0.03144600f, -0.00422280f, 0.02901349f, 
    -0.03371448f, -0.05172736f, -0.01762749f, -0.01218827f, -0.00726296f, -0.03106942f, -0.00987399f, 0.05053644f, 
    0.04152421f, 0.05040822f, -0.01394848f, 0.01233027f, -0.03748978f, -0.02486772f, 0.01316433f, 0.00421582f, 
    -0.01633747f, 0.02942345f, -0.01873082f, 0.01328751f, 0.04866779f, 0.04493861f, 0.01325240f, -0.01031236f, 
    -0.00298029f, 0.02090946f, -0.00545181f, -0.05750572f, -0.03704438f, -0.04829856f, -0.00394098f, 0.02151656f, 
    0.02859786f, -0.02133002f, 0.04250232f, 0.00111563f, 0.03323913f, -0.03945633f, -0.00714190f, -0.00342709f, 
    0.00278936f, -0.03442148f, 0.00615816f, -0.04840159f, 0.00303322f, -0.00891480f, 0.03250512f, -0.02928157f, 
    -0.05596168f, 0.02469148f, -0.00755423f, -0.00344672f, -0.00892156f, -0.06086614f, -0.05533235f, 0.05184289f, 
    -0.05915343f, -0.03213752f, -0.05000284f, 0.05023427f, -0.04251578f, -0.00801669f, 0.01341427f, -0.04865512f, 
    -0.02305275f, 0.01861471f, -0.04394854f, -0.01617930f, -0.05360257f, -0.05750953f, -0.06205886f, 0.02103146f, 
    -0.00170995f, -0.00328430f, -0.05499242f, 0.05114919f, 0.02520644f, 0.05149208f, -0.03872230f, 0.04873868f, 
    -0.01128216f, -0.01122969f, -0.02071009f, -0.02310354f, -0.04227616f, -0.03333358f, -0.01253732f, 0.02926706f, 
    0.02705899f, -0.01090655f, 0.02533247f, 0.01395181f, -0.05842739f, -0.04615607f, -0.00429287f, 0.04709695f, 
    -0.05020451f, -0.04891536f, -0.05027793f, 0.00512826f, -0.00819158f, -0.02966546f, 0.04250460f, 0.04593988f, 
    -0.01503476f, -0.02969203f, 0.03849130f, 0.01830164f, -0.03526684f, 0.00909555f, 0.02186804f, 0.04985138f, 
    -0.05013279f, -0.05164417f, 0.03604684f, -0.04296901f, -0.06172893f, -0.03651300f, 0.01245217f, -0.05518910f, 
    -0.02970105f, -0.03228098f, 0.01937371f, 0.01156753f, -0.04397152f, -0.05024409f, 0.04681651f, -0.04535810f, 
    -0.00959132f, -0.05995193f, -0.05042163f, -0.00965505f, -0.02248670f, 0.00529321f, 0.01465981f, 0.01873729f, 
    -0.05411333f, 0.00108913f, -0.01955087f, 0.03356528f, -0.06254013f, -0.02336968f, -0.01639283f, -0.02301019f, 
    0.04174278f, 0.04362296f, 0.03433112f, 0.03172082f, 0.04549700f, 0.04994648f, 0.03420773f, 0.00064915f, 
    0.02346530f, -0.03692444f, -0.04329407f, -0.03093572f, -0.05656797f, 0.02327354f, 0.03590882f, 0.00577705f, 
    0.03993314f, -0.04808245f, -0.03838945f, -0.01992852f, 0.04041897f, -0.01121634f, -0.05666108f, -0.06213161f, 
    0.03464022f, -0.06254970f, -0.03134927f, 0.04760323f, -0.04363806f, -0.01960356f, 0.01533321f, -0.05540460f, 
    0.01721475f, -0.05213059f, 0.04896325f, 0.02695493f, 0.01846907f, -0.06437199f, -0.05164189f, -0.03429815f, 
    -0.00465524f, 0.02193736f, 0.00347586f, 0.01176633f, -0.04141844f, 0.01278520f, 0.00078966f, -0.01441737f, 
    0.05073748f, 0.03454417f, 0.03832097f, -0.05106084f, -0.04751389f, 0.02356966f, -0.01984878f, -0.03054177f, 
    -0.00763275f, -0.04322692f, -0.04847068f, -0.02152207f, 0.03943864f, -0.04336678f, -0.03230685f, 0.00211937f, 
    -0.03380752f, -0.00384995f, 0.02642379f, 0.02011974f, 0.03004855f, -0.03160785f, -0.05144030f, 0.03296255f, 
    -0.04391816f, -0.05194468f, 0.00277384f, -0.02944853f, -0.01957447f, -0.01647415f, 0.03724482f, -0.05635531f, 
    -0.06453761f, 0.04469097f, 0.03006553f, -0.02854268f, 0.04956393f, -0.00077850f, -0.05054160f, 0.01092928f, 
    0.02595201f, 0.18395874f, 0.27558151f, 0.18730436f, 0.08315422f, 0.13124102f, 0.31876916f, 0.06095251f, 
    0.04532374f, -0.05677625f, 0.03583149f, 0.09961499f, 0.22330843f, -0.05225047f, 0.04203807f, 0.15222479f, 
    -0.05158112f, -0.15246516f, -0.20456426f, 0.04157437f, 0.06283694f, -0.21959245f, 0.02583750f, -0.14134109f, 
    -0.03769344f, -0.02579183f, 0.02633170f, -0.15247041f, 0.34890360f, -0.04722634f, -0.03052166f, 0.18362984f, 
    0.17994265f, -0.12422823f, 0.24245641f, -0.13784882f, -0.30572143f, -0.07567976f, -0.02777063f, 0.03737873f, 
    0.15645368f, -0.08046405f, -0.02381996f, 0.13197136f, 0.22856453f, -0.25543475f, -0.59844786f, -0.03279440f, 
    0.17655842f, -0.07429949f, 0.10868401f, 0.08443388f, -0.04855581f, 0.02022168f, 0.23986134f, 0.13029785f, 
    -0.11472227f, 0.14372067f, 0.05064167f, 0.29526037f, 0.12444214f, 0.02330523f, 0.05225768f, -0.08949010f, 
    0.07668701f, 0.10911008f, -0.38837275f, -0.10840794f, 0.11111055f, -0.05605426f, -0.04930583f, -0.09276050f, 
    -0.28390220f, 0.11464910f, 0.17143387f, -0.02197084f, -0.02718308f, -0.19979373f, -0.03748868f, 0.03908648f, 
    0.03067499f, 0.03126360f, 0.29629165f, 0.07640336f, 0.15821359f, -0.07711980f, 0.30086836f, 0.12659267f, 
    0.29481891f, -0.12123002f, 0.25585714f, -0.24039948f, -0.16280116f, 0.01584009f, 0.11784433f, 0.32732546f, 
    0.04911683f, -0.22919098f, -0.07520638f, 0.54051095f, 0.21747203f, -0.31284663f, 0.31938258f, 0.01621935f, 
    -0.02566380f, -0.13705321f, -0.08265187f, -0.18064505f, -0.54298168f, -0.22758619f, 0.08573583f, 0.04964902f, 
    0.00552724f, 0.01680361f, -0.28779876f, -0.08262452f, 0.19278809f, 0.27749386f, 0.27756581f, 0.03787438f, 
    -0.05291041f, 0.11835588f, -0.08032990f, 0.09420966f, 0.11156838f, -0.13329592f, 0.12406103f, -0.07937406f, 
    -0.12906270f, -0.11838912f, 0.20895174f, 0.19185431f, 0.02339243f, -0.20616125f, -0.14262721f, 0.00289125f, 
    0.17405997f, 0.07181751f, -0.08766511f, 0.06983396f, 0.05402356f, 0.09262028f, 0.20481947f, -0.27486801f, 
    -0.12217977f, 0.08401801f, 0.08862866f, 0.03196014f, -0.10200998f, 0.01000767f, 0.21667975f, -0.00456177f, 
    -0.11621958f, -0.00187380f, -0.12891808f, 0.09293573f, -0.14705053f, -0.08418161f, -0.00712107f, 0.03017977f, 
    -0.24144408f, 0.02169196f, 0.01167880f, -0.07843436f, -0.02068518f, -0.18914522f, 0.14742838f, 0.23914962f, 
    -0.20918891f, 0.09138820f, 0.16589242f, -0.28557685f, -0.16939747f, -0.31378707f, -0.42153940f, 0.11072634f, 
    -0.00869103f, 0.07928763f, -0.10114148f, 0.27209833f, -0.01288756f, -0.05809818f, 0.05724201f, -0.02812642f, 
    0.03710600f, 0.36369205f, -0.04821222f, 0.13865140f, -0.07675171f, 0.15296657f, 0.05061497f, -0.04820520f, 
    0.21344496f, -0.15088721f, 0.13070457f, 0.33497697f, 0.05451536f, -0.22810739f, 0.57501543f, -0.10487041f, 
    -0.12493157f, 0.11271147f, 0.15394612f, 0.18870556f, 0.26707318f, -0.35322106f, 0.05775623f, 0.23085228f, 
    -0.07212962f, 0.02069747f, -0.01758234f, 0.01906214f, -0.01919595f, 0.14710319f, -0.07740077f, -0.06534263f, 
    0.16184215f, -0.45114642f, -0.16869120f, 0.05477889f, 0.17748393f, 0.09675695f, 0.13051552f, -0.11388968f, 
    -0.04951317f, -0.35944733f, 0.11404999f, -0.08348154f, -0.28082192f, -0.15741971f, -0.09610549f, 0.00345940f, 
    -0.08700948f, -0.08746752f, 0.05139548f, -0.18232633f, -0.20824477f, -0.06727967f, -0.02551743f, 0.24933857f, 
    0.03393224f, 0.01038547f, -0.00386026f, -0.06967069f, 0.08474049f, 0.19878002f, 0.02512059f, 0.11891470f, 
    -0.06037458f, 0.00517658f, -0.00951157f, -0.06145751f, -0.26919559f, -0.12344307f, 0.00223838f, 0.02483288f, 
    0.19782439f, 0.09222537f, 0.08460013f, 0.21217056f, -0.19651611f, -0.55574679f, -0.30620986f, -0.38921234f, 
    -0.14174278f, -0.20447943f, 0.05621666f, -0.08698677f, -0.18706991f, -0.01062005f, -0.36520544f, -0.25777698f, 
    0.20770028f, -0.04698971f, 0.09030075f, -0.05363319f, 0.00887503f, 0.02034595f, 0.08215089f, -0.22116949f, 
    0.00936961f, 0.05106170f, 0.05781248f, -0.10551486f, 0.04779017f, 0.07085986f, 0.03394821f, 0.09119563f, 
    0.04323671f, 0.02048918f, -0.01133484f, 0.03152213f, 0.01935725f, -0.01881799f, -0.05749025f, 0.02088590f, 
    0.04344034f, -0.01887373f, 0.03846181f, 0.05349768f, -0.04348644f, -0.03980341f, 0.00361300f, -0.04233293f, 
    -0.02826242f, -0.01548257f, 0.00403751f, 0.01990137f, 0.01255916f, -0.03728386f, 0.01426057f, -0.06642427f, 
    0.01894266f, -0.02828177f, -0.02450900f, -0.03458606f, 0.04321655f, 0.03573715f, 0.04492609f, 0.00881069f, 
    -0.02544305f, -0.04870004f, -0.04521303f, -0.05765830f, -0.03993093f, 0.00699375f, -0.01962937f, -0.00964777f, 
    -0.04609647f, -0.04181527f, -0.03624433f, 0.02861232f, -0.01022945f, -0.01480388f, 0.03118339f, -0.02581323f, 
    -0.01179398f, -0.01864224f, -0.03763454f, -0.04740204f, 0.03165704f, -0.06230476f, 0.05674377f, 0.00923987f, 
    0.00110880f, -0.04969266f, 0.03952684f, 0.02094929f, -0.02761715f, 0.04148744f, -0.01541373f, -0.03998479f, 
    -0.00022559f, -0.02761921f, -0.03514582f, -0.00255946f, -0.01192699f, 0.02245137f, 0.04396630f, 0.01131182f, 
    0.04808229f, -0.03359549f, -0.02013502f, -0.01435295f, -0.02097520f, -0.01441826f, 0.03970254f, -0.00988314f, 
    -0.06620364f, -0.00332602f, -0.03275578f, -0.00415857f, 0.00638669f, -0.00915223f, 0.01415685f, 0.03661245f, 
    -0.06321402f, -0.01508480f, -0.00339407f, -0.04668929f, 0.00732484f, -0.03245069f, 0.01947733f, 0.03852414f, 
    0.01788118f, 0.02349574f, 0.03803284f, 0.01476805f, -0.01391814f, -0.01858961f, -0.01368810f, -0.04217054f, 
    0.04358428f, -0.02077935f, -0.02963393f, 0.03351464f, -0.02761533f, -0.02606044f, 0.03456260f, 0.03485982f, 
    0.03370070f, 0.00220276f, 0.04979080f, -0.06558403f, -0.01457864f, -0.01379929f, 0.01521874f, -0.03017097f, 
    -0.00305211f, 0.03040790f, -0.00158113f, 0.03630626f, -0.06153622f, 0.00685103f, -0.03223015f, 0.02063073f, 
    0.00135432f, 0.04389980f, -0.06689079f, -0.02665534f, 0.03983137f, -0.01148127f, -0.05120900f, 0.02710239f, 
    0.01948557f, -0.05721642f, -0.07248197f, 0.02192698f, -0.05023414f, 0.03854413f, -0.04977141f, -0.01229762f, 
    0.01225884f, -0.05339367f, -0.03322161f, 0.00354275f, 0.03866582f, -0.00751215f, -0.01574421f, 0.04129548f, 
    0.00671555f, -0.04355215f, 0.00742139f, 0.05574812f, -0.01087063f, 0.00667873f, -0.00926803f, 0.02443466f, 
    0.00346123f, 0.00143610f, -0.05746922f, 0.04406468f, 0.01848666f, -0.02921443f, 0.03645230f, -0.02839865f, 
    -0.02100220f, -0.02657013f, -0.04481312f, 0.00726891f, -0.00177308f, -0.03125822f, -0.00106204f, 0.04737266f, 
    -0.02946125f, 0.03940995f, -0.05544074f, -0.04353074f, 0.04763052f, 0.02922096f, 0.00509550f, 0.01539710f, 
    -0.01031699f, -0.05577721f, 0.01781431f, -0.00910166f, -0.04658119f, 0.01514020f, -0.06080352f, 0.03587909f, 
    0.01007832f, -0.01157464f, 0.02404915f, 0.03547392f, -0.01647519f, -0.00572744f, 0.04145222f, 0.03132419f, 
    -0.01608405f, 0.02388518f, 0.01911127f, -0.00962481f, 0.02533132f, -0.06260053f, -0.06684899f, 0.03333072f, 
    0.00243902f, -0.01953186f, -0.03922478f, -0.00651130f, -0.07175573f, 0.00403070f, -0.03030881f, 0.02515429f, 
    -0.05015378f, -0.04819938f, 0.02890174f, -0.00460214f, -0.02864175f, -0.05354439f, 0.02336878f, 0.03547302f, 
    -0.03791824f, 0.03534327f, 0.03922281f, -0.01294048f, 0.00287339f, -0.05684116f, -0.03538434f, 0.02442729f, 
    -0.06594983f, -0.06147890f, -0.03726886f, 0.03530788f, -0.01152630f, -0.05337438f, 0.04280356f, -0.04084998f, 
    0.04825037f, 0.00548100f, 0.00207088f, -0.04935876f, 0.01129561f, 0.02799867f, 0.01376650f, 0.04739988f, 
    -0.04836992f, -0.03674042f, -0.06481372f, -0.04382824f, 0.00716419f, -0.03294717f, -0.01127181f, 0.02624707f, 
    -0.04658809f, 0.00676624f, -0.02478468f, -0.01343300f, -0.01072432f, -0.04373373f, -0.01492012f, -0.03232311f, 
    0.03976239f, 0.02642239f, -0.04393966f, -0.00219739f, -0.03182912f, 0.04853396f, 0.03777687f, -0.07649814f, 
    -0.04868928f, 0.00126302f, -0.00935357f, -0.01403220f, -0.03750838f, -0.01120223f, 0.01438231f, -0.02795351f, 
    -0.06744401f, -0.00696862f, 0.02313723f, 0.02853107f, 0.03513028f, -0.02611007f, 0.03098868f, 0.04491957f, 
    0.23080775f, 0.11531375f, 0.18354376f, 0.29481378f, 0.37055883f, -0.08584829f, 0.21243832f, -0.16962507f, 
    0.04199471f, 0.17431001f, -0.06373531f, -0.25476420f, -0.05905129f, -0.08899553f, 0.13788179f, -0.15115826f, 
    -0.31813514f, -0.11969381f, 0.35159042f, 0.32752278f, 0.13167340f, -0.05481788f, 0.02158887f, 0.08498660f, 
    0.12396722f, -0.04821740f, 0.03045559f, 0.01165104f, 0.04407852f, -0.01276409f, -0.03787522f, -0.12709971f, 
    0.08059191f, -0.15430874f, -0.01363264f, 0.12838757f, 0.34403080f, -0.13796674f, -0.09944765f, -0.07759494f, 
    -0.11937457f, -0.06194122f, -0.14251859f, 0.16188174f, 0.27022058f, 0.13266288f, 0.10346690f, -0.27028403f, 
    0.52884585f, 0.32405704f, 0.16527647f, 0.04597257f, 0.09040190f, 0.15846999f, -0.39812511f, -0.38566208f, 
    0.02942305f, 0.28810498f, 0.16071242f, 0.01070576f, -0.01894985f, -0.06230835f, 0.02756808f, 0.41640142f, 
    0.35516444f, 0.20737912f, 0.28617832f, 0.02505072f, 0.05141497f, 0.09496203f, 0.15660438f, 0.11807029f, 
    -0.05000059f, 0.02706378f, -0.08219367f, 0.20472321f, -0.06931829f, -0.00201664f, -0.01553370f, 0.03627614f, 
    -0.10147518f, -0.31618094f, -0.20359379f, -0.10429633f, -0.03014515f, 0.00885325f, -0.17754629f, -0.02267456f, 
    -0.06499765f, 0.17860399f, -0.53029448f, -0.04819064f, -0.02928774f, 0.20500104f, 0.06287066f, 0.08962257f, 
    -0.01647132f, 0.08023440f, -0.04427721f, -0.89452755f, -0.17228016f, 0.12646107f, 0.04555514f, 0.14584477f, 
    0.15844068f, 0.09565161f, 0.04075686f, -0.08380159f, 0.23795702f, 0.24048603f, 0.12901464f, 0.10708080f, 
    0.02181299f, 0.08199460f, 0.31937790f, -0.05010701f, -0.06704456f, -0.33675784f, -0.12524927f, 0.28799903f, 
    -0.05735105f, 0.10304516f, -0.20580660f, 0.17605092f, -0.01111114f, 0.13421585f, -0.05864523f, -0.40760997f, 
    -0.13992250f, 0.21996954f, -0.23887704f, 0.06850743f, -0.24618070f, -0.05454352f, -0.04072367f, -0.25675827f, 
    -0.22540383f, -0.10816069f, 0.15465601f, 0.07805224f, 0.34129009f, 0.10679284f, 0.17847903f, -0.17966121f, 
    -0.03194849f, -0.34543121f, -0.02397733f, 0.17839994f, 0.15881300f, 0.03902888f, 0.04466026f, -0.06561221f, 
    0.24909525f, -0.54597872f, -0.45828155f, -0.29280397f, 0.15472029f, -0.01255918f, -0.04605650f, -0.24374186f, 
    0.08385792f, 0.04574541f, 0.19120714f, 0.20172705f, 0.03839927f, 0.11496817f, -0.08681303f, 0.01047108f, 
    0.17820585f, 0.24591209f, 0.04738129f, -0.45714131f, 0.44917470f, 0.31239402f, 0.28623959f, -0.14895847f, 
    -0.18316805f, -0.07893883f, -0.11818619f, -0.09529800f, -0.29215354f, 0.40211895f, 0.06867541f, 0.26064798f, 
    0.11967026f, 0.03344382f, 0.02722981f, 0.14125389f, -0.27481169f, -0.07089752f, 0.10579064f, -0.26877955f, 
    0.22968891f, -0.06293358f, 0.19131348f, -0.05974681f, -0.17898999f, -0.11847585f, 0.25721610f, 0.01043514f, 
    -0.22668205f, 0.14063834f, 0.25225613f, 0.28210932f, -0.02087729f, -0.06686432f, 0.00969232f, 0.36513102f, 
    0.37946644f, 0.11864994f, 0.08191305f, 0.12736939f, -0.12325447f, 0.09132239f, 0.08061231f, 0.22648522f, 
    -0.35667211f, -0.07052322f, -0.06668939f, 0.40915540f, 0.17264888f, 0.00753721f, 0.13714774f, -0.01429101f, 
    -0.05279794f, -0.04182101f, 0.46544620f, -0.15405668f, 0.01996286f, 0.04567743f, -0.01673943f, 0.11595416f, 
    -0.00661151f, -0.07725782f, -0.06975938f, -0.14954147f, -0.11827703f, 0.18992801f, 0.16353792f, -0.07479222f, 
    0.08082284f, -0.22882049f, -0.17867519f, 0.09377988f, 0.14270556f, 0.10253446f, 0.25194654f, 0.27597079f, 
    0.12717782f, 0.12313817f, -0.17891668f, 0.21416168f, 0.00785266f, -0.17522395f, -0.05750449f, 0.12408686f, 
    0.03851029f, 0.07268655f, 0.07137217f, -0.00867829f, -0.03729383f, -0.37836495f, 0.13532780f, -0.49310714f, 
    0.07030081f, -0.70283097f, -0.08860962f, 0.34843481f, -0.07869983f, -0.13277212f, 0.07907908f, 0.00175776f, 
    -0.30181706f, 0.14562684f, -0.08757902f, 0.09009282f, 0.19905642f, 0.34526980f, 0.02978198f, 0.35421836f, 
    0.08877748f, -0.01598640f, 0.08225101f, 0.12104764f, 0.16030048f, 0.31872451f, -0.19295406f, 0.15294649f, 
    -0.03692425f, -0.00733142f, -0.00546219f, -0.04243536f, 0.02122822f, -0.00749946f, -0.04960352f, -0.03483947f, 
    -0.00621903f, -0.06245543f, -0.01203667f, 0.01545110f, 0.04590107f, -0.05587861f, 0.00249063f, -0.00310553f, 
    -0.06672771f, 0.04352573f, 0.04606213f, -0.01431476f, 0.03504330f, -0.05096179f, 0.04197261f, -0.01364200f, 
    -0.03984980f, 0.00124674f, -0.04657661f, -0.01996947f, -0.01822844f, -0.00524599f, 0.02189925f, -0.04661451f, 
    -0.01749843f, 0.02384208f, -0.04899025f, -0.02353948f, -0.01551154f, -0.04571047f, 0.03521079f, -0.00409399f, 
    0.01643645f, -0.02947842f, -0.05801808f, -0.01045664f, -0.02197152f, 0.04775475f, -0.02487207f, -0.00413821f, 
    0.02252822f, -0.04011736f, 0.04853640f, -0.02233125f, -0.05530282f, -0.04356498f, -0.03208880f, 0.01872087f, 
    -0.01693540f, -0.05834234f, 0.01632824f, -0.01869122f, -0.02190499f, 0.02405114f, 0.01631982f, 0.04618970f, 
    -0.02290006f, 0.05170938f, -0.06339631f, -0.01793791f, -0.00997103f, -0.03762122f, 0.00796496f, -0.03100635f, 
    -0.04166589f, -0.00411549f, 0.02526408f, 0.00872387f, 0.04483527f, 0.01346934f, 0.02911469f, -0.02499836f, 
    0.02507721f, 0.05230925f, -0.03976190f, -0.02326442f, -0.04879970f, 0.02710376f, -0.06674142f, -0.01019371f, 
    0.02943752f, 0.02931581f, -0.06738135f, 0.02830064f, 0.02076579f, -0.05548208f, -0.02024611f, -0.04953594f, 
    -0.00201088f, -0.06590656f, -0.03148971f, -0.03443619f, -0.03083125f, -0.00157266f, -0.02451164f, -0.06516045f, 
    -0.03404476f, 0.03689705f, 0.01257819f, 0.00447929f, -0.01789154f, -0.00013884f, -0.00673232f, -0.01780819f, 
    0.04037894f, 0.01245076f, -0.01672717f, -0.04660775f, 0.00005502f, -0.05838259f, 0.04750239f, -0.05937389f, 
    -0.06112869f, 0.05863425f, 0.04842687f, -0.02794044f, 0.00683370f, 0.03170028f, 0.03930719f, -0.00320109f, 
    -0.01832451f, -0.01497523f, -0.02059793f, 0.02476786f, -0.03340140f, -0.01363322f, 0.03905245f, 0.05004767f, 
    -0.02160016f, -0.03100399f, -0.03460839f, -0.02264325f, 0.04791700f, 0.03905039f, -0.05293741f, 0.00475557f, 
    -0.04383186f, -0.05505786f, -0.00956723f, -0.03880391f, 0.04067949f, -0.02368112f, -0.01975745f, 0.02340598f, 
    0.03555018f, -0.06008422f, 0.00449560f, 0.01398479f, 0.03849308f, -0.02630516f, -0.01929744f, -0.03829122f, 
    0.01938659f, 0.01739574f, 0.01360934f, 0.04063465f, 0.05055454f, -0.02902873f, -0.01391116f, -0.05154947f, 
    0.03004187f, -0.06376477f, 0.04516136f, 0.04455448f, 0.02158080f, -0.02844004f, -0.01553801f, -0.04119308f, 
    0.04628341f, 0.04100804f, -0.00112132f, 0.01456109f, -0.03381307f, -0.02440145f, -0.00053360f, -0.01464582f, 
    0.04599024f, -0.00634726f, -0.01846881f, -0.02550151f, -0.00452859f, -0.05190763f, -0.03710315f, 0.03765573f, 
    0.04267412f, 0.03717767f, -0.01010885f, -0.00027899f, -0.01149727f, 0.03880089f, -0.04158700f, 0.00026424f, 
    0.01678359f, -0.05518276f, 0.00189250f, 0.01084002f, -0.00972031f, 0.01295433f, 0.03322083f, 0.04021848f, 
    -0.01594421f, -0.01726075f, 0.01787656f, -0.04984958f, -0.06103630f, 0.02926243f, 0.00928622f, -0.06645708f, 
    -0.06286447f, -0.05954597f, 0.04822685f, 0.02753186f, 0.02323426f, 0.03016160f, -0.01062815f, 0.02400439f, 
    -0.00200367f, -0.01846222f, -0.02743540f, -0.00104937f, 0.03164640f, 0.01369046f, -0.05165410f, 0.00544522f, 
    0.03660699f, -0.04980739f, 0.01471761f, 0.00440339f, 0.03350933f, 0.05249258f, 0.02893355f, 0.04191167f, 
    0.03189407f, -0.04847880f, -0.00921809f, -0.02210070f, 0.04645456f, -0.05370430f, -0.05787569f, -0.03186604f, 
    -0.04306472f, -0.03316837f, -0.01030559f, -0.03564817f, 0.04094914f, -0.03646702f, -0.02752934f, -0.02293208f, 
    -0.01494605f, 0.02068264f, -0.04614114f, -0.03633282f, 0.05320352f, -0.03302387f, 0.00348091f, 0.01780145f, 
    -0.03950253f, -0.05837546f, -0.04702567f, -0.04845518f, -0.00278291f, -0.05678417f, -0.02079565f, -0.05960841f, 
    -0.02125701f, -0.04539265f, -0.01636009f, 0.01854360f, 0.01543901f, -0.04650571f, -0.01928344f, 0.02697072f, 
    -0.04158608f, -0.03917516f, 0.00649058f, -0.02757739f, 0.00516903f, -0.05417813f, -0.02067861f, 0.00812913f, 
    0.33610001f, 0.22619674f, 0.18318747f, -0.00941752f, -0.13659412f, -0.11895357f, -0.01752449f, 0.14574325f, 
    -0.00950749f, 0.31309021f, -0.15547021f, 0.04872607f, -0.18019664f, 0.06695306f, -0.29430813f, 0.19774742f, 
    -0.10192281f, 0.11939225f, 0.23595192f, 0.14946246f, 0.03096579f, -0.08890727f, -0.16862579f, 0.03003330f, 
    0.14070162f, -0.12989137f, -0.03391706f, 0.25619167f, -0.09112049f, -0.16281463f, 0.06998157f, 0.05242811f, 
    0.09485318f, 0.19779716f, 0.16447107f, -0.09995880f, -0.35618261f, -0.00590871f, -0.34518406f, 0.11130016f, 
    0.00960566f, 0.13164666f, 0.01905364f, -0.21287613f, 0.08794615f, -0.06470896f, -0.35628235f, 0.01781724f, 
    0.07210895f, 0.11212593f, 0.37348858f, 0.20890591f, 0.04657777f, 0.08567902f, -0.48554856f, -0.50410980f, 
    -0.45737416f, -0.03068508f, -0.05827907f, -0.10469903f, 0.03470219f, -0.05232868f, -0.25678542f, 0.03129174f, 
    -0.02240141f, -0.02526077f, 0.13295518f, -0.00369464f, -0.09420080f, -0.00583719f, 0.21966515f, 0.08041781f, 
    0.18983200f, 0.30479267f, 0.03818389f, -0.08672974f, -0.00125724f, -0.19447330f, 0.00854640f, -0.11864163f, 
    0.02994962f, -0.58243102f, -0.55290383f, -0.03592105f, 0.08248451f, 0.00859356f, -0.10181876f, 0.03822603f, 
    0.04703933f, 0.09470093f, -0.74041969f, -0.38385838f, -0.16818261f, 0.03568437f, 0.19229373f, 0.11037870f, 
    -0.06487201f, 0.07931178f, -0.00449876f, -0.70649737f, -0.16375241f, 0.20211209f, 0.01146426f, -0.16689162f, 
    -0.07520720f, -0.15229446f, -0.07781799f, 0.08706281f, -0.12954697f, -0.06361532f, -0.04890988f, 0.02185213f, 
    -0.19195491f, 0.25340322f, 0.28436869f, 0.07422977f, 0.08470163f, -0.32834694f, -0.31801489f, 0.14858668f, 
    0.17845222f, 0.09615380f, 0.03872094f, 0.10145724f, -0.04502224f, 0.10972132f, -0.19854096f, 0.28650102f, 
    -0.10169936f, -0.18961073f, -0.08353395f, -0.16375637f, 0.07176153f, -0.04676453f, -0.25557867f, 0.04292737f, 
    0.23040779f, 0.18630184f, 0.08186464f, 0.05578494f, 0.20297718f, 0.03235573f, 0.08898292f, 0.05429462f, 
    -0.06956257f, 0.12543574f, -0.01366062f, 0.10345273f, -0.18676834f, 0.11994843f, -0.01516060f, 0.05780972f, 
    -0.02115850f, -0.07897897f, -0.61866337f, -0.25541323f, -0.12441672f, -0.11810679f, -0.16372783f, 0.21839666f, 
    0.12809175f, -0.09523218f, -0.08173116f, -0.02463389f, -0.25138506f, 0.07327842f, 0.00286528f, 0.14657043f, 
    0.20289843f, -0.04287704f, 0.14089075f, -0.15749192f, -0.02421037f, -0.23544624f, 0.15331262f, -0.02250867f, 
    -0.13947599f, -0.08654363f, -0.20527034f, 0.12570229f, 0.10575129f, 0.32747784f, 0.19977531f, -0.18287861f, 
    -0.12696247f, -0.03990872f, 0.03154509f, -0.05246847f, -0.02597874f, -0.23828574f, -0.10110144f, -0.23633642f, 
    0.08820994f, 0.30120611f, 0.17358817f, -0.07940830f, 0.16070400f, 0.13035955f, -0.33295691f, 0.28225917f, 
    0.09976783f, 0.01950706f, -0.12281822f, -0.23241352f, 0.24560086f, 0.07412193f, -0.12185887f, 0.06426248f, 
    0.10751928f, 0.14359662f, 0.18521957f, 0.04033840f, 0.01287181f, 0.13557255f, 0.08094025f, 0.13231562f, 
    -0.53223449f, -0.18336403f, -0.12703049f, 0.20881012f, 0.17797428f, 0.12320805f, 0.01355601f, -0.04277967f, 
    0.13598044f, 0.15067121f, 0.19176209f, -0.00780063f, 0.03838113f, 0.10699513f, 0.16722603f, 0.12307595f, 
    0.02525330f, 0.09831229f, -0.53600818f, -0.02007274f, -0.37492561f, 0.18995096f, 0.19113608f, -0.19351882f, 
    -0.12419841f, 0.09607161f, -0.09211796f, 0.37596598f, 0.21363083f, 0.03741790f, -0.17358008f, -0.22075526f, 
    -0.16556764f, 0.25666851f, 0.03144558f, 0.06888179f, 0.20824623f, 0.20775099f, -0.10525854f, -0.01483568f, 
    0.01794115f, -0.07129751f, -0.16551605f, 0.26644522f, 0.41110530f, 0.05405434f, -0.27924019f, 0.05685256f, 
    -0.18146364f, -0.04169870f, -0.14926548f, 0.20932722f, -0.14150387f, 0.36974603f, 0.07842118f, -0.15806594f, 
    -0.23774888f, -0.05097450f, 0.27307522f, -0.05975483f, 0.10412667f, -0.13624485f, -0.11754997f, 0.33942440f, 
    -0.01748530f, -0.09748313f, 0.04471318f, 0.01629839f, -0.13181962f, -0.13615865f, 0.27489659f, 0.14133167f, 
    -0.37026581f, 0.19453241f, 0.14435229f, -0.01444817f, -0.15625274f, -0.09951853f, 0.10968497f, -0.02721371f, 
    -0.06584505f, 0.06240291f, 0.17055066f, -0.20510873f, 0.10868485f, 0.00091760f, 0.03237502f, 0.10853466f, 
    0.11412947f, -0.09196387f, 0.22513689f, 0.14258128f, -0.08926789f, -0.20047112f, -0.23230428f, 0.00704610f, 
    -0.11473874f, 0.09104938f, 0.14890343f, 0.09719171f, -0.40678367f, 0.14804517f, -0.04427760f, -0.06401803f, 
    -0.01022077f, 0.08916825f, 0.15398428f, -0.18549755f, 0.08728866f, -0.18752772f, -0.22756940f, -0.12632424f, 
    0.06000580f, -0.02525707f, -0.28049135f, 0.05350143f, 0.22705534f, -0.18758036f, -0.08866063f, 0.06618717f, 
    -0.06015659f, 0.11778814f, 0.19285817f, -0.05411585f, 0.04873238f, 0.38534027f, 0.42203328f, 0.05080292f, 
    -0.18768817f, 0.23969232f, -0.05597031f, -0.13925038f, -0.01103647f, -0.11692584f, -0.25793427f, -0.17334163f, 
    0.17897005f, 0.11389722f, -0.26205364f, -0.18110359f, -0.31919950f, -0.13255134f, 0.10820410f, -0.08525351f, 
    0.33104897f, 0.47951442f, 0.09317873f, -0.06432101f, -0.03770008f, 0.03587604f, -0.06274389f, 0.11626756f, 
    0.06746773f, 0.03526905f, -0.15519083f, 0.56652296f, -0.14753522f, 0.08142306f, -0.11331045f, -0.10012198f, 
    -0.05154631f, -0.06705565f, 0.01565124f, -0.21994543f, -0.32020697f, 0.18983120f, 0.16835962f, 0.00139868f, 
    -0.02600079f, 0.04652617f, -0.26192415f, 0.54913151f, -0.35474527f, 0.03796347f, -0.06569932f, -0.03162170f, 
    0.07579374f, 0.05117061f, -0.10278444f, -0.17957123f, -0.19387797f, 0.13179252f, 0.00691869f, -0.19803596f, 
    0.03226513f, 0.29417381f, -0.18902653f, -0.01130088f, 0.26554894f, -0.34154823f, -0.26223630f, -0.11612424f, 
    -0.06827856f, -0.16352922f, -0.06897816f, 0.12606524f, 0.21672541f, -0.11852767f, 0.71755272f, 0.21693401f, 
    -0.15436538f, 0.09934930f, 0.30834213f, 0.09254439f, -0.17528822f, -0.04615351f, -0.01423949f, 0.45608944f, 
    0.10958963f, -0.14650612f, -0.32717195f, -0.03235642f, 0.30151406f, -0.07970656f, -0.03018337f, 0.09826898f, 
    -0.35241985f, 0.37704122f, -0.03323234f, 0.12392902f, -0.25812611f, -0.05527619f, 0.21332163f, 0.08182393f, 
    0.12505345f, -0.23798822f, 0.11955538f, -0.36409086f, -0.33026427f, -0.01584743f, 0.02427500f, -0.03087148f, 
    0.17005745f, -0.22046199f, 0.03113610f, 0.04225669f, 0.08339921f, 0.02219888f, -0.06548078f, 0.18220638f, 
    -0.08785641f, 0.12118482f, 0.13160570f, -0.27662393f, -0.22582567f, 0.55056685f, -0.00855470f, -0.19345388f, 
    -0.04269454f, -0.07567595f, 0.05172671f, -0.16884004f, 0.19107449f, 0.19988121f, 0.22299995f, 0.09630735f, 
    0.12202048f, -0.37338507f, -0.00613768f, 0.07216194f, 0.08696369f, -0.03467660f, -0.24649982f, -0.25357077f, 
    0.29438856f, 0.14114481f, 0.20677474f, 0.10502218f, 0.21862857f, -0.24798238f, -0.12564842f, 0.32629672f, 
    -0.19947682f, 0.14578244f, 0.08750040f, -0.10588093f, 0.25331703f, 0.15232220f, -0.11165175f, 0.02428421f, 
    -0.12305684f, 0.04122747f, -0.38299504f, -0.25550362f, 0.16119756f, 0.15837263f, 0.04576869f, 0.01211320f, 
    -0.53536659f, 0.14202602f, -0.15170829f, 0.03371328f, 0.19336969f, 0.05525913f, -0.15372883f, 0.11845422f, 
    -0.00252405f, 0.20529939f, 0.12792058f, 0.25559881f, 0.04152831f, -0.07942693f, 0.01147960f, -0.22391160f, 
    0.13239382f, 0.24962226f, 0.11069910f, 0.23552552f, -0.76884663f, 0.02289226f, 0.16918907f, 0.05749630f, 
    -0.04408526f, 0.05554385f, -0.06473490f, 0.00532752f, 0.12649040f, -0.24709040f, 0.02521167f, -0.10153667f, 
    0.08559261f, 0.14320226f, 0.02701469f, 0.02863001f, 0.70853627f, -0.07817927f, -0.09541214f, -0.01706991f, 
    0.09029335f, 0.02017200f, 0.02618077f, -0.06744296f, -0.01573041f, 0.05458083f, -0.61988997f, -0.19635020f, 
    0.09195272f, 0.14570099f, -0.07798193f, -0.15899405f, 0.18057340f, -0.19099240f, -0.37424424f, -0.25500765f, 
    -0.19008662f, 0.24168581f, 0.26364279f, -0.06348367f, 0.04915950f, -0.19431674f, 0.07433573f, -0.12713085f, 
    0.40479940f, 0.05154092f, -0.28028339f, -0.01728253f, 0.03665976f, -0.08935942f, 0.10068153f, -0.04027057f, 
    0.04756371f, -0.05239391f, -0.06203245f, 0.03718697f, -0.03002153f, 0.04133633f, -0.00031208f, -0.02978176f, 
    -0.00708700f, -0.02391599f, 0.00224616f, 0.04292078f, -0.02137807f, 0.02629135f, -0.04456976f, -0.05608765f, 
    0.01825391f, -0.03369137f, 0.00603747f, -0.00466905f, -0.01014555f, -0.02551483f, 0.02331822f, -0.06337442f, 
    -0.03257354f, 0.03079125f, -0.06053692f, -0.02190839f, -0.02466024f, -0.03223451f, -0.00386607f, -0.02820442f, 
    0.03363316f, 0.02598812f, 0.01519977f, -0.02238926f, -0.01897516f, 0.01715855f, 0.00716121f, -0.01093264f, 
    0.03870577f, -0.05744540f, -0.06046546f, 0.03131025f, 0.05127989f, 0.03361944f, -0.03403860f, -0.00436328f, 
    -0.04859469f, -0.04031687f, -0.03579643f, -0.03402261f, -0.05999001f, -0.01320686f, 0.03250949f, 0.00241369f, 
    0.00665976f, 0.04254785f, 0.03013233f, 0.05008894f, 0.03825233f, 0.01367715f, 0.06223098f, -0.06013711f, 
    -0.06499724f, -0.01762165f, -0.06690998f, -0.03284330f, -0.03042047f, -0.05395655f, -0.02962072f, 0.05034979f, 
    0.01515252f, -0.03812538f, -0.04156448f, 0.03772535f, -0.04049175f, -0.05823475f, -0.04954885f, -0.05022397f, 
    -0.06719754f, 0.03138225f, -0.06789622f, 0.03970112f, 0.05527378f, -0.02880147f, 0.01731116f, 0.02081959f, 
    0.04069200f, -0.03824308f, 0.01302145f, 0.04489044f, -0.05309989f, 0.04513769f, -0.01147953f, -0.02469695f, 
    0.01104609f, -0.03725223f, -0.05297413f, 0.04655360f, 0.03226395f, 0.01878331f, -0.04149704f, 0.01547834f, 
    -0.03268090f, -0.01603407f, -0.01336925f, -0.02698737f, -0.06546240f, -0.04879883f, -0.02184371f, 0.05001826f, 
    -0.00940175f, 0.01674983f, 0.00915593f, -0.04012500f, 0.00135334f, -0.04193294f, -0.05106042f, 0.03527194f, 
    -0.04507254f, 0.00509985f, 0.01489427f, 0.01509719f, 0.04137094f, -0.02428748f, 0.00312920f, 0.00505289f, 
    0.00794263f, -0.04943894f, 0.02058067f, -0.01396800f, 0.04006532f, 0.00611421f, 0.02209978f, -0.02001468f, 
    -0.02882912f, 0.03069494f, 0.04120611f, -0.00415881f, -0.05005740f, 0.01196494f, -0.04039050f, 0.03175528f, 
    0.02869380f, 0.02750356f, -0.03408271f, 0.01048231f, -0.02764531f, 0.03727104f, 0.04115079f, -0.04901816f, 
    0.01160217f, 0.03057100f, 0.01029017f, -0.04404791f, -0.01642485f, 0.00388903f, -0.00671183f, -0.02313078f, 
    0.05575607f, -0.03319084f, 0.03866414f, -0.02629821f, -0.00860583f, -0.06093843f, 0.04506250f, -0.02529836f, 
    0.04091616f, -0.06096936f, -0.02702147f, 0.00459570f, -0.05103867f, 0.00301933f, -0.03649743f, -0.05453078f, 
    -0.02043442f, 0.01708663f, 0.03263291f, -0.02373219f, -0.02043450f, 0.02004211f, -0.04192889f, 0.04247436f, 
    -0.05503925f, 0.04695003f, -0.01613226f, -0.03421481f, -0.01003409f, 0.03147387f, -0.00543230f, 0.01456818f, 
    0.01245930f, -0.01547991f, 0.02735272f, 0.03668321f, -0.00145517f, 0.01826131f, -0.05797948f, 0.01705611f, 
    0.01719289f, -0.02185721f, 0.04019023f, 0.03744376f, 0.00551404f, 0.03078697f, -0.03009904f, -0.00096061f, 
    -0.03413795f, 0.00055773f, 0.05026121f, 0.01462131f, 0.03293101f, -0.06064952f, -0.01890147f, -0.03054326f, 
    -0.04895209f, 0.01449206f, -0.03839490f, 0.00126411f, 0.06121327f, -0.03193089f, -0.02013651f, -0.05747167f, 
    -0.03367175f, 0.02537150f, -0.04662791f, -0.02914507f, -0.02503821f, 0.02724223f, -0.03990938f, 0.05546036f, 
    -0.05315572f, 0.03079152f, -0.03150603f, -0.03021092f, -0.01465571f, -0.06328821f, 0.00033667f, -0.01556247f, 
    0.01614411f, 0.02823560f, 0.02016505f, -0.05918899f, -0.05417426f, -0.01678726f, -0.00786478f, 0.01594795f, 
    -0.03701229f, -0.00555670f, 0.01610624f, -0.00525160f, -0.01778995f, -0.01032371f, 0.03818700f, -0.03322386f, 
    -0.01351183f, -0.01977393f, 0.03836708f, 0.04092658f, 0.03078337f, -0.04162671f, 0.03585526f, -0.05022018f, 
    -0.06113026f, 0.00265470f, -0.02566808f, 0.03342570f, -0.06011572f, -0.04710862f, 0.02611357f, 0.02413773f, 
    -0.00324240f, 0.04684708f, -0.01922504f, -0.00720532f, 0.05057937f, 0.01760065f, -0.02881162f, 0.04256625f, 
    -0.03714173f, -0.03323440f, 0.03545597f, -0.03288306f, -0.04826262f, -0.05774365f, 0.05718775f, -0.01232955f, 
    -0.30926886f, -0.34405050f, -0.23515174f, 0.15162581f, 0.00335724f, 0.09989858f, -0.07658966f, -0.14166455f, 
    -0.06277911f, -0.41236645f, -0.00504447f, -0.06844306f, -0.02278559f, -0.16006616f, 0.20776761f, -0.19685057f, 
    -0.13632147f, -0.19125496f, 0.32799998f, 0.15458296f, -0.03831952f, -0.01145294f, -0.01063177f, -0.03287771f, 
    0.18936239f, -0.13129851f, 0.13259414f, 0.18971883f, -0.14570698f, -0.24997748f, -0.04635111f, 0.01895035f, 
    0.14079835f, 0.02595893f, 0.09874442f, -0.13193955f, 0.00103326f, -0.19408225f, 0.10803832f, -0.12306434f, 
    0.05436697f, 0.02211292f, 0.10066286f, 0.04875151f, -0.09494191f, 0.32830679f, -0.00245085f, -0.25198227f, 
    -0.16246536f, 0.06063967f, -0.12216837f, 0.02450515f, 0.27329692f, 0.10233013f, 0.27611956f, 0.04430751f, 
    -0.08258265f, 0.09295014f, -0.00683016f, -0.12768339f, -0.14215514f, -0.00361964f, 0.01414705f, 0.26825202f, 
    -0.26121086f, -0.16299754f, -0.05551619f, -0.06951726f, 0.08833741f, 0.00183035f, 0.12461852f, 0.21917196f, 
    -0.23727012f, 0.15252848f, 0.00822813f, -0.00669059f, 0.07182139f, -0.09461064f, 0.25813320f, -0.07009131f, 
    -0.03705921f, 0.15762639f, 0.06878099f, -0.22998011f, 0.04970946f, -0.03960321f, 0.01016621f, 0.12449768f, 
    -0.06716488f, 0.27117926f, -0.02644183f, -0.12681358f, 0.03977355f, -0.19489974f, 0.06801575f, 0.02685587f, 
    -0.05080479f, 0.03685356f, -0.00330126f, 0.21324253f, 0.17277908f, 0.22132358f, 0.10735304f, -0.03116891f, 
    0.23976393f, -0.11333229f, 0.02145049f, 0.05151432f, 0.36876118f, 0.18772642f, -0.05574031f, 0.05855435f, 
    -0.09496182f, 0.01364188f, 0.08884334f, 0.07680737f, 0.09769589f, -0.23436862f, 0.14043088f, 0.28341851f, 
    0.08127704f, -0.30549964f, -0.19491485f, -0.13644485f, -0.07876719f, -0.03469579f, -0.05309711f, -0.22430424f, 
    0.11998194f, -0.04927238f, 0.10337323f, -0.11790225f, -0.07805397f, -0.10838401f, -0.23406421f, -0.47046855f, 
    -0.28397259f, -0.24587175f, 0.19820875f, 0.01528399f, 0.33479041f, -0.02701245f, 0.07917263f, 0.13602579f, 
    -0.39720511f, -0.16195352f, -0.14307383f, 0.27920797f, 0.00480907f, 0.04591192f, 0.05070559f, 0.11867873f, 
    -0.01832781f, -0.04199914f, 0.00795055f, -0.00598234f, -0.16383848f, -0.02220262f, 0.45339787f, -0.07654888f, 
    -0.12683713f, 0.11504336f, 0.17576478f, -0.22792986f, 0.34296995f, -0.09687518f, -0.15738508f, -0.25525561f, 
    0.06114172f, 0.20588885f, 0.07267375f, 0.30230859f, 0.06544534f, 0.24269609f, -0.11479076f, -0.07171249f, 
    -0.00514118f, 0.02790364f, -0.03335293f, -0.01923099f, -0.02411433f, 0.10644565f, -0.09503041f, 0.07069396f, 
    0.10713877f, 0.03351463f, 0.20784730f, -0.17421830f, 0.06492500f, -0.13591725f, -0.25662252f, 0.14915356f, 
    -0.01922241f, 0.01976569f, -0.05780210f, -0.27390376f, -0.00341465f, 0.01629345f, 0.14966245f, 0.11200755f, 
    -0.02991913f, 0.04240936f, -0.02885113f, 0.01454925f, -0.05377756f, 0.00977695f, -0.10212287f, -0.08882519f, 
    0.13700484f, -0.26954344f, 0.14897613f, 0.06124477f, 0.41171986f, 0.16575962f, -0.00215237f, -0.04603050f, 
    0.12516147f, -0.20969215f, -0.00984940f, -0.18402116f, -0.17001680f, -0.07758933f, 0.15594801f, 0.01782481f, 
    -0.08334044f, -0.07910529f, -0.00760764f, -0.28207737f, 0.00035695f, 0.06604923f, 0.26832142f, -0.06129186f, 
    -0.04370220f, 0.00919216f, 0.30089653f, -0.12087931f, -0.19357228f, -0.20670097f, -0.00923606f, -0.42958972f, 
    -0.21878703f, 0.20223838f, 0.00219194f, -0.19366241f, -0.35172367f, -0.31733581f, 0.06838242f, -0.00809465f, 
    0.03503064f, 0.02935957f, 0.00966603f, -0.17867491f, -0.36193085f, 0.08177126f, 0.07489996f, -0.00132729f, 
    0.00512890f, -0.08105262f, -0.19719769f, -0.15435721f, 0.01910715f, 0.12151662f, 0.07348727f, -0.19255611f, 
    -0.08472581f, -0.39931816f, 0.10348863f, 0.00444442f, 0.02184345f, 0.17473210f, 0.27009666f, 0.10518774f, 
    -0.21074492f, -0.05740362f, -0.02180628f, 0.05465140f, -0.14823976f, 0.15491226f, 0.06655946f, 0.05001934f, 
    -0.12361098f, -0.00020918f, 0.03041415f, -0.01931732f, -0.05784212f, 0.24376266f, -0.14955619f, 0.04972551f, 
    0.00235402f, 0.03933704f, -0.03980638f, 0.01812725f, 0.04622286f, -0.03191536f, 0.04030111f, -0.03952520f, 
    0.02147449f, -0.04979109f, -0.01919253f, -0.02335082f, -0.03238538f, -0.04845848f, -0.01975398f, 0.04401825f, 
    -0.05929916f, -0.03545502f, -0.04040625f, 0.01846059f, -0.02919437f, -0.03580483f, 0.03864765f, -0.01619810f, 
    -0.02309736f, 0.02511846f, 0.01071840f, -0.02492028f, -0.05105602f, 0.05568361f, -0.06493741f, -0.04488901f, 
    -0.03282056f, 0.02618750f, 0.03514860f, -0.00709838f, 0.00547604f, -0.01020290f, -0.05100182f, -0.05216904f, 
    0.00819114f, -0.05082103f, 0.02726577f, 0.02578704f, -0.01320329f, 0.04749684f, 0.03389149f, 0.02626394f, 
    0.03515229f, 0.05098259f, -0.01645141f, -0.06090841f, -0.01158752f, -0.04563482f, 0.01111298f, -0.06344712f, 
    -0.05879732f, 0.03616356f, 0.05253277f, -0.02986836f, -0.06545388f, -0.03953528f, 0.03348067f, 0.02439120f, 
    -0.03179137f, 0.01801243f, 0.02987321f, -0.03911277f, 0.04142537f, -0.04687076f, -0.01408549f, 0.00867819f, 
    -0.03060159f, 0.01439775f, -0.01612245f, 0.01202546f, 0.02416617f, 0.03342039f, 0.02787903f, -0.03320584f, 
    -0.04478712f, -0.05983397f, -0.02400708f, 0.01208085f, -0.06229408f, -0.06571428f, -0.05244802f, -0.00065098f, 
    0.02022550f, -0.05742054f, 0.00846716f, -0.02865694f, 0.00997863f, -0.04087925f, -0.05350566f, 0.05406978f, 
    0.01349370f, 0.02383970f, -0.05777866f, -0.05865375f, 0.03559276f, -0.00785499f, 0.03028852f, 0.01094114f, 
    0.01578840f, 0.02635122f, 0.02725297f, -0.04916963f, -0.01470528f, -0.05172376f, -0.02226124f, 0.00647154f, 
    -0.03093711f, -0.02445457f, -0.01435030f, 0.02196100f, 0.02976011f, -0.00776461f, -0.02704531f, -0.04028101f, 
    -0.04186901f, -0.03620550f, 0.01257788f, 0.04702473f, -0.02220035f, -0.00088495f, -0.04565187f, -0.01364790f, 
    -0.01875530f, 0.00597279f, -0.04224533f, 0.04013301f, -0.00666279f, 0.04228578f, 0.00705479f, -0.02756541f, 
    -0.01715057f, -0.01521407f, 0.03907533f, 0.01730658f, 0.00140176f, 0.00025867f, -0.02011765f, 0.04145805f, 
    -0.06081673f, -0.04963888f, -0.00195606f, -0.01096484f, -0.03053278f, -0.05788896f, 0.05027623f, -0.02512995f, 
    0.03090183f, -0.00164501f, 0.00268386f, -0.06959023f, -0.00235910f, -0.01775536f, -0.06211813f, -0.00339118f, 
    -0.05439953f, 0.03791335f, -0.02797101f, 0.04947361f, 0.03187402f, 0.02905873f, -0.02638484f, -0.04588448f, 
    0.04556951f, 0.04404034f, 0.02251909f, -0.05411537f, -0.01327852f, -0.03095113f, -0.00785569f, -0.01803906f, 
    0.00887166f, -0.04625234f, -0.00989271f, 0.01563139f, -0.05145377f, -0.06645007f, -0.00204907f, 0.02686589f, 
    0.04381420f, -0.06462362f, 0.04713635f, -0.05875779f, 0.01661031f, 0.01812502f, 0.00886196f, -0.03787688f, 
    0.03365515f, 0.05326725f, -0.04517425f, -0.05085285f, -0.03417953f, 0.01608279f, 0.00715162f, -0.02044911f, 
    -0.02315320f, 0.02802689f, 0.04969949f, 0.01640619f, 0.03477332f, -0.00896385f, 0.05759836f, 0.00260917f, 
    0.01114625f, 0.00014803f, -0.03538134f, -0.02592285f, -0.01981244f, -0.05854441f, 0.03558799f, 0.01522346f, 
    0.03737057f, 0.05077463f, -0.00421730f, -0.02208244f, -0.05758052f, -0.02263853f, -0.05813249f, 0.02984736f, 
    0.01617515f, -0.01346607f, 0.01617515f, -0.05914785f, 0.03888794f, -0.01499882f, 0.02829231f, 0.03013634f, 
    -0.00957493f, 0.02674538f, 0.00417437f, -0.02779779f, -0.04427401f, -0.02376772f, -0.04802912f, -0.02215806f, 
    -0.06114689f, -0.01261169f, 0.01043674f, -0.04592463f, 0.03159428f, -0.05433647f, -0.06496453f, -0.02002935f, 
    -0.00562262f, -0.05111028f, 0.00331255f, -0.05467644f, 0.00056194f, 0.03774827f, -0.02478007f, 0.03683399f, 
    -0.02007414f, 0.02625941f, 0.04203097f, -0.04618758f, -0.02609439f, -0.04070284f, -0.06212930f, -0.05780711f, 
    -0.04804072f, -0.00832258f, -0.04918758f, -0.05435168f, -0.01747396f, 0.03721953f, 0.02419338f, -0.01857454f, 
    -0.00618772f, -0.01426785f, 0.01232950f, -0.01729539f, 0.00245186f, 0.01960238f, -0.02027296f, 0.00115534f, 
    0.03709328f, 0.02893925f, 0.00172559f, -0.01203407f, -0.05556650f, 0.02643768f, 0.03196207f, -0.05494677f, 
    0.01013316f, -0.02997801f, -0.03265226f, -0.01092444f, -0.03026366f, -0.00595859f, -0.01773033f, -0.05653398f, 
    -0.03465620f, -0.04866289f, 0.01432287f, -0.00532572f, 0.04665315f, -0.00549052f, 0.01148303f, -0.02779019f, 
    0.01361782f, -0.02019986f, 0.02541517f, -0.01888497f, -0.01313622f, -0.01129738f, -0.05501632f, -0.00154681f, 
    0.00054688f, -0.04820731f, -0.05497633f, -0.06377055f, 0.01077633f, 0.01583689f, 0.05234126f, -0.03187105f, 
    -0.00197893f, 0.04197106f, 0.05039334f, -0.03330420f, 0.03725966f, 0.02854917f, 0.02582563f, 0.03075999f, 
    -0.03375249f, 0.03091007f, -0.00398134f, -0.01790643f, 0.02894085f, 0.04936641f, -0.00503089f, 0.04784076f, 
    0.03515980f, -0.04142711f, -0.03879653f, -0.01256966f, -0.03304766f, 0.04988036f, 0.01123954f, -0.05364396f, 
    0.03870653f, 0.01285920f, 0.01964641f, -0.04364722f, 0.01360530f, -0.02613522f, -0.04492344f, -0.00523811f, 
    -0.02085037f, -0.06420960f, -0.03661349f, -0.04290302f, 0.03648975f, -0.06196675f, -0.03313988f, 0.03700763f, 
    -0.01715017f, 0.05303755f, 0.02597130f, -0.01792165f, -0.05247644f, -0.04505161f, 0.03781961f, -0.01322166f, 
    -0.01311367f, -0.06215132f, 0.03738406f, 0.03729307f, -0.03909023f, -0.03727293f, 0.02037371f, 0.02396531f, 
    0.00522462f, 0.02729857f, -0.03116220f, 0.00731637f, 0.04628500f, -0.05297128f, -0.06090903f, 0.01561475f, 
    -0.03123721f, -0.01227670f, -0.04286993f, -0.01741020f, -0.04102157f, -0.05392804f, 0.03393055f, 0.02996861f, 
    -0.02526143f, 0.04900246f, 0.00411216f, -0.01690158f, -0.00753073f, 0.01180588f, 0.02357510f, 0.01351753f, 
    -0.06384914f, 0.01917533f, -0.00450789f, 0.00356747f, 0.02780147f, -0.06243913f, -0.00522553f, -0.00935878f, 
    0.00220350f, -0.00661561f, -0.04005861f, 0.04473983f, -0.04729357f, 0.00126550f, -0.02790904f, 0.00348452f, 
    -0.05174450f, -0.04330844f, 0.03858200f, -0.04604159f, 0.02932104f, 0.00124269f, 0.04390032f, 0.01791197f, 
    -0.01424346f, -0.04481750f, -0.04384629f, -0.00919953f, 0.03598244f, -0.02725809f, -0.00314024f, 0.03880166f, 
    0.04045000f, 0.03774744f, -0.01458038f, -0.04755526f, -0.00276084f, -0.06064364f, -0.05330302f, -0.05785912f, 
    -0.01616080f, -0.01237830f, 0.03991855f, 0.05101810f, -0.02225796f, 0.03327093f, -0.03539062f, 0.01951495f, 
    -0.02309953f, -0.04027849f, -0.03685655f, -0.01986096f, -0.03410688f, 0.01673440f, -0.03397046f, 0.04943306f, 
    -0.01840627f, 0.04215620f, -0.04985461f, -0.02539574f, 0.03668728f, 0.02506371f, -0.02470570f, 0.03750922f, 
    -0.05575508f, -0.02654363f, 0.00867794f, -0.01641416f, 0.01271560f, -0.05310640f, 0.00402915f, -0.04318999f, 
    0.00028280f, -0.00030593f, -0.02403995f, -0.00968924f, 0.02138219f, 0.01733620f, 0.02751297f, 0.05310685f, 
    0.00732084f, -0.01373883f, -0.04784051f, -0.01873014f, -0.06443423f, 0.03478685f, 0.02544284f, -0.05797768f, 
    0.05263516f, 0.00706244f, 0.00660481f, -0.03258017f, 0.04645479f, 0.02524662f, -0.05391695f, -0.01294248f, 
    0.03939584f, -0.00443655f, -0.03712595f, -0.04797845f, -0.06318109f, -0.05270081f, -0.05125898f, -0.02703086f, 
    -0.00703306f, -0.04133685f, -0.06386411f, -0.02976094f, 0.00714631f, 0.03873324f, -0.01366926f, -0.05483258f, 
    -0.01793549f, 0.00348891f, -0.04847853f, 0.03112390f, 0.02149962f, -0.02830357f, 0.04438744f, 0.04658449f, 
    -0.03695372f, -0.06301099f, -0.03717747f, -0.01851647f, 0.02202835f, -0.03081751f, -0.03013106f, 0.00164283f, 
    -0.03148039f, 0.04621840f, -0.01960508f, -0.00132272f, -0.05706352f, -0.05589059f, -0.03478497f, 0.01695026f, 
    0.02150503f, -0.06120297f, -0.04530622f, -0.04632692f, -0.04336891f, -0.05151171f, -0.03970775f, -0.02844306f, 
    0.02449751f, 0.00287584f, -0.02632980f, 0.01252619f, -0.05362861f, -0.03287587f, 0.01369791f, -0.00435783f, 
    0.00194621f, 0.04718794f, -0.01295664f, 0.02146516f, 0.01684784f, 0.00232143f, 0.03454255f, -0.05558973f, 
    0.02657254f, -0.05446872f, 0.05264619f, -0.03299462f, -0.01522321f, -0.03924743f, -0.02432875f, -0.05227034f, 
    -0.05232509f, 0.01112295f, -0.03822005f, 0.02044961f, -0.02334562f, -0.00031573f, 0.02529323f, -0.04452976f, 
    -0.05516626f, -0.05235603f, -0.01355374f, -0.13221562f, 0.05572065f, 0.00854048f, 0.01147441f, 0.11284652f, 
    0.12722276f, 0.21745951f, 0.04556104f, 0.15452306f, -0.15327409f, 0.21991150f, -0.05472617f, 0.14940110f, 
    -0.06440307f, -0.26864287f, 0.12643358f, 0.17535451f, 0.09364273f, 0.12324437f, 0.02996620f, 0.08483791f, 
    -0.03519470f, 0.01670593f, -0.11113309f, -0.31031585f, 0.38853484f, -0.57905799f, -0.04340749f, 0.12383017f, 
    0.31475329f, -0.06969360f, 0.25499827f, -0.24092402f, -0.49258476f, -0.24602680f, -0.26886448f, -0.09572665f, 
    0.03722195f, -0.03951462f, 0.05621941f, 0.08800197f, 0.12791342f, -0.15946740f, -0.22520135f, 0.25400048f, 
    0.09537060f, -0.04718950f, -0.03540798f, -0.08660624f, 0.09004237f, 0.31279624f, 0.44402477f, -0.02189631f, 
    0.17769687f, -0.10428324f, -0.11629131f, 0.09624179f, 0.02928172f, -0.03990195f, 0.17135169f, -0.10927894f, 
    -0.08186801f, 0.29302600f, 0.20909686f, 0.11895344f, 0.04333310f, -0.23760487f, -0.10890270f, 0.09570681f, 
    0.34039736f, -0.04042406f, 0.20570746f, 0.14670496f, -0.01310635f, -0.02454194f, -0.06105917f, 0.10033140f, 
    -0.12284333f, 0.24850534f, -0.00528238f, -0.18346386f, -0.35670707f, -0.07849903f, 0.07787921f, 0.03822660f, 
    -0.01770007f, -0.00707655f, 0.40962958f, -0.26180208f, 0.33044451f, 0.06461141f, 0.04161696f, 0.09979978f, 
    0.15148433f, -0.11500177f, 0.00990853f, 0.41786358f, 0.46555972f, -0.08896553f, -0.05533328f, 0.09405985f, 
    -0.06396022f, -0.04007414f, 0.14992599f, -0.14666785f, -0.13982625f, -0.08151424f, -0.17816752f, 0.18844403f, 
    0.03367073f, 0.06089415f, -0.11602563f, -0.14794105f, 0.02575565f, 0.07631855f, -0.12251034f, -0.11788104f, 
    -0.15772264f, 0.16293199f, -0.01015091f, 0.08541583f, -0.06960075f, -0.18416966f, -0.13923281f, 0.19218862f, 
    0.18286178f, 0.22266008f, 0.01607168f, -0.16392128f, 0.01434926f, -0.12528241f, -0.08690833f, -0.41199133f, 
    0.36750433f, -0.08569393f, 0.20473196f, 0.11413717f, -0.16744854f, -0.06612439f, 0.02317033f, 0.06885017f, 
    -0.01353749f, -0.35942781f, 0.09627947f, -0.05427653f, -0.08572255f, 0.04003040f, -0.18135680f, -0.09236203f, 
    -0.12943307f, 0.02249793f, 0.16434398f, -0.06508300f, -0.20522122f, 0.01747355f, -0.34863853f, -0.04201180f, 
    0.12716261f, -0.09163639f, -0.07065355f, -0.24138919f, -0.40259033f, -0.05160550f, 0.22244947f, 0.09872431f, 
    0.00377684f, 0.13652988f, -0.06946979f, 0.17312925f, -1.26393688f, -0.18179065f, -0.12613727f, 0.04727691f, 
    -0.17129238f, -0.16506264f, 0.18870009f, -0.28385320f, 0.02023938f, 0.16306326f, -0.10168977f, -0.08043768f, 
    -0.15745313f, 0.12959446f, 0.15190469f, -0.06674082f, 0.21031655f, -0.46622849f, -0.27204555f, -0.42008576f, 
    0.29207760f, 0.14353593f, 0.00709212f, 0.09053221f, 0.02512506f, 0.27470326f, -0.10722666f, -0.11531395f, 
    0.13882256f, 0.02566386f, -0.12368975f, -0.26342940f, 0.06071132f, 0.11682341f, 0.12020206f, -0.36208811f, 
    0.14761885f, 0.06981622f, 0.22081971f, -0.03535195f, -0.09628297f, 0.00112160f, 0.09777135f, -0.13347466f, 
    0.56430346f, -0.27186263f, 0.28915167f, 0.04803743f, -0.09307222f, -0.01656303f, 0.09463967f, 0.07148322f, 
    0.07963633f, -0.56867528f, -0.08901329f, -0.22543177f, 0.13372953f, 0.05009961f, 0.08676729f, -0.16547550f, 
    -0.00895064f, 0.03896549f, 0.47297525f, -0.07392354f, 0.12466405f, -0.16279469f, -0.15070982f, 0.02475781f, 
    0.03302561f, 0.07378647f, 0.24662761f, -0.05662365f, 0.06395575f, -0.04588085f, -0.09609355f, -0.05723195f, 
    0.24996458f, -0.03496107f, 0.21173650f, 0.02791434f, -0.19121054f, 0.15744887f, 0.06836128f, 0.09087488f, 
    -0.14049308f, 0.07707658f, -0.15722801f, -0.02555549f, -0.06691884f, 0.40586489f, 0.02535096f, -0.05965545f, 
    -0.09392606f, 0.04419507f, 0.16459218f, -0.19440743f, 0.10310585f, -0.07485292f, -0.20886670f, -0.14526787f, 
    -0.20242374f, 0.24393755f, 0.05566599f, -0.10577618f, 0.02604009f, -0.08068628f, 0.00755230f, 0.09743817f, 
    0.09164809f, -0.23521110f, 0.05002808f, 0.05264208f, -0.11957610f, 0.17763563f, 0.02157620f, -0.08564098f, 
    -0.69147670f, 0.07522471f, 0.23187788f, -0.14573231f, -0.00017010f, 0.01318421f, -0.01918707f, 0.06166327f, 
    -0.11241926f, -0.00504335f, 0.06699943f, -0.12748106f, 0.27204359f, 0.00577924f, -0.06408328f, -0.13334747f, 
    -0.00012988f, 0.00388735f, -0.14737463f, 0.40441039f, 0.03562567f, 0.29399773f, -0.08393156f, 0.07599173f, 
    -0.00765423f, 0.02778565f, -0.04956957f, 0.31780848f, -0.08642688f, 0.03251326f, 0.10376135f, -0.04644074f, 
    0.00715821f, -0.10413630f, -0.20293075f, -0.15817128f, -0.22448775f, -0.16005418f, 0.08201120f, -0.04662587f, 
    0.10352580f, 0.05040720f, -0.10136907f, -0.05146154f, -0.04810146f, 0.01447268f, 0.15835369f, 0.22103201f, 
    -0.17102757f, 0.01577391f, 0.03484945f, 0.10162021f, 0.05516317f, -0.09003303f, 0.49312496f, -0.18646091f, 
    0.01432796f, -0.00200397f, -0.19830322f, 0.05188629f, 0.16411707f, 0.07521496f, 0.00649259f, -0.28991827f, 
    0.47347760f, 0.24428992f, -0.10464850f, 0.03796872f, -0.15257786f, -0.21356168f, 0.01670229f, -0.10045741f, 
    -0.22967362f, -0.02021020f, -0.11024180f, -0.06011689f, -0.01225765f, -0.00376235f, -0.06634661f, 0.06299339f, 
    0.12531038f, 0.53624070f, -0.25353044f, -0.10310498f, -0.12703443f, -0.05859080f, 0.00894535f, -0.06076963f, 
    0.14525026f, 0.00131408f, 0.03453934f, 0.04724906f, -0.18325979f, -0.04464051f, 0.07068398f, 0.15887193f, 
    0.03071610f, 0.04723836f, 0.01552075f, 0.43817863f, 0.09138604f, -0.15474305f, 0.02606965f, 0.04306723f, 
    -0.13192514f, 0.12384976f, -0.13015249f, -0.26017502f, 0.04878157f, 0.18608518f, -0.08766854f, 0.14045335f, 
    -0.05701660f, 0.00961144f, -0.03205734f, 0.29174340f, -0.17288342f, 0.42396200f, -0.17363819f, -0.01442580f, 
    -0.15126604f, 0.05849129f, -0.03887714f, -0.02029294f, 0.07439008f, 0.19533023f, -0.11081617f, -0.09481610f, 
    -0.17885743f, 0.16900308f, -0.01173864f, 0.09534860f, 0.03251353f, -0.09990010f, 0.06059360f, -0.48995402f, 
    0.21720856f, 0.32324779f, -0.07790372f, 0.21882723f, -0.10918332f, 0.03712782f, -0.09192108f, 0.08721659f, 
    0.01414436f, -0.30613911f, -0.16946752f, 0.08304860f, -0.11159527f, 0.08227688f, -0.01767337f, -0.01625627f, 
    0.03901203f, 0.05582858f, -0.38319549f, -0.21886578f, -0.10626859f, -0.26142606f, 0.01859174f, -0.18535310f, 
    -0.06158768f, 0.05798287f, 0.11045252f, 0.14465402f, -0.04246867f, 0.27554902f, 0.11859407f, 0.01723177f, 
    -0.12434288f, 0.16752310f, 0.10813061f, 0.33145720f, -0.08715671f, -0.12900390f, 0.06116086f, -0.07541346f, 
    -0.02461070f, 0.04696326f, -0.08007287f, 0.05894237f, -0.42607340f, 0.17079018f, 0.06674612f, -0.13102974f, 
    -0.13992222f, 0.06405347f, -0.18481886f, 0.11942644f, 0.00062499f, -0.07034383f, -0.10672238f, -0.08948257f, 
    0.09816040f, 0.17496310f, -0.23786035f, -0.31442344f, -0.04307625f, -0.11962633f, 0.20125651f, -0.15660167f, 
    -0.15936244f, -0.11256643f, 0.03842995f, 0.06950660f, -0.06884824f, 0.09568573f, 0.07757264f, -0.44344825f, 
    0.03037262f, 0.27821639f, -0.05915176f, 0.23070300f, -0.04068421f, 0.25314519f, -0.05122923f, 0.06745957f, 
    -0.04764716f, 0.01800534f, 0.22067863f, -0.11006057f, -0.02351568f, -0.03245509f, -0.03305123f, -0.13829584f, 
    -0.01361921f, -0.56709599f, 0.15577878f, 0.07355100f, -0.17281277f, 0.10072680f, 0.08324464f, -0.12085567f, 
    0.29325327f, -0.09610276f, 0.30393717f, -0.15995361f, -0.14121066f, -0.09402777f, -0.10282598f, 0.24206492f, 
    -0.20867509f, -0.03171526f, 0.02813728f, -0.00880956f, -0.22305509f, -0.10571664f, -0.10495117f, -0.05625520f, 
    0.19094972f, 0.06133108f, -0.00635281f, -0.01466429f, -0.22291113f, 0.03781390f, 0.06799097f, -0.00527452f, 
    -0.11054806f, 0.11555906f, -0.06705457f, 0.10170764f, 0.04805264f, 0.35536176f, 0.01021047f, 0.24384356f, 
    0.10290111f, -0.08230090f, 0.15236150f, 0.12814450f, -0.06599304f, -0.08985149f, 0.38882017f, 0.08394115f, 
    -0.06044808f, 0.07670183f, -0.00446878f, -0.02579691f, -0.44230357f, 0.01590762f, 0.07881431f, 0.23572440f, 
    0.15269160f, 0.22563621f, 0.10030685f, -0.10906590f, -0.19188184f, -0.02076263f, 0.10403886f, -0.12806794f, 
    -0.17127772f, -0.11205122f, -0.33869660f, 0.08446258f, -0.00919723f, 0.25019208f, 0.08403514f, -0.00330353f, 
    -0.33965260f, 0.05055042f, 0.04511111f, 0.11030219f, -0.07099967f, 0.04137659f, 0.15270346f, 0.06949087f, 
    0.10967178f, -0.34032410f, -0.29728562f, 0.22512069f, 0.14229687f, -0.12429091f, -0.06720269f, -0.12116752f, 
    -0.06595288f, 0.10625017f, 0.13639057f, 0.13167439f, 0.10816029f, 0.05157362f, 0.13205998f, -0.17036629f, 
    0.16402639f, -0.01473992f, 0.17851146f, 0.02644022f, 0.04572511f, 0.19907027f, 0.00125399f, 0.10954124f, 
    0.01452949f, 0.27595693f, 0.01560296f, 0.22587319f, -0.09661063f, 0.01992312f, -0.11420128f, -0.06791715f, 
    0.05530984f, 0.14921553f, -0.06783537f, 0.31536973f, 0.14226627f, 0.17445733f, -0.19604036f, 0.14406568f, 
    0.12567085f, 0.28603509f, -0.09091285f, 0.18598010f, -0.08688255f, -0.02165217f, -0.19425532f, -0.10335054f, 
    0.11551523f, -0.30757785f, 0.25538871f, 0.01306054f, -0.06136021f, 0.03976372f, -0.21681705f, -0.03717321f, 
    -0.29066059f, 0.10437655f, -0.06095470f, 0.14330913f, 0.01712626f, -0.15017928f, 0.03949790f, 0.08254630f, 
    0.03390025f, 0.04804775f, 0.24652627f, -0.16346774f, 0.12151399f, 0.11574572f, 0.29396480f, 0.25139019f, 
    -0.02114211f, -0.27777517f, -0.29514855f, 0.07142958f, 0.10945465f, -0.02292331f, 0.01664204f, -0.02880519f, 
    -0.14191861f, -0.04466894f, 0.22771123f, -0.02533703f, -0.02371531f, 0.09104405f, 0.12601130f, 0.24359359f, 
    0.01303653f, -0.06158007f, -0.04590457f, -0.01388726f, 0.09982171f, 0.04449018f, 0.05402605f, 0.08615475f, 
    0.17615497f, -0.24255168f, 0.11974117f, 0.05431342f, 0.06224388f, 0.14725070f, 0.05556065f, 0.08838880f, 
    -0.07742186f, -0.04430488f, 0.15436180f, 0.01922778f, 0.11303981f, -0.03269146f, 0.12600613f, 0.04356406f, 
    0.29997477f, -0.04601029f, 0.00095797f, 0.08279756f, 0.03764618f, -0.08664146f, -0.08851076f, -0.12057062f, 
    0.02790856f, -0.11683147f, 0.01420311f, 0.11088941f, -0.13018601f, -0.03070015f, -0.06220277f, -0.10612265f, 
    -0.23500311f, 0.15382020f, -0.10325251f, 0.25821701f, 0.12619235f, 0.11519003f, 0.13240819f, 0.09341606f, 
    -0.37617913f, 0.26360908f, -0.02738698f, -0.06270366f, 0.04004256f, 0.17457148f, 0.11485095f, 0.27911326f, 
    -0.15083100f, -0.22818169f, 0.27139506f, 0.02115597f, 0.07439152f, 0.20198554f, 0.01274715f, -0.02144439f, 
    -0.05772866f, 0.09091995f, 0.03563279f, 0.00640270f, 0.18757434f, 0.09260290f, -0.10061216f, 0.02950529f, 
    0.13117196f, -0.02034064f, 0.15392606f, -0.09045837f, -0.27052262f, -0.08449101f, -0.20321174f, 0.06688668f, 
    0.30777889f, 0.03212029f, -0.13729946f, -0.11115923f, -0.31406644f, -0.17738245f, -0.07302012f, 0.36252984f, 
    0.13404535f, -0.20368554f, 0.10218906f, 0.18178849f, 0.12662473f, 0.28501704f, 0.05768655f, -0.08136895f, 
    0.21842253f, -0.13892706f, 0.01458680f, 0.23751102f, -0.09389902f, -0.15480335f, 0.13521622f, 0.11778738f, 
    -0.03442504f, -0.38006204f, -0.04227857f, 0.17329554f, 0.10197093f, 0.10981132f, -0.10924835f, -0.02773783f, 
    0.07013169f, -0.19308986f, -0.02902676f, 0.16802368f, 0.29631323f, -0.06912529f, -0.01196538f, -0.26045123f, 
    0.01466489f, -0.28501734f, -0.17374471f, -0.18773659f, -0.02629662f, 0.04759905f, -0.06850845f, 0.23568912f, 
    -0.14021495f, -0.18166234f, -0.32852128f, 0.14902782f, 0.13047145f, 0.08709577f, 0.02540070f, -0.02744357f, 
    -0.13792317f, 0.03582083f, -0.05058446f, -0.19625524f, 0.00992830f, -0.25981715f, -0.17771505f, 0.04530479f, 
    0.22760831f, 0.14092235f, -0.07934342f, -0.47976971f, 0.02276384f, 0.05062159f, -0.10254472f, -0.37050101f, 
    -0.06786954f, -0.04427153f, 0.12458500f, -0.09242164f, -0.32067901f, -0.03950817f, -0.03166735f, -0.19707693f, 
    0.06309403f, -0.13793649f, -0.09702864f, 0.00689192f, 0.07605916f, -0.24802090f, 0.10701524f, 0.23246881f, 
    -0.05286060f, 0.18235983f, -0.09942563f, -0.06907462f, -0.20406651f, 0.30540273f, 0.21505409f, -0.20265172f, 
    0.17811352f, 0.12694046f, 0.17508326f, -0.18273963f, -0.01369303f, -0.01244118f, 0.07797495f, -0.29169452f, 
    -0.00874694f, 0.05394084f, 0.01248548f, -0.03420416f, 0.03957989f, -0.04968141f, 0.01045578f, -0.00003402f, 
    0.03851261f, -0.03773278f, 0.01205845f, 0.03000589f, -0.04533848f, 0.01122599f, -0.01704236f, 0.00251156f, 
    -0.06182080f, 0.04774966f, 0.02635368f, -0.03366213f, -0.00951761f, 0.04063105f, -0.05713016f, -0.07044008f, 
    0.03205070f, 0.03095351f, -0.01432726f, -0.03648394f, 0.04397334f, -0.05217721f, -0.05227098f, -0.06008747f, 
    -0.06394228f, -0.00393301f, -0.02029996f, 0.00706826f, 0.02748593f, -0.00117440f, -0.02085640f, 0.00388916f, 
    -0.00248708f, -0.05518294f, -0.06218323f, 0.01969917f, 0.02747611f, -0.02986914f, -0.00020885f, -0.00452626f, 
    -0.04962048f, 0.01310789f, 0.00468973f, -0.06207469f, 0.01077609f, -0.00964710f, 0.00363471f, -0.04662241f, 
    -0.04178448f, 0.00192564f, -0.02648797f, 0.04696156f, 0.04999524f, -0.04730400f, -0.05957026f, 0.01779203f, 
    0.00075967f, 0.00722751f, -0.02873593f, -0.05097564f, 0.04590472f, -0.04538380f, 0.03634432f, 0.04808176f, 
    0.01028293f, 0.01384253f, -0.04972115f, -0.04802234f, 0.00361432f, 0.00650862f, -0.01709850f, 0.02949855f, 
    0.00285519f, -0.01022398f, 0.01348083f, 0.04804971f, -0.05509058f, -0.00404482f, 0.03041850f, -0.04254724f, 
    0.04162931f, 0.04156361f, -0.05412597f, 0.00295961f, -0.02701779f, 0.03438504f, 0.01451279f, -0.05472913f, 
    0.00573394f, -0.06514058f, -0.04878664f, 0.01576890f, 0.02449968f, -0.06237163f, -0.05382339f, 0.02573946f, 
    0.01458798f, -0.01857251f, 0.03859256f, -0.03425645f, 0.00737257f, -0.06398937f, -0.01364927f, -0.01682292f, 
    0.01410996f, 0.01580037f, 0.00268701f, 0.05126268f, 0.04610433f, -0.01533921f, -0.06060701f, 0.02401220f, 
    -0.00242266f, 0.04735733f, 0.01492576f, -0.02359445f, -0.00171157f, -0.04006462f, -0.01186749f, 0.03083001f, 
    -0.02087997f, -0.01969600f, 0.04932073f, 0.00580402f, 0.01102223f, 0.04112668f, -0.05459557f, -0.06421877f, 
    -0.00151446f, 0.00302656f, 0.01242732f, 0.04952836f, -0.03621642f, -0.05964748f, 0.01892276f, 0.00025717f, 
    0.01664339f, -0.04702742f, -0.02617241f, -0.05486127f, 0.01370732f, 0.02547345f, 0.00863529f, -0.00872625f, 
    -0.05027679f, -0.00713426f, 0.01498338f, -0.00489270f, -0.04358621f, -0.00562731f, -0.01407207f, -0.03460156f, 
    0.00611678f, -0.01371857f, 0.00531493f, -0.06820269f, 0.01488040f, -0.03829084f, 0.03594230f, 0.04138593f, 
    -0.04629259f, -0.02137380f, -0.03330651f, 0.02950254f, 0.00037298f, 0.03335397f, 0.00447027f, -0.01574522f, 
    0.05370789f, 0.02454599f, -0.02721598f, 0.00203800f, -0.00783867f, 0.00968075f, 0.02813118f, -0.04803255f, 
    0.01454109f, -0.02993412f, -0.01089525f, -0.03914383f, 0.02034893f, 0.04298827f, -0.00819235f, 0.03128983f, 
    -0.03464526f, -0.05817241f, -0.02345565f, -0.03213441f, -0.05547685f, 0.03472531f, 0.00577457f, -0.05285691f, 
    0.01347914f, -0.03218551f, 0.01764540f, -0.04810590f, 0.03133879f, 0.02578956f, -0.05599362f, -0.00662969f, 
    0.00551200f, -0.00558151f, -0.02535826f, -0.00319598f, 0.03851157f, 0.00206352f, -0.00731603f, -0.00959933f, 
    0.02273789f, -0.01264270f, -0.06769645f, -0.01560444f, 0.04265266f, -0.02888273f, -0.05085450f, 0.04765133f, 
    0.01884477f, -0.04705602f, -0.04383560f, -0.01078016f, -0.03251837f, 0.03024524f, -0.00114731f, 0.01812833f, 
    0.02607815f, -0.01301138f, -0.04046250f, -0.06117548f, -0.02918565f, -0.00889871f, -0.02501740f, 0.04138979f, 
    -0.03397008f, 0.01440095f, -0.05550676f, -0.04844918f, 0.01051500f, 0.01707102f, 0.01065744f, -0.00288111f, 
    0.03726147f, 0.04639376f, -0.00825572f, -0.03223516f, 0.01432626f, 0.01098755f, -0.03147653f, -0.05103446f, 
    -0.03101115f, 0.01428276f, 0.00669614f, -0.00813618f, -0.03434734f, -0.04996404f, -0.06240617f, 0.04286638f, 
    -0.02332262f, -0.00197781f, 0.00745106f, 0.05492778f, -0.05392207f, 0.02444184f, 0.01155976f, 0.03328979f, 
    0.00876371f, -0.06213742f, 0.02807836f, 0.04159715f, -0.00181066f, 0.03499022f, 0.04330133f, -0.04557923f, 
    -0.05593949f, -0.06013755f, -0.05900890f, -0.04521951f, 0.04045655f, 0.04618761f, 0.04767796f, 0.00126789f, 
    -0.96651179f, -0.03052693f, 0.04028522f, 0.08549310f, 0.20281363f, 0.00918489f, -0.09589241f, -0.04668722f, 
    -0.09387822f, -0.11495073f, -0.10421910f, -0.00855716f, 0.16369173f, 0.17160457f, 0.10069582f, -0.12460548f, 
    0.03133963f, 0.04537225f, -0.22670998f, -0.35563517f, 0.04868414f, 0.21373139f, -0.12277888f, 0.03686399f, 
    -0.15066300f, 0.10025009f, -0.08148643f, 0.05555435f, -0.08877665f, -0.11903714f, 0.28480157f, 0.02947115f, 
    -0.10062402f, 0.17770712f, 0.15168183f, -0.14556056f, -0.16224548f, 0.16040452f, 0.13612422f, -0.06042070f, 
    -0.03208247f, 0.07106161f, -0.19167143f, -0.17325954f, -0.22917227f, 0.23095006f, 0.47884893f, 0.13085236f, 
    -0.05552039f, -0.03921843f, 0.03931794f, -0.23120891f, 0.14656456f, 0.26336515f, 0.48250344f, 0.36129642f, 
    -0.13757657f, -0.15643717f, 0.23769082f, -0.11208798f, 0.21959256f, 0.16088113f, -0.05848692f, -0.82882589f, 
    -0.60417420f, 0.01196369f, 0.05144297f, 0.01091188f, 0.17839801f, -0.05209278f, -0.09320231f, -0.26426858f, 
    -0.52555805f, -0.41622454f, -0.04561275f, -0.09515981f, -0.10633558f, 0.10836761f, 0.07642874f, 0.11572917f, 
    0.00090601f, -0.15526804f, -0.01603528f, -0.32310277f, -0.04289280f, -0.19243751f, -0.21615173f, 0.28664896f, 
    0.10374673f, 0.20312652f, 0.02761829f, -0.01370153f, -0.00469462f, 0.19468063f, -0.11305374f, 0.01464576f, 
    0.14673561f, 0.08523201f, -0.15233177f, 0.14986719f, 0.03604381f, -0.15560481f, 0.16095565f, 0.24391043f, 
    0.03328903f, 0.12632151f, -0.04629890f, 0.03229302f, 0.61368906f, 0.28418103f, -0.18916115f, 0.06421387f, 
    0.19725111f, 0.12129171f, 0.00019915f, 0.03272521f, 0.03084122f, 0.01291480f, -0.23685317f, -0.06868546f, 
    0.15595613f, 0.01608031f, -0.25930890f, -0.03779510f, 0.07755843f, -0.15319565f, 0.16472346f, 0.29133785f, 
    0.02770904f, 0.23625311f, 0.12159991f, 0.04500560f, 0.04416821f, 0.40002722f, 0.08303882f, -0.60104543f, 
    -0.38264012f, -0.12284481f, 0.02403055f, 0.02826854f, 0.04537772f, 0.02046338f, 0.02896888f, -0.05154164f, 
    -0.44536540f, -0.20224623f, -0.29729313f, -0.13762112f, 0.06437576f, 0.11698696f, 0.13542908f, 0.26402745f, 
    0.29391852f, 0.03031256f, -0.17412762f, -0.23898125f, 0.09223858f, -0.07537109f, 0.05622853f, -0.20194103f, 
    0.29770693f, 0.23113224f, 0.29008800f, 0.25666040f, 0.31394982f, 0.11249772f, 0.00876358f, 0.19532238f, 
    0.00134839f, -0.09432855f, -0.15276431f, 0.06467897f, -0.14606670f, -0.16055305f, -0.03154369f, 0.06995895f, 
    -0.14284423f, -0.08782348f, -0.03101102f, -0.11758935f, -0.32592967f, -0.38385013f, -0.04682291f, -0.04662824f, 
    0.01150080f, 0.10427459f, 0.08653123f, -0.12976740f, -0.13786650f, -0.31342822f, -0.05692922f, 0.18462078f, 
    -0.22081503f, 0.04287430f, 0.37268078f, -0.13866156f, -0.18898001f, -0.23213340f, 0.42069525f, 0.24618343f, 
    -0.11450188f, 0.05388018f, -0.01379145f, 0.16716950f, 0.17903870f, 0.10348342f, 0.04510448f, -0.53921098f, 
    -0.54478157f, 0.39701307f, 0.09677480f, -0.00432385f, -0.05453693f, -0.09196601f, -0.26587051f, -0.11602523f, 
    -0.11468570f, 0.06206976f, 0.19532743f, 0.05375587f, -0.13690186f, 0.07313715f, -0.10768477f, -0.01902107f, 
    0.10702324f, -0.22633849f, -0.31436861f, -0.21776000f, 0.10927531f, 0.04589421f, -0.00433718f, 0.09616126f, 
    -0.05193058f, -0.00478237f, 0.14921157f, -0.13501360f, 0.03233388f, 0.00486953f, 0.13563035f, -0.31732675f, 
    0.27247146f, 0.17752832f, -0.01396461f, -0.35702038f, -0.24952145f, -0.07540959f, 0.17528324f, 0.25846565f, 
    -0.08689538f, -0.06462535f, 0.07882600f, -0.08750211f, -0.08484284f, -0.06884348f, -0.14432471f, 0.17543486f, 
    0.31649801f, -0.34421760f, 0.02473136f, 0.08660064f, 0.20446341f, -0.11219794f, -0.15234385f, 0.00711615f, 
    -0.19120926f, 0.05204380f, -0.17794406f, 0.08065549f, -0.00048205f, 0.19412746f, 0.32751682f, 0.36597306f, 
    -0.03396125f, -0.07318459f, 0.02456318f, -0.13967034f, -0.06697760f, 0.02156025f, -0.03069142f, -0.03269568f, 
    -0.14838672f, -0.16732663f, -0.14587921f, -0.10888021f, -0.01860312f, 0.10303914f, -0.08199052f, 0.17106375f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03714420f, -0.01028771f, -0.05748101f, 0.07015339f, -0.03659575f, -0.02253637f, -0.02505369f, -0.02591472f, 
    -0.22165656f, 0.03175253f, -0.02086803f, -0.02202134f, -0.00558390f, -0.10267708f, -0.00947711f, -0.08572049f, 
    0.04096315f, 0.16326997f, 0.03863830f, 0.13604847f, -0.00448283f, 0.14442432f, 0.07669513f, -0.03461575f, 
    0.19639194f, -0.05345568f, -0.05234919f, 0.00777237f, 0.00383826f, 0.10355704f, -0.02281409f, 0.16359223f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.58105081f, 0.16564132f, 0.09965419f, -0.26988530f, 0.47413370f, -0.12662373f, -0.28129566f, 0.18877929f, 
    -0.20701717f, 0.02034707f, -0.51109624f, 0.10553088f, -0.18191636f, 0.37676281f, 0.12535310f, 0.45753849f, 
    -0.11107021f, 0.23978356f, 0.14672852f, -0.17813775f, 0.13554478f, -0.74984348f, 0.46680835f, 0.06728028f, 
    -0.25483468f, 0.07305465f, 0.07287875f, -0.14004239f, -0.16803792f, 0.28422230f, 0.15192811f, 0.01736946f, 
    0.05166024f, -0.12079255f, 0.08733758f, 0.06913236f, -0.01858949f, 0.14285192f, 0.07128572f, 0.49991834f, 
    0.24581572f, 0.00090059f, -0.29254812f, -0.47451571f, -0.05970836f, 0.25637546f, 0.07379542f, -0.48345789f, 
    0.13815707f, 0.52918917f, 0.10589977f, -0.28733692f, 0.05326148f, 0.33763707f, 0.18349238f, 0.13094203f, 
    -0.35492650f, -0.16611393f, 0.04857821f, 0.46337450f, -0.21571778f, -0.41621032f, 0.04796355f, 0.05040080f, 
    -0.25665918f, 0.06703793f, -0.12653477f, -0.17160447f, -0.11777898f, -0.11461292f, 0.41491500f, -0.73564523f, 
    -0.33313963f, -0.44791424f, -0.00073521f, -0.44987664f, -0.04623267f, 0.46167508f, 0.07950166f, 0.41827431f, 
    -0.00870699f, -0.20858510f, -0.04988324f, -0.13396414f, 0.05844929f, -0.27787858f, -0.14548041f, -0.06755533f, 
    0.39632154f, -0.14218810f, 0.15368114f, 0.72832161f, 0.52559316f, 0.16732860f, 0.01808137f, -0.53819317f, 
    0.20000002f, -0.05396507f, 0.08341740f, -0.65803498f, -0.19905514f, 0.12635562f, -0.14933039f, 0.04833163f, 
    -0.68979132f, 0.13494438f, 0.27872056f, 0.67382175f, -0.05324452f, -0.44366843f, 0.03334623f, 0.68915683f, 
    -0.05110003f, -0.26443675f, -0.05738992f, -0.46944070f, 0.00209695f, -0.35690224f, -0.45066166f, 0.17039618f, 
    0.04647968f, 0.13123742f, -0.10560028f, -0.06711178f, 0.28767273f, 0.13736759f, -0.13265048f, 0.42324445f, 
    -0.41165265f, -0.08980722f, -0.11990067f, 0.15661465f, -0.78129733f, 0.01638273f, -0.52409077f, -0.04646231f, 
    -0.01002130f, 0.11696026f, 0.22742137f, -0.02322146f, 0.16209398f, -0.06181515f, 0.10952849f, -0.00779812f, 
    0.09650220f, 0.26523131f, 0.04017342f, 0.17204338f, 0.16712552f, -0.18380205f, -0.49927187f, 0.00774342f, 
    0.01179181f, 0.13583875f, -0.14966018f, 0.23299874f, -0.17720276f, 0.43641445f, -0.04646070f, -0.17522737f, 
    0.22001809f, 0.11491458f, -0.07742147f, -0.33512360f, -0.24619617f, 0.03992882f, 0.11600003f, 0.01251337f, 
    0.30008206f, 0.39207622f, -0.78897280f, -0.45488250f, -0.10600599f, -0.60230654f, 0.03512455f, -0.30192730f, 
    -0.04843152f, 0.10882740f, -0.13132608f, 0.35278282f, 0.02731122f, 0.38563699f, 0.12640214f, -0.00910902f, 
    0.20532474f, -0.00300854f, 0.10728898f, -0.45893589f, -0.47349191f, -0.25704473f, 0.13548131f, -0.21577381f, 
    -0.31435052f, -0.17312302f, 0.13792427f, 0.02229634f, 0.69672304f, -0.07481127f, -0.48997340f, -0.60750973f, 
    -0.92080098f, -0.03285655f, 0.03431581f, 0.27325672f, -0.04973917f, -0.69661540f, -0.14040047f, -0.12026566f, 
    -0.03021380f, 0.11438557f, 0.15557122f, 0.23494919f, -0.05529919f, 0.13592631f, -0.01609552f, 0.06940270f, 
    -0.22944252f, -0.17332101f, -0.08318458f, -0.44961581f, 0.73633862f, -0.03268598f, -0.06072787f, -0.37575760f, 
    0.08961739f, -0.09649928f, 0.11497633f, 0.11934046f, -0.34808791f, -0.05346527f, -0.32155389f, 0.44334453f, 
    0.99116707f, -0.07044077f, -0.27101982f, 0.23748894f, -0.16006610f, 0.42041036f, 0.06229920f, 0.37876490f, 
    0.00856061f, -0.04601059f, 0.14341407f, -0.34139994f, -0.11858705f, -0.28960332f, -0.23708910f, -0.00574235f, 
    -0.33326229f, -0.12278295f, -0.13733266f, -0.21915177f, -0.30906540f, -0.04724002f, -0.05356438f, -0.03161350f, 
    0.54285192f, 0.06923849f, 0.04945309f, 0.56711280f, 0.28230006f, 0.00166851f, 0.43594000f, 0.06856683f, 
    -0.34454140f, -0.23178351f, 0.30351672f, -0.00607836f, -0.02408739f, -0.05558743f, -0.09606992f, -0.07306484f, 
    -0.16871417f, -0.87186724f, 0.11698932f, -0.03177541f, -0.08493956f, 0.41895527f, 0.11096579f, 0.13402390f, 
    -0.53475082f, -0.00285188f, -0.04689188f, 0.00530608f, -0.97063494f, -0.55829668f, -0.05724849f, -0.41802123f, 
    -0.04469482f, -0.07671306f, 0.17956273f, 0.05847519f, -0.72191089f, -0.04338774f, -0.65509844f, -0.47948462f, 
    -0.12667321f, -0.12079212f, 0.73138970f, -0.37525961f, -0.06363069f, 0.43802533f, 0.14814718f, 0.15534280f, 
    -0.16313608f, -0.34379587f, 0.04040922f, 0.28932118f, -0.07574303f, -0.11152551f, 0.67604607f, 0.00479727f, 
    -0.19733246f, 0.05189987f, -0.10898529f, -0.44160667f, -0.33034441f, 0.11128576f, -0.00589813f, -0.22412531f, 
    -0.01788715f, -0.15313642f, 0.03821864f, 0.60628295f, 0.07979262f, -0.12291845f, 0.51395309f, -0.14851043f, 
    -0.55315268f, -0.15158923f, -0.05333761f, -0.29034618f, -0.11646211f, -0.00818981f, 0.07011440f, -0.20716381f, 
    0.13773428f, -0.56186807f, -0.07108991f, -0.22316518f, 0.09700800f, 0.00419263f, -0.70774579f, -0.08455857f, 
    0.58450818f, -0.09377611f, -0.06864125f, -0.09578700f, 0.08653080f, -0.15827601f, 0.07660587f, 0.84404284f, 
    0.81515479f, -0.03753959f, -0.11627710f, -0.85973394f, 0.20884341f, -0.15439799f, -0.03112279f, -0.05904034f, 
    -0.02692229f, -0.54105860f, 0.23914216f, 0.17616268f, 0.15223588f, -0.47884905f, 0.11169005f, -0.43546304f, 
    0.04729119f, -0.13912274f, 0.07479621f, 0.31154731f, 0.11857796f, -0.82087249f, -0.46567759f, -0.13693033f, 
    0.67914021f, 0.00687377f, -0.08065335f, 0.00166826f, -0.33765507f, 0.16984679f, 0.15511996f, -0.08663763f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03297653f, -0.00301591f, -0.00347308f, -0.06461455f, 0.10754286f, 0.14701509f, 0.07244411f, -0.47334489f, 
    -0.30129844f, -0.04877234f, -0.06917265f, -0.10545675f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
