#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.61249667f, -0.63769090f, 0.63316590f, 0.95936227f, -0.99007356f, -0.79046303f, -0.39692473f, 0.05763665f, 
    0.66006196f, -0.27824205f, 0.21683133f, 0.60147226f, -0.64939290f, -1.43197799f, -1.49171746f, 0.34640169f, 
    -0.39310563f, -0.50483310f, 1.00259292f, 0.21554606f, 0.05725592f, 0.44770327f, 0.37762725f, 0.43013868f, 
    -0.50924724f, -0.63734657f, -0.51976424f, -0.37633884f, -0.87864459f, -0.37925959f, 0.77852923f, -0.57959443f, 
    0.86375016f, 0.33479682f, -0.22440661f, -0.96720618f, -1.78995693f, -0.26414770f, -1.09221911f, 0.02099741f, 
    0.06923192f, 0.27979982f, 0.58701146f, 0.45924163f, 0.77778471f, 0.03096414f, -1.35505712f, 1.95867550f, 
    -0.34786686f, -0.61253846f, 0.87208802f, 0.19660082f, 0.04388092f, 0.10148427f, -0.44383487f, 0.68044782f, 
    -0.45134974f, -1.27548385f, -0.68343371f, -0.93942416f, 0.47678152f, -0.23865388f, 1.11384571f, -0.33194843f, 
    -0.12181205f, 1.37276256f, 0.38501242f, 0.50370300f, -0.56423223f, 0.13446751f, -0.64359093f, 0.08266450f, 
    -1.55951011f, -0.38740402f, -0.59120101f, -0.77173561f, -0.98849267f, -0.83288562f, -0.10800911f, -0.61448008f, 
    -0.65556473f, 0.23947433f, -0.84407967f, -0.65618718f, 0.80128598f, 1.05156112f, 0.50797516f, 0.39074180f, 
    0.52128309f, 0.46661761f, -0.55683166f, 0.29195920f, 0.42750126f, -0.66597110f, 0.31497583f, 0.08805062f, 
    0.64893985f, 1.07743347f, 0.48486394f, 0.08099597f, 0.70565045f, 0.49900723f, 1.00934017f, 0.73905534f, 
    -0.07764420f, 0.21636331f, 0.55197024f, 0.28924012f, 0.19194856f, -0.15877023f, -1.59385192f, 0.06532417f, 
    -1.04090476f, -0.67399454f, -1.14332712f, -0.70503563f, 0.15106097f, -0.31083837f, -1.33891797f, -1.18976796f, 
    -0.13740088f, 1.29984272f, 0.38299426f, -0.32978445f, -0.58476901f, -0.64108199f, 0.51465243f, 1.13433933f, 
    1.03471363f, 0.06036314f, -0.37565565f, -0.53548759f, -0.04573996f, -0.25234234f, -0.04994021f, 0.71385330f, 
    0.24656187f, 0.95179743f, -0.91225600f, 1.44502759f, -0.57871586f, 0.09761298f, -0.11580534f, 0.35931775f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23409280f, 0.26841471f, 0.67669702f, 0.79694951f, 0.83814806f, 0.00967986f, 0.12764804f, 0.90595561f, 
    -0.47901088f, 0.22189163f, 0.17962982f, 0.37106070f, 0.98470396f, -0.48176044f, 0.38065547f, 0.35957733f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.31549257f, 0.02333980f, 0.58618355f, 0.02568833f, -0.29230282f, 0.15028313f, 0.05197642f, 0.35366333f, 
    -0.01067345f, -0.21759219f, -0.48094091f, -0.18419623f, -0.06132594f, -0.11451631f, 0.18055551f, 0.05895328f, 
    -0.03914894f, 0.09373299f, 0.06379929f, 0.02701821f, 0.19615629f, -0.20227587f, -0.11425446f, 0.03292644f, 
    -0.03202635f, -0.12090581f, 0.14842761f, 0.27795160f, -0.28291744f, 0.08179821f, 0.18803613f, -0.03887457f, 
    0.12313726f, 0.06707280f, -0.13481997f, 0.36126819f, -0.41410980f, -0.06148729f, 0.01245019f, 0.00738614f, 
    -0.03086807f, -0.13353157f, -0.14363101f, 0.05364217f, -0.05708646f, -0.01937015f, -0.08189029f, 0.09142211f, 
    -0.00778148f, 0.17045081f, 0.34024000f, -0.10329626f, -0.03513582f, 0.28950253f, -0.42381024f, -0.70618606f, 
    -0.22998528f, 0.15160596f, -0.23756972f, 0.06928077f, -0.08397726f, -0.09368747f, 0.01265041f, -0.13788161f, 
    -0.13946483f, -0.10705579f, 0.06450400f, 0.08339734f, 0.10069877f, 0.13751891f, 0.24252707f, 0.36700004f, 
    0.00452686f, 0.27476186f, -0.10913496f, -0.19944306f, -0.05338507f, 0.10057048f, 0.10334309f, 0.18168026f, 
    0.03413551f, -0.47074336f, -0.17193533f, -0.32026216f, -0.19972923f, 0.00893403f, 0.03122726f, -0.17442474f, 
    0.14836603f, -0.15826206f, -0.03282037f, 0.00545445f, -0.05063222f, 0.00676749f, 0.12338082f, -0.13525398f, 
    0.09191257f, 0.15534677f, 0.13931900f, 0.07167409f, 0.21103628f, 0.00215736f, 0.07170595f, 0.07690147f, 
    -0.13586509f, 0.05836062f, -0.03545516f, 0.02031258f, 0.04047526f, -0.13590786f, -0.22172640f, 0.13300730f, 
    -0.25609371f, 0.26420182f, 0.19372822f, -0.11981136f, 0.08961298f, -0.14299540f, -0.02539119f, -0.40369064f, 
    -0.15194884f, 0.25143862f, -0.34056070f, -0.09249841f, -0.26430675f, 0.13541746f, 0.66409510f, -0.13299403f, 
    0.12266310f, 0.03890907f, -0.04437054f, 0.03733454f, 0.12806146f, 0.11281728f, 0.02312728f, 0.45729369f, 
    0.04931731f, -0.04276299f, -0.18625577f, -0.01180202f, -0.09008446f, 0.00543229f, 0.13743515f, 0.01020588f, 
    0.05446896f, -0.09312718f, -0.10601389f, -0.08755060f, -0.00396941f, -0.01553103f, 0.06626537f, 0.03759795f, 
    0.02548019f, 0.00133605f, -0.04490022f, -0.07692369f, -0.01122616f, -0.02900737f, -0.08428291f, 0.05744484f, 
    0.06458115f, 0.01398221f, -0.04584008f, -0.03237576f, -0.06644219f, 0.02448025f, -0.02051309f, 0.02331539f, 
    0.03005097f, -0.09812377f, -0.00476429f, -0.06048894f, 0.05000852f, 0.02851154f, -0.07430813f, -0.08745725f, 
    -0.08746887f, -0.08933817f, -0.09015970f, -0.05688170f, -0.06260664f, 0.01020201f, -0.00228500f, -0.04932946f, 
    -0.08429179f, -0.02071569f, 0.00143143f, -0.03363894f, -0.06741069f, 0.01116848f, -0.08298947f, -0.04825851f, 
    0.03285828f, -0.08541916f, -0.01406593f, -0.00546372f, -0.01103467f, 0.01924168f, -0.00742714f, -0.05627050f, 
    -0.07160055f, 0.02404632f, -0.07902926f, -0.09888443f, -0.08923168f, 0.05984809f, -0.02006274f, -0.00569341f, 
    -0.11980274f, -0.01199669f, 0.00331431f, -0.00625638f, 0.04745903f, -0.09736592f, -0.04998679f, 0.01458522f, 
    -0.04566528f, 0.01654127f, -0.04869049f, -0.00700417f, -0.00035823f, -0.02734259f, -0.05538424f, 0.01499215f, 
    0.06467648f, -0.07849421f, 0.04408262f, -0.03203781f, 0.01260980f, -0.07175195f, 0.02517106f, -0.01460949f, 
    -0.04234166f, -0.09431638f, -0.08893923f, 0.01427665f, 0.02442932f, -0.05881954f, -0.07399167f, 0.04636985f, 
    -0.08464580f, -0.10302029f, 0.00783912f, -0.02360935f, -0.02179222f, -0.01795180f, 0.02551068f, -0.07684449f, 
    -0.03365539f, -0.08348686f, 0.04638319f, -0.07851414f, -0.08919711f, 0.04074121f, -0.06129886f, 0.06352346f, 
    -0.06335972f, -0.03257086f, -0.04485737f, -0.00991881f, 0.02862277f, 0.03912257f, 0.03007339f, 0.06951440f, 
    -0.00348384f, -0.06130138f, -0.01596986f, -0.08392161f, -0.00362343f, -0.04443666f, 0.04544551f, -0.07220235f, 
    0.01755548f, 0.04086636f, -0.11126510f, 0.02849464f, -0.03389531f, -0.00379608f, -0.07259880f, 0.02467533f, 
    -0.10882235f, 0.06153666f, -0.00095421f, -0.10610208f, -0.06205618f, -0.01025573f, 0.02332680f, -0.01073598f, 
    -0.42510578f, -0.43521991f, -0.59150052f, -0.05338382f, 0.10253005f, -0.07096912f, 0.17691344f, -0.09211687f, 
    0.06300429f, 0.03290966f, -0.04970112f, 0.10235915f, -0.37698969f, -0.29402506f, 0.12828967f, -0.19820645f, 
    0.01647403f, 0.16924526f, 0.64778370f, 0.24539651f, 0.35827854f, -0.04752178f, 0.16956033f, 0.10356863f, 
    -0.09362558f, -0.03822822f, -0.07996631f, -0.04037402f, -0.01545225f, -0.08401662f, 0.21312091f, 0.07903916f, 
    0.22297058f, -0.08126356f, 0.32845271f, -0.09694171f, -0.21319370f, -0.46708491f, -0.21547641f, 0.08326031f, 
    0.07714812f, 0.25945413f, -0.08207266f, 0.07565781f, 0.16720577f, 0.00250644f, -0.68287981f, -1.38750303f, 
    -0.22783200f, 0.18689558f, -0.09803455f, 0.19379635f, 0.32892835f, -0.19519997f, 0.25188503f, -0.22209519f, 
    -0.27528089f, -0.32360002f, -0.22908647f, -0.33512551f, -0.18194912f, 0.12491231f, 0.36667490f, 0.16844706f, 
    0.29776159f, 0.35479009f, 0.15634252f, 0.16693988f, 0.23467450f, 0.17677379f, 0.11131128f, 0.16822904f, 
    0.47078153f, 0.02638454f, 0.15072206f, 0.03490160f, -0.24282767f, -0.04467249f, -0.07658663f, 0.08363145f, 
    -0.42395788f, -0.05156901f, -0.80843389f, -0.49573973f, 0.13476175f, -0.04819867f, 0.11097098f, -0.06664596f, 
    0.19969265f, 0.12849194f, 0.08079778f, 0.12027004f, -0.07335466f, 0.12667142f, -0.33734661f, -0.08213416f, 
    0.20851976f, -0.19429006f, -0.01161173f, -0.08392096f, -0.04498661f, 0.33787674f, -0.05053311f, -0.09567782f, 
    0.00921433f, 0.09971976f, -0.00169588f, -0.09539876f, 0.37692752f, -0.15751468f, -0.06314472f, 0.29815912f, 
    0.13505141f, -0.16538680f, 0.17353728f, 0.06986737f, -0.19151773f, 0.29053104f, 0.43442506f, 0.47882369f, 
    0.12201922f, -0.13624543f, -0.06733767f, 0.07558373f, -0.11067757f, -0.33045167f, -0.95127070f, -0.02094151f, 
    0.37698236f, -0.13912964f, -0.21163595f, 0.35852656f, -0.02630930f, 0.12893061f, 0.12219880f, -0.15373243f, 
    -0.48022664f, -0.39040977f, 0.02806129f, -0.01456391f, 0.21299857f, 0.12485529f, -0.05676892f, 0.23719254f, 
    -0.02401205f, 0.05753276f, 0.05377102f, -0.06388970f, 0.02158056f, -0.02585381f, 0.00379585f, 0.02029314f, 
    -0.04357603f, -0.01001194f, -0.03398661f, 0.04578799f, 0.04203380f, 0.00772537f, -0.07261160f, 0.01166078f, 
    -0.03768821f, -0.05768086f, -0.00061343f, 0.03760010f, 0.03269813f, 0.00457804f, -0.01649489f, -0.04729157f, 
    -0.08863803f, 0.03796525f, -0.03383552f, 0.02293218f, -0.08529527f, 0.07026931f, 0.02638301f, 0.04999445f, 
    -0.04620096f, 0.05641168f, -0.05148858f, -0.08171616f, -0.00454658f, -0.06308961f, -0.03349801f, 0.05318096f, 
    0.03480241f, 0.04224949f, 0.00941830f, -0.05171808f, -0.00682211f, -0.04369874f, -0.06651759f, -0.05130723f, 
    0.04299719f, 0.06278895f, 0.03877444f, -0.00104966f, -0.06982108f, 0.07483233f, 0.00080590f, 0.07070883f, 
    -0.03118027f, -0.04286066f, 0.04545566f, -0.06156528f, -0.07649065f, 0.02314111f, 0.03539957f, 0.04992231f, 
    -0.04764982f, -0.05274505f, 0.01381032f, -0.08236293f, -0.07796089f, -0.08363860f, -0.07140880f, -0.06882902f, 
    -0.02573414f, -0.04308085f, -0.07289046f, 0.00951228f, -0.00655606f, 0.05100638f, -0.02721936f, -0.05604169f, 
    0.05404111f, -0.05623875f, 0.07867334f, -0.05077733f, -0.06242989f, 0.06220115f, -0.01651369f, 0.03427588f, 
    -0.01195519f, -0.08266517f, -0.01260154f, -0.02415657f, 0.02492537f, 0.03462819f, 0.04833699f, 0.03027198f, 
    -0.03326386f, 0.07326625f, -0.04485483f, -0.04751423f, -0.03982529f, -0.00031464f, 0.05562339f, -0.03523161f, 
    0.05533287f, -0.04568902f, -0.07071310f, -0.02921931f, -0.08461124f, -0.08256552f, 0.00288993f, -0.06195598f, 
    -0.07603775f, -0.02950469f, -0.04314180f, -0.03194144f, -0.08066332f, -0.01740046f, -0.02432626f, -0.01194101f, 
    0.02492961f, 0.08192497f, -0.08509655f, -0.03037916f, -0.06422400f, -0.07602324f, 0.03019528f, 0.03845434f, 
    0.00130255f, 0.06769510f, -0.08583997f, 0.03108861f, -0.03935061f, 0.03881254f, -0.09128610f, -0.08748133f, 
    -0.06756371f, 0.08329580f, 0.04131720f, -0.06684779f, -0.04157465f, -0.01373840f, 0.02127522f, 0.06243697f, 
    0.28125387f, 0.09825613f, -0.37131265f, 0.43007436f, -0.07071386f, -0.05553705f, 0.47718284f, 0.19745027f, 
    0.01721984f, 0.17974548f, 0.28177923f, 0.29637319f, 0.14100841f, -0.11523972f, 0.18909158f, -0.01173304f, 
    0.17573597f, -0.10093170f, -0.29519391f, -0.03714560f, 0.32113922f, 0.05159090f, -0.03196002f, 0.05533578f, 
    -0.15229595f, -0.20214356f, -0.21870545f, -0.00710161f, 0.08341868f, -0.48907834f, 0.10310385f, -0.13653670f, 
    0.04034099f, -0.10777848f, -0.30519518f, -0.39793617f, 0.29936320f, -0.00493799f, -0.62701869f, -0.18260148f, 
    -0.09915212f, -0.24927619f, 0.28730458f, 0.23258245f, 0.03085520f, 0.23628704f, 0.46796712f, -0.24553494f, 
    0.13188231f, 0.32569394f, -0.15054144f, 0.05661285f, -0.20936915f, 0.12123659f, 0.02104371f, 0.36000150f, 
    0.15523928f, 0.04241910f, 0.13428079f, 0.02676476f, -0.05724902f, 0.00153642f, 0.09539042f, -0.25854418f, 
    -0.22136497f, -0.07762938f, 0.10483302f, -0.09023655f, 0.03611323f, -0.20089233f, -0.50448209f, -0.45163569f, 
    0.15809672f, 0.39487875f, 0.21077168f, -0.13409416f, -0.14884534f, 0.16137649f, 0.12381037f, -0.14594482f, 
    0.04489272f, 0.17112148f, -0.13588597f, -0.04212420f, 0.00025960f, 0.20470725f, -0.12550780f, 0.22481540f, 
    0.13645135f, 0.19624096f, 0.08448283f, -0.01022307f, 0.22808751f, -0.01275449f, 0.00350080f, -0.03870712f, 
    0.23141339f, 0.19403017f, 0.43189713f, 0.06051067f, 0.32816735f, 0.56409442f, -0.09140747f, -0.34213361f, 
    -0.10778359f, -0.01433736f, -0.13979897f, 0.14814274f, 0.14124538f, 0.48161075f, -0.50303763f, 0.05218492f, 
    0.05262545f, 0.00626210f, 0.10640521f, -0.13068148f, 0.07227865f, -0.20414135f, -0.47706589f, -0.47975352f, 
    -0.14723772f, 0.07558805f, -0.04339793f, -0.05970705f, -0.17529801f, -0.16521831f, 0.00707773f, -0.41642129f, 
    -0.09458790f, 0.01700275f, -0.05525544f, -0.04815715f, -0.03842433f, 0.30947414f, 0.25981152f, -0.03392783f, 
    0.13360767f, 0.07851845f, 0.14732051f, -0.03853612f, -0.07751762f, 0.30865121f, -0.17003965f, 0.02379862f, 
    -0.00837100f, 0.16438679f, 0.09590453f, 0.05514725f, -0.17255880f, 0.13276629f, -0.01944111f, -0.07525609f, 
    0.08728474f, 0.00684709f, -0.02143264f, 0.19818120f, 0.07335030f, -0.14241096f, 0.15414985f, -0.02550454f, 
    0.08119319f, -0.00174843f, 0.07928260f, 0.02234134f, -0.01450878f, 0.09894822f, 0.00873042f, 0.03957844f, 
    -0.05418577f, 0.11777089f, 0.07588743f, 0.11890804f, 0.16938397f, 0.03772576f, -0.11355774f, -0.07234841f, 
    0.08076630f, 0.10737863f, -0.04702481f, 0.06171259f, -0.11279381f, -0.16010335f, 0.02420731f, -0.01594450f, 
    0.04323274f, -0.03445636f, -0.14010483f, -0.03363491f, 0.11886907f, -0.06992528f, 0.00402930f, -0.32628471f, 
    -0.06197250f, 0.03445789f, -0.13446186f, 0.09179480f, 0.21439281f, -0.04669678f, -0.11965247f, -0.03121084f, 
    0.10990036f, 0.03610544f, -0.10420353f, 0.03540222f, -0.08699299f, 0.06404960f, 0.02270343f, 0.14641841f, 
    0.08532760f, 0.07943619f, -0.10599602f, 0.03023080f, -0.17692170f, 0.04228429f, 0.06920127f, 0.02257711f, 
    -0.07821365f, 0.11094462f, 0.20405638f, 0.00305067f, -0.04015828f, 0.01404867f, -0.01225628f, 0.05979543f, 
    0.05330915f, 0.12897944f, -0.24906433f, 0.01600712f, -0.04525892f, 0.09935179f, -0.04523316f, -0.16598108f, 
    -0.09622912f, -0.05231857f, 0.04864493f, -0.05340683f, -0.13332932f, -0.10330503f, -0.01989925f, -0.13016222f, 
    -0.12617300f, 0.05612685f, 0.09110257f, -0.11435982f, -0.01556452f, -0.11931002f, -0.04096691f, -0.00479926f, 
    -0.13793921f, -0.25867847f, 0.02739686f, -0.17702848f, 0.06947131f, 0.07810955f, 0.26249272f, 0.02572160f, 
    -0.11437944f, 0.06250520f, 0.13843188f, 0.11912025f, 0.00761444f, 0.19374809f, 0.25814071f, 0.33815691f, 
    -0.10077228f, -0.04651666f, 0.12652631f, 0.01691228f, -0.10144300f, 0.02074690f, 0.14133905f, 0.18065138f, 
    -0.02186222f, -0.03227670f, -0.16205366f, -0.21167947f, -0.04863870f, -0.10010792f, -0.10143187f, 0.30255771f, 
    -0.14389308f, -0.14320339f, -0.19904983f, 0.01233357f, -0.15500388f, -0.11754316f, -0.12689845f, -0.10937933f, 
    0.19900152f, 0.19531897f, 0.92847818f, -0.24063168f, 0.21522553f, 0.08773012f, 0.13452756f, 0.13070251f, 
    0.06239722f, -0.35462749f, -0.28827000f, -0.11637269f, -0.09841646f, 0.12193931f, 0.06509696f, 0.25111264f, 
    -0.02758934f, 0.00970618f, 0.17680821f, 0.03218302f, 0.12137801f, -0.11479548f, -0.08316376f, 0.08209550f, 
    -0.32321391f, -0.02594751f, 0.19245687f, 0.11705481f, -0.55513513f, 0.02850501f, 0.03268566f, -0.22857422f, 
    -0.25007579f, -0.05314514f, -0.03691618f, -0.20342489f, 0.57705003f, -0.30097255f, -0.36448374f, 0.03335758f, 
    0.18692105f, 0.06222895f, 0.22810540f, -0.08830696f, -0.16233554f, -0.43252325f, 0.41448113f, -0.07752460f, 
    -0.29512900f, 0.13903831f, 0.05584184f, -0.14043948f, 0.15144667f, -0.14610723f, -0.27099887f, 0.37228033f, 
    0.00399488f, 0.17178452f, 0.15243597f, 0.16670109f, -0.05776710f, 0.02855653f, 0.07008241f, -0.12059425f, 
    0.30876538f, 0.06706367f, -0.06848399f, 0.27927813f, -0.26281804f, -0.18212001f, 0.21352157f, -0.07906274f, 
    0.38869244f, -0.19184436f, 0.34336218f, -0.02387553f, 0.11815576f, -0.07806242f, 0.07832839f, 0.09409959f, 
    0.33069000f, 0.05558479f, -0.13834782f, -0.22474143f, 0.01597950f, -0.30318886f, -0.01633648f, -0.04990235f, 
    -0.09775423f, -0.19470641f, 0.16241796f, 0.21122795f, 0.18317872f, 0.26775432f, 0.02044398f, 0.14376195f, 
    0.16135605f, 0.03584102f, 0.32143724f, 0.32678321f, 0.23778021f, 0.09360434f, -0.01102796f, -0.14546035f, 
    -0.13580552f, -0.11702404f, -0.06089533f, 0.00996177f, -0.18218024f, -0.46389925f, -0.09501804f, 0.03026497f, 
    -0.03106125f, 0.04189452f, -0.00880802f, -0.19801392f, -0.32291955f, 0.28660780f, -0.25629726f, -0.16120653f, 
    -0.06021392f, -0.26045617f, -0.05819953f, -0.17376179f, 0.09272854f, -0.00189446f, -0.11762939f, 0.07447651f, 
    -0.26843005f, 0.04604792f, 0.11108296f, -0.03414395f, 0.23563917f, -0.04301186f, 0.17567156f, -0.07022659f, 
    0.42218646f, -0.01809148f, -0.02344559f, 0.16175851f, -0.06271211f, 0.12074962f, 0.07529704f, 0.07665575f, 
    0.06684914f, -1.17804801f, 0.18517970f, -0.00589886f, 0.28969601f, 0.31329042f, 0.27431113f, -0.08297405f, 
    -0.25207210f, 0.21168083f, -0.21485078f, -1.10797012f, 0.00029070f, 0.12151892f, -0.27316400f, 0.15482445f, 
    0.05300789f, 0.25042093f, -0.00936422f, 0.10951538f, -0.01096567f, -0.02584292f, -0.13229619f, -0.07110143f, 
    0.03359572f, 0.01739242f, 0.62020606f, 0.68633282f, 0.02101246f, 0.73313659f, -0.03230463f, 0.04763441f, 
    0.04622326f, 0.22977675f, 0.15087201f, 0.60821158f, -0.97549736f, 0.38777709f, 0.53690654f, 0.06683433f, 
    0.09285159f, -0.38787946f, -0.10545333f, 0.11341828f, 0.18655069f, -0.08055321f, -0.33825970f, -0.56893653f, 
    -0.00984706f, -0.22834608f, 0.28016078f, 0.08361550f, -0.06049115f, 0.01372716f, -0.21748926f, 0.16726834f, 
    -1.03447878f, -0.04484036f, 0.00460502f, 0.11774955f, -0.02494316f, -0.14651555f, -0.03553283f, -0.41306224f, 
    -0.22424252f, 0.52069652f, 0.08197527f, 0.05701719f, -0.15699053f, 0.16541043f, 0.33654296f, 0.30950248f, 
    -0.28557646f, 0.23345964f, 0.42402139f, -0.26815170f, -0.20949569f, 0.09545928f, -0.01407272f, 0.05968438f, 
    -0.01284611f, -0.04194141f, 0.20888111f, 0.41000691f, -0.08811833f, -0.24313137f, -0.27496269f, -0.15372621f, 
    -0.00912976f, 0.10678374f, -0.02883599f, -0.15113562f, -0.15626380f, -0.19596207f, -0.19328655f, 0.10589521f, 
    0.23043133f, -0.10213052f, 0.12503749f, -0.11489369f, -0.14787915f, 0.10278890f, -0.01900774f, 0.13552237f, 
    -0.01359386f, 0.16449143f, 0.14441949f, -0.20117773f, -0.13799131f, -0.47727665f, -0.57700592f, -0.03237012f, 
    0.00686003f, 0.21863110f, 0.16033116f, 0.02130763f, 0.06749399f, -0.08505248f, -0.48086318f, -0.46720564f, 
    -0.45666814f, -0.11838154f, -0.13295232f, 0.20193763f, -0.10715783f, -0.19395676f, 0.27736214f, -0.54314351f, 
    -0.20112678f, 0.22422557f, 0.17459999f, 0.02560563f, -0.10626664f, -0.01177307f, 0.20427607f, 0.01665786f, 
    -0.78794408f, -0.02175520f, 0.28932202f, 0.25697434f, 0.07931325f, 0.11988830f, 0.13978928f, -0.10915245f, 
    -0.07181999f, 0.01279837f, 0.07506286f, -0.08131929f, -0.00836052f, -0.08165392f, 0.04451843f, 0.05118964f, 
    -0.01121374f, -0.02735513f, -0.05264962f, -0.05267572f, -0.00323518f, -0.02720473f, 0.05289695f, 0.01134848f, 
    -0.03422847f, 0.02818230f, 0.05921525f, -0.03929775f, 0.04609649f, 0.05943149f, -0.06142592f, 0.01888677f, 
    0.02141921f, -0.07992537f, 0.00510646f, 0.06281132f, 0.00783595f, -0.00850454f, 0.08175631f, 0.08073916f, 
    0.05427079f, -0.05000376f, 0.05787256f, 0.06544197f, 0.04528628f, -0.05321094f, -0.00327652f, -0.04933752f, 
    -0.01617612f, -0.01653932f, -0.06405634f, -0.00971932f, 0.02169772f, 0.03749160f, 0.01439072f, -0.08323421f, 
    0.01942765f, -0.03586733f, -0.00353902f, 0.00683716f, 0.04087475f, -0.07656600f, 0.02762380f, 0.01304785f, 
    -0.01025887f, -0.07689520f, -0.05687582f, -0.00382751f, 0.00175389f, -0.02966379f, -0.06275615f, 0.00752781f, 
    -0.06053391f, 0.03856552f, -0.07419343f, -0.08020991f, -0.01011633f, -0.03738428f, 0.01915845f, -0.05865785f, 
    0.06212858f, -0.06031886f, -0.04854776f, -0.03427752f, -0.06906921f, -0.04002926f, -0.05400711f, 0.05780285f, 
    0.01841960f, 0.01170812f, -0.02731100f, -0.03226786f, -0.07562705f, -0.06530514f, -0.01068291f, -0.03909029f, 
    0.08176579f, -0.07041585f, -0.05598009f, -0.05532523f, 0.05715823f, 0.01394484f, -0.08192372f, -0.03429350f, 
    -0.05830698f, -0.04249955f, -0.02992710f, 0.03073367f, -0.00153890f, -0.01152678f, -0.08114490f, -0.08069988f, 
    -0.02477125f, -0.06552619f, 0.00522852f, -0.03508007f, 0.07730611f, 0.05068490f, -0.08043629f, -0.07226948f, 
    -0.01866945f, -0.00881688f, -0.00938685f, -0.04402193f, -0.04963818f, 0.08119012f, -0.04206363f, 0.05818632f, 
    0.03344178f, -0.06870677f, -0.02745762f, -0.04866305f, -0.07159232f, -0.07589395f, -0.02696880f, -0.00014848f, 
    -0.07957065f, -0.08014891f, -0.00323924f, -0.03724620f, 0.05568167f, 0.01212631f, 0.04746957f, 0.05436000f, 
    0.01962235f, 0.01466853f, 0.06274921f, -0.00360792f, 0.00744249f, 0.03395924f, 0.00454809f, 0.00793001f, 
    -0.42209187f, -0.60683089f, -0.36811793f, -0.08989213f, -0.01645978f, -0.04357636f, 0.08908151f, 0.24274017f, 
    0.18936245f, -0.23559929f, 0.59824014f, -0.40421093f, -0.08153514f, 0.13842961f, -0.05926136f, -0.11332551f, 
    -0.16503395f, 0.06517687f, 0.01996326f, -0.02386979f, -0.01774411f, 0.22288242f, -0.14612563f, -0.07100911f, 
    0.11993715f, -0.30005479f, -0.16618058f, 0.58892864f, -0.50611120f, 0.11255591f, -0.09864312f, 0.09901641f, 
    -0.27724174f, -0.26502809f, -0.06130353f, 0.01583659f, 0.47833496f, 0.33859265f, 0.20547749f, -0.02308683f, 
    0.14751747f, -0.00568019f, 0.01489643f, 0.01413895f, 0.08333778f, -0.32815394f, 0.20576812f, 0.82602084f, 
    -0.43897074f, -0.39386949f, 0.14335346f, 0.16296339f, 0.00258502f, -0.04348444f, 0.60978580f, 0.48456216f, 
    0.40608516f, -0.06658974f, 0.05579992f, 0.04975476f, -0.13544902f, -0.03160759f, 0.12906210f, 0.09427584f, 
    -0.51157671f, 0.11436041f, -0.06779637f, -0.10972780f, 0.06999826f, 0.26330286f, 0.06130338f, -0.25160795f, 
    0.84335279f, 0.74075091f, -0.08286506f, 0.14735287f, 0.09599485f, -0.12814038f, 0.08959567f, 0.07526270f, 
    0.04335141f, 0.15484059f, -0.11828894f, -0.02080606f, -0.23301397f, -0.38565132f, -0.40084848f, 0.04265200f, 
    0.00703095f, 0.03232751f, 0.10236590f, 0.13985059f, 0.09301768f, -0.29155675f, 0.24149995f, 0.04095883f, 
    -0.02289196f, 0.22754379f, 0.05713119f, 0.23715580f, -0.12532632f, -0.01784730f, -0.17426369f, -0.19439486f, 
    -0.34845296f, -0.01545629f, 0.27275991f, -0.04691536f, 0.06772812f, 0.09248870f, 0.10137932f, -0.15123187f, 
    -0.12827276f, 0.18110643f, 0.15327545f, -0.15471186f, -0.23717433f, 0.89184880f, 0.04304329f, -0.07690991f, 
    0.02378643f, 0.33660063f, 0.08909991f, 0.18917918f, 0.15568724f, -0.00489541f, -0.69282258f, -0.32351595f, 
    -0.07534964f, 0.07162772f, 0.20610216f, 0.00844747f, -0.04634571f, -0.27024424f, -0.02810189f, -0.40631884f, 
    -0.02083012f, 0.57963115f, -0.03281711f, 0.16812716f, -0.05787428f, -0.07916111f, 0.26049984f, -0.06677500f, 
    -0.53903788f, -0.22460380f, -0.19302988f, 0.00427936f, 0.07658436f, 0.00945418f, 0.18364701f, -0.13944028f, 
    0.25526983f, 0.00438087f, -0.41437003f, 0.50368708f, -0.10451293f, 0.14031653f, 0.08873145f, -0.04209733f, 
    0.05338894f, -0.00675185f, 0.28543228f, -0.28039348f, -0.16149727f, -0.02156185f, 0.03425855f, 0.03875180f, 
    0.04235706f, -0.25840360f, 0.02620094f, -0.16964094f, 0.28053638f, 0.10876974f, 0.05193412f, -0.12157512f, 
    0.07617690f, 0.05328656f, 0.01102191f, -0.15587026f, 0.42605495f, 0.20123704f, 0.17207302f, -0.05654688f, 
    -0.29300365f, 0.11681189f, 0.16404703f, 0.03859393f, 0.28524482f, -0.74112189f, -0.36478236f, -0.32309306f, 
    -0.12763540f, -0.11238565f, -0.00400883f, -0.02633936f, 0.34924045f, 0.14290667f, 0.08571832f, 0.58693153f, 
    0.26684257f, 0.10937927f, 0.13239782f, 0.02722176f, 0.03859902f, -0.20792103f, 0.10000605f, -1.12295556f, 
    -0.21509171f, -0.11191987f, -0.47735468f, 0.20877567f, -0.02996884f, 0.06057709f, 0.00042359f, -0.14413844f, 
    -0.17006314f, 0.46882749f, 0.50024599f, 0.13655616f, -0.13694216f, -0.10685476f, 0.31186199f, -0.02347866f, 
    -0.06994187f, 0.07703500f, -0.14932258f, 0.03243595f, -0.12337340f, 0.05680314f, -0.10537048f, 0.05169463f, 
    -0.01533797f, 0.37519994f, 0.05023172f, -0.03974238f, 0.09784574f, -0.00405566f, -0.21555834f, -0.14152324f, 
    0.01229217f, 0.19773822f, 0.02945125f, -0.07591719f, -0.04573255f, -0.08469909f, -0.09505912f, 0.07766122f, 
    -0.04848151f, 0.37738660f, 0.06930277f, 0.00042475f, 0.11577888f, 0.78009534f, 0.00521493f, 0.08202317f, 
    0.00797100f, 0.02029170f, 0.10662907f, -0.17836721f, -0.08553331f, -0.50159419f, 0.18927106f, 0.17096549f, 
    0.06062315f, -0.43335393f, 0.01799312f, 0.06165634f, -0.01424608f, -0.20485432f, 0.23042323f, -0.70224386f, 
    -0.29745698f, 0.06580030f, 0.06225029f, 0.09200262f, -0.10320862f, 0.29797414f, 0.00251464f, -0.84678775f, 
    -0.67004699f, -0.47378486f, 0.10110910f, -0.05148657f, -0.01340997f, -0.14118847f, 0.04506996f, -0.09370729f, 
    0.14096466f, -0.36758184f, 0.40179342f, 0.11131844f, -0.02168454f, -0.36683404f, 0.11296224f, -0.16207947f, 
    -0.00000074f, -1.04622042f, -0.67470413f, -0.21232180f, 0.02935323f, -0.02629019f, -0.17615709f, 0.19912341f, 
    -0.00122841f, 0.21535082f, -0.06929620f, 0.13023104f, 0.08745294f, -0.00999430f, -0.10037541f, 0.01052708f, 
    0.29986477f, -0.07973272f, 0.28674847f, -0.23287411f, -0.28729224f, 0.14478801f, 0.17601684f, 0.21294454f, 
    0.27833390f, 0.25144809f, 0.02753756f, 0.11691019f, 0.32531875f, 0.77376509f, 0.36158457f, 0.17682907f, 
    0.14582622f, 0.13079257f, 0.06903402f, 0.00377725f, 0.06328716f, 0.53929508f, -0.38621432f, -0.45483536f, 
    -0.01697481f, -0.06172702f, 0.17675698f, -0.16710708f, -0.03107174f, 0.31455883f, -0.82547039f, -1.39207017f, 
    -0.10172409f, -0.04031463f, -0.11808539f, -0.02587550f, 0.09582836f, -0.02104489f, 0.00370114f, 0.45973021f, 
    -0.06085584f, 0.05754463f, -0.11932571f, -0.08818913f, -0.25317907f, 0.18269813f, 0.33262017f, 0.17915285f, 
    -0.54589766f, -0.26693976f, -0.47559673f, -0.10872554f, -0.21193780f, -0.29536152f, 0.05197868f, -0.11701182f, 
    -0.01086348f, -0.08653086f, 0.23624937f, -0.06290835f, -0.38834044f, -0.27531841f, 0.20698826f, 0.00449658f, 
    0.11215302f, 0.13858405f, -0.01215856f, -0.19564728f, 0.07656452f, -0.50092840f, -0.31283224f, -0.05340858f, 
    -0.12275765f, 0.09966727f, 0.06861039f, 0.01861433f, 0.05780669f, 0.05953597f, -0.15034868f, -0.28679413f, 
    -0.41997823f, -0.00893466f, 0.13665807f, 0.16323110f, 0.05093333f, 0.37841004f, 0.38701510f, -0.01402811f, 
    -0.11847485f, 0.11008125f, -0.03433199f, -0.08495535f, 0.24880362f, -0.70923114f, 0.20624521f, 0.32275897f, 
    -0.03064728f, -0.08846054f, -0.13399020f, 0.02180902f, 0.11341077f, 0.07440015f, 0.18646550f, -0.14640567f, 
    -0.12992080f, -0.15032001f, -0.08698339f, -0.05820536f, 0.02595397f, 0.00990903f, -0.00202618f, -0.12172483f, 
    -0.32111138f, 0.39520994f, -0.21536158f, -0.28998312f, -0.07742532f, -0.02426361f, 0.08688901f, 0.08799227f, 
    0.13796921f, -0.76207960f, 0.38544062f, -0.05633191f, 0.28121719f, 0.17813227f, 0.15640061f, 0.35865697f, 
    0.29667881f, -0.58022243f, -0.11214884f, -0.45585099f, 0.16947207f, 0.13804889f, 0.00511838f, 0.24215886f, 
    0.20060818f, -0.02042986f, 0.01279384f, -0.15800998f, 0.02093477f, -0.05209491f, -0.12053891f, 0.14030108f, 
    0.07631439f, -0.14000015f, -0.47134981f, -0.11638453f, 0.17137401f, -0.20778891f, 0.15063782f, 0.13030940f, 
    0.04023610f, -0.38680235f, -0.26855001f, -0.18955402f, -0.50174618f, 0.00361852f, 0.12250693f, -0.05432133f, 
    -0.08138733f, 0.00916741f, 0.16023166f, 0.23247944f, 0.04114210f, -0.34352928f, 0.23257901f, 0.35257220f, 
    0.11087552f, 0.03192522f, 0.33063659f, -0.27262813f, -0.21758571f, 0.08094782f, -0.32647020f, 0.13214678f, 
    -0.21489559f, 0.08932273f, -0.03298684f, 0.15397468f, 0.41874576f, 0.33527860f, 0.23837727f, -0.15043709f, 
    0.23933978f, 0.45719299f, 0.33181274f, 0.12057942f, 0.12580127f, 0.23101197f, 0.12899797f, -0.05948469f, 
    -0.73683125f, -0.16258512f, 0.27814272f, -0.10871175f, 0.01349204f, 0.00445865f, 0.07452600f, 0.04851620f, 
    0.06557549f, 0.17336906f, 0.03727875f, -0.13634783f, 0.14727823f, 0.16793679f, 0.27855709f, -0.06573313f, 
    -0.10862613f, 0.14618404f, -0.06685758f, 0.04235432f, 0.11223575f, -0.00989085f, -0.05177297f, -0.32124954f, 
    0.17769815f, 0.39809141f, 0.14032535f, 0.09398901f, -0.07641391f, 0.14710757f, 0.24384907f, 0.08989204f, 
    -0.03303604f, -0.27015182f, 0.01267445f, -0.00124272f, 0.56677377f, 0.38030872f, 0.20737669f, 0.14375226f, 
    0.09952970f, 0.22190937f, -0.16159987f, 0.02675713f, 0.12366650f, -0.30740723f, -0.17465486f, -0.09917583f, 
    0.09759399f, -0.05540781f, -0.27681443f, -0.38915402f, -0.36328143f, -0.08457005f, 0.16378629f, 0.02841602f, 
    0.32641876f, 0.17891578f, 0.03759389f, -0.12609671f, -0.06624889f, 0.03114429f, 0.05738891f, -0.04335035f, 
    0.12072206f, 0.45974043f, 0.05280795f, -0.03283985f, -0.13162327f, 0.15667129f, 0.21192171f, -0.05268826f, 
    -0.65955544f, -0.07297723f, 0.89958650f, -0.41081342f, 0.01667428f, -0.21578082f, 0.30041966f, -0.15503405f, 
    -0.06616523f, 0.11187376f, 0.16226265f, 0.66715497f, 0.07557605f, 0.03526739f, -0.05566918f, 0.14869609f, 
    0.17414434f, -0.26959872f, -0.33205044f, -0.11845150f, -0.09306035f, 0.11614300f, -0.34871778f, 0.15694880f, 
    -0.03473940f, -0.18855725f, -0.03879986f, -0.29062328f, 0.25954542f, 0.13003491f, -0.20297855f, -0.01183722f, 
    0.08521846f, -0.27294582f, -0.30583590f, 0.15319858f, 0.04808958f, -0.44704229f, 0.49358639f, -0.10563095f, 
    0.21029703f, 0.05461065f, 0.22323994f, 0.09533928f, 0.21058750f, -0.16952668f, -0.09297113f, 0.00963379f, 
    0.14775607f, 0.52483463f, 0.04705864f, 0.01371844f, 0.11320887f, 0.09033320f, 0.65470189f, 0.44032472f, 
    0.35409886f, -0.38774586f, 0.18019763f, 0.06372910f, 0.09864634f, 0.05236681f, 0.11094227f, -0.00917680f, 
    0.37601602f, 0.47098789f, 0.19747454f, 0.18987446f, -0.15026356f, 0.27632108f, 0.06824146f, 0.16384159f, 
    -0.22423485f, -0.39902800f, 0.40956852f, 0.08331401f, -0.17255107f, 0.22870182f, 0.06082700f, -0.05709625f, 
    0.14838229f, -0.10131689f, -0.35456303f, -0.09154890f, 0.00056664f, 0.07806221f, -0.16206023f, -0.06951401f, 
    0.31570399f, 0.21784382f, 0.12145157f, 0.00158859f, -0.37934056f, -0.33866495f, 0.25908270f, -0.11144806f, 
    0.57566363f, 0.07074709f, 0.17862700f, -0.23861393f, 0.01522834f, 0.00631096f, 0.33589745f, 0.14727020f, 
    -0.29403937f, 0.13438839f, 0.18828239f, 0.11642657f, -0.06164744f, -0.27650034f, 0.26654735f, -0.02447623f, 
    -0.04955870f, 0.17685257f, 0.36334246f, -0.04487640f, -0.07807912f, -0.13262126f, -0.11359996f, -0.20198460f, 
    -0.21723540f, -0.20376791f, 0.00661371f, -0.06791756f, -0.15240426f, 0.10815437f, -0.14823884f, 0.31845751f, 
    0.05135303f, -0.01117885f, 0.03645711f, -0.11524351f, -0.15499796f, 0.23417149f, -0.22155069f, -0.41941428f, 
    0.19366552f, 0.26418325f, -0.07375346f, 0.14173929f, -0.05185185f, -0.09787206f, 0.05150906f, -0.27154279f, 
    0.10096040f, -0.06318171f, -0.03288172f, -0.05378912f, -0.31485480f, -0.09417362f, 0.20710042f, 0.16692317f, 
    -0.41943046f, 0.30445993f, 0.09010839f, 0.36275882f, 0.07090871f, 0.10611770f, -0.07031679f, -0.00155654f, 
    0.03776186f, -0.18727499f, -0.79600573f, 0.10467602f, 0.17505804f, 0.03506580f, 0.11817503f, 0.04155527f, 
    -0.01708123f, 0.11938766f, 0.16351874f, 0.34640554f, -0.28567338f, -0.09133357f, 0.21652336f, 0.25567710f, 
    0.31199303f, 0.19072321f, 0.03471580f, 0.07035728f, 0.67957729f, -0.79342729f, -0.61588550f, 0.13844144f, 
    0.20830055f, -0.04731337f, 0.11636318f, -0.11443458f, -0.18782143f, 0.45015967f, -0.41061914f, -0.47187534f, 
    0.03207031f, 0.08302172f, -0.11703967f, 0.26133543f, 0.20089605f, -0.40365034f, -0.19468112f, -0.56459558f, 
    -0.21282169f, -0.00321693f, -0.10727169f, -0.22189763f, -0.07355636f, -0.17621140f, 0.04400386f, -0.06804662f, 
    -0.05924769f, -0.27799892f, 0.05121058f, 0.17563848f, 0.10223266f, 0.14047976f, -0.06335344f, 0.00442978f, 
    0.07475483f, -0.12425601f, -0.24719581f, 0.09302990f, -0.19316937f, -0.01251733f, -0.07051071f, -0.02641302f, 
    0.26629010f, -0.23057997f, -0.25757727f, 0.01982240f, -0.07086055f, 0.05859547f, 0.19350153f, 0.05359796f, 
    -0.16925514f, 0.11846069f, 0.05809084f, 0.13279554f, -0.14946127f, -0.07764755f, -0.04653906f, -0.02905599f, 
    -0.11148967f, -0.07706439f, 0.06932434f, -0.12309375f, 0.05716252f, -0.11286164f, -0.08234348f, 0.04040788f, 
    0.08401765f, 0.10618797f, -0.08489879f, 0.01672148f, -0.27785197f, -0.26100409f, 0.39936414f, 0.08511155f, 
    -0.13985974f, 0.15330203f, -0.10432260f, 0.28877428f, 0.13334355f, 0.27075830f, -0.73045105f, -0.12400574f, 
    0.14324363f, 0.27507892f, 0.12303566f, 0.00015663f, 0.01736619f, 0.17329866f, 0.26583183f, 0.31790856f, 
    0.28166083f, -0.09969494f, 0.17727280f, 0.24883418f, 0.04932620f, -0.09820163f, -0.00042853f, -0.00845888f, 
    0.41518462f, -0.20680749f, 0.04498250f, -0.05137429f, -0.08066821f, 0.08164182f, -0.17762622f, 0.06465826f, 
    0.38222855f, 0.25586703f, -0.39661309f, -0.34841591f, 0.10672459f, 0.07485080f, -0.29030460f, -0.17936188f, 
    0.04888657f, -0.05210618f, 0.05084379f, -0.03061320f, 0.17785606f, 0.12127883f, 0.00600745f, -0.03937704f, 
    0.10205303f, 0.00106351f, -0.02938320f, 0.06482089f, -0.24471566f, 0.49770421f, 0.01565977f, 0.16549450f, 
    0.12414927f, 0.17226045f, -0.01594342f, -0.18025425f, -0.07151469f, -0.12438451f, -0.09689654f, 0.02900158f, 
    -0.03545844f, 0.19543885f, 0.15424909f, 0.30184767f, -0.00574823f, -0.06939223f, 0.00056405f, 0.10286480f, 
    0.18350141f, 0.02660337f, 0.41027990f, -0.05340044f, -0.26906458f, 0.19665064f, 0.21391864f, -0.14954656f, 
    -0.06356046f, 0.14481515f, 0.06713814f, -0.00597179f, -0.02691487f, 0.02226834f, -0.43521631f, -0.13082787f, 
    -0.61850005f, 0.20147079f, -0.19055222f, -0.15818360f, -0.28943759f, -0.59031236f, -0.48960140f, 0.33372721f, 
    -0.39682448f, -0.23904715f, 0.23555230f, -0.01920247f, -0.01115160f, -0.06161851f, 0.16498768f, 0.04500404f, 
    0.38845485f, 0.18897429f, 0.17133614f, -0.06008244f, 0.25832373f, 0.13100259f, -0.01849619f, -0.07433219f, 
    0.13973115f, 0.05129996f, -0.27190122f, 0.49085337f, 0.16151777f, -0.04608563f, 0.28187454f, -0.08833826f, 
    -0.16681901f, -0.17460810f, 0.04814648f, -0.03118259f, 0.06311149f, 0.19280940f, 0.08661187f, 0.17695457f, 
    -0.50400060f, -0.53959978f, -0.39978105f, 0.28214145f, -0.13657841f, 0.15668803f, 0.27318239f, 0.18387857f, 
    0.32488254f, -0.26825026f, -0.31456348f, -0.23786090f, -0.20531093f, 0.08932579f, 0.45873573f, 0.05993637f, 
    0.23791720f, -0.09689637f, -0.13454178f, 0.01850407f, 0.07522903f, 0.05844506f, -0.00921341f, 0.44589001f, 
    0.02595628f, 0.12887788f, 0.21786955f, 0.35169590f, 0.05039262f, 0.29462802f, 0.36264852f, 0.25927263f, 
    0.01163996f, -0.02815899f, -0.08498888f, 0.07462868f, 0.06546965f, 0.13102274f, 0.20968747f, 0.38110337f, 
    -0.11088848f, -0.24972034f, 0.17228512f, -0.06486496f, -0.06106421f, 0.18515232f, -0.08735700f, 0.00950152f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.38610190f, -0.10374352f, 0.19156750f, -0.00381166f, 0.19821382f, 0.02929056f, 0.04822768f, 0.72989899f, 
    -0.03898169f, -0.43491459f, 0.08361534f, 0.27493742f, 0.80234236f, 0.14242025f, -0.00915410f, -0.32299367f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.35123625f, 0.04537737f, 0.05809870f, 0.06572329f, 0.51350540f, -0.23814072f, -0.09514207f, -0.15813404f, 
    -0.14393044f, 0.99019647f, -0.20959780f, -0.08790184f, -0.27485627f, -0.68562382f, -0.47564158f, 0.22731301f, 
    0.39488018f, -0.16961747f, 0.94144291f, 0.13244449f, 0.10152932f, 0.22098111f, 0.31594914f, -0.23858228f, 
    -0.14759341f, -0.10952146f, 0.26179191f, -0.11650512f, 0.26212785f, -0.38052177f, -0.62035811f, -0.16394702f, 
    -0.50148213f, -0.09147903f, 0.30382201f, -0.18743433f, -0.27012622f, 0.01579003f, -0.57350922f, -0.06600836f, 
    -0.01898310f, -0.12362558f, -0.35380816f, 0.80758935f, 0.16167793f, -0.15517065f, -0.33955178f, 0.45129028f, 
    -0.78033143f, 0.07081936f, 0.73039025f, 0.08671025f, -0.19456846f, 0.06066894f, 0.32159644f, -0.21992896f, 
    -0.15287614f, 0.22440298f, -0.23117012f, -0.37440315f, -0.32381687f, 0.19445610f, 0.42587665f, 0.11114143f, 
    -0.17623085f, 0.23815027f, -0.84406006f, -0.00526391f, -0.01223911f, -0.05560269f, 0.26770419f, -0.43025753f, 
    -0.10186264f, 0.05967710f, 0.81478339f, -0.37639323f, -0.04069833f, -0.13575725f, -0.06767146f, 0.23764214f, 
    -0.13512883f, -0.17925172f, 0.14132647f, -0.02172471f, 0.20432658f, -0.06921192f, -0.34218043f, -0.29848084f, 
    0.08045244f, -0.04905055f, 0.28470531f, 0.02796109f, 0.37155798f, 0.06968967f, -0.25914174f, -0.15883119f, 
    0.19511989f, 0.03815662f, -0.93691677f, 0.06394333f, -0.03988934f, 0.19458060f, -0.32707658f, 0.99414355f, 
    -0.04316735f, -0.35334957f, -1.25640821f, 0.60756725f, -0.15105905f, -0.41859099f, 0.09977155f, 0.19961253f, 
    0.22516483f, -0.07720683f, -0.01756183f, -0.01253957f, 0.39895377f, 0.29044193f, 0.65522343f, -0.88194770f, 
    0.07681310f, 0.01774531f, -0.10314354f, 0.37909797f, -0.54248184f, -0.16809666f, 0.55272484f, -0.01093251f, 
    0.11031371f, -0.01683286f, 0.12463602f, -0.17153317f, 0.73015261f, -0.13465352f, -0.25584739f, 0.00328666f, 
    0.04292285f, -0.18821593f, 0.04015685f, 0.01844917f, 0.23576371f, -0.15801439f, 0.92859542f, -0.87865710f, 
    -0.29040289f, -0.08645685f, -0.48556066f, 0.02558720f, -0.38578928f, 0.20886970f, -0.14767811f, 1.06344223f, 
    0.12746343f, -0.26036456f, 0.21459667f, -0.51682562f, -0.19033775f, -0.13557521f, 0.46352354f, 0.41312736f, 
    -0.37051365f, 0.07663153f, -1.04783285f, 0.17185724f, -0.33768898f, -0.29925984f, 0.26834622f, -0.13553090f, 
    0.06974354f, 0.52567518f, -0.04422145f, 0.28258821f, 0.33692145f, 0.44394946f, -0.70620394f, -1.02999604f, 
    0.64973658f, -0.21422683f, -0.69498491f, 0.07199483f, -0.85875940f, -0.11042101f, -0.29286492f, -0.16158110f, 
    -0.22236288f, -0.08291887f, -0.74148822f, -0.46577033f, 0.23096941f, 0.44428846f, -0.05949602f, 0.06277761f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.60073304f, 0.14901108f, 0.40154129f, 0.03722304f, -0.51105708f, -0.13517305f, -0.38453206f, -0.46530026f, 
    0.15293287f, 0.01642933f, 0.18759775f, 0.12808868f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
