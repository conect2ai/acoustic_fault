#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.25253117f, 0.57173491f, 0.45379227f, 0.25356662f, 0.46474591f, 0.00161962f, 0.59943008f, 0.65195489f, 
    0.48412430f, 0.11337984f, -0.16217569f, 0.24873355f, 0.36557898f, -0.22306605f, -0.27159798f, 0.00804038f, 
    0.14479667f, -0.39716473f, -0.12228898f, 0.13147219f, -0.03325053f, 0.11319230f, 0.25052470f, -0.02606545f, 
    -0.18090607f, 0.35795525f, -0.31308919f, 0.29675016f, 0.41413552f, 0.59381545f, 0.15527210f, 0.33590215f, 
    0.20643607f, -0.66703194f, -0.21435590f, -0.15238613f, 0.03142209f, 0.24783444f, -0.52048081f, -0.12944384f, 
    -0.36040834f, 0.11498616f, 0.11608879f, 0.07373812f, -0.47249439f, 0.33007106f, -0.28432208f, -0.28404260f, 
    0.05823176f, -0.27770230f, 0.85040873f, 0.13235120f, -0.07436125f, -0.64232796f, 0.84354764f, -0.46850699f, 
    0.49521640f, 0.06643634f, -0.47520667f, -0.42435032f, -0.30373377f, 0.38857573f, 0.00916156f, -0.06501337f, 
    0.13123551f, 0.08168374f, 0.04963047f, 0.14551045f, 0.12812135f, -0.04945353f, -0.08039661f, 0.03023117f, 
    -0.06848626f, 0.36719084f, -0.05460012f, -0.11916528f, -0.07379421f, 0.38019526f, 0.51095760f, -0.53020322f, 
    0.70161968f, 0.13222097f, 0.05162197f, 0.28959921f, -0.12935722f, -0.33709475f, 0.10575625f, -0.06081304f, 
    -0.29425073f, -0.30761889f, 0.05598930f, -0.03382692f, -0.12436926f, -0.16234553f, -0.31321830f, -0.67049265f, 
    0.13211827f, 0.53126150f, 0.19998316f, -0.09065077f, -0.52679676f, -0.28265259f, -0.72480208f, -0.55064648f, 
    -0.43985391f, -0.02879556f, -0.58338082f, -0.44565877f, -0.29527900f, -0.44833341f, -0.40632278f, -0.07534950f, 
    -0.12570280f, -0.31248489f, -0.14786233f, 0.45835230f, 0.04528532f, -0.12543686f, 0.31372812f, -0.11706784f, 
    -0.00324304f, 0.40422630f, 0.31395298f, -0.03854715f, 0.43615583f, -0.19379964f, -1.56641102f, -0.35142285f, 
    0.75475413f, 0.48405018f, 0.26990935f, 0.04405117f, -0.91853201f, -0.90646768f, -0.82525814f, -0.12650891f, 
    0.18252362f, -0.36594048f, -0.21254030f, -0.58595490f, -0.03218635f, -0.38209015f, -0.15591501f, 0.57426566f, 
    0.39891627f, 0.12711498f, -0.24669813f, -0.36516878f, -0.39307415f, -0.16465336f, 0.11330048f, -0.05488168f, 
    0.36361825f, 0.07715006f, -0.14697492f, -0.50734949f, -0.14916731f, 0.12865983f, -0.14888950f, 0.38895473f, 
    0.23954320f, -0.67305475f, 0.99706745f, -0.46802813f, 0.04790267f, -0.01059389f, 0.02819444f, -0.13744397f, 
    0.30455512f, 0.02661853f, -0.17899178f, -0.25342265f, 0.21857826f, 0.28986511f, 0.28626502f, 0.59620076f, 
    1.33702028f, -0.12080280f, -0.31708381f, -0.70527464f, -0.17353560f, -0.22442149f, 0.32958648f, 0.10474129f, 
    -0.33882844f, -0.38317975f, -0.29939026f, 0.67330003f, 0.01734617f, -0.21805269f, -0.04707632f, 0.24009688f, 
    0.08106770f, -0.19061425f, -0.05469194f, 0.15722212f, 0.17700228f, -0.30694056f, -0.01798972f, -0.30320722f, 
    -0.92795116f, -0.67375398f, -0.58828491f, -0.21957949f, 0.58838421f, -0.20292506f, -0.78065002f, -1.09330666f, 
    -0.69890410f, 0.56215334f, 0.58828843f, -0.48070496f, -0.19485265f, 0.24264583f, -0.47704437f, -0.00517531f, 
    -0.07168219f, -0.21303394f, -0.45183566f, -0.83371085f, -0.25926289f, -0.09007837f, 0.27390382f, -0.13470387f, 
    0.04763278f, 1.14507723f, -0.49614471f, -0.67900002f, -0.10419329f, -0.73102230f, 0.52003992f, 0.32427487f, 
    0.21763563f, -0.22562809f, -0.19036822f, 0.20274119f, -0.15913038f, 0.00466020f, -0.11964340f, -0.21593882f, 
    -0.23402441f, -0.11615876f, -0.17623606f, -0.51200187f, -0.06593129f, 0.20725362f, 0.02676776f, 0.33143750f, 
    0.43426302f, 0.54824340f, -0.26142624f, -1.60089123f, -0.54757941f, 0.04450674f, 0.76892960f, 0.51865965f, 
    0.32173494f, 0.12766254f, 0.28980666f, 0.53174037f, 0.46154457f, -0.28948614f, -0.12346368f, -0.49613866f, 
    0.20611928f, -0.11114161f, -0.26132783f, 0.31741524f, 0.20487316f, -0.05298502f, -0.35687768f, -0.04067770f, 
    -0.00107153f, 0.05606061f, 0.27934876f, 1.11897111f, -0.68603617f, -0.97749567f, -0.87619352f, -0.41483864f, 
    0.00758743f, -0.15464626f, -0.35820398f, 0.47945592f, -0.03728239f, 0.37515944f, 0.54511863f, 0.43860701f, 
    0.16273269f, 0.17038414f, 0.05294228f, -0.27897269f, -0.16235073f, 0.27282375f, -0.15190929f, 0.23967318f, 
    -0.24159560f, -0.13786799f, 0.09426729f, -0.31410417f, -0.91272104f, -0.60225189f, -0.33746222f, -0.36378923f, 
    -0.55313623f, -0.04467643f, -0.40399399f, -0.03675766f, 0.08136007f, -0.22137542f, -0.64122766f, -0.28187019f, 
    -0.17515065f, 0.57441312f, -0.39690876f, 0.09735338f, -0.44132912f, 0.01855878f, 0.09507386f, -0.12856475f, 
    -0.43272251f, 0.06807076f, 0.12421134f, -0.45665419f, -0.24184208f, -0.76997244f, -0.79144436f, -0.50083262f, 
    -0.72433555f, -1.22446454f, 0.98876446f, 0.28792045f, 0.31099862f, 0.32740861f, 0.55856109f, -0.15803644f, 
    -0.36167869f, 0.15918367f, 0.33302966f, 0.15454447f, -0.16751876f, -0.13481385f, -0.03729774f, 0.05081020f, 
    0.04745912f, -0.19121791f, -0.16132168f, 0.42338082f, -0.11317632f, -0.21707872f, 0.60371137f, 0.14859065f, 
    -0.02894833f, -0.35292673f, -0.33539566f, -0.45146048f, -0.33520901f, 0.02734494f, 0.27434406f, -0.19968252f, 
    0.09559943f, 0.24058770f, -0.48792559f, -0.08672424f, -0.33599782f, -0.15273876f, 0.03819354f, -0.38353723f, 
    -0.37068784f, -0.47386122f, -0.60429925f, 0.00769554f, -0.22500773f, -0.80313861f, -0.70564282f, 0.58849877f, 
    0.45963466f, 0.30331439f, -0.02533697f, 0.69068867f, 0.07865278f, -0.05753619f, -0.81698662f, -0.58469987f, 
    -0.08505937f, -0.26074988f, -0.29372934f, 0.49296010f, -0.39647889f, -0.18745598f, 0.02863394f, -0.29289022f, 
    -0.25378421f, 0.06939655f, 0.16144994f, 0.15063030f, -0.05217231f, -0.01789015f, 0.17241032f, 0.41213459f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03272774f, 0.08125225f, 0.63077062f, 0.58131051f, -0.04159905f, 0.55068505f, 0.46153423f, 0.63445210f, 
    0.01325705f, 0.26350766f, 0.36577114f, 0.58282506f, -0.00440823f, 0.35931191f, 0.44122797f, 0.05625142f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.27941942f, -0.07594963f, 0.05933026f, -0.37353903f, -0.13445947f, -0.01629283f, 0.04330505f, 0.00082943f, 
    0.06276096f, 0.04005761f, -0.12017825f, -0.11029112f, -0.03480605f, 0.58707327f, -0.02444360f, 0.10346848f, 
    0.04861053f, -0.30786225f, -0.11804833f, -0.06331161f, 0.15967730f, -0.07520184f, -0.16708276f, -0.00425403f, 
    0.63936627f, 0.06656294f, 0.24124885f, 0.38428980f, -0.12745421f, 0.00979888f, 0.20063269f, 0.07753464f, 
    -0.16918273f, 0.04243360f, 0.11537793f, -0.03771969f, -0.23199785f, 0.08907676f, 0.24001999f, -0.04238814f, 
    0.17900473f, -0.02307468f, 0.15016533f, -0.08304462f, -0.07168806f, 0.14928098f, 0.06551745f, 0.01528949f, 
    -0.22140509f, -0.29668060f, -0.27330533f, 0.10328427f, -0.20346512f, -0.07950366f, -0.09403596f, -0.01174068f, 
    -0.04496756f, 0.03032289f, -0.11738793f, -0.33832806f, -0.23960461f, -0.06824943f, -0.30445215f, 0.22635013f, 
    0.12306947f, 0.05139562f, 0.06870405f, -0.13426998f, 0.03440901f, -0.05135442f, 0.00419701f, 0.03658550f, 
    0.10933319f, -0.17667197f, 0.25061855f, 0.07788530f, -0.15010214f, 0.18964459f, 0.13107191f, 0.06358942f, 
    0.14889871f, -0.10897317f, 0.02466518f, -0.27148533f, 0.05270766f, -0.31816801f, 0.61218733f, -0.40553302f, 
    -0.02191424f, -0.07030579f, -0.12132744f, -0.07816036f, -0.00647006f, 0.16894396f, 0.02121416f, 0.26125693f, 
    -0.11495645f, -0.20175837f, -0.36456388f, 0.07525229f, 0.04242961f, -0.21156320f, 0.08195871f, 0.05185659f, 
    0.05175645f, 0.12318172f, 0.04711285f, 0.06195835f, 0.02254685f, 0.41012368f, 0.04509389f, 0.00878008f, 
    -0.04239431f, 0.06154208f, 0.11102237f, -0.14278516f, -0.22605357f, -0.14196564f, 0.13411425f, -0.03470477f, 
    -0.45609501f, 0.69069386f, -0.17313065f, 0.12324060f, 0.06857904f, 0.05529533f, -0.05879265f, 0.06278738f, 
    0.10329779f, 0.02789569f, 0.14968856f, -0.02499484f, -0.13701758f, 0.38916287f, -0.52872348f, 0.33754098f, 
    -0.07931044f, 0.10015041f, -0.09467816f, -0.00541644f, 0.15810880f, -0.01913635f, 0.00465807f, 0.07289642f, 
    -0.11071439f, 0.04516121f, 0.06725681f, 0.23757751f, -0.11548095f, 0.01161354f, 0.03476308f, -0.04581508f, 
    0.05048953f, 0.18813618f, 0.19163047f, -0.05407605f, 0.12203463f, 0.79227710f, 0.66000193f, 0.56109762f, 
    -0.08039717f, 0.06330182f, 0.34825036f, -0.06127031f, -0.03999025f, 0.05318872f, 0.08773561f, 0.01185174f, 
    -0.02080585f, 0.20150556f, -0.05689469f, -0.19009557f, 0.01605930f, 0.06155838f, -0.03091980f, -0.07732139f, 
    0.01422597f, 0.18771933f, -0.13899703f, 0.25719664f, -0.08719888f, -0.08352882f, -0.20223540f, 0.11548862f, 
    -0.15608829f, -0.19880502f, -0.09758933f, 0.06401166f, -0.41622028f, 0.01143969f, 0.00740613f, -0.18493387f, 
    -0.01064590f, -0.00367514f, -0.03702460f, 0.04906612f, 0.05585658f, -0.07128979f, 0.06375097f, -0.06590842f, 
    0.01203482f, 0.04035521f, 0.00455497f, -0.04032739f, 0.01226234f, -0.02816847f, 0.02895750f, -0.06072574f, 
    0.04937878f, 0.04477001f, -0.07215698f, -0.02420327f, -0.04018563f, 0.02647310f, -0.00829655f, 0.00979967f, 
    -0.00902334f, 0.00031642f, -0.05382366f, -0.01100790f, 0.04200745f, -0.00323943f, -0.01565940f, -0.05053098f, 
    -0.01981913f, -0.00583387f, 0.02483359f, -0.01876338f, -0.03258843f, 0.02938070f, 0.00349299f, -0.00584438f, 
    -0.05437959f, -0.07319943f, -0.02671579f, 0.00067919f, 0.03107177f, -0.02096930f, 0.00571140f, -0.00887931f, 
    -0.07394308f, -0.00125774f, -0.03607544f, 0.04546181f, 0.06417712f, -0.04904080f, 0.01463299f, 0.04542669f, 
    0.02340037f, 0.02427041f, 0.04892125f, 0.04288179f, 0.01040858f, 0.02708572f, -0.04455646f, 0.00269399f, 
    -0.04002768f, -0.03216874f, -0.05876962f, -0.04127503f, -0.04004179f, 0.04529503f, 0.01496730f, 0.02884253f, 
    -0.06431566f, 0.00920840f, -0.05016362f, 0.03549090f, -0.05799732f, -0.04831648f, -0.03220379f, 0.02672947f, 
    -0.05633508f, 0.04348289f, -0.03728527f, 0.01558742f, 0.01842494f, 0.02321780f, -0.04171389f, -0.02377260f, 
    -0.04151006f, 0.05544880f, 0.03997091f, -0.04431972f, 0.01492037f, -0.04689084f, -0.06641673f, 0.05175168f, 
    0.01413126f, -0.01258333f, -0.03619264f, 0.04151841f, 0.06586353f, -0.01556189f, -0.06255611f, -0.06921301f, 
    -0.00268423f, 0.05323527f, -0.03698267f, 0.02081388f, -0.05214041f, 0.03343160f, -0.06202902f, -0.06192491f, 
    -0.06082680f, -0.04423538f, -0.03520398f, 0.05367773f, -0.01806516f, 0.03454017f, -0.00597467f, 0.01343934f, 
    0.03291592f, -0.02957503f, 0.02643599f, 0.00017756f, 0.05755545f, -0.00239947f, 0.05586994f, -0.06256617f, 
    0.05857519f, -0.06800593f, -0.06866720f, -0.05539246f, -0.07516111f, 0.01688734f, 0.02406076f, -0.00119281f, 
    0.00464008f, -0.00071008f, -0.02217440f, -0.07785207f, -0.07291637f, -0.04461932f, 0.00329099f, 0.05289614f, 
    -0.05152994f, -0.04469167f, 0.06095209f, 0.06509191f, -0.07571727f, -0.00357062f, 0.02225428f, 0.03440176f, 
    -0.06866673f, -0.06576229f, -0.03767724f, -0.07209276f, -0.04736622f, -0.03238178f, -0.04217767f, -0.02958822f, 
    0.04088787f, -0.06233880f, -0.03421589f, 0.03953947f, 0.05470673f, -0.00865602f, -0.05296994f, -0.03345428f, 
    -0.03957674f, -0.04835398f, 0.00747698f, -0.03705095f, 0.06361048f, -0.01171931f, 0.01053438f, 0.01260262f, 
    0.01291584f, -0.01730341f, 0.05712234f, -0.03266544f, 0.06146741f, -0.07031731f, -0.06775719f, 0.06410305f, 
    -0.01172400f, -0.04027474f, -0.06365179f, 0.02285888f, -0.07029764f, 0.01312576f, 0.02553746f, -0.06560069f, 
    -0.03979446f, -0.15648314f, -0.17724623f, 0.34677258f, 0.17953895f, 0.19651566f, -0.07213789f, 0.23007797f, 
    0.15555847f, -0.01307281f, 0.17313829f, -0.01425675f, 0.26005781f, 0.07751775f, -0.00838529f, 0.18082327f, 
    0.15058029f, 0.03270387f, 0.13932748f, -0.14568131f, 0.20083849f, 0.20889424f, 0.19347870f, 0.20405699f, 
    0.61265498f, 0.22419021f, -0.20553727f, -0.03857450f, -0.03315140f, -0.12089376f, 0.06340058f, -0.09415479f, 
    -0.15099600f, -0.05031862f, -0.19784777f, -0.39433107f, -0.23604879f, -0.07277218f, -0.22932118f, 0.02971173f, 
    0.13878731f, -0.03593090f, -0.07394922f, 0.08404280f, -0.01823191f, -0.10312723f, 0.18677475f, -0.07957933f, 
    0.20552950f, 0.40766674f, 0.27621725f, 0.00907637f, -0.18335514f, 0.05044989f, -0.12897488f, 0.07075144f, 
    -0.02795313f, -0.12771535f, 0.00454076f, -0.10171410f, 0.12710829f, 0.13993761f, 0.23492227f, -0.20988432f, 
    -0.03171335f, -0.01255314f, 0.13500649f, 0.32122165f, 0.19952655f, -0.04884064f, 0.11361509f, 0.15461054f, 
    -0.36434090f, 0.02160502f, -0.18652645f, -0.47810036f, 0.18638872f, -0.03108019f, -0.06492344f, -0.35420731f, 
    -0.26468217f, -0.43459660f, -0.31642377f, -0.48264450f, -0.22712232f, -0.03852283f, -0.12802781f, -0.10798590f, 
    0.17770742f, -0.18974790f, -0.02199987f, -0.07548137f, 0.24954753f, 0.23534968f, 0.11792009f, 0.09481242f, 
    0.48636967f, 0.10288105f, 0.37532401f, 0.21123543f, 0.13803880f, 0.09246013f, -0.19223899f, -0.12186959f, 
    -0.01739275f, 0.03544382f, 0.15000598f, -0.12715463f, 0.20090209f, 0.17357033f, -0.00783175f, -0.26633143f, 
    -0.09495389f, -0.10470491f, 0.06997289f, -0.03221009f, -0.36999425f, -0.15381497f, -0.20852321f, -0.32180953f, 
    0.15791024f, -0.15983267f, 0.05099305f, -0.22078860f, -0.03339121f, 0.03008088f, 0.05641010f, -0.13836676f, 
    0.14621019f, 0.06854530f, 0.06602085f, -0.08178089f, -0.13336967f, -0.22169624f, 0.48251173f, 0.29235068f, 
    -0.00895860f, -0.12963851f, 0.08087513f, -0.17032039f, 0.01036870f, 0.16627330f, 0.23460603f, -0.00895040f, 
    0.17690279f, -0.12870000f, 0.21456976f, 0.20106910f, 0.00854814f, 0.19811393f, 0.02449152f, 0.14232486f, 
    0.07801658f, -0.01735344f, 0.26176485f, 0.29167464f, 0.46215841f, 0.05595173f, 0.28345227f, -0.31079310f, 
    -0.23076971f, 0.08647866f, -0.04575698f, -0.03310513f, 0.04761292f, -0.05877275f, 0.14963011f, 0.33553168f, 
    -0.11969821f, -0.08353422f, 0.06955426f, 0.16888519f, 0.01108969f, -0.11063665f, -0.03599960f, 0.13713534f, 
    -0.02771582f, 0.20313740f, 0.11679418f, 0.39816377f, 0.47377121f, 0.48329270f, 0.45441672f, 0.03162520f, 
    0.32551330f, -0.27205044f, -0.23769540f, 0.07430990f, -0.31418130f, -0.08348384f, -0.10397434f, -0.39272168f, 
    -0.06163663f, 0.05364850f, -0.06077945f, 0.03774589f, 0.03717507f, -0.06214376f, 0.02217372f, 0.04879890f, 
    -0.05286137f, -0.01663762f, -0.02084764f, 0.02561963f, -0.05896867f, -0.03104165f, -0.08566912f, 0.05088713f, 
    -0.00122577f, -0.02002366f, 0.00494006f, -0.01786204f, -0.00044530f, 0.01136146f, -0.06836046f, -0.03378173f, 
    -0.00500860f, 0.02306309f, 0.05296250f, 0.05792729f, 0.01055970f, -0.06788731f, -0.06620377f, 0.04954140f, 
    -0.00982679f, -0.06527996f, 0.01163841f, -0.00894981f, -0.04726641f, -0.02985783f, -0.04837288f, 0.03053348f, 
    -0.05463481f, 0.03912321f, -0.00320683f, 0.04581476f, 0.02087914f, -0.07933880f, -0.08044714f, -0.02705961f, 
    -0.01009352f, 0.01428820f, -0.06445213f, 0.04524876f, -0.03161374f, -0.06546389f, 0.00955385f, 0.03531016f, 
    -0.04899217f, 0.00053188f, -0.05117984f, -0.01581486f, 0.06808968f, -0.03649739f, -0.07520881f, -0.05873494f, 
    -0.02734424f, -0.01880690f, 0.03782945f, 0.03320856f, -0.08296426f, -0.06246763f, 0.01709836f, -0.01617362f, 
    0.01980072f, 0.05542594f, -0.05336737f, 0.02075234f, -0.05341159f, 0.05229841f, -0.01944097f, -0.04829619f, 
    -0.01602949f, 0.05620571f, -0.06380421f, -0.05394043f, 0.02609922f, 0.00091396f, 0.03892800f, -0.00359752f, 
    0.01651195f, -0.07850986f, -0.03634372f, 0.00262750f, 0.00101961f, -0.01548563f, -0.02817979f, 0.00753619f, 
    0.06476995f, -0.07639318f, -0.00888025f, -0.02256029f, 0.05603592f, 0.03757377f, -0.03552831f, 0.04588595f, 
    -0.05607643f, 0.03398371f, -0.04525527f, -0.03778402f, 0.04385749f, -0.06416159f, -0.04319372f, 0.03873110f, 
    -0.04259535f, -0.05595252f, -0.00079118f, -0.03329725f, -0.06942699f, 0.04485711f, -0.00940484f, -0.05345329f, 
    -0.01800270f, 0.05173203f, -0.04577663f, 0.06399798f, 0.01084922f, 0.04897948f, -0.05062176f, 0.04721522f, 
    0.03047285f, 0.05548248f, 0.02706659f, -0.07339839f, 0.05473139f, 0.05058523f, 0.06349614f, 0.01105876f, 
    0.00410026f, -0.02652321f, -0.03656677f, -0.01683400f, -0.05543581f, -0.01329689f, -0.05272567f, 0.00514177f, 
    0.01976569f, -0.00520418f, 0.05169366f, -0.02192355f, -0.06535565f, -0.07279193f, 0.04362882f, 0.03951878f, 
    -0.02451635f, 0.04271593f, -0.05084689f, -0.02483037f, 0.03468264f, 0.01841179f, 0.05739479f, -0.03200626f, 
    -0.01265118f, 0.02696839f, -0.05428397f, 0.04399566f, -0.04454162f, -0.00373588f, -0.01445209f, 0.02307073f, 
    -0.04769882f, -0.06861897f, -0.03067756f, -0.03561107f, 0.05429664f, 0.02332054f, -0.01178058f, -0.07592571f, 
    -0.04793790f, 0.01046509f, -0.06139536f, -0.06049535f, -0.02354188f, -0.05837345f, -0.01156131f, 0.04461144f, 
    -0.06009786f, -0.02868393f, 0.00380121f, 0.04930477f, -0.05357206f, 0.02865902f, -0.07361532f, -0.03448400f, 
    0.17491469f, -0.06406716f, -0.01805988f, -0.14084317f, -0.09764147f, -0.02584478f, 0.02443591f, -0.04020733f, 
    0.06923497f, -0.13476631f, 0.10979951f, -0.10528242f, -0.22952230f, 0.34063309f, 0.00402930f, -0.00010661f, 
    0.00656457f, -0.04769441f, 0.05499672f, 0.04434395f, 0.14435862f, -0.08100649f, -0.08780403f, -0.03886266f, 
    0.14041881f, 0.05470095f, 0.30807072f, 0.09581944f, -0.08299863f, 0.39792529f, 0.03894335f, 0.06436958f, 
    -0.06326579f, 0.08315404f, 0.04398676f, -0.01875111f, 0.18661466f, -0.17382166f, -0.05748820f, 0.18920125f, 
    0.10767724f, -0.00661128f, -0.01155714f, -0.10812444f, 0.00647235f, -0.02119886f, -0.02962007f, 0.29546350f, 
    0.05179034f, -0.21710621f, -0.13589199f, 0.11153276f, -0.04955949f, -0.11602404f, 0.11357256f, 0.06003698f, 
    -0.01546615f, -0.02679781f, 0.06017343f, 0.07760454f, 0.01092403f, 0.32764399f, -0.01562852f, 0.30604848f, 
    0.13626273f, 0.03894171f, -0.12368517f, -0.08162860f, -0.11961708f, 0.01284958f, -0.03724812f, 0.02518211f, 
    -0.00306474f, -0.22677186f, 0.52626741f, 0.09130572f, -0.12582171f, -0.02678356f, -0.17575929f, 0.15280482f, 
    0.01697900f, 0.09676244f, 0.15430546f, 0.00774894f, 0.37690189f, -0.44041401f, 0.47104445f, 0.24824896f, 
    -0.08706611f, 0.19172080f, 0.10970632f, -0.10154501f, 0.01288252f, 0.00719478f, -0.01477601f, 0.05069734f, 
    -0.22243601f, 0.61156094f, -0.29377729f, 0.24285188f, 0.19418471f, 0.18950438f, 0.13587131f, -0.12756948f, 
    0.03465806f, 0.12744118f, 0.14892623f, 0.26072186f, -0.21609259f, 0.13001867f, -0.28776756f, 0.35653865f, 
    0.05110526f, -0.20430759f, -0.23174688f, 0.07462079f, -0.03630564f, -0.19447607f, 0.07540063f, 0.03322068f, 
    -0.56641155f, 0.35314941f, -0.34988242f, 0.03785332f, 0.05283728f, 0.07187038f, -0.05069407f, -0.06247034f, 
    -0.10433349f, 0.17191549f, 0.17501195f, -0.14670378f, -0.11066808f, 0.09173816f, -0.44858178f, 0.24470907f, 
    0.08807489f, 0.23213767f, 0.06517041f, 0.10999560f, 0.10045566f, 0.00466857f, -0.13654633f, -0.10940695f, 
    0.20276211f, 0.20405024f, 0.02251300f, -0.18894072f, -0.12808751f, -0.27145904f, 0.12876786f, -0.01566106f, 
    -0.02779023f, 0.13705002f, 0.02397545f, 0.01435511f, -0.17157547f, -0.02937450f, 0.03504422f, 0.16877590f, 
    0.33111528f, -0.02797311f, 0.24138515f, 0.14156625f, 0.07479841f, 0.08902758f, -0.16998185f, -0.09043238f, 
    0.03589409f, 0.11434764f, 0.14779778f, 0.18985862f, 0.01395243f, -0.04573290f, 0.01597536f, 0.08134650f, 
    -0.09362145f, 0.04539034f, 0.02571235f, 0.09421236f, 0.12806192f, 0.17869624f, 0.12183318f, -0.02120623f, 
    -0.07698309f, -0.00006211f, -0.06137717f, 0.07567516f, 0.07390407f, 0.06015799f, 0.09552317f, 0.12696484f, 
    0.06646507f, -0.16109470f, 0.06880839f, 0.13640629f, -0.10027280f, 0.03464686f, 0.07387579f, 0.03246795f, 
    -0.05206543f, 0.00928237f, 0.05937865f, 0.15193684f, 0.28921670f, 0.11791999f, -0.14139964f, 0.19149992f, 
    -0.05164536f, -0.15531412f, 0.05486592f, -0.03706329f, 0.01168680f, -0.16418423f, 0.03192293f, 0.00930639f, 
    0.42482975f, 0.09878810f, -0.03984973f, 0.18087390f, -0.14158033f, 0.05892401f, 0.08171019f, 0.03557865f, 
    -0.02418323f, -0.02476832f, 0.07774543f, 0.07562501f, 0.03393892f, 0.19984989f, -0.05832119f, 0.27663046f, 
    -0.03267759f, -0.14143538f, 0.13722120f, 0.07245632f, 0.00519569f, 0.21787094f, 0.05187233f, -0.04758035f, 
    0.07470514f, 0.30955821f, 0.00984471f, -0.15850131f, -0.09159218f, 0.28545824f, 0.08463008f, -0.08478919f, 
    -0.05930465f, -0.02975699f, -0.10379215f, -0.05709522f, 0.56324852f, 0.14005265f, -0.36283404f, -0.22709975f, 
    -0.08987563f, -0.07711062f, 0.20956343f, 0.05720333f, 0.25134197f, 0.06290176f, 0.01627758f, -0.12597299f, 
    0.00365053f, 0.15480961f, 0.30962509f, -0.08569518f, 0.03400318f, 0.21339853f, 0.19122332f, -0.19066836f, 
    0.16410299f, -0.07952823f, 0.13476312f, 0.04178987f, -0.29606041f, -0.27662674f, 0.42498580f, -0.18371868f, 
    0.25925711f, 0.01970580f, -0.14968152f, 0.05521759f, -0.09003240f, -0.12134402f, -0.00739610f, 0.01094606f, 
    0.23228697f, 0.16555449f, -0.13733311f, -0.17874484f, 0.07535831f, -0.03954881f, 0.15155257f, 0.03620966f, 
    0.15068021f, -0.13406874f, 0.28645253f, -0.12060732f, 0.04430077f, -0.18681756f, -0.24677783f, -0.34882325f, 
    -0.09113243f, 0.11126753f, 0.18236358f, -0.03752124f, -0.06975696f, 0.03475820f, -0.21158215f, -0.08265422f, 
    -0.00558965f, 0.15366191f, -0.40862465f, 0.04995232f, -0.13325588f, 0.11642999f, 0.18331282f, -0.06687310f, 
    0.20602955f, -0.10636486f, 0.02460243f, 0.04484850f, 0.15380885f, -0.43947968f, -0.23325124f, 0.31526375f, 
    0.07755498f, 0.04269308f, 0.01313608f, -0.02780595f, 0.28285864f, 0.20815653f, 0.14348282f, 0.00245353f, 
    0.14886491f, 0.17202382f, 0.17965549f, 0.12375736f, 0.06069046f, 0.06505585f, 0.06301618f, -0.05802154f, 
    0.00847533f, -0.11889574f, 0.05657993f, -0.12873936f, 0.14137609f, 0.25578588f, 0.32595035f, 0.18271600f, 
    0.01612122f, 0.23141998f, 0.40614206f, -0.29473531f, 0.04503959f, -0.00566815f, 0.06876308f, -0.13542797f, 
    -0.00365836f, -0.03832133f, 0.04504871f, 0.03128663f, 0.08548509f, 0.04869745f, -0.18681623f, 0.07310294f, 
    -0.01046782f, -0.01389940f, -0.41411379f, 0.20715316f, 0.35870257f, 0.39973268f, -0.21914156f, -0.11796156f, 
    -0.07086742f, -0.14818975f, 0.03428938f, 0.06303011f, -0.11132973f, -0.01475102f, 0.08304059f, -0.03115563f, 
    0.14357494f, -0.11716287f, -0.19136414f, -0.38341826f, -0.01685941f, -0.02331391f, -0.25785846f, 0.08379786f, 
    -0.01757923f, 0.09296416f, -0.14669912f, -0.13409257f, -0.17908886f, 0.76643771f, -0.20715554f, -0.11529412f, 
    -0.01555440f, -0.13541475f, 0.17647353f, -0.05525301f, -0.01525799f, 0.09596658f, -0.25036243f, -0.07769633f, 
    0.23477183f, 0.27991909f, 0.21032342f, 0.31001419f, -0.07947750f, 0.27169120f, -0.02845247f, 0.06244323f, 
    0.09333678f, -0.02591264f, -0.02777633f, 0.04046250f, -0.27944699f, -0.12347191f, 0.02327028f, -0.14624801f, 
    0.12840174f, -0.05609026f, -0.18895505f, -0.14429675f, -0.03474915f, 0.04283559f, 0.11714628f, 0.08503039f, 
    -0.08735224f, -0.23067129f, 0.08310495f, 0.24372031f, 0.01352130f, -0.20318727f, -0.05611660f, -0.03550938f, 
    0.03365549f, -0.14019279f, -0.09409998f, -0.10791865f, -0.34736344f, 0.16664018f, 0.27078289f, 0.29845336f, 
    -0.01129602f, 0.12226220f, -0.05227942f, -0.03088762f, 0.07744210f, -0.01628090f, 0.01149386f, 0.04823534f, 
    0.20827201f, 0.01155366f, 0.04078716f, 0.17411895f, 0.13536370f, -0.06833207f, 0.01098017f, 0.12810174f, 
    0.03058986f, 0.19963720f, -0.06139332f, -0.26242810f, 0.34509429f, -0.12911527f, 0.43839490f, -0.43709826f, 
    -0.15372337f, 0.17542864f, -0.14847711f, 0.08133036f, 0.05613738f, 0.16493812f, 0.13398723f, -0.11570418f, 
    -0.24060498f, -0.23606388f, 0.02581619f, 0.14846118f, 0.01998773f, -0.08840390f, -0.08896061f, -0.03538987f, 
    0.13568972f, -0.00836957f, 0.11464653f, 0.10701423f, -0.52802622f, 0.39007142f, 0.31186530f, 0.20833699f, 
    -0.02771078f, -0.20816794f, -0.03287156f, -0.14232643f, -0.03726624f, -0.02036280f, 0.10579652f, 0.05052454f, 
    -0.56428164f, 0.35005364f, -0.16170636f, -0.11128294f, 0.24722390f, 0.11090680f, -0.00124821f, 0.20816658f, 
    -0.09537502f, 0.06740042f, 0.32465625f, -0.03385844f, -0.26593989f, 0.02348019f, -0.16808169f, 0.41340235f, 
    0.12900281f, 0.22061284f, 0.10305208f, 0.00935186f, 0.00758173f, -0.02537708f, 0.12485637f, -0.02133973f, 
    0.02641110f, -0.31613776f, 0.12766305f, 0.05298186f, -0.13082403f, -0.19463983f, -0.11797055f, 0.04068008f, 
    -0.05455920f, 0.04247211f, 0.12325880f, 0.08899931f, -0.30452034f, 0.07281086f, 0.42504388f, 0.38796702f, 
    0.09328558f, 0.03954600f, 0.14509028f, 0.24348089f, 0.05471878f, -0.07508563f, -0.07409929f, 0.18425843f, 
    -0.01047059f, -0.11214712f, -0.03924757f, 0.07954470f, -0.04384829f, 0.20601413f, -0.06027022f, -0.12296113f, 
    0.06131165f, 0.07657580f, 0.15478110f, 0.05318036f, -0.24302702f, 0.23410490f, 0.46654400f, -0.17184594f, 
    0.02464307f, -0.04225250f, -0.25997594f, 0.03881519f, -0.09188242f, 0.09873242f, -0.01890050f, -0.08418671f, 
    -0.16644056f, 0.07436493f, 0.04776656f, 0.03359789f, 0.02211891f, -0.06265471f, 0.07768458f, -0.06406254f, 
    0.15974382f, 0.00444832f, -0.01124481f, 0.09321368f, -0.05388307f, -0.30813354f, 0.12202006f, 0.19774380f, 
    -0.00952424f, 0.09903929f, 0.09561503f, 0.03864766f, -0.00170146f, -0.06232653f, 0.01109733f, -0.06053018f, 
    -0.32049000f, -0.03234174f, 0.22428359f, 0.04759916f, 0.03648594f, 0.07885519f, -0.13681702f, 0.16053908f, 
    0.23632528f, 0.04688992f, 0.09646330f, -0.09056354f, 0.27001971f, 0.03185590f, -0.15445501f, -0.05237235f, 
    -0.02576713f, -0.00452401f, -0.06737611f, -0.04073137f, 0.21196477f, 0.00632631f, 0.00965307f, 0.19578031f, 
    0.10006977f, -0.23366320f, -0.18732166f, -0.20112200f, 0.16546653f, -0.15565300f, -0.04055312f, 0.01897590f, 
    0.04453250f, 0.03959949f, 0.04209600f, 0.12509890f, 0.75684500f, 0.23130792f, 0.18027757f, -0.04180217f, 
    0.00748552f, 0.08366011f, -0.06364275f, 0.03328693f, -0.03374127f, 0.00825765f, 0.02826735f, -0.08940008f, 
    0.07260607f, -0.00617428f, -0.04110524f, 0.07327176f, 0.04067050f, -0.07547424f, -0.19022530f, 0.19345593f, 
    -0.06275946f, 0.09784862f, 0.04159668f, 0.10057397f, -0.63860708f, 0.09049276f, -0.29492074f, 0.55635571f, 
    -0.00757275f, 0.16205640f, 0.06643648f, 0.07166409f, -0.00222097f, -0.04599100f, 0.07847727f, -0.06686464f, 
    0.40033597f, 0.20824008f, 0.01484016f, -0.42700827f, -0.06492728f, 0.31459415f, -0.16401783f, -0.13341430f, 
    -0.17756689f, -0.19009183f, -0.04129533f, 0.20869143f, -0.51362610f, -0.16915703f, -0.12738143f, 0.24461432f, 
    0.14071500f, 0.21048348f, -0.18953165f, -0.18516882f, 0.07209345f, -0.07485908f, 0.16057728f, 0.30321887f, 
    0.34803012f, -0.21877514f, 0.18235929f, -0.15654124f, -0.01547627f, 0.03059314f, 0.08222430f, 0.02496733f, 
    0.16950047f, 0.12844566f, -0.18179324f, -0.15330693f, 0.03669745f, 0.15795261f, -0.10486165f, 0.07115662f, 
    0.08176590f, 0.04128246f, -0.01428874f, 0.10563485f, -0.24726346f, -0.14159855f, 0.02497233f, 0.01597882f, 
    0.24483088f, -0.07776871f, -0.05743663f, -0.23664621f, 0.15749232f, -0.03021057f, -0.01590003f, -0.06571329f, 
    -0.16968626f, 0.09169433f, -0.10748975f, 0.03319300f, -0.03125212f, -0.65712178f, -0.17557268f, 0.21880670f, 
    0.18978098f, 0.09430321f, 0.10775538f, 0.30797476f, -0.07496949f, 0.03306942f, 0.01680305f, 0.19008820f, 
    -0.07838897f, 0.09637637f, -0.05134462f, 0.19264677f, -0.10449345f, -0.06475535f, 0.18487094f, -0.15591139f, 
    0.01089476f, 0.18981963f, 0.13366441f, -0.10978022f, -0.19195566f, -0.06863777f, 0.17459548f, -0.27211291f, 
    0.14381228f, 0.05209475f, 0.03619184f, 0.06321619f, 0.11307697f, 0.03789435f, 0.08533160f, 0.00790400f, 
    -0.13026927f, -0.14651299f, 0.07470872f, -0.01216676f, -0.21523544f, -0.07650760f, 0.05546826f, -0.05787795f, 
    0.04584444f, 0.02860050f, -0.03656395f, -0.03888984f, -0.24925798f, 0.15512170f, -0.03826416f, 0.10439344f, 
    -0.05911955f, 0.00344491f, -0.06814775f, -0.07881252f, 0.01353766f, -0.10731889f, -0.06529654f, 0.19645308f, 
    -0.28327808f, -0.24198447f, 0.40938553f, 0.15175301f, 0.02317042f, -0.29565501f, 0.25814047f, -0.14157641f, 
    0.07749995f, -0.08986533f, 0.17458741f, 0.09769440f, 0.16512685f, 0.26294804f, 0.39496872f, -0.05503842f, 
    -0.13342924f, 0.06957480f, -0.00336408f, 0.05163424f, -0.27991274f, 0.01175730f, -0.09451129f, 0.12283151f, 
    0.11052011f, -0.21777681f, -0.29621521f, 0.39135170f, 0.01567350f, -0.03407568f, -0.01238597f, -0.00677661f, 
    -0.05637924f, 0.00795338f, 0.05056019f, 0.05769314f, -0.15384865f, 0.29124877f, -0.37724558f, 0.27679312f, 
    0.05832936f, -0.03425111f, -0.19813117f, -0.14937669f, 0.03259594f, -0.09932088f, 0.19309863f, -0.09450936f, 
    0.13570751f, 0.00833480f, -0.13631190f, 0.15532888f, -0.06103400f, -0.06823371f, 0.01630482f, 0.04493388f, 
    0.10481395f, 0.09024769f, 0.18966486f, -0.02413520f, -0.12926090f, -0.12713447f, -0.04546204f, 0.05494560f, 
    -0.20780951f, -0.02601983f, 0.09139755f, 0.02263290f, -0.00883112f, -0.02929267f, -0.05831745f, 0.08621475f, 
    -0.08681831f, -0.15476795f, -0.42605722f, 0.04019608f, 0.16540897f, 0.09605330f, 0.21985210f, 0.22070585f, 
    -0.12294121f, 0.04554159f, -0.07348034f, 0.07389658f, 0.21276087f, 0.31330669f, 0.18639152f, 0.31689927f, 
    0.10767639f, -0.12817694f, 0.18340088f, -0.08636423f, 0.29919112f, 0.31525275f, 0.26754060f, 0.03340683f, 
    -0.32214570f, 0.52520698f, -0.02913984f, 0.15288831f, 0.04709186f, -0.10354324f, -0.06507885f, -0.00603489f, 
    -0.14341283f, -0.06252868f, 0.05136575f, -0.08357345f, -0.18234554f, 0.40090215f, -0.43299475f, 0.05775030f, 
    0.00488825f, 0.11315504f, -0.17170165f, 0.04637048f, 0.15923308f, -0.09253072f, 0.06425751f, 0.08909386f, 
    -0.00538505f, 0.10763489f, -0.13567154f, 0.23398018f, 0.13405965f, 0.05945497f, -0.01362115f, 0.02043710f, 
    -0.10116316f, 0.11258578f, -0.02764913f, -0.04532226f, 0.18936062f, 0.04739815f, 0.06448756f, 0.36440665f, 
    0.20992468f, 0.22654410f, 0.01548667f, -0.12436334f, 0.04144222f, 0.16823553f, 0.08094072f, 0.00627105f, 
    -0.10735599f, 0.26264295f, -0.04063919f, 0.01836748f, 0.01664818f, 0.08276489f, -0.05206845f, 0.14491469f, 
    -0.13698049f, 0.02356278f, -0.33108515f, -0.14915471f, -0.25423551f, -0.42961538f, -0.45967361f, 0.26954186f, 
    -0.14537923f, -0.11461016f, 0.00606119f, -0.07245436f, 0.04076296f, 0.01433745f, 0.11781055f, 0.07149732f, 
    0.03779313f, -0.03863499f, -0.07494839f, -0.05049003f, 0.00048065f, -0.03511542f, -0.01428754f, -0.03581496f, 
    -0.05005913f, 0.01169145f, -0.07546534f, 0.02866763f, -0.00413650f, -0.05213467f, -0.04132833f, 0.05337001f, 
    -0.01284397f, -0.07682122f, -0.07293300f, -0.04048538f, 0.02280376f, 0.02564147f, -0.06260939f, -0.04981048f, 
    0.02076263f, 0.03257364f, -0.00139783f, 0.00277996f, 0.03951053f, -0.06110184f, 0.00592245f, -0.00786203f, 
    -0.02263462f, -0.03193381f, 0.02680550f, 0.05599708f, 0.00616412f, 0.00617324f, 0.04056899f, 0.05114891f, 
    -0.06384096f, 0.05281047f, -0.04027009f, 0.02843115f, 0.00312679f, 0.06492703f, -0.02384615f, 0.03092888f, 
    0.00448432f, -0.00344724f, 0.01496110f, 0.02460590f, -0.01585979f, -0.02188967f, -0.00040186f, -0.06151151f, 
    -0.05503519f, 0.05515483f, 0.06194806f, -0.02567466f, 0.06697561f, 0.00445208f, -0.07293981f, 0.00505233f, 
    -0.06528103f, -0.00862689f, 0.02599096f, -0.06535564f, -0.01737782f, -0.07421437f, -0.02688769f, 0.05484741f, 
    0.00871312f, -0.01160590f, -0.07720742f, -0.02324042f, -0.00461426f, 0.03312426f, 0.02881833f, 0.04769649f, 
    -0.05958924f, -0.03780664f, -0.06102212f, 0.04259884f, -0.02554908f, -0.03661014f, -0.05604070f, -0.00503972f, 
    -0.00346689f, 0.00005417f, -0.04803187f, -0.05354566f, -0.04035890f, -0.00933168f, -0.04262413f, -0.06817327f, 
    0.05976787f, 0.05157342f, 0.06110354f, -0.00263143f, 0.00489298f, 0.03701631f, -0.06329976f, 0.01921217f, 
    -0.07004679f, -0.03262822f, 0.00045941f, -0.01260382f, -0.03258896f, 0.05588520f, 0.04881677f, -0.03571194f, 
    -0.07053147f, 0.03055320f, 0.01066770f, -0.03713251f, -0.05403676f, 0.00173412f, 0.03369398f, -0.06593306f, 
    -0.06147415f, -0.05637773f, -0.06279983f, 0.03499891f, -0.05362438f, -0.01690281f, 0.01084520f, -0.01424256f, 
    -0.05927043f, 0.06465525f, -0.06653989f, -0.02879512f, -0.00480579f, -0.01543513f, 0.03013726f, 0.04059638f, 
    -0.03695682f, -0.00640452f, -0.07357141f, 0.02551755f, -0.06418930f, -0.07709309f, 0.03954513f, -0.07641390f, 
    -0.03502198f, 0.01467802f, -0.03358997f, -0.03394577f, 0.02297138f, -0.00542322f, -0.03459174f, 0.00440567f, 
    0.06192881f, 0.01145750f, 0.04423482f, 0.01372891f, 0.03360880f, -0.04524108f, 0.06101782f, -0.02492626f, 
    -0.02423172f, -0.03251466f, -0.07136301f, 0.06448967f, -0.00634826f, -0.03315905f, -0.00761493f, -0.00715847f, 
    0.00308447f, -0.01917618f, -0.00125402f, 0.02705958f, -0.01530781f, -0.01706031f, 0.01747111f, -0.00985864f, 
    0.04827926f, 0.02897046f, -0.06262467f, -0.00885841f, -0.05092760f, 0.02706065f, -0.05797544f, 0.01991016f, 
    0.01782905f, -0.07165246f, -0.03901181f, 0.05047455f, -0.03095317f, 0.01202088f, 0.01802649f, 0.06446534f, 
    0.31015748f, 0.02232513f, -0.09935141f, 0.03448356f, 0.07950562f, -0.06668695f, -0.00885151f, 0.04902320f, 
    -0.06818022f, 0.02752642f, -0.01815354f, -0.28596482f, 0.34766102f, 0.42502651f, -0.06682650f, 0.20254146f, 
    0.26566759f, 0.08236945f, 0.07182811f, 0.11521801f, 0.21860720f, 0.09794313f, 0.00534499f, -0.01588506f, 
    0.35760587f, 0.25039777f, 0.01783282f, 0.12484332f, -0.11608700f, 0.10799717f, -0.05722295f, 0.11226594f, 
    -0.06218012f, 0.07657402f, -0.01415204f, 0.08647272f, 0.19291839f, -0.06249839f, 0.05141693f, -0.12099918f, 
    0.11260220f, 0.09775744f, 0.05180739f, 0.10564006f, -0.06726195f, -0.11702814f, 0.13621639f, -0.27185881f, 
    -0.02528395f, 0.24072519f, 0.04997423f, -0.32240599f, 0.07372323f, -0.10253554f, 0.00169876f, -0.17595732f, 
    -0.06826050f, -0.09261526f, 0.00314553f, -0.14559522f, -0.53836113f, -0.09283374f, 0.18913594f, 0.28668654f, 
    -0.02994079f, -0.07218835f, 0.13267323f, 0.15144263f, -0.01897969f, 0.01376238f, 0.05941929f, 0.04031710f, 
    0.09579610f, 0.19397694f, 0.18915115f, -0.00062931f, -0.12076982f, 0.04375469f, -0.02988343f, -0.06600659f, 
    -0.01016203f, 0.05085662f, -0.09186969f, -0.06064569f, 0.66690862f, 0.07851640f, 0.32194394f, -0.22044966f, 
    0.02003170f, 0.09893138f, 0.36618695f, -0.07552860f, 0.15306138f, 0.05004397f, 0.10821916f, -0.00424737f, 
    -0.13689359f, 0.00516782f, 0.25466999f, 0.14929336f, 0.26238784f, 0.02371107f, -0.12320140f, -0.23547368f, 
    0.05120328f, -0.11940597f, 0.07304027f, -0.25089246f, 0.32444280f, 0.12802072f, -0.02126375f, -0.05133997f, 
    -0.11664984f, 0.01487019f, 0.21316355f, 0.07753263f, 0.02792060f, 0.11053202f, -0.01768879f, -0.06473344f, 
    -0.00708456f, 0.11765525f, -0.14580297f, -0.10103568f, -0.15004572f, -0.00019089f, 0.06715326f, 0.09398867f, 
    -0.01857211f, -0.04143895f, 0.04241723f, 0.00088675f, -0.11071751f, -0.36321706f, -0.12579435f, 0.18908615f, 
    0.06953616f, -0.01127490f, 0.08135210f, -0.15377514f, 0.05339011f, 0.05841575f, 0.03325894f, 0.04322258f, 
    -0.13923481f, -0.47681248f, -0.15998639f, -0.44481656f, 0.02760145f, 0.02140045f, 0.01242344f, -0.08147714f, 
    -0.10628320f, -0.11590829f, 0.06833722f, -0.02985849f, 0.04686265f, -0.11429940f, 0.00746025f, -0.31898311f, 
    -0.13074206f, -0.23827146f, -0.00607292f, 0.07131605f, -0.16068256f, -0.06570406f, -0.03763989f, -0.00636988f, 
    0.14651351f, -0.42737216f, 0.12723227f, 0.02185600f, -0.11828043f, 0.03399708f, -0.08065313f, 0.01290537f, 
    -0.04584854f, -0.11358447f, 0.12467419f, 0.02623654f, 0.39485350f, 0.46102563f, 0.09942977f, 0.05426192f, 
    0.04665319f, -0.03710167f, -0.06352472f, 0.03131400f, -0.03328878f, -0.01373599f, -0.03466526f, 0.08371586f, 
    -0.19732973f, 0.14630620f, -0.01228524f, -0.33657801f, -0.34023446f, -0.22689572f, -0.17959900f, -0.23913002f, 
    -0.14743818f, 0.02076194f, -0.00445281f, 0.15381928f, -0.11371246f, -0.10542639f, -0.24682942f, -0.33267474f, 
    -0.37768906f, -0.25175694f, -0.15175097f, -0.09360731f, -0.17355260f, -0.30221152f, 0.10265975f, -0.10080468f, 
    0.39631113f, -0.29039532f, 0.18476038f, 0.10497720f, -0.17916732f, 0.18377246f, -0.04913677f, 0.37178922f, 
    -0.02171722f, 0.17631206f, 0.04387532f, 0.38233596f, -0.06295042f, 0.49290752f, 0.09781928f, 0.17498495f, 
    -0.20296670f, -0.29580981f, -0.04633309f, -0.05827985f, 0.18002003f, 0.17969346f, 0.14985505f, 0.12064531f, 
    -0.14405765f, 0.08456393f, 0.13638778f, -0.02992772f, -0.09571698f, 0.05037563f, 0.17122163f, -0.19895585f, 
    0.04497440f, -0.13007928f, -0.10821822f, -0.05251538f, 0.01535535f, 0.12903000f, -0.16932014f, -0.12377428f, 
    -0.03519202f, -0.11549305f, 0.22370082f, 0.01817911f, 0.10393867f, 0.02754455f, 0.03581847f, 0.00935262f, 
    0.25096169f, -0.06042559f, -0.03800352f, 0.06553091f, 0.36191133f, 0.20246671f, 0.25202593f, -0.21314268f, 
    0.18079664f, 0.05864000f, 0.26658976f, 0.17605804f, 0.24836467f, 0.32129773f, 0.42999333f, -0.07624924f, 
    0.24722785f, 0.02759589f, 0.05794179f, 0.11481758f, -0.14040400f, 0.13291146f, 0.08653253f, 0.01307896f, 
    -0.43405831f, -0.54495138f, -0.04305485f, -0.05450387f, -0.02334273f, -0.17249554f, 0.27675566f, 0.12068822f, 
    0.02304154f, 0.03817876f, 0.00661145f, -0.08538677f, -0.14740945f, -0.10358246f, 0.19861458f, -0.50292534f, 
    -0.12569275f, 0.27143699f, 0.16949770f, 0.16451566f, 0.10813929f, 0.16484916f, -0.10928788f, 0.11532068f, 
    -0.13509475f, -0.27920488f, 0.15725388f, 0.22297895f, 0.01464406f, 0.03916731f, -0.01229719f, 0.19345090f, 
    0.09888998f, -0.06515008f, 0.05433476f, 0.23416613f, -0.03366072f, -0.11734757f, 0.16502883f, -0.03624776f, 
    0.05925821f, -0.04934895f, 0.01578020f, 0.18247595f, 0.08415888f, 0.15406865f, 0.20112513f, 0.14346398f, 
    -0.13236719f, 0.26843548f, -0.02335007f, 0.09077013f, 0.08189118f, -0.14227733f, 0.03785957f, -0.06302583f, 
    0.07047816f, -0.04931596f, -0.13825944f, -0.29875252f, -0.11892619f, 0.35921142f, 0.40348023f, 0.07151110f, 
    -0.07638378f, -0.01222503f, 0.11111107f, -0.05405663f, -0.05290968f, -0.00764175f, 0.10186654f, 0.00201400f, 
    0.02324650f, 0.09591678f, 0.04069949f, -0.12060282f, 0.10799707f, 0.17386030f, -0.01187254f, 0.11441338f, 
    0.13215394f, -0.04860301f, -0.20130740f, -0.27532685f, 0.05642509f, -0.14892058f, -0.10696085f, -0.38098627f, 
    -0.47154155f, -0.03454411f, -0.09652148f, -0.27311453f, -0.07452601f, 0.05891993f, -0.07661949f, 0.10778511f, 
    0.01513937f, 0.14517620f, 0.17117912f, -0.08707266f, -0.17962871f, -0.08874466f, -0.19243169f, -0.13065161f, 
    -0.28623199f, -0.05047760f, 0.00196280f, 0.11323990f, -0.05131822f, 0.52206159f, -0.15146792f, 0.04676079f, 
    -0.20210735f, -0.09350656f, -0.17744210f, -0.02888294f, -0.08927064f, -0.02625744f, 0.01511589f, -0.10565574f, 
    0.00082211f, 0.03634117f, 0.05058167f, 0.20719333f, 0.13736486f, 0.42213064f, -0.20620155f, 0.04408034f, 
    0.09804682f, -0.01946146f, 0.12666196f, 0.16277403f, 0.38441715f, 0.07442799f, -0.02654680f, 0.14812636f, 
    -0.05208296f, 0.01120389f, -0.05313052f, -0.06639240f, -0.00973013f, 0.10948841f, -0.14696279f, 0.33744550f, 
    0.11626169f, 0.22590299f, 0.12809721f, 0.02848547f, 0.22938699f, 0.04354596f, 0.09917000f, -0.04985277f, 
    0.05292685f, -0.06201155f, 0.07616822f, 0.13265489f, 0.12350553f, 0.33297098f, 0.06469427f, 0.22248462f, 
    -0.03159442f, 0.01113796f, 0.11178514f, 0.04829899f, -0.05970939f, 0.13349801f, -0.07116481f, 0.12102134f, 
    0.27200031f, 0.00657521f, 0.05376403f, 0.14258140f, 0.34868640f, -0.11452224f, -0.15766269f, -0.13931806f, 
    0.00944989f, 0.21525320f, 0.13471165f, 0.18966371f, 0.60483813f, 0.04075141f, 0.34425405f, 0.15828580f, 
    -0.02713341f, 0.27654499f, 0.08539453f, 0.20501091f, -0.28143269f, -0.00607052f, 0.04024014f, -0.11316731f, 
    -0.29025382f, -0.10561270f, 0.02818267f, -0.06542323f, -0.04784793f, 0.05383286f, 0.16545622f, 0.14228371f, 
    0.17037308f, 0.07578920f, 0.05428288f, 0.21300961f, -0.26478621f, -0.08435592f, -0.03429520f, 0.17679150f, 
    0.03364684f, 0.03497692f, 0.07402523f, -0.00311253f, 0.20104994f, -0.03264333f, 0.05706144f, 0.20142868f, 
    -0.17138954f, -0.09586226f, -0.27781799f, -0.21509545f, -0.00681480f, 0.01793911f, 0.12651788f, -0.01190243f, 
    0.05499901f, -0.05054244f, 0.23515837f, 0.15820810f, -0.00270065f, -0.24527957f, -0.29764384f, -0.03889301f, 
    0.04099570f, 0.12665743f, 0.11853481f, 0.14962329f, -0.02408944f, -0.04770380f, 0.11612964f, -0.10376522f, 
    0.21356259f, 0.01649124f, 0.11972844f, 0.01900040f, 0.13033140f, -0.14133738f, 0.02764304f, 0.08479287f, 
    0.06013924f, 0.03345387f, -0.10850290f, 0.01606622f, -0.45753726f, -0.60991758f, -0.35476989f, -0.23108317f, 
    0.25739795f, 0.15492827f, -0.05734979f, 0.12168913f, 0.02269678f, -0.00815847f, -0.01117497f, -0.11361132f, 
    0.10605898f, -0.07662100f, 0.05284905f, -0.03423007f, 0.02281441f, 0.17853251f, 0.07127836f, 0.13220084f, 
    0.02652970f, -0.14935377f, -0.09246895f, -0.36216226f, 0.12881698f, 0.15099384f, 0.02459941f, 0.07212636f, 
    -0.15414976f, -0.03134140f, -0.18150042f, -0.12327845f, 0.04315053f, 0.06124019f, -0.02106576f, 0.04701974f, 
    -0.23729260f, 0.11453224f, -0.02966587f, -0.41616151f, -0.07397483f, 0.03967779f, 0.08616050f, -0.04799546f, 
    -0.08615257f, 0.01110693f, -0.22972982f, 0.01532520f, -0.03337495f, 0.28523931f, -0.18583654f, -0.30494285f, 
    -0.10888679f, 0.13306710f, -0.03500080f, -0.10084461f, 0.01464088f, 0.06815594f, 0.03840093f, -0.07173761f, 
    -0.32402205f, -0.02339030f, 0.48177642f, 0.09426790f, -0.02525851f, -0.23659576f, 0.00436262f, 0.05177129f, 
    0.03835860f, 0.12363780f, -0.08477297f, 0.12139569f, -0.20938750f, 0.49679458f, 0.33899283f, -0.06394532f, 
    -0.13482943f, -0.04663727f, -0.12636788f, -0.05066586f, 0.03599015f, 0.14859818f, 0.24133393f, 0.10434080f, 
    -0.18612714f, -0.61830193f, -0.33906904f, -0.03039462f, 0.04309342f, 0.01599358f, -0.12680872f, -0.09520050f, 
    -0.10203980f, -0.04463824f, 0.04195880f, -0.07995775f, -0.02852678f, 0.09968241f, -0.08582674f, -0.02346116f, 
    0.06803683f, 0.23834848f, 0.02949014f, 0.21912302f, -0.10974222f, -0.06808513f, 0.13774218f, -0.04370183f, 
    0.15483083f, 0.04239661f, -0.17674297f, -0.02308191f, 0.19896168f, -0.05967201f, 0.02142181f, -0.03506169f, 
    0.04031971f, -0.11307728f, 0.04905599f, -0.10747951f, -0.39941254f, 0.27032867f, 0.23348238f, 0.21366307f, 
    -0.10539658f, -0.06714275f, 0.18462367f, 0.07195392f, 0.13725656f, 0.15660086f, 0.03687211f, 0.17034408f, 
    -0.00040258f, -0.63660514f, -0.26491633f, -0.07453310f, 0.05075243f, -0.04387466f, -0.20582408f, 0.14391677f, 
    -0.06363607f, 0.12231286f, 0.25842476f, -0.17660895f, -0.46707276f, 0.13133684f, 0.39661288f, -0.10732724f, 
    -0.04680936f, -0.07272273f, 0.03696973f, 0.05177379f, 0.01584711f, 0.25100172f, 0.19005410f, 0.09914166f, 
    0.27446893f, 0.06512694f, 0.01914527f, -0.30113471f, 0.06363056f, -0.03813953f, -0.08747147f, 0.33620110f, 
    -0.06226199f, 0.09223798f, 0.15081240f, -0.06431032f, -0.26263508f, -0.04226899f, -0.11594532f, 0.22206344f, 
    -0.06012030f, 0.01378461f, -0.02099944f, 0.11669675f, -0.10420575f, 0.10688745f, 0.05197728f, 0.04447578f, 
    0.22583607f, -0.25810730f, -0.17984803f, 0.09820774f, 0.05793297f, 0.05139069f, -0.16814464f, 0.23458098f, 
    -0.02338103f, -0.05605102f, 0.01555867f, 0.16651545f, 0.29745659f, -0.24556662f, 0.08361017f, 0.16878904f, 
    -0.14011911f, 0.11357613f, 0.14598571f, 0.10992631f, 0.01952307f, 0.01232379f, 0.03687181f, 0.19885945f, 
    -0.14131992f, 0.06654170f, -0.12025923f, 0.15804805f, -0.00294530f, 0.14820129f, 0.05595579f, -0.12040171f, 
    0.12827130f, 0.27576521f, 0.28211606f, 0.19304015f, -0.11778122f, 0.01685596f, 0.23982817f, -0.10157963f, 
    -0.02435486f, -0.09607098f, -0.12939566f, -0.13326460f, -0.15319344f, 0.18859985f, -0.03675918f, -0.14539248f, 
    -0.19380508f, -0.20147507f, -0.03957675f, 0.24111806f, -0.01165828f, -0.17342120f, -0.13149375f, -0.06533938f, 
    0.17719539f, 0.05773066f, 0.04436369f, 0.15636580f, 0.01769121f, -0.62842137f, 0.23599222f, -0.06575195f, 
    -0.06911914f, -0.07908738f, -0.07749593f, 0.19857542f, 0.01807032f, -0.02191612f, 0.00613156f, 0.03751847f, 
    -0.04341521f, -0.30085018f, -0.00541066f, -0.39756927f, 0.18275660f, 0.10792120f, 0.16925143f, 0.17561580f, 
    0.18629541f, -0.04232614f, 0.09090409f, 0.02558962f, 0.15610586f, -0.09579461f, 0.00907645f, 0.12446959f, 
    -0.23161998f, 0.02877323f, -0.04738202f, -0.11782037f, 0.22578089f, -0.11635421f, 0.06644661f, 0.01003140f, 
    -0.32067946f, -0.20823418f, 0.21279319f, -0.04381423f, -0.02730273f, -0.02213469f, 0.19622879f, 0.25398403f, 
    -0.00344884f, -0.15390819f, 0.03215904f, 0.13297835f, -0.29892749f, -0.00104109f, 0.41451630f, -0.10094824f, 
    0.08951817f, 0.11676059f, -0.25925952f, 0.24925661f, -0.02032236f, 0.10184875f, -0.14222950f, -0.08839445f, 
    -0.14382611f, -0.11076193f, -0.32773000f, 0.04831062f, 0.00606025f, 0.11661477f, -0.01924360f, 0.08583527f, 
    0.03266229f, 0.20122384f, 0.18577422f, 0.10883601f, 0.35102743f, 0.47458950f, -0.43545127f, 0.17833403f, 
    -0.04824411f, 0.07159816f, 0.04976453f, 0.06591979f, 0.17200398f, -0.09871585f, 0.19101234f, -0.18549982f, 
    -0.39283469f, -0.03046516f, 0.35376051f, 0.08350223f, -0.03492549f, -0.02525825f, 0.05622448f, 0.10138599f, 
    0.08640613f, -0.12976944f, -0.18325107f, 0.20288716f, 0.15053871f, 0.08684900f, 0.28724605f, -0.08985688f, 
    0.16110288f, 0.02084518f, -0.40922338f, 0.03724279f, 0.11733730f, -0.19930358f, -0.07077972f, 0.04023662f, 
    0.01009700f, -0.32468748f, 0.42914417f, 0.24908927f, -0.07275090f, 0.03424671f, -0.12388361f, -0.00756834f, 
    -0.22718535f, 0.15529783f, -0.08909750f, -0.01492627f, -0.01736343f, 0.38122955f, 0.63080043f, -0.16049294f, 
    -0.00395883f, 0.03729441f, -0.01179420f, 0.08562495f, 0.08895772f, 0.01851550f, 0.05489716f, -0.02548946f, 
    -0.28710780f, 0.14548585f, 0.06314120f, 0.12908390f, -0.04619807f, -0.11207868f, 0.09198637f, 0.10606968f, 
    0.02938272f, -0.03021825f, -0.12927103f, -0.08814324f, -0.18310946f, 0.34614915f, 0.10588202f, 0.10681225f, 
    -0.12813467f, -0.37415144f, 0.05233111f, 0.23345678f, -0.02045476f, -0.07082953f, 0.01323079f, 0.01453606f, 
    0.01231207f, 0.05537600f, 0.01288135f, 0.21495697f, 0.06238207f, 0.12089063f, 0.06072168f, -0.12435251f, 
    0.25559807f, -0.08221953f, 0.13022907f, -0.02119713f, 0.05038303f, -0.35453275f, 0.48458016f, -0.24090563f, 
    -0.15035036f, 0.02638796f, 0.02772906f, -0.01211920f, 0.30536479f, -0.16855310f, -0.10403042f, -0.16114083f, 
    -0.05078594f, -0.05022136f, 0.03881432f, -0.01912436f, -0.03663008f, -0.03863403f, 0.02609098f, -0.02684820f, 
    -0.04849203f, -0.03942140f, 0.03058231f, -0.07440466f, -0.02371448f, 0.00913010f, 0.00199590f, 0.04067969f, 
    0.05710037f, 0.04959032f, 0.01106882f, -0.00327315f, 0.00072094f, -0.07113989f, 0.01565871f, -0.05073138f, 
    -0.00677850f, -0.00832859f, -0.04915654f, -0.07037936f, -0.01847595f, -0.02495519f, -0.03780542f, -0.02687871f, 
    0.00914782f, 0.04293708f, 0.02248490f, -0.05881273f, 0.05098296f, 0.03317189f, 0.01029687f, 0.02962285f, 
    0.03177983f, -0.03587405f, -0.06371827f, 0.05287203f, -0.02678864f, 0.04498305f, -0.01113091f, 0.03329860f, 
    -0.06498690f, -0.07389999f, -0.03205216f, 0.02278552f, 0.06241901f, -0.02228278f, 0.02998286f, 0.03108219f, 
    0.00228086f, -0.05479724f, 0.01426437f, -0.06713808f, -0.02817548f, -0.00862065f, 0.03824734f, 0.01267243f, 
    -0.01268595f, 0.01505294f, -0.03675969f, -0.03698172f, 0.05372538f, -0.03987710f, -0.06834359f, 0.00380051f, 
    -0.02280182f, -0.06312771f, -0.02277052f, 0.03822016f, -0.05416198f, 0.04636974f, -0.02406592f, -0.03072951f, 
    0.04183768f, 0.03662932f, 0.00868714f, -0.06775527f, 0.03483898f, 0.05659654f, -0.08102221f, 0.05182199f, 
    -0.02380964f, -0.07550525f, -0.05552766f, -0.06609763f, 0.04760800f, 0.04540915f, -0.06386561f, -0.00199360f, 
    0.06267133f, -0.01067546f, 0.05014564f, 0.04661666f, 0.02288131f, -0.02276552f, -0.01832362f, -0.04116149f, 
    0.04169688f, -0.07378793f, -0.07015519f, -0.04605335f, 0.00034539f, -0.06759162f, 0.01311196f, 0.02903756f, 
    -0.03478382f, -0.07888815f, -0.05386924f, 0.01420220f, 0.03524321f, -0.01527183f, 0.00370271f, 0.04215484f, 
    -0.08791760f, -0.03971454f, 0.01979727f, 0.06439844f, -0.02873160f, -0.04440205f, -0.03011316f, -0.01838931f, 
    -0.01784927f, -0.01319513f, 0.06360029f, 0.06436503f, 0.03920453f, -0.01407070f, 0.04800100f, 0.00681381f, 
    -0.06655442f, -0.00825421f, -0.07967746f, -0.05389623f, 0.00786692f, -0.03654925f, 0.00183658f, 0.00316167f, 
    -0.00624587f, 0.06158667f, -0.04741263f, 0.00920789f, -0.05457437f, 0.04807434f, -0.04975554f, -0.00737572f, 
    0.03702497f, 0.04282052f, -0.02051821f, 0.03485796f, 0.01427795f, 0.06458801f, -0.04227333f, 0.05279743f, 
    -0.05816482f, -0.03976488f, -0.00842624f, -0.07211409f, -0.03269852f, -0.07625437f, -0.04807613f, -0.01700718f, 
    0.02890137f, 0.04546924f, -0.02809537f, 0.05961759f, -0.00432385f, -0.02707563f, -0.01153919f, -0.03804083f, 
    0.05581066f, -0.06368905f, -0.04590027f, 0.05091782f, -0.02906402f, 0.04967534f, 0.03831540f, -0.01484968f, 
    0.06210333f, -0.04759632f, -0.03097430f, -0.01137998f, -0.01718202f, 0.04487804f, -0.05928688f, 0.05121746f, 
    0.06574020f, 0.09385271f, 0.07391260f, 0.27977103f, -0.03993798f, 0.02044592f, 0.07279859f, 0.01428325f, 
    -0.03395634f, -0.14301181f, 0.01754908f, -0.01596111f, 0.35424688f, -0.25881371f, 0.23979077f, 0.33621380f, 
    0.16696319f, 0.12470638f, -0.04661953f, 0.07299305f, 0.07485102f, 0.11689964f, 0.02096024f, 0.17440489f, 
    0.09225079f, -0.11209757f, 0.04759318f, -0.12323919f, 0.33866906f, -0.30938631f, 0.13411894f, 0.00844589f, 
    -0.01102709f, -0.01656581f, -0.04777955f, 0.01693582f, 0.42393339f, 0.08742615f, 0.34999508f, -0.00629628f, 
    -0.04437448f, 0.05359022f, 0.01074372f, 0.14366050f, -0.12889345f, -0.04099796f, 0.11662617f, -0.14777301f, 
    -0.39874825f, 0.05987367f, -0.10646974f, -0.26033407f, 0.05457370f, -0.06205447f, 0.01657376f, 0.07051934f, 
    -0.05822109f, -0.00180776f, 0.05932123f, 0.03169163f, -0.42509028f, -0.12565960f, -0.03800013f, -0.09776295f, 
    0.02832133f, 0.02743902f, -0.01242064f, 0.11233594f, 0.05819502f, 0.14652778f, 0.13141727f, 0.01335189f, 
    -0.00403249f, 0.10121006f, -0.25032541f, 0.04499943f, -0.14720404f, -0.02300508f, 0.04819451f, 0.05835797f, 
    -0.06685810f, -0.15527874f, -0.02886816f, -0.12073524f, 0.23712395f, 0.34042704f, -0.26976261f, -0.12602597f, 
    0.02254435f, -0.13305126f, 0.17584728f, 0.02318758f, 0.23736379f, -0.05642598f, -0.04715190f, 0.10798085f, 
    -0.17766932f, -0.31172773f, 0.02148091f, -0.38722301f, 0.13917850f, 0.16204166f, 0.04770111f, 0.13133149f, 
    0.12479696f, -0.03051046f, -0.24545939f, -0.10104368f, 0.73631954f, 0.07312142f, 0.21044098f, -0.11996651f, 
    0.10009758f, -0.16612595f, -0.06828488f, -0.03230277f, 0.11306774f, 0.09475034f, -0.03407142f, -0.34096470f, 
    0.00167535f, -0.00978547f, 0.47809580f, 0.19350389f, -0.21407564f, -0.07398233f, -0.08256684f, -0.02541899f, 
    -0.15781277f, -0.17383412f, -0.02333664f, 0.19460446f, 0.24652851f, 0.42806479f, 0.35471413f, -0.45029682f, 
    0.05135777f, -0.01006778f, 0.07062207f, -0.11110532f, 0.07108468f, 0.24134573f, 0.09697144f, 0.04241420f, 
    -0.53839266f, -0.11259945f, -0.31688750f, -0.12162224f, 0.22584826f, 0.23541853f, 0.11427329f, -0.04571632f, 
    0.06474961f, -0.12718976f, 0.04099990f, 0.00144894f, -0.04185970f, 0.14777656f, -0.04801670f, -0.19782910f, 
    -0.24422485f, -0.09181461f, -0.26343828f, -0.04945530f, -0.02239693f, 0.02850757f, 0.16573818f, -0.04468164f, 
    0.04366784f, 0.17266916f, -0.06221841f, -0.18460110f, 0.04714194f, 0.01635737f, 0.07674169f, 0.02908389f, 
    0.05834842f, 0.15424372f, 0.09873657f, 0.00531679f, 0.20250283f, -0.12541300f, -0.33825880f, 0.43520021f, 
    0.02605470f, 0.05012777f, 0.01435712f, -0.00011323f, -0.04358430f, -0.06237403f, -0.02297170f, 0.07192928f, 
    0.00045252f, 0.01224581f, -0.07630357f, -0.04455313f, -0.00248342f, -0.02309576f, -0.00286707f, -0.00161899f, 
    0.03296435f, -0.06055725f, 0.04965260f, -0.02151607f, 0.04218929f, 0.03002062f, 0.02085166f, 0.02433795f, 
    0.00517653f, -0.00531993f, -0.02558958f, -0.06883795f, -0.05277697f, 0.01798841f, -0.05456422f, -0.04599408f, 
    -0.04447484f, 0.01753585f, 0.02232823f, -0.00474109f, 0.01253194f, 0.04841150f, -0.06453826f, -0.00005565f, 
    0.03895129f, -0.05932197f, -0.00518796f, 0.05037498f, -0.00199383f, -0.05866278f, 0.03238330f, -0.04205587f, 
    -0.07918592f, 0.02614280f, 0.05204877f, 0.01687704f, 0.03966056f, -0.05652542f, -0.04811465f, 0.02733402f, 
    -0.05084303f, 0.02844935f, -0.05132885f, -0.04148165f, 0.04881812f, 0.01630513f, 0.04337827f, 0.02759720f, 
    -0.00686580f, -0.07998003f, -0.07534828f, -0.03973293f, -0.04105589f, -0.04534600f, 0.00190145f, -0.01342043f, 
    -0.01369302f, -0.04498008f, -0.05033258f, 0.04070414f, -0.02205566f, 0.02850154f, -0.06720351f, 0.03696165f, 
    0.00135366f, 0.05885826f, 0.06198978f, -0.05142118f, -0.03891990f, -0.05983437f, -0.03357375f, 0.03962654f, 
    -0.04555522f, -0.03075527f, 0.03635293f, 0.05170750f, -0.00430466f, -0.06495342f, 0.00811801f, 0.05937770f, 
    -0.01205975f, -0.00101760f, -0.05008940f, 0.04910469f, 0.01380736f, 0.00790785f, -0.07469089f, 0.04202839f, 
    0.02975443f, -0.05397294f, 0.03652706f, -0.00554645f, 0.01663627f, 0.05569301f, -0.04385398f, 0.01965801f, 
    -0.03910742f, 0.00306896f, 0.02728265f, -0.05684488f, 0.04300632f, -0.04816212f, -0.03833292f, 0.02011635f, 
    0.00874624f, -0.02136564f, 0.02254216f, -0.06710742f, 0.01749301f, -0.00241371f, -0.00017947f, 0.02180567f, 
    0.04517024f, 0.03912780f, -0.03750604f, -0.05258845f, 0.05687211f, -0.02023818f, -0.05550759f, -0.06184749f, 
    -0.07590838f, -0.01320121f, 0.00697623f, 0.03685651f, -0.06592257f, -0.05253367f, -0.07376233f, 0.04158383f, 
    -0.01959120f, 0.05848577f, -0.01881312f, -0.06113233f, -0.00022320f, -0.01790393f, -0.05109303f, -0.07285845f, 
    -0.07673652f, 0.03994964f, 0.06397290f, 0.01434444f, 0.05188597f, -0.05442096f, 0.03788576f, -0.06960182f, 
    -0.07666710f, 0.02046005f, -0.01508456f, -0.07337502f, 0.04144915f, -0.05057231f, -0.02660036f, -0.00095652f, 
    0.02545538f, 0.05670663f, 0.03771742f, 0.03870682f, -0.06609378f, -0.01954517f, 0.02827145f, -0.04942213f, 
    0.05194218f, -0.01283834f, 0.01878944f, -0.01317332f, 0.06046752f, 0.05021827f, -0.04415102f, -0.01544042f, 
    -0.04208340f, -0.01334894f, 0.04344220f, 0.00453784f, 0.00169146f, -0.03508017f, 0.06265288f, -0.03167814f, 
    0.04372429f, 0.00549515f, 0.01933141f, 0.04588697f, -0.03675797f, -0.04240554f, 0.02668192f, -0.03370276f, 
    -0.00588922f, 0.02853627f, -0.05972673f, -0.02649984f, -0.01505061f, 0.04728445f, -0.07828737f, 0.01080711f, 
    0.05677480f, 0.01486105f, -0.03533649f, 0.05331950f, 0.03403259f, -0.06722466f, -0.05507929f, 0.04081318f, 
    0.03427891f, 0.01214638f, 0.06174905f, -0.04468875f, 0.00393535f, 0.06297818f, -0.07576628f, -0.01359202f, 
    -0.06609467f, 0.00132824f, 0.02081538f, 0.03529984f, 0.04336922f, -0.02311736f, -0.04591846f, -0.00141117f, 
    -0.07752158f, -0.05400220f, -0.04868170f, -0.05205643f, -0.01666552f, -0.06279717f, 0.03682511f, -0.03800417f, 
    -0.05169800f, 0.04676651f, 0.00820030f, -0.07255918f, -0.08094129f, -0.03214159f, -0.05670964f, -0.02907917f, 
    -0.04198297f, -0.03528751f, -0.03814712f, 0.06263869f, 0.05061259f, 0.02230424f, 0.03976629f, -0.05607009f, 
    -0.00870938f, 0.05364024f, -0.04518276f, -0.07037923f, 0.03037815f, 0.02440184f, -0.00292068f, 0.02195694f, 
    -0.04988888f, 0.01953490f, -0.05321718f, -0.04356512f, 0.04740169f, 0.01548922f, -0.02391609f, 0.02819980f, 
    0.04228475f, 0.00172532f, -0.04361177f, 0.03559386f, 0.02065297f, 0.03368807f, -0.00737478f, -0.02598296f, 
    -0.04574937f, -0.00946160f, -0.00052892f, -0.03139749f, 0.03264056f, 0.04836531f, -0.05246253f, -0.06988885f, 
    0.00433462f, 0.04025788f, -0.00785476f, 0.05716208f, -0.07043100f, 0.00842444f, 0.03133111f, -0.03353069f, 
    0.05893633f, 0.04808667f, -0.00094574f, -0.03728029f, 0.03029559f, -0.05225079f, 0.05858974f, -0.05979443f, 
    -0.04319723f, 0.06491976f, 0.03245730f, 0.04936978f, -0.06261898f, 0.05740958f, 0.00361316f, -0.03757073f, 
    -0.02477329f, 0.04362065f, -0.02263181f, -0.05675695f, -0.06969324f, 0.00040345f, 0.00711390f, -0.00922355f, 
    0.00441826f, 0.02371457f, 0.00748931f, -0.06294871f, -0.08464188f, -0.01633200f, -0.05843546f, 0.01281610f, 
    -0.07685895f, -0.05938631f, -0.02851403f, -0.04881155f, 0.01684703f, -0.00103331f, -0.01515745f, 0.04459639f, 
    0.02109734f, 0.02075551f, -0.01350981f, 0.04963398f, -0.04914744f, -0.00746228f, 0.00113575f, 0.02516811f, 
    -0.04650067f, 0.00465701f, 0.01236488f, 0.02218484f, 0.05532627f, 0.05802609f, -0.06872036f, -0.01677134f, 
    -0.05616631f, -0.05425847f, -0.07291593f, -0.02633375f, 0.02494093f, -0.07312262f, -0.00592554f, 0.00397533f, 
    0.03974474f, 0.04250254f, -0.01350837f, 0.02856986f, 0.02537419f, -0.01543284f, -0.04473975f, -0.04738252f, 
    -0.06020760f, -0.07120266f, 0.03472972f, -0.03321638f, -0.07122617f, -0.00856320f, -0.07537935f, -0.06893212f, 
    -0.06972927f, -0.06935839f, -0.01638265f, 0.01108880f, -0.00754170f, -0.00175506f, 0.03488481f, -0.05382594f, 
    0.01079930f, -0.08043361f, -0.03010786f, -0.06834680f, -0.01907047f, -0.07557631f, 0.03013122f, -0.04888474f, 
    -0.04280132f, -0.16684060f, 0.01433276f, 0.22204313f, 0.03459538f, 0.02867836f, -0.08160260f, -0.00276408f, 
    0.04316094f, -0.12225432f, 0.08000714f, -0.08944481f, 0.00799425f, -0.25345960f, 0.00448125f, 0.18277828f, 
    0.10246333f, 0.00995594f, -0.00399581f, 0.12348750f, -0.11807006f, 0.01475935f, -0.10327776f, 0.06682833f, 
    -0.02251316f, -0.23628469f, -0.29575002f, -0.15560351f, 0.30393952f, 0.24940814f, 0.21549070f, 0.13240327f, 
    0.16421860f, -0.15681146f, -0.10317723f, -0.10177081f, 0.12841560f, -0.23075074f, -0.03627905f, -0.06185820f, 
    0.01855836f, -0.06930029f, -0.04516242f, -0.08008497f, 0.07415871f, -0.10410294f, -0.00323879f, 0.07278463f, 
    -0.13576236f, -0.07538373f, 0.16542007f, -0.09506381f, -0.00507048f, -0.10250660f, -0.10429165f, 0.08303636f, 
    -0.00770491f, -0.04096849f, 0.03418986f, 0.01902955f, -0.03831194f, 0.01387045f, 0.31614384f, 0.30252388f, 
    0.01046216f, 0.05013363f, 0.00878625f, -0.00950034f, -0.03652022f, 0.11782604f, 0.06562235f, 0.16034202f, 
    0.12138050f, -0.18350752f, -0.32467550f, 0.09784216f, 0.13051733f, 0.00453779f, 0.10347918f, 0.33770743f, 
    -0.02313890f, 0.16696417f, -0.22227207f, -0.20651372f, 0.56826788f, 0.15777256f, -0.28971449f, -0.36032173f, 
    -0.06269272f, 0.03301717f, -0.15544139f, -0.00987911f, 0.18510282f, 0.00077391f, 0.03449346f, 0.02627604f, 
    -0.20021765f, -0.01564875f, 0.34716794f, -0.32911831f, 0.02927209f, 0.01348150f, -0.05517519f, 0.02556835f, 
    -0.03242819f, -0.18548517f, -0.00371039f, 0.14698893f, -0.22810270f, -0.02481406f, 0.12442315f, -0.19653492f, 
    0.18838584f, -0.20121473f, -0.16170467f, -0.12811606f, 0.14198071f, 0.00320692f, 0.02644390f, -0.38438681f, 
    -0.18749812f, -0.05387733f, 0.45814148f, 0.16614813f, 0.07454557f, -0.06699497f, -0.07592782f, 0.29141217f, 
    -0.06881221f, 0.18791661f, 0.11280370f, 0.20027994f, 0.26311564f, 0.59143943f, 0.20682134f, -0.08462958f, 
    0.04858484f, 0.10824385f, -0.06712817f, -0.33211550f, 0.14731432f, -0.06669118f, 0.13689311f, 0.06487260f, 
    -0.17836915f, -0.24476880f, 0.26624227f, -0.05805386f, -0.07431646f, 0.08714938f, 0.01966718f, -0.12515180f, 
    -0.06152957f, -0.02498994f, 0.13334766f, 0.09575563f, -0.60664523f, 0.47337306f, 0.30745173f, 0.25745621f, 
    0.04529542f, -0.03863813f, -0.01347919f, -0.00709366f, 0.15237127f, 0.00938959f, 0.14070782f, 0.29180527f, 
    0.19530012f, 0.11656892f, 0.10051419f, 0.11664635f, -0.02276021f, 0.12701127f, 0.03877155f, -0.10144963f, 
    0.16080511f, 0.20256311f, 0.34164235f, 0.32482129f, -0.09822905f, -0.21054289f, -0.13649894f, 0.13777627f, 
    0.04117001f, 0.11246530f, 0.06166441f, -0.00760960f, -0.02835418f, -0.10734957f, -0.19776912f, -0.11968954f, 
    -0.16206665f, -0.33039743f, -0.05540295f, 0.15321453f, 0.01083699f, -0.03751412f, -0.10947886f, -0.09373286f, 
    0.04582244f, -0.01643371f, 0.17817228f, 0.01183567f, -0.37151167f, -0.69736904f, 0.06731992f, 0.06163803f, 
    -0.09997808f, 0.00344704f, -0.00883866f, 0.02512598f, -0.03746026f, -0.02852958f, -0.02078210f, -0.02706273f, 
    -0.06915411f, -0.07437204f, -0.17109491f, -0.29169935f, 0.13982649f, 0.27407774f, -0.01841749f, 0.13111101f, 
    0.04315637f, 0.13912645f, -0.00161491f, 0.00534412f, 0.23181371f, -0.24216780f, -0.26800826f, 0.22593194f, 
    -0.08257177f, 0.04821529f, -0.04012810f, -0.02735174f, 0.09510352f, -0.12771621f, -0.21748382f, 0.23452233f, 
    0.42371249f, 0.49870244f, 0.27255785f, 0.02257105f, 0.15220812f, 0.16904357f, 0.21432351f, 0.12143176f, 
    -0.12238992f, 0.02552692f, 0.03930363f, 0.05372232f, 0.30497581f, 0.27387607f, 0.07765353f, -0.10882761f, 
    0.20394516f, -0.01677757f, 0.06773780f, 0.16130903f, -0.08230080f, 0.05289783f, -0.17564495f, 0.04353954f, 
    -0.07343831f, -0.06369568f, 0.30772582f, -0.06215243f, 0.11198618f, -0.02725713f, -0.05045895f, 0.04054938f, 
    0.13336256f, 0.08793445f, 0.08298684f, 0.26061577f, 0.23774774f, -0.24546349f, -0.29620972f, 0.39395308f, 
    -0.05098121f, 0.07883347f, -0.02449102f, 0.01937869f, 0.03742286f, -0.01366555f, 0.05497324f, 0.09711616f, 
    0.22758664f, 0.75279856f, 0.18067330f, 0.26004770f, 0.19053604f, 0.44723666f, 0.28260764f, 0.00166845f, 
    0.00889615f, -0.10097022f, -0.06328026f, 0.09912779f, 0.39998230f, -0.04650927f, -0.53298301f, 0.39631441f, 
    -0.01459047f, 0.18574952f, -0.02023104f, 0.15087949f, 0.06860635f, -0.01681322f, 0.03767256f, 0.06585535f, 
    -0.07057638f, -0.03404478f, -0.10412829f, 0.17655766f, 0.24991061f, 0.03682005f, 0.04632697f, -0.17425543f, 
    -0.17596330f, 0.08466929f, 0.01060389f, 0.27840260f, 0.16018082f, -0.08260320f, 0.20216516f, -0.04025383f, 
    -0.01298827f, -0.13418993f, 0.08268340f, 0.11282867f, -0.05532617f, -0.01540800f, -0.13143885f, -0.17867602f, 
    0.29667136f, 0.45270714f, 0.08010586f, -0.00251427f, 0.26294252f, 0.18724971f, 0.17744905f, 0.23543639f, 
    -0.04727901f, 0.01282490f, -0.21477276f, -0.08012776f, 0.27236956f, -0.23271704f, -0.56381565f, -0.39854398f, 
    0.23209085f, 0.05662102f, -0.09140009f, -0.02175504f, 0.02023513f, 0.07245210f, -0.01112238f, -0.15405257f, 
    0.14076295f, 0.02544924f, 0.27435005f, 0.16907385f, -0.05330306f, -0.07197910f, -0.06828219f, 0.15586659f, 
    -0.10136943f, -0.14137879f, -0.10296976f, -0.10665455f, 0.00320470f, -0.08559015f, -0.27184388f, 0.07364026f, 
    -0.19698679f, 0.10704463f, 0.02900008f, 0.00976915f, 0.11210604f, -0.10856529f, -0.02862743f, -0.05307218f, 
    0.17263538f, 0.15599740f, -0.05140300f, -0.19223511f, 0.06471395f, 0.13169588f, 0.01259991f, -0.00438610f, 
    0.22427867f, 0.05730565f, -0.05796302f, -0.15352997f, -0.10029394f, -0.11596093f, 0.33761728f, -0.27933440f, 
    0.08712111f, 0.06975896f, 0.06684189f, 0.04803012f, 0.05380926f, -0.04615745f, -0.14474028f, 0.03950305f, 
    0.22492549f, 0.13326365f, 0.19133146f, -0.08762950f, -0.01767322f, 0.25674590f, 0.17359675f, 0.20307934f, 
    -0.05392550f, 0.00894570f, -0.03770771f, -0.17552702f, -0.40493688f, -0.18196432f, 0.14803320f, 0.19841190f, 
    0.10154051f, 0.05500288f, 0.04328489f, -0.10621119f, -0.01872308f, -0.05028088f, 0.08148094f, -0.06137272f, 
    -0.09615295f, -0.25086758f, 0.04941042f, 0.25983846f, -0.09862089f, -0.06907777f, -0.11331194f, 0.07606146f, 
    0.02548045f, -0.00642340f, -0.03199876f, -0.16978621f, -0.28359595f, -0.44237107f, 0.16368750f, 0.07855216f, 
    0.01516744f, 0.13306287f, -0.14919946f, 0.03169004f, -0.01401996f, -0.03179535f, -0.00255852f, -0.01943287f, 
    -0.09601277f, -0.07706789f, 0.24589661f, -0.01498433f, -0.18709961f, 0.09924235f, 0.10370731f, 0.21265429f, 
    0.13688737f, -0.08320867f, -0.00247611f, -0.17356455f, -0.02883956f, 0.13018195f, 0.24310625f, -0.22413059f, 
    -0.02582900f, -0.17223532f, 0.05497139f, 0.01605198f, 0.04507391f, 0.10763301f, -0.11997253f, 0.02316266f, 
    -0.13180758f, -0.08186737f, -0.25936481f, 0.54061335f, -0.02379906f, -0.16216820f, -0.10423345f, -0.15844014f, 
    -0.05184055f, 0.16632333f, 0.16362663f, 0.12689044f, 0.00696780f, -0.03800810f, 0.25059706f, 0.34796011f, 
    -0.02120373f, -0.10411884f, -0.05992875f, 0.36716792f, -0.36766139f, -0.15837644f, 0.16591015f, 0.00842191f, 
    0.01693735f, -0.09103331f, -0.04658505f, 0.26129344f, 0.01196533f, 0.00418370f, -0.20363273f, -0.16472588f, 
    0.02204871f, 0.15280469f, 0.09850492f, 0.02396118f, -0.17652000f, 0.02107737f, 0.46301121f, 0.27064398f, 
    -0.06281915f, -0.14981183f, -0.07472005f, 0.08727477f, -0.02155246f, 0.07082874f, -0.11467235f, 0.05075176f, 
    -0.17036515f, -0.01220167f, -0.05145295f, 0.07749555f, -0.08566275f, -0.15201974f, 0.04069008f, 0.16407457f, 
    0.11403867f, 0.09978706f, 0.00945633f, 0.12078183f, 0.22356418f, 0.43827796f, 0.17568348f, 0.14918973f, 
    -0.23860636f, -0.48497820f, 0.04261741f, 0.12653093f, 0.00761810f, 0.12532184f, -0.03036572f, 0.14556859f, 
    -0.05531118f, 0.06570499f, 0.27752578f, 0.16191918f, 0.11157297f, -0.07391576f, 0.15149288f, 0.09648200f, 
    0.02610940f, 0.09776500f, 0.37919176f, 0.38233382f, 0.14327160f, -0.01881142f, 0.60669798f, 0.05466434f, 
    0.11841343f, 0.18568192f, 0.03783680f, 0.06691682f, -0.08495960f, 0.00650991f, -0.05124856f, -0.08587269f, 
    0.01140926f, -0.00196443f, -0.03696861f, -0.02285236f, -0.04209704f, -0.01518716f, 0.04719385f, 0.00793814f, 
    -0.03523304f, 0.03614774f, -0.02524885f, -0.06354513f, 0.03660686f, -0.02287444f, -0.03525430f, 0.05024436f, 
    0.01880216f, -0.06199294f, -0.05743957f, -0.02642839f, -0.03668407f, -0.02130739f, 0.00368813f, 0.05752051f, 
    -0.03168470f, 0.02445619f, -0.00498258f, -0.04724878f, 0.02050929f, 0.00719704f, -0.05269730f, -0.05489673f, 
    -0.03106032f, -0.00669411f, -0.03403680f, -0.04642014f, -0.01443365f, 0.05263721f, -0.02578079f, 0.00529950f, 
    -0.03101500f, 0.06163206f, 0.04508654f, -0.03958608f, 0.02908307f, -0.07451101f, 0.06430492f, -0.00510222f, 
    0.03382036f, -0.06529786f, -0.05244854f, 0.01752299f, 0.05728365f, -0.06636772f, -0.00618250f, 0.04354673f, 
    -0.04720226f, 0.06448933f, 0.04148536f, 0.05743737f, -0.05927543f, -0.05145145f, -0.03670966f, 0.02065383f, 
    -0.03871774f, -0.04325875f, -0.04426349f, -0.01533395f, -0.01683842f, -0.05611019f, -0.03237039f, 0.04804118f, 
    -0.01051294f, 0.04600316f, 0.01496774f, 0.04352752f, 0.03775896f, 0.03161779f, 0.05445218f, 0.06191248f, 
    -0.03304020f, -0.00388477f, 0.03407766f, 0.01927987f, 0.03878692f, -0.00417563f, -0.01938278f, -0.06587051f, 
    -0.05979288f, -0.05855212f, -0.07121923f, -0.06353431f, 0.06525126f, 0.02339732f, 0.05342828f, -0.04195636f, 
    -0.05846002f, -0.02380684f, 0.00341141f, 0.05117195f, 0.05553987f, -0.02739758f, 0.00814346f, -0.06888469f, 
    -0.00350533f, 0.00954439f, -0.04614465f, 0.02098424f, -0.03909374f, -0.05580720f, 0.05498272f, -0.01048383f, 
    0.02426505f, 0.02397127f, 0.01255868f, -0.04114942f, 0.01329874f, -0.02477314f, -0.04877723f, 0.00493036f, 
    -0.07715739f, -0.05116376f, 0.01135634f, 0.05338465f, -0.03009096f, 0.05798348f, 0.02108350f, -0.00185304f, 
    0.04550589f, -0.01236456f, 0.01262551f, -0.07590762f, -0.01013812f, -0.05132094f, 0.06014137f, -0.04069320f, 
    -0.06814279f, 0.03658937f, -0.06380119f, 0.04598868f, 0.01930478f, 0.03625672f, -0.03401361f, 0.03593512f, 
    0.00441106f, 0.01696255f, -0.01593045f, -0.07477044f, 0.02203039f, -0.07646126f, 0.04508948f, 0.04325423f, 
    0.03311253f, 0.02311137f, 0.07040755f, -0.06164752f, -0.01475463f, 0.03357901f, -0.05714355f, 0.00428217f, 
    -0.06850607f, -0.04219583f, -0.03369027f, -0.00372862f, -0.02974130f, -0.05974479f, 0.04707777f, 0.01794594f, 
    0.01754940f, 0.04700945f, 0.03082374f, -0.06087306f, -0.02719577f, -0.06917880f, 0.00030888f, -0.07052916f, 
    -0.07182078f, 0.02062641f, -0.03648799f, -0.03322379f, 0.03599841f, -0.05473484f, 0.01034517f, -0.01062642f, 
    -0.02165403f, -0.02028728f, -0.07113150f, -0.05906288f, 0.06363531f, -0.00347757f, -0.06168092f, 0.05083133f, 
    -0.18510258f, 0.16959795f, -0.04629225f, 0.01704892f, -0.04838113f, -0.03518868f, -0.04831119f, -0.15372853f, 
    -0.07458383f, 0.07658738f, -0.02946936f, -0.07112776f, -0.06065208f, -0.08846141f, 0.13359463f, 0.08598688f, 
    -0.03432821f, 0.09846913f, -0.04550057f, -0.02654763f, -0.13917673f, 0.02956450f, 0.00232010f, -0.11132687f, 
    -0.36864799f, -0.01778186f, 0.03409845f, 0.01084373f, 0.27465817f, 0.01419094f, 0.08454053f, 0.12746868f, 
    0.07490768f, 0.11466677f, -0.03968974f, 0.01751540f, 0.05857960f, 0.19366127f, 0.15386377f, -0.12467285f, 
    -0.00719136f, -0.01544926f, -0.06309058f, -0.08068112f, 0.00653518f, 0.14361951f, 0.14566626f, 0.31744477f, 
    -0.24289379f, -0.12334878f, -0.12409330f, -0.37979367f, -0.15615103f, -0.06671605f, -0.07978725f, -0.11094301f, 
    0.03534890f, -0.08615990f, -0.05069286f, 0.00141754f, -0.18689992f, -0.14516486f, 0.03999470f, -0.15698621f, 
    0.23195919f, 0.02300902f, 0.25040841f, -0.01478614f, -0.05450104f, 0.08435231f, 0.17414872f, -0.02990868f, 
    0.00659144f, 0.04365667f, -0.18529074f, -0.00091266f, 0.16302067f, 0.04104684f, 0.02357111f, 0.22038232f, 
    -0.22552653f, 0.04328285f, 0.00854005f, 0.15417539f, 0.04839350f, 0.28931096f, -0.22726528f, 0.11000941f, 
    0.08093868f, -0.02619354f, 0.17361914f, 0.13315430f, -0.07518920f, -0.07990377f, -0.03583618f, 0.07129462f, 
    -0.12283910f, -0.28923550f, 0.02583588f, -0.40789291f, -0.17385788f, -0.03485559f, 0.01296381f, 0.19365430f, 
    0.05318194f, 0.16236448f, -0.10770764f, -0.07821427f, 0.01890844f, 0.14913760f, -0.04068870f, -0.48560500f, 
    0.25116980f, 0.08026268f, 0.00025355f, 0.04740509f, 0.03927063f, 0.15496248f, 0.13349146f, 0.02706647f, 
    0.14124393f, -0.23949538f, 0.47422427f, 0.19149685f, -0.06442332f, -0.03381352f, 0.01180357f, -0.01330345f, 
    0.20188153f, 0.12954935f, 0.27933368f, 0.05287840f, 0.12914169f, 0.24338269f, 0.26571894f, -0.31374195f, 
    -0.10415839f, -0.17594305f, -0.09568564f, 0.13943590f, -0.04639928f, 0.10552818f, 0.03549434f, -0.00964119f, 
    -0.09150933f, -0.03768170f, -0.07637488f, -0.23349346f, 0.14399411f, 0.09365936f, -0.01900068f, 0.05381238f, 
    0.04130280f, -0.01226765f, -0.04531278f, 0.03930861f, 0.00407843f, -0.14560634f, -0.05526783f, -0.03420920f, 
    -0.14936601f, 0.06422754f, -0.25052390f, 0.15136763f, 0.31227002f, 0.11096042f, 0.08901118f, 0.08327506f, 
    0.02896578f, 0.16767244f, -0.21234645f, -0.14208192f, 0.06572875f, 0.00579051f, 0.18532138f, 0.10028662f, 
    0.16520959f, 0.13003819f, 0.27105537f, 0.01766739f, -0.27967486f, -0.42544916f, -0.04086338f, -0.04851320f, 
    0.22852278f, 0.00345379f, 0.03527096f, -0.04293428f, -0.04542615f, -0.00653887f, 0.00501761f, 0.06072835f, 
    0.03585828f, 0.30429700f, -0.05281413f, 0.03514487f, 0.00067960f, -0.03456701f, -0.08489741f, -0.09479634f, 
    0.01480823f, -0.00374470f, 0.05074817f, 0.14204550f, 0.18052450f, -0.62601197f, 0.13014799f, -0.31542912f, 
    0.01786103f, 0.01231859f, -0.10530698f, -0.06095191f, -0.13489650f, -0.04958153f, 0.10779318f, -0.07952939f, 
    -0.13333850f, -0.13050088f, -0.08029211f, -0.22148971f, 0.42877239f, 0.11173345f, 0.09317626f, 0.15670760f, 
    0.11232283f, -0.03392441f, 0.04517844f, 0.12157421f, 0.36911801f, 0.12127462f, 0.08037430f, 0.03151564f, 
    -0.08736286f, -0.00583173f, -0.07219531f, 0.02484235f, 0.20761727f, 0.05633221f, 0.09574215f, -0.03866433f, 
    -0.37576428f, -0.01059823f, 0.22170642f, -0.04505997f, 0.14420728f, 0.12088663f, 0.06905152f, -0.01678141f, 
    0.04510061f, -0.00561598f, 0.02026748f, -0.00211160f, -0.19242164f, -0.16739221f, 0.41628063f, -0.09861664f, 
    -0.05388593f, 0.03311994f, -0.03166238f, 0.07216852f, 0.09827576f, 0.11228857f, 0.00377363f, 0.04211345f, 
    -0.02424709f, 0.10455285f, -0.31308168f, 0.08482300f, 0.23012021f, 0.17938985f, 0.20563506f, 0.16957906f, 
    -0.05046966f, 0.11047997f, 0.15408587f, 0.10743375f, 0.44058505f, 0.77947044f, -0.53469867f, 0.16991982f, 
    0.03560846f, 0.15766975f, 0.24541718f, 0.05290471f, -0.10018336f, -0.10693426f, 0.19188266f, 0.08828540f, 
    -0.31486484f, -0.30986494f, 0.29915592f, -0.07192471f, -0.05425743f, -0.03248852f, 0.08776560f, 0.22601679f, 
    0.15179788f, 0.12629275f, 0.07363282f, -0.02171568f, 0.16304848f, -0.16538756f, 0.35334462f, -0.37840712f, 
    0.03526779f, 0.01085795f, 0.05447592f, -0.01485977f, 0.17587805f, 0.00224332f, 0.07223289f, -0.03966460f, 
    0.35267356f, -0.52036715f, 0.53532666f, 0.05194235f, -0.15882117f, -0.12218644f, -0.04163762f, 0.20052540f, 
    0.14017445f, 0.14143275f, 0.05601300f, -0.02833454f, 0.12402650f, 0.12047168f, 0.45063436f, -0.43795520f, 
    0.00423305f, 0.01375827f, 0.13622975f, 0.07315266f, 0.08271509f, 0.11089686f, 0.05810020f, 0.01439649f, 
    -0.35756737f, 0.05231989f, -0.00708615f, -0.04796558f, 0.04146848f, -0.01865128f, -0.01407361f, -0.03465831f, 
    0.16415851f, 0.01639350f, -0.12955870f, 0.03120056f, -0.12462329f, 0.27141380f, -0.03535172f, -0.09717123f, 
    -0.22263743f, -0.11637448f, -0.20159246f, 0.14140685f, 0.13980994f, -0.05312139f, 0.03120747f, -0.10260560f, 
    0.19028777f, 0.12473826f, -0.12245688f, 0.01876926f, 0.03294938f, 0.02924207f, 0.21015395f, 0.04599747f, 
    0.29077622f, -0.02877008f, 0.06574500f, -0.21074934f, -0.03996948f, -0.46173242f, 0.11733355f, -0.25577655f, 
    -0.01573476f, -0.03180004f, 0.08163036f, -0.06822570f, 0.07590208f, -0.07219511f, -0.05497056f, 0.04030162f, 
    -0.33292994f, 0.16233914f, -0.05801408f, 0.05840626f, -0.00039754f, 0.12090490f, -0.09009515f, -0.06315713f, 
    -0.08893613f, -0.00779286f, 0.11452954f, 0.12241676f, -0.14056620f, -0.12017258f, -0.06334721f, -0.07686005f, 
    -0.07424182f, 0.05742142f, 0.02470334f, -0.07767105f, -0.03541050f, 0.20378393f, -0.00081474f, -0.12835638f, 
    -0.12067074f, -0.00854489f, -0.04548551f, -0.03976383f, 0.20087969f, 0.29454356f, -0.08559996f, 0.21299750f, 
    0.09927909f, -0.04882751f, -0.01868951f, 0.03306168f, -0.03301951f, 0.05475015f, -0.19714236f, 0.13640045f, 
    -0.06911087f, -0.03920157f, -0.19724298f, -0.08270188f, 0.15259813f, 0.01814298f, 0.08869987f, 0.17925906f, 
    -0.05119611f, -0.11435081f, 0.13441819f, -0.37894562f, -0.05715997f, -0.20347080f, 0.01484553f, -0.00126597f, 
    0.05674041f, 0.00401839f, -0.02838498f, -0.05659055f, 0.12597995f, 0.16114581f, 0.02389620f, -0.11381936f, 
    0.07378294f, 0.01642322f, 0.13550577f, 0.05090902f, -0.00288765f, 0.16757911f, 0.07177951f, 0.15085816f, 
    0.25543815f, 0.00268708f, -0.19245824f, 0.06733491f, 0.50697708f, 0.08049494f, 0.04561271f, 0.10487886f, 
    -0.02503169f, 0.20936400f, 0.01046179f, 0.11988953f, 0.05245351f, 0.38272217f, -0.15950195f, 0.04503849f, 
    0.05403553f, 0.15136291f, 0.09988379f, 0.20761879f, -0.04839369f, 0.33356884f, 0.15989359f, 0.07282281f, 
    -0.23193100f, -0.19367491f, 0.26201651f, -0.31997782f, -0.22798957f, -0.06533506f, -0.07800883f, -0.06833743f, 
    0.10246561f, 0.13679108f, -0.00561863f, 0.09039413f, -0.57405114f, -0.17772388f, 0.01795903f, -0.10057352f, 
    0.01575979f, -0.00967789f, -0.12630528f, -0.09673139f, 0.01912889f, -0.00718695f, -0.10261733f, 0.04143718f, 
    0.24610220f, -0.41126147f, 0.53820884f, 0.01933239f, 0.22642469f, -0.01537452f, 0.01358163f, 0.02459198f, 
    0.12859102f, 0.07935542f, 0.26294455f, 0.08782407f, 0.03102053f, 0.00715710f, 0.42538801f, -0.06986261f, 
    0.05523025f, -0.04404220f, 0.12027375f, -0.01129259f, -0.24293607f, 0.05497749f, 0.14042687f, -0.11896363f, 
    0.17483559f, -0.18925679f, -0.12499522f, -0.12802048f, 0.12480273f, -0.09096370f, -0.12815952f, 0.00880626f, 
    0.14537093f, -0.02574027f, -0.09721462f, -0.01013174f, -0.28511363f, -0.46806121f, -0.09840189f, -0.16666424f, 
    0.06266758f, -0.04169655f, -0.10857596f, 0.06809814f, 0.10869528f, -0.12406309f, 0.09158680f, 0.11269571f, 
    -0.11209408f, 0.03528599f, -0.06890388f, -0.00310442f, 0.05714468f, 0.07967813f, 0.09766673f, -0.07714354f, 
    0.14315292f, 0.13442293f, 0.38638341f, -0.19036356f, -0.09178216f, -0.14432861f, 0.36548027f, 0.00057739f, 
    0.18661086f, 0.07490686f, 0.04484187f, -0.07740997f, -0.06170404f, 0.03158192f, -0.06793459f, -0.06719657f, 
    -0.12950894f, 0.03950824f, 0.11180442f, 0.10776144f, 0.12701863f, -0.07033724f, -0.00065883f, 0.04487704f, 
    0.01773552f, 0.05610519f, -0.12400461f, -0.00867481f, 0.15804388f, 0.63081414f, 0.01628940f, 0.20283286f, 
    -0.10575331f, -0.11628465f, 0.08301430f, -0.32123744f, 0.08984916f, -0.08904124f, 0.01465379f, 0.12386485f, 
    0.01435839f, 0.26673895f, 0.26506385f, 0.15140876f, -0.11201468f, -0.51941484f, 0.20681658f, -0.11952052f, 
    0.06821334f, 0.00936158f, 0.07825354f, -0.00742566f, -0.33506334f, 0.40697461f, 0.26218629f, -0.02503643f, 
    0.03442929f, 0.02941011f, 0.11818245f, 0.15571815f, -0.18692760f, -0.19070628f, 0.05493515f, -0.32054815f, 
    0.09642587f, -0.10849267f, -0.08034980f, 0.41786718f, -0.09863476f, 0.06130607f, -0.01186115f, 0.09424689f, 
    0.00778573f, 0.03398264f, 0.00486242f, -0.17357554f, -0.20679531f, 0.27056637f, -0.14310226f, 0.01192326f, 
    -0.00339699f, -0.02471270f, -0.04170421f, 0.14552785f, 0.05990805f, -0.21469115f, 0.19273649f, -0.03549583f, 
    -0.19032812f, 0.15665993f, -0.55643457f, -0.31506807f, 0.07693337f, -0.00101239f, 0.11058294f, -0.36977395f, 
    0.13951552f, -0.03104485f, 0.17324530f, -0.26194876f, -0.44945255f, 0.21913551f, -0.09738149f, 0.16127087f, 
    -0.08322098f, -0.17996423f, -0.21711808f, 0.04970212f, 0.20353718f, -0.03126981f, 0.11398786f, -0.01254861f, 
    0.22694509f, -0.36703846f, -0.17699365f, 0.08195961f, 0.17772964f, 0.14753890f, 0.12454571f, 0.04900078f, 
    0.03305495f, 0.09326856f, -0.02006503f, -0.01609832f, 0.11974443f, 0.31740901f, 0.44340646f, 0.23783860f, 
    0.00811007f, 0.19666544f, 0.23889284f, -0.13836767f, -0.03333832f, 0.16537583f, 0.09346066f, 0.17656639f, 
    0.45171386f, 0.18580700f, -0.14602806f, -0.42346039f, 0.18545453f, 0.15068467f, 0.12815167f, -0.28816125f, 
    -0.01162808f, -0.08975118f, 0.04666829f, 0.04545366f, -0.49812561f, -0.26174346f, 0.03840266f, 0.24328633f, 
    -0.04657376f, -0.07552573f, 0.09596915f, -0.03092636f, 0.07742937f, -0.00296413f, 0.32445997f, 0.08972834f, 
    0.03270790f, -0.03662317f, -0.09303824f, 0.38634336f, 0.00093514f, 0.05484465f, 0.00890713f, 0.21273172f, 
    -0.11883142f, -0.05972302f, 0.20806815f, -0.04658388f, 0.46716848f, -0.21807294f, 0.15881765f, 0.09840836f, 
    0.04342601f, 0.19578457f, 0.07037197f, -0.00698857f, 0.06078804f, 0.01922826f, 0.15287048f, -0.00440929f, 
    -0.12266035f, -0.03881137f, 0.06189078f, 0.13030174f, -0.07937448f, -0.02336106f, -0.06857063f, 0.02199954f, 
    0.03802177f, 0.03866419f, -0.29055154f, 0.04302045f, -0.21647234f, 0.23242716f, 0.08244062f, 0.14893176f, 
    -0.04695177f, -0.32549599f, 0.10741293f, -0.04625766f, 0.02025585f, 0.00664398f, 0.04930725f, -0.20151076f, 
    0.06931164f, 0.05423970f, 0.05353152f, 0.01012063f, -0.22182654f, -0.16977729f, -0.12914929f, -0.20105502f, 
    -0.06994494f, -0.11712578f, -0.02107045f, 0.01699256f, -0.01600275f, 0.24878053f, -0.24409626f, -0.06027270f, 
    -0.27470994f, -0.10711811f, -0.15988553f, -0.07986402f, -0.10733870f, -0.26817280f, 0.09064571f, -0.19238162f, 
    0.00292474f, 0.01999373f, 0.29473540f, 0.10459630f, -0.07900921f, 0.06212304f, 0.04008045f, 0.21953332f, 
    0.01375709f, 0.19112504f, 0.06793928f, 0.22505842f, 0.34810248f, 0.59557503f, -0.06100052f, 0.07110173f, 
    -0.20630343f, -0.10405895f, -0.02242737f, 0.01967394f, 0.10938555f, 0.02568213f, -0.08690922f, 0.09457853f, 
    -0.10945097f, 0.06494489f, 0.19269104f, -0.00423632f, 0.11467969f, 0.07885565f, 0.25719312f, -0.05847959f, 
    0.10385460f, -0.00801800f, 0.00688842f, 0.18730418f, -0.01117722f, 0.38185662f, -0.15792163f, -0.12039284f, 
    0.03567217f, -0.13285051f, 0.14754434f, 0.25704375f, -0.08257087f, 0.07530350f, -0.05100143f, -0.02693331f, 
    0.10708705f, 0.07959160f, 0.07643503f, 0.02352848f, 0.33806437f, 0.06365768f, 0.09290540f, -0.26479125f, 
    0.06508383f, 0.15465364f, 0.45112655f, 0.30111593f, 0.13260446f, 0.31409112f, 0.13065770f, 0.29516473f, 
    0.05485566f, 0.09143483f, 0.10119668f, 0.04454341f, -0.02796772f, -0.13702385f, 0.01110282f, -0.07671665f, 
    -0.33144483f, -0.29087198f, 0.07304424f, 0.04839873f, 0.12410880f, 0.09349800f, 0.29541799f, 0.19227180f, 
    0.05533819f, -0.08591080f, -0.17123950f, 0.03634184f, 0.03836665f, 0.12040828f, -0.01399087f, -0.19883755f, 
    -0.05083268f, 0.34636602f, 0.13257281f, 0.23374268f, 0.26773196f, 0.16635469f, -0.10308303f, 0.26026720f, 
    -0.03371168f, -0.17740683f, -0.12476778f, -0.06449148f, -0.06734806f, -0.09597594f, 0.11686482f, -0.18655680f, 
    -0.02467963f, 0.00394520f, -0.01708934f, 0.15858564f, -0.31082317f, -0.40858558f, -0.06216548f, -0.12015976f, 
    0.09722260f, 0.02553444f, 0.02826340f, 0.16562814f, -0.16071522f, 0.05810419f, 0.15447985f, 0.03875053f, 
    0.05998027f, 0.32786021f, -0.05150999f, 0.14880244f, 0.10050643f, -0.09586085f, 0.07106511f, 0.11983836f, 
    -0.09116618f, -0.09177878f, -0.13037758f, -0.30965695f, 0.14029635f, -0.20141611f, -0.03083585f, -0.20650636f, 
    0.03753075f, -0.02630625f, -0.00086390f, 0.05267172f, -0.05125178f, 0.14968972f, 0.01165731f, -0.29020831f, 
    -0.01803792f, 0.09538908f, 0.02684360f, 0.23014523f, 0.17497756f, 0.10552374f, -0.06168847f, 0.17052378f, 
    -0.14082794f, -0.25910640f, -0.32656416f, -0.50770587f, 0.07544184f, 0.35943323f, -0.02865774f, -0.22055955f, 
    -0.35504097f, -0.13713454f, -0.02469482f, -0.10763144f, 0.01008797f, -0.01062981f, 0.12888837f, 0.12930846f, 
    -0.56963068f, -0.67220318f, -0.41090471f, -0.13404381f, 0.14973699f, 0.01809009f, 0.03951783f, 0.14191604f, 
    0.14730169f, 0.16513820f, 0.11587749f, 0.16867906f, 0.10726803f, -0.77973014f, -0.22410652f, -0.31698164f, 
    0.09504583f, -0.15949434f, 0.00752429f, -0.04445031f, -0.08129159f, -0.00365259f, 0.11305680f, 0.16405296f, 
    0.02255035f, -0.10141537f, -0.68037742f, -0.24670291f, 0.06955224f, -0.13663606f, -0.01271575f, -0.02943701f, 
    0.03613397f, -0.01596275f, -0.00162738f, -0.00911286f, -0.20791228f, -0.22858009f, -0.22539042f, -0.02119852f, 
    0.09649806f, -0.11570825f, 0.04081338f, 0.01603920f, -0.19287619f, -0.13334870f, -0.04517245f, -0.23343368f, 
    0.24240611f, 0.54225665f, 0.31857064f, 0.36692336f, 0.00088635f, 0.23877028f, 0.02103258f, 0.11809810f, 
    0.03212226f, 0.00863944f, -0.07582723f, -0.05894410f, 0.35294318f, -0.02090667f, 0.48328450f, 0.19029546f, 
    -0.02450448f, 0.09650091f, 0.13130063f, -0.00894931f, 0.05511808f, -0.11879736f, -0.09458965f, 0.07977952f, 
    -0.29739055f, -0.10388524f, -0.27893132f, -0.09648467f, -0.14775543f, 0.04150169f, 0.08064194f, -0.02230984f, 
    0.06259866f, -0.08183952f, -0.21163329f, -0.06889556f, -0.24435623f, -0.36220115f, -0.45093629f, -0.32689780f, 
    0.08414368f, 0.09420105f, -0.25617993f, -0.22584306f, 0.07502002f, 0.02329136f, 0.00130555f, -0.00062054f, 
    0.47392967f, 0.37277731f, 0.53987545f, 0.25547028f, 0.07023246f, -0.05901423f, 0.01158819f, 0.25279692f, 
    0.01515057f, 0.12064046f, -0.05442103f, -0.11858723f, 0.73516226f, 0.05310285f, 0.25054479f, -0.02813664f, 
    0.04201213f, 0.22502598f, 0.25503677f, 0.05788392f, -0.14743420f, -0.23438287f, 0.01051200f, -0.01438962f, 
    0.20449568f, 0.04424159f, -0.33349895f, -0.18419239f, -0.09123390f, 0.13583830f, 0.29838842f, 0.06069743f, 
    0.34390709f, 0.04213493f, -0.06532355f, -0.07725484f, 0.39683786f, -0.09499026f, 0.18636419f, 0.13712005f, 
    0.00424249f, -0.07249124f, 0.02508613f, 0.07380445f, 0.03624002f, -0.02516715f, -0.03308256f, 0.13304636f, 
    -0.10809649f, 0.14806646f, 0.24862419f, 0.31407005f, 0.08503744f, 0.25971490f, 0.10649380f, 0.13136062f, 
    -0.00683733f, 0.00120238f, 0.00764206f, 0.08766746f, 0.21829782f, 0.41404220f, 0.14542383f, 0.12604128f, 
    0.13525175f, 0.25369388f, 0.06894726f, -0.10523917f, 0.02125969f, -0.03821673f, 0.04663422f, 0.13673073f, 
    0.21170500f, -0.09236825f, 0.13619156f, 0.05893734f, -0.03585491f, -0.00325038f, -0.19017856f, 0.00403261f, 
    0.16534300f, -0.00218884f, 0.09120890f, 0.18888046f, -0.48540261f, -0.44528607f, -0.27868646f, 0.01891611f, 
    0.02803251f, -0.22150946f, 0.03532138f, 0.04424946f, -0.05725998f, -0.06618257f, 0.00209186f, 0.07639057f, 
    0.06574585f, -0.17934500f, -0.35400626f, 0.00854819f, -0.07993536f, -0.28399554f, -0.09854773f, 0.11298063f, 
    0.11227611f, -0.23236194f, -0.02753519f, -0.01792656f, 0.00774355f, 0.37430343f, -0.10239235f, 0.24851705f, 
    0.03329213f, -0.10908370f, 0.20667942f, -0.24353836f, -0.04888318f, 0.12170396f, 0.05770109f, 0.13207641f, 
    -0.68177319f, 0.06288016f, 0.39396340f, 0.25392416f, 0.17631085f, -0.22220442f, 0.15683217f, -0.11943197f, 
    -0.05003820f, -0.00590615f, 0.17558981f, -0.01927678f, 0.27159020f, -0.02941170f, -0.02684245f, -0.18649760f, 
    -0.20634104f, -0.09654870f, -0.22074798f, -0.29750305f, -0.04918703f, -0.28931788f, -0.02136004f, 0.02132054f, 
    0.05327956f, -0.15932705f, -0.00861599f, -0.11851332f, 0.38730901f, -0.01303664f, 0.10280851f, 0.06398447f, 
    -0.12490722f, -0.22573669f, -0.07145272f, 0.05967984f, 0.01456475f, 0.35159075f, 0.19436575f, 0.17653503f, 
    0.06817453f, 0.19600251f, 0.15456869f, 0.23026811f, 0.02689328f, 0.05392163f, -0.06726147f, 0.14187402f, 
    0.00331567f, 0.07026979f, -0.40540081f, 0.22511241f, 0.16779871f, -0.04863891f, 0.01730423f, 0.00627371f, 
    -0.37453896f, 0.07268915f, -0.14222805f, -0.30921021f, -0.19254865f, -0.00358099f, -0.16054668f, 0.27489269f, 
    0.00448369f, 0.22260433f, 0.06291653f, -0.04910011f, 0.15141949f, 0.00478076f, 0.31338441f, -0.28196955f, 
    0.03576226f, 0.05816661f, 0.21882571f, -0.19643314f, 0.09233234f, 0.21238679f, -0.27288029f, 0.01245637f, 
    0.15495251f, -0.07149322f, 0.00212619f, 0.27822894f, -0.63659644f, 0.29262495f, -0.04747733f, 0.25539979f, 
    -0.11074664f, -0.00264915f, -0.25110182f, -0.23075420f, 0.07081518f, -0.30772296f, -0.33103916f, -0.14733680f, 
    -0.09756390f, 0.16607127f, 0.43298584f, -0.31969592f, -0.10921954f, 0.14314981f, -0.23308459f, -0.15362968f, 
    0.19070518f, -0.06119389f, 0.03221014f, 0.01201992f, -0.21370807f, 0.46122533f, -0.28819996f, 0.23435515f, 
    -0.06608529f, -0.01497437f, 0.16159016f, -0.12440693f, -0.08905645f, -0.00495932f, 0.02602829f, 0.11665262f, 
    0.13746329f, -0.10595389f, 0.15083562f, -0.04155183f, 0.10126790f, 0.01349365f, -0.05242893f, 0.02176163f, 
    -0.14553587f, -0.03324634f, 0.08076131f, 0.04822409f, -0.05305843f, -0.22229579f, 0.25981382f, 0.34395924f, 
    -0.02742748f, 0.00763539f, -0.06805632f, 0.21906932f, 0.20072825f, 0.13148540f, 0.02614793f, 0.27638453f, 
    -0.02439792f, 0.00098250f, -0.00023177f, 0.26578856f, -0.03414450f, -0.07532062f, 0.03829115f, -0.22063853f, 
    0.27859452f, -0.07880871f, 0.28312236f, 0.10497421f, -0.38808337f, 0.37285611f, 0.30840978f, 0.01164867f, 
    0.33157578f, -0.05399081f, -0.19628967f, 0.28718656f, -0.22370516f, -0.14297661f, -0.13576229f, -0.34303483f, 
    0.01615444f, -0.10029455f, -0.03893217f, -0.08315335f, 0.01255053f, -0.02182934f, -0.03988942f, 0.04071159f, 
    -0.00000849f, -0.02850181f, -0.08090825f, 0.01008029f, -0.07561176f, -0.04870821f, 0.02810790f, 0.03056083f, 
    0.03947854f, 0.04743181f, -0.08417236f, 0.03917118f, -0.06557939f, -0.03598443f, 0.02665674f, -0.08648071f, 
    -0.01034994f, -0.10384092f, -0.09813400f, -0.01554849f, -0.06931304f, 0.03930360f, -0.01061440f, -0.06513683f, 
    0.02533960f, -0.04150730f, -0.03775975f, 0.00777490f, -0.00152184f, -0.00272598f, -0.03819454f, -0.01536498f, 
    0.01257873f, -0.01710353f, -0.01886889f, 0.01917981f, -0.08108724f, -0.02821224f, -0.04902599f, 0.00417658f, 
    0.00821111f, 0.03746054f, -0.02259048f, -0.07961560f, 0.08709712f, 0.00501047f, -0.04350272f, 0.03951301f, 
    0.03052515f, 0.02512154f, -0.05754947f, -0.01547585f, 0.00500438f, -0.05412576f, -0.08319472f, -0.04312018f, 
    0.03491287f, 0.01879697f, -0.04890123f, -0.05716844f, -0.01946029f, -0.05923511f, -0.08388463f, -0.02839085f, 
    0.05413757f, -0.06080446f, 0.02491304f, -0.05388087f, -0.02101462f, -0.03247800f, -0.01222229f, -0.07337364f, 
    -0.04695177f, -0.07882890f, -0.02065443f, -0.07714963f, -0.09346883f, 0.02280780f, 0.03165696f, -0.01358209f, 
    0.02450939f, -0.06297598f, -0.03878009f, -0.02966839f, -0.03771210f, -0.06641279f, 0.02361323f, -0.07292488f, 
    0.00308382f, 0.02520145f, -0.06957866f, -0.04428479f, 0.00775215f, -0.03071808f, -0.11134978f, -0.07169875f, 
    -0.00336303f, -0.08918018f, -0.01824060f, -0.12208105f, 0.01156130f, -0.02261080f, 0.01008767f, 0.03362565f, 
    0.06919613f, 0.00452706f, 0.04909411f, -0.02286987f, -0.03303085f, 0.00386721f, -0.00734899f, -0.09010641f, 
    0.00372824f, -0.00489307f, -0.08083498f, -0.09127774f, 0.03873429f, -0.01120499f, 0.00113635f, 0.02309258f, 
    -0.00964783f, 0.02974407f, -0.08962151f, -0.04030392f, 0.01145421f, -0.02730612f, -0.08844624f, 0.03081469f, 
    0.03313939f, -0.08126473f, 0.01162706f, 0.00083507f, -0.01520956f, -0.07236384f, 0.01244584f, -0.07277559f, 
    -0.02579270f, 0.03351567f, 0.00004974f, 0.01844026f, -0.09096148f, -0.01612532f, 0.00357011f, -0.09214498f, 
    -0.07403301f, -0.01013464f, 0.03205125f, -0.08278432f, -0.08696996f, -0.05048549f, 0.01507242f, -0.03775652f, 
    0.04773245f, -0.04984216f, -0.12490235f, -0.08600488f, 0.06277522f, 0.04985254f, 0.04233121f, 0.06885509f, 
    0.03308124f, -0.02895970f, -0.00271792f, -0.01841535f, 0.02660396f, -0.07021015f, 0.01981207f, -0.00373931f, 
    -0.04896082f, -0.01486909f, 0.02844673f, 0.04319571f, -0.01141870f, -0.08332963f, -0.08998673f, -0.10088892f, 
    -0.05197205f, -0.04117090f, 0.00412840f, -0.01531195f, -0.03138645f, 0.03374549f, -0.02764007f, 0.00345886f, 
    0.08885033f, 0.17284836f, 0.29257646f, 0.02747821f, -0.05134049f, 0.00762052f, 0.02830232f, 0.03590130f, 
    -0.00868695f, 0.08382213f, -0.11758580f, 0.00889219f, 0.15036072f, 0.26941463f, 0.30667743f, 0.31645265f, 
    0.02473320f, -0.02823018f, 0.01044350f, -0.10728790f, 0.01040385f, 0.13566960f, 0.08630733f, 0.22890474f, 
    0.32483768f, 0.22135432f, 0.10483316f, 0.12359777f, 0.11184540f, 0.17280616f, 0.16498969f, 0.12471377f, 
    0.08526762f, -0.08903544f, -0.06242279f, 0.08390111f, 0.24923031f, 0.02309922f, 0.46660459f, 0.09325159f, 
    0.02959876f, -0.10781125f, -0.07218476f, 0.01396448f, -0.04689416f, 0.18512848f, 0.21383053f, 0.09947107f, 
    0.15729472f, -0.58186448f, -0.72908497f, -0.21352611f, 0.07683187f, -0.11366150f, -0.20353067f, -0.16371270f, 
    -0.24153414f, -0.21109866f, -0.07167812f, -0.09729902f, 0.18225957f, -0.07944060f, -0.15601912f, 0.25614560f, 
    -0.04170038f, 0.08563475f, -0.02146180f, -0.02446234f, -0.07005683f, -0.01389210f, 0.21369591f, -0.03250550f, 
    0.20597662f, 0.13999580f, 0.10759435f, 0.00797801f, 0.19785537f, 0.08705587f, -0.02771345f, -0.09785774f, 
    0.10656255f, 0.05813121f, -0.21935706f, -0.19641790f, 0.42003104f, 0.04640370f, 0.32265511f, -0.05953114f, 
    -0.10087748f, 0.00136682f, 0.40467310f, 0.30449381f, -0.24965452f, 0.08235547f, -0.01425833f, 0.15813100f, 
    -0.48404163f, -0.27880466f, -0.59031981f, -0.37042955f, -0.20436040f, -0.23101746f, -0.08899891f, 0.10334296f, 
    0.11147439f, 0.25355676f, 0.19774169f, 0.02434241f, 0.11471015f, -0.28397158f, -0.01356510f, 0.17091794f, 
    0.10807934f, -0.32597405f, -0.04995221f, -0.05167426f, 0.08473422f, 0.19452994f, 0.14391400f, -0.17248408f, 
    -0.29498541f, 0.10214262f, -0.26014611f, -0.09986153f, 0.03491519f, 0.02180052f, 0.03465029f, 0.20332077f, 
    0.06303810f, 0.12916851f, 0.07745503f, 0.10357696f, 0.17484008f, -0.07723195f, -0.09118807f, 0.03608996f, 
    -0.03365570f, 0.02319374f, -0.05606817f, 0.05448207f, 0.19850434f, 0.09366718f, -0.03985706f, -0.02142453f, 
    0.29942694f, -0.74271965f, -0.34049302f, -0.47880334f, 0.15486664f, 0.00683168f, -0.03246053f, -0.10744769f, 
    0.04046566f, 0.01924993f, 0.11003863f, 0.20647994f, -0.65377218f, -0.38740838f, -0.49310187f, -0.10256840f, 
    -0.08831100f, -0.19376159f, 0.12116726f, -0.15915138f, -0.06103442f, -0.04034872f, 0.02269700f, 0.08772227f, 
    0.19799016f, -0.10323206f, 0.18161295f, 0.01083093f, 0.19084758f, 0.11867233f, -0.01838925f, 0.11225081f, 
    -0.10354598f, -0.01202967f, 0.28972256f, 0.01313125f, 0.63195884f, 0.11500326f, 0.03835266f, 0.19460858f, 
    -0.23139602f, 0.10677189f, -0.02290548f, -0.25448495f, -0.22685650f, -0.04502500f, -0.19242203f, 0.01313812f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06239729f, -0.06830123f, -0.04226919f, -0.06550855f, 0.01510275f, 0.09068285f, 0.06412596f, -0.02223188f, 
    0.02753534f, -0.03764029f, 0.00863830f, 0.41292337f, 0.15627217f, 0.04757425f, 0.27914479f, -0.04920387f, 
    0.11420580f, -0.03628580f, 0.00754774f, 0.13312361f, 0.04177216f, 0.02461990f, 0.01350418f, 0.03858524f, 
    0.32181394f, 0.21749859f, -0.00938730f, 0.27857023f, -0.14534770f, -0.06399186f, 0.02866856f, 0.14103584f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.32947293f, 0.04246255f, 0.31574667f, -0.06413250f, 0.01979214f, 0.32141748f, -0.84171188f, 0.24210116f, 
    -0.05178888f, 0.15130319f, 0.04711880f, -0.77420509f, -0.27628726f, -0.61946630f, -0.72577018f, 0.09445559f, 
    -0.06092318f, 0.04952611f, 0.13983357f, -0.05043137f, 0.32665345f, -0.45544025f, 0.04420619f, 0.16479215f, 
    -0.70969081f, -0.22951356f, -0.15317710f, -0.45808727f, 0.31112820f, 0.19361098f, 0.10261270f, -0.16555694f, 
    0.20397925f, 0.00191780f, 0.01032263f, -0.15663077f, -0.11758751f, 0.30549815f, -0.58311778f, -0.26004717f, 
    0.06063856f, 0.05388079f, 0.19547802f, 0.21579352f, 0.00529624f, -0.40067318f, -0.14877918f, 0.10691496f, 
    0.23169456f, -0.07414989f, 0.04768690f, -0.16469893f, 0.03310430f, -0.31700900f, 0.17008066f, -0.21478240f, 
    0.00396859f, -0.49389800f, 0.16524118f, 0.26485202f, 0.31616101f, -1.11442351f, 0.00670787f, 0.63021421f, 
    0.59945941f, 0.11340317f, 0.02678816f, -0.15304765f, -0.02412064f, 0.21451293f, 0.21348050f, 0.18212876f, 
    -0.01310239f, -0.05265132f, -0.12953256f, 0.30515829f, -0.45591065f, 0.10073543f, 0.29236546f, -0.00725300f, 
    -0.03254537f, 0.01463203f, 0.03090469f, 0.20551501f, -0.79343182f, -0.04032453f, 0.06929096f, -0.11323962f, 
    -0.03435371f, -0.13230956f, -0.04262563f, 0.04405549f, -0.34366101f, 0.35804033f, 0.06858068f, -1.22756076f, 
    0.25225297f, -0.07426627f, 0.05207258f, 0.00555647f, 0.08545229f, -0.19056854f, 0.42767757f, -0.02686906f, 
    0.49774760f, -0.17260458f, -0.34706107f, -0.63094449f, -0.00938047f, 0.37009263f, -0.27397540f, 0.11538808f, 
    -0.61558092f, 0.08641748f, 0.14617521f, 0.02188425f, -0.12894464f, -0.07348713f, -0.01906125f, -0.45371270f, 
    -0.74204302f, -0.34220752f, 0.87295425f, -0.16641636f, 0.00225149f, 0.39566010f, -0.09557978f, 0.13155539f, 
    -0.13803302f, -0.01607896f, 0.11956338f, 0.14145106f, 0.02182044f, -0.09195760f, 0.05934012f, 0.01786890f, 
    -0.35465813f, -0.00882357f, 0.28543743f, -0.58273023f, -0.26596048f, -0.76191181f, 0.36328945f, 0.12095147f, 
    -0.01344281f, -0.12271416f, -0.09651645f, 0.25944698f, -0.05913842f, 0.50220895f, -0.16065808f, -0.70823282f, 
    0.01997634f, -0.31106845f, -0.13994332f, -0.64976627f, 0.32594469f, 0.03617737f, -0.00224017f, -0.13606480f, 
    -1.09351242f, -0.05801120f, -0.21928364f, -0.14337949f, 0.01341094f, -0.12156460f, -0.23996183f, 0.10398142f, 
    -0.18741423f, 0.01494951f, -0.02584222f, 0.08634190f, 0.38895494f, -0.64551866f, 0.40459824f, -0.03700143f, 
    0.09102503f, -0.02684638f, 0.08311177f, 0.15827630f, 0.28262946f, -0.67755055f, -0.13240381f, 0.13806909f, 
    0.21879512f, 0.23585126f, -0.51438379f, 0.30676129f, 0.01014347f, -0.05791563f, 0.06822094f, -0.27578524f, 
    0.53286713f, -0.13541611f, -0.66966343f, -0.10721523f, -0.17014039f, -0.54144472f, 0.24618365f, -0.09671226f, 
    0.32410640f, -0.06795970f, 0.03360033f, 0.13538629f, -0.14885356f, 0.21227430f, -0.09079375f, 0.13787654f, 
    0.31615818f, 0.07891697f, 0.07612744f, 0.33478960f, -0.97034180f, -0.11533749f, 0.16618276f, 0.30081061f, 
    0.22462137f, -0.06568319f, -0.69612038f, -0.54426521f, -0.98460299f, -0.08741038f, 0.09817502f, 0.09488133f, 
    -1.13204432f, -0.05294698f, 0.46220544f, -0.17370266f, -0.29341379f, -0.23457170f, -0.04862067f, 0.10584397f, 
    -0.31966427f, -0.03395312f, 0.24622868f, -0.26074365f, -0.03711695f, 0.41280007f, -0.11215109f, -0.01406926f, 
    -0.00784653f, 0.00058395f, -0.01511130f, -0.75421739f, -0.37823251f, -0.02706851f, -0.03488227f, 0.20773779f, 
    0.20233026f, -0.05345031f, 0.53716999f, 0.28119633f, -0.54554504f, 0.33214045f, 0.09293159f, -0.18187608f, 
    -0.30226544f, 0.04759539f, -0.85761684f, -0.17669554f, -0.08124963f, 0.23832123f, -0.11901972f, 0.39031348f, 
    0.07535569f, 0.04355722f, -0.63406903f, 0.36790025f, 0.28029525f, 0.53315097f, -0.38874084f, 0.06529717f, 
    -0.52147776f, -0.04282578f, -0.09782939f, -0.49558681f, -0.29468918f, -0.29746231f, -0.01930591f, 0.04264023f, 
    0.05271619f, 0.22766069f, 0.11526775f, 0.25519827f, -0.53188533f, -0.24029857f, 0.04762737f, 0.32900557f, 
    -0.63677174f, -0.13721359f, 0.32134125f, 0.08312417f, -0.53940803f, -0.53896278f, -0.64927721f, -0.14460002f, 
    -0.23039323f, 0.09607255f, -0.29101157f, 0.00965699f, -0.70977116f, 0.02291420f, 0.53697294f, -0.12551291f, 
    0.48982084f, -0.16699080f, 0.12636371f, 0.11600247f, -0.03305620f, 0.33986652f, -0.12039106f, 0.28582221f, 
    0.31240627f, 0.32474166f, 0.08600339f, -0.21962172f, 0.07255743f, -0.27032635f, -0.04519210f, -0.25637349f, 
    0.39909923f, -0.11641523f, -1.10549617f, -0.17765923f, 0.48346746f, -0.18832490f, -0.22567275f, -0.04235664f, 
    0.44105563f, 0.12335104f, -0.31594187f, -0.02177899f, 0.04368412f, -0.35581604f, 0.25333223f, 0.00727058f, 
    -0.27093714f, -0.09211422f, -0.04849434f, -0.45281371f, 0.34699512f, 0.44765812f, -0.08665694f, -0.00620658f, 
    -0.11173512f, -0.48933789f, -0.36479163f, 0.32129201f, -0.38084280f, -0.37233838f, -0.12221593f, -0.23720947f, 
    0.29383194f, 0.08613751f, 0.20290616f, -0.13533126f, 0.12225087f, 0.21714936f, 0.65732247f, -0.56474108f, 
    -0.74179161f, -0.09545307f, 0.36347109f, 0.24604172f, 0.18558489f, -0.14486298f, -0.55323893f, -0.17664468f, 
    -0.46583557f, 0.10956107f, 0.13514493f, -0.19293702f, -0.13594171f, 0.43137878f, -0.08507822f, -0.16436172f, 
    -0.29838741f, 0.10235044f, -0.46108899f, 0.07784148f, -0.42839906f, -0.57342184f, 0.04102945f, 0.20690715f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14058605f, -0.05102778f, -0.04525943f, -0.10571909f, 0.12006605f, 0.22048864f, 0.09086567f, -0.20372301f, 
    0.02712909f, 0.00211402f, 0.14477192f, -0.04766171f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
