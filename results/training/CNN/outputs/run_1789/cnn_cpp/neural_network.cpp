#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.55601007f, 0.03014375f, -0.14057529f, -0.40541866f, -0.34777558f, -0.54645735f, -0.58783984f, -0.48706031f, 
    -0.43010572f, -0.55767918f, 0.09970983f, 0.28696674f, -0.11046186f, 0.42899534f, -0.02225805f, 0.22703804f, 
    0.15254939f, -0.08278424f, -0.09277847f, -0.18420397f, -0.03454526f, 0.37647772f, 0.35068110f, 0.06532879f, 
    0.37221271f, 0.55304110f, 0.52491999f, 0.36280543f, 0.06792668f, 0.16819175f, -0.08642316f, 0.06213393f, 
    -0.09988573f, -0.24947357f, -0.08087407f, 0.12026901f, 0.11075829f, 0.18850178f, 0.47607163f, -0.19490850f, 
    0.31601933f, -0.08146066f, 0.22497801f, 0.14089595f, 0.12440616f, -0.13086464f, 0.12289084f, 0.07321204f, 
    0.19291621f, 0.39758638f, -1.39742064f, -0.11937494f, 0.58213401f, 0.29650965f, 0.18602380f, -0.47795182f, 
    -0.07860290f, 0.12277135f, 0.60234499f, 0.33520183f, 0.06588563f, 0.19730873f, 0.17678869f, -0.28349453f, 
    -0.16286461f, 0.22219069f, -0.12740728f, -0.29438838f, -0.33265543f, 0.21891271f, -0.12471465f, 0.16605404f, 
    0.07311297f, 0.05757073f, 0.16031177f, -1.21573067f, -0.50404453f, -0.33420858f, -0.33186325f, -0.06230579f, 
    0.26052940f, -0.25052959f, -0.57557899f, 0.07731801f, 0.64519405f, -0.44650850f, -0.45593321f, -0.50999844f, 
    -0.48898160f, -0.02900147f, 0.11618131f, 0.02144804f, -0.14013493f, 0.04285372f, -0.00121342f, -0.05436227f, 
    -0.37979177f, -0.31834811f, -0.12272661f, -0.03780232f, 0.59130901f, 0.25062764f, 0.18093055f, 0.36014453f, 
    -0.47167540f, -0.44031048f, -0.05385343f, 0.35823473f, 0.22118400f, -0.14879555f, 0.00708930f, 0.13642417f, 
    0.00180752f, 0.53986353f, -0.12537989f, 0.08715133f, 0.19646190f, 0.16583341f, -0.00041743f, -0.36537093f, 
    -0.20105679f, -0.23250251f, -0.31581932f, -0.11426955f, 0.02803003f, -0.75277102f, -0.42955869f, 0.11144581f, 
    0.04786980f, 0.26743841f, 0.37554240f, -0.54546958f, -0.63458800f, -0.27578878f, -0.48083234f, -0.02039063f, 
    0.22160287f, -0.10628083f, -0.08793872f, -0.35020027f, -0.24806850f, -0.50403088f, -0.00200453f, 0.02791885f, 
    -0.07887270f, -0.18529545f, 0.16752365f, -0.20821846f, 0.17683800f, 0.25950855f, 0.64104676f, -0.21190698f, 
    -0.09440618f, -0.00218958f, 0.24124086f, 0.26221490f, -0.06393065f, -0.16918232f, -0.06157618f, -0.04599793f, 
    -0.25074270f, 0.42070520f, 0.04717574f, -0.03118612f, -0.21496023f, -0.23453218f, -0.15900102f, 0.18576623f, 
    -0.11491861f, -0.15334962f, -0.21226557f, 0.15555903f, 0.35996196f, 0.10447975f, 0.19189072f, -0.77974409f, 
    -0.81889910f, -0.72195041f, -0.25828949f, -0.62584490f, 0.65417355f, 0.39221483f, 0.16076078f, 0.65621400f, 
    0.23873104f, 0.23124076f, 0.19048809f, 0.06433009f, 0.44605455f, -0.32287264f, -0.30726293f, 0.05080944f, 
    0.09811568f, -0.02399931f, -0.09635985f, -0.09012947f, 0.08767478f, 0.10648598f, 0.00424026f, -0.22638980f, 
    0.72951531f, 0.97731167f, 0.48182687f, -0.23807037f, -0.18029526f, -0.23840098f, -0.15672554f, 0.30323341f, 
    -0.28163779f, -0.08681758f, 0.07157833f, -0.33702758f, 0.22793061f, -0.07578637f, -0.26153338f, 0.12383522f, 
    -0.08376914f, 0.15688977f, -0.10965224f, -0.06320921f, 0.18337423f, -0.09334273f, -0.49469557f, -0.43019491f, 
    -0.32267061f, 0.04184186f, -0.21052654f, -0.54197633f, -0.23665868f, -0.69832975f, -0.05828011f, -0.02684470f, 
    -0.39060494f, -0.55383009f, -0.09657720f, -0.08263359f, 0.04936876f, 0.06777096f, -0.28472775f, -0.07102906f, 
    0.19551325f, 0.08975416f, 0.12945996f, -0.06241464f, 0.05327704f, -0.30679193f, -0.19147338f, -0.12587209f, 
    -0.48904115f, -0.56747472f, 0.87340206f, -0.62224740f, -0.67304945f, 0.10028565f, 0.17466357f, 0.49852714f, 
    0.65113389f, 0.12942316f, -0.27583629f, -0.36933920f, 0.38476074f, 0.21168061f, -0.31859988f, -0.15981100f, 
    0.08499702f, 0.07125968f, -0.17125793f, 0.00220174f, -0.12210871f, -0.40648654f, -0.07805652f, 0.21820641f, 
    0.19311629f, -0.14834346f, 0.00695643f, 0.76983011f, -0.14352177f, -0.26389986f, -0.31406134f, -0.34553131f, 
    0.00246219f, 0.16335608f, 0.52328902f, -0.22670409f, -0.46333465f, -0.24985035f, 0.23296575f, 0.06228428f, 
    -0.09198947f, -0.33081642f, 0.17058334f, 0.35200754f, 0.06347059f, -0.39592114f, -0.22264814f, 0.07377181f, 
    0.15548238f, 0.10038101f, 0.20053598f, 0.42090994f, -0.68328077f, -0.68324983f, -0.48667833f, 0.75458580f, 
    0.93971717f, 0.05169151f, -0.09536308f, 0.08207443f, 0.09615224f, 0.58266091f, 0.05975731f, 0.37927032f, 
    -0.26327547f, -0.06351248f, 0.07722897f, 0.00365792f, -0.12518048f, -0.19991243f, 0.26488283f, -0.04714904f, 
    -0.02189802f, -0.43372679f, -0.18223193f, -0.09401693f, -0.25387582f, -0.57196945f, 0.02242504f, -0.38012803f, 
    0.13591470f, -0.36616182f, -0.10851256f, -0.19454746f, 0.26912183f, 0.43293726f, 0.73204494f, -0.30291757f, 
    -0.12451555f, -0.54934776f, -0.28995961f, 0.43702745f, 0.28448984f, 0.03050836f, 0.48096642f, 0.03955442f, 
    -0.36510292f, -0.28974524f, -0.32024366f, -0.43221286f, -0.33859730f, -0.47171533f, -0.66556585f, -0.46426857f, 
    0.71657306f, 0.65109158f, 0.12766887f, 0.53578436f, -0.75453812f, -0.71881193f, -0.21704541f, -0.15950501f, 
    0.10460845f, -0.45214114f, -0.34289217f, -0.11074128f, 0.03883200f, -0.31326222f, 0.14582521f, 0.22653680f, 
    -0.14074233f, -0.17402717f, 0.06733549f, -0.08279355f, -0.06181085f, -0.10045256f, 0.12455393f, 0.29867730f, 
    0.75521153f, -0.44139114f, -0.24904774f, -0.27485096f, -0.73279202f, 0.24709624f, 0.55938405f, -0.02836724f, 
    0.45975757f, -0.23397322f, 0.31030574f, 0.02268846f, 0.20889749f, 0.04593797f, 0.33423647f, -0.09735479f, 
    -0.37321612f, -0.06982636f, -0.06117139f, -0.24502867f, 0.52514809f, 0.06841939f, -0.25093612f, 0.02324022f, 
    -0.95321280f, -0.41081524f, -0.29973835f, -0.92369187f, -0.48983842f, 0.73243862f, 0.13794991f, -0.71437114f, 
    -0.44260883f, 0.70100749f, -0.13323614f, -0.35132435f, -0.13181053f, 0.14257793f, 0.03396166f, 0.26992363f, 
    0.06686568f, -0.08317519f, 0.07308991f, -0.20068930f, -0.03917358f, 0.02043763f, -0.08469194f, -0.17046116f, 
    -0.07854111f, 0.25268638f, 0.39184642f, 0.19880855f, -0.05521419f, 0.13463633f, -0.15345681f, 0.03282413f, 
    -0.03843004f, -0.30383289f, 0.54905856f, -0.07162648f, 0.44368050f, -0.13107087f, -0.42335942f, -0.35930872f, 
    -0.26278046f, 0.04960036f, -0.09402093f, -0.08246480f, -0.07364165f, -0.23670492f, -0.22927625f, -0.04662970f, 
    -0.13907769f, -0.41200915f, 0.18140103f, -0.18559347f, 0.38423127f, 0.39490607f, 0.36794665f, -0.79090941f, 
    -0.55183423f, 0.42433736f, 0.01114300f, -0.10928444f, 0.17309092f, -0.17991984f, 0.06289557f, 0.00960040f, 
    0.37162039f, -0.13256490f, 0.05747619f, 0.08518965f, -0.21016780f, -0.29812855f, 0.08786912f, -0.09497402f, 
    0.04636864f, 0.42284372f, -0.27477115f, 0.16003740f, -0.78260821f, 0.26120317f, 0.34948215f, 0.18104035f, 
    -0.21034020f, -0.05868303f, 0.19895035f, -0.18184339f, 0.23488072f, -0.13892247f, 0.42709532f, -0.24645308f, 
    0.33481437f, -0.48892352f, 0.05831753f, -0.05765740f, 0.14238910f, 0.10993373f, -0.25723675f, 0.16453978f, 
    -0.51499963f, -0.44124702f, -0.01914404f, 0.70271444f, 1.03399384f, -0.39831582f, -0.24991210f, -0.13167381f, 
    -0.25048840f, 0.25599244f, 0.63782525f, 0.18365137f, -0.32949489f, -0.07160617f, -0.36176085f, -0.25804356f, 
    -0.22542545f, -0.03565381f, 0.36162540f, 0.09465787f, -0.32847700f, -0.02286752f, 0.03662711f, -0.25749147f, 
    0.45640758f, -0.42700920f, -0.20443408f, 0.16598657f, -0.39352107f, 0.25393653f, 0.22828346f, -0.25686458f, 
    -0.31567439f, -0.55315721f, -0.63202375f, -0.44764665f, -0.15440935f, 0.00974359f, 0.59849548f, 0.37481090f, 
    0.35641539f, 0.10452791f, 0.19259721f, 0.32718500f, 0.13178024f, -0.29337013f, 0.23833685f, -0.38026607f, 
    -0.42533922f, 0.17429154f, -0.13491672f, -0.17564851f, 0.29843178f, 0.13303822f, -0.42825651f, -0.57566941f, 
    -0.14647478f, -0.42183882f, -0.06824926f, -0.10261671f, -0.14722808f, -0.03312114f, -0.25694484f, -0.77565104f, 
    0.08351733f, -0.08476210f, 0.08626008f, 0.40753785f, 0.22403203f, -0.42011130f, -0.29229584f, -0.29167008f, 
    -0.51963645f, -0.31834862f, 0.00365498f, -0.14141986f, 0.52777839f, -0.15220930f, -0.32354692f, 0.26298997f, 
    -0.44153664f, -0.76653647f, -0.80696821f, -0.98058611f, 0.71803463f, 0.37046260f, 0.09522590f, 0.36856821f, 
    0.20465294f, -0.01941873f, -0.20774490f, -0.22390163f, -0.09064431f, -0.15349188f, 0.09357627f, -0.15828680f, 
    -0.19035001f, -0.10926837f, -0.17728609f, -0.37925425f, 0.02956857f, 0.01960707f, 0.04175066f, -0.09143694f, 
    -0.05574431f, -0.77291685f, -0.51714242f, -0.31874621f, -0.50505608f, 0.36546639f, 0.21151660f, -0.01829121f, 
    -0.45266536f, 0.50284940f, 0.21022505f, 0.01056898f, 0.34394118f, -0.27294564f, 0.46949893f, -0.24758445f, 
    0.01839275f, -0.00571113f, -0.35975048f, 0.50722724f, -0.10259924f, -0.41245425f, 0.15811226f, 0.19345812f, 
    -0.08925693f, -0.27410144f, 0.63692796f, -0.20206749f, -0.37887350f, -0.44841447f, -0.55526650f, -0.33380345f, 
    0.33428481f, -0.54150051f, -0.73443294f, 0.44040155f, 0.01716192f, 0.00710073f, -0.41686675f, -0.26974636f, 
    -0.13451061f, 0.06074093f, -0.05031512f, -0.07760701f, -0.38839236f, -0.27533278f, -0.17329688f, -0.01620361f, 
    -0.24925201f, -0.32117844f, -1.35881555f, -0.79429150f, -0.17028841f, 0.48664460f, 0.44787550f, 0.33335489f, 
    0.19839357f, 0.35215881f, -0.02571037f, 0.26362917f, -0.37258071f, -0.11533294f, -0.38442445f, 0.50642484f, 
    0.19052406f, -0.04799717f, 0.22119293f, -0.40783423f, -0.27465099f, 0.31327531f, 0.32698613f, -0.08452903f, 
    0.00556436f, 0.42016053f, -0.33825925f, 0.05288281f, -0.30584618f, 0.30954772f, 0.27680865f, 0.10152122f, 
    0.40402073f, 0.55180347f, 0.24089345f, 0.29229254f, 0.54609185f, -0.41151321f, 0.04410654f, -0.03597472f, 
    0.12151586f, 0.00956123f, -0.20615052f, -0.00347194f, 0.14002423f, -0.45392558f, -0.03619199f, 0.00695146f, 
    0.37747201f, -0.01119499f, 0.17349549f, 0.00619828f, -0.90550309f, -0.12555622f, -0.28534836f, 0.68074805f, 
    0.81477714f, 0.46684143f, 0.70488554f, -0.86028278f, -0.31022373f, -0.26978770f, -0.18972325f, 0.39467743f, 
    -0.38913250f, -0.06280116f, -0.26532915f, 0.18549383f, -0.27688500f, -0.14027284f, 0.30045828f, 0.38898763f, 
    -0.15982075f, -0.19099261f, -0.23351495f, 0.18798888f, -0.36173409f, -0.51186413f, 0.22252633f, -0.04851012f, 
    -0.13703534f, 0.39817086f, -0.06965584f, 0.04630460f, 0.31254736f, 0.45829731f, 0.23195913f, -0.21101628f, 
    -0.07281099f, -0.03791357f, 0.00414005f, 0.10777558f, -0.20092905f, -0.35765302f, -0.16437583f, -0.01888744f, 
    -0.43830612f, 0.07973143f, -0.00382379f, 0.36929488f, 0.30484360f, -0.11246181f, 0.41713959f, 0.22544925f, 
    -0.19748092f, -0.02810508f, -0.31655389f, 0.51246303f, -0.85387790f, 0.15800358f, 0.40075794f, 0.42059088f, 
    0.32713214f, -0.36152616f, -0.46852669f, 0.12192481f, -0.32679000f, -0.16068286f, 0.23447782f, 0.35186493f, 
    -0.14802170f, -0.31458706f, -0.08863252f, 0.30926782f, 0.28960899f, -0.26366338f, -0.05838710f, -0.47355479f, 
    -0.40298310f, -0.52086049f, 0.43850502f, -0.16595061f, -0.33722281f, -0.05885995f, -0.41793412f, -0.58085650f, 
    -0.24418446f, -0.10641037f, -0.47500011f, 0.47315586f, -0.09549309f, -0.36748087f, -0.40077430f, -0.22243127f, 
    0.12886719f, -0.48045900f, -0.31936738f, 0.17220546f, -0.06469692f, -0.13238876f, 0.10319740f, -0.01962086f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12360159f, -0.20759504f, 0.36324817f, -0.06032791f, -0.12850116f, 0.19030093f, 0.34978691f, 0.06005001f, 
    -0.08603381f, -0.26094493f, 0.53903198f, 0.10346437f, 0.06689383f, -0.03716335f, -0.01997908f, 0.22366586f, 
    0.00718139f, 0.12016895f, 0.17625386f, 0.31029540f, 0.21090387f, 0.15365933f, -0.04019058f, 0.12072722f, 
    0.34590217f, 0.30268273f, 0.37153065f, -0.05297193f, 0.17260952f, 0.33218572f, 0.27858639f, 0.16463624f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02567884f, 0.12279610f, 0.07736715f, -0.04121006f, -0.14620064f, 0.01428057f, -0.00662614f, -0.04250875f, 
    -0.01556358f, -0.00063580f, -0.05664217f, 0.01985906f, 0.23049229f, 0.12062512f, 0.06943548f, 0.01827671f, 
    0.02788593f, -0.01959176f, -0.00785183f, -0.01665120f, -0.00574509f, 0.00908836f, -0.01699289f, -0.01693714f, 
    0.49173194f, 0.12130518f, -0.04620552f, -0.15356231f, 0.07372380f, 0.17812230f, -0.01601334f, -0.08773736f, 
    -0.17988260f, 0.13676552f, 0.03644663f, 0.02305583f, 0.22561982f, 0.22672585f, -0.04833479f, 0.03657228f, 
    0.10176978f, 0.22837952f, -0.04149563f, 0.05561421f, 0.00802794f, -0.08446244f, -0.21046273f, 0.01858433f, 
    0.00081327f, -0.04432544f, 0.11150527f, 0.02494117f, 0.06743436f, 0.17028476f, -0.02794989f, -0.06233688f, 
    -0.03010080f, -0.10229848f, -0.03942301f, 0.09194515f, 0.11797771f, 0.10240290f, 0.09149485f, 0.20023365f, 
    0.01628700f, -0.02453118f, 0.01197815f, 0.27913442f, -0.10538144f, -0.06009756f, -0.05477329f, 0.06624212f, 
    0.22354543f, 0.30923173f, 0.00780606f, 0.12167936f, -0.04998035f, 0.00253241f, 0.11209393f, 0.04215104f, 
    -0.11341172f, -0.03711657f, 0.03873811f, -0.11172388f, 0.47953442f, -0.11729959f, -0.32925171f, -0.23642325f, 
    -0.13226615f, -0.14545740f, 0.03889320f, 0.12395352f, -0.14590843f, -0.09671742f, 0.07650764f, -0.20914209f, 
    0.21922790f, 0.11327093f, 0.23057239f, 0.02806860f, -0.00445960f, -0.10104097f, -0.16728982f, 0.02480775f, 
    0.04096950f, 0.01138810f, 0.09116855f, 0.25475994f, 0.07612417f, 0.07924524f, -0.00296643f, -0.11091196f, 
    0.05324845f, 0.03515821f, 0.05273276f, -0.05787764f, -0.03368993f, -0.07074501f, -0.17631680f, 0.07592323f, 
    0.39272502f, -0.12733582f, 0.01488556f, 0.23276027f, -0.16371654f, 0.01939180f, 0.05330575f, 0.04130517f, 
    0.15220632f, 0.05842978f, -0.06596060f, 0.13307030f, 0.21134241f, 0.05193133f, 0.06193370f, -0.00808496f, 
    -0.17836970f, 0.22739689f, 0.20759895f, -0.03200109f, -0.12544774f, 0.04678888f, 0.02499904f, -0.03710318f, 
    0.02790577f, 0.02253404f, -0.10345411f, -0.02184233f, -0.09733140f, 0.07974394f, -0.01526864f, -0.04283698f, 
    -0.07526264f, 0.04179246f, -0.11383267f, 0.07650458f, -0.35124859f, 0.14610316f, -0.00269717f, -0.17767756f, 
    0.04653768f, 0.01902897f, -0.10776930f, -0.02505001f, 0.15175711f, 0.11192299f, -0.06635842f, 0.09058905f, 
    0.03608258f, -0.05736290f, -0.21544202f, -0.34935787f, 0.07725821f, -0.24325559f, 0.00828042f, 0.08337650f, 
    -0.03448502f, -0.03605632f, -0.01125709f, 0.00202312f, 0.09855783f, -0.22686735f, 0.17261000f, 0.08254826f, 
    -0.07739626f, 0.16091762f, 0.10797072f, -0.04251343f, 0.02770899f, 0.03079285f, -0.28673708f, -0.01778979f, 
    0.30915922f, 0.16227844f, 0.14183223f, 0.14482576f, -0.00756299f, 0.08446730f, -0.04954615f, 0.11686022f, 
    -0.12077213f, 0.01511863f, 0.03601586f, -0.14516932f, 0.08920126f, 0.13773195f, 0.14579403f, 0.04718585f, 
    0.05647746f, -0.04656725f, -0.06224998f, -0.02151723f, 0.03555892f, 0.08578305f, 0.04187019f, 0.12531224f, 
    0.12877041f, 0.48782381f, 0.39057109f, -0.00722302f, -0.09424004f, -0.08859557f, -0.09724339f, -0.08485515f, 
    -0.00590933f, -0.08930628f, -0.03621304f, -0.01771728f, 0.06219973f, 0.32798633f, 0.16205721f, -0.31659278f, 
    -0.10485262f, 0.27311495f, -0.07705519f, -0.14153016f, 0.18009421f, -0.32037821f, 0.12277024f, 0.12644717f, 
    0.28412190f, 0.07024622f, 0.21169704f, 0.27275246f, -0.06462936f, -0.01382647f, 0.04790020f, -0.06633110f, 
    0.14042886f, 0.07682835f, -0.03548048f, 0.10816982f, -0.49511689f, -0.24529725f, 0.06068226f, -0.12477145f, 
    0.20798607f, 0.31682670f, -0.22172235f, -0.06610893f, -0.00392724f, 0.08601488f, 0.02068966f, 0.13939747f, 
    0.01579380f, 0.15741433f, 0.11403922f, -0.09374012f, -0.00980672f, -0.05418880f, 0.10352093f, 0.07935825f, 
    0.11236968f, -0.11559741f, 0.09463965f, -0.07920370f, 0.02604464f, 0.18312259f, -0.03426632f, 0.01651352f, 
    -0.12138865f, -0.07819929f, 0.09071640f, -0.06785129f, -0.01688125f, 0.03678564f, -0.10897344f, 0.00636172f, 
    0.05782506f, -0.16775465f, -0.15832414f, -0.12015186f, -0.11914694f, 0.00939637f, 0.11202499f, -0.02981972f, 
    -0.01958498f, 0.09467509f, -0.12806407f, -0.07324374f, -0.03872724f, 0.08436840f, 0.10086221f, -0.09812517f, 
    0.00770028f, 0.04777309f, -0.11418068f, 0.02632257f, -0.12428071f, 0.01367494f, 0.04327228f, 0.26476249f, 
    0.43842843f, -0.43045923f, 0.15109974f, -0.20665282f, 0.01198598f, 0.03031777f, -0.00984348f, -0.00901373f, 
    0.00004904f, 0.03715585f, 0.00963864f, -0.11503387f, 0.17171487f, 0.02346872f, 0.11832753f, -0.02178667f, 
    0.00488331f, 0.03124882f, 0.06443581f, 0.00249196f, 0.06673250f, 0.15062416f, -0.00932768f, -0.11597016f, 
    0.36239791f, -0.22336081f, -0.07914136f, 0.04188848f, -0.00604243f, 0.01691145f, 0.04823658f, 0.09387854f, 
    -0.03533470f, 0.20326144f, -0.11278523f, 0.00479663f, 0.15715991f, -0.10099729f, 0.01436837f, 0.01578995f, 
    0.02962397f, 0.01928742f, 0.14074636f, 0.03163410f, 0.04244693f, -0.06826476f, -0.10504249f, -0.19111769f, 
    -0.24019483f, 0.08090055f, 0.46299541f, 0.18309636f, 0.03348223f, -0.03175034f, 0.03371912f, 0.11033529f, 
    -0.05660786f, 0.04237673f, 0.17926255f, 0.14151071f, -0.00329581f, -0.03751179f, 0.22720592f, 0.01810213f, 
    0.04791916f, -0.12318330f, 0.12093575f, -0.12270959f, 0.00639964f, -0.18539457f, 0.00812486f, -0.06633389f, 
    -0.25831005f, 0.07401793f, -0.06535175f, 0.05574026f, -0.11172023f, -0.06718751f, -0.12795241f, 0.03978015f, 
    -0.19498739f, -0.11660356f, -0.02495288f, 0.02142409f, -0.05497746f, 0.00469415f, -0.02200216f, -0.08274389f, 
    0.00872084f, -0.06909245f, -0.00044811f, -0.02529101f, -0.11108915f, -0.08341090f, -0.00163625f, -0.08533891f, 
    -0.08223341f, 0.32204872f, 0.00091240f, 0.16152108f, -0.05629177f, 0.18354730f, -0.06015514f, -0.07230239f, 
    -0.04317054f, 0.21397951f, 0.07166392f, 0.15857145f, 0.29867566f, 0.15427917f, -0.10400716f, 0.04760564f, 
    0.09422478f, 0.17560945f, -0.15499529f, 0.03160894f, 0.13220595f, 0.02894364f, -0.04454525f, -0.02403356f, 
    -0.11056963f, 0.05072894f, 0.03124623f, -0.02121904f, -0.07673812f, 0.07478274f, 0.02055459f, -0.04539967f, 
    0.14211541f, 0.15713635f, -0.14618084f, 0.13093935f, -0.33253631f, -0.14777678f, -0.08882661f, 0.36976749f, 
    0.00383817f, 0.03707533f, -0.06546974f, 0.34314877f, -0.05582217f, 0.05159809f, 0.09118062f, 0.11495169f, 
    0.15610394f, -0.01547061f, 0.08735633f, 0.00824516f, 0.05081733f, -0.09141339f, 0.07591251f, -0.02009100f, 
    -0.10549837f, -0.00286786f, -0.00324817f, 0.06270157f, 0.17902862f, 0.15291879f, -0.09352890f, -0.13813895f, 
    -0.12192132f, -0.08457508f, -0.04114454f, -0.01879135f, -0.15551384f, 0.05932052f, 0.10547543f, -0.08926071f, 
    -0.03394855f, 0.04750058f, -0.06099389f, 0.00066745f, -0.01187373f, -0.09331052f, 0.14249642f, 0.05496204f, 
    0.07064326f, 0.09760379f, 0.04390248f, 0.25855005f, 0.09912230f, 0.03386514f, 0.08538634f, -0.10107969f, 
    0.01154219f, 0.02258761f, -0.07061603f, 0.04658416f, 0.08685914f, -0.00481160f, -0.13512255f, 0.03893153f, 
    0.75881577f, 0.08523882f, 0.36761898f, 0.35810682f, -0.13115044f, -0.08564581f, -0.07260621f, -0.01711161f, 
    0.11560313f, 0.34602335f, 0.06017637f, 0.16574121f, 0.24070127f, 0.01935081f, -0.03299559f, -0.06480336f, 
    -0.13944167f, -0.10163627f, 0.11752836f, -0.11334974f, -0.17784820f, -0.09798233f, -0.10554028f, 0.00992503f, 
    0.01354182f, 0.07868584f, 0.15352739f, 0.03944676f, -0.05392079f, 0.02735274f, -0.07681556f, -0.04954633f, 
    -0.07269325f, -0.22443692f, -0.08182630f, -0.17067766f, -0.28460288f, 0.12095118f, 0.05390528f, -0.01493378f, 
    -0.10570568f, 0.13469906f, -0.12729153f, -0.13744161f, -0.02078772f, -0.08636470f, -0.10417219f, -0.26416713f, 
    -0.51681852f, -0.35133237f, -0.45806232f, -0.31356773f, -0.00112696f, 0.01356475f, -0.24393891f, 0.11982517f, 
    -0.05197711f, -0.06248136f, -0.07751336f, -0.04741631f, -0.05548537f, 0.12320334f, 0.18007454f, -0.02885319f, 
    -0.08924916f, -0.04682464f, 0.13351919f, -0.05316150f, 0.07502001f, -0.06248330f, -0.09694768f, 0.03926408f, 
    0.35694695f, -0.11842776f, 0.05208156f, 0.21705994f, 0.03460633f, 0.07992360f, -0.09425240f, 0.05222839f, 
    -0.15315136f, -0.05347143f, 0.03147371f, -0.19995876f, 0.11715874f, 0.16366975f, 0.34885281f, -0.04587264f, 
    -0.00330085f, 0.01135921f, -0.08625253f, 0.03872347f, 0.13687077f, 0.10195772f, 0.00895288f, 0.14391698f, 
    -0.04363905f, 0.19894861f, -0.15894428f, 0.08395827f, -0.15292078f, 0.02488103f, 0.04842809f, -0.09884521f, 
    -0.09966296f, -0.10887729f, -0.06815740f, -0.01438350f, 0.07362459f, 0.32068220f, 0.08753856f, -0.01971759f, 
    -0.00358844f, 0.13472961f, -0.03131872f, -0.25408256f, 0.31846371f, 0.21938871f, 0.02939525f, 0.05162167f, 
    0.60990226f, 0.03408215f, 0.49293417f, 0.28654933f, -0.07381004f, -0.03456318f, 0.00583314f, -0.12252772f, 
    0.00013654f, -0.05502457f, -0.01562091f, 0.14398201f, -0.24534196f, -0.02708681f, 0.16268788f, -0.24487618f, 
    -0.04271864f, 0.21885766f, -0.12045574f, -0.08165847f, 0.24053052f, -0.05935157f, -0.02087998f, 0.05326620f, 
    -0.31709138f, 0.08884546f, 0.09572193f, 0.01784683f, 0.06699391f, 0.10779400f, 0.11433274f, 0.26213714f, 
    0.01710185f, -0.03882552f, 0.06420024f, -0.14541048f, 0.37483719f, 0.32811522f, 0.09894101f, -0.08616903f, 
    -0.07152379f, -0.13904493f, 0.11203159f, -0.02032941f, 0.08620014f, 0.08667910f, 0.00517013f, -0.09526006f, 
    0.18700193f, -0.04812985f, 0.12566639f, -0.19946554f, -0.01958578f, 0.03761707f, -0.07073100f, -0.13027579f, 
    0.08303734f, 0.11794853f, 0.02823704f, -0.06100478f, -0.23124208f, -0.16640295f, -0.02201143f, -0.15617187f, 
    -0.03299468f, 0.09988358f, 0.08729607f, 0.11010408f, -0.10978657f, 0.00912572f, -0.18616644f, 0.16489057f, 
    -0.03637579f, 0.16631325f, 0.28654823f, 0.17270738f, -0.08808440f, 0.17465724f, -0.11096216f, 0.10556705f, 
    -0.05012232f, -0.13591835f, 0.14118749f, -0.04463205f, 0.16103165f, 0.08513480f, 0.07142215f, 0.01409247f, 
    -0.17859118f, 0.00282666f, -0.08797870f, -0.02345069f, -0.05004474f, 0.09750296f, 0.07653594f, 0.05337842f, 
    0.10229933f, -0.37124738f, 0.00072225f, -0.17700329f, -0.22044428f, 0.10475668f, -0.01182749f, 0.17476805f, 
    0.22143498f, 0.01791042f, 0.11369467f, -0.04816167f, 0.00575950f, 0.23856282f, 0.09943050f, 0.06298807f, 
    -0.11915029f, -0.00153120f, 0.08486826f, -0.03479471f, 0.07299480f, 0.01161559f, 0.09626112f, -0.01642765f, 
    -0.01970411f, 0.08596645f, 0.17252070f, -0.13407062f, -0.01945829f, -0.08679646f, 0.02036447f, 0.05517608f, 
    0.04360966f, 0.15493356f, -0.01163105f, 0.11674262f, -0.33368382f, -0.20156863f, 0.08087963f, 0.17311287f, 
    0.03506986f, -0.06568694f, 0.07159047f, -0.06345113f, -0.01855964f, 0.06789494f, -0.05299896f, 0.03388729f, 
    0.21132916f, -0.04769406f, 0.08143304f, 0.16617148f, 0.12178089f, 0.07444189f, -0.02079071f, 0.10565592f, 
    -0.07498406f, 0.03429923f, 0.00913534f, 0.15000300f, -0.09065989f, 0.00509632f, -0.05286036f, -0.08840939f, 
    -0.11904319f, -0.07782967f, -0.22627817f, -0.27538249f, -0.08095831f, -0.03344075f, -0.03445628f, -0.10165136f, 
    0.30724707f, 0.25435758f, -0.02852048f, -0.38789910f, -0.05843543f, 0.00081262f, -0.00047863f, 0.08371477f, 
    0.01061224f, 0.25783944f, 0.07170509f, 0.18095933f, 0.38209331f, 0.32805431f, -0.21436189f, -0.01263701f, 
    0.16184615f, 0.06902371f, -0.04359183f, -0.00311311f, 0.01582283f, 0.07125856f, -0.12112582f, -0.15110956f, 
    -0.22565486f, 0.00314879f, 0.02711136f, -0.06491667f, -0.17907730f, -0.03157215f, -0.07222278f, -0.16702686f, 
    0.00474133f, -0.02131433f, -0.23478135f, -0.04162478f, 0.09894908f, 0.21206675f, -0.15643045f, 0.17153829f, 
    0.10526358f, 0.05762652f, 0.02246624f, 0.17067277f, 0.00606523f, 0.05951917f, 0.06395184f, 0.14619975f, 
    -0.03387200f, 0.07778393f, -0.08468180f, 0.08654846f, -0.02614373f, -0.06789342f, -0.06193726f, -0.14177997f, 
    -0.03242767f, 0.16864604f, 0.05727826f, 0.18614419f, -0.05818377f, 0.04670997f, -0.17996107f, -0.08327452f, 
    0.11116200f, 0.14312960f, 0.19334081f, 0.11252572f, -0.04496274f, 0.07415765f, 0.01972649f, -0.10927837f, 
    -0.18739595f, -0.06019188f, 0.12104888f, 0.16784509f, -0.07110630f, -0.07374631f, -0.21346396f, -0.00281381f, 
    -0.22500402f, -0.05109301f, 0.05467746f, -0.00193361f, 0.14110608f, -0.09956118f, 0.02848805f, 0.26548043f, 
    0.11153976f, 0.02358159f, -0.09663675f, -0.12120433f, -0.04344197f, -0.02773692f, -0.10862919f, 0.02082953f, 
    0.32029194f, 0.25381669f, -0.08029625f, 0.11434016f, -0.20897822f, -0.03231889f, -0.06044781f, 0.05436426f, 
    0.15199907f, 0.15877819f, 0.00922787f, 0.22271608f, 0.13683958f, -0.07147619f, 0.08555967f, 0.08108594f, 
    -0.04316973f, 0.03572388f, 0.12507249f, -0.19813797f, -0.05593876f, 0.10525538f, 0.07162938f, 0.17292832f, 
    -0.03671625f, 0.11693814f, -0.29890984f, -0.19154195f, -0.07241444f, -0.09055356f, -0.00981460f, -0.15377910f, 
    -0.11751843f, -0.08795241f, -0.11363469f, 0.09175192f, -0.27092859f, 0.14182989f, -0.03953714f, -0.12545682f, 
    0.10825738f, 0.16872048f, -0.01655907f, -0.08298038f, -0.15274952f, 0.07620049f, -0.14284682f, -0.22417128f, 
    -0.15786593f, 0.53073347f, -0.20350811f, -0.28846860f, 0.12189643f, -0.21435073f, -0.11023507f, 0.07692794f, 
    0.02457316f, -0.05413079f, -0.02852468f, 0.14417882f, -0.11219279f, -0.12680703f, 0.14230813f, -0.12959559f, 
    -0.05773227f, 0.13131608f, -0.11456647f, -0.12017870f, -0.00329216f, -0.01305593f, -0.03094947f, 0.19995132f, 
    0.43930292f, -0.06402802f, 0.13563851f, 0.38759080f, 0.26937038f, -0.01557307f, -0.05373090f, -0.06530200f, 
    -0.16448508f, 0.01123527f, -0.00753980f, 0.00969140f, -0.04439399f, 0.37003580f, 0.24487612f, -0.03113120f, 
    -0.08449555f, -0.01811227f, -0.11067534f, 0.03193926f, -0.03250397f, -0.07035762f, -0.12090686f, 0.17251442f, 
    -0.11272098f, 0.41319466f, 0.33319297f, -0.04141514f, -0.22199102f, -0.19039801f, -0.07464878f, -0.14450201f, 
    -0.03630908f, 0.10671411f, -0.04994952f, 0.09367681f, 0.04243131f, 0.18235835f, -0.14384647f, -0.00303124f, 
    -0.04787574f, -0.05306207f, -0.04707149f, -0.11648960f, 0.17898327f, -0.00863196f, 0.08346269f, 0.00523085f, 
    0.26463842f, 0.13356115f, 0.33357999f, 0.26881555f, -0.01447789f, 0.13964756f, -0.09038623f, -0.10434861f, 
    0.00820654f, -0.06802090f, -0.05244196f, -0.05963675f, -0.26857230f, -0.23559000f, 0.02920421f, -0.09919248f, 
    0.09988258f, 0.06044350f, -0.07816435f, 0.12107904f, 0.20731041f, 0.04720543f, 0.15635340f, 0.06529348f, 
    0.04333481f, 0.04221595f, 0.00930061f, 0.02555998f, 0.06863651f, 0.18801694f, 0.27257529f, 0.34793296f, 
    -0.03645118f, -0.00850196f, 0.00710673f, -0.12428834f, 0.19099173f, 0.06743588f, 0.04395008f, 0.30761400f, 
    0.00805661f, 0.06905027f, 0.15849267f, 0.10698717f, 0.12309903f, 0.14748119f, -0.06846489f, -0.07632576f, 
    -0.08490004f, -0.17012803f, -0.05602679f, 0.14512663f, 0.17335448f, 0.09727526f, 0.18831030f, -0.00780258f, 
    0.18096101f, 0.09119755f, -0.02698639f, -0.12539977f, 0.05358316f, -0.33839476f, 0.06657295f, 0.03245690f, 
    0.05831196f, 0.06294498f, -0.07063616f, -0.00172552f, -0.03456736f, 0.01035784f, -0.08486439f, 0.22223704f, 
    -0.10302482f, 0.21742918f, 0.29480752f, -0.46503294f, 0.03439035f, 0.08278905f, 0.05363637f, 0.11029482f, 
    0.10330192f, 0.02744528f, -0.00745068f, -0.07830581f, -0.11631513f, 0.02073090f, 0.06515253f, -0.12104674f, 
    -0.24946165f, -0.00369982f, -0.10303790f, -0.05533427f, -0.02011871f, 0.26013654f, 0.19821954f, 0.27538991f, 
    0.31322145f, 0.38364172f, -0.17918925f, -0.11139584f, -0.04937382f, -0.07557893f, 0.08521561f, 0.08744960f, 
    0.05093395f, -0.05890168f, -0.03634359f, 0.03217752f, 0.13209149f, -0.01348185f, 0.13957867f, -0.09289189f, 
    -0.16514045f, -0.09066150f, 0.07042745f, 0.05639042f, 0.11401044f, 0.22047630f, 0.16799626f, 0.16678084f, 
    -0.30309781f, 0.23998162f, 0.07598758f, 0.03749839f, 0.11704154f, 0.00417754f, -0.04615328f, 0.09058002f, 
    -0.00143961f, 0.23645927f, -0.13481803f, 0.26270249f, 0.04223926f, 0.07975806f, -0.10470662f, 0.18124945f, 
    0.07918470f, 0.13449919f, 0.08318925f, -0.08128045f, -0.03364700f, 0.05649507f, 0.04782523f, 0.11367011f, 
    0.02892989f, -0.05165063f, -0.01487486f, 0.04254088f, 0.01166744f, 0.04951465f, -0.00561206f, -0.04599607f, 
    -0.03647254f, -0.05690689f, -0.04833553f, 0.01869955f, -0.05860071f, -0.04413156f, -0.02606701f, 0.02247763f, 
    -0.00002497f, 0.03835110f, -0.04095396f, -0.04932166f, 0.03313460f, -0.05120957f, 0.01314933f, -0.01881259f, 
    -0.03829326f, -0.04800565f, -0.03573137f, 0.00925336f, 0.04147083f, -0.01945533f, -0.05454252f, 0.01366606f, 
    0.00830655f, 0.00459890f, -0.02263074f, -0.01507700f, -0.02598628f, -0.01427881f, -0.04638730f, -0.04877192f, 
    0.03154568f, 0.01987163f, -0.01637021f, -0.01403807f, -0.02034555f, -0.03440823f, 0.03601940f, -0.02046196f, 
    -0.04197040f, 0.03411197f, -0.00700087f, -0.04598005f, -0.01943783f, 0.04036320f, -0.00630411f, -0.01442391f, 
    -0.02050322f, 0.04086069f, 0.01265854f, -0.02767754f, -0.03548783f, -0.03517064f, 0.02059893f, 0.00809976f, 
    -0.05012211f, 0.01824817f, 0.01344964f, -0.04148056f, 0.03687131f, -0.04111776f, -0.05771939f, -0.03129749f, 
    0.00849249f, -0.01294454f, 0.01133448f, 0.02590162f, -0.04237132f, -0.02410304f, -0.05478059f, 0.01870264f, 
    -0.03338775f, -0.00550737f, -0.01710110f, 0.01017651f, 0.02341298f, -0.05107950f, 0.04454530f, 0.03859873f, 
    0.01739443f, -0.03777027f, -0.03145099f, -0.02569217f, 0.00578314f, -0.02847035f, -0.04979622f, 0.03075463f, 
    0.01622143f, 0.03613913f, 0.01154728f, -0.03226255f, 0.00506303f, -0.00879386f, -0.03616932f, -0.03350825f, 
    -0.00477435f, -0.03074349f, -0.01387008f, -0.05261172f, -0.00547022f, 0.00981577f, 0.02067884f, 0.02571170f, 
    -0.01927431f, 0.03110177f, 0.01422669f, 0.00501242f, -0.02921437f, -0.05086722f, 0.00573299f, 0.00792419f, 
    -0.05101286f, -0.01769325f, 0.03377299f, 0.00183144f, -0.06040141f, 0.00882332f, -0.00021989f, -0.05331622f, 
    -0.05131541f, 0.02159212f, 0.01205740f, 0.03399344f, -0.05027464f, -0.03156257f, 0.02743567f, -0.05703358f, 
    -0.05054056f, 0.02644863f, -0.01139685f, -0.04957953f, 0.01156387f, -0.04348673f, 0.02420258f, -0.01410750f, 
    0.00771227f, -0.05005591f, 0.02812426f, 0.03261168f, 0.01906015f, -0.00270279f, -0.01307153f, 0.01418073f, 
    0.02529207f, -0.02786513f, -0.00770179f, 0.03766840f, -0.00690821f, 0.02311850f, 0.01975277f, -0.00716949f, 
    0.01033028f, 0.00255608f, -0.00603070f, 0.03383355f, 0.01051924f, -0.04729034f, 0.04125516f, -0.04593541f, 
    -0.01389115f, -0.02831248f, -0.00986324f, 0.00018162f, -0.03042596f, -0.04815787f, -0.00732220f, -0.04109503f, 
    0.02103554f, 0.03154625f, -0.02438051f, -0.04305822f, -0.05886574f, -0.05786719f, 0.02639945f, -0.05605659f, 
    0.02076072f, 0.02661576f, -0.04354367f, 0.03657597f, 0.00673177f, 0.00840032f, -0.03064617f, 0.03690567f, 
    0.04059127f, -0.03628092f, -0.04204128f, 0.02407608f, 0.02728458f, -0.01564552f, 0.03602503f, -0.01048303f, 
    -0.04664634f, -0.00912176f, -0.04541891f, -0.01388700f, 0.00767889f, 0.03570270f, -0.02422269f, 0.00632293f, 
    0.01558989f, 0.00404561f, 0.03614161f, -0.00586691f, 0.03590167f, -0.00634654f, -0.04524257f, -0.01105262f, 
    0.01310690f, 0.02372452f, 0.02066280f, 0.00923959f, -0.04347006f, 0.02517341f, -0.00903666f, -0.04565593f, 
    0.02257553f, -0.01891678f, -0.00396423f, -0.04179721f, 0.03218129f, -0.03795711f, 0.03908411f, -0.01904120f, 
    0.01992917f, -0.01016126f, 0.02756422f, -0.01364581f, -0.05085724f, 0.01378932f, -0.00025064f, -0.05243549f, 
    0.00852059f, 0.02854147f, 0.03800905f, 0.04150358f, 0.01502979f, -0.03578624f, 0.04066478f, 0.03650523f, 
    0.01052796f, 0.00618731f, -0.01947422f, -0.01152564f, -0.04103787f, 0.03862628f, -0.02905995f, 0.04003453f, 
    -0.00219731f, 0.01142635f, 0.01176850f, 0.02437711f, 0.03654496f, -0.02239761f, 0.01362994f, -0.03596274f, 
    -0.01786105f, 0.03033280f, -0.03799714f, -0.00667154f, -0.03008271f, -0.01830723f, -0.02931364f, 0.02048532f, 
    -0.02200186f, -0.01082830f, -0.00459222f, 0.04251000f, 0.04227812f, -0.01913436f, 0.00966954f, -0.04113203f, 
    -0.02514580f, -0.05459142f, -0.02243593f, 0.02812814f, 0.00686295f, -0.01415989f, -0.01641674f, -0.02368266f, 
    0.03658821f, -0.00438106f, -0.05529967f, -0.03157635f, -0.00537582f, 0.02634668f, -0.02017658f, 0.00836017f, 
    0.03972535f, 0.01197140f, 0.04185826f, -0.04566032f, -0.04338552f, 0.02770114f, -0.00064320f, 0.01353889f, 
    0.02882261f, -0.01295295f, -0.00662813f, -0.00721121f, 0.02293236f, 0.00614133f, 0.01940548f, -0.01697457f, 
    -0.01091476f, -0.05203518f, 0.02270029f, -0.04963642f, 0.03556737f, -0.02641704f, -0.03987832f, -0.02423113f, 
    -0.05531396f, -0.03852208f, 0.04165411f, -0.00361185f, -0.04091242f, 0.00038105f, -0.05066379f, -0.01278798f, 
    0.03562600f, 0.00040303f, 0.01290772f, -0.00406138f, -0.02619082f, -0.03124827f, -0.02150382f, -0.00042658f, 
    0.00187218f, 0.03667947f, -0.01825238f, -0.04402891f, -0.01313865f, 0.02030463f, -0.00136112f, 0.01606058f, 
    -0.03474914f, -0.04612890f, -0.01067598f, 0.01569308f, -0.03310953f, 0.00404542f, 0.01116693f, -0.04685294f, 
    -0.03462796f, -0.00614837f, -0.03480401f, 0.00024361f, -0.00423891f, -0.03418389f, -0.02891401f, -0.05733812f, 
    -0.01829361f, -0.03168591f, -0.03787451f, 0.00366604f, -0.02366884f, 0.01289908f, -0.02332577f, -0.02849554f, 
    -0.02507921f, 0.02838346f, -0.05027407f, -0.00805927f, 0.00050348f, 0.02374062f, 0.00547545f, 0.03545370f, 
    0.01006799f, 0.02917415f, 0.01929080f, 0.03070785f, -0.02871380f, 0.00481473f, -0.01983977f, 0.02321152f, 
    0.52609605f, 0.48523694f, 0.43803504f, 0.37193662f, -0.01785794f, 0.03940816f, 0.11700853f, 0.08273133f, 
    0.07464643f, -0.00721023f, -0.09228358f, -0.05435339f, -0.10224706f, -0.05900801f, -0.09309539f, 0.12576492f, 
    0.07288607f, -0.04336511f, 0.06815149f, 0.05957945f, 0.09336367f, 0.01607384f, -0.04278107f, 0.05993008f, 
    -0.24149571f, -0.22305375f, -0.15171346f, 0.00123465f, -0.04843162f, -0.04791632f, 0.18769610f, 0.06645547f, 
    0.06888708f, -0.06321630f, -0.13634293f, 0.02075706f, 0.28191337f, 0.30735561f, 0.18925440f, 0.08366179f, 
    -0.07678594f, 0.08260554f, -0.02078179f, 0.05077649f, 0.01419863f, -0.07607530f, -0.09169964f, 0.15548250f, 
    -0.28315458f, -0.21619174f, -0.14386323f, 0.10805820f, -0.01905877f, 0.16011284f, -0.00314908f, 0.03765336f, 
    -0.00886819f, 0.06445667f, -0.12141053f, 0.14945842f, 0.32084090f, 0.30221066f, 0.17563231f, -0.05671249f, 
    0.13926175f, 0.02367926f, 0.11605745f, 0.21410091f, 0.03695036f, -0.08817142f, -0.12967080f, -0.04039763f, 
    -0.04356799f, -0.16105148f, -0.13114025f, -0.13381140f, 0.00551502f, 0.08347142f, 0.04614931f, 0.05198851f, 
    -0.00525345f, -0.09766196f, -0.00237877f, -0.14050964f, 0.30863494f, 0.15867490f, 0.06741394f, 0.25187892f, 
    0.11363016f, 0.10095748f, 0.20248064f, 0.07147903f, 0.16649835f, -0.00732039f, 0.03836655f, -0.10085998f, 
    -0.31081578f, -0.32014152f, -0.20987357f, -0.00793026f, 0.09311178f, 0.10572010f, -0.21903871f, -0.16633792f, 
    0.23973447f, 0.03058169f, 0.09159558f, 0.14948504f, 0.19631255f, 0.26605049f, 0.11528653f, 0.04229151f, 
    0.19369574f, 0.09452508f, 0.13718107f, 0.09367269f, -0.05408801f, -0.00394915f, 0.04456736f, 0.02180608f, 
    0.14187284f, -0.33567852f, -0.21162148f, -0.23598588f, -0.08618812f, -0.09729812f, -0.00321108f, -0.04384861f, 
    -0.08742058f, 0.05247229f, -0.07266873f, -0.09965489f, 0.24044514f, 0.06650968f, -0.07059737f, 0.06124289f, 
    0.00023117f, -0.08239917f, -0.05514606f, -0.11268954f, 0.00537202f, -0.06689006f, 0.00205602f, -0.25912583f, 
    -0.10077593f, -0.10081543f, -0.07422332f, 0.14654857f, -0.05941833f, 0.03940809f, 0.16348678f, 0.11763912f, 
    0.05741310f, 0.11756319f, 0.00630174f, 0.27657676f, -0.10534254f, 0.12472995f, 0.07716012f, 0.06077047f, 
    0.07004219f, 0.06317092f, 0.20891328f, 0.09659093f, 0.12735118f, 0.29876706f, 0.12138162f, 0.30672923f, 
    0.34699598f, 0.15946019f, -0.01452832f, -0.26661375f, -0.08990283f, -0.18157925f, -0.00510794f, 0.27321815f, 
    0.05051340f, -0.09802575f, -0.00431856f, -0.01086309f, -0.13198304f, -0.36106324f, -0.06862086f, 0.11937255f, 
    -0.04532294f, 0.08752081f, -0.01494854f, -0.15352915f, 0.14301723f, 0.10463985f, -0.19908826f, -0.02372851f, 
    0.26490617f, 0.23288737f, 0.12301528f, 0.14396964f, 0.04797564f, 0.16326280f, -0.08069111f, 0.16923955f, 
    -0.00262726f, -0.06797986f, 0.08480608f, 0.07696745f, -0.05885456f, -0.50751847f, -0.38973764f, -0.09151626f, 
    0.06820546f, -0.03090686f, 0.02581226f, -0.03873483f, -0.04017294f, 0.03578893f, 0.12400832f, -0.09472509f, 
    -0.52823186f, -0.11671515f, 0.12426110f, -0.06320439f, -0.06079231f, 0.00874337f, 0.03288463f, -0.10217681f, 
    0.14312042f, -0.01205529f, 0.04354174f, 0.07257006f, -0.04041194f, -0.31042218f, 0.02349092f, -0.30346924f, 
    -0.19903842f, 0.08964980f, 0.04359390f, 0.17035082f, 0.00516636f, -0.18171600f, 0.02389627f, 0.00599539f, 
    -0.14428596f, -0.25200501f, -0.10640898f, -0.45341167f, 0.07129841f, -0.07913934f, -0.05818617f, -0.01930602f, 
    -0.05319344f, 0.03039375f, 0.13442884f, 0.08773398f, -0.07275505f, -0.01096755f, 0.24823079f, -0.00629740f, 
    0.07534598f, 0.17126833f, -0.08033408f, -0.17240733f, 0.01671844f, 0.13910264f, -0.22440057f, 0.06030043f, 
    0.35858712f, 0.20004401f, 0.11458631f, 0.06483895f, -0.09059668f, 0.02231255f, 0.16105583f, 0.05629553f, 
    -0.09210835f, -0.13804053f, -0.06632289f, -0.12278030f, 0.19050147f, 0.26078200f, 0.14403185f, 0.08095980f, 
    0.04812253f, 0.04938731f, -0.09471037f, -0.01822418f, -0.05568843f, -0.02851862f, 0.07123692f, 0.23198265f, 
    0.37891722f, 0.10345795f, -0.09911730f, 0.09149018f, 0.09719904f, -0.02164466f, 0.16781814f, -0.16834731f, 
    0.05449034f, -0.02928148f, -0.04963979f, 0.00719826f, 0.16367885f, 0.33517370f, 0.02744979f, 0.02902939f, 
    0.14231522f, 0.01802568f, 0.05171057f, 0.07638292f, -0.05170526f, -0.02000292f, 0.19236341f, 0.11042958f, 
    0.01837820f, -0.10091555f, 0.36947381f, 0.16325670f, 0.04183865f, 0.13516849f, 0.17292432f, -0.06240127f, 
    0.06293295f, -0.08877561f, -0.10605617f, -0.11959082f, 0.05573033f, -0.26342827f, -0.14472620f, -0.08106325f, 
    0.07258838f, 0.09518056f, 0.04806817f, 0.10588361f, 0.04564012f, 0.07296052f, 0.03730979f, -0.19059196f, 
    0.24375802f, 0.03480297f, 0.10805162f, 0.00850128f, -0.22402588f, -0.13018528f, -0.12120084f, -0.03522368f, 
    -0.00096638f, 0.04218280f, -0.00206848f, 0.08800596f, -0.30472338f, -0.30920199f, -0.15956990f, 0.17407228f, 
    0.07532781f, 0.04338050f, 0.06772405f, 0.04604702f, -0.06065494f, -0.06094048f, 0.05180390f, -0.17158572f, 
    -0.02910545f, -0.09109614f, -0.12402806f, -0.47168684f, 0.11100374f, 0.02662312f, -0.02991864f, 0.12852819f, 
    0.12374639f, 0.02625874f, 0.19922899f, -0.14512634f, 0.26833081f, 0.17938785f, 0.25112811f, -0.15707250f, 
    0.17260501f, 0.01011483f, 0.07707591f, 0.05892052f, -0.10241066f, -0.24032933f, -0.05771367f, -0.11764688f, 
    0.01965717f, -0.03698891f, -0.02995590f, 0.03987377f, 0.02633908f, -0.03194645f, -0.00627913f, -0.03210634f, 
    -0.02550393f, -0.02045759f, 0.00795845f, -0.01030371f, -0.05253650f, 0.02528846f, 0.02968236f, -0.04624400f, 
    -0.02162105f, 0.00246159f, -0.04218977f, -0.01033846f, -0.05345795f, 0.02682536f, -0.01881505f, -0.03060616f, 
    -0.02769944f, -0.02569639f, 0.02468073f, -0.04683939f, 0.02188591f, -0.03066869f, 0.02019195f, -0.03052489f, 
    -0.00966683f, 0.04483493f, 0.02098114f, -0.03118517f, -0.03702223f, 0.03760177f, -0.01518977f, -0.00397970f, 
    0.03069363f, 0.03849120f, 0.03498672f, 0.00551097f, -0.04951431f, 0.02953396f, -0.00566171f, -0.01843732f, 
    -0.04270676f, -0.04417924f, 0.02053575f, -0.05329648f, -0.05094926f, 0.03839199f, -0.04944672f, -0.01056520f, 
    -0.02505476f, 0.02988196f, -0.00024595f, 0.04241207f, -0.00662745f, 0.00073567f, -0.04632040f, -0.05897345f, 
    0.03726001f, 0.00933937f, -0.01957608f, -0.02856471f, -0.04867916f, 0.04029137f, -0.03817293f, 0.00489924f, 
    0.01300898f, 0.02079760f, -0.03579278f, 0.02974652f, -0.00147587f, -0.04786474f, 0.02477654f, 0.00848169f, 
    -0.03109822f, -0.04721640f, 0.00350236f, 0.03714264f, -0.02449101f, -0.00193932f, -0.03820742f, -0.04909908f, 
    -0.03474641f, 0.02556258f, 0.01706948f, -0.03995699f, 0.00399628f, 0.01721841f, -0.02079704f, -0.02212509f, 
    -0.03893360f, 0.03154764f, -0.00995926f, 0.03026398f, -0.00431326f, -0.04625934f, -0.04394621f, -0.00388034f, 
    -0.04259823f, 0.03423053f, -0.03531999f, 0.02607468f, 0.02028081f, -0.04343558f, -0.03724120f, 0.00364597f, 
    0.00106000f, 0.02664082f, 0.03514659f, -0.04166047f, 0.03574723f, -0.02926603f, 0.00788618f, -0.01236241f, 
    -0.00961329f, 0.04505546f, 0.01691605f, 0.04118761f, -0.00300530f, -0.04468093f, 0.02389677f, 0.03170487f, 
    0.01644995f, 0.01178361f, -0.03402169f, -0.02455498f, 0.01653695f, -0.05134290f, 0.03497443f, 0.02049916f, 
    0.02641152f, -0.02794803f, 0.02139670f, -0.01189554f, 0.03762952f, -0.03246414f, 0.01056749f, 0.01669606f, 
    0.00216656f, -0.01597544f, 0.03154808f, -0.02496218f, -0.04930101f, -0.04696062f, -0.04915871f, -0.00586445f, 
    0.00628091f, 0.01987742f, 0.04203084f, -0.00644091f, -0.02575537f, -0.05778774f, -0.02728493f, 0.04545793f, 
    0.01989710f, -0.04142159f, 0.01746782f, 0.00587562f, -0.04484149f, -0.03234340f, -0.04962867f, 0.01290329f, 
    -0.02879510f, 0.01776043f, 0.00266700f, -0.01359942f, -0.01239180f, 0.01136365f, 0.02565290f, -0.04122281f, 
    -0.02297241f, -0.01067349f, -0.04193342f, -0.00238658f, 0.01959305f, -0.02234135f, -0.02648609f, 0.04446800f, 
    -0.05603376f, -0.04482067f, -0.03794067f, 0.02376042f, -0.01548473f, -0.03265503f, -0.00989088f, -0.03448076f, 
    -0.02527305f, 0.02863245f, -0.05335500f, -0.04643294f, 0.02591157f, 0.03159064f, -0.04794173f, -0.01723395f, 
    -0.01166903f, -0.00309409f, -0.03954358f, -0.04037930f, -0.02524750f, 0.01774254f, -0.05641240f, 0.00327747f, 
    -0.00698932f, 0.00393977f, -0.05518567f, 0.03187885f, -0.03026680f, 0.00481351f, 0.01180400f, 0.02975904f, 
    0.01802776f, -0.05234731f, -0.02251011f, -0.03121739f, -0.03743175f, 0.03395054f, -0.03750802f, 0.03614568f, 
    -0.00288192f, 0.00334559f, -0.05099519f, -0.02888078f, -0.00532378f, -0.01866168f, 0.00206492f, 0.04691133f, 
    0.01844526f, -0.02499500f, -0.03488173f, -0.03516655f, 0.04524212f, -0.01959751f, 0.00431433f, 0.04219490f, 
    0.01817025f, 0.03092937f, 0.02408429f, -0.05607013f, 0.02178722f, 0.03352294f, 0.02623301f, -0.03347603f, 
    -0.04314292f, -0.03663790f, 0.03177442f, -0.04918170f, -0.02014674f, 0.02659244f, 0.02191618f, -0.01843200f, 
    0.03978565f, -0.01316924f, -0.01411283f, -0.05921720f, -0.02785784f, 0.02659849f, -0.01045621f, -0.02407282f, 
    -0.03553759f, -0.04485533f, -0.03090631f, -0.03198566f, -0.03092312f, -0.01360909f, -0.03006821f, -0.04876216f, 
    -0.05559983f, -0.02937864f, -0.00388170f, -0.01844304f, 0.02604450f, -0.02126575f, 0.00332094f, 0.03795520f, 
    0.01859644f, -0.01755787f, 0.01096178f, 0.01594967f, 0.01047023f, -0.01809160f, 0.02843927f, 0.00703349f, 
    0.00142525f, 0.02903597f, -0.04789436f, 0.00417798f, -0.05074862f, 0.02805328f, 0.00477879f, -0.00360487f, 
    0.00074777f, -0.03404805f, 0.04248317f, 0.03003111f, 0.02556034f, -0.02916770f, -0.02598907f, -0.02520393f, 
    0.04078117f, 0.03329602f, -0.00164766f, -0.04563507f, -0.02283122f, -0.00915064f, 0.03365842f, -0.03298751f, 
    0.03555330f, -0.02601675f, 0.02587209f, 0.01501011f, 0.02376931f, -0.01847588f, -0.01935395f, -0.04063766f, 
    -0.00176484f, -0.00226042f, 0.02419286f, 0.00685712f, 0.01887972f, 0.01242998f, -0.04837045f, -0.00909234f, 
    0.03942772f, -0.03313572f, -0.01288055f, -0.02047419f, -0.05026425f, -0.01952759f, -0.02202188f, 0.04677008f, 
    -0.01003027f, 0.00616572f, -0.04514750f, 0.01647074f, 0.02119624f, -0.03732556f, -0.03908557f, 0.01590327f, 
    0.02400131f, -0.03013422f, -0.01497292f, 0.01925021f, -0.02638241f, -0.00054530f, 0.02663237f, 0.03158042f, 
    0.00787161f, 0.01694641f, -0.00485821f, -0.04077831f, -0.04757647f, 0.03971081f, 0.01059939f, 0.03813696f, 
    0.03685762f, 0.00426467f, 0.03705508f, 0.00157454f, -0.02371864f, -0.01250570f, -0.01284812f, 0.04004254f, 
    -0.05313585f, -0.05591452f, -0.04788387f, 0.00769128f, 0.03972303f, 0.00103253f, -0.02908525f, 0.03115313f, 
    -0.01919030f, 0.01781615f, 0.00092228f, 0.03094018f, -0.03710900f, 0.01410463f, -0.04323024f, -0.04465906f, 
    -0.16586021f, -0.07855897f, 0.00017450f, 0.04074026f, 0.08293514f, 0.04046018f, 0.12017599f, 0.04596931f, 
    -0.01098427f, -0.10767233f, -0.08459686f, -0.02991922f, -0.13079014f, -0.08653556f, -0.03809354f, -0.19641130f, 
    0.04830352f, 0.02205811f, -0.08383494f, 0.01596971f, -0.03807922f, -0.08245283f, 0.03774354f, -0.00154311f, 
    -0.03650547f, -0.18751435f, -0.18070357f, 0.25579116f, 0.04477543f, -0.04935050f, -0.03076450f, 0.01907191f, 
    0.18450816f, 0.03825137f, 0.04710302f, 0.01989169f, -0.30000743f, -0.30394056f, 0.15042849f, 0.03552953f, 
    0.07672752f, -0.10882588f, 0.10788032f, 0.05978109f, -0.03280843f, 0.02535851f, 0.08120188f, 0.17799702f, 
    0.10186176f, -0.21571843f, 0.00818958f, 0.07416578f, 0.11445363f, -0.10563920f, 0.00991507f, -0.04051883f, 
    0.02678967f, -0.00831609f, 0.33563131f, -0.12355456f, -0.16192174f, -0.14881375f, 0.13441509f, 0.05711911f, 
    0.00751046f, 0.09565578f, -0.03749814f, -0.05446782f, 0.12276825f, 0.05414324f, 0.03435569f, 0.07519048f, 
    -0.04837998f, 0.06996638f, 0.12864451f, -0.12685245f, -0.04364033f, 0.11681783f, -0.08539359f, 0.04449926f, 
    0.01452082f, -0.03716737f, 0.12423684f, 0.01359496f, -0.28088799f, -0.20570165f, 0.02052538f, 0.04804157f, 
    -0.05665911f, -0.04083948f, -0.13387688f, 0.00774488f, 0.04465190f, -0.01003364f, 0.05344572f, 0.00539288f, 
    -0.10524461f, 0.06061449f, 0.15957227f, -0.21698168f, -0.01265723f, 0.02539505f, -0.09828320f, 0.14257759f, 
    0.00154689f, 0.05359782f, 0.08617739f, -0.20049749f, -0.16042106f, -0.06735098f, 0.04760577f, 0.05039986f, 
    -0.04185794f, 0.05586854f, 0.02228333f, 0.01773134f, 0.00782821f, -0.00198508f, -0.03292716f, -0.06837470f, 
    -0.35455179f, 0.14803568f, 0.06166126f, -0.02011081f, 0.12602532f, 0.02370063f, -0.03318064f, 0.03378513f, 
    -0.01507873f, -0.09719362f, 0.16537429f, 0.01037453f, -0.22622484f, -0.05457122f, 0.01236598f, -0.00565442f, 
    0.01384708f, 0.07411482f, -0.22495340f, 0.16808963f, 0.01152140f, -0.11203464f, -0.10091043f, 0.08631479f, 
    -0.16793483f, -0.14149852f, -0.11125627f, -0.15492965f, 0.17853646f, -0.00846867f, -0.03709874f, -0.02904904f, 
    0.09108256f, -0.01659569f, -0.07928032f, -0.06657134f, 0.38840026f, -0.29613262f, -0.02912324f, -0.04333176f, 
    0.04447769f, -0.12817070f, 0.09611902f, 0.02774577f, 0.01808303f, -0.22548132f, 0.01250576f, -0.12310298f, 
    -0.06066055f, 0.07567652f, 0.49475950f, 0.49875242f, -0.13579094f, 0.14963423f, 0.19694017f, -0.17036334f, 
    -0.01697134f, 0.06693936f, -0.00789371f, -0.13432929f, 0.18785624f, 0.07174649f, -0.20450108f, 0.06062336f, 
    -0.03225264f, -0.14147955f, -0.00284053f, 0.16221090f, 0.18496248f, 0.07453574f, 0.22155184f, 0.01394170f, 
    -0.35478041f, 0.01233592f, 0.00881980f, -0.02301825f, 0.03817774f, -0.04581784f, 0.18816704f, 0.06544323f, 
    0.11866333f, -0.07324190f, -0.14803503f, 0.09162737f, 0.23962566f, -0.00262013f, -0.00127601f, 0.01389729f, 
    -0.02383005f, 0.07081565f, -0.05546132f, 0.05922860f, 0.08542117f, 0.06614519f, -0.00294291f, -0.01126102f, 
    0.55026734f, -0.09665406f, -0.18603791f, 0.11246098f, 0.32559699f, -0.01604616f, 0.08539180f, 0.07758374f, 
    -0.02824059f, 0.06462958f, 0.13667157f, 0.06662737f, -0.08830014f, -0.02518408f, 0.00628804f, 0.18306889f, 
    0.24484088f, -0.07936980f, -0.05487348f, 0.11449790f, 0.09186866f, 0.19058600f, 0.20658556f, 0.21076052f, 
    -0.24295864f, 0.27568778f, -0.09256777f, -0.20646945f, -0.06544156f, -0.09067371f, 0.02333111f, 0.24683370f, 
    0.09834684f, 0.15940504f, 0.07509175f, -0.21195316f, 0.04621888f, 0.19072597f, -0.09513613f, 0.17977245f, 
    -0.07366358f, -0.09329275f, 0.22734801f, 0.12920861f, -0.11665854f, 0.01422238f, -0.01518200f, -0.18481855f, 
    -0.14630261f, -0.06158050f, 0.01169535f, 0.08896744f, 0.02118282f, -0.15701762f, 0.00298981f, -0.16271299f, 
    0.12627503f, 0.22938143f, -0.07679400f, 0.12029535f, -0.21994911f, -0.07049685f, 0.07979074f, -0.12629884f, 
    -0.06565075f, 0.04095336f, -0.08696771f, 0.04467293f, 0.11247665f, 0.01560793f, 0.07551374f, 0.06769998f, 
    -0.22456048f, -0.12116999f, 0.12403813f, 0.14902577f, -0.00283761f, 0.04777119f, 0.01495283f, 0.23334530f, 
    0.01422702f, 0.13756101f, -0.01920046f, 0.04620657f, -0.02768848f, 0.08428369f, 0.03815956f, 0.09994551f, 
    0.07177898f, -0.01289889f, 0.07014610f, 0.05968062f, 0.05679000f, 0.02872739f, -0.00065278f, 0.00172311f, 
    -0.19727665f, 0.23893909f, -0.15908742f, 0.38393220f, 0.09835807f, -0.06010129f, -0.01711814f, -0.02041155f, 
    0.05221999f, 0.13065818f, 0.04637363f, 0.15801601f, -0.34119397f, -0.10692133f, -0.19135298f, 0.00089845f, 
    -0.00468368f, -0.13359971f, -0.01753383f, -0.10930090f, 0.05897491f, -0.07423131f, -0.06073663f, 0.04352469f, 
    -0.35843936f, 0.20478782f, 0.09705830f, -0.07211716f, 0.12198479f, 0.24920660f, 0.10412130f, 0.13413203f, 
    0.17632683f, 0.02097027f, 0.05105211f, 0.04097566f, 0.10217670f, 0.15199046f, 0.03031417f, -0.07185345f, 
    -0.10036641f, -0.03215720f, -0.13001521f, -0.08475076f, 0.03665147f, 0.08266163f, 0.00530883f, 0.06588150f, 
    0.09958345f, -0.08303790f, 0.10102382f, 0.16558422f, -0.02599966f, 0.10587063f, 0.12012304f, -0.10252179f, 
    -0.15617947f, -0.02630440f, 0.22070201f, 0.04632211f, -0.12083961f, 0.04164398f, -0.01020932f, 0.15826797f, 
    -0.06978296f, 0.01440979f, -0.08053597f, 0.18376251f, 0.08741128f, 0.08434195f, 0.13253678f, -0.01917656f, 
    -0.11042416f, 0.08362474f, 0.07499167f, 0.24291068f, 0.05947590f, -0.02069201f, 0.11995674f, 0.10233396f, 
    -0.07380057f, -0.05857150f, -0.10395566f, -0.02107242f, 0.02921011f, -0.04287280f, 0.01905482f, 0.03513161f, 
    0.15671016f, 0.03536236f, 0.01791228f, 0.01107269f, 0.02616106f, 0.00604997f, -0.03117418f, 0.04299945f, 
    -0.08842591f, 0.15279387f, -0.15780979f, 0.00149504f, -0.03667294f, 0.07391277f, 0.00277754f, 0.07683424f, 
    0.18615741f, -0.06915473f, 0.03143110f, 0.26431778f, -0.20073532f, -0.02846722f, -0.29849130f, 0.21153377f, 
    0.15129745f, 0.02811826f, -0.01982678f, -0.21672632f, 0.04814504f, -0.02063786f, -0.03930913f, -0.08768805f, 
    -0.07576445f, 0.01029061f, 0.08824990f, 0.07854132f, 0.02216341f, 0.00155429f, -0.02144889f, 0.03762500f, 
    0.25394291f, 0.28045779f, 0.06074536f, 0.13541846f, -0.12892507f, -0.07065100f, -0.13173163f, 0.16627230f, 
    0.00243424f, 0.04400948f, 0.16763435f, 0.05035536f, 0.05820973f, 0.10962200f, 0.03863344f, 0.09906687f, 
    0.15923840f, -0.00329693f, -0.03271223f, 0.16282129f, 0.01027750f, 0.01932273f, -0.10544267f, -0.02193248f, 
    0.00714872f, 0.09849685f, 0.07076596f, 0.13816015f, -0.15917569f, -0.08782671f, -0.26411581f, -0.05426405f, 
    -0.06789421f, 0.01500598f, 0.04405050f, 0.02820425f, -0.00435135f, -0.02314105f, 0.11651171f, -0.04275094f, 
    -0.05282034f, 0.04053496f, 0.00692853f, 0.18851289f, -0.10637721f, -0.00768891f, -0.05787698f, 0.02592456f, 
    -0.01852712f, 0.03200303f, -0.00509996f, 0.00035959f, 0.02619240f, -0.07376466f, 0.08325606f, 0.12817146f, 
    -0.08278511f, -0.11447926f, -0.25451484f, -0.11296058f, 0.03068928f, 0.02578979f, -0.12991634f, -0.13020444f, 
    0.31228378f, -0.00858618f, 0.08279618f, 0.03924741f, -0.02605561f, 0.00883181f, -0.04161144f, 0.03223773f, 
    -0.04544230f, 0.26889619f, -0.08529190f, 0.15511650f, 0.12781526f, -0.02703673f, 0.06426056f, 0.10716073f, 
    0.14634068f, -0.06517964f, -0.18827838f, -0.07400326f, -0.02617221f, -0.03274973f, -0.03367274f, 0.14014997f, 
    -0.24426915f, -0.05794485f, 0.03170962f, 0.07003994f, -0.07216620f, -0.02390381f, -0.08964808f, -0.01142017f, 
    -0.24186520f, -0.11050177f, -0.23929986f, -0.11482198f, -0.22598431f, 0.10346932f, -0.09164049f, -0.10650650f, 
    -0.08363414f, 0.02404377f, 0.02481185f, -0.17458875f, -0.17288566f, 0.00208424f, -0.18615787f, -0.34070277f, 
    -0.33665204f, -0.01347152f, -0.28789365f, -0.01138654f, 0.23427561f, -0.04814004f, -0.01181044f, -0.02844678f, 
    -0.16245642f, -0.06542410f, -0.06033833f, 0.06785125f, -0.16502720f, 0.07910882f, 0.11575399f, -0.03014435f, 
    0.07345830f, 0.03031165f, 0.01694879f, 0.09745461f, 0.18075484f, 0.16235685f, -0.05457969f, 0.15303044f, 
    0.07852835f, -0.02726573f, -0.05086496f, 0.27745980f, 0.10470033f, -0.05921895f, -0.09832395f, -0.15506785f, 
    -0.15619040f, -0.05289870f, 0.04371802f, -0.03182187f, 0.22838406f, 0.03559474f, 0.06325080f, -0.02831537f, 
    -0.03656396f, 0.01661289f, 0.01426745f, 0.04392383f, 0.03422292f, 0.07590266f, -0.04337959f, 0.09684871f, 
    -0.01296800f, 0.23251681f, 0.14748693f, 0.03883860f, -0.07547317f, -0.07571930f, 0.09340140f, 0.01818364f, 
    -0.02896377f, -0.00621072f, 0.05264973f, 0.03787930f, 0.12671195f, -0.09695894f, -0.03046056f, 0.23578532f, 
    0.01798481f, 0.01266353f, -0.12772456f, -0.01909412f, 0.49173149f, 0.12877782f, 0.36813727f, 0.04542378f, 
    0.21815680f, -0.00946725f, 0.23103489f, -0.12119072f, -0.06445556f, -0.04924402f, -0.15304227f, 0.03114904f, 
    0.09302314f, 0.03699695f, -0.15250288f, -0.12950666f, -0.29969701f, -0.12952511f, 0.10221203f, -0.18614909f, 
    -0.00883256f, 0.15707207f, 0.13796964f, 0.02344724f, 0.06055875f, 0.06653474f, -0.01255345f, -0.03597011f, 
    -0.17003025f, 0.02830123f, 0.12641093f, 0.19044162f, 0.10572922f, 0.02361310f, 0.15093751f, 0.16039926f, 
    0.12469766f, 0.11083382f, 0.00822676f, -0.15403660f, 0.09636091f, 0.21293235f, 0.19543345f, 0.02052001f, 
    0.04647100f, -0.12885524f, -0.11699115f, 0.05636996f, 0.11924247f, 0.04336557f, -0.13477217f, -0.07121913f, 
    -0.24396113f, -0.05657917f, 0.01293771f, -0.09202154f, 0.06111687f, 0.08011561f, 0.06236443f, -0.08245523f, 
    0.08811428f, 0.10088637f, 0.11742768f, 0.00382331f, 0.10103684f, -0.16929162f, 0.24702585f, 0.06361216f, 
    0.04803197f, 0.02762067f, 0.00286805f, 0.00323343f, -0.05142652f, 0.01119130f, -0.05546569f, -0.03150699f, 
    -0.38433480f, 0.18974076f, 0.29710078f, 0.18181191f, -0.15507208f, -0.10602461f, 0.08497345f, 0.09931249f, 
    0.27609655f, -0.16225313f, 0.06824717f, 0.02871467f, -0.02481964f, 0.10824401f, 0.07722855f, 0.08355838f, 
    -0.05449962f, -0.02996342f, 0.00418371f, -0.04724452f, 0.09104495f, 0.15642411f, 0.15482906f, 0.28474823f, 
    -0.01193319f, -0.00381424f, 0.11033781f, -0.15144823f, -0.20604746f, 0.12917432f, -0.08473235f, 0.11403994f, 
    0.23180309f, -0.09033967f, -0.15262745f, 0.07628071f, -0.08792141f, 0.09791925f, 0.19127642f, 0.06750867f, 
    0.01301934f, -0.04343784f, -0.04641331f, -0.06555720f, 0.00765077f, 0.07961334f, 0.10369676f, 0.23474446f, 
    0.10059980f, 0.12262491f, -0.05472562f, 0.08814293f, 0.20303470f, -0.04348055f, 0.07455220f, 0.04890187f, 
    -0.03450314f, 0.19582179f, -0.19332948f, 0.20018515f, -0.23027736f, -0.08673064f, -0.04968056f, 0.20344290f, 
    -0.02287718f, 0.25247639f, 0.16326801f, 0.03562831f, 0.14114815f, 0.10728962f, 0.15028919f, 0.01222218f, 
    -0.23422523f, -0.50532490f, -0.09619578f, -0.00886790f, 0.07739513f, -0.04061471f, -0.15941611f, -0.07295660f, 
    -0.03144033f, -0.07391227f, -0.10643979f, -0.06104199f, -0.09045196f, -0.06240842f, 0.03659342f, -0.06594462f, 
    -0.06962924f, 0.04001443f, -0.06187872f, -0.05253499f, -0.07479841f, -0.04055303f, 0.00153387f, 0.01570303f, 
    0.23793925f, -0.00746999f, -0.18850277f, 0.04426593f, 0.09479001f, 0.03498465f, -0.05910619f, 0.01624727f, 
    0.03630877f, 0.34431255f, 0.10140837f, 0.09438470f, -0.00824339f, -0.23379056f, -0.05378964f, -0.01220684f, 
    0.08633850f, 0.05835495f, 0.09193717f, 0.04447326f, 0.00183806f, -0.01899182f, 0.12182225f, 0.10189344f, 
    0.15727209f, -0.01098175f, 0.07071556f, -0.16776492f, -0.14991102f, -0.00382507f, 0.04468299f, -0.06099556f, 
    0.17124416f, 0.03375708f, 0.10104636f, 0.14469354f, -0.29065743f, -0.20331922f, -0.01996597f, 0.08188013f, 
    0.22030124f, 0.01069911f, -0.10901595f, 0.06349103f, -0.08934774f, -0.06433418f, -0.02924219f, -0.00406726f, 
    0.00372612f, 0.12634881f, 0.03923712f, -0.03199962f, -0.03090520f, -0.02025521f, -0.06072680f, 0.00291385f, 
    -0.13397069f, 0.02282794f, -0.07248023f, 0.03778267f, -0.34605503f, -0.16759013f, 0.29046103f, -0.00292939f, 
    -0.00739409f, -0.07050829f, 0.04482525f, 0.04602241f, 0.00982921f, 0.11136562f, -0.02336371f, 0.01065603f, 
    0.13666888f, -0.00878147f, 0.21428004f, -0.25983679f, -0.10340177f, -0.03922275f, -0.07464569f, 0.13901433f, 
    -0.01870087f, 0.07781880f, 0.12447994f, -0.06916513f, -0.17466837f, -0.22139227f, -0.05884494f, 0.18999819f, 
    -0.01036629f, 0.08579262f, -0.07060701f, 0.02398418f, 0.00055530f, -0.02172800f, -0.07381676f, -0.08063687f, 
    -0.00270871f, 0.31162682f, -0.03211230f, -0.11540352f, -0.06726958f, 0.05315994f, -0.06123318f, 0.09070096f, 
    0.08830354f, 0.01618277f, 0.34578165f, 0.03663568f, 0.09023800f, 0.04311164f, 0.03989641f, -0.04213941f, 
    -0.04938694f, 0.03901334f, 0.18559952f, -0.01540403f, -0.05324471f, 0.08167990f, -0.09357376f, -0.07734945f, 
    0.04970758f, 0.04768384f, -0.27827999f, -0.12666762f, 0.01247473f, -0.11544927f, 0.08806933f, -0.02939257f, 
    0.11204904f, 0.07595321f, 0.06970005f, 0.01976955f, 0.19733651f, -0.11604834f, -0.13613538f, 0.01098289f, 
    0.00630807f, 0.03695593f, -0.03185323f, -0.02873022f, -0.04930427f, 0.00315960f, 0.11458496f, -0.05591083f, 
    -0.35932499f, 0.35773551f, 0.22433271f, 0.15375152f, 0.01782193f, 0.15157324f, -0.14734502f, -0.10716359f, 
    0.00868192f, 0.04383050f, 0.02089418f, -0.11441813f, 0.37376806f, -0.01280975f, -0.09362470f, 0.06405298f, 
    -0.15887795f, -0.04885792f, -0.10503504f, 0.13027084f, 0.02854638f, 0.02937888f, 0.19680855f, 0.11016080f, 
    -0.04669852f, -0.27092075f, 0.23352517f, 0.15337482f, 0.23711710f, -0.01350754f, 0.02893102f, 0.05837166f, 
    -0.07853740f, 0.06291813f, 0.00254633f, -0.03313594f, 0.25093439f, 0.11663382f, 0.09206105f, -0.13043730f, 
    -0.06132799f, -0.10127334f, -0.15469687f, -0.01930777f, 0.01461419f, 0.13693647f, -0.02775264f, -0.00956108f, 
    0.42041200f, 0.24251512f, -0.18179694f, 0.10122788f, -0.14844082f, -0.07322352f, -0.00301632f, 0.01578059f, 
    -0.03367671f, 0.01920277f, 0.00964408f, 0.08724675f, -0.01982554f, 0.32039568f, -0.06800437f, -0.16452071f, 
    0.07850105f, -0.13796970f, 0.01243433f, -0.19712998f, -0.04808917f, 0.27084896f, 0.06240395f, 0.17446598f, 
    0.19360122f, 0.28763375f, 0.11490613f, 0.22410752f, -0.03699123f, -0.05951105f, 0.09711692f, -0.09480455f, 
    0.09242847f, 0.12168679f, 0.18097919f, 0.03121396f, 0.14174591f, -0.16881385f, -0.25348079f, 0.20707162f, 
    0.09935642f, 0.04623124f, 0.13366131f, 0.31193247f, 0.19397746f, 0.08971321f, 0.16001436f, -0.07373352f, 
    -0.33138585f, -0.15664539f, 0.02718328f, -0.11877093f, 0.05947723f, -0.02892054f, 0.09010266f, 0.06788735f, 
    -0.03128733f, 0.05023288f, 0.02332183f, 0.08181181f, -0.11109100f, 0.16853298f, 0.15069298f, 0.26049232f, 
    0.03385435f, 0.00946069f, 0.11759431f, -0.03237068f, 0.14634643f, 0.09828050f, 0.18707171f, 0.17252259f, 
    -0.15960597f, -0.14866586f, 0.05375922f, 0.20132506f, 0.04541392f, -0.00963445f, 0.08218478f, 0.11154344f, 
    0.08193617f, 0.15197013f, 0.01583107f, 0.00162341f, -0.18075037f, -0.30928099f, 0.00828986f, -0.03944214f, 
    0.11045877f, 0.10968950f, -0.05916174f, -0.02658518f, 0.08046848f, 0.02638571f, -0.01897914f, 0.08620605f, 
    -0.14635628f, 0.15366314f, -0.06318074f, -0.21844918f, 0.00648447f, 0.07861021f, -0.02874674f, 0.03804776f, 
    -0.13769723f, 0.18444666f, 0.01754726f, 0.13302107f, -0.10151953f, -0.02005096f, -0.10267355f, -0.07165993f, 
    -0.05029784f, 0.03550278f, 0.06608745f, 0.04857523f, -0.01144531f, 0.03346146f, 0.05297106f, 0.19105357f, 
    0.04921748f, 0.22181886f, -0.29253763f, 0.08823993f, 0.17096600f, 0.14696762f, 0.10636114f, 0.03389975f, 
    -0.04594412f, 0.10869406f, 0.09535209f, 0.04960459f, 0.35320812f, 0.03061902f, -0.00940997f, -0.12713310f, 
    -0.14674574f, -0.12634680f, 0.00944386f, 0.10469607f, -0.00695131f, 0.10741499f, 0.20169190f, 0.04835723f, 
    -0.12590228f, 0.15802203f, 0.25477290f, 0.01732179f, -0.01734201f, 0.13407624f, 0.01492639f, 0.07034824f, 
    0.04450717f, 0.09236985f, 0.13137658f, 0.02780941f, -0.22035098f, -0.14428705f, -0.24783842f, 0.07317715f, 
    -0.02813876f, -0.00508127f, -0.05485808f, -0.02967122f, -0.07285371f, 0.09002426f, 0.00728473f, -0.07494336f, 
    -0.01765115f, 0.00468550f, 0.01145578f, 0.00985850f, -0.01374946f, 0.03596396f, -0.04527606f, 0.01849758f, 
    0.03455399f, 0.00759917f, -0.05146347f, -0.03633190f, -0.03769647f, -0.02324731f, 0.04086236f, -0.04940453f, 
    -0.03363296f, -0.04543852f, 0.01527247f, 0.01655722f, -0.03830138f, -0.01089638f, -0.03530061f, 0.01024884f, 
    -0.03355365f, -0.03780013f, -0.03894720f, 0.03377752f, 0.00216029f, -0.03429527f, 0.04200429f, 0.00718406f, 
    0.00942174f, 0.03902813f, 0.00891354f, -0.00178977f, 0.03951875f, 0.03968104f, -0.04234568f, 0.01871963f, 
    0.02479833f, 0.04930802f, 0.00063080f, -0.00771252f, -0.00253738f, 0.01440019f, -0.02249349f, -0.01841286f, 
    -0.01654555f, 0.03962455f, -0.05245660f, -0.03874271f, 0.02571307f, -0.04376809f, -0.04660603f, 0.02233222f, 
    -0.05570062f, -0.05064476f, 0.00635112f, -0.04624984f, -0.03302931f, -0.00206527f, -0.04272557f, -0.00986745f, 
    -0.04471444f, 0.00518744f, -0.02708264f, -0.02590815f, -0.02486950f, -0.00736102f, 0.04932424f, 0.00601935f, 
    -0.03348300f, 0.00833837f, -0.02822357f, 0.02785965f, -0.01584275f, 0.00408349f, 0.01413723f, 0.01845925f, 
    0.00800991f, 0.04252233f, -0.02314272f, -0.01042686f, -0.00213702f, 0.04573569f, 0.04585935f, -0.00406195f, 
    -0.01477214f, 0.01638722f, -0.02354200f, -0.01527806f, 0.01082455f, 0.01851583f, -0.05545510f, 0.00975754f, 
    -0.04794143f, -0.03128726f, 0.01672345f, -0.03698054f, 0.03755683f, -0.01561361f, -0.05672961f, -0.00449023f, 
    0.03073051f, -0.01645944f, 0.01484281f, 0.00042925f, -0.03413619f, 0.01500923f, 0.03025205f, -0.00956035f, 
    -0.04943819f, -0.03944687f, -0.01013110f, -0.03313647f, -0.02220341f, -0.04162807f, -0.00237980f, 0.02575338f, 
    0.03327659f, -0.04473296f, -0.04796559f, -0.02263931f, 0.00250291f, 0.02951996f, 0.04130455f, -0.04608847f, 
    0.04183790f, -0.05009007f, 0.01902162f, -0.03841716f, -0.00570352f, -0.01983538f, 0.02648938f, 0.04346739f, 
    -0.00783500f, -0.04846803f, -0.03105080f, 0.03650515f, -0.04237804f, 0.01659120f, -0.00096055f, -0.04119292f, 
    -0.00703663f, 0.02097674f, -0.02349579f, 0.04251284f, -0.04469830f, -0.04307703f, 0.01760973f, -0.05739691f, 
    -0.03549021f, 0.00615551f, 0.04076357f, 0.00855186f, 0.02075470f, -0.01493682f, 0.01490166f, 0.00741869f, 
    0.03095008f, -0.05032852f, 0.04463935f, 0.01734613f, -0.02209089f, -0.02334398f, 0.03825573f, -0.00193286f, 
    0.03835396f, -0.04789760f, 0.00862020f, -0.04883362f, 0.02668190f, -0.02089868f, -0.01068996f, -0.02355658f, 
    0.01971850f, -0.00766784f, 0.04349589f, -0.04615495f, -0.05100774f, 0.03633371f, -0.00656022f, 0.03859171f, 
    0.03358577f, 0.03244752f, 0.03305055f, -0.01011104f, 0.01143693f, 0.04088398f, 0.02246037f, 0.00439684f, 
    -0.03792200f, -0.00505272f, -0.00025366f, 0.01017457f, -0.03523835f, 0.02593268f, -0.03997594f, -0.01875718f, 
    -0.03949912f, -0.02487158f, -0.03335803f, 0.00909073f, -0.01501523f, 0.01581086f, -0.01263010f, -0.04100989f, 
    -0.04017526f, -0.05277572f, -0.05031826f, -0.04601998f, -0.00003659f, 0.00131732f, 0.03395361f, -0.04500340f, 
    0.01325102f, 0.01829592f, -0.03452512f, -0.02038314f, 0.02770484f, 0.03387468f, -0.05341042f, 0.02431871f, 
    -0.01005351f, 0.00016884f, 0.00086026f, 0.01423012f, -0.03445732f, -0.00206333f, -0.04893753f, -0.01484134f, 
    0.02668383f, 0.00537719f, -0.05399773f, -0.04916994f, -0.00297818f, 0.01435462f, -0.02732297f, -0.03334286f, 
    -0.04596819f, -0.04672844f, 0.00249663f, 0.02546290f, -0.05044187f, 0.02478374f, -0.04627492f, -0.01537651f, 
    -0.00745248f, 0.03948915f, 0.00479601f, -0.01352399f, 0.00196916f, 0.02904369f, 0.03699434f, 0.00788720f, 
    -0.03707504f, -0.02945053f, -0.02709278f, 0.04202660f, -0.04454445f, 0.03142621f, 0.04072611f, -0.00558056f, 
    0.04024789f, -0.04792412f, 0.00620637f, -0.00943168f, -0.03208243f, -0.02603885f, 0.00512074f, 0.00121684f, 
    -0.03522750f, 0.04356497f, -0.00858563f, 0.00479367f, -0.04741135f, -0.01077142f, -0.02673551f, 0.01310758f, 
    0.03652178f, -0.03315413f, 0.02597146f, 0.04158438f, 0.02527947f, 0.02463259f, -0.00492780f, 0.04515929f, 
    -0.01700305f, 0.00973735f, -0.01382603f, 0.00451431f, 0.03974950f, 0.04035941f, 0.01811621f, -0.01154726f, 
    0.00732259f, 0.02739454f, 0.01198339f, 0.02143820f, 0.00107757f, 0.00975606f, -0.03201024f, -0.01436688f, 
    0.00642911f, 0.01927585f, -0.04097539f, 0.02000301f, -0.00914544f, 0.02429957f, 0.00393257f, -0.02293832f, 
    0.03981673f, -0.00658480f, 0.02923056f, -0.01109578f, -0.04064323f, 0.00225092f, -0.00937762f, 0.02104356f, 
    0.03422843f, 0.00793805f, 0.00263774f, -0.01382691f, -0.05219339f, 0.01304610f, -0.03134578f, -0.00634386f, 
    -0.01194520f, 0.01215134f, 0.01939901f, -0.03098143f, -0.01415860f, -0.00535241f, 0.03901186f, -0.04794597f, 
    -0.02509163f, 0.03559453f, 0.00088748f, 0.03405919f, -0.02072122f, -0.05066434f, 0.02765053f, 0.02984254f, 
    -0.01387940f, 0.00779166f, -0.00322200f, -0.03750264f, 0.03022019f, -0.04404848f, 0.01273815f, 0.03490977f, 
    -0.01640956f, 0.03552772f, -0.01841057f, -0.00465623f, -0.02292790f, 0.03895126f, -0.04280373f, 0.03251091f, 
    -0.02742751f, -0.00140099f, 0.01272003f, 0.01327591f, -0.01510101f, -0.00544081f, -0.05396802f, -0.02679514f, 
    0.01225251f, -0.04297440f, -0.00919660f, -0.04133480f, -0.03898915f, 0.03066666f, -0.04423130f, 0.01132584f, 
    0.01284872f, 0.03404223f, 0.01547447f, 0.00372633f, 0.01224138f, 0.00581792f, 0.02252046f, 0.03835282f, 
    0.03774213f, -0.01368100f, 0.02823900f, 0.02362134f, 0.02154474f, -0.03748338f, 0.04214906f, 0.03244041f, 
    -0.05682503f, 0.04888722f, -0.02005065f, -0.04455197f, -0.01240205f, -0.03517183f, -0.02154881f, 0.02563989f, 
    0.04053251f, -0.03458566f, -0.03961175f, -0.04258101f, -0.05005032f, -0.04973537f, 0.03675617f, -0.03973532f, 
    0.01908918f, -0.01891749f, 0.01799261f, -0.01418899f, -0.01378541f, -0.00432762f, 0.00519652f, 0.00313619f, 
    -0.01712424f, -0.00672170f, -0.02806781f, -0.02502739f, 0.01287839f, 0.03166861f, 0.01890216f, 0.02314907f, 
    -0.03742092f, 0.00670835f, 0.03930034f, 0.03859862f, 0.03540481f, -0.02570290f, 0.03959605f, 0.00258767f, 
    0.02478540f, -0.02961085f, 0.03662388f, -0.03471031f, 0.03391451f, -0.05314441f, 0.00678117f, 0.02794303f, 
    -0.03627428f, -0.00019152f, 0.03895790f, -0.04636478f, -0.00468574f, 0.00901876f, 0.02485694f, 0.01320635f, 
    0.02437400f, -0.00180026f, -0.03932025f, -0.03416070f, -0.03097611f, 0.00728278f, -0.01112724f, -0.05335615f, 
    0.01216859f, -0.03659433f, -0.04373338f, 0.04765325f, -0.00150198f, -0.02865903f, 0.02032326f, -0.02838830f, 
    0.00876839f, -0.03503389f, -0.01900186f, -0.01556963f, -0.03326502f, -0.03619716f, 0.03513656f, 0.04082475f, 
    -0.05331461f, -0.03239557f, -0.01929508f, 0.00181207f, 0.02950364f, -0.05076534f, -0.05564870f, 0.04361505f, 
    0.01276695f, -0.05031123f, -0.00247922f, 0.01326931f, 0.01570163f, 0.02431356f, -0.03022864f, -0.04707919f, 
    0.02034841f, 0.05036605f, -0.02974305f, -0.02601514f, 0.00294837f, 0.02102888f, -0.00351492f, 0.00009498f, 
    -0.00559143f, -0.03713831f, -0.04236197f, 0.01439050f, -0.04114316f, 0.00478073f, 0.01068262f, -0.01952512f, 
    0.03703769f, 0.01446741f, 0.00437239f, -0.00841793f, -0.00018694f, -0.03378033f, -0.03521402f, 0.03980387f, 
    -0.00815881f, -0.01685283f, 0.03532974f, -0.00319875f, -0.04604544f, -0.04012682f, -0.03681898f, -0.04680698f, 
    -0.04940364f, -0.02177996f, -0.01334824f, 0.02195678f, 0.00893151f, -0.04252454f, -0.03404645f, 0.02193974f, 
    0.00726866f, -0.03220875f, 0.03379283f, 0.01175216f, -0.03672357f, -0.00810501f, -0.00467205f, -0.00219829f, 
    0.02932823f, -0.02751028f, 0.00428870f, -0.02912341f, -0.04030436f, -0.00568057f, -0.04140548f, 0.02519666f, 
    0.02116040f, -0.01195259f, 0.04406366f, -0.00746382f, -0.04222600f, 0.01490269f, 0.03225822f, 0.03789015f, 
    0.02994599f, -0.03720284f, -0.00281969f, 0.04233782f, -0.04683442f, 0.00614822f, -0.00101722f, 0.02823263f, 
    -0.01564593f, -0.04866323f, -0.00180239f, -0.01152555f, -0.00027792f, 0.03526225f, -0.00993465f, -0.02803704f, 
    -0.00956843f, -0.04325576f, -0.01915599f, 0.00285899f, -0.00126146f, -0.01187014f, 0.01220983f, -0.02934446f, 
    -0.01988863f, 0.01599628f, 0.02035305f, 0.04319933f, -0.03245238f, -0.03676838f, -0.02578610f, -0.01327566f, 
    -0.01372844f, -0.00365305f, 0.00765113f, -0.01687638f, -0.05009163f, 0.01449539f, -0.02625030f, 0.02075361f, 
    -0.03975110f, -0.00140837f, 0.01231763f, 0.03835785f, 0.02088971f, -0.01488793f, -0.04361358f, -0.03792907f, 
    0.04481243f, -0.04508651f, -0.05029022f, -0.02938121f, -0.03177111f, 0.01451928f, -0.04515671f, -0.02307232f, 
    -0.02373156f, -0.04114693f, -0.00813160f, 0.02400744f, -0.03649081f, 0.01913323f, 0.01436159f, -0.02553944f, 
    -0.04026441f, -0.03625809f, -0.05514317f, 0.03528190f, -0.05495329f, -0.00818879f, -0.03079264f, 0.01988270f, 
    -0.01231329f, -0.04869106f, -0.04222404f, -0.00912651f, -0.02660875f, -0.04947136f, 0.00853063f, -0.00265674f, 
    0.01551343f, 0.01778415f, -0.01668842f, 0.03215344f, 0.01231504f, 0.01918587f, 0.01266203f, 0.03965862f, 
    -0.05015739f, -0.04266871f, -0.01658421f, 0.02585045f, 0.00305138f, -0.03891425f, -0.05536287f, 0.01314430f, 
    0.04473082f, -0.02109707f, -0.02940948f, -0.03342311f, 0.03581172f, -0.03480619f, -0.05610682f, 0.02352317f, 
    0.02278126f, -0.00217093f, -0.03539084f, -0.02746012f, -0.03053238f, 0.00674849f, -0.04380622f, -0.04950954f, 
    0.00141416f, -0.03566918f, -0.04639073f, 0.04302476f, -0.03169235f, -0.01570382f, 0.03353588f, 0.01563883f, 
    -0.04865665f, 0.01168259f, 0.01212800f, -0.03428103f, 0.00994301f, 0.03013907f, -0.04624865f, 0.00531107f, 
    -0.04092823f, 0.03798158f, -0.04861246f, -0.03813076f, -0.03853321f, -0.01563855f, -0.02455794f, 0.02632960f, 
    -0.02832545f, -0.04756367f, -0.01713797f, -0.02609437f, -0.00807397f, 0.00163923f, 0.02478350f, -0.00899792f, 
    0.02523648f, -0.02820963f, -0.04801822f, 0.02177318f, -0.02292304f, -0.00881222f, 0.00525971f, -0.04341067f, 
    -0.01825819f, 0.00424094f, 0.03310494f, 0.02320947f, -0.02876479f, 0.03384397f, -0.00216925f, -0.01851267f, 
    0.00986280f, 0.03274649f, -0.02309832f, 0.00731603f, -0.04894438f, 0.00779935f, -0.01362913f, 0.02221506f, 
    0.03170127f, -0.01545803f, -0.00058218f, 0.01439344f, 0.03762904f, -0.03297051f, -0.04739223f, -0.04442907f, 
    -0.05457924f, 0.02660776f, 0.01932065f, -0.01083286f, 0.04643531f, -0.01876558f, -0.01149744f, -0.05360714f, 
    -0.00216887f, -0.05134134f, -0.04128357f, 0.03943230f, -0.03699828f, -0.02918191f, -0.01495319f, 0.04486290f, 
    -0.05512045f, -0.05075148f, 0.03658845f, -0.00565738f, 0.03530617f, -0.04413243f, -0.05574125f, -0.04988400f, 
    0.02404037f, -0.01005151f, -0.02381947f, 0.00280155f, 0.02385992f, -0.00548092f, -0.03905209f, 0.01678331f, 
    0.03428960f, 0.03730963f, -0.01176880f, 0.02605877f, -0.03754435f, -0.02682414f, -0.02235335f, -0.03126622f, 
    -0.42228302f, -0.29424170f, -0.15501492f, -0.23704723f, 0.05592966f, -0.06706943f, -0.07374384f, -0.05447035f, 
    -0.13309024f, -0.09107385f, 0.00049298f, 0.06500509f, -0.03281814f, -0.08208533f, -0.09657686f, -0.05446541f, 
    -0.09584198f, -0.19837728f, -0.04125778f, 0.03108155f, -0.16414312f, -0.11451360f, -0.07680213f, 0.04568505f, 
    -0.48907402f, -0.08893009f, 0.20619598f, 0.66089761f, 0.12620749f, -0.05486095f, -0.07982302f, 0.15718079f, 
    0.23468085f, 0.05328935f, 0.16481721f, 0.15733494f, 0.08543803f, 0.09969094f, 0.28869975f, -0.02040778f, 
    -0.11446659f, -0.28748050f, -0.16915932f, 0.21423262f, 0.24381933f, 0.00951618f, 0.04671153f, -0.07444254f, 
    0.05769326f, -0.04509667f, -0.01651658f, 0.00446651f, -0.05635394f, -0.08336239f, -0.00747855f, 0.03231159f, 
    0.21683453f, 0.14122255f, 0.06233681f, -0.01376895f, 0.01503920f, 0.02368689f, -0.07513230f, -0.09378059f, 
    0.03629104f, 0.14098021f, 0.11782099f, -0.06004107f, 0.20079818f, 0.24931660f, 0.10415843f, 0.04343727f, 
    0.02789960f, -0.02534751f, 0.04221004f, -0.03959572f, -0.09166187f, 0.04046252f, 0.01947016f, 0.04289419f, 
    0.09173460f, -0.04389708f, -0.07631226f, 0.10090874f, -0.46183053f, 0.04923239f, -0.07937847f, -0.10021438f, 
    -0.12107862f, -0.02227801f, -0.03610137f, -0.19206673f, -0.04214406f, 0.12123320f, 0.04803770f, -0.15511520f, 
    0.09768131f, -0.02278540f, -0.09375834f, -0.06879093f, 0.07652418f, 0.01080053f, 0.13289894f, 0.12717383f, 
    -0.14083417f, -0.09652866f, -0.13894784f, -0.07274973f, 0.02597261f, 0.10463853f, -0.09198822f, -0.37610406f, 
    -0.07616410f, 0.12448238f, -0.04039578f, 0.08970390f, 0.01643991f, 0.02057205f, 0.04703478f, -0.09004290f, 
    0.31337172f, 0.00217026f, 0.40924665f, 0.03372026f, -0.01325045f, -0.05861297f, -0.01785932f, 0.00129276f, 
    0.15245049f, 0.26065865f, 0.11646290f, -0.15763229f, 0.00212547f, -0.00620262f, -0.11387390f, -0.17837368f, 
    0.15268064f, -0.01225176f, 0.02564831f, 0.11829010f, 0.05750533f, -0.04881633f, -0.14707856f, 0.13583221f, 
    0.10336649f, -0.05935721f, 0.17379563f, 0.14068553f, 0.00459871f, -0.11603246f, 0.07041641f, 0.07237532f, 
    0.20913999f, -0.09216216f, 0.22007822f, -0.00950840f, -0.08630814f, -0.00897994f, 0.11087561f, 0.09455821f, 
    -0.16509083f, -0.02681791f, -0.13805619f, 0.03630261f, 0.04988033f, 0.02091928f, -0.08981382f, -0.04862395f, 
    -0.05005766f, -0.01648318f, -0.10598885f, -0.27650568f, 0.02958766f, -0.00095020f, -0.26732013f, -0.00591077f, 
    0.02721724f, 0.02913279f, 0.02710222f, -0.06084402f, 0.22406960f, 0.06041307f, -0.00817924f, 0.16870415f, 
    0.04130113f, -0.04331264f, -0.06300435f, 0.03010653f, 0.04904920f, 0.06219008f, -0.09680854f, 0.17713583f, 
    -0.15693903f, -0.02712367f, 0.12841871f, -0.34678808f, 0.03722018f, 0.16327319f, -0.04638816f, 0.19577095f, 
    0.12911873f, -0.00425205f, -0.04704168f, -0.02593337f, 0.15400963f, 0.19615385f, 0.26961836f, 0.30218014f, 
    0.08673137f, 0.09846726f, -0.00172861f, 0.08410443f, 0.05358379f, -0.01336109f, 0.16552548f, -0.03993054f, 
    0.08393545f, -0.07500537f, -0.01441317f, 0.26034394f, 0.06847231f, 0.27965188f, -0.05503790f, 0.12340695f, 
    -0.07103667f, 0.03402893f, 0.01174587f, -0.05025286f, 0.31185123f, 0.24881117f, 0.00677703f, 0.00183168f, 
    0.16456617f, -0.15383165f, 0.24832578f, 0.20388730f, 0.13713963f, 0.38807178f, 0.04990246f, 0.33369419f, 
    0.33087265f, -0.28592145f, 0.52378374f, 0.19300687f, -0.03012247f, -0.07143113f, 0.03476545f, -0.01420536f, 
    -0.01701834f, 0.10521617f, 0.26592317f, -0.03959042f, 0.36635777f, -0.03258805f, -0.12500496f, 0.03407589f, 
    -0.09179529f, 0.04821970f, -0.20901209f, 0.08820383f, 0.06660231f, -0.09929600f, -0.15897647f, 0.01524013f, 
    -0.12694280f, 0.02121012f, 0.00176841f, -0.29781017f, 0.10445323f, 0.09581125f, -0.05845225f, -0.26359025f, 
    0.04143314f, 0.05458299f, -0.09260821f, -0.06517276f, 0.36294228f, 0.01733879f, -0.18433803f, -0.35426497f, 
    0.00268337f, 0.08100029f, -0.05910651f, 0.05899346f, 0.20855160f, 0.07519346f, 0.12354471f, 0.07542421f, 
    0.32384828f, -0.06037910f, 0.01441685f, -0.12677243f, -0.03565952f, 0.17543711f, 0.08524922f, -0.04026660f, 
    0.31031406f, 0.11532426f, 0.08695602f, -0.09683035f, -0.29748860f, 0.07260099f, -0.13447221f, -0.19559979f, 
    0.03150920f, 0.13210006f, 0.11929027f, -0.00508211f, 0.02173118f, 0.00091223f, -0.11088395f, -0.15557154f, 
    -0.38764507f, -0.20562968f, 0.26988745f, 0.51037765f, 0.04086612f, 0.02028643f, 0.12596710f, -0.01607960f, 
    0.18655318f, -0.00890814f, 0.13243265f, 0.02700995f, -0.07295874f, -0.09909103f, 0.06431857f, 0.28094998f, 
    -0.16933967f, -0.05242648f, -0.16591692f, -0.06334359f, 0.03342308f, -0.20353132f, 0.11451096f, 0.33656719f, 
    -0.02798942f, 0.18253529f, 0.05218848f, -0.03778301f, 0.14042769f, -0.23463225f, 0.24715632f, 0.28728908f, 
    0.38810360f, 0.08945835f, 0.20066564f, -0.21351233f, -0.22136980f, -0.03440622f, 0.10977709f, 0.13081409f, 
    -0.11571988f, -0.01126491f, -0.02683754f, 0.05049689f, -0.04592603f, 0.29510307f, 0.20362617f, 0.04231015f, 
    0.01210358f, 0.06298545f, 0.04672185f, 0.10208855f, -0.03947040f, 0.17026252f, -0.19773585f, 0.10225064f, 
    0.01114431f, 0.15907277f, 0.20261812f, 0.03376926f, 0.04760884f, -0.00296674f, 0.00416058f, -0.26224029f, 
    0.10217427f, 0.00227084f, 0.00087694f, 0.08572919f, 0.16645560f, 0.15641165f, -0.11095339f, -0.03870947f, 
    0.11136192f, -0.14222808f, -0.33036011f, -0.44433028f, 0.00877564f, -0.01480670f, 0.01970783f, 0.02253465f, 
    0.13743222f, -0.11807540f, -0.12873404f, -0.13248010f, -0.70182675f, -0.21785961f, -0.21162686f, 0.06590767f, 
    -0.01840765f, -0.15496475f, -0.02358860f, -0.14746058f, -0.12519829f, -0.16445524f, -0.19862750f, -0.31407657f, 
    0.07732891f, -0.00232439f, 0.09338063f, 0.21277492f, 0.04513270f, -0.04629002f, -0.01631523f, -0.02719952f, 
    0.12651755f, -0.12354189f, -0.15144669f, -0.00653130f, 0.08114278f, 0.08243736f, 0.19501199f, 0.13879375f, 
    -0.02938678f, 0.04150216f, -0.00363915f, 0.06118292f, -0.04685505f, 0.02406605f, -0.05862178f, 0.13250259f, 
    -0.36198008f, -0.25398010f, -0.40845892f, -0.15891744f, -0.14521259f, -0.04213995f, 0.08413205f, -0.12248764f, 
    0.20585160f, 0.06387851f, 0.25567666f, 0.17575446f, 0.15390824f, 0.14227200f, -0.26079771f, -0.36610526f, 
    0.31915334f, 0.09616136f, 0.04548931f, -0.05416462f, -0.00339775f, -0.07733054f, -0.13079722f, -0.11940776f, 
    -0.33456150f, -0.15617795f, -0.01643936f, -0.18954135f, 0.19064796f, 0.27905309f, -0.01208833f, -0.16237813f, 
    -0.12108470f, -0.27533767f, -0.16799219f, -0.25166485f, 0.03488914f, 0.34573865f, 0.49368480f, 0.30623725f, 
    -0.04429175f, -0.06449302f, 0.06270278f, 0.13411295f, -0.04275832f, -0.01510157f, 0.10389435f, 0.18572612f, 
    -0.18940939f, -0.30219623f, -0.17968224f, 0.02664378f, -0.01901841f, 0.12464579f, -0.07719901f, -0.17611809f, 
    0.30995196f, 0.10473402f, 0.03392677f, 0.09280251f, -0.00095731f, 0.03599530f, -0.11397143f, -0.08502257f, 
    0.10660811f, 0.07345544f, 0.09769797f, 0.06462457f, -0.11108661f, 0.12797119f, 0.20103377f, 0.23749398f, 
    -0.04232978f, 0.08881853f, 0.00070755f, -0.14114393f, 0.14291067f, 0.00043928f, -0.16034238f, 0.00998745f, 
    0.07764065f, 0.01936732f, -0.09874222f, -0.00688156f, -0.33984259f, -0.11376007f, -0.14573453f, 0.01959679f, 
    0.04082124f, -0.00725142f, -0.03800233f, -0.07424978f, -0.05090731f, -0.15430470f, -0.20113416f, -0.26790467f, 
    -0.07770751f, -0.08985752f, 0.04465625f, 0.22410223f, -0.01662475f, -0.12061461f, 0.15717055f, 0.10984448f, 
    0.15211076f, 0.18378848f, 0.22112674f, 0.20389390f, 0.24877982f, 0.09752443f, -0.00144540f, 0.18254666f, 
    0.09467612f, 0.06198500f, 0.14694904f, 0.13579436f, -0.00523912f, 0.38344634f, 0.26607108f, 0.39690411f, 
    0.33324012f, 0.34509847f, -0.01329548f, -0.05694150f, 0.17430994f, 0.02307956f, -0.04093924f, 0.12109876f, 
    -0.04764175f, -0.02602324f, -0.11471795f, -0.06112510f, 0.29394466f, 0.17429376f, -0.35656396f, 0.14478873f, 
    -0.03142605f, 0.11466283f, -0.12760904f, -0.01170090f, 0.07694549f, 0.13504860f, 0.00585934f, 0.08768365f, 
    0.03501562f, -0.09805755f, 0.11233073f, 0.05975081f, 0.00699058f, 0.21152091f, -0.02304711f, 0.09244903f, 
    0.02914114f, -0.15579806f, -0.16322646f, 0.13625634f, -0.11072749f, -0.22520839f, -0.28831312f, 0.05288811f, 
    -0.04565665f, -0.02335288f, 0.06857991f, 0.01757931f, 0.01905164f, -0.03389411f, 0.09775019f, 0.21666268f, 
    -0.12023894f, -0.29397333f, 0.13936286f, 0.25176185f, -0.03748277f, 0.05560588f, 0.15037473f, -0.05737117f, 
    -0.03260591f, -0.13721809f, -0.07996803f, -0.03496012f, 0.13359843f, -0.16273688f, -0.14026730f, -0.16827181f, 
    -0.10940161f, -0.16543902f, 0.05695060f, 0.15056956f, -0.06235840f, 0.13359897f, -0.01923511f, -0.01285883f, 
    -0.19866458f, 0.07539354f, -0.12366012f, -0.11640360f, 0.00597505f, 0.00497472f, 0.05255998f, -0.05324139f, 
    0.27925572f, 0.16865057f, 0.20352779f, 0.16112179f, 0.36368257f, 0.08168264f, -0.24635652f, -0.04961852f, 
    -0.07176322f, 0.07707119f, -0.02899548f, 0.00120649f, -0.04497511f, 0.08880632f, -0.12657142f, -0.06667673f, 
    0.27126136f, -0.04494539f, -0.06859313f, -0.21863844f, 0.02412019f, 0.05200073f, 0.01065198f, -0.03617166f, 
    -0.02345535f, -0.03962792f, -0.03349777f, -0.06262656f, 0.01448413f, 0.26115984f, 0.13209543f, 0.31914553f, 
    0.01508037f, -0.00300473f, -0.05004126f, 0.07098730f, 0.06102537f, 0.03834775f, 0.08246636f, 0.30580115f, 
    0.34907764f, 0.09945115f, 0.14952774f, 0.13230793f, -0.06762467f, -0.09500445f, 0.05116316f, 0.05824616f, 
    -0.02990596f, 0.09293409f, -0.07545730f, 0.04077912f, 0.00797004f, 0.20526530f, -0.09734883f, -0.11284734f, 
    0.07309456f, 0.02940150f, 0.04462526f, -0.04652856f, 0.17927124f, 0.03939125f, 0.23171891f, 0.18757004f, 
    0.14860407f, -0.01850292f, 0.22022434f, 0.17855710f, -0.03411991f, 0.01311377f, 0.04307361f, -0.06478248f, 
    -0.00653082f, -0.07278138f, -0.12536271f, 0.04229138f, 0.01152676f, -0.05831441f, -0.05006195f, 0.03450810f, 
    -0.01770746f, -0.09384016f, -0.14870080f, 0.03662862f, -0.02083955f, -0.10629783f, 0.02412673f, -0.07777563f, 
    0.14732310f, 0.18206118f, -0.09061389f, 0.23923288f, 0.11247358f, -0.09165753f, 0.01963777f, 0.02868055f, 
    -0.06556178f, 0.13684948f, 0.16940364f, 0.06385621f, -0.03794224f, -0.08864435f, -0.06472053f, 0.23874718f, 
    0.13136043f, 0.00571564f, 0.00406068f, -0.09971787f, -0.14002049f, -0.02092876f, -0.00298488f, -0.03376320f, 
    -0.11271085f, 0.09934158f, -0.10827022f, -0.32193226f, 0.09921049f, 0.08987337f, -0.24663430f, 0.06232259f, 
    0.12112054f, 0.02570058f, 0.07611777f, -0.01504265f, 0.31584996f, 0.00951240f, -0.25423691f, -0.34997314f, 
    0.20213765f, 0.03119375f, 0.12739767f, -0.01659800f, -0.14969130f, -0.03285824f, -0.19116478f, 0.05248862f, 
    0.05077966f, 0.43637469f, 0.08073973f, 0.00759794f, 0.02272758f, 0.03633482f, 0.28465128f, 0.17759648f, 
    0.01003045f, 0.08192451f, 0.08503712f, 0.11958127f, -0.33015257f, -0.13151489f, -0.18450858f, -0.05804287f, 
    0.17515571f, 0.04811699f, 0.14563286f, 0.18495499f, 0.01919057f, 0.12153787f, -0.01369305f, -0.00306184f, 
    -0.21379749f, 0.13533068f, 0.13792710f, 0.05004851f, -0.09262715f, -0.03470879f, 0.03641575f, -0.07586632f, 
    0.12252675f, -0.15152234f, 0.11906465f, 0.05027109f, -0.02256492f, 0.16051830f, 0.09133244f, 0.08399452f, 
    0.01733253f, 0.06751788f, -0.03147552f, 0.03057575f, 0.00502972f, -0.05438359f, -0.11624729f, -0.14198247f, 
    -0.36931488f, 0.01249130f, -0.25477481f, 0.11254862f, 0.13475581f, 0.01487757f, -0.09409705f, 0.12207042f, 
    -0.14419404f, 0.01687118f, 0.09117851f, -0.08648258f, 0.25215390f, 0.17385925f, 0.11137424f, -0.15666907f, 
    -0.19076331f, 0.06891552f, 0.18092141f, 0.04792510f, 0.12998050f, 0.18810637f, 0.07392849f, 0.04319981f, 
    -0.16106921f, -0.23714316f, 0.04688362f, 0.01286527f, 0.00742964f, 0.05650654f, -0.06091711f, -0.00792489f, 
    0.27989629f, 0.02182229f, 0.16090266f, 0.14360656f, 0.24708523f, 0.06711736f, -0.28921634f, -0.03690154f, 
    -0.03517944f, 0.02721122f, -0.12114346f, -0.00253954f, -0.00407173f, 0.02415186f, 0.11842948f, -0.04126358f, 
    -0.38362074f, 0.01588481f, -0.32007670f, 0.26804560f, -0.05352935f, -0.03815762f, 0.25898027f, -0.12229217f, 
    -0.23945463f, -0.15163021f, -0.14708522f, -0.07109305f, 0.25467843f, 0.26462787f, 0.16151470f, -0.22986180f, 
    0.08623028f, -0.03286881f, 0.06210667f, 0.07483854f, -0.08549020f, -0.02834183f, -0.00562699f, -0.04952573f, 
    0.06441192f, -0.06851707f, 0.29963470f, 0.09445971f, 0.11434571f, -0.04876705f, -0.03330625f, -0.01953866f, 
    -0.06036123f, 0.16064848f, -0.14259639f, 0.02039039f, -0.35440582f, -0.05197865f, 0.05590763f, 0.13380457f, 
    0.25881690f, 0.07824504f, -0.17123674f, 0.14329557f, 0.15792881f, -0.03583466f, 0.10160079f, 0.23123589f, 
    -0.04884713f, -0.21398215f, 0.34150156f, -0.06212571f, -0.02327835f, 0.04638148f, -0.27870926f, -0.10668457f, 
    0.03040299f, -0.06939095f, 0.03490233f, -0.09878093f, -0.05129688f, -0.02494545f, 0.22558820f, 0.05271346f, 
    -0.06684458f, -0.12552762f, -0.06833246f, -0.02292483f, 0.09926498f, -0.00672281f, -0.06163314f, -0.14641343f, 
    0.41118312f, -0.26050222f, -0.07041943f, -0.11269986f, 0.00931887f, -0.00267844f, 0.25282875f, 0.15626480f, 
    -0.14672086f, -0.05710264f, -0.04848443f, -0.01380280f, -0.45731261f, 0.19863595f, 0.10292522f, -0.19987367f, 
    0.10218334f, -0.10265446f, 0.16295920f, -0.10919054f, 0.02660399f, 0.04633671f, 0.07441700f, 0.12483194f, 
    -0.08075247f, 0.10524000f, -0.31746161f, -0.22628663f, -0.11630271f, 0.09881543f, 0.06666721f, 0.03475901f, 
    0.01292872f, -0.11646258f, -0.05356555f, 0.00351390f, -0.23337388f, 0.04224811f, 0.03541676f, 0.04765462f, 
    0.01731562f, 0.05061716f, 0.09044611f, -0.00612920f, -0.05184863f, -0.15557472f, 0.06318901f, -0.03516691f, 
    -0.34049323f, -0.21826907f, 0.02710461f, -0.09339613f, 0.32003689f, 0.28931835f, 0.07014377f, 0.03608758f, 
    0.01038054f, -0.01293055f, 0.06575309f, -0.16074826f, 0.15019245f, -0.21226335f, 0.13933015f, 0.27991968f, 
    0.02836674f, 0.05378925f, -0.10846941f, 0.31858245f, 0.25863430f, 0.01678339f, 0.14697103f, 0.02902904f, 
    -0.10902394f, -0.22601673f, 0.17496589f, -0.23239048f, 0.05047577f, 0.01597123f, -0.25524855f, 0.06836457f, 
    0.19315240f, 0.03185771f, -0.17437224f, 0.04051998f, -0.10043226f, 0.24337155f, 0.25844747f, -0.09347098f, 
    -0.07238278f, 0.03658401f, -0.05729255f, -0.08010022f, -0.07994155f, -0.03892799f, -0.00239346f, 0.15020697f, 
    0.24289252f, 0.17098610f, -0.18978155f, 0.16070034f, 0.00882457f, 0.05685293f, 0.03075181f, 0.00986178f, 
    0.03789937f, 0.09704497f, -0.05121293f, 0.02087554f, 0.18893650f, -0.25779122f, -0.04083428f, -0.30897638f, 
    -0.00814815f, -0.02205235f, 0.03105235f, 0.08063664f, -0.04236683f, -0.00512093f, -0.09674810f, -0.21041431f, 
    0.05190839f, 0.09271100f, 0.04800776f, -0.20639546f, -0.08398250f, 0.10387055f, -0.18071532f, 0.07299004f, 
    -0.02008107f, -0.05441258f, 0.15080580f, 0.00275355f, 0.13267872f, 0.28417030f, 0.05215481f, 0.18553734f, 
    0.10356889f, 0.00549959f, 0.18294556f, 0.07637436f, -0.09531773f, -0.01271369f, -0.03689943f, -0.15823855f, 
    0.25895721f, 0.10227407f, 0.05424727f, 0.47703752f, -0.09242778f, 0.03297175f, -0.09198552f, 0.05977491f, 
    0.20145653f, 0.03403456f, 0.14221096f, -0.06551336f, 0.06111793f, 0.11381256f, 0.10043907f, 0.07533160f, 
    -0.12286627f, -0.24462301f, -0.18619052f, -0.27413654f, 0.05053293f, 0.07466566f, 0.12291680f, 0.11466625f, 
    0.01283084f, 0.03602987f, 0.38438416f, -0.21896996f, 0.01292878f, -0.01806723f, -0.01667005f, 0.00227028f, 
    0.05749772f, -0.08955648f, -0.06952402f, -0.08102914f, -0.20008211f, 0.15242596f, 0.23244511f, 0.23041447f, 
    -0.02072413f, 0.11219099f, -0.03014995f, -0.19413936f, 0.06445276f, -0.00028029f, 0.07563714f, 0.21484222f, 
    0.09753493f, -0.08303884f, -0.39189863f, 0.21404552f, -0.04942146f, 0.03403456f, 0.07548829f, -0.09295857f, 
    -0.00128101f, 0.11191915f, 0.00960847f, 0.11843026f, 0.20550874f, 0.13825993f, 0.27946821f, -0.01883412f, 
    0.10684425f, 0.30415177f, -0.00726085f, 0.09795333f, 0.08096201f, 0.00826067f, 0.05957296f, 0.01356854f, 
    -0.02953434f, -0.30535659f, -0.12821837f, -0.15636151f, 0.04298900f, 0.02953998f, -0.03239407f, -0.09190779f, 
    -0.00240238f, 0.07072920f, 0.01924625f, 0.15440476f, -0.26527706f, -0.16890372f, 0.12491062f, -0.24578622f, 
    -0.18700251f, -0.25759125f, -0.28920788f, -0.13591155f, -0.15201429f, 0.03405046f, 0.06080793f, -0.20256832f, 
    0.58440238f, 0.15518534f, -0.11117963f, -0.22482081f, -0.01221630f, 0.04847514f, 0.05875324f, 0.05966527f, 
    0.08325888f, 0.10784273f, -0.03553500f, 0.09182870f, -0.09616881f, -0.05306062f, -0.04381841f, 0.16914497f, 
    0.03563510f, 0.08137736f, 0.02527121f, 0.01065410f, -0.10231580f, 0.09894649f, 0.04405701f, 0.00176532f, 
    -0.45877948f, -0.06330401f, 0.01831575f, -0.22863327f, -0.10912098f, -0.09142955f, -0.03877489f, -0.11535204f, 
    -0.09967912f, 0.03638618f, 0.16483881f, -0.05217341f, -0.14837506f, 0.02279850f, -0.26999864f, -0.02113395f, 
    0.10195038f, -0.05323898f, -0.08317158f, 0.13285032f, -0.06420293f, -0.02248516f, 0.12548839f, -0.11632469f, 
    -0.12339268f, 0.25772646f, -0.01076736f, 0.13588673f, -0.05169278f, -0.06187000f, -0.14804810f, 0.05775800f, 
    -0.17839901f, 0.02791843f, 0.18274260f, 0.11350987f, -0.12551281f, 0.35890406f, 0.31620678f, 0.25898921f, 
    0.04008392f, 0.01243401f, 0.01481715f, 0.23453453f, -0.01961576f, 0.02263596f, 0.14142263f, -0.13895252f, 
    -0.14322779f, -0.16830780f, 0.32580334f, -0.25605926f, -0.11132119f, -0.20284450f, -0.24804103f, -0.09368163f, 
    -0.13040249f, 0.01459666f, 0.01928170f, -0.07919452f, -0.27061036f, -0.37597474f, -0.16608818f, 0.13634677f, 
    -0.03127224f, -0.05066635f, 0.05509087f, -0.19447923f, 0.05435587f, 0.06139081f, -0.20014557f, -0.14859471f, 
    -0.30766627f, 0.46243197f, -0.08507515f, 0.08508789f, -0.00961547f, 0.01740910f, -0.00338478f, 0.05799144f, 
    -0.01067950f, 0.01107588f, 0.16673562f, 0.10407925f, -0.10869672f, -0.03403719f, 0.08694917f, 0.07394601f, 
    -0.26201496f, 0.13906649f, -0.06018000f, -0.06095768f, -0.08204983f, 0.03906423f, 0.06392741f, 0.20545268f, 
    -0.29840660f, 0.04339923f, -0.44628096f, -0.22369120f, -0.03915675f, 0.04261823f, -0.11071976f, -0.08728002f, 
    0.01069642f, -0.03802067f, -0.14246333f, -0.04607201f, 0.11051177f, 0.09792078f, -0.03234886f, 0.00460203f, 
    0.10292760f, 0.14208621f, 0.04950335f, -0.01989174f, -0.10247858f, -0.13807221f, 0.01693868f, -0.06590743f, 
    -0.37379882f, 0.56180716f, -0.08783797f, 0.18856816f, 0.10219704f, -0.21269736f, -0.02607780f, -0.15253128f, 
    -0.10059574f, 0.00711872f, -0.10719564f, 0.02239523f, 0.22277094f, -0.01620436f, -0.16018055f, 0.07067496f, 
    -0.13361040f, 0.16716491f, 0.03349451f, -0.01547143f, -0.13436693f, -0.07656635f, 0.03135914f, 0.28870961f, 
    0.17485698f, -0.08224194f, 0.19516055f, 0.43343836f, 0.00200596f, -0.12452085f, 0.05305596f, -0.09135583f, 
    -0.11399239f, -0.05633517f, -0.11190453f, 0.03219545f, -0.05413039f, 0.26886109f, 0.14575887f, -0.13907881f, 
    -0.09854466f, -0.10777851f, -0.19563778f, -0.12320584f, 0.01183009f, -0.02072184f, -0.14406662f, 0.09441795f, 
    0.19441415f, 0.28751230f, 0.17951904f, 0.15856619f, -0.30148974f, -0.35275018f, -0.07562166f, 0.05969752f, 
    -0.12773918f, 0.05502100f, -0.01077846f, 0.11152709f, -0.09187581f, 0.14667308f, 0.01951547f, 0.05163442f, 
    0.10463697f, -0.13820954f, -0.11155775f, 0.13161092f, 0.21982656f, 0.19420660f, 0.27074078f, -0.16677500f, 
    -0.30068740f, 0.41796094f, 0.00778602f, 0.13507612f, -0.03249141f, 0.20535165f, 0.01854097f, 0.04041429f, 
    0.06511033f, -0.00301150f, -0.02456846f, -0.04113171f, -0.08135241f, -0.15850875f, -0.15033448f, 0.13276878f, 
    0.03353205f, 0.03330128f, 0.00762276f, 0.01494649f, 0.04412700f, -0.03485339f, 0.27441248f, 0.08502425f, 
    -0.17370872f, -0.09777208f, -0.13321258f, 0.03755907f, 0.05308393f, 0.01465565f, 0.06751900f, 0.10696522f, 
    0.01213577f, 0.04998043f, -0.13482936f, -0.09377223f, -0.25700521f, 0.22228052f, 0.41987133f, 0.42852423f, 
    0.00143253f, 0.13093513f, 0.16522866f, 0.00851250f, 0.12593266f, 0.07150722f, -0.11449348f, -0.02881774f, 
    -0.23601803f, 0.06864776f, 0.34325144f, 0.38893625f, 0.01768320f, 0.06188301f, 0.11355625f, 0.13783799f, 
    0.01413318f, 0.32759324f, 0.00329694f, -0.00586813f, 0.08104820f, -0.31641573f, 0.09232491f, -0.01212962f, 
    0.01955622f, 0.04194253f, -0.06689005f, -0.08728535f, 0.03923123f, 0.04799857f, 0.02331404f, -0.03173339f, 
    -0.20307824f, 0.35794246f, 0.21171638f, 0.03009598f, 0.08342655f, 0.05108742f, 0.01048931f, 0.20795795f, 
    -0.07808794f, 0.15425642f, -0.04640022f, 0.15017474f, -0.52349061f, -0.00051259f, -0.19697648f, -0.12322932f, 
    -0.01517397f, -0.00152330f, 0.03412110f, -0.03527434f, -0.05660689f, 0.13748133f, 0.10366912f, 0.21397722f, 
    0.05026510f, 0.37853703f, -0.06240359f, 0.03787773f, 0.01420855f, 0.06222323f, 0.13747680f, 0.08668962f, 
    -0.03184483f, -0.11576358f, -0.03653752f, 0.10005111f, 0.40861315f, 0.15760203f, 0.02913270f, -0.20952138f, 
    -0.01636082f, 0.12103976f, 0.07289091f, 0.03247459f, -0.04607881f, 0.17796321f, 0.12319734f, 0.12589413f, 
    -0.30338362f, 0.25593841f, 0.09162518f, 0.38618025f, -0.02259883f, 0.02928670f, 0.03701888f, 0.00623361f, 
    -0.02969100f, -0.01686070f, -0.05834794f, 0.27375036f, -0.22682643f, -0.17844914f, -0.29027823f, 0.11278497f, 
    -0.02942136f, 0.09415307f, 0.07356525f, -0.03331821f, 0.00684936f, 0.15978102f, 0.13042064f, -0.06303736f, 
    -0.26997244f, -0.26035535f, -0.05872646f, -0.02733234f, -0.13600054f, -0.27379563f, -0.14236623f, 0.00718233f, 
    -0.10671688f, -0.06312961f, -0.03131353f, -0.00902319f, -0.00881478f, -0.06607876f, 0.05500206f, -0.01783568f, 
    0.18533066f, 0.12204689f, 0.17079401f, 0.08437541f, 0.03066173f, 0.03439914f, 0.01189680f, -0.03384650f, 
    0.07496095f, 0.03580905f, -0.08792882f, 0.01670863f, 0.06209841f, 0.07242678f, -0.05591704f, -0.07813667f, 
    0.17200008f, 0.15932371f, 0.19327401f, 0.06501077f, -0.11500212f, -0.19303927f, -0.18785329f, -0.09418240f, 
    0.38021281f, 0.18617320f, 0.39097080f, -0.06711274f, 0.18362246f, 0.07943727f, 0.20276102f, -0.02802840f, 
    -0.02693760f, 0.04408850f, -0.04616275f, -0.11301882f, 0.02169034f, -0.02660609f, 0.12209557f, 0.09843559f, 
    0.12808940f, -0.01577180f, 0.08065066f, 0.03019785f, 0.00900946f, -0.32822782f, -0.20702477f, 0.11660265f, 
    -0.13374512f, -0.12001377f, -0.03303489f, -0.15089732f, -0.00361373f, 0.04895011f, 0.10014632f, -0.00351113f, 
    -0.11604546f, -0.08985523f, 0.00728193f, -0.08918642f, 0.10228313f, -0.03856298f, 0.05177875f, 0.05983492f, 
    0.05229089f, 0.14402686f, -0.02296650f, 0.06168041f, -0.07262791f, 0.08063263f, 0.21703492f, 0.27640864f, 
    0.03177254f, -0.06502124f, -0.01705968f, -0.03079710f, 0.15918070f, 0.11770688f, -0.17968288f, 0.19605179f, 
    -0.19805358f, 0.00755835f, -0.10203947f, -0.13086228f, -0.03724628f, -0.01677755f, 0.21294941f, 0.05112863f, 
    -0.21804889f, -0.14235550f, -0.14313293f, -0.27590984f, -0.09211844f, -0.19295627f, -0.01336143f, 0.19462082f, 
    -0.13302848f, 0.01260549f, -0.00511723f, -0.04343078f, 0.06604706f, 0.02387679f, 0.03469807f, -0.04277423f, 
    -0.45561650f, -0.02378619f, -0.01740865f, -0.01181415f, -0.01600684f, 0.02977875f, -0.07292902f, 0.00021074f, 
    -0.10910749f, -0.04908237f, 0.15785961f, 0.13306174f, -0.24589610f, -0.05247645f, 0.09951399f, 0.06664026f, 
    0.13358639f, -0.01446414f, 0.13094349f, 0.13140698f, -0.07885692f, 0.01514653f, -0.05886305f, -0.00507304f, 
    -0.04530338f, -0.07176854f, -0.23622647f, 0.01632185f, -0.00161771f, 0.02160626f, -0.09035018f, -0.09076835f, 
    0.10631066f, 0.13577957f, 0.14299014f, 0.02529191f, 0.21524677f, 0.00230852f, -0.14839007f, 0.01222642f, 
    0.04699164f, -0.06622138f, 0.06263134f, 0.00240003f, 0.06894676f, 0.14471303f, 0.14610536f, -0.06476477f, 
    -0.12769751f, 0.04319624f, 0.19730975f, 0.32704517f, 0.16597836f, 0.31610283f, 0.22637980f, -0.07032580f, 
    -0.12165186f, 0.06384011f, -0.00869745f, 0.01185076f, -0.02719333f, 0.17203279f, -0.04319395f, -0.14546658f, 
    0.01255300f, 0.06111432f, -0.02094428f, 0.13304901f, 0.00314784f, 0.05671933f, 0.29933387f, 0.09757251f, 
    -0.11869016f, -0.09147649f, -0.34006909f, 0.00265699f, -0.05788861f, 0.08297672f, 0.22192319f, -0.09399272f, 
    0.07430487f, 0.05190593f, -0.02371220f, 0.05097977f, 0.01131090f, 0.07208712f, 0.18054745f, -0.05460070f, 
    -0.13136008f, -0.04202750f, -0.02701668f, -0.01585176f, -0.07781162f, 0.13658540f, -0.13053629f, 0.02690704f, 
    0.50869668f, 0.15488641f, -0.38897443f, -0.04053666f, 0.10006129f, 0.09498979f, -0.03080791f, 0.08322261f, 
    0.02792532f, -0.00865935f, 0.06960758f, -0.03949964f, 0.07133815f, -0.08015627f, -0.05653655f, 0.20527229f, 
    0.10375796f, -0.00650318f, -0.02535686f, -0.01376934f, 0.20667484f, 0.18431123f, 0.07019717f, -0.22412549f, 
    -0.07248396f, -0.10211676f, 0.01520273f, 0.10492627f, -0.07997597f, -0.14262109f, -0.04267774f, -0.04740155f, 
    0.01417111f, 0.13247387f, 0.13836573f, 0.30375367f, 0.20585576f, 0.18190804f, 0.09892409f, 0.15053235f, 
    0.00749869f, -0.15112448f, 0.05829262f, 0.01421040f, 0.01372064f, -0.00575975f, 0.16042671f, -0.03671315f, 
    -0.41162932f, -0.31151649f, -0.06853515f, -0.04124498f, 0.05768311f, -0.07030899f, -0.08892033f, 0.12264626f, 
    0.19147414f, 0.06490209f, 0.05863787f, 0.20717964f, -0.15429400f, -0.00262310f, 0.19774425f, 0.08933591f, 
    -0.05235336f, -0.06456957f, -0.02779244f, -0.02974443f, 0.00555811f, 0.24573816f, 0.13812256f, 0.05115584f, 
    -0.07677151f, 0.26385146f, 0.11187159f, 0.15951174f, -0.03732981f, -0.00163782f, -0.04747396f, 0.25198847f, 
    0.04737717f, -0.17652383f, 0.08322061f, 0.06500254f, -0.03074107f, -0.13301142f, 0.01027986f, -0.08560875f, 
    0.01992154f, 0.11894127f, 0.10049906f, 0.19087479f, 0.11070567f, 0.10271773f, 0.05441231f, -0.05238029f, 
    0.01527565f, 0.16001563f, -0.29509279f, 0.16729736f, 0.02098271f, 0.03040567f, 0.03020854f, -0.00957836f, 
    0.16935046f, -0.10730695f, 0.21707441f, 0.09313008f, -0.23683250f, 0.08039920f, -0.14657024f, -0.00712535f, 
    0.03931838f, -0.00135654f, -0.00570720f, -0.06707998f, 0.18144155f, 0.14447340f, 0.03412129f, 0.15801752f, 
    -0.00058646f, -0.12598847f, -0.10080323f, 0.22403716f, 0.17565696f, 0.31345254f, 0.13074613f, -0.00448213f, 
    0.06491631f, -0.04463701f, 0.09186266f, 0.23359317f, 0.08005936f, -0.05867738f, -0.17827114f, -0.17888319f, 
    0.03857637f, -0.00778788f, -0.09342814f, -0.03094581f, -0.08486939f, -0.04525856f, 0.03880923f, 0.13598132f, 
    -0.11056422f, -0.00361568f, 0.01068787f, 0.41217765f, 0.02998475f, -0.02838739f, 0.11860737f, -0.04328190f, 
    0.03277752f, 0.13438472f, -0.11521515f, 0.15380792f, -0.22324203f, -0.23503551f, -0.31335193f, 0.09235329f, 
    -0.12101537f, -0.07289546f, 0.03471763f, 0.01712641f, 0.11824157f, 0.12365423f, 0.02911082f, 0.06864147f, 
    0.03158455f, 0.08977727f, 0.24253170f, 0.28239599f, 0.03431769f, -0.17630123f, -0.05665728f, -0.00847986f, 
    0.01737543f, -0.06271423f, -0.03268507f, -0.11537129f, 0.02599771f, -0.10246120f, -0.17245243f, -0.06766208f, 
    0.07841595f, -0.01366514f, 0.04906799f, 0.03800492f, 0.10319033f, -0.00663352f, -0.05461913f, 0.08860423f, 
    -0.54765826f, -0.27146858f, -0.40703905f, 0.43808177f, 0.07129795f, -0.04485827f, -0.03818147f, -0.01702784f, 
    -0.02733104f, 0.12643623f, 0.01531438f, 0.12280739f, 0.03980706f, -0.03165978f, 0.15561232f, 0.15460634f, 
    0.06750162f, 0.03885904f, 0.00795106f, -0.00871681f, 0.07334030f, -0.13663976f, 0.00304617f, 0.12843169f, 
    0.05629365f, -0.27426851f, -0.06647290f, 0.02335039f, 0.03532492f, -0.03586961f, -0.04678825f, -0.00937219f, 
    0.09497957f, -0.00115630f, -0.09245542f, 0.01288963f, 0.05556411f, -0.08465049f, 0.29895139f, 0.30074188f, 
    -0.05625273f, 0.02326965f, 0.03531025f, 0.01337930f, 0.03140245f, 0.08591440f, -0.05020713f, 0.09663525f, 
    0.18450135f, -0.13136403f, -0.17735139f, -0.11843132f, 0.00373299f, -0.04203222f, 0.02755694f, -0.03780503f, 
    0.08425304f, 0.00761853f, -0.09092481f, -0.00047133f, 0.13058481f, -0.26221284f, -0.03629905f, -0.10760705f, 
    0.04788340f, 0.05285923f, 0.00784508f, -0.06890579f, -0.07486442f, -0.09069994f, -0.00845328f, 0.01955141f, 
    0.07282329f, -0.08800102f, -0.15429184f, -0.13861112f, -0.11225927f, -0.04341780f, -0.08915848f, 0.01854812f, 
    -0.07559323f, 0.03450373f, 0.02232223f, 0.06036265f, 0.11914575f, 0.19011362f, 0.23673077f, 0.10605872f, 
    -0.08819772f, -0.04799685f, -0.10617458f, 0.15633404f, 0.05241481f, -0.08947880f, 0.01581265f, 0.05186783f, 
    -0.02452110f, -0.38744769f, -0.04436905f, -0.22822076f, -0.07583905f, 0.02549707f, -0.08653416f, 0.02359553f, 
    0.04279311f, 0.06524253f, 0.13678111f, -0.11826079f, 0.16476187f, 0.14128178f, -0.00634846f, -0.11071634f, 
    0.12348640f, -0.05317096f, 0.08343379f, 0.02194265f, 0.00135865f, 0.11100180f, -0.09635324f, 0.01882286f, 
    -0.15155575f, -0.27817592f, -0.10142710f, 0.01707190f, 0.01387415f, -0.06235162f, -0.01510720f, -0.11155191f, 
    -0.14087597f, -0.07392248f, -0.06800656f, 0.00307188f, 0.08318841f, -0.06437342f, -0.05358122f, -0.02394943f, 
    0.00846646f, 0.02966535f, -0.05817633f, -0.10232030f, -0.10186378f, -0.17197593f, -0.20457898f, -0.12377565f, 
    0.07263016f, -0.32531118f, 0.23192586f, 0.08806949f, -0.20327479f, 0.00880956f, -0.04448978f, -0.09257110f, 
    0.08574574f, -0.00040475f, 0.03970850f, -0.00857028f, -0.27923533f, -0.32813844f, -0.10050469f, -0.18330635f, 
    0.06086531f, -0.08070377f, -0.13185857f, 0.06587639f, 0.19099966f, 0.09509540f, 0.02329722f, 0.01738456f, 
    0.02489447f, 0.17759761f, 0.22796257f, 0.07416562f, 0.05939158f, 0.11041790f, 0.08219795f, 0.06819629f, 
    -0.00862599f, -0.06514621f, -0.01259146f, -0.04294388f, 0.10462616f, -0.36641750f, -0.23883216f, -0.01792165f, 
    0.04813441f, 0.07082030f, -0.02096870f, 0.02089157f, -0.03322372f, 0.04161371f, 0.11716898f, -0.07798430f, 
    0.32165512f, -0.04279952f, -0.41252932f, -0.04161965f, 0.11292194f, -0.03016597f, 0.09509607f, -0.12236957f, 
    0.01594202f, 0.01422469f, 0.05735866f, -0.03877886f, 0.08375986f, -0.20268565f, -0.02754082f, 0.01719050f, 
    0.10162566f, -0.01554250f, 0.04169872f, -0.18060340f, 0.02892751f, 0.03861995f, -0.08223015f, 0.34996954f, 
    0.21683271f, -0.45535117f, -0.00855418f, -0.16180801f, -0.05452214f, -0.15453731f, 0.08741990f, -0.01774640f, 
    -0.06107220f, -0.11850529f, 0.16510256f, 0.03982960f, -0.03311708f, 0.12206519f, 0.13010599f, -0.04433753f, 
    -0.05699001f, -0.09604798f, 0.04508793f, 0.17640907f, 0.14741482f, 0.05005457f, -0.06154217f, 0.06456443f, 
    -0.06839354f, 0.10586488f, 0.44124565f, 0.17058358f, 0.02498280f, -0.12343691f, -0.00628687f, -0.00656461f, 
    0.02885012f, 0.07554413f, 0.07131564f, -0.02744464f, 0.26578438f, 0.06253392f, 0.00867216f, -0.23466519f, 
    0.04977733f, 0.03307432f, 0.06382020f, 0.05333644f, 0.08604118f, -0.00265050f, 0.13981366f, 0.17056422f, 
    0.13661872f, -0.11785398f, -0.02972659f, -0.03473982f, 0.02633815f, -0.03227508f, -0.02188566f, -0.03093171f, 
    0.05718847f, -0.12915939f, 0.02677033f, -0.00209988f, 0.01934122f, 0.28039497f, 0.20234060f, 0.14143807f, 
    0.11402550f, 0.09299927f, 0.03734599f, 0.10371789f, -0.07093551f, -0.01761157f, 0.00057041f, 0.01559491f, 
    -0.06673542f, -0.05778606f, 0.04612780f, 0.25755167f, 0.09932275f, -0.05030211f, 0.08097105f, -0.09056019f, 
    0.08355688f, -0.05000210f, 0.17700396f, 0.09373368f, -0.17151481f, -0.30978256f, -0.25225616f, -0.08990902f, 
    -0.01213975f, 0.03124308f, -0.03466617f, 0.03103719f, 0.06868805f, -0.05077687f, -0.00887397f, 0.00358609f, 
    -0.17464784f, -0.25613505f, 0.08593981f, 0.07891065f, -0.12940916f, 0.01826413f, 0.07283713f, 0.07545849f, 
    0.19128439f, -0.03760265f, -0.02144885f, -0.03710854f, -0.32445204f, -0.25572976f, -0.10186729f, 0.05919002f, 
    0.01761985f, -0.09578107f, -0.11002535f, 0.01205018f, 0.19892024f, 0.05471973f, 0.07523222f, 0.10673113f, 
    0.23730309f, -0.10167465f, 0.12719797f, -0.18107389f, -0.00868357f, 0.01822199f, 0.07145445f, 0.10617914f, 
    0.03485597f, 0.01613212f, 0.19401623f, -0.02266136f, 0.02689277f, 0.15528136f, 0.28995040f, 0.20751491f, 
    -0.05816808f, -0.08903483f, -0.01937375f, 0.06147826f, 0.01733194f, -0.00017783f, 0.12107371f, 0.03664925f, 
    0.13198674f, 0.11812062f, -0.13010812f, 0.11984988f, -0.04217558f, -0.05951593f, 0.06570336f, 0.20975193f, 
    -0.10882427f, -0.07372355f, -0.10149027f, -0.35897040f, -0.18394658f, 0.01208646f, -0.17321344f, -0.11472595f, 
    0.23139918f, 0.05136301f, 0.14763820f, 0.04389748f, -0.29352787f, -0.27336872f, -0.14866281f, -0.44008845f, 
    0.19951794f, 0.19883567f, 0.00535886f, -0.17509055f, -0.18249203f, -0.02047031f, -0.13420975f, -0.27157110f, 
    0.14388192f, -0.04736391f, 0.02062217f, 0.03849937f, 0.09112602f, -0.17132775f, -0.12091319f, -0.00138018f, 
    -0.02008336f, 0.06675710f, 0.14644505f, 0.00243597f, 0.15834840f, 0.09618917f, 0.14062406f, 0.21254186f, 
    -0.01748005f, 0.01831882f, -0.21467291f, -0.16043036f, 0.04378470f, 0.12937029f, 0.06848781f, 0.12766749f, 
    -0.01177017f, 0.07787631f, 0.09495722f, 0.14942051f, -0.00417683f, 0.00297847f, 0.16367544f, 0.07379878f, 
    0.09584301f, -0.10730246f, 0.03719535f, 0.10557524f, -0.11275080f, -0.03401118f, -0.04079242f, -0.09067875f, 
    -0.20626517f, -0.26059964f, 0.14446770f, -0.02989219f, 0.33756152f, -0.04838104f, -0.13140671f, -0.17647918f, 
    -0.34655958f, -0.19972825f, -0.21509349f, -0.28342959f, 0.55353397f, 0.30128682f, 0.31579509f, 0.25028044f, 
    -0.03911617f, -0.00718229f, -0.02522575f, 0.06855041f, 0.19790442f, 0.13627551f, -0.11763083f, 0.28482962f, 
    -0.12522019f, 0.11445698f, -0.22313197f, 0.09908198f, 0.09712971f, 0.00380633f, 0.31168994f, -0.22993536f, 
    0.18218109f, 0.12729189f, 0.13059562f, 0.24477163f, -0.05977971f, -0.05118003f, -0.00880806f, 0.17638209f, 
    -0.00843963f, 0.03240472f, 0.15515710f, 0.14946082f, 0.14721079f, 0.14044110f, 0.14658630f, 0.18464543f, 
    0.00114931f, -0.11232242f, 0.05228403f, -0.01789291f, 0.07720505f, -0.19719474f, -0.04514744f, -0.31384107f, 
    0.14082600f, 0.04108313f, 0.10313589f, 0.03879420f, -0.39672935f, 0.04360297f, 0.05108207f, 0.18274237f, 
    0.10382643f, -0.16365196f, 0.04630229f, 0.06793167f, -0.31679025f, -0.14838913f, -0.40101680f, -0.30327061f, 
    0.14134553f, 0.12767617f, 0.15060548f, -0.21088606f, -0.17300344f, 0.13375610f, 0.05212238f, -0.01278022f, 
    0.21085323f, 0.20048603f, 0.22285770f, 0.11550225f, 0.35411254f, -0.14172198f, -0.03520306f, 0.18242694f, 
    0.05972883f, 0.11123511f, 0.02210791f, 0.01623950f, 0.23275770f, 0.08453315f, 0.25171319f, 0.44129062f, 
    0.27866068f, -0.26885650f, 0.29456568f, 0.22412075f, 0.10914496f, 0.10659541f, -0.09407103f, -0.02100259f, 
    -0.16464445f, 0.15140457f, -0.22279228f, -0.07852974f, -0.18558402f, 0.02758512f, -0.33413708f, -0.06925422f, 
    0.09265324f, -0.05308808f, 0.02399540f, -0.28628618f, -0.10179892f, -0.11805166f, 0.03489302f, -0.17283066f, 
    0.05845124f, -0.12365278f, -0.16451620f, -0.00621691f, -0.24588510f, 0.15971208f, 0.07315706f, 0.06697492f, 
    0.12146245f, -0.01845575f, 0.05417044f, 0.07381552f, 0.04515280f, -0.01659810f, -0.07973991f, 0.06052669f, 
    -0.08285221f, -0.03746187f, 0.08309653f, -0.20509343f, 0.07372716f, 0.21865284f, 0.13321701f, 0.27246523f, 
    -0.07031622f, -0.19768533f, -0.25360343f, 0.08873649f, 0.14124133f, -0.03902790f, 0.13525212f, -0.19811885f, 
    -0.18779673f, -0.21318479f, -0.13106677f, 0.09290826f, -0.02676634f, -0.01087027f, 0.13209765f, -0.15918736f, 
    -0.16005614f, -0.24080804f, -0.02024085f, -0.04241097f, -0.08797017f, 0.09851662f, -0.21594830f, -0.38287458f, 
    -0.18472701f, 0.18175474f, -0.24294236f, 0.10958458f, -0.00048319f, -0.03950297f, 0.16414556f, -0.14399911f, 
    -0.09665406f, 0.06719378f, 0.13334198f, 0.29084262f, 0.18465264f, 0.02893659f, -0.01480895f, 0.20902351f, 
    -0.15172550f, -0.20377168f, 0.10175337f, -0.25147822f, -0.06907836f, 0.01915822f, -0.11131448f, -0.19388318f, 
    0.15584910f, 0.00663119f, 0.00473284f, 0.26340139f, -0.04081595f, -0.01069112f, -0.18877257f, 0.10644135f, 
    0.14313839f, 0.05882652f, 0.10428044f, 0.19027597f, -0.17507011f, 0.01388176f, 0.22860768f, 0.40481362f, 
    -0.08062537f, 0.10776942f, 0.05102504f, -0.00001205f, 0.10318577f, 0.10518675f, 0.21516412f, 0.25574803f, 
    0.17586204f, 0.23180245f, 0.08723370f, 0.03124027f, -0.11069705f, -0.18556303f, 0.02266252f, -0.04761659f, 
    -0.09713963f, -0.06595826f, -0.07489336f, 0.12060916f, 0.09937172f, 0.11165593f, -0.18733692f, 0.25844175f, 
    0.00505768f, 0.01442661f, 0.08151270f, 0.12598601f, 0.16729927f, 0.11731428f, 0.11173376f, 0.02735362f, 
    0.31456003f, 0.19251208f, -0.12128220f, -0.10684846f, -0.15320925f, -0.02285150f, -0.03784085f, -0.14207694f, 
    -0.13790721f, 0.03072280f, 0.04933075f, 0.08839714f, 0.21577801f, 0.22011243f, 0.01410073f, -0.16236821f, 
    0.19750144f, 0.20413014f, 0.12800825f, -0.02719168f, -0.10464806f, -0.06279886f, -0.09565922f, -0.07195447f, 
    0.14765671f, 0.00441972f, 0.14575104f, 0.09025303f, -0.02133415f, 0.00985613f, -0.08986254f, 0.09773414f, 
    0.07015936f, 0.13714650f, 0.23129800f, 0.10282718f, 0.07112811f, 0.18824019f, -0.04731332f, 0.09958962f, 
    0.09453266f, 0.02719435f, -0.17447044f, -0.19148593f, -0.16877037f, -0.21054617f, -0.10350639f, 0.03527453f, 
    0.05384853f, -0.36424530f, 0.04109855f, -0.14793909f, -0.15799931f, 0.22407781f, -0.06954488f, -0.23505884f, 
    0.10866075f, -0.17687254f, -0.10665394f, -0.13318782f, 0.05420690f, -0.07232157f, -0.00805108f, 0.17055655f, 
    -0.03550181f, -0.00659186f, 0.06316954f, 0.00980874f, -0.19218463f, 0.09141454f, -0.22031564f, 0.10836817f, 
    0.01979478f, -0.00178174f, 0.00324835f, 0.03654678f, -0.05016284f, -0.05033457f, -0.01952168f, -0.00210605f, 
    -0.05110553f, -0.04828517f, 0.01386571f, 0.01157038f, 0.01759141f, 0.03585721f, 0.01404565f, -0.05329203f, 
    -0.02956565f, 0.04182015f, 0.02843435f, 0.00845806f, -0.01159987f, -0.01654520f, 0.04496598f, 0.02873032f, 
    -0.00012178f, -0.04461765f, -0.03620158f, 0.02755362f, -0.01497168f, -0.03078508f, -0.03344121f, 0.03477454f, 
    -0.01829585f, 0.00949111f, -0.00598864f, -0.00234428f, 0.01474306f, 0.04049419f, -0.05866876f, 0.02633757f, 
    -0.02083149f, -0.00360431f, -0.05482540f, 0.00665504f, -0.02972404f, 0.00382742f, -0.01776003f, 0.00931768f, 
    0.02777091f, 0.03599930f, -0.01933820f, -0.00896791f, 0.04226379f, -0.05387432f, 0.00488505f, 0.03962181f, 
    0.01518112f, -0.03695258f, 0.00157727f, -0.00812901f, 0.02427450f, 0.01577598f, 0.03571868f, 0.00623552f, 
    -0.01158660f, 0.01026327f, -0.02262382f, -0.00884737f, -0.05825981f, 0.02712817f, -0.04729250f, -0.04807315f, 
    -0.03599027f, 0.02824339f, 0.01264198f, -0.03344222f, -0.04677525f, 0.04436075f, -0.05391798f, 0.01479771f, 
    -0.00882221f, 0.00067549f, 0.01575407f, -0.00245377f, -0.01517953f, 0.00069962f, -0.04793096f, -0.05324050f, 
    0.00832495f, 0.03289543f, -0.02267082f, -0.02402672f, -0.00660388f, 0.03158304f, 0.01435284f, 0.02747547f, 
    0.01434795f, 0.01008006f, -0.01136204f, 0.00600145f, -0.03896807f, 0.01079556f, -0.02319141f, 0.01113183f, 
    -0.00876495f, 0.04108916f, 0.00523053f, 0.01975160f, 0.02426278f, -0.02362399f, 0.00279111f, -0.01700548f, 
    -0.02787067f, 0.02933315f, -0.03362401f, -0.05060010f, 0.03580187f, -0.02918432f, 0.03234977f, 0.01504473f, 
    -0.01674365f, -0.03863906f, -0.03008137f, 0.00783516f, 0.01704143f, 0.02111177f, 0.01459903f, -0.01726267f, 
    -0.02564551f, 0.01728025f, -0.01949319f, 0.03612183f, 0.02073863f, 0.01867874f, -0.01603638f, -0.01515123f, 
    0.00118943f, 0.02223273f, -0.02897176f, 0.01294751f, 0.00230294f, -0.05713011f, -0.01056746f, -0.04737454f, 
    0.00143658f, -0.00624869f, -0.04185455f, -0.01444030f, 0.00064988f, -0.01853585f, 0.02843531f, -0.00922726f, 
    -0.03254439f, -0.04893087f, -0.01385857f, -0.02484613f, -0.00211767f, -0.04035712f, -0.00126805f, -0.05779205f, 
    -0.04174868f, -0.00826524f, -0.03544442f, 0.00454571f, -0.03009981f, -0.01363346f, -0.02288020f, -0.03576365f, 
    -0.04075594f, 0.02323844f, 0.00402977f, 0.03173998f, 0.03918852f, -0.00994933f, 0.04094540f, 0.01873050f, 
    0.00221855f, 0.01715376f, -0.01839676f, -0.01740305f, 0.03074207f, 0.03594089f, -0.03073214f, 0.00793745f, 
    -0.04159093f, 0.04038408f, -0.03003101f, -0.02435304f, 0.03263590f, 0.01614083f, -0.04839800f, 0.00247692f, 
    -0.03426343f, -0.03037811f, -0.02659958f, -0.01414896f, 0.01950503f, -0.01431395f, 0.04243962f, 0.00652980f, 
    0.03196544f, -0.02443497f, -0.00036252f, 0.03706599f, -0.02176023f, -0.02378720f, -0.02672184f, 0.00674314f, 
    0.02920183f, -0.05418910f, 0.02183900f, 0.01241002f, -0.02697839f, 0.00004601f, 0.01978217f, -0.04146399f, 
    0.03982347f, -0.05755728f, -0.01064837f, 0.01126215f, -0.05408453f, 0.00070182f, -0.01716861f, 0.02900883f, 
    -0.00239213f, -0.04843916f, -0.02860099f, 0.00312038f, -0.03760331f, -0.01085876f, -0.03041061f, -0.04898133f, 
    -0.04111545f, -0.04845352f, -0.03882889f, 0.03426050f, -0.01658093f, -0.00305524f, 0.00546380f, 0.02795428f, 
    -0.01882276f, 0.01074001f, -0.05092439f, -0.00210308f, -0.02617267f, 0.03583451f, -0.01140495f, 0.00617004f, 
    -0.04437706f, 0.04338299f, -0.03274495f, 0.00646280f, 0.02932684f, 0.03770456f, -0.02545116f, -0.01641734f, 
    -0.02041509f, 0.01167172f, -0.03022128f, 0.03300450f, 0.00274699f, 0.00350357f, -0.03321220f, -0.02507313f, 
    -0.02739770f, -0.00956656f, -0.05841266f, 0.02829744f, -0.04123175f, -0.01057100f, 0.01867721f, -0.01826091f, 
    0.00075301f, -0.00748402f, -0.01933286f, -0.01211622f, 0.02758981f, -0.02657072f, 0.01099642f, -0.03235450f, 
    -0.00635722f, 0.00079850f, 0.02563549f, -0.00779462f, 0.02821560f, 0.00245289f, -0.03675105f, -0.01426735f, 
    0.02301021f, -0.05411578f, 0.01876545f, 0.02528107f, -0.03931692f, -0.03053972f, -0.04616744f, -0.03029655f, 
    -0.00722151f, -0.00865811f, -0.00404099f, -0.04362071f, 0.00094758f, -0.01042543f, -0.03428838f, 0.02501062f, 
    0.00596946f, -0.00272624f, 0.02007561f, -0.05277063f, 0.00686958f, 0.03230074f, 0.00180780f, -0.01605272f, 
    0.02994776f, -0.02554311f, 0.01167171f, -0.02115699f, 0.01937118f, -0.02655696f, -0.04040255f, -0.04988278f, 
    0.00511457f, 0.02187527f, 0.00022456f, -0.00043699f, -0.02556935f, -0.04286066f, -0.04725831f, -0.01415672f, 
    -0.01178442f, -0.03444444f, 0.02790532f, -0.01562086f, 0.00315936f, -0.02640100f, 0.02739852f, -0.01864540f, 
    -0.05803482f, -0.01907358f, -0.01463726f, 0.01705797f, 0.00635132f, 0.02105117f, -0.01050922f, 0.03666478f, 
    0.03468409f, 0.02926904f, -0.03635751f, 0.03273469f, -0.03862138f, 0.02721926f, 0.03834293f, -0.04148670f, 
    0.01965011f, -0.02210927f, 0.00061295f, -0.02291215f, 0.03072927f, -0.02758878f, 0.03707735f, -0.00933077f, 
    0.01789488f, 0.02724442f, 0.01331494f, 0.02917141f, 0.01684071f, 0.02179301f, -0.04366173f, -0.04077271f, 
    -0.05386860f, -0.05173901f, -0.05299778f, -0.04011447f, 0.02477802f, 0.00365205f, 0.03660286f, 0.02721028f, 
    0.03331152f, 0.01068737f, 0.01463583f, -0.00779217f, -0.03518380f, -0.01972627f, -0.02977240f, -0.00293709f, 
    0.12184747f, -0.12650917f, -0.07837977f, 0.05294921f, 0.12413305f, 0.08669715f, 0.06654680f, 0.14640303f, 
    0.05753322f, -0.12195635f, -0.05526381f, -0.03089136f, -0.17163043f, 0.11612565f, 0.20613632f, -0.15261759f, 
    0.00306359f, -0.16610688f, -0.05049916f, 0.13242795f, 0.09739319f, -0.04323274f, 0.05566455f, -0.06846877f, 
    -0.08956628f, 0.16371015f, -0.19210148f, 0.16823062f, 0.13933268f, -0.06220211f, -0.25576279f, -0.01430011f, 
    0.03803435f, 0.13004592f, -0.19400042f, -0.06045460f, 0.13978657f, 0.02917586f, 0.22677964f, -0.02967803f, 
    0.17650549f, 0.03585121f, -0.01628431f, -0.10267647f, 0.14330041f, 0.03077891f, -0.03429926f, 0.11773209f, 
    -0.39156359f, -0.03901533f, 0.08807629f, 0.31792426f, 0.01256460f, -0.15035784f, 0.01654743f, 0.06751662f, 
    0.21361497f, -0.03996707f, 0.25892833f, 0.11737650f, -0.08496326f, 0.10314260f, 0.10660096f, -0.02122216f, 
    0.03756018f, 0.13467753f, 0.04303696f, 0.23593748f, -0.09094773f, -0.03907145f, -0.04812861f, -0.09659720f, 
    0.17401350f, -0.07590588f, 0.05437250f, -0.08225594f, 0.10345481f, -0.07165395f, -0.07036307f, -0.21102780f, 
    -0.01476155f, -0.03395060f, 0.05771048f, -0.27805200f, 0.34724823f, -0.40100548f, -0.16633168f, 0.21665750f, 
    0.11273552f, 0.02140352f, -0.14497231f, 0.19697173f, 0.02295193f, -0.05331617f, 0.08974382f, 0.07596188f, 
    -0.45546296f, 0.19719781f, 0.09902346f, -0.07759757f, -0.08001718f, 0.07692508f, -0.16741763f, 0.04766219f, 
    0.17224841f, 0.16392872f, 0.17965700f, 0.11781872f, -0.03341823f, -0.05517809f, 0.06325021f, 0.10275587f, 
    -0.00141181f, -0.06540600f, 0.03002528f, 0.22103590f, 0.00193422f, 0.13141821f, 0.09576271f, 0.08462732f, 
    0.05592912f, 0.01262688f, -0.01170565f, -0.02074901f, 0.00850311f, -0.03915249f, 0.00386236f, -0.06540930f, 
    -0.04716180f, 0.14349985f, 0.08956806f, 0.01662073f, 0.05982294f, 0.06969512f, -0.02054788f, 0.18055907f, 
    0.19960189f, 0.04202974f, -0.10267095f, -0.02099712f, -0.10465556f, -0.00384185f, -0.17903997f, -0.09178255f, 
    0.30242047f, -0.16030057f, 0.03522022f, 0.06751368f, 0.05376288f, -0.09508493f, -0.07900853f, -0.35011858f, 
    0.11077118f, 0.08419332f, -0.01175835f, 0.13819540f, 0.26304650f, -0.16558306f, 0.26376903f, 0.02475148f, 
    0.05055597f, -0.03807370f, 0.03918306f, -0.15621558f, -0.07057701f, 0.09181131f, -0.00085747f, 0.05435163f, 
    0.03838276f, 0.26577863f, 0.37816849f, 0.06284358f, -0.17376231f, -0.04924024f, 0.11051892f, 0.13295294f, 
    0.00073754f, 0.10980807f, -0.02343003f, -0.12539789f, -0.35573354f, -0.04519495f, -0.04406318f, 0.15484951f, 
    -0.01281267f, 0.08969240f, -0.27812719f, -0.25515381f, 0.08417036f, 0.03086468f, -0.05079927f, 0.22101057f, 
    0.02338707f, -0.12517338f, 0.07612742f, 0.15284216f, -0.07074250f, 0.16630523f, -0.01763242f, -0.04324467f, 
    0.15574059f, -0.03489431f, -0.03590828f, 0.03707009f, -0.07545282f, -0.12822151f, 0.13447116f, 0.00031890f, 
    -0.03834531f, 0.16092055f, -0.06504487f, 0.00153095f, 0.13576037f, -0.05425273f, -0.07633538f, 0.12789212f, 
    0.27673307f, -0.00949162f, -0.00725774f, 0.25636703f, 0.08847172f, -0.06969965f, 0.02478251f, -0.10008483f, 
    0.13588619f, 0.09867884f, 0.01385782f, -0.10865784f, -0.10388795f, -0.06709367f, -0.28423825f, 0.02075098f, 
    0.09097958f, -0.22051917f, -0.16843563f, -0.01403791f, -0.13911040f, 0.24115884f, -0.02490088f, -0.07723637f, 
    -0.12989703f, -0.03122679f, 0.04886655f, 0.06795325f, -0.01815626f, 0.05119010f, 0.04386751f, -0.02941884f, 
    -0.01402353f, -0.02831900f, 0.08394404f, -0.02070784f, -0.34613624f, 0.14077033f, 0.38988090f, 0.10347629f, 
    0.02752567f, 0.06109489f, 0.05011258f, -0.14058526f, 0.00995668f, 0.05767528f, 0.08124854f, 0.01946295f, 
    0.12528349f, -0.01091492f, 0.06666975f, 0.17683046f, -0.10797488f, 0.05806716f, 0.09453836f, 0.09590352f, 
    0.08951124f, -0.01889377f, 0.01889022f, -0.02994772f, 0.00673152f, 0.01733792f, 0.17298879f, -0.05031133f, 
    -0.02426545f, 0.11954305f, 0.04327656f, 0.08620633f, 0.02951862f, 0.06127680f, 0.07188033f, 0.06994269f, 
    -0.20050135f, -0.51655859f, -0.07475915f, -0.29342553f, 0.10190431f, -0.13896036f, 0.05457886f, -0.10570607f, 
    0.13943419f, 0.06241099f, -0.10947137f, -0.05097619f, -0.02634422f, 0.09737366f, -0.00637705f, 0.12934084f, 
    0.13414440f, -0.05118812f, -0.10314552f, 0.19223261f, 0.02525638f, 0.05214177f, -0.01545356f, 0.16357900f, 
    0.10256015f, 0.42578062f, 0.01437858f, 0.33430594f, 0.27192566f, -0.04083207f, -0.05760224f, -0.04572151f, 
    -0.09152197f, -0.14060955f, -0.03747032f, 0.04676371f, 0.04732512f, -0.08033296f, -0.05000373f, 0.00887053f, 
    0.19069764f, 0.10164731f, 0.01152199f, -0.10302917f, -0.07908776f, -0.03685838f, -0.02863036f, -0.21630889f, 
    -0.06121399f, 0.46465039f, -0.22056733f, -0.29836217f, 0.00446719f, 0.10128017f, -0.06625362f, 0.11853351f, 
    0.04544961f, -0.03054650f, -0.04962153f, 0.14462887f, 0.02308822f, 0.00347783f, 0.17478356f, 0.21052872f, 
    0.17037870f, -0.06561513f, 0.03461729f, -0.19324327f, -0.00586260f, -0.10931056f, -0.04032378f, -0.08220422f, 
    0.03434108f, -0.25269666f, 0.22283518f, -0.27959034f, -0.22369057f, 0.18487488f, 0.08706640f, -0.19964606f, 
    -0.12746441f, 0.14516328f, 0.09082600f, 0.14988096f, 0.06498767f, 0.06227285f, 0.01205862f, 0.15030263f, 
    0.11929383f, 0.00957354f, -0.08853826f, 0.07245138f, -0.05932244f, -0.10450555f, 0.10761930f, -0.13942631f, 
    0.06050561f, -0.06155768f, -0.04331411f, -0.11762297f, 0.11758582f, 0.11540714f, 0.07879665f, 0.10723189f, 
    -0.00603816f, 0.09939956f, -0.02710941f, 0.10584798f, -0.18198912f, 0.03960957f, -0.03932529f, -0.00628033f, 
    0.00864115f, -0.13023691f, -0.07052989f, 0.04253468f, 0.01077503f, 0.03375163f, 0.04717519f, 0.07298425f, 
    0.19285171f, -0.13672438f, 0.22588210f, -0.05973909f, 0.04284040f, -0.12342898f, 0.00102290f, 0.05664185f, 
    0.08148190f, 0.02152508f, 0.12700179f, 0.06786662f, 0.20873091f, 0.12784708f, 0.26924857f, -0.26042697f, 
    0.06325005f, -0.02347567f, 0.09309734f, 0.22902969f, -0.05838924f, -0.10462105f, -0.17995337f, -0.01100007f, 
    -0.04294371f, -0.09254333f, -0.02013419f, 0.01448954f, 0.01115171f, 0.02903566f, 0.02173539f, -0.03938018f, 
    -0.02900616f, -0.05610190f, 0.09132768f, -0.10324738f, 0.15341645f, 0.15935120f, 0.01265104f, -0.08763275f, 
    -0.07543606f, 0.09041089f, 0.17083010f, 0.00821648f, 0.11349574f, 0.05360338f, 0.03085769f, 0.10519268f, 
    -0.13758318f, -0.01400379f, 0.06413131f, -0.08578204f, -0.09511167f, 0.05553329f, -0.06324571f, -0.03778173f, 
    0.19083542f, 0.05191788f, 0.13233928f, 0.03527623f, -0.29083818f, -0.48261145f, -0.36726424f, -0.27857104f, 
    0.08456543f, 0.08891932f, -0.02474780f, 0.04405956f, 0.12106192f, 0.03862158f, 0.07468461f, -0.07895987f, 
    -0.27678162f, -0.02310634f, 0.10632104f, -0.04232185f, -0.02600510f, -0.02641422f, -0.06707063f, 0.07429761f, 
    -0.25698185f, -0.05353605f, -0.03439675f, -0.32068062f, 0.08422227f, 0.08033472f, 0.00196604f, 0.02887349f, 
    0.09013499f, 0.16561541f, 0.01901108f, 0.06268217f, -0.22516386f, -0.08630846f, -0.02286304f, -0.14111033f, 
    -0.38636333f, 0.26138523f, -0.09426199f, -0.17113236f, -0.00177989f, 0.01767475f, 0.11371506f, 0.01118863f, 
    0.04658968f, 0.02057217f, 0.01377812f, -0.00256764f, -0.28707847f, -0.06365144f, -0.16419460f, 0.07540701f, 
    0.23341611f, 0.13702387f, 0.02130968f, -0.00380916f, 0.08968440f, 0.08863571f, 0.13574351f, 0.13661772f, 
    0.30417314f, -0.09288879f, -0.13627034f, -0.30479771f, 0.12550676f, -0.11541608f, -0.02999727f, -0.18633516f, 
    0.21408032f, -0.00529935f, 0.07890590f, -0.07659010f, 0.16153906f, -0.19029197f, 0.21520516f, -0.16493107f, 
    0.02653374f, -0.14451790f, 0.02352364f, 0.15581095f, -0.02729053f, -0.08485814f, -0.15854743f, -0.20715337f, 
    0.30773026f, 0.41506359f, 0.52114296f, -0.01948971f, -0.20428263f, 0.01178832f, 0.17158629f, 0.05797296f, 
    0.09447183f, 0.02874303f, 0.02511232f, -0.02928851f, 0.00803014f, 0.08812515f, -0.18273494f, 0.15550783f, 
    -0.03743091f, 0.02806806f, -0.06497739f, 0.02348884f, 0.00527761f, 0.13540941f, 0.07918330f, 0.15978804f, 
    -0.09107377f, 0.04300033f, -0.09297756f, -0.31477258f, 0.14353330f, 0.07490414f, 0.12985745f, 0.08986105f, 
    -0.05992428f, -0.13788901f, -0.17857859f, -0.04142053f, -0.18680133f, 0.22742757f, 0.12781174f, 0.17028685f, 
    -0.03986158f, -0.11903286f, -0.11779415f, -0.00895627f, -0.04640197f, -0.11425249f, -0.03273168f, -0.02013801f, 
    0.29246539f, -0.13084370f, 0.24980322f, 0.02454295f, 0.30872446f, 0.15184197f, -0.16707146f, -0.01374574f, 
    0.07628389f, 0.10042907f, 0.05056173f, -0.03902783f, 0.12001687f, -0.00591983f, 0.00659182f, 0.09388752f, 
    0.13417856f, -0.21891262f, 0.08688721f, 0.13846242f, 0.00244063f, 0.09431036f, -0.00287152f, 0.32458046f, 
    -0.14159194f, 0.02089347f, 0.08861947f, 0.16246426f, -0.03565079f, -0.02828925f, -0.09804156f, -0.00379655f, 
    0.04270380f, 0.07048633f, 0.00131892f, -0.29953906f, 0.08331091f, -0.03564008f, -0.08695582f, 0.08057922f, 
    0.01074517f, -0.00849740f, 0.05318673f, 0.18985362f, -0.03808753f, 0.08446329f, 0.11365390f, -0.04096246f, 
    0.08173655f, -0.00912297f, -0.14047907f, -0.11126089f, 0.22885492f, 0.23152076f, 0.14337382f, 0.01637330f, 
    0.06458825f, 0.15174657f, -0.09792619f, 0.05606016f, 0.02377313f, -0.43685696f, -0.33474144f, -0.12834069f, 
    0.03319893f, 0.14367722f, -0.01522721f, 0.13027787f, -0.02729232f, 0.05244708f, -0.01210094f, -0.12288395f, 
    -0.09095584f, -0.32191446f, -0.26285741f, -0.04426327f, 0.02811384f, 0.12889244f, 0.06949352f, 0.17768197f, 
    0.16891094f, -0.00538838f, -0.02104608f, -0.08047707f, 0.07087517f, 0.14015566f, -0.05676271f, 0.06810973f, 
    0.12524502f, 0.08259690f, 0.03289883f, 0.07150196f, -0.04433417f, -0.02129178f, 0.00371534f, -0.05204687f, 
    0.26651508f, 0.08382372f, -0.32229173f, -0.18865231f, 0.19117309f, 0.02536498f, 0.01492496f, 0.04163197f, 
    0.05873951f, 0.15596543f, -0.06329229f, 0.12184197f, -0.13900633f, -0.12111477f, -0.11084805f, 0.01274818f, 
    0.03930710f, -0.08833814f, -0.01983317f, -0.10844675f, 0.14872000f, 0.03001450f, 0.12416725f, 0.17589386f, 
    0.12001539f, 0.62065738f, -0.12506770f, -0.10966974f, 0.04355954f, -0.00908669f, 0.20631585f, -0.00998399f, 
    0.05155452f, -0.07821209f, -0.00161605f, -0.07950875f, 0.19104728f, 0.05062325f, 0.09927893f, -0.11565863f, 
    -0.09366508f, -0.06542140f, -0.08037148f, -0.07757942f, 0.07673860f, 0.17989929f, 0.15174337f, 0.12584732f, 
    -0.09720369f, -0.15166283f, 0.11381713f, 0.00594348f, 0.00339157f, 0.07943054f, -0.12000667f, -0.07149161f, 
    -0.17383826f, 0.13627920f, 0.28815946f, 0.03302675f, 0.23050809f, 0.19789888f, 0.01870307f, -0.04323533f, 
    0.06143636f, 0.07954028f, -0.01404504f, 0.14731348f, 0.06269219f, -0.01939213f, 0.09693543f, 0.04008475f, 
    0.00143150f, -0.04872628f, -0.04228406f, 0.02335221f, 0.03576127f, 0.02759921f, -0.04101495f, -0.05078331f, 
    0.03985194f, 0.02772198f, -0.00904725f, -0.01820097f, 0.04423986f, -0.02652008f, -0.05171666f, -0.05128578f, 
    -0.01417706f, 0.03268261f, -0.02444500f, -0.04552493f, 0.01057147f, 0.00578369f, -0.03520667f, -0.03670023f, 
    0.00137251f, 0.01148874f, 0.02734953f, -0.02520148f, -0.05070725f, -0.00547604f, 0.01946048f, 0.01895258f, 
    0.00490210f, -0.01357456f, -0.05491842f, -0.01817682f, 0.03372868f, -0.01030844f, 0.03006548f, -0.02642795f, 
    -0.00390517f, -0.02529532f, -0.04200933f, -0.04020851f, 0.03149899f, 0.00689353f, 0.03947641f, -0.02045808f, 
    -0.05216758f, -0.02764282f, -0.02590560f, -0.03761779f, 0.01772707f, 0.00405898f, 0.03238080f, 0.02588540f, 
    0.01470354f, 0.04404818f, -0.01290242f, -0.02850533f, -0.00513223f, -0.03360576f, 0.00178342f, 0.03163773f, 
    0.00727750f, -0.01829866f, 0.04220115f, -0.05545294f, 0.00372619f, 0.04352905f, -0.02788954f, -0.02310103f, 
    0.01000461f, 0.01737237f, -0.01389234f, -0.00579817f, 0.02131688f, -0.05446612f, -0.03210548f, -0.02384318f, 
    -0.03767525f, -0.03520121f, -0.00481693f, 0.03645248f, -0.05017747f, 0.03639487f, -0.03635703f, -0.00347360f, 
    0.00895743f, -0.03908312f, -0.04142361f, -0.04008385f, 0.01926517f, 0.02824619f, 0.03848776f, 0.04131968f, 
    -0.00791666f, -0.02066046f, -0.04366428f, -0.03443852f, 0.02268923f, -0.02457476f, 0.00816631f, -0.03283332f, 
    0.02984639f, 0.02016430f, 0.00909677f, -0.03863063f, -0.04942655f, 0.03362326f, 0.01994564f, 0.02603158f, 
    0.02390774f, 0.02707377f, 0.03296202f, 0.01489998f, -0.02456598f, 0.03631518f, -0.04327535f, 0.04187043f, 
    -0.01083160f, 0.01332080f, 0.04330572f, -0.01502495f, -0.04368740f, -0.00836687f, -0.03052844f, 0.02126363f, 
    0.01274382f, 0.00846512f, -0.00931096f, -0.03527633f, 0.01647565f, 0.03154129f, 0.04428322f, -0.03190545f, 
    -0.00400173f, -0.01266960f, 0.03830227f, 0.04550417f, 0.03299886f, -0.01845241f, -0.03658955f, 0.01696722f, 
    0.04015421f, -0.01517238f, 0.01733257f, 0.00560359f, 0.03631013f, -0.04078690f, 0.01529673f, -0.05628424f, 
    -0.00496926f, 0.02964779f, 0.00610894f, -0.01738363f, -0.00430676f, 0.02963551f, 0.04303239f, -0.00922285f, 
    -0.00857515f, -0.03330671f, -0.01200720f, 0.02521679f, -0.01753320f, 0.02644915f, 0.03398824f, -0.04402289f, 
    -0.00954070f, 0.04146076f, -0.01559349f, 0.03452468f, -0.00219374f, -0.03477233f, 0.01912604f, 0.01330322f, 
    0.00161070f, -0.00102357f, 0.02548620f, 0.01188424f, -0.03706145f, -0.01169406f, 0.02467365f, -0.02802001f, 
    0.04033578f, -0.00333436f, 0.03662779f, -0.03600594f, -0.04113399f, 0.03817659f, -0.04144667f, -0.05045177f, 
    0.02639984f, -0.01609470f, 0.03792030f, 0.04404492f, -0.02075813f, 0.04045099f, -0.03292572f, 0.02175436f, 
    -0.00552631f, -0.04496138f, 0.02022820f, -0.04111391f, -0.03789349f, -0.02806267f, -0.00195742f, -0.04641683f, 
    -0.04845625f, -0.01941532f, 0.04465626f, 0.02797336f, -0.03889097f, -0.04403332f, 0.01251460f, -0.04388129f, 
    0.04419067f, -0.02572518f, -0.04095996f, -0.02703553f, 0.02637029f, -0.05271395f, 0.02303656f, -0.04972627f, 
    -0.02297865f, 0.00822324f, -0.04789117f, 0.01050003f, 0.04183302f, 0.03614905f, 0.02407921f, -0.03010639f, 
    0.02294206f, 0.04909167f, -0.02766118f, 0.03561386f, 0.02324941f, 0.00339951f, 0.03025137f, -0.04488447f, 
    -0.01987637f, -0.04919657f, -0.03784345f, 0.02619362f, -0.00826095f, 0.02827805f, 0.00558941f, 0.02328566f, 
    -0.03539395f, 0.01165841f, -0.00209030f, -0.01478615f, -0.00803622f, -0.04173046f, -0.02846788f, 0.00707003f, 
    0.00260011f, -0.00005502f, -0.03125392f, -0.04339346f, -0.00904574f, -0.04144643f, -0.05365858f, 0.01403346f, 
    -0.03901623f, -0.01824517f, -0.01656423f, -0.04851634f, -0.02792114f, 0.03730073f, -0.01904807f, 0.02730370f, 
    0.04171017f, 0.02176263f, 0.03469878f, -0.04961652f, -0.01317849f, 0.04315643f, 0.03204187f, 0.03712621f, 
    -0.04256271f, -0.05494279f, -0.02308008f, -0.04743972f, -0.02293525f, 0.03786553f, -0.03673320f, 0.00606133f, 
    -0.00017144f, -0.04970902f, -0.01224428f, -0.00469241f, -0.05456765f, -0.02403864f, -0.04264518f, -0.00698564f, 
    -0.02475345f, 0.02668575f, 0.02022483f, 0.02583268f, 0.01736580f, -0.04355485f, -0.05524006f, -0.00779662f, 
    -0.03479366f, -0.00374383f, -0.05027424f, -0.03925105f, -0.00486912f, 0.01879170f, 0.02625224f, 0.00036407f, 
    -0.02878486f, 0.02260911f, 0.03448249f, 0.02436917f, -0.04821417f, -0.03445844f, 0.01589101f, -0.04158366f, 
    -0.00911297f, -0.02388573f, 0.04331219f, 0.01222595f, 0.00176192f, -0.02289491f, -0.04627050f, 0.01354555f, 
    0.02028894f, -0.01598718f, -0.01062456f, -0.02206584f, 0.01711860f, 0.03929329f, 0.03606042f, -0.00715735f, 
    -0.02961694f, 0.00780379f, -0.02504924f, -0.03834047f, -0.03898092f, 0.03201041f, -0.04321961f, -0.05507967f, 
    0.02371101f, -0.03562286f, -0.05531684f, -0.02529540f, 0.01102292f, 0.03837899f, -0.01840484f, 0.02263634f, 
    -0.02145986f, 0.03893090f, -0.04213398f, -0.02743297f, -0.00586270f, -0.04971732f, 0.03369698f, 0.00325522f, 
    -0.04675049f, -0.04498708f, -0.05360327f, 0.01465376f, -0.01498653f, 0.02642562f, -0.03214116f, 0.03248290f, 
    -0.05346819f, 0.01528783f, -0.03858742f, 0.00096566f, 0.05739531f, -0.00495944f, -0.05233869f, 0.02666488f, 
    -0.01383308f, -0.04790250f, 0.00865816f, 0.02826568f, -0.01272312f, 0.04076046f, 0.02348832f, -0.03310965f, 
    -0.00978949f, -0.02569321f, 0.02809387f, 0.01046445f, -0.02014035f, 0.02347575f, -0.04118121f, -0.02739925f, 
    -0.00403106f, -0.02130293f, -0.04299441f, -0.00884201f, 0.02762622f, 0.04187227f, -0.04644883f, 0.03417883f, 
    -0.03679298f, 0.01601234f, -0.01458636f, 0.02277038f, 0.00646757f, -0.00751049f, -0.03715214f, -0.02441642f, 
    0.00091532f, -0.01783041f, 0.00489314f, -0.02723198f, 0.03496404f, 0.03323803f, -0.02044198f, -0.00519453f, 
    -0.00789833f, -0.02736055f, -0.00126390f, 0.01027899f, 0.00370246f, 0.01566964f, -0.05357602f, 0.01417542f, 
    0.01960926f, -0.04652857f, -0.01825581f, 0.02066021f, 0.04334814f, -0.04142389f, 0.01027291f, -0.02461497f, 
    0.00688940f, 0.01929875f, -0.01355694f, -0.02900203f, 0.02424869f, -0.02180620f, -0.00689400f, 0.00114695f, 
    0.02008588f, 0.03762272f, 0.02687439f, 0.01566735f, 0.02716831f, -0.03222314f, -0.01030565f, -0.01693669f, 
    0.00693093f, 0.01964613f, 0.01486533f, 0.03165030f, -0.05271231f, 0.02477539f, -0.00850288f, -0.00947095f, 
    -0.04855059f, 0.00792908f, -0.00821729f, -0.00056786f, -0.04234668f, 0.01576656f, 0.00232394f, -0.02467543f, 
    -0.00897643f, -0.02584703f, -0.02634753f, 0.00668051f, -0.01065268f, 0.01056033f, 0.00824027f, -0.03043811f, 
    -0.02641108f, -0.00334790f, 0.02752739f, -0.02217088f, -0.04460388f, 0.03150734f, -0.02899102f, 0.02367331f, 
    -0.00607926f, 0.01217831f, 0.01283687f, 0.03267689f, 0.03507082f, 0.00228859f, 0.02575766f, 0.00761618f, 
    -0.04150330f, 0.01676966f, -0.01867464f, -0.01944325f, -0.02822497f, 0.03536065f, -0.00664007f, -0.05290743f, 
    -0.02885775f, 0.01354307f, 0.01846683f, -0.00021350f, -0.00784127f, 0.00100715f, -0.05418257f, -0.04533623f, 
    -0.05066811f, -0.04155189f, -0.01087252f, 0.00402646f, 0.00535320f, -0.05170862f, 0.00876750f, -0.02109474f, 
    0.04409345f, -0.00132614f, -0.03279474f, 0.04477549f, -0.05378237f, -0.01747788f, -0.02191699f, 0.03326858f, 
    -0.03796332f, -0.05127528f, 0.02971945f, -0.05329324f, 0.02454323f, 0.03530772f, -0.00965269f, -0.01390110f, 
    0.00211614f, -0.03452259f, 0.02647418f, -0.03068475f, 0.02838501f, 0.04019022f, 0.00990882f, 0.04429121f, 
    -0.04753650f, -0.03574882f, -0.00915887f, 0.01257688f, -0.03627862f, 0.04676852f, 0.01174822f, -0.03020176f, 
    0.03039227f, 0.01155229f, -0.05459979f, 0.00169082f, 0.03257121f, -0.02441318f, 0.04076369f, 0.00111516f, 
    0.05078371f, 0.00910834f, 0.01669638f, -0.03158819f, -0.00234828f, 0.03906917f, 0.04358018f, -0.02962066f, 
    -0.00314383f, -0.03285888f, 0.01445410f, 0.03719129f, 0.01298794f, 0.04066692f, -0.05377720f, 0.01891398f, 
    0.02523026f, -0.00244177f, -0.04137933f, -0.04643827f, 0.00320355f, -0.02783414f, 0.01025115f, -0.05656822f, 
    0.00349912f, -0.00115132f, -0.03669969f, 0.01332883f, 0.03830165f, 0.01614988f, -0.05621248f, -0.00108575f, 
    -0.04963078f, -0.02238715f, 0.01873727f, -0.00887446f, -0.04988077f, 0.00587628f, 0.02522465f, 0.02947414f, 
    -0.03677878f, 0.01122873f, 0.02227472f, -0.03347217f, -0.01453931f, 0.02749923f, -0.04351389f, -0.04754075f, 
    -0.05595117f, -0.02351404f, 0.01508635f, -0.01104946f, -0.02449558f, -0.00195772f, -0.02856365f, 0.01250141f, 
    -0.04614209f, 0.01267740f, -0.05394587f, -0.02720736f, -0.05696449f, -0.00126649f, -0.05514381f, -0.04636195f, 
    0.02190414f, -0.03763080f, 0.02847627f, -0.05658162f, 0.04431435f, 0.01009549f, 0.02290289f, 0.00547562f, 
    -0.03385090f, -0.00932054f, -0.01185401f, -0.01167826f, -0.01424006f, 0.02221869f, -0.01699581f, 0.03283868f, 
    -0.04069628f, 0.02957027f, 0.00924554f, -0.02625680f, -0.04699723f, 0.04391766f, -0.02375851f, 0.02622364f, 
    -0.02076112f, 0.03776598f, 0.03162361f, -0.04986028f, -0.04115586f, -0.04716282f, 0.02458424f, -0.03355154f, 
    -0.01918572f, 0.02346851f, 0.01159726f, 0.03267938f, 0.01048569f, -0.01428476f, -0.04066846f, 0.02330873f, 
    -0.00553659f, -0.04607036f, 0.03419046f, 0.03325059f, 0.03683238f, 0.02205861f, -0.00022129f, -0.04836193f, 
    -0.00737306f, -0.03930247f, -0.05276625f, -0.00562894f, 0.01314288f, -0.03601341f, -0.02516068f, -0.04225682f, 
    -0.03963298f, -0.02708014f, 0.03924587f, -0.03785917f, 0.02417525f, 0.04204684f, -0.00506402f, -0.03474520f, 
    0.01682425f, -0.00417232f, -0.01078503f, -0.03998668f, -0.01185120f, -0.04124288f, -0.04678089f, -0.03118673f, 
    0.00161246f, 0.01458000f, -0.04437185f, 0.02706114f, 0.01530029f, -0.03387326f, 0.01862855f, 0.04764799f, 
    -0.03157222f, 0.04378244f, -0.05108925f, 0.00831329f, -0.02844151f, 0.02249074f, 0.04265108f, -0.03345185f, 
    0.02274098f, -0.04968167f, 0.01031109f, 0.00589400f, -0.03199726f, 0.02253432f, -0.03028533f, -0.02306465f, 
    -0.00594916f, -0.02832761f, -0.01915392f, -0.01109159f, 0.01676550f, -0.04035361f, 0.01898306f, -0.00554790f, 
    -0.04238794f, -0.04513888f, -0.01574926f, 0.00406366f, 0.00338177f, -0.00751973f, -0.01645807f, 0.00754181f, 
    -0.04812260f, -0.02115642f, 0.01835921f, -0.04231008f, -0.04213348f, -0.03081655f, -0.05079363f, 0.02545371f, 
    -0.02171509f, -0.01678169f, 0.00215253f, 0.00183261f, -0.03467573f, 0.02037622f, 0.02035894f, -0.02035900f, 
    -0.04089875f, 0.01246101f, -0.00613885f, -0.00681518f, -0.03226676f, -0.01457145f, -0.02151948f, 0.04084704f, 
    -0.00417332f, 0.04321475f, 0.00091967f, -0.01794297f, -0.02920519f, 0.01607412f, -0.04973160f, -0.02843121f, 
    -0.00060655f, -0.04983511f, -0.02754862f, 0.00825240f, 0.03519835f, 0.01912220f, 0.04128088f, 0.00573383f, 
    0.22825022f, 0.29229364f, 0.34197289f, 0.07977659f, -0.06900598f, 0.02325159f, 0.08329125f, 0.02572005f, 
    -0.00670239f, -0.12654601f, -0.13355763f, -0.07895245f, 0.34718356f, 0.14248763f, 0.06815286f, -0.01997834f, 
    0.03946768f, 0.04688018f, -0.09517556f, 0.00656153f, -0.09916371f, -0.00152002f, -0.18773900f, -0.16694239f, 
    -0.11237106f, 0.08132870f, 0.07493847f, -0.28006396f, 0.15950352f, -0.01790732f, 0.16976354f, -0.11714168f, 
    -0.13067108f, -0.02124608f, 0.08460249f, -0.01877961f, 0.08486306f, 0.26274809f, -0.20714514f, -0.01162932f, 
    0.06972398f, 0.16194673f, 0.16722746f, -0.00446878f, 0.01462096f, 0.05935365f, 0.05651641f, -0.06447210f, 
    0.08166532f, -0.06481107f, 0.19275957f, -0.01291106f, 0.04599143f, 0.05114168f, 0.01176506f, 0.03127520f, 
    -0.09163599f, 0.10857020f, -0.10190297f, 0.05931241f, 0.22893095f, 0.15185279f, 0.11493511f, 0.17765157f, 
    -0.04217536f, -0.06368992f, 0.06512161f, 0.06813470f, -0.08144506f, -0.09643304f, -0.10819807f, -0.04283018f, 
    0.15629800f, 0.33809698f, -0.18866573f, 0.20566809f, -0.04593293f, 0.09677221f, -0.10610480f, 0.12514260f, 
    -0.24813503f, -0.08040253f, -0.14053407f, -0.15392444f, 0.26617476f, -0.06440395f, -0.25095302f, -0.01864391f, 
    -0.12831171f, -0.13739732f, 0.03371647f, -0.08028463f, -0.02607642f, -0.00690120f, -0.04255208f, -0.08305956f, 
    0.42451316f, -0.07931552f, 0.26160991f, -0.03302184f, -0.00526743f, -0.07986850f, -0.22094490f, -0.04074268f, 
    -0.05640031f, -0.04138818f, -0.06404401f, -0.04785480f, 0.11508166f, 0.15280905f, 0.00899349f, 0.05136380f, 
    0.11757585f, -0.00082275f, 0.06108414f, -0.05625663f, 0.08841512f, 0.04284531f, -0.10222754f, 0.01738746f, 
    -0.01005464f, -0.09491365f, -0.37345928f, 0.42830345f, -0.17581432f, 0.05838486f, -0.06512893f, -0.01142817f, 
    -0.01139716f, -0.01701459f, 0.04255906f, 0.09921870f, 0.22611152f, -0.12408997f, -0.05943081f, -0.07418426f, 
    -0.07394411f, 0.03418152f, -0.03175530f, 0.03178569f, -0.22587781f, -0.13947761f, -0.01763058f, -0.20145169f, 
    -0.21470119f, 0.11846377f, -0.33936244f, 0.14051020f, -0.11287096f, -0.01091662f, 0.01410439f, 0.01985990f, 
    0.12066849f, 0.12676477f, -0.08584952f, 0.23081206f, -0.33966157f, 0.24656510f, -0.16494136f, -0.25571275f, 
    0.01488406f, -0.03656700f, 0.00540165f, 0.07980385f, 0.13134471f, 0.10274031f, 0.02293497f, 0.12283878f, 
    0.17185329f, 0.02825006f, -0.16116033f, 0.04321956f, 0.28565133f, -0.11588003f, 0.15983148f, -0.12601550f, 
    -0.00051397f, -0.01452799f, -0.01472241f, 0.02183738f, 0.15422285f, -0.31496635f, 0.23809521f, 0.07545768f, 
    -0.07842900f, 0.16162735f, -0.12414128f, -0.00123070f, -0.03931735f, 0.06986032f, -0.04652800f, -0.10380136f, 
    0.19059828f, 0.45269164f, -0.06109023f, 0.13641743f, 0.09530544f, -0.08203693f, 0.09005307f, -0.00315643f, 
    -0.04583219f, -0.00446453f, 0.04883743f, -0.00248932f, 0.27938893f, 0.23068017f, 0.10603260f, 0.23063180f, 
    -0.05882736f, -0.06036605f, -0.00282445f, -0.06518780f, -0.12505977f, 0.06556005f, 0.04981718f, 0.00933625f, 
    0.35101381f, 0.54726803f, 0.56640047f, -0.22816817f, -0.02090009f, 0.02650057f, -0.08786130f, 0.01021201f, 
    -0.08075566f, -0.07136780f, 0.01977157f, 0.04776253f, -0.06044269f, 0.13257939f, 0.17378980f, 0.01135661f, 
    0.03226091f, -0.00062920f, 0.01770186f, 0.08116776f, 0.14907627f, -0.01564787f, 0.09413049f, 0.02341252f, 
    0.06646249f, 0.09222061f, -0.04615134f, 0.19695762f, -0.04580408f, -0.05225078f, 0.05838053f, 0.12070337f, 
    -0.07727991f, -0.00577228f, -0.06519906f, 0.08468983f, -0.12066608f, -0.06391286f, 0.12636238f, 0.08847892f, 
    0.14868571f, 0.12313309f, -0.02085941f, -0.05180798f, -0.05563851f, 0.14322390f, 0.02325126f, 0.06861652f, 
    0.08989253f, 0.07591585f, 0.20220777f, -0.00627397f, -0.08961244f, -0.05429614f, 0.07547687f, 0.06050213f, 
    0.15624674f, -0.10838708f, 0.03623524f, 0.06326811f, -0.06658133f, 0.09664670f, -0.00654692f, 0.00727571f, 
    0.07275851f, -0.10741065f, -0.15921532f, 0.00926353f, 0.00010295f, -0.13374628f, -0.08180509f, 0.06934730f, 
    0.07405408f, 0.16746625f, -0.22675525f, 0.03892378f, -0.02591317f, -0.18156275f, 0.13111453f, -0.05066584f, 
    0.03180235f, 0.09662847f, -0.19309404f, -0.06920693f, 0.23128611f, 0.00022230f, 0.29598090f, 0.00799987f, 
    0.02094716f, -0.05484462f, -0.05361177f, 0.09517304f, 0.06598657f, 0.02011995f, 0.03833486f, 0.02854302f, 
    -0.19747704f, -0.35225192f, 0.06384059f, -0.28210250f, 0.13538620f, 0.09960836f, 0.18727814f, -0.09585309f, 
    0.21589601f, 0.00175729f, -0.07995133f, 0.09941141f, -0.00210267f, 0.00402525f, -0.03701348f, 0.03482421f, 
    0.08442752f, -0.05164027f, 0.05168311f, -0.01520650f, 0.00222777f, -0.05187758f, -0.05939512f, -0.15987982f, 
    0.13349317f, -0.16662502f, 0.02141545f, 0.41264749f, -0.11837405f, 0.10661553f, 0.13701923f, -0.09123681f, 
    0.03835568f, 0.08880990f, -0.06369870f, 0.10716119f, -0.00488261f, -0.16838509f, 0.08414147f, 0.07153311f, 
    0.06926458f, 0.06593846f, -0.05807932f, 0.18889701f, -0.10684782f, -0.16628538f, -0.19032897f, -0.11651257f, 
    -0.09458150f, -0.03867443f, 0.21167015f, 0.44528309f, 0.08384324f, -0.14977692f, 0.00388367f, -0.02530328f, 
    -0.06174384f, -0.01733502f, 0.01619563f, 0.03165269f, 0.10508172f, 0.13842624f, 0.14226104f, 0.10036763f, 
    -0.00107333f, -0.09214035f, 0.04843250f, -0.07604985f, 0.05512849f, -0.07740525f, 0.14229585f, -0.01239643f, 
    -0.10127047f, 0.18079787f, 0.14163437f, 0.22410339f, 0.04464540f, 0.00803395f, 0.11992259f, 0.04688882f, 
    0.04173857f, -0.04492129f, -0.03484546f, -0.02378959f, -0.12426006f, -0.14894716f, -0.11220458f, 0.00318346f, 
    0.11688366f, 0.13302062f, 0.06874497f, 0.17054448f, 0.14691845f, -0.07579379f, 0.01808236f, 0.02240832f, 
    -0.40306306f, -0.07266948f, -0.04332424f, 0.48416385f, -0.08204195f, -0.04112030f, 0.01117647f, -0.08376989f, 
    0.01074748f, -0.07825256f, -0.09406286f, 0.10362641f, -0.33639228f, -0.19008777f, 0.03094939f, 0.11867670f, 
    -0.08589239f, -0.08100794f, -0.09666601f, -0.06766478f, 0.16154295f, 0.03321161f, -0.08526251f, 0.04403154f, 
    -0.04281288f, -0.02487518f, -0.17395711f, 0.11451121f, 0.08545188f, -0.05130500f, -0.02549721f, 0.02270825f, 
    0.01040324f, -0.03027616f, 0.04282770f, -0.00830577f, -0.00249528f, -0.01380143f, 0.21709648f, 0.01944091f, 
    -0.01387954f, 0.06020372f, 0.06404638f, -0.07258638f, 0.09250741f, 0.05512011f, -0.07477927f, 0.02319637f, 
    0.10130073f, -0.19645315f, -0.10001261f, -0.12855244f, 0.00860588f, 0.11015739f, 0.12489370f, -0.00956317f, 
    0.10378463f, -0.12962195f, -0.01226437f, 0.00804908f, 0.33844385f, 0.11164013f, 0.05606753f, 0.00271161f, 
    -0.17127259f, -0.14202178f, -0.04792069f, -0.13609846f, 0.16831221f, -0.16379881f, 0.21732275f, 0.16235009f, 
    0.00976715f, 0.05475502f, -0.35561183f, 0.13148518f, 0.01595580f, -0.00826959f, 0.07659886f, -0.08412820f, 
    0.13200285f, -0.05982058f, -0.11484198f, -0.03814530f, 0.03631028f, 0.14081776f, 0.18469974f, -0.11764149f, 
    0.02811501f, 0.01616361f, -0.03335073f, 0.09497138f, 0.04549957f, -0.02191187f, 0.08407975f, 0.03900898f, 
    0.47243416f, -0.33710870f, 0.26598278f, -0.05462580f, 0.06561945f, -0.13206790f, -0.07239644f, -0.09788016f, 
    0.16000317f, -0.05401289f, -0.17232366f, 0.04623871f, 0.08919687f, -0.04364614f, -0.14500627f, -0.15155159f, 
    0.15655024f, 0.08624608f, -0.01466383f, 0.09171130f, 0.01076906f, -0.13488249f, 0.02177659f, -0.12038289f, 
    0.13181871f, -0.22348008f, 0.33944911f, 0.14411832f, -0.02800024f, 0.00957591f, -0.12967530f, -0.02889549f, 
    -0.11627789f, -0.00126208f, 0.01081888f, 0.03754640f, 0.04080527f, 0.07840993f, -0.01262167f, -0.08180285f, 
    0.00676986f, -0.07835945f, 0.06155057f, -0.17865290f, 0.20413671f, 0.04939379f, -0.03779003f, 0.16048650f, 
    0.16242531f, -0.40369222f, -0.01544524f, 0.06007463f, 0.13470215f, 0.09384106f, 0.16236454f, 0.22205193f, 
    -0.01692847f, -0.07897366f, -0.01773650f, 0.01835633f, -0.08911454f, -0.07114559f, 0.07561617f, -0.14517108f, 
    0.06728984f, -0.21170509f, -0.04402848f, -0.02671758f, 0.29652739f, 0.06744102f, 0.03393264f, -0.09736787f, 
    -0.18390501f, -0.00621770f, 0.03107445f, -0.05021318f, 0.03147389f, 0.05792902f, -0.05493256f, 0.05711937f, 
    0.13975103f, -0.06096145f, 0.03146360f, -0.07745299f, 0.32502395f, -0.22788508f, -0.05735199f, 0.13634695f, 
    0.10895469f, -0.02164537f, 0.09095762f, 0.02314680f, 0.00882569f, -0.00051968f, 0.05389025f, -0.00239199f, 
    -0.29759210f, -0.19103974f, -0.17196886f, 0.07728515f, 0.03392834f, 0.21493691f, 0.10811407f, 0.01313166f, 
    -0.01130794f, -0.10669100f, 0.01637812f, -0.11420359f, 0.28647712f, -0.27198240f, 0.18030393f, 0.21683563f, 
    0.00419695f, 0.24423711f, -0.23463437f, 0.01756238f, -0.05017631f, -0.07114331f, 0.14039299f, 0.10307533f, 
    0.26472691f, -0.13528873f, 0.09530257f, -0.25277796f, 0.03758277f, -0.05830663f, -0.07489110f, -0.01244920f, 
    0.15768710f, 0.05393657f, 0.00590678f, 0.08441613f, -0.10772390f, 0.24817184f, 0.15462013f, -0.11406859f, 
    -0.13489798f, -0.02642082f, 0.04077614f, -0.04114423f, 0.07162386f, 0.08572026f, -0.13069789f, 0.01823285f, 
    0.01318014f, 0.05890134f, 0.18472950f, 0.03141275f, 0.05515490f, -0.09054725f, -0.00336834f, -0.10531164f, 
    0.11192084f, 0.02242401f, 0.06646444f, -0.10527504f, 0.15624723f, 0.05747842f, -0.08054153f, -0.17734081f, 
    -0.04149682f, -0.08599796f, -0.09866589f, 0.04031222f, 0.09708810f, -0.04620787f, 0.03076268f, 0.07853709f, 
    0.18382460f, 0.12700516f, 0.08912080f, -0.10658641f, -0.00992648f, -0.01283635f, -0.17604885f, 0.08523548f, 
    0.05757271f, 0.05174515f, 0.09809709f, 0.09103337f, 0.00630930f, 0.25444168f, 0.02305528f, 0.10475472f, 
    0.02021388f, 0.00244998f, 0.06059612f, -0.02717214f, -0.00012424f, -0.01829226f, 0.12492196f, -0.05974150f, 
    0.22223879f, -0.16363746f, 0.13272166f, 0.47098514f, -0.17130908f, -0.07431500f, 0.06765742f, 0.04443502f, 
    0.26931077f, 0.05746946f, -0.01160863f, 0.05177251f, 0.19972780f, -0.10867982f, 0.09313669f, -0.05535856f, 
    -0.11321845f, -0.08318972f, -0.08095361f, -0.00295869f, 0.01575743f, -0.01213131f, 0.11161754f, -0.04320885f, 
    -0.05446170f, -0.46412376f, 0.34674904f, -0.01266616f, -0.11240067f, -0.02180014f, -0.17252129f, 0.13497095f, 
    0.14275627f, 0.01669793f, -0.11037663f, 0.02455506f, -0.33289587f, 0.03066436f, 0.12962182f, 0.26545954f, 
    0.01108251f, -0.06962921f, -0.08246379f, -0.13127913f, -0.05009830f, -0.17102671f, -0.12893571f, 0.03700672f, 
    0.32338917f, -0.08169735f, -0.36804849f, -0.16251650f, 0.09155127f, -0.11754933f, 0.07113572f, -0.03277788f, 
    0.15505040f, -0.02295178f, 0.01232225f, 0.02001216f, -0.03636041f, 0.04578962f, 0.17824161f, -0.10178143f, 
    0.06083758f, 0.06181028f, 0.08437034f, 0.07972288f, 0.10568119f, -0.02445205f, 0.02525516f, -0.03988225f, 
    -0.03915084f, -0.01599904f, -0.00970001f, 0.00597981f, -0.01563124f, -0.05525660f, -0.04639351f, -0.03223965f, 
    -0.01583606f, 0.02327191f, 0.01598618f, 0.01469050f, -0.03758690f, -0.05130995f, -0.01487768f, -0.00795866f, 
    -0.00170657f, 0.01574010f, 0.00116617f, -0.00561178f, 0.00976051f, 0.00911374f, -0.02521506f, 0.02459937f, 
    0.04065500f, -0.03332074f, 0.00049243f, 0.00256042f, -0.01184591f, -0.03883229f, -0.00612858f, -0.01471507f, 
    -0.03874370f, -0.05565057f, 0.03495467f, -0.00282691f, -0.04337442f, -0.02848644f, -0.01823121f, 0.00356713f, 
    -0.03078978f, -0.00014638f, -0.03809856f, 0.03358012f, -0.02411837f, 0.02309120f, 0.00032200f, -0.04531747f, 
    0.03588956f, -0.01014462f, -0.02442109f, 0.01889416f, -0.03616679f, -0.02199475f, 0.01634988f, 0.04030475f, 
    -0.01030171f, 0.01391090f, -0.02161420f, 0.00185312f, -0.04981557f, -0.04215598f, 0.03960413f, -0.02666845f, 
    -0.03635278f, -0.00695051f, -0.02007435f, -0.01591396f, 0.01031764f, 0.03556712f, 0.00840301f, -0.04449948f, 
    -0.05021526f, -0.01665444f, 0.03395885f, 0.03269731f, -0.02490062f, 0.02350771f, -0.01478165f, 0.03934865f, 
    0.00772826f, -0.01901897f, 0.03320615f, -0.00996336f, -0.01722107f, 0.00068053f, 0.02900439f, -0.00214754f, 
    0.03188732f, -0.04004433f, 0.00965903f, -0.02077829f, 0.02370870f, 0.03104921f, -0.05388322f, -0.01796706f, 
    0.00072003f, 0.01452438f, -0.02599611f, -0.03977695f, -0.00327098f, -0.03704350f, -0.02244638f, 0.00027177f, 
    -0.03697496f, 0.01471139f, 0.01230006f, 0.00860149f, -0.00553752f, -0.04180202f, 0.02071751f, 0.01543381f, 
    0.01585091f, -0.00185384f, -0.02714745f, -0.03632420f, -0.05541424f, 0.01646286f, -0.04209585f, -0.01824188f, 
    -0.00625797f, -0.01986845f, -0.04369580f, -0.03021510f, 0.01529808f, -0.03492840f, -0.04756823f, 0.01467933f, 
    0.02699089f, 0.03826973f, 0.01493197f, -0.01049187f, -0.01739169f, -0.00103097f, -0.00840935f, 0.00019167f, 
    0.02516123f, -0.00253348f, 0.03749199f, 0.01940591f, -0.04676416f, -0.00286243f, -0.00167971f, -0.05632131f, 
    0.01957399f, 0.03930098f, 0.01434886f, -0.01957669f, -0.05447959f, -0.01446115f, 0.04455554f, -0.04125158f, 
    -0.04433396f, -0.04122031f, 0.02806280f, 0.04030882f, 0.02886792f, -0.04787902f, -0.02331386f, 0.04126115f, 
    -0.03286705f, -0.05152554f, 0.04722108f, 0.04910700f, -0.02193002f, -0.05007954f, -0.02499737f, 0.00394684f, 
    0.01246370f, -0.02672137f, 0.04770680f, 0.01729276f, 0.02469939f, -0.05566262f, 0.01818793f, -0.01598039f, 
    -0.00155799f, 0.04248022f, 0.04543701f, -0.03774318f, -0.04221819f, -0.01926386f, -0.03084134f, -0.01800449f, 
    -0.00907489f, 0.04214123f, 0.02216809f, -0.04079746f, -0.04903142f, -0.03843921f, -0.04227198f, 0.00673962f, 
    0.03853010f, 0.01826576f, -0.04043243f, 0.02619524f, -0.05331485f, 0.03676573f, -0.01057104f, -0.00206182f, 
    -0.00371101f, -0.04283843f, -0.03724372f, 0.04023321f, -0.02527447f, 0.01218086f, 0.00462105f, 0.04172080f, 
    0.02085065f, 0.04108284f, -0.02398858f, -0.01134793f, -0.00125456f, -0.00339711f, -0.04537481f, -0.02882347f, 
    -0.05597354f, 0.00145347f, 0.01130691f, -0.03074872f, -0.00720426f, 0.04105299f, -0.04887910f, 0.03280148f, 
    -0.05552655f, -0.02895673f, -0.02700260f, 0.00820934f, -0.01889686f, -0.04280396f, -0.05518558f, -0.01330044f, 
    -0.05451960f, -0.04442059f, 0.02312053f, 0.03302186f, -0.03587463f, 0.00102630f, 0.00065884f, -0.02689582f, 
    -0.02665308f, 0.03955385f, 0.01348127f, 0.00471862f, -0.02486382f, -0.00384268f, -0.01631818f, -0.03319271f, 
    -0.05469094f, -0.00609610f, 0.01202375f, 0.04114989f, -0.05498439f, 0.02826347f, -0.04796643f, -0.05460658f, 
    -0.03648710f, -0.05320410f, 0.02047564f, -0.00047805f, 0.03886233f, 0.01814005f, 0.02368529f, 0.01304102f, 
    0.02070020f, 0.03153189f, 0.00906396f, 0.00889233f, 0.01558825f, -0.04550361f, -0.01417766f, 0.02800514f, 
    0.00621797f, 0.03379579f, -0.00146964f, 0.01297703f, -0.04738814f, 0.01282926f, 0.01672387f, -0.04622703f, 
    0.01942595f, 0.03986229f, 0.00221593f, 0.04126410f, 0.02396020f, -0.01695350f, 0.03517761f, 0.00458294f, 
    -0.05646437f, -0.03271558f, 0.00404461f, 0.03252615f, 0.01072643f, 0.02668512f, -0.05230540f, 0.01796116f, 
    -0.03044725f, -0.03847583f, -0.04550222f, 0.04236570f, -0.02599864f, -0.02046763f, -0.01187752f, 0.01746989f, 
    -0.00121299f, 0.00040840f, -0.02440172f, -0.05368210f, -0.00242417f, 0.03083343f, 0.02600195f, -0.04137384f, 
    -0.00388112f, 0.04041952f, -0.05542482f, -0.03852469f, 0.03382632f, 0.00446711f, -0.01618198f, -0.02788153f, 
    -0.05435748f, -0.02956372f, -0.05598164f, 0.01586057f, 0.00973884f, 0.00038327f, -0.05526506f, -0.04067850f, 
    -0.02816660f, -0.05051066f, 0.03656240f, -0.04585307f, 0.03126287f, 0.03883223f, -0.04563243f, -0.03814151f, 
    0.02604776f, 0.03514817f, -0.05224905f, 0.02937555f, 0.02056940f, 0.01566527f, 0.00805590f, -0.02045724f, 
    -0.00671700f, -0.03769089f, -0.04987907f, -0.01122060f, 0.02135628f, 0.00483938f, 0.01658703f, -0.02678935f, 
    -0.03849663f, -0.01754365f, 0.01774918f, -0.03803804f, -0.03428358f, 0.01382426f, -0.05206734f, -0.01768035f, 
    0.04375818f, 0.03408753f, 0.01467502f, -0.02729063f, 0.03338489f, -0.05283864f, 0.03457896f, -0.03121613f, 
    0.03255168f, 0.01129887f, -0.04621081f, -0.03532724f, -0.01138424f, 0.00838003f, -0.00636729f, -0.04768119f, 
    -0.03042488f, 0.03892025f, -0.01736092f, -0.03644304f, -0.00882603f, 0.01803138f, 0.02144738f, -0.01185825f, 
    0.10853093f, 0.19391938f, 0.05905721f, 0.10041461f, 0.10279903f, 0.19030426f, 0.20145153f, 0.13181342f, 
    0.00104360f, -0.01429129f, 0.06864073f, 0.04366555f, -0.53633296f, -0.25092113f, -0.37193561f, -0.17974557f, 
    0.02951173f, -0.02202978f, 0.09076488f, 0.05303002f, -0.04559403f, 0.17021570f, 0.13481694f, 0.05251238f, 
    0.20034276f, -0.26093635f, 0.32421651f, -0.21798000f, -0.24525197f, -0.06772821f, 0.03738657f, 0.13427703f, 
    0.15138090f, -0.10507851f, -0.00180525f, -0.13025065f, -0.03374343f, -0.04677207f, 0.18645556f, -0.22701643f, 
    0.01096594f, -0.03641109f, 0.06288569f, 0.23380949f, -0.10998429f, -0.05513554f, -0.02510881f, 0.00540118f, 
    0.16859797f, -0.38068190f, -0.26132828f, 0.03259697f, -0.07132762f, 0.00045604f, -0.09799651f, 0.06821835f, 
    -0.08029287f, 0.11279526f, 0.22510691f, -0.15726751f, 0.03883127f, 0.16091932f, 0.29669082f, -0.15237825f, 
    0.04491174f, 0.16423321f, 0.13308264f, -0.01032314f, -0.01802876f, 0.00089652f, 0.08934973f, -0.00270936f, 
    -0.14101955f, -0.13249855f, 0.04707206f, -0.15957597f, -0.07154664f, -0.04649642f, 0.02736585f, -0.08361623f, 
    0.15155044f, -0.06249207f, 0.23639432f, 0.05663759f, 0.00540409f, -0.09509897f, -0.11654066f, -0.10260413f, 
    0.11152817f, 0.03681110f, -0.19411433f, 0.00761838f, 0.12018723f, 0.04193667f, 0.07220720f, 0.02009018f, 
    -0.30485463f, -0.14340460f, -0.16202462f, 0.06266150f, -0.13923918f, 0.04074197f, 0.21562077f, 0.00903691f, 
    0.13150632f, 0.07272760f, 0.05249019f, -0.10036459f, 0.12625562f, 0.00141333f, 0.02811872f, 0.10289807f, 
    0.13759695f, 0.14417629f, 0.14767885f, 0.08720140f, -0.12174739f, -0.18399961f, 0.04312353f, 0.03237800f, 
    -0.07142109f, 0.28149697f, 0.10415286f, -0.11915073f, 0.29959732f, -0.13506527f, 0.05214433f, -0.12699589f, 
    -0.03369872f, 0.00159562f, -0.00773893f, -0.11662105f, -0.37811828f, -0.04657814f, -0.04747931f, 0.22688517f, 
    0.05282144f, -0.04569752f, -0.12480035f, 0.06829811f, 0.13380100f, 0.00941931f, 0.17645578f, 0.24604508f, 
    0.15944751f, 0.14455535f, 0.33644852f, -0.51639616f, 0.14104247f, 0.07966814f, -0.15137973f, 0.04955334f, 
    0.09884045f, -0.05542758f, 0.01849827f, -0.11322426f, 0.49556738f, -0.29684263f, 0.19262427f, 0.00546368f, 
    -0.05696035f, -0.02348204f, 0.12409677f, 0.21143453f, 0.05913391f, -0.15280813f, 0.04383193f, -0.00251546f, 
    0.25475684f, -0.08514134f, 0.43040809f, 0.30827647f, -0.12083025f, 0.22746436f, 0.17710753f, 0.03874187f, 
    -0.00693495f, -0.03268266f, -0.03525571f, 0.05233882f, 0.01820506f, 0.26042020f, -0.33383083f, 0.27598703f, 
    -0.02807438f, -0.27578142f, 0.40805510f, -0.04159301f, 0.00107565f, -0.02559427f, 0.08073530f, -0.06606674f, 
    -0.31336945f, 0.07205354f, -0.15444967f, -0.33577704f, 0.06364186f, -0.05022095f, 0.03942594f, -0.01659709f, 
    -0.01761197f, -0.11048406f, -0.14099278f, 0.12336486f, -0.04421022f, 0.13277705f, -0.11312319f, 0.08576594f, 
    -0.02140059f, -0.03912918f, 0.13679184f, 0.10870073f, 0.06269393f, -0.10844719f, 0.01424180f, -0.04077114f, 
    -0.21920535f, -0.53752804f, 0.00247796f, -0.05393367f, 0.29227915f, 0.27593264f, 0.03207044f, 0.24433975f, 
    -0.02209220f, 0.19769864f, 0.11709812f, 0.07203412f, -0.23406897f, 0.00860655f, 0.09817825f, 0.18168756f, 
    0.10158452f, -0.14171301f, 0.14760967f, 0.13877051f, 0.01438106f, 0.10647523f, -0.10793794f, 0.14752068f, 
    -0.13529216f, 0.26124129f, -0.09966865f, -0.05899204f, 0.01017073f, -0.09192936f, -0.00093456f, 0.18839778f, 
    0.01542404f, 0.06890365f, 0.02125938f, -0.13388781f, 0.07089018f, 0.13627204f, -0.04460913f, 0.18205212f, 
    -0.16400692f, 0.03361050f, 0.06688455f, -0.05037074f, -0.15995365f, -0.05159732f, -0.08013656f, -0.13063097f, 
    0.34998897f, 0.18733516f, -0.19038491f, 0.26359716f, 0.18118687f, 0.01497809f, -0.03204061f, -0.03543445f, 
    -0.09932158f, 0.10636274f, -0.16279975f, 0.01339505f, -0.02939631f, -0.49957615f, -0.23752327f, -0.18310602f, 
    -0.11467224f, -0.03330458f, -0.02625282f, 0.11430601f, 0.10002079f, -0.02788238f, -0.11576901f, -0.05243019f, 
    -0.14706095f, 0.04747608f, -0.00327132f, -0.05117969f, 0.01479940f, 0.08180609f, -0.14428602f, 0.14815772f, 
    -0.06749357f, 0.07091037f, -0.02261297f, 0.00050598f, 0.13298596f, 0.09081207f, -0.04647983f, 0.34966013f, 
    0.06941961f, -0.02437308f, 0.18400027f, 0.01761098f, 0.00796118f, -0.02209367f, -0.03545203f, -0.15063950f, 
    0.23393656f, 0.31261572f, -0.23468453f, -0.09387483f, 0.07772897f, 0.02250330f, -0.13230819f, 0.06714420f, 
    -0.11038362f, 0.20400414f, 0.00545125f, 0.04410372f, 0.03274421f, -0.13288416f, -0.06399576f, -0.07564561f, 
    0.09702430f, -0.22929285f, -0.02683077f, -0.15389806f, 0.10218787f, 0.05600804f, 0.09567823f, 0.00631888f, 
    -0.25818470f, 0.43719572f, 0.14051439f, -0.15743166f, 0.02261169f, 0.03070576f, -0.07062884f, 0.02303907f, 
    -0.03843194f, -0.00128443f, 0.09401961f, -0.13387330f, 0.09288635f, 0.18480048f, 0.00988649f, -0.05788253f, 
    -0.11552738f, -0.00327846f, -0.20544998f, -0.22047104f, 0.08632091f, 0.14753363f, 0.02972864f, 0.17536661f, 
    0.24279834f, -0.40107515f, -0.05727927f, -0.11536995f, -0.20462009f, 0.19949555f, -0.03696084f, -0.07130102f, 
    -0.01801405f, -0.02846303f, 0.22319572f, -0.12940380f, 0.13717866f, 0.21790372f, 0.13985507f, 0.17154346f, 
    0.08518250f, 0.21619101f, -0.03715978f, 0.11874942f, -0.06635470f, -0.03231118f, -0.05423314f, 0.00028061f, 
    0.02940479f, -0.02669893f, -0.03340689f, 0.03560052f, 0.03744178f, 0.01497766f, 0.03033426f, -0.03244524f, 
    -0.04242380f, -0.03246173f, 0.01101046f, -0.00146887f, -0.04355200f, -0.03401984f, -0.01559856f, -0.02905908f, 
    0.03386241f, 0.01185337f, -0.03651189f, -0.00681420f, 0.02419707f, 0.04109418f, 0.04274940f, -0.01953721f, 
    -0.00018792f, 0.01947085f, 0.04076469f, -0.01271871f, -0.02716160f, 0.01909157f, 0.01839723f, 0.02268307f, 
    -0.04176448f, -0.00216275f, 0.03462176f, -0.05669440f, 0.01861708f, 0.01044192f, -0.04467147f, -0.02519697f, 
    -0.03349825f, 0.01999268f, 0.00174848f, -0.04114110f, 0.02676542f, -0.01391448f, 0.02704302f, -0.04188141f, 
    -0.02867466f, 0.05457332f, -0.01812273f, 0.02267152f, 0.01460972f, 0.03234036f, -0.04746659f, 0.02807732f, 
    0.01287994f, 0.03843383f, -0.02967665f, 0.02836171f, -0.00691100f, -0.01543163f, -0.02901927f, -0.02614491f, 
    -0.00647169f, -0.02840905f, -0.05479139f, -0.02672029f, -0.03909045f, -0.01086052f, -0.04070992f, -0.03293099f, 
    -0.01648066f, -0.04796372f, -0.04789983f, 0.04654317f, -0.00155317f, -0.00832069f, 0.04568479f, -0.03124114f, 
    0.04115460f, 0.01093536f, -0.01822378f, -0.04503448f, 0.00431160f, 0.02381470f, 0.03162951f, -0.03009279f, 
    -0.01218790f, -0.00643510f, -0.02875154f, 0.03223180f, 0.00414218f, -0.01168096f, -0.01018840f, -0.00114557f, 
    -0.02116588f, 0.03614155f, -0.05074836f, 0.01252304f, 0.03602897f, -0.03780086f, 0.02462424f, -0.05003812f, 
    0.03802355f, -0.04893094f, -0.02520803f, -0.02213856f, -0.01642961f, -0.03464961f, -0.01689737f, -0.03105878f, 
    0.04040496f, 0.01942551f, -0.03991150f, -0.05639086f, -0.03027137f, -0.01373359f, -0.04782634f, -0.01322176f, 
    0.00267621f, -0.00434778f, -0.03453457f, -0.02622022f, 0.00504442f, 0.01099198f, -0.04950234f, -0.03580122f, 
    -0.03290606f, -0.02448167f, 0.01200769f, 0.01602418f, 0.01996103f, -0.03883836f, 0.03150985f, -0.00322385f, 
    -0.05771430f, -0.01555658f, 0.03638658f, -0.04601316f, 0.00053471f, -0.05475342f, 0.00656312f, -0.04597854f, 
    0.02553207f, 0.00193369f, 0.04469455f, 0.03560336f, 0.03355318f, -0.02481472f, 0.02893944f, -0.04401949f, 
    0.02013984f, -0.00448841f, 0.01165536f, -0.05488345f, -0.04353344f, 0.02425008f, -0.05191185f, 0.03879369f, 
    -0.01161386f, 0.01797325f, 0.03522776f, -0.03792269f, -0.03605761f, -0.02562447f, -0.01123212f, -0.03423717f, 
    0.01625385f, -0.05591746f, -0.05040565f, -0.01924703f, 0.00135884f, -0.02649719f, 0.00945347f, 0.01301144f, 
    0.00059696f, -0.01609034f, 0.04641664f, 0.01274777f, -0.00681555f, -0.05706044f, -0.03574163f, -0.01932825f, 
    0.03856108f, 0.04027020f, -0.03915961f, 0.01343640f, -0.05151362f, 0.04113918f, -0.05467552f, -0.02815924f, 
    -0.03633596f, -0.04965481f, -0.00799225f, 0.03143505f, 0.00646457f, -0.01066065f, -0.00985422f, -0.03086892f, 
    -0.01100466f, 0.02405804f, 0.00750566f, -0.05051759f, 0.00136197f, -0.00247753f, -0.01286894f, 0.01711205f, 
    0.00789364f, 0.01845520f, -0.04240235f, -0.02595005f, 0.02986412f, -0.00808825f, 0.04028329f, 0.03077290f, 
    -0.02731393f, 0.00172469f, -0.03402551f, -0.05415590f, -0.05865601f, -0.02534047f, -0.04593281f, 0.01563985f, 
    -0.03337228f, -0.02376180f, 0.00535154f, -0.05244072f, -0.00702624f, -0.03546473f, -0.01923015f, 0.02201502f, 
    -0.02306961f, -0.00254616f, -0.05228839f, -0.05912999f, 0.00835029f, 0.01418700f, -0.04762473f, 0.03802066f, 
    -0.01287812f, 0.03223568f, -0.05927597f, -0.01133480f, -0.03857673f, -0.01838147f, -0.03847655f, -0.00395227f, 
    -0.00949641f, 0.00324863f, -0.01840893f, 0.01863038f, -0.00457299f, -0.01130464f, 0.02117865f, -0.02020921f, 
    -0.01608512f, 0.04147393f, 0.00463865f, 0.03755815f, -0.00303774f, 0.01207783f, 0.03476150f, -0.01258408f, 
    -0.03934320f, -0.00492129f, 0.02195005f, 0.02428543f, 0.02707894f, 0.01194944f, -0.01432536f, -0.01433772f, 
    -0.01651783f, -0.00518368f, 0.00169526f, -0.00535326f, -0.00408583f, -0.03377303f, -0.03516468f, -0.03387053f, 
    -0.00315348f, -0.00614484f, -0.02055424f, 0.05028524f, -0.04397323f, 0.03072628f, 0.03888264f, -0.01541832f, 
    0.01821845f, -0.02536223f, -0.04918274f, 0.03758308f, -0.05255527f, -0.04256874f, -0.01650664f, 0.00298121f, 
    0.00120928f, -0.00944158f, -0.04608234f, -0.03659048f, -0.04417129f, -0.01503707f, 0.03615719f, -0.04296798f, 
    -0.02373980f, -0.04808916f, -0.01932230f, 0.00962426f, -0.01393327f, 0.01711640f, -0.03491973f, 0.01140567f, 
    -0.00171425f, -0.04988312f, 0.03480487f, 0.00663349f, -0.05164997f, 0.02219645f, 0.00214460f, -0.03126336f, 
    -0.05095072f, -0.05056301f, -0.00589474f, -0.03170368f, 0.03203113f, 0.03397401f, 0.01330520f, 0.04307773f, 
    0.03086663f, 0.01304969f, -0.04598064f, 0.01492318f, 0.01255165f, -0.01172393f, 0.04029570f, -0.04102080f, 
    0.02851552f, -0.00283677f, -0.02563542f, 0.00921939f, -0.02307376f, 0.00875482f, 0.03772941f, -0.05494814f, 
    -0.02662558f, -0.02251812f, -0.00030960f, -0.03888239f, 0.00904624f, -0.02064820f, 0.00880358f, 0.01929812f, 
    -0.04908895f, 0.00670306f, -0.01683570f, -0.04741294f, 0.02423545f, -0.03857762f, 0.01149834f, -0.02198618f, 
    -0.05181246f, 0.00253704f, 0.01309051f, 0.02788942f, 0.01966071f, -0.01996767f, 0.02875163f, 0.01673688f, 
    0.00990583f, -0.00613917f, -0.03585897f, -0.02399629f, -0.01871451f, -0.01725542f, 0.03764639f, 0.03025536f, 
    -0.01584437f, 0.03748048f, 0.02275525f, -0.01777864f, -0.00873428f, 0.04230905f, -0.04828656f, -0.03435554f, 
    -0.19869275f, -0.21844059f, 0.01242904f, 0.40989831f, 0.13571048f, 0.10537184f, 0.03085368f, 0.07219204f, 
    0.00121138f, 0.11348829f, 0.07867588f, 0.08761064f, -0.44544759f, -0.05543262f, -0.06508990f, -0.19205934f, 
    0.02751135f, -0.16255647f, -0.08347978f, 0.11217500f, 0.02868006f, -0.10903076f, 0.15549685f, 0.03274952f, 
    0.48297215f, -0.04500192f, -0.51466048f, 0.23773997f, 0.02662483f, -0.00631032f, -0.03454916f, -0.05857452f, 
    -0.02295832f, 0.16279954f, -0.06276771f, 0.32731801f, -0.24503531f, -0.32418859f, 0.10162777f, 0.26330134f, 
    -0.03328220f, 0.06737854f, -0.16722132f, -0.04620973f, 0.12423401f, 0.09026497f, -0.17239785f, -0.07477543f, 
    -0.30352911f, 0.00796224f, -0.06488270f, 0.00403600f, -0.02809839f, 0.01467465f, -0.12538239f, -0.17208244f, 
    0.02770027f, -0.26481730f, 0.21514766f, 0.17016110f, -0.25267646f, -0.10404692f, 0.23983073f, 0.18719576f, 
    0.04304451f, 0.03135825f, -0.03291179f, 0.09229373f, 0.03055347f, 0.11756087f, 0.07114755f, 0.11736159f, 
    0.00495909f, -0.15520705f, 0.14906462f, -0.18988721f, -0.14185759f, -0.02368840f, 0.05029758f, -0.04786653f, 
    0.12032742f, -0.06398083f, 0.14712261f, 0.07003555f, 0.22782207f, 0.00673967f, 0.07436038f, 0.07472380f, 
    -0.12620386f, -0.08391827f, 0.04979997f, 0.13325913f, 0.09510845f, -0.17452900f, 0.02314746f, 0.07679716f, 
    -0.25312203f, 0.07530492f, 0.07799330f, -0.09460929f, -0.00306042f, -0.12140449f, -0.05206474f, -0.03290529f, 
    -0.03265433f, -0.05549904f, 0.06183299f, 0.10435411f, -0.04364207f, -0.02834017f, 0.14834681f, 0.05892067f, 
    -0.02543570f, 0.02973176f, -0.02738727f, -0.11076128f, 0.06457049f, -0.02594649f, -0.02382449f, -0.08368153f, 
    0.19648632f, 0.01852331f, 0.34529579f, -0.20715731f, -0.03474721f, -0.07775656f, 0.03383188f, -0.03901205f, 
    0.17080136f, -0.04558383f, 0.02203026f, 0.01115190f, -0.02882338f, 0.04530754f, 0.05586196f, 0.01143722f, 
    0.06469256f, 0.13524504f, 0.23990279f, 0.03913161f, 0.07805681f, -0.02526763f, 0.05545628f, 0.14122783f, 
    0.30233514f, -0.20039630f, 0.04614849f, -0.18773705f, -0.14106657f, -0.02597687f, -0.10450358f, -0.12232982f, 
    -0.18724786f, 0.00519042f, -0.13553877f, -0.08602548f, 0.23413275f, -0.27968192f, 0.04735386f, 0.05510764f, 
    0.05855113f, 0.08775453f, -0.07242038f, -0.23832217f, -0.01882730f, -0.20459691f, -0.09856689f, -0.03232143f, 
    -0.09671934f, 0.09771760f, 0.23252775f, -0.08980659f, -0.20768261f, 0.00501273f, 0.02249516f, 0.26910898f, 
    0.01580764f, -0.09425429f, 0.05554603f, -0.01066206f, -0.11335511f, -0.10934689f, -0.01669441f, -0.06576958f, 
    -0.01635354f, -0.14937128f, 0.03191631f, -0.10122677f, 0.13647667f, -0.16439246f, 0.21299915f, 0.11099580f, 
    -0.05449244f, -0.30544841f, 0.29236561f, 0.32856959f, 0.07335465f, 0.04489461f, -0.09867863f, -0.00195815f, 
    0.10677495f, 0.02676011f, -0.04121386f, -0.00230413f, 0.24602957f, -0.05701043f, 0.10833900f, -0.08270569f, 
    0.03042867f, -0.04965610f, -0.04733849f, 0.00435550f, 0.05323572f, -0.13203453f, -0.11631982f, -0.09424805f, 
    -0.08010726f, -0.05699726f, -0.23586345f, 0.35922888f, 0.04408048f, -0.24874738f, 0.12443285f, -0.14209418f, 
    0.08786205f, 0.08927383f, -0.00770297f, 0.01404363f, 0.39990512f, 0.02335466f, -0.01642733f, -0.11504521f, 
    -0.02511540f, 0.17317258f, -0.24019796f, -0.07006977f, -0.02586809f, -0.15561773f, 0.13613398f, 0.06422568f, 
    0.04137572f, 0.04230655f, 0.15088503f, -0.04883071f, -0.01967843f, -0.04852699f, -0.12173705f, -0.03662233f, 
    -0.00289668f, 0.00354983f, 0.01939765f, -0.03898195f, -0.36662751f, -0.19635521f, 0.09000866f, 0.16256818f, 
    0.05608417f, 0.08294229f, -0.21180739f, -0.00829380f, 0.14390260f, 0.16697891f, 0.02134654f, 0.12612695f, 
    -0.18198669f, -0.00332643f, 0.14475338f, 0.14922269f, 0.10712878f, -0.02285745f, 0.15563524f, 0.02144174f, 
    0.10357542f, 0.11220095f, 0.08782198f, -0.02988780f, -0.05327871f, 0.10566546f, 0.20183562f, 0.14791223f, 
    0.02493558f, -0.01292197f, 0.21665733f, -0.07569192f, 0.03025280f, -0.06350810f, -0.06158734f, 0.04785780f, 
    0.11273846f, -0.29876599f, 0.12829648f, 0.03062407f, -0.04535293f, 0.00395819f, -0.02604787f, 0.03120944f, 
    0.05295514f, 0.06170642f, 0.06009959f, 0.03949958f, -0.07956001f, 0.14595674f, -0.02304921f, 0.18746364f, 
    0.09382553f, 0.01073373f, -0.02509251f, -0.12080628f, 0.03414837f, -0.02477409f, 0.02271866f, 0.02030355f, 
    0.27386162f, 0.03151434f, 0.04951820f, 0.14864330f, -0.14284569f, -0.06871191f, -0.01904058f, 0.03012352f, 
    0.07901120f, 0.07186783f, 0.00027642f, -0.03534393f, 0.05002226f, -0.10128705f, 0.07023080f, -0.09586760f, 
    -0.14805140f, -0.00803310f, -0.07095201f, -0.10787112f, -0.04001155f, 0.04768252f, 0.08389875f, 0.11243099f, 
    0.11926770f, -0.05860000f, -0.12626939f, -0.19605011f, -0.03036807f, 0.17137590f, -0.00187031f, 0.08198228f, 
    0.07001355f, 0.06894920f, -0.07775414f, -0.03185505f, 0.23023582f, 0.29811680f, 0.01917019f, -0.10196516f, 
    -0.07124163f, -0.06280549f, 0.11490276f, -0.06109113f, 0.04366895f, 0.01128847f, -0.00121714f, 0.03206394f, 
    -0.14826034f, 0.03085567f, 0.18616575f, -0.28386989f, 0.06512110f, -0.03687511f, 0.08496556f, -0.03461889f, 
    0.06722654f, -0.24791393f, 0.02631721f, 0.22203694f, -0.21870865f, -0.06429153f, 0.14326850f, 0.17068957f, 
    -0.02506759f, 0.04057784f, 0.00335645f, 0.10808287f, 0.01918536f, 0.08848570f, 0.10406108f, -0.08077661f, 
    0.45038781f, 0.50941432f, 0.35804024f, 0.09870554f, 0.11028489f, 0.16784570f, 0.18397333f, 0.14031179f, 
    0.10110796f, -0.13729173f, -0.06463145f, -0.12302752f, 0.29692835f, -0.09758162f, -0.04808798f, -0.07933135f, 
    -0.03636159f, 0.04931196f, 0.01257319f, -0.03396179f, 0.00797638f, 0.11255984f, -0.05809686f, -0.10721447f, 
    -0.38804391f, 0.17108983f, 0.32518250f, -0.07221699f, -0.03733496f, -0.03759183f, -0.01222685f, -0.03862774f, 
    -0.01496963f, 0.00031809f, 0.02981796f, -0.08223829f, -0.12097422f, 0.00335084f, -0.24268809f, -0.03673614f, 
    0.14676167f, 0.10330214f, 0.13543937f, -0.22001767f, -0.05704533f, 0.16185157f, 0.35810357f, 0.31357470f, 
    0.09526295f, -0.18724315f, 0.02430155f, -0.03518203f, -0.07521255f, -0.05874470f, -0.06071387f, 0.00625398f, 
    0.04875138f, 0.29562673f, 0.22969323f, 0.09371009f, -0.09542087f, 0.17536685f, 0.00406226f, 0.17075288f, 
    0.18993174f, 0.10345305f, 0.05787031f, 0.02821129f, -0.03535975f, -0.08220139f, -0.10089895f, -0.02810502f, 
    0.16403031f, 0.11328540f, -0.16824332f, 0.12862442f, -0.09715620f, 0.06467591f, -0.08082721f, 0.05763474f, 
    -0.12526537f, -0.00730875f, -0.07577843f, -0.08171403f, 0.11611371f, 0.10715538f, 0.11477996f, 0.17305382f, 
    0.11133955f, -0.08132483f, -0.17193560f, 0.04456445f, -0.07171543f, 0.07723917f, 0.13902454f, -0.13753200f, 
    0.31816915f, -0.17268026f, -0.01145281f, -0.20612125f, -0.33210278f, -0.02694113f, -0.20080787f, -0.05036813f, 
    0.21983889f, 0.16243206f, 0.17690267f, 0.09842442f, 0.21138534f, 0.21845561f, 0.04030638f, 0.26338539f, 
    0.07070175f, -0.15568390f, 0.07391313f, 0.14531563f, 0.18045308f, 0.10921099f, 0.04584793f, 0.24944709f, 
    -0.00308120f, 0.29265386f, -0.28801861f, 0.44013292f, -0.02482548f, -0.08047970f, -0.18402769f, -0.01172454f, 
    -0.12641168f, 0.03732393f, 0.15420680f, 0.09288056f, 0.12763223f, 0.01700890f, 0.14920141f, 0.03866123f, 
    -0.13466176f, 0.07067574f, -0.15698157f, 0.17404811f, -0.05902057f, -0.05829120f, -0.18480246f, -0.09750063f, 
    -0.45751053f, 0.12654008f, -0.14708810f, -0.04320999f, 0.12408689f, -0.00666280f, -0.18833818f, -0.02497722f, 
    0.04313442f, 0.01788259f, -0.03946468f, 0.27070597f, 0.09882740f, 0.24218416f, -0.11105233f, -0.14002338f, 
    0.05378220f, -0.07297160f, -0.01251958f, 0.15420893f, -0.05437873f, 0.01456352f, 0.28673068f, 0.15788107f, 
    -0.32610825f, -0.09717572f, -0.01495287f, 0.50769711f, 0.14043510f, 0.08082847f, 0.26561981f, -0.33749762f, 
    -0.04160341f, 0.07858629f, -0.12080274f, -0.14285851f, 0.01287911f, -0.11319388f, -0.03253055f, 0.01468346f, 
    -0.13341612f, -0.05531920f, -0.05237273f, -0.04887093f, 0.02853821f, 0.11027966f, 0.14760751f, 0.04609951f, 
    0.07843343f, 0.35332686f, -0.05389722f, 0.18607241f, 0.08893149f, -0.25935879f, 0.08733647f, -0.16961306f, 
    -0.08039437f, 0.01572990f, 0.02239911f, 0.05546756f, 0.08866470f, 0.04981313f, -0.09635352f, -0.00204197f, 
    -0.05044608f, -0.02430735f, -0.09056807f, -0.04635319f, 0.12187800f, 0.13275029f, 0.04512952f, 0.20105337f, 
    0.06609281f, -0.06804876f, 0.16638304f, -0.25543416f, -0.00828687f, 0.02830683f, 0.01007156f, 0.01969790f, 
    -0.04321626f, -0.02250110f, 0.04473103f, 0.03817507f, -0.61863822f, 0.00040469f, 0.21381696f, 0.30388761f, 
    0.16926509f, -0.09067319f, 0.02706117f, -0.06347123f, -0.12514459f, 0.28414917f, 0.01241382f, 0.02371215f, 
    -0.10805803f, 0.35067710f, -0.38887021f, 0.05549767f, -0.11730212f, -0.01243076f, -0.02406001f, 0.18321185f, 
    0.12728971f, -0.11957997f, -0.11140011f, -0.12766187f, 0.04911751f, 0.20512900f, 0.14397095f, 0.03979957f, 
    0.02508473f, 0.06794854f, 0.32175124f, -0.04862532f, 0.03620550f, 0.13638595f, 0.06238953f, -0.19104990f, 
    0.23393790f, 0.04189524f, 0.10471795f, 0.42922202f, 0.04557414f, 0.01728219f, 0.05380071f, 0.10494453f, 
    0.09140000f, 0.03331686f, 0.03984138f, 0.15432824f, -0.08971236f, 0.12624075f, 0.14793058f, 0.06980997f, 
    0.10929605f, 0.05335861f, -0.06658535f, -0.03970180f, 0.03649335f, -0.07781158f, -0.01131250f, 0.06189072f, 
    -0.25418979f, 0.35021874f, 0.09019513f, 0.06546101f, 0.08245680f, -0.09514159f, 0.02891183f, -0.03103230f, 
    0.00255975f, 0.28454095f, -0.17946675f, -0.01430317f, 0.35900047f, -0.16592696f, 0.28021401f, 0.00826116f, 
    0.03188927f, -0.07360860f, -0.06488429f, 0.12874939f, 0.17427698f, 0.14521550f, 0.02764799f, 0.18173736f, 
    -0.40096167f, 0.62409925f, 0.22492334f, 0.19052093f, 0.27705225f, 0.09194207f, -0.03769815f, 0.07575379f, 
    -0.12612692f, 0.04620293f, 0.08727085f, 0.15535223f, -0.06753496f, 0.03398795f, -0.02246181f, 0.03484200f, 
    0.15436433f, -0.09752797f, 0.11058042f, -0.00420213f, -0.00890829f, 0.12485406f, 0.16521785f, -0.02489888f, 
    -0.44771233f, 0.31487682f, 0.25182697f, 0.06784224f, 0.05213185f, 0.15314963f, -0.00184169f, -0.04618650f, 
    -0.01779969f, 0.06404953f, -0.10508020f, 0.20013133f, 0.03378130f, 0.14957052f, 0.18487924f, 0.26245794f, 
    0.05575504f, 0.06192250f, -0.13356009f, -0.03685297f, -0.00288291f, -0.02661263f, -0.03349670f, -0.01165673f, 
    0.23028809f, -0.17753562f, -0.02195873f, 0.22562167f, -0.14301804f, 0.08784710f, -0.00127194f, -0.07168433f, 
    -0.06666589f, 0.01992496f, 0.08244871f, -0.05051942f, -0.05965700f, 0.17924553f, -0.08250142f, 0.40666777f, 
    -0.08684675f, 0.10048004f, -0.11003528f, 0.01471079f, 0.07466548f, 0.05049378f, 0.15888497f, 0.13433728f, 
    -0.14775102f, 0.06959733f, 0.16502503f, 0.02068997f, 0.04037966f, 0.00803224f, 0.08344513f, -0.05237605f, 
    0.03528244f, -0.04467126f, 0.02643099f, 0.02977578f, -0.00353581f, -0.14739814f, -0.24249874f, -0.09019960f, 
    0.10625118f, 0.13355045f, 0.04341574f, 0.07848202f, 0.00110520f, -0.02103277f, -0.12589021f, -0.01605951f, 
    -0.18294704f, -0.33800742f, 0.06928959f, 0.50395072f, 0.03629779f, 0.05890939f, 0.03907734f, -0.03779573f, 
    0.02846740f, -0.05700118f, 0.08120529f, 0.08394611f, -0.44237000f, -0.24801642f, -0.04156166f, 0.11497392f, 
    -0.08312693f, -0.00751019f, 0.01718378f, 0.08342852f, -0.17454910f, -0.02040348f, 0.07197913f, -0.02549047f, 
    0.08222434f, -0.10527120f, -0.20622757f, -0.08391558f, 0.04340759f, 0.01502611f, -0.13264781f, -0.08643579f, 
    -0.09003197f, 0.06184778f, 0.12413441f, 0.02246107f, -0.03278407f, -0.01241737f, 0.16267689f, -0.03718084f, 
    0.00148569f, 0.01160114f, 0.11123598f, -0.18551999f, 0.06437411f, 0.14126600f, -0.06657262f, 0.04546800f, 
    0.04326958f, -0.07713889f, -0.13350995f, -0.08639995f, -0.05650149f, 0.02253182f, 0.03094315f, 0.07381085f, 
    0.10659223f, -0.05032974f, 0.03816013f, 0.02935022f, -0.14809448f, 0.31160608f, 0.30363312f, -0.07956325f, 
    -0.16541144f, -0.07650416f, 0.05980787f, -0.06526633f, 0.08068470f, 0.02315849f, 0.00963570f, -0.13569304f, 
    0.36562759f, -0.11641604f, -0.33142844f, -0.10078349f, 0.02382505f, -0.08225561f, 0.15104857f, -0.09767799f, 
    0.08821645f, -0.12984675f, -0.08540124f, -0.01399131f, -0.01967356f, 0.06808434f, 0.09148340f, -0.16082963f, 
    0.02974515f, 0.03740119f, 0.04425041f, -0.13171279f, -0.06232764f, -0.09098541f, 0.04042384f, 0.03140157f, 
    0.16045594f, -0.20177484f, 0.39065561f, -0.04841708f, -0.03343691f, 0.04305241f, -0.00618900f, 0.03937783f, 
    0.10664443f, -0.10296811f, -0.07085216f, -0.01088065f, 0.00207675f, -0.04192499f, 0.03832936f, -0.26819611f, 
    -0.03906872f, 0.09668389f, -0.02512642f, 0.12324639f, 0.12216872f, -0.04529800f, 0.01722265f, -0.01177161f, 
    -0.25589389f, -0.11530902f, 0.18676120f, 0.02843187f, -0.08953208f, -0.00894078f, -0.01411110f, 0.25496107f, 
    -0.06802975f, -0.02676025f, 0.02258517f, -0.10389581f, -0.08142478f, 0.06980157f, -0.18794592f, 0.01408247f, 
    -0.11771917f, 0.03639133f, 0.00942517f, 0.17030133f, 0.14260574f, -0.10893092f, -0.08327457f, 0.08764154f, 
    -0.02068389f, -0.40817186f, -0.19675726f, 0.11641982f, 0.29658106f, 0.15961763f, 0.05470894f, -0.02993437f, 
    -0.00468599f, -0.02713340f, -0.08595899f, 0.01184273f, 0.36862564f, -0.20667443f, -0.09080705f, -0.02170376f, 
    -0.01016085f, -0.11943295f, 0.11759286f, 0.03576750f, 0.06866971f, -0.01533122f, 0.04527972f, -0.10889700f, 
    -0.23246369f, 0.04770848f, 0.04795972f, -0.05924373f, 0.04543088f, -0.03464679f, 0.09358927f, 0.08007038f, 
    0.01476550f, -0.00562432f, -0.01026718f, -0.03623096f, 0.34700400f, -0.07308793f, -0.17763352f, 0.07470018f, 
    0.09621858f, 0.00661251f, 0.00343508f, -0.02327778f, 0.02734293f, 0.07386207f, 0.14598611f, -0.08165943f, 
    -0.47530127f, -0.29602626f, -0.06013454f, 0.12941347f, -0.00871866f, 0.27609879f, 0.04271305f, 0.12500530f, 
    -0.10151497f, 0.01119935f, 0.14974755f, -0.13151580f, 0.11055730f, 0.02978111f, 0.30365506f, 0.13929532f, 
    0.06276050f, 0.08411374f, -0.09183776f, 0.23698112f, 0.23034206f, 0.03737984f, 0.24349912f, 0.17523876f, 
    0.18043500f, 0.01352294f, 0.02046262f, -0.25810274f, -0.01731292f, -0.02485601f, -0.07925568f, 0.13812549f, 
    0.07469146f, 0.14894906f, -0.01099145f, 0.07416182f, 0.18758850f, 0.09929224f, -0.04774924f, 0.00950550f, 
    0.05723110f, 0.06264674f, -0.06923438f, -0.02169452f, -0.05430674f, -0.05678079f, -0.04403669f, -0.08464243f, 
    -0.03798854f, 0.12338278f, 0.05811277f, -0.00983858f, 0.13341571f, -0.03326342f, 0.00986676f, -0.09399566f, 
    0.00897151f, 0.12921967f, -0.03631592f, 0.08534602f, -0.04438005f, 0.17761856f, 0.05278023f, -0.13855870f, 
    0.04975548f, -0.05358975f, 0.00433666f, 0.04422554f, 0.07609919f, -0.09827712f, -0.01914427f, -0.02342528f, 
    0.15740420f, 0.38823202f, 0.30808786f, 0.01305156f, -0.05424830f, 0.04632317f, -0.01893038f, 0.27430180f, 
    -0.05542798f, 0.16503188f, 0.02665067f, 0.03880417f, -0.05855440f, 0.17166620f, 0.01168632f, 0.04229076f, 
    0.00619950f, 0.07523553f, 0.10546647f, -0.16770738f, 0.06519767f, -0.12326930f, 0.16798502f, -0.13986023f, 
    -0.05492048f, -0.44693041f, 0.21054262f, 0.48658636f, -0.10107259f, -0.00562306f, 0.01077792f, 0.08229677f, 
    0.18994124f, 0.26959899f, 0.03255508f, 0.07244003f, -0.14096045f, -0.13925943f, -0.02347273f, 0.08343757f, 
    -0.06605963f, -0.02932743f, -0.08454233f, -0.06877916f, 0.01817917f, -0.06063341f, 0.09188358f, 0.01336639f, 
    -0.17453831f, -0.52687365f, 0.51777208f, 0.17640728f, 0.12489320f, 0.02047237f, 0.10609450f, 0.18020956f, 
    -0.05552337f, 0.06726005f, -0.01502463f, -0.14729175f, -0.26824710f, 0.01612888f, -0.05836156f, 0.02520387f, 
    -0.05339421f, 0.07019575f, -0.08750315f, 0.02590706f, -0.06322992f, -0.01087733f, -0.08580387f, 0.04423705f, 
    0.33507267f, 0.24016650f, -0.36245543f, 0.28311223f, 0.13334922f, 0.00810097f, -0.03355248f, 0.00409178f, 
    0.11417336f, -0.09509727f, 0.09298030f, 0.00365928f, -0.09670971f, -0.06053334f, 0.14054926f, -0.12845783f, 
    0.04344233f, 0.04342165f, 0.05896014f, 0.06877863f, 0.00459122f, 0.05798559f, 0.11011327f, 0.10204525f, 
    -0.14318593f, -0.15479775f, -0.09515266f, 0.04397150f, -0.10336145f, -0.10255767f, -0.11576299f, -0.05608954f, 
    -0.00842006f, -0.20601748f, -0.09927004f, -0.24103045f, -0.05740770f, -0.11793873f, -0.05103301f, -0.13839066f, 
    0.11577164f, 0.04863134f, 0.03469895f, 0.09594435f, -0.00866432f, -0.13115747f, -0.09795094f, -0.15299250f, 
    0.17296270f, -0.03533372f, -0.20054637f, 0.15884438f, 0.01980287f, 0.04866220f, -0.01357787f, -0.06211913f, 
    0.20571265f, 0.05633793f, 0.04490312f, 0.01689271f, -0.28977504f, -0.44702613f, -0.09004190f, 0.19661222f, 
    -0.00337238f, -0.05697803f, 0.13139410f, -0.01948209f, 0.03114027f, 0.03975513f, 0.20796779f, 0.23157418f, 
    0.04715446f, -0.06683481f, -0.20741840f, -0.16718225f, 0.05488013f, 0.01188650f, 0.03984488f, -0.04853715f, 
    0.20729503f, 0.09899923f, 0.22178285f, 0.09542523f, -0.01829549f, -0.19921547f, -0.06695906f, 0.05236582f, 
    0.16395485f, -0.14636853f, -0.06746912f, -0.06676741f, -0.09432633f, 0.00179674f, -0.02229200f, -0.04228410f, 
    -0.10961281f, -0.05245595f, 0.02933147f, -0.08516842f, 0.19124937f, -0.04066671f, -0.03605531f, -0.01136869f, 
    -0.23138843f, -0.10728329f, -0.09060527f, -0.09326703f, 0.00800429f, 0.30703947f, 0.60179108f, 0.40679345f, 
    -0.05504106f, -0.13379560f, 0.00989692f, 0.09085101f, 0.05594371f, 0.01996018f, -0.13781874f, 0.11992963f, 
    0.01830152f, -0.03925319f, -0.02620070f, -0.25769979f, -0.09790733f, -0.04290326f, 0.06054161f, -0.01272806f, 
    0.15924032f, 0.10476942f, 0.10583955f, -0.11051322f, -0.29166248f, -0.13044904f, -0.03046264f, 0.03344876f, 
    -0.09445796f, 0.08016613f, 0.10152293f, 0.01473670f, 0.10117238f, 0.03084639f, 0.05508004f, 0.06916560f, 
    -0.29120427f, -0.07581606f, 0.15511677f, -0.14020048f, 0.11698619f, 0.03767186f, -0.11339087f, -0.01947229f, 
    0.03440442f, 0.03590367f, 0.20288157f, 0.00794950f, -0.25947359f, 0.05704384f, 0.18200730f, -0.07513193f, 
    -0.04494322f, -0.04962751f, -0.04788700f, 0.01123470f, -0.10285521f, -0.02470723f, -0.08452788f, -0.19693761f, 
    -0.20680428f, -0.16191563f, -0.14367622f, -0.07561295f, 0.00531297f, -0.06026624f, 0.03719084f, 0.15983538f, 
    0.09225000f, 0.22921485f, 0.06608372f, 0.15766722f, 0.31142974f, -0.13397028f, -0.33426198f, 0.06951358f, 
    0.08119716f, 0.05891882f, 0.11568542f, 0.06923795f, 0.16028421f, 0.02682865f, 0.27040210f, 0.36947718f, 
    0.05431404f, -0.07065301f, 0.17864497f, 0.42316690f, 0.10047770f, 0.07764208f, -0.02344012f, -0.20792374f, 
    -0.08292986f, 0.08196542f, -0.14668719f, -0.14208591f, 0.12443398f, 0.14882532f, -0.25614426f, -0.06619501f, 
    -0.02170878f, 0.04122639f, -0.02086653f, 0.10376916f, 0.02554780f, -0.05912035f, 0.18019661f, -0.13062966f, 
    -0.20228203f, -0.15505548f, -0.00935927f, 0.13579953f, -0.09360607f, 0.04912147f, 0.12689354f, -0.02337371f, 
    0.06694104f, -0.09175771f, -0.05350753f, 0.08695979f, 0.19817683f, -0.21919361f, -0.17920652f, -0.03338034f, 
    -0.13251917f, -0.04507031f, -0.12699556f, -0.13855742f, -0.00396787f, 0.26433134f, 0.05989862f, 0.16046210f, 
    0.40784767f, 0.03752176f, -0.33891711f, 0.19264697f, 0.03809676f, -0.17250735f, 0.13983625f, 0.03142833f, 
    -0.04264916f, -0.15787439f, 0.00787442f, 0.11181527f, 0.06187408f, -0.07379140f, -0.01544792f, -0.14096424f, 
    0.03766781f, -0.07488602f, -0.04214088f, 0.05525889f, 0.10615540f, 0.30751842f, -0.00894885f, -0.15261674f, 
    -0.32526356f, 0.07621216f, -0.25175512f, -0.12634291f, -0.00468921f, -0.09210576f, 0.24688923f, 0.02667217f, 
    0.06803040f, 0.13430683f, 0.19765218f, 0.21916334f, 0.36776537f, 0.19179164f, -0.13892844f, 0.27623689f, 
    -0.04064050f, -0.14295973f, 0.23494397f, 0.03860147f, 0.06651483f, 0.02013344f, -0.14375107f, -0.19043773f, 
    -0.16275223f, -0.13633537f, 0.06537987f, 0.06029002f, -0.00380730f, -0.12559900f, -0.22950810f, 0.01177682f, 
    0.05925751f, -0.01497795f, 0.01267045f, 0.19877571f, -0.27546117f, 0.26320013f, 0.36638954f, 0.35816306f, 
    0.03827124f, -0.05371629f, 0.00326586f, 0.11514860f, 0.03716493f, 0.08733594f, 0.18804157f, 0.13509129f, 
    -0.00392300f, 0.27250299f, 0.27886641f, 0.36393324f, -0.07141279f, -0.00747865f, 0.05600092f, 0.19098605f, 
    -0.17004459f, -0.11303928f, -0.04760678f, 0.14715424f, -0.00591223f, 0.02972298f, -0.06146224f, 0.04860842f, 
    -0.01108752f, 0.10729671f, 0.17972836f, -0.01113313f, 0.06155745f, 0.02005825f, 0.13543609f, -0.04675814f, 
    0.01202668f, 0.11352663f, -0.04917155f, 0.29147172f, -0.07916105f, 0.02658633f, 0.02709624f, -0.02646505f, 
    -0.16327326f, 0.00632686f, 0.12060284f, 0.19223987f, -0.09566626f, 0.06166923f, -0.13967730f, -0.22316153f, 
    0.20604791f, 0.06593557f, 0.14262912f, 0.10594023f, -0.01897825f, -0.00942103f, -0.13404420f, -0.00454884f, 
    -0.14129394f, -0.22543249f, 0.10624478f, 0.31970060f, 0.02776001f, 0.12387003f, -0.03722919f, 0.15814696f, 
    -0.00128647f, 0.12256902f, 0.06611767f, 0.19828250f, 0.23104452f, 0.13398357f, -0.13288510f, 0.04078613f, 
    0.12562227f, 0.02816425f, -0.16699786f, 0.01937671f, -0.07324258f, -0.12167187f, -0.00836052f, 0.11975303f, 
    0.01280841f, -0.02487883f, -0.00276404f, -0.00640813f, 0.05617561f, 0.06997444f, 0.06421232f, -0.03721724f, 
    0.19246753f, -0.15999439f, 0.00639546f, -0.11936973f, -0.15141946f, -0.19281968f, -0.21056867f, -0.02518552f, 
    0.01125126f, -0.04789038f, 0.04160297f, 0.06511306f, -0.04398002f, 0.14521027f, -0.07332589f, 0.09710521f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00831103f, 0.09529869f, 0.11829641f, 0.04203041f, -0.04735881f, -0.04199546f, 0.11466338f, 0.17361350f, 
    0.10066370f, -0.04413296f, 0.03220830f, 0.19613253f, 0.01987896f, 0.08008219f, 0.09568988f, 0.08189315f, 
    0.06146972f, -0.09146359f, -0.01605059f, -0.03195443f, 0.01546567f, -0.03637275f, -0.05430481f, -0.02578918f, 
    0.05211305f, 0.03923400f, 0.00684107f, 0.03964377f, 0.12179898f, 0.02211148f, 0.18907696f, 0.03104477f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03058176f, -0.13110641f, 0.21938723f, -0.08046918f, 0.25185910f, 0.02088114f, -0.76679051f, -0.15584691f, 
    -0.63091701f, 0.01980418f, -0.16691314f, -0.17664282f, 0.34402680f, 0.24772872f, -0.30770779f, -0.37952703f, 
    -0.16568892f, 0.12997499f, -0.03187390f, -0.01110827f, 0.15367579f, 0.08097678f, 0.08088516f, 0.15205750f, 
    -0.14608784f, -0.09665716f, 0.08642159f, 0.01244797f, -0.63866013f, -0.09156118f, -0.26740047f, -0.57717365f, 
    0.22576272f, 0.52525872f, 0.34231523f, 0.10824417f, 0.14649370f, 0.15631182f, -0.24582970f, 0.16936606f, 
    0.05242150f, -0.02796118f, -0.02026702f, 0.16130640f, -0.37411931f, -0.02784681f, -0.36208966f, -0.29258791f, 
    0.36438864f, -0.67953914f, -0.08531225f, 0.00085690f, -0.13420375f, -0.14401810f, -0.03001957f, 0.07149825f, 
    0.12500197f, -0.17769706f, -0.47162902f, -0.13597429f, 0.09067614f, -0.11349644f, -0.00727420f, -0.72561461f, 
    0.04205001f, -0.02461173f, -0.00718534f, 0.11228670f, 0.14591990f, 0.02379884f, 0.04432588f, -0.01926453f, 
    0.06718438f, 0.10523849f, 0.05425536f, 0.10181031f, 0.50909656f, -0.22163323f, 0.58653677f, -0.13389996f, 
    -0.39528885f, -0.11232042f, -0.15022893f, 0.11880137f, -0.53458482f, -0.08223811f, -0.04764102f, -0.43322083f, 
    0.10903416f, -0.17728625f, -0.54179853f, 0.09788920f, 0.31602627f, -0.37016425f, 0.12220036f, 0.15823951f, 
    -0.29847422f, -0.14743319f, 0.29053393f, 0.02356874f, -0.05328228f, 0.00432561f, 0.05781379f, 0.03171617f, 
    0.24620175f, 0.08911588f, 0.03815644f, -0.44468886f, 0.08059330f, -0.19934359f, 0.25736356f, -0.12206406f, 
    -0.05427985f, 0.16265666f, 0.09810749f, 0.33079192f, 0.05208732f, 0.15567523f, 0.08754808f, -0.19414830f, 
    -0.42116609f, -0.12994388f, 0.19518670f, 0.15737177f, -0.05235631f, 0.10104568f, -0.77329910f, 0.01647388f, 
    0.28477755f, -0.36786035f, -0.17909338f, 0.10905598f, 0.08428479f, -0.15355580f, -0.13422121f, 0.04001670f, 
    -0.34221998f, -0.01767426f, -0.16998628f, -0.34239340f, 0.08098132f, 0.02742165f, -0.36397287f, -0.14359793f, 
    0.11433246f, 0.30091304f, -0.11909742f, -0.10202121f, -0.46956152f, -0.08470424f, -0.00223736f, 0.12702253f, 
    0.33645731f, 0.01797467f, -0.09670471f, 0.12797193f, 0.00810964f, 0.01817512f, 0.28497043f, 0.21055169f, 
    -0.19591266f, -0.32364702f, -0.14894621f, -0.06808618f, -0.03053470f, 0.03086226f, 0.31361702f, 0.06145524f, 
    -0.20141080f, -0.05274370f, 0.04081039f, 0.31604499f, -0.10204824f, 0.30960873f, -0.42894647f, -0.35421607f, 
    0.26627868f, -0.52000338f, -0.01218034f, 0.04229309f, 0.39095980f, -0.16890733f, -0.02675437f, -0.17991732f, 
    0.23088856f, -0.08634590f, 0.45064521f, -0.18101333f, -0.00664809f, -0.10456914f, 0.28806961f, -0.39180952f, 
    -0.55284661f, 0.08410349f, -0.35937637f, 0.00490130f, -0.71249384f, 0.15414201f, 0.12107076f, -0.19343249f, 
    0.38845736f, 0.11075363f, -0.01701973f, 0.28324571f, 0.21250433f, -0.56422031f, -0.11089244f, 0.15339787f, 
    -0.44057354f, 0.19429418f, 0.16884083f, -0.82991546f, -0.28685954f, -0.15813120f, -0.00319904f, -0.44120654f, 
    -0.13686137f, -0.05983447f, -0.14217123f, 0.15544760f, -0.25399157f, -0.10342105f, 0.39173031f, 0.46886125f, 
    0.36330414f, 0.21578868f, -0.21206224f, 0.05687954f, -0.49622387f, -0.01586745f, 0.12378787f, -0.40978661f, 
    0.16945142f, -0.16530570f, -0.07944562f, -0.09252855f, -0.57055533f, -0.19837677f, -0.40565202f, -0.12884569f, 
    -0.36971354f, 0.49746883f, -0.08238941f, 0.16206759f, 0.26443461f, -0.15761673f, -0.00161483f, -0.31886637f, 
    -0.17477228f, 0.14750926f, 0.59928012f, 0.01980036f, 0.51912570f, -0.46438837f, -0.13178313f, -0.11908097f, 
    -0.11232782f, -0.16092816f, 0.44480720f, -0.14669916f, -0.33974856f, -0.09226190f, 0.14230222f, 0.19084856f, 
    0.08796135f, -0.07264235f, -0.06319275f, -0.00918919f, -0.15976739f, 0.30214149f, 0.31557044f, 0.32683519f, 
    -0.46198353f, -0.38128895f, 0.06891084f, -0.02122433f, 0.44776574f, 0.08197434f, 0.14509504f, -0.28951311f, 
    -0.82115644f, 0.08279423f, -0.32108238f, 0.09806341f, 0.28454259f, -0.64835054f, -0.63310862f, -0.08225680f, 
    -0.45675942f, 0.28508499f, -0.77491647f, -0.05164382f, -0.25757158f, -0.03500638f, 0.10902233f, 0.05722445f, 
    -0.31241640f, -0.17867917f, -0.08380017f, 0.07612535f, 0.02921985f, 0.51934940f, -0.58916587f, 0.10460378f, 
    0.30018288f, 0.34823880f, -0.07029590f, 0.41885257f, -0.56216753f, 0.11987312f, -0.11790451f, -0.51472503f, 
    0.51710421f, 0.15208320f, -0.04845934f, -0.09182505f, 0.06979055f, -0.12516093f, 0.03127041f, 0.20338473f, 
    -0.12165928f, 0.14903377f, 0.33547774f, -0.08982459f, -0.37912685f, 0.15374897f, 0.07110023f, 0.29737869f, 
    -0.32410169f, -0.02984314f, -0.07959925f, -0.32738325f, -0.59732461f, 0.44078964f, 0.52330971f, -0.05704688f, 
    -0.51265585f, -0.25234929f, 0.06926921f, -0.67078400f, -0.33192354f, -0.12472504f, 0.15535757f, 0.07348038f, 
    -0.14538388f, 0.01117362f, 0.23581494f, -0.06148459f, -0.00133051f, 0.18338045f, 0.36354965f, -0.24584413f, 
    -0.01467232f, -0.27406082f, -0.31649041f, 0.02485875f, -0.37233821f, -0.13598607f, 0.44706956f, -0.15779771f, 
    0.27480945f, 0.03266142f, -0.07481115f, -0.04617385f, -0.40343904f, -0.57786644f, 0.20271401f, 0.21664222f, 
    0.33691707f, -0.38819087f, 0.11344656f, 0.05515476f, 0.03559279f, 0.13620366f, 0.10229915f, 0.60966563f, 
    -0.56368095f, -0.12639308f, -0.39861226f, -0.06641430f, -0.60007155f, 0.23131925f, -0.15700515f, 0.21360788f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.40223065f, 0.13176505f, 0.14490207f, 0.02880977f, 0.36141223f, 0.08792723f, -0.14184023f, 0.10680285f, 
    -0.00304864f, -0.13013749f, -0.15460591f, -0.02468029f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
