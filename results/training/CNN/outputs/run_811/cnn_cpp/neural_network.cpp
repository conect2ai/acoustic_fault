#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.90716720f, 0.86891007f, 0.78562385f, 0.35334176f, -1.07495570f, -1.07339406f, -0.06272802f, -0.05852513f, 
    0.34421358f, -0.16099489f, 0.21021059f, 0.17388934f, -0.06330513f, -0.11382027f, -0.10227481f, -0.08633870f, 
    0.05194174f, 0.15219359f, -0.04051625f, 0.23711662f, 0.04466097f, 0.36505628f, -0.11198247f, -0.03319401f, 
    0.12358490f, -0.51583922f, 0.28897166f, -0.49397174f, -0.63093561f, -0.87289912f, 0.55619597f, -0.09253316f, 
    -0.23419024f, -0.05812350f, 0.62515461f, -0.31423849f, -0.05311089f, -0.42047882f, -0.37820634f, -0.69818830f, 
    0.18026450f, 0.08890561f, 0.58492160f, -0.17773432f, 0.04152374f, -0.15640536f, -0.29211766f, -0.07141544f, 
    -0.31688818f, 0.07431348f, -0.81643838f, -0.94903618f, -0.70786834f, -0.39478633f, -0.55378735f, -0.70339733f, 
    0.86346298f, 0.72799772f, 0.31037328f, 0.28220478f, 0.33876374f, -0.29705030f, 0.16011877f, -0.07707182f, 
    0.24190512f, 0.06480316f, -0.33762723f, -0.18363270f, -0.41033876f, -0.27850261f, 0.32517523f, 0.07930998f, 
    -0.06437685f, 0.49651280f, 0.17955393f, 0.70848548f, -1.21211612f, -0.30195701f, 1.27802467f, 0.73167747f, 
    -1.11524439f, 0.31344965f, 0.37170124f, -0.54255450f, 0.54209095f, 0.59512454f, 0.25105131f, -0.26309964f, 
    -0.28385693f, 0.07607519f, 0.05629571f, 0.35098904f, 0.40979037f, 0.35709810f, -0.24294443f, -0.20213486f, 
    -0.05980877f, -0.24154922f, 0.33329573f, -0.22126226f, 0.54339349f, -0.33779246f, -0.86011499f, -1.01072836f, 
    -0.05177554f, -0.25445509f, -0.07249276f, 0.59342080f, 0.13921237f, 0.59238434f, -0.30050898f, 0.21407042f, 
    0.31017944f, -0.26166272f, -0.59942120f, -0.08761461f, 0.34074643f, 0.58182120f, -0.02575857f, 0.02495382f, 
    0.16150019f, -0.03351739f, 0.15042721f, 0.12775072f, 0.21356000f, 0.74244940f, 0.17948174f, 0.50340122f, 
    1.06699979f, -0.63558418f, 0.23597251f, -0.52927119f, 0.36806488f, -0.07098453f, 0.20273051f, 0.38221151f, 
    -0.02529095f, 0.37017325f, -0.21424365f, -0.03995022f, -0.58946925f, -0.09317783f, -0.15465389f, 0.06293215f, 
    -0.37555891f, 0.10001609f, -0.33470029f, -0.24960193f, -0.52077430f, -0.16216752f, -0.92371029f, 0.31475934f, 
    -0.68557715f, -0.32261428f, 0.16874970f, 0.64279646f, 1.16931236f, 0.11332943f, 0.50156987f, 0.79567641f, 
    -0.26004311f, -0.36193350f, 0.05769238f, -0.52769899f, 0.16718584f, -0.04050854f, 0.01889371f, -0.03913498f, 
    0.12314797f, -0.29683560f, 0.08007136f, 0.00324945f, -0.26789299f, -0.00538027f, -0.17727940f, -0.51961130f, 
    -0.60346258f, 0.30726165f, -0.43123472f, -0.36350796f, -0.18255869f, -0.32226902f, -0.84949434f, -0.75926006f, 
    -0.48696253f, -0.52282274f, 0.00142177f, -0.38695365f, -0.26068288f, -0.33057767f, -0.05458258f, 0.27969530f, 
    0.48212945f, 0.01880677f, -0.36500105f, 0.26397616f, 0.10029363f, 0.34006587f, 0.22887327f, -0.30697769f, 
    1.34154558f, 0.14436877f, 0.72383964f, -0.72556329f, -0.76041931f, 0.56269318f, -0.76247293f, 0.20794395f, 
    0.09639844f, 0.32479423f, 0.85802156f, 0.36428261f, 0.10953243f, 0.17705350f, -0.36271054f, -0.15765281f, 
    -0.16809402f, 0.09765581f, -0.17939469f, -0.03745598f, -0.07651876f, 0.28616256f, 0.38275456f, 0.47807804f, 
    -0.03186601f, -0.13334674f, -0.87126833f, -0.57790720f, -0.44577408f, -0.28211316f, 0.15441976f, -0.33191091f, 
    0.01642990f, 0.61087841f, 0.03194652f, -0.50064546f, -0.20767491f, -0.20253885f, 0.26436052f, -0.07291068f, 
    0.27268764f, 0.17457975f, -0.26478595f, 0.13324270f, -0.00857052f, 0.43516806f, 0.46767816f, 0.66836929f, 
    0.27381325f, 0.29423895f, 0.61075950f, -0.48430967f, 0.67194140f, 0.31593847f, 0.90034473f, -0.35509944f, 
    0.98348689f, 0.18458438f, 0.07294183f, 0.68435180f, 0.27322772f, 0.16119288f, -0.22070651f, -0.06275816f, 
    -0.19035508f, -0.39015734f, -0.60860831f, -0.51989979f, 0.14716728f, -0.17963798f, 0.12429871f, -0.13429102f, 
    0.09043572f, 0.00981274f, -0.02285941f, 1.14821768f, -0.28441530f, -0.40401128f, 0.14903747f, -0.55975688f, 
    0.87558973f, 0.33171743f, 0.48043227f, 1.00148070f, 0.41488609f, -0.30762908f, 0.12524419f, -0.32027671f, 
    0.15420286f, 0.33275360f, 0.08696790f, -0.14570332f, 0.03381568f, 0.19534922f, 0.44540289f, 0.17943445f, 
    -0.28868055f, 0.09785672f, -0.27604681f, -0.49074024f, -0.85556865f, -0.87527400f, -0.79138356f, 0.39279407f, 
    -0.08134267f, 0.57896370f, -0.73655593f, -0.08199020f, 0.35625851f, -0.01420809f, 0.20604056f, 0.05517486f, 
    0.24127492f, 0.72909367f, 0.26152346f, 0.17846557f, 0.20858118f, 0.11353470f, 0.11054848f, -0.18695499f, 
    -0.32741234f, -0.29009420f, -0.32537833f, -0.17486049f, -0.45809239f, 0.37445450f, -1.05527985f, -0.35432705f, 
    -0.71720916f, 0.27471688f, 0.23400706f, 0.87354898f, -0.13885294f, -0.25924969f, -0.62420291f, -0.29204190f, 
    -0.16977929f, -0.48893109f, -0.50363576f, -0.60171276f, 0.01880773f, -0.06092222f, 0.14737800f, -0.09555604f, 
    -0.22455324f, -0.26782674f, -0.10340679f, -0.01721055f, -0.09640068f, -0.11601435f, -1.05628836f, -0.25909007f, 
    0.22628297f, 0.76229382f, -0.82422578f, 0.72894317f, -0.38573146f, -0.02908622f, 0.41419792f, -0.76059866f, 
    -0.05120599f, -0.22958335f, -0.38024205f, -0.03391852f, -0.34056360f, -0.13589902f, 0.44384673f, -0.42122960f, 
    0.07592943f, -0.09187051f, -0.08785048f, 0.30598563f, 0.22952555f, -0.07572033f, -0.00687533f, 0.06620473f, 
    1.26600718f, 0.69002306f, 0.02958459f, -0.30462387f, -1.44720972f, -0.04805866f, -0.32982329f, -0.78532088f, 
    -0.47011343f, 0.47371995f, 0.18892039f, -0.19561684f, 0.36815995f, 0.05488271f, 0.09205518f, -0.28416473f, 
    0.32059491f, 0.15505959f, -0.37802479f, 0.15359309f, 0.01217262f, 0.07960781f, -0.00214579f, -0.06918741f, 
    -0.99693239f, -1.09613931f, 0.84836203f, 0.53881168f, -0.64156044f, 0.47587818f, 0.39868781f, -0.17809834f, 
    0.19984381f, -0.30418989f, 0.17998512f, 0.54021090f, -0.32188660f, 0.36036086f, 0.25160390f, 0.14618404f, 
    -0.12312835f, 0.08043574f, -0.19541653f, -0.30938292f, 0.08446900f, 0.07474361f, -0.27575606f, -0.26781988f, 
    -0.07787765f, -1.06474948f, 1.37887371f, -0.08026884f, -0.98002154f, -0.78053123f, 1.22697866f, -0.25460771f, 
    -0.32496321f, 0.50476891f, 0.34812641f, 0.25788015f, -0.18668662f, -0.26965794f, 0.30585408f, 0.02877559f, 
    0.06918519f, 0.08468328f, -0.23032473f, 0.00397702f, -0.13698260f, -0.23437645f, 0.09841739f, 0.13020864f, 
    0.26085967f, 0.10160685f, 1.32707894f, -0.00175978f, 0.94243848f, 0.85795051f, 0.18784423f, 0.75309932f, 
    0.15986568f, -0.03691986f, -0.46004230f, -0.05823854f, -0.63884163f, -0.03673974f, -0.01183879f, 0.27066946f, 
    -0.28575364f, 0.24901563f, 0.28375009f, 0.45784116f, 0.15735571f, 0.02128275f, 0.01619761f, -0.08944082f, 
    -0.16875032f, -0.36510065f, -0.07848821f, -1.40360224f, 1.21581936f, 0.20835893f, -0.69992703f, 0.86223894f, 
    -0.55131167f, 0.83945745f, -0.09692556f, -0.45916027f, 0.04683811f, -0.05474169f, 0.09854341f, 0.47716463f, 
    -0.50385040f, 0.03568911f, 0.04462265f, -0.23686200f, -0.03393360f, 0.05723968f, -0.02053224f, -0.03895272f, 
    0.13880998f, 0.17304921f, 0.09580749f, 0.07663468f, 0.83902270f, 1.10554600f, -0.02658035f, 0.70559573f, 
    0.34792337f, 0.25630787f, -0.38312104f, -1.21494126f, -0.51917344f, -0.12797840f, 0.53074807f, -0.33491644f, 
    -0.07082122f, -0.10226439f, -0.56120533f, -0.11094873f, -0.17614502f, -0.11393306f, -0.20334044f, -0.13376664f, 
    -0.26777849f, 0.25653929f, -0.06200148f, -0.12204856f, 0.02347891f, -0.32335740f, -0.01958756f, -0.08159643f, 
    -0.82277578f, 0.69417733f, 0.28671992f, -0.77121460f, -0.39560676f, -0.09054983f, -0.85255241f, -0.22612900f, 
    0.12295631f, -0.13529059f, -0.28195357f, -0.17591304f, 0.38063478f, 0.17889416f, 0.32895514f, 0.15564223f, 
    -0.15790600f, -0.12174383f, 0.04664445f, -0.28311619f, 0.04105069f, 0.60995829f, 0.85350680f, -0.08700254f, 
    1.03626359f, 1.00205755f, -0.01053778f, -0.18264143f, -0.38420561f, 0.14470160f, 0.23447742f, 0.43628073f, 
    0.12472214f, 0.25071520f, -0.43001011f, -0.02194209f, 0.44034973f, 0.17034647f, 0.04113768f, -0.06949380f, 
    -0.11103747f, -0.30595958f, 0.50114870f, 0.45254022f, 0.24828425f, 0.33292148f, 0.02260900f, 0.53590441f, 
    0.75077999f, 0.99524808f, 0.59888399f, 0.64583427f, -0.15611851f, 0.24586931f, 0.17371185f, -0.80125380f, 
    -0.45083088f, 0.17579244f, -0.28759059f, -0.20774519f, 0.18304633f, 0.38441613f, -0.12512913f, 0.24848691f, 
    0.30145720f, 0.08244730f, 0.51585162f, 0.14700370f, -0.03864949f, 0.18443546f, 0.24913475f, 0.67624098f, 
    0.54321361f, -0.12018196f, -0.62871760f, -0.74086660f, 0.57714647f, 1.04555535f, 0.23695408f, -0.91601235f, 
    -0.16464199f, -0.41696903f, 0.33227068f, 0.04513048f, -0.13855870f, 0.42330959f, 0.53437030f, -0.13276246f, 
    -0.50674033f, -0.14259154f, -0.32348463f, -0.12870878f, 0.41043171f, 0.64547414f, 0.13129765f, -0.00869925f, 
    0.15222724f, -0.33896756f, 0.06066989f, 1.07038331f, 0.69102234f, 0.92899215f, 1.03072321f, 0.62391579f, 
    -0.05768803f, -0.17141865f, -0.06387065f, -0.00564739f, 0.05960914f, 0.34395066f, 0.15260713f, 0.07385534f, 
    0.25516224f, 0.05777904f, -0.16658188f, 0.08020154f, 0.12780087f, 0.05537035f, 0.16785499f, -0.30993944f, 
    0.14487933f, -0.00382530f, -0.29127988f, -1.16954398f, -0.55757928f, -0.05312007f, -0.66847026f, 0.06983012f, 
    1.16527927f, -0.17072941f, 0.04851482f, 0.65490586f, -0.51655138f, -0.00324081f, -0.41573995f, -0.03365835f, 
    0.27460465f, -0.33052278f, 0.11650220f, -0.43365568f, 0.04473094f, -0.07457318f, -0.23073055f, -0.10417300f, 
    -0.25016105f, 0.03838659f, -0.11177783f, 0.90282845f, 0.83494002f, 0.26531109f, 1.32025802f, 1.15386844f, 
    0.71750325f, 0.16073059f, -0.61783761f, 0.56985116f, 0.12277311f, -0.29509670f, 0.25403148f, -0.16250595f, 
    0.30869544f, -0.21396798f, -0.19854936f, 0.10020171f, 0.36442739f, -0.41418836f, -0.40393656f, -0.05339920f, 
    -0.35873577f, -0.28610840f, -0.02662601f, -0.06748337f, 0.01254634f, 0.69865024f, -0.65014064f, -0.46273515f, 
    0.57093602f, -0.27377409f, -1.18193865f, -0.55056733f, -0.97890055f, -0.29748797f, 0.66274810f, 0.21892583f, 
    -0.42871964f, -0.17731683f, 0.06750786f, -0.14883597f, 0.22107445f, -0.24521306f, 0.13698943f, 0.29615098f, 
    0.49658462f, 0.12375925f, -0.05931028f, -0.45223218f, 0.37749150f, -0.67784584f, -0.66854858f, -0.82529670f, 
    -0.80247599f, -0.61964238f, -0.39330193f, -0.49654219f, -0.27045852f, -0.27712107f, -0.00161717f, 0.58074778f, 
    0.33048451f, -0.19058329f, 0.23983289f, -0.10688766f, 0.07902814f, 0.05223638f, 0.21471412f, -0.40668732f, 
    0.41221204f, -0.12692817f, 0.22037177f, -0.13052818f, 0.26359507f, 0.20047997f, -0.67559654f, -1.27458632f, 
    -0.94617546f, -0.10590241f, 0.71586853f, 0.32675764f, 0.79454654f, 0.17132770f, -0.32702518f, -0.20850207f, 
    -0.02257911f, 0.26426134f, 0.18724222f, 0.41697600f, -0.10191078f, 0.09735598f, 0.35886693f, 0.02417648f, 
    0.04446883f, 0.03914367f, 0.08427237f, -0.24450761f, 0.09553179f, -0.03077426f, 0.13047293f, 0.95200324f, 
    0.35453224f, -0.72493523f, -1.06846893f, 0.17695925f, -0.27197513f, -0.37783897f, 0.69639653f, 0.38636890f, 
    0.37006450f, -0.71063852f, -0.26598096f, -0.48705170f, -0.03414561f, 0.26559001f, -0.03305424f, -0.28107792f, 
    -0.04738711f, -0.12057881f, 0.32057929f, -0.25331241f, 0.29416284f, -0.58266789f, -0.01167818f, -0.28970620f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27272406f, 0.00294590f, 0.09556398f, 0.10231548f, 0.29563349f, 0.22956386f, -0.00252127f, -0.00093606f, 
    0.17423952f, 0.06946445f, 0.23678216f, 0.20169504f, 0.25754344f, 0.23637566f, 0.16564234f, 0.32896221f, 
    0.44492480f, 0.12366163f, 0.13322318f, 0.33289683f, 0.11140999f, 0.29347280f, 0.40076643f, 0.35217512f, 
    0.09623619f, 0.27686414f, 0.02568782f, 0.07900540f, 0.34754294f, 0.19553021f, 0.41952187f, 0.33712277f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05016578f, 0.14323947f, -0.20417260f, 0.18883178f, -0.12726492f, -0.11166274f, -0.34706873f, -0.08492924f, 
    0.11010166f, -0.11075106f, -0.09787981f, -0.03293743f, 0.37263918f, 0.13134617f, -0.02010222f, -0.11160231f, 
    0.11905248f, 0.10022070f, 0.03707715f, -0.11608369f, 0.05440991f, -0.00783083f, -0.03807039f, -0.08276914f, 
    -0.08677778f, 0.28764299f, -0.07368352f, -0.23948279f, 0.05573068f, -0.02393609f, -0.17768115f, 0.04488588f, 
    0.01643207f, -0.00369822f, -0.04836129f, 0.09034356f, 0.12558383f, -0.03288175f, -0.08334064f, 0.51361698f, 
    -0.16516759f, 0.03297943f, -0.03115019f, 0.04858523f, 0.02993767f, -0.01007165f, 0.03651832f, 0.11725511f, 
    0.05958622f, 0.05525796f, -0.12213133f, -0.52969491f, 0.08093303f, 0.01691145f, 0.10529380f, -0.02953718f, 
    -0.11462446f, 0.03821923f, -0.11994588f, -0.04769295f, 0.07836311f, -0.05397927f, -0.21162172f, 0.13026080f, 
    0.03299252f, -0.02647046f, 0.01798697f, -0.08767778f, -0.12016675f, 0.09414484f, 0.00877291f, -0.02209361f, 
    0.55062258f, 0.19276744f, 0.28535274f, -0.12558998f, 0.17674083f, 0.08151241f, 0.08526268f, -0.12532806f, 
    0.02256140f, 0.03723474f, -0.11650669f, 0.08951847f, -0.56621337f, -0.25025284f, 0.14960752f, 0.11715669f, 
    0.06096910f, -0.08567424f, -0.02683382f, 0.11385073f, -0.08572540f, 0.12880114f, 0.04457627f, -0.04268924f, 
    0.16635971f, -0.16291539f, -0.02997754f, -0.19454911f, -0.05840232f, 0.04100240f, -0.07891922f, -0.03811559f, 
    -0.15889540f, 0.04694301f, -0.15155426f, 0.05005416f, 0.19036250f, -0.10579501f, -0.05677647f, -0.24771684f, 
    0.11586382f, -0.08007431f, 0.07988739f, 0.12470715f, 0.01296129f, -0.00939066f, 0.17441887f, 0.01482920f, 
    0.06293233f, -0.09712350f, 0.06543710f, 0.00621338f, -0.16175716f, -0.11211425f, -0.07749740f, 0.08029196f, 
    0.04986453f, 0.07266402f, -0.02034249f, -0.01264155f, 0.35024643f, -0.03653717f, -0.18170905f, 0.12625977f, 
    -0.01551136f, -0.06500728f, -0.02989516f, -0.07858956f, -0.11162613f, -0.09598669f, 0.11314141f, 0.03723708f, 
    0.16680932f, -0.23283757f, -0.05167929f, 0.08249681f, 0.18054567f, 0.06104020f, 0.03400325f, 0.05787668f, 
    0.03985274f, -0.08486443f, -0.09056702f, 0.07091201f, -0.28177559f, 0.16255060f, 0.32426354f, -0.35106245f, 
    -0.07517018f, -0.04798860f, 0.03179548f, -0.15750097f, -0.25978476f, -0.02820016f, -0.01184809f, -0.06623598f, 
    0.00444171f, -0.04457098f, -0.14492120f, 0.38380381f, 0.02644987f, -0.01020267f, -0.03384729f, -0.07447454f, 
    -0.02934891f, 0.06579196f, 0.05580420f, -0.15044090f, -0.21425012f, 0.25591600f, -0.09273885f, -0.04994492f, 
    -0.05205737f, -0.04444225f, 0.05238692f, -0.16527437f, -0.14121014f, -0.07476077f, 0.02775717f, -0.08255877f, 
    -0.52347761f, 0.05737475f, 0.09802680f, 0.33569553f, -0.02456662f, 0.04976157f, 0.09829193f, 0.09577344f, 
    0.04677805f, 0.03619461f, 0.08131961f, -0.16218512f, 0.55130887f, -0.15920852f, -0.04036618f, -0.21251634f, 
    -0.21301746f, -0.01583648f, 0.14638664f, -0.14655440f, -0.01526884f, 0.00428670f, -0.05033425f, -0.01751074f, 
    0.25608337f, 0.07078873f, -0.09667607f, 0.26349533f, -0.18528108f, -0.11145619f, 0.10203145f, 0.10990221f, 
    -0.03486353f, 0.07698615f, -0.11472571f, 0.13400011f, -0.09838706f, -0.16177298f, 0.25585970f, -0.20788175f, 
    -0.03910398f, -0.22583242f, 0.00542259f, -0.07077532f, 0.08523863f, -0.09649094f, -0.06831677f, -0.10923702f, 
    0.16127613f, 0.04301687f, 0.13505609f, 0.07021537f, -0.15281746f, 0.01820361f, 0.02138813f, 0.20499997f, 
    0.00660093f, 0.06708658f, -0.11497368f, -0.05431459f, -0.39456403f, -0.18270056f, 0.23648149f, -0.05761803f, 
    -0.03626071f, 0.03894803f, 0.04248326f, -0.00293103f, -0.01091113f, -0.05039659f, -0.01006126f, -0.10774017f, 
    0.27158234f, -0.21364769f, -0.32538566f, 0.23190501f, -0.12901452f, -0.11631982f, 0.01401452f, -0.08001076f, 
    0.05145011f, 0.04470217f, 0.03141899f, -0.13028441f, 0.17951995f, 0.23740409f, -0.08255249f, -0.16989703f, 
    -0.28535357f, -0.14642309f, 0.02089857f, 0.04010895f, -0.01253321f, -0.15517569f, -0.03022701f, 0.02528012f, 
    -0.22547205f, -0.08956694f, 0.31797144f, -0.16285460f, -0.11620604f, -0.02161885f, 0.17940879f, -0.04521727f, 
    0.06671556f, -0.04286039f, 0.06882588f, 0.07807827f, -0.12806088f, -0.11347751f, 0.13904291f, 0.12233269f, 
    -0.17855829f, -0.04026594f, 0.13396575f, -0.12278794f, 0.02432548f, -0.14402874f, 0.01950246f, -0.04829493f, 
    0.06590438f, -0.15490668f, 0.16418986f, -0.29673290f, 0.08004112f, 0.08657038f, 0.02772850f, 0.01899055f, 
    0.07055277f, -0.08513836f, 0.01449261f, 0.07307981f, 0.12305912f, 0.00898273f, -0.02833424f, 0.41600809f, 
    -0.21224795f, 0.01625734f, 0.16313478f, 0.07036650f, -0.00439119f, 0.11816961f, -0.11701123f, -0.09720839f, 
    0.18153375f, -0.21560867f, 0.37151319f, -0.11768981f, -0.08692657f, 0.08089532f, 0.01745696f, 0.09757590f, 
    -0.01495459f, -0.14294927f, 0.07113939f, 0.13239852f, -0.50465763f, -0.46065763f, -0.16595717f, 0.10088733f, 
    -0.22759509f, -0.01001308f, 0.07974659f, 0.01713143f, -0.03492551f, -0.15223432f, -0.09437739f, -0.10104817f, 
    -0.56007314f, 0.18215564f, -0.09665682f, -0.18797982f, 0.09092376f, 0.13856576f, 0.01824973f, -0.06320935f, 
    0.17968370f, 0.11953142f, 0.05469033f, -0.04436032f, 0.21418147f, -0.19452451f, -0.06466883f, -0.48374298f, 
    -0.08225857f, -0.13196979f, 0.01008784f, -0.09135641f, -0.09633526f, -0.08383890f, -0.14791806f, 0.12612912f, 
    0.21524830f, -0.12746327f, -0.30472720f, 0.13453247f, -0.02449028f, -0.05588029f, 0.06627814f, 0.08548324f, 
    -0.03230366f, 0.02826683f, -0.05232601f, 0.01950848f, -0.54529452f, -0.04653268f, 0.05834446f, -0.13997410f, 
    0.07269158f, -0.09296731f, 0.08178235f, -0.10980034f, 0.31203482f, -0.05921775f, -0.07777187f, -0.07390206f, 
    0.28859341f, -0.17118204f, -0.13363424f, 0.08790183f, -0.03281268f, -0.00250735f, 0.00476169f, 0.09844615f, 
    0.06144402f, -0.10630774f, -0.08358256f, 0.05222623f, 0.06328728f, -0.34153512f, 0.06905937f, 0.15673278f, 
    -0.33613980f, 0.00391825f, -0.00434991f, 0.05086058f, 0.02571985f, -0.09001192f, 0.03388230f, 0.14076310f, 
    0.21315989f, -0.37662587f, 0.18777983f, -0.60968298f, 0.17411982f, 0.00569490f, 0.04429297f, 0.10188226f, 
    0.08029846f, -0.23954077f, 0.15577535f, -0.12834926f, -0.17640078f, 0.12767343f, 0.19911198f, 0.21709970f, 
    -0.13116649f, -0.12733549f, -0.03998669f, -0.01920034f, 0.01469139f, -0.15731525f, -0.01918333f, 0.01695449f, 
    -0.08888877f, -0.09734700f, -0.02508107f, -0.09298995f, 0.13204531f, -0.10100792f, -0.25821006f, 0.10782093f, 
    0.18639326f, 0.08564124f, -0.04623696f, -0.04591336f, -0.01919046f, 0.11309811f, -0.07622094f, -0.02964742f, 
    -0.06391366f, -0.13619095f, 0.01644466f, -0.01682764f, 0.10527587f, -0.06630291f, -0.01692293f, 0.01814421f, 
    0.10635541f, 0.03317354f, 0.12972073f, -0.09898177f, 0.08584861f, -0.00146220f, 0.03078885f, -0.07210901f, 
    0.07106342f, 0.03008829f, 0.23109473f, -0.15095292f, 0.01152270f, -0.20101546f, 0.06505609f, -0.34219769f, 
    0.03953739f, -0.01340842f, 0.07785565f, 0.02024909f, 0.12597749f, 0.00772068f, -0.03727127f, 0.05298331f, 
    0.23409578f, 0.05915308f, 0.08451997f, 0.32455835f, -0.07981090f, 0.12730150f, 0.01258604f, 0.15611272f, 
    0.06608591f, 0.13193870f, -0.27064243f, -0.10918842f, 0.45367467f, -0.19490580f, 0.21090217f, -0.03728519f, 
    -0.04828994f, 0.06669451f, 0.08481394f, 0.05378070f, 0.06948975f, 0.23603167f, -0.08310345f, 0.05591719f, 
    0.06763442f, 0.26618358f, -0.07801831f, 0.05114255f, 0.08873363f, -0.09858894f, -0.06790671f, -0.00322642f, 
    -0.15116976f, 0.08856927f, -0.00219673f, 0.06010986f, 0.21850404f, -0.42453772f, -0.04652762f, -0.12748495f, 
    0.16280018f, -0.01250618f, -0.06011201f, -0.00187930f, -0.01777418f, -0.05588833f, -0.21110982f, 0.10190409f, 
    -0.57088006f, 0.04775221f, -0.34453461f, 0.05907869f, 0.06311813f, -0.03683474f, 0.08393208f, 0.04409857f, 
    0.07558756f, 0.11868562f, -0.08741789f, 0.02211170f, -0.34751630f, -0.05722450f, -0.33261645f, -0.20688151f, 
    0.02562995f, 0.14519376f, 0.03204658f, 0.08080766f, 0.11967647f, 0.05361000f, 0.13529335f, 0.09306537f, 
    -0.03302151f, 0.12860887f, -0.27268296f, 0.02586338f, -0.26789480f, 0.02103820f, 0.10599893f, 0.04297580f, 
    -0.15105854f, -0.30130690f, -0.04924561f, 0.13472266f, -0.77816021f, -0.26730153f, 0.01700873f, -0.36524630f, 
    0.00820411f, -0.01216321f, -0.05022128f, -0.05733640f, 0.08474805f, 0.12859778f, -0.10375308f, -0.13062699f, 
    0.42088825f, 0.01594265f, 0.08629069f, 0.07566677f, -0.17650984f, -0.00970607f, -0.05067518f, -0.08528515f, 
    0.13634074f, -0.14454189f, 0.15186776f, -0.08270893f, -0.06244224f, 0.28061336f, -0.29428390f, -0.59802055f, 
    0.02323541f, 0.12236071f, 0.11213135f, -0.00300776f, -0.01025415f, -0.03295776f, -0.03176059f, -0.09166269f, 
    0.29917279f, -0.42985159f, 0.01705112f, -0.02452465f, -0.05690474f, -0.05461999f, 0.02858172f, -0.06343724f, 
    -0.18568055f, -0.00192283f, -0.02542288f, -0.20159274f, 0.12817109f, 0.01446224f, 0.00789180f, -0.42767024f, 
    -0.08543476f, 0.04374206f, -0.06538948f, 0.00456942f, 0.04603586f, 0.05189933f, 0.14691894f, 0.06800091f, 
    -0.09619805f, 0.20222895f, 0.25718802f, 0.29858458f, -0.04255365f, -0.05773028f, 0.08252025f, -0.03691782f, 
    -0.01496137f, -0.07346988f, -0.03006090f, 0.12195546f, 0.01330812f, 0.21547717f, 0.03892465f, 0.31136003f, 
    0.00617229f, 0.08658300f, 0.00602806f, 0.00807180f, -0.00644913f, 0.16978689f, 0.09603705f, 0.07610007f, 
    0.31758890f, -0.38803169f, -0.13964880f, -0.23763920f, -0.04529045f, -0.06074834f, -0.04559575f, -0.05322884f, 
    -0.28828672f, -0.09886871f, -0.33229429f, -0.12215183f, 0.22802117f, 0.20028894f, 0.02743366f, 0.04137979f, 
    -0.18463972f, 0.10703206f, -0.03536598f, -0.11323512f, -0.03091988f, 0.14433154f, 0.14643611f, 0.02939491f, 
    0.16990846f, -0.10459222f, -0.13796496f, 0.03021340f, 0.21795577f, -0.10723181f, 0.07331671f, -0.14201032f, 
    -0.15329507f, 0.06572078f, -0.14245601f, -0.08195336f, 0.34663180f, 0.01201601f, 0.06368555f, 0.16232032f, 
    -0.27022353f, -0.00913618f, -0.12797089f, -0.01169609f, 0.07980250f, -0.18505976f, -0.02744209f, 0.00033985f, 
    -0.12333975f, -0.23254012f, -0.15389712f, -0.36585030f, -0.07097549f, -0.02812240f, -0.08763696f, -0.07175099f, 
    0.06423891f, 0.13791187f, 0.04775130f, 0.01639990f, 0.04864552f, 0.04772605f, -0.05360186f, -0.06919567f, 
    0.04223173f, 0.00186305f, -0.00799886f, 0.21482742f, -0.02709462f, 0.02682189f, 0.10994966f, 0.16608627f, 
    0.33350906f, -0.15463148f, 0.05220302f, -0.05639895f, -0.05134135f, -0.03107575f, -0.07651155f, 0.23898767f, 
    -0.07485855f, -0.11169218f, -0.03363212f, -0.04875226f, 0.16119882f, -0.18699121f, 0.10227566f, -0.21013445f, 
    0.16409381f, -0.00547931f, 0.00662592f, 0.15505090f, -0.02429578f, 0.02986864f, -0.11916558f, 0.03214076f, 
    -0.35212529f, 0.25150087f, -0.16670039f, -0.16041458f, -0.10303724f, 0.05515271f, 0.07040449f, 0.01046414f, 
    -0.05544402f, 0.04551536f, -0.02509940f, -0.02638819f, 0.07901413f, 0.03169373f, 0.01405135f, 0.06008785f, 
    0.06281804f, -0.05608618f, 0.04239320f, 0.03500473f, -0.10043283f, 0.10097745f, 0.14330487f, -0.09865527f, 
    0.41553277f, 0.10181043f, 0.03738109f, 0.32610938f, -0.14084324f, -0.13176014f, -0.05774662f, 0.03101048f, 
    -0.00954413f, 0.01996902f, 0.13851440f, -0.16915521f, 0.65165615f, -0.04547127f, -0.00522424f, 0.01499699f, 
    0.04792055f, 0.05668705f, 0.00710528f, -0.02356076f, -0.10733691f, -0.10919632f, 0.01212860f, -0.01863681f, 
    0.11759004f, 0.08876076f, 0.14142226f, 0.18652937f, -0.08644082f, -0.28266701f, 0.09525242f, -0.10214178f, 
    -0.11293439f, -0.01300075f, -0.09302305f, 0.16511774f, -0.25169575f, 0.04240331f, -0.12230451f, -0.02597368f, 
    -0.02026558f, 0.05892114f, -0.08899856f, -0.05706617f, -0.05354723f, 0.15966806f, -0.00644907f, 0.00545642f, 
    0.38848719f, 0.09595791f, 0.14110440f, 0.18312255f, 0.03840768f, 0.05126286f, 0.01933135f, 0.06607688f, 
    -0.03146863f, 0.01300044f, 0.02535645f, 0.08599899f, -0.31256875f, -0.20110983f, -0.27105594f, -0.34133410f, 
    -0.15031615f, 0.02160246f, 0.06210339f, -0.08006224f, -0.05565945f, -0.00249387f, 0.00212027f, 0.06865568f, 
    -0.54833329f, 0.08389903f, 0.20980006f, -0.21372806f, -0.14630687f, 0.07883992f, -0.04492208f, 0.11946715f, 
    -0.08349468f, 0.04773805f, 0.04954125f, -0.04094771f, -0.17829086f, 0.04551120f, -0.06786343f, 0.35971007f, 
    -0.13677005f, 0.00833261f, -0.20349084f, -0.02987638f, -0.07201519f, -0.03687914f, 0.06774107f, 0.15075068f, 
    0.04136617f, 0.13916284f, 0.04136885f, -0.08276439f, 0.14551507f, 0.03341273f, 0.03897562f, -0.02555460f, 
    -0.08501979f, 0.06712116f, 0.18580784f, 0.05084859f, -0.09852341f, 0.16801924f, -0.02615170f, 0.02021694f, 
    0.01624557f, -0.16117322f, 0.01161006f, 0.14004880f, -0.05627673f, -0.20088789f, 0.02262030f, -0.08497277f, 
    0.04611124f, 0.10837712f, 0.10329986f, 0.00345688f, -0.08344875f, -0.00199527f, -0.07277146f, 0.02438993f, 
    -0.22184920f, 0.00946900f, -0.19194235f, -0.03176901f, -0.46789306f, -0.25192311f, 0.06848434f, -0.15391906f, 
    -0.07691249f, 0.00248319f, -0.10579203f, -0.01457309f, 0.02726839f, 0.06533144f, -0.01426126f, 0.08367544f, 
    -0.11307259f, -0.37829098f, -0.20519762f, -0.13727739f, -0.03121336f, 0.03162367f, -0.16525437f, -0.12707938f, 
    0.08721103f, -0.10827132f, 0.08797308f, 0.07927070f, 0.12510568f, 0.15995881f, -0.29920492f, -0.23027642f, 
    0.18413661f, 0.04557746f, 0.08886492f, -0.13863100f, -0.06610710f, -0.06898189f, -0.08364613f, -0.05800417f, 
    0.51283187f, -0.28136051f, -0.03463827f, -0.21819800f, -0.11563168f, -0.01517991f, 0.17770121f, 0.09675765f, 
    0.16105643f, -0.04069886f, -0.03690182f, -0.08010636f, 0.30454931f, 0.32652625f, -0.00779151f, -0.12173960f, 
    0.10121268f, 0.01831807f, 0.07033518f, -0.03337606f, -0.11993561f, -0.11567333f, 0.03967657f, -0.00751568f, 
    -0.41488522f, -0.06137957f, 0.08884456f, -0.17362510f, 0.12198996f, 0.06561136f, 0.01615186f, 0.03971267f, 
    -0.03612804f, 0.12390539f, -0.22133240f, -0.02834558f, 0.50781238f, -0.26876503f, -0.22010186f, -0.06532507f, 
    0.16234644f, 0.02873152f, -0.17958359f, -0.10709812f, 0.02900818f, -0.05688822f, -0.01006393f, -0.04043587f, 
    0.06016649f, 0.08486797f, -0.05211923f, -0.04233744f, 0.17449856f, -0.15446021f, 0.00276350f, -0.00860414f, 
    0.01134340f, 0.06528662f, 0.01921986f, -0.01816618f, -0.53421426f, -0.37840280f, -0.20671558f, -0.12643331f, 
    0.07391527f, -0.02833658f, 0.01303098f, -0.11366820f, -0.07468678f, 0.00155225f, -0.11397158f, -0.06661163f, 
    -0.22378604f, 0.19187541f, 0.00274215f, -0.03048030f, -0.14996640f, 0.09806339f, -0.01350362f, 0.00101528f, 
    0.01528246f, 0.00004996f, 0.17011903f, -0.07267661f, 0.01361992f, 0.07886349f, -0.24043740f, 0.10067007f, 
    0.13051537f, 0.10197107f, -0.06036884f, -0.05137894f, -0.05600619f, -0.02771235f, -0.00407383f, -0.08529873f, 
    0.06908704f, -0.36213928f, -0.08502401f, -0.27748021f, 0.02728103f, -0.18559861f, 0.04999868f, -0.04402472f, 
    0.13017096f, -0.17944904f, -0.09826048f, -0.02666904f, 0.21510477f, -0.22659011f, 0.06659158f, 0.14893524f, 
    0.01602232f, 0.00962085f, 0.04972205f, -0.16374210f, 0.08979955f, -0.03127226f, -0.04078462f, -0.07348275f, 
    0.36768445f, -0.12945406f, 0.30201989f, 0.02804985f, -0.10632914f, -0.10890300f, 0.10752121f, 0.15306331f, 
    -0.02479055f, -0.01096076f, 0.14565822f, -0.06481989f, 0.23085310f, -0.31839299f, -0.08061015f, -0.00984269f, 
    0.20609899f, 0.00270512f, 0.00692649f, -0.10901390f, 0.08168440f, 0.14039460f, -0.09523218f, -0.06955969f, 
    -0.26469472f, -0.08847276f, -0.02307273f, -0.24926686f, 0.09925867f, -0.13002917f, 0.16881542f, -0.10540701f, 
    -0.06069609f, -0.03052457f, -0.07946849f, -0.12740199f, -0.47071430f, -0.11667724f, 0.19741029f, -0.19856969f, 
    -0.14585522f, -0.15375675f, -0.26159769f, -0.12977046f, 0.02399436f, 0.01656706f, -0.04830663f, -0.24586064f, 
    0.33903700f, -0.20196569f, 0.19798614f, -0.00140522f, -0.24156794f, 0.03394260f, -0.06531584f, 0.10160840f, 
    0.00070160f, -0.10003334f, -0.03198508f, 0.01976964f, -0.16682673f, 0.05881121f, -0.16755027f, 0.25826886f, 
    0.06994956f, -0.06407814f, 0.14046924f, 0.09675597f, -0.03814221f, -0.07267947f, -0.03815789f, 0.11887491f, 
    -0.20915610f, 0.07419544f, -0.35938767f, -0.05031253f, -0.11321852f, 0.17060180f, -0.02315275f, 0.07089330f, 
    -0.03803894f, 0.03692603f, -0.06930632f, 0.00698725f, -0.19773225f, 0.19667684f, 0.10768534f, -0.20881107f, 
    -0.10716870f, 0.06647651f, -0.05825454f, 0.03730077f, -0.07638242f, 0.01774336f, 0.03907282f, 0.15346232f, 
    0.24112201f, 0.01077687f, 0.05938581f, -0.00936375f, -0.09438607f, -0.14869140f, -0.03341521f, -0.02321672f, 
    -0.04376777f, 0.14000192f, 0.03630447f, 0.01405370f, -0.30934551f, -0.05989459f, 0.28063789f, 0.08822062f, 
    0.01246381f, 0.13925964f, 0.14061929f, -0.09082551f, -0.04631665f, 0.13684444f, -0.10576271f, -0.14714630f, 
    0.09593254f, -0.06259133f, -0.15378125f, -0.06660000f, -0.04985308f, 0.05125223f, -0.09222609f, -0.03255108f, 
    -0.13988298f, 0.15625457f, -0.12799712f, 0.02127862f, 0.46226940f, -0.40947336f, -0.25005230f, 0.09867540f, 
    -0.09033000f, 0.01637683f, 0.20273325f, -0.08894555f, 0.07321829f, 0.18009134f, 0.00970125f, -0.10112713f, 
    -0.62621963f, 0.20224242f, -0.23417799f, -0.18889780f, -0.09229397f, -0.08495040f, 0.05578640f, -0.02171267f, 
    -0.08042736f, -0.16805430f, -0.04863241f, -0.12186127f, 0.14907390f, 0.18615869f, 0.15269826f, -0.01867590f, 
    -0.02588076f, -0.01435072f, -0.12193090f, 0.01998831f, -0.03997602f, 0.10775296f, -0.12596558f, 0.06288029f, 
    -0.11843496f, -0.34471563f, -0.24714445f, 0.06009402f, -0.03837974f, -0.01487207f, 0.05052964f, 0.25726810f, 
    -0.01939078f, 0.16609599f, -0.08552976f, 0.01550258f, 0.30525649f, -0.00982966f, -0.10309163f, 0.01732225f, 
    -0.12394822f, 0.07131474f, 0.04883081f, -0.10425038f, -0.11680295f, -0.02958624f, -0.02275122f, -0.13778204f, 
    -0.56838053f, -0.13540757f, -0.14408042f, -0.09847767f, 0.07325783f, 0.04624332f, 0.08972266f, -0.04507449f, 
    -0.13254878f, 0.11460412f, 0.15221119f, -0.02942220f, -0.09133618f, -0.10095505f, -0.23231280f, -0.12194868f, 
    -0.06340957f, 0.02256975f, -0.20095077f, -0.13649857f, -0.02058500f, 0.09980714f, 0.00525336f, -0.03456256f, 
    0.16004845f, 0.05150362f, -0.30764019f, -0.01324364f, 0.10679609f, 0.03677637f, 0.11862998f, 0.05262572f, 
    0.22075336f, -0.05436605f, 0.06332843f, 0.06797957f, -0.06266907f, 0.05996346f, 0.10377102f, 0.23325248f, 
    -0.08415250f, -0.04622586f, 0.01554243f, 0.10628328f, -0.01463445f, 0.14806534f, 0.04090838f, 0.09784704f, 
    0.03544108f, 0.00663759f, 0.01514885f, 0.26934522f, 0.07669693f, 0.06280294f, -0.05778126f, 0.20311812f, 
    0.11206510f, 0.04711680f, 0.15791315f, -0.04547901f, -0.47336990f, 0.17063536f, 0.10459574f, 0.15930180f, 
    0.01575842f, 0.00111486f, -0.00104960f, -0.09108234f, -0.01396120f, -0.00956329f, 0.06262176f, -0.18325534f, 
    0.09001970f, 0.07575736f, 0.13166644f, -0.20435630f, 0.02008567f, 0.02359351f, -0.00778796f, -0.05640782f, 
    0.00209763f, -0.03325079f, -0.02326120f, 0.11284180f, 0.37528047f, 0.45081249f, 0.03632532f, -0.17505477f, 
    0.03377884f, 0.05639375f, -0.06021299f, 0.29060957f, 0.00090376f, -0.10179809f, -0.15822516f, -0.07892523f, 
    -0.17129572f, -0.80353653f, -0.02356334f, 0.31949320f, -0.16087331f, 0.07367255f, 0.11529673f, 0.07499059f, 
    0.02678875f, -0.17479259f, 0.01409002f, 0.17312010f, -0.07224966f, 0.23092145f, 0.41867515f, -0.15225291f, 
    -0.00526761f, 0.03041873f, -0.12013635f, 0.22476497f, 0.00857781f, 0.07092986f, -0.09006142f, 0.04708569f, 
    0.33596385f, 0.00630321f, -0.24380115f, 0.32083711f, 0.09956243f, 0.05387348f, 0.00381375f, 0.10723765f, 
    0.03821567f, -0.01911934f, 0.08150132f, -0.02188721f, 0.18848024f, 0.02445598f, 0.04564138f, 0.13071464f, 
    0.07988452f, -0.15385823f, -0.09333736f, 0.02281430f, 0.06960771f, 0.02410439f, -0.09336432f, -0.16123837f, 
    -0.47936055f, -0.47840151f, -0.15822114f, -0.12869512f, -0.23318309f, -0.01528806f, 0.03766247f, -0.06749091f, 
    -0.06167372f, -0.08776615f, -0.02665018f, -0.11726166f, -0.89467621f, -0.43346474f, 0.14134008f, -0.05422392f, 
    -0.11454313f, -0.04116262f, -0.05367193f, 0.08632734f, -0.02187157f, -0.18781248f, 0.11106148f, -0.14157473f, 
    0.30180508f, 0.16110408f, 0.16578911f, 0.15639919f, -0.15334551f, 0.01204097f, -0.13039228f, -0.18232277f, 
    -0.13683018f, 0.05065660f, 0.09854396f, -0.13879813f, -0.40424097f, -0.22420402f, 0.04003365f, 0.02880160f, 
    -0.01589429f, -0.11078702f, -0.00017007f, 0.00698927f, -0.06910203f, -0.05407462f, -0.04223476f, -0.07734350f, 
    0.09661225f, -0.14643544f, 0.02453531f, 0.05908181f, -0.16783820f, -0.04061551f, 0.08477043f, 0.03625113f, 
    -0.04501296f, -0.07572249f, 0.10256213f, 0.12180518f, 0.24275814f, -0.42439881f, -0.27369758f, 0.08671223f, 
    -0.11921491f, 0.02351337f, 0.08148419f, -0.12066966f, 0.03769907f, -0.06907919f, -0.00944873f, 0.07097447f, 
    0.31120479f, 0.17896813f, 0.04987484f, 0.29126102f, -0.04833343f, 0.01839904f, 0.02466452f, -0.04158712f, 
    -0.00373278f, 0.01974986f, -0.09223414f, -0.14337394f, 0.12448838f, 0.01798167f, -0.02260243f, 0.01856732f, 
    -0.15993997f, -0.15144564f, -0.08184533f, 0.01750638f, 0.04424230f, -0.06466433f, 0.08200083f, 0.03764457f, 
    -0.00499374f, 0.03170136f, -0.16270770f, 0.12276539f, -0.12149828f, -0.06628298f, 0.02253342f, -0.02838546f, 
    -0.17481738f, -0.04803443f, -0.03009535f, 0.02640741f, -0.10492094f, -0.09839179f, -0.00699072f, 0.08969701f, 
    -0.12668739f, 0.10301498f, 0.04840610f, 0.08343696f, -0.03719928f, 0.09740182f, 0.05086847f, -0.02956718f, 
    -0.22959065f, -0.42696911f, 0.08787852f, 0.09361894f, -0.08477519f, -0.11440338f, 0.22180071f, -0.10944492f, 
    0.01267235f, 0.03822289f, 0.00995698f, -0.14331661f, -0.03750467f, -0.12010891f, 0.13428098f, 0.24011898f, 
    -0.03363638f, -0.10265072f, 0.04032496f, 0.23962469f, -0.12852415f, 0.21126537f, 0.09772533f, 0.30562958f, 
    -0.19366165f, -0.17172682f, -0.05677653f, 0.06221743f, 0.10893380f, 0.14236055f, 0.01600309f, 0.09544294f, 
    -0.06935232f, -0.21907853f, 0.10324407f, -0.04727047f, -0.45024768f, -0.11144830f, -0.20286137f, -0.01812617f, 
    0.14488392f, -0.03872717f, -0.01280339f, 0.00050181f, 0.12430684f, 0.02909914f, -0.06015060f, -0.15639634f, 
    -0.05925888f, -0.20203657f, -0.13159698f, 0.23234102f, -0.07964770f, -0.09359099f, 0.09208532f, 0.00028168f, 
    0.08255841f, 0.04248145f, -0.15898265f, -0.06143181f, -0.26746172f, -0.11232924f, 0.13462548f, -0.12798660f, 
    0.04936081f, 0.08445847f, -0.02499739f, 0.02319378f, -0.00187037f, -0.14881530f, 0.03305339f, 0.02673934f, 
    -0.29556087f, -0.24946058f, -0.12366746f, 0.21233986f, 0.10192581f, 0.03719987f, 0.15830916f, -0.13574690f, 
    -0.00324191f, -0.02046011f, 0.00926134f, 0.06001918f, 0.20251496f, -0.13285433f, 0.27008793f, -0.08292466f, 
    -0.05417439f, 0.14447552f, -0.13776585f, 0.11525358f, 0.19836810f, 0.11596537f, -0.09348933f, 0.22186711f, 
    -0.14179257f, -0.14534694f, -0.03810139f, -0.27170175f, 0.00471521f, 0.09868853f, -0.18733208f, 0.05730541f, 
    0.07322177f, 0.04069474f, -0.05165571f, 0.06185181f, -0.18755440f, 0.04020900f, -0.19683896f, 0.22347605f, 
    -0.03791431f, -0.09090713f, -0.05599374f, 0.11997804f, -0.06026493f, -0.08046538f, -0.19344175f, -0.10695007f, 
    -0.47901052f, 0.20413718f, -0.19272289f, -0.12503786f, -0.06282578f, -0.06831158f, 0.04734877f, 0.13665029f, 
    -0.04977407f, -0.04882801f, 0.13811255f, -0.05830051f, -0.38756272f, 0.11606342f, 0.13464434f, 0.19380179f, 
    0.05369839f, 0.12687027f, 0.14652465f, -0.07994932f, 0.11275670f, -0.03961457f, 0.01874939f, -0.00762155f, 
    -0.15350272f, 0.09666543f, 0.15193421f, 0.21952593f, 0.07978612f, 0.13766532f, -0.04385928f, 0.00524631f, 
    0.22130646f, -0.13888955f, -0.06385885f, 0.00006482f, -0.28396776f, -0.02642753f, 0.26294839f, -0.02727541f, 
    -0.00428270f, 0.09911504f, -0.10389917f, -0.11394855f, 0.09686348f, 0.08183524f, 0.03663422f, 0.01053448f, 
    0.17186409f, 0.13769662f, -0.21956758f, -0.48366114f, -0.05690548f, 0.26710564f, -0.13847244f, 0.13520791f, 
    -0.03016112f, -0.26338848f, -0.01184531f, 0.06665114f, -0.32970396f, -0.51260763f, 0.30737478f, 0.13639568f, 
    0.06799023f, -0.02423247f, 0.11374271f, -0.12897007f, 0.18203267f, 0.10736038f, -0.15543289f, -0.18002202f, 
    -0.01485629f, 0.09527882f, -0.00346492f, -0.43088254f, -0.01209563f, -0.00083018f, -0.03549964f, 0.08440885f, 
    -0.00038507f, -0.05448643f, -0.15517668f, 0.00143666f, 0.63658470f, 0.08880883f, -0.07904400f, 0.05046757f, 
    0.09709390f, -0.06389543f, -0.06563170f, 0.03793525f, -0.09842405f, -0.02836144f, 0.02111183f, 0.09638779f, 
    0.06688440f, 0.38509068f, 0.14267524f, -0.24721849f, 0.17776279f, 0.04537813f, 0.00578062f, 0.08227331f, 
    0.05180593f, -0.00552867f, -0.02968847f, 0.02952643f, -0.12691630f, 0.46551704f, 0.01990534f, 0.04240527f, 
    -0.10750786f, -0.02059206f, 0.04358260f, -0.02982770f, -0.04442433f, -0.01818524f, -0.06260276f, 0.10489760f, 
    -0.17875038f, -0.02896334f, 0.18165746f, 0.02789544f, -0.15312634f, 0.04819575f, -0.11852010f, 0.01271142f, 
    0.02919823f, -0.06359135f, 0.16243097f, 0.12348902f, 0.09228764f, 0.09029491f, 0.00528279f, -0.09299062f, 
    -0.03111624f, -0.21432514f, -0.01116247f, -0.00397327f, -0.10096113f, -0.08464532f, 0.03775860f, 0.06319018f, 
    -0.09539973f, 0.00408607f, 0.18525471f, -0.01035649f, -0.02064108f, 0.08180614f, 0.05189638f, -0.01610104f, 
    0.11628263f, 0.08347201f, -0.07610635f, -0.13465431f, 0.06973971f, 0.06463185f, 0.17141367f, 0.04190509f, 
    -0.17070001f, -0.01606126f, -0.05487374f, -0.00130551f, -0.06760171f, -0.10760109f, -0.04422554f, -0.23275556f, 
    -0.20568562f, -0.27416655f, -0.08457123f, -0.47866455f, 0.08479019f, -0.03764005f, -0.00659593f, -0.11828180f, 
    -0.24353592f, -0.13083708f, 0.06153478f, -0.04390280f, -0.28054219f, 0.28001380f, -0.25868207f, -0.13813217f, 
    -0.07009710f, -0.10476278f, 0.01477990f, 0.17227232f, -0.01204637f, -0.13915245f, 0.06026190f, -0.03164554f, 
    -0.95725340f, 0.32090783f, 0.22849052f, 0.29552376f, 0.06302570f, -0.10797867f, -0.12773788f, 0.16940819f, 
    -0.08229815f, 0.07446982f, 0.07027504f, 0.16323453f, 0.30386174f, 0.02156028f, -0.08293376f, 0.07483871f, 
    -0.20178008f, 0.05732240f, 0.08138492f, 0.10946702f, -0.15562153f, -0.02346668f, 0.02763661f, 0.03517674f, 
    -0.34292388f, -0.08314549f, -0.03206898f, 0.26069471f, 0.10387255f, 0.01795614f, -0.05621714f, 0.01866090f, 
    0.03074577f, -0.09793569f, 0.12868197f, -0.14775881f, 0.12003624f, 0.12671898f, 0.16665515f, 0.06569800f, 
    0.28293189f, 0.06872925f, 0.09763051f, 0.22132906f, 0.07704474f, 0.01351210f, 0.03844772f, -0.05315761f, 
    -0.62063605f, 0.10147412f, -0.10448323f, -0.05351873f, 0.08088499f, -0.16565579f, 0.11193300f, -0.04874104f, 
    0.15812042f, 0.06236122f, 0.07279339f, -0.06468106f, 0.09242969f, -0.43414500f, 0.07656205f, 0.11008023f, 
    -0.14688325f, 0.03652793f, 0.08134776f, -0.09687015f, 0.02471846f, 0.07399449f, 0.06186368f, 0.05937833f, 
    0.12572449f, 0.18956910f, 0.05842673f, 0.04179144f, -0.11784519f, -0.03731891f, -0.00341726f, 0.11650386f, 
    -0.01658208f, 0.06031803f, 0.10340651f, 0.02367196f, 0.36833477f, 0.04577479f, -0.16724637f, -0.02698601f, 
    0.04875410f, 0.11274455f, -0.10721814f, 0.02239598f, 0.05789296f, -0.24746218f, 0.00361329f, -0.13918087f, 
    -0.71262825f, -0.19120149f, -0.34089622f, -0.16690452f, 0.08875789f, 0.03494185f, 0.15967219f, -0.00725231f, 
    0.02539353f, 0.03966968f, -0.09944647f, 0.06656414f, -0.14069438f, 0.29177374f, 0.11893079f, -0.52257711f, 
    0.00527274f, -0.00322021f, -0.06290809f, -0.02747362f, 0.16899525f, -0.10846847f, 0.02414583f, 0.03283466f, 
    0.10448136f, -0.11094163f, -0.07059403f, -0.10211303f, -0.11363237f, 0.14442344f, -0.13160346f, -0.02191044f, 
    0.11260023f, -0.23953065f, 0.12562469f, 0.03232009f, 0.29249471f, 0.06315702f, 0.04873125f, 0.09479123f, 
    -0.05452384f, -0.03353344f, 0.05730442f, 0.20688713f, -0.16880600f, -0.08160312f, -0.08545882f, -0.22819531f, 
    -0.30962637f, 0.15955602f, -0.00365774f, -0.19546761f, -0.04563445f, 0.00068209f, -0.04814375f, -0.25938901f, 
    0.04427870f, -0.11921365f, 0.01570343f, -0.17738126f, 0.09443130f, 0.25424239f, -0.09512910f, 0.04104647f, 
    0.07073443f, 0.08866706f, 0.02225013f, -0.00775639f, 0.13559236f, 0.01300398f, 0.19839822f, -0.22381142f, 
    -0.03861688f, 0.03015394f, -0.14313440f, 0.26402050f, -0.03135321f, -0.11924445f, 0.24558142f, 0.05694982f, 
    0.14904802f, -0.44705206f, -0.11142273f, -0.04973498f, -0.22623117f, -0.12678872f, -0.30830291f, 0.14410448f, 
    0.13600676f, 0.16518083f, 0.22420706f, -0.02057907f, 0.18264954f, 0.16930917f, -0.06716971f, 0.04583270f, 
    -0.03402288f, 0.07549877f, 0.27087772f, -0.39306560f, -0.03917640f, -0.01205301f, 0.05944875f, -0.01503709f, 
    -0.00847530f, -0.09858018f, -0.16607895f, -0.15940680f, 0.19869240f, 0.06657664f, -0.07001356f, -0.05142044f, 
    0.03166538f, -0.37426779f, -0.25787956f, -0.27530822f, -0.15432701f, 0.12166339f, -0.12443844f, 0.04597541f, 
    -0.71061569f, -0.45949435f, -0.00238833f, -0.19119711f, 0.05731853f, 0.04185859f, -0.08190404f, -0.16737999f, 
    0.04445706f, 0.18848120f, 0.26300007f, 0.09078781f, 0.16578172f, 0.19668658f, -0.22826546f, 0.11614812f, 
    -0.00031661f, -0.01616034f, 0.02975721f, 0.04033313f, 0.18769833f, 0.04864968f, -0.04245418f, -0.10418200f, 
    -0.34769660f, -0.05696508f, -0.00118443f, -0.15558459f, 0.02479089f, 0.02490024f, 0.09313160f, -0.10846289f, 
    -0.04863506f, 0.00695645f, -0.17461590f, 0.08333980f, 0.18124489f, 0.08429953f, -0.07734726f, 0.19449352f, 
    -0.34286484f, -0.20565970f, -0.17088056f, 0.21515727f, -0.00313832f, -0.04967183f, -0.03156873f, 0.12573533f, 
    -0.59162331f, 0.09071340f, -0.13190313f, 0.13361135f, 0.10525990f, -0.08376843f, -0.23832798f, 0.05039364f, 
    0.06318599f, 0.00330639f, 0.06308187f, -0.00263925f, -0.25955695f, -0.13688630f, 0.09640419f, 0.14648643f, 
    0.09034148f, -0.05129593f, 0.05478904f, -0.04245110f, 0.01261977f, -0.04254521f, 0.03464373f, -0.08297823f, 
    0.04135616f, -0.01887937f, 0.18030772f, 0.17858928f, 0.18711618f, 0.03440176f, -0.06519019f, -0.00872530f, 
    -0.07014091f, 0.09646396f, 0.18853249f, 0.24049895f, -0.20936325f, -0.27792978f, 0.01294567f, 0.12760469f, 
    0.03426947f, -0.11483438f, 0.13200125f, -0.10711067f, 0.09655943f, 0.21186274f, 0.10472924f, 0.06500772f, 
    -0.10656057f, -0.11656308f, 0.15407254f, 0.11797414f, 0.02958702f, -0.05685275f, 0.10277034f, -0.17845201f, 
    -0.06119188f, -0.17010222f, -0.11666347f, 0.14249201f, 0.06871411f, -0.10477908f, 0.05226659f, 0.17637898f, 
    0.28335822f, 0.06541407f, -0.12389349f, -0.00752114f, 0.01585171f, -0.03694641f, 0.07088920f, 0.17231478f, 
    0.05992464f, 0.11099840f, -0.08991477f, 0.06951462f, 0.06845504f, 0.02530847f, -0.04969998f, 0.24145524f, 
    0.00744338f, 0.04665526f, -0.01736217f, -0.02616685f, 0.07961954f, -0.07540467f, 0.03807002f, 0.05251363f, 
    -0.08420024f, 0.16366400f, 0.01933227f, -0.10245372f, 0.02120930f, 0.14213535f, 0.12573896f, 0.21448562f, 
    -0.09919085f, 0.00382435f, -0.02507699f, 0.14851630f, -0.14249595f, 0.08624303f, 0.09901365f, 0.30390534f, 
    0.19775984f, 0.28485128f, 0.08300196f, 0.00696261f, -0.25290468f, 0.15558282f, 0.31086126f, 0.01605767f, 
    0.11946230f, 0.00699403f, 0.04562899f, 0.04259081f, -0.00856761f, 0.15189694f, -0.13770869f, 0.04284330f, 
    -0.40030870f, 0.10547133f, -0.52424783f, -0.12190782f, 0.07344152f, 0.03778977f, -0.04439343f, -0.02621732f, 
    -0.12073466f, -0.15434286f, -0.00282018f, -0.25072938f, 0.01810808f, -0.08125389f, 0.29352090f, -0.38112900f, 
    0.17178352f, -0.03120176f, 0.05710793f, -0.13041507f, 0.05236385f, -0.10086369f, 0.08919253f, 0.01676887f, 
    -0.11007833f, -0.17408244f, 0.10532714f, 0.16511863f, -0.24056533f, -0.08311669f, -0.05414378f, -0.01131612f, 
    -0.29353637f, 0.17397915f, -0.22069812f, 0.13602321f, -0.22768347f, -0.21805859f, -0.21884622f, 0.23063637f, 
    0.06627792f, -0.01682363f, 0.09147894f, 0.01349996f, -0.01363142f, 0.13825756f, 0.02534705f, 0.17057885f, 
    -0.47683242f, 0.02180572f, -0.19453293f, -0.26059186f, 0.14902881f, 0.09205816f, -0.01249784f, -0.04124075f, 
    -0.07730015f, -0.01035152f, 0.07764676f, 0.07178720f, 0.19575575f, 0.02871936f, 0.17217635f, -0.15844525f, 
    0.00314164f, -0.02691813f, -0.18501577f, -0.21308134f, -0.13077219f, -0.03891779f, 0.13282496f, -0.18289086f, 
    -0.30751869f, 0.04245040f, 0.34669039f, 0.08095473f, 0.09450479f, -0.09335712f, 0.01509940f, -0.13031416f, 
    -0.04704995f, -0.10723574f, -0.01755407f, -0.18559828f, 0.07233408f, 0.09268676f, -0.16717683f, 0.23309489f, 
    -0.21555290f, 0.01552439f, 0.06275115f, -0.09656736f, -0.03786806f, 0.13089842f, -0.11704654f, 0.08669210f, 
    -0.22902873f, -0.22161937f, -0.07211458f, -0.32649964f, -0.05497098f, -0.03137150f, 0.01232471f, -0.29679543f, 
    -0.03969115f, -0.03611618f, 0.15559720f, 0.03193258f, 0.63551784f, 0.14968924f, 0.08383261f, -0.23595069f, 
    -0.00005390f, 0.08203582f, 0.05580121f, 0.17167580f, -0.05306317f, 0.15591034f, -0.22457851f, -0.01485339f, 
    -0.29053465f, 0.13013160f, 0.04642942f, -0.03621753f, 0.00064583f, -0.07058306f, 0.01213796f, -0.11156570f, 
    -0.05803498f, 0.09877203f, 0.08215205f, -0.04508823f, -0.01965146f, 0.10378253f, 0.25546023f, -0.10518434f, 
    0.08714650f, 0.06771868f, 0.08560727f, -0.04454611f, 0.22152808f, 0.11242582f, -0.09210568f, 0.28221807f, 
    -0.24690573f, -0.22973765f, -0.20978852f, -0.01200640f, -0.05025613f, 0.09700331f, -0.09328759f, 0.07984596f, 
    -0.19279209f, 0.11082248f, -0.03123677f, 0.20822169f, -0.11408177f, -0.18012986f, -0.25634792f, -0.02379492f, 
    0.09419559f, -0.09528817f, 0.01409513f, 0.06092943f, -0.26899570f, 0.00268162f, -0.07344563f, 0.11369365f, 
    -0.25151086f, 0.11888436f, -0.30560723f, 0.54865849f, 0.03206827f, 0.17240769f, -0.05530193f, -0.00081109f, 
    -0.15741019f, 0.14129712f, -0.12017708f, -0.02805780f, -0.25786757f, 0.08323272f, 0.13496318f, -0.47867298f, 
    -0.13393958f, -0.15405494f, -0.12877196f, -0.19439760f, -0.11613604f, 0.01151558f, -0.06456745f, -0.16226877f, 
    0.39759639f, -0.02725093f, 0.24980085f, 0.15183632f, -0.13265194f, -0.13516673f, -0.10172135f, 0.03788513f, 
    0.07324137f, -0.22376464f, 0.17986673f, 0.36259481f, -0.59775633f, -0.19360174f, 0.01183393f, 0.00429377f, 
    -0.05728233f, 0.10201301f, 0.18059760f, 0.17448270f, 0.14468789f, -0.21200038f, -0.00439418f, -0.04138036f, 
    -0.15793757f, 0.04867730f, 0.04151906f, -0.14342810f, -0.15456674f, -0.04700861f, 0.00490514f, 0.08655154f, 
    -0.04288039f, 0.09474527f, -0.13319999f, -0.08443683f, 0.43632698f, -0.25093180f, -0.53965098f, -0.17236674f, 
    -0.03074714f, 0.00103652f, -0.01358811f, 0.29152107f, 0.06800620f, -0.00843943f, -0.00456800f, 0.11471311f, 
    0.37163582f, -0.06280175f, 0.43552920f, 0.00579792f, -0.08770672f, 0.01071764f, -0.00058111f, -0.04651546f, 
    0.01218381f, -0.04569461f, 0.08397278f, 0.03819044f, 0.02504552f, 0.01183814f, 0.05575557f, -0.08915593f, 
    0.12517700f, -0.03197780f, 0.02556252f, 0.04231589f, 0.00181551f, 0.07074858f, -0.23644498f, 0.11261024f, 
    0.07921077f, -0.29807588f, 0.15844776f, -0.07309475f, 0.20175815f, -0.06658459f, 0.02507098f, -0.02006862f, 
    -0.01369200f, 0.17629561f, 0.14650635f, -0.22476287f, -0.11413836f, -0.02723426f, -0.26753324f, 0.50478220f, 
    -0.23045725f, 0.13198680f, -0.07231725f, 0.07469927f, -0.16093415f, 0.11493888f, 0.01532308f, 0.02728254f, 
    -0.00535194f, 0.12666994f, 0.07749730f, -0.24081020f, -0.08868218f, -0.04647341f, 0.08034181f, 0.01786881f, 
    -0.08548764f, -0.03742466f, -0.11973562f, -0.21320261f, -0.21275575f, 0.00036631f, 0.02222837f, 0.16884120f, 
    0.10696981f, 0.04766252f, 0.00894905f, 0.00412087f, -0.11671485f, -0.07144376f, -0.19595057f, -0.01873531f, 
    -0.02433203f, 0.26874664f, -0.28366768f, -0.12332068f, -0.05078250f, 0.12606934f, -0.11901063f, 0.18450423f, 
    0.04029306f, 0.09421454f, 0.03697106f, 0.02061466f, 0.07701834f, -0.08044120f, -0.34892190f, 0.02830839f, 
    -0.16394939f, 0.07886097f, 0.07664168f, -0.18454212f, 0.09339928f, 0.01984227f, -0.15343980f, -0.14315400f, 
    0.04265680f, 0.05051162f, 0.16425276f, -0.14516605f, 0.10508250f, -0.03429692f, -0.02928071f, -0.14072601f, 
    -0.04608335f, 0.10506848f, 0.12826337f, -0.10381100f, 0.08072064f, 0.19919895f, 0.19229513f, -0.21224993f, 
    0.11983030f, -0.09545752f, 0.05664388f, 0.10408297f, 0.14293605f, -0.13108309f, -0.02047807f, -0.22755115f, 
    -0.17706998f, 0.00338184f, -0.09621859f, 0.00988863f, 0.13101287f, -0.11173796f, -0.19639935f, -0.03304983f, 
    -0.06419320f, -0.02559523f, 0.09398540f, -0.01287163f, 0.38782859f, -0.40219790f, -0.14455996f, 0.00889182f, 
    -0.05831371f, -0.00001593f, 0.06959470f, 0.06303668f, 0.02610991f, -0.03099604f, -0.01350597f, -0.24683547f, 
    0.32018980f, -0.19412181f, 0.05030468f, -0.20502377f, -0.14115326f, 0.20978238f, -0.07523573f, -0.28925109f, 
    0.06159659f, -0.14542766f, 0.26532185f, 0.19068508f, -0.11909416f, 0.33792359f, 0.09848315f, -0.39792302f, 
    -0.25534821f, 0.05484388f, 0.16361023f, 0.14345039f, 0.08122895f, 0.15498325f, -0.10156595f, 0.09582287f, 
    0.06263444f, 0.11276987f, -0.23463978f, 0.06848910f, 0.00826458f, 0.16909841f, 0.10568050f, 0.03807231f, 
    0.00785628f, -0.14092499f, 0.05041653f, 0.03923407f, -0.32318082f, 0.11775069f, -0.34979075f, -0.21409106f, 
    -0.02557633f, -0.01191276f, -0.09903723f, -0.33786124f, -0.09357680f, -0.08652563f, -0.04806552f, -0.08559167f, 
    -0.19502388f, -0.19447313f, -0.15706891f, -0.13612275f, -0.04066091f, -0.01896667f, -0.04285272f, 0.02333389f, 
    0.14929084f, -0.00280593f, -0.00104875f, 0.09095012f, -0.51294786f, 0.06440548f, -0.06970973f, 0.20600963f, 
    0.07905046f, 0.11852646f, 0.27736285f, 0.11211917f, 0.15803431f, -0.15487653f, -0.02191834f, 0.09440719f, 
    0.08214406f, -0.28837365f, -0.13137960f, -0.24242929f, 0.08148962f, -0.00583831f, 0.00686799f, -0.08782412f, 
    -0.10004816f, -0.11080967f, 0.03006993f, -0.01134624f, 0.11231785f, 0.16638988f, -0.03143115f, 0.28701341f, 
    0.17729607f, 0.00200532f, 0.08202542f, 0.04370346f, -0.02347171f, -0.04366252f, -0.00135824f, -0.09867368f, 
    0.07736679f, 0.18030903f, 0.18176013f, 0.09175146f, 0.10710357f, 0.10705535f, 0.09443542f, -0.07736254f, 
    0.01781662f, -0.01917472f, 0.01911231f, 0.00783049f, 0.42248645f, 0.04819655f, 0.00757443f, -0.39039195f, 
    -0.12702601f, -0.02843153f, 0.00693385f, -0.05588599f, -0.09556065f, -0.04320035f, 0.00702518f, -0.17640410f, 
    0.00322104f, 0.15890829f, 0.09920523f, 0.28897408f, 0.01675925f, -0.08502488f, -0.07458425f, 0.00527923f, 
    -0.02811714f, 0.16285309f, -0.09779537f, -0.02284212f, -0.14534165f, 0.03946292f, -0.32261667f, -0.37339011f, 
    -0.00096281f, 0.03247974f, -0.03296274f, -0.08896784f, -0.17218632f, -0.14271964f, -0.06379403f, -0.11953735f, 
    -0.38587591f, 0.12004597f, 0.06642212f, 0.03724765f, 0.09915493f, -0.07433202f, -0.09911963f, -0.01617737f, 
    0.00673934f, 0.03119529f, 0.11958542f, 0.09963851f, 0.14807934f, 0.13126169f, 0.14844513f, 0.28589228f, 
    0.08277574f, 0.04145327f, -0.07585544f, 0.00971652f, -0.05663671f, -0.10584952f, -0.00003092f, -0.04323781f, 
    -0.41955176f, 0.02840229f, -0.11401232f, -0.01255502f, -0.10799473f, -0.12016381f, -0.02038357f, 0.01922303f, 
    -0.13920499f, 0.09607217f, -0.03810466f, -0.09985662f, 0.02272017f, 0.26398122f, 0.17944641f, 0.29082680f, 
    0.08259968f, 0.23392980f, 0.00892922f, -0.07016683f, -0.11823476f, -0.07141776f, -0.07889429f, 0.02084976f, 
    -0.02135733f, -0.19289516f, -0.11251928f, -0.07502982f, -0.09431339f, -0.00750927f, -0.03756421f, -0.08522870f, 
    -0.05695797f, -0.07606189f, -0.07050920f, -0.05083054f, -0.10757278f, 0.09885586f, -0.07240973f, -0.03014431f, 
    -0.14985934f, 0.02399782f, -0.03753353f, -0.02734530f, -0.03653344f, -0.08877368f, -0.08768804f, -0.05550013f, 
    -0.29122603f, 0.12229730f, 0.00839545f, 0.06224790f, -0.01778701f, 0.03652421f, -0.07757936f, -0.12695764f, 
    -0.04421296f, -0.09681854f, -0.09475294f, -0.13569428f, 0.12370431f, 0.10086291f, 0.14498730f, 0.10904837f, 
    0.03237273f, 0.05076620f, 0.00189897f, -0.00780175f, -0.03847376f, 0.14105833f, -0.00602283f, -0.07903317f, 
    0.13956611f, 0.12963615f, 0.10527034f, 0.32089135f, 0.08645307f, -0.01987281f, -0.00385361f, 0.01456981f, 
    -0.13009375f, -0.03281368f, 0.07711700f, -0.09859174f, 0.17415781f, -0.29585454f, 0.04311984f, 0.17646825f, 
    0.06025297f, -0.10133079f, 0.00869469f, -0.07608117f, -0.14516117f, -0.04580230f, -0.06158394f, -0.11271832f, 
    0.25299665f, -0.04595510f, 0.16086544f, 0.03291579f, 0.07224138f, 0.06905499f, -0.01317108f, -0.03337385f, 
    0.00281916f, -0.08377078f, -0.09712396f, -0.05733287f, -0.03799352f, 0.21905877f, -0.09797458f, 0.26198700f, 
    0.12324899f, -0.11063822f, 0.00333205f, 0.02181833f, -0.02704185f, 0.00169452f, 0.00140321f, -0.06809974f, 
    -0.19367644f, -0.05817802f, 0.05055868f, -0.01598755f, -0.07621339f, -0.02692275f, 0.08338209f, -0.03599430f, 
    -0.13600303f, -0.06868187f, -0.04216868f, -0.08410955f, 0.13016109f, -0.34996611f, 0.22248621f, 0.31737182f, 
    0.02830709f, -0.05598606f, -0.11399367f, -0.01260419f, -0.07249309f, 0.00052668f, -0.02024258f, -0.12383766f, 
    -0.65324521f, 0.10410710f, -0.09649934f, 0.12529972f, -0.13512488f, -0.05091343f, -0.02644733f, 0.00897981f, 
    -0.09478102f, 0.01707416f, 0.00916473f, 0.00843363f, 0.03935023f, 0.20940699f, 0.05032570f, 0.30100539f, 
    -0.02544035f, -0.04790631f, -0.10300048f, -0.01015794f, 0.08093344f, -0.02719438f, -0.01618436f, -0.01351449f, 
    0.30904835f, 0.20271906f, -0.19845505f, -0.24858302f, 0.02887826f, 0.06150169f, -0.01428880f, -0.00625691f, 
    -0.07565422f, -0.03079285f, -0.04224448f, -0.08160368f, -0.01053188f, -0.56343436f, -0.17151622f, -0.07009763f, 
    -0.15334660f, -0.08867435f, 0.04458006f, -0.02907734f, 0.02540524f, -0.04771465f, 0.00248682f, -0.03789519f, 
    -0.49524444f, 0.15585697f, -0.23673481f, 0.17160104f, -0.18427835f, -0.00021193f, -0.00851058f, -0.04542335f, 
    0.05285715f, -0.01144022f, 0.07868408f, -0.05367352f, -0.10517943f, -0.09674332f, -0.07818054f, -0.21371529f, 
    0.02608732f, -0.02057852f, -0.02276667f, -0.09287180f, -0.04565248f, -0.01736584f, -0.10438403f, -0.01820797f, 
    0.07392725f, 0.26918897f, 0.17289004f, 0.08335640f, 0.00151333f, 0.16865154f, 0.01438332f, 0.09283920f, 
    -0.04823969f, 0.04331472f, -0.08981989f, -0.00164625f, -0.65392494f, 0.31381130f, -0.15567558f, -0.18587221f, 
    0.07799434f, -0.01123073f, -0.07557158f, -0.11072954f, -0.14515449f, -0.01401337f, -0.09629715f, -0.17380145f, 
    -0.25336313f, 0.02169268f, -0.14545806f, 0.14071181f, -0.09144008f, -0.17637035f, -0.10626725f, -0.02983854f, 
    0.02986902f, -0.12099810f, -0.09315544f, -0.00556267f, 0.14405018f, 0.20806384f, 0.16075462f, 0.21862349f, 
    0.06013791f, 0.06002694f, -0.04855494f, -0.11092023f, -0.07627100f, 0.00003404f, -0.07280235f, -0.08747049f, 
    -0.03116805f, -0.09285121f, 0.27990445f, -0.04988630f, 0.07536697f, 0.11510880f, -0.07352991f, -0.05428464f, 
    -0.03154864f, 0.01754116f, -0.12996720f, -0.02886519f, 0.08197195f, 0.06943607f, -0.10900957f, 0.06311879f, 
    -0.00099329f, 0.03350754f, -0.00463198f, -0.06734969f, -0.08864862f, -0.04687360f, 0.06391735f, -0.10733519f, 
    0.24415936f, -0.43143383f, -0.16986564f, -0.01507237f, 0.20609778f, 0.00664982f, -0.02487510f, -0.04543682f, 
    0.06466991f, 0.10443971f, -0.04606727f, -0.00168815f, -0.08468229f, 0.07260840f, -0.10304298f, -0.17155036f, 
    0.01591659f, -0.08474266f, -0.20740518f, -0.09328305f, 0.05612119f, -0.16348872f, 0.14912497f, -0.02394442f, 
    -0.07599687f, -0.00118750f, 0.22762388f, 0.02566415f, 0.00853507f, 0.09421047f, -0.00966511f, 0.05223250f, 
    -0.05417783f, -0.00890553f, 0.05210688f, 0.03226292f, -0.21501987f, 0.05793247f, -0.02241693f, -0.02845206f, 
    0.13734058f, -0.12773645f, -0.01036918f, -0.13400787f, -0.03002245f, -0.06291152f, 0.09332953f, 0.16047566f, 
    -0.18229398f, 0.19548242f, 0.04355013f, 0.20107162f, -0.15115935f, 0.02853066f, -0.12872419f, 0.03399945f, 
    0.17138514f, 0.02653857f, 0.03786009f, 0.06092111f, 0.07580559f, 0.03461859f, -0.01500548f, 0.04908134f, 
    0.05645221f, -0.16101114f, -0.10470112f, -0.03326731f, -0.04659722f, 0.12006357f, -0.03825228f, -0.10214660f, 
    0.15574591f, 0.14920039f, -0.04489959f, 0.24047421f, -0.10407989f, -0.19437368f, -0.13424091f, 0.02579585f, 
    -0.03939592f, -0.11490203f, -0.09715414f, -0.17429557f, -0.32295486f, -0.17163426f, -0.25353080f, -0.33717126f, 
    -0.09816880f, -0.09272765f, 0.21909030f, 0.06728902f, 0.05128355f, -0.04613430f, 0.01330127f, -0.12510122f, 
    0.38858747f, 0.26372248f, 0.00507985f, -0.07998835f, 0.00556164f, 0.04452775f, 0.08382747f, -0.16424645f, 
    0.07426035f, 0.10941037f, 0.09627720f, 0.11225674f, -0.34113353f, 0.05397723f, 0.27495161f, -0.05323079f, 
    0.03643784f, 0.02274296f, 0.05927291f, 0.13471541f, -0.00194815f, -0.11806657f, -0.04410081f, -0.06358986f, 
    0.22514115f, -0.06709468f, -0.13661991f, 0.14607137f, 0.14106919f, -0.06403293f, -0.10460774f, -0.14346777f, 
    -0.03730684f, 0.02643085f, 0.02474431f, 0.03445102f, 0.20529886f, 0.27571210f, -0.01597912f, 0.06483670f, 
    -0.18860646f, -0.00258908f, -0.09736423f, -0.00543013f, 0.01866301f, 0.12672473f, -0.14432269f, -0.02393120f, 
    -0.11413696f, -0.20694916f, 0.34654638f, -0.07389782f, -0.20454805f, -0.16680065f, -0.04106744f, 0.04438714f, 
    -0.09975062f, 0.07700818f, 0.15953566f, 0.00349836f, -0.27354360f, 0.02432829f, -0.02292806f, -0.27362168f, 
    -0.20430699f, -0.21907002f, 0.07818232f, -0.32942927f, 0.05698247f, -0.00054634f, -0.08558629f, -0.14018737f, 
    -0.11969538f, -0.31896216f, 0.09506462f, -0.34697360f, -0.08446562f, -0.28130472f, -0.04097420f, -0.08182672f, 
    0.12514593f, -0.03218723f, -0.23338363f, 0.06224643f, 0.00153847f, -0.10785163f, -0.37635291f, -0.21283661f, 
    0.12567373f, -0.14172460f, 0.01671050f, 0.05226219f, 0.05000538f, 0.10300910f, 0.21691747f, 0.04188539f, 
    0.02694362f, -0.38561448f, 0.19611490f, -0.05727876f, -0.02885096f, -0.07162223f, -0.06638292f, -0.05478254f, 
    -0.09032551f, -0.00769434f, -0.00900174f, 0.11407641f, 0.02282464f, 0.30599967f, -0.21796319f, -0.10444082f, 
    0.07139300f, -0.24662507f, -0.04426050f, 0.01755197f, 0.10522489f, -0.16264874f, -0.16151303f, 0.10398310f, 
    0.09689584f, 0.07486241f, 0.10063084f, 0.24494116f, 0.01994511f, -0.04039048f, -0.18140481f, -0.11807154f, 
    0.03286491f, 0.04481871f, 0.19658774f, -0.03101461f, 0.02014575f, 0.11428542f, -0.02330283f, 0.05175132f, 
    0.01387448f, -0.02616547f, -0.00497204f, -0.02187358f, -0.02535902f, -0.04790822f, -0.06589153f, 0.01489974f, 
    -0.32856092f, -0.06545849f, -0.05217064f, 0.28659236f, 0.20452733f, 0.04509729f, -0.06523449f, -0.04440819f, 
    -0.00049952f, -0.01420375f, -0.00794553f, -0.06789755f, -0.36741337f, -0.10280047f, -0.18009660f, -0.42500314f, 
    -0.14524361f, 0.13987964f, -0.20795374f, 0.10660072f, 0.04416950f, -0.06840762f, 0.03677061f, -0.04408220f, 
    0.06197690f, -0.11969646f, 0.07766615f, 0.07668689f, 0.09063789f, -0.01682499f, -0.08254432f, 0.02577376f, 
    0.14817090f, -0.06918166f, -0.07117339f, -0.07951088f, 0.15255521f, -0.10187761f, -0.00990502f, 0.22843450f, 
    0.17498429f, 0.01605251f, -0.09117886f, -0.07417829f, -0.01228575f, 0.04696871f, 0.03063328f, 0.16366439f, 
    -0.13214014f, 0.25429353f, -0.06737818f, -0.00550828f, 0.02836484f, 0.12996691f, -0.08545795f, 0.08357929f, 
    0.04217522f, 0.13131975f, -0.06922422f, 0.12439173f, 0.05990698f, -0.12058774f, 0.01665535f, 0.23567866f, 
    -0.04610943f, -0.06288289f, -0.07864577f, 0.03544443f, 0.06229698f, -0.06621698f, -0.00163934f, -0.06613623f, 
    0.10982616f, 0.21611866f, 0.07842876f, -0.02152107f, 0.01698974f, 0.02533568f, -0.05303739f, 0.06333082f, 
    0.04444532f, -0.06107454f, -0.07709578f, -0.16885090f, 0.18562748f, -0.23303595f, 0.16443805f, 0.28426462f, 
    0.14412780f, 0.01472708f, -0.11972322f, -0.11854610f, 0.12290200f, -0.14279452f, 0.14803985f, -0.12588993f, 
    -0.14986129f, 0.19293723f, -0.28498259f, -0.26384029f, -0.05072736f, -0.01178399f, -0.24706328f, 0.15862067f, 
    0.08315479f, 0.09640444f, 0.07090661f, 0.07343489f, -0.20016727f, 0.14674419f, 0.22349529f, -0.29516378f, 
    -0.00551945f, -0.13440375f, -0.03387735f, -0.08955576f, -0.00566850f, -0.06159744f, 0.02178498f, 0.10662166f, 
    -0.50395465f, 0.01473304f, 0.11186286f, -0.09240110f, -0.14640206f, -0.06767303f, -0.01031770f, -0.16504841f, 
    -0.04996925f, -0.01313800f, -0.01687422f, 0.04691036f, -0.34575102f, 0.24228355f, -0.17303671f, -0.39946136f, 
    -0.05737102f, 0.10257218f, -0.25639710f, 0.06467097f, 0.08054093f, 0.12901244f, -0.17557681f, -0.21941122f, 
    0.10122117f, 0.02166835f, 0.19665985f, -0.00481262f, 0.01445570f, 0.09639539f, 0.01348492f, -0.10172968f, 
    -0.04904283f, -0.03689731f, -0.03892795f, 0.04827689f, -0.06126658f, -0.41684431f, 0.19752775f, -0.22578800f, 
    -0.03042795f, 0.11023899f, 0.01962720f, 0.20762599f, 0.08878906f, 0.09626681f, 0.04131589f, 0.05792818f, 
    0.06161400f, -0.13148795f, 0.07088611f, 0.10013144f, -0.00421882f, -0.12675826f, -0.04709049f, 0.08130714f, 
    -0.07730980f, 0.19510205f, -0.12209972f, -0.06272843f, -0.33288747f, -0.00817064f, -0.06819134f, 0.03917781f, 
    0.05694802f, -0.16624632f, -0.06586192f, -0.10473568f, 0.09865480f, 0.06031877f, 0.22804484f, -0.01249415f, 
    -0.01438119f, -0.04505779f, 0.00198904f, 0.26878726f, -0.08079342f, 0.15283321f, -0.07222714f, 0.07091527f, 
    -0.15443209f, 0.10847378f, -0.01634678f, 0.09286787f, -0.02953992f, 0.15390827f, -0.08369333f, -0.05143576f, 
    -0.09069788f, -0.00420075f, 0.07161217f, 0.06359680f, 0.06806152f, 0.03964758f, 0.06423523f, 0.07372899f, 
    0.26590019f, -0.32074216f, 0.16646671f, -0.03984202f, 0.06527463f, 0.08942898f, 0.09065726f, 0.08958524f, 
    -0.07749888f, 0.02612376f, 0.01877073f, 0.08365254f, 0.12859683f, -0.02863599f, -0.21049044f, -0.03963879f, 
    0.08420368f, 0.10126428f, 0.09631123f, -0.02944176f, -0.15539908f, -0.10721155f, 0.06891124f, 0.01733803f, 
    0.53380388f, 0.18354909f, 0.18895224f, -0.13452041f, -0.13352656f, -0.04425187f, -0.01575565f, -0.16577290f, 
    -0.01972347f, -0.02890353f, 0.02198778f, 0.09192827f, -0.07769848f, -0.20013846f, 0.00733205f, -0.01468661f, 
    0.05192365f, -0.14538249f, -0.17575864f, -0.03389581f, -0.09135481f, -0.25744176f, 0.06333575f, 0.12615657f, 
    -0.30082124f, -0.04983082f, 0.03173597f, -0.01449645f, 0.15022397f, 0.08511618f, 0.01168444f, -0.21186438f, 
    0.02173995f, 0.15188526f, 0.02775388f, 0.01428984f, 0.01249328f, 0.19958629f, -0.03851757f, -0.04835494f, 
    0.12580223f, 0.18132529f, 0.04837441f, 0.16565402f, 0.01603260f, -0.04852832f, 0.10528663f, 0.03989040f, 
    0.04450554f, -0.35268676f, -0.14907350f, 0.01554557f, -0.02679344f, 0.01360196f, 0.05407486f, 0.07075737f, 
    0.07627507f, -0.01477010f, -0.16681769f, 0.02253949f, 0.04785793f, 0.08198161f, -0.32059529f, 0.31949377f, 
    0.21761535f, -0.01093775f, -0.02817040f, 0.14993577f, -0.16725615f, -0.02240245f, 0.02936173f, 0.05301072f, 
    0.15601143f, 0.12495577f, -0.15705720f, 0.31892759f, 0.19989121f, -0.17019770f, 0.01993131f, 0.09189568f, 
    -0.10658038f, -0.03704130f, 0.19504407f, 0.00111939f, 0.09320647f, -0.21012664f, 0.16712186f, -0.29797864f, 
    -0.01918381f, -0.04622051f, -0.16837396f, -0.00405987f, -0.00791528f, 0.02721764f, 0.08300442f, -0.08910567f, 
    0.30843726f, 0.04987920f, -0.27120984f, 0.20934615f, -0.03528227f, -0.16166455f, 0.05508222f, -0.09828148f, 
    0.08818178f, 0.01518279f, -0.04393204f, -0.01519624f, -0.48640934f, -0.35542387f, 0.31628501f, -0.26445910f, 
    -0.16136511f, -0.07371576f, 0.01405809f, 0.04916577f, 0.06091484f, -0.15725829f, 0.12993771f, 0.08687710f, 
    -0.03734828f, 0.18779732f, -0.32399240f, -0.10600383f, -0.04822602f, -0.03568210f, 0.14123087f, 0.16014206f, 
    -0.11895942f, -0.00120628f, -0.06499059f, -0.10073003f, 0.58500123f, -0.85566938f, -0.02732117f, -0.05524187f, 
    -0.08075570f, 0.00731088f, -0.01564043f, 0.02785329f, -0.10485125f, 0.02756996f, 0.18284832f, -0.03556572f, 
    -0.47229856f, 0.23459323f, 0.04145715f, -0.39897805f, -0.06476934f, -0.02249126f, -0.17376691f, 0.01888477f, 
    0.01408227f, 0.03560673f, -0.05367775f, -0.17701188f, -0.13430452f, 0.03102187f, -0.26404381f, -0.01647616f, 
    -0.01914507f, -0.14786710f, 0.30415165f, -0.03558872f, -0.04286048f, 0.05212425f, -0.03458804f, -0.00448569f, 
    0.12312070f, -0.00719000f, 0.05593865f, -0.29996848f, 0.04694369f, 0.08505826f, 0.00534512f, -0.33503816f, 
    -0.11463644f, -0.14108005f, -0.04511288f, -0.06307982f, 0.02367561f, -0.02619070f, -0.28436258f, -0.18703754f, 
    0.13870224f, -0.00354196f, 0.00564993f, 0.02408439f, -0.05541829f, -0.08945602f, -0.26018927f, -0.07123721f, 
    -0.29290861f, 0.67465967f, 0.04477797f, 0.26188120f, 0.17124145f, 0.18823102f, -0.02226070f, -0.10994830f, 
    0.00820536f, -0.08203936f, 0.02179600f, 0.10737029f, 0.10557872f, 0.29531765f, -0.22295797f, -0.31824091f, 
    0.10106312f, 0.14222492f, -0.01639307f, -0.10669845f, -0.09478520f, -0.04257120f, -0.11108799f, 0.03997760f, 
    -0.61330473f, -0.43574536f, 0.00237162f, -0.14433073f, 0.02839341f, 0.02627508f, 0.08452681f, -0.03711294f, 
    0.22315569f, 0.13965800f, 0.01392922f, 0.05281600f, -0.68008703f, 0.50962979f, -0.15795217f, -0.22865582f, 
    0.19674216f, -0.10133187f, -0.13684873f, -0.04425602f, -0.03258451f, -0.03895838f, -0.02558918f, -0.05174832f, 
    0.02609835f, -0.03885343f, 0.09587932f, -0.37937126f, 0.01691366f, -0.04069606f, 0.03383794f, 0.01678107f, 
    0.06737509f, -0.01472103f, 0.02563694f, -0.10973793f, -0.19641657f, -0.57572877f, 0.14813542f, 0.01548218f, 
    0.06881030f, 0.12353747f, -0.02067039f, -0.10352971f, -0.15255372f, -0.06515171f, -0.14901988f, -0.15899207f, 
    0.28447431f, -0.06222295f, -0.29266596f, 0.54193795f, 0.07872112f, -0.01746596f, -0.10056869f, 0.01933076f, 
    -0.04761683f, 0.08260642f, -0.19855496f, -0.16219923f, 0.02078130f, 0.39291158f, -0.04010016f, 0.24332196f, 
    0.00941305f, 0.04171268f, -0.05623582f, 0.19052361f, -0.04457991f, 0.04626984f, 0.02038475f, 0.00637028f, 
    -0.85982382f, 0.01418290f, 0.38257891f, -0.03104082f, 0.20484604f, -0.03175219f, -0.13720793f, -0.03430117f, 
    0.02510041f, 0.11729566f, -0.03118442f, 0.13730177f, -0.27115837f, -0.02386843f, -0.09985129f, 0.08089881f, 
    -0.06536578f, 0.01310440f, -0.06106552f, -0.20745388f, -0.09667921f, -0.19328690f, -0.02014918f, -0.11510780f, 
    0.29701445f, 0.02885749f, 0.09872518f, -0.15600732f, -0.08967840f, -0.05387672f, -0.00078354f, -0.16370250f, 
    -0.06911380f, -0.01907407f, 0.03970912f, 0.04641120f, -0.21459416f, -0.17838898f, -0.28123438f, 0.01203416f, 
    0.01238260f, -0.11123011f, -0.08234908f, 0.12129474f, -0.26825488f, -0.07920945f, -0.01289492f, 0.09550097f, 
    -0.12121938f, 0.00649848f, 0.16925126f, 0.08172486f, -0.05607511f, 0.10981662f, 0.12556273f, -0.04904790f, 
    0.10821441f, -0.10504614f, 0.02988869f, -0.01306964f, -0.61651850f, -0.36553001f, 0.03802108f, 0.03223117f, 
    0.08952481f, -0.01933272f, -0.01779712f, -0.10597634f, -0.01782503f, -0.05443941f, -0.05315818f, 0.03729207f, 
    0.31369469f, 0.11694738f, -0.23192637f, 0.06611542f, -0.15479995f, -0.07974315f, -0.08235806f, -0.03740386f, 
    0.01899227f, 0.04878089f, -0.04811121f, -0.08754758f, 0.01714478f, 0.04018047f, 0.08578096f, 0.13367231f, 
    0.08990738f, 0.08152811f, 0.06337181f, -0.15095304f, 0.05608786f, -0.06320368f, 0.02102345f, -0.12736562f, 
    -0.46979952f, -0.31084618f, 0.22402905f, 0.25066158f, 0.14759430f, 0.05014356f, 0.02331476f, -0.02389208f, 
    0.15262389f, 0.17297748f, 0.03867141f, 0.09514301f, 0.04004228f, -0.13175862f, 0.09362471f, 0.00834778f, 
    -0.03791640f, -0.01719263f, -0.00527951f, -0.18310057f, 0.13220790f, 0.27719015f, 0.16321474f, 0.04584749f, 
    0.26032531f, -0.19358276f, -0.26720238f, 0.00592495f, -0.06052116f, 0.14251700f, -0.13889766f, -0.05610677f, 
    0.05111785f, -0.07298491f, -0.25542819f, -0.03391368f, -0.39029688f, -0.27093732f, -0.00207634f, 0.05193862f, 
    -0.02976525f, 0.04680376f, 0.08190015f, 0.04203283f, 0.05881128f, 0.00656141f, 0.02558841f, -0.02680746f, 
    0.11935531f, 0.11295645f, -0.05883672f, 0.02706043f, -0.01025604f, -0.29938564f, -0.00224745f, 0.00581669f, 
    -0.15352640f, -0.02797582f, 0.07924147f, 0.04941732f, 0.20882666f, 0.12715408f, 0.15485272f, -0.09816422f, 
    -0.16780436f, -0.01326452f, -0.01303378f, -0.19895111f, 0.00283920f, -0.28592971f, -0.04735935f, -0.28900185f, 
    0.12172484f, -0.00858793f, 0.16866232f, 0.03902720f, -0.02100743f, -0.14496484f, 0.06209165f, -0.04785265f, 
    0.08048683f, 0.09384010f, -0.16164200f, 0.06544619f, -0.02483012f, 0.37066126f, 0.11184126f, -0.12634681f, 
    0.09997729f, 0.09402969f, 0.03951303f, 0.17808074f, -0.14504690f, 0.02656757f, 0.10397039f, 0.16933528f, 
    0.01815129f, 0.04417415f, -0.16349842f, 0.19535303f, 0.11885630f, 0.06154979f, -0.03545249f, 0.02238773f, 
    0.05898738f, 0.06934207f, 0.00069478f, 0.00121819f, -0.53833836f, -0.07506482f, -0.19574460f, 0.09948010f, 
    0.03712584f, 0.02827296f, 0.05271559f, -0.06514519f, -0.01598283f, 0.09922413f, 0.04921613f, 0.03901081f, 
    -1.06235683f, -0.44169733f, -0.12194272f, -0.25362113f, 0.08988495f, -0.00395728f, -0.14123172f, -0.09122440f, 
    -0.04498136f, 0.01550763f, 0.00446372f, -0.12835298f, -0.07682326f, 0.29425409f, -0.44029254f, 0.05977632f, 
    -0.05851679f, 0.11127816f, 0.00900355f, -0.03724921f, 0.16053091f, 0.16189688f, 0.06302858f, 0.18998709f, 
    -0.23371917f, -0.13051596f, 0.00081335f, -0.33407247f, 0.11684342f, -0.05426916f, 0.07246093f, -0.08713771f, 
    0.05724217f, -0.06112205f, -0.10653345f, -0.04292884f, 0.05096960f, 0.13695469f, 0.02991598f, -0.23053363f, 
    0.07475258f, 0.11587793f, 0.16612780f, 0.12261291f, -0.02633807f, 0.10102828f, 0.05700242f, 0.10524587f, 
    -0.59863257f, -0.02263575f, -0.12885714f, 0.09153784f, 0.22657394f, 0.03188126f, 0.03951954f, 0.03165123f, 
    0.04740903f, 0.10596383f, 0.04737577f, 0.25019574f, -0.59047771f, 0.09532302f, -0.16036989f, -0.29253146f, 
    -0.06542434f, 0.11000910f, 0.03414100f, 0.01287510f, 0.04099005f, 0.26230347f, 0.07727572f, 0.22641635f, 
    0.06633342f, -0.11914767f, 0.08482536f, 0.05773073f, 0.01268742f, 0.05511644f, 0.29707885f, 0.14274019f, 
    0.19775634f, 0.12970769f, -0.05832519f, 0.10945825f, -0.23929663f, 0.17226197f, -0.28753939f, -0.13237876f, 
    0.23734179f, -0.05072812f, -0.09039260f, -0.03842799f, 0.03421947f, 0.00556078f, 0.16195732f, 0.10960959f, 
    0.37886617f, 0.02985375f, -0.15675521f, -0.12436482f, -0.10324615f, -0.10077117f, -0.00636116f, -0.11929781f, 
    0.20749763f, -0.03904961f, -0.19312505f, -0.06643704f, -1.02022481f, -0.43839797f, -0.34603640f, -0.35819912f, 
    0.02894494f, -0.14212115f, -0.24888036f, 0.04355073f, -0.04232286f, -0.14588000f, 0.04992417f, 0.04480126f, 
    0.28550553f, 0.20590355f, 0.09839725f, -0.03953277f, 0.21266103f, 0.04133357f, 0.10280240f, 0.19326980f, 
    0.08571297f, 0.11180592f, 0.01822878f, 0.14871787f, 0.19495817f, -0.02066694f, -0.04707205f, -0.19867246f, 
    0.03470827f, 0.13775137f, -0.07625502f, -0.14607556f, 0.09800293f, 0.04111275f, 0.07751126f, 0.08401313f, 
    0.38877138f, 0.08171126f, 0.12437215f, 0.00519271f, -0.10460447f, -0.23507488f, 0.00921788f, 0.02138207f, 
    -0.07287660f, 0.01865274f, 0.07485794f, 0.05838627f, -0.04419206f, -0.13869973f, 0.11095534f, 0.09837691f, 
    -0.09843358f, 0.04091171f, -0.05764111f, 0.01612567f, 0.01096273f, -0.00153250f, -0.13075832f, -0.20671074f, 
    0.50489235f, 0.13005801f, -0.05373017f, -0.21433586f, -0.01036071f, 0.06810917f, -0.06873094f, 0.10602245f, 
    0.07820287f, -0.06632008f, 0.00235047f, 0.04922879f, 0.09549651f, -0.04924893f, -0.03473745f, 0.06081364f, 
    -0.07407472f, 0.10047901f, -0.03527137f, -0.19459708f, -0.13042179f, 0.19795087f, -0.17638403f, -0.20059107f, 
    -0.50336713f, 0.26962551f, 0.09857579f, 0.02729657f, -0.10285417f, 0.09146766f, -0.10474427f, 0.00324298f, 
    -0.04069139f, 0.14783867f, 0.02294852f, -0.11718661f, -0.42218065f, 0.21768686f, -0.05502598f, -0.03920873f, 
    0.31042662f, -0.03686297f, 0.10921672f, -0.13001777f, -0.14856453f, -0.11291200f, -0.07462344f, 0.03960013f, 
    -0.01454471f, 0.26627496f, -0.21030660f, -0.05502808f, 0.11994593f, -0.28388771f, 0.08460028f, -0.17975147f, 
    -0.01744309f, 0.10929167f, -0.13605839f, -0.06501384f, 0.20101254f, 0.10937007f, -0.05972282f, -0.20792280f, 
    0.07211874f, -0.09307636f, -0.09334319f, 0.08425123f, 0.04271194f, 0.06188998f, 0.15542012f, 0.03383584f, 
    -0.11739643f, -0.33618838f, 0.01713637f, 0.08960959f, -0.03089631f, 0.02187254f, -0.00042417f, 0.14814958f, 
    -0.15329258f, -0.04105383f, -0.01500803f, -0.04837991f, -0.19970775f, -0.10481772f, -0.09780099f, 0.12875828f, 
    -0.26628235f, 0.07071588f, 0.05580930f, -0.17788866f, -0.02076245f, -0.10568531f, -0.12385854f, -0.08372135f, 
    0.36440590f, -0.30588469f, -0.11602988f, -0.08643988f, 0.13466552f, -0.21080577f, -0.25398263f, 0.01953818f, 
    -0.06541849f, 0.07095595f, 0.03703845f, 0.06908060f, 0.18166895f, 0.17284282f, -0.07842995f, -0.10047814f, 
    -0.13290024f, -0.24864821f, -0.12063504f, -0.03206008f, -0.12582482f, -0.01924205f, 0.11284381f, -0.01202022f, 
    -0.06331407f, -0.07122628f, -0.40033978f, -0.13213161f, -0.05357799f, -0.02427827f, 0.13909785f, 0.10612552f, 
    -0.00728218f, 0.00424689f, 0.08397871f, 0.00363224f, -0.34296638f, -0.28076181f, 0.01525842f, -0.13248414f, 
    0.06796732f, 0.07301854f, -0.05984010f, 0.16461334f, -0.15972762f, -0.02597293f, -0.06485699f, 0.10637459f, 
    0.52593940f, -0.01130850f, -0.11726129f, -0.12582305f, -0.05462050f, 0.06821284f, 0.08742085f, -0.09530449f, 
    0.02986622f, -0.13688649f, 0.00427278f, -0.05791228f, -0.21632434f, -0.13005957f, -0.27262411f, 0.14270101f, 
    -0.02238938f, 0.01122036f, 0.12672567f, 0.02536857f, -0.21225050f, 0.03503021f, 0.14075153f, 0.05985934f, 
    -0.01491833f, -0.10783279f, 0.09559527f, -0.51452237f, -0.08663968f, 0.05803183f, -0.11962811f, -0.01906327f, 
    -0.13559930f, -0.18563092f, 0.06956023f, -0.05584113f, 0.63861150f, -0.06154671f, -0.17052206f, 0.21513295f, 
    -0.08266987f, 0.08669586f, 0.07456636f, -0.04577151f, 0.10896823f, -0.03999501f, -0.09102990f, -0.00711741f, 
    -0.24555996f, 0.15273082f, 0.06549629f, 0.05304025f, 0.04182223f, 0.07038268f, -0.04977371f, -0.01681228f, 
    0.04435623f, 0.05516751f, 0.17500873f, 0.15066925f, -0.03461972f, -0.38378829f, -0.07467415f, 0.11258125f, 
    -0.03451753f, 0.20471819f, -0.21365254f, -0.09668915f, 0.11641333f, 0.16946647f, -0.05776618f, 0.09449922f, 
    -0.03417483f, -0.44152346f, -0.13653426f, -0.24581809f, 0.05317616f, 0.05875753f, 0.01298952f, -0.02422462f, 
    -0.00419288f, 0.02150365f, -0.12901871f, -0.13262962f, -0.46568745f, 0.06098460f, -0.01929460f, 0.32254487f, 
    -0.04562464f, 0.07690570f, -0.03488400f, 0.07827538f, -0.01031551f, -0.09282801f, 0.14759655f, -0.12568904f, 
    0.48722619f, -0.05896986f, -0.32331908f, -0.03848303f, -0.03868446f, -0.06680590f, -0.01075162f, 0.01869772f, 
    0.09017856f, 0.06464169f, 0.15117471f, 0.05128111f, -0.00568936f, -0.00124202f, -0.00170954f, 0.49696693f, 
    -0.08556053f, -0.01666983f, 0.00293463f, 0.10962086f, -0.09279326f, -0.09455571f, -0.06124904f, -0.09794717f, 
    0.28668198f, 0.10686371f, 0.00217769f, -0.47270495f, 0.04437984f, -0.01451077f, -0.00418906f, 0.11384596f, 
    0.06739960f, -0.01789345f, -0.04882618f, 0.13146363f, 0.28921601f, -0.06591193f, -0.16594833f, -0.01755460f, 
    0.13474940f, -0.17279609f, -0.06636967f, -0.02084755f, -0.10225122f, -0.01679969f, -0.15840688f, -0.07723755f, 
    0.42730948f, -0.35197490f, -0.03114526f, 0.32313603f, -0.03605128f, -0.02710996f, -0.03148864f, -0.03749414f, 
    0.05787557f, -0.08258747f, -0.00320980f, 0.07418591f, 0.11696558f, -0.36899760f, 0.15969425f, 0.03787261f, 
    -0.08178841f, 0.05324203f, 0.06477325f, -0.00488320f, -0.05270930f, 0.05428311f, 0.02284894f, 0.15010157f, 
    -0.08071306f, 0.00144270f, 0.04060954f, 0.22706731f, -0.04008770f, -0.03469742f, 0.07170653f, 0.07569955f, 
    -0.01320785f, -0.01702273f, 0.02176855f, -0.04050252f, 0.12154771f, -0.17692791f, -0.14551142f, -0.33520430f, 
    0.03700573f, -0.07141151f, 0.05400781f, 0.07868930f, 0.06481914f, 0.07171317f, 0.00447789f, 0.05864714f, 
    0.16994309f, 0.04869609f, -0.18665195f, 0.22516011f, 0.18793759f, 0.17635177f, -0.03582138f, -0.14981171f, 
    0.03780222f, -0.03418908f, 0.05168124f, -0.10109974f, 0.17802863f, -0.02873318f, -0.15671057f, -0.19738080f, 
    -0.17965995f, 0.01269653f, -0.06575985f, -0.21044552f, -0.02407802f, 0.01462639f, -0.08329875f, -0.16366766f, 
    0.11127855f, -0.01750961f, 0.20105314f, 0.00620846f, -0.15996827f, 0.02514607f, 0.06002304f, -0.08490775f, 
    -0.05039729f, -0.05587158f, -0.01202108f, 0.07169779f, -0.14475094f, 0.35424253f, -0.10793770f, 0.14263177f, 
    0.10056678f, -0.09796627f, 0.03696245f, -0.16643406f, -0.01929043f, 0.00708842f, 0.15940928f, 0.11032271f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14696679f, 0.08672947f, -0.08438179f, 0.01540579f, 0.02282043f, -0.05432240f, 0.06216819f, -0.08833017f, 
    -0.02873853f, 0.01824513f, 0.14861034f, -0.00667987f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
