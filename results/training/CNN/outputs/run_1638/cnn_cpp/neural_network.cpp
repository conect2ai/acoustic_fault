#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.35334620f, -0.40782228f, -0.40185985f, -0.69680941f, -0.78733945f, 0.10925195f, 0.27553326f, 0.53416854f, 
    0.22335909f, 0.62157631f, -0.17882645f, -0.04351687f, 0.00406120f, -0.27585840f, 0.12450959f, -0.45388478f, 
    0.27628234f, 0.12066132f, -0.33533388f, -0.19898017f, -0.40940687f, -0.60572284f, -0.53596228f, -0.39349946f, 
    -0.52065933f, 1.06697714f, 0.32483536f, 0.22468649f, -0.18966107f, -0.24795322f, -0.10432268f, 0.56042004f, 
    0.73781240f, -0.05322652f, -0.50399768f, -0.70191580f, 0.31430277f, 0.05733776f, -0.46791205f, -0.02047549f, 
    0.36921075f, 0.10350433f, -0.24506062f, -0.69044548f, -0.44893757f, -0.13525106f, 0.10220193f, 0.17535837f, 
    -0.14943951f, 0.16303439f, 0.86556762f, -0.56396639f, 0.05765273f, 1.20954311f, 0.35963452f, -0.19970106f, 
    0.05024019f, 0.34397283f, -0.95649183f, -0.40333229f, -0.02188238f, 0.22766723f, 0.13057590f, -0.60062206f, 
    0.13958469f, 0.23555847f, 0.24444173f, 0.04767975f, 0.09912533f, -0.36570534f, 0.40888929f, -0.41010785f, 
    0.05493738f, -0.16874185f, -0.28456321f, -1.13480890f, -0.84088755f, -0.77881825f, -0.87839520f, -0.32681933f, 
    0.52499497f, 0.20574471f, 0.13249852f, -0.05921700f, -0.07049457f, -0.47969428f, -0.67056018f, -0.12558623f, 
    0.31446651f, 0.22755966f, -0.51414365f, -0.48864016f, -0.28151438f, -0.29106349f, -0.69936103f, -0.34997028f, 
    0.28222528f, 0.21876611f, -0.03418445f, -0.44538975f, 2.03890944f, -1.19466174f, -1.49382389f, -0.53686303f, 
    -0.18074313f, 0.47037539f, 0.10391279f, 0.32323048f, 0.03333873f, 0.22480695f, -0.38186625f, 0.83302629f, 
    -0.52108955f, -0.24979235f, -0.12980762f, 0.02308274f, 0.13545714f, 0.27059633f, -0.09528168f, -0.17483234f, 
    0.26526383f, -0.10439666f, -0.15460195f, 0.08843949f, 0.20457071f, -1.55062771f, -0.90863889f, 0.59300965f, 
    0.21407208f, 0.46770081f, 1.41236937f, 1.12455058f, -0.15048698f, -0.37898505f, 0.01149967f, -0.05632688f, 
    -0.14539088f, -0.15364206f, -0.13875298f, -0.25019386f, 0.36572650f, -0.03622273f, -0.23547412f, 0.18191259f, 
    -0.06128762f, 0.10109285f, 0.02920005f, -0.07990371f, 0.12298733f, -0.06959504f, -0.33421242f, -1.94448519f, 
    -0.74437892f, 0.37638095f, 1.26368058f, -0.00913776f, -0.05326668f, -0.10550918f, -0.07447358f, 0.29409963f, 
    0.82903641f, -0.05732982f, 0.63672048f, -0.14806615f, 0.41089904f, 0.15295556f, -0.41117242f, -0.41358012f, 
    -0.15488365f, -0.59966952f, -0.44716066f, -0.32952771f, -0.28448021f, -0.17363662f, -0.32689005f, -0.58116406f, 
    -0.56271535f, 0.30608842f, 0.25536671f, 0.42398188f, 0.19988370f, -0.41369441f, -0.25184727f, 0.71161205f, 
    0.99061847f, 0.16290161f, 0.04646100f, -0.35669675f, -0.02407017f, 0.66167563f, -0.66547233f, 0.02964093f, 
    -0.21003021f, 0.05067108f, -0.09689074f, 0.03455293f, 0.20743677f, -0.01662801f, 0.50449836f, 0.13271238f, 
    -1.33840966f, -0.23511450f, -0.74979663f, -0.84802324f, -0.65583730f, -0.55508381f, -0.53648412f, -0.46625558f, 
    -0.65221655f, 0.08310893f, 0.13257642f, -0.13474078f, -0.61866713f, -0.64393789f, -0.30999336f, 0.26501644f, 
    0.03924444f, -0.20483060f, 0.15528415f, -0.28773579f, -0.26483256f, -0.47517186f, -0.60731548f, -0.04378790f, 
    -0.01529943f, 0.46862918f, 0.80754948f, 0.62124437f, -0.07062951f, 0.06718137f, 0.17973067f, 0.00926324f, 
    -0.06065870f, -0.20580493f, 0.49150982f, 0.18237935f, 0.22440375f, -0.30070221f, -0.54931653f, -0.36955386f, 
    -0.03647633f, 0.04139624f, -0.07166712f, -0.31451276f, 0.03214055f, -0.02248246f, 0.23766331f, 0.35019737f, 
    -0.07716784f, -0.45034060f, 0.26472899f, -1.08418810f, -0.50787973f, 0.81905651f, 0.60079736f, 0.57320482f, 
    0.49233890f, -0.07083552f, -0.19681883f, -0.55800045f, -0.41521966f, 0.41563001f, -0.03470761f, -0.44419670f, 
    0.72875386f, -0.50652939f, -0.20664960f, 0.03539457f, 0.05028389f, 0.03543017f, 0.09581809f, -0.18128809f, 
    -0.23882852f, 0.01517424f, 0.36903140f, -1.64517355f, -0.17081337f, -0.77779013f, -1.37683773f, -1.29788959f, 
    0.25321010f, 0.08368926f, 0.14782622f, 0.59227610f, 0.55348486f, 0.08076219f, 0.46195179f, 0.12248270f, 
    0.42468819f, -0.37655097f, -0.30200768f, -0.04818463f, -0.30903199f, -0.08999953f, 0.16336475f, -0.04643216f, 
    0.09023651f, -0.02657235f, -0.00853016f, -0.13365206f, -0.30619514f, -0.85185081f, -0.84859461f, 0.03982209f, 
    -0.17625627f, 0.78492260f, 0.78998876f, 0.28688866f, -0.04700864f, -0.18579318f, 0.31617439f, -0.09016398f, 
    -0.08046116f, 0.60600799f, -0.53161806f, 0.01360077f, 0.19099277f, -0.32640034f, -0.52761704f, -0.33774245f, 
    -0.13196893f, 0.22725113f, 0.17018308f, 0.44242358f, 0.30309060f, -0.96057791f, -0.92586541f, -0.74775004f, 
    0.56727833f, 1.07955587f, -1.09218180f, -0.85703748f, -1.00789106f, -0.96249849f, 0.12943606f, -0.17540608f, 
    -0.43012565f, -0.12552319f, 0.58570737f, -0.65505600f, -0.17360513f, -0.23184991f, -0.02919268f, 0.18753053f, 
    -0.16129276f, 0.28532958f, -0.41367278f, 0.08088228f, -0.32647350f, 0.06140629f, 0.96545506f, 0.49519759f, 
    -0.01687362f, -0.24248539f, -1.07884192f, 0.03240585f, 0.11511858f, 0.45262530f, -0.39216942f, -0.23466463f, 
    -0.41914812f, 0.61208892f, -0.43088344f, 0.11092158f, 0.32001308f, 0.41396904f, -0.26822138f, -0.03726844f, 
    0.26960069f, -0.14934376f, -0.13172114f, -0.59878981f, -0.18034880f, 0.39599487f, 0.49480802f, -0.79199016f, 
    -0.52635753f, -0.20710567f, -0.98802620f, -0.92406756f, -0.33293453f, -0.62754983f, -1.06754839f, -0.90153968f, 
    -0.83507150f, 0.34680498f, 0.04919238f, -0.02430489f, 0.07291352f, 0.33287910f, 0.22547069f, -0.04153360f, 
    -0.01087326f, -0.28174224f, 0.04281365f, -0.14505661f, 0.28773510f, 0.59102362f, 0.22820042f, 0.51997948f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10447939f, 0.82031804f, 0.30717683f, -0.32953447f, 0.76365858f, 0.47533405f, 0.18057235f, 0.66750437f, 
    -0.40972027f, 0.26896715f, 0.52464485f, 0.45239824f, 0.45883030f, 0.42564526f, 0.38435680f, -0.19158497f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.27656320f, -0.02233768f, 0.03035241f, 0.14187129f, 0.13557728f, 0.18788292f, 0.06348132f, 0.05662596f, 
    -0.07638162f, 0.16761208f, 0.07939494f, 0.11968885f, -0.52625608f, -0.79784340f, 0.00127299f, 0.32876062f, 
    0.05444104f, 0.00726873f, 0.08252601f, 0.08147351f, -0.02559723f, 0.00468269f, 0.03273777f, -0.13473152f, 
    -0.18448912f, -0.20908965f, 0.23344027f, -0.06824114f, -0.05640592f, 0.00032539f, -0.06270617f, -0.23071401f, 
    -0.13006139f, -0.11267485f, 0.07008626f, 0.07594477f, 0.42223835f, 0.00584184f, -0.18345252f, -0.11766706f, 
    0.00824077f, 0.34297055f, -0.29201987f, -0.44876897f, -0.16958243f, -0.21650557f, -0.18341406f, 0.24139400f, 
    -0.00642585f, 0.03428597f, -0.63496643f, -0.12044947f, -0.00404903f, -0.00131775f, -0.10482381f, -0.19457719f, 
    -0.07292335f, 0.00736785f, -0.16801304f, -0.05290814f, 0.74100560f, -0.12464492f, -0.56992930f, -0.17976145f, 
    -0.23878060f, 0.03156634f, 0.09820732f, 0.04131133f, -0.05038962f, 0.00977198f, -0.03316724f, 0.05314294f, 
    0.21908502f, 0.26274291f, -0.18259010f, -0.15772434f, -0.02376504f, 0.15740113f, 0.18431836f, 0.01126030f, 
    0.04022026f, 0.08682127f, -0.07990550f, 0.04390218f, 0.03690232f, 0.17641059f, 0.19422390f, -0.09726577f, 
    -0.07325977f, 0.13525909f, -0.04203817f, 0.06621451f, -0.07692788f, -0.25973004f, -0.17197362f, -0.31588396f, 
    0.37863582f, 0.54016149f, -0.00828008f, -0.15699883f, 0.14969003f, 0.16782890f, 0.16403034f, 0.14001991f, 
    -0.15033443f, -0.04559381f, -0.13282418f, -0.19269381f, -0.69353950f, -0.79451907f, -0.00053830f, 0.28253138f, 
    0.11231306f, 0.02083087f, -0.00065589f, 0.08562460f, -0.11786430f, -0.03068855f, 0.03917699f, 0.07614027f, 
    -0.30022562f, -0.32764402f, 0.04329605f, 0.06515975f, -0.04250881f, -0.20272394f, 0.02471586f, -0.37857810f, 
    -0.10832478f, -0.13569535f, 0.01606208f, -0.14200936f, 0.31066605f, -0.02119630f, 0.01579317f, -0.17274113f, 
    0.11952978f, 0.26708922f, -0.15388152f, 0.06218773f, -0.12666270f, 0.02618911f, 0.11362501f, 0.05359116f, 
    -0.10440827f, -0.21211010f, -0.55456156f, 0.01577707f, 0.11093625f, 0.02311666f, 0.05937923f, -0.17928909f, 
    0.07990377f, -0.20402512f, -0.29931962f, -0.14988551f, 0.59851593f, 0.40854773f, 0.09863756f, -0.43720001f, 
    0.07016589f, 0.09158058f, 0.07340430f, -0.15475388f, -0.02274322f, -0.22280981f, -0.06636655f, -0.17029887f, 
    -0.12359899f, -0.23340996f, 0.00315406f, 0.12997338f, -0.00951399f, 0.12346791f, -0.15888312f, -0.65463442f, 
    -0.19077207f, 0.07295211f, -0.04517142f, -0.16803874f, 0.44377169f, 0.32003197f, -0.27992991f, -0.41825220f, 
    0.02363958f, 0.10256840f, -0.19205770f, -0.12670337f, -0.01698625f, -0.07735842f, -0.00202396f, -0.02479201f, 
    0.30066365f, -0.08841015f, 0.07710687f, -0.16173625f, -0.06561112f, 0.01917863f, -0.16826360f, -0.26817614f, 
    0.06139847f, -0.30650714f, -0.30273220f, -0.52240592f, 0.88450420f, -0.09883474f, 0.32734555f, 0.11578862f, 
    -0.15386602f, 0.00897401f, 0.15575022f, 0.01026171f, -0.02015467f, 0.02345748f, -0.37504324f, 0.14825839f, 
    0.10743794f, 0.06840008f, -0.03904749f, -0.03088593f, -0.20369776f, -0.20731866f, 0.04793821f, 0.13415328f, 
    -0.01204533f, -0.09184311f, 0.06915092f, 0.05880458f, 0.05198570f, 0.18716320f, 0.50668496f, 0.15469986f, 
    0.11475670f, 0.04367447f, 0.16906555f, 0.21938233f, -0.02536020f, -0.10919110f, 0.05004428f, -0.22288331f, 
    1.29491520f, 0.08177403f, -0.48234892f, -0.33038974f, -0.02819524f, -0.07940950f, -0.16133466f, -0.21804939f, 
    0.03352017f, -0.19576803f, -0.15917152f, 0.10035354f, 0.24356824f, -0.59408164f, 0.30790865f, 0.29442266f, 
    0.01760665f, -0.02974879f, -0.01276462f, 0.05795864f, 0.08364840f, -0.08060452f, 0.04800802f, -0.01842159f, 
    -0.52401847f, -0.19976455f, -0.62365150f, 0.09712428f, -0.12625363f, 0.05241615f, 0.06664964f, 0.07515442f, 
    -0.26192662f, -0.19787401f, 0.01303608f, 0.09170149f, -0.22260807f, 0.24554406f, -0.11847576f, 0.02561932f, 
    0.01978797f, -0.02316645f, 0.04665457f, 0.15892431f, -0.01552495f, 0.02934352f, -0.01074706f, -0.12314631f, 
    0.45491788f, 0.13176787f, 0.06985325f, 0.03872757f, -0.08265540f, 0.04585978f, -0.41003352f, -0.35839677f, 
    0.12959765f, 0.00171594f, -0.19771902f, 0.09576321f, 0.34169024f, 0.13208894f, 0.30449390f, 0.08275949f, 
    0.01663928f, -0.11021970f, 0.04368223f, 0.01646257f, -0.01651568f, -0.00328405f, -0.13771439f, -0.04872258f, 
    0.47046176f, -0.34304586f, -0.08889904f, 0.44382545f, -0.08053703f, -0.19712915f, -0.06376149f, -0.13628098f, 
    0.33544856f, 0.22352082f, 0.05783388f, 0.00933650f, -0.21692054f, -0.21118718f, -0.43904066f, -0.12768473f, 
    -0.06402747f, 0.23714481f, -0.07169426f, -0.26990843f, -0.07462206f, -0.04186812f, 0.00501723f, -0.01850393f, 
    0.08245104f, -0.34400716f, 0.02576184f, -0.34412950f, -0.19668509f, -0.10371988f, 0.28108045f, -0.06667591f, 
    0.07906448f, -0.10110883f, 0.14704950f, -0.05492058f, -0.31836605f, -0.19414124f, -0.18187758f, -0.08287288f, 
    0.07756831f, -0.41683516f, 0.29473388f, -0.24839163f, 0.06937862f, 0.03997624f, 0.03893549f, -0.01273056f, 
    0.54583848f, -0.26346239f, 0.09518259f, -0.14589773f, -0.02802478f, 0.11062222f, 0.10287647f, -0.36470714f, 
    0.16667680f, -0.03793825f, -0.16323951f, 0.00031084f, -0.03690284f, 0.25283134f, 0.28088868f, 0.13032824f, 
    0.03729524f, -0.04564729f, -0.03155960f, 0.10870860f, -0.09512653f, 0.07646019f, 0.01951599f, 0.05073921f, 
    -0.07819124f, 0.27330145f, 0.26415652f, 0.21202995f, 0.01123533f, 0.08574738f, 0.07613692f, -0.25956795f, 
    0.12646590f, 0.21059367f, -0.02949356f, 0.18579371f, 0.27820462f, -0.31054476f, -0.09277313f, -0.18404678f, 
    -0.07323878f, 0.07345212f, -0.00908813f, -0.00657292f, 0.06728718f, 0.00068967f, -0.31792668f, 0.13414256f, 
    -0.14444938f, 0.01224623f, -0.43568173f, 0.15412070f, -0.13322541f, -0.17718141f, -0.10739828f, 0.16562162f, 
    0.18192962f, -0.07809995f, -0.03325272f, 0.00909027f, -0.75787657f, 0.08188178f, 0.81819320f, 0.58306837f, 
    -0.06869473f, -0.11723734f, 0.16367894f, 0.12139115f, -0.03947182f, -0.13897267f, 0.09111328f, -0.35115674f, 
    -0.40488932f, 0.82431614f, 0.34790766f, -0.05932122f, -0.08486068f, 0.06127706f, -0.33897391f, -0.28632641f, 
    -0.03555695f, 0.03465287f, -0.06244501f, 0.07817911f, 0.12294731f, -0.31381485f, 0.50401413f, 0.06397530f, 
    -0.03443693f, -0.17822054f, 0.11306752f, 0.20945552f, 0.15578452f, 0.04678008f, 0.03979457f, -0.08311064f, 
    0.20112929f, -0.30930194f, -0.10746844f, 0.11704054f, 0.04219355f, -0.01958121f, 0.01374472f, 0.03382341f, 
    -0.12840454f, 0.10647779f, 0.15952805f, 0.02152066f, -0.26357108f, -0.28247607f, -0.22619152f, 0.25003716f, 
    0.11971491f, 0.09882471f, -0.04274179f, 0.18369181f, -0.03657836f, -0.09755942f, -0.14601636f, 0.13458246f, 
    -0.56810194f, 0.03190687f, -0.04881470f, -0.14532775f, 0.06935455f, -0.08080815f, -0.03770501f, -0.24692161f, 
    -0.02124567f, 0.00752520f, -0.01309213f, 0.07436996f, -0.32381788f, -0.46478730f, -0.03120344f, -0.46928498f, 
    -0.03560305f, -0.07995306f, 0.04228804f, 0.04695636f, 0.02538687f, -0.03834445f, -0.08717743f, 0.15282135f, 
    0.23027909f, 0.17372692f, -0.04365308f, -0.00326844f, -0.16312967f, 0.05751566f, -0.03141239f, 0.45892793f, 
    -0.10620891f, 0.12034235f, -0.32861015f, -0.06778185f, 0.69125080f, 0.75289196f, -0.09105600f, 0.69794571f, 
    -0.19453512f, -0.08039760f, 0.09607676f, 0.14333469f, -0.01708929f, -0.01520063f, -0.04098152f, 0.11670550f, 
    -0.24546087f, -0.07786781f, 0.48614532f, -0.22670686f, -0.02678981f, 0.06110329f, 0.02200100f, -0.11517347f, 
    0.09004339f, -0.36123297f, 0.16573313f, -0.08751461f, -0.46657252f, -0.68638700f, -0.29997808f, 0.09575293f, 
    -0.04611022f, 0.08002642f, -0.17083000f, 0.12728910f, 0.04624381f, 0.00823973f, 0.04668474f, -0.18647914f, 
    -0.51168722f, 0.16111298f, 0.12728396f, -0.16949713f, -0.03409817f, -0.05341718f, -0.14386314f, -0.30034351f, 
    -0.09663159f, 0.09112406f, 0.08192088f, 0.10166897f, -0.85188037f, -0.61298597f, -0.08549111f, -0.33268550f, 
    -0.13909082f, -0.03805248f, -0.08262128f, -0.06271867f, -0.08559648f, -0.02760254f, -0.06166718f, -0.11041011f, 
    -0.10303087f, -0.23519960f, 0.00022993f, 0.30354601f, 0.12254289f, 0.11517622f, 0.07922857f, -0.02308543f, 
    -0.05019201f, 0.18324634f, -0.18846247f, 0.18759826f, -0.50224870f, 0.06364109f, 0.32064822f, -0.28459767f, 
    0.00708262f, -0.20466039f, -0.16076693f, 0.00472607f, -0.28862688f, 0.03515846f, 0.10196546f, 0.03958246f, 
    -0.58259475f, 1.20879126f, -0.36839175f, 0.63206398f, -0.04654224f, 0.14753740f, 0.10870702f, -0.06391626f, 
    0.27616763f, 0.23419912f, -0.01200162f, 0.11531144f, 0.32816935f, -0.17265998f, -0.00352803f, 0.46329585f, 
    0.11207700f, -0.06675515f, 0.10814576f, -0.02714577f, -0.05237176f, 0.00988659f, 0.23780771f, 0.14123097f, 
    -0.36138514f, 0.12971385f, -0.06120446f, 0.36426890f, -0.09548404f, -0.05555866f, 0.29468507f, -0.27444258f, 
    0.04842655f, 0.04204951f, 0.24861211f, -0.00690060f, -0.72236025f, 1.24430788f, -0.52779901f, -0.77635098f, 
    0.44653574f, 0.30109152f, -0.04710864f, -0.02179426f, -0.35465136f, -0.26472801f, -0.08003449f, -0.15548356f, 
    -0.23266722f, 0.52047515f, -0.61218035f, -0.35743871f, -0.03116659f, 0.06633501f, -0.02443286f, -0.08172335f, 
    -0.10616768f, 0.19432266f, -0.04615834f, -0.15973538f, 0.15616286f, 0.00615035f, 0.10719053f, -0.70708567f, 
    -0.01668842f, -0.39862463f, -0.06220718f, -0.31304917f, 0.04485334f, 0.00902225f, -0.17014188f, 0.07041585f, 
    0.03541663f, -0.38466486f, -0.22469531f, 0.16759335f, 0.19457261f, -0.00269097f, -0.01356492f, -0.12715188f, 
    -0.07393364f, 0.14787002f, -0.08606594f, 0.13980988f, -1.04511213f, 0.09611559f, -0.01316059f, -0.16669884f, 
    -0.29307410f, -0.13761164f, -0.01466802f, 0.15299621f, 0.23925765f, 0.08360381f, -0.15837294f, 0.11819866f, 
    -0.41166571f, 0.99891281f, -0.68481559f, -0.28514609f, -0.06126529f, -0.42631003f, -0.07160865f, -0.27150300f, 
    -0.11316589f, -0.03987685f, -0.25713694f, -0.01924916f, 0.32814443f, -0.28076318f, 0.15886673f, 0.38334933f, 
    0.07616521f, -0.01663707f, -0.07642838f, 0.07843658f, -0.11082948f, 0.17607816f, -0.13050307f, 0.04239082f, 
    -0.09539080f, 0.12683018f, 0.01486564f, 0.01651665f, 0.30875885f, 0.10629487f, -0.08783392f, 0.05235166f, 
    -0.14948790f, 0.08367267f, -0.20242450f, 0.09442157f, -0.04696777f, 0.04070976f, -0.45456100f, 0.17536120f, 
    -0.06100318f, 0.25262046f, -0.07630898f, 0.01677887f, -0.07062674f, -0.12210951f, 0.12411123f, 0.08103865f, 
    -0.87136227f, 0.16170409f, -0.04674212f, 0.36135343f, 0.10362383f, -0.61938304f, 0.01876328f, -0.08244414f, 
    0.11665250f, -0.13704407f, 0.25641453f, -0.37149709f, 0.17960137f, -0.26409656f, 0.03919339f, 0.41401803f, 
    0.08913413f, 0.02329764f, -0.06021289f, 0.13875318f, 0.09757853f, 0.13436037f, -0.16842963f, -0.20341234f, 
    -0.15342899f, 0.03037778f, -0.10128435f, -0.02851361f, 0.08097523f, -0.20621286f, 0.10005192f, -0.01740635f, 
    0.03324855f, 0.05419780f, 0.15719239f, 0.26921731f, -0.42088360f, -0.18590261f, -0.65034223f, -0.45321137f, 
    0.07819691f, -0.01089112f, -0.06585502f, 0.05038450f, 0.08085201f, -0.11448290f, 0.16670620f, -0.34758034f, 
    0.35684028f, -0.06458962f, 0.46329439f, 0.19004853f, 0.12454490f, 0.00672628f, 0.06587454f, -0.25025079f, 
    0.03019868f, 0.03090258f, -0.05364277f, 0.02143427f, -0.21946453f, 0.02798005f, 0.12802522f, 0.21020570f, 
    -0.14000309f, -0.04446955f, -0.02356630f, -0.12380162f, 0.21920681f, 0.05557194f, 0.11460042f, 0.11955118f, 
    -0.37669516f, -0.26097396f, 0.01069290f, -0.21934135f, -0.17815171f, -0.02512921f, -0.24892099f, -0.18672581f, 
    -0.01860283f, -0.10637861f, -0.16672496f, -0.01644016f, 0.24150312f, -0.48542997f, 0.23702174f, -0.07693698f, 
    -0.02143232f, -0.03685324f, 0.01751717f, -0.19345324f, -0.06619318f, 0.08539028f, 0.00189825f, -0.04939561f, 
    0.31859756f, -0.46015736f, 0.12497175f, -0.05537491f, -0.04242878f, -0.10105123f, -0.12639657f, 0.04800949f, 
    0.14375676f, 0.08595727f, 0.14055605f, 0.17424236f, 0.22024663f, 0.11041740f, 0.06814530f, 0.21875601f, 
    0.01590774f, 0.06448674f, 0.13522771f, -0.02386126f, -0.50576442f, -0.16192409f, -0.40042615f, -0.06263776f, 
    -0.11944160f, -0.08916519f, 0.09390208f, 0.18273427f, -0.04160768f, 0.04402171f, 0.10783611f, 0.08559035f, 
    -0.03839626f, 0.03081966f, 0.10802583f, 0.10717773f, 0.74195677f, -0.12056017f, -0.35599935f, -0.12950020f, 
    0.10602296f, 0.08339106f, 0.13056071f, 0.05501443f, 0.01437443f, 0.06050295f, 0.09827024f, -0.09414170f, 
    0.15460427f, -0.88683015f, 0.10267405f, -0.35315141f, 0.02368175f, 0.26409474f, 0.01463887f, 0.04450765f, 
    -0.15147497f, -0.16404617f, -0.11200852f, -0.27440217f, 0.19913629f, 0.23019330f, 0.24358895f, 0.22999492f, 
    -0.05907669f, -0.22902982f, 0.05269723f, -0.12444942f, 0.14495569f, -0.18192960f, -0.08145171f, -0.05832833f, 
    0.50964481f, -0.26399058f, 0.10489933f, 0.20262226f, 0.09910197f, 0.07129720f, -0.12228406f, 0.00105643f, 
    -0.16713426f, -0.23680447f, -0.11152293f, -0.12216392f, -0.19426525f, -0.10843735f, 0.42495215f, 0.10088911f, 
    -0.22609995f, 0.13289252f, -0.27825013f, -0.12553468f, -0.14104590f, 0.06195138f, -0.09005879f, -0.10659431f, 
    0.04327196f, 0.18985260f, -0.26960653f, 0.11501944f, 0.28130731f, -0.09451934f, -0.02303627f, 0.02190785f, 
    0.01830640f, 0.17002173f, -0.13088278f, -0.22309430f, 0.08891690f, 0.35851187f, 0.24694949f, 0.36468625f, 
    0.00964993f, -0.01492682f, 0.06241091f, 0.05762325f, 0.13862519f, -0.06217083f, 0.01206912f, -0.02959069f, 
    0.03807684f, -0.32392073f, -0.19253661f, -0.20993817f, -0.01057626f, 0.05237478f, -0.06888665f, 0.19015221f, 
    -0.08119532f, -0.37204653f, 0.00046224f, -0.38892928f, -0.03237766f, -0.06709914f, -0.55334967f, 0.30282152f, 
    0.04230491f, 0.14641841f, -0.04086925f, -0.09391339f, 0.05980423f, -0.13060534f, 0.15114234f, 0.11253311f, 
    -0.03303785f, -0.29975504f, 0.07594953f, -0.17565496f, 0.44097883f, -0.11560710f, -0.36956513f, 0.06876430f, 
    -0.23751265f, -0.03200293f, 0.21709543f, -0.13551053f, -0.13195314f, 0.06379338f, -0.33790016f, -0.47738171f, 
    0.01604481f, -0.05637226f, -0.06543853f, -0.07141592f, 0.13377112f, 0.08835917f, -0.31067240f, -0.33349243f, 
    -0.20391929f, -0.19980344f, 0.08397385f, -0.44822776f, 0.01265700f, 0.12783317f, -0.11735160f, 0.13882768f, 
    0.13677864f, 0.06526588f, 0.16726844f, -0.00576356f, -0.65953469f, 0.23606394f, -0.18206140f, -0.07841133f, 
    0.08587801f, -0.15193056f, -0.12974858f, -0.00392533f, 0.15190949f, -0.01206630f, -0.17873739f, 0.13514800f, 
    0.14836197f, -0.03313881f, 0.52697825f, -0.21071747f, 0.03221300f, -0.11717283f, 0.11790901f, 0.05079119f, 
    -0.09109996f, -0.33146310f, -0.30692607f, 0.09747142f, -0.20027551f, -0.44694766f, 0.29978180f, 0.24719791f, 
    -0.36793411f, -0.00638116f, -0.17662044f, -0.01141564f, 0.33618826f, 0.15193689f, 0.24723965f, 0.07083011f, 
    -0.20042777f, 0.38914698f, 0.27894720f, -0.01708743f, 0.00538203f, -0.02041995f, -0.01926124f, -0.09009308f, 
    0.05698172f, -0.19050148f, -0.08148480f, 0.02762637f, -0.30504674f, 0.05526394f, -0.45861626f, 0.26673725f, 
    0.04515445f, 0.06859658f, -0.19591926f, 0.01176572f, 0.09475587f, -0.13195236f, 0.04490539f, -0.09313930f, 
    -0.00273199f, -0.11444653f, 0.19855906f, 0.14542893f, 0.11911558f, -0.00153178f, 0.14299111f, -0.09567914f, 
    0.06101165f, -0.00920625f, -0.02853490f, 0.04728745f, -0.56542730f, -0.16319862f, -0.10507420f, -0.25531808f, 
    0.13115256f, 0.02238252f, -0.07499421f, -0.07025824f, 0.04173729f, -0.04483308f, 0.05570627f, -0.12963219f, 
    -0.32001764f, -0.01910693f, -0.28330618f, -0.07523207f, -0.02757511f, 0.11366288f, -0.15177321f, -0.12237450f, 
    0.18770549f, 0.19130678f, 0.16079578f, 0.07850185f, 0.13061963f, 0.33353418f, 0.57971150f, 0.00552100f, 
    0.24098173f, -0.06590854f, 0.19443107f, 0.27795836f, 0.10606808f, -0.00428923f, 0.03124997f, 0.28676343f, 
    -0.07905653f, 0.17394355f, -0.47302189f, -0.15723592f, 0.00350206f, -0.00487236f, -0.31489009f, 0.33710986f, 
    0.14688475f, 0.10625623f, 0.03807697f, 0.27742702f, -0.00038646f, 0.18194117f, 0.13099636f, -0.28875753f, 
    0.19507174f, 0.25800410f, 0.32150206f, -0.04915830f, 0.12899722f, 0.04176841f, 0.02013652f, 0.09159239f, 
    0.17860119f, 0.34577882f, 0.15387152f, 0.06553373f, -0.04275670f, 0.01139927f, 0.08556098f, 0.22734053f, 
    0.07630098f, 0.18447977f, 0.29806715f, 0.20956084f, -0.04621909f, -0.01580171f, 0.39317188f, -0.60561496f, 
    -0.03989410f, 0.03807929f, -0.00878195f, 0.06115345f, 0.02230412f, 0.17940195f, 0.04100134f, -0.03838111f, 
    -0.10154397f, -0.22673644f, -0.18911608f, -0.08403949f, 0.09332843f, 0.24295242f, 0.04109706f, -0.06120582f, 
    -0.14182679f, 0.12714072f, -0.12795353f, -0.12339590f, -0.62324297f, -0.23354553f, 0.08735853f, -0.80721366f, 
    -0.16733015f, -0.07224916f, -0.11348714f, -0.10134883f, 0.02892390f, 0.09626412f, 0.03546427f, 0.21437284f, 
    -0.20640001f, 0.40756291f, -0.45700255f, 0.46972221f, 0.18841852f, 0.02862522f, 0.34706566f, 0.09979995f, 
    0.08612714f, 0.05278501f, 0.00552596f, -0.29430449f, 0.05836412f, -0.12628615f, 0.24360265f, -0.06315134f, 
    0.02565543f, -0.00888466f, -0.07128269f, -0.10060763f, -0.20559753f, 0.11124402f, -0.02431665f, 0.01775382f, 
    -0.47521460f, 0.70537812f, 0.43459347f, -0.37796351f, 0.01415726f, 0.08778279f, -0.11101091f, 0.20522669f, 
    0.13470441f, 0.34106329f, 0.26557389f, -0.26566344f, -0.05276350f, -0.02892306f, -0.09722252f, 0.35493895f, 
    -0.05810114f, 0.02837823f, -0.07409953f, 0.22128551f, -0.07058793f, 0.02197378f, 0.05278631f, 0.03573320f, 
    -1.25081503f, -1.44765151f, -0.53859538f, -0.10117050f, -0.41890854f, 0.00675103f, 0.10794944f, -0.14840579f, 
    0.00782550f, 0.14791432f, 0.09864617f, -0.23210110f, 0.16536044f, -0.20603010f, -0.11119469f, 0.02534622f, 
    0.02469686f, 0.10267753f, -0.11692379f, -0.07649687f, -0.12553680f, -0.03180346f, -0.04879754f, -0.30056560f, 
    -0.47948217f, 0.13983470f, 0.20113745f, 0.42812517f, 0.05830970f, -0.09699544f, 0.01463169f, -0.02107771f, 
    -0.01102541f, -0.13859923f, 0.11313225f, 0.12286179f, -0.79399341f, 0.66866124f, 0.78934795f, 0.42347461f, 
    -0.12916696f, -0.15224099f, -0.15258937f, 0.26733416f, -0.19604544f, 0.08150011f, -0.06947302f, 0.10363653f, 
    -0.31585699f, 0.27384162f, 0.65784264f, -0.45927408f, -0.09329462f, -0.04541999f, -0.09217076f, 0.18664047f, 
    -0.04519732f, 0.11578218f, 0.10255755f, -0.05133163f, -0.94157016f, -1.76008630f, -1.09475029f, 0.44483206f, 
    -0.21497773f, 0.02268952f, 0.17123735f, -0.16685477f, 0.01202291f, 0.11151739f, -0.08370297f, 0.02869447f, 
    0.52147800f, 0.05769332f, -0.23627339f, -0.33481470f, -0.02533621f, -0.22889279f, 0.39311382f, -0.02961637f, 
    -0.29544857f, -0.09671508f, 0.06087402f, -0.08875419f, -1.25036812f, -1.11126399f, -0.54954612f, -0.64213574f, 
    -0.31615195f, -0.66942602f, -0.36082190f, -0.46752030f, -0.10860149f, -0.10626418f, 0.00389669f, -0.16143383f, 
    0.00028287f, -0.51444113f, -0.23105684f, -0.09648796f, -0.12550105f, 0.06788000f, -0.05238500f, 0.09873363f, 
    0.32265985f, 0.04784979f, -0.15508465f, 0.01072159f, -0.09619954f, 0.12292256f, -0.23922937f, 0.14660691f, 
    0.05387096f, -0.02448531f, 0.09039898f, -0.06983741f, 0.14907490f, -0.13061000f, -0.14888586f, -0.31221572f, 
    0.13146178f, 0.04409312f, 0.08446576f, -0.12013125f, -0.05088157f, -0.31562436f, 0.12101691f, -0.00315827f, 
    -0.01697936f, -0.09073539f, 0.02951542f, 0.00501313f, 0.38689315f, -0.70073438f, -0.80628574f, -0.80731118f, 
    0.08034520f, -0.26942965f, -0.08283419f, 0.23223048f, 0.03058031f, 0.23025651f, 0.07859628f, 0.18499932f, 
    -0.84231228f, -0.62735260f, 0.47159448f, -0.09136236f, -0.13746172f, -0.13010180f, 0.23314284f, -0.14038241f, 
    0.08608332f, 0.10540480f, 0.13446304f, -0.06465346f, 0.31744206f, 0.22333311f, -0.14602265f, -0.16822790f, 
    0.03523240f, -0.03202342f, 0.00215649f, 0.10640354f, -0.02346193f, -0.01755584f, -0.00428725f, -0.03551093f, 
    0.36837322f, -0.90598613f, -0.07634211f, -0.65921360f, 0.05862978f, 0.07224558f, 0.03288770f, -0.01384860f, 
    0.20704573f, 0.06241332f, 0.21835485f, -0.15030462f, 0.32871577f, -0.36271358f, 0.08529291f, -0.41916031f, 
    -0.02123127f, 0.05047450f, -0.03950632f, -0.13729738f, -0.15343426f, 0.09158657f, 0.00086953f, -0.24216309f, 
    -0.37533712f, -0.62194884f, -0.32774064f, 0.38392651f, -0.05059081f, -0.16736464f, 0.27211553f, 0.38871801f, 
    -0.08643522f, 0.03881405f, -0.26808724f, -0.00003363f, 0.06623922f, 0.09242651f, 0.15844253f, -0.02318406f, 
    0.08628923f, -0.05774236f, -0.12627694f, -0.03441136f, 0.15276679f, 0.02197859f, 0.04994955f, -0.09023461f, 
    0.30481252f, -0.33710927f, 0.02548360f, -0.69492280f, 0.11056904f, 0.18863136f, 0.06595587f, 0.09241885f, 
    -0.06819684f, 0.04056252f, -0.06427280f, -0.19894855f, 0.65752256f, -1.59571135f, -0.19444945f, -1.05104196f, 
    -0.11096049f, -0.22557230f, -0.01032010f, -0.02694148f, 0.06987780f, 0.10468474f, 0.08356877f, -0.00725218f, 
    0.28773585f, 0.28344536f, -0.18393156f, -0.27990198f, -0.12333595f, 0.01650074f, 0.20511405f, 0.01014684f, 
    -0.10125811f, 0.30870238f, -0.10287250f, 0.18048923f, 0.07569537f, -1.40563929f, 0.48180693f, 0.20303090f, 
    -0.02580865f, 0.29992902f, -0.21496624f, 0.24721637f, -0.01886144f, -0.00515353f, -0.09517892f, -0.11868583f, 
    -0.20817930f, 0.38947117f, -0.12805071f, 0.04902347f, 0.01788736f, 0.08313624f, -0.01227508f, 0.01808498f, 
    -0.34243220f, 0.10611362f, -0.10574698f, 0.05984922f, -0.94822544f, -0.83152646f, -0.16490504f, 0.50771713f, 
    0.16914120f, -0.05204232f, -0.07266355f, 0.17300354f, 0.07194509f, 0.12450140f, -0.02787759f, -0.06453939f, 
    -0.25102434f, -0.34296510f, 0.10518757f, 0.22391911f, 0.08962465f, 0.10477374f, -0.05122664f, 0.08276781f, 
    -0.37486681f, 0.02131619f, -0.20063604f, -0.65082109f, -0.97067606f, 0.01491402f, 0.30639610f, 0.13800736f, 
    0.08565132f, 0.05754970f, -0.18243138f, 0.06729501f, 0.05404834f, 0.03453187f, -0.05951453f, 0.18194064f, 
    -0.20626946f, 0.15160793f, 0.01599112f, 0.04387930f, -0.18342212f, 0.10616484f, -0.16743019f, -0.41326171f, 
    0.03789911f, 0.12418393f, -0.25312024f, 0.07135697f, -0.10685768f, -1.02289426f, -0.60008901f, -0.08211017f, 
    0.14057994f, 0.22455929f, 0.21694356f, -0.03392942f, -0.03642025f, -0.02992615f, 0.09802397f, -0.20053987f, 
    -0.12869361f, -0.36382884f, 0.08155381f, 0.30064198f, 0.08169780f, 0.13589825f, 0.24469516f, -0.01354557f, 
    0.15418828f, 0.10576227f, 0.07789863f, 0.21802601f, -0.06057306f, -0.04319737f, -0.23145638f, -0.23395598f, 
    -0.22159512f, -0.01470756f, -0.04792944f, 0.08758470f, 0.21709546f, 0.26851907f, 0.18870649f, -0.00072705f, 
    0.43012062f, -0.32096142f, -0.59779745f, -0.42122880f, -0.15702754f, -0.05214050f, -0.00419584f, -0.11143789f, 
    0.02724596f, -0.29075363f, -0.18419549f, -0.46420237f, 0.03623340f, -0.15246786f, -0.25151083f, -0.34964994f, 
    0.03821549f, -0.09430026f, 0.02450397f, 0.04902283f, 0.12217258f, 0.06367154f, 0.43505868f, 0.30329368f, 
    -0.20882176f, -0.35769564f, -0.63787514f, -0.75677747f, -0.18003044f, 0.14107150f, 0.27283803f, -0.12683026f, 
    -0.00473184f, -0.22966345f, -0.06228117f, -0.06039387f, -0.44398585f, 0.38424355f, 0.14698511f, -0.12839048f, 
    -0.09282093f, -0.12610231f, -0.15088764f, -0.12780707f, -0.10425946f, 0.06077627f, -0.19447982f, 0.03812559f, 
    0.23814702f, -0.12242923f, -0.34588784f, -0.46809229f, -0.20317882f, 0.12635283f, 0.08584543f, -0.10188875f, 
    0.06886664f, -0.00166038f, 0.31679490f, 0.29211473f, -0.48852852f, -0.82818931f, -0.72104442f, 0.34847721f, 
    0.17049868f, 0.22516951f, 0.20508789f, 0.29376841f, -0.16655634f, -0.03681925f, 0.02259323f, -0.06148568f, 
    -0.25317734f, -0.10718792f, 0.15651105f, -0.14317577f, -0.21456392f, 0.02598584f, 0.03314971f, 0.00430510f, 
    0.22090825f, 0.09760971f, -0.08916793f, 0.26563165f, 0.84225810f, 0.33345082f, -0.81756175f, -0.19084047f, 
    0.04683059f, -0.13803372f, -0.01956104f, -0.14295611f, 0.16946255f, 0.12367634f, 0.17979284f, 0.12392966f, 
    -0.46856055f, -0.07612145f, 0.34162867f, 0.09042456f, 0.02758775f, 0.08083329f, -0.15441242f, 0.23864552f, 
    -0.08561999f, -0.11241846f, 0.38660580f, 0.02676509f, -0.51461589f, -0.98954052f, -0.36495823f, 0.09271163f, 
    0.11783582f, -0.04528758f, 0.02975330f, 0.03140927f, 0.04493910f, 0.00868163f, 0.04469170f, 0.13998333f, 
    0.37318537f, 0.12530847f, 0.32895350f, -0.09859816f, 0.00855637f, -0.11688018f, -0.07738807f, -0.08913995f, 
    0.03430609f, 0.09494551f, 0.18082859f, 0.10285850f, -0.58084285f, 0.33820343f, -0.13323708f, 0.12573935f, 
    0.22011234f, -0.14853001f, 0.02739089f, 0.08037686f, -0.03776455f, 0.07018854f, 0.21827130f, -0.03599518f, 
    0.00493588f, -0.84776300f, -0.03087288f, -0.29827264f, 0.19264650f, 0.27227512f, -0.00893122f, 0.16260128f, 
    -0.08197695f, -0.00296045f, -0.07694159f, -0.09103452f, 0.28790715f, 0.08324882f, -0.08295828f, 0.39172614f, 
    0.07982095f, 0.01685172f, -0.12463060f, -0.07223196f, -0.03490712f, -0.04668058f, 0.12690705f, 0.24853350f, 
    0.29254055f, -0.36540213f, 0.95393556f, -1.03770781f, -0.11322964f, -0.28512615f, -0.08830865f, -0.11982491f, 
    -0.15058105f, 0.08733022f, -0.22457476f, 0.05061533f, -0.43319187f, 0.25527608f, 0.05286564f, 0.55765682f, 
    -0.16571739f, 0.32493454f, -0.61823583f, 0.22073132f, 0.27999112f, -0.04134414f, 0.18880896f, -0.00018915f, 
    0.18357588f, -0.30721641f, 0.74996120f, 0.65677691f, 0.21155228f, -0.17067030f, -0.17993273f, -0.19673555f, 
    0.09030474f, 0.13195765f, 0.11652953f, 0.01063964f, 0.24987260f, -0.17116950f, 0.53497368f, 0.21124928f, 
    0.10704884f, -0.09813669f, -0.17632465f, -0.43863055f, -0.04121188f, -0.30261743f, 0.01324735f, 0.22433393f, 
    -0.50399143f, 0.33652934f, 0.42974895f, -0.46788099f, 0.11070748f, -0.23930982f, 0.22421113f, 0.02479306f, 
    0.10878760f, 0.25447091f, 0.24350280f, 0.09086113f, -0.21072929f, -0.55622506f, -0.29306316f, 0.04191125f, 
    0.06749323f, 0.41961640f, 0.18408854f, 0.13976081f, 0.20487447f, 0.02020339f, -0.01164756f, 0.03365766f, 
    -0.18984151f, -0.58983725f, 0.33563522f, -0.37629867f, 0.30561292f, -0.26903418f, -0.19088101f, -0.14218341f, 
    -0.58749026f, -0.36273202f, 0.12222871f, 0.08097444f, -0.36386293f, 0.16636975f, 0.35334817f, -0.61321402f, 
    -0.19543678f, -0.44343090f, 0.11549372f, -0.22790635f, 0.01193504f, -0.16870095f, 0.11727949f, 0.12458048f, 
    0.50487727f, 0.39136150f, -0.05754401f, 0.40571842f, 0.19019665f, -0.08074321f, -0.65851355f, 0.14763495f, 
    -0.22392106f, -0.02411273f, -0.09999628f, -0.18605541f, -0.57140768f, -0.74721867f, -0.02823806f, 0.00817814f, 
    0.01453866f, -0.20955896f, -0.06244845f, -0.05511612f, -0.09978966f, -0.01570046f, 0.06554878f, -0.03718909f, 
    -0.12801996f, 0.01346327f, 0.06574951f, -0.40266368f, 0.05069782f, -0.35230014f, 0.28259781f, 0.28543022f, 
    -0.14594334f, -0.06647403f, -0.17284480f, 0.00103590f, -0.37901849f, 0.00804832f, -0.07674665f, -0.54611671f, 
    -0.27431229f, -0.12195373f, -0.03778244f, 0.33754429f, 0.00004651f, -0.27422974f, 0.10538901f, -0.13265544f, 
    -0.44378302f, 0.29465684f, 0.13602145f, -0.11349886f, -0.09580616f, -0.35598281f, -0.35776833f, 0.06318605f, 
    0.02195823f, -0.10239064f, -0.63840365f, -0.50569826f, -0.38804239f, -0.08883594f, 0.12223841f, 0.01730674f, 
    0.03936319f, -0.17316955f, 0.04570495f, 0.08486429f, -0.21084981f, -0.24663195f, -0.35339853f, 0.12297653f, 
    -0.82212108f, -0.02083132f, 0.24085392f, -0.38178137f, -0.30628568f, 0.28211516f, -0.65263104f, 0.29136997f, 
    -0.05612160f, -0.19165954f, 0.20812127f, -0.04120087f, -0.17213415f, 0.03493713f, -0.70179534f, -0.05802983f, 
    -0.11216299f, 0.10153856f, -0.03223361f, 0.18379733f, -0.12221763f, 0.31590596f, -0.41680250f, -0.34112695f, 
    -0.19949083f, 0.24585399f, 0.45885962f, 0.39211038f, -0.00491568f, 0.02284386f, 0.02677344f, 0.32343194f, 
    0.07284861f, -0.15089050f, 0.13849637f, 0.04037404f, 0.47331771f, -0.23899633f, 0.01274495f, -0.44736263f, 
    -0.00820515f, -0.09103967f, 0.06407694f, -0.03324958f, -0.21419325f, 0.19448604f, -0.03026293f, -0.10583387f, 
    -1.10341060f, 0.86434811f, -0.26000816f, 0.64240032f, 0.13613936f, 0.29529774f, -0.10759524f, 0.01848467f, 
    -0.09087230f, -0.36770126f, -0.45472026f, -0.11124921f, -0.70219159f, 0.40968519f, -0.44189283f, -0.41718036f, 
    -0.26565105f, -0.27205324f, 0.35148743f, -0.37446609f, -0.04637786f, 0.15881518f, 0.07045931f, 0.12979464f, 
    0.00905816f, -0.48470068f, -0.13899453f, -0.08170026f, -0.07484057f, 0.12275594f, -0.23959865f, 0.05596009f, 
    0.01050534f, 0.05579823f, 0.00252232f, -0.36254531f, -0.07399962f, 0.15362084f, -0.05899343f, -0.16929859f, 
    -0.29626247f, -0.35981801f, -0.06861941f, -0.20667394f, -0.14866734f, 0.08326249f, 0.15866902f, 0.10022675f, 
    -0.70861626f, 0.87539005f, 0.15841480f, 0.16176584f, -0.15975370f, 0.09607308f, -0.21362591f, 0.15258107f, 
    0.12554432f, 0.05232224f, 0.39409235f, 0.35932851f, 0.36859328f, 0.13540635f, 0.15277857f, -0.31165621f, 
    0.08401604f, -0.17069672f, 0.09728268f, 0.00506829f, -0.15326427f, 0.04780390f, -0.05345168f, -0.32599947f, 
    0.17134416f, 0.51125699f, -0.04449522f, 0.08296677f, 0.07612847f, -0.06648004f, -0.11003099f, -0.00253588f, 
    0.10796772f, 0.19567448f, 0.09222010f, 0.24962112f, -0.59572524f, 0.46508998f, -0.51837385f, 0.29450476f, 
    -0.23317453f, 0.25081664f, 0.01203142f, 0.00932030f, 0.11455795f, 0.28626126f, 0.05449726f, -0.01901468f, 
    -0.13501376f, -0.71776819f, 0.45242199f, 0.03942106f, 0.14734779f, 0.09364530f, -0.24494067f, -0.04208249f, 
    0.18025288f, 0.01610453f, 0.28696889f, -0.14417532f, -0.13958830f, -0.18964724f, -0.18443494f, 0.22822118f, 
    -0.13998257f, 0.05257263f, 0.20930369f, 0.21893910f, 0.04322763f, 0.16955450f, 0.25777519f, 0.17840129f, 
    -0.26175356f, 0.40166569f, -0.13116156f, -0.33891398f, -0.09207663f, 0.02922232f, 0.17182294f, 0.04813332f, 
    -0.08267854f, -0.05490483f, 0.14382456f, 0.15993501f, 0.46582788f, 0.01740469f, 0.01378117f, -0.24135354f, 
    -0.28803232f, 0.04238463f, -0.10991313f, 0.14643833f, -0.22319257f, 0.10237934f, 0.00781755f, 0.01412311f, 
    0.16822025f, 0.65300012f, -0.14083891f, 0.04675478f, 0.12033810f, -0.06418966f, 0.52354383f, 0.33184689f, 
    0.13912371f, 0.02403009f, -0.06148226f, -0.20134130f, 0.13762641f, -0.36353725f, 0.12557060f, -0.29444921f, 
    -0.21210428f, -0.17206636f, 0.02284675f, -0.00091056f, -0.08422601f, 0.13474864f, 0.13629048f, 0.10719272f, 
    -0.41262168f, -0.00711297f, -0.36916298f, 1.03958786f, 0.15158540f, 0.23320623f, 0.08075472f, 0.57355863f, 
    -0.23892944f, -0.00608446f, -0.00109623f, -0.10871384f, -1.16759622f, 0.19520247f, -0.50506580f, 0.17557244f, 
    0.11683020f, 0.01959224f, 0.17790709f, -0.30680850f, -0.04673576f, -0.10055971f, 0.10552662f, 0.13090345f, 
    -0.57719928f, -0.44007921f, -0.54091626f, 0.33398876f, 0.04088005f, -0.21713373f, -0.04788351f, 0.09404820f, 
    0.18476397f, 0.12905712f, 0.25764602f, 0.10851386f, -0.08693755f, 0.12594768f, -0.48724085f, 0.18566138f, 
    0.31199643f, -0.20179375f, 0.05925830f, -0.36347926f, 0.03620590f, -0.21783386f, -0.20000780f, -0.24083702f, 
    -0.11349338f, -0.15112869f, -0.07836240f, -0.37551585f, -0.05374197f, -0.30570534f, 0.02924309f, -0.04262172f, 
    0.17044787f, 0.20204929f, 0.09502656f, 0.08679382f, 0.24279261f, 0.19052209f, 0.11877332f, 0.07393024f, 
    -0.10071640f, 0.07858706f, -0.09124225f, -0.16509371f, -0.26433718f, 0.15672494f, 0.08885020f, -0.19172645f, 
    -0.76950133f, 0.50493115f, -0.63073736f, 0.51542372f, 0.01369627f, 0.04117736f, 0.11063659f, 0.31306568f, 
    0.06559502f, 0.04083900f, -0.15180795f, -0.04261630f, 0.26358706f, -0.16574283f, 0.06595875f, -1.01223183f, 
    0.18395740f, -0.08705397f, 0.18282831f, -0.07818848f, 0.15470982f, 0.14223072f, -0.01810860f, -0.06886186f, 
    -0.56456822f, -0.09788643f, -0.22440690f, 0.35400110f, 0.08019330f, -0.20540552f, 0.01280000f, 0.26278877f, 
    -0.33864093f, -0.03232071f, -0.21071491f, -0.21025470f, 0.08806676f, -0.63007146f, 0.07862370f, 0.28095883f, 
    -0.00110192f, -0.25308284f, 0.03335951f, -0.14088508f, 0.07339189f, 0.10204651f, 0.21040206f, -0.10980619f, 
    0.18744551f, -0.11405732f, 0.12579979f, 0.51055497f, -0.05043961f, 0.12179014f, -0.06770307f, 0.43386841f, 
    0.00992441f, -0.08887290f, -0.17845450f, 0.23028941f, 0.17374735f, -0.12346303f, 0.00284969f, -0.08103398f, 
    -0.15707690f, -0.25134048f, -0.03957203f, -0.49059770f, 0.07659335f, -0.13196993f, -0.23137087f, -0.13844213f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.23606735f, 0.02872915f, 0.08150207f, -0.08760396f, -0.16560532f, 0.15266028f, 0.09369251f, -0.12536290f, 
    0.24149649f, 0.04808583f, -0.04027041f, 0.06797756f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
