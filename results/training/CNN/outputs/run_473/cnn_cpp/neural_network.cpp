#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.32128191f, -0.25183913f, -1.10948789f, -0.69709694f, -0.10711004f, 0.34677899f, 0.55582929f, 0.33397034f, 
    0.33402571f, -0.86067408f, -0.87402225f, -0.14928067f, 0.60014474f, 1.10336423f, 0.39052773f, -0.22666705f, 
    -0.23539077f, -0.89715922f, 0.42449334f, 0.13287930f, -1.33776903f, 0.10815036f, -0.19078578f, 0.32758328f, 
    -0.94498682f, -0.82431519f, -0.13544999f, -0.26768771f, 0.61227542f, 1.26383746f, 0.79293096f, 0.83438110f, 
    -0.57859343f, 0.39035994f, 0.01284816f, 0.75167370f, 0.30253491f, -0.57281059f, 0.20700993f, 1.02683580f, 
    1.22795689f, 0.37648812f, 0.17556490f, -0.42557397f, 0.04051442f, -1.50679529f, 1.22154701f, 0.83040017f, 
    0.51997620f, 0.03538483f, 0.10056718f, -0.80508626f, -0.45314834f, -0.29499662f, -0.96352267f, -0.16202883f, 
    0.69086576f, 1.24585748f, 0.80441308f, 0.72539419f, 0.57284033f, 0.54642308f, 0.27017033f, -0.81446654f, 
    -0.85151273f, -1.06230569f, 0.62312031f, -0.02861593f, 0.68647563f, -0.24479200f, -0.08547289f, 0.25506756f, 
    -0.95070803f, -0.42557439f, 0.41578385f, -1.02837217f, 0.61756629f, -0.74161148f, -0.05683366f, 0.57356608f, 
    -0.41610605f, 0.60717434f, 1.11576676f, 1.37207031f, -0.81023532f, -0.06764804f, -0.26047570f, -0.17478193f, 
    0.26979965f, -0.02849087f, 0.26563182f, 0.04216047f, 0.22979416f, -0.52338606f, -0.96602118f, -0.94906819f, 
    0.89728618f, 0.78365743f, -0.38649082f, 0.42045584f, 0.66172016f, 0.99940747f, 0.85999680f, 0.70070124f, 
    1.00591004f, -0.57746291f, -0.15269651f, -0.18901405f, 0.97638345f, 1.29742169f, 0.32715681f, -1.05532074f, 
    -0.17851511f, -0.66968048f, 0.53162754f, -0.14611267f, 0.32767233f, -0.09416680f, -1.03895164f, -1.04765320f, 
    0.49353534f, -0.98328125f, -0.39046067f, -0.51706499f, 0.03816812f, -0.04468245f, -1.10017121f, -1.41643667f, 
    -0.43597931f, 0.14328153f, -0.49577060f, 0.83906561f, 0.29892173f, -0.13942030f, 0.40010834f, 0.85717094f, 
    -1.38378632f, 0.17867967f, -1.29211092f, -0.06392860f, 0.41089007f, 0.29957795f, 0.42241776f, 0.40062022f, 
    1.00576735f, 0.59499556f, 0.12089967f, 0.12455013f, -0.50399661f, 0.44640410f, 0.55700535f, 0.61087453f, 
    -0.27237758f, 0.34016696f, 0.13911852f, -0.14132090f, -0.32044196f, -1.39058244f, -1.28019655f, -0.25040790f, 
    -0.55438912f, 0.24837479f, 1.33906412f, 0.22750646f, -0.09812534f, 0.52915138f, 0.59965634f, -0.40030244f, 
    0.60770148f, -0.28371400f, -0.74311495f, -0.92466605f, -1.05639148f, -0.39541790f, 0.08315895f, -0.54760426f, 
    -0.79108113f, 0.88376969f, 0.34186599f, -0.17370646f, -0.68188971f, -0.60834879f, -1.04807532f, -0.18006214f, 
    1.19335938f, 0.37898937f, -0.05287600f, -0.54175085f, -0.05683493f, -0.08114388f, 1.36380672f, -1.28849339f, 
    0.56920207f, 0.55809194f, -1.01154494f, 0.07487776f, 0.46294117f, -0.22770452f, 1.19318628f, 0.56952304f, 
    0.97320998f, 0.78480536f, 0.75827909f, -0.07245108f, 0.02593714f, 0.53074151f, 0.01970252f, 1.18379998f, 
    0.29909572f, 0.56709725f, 0.73506284f, -1.20481634f, 0.58592081f, 0.33821288f, -0.31851673f, 0.17595771f, 
    -0.03073431f, 0.28552124f, -0.72798228f, 1.13204885f, 0.79550189f, 0.90884775f, 0.90058351f, -0.20636480f, 
    0.38170412f, 0.91923285f, 1.28126347f, -0.39750481f, 1.22442722f, -0.06413519f, -0.30336389f, -0.50365639f, 
    0.04107840f, -0.41495156f, -0.63142288f, 0.80967051f, -0.60245776f, -0.11862335f, -0.70906436f, -1.09607685f, 
    -0.23633736f, -0.34805855f, -0.08554351f, -0.18975869f, -1.26605630f, -0.64734453f, -1.10763800f, 0.89392239f, 
    -0.85665971f, 0.40536287f, 0.15762293f, -0.07761728f, 0.78852683f, 0.52216703f, 0.13350315f, -0.41167545f, 
    0.90994924f, 1.36699486f, -0.87079114f, 0.53700411f, -0.39602339f, 1.08868325f, -0.42449474f, 0.38480788f, 
    -1.18507552f, 0.39164755f, -0.73451477f, -0.29480141f, 0.23144883f, 0.18864274f, -1.17119217f, -0.39444169f, 
    1.07595348f, -0.25553155f, -0.07667568f, -0.19472830f, 0.29478624f, 0.62044215f, 0.42020932f, 0.99255979f, 
    0.61208773f, 1.10735881f, -0.16712183f, -0.98418540f, 0.77477789f, -0.82705009f, -0.15719175f, -0.05376178f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17958444f, -0.00738268f, -0.18295044f, -0.21937086f, -0.07974324f, -0.19104406f, 0.38249162f, 0.08131537f, 
    0.18040392f, 0.29333115f, -0.03749902f, -0.09951396f, -0.18824182f, 0.23969297f, 0.30500636f, -0.14009336f, 
    0.16651170f, 0.37406346f, -0.01489034f, 0.18183373f, -0.10678070f, 0.09032511f, 0.66677278f, 0.20085125f, 
    0.02904757f, 0.02504762f, 0.38065282f, 0.09101677f, -0.17436619f, -0.26997882f, -0.20245650f, 0.09570344f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.32411644f, 0.22958751f, -0.16063914f, 0.06134614f, 0.09019779f, 0.07223257f, -0.02447331f, -0.09245858f, 
    -0.04234345f, 0.21477515f, -0.10247035f, -0.04307609f, -0.16066134f, -0.08528890f, -0.15326236f, -0.08759952f, 
    -0.09531213f, 0.04005158f, 0.14428899f, 0.18606777f, -0.13493606f, -0.13895652f, -0.01327743f, -0.05338438f, 
    -0.11798957f, -0.06532879f, 0.10566449f, 0.27552781f, -0.06712608f, -0.08175968f, -0.09513430f, 0.02267316f, 
    -0.03497423f, 0.14522414f, -0.14225465f, 0.06334791f, 0.05949453f, -0.11225508f, -0.09759045f, 0.22100455f, 
    0.08673634f, -0.32127589f, -0.11803955f, -0.16693626f, -0.11430462f, -0.50565845f, -0.02687730f, -0.20558426f, 
    -0.01064260f, 0.09304143f, 0.09792487f, -0.27499542f, 0.09153097f, 0.20438880f, -0.26303595f, -0.05202599f, 
    0.04447219f, 0.04292415f, 0.06901971f, -0.10217913f, 0.13805635f, -0.00184894f, 0.07217551f, 0.13430643f, 
    0.23985249f, 0.10527991f, -0.07185172f, 0.22489776f, -0.40139040f, 0.04925708f, -0.02890939f, 0.06189774f, 
    0.00589179f, 0.15872040f, -0.19681817f, -0.10686556f, -0.02708714f, 0.01661749f, -0.00965188f, -0.13504784f, 
    0.03261056f, 0.30603245f, -0.02225200f, -0.09586798f, -0.16056019f, 0.10991676f, 0.18929334f, -0.00600042f, 
    -0.12437911f, 0.14816794f, 0.05567268f, -0.12899515f, 0.05703961f, 0.03130383f, -0.05115996f, 0.32461971f, 
    0.07026937f, 0.01718459f, -0.14323078f, -0.14657210f, -0.22600305f, -0.20143466f, 0.19709137f, -0.06957602f, 
    -0.13928168f, -0.04520505f, 0.00885634f, 0.19959512f, 0.37214947f, -0.12185530f, 0.01078924f, 0.28591788f, 
    0.03774758f, 0.20762974f, -0.22642884f, 0.01981548f, 0.04318814f, 0.25918290f, 0.20872651f, -0.06644398f, 
    -0.12707062f, 0.09263541f, 0.01967372f, -0.04300050f, -0.02623287f, 0.00569499f, -0.12423278f, 0.39932743f, 
    -0.02300287f, -0.06721453f, 0.12280679f, -0.08135907f, 0.15156484f, 0.03025269f, 0.11150131f, -0.38052991f, 
    0.13556027f, -0.06049821f, 0.14837161f, -0.16977800f, 0.26911941f, 0.21830048f, 0.02247098f, -0.01948813f, 
    0.07712719f, -0.17345457f, 0.05985735f, 0.16473025f, 0.09138724f, -0.02576940f, 0.15590915f, 0.03736230f, 
    0.07089195f, 0.04895536f, -0.12064626f, -0.12704746f, 0.03862660f, 0.17908828f, 0.12065453f, -0.30623326f, 
    -0.06170446f, -0.28357884f, 0.04298626f, -0.46642116f, -0.13343221f, 0.17537725f, 0.26142547f, -0.03275013f, 
    0.01136732f, 0.02000427f, 0.26796553f, -0.01147492f, 0.35699373f, -0.26474547f, -0.10670520f, 0.06381382f, 
    0.20079422f, -0.06187786f, 0.17781733f, -0.02782126f, 0.08159897f, -0.15560022f, -0.02236354f, 0.12708001f, 
    0.15945069f, -0.36364314f, 0.09293082f, -0.15903525f, -0.02218008f, 0.04951868f, -0.14418985f, -0.19857714f, 
    0.04660954f, 0.06405777f, 0.07030991f, 0.13944077f, -0.07641040f, -0.06044060f, 0.04983138f, -0.19158638f, 
    0.05904444f, 0.10580710f, 0.16627233f, -0.28040287f, 0.16436858f, -0.02680773f, 0.22789612f, 0.27568430f, 
    -0.10025118f, -0.02232626f, 0.12889880f, -0.03664259f, 0.10642946f, 0.24468429f, 0.03500750f, 0.05051837f, 
    0.18769112f, -0.16681975f, 0.11809837f, -0.04090834f, -0.10538597f, -0.25480133f, 0.30970326f, -0.03980996f, 
    -0.04150576f, 0.04200067f, 0.07736713f, -0.13738148f, 0.04179972f, 0.04013843f, -0.18727930f, 0.06954796f, 
    -0.18887419f, 0.25711343f, -0.04843941f, -0.01413197f, 0.03351067f, -0.07865802f, 0.05917151f, 0.27576339f, 
    -0.07434438f, -0.01902466f, -0.51358306f, -0.20194255f, 0.10459963f, -0.01411468f, 0.23428087f, 0.18643492f, 
    0.04641949f, 0.09767181f, -0.07643041f, -0.12756868f, -0.18263544f, 0.24574070f, -0.00499647f, 0.32686636f, 
    -0.18731011f, -0.18614241f, 0.00634062f, -0.05950995f, -0.06980921f, -0.14223248f, -0.13516821f, -0.21398987f, 
    0.22908081f, 0.01333665f, 0.06085857f, -0.05241685f, -0.09201960f, -0.05851538f, 0.23379250f, 0.25722989f, 
    -0.33743173f, -0.04542623f, -0.02954803f, 0.07033351f, -0.27536795f, 0.05756113f, -0.09721664f, 0.11358344f, 
    0.16464117f, -0.19947283f, 0.12629516f, -0.07703296f, 0.17383273f, -0.10860161f, -0.10304458f, 0.15509948f, 
    0.05699809f, -0.25404340f, 0.24371761f, 0.04220681f, 0.14599186f, 0.04384096f, 0.07710823f, 0.17070073f, 
    -0.15355068f, 0.33273983f, 0.47154769f, 0.21254107f, 0.14951417f, 0.09226830f, -0.03044327f, -0.05115451f, 
    -0.01517329f, 0.13623117f, 0.56161785f, 0.09483994f, -0.26267266f, 0.02112250f, -0.09461044f, 0.16582900f, 
    -0.26535872f, 0.10046494f, 0.03010731f, -0.20002925f, 0.21104532f, -0.43229055f, 0.21995546f, 0.03108366f, 
    0.13221928f, -0.11914550f, -0.00183191f, -0.13781832f, 0.05206368f, 0.04801361f, -0.19949657f, 0.19731529f, 
    0.23707254f, -0.04204492f, 0.02747426f, 0.05266733f, 0.01675444f, -0.03223283f, -0.05889306f, 0.06660655f, 
    -0.21271284f, 0.15026230f, 0.04809622f, -0.09180474f, 0.24878831f, 0.02077746f, -0.07500229f, -0.21533225f, 
    0.13912864f, -0.06161831f, 0.00665044f, -0.15470856f, 0.01754159f, 0.12539589f, 0.07657033f, 0.24147928f, 
    0.13353494f, 0.32117781f, 0.05862425f, 0.01186088f, 0.01815119f, 0.19557729f, 0.13028590f, 0.08401575f, 
    0.12897207f, 0.03103681f, 0.16298857f, 0.18274912f, -0.18144283f, 0.04684227f, -0.16824086f, -0.14216235f, 
    0.02991320f, -0.30277047f, -0.41023108f, -0.20831597f, -0.43164930f, 0.00438269f, -0.14334910f, -0.12526132f, 
    -0.05469549f, 0.14624505f, 0.03550352f, -0.04096509f, -0.12580255f, -0.21232770f, -0.06567473f, -0.16962466f, 
    0.08139081f, -0.02969451f, -0.11600634f, 0.40585250f, -0.18401098f, -0.08111557f, -0.02826547f, 0.12240174f, 
    -0.22191441f, 0.01612823f, -0.14626031f, 0.06299743f, -0.21510926f, -0.01121022f, -0.18821208f, -0.38426200f, 
    -0.11113355f, 0.03974066f, -0.05156174f, 0.01266704f, -0.08552638f, 0.39290398f, 0.22189066f, 0.14125443f, 
    0.10648391f, 0.05378134f, 0.09919436f, -0.08540270f, -0.22005638f, -0.25601766f, -0.07162209f, -0.05832131f, 
    0.24181004f, 0.00469133f, -0.01285255f, -0.08927903f, 0.12739584f, 0.19283304f, -0.06728239f, 0.39645284f, 
    0.03563998f, -0.09614309f, -0.10425644f, -0.12197530f, 0.10685553f, 0.03637049f, -0.22276674f, 0.04746835f, 
    -0.36549860f, -0.02849253f, 0.26565111f, 0.00660567f, -0.08459949f, -0.01356735f, 0.03524248f, -0.09048028f, 
    -0.05656258f, 0.05930978f, -0.21549429f, -0.15287943f, -0.23944388f, -0.10941085f, -0.09927508f, -0.12413374f, 
    -0.04196999f, -0.00724764f, -0.22001104f, -0.13710839f, -0.04000603f, -0.18418624f, 0.04105452f, -0.11128227f, 
    -0.04714530f, -0.06359885f, -0.04303293f, 0.21362133f, 0.19145475f, 0.03531683f, 0.05578201f, -0.10296907f, 
    0.03431213f, -0.03844790f, 0.00737657f, -0.23756391f, 0.31889510f, 0.20613645f, 0.16168472f, 0.20178874f, 
    0.25153574f, -0.12890959f, -0.28975385f, 0.01027995f, 0.09704275f, -0.32425609f, 0.25391513f, -0.13863327f, 
    0.02583556f, -0.21208315f, 0.00557530f, 0.05487717f, 0.01427518f, 0.06163571f, -0.11405641f, -0.03780790f, 
    0.13293600f, 0.03591520f, 0.09815068f, -0.10601884f, -0.04409773f, -0.00031023f, -0.17296180f, 0.25076145f, 
    -0.00445582f, -0.17288007f, -0.06350115f, -0.09325845f, 0.00774524f, -0.17067634f, 0.07792091f, -0.25238699f, 
    -0.10332579f, -0.41363972f, 0.16779934f, -0.00609602f, 0.07747655f, -0.35638437f, 0.21336289f, 0.00536609f, 
    -0.08330017f, 0.62220985f, 0.31770471f, -0.17251229f, -0.05994449f, -0.04790710f, -0.00520066f, -0.06918214f, 
    0.02339525f, 0.02239252f, -0.13897932f, -0.16433869f, -0.00803586f, -0.17063566f, -0.18596439f, 0.03501768f, 
    0.09130302f, 0.03979452f, 0.03274332f, 0.33746439f, 0.24361545f, 0.19287243f, 0.03925491f, 0.07185773f, 
    -0.23324908f, -0.12821677f, 0.01155390f, -0.19980611f, -0.08079097f, -0.11499348f, 0.06970878f, 0.19594765f, 
    -0.06238031f, -0.16468042f, 0.03904266f, 0.01037917f, 0.02226913f, 0.40928736f, -0.36146364f, 0.00869992f, 
    -0.16196457f, -0.14557552f, 0.03918355f, -0.06119668f, -0.04919735f, -0.03935234f, 0.31515965f, -0.20543088f, 
    -0.08904483f, 0.01954642f, -0.16737559f, -0.05431601f, 0.10732183f, 0.01414871f, 0.14615241f, 0.40912917f, 
    0.02244607f, -0.00480790f, -0.00698050f, -0.03365055f, 0.12905794f, -0.04135632f, 0.15925512f, 0.04412714f, 
    -0.22273180f, 0.05000499f, 0.08816693f, -0.00662417f, 0.23015977f, 0.08034082f, -0.06925645f, 0.11156248f, 
    0.04793249f, -0.15078287f, 0.07507895f, 0.20260154f, 0.09974543f, -0.11009833f, 0.20731261f, -0.06960055f, 
    -0.00854375f, 0.20752749f, 0.44206631f, 0.21981402f, 0.12276450f, 0.18824823f, 0.01861525f, 0.11544499f, 
    0.19865464f, 0.02953327f, -0.19982179f, -0.24905486f, 0.05285139f, 0.02300702f, 0.42758182f, -0.14902496f, 
    0.09602603f, -0.07967380f, 0.02726339f, -0.04724333f, -0.14153974f, 0.02957236f, -0.04711563f, 0.10593275f, 
    -0.29088581f, 0.12639330f, 0.09517235f, 0.04759077f, -0.03950877f, 0.33807003f, 0.21663983f, 0.24243946f, 
    -0.10356171f, -0.17241979f, 0.07589301f, 0.14899828f, -0.04809245f, -0.14973509f, 0.23808156f, -0.04629812f, 
    -0.16294505f, 0.06848364f, 0.09382129f, 0.02184127f, -0.04909291f, 0.07539734f, -0.40428019f, 0.00927379f, 
    -0.16087590f, 0.35683176f, 0.11267362f, 0.19929259f, 0.04449242f, -0.16365948f, 0.08047343f, 0.04375287f, 
    -0.20387903f, 0.15725264f, 0.20547062f, 0.06706946f, -0.08208071f, -0.04501588f, -0.10634403f, -0.01639549f, 
    0.01584093f, -0.42713711f, -0.11939815f, 0.01073149f, 0.10385124f, -0.00511354f, 0.04254346f, 0.01748901f, 
    -0.10305633f, 0.07504426f, -0.04631274f, 0.07441571f, -0.09496466f, -0.07014999f, -0.02156917f, -0.35320410f, 
    -0.03209147f, 0.12532833f, -0.11963414f, 0.05012063f, -0.18677242f, 0.02290190f, 0.10022004f, 0.09043517f, 
    0.16232392f, 0.22461621f, 0.04253049f, -0.40326744f, -0.55125946f, -0.08192050f, 0.12910502f, 0.13364162f, 
    0.00253582f, -0.13687202f, -0.04150495f, 0.05815301f, 0.08977791f, 0.20574546f, 0.13629019f, 0.21764845f, 
    0.01032420f, -0.13549167f, -0.07141671f, -0.00336265f, -0.00543648f, 0.31063795f, 0.13083577f, -0.14735456f, 
    0.12428849f, -0.02829062f, 0.15713084f, -0.26814905f, -0.06903303f, -0.05649665f, -0.06794589f, 0.00163866f, 
    -0.17393014f, -0.00715890f, -0.17030595f, 0.08410570f, -0.05603681f, 0.02911713f, -0.01370457f, -0.25564185f, 
    -0.23962031f, -0.07894639f, -0.17981750f, -0.00184792f, 0.08603121f, -0.07825171f, -0.07626332f, 0.07671545f, 
    -0.23349856f, 0.24671540f, 0.10534638f, -0.11587090f, 0.08665610f, -0.10461813f, -0.07050881f, 0.09693509f, 
    0.04413248f, 0.00213275f, -0.05181798f, 0.03143369f, -0.05431385f, 0.02358009f, 0.03720338f, 0.22037444f, 
    0.01018899f, 0.03176013f, -0.12419043f, -0.09759030f, 0.06135822f, 0.11577337f, 0.01418931f, 0.02228052f, 
    -0.06282565f, 0.08992539f, 0.08321825f, 0.08292268f, -0.22249134f, -0.03869595f, 0.20856480f, 0.01531787f, 
    -0.01152935f, 0.09135780f, 0.05707077f, -0.08859373f, 0.14824823f, 0.54934311f, 0.31520182f, 0.24857068f, 
    -0.05980778f, -0.08961541f, 0.10771123f, -0.03491215f, -0.03949534f, -0.00325114f, -0.22579494f, -0.19969335f, 
    -0.32804793f, 0.10720558f, 0.07571641f, 0.22864674f, -0.00655763f, 0.13298866f, -0.36478245f, 0.01659102f, 
    0.09916017f, -0.32237038f, -0.00292407f, 0.14991686f, 0.01016878f, -0.05782429f, -0.08917475f, -0.24176067f, 
    -0.03010950f, -0.00129273f, -0.03075711f, 0.10638219f, 0.02294051f, 0.05430863f, -0.12622593f, -0.03309503f, 
    -0.06346130f, 0.25454602f, 0.28972292f, -0.00196550f, 0.09800735f, 0.03650455f, 0.09728683f, 0.00027687f, 
    0.16872826f, -0.16957806f, 0.56338292f, 0.08011498f, 0.04858733f, -0.00513329f, -0.09479092f, 0.00103429f, 
    0.01590426f, 0.09715276f, 0.17322800f, -0.11891816f, 0.11011456f, 0.17273046f, 0.00880399f, 0.01037443f, 
    -0.12362362f, -0.20403777f, 0.07881755f, 0.09379882f, -0.22974975f, 0.01611128f, -0.02430659f, 0.10229800f, 
    0.03488957f, 0.27538070f, 0.00496281f, 0.15933444f, -0.32395837f, -0.24641153f, 0.25563100f, 0.08680597f, 
    -0.30821091f, 0.06852506f, -0.14136690f, 0.05086599f, 0.08177591f, 0.33288819f, 0.05081180f, -0.01376402f, 
    -0.10430693f, 0.15465398f, -0.15887986f, 0.08834007f, 0.22021618f, 0.11410937f, -0.03853839f, 0.11376245f, 
    -0.49199629f, -0.09222022f, 0.14572448f, 0.19925627f, 0.07409783f, 0.17330642f, -0.00400176f, -0.19262369f, 
    -0.04063275f, 0.10543934f, -0.03605237f, -0.27550468f, 0.03193802f, 0.06665561f, -0.11994079f, 0.07236747f, 
    -0.07138295f, -0.70976645f, -0.07251818f, -0.10275612f, 0.10990790f, -0.05259559f, 0.20469557f, -0.05024360f, 
    0.16370852f, -0.04491332f, -0.24647012f, 0.15322112f, 0.03122562f, 0.08104106f, 0.04819679f, -0.08674349f, 
    0.09795806f, 0.00402456f, 0.10886862f, -0.08874424f, -0.06213784f, -0.16518266f, 0.03031838f, 0.07368740f, 
    -0.08622081f, -0.04482728f, -0.01654714f, -0.32842472f, -0.47349209f, -0.49314132f, 0.13059270f, 0.18551001f, 
    0.17629325f, 0.24015021f, -0.25805318f, 0.06167523f, -0.12015518f, -0.67647529f, -0.33262634f, -0.02715972f, 
    -0.13831246f, 0.13959585f, -0.08325323f, 0.01925997f, -0.14291446f, 0.04977210f, -0.20044810f, -0.24450427f, 
    0.04107848f, 0.29704654f, 0.28422710f, 0.27017677f, 0.01833849f, 0.23270087f, -0.00226849f, -0.00215525f, 
    0.04565766f, -0.05058917f, -0.00962577f, 0.07012625f, 0.06220080f, 0.05958173f, 0.06350026f, 0.13656491f, 
    -0.16341816f, -0.01494766f, -0.50874937f, -0.05176853f, -0.03168650f, 0.04057142f, -0.08918221f, 0.04521832f, 
    -0.18060978f, 0.88337237f, 0.24053736f, -0.11571203f, -0.18920812f, -0.01708718f, -0.17827648f, 0.06115142f, 
    -0.08109714f, 0.01381390f, 0.27282307f, -0.22788063f, -0.07955767f, 0.04007970f, 0.04969237f, 0.17297845f, 
    0.16030073f, -0.12609150f, -0.22963285f, -0.09543270f, -0.40256855f, 0.04040090f, 0.33351922f, 0.33587545f, 
    0.01627406f, 0.05101522f, 0.05859728f, 0.00530217f, 0.92615294f, 0.46460521f, -0.11608715f, -0.04812388f, 
    -0.11604144f, 0.03812712f, 0.15947394f, 0.07985444f, 0.12393718f, 0.21601240f, 0.09510854f, -0.27517897f, 
    -0.18844876f, -0.03063395f, -0.10108435f, 0.00965641f, 0.14216319f, 0.12117113f, -0.12039115f, 0.26931190f, 
    -0.04540401f, -0.05097953f, 0.07762311f, 0.16250442f, 0.17302985f, 0.06507345f, 0.26390851f, -0.18095827f, 
    -0.01286535f, 0.02933945f, -0.03567250f, -0.14919856f, 0.08788402f, -0.00327579f, 0.10551763f, -0.27252311f, 
    0.43064052f, -0.19701193f, 0.05627285f, 0.04780479f, -0.10830097f, 0.25345469f, 0.20729046f, 0.19942757f, 
    0.03159334f, 0.21118626f, 0.04715910f, -0.31575122f, 0.04335530f, 0.03068312f, -0.08182707f, 0.01718871f, 
    -0.00217922f, 0.10554821f, 0.17045860f, -0.23343025f, 0.00909441f, 0.18579407f, -0.01025325f, 0.01044030f, 
    -0.03059805f, 0.07472854f, 0.05950616f, 0.10312219f, -0.09862388f, -0.32617593f, -0.14374360f, -0.17061518f, 
    -0.02974194f, -0.00609637f, -0.00669802f, -0.06855907f, -0.21328309f, -0.02591177f, 0.25636125f, 0.09077740f, 
    0.03681065f, -0.01449214f, -0.15105967f, 0.12422654f, -0.11271599f, 0.01031713f, -0.14492920f, 0.33874965f, 
    0.15523931f, 0.11853024f, -0.16186388f, -0.00083026f, -0.13984586f, -0.04666294f, 0.08858144f, -0.24024172f, 
    0.03459415f, 0.02397694f, 0.12930930f, 0.13314238f, 0.01105766f, 0.22349262f, 0.12469652f, 0.35906786f, 
    -0.13025549f, 0.03988358f, 0.10316194f, -0.09300265f, 0.16574243f, -0.05439688f, 0.13330536f, 0.05640824f, 
    -0.19619705f, -0.38270268f, 0.18807045f, 0.17403714f, 0.30900735f, 0.01431309f, -0.16782281f, 0.01206104f, 
    -0.32140285f, 0.24911737f, 0.04685866f, -0.06150959f, 0.25534186f, 0.02219947f, -0.02778283f, 0.14251584f, 
    -0.16812243f, 0.07385834f, 0.00746726f, -0.08421789f, -0.04407067f, 0.00318992f, 0.02566129f, -0.17438762f, 
    0.07810424f, -0.13875760f, 0.18409507f, -0.06915057f, 0.05975754f, -0.29498446f, 0.11121835f, 0.12410823f, 
    0.01474536f, -0.16543952f, 0.18554872f, -0.00068681f, -0.53826982f, -0.02794754f, -0.03701828f, 0.05742483f, 
    -0.27328900f, 0.07108991f, -0.01705175f, 0.03127638f, 0.15897711f, -0.04214416f, 0.03120699f, -0.13386677f, 
    -0.06603407f, -0.10591424f, 0.05656840f, -0.07255457f, 0.05045224f, -0.02716419f, -0.11015207f, 0.01214412f, 
    -0.21474579f, -0.14425753f, 0.01663879f, 0.14893228f, -0.14016017f, 0.01203332f, -0.13687992f, 0.55623108f, 
    0.12504953f, 0.00358095f, -0.00220553f, -0.17711970f, 0.11815494f, 0.21203685f, -0.00939920f, 0.34212261f, 
    -0.03624447f, -0.01824653f, 0.04648291f, -0.06742460f, -0.03298007f, 0.02237061f, -0.04696385f, -0.03179346f, 
    -0.06039475f, 0.05286027f, -0.01395871f, -0.00852081f, -0.00645186f, -0.04024908f, -0.05797868f, -0.03393333f, 
    0.02900780f, -0.01597542f, 0.00724847f, 0.03332726f, 0.00075538f, -0.05210929f, -0.03292565f, 0.05471345f, 
    0.03624103f, -0.00923293f, 0.04077806f, -0.05772576f, -0.05250726f, -0.02674076f, 0.04175294f, 0.00350612f, 
    0.01625651f, 0.02081742f, 0.00680924f, 0.02975026f, -0.05526213f, 0.01305475f, 0.00032845f, -0.01502276f, 
    0.02106791f, -0.03642473f, 0.00563903f, -0.05726400f, 0.01260397f, -0.02772885f, -0.00554775f, -0.06779130f, 
    0.05058857f, -0.02783407f, -0.03293175f, -0.06406895f, -0.02905514f, -0.05049839f, -0.04227342f, -0.00546552f, 
    0.05449086f, 0.03194278f, -0.06183115f, -0.04298867f, 0.05083763f, 0.03229951f, -0.01539706f, 0.03077101f, 
    0.02701788f, 0.03284819f, -0.04023057f, -0.04776309f, -0.04755808f, -0.03227075f, -0.01018820f, 0.02869260f, 
    -0.02479370f, 0.01174391f, -0.06206993f, -0.05269564f, -0.03815766f, -0.03224702f, 0.00627730f, 0.03880773f, 
    0.03842611f, 0.00808471f, -0.01880542f, -0.03090447f, -0.05276665f, -0.00966317f, -0.06131706f, -0.03499296f, 
    -0.06090391f, 0.01219824f, 0.02154674f, 0.01391894f, -0.05312352f, -0.00547369f, 0.00768644f, 0.03387904f, 
    -0.02276053f, 0.04921047f, -0.04880805f, -0.04239901f, -0.02405657f, 0.01099429f, 0.01973341f, 0.02375834f, 
    -0.05917766f, -0.00019732f, -0.01810202f, 0.03574479f, 0.04008388f, -0.06518866f, -0.02507183f, -0.01654340f, 
    0.00813456f, -0.06237338f, 0.03176039f, 0.05354949f, -0.05695168f, -0.05942694f, -0.00433955f, 0.02737950f, 
    -0.01854499f, -0.04265396f, 0.02161568f, 0.00565769f, 0.03286852f, -0.04820197f, 0.04437744f, 0.03192730f, 
    -0.01393861f, -0.00164654f, -0.02752648f, 0.05091617f, -0.02687989f, 0.01540047f, 0.02202434f, 0.03948253f, 
    -0.02952578f, -0.05499673f, -0.04075205f, -0.05297129f, 0.04724641f, -0.05879535f, 0.01092456f, -0.01321502f, 
    -0.02570810f, -0.01070947f, -0.02142403f, -0.02864896f, 0.03655341f, -0.04218322f, 0.03583259f, -0.03092576f, 
    -0.03842293f, 0.02695031f, -0.01307022f, 0.00598650f, -0.04477782f, 0.00572476f, -0.03025554f, 0.00661809f, 
    -0.01640658f, -0.05393580f, 0.02028673f, -0.03882280f, 0.02905988f, 0.00302658f, -0.06960545f, 0.01862192f, 
    -0.05489331f, 0.01030885f, 0.02724572f, 0.01728865f, -0.04580778f, -0.03524877f, -0.04449734f, 0.02328048f, 
    0.02839511f, -0.04437295f, -0.01337370f, -0.02883044f, -0.03158880f, -0.00148071f, 0.04279783f, 0.00785312f, 
    0.00166474f, 0.04330689f, -0.02193843f, 0.03334393f, 0.00063989f, 0.05031499f, -0.00683106f, 0.03747427f, 
    0.04958110f, -0.01069091f, 0.02812547f, 0.04214767f, -0.03397458f, -0.00308668f, -0.02699200f, 0.00119558f, 
    -0.01954370f, 0.00234704f, -0.04360249f, -0.00544043f, 0.00156692f, 0.01283719f, 0.01412431f, -0.01960829f, 
    -0.00664350f, 0.00796717f, 0.02579590f, -0.04437211f, -0.01572209f, 0.02210683f, 0.00828632f, -0.03896868f, 
    -0.03305544f, 0.01712892f, -0.02501785f, 0.04448424f, -0.06119297f, -0.01566654f, -0.00427541f, 0.02972984f, 
    -0.03421040f, -0.05589807f, -0.01831478f, -0.05752980f, -0.03026344f, 0.00736200f, -0.04426993f, -0.05510716f, 
    0.00809318f, -0.03908548f, 0.01477033f, 0.00616964f, 0.02314063f, 0.05135416f, 0.05255807f, -0.00900031f, 
    -0.00331068f, 0.04317362f, 0.01443966f, -0.03420846f, -0.05069618f, -0.02175745f, -0.02108815f, -0.04053309f, 
    -0.06157921f, -0.01863957f, 0.00033976f, -0.01127835f, 0.02133468f, 0.00594813f, 0.02824265f, -0.04399443f, 
    -0.04918604f, -0.04616058f, 0.04515400f, 0.03984730f, -0.06375389f, -0.03070624f, -0.02747941f, -0.02444127f, 
    0.02667877f, -0.03143495f, 0.03508118f, -0.06108732f, -0.02529181f, 0.02829855f, 0.01715755f, -0.05105998f, 
    -0.02526302f, 0.01356508f, 0.04571904f, -0.04454041f, 0.03911255f, -0.00771318f, -0.04172475f, 0.04673208f, 
    -0.04321025f, -0.03776738f, 0.03248800f, -0.00131942f, 0.02302556f, -0.04474461f, -0.04815775f, -0.05446769f, 
    -0.37852716f, -0.29135215f, -0.26165780f, 0.25057104f, 0.25147086f, 0.14867537f, 0.05972777f, -0.01322321f, 
    -0.05147567f, 0.12453981f, -0.04201472f, -0.05621725f, 0.13184527f, -0.02464624f, 0.11996710f, -0.01108254f, 
    0.00234013f, -0.02327018f, 0.15780485f, -0.32555884f, 0.29808524f, 0.11014657f, -0.12551023f, -0.15094309f, 
    0.10921402f, 0.01474243f, 0.25860977f, -0.06145805f, -0.05446003f, -0.06621654f, 0.09200501f, 0.09198906f, 
    -0.01259258f, 0.03310231f, -0.12198273f, -0.14637539f, -0.17217456f, -0.11136708f, 0.03832844f, 0.09161834f, 
    0.09829529f, -0.04600606f, 0.10148431f, -0.10923754f, -0.10137851f, 0.17655043f, -0.02014906f, 0.26100430f, 
    -0.01435382f, -0.15641198f, -0.17229901f, -0.04474036f, 0.09653538f, 0.14313024f, -0.46821523f, -0.14847596f, 
    0.07466762f, 0.11290008f, -0.04703476f, 0.25570902f, -0.02519443f, -0.23671995f, -0.02699390f, -0.33026966f, 
    -0.17964803f, -0.02025415f, 0.03825905f, 0.18345784f, -0.08930761f, -0.13324226f, -0.02207841f, 0.14538501f, 
    0.21209367f, -0.01212826f, -0.17695636f, 0.21259773f, -0.04590521f, -0.03231895f, 0.18839358f, -0.09497450f, 
    0.06519993f, 0.05128273f, 0.34847176f, 0.36475176f, 0.00676404f, 0.22035135f, 0.15449089f, -0.03866411f, 
    0.06361091f, 0.04777094f, 0.27261737f, 0.00699735f, -0.00423838f, -0.07204463f, 0.00406043f, 0.07144225f, 
    -0.12496158f, -0.08292250f, 0.21224068f, 0.27570707f, 0.00975646f, 0.29410312f, 0.07214464f, -0.03359460f, 
    -0.06020186f, -0.04917936f, 0.00745672f, -0.15175396f, -0.23079145f, 0.13890514f, 0.34164402f, -0.05606765f, 
    0.01478224f, 0.15504040f, -0.17493637f, 0.04226452f, -0.05694393f, -0.07973156f, -0.03479182f, -0.23916160f, 
    0.06099105f, 0.19775830f, -0.30484048f, 0.13194433f, 0.13442446f, 0.24732505f, -0.63394952f, -0.49237832f, 
    -0.42698991f, 0.20135188f, 0.30560365f, 0.04329621f, 0.07945513f, 0.00820983f, -0.02763112f, -0.21667042f, 
    0.01689686f, -0.30638844f, -0.13425294f, -0.28975528f, 0.11824315f, 0.02024014f, -0.08252987f, 0.18375766f, 
    -0.23813832f, 0.08700433f, -0.01582893f, -0.04282080f, 0.06918891f, -0.02794842f, -0.02289181f, 0.01985859f, 
    -0.14097977f, 0.10874745f, 0.09097695f, -0.02318692f, -0.09753602f, 0.22473590f, -0.00984112f, 0.26401475f, 
    0.24988192f, 0.19923992f, -0.27115279f, -0.09920137f, 0.13794895f, -0.13535738f, 0.01624548f, 0.20073791f, 
    0.16844854f, 0.25942141f, 0.02823738f, -0.09429859f, 0.03002635f, -0.26021484f, 0.28387728f, 0.06547040f, 
    -0.05321082f, 0.15779757f, 0.05752151f, -0.12753640f, -0.50198764f, -0.36140597f, 0.05845181f, 0.14955543f, 
    0.00866379f, 0.03890583f, -0.02965987f, -0.18921329f, -0.04705681f, -0.57757205f, -0.03337992f, 0.15320872f, 
    -0.08916733f, 0.20933893f, -0.08914448f, -0.04007609f, -0.15396973f, 0.02650736f, -0.13418031f, 0.30845499f, 
    0.39494893f, 0.06539034f, 0.16919367f, 0.11241974f, 0.01230229f, -0.04050873f, 0.08005011f, -0.29551336f, 
    0.00243409f, 0.00176262f, 0.17506149f, 0.15118483f, 0.00932372f, 0.07693350f, -0.22367209f, -0.25786993f, 
    -0.21128604f, -0.01396674f, 0.08855962f, -0.00046189f, 0.02697556f, -0.08942739f, -0.03679479f, -0.27873889f, 
    -0.04889579f, -0.20226188f, 0.08044628f, 0.15180549f, 0.06249278f, 0.20135953f, 0.18032554f, -0.06480689f, 
    -0.11058449f, 0.08708508f, 0.12092748f, 0.29436591f, 0.13247387f, 0.11033050f, 0.03021381f, -0.00879088f, 
    0.08962402f, 0.32215998f, 0.13593520f, -0.30889446f, 0.07391167f, -0.14359213f, 0.30975959f, -0.07725093f, 
    0.12724666f, -0.03483348f, -0.04790049f, 0.03129014f, -0.26357856f, 0.07749728f, 0.09705788f, 0.17390029f, 
    0.05222098f, -0.07403890f, 0.02596110f, -0.16182792f, -0.12035739f, 0.03496480f, 0.17028175f, -0.00044654f, 
    -0.23799317f, -0.07144232f, 0.11820964f, -0.00462693f, -0.03496817f, 0.16544552f, -0.44590053f, -0.23852123f, 
    -0.32614994f, 0.18170998f, -0.12262168f, -0.12806718f, -0.00040354f, 0.01137122f, -0.00973277f, 0.16544101f, 
    0.29018784f, 0.12702399f, 0.04700023f, 0.38901442f, 0.11044440f, 0.18444838f, 0.11133485f, -0.09590910f, 
    -0.04562029f, -0.02994003f, 0.02201072f, -0.01347645f, 0.02717859f, 0.00124067f, 0.00732030f, -0.04804775f, 
    -0.01545229f, -0.04402776f, 0.03677238f, -0.02603872f, -0.03716968f, -0.00674340f, -0.03997778f, -0.01748328f, 
    -0.03252153f, 0.02923990f, -0.03307319f, -0.02248228f, 0.01275565f, 0.02693416f, -0.03408192f, -0.00878132f, 
    -0.01157963f, 0.02361502f, -0.03424174f, -0.03059208f, -0.03801759f, -0.05320909f, 0.00575605f, -0.04185743f, 
    -0.05771668f, -0.06358626f, 0.02938208f, -0.04995496f, 0.00913177f, 0.00114341f, -0.05628851f, -0.02050611f, 
    0.02753300f, 0.00695208f, -0.00167247f, 0.03266889f, -0.00419936f, -0.04955132f, -0.01307842f, 0.01379563f, 
    0.02796174f, 0.03140704f, 0.03836000f, 0.01462576f, -0.05962595f, 0.02151817f, 0.03673295f, 0.04922321f, 
    0.02534460f, 0.02238224f, -0.03458188f, 0.00636954f, 0.04016523f, -0.06449633f, 0.02455000f, -0.02709217f, 
    -0.03542384f, -0.03525297f, 0.05115413f, -0.03077071f, 0.04330993f, -0.03085431f, 0.02236660f, 0.01786936f, 
    -0.02414466f, -0.01957567f, -0.06103771f, 0.04821709f, 0.03248207f, -0.03708863f, -0.00580500f, 0.03572775f, 
    -0.05211914f, -0.01997307f, 0.00965635f, 0.05678448f, -0.01448018f, 0.01291685f, -0.04737359f, -0.05085725f, 
    0.00627067f, -0.04089116f, 0.04770172f, -0.02978765f, -0.03459373f, -0.04010957f, -0.05958775f, -0.04077734f, 
    0.02598843f, -0.00034778f, 0.01570313f, 0.00391287f, -0.03412926f, -0.00120964f, 0.01335169f, -0.02669101f, 
    -0.00022185f, 0.02563558f, 0.00480705f, -0.03471474f, -0.06208159f, 0.04604905f, 0.03259253f, 0.04497147f, 
    0.04071863f, -0.05824216f, -0.01602042f, 0.03473182f, 0.01927433f, 0.04971054f, 0.03795968f, 0.04135448f, 
    -0.01374017f, 0.03656526f, -0.05097416f, -0.04638228f, 0.03830513f, -0.03562016f, -0.02949105f, -0.00855285f, 
    -0.02155183f, 0.00936415f, -0.03972859f, -0.05224812f, -0.02502266f, 0.00687116f, 0.03502009f, -0.02856528f, 
    -0.00141596f, -0.04841756f, 0.03227507f, 0.02004672f, -0.00042475f, -0.05885379f, 0.00361222f, 0.00851858f, 
    -0.05147869f, 0.00565779f, 0.01025509f, -0.02730140f, 0.03295896f, 0.02325355f, -0.00066698f, -0.00597189f, 
    0.00952724f, -0.05616248f, -0.06094173f, 0.00304974f, 0.02253761f, 0.00367723f, 0.03315467f, 0.04757750f, 
    0.05443659f, -0.03781182f, -0.03538176f, -0.02574058f, -0.05408087f, 0.04278385f, -0.06343114f, -0.06132272f, 
    -0.06029666f, -0.05788274f, 0.00161860f, -0.03593233f, -0.02885480f, -0.00587037f, -0.03573135f, -0.05244040f, 
    -0.04938985f, -0.04974635f, 0.00380734f, -0.02137277f, -0.01568480f, 0.00753668f, -0.04389299f, -0.05580740f, 
    -0.06267034f, -0.05046624f, -0.02259633f, -0.00642992f, 0.03304774f, 0.04806812f, -0.05466905f, -0.04676181f, 
    -0.04031801f, 0.00497424f, 0.01283604f, 0.02927227f, -0.00504196f, 0.04970885f, 0.02297875f, -0.04666992f, 
    0.03940617f, -0.06005581f, -0.00797856f, 0.01583061f, -0.03375323f, -0.05421651f, 0.03937208f, -0.01080953f, 
    0.00860163f, 0.04286927f, -0.03429369f, -0.01232829f, -0.02587922f, -0.02132495f, 0.01921591f, -0.06059161f, 
    -0.04685986f, 0.03498558f, -0.02002543f, 0.01457072f, 0.03851467f, 0.00420243f, -0.04361669f, -0.03939714f, 
    0.02640154f, -0.03582090f, 0.03336830f, -0.03809752f, -0.00296704f, 0.02797974f, 0.02002206f, 0.04730189f, 
    -0.03604695f, -0.01777776f, 0.01215929f, 0.03755441f, -0.04086815f, 0.00279909f, -0.02489888f, -0.02768282f, 
    0.04009715f, -0.01044299f, 0.04524435f, 0.00376697f, -0.01836572f, -0.05736947f, 0.03068885f, -0.03528509f, 
    -0.03674078f, 0.05281672f, -0.06257270f, -0.04348981f, -0.04815512f, -0.01376099f, 0.04966540f, -0.06400960f, 
    0.00363318f, 0.00820306f, -0.03170381f, 0.03437040f, -0.00994258f, 0.01249199f, -0.05417616f, -0.02092099f, 
    -0.01104335f, -0.04517581f, 0.00966177f, -0.06172154f, 0.00086831f, -0.02710663f, -0.02840724f, -0.04961511f, 
    -0.04629011f, -0.00656939f, -0.00290781f, 0.04611822f, -0.01325295f, -0.01338435f, 0.02595980f, -0.00768812f, 
    0.04429096f, -0.00525688f, -0.01079931f, -0.05834273f, -0.05030517f, -0.04710640f, 0.03640610f, -0.06479207f, 
    0.04267212f, -0.01870503f, 0.04327210f, -0.01838835f, -0.02444410f, 0.02912672f, -0.00179508f, -0.04284995f, 
    0.04473202f, -0.02574938f, -0.03402278f, 0.01292585f, -0.06284246f, 0.00942557f, 0.02649564f, 0.04724781f, 
    -0.00902011f, 0.00711110f, -0.06389996f, 0.01258774f, -0.02134814f, -0.02776716f, 0.03312954f, 0.03979037f, 
    0.00096700f, -0.02633278f, -0.00807666f, -0.00266866f, -0.03288151f, -0.00615181f, 0.03921825f, 0.00665373f, 
    -0.00209006f, 0.03618450f, -0.02005657f, 0.05201883f, 0.00149483f, 0.00353663f, -0.00867783f, -0.02436917f, 
    0.04036448f, 0.00017144f, -0.03772423f, -0.00520073f, -0.05315860f, -0.02340770f, 0.01560361f, -0.02844949f, 
    0.01438252f, 0.00007805f, -0.03038500f, -0.03531525f, -0.06848025f, 0.02294790f, 0.04411627f, -0.04896268f, 
    -0.02708348f, 0.01202998f, 0.03689233f, 0.01483735f, 0.03592491f, 0.01046644f, -0.05261428f, 0.03170004f, 
    0.01961369f, -0.07012247f, -0.02552594f, -0.02066443f, 0.04270070f, -0.04309542f, -0.00634158f, -0.00928871f, 
    -0.02199255f, 0.01513097f, -0.05633663f, 0.04194181f, 0.02261916f, -0.00183630f, 0.00889687f, 0.04240992f, 
    0.04399047f, 0.04236692f, -0.05494244f, -0.06913324f, -0.01206727f, 0.01047395f, -0.03314686f, -0.01412038f, 
    -0.01435015f, -0.02329673f, -0.04404811f, -0.06723811f, -0.02783507f, -0.04845264f, -0.01145017f, -0.05108989f, 
    0.04011535f, 0.00381701f, 0.04417479f, 0.03688052f, 0.03740503f, -0.02581864f, -0.03995654f, -0.00685464f, 
    -0.05593445f, 0.01413186f, 0.04895590f, 0.02998839f, -0.00126215f, -0.02588169f, -0.02463399f, -0.01496770f, 
    0.05286921f, -0.02487029f, -0.05075241f, -0.05812144f, -0.03651096f, 0.03533841f, 0.02021817f, 0.03309311f, 
    0.02346960f, 0.03341446f, 0.01801851f, -0.00324041f, 0.03323501f, 0.03475398f, 0.03353400f, 0.00295308f, 
    -0.01662001f, -0.04718827f, 0.00326899f, 0.03125628f, -0.02767714f, -0.04557678f, -0.03052685f, -0.06240702f, 
    0.01341104f, -0.06747494f, 0.01071526f, -0.02959976f, 0.02663371f, 0.00654905f, -0.01707127f, -0.03785201f, 
    0.03322465f, -0.06064037f, -0.00134421f, 0.04636033f, 0.05302965f, -0.00465769f, 0.00834646f, -0.06613003f, 
    -0.05360513f, -0.06308272f, 0.02556368f, 0.00316331f, 0.00055474f, -0.04171170f, 0.01588275f, -0.01347461f, 
    0.03381795f, -0.04259273f, 0.01124554f, 0.04612592f, 0.04553663f, 0.04547159f, 0.03573526f, -0.04672117f, 
    0.01202451f, -0.04268168f, -0.05243320f, 0.01412925f, -0.02833225f, -0.04580033f, 0.00073521f, -0.00721562f, 
    0.00722965f, 0.00197036f, -0.04695079f, 0.01293876f, -0.02466103f, -0.00246287f, -0.06867334f, -0.05944355f, 
    0.00794777f, -0.03947053f, -0.01433783f, -0.01003832f, -0.02569806f, 0.03019597f, 0.00261362f, -0.00929787f, 
    -0.02306012f, -0.04532428f, 0.01745619f, -0.06955895f, 0.01613849f, -0.03342966f, -0.04389725f, -0.00995975f, 
    -0.00427266f, -0.04126617f, 0.02188754f, -0.03562453f, -0.06196698f, -0.04935399f, -0.00146121f, 0.02594789f, 
    -0.03163000f, -0.01983391f, -0.05157227f, -0.02218731f, -0.03278944f, -0.05526863f, -0.03439719f, -0.05291867f, 
    -0.02957558f, 0.03291268f, 0.00185379f, -0.02763111f, 0.04664224f, -0.03317463f, 0.00305850f, 0.01519541f, 
    -0.02744249f, 0.00041054f, 0.01322702f, -0.05357223f, 0.03323912f, 0.00789860f, -0.02639710f, 0.01021548f, 
    0.03220678f, 0.02712387f, -0.00695117f, -0.00059931f, -0.04184685f, -0.00606124f, -0.00524837f, 0.00721189f, 
    0.00904178f, 0.04567776f, -0.06966187f, -0.02702100f, 0.03254630f, -0.00617378f, -0.05789816f, 0.01981281f, 
    -0.04272967f, 0.02024684f, -0.01814345f, -0.06202444f, 0.04248764f, -0.01259769f, -0.04143229f, 0.02792864f, 
    -0.04742543f, -0.00201876f, -0.05739871f, -0.03104408f, -0.00256972f, -0.03890718f, 0.02661103f, -0.03556301f, 
    -0.04442934f, -0.03376908f, -0.06439902f, -0.03673784f, 0.02321237f, -0.06036065f, -0.01173682f, -0.04676857f, 
    0.03146118f, -0.05862575f, 0.00827062f, -0.06675490f, -0.02121019f, 0.03438434f, 0.01328398f, 0.02746780f, 
    0.01321688f, -0.03093832f, -0.00258724f, -0.05904216f, 0.04220296f, -0.05021250f, -0.05342593f, 0.05046785f, 
    -0.01961675f, -0.02571709f, 0.00508466f, -0.04157982f, -0.02373959f, -0.02769280f, 0.02768150f, 0.03369119f, 
    -0.02374666f, -0.03067587f, -0.03353604f, 0.01878128f, -0.04062766f, -0.06666924f, -0.00378586f, -0.03196160f, 
    -0.01714496f, -0.01405753f, 0.00933494f, -0.05310985f, 0.00448880f, -0.01369919f, -0.05023241f, -0.04485568f, 
    -0.06378195f, -0.01003911f, 0.02371751f, -0.00122187f, 0.03372850f, -0.02469305f, 0.03111203f, -0.06274583f, 
    -0.03259675f, 0.00158179f, 0.00068335f, 0.02115455f, -0.05168629f, -0.02432595f, -0.03680696f, 0.02533798f, 
    0.00416001f, 0.02871156f, -0.00231888f, -0.02165293f, -0.01302396f, -0.03566203f, -0.06185250f, -0.05187013f, 
    0.00060849f, -0.01047454f, 0.01346431f, -0.04532657f, -0.00245085f, -0.01407599f, -0.02678834f, -0.04660533f, 
    -0.02258211f, 0.04630376f, -0.06514519f, -0.03433748f, -0.02177278f, -0.07057640f, -0.05674936f, 0.04321722f, 
    -0.04084630f, -0.01207104f, 0.00357140f, -0.02984989f, 0.02946913f, -0.02690636f, -0.00061078f, -0.06181405f, 
    0.02125908f, -0.06050375f, -0.05872745f, 0.03880594f, -0.02636382f, -0.06445546f, -0.00606961f, -0.01094674f, 
    0.03083312f, 0.04251142f, -0.00922505f, -0.06778113f, 0.00748882f, 0.03004142f, -0.06327190f, 0.00694401f, 
    0.02633563f, 0.02335782f, 0.01727089f, -0.04103405f, -0.05368681f, -0.03722342f, -0.04605868f, 0.02356222f, 
    0.02827361f, -0.00990754f, -0.05260314f, -0.03103331f, 0.00415649f, -0.05852032f, -0.02976977f, 0.01066627f, 
    -0.00824251f, -0.04594779f, -0.04794756f, -0.06638479f, 0.03009938f, -0.04752427f, 0.03482081f, -0.00525974f, 
    -0.04363988f, -0.02198542f, -0.00278055f, 0.01919823f, 0.02076786f, -0.05523787f, 0.02210302f, 0.00029126f, 
    0.03910394f, 0.05262682f, 0.03165044f, 0.04061021f, 0.02164413f, 0.00621117f, -0.05042740f, 0.02182216f, 
    0.02577005f, 0.03116446f, -0.01002845f, -0.02051846f, -0.04472618f, 0.01126450f, -0.03952223f, 0.00406519f, 
    0.01986242f, 0.04223875f, -0.04158282f, -0.04868203f, -0.01342833f, -0.04698008f, -0.02339187f, -0.01385774f, 
    -0.05058150f, -0.04180383f, -0.01258225f, -0.02529506f, -0.05320112f, -0.03117969f, -0.06118059f, -0.03547745f, 
    -0.01054139f, -0.02576905f, -0.00492199f, -0.02222989f, 0.01031265f, -0.04273870f, 0.00731238f, -0.07108036f, 
    -0.03573150f, 0.01352732f, -0.03876142f, 0.03626267f, 0.03291846f, -0.04379512f, 0.04687694f, 0.03863040f, 
    0.01055236f, -0.03131740f, 0.03020556f, -0.01437677f, 0.01643912f, -0.02231844f, -0.06904999f, -0.05303679f, 
    -0.00940021f, 0.02599700f, -0.00833642f, 0.01775499f, -0.02002006f, 0.02204365f, 0.03125565f, -0.02166602f, 
    0.01097605f, -0.03011228f, -0.05238836f, -0.06778566f, -0.04212513f, -0.04495094f, -0.03806151f, -0.05541698f, 
    -0.06419209f, -0.05847665f, -0.02202439f, -0.05891007f, 0.01806561f, -0.05807871f, 0.03242895f, -0.05741253f, 
    -0.05522911f, -0.03282626f, -0.04439054f, -0.07317887f, -0.00353665f, 0.02297809f, 0.01964423f, 0.00555348f, 
    0.00167631f, -0.00895794f, -0.06404836f, -0.06970506f, 0.01789167f, 0.03818005f, -0.01547273f, 0.00240411f, 
    0.04202614f, -0.01996541f, 0.00284177f, -0.00719183f, -0.05500767f, -0.03031236f, -0.02582767f, 0.04249698f, 
    -0.04546317f, 0.02138361f, 0.02277241f, 0.03731338f, -0.05181966f, -0.02222737f, -0.03439312f, -0.03279478f, 
    -0.05020300f, 0.03993365f, -0.07124383f, -0.04011025f, -0.03910040f, -0.05342643f, 0.01766123f, -0.02468964f, 
    -0.05876211f, 0.03493648f, -0.05034877f, 0.01022366f, -0.01314739f, -0.05675144f, -0.02235454f, -0.01282046f, 
    -0.07133841f, -0.03670212f, -0.01944804f, -0.05583580f, -0.05566109f, -0.06351165f, -0.01204461f, -0.06821837f, 
    -0.01761062f, -0.00657831f, -0.00050198f, 0.04070506f, -0.00824570f, -0.07123774f, -0.05437078f, -0.00433455f, 
    -0.06420224f, -0.01375438f, 0.00124849f, -0.06484596f, 0.03303336f, -0.03667301f, 0.04341070f, -0.00281588f, 
    -0.03052541f, -0.00791550f, 0.03227738f, 0.01906717f, -0.03595973f, -0.01022044f, -0.02043113f, 0.04172942f, 
    -0.03628348f, -0.04866565f, 0.02308241f, 0.02072367f, 0.00215231f, 0.02261726f, -0.04421069f, -0.07081107f, 
    0.16969189f, -0.00124394f, 0.17973724f, -0.01897838f, 0.13335247f, 0.04106703f, -0.08037793f, -0.18019281f, 
    0.11283615f, 0.02360953f, -0.53119713f, -0.02853756f, -0.27036092f, 0.01483098f, 0.04896688f, 0.03408774f, 
    -0.08323750f, 0.08244249f, -0.17865711f, -0.27138713f, 0.37434506f, -0.00558059f, 0.04305550f, -0.07337897f, 
    -0.04709823f, -0.06799866f, 0.03785323f, 0.18851689f, -0.22796892f, -0.26163432f, -0.16972609f, 0.07376565f, 
    0.07862850f, 0.10393696f, -0.13697113f, -0.05707545f, -0.13697059f, -0.38377404f, 0.03086234f, -0.00423076f, 
    0.01266928f, 0.08680583f, 0.14584394f, 0.19364046f, 0.01230493f, 0.75461346f, -0.08535767f, -0.50170785f, 
    0.03683883f, 0.24344411f, -0.02097241f, 0.01956342f, -0.01515213f, -0.07573307f, 0.29145694f, -0.38940319f, 
    -0.06289376f, 0.01957373f, -0.09485093f, -0.04306970f, 0.06541035f, -0.01859838f, 0.08063109f, -0.01055632f, 
    -0.34505799f, 0.11203048f, -0.09344157f, 0.00217501f, 0.04823408f, -0.01490653f, -0.05060625f, 0.02602802f, 
    0.06545466f, -0.03862028f, -0.26441365f, 0.02642374f, 0.14701182f, -0.05320372f, 0.00621291f, -0.12587182f, 
    0.00744326f, -0.18518125f, 0.32550389f, 0.31680125f, 0.16324891f, 0.07509888f, -0.09690168f, 0.13431209f, 
    0.02567560f, -0.27414197f, -0.07993386f, -0.07710917f, -0.03193840f, 0.12247691f, 0.04307418f, -0.14738014f, 
    -0.20776710f, 0.15211745f, -0.00539672f, -0.03263929f, 0.08080905f, 0.21604097f, -0.03715052f, 0.15832144f, 
    0.06697515f, -0.08742002f, 0.07683966f, -0.17620100f, -0.49513161f, 0.28928274f, 0.17428592f, -0.00657674f, 
    0.09650346f, -0.09135834f, -0.22914216f, 0.08755092f, -0.07706576f, 0.06543122f, -0.05732835f, 0.20533209f, 
    -0.07215586f, 0.19001491f, -0.07391261f, 0.03213275f, -0.29831740f, 0.01910977f, -0.01413696f, -0.11821263f, 
    0.11159730f, 0.10333147f, -0.24850932f, 0.19351055f, -0.03147232f, -0.11785007f, -0.09682443f, 0.09823097f, 
    -0.11256382f, 0.16981332f, 0.01521265f, -0.12329138f, -0.00155212f, 0.03642694f, 0.21702780f, -0.09401438f, 
    -0.28466648f, -0.09768405f, -0.00586540f, -0.02622581f, 0.14180064f, -0.12320263f, 0.05432487f, -0.06975199f, 
    0.02697061f, 0.13304152f, 0.15614282f, 0.14026022f, -0.05848898f, 0.10143399f, -0.13979821f, -0.02578114f, 
    0.17200205f, 0.13033892f, -0.12743382f, 0.06817946f, 0.08936806f, -0.10488739f, -0.09252635f, 0.08987005f, 
    -0.08263434f, -0.03578565f, 0.08439127f, 0.15411693f, -0.02373423f, 0.14500299f, -0.03376197f, 0.04707856f, 
    -0.16686094f, 0.08592141f, -0.03709771f, -0.06255666f, -0.01087419f, -0.52972531f, -0.04876140f, -0.02686258f, 
    0.01568759f, -0.06725036f, -0.02219028f, 0.15899965f, -0.02396972f, 0.03032209f, 0.05148536f, -0.24129409f, 
    0.11405461f, -0.04105198f, -0.06361341f, -0.11056526f, 0.03523379f, 0.17960402f, -0.52702594f, 0.25520712f, 
    0.08934559f, -0.07678759f, -0.11678763f, 0.08878120f, 0.14312029f, 0.14074151f, -0.09569199f, -0.10078098f, 
    0.18392760f, 0.17833282f, 0.04650109f, 0.12857516f, 0.04773301f, 0.02332279f, 0.05925718f, -0.08828300f, 
    -0.07152573f, -0.27443671f, 0.04227766f, 0.24070963f, 0.01437702f, -0.09543607f, -0.02258670f, -0.02964492f, 
    -0.03345791f, -0.16163544f, 0.25711888f, 0.10252986f, 0.14336100f, 0.03132603f, 0.02678679f, -0.24058038f, 
    -0.09737574f, 0.04095708f, 0.22441803f, 0.29657799f, 0.06057751f, 0.00852134f, -0.01427515f, -0.12066040f, 
    -0.03392072f, 0.24805672f, 0.04749963f, 0.09746949f, -0.01379878f, -0.05679141f, -0.00624848f, 0.10706021f, 
    0.12274165f, 0.01010965f, 0.09164647f, 0.12065414f, -0.28039193f, 0.23844048f, 0.26618397f, -0.09446611f, 
    -0.04945074f, 0.12638178f, -0.20020075f, -0.07709156f, 0.03604480f, 0.02258106f, 0.08195177f, -0.17114656f, 
    0.16204900f, 0.27370548f, -0.13839850f, 0.04816133f, 0.02008323f, 0.00397428f, 0.26681650f, -0.29061773f, 
    0.05669000f, 0.00319982f, 0.00353060f, -0.20589450f, -0.19377005f, 0.02274337f, 0.15465899f, -0.28713688f, 
    0.20853266f, 0.47965938f, 0.17830679f, -0.03985368f, 0.02182527f, -0.05455991f, -0.11656162f, -0.21881498f, 
    0.70361519f, -0.02676236f, -0.12815738f, 0.20281261f, -0.09079923f, 0.08660930f, 0.00627267f, -0.02285903f, 
    0.08438735f, 0.25786173f, -0.17416216f, -0.12295599f, -0.01432271f, -0.04045165f, 0.12477530f, 0.03066255f, 
    0.03907210f, 0.02374395f, -0.25873211f, -0.31996027f, -0.12460117f, 0.15923443f, 0.27339587f, -0.11459975f, 
    0.04268056f, 0.14289625f, 0.23252073f, -0.63489586f, 0.04756781f, 0.23106511f, -0.07408333f, -0.00729821f, 
    -0.14314778f, 0.06781129f, -0.16090353f, 0.14537863f, -0.15415160f, 0.08721911f, 0.11729774f, 0.07490982f, 
    0.13454355f, 0.11017317f, 0.02794431f, 0.06601069f, -0.02780022f, -0.02872995f, 0.14869155f, -0.22112280f, 
    0.04148178f, 0.27216437f, -0.00608023f, 0.06350689f, 0.11855163f, -0.16853377f, -0.31395629f, 0.19551079f, 
    0.21160562f, 0.09110711f, 0.02613160f, 0.06473565f, 0.15979551f, -0.05432419f, 0.16343446f, 0.23122951f, 
    -0.00284370f, -0.04066833f, 0.20152761f, 0.06508110f, -0.19811967f, 0.11938290f, 0.01621053f, 0.18911847f, 
    -0.19934873f, -0.16745993f, -0.12978898f, -0.08809237f, 0.16930878f, -0.04217792f, 0.11622987f, 0.02908410f, 
    -0.09436749f, 0.14118999f, 0.07527293f, -0.12354482f, -0.07470305f, -0.00273729f, 0.04372041f, -0.03730925f, 
    -0.04654559f, 0.03877936f, -0.39323723f, -0.24426652f, 0.21527046f, -0.07777417f, 0.07488360f, 0.10759859f, 
    0.16457145f, -0.06529047f, -0.18592395f, 0.18268463f, 0.22312963f, 0.14069724f, 0.03864354f, 0.13108926f, 
    -0.05463248f, -0.00317288f, 0.01776838f, -0.05919562f, -0.02067782f, -0.06240416f, -0.04021917f, -0.16265289f, 
    -0.15238483f, 0.06388441f, -0.22421990f, -0.09003148f, 0.25078303f, -0.10392061f, -0.07648600f, 0.15308568f, 
    -0.11628743f, 0.31076953f, 0.14084876f, -0.04344856f, 0.16617797f, 0.06044979f, 0.04472402f, 0.14522533f, 
    0.18507794f, 0.08285757f, -0.04414037f, 0.01704025f, -0.05679814f, 0.08948566f, 0.17129745f, -0.83318108f, 
    -0.36601666f, 0.05216449f, 0.18476517f, 0.01744984f, 0.04065963f, -0.00346826f, -0.03336810f, -0.09534962f, 
    -0.36464071f, -0.00458966f, -0.00574578f, -0.11247052f, -0.00987472f, 0.00949047f, -0.02555857f, -0.06087108f, 
    0.03382530f, -0.01458191f, 0.01005778f, 0.02515887f, -0.20562302f, 0.15655895f, 0.21480522f, 0.08117961f, 
    -0.02165270f, 0.16945724f, -0.17345619f, -0.30568936f, -0.05687166f, -0.18344773f, 0.12963474f, -0.00705949f, 
    -0.06746987f, 0.23839150f, -0.11771110f, 0.12361946f, -0.26649755f, -0.05829804f, -0.04720506f, 0.04887070f, 
    0.12947476f, -0.02882283f, 0.00725669f, 0.11820209f, 0.35752875f, -0.40812778f, -0.02553285f, -0.00104196f, 
    -0.03858474f, 0.02955399f, 0.17723127f, -0.03471759f, 0.12572786f, -0.20280154f, -0.55183554f, -0.15592989f, 
    0.16720474f, 0.22557822f, -0.03371306f, 0.04043371f, 0.20368053f, 0.00277047f, 0.07323443f, 0.06599258f, 
    0.20024478f, -0.06620865f, 0.02910067f, -0.02202412f, -0.00588741f, 0.08512252f, 0.21057707f, -0.36669305f, 
    0.09083341f, 0.10343271f, 0.04107161f, 0.10485812f, -0.00966514f, -0.06644789f, -0.30436268f, 0.11519387f, 
    0.32170963f, -0.00350046f, -0.09460752f, 0.02845395f, -0.05392690f, -0.08267619f, 0.14113379f, -0.10548616f, 
    0.05213363f, -0.34091955f, -0.22311063f, 0.01942803f, 0.04182269f, -0.09393217f, 0.07326809f, -0.05772616f, 
    -0.03289353f, 0.04237384f, 0.07005978f, -0.02017793f, -0.35494208f, -0.10864243f, 0.03652430f, 0.19448541f, 
    -0.16656418f, 0.08437531f, 0.02209472f, -0.13645507f, -0.66067547f, 0.14549673f, 0.16888417f, 0.04898012f, 
    0.26453733f, 0.25077382f, 0.00913468f, -0.09031125f, -0.02843441f, 0.27160773f, -0.01467910f, 0.05972369f, 
    0.00989513f, -0.12830679f, 0.08811066f, -0.07549976f, 0.07663821f, -0.02504839f, -0.34120056f, -0.15908515f, 
    -0.04085821f, 0.06738676f, -0.04656394f, 0.02853128f, -0.05658849f, 0.04291474f, -0.31443891f, -0.08818180f, 
    -0.11486283f, 0.01120529f, -0.19869632f, -0.15493716f, 0.07568035f, -0.02031045f, -0.00991290f, -0.22452609f, 
    -0.05004640f, -0.16208605f, 0.15655540f, 0.00652505f, 0.04849967f, -0.11751851f, 0.09127926f, 0.01981540f, 
    0.25552976f, -0.33918211f, -0.10120966f, 0.10243388f, -0.09706037f, -0.05225699f, 0.02981801f, -0.04662552f, 
    -0.04079768f, 0.23321995f, 0.38251853f, 0.20762438f, 0.09790573f, 0.17615762f, 0.18316224f, -0.07137083f, 
    -0.09481236f, 0.21219881f, 0.14172964f, 0.11451751f, -0.02970080f, 0.00122276f, -0.00276037f, -0.18005069f, 
    0.03203369f, 0.17097174f, 0.01621788f, 0.02623899f, 0.45469281f, 0.29589051f, 0.01281045f, -0.07370952f, 
    0.07662266f, 0.12901565f, 0.00874859f, 0.01343490f, 0.24402316f, 0.06152170f, -0.09376559f, -0.13170311f, 
    -0.05804646f, 0.03779982f, -0.09140541f, 0.12942073f, 0.01225406f, -0.16123158f, 0.04594127f, 0.42691731f, 
    0.00195874f, 0.04408059f, -0.18141755f, -0.01352781f, 0.03286064f, 0.16360357f, 0.17977330f, 0.30100644f, 
    0.03297141f, 0.08219000f, 0.12310932f, -0.16799539f, -0.05412754f, 0.15340060f, 0.05749198f, 0.35801071f, 
    -0.08418194f, 0.01960484f, 0.08353078f, 0.18280135f, 0.16803484f, 0.08297551f, 0.04274051f, 0.19315755f, 
    -0.46359095f, 0.05141006f, 0.11355770f, 0.04354692f, 0.16559324f, 0.09855469f, -0.07009695f, -0.10469130f, 
    -0.25484005f, 0.23378180f, -0.16966444f, 0.18633331f, -0.21968742f, -0.11989141f, 0.01226119f, 0.07783107f, 
    -0.13152993f, -0.10941422f, -0.18346882f, -0.11002851f, 0.26166499f, -0.10417898f, -0.14697064f, -0.10055095f, 
    0.03178114f, -0.01730703f, 0.01698059f, 0.00123460f, 0.00993674f, 0.13167168f, 0.02698297f, -0.07480484f, 
    -0.00938068f, -0.00550242f, 0.10904940f, 0.12554200f, 0.13859737f, 0.01961104f, 0.03893306f, -0.23976991f, 
    -0.08144915f, -0.09572400f, -0.27967772f, -0.00475513f, 0.09611976f, -0.10123754f, -0.04226752f, -0.12374771f, 
    -0.01458969f, 0.12926683f, -0.13406213f, 0.03787247f, 0.10473798f, 0.06406805f, 0.10057609f, -0.01525468f, 
    -0.06305242f, 0.08584489f, 0.03109468f, 0.03623540f, 0.06252129f, 0.09266817f, -0.01738621f, 0.11098243f, 
    -0.33278632f, 0.19125472f, 0.01292730f, -0.10303815f, -0.11076050f, -0.16531824f, -0.00006073f, -0.05461909f, 
    -0.18460168f, 0.29972225f, -0.18909213f, -0.12843645f, 0.09905212f, 0.04817397f, -0.10085700f, -0.04559689f, 
    -0.09142718f, -0.23362678f, -0.01613976f, -0.10994697f, -0.09092496f, -0.17042708f, -0.11049087f, -0.00218125f, 
    0.11622924f, 0.24050502f, -0.24081856f, -0.06988116f, -0.14126258f, 0.06844699f, -0.15448764f, -0.05012393f, 
    0.07471033f, 0.00357449f, 0.13268138f, -0.61828518f, -0.23503020f, 0.20527574f, 0.20274994f, -0.08188123f, 
    -0.12756628f, 0.12556295f, 0.14084555f, 0.02913084f, 0.58790529f, 0.05134970f, 0.01856603f, -0.06734927f, 
    0.19781426f, 0.18965344f, -0.04075826f, -0.06783749f, 0.19722871f, -0.34180039f, 0.18733582f, -0.03478989f, 
    -0.08230479f, -0.17551598f, 0.11267263f, -0.00777719f, -0.19828501f, 0.09231645f, -0.00970897f, 0.11303472f, 
    0.02179357f, -0.17052993f, -0.06379062f, 0.19017924f, 0.23186430f, -0.15648925f, 0.08071681f, -0.07891983f, 
    0.05627785f, -0.20220296f, -0.17227910f, 0.02800141f, -0.07683047f, 0.20321630f, -0.16841257f, -0.09571252f, 
    0.05468179f, -0.18677489f, -0.82793736f, 0.01257076f, 0.18021286f, 0.08612455f, -0.01421441f, 0.01450986f, 
    -0.11891867f, -0.05208077f, 0.15584110f, -0.32774720f, -0.17756251f, 0.09168439f, 0.17421763f, 0.27742881f, 
    -0.05996431f, 0.17729080f, -0.15904601f, -0.02139395f, 0.13943124f, -0.10061449f, -0.11509680f, -0.14179333f, 
    0.11074018f, 0.03113367f, -0.01490927f, -0.41087487f, 0.07128991f, -0.00474033f, 0.07927949f, 0.07474839f, 
    0.05181611f, 0.16129868f, -0.10939983f, 0.08951508f, 0.13729170f, -0.64717472f, -0.39668053f, 0.14385329f, 
    -0.00501696f, -0.09571975f, 0.20924346f, 0.15456076f, 0.07643022f, 0.26648858f, -0.18786269f, 0.14205542f, 
    0.09016976f, 0.07470032f, -0.04972354f, -0.07546765f, -0.19682424f, -0.12730175f, -0.43058419f, -0.00449054f, 
    0.35728446f, 0.18749279f, 0.09364138f, -0.27773350f, 0.06903081f, -0.06496243f, -0.03581916f, 0.10030995f, 
    -0.16970584f, 0.23386377f, -0.15028301f, -0.11663628f, -0.05748640f, 0.02640718f, 0.02646318f, -0.00804446f, 
    -0.02482439f, -0.07683748f, 0.22739246f, -0.11994839f, -0.02412250f, 0.18094283f, 0.04887763f, 0.13039105f, 
    0.06128646f, 0.14709218f, 0.29848456f, 0.07810299f, 0.00485950f, 0.23030537f, -0.04332756f, 0.12010396f, 
    0.16833924f, -0.02594612f, 0.04909915f, 0.21387851f, 0.11319223f, -0.09573980f, 0.25827575f, -0.02682466f, 
    -0.17914490f, -0.24110746f, 0.13403471f, -0.37426376f, 0.05704767f, 0.13353962f, -0.11853909f, 0.11951858f, 
    -0.03312644f, 0.03815369f, -0.06345764f, 0.03625243f, 0.20940350f, 0.02858499f, -0.13133970f, 0.13809736f, 
    0.20400824f, -0.27316579f, 0.08994551f, 0.11846931f, 0.12256466f, 0.17214493f, -0.35554981f, -0.25347733f, 
    -0.00000242f, 0.03858725f, 0.00745650f, 0.17459711f, -0.12633409f, -0.05948908f, -0.01950590f, 0.02849725f, 
    0.00142226f, -0.28415468f, 0.09513228f, -0.21444182f, -0.03044307f, 0.07291739f, 0.05807470f, 0.23960191f, 
    0.21667552f, -0.12567520f, 0.05413917f, 0.02855789f, 0.05652118f, -0.06529199f, 0.05194741f, 0.04089983f, 
    0.27077931f, 0.23185730f, 0.16301747f, 0.15660930f, 0.01412470f, 0.14740926f, -0.07694773f, -0.11212407f, 
    0.02756600f, -0.30553442f, -0.25042149f, 0.05288946f, -0.03645840f, -0.00741478f, 0.11030201f, -0.00960156f, 
    -0.02393975f, -0.06962905f, 0.12388358f, -0.09055968f, 0.02478353f, 0.14799978f, 0.07637868f, 0.16178772f, 
    -0.12417104f, 0.09116200f, 0.11035658f, -0.38584709f, 0.04325248f, -0.01764431f, -0.02745300f, 0.06410227f, 
    0.09403694f, 0.00170027f, 0.05370923f, 0.06416708f, -0.77245259f, -0.18441924f, -0.05525292f, 0.02418440f, 
    -0.01251452f, 0.27869883f, -0.22796112f, -0.04929073f, -0.00026625f, 0.05385377f, 0.26290107f, -0.13813514f, 
    -0.15081508f, -0.07948437f, -0.06438064f, -0.07807596f, 0.08627511f, -0.18467370f, 0.09034227f, 0.09686282f, 
    0.03507934f, -0.16194999f, 0.03215624f, -0.08699860f, -0.13560139f, 0.25066680f, -0.03872379f, 0.15031962f, 
    0.18759961f, 0.05258060f, 0.04582800f, -0.21403083f, -0.00356159f, -0.10418284f, -0.16255078f, 0.11682663f, 
    -0.36775732f, -0.33744168f, 0.09704855f, -0.14099175f, -0.22444381f, 0.03720162f, -0.04438712f, -0.16814892f, 
    0.03797890f, 0.18835348f, 0.24020933f, 0.05638253f, -0.12524740f, 0.04225769f, 0.24721763f, -0.12227827f, 
    0.01762694f, -0.15912734f, -0.09941875f, -0.30445182f, -0.16991550f, 0.10692934f, -0.00165474f, -0.01490350f, 
    0.01044733f, 0.17769380f, 0.08745135f, 0.17022476f, 0.16148596f, -0.08070456f, 0.03966540f, -0.01484471f, 
    0.08847570f, 0.03123483f, 0.05989929f, -0.12619030f, 0.05701683f, 0.20913330f, -0.15798384f, 0.05170903f, 
    0.24238470f, -0.04819308f, 0.20344661f, 0.17365664f, -0.06568304f, 0.20689324f, -0.11488581f, -0.35212296f, 
    -0.11880317f, 0.05291860f, 0.12429345f, -0.08047343f, 0.29316548f, -0.17156760f, -0.61618912f, -0.13173011f, 
    -0.22124578f, -0.00479248f, -0.13501602f, -0.01986824f, 0.05223909f, -0.00756302f, 0.20750970f, 0.00846935f, 
    -0.17306876f, -0.11828693f, 0.02366265f, 0.04232138f, 0.06052942f, 0.08871020f, 0.03333949f, 0.01021369f, 
    0.36612964f, 0.15340869f, -0.08214311f, -0.14517508f, -0.21648675f, 0.21035948f, 0.26076204f, -0.02188542f, 
    0.13856474f, 0.12584972f, 0.13311885f, -0.13334739f, -0.20254287f, -0.14347011f, -0.04903220f, 0.06868196f, 
    -0.09719111f, -0.03829960f, 0.47238865f, 0.02866241f, 0.07144871f, 0.03173708f, 0.08444080f, 0.23970959f, 
    -0.27940345f, 0.04659259f, -0.15147577f, -0.01716460f, 0.15264408f, 0.18320946f, 0.01433175f, -0.01368714f, 
    0.01382380f, 0.01459110f, -0.22531700f, -0.22118282f, 0.06166334f, -0.17563966f, -0.10528980f, -0.06819822f, 
    -0.11924893f, -0.07226197f, -0.02329447f, 0.07559680f, 0.24621682f, 0.03937371f, 0.29513133f, 0.20772174f, 
    0.23683748f, 0.06097188f, 0.15704533f, -0.07986994f, -0.11519905f, -0.04858488f, 0.06368786f, 0.10757471f, 
    0.04129178f, -0.01992901f, 0.07768812f, -0.15678278f, -0.12288857f, 0.03642690f, 0.28062174f, -0.50883311f, 
    -0.39478904f, 0.19823630f, -0.20334575f, 0.10024475f, -0.05654133f, -0.03393505f, -0.06286820f, 0.17557506f, 
    -0.09905999f, 0.10310536f, 0.01800201f, 0.18484597f, 0.22930466f, 0.08489736f, 0.15948823f, 0.12341660f, 
    -0.02446643f, 0.39691004f, 0.30050236f, -0.13813646f, -0.05646170f, -0.03982023f, -0.26251915f, 0.05068273f, 
    0.07386808f, -0.02476754f, 0.09142178f, -0.36702794f, 0.02086193f, 0.15497398f, 0.10913320f, 0.15022063f, 
    0.14730673f, 0.09186215f, -0.32467628f, -0.40237343f, -0.13434343f, -0.38884273f, 0.04879136f, -0.15903355f, 
    -0.20908560f, 0.03148130f, -0.06501444f, 0.07662485f, 0.27897778f, 0.36056328f, -0.26310715f, 0.04453728f, 
    0.14067855f, 0.00140979f, 0.03114607f, 0.18610750f, 0.27659398f, -0.54925966f, -0.17509070f, -0.62643844f, 
    0.05569195f, -0.03306414f, 0.03987634f, -0.03742426f, -0.13966167f, -0.31538227f, -0.09806942f, 0.03295095f, 
    -0.26647529f, 0.17565958f, 0.26054165f, 0.07446090f, 0.13774401f, -0.06937695f, 0.11364974f, 0.34630895f, 
    0.05620671f, 0.23530811f, 0.15049361f, 0.07828550f, 0.09698870f, -0.01901308f, 0.16564862f, -0.01411845f, 
    -0.02116748f, 0.04923557f, -0.01079848f, 0.10263687f, -0.12765391f, 0.04815425f, 0.12398355f, 0.03791336f, 
    -0.04888138f, -0.43180588f, 0.13305341f, -0.27670702f, 0.13305323f, 0.10232303f, -0.06715780f, -0.14479060f, 
    -0.01252400f, 0.05893877f, 0.30404815f, 0.23558991f, -0.17326427f, -0.02229200f, -0.04308938f, 0.09862961f, 
    -0.15278670f, 0.10544850f, -0.05094823f, -0.14092778f, -0.02693505f, 0.12243616f, 0.13587189f, 0.08230905f, 
    -0.05926593f, -0.40766260f, -0.10330778f, -0.09118582f, -0.31714860f, 0.08569010f, 0.07863237f, 0.02738483f, 
    -0.04454558f, -0.29041937f, -0.17771745f, 0.02504235f, 0.02322084f, 0.27589676f, -0.20595132f, 0.12263246f, 
    0.11470824f, -0.18039688f, -0.11717529f, 0.05823915f, 0.11306986f, 0.17674910f, 0.21973266f, 0.10132840f, 
    0.02254292f, 0.17055792f, 0.10739873f, 0.04280003f, -0.08542994f, 0.22249562f, -0.07091378f, -0.04024582f, 
    -0.14578392f, 0.14172645f, -0.01221183f, 0.04670136f, 0.02024547f, 0.07147270f, 0.17344859f, -0.05032613f, 
    -0.45923981f, -0.06954433f, -0.14491965f, 0.06910326f, -0.11837153f, -0.11393737f, 0.01862777f, 0.19678073f, 
    0.00667952f, 0.27455166f, 0.15095791f, 0.29550874f, 0.13637131f, 0.02468440f, 0.05457357f, 0.13418390f, 
    0.15508591f, 0.06685436f, -0.51540792f, -0.08402333f, -0.36900529f, 0.02925575f, 0.15053000f, 0.04137631f, 
    0.10159417f, 0.19888517f, -0.03732857f, 0.15157774f, -0.03965043f, 0.02202704f, -0.11750173f, -0.06934813f, 
    0.30761480f, -0.28931049f, 0.01826117f, 0.00135716f, 0.22679625f, 0.05324902f, -0.27595839f, -0.11715802f, 
    0.03356877f, -0.02854191f, 0.15420659f, 0.16658653f, 0.04607690f, -0.12938689f, -0.10511821f, 0.24712214f, 
    0.00700456f, -0.01034863f, 0.14388447f, 0.13139473f, 0.05200353f, 0.09383558f, -0.45627061f, -0.15826106f, 
    -0.43884897f, 0.13721858f, 0.19277103f, 0.03644380f, 0.16828553f, 0.09555993f, 0.01626927f, -0.55907625f, 
    -0.20956279f, 0.12485779f, 0.13564113f, 0.09678438f, 0.15476432f, 0.00348754f, 0.10336895f, -0.07881935f, 
    0.17356087f, 0.12150614f, 0.07361399f, 0.29371765f, 0.32938990f, 0.09668171f, 0.10932279f, 0.18006952f, 
    0.12441422f, -0.62100351f, 0.06770977f, -0.29793563f, 0.15699556f, -0.03827643f, 0.01223512f, 0.06285077f, 
    -0.07887821f, -0.12939125f, 0.37822255f, -0.00828778f, 0.16745357f, 0.21242873f, 0.02130000f, 0.00374930f, 
    -0.01801573f, -0.03097511f, 0.01938653f, -0.23426858f, -0.31825283f, -0.10175698f, 0.13123105f, 0.00364623f, 
    0.14113122f, -0.02419308f, -0.13691977f, -0.10970112f, 0.13867243f, -0.40654975f, 0.17715582f, -0.09015417f, 
    0.09119868f, -0.32803926f, 0.09895840f, -0.11774606f, 0.03114122f, -0.65435082f, -0.04341814f, 0.24444313f, 
    0.03217869f, 0.31322864f, 0.11710899f, -0.12607175f, 0.10890446f, 0.15025643f, -0.05004656f, 0.38722691f, 
    -0.45291376f, -0.28802997f, -0.30738583f, -0.12452458f, -0.09408928f, 0.03728108f, 0.32721019f, -0.31139675f, 
    -0.34108824f, 0.04679758f, -0.02798209f, 0.13921745f, 0.06386817f, -0.11766469f, -0.02800379f, -0.15188301f, 
    0.01385886f, 0.00193807f, -0.02230894f, -0.02168739f, 0.04607457f, -0.02899801f, -0.04967611f, -0.03903849f, 
    0.03803270f, 0.05051048f, 0.01089513f, 0.03924002f, -0.04083111f, -0.06413116f, 0.02464142f, -0.06219037f, 
    -0.05926464f, 0.03727160f, 0.02716354f, -0.04734079f, 0.04761043f, -0.01623736f, 0.01042010f, 0.00733231f, 
    -0.01812650f, -0.01871766f, 0.02973953f, 0.02360343f, 0.01137610f, 0.00449652f, -0.01547533f, 0.01845164f, 
    -0.04331968f, 0.02614098f, -0.04824545f, 0.00890825f, -0.01876980f, -0.04430936f, 0.03757085f, -0.01801280f, 
    -0.05304355f, 0.00537847f, 0.04707936f, -0.01066828f, -0.02954899f, 0.00041399f, -0.05381775f, -0.05157564f, 
    -0.04911552f, -0.03315722f, -0.02753839f, 0.01262798f, -0.05132951f, -0.03143299f, 0.01869885f, -0.02348895f, 
    0.02072150f, 0.00107145f, -0.03528701f, 0.02439527f, 0.04055214f, 0.03046364f, 0.02205120f, -0.04312642f, 
    0.04419137f, 0.01947960f, 0.00568768f, 0.04681160f, -0.06265192f, -0.05236728f, -0.04368806f, -0.01475828f, 
    0.04460043f, -0.00831486f, 0.03391901f, 0.02499114f, 0.02267491f, -0.02755771f, 0.04919620f, 0.02383138f, 
    -0.00857804f, 0.00496591f, -0.05582299f, -0.02903188f, -0.01909968f, 0.01321892f, -0.03612785f, -0.03582625f, 
    0.04956853f, -0.06787763f, 0.01096027f, -0.05818712f, 0.02341130f, -0.03681082f, -0.06139106f, -0.03030466f, 
    -0.01746623f, 0.04592507f, -0.03629629f, 0.02985173f, 0.00271068f, 0.02705541f, -0.00012825f, -0.02212701f, 
    -0.00311185f, -0.02467877f, 0.02528931f, -0.04191231f, 0.03324291f, 0.04414138f, 0.04499139f, -0.02971117f, 
    0.04840422f, 0.03193321f, 0.02908098f, 0.00936425f, 0.00485640f, -0.01589454f, -0.03151931f, 0.00871031f, 
    0.05163503f, 0.05928792f, 0.01039157f, -0.02896016f, -0.00620447f, -0.01083574f, -0.06307178f, -0.04647658f, 
    -0.02937510f, -0.00997054f, -0.05480229f, 0.03220506f, 0.01112574f, -0.00614471f, -0.06252975f, 0.01378930f, 
    0.00674480f, 0.00767698f, -0.04325283f, -0.02298722f, 0.02435969f, -0.05373181f, -0.00788167f, -0.01632231f, 
    -0.04925082f, -0.03570299f, 0.03468959f, 0.01602555f, 0.04011904f, 0.04728274f, -0.03801475f, 0.02710754f, 
    0.00695137f, 0.04010574f, 0.02987173f, -0.03978518f, -0.05264339f, -0.01644923f, -0.02221060f, -0.01507136f, 
    -0.03498079f, 0.00134670f, -0.01459456f, -0.05394590f, -0.02662793f, -0.03067251f, 0.02265694f, 0.04153112f, 
    0.04968979f, -0.02427157f, -0.05482458f, 0.03833637f, -0.03957319f, -0.04521087f, -0.00333027f, 0.03891352f, 
    0.02799652f, 0.04671121f, -0.02406222f, 0.04652777f, 0.03188366f, 0.02180020f, 0.04181912f, 0.01320853f, 
    -0.02178397f, 0.03659454f, -0.05630507f, -0.04489616f, 0.02081464f, -0.02701585f, 0.02378730f, 0.00336909f, 
    -0.00230053f, -0.05211266f, 0.03365640f, 0.00754644f, 0.01346084f, -0.05322385f, 0.00558863f, 0.03863591f, 
    -0.01408912f, -0.01524374f, 0.00896582f, -0.01747717f, -0.06475430f, 0.04113143f, -0.03018495f, 0.00321903f, 
    -0.02246752f, -0.00672864f, -0.00608343f, 0.02348862f, 0.04505014f, -0.05535261f, 0.01571249f, 0.01379482f, 
    0.01572320f, 0.00663559f, -0.04786019f, 0.02932624f, 0.01515709f, 0.03198593f, -0.01708061f, -0.03096737f, 
    0.00505287f, -0.03900900f, -0.01230695f, -0.05265548f, 0.02971901f, 0.02549828f, -0.04064239f, -0.01029002f, 
    -0.03498846f, -0.02435833f, -0.05740920f, -0.04264489f, -0.02805284f, 0.03654386f, -0.01056047f, -0.04828867f, 
    -0.01422639f, -0.05398532f, -0.02635673f, -0.04358345f, -0.01418933f, -0.01204533f, 0.02965042f, -0.04377504f, 
    -0.02260985f, -0.05499095f, -0.06239023f, 0.01674184f, -0.05063420f, 0.00819984f, -0.01200745f, 0.01854271f, 
    0.03002452f, 0.00213260f, -0.05758397f, -0.06154128f, -0.04906186f, 0.03194527f, -0.02055861f, -0.04583205f, 
    -0.04097420f, 0.01525095f, 0.04856408f, -0.04765853f, -0.04975978f, 0.01881696f, -0.02068696f, 0.04171145f, 
    -0.01253860f, -0.01867418f, -0.04238985f, -0.04858664f, 0.05698634f, -0.04713144f, -0.05517752f, -0.06034689f, 
    -0.03768401f, 0.04782777f, -0.01200386f, -0.06412934f, -0.06342060f, 0.04535382f, -0.05918498f, 0.00224563f, 
    -0.05895438f, -0.00713920f, -0.06659812f, -0.00663200f, -0.04483123f, -0.03862052f, -0.04065109f, -0.02103178f, 
    -0.01701425f, -0.05265834f, -0.06415204f, -0.05590515f, -0.04120054f, -0.01225641f, 0.02822511f, -0.04771825f, 
    0.04166219f, -0.06478926f, 0.04730210f, -0.01964525f, -0.01973349f, -0.00762202f, 0.02129007f, 0.03566713f, 
    -0.05404850f, -0.02728352f, -0.00435281f, 0.00333156f, 0.02558134f, -0.03314491f, -0.04061076f, -0.00754334f, 
    0.02188921f, -0.05481793f, 0.04785519f, 0.02505169f, 0.02247652f, 0.02313639f, 0.04099925f, -0.02691515f, 
    -0.04250061f, 0.02512424f, 0.04900562f, -0.04607952f, 0.00060747f, -0.01239302f, -0.00720447f, 0.03244624f, 
    -0.05107770f, -0.05379384f, -0.00820514f, 0.02224312f, -0.00706302f, 0.02896965f, -0.03339336f, -0.04682346f, 
    0.04501449f, -0.00709616f, -0.00181229f, 0.01354521f, -0.01917869f, -0.04419972f, -0.00341075f, -0.00252568f, 
    0.00076156f, -0.05824943f, -0.00090150f, -0.03893914f, -0.01051809f, -0.02061569f, -0.02852678f, 0.02208937f, 
    -0.05081649f, -0.00638612f, -0.03971703f, -0.06589812f, 0.01185331f, 0.01163881f, -0.06161430f, 0.03388622f, 
    -0.01830284f, 0.03251101f, 0.04549973f, -0.03167321f, -0.06477999f, -0.01478901f, -0.02429131f, 0.01425178f, 
    0.02941515f, -0.01602761f, 0.00494514f, 0.04057078f, 0.01677975f, 0.01737316f, -0.02571169f, -0.03472089f, 
    0.00798878f, 0.04702722f, 0.01291649f, -0.03580739f, -0.00982007f, -0.02762306f, 0.01948574f, -0.03399802f, 
    -0.00377048f, -0.01873264f, 0.04803787f, 0.01498183f, -0.06277524f, 0.02868810f, -0.00066947f, 0.01293433f, 
    -0.01096405f, -0.00331764f, 0.02056338f, -0.00249608f, -0.01251077f, 0.04163472f, -0.02461715f, 0.01048242f, 
    -0.03367605f, 0.01477139f, -0.00992931f, 0.03287818f, -0.03786882f, -0.00237605f, 0.02620580f, 0.02667418f, 
    -0.01217736f, 0.01289621f, -0.01941520f, -0.05261048f, 0.01812858f, -0.06534187f, -0.00257788f, -0.01333646f, 
    -0.05072731f, 0.03962395f, -0.03195259f, -0.03722004f, 0.02382392f, -0.00533450f, 0.02717641f, 0.01740612f, 
    -0.03702176f, -0.02742662f, -0.04478727f, -0.05585068f, -0.00040042f, 0.03854049f, -0.03376810f, 0.01949249f, 
    -0.04739691f, -0.01504228f, -0.04733184f, -0.01703703f, 0.01841057f, -0.03415691f, 0.00768569f, -0.02391245f, 
    -0.06301844f, 0.02535274f, -0.00800068f, -0.04884428f, -0.00786613f, -0.02652389f, -0.02474465f, -0.05759578f, 
    -0.03466678f, 0.01549369f, -0.02981724f, 0.01692653f, -0.01095818f, -0.00859862f, -0.01411289f, -0.05725040f, 
    0.01878486f, -0.02209405f, 0.00870987f, -0.06389406f, 0.00127181f, 0.04803456f, -0.01467203f, -0.03894030f, 
    -0.00982797f, -0.06769087f, 0.00463011f, 0.03835193f, 0.02968005f, -0.03368452f, -0.05293734f, -0.04039245f, 
    0.03373816f, 0.02110302f, 0.01954217f, -0.06202334f, 0.00918499f, -0.06770722f, 0.00315943f, -0.00398795f, 
    -0.03063487f, 0.02800618f, 0.01133075f, -0.05702111f, 0.02081225f, -0.01890881f, 0.03516076f, 0.00302274f, 
    -0.00515280f, 0.04715063f, -0.01165571f, 0.03928054f, 0.02149911f, 0.02955269f, -0.06112185f, 0.04318601f, 
    -0.01770478f, 0.00106029f, 0.04821004f, 0.01738930f, -0.01307918f, 0.03074693f, 0.01233015f, -0.03474205f, 
    -0.01297549f, -0.01841423f, 0.00369746f, -0.05585737f, -0.02481676f, -0.04146392f, 0.00518407f, 0.02678881f, 
    0.01506637f, 0.02241332f, 0.00096725f, -0.02477662f, 0.04639558f, -0.00975003f, -0.03844072f, -0.00037411f, 
    0.01519308f, 0.02215465f, -0.02510033f, 0.03320056f, -0.04003273f, 0.02141961f, 0.02202171f, -0.00434675f, 
    0.00720278f, -0.01234946f, 0.04390153f, -0.03867441f, 0.03986638f, -0.01442464f, -0.04331883f, -0.03185443f, 
    0.01030414f, 0.03448373f, -0.00615555f, -0.06596719f, 0.00828758f, -0.00244662f, -0.00748307f, 0.02395910f, 
    0.01183159f, 0.03001709f, 0.01437267f, 0.01795630f, -0.00389050f, 0.04112690f, 0.04096636f, 0.01830880f, 
    -0.05338842f, 0.04966686f, -0.05021537f, -0.01678712f, -0.01640855f, -0.00678844f, -0.00330817f, 0.02392321f, 
    -0.01382867f, 0.04568488f, -0.06282410f, -0.04403298f, -0.00629891f, 0.01727256f, -0.04317013f, -0.00554725f, 
    0.08433348f, 0.00017367f, 0.14006911f, 0.23585881f, -0.14790155f, -0.05955295f, -0.13671930f, -0.04948790f, 
    0.03080160f, 0.16791883f, 0.01357266f, 0.03906255f, -0.12353387f, -0.01022200f, -0.11348484f, -0.16661923f, 
    -0.00578451f, -0.12462181f, -0.05907213f, -0.50504845f, -0.17675453f, -0.07888042f, 0.13282356f, -0.02446427f, 
    -0.18385372f, 0.00077807f, -0.15894015f, 0.50563496f, -0.10382547f, -0.14929822f, -0.23848321f, 0.11057286f, 
    -0.23668249f, 0.02603698f, 0.16670699f, 0.01808090f, 0.14419036f, 0.03944474f, 0.43542185f, 0.02111136f, 
    -0.12162819f, 0.11478978f, 0.01336110f, 0.04043328f, 0.12788224f, 0.42631230f, 0.19481674f, -0.57501847f, 
    -0.13908750f, 0.04952241f, 0.21311727f, -0.13905698f, 0.16758859f, 0.07427061f, 0.66413504f, 0.12917194f, 
    0.11670277f, -0.16876280f, -0.05943856f, -0.04573079f, -0.15129411f, 0.23568624f, -0.03805149f, -0.01933922f, 
    0.21520263f, 0.33263761f, 0.09454560f, -0.09212597f, 0.03831311f, -0.07013819f, -0.05523257f, -0.01837081f, 
    0.20972683f, -0.13093086f, -0.50385201f, 0.02638011f, 0.02485061f, -0.04253148f, -0.03845293f, -0.02641105f, 
    -0.02590929f, -0.25804231f, 0.21302170f, -0.19815104f, 0.13315898f, 0.25043628f, 0.05864330f, 0.12924297f, 
    0.02176108f, -0.12698928f, -0.10517757f, 0.15362392f, -0.05778909f, -0.07200993f, 0.14667305f, 0.10738225f, 
    -0.04400710f, -0.00212041f, -0.03919118f, 0.34284317f, 0.07184502f, 0.12656720f, -0.06068558f, -0.18246253f, 
    -0.05428349f, -0.00808813f, 0.19737285f, 0.22344075f, 0.04765505f, 0.12276071f, -0.22048391f, 0.00926067f, 
    0.17543125f, 0.15236306f, -0.25707501f, 0.06568833f, -0.21705353f, -0.85205239f, -0.21885695f, 0.15501806f, 
    -0.11146625f, 0.19244713f, -0.08905609f, -0.00766575f, 0.13542150f, -0.03846314f, 0.02194727f, 0.17046691f, 
    0.31008810f, 0.02404304f, -0.06080322f, -0.23686770f, -0.11860157f, -0.03097634f, 0.16857313f, 0.47584110f, 
    0.21680069f, -0.34951720f, 0.03695344f, 0.14145882f, 0.02026798f, -0.27152172f, -0.01591752f, 0.08772460f, 
    -0.17563526f, -0.00987783f, 0.11781202f, -0.08259482f, -0.06806495f, -0.01345980f, 0.05795648f, 0.12141833f, 
    0.09628291f, -0.24327207f, 0.06757260f, -0.33708513f, -0.00241249f, 0.10922904f, -0.11967464f, 0.01219769f, 
    0.07424820f, 0.05278406f, 0.27846500f, -0.03603701f, -0.11897106f, -0.03724833f, -0.32270288f, 0.21983233f, 
    0.06895479f, 0.12491413f, 0.10399716f, 0.00773866f, -0.38124827f, 0.16786149f, -0.02942218f, -0.02881870f, 
    -0.19257121f, 0.09520038f, 0.01711101f, -0.14526610f, 0.13179308f, -0.04108337f, 0.13310328f, -0.20787624f, 
    -0.29632899f, 0.22305848f, 0.14350474f, -0.06856935f, 0.14433077f, 0.21429238f, -0.55128801f, -0.29661363f, 
    -0.09195978f, 0.14486672f, -0.12983011f, -0.02881364f, 0.13805501f, -0.14858510f, -0.06298236f, -0.04637909f, 
    0.14047053f, 0.02388179f, 0.04185747f, -0.06499935f, 0.00268804f, -0.00105811f, 0.20712623f, -0.18956102f, 
    0.15854873f, 0.06561860f, 0.06801459f, -0.03171523f, -0.10246040f, -0.12156919f, 0.01646885f, 0.06585032f, 
    0.20768829f, 0.31712872f, 0.18666273f, -0.00521141f, -0.16570589f, 0.00044319f, 0.26648611f, -0.16836187f, 
    0.02794282f, 0.36225393f, -0.54958981f, 0.03801145f, -0.06736840f, 0.05668586f, 0.03319721f, -0.19515532f, 
    0.01515807f, 0.14970720f, -0.21487893f, -0.16440369f, -0.38815200f, 0.11975188f, -0.00370984f, -0.09879223f, 
    -0.00769836f, 0.06250492f, -0.04890567f, 0.46500993f, -0.21055718f, 0.03110296f, -0.23212923f, 0.16365698f, 
    0.06504413f, -0.10656233f, -0.04022983f, 0.16409428f, 0.13455576f, 0.06190114f, 0.04410804f, -0.04746893f, 
    -0.04769754f, -0.02238454f, -0.19542293f, 0.15120253f, 0.16720127f, -0.22315024f, 0.39286599f, -0.16465533f, 
    0.13679047f, 0.08390241f, 0.06836907f, -0.10505022f, -0.08068104f, -0.21489990f, 0.62938666f, -0.26800480f, 
    -0.33050361f, -0.30736890f, -0.07775255f, -0.16648722f, -0.07755252f, 0.11942261f, -0.08183583f, -0.56484622f, 
    0.10153616f, -0.17984855f, 0.21012771f, 0.08022661f, 0.12656781f, 0.01347898f, 0.06972426f, 0.32429418f, 
    -0.03746485f, 0.04434284f, 0.00451606f, -0.00171660f, 0.04155409f, -0.05680236f, 0.01392515f, 0.01553213f, 
    0.04599732f, 0.03460853f, -0.04635533f, 0.00678514f, -0.03913264f, -0.00262701f, -0.04004156f, -0.02490188f, 
    -0.00256474f, 0.04238645f, -0.05498701f, -0.04036243f, 0.04421281f, -0.05487773f, 0.01997446f, 0.01305583f, 
    0.03236249f, -0.04402805f, 0.04005206f, 0.04742115f, 0.02562282f, -0.01484379f, -0.00131993f, 0.01983883f, 
    -0.05161117f, 0.00774218f, 0.04642703f, -0.04710476f, -0.05671415f, 0.04802493f, 0.01625749f, 0.02689892f, 
    0.02175356f, -0.03830359f, -0.04980005f, -0.01145650f, -0.05672205f, 0.02101487f, 0.02956278f, -0.01237521f, 
    0.03801630f, -0.06154919f, 0.01872115f, 0.02666285f, 0.04543174f, -0.04579607f, -0.04457799f, -0.05412177f, 
    -0.00191279f, 0.00236637f, 0.04097146f, -0.03290830f, -0.06353662f, -0.02306167f, -0.00587592f, 0.04021925f, 
    -0.06331806f, -0.04510615f, -0.04071756f, 0.02504712f, -0.02811495f, 0.04311038f, 0.01349793f, -0.04561810f, 
    0.01921760f, -0.03188261f, -0.01801576f, 0.04879801f, 0.01016470f, -0.05183505f, 0.04374662f, -0.06287586f, 
    -0.00166366f, -0.00826352f, -0.04332082f, 0.01843837f, 0.02956990f, 0.01140921f, -0.05266927f, -0.06580777f, 
    0.00169610f, 0.05370446f, 0.05229420f, 0.04086626f, -0.05636267f, 0.05067002f, -0.05042157f, -0.02910584f, 
    0.05084330f, 0.01903253f, 0.01897906f, -0.05601873f, 0.01536552f, 0.00334441f, 0.00811695f, -0.03387825f, 
    -0.01378366f, -0.01119579f, -0.01187648f, -0.03404283f, 0.00937809f, 0.03903123f, -0.06592357f, 0.03200966f, 
    -0.02282966f, -0.03242313f, 0.02373025f, -0.02294778f, -0.01891583f, -0.00986212f, -0.02825844f, 0.03926165f, 
    0.01063981f, 0.00052056f, -0.01507625f, 0.03710032f, 0.01462851f, 0.03987429f, -0.02027934f, -0.01535687f, 
    -0.04454316f, -0.04209637f, 0.04279515f, -0.04394550f, -0.05533421f, 0.02802920f, 0.00268622f, -0.03216320f, 
    -0.03433052f, -0.06092586f, -0.01554930f, 0.02796631f, 0.03224379f, 0.04980211f, -0.01556219f, 0.01845458f, 
    -0.05560508f, 0.04954514f, 0.01159453f, -0.05826281f, -0.04285332f, -0.04736545f, -0.05889021f, 0.01694071f, 
    -0.00821960f, -0.05351814f, 0.04437055f, 0.01819098f, -0.03220744f, -0.05778487f, -0.06022515f, -0.05812884f, 
    -0.04389201f, -0.01962265f, 0.01857459f, -0.05919233f, -0.04890314f, -0.00956287f, 0.02117767f, -0.05984266f, 
    -0.06081746f, -0.06276548f, -0.05907001f, 0.02579444f, -0.03382346f, -0.06545939f, -0.06257361f, -0.01973942f, 
    0.02515573f, -0.05798937f, -0.04275631f, 0.00587885f, 0.00241127f, -0.06689514f, 0.04413234f, 0.00549605f, 
    0.03831682f, -0.01013720f, 0.01228996f, -0.04999715f, 0.00646036f, -0.00432035f, -0.01500563f, 0.01232969f, 
    0.01151360f, 0.01341515f, 0.02062110f, 0.03043041f, -0.00297692f, 0.03349832f, -0.04634741f, 0.04051220f, 
    0.01962787f, -0.00526659f, 0.00911344f, 0.00336039f, 0.01490838f, 0.01420849f, -0.05125737f, -0.01584301f, 
    0.03796703f, -0.02174836f, -0.05243079f, -0.02236377f, -0.00537033f, -0.00798465f, -0.04664912f, 0.04784859f, 
    -0.02596428f, -0.02192381f, -0.02108005f, -0.04761737f, 0.01165843f, -0.03200375f, -0.04337370f, 0.02870205f, 
    -0.06555218f, -0.05245565f, 0.02849042f, -0.04189255f, 0.01406874f, -0.04881442f, 0.04040077f, -0.06479809f, 
    -0.04265580f, -0.03663285f, -0.05339206f, -0.02964148f, -0.02355481f, -0.02481372f, -0.02322331f, -0.01745291f, 
    -0.06036992f, 0.04714134f, 0.02776952f, 0.01043748f, -0.02763024f, -0.00247954f, 0.04648141f, -0.04889275f, 
    -0.03963748f, 0.03553503f, 0.02904596f, -0.00066793f, -0.03071506f, -0.02112429f, -0.04427541f, 0.00870495f, 
    0.01065160f, 0.00894182f, 0.00286932f, -0.02921082f, -0.03261255f, 0.03320150f, -0.01051714f, 0.03293520f, 
    0.03810275f, -0.05058230f, 0.00393941f, -0.05829242f, 0.04435225f, 0.00902152f, -0.02177441f, 0.03672167f, 
    -0.00294614f, -0.02140780f, -0.05102289f, 0.04179834f, -0.01588604f, -0.05190682f, -0.02536627f, -0.01480849f, 
    -0.04246391f, 0.02480567f, 0.01141029f, 0.02172565f, 0.04513839f, 0.01917871f, -0.04913694f, -0.02291049f, 
    -0.01498765f, 0.01919579f, -0.01137406f, -0.01527889f, -0.01607446f, -0.03566295f, -0.06122481f, 0.02697465f, 
    -0.05550309f, -0.06329287f, -0.00230670f, -0.02473842f, 0.01083180f, -0.03673479f, 0.00347252f, -0.06647732f, 
    0.03320787f, -0.01695818f, -0.02714987f, 0.02117096f, 0.00702666f, 0.01837238f, 0.02813647f, -0.02226198f, 
    0.02496874f, 0.02948495f, 0.03198215f, -0.01875219f, -0.05012403f, -0.05222280f, -0.03270021f, 0.00837002f, 
    -0.00874376f, -0.06168770f, -0.02695389f, 0.00845798f, -0.01132723f, -0.00575520f, -0.02483441f, -0.06870239f, 
    -0.00888272f, -0.01972971f, -0.00673760f, -0.03975368f, 0.03592621f, 0.01482250f, 0.01229009f, 0.00972373f, 
    -0.03935121f, -0.03709497f, 0.01242219f, -0.00391448f, -0.06223179f, -0.05073128f, -0.03553231f, -0.00014195f, 
    -0.04938768f, -0.06907950f, -0.02752162f, -0.01535265f, -0.02825269f, 0.03852749f, -0.01022127f, 0.02898352f, 
    -0.06261173f, -0.01886979f, 0.03555692f, -0.03653976f, 0.01235191f, -0.06734002f, -0.03114863f, -0.05838343f, 
    0.01171177f, 0.02976491f, 0.02528843f, -0.05116514f, -0.01529728f, 0.01542200f, -0.01698301f, 0.01011892f, 
    0.01167258f, -0.05341937f, -0.06437401f, 0.04412759f, -0.02663921f, 0.03979420f, 0.00082101f, 0.01713575f, 
    0.01621092f, -0.02441406f, -0.01878744f, 0.00531078f, -0.05411316f, 0.00399195f, -0.03746126f, -0.00036738f, 
    -0.06832758f, 0.02733665f, -0.00091907f, 0.04131494f, 0.00308730f, 0.04291564f, 0.00084286f, -0.03315861f, 
    -0.02627659f, -0.02269746f, -0.02922931f, 0.02700017f, 0.02862524f, -0.02350875f, 0.03856071f, 0.00263403f, 
    -0.01167906f, 0.01451121f, -0.01309281f, 0.04313977f, -0.00625651f, 0.02631861f, 0.00393342f, -0.04945350f, 
    0.02948251f, -0.04879390f, -0.02662585f, 0.04544623f, 0.04338694f, -0.04552566f, -0.04581016f, 0.03740823f, 
    -0.03563057f, 0.03231595f, 0.03142431f, 0.03871699f, -0.06057297f, 0.01737246f, 0.02329155f, -0.00310777f, 
    -0.00127697f, -0.01135266f, -0.06695879f, -0.04833407f, 0.04191618f, 0.02705758f, -0.05562679f, 0.01755465f, 
    -0.05183839f, 0.00630868f, 0.01008694f, -0.00201741f, -0.02086475f, 0.03876331f, 0.00551632f, -0.03999082f, 
    0.01733640f, 0.00663896f, -0.05148958f, -0.03153001f, 0.02521571f, 0.01873962f, 0.00274969f, 0.02762306f, 
    -0.00284408f, -0.00466855f, -0.04569415f, -0.02674120f, -0.00767974f, -0.04999258f, -0.01450863f, -0.04232935f, 
    0.01086855f, -0.00273250f, -0.04505448f, -0.02475246f, -0.01479972f, -0.00667877f, 0.00522040f, -0.06199720f, 
    -0.01363861f, 0.03158860f, -0.03918465f, -0.00346317f, -0.04052408f, 0.00428284f, -0.02549709f, -0.01018615f, 
    0.00275313f, 0.04427687f, -0.01504321f, 0.00719140f, -0.04107641f, 0.01942242f, -0.00244458f, -0.02564803f, 
    -0.06029908f, -0.07168984f, -0.05590972f, -0.00018450f, 0.04347444f, 0.04063648f, -0.00488450f, 0.03630571f, 
    -0.05715648f, 0.04273124f, -0.01898775f, -0.05148013f, 0.02911058f, 0.01968767f, -0.01053066f, 0.02831130f, 
    -0.04831505f, -0.01721304f, -0.02027414f, -0.07182256f, 0.02026534f, 0.00757206f, -0.05567192f, 0.02375305f, 
    -0.04471370f, 0.04143380f, -0.02285291f, 0.02449381f, -0.01845215f, -0.06671885f, -0.05738147f, -0.03460193f, 
    -0.02877817f, -0.07069513f, 0.00350962f, -0.02400281f, -0.02929631f, -0.00538119f, -0.02548905f, 0.01381795f, 
    -0.02782059f, -0.02345776f, 0.02666206f, -0.02569044f, 0.03805405f, 0.03805625f, 0.03385327f, -0.02504556f, 
    -0.03786342f, -0.02993684f, 0.03496857f, 0.01226015f, 0.00480793f, 0.04607688f, -0.04959103f, 0.00259273f, 
    -0.02283759f, -0.02996173f, -0.00513706f, 0.03141442f, -0.00296633f, -0.01765640f, 0.00591210f, -0.00538824f, 
    0.03866448f, -0.04030447f, -0.04731710f, -0.00682066f, -0.00445956f, -0.04887523f, -0.03685758f, -0.03934772f, 
    -0.03955222f, -0.02870737f, 0.01113885f, -0.06879365f, 0.00143752f, 0.04407166f, -0.04401314f, -0.02981083f, 
    -0.05170047f, -0.00941445f, 0.03383263f, 0.00347554f, 0.00563926f, -0.06651363f, 0.02711814f, -0.06071167f, 
    -0.04756576f, -0.00324033f, -0.02129428f, -0.01157377f, 0.05224838f, -0.05192143f, 0.04443324f, 0.02916702f, 
    0.04706757f, 0.08350359f, -0.06569865f, -0.25594658f, 0.23161888f, 0.07867334f, 0.20839846f, 0.05094172f, 
    -0.06340584f, 0.18137974f, 0.15513660f, -0.09641013f, -0.01607343f, 0.02752596f, 0.08401971f, -0.01303393f, 
    0.38658848f, 0.02375060f, -0.01395791f, 0.04782485f, 0.06526256f, -0.00359519f, 0.19108042f, -0.03727039f, 
    -0.01802784f, 0.00310153f, -0.22256361f, -0.07379021f, 0.01359529f, -0.03048849f, -0.35592100f, 0.11256800f, 
    -0.08051602f, -0.15316296f, -0.16919218f, -0.01636383f, 0.35552445f, 0.00192759f, 0.03097568f, -0.23252118f, 
    -0.12491626f, 0.17958377f, 0.06484329f, 0.20274234f, -0.15462255f, -0.16081922f, -0.10874217f, -0.06044679f, 
    0.05855256f, 0.16035563f, 0.06964793f, 0.22394583f, -0.27221590f, -0.16657457f, 0.42647427f, -0.03093126f, 
    0.12323895f, -0.12944305f, 0.11402553f, -0.07815525f, 0.05581909f, -0.09802721f, -0.06371990f, 0.19964927f, 
    0.06596173f, 0.06761724f, -0.14855795f, -0.09117819f, 0.10175423f, -0.08865252f, 0.06559322f, 0.05289727f, 
    0.03602424f, 0.17261001f, -0.02805474f, 0.04916982f, -0.21877772f, 0.01826463f, 0.02798758f, 0.10072191f, 
    -0.04608584f, 0.04746736f, -0.10671768f, 0.01676595f, 0.08817773f, 0.17635746f, -0.07847050f, 0.14692286f, 
    -0.06602418f, -0.14884016f, 0.31142750f, 0.14212254f, 0.19533345f, 0.14691414f, -0.09078271f, -0.11296505f, 
    -0.14915107f, -0.20327729f, 0.21763740f, -0.52674067f, -0.19375299f, 0.21254002f, -0.15278420f, 0.27311257f, 
    0.00356525f, 0.06383584f, -0.02385655f, -0.20775223f, 0.19716689f, 0.23496729f, 0.01656777f, 0.26051939f, 
    0.00792799f, 0.06211638f, 0.03773015f, -0.04366097f, 0.05295419f, 0.12921740f, 0.17995070f, -0.01574573f, 
    -0.12216230f, -0.21541840f, 0.14094880f, 0.13380776f, 0.01029691f, 0.23996271f, 0.14920031f, 0.06678101f, 
    0.02614635f, -0.05151846f, -0.23055528f, -0.06577078f, -0.05292548f, 0.01627571f, 0.04816499f, 0.32330096f, 
    0.07924794f, -0.04337962f, 0.16195917f, 0.13594458f, 0.15807208f, 0.05733522f, 0.02655535f, -0.22254694f, 
    -0.11420564f, -0.08429962f, -0.08743335f, 0.04786428f, 0.03092842f, -0.02356707f, -0.24573645f, 0.00601193f, 
    0.08220414f, 0.21469235f, -0.02469886f, 0.02203337f, 0.04390332f, 0.13039067f, -0.10357706f, -0.08917955f, 
    0.10496633f, 0.26119325f, -0.15446612f, -0.10526642f, -0.09976939f, 0.06648728f, -0.08726588f, 0.13882200f, 
    -0.02296362f, 0.05102310f, -0.04688616f, 0.35385689f, -0.04392609f, 0.14375009f, 0.05705772f, -0.05240001f, 
    0.03762878f, -0.30567583f, -0.03973235f, 0.02811748f, 0.33172274f, 0.11769631f, -0.11152431f, -0.20574328f, 
    -0.06346539f, 0.12457142f, 0.08250751f, 0.15797170f, 0.06141256f, 0.09766255f, -0.40312308f, 0.13610119f, 
    -0.31433451f, 0.04554982f, 0.03487977f, 0.16895221f, 0.07796505f, -0.08191759f, -0.47222215f, -0.39869654f, 
    -0.03747202f, -0.06663491f, 0.06094486f, 0.05235464f, 0.07711207f, 0.04834755f, -0.05219350f, -0.28750613f, 
    -0.09930872f, -0.08683644f, 0.01113901f, -0.08851303f, 0.22301593f, -0.29687130f, -0.01070256f, -0.10171806f, 
    0.19862066f, 0.15312071f, 0.05071895f, 0.05202340f, -0.05191306f, -0.03361713f, -0.07274744f, 0.23671003f, 
    -0.08907422f, -0.14281879f, -0.42342106f, -0.06460473f, 0.27012748f, -0.07063899f, 0.32476807f, -0.10770118f, 
    0.03943879f, -0.24812926f, 0.19228193f, -0.23268130f, 0.01475134f, -0.00832292f, 0.22129218f, 0.03791476f, 
    0.04434810f, 0.07755339f, 0.05113634f, 0.11393244f, 0.17651086f, -0.13132352f, -0.00350607f, 0.09778620f, 
    -0.01935835f, 0.07138710f, 0.02647115f, -0.00410224f, -0.51448518f, -0.11581387f, 0.20524913f, -0.03708316f, 
    -0.13090344f, 0.11754111f, 0.28064504f, 0.01556618f, -0.09801825f, 0.04541050f, 0.21558094f, -0.07233147f, 
    0.13702174f, -0.14016266f, 0.20989044f, 0.38681427f, -0.09178098f, -0.03550266f, 0.36041731f, 0.20550679f, 
    0.09731235f, 0.02954251f, -0.21469265f, -0.16893180f, 0.20887259f, 0.09720890f, -0.03533407f, -0.26635760f, 
    -0.12901039f, -0.19894393f, -0.08658276f, 0.19378556f, 0.11193357f, -0.09337884f, -0.04096660f, -0.09257670f, 
    -0.37027776f, -0.16105357f, 0.08006039f, -0.20882680f, 0.11823494f, -0.08075667f, -0.15429454f, 0.04291047f, 
    0.04030041f, 0.08578019f, -0.33232814f, -0.47561365f, -0.00616209f, -0.16786180f, -0.12445907f, 0.25305125f, 
    -0.07795802f, -0.03841447f, -0.51804703f, 0.23152521f, 0.12981562f, 0.08751091f, -0.05540393f, 0.11467940f, 
    0.24963962f, -0.12919745f, -0.16313100f, 0.09188266f, 0.06790436f, 0.02768795f, -0.00117290f, -0.02025179f, 
    0.01126521f, 0.11119905f, -0.00949516f, 0.03145206f, -0.10021588f, -0.12800455f, -0.15287946f, -0.03912178f, 
    -0.12445039f, -0.01323820f, 0.03133504f, 0.02771960f, -0.01905530f, -0.26443243f, -0.32596827f, 0.05665844f, 
    0.11115232f, 0.13094570f, -0.10935412f, 0.17911603f, 0.10675543f, 0.09711719f, -0.34644628f, -0.35206637f, 
    0.10674644f, -0.12841150f, -0.12476894f, -0.08244212f, -0.01395652f, -0.09601234f, 0.05349048f, -0.24427804f, 
    0.14933056f, -0.14812593f, -0.14929536f, 0.08164383f, -0.06905462f, 0.01240324f, -0.10953702f, 0.00170205f, 
    -0.04083559f, -0.35935393f, 0.00660630f, 0.08903579f, 0.11018699f, 0.01603562f, -0.03958656f, 0.00826579f, 
    -0.11617012f, 0.40783882f, 0.17078316f, -0.03423692f, 0.11908991f, -0.13783959f, -0.06718555f, -0.16930822f, 
    0.08327760f, -0.14962289f, 0.09941250f, 0.32010448f, -0.25258896f, 0.14150438f, 0.14066362f, 0.17298412f, 
    0.14070068f, -0.26637688f, -0.25753090f, 0.33255586f, 0.08559089f, 0.01844539f, -0.02152798f, -0.07013628f, 
    -0.03750549f, 0.03723931f, -0.00014099f, -0.00389984f, 0.53405499f, 0.20843059f, -0.02875308f, -0.09721293f, 
    -0.08571767f, 0.03846328f, -0.11221413f, -0.10807591f, -0.01831372f, -0.58908391f, 0.21022139f, -0.35538423f, 
    -0.08891236f, -0.24303474f, 0.20109425f, -0.01639328f, 0.03103301f, -0.12518513f, -0.38289070f, 0.08388740f, 
    -0.07655423f, -0.06590160f, 0.20345889f, 0.00136667f, 0.15454066f, -0.05530646f, 0.10722093f, 0.29362726f, 
    0.01707542f, 0.23712337f, 0.08631369f, -0.00226641f, 0.04270141f, 0.03002878f, 0.02003035f, 0.12425310f, 
    0.44615215f, 0.39759150f, 0.11318609f, -0.14851831f, 0.11840539f, -0.05201929f, 0.00829763f, 0.15242596f, 
    0.10813772f, 0.02538442f, -0.17771564f, -0.06465221f, -0.05933485f, 0.00155553f, 0.24909088f, 0.11273227f, 
    -0.00284689f, 0.09759200f, 0.17304349f, 0.01494707f, -0.00874179f, -0.14146240f, 0.16655619f, -0.06870060f, 
    0.08873829f, 0.06689847f, 0.18875548f, -0.28746217f, 0.00821741f, -0.30974758f, -0.08582132f, 0.17583534f, 
    0.03690700f, 0.18785238f, -0.21754123f, 0.08826460f, -0.22634253f, -0.27952629f, -0.36648807f, 0.04926050f, 
    0.17710610f, 0.09081515f, -0.00081573f, -0.03265778f, -0.15533522f, -0.07032467f, -0.38946983f, 0.02150315f, 
    0.10278186f, -0.20785929f, 0.21001033f, 0.13027449f, -0.14252909f, 0.35486063f, 0.13371509f, 0.21621774f, 
    0.16522621f, -0.01802566f, 0.01163364f, 0.03746271f, 0.02862064f, 0.09457313f, -0.11748759f, 0.03429137f, 
    0.35569158f, 0.27425253f, -0.18698072f, 0.02764624f, -0.00889739f, -0.00783398f, 0.06632330f, -0.01231901f, 
    -0.24949777f, 0.04093478f, 0.03423170f, -0.07042516f, -0.06023324f, 0.03962847f, 0.04979774f, 0.00334703f, 
    -0.02519613f, -0.06401443f, 0.16107409f, -0.02698838f, 0.05824362f, -0.11500523f, -0.14542697f, -0.03929635f, 
    -0.06014636f, 0.02119374f, 0.07717641f, -0.17127055f, -0.09186044f, 0.10936290f, -0.17748149f, 0.27168518f, 
    0.04021466f, -0.14281419f, -0.14997233f, -0.03276151f, -0.05434288f, -0.23210740f, 0.13324448f, -0.00552491f, 
    0.18572488f, -0.10049400f, -0.21090871f, 0.07462898f, 0.27141535f, -0.22106050f, -0.00214504f, 0.11316366f, 
    -0.03087522f, -0.18710308f, -0.02252601f, 0.18496788f, 0.06876089f, 0.27409449f, -0.18425235f, 0.00751081f, 
    0.17990749f, 0.09326917f, -0.11780214f, -0.34171274f, -0.15598489f, -0.03711189f, -0.39467049f, -0.28914088f, 
    -0.01969317f, -0.10909189f, -0.10837012f, 0.00125661f, 0.22335786f, 0.19468826f, -0.09510482f, 0.38966331f, 
    0.23555383f, 0.20319405f, 0.01843805f, -0.18438387f, 0.01861574f, 0.14734827f, 0.06722222f, 0.06118473f, 
    -0.85502738f, -0.22431912f, 0.60546452f, 0.15251406f, 0.00271272f, 0.13619222f, -0.02337015f, -0.18617237f, 
    0.02275666f, 0.13979609f, -0.34006640f, 0.08075143f, 0.10131043f, 0.10885200f, -0.13808830f, -0.10531735f, 
    0.06556744f, 0.05462803f, 0.23036720f, 0.08690888f, -0.04642929f, -0.20197867f, -0.10582797f, 0.04104516f, 
    0.18268012f, 0.08481693f, 0.08344688f, -0.11925597f, 0.15212370f, -0.39022177f, 0.05586727f, -0.05006042f, 
    0.05427878f, -0.25773039f, 0.08595162f, 0.13721931f, 0.19921039f, -0.32232222f, 0.07120011f, -0.13577244f, 
    -0.17772537f, -0.06446460f, -0.06902403f, 0.09720442f, 0.02787215f, -0.60314399f, 0.14993055f, -0.19322757f, 
    -0.12285031f, -0.41983676f, -0.04967334f, -0.00349793f, 0.25375816f, 0.16788192f, -0.00337167f, -0.15815108f, 
    0.19533934f, -0.13416992f, -0.04095262f, 0.22232722f, -0.15099999f, -0.03062747f, -0.02829004f, -0.25709099f, 
    -0.10932816f, 0.35775846f, 0.13310631f, 0.14936443f, -0.18059368f, -0.17695363f, -0.09426907f, 0.14248037f, 
    -0.56020963f, 0.11952589f, -0.08912111f, 0.22060473f, 0.02905733f, -0.03586648f, 0.10169735f, -0.04395313f, 
    -0.11933088f, -0.56307560f, 0.34081525f, -0.29298413f, 0.34067002f, -0.08906095f, -0.08557778f, 0.00008015f, 
    0.20538817f, 0.11034205f, 0.33822677f, -0.07390060f, -0.66522241f, -0.04692847f, 0.21876122f, -0.05786273f, 
    0.00172833f, -0.00325220f, -0.10217204f, -0.16821459f, 0.21371825f, -0.06099382f, 0.14043099f, 0.29916230f, 
    -0.12112025f, 0.06637307f, -0.08363689f, 0.16112384f, -0.04476792f, 0.31946930f, -0.33756617f, 0.24373068f, 
    -0.07275252f, -0.01560868f, -0.12606709f, -0.02913390f, 0.10234202f, -0.25862277f, 0.07841852f, 0.15713228f, 
    0.13189541f, -0.17933732f, -0.04566215f, 0.10452710f, 0.07909661f, -0.14282627f, -0.12549549f, -0.20291719f, 
    0.20572177f, -0.09015126f, 0.12475188f, -0.04329694f, -0.16534202f, -0.00072203f, 0.19159363f, 0.13993844f, 
    -0.10470908f, 0.04540080f, -0.06660815f, 0.06152964f, 0.09551086f, 0.02458367f, -0.08027944f, 0.00546537f, 
    0.19296966f, 0.15984471f, 0.08574151f, -0.02533379f, 0.25224397f, -0.06534126f, 0.00116983f, 0.12063973f, 
    -0.13414407f, 0.07188499f, 0.08706943f, -0.64778948f, 0.05082840f, 0.00370579f, 0.15479849f, 0.06797561f, 
    0.03106455f, 0.04714851f, 0.49643904f, 0.06099089f, 0.18798988f, -0.13015229f, 0.20671619f, 0.03952000f, 
    0.00375016f, -0.01833559f, 0.10569508f, -0.29157525f, -0.19757323f, 0.48566848f, 0.07573004f, -0.13936165f, 
    -0.20172922f, 0.01157224f, 0.21482830f, 0.22111388f, -0.07342272f, -0.24389783f, 0.32468468f, 0.11731172f, 
    -0.34509048f, -0.00086114f, -0.09307723f, 0.07459132f, 0.02625650f, -0.18796219f, 0.41956535f, -0.09015007f, 
    -0.18301602f, -0.24290630f, -0.06490477f, 0.01218142f, -0.01049486f, 0.01828991f, 0.13644628f, 0.22212914f, 
    -0.05614506f, 0.20467891f, 0.04372910f, -0.12057664f, 0.06858906f, -0.00897522f, 0.18575540f, -0.29504117f, 
    0.00953091f, -0.03967150f, 0.03222242f, 0.28846982f, 0.10588118f, -0.04625345f, 0.10737672f, 0.00840611f, 
    -0.28527123f, 0.29306227f, -0.13503468f, -0.07554488f, 0.09235943f, -0.02865416f, -0.15618528f, 0.01820065f, 
    0.00556538f, 0.55016083f, 0.25126356f, 0.17820904f, -0.05329366f, 0.01308275f, -0.04978482f, 0.03166475f, 
    -0.04189645f, 0.09422957f, -0.32235792f, 0.04209726f, -0.19901684f, 0.11221831f, 0.02694603f, 0.12179188f, 
    -0.04387336f, -0.07280321f, 0.11693382f, -0.03313762f, 0.17767748f, -0.09626354f, 0.06262530f, -0.15522468f, 
    0.04036113f, 0.08712739f, -0.02770289f, -0.04278700f, -0.00340505f, -0.15986633f, 0.11894346f, -0.11320274f, 
    -0.07396374f, 0.12327507f, 0.07554450f, -0.06940869f, -0.09550340f, 0.07489119f, -0.07189267f, -0.51533520f, 
    0.02830277f, -0.02502445f, -0.00174923f, 0.05898530f, -0.00843728f, 0.05992607f, -0.26052368f, 0.10890751f, 
    0.05997670f, 0.00276658f, -0.04404531f, -0.08890191f, -0.04024484f, -0.19072980f, -0.03332644f, -0.27584580f, 
    0.00704930f, 0.06069330f, 0.27883777f, 0.08066558f, 0.06011035f, -0.03863189f, 0.09662388f, 0.06250647f, 
    -0.30751005f, 0.18540962f, -0.12410194f, 0.07025643f, 0.07190397f, -0.16504002f, -0.04162573f, 0.16472207f, 
    0.00737174f, -0.31741050f, 0.23765931f, 0.15588422f, -0.13452618f, 0.01516147f, -0.08845799f, -0.13988388f, 
    0.02214165f, 0.25943652f, 0.07307926f, 0.21296203f, -0.08351927f, -0.19829507f, 0.03117898f, 0.01105483f, 
    -0.00384913f, -0.09133555f, 0.10905948f, 0.34513646f, -0.14519484f, 0.38777566f, 0.10074962f, 0.21053262f, 
    -0.19769286f, 0.06480413f, 0.24289259f, -0.05742627f, -0.37680325f, 0.21106602f, 0.11155555f, -0.14231969f, 
    -0.02296146f, -0.05607276f, -0.43058223f, -0.07381595f, 0.05552154f, -0.33169824f, -0.14264992f, 0.07227368f, 
    -0.03785235f, -0.20696276f, -0.01039344f, -0.28156704f, -0.24012758f, 0.03401954f, -0.11694518f, 0.04425637f, 
    0.12045591f, 0.19303940f, 0.07981303f, -0.05561421f, 0.02344574f, 0.20264611f, 0.32138702f, 0.13585815f, 
    -0.09209093f, -0.04749164f, -0.07269339f, 0.07511085f, 0.03572257f, 0.11380073f, 0.19248988f, -0.06847771f, 
    0.09670798f, 0.12658973f, -0.19416448f, -0.10724018f, 0.05218095f, 0.04103124f, -0.03126483f, -0.20665118f, 
    0.02119778f, 0.43681216f, -0.25339752f, 0.23790127f, 0.04012083f, -0.05248367f, -0.14790559f, -0.03612226f, 
    0.07692113f, 0.02631907f, 0.20465383f, -0.00981856f, 0.07490396f, -0.08812045f, 0.00113591f, 0.16535956f, 
    -0.19803137f, 0.08866879f, -0.05394238f, -0.31244996f, 0.07473731f, 0.19980621f, -0.08041685f, 0.06691809f, 
    0.04872278f, 0.07206777f, 0.00062665f, -0.12962630f, 0.38619697f, 0.09034580f, 0.02600136f, 0.30498683f, 
    0.16743274f, -0.10575836f, 0.12081423f, -0.03436421f, 0.06253249f, 0.31465369f, 0.09694976f, -0.38621175f, 
    0.02206011f, -0.02747451f, -0.15647544f, 0.08371935f, -0.02240812f, 0.02660565f, 0.02909578f, 0.10667899f, 
    -0.14009999f, 0.03234576f, 0.08933320f, 0.12251948f, 0.06398392f, 0.27071026f, 0.01721585f, -0.33173344f, 
    0.18131767f, -0.07924602f, -0.12988368f, -0.18046355f, -0.15614912f, 0.28076836f, 0.25649133f, 0.09849670f, 
    0.09318852f, -0.29081017f, -0.14958140f, -0.17305437f, 0.05312615f, 0.10090745f, -0.09645061f, 0.10167458f, 
    -0.04618629f, 0.30255499f, 0.19614977f, -0.17762439f, 0.09123528f, -0.34911907f, -0.08221672f, 0.05566921f, 
    0.22672783f, 0.25620782f, 0.03241315f, -0.23366182f, -0.30915087f, 0.10446635f, -0.08951224f, 0.24945566f, 
    -0.18507983f, 0.12959269f, 0.06197536f, -0.32653597f, 0.17965637f, -0.37483570f, 0.13705342f, 0.02316602f, 
    -0.07880553f, -0.09857466f, 0.30138314f, -0.00757317f, -0.01245079f, 0.14551978f, -0.09071910f, -0.20642157f, 
    -0.11357353f, 0.14795619f, -0.19083020f, 0.08272571f, -0.07204562f, 0.51165742f, -0.36307988f, -0.08924870f, 
    -0.13048583f, -0.07938693f, -0.14051521f, -0.19242550f, -0.13527453f, 0.00387724f, -0.11657365f, -0.03213651f, 
    -0.09561772f, -0.11097185f, 0.05276691f, -0.09876804f, 0.08931515f, 0.18638359f, -0.29919097f, 0.27095351f, 
    -0.48047659f, -0.12411439f, 0.00354929f, 0.15591910f, 0.12652995f, -0.01861425f, -0.01801354f, 0.03816031f, 
    -0.21944235f, -0.17646451f, 0.08859773f, 0.11500672f, 0.02091452f, -0.17439446f, -0.34013671f, -0.10437642f, 
    0.19229515f, 0.30847204f, -0.03868884f, -0.04314710f, 0.09014934f, 0.02491084f, 0.12770133f, 0.00031492f, 
    -0.12187219f, 0.07586427f, 0.07465075f, -0.00662327f, -0.20379916f, 0.04761339f, 0.01310641f, -0.04821662f, 
    0.07779617f, 0.02382564f, 0.14948541f, -0.05537216f, 0.25812584f, -0.31139597f, 0.13766706f, -0.02176204f, 
    -0.00032174f, -0.09033645f, -0.02226616f, -0.04535192f, -0.26719499f, -0.13421088f, 0.05479788f, -0.01206720f, 
    -0.02747771f, -0.04348904f, 0.06733976f, -0.05225494f, 0.02172697f, 0.00790433f, 0.13926895f, -0.14113103f, 
    -0.03195545f, -0.10495078f, 0.04516754f, 0.03702059f, -0.14419813f, -0.04174140f, -0.00300065f, -0.00251168f, 
    0.02566460f, -0.22309381f, 0.10178703f, 0.20651837f, -0.15484694f, 0.09957725f, 0.10944522f, -0.12874596f, 
    -0.41243628f, 0.09815624f, 0.05310971f, 0.12265208f, 0.00151473f, 0.13530862f, 0.13687079f, 0.16137797f, 
    -0.04723511f, -0.00232603f, 0.04805999f, -0.00906476f, 0.02602534f, 0.03282997f, 0.03045702f, -0.01144313f, 
    -0.02347934f, -0.02804039f, 0.04216397f, 0.00681980f, 0.02578891f, -0.04596662f, 0.03084072f, -0.03759454f, 
    -0.02979031f, -0.04238129f, 0.04977219f, -0.02407895f, 0.02255478f, 0.04337394f, -0.03473659f, -0.00981604f, 
    -0.06507367f, -0.00863489f, 0.02742730f, -0.05642549f, -0.04048181f, -0.00176888f, -0.05129836f, 0.02534167f, 
    0.01703689f, -0.05558566f, -0.03651595f, -0.06241504f, -0.01648111f, -0.06821714f, 0.04571124f, 0.02060034f, 
    0.01711968f, 0.01463815f, -0.05133940f, -0.02758627f, 0.03737929f, -0.00257040f, 0.03617816f, -0.00567081f, 
    0.01785370f, -0.00112727f, -0.03678606f, -0.05548196f, -0.01645983f, -0.03301819f, 0.01461350f, -0.02079321f, 
    -0.06682038f, 0.03194195f, 0.00753192f, -0.02261206f, 0.04986373f, -0.03963704f, -0.05605989f, -0.00745808f, 
    0.04613750f, -0.02489924f, -0.03801593f, 0.03093782f, 0.02784731f, -0.05930542f, -0.01469611f, -0.04775651f, 
    -0.05766549f, 0.02835962f, -0.02224609f, -0.00226187f, -0.05930296f, -0.00838770f, 0.02989195f, 0.00702510f, 
    0.03686436f, -0.06997846f, -0.02781141f, 0.00801472f, -0.04546585f, -0.04078014f, -0.06633113f, -0.02613130f, 
    0.01239236f, -0.05209053f, 0.03678980f, -0.05155105f, 0.02750144f, -0.02437653f, -0.04568967f, 0.00772787f, 
    0.00550994f, 0.00689355f, 0.02833955f, 0.03300681f, 0.03399631f, 0.00662941f, -0.05574121f, -0.02244241f, 
    -0.00659523f, 0.00581373f, 0.04179082f, 0.01378248f, 0.03797899f, -0.01446909f, -0.05768166f, -0.02698113f, 
    -0.04759809f, -0.06516927f, -0.06217404f, 0.02227500f, -0.06329898f, 0.04317006f, -0.06334007f, 0.01565720f, 
    0.02003624f, 0.00357040f, -0.05500409f, 0.01191132f, 0.01025858f, 0.03045667f, -0.02994153f, -0.00239670f, 
    -0.05989902f, -0.00568066f, 0.03039045f, 0.02438525f, 0.01779296f, 0.00118761f, 0.01436419f, 0.02543786f, 
    0.00300541f, -0.00490858f, -0.03568548f, 0.00394348f, -0.00988428f, 0.03335160f, 0.01925360f, -0.06413896f, 
    0.01200097f, -0.06802882f, -0.06332708f, -0.05468977f, -0.03305768f, 0.02117890f, 0.00428081f, -0.03564293f, 
    -0.01256353f, -0.05781086f, -0.05030046f, -0.04661508f, 0.03914746f, -0.02910917f, -0.05727464f, -0.04590834f, 
    -0.00756981f, -0.02963813f, -0.05647418f, -0.03436556f, 0.01101409f, 0.04287254f, 0.04647994f, 0.04118149f, 
    0.03037324f, 0.05068406f, 0.04481301f, 0.03627063f, -0.01072733f, 0.02922097f, -0.03916598f, -0.01691145f, 
    -0.04207638f, 0.00271566f, 0.01487141f, -0.03626109f, -0.00356750f, 0.04326605f, 0.01375663f, -0.04117549f, 
    -0.04627779f, -0.03636836f, -0.05172584f, -0.02715258f, -0.04008467f, -0.00959750f, -0.04032467f, -0.02524487f, 
    0.04124163f, 0.00884240f, 0.01654294f, -0.02524190f, -0.01349033f, -0.02652687f, 0.03439934f, -0.02198007f, 
    -0.01336294f, 0.02915121f, -0.01737292f, -0.00843025f, 0.01436637f, -0.01857563f, -0.01992279f, -0.01813447f, 
    -0.02887863f, -0.06392099f, 0.02184344f, -0.01456119f, -0.04898192f, -0.04056910f, -0.01102845f, 0.01279897f, 
    0.00197795f, -0.06004191f, -0.05136506f, 0.03788960f, 0.02104425f, -0.06544318f, -0.03471319f, -0.00279493f, 
    -0.05765689f, 0.03246952f, 0.04983490f, 0.03686142f, -0.00996105f, -0.01982826f, -0.05258898f, -0.04797462f, 
    0.03822354f, 0.02389114f, 0.04664070f, -0.05543179f, -0.03453023f, 0.02659001f, -0.02128941f, 0.01718992f, 
    0.00668305f, -0.04673926f, -0.02770982f, -0.01659804f, 0.03122194f, -0.00687193f, -0.03652404f, 0.02992233f, 
    -0.02413697f, -0.01538226f, -0.00701026f, -0.05092010f, -0.04119769f, -0.00726835f, -0.03690328f, -0.04640416f, 
    -0.04112031f, 0.01093402f, -0.02378327f, -0.00032793f, -0.05469640f, -0.02092213f, -0.03955644f, -0.01730330f, 
    0.01666502f, -0.06648212f, -0.03081835f, -0.01414816f, -0.02426798f, 0.04301389f, 0.03739910f, 0.02000228f, 
    -0.01357891f, 0.01342073f, -0.00071125f, -0.02702283f, 0.02798345f, -0.04729891f, 0.02260131f, 0.01284721f, 
    -0.03900885f, -0.04652283f, 0.01627244f, 0.02931522f, -0.04355460f, -0.04964859f, 0.02576865f, -0.07104021f, 
    -0.20498118f, 0.10079558f, -0.26893377f, 0.01454263f, -0.15421943f, -0.08732115f, -0.08243299f, 0.10878928f, 
    0.09477412f, 0.06400403f, 0.23739487f, 0.18800834f, 0.08844061f, -0.05815708f, -0.04073685f, 0.01086568f, 
    0.05484809f, 0.33895427f, 0.34284225f, -0.11093198f, 0.08250648f, -0.16928713f, 0.23643441f, 0.13440576f, 
    -0.12053783f, 0.01653406f, -0.32439384f, 0.01625948f, 0.18823549f, -0.03537791f, 0.00749137f, -0.13717727f, 
    0.05892699f, -0.03804597f, 0.26893973f, -0.18683465f, -0.18540803f, -0.01610895f, -0.12847462f, 0.16809860f, 
    0.12539847f, -0.15255168f, 0.09594036f, 0.11629020f, 0.07835158f, 0.47788620f, -0.15294199f, -0.10878605f, 
    -0.07764211f, 0.04320154f, 0.05105803f, -0.17392796f, 0.02557452f, -0.06771521f, -0.02745921f, -0.00334017f, 
    0.07697050f, 0.00350639f, 0.13898635f, 0.01406365f, -0.05974603f, 0.09395406f, 0.01010617f, 0.23438443f, 
    0.20714577f, 0.16261306f, 0.02441248f, -0.22669056f, 0.09303938f, 0.09881820f, 0.17169353f, 0.03477469f, 
    -0.13263838f, 0.09050457f, 0.11982465f, 0.01829872f, -0.10115965f, -0.17893824f, -0.07012085f, -0.11136561f, 
    -0.09778329f, 0.17119092f, -0.10303526f, 0.35796121f, 0.19065394f, 0.11276653f, 0.11449705f, -0.00177425f, 
    -0.01837432f, 0.18660864f, 0.08990870f, 0.05671766f, 0.03961401f, 0.09818570f, -0.05919822f, 0.04487881f, 
    -0.08990805f, -0.14708529f, -0.11105134f, -0.67047369f, -0.31533411f, -0.16187537f, 0.09766733f, 0.23584989f, 
    0.21160108f, -0.05533953f, 0.22062726f, -0.00133656f, 0.03616425f, -0.43080035f, 0.10299765f, 0.31885782f, 
    0.19042635f, -0.18693952f, -0.13181058f, 0.00322004f, -0.00927147f, 0.12287896f, 0.07174552f, 0.02771323f, 
    -0.01699404f, -0.30283988f, -0.10411347f, 0.01753184f, 0.12941882f, -0.11163516f, 0.18718129f, 0.15258317f, 
    0.02801083f, 0.00383856f, -0.16956668f, -0.03361178f, 0.07744542f, 0.07560638f, -0.10595874f, 0.23386328f, 
    0.14108403f, -0.00405528f, -0.39493987f, 0.01033995f, -0.18882705f, -0.02632892f, 0.12753409f, 0.04455943f, 
    -0.06674030f, -0.15940826f, -0.11979866f, -0.05053818f, -0.12962224f, 0.02856146f, -0.05655801f, -0.14684328f, 
    -0.01887659f, 0.23302291f, -0.06570299f, 0.04822579f, 0.06753713f, -0.05638516f, -0.01624721f, -0.02659930f, 
    0.10970890f, 0.10278105f, -0.14292586f, -0.29437932f, -0.17037180f, 0.05489383f, 0.15312405f, -0.17426178f, 
    0.13988523f, 0.05776053f, -0.01261850f, -0.04112516f, 0.23153223f, 0.10761075f, -0.17961329f, 0.13078478f, 
    -0.04147994f, -0.13628672f, -0.08039184f, 0.07996671f, 0.08818537f, -0.03064280f, 0.17441101f, 0.06182720f, 
    -0.23460728f, 0.05021307f, 0.17975883f, 0.19507574f, -0.12834688f, 0.55566102f, 0.08284770f, -0.07515171f, 
    -0.39491600f, 0.17621148f, -0.11067958f, -0.21062878f, -0.10672881f, -0.03185588f, -0.24149688f, -0.26871973f, 
    -0.14185527f, 0.02894882f, -0.03038861f, 0.07425305f, -0.01452799f, 0.23787405f, 0.00450818f, -0.18116802f, 
    -0.49095783f, -0.46336606f, 0.25528100f, -0.05402574f, 0.18009104f, 0.08025534f, -0.00963292f, 0.16370149f, 
    -0.18766303f, 0.08902732f, 0.17111062f, 0.08588129f, -0.05040406f, 0.01608074f, -0.06780123f, -0.12578724f, 
    -0.09824242f, 0.25976577f, -0.06433126f, -0.10286327f, -0.12754104f, 0.08002492f, 0.00482880f, -0.33223361f, 
    0.03182594f, -0.18762752f, 0.38119632f, 0.14205395f, 0.26600358f, 0.08837602f, 0.06448390f, 0.03051593f, 
    -0.20042190f, 0.03726530f, -0.02967299f, -0.07158299f, 0.03265543f, 0.15998033f, 0.04412711f, -0.24002194f, 
    0.01264968f, -0.00938808f, 0.03581869f, -0.36346468f, 0.04437733f, -0.04877172f, 0.25432515f, 0.14226685f, 
    -0.02306517f, -0.05359402f, -0.18376783f, 0.05201542f, 0.01696994f, 0.14838079f, 0.12844633f, 0.09045580f, 
    0.19152555f, 0.03869796f, -0.05655069f, -0.10678744f, -0.21951644f, -0.30210677f, -0.01905632f, -0.03408122f, 
    0.09806538f, -0.07787179f, -0.09252648f, -0.12397891f, -0.12713864f, 0.12481560f, -0.28337911f, -0.30832157f, 
    -0.73513460f, -0.17180932f, 0.13233978f, 0.07590307f, 0.07405016f, 0.04006141f, 0.08549351f, 0.20410970f, 
    0.12243215f, 0.12186919f, 0.11675664f, 0.09609868f, -0.00667945f, -0.09869853f, 0.06192222f, -0.10240571f, 
    -0.08831281f, 0.01712616f, -0.04776775f, 0.18675600f, -0.22225443f, 0.08454040f, -0.00386908f, -0.18537043f, 
    0.22038527f, 0.26370537f, -0.17155114f, -0.12317218f, 0.23193568f, -0.24326973f, 0.00391294f, 0.12103394f, 
    0.22481371f, 0.25682095f, 0.14414150f, 0.03374146f, 0.03822431f, -0.00866943f, 0.09640716f, -0.03146338f, 
    -0.19944330f, -0.08859138f, 0.01269909f, 0.24304281f, 0.11578459f, 0.07388879f, -0.03683619f, -0.04171831f, 
    -0.06934397f, 0.11478645f, -0.09288860f, 0.09471449f, -0.03158624f, -0.14900790f, -0.20486967f, -0.27043518f, 
    -0.01908295f, -0.18426518f, -0.05349817f, 0.02821821f, 0.04932261f, 0.11298516f, 0.15648083f, 0.07633983f, 
    -0.07071960f, 0.02077972f, -0.08018062f, -0.07000668f, 0.01935400f, -0.02841390f, -0.23016721f, 0.22359720f, 
    -0.18065435f, 0.34889379f, -0.08861125f, 0.01361494f, 0.17724855f, 0.04752292f, -0.04343871f, 0.29559475f, 
    -0.29507774f, 0.03338270f, -0.11352256f, 0.15649900f, 0.18105575f, 0.03171580f, 0.06215347f, -0.11705515f, 
    0.05732693f, 0.15346833f, 0.02711884f, -0.21218669f, 0.04198134f, -0.17884655f, -0.17690064f, 0.12389577f, 
    -0.04075651f, -0.08306077f, 0.14523676f, -0.02161577f, -0.24579296f, -0.07372087f, 0.24771757f, 0.12331867f, 
    0.25617838f, -0.23804449f, -0.33727700f, -0.02453249f, 0.15763609f, -0.26669741f, 0.12756482f, -0.08231975f, 
    0.05460522f, 0.20519157f, -0.05741268f, 0.02954448f, 0.26727083f, -0.08313414f, -0.62571478f, 0.08680577f, 
    -0.08205058f, -0.08554161f, -0.41541183f, 0.13239399f, -0.29891634f, -0.04023349f, 0.07145149f, 0.01763436f, 
    0.03149726f, 0.00750125f, 0.03818878f, 0.07674160f, -0.12353034f, 0.03656638f, 0.42849174f, -0.05074502f, 
    0.07952759f, -0.21034536f, -0.03624737f, 0.09687504f, 0.12891822f, -0.05257611f, 0.01544006f, -0.06104341f, 
    -0.06088206f, -0.27805194f, 0.03803273f, -0.01275118f, 0.02643713f, -0.18141589f, 0.07815784f, -0.13912888f, 
    0.32424077f, 0.18678677f, 0.04956777f, -0.19317533f, 0.10035241f, 0.00369178f, 0.04027421f, -0.11952343f, 
    -0.16484216f, 0.15602478f, 0.16602188f, -0.19589888f, 0.10822901f, -0.01750777f, -0.10835801f, 0.26047632f, 
    0.08201712f, 0.06915127f, 0.46894366f, 0.19114849f, -0.01847412f, -0.14979203f, -0.03129798f, 0.18255050f, 
    -0.00414598f, -0.04380477f, -0.21308668f, -0.15561248f, -0.18306087f, 0.18719268f, 0.12267246f, 0.04164952f, 
    0.00540511f, 0.27401328f, -0.23395149f, -0.23758167f, 0.12720279f, -0.16711189f, 0.38674223f, -0.11384150f, 
    0.06685270f, -0.03217552f, 0.07242541f, 0.10214370f, 0.26953071f, -0.06303728f, -0.09266988f, -0.49497035f, 
    -0.18754722f, -0.06953026f, 0.22320093f, 0.07921951f, -0.12101766f, -0.02977085f, 0.35900116f, 0.21496484f, 
    -0.31079984f, -0.01541571f, -0.08742698f, -0.15469883f, 0.22766738f, -0.07635039f, 0.07791787f, 0.38012257f, 
    -0.01108189f, -0.05296708f, -0.03468598f, 0.01616241f, 0.02513154f, 0.02229614f, 0.03344360f, -0.11416150f, 
    -0.02148782f, 0.16628711f, 0.03245210f, 0.06623214f, 0.07765413f, 0.08834627f, -0.01831966f, -0.13801615f, 
    -0.27304733f, -0.16493548f, 0.04991786f, -0.34701133f, -0.15140684f, -0.03678020f, -0.10436045f, -0.02629465f, 
    -0.11388583f, 0.05985534f, 0.08765841f, 0.02344576f, -0.07085857f, 0.01986575f, -0.03286620f, -0.14848302f, 
    0.21729404f, 0.26675934f, 0.13808295f, -0.44712880f, -0.03324590f, -0.11019115f, 0.20727624f, 0.00475286f, 
    0.02951900f, -0.08997563f, -0.11027370f, 0.24469942f, -0.01336452f, -0.19444068f, 0.06969471f, -0.13264431f, 
    0.27715781f, -0.03429687f, 0.20051551f, 0.00996754f, -0.00881564f, 0.32792598f, 0.06654438f, -0.29712370f, 
    0.20111541f, -0.07397821f, 0.04810036f, -0.00943474f, -0.00188022f, 0.07773387f, -0.27688104f, 0.38774866f, 
    0.09229752f, -0.22799234f, 0.13661394f, -0.16871519f, 0.02611139f, -0.17438470f, 0.00090969f, 0.09063993f, 
    -0.14279954f, 0.00122782f, -0.20229843f, -0.03625971f, -0.08901533f, 0.05640065f, 0.04180416f, -0.02195966f, 
    0.11184373f, -0.09891493f, -0.01164764f, 0.24246208f, 0.15526758f, 0.20808606f, 0.17275096f, -0.13598341f, 
    0.00808659f, -0.00978998f, 0.21121597f, -0.31121036f, 0.26888219f, -0.02707229f, 0.11100832f, 0.20435053f, 
    -0.09948712f, 0.16742313f, 0.20021872f, -0.30383253f, -0.25764456f, 0.24807690f, -0.03827733f, 0.06008458f, 
    0.06138226f, 0.19586936f, 0.30176792f, -0.20883135f, -0.17946208f, 0.05542534f, -0.15557851f, 0.06514514f, 
    -0.46023312f, -0.14117670f, 0.02865220f, 0.02736250f, -0.11600082f, 0.03426022f, -0.18658999f, 0.37413189f, 
    -0.22575244f, -0.07422027f, 0.09398477f, 0.10900091f, 0.10330793f, 0.56209201f, -0.00936419f, -0.03998111f, 
    -0.26362377f, 0.02986027f, -0.11791480f, -0.15307657f, 0.21208343f, 0.08372373f, -0.04146831f, 0.32523867f, 
    0.15689227f, 0.08342594f, 0.00455774f, 0.12570657f, -0.04620290f, 0.03532117f, 0.12983795f, -0.15375994f, 
    0.16352834f, -0.22026472f, 0.31240985f, 0.17987967f, 0.02160585f, 0.10671254f, 0.00037771f, 0.20323566f, 
    -0.25869471f, -0.19699919f, 0.12869354f, 0.17375588f, -0.01202980f, 0.22929752f, -0.10543026f, -0.23942327f, 
    0.17840451f, -0.16151953f, -0.09734528f, 0.27092645f, -0.02947920f, -0.11729927f, 0.02056112f, -0.08539325f, 
    0.20489344f, 0.19992705f, 0.02154893f, -0.25495839f, 0.42763385f, -0.19351341f, -0.20765135f, 0.01492043f, 
    -0.06154605f, 0.22919464f, 0.09520683f, 0.15133908f, 0.03299128f, 0.15907398f, 0.26633304f, -0.17200431f, 
    -0.31954265f, 0.17966288f, 0.23545696f, 0.27046379f, -0.19535089f, 0.15411124f, 0.09702298f, -0.00101953f, 
    -0.33024698f, -0.07786036f, -0.02106393f, -0.05456565f, 0.09938614f, -0.14694393f, 0.07916944f, 0.23881741f, 
    0.27801535f, 0.07266135f, -0.02858606f, 0.09288556f, -0.11320293f, -0.15683737f, -0.03637319f, 0.15382525f, 
    -0.14744093f, 0.34456334f, 0.21699715f, -0.09570971f, 0.12251612f, -0.02228598f, -0.12388162f, -0.51708990f, 
    -0.51392984f, -0.28521311f, -0.20729806f, 0.25409564f, 0.09436764f, -0.14815913f, -0.00336866f, -0.22614631f, 
    0.08781800f, -0.01700874f, -0.05567850f, -0.18637687f, -0.08691163f, -0.01798711f, -0.02668956f, -0.01418681f, 
    0.04000346f, 0.11515030f, 0.13623759f, 0.40981439f, -0.04514876f, -0.07517151f, -0.09874703f, 0.15668362f, 
    0.02157957f, 0.12932903f, -0.09961198f, 0.34613574f, -0.21055022f, -0.03295146f, 0.06623103f, -0.09188586f, 
    0.04516415f, 0.26937586f, 0.26072457f, -0.31710625f, -0.13465638f, 0.33632976f, 0.34345213f, -0.02577895f, 
    0.12974238f, 0.11900601f, 0.24649432f, 0.17821392f, -0.18289338f, 0.04938664f, -0.17902288f, 0.20387292f, 
    -0.10021512f, -0.05882028f, -0.05663779f, -0.05997115f, 0.18975557f, -0.16449212f, -0.18606824f, -0.24024285f, 
    0.29793233f, -0.00729277f, 0.07838972f, -0.12755035f, -0.05761373f, -0.14579022f, 0.07576431f, 0.15891944f, 
    0.15567277f, 0.21903893f, 0.13895644f, -0.11056759f, 0.18263844f, 0.06401151f, 0.36146796f, -0.21666826f, 
    -0.04168198f, 0.08894263f, 0.00497533f, 0.05767740f, -0.03352611f, -0.10239232f, -0.01935173f, -0.04140093f, 
    -0.15830745f, 0.21170305f, -0.23829114f, 0.31404877f, -0.01402810f, 0.00452692f, 0.17117955f, 0.12576842f, 
    0.23031282f, -0.09283641f, 0.22333579f, 0.04165354f, 0.01202580f, -0.26431999f, 0.07836531f, 0.13540006f, 
    -0.08903699f, 0.02985166f, 0.17730883f, -0.02074246f, 0.22488737f, -0.06206526f, 0.03343602f, 0.05203805f, 
    -0.03948792f, 0.04790800f, -0.09017061f, -0.58785820f, -0.12296069f, 0.02588830f, 0.18280074f, -0.05422628f, 
    0.06571904f, -0.08403146f, -0.18818103f, -0.14941494f, 0.03687329f, 0.17784058f, -0.04343505f, 0.14579105f, 
    -0.01619361f, -0.33459157f, 0.03965081f, 0.04021157f, 0.24715215f, -0.41383138f, -0.21497659f, 0.12609439f, 
    -0.36456847f, 0.07071229f, 0.23621404f, -0.26660120f, -0.12285303f, -0.03662035f, -0.34641856f, -0.19635709f, 
    -0.26015955f, -0.03280134f, -0.10748778f, 0.00558424f, -0.06109628f, -0.04755689f, 0.12479491f, 0.15455648f, 
    -0.07159834f, 0.28721145f, -0.01190535f, -0.02513472f, -0.12936200f, 0.09470891f, 0.07282712f, 0.04416217f, 
    0.00166375f, -0.02105474f, 0.00392242f, -0.01643657f, -0.04152095f, 0.01516603f, -0.02844638f, 0.00081839f, 
    -0.05562014f, -0.03071257f, -0.02429127f, -0.01211144f, -0.00475169f, -0.03325490f, -0.01937850f, 0.02416721f, 
    -0.04209199f, -0.05637906f, -0.01164237f, 0.03338418f, -0.01754376f, -0.00158333f, 0.02329243f, 0.01611533f, 
    0.00062571f, 0.01771533f, -0.02334062f, -0.05441915f, -0.01964516f, 0.01681340f, -0.00323574f, 0.03203699f, 
    0.01763479f, -0.06402324f, 0.02583719f, -0.02220501f, -0.06036207f, -0.00893234f, 0.04765155f, 0.02636785f, 
    -0.05841221f, -0.01405547f, 0.01201590f, -0.05370981f, 0.04782066f, 0.03737415f, -0.04466502f, 0.05244860f, 
    0.00014675f, 0.03244812f, 0.03639197f, 0.00416436f, -0.00531015f, 0.02839899f, -0.04550289f, 0.00700389f, 
    0.03246327f, -0.05045066f, -0.04083112f, -0.03962739f, 0.04450432f, 0.03746971f, -0.02781993f, 0.01012291f, 
    0.04478428f, -0.03784719f, 0.04146580f, -0.06371299f, 0.00083172f, 0.04658682f, -0.00783578f, -0.05515780f, 
    0.04187259f, -0.04050440f, 0.04735028f, -0.02234280f, -0.01617375f, -0.02770491f, -0.00938287f, 0.02644428f, 
    -0.01891176f, -0.02850281f, -0.01534239f, 0.01461689f, 0.04137752f, 0.00251466f, -0.03110079f, -0.00388359f, 
    0.00281660f, -0.02309386f, -0.05066948f, 0.04355788f, 0.04047518f, 0.03046542f, -0.02557021f, -0.03128645f, 
    -0.01692051f, 0.04058145f, -0.00932777f, -0.01644716f, -0.06352963f, -0.05588608f, -0.00242313f, -0.06399275f, 
    -0.01909594f, 0.00654265f, -0.06466641f, -0.05181015f, 0.00956983f, -0.04638110f, -0.00107991f, 0.04449581f, 
    0.02260672f, -0.04237215f, -0.03644446f, -0.02303541f, 0.03378773f, 0.02793423f, -0.05642856f, 0.00372758f, 
    -0.02479224f, -0.04943260f, -0.02211404f, 0.01054601f, -0.02149217f, -0.03383520f, -0.06126881f, -0.00448894f, 
    -0.00603243f, 0.03075554f, -0.05237616f, -0.02336914f, -0.04170428f, -0.04820396f, 0.02329754f, 0.00770420f, 
    0.00733936f, 0.04803539f, -0.02436938f, -0.00265799f, 0.01780048f, 0.02901704f, -0.04711013f, -0.04396856f, 
    -0.03059807f, -0.04402370f, 0.00823268f, 0.01128769f, 0.00257025f, -0.06346355f, 0.01828504f, 0.03124284f, 
    0.04247719f, -0.04951650f, 0.02333591f, 0.04072182f, -0.03577236f, 0.00891801f, 0.01122964f, -0.01788250f, 
    -0.01479136f, -0.04559721f, 0.03727556f, -0.00184196f, -0.01714635f, 0.01082154f, 0.02987044f, -0.04351316f, 
    0.02355345f, -0.02278845f, -0.02119468f, 0.02427925f, 0.03396436f, 0.01449156f, -0.04548781f, -0.01366835f, 
    0.05421446f, -0.00596234f, 0.04240394f, 0.03169524f, -0.03920938f, 0.03088594f, 0.01453349f, -0.01849018f, 
    0.04369174f, -0.05118780f, 0.02833373f, -0.04903804f, 0.00253214f, -0.02830116f, -0.02954418f, -0.01137491f, 
    -0.03740047f, -0.01245332f, 0.02886757f, 0.00849032f, 0.02298948f, -0.05940008f, -0.01727647f, -0.04137738f, 
    -0.05245467f, 0.03849282f, 0.02481017f, -0.06297069f, 0.03852909f, 0.05044769f, 0.00027676f, 0.01566835f, 
    0.01971660f, -0.06373014f, -0.03062635f, -0.04226892f, -0.05899001f, 0.03671912f, 0.04996470f, -0.04551557f, 
    -0.02789276f, 0.00505842f, -0.00572072f, -0.01937707f, -0.02204138f, 0.01830452f, 0.00589490f, -0.05829285f, 
    -0.01618269f, -0.04244512f, -0.06037366f, -0.05457576f, -0.00205111f, 0.00149178f, 0.03012509f, -0.04725202f, 
    0.05242795f, 0.03508817f, -0.05698766f, -0.04156230f, 0.02595954f, -0.03666929f, 0.03654867f, 0.03459389f, 
    -0.05204634f, -0.05126792f, -0.01439382f, 0.00567836f, -0.05158841f, -0.01900502f, -0.02759690f, 0.00047997f, 
    0.02479678f, -0.05752445f, -0.00526587f, -0.03702684f, 0.01795922f, -0.06029196f, -0.01442208f, 0.02876951f, 
    0.05416476f, -0.05632180f, -0.06097268f, 0.01902966f, 0.04254562f, -0.02061592f, 0.03673027f, 0.01623079f, 
    0.01617067f, -0.05732105f, -0.01504484f, -0.01447140f, 0.00790782f, 0.00645542f, -0.01437317f, -0.03992651f, 
    -0.04322603f, -0.03222349f, -0.04083003f, 0.06213545f, -0.02623976f, 0.00992264f, 0.04454048f, 0.02489577f, 
    0.04390139f, -0.00972176f, -0.06002793f, -0.00735317f, 0.04599538f, -0.04684316f, 0.01667626f, -0.05271149f, 
    -0.00333891f, -0.01892140f, -0.00953123f, -0.00175783f, -0.05825117f, -0.02246332f, -0.03633169f, -0.03782348f, 
    -0.00075465f, 0.00782843f, -0.02269613f, -0.05311665f, -0.05039592f, 0.02467982f, -0.00958316f, -0.03943268f, 
    0.04471004f, 0.03628689f, 0.02570301f, 0.00236087f, -0.04689645f, -0.03976792f, -0.05649365f, 0.00698007f, 
    0.03671015f, 0.04716642f, -0.05526005f, 0.03720334f, -0.05711296f, -0.02890882f, 0.02243183f, 0.01143705f, 
    0.02048896f, 0.02520266f, -0.04877798f, 0.00427037f, 0.04575861f, 0.02752433f, 0.01387502f, -0.03057000f, 
    -0.00299817f, 0.02357190f, 0.04681861f, -0.03214232f, -0.06191901f, 0.02025260f, -0.04174710f, -0.02751815f, 
    0.02002732f, -0.06069731f, 0.01047715f, -0.02511925f, 0.04506993f, -0.01691328f, 0.03622933f, -0.06596136f, 
    0.03422632f, -0.02950899f, -0.05193563f, -0.05900187f, -0.02011468f, -0.03796502f, 0.02945809f, 0.04257887f, 
    -0.03920259f, -0.04775229f, -0.02583670f, -0.03558068f, -0.01169766f, 0.00103911f, -0.02244864f, -0.03868853f, 
    -0.04901798f, -0.02798836f, -0.02474656f, -0.01580671f, -0.04384229f, -0.02972091f, -0.00016642f, -0.02620327f, 
    0.02759474f, 0.02033451f, 0.05591681f, -0.03795934f, -0.01291691f, -0.02223398f, -0.04954002f, 0.05024509f, 
    0.04591255f, -0.03225379f, -0.06688882f, -0.04049431f, -0.02399351f, -0.06010918f, -0.06343159f, 0.00845842f, 
    -0.01916241f, -0.04491752f, 0.02228557f, 0.01973630f, 0.02905873f, -0.06544582f, -0.00322863f, -0.03833858f, 
    0.01618053f, 0.01535455f, -0.06021008f, -0.06664168f, -0.04673341f, -0.01723745f, 0.00357600f, 0.01251157f, 
    -0.01348606f, -0.01359333f, -0.05322472f, -0.04243711f, 0.02559561f, 0.04023803f, 0.00964674f, 0.00250976f, 
    0.03430583f, -0.04191397f, -0.03015112f, 0.00394043f, 0.00750282f, 0.02025914f, -0.02019325f, -0.02248512f, 
    0.03776042f, 0.03191865f, 0.03269310f, -0.03032840f, -0.02602403f, -0.04361412f, -0.01041699f, -0.01798197f, 
    -0.01414122f, -0.01707071f, -0.01274342f, -0.04475632f, -0.05446316f, -0.03736108f, -0.01582417f, -0.03942866f, 
    -0.04465080f, 0.04437449f, 0.01651238f, -0.04864438f, 0.02503600f, -0.00385435f, 0.05140786f, -0.01378529f, 
    -0.04112217f, 0.02527604f, 0.04142131f, -0.00120134f, 0.01610769f, -0.06260668f, -0.02269804f, 0.00500763f, 
    -0.00725115f, -0.05697822f, 0.04259708f, -0.01073545f, -0.03947699f, 0.04121716f, -0.01180543f, 0.00067204f, 
    -0.06176748f, -0.05896126f, -0.00713956f, -0.00183749f, 0.03932638f, 0.02536550f, -0.00678978f, -0.05979164f, 
    -0.00382691f, -0.02312573f, -0.00905256f, -0.06602558f, -0.01773576f, 0.02229399f, -0.01472839f, -0.03727734f, 
    -0.03929225f, -0.01965932f, 0.01624379f, 0.03824472f, 0.02835669f, -0.02015452f, -0.00708678f, 0.03940807f, 
    0.03418531f, 0.03497208f, -0.03302223f, 0.00250638f, -0.03910439f, -0.03383711f, 0.03878870f, -0.04552535f, 
    0.04770095f, 0.02162145f, 0.00768566f, 0.04631848f, -0.00965054f, -0.04014579f, 0.00804615f, -0.06250153f, 
    0.02214621f, -0.06212953f, 0.02236911f, -0.00265398f, -0.04881831f, 0.03479582f, 0.01781752f, -0.00543705f, 
    -0.00444876f, -0.01778010f, 0.01758384f, 0.03436635f, -0.06191591f, -0.04559851f, -0.00697535f, 0.04594539f, 
    -0.04035675f, -0.05670135f, 0.01667807f, -0.03627705f, -0.06318454f, 0.00367063f, 0.04092268f, 0.02853208f, 
    0.01825753f, -0.04259424f, 0.00246780f, -0.05283292f, -0.04552251f, -0.03936608f, -0.04463697f, 0.01580003f, 
    -0.01141844f, 0.03777682f, 0.01366566f, -0.01109626f, -0.02020408f, -0.03721209f, 0.04872622f, 0.03348023f, 
    -0.06158959f, -0.03700208f, 0.01036271f, -0.02259782f, -0.03208062f, 0.04741364f, 0.01973102f, 0.01185020f, 
    -0.02282628f, -0.06027844f, 0.00796201f, 0.04676674f, -0.03550834f, -0.04813950f, 0.01121455f, -0.06213069f, 
    0.01431871f, 0.03366443f, 0.00632029f, 0.02928944f, 0.00955231f, 0.03747924f, 0.01699958f, -0.03134939f, 
    -0.04583871f, 0.00532285f, 0.05036417f, -0.06561517f, -0.03033504f, -0.01184668f, 0.03089651f, -0.05212232f, 
    -0.00558419f, -0.01640215f, 0.03789628f, -0.05506365f, 0.03698533f, 0.02071028f, 0.04286561f, 0.03733651f, 
    0.14748575f, 0.28440726f, 0.11159946f, -0.08735818f, -0.10018265f, 0.34607720f, 0.15067437f, 0.04216959f, 
    -0.06608651f, 0.11120867f, 0.38861564f, 0.10796817f, 0.15657949f, 0.10883030f, -0.08155855f, 0.20810844f, 
    0.03327281f, -0.13931742f, 0.12340675f, 0.08487099f, -0.22240683f, 0.24463993f, -0.01617352f, 0.00454702f, 
    -0.09644031f, -0.09520753f, 0.10768811f, -0.18247899f, -0.15704949f, 0.23191774f, -0.15725906f, -0.08311953f, 
    0.13667046f, -0.01679671f, 0.08038898f, 0.07945504f, 0.16604899f, 0.21675964f, 0.16262835f, -0.06707573f, 
    -0.10066585f, -0.28559473f, 0.21407689f, -0.09161384f, -0.14931038f, 0.11937396f, 0.06227764f, -0.10186149f, 
    -0.26854888f, 0.14456370f, -0.37125090f, -0.00448644f, 0.06816656f, 0.15924874f, 0.07393674f, 0.39604628f, 
    0.22892433f, -0.04937155f, 0.12395407f, -0.10297700f, 0.01463095f, -0.08896811f, 0.00741258f, 0.11981390f, 
    0.34467247f, -0.01993066f, 0.03881865f, 0.01902684f, -0.17221652f, 0.17511907f, 0.07649215f, -0.00048743f, 
    -0.31446758f, -0.16970280f, -0.32865569f, 0.03903613f, -0.08220479f, -0.02277566f, 0.05538106f, -0.05028238f, 
    -0.07445536f, -0.23325463f, -0.04231141f, -0.03057217f, 0.08423710f, -0.07387476f, -0.08818444f, 0.01160471f, 
    -0.13916315f, 0.08040892f, -0.32429585f, -0.19772285f, 0.02042639f, -0.12917058f, -0.13456348f, -0.12153947f, 
    0.10083191f, -0.11825968f, 0.27594182f, 0.34241310f, 0.27520889f, 0.01974325f, -0.29005584f, 0.00402829f, 
    -0.15707634f, -0.10398290f, 0.33585933f, 0.12407576f, -0.02658565f, -0.12095147f, -0.02748522f, -0.01278527f, 
    0.03420780f, -0.04406058f, -0.16429153f, 0.05117726f, -0.06943200f, 0.09240517f, 0.23032843f, 0.13933013f, 
    -0.08122477f, -0.00242282f, 0.13812822f, 0.24144872f, 0.00922622f, -0.31116393f, -0.32812172f, 0.54074794f, 
    0.10005661f, 0.03634038f, -0.15855667f, 0.16287772f, 0.16787802f, 0.16073222f, -0.01884775f, -0.11217780f, 
    -0.14651933f, -0.37883776f, -0.02775427f, 0.23122241f, 0.09119681f, 0.15460052f, 0.02481219f, 0.25204057f, 
    -0.01911735f, -0.23113985f, 0.13384257f, 0.16429013f, -0.14682832f, -0.05856438f, -0.06177204f, -0.27802408f, 
    0.11352462f, -0.16183844f, -0.35441288f, 0.14253253f, -0.09720084f, 0.21474443f, -0.09748241f, 0.20887600f, 
    0.08892687f, 0.12942454f, -0.06659152f, -0.28418505f, 0.35148332f, -0.08637377f, -0.00921103f, -0.05441677f, 
    -0.04467183f, 0.04734028f, -0.09869842f, -0.12798567f, 0.50151139f, 0.02550548f, 0.06963819f, -0.14559086f, 
    0.08855405f, -0.03279888f, -0.03626597f, -0.01952038f, 0.31751895f, 0.31549987f, -0.14389414f, 0.11501531f, 
    0.08706709f, -0.09232317f, 0.07299498f, -0.02229979f, -0.07330383f, 0.00325400f, -0.38058081f, -0.25796691f, 
    -0.07182333f, -0.09226195f, -0.19246542f, -0.02388628f, 0.10980454f, 0.06186620f, 0.03218788f, 0.10453669f, 
    0.13184597f, 0.15204038f, -0.26856473f, -0.11340234f, -0.07572582f, 0.21794771f, 0.04562988f, 0.02106522f, 
    -0.12008070f, 0.10725612f, 0.20441575f, 0.00389040f, -0.00626772f, -0.12440553f, 0.02324771f, 0.00106417f, 
    0.38924906f, -0.03211496f, 0.02093386f, 0.01751349f, 0.16997044f, -0.06816841f, 0.00115940f, 0.02774170f, 
    0.13014819f, 0.12223347f, -0.21788754f, 0.08982248f, -0.06248252f, -0.14163920f, -0.09781808f, -0.00522311f, 
    0.01926660f, -0.05427475f, -0.01957062f, -0.39939436f, -0.44578758f, -0.01311067f, 0.00546316f, 0.10229330f, 
    0.04500548f, -0.01246744f, -0.13914792f, 0.27585399f, 0.07453439f, 0.03968875f, -0.04846373f, 0.04249812f, 
    -0.07732144f, 0.13625988f, -0.13572672f, -0.22971283f, -0.26309937f, 0.03319872f, 0.03722670f, 0.08705334f, 
    -0.19173859f, 0.07863205f, 0.22037303f, -0.12782376f, -0.15393229f, 0.09164990f, -0.57545453f, -0.18243694f, 
    0.02782305f, -0.06679626f, -0.03099585f, -0.04341973f, -0.01435359f, -0.08409940f, -0.78523904f, -0.01522336f, 
    -0.25288910f, -0.10317744f, -0.04720326f, -0.12340752f, 0.08680411f, -0.09915716f, 0.06466909f, -0.01741466f, 
    0.02813987f, 0.00644361f, 0.12861839f, -0.11239399f, -0.05413271f, -0.02645665f, 0.06179427f, 0.11390740f, 
    0.04895218f, 0.03146144f, -0.00199267f, -0.02389793f, 0.09231421f, -0.24396841f, -0.13991995f, -0.10462017f, 
    -0.11088429f, 0.43965092f, 0.05168666f, -0.38401529f, 0.09544165f, 0.03904393f, -0.06855099f, 0.10411358f, 
    0.05928093f, -0.10469341f, -0.25017676f, 0.06335423f, 0.22921786f, -0.17050087f, 0.06528202f, -0.00285279f, 
    -0.01126494f, 0.10350374f, 0.00437685f, 0.04970918f, -0.16190150f, 0.23932980f, -0.33490139f, 0.09932783f, 
    -0.17074449f, -0.06393415f, -0.18839677f, -0.10014297f, 0.31991014f, -0.07825966f, -0.02855823f, -0.08875096f, 
    0.21087840f, 0.05697166f, -0.17002277f, -0.03743441f, -0.18235289f, 0.06290874f, 0.04304357f, -0.21829008f, 
    -0.08199792f, 0.00452869f, -0.17927065f, 0.17156129f, 0.16675916f, -0.03046655f, -0.11699251f, -0.05519105f, 
    0.21988982f, 0.01155131f, 0.12825684f, -0.07393825f, -0.09397085f, -0.12208025f, 0.03375643f, 0.18126833f, 
    0.25613821f, -0.55027926f, 0.10297608f, 0.11808215f, 0.03750335f, 0.14213918f, -0.09594918f, -0.16187221f, 
    -0.13967247f, -0.10400533f, -0.04639222f, 0.06762121f, 0.17016362f, 0.23178191f, 0.04513013f, 0.00039038f, 
    -0.14120716f, 0.28520781f, 0.05718779f, -0.16645725f, -0.03144442f, -0.03766466f, -0.02759867f, -0.15437606f, 
    -0.03911921f, 0.00932786f, -0.07765049f, 0.11958539f, 0.20311607f, -0.00528153f, 0.14258766f, -0.09670806f, 
    -0.04412019f, 0.07895250f, 0.07771415f, -0.04395183f, 0.20216535f, 0.12424591f, -0.00496958f, 0.25458848f, 
    -0.02422926f, 0.07286023f, 0.06360033f, -0.12886499f, 0.42834583f, 0.21254599f, -0.13100079f, -0.06845533f, 
    -0.08648577f, -0.07513129f, -0.03679758f, 0.06444125f, 0.00484651f, -0.03455482f, -0.33539367f, -0.26664832f, 
    -0.19078495f, 0.25752079f, -0.13220938f, -0.16280745f, -0.00339505f, -0.08721009f, 0.10807060f, 0.40409252f, 
    -0.33971554f, 0.08755314f, 0.00213345f, 0.01097146f, 0.15106548f, -0.07432115f, -0.00405863f, -0.11550819f, 
    -0.26702091f, 0.07306866f, -0.29451853f, 0.11670609f, -0.15546834f, 0.09459712f, -0.03463158f, -0.21701996f, 
    0.23095176f, 0.08538686f, 0.31897759f, 0.09766512f, -0.11667372f, 0.13195547f, 0.05290767f, 0.17248401f, 
    0.13463527f, 0.01412183f, 0.06086450f, -0.24012956f, -0.01343212f, 0.12827277f, -0.02936374f, 0.07393398f, 
    0.15092075f, 0.35311231f, 0.04079250f, -0.22673248f, -0.07844477f, 0.02245573f, 0.06966151f, 0.02182227f, 
    -0.01347542f, 0.07377987f, -0.01057129f, -0.58754736f, -0.22879949f, -0.14029348f, 0.09571866f, 0.27205059f, 
    -0.06378293f, -0.10565335f, -0.01621559f, 0.02027184f, 0.50944245f, -0.11188956f, -0.69094157f, 0.06977730f, 
    0.24252827f, 0.17497462f, -0.17409320f, -0.12391895f, -0.14515898f, 0.21949320f, 0.05870229f, 0.05203863f, 
    -0.03344610f, 0.14378066f, -0.02116889f, -0.03861906f, 0.02416041f, -0.05744097f, -0.00646836f, 0.22906817f, 
    0.15801208f, -0.13730051f, 0.00162991f, 0.24918467f, 0.19188194f, -0.04580849f, -0.07593241f, -0.13932857f, 
    0.17277420f, 0.24153437f, -0.18220372f, -0.18583246f, 0.13485266f, 0.20592423f, 0.10726064f, -0.13659970f, 
    -0.06629365f, -0.06284920f, 0.05159840f, 0.09962475f, 0.21895844f, 0.04241743f, -0.16182968f, -0.12872161f, 
    -0.17611675f, -0.18698752f, -0.06962538f, 0.15851998f, -0.01236033f, 0.17297046f, 0.04574873f, -0.09384294f, 
    0.09263565f, -0.07206936f, -0.05239794f, -0.02447517f, -0.16582237f, 0.10751817f, 0.10682917f, -0.09890506f, 
    0.01203811f, 0.09932714f, 0.17135343f, -0.06056857f, -0.27930790f, -0.20772842f, -0.08079185f, 0.14526221f, 
    0.24364027f, 0.02104547f, -0.22766210f, -0.04495550f, 0.03952238f, -0.01127632f, -0.04550432f, 0.11811325f, 
    0.00421864f, -0.04341139f, 0.02727938f, 0.06150394f, -0.09425037f, -0.00192589f, -0.32095641f, -0.11079393f, 
    -0.10870764f, 0.30489859f, 0.19413784f, 0.01624349f, -0.09035946f, -0.03355660f, -0.47762281f, -0.14043728f, 
    0.05458238f, -0.04965090f, 0.01044220f, 0.00037512f, -0.22937581f, 0.07877273f, 0.03380023f, -0.06823535f, 
    0.32260454f, 0.26662621f, -0.14263093f, -0.12522803f, 0.03193679f, -0.07879974f, -0.02788290f, -0.00466005f, 
    0.01390830f, -0.03647701f, -0.01421206f, 0.04303733f, -0.01436623f, 0.01078436f, 0.02426616f, 0.00108320f, 
    -0.01011838f, -0.02571486f, -0.04665510f, 0.03587360f, 0.02591153f, -0.02782773f, -0.01009656f, 0.02129219f, 
    -0.05998126f, -0.05188762f, -0.00029130f, -0.01285738f, 0.04552634f, -0.03285338f, -0.05456074f, 0.01980386f, 
    -0.03250190f, -0.00397289f, -0.04331461f, -0.03560106f, -0.02446425f, 0.00634592f, 0.04177877f, -0.00358102f, 
    0.03520498f, 0.04654725f, 0.02252915f, 0.02537076f, 0.03995187f, 0.00368515f, -0.01825231f, -0.04188981f, 
    -0.01708751f, 0.04068702f, 0.01042675f, -0.00082139f, -0.02293896f, 0.05482023f, -0.04297130f, -0.04157333f, 
    0.00132083f, 0.03133493f, -0.05476515f, -0.00326163f, -0.01452721f, 0.00492081f, 0.03919823f, -0.01801800f, 
    0.02610027f, 0.04570230f, -0.06624537f, -0.02240136f, 0.01712458f, -0.04011285f, -0.00318595f, -0.01168867f, 
    0.03456321f, 0.02046680f, 0.04537804f, -0.05814486f, 0.03191068f, -0.00226376f, -0.01145215f, -0.05938075f, 
    0.02177399f, 0.04734929f, 0.04366118f, 0.04447599f, 0.00088004f, -0.01482154f, -0.01677983f, -0.05845038f, 
    0.03178193f, -0.03599832f, 0.03969746f, -0.04875945f, -0.04289566f, -0.01746396f, -0.06078082f, -0.01758882f, 
    0.04499957f, 0.02661591f, 0.01494981f, -0.06699654f, -0.02199318f, 0.01353825f, 0.01953800f, 0.03762491f, 
    -0.01383916f, -0.03209622f, -0.00168731f, -0.05263517f, 0.04496639f, 0.04114146f, -0.00174873f, -0.05781532f, 
    -0.05950904f, 0.00098817f, 0.03834124f, -0.04539814f, -0.05459915f, -0.05507129f, 0.01438754f, -0.03740292f, 
    -0.05383212f, -0.00196686f, 0.04827708f, -0.02431033f, 0.01976222f, -0.03230108f, -0.02603348f, -0.03509557f, 
    -0.02963539f, 0.03393726f, -0.04145970f, 0.02538599f, 0.05297078f, -0.04741959f, 0.01733974f, 0.02527511f, 
    -0.05892302f, 0.03469815f, 0.02779103f, -0.04369295f, -0.05882498f, 0.01620352f, 0.03133681f, 0.01346659f, 
    0.01887995f, -0.06815156f, 0.02769386f, 0.01888511f, -0.06625988f, 0.00497944f, -0.04314538f, -0.01781208f, 
    0.02022674f, -0.00446965f, 0.03248107f, 0.00764562f, -0.06432842f, -0.06310641f, -0.02300676f, -0.01303049f, 
    -0.05877058f, -0.01454474f, 0.04233454f, -0.00456249f, 0.03080377f, 0.05322366f, -0.04006518f, 0.00805802f, 
    -0.01154115f, -0.01402196f, -0.01402613f, -0.04422091f, -0.05327209f, 0.05215431f, -0.06044345f, -0.02262926f, 
    0.02582738f, -0.00117444f, -0.03309132f, -0.04277204f, -0.04020158f, -0.06540855f, -0.03470942f, 0.02170475f, 
    -0.06362987f, -0.05995461f, 0.05152814f, -0.06374343f, -0.05164365f, 0.02564556f, 0.01687427f, -0.05796099f, 
    0.01798564f, -0.03987417f, -0.04450491f, -0.06087162f, -0.03972766f, 0.02753257f, 0.01848966f, -0.05987804f, 
    -0.04834093f, 0.01384223f, 0.04870995f, 0.01854875f, 0.01332605f, 0.02190921f, 0.03801420f, 0.00284322f, 
    -0.05254190f, -0.01126864f, -0.04673357f, 0.01438101f, -0.05065014f, 0.02296619f, -0.00733870f, 0.00375481f, 
    -0.03784450f, -0.05232833f, -0.05552465f, 0.04120804f, 0.04547632f, -0.02356748f, 0.01420166f, -0.03721991f, 
    -0.05161866f, 0.01771521f, -0.00490198f, -0.05406891f, -0.04228937f, 0.02028214f, -0.01412182f, 0.03289543f, 
    0.03723220f, 0.02780056f, -0.04366083f, 0.02748372f, -0.00179815f, -0.02592072f, -0.01980741f, -0.05002739f, 
    0.05093173f, -0.05283164f, 0.02202448f, -0.03089660f, -0.03143322f, 0.00412435f, 0.03204104f, -0.02910987f, 
    0.03142418f, -0.05292729f, 0.05223033f, 0.01523058f, -0.01640295f, -0.00070993f, 0.00254105f, -0.02623626f, 
    0.02060949f, -0.00103161f, 0.00834753f, 0.02759821f, -0.03927166f, -0.00568333f, -0.01856150f, -0.03375507f, 
    -0.00888967f, 0.02699643f, -0.01742092f, 0.02374307f, 0.04492788f, 0.03293416f, 0.00999940f, -0.03160137f, 
    -0.00324196f, -0.00963067f, -0.00113975f, 0.01093217f, 0.00704712f, 0.00032469f, -0.01359521f, -0.04256915f, 
    0.02334208f, -0.05626155f, -0.03937585f, -0.02780430f, 0.03048657f, 0.01044705f, -0.02038482f, -0.03950886f, 
    -0.03331079f, -0.02910933f, -0.02900029f, 0.02346689f, 0.04031168f, -0.06485240f, -0.06311081f, 0.04680893f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07360575f, -0.24629977f, -0.05031110f, 0.10910740f, -0.06062168f, 0.21191648f, -0.02225626f, 0.01069592f, 
    -0.01958981f, 0.05755241f, 0.23562731f, -0.06556856f, -0.06874441f, 0.16688421f, -0.05593010f, -0.02965132f, 
    0.06846511f, 0.02733327f, -0.03361723f, -0.06790629f, -0.06168620f, -0.00721160f, -0.04585930f, -0.01141996f, 
    0.06577853f, -0.05058041f, 0.15652472f, 0.02425791f, 0.00298471f, -0.09250955f, 0.12387434f, -0.02121205f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.66973513f, -0.27921847f, 0.17283165f, -0.28150216f, 0.05712506f, -0.32019848f, 0.13514265f, 0.05840695f, 
    0.01933666f, -0.32786682f, 0.03549119f, 0.90021837f, 0.27203727f, -0.03700057f, 0.02414357f, 0.15897161f, 
    -0.38234556f, 0.14232545f, 0.15635206f, -0.13831872f, -0.21086484f, -0.35305673f, -0.19375387f, -0.09516690f, 
    -0.47049063f, 0.29759037f, 0.23748836f, 0.14045182f, 0.07155108f, 0.36942852f, 0.29345119f, 0.04372809f, 
    0.19191793f, 0.08760034f, -0.58033395f, -0.05414237f, 0.16800778f, -0.38248521f, -0.13437249f, 0.15219322f, 
    -0.03194327f, 0.10217591f, 0.96040797f, -0.05500456f, 0.26899597f, -0.39914814f, -0.10912775f, -0.04826368f, 
    -0.07533491f, 0.11024914f, 0.13791196f, -0.14212444f, 0.30809456f, -0.37370467f, -0.48859736f, -0.12136262f, 
    -0.04162294f, 0.05563913f, 0.03668159f, 0.12908535f, 0.09567422f, 0.33899432f, 0.53721499f, 0.01677515f, 
    -0.32220536f, -0.04739053f, -0.23256776f, -0.18245795f, 0.04756509f, -0.02672503f, -0.14452912f, 0.10653356f, 
    -0.01664260f, -0.08299588f, -0.31354034f, 0.17767479f, -0.07380768f, -0.24864478f, -0.03369335f, 0.14503059f, 
    0.90545982f, -0.01040686f, 0.03946291f, 0.34127685f, 0.18831475f, -0.26267007f, 0.01589861f, -0.00900872f, 
    -0.49570611f, 0.59659678f, -0.47925356f, -0.15738799f, 0.04845388f, -0.29824299f, -0.08336341f, 0.04424175f, 
    0.01990463f, -0.73960972f, 0.35309762f, -0.24923240f, 0.02472589f, -0.26809844f, -0.10038399f, 0.13557436f, 
    0.03531135f, 0.31768626f, -0.02976725f, -0.09081834f, 0.48464054f, -0.04161332f, 0.15426005f, 0.09907215f, 
    -0.12791626f, -0.10974623f, 0.04522971f, 0.07938175f, -0.25628814f, -0.34840024f, 0.66189480f, 0.12394366f, 
    0.65648091f, -0.22397406f, -0.52719295f, 0.02500360f, -0.00212767f, -0.29267675f, -0.47953644f, -0.15601021f, 
    -0.43181875f, -0.23320864f, 0.43295479f, -0.17104666f, 0.06862177f, 0.26331252f, 0.07667281f, -0.04485379f, 
    0.03135907f, 0.35482618f, 0.06283096f, -0.33151558f, -0.44487628f, 0.01581863f, 0.09477826f, -0.15852500f, 
    0.18438251f, 0.05666806f, -0.16217384f, -0.06773673f, -0.87634134f, -0.38121641f, -0.32388586f, -0.00926563f, 
    0.20390113f, -0.05403010f, 0.41467592f, 0.04703546f, 0.07259689f, -0.25097167f, -0.52143925f, 0.15167068f, 
    0.52160144f, 0.48721439f, -0.22980499f, -0.21271421f, -0.12264603f, 0.58740616f, -0.05730710f, 0.00205322f, 
    0.07533539f, -0.52186000f, 0.14432885f, 0.17453937f, 0.07293528f, -0.09828267f, 0.10587041f, 0.07488507f, 
    -0.10390954f, 0.00833211f, -0.02501662f, -0.66591638f, 0.23777473f, -0.12481433f, 0.06521153f, -0.00112330f, 
    0.05931814f, -0.75977135f, 0.12035435f, 0.13832809f, -0.00213924f, -0.28834206f, 0.14331008f, -0.11948978f, 
    -0.42262435f, -0.71662313f, 0.16551459f, 0.48127583f, 0.05309344f, 0.22864480f, -0.13185526f, 0.08885201f, 
    -0.05037809f, 0.63188040f, -0.71360058f, -0.16747959f, 0.13810842f, -0.29379576f, -0.06985154f, -0.04750127f, 
    -0.51461768f, -0.16639706f, -0.05698472f, 0.15517184f, 0.63280076f, -0.22479093f, 0.15148383f, 0.02338258f, 
    -0.60908192f, -0.66937548f, -0.24589930f, -0.14062990f, 0.10022307f, -0.41110459f, 0.42888540f, 0.00034101f, 
    -0.03017721f, 0.82043415f, 0.11898767f, -0.51159710f, 0.15891299f, -0.21374595f, 0.08960583f, -0.08646776f, 
    -0.03024546f, -0.15549929f, -0.32201669f, 0.36018971f, 0.22216864f, -0.17249200f, 0.05904755f, -0.14406022f, 
    -0.20861079f, -0.04436997f, -0.01834460f, 0.01815655f, -0.19177245f, 0.22195254f, -0.03583397f, -0.10170133f, 
    0.20928100f, -0.34966481f, -0.41392079f, -0.12459856f, -0.10064279f, 0.38122559f, -0.04200871f, -0.16530961f, 
    0.33769476f, -0.16771577f, -0.23372726f, -0.12481821f, -0.14545798f, -0.25142968f, 0.02146528f, 0.12766019f, 
    -0.13510551f, -0.62770295f, -0.29600441f, -0.66388404f, 0.02682360f, -0.33541289f, 0.08273414f, 0.03353695f, 
    -0.00598706f, 0.09515518f, -0.08256792f, -0.23741671f, 0.43395650f, 0.62379354f, 0.20419081f, 0.07863156f, 
    -0.22907339f, -0.04919950f, 0.22962396f, -0.07827110f, -0.13051762f, 0.82483792f, -0.43560484f, -0.11803488f, 
    -0.13445857f, 0.58838028f, 0.21422635f, -0.01385685f, -0.07036738f, 0.13293837f, 0.03948488f, -0.17929432f, 
    -0.15383647f, 0.08628431f, -0.66596264f, -0.09414040f, -0.25010705f, 0.06772875f, 0.13900238f, 0.05017422f, 
    -0.36833408f, 0.16723512f, -0.16294998f, -0.28023267f, -0.07637317f, 0.99090934f, -0.18742372f, 0.00638201f, 
    -0.45340529f, 0.27735639f, 0.12117611f, 0.04916738f, 0.08646281f, -0.72733957f, 0.25233650f, 0.11612789f, 
    0.13712490f, -0.56315809f, -0.35136446f, 0.05518477f, -0.00938311f, -0.61429703f, 0.05069086f, 0.02532267f, 
    -0.15146346f, -0.14303081f, 0.32801938f, -0.75619602f, 0.35269320f, 0.90630978f, 0.08981239f, -0.08740105f, 
    0.24665096f, 0.16769633f, -0.15030858f, 0.34556121f, -0.02938571f, 0.01392860f, -0.30568609f, -0.13192655f, 
    -0.03209831f, -0.55306000f, -0.14784563f, -0.17853118f, 0.11552574f, 0.04208191f, -0.56476986f, -0.01659636f, 
    0.53152794f, -0.07752544f, -0.03045111f, 0.63710010f, -0.11222168f, -0.23778762f, 0.02990582f, -0.06229957f, 
    -0.15630689f, -0.34778666f, -0.08217487f, -0.34647655f, -0.64330083f, -0.11481612f, 0.02902067f, -0.06970344f, 
    -0.23746279f, -0.00702770f, 0.10146196f, 0.35100225f, -0.51855135f, -0.44954827f, 0.47628325f, -0.07165796f, 
    0.25765347f, -0.02388791f, -0.26850799f, -0.06306405f, -0.07573713f, -0.17455487f, 0.08260121f, -0.10557967f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03171891f, -0.08267773f, -0.10343004f, 0.05312164f, 0.07862494f, 0.11340770f, -0.18469299f, -0.28513134f, 
    -0.10597825f, 0.07531365f, 0.04553673f, 0.02214040f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
