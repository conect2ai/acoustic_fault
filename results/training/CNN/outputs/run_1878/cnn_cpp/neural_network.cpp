#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.10420743f, 0.09013885f, 0.30484563f, -0.62265223f, 0.47998703f, 0.81310558f, 0.42347026f, -0.25812954f, 
    0.14208466f, -0.29515207f, -0.11513222f, 0.70068216f, 0.21313803f, -0.27329016f, 0.02967981f, 0.81552935f, 
    -0.38359344f, -0.46528780f, 0.15767504f, 0.04913009f, 0.51670027f, 0.87260854f, -0.89034593f, -0.00604250f, 
    0.17422485f, -0.16409057f, -0.12397539f, -0.68810582f, 0.53591639f, 0.32788303f, -0.48212644f, 0.52801323f, 
    -0.93172973f, 0.30581820f, 0.35866505f, -0.22490247f, -0.24632005f, 0.26261812f, 0.38538814f, -0.40921620f, 
    0.01737986f, 0.56437224f, -0.33596054f, 0.17069566f, 0.60487556f, -0.59098566f, -0.34291109f, -0.25484297f, 
    -0.27313858f, -0.31292808f, -0.53699160f, -0.24277586f, -0.44937086f, -0.30110994f, 1.01862574f, 0.26626462f, 
    -0.80424136f, 0.04512931f, -0.40655753f, -0.02970814f, 0.07968849f, -0.19832957f, 0.55541790f, -1.17287374f, 
    -0.90392447f, 0.08967543f, 0.20715119f, -0.45642456f, 0.17999674f, 0.36362481f, 0.10424551f, -0.25482893f, 
    -0.65717101f, 0.91808891f, -0.17471205f, -0.05394904f, 0.03266544f, -0.51773655f, 0.32697681f, -0.24301518f, 
    0.34076402f, -0.26442543f, -0.05917426f, 0.08955027f, -0.52003509f, -0.83295870f, -0.28715166f, -0.40020385f, 
    1.02087963f, -0.74129796f, 0.32694042f, -0.35661605f, -0.33774439f, 0.18366505f, -0.63149053f, -0.58421540f, 
    0.51187497f, 0.50237221f, 0.43587002f, -0.41222924f, 0.79242474f, -0.68517381f, -0.54846382f, 0.92442405f, 
    -0.53126734f, -0.25327471f, -0.29859152f, -0.36076358f, -1.06735337f, 1.07031047f, -0.58942670f, -0.57574248f, 
    0.39309180f, 0.48018450f, 0.07023095f, 0.02562436f, 0.18526316f, -0.36229381f, -0.16641827f, 0.53069586f, 
    -0.21250555f, -0.38918939f, -0.43992248f, 0.43065277f, 0.34552157f, 0.43813768f, -0.97749579f, -0.10837945f, 
    -0.19338261f, 0.80435216f, -0.00183074f, -0.71784717f, -0.25394723f, -0.40829352f, -0.05109416f, -0.03176722f, 
    0.37268636f, 0.07293834f, 0.61205500f, -0.16738905f, -0.42473054f, 0.07391845f, -0.63147926f, 0.53989238f, 
    0.26818928f, 0.35788324f, 0.29458919f, -0.28826779f, 0.50294966f, 0.17779067f, -0.19432487f, -0.41774464f, 
    0.16910040f, 0.41570035f, 0.23423387f, -0.44026700f, -0.43264201f, 0.32968009f, 0.07523113f, 0.62678111f, 
    0.57218152f, 0.27181962f, 0.57329571f, 1.00750113f, -0.76727414f, -0.35458237f, -0.16118367f, 0.34412217f, 
    0.01657204f, 0.17161407f, -0.30132774f, -0.33657271f, -0.16647907f, -0.16306259f, -0.04583337f, 0.79341161f, 
    0.29601490f, -0.14484970f, 0.44232398f, -0.48858574f, 0.55194205f, -0.78944641f, -0.17335244f, -0.62536067f, 
    -0.37845650f, -0.73222381f, -0.26947796f, -0.41278452f, -0.20538722f, -0.29497933f, -0.51154995f, -0.04834084f, 
    0.76359737f, 0.32582754f, 0.46861976f, -0.48030633f, -0.58962542f, -0.19518207f, -0.24939206f, -0.64227647f, 
    -0.86071295f, 0.57964927f, -0.06297055f, 0.59626973f, -0.40692866f, -0.29256749f, -0.29924157f, -0.15757427f, 
    -0.92931831f, -1.16430533f, 0.71031934f, 0.70044923f, 0.29108471f, 0.20667455f, 0.12471253f, 0.28645787f, 
    0.74514812f, 0.53530419f, -0.07841833f, -0.18869281f, -0.09017677f, -0.38415015f, -0.05658466f, 0.33887935f, 
    0.34640375f, -0.88413793f, 0.21143195f, 0.02509408f, 0.63837379f, 0.31705090f, 0.40569973f, 0.27036986f, 
    0.25860798f, -0.41237897f, 0.54098970f, 0.02997610f, -0.20792980f, 0.73674387f, 0.62140042f, 0.36812213f, 
    -0.21827646f, 0.93872601f, -0.41531503f, -0.52638245f, 0.23117936f, 0.90431225f, 0.47849724f, -0.18518564f, 
    -0.08832885f, -0.68106669f, -0.21599308f, -0.14082126f, 0.41550049f, 0.37083200f, -0.65684152f, 0.66458458f, 
    0.62680352f, 0.42390886f, -0.03957699f, -0.29528272f, -0.37830123f, 0.62346119f, 0.09938363f, 0.41703770f, 
    -0.01667883f, 0.21702579f, 0.12861881f, 0.16278446f, 0.01390431f, 0.04345183f, -0.92456782f, -0.84026361f, 
    0.49043027f, 0.00667492f, 0.57149512f, -0.27336282f, -0.09244982f, -0.06429606f, -0.43821386f, 0.44599351f, 
    0.70397204f, 0.56741023f, -0.34193230f, -1.09994125f, 0.04873803f, -0.31663206f, -0.05437566f, 0.20231658f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.39064583f, 0.09352669f, -0.22719902f, 0.06619078f, 0.59151477f, -0.54398054f, 0.04921170f, -0.08192194f, 
    -0.15473752f, -0.39049914f, 0.64106178f, -0.11540334f, -0.04391355f, 0.04967454f, 0.25964820f, 0.26524577f, 
    -0.06896096f, -0.08250407f, 0.39960539f, -0.06392705f, 0.09777256f, -0.08447488f, 0.20683563f, -0.05893516f, 
    0.39416519f, -0.18307674f, -0.13831119f, -0.01993694f, -0.00346280f, -0.15547882f, 0.01026444f, -0.16267170f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.07932666f, -0.17480700f, -0.01143021f, 0.15556505f, 0.03771257f, 0.14185619f, 0.12167708f, 0.02820992f, 
    0.18734477f, -0.08161001f, -0.08713204f, 0.21175604f, 0.03459140f, 0.02846304f, 0.22770303f, -0.03235722f, 
    0.06830662f, -0.02790761f, -0.11383552f, -0.19346271f, -0.10393568f, 0.05928643f, -0.04436513f, 0.10409485f, 
    -0.02219503f, 0.09309271f, -0.13708118f, -0.02549197f, 0.09527221f, 0.11650898f, 0.20747681f, -0.13977738f, 
    0.06573664f, 0.06545711f, 0.12364414f, 0.08592980f, 0.08043198f, 0.00158691f, 0.14076772f, 0.10668626f, 
    0.04083274f, 0.03214353f, 0.15912329f, -0.03794770f, 0.15064853f, -0.46974310f, -0.10250457f, -0.00766414f, 
    -0.01240394f, 0.02987265f, -0.27680695f, 0.11650018f, 0.01484670f, 0.05679784f, 0.09566983f, 0.05597057f, 
    0.10123601f, -0.11055873f, 0.13525166f, -0.15297517f, 0.10065491f, -0.02996101f, 0.07309034f, -0.09183106f, 
    0.12253916f, 0.10411929f, -0.21570240f, -0.15425394f, -0.02646590f, 0.06191185f, -0.07281500f, -0.01187236f, 
    -0.14698313f, -0.14447500f, 0.33363381f, 0.17181937f, 0.09038103f, -0.09615299f, 0.10743987f, 0.06285803f, 
    0.22226970f, -0.16972581f, -0.16622001f, 0.03214826f, 0.32445672f, -0.02996935f, 0.09867262f, 0.06573778f, 
    -0.06370413f, 0.11697712f, 0.11108113f, 0.17743281f, 0.10132441f, -0.12728508f, -0.10014279f, -0.25650969f, 
    0.30817160f, 0.17822494f, 0.12644541f, 0.08131272f, -0.13952567f, 0.63694823f, -0.10793456f, -0.15434007f, 
    -0.03374887f, 0.01119951f, 0.03337326f, 0.15810484f, 0.16263385f, -0.24051601f, 0.27143735f, 0.15612490f, 
    -0.29679954f, 0.05057455f, 0.09181175f, 0.02564588f, -0.00722316f, -0.08703927f, -0.06147691f, 0.03045570f, 
    0.03692455f, 0.02837670f, -0.01146201f, 0.19209231f, 0.08357132f, 0.09679306f, 0.12287899f, 0.11091855f, 
    0.25592068f, 0.05844376f, -0.02678943f, -0.08257150f, 0.07000716f, -0.01663027f, 0.07254685f, -0.00579373f, 
    0.02819520f, 0.17460589f, 0.12827055f, 0.01133198f, 0.03832884f, 0.08482141f, 0.02079020f, 0.10069015f, 
    0.02955461f, -0.09388095f, -0.08459621f, -0.04973750f, 0.07775734f, 0.05630716f, 0.00260325f, 0.09534843f, 
    -0.00194356f, 0.00569652f, 0.05953208f, -0.01329234f, -0.13358666f, -0.06403015f, 0.03002853f, 0.28729028f, 
    0.15190002f, 0.09212925f, 0.01653310f, -0.12509936f, 0.04143407f, 0.10101600f, 0.09601307f, 0.19697939f, 
    0.05547884f, 0.04941242f, 0.06268915f, 0.02397100f, 0.00368716f, 0.03285770f, 0.20100233f, 0.13656367f, 
    0.11300500f, 0.10493374f, -0.11681636f, -0.02853036f, -0.17253557f, 0.05119177f, -0.03932027f, 0.13369736f, 
    0.07542634f, -0.09034830f, -0.04605832f, 0.09624355f, 0.04694983f, -0.02248672f, -0.07775160f, -0.21006344f, 
    0.06379111f, -0.11791372f, 0.14455736f, -0.07241522f, -0.04178797f, -0.32268682f, 0.03244177f, 0.16769128f, 
    0.15975507f, -0.16090351f, -0.15325485f, 0.16751006f, -0.16215183f, -0.00135886f, 0.12112780f, 0.00022930f, 
    0.19747193f, 0.08046779f, 0.10370813f, 0.03043727f, 0.10350934f, -0.08129725f, -0.07642234f, 0.06661052f, 
    -0.03268399f, -0.02871185f, 0.08827980f, 0.07450295f, 0.08837948f, 0.02725685f, 0.14075574f, -0.00104545f, 
    0.01673720f, -0.23326018f, 0.01927473f, 0.02912256f, 0.27091649f, 0.17775585f, 0.06464968f, -0.01837746f, 
    0.08504397f, 0.18175241f, -0.03227778f, -0.00891436f, -0.12397537f, 0.10357610f, 0.14725865f, 0.11409836f, 
    0.02559757f, 0.09826449f, -0.03347304f, -0.07574420f, -0.13246734f, -0.08916032f, 0.08622371f, -0.13194433f, 
    0.08453479f, 0.03617986f, 0.03824626f, -0.13009539f, -0.03411744f, -0.08667223f, -0.15333278f, -0.03092464f, 
    0.07440202f, 0.08051105f, 0.21643806f, 0.17306811f, -0.12678710f, -0.05498874f, -0.14625208f, 0.00781239f, 
    0.04198186f, 0.04228380f, 0.01688148f, -0.01013505f, 0.00324916f, -0.06552612f, 0.03151695f, 0.19202021f, 
    0.21233876f, 0.11456427f, -0.13120218f, 0.00063640f, 0.02147743f, -0.06306399f, -0.08381011f, -0.26328978f, 
    -0.09697103f, -0.10566939f, 0.32134417f, 0.01728560f, 0.02495581f, -0.06131962f, -0.07852164f, -0.03172202f, 
    0.12125553f, 0.01312949f, 0.22298031f, -0.07773555f, 0.01685413f, -0.21989273f, 0.03221042f, 0.02436389f, 
    0.10150585f, -0.11242568f, 0.04811605f, 0.33884439f, 0.08260181f, 0.16615190f, -0.16675141f, 0.07371328f, 
    -0.11362644f, 0.02958205f, -0.45767847f, -0.05220907f, 0.33556023f, -0.03556456f, 0.18567717f, -0.20352376f, 
    0.07883991f, 0.03085666f, 0.08751436f, -0.03734219f, 0.02010642f, 0.37865141f, 0.04835375f, -0.02728022f, 
    0.18265715f, -0.11071961f, -0.10678662f, -0.02178464f, 0.21279573f, -0.19130798f, 0.10566103f, -0.09327766f, 
    0.00929946f, -0.04011415f, 0.03305613f, 0.06983099f, -0.13707805f, 0.53355616f, 0.23844355f, 0.11022127f, 
    -0.01041696f, 0.09231900f, 0.34535706f, 0.05169429f, 0.00379620f, 0.02389335f, -0.20839871f, 0.26229358f, 
    -0.53439677f, -0.00899213f, 0.09550778f, 0.29731306f, 0.09957090f, 0.12833126f, -0.28673840f, 0.28105631f, 
    0.08625191f, 0.47944564f, 0.12941797f, 0.09940854f, 0.15037769f, 0.12555918f, -0.05699967f, 0.03511560f, 
    -0.18934588f, -0.00278001f, -0.16131733f, 0.07698332f, -0.26767415f, 0.05685195f, 0.07794339f, 0.09541145f, 
    0.07868195f, 0.12026998f, 0.16119352f, 0.06933209f, -0.13620900f, -0.08146749f, -0.39732108f, 0.18061049f, 
    0.13113588f, 0.17385466f, 0.09003997f, 0.34200704f, -0.10457973f, -0.11579043f, 0.02401964f, -0.03040362f, 
    -0.04586270f, 0.02940370f, 0.07616445f, -0.08214630f, 0.04078743f, -0.02762287f, -0.13497661f, 0.12060318f, 
    0.12179810f, 0.11870921f, -0.08049491f, -0.10701145f, -0.62594569f, -0.45472306f, -0.01122491f, -0.13496695f, 
    -0.26353273f, -0.02445453f, -0.02338150f, 0.16091645f, -0.00213140f, 0.17459106f, 0.17483108f, 0.49124414f, 
    -0.22439364f, -0.10879055f, -0.13752756f, -0.06638233f, -0.06637220f, 0.14328450f, 0.29382282f, 0.24908870f, 
    -0.27191186f, 0.04066127f, -0.00367369f, 0.09126244f, -0.10693855f, 0.08560358f, 0.05478944f, -0.08483769f, 
    0.10497256f, -0.09166283f, 0.12833121f, -0.14012767f, -0.12077170f, -0.08224532f, 0.08297049f, 0.00069228f, 
    0.12183428f, -0.00415728f, 0.05432000f, 0.22445302f, -0.08234978f, -0.28570992f, -0.02144878f, 0.17946455f, 
    0.06283672f, 0.30137420f, 0.18658100f, -0.27985272f, -0.05207797f, -0.08880787f, 0.05162651f, -0.04219866f, 
    -0.06417987f, -0.11206617f, -0.06527435f, -0.13247098f, -0.44277748f, 0.05291047f, -0.10087671f, -0.17070417f, 
    0.04943302f, -0.05263545f, 0.07269575f, 0.14721847f, -0.34851944f, -0.23806973f, 0.04121948f, -0.30454206f, 
    -0.14339705f, 0.01156797f, -0.09886354f, 0.10791309f, 0.12215730f, 0.19200273f, 0.27034023f, -0.17747524f, 
    -0.05108537f, -0.00803243f, 0.07122761f, -0.10088426f, -0.06045507f, 0.39638808f, -0.27789062f, 0.10991678f, 
    -0.12896761f, -0.12193996f, -0.23157915f, -0.03002263f, 0.15568265f, -0.10416075f, 0.27221009f, -0.19887155f, 
    -0.00094482f, -0.08446059f, 0.10757954f, 0.10889236f, 0.03037018f, 0.06928261f, 0.06481615f, 0.11933760f, 
    -0.20727733f, -0.89199114f, 0.06808992f, 0.08532330f, 0.14064708f, -0.04176281f, 0.08421586f, 0.15212065f, 
    -0.06171428f, -0.26894054f, -0.25539300f, -0.08606492f, 0.01190881f, 0.13718849f, 0.06971813f, 0.15148203f, 
    -0.17847300f, 0.22044504f, -0.17481261f, -0.15408492f, -0.02026902f, -0.18706556f, -0.18933885f, 0.03247082f, 
    0.03739879f, -0.02306409f, 0.02347657f, 0.05578696f, -0.40066293f, -0.03111719f, -0.29941943f, -0.21483454f, 
    -0.01779342f, 0.09227526f, 0.00239242f, -0.04852477f, 0.17964000f, 0.07194856f, -0.07296498f, -0.12571819f, 
    0.06974226f, -0.03756744f, -0.05733036f, 0.03154826f, -0.02453217f, -0.04629220f, -0.11430137f, 0.00906817f, 
    0.00339378f, -0.29452303f, 0.08156727f, -0.13884440f, -0.00995471f, 0.00099642f, -0.05753684f, -0.14531717f, 
    0.12648812f, 0.10367437f, -0.05170147f, -0.01846707f, 0.12317439f, -0.09647146f, 0.50030071f, 0.06249460f, 
    0.01003987f, 0.24395834f, -0.11166449f, 0.32074076f, -0.03525906f, -0.03574127f, -0.05256329f, -0.25774673f, 
    0.01270789f, 0.26160043f, 0.03941467f, 0.09048316f, -0.21567136f, 0.15897188f, 0.00584271f, 0.14788827f, 
    0.06427831f, 0.00217079f, -0.15264255f, -0.08192252f, 0.05486393f, 0.09912719f, 0.13035066f, 0.13788174f, 
    -0.04093285f, -0.03729984f, -0.02623920f, -0.16267839f, 0.01168939f, -0.12140662f, -0.35463935f, 0.24802786f, 
    0.05778157f, -0.19451478f, -0.02588207f, -0.00875069f, -0.09932633f, 0.07317633f, -0.02172418f, -0.18552837f, 
    -0.18395136f, 0.04797920f, 0.04413643f, 0.41132015f, -0.35398105f, 0.08469180f, 0.25444558f, -0.10139398f, 
    -0.14457248f, -0.06114021f, 0.18762466f, 0.06895330f, 0.06745771f, -0.04119040f, -0.14516932f, 0.10770497f, 
    -0.00266056f, -0.05232950f, 0.05554371f, 0.12648679f, -0.00341548f, -0.12815826f, 0.03378525f, -0.12206588f, 
    -0.01590500f, -0.11975435f, -0.04111104f, -0.03782990f, -0.09772074f, -0.23514454f, -0.12341594f, -0.05332829f, 
    -0.33732361f, 0.22247702f, 0.12530062f, 0.02598410f, 0.01300939f, 0.02260394f, 0.00148725f, 0.19581117f, 
    0.13576777f, 0.39134642f, -0.07403966f, 0.10333329f, -0.07737152f, 0.02508470f, -0.06188939f, -0.09880532f, 
    0.70230311f, -0.13777907f, -0.18534543f, 0.18096405f, -0.11865411f, -0.14696015f, 0.07240548f, 0.17151226f, 
    -0.08580898f, 0.09719598f, -0.00935896f, 0.24020121f, -0.17248701f, 0.07175717f, -0.10676165f, -0.04195417f, 
    -0.10574043f, -0.15180098f, 0.25755349f, 0.02716534f, -0.11069781f, -0.04430295f, -0.01748784f, 0.00124241f, 
    0.08343055f, -0.01736526f, 0.17555566f, 0.21739368f, -0.28755936f, 0.04756927f, -0.00927721f, -0.21004371f, 
    -0.04924775f, 0.08476311f, 0.11392536f, 0.19620673f, 0.39246994f, -0.16012979f, -0.16081071f, 0.10106949f, 
    -0.02049242f, 0.24770482f, -0.08009797f, 0.12969500f, -0.19003028f, 0.25423056f, -0.40641940f, -0.21233854f, 
    -0.06509410f, 0.11576697f, -0.07499249f, 0.13418388f, 0.11344068f, 0.23626080f, -0.31556842f, -0.11887467f, 
    0.25758275f, -0.02871054f, 0.01974386f, -0.11450934f, 0.11862860f, -0.16710985f, 0.05099070f, -0.11184152f, 
    -0.10810117f, -0.11702480f, -0.01596958f, -0.07075690f, -0.09172341f, 0.04372161f, 0.00582224f, 0.20212342f, 
    -0.03348684f, -0.09599460f, -0.06597354f, 0.10350294f, 0.00150375f, -0.05712409f, 0.02645741f, 0.04319888f, 
    0.02992808f, 0.10211476f, -0.01989782f, -0.09720238f, -0.14648229f, -0.14420724f, 0.08399951f, 0.13799310f, 
    0.17750652f, 0.12411299f, -0.10100815f, -0.14359102f, -0.15775573f, 0.18249418f, 0.04706677f, 0.01965938f, 
    -0.02799299f, 0.03259764f, -0.05273639f, -0.08191746f, 0.19578986f, 0.24037692f, -0.02050992f, -0.22680412f, 
    0.03348842f, 0.07677373f, 0.14372224f, -0.04146308f, 0.05386049f, 0.08951186f, -0.08975723f, 0.01989395f, 
    -0.14140840f, -0.10421669f, -0.16137849f, -0.05025215f, -0.26666561f, -0.05839754f, 0.06439093f, -0.10654150f, 
    0.02455890f, -0.02409223f, -0.00710681f, -0.02704741f, 0.09642313f, 0.28152385f, -0.10893622f, 0.21908531f, 
    0.21157908f, 0.12172054f, 0.02481145f, 0.00761079f, 0.03925013f, 0.04424239f, 0.04065278f, -0.05303011f, 
    0.35360491f, 0.44790512f, -0.12456229f, -0.09796284f, -0.06994651f, 0.12710303f, -0.04025127f, 0.03539834f, 
    -0.09451782f, -0.12441996f, -0.12975371f, 0.26834303f, 0.03021793f, 0.00683858f, 0.03484809f, -0.03025464f, 
    0.03826203f, 0.12915947f, 0.05233191f, 0.02223466f, -0.33652449f, -0.16366817f, -0.02288230f, 0.04013934f, 
    0.00928913f, 0.07792393f, 0.07958212f, 0.03099755f, 0.04920902f, -0.22807805f, -0.56197131f, 0.08850479f, 
    0.27670279f, -0.00163191f, 0.05035874f, 0.03626784f, -0.05801545f, -0.03500281f, 0.01742855f, -0.12057985f, 
    -0.11922727f, 0.00135096f, 0.09228258f, -0.00450098f, 0.12949871f, 0.02193728f, -0.01002198f, 0.00217593f, 
    -0.29799446f, 0.12558255f, 0.06291391f, 0.17903940f, 0.15748307f, -0.07064911f, -0.06529791f, 0.02431330f, 
    0.19975567f, -0.02596159f, -0.09368747f, -0.00538539f, -0.02231128f, 0.09069878f, -0.26470163f, 0.09463505f, 
    0.16340332f, -0.09523010f, -0.03991788f, -0.18339421f, 0.08042583f, 0.02892305f, -0.06729965f, -0.39186233f, 
    -0.20435023f, 0.08539467f, 0.07899687f, 0.07406150f, -0.14596635f, -0.12726586f, -0.11131120f, 0.02893573f, 
    0.03084040f, -0.04964933f, 0.05425174f, 0.00642069f, 0.02416435f, -0.00098631f, -0.06059120f, -0.01593849f, 
    -0.04906655f, -0.01645698f, -0.03702223f, -0.04094890f, -0.03595196f, -0.03912961f, 0.04052834f, 0.03679014f, 
    0.04319119f, 0.04379414f, -0.00960518f, 0.01363517f, -0.03161711f, -0.04708816f, 0.01690915f, -0.00509353f, 
    0.01610676f, -0.05035832f, -0.02935866f, -0.02872929f, -0.03570492f, 0.02917215f, 0.04215043f, -0.01339323f, 
    0.01834160f, -0.05436666f, -0.01619644f, 0.04292525f, 0.03132683f, 0.00853088f, -0.00139207f, 0.03741887f, 
    -0.01689449f, -0.01682280f, 0.05757543f, -0.00213220f, -0.05468662f, 0.01346053f, 0.00154478f, -0.00752983f, 
    -0.02597989f, 0.01621557f, -0.03415569f, -0.03954170f, 0.02095169f, -0.03326325f, -0.02433430f, -0.04032986f, 
    -0.05587108f, 0.04202870f, 0.01230435f, -0.03253965f, 0.02882584f, -0.05103811f, -0.04341481f, -0.03196937f, 
    -0.03485926f, -0.00202104f, 0.00681594f, -0.04770206f, -0.00638263f, 0.03402250f, 0.03701802f, 0.02413447f, 
    -0.04457068f, 0.00065711f, -0.04058352f, 0.02272378f, -0.00814023f, -0.02797636f, 0.02616334f, -0.06558572f, 
    -0.02573365f, 0.01498511f, -0.03615985f, 0.02940013f, 0.02792075f, -0.02231196f, 0.02897984f, -0.03113182f, 
    -0.05665911f, -0.06960730f, -0.00428664f, 0.03287867f, 0.02528665f, -0.06369740f, -0.04477905f, 0.04522606f, 
    -0.06643697f, 0.04475911f, -0.05761843f, 0.03028774f, -0.06516132f, -0.05670516f, -0.00941004f, 0.03113969f, 
    0.04245321f, -0.00450961f, -0.00088810f, 0.00041404f, 0.01981871f, 0.01750991f, 0.03573142f, 0.01170375f, 
    -0.05407196f, -0.02180796f, 0.02335716f, -0.04932879f, -0.07041723f, -0.03050501f, -0.00760222f, 0.01112957f, 
    0.03957146f, -0.01194194f, -0.00878696f, -0.01133921f, 0.04513612f, 0.04221727f, 0.05110625f, 0.02051569f, 
    -0.05183138f, -0.00324942f, 0.00490582f, 0.04000068f, -0.02758047f, -0.01446621f, -0.02428522f, 0.03638555f, 
    -0.03103190f, 0.00471626f, 0.02321015f, 0.03444399f, -0.03361185f, 0.00592411f, -0.06102355f, -0.03427882f, 
    0.01152053f, 0.02321189f, -0.05011455f, -0.01086029f, -0.01409086f, -0.03961015f, 0.03015459f, 0.05461737f, 
    0.02294780f, -0.05086413f, 0.04070409f, 0.03756626f, -0.05855912f, 0.05121665f, -0.00439442f, -0.00060748f, 
    -0.02352268f, -0.00743187f, 0.03529433f, 0.03924731f, 0.00764099f, -0.06817346f, -0.02151535f, -0.04720714f, 
    0.02119825f, -0.00788692f, -0.00660118f, 0.02902196f, -0.01638655f, 0.03796265f, -0.06244947f, 0.02585288f, 
    -0.03645412f, 0.01032250f, -0.00492561f, -0.07035960f, -0.03751897f, 0.01735163f, -0.07301605f, -0.02257348f, 
    -0.02494943f, 0.02798577f, 0.01418432f, -0.03443870f, 0.02655473f, 0.04510788f, -0.00278600f, 0.00689660f, 
    -0.01828416f, -0.02664761f, 0.02661510f, -0.05820936f, 0.02602013f, 0.02424361f, -0.04134438f, 0.00478750f, 
    -0.00096029f, 0.01693051f, 0.02127152f, 0.03892900f, 0.04214703f, -0.01128000f, -0.00068665f, -0.03347144f, 
    -0.00462679f, 0.01005714f, 0.00603435f, -0.05184285f, -0.06150397f, 0.04563716f, -0.05027265f, 0.02770278f, 
    -0.04138238f, -0.06389877f, -0.02162829f, -0.00480699f, 0.00193558f, 0.03379566f, -0.00568195f, -0.04575418f, 
    0.00624699f, -0.04176499f, 0.01456882f, -0.01175831f, 0.02709208f, 0.03411542f, 0.01036969f, -0.01227327f, 
    0.03348199f, -0.06529657f, 0.04306292f, -0.03882718f, -0.05401338f, 0.00917282f, 0.01582645f, 0.01395193f, 
    0.04356208f, 0.05117137f, 0.00663944f, 0.00026916f, 0.05060806f, 0.00247463f, 0.03104590f, -0.05987705f, 
    0.05023517f, 0.03636510f, 0.00494024f, -0.03097937f, -0.05401433f, -0.01831090f, -0.01691154f, -0.01315625f, 
    -0.04942368f, -0.04536934f, -0.02221873f, -0.03524153f, -0.02851223f, 0.02947860f, -0.00184155f, -0.03281428f, 
    -0.02103738f, -0.00947487f, -0.03323737f, 0.04326804f, -0.03486237f, 0.04766987f, 0.04845078f, 0.03662389f, 
    -0.01081135f, -0.04995691f, 0.03574586f, -0.04199516f, -0.03317550f, 0.00697252f, 0.03440210f, 0.01733949f, 
    -0.04040546f, -0.00849941f, 0.00977990f, -0.05128666f, -0.01428119f, 0.03621919f, -0.01317326f, 0.04156397f, 
    -0.06420030f, 0.04687062f, 0.14993842f, 0.12709957f, 0.17850183f, 0.21621099f, 0.18432379f, 0.06403863f, 
    0.10851043f, 0.12306400f, 0.17394683f, 0.02200134f, -0.07312807f, 0.06146696f, 0.23361419f, 0.08674879f, 
    0.05194759f, 0.12965645f, -0.41083917f, -0.28793266f, -0.11996818f, -0.06126821f, -0.01116017f, -0.02336239f, 
    0.06597279f, 0.04655743f, -0.05774814f, 0.03708097f, 0.12618400f, -0.07273705f, 0.28710988f, -0.08835398f, 
    -0.01508913f, -0.22393909f, 0.10222431f, 0.00906430f, 0.09998582f, 0.07333118f, 0.29740652f, -0.05151667f, 
    0.21181796f, 0.20824564f, 0.02778136f, 0.06904053f, 0.28553426f, -0.23783556f, -0.12901218f, 0.02415751f, 
    -0.16113900f, -0.24825886f, -0.12401754f, 0.17244405f, -0.11564939f, -0.05898342f, 0.35531700f, 0.12574451f, 
    -0.09247711f, 0.08707296f, 0.10089750f, -0.01718899f, 0.06183713f, -0.13846022f, 0.02183657f, -0.01054270f, 
    0.17919455f, 0.17195092f, -0.27432248f, -0.05842907f, 0.11988425f, 0.01667666f, -0.01374078f, 0.03438326f, 
    0.02576769f, -0.02386339f, -0.70408463f, 0.12484619f, -0.01855287f, 0.01771871f, 0.07063074f, 0.05236218f, 
    0.17524758f, -0.45265451f, -0.61752641f, -0.32228565f, -0.24580579f, -0.14579228f, -0.16312855f, 0.11720290f, 
    0.16086857f, -0.05638683f, 0.24580720f, -0.09722405f, -0.14347047f, 0.26001501f, 0.08771568f, 0.12818240f, 
    0.17532259f, 0.22529542f, 0.08066437f, -0.22967932f, -0.20910333f, -0.41269022f, -0.20095879f, -0.04018795f, 
    0.00953561f, 0.09840936f, -0.20383909f, -0.01713416f, -0.26209807f, -0.16403474f, -0.53644031f, -0.15890689f, 
    -0.05693359f, -0.23440611f, -0.05827894f, 0.08340062f, 0.03790823f, 0.08399343f, -0.62615508f, -0.13541061f, 
    0.21749166f, 0.01423143f, 0.05944937f, 0.00138794f, -0.03019981f, 0.17081994f, -0.00746621f, 0.13295439f, 
    0.29987642f, 0.05185591f, -0.13327299f, 0.15193479f, 0.13011703f, 0.01007759f, -0.00303862f, -0.14802584f, 
    0.23635218f, 0.04849484f, -0.04213498f, 0.22991645f, 0.17420565f, 0.01932317f, 0.20540227f, 0.04376990f, 
    -0.39539155f, -0.07285346f, 0.07318811f, -0.12453385f, 0.07520385f, 0.00709499f, -0.01059637f, 0.03332824f, 
    0.00954692f, -0.04558368f, -0.01198256f, -0.28768820f, -0.09245063f, -0.03216553f, -0.07893882f, 0.01188999f, 
    0.02216496f, -0.02417963f, 0.14915092f, 0.00617963f, 0.05864006f, 0.11626825f, 0.08873388f, -0.04159038f, 
    0.24156946f, 0.05849487f, 0.07670525f, -0.13853395f, 0.09815657f, 0.19669093f, -0.03036557f, -0.08431572f, 
    -0.11347748f, -0.17940110f, 0.05915656f, -0.07399732f, 0.03210136f, -0.30476308f, -0.21174721f, -0.03652135f, 
    0.03188860f, 0.10690725f, 0.19713512f, 0.10881948f, 0.01556558f, -0.05108070f, -0.06193599f, 0.06685622f, 
    -0.09433937f, -0.07119801f, -0.12567966f, 0.04148473f, -0.12715749f, -0.27656323f, 0.00153384f, 0.10668235f, 
    -0.02232405f, -0.18531229f, 0.10951925f, -0.08551064f, -0.02047330f, 0.15277201f, -0.07694340f, -0.05787556f, 
    0.02551239f, 0.08530863f, -0.21335816f, -0.17032883f, 0.18874274f, -0.11254076f, 0.14969380f, 0.18202345f, 
    -0.01783858f, -0.07863959f, -0.05399986f, 0.16963565f, 0.03960681f, -0.06566822f, 0.02424078f, 0.00594017f, 
    0.17469168f, -0.17001286f, 0.04172084f, 0.07564860f, -0.05822312f, -0.04284583f, -0.16778935f, 0.12123891f, 
    0.01682900f, 0.04038159f, 0.06297517f, 0.01937766f, -0.08587173f, -0.18080629f, -0.27631053f, -0.25179660f, 
    0.05432260f, -0.13674979f, 0.11760034f, -0.12276641f, -0.00595960f, -0.08487169f, 0.01197676f, -0.16554345f, 
    0.09401140f, 0.16073923f, -0.02255837f, -0.16145164f, -0.08229510f, -0.04814938f, 0.04717237f, -0.25404012f, 
    0.10122855f, -0.38564610f, 0.11287072f, -0.16343150f, -0.27576554f, -0.37641287f, -0.05187016f, 0.03960562f, 
    -0.23955193f, -0.18230405f, -0.23590219f, 0.07450467f, 0.03097221f, -0.05631875f, 0.10699964f, 0.13344063f, 
    0.25921789f, -0.07657472f, -0.14965871f, -0.01104249f, 0.01397852f, -0.03086206f, 0.01618806f, -0.62005448f, 
    -0.15872955f, 0.17169411f, 0.02948145f, 0.05447412f, -0.30638173f, -0.09772170f, -0.10253614f, -0.10405111f, 
    0.01966421f, 0.32202083f, 0.25968632f, -0.11493734f, -0.10579030f, -0.09452616f, -0.16916016f, 0.05847671f, 
    -0.04471559f, -0.01873780f, 0.19734550f, 0.14797464f, -0.17232703f, -0.01680968f, 0.02749176f, 0.09019711f, 
    0.12130661f, 0.21417981f, -0.04068756f, 0.01684284f, 0.34077820f, 0.15366802f, 0.15265475f, -0.00789596f, 
    -0.12247083f, 0.10625624f, 0.15778227f, -0.15066051f, -0.08781448f, 0.24622232f, -0.13691717f, 0.21846525f, 
    0.13392581f, -0.03676011f, 0.14017572f, -0.03756135f, 0.06852584f, 0.25400224f, 0.11559168f, -0.06538211f, 
    0.06579234f, -0.01098844f, -0.10686067f, 0.06579472f, 0.08377313f, 0.05990278f, -0.04260496f, -0.15483788f, 
    -0.07276852f, 0.04554864f, -0.07993033f, 0.03708744f, 0.03610776f, 0.26331890f, 0.37296945f, -0.21261247f, 
    0.25998956f, -0.10856550f, 0.01059462f, 0.25666612f, -0.09344085f, -0.14414382f, -0.01189063f, -0.16993256f, 
    -0.00166542f, 0.03376640f, 0.07959457f, -0.18235807f, 0.07443687f, 0.02494515f, -0.07380721f, -0.00086966f, 
    -0.31255791f, 0.19808103f, 0.26033103f, -0.12784271f, 0.17383438f, -0.03475511f, -0.14109871f, 0.35287511f, 
    -0.15169106f, 0.11142845f, 0.23054598f, 0.14007808f, 0.06508885f, -0.01763268f, -0.11307993f, 0.09047412f, 
    0.07554794f, 0.09102770f, 0.01273404f, -0.08264103f, 0.00274821f, -0.02886193f, -0.05039019f, 0.11438266f, 
    0.06216582f, 0.00562078f, -0.03448327f, 0.01338275f, -0.15400796f, 0.03408260f, 0.06512006f, 0.07488612f, 
    -0.11772794f, -0.25360286f, -0.15257469f, -0.16833812f, 0.08593877f, 0.35500917f, 0.06881559f, -0.01362418f, 
    0.07009128f, -0.06680094f, 0.18201073f, -0.01307347f, -0.00058455f, -0.02249415f, 0.25461271f, 0.21930473f, 
    0.19942276f, 0.12309487f, 0.12430013f, -0.03242930f, -0.01561726f, 0.02126152f, -0.01463066f, -0.26026446f, 
    -0.13496256f, -0.12948108f, -0.00290374f, -0.09985160f, -0.06621860f, -0.03937549f, -0.09602755f, 0.08303935f, 
    0.08325674f, 0.20626059f, 0.10151171f, 0.08599700f, 0.03788785f, 0.04360201f, 0.04647936f, 0.00699879f, 
    0.16575485f, 0.15627702f, 0.28830266f, 0.07943271f, -0.00601103f, 0.02187985f, 0.05956823f, -0.08862734f, 
    0.01931885f, 0.07073939f, 0.03913540f, 0.20563379f, 0.11838366f, 0.03197609f, 0.08804289f, -0.14921601f, 
    0.02807736f, 0.12837881f, 0.42136163f, -0.13659541f, 0.04605399f, -0.06297734f, 0.12604330f, 0.07958839f, 
    0.02333503f, 0.07815119f, 0.06628203f, -0.08862856f, 0.14874309f, 0.06850626f, 0.05763244f, 0.02774654f, 
    -0.27662414f, 0.17024754f, -0.04315780f, -0.22054195f, 0.02208331f, -0.06356565f, -0.40207991f, 0.05741264f, 
    0.07694782f, -0.02423257f, 0.01342382f, -0.05900363f, -0.08560118f, -0.06545816f, 0.02296053f, 0.16566537f, 
    -0.22245418f, 0.10229821f, -0.14609218f, 0.13324437f, -0.08042926f, 0.23114994f, -0.22106661f, -0.30446634f, 
    -0.44448766f, -0.04670236f, -0.08626775f, -0.02468051f, 0.01560856f, 0.05291975f, -0.05654762f, 0.09076202f, 
    -0.06280833f, -0.30221984f, -0.11274754f, 0.02838386f, -0.10264583f, 0.10413616f, -0.01774498f, -0.05641896f, 
    0.26227611f, -0.17872559f, 0.03367276f, 0.04420583f, 0.11467940f, 0.18521929f, -0.02346642f, -0.03586996f, 
    0.12852375f, 0.26077637f, 0.24108900f, 0.27884620f, -0.16291417f, -0.08295872f, -0.09415686f, 0.12331529f, 
    -0.05063725f, -0.10370252f, 0.09596769f, 0.02484144f, 0.35685113f, -0.07335700f, -0.14726053f, -0.19474435f, 
    -0.08899120f, -0.09959603f, -0.05745214f, -0.15746078f, 0.18949005f, 0.22318639f, 0.21189767f, 0.19258729f, 
    -0.00641366f, 0.03537469f, -0.04186240f, 0.04984315f, 0.20287000f, 0.06660178f, 0.25692269f, -0.12168753f, 
    0.00957339f, -0.30828664f, 0.01926367f, -0.18953070f, 0.01016723f, 0.28182498f, 0.02580217f, 0.27141789f, 
    0.01748210f, -0.01546027f, 0.15328698f, -0.00276040f, -0.04184004f, 0.15893130f, -0.11634161f, -0.22276430f, 
    -0.34830326f, -0.01028551f, 0.01667105f, 0.02070611f, 0.16279116f, -0.04288228f, -0.24958447f, -0.05629640f, 
    -0.32662264f, 0.07992274f, -0.03947406f, 0.23501661f, 0.20114048f, 0.07714764f, 0.06669415f, 0.20748210f, 
    0.07215891f, 0.11308853f, -0.07150214f, 0.15258126f, 0.06187754f, 0.00774799f, 0.11496945f, -0.00887114f, 
    -0.01856626f, 0.32441512f, 0.03981044f, -0.00972439f, 0.06052117f, 0.16395229f, -0.01566928f, 0.05578957f, 
    0.16609432f, -0.07287113f, 0.21862952f, 0.00524303f, 0.04359065f, 0.07580290f, 0.01456099f, 0.01097406f, 
    0.05085614f, 0.06230158f, -0.20752828f, 0.03101486f, -0.03870884f, -0.04480616f, 0.11853159f, 0.04087125f, 
    0.28296736f, 0.17723443f, 0.13500439f, -0.14623119f, 0.00340193f, 0.05954895f, -0.09819573f, -0.09250685f, 
    0.06880283f, 0.02358387f, -0.01227244f, -0.14222109f, -0.15335163f, -0.09346974f, 0.10960374f, 0.12427950f, 
    -0.23212178f, -0.15538317f, -0.02226913f, -0.12902856f, -0.10435009f, 0.12451015f, -0.04208393f, 0.24037060f, 
    0.12534486f, 0.13246372f, 0.06141744f, -0.22754233f, 0.10122085f, 0.08430828f, -0.10521257f, -0.14218117f, 
    -0.14648996f, -0.31859943f, 0.06891992f, -0.05205029f, 0.27063155f, 0.04038343f, 0.14414191f, 0.12879416f, 
    -0.00247174f, -0.21786162f, -0.02324330f, 0.08706041f, -0.04758676f, 0.03893017f, 0.09245326f, 0.05858995f, 
    -0.07196735f, -0.11434465f, 0.06088413f, -0.08825286f, 0.21505921f, -0.02688258f, 0.09552164f, -0.07058140f, 
    -0.25707513f, 0.09889886f, 0.03042127f, -0.06776167f, 0.09020977f, 0.15571375f, 0.01977122f, 0.01712852f, 
    -0.08161335f, -0.01523862f, -0.19095302f, 0.11616237f, -0.01475852f, 0.30546769f, 0.19021037f, 0.12398825f, 
    0.07430294f, 0.09520680f, 0.08958109f, 0.29929996f, -0.04618175f, -0.11522385f, -0.22415753f, -0.06108649f, 
    0.04666457f, -0.20497757f, -0.08622412f, 0.05340480f, -0.09766018f, -0.07902620f, -0.20524314f, -0.12852524f, 
    0.06046883f, 0.01111237f, -0.10893226f, 0.00304143f, -0.07810682f, -0.30482733f, -0.10347900f, -0.12059131f, 
    0.17213844f, 0.02560554f, 0.00730761f, 0.20230848f, 0.06056824f, 0.17675965f, 0.33141491f, 0.10146221f, 
    0.04097805f, 0.11772966f, 0.04179500f, 0.12809041f, 0.18048765f, 0.10892491f, -0.03253122f, -0.08532202f, 
    0.01270976f, 0.15763319f, -0.05387693f, 0.06265806f, 0.05397538f, -0.06859880f, 0.13813652f, 0.01377868f, 
    -0.03454641f, -0.11268607f, 0.00568102f, -0.06029769f, -0.03035311f, -0.05033322f, -0.11622210f, -0.10659575f, 
    -0.22585171f, -0.11958577f, 0.17126295f, 0.14216600f, 0.04604581f, 0.11173025f, 0.04956857f, -0.15196276f, 
    0.13510163f, 0.14029242f, 0.01352367f, -0.09758797f, -0.05895765f, -0.04561913f, 0.09140070f, 0.18680172f, 
    0.10450040f, 0.02678783f, -0.11314514f, -0.03503930f, 0.23536952f, 0.27046111f, 0.26212072f, 0.15208063f, 
    0.10553918f, -0.14402075f, 0.06709723f, 0.01962858f, 0.07733672f, -0.22168875f, 0.09261560f, -0.15578401f, 
    -0.01361014f, 0.11129031f, 0.03238409f, -0.00293836f, 0.22181164f, -0.02138709f, -0.19443622f, 0.03015621f, 
    0.20152357f, 0.15007991f, 0.20957942f, 0.31291145f, 0.05598414f, 0.26311749f, 0.14898172f, -0.11732557f, 
    -0.13296460f, 0.16475108f, 0.05237426f, 0.02748190f, -0.03118130f, -0.06653306f, -0.20171186f, -0.04753084f, 
    -0.01101050f, 0.16935652f, -0.01881814f, -0.01405767f, 0.07202307f, 0.00587013f, -0.03343146f, -0.09298921f, 
    -0.04473790f, -0.22799221f, 0.16488530f, 0.01360236f, 0.07568334f, 0.12238648f, 0.06897542f, 0.12138005f, 
    -0.12096774f, -0.12844330f, -0.16196382f, 0.08805703f, -0.01947734f, 0.11583371f, 0.18027426f, 0.14821157f, 
    -0.10329968f, -0.04250188f, -0.04566580f, 0.03930520f, -0.10781375f, -0.07597373f, -0.03041490f, -0.01844450f, 
    -0.05486098f, 0.06441276f, 0.03946491f, -0.15349922f, -0.32290882f, 0.04239249f, 0.20727639f, 0.10963436f, 
    0.09185912f, -0.02014011f, 0.09331691f, 0.19700104f, 0.14306101f, 0.08015603f, 0.13287413f, 0.01673041f, 
    -0.04554445f, -0.02802439f, -0.01324466f, -0.00954774f, -0.00863430f, -0.11867092f, -0.16777843f, 0.00400009f, 
    -0.12981673f, -0.01495775f, 0.16873944f, 0.34665540f, -0.01281879f, -0.10831597f, 0.29835135f, 0.25201258f, 
    0.13832003f, -0.04523718f, -0.09442952f, 0.01761639f, 0.09895574f, 0.01690740f, 0.06576099f, 0.01779225f, 
    -0.25311837f, -0.09697521f, -0.01894639f, 0.06630011f, 0.22231491f, 0.08993474f, 0.03854948f, 0.06242935f, 
    -0.09574453f, -0.05434782f, 0.03669553f, 0.17089285f, 0.03980647f, 0.12048555f, 0.16886410f, 0.05743328f, 
    0.26824957f, 0.05917671f, -0.44311744f, -0.63069063f, -0.21720134f, -0.07340509f, 0.11861911f, -0.00093364f, 
    0.03602102f, 0.04871455f, 0.04577488f, 0.20521165f, 0.21215102f, 0.11508966f, -0.22511865f, -0.06831898f, 
    -0.07465024f, -0.07342038f, 0.00815805f, -0.00169776f, -0.20939258f, 0.03237654f, -0.10865236f, -0.02615156f, 
    0.15106961f, -0.03595523f, 0.32223287f, 0.15134197f, -0.03989634f, 0.27527198f, 0.24642296f, -0.01413602f, 
    -0.16713393f, -0.18064803f, -0.03279126f, 0.05679509f, 0.06054119f, -0.03539941f, -0.74167085f, 0.06572215f, 
    -0.36316562f, 0.22597468f, 0.24695666f, 0.03735787f, -0.06143893f, 0.13036676f, 0.15472060f, 0.34834585f, 
    0.17158529f, 0.26050079f, -0.13169183f, -0.24507308f, 0.21635725f, -0.10001127f, -0.13358004f, 0.00900389f, 
    -0.01858286f, 0.27602851f, -0.17219500f, -0.11861414f, -0.02170147f, -0.18150695f, 0.04821964f, 0.22320226f, 
    -0.04876843f, -0.24910870f, -0.10486177f, -0.14693758f, -0.07766446f, -0.25165021f, -0.05059954f, 0.24625671f, 
    0.01784873f, 0.21100289f, 0.20708634f, 0.25934878f, 0.17150065f, 0.02474053f, 0.11238699f, 0.13757589f, 
    0.19056523f, 0.10945439f, 0.03130729f, 0.02807554f, -0.18083225f, -0.12030366f, -0.13261379f, -0.12285000f, 
    -0.02921974f, 0.05995410f, -0.06181178f, -0.04354735f, 0.00775729f, 0.06194717f, 0.01963004f, -0.16749589f, 
    -0.05325417f, 0.08345206f, -0.24147356f, 0.11039371f, 0.03051712f, 0.30562037f, 0.25758269f, 0.13888161f, 
    0.13728207f, -0.24126284f, -0.09829039f, 0.06737442f, 0.12770540f, -0.05858670f, 0.25065947f, 0.32618529f, 
    -0.17279941f, -0.27742973f, 0.01967491f, -0.11349093f, -0.02949524f, -0.03950110f, 0.03951197f, -0.04063479f, 
    -0.28826547f, -0.11463822f, 0.15778989f, 0.12989801f, 0.00359813f, 0.04515870f, 0.03865707f, 0.25473472f, 
    -0.28600174f, -0.33827513f, -0.12363086f, 0.06984571f, 0.02358680f, 0.05920755f, 0.05453633f, -0.01056925f, 
    -0.01405897f, -0.21474805f, -0.05414018f, 0.17668290f, 0.00622610f, 0.00614251f, 0.05833096f, 0.14624757f, 
    0.26514924f, 0.18823771f, -0.66543508f, -0.16238947f, -0.07371481f, -0.00397851f, -0.16863230f, -0.00159771f, 
    0.00920249f, -0.02060797f, 0.19397010f, 0.39200255f, -0.04965321f, 0.05395908f, -0.07032087f, -0.08688601f, 
    -0.21344756f, -0.00033308f, -0.13301951f, 0.02529707f, -0.19086912f, -0.17417647f, -0.03532177f, -0.38009843f, 
    -0.20523608f, 0.11231889f, 0.03540717f, 0.06435497f, 0.16329104f, 0.17340018f, 0.14252023f, 0.02070563f, 
    -0.11892078f, -0.05192226f, -0.09463851f, -0.08144408f, -0.04256952f, -0.03038899f, 0.52067846f, 0.11596449f, 
    0.23545051f, -0.18974353f, -0.07482625f, 0.08829396f, 0.00430468f, -0.20946427f, -0.00909174f, 0.30335212f, 
    -0.20902157f, 0.03250775f, -0.17157669f, 0.01788629f, -0.05246207f, 0.07105051f, -0.09404037f, 0.04756491f, 
    -0.25863189f, 0.02772458f, -0.07771466f, 0.00806747f, 0.07479646f, 0.01059392f, 0.02976558f, 0.14421789f, 
    0.08173801f, 0.21115071f, 0.00256776f, 0.01653984f, -0.01650966f, 0.01393939f, 0.03568779f, -0.03853477f, 
    0.24484080f, -0.06340929f, -0.02377343f, -0.06696565f, 0.10478117f, 0.01926925f, -0.16227967f, 0.10785517f, 
    0.16651697f, -0.05894469f, 0.08343332f, -0.52997714f, 0.21403022f, 0.13638042f, -0.06700795f, 0.09899034f, 
    -0.03344540f, -0.07332964f, 0.02404684f, -0.01828051f, 0.07645901f, -0.18851285f, 0.06176193f, -0.05784525f, 
    -0.17967385f, -0.04076894f, -0.00560514f, -0.14414473f, 0.11310107f, -0.47395602f, -0.33830076f, -0.10967031f, 
    0.10392485f, 0.12937300f, 0.12042592f, 0.16772258f, 0.00815124f, 0.12326904f, 0.27592945f, 0.30940711f, 
    0.02539047f, -0.18681780f, -0.15046689f, 0.00611634f, -0.04709195f, -0.07571574f, 0.01612651f, -0.50964695f, 
    -0.21674158f, -0.55634660f, 0.12577283f, -0.02829895f, 0.02980239f, -0.02301775f, 0.07571640f, -0.02999138f, 
    -0.04961519f, -0.02351221f, -0.05106959f, 0.04815836f, 0.01770830f, -0.00700920f, -0.05253834f, 0.04894010f, 
    -0.02244088f, 0.04213656f, -0.04270696f, -0.01550874f, 0.01965237f, -0.04427275f, -0.03499024f, 0.04621660f, 
    0.00938067f, -0.00709848f, -0.04311300f, 0.02748911f, -0.05429449f, -0.05544687f, 0.05962789f, -0.00219382f, 
    0.04237872f, -0.00533688f, -0.06108411f, -0.04774579f, 0.02268246f, 0.04534145f, -0.01129739f, 0.02153357f, 
    0.00155482f, -0.03801806f, 0.02644601f, 0.03728205f, 0.05448585f, 0.00113535f, -0.05828952f, 0.00238695f, 
    0.02319866f, 0.03966978f, -0.01226816f, -0.02862090f, -0.03603666f, -0.01048795f, -0.01701416f, -0.00421267f, 
    -0.05245484f, 0.03290338f, -0.07155576f, 0.02370149f, -0.04532453f, -0.04020800f, -0.04803053f, 0.04763426f, 
    0.01851595f, 0.02964847f, 0.03313545f, 0.00105575f, -0.05567520f, -0.02401184f, -0.03179648f, -0.06365073f, 
    0.00817440f, -0.02344136f, 0.03946324f, 0.02243638f, 0.01336700f, -0.01666026f, 0.00406821f, 0.04581030f, 
    -0.05073451f, -0.05439192f, 0.04395697f, -0.04965945f, 0.02781050f, 0.04431336f, 0.01517289f, -0.01043768f, 
    0.03486495f, 0.04706167f, 0.01546388f, -0.03921119f, 0.01858644f, -0.05690088f, 0.00579544f, -0.06768640f, 
    -0.02441772f, -0.04614560f, 0.04257389f, -0.01472599f, -0.01442091f, -0.04887109f, -0.02377130f, 0.05170699f, 
    0.00833081f, -0.03866168f, -0.01512439f, -0.00667489f, 0.03487474f, 0.00304423f, -0.06136442f, 0.01361320f, 
    -0.04823117f, -0.04418226f, -0.06182715f, 0.03290126f, 0.03865306f, 0.05105675f, -0.04707736f, 0.00379320f, 
    -0.00217824f, 0.02120249f, -0.03640869f, -0.06657592f, -0.00293337f, -0.00671874f, 0.01526491f, 0.03706805f, 
    0.02078645f, 0.02872834f, -0.05158363f, -0.03180848f, 0.02639983f, 0.03808245f, 0.02961098f, -0.05962492f, 
    0.00644378f, -0.05185777f, 0.00871983f, -0.03519506f, -0.02234949f, 0.00323627f, 0.00407719f, -0.05366632f, 
    0.03893022f, 0.02515585f, 0.02685881f, -0.01848972f, 0.02381511f, 0.01034603f, 0.00115461f, 0.05083401f, 
    0.04294856f, -0.01201651f, -0.02702155f, -0.01824174f, -0.00474934f, 0.03298366f, 0.03483889f, -0.05379526f, 
    -0.04662889f, 0.04202506f, 0.04775841f, -0.04329623f, -0.00088823f, -0.01818504f, -0.03466149f, -0.04417751f, 
    -0.01877864f, -0.03552244f, -0.05553496f, -0.05979016f, 0.03867777f, -0.03608129f, 0.00601800f, 0.05014114f, 
    -0.02374708f, 0.01837306f, -0.05074868f, -0.00670312f, 0.03082732f, -0.00689335f, 0.02007923f, -0.01245163f, 
    -0.04473393f, 0.02810061f, -0.04269793f, 0.00868917f, 0.03412206f, 0.03480188f, -0.05942237f, -0.03946412f, 
    -0.02611343f, -0.03358860f, -0.04446669f, -0.01215587f, -0.03822014f, -0.05142101f, 0.03627311f, 0.05609140f, 
    0.02578425f, 0.01418853f, -0.02734987f, 0.02331132f, -0.04527421f, -0.02474339f, -0.02459608f, -0.00014728f, 
    0.04602827f, -0.04216187f, 0.01154147f, -0.03020611f, -0.05378633f, 0.03298391f, -0.03299011f, -0.01348661f, 
    -0.00070544f, -0.03911994f, 0.02775795f, -0.00836958f, -0.00489528f, 0.01304329f, -0.02127153f, 0.00241520f, 
    -0.01011616f, -0.03245386f, 0.00008039f, 0.01270572f, -0.04883331f, -0.05187463f, -0.00358770f, 0.01085330f, 
    -0.00085147f, 0.04548508f, -0.01812448f, 0.00906350f, -0.00268407f, 0.00856897f, -0.00015365f, -0.04219842f, 
    -0.00371902f, 0.00389225f, 0.00271252f, -0.00385572f, 0.01957057f, -0.00321496f, 0.03430627f, -0.02024718f, 
    0.00848430f, 0.04996645f, -0.05573888f, 0.03586639f, -0.03428910f, -0.05997868f, 0.00430520f, -0.04581758f, 
    0.05186187f, -0.00346009f, -0.03457092f, 0.00332664f, -0.02301372f, -0.02852395f, 0.05134112f, 0.00095135f, 
    -0.05924677f, -0.03449485f, 0.03235422f, 0.02429810f, 0.01261319f, -0.05260624f, 0.01389199f, -0.03834044f, 
    -0.02315203f, -0.05670441f, 0.03288758f, -0.05325636f, -0.03669673f, -0.04428896f, 0.05008788f, 0.03902438f, 
    -0.01237152f, -0.00725338f, -0.01286918f, 0.02197573f, -0.05850706f, -0.02693428f, -0.00829009f, -0.04052388f, 
    -0.01614492f, -0.06105677f, -0.01023096f, -0.00309538f, -0.01347744f, -0.01677481f, -0.04613641f, -0.03166459f, 
    0.29743752f, 0.17470598f, -0.01132748f, -0.04549700f, 0.00629573f, 0.00897073f, 0.06976870f, -0.02741468f, 
    -0.04932808f, 0.01484973f, 0.09194461f, 0.21211235f, -0.05396353f, 0.23654881f, 0.06776334f, 0.04731983f, 
    0.11164994f, 0.25340277f, -0.09504302f, 0.08964342f, 0.24808419f, -0.19175810f, 0.06569430f, -0.04266837f, 
    0.04802065f, 0.14654274f, 0.01724484f, -0.25836986f, -0.30094883f, -0.21473806f, 0.01954659f, 0.23317160f, 
    0.02541707f, -0.00589015f, 0.18055123f, -0.14436528f, 0.26778546f, 0.10535359f, 0.02936469f, 0.11786721f, 
    0.15341039f, -0.07838056f, 0.19361193f, 0.27297068f, -0.01408502f, -0.14315014f, -0.41640246f, -0.10559698f, 
    -0.03353449f, 0.15226600f, -0.02008488f, -0.03076991f, 0.15565707f, 0.20145364f, 0.30270579f, 0.28940672f, 
    0.10452414f, 0.03311609f, -0.02669691f, 0.00914941f, -0.03159630f, 0.07878143f, -0.05266632f, -0.19729018f, 
    -0.05089705f, 0.08789735f, -0.01620189f, 0.09468541f, 0.12240709f, -0.17062715f, -0.11682244f, 0.18349293f, 
    -0.28444332f, -0.42482209f, -0.19496036f, 0.06470910f, -0.08661338f, -0.08281746f, 0.09371125f, 0.06232377f, 
    -0.18449084f, -0.43493241f, -0.24993949f, -0.13742566f, 0.03615994f, -0.33854535f, -0.08305238f, 0.13480477f, 
    -0.10303880f, 0.11495446f, -0.11052966f, 0.01087394f, 0.19801602f, 0.06582156f, 0.07486950f, -0.06543230f, 
    0.03104435f, -0.05324993f, -0.02169136f, -0.12034854f, -0.27672073f, 0.17338483f, -0.06076621f, 0.40464923f, 
    0.18132719f, 0.14848062f, 0.14683703f, 0.08452757f, 0.02974026f, -0.18293557f, -0.19838636f, -0.28202724f, 
    -0.02826556f, 0.11282858f, 0.06342559f, -0.00921249f, -0.04542146f, -0.23806515f, -0.25762910f, -0.00356385f, 
    -0.02826489f, 0.08559441f, -0.07670080f, -0.27000362f, -0.13596658f, -0.18969762f, 0.04169114f, 0.06328905f, 
    0.07332950f, 0.06506561f, -0.05700373f, 0.08986096f, 0.03005618f, 0.17023800f, 0.13921450f, -0.05745662f, 
    0.20140623f, 0.10011637f, 0.02257251f, -0.02455410f, 0.02811497f, 0.13869509f, 0.22063117f, 0.01551279f, 
    0.02604753f, 0.09096257f, 0.03024086f, -0.03170996f, -0.04323405f, -0.00377662f, -0.04049909f, 0.00353965f, 
    -0.24081007f, 0.22347361f, 0.08596261f, -0.08109257f, -0.07011455f, 0.14715439f, -0.05314087f, -0.04999219f, 
    -0.07030518f, 0.02458992f, 0.44279474f, 0.00093388f, 0.08246716f, 0.00930574f, -0.04433729f, 0.15217096f, 
    0.12932941f, 0.16276298f, 0.11284789f, -0.00674718f, 0.10534560f, 0.00839930f, -0.03235521f, 0.10320179f, 
    -0.27194101f, 0.11719102f, -0.37346762f, 0.02499048f, -0.20099032f, -0.31908211f, -0.23275103f, 0.11157610f, 
    0.06500180f, -0.02573342f, 0.06313933f, 0.09370454f, 0.10413984f, -0.15220751f, 0.21051668f, -0.09797699f, 
    -0.07412118f, -0.06852965f, -0.07112025f, -0.07797749f, -0.10786679f, -0.15461750f, -0.10547332f, -0.08508228f, 
    0.29255831f, 0.09341078f, -0.12183956f, -0.00721713f, -0.09503524f, 0.02970283f, 0.11954474f, -0.45240173f, 
    0.41717497f, 0.30799550f, -0.13393822f, 0.01296304f, -0.06561060f, -0.13433960f, -0.07773872f, -0.14013278f, 
    0.40375531f, 0.12605844f, -0.02504132f, 0.13560815f, 0.13090515f, 0.08658889f, 0.11380903f, 0.16436018f, 
    -0.01888134f, -0.21946231f, 0.00144312f, 0.00328741f, -0.09130682f, 0.05193667f, -0.12183039f, 0.10031329f, 
    -0.17036262f, 0.03098195f, -0.31241378f, -0.18090720f, -0.03074046f, -0.04611607f, 0.08867116f, 0.01156417f, 
    0.32568100f, -0.09992868f, 0.09069248f, -0.23938416f, 0.17141841f, -0.26965639f, -0.13833833f, 0.21196359f, 
    0.11098187f, 0.08978067f, 0.10056388f, -0.08675713f, -0.30994487f, -0.02425890f, -0.05802054f, -0.05508203f, 
    -0.04896150f, -0.03607640f, 0.07531757f, -0.06036742f, 0.04250574f, 0.35222873f, 0.18040945f, -0.10203832f, 
    -0.07603269f, 0.08478951f, 0.07126565f, -0.10487449f, 0.05738121f, -0.12098815f, -0.06398328f, -0.11755285f, 
    -0.15841232f, 0.11285517f, 0.12303153f, -0.00570069f, -0.08075020f, 0.02650645f, 0.25520578f, 0.42503160f, 
    -0.12608899f, -0.20498873f, -0.12015557f, 0.07934690f, 0.08787303f, -0.04419354f, 0.14855036f, -0.15874876f, 
    0.03555290f, -0.06117127f, -0.00846459f, -0.03855276f, -0.03330041f, -0.01682505f, -0.05225124f, 0.00403444f, 
    -0.04750973f, 0.03964425f, 0.03750836f, 0.02407347f, 0.03147537f, 0.01770574f, -0.06726228f, -0.05241271f, 
    0.00231647f, 0.00316485f, -0.01510047f, -0.04681079f, 0.01066225f, 0.04871884f, -0.04628754f, 0.01606683f, 
    0.03274506f, -0.00346125f, -0.06560683f, -0.02143095f, 0.01268384f, -0.00648797f, -0.02292393f, -0.04546009f, 
    0.03630537f, -0.06462351f, -0.04291311f, -0.03308726f, -0.00426369f, 0.02474618f, -0.00345537f, 0.02070660f, 
    -0.04246763f, -0.03819285f, -0.04677420f, -0.05388961f, -0.03181139f, -0.00608098f, 0.01903162f, 0.00001646f, 
    -0.02961361f, -0.01491247f, 0.03245753f, -0.01419098f, -0.06122268f, -0.06401314f, 0.00294086f, 0.01609942f, 
    0.02728467f, 0.01751795f, -0.00850572f, -0.05773001f, -0.05160888f, 0.02714277f, 0.02639707f, 0.03312695f, 
    -0.04596082f, -0.03787972f, -0.05391928f, 0.03911693f, 0.03112766f, -0.05778936f, -0.00202950f, -0.03324767f, 
    -0.06520578f, -0.03477305f, -0.01143455f, 0.02895932f, -0.05193931f, 0.04708614f, -0.00821575f, -0.06307901f, 
    0.01969834f, 0.00386219f, 0.01245391f, 0.01135430f, 0.00235728f, -0.04245722f, -0.06054920f, -0.02599183f, 
    -0.04526102f, 0.02896042f, -0.06398219f, -0.02966305f, -0.03754808f, -0.02335128f, -0.01603886f, -0.00671422f, 
    0.00563990f, -0.00337935f, -0.05798265f, -0.03007699f, -0.00707248f, 0.01043540f, -0.05693033f, -0.03181176f, 
    0.01353797f, -0.01611200f, 0.02978072f, -0.04290196f, 0.00995246f, -0.04727885f, -0.04610788f, 0.03495832f, 
    0.03138715f, 0.02387523f, 0.04492512f, -0.00480906f, -0.03403435f, -0.02491349f, 0.04485475f, -0.05636079f, 
    -0.06254326f, -0.01393485f, 0.04365971f, -0.04618370f, -0.05490543f, 0.04561120f, -0.02027388f, -0.06525493f, 
    0.00554025f, 0.04009162f, -0.06439520f, -0.02383688f, 0.04298957f, -0.03547940f, 0.02891671f, 0.02628180f, 
    -0.01472894f, 0.00139326f, -0.04463514f, 0.04849292f, 0.00412281f, 0.04154776f, -0.00613571f, 0.00935183f, 
    0.04626493f, -0.00539478f, 0.04037118f, -0.02146997f, -0.03211384f, 0.03305158f, 0.02262539f, 0.00309520f, 
    0.04753826f, -0.04497982f, 0.01873633f, -0.04101208f, -0.04112545f, -0.02906834f, -0.02116932f, -0.02957957f, 
    -0.03727730f, 0.02208283f, 0.02798098f, -0.03112326f, 0.01512839f, -0.02226523f, 0.02566191f, -0.02593975f, 
    0.03537490f, 0.03371236f, -0.05089609f, 0.01562361f, 0.03343106f, -0.04866414f, 0.01806115f, -0.04391943f, 
    0.03186375f, 0.00824886f, -0.05040190f, -0.01640771f, 0.03994707f, -0.02138987f, -0.00177399f, -0.01448058f, 
    0.00705372f, -0.03110274f, -0.05138303f, 0.01398199f, -0.01164418f, -0.03265402f, 0.04151226f, -0.01254029f, 
    -0.05038850f, 0.02459829f, -0.01889446f, 0.00411914f, -0.04725897f, 0.04787603f, -0.00288331f, 0.00737369f, 
    -0.01408674f, -0.01220346f, -0.00364198f, -0.00726269f, -0.02294958f, -0.06816857f, 0.01044426f, 0.01181812f, 
    -0.06258605f, -0.03031784f, -0.02573502f, -0.05216021f, -0.02003574f, -0.02389346f, -0.04147870f, 0.03607703f, 
    -0.06150896f, 0.04271608f, 0.04408550f, -0.01016796f, -0.05900075f, -0.03193298f, 0.02077815f, -0.04095493f, 
    -0.00420480f, 0.01166098f, 0.03078155f, -0.02831525f, 0.01892283f, 0.00716415f, -0.04744193f, -0.05767287f, 
    -0.04742252f, 0.04615510f, -0.05891376f, 0.01572562f, 0.01561878f, 0.00068313f, 0.00018649f, 0.01909062f, 
    -0.04281732f, 0.01292097f, -0.05372103f, -0.04613436f, -0.00205601f, 0.03872425f, 0.02215886f, 0.01029022f, 
    -0.02562555f, -0.01497547f, 0.04641767f, -0.06347188f, 0.02234556f, 0.03390244f, 0.01923085f, -0.00332934f, 
    -0.04402437f, -0.02627861f, 0.01449100f, -0.02823248f, -0.05674307f, -0.04671328f, 0.00313061f, -0.04707481f, 
    -0.06543598f, -0.01081116f, -0.03957948f, 0.02740512f, -0.04740519f, -0.00254739f, -0.01935412f, 0.03772557f, 
    -0.00129294f, -0.06535127f, -0.04457010f, -0.05101709f, -0.04514657f, -0.04910227f, -0.00007891f, 0.01621399f, 
    -0.03140021f, 0.04226366f, 0.01083038f, 0.03456559f, 0.03226405f, -0.04449563f, 0.01196233f, -0.06005764f, 
    0.00549167f, -0.01756416f, -0.04132516f, -0.05006037f, 0.02586293f, -0.06659076f, -0.02725614f, -0.03887300f, 
    0.02065865f, -0.06597567f, -0.00391858f, 0.02734581f, -0.05150617f, -0.03778059f, -0.00679292f, -0.03839131f, 
    -0.06731437f, 0.03703851f, 0.02298624f, -0.02928674f, -0.01705762f, -0.01016379f, 0.00388554f, -0.05440888f, 
    -0.06159836f, -0.05413030f, 0.01569190f, 0.04632994f, -0.06857626f, 0.04571585f, 0.00906333f, -0.02074466f, 
    0.02688422f, -0.02243884f, 0.02687737f, -0.06785586f, -0.01442988f, -0.01885437f, -0.06071551f, 0.01157397f, 
    -0.02546413f, 0.01659728f, -0.06371652f, -0.03281080f, -0.01601521f, -0.04933719f, -0.04481187f, 0.01619352f, 
    -0.03831112f, -0.00514073f, 0.03600248f, 0.03938901f, -0.00584862f, -0.00134587f, -0.03434256f, 0.03295087f, 
    0.01534896f, -0.05625105f, 0.04189402f, -0.03832189f, 0.02074967f, 0.03297443f, 0.00698992f, 0.02632935f, 
    -0.06592121f, 0.00402256f, -0.01304326f, 0.04559488f, 0.03155987f, 0.02328594f, 0.00985713f, 0.03587964f, 
    -0.01125593f, 0.00214835f, -0.00915122f, -0.02992097f, -0.04223919f, -0.04944232f, 0.04311675f, -0.03423966f, 
    0.04068450f, -0.04742811f, 0.01199530f, 0.03763196f, 0.01210237f, 0.03675312f, 0.02879653f, 0.01141962f, 
    0.04970635f, -0.02700637f, 0.03862491f, 0.01023492f, -0.01292833f, -0.01283754f, 0.02368318f, 0.02255156f, 
    0.00252986f, -0.06430709f, -0.04793479f, -0.06568993f, 0.04310147f, -0.05563771f, -0.04537415f, 0.02228141f, 
    0.03722232f, -0.06386504f, 0.02300964f, 0.04089758f, -0.04966068f, -0.01336026f, 0.05123321f, -0.04470495f, 
    -0.03701480f, -0.05689156f, 0.03545793f, -0.02011052f, 0.00454814f, -0.03654007f, 0.01258251f, 0.02047896f, 
    0.05076550f, -0.05421027f, 0.02230127f, -0.00841506f, -0.02203394f, -0.04218299f, -0.04095381f, 0.02101756f, 
    0.01267734f, -0.03369463f, -0.03700695f, 0.02172864f, -0.02844978f, -0.05553426f, 0.00478197f, -0.01764022f, 
    -0.06790269f, 0.02168980f, -0.03781956f, 0.00119931f, -0.04463131f, -0.01182503f, -0.05949627f, -0.05907756f, 
    0.01066558f, -0.02313578f, 0.04118692f, -0.02818939f, 0.03155915f, 0.04408937f, 0.01318102f, 0.00211391f, 
    0.01122803f, 0.01784536f, -0.06053920f, -0.04340616f, 0.03302066f, -0.02669651f, -0.02273779f, -0.02531857f, 
    0.04430170f, -0.00254592f, -0.01729305f, -0.01561522f, -0.03903854f, 0.01343373f, -0.06016604f, -0.05450570f, 
    0.03747572f, 0.02779511f, -0.05806541f, 0.02043354f, -0.02692652f, -0.01368895f, -0.01915303f, 0.03605646f, 
    0.02781010f, 0.00898171f, -0.00003962f, 0.04302381f, 0.04288604f, -0.02734328f, -0.04626584f, -0.06039894f, 
    -0.00503488f, 0.01038110f, -0.06422918f, 0.01869339f, 0.01649095f, -0.05613794f, 0.00000198f, -0.06293485f, 
    -0.04971198f, 0.02007325f, 0.03258140f, -0.05255288f, 0.04449209f, -0.00859221f, -0.06537347f, 0.01639437f, 
    -0.03931367f, 0.00537835f, 0.01551208f, 0.04278066f, 0.02325821f, -0.04335108f, -0.05548839f, -0.00054130f, 
    -0.05018450f, -0.01477289f, 0.01170217f, 0.02226058f, -0.06322668f, -0.04753971f, 0.02012304f, -0.05114317f, 
    -0.05421954f, 0.03483732f, 0.04426872f, -0.02669787f, 0.04297557f, -0.06368870f, -0.00370619f, 0.02657645f, 
    -0.03651495f, -0.06661963f, 0.00266532f, 0.00605863f, -0.06600016f, 0.00322481f, 0.02949079f, -0.03912066f, 
    -0.02910694f, 0.03293777f, 0.02888493f, 0.03999296f, -0.05225283f, 0.02849655f, -0.02809410f, -0.01064688f, 
    0.00351512f, 0.00555634f, 0.04107981f, -0.02763301f, 0.02644525f, -0.04677430f, 0.02087695f, 0.02621086f, 
    -0.01871536f, -0.06067761f, -0.03463848f, 0.01403915f, 0.00704807f, -0.03046131f, -0.03475601f, -0.05245964f, 
    0.04198238f, -0.02019903f, 0.04443459f, 0.02138583f, 0.00506185f, -0.01281376f, -0.06485246f, -0.00753081f, 
    0.02656601f, -0.05875878f, 0.00692413f, 0.01367461f, 0.01990356f, 0.03372314f, -0.00873913f, 0.04201446f, 
    -0.05078426f, -0.01498192f, -0.02582048f, -0.04390272f, -0.03148255f, -0.01244215f, 0.02066222f, 0.01560182f, 
    -0.05602845f, -0.04188639f, -0.05678442f, -0.02433996f, -0.00095274f, -0.04181830f, -0.03603739f, 0.02320674f, 
    -0.06155533f, -0.15743309f, -0.09829447f, 0.02315307f, -0.04235502f, 0.12727292f, -0.09349760f, 0.16606306f, 
    0.03472875f, 0.08414598f, 0.21694519f, -0.03248830f, 0.09002154f, 0.05868828f, -0.02818145f, -0.15610673f, 
    -0.01105313f, -0.20320812f, -0.27703682f, -0.13249625f, -0.12815326f, 0.14527425f, -0.07482270f, 0.15115178f, 
    0.00063957f, -0.09099610f, 0.02329323f, -0.07082416f, 0.10510835f, 0.11702929f, -0.03668326f, 0.28256804f, 
    -0.13166468f, -0.00047359f, 0.30532774f, 0.02195378f, 0.04280421f, -0.11219498f, -0.04268262f, -0.00017119f, 
    0.03086777f, -0.14678322f, 0.04571492f, -0.00340908f, 0.18107042f, -0.27130702f, -0.20580873f, 0.04948530f, 
    0.06775224f, -0.01597187f, 0.06222615f, 0.03503745f, 0.03386459f, -0.15034974f, -0.04541396f, 0.18550214f, 
    0.07159131f, 0.04124118f, 0.15242425f, -0.08602516f, 0.02867162f, 0.08021839f, 0.12222812f, 0.21499743f, 
    0.03057783f, 0.25428405f, 0.17386700f, -0.11553531f, -0.17270862f, 0.04799759f, 0.07739754f, 0.10284726f, 
    0.04053075f, 0.70634222f, 0.23443006f, 0.00017320f, -0.07805056f, 0.00232752f, 0.07180058f, 0.32840928f, 
    -0.05228891f, 0.22128199f, -0.45272499f, -0.13111770f, 0.18568715f, 0.36174661f, 0.18257812f, 0.05709523f, 
    -0.01114226f, -0.10384718f, -0.07166603f, -0.03189795f, 0.00002004f, 0.08999436f, -0.13249171f, -0.06508546f, 
    0.14866583f, -0.01279424f, 0.13065657f, -0.06443732f, 0.12852319f, 0.14864066f, -0.04177151f, -0.11359262f, 
    -0.09225974f, -0.16982688f, 0.15754253f, -0.39630654f, 0.29949474f, 0.59673566f, 0.28086799f, -0.01797256f, 
    -0.15114705f, -0.40452453f, -0.03825550f, 0.34960678f, 0.12288200f, 0.12961210f, 0.22104384f, 0.06587165f, 
    0.15527166f, 0.05235614f, -0.13084696f, 0.23111691f, 0.17091833f, 0.16706911f, -0.11626723f, 0.18284136f, 
    0.14305827f, 0.02138059f, -0.16220672f, -0.01427466f, -0.24301296f, -0.18377987f, -0.16363606f, -0.02780522f, 
    -0.11196502f, -0.31968614f, 0.00900615f, -0.13818386f, 0.12840386f, 0.02594047f, -0.14728253f, 0.03610843f, 
    -0.04174432f, -0.18452199f, 0.01347465f, -0.02091422f, 0.16736400f, 0.00154638f, -0.04749694f, -0.10632896f, 
    -0.07509123f, 0.02901121f, -0.04251343f, 0.02684503f, -0.08879285f, 0.06831925f, 0.01153634f, 0.03160260f, 
    0.21450493f, 0.15407909f, -0.00407848f, 0.32033405f, -0.01276296f, 0.15836348f, 0.02576115f, 0.10273270f, 
    -0.11983952f, 0.18110034f, -0.22057101f, 0.04765288f, -0.24257432f, -0.06187156f, 0.00064847f, 0.17096801f, 
    -0.00286670f, -0.10572448f, 0.14114700f, -0.29428869f, -0.03046305f, 0.02797275f, 0.26596028f, 0.10607053f, 
    0.09757658f, 0.07786430f, -0.21900083f, -0.15988281f, -0.33414638f, -0.00585026f, -0.01234678f, -0.09408881f, 
    0.14971711f, -0.14498445f, 0.01323493f, -0.23863757f, -0.06777685f, -0.18256013f, -0.04826332f, 0.11256342f, 
    -0.03297248f, -0.03778441f, -0.13689269f, -0.05422480f, -0.11228655f, -0.09742151f, -0.12488250f, 0.06509493f, 
    0.01856967f, 0.07377034f, 0.13029832f, 0.07010686f, -0.01180814f, 0.02818712f, -0.11103979f, -0.03387864f, 
    -0.07502762f, -0.00475438f, -0.04247963f, -0.03801893f, 0.03408442f, 0.00426526f, 0.27287614f, 0.18316936f, 
    0.04168655f, 0.06322399f, -0.10228533f, -0.02767298f, 0.26849034f, 0.06269273f, 0.02630642f, 0.00374413f, 
    0.10074592f, 0.02590587f, -0.00757993f, -0.10435513f, -0.11346109f, 0.21956654f, 0.26621705f, -0.00366363f, 
    -0.14070071f, 0.00454208f, 0.01454088f, -0.01460968f, -0.03579955f, -0.16905166f, 0.16445237f, -0.05526336f, 
    0.06701520f, -0.18190402f, -0.12870695f, -0.21457161f, -0.02007398f, 0.01716715f, -0.08471336f, 0.22865957f, 
    0.00187732f, 0.04053938f, 0.01383356f, 0.04792910f, -0.28517610f, -0.07766176f, -0.13758254f, 0.10384268f, 
    0.11763524f, 0.05280008f, -0.03515517f, -0.06817261f, -0.01457239f, -0.00773227f, -0.18872164f, 0.07215807f, 
    0.22179009f, 0.10212140f, -0.16984099f, 0.02977118f, -0.00910649f, -0.00526951f, -0.13057718f, -0.26957068f, 
    -0.09953769f, -0.03287282f, 0.11402309f, 0.04411440f, 0.12013455f, -0.12908261f, -0.02535486f, -0.27464384f, 
    0.00481707f, 0.03656540f, 0.03707572f, 0.01938291f, -0.05829830f, -0.03802660f, -0.04460047f, -0.02122963f, 
    -0.05891412f, -0.04679878f, -0.01174162f, -0.06317817f, 0.00313732f, 0.04232131f, 0.04190195f, 0.02108462f, 
    -0.03295526f, 0.04238550f, -0.04044665f, -0.06149588f, -0.05291717f, -0.05572407f, 0.00395730f, 0.02831309f, 
    -0.02540915f, 0.02921255f, 0.02515212f, -0.03087771f, 0.01151251f, -0.06333254f, -0.06050031f, -0.06744717f, 
    0.03557195f, 0.03139092f, -0.00521585f, -0.04553248f, -0.04770780f, 0.00944801f, -0.03552117f, -0.01409853f, 
    -0.00611859f, -0.05742954f, 0.00456312f, 0.03632773f, 0.01967680f, -0.04480508f, -0.01759722f, -0.04474286f, 
    0.03708163f, 0.02020925f, 0.00636390f, 0.00886517f, -0.06061925f, -0.04397386f, 0.00647993f, 0.02580705f, 
    0.00883810f, -0.00191655f, 0.01416170f, -0.01791178f, -0.05897531f, -0.06888868f, 0.02709906f, 0.02581868f, 
    -0.05544415f, -0.04783503f, -0.01224407f, -0.05183076f, 0.00666413f, 0.02786864f, 0.02894679f, 0.03757823f, 
    -0.04394602f, -0.00709657f, -0.05610382f, -0.05840622f, -0.04861139f, -0.02223442f, -0.03024642f, -0.04993970f, 
    0.04241645f, -0.05298822f, -0.03417670f, 0.04133247f, 0.02809644f, 0.02382344f, 0.02213719f, -0.01449640f, 
    -0.05620576f, -0.01591835f, 0.02397005f, -0.02242510f, -0.06087629f, -0.01724167f, -0.05178968f, -0.06020695f, 
    -0.02015917f, 0.02406349f, -0.02859883f, 0.04824163f, -0.03848812f, -0.05450466f, 0.03844911f, 0.04267626f, 
    -0.05320158f, 0.00998265f, -0.01889694f, -0.01794551f, -0.00154583f, -0.06157498f, -0.02986269f, 0.00140282f, 
    0.02281068f, 0.00490253f, 0.01363633f, 0.04765783f, 0.00196235f, 0.00296506f, -0.05961997f, -0.03616082f, 
    -0.03875197f, 0.03119433f, -0.01033512f, -0.01407413f, 0.01766611f, 0.02395261f, -0.01069842f, 0.00082828f, 
    0.02986837f, 0.02121264f, -0.03737178f, 0.02724954f, 0.02193907f, -0.04104656f, -0.00346255f, -0.02984509f, 
    0.00272045f, -0.05485612f, 0.04221251f, -0.02381622f, -0.01376485f, 0.00476966f, -0.06565681f, -0.03828575f, 
    -0.01403500f, -0.06025421f, 0.02721678f, 0.00462253f, -0.01349322f, -0.04301389f, -0.04755199f, 0.03057289f, 
    0.03616928f, -0.02765759f, -0.03105438f, 0.05115142f, -0.00817703f, -0.03250620f, 0.03284844f, 0.02106369f, 
    0.01777537f, -0.02310825f, -0.03635818f, -0.04850664f, -0.00661989f, 0.02236555f, 0.04317246f, -0.06446109f, 
    -0.02784654f, -0.01030593f, -0.03747032f, -0.01400039f, 0.01102432f, -0.05537504f, 0.01763405f, 0.04994934f, 
    -0.02780519f, -0.02723450f, 0.02733515f, 0.04156466f, -0.01065516f, -0.00728999f, -0.03714230f, 0.04480752f, 
    0.04077968f, -0.01385371f, 0.01012362f, 0.02699557f, -0.04066792f, -0.00281525f, -0.06117949f, -0.02962514f, 
    0.00079618f, 0.00896251f, -0.05104404f, -0.03513054f, -0.04967205f, 0.01519234f, 0.04111382f, 0.02159487f, 
    -0.02633388f, -0.04846024f, -0.01104741f, -0.02030641f, 0.04245594f, -0.01685476f, -0.03809050f, -0.01417783f, 
    -0.04557399f, 0.03036353f, 0.02532217f, 0.04027053f, -0.02694602f, 0.00801983f, -0.04433206f, 0.04055132f, 
    0.00924500f, 0.02241489f, 0.02413105f, 0.00363620f, 0.03439377f, -0.05987708f, -0.03073312f, -0.01498610f, 
    -0.02115837f, -0.02282559f, 0.02764752f, 0.00054799f, 0.04183208f, 0.03265834f, -0.06511348f, 0.00512799f, 
    -0.05624539f, -0.03579235f, 0.04943104f, -0.02954700f, 0.01944981f, 0.00048539f, 0.04051341f, 0.04089174f, 
    0.03303609f, -0.00824887f, -0.06981187f, -0.02211238f, 0.02276932f, 0.04277417f, 0.00897276f, 0.02947586f, 
    -0.03272699f, -0.00255351f, -0.05145682f, -0.03909593f, -0.04566705f, 0.04196941f, 0.00362889f, 0.02249583f, 
    -0.04002313f, 0.02108932f, -0.06424753f, -0.05748571f, -0.01570941f, 0.01139316f, -0.06521142f, 0.00097850f, 
    -0.03956545f, 0.04731436f, 0.03409881f, -0.00720067f, -0.03683822f, 0.01203675f, -0.00449684f, -0.01104564f, 
    -0.02546842f, -0.01188592f, -0.02894665f, -0.03395998f, 0.00598927f, -0.04160227f, -0.03953741f, -0.05920338f, 
    -0.02255090f, 0.00668687f, -0.01062850f, -0.05237728f, -0.02429529f, 0.04101504f, 0.04580856f, -0.05191609f, 
    -0.26834986f, 0.08759606f, 0.04541375f, -0.05666677f, -0.07913355f, 0.01073013f, 0.00713396f, -0.05063290f, 
    0.14430034f, -0.25059918f, -0.33332515f, -0.10631246f, -0.08761968f, 0.01754413f, -0.07001429f, -0.08660315f, 
    -0.12429187f, -0.05861856f, -0.02182499f, -0.68431759f, 0.49937984f, -0.08208931f, -0.04297431f, -0.23903233f, 
    0.14633402f, -0.08732721f, -0.16783215f, -0.30318227f, 0.48127720f, -0.27318835f, 0.21096160f, -0.18100633f, 
    0.23559724f, 0.02424127f, 0.03635822f, 0.23204868f, -0.26713398f, 0.14659078f, -0.15044534f, -0.00683308f, 
    0.06336205f, 0.00052848f, 0.03717465f, 0.06288704f, -0.01060895f, 0.19988102f, 0.15450515f, 0.04661471f, 
    -0.08481790f, -0.04272886f, -0.16648786f, -0.00244360f, -0.02180292f, -0.17994541f, -0.15860759f, -0.15493675f, 
    0.25867096f, -0.00596574f, -0.07105820f, -0.13005988f, -0.03868085f, 0.17420146f, -0.10169823f, 0.32325214f, 
    -0.04413059f, -0.04354270f, 0.00780283f, -0.05765267f, -0.01119667f, 0.07127614f, -0.01584177f, 0.10237586f, 
    -0.34600535f, 0.23963423f, 0.20896217f, 0.00692576f, 0.30320078f, -0.18812965f, -0.02515393f, 0.03327944f, 
    0.19910525f, -0.09348787f, 0.24789524f, 0.28798351f, -0.01720413f, -0.25704956f, -0.02481010f, 0.10169908f, 
    0.01888207f, 0.00767558f, 0.07129769f, -0.22745295f, 0.10256431f, 0.03971796f, -0.05748966f, -0.04334351f, 
    0.06922216f, -0.01781893f, 0.19684236f, -0.30024865f, 0.35996795f, 0.39960453f, -0.00167595f, 0.09443331f, 
    -0.09557669f, 0.00952924f, -0.03352701f, -0.06840903f, -0.78743804f, -0.05120234f, -0.34648320f, 0.12352057f, 
    0.47778037f, 0.11881746f, 0.05571521f, -0.16291559f, 0.03125758f, -0.17823988f, 0.00171835f, -0.12652066f, 
    0.05965802f, 0.24243657f, -0.04373534f, -0.05614573f, 0.10440470f, 0.26829031f, 0.10161916f, 0.15285417f, 
    0.27845716f, 0.03667414f, -0.04108096f, 0.08370668f, -0.02768033f, 0.08233055f, -0.10625716f, 0.02575992f, 
    0.00247193f, 0.16173129f, -0.16682667f, -0.13427602f, -0.28638613f, -0.04283284f, 0.05058438f, -0.01991404f, 
    0.16498853f, -0.05036250f, -0.11884020f, 0.04448813f, -0.03635962f, -0.00774080f, 0.11854224f, -0.04249250f, 
    0.05611531f, -0.10853485f, -0.09144951f, -0.01717732f, 0.11386731f, -0.13866995f, 0.02745739f, -0.09907029f, 
    -0.12831996f, 0.21758838f, -0.56381321f, 0.50170380f, -0.11786959f, 0.14330205f, 0.23874071f, -0.07094949f, 
    -0.04212953f, 0.01180152f, 0.13169971f, -0.28127956f, 0.19662762f, 0.20948516f, -0.01955982f, -0.08374313f, 
    0.05134810f, 0.11324286f, -0.04035974f, -0.06595606f, 0.10720697f, 0.06473704f, -0.04527070f, -0.06788243f, 
    -0.08677717f, -0.02741649f, -0.08194766f, 0.04625377f, -0.03919157f, -0.29521924f, -0.01876870f, 0.44258231f, 
    -0.00175350f, -0.02325252f, 0.13849321f, 0.01860360f, -0.02729295f, -0.00589042f, 0.00953950f, 0.24588540f, 
    0.24536002f, -0.02866565f, -0.03086119f, -0.12151112f, 0.09113660f, 0.05656052f, -0.15654011f, 0.02255674f, 
    -0.02592305f, 0.10854717f, 0.01983948f, -0.01267635f, 0.08971483f, 0.04943687f, 0.13295127f, 0.02319140f, 
    -0.27868819f, -0.37011710f, -0.06714187f, 0.00357666f, -0.24896254f, -0.01946914f, -0.04266497f, 0.08596291f, 
    0.12640788f, -0.09854594f, -0.18997595f, 0.10910209f, 0.00178195f, 0.00260074f, 0.10910291f, 0.05894135f, 
    -0.18639684f, 0.02525647f, 0.15348576f, 0.26513129f, 0.04212637f, -0.11543004f, -0.18273635f, -0.03251355f, 
    0.07703897f, -0.03678753f, 0.06222807f, -0.15380128f, -0.42365545f, 0.07087911f, 0.03220744f, 0.04461176f, 
    0.04770755f, -0.05928484f, 0.01570099f, -0.16802940f, 0.08467752f, 0.09461210f, 0.15240619f, 0.14987087f, 
    0.06023962f, -0.09121036f, -0.08539814f, -0.13174149f, 0.18725216f, -0.04738219f, -0.20772628f, -0.16127212f, 
    0.01331167f, -0.04327269f, 0.26894623f, 0.13243340f, 0.07893487f, -0.00521398f, 0.08944280f, 0.08031145f, 
    0.17922768f, -0.13810948f, -0.06526665f, 0.05856711f, 0.04768200f, 0.05053750f, 0.05853784f, -0.83021045f, 
    -0.39127728f, -0.13955185f, -0.22591786f, -0.34519687f, -0.15765373f, 0.00982590f, 0.04920088f, 0.05876289f, 
    0.07452078f, 0.00157884f, 0.24352255f, -0.03806746f, 0.02602079f, 0.06273631f, -0.12297118f, 0.08039341f, 
    0.16988523f, 0.09426358f, 0.00707130f, -0.19432753f, 0.02795915f, 0.00517954f, 0.03931658f, -0.19952655f, 
    -0.01701188f, -0.05196141f, -0.09287284f, -0.08307731f, -0.08066145f, 0.06768057f, -0.04607785f, 0.22466607f, 
    -0.12410131f, 0.05433492f, -0.17951381f, -0.02158989f, -0.01873197f, 0.14331079f, 0.12321452f, -0.07854932f, 
    0.15087053f, 0.03414473f, 0.05892463f, 0.11897127f, -0.11863010f, -0.01467440f, 0.24006963f, -0.09083385f, 
    0.02229294f, -0.01469138f, 0.11293265f, 0.09095013f, 0.20813443f, -0.00636423f, 0.03976250f, -0.00903557f, 
    -0.07188243f, -0.03672218f, -0.11307431f, 0.07138933f, -0.03193818f, 0.07399058f, 0.05090421f, -0.25883296f, 
    -0.01370715f, 0.11778416f, -0.15877946f, -0.18788101f, -0.06440540f, 0.07319279f, -0.11512185f, -0.20408553f, 
    0.22126952f, -0.00776771f, -0.15772046f, 0.05999860f, -0.16425289f, -0.12282531f, -0.16243541f, 0.04851028f, 
    -0.03644887f, -0.20196240f, -0.08907985f, 0.18604004f, -0.22210948f, 0.15199246f, 0.02196025f, 0.01648938f, 
    -0.07082596f, 0.33895797f, -0.10516406f, -0.28170595f, 0.00013546f, 0.06082600f, 0.13838239f, -0.01707106f, 
    -0.10824936f, 0.15922758f, 0.08543161f, -0.07586296f, -0.29400960f, 0.18300259f, -0.07691973f, -0.03822337f, 
    0.16679758f, 0.23768291f, 0.14043848f, 0.02811797f, -0.11954082f, 0.01629056f, 0.10362709f, -0.15073347f, 
    0.22878776f, -0.05641198f, 0.05752094f, -0.17949685f, -0.02896566f, 0.08256314f, 0.10397939f, 0.08691922f, 
    -0.17856139f, 0.15750284f, 0.02495882f, -0.07356820f, -0.00404961f, -0.11269608f, -0.04666208f, -0.07933854f, 
    -0.05124970f, 0.02037999f, 0.00432027f, 0.20650728f, 0.16176791f, 0.16335434f, -0.16213657f, 0.19112705f, 
    -0.01869152f, 0.10681584f, -0.09416285f, -0.18142591f, -0.04837707f, -0.16777235f, -0.02954136f, -0.10153628f, 
    0.00711843f, 0.02273777f, 0.12514038f, -0.10271623f, 0.11370475f, -0.10915356f, 0.08423899f, -0.03338980f, 
    0.02443545f, 0.04890507f, 0.06363958f, -0.10119639f, -0.05847785f, 0.14798276f, 0.04082570f, -0.16312221f, 
    -0.10708585f, -0.03282586f, -0.07152012f, 0.08614245f, -0.09928183f, 0.03213946f, -0.03493989f, -0.02535451f, 
    0.17562337f, 0.18260616f, 0.23232204f, -0.14512511f, 0.17430478f, -0.10774674f, 0.01905656f, -0.07732373f, 
    -0.06551992f, 0.05205905f, 0.06063483f, 0.03656049f, -0.08184683f, 0.21121006f, 0.07242750f, -0.00601537f, 
    0.27113333f, -0.02393865f, -0.09292722f, -0.06982086f, 0.20787963f, -0.10814438f, -0.23253691f, 0.11631866f, 
    0.15182878f, -0.05124514f, 0.00918114f, 0.02892789f, 0.06763365f, -0.04894980f, 0.00086094f, -0.05771858f, 
    0.12117144f, -0.08528723f, -0.01528718f, -0.03251139f, -0.11107748f, -0.49768582f, 0.05078768f, 0.09142273f, 
    -0.07075798f, -0.12252299f, -0.12419549f, -0.08546986f, 0.03131704f, -0.02648271f, -0.18961361f, 0.00297801f, 
    0.27314103f, 0.08705202f, 0.10118290f, 0.07727813f, 0.03921142f, -0.03424556f, -0.03597611f, 0.04124867f, 
    -0.01925589f, -0.10749697f, -0.03121000f, 0.05055588f, -0.01777712f, 0.03352765f, 0.21894597f, 0.22104685f, 
    0.16095990f, -0.07630178f, 0.06170460f, 0.07319779f, 0.13224839f, 0.06208351f, 0.08579070f, -0.05715808f, 
    0.00554236f, -0.00628787f, 0.18347628f, 0.12467812f, 0.13051881f, 0.09975059f, 0.06393794f, -0.04971494f, 
    -0.11107109f, 0.01046460f, 0.00545492f, -0.10082608f, -0.02152084f, -0.08957712f, 0.08323894f, -0.04281544f, 
    0.12766221f, -0.15572405f, 0.04298677f, -0.06366720f, 0.05855651f, -0.06863545f, 0.13474734f, -0.02183084f, 
    0.05352775f, -0.03336863f, 0.05623944f, -0.02837952f, -0.21997747f, -0.04227969f, 0.02234665f, 0.03543853f, 
    -0.00437083f, -0.17851044f, -0.00664651f, -0.10761486f, -0.05060132f, -0.00965500f, -0.12657148f, 0.08679172f, 
    0.13305326f, 0.00365375f, -0.10381789f, -0.16322812f, -0.02263231f, -0.11807847f, -0.06833317f, -0.13227069f, 
    0.16893044f, 0.07811341f, 0.08591009f, -0.02552788f, 0.11537442f, -0.01691148f, -0.09274776f, -0.03767917f, 
    -0.04837881f, -0.00507797f, -0.05416844f, -0.02313138f, 0.00189444f, -0.08702286f, -0.05806881f, -0.03659351f, 
    -0.00589354f, -0.04759286f, -0.01111692f, -0.01895797f, -0.05270859f, 0.00466641f, -0.07622740f, -0.05980475f, 
    -0.03990638f, 0.00522073f, 0.01402094f, -0.01766064f, -0.07248104f, 0.01793751f, -0.00146185f, -0.08373095f, 
    -0.02843258f, -0.02923824f, -0.08251791f, -0.06892303f, -0.05329866f, -0.01541521f, -0.02866960f, -0.05566673f, 
    -0.04419034f, -0.04376519f, -0.06929394f, -0.02996529f, 0.01415580f, -0.07562784f, -0.05574511f, 0.01535989f, 
    -0.06446205f, 0.02425259f, -0.08430249f, -0.07726663f, -0.03382297f, -0.01696055f, -0.02590568f, -0.05974790f, 
    -0.02699189f, -0.07584117f, 0.00672486f, 0.02926415f, -0.07240750f, -0.06664674f, -0.00315892f, 0.02178091f, 
    -0.07379588f, 0.01898887f, -0.07809682f, 0.01157465f, -0.02176592f, 0.01044916f, -0.05860710f, -0.08620548f, 
    0.01521884f, -0.05048655f, -0.02792038f, -0.09177680f, -0.02347668f, -0.00503661f, 0.01826826f, 0.01539238f, 
    0.01018447f, 0.03207284f, -0.00219245f, -0.05015191f, -0.05376510f, 0.02511861f, 0.01210036f, -0.00394301f, 
    -0.03618477f, -0.04874556f, -0.07343835f, -0.05254739f, -0.04910327f, -0.00090269f, -0.08122036f, -0.00402583f, 
    0.01783186f, 0.02254997f, -0.01994345f, -0.07475921f, 0.02085363f, 0.01113422f, -0.04589798f, -0.06663510f, 
    -0.02141955f, -0.02405358f, -0.08227966f, -0.07163411f, -0.02683834f, -0.03805260f, -0.01755936f, -0.00299384f, 
    -0.07942197f, -0.02102568f, -0.07424250f, -0.07153635f, -0.01694087f, -0.04495406f, -0.06162977f, -0.00413379f, 
    -0.01895711f, -0.00332833f, -0.04307620f, -0.03987154f, -0.02530056f, -0.03002400f, -0.07576398f, -0.01952153f, 
    -0.03533534f, -0.07168986f, -0.00121522f, -0.08193792f, 0.02918695f, -0.02110910f, 0.02052513f, -0.07262880f, 
    -0.03544981f, 0.01512031f, -0.06658623f, -0.02210756f, -0.02071176f, 0.01017288f, -0.06308918f, -0.08596890f, 
    -0.02097477f, -0.04497321f, -0.02643664f, -0.00740842f, -0.00449850f, -0.01425719f, -0.02046730f, -0.04941836f, 
    -0.07417116f, -0.01361595f, -0.07317189f, -0.06493287f, -0.01678454f, -0.04027781f, -0.03452902f, -0.00704740f, 
    0.01510284f, -0.05219082f, -0.08653516f, -0.05456800f, 0.01277527f, -0.01649838f, -0.05565343f, -0.00742603f, 
    -0.01501609f, 0.00641820f, 0.00524214f, 0.01484368f, 0.01205032f, -0.07209505f, -0.04992403f, -0.06214426f, 
    -0.06454120f, 0.02347532f, -0.05426873f, -0.03638104f, -0.04823895f, -0.05675498f, -0.03733158f, 0.01653275f, 
    0.05090934f, -0.01992719f, -0.05436630f, -0.06072582f, -0.05599506f, -0.04184125f, -0.05695276f, -0.05936674f, 
    0.00715966f, -0.05577467f, -0.07400734f, -0.03935801f, 0.01729567f, -0.00269877f, -0.05391414f, -0.02498524f, 
    -0.03321278f, -0.06517473f, 0.02131367f, -0.06435745f, -0.00761789f, 0.01545403f, -0.07384352f, 0.00780916f, 
    -0.03321596f, 0.01020835f, -0.08016957f, -0.06587427f, -0.03136996f, -0.01908971f, -0.00602299f, -0.07237343f, 
    0.02778119f, -0.00627075f, -0.04276150f, -0.06418692f, -0.02725009f, -0.00827842f, -0.03663642f, -0.06785059f, 
    -0.06821194f, 0.01731370f, 0.01853633f, -0.04900711f, -0.05576737f, -0.05875771f, -0.09158585f, 0.02640069f, 
    0.03327430f, -0.04009373f, 0.02196814f, -0.05427404f, 0.01603389f, -0.06138011f, 0.01984121f, -0.05542813f, 
    -0.08724258f, -0.01582516f, -0.03826778f, -0.00264489f, 0.00405496f, -0.02100364f, -0.06115225f, 0.02009126f, 
    -0.08117802f, -0.09100866f, -0.05905113f, -0.06276457f, -0.06885579f, -0.04639887f, -0.05195930f, -0.06906950f, 
    0.00603252f, -0.01134678f, -0.02241329f, -0.02198475f, -0.01671831f, -0.00521054f, -0.00438857f, -0.08550431f, 
    0.02658534f, -0.02084068f, -0.07524334f, -0.01944377f, 0.02242479f, 0.01386720f, -0.01299134f, 0.02871783f, 
    -0.07943971f, -0.05567209f, -0.06583292f, -0.01471288f, -0.01092087f, -0.07115217f, 0.02311829f, -0.07543848f, 
    0.00756710f, 0.00156801f, -0.05559735f, -0.06362884f, -0.01097345f, -0.05388958f, 0.01331017f, -0.06260781f, 
    -0.08576514f, -0.07479584f, -0.01887222f, -0.03520707f, -0.06300785f, -0.01847143f, -0.08031056f, -0.03461952f, 
    -0.37801686f, -0.37192479f, 0.19159877f, -0.32405877f, 0.03543928f, 0.08872781f, 0.11099112f, -0.01055027f, 
    0.18167861f, -0.20942897f, -0.19030252f, -0.03626171f, -0.04407582f, -0.09810664f, -0.11434714f, -0.20849186f, 
    -0.23365067f, -0.04950471f, -0.61086845f, -0.46250066f, -0.09054324f, -0.12346902f, 0.11564080f, -0.00927550f, 
    -0.02912330f, -0.00326733f, 0.04377240f, -0.21290334f, -0.45160422f, 0.23090127f, -0.14691451f, 0.11667234f, 
    -0.04107561f, 0.04399562f, 0.13546519f, -0.10270176f, -0.05860781f, -0.06258321f, 0.08220895f, -0.01494732f, 
    0.18146540f, 0.10222233f, 0.22017972f, -0.00246911f, 0.06699735f, 0.29343155f, 0.20798300f, 0.31454635f, 
    0.06050000f, 0.03818395f, 0.09944130f, 0.15728258f, 0.08027037f, 0.18027015f, 0.16046505f, -0.07414364f, 
    0.05467327f, -0.06225429f, -0.02778496f, 0.10932191f, 0.02185505f, -0.08652103f, 0.08604515f, 0.32870433f, 
    0.17875482f, 0.20227589f, -0.20322396f, 0.02100460f, 0.17638956f, 0.00230896f, 0.08348580f, -0.18879637f, 
    -0.36989161f, -0.01632671f, -0.12809865f, 0.00175622f, -0.26077375f, -0.01130489f, 0.17192091f, 0.13432397f, 
    0.07471269f, -0.12179291f, 0.20447615f, 0.15810151f, -0.39987612f, 0.26402819f, -0.19212289f, -0.02001203f, 
    0.08834603f, -0.00622933f, 0.18141982f, 0.19881584f, -0.02887120f, -0.07825157f, 0.04822671f, -0.13058573f, 
    0.06385761f, 0.00757785f, 0.19374856f, -0.27730784f, -0.19359893f, 0.22625951f, 0.08379909f, 0.03442653f, 
    0.02267316f, 0.30728352f, 0.23421197f, 0.03251783f, -1.21606684f, -0.97208762f, -0.24107060f, -0.06018590f, 
    -0.14747943f, -0.08539226f, 0.18165553f, 0.00955944f, 0.26713845f, -0.02084720f, 0.27467003f, 0.32776976f, 
    -0.19439435f, -0.04759929f, -0.05715397f, -0.10513853f, 0.20277162f, 0.15207478f, -0.06989527f, 0.17338502f, 
    -0.06833046f, -0.04903442f, -0.06854635f, -0.01775854f, 0.15270314f, 0.17772678f, 0.08617933f, -0.23847024f, 
    -0.19790767f, 0.09855091f, 0.15866418f, -0.10984203f, -0.04829240f, 0.07947934f, 0.01782263f, -0.12151720f, 
    -0.03290588f, -0.41426244f, -0.13574107f, -0.03725305f, -0.21371849f, -0.08371373f, 0.10224722f, 0.05802367f, 
    0.09318931f, 0.21084794f, 0.14028506f, -0.02658646f, 0.03501849f, 0.13328572f, 0.11092971f, 0.01356493f, 
    0.13281626f, -0.01896581f, -0.15501329f, -0.39419624f, -0.34108937f, -0.08491962f, -0.20983711f, 0.05829686f, 
    -0.07053323f, 0.03046794f, -0.03473785f, -0.02307373f, -0.54326010f, 0.26493785f, 0.14896609f, 0.03228839f, 
    -0.13327639f, 0.10121464f, 0.05269263f, -0.02036571f, 0.32571062f, 0.10524162f, 0.11169564f, -0.03481404f, 
    -0.01098340f, 0.05295852f, 0.01315759f, -0.09563021f, 0.02515880f, 0.20713191f, -0.33387762f, 0.12909511f, 
    -0.11214748f, -0.17253022f, -0.02048093f, 0.06259931f, 0.07348366f, 0.08222470f, 0.30203885f, -0.11268554f, 
    0.11787083f, -0.04392955f, 0.06493729f, 0.14739411f, 0.16080561f, -0.15844485f, 0.06653483f, 0.47733721f, 
    -0.28705117f, -0.37812591f, -0.01578601f, 0.01310516f, 0.09202792f, 0.05426859f, -0.06859139f, 0.09558402f, 
    0.15014614f, -0.44332391f, -0.34955305f, 0.07277524f, 0.05736223f, -0.15396985f, 0.04509310f, 0.06295435f, 
    0.05205090f, 0.03648387f, 0.03061927f, -0.30380970f, -0.22824566f, -0.08707825f, 0.05050740f, 0.00030655f, 
    0.02839002f, -0.05357916f, 0.34804437f, -0.16991705f, -0.17570336f, -0.22423139f, 0.00086784f, -0.08417568f, 
    0.10703078f, 0.12634093f, -0.09811798f, -0.90655839f, -0.41128209f, -0.53430659f, -0.09817743f, -0.05146365f, 
    0.15447482f, 0.25781450f, 0.01846789f, -0.22572173f, 0.71351337f, -0.11615869f, -0.39534697f, -0.16376111f, 
    -0.35845676f, -0.09187451f, -0.01498855f, 0.01146964f, 0.09143164f, -0.32728204f, -0.33034900f, -0.32904941f, 
    0.00840885f, 0.16879144f, -0.01358435f, 0.02344702f, 0.08467163f, 0.37188986f, 0.54317707f, -0.11686438f, 
    0.10458285f, 0.08176348f, -0.05676595f, 0.19444990f, 0.03510482f, 0.07681579f, -0.06291607f, -0.17070892f, 
    -0.28445578f, -0.05720084f, -0.14572096f, 0.11074157f, -0.10361023f, -0.01781353f, -0.13532719f, 0.08586235f, 
    -0.05570996f, -0.03613882f, -0.06489895f, 0.04887047f, 0.02302657f, 0.03807316f, -0.00640481f, -0.06283072f, 
    -0.00172295f, 0.00140226f, 0.00146321f, 0.03517438f, 0.02760527f, -0.06260692f, 0.01853684f, -0.05076966f, 
    -0.01669171f, 0.00811715f, 0.02787508f, -0.00715392f, -0.01182961f, 0.02304224f, -0.04684592f, 0.01948548f, 
    0.02559357f, -0.05017613f, -0.03517543f, 0.05297081f, 0.02109157f, -0.02292086f, 0.01532740f, -0.02075814f, 
    0.00134465f, 0.03426927f, 0.00745748f, 0.05052957f, 0.04990382f, 0.02081391f, 0.01946869f, -0.02382888f, 
    -0.03122776f, -0.00999735f, 0.00208771f, 0.03432173f, 0.04851282f, -0.03934423f, -0.00765976f, -0.02329052f, 
    0.03563156f, 0.02459525f, 0.03228434f, 0.03700776f, -0.04004351f, -0.04961568f, 0.01922454f, -0.01709845f, 
    0.00607596f, 0.03033996f, 0.00345687f, 0.05003066f, -0.02931501f, 0.00105250f, -0.02453543f, 0.00657739f, 
    0.05649643f, 0.01703914f, -0.03278052f, -0.02591102f, 0.03011121f, 0.03907384f, 0.01703193f, -0.06339084f, 
    -0.00694802f, -0.04122869f, 0.04304703f, 0.03984648f, -0.06098332f, -0.06062647f, 0.00889892f, -0.03489405f, 
    0.03523346f, -0.03312212f, -0.04052655f, 0.04484370f, 0.01446416f, 0.00267322f, -0.04407442f, -0.04742700f, 
    -0.02392469f, 0.03837611f, 0.00853320f, -0.02945520f, 0.05780361f, 0.00684300f, -0.05026531f, -0.06277020f, 
    0.01733865f, 0.04857027f, -0.01313145f, 0.00335804f, -0.01931689f, -0.06213989f, -0.03135172f, -0.00007013f, 
    -0.05106224f, -0.03170172f, -0.04435331f, -0.03691300f, -0.05460476f, -0.04821689f, 0.04535967f, -0.04640942f, 
    -0.03224940f, -0.03200486f, -0.00065957f, -0.00944589f, 0.04917179f, -0.00981252f, -0.02042002f, -0.06074565f, 
    -0.00386131f, 0.03341544f, 0.00948426f, 0.02246000f, -0.03671808f, -0.05226323f, 0.02203713f, 0.04260211f, 
    -0.04354604f, -0.02159430f, 0.01769985f, 0.00490097f, -0.02601415f, -0.03585236f, -0.03764082f, 0.01594174f, 
    -0.04468117f, -0.03314194f, 0.05559136f, -0.04701040f, 0.04654351f, -0.05085423f, 0.00754019f, -0.01478202f, 
    -0.01320695f, -0.04307576f, -0.06223237f, 0.01795100f, -0.02026162f, 0.02027915f, 0.03089598f, -0.02892791f, 
    -0.04504529f, 0.00762612f, -0.02657487f, -0.04175873f, 0.01316182f, -0.03416804f, 0.02181351f, -0.04460383f, 
    0.01731384f, -0.04447033f, -0.05071973f, 0.00133485f, 0.03306613f, -0.02286471f, -0.00338130f, 0.00010581f, 
    0.03686488f, -0.04151070f, 0.02310237f, 0.00153032f, 0.00032439f, -0.03851328f, -0.01102140f, -0.00482056f, 
    -0.01473624f, 0.03491069f, -0.04258558f, -0.00499786f, -0.05005139f, 0.03018988f, 0.00202112f, 0.05552848f, 
    -0.01238386f, 0.03416495f, -0.00710419f, -0.03258350f, 0.02482011f, -0.04486206f, -0.03450413f, 0.03626667f, 
    -0.00267050f, 0.02359889f, 0.01507435f, 0.02973707f, -0.02755430f, -0.00595289f, -0.04583234f, -0.05953790f, 
    -0.01907872f, -0.05372592f, 0.04727097f, 0.02767680f, 0.00918981f, 0.02083341f, 0.00491351f, -0.04028238f, 
    0.00162012f, -0.01716696f, 0.02332377f, -0.06844006f, -0.00643612f, 0.04407105f, -0.03530961f, -0.01848001f, 
    -0.04284990f, 0.04150299f, -0.06297215f, -0.01081861f, 0.04120973f, -0.00962589f, -0.03494358f, 0.00371126f, 
    0.00547515f, -0.00022657f, -0.00345081f, -0.00839476f, 0.01838699f, 0.00933304f, 0.03643430f, -0.03097581f, 
    -0.03307813f, 0.03937093f, -0.00783585f, -0.05610680f, -0.00558167f, 0.01922656f, -0.05703076f, -0.01787391f, 
    0.00775880f, 0.05499675f, -0.00965829f, 0.02253563f, -0.02851820f, 0.01458498f, -0.00922567f, -0.04116097f, 
    -0.05564324f, 0.02774486f, -0.01850053f, -0.06423927f, 0.02899550f, -0.01963181f, -0.02964490f, -0.02131651f, 
    -0.05040537f, -0.06280003f, -0.03379386f, 0.05742392f, -0.05425356f, -0.06821305f, -0.04781118f, 0.01102347f, 
    -0.00779863f, -0.04324779f, -0.02636235f, -0.03534961f, -0.03118937f, 0.01069894f, -0.00151950f, -0.01599444f, 
    0.02584599f, -0.05374259f, -0.03315239f, 0.02513153f, -0.01266310f, -0.02364030f, -0.02417361f, 0.02654205f, 
    -0.04439967f, -0.07336331f, -0.00444762f, -0.04109455f, -0.00374393f, -0.03249079f, -0.02518297f, -0.05305722f, 
    -0.14731631f, -0.13657996f, 0.03700383f, -0.03980341f, 0.06106582f, -0.14911486f, -0.02263789f, 0.06681199f, 
    0.07482281f, -0.26935852f, -0.14299718f, -0.13001448f, 0.01618116f, -0.22523117f, 0.14937481f, 0.21311657f, 
    0.01126597f, 0.00350578f, -0.36793795f, -0.46355951f, -0.11536319f, -0.02058163f, -0.09153222f, -0.06223182f, 
    0.00620402f, -0.09225158f, -0.08388694f, 0.23057854f, 0.08151627f, 0.10348429f, -0.22834100f, 0.07708427f, 
    -0.08049357f, 0.05730848f, 0.07578315f, 0.05263427f, -0.20931086f, -0.07509269f, -0.20857583f, -0.01554756f, 
    -0.03823172f, 0.09587290f, 0.22869849f, -0.05032883f, 0.01491398f, 0.31560040f, 0.13137791f, 0.18512233f, 
    0.13936085f, 0.01798862f, -0.12019582f, 0.16026916f, 0.16451581f, 0.08172841f, -0.80685395f, 0.25894341f, 
    0.25283387f, 0.04429999f, -0.05920464f, -0.02419981f, 0.01323631f, -0.00375195f, 0.08732589f, 0.14436090f, 
    0.02124727f, 0.43977571f, 0.05163857f, -0.16954508f, -0.05633397f, 0.14006214f, -0.03791308f, 0.16510645f, 
    0.16333102f, 0.13045870f, 0.16206369f, -0.11896449f, 0.17341074f, -0.13843441f, 0.17620078f, 0.08686663f, 
    0.02480470f, 0.20275030f, 0.18468972f, 0.70482600f, -0.23326449f, -0.06307688f, -0.00331257f, 0.04437808f, 
    0.09023712f, -0.16090286f, 0.26745933f, 0.04341345f, 0.27943668f, 0.08747210f, 0.02794038f, 0.14829889f, 
    0.11318397f, 0.02051643f, 0.14133011f, -0.01802721f, -0.33241677f, 0.16651227f, -0.00548332f, 0.03093656f, 
    -0.03355533f, -0.03606706f, -0.11566290f, -0.20712312f, -0.60121518f, -0.12035102f, 0.02372685f, -0.22318652f, 
    -0.12138261f, 0.18070720f, -0.08461250f, 0.03421631f, 0.15726939f, 0.34763059f, 0.23923567f, 0.08942989f, 
    0.01828966f, -0.08378551f, -0.02102703f, 0.06738582f, 0.05794391f, -0.07933550f, 0.13405336f, -0.14133622f, 
    -0.05011451f, -0.23542534f, 0.13765779f, -0.13307314f, 0.08168428f, 0.01911303f, -0.07275046f, -0.09688412f, 
    -0.12190460f, 0.05358061f, 0.03488187f, -0.00008178f, -0.11130880f, 0.18580696f, -0.05112964f, 0.06041606f, 
    -0.13269584f, -0.38169384f, -0.01845634f, 0.23226888f, -0.10774116f, -0.04596176f, 0.07020196f, 0.06147353f, 
    0.08656446f, -0.00760493f, 0.23628700f, 0.03433827f, -0.11121625f, -0.12403361f, -0.11001317f, 0.14642031f, 
    0.08135784f, 0.11603682f, -0.58390450f, -0.02170895f, -0.15518029f, 0.06702721f, -0.00927083f, 0.12726186f, 
    -0.10971525f, 0.00979623f, 0.08387784f, -0.07068182f, 0.11011574f, 0.31840226f, -0.25232387f, -0.10059901f, 
    -0.01535101f, -0.08972728f, 0.13646640f, -0.11161496f, 0.12640381f, 0.34111315f, 0.19025768f, -0.03692202f, 
    -0.07888361f, 0.14137542f, 0.03850753f, -0.08311949f, -0.07639151f, 0.04976488f, -0.24790414f, -0.19147451f, 
    -0.17326498f, 0.07889987f, 0.02230444f, 0.15805764f, -0.04655794f, 0.02345815f, -0.02763933f, -0.00905969f, 
    0.30165276f, -0.00548906f, -0.00790414f, -0.06448072f, 0.13769296f, 0.03142929f, -0.13966416f, 0.11503674f, 
    -0.14703673f, 0.51191616f, -0.16327038f, -0.11155341f, -0.27055001f, -0.02064272f, -0.02495361f, 0.00899091f, 
    -0.33219025f, -0.01303962f, 0.11848810f, 0.13683587f, -0.06005280f, -0.09795275f, 0.03344246f, 0.05567322f, 
    -0.00366997f, 0.06954379f, -0.03374909f, 0.06217929f, -0.19908667f, -0.11425237f, -0.01635602f, 0.00698342f, 
    -0.09721338f, 0.08930493f, 0.28198570f, 0.08657844f, 0.12453210f, -0.23802507f, -0.28352764f, -0.09605579f, 
    -0.00335929f, 0.14489235f, 0.00496027f, -0.17049976f, -0.19307193f, -0.16005972f, 0.06322596f, 0.06584695f, 
    0.14135332f, 0.02197756f, -0.17459700f, -0.13726671f, 0.21716651f, -0.05334947f, 0.11194883f, -0.04373530f, 
    -0.19137475f, 0.01272838f, -0.08964920f, -0.02605533f, 0.12421681f, -0.21195257f, -0.22852977f, 0.07580460f, 
    0.28163049f, 0.13934641f, 0.08088271f, 0.05026676f, 0.09899497f, 0.06575190f, -0.01516840f, -0.13908240f, 
    0.27729833f, -0.01897649f, 0.09504424f, -0.08879901f, -0.00858997f, 0.10771795f, 0.09052407f, -0.49582046f, 
    -0.12448600f, -0.24107294f, 0.08236101f, -0.04293765f, 0.11200544f, -0.04761747f, -0.11923851f, -0.15889762f, 
    0.20204897f, 0.06277700f, 0.02717532f, 0.07984465f, -0.03657638f, 0.13920990f, -0.11857620f, -0.14237234f, 
    0.09233506f, 0.18752164f, -0.13081789f, 0.07793247f, 0.18673646f, -0.06222859f, 0.07079796f, -0.02943359f, 
    0.03922011f, 0.00696336f, 0.01412693f, -0.20178473f, 0.02788678f, 0.01792063f, 0.01070507f, -0.04879828f, 
    0.16506247f, -0.00048145f, 0.02274929f, -0.00722616f, -0.18839967f, 0.44797993f, 0.06557025f, 0.03581291f, 
    -0.00100631f, 0.06865198f, 0.08006286f, 0.20114140f, 0.29094207f, 0.02308326f, 0.03828291f, 0.17413968f, 
    0.05559455f, 0.00010262f, 0.05177641f, 0.04613948f, 0.02268129f, -0.27393743f, -0.21066007f, -0.05069411f, 
    0.08148380f, -0.01822633f, 0.06388030f, 0.05746332f, 0.04653832f, 0.09719592f, 0.00160495f, -0.04559975f, 
    0.28100586f, 0.11007759f, -0.10682896f, 0.00931864f, 0.01258169f, -0.14807764f, 0.12147315f, -0.37056354f, 
    -0.00973386f, -0.31725597f, -0.03600982f, 0.10513734f, -0.09403688f, -0.02738534f, 0.08592424f, 0.04126481f, 
    -0.04595609f, -0.17428651f, 0.11593141f, -0.03014972f, 0.00637695f, 0.20732145f, 0.19421519f, 0.16462208f, 
    0.03894957f, 0.11106929f, -0.26056841f, -0.06778827f, 0.05504303f, 0.13406810f, 0.20804039f, 0.02766935f, 
    0.08456338f, 0.12015168f, -0.31341937f, -0.03337308f, -0.04260573f, -0.02930398f, 0.00560624f, 0.01103459f, 
    0.25124538f, 0.22513559f, 0.19560316f, 0.06631348f, 0.12563697f, 0.12706073f, 0.14711972f, 0.07882435f, 
    0.05835402f, -0.29989064f, -0.08042859f, -0.05806406f, 0.16240937f, -0.13416183f, -0.22256519f, 0.09257289f, 
    -0.00394335f, -0.15471350f, 0.23486365f, 0.05071312f, 0.02614333f, -0.09018172f, -0.03185434f, 0.07920597f, 
    -0.11199216f, -0.07896755f, -0.02567688f, 0.18226077f, 0.28332701f, 0.27403530f, -0.15077348f, 0.07599945f, 
    0.22691210f, 0.13937372f, 0.09949841f, -0.00828036f, -0.02694350f, -0.08963105f, -0.00390157f, 0.03257765f, 
    -0.01648053f, 0.10030127f, 0.02173516f, -0.01414149f, -0.01164644f, 0.09744883f, -0.10718476f, -0.03067782f, 
    0.00453794f, 0.07943134f, -0.06078884f, -0.15069593f, -0.05890289f, 0.00794215f, -0.19521880f, -0.20193213f, 
    -0.14618352f, 0.02058605f, -0.03377837f, 0.00198290f, -0.01000693f, 0.11949067f, 0.07254631f, -0.06090947f, 
    0.02629836f, 0.09655403f, 0.28885031f, 0.03820734f, 0.09164478f, -0.01720008f, 0.11266219f, 0.13950369f, 
    -0.05447601f, 0.18218213f, 0.06338684f, -0.02448944f, -0.04353208f, -0.08971222f, -0.03319061f, -0.05722339f, 
    -0.15181236f, 0.00565161f, -0.12680009f, 0.03260757f, -0.04004604f, -0.11526251f, -0.01680134f, 0.14723656f, 
    -0.01694677f, 0.08117933f, 0.08210991f, 0.10093711f, 0.11291317f, -0.12825200f, 0.05656346f, -0.05592297f, 
    0.07442985f, -0.06365231f, -0.30184492f, -0.22188002f, -0.45655769f, -0.26880619f, -0.13997838f, 0.03198954f, 
    0.04982989f, 0.00216179f, -0.01879174f, -0.12759069f, -0.13446292f, -0.12351714f, 0.04130263f, -0.28241768f, 
    -0.00828210f, -0.07079300f, -0.15823051f, 0.01659150f, -0.11180206f, 0.06969337f, 0.03356496f, 0.00016895f, 
    0.07839603f, 0.07907600f, 0.04871168f, 0.02603546f, 0.00386155f, -0.00184148f, 0.12245530f, 0.31057870f, 
    0.21342432f, -0.11179002f, -0.06054996f, -0.08630960f, 0.16698377f, 0.09379901f, -0.05320162f, -0.04056896f, 
    -0.02004563f, 0.14022622f, -0.21336246f, 0.08185721f, -0.05191493f, 0.07568134f, 0.14866805f, 0.05469872f, 
    -0.10293914f, -0.19751008f, -0.03144236f, -0.05220250f, -0.10456695f, -0.03312210f, 0.17033060f, 0.06153556f, 
    0.04544741f, 0.00398189f, -0.14023702f, -0.39298126f, -0.18941116f, -0.02380181f, -0.06358271f, 0.05599372f, 
    0.00571588f, -0.08112604f, -0.09490510f, -0.28417915f, -0.13188379f, 0.14844020f, 0.09652428f, 0.02916577f, 
    -0.19101231f, -0.11524705f, -0.08190948f, -0.26027432f, -0.11604749f, 0.06946394f, -0.14599662f, 0.00837576f, 
    0.02383397f, -0.06938077f, 0.09520742f, 0.01926118f, -0.02402936f, -0.10575920f, -0.01201172f, 0.11463093f, 
    0.01486447f, 0.09721633f, 0.05338394f, 0.05215446f, 0.09336346f, -0.04432728f, 0.33314341f, -0.07450754f, 
    0.03724389f, 0.19902962f, 0.04227053f, -0.10939937f, 0.01988506f, 0.02334897f, 0.08430921f, 0.05913679f, 
    0.06006896f, -0.02963257f, 0.20576890f, 0.19153355f, -0.03791153f, 0.16660073f, -0.29724869f, 0.02584354f, 
    -0.13820653f, -0.05119347f, -0.15425900f, -0.05604791f, 0.07926968f, -0.13335200f, 0.04809622f, -0.24564128f, 
    0.10799126f, 0.00867171f, -0.12426846f, 0.09199102f, 0.21471134f, 0.14108805f, -0.14912896f, 0.10737206f, 
    -0.03156888f, 0.12804914f, 0.18030308f, 0.11116174f, 0.04088322f, 0.13587008f, -0.14923915f, 0.12370956f, 
    -0.04138663f, -0.02517088f, 0.02303221f, -0.00255610f, 0.03343311f, 0.23467830f, 0.08727475f, -0.06573612f, 
    -0.06242222f, -0.11917060f, -0.00045639f, 0.12188441f, 0.06785781f, -0.03968847f, -0.37246826f, -0.14728682f, 
    0.15272702f, 0.03654368f, -0.06473709f, 0.23363456f, 0.00682781f, 0.00871425f, -0.00040709f, 0.84159911f, 
    -0.27405363f, -0.29961970f, -0.17144848f, -0.20350772f, -0.06008584f, 0.17967288f, 0.01697415f, -0.00215104f, 
    0.60235888f, 0.26450437f, -0.09177985f, -0.03262619f, 0.21867441f, -0.18016876f, 0.02532500f, 0.17050312f, 
    0.01196726f, -0.27125007f, 0.51255697f, 0.24127686f, 0.10233126f, -0.00738998f, 0.03054666f, 0.01086822f, 
    0.11187393f, 0.02449225f, -0.20090070f, -0.06346790f, 0.25695416f, -0.02798853f, 0.03206950f, 0.04018212f, 
    -0.04324527f, 0.00128333f, 0.12174302f, -0.39684263f, -0.00990295f, -0.24730900f, -0.07859057f, -0.13228852f, 
    -0.03517326f, -0.08073860f, 0.02428511f, -0.00503426f, 0.64472324f, 0.36545798f, -0.23904094f, 0.01501464f, 
    0.05887893f, 0.19400850f, 0.03744614f, 0.07408349f, -0.01666782f, 0.17027868f, 0.21769416f, 0.04288778f, 
    0.22518624f, 0.08455989f, -0.15766349f, 0.15810995f, 0.09182248f, 0.11760511f, 0.29776600f, -0.26908356f, 
    -0.26499876f, -0.11883969f, -0.02275804f, -0.01243020f, 0.13528351f, -0.01109286f, 0.00155118f, 0.09885205f, 
    -0.09482129f, 0.17907228f, -0.14951101f, 0.04572083f, -0.30857426f, -0.01141431f, 0.02666565f, -0.07719439f, 
    -0.00336968f, 0.01904026f, 0.10136944f, -0.02157501f, -0.07178067f, 0.04211473f, 0.08608712f, -0.11772308f, 
    -0.01024698f, -0.24140052f, 0.01697569f, 0.08116612f, 0.02515824f, -0.10030298f, -0.06372035f, -0.02336835f, 
    0.18677677f, 0.00757255f, -0.28933242f, 0.13238910f, 0.12366004f, 0.05912816f, 0.14034784f, 0.06732722f, 
    -0.02220829f, -0.06338663f, 0.07517964f, 0.08152957f, 0.02531388f, -0.05669789f, -0.11552638f, -0.39677781f, 
    -0.19625820f, 0.02173285f, 0.07928855f, 0.01870549f, -0.07543101f, 0.19813086f, 0.11978102f, -0.18983790f, 
    -0.05262749f, 0.13013196f, 0.06740159f, 0.04838876f, -0.14840959f, 0.07597923f, -0.11519163f, 0.08255024f, 
    -0.12822489f, -0.10151941f, -0.00676111f, 0.10040750f, -0.18682756f, -0.05874291f, 0.14110748f, -0.10434420f, 
    -0.28463724f, -0.05011923f, -0.07966932f, -0.01191242f, -0.06400365f, 0.03031825f, 0.02307045f, 0.07412165f, 
    -0.35399362f, -0.11367989f, -0.10887185f, 0.02533982f, -0.07706788f, -0.00197959f, -0.01564482f, 0.07879402f, 
    -0.26441932f, 0.14205025f, 0.23266888f, -0.06542398f, -0.05658445f, 0.12414233f, -0.05291117f, 0.26971450f, 
    -0.02565356f, 0.34216538f, 0.07583882f, 0.04232423f, -0.14773083f, -0.23788941f, -0.10836525f, 0.10053539f, 
    0.01215725f, 0.04195240f, -0.08542421f, 0.08289082f, 0.18135524f, -0.10831507f, -0.24225971f, -0.27157003f, 
    -0.14474766f, 0.00577082f, -0.03988951f, 0.05845219f, 0.00955636f, 0.10545581f, -0.11284343f, -0.02625878f, 
    -0.15998009f, -0.02690194f, -0.06763425f, -0.14956535f, 0.01497848f, 0.05799382f, 0.12367706f, 0.01289933f, 
    -0.20669277f, 0.00162868f, 0.06619391f, 0.01771677f, 0.00445717f, -0.03473157f, 0.04113333f, 0.19707051f, 
    -0.05034708f, -0.02640564f, -0.03288211f, 0.16790719f, -0.09160317f, 0.00634207f, 0.50715756f, -0.19148681f, 
    -0.15636201f, -0.08981212f, -0.22542351f, 0.09908716f, 0.12449550f, 0.07257788f, -0.05048044f, -0.32248193f, 
    0.00382068f, 0.21446671f, -0.02948489f, -0.05396879f, -0.06800895f, -0.04239661f, 0.04123763f, 0.05555089f, 
    -0.08968977f, 0.20652968f, -0.02604743f, -0.02909157f, -0.16449779f, -0.10492146f, -0.16388060f, 0.00446874f, 
    -0.03710908f, -0.07398310f, 0.20553038f, 0.51872748f, -0.20570017f, 0.19223456f, -0.11349726f, 0.13062140f, 
    0.27292445f, -0.03390370f, 0.07830416f, 0.08313288f, 0.42908123f, -0.19430919f, 0.06745204f, -0.31655952f, 
    0.10698761f, 0.17175929f, -0.06028636f, 0.03240955f, 0.13390125f, 0.22063625f, 0.02378782f, -0.06416050f, 
    0.02471080f, 0.03971414f, 0.21778184f, -0.03881198f, 0.09100336f, 0.27654126f, -0.24769013f, 0.10562988f, 
    0.07673471f, 0.06409958f, 0.09891073f, 0.12384529f, 0.15279524f, 0.00482019f, -0.08844941f, -0.33438796f, 
    -0.20339863f, -0.08615054f, -0.05735834f, 0.08812332f, 0.06411840f, -0.07562177f, -0.01271037f, 0.22377293f, 
    -0.06206448f, 0.00365841f, 0.09381180f, 0.31333289f, 0.10606959f, 0.03240918f, -0.00308307f, -0.23030743f, 
    0.10347494f, -0.24372275f, -0.25921944f, -0.12642848f, 0.10707103f, -0.17461145f, 0.09158926f, -0.02555181f, 
    -0.52120692f, 0.11633079f, 0.12756833f, 0.03683058f, -0.10235815f, 0.37925547f, 0.06914491f, 0.05798683f, 
    0.00338285f, 0.02190561f, -0.08281703f, 0.48287499f, -0.07827474f, -0.07710797f, -0.24471104f, 0.10663961f, 
    0.01388856f, 0.14670454f, -0.02114176f, -0.21189921f, 0.35023272f, 0.01241663f, 0.15950826f, 0.04270517f, 
    0.12466278f, 0.11997354f, 0.02908278f, -0.19538538f, -0.38617283f, 0.22233155f, 0.06275472f, 0.06802455f, 
    -0.00610399f, -0.01725402f, 0.00682339f, -0.25456157f, -0.63167888f, 0.05647156f, -0.36573479f, 0.04026295f, 
    -0.05105568f, 0.38257134f, 0.01199035f, 0.01124229f, -0.08972145f, -0.08245336f, -0.06735277f, 0.10524561f, 
    0.04044440f, 0.35830554f, -0.02436470f, 0.07839525f, 0.21885434f, 0.08390951f, 0.05333930f, -0.25007570f, 
    0.11744710f, -0.03348324f, 0.10139722f, -0.01841491f, -0.06760786f, 0.07020061f, -0.09937883f, 0.02462680f, 
    0.40274811f, 0.03960737f, -0.08142341f, -0.01324402f, -0.11018033f, 0.18410601f, 0.07843728f, 0.06562582f, 
    0.00596487f, 0.17805906f, 0.00818124f, -0.07032660f, -0.23602605f, -0.15501067f, -0.00952470f, -0.03308683f, 
    -0.05548877f, 0.05016487f, -0.08348896f, -0.12038741f, 0.08861017f, -0.08444326f, 0.09442009f, 0.20218237f, 
    0.10486226f, 0.23868804f, -0.10838416f, 0.11880872f, 0.37061578f, 0.10802383f, -0.17807928f, 0.12739247f, 
    0.11211549f, 0.09513754f, 0.10035373f, -0.23646557f, -0.38891548f, -0.09996241f, 0.15122570f, -0.12923141f, 
    -0.12636006f, -0.04454380f, 0.03300650f, 0.06243436f, -0.08250684f, -0.25959998f, 0.05001983f, -0.05710477f, 
    0.04874849f, 0.19764036f, -0.01845754f, 0.07044102f, -0.00514940f, -0.19850682f, -0.29656118f, 0.08787612f, 
    0.01764287f, 0.16978896f, -0.10720856f, -0.28369513f, -0.09939651f, 0.05978686f, -0.01372392f, -0.15441898f, 
    -0.56625587f, -0.18585165f, -0.03011447f, -0.05960517f, -0.11405332f, -0.04087553f, -0.08667453f, -0.32484400f, 
    -0.50712401f, -0.34741455f, 0.07645713f, 0.01567503f, -0.04838266f, 0.03687751f, -0.13629884f, -0.23457545f, 
    0.26343378f, 0.23103526f, 0.13262555f, 0.09516942f, -0.17013194f, 0.15327430f, 0.13855985f, 0.04873514f, 
    0.10798208f, -0.11829255f, -0.12122867f, -0.08756802f, 0.00258667f, -0.03876653f, 0.02551009f, 0.01288060f, 
    0.02803155f, -0.05713747f, -0.02994179f, -0.30471873f, 0.18959966f, -0.02417172f, -0.07784934f, 0.03276908f, 
    0.04882923f, 0.00932136f, 0.08900290f, -0.26705131f, 0.07639208f, 0.18709433f, -0.06277298f, 0.21437445f, 
    -0.20156547f, 0.03435636f, 0.07484377f, 0.06122649f, -0.01590944f, -0.25648680f, 0.05372884f, 0.04631126f, 
    -0.04100506f, -0.12621184f, 0.04188542f, -0.08561941f, 0.05273171f, 0.29157132f, 0.22430040f, 0.06090254f, 
    -0.17094468f, -0.13829885f, -0.05994629f, -0.11351979f, 0.15425423f, 0.07811065f, -0.16319196f, -0.44174701f, 
    -0.12583052f, 0.00236380f, 0.05462576f, -0.15084137f, 0.02363310f, 0.02348851f, 0.06012510f, 0.11771242f, 
    0.45285183f, 0.11170643f, -0.08438730f, -0.19975488f, -0.19702625f, 0.10794511f, 0.09831536f, -0.00689746f, 
    0.06517626f, -0.31371051f, 0.00765026f, 0.05618913f, -0.35457799f, -0.17349075f, 0.10459822f, 0.23707405f, 
    0.08756856f, 0.18299413f, -0.08915369f, 0.07091445f, 0.07113981f, -0.14507557f, 0.15441042f, 0.05778364f, 
    -0.25074536f, 0.11740655f, -0.34027821f, -0.06144965f, 0.02967416f, -0.15903442f, 0.08197324f, -0.13125475f, 
    0.15041320f, -0.03275247f, 0.06923889f, -0.48301464f, -0.17619799f, 0.36203995f, 0.12551147f, -0.17989300f, 
    0.11205953f, 0.11255088f, 0.01763861f, -0.08432852f, -0.17749304f, -0.15909371f, -0.10577221f, 0.11752408f, 
    0.08592863f, 0.09615658f, 0.00182868f, -0.01198008f, -0.06684452f, -0.03002122f, 0.00665611f, 0.18151593f, 
    -0.12546128f, -0.01938056f, -0.08594160f, 0.15075937f, 0.15609865f, 0.04532620f, 0.61938679f, 0.02324876f, 
    -0.14618470f, -0.02698722f, 0.14027531f, -0.03033146f, -0.03642169f, -0.18806063f, 0.15790458f, -0.06627795f, 
    -0.15465932f, 0.12354998f, -0.05566904f, 0.06435876f, 0.09457450f, 0.15467961f, 0.07310261f, -0.13285258f, 
    -0.44359955f, 0.00990791f, 0.13091028f, 0.10296823f, -0.08838880f, -0.04718922f, 0.05949140f, -0.01491570f, 
    0.14338215f, -0.00871456f, 0.03123961f, 0.43357340f, -0.31774488f, 0.06945791f, -0.04299127f, -0.09027404f, 
    0.11908685f, 0.23403871f, 0.20183404f, 0.03338365f, 0.28292701f, 0.01717864f, 0.05398617f, 0.03470341f, 
    0.05563282f, -0.06169747f, 0.11152974f, -0.17543320f, 0.35578763f, 0.00989520f, 0.15025948f, -0.06754620f, 
    0.24686767f, 0.04359384f, -0.06062155f, -0.14474626f, -0.64298326f, 0.38777989f, -0.47037062f, -0.10559338f, 
    -0.05940602f, 0.11141174f, 0.21422765f, -0.19065958f, -0.11242883f, 0.00496871f, -0.24828541f, 0.40667158f, 
    -0.04717741f, -0.12218303f, -0.05425230f, 0.03388990f, 0.06995352f, 0.17561360f, -0.45596781f, 0.03010450f, 
    0.01541432f, -0.10178824f, -0.05855627f, 0.05510318f, 0.21007195f, 0.01342854f, -0.05628423f, 0.08590692f, 
    -0.27133632f, 0.17900407f, -0.14752451f, 0.09971049f, 0.06458106f, 0.13060318f, -0.06243092f, -0.09975840f, 
    0.36562571f, -0.37303770f, 0.45319098f, 0.11427226f, 0.02617119f, -0.20003481f, 0.06191137f, -0.08697374f, 
    -0.10559785f, 0.18183568f, -0.07881695f, -0.34359008f, 0.05862670f, 0.03760557f, 0.21068217f, -0.09642916f, 
    0.08520836f, 0.10009099f, 0.64636463f, 0.08090128f, -0.75455648f, 0.04376063f, -0.02134901f, 0.14145556f, 
    0.10902241f, 0.18205836f, 0.14937536f, 0.02279891f, -0.22314651f, 0.06993424f, 0.00576962f, 0.09688459f, 
    -0.11503057f, -0.11416426f, 0.04778224f, 0.16019030f, 0.49769542f, 0.14490962f, 0.36332065f, 0.18377325f, 
    0.09354046f, 0.07628337f, 0.06826165f, -0.04661383f, 0.02091327f, -0.12907331f, -0.34199986f, -0.44517493f, 
    -0.05734549f, -0.14801872f, -0.15045144f, -0.05458977f, 0.01779775f, -0.19826180f, -0.05129234f, -0.12356557f, 
    -0.27892312f, -0.00026923f, 0.02586331f, -0.02008754f, -0.05926670f, -0.01962102f, -0.01948932f, -0.22041801f, 
    -0.57694745f, -0.53828228f, -0.02590458f, -0.13366060f, -0.04946744f, 0.02566427f, 0.13393275f, 0.01931648f, 
    0.21368033f, -0.18461128f, -0.26783755f, -0.13517952f, 0.09434469f, -0.10420977f, -0.01429982f, -0.04624990f, 
    0.36411154f, -0.06851938f, 0.23842481f, -0.36999243f, 0.02902451f, 0.14115095f, -0.19488843f, 0.22943935f, 
    -0.03195725f, 0.17806564f, 0.08854038f, -0.29189003f, -0.94890815f, -0.14849737f, 0.15088350f, -0.16496241f, 
    0.11153212f, 0.10407280f, 0.10299368f, -0.87614399f, -0.49366611f, -0.10930157f, 0.10888110f, -0.15457861f, 
    0.09270237f, -0.02206337f, 0.03682922f, -0.27568197f, 0.11318674f, -0.20106672f, -0.47534871f, -0.07400016f, 
    -0.22129069f, -0.13456729f, 0.21090665f, -0.05278511f, -0.16553150f, 0.02427280f, -0.14613260f, 0.06507013f, 
    0.07337160f, 0.32136819f, 0.05971589f, 0.09343127f, -0.20880838f, 0.00665293f, -0.05599739f, -0.17528053f, 
    0.08033495f, -0.08692623f, 0.07718276f, 0.12021844f, 0.11176822f, 0.06265312f, -0.02948289f, -0.03714888f, 
    -0.21310821f, -0.37103340f, -0.29803976f, -0.09499088f, 0.11874363f, -0.11118391f, 0.09322935f, 0.01189632f, 
    0.00924790f, 0.15199208f, -0.05476191f, 0.14089233f, 0.13370089f, 0.04966464f, -0.01211765f, -0.19465531f, 
    0.08362636f, 0.10359210f, 0.15052311f, -0.03883971f, -0.04089002f, 0.15865152f, -0.08466237f, 0.14184602f, 
    -0.00583087f, -0.12281980f, 0.16696118f, -0.07075372f, 0.09207609f, -0.07461016f, 0.14993799f, 0.14212576f, 
    0.03025006f, 0.12705018f, -0.19469522f, 0.20440622f, 0.09586944f, 0.02679837f, -0.10388397f, -0.00916308f, 
    0.05701855f, -0.00063329f, -0.00666997f, 0.06270888f, -0.05703150f, 0.08443579f, -0.11632489f, -0.04571019f, 
    0.12091778f, 0.01544774f, -0.15216833f, -0.22484297f, -0.03249487f, 0.21672797f, 0.26147792f, 0.14291373f, 
    0.18869244f, 0.14146286f, -0.07492420f, -0.17186013f, -0.05455751f, 0.01347934f, -0.29753008f, 0.37012464f, 
    0.23051347f, 0.08009046f, -0.05800589f, -0.32321414f, 0.11053104f, 0.16332282f, -0.03076820f, 0.19101448f, 
    -0.40786257f, 0.02973697f, 0.18488850f, 0.05245574f, 0.14368464f, 0.10540576f, -0.05705803f, -0.02721014f, 
    0.18347764f, 0.09834028f, -0.07063929f, 0.08842915f, -0.08519544f, -0.02167611f, -0.08135494f, -0.06984007f, 
    -0.09662338f, 0.11177301f, 0.25829202f, 0.06002530f, 0.21049374f, 0.23472144f, -0.15339109f, -0.05066822f, 
    -0.02021190f, -0.10389815f, -0.03642017f, 0.02162483f, -0.01815741f, -0.00274793f, -0.06244964f, -0.05704704f, 
    -0.19758566f, -0.09110953f, -0.26784164f, 0.32758823f, 0.04708261f, 0.09492888f, -0.18770139f, 0.08903607f, 
    0.18910761f, 0.00079314f, 0.20946620f, 0.32561603f, 0.34744596f, 0.23526353f, 0.13317795f, -0.16208334f, 
    0.14648670f, 0.16452594f, -0.11587328f, -0.03086389f, 0.25097719f, 0.02125704f, -0.01658380f, -0.09508067f, 
    0.10187563f, -0.08454885f, -0.15227532f, -0.10458198f, -0.21422608f, -0.22578238f, 0.17881230f, 0.06901901f, 
    -0.10830429f, 0.04310329f, -0.03395479f, 0.12652135f, 0.08396716f, -0.01490436f, 0.26865390f, 0.00495320f, 
    -0.25882998f, 0.04875132f, -0.06765211f, 0.08367818f, 0.09217189f, 0.05387483f, 0.13013661f, -0.17176308f, 
    -0.08048265f, 0.00184235f, -0.21759774f, 0.03350716f, 0.14397544f, -0.02310847f, 0.07483429f, -0.03580567f, 
    0.02778475f, -0.21433367f, -0.07813679f, -0.00496762f, 0.05571613f, 0.02980470f, -0.00452772f, -0.25861704f, 
    -0.24157701f, -0.43118814f, -0.06715661f, 0.16972530f, -0.11866543f, -0.14434461f, -0.06244524f, 0.02432233f, 
    0.17499331f, 0.06335828f, 0.04319462f, 0.19507170f, -0.16547103f, 0.17804983f, -0.13342226f, 0.17330644f, 
    0.11049726f, -0.03249064f, -0.02041286f, 0.15737325f, -0.03867342f, 0.36245877f, 0.26274484f, 0.09209945f, 
    0.13010934f, -0.08564075f, -0.13373551f, 0.02506574f, -0.02392313f, -0.01239955f, -0.03602191f, -0.26375109f, 
    0.00247194f, 0.12941195f, 0.10486208f, 0.10550303f, 0.18813232f, 0.17651124f, 0.06015273f, -0.00934223f, 
    0.02796846f, 0.04948315f, 0.15385446f, 0.09969194f, 0.03344995f, 0.24492009f, 0.21848246f, 0.13513005f, 
    -0.22302465f, 0.22254546f, -0.05689789f, -0.00454635f, 0.03523883f, 0.03455907f, 0.09774359f, 0.16150171f, 
    -0.05388371f, 0.14666355f, 0.09171133f, -0.11705171f, -0.00248468f, -0.01133924f, -0.16219769f, -0.01912313f, 
    -0.18846579f, 0.10898198f, 0.06727186f, 0.11742172f, 0.00827475f, 0.01321384f, 0.14203942f, 0.17534165f, 
    -0.24000680f, 0.04407080f, -0.09047292f, 0.05182132f, 0.07671337f, 0.03625721f, -0.02747007f, 0.19450352f, 
    -0.26606908f, -0.09785332f, -0.09362366f, 0.37457743f, -0.01087619f, -0.16140090f, 0.14561641f, -0.03983390f, 
    0.03981040f, -0.08703548f, 0.11615825f, -0.07193662f, -0.33344719f, 0.09277952f, 0.00800940f, 0.02139177f, 
    0.07657933f, 0.03458783f, -0.03811314f, -0.01390311f, 0.04684580f, 0.12906718f, 0.18624453f, 0.03253836f, 
    -0.05090770f, -0.00999939f, 0.07786608f, 0.15118562f, 0.02979068f, 0.07199251f, 0.17182444f, -0.02785112f, 
    0.05522818f, -0.12287696f, 0.11159857f, 0.14960402f, 0.09112989f, 0.00036245f, 0.07168189f, 0.25407544f, 
    0.09661605f, -0.08351540f, -0.19313163f, -0.11852980f, -0.00728498f, 0.03233435f, 0.10480398f, -0.00727770f, 
    -0.08448587f, -0.38247389f, -0.31727126f, -0.13318503f, 0.08028262f, -0.01205744f, 0.03597920f, 0.11670204f, 
    0.17581168f, 0.03371234f, 0.01051125f, 0.00235604f, -0.20717686f, 0.10853348f, 0.14109200f, 0.45598054f, 
    0.05241137f, 0.18847865f, -0.34725025f, -0.77139848f, -0.19608763f, -0.07308034f, -0.20206663f, 0.02920493f, 
    0.09460968f, 0.06230940f, 0.22102880f, 0.27112415f, 0.10996748f, 0.04748351f, 0.02169939f, -0.08738104f, 
    0.05042733f, 0.08872462f, 0.04658281f, 0.25932965f, 0.00378552f, -0.13162048f, 0.00158449f, 0.09925309f, 
    0.04819127f, -0.00330836f, 0.16489977f, 0.24711111f, 0.08397055f, 0.03526619f, 0.12169705f, 0.03298371f, 
    0.06454875f, 0.08707500f, 0.02135054f, -0.00013981f, 0.07479159f, -0.17575541f, -0.11387511f, 0.03745404f, 
    -0.07579776f, 0.06520252f, 0.03126357f, -0.01019841f, 0.08350638f, -0.11583862f, 0.22927363f, 0.08320120f, 
    -0.08625284f, -0.31110144f, 0.00321318f, -0.02773616f, 0.15146826f, -0.10615437f, 0.21324143f, -0.12809338f, 
    0.19159953f, -0.15937975f, 0.33508125f, -0.17892262f, -0.04906384f, 0.16696657f, 0.00097833f, 0.03366239f, 
    0.09619596f, 0.14276560f, -0.45367569f, -0.06707490f, 0.15735257f, -0.14863092f, 0.17092615f, 0.17075355f, 
    0.18940938f, 0.09075069f, 0.07473961f, -0.12085975f, -0.05237231f, 0.03470703f, 0.21674490f, 0.20855491f, 
    0.12969507f, 0.22556472f, 0.06916935f, 0.07420882f, -0.03993942f, 0.14684559f, 0.05015981f, -0.06513810f, 
    0.07223187f, 0.30115682f, -0.03931576f, 0.00199481f, 0.25766137f, -0.36609161f, -0.17220077f, -0.00333981f, 
    -0.11155981f, 0.26349953f, -0.01347992f, 0.00956880f, 0.15676773f, -0.02593883f, -0.09709881f, -0.34381434f, 
    -0.01566377f, 0.08418573f, 0.09154719f, 0.12048666f, 0.15064619f, -0.04823250f, 0.26900184f, 0.28931591f, 
    0.33490616f, 0.20628539f, 0.08793199f, 0.20218836f, 0.08072422f, 0.08129262f, 0.02390395f, 0.01001583f, 
    -0.22258711f, 0.04022006f, 0.10536608f, -0.09395628f, -0.05249115f, 0.18377087f, 0.34781384f, 0.35118395f, 
    -0.23472589f, -0.16557489f, -0.32638502f, -0.13050473f, -0.02884915f, -0.12129751f, -0.07334352f, -0.05906255f, 
    -0.00883154f, -0.38354567f, -0.37938577f, -0.10215171f, -0.11630244f, 0.11078674f, -0.07893361f, 0.13904952f, 
    0.16385409f, 0.08853616f, 0.03357435f, -0.18349104f, 0.26083201f, -0.17415348f, -0.04016913f, 0.04076197f, 
    0.09281198f, -0.00459409f, 0.18347852f, -0.13796973f, -0.03018101f, -0.18808867f, -0.17638712f, -0.08235684f, 
    0.06634502f, -0.02306869f, -0.04344339f, 0.09786335f, -0.11506283f, 0.02585994f, -0.08536284f, 0.01822530f, 
    -0.01362546f, 0.02998818f, 0.10280539f, 0.00454832f, 0.06857168f, -0.06919682f, 0.06597073f, 0.02977077f, 
    0.09940381f, -0.01483163f, -0.04736407f, 0.26961228f, -0.08387493f, 0.04233923f, 0.16194485f, 0.24421100f, 
    0.19742061f, 0.01044756f, 0.13179098f, 0.00782166f, 0.12798829f, -0.01388336f, 0.02642956f, -0.14461128f, 
    -0.14433423f, -0.18185891f, -0.14870758f, 0.08021380f, -0.01614421f, -0.04095171f, 0.05345792f, 0.09430407f, 
    -0.25185156f, -0.00703610f, 0.21256866f, -0.00109054f, 0.14460121f, 0.06179949f, 0.11384573f, 0.12778042f, 
    0.24785650f, -0.17180440f, -0.13806006f, -0.40437579f, -0.03511636f, 0.01369987f, 0.12774663f, -0.06943367f, 
    -0.07841135f, -0.01936206f, 0.07214788f, -0.12832920f, 0.01180313f, -0.21036972f, -0.06649190f, -0.24875180f, 
    -0.13152155f, -0.10292939f, 0.19838960f, 0.14141929f, -0.01847109f, 0.13888919f, -0.05113709f, 0.08623052f, 
    -0.17802089f, 0.01752845f, 0.01904045f, -0.11679277f, 0.05049755f, -0.00613059f, -0.21721897f, -0.12006534f, 
    -0.05155679f, -0.16187827f, 0.06084130f, -0.16449337f, -0.04220342f, -0.06354060f, -0.28554401f, -0.08316970f, 
    -0.30190548f, -0.09081399f, -0.22217335f, -0.02152422f, 0.20597301f, 0.16669534f, 0.30940738f, 0.38167924f, 
    -0.05169685f, 0.03208733f, -0.01430563f, -0.06711239f, 0.03130364f, 0.01990369f, 0.07349120f, -0.67548758f, 
    -0.60479134f, -0.13657340f, -0.12168323f, -0.11026318f, -0.20151225f, 0.04777158f, 0.06972563f, 0.10210784f, 
    -0.09415242f, -0.28556028f, -0.28344533f, 0.00351610f, -0.05626152f, -0.08643213f, -0.15477511f, 0.02782471f, 
    0.07842619f, 0.28661108f, -0.10430621f, -0.16795711f, 0.00642564f, 0.00238631f, 0.04300730f, -0.08040391f, 
    -0.13593476f, -0.02990655f, -0.03063736f, -0.22841668f, -0.35160792f, 0.05699501f, -0.01189590f, 0.17562822f, 
    0.10279005f, -0.08020117f, -0.21135426f, -0.23387192f, 0.12731765f, 0.41812900f, -0.05693172f, -0.04463384f, 
    0.18700820f, -0.06488768f, -0.04229693f, -0.03786630f, -0.03762985f, -0.23765008f, -0.03537708f, -0.05180567f, 
    -0.09456644f, -0.10586616f, -0.01161254f, 0.01213260f, 0.17584330f, 0.20305337f, -0.09426548f, 0.24793248f, 
    0.11712965f, -0.05092788f, 0.02392576f, 0.02873412f, 0.22712439f, -0.08835647f, 0.22693534f, 0.07669880f, 
    -0.06062802f, -0.07014472f, 0.40483102f, 0.14692450f, -0.06639904f, -0.40710387f, -0.04494395f, -0.01995075f, 
    0.18608953f, 0.09026091f, 0.30705494f, -0.04370809f, 0.04646324f, 0.10965985f, 0.15848094f, -0.03664419f, 
    0.23851858f, 0.21344779f, 0.39839306f, -0.16239074f, 0.27535060f, 0.02291491f, -0.05305329f, -0.02950527f, 
    0.25337887f, -0.21502799f, 0.42004240f, 0.13477199f, 0.10040940f, 0.05323041f, -0.02373197f, -0.07191049f, 
    0.01794585f, -0.27957463f, 0.13465016f, 0.29797271f, 0.00850591f, -0.08798689f, -0.03680955f, 0.19395992f, 
    0.02711189f, -0.01437994f, -0.08742236f, -0.14421754f, 0.26301974f, 0.14288823f, -0.02674383f, 0.09021252f, 
    0.02879518f, -0.02924095f, -0.04377938f, 0.04203066f, -0.28112969f, 0.13943654f, -0.11679646f, -0.17018048f, 
    -0.04297947f, 0.17541005f, -0.03136994f, 0.06499624f, 0.04546636f, 0.21120124f, 0.32560241f, 0.23845820f, 
    0.15263543f, 0.11441305f, 0.09753216f, -0.00114445f, 0.02635219f, 0.18853921f, 0.20068023f, 0.11084718f, 
    0.25946406f, 0.06089402f, 0.14542562f, 0.22722571f, -0.15577635f, -0.08352312f, -0.10368384f, 0.14069389f, 
    -0.05933541f, -0.04056652f, -0.04887921f, 0.07952582f, -0.16124704f, 0.04302830f, -0.11609720f, -0.06065739f, 
    0.03472508f, -0.06605050f, -0.15142024f, -0.09261094f, 0.02180116f, 0.00997823f, -0.03470375f, -0.21180464f, 
    -0.09932986f, -0.10593159f, 0.10559498f, -0.12079281f, 0.01585450f, 0.14814141f, 0.09343399f, -0.13745672f, 
    -0.00375150f, -0.04817728f, 0.00503045f, 0.34257007f, -0.26974303f, 0.11885575f, 0.22435452f, 0.02911904f, 
    -0.08946909f, -0.06476343f, 0.05181027f, -0.01563831f, -0.22963621f, 0.00746904f, -0.03528390f, 0.28125429f, 
    -0.23661400f, 0.06625149f, -0.00744633f, 0.12953097f, 0.11255115f, 0.42258167f, -0.00165963f, 0.20228788f, 
    0.06889272f, -0.12321636f, -0.02832333f, 0.00544661f, -0.49961680f, 0.19244671f, -0.05191790f, 0.07929983f, 
    0.04493361f, 0.20386766f, -0.15053177f, -0.07708897f, -0.10546310f, 0.09520198f, 0.24828121f, 0.13529769f, 
    0.14207250f, 0.13973293f, 0.20924410f, -0.20812774f, 0.03790545f, 0.05052343f, 0.03599827f, 0.00280909f, 
    0.06981409f, -0.45474511f, -0.02851588f, 0.03688929f, -0.03129277f, 0.05579825f, 0.04338845f, 0.13509148f, 
    -0.07257468f, -0.15462351f, -0.02131418f, -0.06790251f, 0.09604149f, 0.12556927f, 0.03143225f, -0.03102716f, 
    0.06319853f, -0.13780108f, -0.04128174f, -0.02836849f, 0.13155313f, 0.08722617f, -0.07739812f, -0.15783757f, 
    -0.07137284f, -0.02304817f, -0.04728771f, -0.07767336f, -0.28185201f, 0.04566850f, 0.15438181f, -0.05371791f, 
    -0.08304852f, -0.01253073f, -0.14804003f, -0.02189384f, -0.17148045f, -0.17701650f, 0.16049361f, -0.01424491f, 
    0.07113380f, -0.10581394f, -0.16648676f, -0.41814041f, 0.22000821f, -0.01258319f, -0.08488713f, 0.03291965f, 
    0.10258086f, -0.12426671f, -0.01964948f, -0.14152218f, 0.01693093f, -0.04375895f, -0.25747892f, -0.36091730f, 
    0.13855886f, 0.26040420f, -0.00054899f, -0.05661439f, -0.07354854f, 0.02992771f, 0.17077866f, -0.11119980f, 
    0.28799003f, 0.21595365f, 0.01141397f, -0.07943363f, 0.01417217f, -0.06886436f, 0.06427151f, -0.21065980f, 
    -0.30020833f, -0.27974784f, -0.03675476f, 0.10048907f, 0.16131575f, -0.01888338f, -0.22353789f, 0.02465061f, 
    0.20369351f, 0.00730242f, 0.03292608f, -0.04535919f, 0.03534295f, -0.14009173f, -0.01209094f, 0.11952486f, 
    -0.03735281f, -0.11580852f, 0.33610287f, -0.02859633f, 0.06093660f, 0.10762548f, 0.05899365f, 0.04893380f, 
    0.10198896f, 0.13897315f, 0.05931561f, 0.13675690f, -0.06498405f, -0.15201518f, -0.09988367f, -0.07641122f, 
    0.02622932f, 0.00061418f, 0.17277402f, -0.15402177f, -0.29012224f, 0.06674712f, -0.03759891f, 0.17006533f, 
    0.05614160f, -0.03438196f, 0.03158091f, 0.08953479f, 0.03739811f, 0.05967943f, -0.02579186f, 0.06982435f, 
    0.08263107f, 0.01727020f, 0.00476137f, 0.15261234f, -0.07683071f, -0.24706168f, -0.13834445f, 0.09340668f, 
    0.02733872f, -0.03146670f, 0.28554386f, 0.05144931f, -0.01640617f, 0.04545654f, 0.17229432f, 0.25506896f, 
    0.29269010f, -0.01194694f, 0.07332480f, 0.19449866f, 0.18338545f, -0.05237978f, 0.15282042f, -0.25909460f, 
    -0.05495726f, 0.04090738f, -0.02604926f, -0.07659390f, 0.21489877f, 0.08580840f, -0.04323141f, 0.07307956f, 
    -0.08612569f, -0.31246373f, 0.10506096f, -0.03008178f, 0.09792490f, 0.05095793f, -0.07509496f, 0.16541682f, 
    -0.03794800f, -0.42628294f, -0.23869213f, 0.25421369f, -0.03649135f, 0.01019417f, 0.04680853f, 0.07250530f, 
    -0.06382673f, -0.02689604f, -0.29439873f, 0.22231159f, 0.14520900f, -0.05999046f, -0.01250119f, 0.02795355f, 
    0.08299882f, 0.14252880f, 0.16851018f, -0.03942846f, -0.02237325f, 0.13533026f, -0.10126961f, 0.05588643f, 
    0.06907657f, 0.03435286f, -0.07128007f, 0.07716268f, 0.22166838f, -0.40833119f, 0.07131890f, -0.17490643f, 
    -0.02916845f, -0.29538569f, 0.03806290f, 0.11111778f, 0.22206417f, -0.17800874f, -0.18285885f, -0.13587835f, 
    0.00369813f, -0.03640173f, 0.05964712f, -0.07429987f, -0.09881085f, -0.04919316f, -0.17487848f, 0.04054322f, 
    0.05445171f, 0.19080254f, -0.05477524f, 0.21510115f, 0.09931468f, 0.10601891f, 0.11242682f, 0.27458999f, 
    0.09454519f, 0.21478839f, -0.00406468f, -0.04765806f, 0.03403636f, 0.28699708f, 0.16791677f, 0.12014087f, 
    0.08772326f, -0.10364710f, 0.15428637f, -0.08640524f, -0.11241043f, -0.18950440f, 0.07208727f, 0.01881310f, 
    -0.05480735f, 0.03224479f, -0.16754825f, -0.03321125f, 0.01394591f, 0.06085535f, -0.03960626f, 0.03565403f, 
    0.05513291f, 0.10013264f, 0.33004788f, -0.14148605f, 0.08676586f, -0.05018658f, 0.06611379f, -0.02595668f, 
    0.20114036f, 0.18829198f, -0.03823691f, 0.32296556f, 0.07621809f, -0.11163974f, -0.13615237f, 0.07677820f, 
    -0.08768826f, -0.10230790f, -0.23435958f, 0.16529448f, -0.24484719f, 0.02523862f, 0.26524130f, 0.01366625f, 
    0.05355554f, 0.11364625f, 0.06904385f, 0.00415664f, 0.02503570f, -0.02444603f, -0.15984572f, -0.04963196f, 
    -0.01961779f, -0.08433024f, 0.02151106f, 0.20828784f, -0.34288219f, 0.05981418f, -0.18435615f, -0.10027180f, 
    0.17605847f, -0.03946688f, -0.08824703f, 0.13462625f, 0.01014347f, -0.14371690f, 0.22515573f, -0.11632237f, 
    -0.42346457f, -0.02262384f, -0.32691598f, 0.02388557f, 0.00713289f, -0.00081017f, -0.12021231f, 0.05388025f, 
    0.19604276f, 0.10871169f, 0.05839971f, 0.04027556f, 0.05826443f, 0.01409801f, -0.02732088f, 0.09379798f, 
    0.11793906f, 0.31766230f, 0.12526423f, -0.28792632f, 0.03508855f, 0.05190894f, 0.05728450f, -0.11731075f, 
    -0.10968733f, -0.01719623f, 0.10807423f, 0.09123592f, -0.11962738f, -0.01086461f, 0.08066439f, 0.01545614f, 
    0.07491095f, -0.08639707f, 0.08825579f, -0.07971883f, -0.07211901f, 0.05001033f, -0.01828315f, -0.07733506f, 
    -0.09590626f, 0.05566219f, 0.17412062f, -0.08094148f, 0.09966902f, -0.21469526f, -0.11853477f, -0.01696982f, 
    0.12745829f, -0.06350291f, 0.13060932f, -0.03717364f, 0.03389047f, -0.03603151f, 0.00667409f, -0.00305999f, 
    -0.03195067f, -0.13994837f, -0.03386184f, 0.02120342f, 0.03242176f, -0.03430604f, -0.29363653f, -0.02423036f, 
    -0.07395586f, -0.03027148f, -0.06201900f, 0.38318178f, 0.06704194f, -0.13791841f, 0.12055205f, 0.11058109f, 
    -0.30620989f, 0.17328487f, -0.04868061f, -0.17779121f, -0.19536018f, 0.03053798f, 0.01138434f, 0.03498323f, 
    0.00125162f, 0.07149939f, -0.02112890f, -0.03585992f, 0.02703597f, -0.13567501f, 0.09056297f, 0.17914182f, 
    -0.03810211f, -0.10726324f, 0.13977425f, 0.26145953f, 0.07361571f, -0.15035000f, -0.21279663f, 0.12921429f, 
    0.17157581f, 0.06811016f, -0.07893413f, -0.08323478f, 0.24838528f, 0.11267573f, -0.11624387f, -0.23815425f, 
    0.09515202f, -0.04142826f, 0.13447145f, -0.61860293f, -0.12413328f, -0.04491040f, 0.10771158f, -0.01516113f, 
    -0.02951569f, 0.01537052f, 0.07422365f, 0.08621536f, 0.01801870f, 0.03157659f, -0.06221387f, 0.03478630f, 
    0.15277593f, -0.02484284f, 0.07171235f, -0.00740041f, -0.05037742f, 0.46275544f, -0.04114444f, -0.14920954f, 
    -0.07409751f, -0.04560516f, -0.05439596f, -0.06532055f, -0.05240509f, 0.26175541f, 0.85156316f, 0.09623060f, 
    -0.33030570f, 0.06897558f, 0.03451513f, 0.22316179f, 0.18207549f, 0.00004606f, -0.07504906f, -0.09160197f, 
    0.22598377f, 0.49415338f, -0.01207110f, -0.01791188f, -0.20100991f, 0.07859135f, 0.05999260f, -0.04242143f, 
    -0.40493706f, 0.20491266f, -0.28340310f, -0.16486372f, 0.11726412f, -0.08970929f, 0.11543439f, 0.00108400f, 
    0.07245613f, -0.34400782f, -0.17034514f, -0.14488375f, -0.26119897f, -0.19998789f, -0.38761255f, 0.05320463f, 
    0.06547371f, -0.02719296f, 0.28093722f, 0.27567226f, 0.25686365f, 0.16869593f, 0.10800431f, 0.01832975f, 
    0.04418861f, -0.01732657f, -0.01125370f, -0.30504233f, -0.01916321f, -0.44836184f, -0.08941488f, 0.01371463f, 
    0.02732413f, -0.27636376f, -0.00099089f, 0.02794463f, -0.20221268f, -0.01295241f, -0.44052675f, -0.00284397f, 
    -0.03431814f, 0.05996379f, 0.06971660f, -0.01678887f, -0.23239158f, -0.08336253f, 0.05907938f, -0.01248525f, 
    0.17134789f, 0.06923319f, -0.07997902f, -0.02308725f, -0.07145451f, -0.13836206f, -0.16598096f, -0.29498768f, 
    -0.38016075f, -0.03403054f, 0.05400529f, -0.07390154f, 0.01494023f, -0.17925808f, 0.17862861f, 0.11805286f, 
    -0.11867826f, 0.13381939f, -0.04645192f, 0.21776989f, -0.08791304f, 0.00532581f, 0.22673956f, 0.13626179f, 
    0.05481848f, -0.08605851f, 0.00750251f, -0.08099969f, 0.06480388f, -0.23410320f, 0.15049382f, 0.22041783f, 
    0.08533562f, 0.22071351f, 0.09029230f, -0.14974569f, 0.04560890f, -0.04677184f, 0.02541469f, 0.14965418f, 
    0.06938647f, -0.09292378f, 0.24737193f, -0.01419414f, -0.32505909f, 0.06896199f, 0.01707475f, 0.09472249f, 
    0.21963182f, 0.16953266f, -0.04314635f, 0.13977005f, 0.35247380f, 0.11625060f, -0.13419938f, -0.23638357f, 
    -0.08820403f, 0.01689642f, 0.08299130f, 0.14056692f, 0.10951556f, -0.71509135f, -0.31977630f, -0.05770936f, 
    0.05671693f, 0.07814237f, 0.15993178f, -0.04542296f, 0.07253174f, 0.22867125f, 0.19005647f, 0.00884864f, 
    -0.00193815f, -0.02619307f, -0.02327702f, -0.12097582f, -0.09609582f, 0.30452672f, 0.26514980f, -0.31211916f, 
    -0.46028778f, 0.14862782f, -0.09442252f, 0.23154397f, -0.16238956f, 0.03602150f, 0.14724940f, 0.04450681f, 
    0.01147784f, -0.37623549f, 0.15656020f, -0.30403286f, 0.05384320f, 0.01990972f, 0.03671765f, -0.00144278f, 
    0.40111011f, 0.06020756f, -0.12298747f, 0.09528595f, 0.07384542f, 0.11440773f, 0.03821736f, -0.03567111f, 
    -0.17288482f, 0.23825715f, 0.27678555f, 0.08353385f, -0.18255612f, -0.08308518f, -0.27431726f, 0.03046412f, 
    -0.06529023f, -0.15303662f, 0.16256553f, 0.12825821f, -0.00241794f, -0.09642608f, -0.28277111f, -0.18488321f, 
    -0.01996270f, 0.02383539f, -0.07821962f, -0.10414547f, 0.00874237f, 0.02190235f, -0.18091449f, -0.02172806f, 
    -0.17612778f, -0.02389264f, 0.08772056f, 0.08253730f, 0.15243629f, 0.10389098f, -0.00948064f, -0.18017501f, 
    -0.18827018f, 0.09603692f, -0.00532904f, 0.12326676f, 0.05062646f, 0.12970130f, -0.17500867f, -0.00861214f, 
    0.16554548f, 0.07514469f, -0.20715638f, 0.12034243f, 0.18345083f, 0.03775661f, -0.33050337f, 0.05515540f, 
    -0.15292756f, 0.01530292f, -0.01253677f, -0.16724247f, -0.08733635f, -0.02997655f, 0.05084293f, -0.22646636f, 
    -0.07396895f, -0.02734651f, 0.11090443f, 0.06962929f, -0.18210571f, 0.04519286f, -0.31203032f, 0.04494547f, 
    0.01298813f, -0.28913060f, -0.04149975f, 0.02943499f, -0.01890201f, 0.05994117f, -0.10556626f, 0.14607851f, 
    0.19626449f, -0.03420082f, -0.13394627f, -0.12113087f, -0.06863284f, 0.12088528f, -0.17266898f, 0.02401035f, 
    0.01176682f, -0.05728271f, -0.04691649f, 0.12765266f, -0.22150433f, -0.12832451f, 0.01173226f, 0.15363136f, 
    0.02291126f, 0.04242949f, 0.05741261f, 0.18257685f, -0.23262988f, 0.03891297f, 0.01557977f, 0.11402618f, 
    -0.17065519f, -0.21951184f, -0.11294530f, -0.16629085f, -0.04737984f, -0.05739796f, -0.25009367f, 0.12479954f, 
    0.12791800f, 0.04402630f, 0.18474828f, 0.05879500f, 0.07277767f, 0.17892554f, 0.17461465f, 0.33179450f, 
    0.08574556f, 0.08679923f, -0.06876276f, 0.12134451f, -0.08127359f, -0.03700946f, -0.15245877f, 0.28045005f, 
    -0.15011652f, -0.17058013f, -0.01599308f, 0.17052807f, 0.09833138f, 0.13388401f, 0.08020823f, 0.21617132f, 
    0.12263939f, 0.23073359f, -0.03375920f, 0.17440939f, 0.18376786f, 0.23097534f, 0.06370813f, 0.03653505f, 
    0.10845196f, -0.00873365f, -0.38247418f, 0.05072800f, -0.14224002f, -0.00941273f, -0.08894350f, -0.06381911f, 
    -0.17834172f, -0.05990322f, 0.04053003f, 0.21893787f, -0.19901480f, 0.01345456f, -0.19886531f, 0.04971278f, 
    -0.07614044f, -0.24678509f, 0.15053493f, 0.21064748f, 0.13724671f, -0.04782300f, 0.14691152f, 0.07606032f, 
    -0.06030859f, -0.13392930f, -0.08541884f, -0.08005881f, -0.13632603f, -0.06831191f, 0.11662170f, -0.04669999f, 
    -0.02822430f, 0.15991503f, -0.06221272f, -0.10456756f, -0.52339888f, -0.40601119f, -0.57598323f, -0.02957551f, 
    0.06289046f, 0.20018470f, 0.05359806f, 0.14491023f, 0.11042853f, 0.09062365f, 0.09715695f, 0.03308818f, 
    -0.10554390f, -0.23361887f, -0.04243653f, -0.47754005f, -0.21635421f, -0.18458065f, 0.20871335f, 0.10431215f, 
    0.27456114f, 0.18460919f, 0.16540632f, -0.06186211f, 0.02631803f, 0.08481351f, 0.03434847f, -0.10332181f, 
    0.20964736f, -0.09645784f, 0.19322717f, -0.04871076f, 0.13442419f, 0.06735483f, 0.22917061f, 0.17238966f, 
    0.03716274f, -0.21273895f, -0.34600994f, 0.08158290f, -0.11941349f, 0.02274159f, 0.03811969f, 0.05967734f, 
    0.08054294f, -0.03915914f, 0.02115010f, -0.07279668f, 0.05314693f, -0.03512590f, -0.03724941f, -0.06309076f, 
    -0.22515878f, -0.25003397f, -0.04178089f, -0.11170878f, -0.08627341f, 0.03018333f, -0.15924308f, -0.00124962f, 
    0.26131040f, 0.06333113f, -0.10492077f, -0.13387251f, 0.04575268f, 0.23689933f, 0.08170360f, -0.00548109f, 
    -0.02844959f, 0.04584495f, 0.13443184f, 0.11401831f, -0.02394884f, 0.21405318f, 0.12520103f, -0.09700599f, 
    0.08915333f, -0.18677966f, 0.09738097f, -0.10178555f, -0.02082670f, 0.00314435f, 0.11210139f, 0.09202598f, 
    -0.03339493f, -0.06099971f, -0.05672908f, -0.01502387f, 0.07262032f, 0.03993076f, 0.23579578f, 0.36159885f, 
    0.30339214f, 0.01503445f, 0.20776109f, -0.01302081f, 0.13698938f, 0.09483539f, -0.04951129f, 0.11743513f, 
    -0.19973503f, 0.46594435f, 0.00283945f, 0.16268851f, 0.21487665f, 0.04406171f, 0.04924856f, 0.09396376f, 
    -0.02398865f, -0.07340121f, -0.07325927f, -0.05395811f, 0.02701336f, -0.04763547f, -0.10116173f, -0.07376650f, 
    -0.04406174f, -0.12855653f, -0.34110427f, -0.32592523f, 0.03452507f, -0.02884232f, -0.04831055f, -0.02454869f, 
    0.04324515f, 0.21355431f, -0.03923461f, -0.34224635f, -0.43975320f, -0.02877086f, -0.24558318f, -0.09059399f, 
    0.16317113f, 0.07147530f, 0.13304217f, -0.28941169f, -0.00086994f, -0.21064833f, 0.06527691f, -0.06169038f, 
    0.03414059f, 0.20888600f, 0.18627338f, -0.00110141f, 0.31386119f, -0.15333682f, -0.27848595f, 0.03912271f, 
    -0.06640320f, -0.07338029f, -0.01847607f, -0.05117896f, 0.06000218f, 0.01294659f, -0.05405918f, -0.13040349f, 
    0.07804514f, 0.04436212f, 0.02297056f, 0.08941612f, -0.10297456f, 0.15009525f, 0.23302191f, -0.04444287f, 
    0.40201241f, 0.08241283f, -0.03720617f, -0.01461094f, 0.18190327f, 0.10265594f, 0.01052030f, -0.13688830f, 
    -0.07061449f, -0.13910462f, -0.13760057f, -0.02426595f, -0.18675824f, -0.01082595f, 0.02474803f, 0.09629180f, 
    0.02505713f, -0.05197547f, -0.18197861f, 0.03890985f, 0.11029337f, -0.09868321f, -0.04890088f, 0.19719706f, 
    -0.08030851f, -0.02138417f, -0.20568721f, 0.09483930f, -0.03478159f, -0.02317439f, 0.00228548f, 0.16995844f, 
    0.07052752f, 0.13885097f, -0.12475657f, -0.35120898f, 0.20994090f, 0.05386506f, 0.00632833f, 0.00523553f, 
    0.09334165f, 0.03831399f, 0.08537681f, 0.03938035f, -0.07940728f, 0.09200949f, -0.24457143f, 0.06704649f, 
    0.04073645f, 0.05489950f, 0.00320938f, -0.18600723f, -0.23023595f, 0.01684537f, -0.25504571f, 0.05911004f, 
    0.11940052f, 0.06447857f, -0.10418388f, -0.04351321f, -0.30420029f, -0.00941924f, 0.08027086f, 0.19510759f, 
    0.08877045f, -0.24811023f, -0.16657986f, -0.12248101f, 0.05816467f, 0.15679961f, -0.22354181f, 0.33408666f, 
    -0.11218368f, -0.03727137f, -0.08153512f, -0.03716414f, 0.01664564f, -0.00595469f, 0.05517826f, -0.04015530f, 
    0.12274768f, 0.51482213f, -0.00930454f, -0.02902685f, -0.14530921f, 0.08836985f, -0.27138916f, 0.14225113f, 
    0.28415057f, 0.06766257f, 0.08230685f, -0.18816209f, 0.15473476f, -0.05412957f, -0.13035251f, -0.25202951f, 
    -0.00407708f, 0.08178195f, 0.54104108f, 0.33425698f, -0.35055408f, 0.03637914f, -0.10842460f, 0.02466037f, 
    0.04569684f, 0.16229086f, 0.09668423f, 0.07971502f, 0.05701243f, 0.15626834f, -0.13778731f, -0.04364600f, 
    0.12856936f, -0.21655184f, 0.07439560f, 0.12192421f, 0.04996157f, 0.11890194f, -0.14540440f, 0.04329726f, 
    -0.02891229f, -0.01738262f, 0.00467665f, 0.14232378f, -0.02932472f, 0.01423869f, -0.29354250f, -0.11114817f, 
    0.11833055f, 0.01918134f, -0.22740465f, 0.12085206f, 0.02533879f, 0.06526941f, -0.11792197f, -0.01664258f, 
    0.11994175f, 0.09511835f, -0.32869747f, -0.01921048f, -0.54444253f, -0.08648477f, -0.11590422f, -0.24928124f, 
    0.19720952f, -0.22027914f, 0.09267262f, 0.00434549f, -0.02572333f, 0.00199438f, 0.11070140f, 0.08586739f, 
    -0.09017984f, 0.13635655f, -0.23873764f, 0.00018420f, 0.15271331f, 0.09552795f, -0.04352992f, 0.07419002f, 
    0.09283012f, -0.10640359f, -0.27577829f, 0.01734726f, 0.04245444f, 0.10192641f, 0.05948909f, 0.02897699f, 
    0.15649419f, -0.11408190f, 0.01295102f, 0.00735541f, 0.00481857f, -0.03763054f, 0.07709997f, -0.11449534f, 
    -0.05016671f, -0.30610523f, 0.06142461f, 0.16855037f, -0.38179612f, -0.09853925f, 0.18597835f, -0.00880771f, 
    0.18805811f, 0.17594765f, -0.00635142f, 0.14578438f, 0.49860126f, 0.10725232f, -0.04296065f, -0.05598703f, 
    0.00100287f, -0.09273969f, 0.05931681f, 0.13825653f, 0.14983545f, 0.32784674f, 0.22668684f, 0.05286622f, 
    -0.11381052f, 0.01169122f, 0.05068695f, 0.04103226f, 0.19571832f, -0.14270003f, -0.27225351f, 0.05274278f, 
    -0.07848988f, 0.18353182f, 0.07124971f, 0.01081845f, -0.00776142f, 0.02116918f, -0.11444449f, 0.14488471f, 
    0.24348587f, 0.18745902f, -0.07480816f, -0.04139802f, 0.04821298f, -0.00636534f, 0.02875564f, -0.04282687f, 
    0.45365733f, 0.40948468f, -0.17008358f, -0.09173205f, -0.14802489f, -0.11490737f, -0.05274580f, 0.20550089f, 
    0.01418829f, -0.07573435f, 0.07060035f, 0.21298905f, 0.03689150f, 0.00301093f, 0.00444496f, -0.15346611f, 
    -0.22986297f, 0.23366477f, 0.11136905f, 0.19462436f, -0.20201232f, -0.05623127f, -0.07973727f, 0.04683069f, 
    0.10044882f, 0.07564387f, 0.05074363f, 0.03639705f, 0.07147910f, -0.00844782f, -0.15076926f, -0.09108917f, 
    -0.07918024f, 0.07740387f, 0.19750839f, -0.26538393f, -0.31505179f, -0.00795583f, -0.12110846f, 0.10796385f, 
    -0.11583388f, 0.08620817f, 0.10956788f, 0.07104659f, 0.09254938f, -0.01670065f, -0.11245372f, -0.03555989f, 
    -0.02880205f, -0.07931754f, -0.04490256f, 0.01081564f, 0.35521480f, 0.10543972f, -0.05104680f, -0.07326394f, 
    0.06228526f, -0.03849220f, 0.12453873f, 0.07596996f, -0.03612012f, -0.01210008f, -0.35808355f, 0.10308711f, 
    0.28340974f, -0.09533866f, 0.10037535f, -0.10940789f, -0.08791197f, 0.02948895f, 0.07219294f, -0.08788843f, 
    -0.17374890f, -0.10882351f, -0.13442384f, -0.04074651f, -0.01219024f, 0.03065288f, -0.01703692f, 0.02531648f, 
    -0.27645358f, 0.03565525f, 0.02564039f, -0.01687840f, 0.04690596f, 0.02740560f, -0.06913283f, 0.06049635f, 
    -0.00904792f, -0.06052987f, -0.18895446f, -0.34212166f, 0.02724696f, -0.02430133f, -0.05074219f, 0.11069241f, 
    -0.07403933f, -0.01941826f, -0.11700456f, -0.36340293f, -0.25217405f, -0.02016995f, 0.03605815f, 0.04340760f, 
    0.07166062f, -0.05292683f, -0.14555562f, -0.21425273f, 0.00746931f, -0.20457783f, -0.09603817f, 0.02804064f, 
    0.05573240f, 0.08941635f, -0.07907711f, -0.17434339f, -0.19239514f, 0.03406061f, 0.03067737f, 0.11399305f, 
    -0.04385722f, 0.12485353f, 0.12486344f, -0.00045379f, -0.01801892f, -0.12342438f, -0.26843426f, -0.14591321f, 
    -0.13720796f, -0.31186306f, -0.08052749f, 0.03414268f, 0.10812256f, 0.23037362f, -0.06340242f, 0.21300462f, 
    0.02280062f, 0.20684820f, -0.31218210f, 0.08372167f, 0.15845796f, 0.01309921f, -0.31516704f, -0.50225514f, 
    -0.05617267f, 0.44634208f, 0.15759225f, -0.26122749f, -0.03165950f, -0.09441869f, -0.07202666f, 0.09240498f, 
    0.01007866f, -0.16508049f, -0.40170717f, -0.33250535f, -0.01622384f, -0.05828034f, -0.06742842f, -0.05656390f, 
    -0.26549390f, -0.49064571f, -0.37949118f, -0.20619191f, -0.25457880f, -0.33895230f, -0.17905614f, -0.02485499f, 
    0.11881121f, 0.06690960f, 0.36054239f, 0.09956444f, 0.03554495f, 0.04027531f, -0.01135537f, 0.04898290f, 
    -0.00284694f, 0.09456203f, -0.11626101f, -0.24102764f, -0.50018972f, -0.33934426f, -0.08881668f, -0.07997718f, 
    0.16177766f, 0.18545680f, 0.08973698f, 0.08074593f, -0.66368729f, 0.02424924f, -0.06602632f, 0.14856873f, 
    -0.01655638f, 0.15396629f, -0.02711528f, -0.28859779f, 0.09403136f, 0.18961926f, 0.00377723f, -0.05110358f, 
    0.08545309f, -0.14086550f, 0.03272766f, 0.00998517f, -0.04383842f, -0.13600555f, -0.38076741f, 0.05465483f, 
    -0.28697038f, -0.32474405f, 0.40511969f, -0.00034030f, 0.14460011f, 0.07464838f, 0.07548134f, 0.01124640f, 
    -0.25247788f, 0.06620973f, 0.06273365f, -0.03642042f, 0.15994510f, 0.02970659f, -0.03169094f, -0.03316271f, 
    -0.16837384f, -0.11017575f, -0.10813535f, 0.10060251f, -0.02345616f, 0.10995498f, 0.02612210f, 0.03863137f, 
    0.05131059f, 0.01548196f, 0.08129178f, 0.12340435f, 0.11739866f, 0.06968617f, 0.05921844f, 0.12157099f, 
    0.04136578f, -0.08241697f, -0.19373348f, -0.00699650f, -0.10544527f, -0.03937090f, 0.00208997f, -0.00540402f, 
    0.01722756f, 0.00863460f, -0.08951424f, -0.02782998f, 0.31723335f, 0.38180661f, -0.01272588f, -0.00660383f, 
    -0.13875943f, 0.20820643f, -0.07153710f, 0.05619628f, 0.01039193f, -0.28008458f, -0.66749197f, -0.16258353f, 
    -0.26656127f, -0.06986758f, 0.15381131f, 0.15881096f, 0.01917643f, 0.15426204f, 0.24562748f, 0.25972798f, 
    0.02429856f, 0.09908305f, -0.02359258f, 0.25577778f, 0.02162687f, 0.23595680f, 0.20290397f, 0.08039513f, 
    0.28319418f, 0.14677124f, 0.11393106f, -0.19374534f, 0.20680784f, -0.01257123f, 0.17819563f, 0.25233027f, 
    0.10291050f, 0.35447025f, 0.04792368f, -0.04765746f, -0.22182553f, 0.05193890f, -0.03066007f, 0.17491990f, 
    0.10004998f, -0.06491391f, 0.03565811f, 0.16802703f, 0.05649288f, 0.11485889f, 0.13931689f, 0.01006034f, 
    -0.16582929f, -0.18608345f, 0.25880870f, 0.23979475f, -0.07602819f, -0.00457985f, -0.02772149f, 0.18271032f, 
    0.07051664f, -0.20593035f, -0.04623618f, -0.01043336f, 0.21260153f, -0.05318927f, -0.08631088f, -0.05581426f, 
    0.06402247f, -0.02323739f, 0.02198560f, -0.18721901f, -0.06419636f, -0.06777437f, -0.10794590f, 0.01444690f, 
    0.14678550f, 0.01784891f, -0.08063644f, -0.01793516f, 0.15353592f, 0.01123504f, 0.09428512f, -0.04200826f, 
    -0.06920794f, 0.02916733f, -0.06303667f, 0.02917714f, 0.15836307f, -0.17600977f, -0.20372833f, -0.07122406f, 
    0.06236229f, 0.03673983f, -0.00943937f, 0.18726325f, 0.04112978f, 0.02033104f, -0.54478937f, -0.00335957f, 
    0.06219153f, -0.04234165f, 0.10039295f, -0.16944079f, 0.15108003f, -0.10396910f, 0.12663941f, 0.02886983f, 
    0.10162115f, -0.50548279f, 0.15180470f, 0.01614322f, 0.23283285f, 0.10561929f, -0.03607676f, -0.05113013f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.12919325f, -0.04598341f, 0.07298439f, -0.01388471f, 0.45488328f, 0.01470691f, 0.16065954f, 0.03884935f, 
    0.03677827f, 0.24142583f, 0.02717045f, -0.01446978f, -0.07380181f, -0.04235404f, 0.06548332f, 0.14982653f, 
    -0.07432774f, -0.04728216f, -0.05592741f, 0.07719425f, 0.14524390f, -0.06920537f, 0.05704824f, 0.15325601f, 
    -0.10015418f, 0.26437688f, -0.02924389f, 0.24039683f, 0.17868039f, 0.14744551f, 0.04552613f, 0.02486052f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18617800f, 0.36116010f, -0.28354925f, 0.16555136f, -0.00725788f, 0.02615735f, -0.06763851f, 0.09225545f, 
    0.04433681f, 0.18918306f, 0.16581635f, -0.16261573f, -0.06060905f, 0.06312427f, -0.05412540f, 0.13800146f, 
    -0.14339623f, 0.81177378f, 0.01100985f, -0.01111395f, 0.12817219f, -0.33333007f, 0.48007867f, 0.92526501f, 
    -0.21596688f, -0.08912095f, 0.04426297f, 0.01260020f, -0.07488745f, -0.13278374f, -0.03847689f, 0.08152521f, 
    0.14435180f, 0.24766779f, 0.04358553f, -0.04294232f, 0.61399776f, 0.04171871f, -0.23454791f, 0.27585894f, 
    -0.15829311f, -0.24294741f, 0.00711014f, 0.06411910f, 0.30367383f, -0.14499469f, 0.70443702f, 0.20392850f, 
    -0.09180404f, 0.27707234f, -0.15472178f, 0.09851206f, 0.13110669f, -0.12898889f, -0.36422464f, -0.34353969f, 
    -0.00536195f, 0.35351396f, 0.19410956f, -0.09221549f, -0.34466144f, 0.14503442f, 0.12737656f, 0.13502988f, 
    0.19370276f, 0.01852653f, -0.17074074f, 0.09343307f, -0.45507905f, 0.06783191f, 0.14910863f, -0.11763078f, 
    -0.10065037f, 0.20957528f, 0.06762336f, 0.13961814f, -0.07226852f, -0.11730239f, -0.22149482f, -0.14458703f, 
    -0.13247840f, -0.65785784f, -0.16417980f, -0.47800845f, 0.20566043f, -0.12014020f, 0.57276767f, 0.08111025f, 
    0.01779047f, 0.05422489f, -0.09907848f, -0.10465942f, 0.06310190f, 0.06966085f, -0.00015722f, -0.33758634f, 
    -0.03267411f, 0.32463631f, 0.17221570f, -0.03412282f, -0.08868254f, -0.29585263f, 0.03131797f, 0.16141717f, 
    -0.01255470f, -0.32903364f, -0.01016612f, -0.00802290f, 0.46224290f, -0.14010750f, 0.02880743f, 0.24817671f, 
    0.03903135f, -0.27636042f, 0.11841308f, 0.15854663f, 0.21813853f, 0.84942830f, 0.04162129f, 0.26003107f, 
    0.09778140f, 0.35944825f, 0.40832156f, -0.16045479f, -0.22337203f, -0.19909500f, 0.08062675f, -0.40908122f, 
    0.03028715f, -0.33787805f, -0.18987736f, 0.08853658f, 0.43318233f, 0.06433983f, -0.10741274f, -0.22351526f, 
    -0.16034758f, 0.13314551f, 0.11657958f, 0.07317084f, -0.02575766f, 0.10899460f, -0.01257865f, 0.16956532f, 
    0.10660896f, -0.19324745f, -0.03917104f, 0.10234617f, 0.18111205f, 0.02347500f, 0.09897207f, -0.08303655f, 
    -0.00928443f, -0.65289366f, -0.13741733f, -0.12807626f, 0.09891920f, -0.02422751f, -0.15767859f, 0.11322403f, 
    0.25298318f, 0.24620983f, -0.07708625f, -0.09559456f, 0.35581076f, -0.09020956f, 0.25132939f, 0.51027316f, 
    0.03370028f, -0.01352456f, 0.00580171f, 0.16880730f, -0.13702531f, 0.16792212f, -0.51135123f, 0.24453844f, 
    -0.04291483f, -0.06238391f, -0.14726320f, 0.12426835f, 0.05027953f, -0.26619619f, 0.03487541f, -0.27727357f, 
    0.04580897f, 0.10975996f, -0.18677840f, -0.12506801f, -0.19998023f, 0.13118988f, -0.32403412f, 0.05775085f, 
    -0.04762237f, -0.44378269f, -0.08386741f, 0.00226363f, -0.25651175f, 0.05166104f, 0.21691923f, -0.31331080f, 
    -0.07729760f, 0.24061790f, 0.14910097f, 0.04514424f, -0.14957020f, 0.04032495f, 0.20144144f, -0.16861258f, 
    -0.19365782f, 0.05526763f, -0.00755213f, 0.00910874f, -0.01222030f, -0.26356980f, 0.23195685f, 0.27883795f, 
    0.16123089f, -0.00858091f, 0.19413136f, 0.32154983f, 0.21260950f, 0.18806231f, 0.25049177f, -0.17123364f, 
    -0.12518142f, -0.01924998f, 0.12139538f, 0.15170029f, 0.11171293f, -0.31037334f, 0.36249143f, 0.01837094f, 
    0.18369247f, 0.06078840f, 0.10410663f, 0.13053043f, -0.23561195f, 0.11911154f, -0.28384662f, -0.39977375f, 
    -0.12901601f, -0.18962049f, -0.06293943f, 0.42687762f, -0.43365428f, -0.01211361f, -0.35803518f, -0.24360621f, 
    0.50877470f, -0.09266675f, -0.12554635f, 0.12307230f, 0.35211107f, 0.08679159f, 0.46646208f, 0.32172319f, 
    -0.00295817f, 0.09057397f, -0.36724749f, 0.16000581f, -0.18124469f, 0.26572895f, -0.13025869f, 0.20187454f, 
    0.06482917f, 0.18273763f, 0.14376381f, -0.17341028f, -0.07650634f, -0.04279865f, -0.23454055f, -0.00322629f, 
    0.11717430f, 0.16836470f, -0.04468628f, 0.07069809f, -0.07218124f, -0.16772026f, 0.48935270f, 0.37971506f, 
    -0.12369372f, 0.03068899f, -0.25043663f, 0.19038858f, -0.10673858f, 0.19399501f, -0.34847105f, -0.05661686f, 
    -0.21669212f, -0.12339492f, 0.31823069f, -0.12966105f, 0.06729116f, 0.13219009f, 0.18307191f, 0.05037843f, 
    0.01946796f, 0.06605461f, -0.02862868f, 0.02030109f, -0.07443821f, 0.14700866f, 0.08441402f, -0.23186424f, 
    0.14180897f, 0.22609234f, -0.01821426f, 0.17948711f, -0.30489859f, 0.03844770f, -0.21607924f, -0.00406800f, 
    0.25511602f, -0.08964651f, -0.06669624f, 0.02730884f, 0.38263789f, 0.04651365f, 0.30850556f, 0.19183232f, 
    0.16269718f, -0.46405521f, 0.20976783f, -0.16490965f, 0.26545990f, -0.05045227f, 0.02185059f, -0.24553838f, 
    0.07909464f, 0.01978497f, -0.12252396f, -0.16528352f, 0.35719636f, 0.11041139f, 0.14651681f, 0.26201022f, 
    0.07154380f, -0.06252819f, -0.05938144f, -0.07961470f, 0.35405374f, 0.57310665f, 0.02460343f, 0.37136611f, 
    -0.38087779f, 0.14400378f, 0.45994440f, 0.15728700f, -0.24590249f, -0.02221222f, -0.00876163f, -0.36314553f, 
    0.00077314f, 0.07855985f, 0.02834341f, 0.03910286f, 0.64413714f, -0.46381521f, 0.19385266f, 0.46165717f, 
    0.17580564f, -0.29640380f, -0.09026394f, -0.13932402f, -0.24890316f, 0.05557979f, -0.54776406f, -0.12010101f, 
    -0.03545301f, -0.20236917f, -0.06992939f, 0.19625165f, -0.22400288f, 0.33646682f, -0.34075728f, 0.26891705f, 
    0.24070819f, 0.06668424f, 0.08267118f, 0.13065366f, -0.34385315f, 0.34812573f, 0.22536248f, 0.23837289f, 
    0.34709069f, -0.13779585f, 0.00559748f, -0.12872437f, -0.37437564f, -0.19485368f, -0.10683257f, 0.38320360f, 
    0.05306736f, 0.22391249f, -0.12884939f, -0.07837827f, 0.35086030f, 0.03201292f, 0.00898686f, -0.04237516f, 
    -0.12438864f, -0.60634214f, -0.00111765f, 0.15054747f, 0.25471193f, 0.28128856f, 0.39344981f, -0.57769036f, 
    -0.00444638f, 0.41310310f, 0.00936412f, 0.25920206f, -0.35536358f, -0.03138022f, 0.04654490f, -0.37816173f, 
    -0.22765507f, 0.19831438f, -0.17154095f, -0.02663807f, 0.21832593f, 0.22965822f, -0.24412553f, 0.08931821f, 
    -0.01130161f, -0.00507265f, -0.04929446f, 0.16298102f, 0.02254473f, -0.11746912f, 0.52630126f, -0.02536309f, 
    -0.08190130f, 0.50994742f, -0.18424609f, 0.32432792f, -0.23047763f, 0.19285686f, 0.27412349f, -0.36259836f, 
    -0.13171051f, 0.02112428f, 0.08536666f, 0.25051337f, 0.23921645f, 0.26306677f, -0.07857725f, -0.00492399f, 
    -0.17143719f, 0.03557502f, -0.05705411f, -0.05111899f, 0.59294915f, 0.16418748f, -0.03602311f, 0.02669288f, 
    -0.13690828f, -0.00655640f, -0.08373733f, 0.05537978f, -0.22773862f, -0.08956520f, 0.21694025f, 0.02524260f, 
    -0.16445994f, 0.04901299f, -0.02116968f, -0.21165563f, -0.13084419f, -0.05209907f, -0.03303101f, 0.59554583f, 
    -0.24766235f, 0.18194516f, 0.00700152f, 0.15387064f, 0.17477903f, 0.40416950f, -0.24648468f, -0.11931305f, 
    0.05197092f, -0.09729869f, 0.20197220f, -0.07983559f, 0.87715334f, -0.06126771f, 0.20493715f, -0.30983883f, 
    0.09349143f, 0.09956437f, 0.01086366f, -0.07092767f, -0.11789797f, -0.10786267f, -0.16289930f, 0.24776652f, 
    -0.13213530f, 0.34732595f, -0.08526851f, -0.07759266f, 0.22389157f, -0.35086131f, -0.32092059f, 0.83634990f, 
    -0.12830251f, -0.27826452f, 0.16203886f, 0.04832873f, 0.40162274f, -0.05256888f, 0.32310018f, 0.03626290f, 
    -0.05146823f, 0.46753865f, 0.04809320f, -0.16257025f, -0.08674397f, -0.07045452f, 0.17916739f, 0.25014341f, 
    -0.05943799f, -0.22296304f, -0.03428329f, 0.08267032f, -0.16571650f, 0.12565525f, -0.55757242f, -0.26828760f, 
    -0.11205624f, 0.24436302f, 0.08781110f, 0.15376249f, -0.20579995f, -0.08477238f, -0.03083769f, 0.69355702f, 
    0.28873572f, -0.23166630f, -0.02379415f, 0.27513152f, 0.42793903f, 0.45654428f, 0.19863011f, 0.27542239f, 
    -0.20650561f, 0.41540670f, 0.11625427f, -0.10210456f, -0.15023232f, 0.34331161f, -0.20427887f, 0.01814357f, 
    0.04848002f, -0.06242082f, -0.15112014f, 0.15150352f, 0.00522117f, 0.00405069f, 0.47320434f, -0.08182435f, 
    0.07522409f, 0.70303464f, 0.04004567f, 0.23785926f, -0.09101721f, 0.37301353f, 0.02140807f, 0.03302760f, 
    -0.19273050f, -0.30224073f, 0.13798031f, 0.12588099f, 0.21420048f, 0.40876958f, 0.21715616f, -0.00185851f, 
    0.16686857f, -0.53491008f, 0.18668534f, 0.13160446f, -0.05981692f, 0.15667248f, 0.06779557f, 0.03775566f, 
    -0.10455623f, 0.05638140f, 0.16095252f, -0.11978579f, 0.11019155f, -0.02647041f, 0.17578256f, 0.13133012f, 
    -0.00302278f, -0.33656114f, 0.09263515f, -0.29591200f, -0.12589234f, -0.33649024f, -0.26137027f, -0.66508317f, 
    0.11580958f, 0.13746375f, -0.20598394f, -0.20281570f, -0.00698131f, -0.04483789f, -0.00993282f, 0.22029991f, 
    0.06428055f, 0.36627325f, -0.01055114f, -0.09723820f, -0.07230743f, -0.24368221f, -0.19020677f, 0.36536631f, 
    -0.12960874f, -0.23869762f, -0.11187324f, -0.10730981f, 0.19095877f, 0.01300696f, 0.21886189f, -0.34617490f, 
    -0.19281022f, -0.39225143f, 0.15466528f, 0.41286591f, -0.16076039f, 0.38342750f, -0.02887619f, 0.81756115f, 
    0.30063906f, 0.09610523f, 0.18845880f, 0.14525698f, -0.12908989f, 0.34153894f, 0.47515255f, -0.40999699f, 
    0.06948084f, -0.51992655f, 0.46414807f, -0.11942688f, -0.09517964f, -0.31077024f, 0.32473958f, -0.24900986f, 
    -0.08530802f, 0.42823857f, -0.03161656f, 0.05853435f, -0.28366017f, -0.01979785f, 0.28008792f, -0.37489349f, 
    -0.05237271f, -0.32831591f, 0.10993842f, 0.31600133f, 0.06489827f, -0.84147614f, 0.25697285f, -0.35492021f, 
    0.05231293f, 0.31107935f, -0.23019634f, 0.28165653f, -0.38334921f, 0.26838511f, 0.35667181f, -0.06943126f, 
    0.19967440f, 0.39181873f, -0.20098245f, -0.15322486f, 0.90663749f, -0.13975465f, 0.06687010f, 0.13607790f, 
    0.12712848f, -0.18479063f, -0.01767566f, -0.14837024f, -0.21985802f, -0.12079225f, -0.21503295f, 0.32851651f, 
    -0.07071930f, 0.35170254f, -0.09203809f, -0.38703215f, 0.20531525f, -0.39950463f, 0.10729280f, -0.31564111f, 
    0.01622166f, 0.30972281f, 0.29416749f, -0.09590343f, 0.21224840f, 0.27801281f, -0.61749196f, -0.11947828f, 
    0.06774203f, -0.05717843f, 0.20522112f, 0.09004392f, -0.06915589f, -0.02558459f, -0.17619154f, -0.07058969f, 
    -0.15896513f, -0.26443407f, 0.05529347f, -0.06189318f, -0.09489622f, -0.11439413f, 0.13766952f, 0.02625045f, 
    -0.10450376f, 0.32261172f, -0.03919761f, 0.32743520f, 0.08838931f, -0.11775289f, -0.21626553f, 0.86974436f, 
    -0.26758119f, 0.02810411f, 0.25122026f, -0.17191710f, -0.44085971f, 0.46022692f, 0.22574845f, 0.04482667f, 
    0.05667878f, 0.25670710f, -0.01416382f, -0.00150534f, -0.31841624f, 0.04607090f, 0.23229410f, -0.08006165f, 
    0.05724449f, 0.15104246f, -0.12830172f, 0.09613029f, -0.06491671f, 0.07325596f, 0.34611753f, -0.28328377f, 
    0.04382475f, -0.58498323f, 0.05314141f, -0.20175162f, -0.15538689f, 0.29044333f, 0.11241911f, -0.37892449f, 
    0.26732552f, 0.56015843f, -0.26725477f, 0.21292005f, 0.13521890f, -0.39744517f, 0.11779419f, -0.22566493f, 
    0.23555903f, -0.27601013f, 0.06288946f, -0.07404442f, 0.43259025f, -0.07297271f, 0.24012917f, -0.29333493f, 
    0.13999960f, -0.01575007f, 0.08296100f, -0.14338325f, 0.15367895f, 0.17010956f, -0.01073610f, 0.03598083f, 
    -0.04708107f, -0.02859450f, 0.06808074f, -0.13946608f, 0.03218589f, -0.13073225f, -0.13921906f, 0.47775191f, 
    -0.24075608f, -0.17685343f, 0.26556817f, 0.06885065f, 0.05091108f, 0.07291538f, 0.33563727f, 0.01035718f, 
    -0.09890514f, 0.26521808f, 0.23199502f, -0.10068286f, -0.64790034f, -0.01368786f, -0.08220267f, 0.18489343f, 
    0.01356925f, -0.27186182f, 0.08983108f, -0.16819471f, 0.00194214f, -0.09010814f, 0.35996580f, -0.22333765f, 
    -0.04032213f, 0.63122088f, -0.03195605f, 0.45503742f, -0.35452151f, 0.14405134f, -0.14901283f, -0.18496877f, 
    0.18863747f, 0.22880708f, 0.28522569f, -0.26720288f, 0.06799309f, 0.09371402f, -0.06646911f, 0.37130445f, 
    0.14781392f, 0.13074952f, -0.03210005f, 0.05656309f, 0.40941173f, -0.06813411f, 0.32614976f, -0.04457020f, 
    -0.16118790f, 0.09346106f, -0.13039061f, 0.09379213f, -0.03758188f, 0.03924565f, -0.42119807f, 0.11469284f, 
    -0.09653343f, -0.21935134f, 0.10676163f, 0.05776538f, -0.13704501f, -0.14373748f, -0.34339145f, 0.22380559f, 
    0.22252631f, 0.13040879f, -0.13969839f, -0.09603775f, 0.07638103f, -0.27924183f, 0.21445699f, 0.32345980f, 
    0.01177248f, 0.15654568f, -0.01246276f, 0.16624731f, -0.01075290f, -0.05354243f, -0.10517488f, -0.07023408f, 
    0.14555703f, -0.11635923f, 0.16831931f, -0.03535183f, -0.17516325f, 0.07616597f, 0.15944196f, 0.06739913f, 
    0.05529108f, -0.15708303f, -0.05329132f, -0.08462596f, -0.16471234f, -0.07964794f, -0.11344351f, 0.10898638f, 
    -0.04258992f, 0.11057706f, -0.04805333f, 0.11307692f, -0.03756816f, -0.09822749f, -0.04433130f, -0.02342903f, 
    -0.03696461f, 0.00339518f, 0.10961770f, -0.04748091f, 0.09496828f, -0.05089148f, -0.04521447f, 0.07319098f, 
    0.17128652f, -0.02870449f, -0.15400402f, -0.05846077f, 0.01698576f, -0.13568427f, -0.11785180f, 0.09642868f, 
    0.10612475f, -0.01503409f, 0.06019935f, -0.16822161f, -0.17337230f, -0.02414960f, -0.09754767f, -0.06841201f, 
    -0.10559364f, -0.12463509f, -0.16929500f, 0.10331837f, -0.09537368f, 0.03069449f, -0.00692421f, 0.02117259f, 
    -0.06869880f, -0.02296614f, -0.08724187f, 0.07445434f, -0.19031172f, -0.19880529f, -0.06508813f, -0.14137404f, 
    -0.13343525f, -0.05675894f, -0.16871804f, 0.15956756f, 0.10145830f, -0.01624243f, -0.18746257f, 0.11306671f, 
    -0.05969172f, 0.06215223f, -0.10742096f, 0.13067856f, -0.18782932f, 0.13782483f, 0.01187914f, 0.01369817f, 
    -0.18870680f, 0.09303997f, -0.15708740f, -0.08617972f, 0.10579276f, -0.11731780f, -0.06456607f, -0.15191492f, 
    0.03356163f, 0.07644385f, -0.18714069f, 0.00137888f, -0.05051647f, 0.13712494f, 0.02728592f, -0.19244015f, 
    0.09111002f, -0.18870179f, -0.01543538f, 0.15032989f, 0.00384273f, -0.03493107f, -0.08643757f, -0.04733240f, 
    0.01022638f, -0.05226575f, 0.01933462f, -0.04656937f, -0.19064943f, -0.15791617f, 0.05430509f, 0.07587136f, 
    -0.18366683f, -0.06917427f, -0.03528879f, -0.18436778f, -0.05109809f, 0.05974631f, 0.02295038f, 0.08224779f, 
    0.05430137f, -0.15412244f, 0.25673395f, 0.14521450f, 0.61134714f, -0.06798687f, 0.18264136f, -0.30004540f, 
    0.07962830f, 0.31218365f, -0.03170175f, 0.15557458f, -0.14592062f, 0.10091628f, 0.18760474f, 0.16639422f, 
    0.12232536f, -0.04460356f, -0.07751084f, -0.29861435f, -0.08370615f, -0.34169549f, -0.50136679f, -0.55820978f, 
    -0.10342741f, 0.37329125f, 0.02589337f, 0.05509819f, -0.19494671f, 0.12344358f, -0.15520196f, -0.14757288f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.33520085f, -0.06280152f, 0.08318301f, -0.02011568f, 0.34753776f, 0.35052419f, 0.19530155f, 0.02293342f, 
    0.17365456f, 0.02515937f, 0.05254067f, 0.08622537f, 0.27713391f, 0.16359292f, 0.22357267f, 0.06174392f, 
    0.07021111f, -0.22748244f, -0.17235093f, 0.15816712f, 0.47538981f, 0.32670349f, -0.04876588f, 0.05105602f, 
    0.14763197f, -0.16775005f, 0.06420992f, -0.13700524f, -0.00617758f, -0.08505705f, 0.06272046f, 0.28781775f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.21805663f, 0.04908312f, -0.02749592f, 0.14002728f, 0.09175206f, 0.05407980f, -0.50032336f, -0.07333992f, 
    -0.00705033f, 0.13212934f, -0.34538719f, 0.00435474f, -0.49583438f, 0.16902061f, -0.19813056f, -0.19459954f, 
    0.13922010f, 0.33251315f, 0.18226896f, 0.13222292f, -1.22300696f, 0.22162026f, -0.04547956f, -0.15203618f, 
    -0.30476907f, 0.33746850f, -0.05869595f, 0.02630631f, 0.02077157f, -0.13228829f, 0.02537951f, -0.24733101f, 
    0.21283805f, 0.23456690f, 0.17038639f, -0.25247556f, 0.07678696f, 0.02117261f, 0.11827893f, -1.35632956f, 
    0.20813015f, -0.11773705f, 0.05297384f, -0.45273134f, -0.08842128f, 0.39433873f, 0.31462628f, 0.03117869f, 
    -0.05735122f, 0.28096899f, -0.19719712f, -0.14768969f, -0.19256410f, 0.37426925f, 0.24081540f, -0.19142723f, 
    0.00163371f, 0.22103769f, -0.25720698f, 0.00530972f, -0.06546669f, 0.00162704f, 0.09687589f, 0.42654514f, 
    -0.36055309f, 0.18080468f, -0.45189932f, -0.22758736f, 0.09539998f, 0.10935608f, -0.29317036f, 0.07291431f, 
    0.12730542f, 0.04766878f, 0.14065029f, 0.45703325f, -0.06623924f, -0.27722478f, 0.16680203f, 0.10845553f, 
    -0.38674626f, -0.15377337f, 0.27326995f, 0.05754781f, 0.47232822f, -0.06203347f, -0.39886141f, -0.18090792f, 
    0.10031895f, -0.94655389f, 0.06127046f, 0.11152323f, 0.06426633f, -0.11524305f, 0.13374498f, 0.72298104f, 
    -0.52657157f, -0.01516893f, -0.25248992f, 0.31189370f, -0.21467718f, 0.22606796f, -0.21234651f, 0.25401506f, 
    0.14299515f, -0.09051473f, -0.30827951f, 0.19019766f, 0.28413630f, -0.24580242f, -0.42854291f, -0.89081508f, 
    0.19206950f, -0.24201888f, 0.28558481f, 0.22670573f, -0.03347542f, 0.04560298f, -0.07180554f, 0.07817828f, 
    -0.43986008f, 0.19699615f, 0.01481003f, -0.14416036f, 0.05342568f, 0.02689485f, -0.07902993f, -0.36860910f, 
    0.07874271f, -0.16908091f, -0.04573813f, -0.05727067f, -0.05496300f, -0.09442820f, 0.17657612f, 0.18330915f, 
    0.04825845f, 0.27059865f, -0.00211065f, -0.08729824f, -0.21394202f, -0.01896777f, -0.20579769f, 0.18346120f, 
    0.19691138f, 0.18137240f, -0.00847368f, 0.12636833f, 0.22717099f, -0.70284420f, 0.23569210f, -0.35970914f, 
    0.13490401f, 0.21789965f, -0.05462799f, 0.00623171f, 0.13369563f, -0.13431109f, 0.14404424f, -0.45713872f, 
    0.31680185f, -0.03307083f, -0.01721984f, 0.32166868f, 0.01546215f, 0.07964129f, -0.00529960f, -0.56464016f, 
    0.12092188f, -0.26963148f, 0.20546395f, 0.05299909f, -0.15812995f, -0.44885549f, 0.12849480f, 0.39502829f, 
    0.20091814f, -0.03374575f, -0.11281243f, 0.30637380f, -0.65863597f, 0.10805713f, 0.31183660f, -0.24814171f, 
    0.30782646f, -0.38387433f, 0.06970296f, -0.05888639f, -0.06191026f, 0.02137638f, 0.01343984f, -0.57235372f, 
    -0.02054110f, -0.50777876f, -0.02826569f, -0.68727666f, -0.19861983f, -0.20985352f, 0.24952294f, 0.46894625f, 
    -0.57828069f, 0.24511635f, -0.19218595f, -0.91807461f, -0.25191921f, -0.70782024f, -0.24789304f, 0.36246935f, 
    -0.05665893f, -0.31794989f, 0.20354795f, -1.04968750f, 0.58830923f, 0.12122378f, -0.50470507f, 0.11438680f, 
    0.22187173f, -0.37884155f, 0.20812316f, 0.05534159f, 0.07669424f, -0.07851146f, 0.06139066f, 0.53289753f, 
    -0.28578442f, -0.99777913f, -0.02148475f, 0.26099247f, -0.13266215f, -0.68745065f, 0.25670645f, 0.17897342f, 
    -0.28423929f, 0.14840277f, 0.25579673f, -0.12867640f, 0.13641091f, 0.19849308f, -0.15661214f, -0.07194579f, 
    0.18707196f, 0.34887990f, -0.21238953f, 0.31725684f, -0.16147594f, -0.68757790f, -0.61055654f, 0.24768411f, 
    -0.03258068f, -0.58541721f, -0.23811650f, -0.06660401f, -0.02157026f, 0.00759929f, 0.02061335f, -0.57372081f, 
    0.21540993f, 0.05659364f, 0.04534044f, 0.43404377f, 0.04480031f, 0.35462230f, -0.18798085f, -0.81916708f, 
    -0.00459036f, -0.59721786f, 0.42612666f, -0.09874573f, 0.33111522f, -0.25206259f, -0.78194076f, -0.13702123f, 
    -0.83009964f, -0.43905929f, -0.07405515f, -0.37752929f, -0.08113688f, 0.32829022f, -0.57895058f, 0.02480719f, 
    0.16597015f, -0.56072009f, 0.04729666f, -0.11965195f, -0.13196105f, 0.08888077f, -0.03511774f, -0.00800578f, 
    0.20870537f, -0.09193688f, -0.78802806f, -0.68380159f, -0.05794216f, 0.21347602f, 0.00342246f, 0.49948296f, 
    0.13605094f, 0.32275492f, -0.46469006f, 0.39168832f, -0.32799593f, 0.23279876f, 0.00590457f, 0.17405370f, 
    0.48927385f, -0.10082565f, -0.14659896f, -0.15260060f, -0.17540598f, 0.08125407f, -0.45632058f, 0.06161088f, 
    -0.06022877f, -0.42125177f, 0.31452268f, -0.08934504f, -0.00125720f, 0.12024013f, -0.17854445f, -0.40874520f, 
    0.16234851f, 0.40898031f, -0.65467823f, 0.32305011f, -0.47787619f, -0.38040358f, -0.09899261f, -0.62192875f, 
    -0.43748909f, -0.22183895f, 0.23533437f, -0.93796986f, 0.29885817f, 0.32264638f, -0.28804392f, -0.36518344f, 
    -0.69172722f, 0.20492963f, -0.28134307f, 0.25648704f, -0.16274078f, -0.39972019f, -0.28849781f, 0.16104820f, 
    0.03837742f, -0.13444209f, -0.22216780f, 0.08150901f, -0.15912004f, -0.13340060f, 0.10054359f, 0.09769764f, 
    0.36489692f, -0.22265179f, 0.37187326f, -0.74237990f, -0.47751009f, 0.25513107f, 0.24608614f, -0.32957116f, 
    0.36214012f, -0.34543747f, -0.23966442f, -0.39980194f, 0.43435001f, -0.21175896f, -0.12789345f, -0.56794447f, 
    -0.00763099f, -0.36043692f, -0.06287728f, 0.06207680f, 0.86157167f, -0.31060466f, -0.37682706f, 0.17606291f, 
    -0.17104411f, -0.51910073f, -0.10723803f, -0.16362353f, 0.01239827f, -0.03509111f, -0.10358298f, -0.27146801f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.31030780f, 0.31936473f, 0.01511053f, -0.09745064f, -0.06154824f, -0.15867800f, 0.19037768f, -0.25595632f, 
    0.31769836f, 0.17063853f, 0.02263974f, -0.08942724f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
