#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.46659130f, 0.46471503f, 0.30636871f, 0.43162581f, 0.14568594f, 0.32696438f, -0.15713573f, -0.47065285f, 
    -0.18042721f, -0.55032313f, 0.22294879f, -0.16200806f, -0.05943693f, 0.56137496f, -0.45063242f, 0.32178107f, 
    -0.39130220f, -0.38648567f, 0.08720393f, -0.01741549f, 0.06910559f, -0.28215605f, 0.23500323f, -0.33350596f, 
    0.24736437f, 0.78099293f, 0.96354902f, 0.22630265f, -0.22739176f, -0.19203396f, 0.11725134f, -0.87808686f, 
    -0.35045567f, -0.51139706f, -0.20598221f, 0.01809099f, 0.01346587f, -0.03867749f, 0.02972452f, -0.12202150f, 
    0.18538071f, -0.05156599f, -0.23877084f, -0.03770351f, -0.22701207f, 0.12112775f, 0.18901397f, 0.44349793f, 
    -0.33073658f, 0.28020349f, 1.01206672f, 0.09963726f, -0.66753852f, 0.61583948f, 0.79164743f, 0.59398961f, 
    0.06762587f, -0.66563457f, -0.24226108f, -0.01593191f, -0.06932549f, 0.38810462f, -0.13107139f, 0.13480610f, 
    -0.05653135f, 0.12938209f, -0.06581365f, 0.26607427f, 0.03858266f, -0.16720432f, -0.03046848f, -0.04253975f, 
    -0.07727106f, 0.17083192f, 0.44893634f, -0.53121167f, -0.70786011f, -0.54507267f, -0.54750264f, -0.14137568f, 
    -0.62083089f, -0.37785664f, -0.01765595f, -0.10648189f, -0.10343725f, -0.34155780f, 0.04595114f, 0.08822540f, 
    0.01930836f, -0.17257956f, 0.13902232f, 0.04002561f, -0.02434858f, 0.39943659f, 0.32371503f, 0.05947562f, 
    -0.04371770f, 0.03124972f, 0.02419280f, 0.07135326f, -0.97854537f, 0.28865418f, 0.64347976f, -0.73950320f, 
    -0.08941936f, 0.50138825f, 0.29230410f, 0.01363385f, 0.29567769f, 0.43060449f, 0.64378047f, -0.03066282f, 
    -0.43259001f, -0.23846039f, -0.12228593f, 0.34845018f, 0.11420859f, -0.02994035f, -0.10368360f, 0.23195218f, 
    0.02473655f, 0.00038730f, -0.07122348f, -0.10861205f, 0.29715610f, -0.88939953f, -0.98550957f, -0.53694093f, 
    0.89839482f, 0.57958806f, -0.25836372f, 0.50207567f, 0.53117281f, -0.05336284f, -0.19687667f, 0.12049311f, 
    0.08576901f, -0.10282347f, 0.02340334f, -0.09597313f, -0.23570205f, 0.15553342f, 0.21464090f, -0.22518171f, 
    -0.02835664f, -0.20119746f, 0.31795540f, -0.18917952f, 0.11594865f, -0.34861398f, 0.71682912f, 0.57737911f, 
    0.85243994f, 0.67489648f, 0.52606046f, -0.40791222f, 0.30423862f, -0.14688767f, -0.18018603f, -0.13067022f, 
    0.16286036f, 0.04978557f, 0.19709951f, 0.27132693f, 0.03186039f, 0.38138872f, -0.05699641f, 0.01101985f, 
    0.35802180f, 0.37031353f, -0.23244648f, -0.10412693f, 0.11815378f, 0.16849539f, -0.28638703f, -0.48569214f, 
    0.37474138f, -0.32630381f, -0.53876120f, -0.89888293f, 0.78017038f, 0.81288159f, -0.46889210f, 0.37660372f, 
    -0.00599682f, 0.07497111f, -0.28023443f, -0.12569083f, 0.13766721f, -0.09110579f, -0.02705060f, 0.03547793f, 
    0.21249530f, 0.09374615f, 0.11815614f, 0.22141095f, -0.43676504f, -0.01888036f, 0.09275682f, -0.15068696f, 
    -0.94630378f, -0.40195084f, 0.05079059f, 0.49902645f, -0.22697799f, -0.71145576f, 0.49452868f, 0.12590872f, 
    -0.40158013f, -0.72545046f, -0.12609084f, 0.27882782f, 0.13870177f, 0.48454598f, 0.61141151f, -0.40143374f, 
    0.11527041f, -0.06381113f, -0.24553959f, -0.20375928f, 0.20188536f, -0.01931963f, -0.14775875f, -0.05705003f, 
    -0.07054140f, -0.52969378f, 0.62238014f, 0.95884717f, 0.45859990f, 0.50614303f, 0.82719690f, 0.39534962f, 
    0.06614274f, 0.38788143f, 0.00389323f, -0.72290957f, -0.06551804f, 0.04004129f, 0.24452017f, -0.18657562f, 
    -0.26588655f, -0.19520958f, -0.19285136f, 0.14609478f, -0.04847208f, 0.03187917f, -0.42776325f, -0.04348989f, 
    0.32337180f, 0.01884562f, 0.90832216f, -0.24839328f, -0.86502808f, -0.86507004f, -0.40317011f, -0.44872180f, 
    -0.24087669f, 0.38998297f, 0.40897757f, -0.04940891f, -0.17956635f, -0.00245135f, 0.05920967f, -0.00301468f, 
    -0.08042296f, 0.30373546f, -0.32552302f, 0.12588492f, 0.24405120f, 0.42194647f, -0.01960038f, 0.23086165f, 
    0.15000144f, -0.21076976f, -0.18078037f, -0.17363614f, 0.73383033f, 0.78218752f, 1.01419055f, -0.59716916f, 
    0.11492379f, 0.22377054f, -0.03736359f, -0.05845656f, -0.04974427f, 0.02151703f, -0.26276875f, -0.15635172f, 
    0.23832147f, -0.21011876f, -0.08529439f, 0.05184684f, 0.16746846f, -0.16147013f, -0.29678214f, -0.07314575f, 
    -0.12372283f, -0.38445154f, -0.10218870f, -0.23754369f, -0.70211983f, 1.06939769f, -0.26626748f, -0.66893768f, 
    0.39973554f, -0.62014937f, 0.19664055f, 0.54005617f, -0.10255326f, -0.55666590f, -0.24282199f, -0.04794741f, 
    0.05809059f, -0.24850535f, -0.30307579f, 0.34131193f, 0.21583970f, -0.08742787f, -0.34332371f, -0.57561678f, 
    -0.07851059f, -0.01395562f, 0.14594392f, -0.06617645f, 0.26792046f, -0.47477281f, -0.02398521f, 0.68960625f, 
    0.42646468f, 0.06587159f, -1.18081141f, -0.70034963f, -0.17319334f, -0.08914305f, -0.24189739f, 0.48969141f, 
    0.12868202f, -0.11568963f, 0.15088379f, 0.02254202f, 0.01072461f, -0.24428254f, 0.45412791f, -0.01413982f, 
    0.06348626f, 0.45004058f, 0.26230350f, 0.13768110f, -0.24412453f, -0.01531096f, -1.03763580f, 0.76696736f, 
    -0.00922832f, -0.38492301f, -0.64189965f, 0.55208701f, 0.62881798f, 0.13528112f, 0.41449457f, 0.76513451f, 
    -0.46654618f, -0.10574523f, 0.05537061f, -0.05266637f, -0.21313597f, -0.11534582f, 0.13050880f, -0.10298172f, 
    0.26682797f, -0.22390716f, -0.16722623f, 0.12333263f, -0.08708657f, -0.08154448f, -0.13671441f, 0.71407288f, 
    1.00114453f, 0.62391788f, 0.66621554f, 0.50204712f, -0.34527579f, 0.30790743f, -0.79729265f, -0.44503632f, 
    -0.03016692f, 0.22589111f, 0.33313560f, -0.11667894f, 0.02850886f, -0.03147367f, -0.06755979f, 0.28528199f, 
    0.47998202f, -0.24596709f, -0.17766714f, 0.01120399f, 0.47785854f, 0.27021989f, 0.24086487f, 0.45816138f, 
    -0.57432795f, 0.06217840f, -0.29700866f, -0.24900167f, -0.18503664f, -0.88713861f, -0.49338543f, -0.21303712f, 
    -0.68902695f, -0.13345361f, 0.13684408f, 0.34709501f, 0.35179174f, 0.20891061f, -0.26216948f, 0.00243591f, 
    -0.39939752f, -0.09217336f, 0.08098959f, -0.49931705f, -0.21642277f, 0.13043396f, 0.04791101f, 0.12163781f, 
    0.44783747f, -0.25113621f, -0.31564671f, -0.61206651f, -0.13261402f, -0.10653415f, 0.57108825f, 0.59643447f, 
    -0.21681164f, 0.44752851f, 0.45177370f, -0.42592460f, -0.28365827f, 0.00269440f, -0.16980867f, 0.12752607f, 
    -0.33242252f, -0.32203981f, -0.44808361f, -0.33953744f, -0.09749242f, 0.27277708f, 0.08936381f, 0.49068704f, 
    0.09342431f, 0.27918231f, -0.27115428f, -0.78144878f, -0.67468148f, 0.07704417f, 0.07588940f, -0.41010410f, 
    0.43375862f, 0.60296375f, -0.57082814f, -0.21542424f, -0.20477012f, 0.16131018f, -0.18752059f, -0.13303402f, 
    0.19744168f, 0.23337099f, -0.28678524f, -0.42316297f, -0.54606372f, -0.24739926f, -0.28221402f, -0.20438422f, 
    0.12998743f, 0.19508596f, 0.21509971f, -0.80178976f, -0.58367342f, -0.41844094f, -0.39184141f, -0.32919192f, 
    0.14554752f, 0.00698500f, -0.00833674f, 0.40245679f, 0.46748829f, -0.19455342f, 0.41454911f, 0.02365843f, 
    0.47606981f, 0.26941067f, -0.43747738f, -0.32025269f, -0.34380880f, -0.14802638f, -0.15142781f, -0.29055086f, 
    -0.31925160f, 0.24244943f, -0.25204769f, -0.47215095f, 1.00962627f, 0.36119381f, 0.13989076f, 0.85215223f, 
    0.70890504f, -0.63740730f, -0.67081958f, -0.00508526f, -0.46620092f, 0.00701286f, -0.44096896f, -0.14618403f, 
    0.29361844f, -0.30761367f, 0.07842158f, -0.06146418f, -0.12470926f, -0.00400667f, -0.22456151f, -0.03599644f, 
    -0.04643008f, 0.10770144f, -0.02529317f, -0.38694325f, 0.15935263f, -0.00526959f, -0.61322397f, 0.28107199f, 
    0.25261036f, 0.17015806f, -0.32688206f, 0.96097016f, 0.88315439f, 0.02042765f, 0.53884852f, -0.39228261f, 
    -0.28471810f, -0.38818836f, 0.04081624f, -0.32132509f, 0.10352239f, 0.09393417f, -0.16822204f, 0.15414993f, 
    -0.25660515f, 0.20346202f, -0.40913236f, 0.36914358f, -0.00147814f, -0.37116617f, -0.80622792f, -0.48342618f, 
    -0.60805905f, -0.12221563f, 0.17863208f, 0.26055187f, 1.07438982f, -0.27167520f, 0.22070847f, 0.27518004f, 
    0.23671100f, -0.30912840f, 0.16054410f, -0.29472619f, -0.02284034f, -0.05097838f, 0.18076281f, 0.32882157f, 
    -0.09330323f, -0.32803205f, 0.12972780f, -0.28173786f, -0.02297081f, -0.21661334f, -0.20777062f, -0.62737739f, 
    -0.10937484f, -0.33181790f, -0.58276242f, 0.07373530f, 0.21398804f, -0.36190322f, -0.66291511f, -0.40947270f, 
    -0.24798533f, -0.41342357f, 0.15928166f, -0.41052142f, -0.17337397f, -0.62251860f, -0.21638460f, 0.13413443f, 
    0.22025602f, -0.36966372f, -0.17538927f, 0.30587888f, 0.26214978f, 0.26550600f, -0.03704492f, -0.17818013f, 
    0.66616559f, 0.97034323f, 0.41048235f, 0.00946297f, -0.50056428f, -0.39455241f, 0.62746090f, -0.18536325f, 
    0.27093539f, 0.56679350f, 0.25326106f, -0.13496047f, -0.31442112f, -0.55876535f, -0.13571832f, -0.23019259f, 
    -0.32642218f, -0.30676654f, 0.04563564f, -0.29421929f, -0.33044288f, 0.04964756f, 0.03742183f, -0.15377209f, 
    -0.13580100f, -0.13466348f, 0.87176508f, -0.64711773f, -0.53081179f, -0.81751275f, 0.90966707f, -0.67895728f, 
    -0.24185027f, -0.68363780f, -0.46533203f, 0.26185149f, -0.14760141f, 0.28912261f, 0.23133264f, 0.33875790f, 
    0.27004236f, -0.16995451f, 0.17252493f, -0.08624297f, -0.00307514f, 0.01044935f, -0.08226451f, 0.12814334f, 
    -0.16819657f, 0.20689413f, -0.37210917f, -0.62485886f, -0.45575666f, 0.44984096f, 0.12446618f, 0.22796385f, 
    0.61119628f, 0.25864276f, 0.22458892f, 0.09163718f, 0.41514036f, -0.07522790f, 0.32173184f, 0.26784849f, 
    0.27683398f, 0.33556312f, 0.05461555f, -0.02433895f, -0.16727355f, -0.20681980f, 0.16263987f, 0.07045145f, 
    -0.02776658f, -0.11113171f, 0.45860445f, -0.32542998f, -0.60619324f, -0.79466754f, -0.27358830f, -0.31524801f, 
    -0.13624704f, -0.17901331f, 0.04857643f, 0.65745044f, 0.45596287f, -0.26349199f, -0.07993472f, -0.02362759f, 
    0.00380801f, -0.55813509f, -0.18101493f, 0.37990448f, 0.16783267f, -0.00385628f, -0.08032766f, 0.21744366f, 
    0.04717276f, -0.14406069f, 0.39894751f, 0.32722196f, -1.06193960f, 1.23672366f, -0.51319128f, -0.55417883f, 
    0.60000694f, -0.34198332f, 0.32950258f, 0.13318516f, 0.15940103f, 0.02291350f, -0.17255467f, -0.08893905f, 
    -0.08699711f, 0.20488463f, 0.34107882f, 0.06722454f, -0.36811212f, -0.15085311f, -0.00431658f, -0.04201216f, 
    0.42240554f, 0.33279788f, -0.09393676f, 0.30166367f, 0.17253453f, 0.93326724f, 0.88994658f, 0.33619213f, 
    -0.45568901f, -0.76398146f, -0.21389738f, 0.19042808f, 0.24924543f, -0.30759212f, 0.45636228f, 0.56808943f, 
    0.47843900f, -0.02289524f, 0.18749402f, 0.28625727f, 0.21327436f, 0.22829035f, -0.06459419f, 0.07435009f, 
    0.25295717f, -0.06857409f, 0.02785985f, -0.07862552f, -0.05172157f, 0.29559001f, -0.47235891f, -0.44751835f, 
    -0.49090403f, 0.32563648f, -0.10738833f, 0.62115806f, 0.59936368f, -0.79619688f, 0.50746959f, -0.24670200f, 
    0.46327916f, 0.62579131f, -0.25007072f, 0.57049835f, -0.06840461f, 0.11117143f, -0.03170839f, -0.14246257f, 
    0.26508063f, 0.29792464f, -0.09189155f, 0.05673637f, 0.04980044f, -0.00360692f, 0.12708241f, 0.05367842f, 
    -0.62126559f, 0.55075502f, 0.99049920f, 0.43632185f, -0.16890647f, 0.69667518f, 0.32135123f, -0.10844634f, 
    0.53844911f, -0.12313818f, 0.10385232f, 0.15107633f, -0.31487104f, -0.01495587f, -0.27742192f, -0.25672451f, 
    0.09806406f, 0.09278633f, -0.11936785f, 0.24847122f, 0.24059433f, -0.07601722f, -0.01297563f, 0.32632339f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20950039f, 0.10596038f, 0.18001086f, 0.06410123f, 0.05512686f, 0.19851883f, 0.08955494f, 0.25897723f, 
    0.29501167f, 0.11091532f, 0.20427616f, 0.10757474f, 0.32438233f, 0.15996382f, -0.06879569f, 0.24392121f, 
    0.22601673f, 0.07080862f, 0.02105540f, -0.22923295f, -0.04256286f, 0.37694031f, 0.04931981f, 0.15431054f, 
    0.23624015f, 0.35767117f, 0.13381369f, 0.22491543f, 0.40578824f, 0.20862179f, 0.21122746f, 0.02289512f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01568248f, -0.05787757f, -0.02275804f, -0.00832276f, 0.02384876f, -0.02402505f, -0.04273373f, -0.05458454f, 
    0.01191260f, 0.04185988f, -0.03301233f, 0.03548300f, 0.03534769f, -0.04993170f, 0.03631603f, 0.00613436f, 
    -0.01070524f, -0.04826106f, 0.01003416f, -0.02294453f, -0.04279370f, -0.02665806f, -0.02831064f, 0.01274295f, 
    -0.03334400f, -0.05605319f, -0.01355985f, -0.03607626f, 0.01618733f, 0.00171370f, 0.01629101f, -0.05019690f, 
    -0.04054589f, 0.02165503f, -0.05407486f, -0.01731804f, -0.01270778f, -0.02925040f, 0.03109051f, -0.03295097f, 
    0.00371973f, 0.03084089f, -0.02435460f, 0.03820273f, 0.01417626f, -0.02396964f, 0.02054873f, -0.04357879f, 
    0.03803759f, -0.01927138f, -0.00216819f, 0.01354844f, 0.03048924f, -0.01203746f, -0.03674539f, -0.03980879f, 
    -0.00845831f, 0.03172267f, -0.01961925f, -0.01220824f, -0.02475191f, -0.02893233f, 0.00418817f, 0.03139634f, 
    -0.02522570f, 0.02672519f, 0.00919299f, -0.00477299f, -0.02335532f, -0.05671160f, 0.01983187f, 0.00203297f, 
    0.01384924f, -0.04014294f, 0.03829633f, 0.00074018f, -0.03177560f, -0.00911507f, -0.05637405f, -0.00966587f, 
    -0.03074976f, -0.05789912f, -0.02275029f, -0.00632487f, 0.03178395f, -0.02886834f, 0.00118142f, 0.03137100f, 
    -0.03510845f, -0.05320080f, -0.03746543f, 0.03548118f, 0.00577148f, -0.05564383f, -0.01749752f, 0.00768920f, 
    -0.01874900f, -0.01809088f, 0.03215548f, 0.03552586f, 0.03497497f, -0.02859286f, -0.00503614f, 0.00313757f, 
    -0.02595841f, -0.03426890f, 0.04097011f, -0.02509224f, -0.02385138f, 0.03423225f, -0.02046913f, -0.05923830f, 
    0.00945209f, 0.01336808f, -0.01845110f, -0.03998628f, -0.03735093f, -0.00395546f, 0.02026806f, -0.03148930f, 
    -0.05268048f, 0.00348195f, 0.04129519f, -0.05095904f, 0.01909138f, 0.03679852f, -0.04684697f, 0.01909077f, 
    0.00014422f, -0.05072057f, -0.01088643f, -0.01499058f, 0.02269534f, -0.02344571f, 0.02238466f, -0.05731792f, 
    -0.05240133f, 0.01338908f, -0.03770128f, -0.01248418f, 0.03312195f, -0.02679419f, -0.05240608f, -0.01371847f, 
    -0.05087739f, -0.00496430f, 0.04018172f, 0.01198420f, 0.01806890f, -0.00252544f, 0.02160165f, 0.00712358f, 
    0.01998815f, -0.03614086f, 0.01554541f, -0.04785846f, -0.04999518f, 0.00615108f, -0.03492027f, 0.03737826f, 
    0.01250490f, -0.02329509f, -0.01501583f, -0.01655038f, -0.04094935f, 0.01413581f, 0.00434401f, -0.01115107f, 
    0.00134538f, -0.03245239f, 0.01459630f, -0.01723616f, 0.02683773f, -0.02665254f, 0.03896866f, -0.00363852f, 
    -0.03540670f, -0.03874134f, -0.04494474f, -0.00513074f, -0.02161387f, 0.04178573f, 0.02777213f, -0.01166519f, 
    -0.02741175f, -0.03548618f, -0.00053835f, 0.02976141f, -0.04367680f, 0.02593454f, -0.03311091f, 0.01232558f, 
    -0.02305439f, 0.02658519f, 0.02350641f, 0.03866807f, -0.01937660f, -0.03861626f, 0.01763662f, 0.00385207f, 
    0.01728360f, -0.02601770f, -0.05347869f, -0.01280714f, -0.00293327f, 0.04152399f, -0.03961232f, -0.00153554f, 
    0.03675986f, 0.00629610f, -0.00301831f, -0.04564703f, -0.03926909f, 0.03342180f, 0.00854450f, 0.04142643f, 
    0.02925781f, -0.02560418f, -0.00608053f, 0.02991971f, -0.02939538f, 0.03214885f, 0.02308890f, 0.03959448f, 
    -0.05038758f, 0.00232703f, -0.03182807f, 0.04087808f, -0.04184353f, 0.00291073f, 0.02886091f, 0.03798628f, 
    -0.01469710f, -0.02724313f, 0.03491405f, 0.00794722f, -0.01629642f, -0.01641261f, -0.03504061f, -0.02244101f, 
    -0.01526230f, -0.05057127f, 0.00841983f, -0.02712582f, -0.02999225f, 0.02597611f, 0.00192648f, -0.04203606f, 
    0.03411848f, -0.00260776f, -0.04279413f, -0.01733041f, -0.03162142f, 0.00248605f, -0.04386058f, -0.03060086f, 
    -0.01550694f, 0.02164029f, -0.02685990f, 0.02354199f, 0.00980131f, 0.01349804f, -0.02323233f, 0.01583817f, 
    -0.05332340f, -0.02082553f, -0.02695194f, -0.04183462f, -0.04362238f, -0.00750157f, -0.01181766f, 0.00250038f, 
    0.02329084f, 0.00501735f, -0.00824447f, 0.00085261f, -0.05160923f, 0.04079141f, 0.02888855f, -0.03965736f, 
    -0.05366628f, 0.02134851f, 0.00370784f, 0.01651042f, -0.02635498f, 0.02576909f, -0.01313873f, 0.03162966f, 
    0.00738506f, -0.04741597f, -0.04336242f, -0.00884801f, 0.04239408f, -0.03152464f, -0.01506336f, 0.00611766f, 
    -0.02563000f, 0.00959321f, -0.05066873f, 0.01601319f, 0.03732249f, -0.03443235f, 0.01234320f, -0.04326944f, 
    -0.02468189f, 0.03978287f, -0.02383434f, -0.00467966f, -0.04678730f, 0.02365380f, -0.05222296f, -0.01348587f, 
    -0.02543760f, 0.01313486f, 0.02643984f, -0.00451312f, 0.02632864f, -0.05921377f, 0.03148673f, -0.03482113f, 
    -0.05587274f, -0.02479591f, -0.00350772f, -0.01141288f, -0.03732551f, 0.00184092f, -0.01283405f, -0.01697962f, 
    0.02312002f, 0.04309376f, -0.04141701f, -0.05281669f, 0.01247850f, 0.03736623f, -0.02725130f, 0.03263244f, 
    -0.05312331f, -0.02382800f, 0.01769609f, 0.01914946f, 0.01604584f, 0.00288818f, 0.00912124f, -0.01113525f, 
    -0.00956415f, 0.04176054f, 0.01977237f, -0.03509786f, -0.05634962f, -0.01127729f, -0.01297688f, 0.00686278f, 
    -0.00566110f, -0.03830995f, -0.05732349f, -0.02132797f, 0.01044698f, -0.01780715f, -0.04171083f, -0.03506523f, 
    0.03309605f, -0.04130137f, -0.04587506f, -0.00858479f, -0.02179042f, 0.02470561f, 0.02295873f, -0.02105876f, 
    0.01264864f, 0.01463768f, -0.04884516f, -0.01268280f, -0.04107189f, -0.05590098f, -0.01536467f, 0.00287834f, 
    -0.03780151f, 0.02309267f, -0.02672702f, -0.05218579f, -0.02457468f, -0.05218223f, -0.02776041f, 0.04443835f, 
    0.00866330f, -0.01621293f, -0.03751405f, -0.04256158f, 0.00742620f, -0.03848792f, 0.00830065f, 0.00138592f, 
    0.02355109f, -0.04560682f, -0.02603841f, -0.02768333f, -0.03650182f, 0.03771702f, 0.02998050f, 0.03793258f, 
    0.00199285f, 0.00345168f, -0.03516524f, -0.02090683f, 0.01262273f, -0.02544402f, -0.00846979f, 0.01709002f, 
    0.03516495f, -0.00858221f, -0.04326820f, -0.00315927f, -0.04479921f, -0.01282184f, -0.03716011f, -0.03295301f, 
    -0.02544879f, -0.05390428f, -0.02770452f, -0.04371144f, -0.01995161f, 0.00143679f, -0.01707955f, -0.00607561f, 
    -0.05420057f, 0.01754726f, 0.03064020f, 0.03193729f, 0.03168885f, -0.03826030f, 0.01698693f, 0.02057664f, 
    -0.04419699f, 0.01571992f, -0.04954156f, 0.00928257f, -0.05862613f, 0.03220139f, -0.04027480f, -0.03807832f, 
    0.01901669f, -0.02489537f, -0.03886686f, -0.03569581f, 0.04356014f, 0.02989876f, -0.00516991f, 0.00781876f, 
    0.00175407f, -0.00721877f, 0.01620828f, -0.00687337f, -0.01236531f, -0.01620828f, 0.03093171f, -0.03413456f, 
    -0.03461830f, -0.05279283f, -0.03618890f, 0.01423842f, -0.03268275f, 0.04402247f, -0.00689593f, -0.04672471f, 
    0.00851955f, 0.02234875f, -0.03076576f, 0.03803197f, 0.03136430f, -0.01796133f, 0.03851447f, 0.01501996f, 
    -0.00962374f, 0.01076086f, -0.03671919f, -0.00688419f, 0.03133003f, -0.00642070f, -0.03216569f, -0.00039154f, 
    -0.01763108f, 0.01837674f, -0.02183057f, -0.02145225f, 0.00150332f, 0.03704264f, 0.03435206f, 0.00627517f, 
    -0.03331495f, -0.05439654f, -0.00467248f, 0.03088097f, 0.03631447f, -0.05672054f, -0.01180582f, 0.02803146f, 
    0.00428984f, -0.01443624f, 0.01116143f, 0.01662659f, -0.00164597f, 0.02457283f, -0.02348425f, -0.05609098f, 
    -0.04254510f, -0.01106935f, -0.00360960f, -0.03483638f, -0.02364711f, -0.05761147f, -0.03618894f, -0.05086217f, 
    0.01189029f, 0.03994990f, -0.05845140f, -0.00612366f, 0.03425358f, -0.00499990f, -0.02803092f, -0.02462615f, 
    -0.00301167f, 0.00482201f, -0.05123925f, -0.01582653f, -0.01721520f, -0.00367009f, 0.04390515f, -0.04562698f, 
    0.00711703f, 0.00673561f, -0.04445811f, -0.00820477f, 0.02133025f, -0.02634556f, -0.03746663f, 0.04109538f, 
    -0.00771634f, 0.00406978f, -0.00374712f, -0.04018202f, 0.00135817f, 0.00709495f, -0.05161761f, 0.00211067f, 
    -0.01916603f, -0.03757676f, 0.02507040f, 0.01015159f, 0.01355344f, -0.00999646f, 0.03309924f, -0.02493698f, 
    0.00060707f, -0.01472516f, -0.02586843f, 0.04322745f, -0.04184422f, 0.01480278f, -0.00035896f, 0.03373609f, 
    0.00436054f, 0.00786520f, -0.03687808f, 0.03954195f, -0.02044702f, -0.02454090f, -0.04871983f, -0.01294445f, 
    -0.00373068f, 0.03460115f, 0.01184263f, -0.05267354f, -0.00609060f, 0.03509380f, -0.00367435f, -0.01295426f, 
    0.03361235f, -0.04569031f, -0.03185916f, 0.03615619f, 0.00883888f, -0.02094184f, 0.04398915f, -0.01035685f, 
    -0.01859521f, -0.01785164f, -0.00242353f, 0.00415861f, 0.02742500f, -0.02316420f, 0.04013919f, -0.02287746f, 
    0.02466871f, -0.01964910f, 0.02907695f, -0.02039328f, 0.00560229f, 0.01854431f, -0.04958254f, -0.03597545f, 
    0.01807718f, 0.00632112f, 0.00389262f, 0.02735595f, -0.04364859f, -0.05279936f, 0.02810458f, 0.00098149f, 
    -0.00543460f, -0.03904101f, -0.03031042f, 0.03682592f, -0.02615199f, -0.02382279f, -0.03063579f, 0.03415624f, 
    -0.03358884f, 0.03298334f, 0.03920751f, 0.02856297f, -0.04882037f, 0.00749752f, 0.01082930f, 0.04858548f, 
    -0.02181094f, -0.05366398f, 0.00677622f, -0.01916504f, -0.00891617f, 0.02845543f, 0.00818500f, 0.01877667f, 
    -0.00961183f, -0.01454254f, 0.03688405f, -0.02974005f, 0.01784964f, -0.04666838f, -0.03797491f, -0.02986803f, 
    0.02323647f, 0.04069835f, -0.00032095f, -0.05272953f, 0.03101877f, -0.04907381f, 0.03990725f, -0.00486725f, 
    0.01000497f, -0.03245842f, 0.03316284f, -0.00357911f, 0.02111331f, 0.00468034f, 0.02365350f, -0.04519882f, 
    0.03693326f, -0.02129131f, 0.02767069f, 0.01579941f, -0.01222883f, -0.00382281f, 0.01757095f, -0.01306231f, 
    -0.03638890f, -0.00533245f, -0.00792462f, -0.01045761f, -0.04025102f, 0.03713739f, 0.02394476f, -0.00216286f, 
    0.02179824f, -0.05326969f, -0.02638501f, -0.01124051f, 0.00947875f, 0.00384473f, -0.02924335f, -0.05878885f, 
    0.03180333f, 0.04005321f, -0.01519413f, -0.01906078f, 0.02382977f, 0.00018051f, -0.01343232f, -0.03036455f, 
    -0.05120051f, -0.03379877f, -0.02657436f, -0.00813194f, -0.03388266f, 0.01784817f, 0.00582098f, -0.02080857f, 
    0.00290096f, -0.04730492f, -0.03705626f, -0.03146350f, -0.00063454f, -0.02853797f, 0.04719234f, -0.02475790f, 
    0.01573532f, 0.02176442f, 0.01481779f, -0.04099008f, -0.05087201f, -0.04301549f, 0.03625803f, 0.00050422f, 
    0.03698571f, -0.04463021f, -0.03048437f, -0.05100753f, -0.04652985f, 0.00064060f, -0.05659334f, -0.02602805f, 
    -0.00004564f, 0.03496399f, 0.01062343f, 0.01148691f, 0.02712373f, 0.01299282f, 0.02378540f, 0.03045433f, 
    -0.02800229f, -0.05777259f, -0.04646350f, 0.04666678f, 0.03741524f, -0.02816084f, 0.02098374f, 0.04609624f, 
    -0.04299432f, -0.02486430f, 0.00626173f, 0.02832224f, 0.00277443f, -0.04529351f, 0.01464339f, 0.00874305f, 
    0.02173372f, -0.00774788f, -0.03213552f, -0.01230269f, 0.02141217f, 0.02291233f, 0.00896674f, -0.04480424f, 
    0.03388750f, 0.01365751f, 0.00786486f, 0.03341225f, 0.00936669f, -0.05130379f, -0.04456760f, -0.03623634f, 
    -0.03918724f, -0.03415351f, 0.00846815f, -0.00414109f, 0.02363904f, 0.02566260f, 0.00154709f, -0.02889074f, 
    0.03101395f, 0.00913581f, -0.00635125f, -0.01306341f, -0.04695128f, -0.05397540f, 0.01191534f, -0.05555909f, 
    -0.03796991f, 0.00982186f, -0.04619526f, 0.02359469f, 0.00165376f, 0.00960340f, -0.02026197f, -0.00795000f, 
    0.02981258f, -0.01027658f, -0.04697310f, 0.04176006f, -0.00104709f, -0.02090350f, -0.04678755f, -0.04327968f, 
    0.04472421f, 0.01991952f, 0.04060800f, -0.00203630f, 0.02720387f, 0.00207162f, 0.01824364f, -0.00671766f, 
    -0.00869268f, 0.03699291f, -0.05026711f, 0.00069660f, -0.04958419f, 0.03160904f, 0.00341259f, -0.02358119f, 
    -0.04675358f, 0.02332992f, -0.03732637f, 0.01526762f, 0.01027656f, 0.00661423f, 0.01090343f, 0.00623705f, 
    0.00932910f, -0.03161508f, -0.01324719f, -0.00039287f, -0.03468191f, -0.03250996f, 0.01308900f, -0.02279262f, 
    0.01861830f, -0.04897691f, 0.02058386f, 0.01126282f, -0.01192292f, 0.02455470f, -0.04084619f, 0.03656968f, 
    0.03878774f, 0.03040204f, 0.00598697f, -0.04900360f, -0.01016884f, 0.01455963f, 0.03147223f, -0.02606318f, 
    0.01319281f, 0.02735300f, -0.02751909f, 0.04466986f, -0.00810098f, 0.04331567f, -0.03235945f, -0.01720414f, 
    0.00584958f, -0.03601822f, -0.02620186f, -0.00984821f, -0.05593011f, -0.05227038f, -0.00831967f, -0.03374902f, 
    -0.01394235f, -0.02306846f, -0.02221147f, 0.02033825f, 0.00003256f, -0.03377894f, 0.01699682f, 0.00781721f, 
    0.04411392f, -0.01874107f, -0.04147782f, 0.03163436f, 0.00516746f, -0.04958295f, 0.00278937f, -0.03931246f, 
    -0.05246736f, 0.02769843f, -0.02425103f, 0.04859245f, -0.04619715f, -0.03860453f, -0.04733679f, 0.04377784f, 
    0.02418294f, 0.03098364f, -0.02355950f, -0.02925275f, -0.02863369f, -0.03049506f, 0.01717069f, -0.00212465f, 
    0.01013152f, -0.01318604f, -0.04250459f, -0.03570399f, 0.03782983f, 0.03746177f, -0.04070059f, -0.00956000f, 
    0.02869419f, -0.04467122f, -0.00598565f, 0.01251954f, 0.03409120f, 0.03495318f, -0.02703254f, 0.03741290f, 
    -0.02535225f, 0.02201489f, -0.03543571f, -0.03936506f, -0.02183870f, -0.03732308f, -0.02309241f, -0.04596620f, 
    0.01309327f, -0.02344703f, 0.03363243f, -0.04233944f, -0.01150594f, 0.01727421f, -0.01725323f, -0.02219834f, 
    -0.04598778f, -0.02445877f, 0.01486217f, -0.02042554f, -0.00379404f, -0.02683900f, -0.01873100f, 0.03756892f, 
    0.03241761f, -0.00104949f, -0.04954277f, 0.01374598f, -0.00402569f, 0.04092050f, 0.03510840f, 0.00597379f, 
    0.02901400f, 0.03577658f, -0.05459151f, 0.01126135f, 0.01198629f, 0.00515092f, -0.03817241f, 0.02329622f, 
    0.01681523f, 0.01852785f, -0.03645445f, -0.00324514f, 0.01610405f, -0.02765416f, -0.03955085f, -0.00193885f, 
    0.03512613f, -0.02850367f, -0.01115643f, -0.02337936f, -0.02281605f, 0.00627517f, -0.05532141f, -0.05169511f, 
    0.03983925f, 0.04173717f, 0.04387233f, -0.02100682f, 0.01196382f, 0.03330276f, 0.00065334f, -0.04955741f, 
    -0.01135436f, -0.03255441f, 0.03726719f, -0.00218447f, -0.05369543f, -0.03944917f, -0.04618237f, 0.03474681f, 
    -0.02637778f, 0.00601867f, 0.02073376f, 0.01582489f, -0.04478433f, 0.01704247f, -0.00365310f, 0.00760113f, 
    -0.02245325f, -0.04654828f, -0.04904204f, -0.01832910f, 0.01307424f, 0.02399708f, -0.04635485f, -0.01042859f, 
    -0.02626340f, -0.01008820f, -0.01056567f, -0.04834976f, -0.01934498f, -0.01861974f, 0.02873191f, -0.00325190f, 
    0.02466601f, -0.05390113f, -0.04369568f, 0.02879206f, -0.01331999f, 0.00068222f, -0.05631758f, -0.02802216f, 
    -0.05585251f, 0.00252553f, -0.03872095f, 0.00639416f, -0.02718131f, -0.02027280f, -0.02755461f, -0.05534003f, 
    0.00891438f, 0.00601990f, 0.02490372f, -0.00277372f, -0.04918740f, -0.01635319f, 0.03835319f, 0.01187348f, 
    -0.02882038f, -0.00497085f, -0.05177635f, 0.00456637f, 0.00495631f, 0.00816124f, -0.03579997f, 0.00891702f, 
    0.03429905f, 0.03460203f, 0.04270791f, -0.02815426f, 0.00377991f, -0.05173314f, 0.04244160f, 0.01038401f, 
    0.00057723f, 0.04551553f, -0.00169710f, 0.00697520f, 0.00688849f, 0.04478099f, -0.02711133f, 0.00877239f, 
    0.01530616f, -0.01209638f, 0.04487099f, 0.04343554f, -0.00973294f, -0.02619171f, -0.00299168f, -0.05185616f, 
    0.02053558f, -0.01923591f, 0.00404261f, -0.04078265f, -0.04342302f, -0.01780008f, 0.00103097f, 0.01630280f, 
    0.00445120f, -0.02112988f, -0.03417528f, 0.02362288f, 0.00340003f, 0.03044270f, -0.04358417f, 0.02064651f, 
    -0.03905807f, -0.03995240f, -0.01175766f, -0.00127013f, -0.04457592f, -0.01921679f, -0.03853974f, 0.03482506f, 
    -0.05661920f, -0.03367501f, 0.02855976f, 0.00247356f, -0.05533552f, -0.04949753f, -0.02594006f, 0.04153812f, 
    -0.03156586f, -0.00276350f, 0.04069692f, 0.04439924f, -0.00623512f, -0.01751800f, 0.00393759f, -0.03840518f, 
    -0.02243373f, 0.02042194f, 0.00690195f, -0.03160303f, -0.00021906f, -0.01019658f, 0.00692618f, 0.03869363f, 
    -0.03867217f, 0.03171827f, 0.03084746f, -0.04916879f, 0.02576978f, -0.05179604f, -0.02386359f, -0.02206445f, 
    -0.03150452f, -0.00019212f, -0.01520439f, -0.01524627f, -0.00773180f, -0.01796410f, 0.03854427f, -0.03324946f, 
    -0.03721978f, 0.02806607f, -0.04350682f, 0.01408184f, 0.01676413f, 0.00783901f, -0.01793496f, -0.04833809f, 
    -0.04003457f, -0.01269551f, -0.00983020f, 0.02833419f, -0.03264244f, -0.05479215f, -0.05648468f, -0.04438103f, 
    0.00701066f, 0.01594522f, 0.03556242f, -0.03933491f, 0.01965556f, 0.02966484f, -0.05463951f, 0.04177388f, 
    0.00937394f, 0.04209570f, -0.04444043f, 0.02187287f, 0.03184376f, -0.01701688f, 0.03717117f, -0.02761205f, 
    -0.18216953f, 0.24077576f, 0.07750797f, -0.03526463f, -0.04560564f, 0.11281660f, 0.05342119f, 0.06100741f, 
    0.14397486f, -0.08543153f, -0.02499388f, -0.00787916f, -0.30563313f, 0.18625163f, 0.39898294f, -0.02065453f, 
    -0.15581657f, 0.12681879f, 0.10493990f, 0.18377540f, -0.03693915f, -0.02305318f, 0.05159092f, 0.00624872f, 
    0.14195964f, 0.44390994f, 0.01293179f, -0.04747421f, -0.02841979f, 0.06397004f, -0.06563050f, 0.11429524f, 
    0.06540376f, -0.00625816f, 0.08829284f, 0.08327270f, -0.01505919f, -0.26270792f, 0.06036714f, 0.06901873f, 
    0.28050900f, 0.30487138f, 0.22778875f, 0.15746711f, 0.00595983f, 0.09729721f, 0.00536128f, 0.09243415f, 
    0.02842335f, -0.08077413f, -0.06619188f, -0.06016855f, 0.12205540f, 0.03277630f, -0.02546137f, -0.22293536f, 
    0.04569443f, 0.11618625f, 0.11249555f, 0.30273333f, -0.30787033f, 0.23615049f, -0.19431628f, 0.04139820f, 
    0.12743162f, 0.03870988f, -0.07821695f, 0.15330216f, -0.02077156f, -0.01094254f, -0.02012778f, -0.01968753f, 
    0.09291926f, 0.02654572f, 0.11053949f, -0.03812327f, 0.01028034f, 0.01024871f, 0.07420309f, 0.06107812f, 
    0.14494222f, 0.11048230f, 0.07777382f, 0.28994504f, -0.07687835f, 0.09499330f, 0.06683641f, -0.17016943f, 
    0.12622640f, 0.05772224f, 0.08910153f, 0.10733828f, 0.09265672f, -0.02233221f, 0.08458517f, -0.01744523f, 
    -0.33638903f, -0.18997887f, -0.12021261f, 0.12084038f, 0.15408665f, 0.05613585f, 0.03557486f, 0.17793944f, 
    0.03830485f, 0.08031887f, 0.06649945f, -0.06902043f, -0.03523246f, 0.18871884f, 0.16388680f, 0.31568673f, 
    0.14846651f, 0.05702893f, 0.06197068f, -0.04378693f, -0.05680288f, -0.00273891f, 0.10720415f, -0.08169357f, 
    0.16268945f, -0.23108239f, 0.11072341f, -0.18967485f, -0.01288651f, 0.03147134f, -0.01730691f, 0.07578269f, 
    -0.05597767f, 0.00591839f, 0.05292000f, 0.00928939f, -0.01971971f, 0.19446100f, 0.08085812f, 0.28633338f, 
    0.08168302f, -0.01250791f, 0.00894228f, 0.00159621f, 0.04822555f, -0.09712338f, -0.00916647f, -0.00086233f, 
    0.30124116f, -0.26787525f, 0.05910026f, -0.05039830f, -0.04201249f, 0.05486682f, 0.05934438f, 0.06839506f, 
    0.05773747f, 0.02155702f, -0.00657550f, 0.07509647f, -0.06040952f, -0.02324993f, 0.00336597f, -0.02396421f, 
    -0.03393715f, -0.07563841f, -0.05625414f, 0.09944858f, 0.11327741f, 0.17139868f, 0.04657443f, -0.01716848f, 
    0.35399017f, -0.11125544f, 0.11455818f, 0.00669850f, 0.15051742f, 0.00140211f, 0.05088991f, -0.16158724f, 
    0.10301458f, -0.05912190f, 0.11816457f, 0.04102502f, -0.24756351f, 0.15532157f, 0.29833400f, -0.07661750f, 
    -0.08407053f, 0.01027095f, 0.02745458f, 0.08534303f, 0.09089155f, 0.10077669f, 0.02453354f, 0.13475791f, 
    -0.00641798f, -0.14993180f, 0.13230078f, 0.21309541f, -0.00195521f, 0.23301594f, 0.05954290f, 0.16279852f, 
    0.03339428f, 0.01129190f, 0.14090885f, 0.14813790f, -0.04777587f, 0.07459544f, -0.10493243f, -0.13788958f, 
    0.06063867f, 0.08008991f, 0.03838075f, 0.16861238f, 0.06734920f, 0.03452347f, -0.08510435f, -0.06707589f, 
    -0.44799751f, 0.20638271f, -0.26264033f, -0.05613403f, -0.00182449f, 0.06911495f, 0.08670083f, 0.13127996f, 
    -0.01573790f, 0.02437951f, -0.13012397f, 0.01824930f, -0.30123875f, -0.12753233f, 0.06546304f, -0.04003009f, 
    0.25236750f, -0.02591005f, 0.10981282f, -0.05861278f, 0.04273381f, 0.03933041f, 0.01208986f, -0.09700640f, 
    0.08424968f, -0.11746179f, 0.08607236f, 0.06321730f, -0.11165977f, 0.00692886f, 0.05693257f, 0.06600723f, 
    -0.11510529f, 0.04430524f, 0.10728387f, 0.09804856f, 0.25714445f, 0.14734820f, 0.16229030f, 0.08481127f, 
    -0.05765798f, 0.13329783f, 0.00646005f, -0.02237461f, 0.06328214f, 0.00698528f, 0.07220607f, 0.01043858f, 
    -0.30085415f, 0.14610180f, -0.04247024f, 0.06746498f, 0.12726021f, 0.18171684f, -0.07617296f, -0.09868303f, 
    0.09634852f, -0.03925691f, -0.01650319f, -0.10715038f, -0.13869826f, -0.00536697f, 0.01374582f, -0.04087775f, 
    0.32884496f, 0.12542826f, 0.11991326f, 0.16608250f, 0.03221500f, -0.10216212f, 0.15790582f, -0.06457960f, 
    -0.00592508f, -0.04830511f, 0.09292401f, 0.28593332f, -0.01890682f, -0.21063259f, 0.03130815f, -0.09117693f, 
    0.09116343f, 0.02950758f, -0.01999813f, 0.05435624f, -0.24177676f, -0.02234105f, 0.30596808f, -0.00390817f, 
    -0.05752461f, 0.07865555f, 0.04523063f, 0.04001913f, -0.02670545f, 0.13150676f, 0.11429212f, -0.01363576f, 
    -0.29139784f, 0.15404160f, -0.08340811f, 0.08816646f, 0.03210421f, 0.08757304f, 0.03197406f, 0.10448313f, 
    0.10787463f, 0.05121321f, 0.02611741f, 0.24882290f, -0.17872955f, -0.12822200f, -0.03431172f, -0.11235239f, 
    0.27201691f, 0.25867951f, -0.01295086f, 0.06804317f, -0.04131111f, -0.00333450f, 0.10649046f, 0.09018818f, 
    0.08263023f, -0.12854365f, 0.10760763f, -0.00150731f, -0.14727040f, -0.03476536f, 0.12667195f, 0.10869722f, 
    0.13957027f, 0.13137411f, 0.03776347f, -0.13194582f, -0.00698435f, 0.12204564f, -0.03987887f, -0.03183547f, 
    -0.01134580f, 0.06836161f, 0.10579807f, 0.00477893f, -0.06999804f, 0.06689829f, 0.19680774f, 0.13362846f, 
    -0.52427220f, 0.24417143f, -0.21053413f, 0.01803893f, 0.03352182f, 0.10198789f, 0.09224734f, 0.04144632f, 
    0.13608105f, 0.12028230f, 0.02677100f, 0.07562856f, -0.02314379f, 0.14550948f, 0.12155671f, 0.12140793f, 
    -0.11658146f, 0.03814116f, 0.06559967f, -0.00272496f, -0.04591633f, 0.03812294f, 0.06687518f, -0.00718573f, 
    0.01208575f, 0.03023171f, -0.04183982f, -0.02364077f, -0.02246681f, 0.01997074f, -0.00760960f, 0.04346989f, 
    0.03835984f, -0.03006025f, 0.02849774f, -0.04872336f, 0.04187118f, 0.01896760f, 0.03011620f, 0.01049209f, 
    -0.00531241f, 0.01355556f, 0.01461763f, 0.02768348f, 0.02822834f, -0.04870600f, -0.05656886f, 0.03706786f, 
    0.00863043f, 0.01137337f, -0.03812186f, 0.02611680f, -0.02740507f, 0.04568625f, 0.04604754f, 0.03395220f, 
    0.01638708f, 0.04015495f, -0.01045567f, -0.01786884f, -0.04781334f, -0.02909103f, -0.00322602f, -0.01089703f, 
    0.00722979f, 0.00433655f, -0.00076984f, 0.00743336f, 0.01363934f, 0.02566236f, -0.03010480f, -0.02797118f, 
    0.01485692f, -0.00117726f, 0.04286152f, 0.03385111f, 0.03544988f, 0.02507407f, 0.01969836f, -0.03898789f, 
    0.01007408f, -0.02386814f, -0.01020929f, -0.02774328f, -0.02650261f, -0.00438447f, 0.01078972f, 0.02075956f, 
    0.03408048f, -0.01687673f, 0.02587016f, -0.04815859f, -0.00353914f, 0.01035198f, -0.02304667f, 0.02845476f, 
    0.02893883f, -0.01815195f, -0.04149297f, 0.02330523f, -0.03900957f, -0.02012692f, -0.03036352f, -0.05545090f, 
    -0.02058999f, -0.01520523f, -0.05310161f, 0.01166779f, -0.04776549f, 0.03073339f, 0.00494904f, 0.02776877f, 
    0.04022149f, -0.05085680f, -0.03710471f, 0.03043285f, 0.02017192f, 0.02217263f, 0.04226381f, -0.03991174f, 
    -0.01632840f, -0.01714908f, -0.00071583f, -0.04072790f, 0.00793728f, 0.01095462f, -0.03563529f, -0.02000681f, 
    -0.01200758f, -0.04878606f, -0.02130229f, -0.02463809f, 0.02907436f, 0.02777175f, 0.04851193f, 0.02241872f, 
    -0.02573361f, -0.05523585f, 0.03211883f, 0.02884196f, 0.03326745f, 0.03785719f, -0.01758383f, -0.02377320f, 
    -0.05301102f, 0.02125801f, -0.02991585f, -0.01623170f, -0.03805735f, -0.05285405f, -0.01088369f, -0.03342954f, 
    0.00823292f, 0.00946494f, 0.01543183f, 0.02553040f, -0.02232262f, 0.02678083f, -0.01550117f, 0.00062083f, 
    0.00123747f, 0.03910058f, -0.03110513f, -0.01720046f, -0.02939065f, -0.05627137f, 0.00503891f, -0.04103144f, 
    0.03301949f, -0.01237994f, -0.00134436f, 0.00625331f, 0.01943356f, 0.02362650f, -0.03863330f, 0.01153589f, 
    -0.04456593f, -0.03629602f, 0.00121338f, 0.00032085f, -0.03844488f, -0.05713820f, 0.04151123f, -0.00722573f, 
    -0.02944528f, 0.01092759f, 0.00745053f, 0.04098653f, 0.00249819f, 0.03900238f, 0.00820118f, 0.02077270f, 
    -0.04590160f, -0.03729248f, -0.03496917f, -0.00467920f, -0.02698108f, -0.01118102f, 0.01122863f, 0.02318365f, 
    0.03665866f, -0.01076878f, -0.02885828f, 0.04261755f, -0.00084599f, 0.01755912f, 0.04324827f, 0.03462319f, 
    -0.04932530f, -0.01899870f, 0.04125071f, 0.03361190f, 0.01410104f, -0.04529192f, 0.00612742f, 0.01682028f, 
    0.01160945f, -0.01584972f, 0.01707517f, -0.03084970f, -0.03878737f, 0.03957156f, -0.04578475f, 0.01099601f, 
    0.04262711f, 0.03504827f, -0.01670615f, -0.03642964f, -0.04913640f, -0.00152052f, 0.00878471f, 0.02118191f, 
    -0.02530674f, -0.00270027f, -0.03721299f, 0.00938784f, 0.00803134f, 0.03383392f, -0.00020488f, -0.01128520f, 
    0.02996510f, 0.00754310f, -0.04525425f, -0.03885587f, 0.02219911f, -0.05770088f, 0.02746125f, 0.04156824f, 
    0.03185984f, 0.00737189f, -0.04073478f, -0.00601388f, -0.04241524f, 0.04317750f, -0.03358156f, 0.00498206f, 
    0.00707869f, -0.01443481f, -0.02095702f, 0.01508978f, -0.04907376f, 0.02113221f, -0.04338794f, 0.02814958f, 
    -0.00797014f, 0.00499222f, -0.05021383f, 0.03272969f, -0.03328006f, -0.04303475f, -0.01739594f, 0.01815728f, 
    0.01601649f, -0.05131327f, -0.04343911f, 0.02462897f, 0.02391944f, 0.01516751f, -0.03651682f, 0.04225545f, 
    -0.00774101f, -0.01001874f, -0.05326290f, -0.02675432f, -0.02344527f, -0.04323334f, -0.01366679f, 0.04049122f, 
    -0.00962889f, -0.00222343f, 0.03091747f, 0.04327607f, 0.03227109f, -0.02683592f, -0.04585289f, -0.01536841f, 
    0.02726207f, -0.04647178f, -0.05156630f, -0.03963912f, 0.00819221f, -0.02788421f, 0.02692263f, -0.03541210f, 
    0.03316552f, -0.05723425f, 0.03596902f, 0.05170128f, -0.00917591f, -0.00242851f, -0.01741590f, -0.05395546f, 
    -0.01316399f, 0.03765052f, -0.03620744f, -0.04090848f, 0.00984653f, -0.04991488f, -0.01315437f, -0.03922309f, 
    0.03620804f, -0.01124579f, 0.03756770f, -0.03899505f, -0.04416490f, -0.02491301f, 0.02866094f, -0.04220160f, 
    -0.05738194f, -0.04489395f, -0.04876956f, 0.00994563f, -0.04588868f, -0.03315637f, 0.03379974f, 0.00808781f, 
    -0.00260051f, -0.03016536f, -0.04227577f, 0.03394140f, -0.00936886f, -0.04209598f, 0.01483326f, 0.03523693f, 
    0.00963012f, 0.00100524f, 0.02539110f, 0.04953544f, 0.00812540f, -0.05075573f, 0.00053939f, -0.02881422f, 
    -0.03995527f, 0.02792469f, 0.01552738f, -0.02925526f, 0.00897970f, -0.03856948f, 0.00857795f, -0.04769938f, 
    0.01562021f, -0.01727435f, -0.01918844f, -0.01615961f, -0.03378519f, 0.02487171f, -0.03890143f, 0.01178479f, 
    -0.05191856f, 0.00975459f, -0.00430611f, -0.01425715f, 0.04046686f, 0.01541512f, 0.03415685f, 0.04152174f, 
    -0.04294392f, 0.04389373f, -0.03666340f, -0.02144298f, -0.03712044f, 0.01470858f, -0.02566462f, 0.05150716f, 
    0.02157083f, 0.02816411f, -0.01886836f, -0.01806069f, -0.04301775f, -0.00706799f, 0.02543605f, 0.01046415f, 
    0.02065975f, -0.03739431f, 0.00949281f, 0.03025528f, 0.00634939f, -0.00273739f, -0.01608961f, -0.03559700f, 
    -0.04453701f, 0.00065283f, -0.05288657f, -0.00338782f, 0.02378014f, 0.00177603f, -0.02270466f, -0.05380996f, 
    0.03558917f, 0.02062852f, 0.04239190f, -0.00346990f, -0.04749283f, 0.00766177f, -0.03682994f, -0.04634559f, 
    0.02695884f, -0.01269895f, 0.02302985f, -0.03779979f, -0.04621950f, -0.02551664f, -0.03756929f, -0.04528142f, 
    -0.04769483f, 0.01057551f, 0.02821660f, 0.03366028f, 0.00125262f, -0.00080050f, -0.03792302f, -0.05365042f, 
    0.00676906f, -0.01651738f, -0.01621304f, 0.03214736f, 0.03349897f, 0.04169746f, -0.00495267f, -0.01765883f, 
    0.00775601f, 0.00451650f, -0.00348428f, -0.02528433f, -0.05393545f, -0.02359098f, 0.04319609f, -0.02848422f, 
    -0.00696978f, 0.01641270f, 0.03608177f, -0.00398287f, -0.00927310f, -0.00908079f, -0.02541533f, 0.04160826f, 
    -0.03776671f, 0.04432616f, -0.01535380f, -0.05094174f, 0.02150013f, -0.02116282f, 0.01859138f, -0.00791724f, 
    0.01705308f, -0.04622895f, -0.02399525f, -0.02985650f, 0.00011527f, -0.02894131f, -0.00122065f, -0.01767969f, 
    -0.03609525f, 0.01986778f, -0.01817684f, -0.05526484f, -0.00940648f, -0.01305813f, 0.00099146f, 0.03671894f, 
    0.01097559f, -0.03659752f, 0.03789167f, -0.05034183f, 0.02692842f, 0.03236001f, -0.01985348f, 0.01811003f, 
    -0.02036352f, 0.01356707f, -0.04965405f, -0.04094554f, 0.04507886f, 0.01684644f, -0.00177389f, 0.01968596f, 
    -0.04481285f, -0.03490857f, -0.04293689f, 0.02300573f, 0.04404712f, 0.04423440f, -0.01449888f, -0.04235267f, 
    -0.03499198f, 0.00561996f, -0.02607634f, -0.03387427f, 0.00746393f, 0.04559445f, -0.02721132f, -0.02463680f, 
    -0.00882632f, -0.05504794f, -0.01179758f, -0.02172984f, -0.00803357f, -0.04699881f, -0.02332775f, -0.05334469f, 
    0.04082892f, -0.01434847f, 0.00997907f, -0.03322264f, -0.05082710f, 0.04226360f, -0.04914452f, -0.02026693f, 
    -0.01406553f, 0.04022715f, 0.02576134f, 0.03475508f, -0.02382117f, 0.02943962f, 0.02728747f, 0.02352738f, 
    -0.01324993f, -0.05335452f, -0.03050788f, -0.00798555f, 0.04414494f, 0.03548144f, -0.05447685f, -0.02935213f, 
    -0.01709627f, -0.01625082f, -0.02830064f, 0.04093463f, -0.03341795f, 0.02132946f, -0.03063813f, -0.04086282f, 
    -0.04966742f, -0.03842868f, -0.03841804f, -0.04155957f, -0.04030763f, -0.01769589f, 0.00828764f, 0.01945940f, 
    0.02987155f, 0.04172377f, 0.00217756f, -0.05547358f, 0.01588480f, 0.02083311f, -0.01940081f, 0.01459175f, 
    0.01403422f, -0.05529286f, -0.00902849f, -0.04334283f, -0.01882769f, -0.04280714f, -0.04376736f, 0.01316267f, 
    0.02696357f, -0.01778205f, -0.02701572f, 0.03720111f, 0.04544845f, -0.05518385f, -0.04750331f, -0.02372876f, 
    -0.01407671f, -0.02133685f, -0.01535132f, -0.01816589f, -0.02591077f, -0.01833196f, -0.00797533f, 0.04369996f, 
    -0.04481709f, -0.01031906f, -0.01673831f, -0.00094149f, -0.03708393f, -0.04181627f, 0.04584875f, 0.04284039f, 
    0.01029776f, 0.00658772f, 0.01402664f, -0.03088863f, -0.05406536f, -0.05464699f, 0.04544666f, 0.02586268f, 
    -0.03705042f, 0.04416990f, -0.04480859f, 0.00128267f, -0.02156554f, 0.01364609f, -0.05010369f, 0.02214978f, 
    0.03643230f, -0.00681117f, -0.05585564f, 0.01229517f, 0.02301607f, -0.01496635f, 0.01946172f, -0.02156749f, 
    -0.03545330f, -0.03047768f, -0.03164299f, -0.04408056f, 0.04330682f, 0.00733397f, 0.04339590f, -0.01728518f, 
    -0.03298899f, -0.02234072f, -0.02339937f, 0.01646965f, 0.01502749f, -0.02506251f, -0.03946861f, -0.04871513f, 
    0.00031086f, -0.02047538f, 0.01459252f, -0.04141072f, -0.00524005f, 0.00402525f, 0.02906817f, 0.04035877f, 
    -0.04982398f, 0.00544874f, -0.03744973f, -0.02659708f, 0.00420859f, -0.04305909f, -0.03153599f, 0.01857963f, 
    0.03751262f, -0.05386769f, 0.00900986f, -0.01983095f, 0.03899281f, -0.03897019f, -0.04764777f, 0.02963493f, 
    -0.01661573f, -0.02502740f, -0.00414921f, -0.03283241f, 0.02395648f, 0.03333201f, -0.05127208f, -0.01448489f, 
    -0.02156705f, -0.01844816f, -0.01777491f, -0.05155510f, -0.01590089f, -0.01312901f, -0.01993950f, 0.01564902f, 
    0.00052045f, 0.00029172f, 0.00795542f, 0.02931389f, 0.02447736f, -0.02302187f, -0.00482868f, -0.01838317f, 
    0.05041333f, -0.01070098f, -0.01456923f, -0.04531043f, 0.02567637f, 0.02630973f, -0.03746960f, -0.03551820f, 
    0.01226297f, 0.02434313f, 0.02887998f, -0.00503433f, -0.04230127f, 0.04469383f, 0.02151055f, 0.02350049f, 
    -0.04959901f, -0.03115203f, 0.00574499f, 0.00340847f, -0.04224216f, -0.03391143f, 0.00791150f, -0.04374831f, 
    -0.00552220f, -0.04181194f, -0.01408721f, 0.03125016f, -0.00589907f, -0.01964096f, -0.00462903f, -0.03097583f, 
    0.03644471f, -0.03900112f, 0.02979532f, 0.04538653f, 0.00741501f, -0.05571354f, 0.04177113f, 0.03558945f, 
    0.04178165f, -0.04732043f, -0.01148644f, 0.04602677f, 0.01632922f, -0.00027729f, -0.04443413f, 0.01482096f, 
    0.01063237f, -0.05088142f, 0.00990790f, 0.04525431f, -0.02942214f, -0.04280564f, -0.01744438f, -0.01802043f, 
    -0.02689307f, 0.03331617f, 0.01510015f, 0.03938608f, -0.05095416f, -0.05136397f, -0.03354177f, 0.00288524f, 
    -0.02262298f, 0.03846250f, -0.05197409f, 0.02235778f, -0.04814267f, 0.00353898f, -0.03273223f, -0.00925215f, 
    0.04300757f, 0.02756969f, -0.01968231f, 0.04588914f, 0.03379615f, -0.00109106f, 0.02658021f, -0.02439356f, 
    0.01914719f, -0.04917736f, -0.00571639f, -0.02753372f, -0.05198206f, 0.02632837f, -0.01423212f, 0.01346080f, 
    -0.05149953f, 0.03146107f, 0.01444570f, -0.02413739f, 0.01684356f, -0.00269751f, -0.00782022f, 0.03807691f, 
    -0.04411045f, -0.01250254f, -0.02433274f, -0.00199686f, 0.00353384f, 0.01822273f, -0.03237808f, -0.04232276f, 
    0.19434512f, -0.10772327f, 0.11295609f, -0.00813698f, 0.10467193f, -0.03550148f, -0.07850649f, 0.11242815f, 
    0.01198590f, 0.02936844f, -0.00849323f, -0.02928076f, 0.12254409f, -0.11100478f, 0.26047146f, -0.26607677f, 
    0.07116967f, -0.14411092f, 0.12652312f, -0.05304059f, 0.18491626f, 0.00863792f, 0.07535437f, 0.09269284f, 
    0.29024211f, -0.54922360f, 0.31127587f, 0.19966841f, -0.05335412f, -0.05587707f, -0.01023963f, 0.12041936f, 
    0.09042482f, 0.00208560f, -0.00696080f, 0.02156961f, 0.07866628f, 0.19947776f, 0.16894315f, 0.00918093f, 
    -0.03644902f, -0.04369017f, 0.19380474f, 0.18691547f, 0.10666882f, 0.09761433f, 0.18553017f, -0.01994695f, 
    0.04225006f, 0.40568551f, 0.07552221f, -0.26374066f, -0.02838328f, -0.14971010f, -0.04685695f, 0.10879976f, 
    -0.02183746f, 0.03946501f, 0.03622749f, 0.04528132f, -0.10175123f, 0.26456991f, -0.26424477f, 0.14789347f, 
    0.09097108f, -0.01282403f, -0.00474125f, 0.02818682f, -0.09751674f, -0.03427373f, 0.02409459f, 0.05125287f, 
    -0.07574494f, -0.08222571f, -0.27223709f, 0.08906849f, -0.06071640f, -0.05512245f, -0.07811537f, 0.11350884f, 
    0.08945043f, -0.02104827f, 0.14939818f, -0.13943073f, 0.19629306f, 0.10882198f, 0.00984302f, -0.17549065f, 
    0.13930114f, -0.02786593f, 0.09928774f, 0.04819452f, -0.07475422f, 0.15625599f, -0.04721981f, 0.05280390f, 
    -0.45959699f, 0.21792664f, -0.07728664f, 0.05463918f, -0.07729384f, 0.05987361f, -0.06102470f, 0.01315216f, 
    0.00547989f, -0.03902031f, -0.01423241f, 0.04692216f, -0.12646931f, 0.31393522f, -0.22350602f, -0.02471610f, 
    0.01777541f, -0.09500939f, -0.07353269f, 0.12661457f, 0.08339182f, 0.01237260f, 0.02626188f, -0.06948555f, 
    0.13758983f, -0.18557732f, 0.25107419f, -0.14402376f, 0.01195610f, 0.04957772f, 0.14949258f, -0.19356118f, 
    -0.00686399f, 0.13944940f, 0.05066812f, -0.01822263f, -0.33224067f, -0.10739408f, -0.23161325f, 0.03225784f, 
    -0.14625202f, 0.02009397f, 0.08169051f, -0.01024499f, -0.11823477f, -0.17107888f, 0.00351786f, 0.03593417f, 
    -0.12962493f, 0.39867377f, 0.00715767f, -0.31552103f, -0.03308091f, -0.04632396f, 0.07232103f, -0.10089999f, 
    0.06832345f, -0.14728968f, 0.02881257f, -0.06550381f, -0.17848399f, 0.13020018f, -0.13199502f, 0.26490086f, 
    0.08803656f, 0.02316749f, 0.02318994f, 0.13290015f, -0.05220278f, -0.02281534f, 0.12563570f, 0.08896742f, 
    -0.14081761f, 0.22024657f, -0.10671754f, -0.05338870f, 0.05022155f, -0.03660666f, -0.08504201f, 0.05634443f, 
    0.01093904f, 0.04715940f, 0.00007652f, -0.23935243f, 0.21170121f, -0.13318413f, 0.11117692f, 0.22326769f, 
    -0.21967481f, 0.04130043f, 0.07047222f, 0.02922540f, 0.19035093f, 0.08554477f, 0.03440959f, 0.14554231f, 
    0.14252353f, 0.03648388f, 0.03212164f, 0.00487858f, 0.08502459f, 0.00282761f, 0.16724861f, 0.12373500f, 
    0.14506632f, 0.07462420f, -0.11912360f, -0.11611329f, 0.11370431f, -0.03099749f, -0.16483355f, 0.01772693f, 
    0.03401968f, -0.00504844f, 0.07900002f, 0.08222373f, -0.06331504f, 0.06858469f, -0.02317897f, 0.01265138f, 
    0.09027126f, -0.03139587f, 0.04482399f, 0.12305894f, 0.00698237f, -0.02940005f, -0.13709918f, 0.03194135f, 
    -0.14319365f, -0.17725965f, -0.01642782f, 0.08895047f, 0.40239295f, 0.36130813f, -0.10919557f, 0.05848752f, 
    -0.12227640f, -0.04124048f, 0.10200948f, 0.19018516f, 0.01263359f, -0.01444244f, -0.09198446f, -0.03598553f, 
    0.27524653f, -0.07448016f, 0.12114857f, 0.48934677f, -0.15890376f, -0.06714341f, -0.06479862f, 0.10944009f, 
    0.07707026f, 0.04207548f, -0.10992344f, -0.06629160f, -0.34920290f, 0.02785667f, -0.20967522f, 0.18699861f, 
    -0.12176315f, 0.12795044f, 0.02087885f, 0.12417509f, 0.02387136f, 0.08369224f, 0.04130960f, -0.01817062f, 
    0.29663107f, 0.29869500f, -0.05066262f, -0.07836790f, 0.02584960f, -0.11894380f, 0.13311020f, 0.03919534f, 
    -0.00403886f, 0.02607691f, 0.12663856f, -0.01910111f, 0.08728462f, 0.20245041f, 0.12171492f, -0.00364330f, 
    -0.07056786f, -0.16598824f, 0.05416324f, 0.05023583f, 0.02087488f, 0.03197799f, 0.05113721f, -0.10332310f, 
    -0.07353903f, -0.03091418f, -0.13403626f, -0.17566314f, -0.05215365f, 0.02193134f, 0.06120523f, -0.00069446f, 
    0.00415588f, -0.01597365f, -0.01241754f, -0.02499619f, 0.06269036f, -0.12243201f, -0.23248148f, -0.07109350f, 
    0.03318925f, 0.04788364f, 0.12079148f, -0.02619384f, -0.01007235f, 0.10580827f, -0.04705504f, 0.04981864f, 
    0.00215781f, 0.23080775f, -0.05845191f, 0.02168548f, 0.06193266f, 0.12654613f, -0.06782337f, 0.21180470f, 
    -0.03832785f, -0.01111654f, -0.00283704f, 0.01290099f, 0.18311681f, 0.18740390f, -0.09726733f, 0.17083107f, 
    -0.01565279f, -0.00723061f, 0.01038599f, 0.14650753f, 0.15960960f, -0.22808969f, -0.00574695f, -0.03735528f, 
    -0.00243145f, 0.32383218f, -0.33251846f, -0.18800883f, 0.03334507f, 0.19160897f, 0.05850851f, -0.04971250f, 
    0.21178563f, 0.08586188f, -0.07817063f, 0.18723015f, -0.27249077f, -0.17758718f, 0.00959351f, -0.26726139f, 
    0.01835486f, -0.10492532f, 0.03523599f, 0.00367928f, 0.11195190f, 0.05757488f, -0.01528540f, 0.10831142f, 
    0.27626663f, 0.09244509f, -0.08568828f, -0.05401153f, 0.01974036f, -0.01534767f, -0.03675942f, 0.26573816f, 
    -0.03217003f, -0.02470462f, 0.06497685f, 0.13711438f, -0.37292883f, 0.22169384f, -0.20243037f, 0.29577276f, 
    -0.14935565f, 0.07434794f, 0.01883274f, 0.20458995f, -0.01900280f, 0.05308091f, 0.07107962f, -0.01555721f, 
    -0.10245010f, -0.18456380f, 0.02408884f, 0.30995476f, 0.13100874f, 0.14418933f, -0.05328910f, -0.02614122f, 
    0.03964131f, 0.06142710f, 0.01899780f, 0.07699598f, -0.30807927f, 0.09748984f, 0.01460545f, -0.07173099f, 
    0.28457770f, -0.21307822f, 0.05527633f, -0.13179587f, 0.10028929f, -0.00788446f, 0.06693569f, 0.00589718f, 
    -0.09146083f, -0.20108294f, 0.08979330f, 0.04472984f, -0.02237270f, 0.13958022f, -0.06892484f, -0.13198791f, 
    0.01912375f, -0.02698609f, -0.06171665f, -0.03242914f, 0.20185044f, 0.09333444f, 0.41756168f, -0.10057976f, 
    0.13714142f, 0.05589074f, 0.05212495f, -0.11787803f, -0.11868176f, 0.05897284f, -0.01576368f, 0.10031036f, 
    0.09534980f, 0.26625106f, 0.28261271f, 0.16534814f, 0.20458227f, 0.03827735f, -0.01674428f, -0.00494285f, 
    0.09517890f, -0.06537010f, -0.22523016f, 0.19301209f, 0.22520500f, -0.13647141f, 0.15361494f, 0.04011403f, 
    0.02694397f, -0.10798477f, -0.08163011f, 0.08490130f, -0.08793440f, 0.07604737f, -0.13433605f, -0.02856306f, 
    0.10224572f, -0.19993065f, -0.22096908f, 0.25292310f, 0.09914692f, 0.03280973f, -0.05005924f, -0.10088125f, 
    0.02714480f, 0.04024243f, 0.08495127f, 0.05749544f, 0.26362190f, 0.35305911f, 0.10939986f, -0.02251239f, 
    0.07371774f, -0.16809623f, 0.03609771f, 0.17155668f, -0.06131451f, -0.07440902f, 0.01180761f, -0.06922493f, 
    0.57416868f, -0.21805708f, -0.02130544f, 0.04221190f, -0.05403957f, -0.06973509f, -0.12378191f, 0.09088095f, 
    0.11789589f, 0.18415257f, -0.07769375f, -0.07636070f, 0.07598649f, 0.00138151f, 0.11419678f, 0.02094732f, 
    0.12018335f, 0.03154422f, 0.01590171f, -0.16508420f, 0.05388347f, -0.01264213f, 0.00800878f, -0.23467252f, 
    -0.02893069f, 0.13566685f, 0.10330869f, -0.11231979f, 0.04268713f, 0.06670690f, -0.03087184f, 0.09249636f, 
    -0.00418015f, -0.08106752f, -0.06826463f, -0.13139130f, -0.18686904f, -0.16431315f, -0.13797581f, 0.20571630f, 
    0.10058635f, -0.12079765f, -0.09929401f, -0.26813489f, -0.08051446f, -0.01715706f, -0.02884026f, -0.04345259f, 
    0.04802845f, 0.06306250f, 0.05861827f, 0.06052155f, 0.20302945f, 0.15403214f, -0.33566844f, -0.06277847f, 
    -0.03403497f, -0.11597534f, 0.07316217f, 0.13101597f, 0.13038389f, -0.08902852f, 0.04504090f, -0.19240899f, 
    -0.05978236f, -0.14009973f, -0.07462242f, 0.13505170f, -0.08376610f, 0.02764588f, 0.18199174f, 0.20096199f, 
    0.25133285f, 0.36354139f, -0.13769606f, 0.10055826f, 0.08739924f, -0.22449619f, -0.05553579f, -0.06208161f, 
    -0.05037326f, -0.18498211f, 0.15372828f, -0.27348998f, -0.00286564f, -0.16780016f, -0.06125991f, 0.22550115f, 
    0.00250396f, 0.08578010f, 0.08165970f, -0.10750013f, -0.01343840f, 0.01467589f, 0.14340180f, 0.20126313f, 
    0.34047210f, 0.16323861f, 0.06642410f, -0.12206946f, 0.02607557f, -0.00447097f, -0.18775931f, -0.00603645f, 
    -0.10391764f, -0.01931682f, 0.19795868f, 0.00143604f, 0.14388686f, 0.09977540f, 0.17150873f, 0.01832693f, 
    -0.09485266f, 0.11660231f, 0.07232683f, 0.02839608f, 0.02300083f, 0.18585487f, -0.05989733f, -0.13018034f, 
    0.32816246f, -0.00178621f, 0.24816218f, -0.08514900f, -0.20465828f, 0.06015583f, 0.09574056f, -0.18989202f, 
    0.05312856f, 0.10197636f, -0.25286701f, 0.05330761f, 0.17644274f, 0.12802431f, 0.29171088f, 0.20156083f, 
    -0.04263563f, -0.05390752f, 0.23567197f, -0.12487422f, -0.03949483f, 0.01785323f, 0.05372549f, -0.25481242f, 
    -0.25941578f, -0.23146141f, 0.01744021f, 0.32958326f, 0.07869928f, -0.06534305f, -0.10909561f, -0.03080599f, 
    0.02911218f, 0.01566634f, 0.07833949f, -0.11942793f, 0.53983945f, -0.01612580f, -0.13715437f, 0.04430944f, 
    -0.21567549f, 0.04274363f, 0.11795686f, -0.07011338f, 0.02955109f, 0.15074214f, 0.04556520f, -0.05763875f, 
    0.38323185f, 0.21142413f, 0.25128609f, 0.10247732f, 0.04786311f, -0.14950714f, -0.17266107f, 0.05219311f, 
    -0.02182979f, -0.05331567f, -0.05285858f, -0.12152533f, -0.21536204f, 0.08486124f, 0.14370640f, 0.18878005f, 
    0.02665663f, -0.03667035f, 0.04836604f, 0.00497524f, 0.07038269f, -0.13968830f, -0.02262650f, -0.33626050f, 
    0.34578955f, -0.10723209f, -0.20928638f, -0.08014210f, 0.08754782f, -0.03036946f, -0.03400199f, -0.05654095f, 
    -0.04334791f, -0.11016956f, -0.18448815f, -0.05243677f, -0.13368143f, 0.25277874f, -0.20432217f, -0.31400323f, 
    -0.04023698f, -0.13067876f, -0.00380205f, 0.10295048f, 0.08231200f, 0.16642718f, 0.01581384f, 0.01052360f, 
    0.29039177f, 0.19819359f, 0.30840230f, 0.03487786f, -0.11167739f, 0.02154516f, 0.01948876f, 0.11319453f, 
    -0.03465651f, 0.05001471f, -0.02421773f, -0.05500570f, 0.08446600f, 0.15860616f, 0.34055188f, 0.28639805f, 
    0.02687527f, 0.14213102f, -0.03571187f, 0.12268496f, 0.20927152f, -0.12861764f, -0.04533369f, -0.04157427f, 
    -0.30983809f, 0.07013259f, 0.00229910f, -0.08224417f, 0.07672235f, 0.15137461f, -0.12782304f, 0.05754059f, 
    0.17448370f, 0.22726862f, -0.00457213f, 0.12312955f, 0.16276647f, 0.27794755f, -0.14417958f, -0.21431291f, 
    0.09534445f, 0.00410996f, 0.05217544f, -0.08197126f, -0.07584793f, 0.04680462f, 0.01708206f, 0.20916939f, 
    0.34446034f, -0.02477217f, 0.09176777f, 0.16019590f, -0.18321514f, -0.16027898f, 0.00945516f, 0.02208258f, 
    0.02233309f, -0.00005424f, 0.13491723f, 0.25178927f, 0.42060569f, -0.08086319f, -0.05757348f, 0.16229708f, 
    0.06853983f, -0.00066872f, -0.07691400f, 0.05093741f, 0.01695168f, 0.00475643f, -0.02218604f, -0.18836975f, 
    0.05427837f, 0.06123973f, 0.08337782f, 0.06181613f, 0.03858261f, 0.07491270f, -0.02072458f, 0.04042545f, 
    0.02061052f, 0.03388535f, -0.02472652f, 0.04070326f, -0.11294248f, -0.08012398f, 0.00617596f, -0.11760255f, 
    -0.01286397f, 0.07136707f, 0.09989419f, 0.04800849f, 0.06627520f, 0.02503971f, -0.00540362f, -0.02694103f, 
    0.38822559f, -0.21940711f, 0.14469101f, 0.01264977f, -0.09270927f, 0.11417195f, -0.11706445f, 0.07792592f, 
    -0.01572695f, -0.02925391f, 0.02989851f, 0.13034891f, -0.08960655f, -0.18446182f, 0.14754656f, -0.06059622f, 
    -0.01282468f, -0.10186375f, 0.13371839f, 0.04612015f, -0.07419779f, -0.02184984f, 0.12198504f, 0.21969298f, 
    -0.13161421f, 0.02262292f, -0.04870870f, -0.13719383f, 0.01468739f, -0.20372629f, -0.03707189f, 0.08122823f, 
    0.05604315f, -0.01985301f, 0.02288956f, 0.10846902f, 0.04535601f, 0.11911975f, -0.10828841f, 0.27051258f, 
    0.00045227f, 0.14495601f, 0.08535413f, 0.05748288f, 0.09612717f, -0.02646691f, -0.07529534f, 0.11067171f, 
    -0.06890196f, 0.23199260f, 0.17433339f, 0.15660474f, 0.12161560f, -0.07075059f, 0.04443001f, 0.00898908f, 
    0.05594785f, 0.12949012f, 0.00316978f, 0.04422242f, -0.05906316f, -0.05281575f, 0.09072652f, -0.13639171f, 
    0.15017569f, -0.07432487f, 0.02115745f, 0.09513461f, 0.03137777f, 0.06447613f, -0.01161743f, 0.06311856f, 
    -0.18110280f, 0.10028944f, -0.15907221f, -0.09231029f, -0.00533726f, 0.09990172f, 0.03789255f, 0.01668484f, 
    0.02537328f, -0.00537916f, -0.03808698f, 0.02483000f, 0.45510671f, 0.15836047f, -0.01563912f, 0.21027908f, 
    -0.06833179f, 0.02367046f, 0.04036167f, -0.00170039f, 0.01494351f, 0.10958596f, 0.14213252f, -0.03910189f, 
    0.16119678f, -0.29780492f, -0.02463102f, -0.22171926f, 0.03147877f, 0.11018682f, 0.22480264f, 0.18124843f, 
    -0.03545316f, 0.10061448f, 0.09034999f, 0.09908146f, -0.12601981f, 0.02279137f, -0.13373348f, 0.17608422f, 
    -0.03384120f, -0.01873064f, 0.12832849f, 0.12458005f, 0.01030085f, -0.02965651f, 0.08460325f, 0.03731460f, 
    0.01734951f, 0.20059782f, -0.15383911f, -0.44978866f, 0.03411966f, 0.07081523f, -0.00481083f, -0.07494143f, 
    0.12422051f, 0.07804731f, -0.03364123f, 0.00530613f, -0.47928479f, -0.23004510f, -0.02986438f, 0.03665497f, 
    0.08996626f, -0.02243374f, -0.02567006f, 0.04529242f, -0.07279512f, 0.08048647f, 0.00786099f, 0.15275751f, 
    -0.01076007f, 0.10970619f, -0.00696815f, -0.00895462f, 0.03114601f, 0.00422471f, 0.06224686f, -0.08397141f, 
    0.08847830f, 0.02989659f, 0.09240713f, -0.02750381f, -0.04878497f, 0.04094721f, 0.31077245f, 0.17151321f, 
    -0.01678718f, 0.16811971f, 0.02751695f, -0.02612716f, 0.01460790f, -0.03534651f, 0.08385818f, 0.08794314f, 
    -0.12485051f, -0.02756869f, 0.02235414f, -0.04993043f, 0.01487294f, 0.05507178f, -0.06107713f, 0.17908444f, 
    0.07132426f, 0.02609280f, 0.12866691f, 0.04350720f, 0.08341336f, 0.01221575f, -0.05751018f, -0.08487043f, 
    0.09260949f, -0.04244751f, 0.03770999f, 0.02212502f, -0.05779320f, 0.08381481f, -0.07247093f, 0.01110442f, 
    -0.01129034f, -0.00471460f, -0.08828411f, 0.01448413f, -0.04239019f, -0.00876347f, -0.01825362f, -0.01470652f, 
    -0.11360552f, -0.13610545f, -0.07553190f, -0.05824104f, 0.22112998f, 0.17924772f, 0.05738159f, -0.01820867f, 
    -0.14466797f, -0.03554558f, -0.06333061f, 0.03096356f, -0.09948018f, -0.04608614f, 0.05170320f, -0.03706960f, 
    0.41561839f, -0.28361690f, 0.19340152f, 0.37350091f, 0.04186083f, 0.07854512f, -0.02166115f, -0.07119163f, 
    0.09983023f, 0.06586923f, -0.04258895f, -0.02637361f, 0.08228377f, 0.05900885f, 0.08232716f, 0.19882408f, 
    -0.07314985f, 0.11027597f, -0.04097623f, -0.01479135f, 0.02467836f, 0.07601683f, 0.02573978f, 0.05192447f, 
    -0.04548907f, -0.02226549f, -0.23449980f, -0.06837887f, 0.05011929f, 0.00107138f, -0.12862723f, 0.05009614f, 
    0.15471219f, 0.04963434f, -0.04038865f, -0.05697516f, 0.12532538f, -0.01941448f, -0.05553996f, -0.35379285f, 
    -0.03735708f, -0.14076996f, 0.00322323f, 0.12398338f, 0.15049136f, 0.07803540f, 0.02887839f, -0.10755578f, 
    -0.09082419f, 0.15827800f, -0.05111742f, 0.15228932f, -0.07662481f, -0.02895888f, 0.15585613f, 0.03931896f, 
    -0.02782319f, -0.10705463f, -0.13106744f, -0.02771512f, 0.08401947f, 0.18704225f, -0.07542667f, -0.15120414f, 
    -0.05500151f, -0.03598513f, 0.12387940f, 0.00850350f, 0.01928312f, 0.07802211f, 0.02619655f, 0.01529296f, 
    0.03515522f, 0.05439974f, -0.14315215f, 0.05140951f, -0.06317123f, 0.05276987f, 0.13663149f, -0.00564147f, 
    -0.01567627f, -0.02591944f, -0.04994817f, 0.01928519f, -0.05672564f, -0.11042619f, 0.01110451f, -0.02708788f, 
    0.04490726f, 0.08320177f, -0.11922735f, 0.03369920f, 0.03880354f, -0.08386254f, 0.00189193f, 0.19556645f, 
    0.04798160f, 0.28070170f, -0.34357420f, -0.30938604f, 0.04722455f, 0.07208908f, 0.06277721f, -0.17055531f, 
    0.13743626f, 0.00832833f, -0.01566705f, 0.03229020f, -0.01269360f, 0.10741345f, -0.16370529f, -0.14942564f, 
    -0.18656734f, -0.15896587f, -0.04718959f, -0.03631935f, -0.00989292f, 0.04412237f, -0.00344717f, 0.00954751f, 
    0.28389025f, -0.16880539f, -0.14060473f, -0.04593009f, -0.08388925f, 0.07169119f, -0.06837061f, 0.13032240f, 
    -0.06522483f, -0.03757213f, 0.07136880f, 0.06672741f, 0.15146291f, 0.08704460f, 0.07651457f, 0.36969671f, 
    -0.10813802f, 0.10389430f, 0.04716274f, 0.01987188f, 0.02838124f, -0.05274801f, 0.06286748f, -0.06647348f, 
    0.01159728f, 0.00176786f, -0.01635495f, -0.05578830f, -0.01390191f, 0.01448502f, -0.03042247f, 0.02259661f, 
    -0.04366365f, -0.06008063f, -0.03570965f, -0.02920157f, -0.03711887f, -0.03644302f, 0.02156268f, 0.02604786f, 
    0.02074999f, 0.00625762f, 0.02294401f, 0.02164518f, -0.04292482f, -0.05743871f, -0.04551404f, 0.03428303f, 
    0.03788152f, -0.00795863f, -0.03915936f, 0.02298309f, 0.01647832f, -0.03460213f, -0.04817202f, 0.01908738f, 
    -0.02486913f, -0.02439625f, -0.04238717f, -0.00228036f, 0.04375283f, -0.03285604f, -0.04107476f, 0.06014448f, 
    0.00717723f, -0.05465860f, -0.02947327f, -0.01345598f, 0.01343653f, -0.04540176f, -0.03063149f, -0.03803667f, 
    -0.01440182f, 0.01449345f, 0.01662860f, 0.02375166f, 0.02936591f, -0.05936765f, 0.00825689f, -0.01515540f, 
    -0.01097070f, -0.03688167f, -0.04373188f, 0.00080396f, 0.05020766f, -0.02417629f, -0.00532561f, 0.00384023f, 
    -0.00494911f, 0.03735261f, -0.01156327f, -0.01936407f, 0.02860981f, 0.02120026f, 0.00364935f, 0.02988274f, 
    -0.01507639f, 0.00514584f, -0.01466989f, -0.01784663f, -0.02637531f, 0.01938375f, -0.00169122f, 0.02426784f, 
    -0.04101323f, 0.04117197f, 0.00681318f, 0.03103404f, -0.03039567f, 0.04807779f, -0.04615382f, -0.05342910f, 
    -0.05838867f, -0.05274535f, 0.02284360f, 0.01259633f, 0.02385482f, -0.01780033f, 0.02529251f, 0.00060806f, 
    -0.04207560f, 0.02059482f, -0.02675378f, -0.05617340f, -0.05626432f, -0.01733140f, 0.03909205f, -0.00946903f, 
    0.03439941f, 0.03631894f, -0.05526887f, -0.03048655f, -0.06253392f, -0.06384838f, -0.05356223f, -0.02128748f, 
    0.04510344f, -0.03264716f, -0.02971969f, -0.01066421f, -0.03178065f, -0.04667691f, -0.00330322f, 0.02961357f, 
    0.02661443f, 0.04224615f, -0.02856905f, 0.00677436f, -0.06025365f, -0.01987866f, 0.02785215f, -0.03737417f, 
    -0.03379736f, 0.02178410f, 0.02239511f, -0.04463607f, 0.00803273f, 0.02153598f, -0.03399332f, -0.05708945f, 
    -0.05555475f, 0.00541568f, 0.00460581f, 0.04046885f, -0.05673139f, 0.03129940f, -0.02245442f, -0.02819931f, 
    0.02511644f, -0.03162938f, 0.03100234f, -0.05014404f, -0.00946837f, -0.02852877f, 0.01110491f, 0.02507756f, 
    -0.01179846f, -0.04320250f, 0.04345136f, -0.00535438f, 0.04895019f, -0.02003163f, -0.00626603f, 0.04244124f, 
    0.01559777f, -0.06029740f, -0.03381449f, -0.05383268f, -0.00479471f, 0.03589778f, 0.01461693f, -0.02749423f, 
    0.03365608f, 0.00753250f, 0.03264484f, 0.03240702f, -0.00725577f, -0.04368713f, 0.03792910f, -0.00859871f, 
    -0.02079480f, -0.03735719f, 0.02132161f, -0.00905496f, -0.00092793f, -0.05546723f, -0.04828746f, -0.01132171f, 
    -0.04116391f, 0.03264038f, -0.01660520f, 0.03954748f, -0.02935793f, 0.02352027f, 0.00000470f, 0.04242605f, 
    -0.02134434f, -0.03384979f, 0.03050427f, 0.03240351f, -0.02319384f, -0.05467812f, -0.02809653f, -0.05146760f, 
    -0.00096045f, 0.03888395f, -0.02229773f, -0.01604127f, -0.01580192f, -0.04237514f, 0.01805081f, -0.01084740f, 
    -0.04269562f, -0.03120120f, -0.04526229f, 0.02291443f, -0.04133750f, 0.00319260f, 0.01488328f, 0.00897205f, 
    -0.03501516f, -0.04149708f, -0.04153376f, 0.02381776f, -0.02048770f, 0.02921479f, 0.03269441f, 0.00060810f, 
    0.02634430f, -0.00315132f, -0.02175914f, -0.03882800f, -0.01375911f, 0.00844762f, -0.04365034f, 0.04161748f, 
    -0.00574193f, 0.02866151f, -0.00450866f, 0.00453498f, -0.00653778f, -0.01083957f, -0.00610663f, -0.02353527f, 
    0.03089770f, 0.01824826f, 0.00885892f, 0.02302428f, 0.03191440f, 0.02756571f, -0.03230217f, 0.03315016f, 
    -0.00323801f, 0.02744944f, 0.00564895f, -0.04729273f, -0.01782512f, -0.02111052f, -0.01377479f, 0.00488030f, 
    0.02978497f, 0.02013152f, 0.04209882f, -0.00257749f, -0.01722006f, -0.04178331f, -0.03893744f, -0.03432430f, 
    0.04257912f, 0.04357980f, 0.03742659f, -0.02169029f, 0.03776208f, 0.03055517f, 0.02523643f, 0.02000285f, 
    -0.00990778f, -0.01095910f, -0.04903550f, 0.00919280f, -0.03700270f, 0.00426303f, -0.04058011f, -0.00681680f, 
    -0.02864001f, -0.05189498f, 0.02185964f, 0.00760409f, -0.03209618f, 0.02758031f, -0.03592036f, 0.02526271f, 
    -0.05190897f, 0.03579000f, 0.02591279f, -0.04285710f, 0.00102138f, -0.01425805f, 0.03824099f, -0.01219514f, 
    -0.05914332f, 0.00096591f, 0.03139541f, -0.01444894f, 0.00673776f, -0.00097104f, -0.04923904f, -0.00983346f, 
    -0.04801285f, -0.00560913f, 0.03474714f, -0.05480074f, -0.03546061f, -0.00395001f, 0.03270384f, -0.05142562f, 
    0.03202450f, 0.00150755f, -0.01314287f, 0.03872219f, 0.00918692f, -0.00993296f, -0.03543252f, 0.02214460f, 
    -0.02869718f, -0.03651171f, 0.02174626f, -0.01591133f, -0.04163275f, -0.02653135f, 0.05210637f, 0.04913730f, 
    -0.01686042f, -0.03115376f, -0.01501269f, 0.04588128f, 0.01802363f, 0.04476032f, -0.03376077f, 0.01982398f, 
    0.02953853f, -0.03440934f, 0.01079432f, 0.01334631f, -0.00324054f, 0.01904963f, -0.00986729f, 0.03541504f, 
    -0.04647167f, -0.03174755f, -0.03647603f, -0.00223391f, 0.00345126f, 0.00933405f, -0.02073264f, 0.01836886f, 
    0.03664973f, -0.01546834f, 0.01358254f, -0.00512096f, 0.04018255f, -0.01945057f, 0.03271443f, -0.04378265f, 
    0.02343388f, -0.01774148f, -0.01719040f, 0.02989031f, -0.00144037f, 0.02781641f, 0.02517817f, 0.00291976f, 
    0.01202791f, 0.01645344f, 0.00329585f, 0.03624864f, 0.02917529f, -0.01747958f, 0.03816196f, -0.01255046f, 
    0.03096216f, -0.00944812f, -0.03067632f, -0.00230968f, -0.00710084f, 0.00736461f, 0.04130999f, -0.04275756f, 
    0.04346116f, -0.22846542f, 0.10416484f, 0.22028726f, 0.12128839f, 0.10568281f, 0.20438075f, -0.07777502f, 
    -0.01774804f, 0.00265351f, -0.01068319f, 0.12151297f, 0.00562286f, 0.12433697f, 0.06896451f, 0.30584863f, 
    0.15453786f, -0.10217527f, 0.16117848f, -0.10831740f, 0.11034878f, 0.12024551f, -0.06195638f, 0.09794143f, 
    -0.03807035f, -0.28899145f, 0.08340670f, -0.28544682f, 0.07661789f, 0.17005299f, 0.07124675f, -0.08703851f, 
    0.15621948f, -0.08862062f, -0.05196002f, 0.17356552f, 0.13927086f, 0.16526756f, -0.10097576f, -0.16589440f, 
    0.19888830f, 0.04563266f, -0.11562174f, -0.16980653f, 0.08837851f, 0.12305225f, -0.14528529f, 0.03589433f, 
    -0.08208647f, -0.08211622f, -0.00470309f, 0.18511958f, 0.08016400f, 0.13761684f, -0.15093067f, -0.03671747f, 
    0.01049161f, 0.09106731f, -0.20511511f, 0.09024689f, 0.02335642f, 0.01160574f, 0.00369785f, -0.28419077f, 
    0.09595070f, -0.13093036f, 0.01533687f, -0.05710601f, -0.04080293f, 0.12819065f, -0.03630758f, -0.02898119f, 
    0.03274393f, -0.05695554f, -0.02159498f, -0.02451432f, 0.19562656f, -0.01084678f, -0.00260725f, -0.17158070f, 
    -0.16376290f, 0.10743752f, 0.03704273f, 0.27330810f, -0.02707365f, -0.11181428f, -0.09220941f, 0.15186611f, 
    -0.03319165f, -0.06160209f, 0.00985030f, -0.02997789f, 0.03803903f, -0.08687391f, 0.06533489f, -0.18684708f, 
    0.20086704f, -0.07393610f, -0.09366382f, -0.05433452f, 0.00830644f, 0.00997808f, -0.04471525f, 0.25704834f, 
    0.05444678f, 0.12396373f, 0.04219957f, 0.02319588f, -0.22588643f, -0.07319185f, 0.17297223f, -0.12734215f, 
    0.04987621f, 0.12897304f, -0.06676496f, 0.01584925f, -0.02920981f, 0.13917893f, -0.04676716f, -0.09957516f, 
    -0.10047919f, 0.04689825f, 0.02189556f, 0.15306900f, 0.08651505f, -0.14427519f, -0.12693571f, -0.03506944f, 
    0.12752828f, 0.05406266f, -0.11625668f, -0.03399849f, -0.13368890f, -0.21716848f, 0.17691839f, -0.11651076f, 
    0.20459923f, -0.06653975f, -0.28229132f, -0.17333846f, -0.06425458f, -0.01105568f, -0.07654279f, -0.00802339f, 
    -0.14142258f, -0.06220611f, 0.05623773f, 0.34944981f, 0.11469559f, 0.19718008f, -0.00992542f, 0.09356497f, 
    0.06850145f, -0.13366336f, 0.02478062f, 0.12229388f, 0.22152846f, 0.21849048f, 0.08458962f, -0.17257769f, 
    0.03127410f, -0.08497752f, -0.00185252f, 0.15913281f, -0.00236120f, 0.04636988f, 0.06739700f, 0.16156119f, 
    -0.45883796f, -0.02212370f, -0.26198807f, -0.08018183f, 0.03299468f, -0.15258889f, -0.11878837f, -0.03501881f, 
    -0.18461147f, -0.17293195f, 0.10177507f, -0.18686198f, 0.24376357f, -0.03215151f, -0.01433293f, 0.02066584f, 
    0.05989943f, 0.07657627f, 0.10705057f, -0.03451461f, 0.04257781f, 0.10714626f, 0.16923703f, 0.13841857f, 
    0.21279506f, 0.30273908f, -0.08802684f, 0.03374457f, 0.01143891f, 0.03636085f, -0.04325382f, -0.08826376f, 
    0.08336890f, -0.14854014f, 0.18344150f, 0.07970564f, 0.00392282f, -0.13631944f, -0.10698499f, -0.12571876f, 
    -0.15519316f, 0.06389482f, 0.11400101f, 0.06356468f, 0.19257008f, 0.14122331f, -0.09410986f, -0.04890477f, 
    0.00214791f, -0.07370675f, -0.04564948f, 0.02988400f, -0.03849668f, 0.06416488f, 0.20336847f, 0.05604920f, 
    0.00859010f, 0.03154894f, -0.13753669f, 0.11998406f, -0.14004058f, -0.11139751f, -0.05322026f, -0.01338558f, 
    0.01801328f, -0.02759524f, 0.09084257f, -0.11518489f, 0.00330360f, 0.07890299f, -0.07618380f, 0.05740888f, 
    -0.34025526f, 0.05446751f, -0.09574489f, -0.17998961f, 0.05295559f, -0.06943054f, 0.13154382f, -0.04379469f, 
    -0.06782712f, 0.00250807f, 0.08845878f, 0.12286834f, 0.30496475f, 0.21632287f, -0.23180376f, -0.12757878f, 
    0.05690007f, -0.13068654f, 0.11964205f, 0.04525734f, 0.14746234f, -0.04249822f, -0.08682959f, -0.00112048f, 
    0.07645774f, -0.00502398f, 0.05814354f, -0.07407188f, -0.08393156f, -0.03814965f, 0.00606374f, -0.14221458f, 
    0.05268597f, -0.22533585f, -0.02838490f, -0.15017988f, 0.04073809f, 0.03515057f, -0.01450129f, 0.21348776f, 
    0.06067891f, 0.22389433f, -0.02393740f, -0.16366455f, 0.13748874f, -0.05467663f, 0.05086891f, -0.07641979f, 
    0.35776103f, -0.18808159f, -0.09261970f, -0.05999014f, 0.09984239f, 0.01231771f, -0.08538340f, 0.04149617f, 
    -0.10057580f, -0.08538139f, -0.13637072f, -0.00987003f, -0.11235606f, -0.31983319f, -0.10993098f, 0.04901830f, 
    0.13009489f, 0.08121031f, 0.03554865f, 0.10024043f, 0.17157115f, 0.08637670f, 0.11877064f, 0.00103508f, 
    0.07713510f, 0.03734742f, 0.21426336f, 0.05329989f, 0.06100085f, -0.04576895f, -0.00676702f, 0.15004921f, 
    -0.02634346f, -0.07837648f, 0.15837994f, 0.10840604f, 0.09759291f, 0.02417263f, 0.08699354f, 0.10597584f, 
    0.05267956f, 0.12059923f, -0.01856784f, -0.09448384f, 0.15153463f, -0.10678499f, -0.02752401f, -0.11235960f, 
    -0.25077394f, -0.03915297f, 0.00991656f, 0.31717175f, -0.00158294f, 0.13025855f, -0.08513736f, 0.14076875f, 
    0.04548879f, 0.10381604f, 0.09943046f, 0.02229470f, 0.36781815f, 0.21006835f, -0.06656924f, 0.04463226f, 
    0.09422543f, 0.01316422f, 0.07443097f, -0.02675588f, 0.08195514f, 0.13181074f, 0.01918569f, 0.19026469f, 
    0.15667285f, -0.11217821f, -0.03238528f, 0.02558093f, -0.10882785f, 0.00177608f, 0.03568905f, -0.07387382f, 
    -0.03255774f, -0.00525081f, 0.01430445f, 0.23567499f, 0.15967953f, 0.01579121f, -0.04699340f, -0.30550575f, 
    0.18193035f, -0.04793521f, -0.17339048f, 0.13310085f, 0.00399394f, 0.07667854f, 0.12560453f, -0.16328697f, 
    -0.19194460f, 0.08918226f, -0.02624070f, -0.05792108f, -0.02354107f, 0.02094362f, 0.13089103f, -0.00157054f, 
    0.05362192f, -0.01202956f, -0.03981133f, 0.03516322f, -0.09586529f, 0.30731386f, 0.09109323f, 0.07416513f, 
    0.11483259f, 0.04918841f, 0.02325713f, -0.07843135f, -0.07608964f, 0.03392608f, 0.02984901f, 0.09954561f, 
    -0.17108199f, 0.17811705f, -0.13865423f, -0.28160220f, 0.21378359f, -0.02052642f, 0.06258573f, -0.02937368f, 
    0.00701405f, 0.10938539f, 0.08643206f, -0.07325430f, 0.10171697f, 0.04556430f, -0.20571621f, 0.02732440f, 
    0.10087958f, 0.20070536f, -0.10166919f, -0.05783413f, 0.05685502f, 0.02306848f, -0.14229405f, -0.00668951f, 
    0.23853487f, -0.42094684f, -0.05483352f, 0.21447316f, -0.04238787f, 0.17748792f, 0.06772067f, -0.10698173f, 
    -0.00350516f, 0.11426225f, -0.08966092f, -0.01321113f, 0.25832638f, -0.07130789f, 0.01288451f, -0.17049865f, 
    -0.01938940f, 0.02896513f, -0.05749878f, -0.05710809f, 0.01764180f, 0.03229748f, 0.08936593f, 0.02101197f, 
    0.19830543f, 0.17725863f, -0.06538028f, -0.16338773f, -0.01258349f, 0.08727871f, -0.05323167f, -0.06358795f, 
    0.04211890f, -0.01511278f, -0.08834867f, 0.09085344f, 0.14739361f, -0.13262686f, 0.00875973f, 0.13231649f, 
    -0.07376025f, 0.16160806f, -0.06740422f, -0.01340616f, 0.02333788f, -0.02978660f, 0.06917182f, -0.05037499f, 
    0.46143401f, -0.16225883f, -0.12336473f, 0.09662335f, 0.03677654f, -0.05960537f, 0.07608322f, 0.09980160f, 
    0.11902432f, 0.05078283f, 0.05764482f, -0.14472243f, -0.29193649f, -0.26590511f, 0.28368896f, 0.01559765f, 
    0.07460702f, 0.13229740f, 0.02110192f, 0.05072224f, 0.05016071f, 0.09012105f, -0.07842565f, 0.11609025f, 
    -0.21846196f, 0.30308503f, -0.03117373f, 0.28951111f, 0.07622651f, -0.13782986f, -0.08191763f, -0.07043329f, 
    0.02938436f, -0.22094865f, -0.03844567f, 0.00871995f, 0.24734926f, 0.09018234f, 0.28654569f, -0.22634611f, 
    0.08435733f, 0.07734273f, -0.12645343f, -0.09898775f, 0.07128760f, 0.14495704f, -0.10361344f, -0.07103112f, 
    0.03288115f, -0.31884572f, -0.02314508f, 0.34105387f, 0.02088118f, 0.04844892f, 0.03922803f, 0.03616775f, 
    -0.03976873f, -0.05615547f, 0.11832456f, 0.08456061f, 0.56057942f, 0.07514319f, 0.02092860f, -0.30374968f, 
    -0.04946014f, 0.04056464f, 0.02981293f, 0.01746528f, 0.14657649f, -0.06107444f, -0.05642487f, -0.00381325f, 
    0.54207605f, -0.23458035f, -0.04792005f, 0.12548812f, -0.02777553f, 0.01662051f, 0.08208532f, 0.00318067f, 
    -0.10384954f, 0.03167174f, 0.04346344f, 0.01495377f, 0.16644537f, 0.30720684f, -0.14846586f, -0.34184796f, 
    0.21694091f, -0.06682034f, -0.03421500f, -0.09487084f, -0.01340306f, 0.10292138f, -0.00508743f, -0.09500468f, 
    0.00883036f, -0.01054267f, -0.07831169f, 0.09527314f, 0.03075313f, 0.10523118f, 0.01512583f, -0.09249978f, 
    -0.06265128f, -0.09738188f, 0.02685413f, -0.04832063f, 0.01256273f, -0.02798876f, 0.19575322f, 0.04790017f, 
    -0.10915034f, 0.02660507f, -0.10760591f, 0.00404274f, 0.02090569f, 0.02757727f, -0.00061183f, 0.16027488f, 
    -0.03984101f, 0.05574119f, -0.10654855f, -0.09590932f, 0.02589400f, 0.06745435f, 0.08779687f, 0.02064938f, 
    0.24633712f, 0.12662548f, 0.07884947f, -0.05829924f, -0.21980515f, -0.19003886f, 0.04184194f, -0.02173307f, 
    0.08358435f, 0.02362916f, 0.11252209f, -0.10005038f, 0.01672965f, 0.09197067f, -0.04170714f, -0.03446399f, 
    -0.40988392f, 0.53672856f, -0.11527374f, -0.49681070f, -0.00911457f, -0.10491578f, 0.06336129f, 0.11957949f, 
    -0.07742560f, 0.08815416f, 0.10450216f, 0.16169168f, 0.27241489f, -0.02537640f, 0.00075698f, -0.02644614f, 
    0.12022633f, -0.07972235f, 0.06959924f, 0.04471261f, 0.03514345f, 0.02233518f, 0.05547053f, 0.06091486f, 
    0.18630534f, -0.20732155f, 0.29887068f, -0.00940303f, -0.03552301f, 0.04152671f, -0.00278286f, -0.04892344f, 
    -0.06161293f, -0.11877339f, 0.02331353f, 0.13944946f, -0.23055530f, -0.18454559f, -0.07187817f, 0.14150017f, 
    0.16005178f, 0.22666895f, 0.06017652f, -0.21171044f, -0.07137450f, -0.04659143f, 0.04674980f, 0.06397793f, 
    0.34357297f, -0.04948290f, 0.30004269f, 0.10695882f, 0.08355258f, -0.03362520f, -0.03458562f, 0.03831266f, 
    0.03450511f, 0.06731243f, 0.06873063f, 0.08197651f, -0.19859129f, -0.18751478f, 0.15884155f, 0.09650508f, 
    0.09251001f, 0.02800201f, -0.04198648f, -0.01407246f, 0.03038098f, -0.00034118f, 0.01834180f, 0.01397575f, 
    0.02012744f, -0.14925729f, 0.30949357f, 0.09763040f, 0.04355499f, 0.03469559f, 0.00796423f, 0.03020212f, 
    0.08802778f, 0.04386711f, 0.09226172f, 0.02112127f, -0.07513075f, 0.03277747f, 0.06495669f, 0.03071594f, 
    -0.00621348f, -0.03752461f, -0.00280443f, -0.02638033f, -0.02923879f, 0.08948226f, -0.00347434f, -0.04155394f, 
    -0.07125523f, -0.42974547f, 0.27440551f, 0.29303551f, -0.02491649f, 0.03348991f, 0.04321535f, 0.06962331f, 
    -0.07079974f, 0.03505641f, 0.08177403f, -0.01528871f, 0.22645096f, 0.24361110f, 0.09667899f, 0.23610871f, 
    0.24639921f, 0.14722535f, 0.07461734f, 0.01224987f, 0.03450489f, -0.04897924f, 0.06571034f, 0.04494180f, 
    -0.04210786f, -0.11227312f, 0.11355438f, 0.08495064f, 0.04176876f, 0.06454642f, 0.07567047f, -0.09588847f, 
    0.10280289f, 0.00415504f, -0.03333436f, 0.00627803f, 0.45365065f, -0.22685960f, 0.09931985f, -0.27514762f, 
    0.20209293f, -0.08458851f, 0.00069083f, -0.06535110f, -0.00049000f, 0.09987147f, 0.02471749f, 0.09112768f, 
    0.22543310f, -0.13976656f, -0.00470579f, -0.02262552f, 0.05441264f, 0.01970548f, 0.04636331f, 0.00568599f, 
    -0.03784432f, 0.10166181f, 0.02311195f, 0.01530025f, 0.33496609f, -0.09042304f, -0.04677464f, -0.09835607f, 
    0.00902973f, 0.01004504f, -0.03268855f, -0.03562892f, -0.04032943f, 0.04663419f, 0.00097517f, -0.05392964f, 
    -0.01021858f, 0.23310345f, -0.04686306f, -0.03501137f, 0.15448691f, -0.05651109f, 0.01168425f, 0.04264243f, 
    -0.11771636f, 0.06205212f, 0.00665217f, 0.08391406f, 0.12943751f, 0.00636896f, -0.03371692f, -0.02365787f, 
    -0.15567379f, -0.14269684f, -0.02616759f, -0.13770385f, -0.13493662f, -0.02675009f, -0.06640788f, 0.05789712f, 
    -0.51788956f, -0.16417859f, 0.07543597f, -0.09558102f, 0.08287733f, 0.05628721f, 0.02415179f, 0.22880185f, 
    0.01769627f, 0.03066326f, -0.01817944f, -0.16379011f, 0.41241312f, 0.08955976f, 0.01535486f, 0.30990067f, 
    -0.04475727f, 0.02307262f, 0.06498522f, 0.05812469f, 0.02397531f, 0.05980606f, 0.07960249f, 0.03804216f, 
    -0.07214064f, 0.00204490f, 0.07282857f, 0.02583685f, 0.10732612f, 0.02830035f, 0.08273448f, -0.05056242f, 
    -0.02065718f, -0.01364936f, -0.10066224f, 0.01836436f, -0.45218661f, -0.14183816f, 0.05393974f, 0.01875901f, 
    0.05730158f, 0.01515583f, -0.01135236f, -0.01184570f, 0.01824278f, -0.03993668f, 0.01592757f, 0.01050790f, 
    0.09439404f, 0.22400394f, -0.06083895f, 0.19970110f, -0.12591469f, 0.02435447f, 0.05403482f, -0.07202487f, 
    0.06238392f, -0.15612157f, -0.05895898f, 0.05444106f, 0.16059765f, 0.00200817f, -0.05072978f, -0.10152682f, 
    -0.05926434f, -0.01654654f, 0.01999369f, 0.00206274f, 0.03271465f, 0.07811027f, 0.22699219f, 0.15283218f, 
    0.21683440f, -0.15866935f, 0.07683349f, 0.01225544f, 0.02745002f, 0.07398428f, -0.01922925f, 0.18542176f, 
    -0.08346171f, 0.06294862f, -0.03465256f, 0.13164005f, -0.14608559f, -0.03279760f, -0.11694462f, 0.13113557f, 
    0.02808424f, -0.00748580f, -0.00316425f, 0.02300694f, 0.02794155f, -0.02042520f, 0.08167599f, 0.01059320f, 
    0.04124893f, -0.02289825f, -0.13651434f, -0.17158486f, 0.01828335f, 0.13621074f, 0.02671995f, 0.21924827f, 
    0.03623050f, 0.09507374f, -0.00345536f, 0.06078822f, -0.23948422f, 0.16596234f, 0.17059590f, -0.00353234f, 
    0.01192859f, -0.06541090f, -0.00795989f, -0.08506156f, -0.02728664f, 0.05206871f, 0.02756224f, 0.04008655f, 
    -0.50226903f, -0.03436305f, 0.05270432f, -0.27522475f, -0.02010997f, 0.14010434f, -0.04526536f, 0.02934337f, 
    0.08255216f, 0.05455719f, -0.03578315f, 0.13594383f, 0.13412605f, -0.15284516f, -0.09765223f, -0.03290642f, 
    -0.02717453f, 0.15432741f, 0.00551545f, -0.05624920f, -0.14622727f, -0.04021045f, 0.06875210f, -0.13591725f, 
    -0.09006849f, 0.13537441f, -0.06518351f, -0.00427550f, -0.07320283f, -0.08649839f, -0.03734815f, 0.06037971f, 
    -0.04444784f, 0.18249206f, -0.01606472f, -0.00224214f, -0.05781060f, 0.07971177f, 0.06761398f, -0.10714611f, 
    0.16586937f, -0.03873437f, -0.06693783f, -0.12074619f, 0.16300295f, -0.04930054f, 0.08843907f, 0.00045454f, 
    0.30314362f, -0.13859549f, 0.08197778f, 0.38701016f, -0.03847404f, -0.07513697f, -0.03380084f, 0.03158082f, 
    0.01373797f, -0.06828093f, 0.01200941f, 0.00182071f, 0.12593764f, 0.08434401f, -0.03214298f, -0.06326178f, 
    -0.20936401f, 0.01412452f, -0.12740843f, 0.00177820f, -0.00476029f, -0.07876139f, 0.10800528f, 0.06504374f, 
    0.01513785f, -0.23342578f, -0.01318832f, -0.14233340f, 0.07436354f, 0.05037800f, 0.02630552f, -0.05675305f, 
    -0.01641178f, -0.01126807f, -0.15134667f, -0.00518673f, 0.16798128f, 0.03666198f, -0.00315006f, 0.05234216f, 
    0.10951446f, 0.11409009f, -0.05290356f, -0.06854989f, 0.06172360f, 0.09285282f, -0.07209690f, -0.00707017f, 
    0.33335820f, -0.06478343f, -0.23963277f, 0.05589966f, 0.03511509f, -0.04476758f, -0.05221468f, 0.14461832f, 
    0.03563138f, 0.07125400f, -0.09112344f, 0.02577033f, 0.29085776f, 0.13233291f, -0.07100889f, -0.01674708f, 
    -0.13745682f, 0.02120315f, -0.04851561f, -0.07867365f, 0.02482700f, 0.05615431f, 0.08722655f, -0.07810763f, 
    0.25402617f, 0.06000319f, -0.04723699f, 0.01182252f, -0.12888220f, 0.09347415f, 0.00993232f, 0.09969321f, 
    -0.01322156f, -0.01706116f, -0.04098771f, 0.00089709f, 0.03739905f, -0.03628263f, 0.16931057f, -0.05376705f, 
    -0.03019728f, 0.00775367f, 0.03496592f, 0.14487968f, 0.06699365f, -0.04837866f, -0.05980153f, -0.10621639f, 
    0.35758165f, 0.05350574f, -0.11449827f, 0.10338740f, -0.00625966f, -0.03461833f, -0.02581830f, -0.01929298f, 
    -0.01474347f, 0.04841473f, -0.16236460f, -0.04863677f, 0.20838049f, -0.13384141f, -0.03996370f, -0.37084138f, 
    -0.06355875f, -0.13356777f, 0.00105015f, 0.01156272f, 0.12539807f, 0.06234162f, -0.04158242f, 0.11004549f, 
    0.23894463f, 0.01827905f, -0.10730258f, -0.12506358f, 0.12898807f, 0.06038865f, -0.01310858f, -0.00683227f, 
    -0.04126057f, -0.02413209f, 0.17674246f, 0.11583424f, 0.20588976f, -0.07205191f, 0.10764742f, 0.01938341f, 
    -0.00079936f, -0.10128036f, 0.00732736f, 0.04619059f, -0.10835223f, 0.05782515f, -0.05280012f, -0.08170475f, 
    0.26829398f, -0.04604004f, -0.07671012f, 0.03607580f, 0.04225008f, -0.03121711f, -0.06640475f, 0.07717997f, 
    -0.05841972f, -0.03146149f, -0.05578940f, 0.01610182f, -0.20129098f, 0.00619629f, 0.01167826f, -0.02722216f, 
    0.08491720f, 0.09421524f, 0.04097543f, -0.02065074f, 0.04620217f, 0.00655297f, -0.03294090f, -0.02443574f, 
    -0.14517780f, 0.19261752f, -0.00805826f, 0.03977791f, 0.08117697f, -0.00430802f, 0.03498703f, -0.07363214f, 
    -0.06643087f, 0.13342354f, 0.04285070f, -0.01527787f, -0.48021552f, 0.01627957f, -0.15010537f, 0.04709974f, 
    0.06547928f, 0.09832557f, 0.08301129f, -0.11672314f, 0.06099513f, 0.12136911f, 0.04190665f, -0.07279608f, 
    0.15914646f, -0.13404436f, 0.01332320f, -0.29469618f, -0.03753758f, 0.03417507f, -0.01133781f, -0.06449138f, 
    -0.00980770f, 0.13065386f, 0.03817553f, -0.04600511f, -0.08315139f, -0.19465022f, 0.10032518f, 0.06421559f, 
    -0.02433721f, 0.02253894f, -0.08813400f, 0.04753150f, 0.08563032f, -0.00788026f, -0.01710637f, 0.07039441f, 
    0.43888417f, 0.18435237f, -0.11564580f, 0.14177777f, 0.04424864f, -0.12670518f, 0.10062479f, 0.11148497f, 
    -0.03329882f, -0.12726030f, 0.04699710f, -0.10720816f, 0.26652670f, -0.29669845f, -0.03348621f, -0.00270423f, 
    -0.15826412f, 0.20014144f, -0.01123826f, -0.05185911f, 0.05286290f, 0.07057860f, -0.09786597f, 0.01304879f, 
    0.01982422f, 0.19153176f, 0.08766486f, 0.12040062f, 0.07420123f, 0.05866488f, 0.02298316f, 0.13127589f, 
    -0.05761878f, 0.05256513f, -0.01062991f, -0.08937172f, 0.12153715f, 0.16249573f, 0.17773013f, 0.15978038f, 
    0.12657250f, -0.16647045f, 0.08824926f, 0.06941441f, 0.06270134f, -0.00747400f, -0.04101394f, -0.00714227f, 
    0.30666479f, -0.10074025f, -0.07826629f, -0.30937326f, -0.07094262f, 0.09679610f, -0.01531599f, 0.04344477f, 
    0.09087697f, 0.00175901f, -0.11773810f, -0.07163952f, 0.41809106f, 0.07096236f, 0.03412218f, 0.09654225f, 
    -0.03729958f, 0.12853429f, 0.02668023f, 0.09760311f, -0.00344767f, 0.12229048f, -0.03070539f, 0.01377787f, 
    -0.22952716f, -0.04946700f, -0.12802367f, 0.18010242f, -0.03080821f, 0.07159027f, 0.24021778f, 0.06294634f, 
    0.12043401f, 0.05172478f, 0.02166697f, 0.00981239f, 0.10765795f, 0.08695980f, 0.02756720f, -0.18500111f, 
    0.06196933f, 0.14321357f, 0.12289310f, 0.12530978f, 0.05417562f, 0.18681380f, 0.02621803f, 0.08403285f, 
    0.04924958f, -0.06150186f, -0.28146777f, -0.03378558f, 0.08084866f, -0.11650204f, 0.01041736f, -0.11566027f, 
    -0.02753473f, 0.00427448f, -0.07994889f, 0.01179048f, -0.09247857f, -0.41303134f, -0.11627378f, 0.07909334f, 
    -0.02723726f, 0.06266966f, 0.06372324f, -0.01956794f, 0.01157805f, -0.08257405f, -0.07153104f, 0.11876361f, 
    0.47178617f, 0.10023214f, 0.05710979f, 0.29986238f, 0.00017096f, -0.03631276f, 0.18959174f, 0.10396322f, 
    -0.03017080f, 0.03823711f, 0.07317909f, -0.00935577f, -0.15851825f, 0.14379759f, 0.18292156f, 0.00807405f, 
    0.11332024f, 0.05515163f, 0.07458731f, -0.10166912f, 0.03516258f, 0.07009905f, 0.00557591f, 0.01227293f, 
    0.07491569f, -0.13537353f, 0.01570000f, -0.18736950f, 0.16454715f, 0.05040926f, -0.07746962f, -0.15454285f, 
    0.10100765f, -0.09325469f, 0.06556147f, 0.04853567f, -0.04795649f, -0.01299944f, 0.04164730f, 0.08653616f, 
    -0.06768531f, -0.07083531f, -0.04895826f, -0.00033893f, -0.12574306f, 0.04146733f, -0.17542361f, 0.13523714f, 
    0.15894961f, -0.01870741f, -0.13734446f, -0.19866176f, -0.03034871f, -0.07691771f, -0.08307053f, -0.02501811f, 
    0.04980749f, -0.02127639f, -0.03341447f, -0.09148098f, 0.38262179f, 0.19375063f, 0.13511020f, 0.07477583f, 
    -0.04466344f, 0.03529949f, -0.02340842f, 0.10670760f, -0.04203293f, 0.10865778f, -0.07285255f, 0.01260000f, 
    -0.01441599f, 0.20594685f, 0.11135019f, 0.17388535f, 0.10349713f, 0.00345341f, -0.07030454f, -0.06647355f, 
    0.08225352f, 0.07804509f, 0.04493337f, -0.02655935f, 0.07737301f, -0.06507507f, 0.06177131f, 0.11672680f, 
    -0.05715315f, -0.02271898f, 0.05672009f, -0.03588688f, -0.12420820f, 0.00481942f, 0.14178455f, 0.11075519f, 
    -0.29252574f, -0.19157389f, 0.17029509f, -0.00797020f, -0.00171381f, 0.07042474f, -0.16103350f, 0.17843969f, 
    0.04441619f, 0.04639073f, 0.10919672f, 0.10847091f, 0.01363686f, -0.16103436f, -0.02664072f, -0.33775610f, 
    -0.03825428f, -0.04296648f, -0.10977682f, 0.00156750f, 0.01738081f, 0.10511846f, -0.09693575f, 0.13108914f, 
    -0.18493947f, 0.16180354f, 0.13139845f, -0.03638478f, -0.04361298f, 0.03228292f, 0.23016223f, 0.10941026f, 
    -0.05302200f, -0.01041539f, 0.04630391f, 0.04006464f, -0.13497880f, 0.28437948f, -0.19886802f, -0.14185135f, 
    0.04607944f, -0.12495512f, 0.00403802f, 0.06641784f, -0.13751303f, -0.02954658f, -0.07380862f, -0.05260574f, 
    0.02502323f, -0.17116882f, 0.11883810f, -0.03127193f, -0.12272590f, 0.01193812f, 0.04945689f, 0.00424055f, 
    -0.01355113f, -0.05240448f, 0.09230109f, -0.00645044f, -0.22040735f, -0.04230730f, 0.12400282f, 0.32997638f, 
    -0.04723327f, -0.03571913f, -0.07663944f, -0.00868472f, -0.08492125f, -0.00233291f, 0.00550818f, -0.03094420f, 
    0.01638381f, 0.02298385f, -0.27347085f, -0.14448076f, -0.01970140f, 0.07206035f, 0.07474442f, -0.19983666f, 
    0.02413072f, -0.03569909f, -0.03403724f, -0.04499767f, -0.20102684f, 0.05093095f, 0.07594950f, -0.10980427f, 
    -0.20087190f, 0.05846023f, 0.03434661f, -0.12483796f, -0.02272866f, -0.11138725f, -0.01209868f, -0.11391847f, 
    0.32516128f, -0.13501394f, 0.20219770f, -0.15441969f, 0.01991391f, 0.06906698f, -0.00351731f, -0.02687135f, 
    -0.10258080f, 0.05669172f, -0.02662203f, -0.06108927f, 0.44467822f, 0.00173707f, 0.16618884f, 0.27194554f, 
    0.05870156f, 0.06279829f, 0.03949892f, -0.01875293f, 0.10775565f, 0.07570383f, 0.09428845f, 0.03769934f, 
    -0.03332086f, -0.02182021f, -0.01996534f, -0.00822251f, -0.00518127f, 0.01030054f, 0.01129293f, -0.03846343f, 
    0.03512752f, 0.02183342f, 0.00748317f, 0.00690844f, -0.04998678f, -0.00399643f, -0.00828893f, 0.00721013f, 
    -0.04244933f, 0.01655989f, -0.04767120f, -0.03695915f, -0.00945177f, -0.02033489f, 0.01745484f, -0.01253766f, 
    -0.03529129f, -0.01463277f, -0.03732819f, -0.03788880f, 0.01756145f, -0.02061760f, 0.03689404f, 0.04011268f, 
    -0.01939752f, -0.02247788f, 0.04484507f, -0.04471688f, -0.02373848f, -0.00914551f, 0.01365475f, -0.01075758f, 
    -0.02102489f, 0.03045250f, -0.00817264f, -0.02394073f, 0.00700890f, 0.02521192f, 0.02763622f, -0.00138875f, 
    -0.01919669f, -0.05646104f, -0.02146211f, 0.03370780f, -0.03977307f, 0.01068277f, 0.04664886f, 0.00801332f, 
    0.02077270f, 0.00632226f, 0.01164215f, 0.00825819f, 0.02885239f, 0.02164770f, -0.00292577f, -0.00001157f, 
    -0.01279533f, -0.00700987f, 0.00185444f, -0.05239995f, -0.05393627f, 0.00950689f, -0.03766364f, -0.03892478f, 
    0.03588576f, -0.00535472f, 0.03142433f, -0.03161256f, 0.01356977f, 0.00109467f, -0.02179417f, 0.04936240f, 
    0.00971920f, -0.01521365f, -0.02633766f, 0.02368033f, 0.00987456f, 0.02210457f, 0.03420575f, -0.02364538f, 
    0.03561172f, -0.02029514f, -0.00042397f, 0.01202128f, -0.05862554f, -0.01603932f, 0.04636924f, -0.00273121f, 
    0.00048837f, -0.02056108f, -0.00066943f, -0.04242538f, -0.02826590f, 0.01097711f, 0.03581220f, -0.04496186f, 
    -0.01237441f, 0.04219635f, 0.04103129f, -0.04620635f, -0.00469461f, -0.00031896f, 0.01956394f, -0.02418192f, 
    0.00413854f, 0.03259965f, -0.03433570f, 0.02059133f, 0.00546715f, 0.03459558f, 0.01800874f, -0.01169288f, 
    0.01477606f, -0.01940221f, 0.03209370f, 0.03002014f, 0.02505630f, -0.03072034f, -0.03964939f, -0.05460775f, 
    0.04466536f, -0.01722486f, 0.02185108f, -0.06127923f, 0.02477394f, -0.00277940f, 0.01853366f, -0.03482791f, 
    0.02250239f, 0.00016122f, -0.00388305f, -0.04592204f, 0.01584810f, -0.00688690f, 0.03623721f, 0.03331137f, 
    -0.01252458f, -0.03396577f, 0.03774741f, 0.03188922f, -0.04486755f, -0.00209635f, 0.00756076f, -0.05069593f, 
    -0.01680877f, -0.02923054f, -0.02491063f, -0.04821334f, -0.05137871f, 0.02598460f, 0.01461742f, -0.00183084f, 
    -0.01906789f, 0.03459286f, -0.00785237f, 0.02742439f, -0.01876915f, -0.02169969f, 0.01911752f, 0.02209472f, 
    0.04316019f, -0.02631538f, -0.03059993f, 0.05067120f, -0.03698400f, 0.00706388f, -0.00327624f, -0.02217884f, 
    -0.04108683f, -0.03796368f, 0.03095486f, -0.04804641f, 0.00375661f, -0.01386253f, -0.03157640f, 0.01956110f, 
    0.00755533f, 0.01818906f, 0.01160432f, -0.02515676f, -0.06668171f, -0.04932101f, -0.01012490f, -0.00301121f, 
    -0.02113968f, -0.03543225f, -0.05321923f, 0.00271555f, 0.01453566f, -0.00177414f, -0.03663671f, -0.00964190f, 
    0.00510290f, 0.05088610f, -0.00566846f, 0.03568396f, 0.00292740f, 0.02794514f, 0.02108267f, -0.03464291f, 
    0.02022563f, -0.03403382f, -0.05289724f, -0.00216917f, 0.02985663f, -0.03233715f, -0.00994854f, -0.01510905f, 
    0.05098872f, 0.03721539f, -0.03721227f, -0.00787677f, -0.03663175f, -0.04018041f, -0.05524065f, -0.05045114f, 
    0.00100578f, -0.05320423f, 0.01599694f, -0.01941022f, -0.02438137f, -0.03265831f, 0.01522895f, -0.05446483f, 
    0.01954186f, -0.02060381f, -0.03019717f, -0.05119266f, 0.04369783f, -0.02202312f, -0.01274557f, -0.02198086f, 
    0.01806542f, 0.02455932f, -0.04197690f, 0.03622494f, 0.04938815f, -0.00419849f, 0.04097496f, 0.03453967f, 
    -0.03649226f, 0.03010411f, -0.04114809f, 0.02977013f, 0.00634422f, 0.03688711f, -0.03733076f, -0.00761111f, 
    -0.02420916f, -0.02559908f, -0.03672887f, 0.03077419f, -0.03670683f, -0.02574928f, -0.04854392f, -0.03483889f, 
    -0.00759114f, -0.02177282f, -0.00127888f, -0.00329514f, -0.01238640f, 0.01549852f, -0.03188445f, -0.01708009f, 
    -0.01243204f, -0.03756853f, -0.01433372f, 0.02210888f, 0.00966856f, -0.04432095f, -0.02372946f, -0.00936018f, 
    -0.04467680f, -0.01892872f, -0.00702535f, -0.03278707f, -0.00059967f, 0.04554901f, 0.01232715f, -0.05658818f, 
    0.02125945f, -0.00146357f, 0.00934347f, -0.00213645f, -0.00619282f, 0.00831396f, 0.00160837f, -0.00139341f, 
    -0.03064017f, 0.04092176f, 0.04093531f, 0.01555176f, 0.02338375f, -0.03534724f, 0.01737283f, -0.05267657f, 
    0.03625716f, 0.00542795f, -0.02751914f, -0.00737487f, 0.01551101f, -0.03755630f, -0.04779697f, -0.01682753f, 
    -0.00414360f, 0.00139055f, 0.01206361f, -0.04563420f, -0.00298777f, 0.04108576f, -0.03276119f, -0.02968669f, 
    -0.00557026f, 0.03488966f, 0.02970124f, 0.03225699f, 0.01278408f, 0.01547986f, 0.01840488f, -0.03297934f, 
    0.02026011f, -0.05779975f, -0.03899853f, -0.03025873f, -0.04398211f, -0.03493631f, 0.02323903f, -0.02391884f, 
    -0.00641645f, 0.02109252f, -0.04620954f, 0.00845537f, -0.02226441f, 0.03288592f, 0.00472409f, -0.02047525f, 
    0.04429581f, -0.01287770f, -0.02421292f, -0.01611501f, -0.00112892f, -0.04553148f, 0.00658596f, 0.01760690f, 
    0.04289353f, 0.04780328f, 0.02131531f, -0.01793458f, -0.02290438f, -0.00027790f, -0.01245641f, -0.04663674f, 
    0.04498968f, -0.00882713f, 0.00266868f, 0.01118044f, -0.03804825f, -0.05854322f, -0.06370229f, 0.01164927f, 
    -0.03344681f, -0.01437804f, -0.01376798f, 0.01710330f, 0.02622389f, 0.01506530f, 0.04526016f, -0.02031628f, 
    -0.03042470f, -0.00706523f, 0.03263353f, 0.00467163f, -0.01966849f, 0.01950165f, 0.03509042f, 0.04592777f, 
    -0.04487782f, -0.05254715f, 0.04159776f, -0.03768168f, -0.01900553f, 0.01112324f, -0.05243362f, -0.00943252f, 
    0.02727315f, 0.03223061f, -0.03971806f, -0.00235147f, 0.04297459f, 0.00622335f, -0.03199080f, -0.00853943f, 
    0.03820989f, -0.01370293f, -0.03752694f, -0.00449428f, -0.05407836f, -0.05212540f, 0.01050794f, 0.02466483f, 
    -0.02947845f, 0.03949271f, 0.00630616f, -0.02587772f, -0.03293829f, 0.03482066f, 0.04349387f, -0.00544260f, 
    0.03187580f, 0.00008367f, -0.02637420f, 0.03446336f, 0.02031448f, -0.03169233f, -0.03283595f, -0.02647272f, 
    0.00842462f, -0.03369812f, 0.00481173f, 0.01102631f, -0.05583653f, -0.01514803f, -0.02191715f, -0.02799116f, 
    0.01121144f, 0.02515073f, 0.04776190f, 0.03981657f, -0.05020597f, -0.00692824f, -0.01515506f, 0.00101339f, 
    0.03500572f, 0.02814868f, 0.02597342f, -0.02683845f, 0.02911676f, -0.02156066f, 0.03006045f, -0.04896599f, 
    -0.00001329f, -0.00148307f, 0.04211387f, -0.00853798f, -0.04466549f, -0.03714041f, -0.04875770f, 0.00027658f, 
    -0.03118217f, 0.01358819f, 0.02405102f, -0.00235682f, -0.03386538f, -0.03421751f, 0.01818613f, -0.04728882f, 
    0.04542450f, -0.01063070f, -0.05517251f, -0.02563933f, 0.03796563f, 0.00143879f, 0.02673419f, 0.01489293f, 
    0.01054559f, -0.04622772f, 0.01416709f, -0.00712876f, 0.03706393f, -0.04071141f, -0.04745967f, -0.05298011f, 
    0.04404126f, -0.03175683f, 0.02330372f, -0.03910500f, -0.00499425f, -0.00804070f, 0.03960464f, -0.02973115f, 
    0.00360767f, -0.02022010f, 0.03735693f, 0.03063923f, -0.04465674f, 0.01227997f, 0.01607571f, -0.01035053f, 
    0.03299986f, 0.02574883f, 0.04157047f, 0.03422764f, -0.00489801f, 0.01920027f, 0.04283453f, 0.00119415f, 
    0.03911844f, 0.02410243f, 0.03260913f, -0.01765710f, -0.04186128f, 0.00761221f, -0.05533374f, 0.00740573f, 
    0.00616790f, -0.04309263f, -0.05260476f, -0.02377435f, 0.00316162f, -0.03636777f, 0.02917151f, 0.00991731f, 
    0.03229003f, 0.04406514f, 0.01016004f, 0.00985172f, -0.00324749f, 0.02414168f, -0.05173995f, -0.00377131f, 
    -0.03074170f, 0.03934942f, -0.05280974f, -0.00667166f, -0.04178276f, -0.03370951f, 0.01120745f, 0.03597880f, 
    -0.04564657f, -0.04103113f, -0.01800968f, -0.02537351f, -0.00791728f, -0.02181556f, -0.03899458f, -0.04443066f, 
    0.03831214f, -0.05461412f, 0.01516329f, 0.01682812f, -0.00490897f, -0.00018182f, -0.01736614f, 0.00279234f, 
    -0.03119089f, -0.04151437f, 0.01159607f, -0.01535184f, 0.03347110f, -0.03750133f, -0.01931229f, -0.00775215f, 
    0.00610807f, 0.00930142f, 0.02413870f, 0.04408726f, 0.02145914f, 0.00841972f, 0.04351436f, -0.00267023f, 
    -0.04607656f, 0.02758179f, -0.04836692f, -0.01304534f, -0.04316216f, -0.04604102f, -0.01670496f, -0.03482803f, 
    0.03799126f, -0.03962569f, 0.00609243f, 0.00349431f, -0.02909919f, 0.01739322f, 0.01657506f, -0.03741558f, 
    -0.05047106f, 0.02558720f, -0.02434493f, 0.03171676f, -0.02325816f, -0.00170245f, -0.04419790f, -0.00492029f, 
    -0.01310786f, 0.00755249f, 0.04313227f, -0.04467526f, -0.03363841f, -0.00415326f, 0.04204942f, 0.03021900f, 
    -0.04936278f, -0.05569638f, -0.03073874f, -0.04417793f, 0.02427810f, -0.02252509f, 0.01016438f, -0.02908384f, 
    -0.05159736f, 0.02903758f, -0.01089470f, 0.02632780f, -0.04934232f, -0.02535779f, -0.03480072f, -0.04276485f, 
    0.02623525f, -0.04544631f, -0.04791369f, 0.01346292f, 0.01327989f, -0.00432416f, -0.00484876f, 0.02187297f, 
    0.04106048f, -0.03122170f, -0.00913960f, -0.00554305f, 0.02533852f, 0.01349965f, 0.00161757f, -0.04603496f, 
    -0.04488294f, -0.04158758f, -0.04158486f, -0.01964246f, 0.00745975f, 0.00878853f, -0.04905811f, -0.01505195f, 
    -0.04605155f, -0.04422409f, -0.03531407f, -0.05615921f, 0.01878566f, -0.02675686f, -0.02190153f, -0.00179275f, 
    -0.01871651f, 0.02294899f, -0.03413670f, -0.03441513f, -0.00001041f, -0.03787986f, 0.03911930f, -0.00252254f, 
    -0.05284414f, 0.01199876f, 0.00124691f, 0.02889448f, -0.00153616f, -0.01223429f, 0.02589656f, -0.01459889f, 
    -0.03053994f, 0.02580165f, 0.01212722f, 0.01890876f, -0.03926995f, 0.00201933f, 0.01808739f, -0.03383619f, 
    -0.01638913f, -0.01657232f, -0.00567096f, 0.00163546f, -0.02912319f, -0.03466999f, 0.00477485f, -0.03585812f, 
    -0.03666036f, -0.03577481f, -0.01424831f, -0.02071238f, -0.05424046f, 0.03188835f, 0.03577495f, 0.00483835f, 
    0.03979891f, -0.04738556f, 0.03288273f, 0.04204402f, -0.00980666f, 0.01066356f, 0.02080000f, -0.03627434f, 
    -0.03848144f, -0.03876833f, -0.05548217f, 0.04498860f, 0.04026748f, 0.00999898f, 0.03927428f, -0.03562443f, 
    0.00511301f, -0.04340906f, 0.00041294f, -0.00328882f, -0.01375649f, 0.00396692f, -0.03438497f, 0.04061331f, 
    -0.02945486f, 0.04328062f, -0.01392183f, -0.03607990f, 0.00060748f, -0.02870185f, -0.00491562f, 0.02982191f, 
    0.04083934f, -0.00834227f, 0.00067872f, 0.03058825f, 0.04393433f, 0.00216376f, -0.02095738f, 0.01045961f, 
    0.01983292f, 0.01778314f, -0.04448499f, 0.00852452f, 0.02566056f, 0.04340447f, -0.05406318f, 0.01001373f, 
    0.04313820f, 0.00737030f, -0.01878116f, -0.03991424f, -0.01959822f, 0.01097885f, -0.03975846f, -0.03405520f, 
    -0.00266716f, -0.02726573f, 0.04264132f, -0.02663519f, -0.03480237f, -0.00268785f, -0.04663598f, -0.00543597f, 
    0.00936197f, -0.04467191f, 0.00253752f, -0.02978178f, -0.00140668f, 0.02014971f, -0.03526282f, -0.04894545f, 
    -0.05048271f, -0.05203063f, 0.01240248f, -0.05614652f, 0.01309603f, -0.04661719f, 0.01091726f, -0.02325633f, 
    -0.01693303f, 0.28953519f, -0.08905994f, -0.26714805f, 0.02570514f, 0.01480993f, -0.08283366f, 0.11025699f, 
    0.11512598f, 0.15023854f, 0.08791770f, -0.15245585f, 0.00419714f, 0.08845180f, 0.19624540f, -0.43390682f, 
    0.11232409f, 0.08806005f, -0.02060764f, -0.04525799f, -0.01825194f, 0.00793492f, 0.04421729f, 0.06607895f, 
    0.00014573f, 0.17371447f, -0.10410372f, 0.19271104f, 0.14451838f, -0.15075886f, 0.09799416f, 0.02278818f, 
    0.00170956f, 0.18307930f, 0.30521715f, -0.10318968f, -0.11477307f, -0.07725985f, -0.30636373f, -0.10310317f, 
    -0.14688055f, -0.06938634f, -0.02216491f, -0.02238396f, 0.00786997f, -0.12075096f, -0.02697571f, -0.03875058f, 
    0.17509727f, -0.30946139f, 0.11849120f, -0.02787191f, -0.00475252f, -0.01875727f, 0.25179479f, 0.08080249f, 
    0.02866854f, -0.00315374f, 0.07755057f, 0.02441571f, 0.18162522f, 0.03837557f, -0.02750334f, 0.39508149f, 
    -0.22047411f, -0.00155842f, -0.05161115f, 0.18630403f, 0.05668561f, 0.01411514f, 0.04041952f, 0.06119987f, 
    -0.26734212f, -0.01417280f, -0.13687141f, -0.12556405f, 0.05124457f, 0.02644419f, -0.17210194f, 0.07398696f, 
    0.10746165f, -0.02519066f, -0.03303328f, -0.11379682f, 0.36063680f, -0.01113217f, -0.03767203f, -0.06190284f, 
    -0.17603359f, 0.14270523f, 0.05286957f, 0.05941911f, -0.08529588f, -0.02844492f, 0.04250560f, 0.11487678f, 
    0.35269830f, 0.07982193f, -0.23259336f, 0.12247650f, -0.06566247f, 0.07384939f, 0.23652190f, -0.05515034f, 
    0.13560238f, 0.05791511f, 0.02452832f, -0.03500335f, -0.06302463f, -0.23190908f, -0.16135649f, -0.09528683f, 
    0.07070751f, 0.01382796f, -0.08860023f, 0.01547279f, 0.07504968f, -0.08059648f, 0.06117021f, 0.25755069f, 
    -0.30470407f, 0.08982577f, 0.11795154f, 0.02218989f, -0.00005796f, 0.12903039f, 0.01686998f, 0.04039019f, 
    0.01168881f, -0.10826926f, -0.03052569f, 0.06174960f, -0.17957386f, 0.10550763f, -0.07366346f, -0.06991789f, 
    0.09503427f, 0.11754681f, -0.14944941f, -0.10046945f, 0.04936336f, -0.03064235f, -0.00135607f, -0.08406429f, 
    0.02390144f, 0.02035362f, 0.01076889f, -0.00900795f, 0.01384221f, -0.03059617f, 0.07408764f, 0.03415783f, 
    -0.13304245f, 0.21609238f, 0.19454576f, 0.02807809f, 0.30153465f, 0.42879105f, 0.13175279f, -0.05420832f, 
    -0.11484597f, 0.06384815f, 0.14754291f, -0.06778707f, 0.10310750f, 0.17841685f, 0.14521717f, -0.10384901f, 
    0.60613364f, -0.03364622f, -0.05573166f, -0.01085411f, -0.18261644f, 0.14913534f, 0.04063312f, 0.15484171f, 
    -0.11420041f, 0.01551924f, -0.03393352f, 0.08127278f, -0.32578811f, 0.10332999f, -0.13396212f, -0.25316632f, 
    0.17245086f, -0.05967397f, -0.12969136f, -0.02692781f, -0.03769166f, 0.13442132f, 0.01242766f, 0.00809755f, 
    0.02220321f, 0.05875572f, -0.12132785f, -0.14489388f, 0.03985687f, 0.03598693f, 0.10792887f, -0.06985221f, 
    -0.04550744f, 0.16837391f, -0.01045788f, -0.08694585f, 0.25452670f, 0.06638765f, 0.05044017f, 0.13827141f, 
    -0.01579261f, -0.04824352f, -0.00361781f, -0.07009169f, -0.00288914f, 0.06414651f, 0.13605677f, 0.15041256f, 
    0.19488873f, 0.03493576f, -0.11912725f, 0.08118915f, 0.02841834f, -0.11102520f, -0.07808304f, -0.03734307f, 
    0.16556902f, 0.08512320f, 0.17506036f, -0.02864609f, 0.01847497f, -0.23058964f, -0.09129019f, -0.28424093f, 
    -0.02719155f, -0.03274446f, 0.07552990f, 0.19051652f, 0.01910286f, -0.09011145f, 0.08461591f, -0.14610782f, 
    -0.01181085f, 0.17835791f, -0.05568234f, -0.15042596f, 0.02720350f, 0.02306108f, -0.10989176f, 0.01518584f, 
    0.08416258f, 0.16518784f, 0.10263926f, 0.02988418f, 0.03711073f, -0.22488716f, -0.03193296f, 0.08029539f, 
    -0.02979116f, 0.06574515f, 0.05569346f, 0.20092539f, -0.09802092f, 0.07802922f, 0.21978272f, 0.00861258f, 
    0.36711022f, -0.17584112f, -0.10111991f, 0.20579551f, -0.04093875f, -0.11328179f, 0.09103041f, 0.14982897f, 
    -0.06359127f, 0.11131380f, -0.08701310f, 0.16859564f, -0.22223662f, -0.10560552f, 0.03538344f, -0.13152353f, 
    -0.06732532f, -0.03667450f, 0.13021363f, -0.06172255f, -0.12164292f, 0.09350754f, 0.05174354f, 0.13567503f, 
    -0.20195813f, -0.03536576f, 0.07158277f, 0.02480950f, 0.12341764f, 0.20765288f, 0.03238738f, -0.09015612f, 
    0.09013970f, 0.21826717f, 0.05043618f, 0.07400712f, 0.13946879f, 0.05201376f, 0.04032666f, -0.15878761f, 
    -0.05053349f, 0.12163255f, 0.03074713f, -0.05262713f, 0.03218511f, -0.04933029f, -0.03003676f, 0.13352200f, 
    0.35060143f, -0.01669805f, 0.02326539f, 0.00305822f, 0.07731715f, 0.05891379f, 0.12369382f, 0.12365550f, 
    0.05462608f, 0.11649271f, 0.00453143f, 0.00541381f, -0.01301532f, -0.05841885f, 0.03942791f, -0.09973688f, 
    -0.18884525f, -0.22951816f, 0.01825599f, 0.12862732f, 0.01908104f, 0.08326019f, 0.07194523f, 0.07428259f, 
    0.37850204f, -0.12196162f, 0.21127386f, 0.12897992f, 0.11218946f, -0.00150409f, 0.13083808f, 0.04812213f, 
    -0.01508632f, 0.12079635f, -0.01608351f, 0.11180477f, -0.27536801f, -0.00190990f, 0.19569723f, 0.27597088f, 
    0.26910600f, 0.10381969f, -0.04862438f, 0.07909853f, 0.08693459f, -0.08395698f, 0.01912628f, 0.03540923f, 
    0.22668441f, -0.00365131f, -0.03970916f, 0.09793471f, 0.11730000f, 0.02641947f, 0.05393278f, 0.11724924f, 
    0.25362635f, -0.01886674f, -0.00512379f, -0.03097443f, 0.04065945f, -0.14991246f, -0.04315755f, -0.04036639f, 
    0.11879566f, -0.15932469f, -0.06668704f, -0.12154027f, 0.05020721f, 0.09303648f, -0.01369142f, 0.31535840f, 
    -0.03705782f, -0.01069286f, -0.03917737f, -0.02762990f, -0.00593383f, 0.03319814f, 0.03301262f, -0.01517300f, 
    0.01869691f, -0.02850655f, -0.03418757f, -0.02109635f, 0.01928192f, 0.01005692f, 0.03660686f, -0.05403599f, 
    0.02818544f, 0.02885382f, 0.03328685f, -0.04304446f, 0.03601284f, 0.02828395f, -0.04826650f, -0.04352297f, 
    -0.03865160f, -0.00147161f, 0.01536929f, 0.00301122f, 0.03914409f, 0.01845422f, -0.04962327f, -0.03369075f, 
    0.03968142f, -0.05583993f, -0.04484300f, 0.01964624f, 0.00712994f, -0.00369235f, -0.00482533f, -0.00253428f, 
    -0.01786141f, 0.01045547f, -0.05126797f, -0.05040745f, 0.04118132f, 0.01596379f, 0.00271567f, 0.03185247f, 
    0.01067853f, -0.01746566f, 0.03133034f, -0.00372937f, -0.05590138f, 0.03561892f, -0.00490163f, -0.03579805f, 
    0.01204043f, 0.04339887f, 0.01698792f, -0.00672993f, -0.00090501f, -0.05464441f, 0.01851729f, -0.02329459f, 
    0.03834243f, -0.04326922f, 0.03593175f, 0.03786076f, -0.00659805f, -0.01208861f, -0.02562393f, -0.05097036f, 
    -0.04590314f, 0.01183652f, -0.04594512f, -0.05621109f, -0.02680744f, 0.00567163f, -0.03035345f, 0.03324045f, 
    -0.03257068f, -0.04025029f, 0.04443845f, -0.03839285f, 0.00979619f, -0.05282064f, 0.02795775f, -0.02653469f, 
    0.00134643f, -0.05057684f, 0.04333988f, 0.00883165f, -0.03602643f, 0.04194930f, -0.04976703f, -0.04010314f, 
    -0.01811975f, 0.02058212f, -0.01572073f, -0.03958635f, -0.04950314f, -0.00334866f, 0.00955681f, -0.05079235f, 
    -0.05328413f, -0.03391982f, 0.00444342f, 0.04568575f, 0.03794955f, -0.01833379f, -0.01865592f, -0.04538081f, 
    -0.00178417f, -0.02688808f, -0.04754134f, 0.00809536f, 0.02298738f, -0.03242255f, -0.04001433f, -0.02764218f, 
    0.00185183f, -0.05265373f, 0.01579405f, -0.01730145f, -0.02010359f, 0.04228280f, 0.00884519f, -0.04878834f, 
    0.04558255f, 0.02648369f, 0.00355361f, -0.02274156f, 0.03213892f, 0.03701312f, -0.01940914f, -0.00549142f, 
    -0.03054117f, 0.04028822f, -0.02600086f, -0.00918162f, -0.01508577f, -0.00723189f, 0.00290642f, -0.03858059f, 
    -0.02289048f, -0.04159990f, -0.04823745f, -0.03690863f, -0.04139593f, -0.04982007f, 0.01262662f, -0.03986580f, 
    -0.03483571f, -0.03903618f, 0.01114867f, 0.03810260f, 0.00048972f, 0.03054282f, -0.01915776f, -0.02658213f, 
    0.01913839f, 0.04010754f, -0.02429021f, -0.03169302f, -0.02937203f, 0.03421829f, -0.03482270f, 0.03113185f, 
    0.02408036f, -0.01939389f, -0.02345091f, -0.00447935f, 0.00449389f, -0.02639796f, 0.00051155f, -0.01865209f, 
    -0.01327403f, -0.04520595f, 0.02190487f, 0.00864258f, -0.02869710f, -0.01480850f, -0.00321218f, -0.01927411f, 
    0.03472439f, -0.03730265f, -0.01338417f, 0.00032671f, -0.02325881f, -0.04623070f, -0.05247344f, -0.00165011f, 
    0.01999648f, -0.04241541f, -0.02711682f, 0.02295312f, -0.02230675f, 0.00029158f, -0.01490669f, -0.03979947f, 
    0.00901760f, 0.04108115f, -0.04277768f, -0.05540667f, -0.01151777f, 0.00803035f, -0.05557273f, 0.03913420f, 
    -0.01296713f, 0.03050664f, -0.03993946f, 0.00833752f, 0.02817957f, -0.00056167f, -0.00655296f, 0.02235901f, 
    -0.01721535f, -0.02120797f, 0.00892033f, 0.04015537f, 0.02693942f, 0.00358320f, 0.03768069f, -0.02348518f, 
    -0.01583661f, 0.01210767f, -0.00373392f, 0.01992940f, 0.01745484f, 0.02867758f, 0.01026189f, 0.00921426f, 
    0.00191530f, 0.04169315f, -0.03099323f, -0.03140255f, -0.01887639f, -0.02078287f, -0.02662135f, 0.03293441f, 
    0.03354584f, -0.02853446f, -0.04872848f, -0.02029948f, -0.03235648f, 0.03901288f, -0.00823453f, -0.03462711f, 
    -0.01506590f, -0.04634742f, -0.01940248f, -0.02472085f, -0.05262325f, -0.03154159f, -0.01253113f, 0.03650785f, 
    -0.05064313f, -0.02729197f, -0.02878745f, -0.00819380f, 0.02583833f, -0.04817176f, 0.02619087f, 0.02081310f, 
    0.02619475f, -0.01353391f, -0.02131505f, 0.03253317f, -0.03088387f, -0.04648034f, -0.05554268f, -0.05380147f, 
    0.01484062f, 0.01648716f, 0.04533045f, -0.03220665f, -0.03091718f, 0.03862815f, 0.02578743f, -0.00901417f, 
    0.04242338f, 0.00369337f, -0.03359348f, -0.04452194f, -0.00792322f, 0.00207303f, 0.02572176f, 0.03255437f, 
    -0.03601556f, 0.01920337f, -0.04470708f, 0.01578751f, -0.02069332f, -0.00477780f, -0.04264077f, 0.04334667f, 
    0.01432584f, -0.00253704f, -0.04515091f, -0.02697408f, -0.03244066f, -0.01040423f, -0.00193551f, -0.02711850f, 
    0.01120643f, 0.03883366f, -0.01723096f, -0.01500999f, 0.03524893f, 0.01196494f, -0.05510668f, 0.01102773f, 
    -0.03174289f, -0.02644739f, -0.03836239f, -0.05408064f, -0.02407424f, -0.01057259f, -0.01996613f, 0.00363718f, 
    -0.04456485f, -0.00129602f, 0.02569005f, 0.01370188f, 0.00982873f, 0.01354292f, -0.02324691f, -0.03956043f, 
    -0.00672952f, 0.03416228f, -0.01611017f, 0.00308787f, 0.02878857f, 0.00299784f, 0.01718302f, 0.03022115f, 
    -0.03248349f, -0.03008976f, 0.04516660f, -0.02237824f, -0.03234148f, -0.03038645f, 0.01064238f, 0.02953756f, 
    0.04164942f, -0.02955413f, 0.04452242f, 0.02181997f, 0.03498401f, -0.00054327f, -0.03051770f, -0.03984085f, 
    -0.01382493f, -0.01810586f, -0.01818751f, 0.00546906f, -0.02923329f, -0.02158134f, 0.02592974f, 0.00174062f, 
    0.00954243f, 0.00892181f, 0.03018155f, -0.02230666f, -0.03521291f, 0.00916370f, -0.00421253f, -0.02965062f, 
    -0.04217869f, 0.03734912f, 0.00539074f, 0.03728336f, -0.05552931f, 0.02690309f, -0.05466909f, -0.03264612f, 
    0.03770929f, -0.03319000f, 0.02076658f, 0.01258578f, 0.00513093f, -0.02980014f, -0.01492138f, 0.02120893f, 
    0.11834159f, -0.01805241f, 0.07922527f, 0.03885561f, -0.01782795f, -0.05236680f, -0.05767231f, 0.10973687f, 
    0.08045923f, 0.05394645f, -0.00917740f, 0.18552248f, 0.10496815f, 0.06633136f, 0.08042421f, -0.08602480f, 
    0.04271054f, -0.13701148f, 0.09128102f, 0.12157971f, -0.14060411f, -0.05028224f, 0.10617515f, 0.05694625f, 
    0.11753187f, -0.41122389f, 0.36421868f, -0.05366869f, -0.04148081f, 0.03529663f, -0.14550641f, 0.09478099f, 
    0.15181732f, 0.17569828f, -0.08037493f, -0.08155897f, -0.27214372f, -0.25391790f, -0.05284178f, -0.28059855f, 
    -0.05934603f, 0.06283034f, 0.01525603f, -0.04336097f, -0.04487359f, 0.04189106f, 0.09588184f, -0.01923395f, 
    -0.36072150f, -0.18186942f, -0.05406220f, -0.09339780f, -0.07072203f, 0.06596551f, 0.03034763f, -0.11702317f, 
    0.13989308f, -0.08099516f, -0.00684016f, -0.00911626f, 0.07749184f, 0.29058984f, -0.27746472f, 0.08983166f, 
    0.23286405f, 0.06655422f, -0.14621519f, 0.09705202f, 0.00200553f, -0.06075956f, 0.11414550f, 0.09477185f, 
    0.52383983f, 0.27130538f, 0.22042088f, 0.08849669f, -0.14934686f, 0.03015149f, -0.07170102f, -0.00199361f, 
    0.14975312f, 0.00183788f, 0.07803624f, 0.13824393f, 0.03204126f, -0.28080398f, -0.10872787f, -0.26096740f, 
    0.11618270f, 0.15455453f, -0.05780570f, 0.06448689f, -0.03934098f, 0.05048034f, -0.00367701f, -0.02673137f, 
    -0.07577235f, 0.22067164f, -0.16530678f, 0.27055818f, -0.09545892f, 0.09815909f, -0.02073275f, 0.07517704f, 
    0.04702502f, -0.01838345f, 0.11999135f, -0.09846606f, -0.00775210f, 0.00527524f, 0.15972412f, 0.27069664f, 
    -0.14736235f, 0.11065166f, 0.07988578f, -0.10322833f, 0.09118444f, 0.18874760f, 0.01329638f, 0.08274084f, 
    0.05204725f, -0.46281061f, -0.00548789f, -0.34354863f, 0.17779361f, -0.11492392f, 0.04248670f, 0.00676369f, 
    -0.04303309f, -0.15564138f, -0.00230468f, 0.03436445f, 0.28862560f, 0.29063568f, 0.08092354f, 0.26672682f, 
    -0.07548338f, 0.09458287f, 0.03200050f, 0.08376414f, -0.03477267f, -0.00673683f, 0.07410999f, 0.00552667f, 
    -0.31915367f, 0.06724724f, -0.07927523f, -0.16722284f, 0.07561137f, 0.06745835f, -0.09178302f, -0.09977449f, 
    0.02494369f, 0.01678456f, 0.00448039f, -0.05926719f, -0.11513294f, -0.00874506f, -0.28770933f, -0.00950933f, 
    0.01793004f, -0.02619959f, -0.01905021f, 0.14420199f, -0.07570309f, 0.02347922f, 0.01521473f, 0.18169391f, 
    0.07421072f, 0.14933509f, -0.09068964f, -0.22597581f, 0.07703640f, 0.09635724f, 0.01685741f, -0.04945989f, 
    0.09942945f, 0.06546082f, -0.02974486f, -0.06303900f, 0.44421083f, 0.28540975f, 0.06125349f, 0.02138385f, 
    -0.21366464f, -0.08412921f, 0.19711904f, 0.06124874f, -0.07361576f, 0.05382242f, 0.10653832f, -0.01743727f, 
    -0.33993611f, -0.14051214f, -0.12195554f, 0.07693899f, -0.11560696f, 0.03051168f, -0.05927130f, 0.09812122f, 
    -0.00659308f, 0.14164309f, 0.00685559f, -0.18656076f, 0.26481593f, -0.08213039f, -0.04575018f, -0.32886904f, 
    -0.04265893f, -0.04000010f, 0.04855260f, -0.02632943f, 0.06444646f, 0.10651451f, 0.01506889f, 0.13201284f, 
    -0.02512025f, 0.01361564f, -0.01570590f, -0.23656647f, -0.06649837f, 0.13622080f, -0.08061926f, -0.06833546f, 
    0.03419863f, 0.11308127f, 0.04754386f, -0.11377573f, -0.22077246f, -0.10469448f, -0.28858891f, -0.22262222f, 
    -0.08100418f, 0.00200589f, 0.18332085f, -0.08006821f, -0.13311817f, 0.08062836f, -0.04440531f, -0.07423369f, 
    0.27998409f, 0.28207213f, 0.16001640f, -0.02158500f, -0.18533458f, 0.13428085f, 0.02311525f, 0.12894689f, 
    -0.13196599f, -0.02855478f, 0.05147016f, 0.03029665f, 0.11646831f, 0.01638115f, -0.00762696f, -0.01834478f, 
    0.02355593f, 0.04030142f, -0.15150256f, -0.02694515f, 0.08120144f, 0.10781203f, -0.20636703f, 0.08760319f, 
    0.46907589f, -0.11769790f, -0.18037994f, -0.28953129f, 0.26408389f, 0.00766350f, -0.13489777f, 0.15438192f, 
    0.00396340f, 0.04333323f, -0.02262449f, -0.08808620f, -0.10800342f, -0.14537640f, -0.06946756f, 0.01512505f, 
    0.02295794f, -0.19678073f, 0.00299468f, -0.07671199f, 0.08782234f, -0.11162512f, 0.07064958f, -0.14206876f, 
    0.28423786f, 0.18610151f, 0.05955055f, 0.04935900f, -0.04438118f, -0.02989520f, 0.03797161f, 0.03331919f, 
    -0.05647781f, -0.17667271f, -0.02431194f, 0.07299698f, -0.00052780f, -0.22775769f, 0.12605585f, 0.11296829f, 
    -0.14827934f, -0.00129751f, 0.21455915f, 0.10313118f, 0.03953127f, -0.07165545f, -0.10241695f, 0.09720004f, 
    -0.13499813f, 0.09836990f, -0.20674773f, 0.04012535f, -0.09579968f, 0.13023554f, 0.14907169f, 0.03097706f, 
    0.04166804f, 0.03016092f, -0.05450264f, 0.05242277f, 0.01890107f, -0.07612137f, -0.31914520f, -0.42387381f, 
    0.04083458f, 0.04211221f, 0.16512595f, -0.16914821f, 0.11085146f, -0.01924424f, -0.10297932f, -0.00114876f, 
    -0.25194234f, 0.02567659f, 0.16805604f, -0.14777231f, 0.11088344f, 0.01890996f, 0.03655000f, 0.06359220f, 
    0.10104235f, 0.08553170f, -0.06262386f, -0.04368561f, -0.11959913f, 0.40397605f, 0.07545334f, 0.06375728f, 
    0.01696715f, 0.00937410f, 0.02060552f, 0.16609363f, -0.07158727f, -0.01241472f, 0.10080150f, 0.00533122f, 
    -0.21395604f, -0.22344948f, -0.10378906f, 0.05669719f, -0.07751267f, 0.11019160f, 0.05476580f, 0.10719838f, 
    -0.00572450f, 0.13843964f, 0.12250299f, -0.01395993f, 0.38262224f, 0.07209947f, 0.04897014f, 0.26626766f, 
    -0.01539229f, 0.24259572f, 0.08351981f, -0.00179944f, -0.01173743f, -0.02254228f, 0.05645534f, -0.00690939f, 
    -0.03627327f, 0.04532918f, 0.12388828f, -0.15461928f, 0.05044515f, -0.12934293f, 0.06246525f, -0.05711023f, 
    -0.05967177f, 0.02960369f, 0.06033240f, 0.11457748f, -0.19081452f, -0.03035356f, -0.01745665f, 0.37455964f, 
    -0.06085910f, 0.04706051f, 0.03476179f, -0.12005297f, 0.09657637f, 0.12429430f, 0.06687357f, 0.06080237f, 
    0.13413697f, -0.16510516f, 0.01456909f, -0.24056351f, -0.08893204f, 0.02088337f, 0.03487210f, 0.02024618f, 
    0.13261543f, -0.01169070f, -0.08573651f, -0.00261456f, 0.13250308f, 0.28020126f, 0.04519322f, 0.02174803f, 
    -0.00293435f, -0.00170190f, -0.03709749f, 0.03621628f, 0.19994198f, 0.08389034f, 0.13004240f, -0.07360134f, 
    0.30008969f, 0.33011964f, -0.24842089f, 0.22960640f, -0.07734557f, 0.02498902f, -0.11464906f, 0.06712758f, 
    -0.14238396f, 0.04042301f, 0.17338665f, -0.16026074f, 0.09799743f, -0.26562700f, -0.10030550f, -0.23745808f, 
    0.10737300f, 0.05121898f, 0.10667906f, -0.07364519f, 0.02766563f, 0.08258236f, 0.08439192f, 0.00659076f, 
    -0.04611347f, 0.15143628f, 0.20792443f, -0.16061771f, -0.01029544f, -0.06004583f, 0.01485554f, 0.11978867f, 
    -0.02391863f, 0.05251620f, 0.13935873f, -0.11121750f, -0.05828136f, -0.04700003f, -0.09148882f, 0.27833942f, 
    0.04016878f, -0.07395742f, 0.05784289f, -0.10684162f, 0.11463869f, 0.13104148f, 0.00790590f, -0.07894381f, 
    -0.16564965f, 0.02718151f, 0.08816990f, -0.25672728f, 0.01754609f, 0.04811459f, 0.03601955f, 0.02218726f, 
    -0.10904921f, -0.08777556f, 0.05926025f, 0.03280415f, 0.04771132f, 0.18601193f, -0.15835004f, -0.14751792f, 
    -0.01767384f, 0.12422391f, 0.00867046f, 0.23088989f, -0.05415315f, 0.09155595f, -0.10865566f, 0.04993206f, 
    0.04860767f, -0.03275594f, -0.04187169f, 0.28374788f, -0.00191963f, -0.02358226f, 0.18725052f, -0.15260689f, 
    0.03217873f, 0.04034705f, 0.10809232f, -0.07552975f, 0.13318838f, -0.01372095f, 0.22137240f, -0.45182425f, 
    0.05664200f, 0.15808360f, 0.11263872f, 0.16535985f, 0.04331055f, 0.06327198f, -0.07642172f, 0.14798768f, 
    -0.07345824f, 0.09889071f, 0.04552139f, 0.19039772f, -0.00283338f, -0.12498605f, 0.17855893f, -0.12853850f, 
    0.13812463f, -0.12422001f, -0.01223837f, -0.09629656f, 0.11869356f, 0.04670667f, 0.02402269f, 0.06959732f, 
    0.17324223f, 0.02081434f, 0.06684273f, 0.03740476f, 0.00140081f, -0.11128978f, -0.16784184f, -0.04276663f, 
    -0.23242155f, -0.28307247f, -0.03302640f, 0.27182788f, -0.05827998f, 0.00620464f, 0.10143425f, 0.11734472f, 
    -0.05802821f, 0.18527460f, 0.00899207f, 0.01142517f, 0.03935742f, 0.06461664f, 0.16998456f, -0.05333779f, 
    0.06949222f, 0.02024259f, 0.05308693f, -0.02191884f, 0.24858268f, 0.13090818f, 0.00133990f, 0.03879531f, 
    0.15026952f, -0.01160100f, 0.03909500f, -0.04720811f, 0.15830542f, -0.00890807f, 0.02954016f, -0.07689962f, 
    0.15393603f, -0.11780876f, -0.06985711f, -0.00855044f, -0.14158742f, -0.18074794f, -0.14438079f, 0.05684014f, 
    -0.02237267f, -0.02533227f, -0.07709502f, 0.03240965f, -0.10820883f, -0.07245024f, -0.06904040f, 0.18400790f, 
    0.07540077f, -0.09947183f, -0.03127520f, -0.08428027f, -0.01277985f, 0.04937332f, 0.03253115f, 0.07230511f, 
    -0.07741062f, -0.13237728f, 0.12746841f, 0.05757115f, 0.28598687f, 0.19193155f, -0.13735388f, 0.16770965f, 
    0.02877910f, 0.05500396f, -0.01699648f, 0.13119654f, 0.07802398f, 0.11961801f, -0.20582587f, 0.18138844f, 
    -0.03803803f, 0.30049667f, 0.12328444f, -0.01248832f, -0.02033217f, 0.01836436f, 0.02559531f, 0.03478750f, 
    0.03650717f, -0.01946000f, -0.00891255f, -0.00317775f, -0.30165103f, 0.00373044f, -0.03088119f, -0.06055857f, 
    0.16061795f, -0.03111220f, 0.00994534f, 0.17012665f, -0.04458200f, -0.17778103f, 0.07995937f, 0.09588290f, 
    -0.45549363f, -0.00205718f, 0.02572611f, -0.11591099f, -0.08167633f, 0.05604267f, 0.17923789f, 0.01716491f, 
    0.01258543f, 0.03400729f, 0.13702996f, 0.04729288f, 0.33444569f, 0.12091733f, -0.07981732f, -0.06716052f, 
    -0.06779485f, 0.01609657f, 0.00741440f, -0.08376323f, 0.01718998f, 0.13926169f, 0.02625798f, 0.19308493f, 
    -0.42777228f, 0.02412236f, 0.18348491f, -0.08592770f, 0.07550048f, 0.06949326f, 0.10477396f, 0.06908111f, 
    -0.02297446f, -0.00560504f, 0.14117332f, 0.05100707f, 0.17207943f, -0.25101599f, -0.18901050f, 0.40147418f, 
    0.20147564f, 0.06744835f, 0.02460748f, -0.07913791f, -0.11028325f, -0.06521992f, -0.01172295f, 0.04509035f, 
    -0.13921851f, -0.14847907f, 0.02425150f, -0.14014567f, -0.07845169f, -0.00333185f, 0.08054455f, 0.06852459f, 
    -0.03828626f, -0.19625820f, 0.24328165f, -0.01642457f, -0.09921284f, 0.15948313f, -0.01102883f, 0.26233223f, 
    -0.01414874f, -0.05707718f, 0.04668321f, -0.09746012f, -0.08082212f, 0.05601605f, 0.12372337f, -0.08025794f, 
    -0.02349510f, 0.05038000f, -0.10131783f, 0.15941846f, 0.03435752f, -0.02004323f, 0.02068728f, -0.12112473f, 
    0.02291301f, -0.04713837f, -0.08885653f, 0.00906407f, -0.26230580f, -0.38926205f, 0.03350105f, 0.12258250f, 
    -0.09336315f, 0.05597387f, -0.05055076f, -0.07231652f, 0.19927371f, 0.02973733f, -0.10224695f, -0.11710197f, 
    0.01989946f, 0.13100079f, 0.08009119f, -0.09395030f, 0.11397623f, 0.12532586f, 0.07547168f, 0.09956884f, 
    -0.04177614f, -0.02125874f, -0.11384143f, -0.07281268f, 0.08003916f, 0.01723461f, -0.03020654f, -0.10937349f, 
    0.10482963f, 0.01715614f, 0.00111850f, 0.20275576f, 0.03382937f, 0.07445356f, 0.18753180f, 0.00276044f, 
    0.12875298f, -0.02554676f, 0.07409666f, 0.24724869f, -0.04949563f, -0.05832423f, -0.03613678f, 0.02122905f, 
    0.00387098f, -0.10064287f, 0.06522120f, 0.10430858f, 0.34567416f, -0.03117577f, -0.27662745f, 0.34934106f, 
    -0.01883210f, -0.09429243f, -0.03808255f, 0.17983250f, -0.02040813f, 0.00960157f, -0.05500094f, 0.00305370f, 
    0.02914236f, -0.37037328f, 0.20086104f, 0.33143476f, -0.15378216f, 0.02109400f, 0.13514434f, -0.01443647f, 
    0.05807652f, -0.04476278f, -0.06725356f, 0.07167415f, -0.14793499f, 0.21512048f, 0.03109945f, -0.02301796f, 
    -0.02511487f, 0.02467271f, 0.12066218f, -0.00479711f, 0.08158420f, 0.01751041f, 0.03070263f, -0.11705804f, 
    0.12538038f, 0.16433945f, 0.09554286f, 0.16442516f, -0.04149204f, -0.00478432f, 0.01758377f, -0.08778756f, 
    0.13652904f, -0.01656877f, -0.03600825f, -0.02163937f, -0.37985855f, 0.10947105f, 0.31847906f, -0.27308989f, 
    0.22103077f, -0.00453941f, 0.17336084f, -0.07714751f, -0.01904365f, 0.03567533f, -0.07300317f, -0.07026216f, 
    0.05235129f, -0.15745269f, 0.12098305f, -0.00504440f, -0.09150749f, 0.11547530f, 0.08384168f, 0.02697614f, 
    0.02121495f, -0.04818384f, 0.16935104f, -0.03964145f, 0.42087230f, 0.15184779f, -0.21368580f, -0.07336650f, 
    -0.00258403f, 0.09652509f, -0.03711237f, -0.06576901f, 0.05797959f, 0.01580060f, 0.06624622f, 0.11988253f, 
    -0.15436999f, 0.21034856f, 0.48177689f, -0.00229153f, 0.20994350f, -0.08209973f, 0.04742217f, 0.00864056f, 
    -0.03204665f, 0.16501752f, 0.13789193f, 0.19190393f, -0.23845510f, -0.22475311f, 0.04688621f, -0.00735601f, 
    0.00503999f, -0.16311482f, 0.06755194f, 0.09076250f, 0.10318340f, -0.03874307f, -0.14463806f, -0.15046959f, 
    -0.10323557f, 0.23972732f, -0.14213376f, -0.03354488f, 0.00115456f, -0.00894436f, -0.02539507f, -0.17021041f, 
    0.09095960f, 0.03055275f, 0.02140538f, 0.07010596f, 0.32193637f, -0.06576789f, 0.02492222f, 0.16508999f, 
    -0.07137819f, -0.09363307f, 0.13565959f, 0.02156612f, -0.00835713f, 0.00769640f, 0.14784607f, 0.01724080f, 
    -0.36679101f, 0.33825529f, 0.38764063f, 0.32668141f, 0.00074329f, -0.12098194f, -0.02950522f, -0.11370552f, 
    0.03100184f, 0.15433738f, -0.05681462f, -0.05434687f, 0.15237671f, 0.16840304f, -0.05920309f, 0.15839630f, 
    0.06018041f, 0.09389383f, 0.03898646f, -0.04291854f, -0.08786593f, -0.01210952f, 0.03249632f, -0.08396246f, 
    -0.19522449f, 0.21207641f, -0.05313898f, -0.04779036f, -0.01166793f, 0.00583991f, -0.07339738f, -0.05745175f, 
    0.09420092f, -0.12772103f, -0.05923806f, 0.10185564f, 0.11371443f, -0.11643799f, -0.14746368f, 0.27214098f, 
    0.03057851f, -0.14166962f, 0.02271887f, 0.07573371f, -0.02850689f, 0.05588038f, -0.15720099f, 0.03410445f, 
    0.02233288f, 0.20031795f, 0.10044109f, 0.28865814f, -0.06761528f, -0.01709935f, 0.02041592f, -0.00225636f, 
    0.04435140f, -0.10899629f, 0.01539832f, 0.04330368f, 0.11652440f, 0.07000136f, -0.11393563f, -0.07997620f, 
    -0.15162089f, 0.13715555f, 0.15672146f, 0.01417517f, -0.08381570f, 0.02664872f, 0.11479373f, -0.03727334f, 
    -0.03978067f, 0.03020678f, 0.20147736f, -0.10579650f, 0.10883456f, 0.06883325f, 0.11000860f, -0.13589710f, 
    0.00072430f, 0.16648765f, 0.06362742f, -0.02200858f, -0.21355246f, -0.05310972f, -0.09810099f, -0.16965881f, 
    0.10007221f, 0.06137345f, 0.10609427f, -0.04800016f, 0.10012401f, 0.04759272f, 0.18228586f, 0.25748181f, 
    0.30557826f, 0.16764498f, 0.12491699f, 0.05087727f, 0.06191642f, 0.07019147f, -0.07886001f, 0.09390976f, 
    -0.00912792f, -0.05290121f, 0.03732201f, 0.07252767f, -0.27734050f, 0.02141528f, 0.07787543f, -0.24075884f, 
    -0.03730322f, 0.00877447f, -0.00338075f, 0.03064538f, 0.10431646f, 0.03236335f, -0.07385718f, -0.08401072f, 
    -0.05936947f, 0.25981691f, 0.14437644f, -0.20706765f, -0.04360991f, 0.10928696f, 0.21537469f, -0.04491131f, 
    0.01476719f, -0.07904757f, 0.05531790f, 0.03542497f, 0.18967260f, 0.12069529f, 0.15550582f, 0.30735743f, 
    0.07807560f, -0.01357543f, 0.01212853f, 0.09743761f, -0.04036716f, 0.08325135f, -0.08886040f, 0.12360728f, 
    -0.27289143f, 0.00941890f, -0.27829725f, -0.01912081f, 0.16652067f, 0.05497071f, -0.08228890f, 0.03656315f, 
    0.01554077f, 0.06637648f, 0.18187152f, 0.01973367f, 0.48165363f, 0.11411022f, -0.17618588f, 0.35063338f, 
    0.01357940f, -0.05002901f, -0.05114037f, -0.05391895f, -0.00400839f, 0.03550964f, 0.03788530f, 0.18073560f, 
    -0.32203284f, -0.08799525f, 0.01573461f, -0.14933400f, 0.07274339f, 0.03894819f, 0.14361590f, -0.11764000f, 
    0.01839311f, -0.04566639f, 0.07110210f, -0.00619508f, 0.07746751f, 0.22995274f, -0.04046001f, -0.09261535f, 
    -0.01213072f, 0.08092928f, 0.07760805f, -0.07319315f, 0.02984079f, 0.00261080f, -0.02463997f, -0.06885398f, 
    -0.32243869f, 0.42112929f, 0.46368888f, 0.15487036f, 0.01866486f, -0.01031927f, -0.02156834f, 0.03185430f, 
    -0.04518109f, -0.01066388f, -0.05739528f, -0.03417371f, -0.22078902f, -0.03504483f, -0.20732960f, 0.05222459f, 
    0.00125396f, 0.03883074f, 0.03280763f, 0.24725913f, 0.07610872f, -0.03808483f, 0.06167470f, -0.05844403f, 
    -0.23143877f, 0.06998608f, 0.09166490f, -0.03765744f, -0.06824589f, 0.05584450f, 0.08415091f, -0.16695204f, 
    0.04165765f, -0.00515278f, 0.17813231f, -0.07097782f, -0.05122877f, -0.00715396f, 0.02655450f, -0.20496184f, 
    -0.06252047f, -0.03883207f, -0.03603742f, 0.15272529f, -0.03885100f, -0.00478236f, -0.02026493f, -0.01117122f, 
    -0.04800441f, -0.00405216f, -0.04636677f, 0.04002255f, 0.02011510f, 0.03117660f, 0.02888472f, -0.03433676f, 
    -0.00501190f, -0.02002563f, -0.04763233f, 0.02821769f, 0.01549392f, 0.00906081f, 0.02131034f, 0.02864009f, 
    -0.02391070f, 0.02849419f, 0.00104029f, -0.01116550f, -0.02657399f, -0.01858762f, 0.02368224f, -0.01357698f, 
    0.02572117f, 0.00779672f, -0.02493418f, 0.01941944f, -0.03610188f, 0.03163316f, -0.05255929f, 0.01972241f, 
    -0.00495685f, 0.01692300f, -0.01986892f, 0.02011877f, -0.02779400f, 0.03261945f, 0.03298653f, -0.00720924f, 
    0.02090266f, -0.00501966f, -0.05341943f, 0.03827137f, 0.01057026f, -0.01712975f, 0.02658439f, 0.03142281f, 
    0.00164440f, -0.02190746f, -0.03896051f, 0.01131872f, 0.03233508f, -0.00634312f, 0.01587654f, -0.05700656f, 
    -0.03212547f, 0.04638684f, -0.02120946f, -0.03208547f, 0.00881016f, 0.03917989f, 0.02490917f, -0.00953330f, 
    -0.00483677f, -0.00190031f, -0.04901353f, -0.00665318f, -0.05409607f, -0.00873410f, 0.04278490f, -0.05397247f, 
    -0.05997733f, -0.01408879f, -0.02759034f, -0.02385590f, 0.01820023f, 0.02826829f, -0.03290822f, -0.01037149f, 
    -0.04131575f, -0.00895531f, -0.00858462f, -0.01055192f, 0.00552011f, 0.03200319f, 0.01060767f, 0.00940652f, 
    0.02492581f, -0.05289996f, -0.04506906f, -0.04875971f, -0.02089841f, -0.02219745f, 0.00655938f, -0.01772560f, 
    -0.01000381f, -0.03403232f, -0.03940760f, -0.00706029f, -0.05987398f, 0.02923948f, -0.01061422f, 0.01955953f, 
    0.03106067f, -0.00607660f, 0.00822211f, 0.01553646f, -0.00276241f, -0.02899385f, 0.00470310f, -0.00783424f, 
    -0.00125947f, 0.03313960f, -0.03614892f, -0.02373167f, -0.01985960f, -0.04601175f, 0.00860960f, 0.00631568f, 
    -0.03804610f, -0.00118685f, -0.04944015f, 0.01152291f, -0.05806830f, 0.02405031f, -0.02666235f, 0.03262873f, 
    -0.04796683f, 0.02469662f, -0.04728408f, 0.03021237f, -0.05986454f, 0.00573818f, -0.05292249f, -0.01480645f, 
    0.00575006f, -0.02124438f, -0.01321403f, 0.02135060f, -0.04559255f, 0.00067373f, -0.02571457f, -0.02206885f, 
    -0.05481532f, 0.03676982f, -0.00367441f, -0.04305460f, -0.03408454f, 0.00338452f, -0.00196756f, 0.00448647f, 
    -0.02421441f, -0.05684663f, 0.00597435f, 0.00647532f, -0.04051317f, -0.05430001f, 0.01662996f, 0.01975317f, 
    -0.03007668f, 0.03643041f, -0.01817363f, 0.04189384f, 0.04473887f, 0.00212161f, -0.02353229f, 0.04236906f, 
    0.04483384f, 0.02275812f, 0.02153420f, -0.01836114f, 0.04036745f, 0.01298542f, 0.00980043f, 0.02473115f, 
    -0.00509440f, -0.02308094f, -0.05115819f, -0.04127040f, 0.00780212f, -0.00324460f, -0.01426929f, -0.00543151f, 
    -0.00569730f, 0.01730631f, -0.05834154f, 0.03690619f, 0.03511772f, 0.03448728f, -0.06127205f, -0.00693722f, 
    -0.04985626f, 0.02593648f, 0.02061147f, -0.01268083f, -0.02627832f, -0.05472352f, 0.00284708f, -0.03165253f, 
    0.01721122f, -0.04793873f, -0.01958094f, 0.00465489f, 0.02648900f, -0.04642063f, -0.03579248f, 0.02317705f, 
    0.02906211f, 0.03056953f, -0.04153030f, -0.01465695f, -0.00856418f, -0.04961352f, -0.01762584f, 0.02832332f, 
    0.00853385f, -0.04470357f, -0.05995618f, -0.01386573f, 0.02881587f, -0.00811036f, -0.02449321f, -0.04125108f, 
    -0.00937237f, 0.02578140f, 0.00774791f, 0.03341477f, 0.03211387f, -0.02887539f, -0.03373549f, -0.04530952f, 
    0.00289846f, -0.06446357f, -0.02006774f, -0.04946532f, -0.00798208f, 0.01819956f, -0.00712495f, -0.04734990f, 
    -0.03763276f, -0.00834160f, 0.00092177f, -0.03988943f, 0.02725405f, -0.04274869f, 0.03968305f, -0.03008940f, 
    -0.04566922f, -0.06180194f, 0.02003512f, 0.00162274f, -0.02046454f, -0.00165991f, -0.01608471f, 0.04322002f, 
    -0.04373012f, -0.05570927f, 0.04089755f, 0.00415666f, -0.03195412f, -0.05241571f, 0.02247838f, 0.01731979f, 
    -0.03965822f, 0.01171885f, -0.04302220f, 0.04206964f, 0.00469749f, 0.03837101f, 0.01608598f, 0.01753326f, 
    -0.03248836f, -0.04937619f, -0.01068124f, -0.01780245f, 0.03511776f, 0.03607871f, -0.04705723f, -0.02938183f, 
    0.01853219f, 0.02119222f, -0.01072674f, -0.00893036f, 0.00979512f, -0.00321498f, 0.02674065f, -0.02857481f, 
    0.01129772f, -0.03307701f, 0.03204879f, 0.03108977f, 0.02154652f, 0.03847915f, -0.01826771f, 0.04255602f, 
    -0.02799945f, -0.04784219f, 0.00393571f, 0.02245926f, 0.03598747f, -0.01760719f, -0.00087930f, -0.02719244f, 
    0.00724323f, 0.00427890f, -0.00280190f, 0.01138205f, 0.03158024f, 0.04019486f, -0.05090060f, -0.01814938f, 
    0.02592693f, -0.01683715f, -0.02177173f, -0.01881770f, 0.03472529f, 0.00692565f, -0.05118501f, 0.03130056f, 
    0.01830607f, 0.01057603f, 0.03583126f, -0.02360211f, -0.04429296f, -0.02845211f, -0.03867772f, -0.02661265f, 
    0.04096262f, 0.00214448f, -0.02091747f, 0.02644987f, 0.01007103f, 0.00773440f, 0.01656079f, -0.06044352f, 
    -0.04769755f, -0.03209151f, 0.01537267f, -0.03333692f, 0.04075496f, 0.00788675f, -0.05891007f, -0.03531822f, 
    0.03608304f, 0.00304771f, -0.04979531f, -0.05523484f, 0.02699870f, 0.01975376f, -0.04466079f, 0.01631022f, 
    0.00903539f, 0.02673162f, 0.01051013f, -0.00978764f, -0.05582597f, -0.03648511f, -0.01683438f, -0.01843329f, 
    0.02367494f, -0.04230645f, -0.00036743f, 0.05121011f, 0.01653393f, -0.04843399f, -0.04986194f, 0.00857975f, 
    -0.05621044f, 0.02071370f, 0.04413209f, 0.00694231f, 0.03517922f, 0.00106248f, -0.00745113f, -0.01965437f, 
    -0.05036161f, 0.02683892f, 0.00446128f, 0.01898243f, -0.04816652f, -0.06100881f, -0.03020291f, -0.04073919f, 
    0.20335837f, 0.03085793f, -0.03181744f, -0.16350216f, -0.03788208f, -0.14720254f, 0.00542576f, 0.05468509f, 
    -0.07212647f, 0.17379488f, 0.06264476f, -0.10175184f, 0.31524217f, -0.10963347f, 0.06200218f, -0.21902344f, 
    -0.03021480f, -0.01424641f, -0.08657035f, -0.06090548f, -0.06690038f, 0.02431411f, 0.05221308f, 0.00446789f, 
    -0.22919555f, 0.24566515f, -0.11021410f, 0.09293095f, 0.15139750f, -0.15834208f, -0.01665747f, -0.02078351f, 
    -0.10020782f, 0.14750996f, 0.01071620f, -0.11329627f, 0.33371872f, 0.16202590f, 0.05818122f, 0.29650757f, 
    -0.14297220f, -0.07205640f, -0.07842993f, -0.05885853f, 0.03730864f, -0.08754487f, 0.06762484f, -0.09000774f, 
    -0.12464511f, 0.10976420f, 0.13841660f, -0.08686387f, -0.02734692f, 0.12515827f, 0.11021420f, 0.27635428f, 
    -0.05914732f, -0.04898291f, 0.02440945f, -0.20043147f, 0.35630611f, -0.09523071f, 0.09888796f, 0.33894998f, 
    -0.18394029f, 0.06108490f, -0.06118042f, -0.01740527f, 0.03369342f, -0.00538439f, 0.20985229f, 0.05138081f, 
    0.03125081f, -0.10207713f, -0.22756638f, -0.09117474f, -0.02452384f, -0.03471825f, -0.07559576f, 0.00888758f, 
    0.05099972f, -0.07741040f, -0.07094049f, -0.22911838f, -0.21562316f, 0.04302255f, 0.11287220f, 0.16800176f, 
    0.01752320f, -0.00542172f, 0.00865683f, 0.06003939f, -0.04511537f, 0.03079537f, -0.02760407f, 0.16317399f, 
    0.17306691f, 0.15781255f, 0.02900790f, 0.07771762f, -0.07109111f, -0.08893473f, 0.15435158f, -0.15337037f, 
    0.06709675f, -0.13264753f, -0.12596925f, 0.04139447f, -0.04875571f, 0.03480661f, -0.20124480f, -0.25920901f, 
    0.03562308f, -0.00466144f, -0.07064055f, 0.00297571f, -0.02550184f, 0.02184128f, 0.16577519f, 0.18768945f, 
    0.21621206f, 0.23825581f, 0.11321980f, 0.17936286f, -0.03468585f, 0.05246404f, -0.00747827f, 0.02783320f, 
    -0.12499364f, 0.03100723f, -0.01029996f, 0.05313877f, -0.10287052f, 0.00250225f, -0.15112527f, -0.09365690f, 
    -0.11842600f, 0.17681359f, 0.04835247f, -0.08531221f, 0.02769406f, 0.00350145f, -0.00768708f, 0.00487152f, 
    0.25580239f, -0.05246981f, 0.00344767f, -0.04148233f, -0.06775475f, -0.01319773f, 0.09288759f, 0.09738058f, 
    -0.09220281f, 0.05252501f, 0.12831846f, -0.01630186f, 0.01524439f, -0.00942807f, 0.11530393f, 0.15105483f, 
    -0.06203816f, 0.00562542f, 0.05019138f, -0.15100175f, 0.01455966f, -0.04014549f, -0.04209942f, -0.13852207f, 
    -0.04061152f, -0.03915058f, 0.08558598f, -0.13550536f, 0.06377283f, 0.12278782f, 0.07548510f, 0.19544595f, 
    0.07201693f, 0.22330634f, -0.07219554f, 0.04484306f, 0.11510932f, -0.01988009f, -0.20704947f, -0.15697785f, 
    -0.01986532f, -0.07474072f, -0.10483996f, -0.06326775f, -0.06898823f, -0.10533328f, -0.13637336f, -0.11314917f, 
    0.01821957f, 0.02948525f, -0.01283729f, -0.00982130f, 0.05463993f, -0.01022055f, 0.14704011f, -0.00134505f, 
    -0.03205274f, 0.16363004f, -0.21626735f, -0.07016226f, -0.10330273f, 0.17387952f, 0.28536543f, 0.17064084f, 
    0.19001159f, -0.17596652f, -0.17331475f, -0.11747894f, 0.00981073f, -0.14305882f, 0.13161026f, 0.22778988f, 
    0.44673732f, 0.04130290f, 0.22298147f, 0.37718236f, 0.00143029f, -0.01247011f, -0.16026135f, 0.09935296f, 
    0.03609625f, -0.02343480f, 0.16593182f, 0.02401642f, 0.27796906f, 0.17004323f, -0.01327074f, 0.09918744f, 
    -0.09985936f, 0.02581071f, -0.13760242f, 0.18025135f, 0.07694287f, -0.00113852f, -0.03685675f, 0.01808782f, 
    -0.04258372f, -0.05428419f, -0.13630123f, -0.01964150f, 0.06028276f, -0.03304298f, 0.02930466f, -0.09188455f, 
    0.14661336f, 0.05209532f, -0.09877548f, -0.02140129f, -0.13558786f, -0.04867573f, -0.03418271f, 0.10788894f, 
    0.09051541f, -0.02611079f, -0.03130575f, 0.04967363f, -0.05703736f, 0.07633694f, 0.02606764f, -0.01022411f, 
    0.33669829f, 0.06741927f, 0.14280961f, 0.29956368f, -0.01194726f, -0.03961243f, 0.09252071f, 0.10441814f, 
    -0.09712301f, 0.20822608f, 0.09662221f, 0.10115028f, 0.03098981f, 0.15152378f, 0.03600781f, 0.18887483f, 
    -0.11629914f, 0.05116553f, 0.05172287f, -0.07919442f, -0.08297319f, 0.02048199f, -0.00985605f, 0.02224495f, 
    0.17708498f, 0.09674580f, 0.16374853f, -0.18333021f, -0.10118181f, 0.07891003f, -0.04392257f, 0.03224851f, 
    0.05462614f, 0.12807861f, 0.09489055f, 0.07801711f, -0.03386843f, -0.07543800f, 0.09695514f, -0.06415103f, 
    -0.04676380f, 0.07621380f, 0.05684061f, -0.02471494f, 0.00877063f, -0.09772184f, -0.06387034f, -0.04385382f, 
    0.34244841f, 0.07193672f, -0.00645350f, 0.03464996f, 0.00076273f, -0.04991797f, -0.15082638f, 0.08533373f, 
    -0.04439344f, 0.08689854f, -0.17679122f, -0.10816339f, 0.16696107f, 0.10662077f, 0.03168110f, 0.11078244f, 
    -0.09482724f, -0.23750624f, 0.06779285f, 0.12444018f, -0.02166071f, 0.15014003f, -0.01428275f, -0.02601947f, 
    0.40899876f, -0.15484932f, -0.16560940f, -0.03339422f, 0.15250362f, -0.00296673f, 0.06144933f, -0.00010060f, 
    -0.05247770f, -0.11736781f, 0.05120543f, 0.25907174f, -0.00759096f, -0.15847713f, 0.24311835f, 0.02946319f, 
    0.02126277f, -0.02819084f, -0.01656413f, 0.04237024f, -0.03799400f, -0.06572550f, -0.12370305f, -0.08800364f, 
    0.13849524f, 0.16217223f, 0.08066697f, 0.03190134f, 0.17184740f, 0.00546190f, 0.01947827f, 0.18269938f, 
    0.01544556f, 0.00731814f, -0.09935282f, -0.07137451f, -0.37185612f, -0.04091839f, -0.11583576f, -0.14598110f, 
    -0.00834186f, -0.03600838f, 0.07861137f, -0.16766737f, -0.02308264f, 0.02690013f, -0.07974022f, 0.16712500f, 
    -0.02268235f, -0.00807139f, -0.01855033f, -0.00085936f, 0.01235981f, -0.02224359f, 0.02108724f, 0.00897091f, 
    -0.01329632f, -0.03945103f, 0.02749880f, -0.03377260f, -0.03703059f, 0.03711993f, -0.02567823f, -0.00659742f, 
    -0.03834572f, 0.02945732f, 0.03391205f, -0.02926591f, -0.05268886f, -0.05273184f, 0.04199006f, -0.03190663f, 
    0.00378481f, 0.00426871f, -0.02420656f, -0.01295565f, -0.05042678f, 0.03824584f, -0.05342045f, -0.03037138f, 
    -0.01893109f, -0.04985858f, -0.02749732f, -0.03157799f, 0.00725752f, 0.02661206f, 0.03760594f, -0.01331719f, 
    0.02481334f, 0.04353281f, -0.04113082f, 0.04437016f, -0.00902934f, 0.03249059f, 0.02343405f, -0.01411419f, 
    -0.00393745f, 0.04485591f, 0.03373574f, -0.01960403f, -0.02303765f, 0.02962688f, 0.02346816f, -0.03306206f, 
    0.04557775f, -0.05908809f, 0.00207614f, -0.00835805f, -0.02122406f, -0.04402019f, 0.02954692f, -0.05480819f, 
    -0.04312782f, -0.04407132f, -0.04994612f, -0.05583946f, 0.01427284f, 0.02378177f, -0.00056429f, -0.01285933f, 
    0.00282915f, -0.02391616f, 0.00637590f, -0.01976248f, -0.03657550f, 0.03562652f, 0.02263157f, 0.01500060f, 
    0.02366260f, -0.04194690f, -0.01667698f, -0.02451025f, 0.03390607f, -0.02680017f, -0.03079716f, 0.02979458f, 
    0.03824721f, 0.02813572f, 0.03990522f, -0.03803938f, 0.04174430f, -0.02593358f, 0.02987562f, -0.01105033f, 
    -0.00201305f, 0.00850189f, -0.01992832f, 0.02778852f, -0.01823642f, 0.02127342f, -0.03147554f, 0.04266284f, 
    -0.01030925f, -0.03393154f, 0.02923123f, 0.03822226f, -0.00628306f, -0.00752862f, -0.00710075f, -0.00176697f, 
    0.01179119f, -0.02338887f, -0.05643190f, -0.01217965f, -0.05496151f, 0.03182840f, 0.02535594f, -0.01168502f, 
    -0.02679509f, 0.01350385f, 0.00682512f, -0.00510640f, 0.01337027f, -0.02479232f, -0.05207929f, 0.00640680f, 
    -0.02560692f, -0.02306959f, -0.02959104f, -0.03336933f, -0.05602289f, 0.01324046f, 0.04330536f, -0.01414778f, 
    -0.00575030f, 0.02012504f, -0.03876859f, 0.00029768f, 0.01345993f, -0.03561804f, 0.02580545f, 0.02357697f, 
    0.04521121f, -0.05621567f, 0.03364054f, 0.03172647f, -0.04407626f, 0.02064230f, 0.01376311f, -0.05320524f, 
    -0.01908808f, -0.01660330f, -0.04640542f, -0.05404928f, -0.01062438f, 0.00018108f, -0.03005217f, 0.01641567f, 
    -0.00125701f, 0.00168470f, 0.02518111f, 0.02392129f, -0.01938535f, 0.00763398f, -0.00909773f, -0.00918220f, 
    0.00148178f, -0.03490762f, 0.01586591f, 0.00669344f, -0.01546156f, 0.02732779f, -0.02065619f, 0.00277463f, 
    -0.05594555f, -0.05018684f, -0.02514137f, 0.00841280f, 0.03243236f, -0.03932715f, 0.01604884f, 0.04048828f, 
    0.02750096f, -0.02912681f, 0.04201246f, -0.05176596f, -0.01384795f, -0.00582393f, -0.01062453f, -0.00408205f, 
    -0.00952082f, 0.00734415f, 0.00000528f, 0.03175452f, 0.02138105f, -0.04795790f, -0.01140174f, 0.01079420f, 
    -0.02956490f, 0.02592879f, -0.00086665f, -0.01681964f, -0.01956116f, -0.04163637f, 0.00603526f, -0.05278123f, 
    0.02633222f, -0.00824630f, 0.02059279f, -0.02100716f, -0.03633509f, -0.02116941f, 0.03503836f, 0.00643313f, 
    0.01130875f, 0.03657664f, 0.01038078f, 0.04222851f, -0.04499066f, 0.03455975f, 0.00478600f, -0.01353286f, 
    -0.01410523f, -0.01781817f, -0.04556476f, -0.02595474f, 0.04140214f, -0.05271311f, 0.00940210f, 0.01554477f, 
    -0.03376909f, 0.00047617f, 0.03819590f, -0.03359664f, -0.01395564f, -0.00675876f, 0.00421501f, 0.04319243f, 
    -0.02177002f, 0.00638328f, -0.01202709f, -0.03135600f, -0.00636628f, 0.02304811f, -0.02723700f, 0.02145677f, 
    -0.01971702f, -0.01373782f, -0.00417404f, 0.02823841f, 0.00169470f, 0.00841924f, -0.04028737f, 0.02757372f, 
    -0.02873921f, -0.05526896f, -0.01753913f, 0.01240580f, 0.01201221f, -0.04066296f, -0.01777367f, -0.02612559f, 
    0.02599436f, -0.04041661f, -0.03888587f, -0.00399266f, 0.01461132f, 0.02103513f, 0.03164786f, -0.05441068f, 
    0.02041091f, 0.02659520f, -0.03593833f, -0.01490059f, -0.00653897f, 0.01732920f, -0.03935722f, 0.02397283f, 
    0.04037080f, -0.01881206f, 0.03169230f, 0.02764240f, -0.01225618f, 0.00169587f, 0.02110644f, 0.03386071f, 
    0.01784556f, 0.02894695f, -0.01024519f, -0.05925867f, -0.05310284f, -0.04711278f, 0.01667562f, -0.00495792f, 
    0.01116683f, 0.02987798f, -0.01678030f, 0.00021258f, -0.01369301f, -0.02073458f, 0.04237900f, 0.03440866f, 
    0.04236840f, 0.00214459f, -0.01396042f, -0.05500981f, -0.01671314f, 0.00329396f, -0.02433941f, 0.03850523f, 
    0.02618179f, -0.03778343f, -0.02533271f, -0.01291606f, 0.00574589f, -0.02795589f, -0.00853078f, 0.04314150f, 
    -0.04717043f, 0.02600349f, -0.03288341f, 0.01889981f, -0.02157152f, 0.01631595f, -0.02489276f, 0.03361116f, 
    -0.01720515f, -0.00931273f, -0.00401887f, 0.04877761f, -0.01487863f, 0.03258802f, -0.05708136f, 0.02731387f, 
    -0.04313266f, -0.00781414f, 0.03545668f, 0.03851984f, 0.02183651f, 0.00832103f, 0.00799887f, -0.02097453f, 
    0.04014995f, -0.00649678f, -0.05466934f, -0.00171849f, -0.00141204f, 0.00655200f, -0.00156167f, -0.04335727f, 
    -0.00417642f, 0.01489144f, -0.06028108f, 0.03365405f, 0.00611934f, -0.00371955f, -0.01436702f, 0.03159374f, 
    0.03406545f, -0.01227358f, 0.03340948f, 0.01607129f, 0.00457455f, -0.02497922f, -0.05582903f, -0.04938732f, 
    -0.02833162f, -0.03436832f, 0.04198506f, -0.01525654f, -0.03552295f, 0.03862736f, -0.03189762f, 0.01038385f, 
    -0.04011512f, 0.01808449f, 0.03882273f, -0.00690765f, -0.00015764f, 0.00172460f, -0.01683238f, 0.00903502f, 
    -0.26828378f, 0.22300048f, 0.00862892f, -0.21688320f, -0.01805109f, -0.05157435f, -0.12411560f, -0.01054617f, 
    0.00009481f, 0.03889692f, 0.11712457f, -0.02508863f, -0.13728777f, -0.15762836f, -0.32290307f, 0.18798584f, 
    -0.02207104f, 0.11824308f, -0.30235115f, 0.08007532f, -0.15198389f, 0.04309579f, 0.09831996f, 0.03016998f, 
    -0.26098520f, 0.30178532f, -0.31581852f, 0.11881211f, -0.00248583f, -0.08925182f, 0.00795242f, -0.04944911f, 
    -0.06419820f, 0.01231735f, 0.03177921f, -0.17870826f, 0.10175800f, 0.14794058f, 0.15029319f, 0.04385962f, 
    -0.03408795f, -0.03452196f, 0.05948360f, -0.04198204f, -0.07705680f, -0.08596899f, -0.01175660f, -0.08781716f, 
    -0.05357030f, 0.22819155f, -0.05608874f, 0.14502284f, 0.12060919f, -0.00816492f, 0.07815968f, 0.15863080f, 
    0.06360805f, -0.15662570f, 0.21845551f, -0.10987242f, 0.40857589f, -0.41464621f, 0.25790337f, 0.09433412f, 
    -0.02405587f, -0.00846194f, 0.14731236f, 0.11556510f, 0.03340169f, 0.03631581f, 0.08007450f, 0.01883784f, 
    -0.26475075f, -0.05302509f, 0.18185206f, -0.23228928f, -0.08605801f, -0.04935126f, -0.04845006f, 0.00208380f, 
    -0.01067675f, -0.01415699f, -0.10796527f, -0.20211568f, -0.15673202f, 0.13918193f, 0.03257199f, 0.20941442f, 
    0.03459093f, 0.02312695f, -0.00539591f, 0.03108463f, 0.07975113f, 0.01238988f, 0.02044192f, 0.15616587f, 
    0.31733778f, -0.00585939f, 0.26168770f, -0.03292596f, 0.02073364f, -0.00426026f, 0.19890563f, -0.14704441f, 
    -0.04254497f, -0.02613649f, -0.09985796f, 0.13091256f, 0.16570379f, -0.09497551f, -0.25404397f, -0.26082149f, 
    -0.03051315f, -0.02725758f, -0.01310873f, 0.00347774f, 0.02476517f, -0.01220575f, 0.11548522f, 0.17059158f, 
    0.08798520f, 0.09133828f, -0.06275810f, 0.15276237f, -0.04169231f, 0.16261336f, 0.08215959f, 0.07205473f, 
    -0.01763281f, 0.01098321f, 0.04800539f, -0.04449943f, 0.09505752f, 0.01061069f, 0.08322664f, -0.08850391f, 
    -0.04049061f, -0.01446407f, 0.10340492f, 0.05552012f, 0.07977190f, 0.03145852f, 0.16691653f, 0.03196982f, 
    0.08077339f, -0.03837192f, 0.18009357f, 0.18212597f, 0.00570576f, -0.20748980f, 0.04369133f, -0.04975404f, 
    -0.07130298f, 0.25869444f, -0.02036819f, -0.03622020f, 0.03985301f, 0.04533045f, 0.21646953f, -0.09446147f, 
    0.01110744f, 0.11060943f, 0.11515420f, -0.17527752f, -0.12511486f, 0.10326877f, -0.09090922f, -0.10042886f, 
    -0.05684377f, 0.03344354f, 0.01800366f, 0.09010529f, -0.18401593f, 0.04054857f, 0.06260659f, 0.16934991f, 
    0.13775407f, 0.10494477f, -0.01891275f, 0.20596239f, -0.55293387f, -0.06379855f, -0.08398356f, -0.21730837f, 
    0.10868966f, -0.03496269f, -0.13364960f, 0.02047851f, 0.00132475f, 0.01576779f, -0.00449648f, -0.09795287f, 
    0.19253930f, 0.01744284f, 0.13577716f, -0.07275099f, -0.03824643f, -0.07722461f, -0.10332704f, -0.06505483f, 
    0.01444795f, 0.04403853f, 0.00820657f, 0.01563767f, -0.03311145f, 0.14672944f, 0.01516668f, 0.00110784f, 
    0.03965722f, -0.10202195f, 0.06047752f, -0.20031789f, -0.13488260f, -0.06659278f, 0.14628801f, 0.15296683f, 
    0.44441372f, -0.03538153f, 0.15530513f, 0.05792146f, -0.01784360f, 0.03389709f, 0.05635009f, -0.00153140f, 
    0.00300781f, 0.07583582f, 0.09856186f, 0.04238142f, 0.24701658f, 0.13946386f, 0.00527252f, 0.11795442f, 
    -0.10074005f, 0.10319850f, 0.01110071f, 0.10345799f, 0.09849358f, -0.17044272f, 0.05163044f, 0.15361650f, 
    0.06710489f, -0.00369573f, 0.11921314f, -0.10391071f, 0.17085534f, 0.09878309f, -0.14863330f, -0.09930394f, 
    0.04563557f, 0.02105383f, -0.00698960f, -0.16016519f, 0.09357756f, -0.40686119f, 0.21309687f, -0.19375314f, 
    0.11205200f, 0.06458708f, -0.06543285f, 0.07340807f, -0.08399159f, 0.05755762f, 0.18792321f, 0.02172956f, 
    -0.16917238f, 0.10939085f, -0.04948778f, 0.15590842f, -0.04264111f, 0.01506644f, 0.04485635f, 0.19507900f, 
    -0.04980582f, 0.23057924f, 0.10831237f, 0.21188590f, 0.32562980f, 0.22487120f, 0.15208600f, 0.03468306f, 
    -0.04376348f, -0.08092498f, -0.07280179f, 0.03471060f, -0.07972924f, 0.07885351f, -0.03373956f, 0.11088057f, 
    -0.52988619f, 0.16577393f, -0.05901413f, 0.00738291f, 0.11806831f, 0.20914675f, -0.02488524f, -0.03359454f, 
    0.07130395f, -0.03984962f, -0.01850974f, 0.13665570f, 0.52513862f, 0.27026740f, 0.08598704f, 0.28785402f, 
    -0.10049357f, -0.05518295f, -0.07677612f, 0.03312983f, -0.10548291f, -0.09461912f, 0.02459260f, 0.05995540f, 
    0.21738692f, -0.24683493f, -0.07208992f, -0.20192137f, -0.24510622f, -0.03844614f, 0.12788865f, -0.15669978f, 
    -0.05220766f, 0.00753937f, -0.02663409f, -0.12664889f, -0.09774593f, 0.21630628f, 0.24903540f, -0.02523340f, 
    -0.04167429f, -0.08760082f, 0.16537605f, -0.03236805f, -0.11701554f, 0.21622698f, 0.02054219f, 0.04096567f, 
    0.13576372f, 0.06913644f, 0.14414988f, 0.08279353f, 0.33488068f, -0.12956044f, -0.06289800f, -0.06534746f, 
    -0.20998022f, 0.00027441f, 0.02057735f, -0.02255339f, -0.56671911f, -0.26714915f, 0.01572094f, 0.19505270f, 
    0.02142805f, 0.01865683f, -0.20117588f, 0.06878109f, 0.03569807f, -0.10880252f, -0.07175872f, -0.29583022f, 
    -0.02303434f, 0.15468991f, 0.09280054f, 0.07477867f, 0.05570341f, 0.00455988f, 0.13773730f, 0.02870563f, 
    0.02496301f, 0.05289002f, 0.02721922f, -0.12778997f, 0.16848862f, -0.19904675f, -0.01721656f, -0.12682922f, 
    0.03425216f, 0.03273414f, 0.00367770f, -0.08144478f, 0.12244136f, 0.08294153f, -0.00183675f, 0.10296068f, 
    -0.00701234f, -0.03469414f, 0.03353227f, 0.03216242f, -0.05181017f, 0.02477650f, 0.01469163f, 0.01032366f, 
    0.02195688f, -0.05344447f, 0.03217556f, 0.02586749f, -0.00951907f, 0.02615909f, 0.03443964f, -0.02988427f, 
    -0.02255051f, 0.02368703f, -0.02322008f, -0.00459176f, -0.01991452f, 0.01702607f, -0.02787078f, 0.02984681f, 
    0.04193040f, 0.01582485f, -0.02253945f, -0.05366140f, -0.05455729f, -0.00961140f, 0.02338502f, 0.00222254f, 
    0.01913795f, -0.04302740f, 0.00040516f, -0.00917851f, -0.03606656f, -0.00547454f, -0.02782332f, 0.01036160f, 
    -0.03647036f, 0.01174931f, 0.00976769f, 0.03337425f, -0.00519267f, -0.05082129f, 0.02033829f, -0.05453441f, 
    0.00823049f, -0.03682942f, -0.03282597f, 0.03991266f, 0.01866287f, -0.00041560f, 0.04450298f, 0.02862375f, 
    -0.05790636f, -0.03365854f, -0.03506951f, 0.01722358f, -0.03842815f, -0.04146958f, -0.02176466f, -0.04375616f, 
    -0.00728648f, 0.03907392f, 0.02098291f, 0.02303075f, -0.00785204f, 0.00546988f, 0.01665893f, -0.03537044f, 
    -0.00936244f, -0.01059202f, -0.02963105f, -0.05241642f, -0.04589630f, -0.04719473f, 0.02052753f, -0.02888042f, 
    -0.03926553f, -0.05599374f, -0.03297200f, 0.01665829f, 0.04255959f, 0.01197010f, -0.05541034f, -0.04660077f, 
    -0.04963328f, 0.00269924f, 0.00586684f, 0.04618440f, -0.01872258f, -0.00265758f, -0.02234705f, -0.00780769f, 
    -0.04073022f, 0.03469543f, -0.00782649f, 0.03056568f, 0.03921006f, 0.02234546f, -0.03972531f, 0.04818080f, 
    -0.05105624f, -0.04218318f, -0.02216517f, -0.01830070f, 0.02391315f, -0.03749230f, 0.02555256f, -0.04385085f, 
    0.02531734f, 0.04277271f, 0.01341970f, -0.04868358f, 0.03717037f, 0.00988448f, -0.03052998f, 0.03889066f, 
    -0.00251296f, -0.02051148f, 0.04652603f, 0.01020170f, -0.00134608f, -0.02930440f, 0.02634519f, -0.03037274f, 
    0.01861973f, -0.00141928f, 0.01416944f, 0.01725757f, 0.01734656f, 0.02455216f, 0.01232695f, 0.02620471f, 
    -0.02823713f, 0.03242484f, -0.04660022f, -0.02763020f, -0.00437019f, 0.03661933f, 0.03599546f, 0.03148716f, 
    -0.01473636f, 0.02052449f, -0.01843574f, -0.04631221f, 0.01229437f, 0.03119635f, -0.05153941f, 0.03929401f, 
    0.02801424f, -0.01902359f, 0.02813334f, -0.05418592f, 0.02471622f, -0.02353828f, 0.00159433f, -0.01407884f, 
    0.02971825f, -0.00474399f, 0.01945950f, 0.01852112f, 0.03807775f, -0.02676252f, -0.01925459f, 0.01031676f, 
    0.01140882f, 0.00752046f, 0.02634133f, -0.04106330f, 0.03653047f, 0.01043586f, 0.03351061f, 0.04343119f, 
    -0.05538207f, 0.02871560f, -0.04570042f, 0.00248987f, -0.05443221f, 0.00609488f, -0.04750060f, 0.04120452f, 
    0.01060368f, 0.04667504f, 0.02453204f, 0.01552515f, -0.01748184f, -0.05048985f, 0.02710343f, -0.00903769f, 
    0.01609339f, 0.04214186f, 0.03204701f, -0.05654288f, 0.01029653f, 0.03117665f, 0.04072267f, -0.00228803f, 
    0.02655805f, -0.02110680f, -0.05304676f, -0.01698226f, 0.02102449f, -0.01164636f, -0.00238807f, 0.00106526f, 
    -0.03935388f, -0.04525479f, -0.01794124f, -0.03530183f, -0.04100888f, 0.03876851f, 0.00313702f, 0.00029340f, 
    -0.04977321f, -0.01575182f, -0.03594144f, -0.02253790f, 0.00736397f, -0.01382845f, -0.00282606f, 0.02714225f, 
    -0.04475547f, -0.04481921f, -0.04969230f, -0.02496027f, 0.04280431f, -0.02230610f, -0.02160149f, 0.04134188f, 
    -0.04037396f, 0.03015321f, 0.03264460f, 0.02497279f, 0.02510099f, 0.03489823f, 0.01761683f, -0.02571067f, 
    -0.03955292f, 0.01346079f, -0.03544207f, 0.04256897f, -0.04895767f, 0.03045531f, 0.01749773f, -0.02534458f, 
    0.01948794f, -0.01327666f, 0.01767501f, -0.02617309f, -0.01215480f, -0.02233190f, 0.01561252f, 0.03360752f, 
    -0.02699626f, -0.02545179f, -0.01008642f, 0.01661916f, 0.04333780f, -0.03265456f, -0.01351419f, 0.01038195f, 
    0.04005156f, 0.01563650f, -0.01892706f, -0.00517758f, -0.01950338f, -0.01408643f, -0.04449900f, 0.01512166f, 
    -0.01069436f, -0.01954634f, 0.03425905f, 0.01570792f, -0.04537580f, 0.03797163f, 0.01787744f, -0.01209255f, 
    -0.04524565f, -0.01951969f, -0.02192538f, -0.03373189f, -0.02174327f, 0.00194251f, 0.02578232f, -0.03894633f, 
    -0.04428509f, 0.00624666f, 0.00163182f, -0.01949615f, -0.02739908f, 0.02231849f, -0.05427095f, 0.03811109f, 
    -0.01163680f, -0.03451475f, -0.04376180f, -0.03120661f, -0.04152566f, 0.04974682f, 0.01938050f, -0.05611449f, 
    0.02528859f, 0.00289410f, -0.02400491f, -0.01671809f, 0.00496403f, -0.04826820f, -0.05048066f, -0.01127935f, 
    0.00136906f, 0.00999151f, 0.01391474f, -0.01521553f, -0.01570034f, -0.00028011f, 0.04715973f, -0.02828600f, 
    -0.01954780f, 0.02036626f, -0.00795486f, 0.00379436f, 0.02651792f, -0.04496872f, -0.00591643f, 0.00979817f, 
    0.02997236f, 0.03767693f, -0.04165529f, 0.03772301f, 0.01113924f, -0.02774885f, 0.01703608f, 0.02639963f, 
    -0.00507282f, -0.04691947f, 0.00192581f, -0.02283899f, 0.01889857f, -0.03457527f, -0.03058342f, -0.05079571f, 
    -0.05413908f, -0.04136338f, 0.00898066f, 0.03653581f, 0.03220446f, 0.05092843f, -0.05115245f, -0.04420662f, 
    -0.00951730f, -0.01624577f, 0.00767742f, -0.01854246f, 0.03937525f, 0.02484220f, 0.03202543f, -0.04857483f, 
    -0.04365906f, 0.03841999f, 0.04381745f, -0.00947910f, 0.01381209f, -0.00292020f, -0.04050338f, 0.05344906f, 
    -0.05390518f, -0.01548754f, 0.04567508f, -0.00101977f, 0.03079175f, -0.01380769f, -0.04627948f, 0.01989393f, 
    0.03345325f, 0.00860243f, -0.04648596f, -0.05975295f, -0.03029107f, 0.00564083f, 0.02585807f, -0.03257285f, 
    0.04761219f, -0.04187166f, -0.03489386f, -0.06185024f, -0.02687179f, -0.08860193f, -0.00003867f, -0.01253764f, 
    -0.02295925f, 0.08051626f, 0.10620832f, 0.05325601f, 0.35159406f, 0.08106489f, -0.23348711f, -0.12367510f, 
    -0.08589413f, 0.16881973f, -0.13846271f, -0.00475900f, -0.00890190f, -0.01049007f, 0.20868775f, 0.04613891f, 
    0.09223573f, 0.33906552f, -0.07441124f, 0.04086386f, 0.01668224f, -0.04618764f, -0.13290451f, 0.00632328f, 
    -0.08407055f, 0.02096922f, -0.05886702f, -0.08870325f, -0.00517508f, 0.22221684f, 0.19884767f, 0.12046592f, 
    -0.04787320f, -0.05231303f, 0.00428479f, 0.02199158f, -0.02995778f, -0.01037484f, 0.07293589f, -0.05625979f, 
    -0.06298664f, -0.06374282f, -0.20679092f, -0.01378495f, -0.12575394f, 0.11251577f, -0.00898062f, 0.08743814f, 
    -0.05385645f, 0.06235935f, 0.05404945f, -0.15684371f, 0.09797736f, 0.00178205f, 0.02129033f, -0.01252366f, 
    -0.06025111f, 0.09988947f, -0.05546924f, -0.10339798f, 0.04559493f, -0.03059369f, 0.12302718f, 0.01647126f, 
    0.49283731f, 0.22982185f, 0.05423817f, 0.07429244f, -0.01485057f, -0.03754373f, -0.01255819f, -0.07311567f, 
    0.07891221f, -0.02067188f, -0.13831410f, -0.07280818f, -0.12353992f, -0.20335737f, 0.09913860f, 0.10443435f, 
    0.08518559f, 0.08151808f, -0.06147839f, 0.01755678f, -0.02021910f, -0.01952098f, -0.16823091f, 0.07881422f, 
    -0.08511317f, 0.01264447f, 0.05379504f, 0.09821504f, -0.00540653f, -0.08785886f, -0.01888382f, -0.15107286f, 
    0.03499419f, -0.06430800f, 0.05136481f, -0.02349267f, 0.32631731f, 0.12145669f, -0.04729502f, 0.16465235f, 
    -0.10443245f, 0.06230757f, 0.01329114f, -0.01513833f, 0.06694824f, -0.00472595f, 0.07309362f, 0.18715410f, 
    0.28391451f, 0.24519625f, -0.03892349f, 0.05188544f, 0.02482755f, -0.02271373f, 0.07349249f, 0.10878981f, 
    -0.13542749f, -0.03286811f, 0.11951283f, 0.01532990f, 0.67108357f, 0.03187107f, 0.11743370f, -0.12294241f, 
    -0.11904214f, -0.10752302f, 0.08417979f, 0.06679470f, 0.12970328f, 0.18481055f, 0.04095091f, 0.10462462f, 
    0.04725060f, -0.02763141f, -0.15920439f, -0.23459359f, -0.04683994f, 0.03660186f, -0.10858657f, 0.06094331f, 
    -0.05857713f, -0.07929897f, 0.13853566f, -0.02962926f, -0.19432612f, -0.43674693f, -0.12417311f, -0.15692344f, 
    0.05092021f, 0.09536631f, -0.05953850f, -0.03025313f, 0.09784586f, -0.12372313f, -0.11643501f, 0.01400858f, 
    0.04075641f, -0.18000950f, 0.16367373f, 0.09102583f, 0.10473508f, 0.08534889f, 0.15547141f, 0.05594919f, 
    0.16033146f, 0.27078307f, 0.00628001f, 0.03099146f, 0.39296171f, 0.26633337f, -0.03178667f, -0.03554457f, 
    0.06034467f, 0.00948995f, 0.12064733f, -0.06293608f, 0.05129173f, -0.06194986f, 0.04334097f, -0.13210791f, 
    -0.32833645f, -0.15542631f, -0.07496714f, -0.14111041f, -0.01958216f, -0.02557059f, 0.00000147f, 0.08350789f, 
    -0.06145943f, 0.13740245f, -0.12731437f, -0.04693032f, -0.07517660f, -0.04538523f, 0.22907914f, 0.01096369f, 
    0.31323549f, -0.05529066f, -0.14043511f, 0.01425829f, -0.07526313f, -0.04449511f, -0.01240744f, 0.10208508f, 
    -0.13841499f, 0.07754476f, 0.07846833f, -0.02436030f, 0.08768778f, -0.00356028f, -0.02156525f, -0.01540143f, 
    -0.02705529f, -0.05939075f, 0.13362081f, 0.08795767f, 0.05531195f, 0.12550697f, 0.16585812f, 0.22644360f, 
    0.11094189f, 0.06222971f, -0.04275913f, -0.02033344f, 0.05005984f, 0.12726061f, -0.12002506f, 0.00432785f, 
    -0.12772404f, 0.18364649f, -0.14288712f, 0.00569502f, -0.08657764f, -0.07842642f, 0.06767590f, 0.01426536f, 
    0.14475252f, 0.03025121f, -0.06609209f, -0.05162264f, -0.06657789f, 0.01808540f, 0.09064727f, 0.09671442f, 
    0.12915099f, -0.04053270f, -0.12549271f, -0.04419256f, -0.00863555f, 0.04957384f, -0.03453547f, 0.10785693f, 
    0.07726248f, -0.09737739f, 0.06922018f, 0.04761885f, 0.15321317f, 0.04939380f, 0.03321814f, 0.19736616f, 
    -0.08205981f, 0.15305121f, 0.06952133f, 0.10843944f, -0.00349314f, -0.09946468f, -0.07136642f, -0.18249498f, 
    -0.16674401f, -0.09597661f, -0.08924594f, -0.05134428f, 0.00910900f, -0.07993984f, -0.03113529f, -0.07223386f, 
    0.38007507f, 0.17688997f, 0.23776177f, 0.09604285f, 0.01647545f, -0.09212528f, 0.01953161f, 0.03303747f, 
    0.20557366f, 0.04345759f, 0.04575142f, 0.10536639f, -0.02556698f, -0.06338472f, 0.03689549f, -0.01788787f, 
    0.00683030f, 0.00571964f, 0.04935575f, -0.05851800f, 0.05174137f, -0.03766212f, 0.02167867f, -0.10312669f, 
    -0.09821744f, -0.01909588f, -0.07442503f, 0.09182048f, 0.05884243f, 0.09384269f, 0.00289007f, 0.01564541f, 
    -0.12603126f, 0.05124575f, -0.02341230f, -0.07750355f, 0.07368526f, -0.00036073f, 0.01798881f, -0.09745843f, 
    0.05874955f, -0.03326339f, 0.05938917f, 0.03061562f, -0.01879855f, 0.10774931f, -0.10444321f, 0.04321675f, 
    0.03436660f, -0.18063977f, -0.09357391f, -0.00558354f, 0.08008669f, -0.06026206f, -0.08267628f, 0.01389927f, 
    -0.05788736f, -0.27357253f, -0.00304584f, 0.08358876f, 0.59076452f, 0.12743524f, -0.05575403f, -0.04362201f, 
    0.01211264f, 0.05251523f, 0.00729953f, -0.13096273f, 0.08400625f, 0.04978375f, -0.09073493f, -0.08903479f, 
    -0.00770218f, -0.10387059f, 0.11238255f, 0.12489610f, 0.16536012f, 0.03075643f, -0.05802989f, 0.02321365f, 
    -0.00818049f, 0.06036862f, -0.12311634f, -0.06081219f, 0.21987967f, 0.05958480f, 0.03968901f, 0.16564295f, 
    0.06852102f, -0.01376650f, 0.01445838f, -0.10782105f, 0.03711823f, -0.08279847f, -0.03847765f, 0.12043230f, 
    -0.05883975f, -0.16874726f, 0.12482323f, -0.00413094f, 0.06684324f, 0.14409310f, 0.10435343f, -0.10787835f, 
    0.07423972f, -0.14190614f, -0.04536861f, 0.11908624f, -0.08916830f, -0.04429191f, 0.21254474f, 0.23899414f, 
    0.03935099f, -0.08025660f, 0.05997976f, -0.07554384f, 0.06024098f, 0.04841740f, 0.02575768f, 0.08056840f, 
    -0.17850609f, 0.39711353f, -0.01007651f, -0.05684827f, 0.11941472f, 0.01800156f, 0.01896293f, -0.02394720f, 
    0.11197809f, -0.09503057f, -0.00432584f, 0.21199735f, 0.21907832f, 0.14268863f, 0.11979550f, 0.08656279f, 
    0.29288307f, 0.14423630f, -0.02139765f, -0.04770036f, -0.03323320f, 0.11869457f, -0.07259177f, 0.01881453f, 
    -0.30053928f, 0.11935640f, -0.09614820f, 0.01177149f, 0.08686355f, 0.13382544f, -0.16557403f, 0.04127615f, 
    -0.06551506f, 0.14513259f, -0.04402463f, 0.13511378f, 0.02277349f, 0.01573818f, -0.13715856f, -0.05895897f, 
    0.10098809f, -0.09560816f, 0.03342129f, 0.05488041f, -0.05837542f, 0.10982278f, 0.06958802f, -0.08568537f, 
    -0.14516710f, -0.07863345f, 0.04478803f, -0.10115667f, 0.08110733f, 0.02313138f, 0.03682464f, -0.12053110f, 
    -0.02441990f, 0.07485870f, 0.02118503f, 0.28777105f, -0.48404697f, 0.02389469f, -0.02930174f, 0.12415138f, 
    -0.00150245f, -0.05763822f, 0.08115918f, 0.02817763f, 0.08192249f, 0.04343313f, 0.00484259f, -0.14815007f, 
    -0.23587345f, -0.17367722f, 0.02814229f, 0.10136005f, 0.00515329f, 0.03685810f, -0.01661825f, 0.16111314f, 
    -0.03863331f, 0.01851790f, -0.00616611f, 0.06323703f, -0.11638861f, 0.11205908f, 0.04553939f, -0.19933245f, 
    0.13646340f, 0.08032987f, -0.02958854f, 0.06300051f, -0.09738828f, 0.05506139f, 0.12494823f, -0.08339240f, 
    0.31782472f, -0.10590015f, 0.17268445f, 0.03123519f, -0.00344260f, 0.01323378f, -0.08034454f, 0.04999101f, 
    0.04658763f, 0.11124386f, -0.06171639f, -0.10518029f, -0.24378744f, -0.11650348f, 0.07976105f, 0.01858175f, 
    0.19228874f, -0.11085019f, -0.14081144f, -0.05290803f, -0.05226858f, -0.17604779f, -0.08094341f, 0.08263350f, 
    0.32083187f, -0.17925170f, 0.14531650f, 0.23494168f, -0.01054074f, 0.23144753f, 0.02224953f, 0.14893831f, 
    0.08009556f, -0.04541501f, 0.05177585f, 0.11380946f, -0.02700229f, 0.26017061f, 0.23479880f, 0.01030707f, 
    0.13354185f, -0.09539399f, -0.04675352f, 0.06205202f, 0.02488659f, 0.19837171f, 0.05749965f, 0.06207205f, 
    -0.56760240f, -0.19228107f, -0.02587105f, -0.12506995f, 0.03411563f, -0.03642010f, -0.06977706f, -0.05388413f, 
    -0.04121063f, -0.03182183f, 0.07577340f, -0.03668274f, -0.10093249f, -0.12458526f, 0.13721471f, -0.06142126f, 
    -0.07749136f, 0.16360176f, -0.01710289f, 0.00952162f, 0.11044693f, 0.01356626f, 0.16358408f, 0.09706489f, 
    0.26088169f, 0.14977916f, 0.09507979f, 0.12084281f, 0.02932430f, 0.03425428f, -0.00216059f, 0.05612682f, 
    0.07875809f, -0.06744164f, 0.11731350f, 0.06210579f, -0.26745379f, -0.01754003f, -0.12144523f, -0.06598726f, 
    0.01781935f, 0.10437287f, 0.08012597f, 0.12945172f, 0.21314199f, 0.03160051f, -0.02833215f, -0.05770512f, 
    -0.05422286f, -0.04694419f, -0.06370058f, 0.20205842f, -0.03740024f, 0.11370267f, 0.13347720f, 0.24439754f, 
    -0.02658417f, -0.13362440f, -0.14655311f, 0.18808365f, -0.16188250f, -0.02900720f, -0.15720055f, 0.16402288f, 
    0.11015183f, 0.01762197f, -0.00109024f, -0.17125642f, 0.05466845f, -0.01874135f, -0.14314434f, -0.00258943f, 
    -0.27327442f, -0.23104347f, 0.01072467f, -0.08436192f, 0.01140573f, -0.05567640f, 0.11374898f, -0.10569794f, 
    -0.01490699f, -0.08340161f, 0.00337450f, 0.06331270f, 0.24355234f, 0.19320522f, -0.01200532f, -0.00544885f, 
    0.06947632f, -0.01525530f, 0.01763156f, 0.03102929f, 0.12484688f, -0.09768315f, -0.03634779f, 0.05882985f, 
    -0.21229890f, 0.19630122f, -0.13684420f, 0.11006290f, 0.02096570f, 0.06313433f, -0.02068219f, -0.14814305f, 
    -0.02529182f, -0.09198948f, 0.04388240f, -0.19530709f, 0.19950972f, 0.27715746f, -0.06935329f, 0.25288594f, 
    0.14260057f, 0.23323475f, -0.02834510f, -0.04855872f, 0.10867608f, -0.12964790f, 0.06354017f, -0.10156342f, 
    0.16313262f, -0.15555969f, -0.02324566f, 0.05439118f, -0.01808783f, 0.05887479f, -0.06673592f, 0.01939514f, 
    0.07951177f, -0.04963654f, -0.16490509f, 0.00191749f, -0.17617556f, -0.24404551f, 0.24435428f, 0.03895900f, 
    0.09677240f, 0.07758024f, -0.01981625f, 0.01710217f, 0.13199916f, 0.16661274f, 0.13664758f, -0.05292489f, 
    0.07482109f, 0.22390606f, -0.11614800f, 0.04809419f, 0.02400853f, -0.10755563f, -0.10443477f, 0.14132997f, 
    -0.04313197f, -0.01367847f, 0.07447185f, 0.11319962f, 0.09075462f, -0.00128245f, 0.01529672f, 0.04290498f, 
    0.14674053f, 0.13948531f, -0.00136025f, -0.05045800f, 0.04194706f, 0.07310111f, 0.09376214f, -0.03527668f, 
    0.12083079f, -0.17603230f, -0.04985444f, 0.18430081f, 0.02460587f, 0.03355013f, 0.03923882f, 0.16293110f, 
    0.10374153f, 0.06479827f, 0.19489533f, 0.01791601f, 0.24565624f, -0.13591687f, 0.07614571f, 0.02103551f, 
    0.00721271f, 0.06751988f, 0.08217488f, -0.06002570f, 0.03865734f, 0.11303981f, 0.05509826f, 0.10683793f, 
    -0.28124619f, 0.28306749f, -0.12689222f, 0.03602398f, 0.07215064f, -0.00727410f, 0.08099383f, 0.05398802f, 
    -0.04371387f, 0.04853150f, -0.04846022f, 0.16822745f, -0.19317923f, 0.07872763f, -0.10841106f, -0.15668251f, 
    0.03194401f, -0.03158846f, -0.09846429f, 0.09979018f, -0.05582336f, -0.03941420f, 0.02778239f, -0.10920644f, 
    0.05310160f, 0.14882532f, 0.03464280f, 0.10479935f, -0.02301212f, -0.02010268f, -0.02489197f, -0.10385232f, 
    -0.05717940f, -0.10139840f, -0.03393372f, -0.00990300f, 0.06847360f, -0.01042609f, 0.25053054f, 0.18698606f, 
    -0.13844199f, -0.00295902f, -0.03529717f, -0.05023453f, 0.02221883f, -0.07000607f, -0.03772926f, 0.00280237f, 
    0.04452110f, 0.36346227f, 0.21612389f, 0.15832780f, 0.10499824f, -0.10463519f, 0.14814505f, -0.05423193f, 
    -0.00434101f, 0.03824261f, -0.02933664f, 0.09761091f, -0.07937725f, -0.30611587f, -0.09562306f, 0.54920483f, 
    0.17906453f, -0.05050333f, -0.06198857f, 0.03908142f, 0.07406477f, -0.02109955f, -0.03767214f, -0.07847568f, 
    0.42510542f, 0.12811838f, 0.23190527f, -0.20847513f, 0.04255055f, 0.03586782f, -0.00391423f, 0.00365036f, 
    0.03889486f, 0.02617101f, 0.08673269f, -0.10833304f, -0.52747369f, 0.21302927f, -0.08260410f, -0.24830449f, 
    0.09186874f, -0.02627030f, 0.12719433f, -0.01019231f, 0.01926992f, 0.08854332f, 0.01958160f, 0.01846102f, 
    0.16252936f, 0.00307684f, -0.12263524f, 0.13881892f, 0.08721086f, 0.07973615f, 0.07458602f, 0.19171998f, 
    -0.05588083f, -0.05697805f, 0.12816510f, -0.03559494f, 0.10044624f, 0.29760918f, 0.18754673f, -0.11666164f, 
    0.05036561f, -0.00241877f, 0.09654239f, 0.00601275f, 0.13938697f, 0.02158410f, 0.08759785f, 0.15812387f, 
    -0.33021569f, -0.02267500f, 0.09233759f, -0.17715825f, 0.19567750f, -0.09757363f, -0.02387701f, -0.05418912f, 
    -0.10916398f, 0.06197571f, -0.03794861f, 0.02612733f, -0.16213870f, 0.17915623f, 0.04233673f, -0.11397816f, 
    0.15272169f, -0.05123947f, 0.06962019f, 0.14839886f, -0.18028170f, -0.05889439f, -0.08818993f, -0.02880017f, 
    0.05385745f, 0.13006634f, 0.09700124f, 0.16653398f, -0.10868553f, 0.06573971f, 0.00738530f, -0.10868788f, 
    0.01052631f, 0.04547185f, -0.09963451f, 0.05611787f, 0.07523611f, 0.21476904f, -0.14211093f, 0.16990542f, 
    0.05660022f, 0.10687773f, 0.05520287f, 0.10936267f, 0.06761862f, 0.08001117f, -0.03436779f, 0.16358307f, 
    0.23468202f, -0.00247794f, 0.10411765f, 0.25549349f, 0.04270135f, -0.01026118f, 0.06010185f, 0.10573798f, 
    0.06728356f, 0.12056023f, 0.01453533f, 0.01383818f, -0.01972846f, -0.28801596f, 0.04524256f, 0.61218250f, 
    -0.00717413f, -0.09929349f, -0.10614951f, -0.28102422f, 0.14240588f, 0.00103266f, -0.17804949f, -0.12913489f, 
    0.35264069f, -0.08918700f, 0.17451373f, -0.19045706f, 0.18788648f, 0.13263820f, 0.10734374f, 0.10971006f, 
    0.01927037f, -0.05153953f, -0.00381794f, 0.21643367f, 0.01384351f, -0.00356577f, 0.24819329f, 0.24731006f, 
    0.03250770f, 0.00276508f, -0.25261036f, 0.02647866f, -0.00776390f, -0.05537513f, -0.24735384f, 0.02192524f, 
    -0.11280225f, -0.21930945f, 0.14714611f, 0.34256774f, 0.02683210f, -0.07155249f, 0.01759671f, -0.01340562f, 
    0.15087560f, 0.05294475f, -0.00300039f, 0.15450341f, -0.27213767f, -0.03546400f, -0.16312961f, 0.08064777f, 
    0.15239164f, 0.07757804f, 0.05215893f, 0.17599539f, -0.04912086f, -0.09904483f, 0.05972684f, 0.01618248f, 
    -0.47336105f, 0.20066853f, 0.00325400f, 0.10763534f, 0.06247716f, 0.07629897f, 0.01146906f, 0.25045264f, 
    -0.04628976f, 0.13170554f, 0.08012582f, 0.11878312f, -0.11615277f, -0.28201872f, -0.07919377f, 0.10996428f, 
    0.30660439f, 0.17791443f, -0.15075172f, 0.17119968f, 0.09676246f, 0.14794038f, 0.04793382f, 0.16841693f, 
    0.23841862f, -0.04421920f, 0.02287337f, 0.26313984f, -0.07746529f, -0.04154434f, 0.01643676f, -0.22091553f, 
    -0.01166837f, 0.05166294f, -0.02458404f, 0.19037172f, -0.24841544f, 0.32719544f, -0.12118118f, -0.05084977f, 
    0.07520556f, -0.04248638f, 0.02777763f, 0.06843594f, -0.02963534f, -0.03608295f, 0.07643066f, -0.02130674f, 
    -0.43946722f, 0.24659014f, 0.19977812f, 0.01344661f, 0.07987005f, 0.26088825f, 0.20286466f, -0.06371143f, 
    0.10137245f, -0.04051103f, -0.02724754f, -0.07985393f, -0.16539674f, -0.01052047f, 0.21039081f, 0.27552751f, 
    0.08605939f, 0.10867344f, -0.06353638f, 0.12660848f, 0.03124470f, 0.00868159f, -0.09676129f, 0.16940096f, 
    0.07550991f, -0.21681190f, -0.05940565f, -0.06506829f, -0.12027362f, 0.01635651f, 0.01451428f, 0.09940804f, 
    -0.00586345f, 0.20456494f, 0.26850167f, -0.06343868f, -0.33969855f, 0.13596308f, 0.20488390f, -0.07052529f, 
    0.00046778f, -0.00426636f, -0.08095650f, -0.03423903f, 0.01746519f, 0.01574136f, -0.02248458f, -0.03187248f, 
    -0.34501463f, 0.16298559f, -0.08032939f, -0.24006970f, 0.17889981f, -0.10412211f, -0.03086462f, -0.14933045f, 
    0.11502996f, -0.02562536f, -0.02111022f, -0.02863706f, 0.18431927f, -0.13352121f, -0.24113759f, 0.40900642f, 
    0.21693459f, 0.08511507f, 0.00339677f, 0.03883467f, -0.21454015f, 0.10593454f, 0.01902393f, -0.01365254f, 
    0.29782754f, 0.02448794f, -0.03652985f, 0.04455823f, -0.11858536f, -0.06315551f, 0.11505730f, -0.12070106f, 
    -0.07603186f, -0.15324302f, 0.01731058f, -0.03195267f, 0.06083482f, -0.09727815f, 0.19228625f, -0.26483700f, 
    -0.14981712f, 0.06926885f, 0.15496095f, 0.11234966f, -0.03958974f, -0.06281844f, 0.03004161f, -0.00063202f, 
    -0.32180047f, 0.28210220f, 0.18769710f, -0.45612469f, 0.20093276f, -0.06761820f, 0.01275618f, -0.12013962f, 
    -0.01893415f, -0.08599120f, -0.01465523f, -0.16031596f, -0.56765652f, 0.21937737f, -0.06206005f, -0.14422671f, 
    -0.01483112f, -0.21252458f, 0.12185059f, -0.02284983f, -0.11323427f, -0.02754062f, -0.03700206f, 0.02342312f, 
    0.24787645f, -0.01019447f, 0.04487232f, 0.09643859f, 0.10753538f, 0.01497198f, 0.00904586f, -0.06800202f, 
    0.00461846f, -0.00813592f, 0.09820256f, 0.13673502f, 0.40172789f, -0.03253204f, -0.36995047f, 0.21987508f, 
    -0.11532135f, 0.12981719f, -0.17669359f, 0.02767152f, 0.07049990f, 0.04236504f, -0.01432935f, 0.03003848f, 
    0.16431396f, 0.25896543f, -0.09081378f, 0.12542750f, -0.01328122f, 0.09523311f, -0.00324515f, 0.01436562f, 
    0.00016575f, -0.07624112f, -0.05110104f, 0.11572561f, -0.21402819f, 0.11704505f, -0.00179921f, -0.13951318f, 
    -0.14256054f, -0.18603218f, -0.09305931f, -0.04824372f, -0.08154098f, -0.02154438f, -0.01478780f, -0.06334554f, 
    -0.14277630f, -0.02782885f, -0.19798394f, 0.07574037f, -0.13739400f, -0.00866972f, -0.05893556f, 0.19480065f, 
    0.00527468f, -0.01919994f, 0.08222301f, -0.05064315f, -0.05675124f, -0.06991281f, 0.10462408f, 0.02067700f, 
    0.04300436f, 0.04137478f, 0.16692272f, 0.03958661f, 0.08521181f, 0.05068421f, 0.02792619f, 0.04327527f, 
    0.05801136f, 0.17362335f, 0.32242975f, 0.14612006f, 0.13748400f, -0.11493871f, 0.08957890f, -0.10737383f, 
    -0.06139850f, 0.06194462f, 0.00910246f, 0.04410365f, -0.21638057f, -0.31522444f, 0.04292722f, 0.12154622f, 
    -0.08546709f, 0.02426074f, -0.02445044f, -0.09221682f, 0.02565085f, 0.03300144f, -0.07135054f, 0.11829673f, 
    -0.28419277f, 0.03941169f, 0.10660078f, -0.16455038f, 0.03724387f, 0.01500518f, 0.10230718f, -0.09894893f, 
    0.01117774f, 0.01140786f, 0.08187542f, 0.14399555f, 0.43929484f, -0.10890144f, -0.03064231f, 0.00489351f, 
    -0.13067707f, -0.06403787f, -0.04452445f, 0.06371291f, -0.00764125f, -0.04131733f, 0.05804901f, 0.15667471f, 
    0.08621544f, 0.05419074f, -0.17645919f, 0.03968479f, 0.06468727f, 0.07961349f, 0.12833881f, 0.18513717f, 
    0.02572608f, 0.13951144f, 0.07087844f, 0.08951360f, 0.50346529f, -0.08866949f, 0.11886977f, -0.06348542f, 
    0.03650317f, -0.14610094f, 0.06436968f, 0.09105776f, 0.15224326f, 0.12309748f, 0.23046975f, 0.16144103f, 
    -0.18646874f, 0.20597114f, -0.03418040f, -0.18999328f, -0.08771636f, 0.00218726f, 0.02486944f, 0.06889253f, 
    0.08082170f, 0.15619417f, -0.02799625f, 0.05910330f, -0.34156948f, -0.18194808f, 0.11505301f, -0.14522250f, 
    0.11110433f, 0.10326447f, -0.02497581f, 0.01782990f, 0.01397390f, -0.01114485f, 0.00325378f, -0.00797345f, 
    -0.46411294f, -0.16518432f, 0.09092642f, 0.06021603f, -0.13159072f, 0.08834720f, 0.00542192f, 0.10427132f, 
    0.06306369f, 0.11495670f, -0.04824373f, 0.17851360f, 0.19478007f, 0.10708745f, -0.01348714f, 0.19086073f, 
    0.17341502f, 0.05438996f, 0.03740010f, -0.02483065f, 0.06112055f, -0.11387714f, 0.07724327f, -0.03216344f, 
    -0.26089200f, 0.07385597f, -0.03312270f, -0.20480378f, -0.03714360f, -0.11627927f, -0.01041402f, -0.00003352f, 
    -0.02022577f, 0.04345688f, 0.02783979f, 0.04647939f, -0.16848931f, -0.10236739f, 0.05099009f, -0.01506045f, 
    0.22952092f, -0.01341972f, -0.01664765f, -0.08101238f, -0.11274007f, -0.11115687f, 0.04459853f, 0.03443675f, 
    -0.23329142f, -0.00957282f, -0.08490916f, -0.03006362f, 0.13059372f, -0.08703914f, 0.11822341f, 0.03185965f, 
    -0.05056899f, 0.00917743f, 0.03029360f, 0.12728693f, -0.05868312f, -0.03747304f, 0.06774861f, 0.06035208f, 
    -0.03463602f, 0.06882973f, -0.01570140f, -0.02016508f, 0.00965917f, 0.09685103f, 0.16134602f, 0.25361523f, 
    0.14593363f, 0.04258529f, 0.10578581f, -0.04162043f, 0.09658311f, 0.03049810f, -0.01141295f, -0.04663641f, 
    0.17495540f, -0.05605516f, -0.01889563f, -0.07135764f, -0.15631017f, 0.04378647f, 0.12544660f, 0.02238152f, 
    0.14115843f, -0.01107100f, 0.00535348f, -0.04104199f, -0.01762545f, -0.03302329f, 0.05624760f, 0.08594804f, 
    -0.23767389f, -0.28590086f, -0.26239741f, 0.05041374f, -0.03962607f, -0.02738566f, 0.06813364f, 0.10238403f, 
    0.01667869f, 0.11393876f, -0.04549467f, 0.06587009f, 0.28378060f, -0.03836297f, -0.14130194f, -0.24891566f, 
    -0.20036051f, -0.05321509f, -0.09839972f, 0.11000619f, 0.14486116f, 0.14636099f, -0.07837093f, 0.15873095f, 
    -0.02642071f, 0.30755118f, 0.01928137f, 0.15084656f, 0.15099999f, 0.08307854f, 0.00419282f, 0.03386610f, 
    0.14518490f, -0.00915400f, 0.07701498f, 0.16355105f, 0.38278106f, 0.00786509f, -0.10411382f, 0.09790038f, 
    0.07591603f, 0.06554563f, 0.03812232f, -0.03500211f, 0.05279705f, -0.06383769f, 0.03446065f, -0.06186277f, 
    -0.01484702f, -0.08995778f, -0.08885527f, 0.05825954f, 0.01890920f, -0.01918693f, 0.06563310f, -0.04379308f, 
    -0.10300716f, -0.00598556f, 0.00714598f, -0.10777750f, 0.02441402f, -0.08823264f, 0.06862425f, -0.17885837f, 
    -0.17833903f, -0.07730172f, -0.05932371f, -0.05113021f, -0.07255900f, 0.04316694f, -0.02026144f, 0.07583473f, 
    0.04521728f, 0.17144434f, -0.02377387f, 0.06682603f, 0.03655465f, -0.05049674f, -0.04360241f, 0.05501573f, 
    -0.08728053f, -0.17747176f, 0.04581239f, 0.06117818f, 0.43445727f, -0.03209839f, -0.18270411f, 0.10229304f, 
    -0.04928112f, 0.01974631f, -0.04812548f, -0.04669389f, 0.14035869f, 0.06569958f, -0.11598624f, -0.14688557f, 
    0.11386375f, -0.17671533f, 0.01172431f, 0.08363930f, 0.05508201f, 0.06733819f, 0.02189730f, 0.01875182f, 
    -0.01730602f, -0.03156724f, -0.02897392f, 0.00117557f, 0.16142049f, 0.01981831f, 0.07621844f, 0.10783620f, 
    0.06030872f, 0.00307303f, -0.12410655f, 0.03356901f, -0.01440051f, -0.05183856f, -0.01479333f, 0.05267892f, 
    0.43073460f, -0.31489709f, -0.02876823f, 0.24756314f, 0.10773852f, 0.04412655f, -0.05284894f, -0.02367792f, 
    -0.07505646f, 0.12695894f, 0.08536596f, 0.09997056f, 0.43322745f, 0.04030756f, -0.20869589f, 0.01608839f, 
    0.07049897f, -0.07688048f, 0.07321183f, -0.02683431f, 0.14665265f, 0.05908661f, -0.02195354f, -0.00156407f, 
    0.13166358f, -0.55319828f, 0.24850008f, 0.18440989f, 0.02425497f, 0.08893207f, 0.06969374f, -0.02780971f, 
    -0.03574727f, -0.01460140f, -0.05158411f, 0.08919460f, -0.22302695f, 0.21517448f, -0.05083580f, -0.10072342f, 
    -0.12814549f, -0.15506573f, -0.04283753f, -0.10855400f, 0.01891136f, -0.01473718f, 0.02265859f, 0.08965246f, 
    -0.09199645f, -0.11370230f, 0.16650169f, -0.05066928f, -0.04469100f, 0.01394953f, 0.02450375f, 0.16021502f, 
    0.04784619f, 0.04052887f, -0.12908818f, 0.01357414f, -0.02498581f, 0.12898971f, 0.10349166f, 0.01237838f, 
    0.03410998f, -0.11217528f, 0.10283965f, -0.07673280f, 0.11175973f, 0.02380144f, -0.05042315f, 0.09317552f, 
    0.12191774f, -0.05649009f, -0.08718687f, 0.25434273f, 0.07946371f, 0.02679345f, -0.00362983f, -0.06163230f, 
    -0.12174512f, -0.00450359f, 0.03947200f, -0.04338805f, 0.17554754f, -0.15932412f, -0.01978079f, -0.00265340f, 
    -0.08095664f, -0.03539992f, -0.12143660f, 0.00033157f, -0.05830809f, 0.02288776f, -0.02226836f, 0.02822153f, 
    0.06305984f, 0.29389122f, 0.01088876f, 0.00399061f, -0.01910266f, 0.03443494f, -0.05440689f, -0.00712385f, 
    0.07682780f, 0.04025647f, 0.02711098f, 0.06835303f, 0.14446878f, -0.07720587f, -0.05054986f, -0.02607959f, 
    -0.02759692f, -0.06913273f, -0.04351201f, 0.04818131f, 0.14819376f, 0.12180459f, 0.02874884f, 0.00699341f, 
    -0.08253404f, 0.11952055f, 0.06914335f, 0.03766321f, 0.09494814f, -0.04501741f, -0.02053476f, -0.01189927f, 
    0.13341345f, 0.07866541f, -0.04547509f, 0.09473794f, 0.06926996f, -0.17005087f, -0.19087972f, -0.00315968f, 
    -0.00297881f, -0.05432856f, -0.04753700f, -0.01480602f, -0.07472905f, 0.02547020f, 0.15503655f, 0.04756522f, 
    -0.32818100f, 0.36353761f, -0.05516200f, -0.09125102f, 0.12117237f, 0.07804365f, -0.01298726f, 0.04399199f, 
    0.06853633f, 0.00423168f, 0.03401593f, 0.01623244f, -0.12503918f, 0.03275143f, -0.02505575f, 0.01004183f, 
    0.08469772f, 0.08557354f, 0.10220706f, 0.16158673f, -0.03802081f, -0.07778833f, 0.09302592f, 0.19575351f, 
    -0.33419451f, 0.20877863f, -0.08896726f, -0.06974310f, -0.06380339f, -0.00107764f, -0.16140331f, 0.02794971f, 
    -0.05391859f, -0.03699408f, -0.04410135f, -0.09436368f, 0.44766831f, -0.04745213f, -0.24073581f, 0.37896100f, 
    0.01871554f, 0.05482897f, 0.13949144f, -0.06630337f, -0.07664987f, 0.01010317f, 0.16979271f, 0.01118682f, 
    -0.09372315f, 0.23646174f, -0.20394716f, -0.10524587f, 0.01517207f, -0.09009185f, -0.01447428f, -0.00608193f, 
    -0.00657415f, 0.00691548f, -0.00881121f, -0.08973071f, 0.14870048f, -0.07845147f, 0.04084504f, 0.10002321f, 
    0.05158291f, 0.05312385f, 0.04836522f, 0.05411347f, 0.01872596f, 0.06860830f, 0.08738549f, 0.00350397f, 
    0.09409893f, -0.13642709f, 0.05711737f, 0.08173674f, 0.09072844f, -0.05951580f, 0.07766605f, -0.18244871f, 
    0.01502705f, 0.04100845f, 0.01612461f, 0.01857322f, 0.07956519f, 0.07643524f, 0.04217057f, -0.05847148f, 
    -0.04041211f, -0.02231970f, 0.06255069f, 0.04863280f, 0.02095752f, 0.05946997f, 0.10711459f, 0.05060108f, 
    0.09599396f, 0.03556224f, -0.02038390f, 0.18106872f, 0.03423325f, -0.03362937f, 0.01705721f, 0.01500770f, 
    0.13145046f, -0.05462716f, -0.00791440f, -0.04021061f, -0.23088875f, 0.09624920f, -0.20291182f, 0.00780408f, 
    -0.01888439f, 0.03061312f, 0.13579796f, 0.01062929f, 0.13413510f, 0.05349620f, -0.08890039f, 0.06423696f, 
    0.40910164f, -0.18084037f, -0.08919935f, -0.03604277f, 0.01237905f, -0.16967621f, 0.08990144f, -0.08126218f, 
    -0.00667373f, -0.02389787f, 0.00177895f, -0.03476940f, 0.07409243f, -0.10952588f, -0.01748626f, 0.04559270f, 
    -0.15337054f, -0.12553069f, -0.06872449f, -0.02305616f, 0.11982701f, 0.11637033f, -0.07205131f, -0.06410421f, 
    0.33087477f, 0.08089773f, -0.20835561f, -0.11708840f, 0.08275102f, 0.12820175f, -0.06786247f, 0.06667428f, 
    -0.06547412f, 0.00567328f, 0.02219919f, -0.06191935f, 0.07957703f, 0.05749578f, -0.28595722f, -0.14108340f, 
    0.02366650f, 0.04772999f, 0.02272121f, 0.05631549f, 0.12433875f, 0.00959190f, -0.03151482f, 0.03763377f, 
    0.07557347f, -0.05464446f, 0.09773289f, 0.06114138f, 0.06359489f, 0.02423818f, 0.01478145f, 0.06421512f, 
    -0.08384051f, 0.06410143f, 0.01276229f, -0.01636165f, 0.16551319f, 0.04671770f, 0.01213323f, 0.02080516f, 
    -0.23301905f, -0.02746652f, -0.05314051f, 0.00296385f, 0.16518484f, -0.18668978f, -0.19465783f, 0.00348885f, 
    -0.22905760f, 0.33634052f, -0.08879175f, 0.02121557f, -0.04976356f, 0.17058069f, -0.05470050f, 0.01908866f, 
    0.09927560f, 0.03248783f, 0.07780942f, 0.14433557f, 0.32054633f, 0.11984345f, -0.07690174f, -0.05663312f, 
    -0.02142042f, -0.07533383f, 0.04993771f, 0.00151163f, 0.05773624f, 0.08588582f, -0.05388115f, 0.16485339f, 
    0.48406780f, -0.30590785f, 0.01891876f, 0.01954739f, -0.12028446f, -0.06764007f, -0.06994747f, 0.05404194f, 
    -0.06674249f, -0.15129925f, 0.09412703f, 0.15864967f, -0.00266643f, -0.04325380f, -0.18350765f, 0.09614250f, 
    0.13524471f, 0.01872144f, -0.08938356f, 0.13503183f, -0.01340402f, -0.03056706f, -0.02671127f, 0.00922450f, 
    0.03953065f, -0.04242815f, 0.02802584f, 0.02037462f, 0.00997685f, 0.02490793f, 0.01505454f, 0.05290920f, 
    0.01476573f, -0.01474032f, -0.03841449f, 0.01537832f, -0.05117041f, -0.00763926f, 0.03780212f, -0.04213808f, 
    -0.04042272f, 0.01971859f, -0.01117991f, 0.00408179f, -0.02191542f, -0.04262162f, -0.04106604f, -0.04986846f, 
    0.01432248f, -0.03514545f, 0.04417247f, 0.05063010f, -0.02070587f, 0.01177459f, 0.00486584f, 0.01631428f, 
    0.02730441f, 0.00371826f, -0.02851294f, 0.00528376f, -0.01211284f, 0.04245945f, 0.02132975f, -0.04856144f, 
    -0.00076839f, -0.02402361f, -0.05577510f, 0.00702104f, -0.00972643f, 0.02355372f, -0.01068537f, -0.01778753f, 
    0.02336509f, -0.01605937f, -0.03038668f, -0.00016967f, -0.03903605f, -0.04751762f, -0.01743070f, 0.00772101f, 
    0.00167397f, -0.02587225f, 0.03682464f, -0.04166825f, -0.02769364f, -0.01174856f, -0.02173001f, -0.01577765f, 
    -0.02313875f, -0.02386430f, -0.03655370f, -0.03107152f, -0.04334486f, -0.03134219f, -0.00696611f, 0.04661384f, 
    -0.02342415f, 0.01950042f, 0.03792436f, -0.01081336f, -0.04928643f, -0.01372838f, -0.04482687f, 0.02318395f, 
    0.02549460f, -0.01109339f, -0.00910080f, -0.04188564f, -0.02400749f, -0.00897935f, 0.03276638f, -0.01294350f, 
    0.02016836f, -0.03187666f, -0.03698795f, -0.04979269f, 0.03593980f, -0.04728581f, -0.03060476f, -0.03006955f, 
    -0.03182195f, -0.02709462f, 0.01446616f, 0.02539232f, 0.02104264f, 0.01575073f, -0.01583246f, -0.02466246f, 
    0.02902001f, -0.05659534f, -0.02079834f, -0.00641479f, -0.02419893f, -0.02635458f, 0.03598928f, 0.00926599f, 
    -0.04504437f, -0.00584941f, 0.02795203f, -0.02895240f, -0.03749603f, -0.03865427f, -0.01329685f, 0.04188729f, 
    -0.03457287f, 0.03781722f, -0.04862512f, -0.05085137f, 0.03641421f, -0.00111044f, 0.01516641f, 0.02159779f, 
    0.01019526f, 0.02965905f, 0.02033684f, 0.03102203f, -0.03972783f, 0.00219279f, -0.05186806f, -0.03488227f, 
    0.02297909f, -0.02079936f, -0.01681060f, 0.03429530f, -0.00579699f, 0.03281789f, -0.01121269f, -0.05059049f, 
    0.03093738f, 0.00990180f, 0.00958381f, -0.04208643f, -0.05541397f, -0.02681979f, -0.01291449f, 0.01996560f, 
    -0.01413255f, -0.01467360f, 0.00140680f, 0.00215093f, 0.01036321f, 0.03475927f, 0.02168247f, -0.03035837f, 
    -0.05688500f, 0.04278319f, -0.02306401f, -0.00722410f, 0.01775277f, 0.01075260f, 0.02615741f, -0.03135841f, 
    0.05339053f, -0.05128098f, -0.02600831f, -0.05357112f, 0.02281832f, 0.02863054f, -0.02277591f, 0.03072749f, 
    -0.00221779f, 0.02866893f, -0.00605833f, 0.04177110f, 0.02625576f, 0.03620376f, 0.01118054f, 0.00446239f, 
    0.01501029f, 0.01575893f, 0.02801755f, -0.05277540f, -0.01075878f, 0.03093120f, 0.00095529f, -0.00820285f, 
    -0.04502348f, 0.03799485f, -0.01086010f, 0.05252796f, -0.03613911f, -0.02438298f, -0.02108339f, -0.04758011f, 
    -0.05406339f, -0.03703868f, -0.02791895f, -0.03247251f, -0.00492216f, -0.00973044f, -0.02664395f, 0.03373329f, 
    0.02622432f, -0.04923196f, -0.05230434f, 0.04704404f, -0.04424348f, 0.04017077f, -0.05556872f, 0.04580832f, 
    -0.04234934f, 0.03161454f, 0.03352614f, -0.03340242f, -0.04831090f, -0.00386277f, -0.01305064f, -0.00594093f, 
    -0.04157310f, -0.00570576f, -0.02079422f, 0.02694768f, -0.02246131f, 0.00061691f, -0.01008087f, 0.01805397f, 
    0.00802690f, 0.04058713f, 0.03929621f, -0.03235010f, 0.02869934f, -0.02463278f, -0.01974081f, -0.04360899f, 
    -0.03459322f, -0.00209518f, -0.04437245f, -0.00623948f, -0.01773091f, -0.03686031f, 0.00286255f, -0.00066328f, 
    0.01628810f, -0.02762181f, 0.03804595f, -0.02659757f, -0.00763368f, -0.04395384f, 0.00983914f, -0.00940550f, 
    -0.04177932f, -0.01576015f, -0.05129069f, 0.02576065f, -0.00779901f, 0.01685407f, 0.03947679f, -0.02364393f, 
    -0.01827910f, 0.00188881f, -0.01539370f, 0.03439635f, -0.01570670f, 0.02225187f, -0.04845379f, 0.03772116f, 
    0.04501765f, 0.03727721f, 0.00363944f, 0.00169930f, -0.04862244f, 0.03263934f, 0.01810646f, 0.03782349f, 
    -0.05402051f, 0.03818631f, -0.00357569f, -0.03164394f, 0.03449217f, -0.01597209f, -0.02536628f, 0.03285269f, 
    0.03714277f, -0.03337634f, -0.00151726f, -0.03020183f, 0.00047890f, -0.04754841f, 0.03841747f, 0.03323400f, 
    0.04209138f, 0.02921572f, -0.01335701f, 0.03003710f, -0.02983769f, -0.04038458f, 0.02738300f, -0.01658042f, 
    -0.03025608f, -0.03331779f, -0.02929972f, 0.01015149f, -0.03336484f, 0.03138499f, -0.01367765f, -0.05865766f, 
    0.00291579f, 0.05249719f, 0.00209041f, -0.03554951f, -0.00303843f, 0.02110828f, 0.01661208f, 0.04091905f, 
    -0.03245848f, -0.00349500f, 0.01432945f, -0.00056058f, 0.04629007f, -0.00260874f, -0.05693520f, -0.04869465f, 
    -0.02267696f, 0.00194125f, -0.05405206f, 0.03669224f, -0.04665660f, 0.00335486f, -0.04170318f, -0.04914588f, 
    -0.02539433f, -0.03576938f, 0.02735589f, -0.01453195f, -0.01896888f, -0.00292043f, -0.02609769f, 0.00921589f, 
    -0.01276028f, -0.00157832f, 0.04552280f, 0.03180829f, -0.01690820f, 0.04360281f, -0.00525856f, 0.00973953f, 
    0.01911259f, -0.01327666f, 0.01659442f, 0.03598307f, -0.05786282f, -0.00934752f, -0.00948404f, 0.02699634f, 
    0.02781824f, 0.01136515f, 0.01230843f, -0.02041318f, 0.01771608f, -0.02949060f, -0.01033221f, -0.02068567f, 
    0.04001061f, -0.02647506f, 0.02243328f, 0.00700630f, -0.02096275f, -0.01381901f, 0.04282348f, 0.04998137f, 
    -0.00782656f, 0.00486559f, 0.01426676f, 0.00099914f, -0.00196692f, 0.00378710f, -0.00262556f, -0.00912123f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03216830f, 0.03126718f, 0.00472662f, 0.07365374f, 0.00262213f, -0.05305914f, 0.01453780f, -0.07075509f, 
    0.00863182f, -0.04012967f, 0.10238539f, -0.02718348f, 0.01423614f, -0.01498414f, 0.02973966f, -0.03961230f, 
    0.08451691f, -0.00899232f, 0.04142419f, 0.08036962f, -0.05416902f, -0.00411168f, -0.02646432f, -0.05080405f, 
    -0.00024567f, -0.04563999f, -0.08082539f, 0.17859492f, -0.03283944f, 0.05059428f, 0.01170165f, -0.03467106f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14660721f, -0.02216095f, 0.12959878f, 0.23063266f, -0.00353227f, -0.07336266f, 0.40366131f, 0.02876102f, 
    0.03726652f, 0.00678748f, -0.68062335f, -0.07620587f, -0.49888533f, -0.20637426f, -0.00923710f, 0.11734598f, 
    0.25601348f, -0.01840452f, 0.39396614f, -0.47743538f, 0.30446303f, -0.01608593f, -0.03690303f, -0.11319130f, 
    -0.34377992f, 0.12440187f, -0.02466116f, -0.58035111f, 0.24737969f, -0.41636145f, -0.06995676f, 0.15426178f, 
    0.07090656f, -0.00060721f, -0.02743053f, 0.05560942f, 0.03652944f, 0.00634580f, 0.30794600f, 0.08791980f, 
    0.36525559f, -0.10517167f, -0.05042699f, -0.32282245f, 0.39072579f, -0.11957340f, -0.08369244f, 0.06833076f, 
    -0.44860595f, -0.15066256f, 0.51914042f, -0.16101460f, -0.33014318f, 0.16317856f, 0.00987963f, 0.09533718f, 
    -0.30255246f, -0.04951002f, 0.30038795f, 0.16440065f, -0.36517334f, 0.16734515f, 0.10835939f, 0.00017260f, 
    0.02899870f, -0.02828571f, 0.12285827f, -0.19508627f, -0.14790773f, -0.13087749f, 0.04620792f, 0.26326764f, 
    0.16424361f, 0.02552852f, -0.08355574f, 0.25289768f, -0.01591846f, 0.52039635f, 0.07193644f, 0.02284365f, 
    0.28705132f, -0.03874047f, -0.08319969f, -0.04330086f, -0.52836651f, -0.15106541f, 0.26020807f, 0.00911417f, 
    -0.33503088f, 0.02494477f, -0.10658029f, -0.61223280f, -0.07877380f, -0.41489914f, 0.16261905f, 0.08948663f, 
    -0.09525181f, -0.15477809f, 0.15649925f, -0.17841819f, 0.11979045f, 0.06877724f, 0.19384904f, -0.08677591f, 
    0.19539057f, 0.04048961f, -0.27367994f, -0.75183791f, 0.45221061f, -0.28472760f, -0.12431379f, -0.05316801f, 
    0.05162229f, 0.01650581f, -0.62275726f, -0.19529738f, 0.42871591f, 0.02506824f, 0.14181019f, -0.15590438f, 
    0.20796792f, 0.15218648f, -0.55988067f, 0.02729660f, 0.08579500f, 0.28014395f, 0.21935189f, 0.11462011f, 
    0.03465566f, -0.09413272f, -0.09557767f, 0.17449711f, -0.01015740f, -0.08314057f, 0.26372492f, -0.29140529f, 
    0.09637938f, -0.02147736f, -0.32216370f, -0.19350663f, -0.47355753f, 0.19639066f, -0.08007108f, 0.10424953f, 
    -0.10993636f, -0.00568351f, -0.68289870f, 0.48843077f, -0.10160483f, 0.12251095f, -0.03737526f, 0.10559618f, 
    -0.14653061f, -0.05493400f, 0.06314924f, 0.11629601f, 0.42829505f, 0.11094079f, -0.28770381f, -0.04101616f, 
    0.15305810f, -0.14775507f, 0.04133803f, 0.32265824f, 0.11787609f, -0.06048707f, -0.33372131f, 0.00269504f, 
    -0.15711601f, -0.02192641f, 0.38556001f, 0.28653446f, -0.38538811f, -0.17473488f, -0.11791057f, -0.01712378f, 
    -0.32231501f, 0.10691623f, 0.08184440f, -0.04129650f, 0.26824406f, -0.12196765f, -0.69734102f, -0.07740317f, 
    -0.65589327f, -0.12372715f, -0.21245940f, 0.35407981f, 0.29869145f, -0.16859925f, -0.15713374f, -0.13999212f, 
    0.01609906f, -0.08541960f, 0.07304834f, -0.00307968f, -0.15605797f, -0.12123054f, -0.54525745f, -0.36046413f, 
    -0.04640049f, 0.10676697f, -0.22044230f, 0.27680430f, -0.20911202f, 0.12516843f, 0.18350951f, -0.11537189f, 
    0.17056148f, 0.14762951f, 0.24954543f, 0.35428238f, 0.18360820f, -0.16564438f, -0.28669077f, -0.06967917f, 
    0.34356278f, 0.10337923f, 0.19964147f, -0.29731962f, -0.46176085f, 0.34491724f, -0.20776053f, -0.01503579f, 
    -0.05002624f, 0.09599566f, 0.07294377f, -0.15649237f, -0.07565045f, 0.03388530f, -0.09778921f, 0.36557341f, 
    -0.48387000f, 0.15357710f, -0.01266819f, 0.07590437f, -0.26640052f, 0.03700918f, 0.13861008f, -0.07308248f, 
    -0.41972178f, -0.03385574f, -0.05691468f, 0.18776265f, 0.21154304f, -0.14250237f, 0.25336981f, 0.11888124f, 
    0.33253354f, 0.08220232f, -0.02331936f, 0.20049353f, 0.04696822f, -0.51204687f, -0.42277941f, -0.04330833f, 
    -0.00927121f, -0.01253606f, -0.14671716f, 0.05263562f, 0.15999231f, 0.09186167f, -0.21570590f, 0.48944685f, 
    0.13559647f, 0.03855865f, 0.14930104f, 0.10174239f, -0.53309983f, 0.10415499f, 0.09081472f, -0.05000696f, 
    0.13384992f, -0.15674883f, -0.62338305f, -0.64897048f, 0.01893827f, 0.13447362f, -0.59939688f, -0.17042568f, 
    -0.35910699f, 0.16473855f, 0.13666326f, -0.18126056f, -0.42861068f, 0.34849194f, 0.31876343f, 0.01508307f, 
    0.15981118f, 0.12774451f, 0.09229863f, 0.24608539f, 0.16572538f, 0.09421911f, -0.64366192f, -0.19049765f, 
    -0.22299464f, 0.04263011f, -0.23154007f, 0.34631345f, 0.44129503f, -0.26097983f, -0.01910931f, -0.07767414f, 
    0.36774909f, -0.01143446f, -0.25920588f, -0.44384608f, -0.61405748f, -0.01257512f, 0.42967299f, -0.03224653f, 
    -0.04429856f, 0.12629926f, 0.25542185f, 0.30493253f, 0.06237584f, 0.00047442f, -0.47253937f, -0.12933190f, 
    -0.03894478f, 0.06594425f, 0.14985192f, 0.00795794f, 0.16157576f, -0.17126612f, 0.43659782f, 0.21443330f, 
    -0.14863625f, 0.15486616f, 0.31218475f, 0.06380662f, -0.02187516f, -0.33407438f, -0.13450630f, 0.13405868f, 
    0.40025440f, 0.04550665f, -0.33287778f, 0.07241991f, -0.06625617f, 0.14164099f, 0.04642656f, 0.07124708f, 
    -0.09547945f, 0.10565697f, -0.84454465f, 0.35670674f, -0.60260749f, -0.57189620f, -0.01064913f, -0.09593423f, 
    0.02252585f, 0.05773931f, 0.12658529f, -0.42469025f, -0.14073299f, -0.11948279f, 0.13362516f, -0.15511511f, 
    -0.49470937f, 0.11627370f, 0.26326355f, 0.24133924f, 0.09497397f, -0.47686383f, 0.03150902f, 0.16744000f, 
    -0.09894996f, 0.07155052f, -0.09996457f, 0.14499827f, 0.23204309f, 0.07573269f, 0.30870044f, -0.02411134f, 
    -0.48791301f, -0.01152026f, 0.35731253f, -0.00545943f, -0.11229134f, 0.25589240f, 0.45040280f, -0.00273687f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21378793f, 0.13901076f, -0.13814403f, 0.03296382f, 0.19134183f, 0.19457638f, 0.08735134f, -0.06816755f, 
    0.14187217f, 0.17436703f, 0.27105108f, -0.03396632f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
