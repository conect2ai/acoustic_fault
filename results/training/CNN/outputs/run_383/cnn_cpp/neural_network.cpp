#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.06792200f, 0.26674384f, 0.92384362f, -0.87336165f, -0.61275446f, 0.35689235f, -0.29294175f, 0.40085113f, 
    -0.48737431f, 0.03703779f, 0.20305291f, -0.03179969f, -0.23130542f, 0.44759628f, -0.59859103f, 0.62005544f, 
    -0.04381649f, 0.13063401f, -0.26587042f, -0.16174920f, -0.28526658f, -0.23256809f, 0.63402635f, -0.36350343f, 
    -0.09118078f, 0.35253099f, -0.74049067f, 0.47496429f, 0.77426237f, 0.38636675f, 0.63383621f, 0.88634396f, 
    0.24195316f, 0.49922442f, 0.71661794f, -0.23592184f, 0.74775624f, 0.18682587f, 0.44557509f, -0.21469189f, 
    -0.08381362f, -0.15051477f, 0.19525591f, 0.03679423f, 0.10221702f, 0.21294309f, 0.05269272f, 0.12355477f, 
    0.04761999f, -0.16148473f, 0.71952248f, -0.10445978f, 0.62386727f, 0.22915304f, 0.32776651f, 0.59033757f, 
    -0.95273495f, -0.51278090f, -0.34003437f, 0.21104491f, 0.51314366f, 0.63506109f, 0.00670097f, 0.00571954f, 
    -0.26379323f, -0.37738216f, 0.22418685f, 0.28185523f, 0.17690174f, 0.06101876f, 0.16398735f, 0.25846228f, 
    -0.11576170f, -0.02535354f, 0.25863475f, -0.58620572f, -1.06981719f, -1.05669963f, -0.70093352f, -0.03560025f, 
    -0.12952554f, 0.46768242f, 0.13367070f, -0.13323322f, 0.25179124f, 0.28392908f, 0.37643623f, 0.14862616f, 
    -0.14571184f, -0.26616177f, -0.27900362f, 0.02102025f, -0.12498162f, -0.12698974f, -0.19926943f, -0.44745919f, 
    -0.52405769f, 0.45812768f, -0.19208346f, -0.21502747f, -1.04131186f, -0.87858737f, 0.71553081f, 0.20673680f, 
    -0.79502958f, 0.00350137f, 0.02789469f, -0.45253593f, -0.04196148f, -0.68520570f, -0.18561086f, 0.41702878f, 
    -0.31882474f, 0.76534015f, 0.45910686f, 0.06161610f, -0.22442578f, 0.32322776f, -0.24188502f, -0.39650983f, 
    0.11594592f, -0.21482705f, 0.00230753f, -0.40746614f, -0.07389349f, 0.84423023f, 0.90981811f, 1.20180380f, 
    0.27674133f, 0.26855257f, -0.38161096f, 0.58043724f, -0.54737389f, 0.05110841f, 0.56684399f, -0.00499485f, 
    0.44372436f, 0.27512917f, 0.00108397f, -0.09729478f, -0.44791839f, 0.10120460f, 0.21895598f, 0.04360625f, 
    0.09673481f, -0.23726591f, 0.10782243f, 0.28389579f, 0.24906689f, 0.14674416f, 0.38728926f, 1.38339269f, 
    -0.66800565f, -0.10910036f, -1.08035207f, 0.84302461f, 0.51863497f, -0.76945537f, 0.30232209f, 0.38457173f, 
    0.49628279f, -0.21182840f, -0.21437363f, -0.07897513f, 0.12087607f, 0.37549707f, -0.34666592f, 0.19572349f, 
    0.16218768f, -0.05670763f, 0.06108984f, -0.23345162f, 0.00294661f, -0.09267437f, 0.25071272f, -0.05514721f, 
    0.50390965f, 0.60522556f, 0.47442421f, 1.06082737f, -0.97349614f, -0.76382393f, -0.01936945f, -0.64393085f, 
    0.05120476f, 0.50676239f, -0.06937966f, 0.08846593f, 0.52342111f, 0.09657572f, 0.41078889f, -0.23354562f, 
    -0.19931304f, 0.37586263f, 0.06769387f, -0.09444975f, -0.00880707f, -0.10020418f, -0.17661412f, -0.12379783f, 
    0.85217440f, -0.71864200f, 0.61292785f, 0.09653257f, -0.36184564f, 0.82420468f, -0.15009113f, 0.48563373f, 
    0.64353430f, 0.65180856f, -0.06041379f, -0.56202114f, -0.24377581f, -0.14260821f, -0.24475327f, 0.14353766f, 
    0.30292296f, 0.02656277f, -0.27182388f, 0.20044906f, 0.46111345f, -0.36543083f, -0.01168537f, -0.04897375f, 
    -0.26118088f, 0.95280707f, 0.82301933f, -0.49262267f, 0.32289755f, 0.10189322f, -0.80898178f, -0.63088977f, 
    0.46156842f, -0.22176893f, 0.02647053f, -0.10196482f, -0.00835361f, 0.15276390f, -0.16916476f, -0.38257679f, 
    0.39617252f, -0.69662529f, -0.19105436f, -0.39680457f, 0.10483852f, -0.31505099f, -0.30828232f, -0.13098399f, 
    -0.56386787f, -0.49952981f, 0.28057235f, 0.59047323f, -1.07448089f, -0.96881062f, 0.00561514f, 0.79518014f, 
    -0.65413034f, 0.55231780f, 0.09473803f, -0.26550752f, 0.33131182f, 0.15619318f, 0.18601315f, 0.08739913f, 
    -0.49579284f, -0.01015212f, 0.31809041f, -0.11331414f, -0.16049853f, 0.05634249f, -0.11281289f, 0.17522684f, 
    0.03075096f, -0.06342225f, 0.53100634f, 1.48316514f, 0.30209562f, -0.87195921f, 1.47489548f, 0.30544639f, 
    0.84803081f, 0.53330761f, -0.13339932f, 0.64722192f, 0.22229004f, -0.17737977f, -0.24735311f, 0.00101675f, 
    -0.34934056f, -0.06953324f, 0.00982534f, -0.11254295f, -0.00857908f, -0.17841142f, -0.01252477f, 0.00684962f, 
    -0.38101214f, -0.17158271f, -0.18513434f, -0.16960227f, -1.28928506f, 0.75326532f, 0.67128259f, -0.85970736f, 
    0.76493168f, -0.65695077f, 0.77778268f, -0.39003089f, -0.27706063f, -0.55888927f, -0.20438027f, 0.33378956f, 
    0.41738328f, 0.04170439f, -0.11190026f, 0.13707258f, 0.01631390f, 0.07521669f, -0.03563904f, 0.32573286f, 
    0.00274791f, 0.04772573f, 0.14393443f, 0.20572045f, 0.26822522f, 1.18561113f, 0.01711814f, 0.63689631f, 
    0.79250252f, 0.95973259f, -0.67389560f, 0.83321589f, 0.17116918f, -0.54909992f, 0.04513097f, 0.32795516f, 
    -0.10021628f, -0.08937325f, -0.20917955f, -0.04330184f, -0.41328001f, -0.11357794f, 0.09725525f, 0.08734555f, 
    -0.17517631f, -0.14960054f, 0.41050279f, 0.15112549f, 0.13076635f, -0.12546062f, 0.35164085f, 0.38679850f, 
    0.68001395f, -0.36665767f, 0.25326246f, -0.88391632f, -0.76393151f, -0.73113650f, -0.00694383f, -0.45857602f, 
    0.25722289f, 0.48673841f, 0.37565011f, 0.22014706f, 0.19117807f, -0.33799690f, 0.24958736f, -0.16247310f, 
    -0.25713781f, -0.11558685f, 0.38855970f, -0.30955118f, 0.08229189f, -0.11064960f, 0.41849983f, 1.19000328f, 
    0.87319964f, 0.01818494f, -0.02986346f, -0.57236236f, -0.32390085f, 0.10616434f, -0.24547625f, 0.36924914f, 
    0.27935654f, 0.47796458f, 0.02751323f, -0.02825073f, -0.22246118f, -0.34982425f, -0.01227730f, -0.04132574f, 
    -0.15932529f, -0.14195149f, -0.26494554f, 0.07976306f, 0.34757751f, 0.01750524f, 0.27283615f, 0.07973329f, 
    -0.07680013f, 0.35175729f, 1.01959920f, 0.48731354f, -0.51390070f, -0.74362612f, -0.25332481f, -0.80568737f, 
    -0.74827820f, -0.48208070f, 0.38743839f, 0.25680938f, -0.14417242f, -0.14515851f, 0.18229511f, 0.07385905f, 
    -0.16228004f, -0.16887841f, 0.09314089f, 0.16779105f, 0.07759030f, 0.31359336f, 0.48172909f, 0.33131269f, 
    -0.16468544f, -1.28939867f, -0.71873468f, -0.35487685f, -0.04986150f, -0.67878300f, 0.87635607f, 1.20948327f, 
    -0.24137701f, 0.36889550f, 0.84856671f, -0.35748830f, -0.50871634f, 0.02110208f, -0.31125700f, 0.28193322f, 
    -0.28809607f, 0.17726515f, -0.18959427f, 0.00934524f, -0.36897898f, 0.01600430f, -0.27021560f, -0.01629412f, 
    0.23175812f, -0.16541028f, -0.61719608f, -1.20337880f, -0.50859135f, -0.52467841f, -0.52812558f, 0.28745162f, 
    -0.66863817f, 0.35300580f, 0.19482812f, 0.05301591f, 0.20641544f, -0.22615074f, -0.39633688f, 0.34804776f, 
    -0.35818526f, 0.08688937f, 0.29326767f, -0.02161882f, -0.07467206f, 0.13964155f, -0.03792826f, 0.09875856f, 
    0.43897122f, -0.03360501f, 0.50008518f, -0.71319824f, -0.56277102f, 0.02868756f, 0.99442631f, -0.25386572f, 
    -0.90850699f, -0.06479459f, 0.12976962f, 0.21667902f, -0.46564576f, 0.19977769f, 0.40078893f, 0.01608327f, 
    0.08376622f, 0.24199674f, -0.70686847f, 0.28562051f, -0.35044515f, 0.03310267f, -0.51092523f, -0.11135388f, 
    -0.04524792f, -0.17895731f, -0.12946889f, -0.29770064f, -0.68757969f, -0.15243213f, -0.19097517f, -0.09360515f, 
    0.38664985f, -0.38678500f, 0.27910849f, 0.90103638f, 0.41111684f, 0.49890137f, 0.20450115f, -0.14084266f, 
    -0.36934301f, -0.71029359f, -0.25614733f, 0.70885903f, -0.51015711f, -0.42458951f, -0.52856410f, 0.00153344f, 
    -0.48057476f, -0.11079311f, -0.22153510f, 0.22873557f, -0.53925860f, 0.55644250f, 0.69263637f, 0.79721981f, 
    0.44919854f, 0.87341499f, -0.32226878f, 0.46210456f, 0.21776660f, 0.01768967f, 0.38755673f, 0.10912517f, 
    -0.16258457f, -0.22148781f, -0.13659485f, -0.10016707f, 0.10874146f, 0.31189361f, -0.29492787f, 0.55825680f, 
    0.83713597f, 0.42533678f, 0.15123695f, 0.24848841f, -0.13970682f, -0.04369133f, 1.11416209f, 0.42080525f, 
    0.18515465f, -0.94471896f, -0.99854511f, -0.56438357f, -0.13762681f, -0.42889461f, 0.06189401f, 0.14375453f, 
    0.36125463f, 0.44219020f, -0.08776334f, -0.01346883f, 0.18283851f, 0.24965486f, -0.11410987f, -0.27883083f, 
    0.14007604f, 0.31080452f, 0.00037940f, 0.25405443f, -0.48920012f, 0.04837552f, 0.15637511f, 0.38778263f, 
    0.70426363f, 0.41032958f, 0.87352163f, 0.36965623f, 0.31867477f, 0.26620609f, 0.72320503f, 0.10474613f, 
    0.31559214f, -0.69521105f, -0.54876190f, 0.02104486f, -0.16693053f, 0.31300688f, -0.11267512f, 0.02170596f, 
    -0.09017386f, -0.32467529f, 0.25880173f, 0.01924186f, -0.23976219f, -0.17153293f, 0.25345600f, 0.26742399f, 
    -0.54024732f, -0.55356133f, -0.31661153f, -0.17497310f, -0.00530619f, -0.26170909f, -0.69318962f, -0.18565910f, 
    -0.53479034f, 0.35576075f, -0.53122151f, 0.23844011f, 0.68874300f, -0.06950726f, 0.30632707f, 0.35184562f, 
    0.28620160f, 0.56769270f, 0.32803571f, -0.48614019f, 0.25059357f, -0.28952226f, -0.40148482f, -0.13622788f, 
    0.04122927f, -0.36050329f, 0.00696031f, -0.53269404f, 0.22676528f, 0.68803954f, -0.69583344f, 0.06250113f, 
    -0.42926118f, 0.01840248f, 0.43642020f, 0.24919201f, 0.54658294f, -0.34399486f, 0.08280278f, 0.18932252f, 
    -0.27958691f, 0.38406143f, 0.31245133f, 0.06245387f, 0.27990401f, -0.48951846f, 0.04644290f, 0.30671620f, 
    0.59265512f, 0.22580762f, -1.48185420f, 0.87044519f, 1.16593540f, -0.25446516f, 0.84977245f, 1.13892436f, 
    -0.43527851f, 0.06807815f, -0.28804502f, -0.80445522f, -0.12239889f, -0.09095416f, 0.36092016f, 0.33517289f, 
    -0.35291934f, -0.11774289f, -0.04273434f, -0.04491547f, -0.33461916f, 0.08307050f, -0.10782326f, -0.27245662f, 
    -0.16089422f, -0.11532452f, -0.30511472f, -0.40268493f, -1.29813087f, 0.00805646f, 0.84087145f, -0.24603945f, 
    -0.95740062f, 1.31623268f, 1.02764630f, -0.99603778f, 0.32214510f, -0.11477698f, 0.27604902f, 0.07544840f, 
    0.20060422f, 0.29295811f, -0.12137274f, 0.24130437f, -0.15239014f, -0.06559651f, -0.29625919f, 0.15167265f, 
    -0.18014757f, -0.09090072f, 0.21033372f, -0.02606134f, 0.77066320f, 0.42233151f, -0.93608272f, 1.33967543f, 
    -0.72389734f, -0.68998593f, -0.07197522f, -1.01732826f, 0.38658369f, -0.24161665f, 0.19005485f, -0.26497793f, 
    0.31731129f, 0.08068685f, -0.16704471f, 0.27057761f, -0.11069095f, -0.03569800f, 0.05949743f, -0.19300018f, 
    -0.02709624f, 0.00097392f, 0.26314995f, -0.05967903f, 0.10152157f, -0.08586497f, -0.24890634f, -0.58411789f, 
    -0.90383255f, -0.78307217f, -0.00564300f, 1.00564659f, 0.46733776f, -0.20322268f, -0.02596370f, -0.13823631f, 
    0.21296459f, -0.61313528f, -0.19469325f, -0.21244887f, 0.30578068f, -0.01177492f, -0.04208932f, 0.05227137f, 
    0.26378521f, 0.17184108f, 0.14617363f, -0.17323339f, -0.28758347f, 0.41955447f, 0.98314410f, 0.21546400f, 
    0.62857580f, 1.08788562f, 0.63047612f, 0.08521317f, 0.11834892f, -0.76091224f, -0.30248800f, 0.18264027f, 
    -0.36427185f, -0.13196997f, -0.33126834f, 0.07804155f, -0.56089693f, -0.20049554f, 0.03884834f, -0.37822741f, 
    -0.34274402f, -0.37816575f, 0.38825995f, 0.66225284f, -0.22552288f, 0.05035632f, 0.14324330f, 1.03723705f, 
    0.41806442f, -0.94151682f, -1.31876218f, -0.47296932f, 0.31160456f, -0.01083549f, 0.63332337f, 0.88830930f, 
    0.49766681f, -0.44867206f, -0.23547937f, -0.41136602f, -0.14138307f, -0.18659824f, -0.15788245f, -0.07183935f, 
    -0.08846563f, 0.33083990f, -0.12294891f, -0.25582257f, -0.07243275f, -0.07928890f, 0.09428244f, -0.22412814f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20858492f, 0.23539147f, -0.06879140f, -0.02799344f, 0.42122743f, 0.07479431f, 0.11064427f, 0.02588010f, 
    -0.09141378f, 0.16521491f, 0.11033070f, 0.20671935f, 0.13666436f, 0.21428096f, 0.01692303f, 0.08948293f, 
    0.23323216f, -0.00807595f, 0.11666154f, 0.25846985f, 0.21014929f, 0.21514910f, -0.10711495f, 0.31156203f, 
    0.25129423f, 0.10192926f, 0.02872535f, 0.09129852f, 0.22140135f, 0.09060534f, 0.04839387f, 0.33131039f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23688228f, 0.14140181f, -0.02768585f, -0.31686968f, -0.36895853f, -0.21562564f, -0.01712222f, -0.01721715f, 
    -0.02326489f, 0.22632213f, -0.13727698f, -0.21880265f, -0.09221452f, 0.06955372f, -0.30974579f, 0.09336703f, 
    -0.00790812f, -0.01095537f, 0.07149568f, 0.00287294f, -0.04376227f, 0.10873211f, 0.08237667f, -0.12648146f, 
    0.14980507f, -0.31078017f, 0.25780728f, -0.21654864f, -0.23355450f, 0.05423985f, 0.12816894f, -0.00836091f, 
    0.20058699f, 0.11740652f, -0.14090998f, 0.03701947f, -0.24886420f, 0.04501810f, 0.01551068f, -0.37599438f, 
    -0.04694045f, -0.00367706f, 0.22981252f, 0.05155867f, 0.02198053f, 0.10393690f, -0.13115069f, -0.09616680f, 
    -0.39469305f, 0.08764194f, -0.09458972f, 0.27710873f, -0.05269557f, 0.08650087f, 0.05092756f, 0.14221558f, 
    0.11889172f, 0.09171764f, -0.05484316f, -0.20058756f, 0.01964265f, 0.03867662f, 0.02949977f, 0.12600100f, 
    -0.09908745f, -0.21428183f, -0.06021147f, 0.12118016f, -0.01903341f, 0.15372172f, -0.07433686f, 0.05581531f, 
    0.52327466f, 0.16872492f, 0.08982052f, -0.29156575f, -0.11858431f, 0.09503587f, 0.12761633f, -0.04350683f, 
    -0.03032331f, 0.05551992f, -0.06575073f, 0.07387754f, 0.20306151f, 0.19160520f, -0.09580001f, 0.01778963f, 
    -0.01058711f, 0.03779577f, -0.03249752f, -0.03164148f, 0.06946480f, -0.00763700f, 0.16478480f, -0.05337203f, 
    0.29036602f, -0.03573006f, -0.06097677f, 0.25763983f, 0.16922258f, 0.13334213f, 0.12026180f, -0.02725083f, 
    -0.06857982f, 0.03731151f, -0.06411621f, 0.12034514f, 0.26379240f, 0.13044494f, 0.10289810f, -0.17627604f, 
    -0.31294319f, -0.01469724f, -0.12562735f, 0.19747166f, 0.00121160f, 0.01413958f, 0.07454473f, -0.06139749f, 
    0.21171448f, -0.21254034f, 0.10345442f, -0.35366827f, -0.18750148f, -0.09284363f, 0.16124938f, 0.02683166f, 
    0.01725867f, -0.03573247f, 0.09003872f, -0.09611978f, 0.07686250f, 0.03548181f, -0.07555033f, 0.48891434f, 
    -0.22650577f, 0.17036493f, 0.00915946f, 0.12332942f, -0.05323296f, -0.02522935f, -0.08014825f, 0.03105301f, 
    -0.43476659f, -0.25156543f, 0.22647849f, -0.13578339f, -0.01688756f, 0.07724562f, -0.07275180f, 0.11019670f, 
    -0.10528319f, -0.04312048f, 0.01628026f, 0.03271939f, 0.37111932f, 0.15140150f, -0.23493585f, 0.22222744f, 
    -0.36871171f, -0.13547085f, -0.14217640f, 0.06066542f, -0.13269766f, -0.05189624f, -0.07435735f, -0.08994949f, 
    -0.07806205f, 0.14068539f, 0.13396978f, -0.13078563f, -0.14781763f, -0.01593144f, 0.11158030f, -0.19790049f, 
    0.06743315f, -0.12061954f, 0.09723036f, -0.14505292f, -0.26527712f, 0.10364843f, -0.10169058f, 0.00057159f, 
    0.06306788f, -0.00084023f, -0.06032251f, 0.11597013f, 0.06464367f, 0.08102722f, 0.04778097f, -0.05829873f, 
    -0.16612504f, 0.18546040f, -0.18233465f, 0.30063638f, 0.09397274f, 0.12889376f, -0.09019013f, 0.00750483f, 
    0.02075392f, 0.03425058f, 0.10351494f, -0.05941206f, 0.76320148f, 0.20552441f, 0.13967180f, -0.14650835f, 
    0.16474013f, 0.09694881f, -0.11695602f, 0.17078704f, 0.03840386f, -0.11018251f, -0.14305784f, 0.05571575f, 
    0.00647327f, -0.23435745f, -0.24609061f, -0.42217860f, -0.13201877f, 0.07483028f, -0.00430721f, 0.24825881f, 
    -0.04526085f, 0.02689227f, -0.01536184f, -0.07697270f, -0.08812641f, -0.05023983f, -0.34857145f, 0.34524962f, 
    -0.00523622f, -0.16274719f, 0.01062235f, -0.16301036f, -0.03756035f, 0.01414683f, -0.01884564f, 0.10141334f, 
    -0.01149961f, 0.19425079f, -0.05277633f, -0.11346851f, -0.25262788f, 0.12410160f, -0.06685223f, 0.07519534f, 
    0.11432577f, 0.04021563f, 0.00151041f, -0.03951954f, 0.03553080f, 0.04619833f, 0.10222949f, 0.01536711f, 
    -0.03905712f, 0.13626228f, -0.01948282f, -0.10560068f, 0.16054547f, -0.15157814f, -0.02340425f, 0.06145154f, 
    -0.51184767f, 0.11690098f, 0.20545158f, -0.10567858f, 0.05577186f, 0.05652947f, -0.12549651f, 0.09355310f, 
    0.02506826f, 0.03606772f, -0.00811417f, 0.12990178f, 0.06776703f, 0.00364989f, -0.07313372f, 0.19317925f, 
    -0.05836156f, 0.04633410f, 0.06731565f, 0.05823283f, -0.06142006f, 0.08204561f, 0.00882011f, -0.08623998f, 
    -0.23617375f, -0.24115793f, 0.12055363f, 0.11531460f, -0.00174423f, -0.19080383f, 0.04009418f, 0.01281024f, 
    0.04949512f, -0.02001049f, -0.43108580f, 0.22589128f, -0.05197612f, -0.24983047f, 0.12609725f, 0.12804730f, 
    -0.05309612f, 0.02694068f, -0.03946153f, 0.14975342f, -0.05819628f, -0.06727941f, -0.07255517f, -0.05326167f, 
    -0.74341172f, -0.09304319f, 0.30793175f, -0.04163872f, 0.03681240f, 0.02021726f, 0.06406490f, -0.18259315f, 
    0.12828562f, -0.25866422f, 0.00665665f, 0.07707678f, -0.48041835f, 0.00420506f, -0.07060986f, 0.27139521f, 
    -0.09670123f, 0.07920356f, -0.28294092f, -0.11689728f, 0.13136832f, 0.05528213f, 0.15837142f, -0.02444472f, 
    -0.11545476f, 0.07247657f, 0.02478882f, 0.25037587f, -0.07974382f, 0.02319442f, -0.21487801f, 0.02817333f, 
    -0.06532460f, -0.09127621f, 0.00834296f, 0.10575622f, -0.16157673f, 0.06102141f, 0.21799563f, -0.86755097f, 
    -0.12698679f, 0.05333161f, 0.13479970f, 0.02250256f, -0.06125602f, 0.07195959f, 0.02845966f, 0.14422062f, 
    0.35011005f, 0.03224952f, 0.03829769f, 0.30094266f, -0.05231026f, -0.22548245f, 0.05018846f, 0.01173568f, 
    -0.18551579f, 0.20042241f, -0.13953823f, 0.02468008f, 0.29389903f, -0.01421482f, -0.14602481f, -0.56295669f, 
    0.03165277f, -0.03143663f, 0.00034467f, -0.16436215f, -0.18496232f, 0.02405779f, 0.00116664f, 0.01156993f, 
    0.21243317f, 0.28421542f, -0.05912444f, -0.10044555f, 0.22836106f, -0.13224925f, 0.01319653f, -0.11768404f, 
    -0.10626790f, -0.07522302f, 0.15656808f, 0.05068918f, 0.50647265f, 0.03308498f, 0.11496416f, 0.08674403f, 
    -0.06767054f, -0.00055902f, -0.00003992f, 0.00348547f, 0.03409388f, -0.10192697f, -0.06087736f, -0.07705564f, 
    -0.20616682f, 0.14136124f, 0.34525722f, 0.03747845f, -0.21060127f, -0.03600274f, -0.01175145f, 0.03366289f, 
    -0.03617129f, 0.06534562f, 0.19131115f, -0.07047898f, 0.42313242f, -0.05522918f, -0.07466786f, -0.04297409f, 
    -0.12629604f, -0.21011241f, 0.02693876f, -0.01283847f, -0.14416578f, -0.26617932f, 0.10643242f, 0.18831728f, 
    -0.16932616f, 0.18644808f, -0.32695860f, 0.03550314f, -0.19596611f, 0.04906817f, -0.03404104f, 0.02845067f, 
    -0.14802895f, -0.16063936f, -0.08360605f, 0.15738513f, 0.29864779f, 0.23351033f, 0.12467333f, 0.14072815f, 
    -0.25106150f, 0.08380642f, 0.12836021f, -0.10055765f, 0.12357436f, -0.30684957f, 0.15751849f, -0.11897662f, 
    -0.23321980f, -0.29341203f, 0.00868265f, -0.21228877f, -0.06272395f, -0.11084662f, -0.02696701f, 0.07569339f, 
    0.03848503f, -0.15569063f, -0.21096075f, 0.07114822f, -0.01851824f, 0.00097182f, 0.03765684f, -0.08130093f, 
    0.00834889f, -0.05587706f, 0.02834778f, -0.01816707f, -0.11842235f, 0.04295092f, -0.21136893f, 0.18883413f, 
    0.14029844f, 0.07555097f, 0.17997418f, -0.09656549f, -0.01359200f, -0.15372157f, -0.01699539f, 0.03179518f, 
    0.39328849f, 0.31168130f, -0.00261710f, -0.04322924f, 0.13026027f, -0.08392102f, 0.04064569f, -0.12563546f, 
    0.07029292f, -0.25966892f, -0.01677909f, 0.01362130f, 0.12370385f, -0.13777815f, -0.10058197f, 0.12832971f, 
    -0.08793509f, -0.45701799f, 0.07796593f, -0.35910615f, -0.07454567f, -0.04040344f, -0.09032599f, -0.03860691f, 
    0.01742091f, 0.11457521f, 0.08498647f, 0.03425512f, 0.27596715f, -0.36121911f, 0.05803419f, 0.07004700f, 
    -0.03468513f, -0.00299714f, -0.21413624f, -0.03361182f, -0.02281834f, 0.11479404f, -0.03044708f, 0.08625978f, 
    -0.45166990f, 0.15813066f, -0.24080688f, -0.40039608f, -0.00115180f, 0.15489163f, 0.12496471f, -0.04881815f, 
    0.02338098f, 0.07868893f, 0.13403621f, 0.10017098f, 0.01792811f, 0.02912026f, 0.15504029f, 0.35403910f, 
    -0.25233424f, 0.16356492f, 0.08809901f, 0.01879339f, 0.07267394f, -0.01641636f, 0.00444583f, 0.00874468f, 
    -0.39906842f, 0.07421735f, 0.03353443f, -0.01702792f, 0.07692652f, -0.06520949f, -0.08508375f, 0.16640802f, 
    0.11900280f, 0.02573504f, 0.04484544f, -0.02479905f, 0.58147877f, 0.02009797f, -0.01004368f, 0.01995098f, 
    -0.07904204f, -0.18638207f, 0.07015844f, 0.02465883f, -0.05728152f, -0.02377966f, -0.11114807f, 0.22524087f, 
    -0.25563106f, -0.04552018f, -0.10484255f, -0.05070977f, -0.05162868f, -0.04961544f, 0.05896421f, -0.05322833f, 
    0.07658596f, 0.02968892f, 0.04915973f, -0.04766708f, -0.20178342f, 0.00201697f, -0.20698676f, -0.09225159f, 
    0.07097787f, -0.06435864f, -0.11537732f, -0.14266472f, 0.00666503f, 0.15970156f, -0.00937403f, -0.04339221f, 
    -0.09111903f, -0.00602808f, -0.01240152f, -0.04964916f, -0.00788404f, -0.02364731f, -0.01107849f, 0.06817860f, 
    0.13693030f, 0.03533185f, 0.01699482f, 0.00337958f, -0.02285430f, -0.01810760f, -0.28677276f, 0.09233943f, 
    -0.07684719f, -0.02242565f, -0.26450583f, 0.01090576f, -0.11395950f, -0.10022724f, -0.04538533f, -0.13139774f, 
    -0.01075412f, 0.05555527f, -0.04306384f, -0.15813170f, 0.12873153f, 0.11378389f, -0.14415354f, -0.05484805f, 
    -0.04888642f, -0.14820208f, -0.22991040f, -0.09049042f, 0.21650520f, -0.00126121f, 0.07207106f, 0.34275460f, 
    -0.13702515f, -0.08787373f, 0.00001758f, 0.00826776f, -0.03864456f, 0.10012288f, -0.01616052f, 0.10957479f, 
    0.38368812f, -0.05126423f, -0.19485915f, -0.24048053f, -0.01224197f, -0.07113554f, -0.10530531f, 0.08006727f, 
    -0.30976897f, 0.18105762f, -0.02631004f, 0.15945728f, 0.31209120f, 0.23215106f, 0.08334291f, 0.31604254f, 
    -0.17443006f, 0.04320215f, 0.04019684f, 0.01603720f, -0.00839486f, 0.02635310f, 0.04162580f, -0.09572667f, 
    0.18361588f, 0.13754976f, -0.02363620f, -0.09120696f, -0.07013535f, -0.00813859f, -0.03347025f, 0.00591576f, 
    -0.04594025f, -0.13959862f, 0.23009206f, -0.01740962f, 0.09127391f, -0.24183275f, -0.12079552f, 0.02523856f, 
    0.00802677f, -0.11865319f, -0.10797729f, 0.10245297f, 0.07648493f, -0.08691295f, 0.14979991f, 0.13967118f, 
    0.34697568f, 0.03750283f, -0.35210216f, -0.18288799f, -0.04073504f, 0.12005033f, -0.05050993f, -0.27351859f, 
    -0.07478976f, 0.06868567f, 0.00933815f, -0.13152172f, -0.06265243f, -0.00839152f, -0.05078706f, 0.23021203f, 
    -0.17514881f, 0.02592082f, -0.00666987f, 0.06239476f, 0.01813638f, -0.09905551f, 0.01497429f, -0.08705337f, 
    0.46540508f, -0.58608735f, -0.37645274f, -0.04648497f, 0.02141515f, -0.15849648f, 0.10408717f, 0.18815506f, 
    -0.17226064f, 0.11892656f, 0.07154302f, -0.12447896f, -0.00708431f, -0.23208955f, -0.19943424f, -0.20437466f, 
    0.07500648f, -0.11423609f, -0.10668740f, 0.08795249f, 0.04250278f, 0.01619009f, -0.16936523f, -0.16919561f, 
    0.24733411f, -0.10100468f, 0.29103705f, 0.05685898f, -0.18402612f, 0.19133601f, 0.07080577f, 0.09249020f, 
    0.01964930f, -0.16084039f, 0.06828715f, -0.22125271f, 0.19326782f, -0.31107959f, 0.29391345f, -0.35300702f, 
    0.22993879f, -0.15708080f, 0.04581953f, 0.02909848f, -0.01456669f, -0.01738669f, 0.04339290f, -0.15490197f, 
    -0.73414606f, -0.09741842f, -0.19188723f, -0.08863147f, 0.16252014f, -0.10731249f, 0.14897169f, 0.08052425f, 
    -0.22191122f, -0.03316190f, -0.22720061f, -0.11609633f, 0.06121741f, -0.00319096f, 0.01145081f, 0.02803855f, 
    -0.16475779f, 0.07143880f, 0.06365144f, -0.03151124f, -0.10153770f, -0.01700315f, 0.04306339f, -0.01888268f, 
    -0.36516163f, 0.09613375f, 0.13573153f, 0.02359635f, -0.09260482f, 0.09271319f, 0.04849900f, -0.06748652f, 
    -0.04451643f, 0.10045364f, -0.03473713f, -0.13322029f, 0.26468039f, 0.02473981f, 0.24029681f, 0.05854828f, 
    -0.18566078f, -0.28759235f, -0.04735439f, 0.00863812f, -0.09165918f, 0.02484242f, -0.04179404f, -0.05812926f, 
    0.48268175f, -0.07282397f, -0.32002851f, -0.34407052f, -0.17468405f, -0.02029591f, -0.07893104f, 0.14078707f, 
    0.06750128f, 0.02871772f, -0.16418152f, -0.13264216f, 0.10440899f, 0.15828010f, 0.01704271f, 0.08489538f, 
    -0.00719145f, 0.11668768f, 0.04437495f, 0.10104980f, 0.11390693f, 0.03528498f, -0.00154031f, -0.07384942f, 
    0.45071205f, -0.16997930f, 0.05853671f, -0.20147777f, 0.10363844f, -0.04666458f, 0.08381356f, -0.12556621f, 
    -0.05046586f, -0.04552196f, 0.07445751f, -0.07065263f, 0.23649089f, 0.08890343f, -0.40906009f, 0.28627625f, 
    0.09331515f, 0.15876752f, 0.01644427f, -0.17846587f, -0.16208450f, -0.13007812f, -0.02599899f, -0.03607638f, 
    -0.21828249f, 0.20920092f, 0.04322433f, 0.13481946f, 0.02204640f, 0.02485140f, 0.15781924f, 0.09935258f, 
    -0.04350194f, -0.13161606f, 0.03797461f, -0.15037814f, -0.13902147f, 0.01957260f, -0.17686312f, -0.11060365f, 
    0.10820550f, 0.07607453f, 0.15684032f, 0.03411008f, 0.12345972f, 0.02429060f, 0.05919432f, -0.19768272f, 
    -0.18475290f, 0.04549008f, 0.11215689f, 0.04802104f, -0.00195580f, -0.25330162f, 0.11233222f, -0.14121711f, 
    -0.07093263f, -0.18014075f, 0.00908724f, 0.02920221f, 0.38473618f, -0.23766071f, -0.01410658f, -0.12820084f, 
    0.16905442f, 0.02713499f, -0.07597487f, 0.15346226f, -0.05006415f, 0.05001084f, 0.10412075f, -0.03759239f, 
    0.28246176f, -0.33471161f, -0.58651698f, -0.11238507f, 0.04208990f, -0.04176204f, -0.09031585f, -0.08242058f, 
    0.06618392f, 0.01711150f, 0.02972828f, -0.09926090f, 0.11773892f, 0.19639595f, 0.00003095f, 0.02228188f, 
    0.25068283f, 0.02454711f, -0.07723264f, 0.06328080f, 0.02504458f, 0.02367057f, 0.00513008f, 0.06061982f, 
    -0.14291164f, 0.03042353f, -0.28839719f, -0.07209483f, 0.14596184f, 0.09864839f, -0.01472683f, -0.01611957f, 
    0.01252326f, 0.00697979f, -0.08766456f, -0.16422336f, 0.12932539f, 0.14100689f, 0.12864572f, -0.15941396f, 
    -0.07095876f, -0.13712142f, 0.07694091f, 0.05532142f, -0.08647395f, 0.02182857f, 0.04296706f, -0.13276322f, 
    0.08313016f, 0.07652034f, -0.25379714f, -0.25477567f, -0.13060012f, 0.13269585f, -0.06973591f, 0.01493376f, 
    -0.13314453f, -0.15794928f, -0.13124156f, -0.18919532f, 0.52479821f, 0.10075379f, 0.35939303f, 0.12652645f, 
    -0.08559731f, -0.19490671f, -0.00646921f, 0.10442419f, 0.06707852f, 0.11010195f, -0.02698577f, 0.03666723f, 
    -0.25287685f, 0.08596980f, 0.11181275f, 0.20888123f, -0.28742525f, -0.19023375f, -0.38478488f, -0.17778236f, 
    -0.10215212f, -0.06270998f, 0.08463645f, -0.04815409f, 0.34243041f, -0.29270905f, -0.23447651f, -0.08608758f, 
    -0.18950377f, -0.00941779f, -0.02607968f, -0.15733700f, 0.00830730f, 0.08772673f, -0.01662631f, -0.10498422f, 
    0.15946420f, -0.10181468f, 0.03100784f, 0.15270676f, -0.23023061f, 0.06074570f, -0.00306525f, -0.07843689f, 
    0.00184139f, 0.11302765f, 0.04749145f, -0.19309790f, 0.06063071f, 0.06516437f, 0.02140340f, 0.10207538f, 
    0.14219700f, 0.03642631f, 0.04768213f, -0.00364355f, -0.15018527f, -0.00093170f, 0.02185027f, 0.03173684f, 
    -0.58441174f, 0.10831328f, 0.25792488f, -0.20875886f, 0.00886526f, 0.08031216f, 0.10783114f, -0.01572522f, 
    -0.00394072f, -0.09394798f, -0.00094275f, -0.03909562f, -0.11324735f, -0.04454173f, -0.18105336f, -0.02501114f, 
    0.11864367f, -0.00200791f, -0.00065141f, -0.01874764f, 0.01408543f, 0.00119425f, 0.04052718f, 0.05114119f, 
    0.15880685f, -0.21127979f, 0.01595813f, 0.12409371f, -0.11520734f, -0.07669804f, -0.15375079f, 0.06890181f, 
    -0.05831448f, 0.01268205f, -0.22418883f, 0.07897961f, 0.27696645f, -0.18672298f, 0.00536736f, -0.18669519f, 
    -0.09952686f, 0.05404152f, -0.15635468f, 0.03695522f, -0.20791785f, -0.05080455f, 0.14153561f, -0.06628334f, 
    0.41014117f, 0.10087918f, -0.05924016f, 0.22742160f, -0.18504472f, 0.03919742f, 0.16846797f, -0.14496318f, 
    -0.10271551f, -0.01096495f, -0.11314850f, 0.12486912f, 0.73803675f, -0.06322145f, -0.18045773f, 0.02218817f, 
    -0.07375163f, 0.00431598f, -0.00611036f, -0.00134640f, -0.06222750f, -0.04230480f, -0.13191099f, -0.03687780f, 
    -0.16544907f, 0.00048329f, -0.37909818f, -0.26488906f, -0.08617408f, 0.01524390f, -0.15546858f, 0.00224751f, 
    -0.03101473f, 0.08030356f, 0.00211293f, -0.14065355f, 0.10210606f, 0.16013210f, 0.16729844f, 0.14577852f, 
    -0.11775286f, -0.34545919f, -0.00246384f, -0.00819948f, -0.00667383f, -0.09135018f, 0.07319334f, -0.00195866f, 
    -0.15184493f, 0.05670217f, -0.01618561f, -0.12342826f, 0.09409272f, 0.05816636f, -0.05584470f, -0.03512514f, 
    0.08143638f, 0.20075504f, 0.05467899f, 0.01537779f, -0.21650746f, 0.10579832f, -0.08374575f, 0.31796885f, 
    -0.10580178f, -0.11385301f, 0.11857455f, 0.08996610f, -0.13865705f, -0.02784501f, 0.09487411f, -0.06362196f, 
    -0.16326873f, -0.42225125f, -0.02691282f, 0.07292264f, -0.12707159f, -0.08865949f, -0.05848859f, 0.23475237f, 
    0.05494434f, 0.17574026f, -0.06152626f, -0.04647663f, -0.48106268f, -0.25262564f, -0.26042214f, -0.36111268f, 
    0.00716820f, -0.02052346f, 0.05005814f, -0.09873980f, -0.06721275f, -0.04073535f, -0.00193151f, 0.09572575f, 
    0.04346414f, -0.04306388f, -0.31633857f, 0.51395708f, 0.11740844f, 0.08409401f, -0.02123749f, -0.08099018f, 
    -0.15259707f, -0.03596392f, -0.14694051f, -0.09622623f, 0.13919637f, -0.01717500f, -0.09436852f, 0.02070059f, 
    -0.26963583f, -0.02225340f, 0.05046066f, 0.20119366f, -0.06660987f, 0.04304813f, 0.11323530f, 0.06737716f, 
    0.12996443f, 0.24257332f, 0.18309550f, -0.07978803f, -0.09655440f, 0.02388228f, -0.04404547f, -0.06082393f, 
    -0.04066517f, -0.02655072f, 0.12124839f, 0.27839509f, -0.70267409f, -0.26122391f, -0.28222331f, -0.03721738f, 
    -0.10379274f, -0.04039850f, 0.09615922f, 0.00710600f, -0.01432448f, 0.09034863f, -0.03489981f, 0.14765051f, 
    0.13452934f, 0.20731021f, 0.01179710f, -0.08014913f, 0.01540761f, 0.12718895f, -0.01936550f, 0.10494191f, 
    -0.02978631f, 0.00444364f, 0.09151368f, 0.02159036f, -0.27453420f, -0.13660446f, 0.14945927f, 0.35406166f, 
    0.07846464f, 0.24523106f, 0.04865666f, -0.21722187f, 0.06430618f, -0.01693719f, 0.01307241f, -0.16488929f, 
    -0.46334180f, 0.03779031f, -0.25688869f, -0.18988648f, 0.00173422f, 0.05703734f, -0.17250781f, 0.04088275f, 
    0.00211733f, 0.27068791f, 0.05237862f, -0.18495476f, 0.50062054f, -0.04288113f, -0.10990325f, 0.07296310f, 
    -0.00840497f, 0.11142839f, -0.11496314f, 0.11536285f, 0.07623106f, 0.05437015f, 0.03273809f, -0.05106971f, 
    0.14649199f, 0.13686961f, -0.17641757f, 0.34095079f, -0.14768572f, -0.06184032f, -0.01572265f, 0.03599969f, 
    -0.04507942f, 0.06414644f, -0.24666624f, 0.03239344f, 0.08070431f, -0.44332704f, -0.51318705f, -0.08533067f, 
    -0.05230057f, -0.09845221f, 0.04615000f, -0.12417065f, 0.15219378f, 0.04336739f, 0.18017809f, -0.04431175f, 
    0.09140505f, 0.34827700f, 0.30321190f, -0.03466254f, 0.17200695f, -0.00590491f, 0.02458822f, 0.08831273f, 
    -0.07432963f, 0.06060753f, -0.04938740f, -0.05450357f, -1.05943072f, -0.36876544f, 0.17946737f, 0.03254501f, 
    -0.01203745f, 0.20295590f, -0.05382695f, 0.04891328f, 0.00015561f, 0.08527031f, 0.12234869f, -0.09584258f, 
    0.09155629f, 0.08557019f, 0.03698133f, 0.24728738f, 0.06679621f, -0.02423293f, 0.13181764f, -0.19878526f, 
    0.09852125f, 0.04887629f, -0.11228939f, -0.26041132f, -0.10625680f, -0.52781999f, -0.41265458f, 0.02501504f, 
    -0.05880323f, 0.15820548f, -0.12775014f, 0.07525229f, -0.00522212f, -0.02132894f, -0.03043613f, -0.02370657f, 
    -0.25092715f, 0.18216768f, -0.04219658f, 0.06805942f, 0.03996057f, -0.01062952f, -0.15561190f, 0.09086763f, 
    -0.07384418f, -0.05685104f, 0.01055076f, -0.25007385f, -0.09736858f, -0.11550530f, -0.00439910f, -0.17111804f, 
    -0.05433964f, -0.03658849f, -0.00100323f, 0.01665531f, -0.06041960f, -0.13271748f, 0.01849725f, -0.16922402f, 
    0.29509610f, -0.08108702f, -0.06670644f, -0.14310540f, -0.20046201f, 0.07252586f, 0.02629052f, 0.00536017f, 
    -0.12077532f, -0.05027737f, 0.06081468f, -0.00513643f, -0.17682461f, 0.31657475f, 0.12092912f, 0.00518703f, 
    -0.07808641f, 0.11933214f, 0.14960851f, 0.01300309f, -0.13518043f, 0.03456558f, 0.05742596f, 0.04457671f, 
    -0.08086144f, 0.07704783f, 0.21709333f, 0.02260427f, 0.04243842f, -0.12083696f, -0.27994543f, 0.00827023f, 
    -0.09121515f, -0.04034937f, 0.10140365f, 0.11960875f, -0.71939313f, -0.14061546f, -0.11801961f, -0.19608384f, 
    -0.09170862f, -0.00801935f, 0.05318236f, -0.05400034f, 0.03512334f, -0.01694103f, 0.08214621f, 0.14734456f, 
    -0.18950678f, -0.06178159f, -0.12569919f, -0.02677205f, -0.07697792f, 0.07042035f, 0.15130053f, 0.17953494f, 
    0.07687956f, -0.04758723f, 0.01736921f, 0.09228175f, -0.53624260f, -0.43526098f, -0.14349261f, -0.11034112f, 
    -0.15658291f, -0.32882074f, 0.01744613f, -0.08974045f, 0.01254176f, -0.07250162f, 0.23672129f, 0.03396497f, 
    0.15936989f, -0.06987467f, 0.12054446f, 0.09531120f, -0.06489541f, 0.00784459f, 0.02992980f, -0.07450206f, 
    0.01839840f, 0.09071150f, -0.13692343f, 0.12357676f, -0.18277805f, 0.19456841f, 0.05173808f, 0.20238261f, 
    0.14363365f, 0.10764153f, 0.00950908f, -0.00463948f, -0.09151975f, -0.01181256f, -0.00100379f, 0.07035179f, 
    0.79304212f, 0.01807717f, 0.09439371f, 0.26721069f, 0.08601034f, -0.03141434f, 0.00798043f, 0.27486277f, 
    0.10332527f, -0.01009041f, -0.18253966f, -0.01561858f, -0.06281273f, 0.06238157f, 0.37843966f, -0.03582618f, 
    0.05234546f, 0.04258554f, 0.08251975f, -0.12938501f, -0.09919750f, 0.06436586f, -0.23248842f, 0.16183479f, 
    0.46736595f, -0.11123451f, -0.18314964f, -0.09785105f, 0.11009624f, 0.17290820f, 0.06156178f, -0.05064685f, 
    0.07101085f, -0.16451816f, 0.00708282f, -0.03292965f, -0.04040235f, -0.04786630f, 0.07460891f, -0.12677331f, 
    0.02828904f, -0.01893134f, 0.10390242f, -0.06583160f, -0.20700704f, 0.03023159f, -0.00995945f, 0.07146181f, 
    -0.29923359f, -0.54948902f, -0.33315909f, 0.23270264f, -0.09947024f, -0.00856454f, -0.09805886f, -0.15869111f, 
    0.06753356f, 0.01917203f, 0.10396857f, 0.07422935f, -0.17786168f, -0.23876783f, 0.11900119f, 0.02506877f, 
    -0.11280645f, 0.15938608f, -0.01526063f, 0.03194030f, -0.03884329f, 0.07282300f, -0.09798282f, 0.10877118f, 
    0.15594484f, -0.04354915f, 0.12115767f, -0.22984186f, -0.06363462f, 0.30136046f, -0.22456555f, 0.14687645f, 
    0.03993167f, 0.09160466f, 0.07918883f, 0.09115240f, -0.49681142f, 0.25418952f, -0.07797707f, 0.04002386f, 
    0.05373701f, -0.05829172f, -0.04566072f, 0.00597465f, 0.09537996f, 0.13346563f, 0.01368588f, 0.06177482f, 
    -0.33503950f, -0.28628311f, -0.04262348f, 0.03167417f, -0.02038539f, -0.00919882f, -0.13972710f, -0.05486404f, 
    0.09397567f, -0.08935334f, -0.19721164f, 0.05101568f, -0.31759089f, 0.22094557f, 0.14325705f, 0.17128862f, 
    0.15638065f, 0.01743340f, 0.06964861f, 0.10542732f, -0.01610733f, 0.12664686f, 0.08781227f, -0.08852109f, 
    0.04384559f, 0.01927608f, 0.10731097f, -0.28572309f, 0.09738189f, -0.07135281f, -0.08923702f, -0.09583715f, 
    0.09709285f, -0.12441813f, -0.20154956f, 0.17385264f, -0.44920698f, -0.02152593f, 0.00248457f, -0.12010039f, 
    -0.10746808f, -0.15121441f, -0.18457870f, 0.16214089f, 0.00930059f, 0.03239306f, -0.13678284f, -0.03575820f, 
    -0.49491623f, -0.04388392f, 0.05270709f, -0.03294359f, 0.08014808f, -0.04342424f, -0.04642019f, -0.05752620f, 
    0.00114365f, 0.04977619f, -0.09694328f, -0.06642040f, -0.21445957f, -0.06779988f, -0.00044733f, 0.49429634f, 
    -0.11099132f, -0.12345976f, -0.09935733f, -0.03137954f, -0.00153388f, 0.01407916f, -0.02536144f, -0.20729163f, 
    -0.36550319f, 0.09820879f, 0.16100307f, -0.00743233f, 0.07436725f, -0.02778714f, -0.00512718f, -0.03717381f, 
    -0.01653988f, -0.05337887f, -0.10514382f, 0.13886696f, 0.06217259f, -0.26593116f, -0.08605954f, 0.16960108f, 
    -0.25717583f, 0.00075960f, 0.18924806f, -0.12356872f, -0.06571011f, 0.21832207f, -0.05197020f, -0.14385548f, 
    0.09905677f, -0.06775972f, -0.52232695f, 0.11867663f, -0.01764377f, 0.03094658f, 0.00976306f, -0.02156611f, 
    -0.04625707f, -0.04244390f, 0.05501878f, -0.07115188f, 0.27240422f, 0.11518466f, -0.21373160f, 0.01319991f, 
    -0.01307491f, 0.09020297f, 0.05074074f, 0.01175951f, -0.16831554f, -0.08313072f, 0.03493588f, 0.01426485f, 
    -0.04526513f, 0.39868855f, 0.03213220f, -0.13877067f, 0.04796074f, -0.28265065f, 0.02236685f, -0.10684572f, 
    0.00929852f, -0.04511133f, -0.01971748f, -0.05603141f, 0.11773857f, 0.06305911f, 0.02196139f, -0.21052024f, 
    0.01120454f, 0.01983412f, -0.02274180f, 0.02679047f, 0.00986257f, -0.06449945f, -0.06274950f, -0.01352635f, 
    -0.19183932f, -0.33696607f, 0.04308305f, 0.19098096f, -0.23466350f, 0.10431778f, -0.19491176f, -0.26970562f, 
    0.06738447f, 0.14229688f, -0.14710447f, 0.07553300f, -0.29003084f, -0.33086255f, -0.00333861f, -0.12238616f, 
    -0.20727921f, 0.08797732f, 0.08722109f, 0.00646097f, 0.06361225f, 0.10351400f, -0.03038174f, -0.10052972f, 
    -0.25254175f, -0.33592984f, 0.32721111f, 0.07399632f, -0.17007692f, -0.06256808f, -0.09649231f, -0.09847967f, 
    0.01093184f, -0.14953057f, 0.03021178f, 0.10446126f, -0.65100867f, -0.07506686f, 0.12794200f, 0.20961744f, 
    0.04942011f, 0.02848761f, 0.00211994f, 0.07683164f, 0.02021538f, 0.02671687f, 0.03397309f, 0.08475596f, 
    -0.13889425f, -0.06511740f, -0.06587099f, 0.19717540f, 0.13217726f, 0.05874680f, 0.03412829f, 0.06188449f, 
    -0.07586247f, -0.12456773f, 0.14798149f, -0.01870852f, -0.21203552f, -0.04990147f, 0.09133258f, -0.02333861f, 
    0.13191453f, 0.06869262f, -0.04225527f, 0.02752936f, -0.07598060f, -0.02348278f, -0.10463592f, 0.05094758f, 
    0.25871193f, 0.10734452f, -0.09314307f, 0.17287639f, -0.02205255f, 0.03441548f, 0.08891419f, 0.18962994f, 
    -0.14100182f, 0.17011926f, 0.15662752f, 0.12589952f, -0.00316986f, 0.12416457f, -0.16755533f, -0.13680780f, 
    -0.05974993f, -0.05480187f, 0.03796135f, 0.03829116f, 0.05877335f, -0.06289017f, 0.19381022f, -0.35353842f, 
    -0.03581524f, -0.31630126f, 0.09507546f, -0.12570997f, -0.00715873f, 0.06130846f, 0.16375852f, -0.08141950f, 
    0.10013423f, -0.05492465f, 0.06214243f, -0.16638581f, 0.28559604f, -0.09185473f, 0.13730897f, 0.12000521f, 
    -0.06525111f, -0.03442637f, 0.07526033f, 0.03985777f, 0.10236829f, 0.22711465f, 0.02218311f, 0.11750361f, 
    0.05703900f, -0.14101845f, 0.33977970f, 0.18215516f, 0.01387793f, -0.14567633f, 0.02743067f, 0.14207745f, 
    0.26862150f, 0.01933046f, -0.16645871f, -0.02428119f, 0.11712992f, 0.02965835f, 0.23404166f, 0.04076722f, 
    -0.12507176f, 0.04375390f, -0.00291045f, 0.11423519f, -0.13658345f, 0.06903128f, -0.19567031f, -0.08963638f, 
    0.27543038f, 0.67919469f, -0.37181953f, -0.41649342f, 0.10511370f, 0.03349290f, 0.12846948f, 0.22014396f, 
    -0.09154329f, 0.15007272f, -0.05443108f, 0.08095797f, -1.00540400f, 0.23425078f, 0.11197291f, -0.13309041f, 
    0.06952595f, -0.10955051f, -0.03799545f, 0.09494452f, -0.21990752f, -0.07305055f, -0.02873121f, -0.02588608f, 
    -0.08895405f, 0.15602863f, 0.15357566f, 0.06276432f, -0.08106596f, 0.28819296f, -0.02940609f, -0.25679815f, 
    0.12298501f, -0.06778497f, -0.02756895f, 0.00819488f, -0.33957499f, -0.07068419f, 0.26538903f, 0.24563232f, 
    0.02335245f, 0.09934565f, 0.04994458f, 0.04308362f, -0.10649671f, 0.19240806f, 0.05871554f, 0.01793250f, 
    -0.00589412f, 0.23102909f, 0.12626208f, 0.20749906f, -0.09611063f, 0.17304565f, -0.08372176f, 0.03493081f, 
    0.11981427f, 0.01973565f, -0.03870377f, 0.19716376f, -0.21975501f, -0.18511431f, -0.08849473f, 0.24447152f, 
    -0.17908305f, -0.02718323f, 0.05309191f, 0.05531432f, 0.08144366f, 0.12473805f, 0.05507641f, 0.13243069f, 
    -0.13583069f, -0.03393890f, 0.18911035f, 0.29526106f, -0.16554311f, -0.13231446f, 0.07177099f, -0.16150931f, 
    0.31814554f, -0.04652161f, -0.03790380f, 0.04936082f, -0.30288222f, 0.17669351f, 0.19371240f, -0.15741305f, 
    0.19353585f, -0.13670288f, 0.01647027f, 0.03416844f, 0.10374282f, -0.05575569f, 0.04966113f, 0.05814710f, 
    0.09809484f, -0.01000184f, -0.06956699f, 0.21897598f, 0.01742978f, 0.09753551f, 0.13597971f, 0.11213765f, 
    0.04931680f, -0.07940104f, 0.14185500f, 0.23588476f, -0.49287379f, -0.53143007f, -0.36670208f, -0.09414642f, 
    0.11698773f, 0.11602566f, -0.02119429f, -0.19871978f, 0.17541713f, 0.02629726f, 0.06264734f, 0.08416835f, 
    -0.33580279f, -0.11577765f, -0.04767175f, 0.21517994f, 0.17964140f, -0.06232716f, -0.16067965f, 0.11305622f, 
    0.04002224f, 0.19777817f, 0.11062066f, -0.05111442f, 0.06149684f, -0.08080850f, 0.03058153f, 0.01202358f, 
    0.20353159f, 0.20717545f, 0.16389453f, -0.04099843f, 0.00617929f, -0.04095681f, 0.04514913f, -0.06099845f, 
    0.18266614f, 0.03197929f, -0.31604350f, -0.01759921f, 0.08266798f, 0.02711962f, -0.00792223f, -0.16252811f, 
    -0.02482354f, 0.07234419f, 0.18112621f, -0.00577904f, 0.27814767f, 0.05389633f, 0.02119330f, -0.09057943f, 
    -0.10409919f, -0.10916556f, -0.01796279f, 0.14672327f, -0.06240879f, -0.01756506f, 0.04708689f, 0.29418254f, 
    0.19529997f, 0.00234046f, -0.09806032f, -0.02492054f, -0.01919338f, -0.19333105f, -0.14707725f, -0.11376791f, 
    0.07979750f, -0.07224921f, -0.08396436f, 0.04159265f, 0.05364982f, -0.06933842f, 0.02877349f, 0.27096266f, 
    0.02658121f, -0.05502933f, 0.09175199f, -0.20053811f, -0.21892631f, -0.13038164f, -0.11365017f, 0.08660775f, 
    -0.26794389f, 0.34388489f, 0.16971719f, 0.07015045f, -0.10802060f, 0.04766904f, 0.03181123f, -0.02018494f, 
    0.02275582f, -0.20793746f, -0.03686545f, 0.14592060f, 0.16824378f, 0.39583766f, 0.36110994f, -0.33965001f, 
    -0.14938481f, -0.23031016f, -0.08988257f, -0.11826455f, -0.11112984f, -0.06609731f, -0.06553712f, -0.05500004f, 
    0.01801310f, -0.20862938f, 0.02143136f, 0.02305346f, 0.07780257f, -0.03317988f, 0.01704262f, 0.09969442f, 
    0.12106056f, 0.16919668f, 0.11357982f, 0.04114941f, -0.14064975f, 0.01605330f, 0.17067677f, -0.04575162f, 
    -0.01060677f, -0.10771504f, 0.04905485f, -0.12152512f, 0.06201700f, -0.17573008f, 0.10441330f, -0.08719039f, 
    0.08035343f, 0.15133239f, 0.09525965f, 0.25931209f, -0.16482237f, -0.08617316f, 0.11785222f, 0.02213020f, 
    -0.28074831f, -0.22057149f, 0.07362379f, 0.27664387f, -0.13293603f, 0.01319950f, -0.08833455f, 0.01560424f, 
    0.00391938f, 0.13268551f, 0.04678055f, 0.05447903f, 0.03995091f, -0.15892047f, -0.03538127f, -0.07135976f, 
    -0.01887834f, 0.18852629f, 0.10026917f, 0.25464579f, -0.14967768f, -0.09920043f, 0.16193223f, 0.04699978f, 
    0.04838196f, 0.13025601f, -0.07017015f, 0.16631567f, -0.71915138f, 0.09829329f, -0.25117671f, -0.19365834f, 
    0.05965520f, 0.09899822f, 0.09150822f, -0.16270937f, 0.03883688f, -0.18739468f, 0.08149488f, -0.26101807f, 
    -0.46361750f, -0.04168528f, -0.35807523f, 0.15101573f, 0.22241446f, 0.04341393f, -0.00225755f, -0.06910861f, 
    0.18306643f, 0.19134964f, -0.11485468f, 0.18172383f, 0.01158022f, -0.10708747f, -0.02763542f, -0.23040785f, 
    0.02939298f, 0.04509297f, -0.01050874f, 0.27263343f, -0.10510205f, 0.17991248f, 0.11005255f, -0.08895393f, 
    -0.00945925f, -0.08510310f, -0.03846877f, -0.26715177f, 0.17165993f, -0.06494167f, 0.27884111f, -0.41297793f, 
    -0.04824177f, 0.01494618f, -0.42652899f, -0.06448440f, -0.11127590f, 0.04110415f, 0.27480769f, -0.34232274f, 
    -0.03822851f, -0.03773610f, 0.03881543f, 0.03624748f, 0.12834580f, 0.20904812f, 0.05124166f, 0.15627487f, 
    0.03150244f, 0.13280593f, -0.06272124f, 0.06120629f, -0.08752373f, -0.19544010f, 0.16997683f, -0.10835316f, 
    -0.11900862f, 0.00447125f, 0.07916304f, -0.05714994f, 0.07383340f, 0.07440554f, 0.21021636f, -0.13364622f, 
    0.03889455f, 0.14896572f, 0.02130740f, -0.01654605f, -0.09876776f, -0.03831144f, -0.18500194f, -0.00373429f, 
    -0.23453093f, 0.01294752f, -0.25421506f, 0.00750863f, 0.30047533f, 0.10925911f, -0.17985561f, 0.18429385f, 
    0.06079275f, 0.10404520f, 0.41402078f, -0.09942783f, 0.10240348f, -0.10211999f, -0.14306095f, -0.45019215f, 
    0.11008362f, -0.05754951f, 0.25608602f, -0.12474837f, -0.11618307f, 0.04741042f, -0.07879871f, 0.18430313f, 
    -0.66467071f, -0.66905791f, 0.52695668f, 0.25243011f, 0.08553826f, -0.02303258f, 0.04265029f, 0.04247463f, 
    -0.05031485f, 0.04565910f, 0.01121831f, -0.00688163f, -0.32738769f, 0.08193120f, -0.18220323f, -0.38724753f, 
    0.05590991f, 0.00667284f, -0.04247769f, 0.06067589f, 0.08989362f, -0.12167307f, 0.04751461f, -0.12948756f, 
    -0.11649520f, 0.18756884f, 0.32065392f, -0.05763878f, -0.10237537f, -0.06703158f, 0.08217768f, -0.01586965f, 
    0.02334565f, -0.14995931f, -0.16430262f, 0.05442927f, 0.17509300f, -0.17084594f, -0.36791563f, 0.10722043f, 
    0.07608542f, 0.08101303f, -0.02087948f, 0.05709144f, 0.15392335f, 0.04937427f, -0.11665567f, 0.08965747f, 
    -0.05349686f, -0.05171905f, 0.12303703f, -0.01556821f, 0.00277408f, -0.14977804f, 0.13315721f, -0.00944200f, 
    -0.06674800f, 0.01735842f, -0.20511766f, -0.00898256f, 0.40994856f, -0.11974820f, -0.19298980f, -0.09059799f, 
    0.01762507f, -0.01336416f, -0.18711460f, -0.14255838f, -0.01811463f, -0.08954458f, -0.05557332f, -0.03151124f, 
    -0.10985684f, 0.26891282f, -0.18537487f, 0.33807823f, -0.01472509f, 0.21422745f, 0.12304348f, 0.11748036f, 
    -0.15590291f, 0.06139256f, -0.04561748f, 0.12963684f, 0.17573042f, -0.54071653f, 0.20601629f, 0.24902919f, 
    -0.11874871f, 0.00525472f, -0.05476012f, -0.02762241f, -0.04374294f, 0.03901014f, -0.02422313f, -0.01727318f, 
    0.20585591f, 0.10283855f, -0.08841193f, -0.18469132f, 0.00087698f, -0.00625976f, -0.11027666f, -0.11230990f, 
    0.12193040f, -0.00308218f, -0.27916047f, -0.12459172f, -0.18594767f, 0.07117969f, -0.19197394f, -0.31023669f, 
    0.07411139f, 0.07197937f, -0.20520005f, -0.00037154f, 0.18947215f, 0.08089849f, -0.07031800f, 0.23360614f, 
    -0.14530541f, 0.03049871f, 0.07136080f, -0.31275424f, -0.02949037f, -0.04020322f, 0.09416412f, -0.00921444f, 
    -0.09109903f, 0.22165860f, 0.16989084f, -0.23037443f, -0.23560695f, 0.23259257f, 0.16256526f, -0.00481012f, 
    0.04935403f, -0.13884035f, -0.12062204f, 0.00405821f, -0.06973965f, 0.15332246f, -0.08258038f, 0.08626942f, 
    0.02842803f, 0.01965745f, -0.07693598f, 0.56951231f, 0.06513766f, 0.24224654f, 0.01168059f, 0.13687475f, 
    0.09778038f, -0.00725792f, -0.01662165f, 0.01324814f, 0.09057656f, 0.31372967f, 0.18986923f, -0.60613787f, 
    -0.06978361f, 0.12388892f, 0.16863577f, -0.00012389f, -0.07145353f, -0.05487538f, -0.11864533f, -0.20898151f, 
    -0.39125055f, 0.03780623f, -0.07363892f, -0.01997053f, -0.03488395f, 0.15095869f, 0.24646209f, 0.10131958f, 
    -0.17813095f, -0.26185790f, 0.12179252f, -0.04765793f, -0.21200530f, 0.26771277f, 0.09110402f, -0.14832944f, 
    -0.01788758f, -0.02939696f, -0.20136444f, 0.17206617f, -0.11650986f, 0.05432858f, 0.15510587f, 0.11543079f, 
    0.18736334f, -0.10914684f, -0.10665233f, 0.15917419f, 0.00981620f, -0.00910237f, -0.05046200f, -0.07292742f, 
    0.03094675f, 0.02685805f, -0.08964448f, -0.19911149f, -0.39690414f, -0.01290921f, -0.00046253f, -0.09904676f, 
    -0.10452415f, 0.09427086f, 0.00986608f, 0.15139405f, 0.04608332f, -0.06036351f, -0.04438441f, 0.07241109f, 
    0.10746451f, -0.13606666f, -0.15380611f, 0.31855235f, 0.00178083f, 0.00708143f, -0.11590445f, -0.00212351f, 
    -0.03131303f, -0.01169202f, -0.33628598f, -0.14148894f, 0.40899742f, 0.17135328f, 0.10936357f, -0.14857839f, 
    0.04103771f, 0.05791951f, 0.05571225f, 0.10651441f, -0.14294851f, 0.12632893f, 0.09081709f, 0.20484915f, 
    -0.08517586f, 0.17939623f, -0.05853616f, -0.10311236f, 0.12423015f, 0.05812871f, -0.14694984f, -0.07806969f, 
    0.08714184f, -0.02810036f, -0.05421161f, 0.07214089f, -0.56578994f, 0.14373407f, 0.08217089f, 0.17077714f, 
    0.09379244f, -0.01816704f, -0.06214357f, -0.00795108f, -0.07577110f, 0.14291689f, 0.10902065f, -0.21109210f, 
    0.01422792f, -0.11486998f, -0.12096515f, -0.42960235f, 0.08386080f, 0.15161149f, 0.09675648f, -0.02692441f, 
    -0.04133403f, 0.02551113f, -0.09816961f, -0.03059000f, 0.41977248f, -0.42352727f, -0.00886084f, -0.06920533f, 
    -0.08854143f, 0.06337517f, -0.01798857f, 0.00151714f, -0.13932329f, 0.08675109f, 0.09671274f, 0.19200587f, 
    -0.49297914f, 0.18040326f, -0.13582392f, -0.25116646f, -0.06946804f, -0.06159526f, 0.12030628f, -0.10472187f, 
    -0.08927518f, -0.05061004f, -0.16931921f, 0.12678374f, 0.30658686f, 0.13437587f, 0.18996583f, -0.02802791f, 
    -0.04422617f, 0.02286511f, 0.17571416f, -0.14516526f, 0.16314977f, -0.12269426f, 0.08956085f, 0.04882318f, 
    -0.23126034f, -0.34204450f, -0.00767280f, -0.03279605f, 0.03431530f, -0.04122639f, -0.09469140f, 0.06097730f, 
    0.02313643f, -0.04421790f, 0.33116043f, 0.02612417f, 0.03142191f, 0.14947324f, 0.08887405f, -0.13215312f, 
    -0.08996774f, 0.04205373f, -0.03190172f, 0.05330534f, -0.16831566f, -0.09273086f, -0.13416623f, -0.09980390f, 
    -0.43507940f, -0.13549407f, -0.07492969f, 0.43350324f, 0.02965735f, 0.17348997f, -0.00475121f, -0.01042075f, 
    0.05337863f, -0.24755372f, -0.09302593f, -0.29183620f, -0.20573674f, 0.24105960f, 0.06511792f, -0.08813385f, 
    -0.02063986f, 0.01280441f, 0.00953733f, 0.12902334f, -0.00932916f, -0.04034333f, -0.00320860f, -0.10278529f, 
    -0.25781116f, 0.02258954f, -0.12698923f, -0.18852139f, 0.01253795f, 0.14361186f, -0.11494793f, -0.03260910f, 
    -0.12027483f, -0.05783059f, -0.20196210f, 0.16405950f, -0.10506876f, 0.21700461f, -0.04775788f, -0.07538291f, 
    -0.12521818f, 0.17950538f, -0.09787247f, -0.15736949f, -0.00872976f, -0.16531220f, -0.24943508f, -0.10238959f, 
    0.39374804f, -0.33866999f, -0.19201849f, 0.06944548f, -0.24658492f, -0.09563076f, 0.07921086f, 0.04592297f, 
    0.14341438f, 0.02730777f, -0.02900888f, 0.11349538f, 0.24523216f, -0.51431197f, 0.07116406f, -0.01351732f, 
    -0.00078477f, -0.06530444f, 0.25021979f, -0.27207178f, 0.09025910f, -0.02836589f, 0.15619396f, 0.02011021f, 
    -0.10668576f, 0.17514707f, 0.16163175f, 0.09964556f, 0.06525468f, 0.06553915f, -0.05719983f, 0.02170852f, 
    -0.00857556f, 0.07025801f, -0.00646733f, 0.15006933f, -0.13754663f, -0.12298762f, -0.42332226f, 0.09959572f, 
    0.05362210f, -0.04754996f, -0.05949468f, -0.14646240f, -0.01305027f, -0.13113238f, 0.16030163f, -0.04075671f, 
    0.08112371f, 0.01621999f, 0.11173712f, -0.52361792f, -0.02440753f, -0.09764227f, -0.12217215f, 0.09386647f, 
    -0.20475425f, -0.09853370f, 0.22631910f, 0.04189643f, -0.53442216f, 0.06251938f, -0.26054931f, 0.20891243f, 
    0.14561191f, -0.02688693f, 0.13144198f, -0.04107940f, 0.16506110f, 0.01723814f, 0.07212163f, 0.05590436f, 
    -0.17384693f, -0.49428859f, -0.15289235f, -0.02365201f, -0.07873179f, -0.05553404f, -0.08372837f, 0.12986490f, 
    -0.07950823f, 0.00476243f, -0.15912822f, -0.03878281f, -0.00440246f, 0.10683902f, -0.02129373f, -0.07883174f, 
    -0.02350500f, 0.00104724f, -0.03523455f, -0.10651742f, 0.01466580f, 0.04382190f, -0.03390029f, -0.10180379f, 
    -0.53232265f, 0.07819711f, -0.38958198f, 0.00614416f, 0.07666744f, -0.08856634f, 0.01945091f, -0.01479143f, 
    -0.14903751f, 0.14312266f, -0.02204465f, 0.02804151f, 0.05009838f, 0.16755439f, 0.17858516f, 0.21881984f, 
    0.15520623f, 0.18724732f, 0.07512952f, 0.00017189f, -0.00545044f, 0.05790196f, -0.14072874f, -0.05934081f, 
    0.22337425f, -0.03072881f, 0.21563514f, 0.07191616f, 0.09498703f, -0.07776571f, 0.10324342f, -0.10335833f, 
    -0.11369700f, -0.10317173f, -0.09826355f, -0.10518486f, -0.09680646f, -0.13428847f, -0.10329802f, -0.28595445f, 
    0.02190550f, 0.09345494f, 0.05621196f, 0.02081941f, -0.05585384f, 0.08347885f, 0.05110826f, -0.08453938f, 
    -0.60807610f, 0.13829866f, -0.06471554f, 0.01613086f, -0.09922643f, -0.11300483f, -0.02129780f, 0.09728982f, 
    0.01380774f, 0.01784848f, 0.04545484f, 0.00770202f, -0.05508916f, -0.28935853f, -0.18192793f, 0.12072843f, 
    -0.07405022f, -0.05063577f, 0.03484654f, -0.05171661f, -0.02617141f, 0.11159730f, 0.05964009f, -0.06666485f, 
    -0.24349794f, -0.05558842f, -0.08963948f, -0.14286551f, -0.12043281f, -0.03234448f, -0.12381702f, -0.06937779f, 
    0.07487980f, 0.04021771f, -0.01604668f, 0.02749881f, -0.12831274f, 0.00528803f, -0.17677455f, 0.15406302f, 
    -0.03776240f, 0.06111548f, -0.03305978f, -0.01056493f, -0.23548752f, -0.10685191f, 0.01393364f, -0.05741098f, 
    0.10458796f, 0.17361932f, -0.08904481f, 0.01537688f, 0.16489182f, -0.04438463f, -0.09616188f, 0.08474659f, 
    0.07837098f, 0.12664479f, -0.09211215f, -0.08400829f, -0.46834579f, 0.33871794f, 0.06446058f, -0.15133853f, 
    -0.12512314f, -0.00021404f, -0.06060653f, -0.15667459f, -0.03925641f, -0.09122758f, -0.25856555f, -0.24459535f, 
    0.28892395f, -0.34292510f, 0.28176221f, 0.38151628f, 0.05157197f, 0.03821519f, -0.07364304f, 0.00838781f, 
    -0.05276681f, 0.05187916f, -0.00244172f, -0.03803112f, 0.41008887f, -0.26758313f, -0.12174144f, -0.01437673f, 
    -0.10096763f, 0.01023889f, -0.01389385f, -0.08300099f, 0.02608577f, -0.07308120f, -0.02912467f, -0.11731067f, 
    -0.04792198f, -0.17120528f, 0.04325259f, 0.11074696f, 0.03251382f, -0.13661700f, -0.10460582f, -0.05229601f, 
    -0.22636525f, -0.00458229f, 0.05451723f, 0.11395592f, -0.42745918f, 0.07434952f, -0.07067987f, -0.20811303f, 
    -0.04116852f, 0.04853927f, -0.06316235f, -0.05611694f, -0.03510027f, 0.11258670f, 0.08649356f, 0.03558779f, 
    0.23796181f, -0.29794303f, -0.00231691f, 0.23011577f, -0.03380271f, -0.12337090f, -0.08399874f, -0.02484763f, 
    -0.07016871f, 0.04244060f, 0.02379379f, -0.11223780f, -0.07806374f, 0.23329680f, 0.13482706f, 0.25116608f, 
    0.18671916f, 0.05008463f, 0.11029766f, 0.04645833f, -0.09110919f, -0.01087334f, 0.04199436f, -0.01265758f, 
    0.09799124f, 0.24382800f, 0.27407309f, 0.41693994f, 0.28747961f, 0.17358819f, 0.11324704f, 0.04341416f, 
    -0.10185821f, 0.00896371f, -0.02279029f, -0.20548767f, 0.33076286f, -0.14942998f, 0.12798248f, -0.02545641f, 
    0.10376891f, -0.08486898f, -0.02115969f, -0.05157362f, -0.05845749f, -0.12125353f, 0.01221766f, -0.06246730f, 
    -0.10538264f, -0.11336055f, 0.03750262f, 0.05220043f, -0.03913111f, -0.00091738f, -0.08772961f, -0.02030275f, 
    -0.00025461f, 0.04184644f, 0.02846904f, -0.12888823f, -0.04476402f, -0.10813923f, 0.00607928f, -0.13783398f, 
    0.02433345f, 0.12791282f, -0.02319960f, -0.11018153f, -0.04633769f, 0.02995726f, 0.07440292f, 0.02127546f, 
    -0.09895192f, -0.08941706f, -0.14851026f, 0.15729962f, -0.02410116f, -0.08044104f, -0.13413829f, 0.04798961f, 
    -0.04665830f, -0.01657740f, 0.02808305f, -0.06394844f, -0.03588465f, -0.17582470f, -0.04032873f, -0.35477528f, 
    -0.04500980f, -0.01466433f, -0.02914810f, -0.07519863f, 0.04035533f, 0.00271459f, 0.04053580f, -0.01642189f, 
    0.14627427f, 0.03899011f, 0.10507251f, -0.03411633f, 0.09103011f, -0.11232341f, 0.10007872f, -0.12322866f, 
    -0.08581050f, -0.20100583f, -0.08685641f, -0.12952462f, -0.14407413f, 0.10833219f, 0.03693525f, -0.20555241f, 
    0.12415794f, -0.12499379f, -0.00599491f, 0.10059730f, -0.06360820f, 0.02547216f, -0.00319597f, -0.24655272f, 
    -0.23966770f, 0.23351081f, -0.01645568f, 0.17714363f, 0.07374577f, -0.03744863f, 0.06528373f, -0.06949805f, 
    0.06274428f, -0.05520457f, -0.05639273f, -0.14449665f, 0.49257350f, -0.15522511f, 0.24095052f, -0.18882479f, 
    -0.08578248f, 0.06509335f, 0.03610634f, -0.01140724f, 0.08423607f, 0.14012040f, -0.07591558f, 0.12332532f, 
    -0.00504264f, 0.32058534f, -0.01549829f, -0.06688526f, -0.15264244f, -0.02878118f, -0.01024511f, -0.05913394f, 
    -0.11328806f, 0.01566322f, 0.11706587f, -0.13884032f, 0.24105631f, 0.22274277f, 0.32827434f, 0.28260145f, 
    0.16965216f, 0.16602805f, 0.17176242f, 0.04580547f, -0.06599154f, -0.14933631f, -0.08493998f, -0.04279388f, 
    -0.43566868f, -0.06151394f, -0.21440774f, -0.01755902f, -0.08202401f, -0.14322463f, -0.12899581f, -0.10885830f, 
    -0.06235127f, 0.00516629f, -0.01691165f, -0.00196763f, 0.26080668f, 0.23626484f, -0.13043843f, 0.06642234f, 
    0.01802517f, 0.07601467f, -0.12167245f, 0.04478807f, -0.03165387f, 0.06122566f, 0.06920227f, -0.18491188f, 
    0.13352266f, 0.35048172f, -0.40535995f, -0.04752726f, 0.13118128f, -0.04675106f, -0.02287729f, -0.13176553f, 
    0.20963316f, -0.11937714f, -0.00156862f, 0.09815095f, 0.28400385f, -0.10305572f, 0.05345959f, 0.16948913f, 
    -0.06535570f, -0.05073955f, 0.01552563f, -0.03999171f, -0.10892410f, -0.18100125f, 0.07023855f, -0.08334431f, 
    -0.09976649f, 0.06442766f, -0.10306405f, -0.00943125f, 0.08383048f, -0.04003244f, 0.04520622f, -0.01313132f, 
    0.06661808f, -0.00112116f, 0.01886147f, 0.13475998f, -0.40404034f, 0.02636729f, 0.24257308f, 0.01068082f, 
    -0.05947414f, 0.04401221f, 0.03052678f, -0.41596013f, -0.03091488f, -0.05721391f, 0.07493015f, 0.18763271f, 
    -0.15390791f, -0.40732589f, 0.17285646f, -0.17776597f, -0.08173313f, -0.14973797f, 0.04789103f, -0.16013850f, 
    -0.11875349f, 0.10794407f, 0.15323322f, 0.12264872f, 0.19208656f, -0.23698021f, -0.32645190f, 0.15751593f, 
    0.13589203f, 0.00575033f, 0.01043449f, -0.08915588f, -0.13290085f, -0.04731959f, 0.14701097f, 0.09858005f, 
    0.18582676f, 0.33627328f, -0.50095958f, 0.18079130f, 0.05762764f, -0.04786834f, -0.15943196f, 0.01245011f, 
    -0.05908499f, -0.14444412f, 0.09712769f, 0.12531979f, -0.09468270f, -0.11458832f, 0.03028456f, 0.11481945f, 
    0.08705703f, 0.07426909f, -0.03569067f, 0.05826535f, 0.07682917f, -0.00240389f, 0.09937365f, -0.03557686f, 
    0.11488720f, 0.13371594f, 0.09723895f, 0.16283847f, -0.17258047f, 0.07603828f, -0.11067533f, -0.02512407f, 
    0.05287499f, -0.01634614f, -0.04175330f, -0.11789918f, -0.17242296f, -0.11209604f, -0.37032607f, -0.31157294f, 
    0.31085229f, -0.15739615f, -0.07659372f, 0.02911841f, 0.04623055f, 0.06016852f, -0.05130402f, -0.03338068f, 
    -0.07841998f, 0.54090351f, 0.08199637f, -0.07425852f, -0.01636036f, 0.04231667f, -0.14365925f, 0.10888494f, 
    0.08279925f, -0.19885352f, 0.18506803f, 0.24233243f, 0.35411909f, -0.24793145f, 0.22223453f, 0.18455598f, 
    -0.01379720f, -0.15939295f, 0.03952439f, -0.05358406f, -0.04526377f, 0.01978763f, -0.00919570f, -0.19273670f, 
    -0.04818019f, -0.10401811f, -0.07945180f, -0.17113186f, -0.04608687f, -0.07279953f, -0.21430467f, -0.15728632f, 
    0.03809474f, 0.14014985f, 0.05081755f, 0.03114798f, 0.17938998f, -0.16682051f, -0.10811498f, 0.19214655f, 
    0.18114971f, -0.02820567f, -0.09059355f, -0.04354229f, 0.11341070f, -0.11656933f, -0.01589426f, -0.18346143f, 
    0.13141100f, -0.08650026f, -0.08062677f, -0.33339393f, 0.07753491f, -0.11391575f, -0.03827807f, 0.08662733f, 
    0.12228704f, -0.02956098f, 0.11111402f, 0.17805015f, 0.15495704f, -0.12074380f, -0.12884185f, 0.09705041f, 
    0.17488337f, 0.03851029f, 0.03926619f, -0.06150714f, 0.01838380f, -0.24651554f, -0.13974166f, 0.01086247f, 
    -0.08536941f, -0.37037605f, -0.24304208f, -0.21405204f, 0.04677213f, -0.13913970f, 0.23289414f, -0.09797408f, 
    0.09279273f, 0.03463703f, -0.03052184f, 0.18112415f, -0.02555306f, -0.23177597f, 0.18246299f, 0.11829872f, 
    -0.11675226f, -0.01131178f, 0.00903632f, -0.12579569f, 0.00122263f, -0.04419178f, -0.14471503f, -0.36622825f, 
    -0.41451082f, -0.00630432f, 0.50194460f, -0.17921130f, -0.07382829f, 0.07951955f, -0.01557234f, -0.08246378f, 
    -0.09621244f, 0.04218384f, -0.09307918f, -0.04355346f, -0.04086059f, -0.23262811f, 0.13531904f, -0.14372185f, 
    0.17089839f, -0.11625461f, 0.01639419f, 0.01632525f, 0.03423619f, -0.08701462f, -0.01996716f, 0.02479298f, 
    -0.10008447f, -0.11663540f, 0.24381724f, 0.29859185f, 0.04955544f, 0.02703722f, 0.04951967f, -0.40313575f, 
    0.04269787f, -0.08543517f, -0.46564806f, 0.29440323f, 0.20554921f, -0.07283197f, -0.00317443f, 0.32375816f, 
    0.15795094f, 0.00401617f, 0.02380680f, 0.00924812f, 0.03983575f, 0.24773116f, -0.04229075f, -0.01937873f, 
    0.25545263f, 0.20595880f, -0.34266201f, -0.14291041f, 0.13970912f, -0.05506687f, -0.13320340f, -0.04774771f, 
    0.11448971f, 0.12291963f, 0.12376206f, 0.18827383f, 0.13572033f, -0.10410550f, 0.13796090f, 0.11102346f, 
    0.19686706f, -0.13504569f, -0.08007575f, -0.08897013f, -0.00400526f, 0.06098038f, -0.13827419f, -0.17504723f, 
    -0.31178686f, -0.19063772f, 0.00945453f, -0.33186570f, -0.11994378f, -0.12828618f, 0.06394966f, -0.25212815f, 
    0.07408587f, 0.08538599f, 0.23356090f, 0.03797519f, -0.28965968f, 0.24586318f, -0.32412624f, 0.00197264f, 
    0.04343948f, 0.10015066f, -0.03767854f, -0.25776854f, 0.05169161f, -0.04079689f, 0.11258540f, 0.22286715f, 
    0.08734285f, -0.06515861f, 0.14896096f, 0.02700917f, -0.03370348f, -0.16734014f, -0.29097262f, 0.12902921f, 
    0.08267255f, 0.00427889f, 0.10613406f, -0.23076719f, 0.25415495f, -0.05627979f, 0.01967187f, -0.06118726f, 
    0.06096566f, -0.00949268f, 0.10540312f, 0.09596615f, 0.18324555f, -0.03591168f, 0.08982746f, 0.18747878f, 
    0.09263038f, -0.46714568f, -0.26748782f, -0.00356649f, -0.03586949f, -0.19983171f, -0.13019627f, -0.00950004f, 
    0.07341040f, 0.03243843f, 0.07867730f, -0.13175069f, -0.06663924f, 0.25258511f, -0.15334871f, -0.04540955f, 
    -0.12629241f, 0.05111574f, -0.37355679f, 0.06282996f, 0.06692424f, -0.01568325f, -0.06279202f, 0.12408388f, 
    -0.32219440f, -0.13048437f, -0.06811809f, 0.41040549f, 0.14145577f, 0.02206269f, -0.00454767f, 0.03786724f, 
    0.17170019f, -0.21332404f, -0.03503014f, -0.12599844f, 0.00492882f, 0.31126890f, -0.10092963f, 0.12320352f, 
    -0.10263976f, 0.07693081f, -0.24074653f, 0.06229391f, 0.01953676f, -0.20498592f, -0.21491516f, -0.15937604f, 
    0.58788925f, -0.17519672f, 0.14878216f, -0.11519298f, -0.00232320f, 0.11896870f, 0.03036311f, 0.21051426f, 
    0.06391474f, -0.00650609f, 0.06196398f, -0.14184056f, 0.13168837f, 0.14755607f, -0.02241654f, -0.23508801f, 
    0.08298491f, 0.12399936f, -0.04231253f, -0.01729072f, 0.03496693f, -0.08252721f, -0.13820872f, 0.04649957f, 
    0.22835074f, 0.36005184f, -0.14812645f, -0.50064200f, 0.02475570f, -0.02541811f, 0.04568659f, -0.08272832f, 
    -0.21966371f, -0.09172295f, -0.02727933f, -0.40948835f, -0.44943631f, -0.55797201f, -0.12043436f, 0.32336086f, 
    -0.01017270f, 0.10094985f, -0.13427877f, 0.18152323f, 0.19505908f, 0.02044188f, 0.00702401f, -0.22570696f, 
    0.24873498f, -0.37792853f, -0.06741194f, 0.24148525f, 0.05588987f, -0.07647470f, 0.05937323f, -0.03027535f, 
    0.08872611f, -0.09466626f, -0.05554471f, 0.03894975f, 0.11433032f, -0.09391025f, 0.18956281f, -0.21148327f, 
    -0.09376528f, 0.09888435f, -0.16491801f, 0.08698973f, 0.04913314f, -0.04833892f, -0.10820559f, -0.01564934f, 
    -0.24325152f, 0.18871798f, 0.65618163f, -0.17176530f, -0.08238144f, -0.04489179f, -0.07105403f, -0.00119866f, 
    0.07986661f, -0.02011962f, 0.10804433f, -0.03140380f, -0.07434748f, -0.33382815f, 0.08215535f, -0.50739688f, 
    0.01483145f, 0.09166073f, 0.10917580f, -0.10689242f, 0.18082586f, -0.02628908f, 0.14684251f, -0.04014207f, 
    0.64122039f, 0.04702017f, -0.10299793f, 0.04886727f, -0.02198316f, 0.08342654f, 0.01216944f, -0.09311831f, 
    -0.18718861f, 0.01540994f, 0.11338792f, -0.15004826f, -0.15456223f, -0.16832268f, 0.17225948f, 0.07828128f, 
    -0.02964653f, 0.10958929f, 0.10953819f, -0.04382692f, 0.11442319f, -0.01239470f, 0.04838928f, 0.12503234f, 
    -0.21527493f, 0.03664784f, 0.32837620f, -0.04044010f, -0.04655083f, 0.08236053f, -0.00775408f, 0.30683288f, 
    -0.01362179f, 0.02089474f, 0.12421748f, 0.08869973f, -0.94277847f, 0.46720073f, -0.08942338f, -0.01796725f, 
    0.21982741f, -0.07117051f, 0.02456200f, 0.01704361f, 0.15251093f, 0.02354245f, 0.20326586f, 0.09621222f, 
    0.43022439f, -0.62098849f, 0.05381913f, -0.25991008f, 0.05834671f, 0.14874279f, 0.07046703f, 0.09936294f, 
    -0.06416348f, -0.25239953f, 0.04356340f, -0.05491629f, -0.30814442f, -0.09984196f, -0.14777598f, -0.20852883f, 
    -0.03568313f, -0.10301053f, -0.05969986f, -0.16218036f, -0.21240416f, -0.02647440f, -0.01549963f, 0.04831098f, 
    0.07808889f, -0.17142886f, 0.07173958f, -0.45075107f, 0.06439982f, -0.05326470f, 0.07920941f, -0.07969559f, 
    -0.02716986f, -0.13323157f, -0.01784761f, -0.26978692f, 0.16012120f, 0.19889866f, 0.26680073f, 0.13547029f, 
    0.06767454f, -0.11185948f, -0.04042726f, -0.09876584f, -0.01305262f, -0.03067411f, 0.04426859f, -0.02203729f, 
    -0.05529148f, 0.16124523f, 0.14315963f, -0.37177974f, 0.05740455f, 0.19079924f, -0.27547356f, 0.11837052f, 
    -0.11233419f, -0.04117398f, -0.01060930f, -0.09252843f, -0.23606375f, -0.18030962f, -0.05262277f, -0.20447275f, 
    0.06738017f, -0.03536104f, -0.02776152f, -0.01176824f, 0.03852570f, 0.14652601f, 0.06654896f, 0.20264028f, 
    0.44106108f, -0.26431614f, -0.11357996f, -0.07361472f, 0.07484052f, -0.10766505f, -0.06287422f, 0.14071308f, 
    -0.02287530f, -0.12597017f, 0.14616568f, 0.00133005f, -0.37183225f, 0.00797889f, -0.03348951f, 0.23953578f, 
    -0.11242609f, 0.07625042f, -0.06073447f, -0.02165899f, 0.16902152f, 0.02373149f, 0.01319692f, 0.04993241f, 
    0.08918013f, -0.09139929f, -0.15227214f, 0.14225867f, 0.16364151f, -0.18543006f, -0.02794647f, 0.23997098f, 
    0.17527786f, -0.16547811f, 0.23435052f, -0.01109104f, -0.00482149f, -0.14525494f, 0.07989796f, 0.15264264f, 
    -0.06595960f, -0.03315819f, -0.05298433f, -0.09616773f, -0.02789528f, -0.30255023f, -0.12816691f, -0.09391923f, 
    0.43445167f, 0.13932523f, 0.11451259f, 0.15797333f, 0.04447487f, 0.10809682f, -0.03142526f, -0.02513811f, 
    -0.08225317f, -0.04398829f, 0.03206454f, 0.01611523f, -0.02295062f, -0.00570732f, -0.19337539f, -0.11167562f, 
    -0.00126659f, 0.07249813f, -0.04486817f, -0.14391595f, 0.00205496f, -0.07100725f, 0.04982962f, 0.16751598f, 
    0.06222008f, -0.11425923f, -0.02915361f, -0.12902804f, -0.09950043f, 0.21488619f, 0.24105138f, -0.12805800f, 
    -0.16361247f, 0.07426120f, -0.17233071f, -0.11125994f, -0.34405300f, -0.00996193f, 0.21411425f, 0.04136597f, 
    0.08903091f, -0.00267541f, -0.06871065f, -0.06499699f, 0.31939515f, 0.11640292f, 0.29652333f, -0.08199089f, 
    -0.14908937f, -0.09024128f, -0.31128278f, -0.26828638f, -0.06750770f, -0.07363351f, -0.13287830f, 0.13136758f, 
    -0.03055143f, -0.08528206f, 0.05827146f, -0.04490312f, 0.19541565f, -0.15174261f, -0.12313268f, 0.01756169f, 
    0.03482857f, -0.08933000f, 0.01145301f, -0.13218641f, -0.00992199f, 0.17023742f, -0.09335347f, -0.00101927f, 
    -0.80150312f, 0.08653329f, 0.08361214f, -0.00391875f, -0.13228433f, -0.02524208f, 0.11732823f, -0.05544681f, 
    -0.08995523f, -0.07121066f, 0.02047848f, -0.09329318f, -0.40268248f, 0.00143480f, 0.13119940f, 0.01616305f, 
    0.03904156f, 0.07066198f, -0.03461355f, 0.00274797f, -0.05390278f, -0.01528400f, 0.02566720f, 0.07308632f, 
    -0.48947519f, 0.27491552f, -0.13680813f, -0.35817513f, 0.07841159f, 0.06458400f, -0.01687779f, -0.05361534f, 
    -0.05772512f, -0.07287305f, -0.02979914f, 0.02231928f, -0.01277333f, 0.27133060f, 0.30962428f, 0.20793906f, 
    -0.05688747f, -0.04519522f, -0.07091080f, 0.34295794f, 0.03653438f, -0.00679373f, 0.05460620f, 0.19574821f, 
    -0.46286398f, -0.22894892f, 0.26699340f, 0.04788192f, 0.27622765f, -0.11711426f, -0.06761512f, -0.24972852f, 
    -0.11450882f, -0.10370336f, 0.12353732f, 0.19909748f, 0.05766249f, 0.04037507f, -0.16604249f, -0.00190119f, 
    -0.11160949f, -0.03123540f, -0.01660394f, 0.08369663f, 0.04966913f, -0.01911645f, 0.24379668f, 0.06351440f, 
    -0.02886645f, -0.20421766f, 0.02016961f, -0.20900105f, 0.09913042f, -0.01941724f, -0.07749926f, 0.11275310f, 
    0.05817081f, 0.12072746f, 0.15599102f, 0.05894228f, 0.23509671f, 0.14518610f, 0.07686415f, -0.18873264f, 
    -0.07668281f, -0.11669367f, 0.01924825f, -0.08462761f, -0.12731071f, -0.18343028f, -0.02372734f, -0.07614106f, 
    0.10423243f, 0.12186022f, -0.12733357f, 0.26324862f, -0.00464388f, 0.06585801f, 0.13647072f, 0.11669943f, 
    0.06171076f, -0.01376073f, -0.05088849f, -0.05797549f, -0.76613855f, -0.37989357f, -0.16198273f, -0.06780561f, 
    0.13461591f, 0.04288048f, -0.09769439f, -0.00551650f, 0.09344900f, 0.15335201f, 0.04533015f, 0.05403815f, 
    -0.39095134f, -0.18845244f, -0.28591767f, 0.13610093f, 0.04852339f, -0.04968710f, 0.10120057f, -0.08033840f, 
    0.05882014f, -0.04653842f, 0.10823984f, -0.03941448f, -0.16011931f, 0.17983884f, -0.13381721f, -0.28878543f, 
    0.04436226f, -0.07177599f, -0.06520656f, 0.15113808f, 0.06122766f, 0.09350531f, -0.05137524f, 0.10413603f, 
    -0.25079784f, -0.37704715f, -0.06954405f, 0.05621157f, 0.10128158f, -0.05394812f, 0.00488612f, -0.17332084f, 
    -0.10891005f, -0.08636294f, -0.15333833f, 0.14688204f, -0.49077842f, -0.14974438f, 0.08965894f, -0.06884653f, 
    0.25274754f, 0.18381146f, -0.10964277f, -0.19698386f, 0.00612808f, -0.24267696f, -0.18177454f, 0.07801533f, 
    -0.17853855f, -0.22703229f, 0.02366771f, -0.05938550f, 0.09211811f, 0.08281001f, 0.13152559f, 0.06923760f, 
    0.16351952f, -0.02005618f, -0.00570621f, 0.10980655f, -0.58663177f, -0.28526461f, -0.34484702f, -0.14902680f, 
    0.14558494f, -0.06955505f, 0.03290373f, 0.02989317f, 0.10395969f, -0.08355965f, -0.09763119f, 0.02314563f, 
    0.03895007f, 0.21409166f, -0.20449506f, -0.09759790f, 0.03189149f, 0.07365944f, 0.17905523f, -0.03286840f, 
    0.18817729f, 0.13815819f, 0.06852839f, 0.12043174f, -0.53775591f, -0.31756371f, -0.33977470f, -0.23784357f, 
    -0.09428104f, -0.01937170f, -0.01357051f, 0.03524800f, -0.00649778f, 0.02292728f, -0.11555098f, -0.08380714f, 
    0.26215991f, 0.14387511f, -0.00444747f, -0.27836135f, 0.22029644f, 0.06721488f, -0.09683756f, 0.27256230f, 
    -0.11243862f, 0.07893002f, 0.03188216f, 0.10219122f, -0.59093660f, -0.32655358f, 0.22573748f, 0.22811979f, 
    0.14138238f, 0.00627061f, 0.17581134f, -0.05084847f, 0.16090065f, 0.07018209f, 0.02719377f, 0.15129115f, 
    -0.10763965f, 0.30798948f, 0.15913896f, 0.07310697f, 0.20124361f, 0.05929565f, 0.20185395f, 0.01365852f, 
    0.06074058f, 0.17731248f, 0.05028515f, 0.16244689f, 0.33345664f, 0.27964810f, -0.18514553f, 0.06515425f, 
    -0.31134596f, -0.19974568f, 0.05036928f, -0.10263998f, 0.20949906f, -0.03115894f, -0.11853173f, -0.17157204f, 
    0.18739319f, 0.06573895f, 0.10289273f, -0.14717600f, -0.00248796f, 0.04432777f, 0.07995412f, -0.03235625f, 
    0.11244891f, 0.17865263f, -0.02210370f, -0.02291392f, 0.29092836f, 0.15944031f, 0.08042338f, 0.15325509f, 
    0.05007384f, -0.10629246f, 0.01179914f, 0.13052420f, 0.05156201f, -0.07657657f, -0.11645800f, 0.09473475f, 
    0.15130666f, 0.13759089f, -0.05203021f, -0.15986468f, -0.01326860f, -0.01736095f, 0.02020126f, -0.07747202f, 
    -0.06961784f, -0.28229061f, -0.16826318f, 0.15046404f, -0.69221890f, -0.16532190f, -0.28796789f, -0.22219425f, 
    0.06140143f, -0.06780945f, -0.12978309f, -0.01785601f, 0.08257014f, 0.19165958f, 0.01436234f, 0.11663735f, 
    -0.34564564f, -0.15604684f, 0.21818814f, 0.02145194f, 0.18020247f, -0.07506711f, -0.07519083f, -0.01794332f, 
    0.14673224f, 0.16779836f, -0.09731375f, 0.09478559f, -0.51393229f, -0.29509374f, -0.30417600f, -0.28113976f, 
    0.19706108f, 0.09549562f, -0.19336677f, -0.01633647f, 0.09150980f, -0.10474950f, -0.12517790f, -0.05868674f, 
    0.20608601f, 0.26448816f, -0.14270391f, -0.06814022f, 0.16968071f, 0.16855791f, -0.04727239f, 0.00210347f, 
    -0.20706320f, 0.04375833f, 0.32318863f, -0.09498172f, 0.25164247f, -0.00772170f, -0.10416452f, 0.06257968f, 
    -0.07440386f, 0.16349958f, 0.03300148f, 0.04141673f, 0.02509253f, 0.24575563f, 0.14345199f, 0.11086425f, 
    -0.53980267f, 0.18651922f, -0.08380008f, -0.38473952f, 0.27628416f, -0.02957849f, -0.11046360f, -0.03024450f, 
    0.11532269f, 0.01289802f, 0.12045488f, -0.05182071f, 0.02496311f, -0.06329672f, -0.17735222f, 0.04248764f, 
    0.03097133f, 0.07213397f, -0.02083184f, 0.05279870f, 0.10260140f, -0.02074406f, 0.04097837f, -0.02664598f, 
    -0.21176861f, -0.39173058f, 0.27076900f, 0.20345177f, 0.28162411f, -0.02088520f, 0.11453474f, 0.06665039f, 
    0.20136821f, 0.15895803f, 0.04454434f, 0.13716622f, 0.27254719f, -0.01969955f, 0.11562686f, -0.06776603f, 
    -0.27995047f, 0.10068912f, -0.03874978f, 0.05699768f, 0.13525937f, -0.07364088f, -0.04014742f, -0.05273160f, 
    -0.29522097f, -0.21571003f, 0.10102636f, -0.42745617f, 0.07732481f, -0.06912397f, 0.06910811f, 0.10264049f, 
    0.20177513f, -0.06141344f, -0.08890610f, 0.01523798f, -0.21017331f, -0.15312970f, 0.07365274f, 0.00476729f, 
    0.01238482f, 0.16281292f, 0.20072433f, -0.18315865f, 0.01886810f, -0.16733304f, -0.20879053f, -0.18577026f, 
    0.25531855f, -0.19828653f, -0.13239136f, 0.10892490f, -0.01916082f, -0.24876268f, 0.11232433f, -0.08473308f, 
    -0.07750423f, -0.13924195f, -0.10275221f, -0.03379187f, -0.33056229f, -0.14747573f, -0.15683290f, -0.15345974f, 
    0.14468822f, 0.06910484f, 0.07294231f, 0.04918092f, -0.02799266f, -0.09549861f, -0.25146240f, 0.06543093f, 
    0.27179042f, -0.12658902f, 0.00536020f, 0.17297946f, 0.12796921f, -0.10356206f, -0.08572516f, 0.09083872f, 
    -0.02407787f, 0.14022167f, -0.01806537f, 0.01833202f, 0.00961942f, 0.00486957f, -0.04139011f, -0.10780799f, 
    -0.04013423f, -0.15567930f, 0.05139052f, -0.18892667f, -0.07832957f, -0.07967941f, -0.05239225f, -0.10074845f, 
    -0.22805783f, 0.00137687f, 0.06124161f, -0.01185313f, -0.01699068f, 0.09746063f, -0.06914245f, -0.08482975f, 
    -0.03592921f, -0.13618778f, 0.14744942f, 0.09071460f, 0.50764495f, 0.14723724f, -0.28912613f, 0.09488437f, 
    0.06692592f, -0.05031528f, -0.07221147f, -0.00150431f, -0.00344862f, -0.12945393f, -0.06475862f, -0.04343708f, 
    0.23552470f, -0.52836114f, -0.20438075f, 0.22992496f, -0.07784961f, -0.19198716f, -0.10978708f, 0.00485708f, 
    -0.00578215f, 0.08430582f, -0.04104765f, 0.12247138f, 0.01061534f, -0.00467853f, -0.32188773f, -0.07086129f, 
    0.06703578f, -0.12459968f, 0.01290448f, 0.25717139f, 0.01194790f, -0.08167133f, -0.01167251f, 0.03633690f, 
    -0.35735047f, -0.47373506f, -0.03089677f, -0.39817101f, 0.02163124f, -0.02843560f, -0.10067622f, 0.23803771f, 
    -0.19315143f, -0.20200579f, 0.07184286f, -0.00302415f, -0.06592400f, 0.43797094f, -0.04629890f, -0.07352147f, 
    0.05253855f, 0.07502916f, 0.02686429f, 0.12230597f, 0.20535131f, 0.08483610f, 0.14077906f, -0.03632831f, 
    0.02689863f, -0.36275920f, 0.07539024f, 0.21610910f, 0.20180714f, 0.07350148f, 0.05741722f, -0.26831627f, 
    -0.14092639f, 0.09841447f, -0.06998713f, 0.06130765f, -0.35728893f, -0.56855267f, 0.07318667f, -0.18527971f, 
    0.08658179f, -0.00131553f, 0.20429055f, 0.06156085f, 0.10987392f, 0.10514285f, 0.01426278f, 0.00138926f, 
    -0.28137869f, 0.18711819f, 0.07699428f, 0.49392813f, -0.25238243f, -0.09349778f, -0.03528554f, 0.12943737f, 
    -0.12377873f, 0.02928919f, 0.15611549f, -0.03365624f, -0.06436134f, 0.22101675f, -0.34775847f, -0.19867295f, 
    0.22930764f, -0.09908545f, 0.13004167f, -0.04233475f, 0.02136212f, 0.06718382f, -0.12393901f, 0.02380937f, 
    0.34727448f, -0.03636130f, -0.15918113f, 0.26290283f, -0.13105825f, 0.09483504f, 0.03464043f, 0.25764748f, 
    0.16455512f, 0.07422231f, -0.06752040f, -0.10578419f, 0.51554894f, 0.08028467f, 0.10051881f, -0.25028169f, 
    -0.01493679f, 0.00393003f, -0.10024342f, -0.15719877f, -0.04830867f, 0.09636899f, -0.02506338f, 0.09988854f, 
    0.61238813f, -0.14727451f, -0.03729834f, 0.12106374f, 0.05287942f, 0.01872532f, -0.13421436f, 0.02701204f, 
    -0.00164609f, -0.06567825f, 0.08121300f, -0.05521004f, -0.06595150f, -0.29686740f, 0.03933287f, 0.05194188f, 
    -0.09065638f, 0.07485087f, -0.04416446f, 0.19170170f, -0.03853174f, -0.06221567f, -0.11007289f, -0.04959649f, 
    0.21594562f, -0.00067347f, -0.09062655f, -0.17116202f, -0.17232826f, -0.13525499f, -0.16542457f, -0.05358489f, 
    0.01726982f, 0.03159238f, 0.07298983f, -0.26893044f, -0.28824800f, 0.28038970f, 0.06697096f, -0.52310950f, 
    0.04522049f, -0.11207806f, 0.07463155f, 0.00683558f, 0.07869845f, 0.05303441f, 0.00004624f, 0.00718222f, 
    -0.56303245f, 0.14166011f, 0.01963512f, -0.21965252f, -0.16971722f, 0.11329631f, -0.05212962f, 0.16337745f, 
    -0.00840860f, 0.37346959f, 0.07964286f, -0.18174052f, 0.35393748f, -0.07139736f, -0.30210021f, 0.01903368f, 
    -0.03374701f, 0.02957898f, 0.03864520f, 0.10883286f, -0.04818993f, -0.16253805f, 0.08250143f, -0.10865349f, 
    0.25498825f, 0.07235123f, 0.01254865f, -0.05447882f, 0.05022098f, 0.04542381f, -0.07838336f, -0.05521129f, 
    0.14052075f, 0.05266860f, -0.05945851f, 0.02793903f, -0.17776130f, -0.17107216f, -0.03050319f, -0.27996993f, 
    0.06665197f, -0.09061835f, 0.07139269f, -0.00437396f, -0.03407704f, -0.16040631f, -0.17852402f, -0.00409479f, 
    -0.06888292f, 0.20419857f, -0.32254514f, 0.10519133f, -0.17789996f, 0.15893304f, 0.21780924f, -0.08474808f, 
    0.13289484f, -0.08736486f, -0.03599584f, -0.18961495f, 0.04900846f, 0.20637856f, -0.08152664f, 0.13615693f, 
    0.12971926f, -0.08391322f, -0.02809581f, 0.04373568f, 0.03728071f, 0.03007648f, -0.16160919f, -0.19160265f, 
    -0.21710017f, -0.31082204f, 0.24889416f, 0.27108687f, 0.05670516f, 0.04956482f, 0.03240072f, -0.01348969f, 
    -0.07605709f, -0.01157504f, 0.01022186f, 0.20052932f, -0.58548450f, 0.44281796f, -0.07479374f, 0.18965736f, 
    0.13026182f, -0.08878636f, -0.01082162f, 0.06987470f, -0.02472251f, -0.02959694f, 0.05240305f, -0.04413847f, 
    0.10734119f, 0.06977013f, -0.06402675f, -0.25426242f, 0.18994871f, -0.05055946f, 0.00991062f, 0.15975635f, 
    0.01511909f, 0.15891226f, 0.00749677f, 0.03460860f, -0.12391741f, 0.01036465f, -0.11016761f, 0.26044104f, 
    -0.10091535f, 0.04399988f, 0.08052015f, -0.14796986f, -0.13951388f, -0.09088660f, 0.11009056f, -0.18843326f, 
    0.47286114f, 0.08232903f, -0.34874994f, -0.24257991f, -0.02336602f, -0.19601847f, 0.14320843f, -0.09436479f, 
    0.06093965f, 0.04324102f, 0.05917223f, -0.06393582f, -0.19299732f, 0.32734156f, -0.02812884f, 0.16975394f, 
    0.11084919f, -0.02365605f, -0.05792286f, -0.22399785f, 0.03463087f, 0.02356039f, 0.03749371f, -0.03699565f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13382739f, 0.05260237f, -0.08353671f, 0.01467666f, 0.01088358f, -0.00162078f, 0.01680581f, -0.08827866f, 
    -0.04427217f, 0.01701342f, 0.12439054f, 0.03587691f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
