#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.41297072f, -0.21300849f, 1.12669969f, 0.56967622f, 0.46356732f, 0.71896207f, -0.07635461f, -0.11592155f, 
    0.10719223f, 0.78537309f, 0.94349462f, -0.46419463f, -0.40676358f, 0.20847015f, 0.02727698f, 0.02307884f, 
    0.18547669f, 0.14907883f, -0.06855997f, -0.82835847f, -0.01720784f, 0.07053011f, -0.36309451f, -0.38914669f, 
    -0.45285133f, -0.20618215f, -0.70058662f, 0.07224485f, 0.28199071f, -0.13710830f, 0.24233231f, -0.57620901f, 
    -0.79209524f, -0.71701211f, -0.10506769f, -0.11003366f, 0.43425155f, 0.57507610f, 0.30087927f, -0.68516755f, 
    -0.45821390f, -0.29965040f, 0.15869333f, 0.44973299f, 0.43875703f, -0.10782018f, -0.15311073f, -0.16635761f, 
    0.39473775f, 0.47376710f, 0.47656542f, 0.26810440f, 0.20572066f, -0.66164106f, -0.50140005f, 0.33634493f, 
    0.75401467f, 0.42792618f, -0.40494460f, 0.69756240f, 0.38110384f, 0.41239837f, 0.15618545f, -0.55485827f, 
    -0.22976819f, -0.18779618f, -0.55766785f, -0.64525211f, -0.51476187f, 0.61392200f, 0.39131293f, 0.09145348f, 
    -0.52389288f, -0.94539618f, -0.26147828f, 0.84438586f, 0.74095792f, 0.15402320f, -0.31956378f, -0.28594673f, 
    -0.24956708f, 0.33363095f, 0.36548644f, 0.72107464f, -0.15925218f, -0.02546277f, 0.43918261f, -0.13539524f, 
    -0.64081079f, -0.41313863f, -0.16098595f, -0.42847225f, 0.08726589f, -0.35596758f, -0.64677554f, -0.82547057f, 
    0.07078946f, 0.41089413f, 0.67190981f, -0.63223654f, 1.00464332f, -1.02102792f, 0.44523203f, -0.05481234f, 
    -0.09746382f, 0.09776557f, 0.24995641f, 0.08299777f, 0.34670860f, -0.43303552f, -0.11484825f, 0.69581920f, 
    -0.35589352f, -0.29528207f, 0.58984387f, -0.08179782f, -0.20592608f, 0.76564819f, -1.24798882f, -0.25487983f, 
    -0.55633277f, 0.23120168f, 0.34975097f, -0.14497633f, 0.18605715f, -0.03790614f, 0.73870111f, -0.30876517f, 
    0.65429533f, 0.07781971f, -0.05974965f, -0.06737329f, -0.11123214f, -0.13866700f, 0.61826551f, 0.28850129f, 
    -0.29399425f, -0.58121699f, 0.34094223f, -0.51710111f, -0.41046983f, -0.13492191f, 0.58111393f, -0.33381972f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22004500f, 0.61146265f, 0.09037156f, -0.02180905f, 0.35401276f, 0.55728382f, 0.02614570f, 0.13576637f, 
    -0.07527263f, 0.38147062f, 0.38929412f, -0.03536783f, 0.48620787f, 0.36586797f, -0.05300237f, 0.43721649f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06831217f, -0.08593549f, 0.01764585f, 0.01951846f, 0.02125776f, -0.02767525f, -0.06941401f, -0.04135054f, 
    -0.00347784f, -0.07313910f, 0.02159178f, -0.02006494f, 0.04636448f, -0.06685885f, 0.01076142f, -0.03153061f, 
    -0.03582775f, -0.07581033f, 0.01255977f, 0.04298924f, 0.06024212f, 0.07772090f, -0.06597960f, -0.04911166f, 
    -0.08661057f, -0.00007522f, -0.08711695f, -0.06039075f, -0.07795178f, -0.01947626f, -0.02705413f, -0.06251164f, 
    0.01228520f, 0.02213966f, -0.02805536f, -0.01639607f, -0.08336215f, 0.06811188f, -0.05270296f, -0.04614841f, 
    0.02690780f, 0.05368987f, 0.03225125f, -0.06837002f, 0.05477529f, 0.03666217f, 0.05176438f, -0.02114434f, 
    0.06954452f, -0.08802803f, -0.06807896f, -0.06995577f, -0.06178479f, -0.06728845f, 0.04091555f, 0.02420187f, 
    -0.08881195f, 0.01695454f, 0.04481947f, -0.07661538f, 0.05789365f, -0.00708390f, -0.04660618f, -0.06216149f, 
    0.03527443f, -0.02632986f, 0.02813528f, -0.00700134f, -0.07100286f, -0.05243236f, -0.03012457f, -0.07567937f, 
    0.04485872f, 0.00793067f, -0.04352611f, 0.05039163f, 0.05922291f, -0.05373665f, -0.07516662f, 0.04162675f, 
    -0.05072173f, 0.02355654f, -0.03407243f, -0.08817455f, 0.01590985f, -0.01179564f, 0.05149373f, 0.00565235f, 
    0.03552134f, -0.01403135f, -0.06943326f, 0.05881950f, -0.00247611f, -0.02932847f, -0.05223244f, 0.04993372f, 
    -0.02066593f, -0.06034258f, -0.05835441f, -0.03725899f, -0.04220580f, -0.04534090f, -0.02439358f, 0.05723818f, 
    -0.01250177f, -0.03990740f, 0.01188075f, -0.02661745f, 0.04474116f, -0.02850606f, -0.07954732f, -0.04661646f, 
    -0.08219803f, -0.04062888f, 0.05637634f, 0.01698725f, 0.03233653f, 0.02992569f, 0.03861449f, -0.01952738f, 
    -0.04776150f, 0.05234683f, -0.03678130f, -0.01025149f, -0.03737718f, -0.03456741f, -0.04233046f, -0.03779335f, 
    -0.02957863f, 0.04248171f, -0.05479840f, 0.04590155f, 0.03131165f, 0.00006465f, 0.06579810f, 0.02948313f, 
    -0.04468989f, -0.00850745f, -0.08014026f, 0.07903659f, -0.02180978f, 0.06187895f, 0.06384181f, 0.06003820f, 
    0.00647562f, 0.38653931f, 0.15881753f, -0.30494341f, -0.20576492f, -0.20864667f, -0.15271458f, 0.10229471f, 
    -0.11243255f, 0.04442205f, 0.14061436f, -0.05714529f, 0.04488365f, -0.27425420f, 0.21971701f, 0.10420826f, 
    0.11057048f, 0.08854444f, 0.10870161f, -0.18708152f, -0.25324303f, -0.04916875f, -0.07557681f, 0.09640087f, 
    -0.01126384f, -0.08178438f, 0.15637803f, -0.03046463f, -0.66364783f, -0.03164777f, 0.07014759f, 0.10483146f, 
    0.05639546f, 0.09952136f, -0.13143137f, -0.03860870f, -0.35024273f, 0.07643598f, -0.16967216f, 0.09897793f, 
    -0.03215596f, 0.23029420f, 0.18181439f, 0.09493869f, 0.25067070f, 0.14800422f, 0.30801547f, 0.27954310f, 
    0.01913871f, -0.01629856f, -0.18444502f, 0.00537908f, -0.11938457f, 0.01146105f, -0.12417120f, 0.11081161f, 
    0.23132737f, -0.07455615f, 0.15528958f, -0.08751273f, 0.06843063f, 0.16568248f, -0.05078556f, -0.00697513f, 
    0.17260388f, 0.09482128f, -0.05854008f, -0.12377314f, 0.05823430f, 0.13478900f, -0.00985578f, -0.00304652f, 
    0.59320992f, -0.52905935f, -0.58269966f, -0.09010129f, 0.04029617f, -0.25072291f, 0.05663468f, -0.11844930f, 
    0.10533234f, 0.13866879f, -0.14746420f, 0.00928966f, 0.04141565f, 0.12573646f, 0.15388207f, 0.03197377f, 
    0.02433120f, 0.14317358f, -0.09977409f, 0.07244704f, 0.20712587f, -0.12226873f, -0.12630047f, 0.00996557f, 
    -0.03174319f, -0.07084545f, 0.22276078f, 0.58778495f, 0.01920159f, -0.12436871f, -0.38168934f, 0.33050388f, 
    -0.04582145f, 0.20076428f, -0.04849806f, -0.10842852f, -0.06354170f, -0.52273780f, 0.21887133f, -0.10940091f, 
    0.20664649f, 0.00195436f, 0.18592757f, 0.07176551f, 0.01707393f, -0.42919448f, -0.64866358f, -0.21333188f, 
    0.15584271f, -0.08136950f, 0.31007901f, -0.03266873f, 0.13795711f, -0.07318638f, 0.07761082f, -0.29094788f, 
    0.08954227f, 0.04095384f, -0.00959745f, 0.02001116f, 0.20552036f, 0.08168165f, -0.00927508f, -0.03658336f, 
    -0.51659936f, 0.30508250f, -0.29503515f, 0.04358169f, -0.04741238f, 0.02061887f, 0.11460032f, 0.05825054f, 
    -0.00451802f, -0.11179772f, -0.41582698f, -0.20062946f, -0.07868002f, 0.03625409f, 0.09526679f, 0.15956146f, 
    0.05391499f, 0.11456504f, -0.30978552f, -0.65598315f, 0.00663376f, 0.07556432f, 0.02563614f, -0.01348044f, 
    -0.02372227f, -0.01353108f, 0.31435612f, 0.04182471f, 0.39420894f, 0.01094817f, 0.07356547f, 0.10190097f, 
    0.28724638f, -0.05131241f, 0.01566032f, -0.21237458f, 0.20902428f, -0.15100650f, 0.00456516f, -0.03958540f, 
    -0.08926772f, -0.02323548f, -0.01190596f, 0.07136774f, -0.14506030f, -0.32455468f, -0.18636490f, -0.05810957f, 
    0.02631503f, -0.16600345f, 0.03289323f, 0.07317566f, 0.16632363f, 0.19487505f, -0.42177171f, -0.28570125f, 
    -0.12736593f, -0.15945199f, -0.00789346f, 0.01505787f, -0.03372169f, 0.00474992f, -0.09107999f, 0.00356084f, 
    0.13058539f, -0.06300256f, -0.20329253f, -0.07215436f, 0.02368421f, 0.04716631f, 0.15233973f, 0.02411444f, 
    0.30164787f, 0.25481039f, -0.22539937f, -0.04172666f, -0.01391712f, 0.01785468f, 0.24068494f, -0.03321564f, 
    0.38132346f, -0.38338941f, -0.17384011f, -0.07057915f, -0.02499536f, 0.13837425f, 0.09286523f, 0.05360974f, 
    0.06351665f, -0.01900387f, -0.08834165f, -0.06767904f, -0.08413914f, -0.05388449f, -0.10471210f, 0.10541904f, 
    -0.09934323f, -0.19668834f, 0.19328696f, 0.30040020f, 0.27507180f, -0.00185142f, 0.16320516f, -0.04511880f, 
    0.07234827f, 0.01459340f, 0.12360767f, -0.18177123f, -0.04485285f, -0.93767577f, -0.23812956f, -0.43102139f, 
    0.22467630f, 0.04608260f, 0.18026641f, -0.21123314f, 0.12899992f, -0.11316022f, -0.08209686f, -0.00199157f, 
    0.23754449f, 0.14002374f, 0.06782965f, -0.00676603f, -0.01731158f, 0.29957727f, 0.07478419f, -0.28822565f, 
    -0.10244127f, -0.04437295f, 0.28135553f, -0.00292675f, 0.06419894f, -0.16635747f, -0.05595769f, 0.20410566f, 
    0.32674059f, 0.02641046f, 0.10657027f, -0.25036818f, 0.07682946f, 0.06836137f, -0.02067980f, 0.22268446f, 
    0.00502035f, -0.17087321f, -0.05314282f, 0.08702391f, -0.01694315f, -0.02367938f, 0.01786662f, 0.01401456f, 
    -0.03071295f, 0.19666626f, -0.37417176f, -0.13095886f, 0.07765836f, -0.01855950f, 0.00481351f, 0.04495917f, 
    0.03845537f, 0.53784823f, 0.03112675f, -0.07762164f, 0.11164808f, -0.07740923f, 0.19146921f, 0.11037796f, 
    0.15787116f, -0.03286546f, 0.37091297f, -0.00894976f, 0.00958791f, -0.12624899f, 0.10148771f, 0.00677849f, 
    -0.00372785f, 0.17620875f, 0.15440390f, 0.07151551f, -0.36720780f, -0.01769562f, -0.13781102f, -0.08825970f, 
    -0.13438748f, 0.18119632f, 0.05059358f, -0.01538207f, 0.16856344f, -0.11572900f, -0.37543476f, 0.11256663f, 
    0.00267899f, 0.04440455f, -0.02223217f, -0.09126402f, -0.03062774f, -0.00115846f, -0.01603524f, 0.14586978f, 
    -0.04437404f, 0.13444003f, -0.03882988f, -0.04545110f, -0.00173221f, 0.32806110f, 0.02324655f, -0.17040782f, 
    -0.08102118f, 0.04010623f, 0.24328084f, -0.02619922f, -0.05067135f, 0.04730248f, -0.20016406f, -0.24203457f, 
    -0.06213391f, -0.15492235f, -0.09086695f, 0.16057502f, -0.13730772f, 0.06463574f, -0.08281759f, -0.05839162f, 
    -0.23641387f, -0.25001025f, 0.20082925f, -0.19016598f, -0.09228928f, -0.07863290f, -0.10675191f, 0.00656939f, 
    0.23054898f, -0.01089755f, 0.28677288f, 0.00915489f, -0.00826438f, 0.10441402f, 0.13750723f, -0.03333605f, 
    0.02893988f, 0.18660061f, -0.50671273f, -0.19953293f, -0.06541758f, 0.04457583f, -0.01539588f, -0.27206427f, 
    0.04695453f, -0.04630210f, -0.10645299f, 0.07280301f, -0.26488477f, 0.07286831f, -0.02191646f, -0.02331394f, 
    0.10825763f, -0.00258687f, -0.24958953f, -0.03741621f, -0.11195013f, 0.08567218f, 0.05887719f, 0.19568858f, 
    0.16924280f, -0.04353818f, 0.10059357f, 0.02982446f, -0.06363389f, -0.23060866f, 0.40664709f, 0.08575732f, 
    -0.02942783f, -0.01269428f, 0.11761944f, 0.09578294f, 0.11389159f, 0.05780891f, 0.50416762f, -0.00176468f, 
    -0.06171260f, 0.05427793f, -0.03254314f, 0.16346526f, 0.10087683f, -0.04394662f, -0.28100646f, -0.30088702f, 
    0.14458013f, -0.04790181f, 0.12704673f, -0.04091188f, -0.00464014f, 0.09437545f, -0.26776195f, 0.09701709f, 
    -0.07333281f, 0.00917897f, -0.02577963f, 0.01482517f, -0.09209104f, -0.21391295f, -0.14139254f, -0.16895136f, 
    -0.17197600f, -0.59460169f, 0.10227894f, 0.07653193f, -0.17079994f, -0.00915225f, 0.01742504f, 0.03223811f, 
    0.10445679f, 0.23227943f, 0.32560658f, 0.07955156f, -0.23331214f, 0.12366343f, -0.03488507f, 0.06446207f, 
    0.24809155f, -0.08908948f, -0.31710088f, -0.19875635f, -0.08228864f, 0.20926547f, 0.15350421f, -0.03967277f, 
    0.15858805f, -0.17351326f, 0.04396620f, -0.14284451f, -0.14120722f, 0.07552117f, 0.30679861f, -0.15782343f, 
    0.09347157f, 0.04936294f, 0.18826681f, 0.20013729f, 0.14144291f, -0.05905941f, -0.18294416f, 0.05610361f, 
    0.00720369f, 0.01054338f, -0.11149798f, 0.02721899f, -0.06298428f, 0.07017523f, 0.28025976f, 0.16045710f, 
    0.15120977f, 0.00439157f, -0.05655171f, -0.39529726f, 0.08701893f, -0.06838052f, 0.21796826f, 0.49143004f, 
    -0.13608961f, 0.12642398f, 0.13980851f, -0.08059770f, -0.06995769f, 0.07274324f, 0.12369613f, 0.11853821f, 
    0.38332126f, 0.01477927f, -0.30350426f, -0.05688589f, 0.11193107f, 0.05682720f, -0.07789646f, -0.08432614f, 
    -0.11042397f, -0.43181840f, -0.19037087f, 0.06806643f, 0.14477466f, -0.04212058f, -0.11083106f, -0.33751175f, 
    -0.06199350f, -0.20529470f, 0.39392957f, 0.10302152f, 0.16835637f, 0.01858410f, 0.12473840f, 0.04985095f, 
    0.05488278f, -0.04013235f, 0.08599579f, 0.03946909f, -0.36706063f, -0.06093134f, -0.01030696f, 0.12835781f, 
    0.12145553f, -0.04253675f, 0.30012304f, 0.03798875f, -0.21547355f, 0.14752160f, 0.11904109f, 0.07236661f, 
    0.06949308f, -0.11189629f, 0.04749876f, 0.03775905f, 0.04234079f, 0.05553098f, -0.09908992f, -0.04023663f, 
    -0.24911806f, 0.14197625f, 0.15655439f, 0.15842393f, -0.09345322f, -0.08656684f, -0.06341855f, 0.23951420f, 
    -0.09751096f, 0.24509642f, 0.16423805f, -0.08248619f, 0.10766920f, 0.33505583f, 0.07730072f, -0.06658001f, 
    0.06082594f, -0.01901895f, -0.03764004f, 0.01741877f, 0.12263151f, 0.04039843f, -0.01164483f, 0.05346457f, 
    -0.39864874f, -0.26123878f, 0.16121848f, 0.06144979f, -0.11728086f, -0.32504663f, -0.02494985f, -0.13275790f, 
    0.19019987f, -0.19524476f, -0.17044409f, -0.01009987f, -0.01312769f, 0.06501205f, 0.08214203f, -0.07057197f, 
    0.06678500f, 0.17659937f, 0.13704738f, 0.23784271f, -0.11812752f, 0.15602416f, 0.12991774f, -0.11313423f, 
    0.05947985f, -0.17055057f, -0.10079727f, -0.13024598f, 0.23560560f, -0.03933625f, 0.11164875f, 0.15803537f, 
    0.00014253f, -0.17264454f, -0.14107569f, -0.30381787f, -0.23100947f, -0.20837171f, -0.09530023f, -0.03666109f, 
    0.08031700f, 0.06417313f, -0.13124493f, -0.07955816f, 0.25220674f, 0.00805899f, -0.03097199f, 0.10834051f, 
    0.05454933f, 0.09917232f, 0.03823227f, 0.04970856f, -0.11575039f, -0.12862428f, -0.02802977f, -0.13221118f, 
    0.30670041f, -0.36150602f, -0.05363604f, -0.12319565f, 0.00308325f, 0.10907874f, 0.07520699f, 0.12505448f, 
    0.13537760f, 0.21752302f, -0.00062889f, -0.06316173f, 0.14919406f, 0.07859006f, 0.02001897f, -0.06028118f, 
    -0.19327891f, -0.10173862f, -0.48579258f, 0.19273607f, -0.15396631f, -0.08771886f, -0.04784021f, 0.08023208f, 
    0.09402119f, -0.15546829f, -0.23610179f, 0.09886114f, 0.02810956f, -0.13118593f, 0.06531697f, 0.14341840f, 
    -0.03159600f, -0.11201856f, 0.07036632f, 0.21079749f, 0.19592945f, -0.02344465f, 0.16246486f, 0.02330610f, 
    0.05975873f, 0.08278813f, 0.00210016f, 0.06731269f, 0.11888161f, 0.13386075f, 0.02157260f, -0.05664544f, 
    0.10601019f, 0.01844601f, -0.10351878f, -0.11108161f, 0.33217841f, 0.22756636f, -0.06242979f, 0.08222070f, 
    0.10573538f, 0.13755061f, -0.04698596f, 0.22625135f, 0.12758991f, 0.28954715f, 0.07157545f, -0.04842884f, 
    0.01734241f, 0.02837648f, 0.04202698f, 0.01349293f, 0.14870429f, 0.21968435f, -0.46028519f, -0.22372451f, 
    -0.19536431f, 0.00000029f, 0.01014727f, 0.05075138f, 0.07818143f, -0.14966302f, 0.16163360f, 0.07334643f, 
    0.01697954f, 0.14116694f, 0.06694873f, 0.17311847f, -0.10662566f, 0.09223700f, -0.04427993f, 0.08086861f, 
    -0.02816139f, 0.16194989f, 0.34771907f, 0.01044941f, 0.24435043f, 0.09332877f, -0.17310449f, 0.01547992f, 
    -0.03810366f, 0.10254149f, 0.12356610f, 0.14597110f, 0.10046560f, 0.21359868f, 0.13860834f, 0.00539926f, 
    -0.20259652f, -0.06249061f, 0.09797785f, -0.17896068f, -0.51833642f, 0.00453668f, -0.03514002f, -0.06256419f, 
    0.05926985f, 0.12897606f, 0.16365451f, 0.02165690f, -0.25533128f, -0.23544726f, -0.19232488f, 0.17060731f, 
    -0.02064048f, 0.37886012f, -0.07535346f, -0.02712120f, 0.00530875f, 0.22986177f, -0.00490859f, 0.14686757f, 
    0.06160789f, -0.15090509f, -0.00839234f, -0.03403183f, -0.19321896f, 0.02010938f, 0.08107810f, 0.43310919f, 
    0.01278174f, -0.08353908f, -0.04550615f, 0.08810642f, 0.02982985f, -0.19884741f, 0.00084015f, 0.27189788f, 
    0.20488204f, -0.21071570f, 0.02536526f, 0.06754829f, 0.13707471f, 0.08341288f, 0.07379195f, -0.13361748f, 
    0.22729304f, 0.06913155f, -0.12913156f, -0.08973425f, -0.00100545f, 0.02985894f, -0.03783053f, 0.02504289f, 
    -0.42568430f, 0.10913412f, 0.21481182f, 0.15877627f, -0.29582113f, -0.42092401f, -0.02238509f, 0.27030975f, 
    0.02913850f, 0.12241314f, -0.16701105f, 0.05986732f, 0.13216464f, 0.13852049f, 0.15031391f, 0.15143131f, 
    -0.10959924f, 0.00093036f, 0.13319106f, 0.32200381f, -0.07259337f, -0.13462850f, 0.11112883f, -0.00364928f, 
    -0.05787597f, 0.04142006f, 0.03998388f, -0.09453118f, -0.23952779f, -0.09868507f, -0.18184154f, 0.15090008f, 
    -0.09947238f, 0.01279105f, 0.20901917f, -0.19999857f, 0.06934217f, -0.22912408f, -0.00398748f, 0.02646944f, 
    -0.20954742f, -0.03279148f, -0.04864667f, -0.16190837f, -0.01955160f, -0.28117454f, -0.11550212f, 0.22375301f, 
    -0.20731509f, -0.29634356f, 0.04500076f, -0.03245697f, -0.08926606f, -0.33710346f, -0.08612587f, 0.03669914f, 
    -0.07127892f, 0.08190233f, 0.07079617f, 0.20025295f, 0.36642882f, -0.17224580f, 0.03438012f, 0.10647753f, 
    0.07234114f, -0.09794667f, -0.17021677f, -0.00888162f, -0.03412541f, 0.31633595f, -0.06344797f, 0.06290230f, 
    -0.02949305f, -0.12624769f, -0.06259887f, 0.02960590f, 0.30089232f, 0.15915039f, 0.15487924f, 0.11630696f, 
    -0.05041523f, -0.06951535f, 0.16611750f, 0.04243645f, 0.01507563f, 0.11401647f, -0.01257193f, -0.16930044f, 
    0.03027611f, 0.13723087f, -0.02908842f, 0.14688030f, 0.21313037f, 0.20987849f, -0.04124295f, 0.03334350f, 
    0.08460426f, 0.30228785f, 0.36031476f, 0.25394315f, -0.10961790f, 0.37071660f, 0.00307256f, -0.02359820f, 
    -0.00961449f, 0.22557147f, 0.27617684f, 0.17449498f, 0.11710165f, -0.00710932f, 0.14457211f, -0.00539724f, 
    0.08174124f, -0.05479554f, -0.02733254f, -0.05756895f, -0.21865650f, -0.10574757f, 0.06267254f, -0.05967808f, 
    0.25508940f, 0.06706127f, 0.13787277f, 0.03580004f, 0.19650120f, 0.09770285f, -0.13073117f, 0.00301621f, 
    0.13091874f, -0.04881906f, 0.03207482f, -0.01387681f, 0.01069594f, 0.15061481f, -0.02970120f, 0.03321500f, 
    -0.12221176f, -0.05543273f, 0.23538065f, 0.06502737f, 0.05435723f, 0.04897002f, 0.03470534f, -0.16965503f, 
    -0.39325079f, -0.09200606f, -0.25453165f, 0.12398077f, -0.05349756f, 0.30842423f, -0.03275395f, -0.09799793f, 
    0.16313399f, 0.14681941f, 0.03521891f, 0.17529230f, -0.26279178f, 0.09713902f, 0.20665403f, 0.15968278f, 
    0.16120084f, 0.03564793f, 0.09333175f, -0.09427459f, -0.02153506f, 0.30446711f, 0.13580771f, 0.24895599f, 
    0.09767199f, 0.17956010f, -0.23922567f, -0.01321628f, -0.10107365f, -0.06433328f, -0.01913795f, 0.06743903f, 
    -0.03146410f, 0.03860581f, -0.09229162f, 0.15799087f, -0.08142447f, -0.14636296f, 0.01352260f, -0.00437635f, 
    0.10106499f, 0.14115004f, -0.00993890f, 0.16864812f, 0.21216938f, 0.00456417f, 0.12091939f, 0.20450337f, 
    0.17544092f, 0.06638064f, 0.08790161f, 0.25456190f, 0.05992742f, 0.20698376f, -0.00312362f, -0.18253928f, 
    0.18835483f, -0.09996279f, -0.03539016f, -0.05073731f, -0.14559464f, 0.01053460f, -0.11246637f, 0.06650742f, 
    0.14004049f, 0.14179640f, 0.23881371f, 0.17080274f, 0.16317585f, 0.09908435f, 0.14374669f, 0.16075827f, 
    -0.59589261f, 0.16790451f, -0.02602081f, -0.06099045f, 0.17074721f, -0.29725537f, -0.11795673f, -0.02437120f, 
    -0.12552583f, -0.08804093f, -0.35703659f, -0.28485131f, 0.11490608f, 0.11262490f, 0.01485006f, -0.06007769f, 
    -0.07438324f, 0.09668901f, 0.05265205f, 0.10530446f, 0.16436954f, 0.17270257f, 0.12333659f, -0.01847653f, 
    -0.01259459f, -0.04193631f, -0.20793946f, -0.09337582f, 0.18243080f, 0.09950585f, 0.23987907f, 0.10573477f, 
    -0.05558673f, 0.12236538f, -0.00031104f, -0.04749496f, -0.14454082f, -0.22922303f, -0.25096089f, 0.26449108f, 
    0.19221792f, -0.00469886f, 0.02285154f, 0.18006071f, 0.07868672f, -0.34374493f, 0.35596222f, -0.15546302f, 
    0.13154335f, -0.16264865f, 0.08437185f, -0.04237624f, 0.14096536f, 0.05613935f, -0.36454865f, 0.12365743f, 
    -0.00956888f, 0.07302418f, -0.00634032f, 0.17222026f, 0.19507313f, 0.06506118f, 0.12138411f, -0.16984279f, 
    0.07075541f, 0.29288572f, -0.12882075f, -0.06786823f, -0.02643055f, 0.03727603f, 0.06656737f, 0.08668707f, 
    -0.66872668f, 0.32483286f, 0.07737058f, 0.21658644f, -0.17450061f, -0.09488141f, 0.00637753f, -0.27082521f, 
    -0.20686698f, -0.09486425f, -0.20080787f, -0.06861146f, -0.13072453f, -0.19919460f, -0.20410784f, -0.00749313f, 
    0.06215400f, -0.18960807f, -0.18763918f, 0.24957964f, 0.19356093f, 0.05856501f, -0.01114409f, -0.00944062f, 
    0.06102535f, 0.24619117f, 0.17864846f, 0.12764016f, 0.28992599f, 0.28885284f, 0.00500696f, 0.23708208f, 
    0.18135366f, -0.15526870f, 0.10382774f, -0.08155613f, -0.00293279f, -0.13838443f, 0.40050888f, 0.15380141f, 
    0.00193435f, -0.02762677f, 0.08011901f, 0.05553260f, 0.17201889f, 0.32448757f, -0.03826387f, 0.14935134f, 
    0.08991892f, -0.22491391f, 0.37146685f, -0.04865700f, 0.03299128f, -0.02248370f, -0.31450638f, 0.32744673f, 
    0.28556582f, -0.04065278f, 0.21358739f, 0.21654312f, -0.15223783f, -0.17538573f, 0.15917854f, 0.09231821f, 
    0.40044165f, 0.13682704f, -0.15425707f, 0.05510705f, -0.02353999f, 0.06100890f, 0.16463338f, 0.17319909f, 
    0.27401248f, 0.17682083f, -0.04269175f, 0.00219138f, 0.13757320f, 0.05345236f, -0.05022180f, 0.09917375f, 
    0.08178344f, -0.46867621f, 0.42682105f, -0.19559711f, 0.05627618f, -0.14682993f, -0.03363375f, 0.02165314f, 
    0.07766987f, 0.05013093f, 0.14512698f, 0.00144131f, 0.14955759f, 0.05821902f, -0.05527734f, -0.00531449f, 
    -0.02642726f, -0.02742809f, -0.12163501f, -0.21224196f, -0.14540750f, 0.09049993f, -0.01186002f, 0.05873858f, 
    -0.06022907f, 0.05660786f, 0.01355434f, -0.00744443f, 0.06482420f, -0.00971924f, -0.08867391f, -0.02430645f, 
    -0.18985601f, -0.01421522f, -0.10850830f, -0.09026489f, -0.26836729f, 0.09038234f, -0.17834207f, 0.16238686f, 
    -0.11125831f, -0.03791323f, -0.11326040f, -0.10833123f, -0.03451731f, 0.30111736f, -0.05963860f, -0.14785340f, 
    -0.24869683f, -0.10000914f, -0.01069321f, -0.10013174f, 0.21288943f, 0.11615500f, 0.05971428f, 0.11640001f, 
    0.21248597f, 0.34757182f, 0.04831529f, -0.05171513f, 0.04715422f, -0.12887214f, 0.13378002f, 0.12542561f, 
    0.51350969f, 0.04294184f, 0.36451504f, -0.05753181f, 0.06887783f, -0.06127409f, -0.02011685f, -0.02752113f, 
    0.02798400f, -0.21504335f, -0.39593750f, -0.39838508f, 0.10557436f, -0.02793443f, 0.02564394f, 0.07427586f, 
    -0.01754883f, 0.01443078f, 0.23809086f, 0.25232229f, 0.19982466f, 0.06158124f, 0.06687434f, -0.08554476f, 
    -0.11710612f, 0.09579900f, 0.13629089f, -0.42339897f, -0.59822077f, -0.25198835f, -0.16559692f, 0.05943755f, 
    0.14259991f, 0.03837606f, 0.14952469f, -0.16178218f, 0.10162362f, -0.29652184f, -0.07567812f, 0.23287278f, 
    0.11694396f, -0.02486511f, 0.06955239f, -0.06810180f, 0.02768429f, -0.26032534f, 0.35628501f, -0.02149143f, 
    0.03318419f, -0.09117998f, -0.01805720f, -0.09018449f, 0.05290361f, 0.07267673f, -0.08744786f, -0.30908886f, 
    -0.11551186f, 0.24425939f, 0.05229983f, -0.02414766f, 0.01780837f, 0.00564133f, -0.26089293f, 0.19688691f, 
    0.03135294f, 0.23627067f, 0.12378085f, -0.08956786f, -0.11812087f, 0.04507063f, -0.06834820f, 0.03458314f, 
    -0.03823075f, 0.18744567f, 0.30768368f, 0.05312009f, 0.04094069f, -0.02131878f, 0.06271491f, -0.04642896f, 
    -0.03667756f, 0.16871089f, 0.26297462f, 0.05789928f, 0.15934649f, -0.14971325f, 0.09898999f, -0.04454451f, 
    -0.08456118f, -0.03881380f, -0.06067675f, 0.06417486f, -0.15792756f, 0.12276011f, 0.11051150f, -0.04303116f, 
    -0.13699637f, 0.02936667f, 0.18279879f, 0.25797921f, -0.03612850f, 0.16997109f, 0.08552098f, 0.16146229f, 
    -0.12616867f, -0.03992854f, -0.10767978f, 0.01648577f, 0.12612076f, 0.18672889f, 0.14956915f, 0.06275477f, 
    -0.06693150f, 0.06452329f, -0.08571163f, -0.21189708f, -0.13946925f, 0.05553747f, -0.04267595f, -0.00145085f, 
    -0.05694215f, -0.00706606f, 0.11643600f, 0.12848112f, -0.28736991f, 0.06343062f, 0.17148279f, 0.21893859f, 
    0.03231674f, 0.19551410f, -0.19014703f, 0.02753738f, -0.05284756f, -0.26598412f, -0.12816563f, -0.00364233f, 
    -0.07783780f, -0.09997264f, 0.07079505f, 0.12737329f, -0.04574564f, -0.01070215f, 0.04301137f, -0.06331173f, 
    -0.11798597f, -0.39501807f, 0.01681388f, 0.03184541f, -0.31293145f, -0.04014542f, 0.13541292f, 0.20385376f, 
    -0.03627886f, 0.33385247f, 0.26989368f, 0.31265712f, 0.13547499f, -0.14149117f, 0.04690298f, 0.16144800f, 
    -0.13976344f, 0.25997019f, -0.16896178f, 0.02634022f, 0.00607214f, -0.11030684f, -0.01513638f, -0.01008249f, 
    -0.23011197f, -0.15740502f, 0.01916370f, 0.24336685f, 0.18569741f, -0.12072166f, 0.27078363f, 0.18567955f, 
    -0.01731448f, 0.00401798f, 0.04050983f, -0.13773033f, 0.09613217f, 0.06358467f, -0.06875060f, 0.06676716f, 
    0.27499229f, -0.20800549f, -0.26650894f, -0.10931312f, -0.31098881f, -0.22563221f, 0.27439737f, -0.00801440f, 
    -0.04274942f, 0.18882781f, 0.11336085f, 0.00553157f, 0.03570980f, -0.05771198f, 0.33145413f, 0.22639090f, 
    -0.10114883f, -0.07174976f, -0.00995333f, -0.08068778f, -0.02021048f, 0.29791367f, -0.23125944f, -0.13922751f, 
    0.03261927f, -0.03822600f, 0.09970099f, -0.11831252f, -0.07812532f, 0.01669485f, -0.10900071f, 0.03608732f, 
    -0.02170461f, -0.26949510f, -0.00027026f, 0.05611001f, -0.14799619f, 0.04899566f, 0.08581214f, -0.00630799f, 
    -0.01015801f, -0.05072730f, 0.07379151f, 0.00638509f, 0.12887974f, -0.09605414f, -0.08798441f, -0.00171399f, 
    -0.16256273f, 0.18578456f, -0.02666244f, 0.14476970f, -0.16272834f, 0.04911597f, -0.09020240f, -0.10128099f, 
    0.04986376f, -0.01157234f, -0.14064981f, 0.03301886f, -0.06656720f, -0.19725581f, 0.05377045f, 0.02213190f, 
    0.18502761f, -0.14442113f, -0.05337151f, -0.09955443f, -0.23471428f, 0.06619468f, 0.25790575f, -0.05399527f, 
    -0.02083419f, -0.08471782f, 0.10484595f, 0.24308129f, 0.04640283f, -0.07041129f, -0.00048854f, 0.05916123f, 
    -0.00317918f, 0.05154094f, -0.01469992f, -0.06418389f, 0.10343067f, -0.19028042f, 0.09417815f, 0.23496966f, 
    0.47405919f, 0.18056482f, -0.09593046f, -0.00398474f, 0.08237866f, 0.07906024f, -0.00476863f, -0.12413856f, 
    0.01901948f, -0.14925241f, -0.00809088f, -0.05140771f, 0.13700610f, 0.05549221f, 0.17136854f, 0.10643529f, 
    0.07618779f, 0.09686908f, -0.10690056f, 0.01533890f, -0.17183453f, -0.22404625f, -0.04799228f, -0.31070262f, 
    -0.34113494f, -0.03602768f, -0.14043882f, -0.01697325f, 0.23583855f, 0.12043338f, 0.24770305f, -0.31496269f, 
    -0.08394141f, -0.20060273f, 0.03839660f, -0.16981806f, -0.06479625f, 0.17440805f, 0.13638113f, 0.07851735f, 
    0.21029684f, 0.16299422f, 0.00957806f, -0.06277908f, 0.41640928f, 0.03198470f, -0.16639933f, 0.00026082f, 
    0.00647151f, 0.04148014f, 0.21311273f, -0.02184515f, 0.25777441f, 0.18713717f, -0.31071723f, -0.08341417f, 
    -0.04646501f, -0.04811435f, 0.15206860f, -0.01394230f, 0.11216495f, 0.47949675f, -0.06388181f, -0.06989057f, 
    -0.00012329f, -0.00559744f, -0.06075364f, -0.09012640f, 0.06158195f, 0.12668380f, 0.04039178f, 0.08050209f, 
    0.01768262f, -0.08199286f, -0.02868721f, 0.03746397f, 0.02310103f, 0.17824443f, -0.15502597f, 0.31536084f, 
    -0.06319188f, -0.14299843f, 0.01226095f, 0.11784235f, -0.14291608f, -0.08812097f, -0.08013307f, 0.23285183f, 
    -0.02470098f, 0.02221665f, -0.05217106f, -0.02473406f, -0.04365395f, -0.02828170f, 0.04532328f, 0.01817849f, 
    -0.01107020f, 0.00931274f, -0.05463940f, -0.04950517f, 0.00154581f, -0.00628437f, 0.05394766f, -0.05335947f, 
    0.01930008f, -0.07019574f, 0.02267256f, 0.02927966f, -0.03265781f, 0.02496826f, -0.04871366f, -0.05156467f, 
    0.00435295f, 0.07141286f, 0.03165511f, -0.00740771f, 0.04318576f, -0.06392381f, -0.04139359f, 0.01418541f, 
    0.04494268f, -0.05388216f, 0.02089969f, -0.08606977f, -0.03223391f, 0.06389140f, 0.03199140f, -0.01173629f, 
    -0.06726554f, 0.01770660f, -0.05632747f, -0.07342315f, -0.06413772f, 0.04631070f, -0.00029514f, -0.05498620f, 
    -0.02472187f, -0.04444980f, -0.03884669f, -0.08675702f, -0.06202143f, -0.00644319f, -0.03092378f, 0.05551251f, 
    -0.06244374f, -0.00248981f, 0.05715846f, -0.02114015f, -0.04274895f, -0.00364537f, -0.01529751f, 0.01308818f, 
    0.03758608f, -0.05077122f, 0.03051279f, 0.01071180f, -0.08804997f, 0.01043013f, -0.06866288f, -0.04181281f, 
    -0.06823973f, -0.03360654f, -0.01004434f, -0.04550777f, 0.02905764f, -0.01811530f, 0.03032745f, -0.04669090f, 
    0.06133284f, -0.09178008f, 0.06572051f, -0.00267559f, 0.02625213f, -0.01497639f, -0.00616941f, -0.07187472f, 
    -0.04271396f, 0.06194307f, -0.03270119f, 0.05021642f, 0.04128497f, 0.03935133f, 0.03016626f, 0.06657528f, 
    0.04138360f, 0.04539381f, 0.06627937f, 0.03727714f, 0.06789097f, 0.05738856f, -0.06949537f, 0.03265917f, 
    -0.08203461f, 0.06435965f, 0.02869497f, 0.04715532f, -0.07224966f, 0.04604431f, -0.03018256f, -0.07900215f, 
    -0.00625924f, 0.06846423f, 0.00198689f, 0.03456520f, -0.00950759f, 0.03325686f, 0.00691624f, 0.06836927f, 
    -0.08610470f, -0.00445708f, -0.06614693f, -0.00421496f, -0.08736900f, -0.08968565f, 0.01577748f, 0.06895705f, 
    0.01425413f, 0.03884719f, -0.03025194f, 0.03570714f, -0.00643971f, -0.08489914f, 0.00566893f, -0.05116935f, 
    -0.05125984f, -0.04454825f, 0.02544491f, -0.07149594f, -0.08554903f, -0.06590803f, 0.01627100f, 0.05500588f, 
    -0.19811328f, -0.26526946f, -0.07967033f, 0.16577412f, -0.12843437f, 0.13507070f, 0.02511467f, 0.04537933f, 
    -0.02185231f, 0.20405477f, 0.26511008f, 0.14566106f, 0.21212202f, 0.00283975f, -0.01897813f, 0.00760948f, 
    0.03107461f, -0.11033329f, -0.23531665f, 0.03074570f, 0.15461247f, 0.19449241f, -0.11307111f, -0.10038232f, 
    -0.28064898f, -0.09402811f, -0.21728961f, 0.07470856f, -0.05058572f, -0.16485865f, 0.07790453f, 0.02424779f, 
    0.18005751f, 0.07438085f, -0.00491762f, -0.01820966f, 0.29565236f, -0.02720157f, -0.15079804f, 0.10924391f, 
    0.01008188f, 0.02321421f, 0.08473831f, 0.12530227f, 0.17420220f, 0.04102583f, -0.03697086f, -0.04448505f, 
    0.00538782f, 0.19629481f, 0.04427177f, -0.13965796f, 0.15585601f, -0.20422642f, -0.06691570f, 0.28084338f, 
    0.04194035f, 0.21741872f, 0.06600595f, -0.00556666f, -0.18598233f, 0.09117629f, 0.20877385f, -0.21770303f, 
    -0.08323179f, 0.01776905f, -0.19200169f, -0.07368366f, 0.04055334f, 0.05299895f, 0.12677687f, 0.16528939f, 
    -0.38114753f, 0.04091613f, 0.00616756f, 0.16676308f, -0.05951278f, 0.08241673f, -0.25507274f, -0.27865767f, 
    -0.38134447f, 0.13504589f, 0.12033013f, -0.09643863f, -0.09569070f, 0.09334864f, 0.14703201f, -0.26112750f, 
    0.02398261f, -0.35752392f, 0.03989032f, -0.19398141f, -0.26360029f, -0.00421034f, -0.00072343f, 0.02196927f, 
    0.16928011f, -0.00129961f, 0.13278441f, -0.16065742f, 0.46636048f, 0.07128807f, 0.11848036f, -0.29367486f, 
    0.00812586f, -0.06001366f, 0.36986381f, -0.15372236f, 0.02315024f, 0.13361183f, 0.10660841f, 0.18218292f, 
    0.06996389f, 0.11891387f, -0.20529202f, 0.18708436f, 0.00012617f, 0.24590276f, -0.05552426f, 0.13564086f, 
    0.14266211f, 0.19098163f, 0.11415710f, 0.01748039f, -0.01441941f, -0.00673638f, -0.24313295f, 0.19239210f, 
    0.23157352f, 0.20928289f, 0.11725663f, 0.25368083f, -0.03311922f, -0.03405071f, 0.38722315f, -0.02401834f, 
    0.07076113f, -0.00209525f, -0.02128277f, 0.32724705f, -0.13069917f, 0.12028758f, 0.09123604f, 0.06461933f, 
    0.27360958f, -0.00629526f, -0.21091168f, -0.08873954f, 0.16816221f, -0.06153830f, 0.24681295f, 0.15421401f, 
    0.19164820f, 0.25151405f, 0.06969186f, -0.53216159f, -0.00502261f, -0.15801378f, 0.06548841f, 0.06336171f, 
    0.02536324f, -0.09122206f, -0.12419441f, 0.09957684f, 0.11600935f, 0.08283589f, 0.12694937f, 0.08412720f, 
    0.14830792f, 0.01935768f, -0.02114142f, 0.25943264f, 0.13980711f, 0.46743500f, 0.10835187f, -0.18491769f, 
    0.01742050f, -0.26255524f, -0.03984151f, 0.00170630f, 0.12989305f, 0.09682401f, 0.12699573f, -0.07900137f, 
    -0.09112086f, -0.09567365f, 0.05888616f, -0.11526271f, -0.12804081f, -0.19008128f, 0.02788031f, -0.30866766f, 
    0.09314735f, 0.11372832f, -0.03546759f, 0.09096199f, -0.13223423f, 0.22023247f, 0.34087878f, 0.01462974f, 
    -0.12705079f, 0.21786179f, -0.13355660f, -0.12031598f, 0.07401325f, 0.07818395f, -0.06785176f, 0.62374163f, 
    0.07153505f, 0.19697584f, 0.24717034f, -0.09797718f, 0.02015576f, 0.06116964f, -0.06793722f, -0.14366065f, 
    -0.44340315f, -0.04860085f, -0.34042883f, -0.00663661f, -0.17197104f, 0.05526077f, -0.06004057f, -0.02233993f, 
    0.25825268f, -0.17155488f, -0.04082078f, -0.00839596f, 0.18446954f, 0.07871164f, -0.13929856f, 0.10923450f, 
    0.04535445f, 0.17976800f, 0.37072659f, 0.17111970f, 0.04062381f, 0.02479943f, 0.03361480f, -0.01245356f, 
    -0.17259818f, 0.04112821f, -0.13096677f, -0.12438554f, -0.01138745f, -0.57902509f, -0.02304775f, -0.06767598f, 
    0.08542479f, 0.15533797f, -0.05135760f, -0.19004148f, -0.06316915f, -0.01657446f, -0.15406601f, 0.08359906f, 
    0.04115139f, 0.16728000f, 0.08755958f, 0.02779296f, -0.04231152f, -0.22699305f, 0.08150399f, 0.13261224f, 
    -0.11545405f, 0.18037148f, -0.09407935f, -0.01166242f, -0.02199580f, -0.15070365f, 0.39602822f, -0.59342194f, 
    -0.66175973f, -0.07909092f, 0.01176718f, -0.08154574f, 0.14668232f, -0.15852533f, -0.09955154f, -0.14603207f, 
    0.03961299f, 0.08973313f, -0.03509147f, 0.21481784f, -0.08442433f, 0.11353173f, -0.28033638f, 0.09221485f, 
    -0.09045256f, -0.29237431f, -0.08269800f, -0.04024822f, -0.05852056f, 0.08285161f, -0.09600707f, -0.00068837f, 
    0.03697892f, 0.41975313f, 0.15839031f, 0.06693472f, 0.03607225f, 0.01697855f, -0.09929522f, -0.03505483f, 
    -0.00257497f, 0.03097746f, 0.15996085f, -0.27033445f, -0.27537313f, -0.19096145f, -0.08364479f, 0.05579453f, 
    0.21998648f, -0.18201509f, 0.11096328f, -0.24026845f, 0.17219216f, -0.28832313f, -0.01120460f, -0.08848437f, 
    -0.03655250f, 0.17906719f, 0.01798981f, 0.13715106f, 0.41468590f, 0.27702823f, 0.34948602f, -0.04580946f, 
    -0.04949562f, 0.05554713f, 0.10208537f, 0.07169680f, 0.05920500f, 0.09994604f, 0.32655978f, 0.01066056f, 
    0.04474172f, 0.02651226f, -0.10735663f, 0.08881832f, 0.10842532f, 0.32237551f, -0.13660982f, 0.03659373f, 
    -0.26371929f, -0.10775480f, -0.18885885f, -0.07239904f, 0.08503523f, -0.03131122f, 0.00055386f, 0.03264448f, 
    -0.12438010f, 0.02679398f, -0.06439926f, -0.00432542f, 0.09210409f, 0.00007415f, -0.03585923f, 0.14468789f, 
    -0.37496957f, -0.56780499f, -0.42051238f, -0.05776389f, -0.03242398f, 0.03271055f, -0.06941530f, -0.11967988f, 
    -0.02383994f, 0.24207768f, 0.26462382f, 0.19551878f, 0.06435017f, -0.15565430f, 0.07561209f, -0.04274637f, 
    0.10521225f, 0.19915600f, -0.07515534f, -0.10323856f, -0.05432043f, -0.05847079f, -0.17604993f, 0.12612088f, 
    -0.03309427f, 0.11271361f, 0.05172673f, -1.04526627f, -1.06348717f, -0.74749041f, -0.20581633f, 0.01665993f, 
    0.11540829f, 0.01378514f, -0.07772805f, -0.18252601f, -0.38624471f, -0.02484285f, 0.17061208f, -0.04195315f, 
    0.14679429f, 0.19893335f, 0.11084820f, 0.25752106f, -0.02068752f, -0.27434498f, -0.57841659f, -0.32076862f, 
    0.18340807f, 0.01637792f, -0.10569086f, 0.03117219f, 0.08905581f, 0.04933709f, 0.24860218f, 0.19513297f, 
    0.37243408f, -0.21612732f, -0.16361016f, -0.11075403f, 0.07642220f, 0.12403788f, -0.07804650f, -0.07316599f, 
    -0.04394008f, 0.09028896f, 0.02453845f, -0.03096629f, -0.09762450f, -0.05257453f, 0.05428420f, -0.02077619f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00802180f, -0.03079262f, -0.00919525f, 0.16311945f, -0.11707619f, 0.11335945f, -0.03252154f, 0.17703821f, 
    0.08209487f, -0.00471553f, -0.14707334f, 0.02116766f, 0.04597219f, 0.14570375f, 0.05071616f, 0.26022086f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03245065f, -0.30607203f, 0.38664818f, 0.47988659f, -0.36432269f, -0.25014424f, -0.08158399f, -0.04849982f, 
    -0.04779380f, -0.21304555f, 0.38098857f, -0.27051610f, 0.22157833f, 0.16949129f, 0.13086502f, 0.18012334f, 
    -0.22487450f, -0.18557705f, -0.44569579f, -0.21922949f, 0.26993099f, 0.07622381f, -0.40530923f, 0.20884328f, 
    0.41224021f, 0.01583718f, -0.18753143f, -0.02957724f, 0.01147721f, 0.20617127f, -0.18726152f, 0.38097781f, 
    0.21571310f, -0.21240234f, 0.21696772f, 0.03096010f, 0.15076338f, 0.10951259f, -0.09892096f, 0.15085167f, 
    0.39540026f, -0.07187457f, 0.23936598f, -0.36761910f, -0.11244604f, -0.52481508f, -0.05307770f, -0.23357110f, 
    0.20024186f, 0.05463907f, 0.12510289f, -0.01873612f, 0.08163238f, 0.02033609f, -0.20135719f, -0.09089083f, 
    -0.25770146f, -0.16099773f, -0.14458184f, 0.04593484f, -0.20939922f, 0.20059650f, -0.14289467f, -0.18494520f, 
    -0.05352014f, 0.44456470f, 0.26105860f, -0.12084228f, -0.29269257f, 0.31921238f, 0.34041694f, -0.00260341f, 
    -0.31600198f, 0.19842160f, 0.27933317f, 0.08035570f, -0.06542134f, 0.26872569f, -0.23542605f, -0.32840395f, 
    0.24085671f, -0.46675968f, -0.17835680f, -0.08077239f, 0.08179674f, 0.08936025f, -0.06908984f, 0.37966579f, 
    -0.02769893f, 0.21165673f, 0.04406393f, -0.19885702f, -0.02407606f, -0.48797184f, 0.51054591f, -0.82187510f, 
    0.05289050f, 0.24580702f, 0.39412209f, 0.03355493f, -0.29566842f, -0.77490169f, -0.09163316f, -0.25163579f, 
    -0.17079887f, -0.15527515f, 0.13461234f, 0.04297851f, 0.08435224f, 0.02235102f, -0.06331563f, 0.35736799f, 
    0.14704499f, 0.14940301f, -0.16545743f, 0.31311831f, 0.03843075f, -0.35716963f, -0.07945996f, 0.04381994f, 
    0.63185650f, 0.16083583f, -0.16814615f, -0.11020528f, 0.16380221f, -0.20127553f, 0.41173932f, 0.83869052f, 
    -0.13210210f, -0.32946259f, -0.24688138f, 0.52404004f, -0.19611846f, 0.17192338f, -0.34127423f, 0.21328916f, 
    0.08643869f, -0.47278556f, -0.12170354f, 0.29791933f, -0.10971275f, 0.18042676f, -0.03030936f, -0.63845432f, 
    -0.03137732f, 0.43335563f, 0.50869066f, -0.37335375f, 0.24413256f, 0.10787251f, 0.04607035f, -0.13031679f, 
    -0.34468144f, -0.11699839f, 0.15121752f, 0.04604588f, 0.03002229f, 0.17828080f, 0.01779393f, -0.18364583f, 
    -0.08435827f, 0.06907916f, 0.44728759f, -0.51338857f, 0.28147748f, 0.06793455f, 0.36052254f, 0.08831127f, 
    -0.08686440f, 0.39304557f, 0.03242286f, -0.18637170f, 0.16765867f, -0.13870032f, 0.26885760f, -0.50644463f, 
    -0.19730686f, -0.11857884f, 0.60300761f, -0.13854830f, 0.26634228f, 0.37090653f, -0.07474223f, -0.14650857f, 
    0.00598251f, 0.06467423f, -0.31924370f, 0.09576996f, 0.03904252f, 0.27030456f, 0.22064416f, -0.03845124f, 
    -0.20167769f, -0.38226822f, -0.58556074f, -0.15282558f, 0.31581861f, 0.07519829f, 0.09084139f, 0.21238042f, 
    0.31071013f, -0.31248426f, -0.25842321f, 0.29681635f, 0.12071908f, 0.36945575f, -0.23221226f, 0.14916043f, 
    -0.11644927f, 0.47904804f, 0.29149029f, 0.12498465f, 0.14024267f, 0.08030769f, -0.41176039f, 0.24449237f, 
    0.35604429f, 0.37745434f, 0.09942674f, -0.31621882f, -0.17773998f, -0.26880449f, -0.21772079f, -0.19794919f, 
    -0.02272964f, -0.14643121f, -0.40977097f, 0.55375075f, -0.25542203f, -0.32230592f, 0.14286578f, 0.35472348f, 
    -0.04622725f, 0.49261102f, 0.06753294f, -0.71757072f, 0.10296081f, -0.23669294f, 0.16633159f, -0.48909238f, 
    0.18465775f, 0.02963889f, 0.00020909f, 0.05939011f, 0.38634944f, -0.15545683f, -0.32286873f, 0.23186505f, 
    -0.36404359f, 0.06947973f, 0.01880050f, 0.13688703f, 0.20136259f, -0.09935044f, 0.58327127f, 0.34695435f, 
    0.05013776f, -0.15371528f, -0.37083530f, 0.01062861f, 0.35443631f, 0.32184169f, -0.06897400f, -0.13925801f, 
    0.41058591f, 0.04242657f, -0.51530802f, 0.15761650f, 0.23655075f, 0.11789941f, -0.08715522f, 0.08750831f, 
    0.09320301f, -0.14206037f, 0.55927265f, -0.22092338f, -0.24710107f, 0.05175065f, 0.31771961f, -0.18935427f, 
    0.46843049f, 0.08669531f, 0.13348353f, -0.19573677f, 0.23773167f, 0.20752743f, 0.26608410f, 0.49969426f, 
    0.06708115f, 0.31912205f, 0.62264073f, -0.10485546f, 0.13540022f, 0.12239667f, -0.33790281f, -0.18761928f, 
    0.13807458f, -0.15096940f, 0.14789437f, 0.19518505f, -0.08295438f, 0.09619521f, 0.30306193f, 0.51426482f, 
    -0.02749684f, 0.24853019f, 0.16316612f, 0.44122273f, -0.24857464f, -0.16975668f, 0.08349323f, -0.01949734f, 
    0.43731150f, -0.19008690f, -0.00666860f, -0.05374061f, 0.12688053f, 0.22475259f, 0.06425228f, 0.37290663f, 
    0.07625043f, -0.26699001f, 0.07685313f, -0.17107160f, -0.07520645f, 0.18332833f, 0.17900704f, 0.42609844f, 
    -0.13835149f, 0.15537585f, 0.02955914f, -0.30586749f, 0.08070639f, -0.06468184f, 0.62423438f, -0.82119638f, 
    0.16005519f, -0.12932657f, 0.42631200f, -0.10907391f, -0.01442575f, 0.37826473f, -0.10662152f, -0.16773398f, 
    0.32891512f, 0.18121520f, -0.15992548f, -0.16699062f, -0.07357470f, 0.32848018f, -0.44570991f, -0.93107235f, 
    -0.02286122f, 0.19147815f, 0.01960010f, -0.37441117f, 0.32322386f, 0.43039522f, 0.22860657f, -0.14109354f, 
    0.08435722f, 0.09827458f, -0.16800322f, 0.25875181f, -0.20589344f, 0.14090541f, 0.24414556f, -0.33543387f, 
    -0.03835447f, -0.43567377f, 0.27242550f, -0.10895099f, 0.20207642f, 0.23768419f, 0.33509007f, -0.18546405f, 
    0.05899213f, 0.39130959f, 0.28858462f, -0.67386550f, -0.09372364f, -0.45544967f, 0.25449756f, 0.29584941f, 
    0.23404658f, 0.21334344f, -0.50527531f, -0.13666229f, 0.22471492f, 0.10677619f, -0.32265845f, 0.34309590f, 
    0.29753819f, 0.16748214f, 0.19633672f, -0.50720483f, -0.19376752f, -0.05095063f, 0.28888991f, -0.46237725f, 
    -0.07429305f, 0.52089739f, 0.34981546f, 0.12968412f, 0.22687632f, -0.17839123f, -0.08558984f, -0.04423426f, 
    -0.12378733f, 0.23970585f, 0.32029468f, -0.11702175f, -0.05985022f, -0.07059596f, -0.10087293f, -0.14866717f, 
    0.23221740f, -0.18200187f, 0.40480241f, 0.00146941f, -0.37445179f, 0.18430765f, -0.06160641f, 0.21671048f, 
    -0.14440829f, -0.38696763f, 0.20935616f, 0.32098457f, -0.25154537f, -0.16929317f, 0.29614401f, 0.37087375f, 
    -0.17663148f, 0.33806920f, 0.12839884f, -0.25392592f, -0.26945040f, 0.32756457f, 0.12842952f, -0.16151115f, 
    0.26884809f, 0.38974318f, 0.34794042f, -0.09781180f, -0.17118821f, 0.08029216f, -0.22455521f, -0.20271420f, 
    -0.02338541f, -0.43368915f, 0.30456367f, -0.52165616f, 0.33779162f, 0.16533491f, -0.08279045f, -0.12495933f, 
    -0.14913788f, 0.28751922f, 0.06077627f, -0.09899616f, 0.00581387f, -0.32632253f, -0.03381333f, -0.24402155f, 
    0.23510087f, 0.10679379f, -0.26600653f, 0.54054916f, -0.40169427f, 0.15833551f, -0.20741154f, 0.35242227f, 
    0.36382577f, -0.12309696f, -0.03131551f, -0.48932204f, -0.12873702f, 0.17068517f, -0.29343608f, -0.40492415f, 
    0.07032533f, -0.39023656f, 0.11543706f, -0.35455564f, 0.64206415f, 0.20173459f, -0.22379264f, 0.01992687f, 
    0.30644444f, 0.25562602f, -0.48061639f, 0.09868003f, 0.07212692f, 0.29416597f, 0.07221790f, 0.02544906f, 
    -0.22159392f, -0.44710505f, -0.46672899f, 0.55905926f, -0.08108722f, 0.13959685f, 0.30526763f, 0.33008641f, 
    0.19112267f, -0.21499118f, -0.07701337f, -0.11481477f, -0.22904566f, 0.03099925f, -0.28834707f, -0.18867731f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.37340221f, 0.48995501f, -0.10398224f, 0.18968222f, -0.12074542f, 0.33497471f, 0.74854887f, -0.32279497f, 
    -0.07095847f, -0.62981391f, 0.31111166f, 0.23316613f, 0.07507509f, 0.09776419f, 0.38884258f, -0.10386523f, 
    -0.03895231f, -0.09879793f, -0.08136807f, -0.02131441f, 0.22403322f, -0.00502977f, 0.14767388f, -0.18863624f, 
    0.44747469f, -0.02256232f, 0.47352958f, -0.08673263f, -0.27448535f, 0.44288245f, 0.33547574f, 0.30236712f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10323323f, -0.03360918f, -0.15256117f, -0.09873948f, -0.12618528f, -0.14487050f, 0.14149989f, -0.05560478f, 
    0.05426459f, 0.02758157f, 0.02686924f, -0.03364560f, 0.03685973f, -0.10778816f, -0.01416867f, -0.14432491f, 
    0.10379089f, 0.00864673f, 0.07346483f, -0.08373217f, -0.06958248f, -0.19068669f, 0.04305832f, 0.02669063f, 
    -0.11386257f, -0.05930601f, 0.00754702f, -0.04052348f, -0.08512740f, -0.08261397f, 0.09929872f, -0.11207706f, 
    0.46529794f, 0.28050128f, -0.20707507f, -0.06830381f, -0.23471245f, -0.20468095f, 0.16538496f, 0.50688648f, 
    -0.67316914f, -0.01655742f, -0.72511822f, -0.11445121f, 0.17130776f, 0.13621847f, -0.29771641f, 0.14537723f, 
    0.15952122f, 0.33035499f, 0.07109787f, 0.28525057f, -0.31982923f, -1.27660251f, -0.19803850f, -0.74041957f, 
    -0.06397632f, 0.28611213f, -0.27326301f, -0.27511349f, -0.19417498f, 0.07435609f, 0.15129012f, 0.17613779f, 
    -0.84025824f, 0.30441418f, 0.17287467f, -0.00999631f, 0.03997023f, -0.16745131f, -0.13480115f, -0.36687893f, 
    0.03112041f, -0.33207980f, 0.32406047f, 0.39138722f, 0.02148758f, -0.03772009f, -0.75663018f, 0.08427441f, 
    0.42864528f, 0.11777572f, 0.22770210f, -0.18470000f, 0.08906835f, 0.81296194f, 0.36661890f, 0.16128123f, 
    0.08144844f, 0.07128529f, -0.24753065f, 0.03753404f, 0.40816456f, 0.13276768f, 0.32232943f, -0.20013839f, 
    -0.17180687f, 0.09097129f, 0.23852877f, 0.09293252f, -0.07548746f, 0.15331681f, 0.26316676f, 0.52876502f, 
    -0.52117169f, -0.17328826f, -0.00498228f, -0.04350534f, -0.11488540f, 0.29558304f, 0.88802058f, 0.10420027f, 
    -0.27046385f, 0.06088822f, -0.09852645f, 0.07892887f, 0.08467162f, -0.29559085f, -0.15119262f, -0.06085128f, 
    0.27002287f, 0.31487077f, 0.09842072f, 0.13389389f, -0.26951009f, 0.34141624f, -0.31129563f, 0.01401047f, 
    -0.09079683f, -0.07533646f, -0.15583102f, -0.14251527f, -0.11087957f, -0.13664159f, -0.10840918f, 0.05417931f, 
    0.02688666f, 0.04367092f, -0.17540696f, 0.07473881f, -0.08543915f, -0.14518742f, -0.10762641f, -0.19967236f, 
    -0.16723947f, -0.20231867f, 0.02065807f, 0.05095929f, 0.01979090f, 0.00554969f, -0.01854225f, -0.10733926f, 
    0.00017005f, 0.03637172f, 0.14272974f, -0.03245641f, 0.09308325f, -0.14043608f, -0.13574481f, -0.08388991f, 
    -0.02014146f, 0.31413567f, 0.30658719f, -0.17659315f, -0.07773135f, -0.24185240f, -0.10821318f, 0.50473607f, 
    -0.71747005f, -0.14470731f, 0.11603148f, -0.11365137f, 0.03208560f, 0.52944726f, 0.17326826f, 0.44485602f, 
    0.18342754f, -0.21597628f, 0.10170088f, 0.10604232f, -0.28307131f, -0.63663298f, 0.06929892f, 0.38674390f, 
    0.21465459f, 0.38140690f, -0.43615016f, 0.13762881f, -0.17495131f, 0.06191338f, 0.00096312f, -0.23615626f, 
    0.30222157f, 0.09817784f, -0.36006120f, -0.00792037f, 0.20650846f, -0.20510113f, 0.41920963f, -0.39304948f, 
    0.07740214f, -0.52342516f, 0.15304177f, -0.09943208f, 0.08036555f, 0.03619288f, -0.00084144f, -0.28480577f, 
    -0.23564705f, 0.00928600f, -0.35692602f, -0.03976855f, 0.27380186f, 0.65437877f, -0.02803694f, -0.91555828f, 
    0.09754106f, -0.27934277f, 0.25960645f, 0.19929598f, -0.55409753f, 0.32478574f, 0.16010903f, 0.19326682f, 
    0.65717393f, 0.18844096f, -0.15357304f, -0.04792064f, 0.02039348f, 0.12358244f, -0.38174468f, -0.04450132f, 
    0.99289668f, 0.04960690f, -0.24850269f, -0.02365997f, 0.46331492f, -0.16754563f, 0.36749446f, 0.11332146f, 
    0.05472306f, -0.17287181f, -0.44609013f, -0.00935142f, 0.03669859f, -0.29467466f, -0.30573142f, -0.30686504f, 
    0.10742210f, -0.41419303f, 0.43922073f, -0.33059347f, -0.26781791f, 0.28191754f, 0.12487902f, 0.60496616f, 
    0.41404524f, 0.41280410f, -0.09552076f, -0.15118708f, -0.70357722f, 0.12786710f, 0.37271589f, 0.25884980f, 
    0.89697427f, -0.51635152f, -0.25552359f, 0.09892210f, 0.37322319f, -0.14461130f, 0.14019087f, -0.01359643f, 
    0.49622172f, 0.12713265f, -0.32896879f, -0.15866084f, 0.26750869f, 0.05827712f, 0.01328294f, 0.12511210f, 
    0.01706816f, -1.01777351f, -0.18015720f, -0.29227293f, -0.47719383f, 0.27358183f, 0.37776038f, 0.35392508f, 
    0.95955163f, 0.06082381f, 0.13077052f, 0.02010220f, -0.38272023f, 0.19610693f, -0.53175795f, 0.15448667f, 
    -0.22949648f, -0.10104520f, 0.04261241f, 0.00014694f, 0.29710126f, -0.24764509f, 0.17290500f, 0.38822392f, 
    0.26037630f, -0.12438969f, -0.07201704f, 0.08867873f, 0.18822205f, -0.56878585f, -0.00864756f, -0.06779071f, 
    0.17359267f, -0.34599140f, 0.09914888f, -0.56830913f, -0.00627949f, -0.10978321f, 0.06268728f, 0.03751068f, 
    0.23676285f, 0.12920719f, 0.27791193f, -0.10861467f, -0.74512786f, 0.14953621f, -0.40200877f, 0.19041733f, 
    0.87081462f, -0.40569186f, -0.17366676f, 0.01606730f, -0.03471383f, 0.06506759f, 0.38668209f, -0.21417664f, 
    0.15850130f, 0.22231185f, -0.24118038f, 0.17192072f, 0.14880344f, 0.24997714f, -0.18305886f, -0.10298182f, 
    0.21886906f, -0.62916714f, 0.10222743f, -0.19272096f, -0.31881484f, 0.42758223f, -0.04232864f, 0.06145019f, 
    -0.12419649f, 0.08595596f, -0.25569952f, -0.02178285f, 0.18979198f, -0.06842228f, 0.39964733f, 0.21425205f, 
    -0.32613021f, 0.00486000f, -0.21260995f, 0.27399844f, -0.06205910f, -0.33926937f, 0.24801959f, -0.07820688f, 
    -0.58855844f, 0.33999389f, 0.28315741f, -0.11550680f, -0.78985441f, -0.04739889f, -0.18609977f, 0.34216893f, 
    -0.22688822f, 0.21472606f, 0.14410453f, 0.22043514f, -0.08355954f, -0.48187727f, -0.18004121f, -0.19779864f, 
    0.16417828f, 0.35517246f, -0.32037139f, 0.08593915f, -0.04732063f, -0.22917564f, 0.05055949f, 0.04655745f, 
    0.53071100f, -0.08704644f, -0.00886182f, 0.19747633f, 0.40891197f, -0.10160448f, -0.90774369f, 0.02325790f, 
    0.44787261f, -0.05829284f, 0.04121965f, 0.03808432f, -0.25056529f, 0.26017874f, 0.14720006f, -0.72344244f, 
    -0.01407945f, -0.40402061f, 0.19908603f, 0.01429761f, -0.37259310f, 0.13391891f, 0.32551652f, 0.16630332f, 
    -0.26682234f, 0.15528847f, -0.82478243f, 0.03697002f, 0.00952739f, -0.36174124f, 0.34604174f, 0.32984877f, 
    0.03775894f, -0.00407131f, -0.68235952f, 0.18179446f, -0.19146208f, 0.17606950f, -0.63412428f, 0.18984139f, 
    -0.00093442f, -0.04588674f, 0.30931297f, 0.11087605f, -0.11958984f, -0.51748031f, 0.18262771f, -0.41425458f, 
    0.13940725f, 0.03004098f, 0.21471336f, 0.11963602f, 0.05466937f, -0.14832899f, -0.39292419f, -0.03187283f, 
    -0.04882343f, 0.15233101f, 0.05180146f, 0.01904603f, -0.01851580f, -0.17481358f, 0.09623823f, 0.26474577f, 
    -0.37000987f, -0.13151416f, -0.01716158f, -0.16509296f, -0.41059762f, 0.28101811f, 0.32813478f, 0.20155255f, 
    -0.28995490f, -0.05002414f, 0.23230655f, 0.07927535f, -0.07825617f, -0.27711329f, -0.33340421f, -0.45577157f, 
    0.37353626f, 0.07259078f, 0.03647955f, 0.04663850f, 0.01583933f, 0.14913489f, -0.24723791f, -0.07163588f, 
    0.40581086f, 0.00432866f, 0.03634882f, -0.14943260f, 0.19557002f, 0.21039446f, -0.35975805f, 0.29142776f, 
    -0.36830768f, -0.01348096f, 0.32392004f, -0.11980209f, 0.08595685f, -0.12459997f, -0.35623440f, 0.13270326f, 
    0.25265393f, 0.17983298f, -0.08285551f, -0.10902440f, -0.00384521f, -0.09403729f, 0.12979168f, 0.58148545f, 
    0.18155465f, -0.11486756f, 0.04608570f, -0.06049340f, 0.57442528f, -0.21570952f, 0.28256875f, 0.00792413f, 
    -0.57037836f, -0.14648753f, 0.58249801f, -0.02312621f, -0.45482153f, 0.67689544f, 0.32049480f, 0.09293875f, 
    -0.01642668f, 0.56331152f, 0.41748863f, 0.34640872f, -0.25844273f, 0.15896280f, 0.04170413f, 0.53058660f, 
    -0.33824435f, 0.22529818f, 0.19547272f, -0.21694323f, 0.50938088f, -0.20974338f, 0.04944084f, 0.63513142f, 
    0.05163640f, -0.11307723f, 0.36246601f, -0.33503073f, 0.73813957f, -0.27085063f, 0.35369349f, -0.12997682f, 
    0.52613187f, 0.03669380f, 0.10045172f, 0.02466265f, -0.08639851f, -0.03166947f, 0.46615514f, 0.27280325f, 
    -0.24683523f, -0.23101231f, -0.07660194f, -0.23903812f, 0.22091849f, 0.08350329f, 0.53999037f, -0.32187280f, 
    0.24718139f, 0.05102675f, -0.27074248f, 0.32556903f, -0.01686832f, 0.24994798f, 0.16541100f, 0.01971825f, 
    0.09384450f, -0.29675061f, -0.05604663f, 0.30510676f, -0.41495436f, 0.20634495f, 0.10489892f, 0.30418870f, 
    -0.01225978f, -0.01246289f, 0.20608692f, -0.05464391f, -0.79201734f, 0.43695390f, -0.14445645f, 0.05426832f, 
    0.37496591f, -0.18301108f, -0.16301201f, -0.02157317f, -0.14984028f, -0.03797069f, 0.67662400f, 0.26381940f, 
    0.15592358f, -0.06960140f, -0.29116306f, -0.51331931f, 0.15195572f, -0.19101079f, -0.09403862f, 0.62706453f, 
    0.10543019f, -0.37540904f, 0.06165670f, -0.15467536f, 0.39643720f, -0.18758793f, 0.00584168f, -0.10784314f, 
    -0.26142180f, -0.04206515f, 0.27522162f, 0.04074303f, 0.08304051f, -0.26658431f, 0.04652447f, -0.02886567f, 
    -0.14182383f, -0.43097442f, 0.18160495f, 0.06052047f, -0.33857250f, 0.38326851f, 0.10375015f, -0.27229780f, 
    -0.15610957f, 0.18899766f, -0.00943037f, -0.20209415f, 0.04629715f, 0.57987601f, -0.05111754f, 0.05933365f, 
    0.19693495f, 0.19892207f, 0.13258664f, 0.32975546f, 0.00619036f, 0.20499615f, -0.14060952f, 0.08994593f, 
    0.42789644f, -0.73102850f, -0.51671064f, -0.17798449f, 0.10416774f, 0.15846978f, -0.04670269f, 0.43388644f, 
    0.30043170f, -0.13023798f, 0.31698039f, -0.26961762f, -0.34958255f, -0.24979542f, 0.18556668f, -0.16207317f, 
    -0.02985207f, 0.17454252f, -0.18791047f, 0.00192061f, 0.23879071f, -0.18308589f, -0.36190036f, 0.59598953f, 
    -0.24382038f, 0.08898679f, 0.20483150f, 0.04749313f, -0.20878015f, -0.16385007f, -0.32972261f, -0.00476629f, 
    -0.38710168f, 0.15047923f, 0.11899796f, 0.08583447f, -0.30438355f, -0.03376625f, 0.72121924f, 0.39952487f, 
    -0.64383465f, -0.51080257f, 0.39715081f, 0.24343047f, 0.31528768f, -0.06332991f, -0.29497674f, -0.09848190f, 
    0.40430781f, 0.60562414f, 0.13140991f, -0.12042789f, 0.29074714f, -0.10871155f, 0.40151739f, 0.05900530f, 
    0.25824466f, -0.35850608f, -0.06233052f, -0.11906745f, -0.38585794f, -0.12246241f, 0.45156896f, -0.00013692f, 
    0.02315243f, 0.16624141f, -0.05802558f, -0.09684009f, 0.16695219f, -0.18758224f, 0.12497883f, -0.06622584f, 
    -0.45957178f, -0.52802753f, 0.38441882f, 0.28117409f, -0.02969888f, -0.07998414f, -0.20371982f, -0.05189475f, 
    0.10498521f, 0.38069221f, -0.09615207f, 0.01019300f, 0.31707412f, 0.81892753f, 0.21769296f, -0.75705546f, 
    0.05520752f, -0.29125455f, -0.06222139f, 0.26888388f, -0.64544791f, 0.12505552f, 0.19194572f, -0.20439461f, 
    -0.55724865f, 0.19794576f, 0.15438169f, -0.04719559f, 0.17891181f, 0.40458620f, 0.25504968f, -0.61497557f, 
    -0.20836803f, 0.40864301f, 0.44028628f, 0.10734742f, -0.00586076f, 0.16468981f, 0.49695605f, -0.05761915f, 
    -0.15394244f, -0.30596754f, -0.65213197f, -0.34217152f, 0.28588277f, 0.02135351f, 0.14892244f, 0.12485378f, 
    0.13726915f, 0.12146968f, -0.28027964f, 0.22248471f, 0.35083410f, 0.10680479f, 0.29843116f, -0.08185750f, 
    0.82241118f, 0.36093205f, -0.42030850f, 0.08299866f, -0.26105654f, -0.38244018f, 0.01881541f, 0.11342211f, 
    -0.37964889f, 0.02872949f, -0.02678199f, 0.05888951f, 0.43605718f, 0.19965403f, -0.67140418f, -0.10527593f, 
    0.51451600f, 0.41678518f, 0.03270531f, 0.01342400f, -0.30184624f, 0.37609872f, -0.07913977f, -0.64844614f, 
    -0.04430491f, -0.21911703f, -0.02817765f, -0.08393475f, -0.53728116f, 0.18988878f, 0.42643055f, 0.17590359f, 
    0.16542785f, 0.32319334f, -0.20270143f, 0.08575286f, -0.37951049f, 0.12019974f, 0.09567374f, 0.15459016f, 
    0.81104267f, 0.26604989f, -0.20835486f, 0.18849403f, 0.24244520f, 0.03724143f, 0.01169226f, 0.29348278f, 
    0.44981423f, -0.46003297f, -0.03150739f, -0.22910737f, -0.01034320f, -0.25420734f, 0.20213974f, -0.22922273f, 
    0.31772578f, -0.31033102f, 0.06289968f, -0.44859764f, -0.09707244f, -0.11263783f, 0.14086951f, -0.12503164f, 
    0.30937597f, 0.06752862f, -0.06463048f, 0.05279685f, -0.25975317f, 0.10027102f, 0.09866434f, 0.02231883f, 
    0.60783756f, 0.14659089f, -0.14866903f, -0.16674803f, -0.10188135f, 0.23643067f, 0.75848830f, 0.02737057f, 
    -0.10355382f, -0.71093875f, -0.53104043f, -0.25692734f, 0.28668877f, -0.11419592f, -0.16012244f, -0.15611272f, 
    0.34903175f, 0.14887151f, -0.14592990f, -0.24624905f, -0.18541510f, 0.28627220f, 0.03768464f, 0.29867947f, 
    -0.19967945f, -0.01520592f, 0.21947026f, 0.16233826f, -0.19883133f, 0.19807811f, 0.48100966f, 0.36603576f, 
    -0.10416158f, -0.10107958f, 0.20342764f, 0.33832720f, -0.16884889f, 0.11928290f, -0.27518257f, 0.28416303f, 
    -0.06396233f, 0.33113664f, 0.48504660f, 0.12196316f, 0.19490905f, -0.14608693f, -0.12660788f, 0.36376911f, 
    -0.07106698f, 0.22677542f, 0.41397119f, -0.38660786f, -0.04954784f, -0.08348303f, 0.23664564f, -0.20111229f, 
    -0.23416772f, -0.10172601f, -0.07199022f, -0.08306780f, 0.06035162f, -0.31052348f, -0.07547965f, -0.19581640f, 
    1.14294517f, -0.18458001f, -0.20239957f, 0.32931578f, -0.03533896f, 0.19133280f, -0.82025594f, 0.19087562f, 
    -0.03299272f, -0.01727617f, 0.35274357f, 0.16756733f, 0.10589999f, 0.06557921f, 0.21185535f, 0.02461393f, 
    -0.14945827f, -0.28499028f, 0.21917930f, -0.06429729f, 0.53092372f, 0.11418603f, 0.15992148f, -0.17880622f, 
    -0.16458058f, -0.15068699f, -0.03503809f, 0.06605047f, 0.17799328f, 0.41719842f, -0.10905591f, 0.06831878f, 
    -0.10665292f, -0.08232794f, 0.20775710f, -0.30152017f, -0.18972865f, 0.24310604f, 0.67737198f, 0.45413661f, 
    -0.21522816f, -0.18835104f, -0.27059078f, 0.03372675f, 0.33441809f, -0.40834987f, -0.01905696f, -0.27914730f, 
    0.30276132f, 0.19639090f, 0.03887441f, -0.27517375f, -0.19490530f, 0.18739246f, -0.23446512f, 0.26329798f, 
    -0.23925157f, 0.10622762f, -0.03228189f, -0.10485718f, -0.16110349f, -0.49259230f, 0.47725427f, 0.27817044f, 
    -0.56308550f, -0.41608778f, -0.05714567f, 0.24965830f, 0.16441299f, 0.27073637f, -0.72357076f, -0.02092098f, 
    0.52098453f, 0.10571933f, 0.37826043f, -0.11808386f, 0.00816514f, 0.27610284f, 0.11107942f, -0.01016718f, 
    0.29057926f, -0.14347084f, 0.06859448f, 0.42832667f, -0.54400128f, -0.07359848f, 0.13559760f, -0.20425446f, 
    -0.01973953f, 0.00037690f, -0.66848272f, -0.13764729f, -0.08258531f, -0.12425778f, 0.16402806f, 0.08041249f, 
    0.04998454f, -0.45952317f, -0.34763110f, -0.18713810f, -0.24288902f, 0.04416551f, 0.37016359f, 0.19263488f, 
    -0.71677548f, 0.18684369f, 0.13998915f, 0.03734399f, 0.17782347f, 0.16957062f, -0.15949775f, -0.53809506f, 
    0.22653151f, 0.09929690f, 0.15743782f, 0.07726145f, -0.04186545f, 0.41124800f, -0.37208849f, 0.20158440f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06999814f, 0.13352284f, 0.13308521f, -0.00322873f, 0.16656193f, -0.33367953f, 0.76947576f, 0.18590772f, 
    0.24903665f, 0.13694829f, 0.02230763f, 0.29377672f, 0.27049083f, 0.18505482f, 0.14493263f, -0.34210646f, 
    0.25151828f, 0.04455074f, -0.15990855f, -0.11093763f, 0.64239335f, 0.31645411f, 0.38094717f, 0.38109615f, 
    0.18690267f, 0.30132747f, 0.27741173f, 0.24306105f, -0.12482062f, 0.25182915f, 0.15118971f, 0.42168006f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.04858681f, -0.53144443f, 0.23879090f, -0.38490224f, -0.18066117f, -0.04813267f, 0.18194604f, -0.19599207f, 
    -1.03762257f, -0.47354692f, -0.85284328f, 0.04949788f, -0.56722599f, -0.02747241f, -0.37202376f, 0.17913392f, 
    0.38064212f, -0.71573383f, 0.16207717f, 0.25870141f, -0.39370936f, 0.03786966f, 0.06016068f, 0.31109369f, 
    -0.41570562f, -0.76494074f, 0.32859400f, 0.22606391f, 0.36278185f, -0.17772676f, 0.04206386f, 0.51340497f, 
    0.10902647f, 0.11777212f, 0.18328097f, -0.33836094f, 0.09704564f, -0.22629736f, 0.33973619f, -0.28865790f, 
    -0.14562015f, -0.18920177f, -0.20169707f, 0.10287476f, 0.27189958f, 0.27923483f, 0.15675817f, -0.15336864f, 
    -0.03188918f, -0.05583140f, -0.34655693f, 0.14015560f, 0.26680315f, 0.12890220f, 0.20979384f, 0.17970729f, 
    0.12159587f, -0.02703451f, -0.88609242f, 0.00742560f, 0.02982145f, -0.22868937f, 0.25912005f, 0.29260004f, 
    0.11328458f, -1.02603900f, -0.80549532f, -0.11024522f, 0.11628424f, -0.64589161f, 0.10263912f, 0.34624925f, 
    0.49668729f, 0.30733868f, 0.31207195f, 0.25524530f, 0.00896992f, 0.09987243f, -0.93251270f, -0.16532494f, 
    -0.00762005f, 0.08135726f, 0.15399843f, -0.54345113f, -0.39300513f, -0.09269879f, -0.17521814f, 0.31712231f, 
    -0.29918158f, 0.29250452f, 0.24910556f, -0.36239174f, -0.08009806f, 0.02909770f, -0.63680089f, -0.21542767f, 
    -0.03097966f, -0.41485256f, 0.10577580f, -0.03835020f, -0.13340938f, 0.43352982f, -0.19575457f, -0.00926216f, 
    -0.14609818f, 0.20456988f, -0.29038563f, -1.57915866f, -0.33847076f, -1.03971589f, -0.36176476f, 0.22896336f, 
    0.20088868f, -0.24502485f, 0.40432855f, -0.13147706f, -1.27841663f, 0.08613174f, -0.01185089f, 0.19294643f, 
    -0.26066139f, 0.27021846f, 0.24259740f, -0.09899570f, -0.14083904f, 0.13983752f, 0.11347985f, -0.58520848f, 
    0.13045610f, -0.04895231f, 0.01465824f, 0.36013225f, -0.10434956f, 0.17437024f, -0.45660910f, -0.86822832f, 
    -0.05143965f, -0.33994439f, 0.33176118f, -0.19470257f, -0.63561445f, 0.03503024f, -1.06268620f, 0.06958701f, 
    0.17599690f, 0.37087810f, -0.04199856f, 0.24636590f, -0.30621833f, 0.21008779f, 0.10207599f, -0.08186234f, 
    -0.66066104f, -0.70741832f, -0.70958722f, 0.18254867f, -0.13174778f, 0.07969356f, 0.14425497f, -0.58376563f, 
    -0.13447532f, -0.14542083f, 0.15987298f, -0.24344572f, -0.05380363f, -0.13939013f, -0.13166703f, 0.22599164f, 
    0.05011615f, 0.06173307f, 0.02004681f, 0.20714441f, 0.09526791f, -0.13631117f, -0.09244045f, 0.08128425f, 
    0.21045958f, -0.32044959f, -0.77949649f, -0.13977146f, -0.18876579f, 0.14396775f, 0.11444275f, -0.27706629f, 
    -0.00164111f, 0.14804320f, -0.59907198f, 0.23110086f, 0.31232259f, -0.09034283f, 0.06888053f, -0.04603733f, 
    0.11095560f, -0.10680217f, -0.67837149f, 0.04167333f, -0.10066722f, -0.12137607f, -0.02119417f, 0.35027486f, 
    0.15908732f, 0.03242211f, 0.36920565f, 0.21310547f, -0.07997136f, -0.04330450f, 0.09452111f, -0.26841486f, 
    -0.80744040f, 0.09091379f, -1.08336639f, 0.01903772f, 0.45496267f, -1.54824317f, -1.02919090f, -0.77753961f, 
    -0.34852871f, 0.32812473f, 0.40985119f, -0.63568032f, 0.25980592f, 0.31431699f, -1.03977609f, 0.49986142f, 
    0.07630336f, 0.26595187f, 0.06381620f, 0.37182823f, -0.02542347f, 0.39187437f, -0.68032718f, -0.95822310f, 
    -0.72785044f, -0.78513837f, 0.24811411f, -0.05135361f, -0.34470341f, -0.02749926f, 0.53084111f, -0.49786606f, 
    -0.49908921f, 0.11563794f, -0.25859287f, 0.35564521f, -0.66413283f, -0.42445505f, -0.37883827f, -0.80095726f, 
    -0.25441167f, 0.00686228f, 0.29196560f, 0.04820020f, -0.23071605f, 0.03861234f, 0.16255811f, 0.30074936f, 
    0.04446637f, 0.30296683f, -0.08108217f, -0.29494050f, 0.11461911f, 0.17977452f, -0.44573012f, -0.01454372f, 
    0.04124910f, 0.27240577f, -0.25094798f, -0.24147613f, 0.37774011f, -0.17187519f, -0.08967360f, -0.01501215f, 
    -0.47979778f, 0.13843673f, -0.31369513f, -0.36686906f, -0.12464964f, 0.23231393f, -0.01177333f, -0.82105619f, 
    0.45058846f, 0.16686380f, -0.53048342f, -0.12724274f, 0.12348762f, -0.42493808f, 0.26104072f, -0.59820819f, 
    0.01575398f, -0.13681845f, -0.14518215f, 0.28376883f, 0.12352869f, -0.08564086f, 0.36089325f, -0.07843814f, 
    -0.30205086f, -0.03652117f, -0.16929880f, -0.21854791f, -0.78326434f, -0.32244134f, 0.11910533f, -0.17580433f, 
    0.04191175f, 0.02452788f, -0.66535258f, 0.17249298f, 0.39666516f, -0.17105626f, 0.35455680f, 0.30391079f, 
    -0.69749880f, -0.29011288f, 0.07837217f, -0.14035513f, -0.36219236f, 0.46321532f, -0.48258513f, 0.28190821f, 
    0.12074448f, -0.57090670f, 0.24669042f, -0.40432423f, -0.13057955f, -0.19109370f, 0.31976950f, 0.06515300f, 
    0.13205919f, -0.90727681f, 0.24972193f, -0.76365852f, 0.31714955f, -0.66707861f, -0.43928307f, 0.05581577f, 
    -1.08916140f, 0.33733574f, -0.47839957f, 0.15774165f, -0.50996268f, 0.00897392f, 0.32414287f, -0.01413024f, 
    0.41296738f, -0.05611371f, -0.02087948f, -0.87006032f, 0.11672711f, -0.54503536f, 0.25642577f, -0.30514103f, 
    0.13320141f, 0.39610967f, -0.84682578f, -0.03929724f, 0.03130988f, -0.00487001f, -0.15450640f, 0.14585568f, 
    0.29237249f, 0.17599683f, 0.32553905f, -0.88623160f, 0.06767704f, -0.32042098f, -0.22450586f, 0.16025519f, 
    0.22537601f, 0.23807968f, -0.91381520f, -0.51477772f, -0.10980161f, -0.12489706f, -0.21720950f, -0.33588305f, 
    0.53868312f, 0.10732947f, -0.24389160f, -0.20588021f, -1.09281552f, 0.06798214f, -0.41725069f, -0.05257712f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.13896784f, 0.50631005f, 0.16861451f, -0.09620227f, -0.06100623f, -0.04344808f, -0.13144548f, -0.28115830f, 
    -0.10328227f, 0.12310062f, -0.12508264f, -0.30333620f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
