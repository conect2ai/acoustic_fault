#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.71251452f, -0.47116596f, -0.27408698f, -0.29310656f, -0.46083736f, 0.26642087f, -0.50505298f, -0.12554660f, 
    -0.35423514f, -0.16438273f, -0.28734493f, -0.23429295f, 0.10816636f, -0.23721212f, -0.13183124f, 0.22486126f, 
    -0.25497890f, 0.06583736f, 0.21318230f, 0.02909527f, 0.06200108f, 0.36398569f, 0.07029022f, -0.02457326f, 
    0.52312928f, -0.58680332f, -0.79472792f, 0.03371934f, 0.57469672f, 0.40110981f, 0.15838274f, 0.56199545f, 
    0.42660373f, -0.31067914f, -0.49259317f, 0.19078629f, -0.13082340f, -0.21928781f, 0.05785750f, -0.04757834f, 
    -0.13228078f, 0.13971142f, -0.23776713f, -0.22159584f, 0.34747529f, 0.04368531f, -0.17343532f, 0.03851191f, 
    0.17635497f, 0.04806334f, 0.11862709f, 0.05806565f, -0.34608513f, -0.48996842f, -0.62804478f, 0.55571711f, 
    0.42746261f, -0.30550143f, -0.43876645f, 0.55288166f, -0.07501562f, 0.30899909f, -0.38340962f, 0.03098978f, 
    0.37443659f, -0.40219179f, 0.17052835f, 0.00960506f, -0.20355366f, -0.37895694f, -0.13602033f, -0.08039055f, 
    0.18091294f, 0.25383767f, 0.29431826f, 1.08729303f, -0.48709691f, -0.72585011f, -0.27734789f, -0.56034023f, 
    0.26134807f, 0.25694343f, 0.53796297f, -0.35393128f, -0.20033358f, -0.14731187f, 0.65146095f, -0.39033115f, 
    -0.42354870f, 0.11160798f, 0.08894189f, -0.23049349f, 0.01750213f, -0.00208523f, -0.08878700f, 0.43127698f, 
    -0.12215946f, -0.13516489f, -0.14270465f, 0.01413276f, -0.19622569f, -0.25483289f, 0.16085523f, 0.37340644f, 
    0.26080266f, -0.55667871f, -0.53558040f, -0.32763350f, -0.21479101f, 0.23272620f, 0.26296067f, 0.03205907f, 
    -0.14101854f, 0.15375394f, 0.08364656f, -0.02785850f, -0.09120123f, -0.11406098f, -0.02753169f, 0.16170272f, 
    -0.26657212f, 0.07131777f, 0.17013109f, 0.40536633f, 0.10700132f, -0.58781159f, -0.17971732f, -0.33415255f, 
    0.41739953f, 0.60321808f, 0.80197376f, -0.10352425f, -0.56527752f, -0.38830113f, 0.56793702f, -0.13068876f, 
    -0.02724843f, -0.38925615f, -0.23638444f, 0.30767027f, 0.03575063f, -0.03074603f, 0.46645918f, -0.01094189f, 
    -0.21107718f, 0.28373948f, -0.27899122f, -0.40599266f, -0.09165831f, 0.13570158f, 0.09377255f, -0.63245535f, 
    -0.09495457f, 0.72490203f, -0.92332625f, -0.07151492f, 0.27312782f, -0.51821429f, -0.76495606f, -0.58626384f, 
    -0.07998186f, -0.19149667f, -0.34221122f, -0.30555311f, -0.29589146f, -0.39349654f, -0.02935158f, 0.19153088f, 
    0.01912839f, 0.13249089f, -0.11916421f, -0.05590336f, -0.01648239f, 0.20095675f, -0.26173878f, -0.18681936f, 
    0.38958406f, 0.09076778f, -0.20397910f, 0.40059024f, 0.35656771f, 0.21579978f, -0.31007019f, -0.21390501f, 
    -0.37420961f, -0.32009548f, -0.13560589f, 0.18311957f, 0.05206106f, 0.01926529f, -0.10512301f, -0.26969454f, 
    0.00799989f, -0.06469710f, -0.19765884f, 0.11576020f, -0.43824929f, -0.31837660f, -0.47102457f, -0.47600484f, 
    0.05016656f, -0.64209300f, -0.57389170f, -0.42022565f, -0.75259441f, 0.51034611f, 0.56633389f, 0.35486174f, 
    -0.00333443f, 0.47959423f, -0.00531086f, 0.41815606f, 0.05413134f, 0.06698433f, -0.23717584f, -0.20655338f, 
    -0.00660112f, 0.08786681f, 0.01288824f, -0.08013242f, 0.16528441f, -0.26586321f, -0.15350406f, 0.25347030f, 
    -0.20589969f, -0.81614429f, -0.28511116f, 0.28972897f, 0.16622923f, -0.14166790f, -0.51828295f, 0.14997296f, 
    0.51076323f, 0.23463608f, -0.48217160f, 0.10714677f, 0.11241400f, 0.27812526f, 0.01672735f, -0.30913332f, 
    0.01801296f, -0.41206765f, 0.12892628f, 0.11624164f, 0.31114125f, -0.07203658f, -0.04930160f, -0.21117947f, 
    -0.28290737f, 0.36012718f, -0.32415506f, -0.82173878f, 0.51428998f, 0.76354903f, 0.53188640f, 0.59609675f, 
    -0.28211722f, -0.45964816f, -0.35860667f, -0.29357022f, -0.02847208f, 0.09568972f, -0.26236925f, 0.02569451f, 
    -0.03551996f, -0.32046494f, -0.21310888f, 0.00365822f, 0.04367203f, 0.38594308f, 0.09915671f, 0.10334320f, 
    -0.01935404f, 0.00573409f, -0.09369214f, -0.63949043f, -0.46940848f, -0.07634487f, 0.26650766f, 0.04139640f, 
    0.31623879f, 0.11782447f, 0.08124826f, 0.16453458f, 0.38140723f, 0.04608020f, -0.24803874f, 0.16496889f, 
    0.22457780f, -0.30159739f, -0.17641032f, -0.16229306f, -0.21382426f, -0.07392307f, -0.20887938f, -0.33358470f, 
    -0.23679398f, -0.28845704f, -0.19649407f, -0.31371519f, -0.64866161f, -0.53879029f, -0.42272910f, -0.30973995f, 
    -0.13949774f, 0.24621211f, 0.15404637f, 0.46757522f, -0.12320559f, 0.23110244f, 0.11961761f, 0.33420125f, 
    0.27005839f, -0.10904149f, 0.03744818f, 0.05448102f, -0.09412381f, -0.32468817f, -0.32265353f, 0.35150331f, 
    -0.17658448f, -0.03259152f, 0.24829064f, 0.18077327f, 0.29649186f, -0.40236381f, -0.51179320f, -0.08308317f, 
    -0.16166039f, -0.52859414f, 0.32611451f, -0.04122066f, 0.28822738f, 0.00076195f, -0.32646137f, 0.01519661f, 
    0.15976353f, 0.15416707f, 0.39169896f, 0.26117036f, 0.31776562f, 0.20212556f, -0.15282394f, -0.20680611f, 
    0.06607474f, 0.23281592f, -0.36615553f, 0.28525963f, -0.22914062f, -0.29023665f, -0.98983598f, -0.69983339f, 
    0.63236439f, -0.03756404f, 0.70302069f, -0.09946748f, -0.63939333f, -0.42991588f, 0.50041521f, 0.42972353f, 
    -0.04249919f, 0.23832342f, 0.11385187f, 0.16091533f, -0.13661094f, -0.04005178f, 0.13964641f, -0.24354617f, 
    0.08277693f, 0.08947535f, 0.04792782f, -0.01711753f, 0.12513119f, -0.02462694f, -0.11283160f, 0.54302680f, 
    0.35268140f, 0.51675200f, -0.11548029f, 0.57554287f, -0.44180882f, 0.03501686f, -0.22064759f, -0.02883060f, 
    -0.29961348f, -0.24286763f, 0.16597027f, -0.07373621f, -0.11633690f, 0.10563649f, -0.00469406f, 0.24483778f, 
    -0.30911264f, -0.25955644f, 0.00502510f, 0.06935039f, 0.02434211f, 0.20137540f, -0.02137661f, 0.05037891f, 
    -0.67747062f, -0.21649420f, -0.20127642f, -0.50790828f, 0.39243293f, -0.21344122f, 0.20716392f, 0.20202218f, 
    0.39004591f, 0.37028921f, 0.04300328f, -0.14289622f, -0.17953914f, -0.29488689f, -0.13374090f, -0.29537666f, 
    -0.22699273f, 0.14895898f, -0.32917494f, -0.50496101f, 0.09671696f, 0.07021651f, 0.20854594f, -0.08332170f, 
    0.23170529f, -1.08534598f, 0.71153486f, -0.03077497f, -0.80003011f, -0.09605038f, -0.02117370f, -0.15498164f, 
    0.09755683f, -0.44255650f, -0.35631421f, -0.12158542f, 0.17612548f, -0.20874245f, -0.48706707f, 0.46895403f, 
    -0.14444198f, -0.33942947f, -0.42302102f, -0.24553031f, -0.13939248f, 0.07372852f, 0.31865689f, -0.06453975f, 
    -0.07487167f, -0.23955452f, 0.67782366f, 0.14039773f, -0.28624061f, -0.52063292f, -0.15701200f, 0.69286972f, 
    -0.48164225f, 0.45704857f, -0.61304623f, -0.48766023f, -0.22567524f, 0.20334101f, 0.16175419f, -0.09457101f, 
    -0.24465039f, 0.17603354f, 0.25855356f, 0.40508389f, -0.23313017f, -0.19003503f, -0.24561694f, -0.05600533f, 
    -0.09615304f, 0.20383316f, 0.11641845f, -0.12002729f, -0.37887412f, -0.17449526f, -0.04951451f, -0.24575402f, 
    -0.45758802f, -0.28901041f, -0.47867125f, -0.42286345f, -0.43839511f, 0.27167827f, 0.36719188f, 0.30871800f, 
    -0.16523239f, -0.17898712f, 0.23613395f, -0.07654539f, -0.06343818f, -0.16409048f, 0.00292024f, -0.20842165f, 
    0.13787347f, -0.33267537f, -0.04293383f, -0.30392841f, 0.52662653f, 0.30630311f, -0.11639675f, -0.24491259f, 
    -0.02759060f, -0.11699124f, -0.26409456f, 0.12064477f, -0.02148468f, 0.11783497f, 0.30711114f, -0.36520985f, 
    0.20275980f, 0.03155968f, 0.33257630f, 0.39506394f, 0.30801421f, -0.16219333f, -0.25747585f, 0.31260428f, 
    -0.05432112f, 0.12670216f, 0.09677045f, 0.15934472f, 0.20273140f, 0.20248674f, 0.22600955f, 0.30344093f, 
    0.40159455f, 0.29302153f, 0.34488374f, 0.39757481f, -0.10051434f, -0.26615348f, -0.28686681f, 0.34711990f, 
    0.20423064f, 0.22586040f, -0.21355233f, 0.12634894f, -0.01726171f, 0.12239137f, -0.07259525f, -0.19191271f, 
    0.22110835f, 0.18848202f, -0.15140589f, -0.12059391f, -0.06169047f, 0.00961008f, 0.42454812f, 0.19750549f, 
    0.14597899f, 0.42465815f, -0.42551535f, -0.40513289f, -0.60745019f, -0.34945741f, 0.29845861f, 0.07719914f, 
    0.11630563f, -0.24368192f, -0.12013125f, 0.12600702f, 0.19517675f, -0.10755520f, 0.35552832f, -0.03127109f, 
    0.03454901f, -0.34452581f, -0.37562340f, -0.30531874f, -0.29645187f, -0.53604913f, -0.53447169f, -0.16652112f, 
    -0.19668387f, -0.01649615f, 0.56496972f, -0.31953964f, 0.12588353f, 0.04765911f, -0.04515089f, -0.24056336f, 
    0.44612452f, 0.28332686f, -0.32389432f, -0.06338521f, 0.01926522f, 0.15151156f, -0.14007607f, 0.05539474f, 
    -0.22743486f, -0.02753443f, -0.08171344f, -0.07137644f, 0.35890487f, 0.20810720f, 0.02359487f, 0.35245684f, 
    -0.42617381f, 0.18270217f, 0.11538479f, -0.04635547f, 0.19402339f, 0.17126174f, 0.15719658f, 0.00513857f, 
    0.30816865f, 0.41170126f, 0.21307161f, 0.20591128f, -0.06232353f, -0.12393603f, 0.17328417f, -0.12231845f, 
    0.16265275f, 0.17935868f, -0.22619633f, -0.13115461f, 0.35282424f, 0.47067672f, -0.12855513f, 0.23906584f, 
    -0.20390187f, -0.56919622f, -0.45829755f, -0.59517998f, -0.34074113f, 0.31453806f, 0.08485640f, -0.14268032f, 
    -0.53802818f, -0.28132442f, 0.19754308f, -0.39098448f, 0.18280034f, -0.32493502f, -0.16682908f, -0.57237828f, 
    0.33110520f, 0.06323051f, -0.22159150f, 0.34444687f, -0.07621820f, -0.04828878f, -0.48579621f, -0.09364616f, 
    -0.15063436f, -0.21674401f, 0.54636228f, 0.58939749f, 0.31276307f, -0.05118827f, -0.27006105f, -0.38766450f, 
    -0.08334943f, -0.16325508f, 0.13874690f, -0.29723611f, -0.04729543f, -0.23077874f, 0.00130480f, -0.27730492f, 
    -0.15918297f, 0.28736159f, 0.26540428f, 0.23065752f, -0.04334695f, -0.04994786f, -0.06344981f, 0.05173837f, 
    -0.09328546f, -0.11417483f, -0.19690633f, -0.56194890f, -0.62549227f, -0.33921704f, -0.09175366f, -0.02109694f, 
    0.15930398f, -0.22941689f, -0.56660849f, -0.58417875f, -0.21839672f, 0.35869542f, 0.37967733f, 0.11649360f, 
    0.20127432f, 0.48839515f, -0.16588533f, -0.00131979f, -0.12691595f, -0.30922398f, 0.03730411f, 0.01196814f, 
    -0.12892900f, 0.12389829f, 0.11385538f, -0.26229611f, -0.30399227f, -0.78752649f, -0.67053711f, 0.00866556f, 
    -0.04846444f, -0.10755861f, -0.21001036f, 0.17130466f, 0.49697399f, 0.15215003f, -0.02117003f, -0.08659361f, 
    -0.03792425f, 0.29706785f, -0.00292092f, 0.12027340f, 0.01048777f, -0.01340212f, -0.22391856f, -0.41373309f, 
    -0.36402747f, 0.07619353f, -0.01045494f, -0.09776329f, 0.01504577f, -0.98743474f, -0.06406788f, -0.03856458f, 
    -0.54981238f, 0.07903684f, 0.07893186f, 0.35889766f, -0.09304903f, 0.40347934f, 0.37701163f, -0.37947613f, 
    -0.26703122f, -0.38651088f, 0.29063529f, 0.33274794f, -0.05372437f, 0.05815034f, -0.04045678f, 0.29964384f, 
    -0.00449634f, -0.19002075f, 0.15461090f, -0.12883663f, -0.34895742f, -0.21883060f, 0.53471601f, 0.39719588f, 
    0.31959164f, 0.28301513f, -0.17863746f, -0.10957891f, 0.28013426f, 0.08546245f, 0.18670951f, 0.21638134f, 
    0.24485138f, 0.00394184f, -0.18160032f, -0.25866196f, 0.11215340f, -0.12260530f, 0.17270949f, 0.18128236f, 
    -0.06782041f, 0.14914627f, -0.14021876f, -0.19885932f, -0.22871052f, -0.24178725f, -0.30894929f, -0.04879573f, 
    0.24316892f, 0.29349408f, 0.28894150f, -0.30715823f, 0.08514406f, 0.13970050f, 0.43927601f, -0.12707138f, 
    0.23636751f, -0.13508737f, 0.13868077f, 0.34386116f, -0.56809795f, -0.15353243f, -0.16827193f, 0.17167056f, 
    -0.42604652f, -0.11525308f, -0.13881701f, 0.11911129f, 0.14982592f, -0.03013283f, 0.18446863f, 0.41196319f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08946883f, 0.32633230f, 0.27597052f, 0.25969294f, 0.22966009f, 0.38803831f, 0.14334305f, -0.10019979f, 
    0.18810071f, 0.41723022f, 0.35598698f, -0.05378338f, 0.23500699f, 0.11761340f, 0.10270394f, 0.24252062f, 
    0.15432958f, 0.22437602f, 0.31077233f, 0.09184188f, 0.16993827f, -0.02682441f, -0.02115707f, 0.24035724f, 
    -0.12274135f, -0.01814367f, 0.17101966f, 0.06421481f, 0.12717119f, -0.02023321f, 0.09273833f, 0.22074495f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05871493f, -0.10855380f, -0.03585176f, 0.10299257f, 0.10534269f, -0.06814820f, -0.07171591f, 0.06561448f, 
    -0.05822160f, 0.02995102f, -0.05733458f, 0.03730922f, -0.01845615f, 0.48136923f, -0.21061078f, -0.37951800f, 
    0.06113270f, 0.00478878f, 0.01097525f, 0.13894747f, -0.05352682f, 0.02298356f, 0.05218183f, 0.06251369f, 
    0.04328491f, -0.29691499f, 0.20781937f, 0.20077731f, 0.07892367f, 0.00665565f, 0.11802068f, 0.09490077f, 
    0.13827108f, 0.09467959f, 0.05371548f, 0.04802103f, -0.08916411f, 0.13248828f, -0.17829575f, 0.19224130f, 
    -0.03737963f, 0.03118636f, 0.15240245f, -0.02083897f, -0.01240315f, -0.02588923f, 0.17173196f, 0.00684607f, 
    0.02226567f, -0.06224257f, -0.17918533f, 0.11276893f, 0.02152994f, -0.00416175f, 0.06577376f, -0.02822432f, 
    -0.00946098f, -0.02592558f, 0.00046607f, 0.00625358f, 0.21091186f, 0.18725319f, 0.02146216f, -0.19126761f, 
    0.18818472f, -0.01255610f, 0.02044692f, -0.08203233f, -0.02694684f, 0.07318182f, 0.00685363f, 0.02536832f, 
    -0.13035107f, -0.11687292f, -0.03764940f, 0.28330699f, 0.02635121f, -0.04642508f, 0.00509427f, -0.05959749f, 
    0.02092215f, -0.06537128f, 0.01327432f, 0.15070851f, -0.01008705f, 0.05865924f, 0.09483913f, 0.11462672f, 
    -0.11927855f, 0.10082781f, 0.04283011f, -0.09318511f, -0.14672419f, -0.06481020f, 0.04707162f, -0.03076570f, 
    -0.07296977f, -0.21167322f, 0.01074812f, 0.22713447f, 0.02763157f, 0.05433548f, 0.08617613f, -0.03981174f, 
    -0.00516283f, 0.10928632f, 0.02978368f, 0.09038598f, 0.02164608f, 0.05885250f, -0.07498433f, -0.20839226f, 
    -0.04601137f, -0.08058735f, 0.00176715f, -0.12438551f, -0.05348477f, -0.01667952f, 0.00870561f, -0.02574850f, 
    -0.20976698f, 0.34022731f, -0.15783267f, 0.09262533f, -0.06295790f, 0.02111157f, -0.04993739f, 0.04475108f, 
    0.01314192f, 0.07336732f, 0.10962721f, -0.02816971f, 0.08534801f, 0.08503231f, 0.12922141f, -0.29594532f, 
    0.01409226f, 0.02373544f, -0.02539277f, -0.02454073f, -0.06174679f, -0.04304300f, 0.05312382f, -0.14358482f, 
    0.00767783f, 0.00500298f, -0.15839438f, 0.01974578f, 0.05153567f, 0.01435086f, 0.13663487f, 0.13969831f, 
    0.03166066f, 0.08479900f, -0.00116294f, 0.02231660f, -0.13252644f, 0.02664168f, 0.01032126f, 0.02959199f, 
    0.08412705f, 0.15667900f, 0.09256045f, 0.05880407f, -0.06460115f, 0.01883563f, -0.04262887f, -0.04397160f, 
    0.24986967f, 0.02751288f, -0.22252701f, -0.44062394f, 0.09191440f, 0.08405492f, -0.17519358f, 0.21950339f, 
    0.01303929f, -0.00825369f, -0.05782368f, 0.05226706f, -0.21826048f, -0.07805554f, 0.13252094f, -0.02512322f, 
    -0.12716720f, -0.14354032f, -0.06683450f, -0.09011030f, -0.03905821f, 0.11091587f, -0.08850776f, 0.02532162f, 
    0.29326090f, 0.04055590f, -0.02495897f, -0.05654989f, 0.11846685f, 0.00570087f, 0.06496935f, 0.13956879f, 
    0.09177165f, 0.20487690f, -0.02402844f, 0.10137608f, 0.21200867f, -0.09605590f, -0.07196468f, 0.07406424f, 
    0.13193178f, -0.03182713f, -0.00058554f, 0.08140869f, -0.13259880f, -0.01880526f, -0.02481501f, 0.05208305f, 
    -0.05860260f, -0.01871579f, 0.10854049f, 0.09591020f, 0.13557956f, -0.06715958f, 0.04315099f, -0.01789043f, 
    0.15732463f, 0.01256297f, -0.08677504f, 0.12281545f, -0.09864670f, -0.08268412f, -0.12186387f, 0.06382596f, 
    0.06159343f, -0.02092935f, 0.05025689f, 0.00568405f, 0.00767422f, 0.00308153f, -0.05457870f, -0.00977392f, 
    -0.09816308f, 0.05533078f, -0.11323808f, -0.04173613f, -0.02973116f, -0.12574525f, 0.01783058f, -0.08419973f, 
    0.15074769f, -0.05986792f, 0.06664077f, 0.00019757f, -0.10186065f, -0.06344570f, 0.07546026f, 0.07857479f, 
    -0.13443354f, -0.12816739f, -0.01891586f, -0.06475079f, 0.04307376f, -0.02769559f, 0.05028269f, 0.04475420f, 
    -0.06161122f, -0.11372243f, 0.07717627f, -0.09312786f, -0.11919951f, 0.08805054f, -0.06787413f, 0.05721768f, 
    0.03012616f, 0.09692363f, 0.00927406f, -0.08641981f, 0.06056559f, -0.22082548f, 0.04467408f, -0.05846143f, 
    -0.03384548f, -0.01275672f, -0.04348296f, -0.02149284f, 0.09434816f, 0.17279235f, 0.22178777f, 0.07253551f, 
    0.11448541f, -0.15815701f, -0.01885785f, -0.16779037f, 0.01122860f, -0.05164884f, -0.03883628f, -0.00452024f, 
    -0.03869621f, -0.05461958f, 0.04402743f, 0.19362724f, 0.11591353f, -0.05072076f, -0.16565344f, 0.03112236f, 
    0.05784471f, 0.02931501f, 0.11047035f, 0.06078881f, 0.00447396f, 0.03012411f, 0.04964992f, 0.08604258f, 
    -0.14067101f, -0.08323210f, 0.11066449f, -0.00643488f, -0.08072706f, -0.00533313f, 0.04083943f, 0.00651868f, 
    -0.05502024f, 0.09710123f, -0.06424281f, 0.15272370f, -0.17926678f, -0.17240089f, -0.03274313f, -0.04075710f, 
    0.08153153f, 0.22516796f, 0.18180703f, 0.11068546f, -0.01768140f, 0.01885129f, 0.06886215f, -0.03658758f, 
    -0.09477659f, -0.07448898f, -0.12911379f, -0.09015284f, 0.03243218f, 0.00014941f, 0.03162807f, 0.05300742f, 
    -0.03096583f, 0.08908879f, -0.01518425f, 0.00120014f, 0.53193283f, -0.00638985f, -0.00778286f, -0.07036702f, 
    0.15577427f, 0.10265367f, 0.08113946f, 0.01142869f, -0.16784868f, -0.04397710f, 0.02951484f, 0.02923545f, 
    0.08026335f, 0.04194562f, -0.00504160f, -0.01169992f, -0.04677949f, -0.03580749f, -0.09404259f, 0.00803855f, 
    0.02728106f, 0.04774644f, -0.03724762f, -0.08786751f, 0.16400816f, 0.07563624f, -0.04641152f, 0.01955895f, 
    -0.08074930f, -0.11226559f, 0.00441747f, -0.03122123f, 0.06624427f, 0.05644749f, -0.10232517f, 0.10865363f, 
    -0.17744659f, -0.17389247f, -0.00239176f, 0.01725642f, -0.05333630f, -0.14946650f, -0.12026000f, -0.02352617f, 
    -0.09787498f, -0.07296417f, -0.07750417f, -0.11095421f, -0.00779564f, 0.15668814f, 0.02197883f, -0.07571092f, 
    -0.02062880f, -0.04822699f, -0.03291735f, 0.08505964f, -0.10695551f, 0.03573093f, -0.10405490f, -0.01229839f, 
    -0.02123966f, 0.18780175f, 0.06328770f, 0.12483191f, -0.04810490f, -0.02135670f, -0.14879784f, -0.16732225f, 
    -0.05663548f, 0.04224298f, -0.01614285f, 0.07191069f, -0.24287623f, 0.15503867f, 0.16484363f, 0.05793396f, 
    -0.00685069f, -0.01787428f, 0.13900234f, -0.01462539f, 0.09280094f, -0.02569588f, -0.06421359f, 0.08684609f, 
    -0.06800669f, -0.10194188f, -0.03235061f, 0.24664304f, -0.13501686f, 0.02637847f, 0.00063211f, 0.06754322f, 
    -0.14252844f, -0.09683938f, -0.17956735f, -0.32309756f, 0.13771227f, -0.25948861f, 0.06946539f, 0.12805603f, 
    0.01771734f, -0.02781341f, -0.11440849f, 0.06290361f, -0.02489857f, 0.18438847f, 0.04206109f, -0.01005600f, 
    -0.29659277f, 0.03652033f, 0.13452950f, 0.09429331f, -0.13202037f, -0.01329404f, 0.14855647f, 0.04873033f, 
    -0.06544767f, 0.01620576f, -0.10436335f, -0.09596855f, 0.00694040f, -0.08207031f, 0.08371279f, 0.02317427f, 
    0.02230339f, -0.08519572f, -0.03329101f, 0.04452580f, 0.11171253f, 0.30892640f, 0.13038445f, 0.28962919f, 
    -0.02492110f, 0.41188753f, 0.32982716f, 0.22432660f, -0.03588461f, -0.10253549f, 0.16229548f, -0.16297406f, 
    -0.05506138f, -0.01301508f, -0.09371486f, 0.12573090f, 0.09341040f, 0.07358776f, -0.07752726f, 0.06518880f, 
    0.07625523f, -0.01813663f, -0.04040341f, 0.07898928f, 0.08289341f, 0.17145604f, 0.05852759f, -0.06592996f, 
    -0.11310391f, 0.09035387f, 0.08356635f, 0.10049036f, 0.08474778f, 0.06480075f, 0.01258895f, -0.03581855f, 
    -0.07338149f, 0.04556935f, 0.01117899f, 0.12683958f, 0.11116817f, 0.01062101f, -0.05730674f, 0.11695597f, 
    -0.05038904f, -0.07492869f, 0.00348753f, 0.06576119f, 0.10777513f, 0.16242275f, 0.23006010f, 0.25799152f, 
    0.24001434f, 0.14834239f, 0.18518399f, 0.15139544f, -0.10071378f, -0.12898195f, 0.00838558f, 0.00272224f, 
    0.02778192f, 0.10410724f, -0.09406198f, -0.12158744f, 0.10301632f, 0.03948292f, 0.16312940f, 0.17710622f, 
    -0.08123384f, -0.05651766f, 0.15011919f, -0.01483913f, 0.15373039f, 0.00561962f, -0.12210150f, 0.13954006f, 
    0.23577613f, -0.16736375f, -0.18568596f, 0.19272378f, -0.01966714f, 0.11261951f, -0.05068238f, -0.20459451f, 
    0.06804064f, -0.02858008f, 0.02664224f, 0.03016947f, 0.22472142f, 0.18648425f, 0.11539072f, 0.01392688f, 
    0.04393721f, 0.11227141f, -0.12623540f, -0.03911947f, -0.20010635f, -0.24051076f, -0.04601667f, -0.12000310f, 
    -0.00721677f, -0.07996709f, 0.07168085f, 0.11517343f, 0.04271809f, -0.05017949f, -0.07617478f, -0.08640577f, 
    -0.07049581f, 0.08916549f, 0.02878603f, -0.02351575f, 0.08784840f, -0.07644107f, -0.01810253f, 0.16260117f, 
    0.07256456f, -0.12161444f, -0.02607520f, -0.13879813f, 0.05781656f, 0.03783236f, 0.04099184f, 0.08814535f, 
    -0.24547887f, 0.25861764f, 0.23367357f, -0.03105727f, 0.03430786f, -0.03410684f, 0.04400194f, -0.07962252f, 
    -0.11675054f, -0.06755282f, -0.13147654f, -0.29836059f, -0.04414562f, -0.04327632f, 0.04880740f, 0.15365846f, 
    0.01681688f, -0.01750280f, 0.06238414f, 0.04556233f, 0.21360414f, 0.13480321f, 0.10027453f, 0.06793549f, 
    0.00321823f, -0.11139458f, 0.10782877f, -0.04289699f, 0.02546067f, 0.03118249f, 0.02334522f, -0.01206288f, 
    -0.12428769f, -0.14258547f, -0.15642862f, -0.38752365f, -0.09106149f, 0.02707233f, -0.09544247f, -0.20276390f, 
    0.12444123f, 0.06499647f, 0.00597318f, 0.13994922f, 0.04475717f, 0.06393123f, -0.07186076f, 0.02745405f, 
    0.11126206f, -0.01667379f, -0.06127430f, 0.17989497f, -0.05235850f, 0.07535880f, 0.04543626f, -0.13623275f, 
    0.25493568f, 0.17950144f, 0.06050574f, 0.41513628f, 0.09634420f, 0.03340767f, -0.04148581f, -0.06760149f, 
    -0.02727162f, -0.06853323f, -0.00246607f, -0.11471367f, -0.11467478f, -0.17680319f, -0.10183731f, -0.23986217f, 
    0.05365012f, -0.08823540f, -0.03530389f, -0.23568434f, 0.19492894f, -0.09842058f, 0.02041335f, -0.09481741f, 
    0.06185678f, -0.01431187f, -0.16449580f, -0.13343188f, -0.18978909f, -0.14205436f, 0.05917268f, 0.12495497f, 
    -0.07883125f, 0.01838085f, -0.04006201f, 0.10847230f, -0.00446548f, 0.07707085f, 0.13488406f, 0.10472394f, 
    0.03305893f, 0.20458235f, 0.22836165f, -0.00630788f, 0.04255306f, -0.07101896f, 0.10296072f, 0.04171279f, 
    0.25009519f, 0.13936949f, 0.12753093f, -0.10887871f, 0.05815002f, -0.09409599f, 0.08633692f, 0.12806451f, 
    -0.13346207f, -0.08182582f, -0.10671701f, 0.03524917f, 0.17528209f, -0.00188793f, -0.03732671f, 0.08543324f, 
    0.04274108f, 0.03642587f, 0.15941101f, 0.21982849f, -0.11188743f, 0.07886802f, 0.05677506f, 0.09135782f, 
    0.05262016f, 0.12237444f, 0.08416634f, 0.07850686f, 0.19235232f, -0.14311507f, -0.04768264f, 0.13114886f, 
    -0.00384609f, 0.03755612f, 0.04949316f, -0.11131290f, 0.02196669f, -0.08140715f, 0.14306767f, 0.28955519f, 
    -0.07787216f, -0.11075282f, -0.18952313f, -0.15848115f, -0.03568107f, 0.00138114f, 0.13529588f, -0.00620579f, 
    0.24210989f, 0.15344022f, 0.14103937f, 0.24108791f, -0.04270203f, 0.04755931f, -0.14988333f, -0.29200879f, 
    0.25010586f, 0.01579764f, -0.17410976f, -0.12207907f, -0.17629889f, 0.03777879f, -0.18021736f, -0.43142271f, 
    -0.00016057f, -0.00885769f, -0.01183529f, -0.05121338f, -0.00306287f, 0.02077349f, -0.05985677f, -0.04715955f, 
    -0.01287202f, 0.00070645f, -0.00608154f, -0.02500307f, 0.02382500f, -0.00105149f, -0.05311887f, 0.02923004f, 
    0.02759713f, -0.05847042f, 0.00645328f, 0.01911998f, -0.01776084f, 0.02398913f, 0.01078159f, 0.02859144f, 
    0.02050592f, -0.05008850f, -0.04355948f, -0.04122109f, -0.02424816f, 0.00046482f, -0.03085835f, -0.03095090f, 
    0.00216644f, 0.01103555f, 0.00019881f, -0.01728768f, 0.01020369f, -0.03931660f, -0.00205363f, -0.03255684f, 
    -0.00552314f, 0.00342456f, -0.00088362f, 0.01462427f, -0.03505454f, -0.01145123f, -0.06252095f, 0.02583235f, 
    -0.01625237f, 0.01925297f, -0.02529273f, -0.01124383f, 0.02113093f, 0.03306895f, -0.01440622f, -0.04036036f, 
    -0.03269505f, 0.03363460f, -0.00332689f, -0.04298335f, 0.00552675f, -0.04781332f, 0.03904630f, 0.03452139f, 
    -0.02057056f, -0.00711835f, -0.05254314f, 0.01222258f, -0.02020487f, -0.01003684f, -0.04067241f, 0.02774263f, 
    0.02334659f, -0.01029404f, 0.02689018f, -0.00534433f, -0.01358588f, -0.00954927f, 0.01236167f, -0.05321833f, 
    -0.01089942f, 0.02610991f, 0.00122638f, -0.03581451f, -0.04925166f, 0.00899596f, -0.00097313f, 0.03898248f, 
    0.02945046f, -0.04330969f, 0.01594561f, 0.00997006f, -0.01107250f, 0.00180991f, -0.01715324f, -0.02316045f, 
    -0.02714449f, -0.04083505f, -0.00062786f, 0.03697186f, 0.00673701f, 0.02440691f, -0.02911727f, 0.01366712f, 
    0.00990088f, -0.00774476f, 0.00643610f, -0.04956164f, 0.03281593f, 0.01143429f, -0.04780472f, 0.03875532f, 
    0.03311981f, -0.05042031f, 0.03237352f, -0.01372543f, -0.04129153f, -0.03339338f, 0.00446459f, 0.04053575f, 
    -0.01898195f, 0.02069129f, 0.03507996f, -0.03412021f, 0.01499599f, -0.03340948f, -0.05198393f, -0.05416052f, 
    0.00577491f, -0.01017460f, -0.03529918f, 0.01727438f, 0.00574541f, -0.00116637f, -0.02347516f, -0.01614038f, 
    -0.01990656f, 0.00938517f, 0.00607686f, -0.00647134f, -0.00284834f, -0.00113826f, -0.00080708f, 0.03315571f, 
    -0.03920008f, -0.05466460f, -0.00696610f, 0.01140690f, 0.01656901f, 0.00391644f, 0.01157805f, -0.01487976f, 
    -0.01130490f, -0.00691364f, -0.02222318f, 0.02206914f, 0.02771547f, 0.00669361f, -0.02788660f, 0.01464741f, 
    0.03990792f, 0.01222813f, 0.01892179f, -0.01874371f, -0.03508982f, -0.02885110f, 0.00061183f, -0.01460147f, 
    0.04015251f, 0.02511160f, -0.01561554f, 0.04812269f, -0.03599958f, 0.00689597f, -0.02236816f, -0.05522028f, 
    0.01861869f, -0.03203962f, 0.04068539f, 0.01485035f, -0.01683982f, 0.00809319f, 0.03243326f, 0.00711266f, 
    0.03384152f, -0.01852643f, -0.01628418f, -0.01464870f, 0.00912224f, -0.02446035f, -0.05358923f, -0.00317094f, 
    0.00434486f, 0.02950310f, 0.03483113f, -0.03887157f, -0.04320223f, 0.02195476f, -0.05593773f, -0.00734698f, 
    0.02044963f, -0.00712971f, 0.01759472f, -0.03513411f, 0.00233609f, -0.02686282f, 0.02924822f, 0.00816908f, 
    -0.04512700f, -0.06129457f, -0.05133486f, 0.02657511f, -0.01021217f, 0.03279490f, 0.00406522f, 0.02500894f, 
    0.03014904f, 0.01216422f, -0.03709314f, 0.03761799f, 0.00570913f, -0.02607800f, 0.04117767f, -0.02879404f, 
    -0.03742738f, -0.01653348f, -0.01236276f, -0.05347360f, 0.03025089f, 0.00655887f, -0.05133678f, -0.02284627f, 
    -0.01670634f, -0.05322635f, -0.03130063f, 0.01745058f, 0.03845681f, -0.04088062f, -0.01072950f, 0.03433364f, 
    -0.05065180f, -0.02346479f, 0.03634147f, 0.02737882f, -0.02983129f, -0.00962735f, -0.02414841f, 0.02352160f, 
    -0.03719924f, 0.00017051f, -0.02190475f, -0.00156310f, 0.00324093f, -0.03694814f, 0.01793365f, 0.01937309f, 
    0.01882614f, -0.01058440f, -0.03836526f, 0.03617974f, 0.00539402f, -0.04329747f, -0.02428750f, -0.02421327f, 
    0.01290646f, -0.00104523f, -0.05465768f, -0.01971462f, -0.00735255f, 0.04316920f, -0.03074998f, -0.02319562f, 
    -0.02804400f, 0.00912853f, 0.02999106f, 0.03366273f, 0.02689788f, -0.00129242f, -0.00267299f, 0.03628168f, 
    0.01755776f, 0.02283250f, 0.03345307f, -0.02630065f, 0.02506758f, -0.04401224f, -0.05449210f, 0.00115188f, 
    -0.02909042f, -0.02596337f, -0.04202886f, 0.00160560f, 0.00720034f, 0.04266956f, -0.01463886f, 0.03566678f, 
    0.03727910f, 0.02172035f, -0.05551589f, -0.04362100f, 0.03369280f, 0.02116059f, -0.00900870f, 0.00502098f, 
    0.00088377f, 0.03416226f, 0.02971700f, 0.00135532f, -0.04934591f, -0.03512820f, 0.00796670f, -0.00715461f, 
    -0.02814972f, -0.04261846f, -0.03410227f, 0.01548905f, 0.00302202f, -0.02174042f, 0.01787288f, 0.02222262f, 
    -0.00412862f, -0.01476907f, -0.00490647f, -0.02515053f, 0.04334601f, 0.00177582f, -0.00915315f, -0.00200323f, 
    0.00165075f, -0.01618908f, -0.01397808f, 0.03331142f, -0.04377045f, -0.03900852f, -0.02063686f, 0.04757240f, 
    0.02898812f, 0.03044835f, 0.02241360f, 0.03285291f, 0.01648192f, -0.05365387f, -0.01460687f, -0.01731700f, 
    -0.02723502f, 0.00753224f, -0.03690721f, -0.01227187f, 0.01542883f, -0.04057290f, 0.03923922f, 0.05057947f, 
    0.04485967f, -0.01608346f, -0.00518486f, -0.03455157f, 0.04159550f, -0.02858103f, 0.00130172f, 0.02532342f, 
    -0.04894347f, -0.00455743f, -0.05097095f, 0.04780482f, 0.01717829f, 0.03688524f, 0.03843753f, 0.00796329f, 
    -0.02649850f, 0.01341012f, -0.05369901f, -0.03199742f, -0.04254461f, -0.04841169f, 0.01733222f, -0.01564683f, 
    -0.01429737f, 0.01688758f, 0.01206426f, 0.01417855f, 0.04019802f, -0.03694667f, -0.05354819f, 0.02784928f, 
    0.03939050f, 0.05376746f, 0.06258043f, 0.03504178f, 0.04704602f, 0.09953919f, 0.12661827f, -0.07681067f, 
    -0.04569277f, 0.03814310f, 0.02922723f, -0.02118373f, 0.15962818f, -0.28524646f, 0.24020183f, 0.12531403f, 
    0.01094053f, -0.16298497f, 0.03460035f, -0.02062548f, 0.15939417f, 0.12750021f, -0.02238194f, 0.06808434f, 
    0.12523653f, 0.24168774f, 0.05441630f, 0.05056793f, 0.10855986f, 0.07072575f, -0.02488598f, 0.19929332f, 
    0.17937706f, 0.08860134f, 0.03042404f, 0.01551899f, 0.25216803f, -0.01508030f, 0.07753253f, -0.02211442f, 
    0.13587567f, 0.17895398f, -0.13999712f, 0.13648152f, 0.08175523f, 0.01141551f, 0.02285468f, 0.09655568f, 
    -0.08792191f, 0.13638775f, -0.05914136f, -0.25016844f, -0.01178193f, 0.10531451f, 0.02334404f, 0.01132737f, 
    0.12715276f, 0.06213861f, 0.03832522f, 0.04045415f, -0.14722577f, 0.09618746f, -0.06259622f, 0.12771693f, 
    0.01715437f, -0.03605288f, 0.05677029f, 0.14990811f, 0.12341886f, -0.07228982f, 0.08108615f, 0.05069341f, 
    0.12082133f, 0.03781674f, -0.02825869f, -0.26035836f, 0.14587133f, 0.21199954f, 0.12139782f, -0.06409047f, 
    -0.03222805f, 0.10254201f, 0.00607196f, -0.01644988f, 0.03258758f, -0.04456852f, -0.12174387f, -0.17011939f, 
    -0.00553713f, -0.06242932f, 0.00391516f, 0.00277736f, 0.17172126f, -0.05820897f, -0.07905511f, -0.15864769f, 
    0.02234272f, 0.27715719f, 0.14017929f, 0.01498075f, -0.09447929f, -0.03436336f, -0.12693724f, 0.12140433f, 
    0.09605168f, 0.00222368f, 0.04822602f, -0.08393679f, 0.19822559f, 0.10305704f, 0.14841582f, 0.16388786f, 
    0.01135820f, 0.13951844f, 0.04049246f, 0.02758156f, -0.00649835f, 0.04204043f, 0.11816517f, 0.11282402f, 
    0.41550848f, 0.05933553f, -0.01019660f, 0.17889379f, 0.11519791f, 0.00479421f, 0.09639338f, -0.01702528f, 
    0.18318364f, -0.06793849f, -0.12905678f, -0.01002629f, -0.14624009f, 0.00627689f, 0.04340874f, 0.03431960f, 
    -0.01574847f, -0.00542851f, -0.03346799f, 0.06491276f, 0.02651248f, 0.02300566f, 0.00190559f, 0.08328324f, 
    -0.09829938f, 0.14175016f, 0.17698301f, 0.11036803f, -0.11536072f, 0.10716492f, -0.00030861f, 0.00188764f, 
    0.06348851f, 0.00185004f, -0.02118712f, -0.00909182f, 0.09580979f, -0.09337441f, 0.01499953f, -0.14233229f, 
    0.05669365f, -0.01969483f, -0.05774606f, 0.05327598f, 0.03302484f, 0.04109036f, 0.08422611f, 0.06103050f, 
    0.04147789f, 0.02497661f, 0.11255278f, 0.13841546f, -0.02122536f, -0.06506658f, 0.15350378f, 0.04532354f, 
    0.05465459f, 0.03249268f, 0.22848396f, 0.07661287f, -0.06746791f, -0.09084790f, 0.04533453f, 0.05807155f, 
    -0.05004871f, 0.02280576f, 0.01358980f, 0.01373729f, -0.09011112f, -0.06178629f, 0.01781438f, 0.03725686f, 
    -0.26362556f, 0.10078844f, 0.05010888f, -0.03781858f, -0.09001949f, 0.12501964f, 0.06010417f, 0.07680991f, 
    0.06619117f, -0.02028771f, 0.10172464f, 0.03639246f, 0.03927347f, -0.05533841f, 0.10118247f, -0.14086629f, 
    -0.01899098f, 0.05067253f, 0.06071116f, 0.19941711f, 0.13454129f, 0.08293948f, 0.14773138f, 0.13278107f, 
    -0.00928115f, -0.16063844f, -0.15146039f, -0.01039723f, 0.10528284f, 0.18947105f, -0.07820320f, 0.04776175f, 
    -0.00947421f, -0.03901002f, 0.11539301f, 0.13914056f, 0.11644494f, 0.03812237f, 0.04536689f, -0.07751839f, 
    0.03422034f, 0.13407962f, -0.05659066f, -0.10881766f, -0.03890652f, 0.06393602f, -0.02198923f, 0.06208583f, 
    -0.02401947f, -0.10441918f, -0.09624387f, 0.07046138f, 0.02168647f, 0.08546641f, -0.06117769f, 0.01398594f, 
    0.06933550f, -0.02926789f, 0.01486706f, 0.03872244f, -0.07424484f, -0.11888135f, -0.14575037f, 0.04053671f, 
    -0.09476426f, -0.12839212f, -0.18604358f, -0.10060395f, 0.04359502f, -0.04365319f, 0.04858937f, -0.04203181f, 
    -0.21580915f, 0.15992768f, -0.14318219f, 0.01874640f, 0.03871702f, -0.09725495f, -0.04541680f, -0.00237580f, 
    -0.02304449f, -0.02825870f, 0.07789481f, -0.08811566f, -0.13738015f, 0.12649913f, -0.01205902f, 0.15368617f, 
    0.01139660f, -0.14250606f, 0.06982246f, 0.06647008f, -0.02497122f, 0.01078873f, 0.01762757f, 0.03481902f, 
    -0.23609014f, -0.04562204f, -0.03897250f, 0.04771942f, -0.14098567f, -0.14078814f, -0.05303549f, -0.02705612f, 
    -0.00298299f, 0.04581580f, 0.21194321f, -0.00809319f, -0.02010438f, 0.16240117f, 0.10603266f, -0.02225160f, 
    0.04188980f, 0.03902608f, 0.05350220f, 0.06568822f, -0.08993830f, -0.05146629f, 0.01703192f, -0.06142243f, 
    -0.01424920f, -0.20541491f, -0.08852734f, -0.02002495f, -0.01180559f, 0.06326392f, -0.14529304f, -0.04048086f, 
    -0.07508367f, -0.11770739f, -0.01047562f, -0.07500334f, -0.08494493f, 0.14976068f, 0.10082085f, -0.11362668f, 
    0.01115634f, -0.09605817f, -0.01712015f, -0.17706756f, 0.04894995f, 0.01346519f, 0.06344226f, 0.03196789f, 
    -0.12760158f, 0.32302636f, 0.09316493f, -0.07234796f, 0.12358532f, 0.14506125f, 0.05179946f, 0.03274488f, 
    0.08149935f, 0.04586672f, 0.07873221f, 0.00015327f, -0.46844298f, 0.15646736f, 0.20155337f, -0.08760387f, 
    -0.00370485f, -0.03802188f, -0.02646152f, 0.09461445f, 0.04589562f, 0.18855034f, -0.15221725f, -0.03423178f, 
    -0.06930276f, 0.00686618f, -0.07703063f, -0.04578891f, 0.03600791f, -0.12737346f, -0.15225507f, -0.12685247f, 
    -0.17919213f, -0.08227320f, -0.02182380f, -0.01953009f, -0.02071617f, -0.09298398f, 0.09146130f, 0.01516035f, 
    -0.06903064f, -0.03811606f, -0.08141806f, -0.00514165f, -0.03114164f, -0.18988650f, 0.11878689f, 0.16898896f, 
    -0.14345786f, -0.15527149f, -0.00137101f, 0.15054959f, -0.17216745f, -0.02291394f, -0.04767516f, 0.02533114f, 
    -0.23727842f, -0.13383773f, -0.08259483f, -0.11762609f, -0.00897445f, -0.10977820f, 0.19275162f, -0.01749673f, 
    0.15817657f, 0.20743383f, 0.12222080f, 0.06926873f, 0.20732632f, 0.00686117f, 0.16154791f, 0.03943638f, 
    0.15650484f, -0.26641777f, 0.27291876f, -0.02114914f, 0.09645426f, 0.02112480f, -0.07601824f, -0.06517344f, 
    0.02976852f, 0.09078719f, -0.00020990f, 0.08808172f, 0.30636740f, 0.23104152f, 0.24433410f, -0.01063049f, 
    -0.09115970f, 0.04651805f, -0.00002535f, 0.00850140f, 0.14905252f, 0.15182658f, -0.11776533f, 0.01866128f, 
    -0.00358979f, 0.00593414f, -0.28269815f, 0.00222893f, -0.03371705f, -0.10452688f, -0.14095084f, 0.08490963f, 
    -0.14562750f, -0.03946665f, 0.13627684f, -0.03493688f, 0.32507956f, -0.29298329f, 0.03482740f, 0.32510200f, 
    0.12610459f, 0.19739650f, 0.10929894f, 0.08666770f, 0.06479256f, 0.00680071f, 0.04644242f, -0.14036471f, 
    -0.11914723f, -0.19670047f, 0.09914140f, -0.29267800f, 0.01640222f, -0.12492675f, -0.16809243f, 0.06002453f, 
    -0.06561547f, -0.02772944f, 0.10252234f, 0.17047599f, 0.02027617f, -0.22932009f, 0.20498905f, -0.03963938f, 
    0.02002025f, -0.05804376f, -0.07858283f, 0.03515481f, -0.06151278f, 0.06180784f, 0.03138338f, -0.11052905f, 
    0.25584647f, -0.03134814f, 0.40973246f, 0.04188000f, -0.00192670f, 0.01043479f, 0.01386221f, -0.05426198f, 
    0.03306213f, 0.07356960f, 0.12766872f, 0.01736385f, -0.35338908f, 0.06695469f, -0.00152221f, -0.05556140f, 
    -0.08957494f, -0.04222264f, 0.10785761f, 0.03427273f, 0.12696044f, 0.14942177f, 0.07358769f, -0.06136930f, 
    -0.08241957f, 0.18033601f, -0.37478638f, -0.07120392f, 0.06039940f, 0.05553305f, 0.03250587f, 0.11427895f, 
    -0.08750813f, 0.04578283f, 0.05009246f, -0.10335292f, 0.04624431f, 0.05409297f, 0.06822085f, 0.15024626f, 
    -0.08076996f, -0.00114274f, 0.03546149f, -0.05991549f, -0.01772170f, 0.04698506f, 0.11952743f, -0.10459390f, 
    0.09754660f, 0.08185395f, -0.01763819f, 0.16409919f, 0.02354380f, 0.04076530f, 0.17843597f, -0.08642797f, 
    -0.10653422f, 0.07628438f, -0.02220137f, -0.10519981f, -0.24920447f, 0.02626429f, 0.26693010f, -0.02095716f, 
    -0.20924121f, 0.01662228f, 0.27517214f, -0.03657696f, 0.10724515f, -0.02605579f, -0.04287307f, -0.05900865f, 
    -0.16594887f, 0.19983622f, -0.33097762f, 0.38740399f, 0.10637838f, -0.04181054f, -0.00601165f, 0.08435149f, 
    -0.17492871f, -0.01261821f, 0.12860030f, 0.22838728f, 0.15484725f, -0.07426970f, -0.03074336f, -0.05233263f, 
    -0.04919704f, -0.07091549f, 0.01024920f, 0.00402833f, -0.00269774f, -0.03974480f, -0.00200211f, 0.06889267f, 
    -0.12660460f, 0.04471319f, -0.00142453f, -0.05225581f, 0.07771120f, 0.06616051f, -0.19020838f, -0.06483263f, 
    -0.02454408f, -0.01352902f, -0.03445787f, 0.00219133f, -0.18328781f, -0.30739081f, -0.00824101f, 0.11735011f, 
    0.25362918f, 0.08929598f, -0.11206094f, 0.11590956f, -0.04165986f, 0.03953101f, -0.12088580f, 0.16172475f, 
    0.12272488f, -0.16994439f, 0.06525534f, 0.17923445f, 0.06531974f, -0.08839122f, 0.04858613f, 0.04482101f, 
    -0.01427089f, 0.06641216f, -0.08999775f, 0.08040038f, -0.21107776f, -0.28755817f, -0.19105361f, 0.08133271f, 
    -0.12354302f, 0.08910545f, 0.04476289f, 0.12476707f, 0.10037315f, 0.06044902f, -0.00366085f, -0.01200120f, 
    0.01533828f, 0.06218218f, 0.07983110f, 0.11518361f, 0.02733453f, -0.02823712f, 0.28561723f, 0.01907731f, 
    -0.10359211f, 0.01206674f, 0.00052207f, 0.00292816f, -0.04350448f, 0.05257198f, 0.15662962f, 0.11810336f, 
    -0.13461758f, 0.02133400f, 0.04727817f, 0.01874148f, -0.00454507f, -0.02417494f, -0.03539053f, 0.00305073f, 
    -0.41660708f, 0.03230991f, -0.08219574f, -0.14592132f, -0.04216763f, 0.15891537f, -0.06289762f, -0.11886246f, 
    0.18172912f, 0.10950669f, -0.09781983f, 0.05027742f, -0.09827083f, 0.02071358f, 0.06691345f, -0.03448466f, 
    0.07396829f, 0.23064052f, -0.03119955f, 0.06241596f, -0.15360698f, 0.02349980f, 0.15949467f, 0.12047766f, 
    -0.02335005f, 0.03833610f, 0.06725046f, 0.07183438f, 0.13231771f, 0.09420646f, 0.03259117f, 0.05704283f, 
    -0.14053279f, -0.07827348f, 0.03871778f, 0.08617282f, 0.06915928f, -0.13680714f, -0.05716128f, 0.26670572f, 
    -0.11335972f, 0.02465843f, -0.05706024f, -0.06716864f, 0.15925072f, -0.06281295f, 0.01856088f, -0.06311588f, 
    -0.23809482f, -0.11869773f, 0.02374833f, -0.23220535f, -0.09799140f, -0.09868827f, 0.12353417f, -0.11801259f, 
    -0.05477781f, 0.05008590f, -0.08707279f, 0.05384399f, -0.37085742f, -0.28437346f, 0.06997089f, -0.06056924f, 
    -0.09262347f, -0.01382850f, -0.03453899f, -0.02706124f, -0.05929017f, 0.07040101f, -0.01573282f, -0.07219864f, 
    -0.17728852f, 0.17499498f, -0.09537940f, 0.10212082f, -0.03492958f, 0.08915679f, 0.19326958f, -0.12849498f, 
    -0.09382457f, 0.20181997f, 0.11235809f, 0.28142673f, -0.12145456f, -0.04506347f, 0.04163707f, 0.20229432f, 
    0.00462758f, 0.17264193f, -0.16622750f, 0.05129657f, -0.03623857f, -0.08490297f, 0.09904056f, 0.10068673f, 
    -0.06539337f, 0.00297950f, 0.09717276f, -0.05450359f, -0.10340142f, -0.00970689f, 0.00648166f, -0.03158028f, 
    0.24960059f, 0.10733500f, 0.05843011f, 0.07438780f, 0.02389177f, 0.06649125f, -0.01254317f, -0.09381121f, 
    -0.04092071f, 0.04907918f, 0.10484207f, 0.08722818f, 0.03769102f, 0.02765237f, -0.01246333f, 0.04772837f, 
    -0.02178494f, 0.00562117f, 0.00647204f, -0.05049822f, -0.05491867f, -0.03742789f, 0.02304654f, -0.01717494f, 
    -0.02978962f, 0.02517891f, -0.03803093f, 0.02431140f, -0.03032730f, 0.00623117f, -0.04137686f, 0.01326981f, 
    0.04240100f, 0.02519719f, -0.04741431f, 0.03761443f, -0.01602954f, 0.00078523f, -0.00430966f, 0.03545200f, 
    -0.02275736f, 0.02960083f, -0.03660268f, -0.03480336f, 0.03904993f, 0.01212396f, 0.00977587f, 0.02212374f, 
    -0.01138155f, -0.04151449f, 0.04099747f, 0.01060552f, -0.05720537f, -0.04383907f, -0.03378759f, 0.02187936f, 
    0.00569088f, -0.04404432f, 0.02652923f, -0.02710100f, -0.00713491f, 0.00324764f, -0.04051875f, -0.02575506f, 
    0.01382044f, -0.04744658f, 0.04094486f, 0.04296887f, 0.02344316f, -0.01755951f, 0.02990251f, -0.03942777f, 
    -0.03794057f, 0.00058824f, -0.03623650f, 0.03586582f, 0.01513866f, 0.02629181f, 0.03287055f, 0.01050610f, 
    -0.02391608f, 0.00150746f, 0.04560103f, -0.01104458f, 0.01097390f, -0.01128240f, 0.00083178f, 0.04044931f, 
    -0.00714510f, -0.04572217f, 0.03611345f, -0.01078003f, -0.03572247f, -0.04916442f, 0.02772427f, -0.01636013f, 
    0.03048602f, -0.00733753f, 0.02065547f, 0.00563469f, 0.01285616f, 0.02808538f, -0.04477867f, 0.02870561f, 
    0.01440428f, 0.00788582f, 0.00336292f, -0.00547098f, 0.00030176f, 0.01332224f, -0.03364009f, -0.04012458f, 
    -0.04048723f, 0.04456958f, 0.03937824f, 0.02003607f, -0.03739722f, 0.01833617f, 0.03750019f, 0.04281020f, 
    -0.01132822f, -0.05432941f, -0.01682332f, 0.03423107f, -0.00605987f, -0.02940843f, -0.03467176f, -0.02814945f, 
    -0.03401099f, 0.02217881f, -0.02880635f, -0.04539328f, -0.01143953f, -0.00742813f, -0.05264266f, 0.02877326f, 
    -0.04072347f, -0.04418474f, -0.03334321f, -0.01893206f, -0.04654341f, -0.01361304f, 0.01643790f, -0.05330809f, 
    -0.01004766f, -0.01492407f, 0.01002394f, -0.00216702f, -0.03507080f, 0.03635430f, 0.04003210f, -0.03600631f, 
    -0.04151206f, -0.04051403f, 0.01285260f, -0.01169684f, 0.02644010f, 0.00468276f, -0.02894271f, -0.01285436f, 
    -0.02948339f, -0.03719108f, -0.03874450f, -0.03283948f, 0.02166291f, 0.04151713f, 0.04553606f, 0.02503522f, 
    -0.03246510f, 0.02242028f, -0.05111766f, -0.02291331f, 0.02724943f, -0.04836132f, -0.05103285f, -0.01599281f, 
    -0.03819058f, -0.00942946f, 0.03667566f, -0.02396436f, -0.02807984f, -0.02564866f, -0.03998239f, 0.01445006f, 
    -0.02709875f, 0.00157647f, -0.03566946f, 0.01399298f, -0.02878099f, 0.02039466f, -0.04564814f, -0.04494527f, 
    0.02632042f, 0.04207113f, -0.03610414f, 0.03577382f, -0.00150915f, -0.04781695f, 0.01316619f, -0.03262056f, 
    -0.02515746f, 0.04233365f, 0.04218024f, -0.04195291f, -0.01023626f, 0.00506116f, -0.04373652f, 0.00058584f, 
    0.01106071f, -0.03180709f, 0.00545273f, 0.03036355f, 0.01722578f, -0.03604443f, -0.03746575f, -0.03041056f, 
    -0.03303211f, 0.01405007f, 0.03358786f, 0.00924164f, -0.02631155f, -0.01440027f, -0.01972178f, 0.03642148f, 
    0.00657256f, 0.03743179f, 0.03212791f, -0.02068001f, 0.03918437f, 0.03071915f, -0.04830758f, -0.02379943f, 
    0.02119454f, -0.02437535f, -0.03281023f, 0.00635739f, 0.04138125f, -0.00149818f, -0.04184512f, 0.02937255f, 
    -0.01876725f, -0.04208845f, 0.04401348f, 0.01172480f, -0.03357302f, 0.01007387f, -0.05349070f, -0.05660911f, 
    -0.01556561f, 0.01742496f, 0.01981030f, -0.03271971f, 0.00283877f, 0.04431410f, -0.04009685f, 0.00502195f, 
    -0.02391658f, 0.00063056f, -0.04448848f, -0.03123365f, 0.04296592f, -0.02765497f, -0.01245329f, -0.00938506f, 
    -0.01867035f, -0.04437095f, -0.01192283f, 0.04145830f, 0.00908670f, 0.03911088f, -0.03908507f, 0.00689497f, 
    0.02392332f, 0.02841504f, -0.04346494f, -0.03528262f, 0.02154427f, 0.00884582f, -0.01255870f, 0.01564363f, 
    0.02718050f, 0.01031990f, -0.03297636f, -0.00995573f, -0.05068114f, 0.00371400f, -0.03671939f, 0.01970441f, 
    -0.04509983f, 0.03988025f, -0.02176656f, -0.01632871f, -0.03686515f, -0.01561079f, -0.02902270f, 0.01999978f, 
    -0.02973180f, -0.03823259f, -0.05182231f, 0.01431621f, -0.01430456f, -0.04896215f, -0.05615883f, 0.01706242f, 
    0.02364221f, -0.02826308f, -0.04549631f, -0.02413252f, -0.04735414f, -0.00337027f, -0.01038058f, -0.02698510f, 
    -0.01560203f, -0.05297966f, 0.00461934f, -0.01587362f, 0.03813310f, -0.01053831f, 0.01863184f, 0.00752539f, 
    -0.04784938f, -0.02521038f, -0.02443258f, -0.05535119f, -0.03317535f, -0.02547023f, -0.03676703f, 0.01080696f, 
    0.01039765f, 0.01340272f, 0.02415705f, -0.00387129f, -0.00202197f, 0.02508073f, -0.04604533f, 0.01006531f, 
    0.04616376f, 0.03880430f, -0.04584503f, -0.03398193f, 0.00543789f, 0.02279403f, -0.04207711f, 0.03194012f, 
    -0.01324383f, 0.03824924f, -0.02079320f, -0.03413779f, -0.05571064f, 0.03161921f, -0.03894300f, -0.00209446f, 
    -0.00409883f, 0.03955711f, 0.01053284f, 0.01112943f, 0.04028865f, -0.05025169f, -0.03929111f, 0.03378204f, 
    0.00635184f, -0.01476862f, -0.03762449f, -0.02223109f, -0.02920017f, -0.00259829f, 0.00022300f, -0.03047123f, 
    -0.00374751f, -0.02086920f, -0.04564703f, 0.01111498f, 0.01109251f, -0.01358761f, 0.02013136f, 0.04267869f, 
    0.00482956f, -0.04939294f, 0.02433614f, 0.02132669f, -0.04311689f, -0.00908459f, -0.02616286f, 0.02287333f, 
    -0.03283296f, -0.01174698f, 0.01464278f, -0.02679198f, -0.03249647f, -0.04880143f, -0.05171572f, -0.01627942f, 
    0.03685385f, -0.03693146f, -0.02490493f, -0.00251819f, 0.01591800f, 0.04260678f, 0.00813375f, 0.01582135f, 
    -0.05038711f, 0.02486473f, 0.02279769f, -0.01156706f, -0.04480287f, -0.00000638f, -0.04875561f, -0.00772212f, 
    0.01308635f, -0.00336887f, -0.04651884f, 0.02131485f, -0.00879941f, 0.04334455f, -0.05621730f, -0.00643365f, 
    0.00228628f, 0.02247851f, -0.03475645f, -0.05060952f, -0.04787021f, -0.00720851f, -0.05325923f, -0.02097718f, 
    -0.03385361f, 0.01417793f, -0.01877270f, -0.02709966f, 0.01581116f, -0.00331662f, 0.04734041f, 0.03401063f, 
    -0.02790008f, 0.00740837f, -0.04045888f, -0.02325623f, -0.05235381f, -0.02080734f, 0.02230316f, -0.03548719f, 
    -0.04586133f, 0.03515203f, -0.01386518f, -0.03662698f, -0.04822617f, -0.03207292f, -0.03944936f, -0.02736295f, 
    0.01258888f, -0.04570160f, -0.00133418f, 0.03904480f, -0.04343517f, 0.03424018f, -0.04015758f, 0.00227326f, 
    0.00305152f, 0.04250041f, 0.03484983f, 0.04247953f, 0.01246038f, -0.05451042f, 0.00378629f, -0.03867097f, 
    -0.05115468f, -0.03435289f, -0.00476750f, -0.04497047f, 0.01741047f, -0.03064988f, -0.00332557f, -0.05794024f, 
    0.03559889f, 0.00895219f, -0.00884034f, 0.00153119f, -0.00990222f, -0.01373374f, 0.00571363f, 0.03298562f, 
    -0.01821024f, 0.03106570f, 0.03110500f, 0.03754811f, 0.01574559f, 0.03870015f, 0.00976774f, 0.03050164f, 
    0.02129166f, 0.00635934f, -0.02334918f, -0.03177179f, -0.01467529f, 0.03894838f, 0.02285224f, 0.00912705f, 
    -0.03965388f, 0.02129336f, -0.00311019f, 0.02859380f, 0.00083239f, -0.01474838f, -0.01574421f, -0.03488044f, 
    -0.04499360f, -0.03512296f, 0.02774397f, 0.02720001f, -0.01336387f, 0.02603960f, 0.02137018f, -0.02190921f, 
    0.01577499f, -0.00250992f, 0.01135738f, -0.02579301f, 0.00386090f, 0.03899572f, -0.04518188f, -0.05094367f, 
    0.02094944f, -0.04400385f, -0.04032789f, -0.03507126f, 0.04386878f, -0.00591509f, 0.03176562f, -0.00375626f, 
    0.03959851f, -0.04529639f, -0.04778657f, 0.03127491f, 0.00146712f, -0.03457293f, 0.01517346f, -0.04084254f, 
    -0.02067800f, -0.04054872f, 0.03118728f, 0.04515807f, -0.03466064f, -0.02529912f, 0.01519715f, -0.04145027f, 
    0.01445577f, 0.01813853f, 0.03482822f, 0.04070783f, 0.04483372f, -0.02767751f, 0.03439428f, -0.05322159f, 
    -0.02228141f, 0.00991818f, -0.00037247f, -0.04484064f, -0.01352527f, -0.04865450f, -0.03931028f, 0.03174130f, 
    0.03945342f, 0.03786223f, -0.03399050f, -0.01649914f, -0.01463776f, -0.00071754f, 0.05219225f, -0.00457687f, 
    0.04647280f, -0.01438451f, 0.01510111f, 0.01077618f, 0.03045987f, -0.00525797f, -0.03587677f, -0.03334166f, 
    -0.02209491f, 0.02768407f, 0.01144629f, -0.00294576f, -0.00127273f, -0.04794574f, -0.00636255f, -0.04374234f, 
    -0.04387980f, 0.02356804f, -0.05278916f, -0.02512486f, -0.03672706f, 0.02800830f, -0.04616613f, 0.03924445f, 
    -0.03261698f, 0.02983210f, -0.00374379f, -0.01844521f, -0.00765147f, 0.02348424f, -0.02892266f, 0.00736313f, 
    0.03708967f, -0.00362519f, -0.02187539f, 0.01045486f, 0.01401826f, 0.03251433f, 0.05098701f, -0.02996976f, 
    0.01551402f, -0.03725737f, 0.04162632f, 0.04592803f, -0.02729050f, 0.04193898f, -0.01151270f, -0.04652392f, 
    -0.01418587f, -0.02625138f, 0.02953626f, 0.02942142f, 0.04245348f, -0.03916725f, 0.04797698f, 0.03950823f, 
    0.01752592f, 0.03804535f, -0.03446903f, 0.00028578f, 0.02307373f, -0.01690514f, -0.01986876f, -0.05005975f, 
    0.01585432f, -0.02005938f, 0.02084424f, 0.02321559f, 0.00677847f, 0.04783744f, 0.00840123f, -0.01416892f, 
    0.01450451f, 0.00043673f, 0.02580278f, 0.00129335f, -0.05516192f, 0.03906767f, -0.03206752f, -0.04254792f, 
    0.03711657f, 0.00514848f, 0.02471716f, 0.01566827f, -0.02588615f, -0.02583562f, -0.03193566f, -0.03593439f, 
    -0.01134550f, 0.02345597f, -0.02133380f, -0.01803119f, -0.01732249f, 0.00480985f, -0.02612564f, 0.03467381f, 
    0.00490635f, 0.04667171f, 0.01166768f, -0.01587024f, -0.03141111f, 0.03482032f, -0.01099398f, 0.00568823f, 
    -0.02534226f, -0.03234636f, 0.01702242f, -0.02069693f, 0.03433714f, -0.03536573f, -0.05791635f, -0.05781616f, 
    0.02127541f, -0.05069415f, 0.02302486f, -0.00196940f, 0.02720778f, -0.02784257f, 0.01667995f, 0.04108394f, 
    -0.00437086f, -0.06061505f, 0.03081535f, -0.00139561f, -0.05374551f, 0.02842028f, 0.01325982f, -0.01009139f, 
    -0.02870751f, -0.04702285f, -0.03929049f, 0.00222933f, -0.03586522f, -0.04218263f, 0.03564611f, -0.03442645f, 
    -0.01251605f, -0.00415128f, -0.04325905f, -0.00138278f, -0.00323536f, 0.02767784f, -0.05094225f, -0.02290581f, 
    -0.00085558f, -0.00170632f, -0.04405579f, -0.03849405f, -0.02806758f, -0.04644062f, -0.02451003f, -0.03631873f, 
    0.03301543f, -0.05014252f, -0.03311745f, 0.00650061f, -0.00343352f, 0.00710608f, 0.03797139f, 0.03118079f, 
    -0.01726446f, -0.01125552f, -0.04524759f, 0.02710034f, 0.03710673f, 0.02175740f, -0.03995717f, 0.01766449f, 
    -0.01312062f, 0.04575353f, 0.01443044f, -0.05599808f, -0.01885623f, -0.00068639f, -0.02093748f, -0.05119845f, 
    -0.01366711f, -0.02181452f, 0.01876240f, -0.05014687f, 0.03035836f, -0.04265910f, 0.01785783f, 0.04064933f, 
    -0.02476540f, -0.00627196f, -0.01034719f, 0.03159736f, -0.03896994f, 0.02548326f, 0.02287857f, -0.01150308f, 
    0.03587105f, -0.03810661f, 0.02262114f, 0.03129900f, -0.00655510f, 0.00012333f, 0.00911590f, 0.01261100f, 
    -0.05119245f, 0.02902146f, 0.03039280f, 0.01625240f, -0.00226168f, 0.01258852f, -0.00668096f, 0.00360129f, 
    0.01446458f, -0.01334391f, -0.04021402f, -0.04806071f, -0.05136379f, 0.03594553f, 0.03778758f, -0.05147844f, 
    -0.17572688f, -0.05105408f, -0.05172874f, -0.01378611f, -0.23638937f, -0.13651004f, -0.10907026f, -0.02254971f, 
    -0.04814958f, -0.11510134f, 0.00932742f, -0.07107084f, 0.06713391f, -0.13397600f, 0.06657769f, 0.10870874f, 
    -0.04892973f, 0.01592968f, 0.08990856f, 0.00346458f, -0.06734747f, 0.11418047f, 0.03429201f, -0.09111811f, 
    0.09257454f, 0.14117897f, 0.03792897f, -0.00874027f, -0.01729918f, -0.02348945f, -0.04688229f, 0.02533325f, 
    -0.14230792f, 0.01730966f, 0.06028419f, 0.06247453f, -0.09233215f, 0.09323963f, 0.17959218f, -0.12965329f, 
    0.00838802f, -0.02454587f, 0.16968849f, -0.01152186f, 0.00266480f, 0.08647928f, -0.15396202f, 0.11530772f, 
    -0.01635978f, -0.03284559f, -0.12893005f, 0.23574089f, -0.09897602f, 0.03600612f, -0.09130831f, 0.11547938f, 
    -0.13567397f, -0.08828288f, -0.06529472f, -0.27012920f, 0.19232951f, -0.38947606f, 0.02412080f, 0.24177767f, 
    -0.08549041f, 0.10915818f, -0.11764775f, 0.03580606f, -0.03372436f, 0.11880181f, 0.03697037f, -0.01457237f, 
    -0.10503913f, -0.07911890f, 0.08979022f, -0.10311642f, -0.07284512f, -0.03989226f, 0.08345097f, 0.15215582f, 
    -0.05997649f, 0.02610823f, 0.04493290f, -0.03969781f, 0.00588420f, -0.10690701f, 0.11288265f, -0.03699854f, 
    0.02551203f, -0.07207551f, -0.00984720f, -0.02438396f, 0.10055029f, 0.25135279f, 0.14334242f, 0.20766486f, 
    0.19401872f, 0.31531635f, 0.22671542f, -0.09583940f, -0.09499457f, -0.17268485f, 0.06477803f, 0.01556945f, 
    0.00810173f, -0.04317864f, -0.00920875f, 0.10887685f, -0.03961128f, 0.10108473f, -0.04322320f, -0.01543277f, 
    0.05153716f, -0.03137959f, 0.03403554f, 0.07888309f, -0.01647746f, 0.10820277f, -0.03819000f, -0.01097865f, 
    0.01219254f, -0.10330590f, 0.10964627f, -0.08718940f, 0.06325912f, 0.07291082f, 0.02932679f, 0.03519287f, 
    -0.02895237f, 0.06626709f, 0.01895158f, 0.05599988f, 0.12382142f, 0.04893568f, -0.11301234f, 0.17595698f, 
    -0.14658412f, -0.04764717f, 0.03513972f, 0.02258298f, 0.09177931f, 0.12330595f, 0.07968634f, 0.27547920f, 
    0.26082161f, 0.07599657f, 0.11625316f, 0.01661640f, -0.18237405f, -0.10739556f, 0.00610633f, 0.00728596f, 
    -0.08374491f, -0.00437706f, -0.01604793f, -0.01052542f, -0.03155808f, -0.07308234f, 0.18018708f, 0.13131264f, 
    -0.07292805f, -0.05976497f, 0.19221997f, -0.04358586f, 0.13649169f, 0.05943831f, -0.00999119f, 0.02311019f, 
    0.15326478f, -0.07265453f, -0.25116554f, 0.46974936f, -0.02088932f, 0.08383926f, -0.06455005f, -0.19039156f, 
    -0.03302884f, 0.01674501f, 0.12785316f, -0.04161190f, 0.41601360f, 0.28584257f, -0.02157794f, -0.02550797f, 
    -0.03353371f, 0.00695167f, -0.12871303f, -0.02049824f, -0.04826963f, -0.11829709f, 0.03238418f, -0.09069068f, 
    -0.01933379f, -0.05144675f, 0.02194442f, 0.06070522f, 0.03080516f, -0.06324092f, -0.14981900f, 0.00449152f, 
    -0.09829839f, 0.03888984f, 0.03993176f, -0.05881282f, -0.12310538f, 0.00622755f, -0.04896202f, 0.15459131f, 
    0.15045974f, -0.07513360f, -0.04942809f, -0.13528740f, 0.05935596f, -0.05504104f, -0.05119800f, 0.12281306f, 
    0.00589126f, 0.17528744f, 0.13976113f, 0.12403399f, -0.04195265f, -0.07576614f, 0.10613550f, 0.03632166f, 
    -0.05433576f, 0.02640592f, -0.07956027f, -0.20412605f, -0.00600508f, -0.05149922f, 0.04081628f, 0.03963170f, 
    -0.01600063f, 0.14303045f, -0.00101715f, 0.05040146f, 0.11339273f, 0.09928972f, 0.06319113f, 0.03261258f, 
    0.09399739f, -0.09739999f, 0.06951247f, 0.07016659f, -0.00539863f, 0.02775638f, -0.00011551f, 0.04232598f, 
    -0.11955228f, -0.12272025f, -0.11233125f, -0.26330337f, -0.00303258f, 0.13571233f, -0.03183876f, -0.13941827f, 
    0.04272773f, 0.04420579f, 0.06695622f, 0.12810534f, 0.03535760f, 0.01545105f, -0.01177987f, 0.03500374f, 
    0.06449424f, 0.09954704f, -0.03216538f, 0.14650002f, 0.03128269f, -0.00614489f, 0.04119082f, -0.08089837f, 
    0.18264049f, 0.07198894f, 0.13988599f, 0.26423824f, 0.11540709f, 0.13287604f, -0.07184102f, -0.03668247f, 
    -0.02471405f, -0.02145002f, 0.04916947f, -0.07049182f, -0.07108327f, -0.11776666f, -0.03279195f, -0.11824633f, 
    0.01099332f, 0.03017724f, -0.01829012f, -0.07169000f, 0.13260502f, -0.07000323f, 0.07366029f, -0.06283762f, 
    0.06423218f, -0.06188138f, -0.18345523f, -0.11474996f, -0.17038512f, -0.18963249f, 0.10400729f, 0.07970662f, 
    -0.05568668f, 0.00827236f, -0.14618845f, 0.04455112f, 0.05332740f, 0.10617044f, 0.02924451f, 0.03558561f, 
    0.07550942f, 0.25220960f, 0.14335422f, 0.06658290f, 0.00530712f, -0.10342860f, 0.09218472f, 0.00257817f, 
    0.20389208f, -0.06854843f, 0.07827862f, -0.03524614f, 0.03880552f, -0.13808431f, 0.12685387f, 0.13338405f, 
    -0.07740710f, -0.09147096f, -0.11854866f, 0.02761190f, 0.03033105f, 0.00290171f, -0.02155330f, -0.01831300f, 
    0.07858390f, 0.00370202f, 0.09748200f, 0.16842133f, -0.09243647f, 0.01866958f, -0.01944721f, 0.04365272f, 
    0.03863406f, 0.05989346f, 0.09159076f, 0.08606096f, -0.10795693f, -0.11007720f, -0.09004251f, 0.14772014f, 
    -0.08402231f, -0.00511658f, 0.07412522f, -0.04072531f, 0.11323679f, -0.09125393f, 0.10472713f, 0.14538865f, 
    -0.00164395f, -0.07870021f, -0.05743501f, -0.16930321f, -0.09574355f, -0.07478149f, 0.10371640f, -0.01275923f, 
    0.13232766f, 0.12537944f, 0.06262231f, 0.15924951f, 0.00064708f, 0.12411494f, -0.03339580f, -0.25103432f, 
    0.13155341f, 0.07636976f, -0.05372111f, -0.08884773f, -0.11099819f, 0.08410116f, -0.12441418f, -0.39403498f, 
    -0.08004910f, 0.11990996f, 0.07876035f, 0.27098194f, 0.00044227f, 0.03228136f, 0.07600132f, -0.10615828f, 
    -0.09912439f, -0.01608524f, -0.04136276f, 0.00932357f, -0.01194705f, -0.18840054f, 0.31375605f, 0.13589948f, 
    -0.02684284f, -0.02091268f, 0.16359979f, -0.11423759f, 0.27052003f, 0.05998464f, 0.00755899f, 0.12661067f, 
    -0.14464696f, 0.01413080f, -0.12307518f, 0.13204476f, 0.11226913f, -0.00205127f, 0.01993338f, 0.07545430f, 
    0.25511768f, 0.06143712f, 0.03273687f, -0.04174873f, 0.30704808f, 0.12166280f, 0.03081716f, 0.07241827f, 
    -0.06656418f, 0.15547812f, 0.02423366f, -0.02443177f, 0.02794469f, 0.03882693f, -0.10682225f, 0.12437754f, 
    -0.00796395f, 0.13992997f, -0.06202442f, 0.14752530f, 0.02096551f, 0.03513899f, 0.09661947f, 0.14130437f, 
    -0.02971882f, -0.08784523f, -0.02523751f, 0.10826560f, -0.06621346f, 0.01040951f, -0.04026524f, 0.11468448f, 
    -0.01655613f, 0.11644282f, -0.06744903f, 0.10115587f, 0.14227399f, -0.02159272f, -0.08423960f, 0.26944882f, 
    0.02330125f, 0.09521498f, 0.13740988f, 0.07416593f, 0.00842193f, -0.12748806f, 0.04429996f, 0.00892065f, 
    -0.06737028f, -0.02767950f, 0.09315141f, 0.02936341f, 0.11850735f, -0.08810303f, 0.21649249f, 0.00138435f, 
    0.08100590f, -0.05884840f, -0.10190132f, -0.03643835f, -0.03583726f, 0.00429282f, 0.05417085f, -0.03791567f, 
    0.19664235f, -0.06033493f, -0.14522116f, -0.04183042f, -0.01079177f, -0.05686393f, 0.19684689f, -0.00990768f, 
    0.06920372f, -0.06668856f, 0.06130859f, 0.00758091f, -0.16831727f, -0.29040208f, -0.16425508f, -0.06099377f, 
    0.00464816f, 0.05442992f, -0.02369754f, -0.02256105f, 0.11046816f, 0.08510191f, -0.08066095f, -0.01240040f, 
    0.09957238f, 0.07187604f, -0.00427564f, 0.20263371f, -0.01779966f, -0.06284853f, -0.03534103f, -0.05781912f, 
    -0.03824243f, -0.08698293f, 0.02405387f, 0.24665797f, -0.04437198f, -0.07268931f, -0.15686908f, -0.00977767f, 
    -0.01158183f, -0.06894683f, 0.06331951f, 0.00646031f, -0.21719812f, -0.04153526f, -0.10995696f, -0.01762940f, 
    -0.06210845f, 0.09864061f, -0.13525009f, 0.17907265f, 0.02846645f, 0.19509979f, 0.10229748f, 0.04713278f, 
    0.08230852f, 0.07348770f, -0.13910595f, 0.03437072f, -0.22107677f, 0.01570928f, 0.09649492f, 0.04134437f, 
    -0.02374221f, -0.07840097f, 0.29362091f, -0.05281256f, -0.01023967f, -0.02542108f, 0.00479107f, -0.05595183f, 
    -0.48083690f, -0.12575535f, -0.11245228f, 0.17106377f, 0.01117682f, -0.08326075f, 0.02055846f, 0.12139180f, 
    0.06593519f, 0.07999229f, 0.08443277f, 0.00555190f, 0.48836210f, 0.09098106f, 0.05213131f, 0.15053082f, 
    0.00083230f, 0.00362856f, -0.06710676f, -0.06011488f, -0.07731345f, -0.03265620f, -0.04621296f, 0.06235062f, 
    -0.26858753f, -0.00668108f, -0.11967131f, -0.04948787f, -0.08388956f, -0.01484099f, -0.05028564f, 0.01102059f, 
    0.00843129f, 0.01578020f, -0.12932739f, -0.09389349f, -0.11858508f, -0.10454445f, 0.16554549f, 0.13560058f, 
    0.15205234f, 0.03354751f, -0.01066199f, 0.10324709f, 0.07675947f, 0.05077708f, 0.06078400f, 0.20527598f, 
    0.30784452f, 0.04931610f, 0.16331665f, -0.19107370f, 0.01812408f, -0.00445299f, 0.03860908f, -0.20995979f, 
    -0.08915985f, -0.00643272f, 0.05463124f, -0.06768966f, 0.01518249f, 0.06963460f, 0.15694925f, 0.18138735f, 
    -0.03890033f, 0.09779679f, -0.06762093f, 0.09832558f, -0.04927268f, -0.12821893f, 0.03988562f, -0.02086606f, 
    0.09395447f, -0.03020013f, 0.07941186f, 0.04025099f, 0.00744588f, 0.16287768f, -0.00722162f, -0.07256918f, 
    0.03832855f, -0.05465952f, -0.01449499f, 0.01234666f, 0.06089292f, -0.00639523f, 0.00121566f, 0.02864745f, 
    -0.01795805f, -0.05403564f, -0.01232489f, -0.03271594f, 0.08080848f, 0.07766169f, 0.03384889f, 0.13558909f, 
    -0.19443104f, -0.07822373f, -0.03670600f, 0.01439735f, 0.00253228f, -0.08043226f, -0.14596459f, -0.11288643f, 
    -0.00078294f, -0.02514703f, -0.04959771f, 0.08611464f, -0.02673405f, 0.09701391f, -0.00899945f, 0.01496005f, 
    0.03657891f, -0.00500160f, 0.02905652f, 0.07775778f, -0.05792728f, -0.01143713f, 0.04699329f, 0.04667496f, 
    0.04675641f, 0.00173763f, -0.02683054f, 0.01081239f, 0.02457371f, 0.00521628f, -0.03185917f, -0.00971970f, 
    -0.00673064f, 0.01740921f, -0.01563297f, -0.05463297f, -0.10652123f, -0.03330053f, 0.08337702f, 0.19370158f, 
    0.00468733f, -0.03980583f, -0.16014932f, -0.02332980f, -0.06351963f, -0.00767781f, -0.09160274f, 0.00322248f, 
    0.35180229f, 0.02360560f, 0.08928964f, 0.05124588f, -0.08318312f, -0.07640288f, 0.13158256f, 0.00085095f, 
    0.08069127f, -0.05910202f, -0.06678149f, -0.05969139f, -0.15449016f, 0.06261260f, 0.19043615f, 0.25162110f, 
    -0.02856793f, -0.03548973f, 0.19878198f, 0.04333096f, 0.05265368f, -0.07233906f, -0.06870540f, -0.03665340f, 
    -0.04230254f, -0.05145579f, 0.05314763f, 0.08673517f, 0.02236486f, 0.20455360f, 0.02517063f, -0.07229073f, 
    0.05807049f, -0.07258414f, 0.09648874f, 0.11107662f, -0.40024197f, -0.06535733f, -0.05825487f, 0.00594598f, 
    -0.05796100f, 0.02659842f, -0.17626362f, 0.01209489f, 0.04384727f, -0.10868932f, -0.06820551f, 0.06824345f, 
    0.05173224f, 0.02883407f, 0.02002847f, 0.08124800f, 0.05934415f, 0.01205880f, -0.05537409f, -0.07790499f, 
    0.19034958f, 0.05038436f, -0.02746227f, 0.07965421f, 0.11564931f, 0.01154362f, -0.01767101f, 0.07664670f, 
    0.00768307f, -0.06548057f, -0.02703694f, 0.02257730f, -0.09831817f, -0.02208001f, -0.11015213f, 0.02507263f, 
    -0.06675987f, -0.05704770f, 0.00486002f, -0.01709865f, -0.11949111f, 0.15817203f, 0.13535832f, 0.24518405f, 
    0.07980893f, 0.02854692f, 0.04787696f, 0.05036934f, 0.42727923f, -0.30598658f, 0.09667569f, 0.14770292f, 
    -0.11635660f, 0.05166426f, -0.02402942f, 0.07377552f, 0.19249655f, 0.12882455f, 0.15658471f, 0.11546379f, 
    0.21710062f, -0.01176674f, 0.40705803f, -0.29994342f, -0.16140273f, 0.23658086f, 0.02186836f, 0.04251230f, 
    0.09520016f, 0.05419782f, -0.01306704f, 0.10849251f, 0.14431109f, -0.02380752f, 0.35602525f, -0.38383856f, 
    0.10063338f, 0.00100292f, -0.02721526f, 0.07286564f, 0.04250669f, -0.06921767f, -0.17837888f, 0.09846865f, 
    -0.12371264f, -0.10467385f, -0.13581356f, -0.07500817f, 0.03420742f, 0.03420416f, 0.01933268f, 0.05764308f, 
    0.13980523f, 0.01315988f, 0.02744374f, 0.04972779f, 0.29561815f, -0.33036518f, 0.14489940f, 0.02157363f, 
    0.01464862f, 0.10582078f, -0.19708730f, 0.08944280f, 0.22181515f, 0.01010356f, -0.01212800f, 0.01898882f, 
    0.12265927f, -0.06943028f, 0.11206464f, -0.37606186f, 0.11936654f, 0.11477392f, -0.10353715f, 0.11490551f, 
    0.01325324f, 0.03756690f, 0.09992981f, -0.00966613f, 0.20733765f, -0.12889825f, -0.01248273f, -0.01754733f, 
    -0.01349585f, -0.01667716f, -0.08983658f, 0.06345111f, -0.04572452f, -0.11761007f, -0.04923026f, -0.21018118f, 
    0.28155267f, -0.03238213f, 0.29216531f, -0.22122701f, -0.12540834f, 0.02129198f, -0.18033902f, 0.23520008f, 
    0.12708795f, -0.09167986f, 0.14626002f, -0.04337314f, -0.04964371f, 0.19414327f, -0.07954074f, 0.17831723f, 
    0.02300935f, 0.04985423f, -0.00546540f, 0.20716007f, 0.08320407f, -0.11258470f, 0.13520640f, -0.05764633f, 
    0.59860235f, -0.11522384f, 0.03840353f, -0.31555414f, -0.09594102f, 0.05878371f, -0.01983498f, 0.07767924f, 
    0.04743836f, 0.05180046f, -0.07334347f, -0.11267854f, 0.18335700f, 0.11423557f, 0.00368218f, 0.12867074f, 
    0.02072743f, -0.00372437f, -0.09196718f, -0.05048145f, 0.01929171f, -0.02051825f, -0.07240701f, -0.07019863f, 
    0.26684263f, -0.17174627f, -0.01839866f, 0.01742035f, -0.18883243f, -0.01554885f, 0.11367540f, -0.01406682f, 
    0.02970899f, 0.03168698f, 0.04529863f, 0.03970915f, 0.00899645f, -0.12388936f, -0.11395898f, -0.07126150f, 
    -0.04277895f, -0.04743307f, -0.03649514f, 0.14484847f, 0.11462592f, 0.04766582f, 0.02540818f, -0.03191480f, 
    0.24074657f, 0.01711305f, -0.04696258f, 0.32553518f, -0.03372598f, -0.00927598f, -0.06497900f, -0.00793529f, 
    -0.14039771f, 0.02958616f, -0.01280503f, 0.02292822f, -0.19351037f, -0.07488283f, -0.04166047f, 0.12507895f, 
    -0.03947099f, -0.06678060f, 0.07696830f, 0.07819775f, 0.06008898f, 0.03668422f, -0.06408666f, 0.02787730f, 
    -0.14995663f, 0.16089283f, 0.12920587f, 0.05044147f, -0.03232497f, 0.04780071f, 0.02901738f, 0.02851006f, 
    0.18128112f, -0.08265388f, -0.07194591f, -0.06900981f, -0.07487909f, 0.02082771f, -0.01431356f, 0.14451399f, 
    0.06731157f, 0.13742478f, 0.04065664f, 0.21200490f, 0.08976366f, 0.05743871f, 0.00254440f, 0.03531392f, 
    -0.07847113f, -0.13544434f, -0.23126477f, 0.20226462f, 0.12557214f, 0.05975847f, 0.19201587f, 0.17310199f, 
    0.00385014f, -0.10518689f, 0.16449320f, 0.14757408f, 0.08467940f, -0.02446204f, 0.07601384f, 0.00395307f, 
    0.10594834f, 0.14233319f, 0.09209239f, 0.12899651f, 0.07767345f, 0.00527231f, -0.01231096f, -0.01142718f, 
    -0.39184636f, 0.02921041f, -0.08856213f, -0.04835166f, 0.15375765f, -0.00464419f, 0.12557332f, -0.02243957f, 
    -0.06211946f, 0.25091705f, 0.13100813f, 0.18096955f, -0.01601464f, -0.03117025f, 0.14345556f, 0.03091642f, 
    -0.06930272f, -0.03320358f, -0.09299985f, 0.01218808f, -0.00852825f, -0.06325567f, -0.05905100f, -0.04520743f, 
    -0.16756377f, 0.01569321f, -0.05922460f, -0.15600328f, 0.09284328f, -0.02511567f, 0.06916133f, -0.03874361f, 
    -0.05900788f, -0.04795172f, -0.05249256f, -0.13330507f, 0.08480375f, 0.01048882f, 0.06320841f, -0.08090391f, 
    0.01907948f, 0.20399131f, -0.02187374f, 0.03050451f, 0.05276920f, 0.20479473f, 0.05300049f, 0.22886901f, 
    0.05865382f, -0.05150510f, 0.00272468f, -0.02917338f, 0.02534286f, -0.00299448f, -0.04896940f, -0.09875133f, 
    0.06431193f, 0.10398915f, 0.26327741f, 0.24889478f, 0.01819617f, -0.04075103f, 0.16277535f, -0.07315698f, 
    -0.00479261f, -0.05833670f, -0.05366856f, 0.08714690f, 0.14917856f, -0.10739731f, -0.11369556f, -0.06092830f, 
    -0.30225635f, 0.07839027f, -0.16751729f, 0.15737996f, 0.09195928f, 0.01636532f, -0.11025187f, -0.02889709f, 
    -0.03462990f, -0.18273883f, -0.03518361f, 0.05265404f, 0.03875825f, -0.09952273f, 0.12754546f, -0.17435922f, 
    -0.04303454f, -0.01501874f, -0.05020667f, 0.14467090f, 0.04693921f, 0.02169994f, 0.04760049f, 0.01980788f, 
    0.06727789f, 0.17408018f, -0.07655851f, 0.02399106f, -0.03579776f, 0.04092937f, 0.18367250f, -0.07061014f, 
    0.00402363f, -0.07475028f, -0.00564947f, 0.06376424f, -0.28900662f, -0.04872138f, 0.09347712f, 0.02543674f, 
    0.01418437f, -0.17330314f, -0.12266309f, 0.08904308f, 0.07439191f, -0.01661572f, -0.11731432f, -0.18321760f, 
    -0.12138231f, -0.04094328f, 0.05900857f, -0.09675107f, -0.00676009f, -0.01123414f, -0.04124128f, -0.06614875f, 
    0.04330761f, -0.04419838f, 0.01253190f, 0.06551644f, 0.00488133f, 0.03841255f, 0.09830074f, 0.12908041f, 
    -0.13266933f, 0.06678161f, 0.01978431f, -0.03872082f, 0.16343960f, -0.15733466f, 0.07748424f, 0.17887318f, 
    -0.23278232f, -0.29207090f, 0.01530609f, 0.02259277f, 0.23141025f, -0.08258665f, 0.08933778f, -0.02917810f, 
    -0.09148719f, 0.00987948f, 0.03180097f, -0.03970817f, 0.06782470f, 0.06933375f, -0.01339282f, -0.01488823f, 
    -0.01750078f, -0.00185165f, 0.00399617f, 0.02511431f, 0.21756163f, 0.07981561f, 0.00386882f, 0.20781964f, 
    -0.13447557f, 0.03761207f, 0.21623033f, 0.26045540f, 0.07681216f, 0.06313164f, 0.00485793f, 0.14683262f, 
    0.04629823f, 0.08116027f, 0.01701447f, 0.11478530f, -0.17414995f, 0.12397347f, 0.11813948f, 0.15379490f, 
    -0.01078844f, 0.14233948f, -0.04707503f, 0.15539426f, 0.08449157f, -0.08074997f, 0.13510478f, 0.07794024f, 
    0.08453480f, -0.04181734f, 0.00748994f, 0.02120350f, 0.00795214f, 0.10676757f, 0.06519323f, -0.08392961f, 
    0.13866603f, 0.06027197f, 0.11495816f, 0.07977819f, -0.16433732f, 0.19267219f, 0.02417620f, 0.07426191f, 
    0.03293947f, -0.07368626f, 0.05049626f, 0.13943551f, 0.08154407f, 0.01547684f, 0.00074447f, 0.02945767f, 
    -0.20573218f, -0.02453074f, -0.05104740f, 0.12962098f, 0.05953322f, 0.21993083f, 0.11014416f, -0.19369186f, 
    0.04395298f, 0.00528611f, 0.00338702f, -0.01788958f, 0.04449837f, -0.03920639f, -0.06715315f, -0.19144687f, 
    -0.02123030f, -0.03896561f, -0.02862171f, -0.03301099f, 0.12426598f, -0.06819843f, -0.05398628f, -0.20285182f, 
    -0.18217461f, 0.18514524f, 0.11115451f, 0.25946859f, -0.15203577f, -0.07352358f, -0.12022226f, 0.11303516f, 
    0.16085188f, 0.02323890f, 0.07349178f, -0.04287541f, 0.41341290f, 0.17041007f, 0.15649061f, 0.12432016f, 
    0.11804596f, 0.18259290f, 0.05801749f, -0.01082027f, 0.05499700f, 0.01092511f, 0.13330987f, 0.02031315f, 
    0.13157263f, 0.36245665f, -0.09186339f, 0.21393684f, 0.05388559f, 0.05551850f, 0.02857677f, -0.08018075f, 
    0.14285894f, 0.07290068f, 0.03761602f, 0.07389618f, -0.22404352f, 0.01331709f, 0.12431298f, -0.20074749f, 
    -0.00359745f, -0.06479482f, -0.02830961f, -0.05133284f, -0.01558933f, -0.07013035f, -0.02281195f, -0.03835735f, 
    -0.10987055f, 0.06590632f, 0.23854555f, 0.16254671f, -0.19468118f, 0.09940779f, -0.03495745f, 0.14146771f, 
    0.18871547f, 0.01697951f, -0.06013422f, -0.00472502f, 0.10728113f, 0.02926133f, 0.04035794f, -0.05541522f, 
    0.11986539f, 0.07018655f, 0.03348915f, 0.13103878f, -0.00034668f, 0.02130839f, -0.05431399f, 0.00816672f, 
    0.19402972f, -0.26303655f, 0.05780450f, 0.00962719f, 0.07725085f, 0.05750734f, 0.04832190f, 0.10921942f, 
    0.03758039f, 0.01779624f, 0.18270807f, 0.04364577f, -0.13898712f, 0.02767172f, 0.16928177f, 0.00771037f, 
    -0.05954385f, 0.02852670f, -0.07408378f, 0.02101228f, -0.11973026f, 0.07726526f, 0.01714145f, 0.19907755f, 
    -0.17399073f, 0.04824346f, -0.07596544f, 0.00353804f, -0.08904790f, -0.02120494f, 0.04355802f, 0.02927902f, 
    0.09738565f, 0.08970796f, 0.18580280f, 0.21252824f, 0.20154656f, -0.20606321f, 0.17431441f, -0.26862332f, 
    -0.02409696f, -0.05762861f, 0.09418049f, 0.09166592f, 0.06110856f, 0.18045057f, 0.04806215f, 0.04072351f, 
    -0.27941024f, 0.00994332f, 0.16514644f, -0.00854470f, 0.15549842f, 0.07951789f, -0.12188583f, 0.12183234f, 
    0.16558175f, -0.06438535f, 0.13825889f, 0.15980661f, -0.00775396f, -0.20497517f, -0.10765564f, -0.03067151f, 
    -0.02383777f, 0.10847794f, -0.04513945f, -0.17446972f, -0.05499454f, -0.04857232f, -0.04077635f, -0.00230172f, 
    -0.08810056f, 0.08598640f, 0.00687236f, 0.18152210f, 0.06006465f, -0.03619442f, -0.02843561f, -0.00923764f, 
    0.09713367f, -0.06171231f, -0.00188199f, 0.15344317f, -0.20820241f, -0.15278192f, -0.17843309f, -0.11350941f, 
    -0.02341017f, -0.13968819f, -0.19581920f, -0.10684168f, -0.00296754f, -0.04701170f, 0.06038078f, -0.06330303f, 
    -0.19262463f, -0.01215297f, -0.22428015f, -0.04740001f, 0.04426814f, -0.03970044f, 0.04089037f, -0.07354288f, 
    -0.07565399f, -0.04285556f, -0.05893743f, -0.13932079f, -0.09922543f, 0.11385184f, 0.02864301f, 0.18306781f, 
    -0.01025586f, -0.17996749f, 0.12024396f, 0.08764648f, 0.08304676f, 0.09053887f, 0.01893785f, 0.17159691f, 
    -0.18445018f, -0.18924171f, -0.15323868f, -0.11591510f, -0.17486632f, -0.18272482f, -0.08292949f, 0.01562979f, 
    0.04592070f, 0.00213274f, 0.20148890f, 0.00954638f, -0.06220397f, -0.01732910f, 0.09367982f, -0.08318752f, 
    0.01717893f, 0.00439367f, 0.08214857f, 0.04573596f, -0.11857468f, -0.08764921f, -0.00839446f, -0.03478254f, 
    -0.02923384f, -0.16202527f, -0.01479977f, -0.10335544f, -0.01585140f, 0.01010819f, -0.18938871f, -0.05342419f, 
    -0.13929890f, -0.10723671f, -0.04598884f, -0.07296070f, -0.27272221f, -0.10216675f, -0.06007795f, -0.13835004f, 
    -0.08675355f, -0.09567183f, 0.01360765f, -0.11186180f, -0.02565920f, 0.02849711f, -0.09327231f, -0.03943272f, 
    -0.26636013f, 0.17926936f, -0.08785994f, -0.14526446f, -0.03147817f, 0.10944462f, -0.02249420f, 0.08952753f, 
    0.11106053f, -0.04320801f, -0.00636247f, -0.04458681f, -0.13918032f, 0.09406929f, 0.27732536f, -0.14707825f, 
    0.00334051f, -0.13494626f, 0.00643611f, 0.15456915f, -0.05774834f, 0.20002024f, -0.06920385f, -0.04990102f, 
    -0.13998634f, -0.00667264f, -0.04986705f, -0.06184224f, -0.00968264f, -0.15649596f, -0.14713421f, -0.12237138f, 
    -0.07111476f, -0.01321763f, -0.07961171f, -0.10015220f, 0.02542304f, -0.03286310f, 0.04259675f, -0.02134255f, 
    -0.17642789f, -0.06225671f, -0.11444344f, 0.02299161f, 0.08100383f, 0.00346222f, 0.21541166f, 0.17021069f, 
    -0.02435405f, -0.08307010f, -0.07998923f, -0.03419793f, -0.01395856f, -0.06501660f, -0.03989277f, -0.05338721f, 
    -0.06044148f, 0.02224394f, 0.01432256f, -0.01428307f, -0.07299047f, 0.02338149f, -0.08525090f, -0.04484753f, 
    0.04392813f, -0.04474624f, -0.02600432f, -0.04396906f, -0.01910746f, 0.02890451f, -0.04118796f, -0.06558453f, 
    0.01181219f, -0.02165133f, -0.02487543f, -0.05523819f, 0.00159258f, 0.01867166f, -0.01200588f, -0.08031320f, 
    -0.00282346f, -0.02953945f, -0.01688207f, -0.02926332f, -0.07279792f, -0.05881154f, 0.01404694f, -0.02597710f, 
    -0.07792851f, -0.07009568f, -0.04056288f, 0.00207142f, -0.06082363f, 0.00392546f, -0.09111410f, -0.06405424f, 
    -0.02603414f, -0.04915236f, -0.02014430f, -0.06164527f, 0.01354573f, -0.04743207f, -0.08020569f, -0.06295430f, 
    -0.07157922f, -0.01539450f, 0.02961716f, 0.02123709f, -0.02407202f, -0.03050539f, -0.00520600f, -0.06605886f, 
    -0.01666596f, -0.04884157f, -0.01156568f, 0.02086359f, -0.02663827f, 0.01562137f, -0.02179586f, -0.03409921f, 
    0.01330592f, -0.01534125f, -0.00181099f, -0.03304886f, 0.00344308f, -0.08815034f, -0.09155378f, -0.03046277f, 
    -0.06117093f, -0.06789915f, -0.03231550f, -0.03868799f, -0.03376912f, -0.04176063f, -0.07723787f, -0.04946869f, 
    0.02754970f, -0.01170077f, 0.01874884f, 0.00567704f, -0.01105962f, -0.06896508f, -0.00829377f, -0.03990952f, 
    -0.06805421f, 0.01462961f, -0.02211127f, -0.03835633f, 0.01430322f, -0.02786731f, 0.02182455f, -0.01211601f, 
    -0.06051754f, -0.04663110f, -0.11016636f, 0.01703431f, -0.05330810f, -0.06290350f, -0.03041458f, -0.05870660f, 
    -0.09522495f, -0.01630723f, -0.00810688f, -0.02403753f, -0.00313653f, -0.02636904f, 0.01154651f, -0.01360300f, 
    -0.01352649f, -0.05872890f, -0.03662179f, -0.00068899f, -0.01581137f, -0.00626811f, -0.03579348f, -0.05844390f, 
    -0.04769864f, -0.04701101f, -0.00301681f, -0.02938046f, -0.02185732f, -0.07095214f, 0.01888914f, -0.00127313f, 
    0.00733339f, 0.02430126f, -0.01262406f, -0.05969815f, -0.00347876f, -0.01908409f, -0.04909868f, 0.00191806f, 
    -0.05836562f, -0.00901204f, -0.01930852f, 0.00949216f, 0.01065768f, 0.01786429f, 0.01810259f, -0.09118946f, 
    0.00425727f, -0.06819802f, 0.01279538f, 0.01534816f, 0.01783246f, -0.00812058f, -0.01781693f, 0.00992776f, 
    0.00462459f, -0.06966758f, -0.07176213f, -0.00210883f, 0.00035082f, 0.02679996f, -0.05773542f, 0.01983452f, 
    -0.04200590f, -0.04502125f, -0.02311313f, 0.00942265f, -0.04961089f, 0.00163402f, -0.02923218f, -0.07453847f, 
    -0.02431148f, -0.00473125f, -0.05579712f, -0.07043054f, 0.02973588f, -0.07346318f, -0.01339339f, -0.04769182f, 
    -0.00184444f, -0.02900299f, -0.00883820f, -0.02515482f, -0.00230799f, 0.01837160f, -0.05702209f, 0.00789774f, 
    -0.02673782f, -0.03851642f, -0.02680713f, -0.06190199f, -0.04509301f, -0.07898314f, -0.00897656f, -0.05388615f, 
    -0.08815204f, -0.05860477f, -0.05352250f, -0.06598703f, -0.04060710f, -0.08214384f, -0.03992737f, -0.03452957f, 
    0.00480241f, -0.03251630f, -0.00084580f, 0.00324099f, -0.07542118f, -0.09384360f, -0.08221788f, -0.08142882f, 
    -0.02166854f, -0.04839733f, 0.01210779f, -0.01120342f, -0.08687646f, -0.07017308f, -0.07967131f, -0.06549329f, 
    -0.05671597f, -0.00958794f, -0.00742884f, -0.03579193f, -0.03426901f, 0.00509085f, -0.03798432f, -0.06620608f, 
    0.00127196f, -0.02285461f, -0.07654882f, 0.00480264f, -0.00922223f, -0.05697358f, -0.01155555f, 0.01819583f, 
    -0.04534159f, -0.01044234f, -0.03115868f, 0.03114044f, 0.00838845f, -0.01833987f, -0.01765016f, 0.01384045f, 
    -0.06010551f, -0.05505484f, -0.03021923f, -0.05717452f, -0.03107319f, -0.00060886f, -0.03681598f, -0.00974928f, 
    0.04132780f, 0.03575739f, 0.02244612f, 0.02931875f, -0.01993234f, -0.04778728f, 0.01367190f, -0.00135116f, 
    -0.00342759f, 0.02190153f, 0.00653045f, -0.06328268f, -0.04072890f, 0.00307299f, -0.02466589f, 0.00188130f, 
    -0.08212512f, 0.00694192f, -0.05913969f, -0.06197497f, -0.01319296f, -0.04325481f, -0.03040675f, -0.05350832f, 
    0.01382540f, 0.01700500f, -0.05189284f, -0.02877229f, 0.01273696f, -0.06500302f, 0.02814762f, 0.01095498f, 
    -0.06462291f, -0.04527064f, -0.00860294f, 0.01289703f, -0.00291973f, 0.01376796f, -0.00397854f, -0.01992874f, 
    0.03260279f, -0.00692066f, -0.02262844f, -0.03015048f, -0.05083532f, 0.01973476f, -0.02845737f, -0.01952802f, 
    -0.01384208f, 0.00082563f, -0.00965106f, -0.07769454f, -0.06751068f, -0.00221561f, -0.03163979f, -0.07909293f, 
    0.00812854f, -0.07830528f, -0.00747222f, -0.05251072f, -0.01167655f, 0.02537949f, -0.06208342f, -0.02368075f, 
    -0.01969462f, 0.00750486f, -0.05897290f, -0.05108671f, 0.01986174f, -0.05248367f, -0.02215745f, 0.01611788f, 
    -0.04560934f, -0.05222484f, -0.06291365f, -0.03696855f, -0.09079476f, 0.03029398f, 0.00597188f, 0.02191383f, 
    -0.05015847f, -0.04855616f, -0.02314091f, -0.08851561f, -0.01085808f, -0.02385532f, -0.03188397f, -0.08445513f, 
    0.00807953f, -0.02763195f, -0.07700656f, 0.00792246f, -0.06992799f, -0.03427586f, -0.07651499f, -0.02079494f, 
    0.00732759f, 0.00605063f, -0.03851040f, 0.01801425f, -0.05241507f, 0.02504429f, -0.00140979f, 0.01490477f, 
    -0.04626796f, 0.01471092f, 0.00933912f, -0.05453161f, -0.02934194f, 0.03175879f, -0.00807867f, 0.00564271f, 
    -0.06936406f, -0.03496369f, -0.04491686f, -0.03343321f, -0.00200363f, -0.03388379f, 0.00660970f, -0.08194764f, 
    0.01579694f, -0.03444012f, 0.03008063f, 0.04291587f, -0.04854929f, -0.01221257f, -0.06461368f, -0.01263430f, 
    -0.01098711f, 0.04091723f, -0.00124046f, 0.01401798f, 0.01269603f, 0.02341312f, 0.02512139f, -0.03602967f, 
    0.00768903f, 0.03546659f, 0.03057192f, -0.05508134f, 0.00426020f, 0.02047310f, -0.01930684f, -0.04626138f, 
    -0.00675567f, 0.01936789f, -0.00658204f, -0.05015803f, -0.02906130f, 0.00782516f, 0.00416600f, -0.05412526f, 
    0.04271354f, -0.00647098f, 0.03239832f, 0.02795631f, -0.03087405f, 0.00664685f, 0.01943244f, 0.00860440f, 
    -0.04709671f, -0.04163184f, 0.02221963f, 0.03043092f, 0.00548577f, 0.01480809f, 0.04542157f, -0.02781200f, 
    -0.01996098f, -0.01381181f, -0.05438842f, -0.01879000f, 0.02526746f, -0.03937479f, 0.00260167f, 0.03744807f, 
    -0.00908308f, 0.00867289f, -0.04184665f, -0.04561951f, -0.02739114f, 0.03451180f, -0.04625209f, -0.04643624f, 
    -0.02797703f, -0.03002127f, 0.04197793f, 0.03523029f, 0.04141403f, -0.02636765f, 0.00118617f, -0.03619612f, 
    -0.00708913f, 0.02866541f, -0.03564468f, 0.02276860f, -0.00833120f, 0.03666930f, 0.03258626f, -0.04796951f, 
    -0.03222343f, 0.02177857f, -0.01525932f, 0.00891597f, -0.00235051f, 0.03141198f, -0.00020370f, -0.00229568f, 
    -0.03149185f, 0.01125011f, -0.03717205f, 0.02402294f, -0.03821323f, 0.01671531f, 0.00723139f, 0.03085788f, 
    -0.03609205f, 0.00586808f, 0.04066227f, 0.00486533f, -0.03716048f, -0.03502589f, 0.03045217f, -0.04494107f, 
    0.01093406f, -0.00607071f, -0.01507370f, 0.02488346f, 0.02967252f, -0.04404314f, -0.02227216f, 0.04264473f, 
    0.01519966f, -0.01958014f, -0.04275825f, 0.00198401f, 0.02057028f, -0.03312244f, 0.02761288f, 0.02310452f, 
    0.03904404f, 0.01057796f, -0.03056693f, -0.00092850f, 0.01485490f, -0.05365479f, 0.00166528f, -0.01687844f, 
    0.00955991f, -0.02882636f, 0.02800038f, 0.04308550f, -0.02398041f, -0.00815683f, -0.02501908f, 0.01289621f, 
    -0.04459521f, -0.05563920f, 0.01507353f, -0.00482079f, 0.03185695f, -0.01658294f, -0.01621741f, -0.02559038f, 
    0.04574628f, -0.04922520f, 0.04173459f, -0.01581207f, 0.04375929f, 0.03810426f, 0.03391034f, -0.01191185f, 
    -0.01746785f, 0.02936765f, -0.01344785f, 0.01194465f, 0.03161268f, -0.02164140f, -0.01056843f, -0.01489672f, 
    0.03363547f, -0.04229772f, -0.04930450f, 0.03273892f, 0.00137435f, -0.02486006f, -0.00341650f, 0.04376106f, 
    0.03474334f, 0.00785225f, -0.01986457f, -0.00711805f, -0.05319967f, -0.02045110f, -0.03100566f, 0.03807304f, 
    -0.05391312f, -0.04403658f, -0.03963035f, -0.02287183f, -0.00109379f, -0.02243909f, 0.02637199f, -0.01356123f, 
    -0.04106488f, 0.01656876f, -0.04109176f, 0.03007305f, 0.02110163f, 0.02707813f, -0.02694686f, 0.03409893f, 
    -0.03314105f, -0.01309721f, -0.00212887f, 0.04264956f, -0.03355475f, 0.01024170f, 0.00889013f, -0.05157935f, 
    0.00970531f, -0.02717157f, -0.04395108f, -0.00700728f, -0.02840964f, -0.00997502f, 0.03718048f, -0.02977715f, 
    -0.02210832f, -0.03128665f, 0.03053168f, -0.00080838f, -0.03061238f, -0.01120019f, 0.02007836f, -0.01955263f, 
    0.00238248f, -0.00597631f, 0.01026088f, -0.00106274f, -0.01650177f, -0.03525027f, 0.01969801f, -0.05025416f, 
    0.01270851f, -0.01737207f, -0.02195110f, -0.03856766f, -0.04398572f, -0.05534568f, 0.03678909f, 0.04457837f, 
    -0.02646311f, -0.03516509f, 0.01296609f, -0.02705853f, 0.04691759f, -0.02283330f, -0.04785242f, 0.00824400f, 
    -0.02180767f, -0.05670264f, -0.05349657f, -0.03077625f, -0.02492389f, -0.05533202f, 0.02051553f, 0.03661310f, 
    0.00003117f, -0.00272435f, -0.03304694f, 0.04027471f, -0.03943030f, -0.03101078f, 0.04262386f, -0.05012120f, 
    0.03202315f, -0.02795503f, 0.04176062f, -0.01598408f, -0.03912291f, -0.03320945f, -0.04152495f, -0.00573874f, 
    -0.00365382f, -0.05276918f, 0.02574080f, 0.00764481f, 0.04290959f, -0.04278111f, -0.00602485f, 0.02829989f, 
    0.03067073f, 0.01910677f, 0.00545209f, -0.00483043f, -0.04320619f, 0.03367066f, 0.00178569f, -0.04067765f, 
    -0.03235931f, -0.04926626f, -0.03423728f, -0.03274471f, 0.02227262f, 0.03875985f, -0.01383515f, -0.05534283f, 
    -0.01225673f, 0.04400577f, 0.02495535f, 0.00132221f, -0.02138685f, -0.04369371f, -0.00502171f, 0.00205867f, 
    0.00541955f, -0.04943463f, 0.02360287f, -0.05483941f, -0.01379897f, 0.00744587f, -0.01807813f, -0.02484683f, 
    -0.03621295f, -0.03134200f, -0.00776886f, -0.05382496f, -0.03489523f, 0.03174959f, -0.04527577f, -0.05223235f, 
    0.02777218f, -0.05470164f, 0.04556329f, 0.02077877f, 0.00875974f, -0.00840376f, -0.02041977f, -0.02982911f, 
    -0.00319461f, -0.01498104f, -0.02653936f, -0.03462781f, -0.01382715f, 0.02489158f, 0.04655020f, -0.05323818f, 
    0.03400250f, -0.03306790f, -0.03256551f, 0.03516993f, -0.02982258f, -0.02394170f, 0.00266117f, -0.00436558f, 
    -0.03640025f, 0.03350328f, 0.05498810f, 0.00896021f, 0.02860274f, 0.01548534f, 0.02507551f, -0.04719558f, 
    0.00901457f, 0.04697593f, 0.00311179f, -0.02683726f, 0.01839286f, 0.04220490f, -0.02811993f, 0.02863403f, 
    -0.04212145f, -0.02547152f, 0.04021069f, 0.00662991f, 0.02324478f, 0.02141513f, -0.04408020f, 0.04414571f, 
    -0.03190244f, -0.00915980f, -0.02205298f, 0.04081111f, -0.00355278f, 0.05101475f, -0.04737419f, -0.04318491f, 
    -0.04466646f, 0.00480232f, -0.03794244f, -0.03775701f, -0.04733009f, 0.00388444f, 0.00957558f, 0.00644217f, 
    -0.01536160f, 0.01138208f, 0.00778410f, -0.03217544f, 0.03554608f, -0.03589846f, -0.03868254f, 0.01409579f, 
    -0.05215502f, -0.01681622f, -0.02835171f, -0.04920827f, -0.02819817f, 0.03410943f, -0.01664772f, 0.02748470f, 
    -0.11971211f, 0.10719591f, 0.10875533f, 0.19125775f, -0.16064209f, -0.03338711f, -0.05101644f, -0.04298177f, 
    -0.01584481f, 0.03285715f, -0.06734929f, -0.05937112f, -0.17494005f, -0.07965368f, 0.36974236f, 0.15123370f, 
    0.05738387f, 0.09958258f, 0.00059097f, -0.08156089f, 0.15084693f, 0.03398228f, 0.16210660f, -0.10623135f, 
    0.33676884f, -0.01601639f, 0.06219722f, -0.02917211f, -0.02078100f, -0.15510288f, 0.15866315f, 0.07858867f, 
    0.12527621f, 0.04245552f, 0.11079895f, -0.05129113f, 0.34325030f, 0.10634714f, 0.08087119f, -0.01779391f, 
    -0.06611069f, 0.05565206f, -0.02755687f, -0.12276464f, 0.06347205f, -0.06955960f, -0.06960680f, 0.01931057f, 
    -0.13239218f, -0.09605185f, -0.18224275f, 0.05858080f, 0.02686149f, 0.01801930f, 0.00341675f, 0.17953418f, 
    -0.06516448f, -0.04562034f, -0.00288244f, -0.04785384f, 0.23016253f, -0.24883153f, -0.03181256f, 0.23970976f, 
    0.04806482f, 0.14192410f, -0.06051887f, -0.11566813f, 0.15681833f, 0.03629929f, 0.02499155f, 0.13135886f, 
    -0.13524124f, -0.14934453f, 0.17064832f, 0.07402004f, 0.05248440f, -0.16434500f, -0.04241779f, 0.04324919f, 
    -0.02433735f, -0.06663276f, 0.02715946f, 0.07735927f, 0.06430068f, -0.15418181f, 0.20947522f, 0.07103582f, 
    0.07346103f, 0.04597941f, 0.04808239f, -0.08682168f, -0.10836228f, 0.00086131f, -0.07537868f, 0.10621758f, 
    0.47648051f, 0.11882145f, 0.23763850f, -0.01258271f, 0.02732755f, -0.07671195f, 0.02473204f, -0.05568134f, 
    0.04674636f, -0.05902471f, 0.02977935f, 0.15088035f, -0.41464370f, -0.19949088f, -0.07022066f, -0.15368696f, 
    -0.11071651f, -0.04766389f, 0.00479648f, -0.16268685f, 0.06905119f, 0.15398586f, -0.07825915f, 0.01761855f, 
    -0.22084355f, -0.32742736f, 0.06421734f, 0.14818570f, 0.00519875f, 0.06165823f, -0.04608041f, -0.04941643f, 
    0.03979351f, -0.06446289f, -0.00204081f, 0.04404632f, 0.13407899f, 0.10950781f, -0.00729610f, 0.01501565f, 
    -0.01925523f, 0.02298028f, -0.04024572f, -0.00098938f, -0.08833504f, 0.07015788f, -0.08152639f, 0.01158655f, 
    -0.00258577f, 0.21925157f, 0.07357001f, 0.16055800f, -0.04733701f, 0.03812407f, 0.02463355f, 0.00472195f, 
    -0.01933021f, 0.07431135f, 0.07209139f, 0.10507356f, -0.30716455f, 0.04056226f, 0.06932084f, 0.00182208f, 
    -0.09978856f, -0.09000726f, 0.07665958f, -0.06452689f, 0.03373149f, 0.06856140f, 0.00165113f, -0.08177593f, 
    -0.78232849f, -0.01225070f, -0.23241720f, 0.11855654f, -0.00434377f, -0.03794707f, -0.00242997f, 0.05203363f, 
    -0.06060468f, 0.09088778f, -0.00079883f, 0.11919367f, 0.20288996f, -0.04805418f, -0.09526934f, 0.00621811f, 
    -0.02604439f, -0.06453557f, -0.00342439f, -0.06760161f, -0.02801392f, 0.02652427f, -0.07341643f, 0.01803065f, 
    0.01112521f, 0.01204599f, 0.07644550f, 0.03592067f, 0.00200541f, -0.12883545f, 0.06380967f, 0.06563974f, 
    0.09514603f, 0.02706027f, -0.11507647f, -0.10835908f, -0.08100395f, -0.11424141f, 0.14838174f, 0.08715936f, 
    0.16208312f, 0.12146176f, -0.00563993f, 0.03873627f, 0.00280229f, -0.05416543f, 0.04322350f, 0.13433346f, 
    0.24983621f, -0.06054841f, 0.10186119f, 0.07151566f, 0.09111884f, -0.09733503f, 0.16328248f, -0.12726134f, 
    -0.04486185f, 0.07422024f, -0.12131678f, -0.02103239f, -0.06685787f, 0.00695308f, 0.01149481f, 0.03563816f, 
    0.00631933f, 0.13211165f, -0.00156155f, 0.07228185f, 0.00716774f, -0.01804699f, 0.00387039f, 0.01876059f, 
    0.09688517f, -0.08763010f, 0.01171482f, -0.07319102f, -0.01878744f, 0.11196292f, 0.15740632f, 0.00867216f, 
    -0.03754092f, -0.02163553f, -0.02971190f, -0.00693051f, 0.06255494f, -0.08404105f, 0.04631503f, 0.07080452f, 
    0.03342595f, 0.00884217f, -0.02983230f, -0.04779488f, 0.01889729f, -0.04888105f, 0.01305543f, 0.09285190f, 
    -0.00188948f, -0.03268795f, -0.15803042f, -0.03970822f, 0.04574410f, 0.03515117f, 0.02552969f, -0.09203341f, 
    -0.00001908f, -0.00866989f, 0.03740429f, 0.03313389f, 0.05346111f, -0.00326367f, 0.09175517f, -0.07330438f, 
    0.01498174f, -0.02311537f, -0.03350893f, 0.04845090f, -0.03389038f, 0.08397829f, 0.15558100f, -0.01004537f, 
    0.00750639f, 0.00296175f, 0.03718030f, 0.03807549f, 0.05902783f, -0.02067029f, -0.03006089f, -0.06000106f, 
    0.04965092f, 0.02180919f, -0.05614335f, 0.00028667f, -0.05796418f, -0.13101530f, -0.00144065f, 0.21544811f, 
    -0.01060664f, -0.02975567f, -0.14918000f, 0.01229414f, 0.13177174f, 0.10842036f, 0.00477144f, -0.07193404f, 
    0.28661394f, 0.04195490f, -0.02739869f, 0.01298324f, -0.10363838f, -0.02316754f, 0.06037290f, -0.07367591f, 
    0.02766016f, 0.02183480f, -0.06261951f, -0.01216623f, -0.21470284f, -0.00570392f, 0.14380246f, 0.22344288f, 
    -0.00567722f, 0.07441673f, 0.03046549f, 0.10067192f, -0.06241992f, -0.07173779f, 0.03345639f, 0.05547962f, 
    -0.08218946f, 0.05401224f, 0.01872996f, 0.22841057f, -0.08079024f, -0.05530272f, 0.07758325f, -0.02031458f, 
    -0.01618651f, 0.03474521f, 0.06670311f, 0.02811195f, -0.17739372f, 0.01649731f, -0.07911786f, 0.07050726f, 
    -0.00239731f, 0.02359349f, -0.08887795f, -0.01743921f, 0.08123781f, -0.04963254f, 0.07636687f, 0.02926771f, 
    0.13022074f, 0.03409373f, -0.05746057f, 0.01909764f, -0.04776611f, -0.07585727f, 0.00799720f, -0.01112850f, 
    0.18190764f, 0.02206669f, -0.01633423f, -0.01168367f, 0.07228397f, -0.00328427f, 0.13153870f, 0.09958346f, 
    0.00877571f, -0.02984576f, 0.01249469f, -0.02576379f, -0.01413242f, 0.02344056f, -0.21829560f, -0.01119871f, 
    -0.03683724f, -0.02384757f, 0.08212404f, 0.05908968f, 0.16205299f, 0.17469731f, 0.02566470f, 0.04816059f, 
    0.08662371f, 0.06033398f, 0.10883565f, 0.07869653f, -0.25004563f, 0.43706608f, -0.14327781f, 0.08436174f, 
    0.21074164f, -0.06194813f, 0.02252748f, 0.16821432f, 0.17804684f, 0.09880155f, 0.01473152f, 0.15454422f, 
    -0.30867225f, 0.01775426f, -0.13323778f, -0.04529967f, -0.03458619f, 0.08853168f, 0.01013464f, 0.05065855f, 
    0.20749292f, -0.01848621f, -0.19867653f, -0.01813666f, -0.07676418f, -0.05570772f, -0.00520268f, 0.15840615f, 
    -0.10090093f, 0.10687026f, -0.11157200f, 0.20957865f, 0.04258292f, 0.01274243f, 0.09351691f, 0.06739343f, 
    0.13860454f, 0.08181096f, 0.14804621f, -0.06736807f, 0.14132497f, 0.11331598f, 0.18312152f, -0.06052934f, 
    0.07423114f, 0.03016158f, -0.00723172f, 0.15083043f, -0.49736497f, 0.40596342f, 0.02926623f, -0.28523579f, 
    0.02271836f, -0.09213915f, 0.00765965f, -0.01863482f, -0.00925793f, -0.04395816f, 0.02876712f, -0.00167383f, 
    -0.03933359f, 0.10065990f, -0.00360789f, 0.26775274f, -0.01756095f, 0.14566787f, 0.03239651f, 0.01602604f, 
    0.08381076f, 0.06547245f, 0.05767768f, -0.01372050f, 0.02499297f, 0.13374466f, 0.03484818f, -0.12998928f, 
    0.06678310f, 0.09810024f, -0.02328639f, 0.06425806f, -0.00458494f, -0.14575677f, -0.01194073f, -0.23490386f, 
    -0.19268140f, -0.22834755f, -0.29922637f, -0.01728100f, 0.08732680f, 0.11504467f, 0.05443342f, 0.00411372f, 
    0.00925261f, 0.07572859f, 0.04726835f, -0.10570640f, 0.13772736f, -0.03871959f, -0.08408520f, 0.06317519f, 
    0.17494151f, 0.08699069f, 0.02663156f, 0.15141062f, 0.04348744f, 0.03284908f, 0.07447013f, 0.06018192f, 
    -0.20958912f, 0.40543535f, -0.11992642f, 0.17432535f, -0.00581913f, -0.05486992f, -0.05411248f, 0.03185818f, 
    0.08209652f, -0.05115869f, -0.08059325f, 0.04137589f, -0.26270348f, -0.21186292f, -0.00998163f, -0.09575048f, 
    0.05093968f, 0.05238642f, -0.00157070f, 0.01359642f, -0.11027110f, -0.23428366f, 0.01001846f, -0.24256307f, 
    -0.28582999f, -0.07894948f, 0.00431949f, 0.06274711f, 0.09907850f, 0.12641551f, -0.02252902f, 0.04732218f, 
    0.18240429f, 0.14400247f, -0.24018644f, 0.00354400f, -0.01721527f, 0.09717195f, -0.14416106f, 0.06705806f, 
    0.08218137f, 0.12038705f, 0.06572615f, 0.14267734f, -0.06380003f, -0.02005720f, -0.05295366f, -0.02692408f, 
    -0.35203913f, -0.22831461f, 0.02668698f, -0.03747603f, 0.06661849f, -0.12494323f, 0.12445769f, 0.19638604f, 
    0.05067835f, 0.04772837f, 0.06792546f, 0.03829506f, -0.02723734f, 0.04682757f, 0.16012523f, 0.10922678f, 
    -0.03833494f, 0.09553088f, -0.00663247f, -0.07016302f, 0.02050068f, 0.08202562f, 0.08731239f, 0.03210496f, 
    0.05705084f, 0.05257215f, -0.02965841f, 0.02819752f, -0.05064182f, 0.03001864f, 0.08694270f, -0.01127126f, 
    0.12901312f, -0.01053139f, 0.04956429f, 0.18593672f, 0.10693182f, 0.06546404f, 0.18675713f, -0.10005002f, 
    -0.11316660f, -0.11209510f, -0.03667273f, 0.20995131f, 0.06116117f, 0.14138836f, -0.00523710f, -0.04458264f, 
    -0.02823723f, -0.05924265f, 0.09727544f, -0.06280089f, 0.02541448f, 0.18660118f, -0.06709955f, 0.10120849f, 
    -0.00381537f, 0.03384347f, 0.12073679f, 0.05812457f, -0.01768198f, 0.00700256f, 0.02526770f, 0.01906329f, 
    -0.00738656f, -0.03022519f, 0.00387977f, 0.02068912f, -0.01713636f, 0.09742951f, -0.00479373f, 0.00454307f, 
    -0.09312110f, -0.01671023f, 0.01811148f, -0.01970877f, 0.00819024f, 0.01260211f, -0.08994087f, -0.06237088f, 
    0.02062006f, -0.04866882f, -0.01693716f, 0.14257246f, -0.04289690f, -0.01642310f, -0.11524843f, -0.00834706f, 
    -0.04364372f, -0.03343812f, -0.10046782f, -0.07118756f, -0.04735677f, 0.00500696f, 0.06687894f, -0.01826872f, 
    -0.00654103f, 0.00316103f, 0.02558676f, 0.03409304f, 0.05221074f, 0.01479473f, -0.00235782f, 0.08251115f, 
    0.00317944f, 0.00206038f, -0.07682008f, -0.20159861f, -0.19465815f, 0.00573563f, -0.05099595f, 0.05118478f, 
    -0.04570242f, -0.09773358f, -0.05629366f, -0.00203604f, 0.16798820f, -0.03310120f, 0.13296789f, 0.15183206f, 
    -0.21269196f, 0.01791060f, -0.12774105f, 0.02355678f, -0.05830057f, -0.10178881f, -0.01906757f, -0.03943646f, 
    0.03862348f, -0.01637962f, 0.15341106f, 0.03439755f, 0.00787595f, 0.06073150f, 0.01592905f, -0.02700436f, 
    0.01615235f, -0.05348608f, 0.01782674f, -0.07855989f, 0.03099919f, 0.03177864f, 0.03907921f, 0.05315661f, 
    0.16774675f, -0.04567988f, 0.08488712f, 0.02343263f, -0.03262924f, 0.07648523f, -0.05587098f, 0.07509516f, 
    -0.11253640f, -0.03319217f, 0.02130230f, -0.06258425f, -0.08624257f, 0.02656255f, -0.08263192f, -0.01697176f, 
    -0.03186696f, 0.08683567f, 0.27427652f, -0.06554371f, 0.08072623f, 0.07893425f, -0.12049580f, -0.04127624f, 
    -0.02773743f, -0.07513460f, 0.00416184f, -0.01005207f, 0.07457846f, -0.03415275f, -0.11628439f, -0.07309482f, 
    0.15519224f, -0.12944368f, -0.04334587f, 0.04807480f, 0.15477876f, -0.05135997f, 0.03229667f, 0.00979539f, 
    0.12048928f, -0.05020861f, 0.08333821f, 0.00718028f, 0.00005613f, -0.06604722f, -0.15073234f, -0.20012291f, 
    -0.05560061f, -0.01299752f, -0.00734487f, -0.02063248f, -0.01568303f, -0.03891592f, -0.03926389f, 0.02989065f, 
    -0.05899740f, -0.03005264f, -0.06854717f, -0.15070333f, -0.18906011f, -0.13447851f, 0.13260725f, 0.11165443f, 
    0.00492783f, -0.10471539f, -0.10841886f, -0.04605927f, -0.00836373f, -0.00555255f, 0.20624414f, 0.19024934f, 
    0.08425764f, -0.08043924f, -0.11865222f, -0.17079543f, -0.05030547f, 0.11379134f, 0.11326053f, 0.03606109f, 
    -0.01251945f, -0.04136519f, 0.05080948f, 0.02497706f, -0.09941941f, -0.13602768f, 0.07907356f, 0.22945262f, 
    0.05213761f, 0.00983851f, -0.00509931f, 0.14076932f, 0.10151689f, -0.06442790f, 0.11820037f, 0.07940782f, 
    -0.11761525f, 0.10321802f, 0.05180707f, -0.00049945f, 0.02942373f, 0.03476113f, -0.05236556f, -0.22900555f, 
    -0.05206610f, -0.07155205f, -0.12775783f, 0.14076960f, -0.18307045f, -0.23131737f, 0.21235153f, -0.14476268f, 
    0.02411778f, 0.06313786f, -0.13608046f, 0.17081340f, 0.03564761f, 0.05975575f, 0.04549274f, 0.00409225f, 
    0.39659449f, 0.04046635f, 0.00418922f, -0.18996401f, 0.07592130f, -0.04641990f, 0.01001024f, -0.04136359f, 
    0.07909822f, 0.04466783f, 0.05357444f, 0.01430248f, -0.13523452f, 0.13170610f, -0.11723886f, -0.00045351f, 
    -0.03277007f, -0.02766605f, 0.07334207f, 0.01704171f, 0.01458784f, 0.07207164f, 0.23328544f, -0.00430262f, 
    0.09426930f, -0.05127711f, -0.27381927f, -0.21209766f, 0.01999248f, 0.09786351f, 0.02793742f, 0.05126115f, 
    0.01081697f, 0.09680237f, 0.00206951f, 0.07769413f, -0.08080834f, -0.00753450f, -0.01991050f, -0.00758824f, 
    -0.00852492f, 0.02088059f, -0.05210824f, 0.07664264f, -0.00669157f, 0.14111546f, 0.07096002f, 0.01284955f, 
    -0.00528428f, 0.19207972f, 0.18238655f, 0.04706305f, 0.01743300f, 0.04646925f, -0.04250795f, 0.04498408f, 
    0.08521125f, 0.05396800f, 0.07433204f, 0.03589313f, 0.17337599f, -0.01373186f, 0.11070292f, -0.00354731f, 
    0.18652770f, -0.02579676f, 0.05373069f, 0.22277337f, 0.12326688f, -0.01340376f, 0.07735664f, -0.02657711f, 
    0.16593570f, 0.28792515f, -0.06080918f, -0.01500998f, 0.01571589f, 0.02013393f, -0.03812990f, -0.03121663f, 
    -0.05007880f, -0.08154011f, 0.05725355f, 0.03048859f, -0.05174839f, -0.09602728f, 0.04880499f, 0.23345757f, 
    0.00936293f, -0.03877516f, -0.00278778f, -0.02691852f, 0.11822494f, -0.04878306f, 0.20421582f, -0.01775962f, 
    -0.14594224f, -0.00489131f, 0.21437182f, 0.09666774f, 0.00341140f, 0.02760713f, 0.01650797f, 0.09341002f, 
    0.10368657f, -0.20527941f, -0.07959801f, -0.11505850f, 0.10052262f, 0.00716844f, -0.02878821f, 0.08307768f, 
    -0.06947317f, 0.04861759f, 0.08598069f, 0.10467603f, 0.01703486f, -0.02602181f, -0.03018090f, 0.02007931f, 
    -0.02609720f, 0.25791314f, 0.00938157f, 0.29929912f, 0.10481837f, -0.03231008f, 0.05362446f, -0.10074968f, 
    0.06677863f, -0.06228255f, -0.04060682f, 0.17948231f, 0.02335063f, -0.05023982f, -0.02852840f, 0.02323177f, 
    0.07867211f, 0.06806433f, 0.09915848f, 0.00875137f, -0.09855964f, 0.02153174f, -0.01640380f, 0.07156736f, 
    -0.10005458f, 0.10830472f, 0.16434842f, 0.20037834f, 0.04388027f, 0.02508379f, -0.06209851f, -0.16571829f, 
    0.03810482f, -0.00271557f, 0.10709456f, 0.06767217f, -0.04648304f, -0.09127077f, -0.10127893f, -0.37126258f, 
    -0.14110777f, 0.03943759f, -0.06005875f, 0.14001024f, 0.13578603f, 0.07314247f, -0.06574816f, 0.02065360f, 
    -0.16283365f, -0.21374224f, -0.04359084f, 0.16564186f, 0.02560605f, 0.09268121f, -0.02409873f, 0.15483241f, 
    -0.03045805f, 0.02213865f, 0.18865299f, -0.00985641f, 0.10979642f, -0.07681765f, -0.04248749f, -0.19378999f, 
    -0.10275401f, 0.02882845f, 0.06243697f, 0.07126913f, 0.03104847f, 0.00969189f, 0.01580705f, -0.01977628f, 
    0.00628242f, -0.04355590f, -0.01496735f, 0.02098853f, 0.02853530f, 0.01669164f, 0.04056980f, 0.13543281f, 
    -0.08846129f, -0.00281244f, 0.08905078f, 0.04340523f, -0.05151780f, -0.07102160f, 0.01743995f, -0.03303904f, 
    -0.04173100f, 0.00875903f, -0.02184816f, 0.05135147f, -0.04303348f, 0.05123311f, 0.06600647f, -0.01468658f, 
    -0.13695827f, 0.11835683f, -0.03561569f, 0.05170619f, 0.03562546f, -0.05851429f, 0.05378382f, -0.00429983f, 
    0.11737594f, 0.09878755f, 0.09340355f, 0.04067837f, -0.11075724f, 0.01458808f, -0.00882678f, 0.07759122f, 
    0.07769880f, 0.04050098f, -0.02672251f, -0.03354347f, 0.07008807f, -0.01381409f, -0.02663553f, 0.10759646f, 
    -0.16841944f, 0.03434607f, -0.01709569f, 0.08840426f, -0.02669659f, 0.05691360f, 0.04387268f, -0.05490497f, 
    0.07857251f, 0.05660978f, 0.12621695f, 0.07957368f, 0.13938795f, 0.12559861f, -0.08869290f, -0.11365818f, 
    0.13561700f, 0.04354832f, 0.15651575f, -0.09344144f, 0.01590185f, 0.05323343f, 0.09636843f, 0.04658130f, 
    -0.21099819f, -0.12835677f, -0.08926923f, -0.03295279f, 0.06253961f, 0.04456718f, 0.00727839f, 0.13472307f, 
    -0.00417633f, -0.05540205f, -0.10303187f, -0.06791500f, 0.12463015f, 0.12142514f, -0.21688335f, -0.22374904f, 
    -0.14049785f, -0.13637103f, -0.06861694f, -0.04672205f, -0.08396633f, -0.04873536f, -0.13202828f, 0.00675489f, 
    0.11703556f, 0.24388456f, 0.04867496f, 0.05545629f, 0.12263897f, -0.05387208f, 0.02442308f, 0.10564875f, 
    -0.04570724f, -0.05998258f, -0.00910181f, 0.05168212f, -0.09872245f, 0.04949024f, 0.15140437f, 0.08528990f, 
    0.09862775f, 0.09289379f, 0.14432622f, -0.05486789f, 0.06259996f, 0.09607906f, 0.06909797f, -0.02342730f, 
    -0.12826602f, -0.01061746f, -0.08014104f, -0.01356700f, 0.04144666f, 0.00577222f, 0.04301289f, -0.02956208f, 
    -0.01508816f, 0.03122490f, 0.03097036f, 0.07649212f, -0.18400930f, -0.08235650f, -0.04972825f, -0.08276109f, 
    -0.02282480f, 0.01135560f, -0.00428981f, 0.02336593f, 0.01372128f, -0.00056037f, 0.23096517f, 0.08665724f, 
    -0.16726381f, -0.11136350f, 0.04356429f, 0.04109211f, 0.12092157f, -0.15392549f, -0.04923728f, -0.05898634f, 
    -0.01589149f, -0.04678917f, -0.01272779f, 0.04525068f, -0.02977978f, 0.45001331f, -0.16991253f, -0.00406055f, 
    0.03139191f, -0.06481021f, -0.12682417f, 0.07259261f, -0.20612668f, -0.00469837f, -0.11879761f, 0.05065142f, 
    -0.18899244f, 0.01768579f, -0.02838288f, 0.14144130f, 0.09403577f, -0.02139323f, -0.11349452f, -0.10992889f, 
    0.07286468f, -0.05557277f, 0.03860451f, 0.09416153f, -0.29941678f, 0.13956761f, 0.02504458f, -0.04295898f, 
    0.12407399f, 0.02353912f, 0.06771153f, 0.01384346f, 0.15107106f, -0.01334019f, 0.15584430f, 0.13301831f, 
    -0.01718714f, -0.15401612f, 0.21738613f, 0.19356532f, 0.05084010f, 0.15994570f, 0.07730924f, 0.03193913f, 
    -0.02169478f, -0.08405355f, -0.04694894f, -0.07087133f, -0.00800318f, -0.01106256f, 0.21313399f, -0.22875297f, 
    0.00610323f, -0.15467972f, 0.01228583f, 0.08343489f, -0.18616308f, 0.10922799f, 0.00470454f, 0.02821672f, 
    -0.18026502f, 0.09249794f, 0.09879153f, 0.30957928f, -0.03016070f, 0.07558097f, 0.20904838f, -0.06639731f, 
    -0.02835244f, 0.05743451f, -0.08879762f, -0.07809317f, -0.06177877f, 0.13060227f, 0.20656468f, 0.01332254f, 
    0.02366559f, -0.09118200f, 0.00712056f, -0.00470246f, 0.14182252f, 0.02289158f, 0.04096780f, -0.07322837f, 
    -0.35851559f, 0.29311901f, 0.19656770f, 0.27048954f, 0.03486292f, -0.02069630f, 0.10564023f, 0.05814361f, 
    -0.03307890f, 0.07348589f, 0.04038848f, -0.00382039f, 0.06475990f, 0.00804792f, 0.00949720f, 0.16775931f, 
    0.06804495f, 0.05875197f, -0.03950593f, -0.04555259f, 0.02400205f, 0.04068181f, -0.02979416f, 0.08222857f, 
    -0.00315989f, 0.18490499f, 0.40766323f, 0.33892244f, 0.05736513f, 0.10161318f, 0.00937404f, -0.01144253f, 
    -0.02774063f, 0.02566393f, -0.10062785f, 0.04819223f, -0.14719893f, -0.09042079f, 0.16049501f, -0.17691173f, 
    0.02545245f, 0.05819336f, 0.02420004f, 0.09160194f, -0.00087013f, 0.03161758f, 0.02245482f, 0.08785205f, 
    -0.13314876f, 0.09098279f, 0.16605346f, 0.16239284f, -0.04755944f, 0.02239391f, -0.08702584f, 0.13747418f, 
    0.01483513f, -0.03592227f, -0.09289177f, -0.04428603f, 0.18637297f, 0.16675377f, -0.05050942f, 0.16537677f, 
    0.13130799f, 0.01614439f, 0.02882212f, -0.04288952f, 0.07523443f, 0.03788235f, -0.05788945f, 0.16302815f, 
    0.07707265f, -0.42156118f, 0.11123074f, -0.08443467f, -0.00652787f, 0.02229560f, -0.03070294f, 0.01247523f, 
    0.19971965f, 0.00109938f, 0.08323094f, -0.02471551f, -0.31197923f, -0.16058636f, 0.25755346f, 0.15449211f, 
    0.06857020f, 0.09549043f, -0.02238707f, 0.14061913f, -0.07645123f, -0.05619028f, 0.00381509f, 0.03470321f, 
    -0.02949437f, -0.04595054f, 0.01934999f, 0.16030964f, -0.01593301f, -0.08296186f, 0.06497584f, 0.00012156f, 
    -0.10690445f, 0.08033326f, 0.02025901f, 0.12821804f, 0.20372021f, 0.08898497f, 0.04422008f, 0.01681807f, 
    0.02962090f, -0.23981875f, 0.02998565f, -0.12592845f, 0.05649437f, -0.00692916f, 0.05320271f, -0.07041474f, 
    -0.30722538f, 0.27374324f, 0.19471480f, -0.15298095f, 0.07591444f, 0.11751252f, -0.11530891f, -0.08419672f, 
    -0.05023951f, -0.14249291f, 0.03250499f, -0.06165693f, -0.00145446f, -0.00074320f, 0.09173559f, 0.07692906f, 
    0.19101952f, 0.01814463f, -0.06462497f, -0.11633743f, 0.01590756f, 0.05451281f, 0.02903423f, 0.07944663f, 
    -0.12946229f, 0.08663853f, -0.00533676f, 0.05421501f, 0.01181350f, 0.04609389f, -0.06988219f, -0.00833147f, 
    0.13353199f, -0.05636834f, -0.09350211f, 0.06619032f, -0.11136357f, -0.20811850f, -0.26855540f, 0.01512044f, 
    0.35042453f, 0.03644417f, -0.13923764f, 0.04664598f, 0.12232737f, 0.08689324f, 0.05195417f, 0.06041211f, 
    0.05730621f, -0.12861778f, -0.23081088f, 0.23809482f, 0.02730282f, 0.13695808f, -0.04511381f, -0.11592617f, 
    0.18741806f, 0.10096286f, 0.06237599f, 0.06154850f, 0.15066938f, -0.08848348f, 0.13348788f, -0.02513789f, 
    0.07326994f, -0.26879036f, -0.02184455f, 0.02450570f, 0.02837848f, 0.00226211f, -0.10438827f, -0.08330184f, 
    0.11655012f, -0.22401404f, -0.23877983f, -0.05242670f, 0.04430171f, -0.11524555f, -0.12123965f, 0.06196604f, 
    0.11036695f, 0.06092362f, -0.00521117f, 0.02572210f, -0.22417435f, -0.17088540f, 0.13290653f, -0.09436592f, 
    -0.02628853f, -0.09805726f, 0.03258177f, 0.19889674f, -0.09024645f, 0.06958606f, 0.11597905f, 0.10346630f, 
    0.19854696f, -0.04929164f, -0.09470810f, 0.03328274f, -0.03667108f, 0.12240411f, 0.06384724f, 0.13313232f, 
    0.22118035f, 0.09792220f, 0.09701192f, -0.08949509f, 0.06043241f, 0.01580252f, 0.06731813f, 0.07617037f, 
    0.12844022f, -0.00515386f, -0.13321972f, -0.05686419f, 0.15794122f, 0.04987678f, -0.06573302f, 0.05179157f, 
    -0.03456521f, -0.10440123f, 0.15156665f, 0.06601809f, -0.04497155f, 0.01267115f, -0.07832700f, 0.09833966f, 
    0.09411893f, -0.04574267f, -0.05766329f, 0.06691577f, 0.11511336f, -0.08920696f, 0.03797901f, 0.00599537f, 
    0.01324519f, -0.05899555f, 0.08251289f, 0.07942781f, -0.06245537f, -0.06318284f, 0.06066004f, 0.14826952f, 
    -0.15613170f, -0.24382482f, -0.28321683f, -0.01347280f, 0.12241556f, -0.04421828f, 0.04484764f, -0.01595905f, 
    0.15254079f, 0.15008749f, -0.02307662f, 0.12855336f, -0.14023004f, -0.04368546f, -0.26679632f, 0.01155063f, 
    0.10045244f, -0.18599537f, -0.17303894f, -0.08304559f, -0.11812907f, -0.06662210f, -0.00030839f, 0.06538507f, 
    -0.04772369f, -0.01131410f, 0.02029677f, 0.04704797f, 0.04334078f, 0.02242892f, -0.04337934f, -0.03305925f, 
    -0.03616462f, -0.05098464f, -0.02602879f, 0.03720963f, 0.00779458f, 0.00809505f, -0.02055048f, -0.04843230f, 
    -0.01173534f, 0.03220584f, -0.01647062f, -0.01140047f, 0.01620011f, 0.03015298f, 0.01897066f, 0.01975731f, 
    -0.00564362f, -0.04477835f, -0.02874740f, -0.04323137f, -0.03824282f, -0.04720457f, 0.01914362f, 0.02788084f, 
    -0.03156680f, 0.00859741f, -0.00558868f, -0.00642565f, -0.02729034f, 0.00048170f, -0.03797999f, -0.00701931f, 
    -0.04828130f, -0.05021355f, -0.02172581f, 0.03889212f, -0.02667739f, 0.02025826f, -0.04341582f, -0.01383719f, 
    -0.04752062f, -0.03078642f, -0.00579041f, 0.04214047f, 0.03076980f, 0.00520536f, -0.05573144f, -0.02431889f, 
    -0.03190547f, -0.02332992f, 0.03323408f, -0.05967975f, 0.00233463f, 0.03271172f, -0.05494258f, 0.03878084f, 
    0.00563535f, -0.00814564f, 0.02110909f, 0.00736713f, 0.04283179f, 0.00368535f, 0.02235803f, 0.04175702f, 
    -0.05124816f, -0.03950736f, -0.01989990f, -0.05602462f, 0.01087277f, -0.00385252f, 0.03246190f, -0.05335122f, 
    0.03451827f, -0.02971853f, -0.04513130f, 0.01725032f, 0.01514685f, 0.02997350f, -0.00469574f, 0.01636209f, 
    -0.00629538f, 0.00221706f, -0.00202535f, -0.02763540f, -0.01364308f, -0.01089567f, -0.03643078f, -0.01634274f, 
    -0.04093216f, -0.05934766f, 0.01260885f, -0.03916061f, -0.02651715f, -0.04205258f, -0.04452297f, 0.02606132f, 
    0.00720437f, 0.02887109f, -0.02659839f, 0.02216263f, 0.03976607f, -0.04945804f, 0.03388281f, 0.03752604f, 
    -0.02202344f, -0.00816687f, -0.04987603f, -0.01346292f, -0.05638438f, -0.00810240f, 0.03780090f, 0.01271316f, 
    -0.04073004f, -0.05705215f, -0.02243451f, -0.01032114f, 0.04511878f, -0.05006565f, 0.01133878f, 0.02493477f, 
    -0.02259123f, 0.01205700f, 0.04413057f, -0.01829321f, -0.02843168f, 0.03525257f, -0.03529375f, 0.03281074f, 
    -0.00471390f, 0.01841056f, 0.03386566f, 0.02179221f, -0.02983715f, 0.00002321f, -0.00488845f, -0.03909265f, 
    0.01931476f, -0.06069758f, 0.03099569f, -0.02258690f, -0.00428004f, -0.05743022f, -0.04602531f, -0.02942145f, 
    -0.05569052f, -0.01856430f, -0.01370130f, -0.02894229f, 0.03526907f, -0.03694357f, -0.02872034f, -0.03282316f, 
    -0.00545251f, -0.00374104f, 0.03763786f, 0.01240582f, -0.03732141f, -0.02062966f, -0.00995956f, -0.03758235f, 
    0.02594553f, 0.04610233f, 0.00289375f, -0.00977252f, 0.00890102f, -0.04823370f, -0.05322847f, 0.01095841f, 
    -0.02260740f, -0.02112070f, -0.04893451f, -0.02392201f, 0.03016498f, 0.02324050f, -0.00849053f, 0.01653052f, 
    0.00405364f, 0.03740158f, -0.05562255f, -0.02973356f, -0.00337122f, 0.01573028f, 0.00983941f, 0.01371596f, 
    -0.06123735f, -0.00661677f, -0.02567600f, -0.04180831f, -0.00811857f, -0.01869917f, 0.03139169f, -0.04109073f, 
    0.00673863f, 0.00579905f, 0.03000700f, 0.00328589f, -0.03209697f, 0.00180434f, -0.02780274f, -0.02110822f, 
    -0.01471571f, -0.03904606f, 0.00247161f, -0.03797701f, 0.03270225f, 0.00111367f, 0.01676206f, 0.01325665f, 
    0.03199927f, 0.00819956f, -0.01463678f, 0.00772144f, 0.00442114f, -0.05332347f, 0.00998538f, -0.04830118f, 
    -0.04777182f, -0.04579677f, 0.03159784f, -0.04250032f, 0.02431486f, 0.04474441f, -0.05606332f, -0.03148873f, 
    0.01474588f, 0.00868678f, -0.06038377f, 0.01212560f, -0.02687064f, -0.00551559f, 0.02663299f, 0.02470509f, 
    0.03374797f, -0.00722859f, 0.01482100f, -0.02127190f, 0.03557695f, -0.02434231f, -0.05314688f, 0.00261963f, 
    -0.01341034f, -0.03617628f, 0.00958473f, 0.03529366f, 0.04861339f, -0.01656536f, 0.01529263f, -0.01911720f, 
    0.00142044f, -0.00388222f, -0.05202992f, 0.04220120f, -0.01112458f, -0.03380828f, 0.00696103f, -0.01360003f, 
    -0.02685810f, 0.03953957f, -0.02357905f, 0.00610722f, -0.00969580f, -0.00906176f, 0.04153736f, -0.04201074f, 
    -0.01089410f, -0.00907366f, -0.03975386f, 0.01608967f, -0.01069561f, -0.05888458f, -0.04620946f, -0.05615083f, 
    0.00153433f, 0.02738986f, 0.00816975f, 0.03018974f, 0.03165461f, 0.01480076f, 0.03713070f, -0.03813624f, 
    -0.03905619f, 0.03443997f, -0.03781463f, -0.04241513f, -0.01092027f, 0.03621202f, -0.01737726f, -0.04614814f, 
    -0.00135610f, 0.01319654f, -0.02794524f, -0.00078371f, 0.00261626f, -0.04042299f, 0.00943761f, -0.00362869f, 
    -0.01359212f, 0.00391721f, 0.03322325f, 0.01044774f, -0.00391686f, -0.03282914f, -0.05025064f, -0.00184987f, 
    -0.03819236f, 0.00572330f, -0.03278568f, -0.02333728f, 0.01839705f, -0.00593389f, -0.00019640f, -0.02424782f, 
    -0.00243331f, 0.02583309f, -0.04334464f, -0.05140219f, -0.02126796f, 0.01043376f, 0.04746447f, -0.04404140f, 
    0.03440619f, 0.02423205f, -0.05311657f, -0.01996383f, -0.03639742f, -0.02113019f, 0.01824857f, -0.00649449f, 
    -0.00072972f, -0.05763803f, -0.05850626f, -0.00566009f, 0.03958257f, 0.03011326f, -0.05114685f, 0.03746096f, 
    -0.03422367f, -0.05009276f, -0.01532762f, -0.00105670f, -0.05428939f, 0.00560706f, 0.04313523f, 0.00510402f, 
    -0.03394141f, 0.02210000f, -0.04268738f, 0.03548273f, -0.04300534f, 0.03919760f, 0.03440817f, -0.04753451f, 
    0.01549486f, 0.03856133f, 0.00586101f, -0.00399653f, -0.04535284f, -0.04386611f, 0.00305643f, 0.02718109f, 
    0.00076912f, -0.00373088f, 0.03853211f, 0.00676438f, -0.01803168f, -0.04732605f, -0.02355522f, -0.05782704f, 
    0.03017393f, -0.04349298f, -0.02404886f, -0.03680570f, -0.03330890f, -0.00495738f, 0.03538712f, -0.01491166f, 
    -0.20950307f, -0.34950095f, -0.12523150f, -0.59162694f, -0.06432482f, -0.11549377f, -0.14671229f, -0.10770483f, 
    -0.12683761f, -0.06587962f, -0.04936746f, -0.06485459f, -0.24050304f, 0.05364203f, 0.20895119f, 0.29122543f, 
    0.17141704f, 0.37289286f, -0.14311923f, -0.11099775f, 0.12727122f, -0.05363068f, 0.17290652f, -0.04460810f, 
    -0.07054585f, 0.21827368f, -0.28350151f, -0.23296091f, -0.12798974f, -0.17170779f, 0.01538341f, 0.13040432f, 
    0.10740732f, 0.00823627f, -0.02760994f, 0.03937054f, 0.03890526f, -0.30685359f, -0.31141084f, 0.08343164f, 
    0.05184318f, -0.12110063f, 0.11249876f, 0.12437905f, 0.05751892f, 0.10617051f, 0.05639369f, 0.08354848f, 
    -0.04225120f, -0.14609471f, -0.08160551f, -0.08486756f, 0.20768796f, 0.12922780f, 0.06812830f, 0.04156731f, 
    -0.09414160f, -0.13241935f, -0.09687294f, -0.03619251f, 0.09404214f, 0.27116928f, 0.06997406f, 0.32326612f, 
    -0.03611596f, 0.04268333f, 0.15741074f, -0.00195461f, 0.20809253f, 0.13000979f, 0.21984328f, 0.12305699f, 
    -0.07271618f, -0.47616610f, -0.25634962f, 0.16264720f, 0.09241421f, 0.03963880f, 0.01228727f, 0.05346465f, 
    -0.02048416f, 0.01558510f, 0.03259656f, 0.12443516f, 0.04128262f, 0.06543104f, 0.19924876f, 0.15506831f, 
    0.02170761f, 0.12814502f, -0.02478413f, -0.05767348f, 0.11468648f, 0.07762947f, 0.17429948f, 0.40660018f, 
    0.03970183f, -0.06539942f, -0.21856031f, -0.30354136f, -0.02265766f, -0.16923672f, -0.09854925f, 0.01245087f, 
    -0.05222191f, 0.24805965f, 0.02892542f, 0.04380889f, -0.32080507f, -0.09633955f, 0.16927715f, -0.12309330f, 
    0.10612924f, -0.07397614f, 0.08347075f, -0.02397909f, 0.22343454f, 0.10130897f, 0.04876363f, 0.12639335f, 
    -0.12479729f, -0.23937033f, 0.21063447f, 0.20949493f, 0.09316403f, 0.14411502f, 0.03575745f, 0.04424593f, 
    0.03816793f, -0.02656503f, 0.08270027f, 0.05841736f, 0.21855800f, 0.07905193f, -0.08686682f, 0.04985015f, 
    -0.02897501f, -0.05815678f, 0.00470270f, -0.03905397f, 0.02586358f, 0.07185555f, -0.08102623f, 0.14729027f, 
    -0.20531102f, 0.11134771f, 0.03638905f, -0.20024438f, -0.09966294f, -0.15634042f, -0.13811311f, -0.06126668f, 
    -0.11315065f, 0.05583999f, 0.04494394f, 0.01603747f, -0.28377271f, 0.03235882f, -0.09622141f, -0.19783026f, 
    0.03518042f, 0.01063134f, -0.06346704f, 0.08826523f, 0.06543426f, -0.11934048f, -0.02053883f, -0.14578968f, 
    -0.44427255f, 0.11446451f, 0.10561153f, 0.03399310f, 0.05226491f, 0.16454363f, 0.24810313f, -0.02132816f, 
    0.06242235f, 0.14781742f, 0.00454029f, -0.16940916f, 0.63050348f, 0.25038898f, -0.03583506f, 0.05405308f, 
    0.01784563f, 0.04387063f, -0.00632030f, -0.01357585f, -0.10626496f, -0.10795289f, 0.01760205f, -0.02470439f, 
    -0.12749732f, -0.33161446f, 0.02459392f, -0.07532972f, -0.01301090f, -0.10106383f, -0.03222984f, -0.00361079f, 
    0.11869645f, 0.00472494f, 0.12434491f, -0.08497545f, -0.76227236f, -0.01530690f, 0.05908306f, -0.37784997f, 
    -0.19592297f, -0.05440775f, 0.02654562f, 0.04221993f, 0.06829177f, -0.07302181f, 0.15291575f, 0.22281332f, 
    0.24718633f, -0.05831117f, 0.26581219f, 0.02725166f, -0.04499630f, -0.03211355f, 0.26834941f, 0.25184068f, 
    -0.01604993f, 0.03441480f, -0.20557149f, -0.04268679f, -0.23546147f, -0.03752630f, 0.13556102f, -0.04577647f, 
    0.06218644f, -0.09476059f, 0.03494460f, 0.04160362f, 0.03255530f, 0.10076073f, 0.11415808f, 0.04499297f, 
    0.27192438f, 0.03443376f, -0.00587919f, -0.02389651f, 0.04215283f, 0.15502067f, 0.10096327f, 0.09329200f, 
    -0.06116140f, 0.01969541f, -0.03512689f, -0.13925283f, 0.07891594f, -0.01834652f, 0.09526229f, 0.11546792f, 
    0.03469863f, 0.05355483f, 0.01265299f, -0.00991275f, 0.02557463f, -0.00298540f, -0.02540540f, -0.02836815f, 
    0.24593809f, -0.08928449f, 0.00061614f, 0.03885453f, -0.03167206f, 0.09531583f, 0.15150227f, 0.08285441f, 
    0.09036849f, 0.06949120f, 0.09003315f, 0.09354685f, -0.04753446f, 0.04685616f, 0.02638475f, 0.10677028f, 
    0.00082974f, 0.03896285f, 0.00371321f, -0.11080775f, -0.03207010f, -0.13449217f, -0.02006025f, -0.20313154f, 
    -0.01344821f, 0.13092582f, 0.02958245f, 0.07471658f, -0.11044067f, -0.06593388f, -0.05623394f, 0.00524535f, 
    -0.00250025f, -0.01075275f, -0.07282951f, -0.09657896f, -0.30297530f, -0.25142851f, -0.17950094f, 0.02375805f, 
    -0.03228900f, -0.00026735f, -0.05853864f, -0.02397197f, 0.11275561f, 0.19062562f, 0.10061644f, 0.09564655f, 
    0.43477094f, 0.01075229f, 0.05860983f, 0.09228326f, -0.06140257f, 0.03672713f, 0.17124902f, 0.08292364f, 
    -0.00150278f, 0.13928744f, -0.03031721f, 0.01059411f, -0.14560580f, 0.06907431f, -0.15427521f, 0.01239180f, 
    0.05740720f, 0.01514737f, 0.01095446f, -0.08328717f, -0.06137216f, -0.06935448f, -0.10223220f, -0.08014999f, 
    -0.02753623f, -0.20940760f, -0.10631603f, -0.04386821f, -0.09706239f, -0.10242900f, -0.03791105f, 0.04138965f, 
    0.02450334f, 0.08904003f, 0.10309891f, -0.06290434f, -0.06489297f, -0.00500700f, -0.25834292f, -0.07467831f, 
    -0.04953738f, -0.06257300f, 0.09719863f, -0.05392370f, 0.13707370f, -0.02778485f, 0.20785388f, 0.11976148f, 
    0.20592733f, 0.02149845f, 0.03436364f, 0.08422945f, -0.10676254f, 0.00216783f, 0.05461906f, 0.03822259f, 
    0.15843800f, 0.14271700f, 0.09918586f, 0.00510292f, 0.13593782f, 0.14887124f, 0.20828995f, 0.13877772f, 
    -0.07675385f, -0.02274778f, -0.03120456f, -0.06349757f, -0.10452963f, -0.02171082f, -0.11643066f, -0.09799885f, 
    0.16429915f, 0.02224870f, -0.02369928f, -0.04019127f, 0.06700000f, 0.04901368f, -0.02283650f, 0.14456487f, 
    -0.06115854f, -0.01921699f, -0.04542184f, -0.04027986f, 0.07070141f, 0.21239699f, -0.19784813f, -0.17588578f, 
    0.09584852f, -0.03209378f, 0.13331074f, 0.15476987f, -0.17917274f, -0.07640717f, -0.07237571f, 0.06049338f, 
    -0.02353948f, -0.03791090f, -0.06511917f, 0.13847455f, -0.12159837f, 0.04817500f, -0.19065842f, -0.31012163f, 
    -0.07767933f, -0.03691830f, -0.15504527f, 0.07217582f, -0.32858655f, 0.11551176f, -0.08589073f, 0.17329681f, 
    0.04555633f, -0.04303721f, 0.19791374f, 0.11594792f, -0.02900114f, 0.03129438f, 0.01740074f, 0.02444349f, 
    0.08494443f, 0.06956011f, 0.07326348f, 0.04730652f, 0.00275310f, -0.02454642f, -0.02720459f, -0.06649387f, 
    -0.14569178f, -0.04367925f, -0.18539524f, -0.30738652f, 0.06460529f, 0.27984962f, 0.03698885f, -0.05808312f, 
    0.06264357f, -0.17461967f, 0.10525452f, -0.01694667f, -0.06158083f, 0.08277692f, 0.02906248f, -0.07369754f, 
    0.00103663f, 0.12741715f, -0.04019010f, 0.07599577f, -0.07610844f, 0.00390035f, 0.07113911f, 0.07937472f, 
    -0.02466715f, -0.02003565f, -0.13329838f, -0.00557504f, 0.00244894f, 0.14727302f, -0.03711531f, 0.19641457f, 
    -0.23356174f, 0.03069622f, 0.01014069f, 0.06472476f, -0.06963722f, 0.25385597f, 0.23052464f, 0.23114191f, 
    -0.26253703f, 0.14278176f, -0.07494583f, 0.14159624f, 0.03676925f, 0.04552774f, 0.04591202f, -0.24452055f, 
    -0.03618105f, 0.12463886f, -0.05404628f, 0.01915056f, 0.27719796f, 0.11463012f, -0.02639795f, -0.09372812f, 
    0.11129721f, -0.05123526f, -0.00073883f, 0.12153644f, 0.03949787f, 0.08834472f, 0.18794264f, -0.10013964f, 
    -0.12947439f, 0.31468946f, 0.01340415f, -0.03830333f, 0.04654348f, -0.02559026f, 0.02205403f, -0.00091994f, 
    -0.07214224f, 0.00699404f, 0.02555749f, 0.05493754f, 0.11352105f, -0.01247832f, 0.02491774f, -0.00671960f, 
    -0.09521275f, -0.03347388f, -0.10972734f, -0.04196659f, 0.17625152f, 0.15086000f, 0.22664183f, 0.15228716f, 
    0.15926021f, -0.05993481f, 0.04104177f, -0.01997879f, 0.12836334f, -0.05762207f, 0.00154546f, 0.00919758f, 
    0.02730985f, 0.05959984f, -0.14537628f, -0.12384855f, 0.21974239f, -0.00442571f, 0.08789111f, -0.04181950f, 
    0.00720990f, 0.14643918f, 0.17127429f, 0.02139090f, 0.10404514f, 0.00311774f, -0.02529622f, 0.10995256f, 
    0.50510538f, 0.12935816f, 0.03563425f, -0.13257267f, 0.06655928f, 0.11091714f, -0.04070977f, -0.05591757f, 
    0.11751942f, -0.04381323f, -0.03171492f, -0.02281508f, 0.09992211f, 0.21240485f, 0.17677557f, -0.02740173f, 
    -0.04555410f, 0.00467604f, -0.24074277f, -0.10553586f, -0.17971981f, -0.17287980f, -0.14391363f, -0.13351126f, 
    0.15932165f, 0.06330813f, 0.02702896f, 0.13348387f, 0.09223306f, 0.08044786f, -0.03112215f, -0.12463334f, 
    -0.04191579f, 0.16692147f, 0.12684046f, -0.01062158f, 0.17390260f, 0.11588815f, -0.08728503f, 0.09284810f, 
    0.01919763f, -0.06246436f, -0.04488983f, -0.06507999f, -0.12079737f, -0.05855841f, -0.14006118f, 0.05464972f, 
    -0.17233834f, 0.15067814f, 0.01400712f, -0.08774131f, -0.06629951f, -0.00165982f, 0.04930158f, -0.01584398f, 
    -0.13324049f, 0.06545375f, -0.10433445f, -0.15299951f, 0.11989542f, 0.05710267f, -0.01790362f, 0.06454778f, 
    0.00906686f, -0.06741233f, 0.02838400f, 0.00101985f, 0.18101829f, 0.11702628f, 0.05773804f, 0.02571153f, 
    -0.06725106f, -0.07424292f, 0.05750878f, -0.16800693f, -0.02986549f, -0.00702668f, 0.01541188f, -0.00914165f, 
    -0.11022021f, -0.06678470f, -0.17495772f, -0.28894427f, -0.04443122f, 0.15381831f, -0.09399310f, -0.16291946f, 
    0.04004191f, -0.04686356f, 0.05332790f, 0.01713346f, -0.04874369f, 0.02013322f, 0.00848652f, -0.01399240f, 
    0.06221744f, -0.01141323f, 0.26982364f, 0.13460621f, -0.14680716f, -0.00943456f, -0.02413376f, 0.04431635f, 
    0.23991607f, 0.15475756f, 0.13222167f, 0.30834156f, -0.02463541f, -0.09372862f, -0.04215542f, -0.06735657f, 
    0.00099959f, -0.04619210f, -0.17655472f, -0.27790433f, -0.00346601f, -0.21503696f, -0.16868451f, -0.32801643f, 
    0.13653836f, -0.15476789f, -0.03010891f, -0.20004997f, 0.02600811f, 0.10224343f, -0.05402921f, 0.03344684f, 
    -0.07344522f, -0.08352710f, -0.15143970f, -0.19052701f, 0.15713575f, 0.08451959f, -0.12976143f, 0.05990564f, 
    0.06096202f, 0.06554365f, 0.17949936f, 0.09988084f, 0.05922809f, 0.07767128f, 0.17591098f, 0.18910988f, 
    -0.12460411f, 0.09514386f, 0.23840736f, 0.00775009f, 0.05891335f, -0.07694546f, 0.00917758f, 0.09829188f, 
    0.05697670f, 0.24431641f, 0.04494123f, -0.01722235f, 0.24577916f, -0.02438665f, -0.05532295f, -0.02318699f, 
    0.06080266f, -0.04325822f, -0.04074663f, 0.11083243f, 0.15821248f, 0.13474134f, -0.03351512f, -0.07321396f, 
    0.12819140f, 0.03507896f, 0.23983845f, 0.03413774f, -0.05302590f, 0.01335451f, -0.01044008f, 0.03390491f, 
    0.00289269f, 0.06880175f, 0.02967720f, 0.02687429f, 0.62363052f, -0.07542560f, 0.01614089f, 0.06169421f, 
    0.04740231f, 0.16442695f, 0.05745657f, -0.01024161f, -0.01711333f, 0.03748835f, 0.08112500f, 0.22957332f, 
    -0.01713757f, -0.05270977f, -0.10511113f, -0.06288792f, -0.13954484f, -0.02067146f, 0.02977626f, 0.00135757f, 
    0.13006760f, 0.13246146f, 0.08725752f, 0.13691744f, 0.01682000f, 0.11623451f, -0.18252920f, -0.23136444f, 
    0.14324126f, -0.03809737f, -0.20217486f, -0.15912789f, -0.15094730f, 0.04105749f, -0.01561841f, -0.29078281f, 
    -0.00306669f, 0.07357353f, 0.06927870f, 0.08133201f, -0.18878233f, -0.02088032f, 0.02132435f, -0.05751214f, 
    0.02458973f, 0.01362517f, 0.06669602f, 0.03147567f, -0.03664153f, -0.43948284f, 0.36044651f, 0.33338958f, 
    -0.03573348f, 0.10964172f, -0.14850071f, -0.00199960f, 0.03555699f, 0.02101275f, 0.06626972f, -0.14197370f, 
    0.47374931f, 0.14750631f, 0.11009017f, -0.11685728f, 0.03774116f, -0.05926621f, -0.03972665f, -0.15185858f, 
    -0.06163633f, 0.10740182f, 0.03468759f, 0.01649778f, 0.16245919f, 0.13173835f, 0.23541003f, -0.38328308f, 
    0.08769359f, 0.00899606f, -0.14602923f, 0.00075735f, 0.11601534f, 0.00011138f, -0.13852371f, -0.12049698f, 
    -0.13209328f, -0.08857290f, -0.11006749f, 0.01959535f, 0.11874826f, 0.09430905f, -0.01896923f, 0.10045854f, 
    -0.01858561f, 0.00904866f, -0.01291808f, 0.00883780f, 0.11225937f, -0.25261670f, 0.03953126f, 0.28476435f, 
    0.02470376f, 0.20285630f, 0.03668095f, 0.04338011f, 0.05236160f, 0.12197660f, 0.04719970f, 0.01911818f, 
    0.00035360f, -0.14142351f, 0.01504066f, -0.39089879f, 0.08434296f, -0.05074122f, 0.01600833f, 0.02739769f, 
    0.06824005f, 0.05741259f, 0.03058590f, 0.02660680f, 0.01060528f, -0.12330180f, 0.05617471f, -0.00756852f, 
    -0.00050247f, -0.02143214f, 0.00103106f, 0.04732738f, -0.09137726f, 0.06655871f, 0.04417646f, 0.13820004f, 
    0.39195123f, 0.32271793f, 0.49672711f, 0.03878559f, 0.01651084f, -0.01681442f, -0.11383938f, -0.11453485f, 
    0.03980651f, 0.03787199f, 0.00608471f, 0.02318314f, -0.26501679f, 0.01571624f, 0.21083905f, 0.06002204f, 
    0.02620825f, 0.07589466f, -0.12281527f, 0.04390145f, 0.04366980f, -0.06981932f, -0.01206350f, -0.03282174f, 
    0.08587484f, -0.31593236f, 0.14965786f, 0.17159708f, -0.03798290f, 0.17767529f, 0.03992978f, 0.02555249f, 
    -0.00530189f, -0.00605018f, 0.04212315f, 0.03435259f, 0.05363652f, 0.17963243f, 0.19676003f, 0.26748726f, 
    -0.05549746f, -0.03544764f, 0.08415253f, 0.00007174f, 0.16002090f, 0.19657798f, 0.10443871f, 0.15803201f, 
    0.03497373f, 0.25471252f, 0.31150544f, 0.07011800f, 0.02987697f, -0.08121573f, -0.09256721f, -0.04476042f, 
    -0.00540068f, 0.00122895f, 0.13929023f, 0.08580704f, 0.10387151f, 0.16082777f, 0.02257452f, 0.02843955f, 
    -0.00154905f, -0.07268409f, -0.00183807f, -0.12341016f, 0.08246627f, 0.17514493f, 0.11184540f, 0.05521969f, 
    -0.43275931f, 0.38327909f, -0.03849377f, 0.33691967f, -0.13445726f, -0.03552834f, 0.09087187f, 0.01923920f, 
    -0.07699227f, -0.05120347f, -0.07458119f, 0.13566232f, -0.05401322f, -0.18496571f, -0.22067165f, -0.00034463f, 
    0.10720117f, 0.08232254f, 0.14284819f, 0.05615948f, -0.00096966f, -0.02371651f, -0.00790695f, -0.04731704f, 
    0.00287327f, 0.19108963f, 0.31168309f, 0.09721278f, -0.00876694f, 0.01765772f, 0.01105205f, -0.04601946f, 
    0.02998780f, -0.16555835f, -0.03553240f, 0.00088162f, 0.03024132f, -0.13071874f, -0.06363838f, -0.06897759f, 
    -0.01615120f, 0.11416435f, -0.02752608f, -0.10739513f, 0.09840982f, -0.13658349f, -0.05065563f, 0.05810595f, 
    0.18430844f, -0.21402909f, -0.12384633f, -0.00980510f, 0.03672021f, 0.03895321f, 0.00494783f, 0.00242123f, 
    0.02485367f, 0.07856060f, 0.07423920f, -0.08184926f, 0.02228940f, 0.05702779f, 0.08264529f, -0.09683832f, 
    0.00797459f, 0.01909862f, 0.02309875f, 0.01690987f, 0.11185616f, 0.05962997f, 0.09611426f, 0.09870884f, 
    0.04681082f, -0.00984733f, -0.05802068f, -0.03645581f, -0.14486977f, -0.02798093f, 0.02116303f, -0.03698996f, 
    -0.01104009f, 0.02441011f, 0.00249089f, -0.01898297f, -0.05927791f, -0.19185837f, -0.03697333f, -0.03540902f, 
    0.08289506f, 0.03357530f, 0.01535621f, 0.07823522f, 0.02039291f, -0.04460435f, -0.02423933f, 0.00507593f, 
    0.04185879f, 0.09888588f, -0.12954055f, -0.05899710f, -0.05325422f, 0.00645270f, -0.00859168f, 0.04057079f, 
    0.04464698f, 0.12486907f, 0.10635760f, 0.17380920f, 0.04885655f, -0.04702767f, 0.08577018f, 0.02483328f, 
    0.00095646f, 0.05752145f, -0.03774156f, -0.02583019f, 0.01093294f, -0.01423798f, -0.08357930f, -0.03230381f, 
    -0.06869762f, -0.04597805f, -0.05688740f, 0.13434872f, -0.00632371f, 0.04638368f, -0.00844798f, -0.01296650f, 
    0.00605983f, -0.02209418f, -0.05419977f, 0.01822985f, -0.06909030f, -0.01470278f, 0.14512493f, 0.02848519f, 
    0.07705162f, 0.05774784f, -0.14369431f, -0.02372869f, 0.08544858f, 0.12170727f, 0.09893008f, -0.06651721f, 
    -0.03953047f, -0.13758665f, -0.33089450f, -0.10367306f, 0.04783566f, -0.04508736f, 0.07731427f, 0.08594626f, 
    0.05495584f, -0.00982056f, -0.04004120f, 0.06306477f, 0.10811556f, 0.00916547f, 0.14314888f, 0.08312182f, 
    -0.00861273f, -0.11964022f, -0.21209219f, 0.09227765f, -0.03520168f, 0.02126773f, 0.03031775f, 0.08118987f, 
    0.04836864f, 0.33516675f, 0.13227955f, 0.23337142f, 0.03076128f, -0.00507089f, 0.04988999f, -0.10174114f, 
    -0.17638333f, 0.07147222f, 0.08326837f, -0.02160269f, -0.23375943f, 0.07348743f, 0.21903731f, 0.25645801f, 
    -0.08582666f, 0.00339193f, -0.00528127f, 0.07539963f, 0.05018497f, 0.10572274f, 0.14566611f, 0.06760161f, 
    -0.04611083f, -0.14447358f, -0.08659960f, -0.05997407f, -0.00355486f, 0.06184336f, 0.07147973f, -0.00938666f, 
    0.10072613f, 0.03228198f, -0.01497762f, 0.03321736f, -0.08068938f, -0.20004684f, -0.15218075f, -0.03751947f, 
    -0.03484428f, 0.04570420f, 0.04669813f, 0.05531640f, -0.00227087f, -0.09527415f, -0.09224986f, -0.09978130f, 
    -0.09444977f, 0.05050478f, -0.00722260f, -0.05251707f, 0.05523049f, 0.11196406f, 0.03300178f, 0.12920779f, 
    0.05598985f, -0.01484970f, -0.02295977f, 0.05535174f, -0.08077186f, -0.07204486f, 0.19758278f, 0.37445977f, 
    0.14250575f, 0.12661703f, -0.00827915f, 0.03598257f, 0.30384684f, 0.00266327f, 0.09273279f, 0.04918264f, 
    0.05457729f, -0.02053464f, 0.15586752f, -0.41643932f, -0.09981290f, 0.00336474f, 0.07080984f, 0.22323978f, 
    0.21465221f, 0.03487713f, -0.05573438f, -0.08076990f, 0.27209240f, -0.03710090f, -0.00298498f, -0.18833305f, 
    -0.04675676f, 0.07340263f, 0.05280203f, 0.20187701f, -0.00146077f, 0.11516879f, 0.07584073f, 0.08520818f, 
    0.00446138f, -0.14072224f, 0.00085271f, -0.00026307f, 0.23579153f, 0.07193016f, 0.19985069f, 0.00011496f, 
    0.03123089f, -0.08727992f, 0.02270865f, 0.15118662f, 0.08799035f, -0.03888682f, 0.22112577f, 0.09836151f, 
    -0.06531064f, 0.05618038f, -0.07022661f, 0.06354927f, 0.22762151f, -0.06462856f, 0.04497070f, 0.10073026f, 
    0.20435652f, 0.02966952f, 0.05136646f, -0.01629877f, 0.06128061f, 0.11451748f, -0.05724845f, 0.13025038f, 
    -0.01345574f, 0.02419044f, 0.08961916f, 0.03340416f, -0.05995964f, -0.02494780f, 0.09660626f, -0.11744575f, 
    0.05795715f, 0.10714389f, -0.00571392f, 0.04205371f, 0.04802954f, -0.13722520f, -0.01876913f, -0.20346731f, 
    0.16705495f, -0.24178152f, -0.15403499f, -0.36006066f, -0.05316915f, -0.03297203f, -0.05775183f, 0.03446411f, 
    0.04433168f, 0.07743578f, 0.17245871f, 0.04223376f, -0.39717811f, -0.01549443f, -0.02286892f, 0.15473077f, 
    0.17142485f, 0.11391728f, 0.11338715f, 0.03114650f, 0.11216673f, -0.00562855f, 0.00244342f, 0.18582538f, 
    0.13477287f, -0.25112951f, -0.02468559f, 0.01440241f, -0.08928054f, 0.09580702f, -0.01824990f, 0.10813864f, 
    0.11657633f, 0.03202649f, 0.05367992f, -0.02430759f, 0.08219436f, 0.00793944f, -0.00387665f, 0.03801608f, 
    0.03603780f, 0.04598435f, 0.01584803f, -0.07665448f, -0.05723798f, -0.04171845f, -0.16869093f, -0.02506085f, 
    -0.17578056f, -0.04323501f, -0.08544136f, -0.04625422f, -0.05523281f, 0.03309994f, -0.08823387f, 0.00815870f, 
    -0.01399199f, 0.01546853f, 0.00736194f, 0.02884291f, -0.21630435f, 0.01956156f, -0.22209510f, -0.05436053f, 
    0.02284727f, 0.08099789f, -0.02885515f, 0.06424772f, -0.01323295f, -0.01537609f, 0.06098365f, -0.12792175f, 
    -0.38569659f, -0.21318138f, 0.09673815f, 0.28196058f, 0.02238677f, -0.03341912f, 0.00515865f, 0.11904942f, 
    0.08798020f, 0.00748150f, 0.04233149f, -0.05434977f, 0.18370850f, -0.00664890f, -0.17103912f, -0.00470673f, 
    0.05310322f, -0.06225055f, 0.03892690f, -0.08778202f, -0.02105702f, 0.03084303f, 0.00736748f, 0.02202826f, 
    -0.06138244f, -0.04832457f, 0.03461711f, 0.00749736f, -0.08468144f, -0.03420296f, 0.02144884f, 0.09636685f, 
    0.18946844f, 0.02577161f, 0.04529253f, 0.10276311f, -0.40501055f, 0.19990934f, 0.07216822f, -0.01486991f, 
    -0.03583946f, 0.21450832f, 0.06913364f, 0.20099771f, 0.01770193f, 0.07104293f, 0.07898446f, 0.03902373f, 
    0.20265794f, -0.05566945f, -0.05313677f, -0.23628241f, 0.11530787f, 0.08965860f, 0.25053295f, 0.19195607f, 
    0.02144088f, -0.00749830f, 0.04424940f, 0.06452492f, -0.15789840f, 0.06260567f, 0.11249191f, -0.07354029f, 
    0.08140256f, 0.05191066f, 0.05436639f, 0.13796538f, -0.07466561f, -0.05361961f, 0.08037008f, -0.01256074f, 
    0.03465820f, -0.01913416f, -0.05777358f, -0.14916138f, 0.04383944f, 0.02329040f, 0.05073225f, -0.05797320f, 
    0.08102441f, 0.04903322f, -0.00717922f, 0.02890677f, 0.04980526f, -0.00974390f, 0.05395802f, -0.00311995f, 
    -0.10217363f, 0.01935497f, -0.09515902f, -0.11138404f, 0.09673311f, -0.04312626f, -0.06490473f, -0.07893191f, 
    0.09630436f, -0.07385426f, -0.02075151f, -0.08506813f, 0.05394165f, -0.01092489f, 0.14306021f, 0.16274202f, 
    -0.07445496f, -0.08779056f, 0.01735441f, -0.26604068f, 0.01931925f, -0.07429247f, -0.05439519f, -0.02927127f, 
    0.04168490f, 0.06571046f, 0.01269802f, 0.01010082f, 0.00764839f, 0.08199548f, 0.05892494f, 0.10477815f, 
    -0.07661463f, 0.11316082f, -0.00648381f, -0.00273718f, -0.13249893f, -0.08771132f, -0.14915863f, -0.10057759f, 
    0.11072347f, 0.01602204f, 0.09040421f, -0.00927373f, 0.05091010f, 0.07782327f, 0.10799804f, -0.01215629f, 
    -0.00208430f, 0.00229568f, 0.01114252f, 0.07221503f, 0.06553798f, -0.10583132f, -0.08611343f, -0.04122335f, 
    0.08216736f, -0.00759944f, -0.18669935f, 0.05904686f, 0.00646792f, 0.08651812f, 0.06874266f, 0.01180377f, 
    -0.08584745f, -0.03934769f, -0.00999130f, 0.01383333f, -0.07253025f, -0.04449462f, 0.10811412f, -0.06837615f, 
    0.05262487f, 0.16635580f, 0.13985075f, -0.06576975f, -0.04564213f, -0.08451385f, 0.04220357f, -0.08320438f, 
    0.12509663f, -0.08198347f, 0.02863622f, -0.02581220f, 0.08565761f, -0.03786265f, -0.03104414f, -0.09308044f, 
    0.10969317f, -0.08798901f, 0.08711410f, -0.01582740f, -0.24688078f, 0.04830430f, -0.06061111f, 0.05300817f, 
    0.05447109f, -0.20704378f, -0.04701063f, 0.07991266f, 0.19367941f, -0.06458448f, 0.04335616f, -0.15617695f, 
    0.09329981f, 0.06624135f, 0.01819167f, 0.05047650f, -0.05631405f, -0.03905016f, -0.00083230f, -0.07293794f, 
    -0.03551016f, -0.04337679f, -0.01676353f, -0.08012235f, 0.04608052f, 0.01004955f, 0.06207676f, 0.26903871f, 
    -0.10586730f, -0.05482368f, 0.02096279f, -0.05126297f, 0.06588939f, 0.02701142f, -0.05182789f, 0.15072703f, 
    0.07387044f, 0.33135748f, 0.19478692f, 0.17628139f, 0.08310928f, 0.10119560f, 0.08874302f, 0.03271167f, 
    0.05394210f, 0.00641447f, -0.03929913f, 0.00758018f, 0.33210111f, -0.23176637f, -0.02764657f, 0.08324359f, 
    -0.17098585f, -0.14102083f, 0.19403511f, -0.06853607f, -0.07463540f, 0.21167988f, -0.20134948f, 0.04581022f, 
    0.14226432f, 0.18596259f, -0.05005036f, -0.11256822f, 0.01515344f, -0.07487772f, -0.19565427f, -0.14600405f, 
    0.14501180f, -0.05678314f, 0.00091498f, -0.16092291f, 0.08236113f, 0.12662649f, 0.04183515f, -0.01722714f, 
    0.05862736f, -0.05794198f, -0.06521981f, 0.11438181f, 0.08755120f, -0.04466751f, -0.09424523f, 0.05868657f, 
    -0.14614229f, 0.30773130f, 0.27943155f, -0.01721829f, -0.04475314f, 0.13412991f, -0.05477497f, -0.03007814f, 
    -0.03753240f, 0.08536860f, -0.09242538f, -0.09791372f, -0.22212137f, 0.07028759f, 0.05178948f, -0.12341236f, 
    -0.06167947f, -0.00748661f, -0.18296017f, 0.09573913f, 0.01855113f, -0.07835622f, -0.02979138f, 0.10902498f, 
    0.28660160f, 0.37523839f, 0.18257295f, -0.04998630f, 0.03003771f, 0.04231090f, 0.14882417f, 0.11107212f, 
    0.01665312f, 0.17299579f, 0.07606620f, -0.08248897f, 0.10180515f, 0.09800021f, -0.09373944f, -0.03052878f, 
    0.12208987f, -0.06669898f, -0.05476809f, 0.07129476f, 0.11959894f, 0.06983373f, 0.08130929f, -0.08506530f, 
    -0.02455874f, 0.20071611f, 0.02938328f, -0.07975740f, -0.04647662f, -0.03613599f, -0.00879600f, 0.07196245f, 
    0.03146585f, 0.03185061f, 0.03685972f, 0.02937319f, 0.14583042f, 0.04888504f, 0.07834794f, 0.19660780f, 
    -0.00554038f, 0.05598990f, 0.00474195f, 0.03710309f, -0.11301298f, 0.00197875f, -0.09464815f, -0.01608634f, 
    0.25119305f, 0.20383854f, 0.14897028f, -0.12970757f, -0.02954385f, -0.03878049f, 0.02831555f, 0.08794245f, 
    0.06318210f, -0.03353904f, -0.16767949f, 0.01135944f, -0.12397099f, -0.12186266f, 0.06558715f, 0.01472722f, 
    -0.00786807f, 0.08629857f, 0.01937265f, 0.03603787f, 0.03864342f, 0.05431302f, 0.04023933f, 0.09765305f, 
    0.21677597f, 0.04339395f, 0.08556867f, 0.16705842f, 0.06624477f, 0.01536671f, 0.02311324f, -0.03136108f, 
    0.07523242f, 0.07048280f, -0.14298180f, -0.02460619f, 0.34974548f, 0.05091330f, 0.06349570f, 0.07965500f, 
    0.02237266f, -0.02066686f, 0.04172180f, 0.07634332f, 0.05468574f, 0.06383335f, 0.04469518f, 0.17043659f, 
    0.03487867f, 0.08458732f, 0.37774357f, 0.03914224f, -0.11770521f, 0.10238015f, -0.15463123f, -0.04168444f, 
    -0.03343184f, 0.00817121f, -0.04178756f, 0.05865704f, -0.09491679f, -0.11397772f, 0.00286547f, 0.08514812f, 
    -0.12141459f, -0.12319767f, -0.03132098f, 0.04083300f, -0.02421564f, -0.14407057f, 0.01994546f, -0.03203347f, 
    -0.12727249f, 0.13862529f, 0.08478285f, 0.05521155f, 0.04102745f, 0.17152569f, 0.02717644f, -0.11280918f, 
    -0.03178113f, -0.00611899f, -0.01634957f, 0.01930568f, 0.37507340f, 0.26535186f, 0.09048869f, 0.20092775f, 
    0.04642852f, -0.04469275f, 0.04684694f, 0.04590663f, 0.02498240f, -0.05308674f, -0.06426432f, -0.07793989f, 
    0.04571081f, 0.05328417f, -0.23549272f, -0.07884821f, -0.05145872f, 0.02734405f, -0.13692157f, -0.04882416f, 
    -0.11585035f, -0.06077849f, 0.09650651f, -0.07419960f, 0.27777439f, 0.26892251f, 0.23360732f, 0.09433470f, 
    0.15363637f, -0.01388207f, -0.03080725f, 0.05156798f, -0.00803970f, 0.01378625f, 0.07812398f, 0.10398494f, 
    -0.42941111f, -0.19092894f, -0.01347501f, 0.01640681f, 0.10914991f, 0.00699497f, -0.07292816f, -0.07771991f, 
    0.00873285f, -0.00495597f, -0.07710494f, 0.15344374f, -0.03169344f, -0.01378499f, -0.25381571f, -0.09042964f, 
    0.15265991f, -0.17826116f, -0.03548958f, 0.05160204f, 0.10208105f, 0.09436390f, 0.00374667f, 0.05204495f, 
    -0.24508941f, 0.08856340f, 0.06019096f, 0.05668965f, 0.09039651f, -0.04071279f, -0.21553876f, -0.12514432f, 
    0.08749624f, 0.03057991f, 0.10308076f, 0.13808556f, -0.04201353f, 0.03069407f, -0.08223055f, -0.13272525f, 
    -0.00111475f, -0.04754015f, 0.00012124f, 0.02726830f, -0.00118739f, -0.11666925f, -0.14255889f, -0.00723526f, 
    -0.08273908f, -0.27702439f, -0.17229760f, 0.01026263f, 0.07968292f, -0.05829407f, -0.06158554f, -0.00522468f, 
    -0.02542034f, -0.09502797f, 0.03213069f, -0.03165704f, 0.01244082f, 0.26678887f, 0.22332366f, 0.06869479f, 
    0.15099792f, 0.01522733f, 0.00198233f, 0.06565863f, -0.03046691f, -0.02363137f, 0.01506596f, -0.01519278f, 
    0.07889981f, -0.02069110f, -0.11855284f, -0.02310964f, 0.05501744f, -0.06640085f, -0.10355631f, 0.06252007f, 
    0.15957749f, -0.04500131f, 0.09204415f, -0.01151565f, 0.36821470f, 0.20609896f, 0.16623417f, 0.13324682f, 
    0.10096566f, -0.10869616f, 0.00035716f, 0.10067474f, 0.08467440f, 0.17446168f, 0.03619099f, 0.02970377f, 
    0.07314035f, 0.22295018f, 0.25420401f, 0.14472291f, -0.02460245f, 0.10843801f, 0.02862532f, -0.10611540f, 
    0.08661584f, 0.01193514f, 0.08122825f, 0.03747804f, -0.15836108f, 0.03991924f, 0.30285767f, 0.09086331f, 
    -0.05948059f, -0.04791769f, -0.00773227f, -0.01386849f, 0.08172683f, 0.16122375f, -0.00977641f, 0.02648971f, 
    -0.23419318f, -0.23144892f, -0.19921036f, -0.00833345f, 0.09145829f, -0.10078461f, -0.10859434f, -0.16837861f, 
    0.07839832f, -0.04116191f, -0.05262730f, 0.18831165f, -0.14864902f, -0.33763736f, -0.21907508f, -0.10889840f, 
    0.05505663f, -0.04896745f, -0.06722406f, -0.08093467f, -0.13241641f, -0.12071983f, -0.04315136f, 0.00282501f, 
    0.33157003f, 0.17980160f, 0.15608990f, 0.08717195f, -0.19081005f, 0.11392456f, 0.01068110f, 0.06924590f, 
    0.07812867f, -0.02161033f, -0.02006617f, -0.04452622f, -0.00428507f, -0.23535225f, 0.30971965f, 0.20608094f, 
    -0.06749932f, 0.08393472f, -0.05542093f, -0.03952671f, -0.14210404f, -0.05700439f, 0.06163928f, -0.05196444f, 
    0.22460438f, 0.20297164f, -0.10577928f, -0.01529151f, -0.07926082f, -0.05961069f, 0.10454321f, -0.09166883f, 
    -0.06923166f, -0.01070534f, 0.19047661f, -0.03768635f, 0.24435864f, -0.07777955f, 0.14913280f, 0.05813999f, 
    0.00637641f, -0.05709861f, -0.04967541f, 0.05515104f, -0.03082153f, -0.01961828f, -0.13765375f, -0.08399148f, 
    0.01368964f, 0.25236917f, 0.18089584f, 0.02110326f, -0.09632768f, -0.00405994f, -0.04131995f, 0.09829346f, 
    -0.03287483f, -0.00760817f, -0.00496299f, -0.08806995f, -0.01193223f, -0.10963501f, -0.16964747f, 0.17573637f, 
    -0.19597921f, 0.05631300f, -0.00950011f, -0.08754684f, -0.04311105f, -0.09177388f, -0.00003884f, -0.01800156f, 
    0.19329749f, 0.01668337f, 0.13125984f, -0.06921861f, 0.03589658f, -0.08434334f, 0.01042124f, 0.12110940f, 
    0.01033570f, -0.00502169f, -0.04219459f, 0.01593611f, -0.00363362f, -0.09399641f, -0.00687008f, 0.05633812f, 
    0.02130848f, -0.07152298f, -0.04516505f, -0.04104696f, 0.03037236f, -0.03791402f, 0.00295668f, 0.12624006f, 
    0.17839211f, 0.12503007f, -0.04515851f, -0.08427988f, 0.02861417f, 0.06970330f, -0.03026963f, 0.10450666f, 
    -0.01602833f, -0.02633281f, 0.05260949f, 0.06695863f, -0.00387043f, 0.02825202f, 0.15687022f, 0.01588005f, 
    -0.11415859f, -0.05469606f, 0.04095355f, 0.08843265f, 0.01351279f, -0.01574730f, -0.04777074f, -0.13841766f, 
    -0.01652207f, -0.43601236f, 0.20682855f, -0.14910533f, -0.11447258f, -0.05719774f, 0.05900750f, 0.00959973f, 
    -0.03735133f, -0.04896317f, -0.12253956f, 0.05197798f, -0.12829670f, -0.02648717f, -0.01773310f, 0.14967582f, 
    -0.07674433f, 0.00370414f, 0.05080483f, -0.03662003f, -0.00047705f, 0.03882004f, -0.06079110f, 0.02510353f, 
    0.27208471f, 0.05182819f, 0.03975774f, -0.07500220f, 0.09417616f, 0.01848899f, 0.06284715f, 0.02246502f, 
    -0.02966588f, -0.00367592f, 0.15307924f, 0.02227193f, 0.12199566f, 0.05664351f, 0.07265293f, 0.01759579f, 
    -0.00850555f, -0.04362684f, -0.05235102f, 0.10988937f, -0.08109497f, -0.03584471f, 0.02811546f, 0.03781061f, 
    -0.29710731f, 0.44092345f, 0.06566598f, -0.01036597f, 0.00229795f, -0.03093971f, 0.20960227f, -0.19025715f, 
    -0.19756941f, 0.11375204f, -0.04926737f, -0.02996230f, -0.01001987f, -0.03795986f, -0.29287004f, -0.08831275f, 
    -0.00574366f, -0.00540104f, 0.06374823f, 0.05513581f, 0.03275926f, -0.00755184f, 0.03092205f, -0.10271651f, 
    0.09883694f, 0.08431703f, 0.18137716f, 0.10991336f, 0.02222789f, 0.03632052f, 0.05677190f, -0.02206016f, 
    -0.09928810f, -0.17420360f, 0.02478670f, -0.13370749f, 0.16049731f, 0.09654311f, 0.04306922f, 0.21404427f, 
    -0.01350210f, 0.09248649f, -0.01154728f, 0.01091207f, -0.06868579f, -0.07044770f, 0.04110152f, 0.01913558f, 
    0.28739575f, -0.12322485f, -0.03003790f, 0.32926789f, -0.04959509f, -0.05096901f, 0.14527437f, 0.05477777f, 
    -0.10710127f, 0.03373624f, 0.03531967f, -0.10743107f, 0.20102870f, 0.19904765f, 0.18926105f, 0.01910452f, 
    -0.01427835f, -0.01701364f, 0.03266403f, 0.11950221f, -0.00884930f, 0.03029844f, -0.03259628f, 0.00917806f, 
    0.04621296f, -0.15628457f, -0.15364721f, -0.07895917f, -0.01059380f, 0.02891943f, 0.14703673f, 0.05902493f, 
    -0.12483829f, 0.18969503f, 0.04968936f, -0.02897346f, -0.04231095f, -0.09259018f, 0.00521539f, -0.14818637f, 
    0.02221195f, 0.13087763f, 0.00726660f, -0.04869231f, 0.01068819f, -0.01792039f, 0.11447959f, 0.02438681f, 
    0.04354637f, 0.20501460f, 0.01030869f, -0.04392613f, -0.02388584f, -0.05233801f, 0.01160051f, -0.00423742f, 
    -0.14650710f, -0.01287371f, 0.06049914f, 0.20686492f, 0.14612465f, 0.05168932f, 0.03489425f, -0.07497482f, 
    -0.07761662f, 0.24078049f, 0.01901863f, -0.07022178f, -0.01327029f, -0.01895070f, 0.07507192f, -0.11271168f, 
    -0.11047966f, 0.06021552f, 0.01408083f, -0.05686399f, -0.01295479f, 0.06612533f, 0.12318893f, -0.06980915f, 
    0.02271607f, 0.05881796f, 0.04113754f, 0.04824689f, 0.15070981f, 0.09101588f, 0.11836980f, 0.01897160f, 
    -0.01420805f, 0.00405783f, -0.15368047f, -0.04501542f, -0.00879146f, 0.06212037f, 0.02009250f, -0.06616138f, 
    0.07190139f, 0.14678949f, -0.13399240f, 0.17105033f, 0.02414132f, -0.05124060f, 0.01946468f, 0.01810793f, 
    0.13560192f, 0.08598169f, 0.06065149f, 0.04921262f, 0.26259825f, 0.31058857f, 0.06993270f, 0.14938982f, 
    0.08167889f, 0.05139064f, 0.05470685f, 0.13344379f, 0.00495864f, 0.05452073f, -0.00040164f, -0.06585954f, 
    0.13829266f, 0.20778425f, 0.07350697f, 0.17534493f, 0.05027329f, -0.00204345f, 0.08524374f, 0.01683828f, 
    -0.16702315f, 0.00911928f, 0.00935804f, -0.00633231f, -0.10734253f, 0.11185351f, -0.00679385f, 0.03974378f, 
    -0.03704802f, 0.00936188f, -0.05342558f, -0.02299520f, -0.01311106f, -0.06975603f, -0.03895255f, -0.03712936f, 
    -0.13472444f, -0.21233033f, -0.13977085f, -0.14229399f, 0.00944474f, 0.07631893f, 0.05252722f, 0.00028190f, 
    0.06891582f, 0.03139789f, 0.12908609f, 0.05272492f, -0.14244486f, -0.25135225f, -0.00718775f, -0.00401519f, 
    0.02062218f, 0.04437034f, 0.09728975f, -0.04598396f, 0.00830274f, -0.10913373f, 0.00992100f, -0.13025208f, 
    0.26082081f, 0.09421860f, 0.18101366f, -0.09731507f, 0.07161461f, 0.13798146f, 0.06940298f, 0.07848155f, 
    0.03715816f, 0.01725141f, 0.08605027f, 0.05238136f, 0.00726788f, 0.04805031f, 0.08304170f, 0.01454429f, 
    -0.02352579f, -0.03399373f, -0.27668744f, -0.08872291f, -0.12742400f, -0.02958181f, 0.03807165f, -0.05572706f, 
    0.14984407f, 0.24113420f, -0.20521027f, 0.12573801f, -0.05097123f, -0.15235165f, 0.08501633f, -0.03201255f, 
    0.01820377f, -0.09172779f, 0.16141443f, 0.05457341f, 0.01446657f, -0.18232523f, -0.02161507f, 0.08227858f, 
    0.15709029f, -0.03580795f, -0.03484420f, 0.00460538f, -0.04700769f, -0.03359310f, 0.00201015f, -0.15133418f, 
    -0.00465381f, 0.06139591f, 0.34141713f, -0.03366660f, 0.04761805f, 0.04144757f, 0.07176799f, 0.12364386f, 
    0.03189692f, -0.02591559f, -0.02685221f, 0.00113130f, 0.05159038f, 0.02615843f, 0.01114701f, -0.20016398f, 
    -0.13730280f, -0.02781236f, 0.00350431f, -0.03502436f, -0.15336071f, -0.03922256f, 0.06857716f, 0.03970813f, 
    0.29952306f, 0.15284461f, 0.13808173f, 0.25502560f, 0.07374775f, 0.09862033f, 0.05735017f, 0.13835755f, 
    -0.08352936f, -0.04820355f, 0.00941088f, -0.09456330f, -0.01074559f, 0.02606603f, 0.07432309f, 0.16516784f, 
    -0.05001754f, 0.01297361f, 0.02134821f, -0.07692179f, 0.11101643f, -0.19502103f, -0.11547568f, 0.08934852f, 
    -0.04690781f, -0.08362037f, -0.09492497f, -0.07035826f, 0.12602352f, 0.12831256f, -0.08911438f, 0.08647066f, 
    0.00982733f, 0.06419506f, 0.02178517f, 0.06578164f, -0.08189108f, 0.01090156f, 0.16600052f, 0.05815692f, 
    -0.10969702f, 0.06099100f, -0.00966909f, 0.07900915f, -0.01286138f, -0.09245048f, -0.16716921f, 0.01138250f, 
    0.13852939f, -0.35567033f, 0.43435115f, -0.06523786f, -0.08001320f, -0.00102530f, -0.08738443f, 0.08052605f, 
    -0.05067452f, -0.04680720f, -0.12507738f, 0.06966355f, -0.04148395f, 0.02702892f, 0.01674053f, -0.09235204f, 
    -0.00676163f, 0.06055105f, 0.05052359f, -0.03893641f, 0.02663523f, 0.09504100f, -0.09250825f, 0.04301716f, 
    0.16410734f, -0.06169704f, -0.04033362f, -0.07341431f, 0.03738535f, -0.10219754f, -0.04955707f, -0.05051578f, 
    0.11086615f, -0.02547027f, 0.07261109f, 0.10288869f, 0.12764776f, 0.07620426f, -0.23255026f, 0.02006163f, 
    0.08770088f, -0.09944473f, -0.19716451f, 0.13958965f, -0.12643413f, -0.05435042f, -0.02833358f, -0.00371539f, 
    -0.18552294f, 0.26809350f, 0.43572325f, -0.32066280f, 0.03310686f, 0.03807659f, 0.16540202f, -0.00893507f, 
    -0.03493599f, 0.02906466f, -0.09503791f, -0.07548153f, -0.35344684f, -0.24031840f, -0.17665264f, -0.04077242f, 
    0.09703015f, 0.00379438f, 0.03621785f, 0.04805770f, 0.07699753f, -0.05610946f, 0.12581329f, -0.05633076f, 
    0.26397356f, 0.10918647f, 0.05643998f, 0.17124887f, 0.08051946f, 0.01678377f, 0.08585741f, -0.01539964f, 
    -0.03580017f, -0.08862776f, -0.00839279f, 0.01069315f, 0.26036328f, 0.24355990f, 0.06755397f, 0.09632903f, 
    -0.15358149f, -0.01702409f, 0.05461335f, 0.03466745f, 0.04383096f, -0.16631424f, 0.08527871f, -0.08492424f, 
    0.03840181f, -0.01049550f, -0.06841619f, 0.27620873f, 0.05768567f, 0.03398583f, -0.02042043f, 0.13211660f, 
    -0.04075414f, 0.01367028f, -0.02874838f, -0.05443944f, 0.18564191f, 0.20743015f, 0.29098216f, 0.06425155f, 
    0.12485889f, -0.07886516f, 0.00939102f, 0.07717722f, -0.06916787f, -0.00910154f, -0.02177203f, -0.05448184f, 
    0.01217387f, -0.11800396f, -0.15178299f, -0.08144348f, 0.04908198f, 0.05652479f, 0.02089062f, 0.06691784f, 
    -0.00877990f, 0.00050188f, 0.05567884f, -0.03991624f, -0.05649085f, -0.24251246f, -0.03647348f, -0.06527528f, 
    0.14994210f, 0.09053820f, -0.02989428f, -0.01762366f, 0.04826634f, -0.00562000f, 0.10432732f, 0.10877421f, 
    0.11988855f, -0.01108582f, -0.05471302f, 0.04829059f, -0.00376532f, 0.07480273f, -0.02402533f, -0.06430922f, 
    -0.08477441f, 0.01126142f, 0.10843439f, -0.06845621f, 0.23633276f, -0.11618507f, 0.12016721f, 0.00754497f, 
    -0.03830894f, -0.00919021f, -0.05564773f, -0.10812470f, -0.00916993f, 0.01095747f, 0.01369561f, -0.05075799f, 
    -0.02795951f, 0.06046274f, -0.04638685f, 0.03412987f, -0.02120612f, 0.08352865f, 0.04517444f, -0.11309337f, 
    0.07514318f, 0.05807356f, 0.07561814f, 0.01346541f, 0.07258286f, 0.13272265f, 0.08845697f, -0.05445224f, 
    0.11913223f, 0.08739448f, -0.04517224f, 0.00977204f, -0.10377688f, 0.09682174f, 0.03898470f, -0.03662270f, 
    0.17715666f, 0.10850798f, -0.26635256f, 0.28162616f, -0.00404882f, 0.03768822f, 0.03929351f, 0.12833469f, 
    0.17510331f, 0.06646986f, 0.01366450f, -0.06706201f, 0.43758586f, 0.32427382f, -0.04621308f, 0.11044401f, 
    0.13585509f, 0.04583672f, 0.03550880f, 0.16056965f, -0.01075589f, 0.05794286f, -0.02037602f, -0.06102606f, 
    0.19303751f, -0.02587670f, -0.01425536f, 0.12849297f, 0.04315297f, -0.02418356f, -0.08998712f, 0.02456247f, 
    -0.03341516f, -0.07667106f, -0.11338633f, -0.04168463f, 0.11569662f, 0.15808380f, -0.08701755f, -0.16831832f, 
    -0.01767735f, -0.04388902f, 0.09988532f, -0.07972192f, -0.01947223f, -0.07000686f, -0.00386720f, -0.00743172f, 
    -0.17918135f, -0.30558422f, -0.14826407f, 0.01108348f, 0.05240688f, 0.06189838f, 0.01627868f, -0.02989836f, 
    0.03867904f, 0.01964031f, -0.02218687f, 0.08164573f, -0.16977230f, -0.27869496f, -0.00290746f, 0.26320544f, 
    -0.02696560f, -0.02650269f, -0.03938015f, 0.00007171f, 0.00713525f, -0.14034535f, 0.00902083f, 0.08001205f, 
    -0.03235563f, 0.01384382f, -0.00696132f, -0.04542106f, 0.03747423f, -0.04800583f, 0.01642993f, -0.04655030f, 
    -0.03830280f, 0.02407222f, -0.01237106f, -0.00783619f, -0.03223915f, -0.03705543f, 0.01999072f, -0.02023542f, 
    -0.00114245f, 0.02796982f, -0.02408683f, -0.01261863f, -0.01605080f, 0.02895842f, -0.03919214f, -0.03544396f, 
    0.02726502f, -0.00844932f, -0.00687491f, -0.02281478f, -0.00888989f, -0.00158429f, -0.03723554f, 0.04372359f, 
    -0.02524049f, -0.04855139f, -0.01961442f, -0.00836847f, 0.01233643f, -0.04040273f, 0.01570922f, 0.02163972f, 
    0.03952705f, 0.01738389f, 0.02595494f, -0.04204684f, 0.00737552f, -0.01635204f, -0.04843727f, 0.01672030f, 
    0.03509269f, 0.01220284f, -0.02543140f, -0.03206585f, -0.00756238f, -0.04503960f, 0.01082432f, -0.01324960f, 
    -0.03412525f, 0.01305166f, -0.05459823f, 0.00520296f, 0.02061955f, 0.02814415f, -0.05130677f, -0.00339211f, 
    -0.03590092f, -0.00736945f, 0.01751390f, 0.03141494f, -0.04990259f, -0.03911459f, 0.00027203f, 0.00332647f, 
    -0.01435102f, 0.01329293f, -0.01226902f, -0.02857764f, -0.05132898f, 0.03215120f, -0.01803155f, -0.03590814f, 
    0.01460816f, -0.05044782f, 0.04075162f, -0.01783523f, 0.00144268f, 0.03422602f, 0.03468411f, -0.03394290f, 
    -0.02915818f, 0.02717791f, 0.00181213f, -0.05010882f, -0.03618971f, 0.03987066f, -0.01685433f, 0.02265896f, 
    -0.01331028f, 0.00844867f, -0.00618523f, 0.02356982f, 0.03986929f, 0.01366341f, 0.01797451f, -0.00136557f, 
    0.03869436f, 0.04322064f, -0.01038784f, -0.00097043f, -0.03473656f, 0.00108003f, 0.00980970f, 0.03714057f, 
    -0.00814583f, -0.00228857f, -0.02005049f, 0.04152558f, 0.02115906f, -0.04880134f, -0.03096524f, 0.04050502f, 
    -0.02921706f, 0.02340699f, -0.01063740f, -0.01708337f, 0.01252963f, 0.03930184f, -0.03634327f, 0.03648174f, 
    0.02215990f, 0.02901048f, -0.01838342f, -0.03313117f, -0.04289155f, -0.03063370f, 0.03992557f, 0.00057307f, 
    -0.03946138f, -0.01294053f, -0.05118193f, -0.04924021f, -0.01731037f, 0.03110500f, 0.01017669f, 0.04424352f, 
    -0.01535371f, 0.02652581f, 0.00489309f, 0.03063552f, -0.01800195f, -0.03129007f, -0.04113971f, -0.02104980f, 
    -0.01356479f, 0.00702449f, -0.01306278f, -0.05619688f, -0.05338617f, 0.03868354f, -0.03066180f, 0.03039910f, 
    0.01251087f, -0.00743664f, 0.00695473f, 0.01475141f, -0.03453017f, 0.02290767f, -0.02502602f, 0.03740252f, 
    -0.03061337f, 0.01774947f, 0.00929111f, -0.00046217f, -0.04398593f, -0.00132463f, -0.03936035f, -0.00417759f, 
    -0.02737352f, -0.01549323f, -0.04101187f, -0.03347228f, 0.02070395f, -0.05328564f, 0.02962674f, -0.02148425f, 
    0.00332635f, -0.03175815f, 0.04243663f, -0.02225409f, 0.02399475f, 0.00516860f, -0.01935731f, -0.02421094f, 
    -0.00432231f, -0.04875227f, 0.02598945f, -0.01493450f, 0.01104944f, -0.03461037f, 0.01332088f, -0.01329404f, 
    0.00612986f, 0.03492868f, -0.04905280f, 0.02032225f, -0.01496000f, -0.00310429f, -0.03854502f, -0.00320917f, 
    0.00481192f, 0.02482641f, 0.02681677f, -0.02850330f, -0.02255870f, 0.02341735f, 0.02588945f, 0.00027749f, 
    -0.00532587f, 0.02725982f, -0.05494519f, -0.04745926f, -0.00081860f, -0.04978721f, -0.02776581f, -0.04329768f, 
    0.02567372f, -0.04054550f, 0.01115171f, -0.04003801f, -0.05302858f, -0.04200209f, -0.00995646f, 0.04053584f, 
    0.02372833f, -0.02067540f, -0.04558086f, 0.03486931f, -0.05164557f, 0.01685454f, 0.00817107f, 0.03622286f, 
    -0.02396361f, 0.01347808f, 0.03844132f, -0.02370012f, -0.00897152f, 0.04466550f, -0.02431817f, -0.03668940f, 
    -0.05099492f, -0.03858589f, 0.02930631f, -0.03916362f, -0.05265171f, -0.00172368f, -0.04408277f, 0.03669436f, 
    0.01503097f, -0.03318075f, -0.03865073f, -0.01698902f, 0.02924650f, -0.03759068f, 0.02464839f, -0.00751834f, 
    -0.00937752f, 0.03353508f, -0.04368870f, 0.03149042f, -0.01155176f, -0.02932845f, -0.03111112f, 0.01376028f, 
    0.02173640f, -0.05681922f, -0.00615873f, -0.04385182f, -0.05203729f, 0.01017113f, -0.00722333f, -0.00227251f, 
    -0.04011853f, -0.04455794f, 0.00072146f, -0.01239399f, -0.00137846f, 0.03298323f, -0.04444394f, 0.02040811f, 
    -0.03841515f, 0.02378859f, -0.04849618f, -0.00726565f, -0.01243219f, 0.02573140f, 0.00024929f, 0.04410173f, 
    0.04171018f, 0.02140386f, 0.01690866f, -0.02772992f, 0.00888889f, -0.04059971f, -0.02921135f, -0.05295765f, 
    -0.04795163f, -0.01116854f, 0.00890662f, 0.02365409f, -0.02922055f, 0.04017808f, 0.03662595f, -0.00232721f, 
    -0.04624357f, 0.01770901f, 0.03042519f, 0.03818769f, -0.05036282f, -0.05205925f, -0.05125247f, -0.05062236f, 
    -0.01668693f, 0.03001395f, -0.00042236f, -0.00219676f, -0.05192831f, -0.00864076f, -0.00742750f, -0.03077245f, 
    0.01346155f, 0.04491847f, 0.03866623f, 0.04392300f, -0.03974987f, 0.00134654f, -0.01971602f, -0.00564746f, 
    -0.01312448f, -0.00950072f, -0.04465815f, 0.03840512f, -0.02078333f, -0.04226926f, 0.02190950f, -0.03797117f, 
    0.03970685f, 0.04413030f, 0.00810267f, -0.02792853f, -0.03353688f, -0.04666239f, 0.00797976f, -0.02454932f, 
    -0.02071199f, -0.00914031f, -0.04465486f, -0.04785121f, -0.00739972f, 0.02028530f, -0.04173373f, -0.01290550f, 
    0.02059384f, -0.03303270f, 0.01815515f, -0.00726495f, -0.05217509f, -0.00457658f, -0.03413881f, -0.01981651f, 
    -0.02321678f, -0.04542208f, -0.01211669f, -0.05164690f, -0.00173966f, -0.03312310f, -0.04689426f, -0.01509772f, 
    -0.01925324f, -0.00828440f, -0.02019367f, 0.00460464f, 0.01625148f, -0.01227852f, 0.00782597f, -0.04610790f, 
    0.21194954f, 0.17128548f, 0.05681181f, -0.01609094f, 0.08349066f, 0.12970087f, 0.20363520f, 0.03421563f, 
    -0.01089513f, 0.00076215f, 0.02700895f, 0.01175048f, 0.14832318f, -0.47212601f, 0.14886622f, -0.06717765f, 
    -0.06975466f, 0.05735292f, 0.15226871f, -0.16000150f, 0.18029663f, 0.02423598f, 0.06318818f, 0.08073296f, 
    0.05524363f, 0.12491116f, -0.07172737f, 0.13233037f, 0.00400867f, 0.03939792f, 0.10805673f, 0.07898213f, 
    0.10232314f, 0.07981753f, 0.04165402f, -0.01422584f, 0.34433523f, -0.05574825f, -0.00923918f, 0.09218010f, 
    0.07933114f, 0.13413279f, -0.08485042f, 0.09012436f, 0.02570025f, 0.00831479f, -0.05859470f, -0.09601101f, 
    0.04751044f, 0.25584736f, 0.04040679f, -0.19924733f, -0.03990583f, 0.05089454f, 0.00920182f, 0.03666499f, 
    -0.00416177f, 0.08974445f, -0.01828207f, 0.06104727f, -0.16481765f, 0.24529648f, -0.19086954f, 0.22505699f, 
    -0.02295287f, -0.04425712f, 0.12529784f, 0.04696923f, 0.16629434f, -0.12242775f, 0.09337381f, 0.10891966f, 
    0.30567268f, 0.07991779f, -0.01357415f, -0.20479365f, 0.14609218f, 0.16569032f, 0.08505080f, 0.00923251f, 
    -0.01553931f, -0.00774681f, 0.08856605f, 0.06545892f, 0.03043853f, -0.01752656f, -0.10440420f, 0.00472859f, 
    0.00614242f, -0.01150003f, -0.04821122f, -0.03847991f, 0.01456760f, -0.02029070f, -0.16463776f, -0.06344607f, 
    0.09711431f, 0.02509156f, -0.12566938f, 0.01881314f, -0.04914089f, 0.06386422f, -0.09787324f, 0.06362145f, 
    0.10171211f, 0.06680311f, 0.10702734f, -0.01667017f, 0.21231234f, 0.03043799f, 0.15761359f, 0.00910885f, 
    0.01257065f, 0.10303949f, 0.10929865f, 0.06429533f, 0.06745188f, -0.02000247f, 0.03478249f, 0.06785603f, 
    0.30718112f, -0.08662704f, -0.01852078f, -0.03129340f, 0.02822664f, -0.00890127f, 0.09497441f, 0.00780784f, 
    0.11647753f, -0.04942030f, -0.03199998f, -0.06035083f, -0.12789278f, 0.03042105f, -0.02891481f, 0.01384350f, 
    -0.01020796f, -0.01510516f, 0.00854994f, 0.02183930f, 0.00046375f, 0.00206444f, -0.08928012f, 0.00315256f, 
    0.03746470f, 0.05269489f, 0.01954721f, 0.02254729f, 0.01119017f, 0.07972976f, 0.03102560f, -0.01710421f, 
    0.10296477f, 0.01581032f, 0.09769505f, -0.03718087f, -0.03254831f, -0.11645525f, 0.01606958f, -0.14205973f, 
    0.05565806f, 0.09537508f, 0.01851270f, 0.13510311f, 0.01569139f, -0.01649616f, 0.07624879f, -0.06430778f, 
    -0.01523053f, 0.24492106f, 0.13891953f, -0.09681266f, 0.04921955f, 0.09181877f, 0.19743089f, 0.06447276f, 
    -0.01672397f, 0.10467567f, 0.10328387f, 0.02974939f, 0.05186637f, 0.13876083f, -0.08519141f, 0.00741319f, 
    -0.05919301f, 0.02678396f, 0.04626090f, -0.02678397f, -0.07396810f, 0.04128293f, 0.05061672f, -0.01310984f, 
    -0.15709874f, 0.06915812f, 0.03784821f, -0.09632312f, -0.19745541f, 0.18766747f, 0.03793968f, 0.08367469f, 
    0.08964569f, -0.05361576f, -0.00227207f, 0.04418249f, 0.01045405f, -0.02854441f, 0.12517664f, -0.12568858f, 
    -0.02858653f, 0.15719159f, 0.14738071f, 0.22405140f, -0.00102616f, 0.00945211f, 0.07795444f, 0.04578596f, 
    0.10947559f, -0.21444061f, -0.12136006f, 0.16592737f, 0.04174965f, 0.08063836f, -0.03394686f, 0.18593708f, 
    -0.01245990f, 0.02170202f, -0.01918652f, 0.15302379f, 0.16935198f, 0.11065689f, 0.07674324f, -0.05391642f, 
    0.01009234f, 0.05224956f, 0.00528408f, -0.05299951f, -0.05205945f, -0.02186273f, -0.01287002f, 0.02538209f, 
    -0.00515498f, -0.07328521f, -0.04158509f, 0.09120379f, 0.04580753f, -0.02993325f, 0.00917208f, 0.04670878f, 
    -0.09305304f, -0.04728490f, 0.07050752f, 0.03559395f, -0.06174808f, -0.09260228f, -0.04643685f, -0.02427734f, 
    -0.15278177f, -0.08174024f, -0.07942768f, -0.08766878f, -0.02160458f, -0.06141468f, 0.00731480f, -0.03475446f, 
    -0.09880679f, 0.10423753f, -0.01351221f, -0.05008975f, 0.05455077f, -0.09067324f, -0.00736208f, 0.05034977f, 
    -0.15629891f, -0.15748483f, -0.10086402f, -0.06647540f, -0.18840617f, 0.08933179f, -0.06255462f, 0.11888417f, 
    -0.05131953f, -0.01641416f, 0.07697521f, 0.00105971f, -0.02194889f, 0.09401524f, 0.05214040f, 0.07307316f, 
    -0.19876856f, -0.03367700f, -0.02917520f, -0.07672342f, -0.09461010f, -0.02226577f, -0.01174593f, -0.06647037f, 
    -0.03977683f, 0.04182108f, 0.13843402f, -0.04891680f, 0.11212000f, 0.23717386f, 0.03588301f, 0.02585608f, 
    0.04334617f, 0.12936077f, 0.08390755f, -0.07413636f, -0.04891944f, -0.02250800f, -0.03322113f, -0.15341063f, 
    -0.03428623f, -0.06175008f, -0.01596487f, -0.04947331f, -0.04123516f, 0.06493700f, -0.10547509f, -0.10018016f, 
    -0.12243414f, -0.05192845f, -0.08558039f, -0.07963940f, -0.02453514f, 0.25842625f, -0.07437301f, -0.05039228f, 
    -0.02274691f, 0.01536052f, 0.05461541f, -0.07243764f, -0.00099847f, -0.03148653f, 0.03411727f, -0.01444311f, 
    -0.00624138f, 0.22990826f, -0.14386353f, -0.11857964f, 0.06144857f, 0.16997163f, 0.15970920f, -0.00306726f, 
    0.01666504f, -0.01694020f, 0.02021457f, 0.03188696f, -0.35518211f, 0.19535984f, 0.03906372f, -0.25371188f, 
    -0.02856510f, 0.03340789f, 0.03800895f, 0.03890257f, 0.04100521f, 0.14602640f, -0.05421273f, -0.05054073f, 
    -0.04016053f, 0.04464562f, -0.03384841f, -0.04496302f, -0.04270447f, -0.07004398f, -0.06255440f, -0.02091343f, 
    -0.18819286f, -0.08522390f, -0.04560643f, -0.05244340f, 0.05307652f, -0.03680357f, 0.13991497f, 0.06328826f, 
    -0.16151012f, -0.00010529f, 0.06126909f, -0.02167770f, 0.05074657f, 0.00480797f, 0.16472931f, 0.09408163f, 
    0.26557386f, 0.14162843f, 0.15754530f, 0.20331439f, -0.12594315f, 0.06225421f, -0.00045973f, -0.08146754f, 
    -0.13853453f, 0.01862778f, -0.03988656f, -0.16803162f, -0.05321632f, -0.12088054f, 0.31644452f, -0.00687757f, 
    0.08147602f, 0.03118262f, 0.08796668f, -0.00145020f, 0.02266131f, 0.00691488f, 0.10026564f, 0.03701098f, 
    0.17146076f, 0.06782824f, -0.12662877f, 0.18100391f, 0.07441082f, -0.08837361f, 0.01834851f, -0.06217301f, 
    -0.12140232f, 0.00384574f, -0.06462985f, -0.04257318f, 0.28793609f, 0.08762468f, -0.05273766f, 0.21785161f, 
    -0.02216324f, 0.00704430f, -0.08733215f, 0.03941948f, -0.02751351f, -0.00152976f, -0.14741202f, -0.05448969f, 
    -0.06553473f, 0.30344790f, -0.09184092f, -0.08654196f, -0.02860826f, -0.05941894f, -0.03563122f, 0.06874195f, 
    -0.07642990f, 0.00868797f, 0.01946712f, 0.01253956f, -0.15652680f, 0.29976708f, -0.24978295f, 0.32451805f, 
    0.00719614f, -0.02884129f, 0.13602483f, 0.02166983f, 0.14217886f, 0.01481455f, 0.07948032f, 0.10309403f, 
    0.05959728f, -0.07918917f, -0.02239677f, -0.15150586f, 0.04198555f, -0.10782413f, 0.01537236f, 0.07769128f, 
    -0.01982138f, -0.03915442f, -0.02374798f, 0.06098980f, 0.09640731f, -0.04703975f, -0.05917808f, 0.13858078f, 
    -0.08624806f, 0.00649159f, -0.04461725f, -0.05931498f, -0.15528314f, 0.17814946f, 0.04636993f, 0.26720473f, 
    0.23570393f, 0.19289047f, -0.05307781f, 0.07268501f, 0.04664507f, -0.03079940f, 0.02975508f, -0.06441627f, 
    -0.09768221f, -0.04148474f, -0.00230578f, 0.01494326f, 0.10116129f, -0.07984621f, 0.19110253f, -0.24216120f, 
    -0.02634134f, 0.04202881f, 0.01499765f, -0.02766647f, 0.06824545f, 0.14103843f, 0.05623369f, -0.07669020f, 
    -0.16172221f, 0.23602588f, -0.16668880f, 0.09015945f, 0.03976188f, -0.12431590f, 0.11249674f, -0.01247583f, 
    -0.06524660f, -0.07296786f, -0.00001743f, 0.06250726f, -0.02531237f, 0.05454310f, -0.00583084f, 0.05515996f, 
    -0.07065415f, -0.09931774f, -0.05929409f, 0.00371282f, -0.06447421f, -0.06670143f, 0.15203027f, 0.05183170f, 
    0.10583501f, 0.23432261f, 0.05227880f, -0.02186098f, 0.03482342f, 0.07172054f, 0.03590308f, -0.03824816f, 
    -0.02786038f, 0.09618140f, -0.03843211f, -0.00057337f, -0.10486339f, -0.01360491f, 0.26450518f, -0.03472167f, 
    -0.13477786f, 0.03415880f, 0.19618899f, 0.01283690f, -0.03926184f, -0.00629059f, 0.00053538f, 0.01974966f, 
    -0.26938701f, 0.49687284f, -0.20052814f, -0.00937810f, 0.05945928f, 0.04517373f, 0.09704072f, 0.02480450f, 
    0.02285246f, 0.06947102f, -0.05828744f, 0.10488959f, 0.38374299f, 0.07326532f, 0.02255533f, 0.00615714f, 
    -0.08021866f, -0.02790490f, 0.00464317f, -0.08825088f, -0.05609681f, 0.02726779f, -0.09845302f, -0.02136943f, 
    -0.00746914f, 0.11794975f, 0.00767463f, -0.13263513f, -0.03764259f, 0.06723939f, 0.01462074f, 0.03221839f, 
    -0.00010072f, 0.07017276f, -0.08202714f, -0.15128440f, 0.16038981f, -0.15775436f, 0.09076519f, 0.05982315f, 
    0.09561110f, 0.14328024f, -0.11825902f, 0.07017086f, -0.10769260f, -0.02910341f, -0.08598357f, 0.10594045f, 
    0.28499317f, -0.20653298f, 0.09354549f, 0.19029531f, -0.09961227f, -0.08807988f, 0.00866067f, -0.10824463f, 
    -0.12172678f, 0.17175767f, -0.10021909f, 0.01308555f, 0.05779129f, 0.01320142f, -0.07761347f, 0.05456956f, 
    -0.10659797f, -0.05279517f, 0.02408820f, -0.01922531f, 0.05979062f, 0.03585649f, -0.03149717f, 0.07928449f, 
    0.20160902f, -0.06730138f, 0.07391196f, 0.03626375f, -0.05797132f, 0.02349872f, 0.10000546f, -0.01832468f, 
    -0.10961182f, 0.00355052f, -0.07659116f, -0.05613916f, 0.08784325f, 0.01613075f, 0.04489584f, 0.05998369f, 
    -0.02847718f, -0.04680533f, -0.04537794f, -0.05028817f, -0.00110591f, -0.03249758f, 0.01999687f, 0.06516417f, 
    -0.24123044f, 0.10563426f, 0.05206210f, 0.00598471f, -0.04044554f, -0.01708251f, -0.06071241f, -0.03516396f, 
    0.09933668f, 0.09224856f, 0.07385177f, 0.30699605f, -0.07700362f, 0.08793998f, 0.02591420f, 0.08035864f, 
    -0.01220128f, 0.09976936f, 0.06564334f, -0.01867754f, -0.00500367f, -0.05307739f, 0.04080994f, -0.03440702f, 
    -0.01757834f, 0.03025503f, 0.05242002f, 0.02734445f, 0.00694399f, 0.07163255f, 0.06671054f, 0.03213404f, 
    -0.10817523f, -0.05569667f, -0.14573917f, -0.07694425f, 0.18886252f, 0.19156098f, -0.13675468f, 0.17812231f, 
    0.06961524f, 0.16552550f, -0.01324639f, -0.13906853f, 0.02893218f, 0.04499636f, -0.03077506f, 0.02974869f, 
    0.13582346f, -0.06729633f, 0.19776770f, -0.09103274f, -0.14579041f, -0.13799283f, -0.06738926f, -0.10067353f, 
    -0.05058888f, 0.07601799f, -0.07088908f, 0.00328327f, -0.09702130f, 0.13835990f, -0.01290504f, 0.13178805f, 
    0.02745198f, -0.02465615f, 0.06653730f, -0.01774753f, 0.05420284f, -0.07024887f, -0.01073937f, -0.05481697f, 
    -0.10210896f, 0.29304835f, 0.00451772f, -0.01170954f, 0.00701323f, 0.03430726f, 0.00666998f, 0.03766705f, 
    -0.07902029f, 0.06155999f, 0.07355726f, -0.00012550f, 0.05156174f, 0.16425638f, 0.05304202f, 0.02470751f, 
    0.03233173f, 0.20207182f, -0.05621182f, 0.00700511f, -0.03412531f, 0.10818591f, 0.10387015f, 0.08006249f, 
    0.06571404f, 0.04798041f, 0.03961642f, 0.01737302f, -0.04782191f, -0.05195802f, 0.04016383f, -0.02118574f, 
    0.14296794f, 0.03618057f, 0.08721296f, 0.04690909f, 0.12555237f, -0.02430288f, 0.12017494f, -0.11170775f, 
    -0.01462604f, 0.03382673f, 0.01978845f, 0.02599795f, -0.06762324f, -0.04938972f, -0.05522128f, -0.10663356f, 
    -0.16056618f, 0.00775055f, -0.03857897f, -0.08299683f, 0.22116268f, -0.02773602f, -0.01552485f, -0.06187194f, 
    0.02894985f, 0.01285540f, -0.08227273f, 0.02058820f, 0.03834617f, 0.11521161f, -0.08018032f, -0.15077049f, 
    0.15842681f, -0.10104931f, 0.11628176f, 0.03271700f, 0.09465421f, 0.13693698f, 0.03229525f, 0.00693227f, 
    -0.01886054f, -0.18256493f, 0.14011851f, -0.08608665f, -0.06970470f, 0.13683155f, 0.06380627f, 0.37543154f, 
    0.33396330f, -0.02069401f, 0.04642772f, -0.15987001f, 0.19263534f, 0.13110837f, -0.18244018f, -0.06183551f, 
    0.06257223f, 0.03224862f, 0.07965825f, -0.02177884f, 0.08707417f, 0.01648219f, 0.09404857f, 0.17774750f, 
    -0.10113886f, -0.08076868f, 0.05885324f, 0.10238554f, 0.04759328f, 0.11155710f, 0.02470620f, 0.00155476f, 
    0.06804796f, 0.01046488f, -0.00713249f, -0.00913625f, 0.14203364f, -0.11196592f, 0.43034497f, -0.15216279f, 
    0.09028447f, -0.09586138f, -0.04455378f, 0.15630719f, 0.09749635f, 0.04746103f, -0.05249772f, 0.12930936f, 
    0.15079446f, 0.11643939f, 0.16722007f, 0.11757968f, 0.05638109f, -0.00364664f, 0.05600962f, -0.08591928f, 
    0.02781537f, 0.10107534f, 0.02941223f, 0.07727828f, 0.07846034f, 0.10727485f, -0.06224451f, -0.12742530f, 
    0.00225968f, 0.00685421f, 0.04015071f, 0.01746100f, 0.01631160f, -0.05242288f, -0.05264856f, -0.28529602f, 
    -0.05838662f, -0.23349388f, -0.14727075f, -0.10810663f, -0.08766489f, -0.01672888f, 0.08362512f, -0.03676395f, 
    0.02076479f, 0.11770739f, 0.04079821f, -0.06138660f, -0.14834706f, 0.17983066f, -0.16674218f, 0.10823994f, 
    -0.00065213f, 0.06087162f, 0.16352934f, -0.08141749f, -0.03545976f, 0.18988672f, -0.06731363f, 0.16640304f, 
    0.09032715f, -0.07786425f, 0.05554802f, -0.00983913f, 0.11412282f, 0.05338904f, 0.16390193f, 0.17695276f, 
    0.14908977f, 0.04475362f, 0.07104244f, -0.07023025f, -0.00494257f, 0.01138176f, 0.03199436f, -0.18076782f, 
    -0.00527355f, 0.03632358f, -0.03976263f, 0.02956977f, -0.00863405f, 0.10154445f, -0.06820981f, -0.02573050f, 
    -0.08454821f, 0.09264467f, -0.16295163f, 0.08522318f, -0.04886545f, -0.00330612f, -0.01864382f, 0.00464645f, 
    0.01506442f, 0.16945708f, -0.03539808f, 0.02337603f, -0.06340436f, -0.00633369f, -0.11740468f, -0.06711939f, 
    0.02706677f, 0.07168065f, -0.08788513f, 0.07789003f, 0.09610522f, -0.01634093f, 0.03338927f, -0.05606280f, 
    0.11270497f, -0.51226491f, 0.21855031f, 0.07372431f, -0.03293953f, 0.00721784f, -0.04009078f, 0.21504080f, 
    0.06442522f, 0.11798613f, 0.17402938f, -0.11763411f, -0.13022628f, -0.08406842f, -0.04494755f, 0.04470895f, 
    0.03208447f, 0.04714423f, -0.08045965f, -0.02530260f, 0.03557293f, -0.03325002f, -0.00771069f, 0.02380778f, 
    -0.15838289f, -0.10644735f, -0.03775968f, -0.02560806f, -0.00934984f, -0.03012995f, 0.00158268f, 0.17458656f, 
    0.03509669f, 0.15522273f, 0.14122194f, 0.13976786f, -0.29474017f, 0.26209870f, -0.00906406f, 0.03935355f, 
    0.01975540f, 0.02426640f, 0.05478142f, 0.01996150f, 0.03035272f, 0.04768506f, 0.19173642f, -0.05579364f, 
    -0.04301072f, 0.24771146f, -0.08734478f, -0.39160761f, 0.07664312f, 0.09485326f, 0.06177051f, 0.07369844f, 
    0.10044087f, 0.00711283f, -0.06901665f, 0.12399016f, -0.15946908f, 0.06210116f, -0.02787648f, 0.06948992f, 
    0.06179789f, 0.11273672f, 0.00668170f, -0.04225700f, -0.01139402f, 0.01570787f, -0.02937280f, 0.04386557f, 
    -0.02990655f, -0.03435082f, -0.02871458f, -0.06490095f, 0.06142407f, 0.08698398f, 0.01138842f, -0.00676991f, 
    0.07983392f, -0.03970426f, 0.06844054f, 0.04256235f, 0.00621752f, -0.02635916f, -0.02247594f, 0.06193016f, 
    0.05396932f, -0.03116894f, -0.00722860f, -0.00538102f, 0.02616915f, -0.02517164f, -0.03453224f, -0.04382732f, 
    0.04510707f, -0.17835659f, 0.04753234f, -0.12925720f, 0.09324220f, 0.09481403f, 0.06315698f, 0.07493357f, 
    -0.03241414f, -0.01914075f, 0.06581701f, -0.15538238f, -0.05751212f, -0.01744966f, 0.03735889f, 0.01583193f, 
    -0.02998842f, -0.11631464f, 0.02246824f, 0.13084047f, -0.03450005f, 0.11244379f, 0.02522350f, 0.02377004f, 
    0.04214603f, -0.01206122f, 0.03189353f, -0.03295145f, -0.01761465f, -0.09711101f, -0.12688981f, -0.01748296f, 
    0.04117296f, -0.12075465f, 0.10899042f, -0.01064789f, -0.03160352f, -0.12154371f, 0.13736862f, 0.00423077f, 
    -0.09515705f, -0.03765174f, 0.02263848f, 0.16232315f, 0.05167637f, 0.01045444f, -0.00176052f, -0.02672233f, 
    0.07941449f, -0.01069376f, -0.07902667f, 0.03071512f, -0.01602800f, 0.14943300f, -0.00993640f, -0.12888573f, 
    -0.08028542f, 0.03561531f, -0.00525597f, -0.00883389f, -0.16469099f, -0.10743390f, 0.17905302f, -0.04810179f, 
    -0.05341973f, 0.08689528f, 0.06656643f, -0.08425208f, 0.06843638f, 0.07945994f, 0.06673945f, 0.02393527f, 
    0.00561468f, -0.19169317f, 0.00543042f, -0.12853749f, -0.02803547f, 0.05426391f, -0.01069972f, -0.05568403f, 
    0.26724297f, -0.01164586f, 0.06667790f, 0.04895516f, -0.20284705f, -0.11694547f, -0.00350196f, -0.02442669f, 
    0.02371011f, 0.01896426f, -0.01594033f, 0.04024258f, 0.08524986f, -0.12710802f, -0.01411393f, -0.01086921f, 
    0.12933211f, 0.01809904f, 0.07028549f, 0.10810423f, 0.04860538f, -0.04462666f, -0.07164638f, -0.05295820f, 
    -0.00672637f, -0.06808215f, -0.04826779f, -0.05395535f, 0.05662606f, 0.13720430f, -0.12657103f, 0.22356774f, 
    -0.04690612f, -0.08485439f, -0.04911615f, -0.06456517f, 0.04424657f, -0.01383650f, 0.01531178f, 0.16187638f, 
    0.08881951f, 0.25618914f, 0.08946787f, 0.17546557f, -0.10227707f, 0.24919465f, 0.05681619f, 0.13301183f, 
    0.03808049f, -0.10783337f, -0.04536461f, 0.04744579f, 0.20682567f, 0.07356538f, -0.01262352f, 0.04946410f, 
    0.10288271f, -0.02464944f, -0.06688232f, 0.00489378f, -0.07754155f, -0.05445185f, 0.00503802f, 0.03950061f, 
    0.26793700f, -0.14353135f, 0.03995677f, -0.34350598f, -0.14889812f, 0.00152550f, -0.09975040f, -0.13563536f, 
    0.04699036f, -0.07987071f, -0.03994416f, -0.05510401f, 0.15421927f, -0.04236396f, 0.10220744f, -0.29217902f, 
    0.01891530f, -0.06313170f, 0.06252582f, 0.04130372f, 0.02142351f, 0.04513413f, -0.13287739f, 0.00703840f, 
    -0.08163758f, -0.01988902f, -0.11934647f, -0.05862280f, 0.17351159f, 0.08728406f, -0.00207702f, 0.04733545f, 
    -0.01099904f, -0.08632421f, -0.15881078f, -0.05200386f, 0.33991376f, -0.20183375f, 0.19548574f, -0.10289674f, 
    -0.03717774f, 0.11391057f, -0.24917608f, -0.07527632f, -0.02936239f, 0.13305892f, -0.03726867f, 0.01563172f, 
    0.21652335f, 0.04303597f, 0.10468932f, -0.28756762f, 0.09861545f, -0.11537925f, -0.03062986f, 0.19085377f, 
    -0.04615277f, -0.01380581f, -0.03892127f, 0.12699217f, 0.10903357f, 0.03398388f, 0.03116039f, 0.15236120f, 
    0.02592928f, -0.00739850f, -0.06646241f, 0.04776827f, -0.02118080f, 0.16291119f, 0.17971426f, 0.11212867f, 
    0.44687834f, -0.13018024f, 0.17182079f, -0.14797872f, -0.13725856f, -0.05797574f, -0.08058707f, -0.09499317f, 
    0.05998001f, -0.07119051f, -0.00459622f, 0.12906918f, -0.30585843f, 0.00473087f, -0.18533435f, -0.04413880f, 
    0.03350629f, -0.03997694f, -0.05062465f, 0.06203653f, 0.05771020f, -0.00666015f, 0.04583531f, -0.08455481f, 
    0.15573116f, 0.00587710f, 0.08421566f, -0.13394405f, -0.06325033f, -0.09488624f, -0.02607219f, 0.04532443f, 
    0.01590267f, -0.00136242f, -0.00727780f, 0.04421177f, 0.32593566f, -0.02189133f, 0.05663757f, 0.35964289f, 
    -0.10107145f, 0.00136355f, -0.08139902f, -0.14286985f, 0.12928058f, 0.07488598f, 0.22586043f, 0.03465258f, 
    0.29746416f, 0.01754633f, -0.10593008f, 0.05124088f, 0.01717747f, -0.04650300f, -0.00961414f, -0.09897763f, 
    -0.06743380f, 0.05868869f, -0.10393999f, 0.10957340f, -0.01010327f, -0.09079044f, -0.15415254f, 0.02607696f, 
    -0.08626556f, -0.02045769f, 0.06581496f, 0.01006596f, 0.08183674f, 0.12169234f, 0.12926927f, 0.09130183f, 
    0.01012744f, 0.11363208f, -0.11568461f, 0.15697281f, -0.00956333f, -0.03532199f, -0.25475621f, -0.05816696f, 
    0.00402270f, -0.08067489f, -0.05736460f, 0.00900231f, -0.05780972f, -0.07663602f, 0.00074098f, 0.11676720f, 
    0.05995340f, -0.07382345f, -0.08564024f, -0.08206148f, 0.04511712f, -0.11061815f, -0.02624347f, -0.18245417f, 
    0.12411690f, 0.20129523f, 0.16674200f, 0.17828882f, 0.17986652f, -0.06154745f, -0.08831529f, -0.11596434f, 
    0.01526986f, 0.07684013f, -0.06211243f, -0.08593975f, -0.08584744f, 0.27672985f, -0.22491811f, 0.28650957f, 
    0.11959273f, 0.15504988f, -0.11742008f, -0.04277613f, 0.00692163f, -0.01649255f, -0.12393878f, -0.01923016f, 
    0.04278313f, -0.17028099f, -0.28147060f, -0.11633138f, 0.04484232f, 0.02136825f, 0.13758412f, 0.01931784f, 
    -0.02219783f, 0.02278893f, 0.00174122f, 0.00618018f, 0.14270966f, 0.08010745f, -0.01238198f, 0.05454001f, 
    0.08269157f, -0.03782333f, 0.04667464f, 0.19300435f, 0.10703405f, 0.04716256f, -0.01033052f, 0.03653108f, 
    -0.45365721f, -0.13674243f, -0.22852947f, -0.29806292f, 0.07961944f, 0.04944124f, 0.15380637f, -0.08844204f, 
    0.01019628f, 0.09105294f, -0.05745684f, 0.04434016f, 0.17770675f, 0.05963064f, 0.21017708f, 0.10067803f, 
    -0.04883324f, 0.03178729f, -0.03456669f, 0.03001840f, 0.08212177f, 0.07324784f, -0.06599586f, 0.22922446f, 
    -0.14089695f, 0.01427673f, 0.16132411f, -0.06071007f, 0.01500969f, 0.03322805f, -0.08137486f, 0.03418136f, 
    0.19746718f, 0.12298008f, 0.16262524f, 0.11382619f, 0.09737995f, -0.16294602f, -0.00569482f, -0.21014956f, 
    0.03752043f, 0.14470807f, -0.25446683f, -0.06433156f, 0.08502251f, -0.12883934f, -0.09807888f, -0.07936004f, 
    0.18951115f, 0.14925615f, 0.13217922f, 0.19108371f, 0.05124618f, 0.05980986f, -0.15850732f, -0.17743653f, 
    -0.02826339f, -0.04353737f, -0.13608147f, 0.07341921f, 0.12546699f, 0.03209183f, 0.00578376f, 0.05786316f, 
    0.07020532f, 0.07153356f, -0.02743302f, -0.00813969f, 0.16562703f, 0.03894661f, 0.05904776f, 0.11100251f, 
    -0.29143411f, 0.05774825f, -0.07095926f, 0.07689979f, 0.13413318f, 0.01634896f, 0.02593200f, 0.13711011f, 
    0.05439871f, -0.07664669f, -0.01869477f, 0.10735519f, 0.36145720f, -0.14040197f, 0.09005009f, -0.07830509f, 
    0.06707283f, 0.06528834f, 0.06127124f, 0.20729867f, 0.09637827f, 0.08849697f, -0.00638970f, 0.01239252f, 
    0.35683838f, -0.05030538f, 0.16302893f, 0.28516650f, 0.09691533f, -0.13609400f, 0.01634829f, -0.11910247f, 
    -0.02541176f, 0.03395234f, 0.07622573f, 0.04852260f, 0.15368943f, -0.02623774f, -0.06083901f, 0.38790652f, 
    0.00991475f, 0.08570167f, -0.15172255f, -0.10055550f, 0.06945731f, -0.11241423f, 0.14445247f, 0.13437290f, 
    -0.12809686f, 0.05019008f, 0.00782030f, 0.02804164f, -0.16129790f, 0.11113743f, -0.04811159f, -0.05071495f, 
    0.06642525f, 0.05442731f, 0.07081435f, 0.18810976f, -0.00690525f, -0.04274679f, -0.09560055f, 0.13643713f, 
    -0.01831697f, -0.00693138f, -0.02761426f, -0.09949204f, -0.00197245f, -0.06758701f, -0.13528070f, -0.10053013f, 
    -0.00773521f, 0.01033660f, 0.00194899f, -0.05859818f, -0.02800092f, -0.04030883f, -0.07256479f, -0.02998915f, 
    -0.00927154f, -0.03098325f, -0.01331361f, -0.03929707f, -0.02040304f, -0.04142410f, -0.06311486f, -0.03835428f, 
    -0.04383966f, -0.09230873f, 0.00046271f, 0.03088639f, -0.02694816f, -0.05248542f, -0.01512344f, -0.08149226f, 
    -0.03994124f, -0.06277850f, -0.02487408f, -0.02245724f, 0.01382911f, -0.05169680f, -0.00503493f, -0.04295705f, 
    -0.08198927f, -0.05700906f, -0.04582098f, -0.05038645f, -0.02920946f, -0.01962956f, -0.10486177f, -0.02494128f, 
    -0.11826847f, -0.11946478f, -0.07520803f, -0.04828443f, -0.08866187f, -0.06697869f, -0.01008141f, -0.09918600f, 
    -0.07564707f, -0.07975318f, 0.03198656f, -0.02456875f, -0.07651444f, 0.01105263f, -0.12016772f, -0.08199353f, 
    0.04023246f, -0.04920087f, -0.06619862f, -0.05005846f, -0.09888523f, -0.08812333f, -0.05577479f, -0.07259818f, 
    -0.03238144f, -0.07984323f, -0.05895453f, -0.09987734f, -0.13951442f, -0.10661276f, -0.00358103f, -0.09067032f, 
    -0.03358406f, -0.08041079f, -0.02708116f, -0.02282524f, -0.07572760f, -0.00614310f, 0.01075103f, -0.07278783f, 
    0.00076075f, -0.05976911f, -0.09273288f, -0.09072636f, -0.12415677f, -0.06075580f, -0.08976702f, -0.08439837f, 
    -0.00022830f, -0.04773521f, -0.06608313f, -0.09267952f, -0.06414815f, -0.00950350f, -0.01709455f, -0.09725375f, 
    -0.12925297f, -0.08493932f, -0.10382639f, -0.06483326f, -0.03074674f, -0.01660561f, -0.01486372f, 0.01861306f, 
    -0.01343497f, -0.03863113f, -0.05402234f, -0.09082778f, -0.01747870f, -0.05998942f, -0.03467092f, -0.11589995f, 
    -0.10099638f, -0.10809742f, -0.11025717f, -0.06710463f, -0.02575312f, -0.07050475f, -0.07315987f, -0.12169247f, 
    -0.04232820f, -0.10894328f, -0.10081106f, -0.07494109f, -0.09616263f, -0.10676481f, -0.10059950f, -0.14923196f, 
    -0.03876431f, -0.01350384f, -0.08273393f, -0.02079619f, -0.09061433f, -0.07637765f, -0.02929206f, -0.02550165f, 
    -0.09400410f, -0.03390675f, -0.03657413f, 0.00203432f, -0.04580433f, -0.04968193f, -0.02448416f, -0.02778142f, 
    -0.01510146f, -0.10843074f, -0.10371041f, -0.13236748f, -0.05580578f, 0.01847971f, -0.00656966f, 0.09373436f, 
    0.07168432f, -0.05933526f, 0.02967669f, -0.06278489f, -0.04933984f, -0.03227388f, -0.07433119f, -0.08405793f, 
    -0.09777696f, -0.07142080f, -0.02156711f, 0.01657897f, -0.05174579f, -0.01540437f, -0.07824438f, -0.02964189f, 
    -0.01978582f, -0.10786000f, -0.08025029f, -0.11070093f, -0.11841149f, -0.02764864f, -0.12289040f, -0.08102331f, 
    0.01954441f, -0.05270524f, -0.10160234f, -0.09340574f, 0.02055577f, 0.03456937f, -0.00111116f, -0.05488712f, 
    -0.05763795f, 0.00185789f, -0.00733873f, -0.04240707f, -0.04827659f, 0.02461047f, -0.03857782f, -0.00958936f, 
    -0.07334342f, -0.02369658f, -0.05691596f, -0.06944484f, -0.13140230f, -0.07955591f, -0.01648128f, -0.07627626f, 
    -0.06074516f, -0.08163416f, -0.09067120f, -0.07678895f, -0.01865512f, -0.06229734f, -0.03220190f, -0.07287308f, 
    -0.07973906f, -0.09118959f, -0.04402775f, -0.11206360f, -0.06568423f, -0.11451278f, -0.11148820f, -0.12123944f, 
    -0.02166673f, -0.04628732f, -0.00986258f, -0.02556225f, -0.07095329f, -0.02677006f, -0.05518321f, -0.08895704f, 
    -0.09393448f, -0.02191316f, -0.05628846f, -0.02360630f, -0.09834751f, -0.08149555f, -0.11918130f, -0.08986271f, 
    -0.02135098f, -0.04335362f, -0.02027787f, -0.06651805f, -0.08058976f, -0.13879482f, -0.06832229f, -0.09120061f, 
    0.04339486f, 0.02497503f, -0.02521711f, 0.00593733f, 0.05426524f, 0.06234134f, 0.08764773f, 0.07535065f, 
    0.04996254f, -0.02395864f, 0.03073867f, 0.02942135f, 0.03439433f, 0.01325350f, -0.05185988f, 0.00851060f, 
    -0.02661234f, 0.01389658f, -0.03019731f, 0.00410141f, 0.03737123f, 0.04248760f, 0.01692612f, 0.05463697f, 
    -0.02359410f, -0.01268993f, -0.05307776f, -0.07307819f, -0.04267751f, -0.05976469f, -0.07767241f, -0.00818018f, 
    -0.10807160f, -0.10630261f, -0.04555250f, -0.06479381f, -0.03275191f, -0.04095345f, 0.02043715f, -0.02455475f, 
    0.01421292f, 0.03865645f, 0.01006637f, -0.04286075f, -0.00635266f, -0.05494851f, -0.02305914f, 0.04899308f, 
    0.03193334f, -0.01356214f, 0.03609580f, -0.03054160f, 0.02807007f, 0.03877309f, 0.05536626f, 0.02332096f, 
    0.11175702f, 0.10705352f, 0.06422538f, 0.10026006f, -0.08435807f, -0.02499277f, -0.07332981f, -0.02256051f, 
    -0.02677394f, -0.01592584f, -0.06901605f, -0.01803980f, -0.04924951f, -0.11310583f, -0.04811137f, -0.08632564f, 
    -0.09603218f, -0.03993961f, -0.07885840f, -0.03451790f, -0.06559487f, -0.07200287f, -0.10773618f, -0.05858014f, 
    0.02022788f, -0.07468174f, -0.00093938f, -0.01643337f, -0.08526438f, -0.04768012f, -0.06283508f, -0.03948115f, 
    -0.05237918f, -0.09261781f, -0.00229810f, 0.00446870f, -0.12951684f, -0.11989702f, -0.06939001f, -0.08031324f, 
    -0.09292574f, -0.00930975f, -0.03541543f, -0.08466388f, -0.04983149f, -0.04304165f, -0.09203587f, -0.08321184f, 
    -0.04338844f, -0.03293767f, -0.04867274f, -0.02711952f, -0.04274936f, -0.04230996f, -0.07324514f, -0.08229051f, 
    -0.10607190f, -0.04244199f, -0.03987813f, -0.11689734f, -0.02399072f, -0.06028926f, -0.12232868f, -0.05295783f, 
    0.00373294f, -0.05154043f, -0.04266840f, 0.00105932f, -0.01163449f, -0.04115475f, -0.03333654f, 0.00306255f, 
    0.01398988f, -0.01474379f, -0.02115601f, 0.03827070f, 0.00488179f, 0.02484973f, -0.04029633f, -0.01726592f, 
    0.03159003f, -0.01507333f, -0.05786312f, -0.03331531f, -0.02797908f, -0.04004747f, 0.00448515f, 0.02330394f, 
    0.22707289f, 0.09102661f, -0.09500065f, -0.37844566f, 0.24099012f, 0.04738607f, 0.05706030f, 0.06372489f, 
    -0.02921469f, -0.06393014f, -0.04922496f, 0.14426701f, 0.41095048f, -0.16928302f, -0.24465190f, -0.16561773f, 
    -0.07399312f, -0.11793886f, 0.02417446f, -0.08490653f, -0.06295215f, -0.08312053f, 0.01744776f, -0.07889772f, 
    0.13969207f, -0.13483511f, 0.04248791f, -0.10219700f, -0.10499935f, 0.04345971f, -0.13897052f, 0.03572172f, 
    0.18140320f, -0.13713554f, 0.19554460f, -0.05827032f, -0.03929420f, -0.15533978f, -0.16977054f, -0.20409153f, 
    0.24363282f, -0.09440348f, 0.13057804f, -0.01768778f, 0.01075319f, 0.09649492f, 0.13287087f, 0.01823852f, 
    0.03568435f, -0.10612977f, 0.28505820f, -0.01885888f, 0.11541939f, 0.09552420f, -0.00564689f, 0.03722802f, 
    0.08270149f, -0.07290791f, -0.05938636f, -0.05707671f, 0.39933476f, -0.00012744f, 0.35679027f, -0.23131627f, 
    -0.16311382f, -0.02889232f, -0.05016480f, 0.00429673f, -0.01537704f, 0.10626623f, 0.06929713f, 0.02829954f, 
    0.40352237f, 0.18644252f, 0.04040675f, -0.15644319f, 0.09496348f, 0.05984692f, 0.08345959f, 0.01403034f, 
    -0.09793253f, -0.02979422f, 0.02532119f, 0.05749084f, -0.09631819f, 0.06074196f, 0.06414355f, 0.26852754f, 
    -0.09948752f, -0.06381147f, 0.05948362f, 0.08757347f, 0.09952581f, 0.03686888f, 0.10917634f, -0.01898381f, 
    0.02137858f, -0.30783027f, -0.06380614f, -0.08932307f, 0.02181523f, 0.12204394f, 0.03046679f, 0.06022026f, 
    0.07045107f, 0.03884591f, 0.00410254f, 0.07181580f, -0.13312559f, 0.24641292f, 0.02466756f, 0.12795268f, 
    0.02890506f, -0.01304193f, 0.10482153f, 0.08200206f, 0.06255680f, -0.03181233f, 0.01941531f, 0.15615915f, 
    0.58956856f, -0.20109718f, 0.39649978f, -0.18771663f, -0.09934582f, 0.16913271f, -0.08930676f, 0.08180938f, 
    -0.01665606f, -0.01502864f, 0.04876667f, -0.03446575f, 0.23559876f, 0.00181637f, 0.15610808f, -0.00926247f, 
    -0.09993143f, 0.03580554f, 0.04464190f, 0.08083397f, 0.18730631f, 0.23741581f, 0.04582703f, 0.05638267f, 
    0.10542826f, -0.17659034f, -0.18757397f, -0.07604472f, 0.04756841f, -0.05977017f, 0.00067481f, 0.07881346f, 
    0.09456211f, -0.18250144f, 0.08239538f, 0.00530022f, 0.09915968f, -0.08402117f, -0.33745971f, -0.19391184f, 
    0.06536302f, 0.06291245f, -0.19661216f, 0.03473769f, 0.09540007f, -0.07920496f, 0.00148818f, -0.00336994f, 
    0.43500450f, 0.02502468f, 0.49914932f, -0.16863345f, -0.03763210f, 0.15836523f, -0.09643400f, 0.01891698f, 
    0.15062909f, -0.07949124f, 0.07086227f, -0.03411187f, -0.38502291f, -0.14791611f, -0.04650114f, 0.12230480f, 
    0.18233232f, 0.06503201f, 0.07192963f, -0.02657886f, -0.05086583f, -0.15657301f, 0.08773593f, -0.04344660f, 
    0.10785904f, -0.01710799f, 0.09694676f, 0.11410507f, -0.02976560f, 0.08960865f, 0.03771090f, -0.03688513f, 
    0.12406517f, 0.08523651f, 0.13250218f, 0.06068816f, -0.26704311f, 0.39130673f, -0.34205809f, 0.01135727f, 
    -0.06294017f, 0.07049929f, 0.16481669f, -0.05006121f, 0.02980304f, -0.05664559f, 0.03041901f, -0.12947454f, 
    -0.15081669f, 0.02517188f, -0.25376785f, -0.11373875f, 0.14203127f, 0.09447259f, -0.00702991f, 0.26882172f, 
    0.02246299f, -0.08901515f, 0.00857078f, -0.09401514f, 0.13971633f, 0.14512311f, 0.01342671f, -0.01893015f, 
    0.10522934f, 0.04636043f, 0.02602921f, 0.05851088f, -0.02681728f, -0.01180415f, 0.13158284f, -0.08033787f, 
    -0.33594799f, 0.03458598f, -0.19720578f, -0.15298359f, 0.17496173f, -0.01112009f, 0.04819489f, 0.00165796f, 
    0.06733872f, -0.06327376f, 0.01736115f, -0.15242863f, -0.04287313f, -0.09422812f, 0.11490241f, 0.06865251f, 
    0.01416939f, 0.11522756f, -0.01078208f, -0.09058562f, 0.02662792f, 0.06876114f, -0.01336090f, 0.05418495f, 
    0.12549974f, -0.23020440f, 0.12237720f, 0.01858497f, 0.02013004f, 0.14016168f, 0.18669820f, 0.05133333f, 
    0.07625010f, 0.00371758f, 0.17026709f, -0.00437865f, 0.03562310f, -0.27294159f, 0.09495389f, -0.15776253f, 
    0.00302059f, 0.05138715f, -0.15969978f, -0.13378619f, -0.02615535f, 0.04636861f, -0.16024661f, -0.02354015f, 
    0.13300283f, -0.01014744f, 0.06799207f, 0.04786697f, -0.06962240f, 0.04558336f, -0.12509321f, -0.12840272f, 
    0.01074575f, -0.01852067f, 0.04788416f, 0.06112453f, 0.14625846f, 0.05881293f, 0.06024828f, -0.12787695f, 
    0.03928847f, 0.15439798f, 0.18857035f, 0.16842662f, -0.01581556f, -0.00376429f, 0.05368196f, 0.04405444f, 
    -0.39611086f, 0.09028050f, -0.19261494f, 0.26092982f, 0.18590146f, 0.12803791f, 0.06904159f, 0.11584245f, 
    0.04113055f, 0.03297307f, -0.02276587f, 0.02792629f, 0.46969616f, 0.05768906f, 0.02725603f, -0.25028762f, 
    0.09647045f, 0.17367412f, -0.09194198f, 0.08000506f, 0.16753361f, -0.04463647f, -0.06385521f, -0.03602335f, 
    0.40774232f, -0.24943885f, 0.08204950f, -0.14464353f, 0.09776743f, 0.04645971f, 0.14609030f, -0.01956497f, 
    0.13516493f, -0.05117736f, -0.06234377f, 0.06444462f, -0.02635781f, -0.01956805f, -0.16148318f, -0.23383352f, 
    -0.01003816f, 0.05161748f, 0.15548256f, 0.05364024f, 0.06185727f, -0.18009241f, -0.06197624f, 0.09513242f, 
    -0.08506455f, -0.09731839f, 0.04763071f, 0.07763230f, 0.04188063f, 0.01772412f, 0.04329691f, 0.00015218f, 
    -0.01129421f, -0.01595276f, 0.00812327f, 0.08707249f, -0.04453408f, 0.01602492f, -0.12403170f, 0.29555821f, 
    -0.10454308f, -0.08800536f, -0.10408784f, -0.10309424f, 0.03837444f, -0.04790593f, 0.02555340f, 0.22013675f, 
    0.03343318f, 0.03426904f, -0.05307626f, 0.02939042f, -0.01046127f, -0.01560403f, 0.03424467f, 0.03222994f, 
    0.03560120f, -0.01676644f, 0.00749092f, -0.00687252f, -0.04747550f, -0.02074493f, 0.01558171f, 0.00630667f, 
    -0.05286789f, 0.01895519f, -0.02688534f, -0.03892995f, -0.04151440f, -0.04790725f, 0.00751392f, -0.01450298f, 
    -0.04720706f, 0.02913186f, -0.00931127f, -0.00430589f, -0.01051660f, 0.02580744f, 0.02936762f, 0.03831919f, 
    0.02055771f, 0.02842163f, -0.05236736f, -0.02256612f, -0.02678948f, -0.04710554f, -0.01391394f, -0.02766391f, 
    -0.02639033f, 0.03995143f, -0.05004482f, 0.04231727f, 0.03534813f, -0.05407215f, 0.04931986f, -0.00668160f, 
    0.03487590f, 0.03847860f, 0.00734359f, 0.00779716f, -0.04002360f, -0.03047437f, 0.03086367f, -0.04434603f, 
    0.01655984f, -0.03952433f, 0.01933702f, -0.01594016f, -0.00007870f, -0.05332157f, -0.04482129f, 0.04123027f, 
    -0.00358021f, -0.03691654f, -0.02796061f, -0.01829115f, -0.04886174f, 0.04026865f, -0.04472520f, 0.02416834f, 
    0.00110526f, 0.02011365f, -0.00046314f, 0.00579045f, 0.02235310f, -0.02955435f, 0.04787186f, -0.05206970f, 
    0.02228155f, 0.00054524f, -0.03080359f, -0.01678004f, 0.01624423f, -0.01809489f, 0.03594567f, -0.03786474f, 
    -0.03208543f, -0.04205282f, -0.01128596f, 0.03680506f, -0.04743263f, 0.01360881f, -0.01954411f, 0.01630056f, 
    -0.01795849f, 0.03332962f, 0.00137152f, -0.02227862f, 0.00904960f, -0.04340596f, 0.04220212f, 0.03950706f, 
    -0.02727743f, -0.04717464f, -0.02940417f, 0.02115531f, -0.04442628f, 0.00980683f, -0.02057158f, 0.02379402f, 
    -0.04522186f, -0.04007344f, 0.03679363f, -0.03561522f, -0.02082970f, -0.00842496f, 0.00595312f, -0.02573327f, 
    0.03132300f, 0.02573895f, 0.03601975f, -0.02383011f, 0.00058864f, -0.01209128f, -0.02618832f, -0.01435300f, 
    -0.01090159f, -0.01819509f, -0.05563970f, -0.03797808f, -0.00953348f, -0.00672571f, -0.02874562f, -0.00601540f, 
    0.04470805f, -0.01963890f, 0.03417910f, -0.00226417f, -0.01852562f, 0.01528151f, -0.03730788f, -0.02724519f, 
    -0.02909448f, 0.00986827f, 0.00482981f, 0.04101847f, -0.02007470f, -0.00295544f, 0.04170862f, -0.01857035f, 
    -0.04829599f, 0.02188043f, -0.02598852f, 0.03425542f, 0.01060910f, -0.01008280f, -0.03187816f, 0.00429945f, 
    0.02006543f, -0.04191662f, -0.01180953f, 0.01791496f, -0.02472354f, 0.00492358f, -0.04027838f, -0.00908382f, 
    -0.02712239f, 0.02828375f, 0.02347808f, 0.01253284f, 0.02789732f, -0.03824611f, -0.05160795f, 0.00447812f, 
    -0.03515473f, 0.00587124f, -0.03730329f, 0.03729159f, -0.05667058f, -0.03709256f, -0.01606578f, -0.03215223f, 
    -0.02708357f, -0.05165312f, -0.04964381f, -0.03787770f, 0.03891836f, -0.03153567f, 0.04294592f, 0.03851490f, 
    -0.03075703f, 0.02477188f, -0.00431197f, 0.02629688f, -0.04081469f, 0.00502827f, 0.01170867f, -0.00118550f, 
    -0.05565618f, -0.00465350f, -0.05146002f, 0.04273448f, 0.04723142f, -0.03236799f, 0.02537435f, -0.04865460f, 
    0.02945156f, -0.01819003f, -0.01092605f, 0.01076819f, -0.05479665f, -0.02835208f, -0.04503916f, -0.02491213f, 
    -0.04261192f, 0.01997178f, -0.01975382f, 0.04502689f, -0.03909710f, -0.05011214f, -0.01058834f, -0.02503394f, 
    -0.01754026f, -0.00405956f, 0.00977271f, -0.02532480f, 0.00680668f, -0.04284092f, 0.00595482f, 0.01772936f, 
    0.02690626f, -0.02259395f, 0.00985096f, -0.02089672f, -0.04313149f, -0.01475646f, 0.03494890f, -0.01695594f, 
    -0.02902027f, 0.04345843f, -0.05408515f, 0.00940984f, 0.02063562f, 0.02898126f, 0.04264887f, -0.02309094f, 
    0.02336916f, 0.02521780f, -0.00713449f, -0.05489446f, 0.01364702f, -0.01699964f, 0.03193369f, -0.04630888f, 
    0.00374975f, 0.02094108f, 0.00839230f, 0.03687435f, -0.01805902f, -0.05442824f, -0.03665192f, 0.03004395f, 
    -0.01284571f, 0.03012229f, -0.02789790f, 0.01023772f, -0.02871929f, 0.03206448f, 0.02935808f, 0.03883886f, 
    0.03051748f, -0.01878163f, -0.05050632f, 0.03603370f, -0.03546177f, 0.01154820f, 0.04019177f, 0.01963243f, 
    0.02878200f, 0.02881698f, 0.01986218f, 0.04210668f, -0.03346691f, 0.03695877f, -0.01774775f, 0.03563359f, 
    -0.01363178f, -0.01210692f, -0.03329119f, -0.02293045f, -0.02660663f, -0.04802517f, 0.04468156f, 0.04241802f, 
    0.00199767f, 0.00599266f, 0.00877501f, -0.03678802f, -0.04323084f, 0.02367499f, -0.01089371f, 0.00797990f, 
    -0.00946067f, 0.01615894f, 0.00674590f, -0.01026112f, 0.01032096f, -0.05068867f, 0.02077866f, -0.01667117f, 
    -0.00663811f, -0.04376822f, 0.02633419f, -0.01734802f, -0.04255216f, -0.02253214f, 0.03782468f, 0.03336929f, 
    0.00039317f, -0.00657661f, 0.03057581f, -0.01217143f, -0.04488040f, 0.01352916f, 0.02892010f, -0.04930465f, 
    0.00784331f, -0.01961072f, -0.03430479f, -0.01422895f, 0.03133851f, -0.00467469f, 0.03864691f, -0.02935520f, 
    -0.00656522f, -0.01573656f, 0.02115474f, 0.03755683f, -0.03830579f, -0.03646513f, 0.03186251f, -0.02017156f, 
    0.03972284f, -0.02860286f, -0.03187733f, -0.01867705f, 0.00610881f, 0.03531687f, -0.02499759f, -0.01070800f, 
    0.00991041f, -0.04068506f, -0.00742276f, -0.00194725f, 0.01694269f, -0.01559196f, -0.00926077f, 0.04449978f, 
    -0.02915916f, -0.03669431f, -0.02619339f, -0.03249494f, 0.03768515f, -0.04353430f, -0.02952144f, -0.03543967f, 
    -0.00426169f, -0.02611499f, -0.03637790f, 0.01771703f, 0.03223519f, -0.04916984f, -0.04965223f, -0.00902971f, 
    -0.01058472f, 0.02061937f, -0.03974300f, -0.01982256f, -0.01549077f, -0.01756710f, 0.03446426f, 0.02189795f, 
    -0.13312569f, -0.21008354f, -0.24459939f, -0.17718309f, 0.15659961f, -0.10949618f, -0.07324546f, -0.11355510f, 
    -0.01246630f, 0.00387745f, -0.00970023f, -0.00657786f, -0.30738696f, 0.49850354f, -0.21563604f, -0.09375089f, 
    0.25743333f, 0.03439941f, -0.05705985f, 0.11882139f, -0.11135211f, -0.20682579f, 0.13084838f, 0.05846696f, 
    -0.15834495f, -0.21492842f, 0.03385714f, 0.24128851f, 0.03817714f, -0.09463271f, -0.08751436f, 0.01881611f, 
    -0.03281095f, -0.08389389f, 0.15892936f, 0.12321448f, -0.30491292f, -0.07818337f, -0.15928367f, 0.15315464f, 
    -0.04036085f, 0.08327411f, 0.08273911f, -0.00048987f, -0.08603970f, 0.12893814f, 0.14089203f, 0.04558883f, 
    0.30212200f, -0.18787748f, -0.03893895f, 0.02986500f, 0.07379124f, 0.01005971f, 0.03027814f, 0.07413926f, 
    0.00641768f, -0.06473397f, 0.03568759f, -0.03050213f, 0.18997949f, 0.09503630f, 0.01335328f, -0.07675862f, 
    0.07944862f, -0.03010113f, 0.16875599f, -0.06553228f, -0.05846035f, 0.21773289f, 0.23748222f, 0.08106358f, 
    -0.13327280f, -0.08557303f, -0.18463424f, 0.26174092f, -0.08615536f, -0.03192413f, -0.02777405f, -0.10666683f, 
    -0.03108021f, -0.01118042f, -0.04772791f, 0.12955578f, -0.11523122f, 0.05179545f, 0.06747662f, 0.24775817f, 
    -0.03409051f, 0.05740056f, 0.05186395f, -0.08006486f, -0.03349974f, 0.15532930f, 0.08201864f, 0.18350816f, 
    -0.15053675f, -0.01698512f, 0.22023308f, 0.32874823f, 0.05414433f, 0.06071589f, 0.02252536f, -0.13903725f, 
    -0.04185215f, 0.13064384f, 0.03684585f, 0.16815251f, 0.06689646f, 0.00617644f, 0.01367099f, 0.00362153f, 
    0.06057668f, -0.10749660f, -0.01966344f, -0.04206393f, -0.01144941f, 0.07437358f, 0.02798898f, 0.03857392f, 
    -0.10992640f, 0.23040546f, -0.10569835f, 0.22525108f, 0.06262271f, 0.04783671f, -0.01698813f, 0.01389703f, 
    -0.01803611f, 0.03243484f, 0.17072329f, 0.06591684f, -0.01143315f, -0.01843090f, 0.15883854f, 0.06587312f, 
    -0.00792674f, -0.02710862f, -0.01243025f, 0.01790147f, 0.18207306f, 0.12502001f, 0.19975178f, 0.04356229f, 
    -0.27139851f, 0.13745141f, 0.06534936f, 0.03026224f, 0.09211514f, 0.04286306f, -0.13046430f, 0.07648737f, 
    0.00860047f, 0.00300311f, 0.05991734f, 0.02806490f, 0.02497919f, 0.06118966f, 0.01644482f, 0.07512526f, 
    0.01457837f, 0.13538788f, -0.10600784f, -0.06378328f, 0.05313763f, -0.02359831f, 0.05281616f, 0.09548158f, 
    0.33119491f, -0.07183517f, -0.04012322f, -0.20769385f, 0.15453525f, -0.01202958f, -0.10475498f, 0.00487344f, 
    0.17843492f, -0.02744986f, 0.03518330f, 0.07632870f, -0.21925244f, -0.00809968f, 0.05625739f, -0.07739939f, 
    0.10371466f, 0.02140610f, -0.04470323f, 0.00315151f, -0.01314294f, -0.05612013f, -0.03226300f, 0.04960035f, 
    0.27301547f, 0.01015746f, 0.06317864f, 0.13141215f, 0.14292672f, -0.10726185f, -0.05424060f, -0.03079089f, 
    -0.04839265f, 0.22218411f, 0.20179763f, 0.22747466f, -0.07160550f, -0.09918048f, -0.09662808f, -0.13646519f, 
    0.02867230f, -0.04193942f, -0.07766851f, -0.14122422f, -0.04273479f, -0.05998604f, 0.00692321f, 0.04499429f, 
    -0.27556852f, -0.02535824f, 0.09440926f, -0.08181419f, 0.13018291f, -0.01657533f, 0.05106582f, 0.10825370f, 
    0.09914325f, 0.00983017f, 0.00161491f, 0.01144752f, -0.13180342f, -0.11049435f, -0.12893888f, 0.00138582f, 
    -0.08755673f, -0.05229008f, 0.02166048f, -0.04898205f, 0.00045399f, 0.03623482f, 0.00049600f, -0.13044268f, 
    0.06573663f, 0.04185716f, -0.03573045f, -0.07536195f, 0.01592528f, -0.09089790f, 0.06084829f, 0.14887840f, 
    0.07676826f, -0.15904048f, 0.02826273f, -0.02900723f, -0.11641887f, -0.03025975f, -0.00530072f, -0.00607711f, 
    0.03447128f, 0.10782086f, 0.02202735f, -0.01114630f, -0.06725200f, 0.04521722f, 0.07192242f, 0.01817999f, 
    0.04554339f, -0.07207625f, 0.03705600f, 0.03110508f, -0.04225872f, 0.04066436f, 0.08267734f, 0.04524866f, 
    0.14199533f, 0.10023332f, 0.16802315f, 0.06023731f, -0.11706635f, -0.09121497f, 0.00112955f, 0.05337630f, 
    0.15978102f, -0.12174624f, -0.01258737f, 0.01641857f, 0.08981391f, 0.03463946f, 0.07065063f, 0.00828756f, 
    -0.14018132f, -0.06548385f, -0.05215303f, 0.02841936f, -0.02298049f, 0.05479651f, -0.04273026f, -0.00747384f, 
    -0.02950623f, 0.07972844f, -0.07316655f, 0.06936351f, 0.07833464f, -0.03907435f, -0.15982553f, -0.05058235f, 
    0.04692281f, 0.07841416f, 0.15497343f, 0.06881041f, 0.03023212f, 0.10532135f, 0.02150268f, 0.06481325f, 
    -0.20723812f, -0.06903243f, 0.01959130f, -0.08302779f, -0.01324803f, 0.08855037f, 0.19136532f, 0.07376307f, 
    0.00353256f, 0.12664552f, -0.05919835f, -0.05803761f, 0.02623641f, -0.19387935f, -0.21410638f, -0.13994147f, 
    -0.08100674f, 0.05317249f, -0.04552759f, -0.03723653f, -0.06751567f, -0.12069401f, -0.06135600f, 0.06715377f, 
    0.11008928f, -0.08301406f, 0.09268474f, 0.00780629f, 0.10362325f, -0.10736552f, -0.00569436f, 0.17220317f, 
    0.01946546f, 0.12696899f, 0.02874339f, 0.02811964f, 0.45224589f, -0.09584629f, 0.02859976f, 0.13277376f, 
    0.15348247f, 0.07534566f, 0.07422569f, -0.05540701f, -0.00774953f, -0.03826487f, 0.17332073f, 0.14751586f, 
    -0.04397743f, 0.02733996f, -0.04072273f, -0.05802387f, -0.05140608f, 0.05429885f, 0.01308881f, 0.01839496f, 
    -0.02957794f, 0.04958369f, 0.00881641f, 0.01313912f, -0.10672580f, 0.03039316f, -0.16925010f, -0.02526234f, 
    0.00763065f, -0.09752777f, -0.02988714f, -0.03501321f, 0.00838869f, 0.15608275f, -0.10035223f, -0.05845139f, 
    -0.01038913f, -0.15420842f, 0.09589554f, 0.15924452f, 0.09367303f, 0.15633200f, 0.09328295f, 0.28067017f, 
    0.02924238f, 0.04495278f, 0.07723817f, 0.02623659f, -0.02885851f, 0.53921336f, -0.15784179f, -0.06926594f, 
    -0.01932768f, 0.12627399f, 0.08834156f, 0.09307443f, 0.13468361f, 0.18502723f, 0.08811864f, 0.14636759f, 
    -0.31881070f, 0.07359159f, 0.10539077f, 0.05075919f, 0.01510836f, 0.12068201f, 0.19745670f, 0.06988653f, 
    0.12527291f, 0.09276935f, -0.10722675f, 0.03343082f, -0.11763104f, 0.02946331f, 0.06275761f, 0.35067919f, 
    -0.00367658f, 0.00097920f, 0.14667322f, 0.32088280f, 0.01311770f, -0.00025647f, 0.15538387f, 0.05154018f, 
    0.13773012f, 0.12051553f, 0.06283719f, 0.07967573f, 0.06437626f, 0.05674321f, 0.18849964f, -0.08399448f, 
    0.11701418f, 0.04883717f, 0.09657102f, 0.02843293f, -0.17946646f, 0.22430174f, -0.13263854f, -0.24400809f, 
    -0.02676606f, 0.00725681f, -0.06500109f, -0.07605746f, 0.04790510f, -0.13115884f, 0.07463440f, 0.01140470f, 
    -0.18910284f, 0.09197260f, 0.08389103f, 0.40705732f, -0.02877240f, 0.17241772f, 0.04337613f, 0.12713277f, 
    -0.00061232f, -0.00323560f, 0.03560379f, -0.01820119f, 0.15823336f, 0.13638483f, 0.03907639f, -0.07949886f, 
    -0.07466998f, 0.11553720f, -0.00853371f, -0.03500156f, 0.02304153f, -0.20138155f, -0.09770300f, -0.23980904f, 
    -0.26177257f, -0.25479096f, -0.34656480f, -0.08400651f, -0.07902707f, 0.02254167f, -0.07933673f, 0.13021982f, 
    0.13986678f, 0.03789767f, 0.10299867f, -0.02123420f, 0.38582128f, 0.01953753f, -0.02041720f, 0.00075630f, 
    0.15462419f, 0.13745257f, 0.02124901f, 0.15099612f, 0.02101447f, -0.02180625f, 0.04119020f, -0.00972154f, 
    -0.19774225f, 0.49619538f, -0.07898737f, -0.12377116f, -0.09205294f, -0.04893291f, 0.10373107f, 0.04587712f, 
    -0.00006169f, -0.00826001f, -0.08935492f, -0.08397152f, 0.00520693f, 0.04630426f, -0.11109143f, 0.02221142f, 
    0.02765073f, 0.00495842f, -0.10623967f, -0.04661496f, -0.13926871f, -0.23504873f, -0.11659280f, -0.23132877f, 
    0.11168392f, -0.33910194f, -0.20734191f, -0.16809741f, -0.00962158f, 0.04406884f, 0.05927893f, 0.09214946f, 
    0.19106221f, 0.14346044f, -0.10121385f, -0.05078008f, -0.07767197f, -0.11867887f, -0.09419548f, 0.04006055f, 
    0.13797359f, -0.03481992f, 0.05397966f, 0.19960850f, 0.00336970f, -0.01090515f, -0.07244658f, -0.08641649f, 
    0.34650260f, 0.05882999f, -0.01402854f, -0.21646449f, 0.19356309f, 0.09392612f, 0.06526891f, -0.06760479f, 
    -0.12499695f, 0.07288577f, -0.03419687f, 0.08344653f, 0.11561879f, 0.21432713f, 0.24224323f, 0.03516174f, 
    -0.09152126f, -0.11937002f, -0.05744356f, -0.02746716f, -0.03454973f, 0.01280893f, 0.04214093f, -0.01648486f, 
    0.14451411f, -0.06379390f, -0.28216311f, -0.05519516f, 0.02060907f, 0.09357125f, -0.04916802f, 0.03374971f, 
    0.20396814f, 0.06392217f, 0.08078712f, 0.17860211f, 0.34301090f, 0.03161470f, 0.20788591f, 0.14804032f, 
    0.15877901f, -0.02069253f, 0.11878236f, 0.29256696f, -0.03251466f, 0.10219666f, 0.00251617f, 0.04170982f, 
    -0.21616979f, 0.09078029f, 0.17980832f, 0.34550971f, 0.06728821f, 0.09338744f, 0.11331575f, 0.11961377f, 
    0.02648130f, -0.10810972f, 0.13291438f, 0.16025738f, -0.02764128f, -0.18855926f, 0.03170614f, 0.12295486f, 
    0.04138874f, 0.04487460f, 0.08720937f, 0.12304414f, -0.04528433f, 0.01600689f, -0.06852071f, -0.05355343f, 
    -0.17019343f, -0.09193410f, 0.06546707f, 0.00320562f, 0.06531793f, -0.00873241f, 0.01011333f, 0.00537118f, 
    0.03887613f, 0.08937827f, 0.09380719f, 0.22260138f, -0.05122408f, 0.12075785f, -0.02823502f, -0.11430395f, 
    -0.18129183f, -0.13825181f, -0.06614974f, -0.02219684f, -0.06475467f, 0.00211924f, 0.01537364f, -0.08585338f, 
    -0.03672435f, 0.01582477f, 0.12560250f, -0.01280841f, 0.02848751f, 0.01852241f, -0.03392931f, 0.00971249f, 
    -0.04873959f, -0.09395328f, -0.12863117f, -0.11091827f, -0.00710811f, 0.00946210f, -0.10528617f, -0.02233058f, 
    -0.09035274f, 0.14526090f, 0.03786902f, 0.02755358f, 0.13672553f, 0.03348267f, 0.14686745f, 0.26288095f, 
    0.01049766f, -0.02858643f, -0.01773178f, -0.20535542f, -0.07904286f, -0.01327398f, 0.04915385f, -0.03257056f, 
    -0.04911048f, -0.00793364f, 0.18527746f, 0.11747229f, -0.00109142f, 0.06060474f, -0.01283141f, -0.09069679f, 
    0.00775767f, -0.02391600f, 0.09567698f, -0.03290907f, 0.04968993f, -0.09720009f, -0.09661335f, 0.07328503f, 
    0.03525862f, 0.18426596f, 0.26667851f, 0.04544558f, 0.06992646f, -0.11258389f, -0.15984066f, 0.02194103f, 
    -0.10692993f, -0.12814638f, -0.07377116f, -0.02624780f, -0.10019664f, 0.05240391f, -0.05571735f, 0.04141010f, 
    0.11965442f, 0.21097620f, 0.23117757f, 0.14452703f, 0.12760419f, 0.06646233f, 0.00834017f, -0.07325992f, 
    -0.05120420f, -0.08531666f, -0.20734534f, -0.15237133f, 0.05330605f, -0.02637628f, -0.00576345f, 0.08568548f, 
    0.01855163f, -0.05841779f, -0.03115792f, 0.03916201f, 0.43585527f, 0.07457667f, -0.03520165f, -0.13744247f, 
    0.13343152f, -0.12285252f, -0.00596477f, 0.05260759f, 0.07027987f, 0.04195888f, -0.09926376f, -0.21291377f, 
    -0.06439963f, 0.09803447f, 0.10079674f, -0.08199986f, -0.12179269f, -0.10851087f, -0.07086203f, -0.08740395f, 
    -0.08232399f, -0.03615434f, -0.04660799f, -0.15058181f, 0.02016306f, 0.03260005f, 0.11332071f, -0.00344935f, 
    -0.08398148f, 0.00146804f, -0.01994906f, -0.00956242f, 0.09044381f, -0.00435629f, 0.11918245f, 0.08550327f, 
    0.05532789f, 0.08198699f, -0.00034579f, 0.01714008f, 0.01632782f, 0.04909465f, 0.01785405f, 0.06240516f, 
    -0.01792735f, -0.04932938f, -0.06896953f, -0.00771169f, 0.09566210f, 0.04805464f, -0.12247606f, -0.23467788f, 
    0.04115358f, -0.02856283f, 0.19668080f, -0.04619068f, 0.06143870f, 0.04718946f, 0.07545666f, 0.06618433f, 
    0.17565085f, -0.28676832f, 0.36718395f, -0.12041584f, -0.01160011f, 0.19933128f, 0.05311050f, 0.10776407f, 
    0.14370398f, 0.08171675f, -0.10333420f, -0.01829609f, 0.16175155f, 0.13367628f, -0.05334729f, -0.03436755f, 
    0.00697466f, 0.11174538f, 0.10799165f, -0.03035612f, -0.02259688f, -0.04702521f, -0.05042781f, -0.03846521f, 
    -0.04303150f, 0.03604620f, -0.08585384f, -0.05504843f, 0.05339778f, -0.08537593f, -0.01428651f, 0.01908894f, 
    0.01671799f, 0.08940996f, 0.10556483f, 0.11836443f, 0.30449617f, 0.19854216f, 0.13873941f, -0.03132313f, 
    0.08730078f, -0.00196438f, 0.05109609f, 0.13795282f, 0.20364822f, 0.06967216f, -0.04624884f, -0.08359923f, 
    0.06383363f, -0.07226764f, -0.00445974f, -0.09160490f, 0.09379382f, 0.00778991f, -0.12688059f, -0.07210886f, 
    -0.05026938f, -0.05539628f, 0.03731789f, 0.08663685f, 0.10532901f, -0.03041861f, -0.15678754f, -0.09353347f, 
    -0.04037704f, 0.02367144f, -0.05431009f, -0.01691232f, -0.22809568f, -0.03537070f, -0.03226191f, -0.16853383f, 
    0.09418531f, -0.21941312f, -0.00207514f, 0.12950787f, -0.08016895f, 0.12335975f, -0.01053797f, -0.07392366f, 
    0.06067194f, 0.09525088f, -0.01928585f, 0.00243835f, 0.07465045f, 0.25387236f, -0.07643396f, -0.08910394f, 
    -0.02040451f, 0.00275409f, 0.15323484f, -0.03818778f, 0.08015063f, 0.06983007f, 0.10432324f, -0.01318247f, 
    0.07754489f, 0.24845839f, -0.35214967f, -0.19758686f, 0.02851241f, -0.04862078f, 0.10246545f, -0.00367879f, 
    0.08706374f, 0.12222531f, 0.09001609f, -0.11304447f, 0.08247973f, 0.11108231f, -0.04330788f, -0.09673619f, 
    -0.01121095f, -0.00854468f, -0.08770929f, 0.01268162f, -0.00877033f, -0.09202309f, -0.07425050f, -0.19827586f, 
    0.13383456f, 0.03723307f, -0.08596057f, 0.02706075f, 0.00934894f, 0.13761170f, 0.22282985f, -0.06800076f, 
    0.02841608f, 0.06848595f, -0.00883520f, -0.02932732f, 0.02696353f, -0.04921785f, 0.00946130f, -0.00655498f, 
    0.03080038f, 0.18916589f, 0.10691325f, 0.12843862f, 0.07823640f, 0.02325762f, 0.00722932f, -0.09767468f, 
    0.26586285f, 0.27127394f, -0.05554010f, -0.01859301f, 0.11883230f, 0.21151362f, -0.00282595f, 0.26223329f, 
    -0.04032804f, 0.05673580f, 0.02081815f, -0.02214764f, -0.27520689f, -0.14832871f, -0.08494612f, -0.10462621f, 
    0.00595414f, -0.05515002f, -0.01409578f, 0.00361370f, 0.00251665f, 0.06135592f, -0.04782078f, 0.04789499f, 
    0.10685372f, 0.14714119f, -0.00049400f, -0.12403822f, 0.02519103f, 0.03237787f, -0.04628688f, 0.03836320f, 
    0.13876267f, 0.17730299f, 0.02512106f, 0.03945022f, -0.03883645f, -0.03157594f, -0.05119969f, 0.04966184f, 
    0.11526652f, 0.22435662f, 0.07146550f, 0.19371086f, -0.06789606f, 0.03414779f, -0.09395329f, 0.10460917f, 
    0.10354832f, -0.13696311f, -0.10218012f, 0.00578336f, 0.04033829f, -0.00646678f, 0.08159193f, 0.00550321f, 
    0.12038716f, 0.07550494f, -0.09612525f, 0.25722000f, 0.01268006f, -0.00335428f, -0.19850111f, -0.01583936f, 
    0.03613472f, 0.00639057f, 0.02639928f, -0.00825793f, 0.01657799f, 0.02329404f, -0.06690591f, 0.07367376f, 
    -0.13512829f, -0.00829291f, -0.00179298f, 0.02008921f, -0.06531818f, -0.03713160f, 0.11804612f, -0.06759104f, 
    -0.06022322f, 0.09385838f, 0.09935410f, 0.03297097f, -0.05194779f, -0.03029896f, 0.05008867f, 0.01832774f, 
    -0.06323544f, -0.16081242f, -0.03062927f, -0.07591212f, 0.01144230f, -0.05365691f, 0.03717338f, -0.02382121f, 
    -0.23911411f, -0.10854829f, 0.11762143f, -0.20214748f, 0.04995146f, 0.02896775f, -0.08985377f, 0.06910198f, 
    -0.06195864f, 0.05303194f, -0.05554703f, -0.05805310f, -0.06372305f, -0.03198568f, 0.02133904f, -0.06330069f, 
    -0.03283496f, 0.12477764f, 0.04660514f, 0.08891869f, 0.04013929f, 0.13217624f, 0.12946819f, 0.12058391f, 
    0.03630628f, -0.12632726f, 0.00233091f, -0.05434960f, 0.01598554f, -0.06351687f, -0.04758853f, 0.11650985f, 
    -0.11817856f, -0.12128930f, 0.06754808f, 0.03477572f, 0.19882564f, 0.05948249f, -0.09739068f, 0.02684071f, 
    0.05253958f, 0.05238730f, 0.12624544f, -0.00143452f, 0.09817508f, -0.08451226f, -0.14629616f, -0.02907397f, 
    -0.27801040f, -0.18648906f, 0.03330360f, -0.16467525f, 0.00198982f, -0.03097797f, -0.12238675f, -0.08338796f, 
    -0.12778445f, 0.01746063f, -0.03911652f, 0.06836832f, -0.02403236f, -0.08675050f, -0.01449111f, -0.20026796f, 
    0.05450547f, 0.15378636f, 0.15094087f, 0.01869836f, 0.02265818f, 0.04941488f, 0.05829772f, -0.05208020f, 
    -0.06701466f, 0.05787219f, -0.10111880f, -0.29215255f, 0.10700249f, 0.09498348f, 0.12084838f, -0.02276748f, 
    0.02452076f, 0.12123629f, -0.03189989f, 0.01410726f, 0.05574689f, 0.00131791f, 0.20050143f, 0.01696512f, 
    0.19460669f, 0.15844461f, -0.11292007f, 0.09210206f, -0.07485467f, 0.04994671f, 0.03420211f, -0.10244937f, 
    -0.04276999f, 0.03870231f, 0.11078730f, 0.02601880f, -0.07322671f, -0.06432127f, -0.05732756f, 0.04221798f, 
    -0.01327040f, -0.05893276f, 0.04858061f, 0.01706780f, 0.06422371f, 0.05620796f, -0.04698827f, -0.03656856f, 
    -0.05063846f, 0.01045611f, 0.03151094f, 0.03150493f, 0.05071760f, 0.02583796f, 0.02790242f, 0.11838227f, 
    0.20853922f, -0.04327740f, -0.19895270f, -0.15979354f, 0.08930034f, -0.08509574f, 0.09458787f, -0.12520401f, 
    -0.02333871f, -0.01835204f, -0.04819684f, -0.00126015f, 0.19666244f, -0.08393643f, -0.06956440f, -0.21941890f, 
    -0.14370853f, -0.08020059f, 0.18591049f, 0.03536575f, 0.09302433f, -0.04656395f, -0.04346346f, 0.07788305f, 
    -0.54283673f, -0.14657144f, -0.18934110f, 0.36439723f, 0.18004486f, 0.10374989f, 0.00539264f, -0.03880760f, 
    0.17824702f, -0.16609100f, 0.05085194f, 0.06145633f, -0.10514261f, -0.28020588f, -0.20078947f, 0.21101853f, 
    -0.03373606f, 0.13292417f, 0.03943408f, -0.04910947f, -0.01403824f, 0.00696253f, 0.19981071f, 0.07230573f, 
    0.26811317f, 0.19875701f, 0.12980939f, 0.04842699f, -0.18622266f, 0.01599396f, -0.05252394f, -0.00956011f, 
    0.11791215f, -0.00432648f, -0.06625188f, 0.01812856f, -0.10073820f, 0.21351145f, -0.16220474f, -0.08212537f, 
    -0.01910716f, -0.07057443f, 0.11787218f, 0.02804977f, -0.05226615f, -0.07352098f, 0.04006631f, 0.06850932f, 
    0.18610156f, 0.10252744f, -0.11577926f, -0.05742481f, -0.07660001f, 0.00939187f, 0.19856180f, -0.09386960f, 
    -0.02838416f, 0.03455806f, 0.01344749f, 0.02367714f, 0.01499004f, 0.01409849f, 0.05170488f, 0.08204335f, 
    -0.04760164f, 0.01659820f, 0.01796132f, 0.01129097f, 0.11142582f, 0.14502108f, 0.00051687f, -0.02977399f, 
    -0.32401636f, -0.15709454f, -0.30933946f, 0.14255309f, -0.03400089f, 0.00909373f, 0.23985618f, 0.10969817f, 
    0.09048268f, -0.09311292f, 0.04720989f, -0.04992679f, 0.41679454f, -0.13256818f, -0.02377279f, 0.01584252f, 
    0.11314039f, 0.06608809f, 0.17073800f, 0.18405083f, -0.00576984f, 0.08386427f, 0.07143434f, 0.00606735f, 
    0.35656464f, 0.29990214f, 0.12164848f, 0.01269367f, 0.03049112f, -0.08511035f, -0.07153475f, -0.08477995f, 
    0.00300188f, -0.01115998f, 0.03489320f, 0.10168195f, -0.14299521f, -0.21416396f, -0.13207354f, -0.03253566f, 
    -0.03046004f, -0.03577810f, 0.03657043f, 0.02664794f, 0.02169719f, -0.01886970f, 0.21491276f, 0.11530408f, 
    -0.23533575f, -0.24156494f, -0.21940815f, 0.10827933f, 0.03804630f, 0.18185860f, 0.08455047f, 0.10344754f, 
    0.19612838f, -0.17208113f, -0.04609780f, -0.01893056f, 0.00554460f, -0.12298683f, 0.08900212f, 0.01698153f, 
    0.08290434f, 0.02523134f, 0.09264221f, -0.03182953f, 0.01118804f, -0.12681526f, -0.12840055f, -0.06218703f, 
    0.60488093f, -0.14080481f, 0.03991105f, -0.08329599f, 0.15527679f, -0.08423025f, -0.08778943f, -0.05435333f, 
    0.11502175f, 0.12003855f, 0.18648908f, 0.01311327f, 0.19971634f, 0.25423193f, 0.19306874f, 0.08364635f, 
    0.00179286f, 0.01552153f, -0.09904156f, -0.03807201f, -0.03815551f, 0.03561450f, 0.02758515f, -0.00295975f, 
    -0.30572408f, -0.15407564f, -0.35079035f, -0.07885685f, -0.02958650f, 0.09822436f, -0.01464396f, -0.03461860f, 
    -0.01985898f, 0.15263662f, 0.05003462f, 0.09526186f, -0.29846972f, -0.09526742f, -0.25309515f, -0.21391225f, 
    0.13360289f, -0.01807410f, 0.04130799f, -0.03666220f, 0.00593113f, 0.16315739f, 0.15647742f, 0.12235510f, 
    -0.18887921f, 0.14146975f, 0.01365287f, -0.00630179f, -0.01164963f, 0.11424508f, -0.05635399f, 0.07230270f, 
    0.01621460f, -0.04505761f, 0.01322686f, -0.12525390f, 0.19518059f, 0.03675899f, -0.02177596f, 0.02402514f, 
    0.00800610f, 0.04645171f, -0.09330917f, -0.07660262f, -0.01362256f, 0.09366594f, 0.10699289f, -0.05950709f, 
    0.02423923f, 0.02837242f, 0.12216589f, 0.09918606f, 0.11774249f, 0.03112001f, 0.02072208f, 0.07518473f, 
    0.06516149f, -0.09761853f, 0.06640317f, -0.00410693f, -0.07409576f, 0.08828169f, -0.05898604f, -0.01587154f, 
    -0.03442297f, -0.03198887f, -0.01957913f, -0.02360715f, -0.01884693f, 0.07863554f, 0.01863976f, 0.07070647f, 
    -0.06215531f, 0.02025349f, 0.05661666f, 0.11653683f, 0.02642269f, -0.08667944f, 0.01621871f, -0.04671833f, 
    0.04090027f, -0.00879556f, 0.07592235f, 0.10109580f, -0.04736947f, 0.03396412f, -0.05200743f, 0.03622170f, 
    0.05485166f, 0.04304343f, 0.04522676f, 0.03614149f, 0.04533539f, -0.01015108f, -0.04962575f, 0.09805671f, 
    0.00331147f, -0.01798006f, -0.04072333f, -0.04677417f, -0.05396926f, 0.03470762f, 0.08159292f, 0.05379857f, 
    0.11875043f, 0.14350367f, 0.09851328f, 0.07301215f, 0.14976425f, 0.00287888f, -0.15985192f, -0.13952325f, 
    -0.02835686f, 0.03784034f, 0.16667439f, -0.00711470f, -0.03440508f, -0.04968951f, 0.10998414f, 0.06368843f, 
    -0.14524512f, 0.03089311f, 0.23950280f, 0.08993453f, -0.00705059f, 0.00967185f, -0.01965843f, 0.05949616f, 
    0.06847593f, 0.03088054f, 0.01384563f, -0.11757649f, 0.06676464f, 0.07941615f, -0.02995957f, -0.06828020f, 
    -0.14382938f, -0.04966228f, 0.01322298f, -0.11731643f, 0.10854068f, -0.08371197f, -0.04971392f, 0.00834277f, 
    0.05005772f, -0.25511718f, 0.10446601f, -0.13371700f, 0.18332237f, 0.13864915f, 0.03128678f, 0.13396463f, 
    0.06298550f, -0.02858058f, 0.04851137f, 0.15378548f, -0.14798924f, -0.03482054f, -0.14972273f, -0.12166245f, 
    -0.01404110f, 0.05767516f, 0.07326771f, 0.01648776f, 0.01209601f, 0.03116290f, -0.09580960f, 0.19339831f, 
    -0.04859931f, 0.01836476f, -0.00667233f, 0.03942129f, 0.05282677f, -0.03084155f, 0.02703349f, -0.05288056f, 
    -0.08471157f, 0.01858280f, 0.02356274f, 0.02952667f, 0.04851685f, 0.15290554f, 0.00521139f, -0.09066121f, 
    0.07649129f, -0.04064237f, -0.03679344f, 0.03147590f, -0.02381910f, 0.11133517f, 0.11201131f, 0.05409458f, 
    0.03805291f, 0.02578591f, -0.03725787f, 0.02337180f, 0.01213220f, -0.00867885f, -0.03310517f, -0.01021225f, 
    0.03806009f, 0.03182594f, -0.02908903f, 0.03446868f, -0.01217267f, 0.00872365f, 0.01289494f, -0.00500080f, 
    -0.02301849f, 0.03117416f, 0.04143390f, 0.01254644f, 0.03836242f, 0.04233408f, 0.01734707f, -0.02064563f, 
    -0.04646934f, -0.04439999f, 0.02236698f, -0.01561870f, -0.01154107f, -0.03056348f, 0.02600314f, -0.04355316f, 
    0.00841565f, 0.00727245f, -0.04156312f, 0.02229284f, 0.01170308f, -0.00460626f, -0.03138082f, 0.03282062f, 
    -0.01774675f, -0.01343683f, 0.00334798f, -0.01096408f, -0.04137680f, 0.04430361f, -0.04459611f, -0.02268369f, 
    -0.05136648f, -0.01644953f, 0.01326854f, -0.05704908f, -0.01843952f, -0.03494187f, -0.00038514f, 0.00017672f, 
    0.02248661f, -0.03456456f, 0.02937654f, -0.00343846f, -0.03039614f, -0.01422284f, -0.01741331f, -0.03764966f, 
    0.03820291f, 0.03085213f, 0.00187575f, -0.03256109f, 0.00237474f, -0.03145911f, -0.02931331f, -0.03270281f, 
    -0.04687934f, -0.04232471f, -0.04428882f, -0.00185058f, -0.04560642f, -0.04300550f, -0.00221265f, 0.01064248f, 
    0.00113019f, -0.01653174f, -0.04371504f, 0.00344959f, -0.03210251f, -0.04038611f, 0.00481634f, 0.01134270f, 
    -0.02192067f, 0.03644649f, 0.01646519f, -0.05135799f, 0.05150510f, 0.00300049f, 0.01111921f, -0.03959781f, 
    -0.04162139f, 0.04041826f, 0.02164497f, -0.05427308f, -0.00286818f, 0.03356010f, -0.02203100f, -0.05511188f, 
    -0.03796808f, 0.04350485f, 0.00841369f, -0.00127747f, -0.01159316f, 0.02384685f, -0.00482096f, -0.03554147f, 
    -0.00928595f, -0.05086782f, 0.04300255f, -0.03035156f, 0.04051974f, -0.01403861f, 0.01517048f, 0.01426662f, 
    0.02512821f, 0.02932443f, -0.02442474f, 0.03984775f, 0.04228272f, -0.02468611f, -0.03458212f, 0.00315492f, 
    0.02147539f, -0.04179668f, -0.03077262f, 0.03209221f, -0.04645480f, -0.03036701f, 0.02313247f, 0.03413303f, 
    0.01252620f, 0.02415382f, -0.03071454f, -0.04029071f, -0.03044847f, 0.01885826f, -0.03703742f, -0.02107077f, 
    -0.04674968f, 0.03828807f, 0.00747264f, -0.05504651f, -0.03915788f, -0.03442635f, 0.01078218f, 0.00785453f, 
    0.00535481f, -0.04807812f, -0.05369746f, -0.01531805f, -0.05391760f, -0.05066776f, 0.00770184f, -0.02145923f, 
    -0.00551754f, -0.01495205f, -0.01725602f, -0.01743938f, 0.01784630f, 0.00931811f, -0.03595572f, -0.04580129f, 
    -0.04338158f, -0.05508143f, 0.00704084f, -0.05247872f, 0.00611104f, 0.02987042f, 0.00809200f, 0.03965301f, 
    0.04241143f, -0.05366818f, 0.03695269f, -0.00989003f, -0.01960425f, -0.02805414f, 0.03495730f, 0.02210933f, 
    0.04232206f, -0.04276841f, 0.00464234f, -0.01165817f, -0.02995690f, 0.00733640f, -0.03744638f, -0.04009072f, 
    0.00723365f, -0.00484297f, 0.02867192f, -0.01258155f, -0.01010793f, -0.03422118f, 0.02099719f, -0.00262274f, 
    -0.03704920f, 0.02995454f, 0.02589683f, 0.00962895f, 0.00185111f, -0.05460389f, -0.02835011f, 0.03488719f, 
    -0.03505540f, -0.02930999f, 0.02425038f, 0.03225159f, 0.01729339f, -0.00919851f, -0.00469932f, -0.03967739f, 
    0.03715912f, 0.00570299f, -0.00415180f, -0.00444916f, -0.03539451f, -0.03966872f, 0.04160156f, 0.04566793f, 
    0.01592596f, 0.00340172f, -0.00877008f, 0.01937216f, -0.02121018f, -0.00502825f, -0.00249556f, 0.00406053f, 
    -0.01361258f, 0.02671196f, 0.00567233f, -0.00640690f, 0.01885496f, -0.00066830f, 0.03894448f, -0.02476231f, 
    -0.01269373f, 0.00685581f, 0.00958080f, 0.00391973f, 0.01859012f, 0.00297954f, 0.02885218f, 0.04012628f, 
    -0.01548493f, -0.03351098f, -0.00325535f, -0.01657063f, 0.02534642f, -0.00665446f, 0.04256967f, -0.04899070f, 
    -0.05231960f, -0.00882143f, 0.03826355f, -0.00450448f, -0.00551670f, -0.03518121f, 0.00658557f, -0.02617881f, 
    -0.04995854f, -0.05005301f, -0.00387737f, -0.04533160f, 0.00656319f, -0.03382908f, -0.00209219f, 0.03698914f, 
    -0.01179765f, -0.03543533f, -0.02548607f, 0.01081709f, -0.03110356f, -0.02180399f, 0.00854402f, 0.01752124f, 
    -0.00628669f, -0.01977815f, -0.03446491f, 0.00163824f, -0.01893668f, -0.03212833f, -0.00375893f, 0.00687560f, 
    -0.05330729f, 0.02168151f, 0.00736707f, -0.04946577f, 0.04051796f, -0.04453067f, 0.00767482f, -0.01773695f, 
    -0.01389985f, 0.03063645f, 0.02147827f, 0.03517390f, -0.05307704f, 0.02661511f, -0.01315445f, -0.03201539f, 
    -0.04131757f, -0.03331674f, -0.04540269f, -0.02322790f, 0.00099061f, -0.02627313f, 0.02023162f, -0.01237015f, 
    -0.04932490f, -0.04072898f, -0.02282495f, -0.05109851f, -0.04679431f, 0.02914541f, 0.01892824f, -0.01898353f, 
    -0.01035086f, 0.01726228f, 0.00131663f, 0.04189377f, 0.00305908f, -0.04937743f, 0.03296379f, 0.00843935f, 
    0.02648703f, 0.03888806f, -0.05396459f, -0.00766742f, -0.03301294f, 0.00966780f, -0.00322428f, -0.04868939f, 
    0.00726864f, -0.03726386f, -0.02536952f, -0.00545270f, -0.05086641f, -0.04262611f, 0.03225569f, -0.04646896f, 
    0.01629153f, -0.02297280f, 0.02290460f, -0.01240614f, 0.02957703f, -0.01285325f, 0.03468471f, 0.01223004f, 
    -0.05503992f, 0.02105233f, 0.03848096f, -0.01361157f, -0.01208213f, -0.05476557f, -0.03740019f, -0.04585812f, 
    -0.05502789f, 0.02760509f, 0.02204870f, 0.02918408f, 0.01783285f, -0.05680865f, 0.00114000f, -0.05667978f, 
    0.01400556f, 0.02524226f, 0.04161832f, -0.01511513f, 0.00866171f, 0.01158594f, -0.01852139f, -0.03388893f, 
    0.01421422f, -0.04879900f, 0.00902086f, -0.00338557f, 0.00923688f, 0.03878329f, -0.02802980f, -0.04440397f, 
    -0.05597651f, 0.00650985f, 0.03814738f, -0.03765896f, -0.05124624f, -0.03007197f, -0.01635547f, -0.03644610f, 
    -0.05625880f, 0.04083059f, 0.02605849f, -0.03805551f, 0.02062978f, 0.03273457f, 0.03278340f, 0.01411177f, 
    -0.01997212f, 0.01072677f, 0.03370869f, 0.04258408f, 0.01784219f, -0.01058423f, -0.05230438f, 0.02325026f, 
    0.02757324f, -0.01594401f, 0.03552010f, 0.02741249f, 0.01918409f, 0.04162382f, -0.01695758f, 0.02154935f, 
    -0.04274298f, -0.02646100f, -0.02870881f, -0.02208265f, -0.03194738f, -0.01476228f, -0.05232889f, 0.00357822f, 
    0.02926483f, 0.03446761f, 0.02724505f, 0.01992035f, -0.05483657f, 0.03962699f, -0.03413987f, -0.05526835f, 
    -0.01491535f, -0.02942349f, 0.02353427f, 0.02146305f, 0.04254501f, 0.03071517f, -0.03655623f, 0.03154825f, 
    -0.02137174f, 0.02024584f, 0.00013417f, -0.03430466f, -0.00725106f, -0.03625584f, 0.00184981f, -0.00889085f, 
    -0.03384682f, -0.04565102f, 0.01649218f, 0.03449157f, -0.03624156f, -0.00908470f, -0.05516801f, 0.00538857f, 
    -0.00927151f, -0.03136329f, 0.01478761f, -0.00993321f, 0.00854776f, -0.00752984f, -0.05020052f, -0.02218921f, 
    0.00486258f, 0.02582408f, -0.05002470f, -0.01622375f, 0.01577259f, 0.01685251f, -0.01077312f, -0.05083202f, 
    -0.02394971f, -0.01278939f, -0.03424135f, -0.03710198f, 0.01263721f, 0.00891517f, -0.02349966f, -0.01499342f, 
    0.01230840f, -0.00124196f, -0.03651419f, -0.05520850f, -0.00980908f, 0.02904665f, 0.03674877f, -0.02996814f, 
    -0.02869452f, 0.03856928f, 0.00654836f, 0.02860649f, -0.02379593f, -0.00352511f, -0.02004243f, -0.01069537f, 
    -0.00841243f, 0.00226306f, 0.03133897f, 0.01757894f, 0.00443447f, -0.01811793f, -0.01330605f, -0.00551040f, 
    -0.00791601f, -0.02945845f, 0.01793950f, -0.05178913f, 0.02063038f, -0.00208406f, 0.01913843f, 0.03667387f, 
    -0.01728282f, 0.04158629f, -0.04478760f, 0.01152787f, -0.04164805f, 0.03406288f, -0.03218149f, 0.02339568f, 
    0.01902413f, -0.02978744f, -0.04808964f, -0.03980505f, -0.05267398f, 0.04126795f, -0.01810526f, -0.02340078f, 
    -0.00573935f, -0.00332694f, -0.02588644f, -0.03883181f, -0.04503281f, -0.04039523f, -0.00569949f, 0.01737728f, 
    -0.00083233f, -0.01886747f, 0.02387958f, -0.01898364f, -0.03185434f, -0.00573669f, -0.03910673f, 0.03095242f, 
    0.03031760f, -0.01261786f, -0.02222257f, 0.00301303f, -0.00075504f, -0.02373711f, -0.01064198f, -0.00391808f, 
    0.04197589f, 0.04370937f, -0.00407846f, 0.04486579f, -0.00837982f, 0.02691908f, -0.04340167f, -0.05687616f, 
    -0.01690329f, -0.04192196f, -0.00880114f, -0.01626574f, -0.05443725f, 0.04430964f, -0.04564122f, 0.02785765f, 
    -0.00343257f, -0.01967843f, 0.02060612f, 0.03030393f, -0.02390138f, -0.03562199f, 0.04152415f, -0.02703420f, 
    0.02985781f, -0.04613803f, -0.02878031f, 0.00504502f, 0.00406632f, 0.00611896f, 0.00811481f, -0.03114216f, 
    0.00476605f, 0.00631376f, -0.02393557f, -0.03290806f, 0.03102523f, -0.04646983f, -0.04638507f, -0.02464273f, 
    -0.04030713f, -0.02064137f, -0.00243212f, -0.04517226f, -0.01135072f, -0.03834883f, 0.01129059f, -0.02072061f, 
    0.00765030f, -0.02667078f, -0.05351909f, 0.03871003f, -0.02752819f, 0.00079347f, 0.04404101f, 0.03849798f, 
    -0.04506142f, -0.05468643f, -0.04461791f, -0.02264159f, -0.00353354f, -0.02300176f, -0.00412882f, -0.01449141f, 
    -0.04381330f, -0.01009895f, -0.02296188f, -0.02975351f, -0.02782372f, 0.01453692f, 0.02553617f, -0.00129801f, 
    -0.00687063f, 0.03418318f, 0.02015383f, 0.03567262f, -0.05545352f, -0.04937433f, 0.03002841f, 0.03121129f, 
    0.04323802f, 0.02930668f, -0.01930589f, 0.04337573f, -0.05093309f, 0.03373653f, 0.04108688f, 0.00606601f, 
    -0.02079163f, -0.05390226f, -0.03787679f, -0.01773944f, -0.00528451f, -0.04970972f, -0.00941302f, 0.00298232f, 
    -0.00117454f, -0.03840951f, -0.04735947f, -0.03690093f, -0.02569972f, -0.04752418f, -0.05333062f, 0.02643732f, 
    -0.01166583f, -0.02266338f, -0.02605003f, 0.03934421f, -0.01469048f, 0.03542794f, -0.05461868f, -0.03908971f, 
    0.01032726f, -0.00245738f, 0.01771362f, -0.01699276f, -0.05377251f, -0.03922155f, -0.00418165f, -0.01869958f, 
    0.00679697f, -0.01235191f, -0.01457106f, -0.05580103f, -0.00363182f, 0.04393758f, -0.05588548f, 0.02460350f, 
    -0.04363007f, -0.00213197f, -0.02959257f, -0.05654247f, -0.05056784f, -0.03620627f, -0.01219857f, -0.02356729f, 
    -0.04731385f, -0.02509585f, -0.01810528f, -0.00209989f, 0.00241929f, -0.04504481f, -0.01642779f, 0.01270670f, 
    0.01303290f, 0.02373887f, -0.02730208f, 0.03671310f, 0.04154729f, 0.00841284f, -0.01975134f, 0.04115415f, 
    -0.03175291f, 0.01458369f, -0.04002267f, 0.03464877f, -0.04826537f, 0.01241136f, -0.05307706f, -0.03023433f, 
    0.01314121f, 0.03692672f, -0.02794281f, 0.03991225f, 0.02975172f, 0.01230147f, -0.02575631f, 0.03897537f, 
    0.01508000f, 0.03734374f, -0.04716741f, -0.03024216f, -0.03393371f, 0.02994485f, -0.03357151f, 0.00394589f, 
    -0.04456570f, 0.00053640f, 0.04352989f, 0.00282668f, -0.02835123f, -0.01518321f, -0.01659743f, -0.04070221f, 
    -0.01597486f, -0.00795540f, 0.01407392f, -0.05429803f, 0.01282783f, 0.02786175f, -0.02557640f, -0.03777735f, 
    -0.04477074f, 0.00585723f, -0.00365284f, -0.04907947f, 0.01817891f, 0.04472397f, -0.01674082f, -0.04438271f, 
    -0.03015405f, 0.00719011f, -0.00163200f, 0.00405573f, -0.02594103f, -0.03389158f, 0.00613892f, -0.04055114f, 
    -0.03026501f, -0.02499657f, 0.02562226f, -0.05355043f, -0.01578555f, 0.01940534f, -0.01416440f, 0.04430795f, 
    0.28086501f, 0.26362580f, 0.13507313f, 0.37791395f, 0.12769061f, 0.16361117f, 0.10432945f, 0.15561816f, 
    0.01115015f, 0.00009340f, -0.04077713f, 0.07069886f, 0.22588632f, 0.22778647f, -0.20464367f, -0.27541026f, 
    -0.05966618f, -0.11402637f, 0.27923587f, 0.03261580f, 0.09051242f, 0.09814090f, -0.14601272f, 0.15278569f, 
    -0.33535331f, -0.32848462f, -0.05602128f, 0.28054792f, 0.17073330f, 0.17168950f, -0.00584801f, -0.04587865f, 
    0.21008053f, 0.00358662f, -0.19293141f, -0.00126041f, 0.11689667f, 0.09573762f, -0.11454709f, 0.41551232f, 
    -0.03748072f, 0.06113458f, 0.07534204f, 0.11624993f, 0.06291165f, -0.02100396f, 0.06085966f, 0.00260370f, 
    0.25294867f, 0.42770240f, 0.10642536f, 0.06903448f, -0.02996853f, 0.03083231f, 0.07944179f, 0.01784226f, 
    -0.03356659f, 0.09655742f, 0.00536246f, 0.12203325f, -0.15333138f, 0.41877750f, -0.23503935f, -0.29462153f, 
    -0.03991332f, -0.02949215f, -0.06027548f, 0.07543876f, 0.07686368f, -0.02973773f, -0.05255739f, 0.02697176f, 
    -0.02716705f, 0.12697333f, 0.10924485f, 0.21355164f, 0.01490356f, -0.05106460f, 0.04674519f, 0.04843343f, 
    -0.03261953f, 0.02925159f, -0.03121467f, 0.03384676f, 0.16734155f, 0.13796173f, -0.01310679f, -0.03107737f, 
    0.02255099f, 0.01153155f, -0.06644139f, -0.00359785f, -0.04383815f, -0.03450798f, 0.11896070f, -0.13229395f, 
    -0.05365646f, -0.21533336f, -0.26350403f, 0.09884970f, 0.07739660f, 0.16053864f, 0.21108194f, 0.07559741f, 
    0.03317733f, 0.01330419f, 0.11508169f, 0.01868851f, 0.46265101f, -0.07627518f, -0.15678477f, -0.07323826f, 
    0.04808955f, 0.05986860f, 0.05413555f, 0.09391969f, 0.08371934f, -0.03621317f, 0.15414232f, -0.11495257f, 
    0.08940838f, 0.65292233f, -0.19126417f, -0.16851790f, -0.08497240f, -0.18958560f, 0.03307543f, 0.00639538f, 
    -0.04355377f, 0.05625086f, -0.03219034f, 0.03604427f, -0.01437061f, -0.08021882f, -0.12022196f, -0.02010607f, 
    0.07294862f, 0.00967189f, 0.02719045f, 0.00191571f, -0.07782993f, -0.19307990f, 0.11562388f, -0.21046712f, 
    0.19330730f, -0.25340757f, -0.32868454f, 0.10763784f, 0.14586198f, 0.18503283f, 0.36975333f, -0.02027234f, 
    0.15234563f, 0.07889398f, -0.13780300f, 0.00676898f, -0.01316478f, -0.09003124f, 0.14076343f, 0.11395435f, 
    0.09450386f, 0.15596549f, 0.33003557f, 0.12548240f, -0.06268647f, -0.01836694f, -0.10850746f, -0.07330010f, 
    0.30567223f, 0.19607900f, -0.13335229f, -0.25268322f, 0.13507715f, 0.04441360f, -0.02433240f, 0.05203909f, 
    0.02148074f, 0.00829879f, -0.02958230f, 0.04893880f, 0.21532041f, 0.16890423f, 0.23801707f, 0.04233934f, 
    -0.06726064f, -0.13786221f, -0.15355988f, -0.04644670f, 0.02921263f, 0.06001519f, -0.07377897f, 0.09370675f, 
    0.04067540f, 0.09794501f, -0.23147471f, -0.15561838f, 0.03958726f, 0.16599740f, 0.01338660f, 0.06615102f, 
    0.14749324f, 0.09248289f, -0.01554698f, 0.05874373f, 0.35396731f, -0.06000743f, 0.07646252f, 0.21011192f, 
    0.17439653f, 0.05319130f, -0.04172559f, 0.23305485f, -0.04027547f, 0.09298111f, -0.13410516f, 0.09312093f, 
    0.02583263f, 0.02183917f, -0.06109804f, 0.15382025f, -0.00429507f, 0.06793246f, 0.06849422f, -0.09867111f, 
    0.03502911f, 0.13149686f, 0.00137726f, 0.12416980f, 0.20708442f, 0.15488631f, -0.07133474f, 0.20760165f, 
    0.03311915f, -0.00596545f, 0.00214496f, 0.11359268f, 0.01389467f, -0.00933432f, 0.01129837f, 0.01460518f, 
    -0.30949563f, -0.09275680f, 0.11078221f, -0.00379824f, 0.05870650f, 0.01043809f, -0.07501882f, -0.13261764f, 
    -0.03865082f, 0.06712525f, -0.02329067f, 0.06620023f, 0.00697254f, 0.14805435f, -0.11931558f, -0.06221914f, 
    -0.18916915f, -0.19234604f, -0.07136636f, -0.00022704f, -0.03845444f, 0.11825742f, -0.06497627f, 0.03390742f, 
    -0.27685279f, 0.01303920f, 0.21497592f, -0.01416150f, 0.04913674f, -0.04159467f, -0.19348554f, -0.06736416f, 
    -0.03381776f, 0.01864762f, -0.04840895f, 0.08020365f, -0.12858750f, -0.04376636f, -0.13202699f, -0.00471294f, 
    -0.06521942f, 0.10457804f, -0.05941837f, 0.02601643f, 0.06215837f, 0.03383093f, 0.11938013f, 0.09335384f, 
    -0.07628436f, -0.10113910f, -0.06903037f, -0.15108553f, -0.07417284f, -0.07063469f, 0.00143005f, 0.15008891f, 
    -0.08705609f, -0.00059907f, 0.05332995f, 0.06778354f, 0.24928550f, 0.18979985f, -0.13061523f, 0.11765619f, 
    0.10173195f, 0.01288963f, 0.05624603f, -0.08220600f, 0.07968707f, -0.08919307f, -0.08404640f, 0.14070508f, 
    -0.05129752f, 0.07697663f, 0.31364441f, 0.03892602f, 0.00831706f, -0.14331704f, -0.11869260f, -0.01919836f, 
    -0.04291698f, -0.01139709f, -0.09422648f, -0.04039386f, 0.11588293f, 0.13201271f, -0.01396033f, 0.07740608f, 
    0.14904460f, 0.14583942f, 0.32986370f, 0.18501981f, 0.14459829f, 0.04553472f, -0.06740738f, 0.03462538f, 
    -0.00448839f, -0.09958480f, -0.08078049f, -0.11132964f, 0.15212792f, 0.15724844f, 0.06305632f, 0.01099912f, 
    0.00925926f, -0.05087336f, 0.08218961f, 0.09648611f, 0.26956096f, 0.00966890f, 0.04376326f, -0.00427188f, 
    0.23075987f, 0.15437505f, -0.03097449f, 0.07217868f, -0.05979867f, 0.08384135f, -0.01608505f, -0.08944110f, 
    -0.18392138f, 0.04666273f, 0.09276607f, -0.04003166f, -0.05948185f, -0.05669102f, -0.18508358f, -0.02632456f, 
    0.00958178f, -0.04864180f, -0.03959218f, -0.01446656f, 0.02534792f, 0.05721677f, -0.01878098f, -0.13639842f, 
    -0.02278338f, -0.05368675f, -0.04644015f, 0.00335749f, 0.02188404f, 0.04540922f, 0.11572325f, 0.16555715f, 
    0.06597971f, 0.22149408f, 0.06376567f, -0.00400749f, 0.13219738f, 0.25514153f, 0.02382275f, 0.15504095f, 
    0.05117045f, -0.06969106f, -0.08877737f, 0.02431945f, 0.05183680f, 0.37800980f, -0.05551208f, 0.14993112f, 
    0.23410322f, -0.03039428f, 0.00145383f, 0.18675432f, 0.04097186f, -0.01786049f, -0.14265281f, 0.08543567f, 
    0.14971654f, -0.26989532f, 0.01901727f, -0.30908775f, -0.02756851f, 0.03508099f, -0.04976032f, -0.00475382f, 
    0.14588524f, -0.06374107f, -0.06022955f, -0.09768351f, 0.15547709f, 0.03723598f, -0.04368487f, -0.12972464f, 
    0.00681205f, -0.06558818f, 0.02571573f, 0.10157317f, -0.04522581f, 0.11815533f, 0.04920547f, -0.05263533f, 
    0.14375982f, 0.00233523f, 0.16394553f, -0.06262159f, 0.15045860f, 0.03624308f, 0.14743322f, 0.06043112f, 
    0.00046372f, -0.06053285f, -0.05753011f, 0.14838350f, 0.07250413f, 0.09585088f, 0.21239519f, -0.19965333f, 
    -0.03970530f, 0.01037340f, -0.09462615f, 0.05474428f, -0.05276202f, -0.04237606f, 0.01981923f, 0.01829025f, 
    0.19783725f, 0.13669847f, 0.00990629f, 0.01210556f, 0.07466858f, -0.03622203f, 0.00393032f, 0.15053461f, 
    0.02982051f, 0.06967676f, -0.00305032f, -0.01336072f, -0.07391194f, 0.21192333f, -0.05585415f, 0.03693219f, 
    0.05503244f, 0.13757402f, -0.00764521f, 0.08517939f, -0.01664498f, -0.08666649f, 0.05235834f, -0.20629273f, 
    0.18255399f, -0.35945562f, -0.14223608f, -0.17532627f, 0.02436384f, 0.03464381f, -0.07441189f, -0.09433635f, 
    -0.04624584f, 0.10611632f, 0.08238974f, 0.11291225f, -0.23866656f, 0.05421166f, -0.14123702f, 0.16270296f, 
    0.18204488f, -0.05043688f, -0.07581069f, 0.00733178f, -0.00787814f, -0.02889407f, -0.05171664f, 0.04174970f, 
    0.05292883f, 0.15180743f, 0.00170020f, -0.14006583f, -0.10866259f, -0.03614893f, -0.00515653f, 0.11697807f, 
    0.03921403f, -0.10212865f, -0.03907088f, -0.08564760f, 0.02649146f, -0.08684570f, 0.10998715f, 0.19046494f, 
    0.02208847f, -0.00149074f, -0.14605707f, -0.07863343f, 0.00079549f, -0.03704493f, 0.06839945f, -0.08348777f, 
    0.02720304f, -0.00406452f, -0.20365600f, 0.06166397f, 0.14852288f, 0.11906309f, -0.01615475f, -0.01456414f, 
    -0.00553893f, 0.00144853f, -0.10402321f, 0.09080698f, 0.03902987f, 0.05334362f, -0.22022651f, 0.04055685f, 
    0.03731367f, 0.07262362f, -0.04453822f, -0.05692795f, -0.06212886f, 0.08707198f, 0.02576419f, 0.00674017f, 
    -0.09063676f, -0.07944029f, 0.25450289f, 0.12062921f, 0.01085640f, -0.13301668f, -0.21031421f, 0.10355461f, 
    0.12131380f, -0.09701020f, -0.03896880f, -0.00455153f, -0.31557965f, -0.43498260f, -0.17052063f, 0.01621306f, 
    0.00057492f, -0.10212211f, -0.06740092f, -0.02056546f, 0.10642248f, 0.02869005f, -0.02089676f, -0.07503695f, 
    0.24950986f, 0.19650102f, 0.17079332f, 0.13426705f, 0.07815525f, -0.07244828f, -0.02555760f, -0.03129100f, 
    0.05706423f, 0.02532303f, 0.05564616f, -0.02906038f, -0.07008140f, 0.32107234f, -0.05702470f, 0.09507759f, 
    0.00945868f, 0.07099061f, -0.04117974f, 0.08617651f, -0.00489572f, -0.01624825f, -0.06515741f, 0.00876008f, 
    0.18393122f, -0.11818327f, -0.24029046f, -0.34937766f, 0.03367667f, 0.14181672f, 0.06196025f, 0.08677134f, 
    0.03161627f, 0.07673073f, 0.15481535f, -0.00582225f, 0.06766327f, 0.07392308f, 0.01603672f, 0.02725479f, 
    0.05840409f, -0.02000147f, 0.07088335f, 0.13981825f, -0.10975822f, 0.01573325f, 0.05795906f, 0.02214047f, 
    -0.34497371f, 0.04107768f, -0.33675104f, -0.30983514f, 0.04709445f, -0.02422780f, -0.03640906f, -0.06271739f, 
    0.11579517f, 0.12482474f, 0.02945749f, 0.34492099f, 0.05881895f, -0.14943229f, -0.05165708f, 0.02216034f, 
    0.03999200f, -0.02828103f, 0.03637173f, 0.01656729f, 0.07033025f, 0.02211957f, 0.01095537f, 0.05617422f, 
    -0.15970710f, -0.12565579f, 0.16541947f, -0.14739805f, 0.01569635f, 0.04866825f, -0.02351635f, 0.15820660f, 
    0.04292921f, 0.05541939f, 0.09746735f, -0.13371283f, -0.05456861f, -0.21074086f, 0.00160153f, -0.00875826f, 
    0.10196129f, 0.01708705f, -0.18213437f, 0.01623852f, 0.15787192f, 0.01009739f, 0.07398802f, 0.13585806f, 
    -0.11717331f, -0.03516616f, -0.03050923f, 0.19134207f, -0.08151893f, 0.03065233f, -0.17942744f, 0.02918652f, 
    0.11993621f, 0.05490087f, 0.08045402f, 0.19262572f, 0.14334615f, 0.21262103f, 0.06735073f, -0.00198355f, 
    0.15831882f, 0.06402902f, 0.11533227f, 0.09294194f, 0.03313761f, -0.01492145f, 0.01385034f, 0.02145375f, 
    -0.15185636f, -0.14852263f, -0.29069209f, -0.04711542f, -0.01529023f, 0.04149731f, -0.02081383f, 0.04067574f, 
    -0.01608583f, -0.00300498f, -0.02777729f, 0.04794012f, 0.28650516f, -0.06437165f, -0.02457773f, -0.10811135f, 
    0.10450092f, 0.04471063f, 0.09108564f, 0.06945145f, 0.02998476f, -0.00526804f, 0.03166882f, -0.12274709f, 
    0.30332419f, -0.03207860f, 0.23816037f, 0.13761695f, 0.07594702f, -0.08819132f, -0.10816460f, -0.08526563f, 
    0.07048300f, -0.14161797f, 0.08907981f, 0.03685767f, 0.13580319f, 0.04509956f, 0.13725066f, 0.32909113f, 
    0.11142589f, -0.13774268f, -0.10386647f, -0.01180014f, 0.00250079f, -0.16830850f, -0.01233085f, 0.03793155f, 
    -0.18395840f, -0.17388825f, -0.07749631f, 0.03325272f, -0.06088210f, 0.03142458f, -0.09165794f, 0.00704937f, 
    -0.00993790f, -0.05389633f, 0.03795270f, 0.02289872f, -0.25788265f, -0.28975415f, -0.22357674f, 0.21539442f, 
    -0.02000679f, -0.09261488f, -0.04050630f, 0.06618050f, 0.10971703f, 0.03685265f, 0.02821738f, 0.20815133f, 
    -0.25032526f, -0.04931718f, -0.00384804f, 0.22825220f, -0.13137840f, -0.02079125f, -0.17898957f, 0.04814944f, 
    -0.04863876f, -0.06223010f, -0.10056414f, -0.02213629f, -0.07947126f, 0.35573846f, 0.09810196f, 0.13228297f, 
    0.15827475f, 0.14896567f, 0.04945284f, 0.00368132f, 0.14088921f, -0.02461919f, 0.10110931f, 0.09122077f, 
    -0.01011125f, -0.21524306f, 0.25093818f, -0.16767992f, 0.01392985f, 0.06474696f, 0.14592120f, 0.19488384f, 
    0.08289510f, 0.18802035f, -0.19753657f, 0.01297448f, 0.08508351f, 0.15461954f, 0.13514587f, -0.16539991f, 
    -0.11890990f, 0.08043898f, 0.06593759f, -0.04228219f, 0.11481988f, 0.02064585f, -0.08368714f, 0.15146948f, 
    -0.00191383f, -0.10324887f, -0.18105097f, 0.15193824f, 0.14235814f, 0.02984269f, 0.01812604f, 0.05587193f, 
    -0.09094431f, -0.05628859f, 0.05001322f, 0.02667734f, 0.21432890f, -0.25616580f, 0.13793057f, 0.07005480f, 
    0.08978890f, 0.10171474f, -0.06090332f, 0.07907000f, 0.11590178f, 0.16330616f, -0.07604028f, 0.03434322f, 
    -0.19799255f, -0.08181965f, 0.18966261f, 0.08955236f, -0.14738217f, -0.17318800f, -0.10037591f, 0.03364024f, 
    0.06309234f, 0.03948289f, 0.04840079f, -0.00062958f, 0.02019821f, -0.02110961f, 0.17540902f, -0.12839681f, 
    0.08692206f, -0.01322602f, -0.00594629f, -0.02783522f, -0.12570201f, 0.09699267f, 0.09840906f, -0.06580252f, 
    0.27526292f, -0.00116935f, 0.21429797f, -0.05989326f, -0.05532991f, -0.02431764f, 0.05278962f, -0.05903656f, 
    -0.02611881f, 0.01304533f, 0.00983076f, 0.13176124f, -0.30635008f, -0.01153067f, -0.23747309f, 0.02884171f, 
    0.07883269f, -0.05550394f, 0.00303135f, -0.04378871f, 0.16179737f, 0.05155911f, 0.21582635f, -0.03595696f, 
    -0.23747911f, 0.19117789f, -0.18095499f, -0.02547575f, 0.02322325f, 0.05263453f, 0.04479735f, 0.05144650f, 
    -0.06836113f, 0.08543433f, 0.11543718f, 0.03698696f, 0.18644665f, 0.01051158f, -0.03269999f, 0.15374181f, 
    0.06875172f, -0.00500536f, 0.00916216f, -0.07338544f, -0.11882117f, -0.02458646f, 0.07799333f, -0.06231370f, 
    0.07165096f, 0.11640565f, -0.05758454f, 0.18013899f, -0.07469635f, 0.04550494f, 0.04660994f, -0.13189375f, 
    -0.01383821f, 0.13359357f, 0.03212566f, 0.00551670f, -0.14489755f, 0.05892072f, 0.11175294f, 0.06156836f, 
    -0.04485725f, -0.03546089f, 0.20143549f, -0.03852471f, 0.12737787f, 0.10395071f, 0.05307433f, 0.01851818f, 
    -0.22777915f, -0.23297098f, -0.34608966f, 0.34015828f, 0.12971982f, -0.14783634f, -0.17033838f, 0.00865550f, 
    -0.05257502f, 0.07118597f, 0.11921947f, 0.02030665f, 0.13816860f, -0.04296198f, -0.02807827f, -0.06565721f, 
    0.02816201f, -0.07245524f, -0.02429422f, -0.06587488f, 0.02487893f, 0.01510102f, -0.05749628f, -0.02422113f, 
    0.13114336f, 0.04422693f, -0.01469857f, -0.04209334f, 0.10906596f, -0.02455153f, -0.09813808f, 0.05035268f, 
    0.07278115f, 0.10751624f, -0.05695669f, 0.00092014f, -0.21552691f, -0.01357793f, -0.03334191f, 0.10149331f, 
    0.08404446f, 0.01425190f, -0.09119431f, 0.07551149f, 0.08150911f, 0.11764409f, -0.11202114f, 0.12208222f, 
    0.05348036f, 0.11007098f, 0.07923611f, -0.14590092f, 0.07437588f, -0.06003375f, 0.26317564f, -0.11036136f, 
    0.04301581f, 0.07055397f, -0.13303503f, 0.03661879f, -0.16218805f, -0.00842442f, -0.05150366f, 0.08562626f, 
    0.02489246f, 0.03634356f, -0.00670272f, 0.14621381f, 0.07918315f, -0.05386680f, 0.10009573f, -0.01966303f, 
    -0.04725660f, -0.06199065f, 0.04006309f, -0.04519712f, 0.06667049f, 0.03618983f, 0.16784285f, -0.04628569f, 
    0.10561603f, 0.07683188f, -0.03086180f, 0.01411211f, 0.02972492f, -0.01775970f, 0.01098960f, -0.02082002f, 
    -0.06297017f, -0.02482242f, 0.01168881f, 0.05059360f, 0.01635822f, 0.02472701f, -0.10531003f, 0.09587993f, 
    0.02376482f, -0.09908749f, -0.06365567f, -0.03012618f, -0.00949680f, -0.00752742f, 0.01468104f, 0.00921796f, 
    0.06235270f, 0.16577460f, 0.04859542f, -0.01152268f, 0.02135289f, -0.09741261f, 0.01641967f, -0.06979456f, 
    0.07367529f, 0.09948992f, -0.03608937f, 0.07182985f, 0.00482725f, 0.11275952f, 0.09425872f, 0.06128982f, 
    0.02117547f, -0.01110281f, 0.01865108f, 0.04905922f, 0.07560428f, -0.04855275f, -0.00716967f, 0.03404026f, 
    -0.07188548f, -0.03697302f, -0.06415974f, 0.11906307f, -0.05232836f, -0.13933043f, 0.00092313f, 0.14379181f, 
    -0.07521220f, -0.10659926f, -0.06593995f, 0.04129816f, 0.15641358f, -0.01340183f, -0.01789487f, 0.06152451f, 
    0.00758232f, -0.02501810f, 0.03846593f, -0.04243530f, 0.00496292f, -0.04350275f, 0.13826001f, -0.03661241f, 
    -0.00616418f, -0.01731682f, -0.02251231f, 0.07923366f, -0.10524798f, -0.20161541f, 0.19344780f, 0.12369359f, 
    -0.01298013f, 0.01452988f, 0.11054760f, 0.14552279f, -0.01316851f, 0.02098479f, -0.04313844f, -0.02872778f, 
    0.00986869f, -0.07832693f, 0.10536988f, 0.12526259f, -0.02950692f, 0.02209113f, -0.08007418f, -0.04959037f, 
    -0.01692136f, 0.11638293f, 0.15799065f, 0.06356084f, 0.17162144f, -0.12045011f, -0.00330710f, 0.24960679f, 
    -0.00163432f, 0.01927254f, -0.13541394f, 0.04429099f, 0.01954762f, -0.01951156f, 0.11819363f, 0.03752961f, 
    0.01730829f, -0.03674283f, 0.06948772f, -0.01818152f, -0.09130069f, -0.02240792f, 0.00931737f, -0.05213796f, 
    0.20361534f, 0.09342184f, 0.02817700f, 0.08860172f, 0.04780188f, 0.03990773f, -0.16530812f, 0.10349805f, 
    0.00798184f, -0.03382995f, -0.00407316f, -0.04289464f, 0.03225404f, 0.06386934f, -0.10200135f, -0.01930560f, 
    0.04171291f, 0.01149081f, 0.01375500f, -0.00207847f, 0.00425163f, 0.03989007f, -0.05042122f, 0.03351264f, 
    0.03888982f, 0.03758035f, -0.04304336f, -0.05433747f, 0.01600139f, 0.00965861f, -0.05441641f, -0.02058571f, 
    0.03945725f, 0.03977857f, 0.05056785f, 0.01721567f, -0.00687083f, -0.05094657f, -0.02347668f, -0.05557743f, 
    -0.05367285f, 0.02623429f, 0.03473704f, 0.00418680f, 0.01831593f, 0.04131687f, -0.02941820f, -0.04743748f, 
    -0.03816786f, 0.01723074f, 0.01711939f, -0.01297903f, 0.01161181f, -0.04130698f, -0.00038451f, -0.04523689f, 
    0.03830056f, 0.03747388f, -0.04711287f, 0.03434350f, 0.03971292f, 0.00580502f, -0.01176438f, -0.02796915f, 
    -0.02389703f, -0.01248178f, 0.02141000f, -0.00987420f, -0.05278615f, -0.02037274f, 0.02235170f, 0.00691557f, 
    0.02362580f, -0.00606168f, 0.02806699f, -0.02543878f, -0.00246000f, 0.03356974f, 0.02408629f, -0.05625114f, 
    -0.02677216f, -0.04948051f, -0.05078252f, 0.03540757f, 0.03497019f, 0.01075386f, -0.01343706f, 0.01618956f, 
    0.00411693f, -0.03796605f, 0.03630945f, -0.05201005f, 0.01159040f, 0.04351759f, -0.00541077f, -0.01721104f, 
    -0.05272486f, -0.05342971f, -0.01938841f, -0.03348137f, -0.01841716f, 0.01663351f, 0.03566912f, -0.04376614f, 
    -0.05620202f, -0.02492080f, 0.00080822f, -0.00848694f, -0.04623936f, -0.00967564f, -0.01084636f, -0.03645843f, 
    -0.04006850f, 0.02466993f, 0.03258658f, 0.00219677f, 0.01351537f, -0.05218864f, -0.02116680f, -0.05172138f, 
    0.01704211f, 0.01209430f, -0.02582940f, 0.03058591f, -0.03266621f, -0.05599929f, -0.02799809f, -0.00644671f, 
    -0.02881549f, -0.04631997f, 0.01794146f, 0.01934743f, 0.01998476f, 0.01909593f, -0.02009604f, -0.01921202f, 
    -0.01283763f, -0.01379192f, 0.02725717f, -0.02953831f, 0.03970595f, -0.00774738f, 0.02877264f, 0.03777713f, 
    0.02518604f, -0.01254439f, -0.04544014f, -0.04334943f, -0.02839025f, 0.01874880f, 0.03129457f, -0.04929165f, 
    -0.01623679f, -0.05081971f, 0.00663708f, 0.00415485f, -0.02105062f, 0.03259892f, -0.01267539f, -0.05776047f, 
    0.01418803f, -0.05558842f, -0.02729801f, -0.00006327f, 0.00977213f, -0.02542348f, -0.04432981f, -0.04955678f, 
    -0.05670988f, -0.00215174f, 0.03550754f, -0.03333163f, 0.03349227f, 0.01324782f, 0.01389642f, -0.01613511f, 
    -0.01910441f, -0.03444173f, -0.03324021f, -0.01216064f, 0.03027146f, 0.02478701f, 0.01644161f, 0.02963504f, 
    0.01058193f, 0.01302717f, -0.04067524f, 0.02715640f, -0.05192230f, -0.02309950f, 0.03015570f, 0.03945387f, 
    -0.03262861f, -0.00151371f, 0.02731190f, 0.00516246f, -0.03397795f, 0.01417316f, -0.02029485f, 0.03163349f, 
    -0.02937701f, -0.00220597f, -0.05353672f, -0.01596871f, -0.04964600f, 0.02581832f, -0.01952726f, -0.03517903f, 
    -0.00062538f, 0.04481343f, 0.03422732f, -0.04499954f, 0.02128410f, -0.01311687f, 0.01647226f, -0.02169127f, 
    -0.01758807f, -0.03225705f, -0.00106285f, 0.01139536f, -0.03989453f, 0.02273709f, -0.04038727f, -0.02295384f, 
    -0.03287258f, 0.01257987f, -0.04553929f, 0.03392708f, 0.03113341f, -0.02573342f, 0.02851480f, 0.00982218f, 
    -0.01689609f, 0.01502850f, -0.03412225f, -0.02981364f, -0.03529308f, -0.02177767f, -0.03063772f, 0.03090642f, 
    -0.00763999f, -0.04746877f, 0.03929643f, -0.04284654f, 0.02815855f, 0.00641988f, 0.00991457f, -0.02563406f, 
    0.00769668f, 0.03778891f, -0.03007317f, 0.00062973f, -0.00370472f, 0.04239320f, -0.00717869f, 0.02370126f, 
    0.02485393f, -0.02800090f, 0.04202452f, 0.04440783f, -0.02360331f, 0.03218760f, -0.03555833f, -0.04001722f, 
    0.00772926f, -0.00621651f, -0.03998942f, -0.00946940f, 0.02144608f, 0.00494231f, -0.00951447f, 0.01454022f, 
    0.03471296f, 0.01940895f, 0.04491350f, -0.01955974f, -0.03879442f, 0.04271435f, 0.00855116f, -0.00352600f, 
    -0.00573450f, -0.01374341f, -0.01777275f, -0.03724264f, -0.01886864f, -0.05389881f, -0.03819914f, -0.03022466f, 
    -0.01569477f, -0.01722605f, -0.00877582f, -0.02056662f, 0.01865404f, -0.02515485f, -0.04963404f, 0.03301048f, 
    -0.01198462f, -0.01422518f, 0.00471829f, -0.02098764f, 0.02612704f, 0.00186432f, -0.01648935f, 0.00297191f, 
    -0.02141106f, 0.00132719f, 0.03037086f, -0.02885641f, -0.04770665f, 0.00364128f, 0.02227780f, 0.00104635f, 
    0.03558072f, -0.00435153f, -0.03582000f, -0.02757251f, 0.00592926f, 0.01169460f, -0.00081385f, -0.00105839f, 
    0.02960084f, -0.04599538f, -0.01801374f, 0.00612471f, -0.01762818f, 0.03849045f, -0.01461122f, -0.05100791f, 
    0.02264871f, 0.03948406f, 0.03615494f, -0.00665235f, 0.03168305f, -0.05413962f, 0.04031214f, 0.01117966f, 
    0.00759156f, -0.02001575f, 0.04081199f, -0.02988402f, -0.01117676f, 0.00405081f, -0.04272119f, 0.01552210f, 
    -0.04508419f, 0.00689100f, -0.04169054f, -0.03884539f, 0.00403412f, -0.00592455f, -0.03715568f, -0.03679631f, 
    -0.00632318f, -0.00846773f, 0.02049989f, 0.03566041f, 0.04160697f, -0.05134856f, -0.02676748f, -0.01659358f, 
    -0.00116353f, 0.03827928f, 0.02213916f, -0.01434806f, -0.00805596f, 0.00631541f, 0.03262369f, -0.02325955f, 
    -0.00878216f, -0.04207712f, 0.02379830f, -0.02819642f, 0.02084367f, 0.00717142f, -0.03448365f, 0.03740650f, 
    -0.05818713f, -0.02179033f, -0.03317846f, -0.03673089f, 0.03736667f, 0.01811872f, -0.02263782f, -0.02892478f, 
    -0.02091615f, -0.00971777f, -0.04993610f, 0.00478760f, 0.00754635f, 0.01776295f, 0.03381027f, -0.04399776f, 
    -0.03024577f, -0.02546988f, 0.03587597f, 0.01442991f, 0.01336390f, -0.04008667f, -0.01985803f, 0.04757044f, 
    -0.05541087f, -0.01962837f, -0.04857085f, 0.00663847f, -0.02719963f, 0.01714077f, -0.03453659f, 0.04279839f, 
    0.03581476f, -0.03091383f, 0.00361649f, 0.03162447f, 0.00424817f, 0.00572410f, -0.04085484f, -0.02161608f, 
    0.03348709f, 0.01580742f, -0.04221924f, 0.01663236f, 0.00141390f, -0.01262440f, -0.01039668f, 0.00513518f, 
    -0.04716633f, -0.00445896f, 0.02488142f, 0.03345352f, 0.01225727f, -0.02600745f, -0.03446489f, 0.01008955f, 
    0.01446381f, -0.00893913f, -0.00974946f, -0.05297859f, 0.02449560f, 0.03391264f, -0.05707682f, 0.00633312f, 
    -0.04551673f, 0.02210816f, -0.05508425f, -0.01035257f, 0.04000761f, -0.03612609f, 0.03817368f, -0.04445889f, 
    -0.03442374f, 0.00385786f, -0.05762876f, -0.01428449f, -0.02251310f, 0.03588288f, -0.05491496f, 0.01288530f, 
    -0.01608124f, -0.05624446f, -0.00582431f, -0.05929770f, 0.04324736f, -0.01727038f, 0.00381174f, -0.02964903f, 
    -0.05467134f, -0.01769306f, -0.01628692f, -0.05824482f, -0.01351925f, 0.03735576f, 0.02087584f, -0.02359240f, 
    0.01232674f, -0.05780350f, 0.00166420f, -0.03607745f, -0.01431488f, -0.04156247f, 0.02331552f, 0.02539278f, 
    -0.05559429f, -0.03804865f, -0.04740909f, -0.00924580f, 0.02174844f, 0.01969270f, -0.03242002f, 0.02656608f, 
    -0.04521852f, 0.00009587f, 0.03444414f, -0.05232676f, 0.01270523f, -0.02746273f, 0.03309949f, -0.04486978f, 
    -0.04886425f, -0.03040193f, -0.01419337f, 0.04191018f, -0.00098278f, 0.01050899f, -0.02061152f, 0.02565015f, 
    -0.05207641f, 0.00121949f, 0.02425917f, -0.04905325f, -0.02300571f, 0.00784315f, -0.04323978f, 0.01216951f, 
    -0.00897252f, -0.04174776f, 0.03306365f, -0.01695570f, -0.00260134f, 0.02403843f, 0.03734653f, -0.03398981f, 
    0.03811266f, -0.03486264f, -0.02219377f, 0.00292079f, -0.01720043f, 0.01891184f, 0.03462141f, -0.02326660f, 
    -0.04408637f, -0.05636575f, -0.01347896f, -0.05680790f, 0.02011675f, -0.03920053f, -0.02314755f, 0.02292410f, 
    -0.03443804f, -0.05484234f, -0.00871544f, 0.00660418f, 0.03249760f, -0.04456786f, -0.02449443f, -0.03975318f, 
    -0.02391342f, -0.01333833f, 0.01065013f, -0.03858481f, -0.05029924f, -0.03264434f, -0.04794654f, 0.03041005f, 
    -0.03560582f, 0.02726649f, 0.02917465f, -0.00614744f, 0.01305272f, 0.02728837f, -0.00242796f, -0.02851025f, 
    -0.03746964f, 0.02084860f, 0.00167321f, -0.03662005f, 0.01184240f, 0.00120651f, -0.01128557f, -0.00157361f, 
    0.01050632f, 0.01417579f, -0.01602174f, 0.03364648f, -0.02607593f, 0.00386289f, 0.04032890f, 0.01556013f, 
    -0.00624061f, -0.05123455f, 0.04082756f, -0.04055370f, 0.03836855f, 0.01093618f, -0.03079107f, -0.02545924f, 
    0.03587860f, -0.04661725f, 0.02885737f, -0.04070340f, 0.00004414f, 0.00030482f, -0.05756614f, 0.00426167f, 
    -0.04917286f, -0.02228132f, 0.01604106f, -0.03957589f, -0.01498673f, -0.03017169f, 0.03195851f, -0.01909339f, 
    0.00012833f, 0.00909634f, -0.03090247f, 0.03818939f, -0.03991976f, 0.02251958f, 0.00765519f, 0.02021802f, 
    -0.04696968f, -0.01075951f, -0.03844979f, 0.01509445f, -0.00240926f, -0.03690211f, 0.02684266f, 0.00093366f, 
    -0.02197098f, 0.02429720f, 0.03215450f, -0.03934733f, 0.03619261f, -0.03269012f, -0.01768839f, 0.02293253f, 
    -0.02759085f, -0.01378948f, -0.03228472f, -0.04145524f, -0.00127078f, -0.05366898f, 0.00736650f, 0.03775300f, 
    0.00656135f, 0.00303195f, 0.03643101f, 0.03861289f, -0.01771221f, 0.01615927f, -0.03947342f, 0.03596588f, 
    0.03612650f, 0.00311064f, -0.05946633f, 0.02273465f, -0.06177872f, -0.05611419f, 0.03123466f, 0.02629162f, 
    0.01814212f, -0.04283786f, -0.01190242f, 0.03183521f, -0.01085229f, -0.03749057f, 0.02292117f, -0.01052383f, 
    -0.04873011f, 0.01273752f, 0.00696350f, -0.05129332f, 0.03799283f, 0.01253669f, -0.01944035f, -0.05642791f, 
    -0.00919964f, -0.01615495f, 0.03812366f, 0.02555337f, -0.02425551f, -0.05849243f, 0.00916800f, 0.00478034f, 
    -0.01596058f, -0.04112909f, 0.02728718f, -0.04607300f, 0.00776615f, 0.02397365f, 0.02685403f, 0.03774081f, 
    0.00466790f, -0.02521883f, 0.00184131f, 0.02106932f, -0.01003525f, 0.01272320f, 0.03061298f, -0.01454152f, 
    -0.02608944f, 0.00534194f, 0.01389400f, -0.00785137f, 0.02541584f, -0.03856663f, -0.02346393f, -0.02834623f, 
    -0.01465755f, 0.03918869f, 0.00189957f, 0.03133389f, -0.00230633f, -0.02928779f, 0.02464154f, 0.00740012f, 
    -0.01377908f, 0.02077023f, -0.03559266f, -0.02471990f, -0.04886040f, -0.00337174f, -0.05392336f, -0.00604384f, 
    0.03735481f, 0.00495111f, -0.02358536f, -0.00414894f, 0.03830066f, 0.01159303f, -0.01781536f, -0.01568956f, 
    -0.03586423f, -0.00915224f, 0.01291827f, 0.00883417f, -0.05665916f, -0.02049157f, -0.05423355f, 0.01489950f, 
    -0.03617517f, -0.05144110f, 0.02821509f, -0.03015314f, -0.00073454f, -0.02233668f, -0.05430752f, -0.02825987f, 
    -0.04846330f, 0.00299504f, -0.00211630f, 0.02708954f, -0.03028924f, -0.05179595f, -0.05709311f, -0.01873589f, 
    -0.01974330f, 0.00797975f, -0.02999936f, 0.00562157f, -0.05709917f, 0.02249172f, 0.04240571f, -0.00168629f, 
    -0.04226580f, -0.05167393f, 0.00048185f, -0.01163387f, -0.02483576f, 0.03791464f, 0.00810560f, 0.00141304f, 
    -0.02464348f, -0.01608321f, 0.03662408f, -0.04821892f, -0.02336876f, 0.01999515f, -0.05150336f, -0.03739902f, 
    -0.00437050f, -0.01859924f, -0.01961567f, -0.04001535f, 0.02976011f, 0.01794299f, 0.01269171f, -0.00756623f, 
    -0.04675625f, -0.00268905f, 0.02395255f, -0.02165889f, 0.04212657f, -0.04752280f, 0.01532472f, 0.02194366f, 
    -0.15305056f, 0.04498482f, 0.05988544f, 0.15990868f, -0.03014869f, -0.00399140f, -0.06919041f, -0.04675831f, 
    -0.06292762f, -0.03107095f, -0.04392529f, -0.07915004f, -0.41136485f, 0.21222021f, 0.24165940f, 0.30159399f, 
    0.31231156f, 0.15694606f, 0.08658390f, 0.06799205f, 0.35687029f, -0.00947911f, 0.09700040f, 0.13666497f, 
    -0.04559936f, 0.11420527f, 0.02193161f, -0.14215979f, 0.04580674f, 0.03027681f, 0.09070336f, 0.26871696f, 
    0.09555110f, 0.03571272f, -0.22377095f, -0.01963140f, 0.25520366f, 0.09392808f, 0.02314787f, 0.08356619f, 
    -0.25393423f, 0.11616250f, 0.00504681f, 0.19730608f, -0.01561588f, 0.08156691f, 0.05532471f, 0.05861324f, 
    0.08377840f, 0.11330500f, -0.20890127f, -0.07461228f, 0.17009117f, 0.09605815f, 0.08631515f, 0.05351086f, 
    0.02596660f, -0.02372340f, 0.03912565f, 0.07996989f, -0.39665595f, 0.18462311f, -0.09596382f, 0.26736951f, 
    -0.02728090f, 0.05593615f, 0.08400644f, 0.12531105f, 0.24352336f, 0.02511130f, 0.18080014f, 0.09342831f, 
    0.01706471f, -0.09050296f, -0.05261243f, 0.07168226f, -0.08104405f, 0.03622989f, -0.07479380f, 0.00622475f, 
    0.06836099f, 0.06370094f, 0.00127003f, 0.07156436f, -0.08128532f, 0.02292304f, 0.00072585f, -0.18780665f, 
    0.08044602f, 0.12571913f, -0.04104499f, 0.04013279f, -0.05617290f, 0.11216657f, 0.13456790f, 0.02664021f, 
    0.16599172f, 0.10325214f, -0.06210099f, -0.11109723f, -0.09109768f, -0.03832267f, 0.04228049f, -0.04501203f, 
    -0.04310081f, 0.14814343f, 0.13419613f, -0.06423049f, -0.14378481f, -0.10159348f, 0.07675328f, -0.05740722f, 
    0.21129258f, 0.11490220f, 0.11158715f, -0.03225218f, 0.24397035f, 0.15227517f, 0.14805619f, 0.14115612f, 
    -0.34932414f, 0.28915268f, -0.30462846f, 0.18091913f, 0.00502468f, -0.00845144f, 0.05471494f, 0.03104815f, 
    0.07831356f, -0.05856660f, 0.09188630f, 0.12946893f, -0.12079324f, -0.05185505f, -0.11025392f, 0.08936647f, 
    0.04674311f, -0.05285532f, -0.09884624f, -0.09886129f, -0.06994238f, -0.14157607f, 0.07890295f, -0.08583884f, 
    -0.30884314f, 0.21419950f, 0.15997617f, 0.10087102f, -0.00042639f, 0.13200717f, 0.03346060f, -0.00286737f, 
    -0.12353734f, 0.05213068f, -0.08933964f, 0.00187006f, -0.31726903f, 0.16248874f, 0.14871086f, -0.04413556f, 
    -0.04261357f, 0.13762453f, 0.17144546f, -0.00625817f, 0.06224290f, -0.11598197f, 0.03077390f, -0.10643464f, 
    -0.48336688f, -0.12068687f, -0.22367339f, 0.51797718f, 0.18262766f, -0.05225518f, 0.03168676f, 0.17918278f, 
    0.14241827f, -0.00963338f, 0.16186097f, 0.05670793f, 0.44678140f, 0.05454656f, -0.07446428f, -0.06147965f, 
    -0.08528572f, -0.03557276f, -0.02542652f, -0.10004932f, -0.08007108f, 0.09251262f, -0.07799105f, 0.06134948f, 
    -0.13279331f, 0.05460377f, 0.05739595f, -0.03818814f, -0.04205932f, -0.05874084f, -0.05713964f, -0.02540355f, 
    0.07513177f, 0.20445056f, 0.15763952f, 0.04961304f, -0.38896981f, -0.01660279f, 0.29890391f, -0.13291842f, 
    0.02852464f, 0.11219997f, -0.05716248f, 0.26308107f, 0.02219955f, 0.13129099f, 0.04914318f, 0.17812452f, 
    0.24850169f, -0.04479195f, 0.28195399f, -0.29439628f, -0.07139130f, -0.02117262f, 0.10394055f, 0.09336341f, 
    0.00430229f, 0.07429586f, -0.10129908f, 0.13722633f, -0.20564303f, -0.11106504f, -0.16248734f, -0.03197366f, 
    -0.16607052f, 0.02213771f, 0.00987025f, 0.01304227f, -0.01750087f, 0.02018788f, -0.02872495f, 0.07942863f, 
    0.14397396f, -0.02369437f, 0.07128546f, 0.02324508f, -0.03569385f, 0.10274263f, 0.02194741f, 0.09334074f, 
    0.04949247f, 0.03615684f, -0.06270088f, 0.08876627f, 0.04927050f, 0.05803787f, -0.05462813f, -0.01367657f, 
    -0.10761727f, 0.00633748f, -0.02487792f, -0.06887626f, 0.03396964f, 0.02283799f, 0.06191318f, -0.01539745f, 
    -0.08377299f, 0.00083236f, -0.02717681f, -0.06134805f, 0.00531010f, -0.06623594f, -0.04492593f, 0.05436437f, 
    0.05408080f, 0.00485954f, 0.06204775f, -0.09203581f, -0.17027907f, 0.12659670f, -0.08521917f, 0.15426396f, 
    0.04105089f, 0.03441561f, 0.02614314f, 0.04471264f, 0.06960811f, -0.07112576f, 0.03980330f, 0.05288961f, 
    -0.17219274f, 0.01782289f, -0.05192169f, 0.00397315f, -0.03003093f, -0.01606156f, -0.01954080f, 0.03373539f, 
    0.03717961f, -0.04461538f, -0.02870402f, -0.04674874f, 0.07462919f, 0.15656622f, -0.01461384f, 0.13531812f, 
    -0.02720354f, -0.00199960f, 0.00697772f, -0.07934792f, 0.15197515f, 0.04932277f, 0.04550575f, -0.00283226f, 
    0.27233094f, -0.18170688f, 0.12630701f, -0.24266429f, -0.18607791f, -0.02197779f, 0.02254890f, -0.08760367f, 
    -0.17188092f, 0.04444292f, -0.10169907f, -0.01044240f, -0.37961578f, -0.19008392f, 0.03675686f, 0.11791547f, 
    -0.10041490f, -0.00703309f, 0.19483788f, -0.13864821f, -0.04778795f, -0.15288892f, -0.03387583f, -0.04661570f, 
    -0.04813796f, 0.14277776f, 0.14771923f, 0.02141310f, -0.00338710f, -0.03694760f, -0.03926847f, 0.04508768f, 
    0.08036134f, 0.06618694f, 0.12336786f, -0.01661883f, -0.09013104f, 0.12781607f, 0.17177799f, 0.25465113f, 
    0.12137928f, -0.02576211f, -0.06381736f, -0.03893376f, 0.14111777f, 0.11058667f, 0.09285090f, 0.07892605f, 
    0.06222320f, 0.03994500f, 0.04095406f, 0.07920210f, -0.05964397f, -0.02242519f, 0.03688483f, 0.04113363f, 
    -0.01340442f, -0.03507190f, 0.02256580f, 0.00062349f, -0.00151380f, -0.02262763f, 0.09988483f, -0.04984228f, 
    -0.04459102f, -0.07827643f, 0.00196771f, -0.06464813f, -0.01585917f, 0.07415886f, 0.01503032f, -0.01394821f, 
    0.19259839f, 0.31510857f, 0.10082274f, 0.01702229f, 0.07928054f, -0.12425129f, 0.02400595f, -0.32183367f, 
    -0.03137333f, 0.00527449f, -0.04287917f, -0.02918515f, 0.12693787f, -0.39878649f, 0.17209530f, -0.08345691f, 
    -0.00490494f, -0.13503146f, 0.07378763f, -0.20657964f, 0.07076780f, -0.07274634f, -0.01619330f, -0.10824784f, 
    0.29722753f, 0.00477697f, -0.15659396f, 0.21051614f, 0.03284162f, -0.05693422f, 0.06177502f, 0.13590996f, 
    0.05571656f, -0.07860924f, 0.11671733f, -0.16225842f, 0.42334923f, 0.11708822f, -0.10080099f, 0.10168241f, 
    0.09461197f, 0.08262161f, -0.03940760f, -0.26833975f, 0.01188003f, -0.07106768f, 0.00502534f, 0.04297796f, 
    -0.18089795f, 0.11462773f, 0.08219983f, 0.08047380f, 0.01739492f, 0.05980754f, -0.13139935f, 0.08404720f, 
    -0.04735809f, -0.05276516f, -0.09903318f, 0.00860084f, 0.00699340f, -0.17514774f, 0.05702255f, 0.08104815f, 
    0.02914994f, -0.11522190f, 0.02979502f, -0.06030580f, 0.02154636f, -0.03600160f, -0.07792348f, 0.13437957f, 
    0.27072167f, 0.04334745f, 0.05187315f, -0.09025840f, 0.09880020f, -0.13616551f, 0.12356124f, -0.09804318f, 
    -0.05690887f, 0.00022185f, -0.03576479f, 0.05620615f, -0.06578954f, -0.08834889f, -0.15219204f, 0.02361355f, 
    0.02456010f, -0.11213829f, 0.03625428f, -0.06051381f, 0.04248579f, 0.07971352f, -0.02915096f, 0.19958709f, 
    0.15839754f, 0.16868252f, -0.00583515f, 0.16323270f, 0.00790281f, -0.03836960f, 0.09937516f, 0.03095373f, 
    -0.01535418f, -0.02243573f, -0.06111945f, 0.00410344f, -0.05818349f, -0.07891055f, 0.14400135f, 0.02586658f, 
    0.00524244f, 0.00958154f, 0.13932437f, -0.12927571f, 0.05729790f, 0.09797449f, -0.08460216f, 0.06792444f, 
    0.26403099f, -0.47520056f, 0.21108361f, 0.25940827f, 0.05998002f, -0.02175146f, 0.02573045f, -0.14342485f, 
    0.01958054f, -0.06383935f, -0.01262971f, 0.08216767f, -0.04308208f, -0.06767816f, 0.09211475f, -0.15311685f, 
    -0.02275741f, 0.02937254f, 0.09366384f, 0.04016720f, 0.09769179f, 0.29913449f, -0.00649070f, 0.22295843f, 
    0.01211696f, 0.33233660f, 0.04768611f, 0.14081509f, 0.02850080f, 0.07537197f, -0.04834813f, 0.05552712f, 
    0.03205378f, -0.14803457f, 0.02672847f, -0.06721567f, -0.02896499f, 0.10124408f, 0.10773093f, -0.07647335f, 
    0.04056871f, 0.04189914f, -0.04396528f, -0.07578386f, 0.07652267f, -0.03061773f, 0.02220675f, 0.01353922f, 
    -0.12663810f, 0.01748060f, 0.29585478f, -0.10418212f, 0.10359589f, 0.05729114f, 0.00309606f, 0.07042497f, 
    0.15129173f, 0.10651162f, 0.02489058f, -0.07879589f, -0.07734223f, -0.17920144f, -0.18016024f, -0.06570911f, 
    -0.02725688f, 0.03117489f, -0.02756808f, -0.00288024f, 0.00867619f, 0.02322448f, 0.06764041f, -0.04420690f, 
    -0.01889914f, 0.04166776f, 0.08268944f, 0.08416509f, -0.06663401f, -0.01095907f, 0.06898368f, 0.06577220f, 
    -0.05364643f, 0.03948733f, 0.06266499f, 0.02913997f, -0.14040215f, 0.07202391f, -0.04418195f, 0.01766505f, 
    0.05550290f, 0.11919243f, -0.01763825f, -0.10066240f, 0.03615363f, 0.03270990f, 0.15709773f, 0.02997216f, 
    0.31345487f, 0.14108968f, -0.03012621f, -0.26853675f, -0.06380421f, 0.10203927f, -0.12353005f, -0.04168842f, 
    -0.04468522f, -0.03507541f, -0.14300543f, -0.04755635f, 0.17970628f, 0.26634970f, 0.11416412f, 0.01948052f, 
    0.03728836f, 0.03095594f, -0.05161007f, -0.06207321f, -0.03767751f, -0.00511247f, -0.00618153f, 0.01414468f, 
    0.15420981f, -0.05765858f, -0.00694856f, -0.05321357f, -0.05617554f, 0.09376403f, -0.06860054f, -0.01372459f, 
    0.09701500f, -0.03339319f, 0.02313753f, -0.14607425f, -0.06039308f, -0.13619195f, -0.08899411f, 0.04849952f, 
    0.07458863f, 0.04109753f, -0.01174085f, -0.07154266f, 0.04611043f, 0.00641623f, 0.02466597f, 0.04342924f, 
    0.09157996f, -0.10825808f, -0.05358458f, -0.10203241f, -0.00531107f, -0.04601336f, -0.00917207f, 0.02019997f, 
    0.04664204f, -0.04033309f, 0.05283274f, 0.14293844f, 0.01371700f, -0.04926614f, 0.09259103f, -0.00325339f, 
    0.01348158f, -0.16915511f, 0.04913964f, 0.05959900f, -0.08541461f, 0.06696462f, -0.07092368f, -0.17555420f, 
    0.02487703f, -0.03034966f, -0.06159303f, -0.04459119f, 0.01655353f, -0.01101836f, -0.09934065f, 0.02484328f, 
    0.03422648f, 0.09902269f, -0.05041201f, -0.07341920f, 0.01156503f, -0.00897137f, 0.06817447f, 0.10960384f, 
    0.10664410f, 0.10744303f, -0.01148836f, 0.07253810f, -0.01037129f, 0.08299135f, 0.00059857f, -0.05825927f, 
    0.20710629f, -0.12888183f, -0.18305221f, -0.03093046f, -0.11116093f, 0.02094476f, -0.03349967f, -0.04033200f, 
    0.06741638f, 0.10043332f, 0.04818335f, -0.01307710f, 0.06751601f, 0.20841128f, 0.19827642f, 0.19202586f, 
    0.01094121f, 0.05471734f, -0.00809228f, -0.04687798f, 0.11889704f, -0.05219053f, 0.03977182f, 0.01516931f, 
    0.10836294f, 0.06868428f, 0.17261834f, 0.07322276f, 0.08154104f, 0.07840111f, 0.07615336f, -0.02038836f, 
    0.10008732f, 0.05502038f, 0.08383832f, -0.01541292f, -0.34918004f, 0.06435700f, 0.04890414f, -0.05741417f, 
    -0.07032491f, 0.07092772f, 0.09199169f, 0.00362414f, 0.04724600f, -0.02462938f, 0.06114948f, 0.18892443f, 
    0.07938669f, -0.06980814f, -0.16402814f, 0.02198810f, 0.01391640f, 0.05847143f, -0.03273053f, -0.00321456f, 
    -0.01474998f, -0.12048499f, 0.06481799f, 0.03529114f, 0.03512611f, 0.00482945f, -0.11288463f, -0.01921762f, 
    0.02221833f, -0.00781008f, 0.05256465f, -0.03607386f, -0.10728772f, 0.06686343f, -0.14715219f, -0.01567561f, 
    0.01429292f, -0.02141981f, 0.02183692f, 0.01476660f, -0.05502594f, -0.05562538f, 0.02160687f, -0.05343432f, 
    -0.03176646f, -0.03088435f, 0.04210505f, -0.01321859f, -0.03103332f, 0.03652641f, -0.02211948f, 0.02631785f, 
    -0.04601002f, 0.00746206f, 0.01073489f, -0.01146668f, -0.03421500f, -0.00825255f, -0.03102126f, -0.00824621f, 
    -0.06087138f, -0.04766147f, -0.02971783f, 0.00065402f, 0.01275137f, 0.00070030f, -0.01487129f, -0.03152869f, 
    0.01184710f, -0.05231305f, -0.00939067f, 0.04303090f, -0.00997025f, -0.03990891f, -0.03787344f, 0.02612074f, 
    0.01978458f, 0.04610913f, 0.01206504f, -0.04732493f, 0.00517314f, -0.00711894f, 0.00131483f, -0.03479389f, 
    -0.00703308f, -0.03635865f, -0.04510842f, -0.02467259f, 0.03757627f, 0.01803776f, -0.04599063f, -0.03878671f, 
    0.02247980f, -0.01427609f, -0.00490186f, -0.02860345f, 0.04626690f, 0.01848463f, 0.01646540f, 0.02590672f, 
    0.01507545f, -0.03433174f, 0.01479293f, 0.03901172f, -0.04915754f, 0.01048689f, -0.03758206f, -0.00095727f, 
    -0.00832341f, 0.01064098f, -0.05727885f, -0.02358056f, -0.01602626f, 0.03466712f, 0.01821561f, -0.04976201f, 
    -0.02963230f, 0.00195079f, -0.00103929f, 0.01074406f, 0.01521998f, -0.05180066f, 0.02142828f, -0.00926344f, 
    0.00561745f, -0.03458191f, 0.03064992f, 0.01065354f, -0.04808380f, 0.02858289f, 0.02583009f, -0.01050682f, 
    -0.01315070f, -0.03822215f, 0.01003130f, -0.03167032f, 0.02524309f, 0.04154151f, 0.01646667f, 0.03306446f, 
    -0.04490535f, 0.00717982f, 0.03649882f, -0.04312317f, -0.00446444f, 0.01893911f, 0.03475042f, -0.00883336f, 
    -0.05521690f, -0.03057318f, -0.02159363f, 0.01139349f, -0.04303019f, -0.00786352f, -0.04262736f, 0.01245163f, 
    -0.02068911f, 0.04872376f, -0.03721241f, 0.02726208f, 0.01383162f, 0.02029679f, 0.01355153f, -0.01155427f, 
    0.01683988f, -0.02202835f, -0.03065288f, 0.00586639f, -0.03240537f, 0.02666122f, -0.01248720f, -0.00242884f, 
    -0.01668248f, 0.00442994f, -0.04651587f, -0.00937128f, 0.03564036f, -0.05940974f, 0.00786883f, -0.05784274f, 
    -0.03866524f, 0.01506524f, 0.02023887f, -0.00085332f, 0.04368465f, 0.00609855f, 0.04141648f, -0.04779189f, 
    0.03946757f, -0.05333168f, -0.05396537f, 0.00695651f, 0.03916819f, -0.01941717f, -0.01051677f, -0.02152738f, 
    0.01395101f, -0.06075386f, -0.05997644f, 0.03799222f, 0.01600368f, -0.05261756f, -0.02996624f, -0.01082532f, 
    -0.00621782f, 0.03602833f, -0.00051230f, -0.05439968f, -0.05374496f, -0.00673220f, 0.02469655f, 0.03306651f, 
    0.00130361f, 0.03038598f, 0.00193721f, -0.00932861f, 0.04475052f, 0.03320429f, 0.00925275f, 0.00633384f, 
    -0.00524647f, 0.01327879f, -0.00440493f, -0.02149845f, -0.04594697f, -0.02499485f, 0.04310952f, -0.02774424f, 
    -0.00034840f, 0.03549575f, -0.04774516f, 0.00473270f, 0.02447688f, -0.04394774f, 0.00827848f, 0.02208719f, 
    -0.04692384f, 0.00668093f, 0.01402439f, -0.00523980f, 0.03176093f, -0.01439417f, -0.05496873f, -0.04190304f, 
    -0.02647782f, -0.04943856f, 0.00293559f, -0.04177069f, 0.00555947f, 0.01617347f, 0.03070665f, 0.03404249f, 
    0.03385138f, 0.02146477f, 0.02306834f, -0.01022077f, 0.03382451f, -0.04969829f, 0.03842358f, 0.03759295f, 
    0.00261561f, 0.03312367f, 0.01074817f, 0.02150005f, -0.00501047f, 0.03784472f, -0.03939451f, 0.00683497f, 
    0.01322303f, 0.02842896f, 0.00248285f, -0.01333046f, -0.01305874f, -0.06032896f, -0.01528572f, -0.03802187f, 
    -0.03680282f, 0.03043279f, -0.04881151f, -0.00246290f, 0.02142131f, -0.01369920f, -0.01393707f, 0.00487020f, 
    -0.02528403f, 0.00676948f, 0.01708126f, -0.02721111f, 0.03908928f, -0.02488221f, 0.02515000f, -0.03900393f, 
    0.03645056f, -0.01029827f, 0.01208310f, 0.01024545f, 0.03513134f, -0.02246759f, -0.03555815f, 0.00032442f, 
    0.01559097f, 0.00233982f, 0.00588729f, 0.00266305f, -0.00557104f, -0.04146932f, 0.02154094f, -0.04710986f, 
    -0.02969890f, 0.00572327f, 0.02262142f, 0.01284781f, -0.05693390f, 0.00771133f, 0.00093868f, 0.03890771f, 
    -0.03866726f, 0.02580537f, -0.02079812f, -0.03264762f, -0.01941480f, -0.05271926f, 0.01287504f, 0.02209706f, 
    -0.02027193f, -0.00770162f, -0.04023588f, -0.01091239f, -0.02240543f, -0.01566533f, -0.04278241f, 0.01175107f, 
    -0.05691766f, -0.04849302f, 0.02029704f, -0.02721995f, -0.01469478f, 0.00274713f, -0.04495601f, -0.05079896f, 
    -0.03628943f, -0.04523447f, -0.05844427f, 0.02015781f, -0.00226374f, -0.01401636f, 0.00287566f, -0.02487317f, 
    -0.05117483f, 0.00816525f, -0.00158113f, -0.04028698f, -0.04707494f, 0.03096513f, 0.01653288f, -0.03266189f, 
    -0.01301455f, -0.03620702f, -0.04591821f, -0.00593561f, 0.04053494f, -0.01570723f, -0.03027733f, -0.02810884f, 
    0.03561702f, -0.02591966f, -0.01064899f, -0.00212583f, 0.03636459f, 0.01369360f, -0.02447579f, 0.00721457f, 
    -0.00611071f, -0.01915780f, -0.00451197f, -0.06127896f, 0.03275131f, -0.02714264f, -0.06012597f, 0.01459503f, 
    0.01271793f, 0.01620058f, -0.03278647f, 0.00819506f, -0.00887701f, -0.01632691f, 0.01473887f, -0.03939232f, 
    -0.04383872f, -0.05834362f, -0.05351565f, -0.04885271f, -0.02712490f, 0.04184609f, 0.02497640f, -0.03146179f, 
    0.04550477f, -0.04337472f, -0.01313258f, -0.03829259f, -0.03472877f, -0.00285809f, -0.04302433f, 0.01141279f, 
    -0.00241695f, 0.01736453f, -0.00602557f, -0.03831024f, -0.01580668f, -0.05103125f, 0.04055309f, -0.04701897f, 
    -0.03893013f, 0.00700620f, -0.05280084f, -0.00414115f, -0.02897027f, -0.00147519f, 0.01963887f, -0.00494537f, 
    -0.03417921f, 0.04028962f, -0.01201199f, 0.01544947f, 0.04385683f, -0.05335845f, -0.03484154f, -0.02166260f, 
    0.00184259f, 0.03647006f, 0.03370818f, -0.02857995f, -0.02763705f, -0.00652263f, -0.04053377f, 0.03082357f, 
    -0.01881495f, 0.03777497f, -0.02640770f, 0.01676144f, 0.03166519f, -0.01678198f, 0.01099355f, -0.05506740f, 
    0.00431712f, -0.02174583f, 0.02166414f, -0.03905062f, -0.04596310f, 0.03275804f, -0.02828599f, -0.02288934f, 
    0.01064273f, 0.00150739f, 0.01249304f, -0.02527539f, -0.04286598f, -0.00232462f, -0.04143707f, 0.02142243f, 
    -0.00626545f, -0.03853093f, -0.04411958f, -0.03818709f, -0.00778672f, -0.00772723f, 0.01690717f, -0.01025773f, 
    -0.01814939f, -0.01555476f, 0.00458621f, -0.05084178f, 0.01158967f, -0.05100105f, 0.00467014f, -0.03640430f, 
    -0.00855391f, 0.01866006f, 0.02151609f, 0.03887272f, 0.02733258f, -0.02579023f, 0.02850421f, -0.01744513f, 
    -0.03345516f, -0.00383870f, 0.01307921f, 0.00113881f, -0.04539539f, 0.01093830f, 0.02065352f, 0.03901023f, 
    -0.04411048f, -0.04345483f, -0.04395043f, -0.01115125f, -0.05515422f, 0.02388845f, -0.02197421f, -0.00302861f, 
    -0.02989749f, 0.01146875f, -0.02025487f, -0.01962749f, 0.03708312f, -0.02437483f, -0.02211099f, -0.00609800f, 
    -0.02898844f, 0.02233407f, -0.04402753f, 0.04514442f, -0.02783916f, -0.06235930f, -0.02761240f, 0.01368760f, 
    -0.03036016f, -0.00658738f, 0.01000437f, -0.02326708f, -0.00819907f, -0.00486064f, -0.04253667f, 0.01761768f, 
    -0.04424264f, -0.02544943f, 0.02260034f, -0.03869604f, -0.04771403f, 0.02441128f, 0.02170515f, 0.03013817f, 
    -0.04850927f, 0.03523180f, -0.02845159f, -0.03342852f, 0.03818791f, 0.02360095f, 0.01697219f, -0.02105720f, 
    0.04903533f, 0.03929054f, -0.03841871f, -0.03961460f, 0.03367279f, 0.00603334f, -0.02466858f, -0.03049285f, 
    0.03419961f, 0.00422167f, 0.01667069f, -0.05648145f, -0.05411301f, 0.00762247f, 0.02426144f, -0.00694364f, 
    0.01589474f, -0.04388637f, -0.03699289f, -0.01873473f, -0.04211628f, -0.01069110f, -0.06790584f, -0.00207371f, 
    -0.00425337f, 0.01839470f, 0.00088669f, -0.01913776f, 0.02185591f, -0.02775528f, -0.04325312f, 0.03055570f, 
    -0.04981407f, -0.04103612f, -0.05443105f, 0.01882021f, 0.04189416f, 0.01844983f, -0.01983635f, -0.04339519f, 
    -0.00486976f, 0.01154746f, 0.02607808f, -0.03141094f, 0.00907592f, -0.00069253f, -0.02717490f, 0.04433735f, 
    0.03995812f, -0.00898684f, 0.04348497f, 0.01554004f, 0.01184454f, 0.02732760f, 0.04032532f, 0.02620556f, 
    0.02983845f, -0.02731381f, 0.03208347f, 0.03741910f, 0.01022910f, 0.04269554f, -0.02478371f, 0.00368569f, 
    0.01690268f, 0.01148775f, -0.03222814f, 0.01573597f, -0.00731301f, -0.03383294f, -0.02953293f, -0.03222188f, 
    0.03228514f, 0.03306795f, -0.00756815f, 0.01709471f, 0.04041486f, 0.02287609f, -0.02935469f, 0.03067025f, 
    0.02166132f, 0.00245979f, 0.00590439f, -0.06713894f, 0.00588921f, 0.02185624f, 0.00613399f, 0.03315647f, 
    0.03124786f, -0.00773342f, 0.00904848f, -0.01648013f, -0.02794233f, -0.00060560f, 0.03452449f, 0.02523742f, 
    0.05487048f, 0.04836225f, -0.01226556f, 0.04733166f, 0.00215823f, -0.03893138f, -0.02802182f, 0.03290086f, 
    -0.02337975f, -0.02795209f, -0.04754473f, -0.01749939f, 0.04490789f, 0.02441721f, -0.04836605f, -0.01190609f, 
    -0.03122537f, -0.00586218f, 0.00128649f, -0.06231944f, 0.01402388f, -0.04467863f, 0.03434591f, 0.02072855f, 
    0.02144420f, 0.03271607f, 0.04903234f, 0.03734896f, -0.03061774f, -0.02785613f, 0.03624991f, 0.02795069f, 
    -0.05157281f, 0.01540132f, -0.04277402f, 0.01101809f, -0.03958189f, 0.00793928f, 0.03218769f, 0.04745299f, 
    -0.01063504f, 0.04076851f, 0.04089307f, 0.03896553f, 0.02544057f, -0.05400147f, -0.05865460f, -0.00231963f, 
    0.01075204f, 0.00973266f, -0.04380985f, -0.01121615f, 0.05172870f, 0.01580359f, 0.04881505f, -0.03521316f, 
    -0.02346382f, 0.03002025f, 0.00979895f, 0.00806568f, -0.02054645f, 0.01561240f, 0.02471067f, 0.00135165f, 
    0.01929211f, 0.00677191f, -0.05016648f, -0.01828823f, -0.04616181f, -0.04659694f, 0.02503709f, -0.01545303f, 
    0.03681126f, -0.04057473f, 0.00982222f, 0.03870779f, -0.00783052f, -0.04741329f, 0.03749359f, -0.00026327f, 
    0.00144658f, 0.02790654f, -0.04438937f, -0.02337177f, -0.03880161f, -0.05586541f, 0.01105787f, -0.05389363f, 
    0.00045019f, -0.05075450f, -0.04791547f, -0.00311869f, -0.01739020f, -0.05397826f, -0.04007363f, -0.04919624f, 
    -0.04291103f, 0.01573368f, 0.04306974f, -0.02157685f, -0.01719766f, -0.01406255f, -0.02191485f, -0.04898278f, 
    -0.01365865f, -0.03499621f, -0.01651090f, -0.03344001f, 0.02467965f, -0.04247709f, -0.03356967f, 0.03826526f, 
    -0.05640161f, 0.03258159f, 0.03246093f, 0.00386582f, 0.01873944f, 0.00947973f, -0.00352091f, -0.02765133f, 
    -0.05361825f, 0.01309946f, -0.05260654f, 0.02038525f, -0.04256750f, 0.01683420f, 0.03614632f, -0.04155437f, 
    -0.02236891f, -0.00073332f, -0.05063767f, -0.05042516f, -0.00052114f, 0.04642138f, 0.00820192f, 0.00225823f, 
    -0.02017933f, 0.04391930f, 0.00138227f, 0.03913634f, 0.00621144f, -0.00961394f, -0.01749934f, -0.05355927f, 
    -0.03376685f, -0.03945696f, 0.01984319f, 0.02566171f, -0.02874676f, 0.00667578f, 0.01489100f, -0.00954943f, 
    0.02108176f, -0.02124643f, -0.00369642f, 0.00486628f, -0.02846237f, -0.00655990f, -0.05567991f, -0.03799677f, 
    -0.01386975f, -0.01554627f, 0.00539376f, -0.04919956f, 0.03450283f, -0.03772333f, 0.02498307f, 0.05038355f, 
    0.13688679f, -0.14042272f, -0.04807172f, -0.04018108f, 0.01230097f, -0.17859329f, -0.03393488f, -0.07814094f, 
    -0.04343121f, 0.04438335f, 0.01962062f, -0.01456864f, -0.27473485f, 0.47906250f, -0.09062210f, -0.07379883f, 
    0.10864059f, 0.06892126f, -0.13837907f, 0.08359268f, -0.08059788f, -0.07607494f, 0.01982708f, 0.13030863f, 
    -0.43008092f, 0.15682276f, -0.31502903f, 0.37304622f, 0.09593169f, -0.08090235f, 0.17119753f, -0.07202317f, 
    -0.10891946f, -0.00289667f, -0.07293678f, 0.13904804f, -0.40452388f, -0.12631410f, -0.00394610f, 0.35832074f, 
    0.01706532f, 0.10514700f, 0.04668583f, 0.04039560f, -0.01020924f, -0.00570501f, 0.17513281f, -0.00752805f, 
    0.46119660f, 0.03164965f, 0.04748285f, 0.04868815f, -0.01092562f, -0.02899966f, 0.03878500f, -0.01349699f, 
    -0.04885909f, -0.02270416f, -0.00705517f, -0.01833744f, -0.09126560f, 0.19864948f, -0.29091898f, 0.00473297f, 
    -0.07424567f, -0.18424623f, 0.12973727f, -0.13365157f, -0.16580628f, 0.04566319f, 0.13848300f, 0.00585466f, 
    -0.17548332f, -0.01866518f, -0.13436030f, 0.44425830f, -0.15633018f, -0.02835931f, 0.08318403f, -0.03362060f, 
    0.07401914f, -0.01404902f, -0.06966050f, 0.09012976f, -0.15402688f, 0.07560477f, 0.14338766f, 0.08571513f, 
    -0.05343482f, 0.08572815f, 0.02313367f, 0.00692278f, 0.07531048f, 0.17156677f, 0.06192101f, 0.30258453f, 
    -0.20333287f, 0.11762875f, 0.01200277f, 0.27556443f, 0.09444579f, 0.06105278f, 0.10771936f, 0.04542166f, 
    -0.02440958f, 0.03096084f, -0.01778785f, 0.11702051f, 0.23268224f, -0.21553762f, 0.10397802f, -0.09307880f, 
    0.06942434f, 0.00858865f, -0.03169005f, 0.09526791f, 0.06611240f, 0.01555424f, 0.11120639f, 0.02925450f, 
    -0.23653458f, 0.14735249f, 0.12351359f, 0.20566587f, -0.04283643f, -0.05794641f, -0.02366885f, -0.09075188f, 
    -0.12838314f, -0.06140743f, 0.03239070f, 0.07756651f, -0.14153436f, -0.07612229f, -0.04791296f, 0.09976038f, 
    0.07895982f, -0.03205111f, -0.01201285f, -0.06659544f, 0.10706986f, -0.03133956f, 0.14172059f, 0.05255849f, 
    -0.15181042f, 0.07583159f, 0.07824036f, 0.02891190f, 0.08399235f, 0.07200656f, -0.03057174f, 0.05329547f, 
    0.11772472f, -0.02284335f, -0.03519632f, -0.06255928f, -0.05200406f, 0.02896539f, -0.00619023f, 0.12399621f, 
    0.06956767f, 0.00674351f, 0.08952154f, 0.02755548f, 0.06791345f, -0.09890546f, -0.09581184f, 0.02112817f, 
    0.01611175f, 0.05227067f, -0.15945251f, -0.17824815f, 0.26496473f, -0.07670651f, 0.05282668f, -0.14445402f, 
    0.11242580f, 0.01461317f, -0.00303613f, 0.10513933f, 0.07383133f, 0.23436084f, 0.08523861f, -0.03164681f, 
    0.08944087f, 0.12090076f, 0.01439478f, 0.02488640f, -0.08387946f, 0.00127703f, 0.02860095f, -0.03516140f, 
    0.23961911f, -0.04965762f, -0.02490655f, 0.16124405f, 0.19493170f, -0.02039142f, 0.03813843f, -0.02416356f, 
    0.03613041f, 0.07834437f, 0.14059532f, 0.06189585f, 0.14875802f, -0.17695996f, 0.02711954f, -0.21522649f, 
    -0.04782395f, -0.07288644f, -0.08752627f, -0.05067088f, 0.04275491f, 0.08894783f, 0.05876567f, 0.05643827f, 
    -0.20771156f, 0.03406432f, 0.38556835f, 0.17448351f, 0.04372891f, 0.00591575f, -0.02136097f, 0.02101216f, 
    0.02519517f, -0.06789976f, -0.06937076f, -0.09755366f, -0.01863272f, -0.00738200f, 0.03507334f, 0.04245740f, 
    -0.06336114f, -0.01894170f, -0.00751933f, -0.03457429f, 0.03660033f, 0.15311421f, 0.02214627f, 0.00661710f, 
    0.18281831f, 0.04479487f, 0.04960071f, 0.00131095f, 0.08084130f, -0.02805601f, 0.01846338f, 0.18268280f, 
    0.06325010f, -0.06075357f, 0.01547178f, -0.04453081f, -0.03964119f, -0.04635504f, -0.03098353f, -0.14048652f, 
    -0.00932546f, 0.14571428f, 0.09074995f, -0.03485879f, -0.01394442f, 0.06885285f, 0.01375997f, -0.02400332f, 
    0.17159271f, 0.12399414f, -0.05833814f, 0.19597110f, 0.01160488f, 0.03308868f, 0.05355081f, 0.05301464f, 
    0.07163962f, 0.16051385f, 0.09991037f, 0.19912194f, -0.00911592f, 0.04612558f, 0.00385968f, 0.03348991f, 
    0.10041388f, -0.09680676f, 0.07730142f, -0.09903602f, 0.02522771f, -0.00804732f, -0.01941145f, -0.00875509f, 
    -0.16311103f, 0.07785243f, -0.08420475f, -0.06580310f, -0.00711831f, 0.04864879f, 0.06388779f, -0.05545262f, 
    0.10505854f, 0.08657309f, -0.00899788f, 0.04307677f, -0.04557073f, -0.06102001f, -0.16301793f, 0.00419662f, 
    -0.07799420f, 0.00711082f, 0.05383096f, -0.06399278f, 0.04572072f, 0.14243442f, 0.09260457f, 0.09963752f, 
    0.08607420f, 0.09271496f, 0.23610605f, 0.05257682f, -0.05809503f, 0.01128989f, 0.11230272f, 0.09428178f, 
    0.02158338f, 0.12426508f, -0.05929594f, -0.18395609f, 0.05575350f, 0.08630919f, -0.28185371f, 0.18739712f, 
    -0.01993076f, 0.07473262f, 0.02401763f, 0.03986374f, -0.00174771f, -0.08108083f, -0.18486662f, 0.04958579f, 
    0.05355704f, -0.15239929f, 0.05053218f, 0.17839858f, 0.11682420f, -0.01333088f, -0.06965393f, 0.12945350f, 
    -0.04114649f, 0.05263766f, 0.08702977f, 0.04998570f, 0.40189445f, 0.10441886f, -0.16614975f, 0.07593814f, 
    0.14893977f, 0.06564096f, 0.14368191f, -0.06064870f, -0.03608027f, 0.01102881f, 0.18299334f, 0.13959344f, 
    -0.12730731f, -0.01565565f, -0.17761365f, -0.09749074f, 0.02898025f, 0.07301083f, 0.03541949f, 0.01981650f, 
    0.04201565f, 0.15553038f, 0.04085521f, -0.00881074f, -0.16864665f, 0.03551971f, 0.03909718f, -0.08107702f, 
    0.08598742f, -0.01043600f, -0.03631651f, -0.06656998f, -0.14660558f, 0.15264937f, 0.00876255f, -0.09820562f, 
    -0.28610274f, -0.26789993f, -0.07223666f, -0.19880491f, 0.12458946f, -0.17747091f, -0.05023465f, -0.02518363f, 
    -0.03676090f, -0.01431945f, 0.04981697f, -0.02102404f, -0.18414448f, 0.40135309f, -0.02032338f, 0.08487099f, 
    0.10166558f, 0.05395081f, -0.20131379f, 0.08068831f, 0.06668875f, 0.04651123f, 0.08813219f, -0.03830265f, 
    -0.21462801f, 0.27559635f, -0.07228941f, 0.11600155f, -0.00492543f, -0.01611104f, 0.10164052f, 0.18253273f, 
    -0.01839638f, -0.00824205f, 0.13669807f, 0.04251157f, -0.24461183f, -0.11608671f, 0.00352024f, 0.07871906f, 
    0.13554597f, 0.07771710f, 0.09680351f, 0.09598200f, -0.01940072f, 0.04232391f, 0.33044571f, 0.07612550f, 
    0.05911088f, -0.29891205f, 0.09281864f, 0.04473513f, -0.05152509f, 0.12564288f, 0.11000928f, -0.05583811f, 
    0.07983700f, 0.04642485f, -0.01448635f, -0.07683864f, -0.05823224f, -0.11143897f, -0.00244382f, -0.03216768f, 
    0.08541486f, -0.15648234f, 0.09521487f, -0.01673510f, -0.12869948f, -0.03408562f, 0.21386577f, -0.01075715f, 
    -0.14584073f, 0.07675050f, -0.00335058f, 0.39210215f, -0.01207040f, 0.23063222f, 0.12107295f, -0.03768285f, 
    -0.03472019f, 0.01368059f, -0.03190305f, -0.01993987f, -0.00207396f, 0.07630746f, 0.02075749f, -0.02689642f, 
    -0.04682805f, -0.00375717f, 0.08841854f, -0.04563161f, 0.22561984f, -0.04833154f, -0.05356501f, -0.02215900f, 
    -0.44015789f, 0.14308546f, -0.00254683f, 0.01779182f, -0.02974816f, 0.01174020f, 0.04630714f, 0.15712787f, 
    0.09747847f, 0.13630612f, 0.01258174f, 0.00510195f, 0.19181208f, 0.12741819f, 0.07108465f, 0.17161109f, 
    0.10907301f, 0.15672748f, 0.04316733f, 0.03310027f, -0.01761834f, 0.13204998f, -0.03253211f, 0.19282165f, 
    -0.07279529f, -0.14066930f, 0.10393078f, 0.18026595f, 0.16566627f, 0.17313769f, -0.02594835f, 0.04499907f, 
    0.02723545f, -0.01326812f, -0.02303737f, -0.05356025f, -0.08845107f, 0.00507163f, 0.07267874f, -0.07677081f, 
    0.01661777f, -0.03790535f, -0.00628246f, -0.01431994f, 0.13677935f, 0.11363429f, -0.09380451f, 0.21919702f, 
    -0.12944323f, 0.02787638f, 0.16420783f, -0.09219740f, -0.11387359f, -0.02292392f, -0.15532692f, 0.22086555f, 
    0.04188331f, 0.13030013f, 0.10877956f, 0.02366545f, 0.00993197f, 0.06239967f, -0.14139146f, -0.06147110f, 
    0.11604755f, -0.07436349f, -0.25125957f, 0.01537432f, 0.05576847f, 0.04033083f, -0.02562110f, 0.06339356f, 
    0.27661580f, -0.50785303f, 0.13600715f, 0.11045650f, 0.09787048f, 0.01204040f, 0.10061110f, 0.03310391f, 
    0.14011791f, 0.20426278f, 0.16999207f, -0.00879281f, -0.14612976f, 0.04274039f, 0.08103568f, -0.09701835f, 
    0.04350139f, 0.13005416f, -0.01702705f, -0.04421763f, -0.03083885f, -0.03398122f, 0.10596772f, -0.02401390f, 
    -0.01821962f, -0.21045980f, -0.06786003f, 0.07097120f, 0.04724257f, -0.08360606f, 0.03156207f, 0.04168188f, 
    -0.08596899f, 0.15345889f, 0.26118070f, 0.24106334f, -0.07448830f, 0.03410229f, 0.16352077f, -0.17953452f, 
    -0.02680590f, -0.14636908f, 0.18203706f, -0.08327356f, 0.09419050f, 0.14788356f, 0.19487223f, -0.08461395f, 
    -0.34946266f, 0.26064453f, 0.36980265f, 0.05076100f, 0.10838461f, 0.15930976f, 0.01866471f, 0.23462164f, 
    0.06494078f, -0.14502981f, -0.03739418f, -0.07071418f, -0.14948279f, -0.11147239f, 0.17469512f, 0.03999857f, 
    0.02648400f, 0.09635428f, 0.02972409f, -0.07457443f, -0.02871597f, 0.10284708f, 0.02191333f, -0.07783434f, 
    0.05391639f, 0.04277912f, -0.04124494f, -0.00437324f, 0.13052081f, 0.02737488f, -0.01660011f, 0.17173068f, 
    0.15072742f, -0.04447198f, 0.02742451f, 0.05813609f, 0.00497160f, 0.05616352f, -0.02184367f, -0.08886341f, 
    0.04813978f, 0.12805134f, 0.03830906f, 0.02738240f, 0.01356850f, -0.06029996f, 0.11239307f, -0.08518723f, 
    0.30008903f, -0.04362104f, -0.10143068f, 0.10529231f, -0.05568518f, -0.02157128f, 0.12411645f, -0.00165981f, 
    0.11757219f, -0.08203838f, 0.01240757f, -0.13693932f, 0.01518251f, 0.07458201f, -0.02677097f, 0.01715302f, 
    0.00560401f, -0.10076357f, 0.12927304f, -0.01114663f, 0.04385860f, 0.01282496f, -0.01166615f, 0.13972528f, 
    0.02719459f, -0.00931599f, -0.01764357f, -0.00722990f, 0.02210086f, -0.02322581f, 0.01128646f, -0.09071992f, 
    0.12215786f, 0.10837795f, 0.14000234f, 0.00892382f, -0.15987387f, -0.15117319f, 0.10225965f, -0.14212985f, 
    -0.03139517f, -0.00767334f, 0.08365099f, 0.11257172f, -0.04371074f, -0.00103263f, 0.17214653f, 0.03520507f, 
    0.10529979f, 0.14511836f, 0.01863761f, -0.03931263f, 0.01180478f, 0.11307272f, 0.16509974f, 0.09283281f, 
    0.00497555f, 0.03941808f, 0.06278995f, -0.07346591f, -0.13531652f, -0.03878100f, -0.01976593f, 0.09819762f, 
    -0.12454718f, 0.05065050f, -0.16948074f, -0.16730282f, 0.03464430f, 0.02507824f, 0.08405489f, 0.01772887f, 
    -0.00319147f, -0.17015651f, -0.01305799f, -0.01505789f, -0.02922424f, -0.10280341f, -0.11280088f, 0.27439022f, 
    0.11778606f, 0.04981966f, 0.04992940f, 0.01946430f, 0.13603628f, -0.09139267f, -0.11138105f, -0.21360829f, 
    0.07126792f, -0.14769179f, 0.15482277f, -0.16651163f, 0.21176510f, -0.03357733f, -0.10516080f, 0.05971131f, 
    0.07558903f, 0.06756579f, -0.06912946f, -0.09334220f, 0.01704898f, -0.02354453f, -0.02188331f, -0.03393417f, 
    -0.11731172f, 0.05454424f, 0.05288982f, -0.04127741f, -0.07128697f, -0.00371380f, 0.04134148f, 0.01374657f, 
    -0.02518917f, -0.04253092f, -0.03261490f, -0.00224457f, 0.01948577f, 0.03417340f, 0.09151217f, 0.04602494f, 
    0.03878294f, -0.03464422f, -0.03939503f, -0.02000153f, -0.00174443f, 0.03533450f, 0.05096246f, 0.04415394f, 
    0.01621790f, 0.00321756f, 0.00487579f, -0.05354445f, 0.05701158f, 0.03048994f, 0.00312188f, -0.05849477f, 
    -0.02460114f, -0.04695258f, 0.01981732f, -0.05700954f, -0.05075615f, 0.03880895f, 0.00309771f, 0.03173195f, 
    0.00012861f, 0.00902748f, -0.02568555f, -0.05153989f, 0.05105748f, 0.00490470f, -0.00344453f, -0.04820775f, 
    -0.02253482f, 0.01918419f, 0.01547327f, -0.04960659f, 0.02833072f, -0.01599044f, -0.00305798f, -0.02969615f, 
    0.02778788f, 0.04357392f, 0.03440268f, 0.04279435f, 0.00645926f, -0.01507414f, -0.01878413f, -0.04849016f, 
    0.00947365f, 0.02910505f, 0.03978492f, -0.05308196f, -0.03170972f, -0.03134599f, -0.00102086f, 0.04465087f, 
    -0.04336230f, 0.03769397f, 0.01205721f, -0.01166572f, 0.01906488f, 0.00165770f, -0.04102464f, -0.06102869f, 
    0.02695111f, 0.00851869f, 0.00124901f, -0.03108381f, 0.02810346f, -0.02345948f, -0.01762333f, -0.00608050f, 
    0.04842119f, 0.02282620f, 0.00281482f, -0.01734857f, 0.03636990f, 0.04313767f, -0.03034997f, -0.03355106f, 
    -0.04493889f, -0.02799099f, -0.00628690f, 0.01925533f, -0.04038161f, 0.02883694f, -0.05197294f, 0.01203003f, 
    -0.05345147f, -0.04083993f, -0.04715000f, 0.03036429f, -0.04768057f, -0.02071915f, -0.03961638f, 0.01345099f, 
    -0.00539486f, 0.03115341f, 0.00306630f, 0.00168709f, -0.03803372f, -0.05661281f, -0.05512854f, -0.00607433f, 
    -0.01440930f, -0.02151880f, -0.04193209f, 0.04700468f, 0.02132105f, -0.03802826f, -0.01883725f, -0.01283560f, 
    -0.02227343f, -0.02614172f, -0.03835152f, -0.02237448f, -0.02584071f, -0.00826477f, 0.01379854f, 0.03543966f, 
    -0.02922503f, -0.04245784f, 0.01660730f, 0.02333303f, -0.04049325f, -0.04519504f, -0.05548736f, 0.03060287f, 
    0.01137894f, -0.02544849f, -0.05976539f, -0.03393608f, -0.05346114f, -0.02033455f, -0.05128822f, 0.03502786f, 
    0.02122373f, 0.03365735f, -0.02132578f, 0.01451329f, 0.02148477f, 0.04955462f, 0.02920728f, 0.04937412f, 
    -0.03235359f, -0.01099788f, -0.03829958f, 0.03612182f, 0.02042704f, 0.00983195f, 0.03459750f, -0.06185630f, 
    0.01722317f, 0.02775369f, -0.00838199f, -0.04243557f, -0.04428688f, 0.03766478f, 0.03864815f, -0.04927497f, 
    0.00894283f, -0.04580056f, -0.00584646f, -0.00403011f, -0.02804252f, -0.02055450f, -0.05030371f, -0.05253869f, 
    0.03355347f, 0.02602397f, -0.05488535f, -0.03159331f, -0.00877896f, 0.01862873f, 0.02103058f, -0.02370514f, 
    -0.01171952f, 0.04925846f, 0.03030399f, 0.00784341f, -0.01213573f, 0.00458348f, -0.00797423f, 0.01680767f, 
    -0.00020312f, -0.05942553f, -0.05331545f, -0.00567902f, -0.03325950f, -0.01681419f, 0.02833481f, -0.00483059f, 
    0.03974402f, 0.03292367f, -0.00820432f, 0.05326242f, 0.03694456f, -0.05561723f, -0.02223423f, 0.02768331f, 
    0.02540169f, -0.02966248f, 0.04094217f, 0.03797324f, 0.00372813f, 0.01445033f, 0.04761263f, 0.00224951f, 
    0.01525192f, -0.00819188f, -0.00116465f, -0.00775255f, -0.01672968f, -0.04032084f, -0.00648539f, 0.01383914f, 
    -0.00604226f, 0.04382997f, -0.03170289f, -0.05724012f, -0.04595638f, 0.03462805f, 0.03689566f, -0.01903326f, 
    0.01401938f, 0.03403159f, 0.02819488f, -0.05360944f, -0.03431449f, -0.04412131f, 0.04299394f, 0.02748010f, 
    0.05039412f, 0.01137573f, 0.00399624f, 0.00625881f, 0.02292834f, 0.01366762f, -0.05389017f, -0.02078397f, 
    0.03078684f, 0.01589870f, 0.00621746f, -0.00932618f, -0.05428531f, -0.03049917f, -0.02309359f, 0.02014206f, 
    -0.03660385f, 0.04446420f, -0.01270458f, 0.03292602f, -0.01319156f, 0.04253585f, 0.01883492f, -0.02674368f, 
    -0.04597796f, 0.01277486f, -0.06220350f, 0.01467189f, 0.01439521f, -0.03857335f, -0.01437182f, 0.04024148f, 
    0.02563620f, -0.04397009f, 0.01063309f, -0.03446090f, 0.01377229f, -0.06218609f, -0.00505774f, -0.03411063f, 
    -0.04191991f, 0.00886699f, -0.01445861f, 0.01442161f, -0.01675490f, 0.00049859f, -0.01336921f, -0.03937976f, 
    0.00432999f, -0.02242502f, -0.04363346f, -0.03073687f, 0.03934771f, -0.02467677f, 0.02924171f, -0.02708462f, 
    0.00920369f, 0.01767531f, 0.04139838f, -0.03487673f, -0.04170554f, -0.02980112f, 0.02872617f, 0.03453543f, 
    -0.02263302f, -0.03591789f, -0.04288762f, -0.04642130f, -0.03403180f, -0.02920416f, -0.04773026f, -0.00537015f, 
    -0.01003959f, -0.01572779f, -0.01188567f, -0.03558704f, -0.01229867f, 0.03528494f, -0.04748833f, 0.03530749f, 
    0.02372671f, -0.01523551f, -0.04536735f, -0.03817049f, -0.06238329f, -0.02696955f, -0.00003665f, 0.03099493f, 
    -0.03392107f, -0.03073532f, -0.04697252f, -0.06144670f, -0.04666071f, 0.00564653f, -0.01293853f, -0.02334316f, 
    0.02621821f, -0.01566095f, -0.02225026f, 0.00243924f, 0.02236797f, -0.02334079f, 0.02937215f, -0.02451424f, 
    0.03167136f, -0.04580044f, -0.01626717f, -0.00551944f, -0.04734550f, 0.02837503f, 0.03586431f, -0.00701470f, 
    -0.04847740f, 0.02951744f, 0.02633275f, -0.04713295f, 0.00258372f, -0.02740028f, 0.03182555f, 0.00952655f, 
    -0.03842456f, 0.04056511f, -0.01783103f, -0.02702396f, -0.01293040f, -0.05719934f, 0.01183466f, -0.01019764f, 
    -0.04624097f, 0.04304186f, -0.00445672f, 0.03925150f, -0.05411799f, -0.00855644f, 0.00760212f, -0.00844386f, 
    -0.02338937f, 0.03634614f, -0.03250653f, 0.02103901f, -0.01574773f, -0.05195537f, 0.01390304f, 0.02570014f, 
    0.04144370f, 0.03043285f, 0.01128004f, 0.00402835f, 0.03112314f, 0.02407870f, 0.04240524f, -0.01386122f, 
    0.10903884f, 0.23775715f, 0.14581569f, 0.04158178f, -0.10400570f, -0.01664378f, 0.02987173f, 0.01534019f, 
    0.02075190f, -0.00866557f, 0.05763718f, -0.00247409f, 0.38874885f, -0.47239068f, 0.17050782f, 0.00145640f, 
    -0.15920711f, 0.05358106f, 0.14476961f, -0.20597269f, -0.03139034f, 0.17063218f, -0.10258318f, -0.03520167f, 
    0.13491794f, 0.12987600f, -0.06993675f, -0.03348671f, 0.01346230f, 0.05245837f, 0.03018269f, 0.03698569f, 
    -0.08912620f, -0.01396166f, 0.03399729f, -0.10261151f, 0.26260871f, 0.02344302f, -0.00303438f, -0.01127232f, 
    0.02089207f, -0.10750476f, 0.07980976f, -0.05309299f, -0.00208693f, -0.01595809f, -0.09811898f, -0.05476100f, 
    -0.17637183f, 0.19214286f, 0.02983383f, 0.02846445f, -0.11173372f, -0.01118285f, -0.09088803f, 0.09953897f, 
    0.02522231f, -0.04313231f, -0.07197403f, 0.06872469f, 0.04372379f, -0.00021951f, 0.06534725f, 0.21128401f, 
    -0.03344877f, 0.11992509f, -0.16782947f, 0.02143504f, 0.14116409f, -0.04975441f, -0.12794951f, 0.01899695f, 
    0.14970499f, 0.06394836f, 0.08384900f, -0.23642674f, 0.07560695f, 0.02816205f, 0.04077633f, 0.16348748f, 
    -0.07117695f, 0.00782647f, 0.00573097f, -0.11363793f, 0.02297157f, -0.03176534f, -0.12108378f, -0.00638434f, 
    0.01734590f, -0.07082392f, -0.09854215f, 0.04038855f, 0.14942403f, -0.00123080f, 0.00319791f, -0.04252604f, 
    0.12448846f, -0.01719060f, -0.27127719f, -0.17830548f, -0.02383036f, -0.00423303f, 0.01684653f, 0.23019043f, 
    -0.02175085f, -0.11004341f, -0.05302103f, -0.13170171f, 0.06995918f, -0.07626088f, 0.04130634f, -0.05327947f, 
    -0.08956838f, -0.01337405f, 0.08847791f, 0.02448574f, -0.01183037f, -0.06323781f, 0.01585401f, -0.04188259f, 
    0.36821762f, -0.28216362f, 0.24117352f, -0.13186835f, -0.06782220f, -0.07574728f, -0.00025245f, -0.03571655f, 
    0.05220014f, 0.05549606f, -0.02629213f, 0.05383146f, 0.12664400f, -0.01733589f, -0.15133582f, -0.10565039f, 
    -0.04519001f, -0.06272437f, 0.04143601f, 0.05872465f, -0.00860938f, 0.06763482f, -0.10868993f, 0.17464247f, 
    0.28505996f, -0.04816655f, -0.15271625f, -0.05562243f, -0.06033014f, 0.00379610f, 0.11391409f, 0.00131514f, 
    -0.07792187f, -0.01184977f, 0.01796805f, 0.03662521f, 0.03380837f, -0.04973721f, 0.11169484f, -0.03790844f, 
    0.06897868f, 0.00167790f, 0.04480374f, 0.07009535f, -0.10336851f, 0.02688391f, 0.00986855f, 0.03862557f, 
    0.10236184f, 0.12245174f, 0.06832738f, -0.02014377f, -0.13812222f, 0.09770191f, 0.04939042f, -0.06056510f, 
    0.00125602f, 0.02572602f, -0.01433387f, -0.08960272f, 0.44724500f, 0.32674888f, 0.06229950f, 0.15785424f, 
    -0.04576273f, -0.00490467f, -0.04695914f, 0.08372518f, 0.05062524f, 0.02527972f, 0.08301347f, -0.01521416f, 
    -0.19725767f, -0.09373209f, -0.05598069f, -0.04032785f, -0.09389997f, 0.08260619f, -0.00619304f, 0.12857647f, 
    -0.00835100f, -0.10978580f, -0.11259944f, -0.13440795f, -0.05733059f, 0.03858554f, 0.01365987f, 0.18382692f, 
    0.00649886f, 0.12389995f, 0.00856316f, -0.01574332f, -0.08035988f, -0.00809690f, 0.00705961f, 0.08345150f, 
    0.18683982f, 0.14856999f, -0.08000520f, 0.09357791f, -0.09783664f, -0.00077679f, 0.00646107f, -0.05478337f, 
    -0.09580512f, 0.05102050f, 0.00769390f, -0.06649295f, 0.17726247f, 0.12765040f, 0.07297082f, 0.00254532f, 
    0.10158952f, -0.01276326f, -0.02804545f, 0.05506118f, 0.02537498f, -0.01473590f, 0.03471033f, 0.09315022f, 
    0.01493617f, -0.01618158f, 0.06542354f, 0.02761663f, 0.01349734f, 0.05155358f, -0.05386070f, -0.08287334f, 
    -0.01484824f, 0.14879796f, -0.02103214f, -0.10809114f, 0.12334415f, 0.15615590f, 0.04503433f, 0.06961020f, 
    0.08365281f, -0.03103790f, 0.00857681f, 0.05157834f, 0.04281453f, 0.13303003f, -0.02782871f, 0.08719896f, 
    -0.03573262f, 0.07102166f, 0.06694473f, 0.04459257f, 0.07194979f, -0.00305821f, -0.03954833f, -0.01776171f, 
    -0.04806027f, -0.06067048f, -0.00798616f, 0.13582382f, 0.14198975f, 0.12079508f, 0.04509046f, -0.03808177f, 
    -0.07427476f, 0.07353442f, 0.15838398f, -0.04975487f, -0.10667446f, -0.01755557f, -0.05193053f, -0.02357658f, 
    0.15259311f, 0.09548651f, 0.11870657f, -0.03512296f, 0.02921975f, 0.09230965f, 0.10933235f, 0.04577487f, 
    0.02122223f, -0.04678802f, -0.10878389f, -0.16679120f, -0.00341747f, 0.06488758f, 0.12304188f, 0.08738828f, 
    -0.07359361f, 0.03933117f, -0.11113440f, 0.02056956f, -0.09792426f, -0.11247192f, -0.04302261f, -0.03069047f, 
    0.20355588f, 0.22853912f, 0.10648308f, 0.23825087f, -0.00514226f, -0.08389969f, -0.12933180f, -0.05706187f, 
    0.13048346f, -0.02973321f, 0.10853447f, 0.09148262f, 0.01829107f, 0.13730775f, 0.17123300f, 0.13033795f, 
    0.13341947f, -0.04878711f, 0.01008634f, 0.06889402f, 0.05643487f, 0.00926991f, 0.03238181f, -0.00495556f, 
    0.00792134f, 0.01750455f, -0.04670420f, -0.06075809f, -0.07355966f, 0.04071552f, 0.14214425f, -0.07556240f, 
    0.06016192f, -0.03080173f, 0.04298517f, -0.06330568f, -0.32856295f, 0.04990048f, -0.11857302f, -0.09638643f, 
    -0.11420025f, -0.12389469f, -0.12703046f, 0.08539291f, -0.01797443f, -0.00227965f, -0.17440635f, 0.08758788f, 
    0.13679111f, 0.06422539f, 0.11020802f, 0.06240179f, 0.03879434f, 0.07987348f, 0.05683322f, 0.04237115f, 
    0.00097827f, -0.02945104f, 0.12997292f, 0.13395366f, 0.30800277f, 0.22815487f, 0.18239401f, 0.09943888f, 
    0.05008534f, 0.06295183f, 0.12881361f, 0.06729588f, 0.01686424f, 0.01627346f, 0.01013711f, 0.00482920f, 
    -0.04353673f, 0.00925958f, 0.01256389f, 0.03013826f, 0.03866620f, -0.00825901f, -0.03927107f, -0.02683031f, 
    0.02229256f, 0.01173526f, 0.03415205f, -0.03529580f, -0.05821905f, 0.04026201f, 0.03497867f, -0.02494630f, 
    -0.02370214f, -0.02321426f, -0.02444804f, -0.01158025f, -0.03253926f, 0.00052285f, 0.03489892f, -0.03448395f, 
    -0.03851550f, 0.03863629f, -0.05268998f, -0.02772786f, -0.01752538f, -0.01731744f, -0.04769791f, 0.03153981f, 
    0.04039136f, 0.01955577f, 0.00237706f, -0.00729002f, 0.04325828f, -0.01652224f, -0.02047187f, -0.02985512f, 
    -0.04178811f, 0.00531299f, -0.00434989f, 0.01870044f, -0.04886873f, -0.01221120f, 0.02688876f, -0.03112204f, 
    0.04027051f, -0.04591533f, 0.03887613f, -0.02389592f, 0.03037320f, -0.05280876f, -0.03062289f, 0.01280726f, 
    0.00455985f, 0.00026861f, 0.02151812f, -0.00674183f, 0.03366489f, 0.04515213f, -0.00887263f, -0.05428114f, 
    -0.02563047f, -0.00527074f, -0.05646489f, 0.01400433f, 0.01896839f, -0.03764778f, 0.03979516f, 0.01805900f, 
    0.02725068f, 0.02044041f, -0.05425330f, -0.00900750f, -0.01520299f, -0.04884870f, -0.01106638f, 0.03880537f, 
    -0.00839463f, -0.03348065f, -0.05084636f, -0.02691053f, 0.04132777f, 0.01923479f, 0.05043877f, -0.00123756f, 
    -0.00588135f, 0.03241805f, 0.02416220f, -0.04564198f, 0.00669922f, -0.00762728f, 0.03539507f, -0.01995180f, 
    0.00333758f, 0.03907162f, -0.02826591f, 0.01605984f, 0.04329282f, 0.02667540f, 0.01744707f, 0.01645814f, 
    -0.04210335f, 0.00691217f, 0.04264328f, 0.00593440f, 0.03049054f, -0.04783427f, -0.02674326f, -0.01080413f, 
    0.02974608f, 0.00326944f, 0.00294233f, 0.03157115f, 0.01306817f, -0.00999731f, 0.03860518f, -0.00076693f, 
    -0.04980194f, 0.04142108f, -0.00573651f, -0.02442016f, -0.04782132f, -0.01793505f, 0.00390861f, -0.01605177f, 
    -0.02273209f, 0.00261485f, -0.03909989f, -0.04661267f, 0.02271301f, 0.02813416f, -0.03790692f, -0.05826079f, 
    0.00997246f, -0.02178049f, 0.00137015f, -0.05856828f, 0.05175811f, 0.05137149f, -0.01289871f, 0.05306048f, 
    0.02555402f, 0.00564985f, -0.04237293f, 0.01469763f, -0.01103975f, -0.03370466f, -0.05069938f, -0.01415378f, 
    0.03600334f, -0.04184496f, 0.00905350f, -0.03606786f, -0.05473409f, -0.01340580f, -0.04878937f, -0.04508610f, 
    -0.03349664f, -0.03084475f, 0.04475035f, -0.04935301f, -0.04054086f, -0.00209122f, 0.04739455f, -0.02577973f, 
    0.01632573f, 0.02820938f, -0.00258709f, -0.04761525f, 0.02574028f, 0.02126983f, 0.01256134f, 0.00947620f, 
    -0.04739673f, 0.01859011f, 0.00524636f, -0.01945142f, -0.00293701f, 0.02847000f, 0.01902100f, -0.00272607f, 
    -0.05364981f, 0.03890583f, -0.01734803f, 0.00337019f, -0.03946115f, 0.02201953f, -0.02093201f, -0.01149645f, 
    0.00650191f, -0.04755658f, 0.04565384f, -0.00565364f, 0.01181842f, -0.04541162f, 0.02096718f, 0.03666741f, 
    0.04570767f, -0.01744290f, -0.01862467f, -0.04911098f, 0.02158155f, 0.01386750f, 0.01109640f, 0.05515335f, 
    -0.03007386f, -0.01168602f, 0.03130173f, -0.01602996f, 0.02383892f, -0.02219137f, 0.02085063f, 0.03678562f, 
    0.01718813f, -0.02342830f, 0.01074765f, -0.02421721f, 0.01943882f, -0.04391339f, -0.02018039f, -0.04997092f, 
    -0.03525198f, 0.02948287f, -0.01175091f, -0.02055525f, 0.04251808f, 0.03930497f, 0.00655427f, 0.01205618f, 
    -0.02827014f, 0.00624564f, -0.03220851f, -0.04484283f, 0.01166829f, -0.05495080f, 0.02772699f, 0.03664567f, 
    0.00026849f, -0.01773945f, 0.00126435f, -0.00275701f, 0.00532563f, -0.01869080f, 0.00151343f, -0.04056495f, 
    0.04236925f, 0.00808053f, -0.04853354f, -0.03158103f, -0.01534519f, 0.04147799f, -0.01149003f, -0.02929727f, 
    -0.02241663f, -0.05191588f, -0.05515676f, -0.05304328f, 0.04425826f, -0.05145676f, -0.04384382f, -0.04858582f, 
    -0.00505479f, -0.00580825f, -0.03042090f, -0.04982116f, 0.03896736f, -0.02930182f, -0.03118089f, -0.03274340f, 
    -0.05284706f, -0.00682321f, 0.00060236f, -0.02351266f, -0.02250884f, -0.02724697f, 0.03993645f, 0.00288591f, 
    0.00935248f, 0.03470150f, -0.04218789f, -0.05703527f, -0.00185894f, -0.05028609f, 0.00541618f, -0.01140176f, 
    -0.00224594f, -0.00465739f, -0.02315881f, 0.01879231f, 0.03361268f, -0.05480918f, -0.01633160f, 0.02914979f, 
    0.01721255f, -0.03277175f, -0.02544611f, 0.01258550f, 0.04435936f, -0.00717606f, -0.06072706f, 0.03858431f, 
    -0.05348200f, -0.04069156f, 0.03774754f, -0.00548541f, 0.00515956f, -0.05436334f, -0.04017690f, -0.03538506f, 
    0.01446860f, -0.04626050f, -0.02823938f, -0.02218631f, -0.02400574f, 0.00449156f, -0.05034584f, 0.00357397f, 
    0.00795820f, 0.00082998f, -0.01437160f, -0.00690135f, 0.00039607f, -0.03023704f, -0.02052068f, 0.04518747f, 
    0.04305694f, 0.02300260f, -0.03941421f, 0.04686257f, -0.03666694f, 0.00553401f, 0.00862962f, -0.05088694f, 
    -0.00493658f, -0.01071684f, -0.04554576f, -0.03306990f, -0.00757619f, 0.03486914f, 0.03777121f, 0.02432219f, 
    0.03840993f, -0.01926940f, -0.02252858f, -0.04120755f, 0.01106413f, 0.01031412f, 0.00156833f, 0.02374278f, 
    -0.01887125f, -0.03766487f, 0.04181780f, 0.03702594f, -0.03729671f, 0.01229019f, 0.03103344f, -0.04804633f, 
    -0.01301366f, -0.02984269f, -0.04815854f, -0.02236761f, 0.00590126f, -0.03707181f, 0.01494450f, 0.00126250f, 
    -0.04173176f, -0.03965184f, 0.01998322f, 0.03792103f, 0.00344065f, -0.05187289f, -0.03612482f, -0.01057062f, 
    -0.04345807f, 0.00947660f, -0.00109886f, -0.01429497f, 0.02213064f, 0.01626680f, -0.05267916f, 0.01760661f, 
    -0.09273991f, 0.01648902f, 0.09562980f, -0.02352294f, 0.15499908f, 0.11675338f, 0.09717152f, 0.08235438f, 
    0.13245541f, -0.07214221f, 0.02198276f, 0.13482273f, -0.19235225f, 0.22947890f, -0.04191870f, 0.25080606f, 
    0.04401035f, -0.01011852f, -0.21954252f, 0.07907109f, -0.04212417f, 0.00127385f, -0.06328315f, -0.01905096f, 
    -0.04257058f, 0.23194052f, -0.04834538f, -0.35912454f, -0.11810407f, -0.02197303f, -0.01779757f, 0.02629148f, 
    0.07379593f, -0.07447015f, 0.00576323f, -0.05380685f, -0.21984534f, -0.06981690f, 0.07324869f, -0.19919971f, 
    0.13246600f, -0.06656161f, -0.01867577f, 0.20428696f, 0.11221641f, 0.01056687f, 0.02392027f, 0.05026460f, 
    0.00072586f, -0.13750048f, 0.38797295f, 0.21050273f, 0.11887547f, 0.13416249f, 0.11688510f, -0.03094166f, 
    -0.00178727f, 0.02254109f, -0.10975496f, 0.02300545f, -0.12991966f, -0.06984748f, 0.31923598f, -0.22504765f, 
    -0.20530514f, 0.01385989f, -0.21395978f, -0.00585249f, -0.07278206f, 0.00984055f, -0.00064375f, -0.01141403f, 
    0.07209681f, 0.22790028f, 0.13113159f, 0.15896730f, 0.02632549f, 0.21697408f, 0.08881713f, 0.24563229f, 
    0.03270369f, 0.07909855f, -0.01741271f, -0.19938157f, -0.10223577f, 0.12487310f, 0.17438231f, -0.10302560f, 
    0.09443023f, 0.04718341f, -0.07972958f, -0.00681269f, 0.14105462f, -0.11602410f, -0.01582057f, -0.10823608f, 
    -0.25084534f, -0.08558800f, -0.08728820f, -0.25366718f, 0.01428243f, -0.02786931f, -0.05941352f, -0.03438547f, 
    -0.04224048f, 0.00101341f, -0.01329043f, 0.03176637f, -0.05442018f, 0.05305853f, -0.04772662f, 0.27770013f, 
    0.23881368f, 0.03738698f, -0.07756739f, 0.08802270f, 0.10376529f, -0.01694217f, -0.06647078f, 0.13482423f, 
    0.05630343f, -0.12221553f, 0.38167953f, -0.04974728f, -0.09220202f, 0.02516433f, -0.10946697f, 0.07796922f, 
    0.03791381f, 0.07549302f, -0.03988842f, 0.03134022f, -0.00809632f, -0.20215607f, -0.04251297f, 0.11780462f, 
    0.10437461f, 0.06915027f, 0.03705943f, -0.08208627f, -0.05376418f, 0.06226399f, -0.09044275f, 0.09923699f, 
    -0.09120967f, -0.15061930f, -0.03292098f, -0.01446819f, -0.04691433f, -0.05547526f, -0.16181780f, -0.02624410f, 
    0.03540089f, -0.05035174f, -0.00330715f, -0.00136939f, 0.16529019f, 0.07500727f, -0.32123986f, 0.14602891f, 
    0.10976690f, -0.10294669f, -0.09775233f, 0.06399005f, -0.00343188f, 0.05802326f, -0.00376142f, 0.04559309f, 
    -0.35145310f, -0.44786948f, 0.30314946f, 0.12903747f, -0.06301543f, 0.05319246f, 0.04604247f, -0.10583632f, 
    0.07134694f, 0.00768733f, -0.06248621f, -0.12985398f, 0.00770925f, -0.02028563f, -0.03307467f, 0.06561683f, 
    0.19564037f, 0.12240890f, 0.07076672f, 0.05968625f, -0.00063278f, -0.11178439f, 0.14147586f, -0.06298716f, 
    -0.06276286f, -0.12407108f, 0.03857312f, 0.13664182f, 0.01781992f, -0.11890897f, 0.03591443f, -0.11591110f, 
    -0.03852718f, 0.00414171f, 0.03042652f, 0.09241099f, -0.06296210f, 0.29993027f, 0.01876802f, 0.01063771f, 
    -0.11383203f, -0.07233495f, 0.04213185f, -0.01939387f, 0.13380668f, -0.01475619f, 0.04319532f, -0.13343376f, 
    -0.14559773f, 0.29515344f, 0.01698510f, -0.14888690f, 0.06225270f, 0.09102726f, -0.01280750f, 0.15609829f, 
    -0.06678575f, -0.14153863f, 0.19526617f, -0.09001487f, 0.02383838f, 0.07584252f, 0.24677667f, 0.01895273f, 
    0.13756074f, 0.07069610f, 0.12752393f, 0.06661250f, 0.02825206f, -0.04767924f, 0.02673372f, -0.02422691f, 
    -0.26216763f, 0.06882464f, -0.18024123f, -0.27985197f, 0.16510081f, 0.03611692f, -0.02965284f, 0.05553199f, 
    0.10278200f, 0.11094987f, 0.06028040f, 0.14732274f, 0.08210076f, -0.13551359f, -0.17722654f, -0.24463822f, 
    0.21554370f, 0.15195724f, -0.07891935f, 0.07138731f, 0.10036964f, 0.15108280f, 0.09523433f, -0.01455855f, 
    0.27518779f, -0.17614175f, -0.07149566f, 0.22227070f, 0.05379313f, 0.04423315f, 0.00830818f, 0.09796204f, 
    0.00352206f, -0.05241109f, 0.05237761f, -0.18780953f, 0.13197702f, -0.09630710f, -0.06844521f, 0.02835750f, 
    0.06683960f, -0.06584518f, -0.08376496f, -0.07540456f, 0.12717116f, -0.03962376f, -0.05823585f, -0.03363118f, 
    -0.18943998f, 0.06814503f, -0.08732050f, 0.12897500f, -0.11639541f, 0.01085660f, -0.11340963f, -0.12108567f, 
    0.16370152f, 0.02831048f, 0.07342666f, 0.01820519f, -0.18752891f, 0.04618714f, 0.25383353f, -0.18323322f, 
    0.00822395f, 0.03235767f, 0.01131430f, 0.07849146f, -0.08442332f, 0.06136568f, 0.02107677f, 0.04698721f, 
    0.21273993f, 0.23553060f, -0.24271066f, 0.18958259f, 0.12589657f, 0.08110034f, 0.08341751f, 0.09662571f, 
    0.01882635f, -0.11295415f, 0.10161171f, -0.13344662f, 0.23372774f, 0.10135036f, -0.01370467f, 0.02233172f, 
    0.05361602f, 0.05304238f, 0.01530448f, 0.07779376f, 0.08821984f, 0.05493963f, -0.06478146f, -0.04225016f, 
    0.11939918f, -0.19568105f, 0.08092888f, 0.05381959f, 0.00460777f, -0.05368338f, -0.24463099f, -0.03921998f, 
    0.08433895f, -0.14346346f, -0.00839841f, -0.04423527f, -0.18006970f, 0.01313246f, -0.04237297f, 0.12275543f, 
    -0.04133007f, -0.29357082f, 0.02196551f, 0.03850883f, 0.04445906f, -0.16419418f, 0.05513953f, 0.01879979f, 
    -0.27861473f, -0.25973088f, -0.08558239f, 0.03941986f, -0.02197120f, 0.07402197f, 0.06798711f, -0.01742722f, 
    0.04750311f, 0.07665108f, 0.02164132f, 0.07631074f, -0.29353756f, -0.17261325f, -0.14650220f, 0.29379967f, 
    0.00374439f, -0.09879893f, -0.25868553f, -0.07473046f, 0.09071006f, 0.01326199f, 0.07395413f, 0.08811565f, 
    -0.06270445f, -0.20605096f, 0.01333907f, -0.00403865f, 0.13761383f, -0.09893875f, -0.02957369f, -0.01872676f, 
    -0.07116683f, 0.01896602f, 0.03544491f, 0.07175341f, -0.15655367f, 0.42659998f, -0.07550789f, -0.20778148f, 
    0.15883683f, -0.08234710f, -0.20354773f, 0.12684660f, -0.17866454f, 0.06166836f, 0.04263202f, 0.03928690f, 
    0.07958260f, 0.03499470f, 0.02720960f, 0.33875829f, 0.03911875f, -0.05536177f, 0.03692126f, -0.05762054f, 
    -0.00627590f, 0.03564452f, 0.06512734f, 0.07622291f, -0.18057063f, 0.18667206f, -0.04646220f, 0.27299905f, 
    0.05475621f, 0.00737777f, 0.01554855f, 0.00130832f, 0.04087477f, -0.02973271f, 0.16666986f, -0.00692878f, 
    -0.09878080f, -0.06717303f, -0.04057723f, -0.05494978f, 0.04062821f, 0.05090312f, 0.06917317f, 0.04835010f, 
    -0.05340205f, -0.01765271f, 0.02601151f, -0.01352359f, -0.02596162f, 0.25009537f, -0.00269812f, -0.02174069f, 
    0.13191202f, -0.04329308f, 0.09772411f, 0.03211118f, -0.11803047f, 0.03659229f, 0.04204622f, -0.04275530f, 
    -0.20225979f, -0.11999576f, -0.07670617f, 0.29600689f, 0.08676823f, 0.04278117f, 0.11704143f, -0.13672103f, 
    -0.04506692f, 0.00629917f, -0.09950927f, 0.01412332f, -0.02519638f, 0.09666988f, 0.06387983f, 0.08828133f, 
    -0.05522546f, -0.01354544f, 0.06600188f, -0.08866910f, 0.03324194f, -0.10392366f, -0.05463777f, 0.01391406f, 
    -0.27985972f, 0.11410762f, 0.11247866f, 0.21488413f, 0.14181170f, 0.03046318f, -0.03355431f, 0.02032911f, 
    -0.02409442f, 0.08241287f, -0.08946332f, 0.00113055f, 0.14575914f, 0.12593938f, 0.18751043f, -0.07492414f, 
    -0.04632024f, 0.02190772f, -0.06076998f, -0.11419161f, -0.10257945f, 0.00480334f, -0.05038825f, -0.06826806f, 
    -0.35328099f, 0.28910735f, -0.00098035f, 0.34783986f, 0.06807212f, 0.13020059f, -0.07239518f, -0.00514392f, 
    0.03490139f, -0.01112512f, -0.00068784f, 0.01036286f, -0.11911706f, 0.19646996f, 0.13702601f, -0.32495707f, 
    -0.02368898f, 0.02809889f, -0.09288719f, 0.08689344f, -0.02642045f, 0.00818248f, -0.04988019f, -0.11238763f, 
    0.06263179f, 0.13534017f, 0.19298416f, 0.03957318f, 0.06913508f, -0.07717712f, -0.03004235f, 0.17639638f, 
    0.06040005f, 0.12318869f, 0.00166609f, -0.02114916f, 0.08293773f, 0.09990001f, 0.02001603f, 0.00581505f, 
    0.15806517f, 0.06209782f, -0.04512053f, 0.11192227f, -0.13305080f, 0.03268813f, -0.15225063f, 0.05743415f, 
    0.06200085f, 0.12874679f, -0.03106047f, -0.45417055f, 0.03873277f, 0.11062883f, 0.07867664f, 0.14172550f, 
    0.10719620f, 0.00654165f, -0.04242209f, 0.03898997f, -0.34107241f, -0.23391674f, 0.14993745f, 0.02509780f, 
    -0.07274641f, 0.00586452f, 0.06389961f, 0.01123649f, -0.10454148f, 0.04565487f, 0.04704849f, 0.04323620f, 
    0.20339181f, 0.03748526f, -0.02460494f, 0.04020454f, 0.07895064f, -0.01911502f, 0.11044092f, -0.00345265f, 
    -0.01059631f, 0.12084412f, 0.01835344f, 0.16342457f, 0.44365731f, -0.15769157f, 0.13293172f, -0.00032369f, 
    0.04031096f, -0.07513610f, 0.06497207f, -0.05912830f, -0.03689190f, 0.00056571f, 0.05128850f, -0.03788073f, 
    -0.12981705f, -0.13077591f, 0.27318498f, 0.19766840f, 0.10582874f, 0.04534023f, -0.12783353f, 0.03382027f, 
    -0.03023855f, 0.04269192f, 0.00357222f, -0.02020248f, -0.03974605f, -0.09875102f, -0.05232644f, 0.02854131f, 
    0.09453207f, -0.00148634f, 0.00780136f, -0.13024734f, 0.00038499f, 0.03692613f, -0.06399013f, 0.03658207f, 
    0.16890031f, 0.06145462f, -0.01466085f, 0.24302763f, -0.13938949f, -0.04327301f, -0.02352569f, 0.00573270f, 
    -0.01709751f, -0.15248302f, -0.06670092f, -0.04150809f, -0.07955715f, -0.21602078f, 0.00911836f, 0.05654192f, 
    0.07038394f, -0.10741101f, -0.06854821f, -0.07157215f, -0.03369798f, -0.00660507f, 0.08564761f, -0.03530781f, 
    -0.03093413f, -0.11463186f, -0.05763745f, -0.00054151f, -0.18308008f, 0.19585197f, 0.01365219f, -0.00758279f, 
    0.04920219f, 0.09865312f, -0.07097325f, 0.03881819f, 0.11359926f, -0.06378967f, 0.15698539f, 0.03553423f, 
    -0.11905805f, -0.14387719f, 0.02778671f, -0.04198994f, -0.01115922f, 0.13487256f, 0.08489285f, -0.03591673f, 
    0.08850045f, -0.26311007f, -0.08902001f, -0.22651872f, -0.01050505f, -0.06189460f, -0.02826899f, -0.07487694f, 
    -0.06990886f, -0.00579605f, 0.02686729f, 0.04440705f, -0.00910422f, 0.00243353f, -0.07684433f, -0.02248315f, 
    0.03906893f, -0.01153975f, 0.05931134f, 0.10065724f, -0.05055802f, 0.07683160f, 0.08763070f, 0.06648035f, 
    0.10011563f, -0.14813715f, 0.16998249f, -0.03146265f, -0.18063369f, 0.03067925f, 0.01104618f, 0.03950560f, 
    -0.05630266f, 0.17193028f, -0.05324577f, 0.03772235f, -0.15942998f, 0.11775579f, -0.05200971f, 0.03200617f, 
    0.13271265f, 0.06549882f, 0.02694867f, 0.06008002f, 0.01736560f, 0.02302455f, -0.03106184f, 0.00120619f, 
    -0.27042902f, 0.12574157f, -0.10260315f, -0.07857902f, -0.02626538f, 0.01479918f, -0.04157265f, 0.16421954f, 
    0.00373723f, 0.04716825f, -0.11267389f, -0.02885727f, 0.43143335f, 0.05079694f, 0.08197181f, -0.16956277f, 
    0.05388416f, 0.13055581f, 0.21903399f, 0.00044128f, -0.09893938f, 0.07153697f, -0.01049245f, 0.01870173f, 
    0.04300740f, -0.14760798f, -0.08420499f, -0.09636188f, 0.00492813f, -0.11342525f, 0.04391437f, 0.03941762f, 
    0.07795022f, 0.19822124f, 0.05138248f, -0.02829159f, 0.19832745f, 0.00365369f, 0.17612623f, -0.06005184f, 
    0.01094997f, -0.09654356f, -0.05340158f, -0.05874163f, 0.00957264f, -0.03709043f, 0.04607361f, 0.11748421f, 
    -0.05322503f, -0.12237087f, 0.02163404f, -0.00307650f, -0.18385619f, -0.15618770f, -0.11205209f, 0.08802327f, 
    -0.00477969f, -0.07916028f, 0.04387857f, -0.15228538f, -0.35009664f, 0.23041086f, 0.12498230f, 0.31672624f, 
    0.13902929f, 0.30536118f, -0.11686590f, 0.06011642f, 0.16611651f, -0.02146149f, 0.15828450f, 0.10908346f, 
    -0.25100100f, 0.37879777f, -0.09754446f, 0.04578145f, -0.03781690f, -0.03356260f, 0.14766526f, 0.01778147f, 
    -0.25115627f, 0.08732659f, -0.15618843f, 0.10826152f, -0.14613245f, -0.13606885f, 0.09717124f, 0.10854226f, 
    -0.10998329f, -0.00465637f, 0.07375199f, 0.17257278f, -0.08608773f, 0.04220397f, -0.03435130f, -0.04129231f, 
    0.27767232f, -0.00463827f, -0.06601629f, 0.12138806f, 0.01883738f, -0.01308845f, 0.06600817f, 0.02668439f, 
    0.04245990f, -0.02083283f, -0.02609193f, -0.00238499f, -0.25995398f, 0.02608705f, -0.20268290f, 0.22965465f, 
    -0.07296114f, 0.04506438f, 0.00783236f, -0.09396403f, 0.09516234f, -0.05230102f, 0.25024617f, 0.00549505f, 
    -0.20087506f, -0.04986477f, -0.02990254f, 0.16558352f, -0.14866790f, -0.03319299f, -0.02942905f, 0.10770541f, 
    0.03600050f, -0.04584322f, 0.03910768f, -0.01591293f, -0.08282702f, -0.01501211f, 0.15391763f, -0.10259577f, 
    0.04857562f, 0.07863602f, 0.00809741f, -0.02371719f, 0.09498700f, 0.16714635f, 0.06789226f, 0.22196546f, 
    0.09076145f, 0.23138036f, 0.01894093f, -0.16773351f, -0.04719561f, -0.06182380f, -0.03734702f, 0.06821716f, 
    0.01967075f, -0.00853246f, 0.05567984f, 0.01384216f, 0.10343533f, -0.14202024f, 0.18738700f, 0.04524865f, 
    0.16362517f, 0.01973502f, 0.00652622f, 0.03249510f, 0.16263489f, 0.15290061f, 0.06489265f, 0.11845391f, 
    -0.24865282f, -0.03402183f, 0.02937065f, 0.03325091f, -0.02272814f, 0.09272832f, -0.04025058f, 0.00577190f, 
    -0.03091039f, -0.03221056f, 0.09213622f, 0.02047339f, 0.02149714f, 0.05194158f, -0.11787605f, 0.16348448f, 
    0.09424617f, -0.11846343f, -0.04378907f, -0.11626952f, -0.01477827f, 0.00567437f, -0.03815195f, 0.09770134f, 
    0.05761597f, 0.02574362f, 0.20917612f, -0.06577371f, -0.03090672f, -0.04447340f, -0.05615022f, 0.04471853f, 
    -0.01341787f, 0.04429746f, 0.03223570f, -0.06837825f, -0.11086410f, 0.14067240f, 0.09805651f, 0.11749889f, 
    -0.08383960f, -0.08360129f, 0.09184235f, -0.02778545f, 0.08473553f, -0.06116794f, 0.02619867f, 0.04208200f, 
    -0.17591748f, 0.01645724f, -0.12300171f, 0.44806978f, 0.19425619f, -0.01743373f, 0.18811657f, -0.31236675f, 
    -0.02748968f, 0.10918819f, -0.01418306f, 0.07980682f, 0.39612654f, 0.20847219f, -0.02664646f, -0.06191935f, 
    -0.04995114f, 0.04357895f, -0.01013197f, 0.00174252f, 0.03000926f, 0.01973765f, -0.00163304f, -0.06436440f, 
    -0.01502870f, -0.16437034f, -0.08848924f, 0.13353170f, 0.05260150f, -0.07340434f, -0.05186798f, -0.00546317f, 
    0.02718985f, -0.00105341f, 0.08874898f, 0.05772654f, -0.18551151f, -0.13564652f, 0.22661659f, -0.10551404f, 
    -0.04176765f, -0.10957554f, -0.04061434f, -0.00667655f, 0.05301375f, 0.09868377f, 0.01156651f, 0.06112376f, 
    0.00777759f, -0.01396306f, 0.40019900f, 0.21972081f, -0.12328306f, -0.06375703f, 0.13865849f, 0.02943362f, 
    -0.08432011f, 0.02484427f, -0.00682056f, -0.04409086f, -0.14459223f, -0.10167237f, 0.13525315f, 0.06325663f, 
    -0.06908751f, 0.06252266f, 0.13021223f, 0.03224790f, 0.12453923f, 0.08356209f, 0.05278085f, -0.02035977f, 
    0.20447290f, -0.06049369f, 0.08194379f, -0.00483688f, 0.05770593f, 0.03481574f, 0.01649835f, 0.16193719f, 
    -0.09293290f, 0.07712282f, -0.01350450f, -0.01464677f, 0.01769675f, 0.03020075f, -0.02127786f, -0.21395241f, 
    -0.09352928f, 0.10371765f, 0.05172947f, 0.04057377f, -0.00036250f, 0.03036179f, 0.00380025f, -0.03065078f, 
    0.21225224f, 0.09726785f, -0.09351241f, 0.13357466f, 0.00992667f, -0.05517742f, 0.11257978f, 0.02192245f, 
    0.08115147f, 0.03757164f, 0.01694010f, 0.09707138f, -0.02020772f, 0.16255967f, -0.19769405f, 0.02925366f, 
    0.01579651f, 0.02175921f, 0.12642094f, -0.02691731f, -0.04803626f, -0.11802159f, 0.01265235f, -0.04174959f, 
    -0.12489302f, 0.08394267f, -0.04302279f, -0.07277268f, -0.06696945f, 0.05374888f, 0.06381468f, -0.06143144f, 
    0.08934896f, 0.05842373f, 0.03882810f, -0.00108253f, -0.15074646f, -0.05308806f, -0.01252293f, 0.01617824f, 
    -0.10107101f, -0.03987636f, -0.14703152f, -0.11698540f, 0.15626062f, 0.02120773f, 0.00957179f, 0.02528895f, 
    0.15017956f, 0.10367706f, 0.12027586f, -0.05297291f, -0.07235173f, -0.03198294f, 0.09084478f, 0.12134791f, 
    0.00536986f, 0.02784126f, -0.00446837f, -0.03577654f, -0.08389541f, -0.03595296f, -0.08126401f, 0.22013274f, 
    -0.09601980f, -0.09736662f, -0.03014643f, -0.07973761f, -0.03845978f, 0.03047920f, -0.04872830f, -0.00926509f, 
    0.05215619f, -0.02746972f, -0.01693969f, 0.25833681f, -0.02067513f, -0.15064497f, -0.11832914f, 0.08001294f, 
    0.07342252f, 0.06535435f, 0.07725459f, 0.00990395f, 0.14581878f, 0.07648500f, -0.18964334f, 0.08695681f, 
    0.10870031f, -0.07715231f, -0.00323724f, -0.03927778f, 0.16487040f, 0.03989177f, 0.13082795f, 0.05981422f, 
    -0.01462051f, -0.02092239f, -0.10868479f, -0.08518672f, -0.08900297f, 0.00976518f, 0.14441426f, -0.04775220f, 
    0.08405966f, 0.04957106f, 0.10231845f, -0.06826875f, -0.10546763f, -0.04374216f, 0.09693842f, -0.22327556f, 
    -0.03930814f, 0.10162807f, -0.04353677f, -0.08742130f, -0.06780336f, 0.11582867f, -0.02161684f, -0.21467842f, 
    -0.16289285f, -0.29652929f, -0.04707760f, 0.05729420f, -0.06351878f, -0.18454082f, -0.03667920f, 0.04342390f, 
    0.04138725f, 0.07702681f, 0.08955520f, 0.01603930f, -0.21627598f, 0.40474030f, 0.00068472f, -0.16111679f, 
    -0.08376587f, 0.07071093f, -0.24776171f, 0.07020821f, -0.11521757f, -0.00657156f, 0.19169192f, -0.08787104f, 
    0.04908783f, 0.06684919f, 0.13204795f, 0.28306249f, -0.00166374f, -0.13329703f, 0.11570472f, 0.06074212f, 
    -0.08017559f, 0.14540829f, 0.25963271f, 0.14341174f, -0.25996771f, 0.03972369f, 0.16143258f, 0.10089099f, 
    0.11004289f, -0.02840778f, 0.04093232f, 0.02433129f, 0.13722904f, -0.02771438f, 0.11175752f, 0.00239631f, 
    0.03582874f, -0.25771940f, -0.11127822f, 0.11760039f, -0.06921037f, 0.02652590f, -0.00810071f, 0.11741405f, 
    -0.04740082f, 0.00762675f, 0.08068693f, -0.05445969f, 0.34504384f, -0.18634591f, 0.02095399f, -0.00522254f, 
    0.05676245f, 0.08591977f, 0.02659230f, -0.05997928f, -0.17932659f, 0.03773173f, 0.09043754f, -0.06361105f, 
    -0.36274114f, -0.15137330f, 0.00929460f, 0.28166589f, 0.00830548f, 0.06286608f, -0.00354012f, -0.03773291f, 
    0.00644903f, -0.03415557f, 0.00767854f, 0.07083747f, 0.00982926f, 0.00944988f, 0.23939621f, 0.10067687f, 
    -0.00977877f, 0.07210928f, 0.13891850f, -0.02301641f, 0.06255318f, -0.10768390f, -0.13304497f, 0.13715923f, 
    -0.18598580f, 0.08702215f, 0.35698918f, 0.17949185f, 0.02523430f, -0.00983093f, -0.07011491f, -0.01428282f, 
    0.04721732f, -0.00163066f, -0.03914553f, 0.09777610f, -0.04148743f, 0.01155183f, 0.06886603f, 0.03039307f, 
    -0.07091386f, 0.08267759f, 0.09176433f, -0.04792021f, 0.00875161f, 0.06487658f, -0.15921634f, -0.00603902f, 
    -0.34254241f, -0.12694120f, 0.17366834f, 0.14857748f, 0.02136215f, 0.19756106f, -0.08916521f, -0.00658033f, 
    0.00216288f, 0.00668327f, 0.08045932f, 0.01296635f, 0.07587602f, 0.22259435f, 0.12050287f, -0.10011317f, 
    0.03108424f, 0.00584991f, -0.01538899f, 0.01092908f, 0.08193658f, 0.01150107f, -0.14877585f, 0.07845424f, 
    0.06330010f, 0.11656547f, 0.15519953f, -0.01170456f, -0.11005595f, -0.11163276f, -0.07078118f, 0.13712236f, 
    0.00716059f, 0.04826692f, 0.07738665f, 0.03584395f, 0.04428828f, 0.09620295f, -0.08358259f, 0.12610148f, 
    0.10294637f, 0.04890324f, 0.00233629f, 0.10030582f, -0.04402813f, 0.00522745f, -0.00760649f, 0.09186114f, 
    0.01761025f, -0.06012915f, -0.09801492f, -0.20099303f, 0.05318783f, 0.10013903f, 0.03995280f, 0.02095255f, 
    -0.04761989f, 0.03440194f, -0.06115540f, 0.12992620f, -0.28680086f, -0.10211921f, 0.13614827f, -0.05029295f, 
    0.06369860f, 0.01061880f, 0.10530624f, -0.05185369f, -0.05048415f, -0.03797923f, 0.08585139f, 0.03415504f, 
    0.26256788f, -0.07179725f, 0.00872361f, 0.06935022f, 0.04188956f, -0.02331343f, 0.10887267f, 0.00108713f, 
    0.08403946f, 0.00712696f, -0.01974292f, 0.10937270f, 0.22077583f, -0.25855228f, 0.10843978f, 0.04094838f, 
    0.04326873f, -0.07855253f, 0.11403357f, -0.04946057f, 0.05959088f, 0.01095927f, 0.07275454f, 0.12019409f, 
    -0.25876296f, 0.10206395f, 0.37107351f, 0.41340193f, 0.09115916f, -0.01540733f, 0.05279340f, 0.04126341f, 
    0.01944995f, -0.09733513f, 0.05408419f, -0.02583113f, -0.17277130f, -0.17202292f, 0.12538427f, 0.07796722f, 
    0.05980994f, 0.13717483f, 0.07082450f, -0.01878151f, 0.06653933f, 0.10013041f, -0.04583383f, 0.07972026f, 
    0.02409487f, -0.05443505f, -0.10105330f, 0.04574012f, 0.03144122f, -0.15149330f, 0.01677008f, 0.05736947f, 
    0.03412171f, -0.11280578f, 0.13342789f, -0.07665309f, -0.12286409f, -0.22863215f, 0.02932794f, -0.12790596f, 
    -0.02091626f, 0.07726742f, -0.04059158f, -0.10602497f, 0.04616161f, -0.04702632f, -0.02558280f, -0.16959977f, 
    0.20874511f, -0.03771569f, -0.19463971f, 0.09127794f, -0.08447668f, 0.24064669f, 0.13279924f, -0.05003025f, 
    -0.03766485f, 0.01748948f, -0.05835294f, -0.00418677f, 0.21347411f, -0.05883989f, 0.12461127f, -0.11475389f, 
    -0.04384271f, -0.05112858f, 0.01654182f, 0.00299283f, -0.03608887f, 0.13794520f, 0.08578903f, -0.03785510f, 
    0.03414690f, -0.17295077f, -0.03472469f, -0.19316339f, 0.01418595f, -0.07956331f, -0.00431243f, -0.16651550f, 
    0.06902687f, -0.02282516f, 0.03042785f, -0.02755201f, -0.12627831f, -0.18817307f, 0.04273493f, -0.12085419f, 
    -0.00863768f, -0.04930386f, 0.01723912f, 0.00242528f, 0.01045034f, 0.08097541f, 0.03908426f, 0.00920612f, 
    0.00678212f, 0.17361131f, 0.07131973f, 0.11232097f, -0.04044960f, -0.04693366f, 0.12620793f, 0.02968129f, 
    0.04632577f, 0.10027394f, 0.00294683f, -0.04657908f, -0.15566120f, -0.05733665f, 0.02030262f, 0.07495889f, 
    0.03665137f, 0.10368785f, -0.07542348f, 0.11451606f, 0.02727589f, 0.04247281f, 0.03773242f, 0.03139944f, 
    -0.19025247f, 0.03740803f, -0.15525548f, 0.13918976f, -0.07823131f, 0.07675907f, -0.03241861f, 0.18383309f, 
    -0.01007466f, 0.06807783f, -0.06484899f, 0.08697970f, 0.28523710f, 0.01375235f, -0.12778555f, -0.11200321f, 
    0.01120405f, 0.06573165f, 0.13042668f, 0.02048239f, -0.02273822f, -0.01834440f, 0.07685672f, 0.05870900f, 
    -0.03643591f, -0.15525950f, -0.07199208f, -0.12459007f, -0.02845286f, -0.05047505f, 0.02421376f, 0.02309123f, 
    0.15225814f, 0.21998200f, 0.00502543f, -0.06712299f, 0.02320830f, 0.05705170f, 0.04416203f, 0.02617664f, 
    -0.02727566f, -0.05334753f, -0.01418942f, -0.05961007f, 0.02606943f, -0.01959416f, -0.07428364f, 0.00531403f, 
    0.00466663f, -0.00455036f, -0.00201408f, -0.02465314f, 0.03305376f, 0.03123671f, -0.02419040f, -0.02195696f, 
    -0.01775822f, -0.01519480f, 0.02109184f, -0.03119696f, 0.03753666f, -0.02140906f, -0.03241482f, -0.02019210f, 
    0.04318410f, -0.05345190f, -0.03613884f, 0.03108541f, -0.01268599f, 0.04732168f, 0.00678864f, -0.00357247f, 
    -0.00032086f, -0.03485344f, -0.01692166f, 0.02165204f, -0.02858817f, -0.05045487f, -0.03583760f, 0.03375861f, 
    -0.00202020f, -0.01195107f, -0.04031602f, -0.00536534f, 0.01123201f, 0.01069723f, 0.00871217f, 0.02182775f, 
    0.00321068f, 0.02642658f, 0.00415609f, -0.05668693f, 0.04283971f, -0.04979691f, -0.03016022f, -0.03267257f, 
    0.03573626f, 0.02549366f, -0.02578476f, 0.00763951f, 0.01282981f, 0.01337858f, -0.01814345f, -0.00533746f, 
    -0.03420742f, 0.01599960f, 0.02876928f, 0.02941373f, 0.02472324f, -0.02093021f, -0.02093629f, -0.01214872f, 
    -0.03866936f, 0.00834872f, -0.04935710f, -0.01098698f, 0.01308838f, 0.02562251f, -0.02186539f, -0.00033587f, 
    -0.02062687f, -0.02393815f, -0.01979874f, -0.04477398f, -0.04542955f, 0.01539134f, 0.00539534f, 0.02463817f, 
    0.00959885f, 0.00244187f, 0.05171979f, -0.04464299f, 0.02081412f, -0.01998219f, -0.03977615f, 0.01177037f, 
    0.04371587f, 0.01061654f, -0.02263635f, 0.04506251f, -0.00034114f, -0.00914089f, -0.00461237f, -0.00906702f, 
    -0.00869524f, -0.05803901f, 0.02607597f, 0.01495266f, -0.04778421f, -0.02268480f, 0.02070999f, -0.06811760f, 
    0.00294035f, -0.03206168f, -0.02957161f, -0.03583716f, 0.04531910f, -0.00204859f, 0.01351096f, 0.01548693f, 
    0.02289357f, -0.03289844f, -0.00932699f, -0.01745169f, -0.01145092f, -0.05152810f, -0.01751874f, -0.04341481f, 
    -0.04044560f, -0.02622822f, 0.00678409f, 0.02733529f, 0.04363761f, 0.02490998f, -0.04158721f, 0.04574661f, 
    -0.05639451f, -0.02148982f, -0.01948344f, 0.04230669f, 0.01427010f, -0.02813034f, -0.04223830f, 0.03633290f, 
    0.00978521f, -0.03455405f, 0.00557105f, 0.00860240f, -0.04914067f, 0.01490613f, 0.03450549f, 0.03456431f, 
    -0.02773392f, -0.02466431f, 0.03623744f, -0.03567153f, 0.02055417f, -0.00710918f, 0.02177146f, 0.01440789f, 
    -0.04900024f, -0.02484708f, 0.01988836f, -0.03137640f, 0.02507548f, 0.05198485f, 0.02245193f, 0.00585005f, 
    -0.02718603f, -0.00510575f, -0.03096194f, -0.03783275f, -0.04491883f, 0.03893341f, -0.03662055f, -0.03587145f, 
    -0.00598373f, 0.03916739f, 0.00294582f, -0.04455368f, 0.00710149f, -0.03497666f, 0.00354056f, -0.00363952f, 
    -0.05052094f, -0.00047485f, 0.03108401f, 0.01632316f, 0.03230288f, -0.04751670f, -0.00959488f, -0.02767879f, 
    -0.02151838f, -0.04376271f, -0.03852545f, -0.01045480f, -0.03252429f, -0.03580214f, 0.02602289f, 0.01181990f, 
    -0.04010902f, -0.03326085f, -0.02592388f, 0.00028924f, 0.00196259f, -0.05039834f, -0.01312478f, -0.00622763f, 
    -0.05601713f, -0.02433924f, 0.01768531f, -0.02480726f, -0.03621219f, 0.02093376f, -0.01155971f, -0.01008403f, 
    0.02516946f, 0.01908833f, -0.03501181f, 0.03030459f, -0.04328279f, 0.01637635f, 0.01645584f, 0.03432057f, 
    -0.00382171f, 0.04715599f, -0.05376047f, -0.01031041f, 0.03472643f, 0.04201093f, 0.00475982f, -0.01830826f, 
    0.02706189f, -0.01656041f, 0.02675726f, 0.03130588f, -0.03764024f, -0.04686446f, -0.05388990f, 0.00067868f, 
    -0.01867739f, -0.00524012f, -0.04404258f, -0.03140894f, 0.03535758f, -0.01749889f, 0.03773929f, -0.04925081f, 
    0.02017258f, 0.03427354f, -0.03268398f, -0.02064744f, -0.00432076f, -0.03684666f, -0.00516088f, 0.02066913f, 
    -0.00566845f, -0.03909745f, 0.04394851f, -0.05136993f, 0.04712682f, 0.04214226f, -0.01420263f, 0.02435170f, 
    -0.00826692f, -0.03199594f, -0.00328325f, 0.02026368f, -0.00380468f, 0.00365915f, -0.01274158f, -0.03236371f, 
    -0.01732116f, -0.02267300f, -0.01790500f, -0.02980826f, 0.01549030f, -0.03311353f, -0.02144955f, -0.04254989f, 
    0.01068031f, -0.03332362f, 0.04896404f, -0.01446913f, -0.04411206f, 0.01994714f, 0.02591072f, 0.02334431f, 
    -0.01245074f, -0.01326856f, -0.02304653f, 0.00632864f, -0.03936651f, -0.06458075f, 0.00423720f, 0.00159547f, 
    0.01386640f, -0.01576484f, -0.01608610f, 0.04783254f, 0.00760361f, 0.01778005f, -0.02666961f, 0.03141815f, 
    -0.04070235f, 0.03066863f, 0.02931318f, 0.00702157f, 0.03592482f, -0.02556100f, -0.01531257f, 0.01814321f, 
    -0.03761346f, 0.03686455f, 0.00039517f, 0.04188044f, 0.04737488f, -0.03009656f, 0.03885691f, 0.00348135f, 
    0.03588888f, -0.03079193f, -0.02855035f, 0.02411764f, 0.02323791f, 0.00218870f, 0.04663301f, 0.00735061f, 
    -0.03115921f, -0.01902708f, -0.02398085f, 0.01671246f, 0.04363219f, -0.02742781f, -0.03642064f, -0.04718200f, 
    0.00803709f, -0.04749677f, 0.00203366f, -0.01024996f, -0.00278192f, -0.04275052f, 0.01165183f, 0.01365084f, 
    -0.03441097f, -0.00315029f, 0.02380097f, 0.03073384f, -0.04075905f, -0.01364988f, 0.01421005f, 0.01774086f, 
    0.02996374f, -0.00392246f, -0.00736461f, -0.01097712f, -0.05464667f, 0.01408826f, -0.01198929f, -0.02178847f, 
    0.02353841f, 0.01280380f, 0.03771914f, 0.00704315f, -0.01033619f, -0.03413882f, 0.05472719f, -0.03471112f, 
    -0.00824511f, -0.02996841f, -0.02305814f, -0.04177494f, -0.00175341f, -0.02398503f, 0.01813580f, -0.00282691f, 
    -0.03956367f, -0.02901305f, -0.02988712f, -0.03361468f, -0.00378379f, -0.00379732f, -0.05550926f, -0.04436553f, 
    -0.02676246f, -0.02604472f, 0.02218327f, -0.02215892f, -0.00010025f, 0.02967241f, 0.01167676f, -0.04139321f, 
    -0.19868775f, -0.21229535f, 0.05485563f, -0.05141584f, -0.01268822f, -0.15307736f, 0.02811417f, -0.11691639f, 
    0.01037159f, -0.03194183f, -0.01508858f, 0.08678941f, -0.13899277f, -0.02952597f, 0.05460560f, 0.28024265f, 
    0.06150994f, -0.06692473f, -0.28692657f, 0.10987600f, -0.09658066f, 0.04491385f, 0.07888159f, -0.09240047f, 
    0.11334034f, 0.25788829f, 0.09791826f, 0.00030500f, -0.00156112f, -0.05822762f, 0.01771836f, 0.02557774f, 
    -0.01925505f, 0.02986101f, 0.14111304f, 0.05734229f, -0.26625791f, 0.01543288f, 0.09550390f, -0.18981329f, 
    0.06786846f, -0.03395069f, 0.04344328f, -0.05235241f, -0.02689086f, -0.01396219f, 0.12186049f, 0.09210345f, 
    -0.09462285f, -0.25638774f, 0.08974504f, 0.23102482f, 0.06029898f, 0.13408270f, 0.08825928f, 0.08940773f, 
    0.02549840f, -0.02939489f, -0.07420132f, -0.08853488f, 0.03543014f, -0.32492816f, 0.28086850f, 0.07362768f, 
    -0.06805228f, -0.03312720f, -0.04196790f, 0.12283824f, -0.09312987f, 0.11115967f, 0.00980995f, 0.01874318f, 
    -0.14291970f, -0.03487670f, 0.07060804f, 0.10628383f, -0.02658710f, 0.08612656f, 0.13746965f, -0.04001674f, 
    -0.00527301f, 0.01887342f, 0.03951178f, -0.08172769f, -0.09380318f, -0.03724983f, 0.11538187f, -0.12740892f, 
    0.04525056f, -0.02678622f, 0.04051194f, 0.02411748f, 0.05507613f, -0.05405827f, 0.00865102f, 0.06903115f, 
    -0.10423585f, 0.38741586f, 0.38187870f, 0.02701343f, 0.00449085f, -0.04719442f, -0.01111894f, 0.11825260f, 
    -0.03222814f, 0.04891274f, -0.11354584f, -0.04139762f, -0.07311050f, 0.10861872f, 0.09731408f, 0.16204961f, 
    0.12299952f, 0.12042985f, 0.03103215f, -0.01370215f, 0.05967538f, -0.00244011f, -0.10601638f, 0.07524298f, 
    -0.02053754f, -0.38485128f, 0.36487478f, 0.29329801f, 0.12203547f, 0.09963989f, -0.07797380f, -0.10197340f, 
    0.01650765f, -0.03026885f, 0.00455798f, -0.01054561f, -0.03105768f, 0.02648886f, 0.10527848f, -0.09591479f, 
    -0.04374219f, -0.02080038f, 0.03965600f, 0.11349933f, 0.12685688f, 0.11118536f, -0.08408272f, 0.21838249f, 
    -0.07822983f, 0.22975253f, 0.26485419f, 0.15760455f, -0.09847833f, -0.16396244f, -0.21247108f, 0.15557253f, 
    0.00961571f, -0.02222455f, 0.06648094f, -0.00361101f, 0.03720237f, 0.11880203f, -0.12104430f, 0.05238175f, 
    0.04373991f, -0.04677172f, -0.10048839f, 0.01073463f, 0.01502161f, 0.03686401f, -0.05298777f, 0.06257927f, 
    -0.21519856f, -0.35340363f, 0.07591685f, 0.10768852f, -0.07236674f, 0.03525472f, -0.01638179f, 0.01033998f, 
    0.11080360f, -0.04205718f, -0.00975932f, -0.01592538f, -0.25227892f, -0.15491870f, -0.07994903f, 0.00638367f, 
    0.15261404f, 0.12541363f, 0.11234847f, 0.06016813f, -0.02001843f, -0.06182898f, 0.11396425f, -0.04800832f, 
    -0.04164051f, -0.05518963f, 0.17056683f, 0.20036583f, -0.07701658f, -0.13290237f, 0.09361256f, -0.00018187f, 
    -0.00523858f, 0.02768691f, 0.14595297f, 0.11483195f, 0.07871450f, -0.00748172f, 0.04220776f, -0.06803286f, 
    -0.07507534f, -0.16787371f, 0.07713409f, -0.11751289f, 0.14389275f, -0.09238117f, 0.18171650f, 0.01015759f, 
    -0.15979049f, 0.21306647f, 0.19533539f, -0.13405654f, 0.06238730f, 0.07992649f, -0.03317340f, -0.05545740f, 
    -0.08061017f, -0.09202922f, 0.14087968f, -0.16716212f, -0.04136953f, -0.04346259f, 0.19350927f, 0.06383011f, 
    0.15013622f, 0.14478526f, 0.03225530f, -0.11567850f, 0.05606956f, 0.02355049f, 0.07713774f, 0.03076254f, 
    0.05457094f, 0.09365134f, -0.14145976f, -0.01958123f, 0.04734822f, 0.06094941f, -0.01825159f, 0.10449994f, 
    0.10385469f, 0.02718340f, 0.01042755f, 0.00349097f, -0.03715697f, -0.27923739f, -0.06790387f, -0.01028804f, 
    0.24773060f, 0.14023373f, -0.08812832f, 0.04594408f, 0.03933140f, 0.00343893f, 0.01608091f, -0.06563751f, 
    0.22965279f, -0.16829965f, -0.34253103f, 0.05028102f, -0.02961476f, 0.16756120f, 0.06596176f, -0.03134618f, 
    0.08043382f, 0.02046115f, 0.01486008f, -0.04987367f, 0.25700331f, -0.03293053f, 0.14022380f, 0.06103387f, 
    0.02492396f, -0.16670264f, -0.05100658f, -0.02568931f, -0.01387924f, 0.03181235f, -0.07212075f, -0.01791704f, 
    0.00601380f, -0.04399624f, -0.04489312f, 0.02389272f, -0.02449610f, -0.03036785f, -0.07413301f, -0.11824060f, 
    0.15242486f, 0.05671214f, 0.10811646f, -0.03341758f, -0.24809064f, -0.20767996f, 0.24645497f, -0.12769392f, 
    -0.05722793f, -0.02738185f, 0.04772799f, 0.17973581f, -0.05001612f, 0.10293569f, 0.13208593f, 0.06929038f, 
    0.14335415f, 0.09188899f, -0.25546858f, -0.00257585f, -0.01192437f, 0.11889605f, 0.13404123f, 0.06289550f, 
    0.12762864f, 0.08771342f, 0.12354437f, -0.06383438f, -0.09833296f, -0.00202549f, 0.16020727f, 0.12537365f, 
    0.04394508f, 0.02797464f, -0.24373627f, 0.00297250f, 0.01823535f, -0.07628348f, 0.02678339f, -0.01922508f, 
    -0.10220523f, -0.00073603f, 0.05356496f, 0.11369080f, -0.05783432f, -0.07032722f, -0.02473368f, 0.18982939f, 
    0.09149902f, -0.01629514f, -0.10870674f, -0.09740882f, -0.19015467f, -0.03191398f, -0.06347652f, 0.04615268f, 
    -0.11657640f, -0.10619549f, 0.11401963f, 0.10748935f, -0.00650017f, -0.12537624f, 0.05782583f, 0.12060113f, 
    -0.00494413f, -0.20591675f, -0.25418881f, -0.03149623f, 0.00496359f, -0.01941625f, 0.13054784f, 0.02201105f, 
    0.14486723f, 0.09528716f, 0.07186712f, 0.11365496f, -0.10096847f, -0.08023818f, -0.11851384f, 0.13648117f, 
    0.01397348f, -0.03436258f, -0.11377652f, -0.03884920f, 0.06297373f, -0.08120261f, 0.07584348f, 0.01891400f, 
    0.01502483f, 0.03561723f, -0.02365086f, -0.02826632f, 0.03680496f, 0.00842713f, -0.03805289f, -0.01841266f, 
    0.03624618f, -0.02180008f, -0.05520720f, 0.01491898f, -0.03379468f, 0.02751846f, 0.03330550f, -0.01683310f, 
    0.02599508f, -0.02563709f, -0.03889138f, -0.06095707f, 0.01105424f, -0.05368950f, -0.02121235f, -0.00830358f, 
    -0.03299514f, -0.00813438f, -0.02307690f, 0.01739486f, -0.02033356f, 0.02822233f, -0.01794990f, -0.05090142f, 
    0.01364845f, -0.02772196f, -0.05475049f, -0.02241835f, -0.01141778f, -0.05018316f, -0.04649935f, 0.03747614f, 
    0.00974465f, -0.02672582f, -0.00005671f, 0.02179180f, 0.01720465f, 0.02926796f, 0.02382769f, -0.06021759f, 
    0.02687135f, 0.01371049f, 0.00477635f, 0.02816718f, 0.03442957f, 0.02243184f, -0.04933018f, -0.03120194f, 
    -0.05487762f, -0.04816420f, 0.01991948f, -0.03415192f, -0.02692513f, 0.02863760f, 0.01471248f, 0.04532158f, 
    -0.03700356f, 0.01248215f, 0.00558191f, -0.05266688f, 0.02043860f, 0.02290822f, 0.00975615f, -0.04618186f, 
    0.02223733f, 0.02832308f, 0.02816925f, -0.01159547f, 0.01748781f, -0.01221647f, -0.04371098f, -0.00310154f, 
    0.00881529f, -0.00286331f, 0.02073668f, -0.05047761f, 0.00660210f, 0.02985505f, -0.01081348f, 0.03886363f, 
    0.02967572f, 0.00484336f, 0.02574364f, -0.04981564f, 0.02870245f, -0.05099069f, -0.00166558f, -0.01041712f, 
    -0.05358565f, -0.00613165f, -0.00048352f, -0.04391297f, 0.01284197f, -0.05110750f, -0.00915142f, 0.02647233f, 
    -0.01152960f, -0.04290177f, -0.00345359f, 0.02271503f, 0.01244262f, 0.02291424f, -0.05461634f, -0.01197687f, 
    0.03321345f, 0.01039988f, -0.03859864f, 0.00043007f, 0.03659758f, 0.03819175f, -0.04072615f, 0.03959787f, 
    -0.04664823f, -0.02944146f, -0.01859456f, -0.03711968f, -0.01004588f, -0.02390282f, -0.06164560f, -0.02436731f, 
    -0.05697707f, -0.02545225f, 0.00120216f, -0.02289932f, 0.03963234f, 0.00215518f, -0.02760876f, -0.01211180f, 
    0.02149875f, -0.00135713f, 0.00180129f, -0.05292359f, 0.03683339f, 0.00076515f, 0.03804691f, -0.01522391f, 
    -0.02081097f, -0.03391651f, -0.00677914f, 0.00074238f, 0.00225606f, -0.04249324f, 0.01371692f, -0.01451677f, 
    0.01430619f, 0.01721885f, 0.03604423f, -0.04151100f, 0.01096321f, -0.03556949f, -0.02178898f, -0.01243128f, 
    0.01970959f, 0.01235326f, -0.05116867f, 0.00155966f, -0.03979611f, -0.02384314f, -0.03400857f, -0.05844122f, 
    -0.00739584f, 0.03344773f, 0.03487707f, -0.01676678f, -0.05743232f, 0.02325481f, 0.02315176f, -0.00678550f, 
    -0.04227776f, -0.00142701f, -0.01818445f, 0.02766341f, 0.02551578f, 0.02075775f, -0.01011140f, -0.01265853f, 
    0.00922533f, -0.01288333f, 0.01420393f, -0.05555487f, 0.02462336f, 0.00541409f, -0.04636852f, 0.01685565f, 
    0.03764687f, -0.02350021f, -0.00984335f, 0.00647431f, -0.00075498f, -0.00594833f, -0.00057646f, -0.03784980f, 
    0.03322189f, -0.00416961f, -0.04349041f, 0.02549132f, -0.02536311f, 0.01104942f, -0.02794475f, -0.03020670f, 
    -0.01407068f, 0.00743615f, -0.05838852f, -0.03823920f, 0.01395388f, 0.02016804f, 0.01147566f, -0.04183862f, 
    -0.02532444f, -0.05488961f, -0.03348025f, -0.04598986f, 0.01667049f, -0.03860136f, 0.04274637f, 0.03463469f, 
    -0.00813490f, 0.03926464f, 0.03556142f, 0.01624409f, 0.03900320f, -0.01025630f, -0.04937339f, -0.03873488f, 
    0.03143096f, -0.00612525f, -0.04360899f, -0.04032531f, -0.03361807f, 0.02074074f, 0.02936445f, 0.03819174f, 
    0.01702533f, 0.00804214f, -0.03737519f, -0.04446913f, -0.03834776f, 0.00725273f, 0.03315295f, 0.02709246f, 
    -0.02705501f, -0.03049653f, 0.00806816f, 0.04256351f, 0.03879536f, 0.00986548f, -0.02687265f, 0.02604717f, 
    -0.00280867f, -0.05255195f, -0.02951925f, 0.03407842f, -0.05570142f, -0.05454535f, -0.04704173f, -0.01374544f, 
    -0.00578973f, -0.02340063f, -0.00323109f, -0.01990515f, 0.02769612f, -0.03876594f, -0.02672592f, -0.00036299f, 
    0.03750078f, 0.00098086f, -0.00935642f, -0.03902755f, 0.00373251f, 0.03295795f, -0.04581867f, -0.05376851f, 
    0.03622433f, 0.03802501f, 0.03540000f, -0.00846092f, -0.01956626f, -0.03164084f, 0.01405464f, -0.03064485f, 
    -0.01187458f, -0.03577158f, -0.03180125f, 0.04395484f, 0.02796288f, -0.04229903f, 0.01417732f, -0.01482773f, 
    -0.04948589f, 0.02586418f, -0.03167446f, 0.00717299f, -0.04783166f, -0.02232314f, -0.03546070f, 0.01662457f, 
    0.02813077f, 0.02785751f, -0.02998904f, -0.03787800f, 0.00125440f, -0.03161199f, 0.01558950f, -0.03607126f, 
    -0.02027202f, -0.00648832f, -0.04033384f, -0.03327849f, -0.02126253f, -0.04683353f, -0.01443297f, -0.01270881f, 
    -0.00148379f, 0.01855433f, 0.01514485f, -0.02436584f, 0.02077092f, -0.01235621f, 0.03982916f, -0.05662173f, 
    0.03171397f, -0.01328525f, -0.04477964f, -0.03269295f, -0.00239251f, 0.01870772f, 0.01847558f, -0.04013913f, 
    -0.05773292f, 0.02516271f, 0.01126847f, 0.00826071f, -0.01765019f, 0.00337409f, -0.04314477f, 0.01124135f, 
    -0.03769302f, 0.03038590f, -0.04717271f, -0.04791348f, -0.04964818f, 0.02373332f, -0.03628680f, -0.01332592f, 
    -0.02802664f, 0.00124895f, 0.03019959f, 0.01618857f, -0.03239653f, 0.01864993f, 0.03726031f, -0.05492440f, 
    0.01275262f, -0.02894940f, -0.05418212f, -0.05258277f, -0.00050254f, -0.05294009f, -0.02414732f, 0.03864173f, 
    -0.02394271f, 0.02292429f, -0.02903383f, 0.01639939f, 0.05045751f, -0.02381321f, -0.01544879f, -0.01862057f, 
    -0.02740617f, -0.01402732f, 0.02420477f, 0.00573648f, 0.02559283f, 0.04147070f, -0.03444039f, -0.02199907f, 
    0.00051499f, 0.00556106f, 0.04651051f, -0.03568633f, 0.02274905f, -0.02376498f, -0.00793429f, -0.05400261f, 
    -0.01803469f, 0.01683118f, -0.01016452f, 0.00180670f, -0.00873992f, 0.03092888f, -0.00321096f, 0.02038752f, 
    -0.03510589f, -0.04986384f, -0.03335924f, -0.00839576f, -0.00936412f, 0.01929119f, 0.02002776f, 0.00578573f, 
    -0.00599745f, 0.00425628f, -0.04861967f, -0.03987843f, -0.04455406f, -0.03170175f, -0.04075764f, -0.05022743f, 
    -0.00816512f, 0.02820241f, 0.01836122f, 0.02252028f, -0.02879747f, -0.01619008f, 0.03055734f, -0.05608284f, 
    -0.00802302f, 0.00370743f, 0.03141760f, 0.03703682f, 0.03147519f, -0.02519026f, -0.02174628f, 0.01176636f, 
    -0.02757747f, 0.04354031f, 0.04353608f, -0.00195606f, -0.04170827f, 0.03247688f, -0.00472998f, 0.02703006f, 
    0.03336073f, -0.01933879f, -0.00702680f, 0.03217080f, -0.01262308f, -0.01563020f, -0.00623503f, -0.03253027f, 
    0.01745391f, -0.00373357f, 0.00287183f, 0.03863960f, -0.03614156f, 0.02136589f, -0.05053315f, 0.03058370f, 
    -0.01617536f, -0.00890558f, -0.01611972f, -0.05451462f, -0.02413697f, -0.04979174f, 0.00319746f, -0.01139766f, 
    0.02259228f, -0.04657279f, -0.01667592f, 0.01990748f, -0.04264984f, -0.02258158f, 0.02546122f, -0.04301299f, 
    -0.03402456f, 0.01441854f, -0.01441062f, -0.04167268f, -0.05523291f, -0.02459035f, -0.05475903f, -0.05082403f, 
    -0.03509365f, 0.04487122f, 0.04167765f, -0.04754925f, -0.04562923f, 0.03897782f, -0.00866271f, 0.02004384f, 
    0.02729356f, -0.04364549f, -0.01158704f, -0.02624306f, -0.03178972f, -0.04969592f, -0.02562231f, -0.01573917f, 
    0.02492025f, -0.03834663f, -0.04098233f, -0.03773656f, 0.04023972f, 0.01575366f, -0.03085892f, -0.01223807f, 
    0.01469486f, -0.05058022f, -0.03652457f, -0.05371728f, 0.01310769f, -0.01248483f, 0.02928331f, 0.01642200f, 
    -0.02276785f, -0.05094607f, 0.00701864f, 0.02212465f, -0.03191222f, -0.03540225f, -0.00526758f, -0.00660288f, 
    -0.03249655f, -0.00518394f, -0.03276384f, 0.03268704f, -0.04292561f, 0.01827557f, 0.00348722f, 0.03512865f, 
    0.00137259f, 0.00701638f, -0.04085292f, 0.00271390f, -0.04611020f, -0.00137278f, -0.02992337f, 0.03886040f, 
    0.01284035f, 0.00400952f, -0.00873483f, -0.02825536f, 0.01194618f, -0.02535760f, 0.00107288f, -0.03711255f, 
    0.00934279f, 0.03534303f, 0.01671337f, 0.03669222f, 0.02665138f, -0.02706638f, -0.00017280f, -0.01392425f, 
    0.02521546f, 0.01265723f, -0.02403169f, 0.02990935f, -0.00161575f, 0.02718728f, -0.00987051f, 0.00504906f, 
    0.03686386f, -0.01822184f, -0.03564866f, -0.01038068f, 0.00390083f, 0.00997093f, -0.03789493f, -0.03860544f, 
    -0.01267656f, 0.02937084f, -0.01177914f, -0.01497865f, -0.01386990f, -0.04538152f, 0.01858215f, 0.00377745f, 
    0.02649591f, -0.05534471f, -0.03370177f, -0.02500182f, -0.02140399f, 0.00229491f, -0.04301087f, -0.00006710f, 
    0.04315954f, 0.00738744f, -0.02824158f, -0.02770611f, -0.02840942f, 0.01575544f, 0.00889432f, -0.00759148f, 
    0.02591840f, -0.03405520f, -0.00397624f, -0.03263360f, 0.00835473f, -0.05548644f, 0.03426829f, -0.04135200f, 
    -0.01381868f, 0.03257385f, 0.01437524f, 0.02188617f, -0.05291025f, -0.02556172f, -0.05580878f, -0.02610010f, 
    -0.01873828f, -0.01022096f, -0.04411065f, -0.01898340f, -0.03907883f, -0.03530255f, -0.04423451f, -0.00971804f, 
    -0.01005279f, -0.02414443f, 0.03604826f, -0.04559444f, -0.01590450f, 0.02053140f, -0.05663744f, 0.00603977f, 
    0.04448061f, -0.04845114f, -0.01532329f, -0.02142204f, -0.04527794f, -0.01290680f, -0.04546228f, -0.02851425f, 
    0.00184230f, 0.04022638f, -0.05481486f, -0.03312096f, -0.01700142f, 0.02686860f, 0.03404379f, 0.00410320f, 
    0.03865951f, -0.03532129f, -0.02474418f, -0.04500336f, -0.04279583f, 0.00700776f, 0.04344177f, 0.05032738f, 
    -0.00655936f, 0.02546188f, 0.01653669f, -0.04785166f, 0.04470191f, -0.02215585f, -0.01408174f, 0.03557465f, 
    0.02694831f, 0.02768163f, -0.03472692f, -0.01092599f, -0.05583159f, 0.02819393f, -0.02356157f, 0.01588026f, 
    -0.04534641f, -0.04470786f, 0.00916099f, -0.05439063f, -0.04094064f, 0.01391158f, 0.04304084f, -0.01534500f, 
    -0.02689971f, -0.04880375f, 0.01458225f, -0.01819606f, 0.04855825f, -0.00036583f, -0.02980708f, 0.03927686f, 
    0.01102706f, 0.03175965f, -0.04422195f, -0.01607102f, 0.02639022f, 0.03915847f, -0.00668400f, 0.01976077f, 
    -0.00985326f, 0.03153335f, 0.01286447f, 0.01843237f, 0.02132596f, 0.00116791f, 0.03693967f, 0.03504377f, 
    -0.02148408f, -0.01429785f, 0.01005471f, -0.04958310f, 0.03109832f, 0.04239556f, 0.01870546f, 0.02405294f, 
    0.00530792f, -0.03986615f, -0.03068395f, -0.05515874f, -0.05019793f, -0.04710986f, 0.00405904f, -0.02016609f, 
    -0.02397981f, 0.00687334f, -0.04180231f, 0.03046368f, -0.05017848f, 0.03498034f, -0.05345330f, -0.03149452f, 
    -0.01889732f, -0.01708353f, 0.03002159f, -0.04071411f, 0.02414795f, 0.03901345f, -0.02265315f, -0.00925948f, 
    0.00767148f, 0.02902040f, -0.05240955f, 0.01692823f, 0.00408659f, -0.02394046f, -0.02998253f, 0.00186284f, 
    0.02707524f, -0.04510470f, -0.05160217f, -0.04783737f, 0.03918181f, -0.05503803f, -0.02219020f, -0.04293755f, 
    0.03929617f, -0.01580758f, 0.01160427f, -0.04665902f, 0.00486416f, 0.02442642f, 0.00473916f, 0.03023898f, 
    0.03644399f, -0.03775385f, -0.02553250f, -0.00507376f, -0.05615175f, 0.03251752f, 0.01406328f, -0.00256556f, 
    0.00417099f, -0.02122671f, 0.02611449f, -0.04431881f, -0.05265189f, -0.01367121f, -0.01394626f, -0.03282537f, 
    0.33719158f, 0.24349289f, 0.05819169f, 0.15633953f, -0.03741598f, 0.16321261f, 0.05599587f, -0.00580163f, 
    0.02160700f, 0.05954196f, 0.00094562f, -0.01601598f, -0.08404849f, -0.12773280f, -0.11036401f, -0.22921374f, 
    -0.08594796f, 0.00701263f, 0.10823648f, -0.07332087f, -0.08683664f, -0.15210450f, 0.10932077f, -0.03539100f, 
    0.24130979f, -0.11215318f, -0.05858931f, 0.17247181f, -0.02668677f, 0.01337232f, -0.00384330f, -0.07825918f, 
    -0.05973380f, -0.01341186f, 0.04882254f, -0.04506981f, 0.22906865f, 0.03318130f, -0.05510154f, 0.18684161f, 
    0.01945058f, 0.03302084f, -0.04617076f, -0.09730856f, -0.01130627f, 0.03582661f, -0.08670331f, 0.00043679f, 
    0.16190776f, 0.20460851f, -0.00306918f, 0.00298433f, -0.04494280f, -0.05199840f, -0.14285126f, 0.05357100f, 
    -0.14071763f, -0.00992003f, 0.08679880f, -0.03832553f, 0.24661388f, -0.06198949f, -0.11925630f, -0.05124748f, 
    -0.06679437f, -0.04377400f, 0.00506685f, -0.22830661f, 0.02178340f, 0.02014164f, 0.04475598f, 0.00069833f, 
    0.23075981f, -0.03751055f, 0.09646723f, 0.00873836f, -0.00127330f, -0.15149181f, 0.00854294f, 0.06747051f, 
    0.00737025f, -0.05733762f, 0.06743176f, 0.16056702f, 0.02841051f, -0.05133420f, -0.08002728f, 0.19996464f, 
    0.02973142f, -0.03445012f, 0.03909554f, -0.06608892f, -0.09081776f, 0.12856774f, 0.02743029f, 0.36041147f, 
    0.31568849f, -0.23872559f, -0.01107979f, 0.17977010f, 0.13664217f, 0.12549958f, -0.04957592f, -0.04441788f, 
    -0.00455905f, 0.00412554f, -0.02985708f, 0.11661070f, -0.08911858f, -0.00818658f, 0.01579063f, -0.07867666f, 
    -0.06517601f, -0.06277959f, 0.03022732f, 0.03090950f, -0.06242516f, -0.01233303f, 0.03737390f, -0.05155933f, 
    -0.18102090f, -0.26626027f, -0.08739982f, -0.18272349f, -0.01391054f, -0.03640673f, 0.01653931f, -0.03011520f, 
    -0.10588040f, -0.05982995f, 0.08413918f, 0.09081724f, 0.08383079f, 0.05987649f, -0.04621601f, 0.05909141f, 
    0.06590398f, 0.00424639f, -0.01803658f, -0.08482382f, 0.05915540f, 0.08887440f, 0.16976985f, 0.08229485f, 
    0.12116936f, 0.07909407f, -0.10941805f, -0.00512650f, 0.09296931f, 0.09847103f, 0.01715139f, -0.07408831f, 
    -0.11271802f, -0.05545291f, 0.03801384f, 0.01045344f, -0.07284394f, 0.03919296f, 0.12920906f, 0.03317939f, 
    -0.05611579f, 0.07074768f, 0.04903597f, 0.03564514f, -0.02968135f, -0.05473948f, 0.03424567f, -0.05949241f, 
    -0.13690259f, 0.46062535f, -0.03064949f, -0.05254658f, 0.09669165f, -0.09932725f, -0.05921927f, -0.01317600f, 
    -0.03813036f, 0.13111120f, 0.05568956f, -0.02408889f, -0.19949152f, -0.38065851f, -0.42368019f, -0.22858834f, 
    0.05367489f, -0.01154665f, -0.08087862f, -0.13086408f, -0.05727893f, 0.02118202f, -0.11365471f, -0.11315979f, 
    0.25426510f, 0.14563660f, 0.05597568f, 0.20568426f, 0.16441965f, 0.01562477f, -0.01039402f, -0.03049802f, 
    0.06744792f, 0.05367449f, -0.03605955f, -0.10915352f, 0.13668565f, 0.05613967f, 0.00455388f, 0.22254728f, 
    0.05119457f, 0.18420732f, -0.00404034f, -0.04398967f, -0.09429589f, -0.06125502f, 0.07979923f, 0.12137432f, 
    0.28254977f, -0.09000691f, -0.00677480f, 0.15698932f, -0.00128930f, 0.02060596f, 0.01227160f, 0.07042348f, 
    0.00063624f, 0.09480444f, -0.17158701f, -0.02327224f, 0.23491743f, 0.22976561f, 0.08597659f, 0.04170022f, 
    -0.09655572f, -0.06926136f, 0.04700926f, 0.07002100f, 0.00095068f, -0.00430064f, 0.02415418f, -0.03392795f, 
    0.09297158f, -0.31620309f, -0.10893365f, -0.21371920f, -0.04091658f, 0.02335341f, 0.03943823f, -0.10866129f, 
    -0.18599071f, -0.00939854f, -0.10844254f, -0.20270294f, -0.15260454f, -0.24831586f, -0.03353996f, -0.12777609f, 
    -0.15716428f, 0.03289577f, 0.06839088f, -0.09995092f, -0.16958071f, 0.02215253f, -0.00273123f, 0.01925218f, 
    0.10746720f, 0.02835366f, 0.08598992f, -0.06480350f, -0.07789396f, -0.01306083f, -0.06713902f, 0.03139562f, 
    0.00320432f, 0.08364690f, 0.15130866f, 0.31652710f, -0.07592393f, -0.11673729f, -0.06364324f, -0.25237483f, 
    0.00654131f, 0.04380069f, -0.07516027f, -0.23712288f, -0.06569883f, 0.04360715f, 0.04709663f, -0.12436022f, 
    -0.18992573f, -0.24482839f, -0.05331259f, -0.15202042f, 0.01078382f, 0.10035478f, 0.06132798f, -0.14170919f, 
    -0.21346074f, 0.00388218f, -0.17512937f, -0.03940836f, 0.25891957f, 0.17627554f, -0.02552906f, 0.18877815f, 
    -0.01381265f, 0.12172039f, -0.02832245f, -0.06307626f, 0.06588478f, 0.11176808f, 0.04214608f, 0.04229688f, 
    -0.25317264f, -0.04974701f, -0.14237362f, -0.11921152f, 0.00065022f, -0.05827666f, 0.07717331f, -0.06983933f, 
    0.06420910f, 0.04844204f, -0.11247343f, 0.09173071f, 0.24481454f, 0.27088395f, 0.05257571f, 0.07384285f, 
    -0.02871767f, 0.06129828f, 0.00871990f, 0.13932177f, -0.06557092f, -0.07186357f, 0.04711283f, 0.02629600f, 
    0.22518735f, 0.11904860f, 0.00145674f, 0.21155837f, 0.14998861f, 0.02503459f, 0.13260742f, 0.01358965f, 
    -0.07496783f, 0.10211350f, 0.07016175f, 0.02539379f, 0.28210235f, 0.07368702f, -0.07767409f, 0.12829180f, 
    0.06703067f, 0.21790832f, 0.06560446f, -0.14948061f, -0.01740438f, -0.04620128f, 0.12016833f, 0.10359436f, 
    -0.15710476f, -0.27654240f, -0.13056564f, -0.17701375f, 0.00303728f, 0.12318351f, 0.04996135f, -0.06871539f, 
    -0.08764447f, -0.07618801f, 0.08134995f, 0.06711771f, -0.35337624f, -0.15117478f, -0.18113394f, -0.15903182f, 
    -0.01680495f, 0.04659928f, 0.02699151f, 0.03723692f, -0.04420938f, 0.07696386f, -0.06882620f, -0.10036123f, 
    -0.16955383f, -0.07447144f, 0.08439904f, 0.18736020f, -0.10459435f, -0.00354262f, -0.03346712f, 0.04174541f, 
    -0.03370593f, 0.01963664f, 0.01161067f, -0.01806622f, -0.05206598f, 0.17492281f, 0.17143770f, 0.09561380f, 
    -0.01292872f, 0.00099522f, -0.09495708f, 0.04754372f, -0.09767021f, 0.11288270f, -0.02509017f, 0.04578097f, 
    0.10277467f, 0.10568788f, 0.05575397f, 0.05996793f, 0.00846805f, -0.07365104f, -0.04783805f, -0.19990747f, 
    -0.05472528f, 0.07597142f, -0.06180456f, -0.03509111f, -0.07015784f, 0.24567655f, 0.19485365f, 0.01500734f, 
    0.01461725f, 0.00728098f, -0.06562464f, 0.03635102f, 0.08409914f, -0.05321315f, -0.06032163f, 0.11169980f, 
    -0.19090876f, -0.04393613f, -0.16104786f, 0.09501123f, 0.04574106f, 0.09136561f, -0.02484524f, -0.03886327f, 
    -0.11597496f, -0.00206159f, -0.11498317f, -0.19133185f, -0.06138914f, -0.12579694f, -0.07315855f, 0.14941432f, 
    0.12312029f, 0.07448652f, -0.19125670f, -0.08800114f, 0.00209960f, 0.05923491f, -0.03634672f, -0.05953771f, 
    -0.28280747f, -0.11316136f, 0.08699430f, 0.12059791f, -0.07891144f, -0.03066866f, 0.05846673f, 0.12015925f, 
    -0.01483868f, 0.03592709f, -0.03161175f, -0.03013900f, 0.15185493f, -0.06849179f, 0.15999971f, 0.03051245f, 
    0.09827947f, -0.07813139f, -0.07185701f, 0.04391109f, 0.01059100f, 0.19707333f, 0.10436543f, 0.22655287f, 
    0.24136285f, 0.39207709f, 0.28121784f, 0.10527249f, -0.00944352f, -0.11324774f, -0.06012296f, -0.14738905f, 
    -0.00069142f, -0.10109112f, -0.01968916f, 0.05440202f, 0.04675375f, -0.05165510f, -0.06965692f, -0.06265050f, 
    0.04127878f, 0.06381124f, -0.13305517f, 0.01936729f, 0.05498725f, 0.10529844f, 0.10224263f, -0.09477603f, 
    -0.34567916f, 0.20548685f, -0.05963234f, 0.13915139f, 0.02957606f, -0.05422284f, 0.09733293f, -0.05223440f, 
    -0.10017697f, -0.01688694f, -0.15215005f, 0.09412842f, 0.03404242f, 0.14290087f, 0.06969909f, 0.15476401f, 
    -0.05560572f, -0.02213557f, -0.07101573f, -0.01028737f, -0.03589360f, 0.01511407f, 0.10858732f, 0.05968958f, 
    0.22744977f, 0.15985958f, 0.22475131f, 0.08561576f, -0.03375059f, -0.00781966f, -0.05219702f, -0.08370654f, 
    -0.05634886f, 0.07570823f, -0.11221359f, -0.02895190f, 0.02966842f, 0.05271840f, 0.16681142f, 0.14200315f, 
    -0.05673646f, -0.06391858f, 0.17579271f, 0.03178993f, 0.00219623f, 0.23047712f, 0.01400550f, 0.13155809f, 
    -0.27245107f, 0.05094909f, -0.38658082f, 0.10809468f, -0.03606430f, -0.00604223f, -0.04805970f, -0.13466251f, 
    -0.12371638f, 0.00948485f, -0.07271332f, 0.04157545f, 0.33110237f, 0.12089601f, 0.14629194f, 0.09700350f, 
    0.00466764f, 0.00562996f, -0.01750311f, 0.00046570f, -0.09720085f, -0.06902444f, -0.16005346f, -0.06823216f, 
    0.13463394f, 0.09540237f, 0.10861295f, 0.06858590f, 0.08626449f, -0.06474632f, -0.05302590f, -0.02159843f, 
    -0.00692672f, 0.09329858f, -0.04535648f, -0.01326399f, 0.33355078f, -0.14848033f, 0.04862664f, 0.21430108f, 
    0.18713054f, -0.11680610f, 0.00735181f, 0.00055880f, 0.01942492f, -0.02453767f, -0.02351847f, 0.19448911f, 
    0.00208980f, -0.02450220f, 0.18846519f, 0.19413565f, -0.00511864f, -0.01100093f, -0.00983101f, -0.09294906f, 
    -0.07280681f, 0.07003367f, -0.05079937f, -0.10189972f, -0.04373884f, -0.10125194f, 0.05880371f, 0.11409864f, 
    0.07164573f, -0.00861566f, 0.08469642f, 0.18017219f, 0.13561048f, 0.10281615f, 0.03674654f, 0.18122353f, 
    -0.08515202f, -0.16058734f, 0.03345776f, 0.00069675f, -0.02477976f, -0.03680124f, -0.03776072f, -0.08347575f, 
    -0.13779384f, 0.02512443f, -0.20580558f, -0.01798311f, 0.10010821f, -0.00228082f, -0.10036527f, 0.00157098f, 
    0.02104055f, -0.01173603f, -0.07189495f, 0.08576071f, -0.00500053f, 0.05437097f, -0.05589855f, 0.06623668f, 
    -0.04612697f, 0.10664338f, -0.04904750f, 0.02366664f, -0.01592555f, 0.04691391f, -0.11891498f, -0.11258108f, 
    0.16062020f, 0.21458142f, 0.03238381f, 0.27553153f, 0.09834398f, 0.12348504f, -0.05329512f, -0.10559998f, 
    0.04274366f, -0.05591635f, -0.06758051f, -0.05833595f, -0.02234942f, -0.06417170f, -0.01519492f, -0.05999706f, 
    0.00502534f, -0.06419763f, -0.10566460f, -0.02800934f, 0.20544375f, -0.14521644f, 0.04791320f, -0.07989042f, 
    0.01039078f, 0.03715868f, -0.09137917f, 0.01807699f, -0.16351038f, -0.13003701f, 0.02984446f, 0.09715095f, 
    0.04089997f, -0.04484106f, -0.12707944f, 0.00598468f, 0.03422140f, 0.05936396f, 0.02112001f, 0.10533993f, 
    0.23102321f, 0.07489634f, 0.15789558f, -0.00375801f, -0.02843040f, -0.09725537f, 0.05841418f, 0.05192591f, 
    0.08600013f, 0.03596233f, 0.07948916f, 0.03913302f, -0.07833423f, -0.09246439f, 0.09532909f, 0.15987514f, 
    0.11374238f, -0.03873384f, -0.02955907f, 0.16455792f, 0.09072559f, 0.14981093f, 0.05859943f, 0.10643186f, 
    -0.06686396f, 0.11699099f, 0.07876050f, 0.26667136f, -0.08165856f, -0.06377216f, -0.02854913f, -0.04403632f, 
    -0.04088700f, 0.03156497f, 0.03859320f, 0.06246257f, 0.25361833f, -0.05627578f, -0.02280089f, 0.21581946f, 
    0.00954728f, 0.01329955f, -0.11563580f, -0.06703858f, 0.00301060f, 0.06815153f, 0.09609868f, 0.04215651f, 
    -0.04469163f, -0.06941500f, -0.10914201f, -0.05298288f, -0.03366019f, -0.05227937f, -0.05052717f, 0.00770601f, 
    0.23772612f, 0.18276894f, 0.07260288f, 0.12609175f, -0.02770353f, -0.05928827f, 0.01125798f, -0.23252809f, 
    0.23931193f, 0.08764566f, -0.05140455f, -0.10461342f, -0.08990830f, -0.09619913f, -0.19989924f, -0.27378309f, 
    -0.04148353f, 0.09351155f, 0.11026600f, -0.07712033f, 0.01451111f, 0.03022052f, -0.00291003f, -0.05807432f, 
    0.04118758f, 0.01685699f, -0.02142206f, -0.04807549f, 0.11671195f, -0.26699388f, 0.18711652f, 0.31160942f, 
    0.06920350f, 0.05958856f, 0.15390925f, -0.05565959f, 0.21057642f, 0.11169361f, -0.03828009f, -0.05301194f, 
    -0.01614085f, 0.12420320f, 0.05222050f, -0.24092202f, -0.03465950f, 0.07857389f, -0.02645957f, 0.22449909f, 
    0.08465164f, -0.04360361f, -0.06723142f, -0.00306980f, 0.20785448f, 0.06021003f, 0.09306268f, -0.20185526f, 
    0.04651051f, -0.01660316f, 0.11305445f, -0.07960992f, 0.08539668f, -0.01268464f, -0.10797567f, 0.08127642f, 
    -0.12940438f, 0.01160358f, 0.05356012f, 0.12928878f, -0.03700845f, 0.16315424f, 0.07504489f, 0.00895365f, 
    0.08652668f, -0.03580133f, -0.10691391f, -0.07080393f, -0.13812907f, -0.33486795f, 0.27726650f, 0.15292993f, 
    -0.00392947f, 0.07428601f, -0.06043086f, 0.23845036f, 0.22088565f, -0.01201035f, -0.04395540f, 0.07175323f, 
    0.13339211f, 0.16629741f, 0.07432492f, -0.18356971f, -0.08386184f, -0.00448067f, 0.03901420f, 0.05181782f, 
    0.03780719f, 0.05383431f, 0.00702152f, -0.06966054f, 0.00642762f, -0.02479873f, -0.08850906f, -0.23306654f, 
    0.12109880f, -0.09138144f, -0.02957366f, 0.04847229f, 0.14303592f, 0.14706966f, 0.10374829f, -0.15352108f, 
    0.06686242f, 0.15144575f, -0.10122514f, -0.22851688f, -0.12771361f, -0.07858843f, 0.09030267f, 0.05947280f, 
    0.03488244f, -0.04895518f, -0.00024426f, -0.04980764f, -0.03080491f, 0.11408857f, -0.01410970f, 0.14838721f, 
    0.14933175f, 0.10680160f, 0.12395387f, 0.07937304f, 0.04121033f, 0.11476512f, 0.00267931f, 0.19893855f, 
    0.28867462f, -0.19406496f, 0.14915769f, -0.09956179f, 0.08372432f, 0.06170299f, 0.10682715f, 0.15308064f, 
    0.08518203f, 0.07015312f, -0.04557369f, 0.01577849f, 0.04537085f, -0.06825434f, -0.10190240f, 0.07146176f, 
    0.03523075f, -0.05950964f, 0.06235999f, 0.01889607f, 0.02302469f, 0.10234668f, 0.03813240f, 0.28988668f, 
    -0.02785108f, 0.09115190f, 0.06274547f, 0.07217634f, -0.10612349f, 0.01205148f, -0.06432434f, -0.05127264f, 
    -0.04636907f, -0.05379100f, 0.00701559f, -0.01329137f, -0.03190627f, -0.04961803f, 0.09012717f, -0.04494591f, 
    0.01526165f, -0.09862618f, 0.04187181f, -0.08207473f, 0.15838403f, 0.02780859f, 0.00623279f, 0.00397847f, 
    0.00298818f, -0.34973678f, 0.17674927f, 0.53779912f, -0.03737636f, 0.03756981f, 0.01214937f, -0.04832197f, 
    0.04369095f, 0.04903720f, 0.21927229f, -0.04588968f, 0.37611440f, 0.09353788f, -0.14555347f, -0.05651552f, 
    -0.00763913f, 0.09592799f, -0.02346637f, -0.03315203f, 0.05082979f, -0.04919167f, -0.01075750f, -0.05818509f, 
    -0.33568907f, -0.11348660f, -0.00089896f, -0.01650716f, -0.07857820f, 0.05236017f, -0.02156124f, -0.01540148f, 
    -0.07419648f, 0.00254724f, 0.06518830f, -0.04678594f, -0.33577117f, 0.21295963f, 0.00818312f, 0.01687591f, 
    0.03974132f, -0.02969659f, -0.00215134f, -0.06194914f, 0.12752147f, 0.08595140f, 0.03918443f, -0.00579339f, 
    0.11958018f, 0.29166090f, -0.03167566f, -0.28845045f, -0.04310683f, 0.08685046f, 0.03168647f, -0.03541292f, 
    0.00792525f, -0.02837047f, -0.01848134f, -0.04187108f, -0.01144698f, 0.07298592f, 0.07308766f, -0.03612678f, 
    0.02986348f, 0.06420781f, -0.01916605f, -0.06216955f, 0.07614569f, 0.00047933f, 0.14371489f, -0.05401795f, 
    0.06393895f, -0.02349353f, 0.08350248f, -0.07787973f, 0.11062092f, 0.13755733f, -0.07412122f, 0.03608653f, 
    0.11605506f, -0.03382246f, -0.08419994f, -0.01813371f, -0.00785040f, 0.11930942f, -0.04389701f, -0.06805862f, 
    0.01462894f, 0.05206965f, 0.04010971f, 0.01787495f, -0.00856615f, 0.03582206f, -0.04915813f, -0.03025880f, 
    0.15732384f, 0.00443826f, -0.02125512f, 0.04581555f, 0.12164051f, -0.04431416f, 0.01715548f, -0.01461287f, 
    0.12222845f, -0.03037104f, 0.02688858f, 0.05510716f, -0.05643636f, 0.04536500f, -0.05105310f, -0.01379708f, 
    0.08437834f, -0.07057067f, 0.10728179f, 0.03738022f, -0.04710353f, -0.12922774f, -0.07991607f, -0.01109540f, 
    -0.07165893f, 0.09436509f, -0.02533842f, 0.04893916f, -0.00372329f, -0.04573406f, -0.05970111f, 0.00996517f, 
    0.04089560f, -0.00690493f, 0.06843188f, -0.09293365f, -0.16164745f, -0.05318283f, 0.25148743f, -0.01787448f, 
    -0.07560429f, -0.04021514f, -0.12054442f, 0.10068824f, 0.02722402f, -0.01953440f, 0.06123883f, -0.00220160f, 
    0.19712323f, 0.00921355f, -0.06108382f, 0.00593523f, 0.05214497f, 0.03831798f, 0.03112061f, -0.06581271f, 
    0.09939773f, -0.12784451f, 0.08672242f, -0.00101931f, -0.03086725f, -0.07559982f, 0.25278184f, 0.05998091f, 
    -0.07032030f, -0.09006872f, -0.03512361f, -0.10347361f, 0.08563881f, 0.01588988f, 0.00402525f, 0.03875657f, 
    0.09299711f, -0.07273605f, 0.14080000f, 0.05222661f, -0.07392689f, 0.03837358f, 0.03313931f, -0.03699749f, 
    0.14873376f, 0.01903115f, 0.16092768f, 0.03458635f, -0.42775765f, -0.02972741f, 0.03088618f, 0.00727551f, 
    -0.05908931f, -0.11360018f, 0.07908518f, -0.00067758f, 0.22919817f, -0.03957192f, -0.06262125f, 0.05848923f, 
    0.08744849f, 0.00527945f, -0.00057119f, -0.00729067f, -0.03018692f, 0.02682484f, 0.04141533f, -0.06345969f, 
    0.02214396f, -0.15421139f, 0.04855455f, -0.00485391f, -0.08942299f, -0.03128577f, -0.17053373f, -0.01510574f, 
    0.03172847f, 0.00866961f, -0.03654294f, -0.00816297f, -0.02234043f, -0.05581122f, 0.00144319f, -0.07358900f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01527394f, -0.02292261f, -0.05175768f, 0.11584077f, 0.15231019f, 0.01827349f, -0.00996145f, -0.01953331f, 
    0.09797414f, 0.07987935f, 0.14447638f, -0.04160751f, -0.05200709f, 0.10275491f, 0.09919997f, 0.07317272f, 
    0.00713292f, 0.03186876f, 0.12040699f, -0.08138391f, 0.07827501f, 0.13406999f, 0.00125189f, -0.05808819f, 
    -0.10233830f, -0.04946306f, 0.09861677f, -0.02788576f, 0.08057267f, -0.05991570f, -0.04049429f, -0.05933560f, 
    0.00263838f, 0.04143249f, 0.05339164f, 0.04716513f, 0.05154204f, -0.04077858f, 0.02440463f, -0.05311580f, 
    0.06375583f, 0.16521917f, -0.01051729f, 0.00522879f, 0.20449853f, -0.04894078f, 0.00717370f, 0.02770560f, 
    -0.01467130f, 0.09574506f, 0.04100882f, -0.03745038f, -0.02475868f, 0.03610816f, 0.02016769f, 0.03484821f, 
    -0.03258488f, -0.05172515f, 0.06532747f, 0.03907298f, 0.01522080f, -0.13116719f, -0.04651325f, 0.08613639f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09349488f, -0.25824171f, -0.06494931f, 0.05835452f, -0.27242619f, -0.01309825f, -0.09458135f, -0.41949520f, 
    -0.25659177f, -0.05052996f, -0.19867030f, 0.01879914f, 0.04033460f, -0.35961589f, -0.16441657f, 0.12286156f, 
    -0.29769915f, 0.04857587f, -0.09127562f, 0.28280604f, 0.08522598f, -0.25013113f, 0.19531523f, 0.12176433f, 
    0.12990676f, 0.03819678f, 0.18956985f, 0.19650690f, -0.21334834f, 0.19345675f, 0.09324811f, 0.38326979f, 
    0.07389823f, 0.01451938f, -0.22991617f, 0.12555616f, 0.12282296f, -0.07953684f, 0.10025076f, 0.11281165f, 
    0.16271921f, -0.38778588f, 0.01777515f, -0.03624398f, -0.23656762f, 0.12044554f, 0.08328965f, 0.10123466f, 
    -0.08288999f, -0.46002132f, -0.06437848f, 0.12748384f, -0.07251646f, -0.31053862f, -0.03504099f, -0.43441761f, 
    -0.51181567f, -0.00081800f, -0.48583385f, -0.04309047f, -0.00322708f, 0.25497761f, -0.14183937f, -0.17836551f, 
    0.06360760f, -0.54890937f, -0.03114960f, 0.03710569f, 0.32495531f, -0.04605967f, -0.07251886f, -0.12337836f, 
    0.33460158f, 0.11317012f, -0.14881980f, -0.02280349f, 0.02060769f, 0.40014818f, -0.00062162f, -0.10202087f, 
    -0.69550574f, -0.02314272f, 0.38991120f, -0.55873263f, 0.02226291f, 0.18349099f, 0.01500816f, 0.06214581f, 
    -0.12921926f, 0.08389565f, 0.13147703f, 0.19102205f, 0.09615123f, 0.11784033f, -0.03330741f, -0.19654621f, 
    -0.06083631f, -0.24571992f, 0.00923199f, 0.17158258f, -0.05064685f, -0.11386698f, -0.04250215f, 0.13901845f, 
    0.17526360f, 0.15648678f, 0.07988319f, -0.03596187f, 0.17247856f, 0.12695080f, 0.07819425f, -0.00352959f, 
    -0.39225891f, -0.32726943f, 0.03274520f, 0.07353587f, -0.06294841f, -0.40035716f, -0.29647520f, -0.11433814f, 
    -0.41248631f, -0.08157725f, -0.46389061f, 0.06892856f, 0.05014464f, 0.25572327f, -0.03841112f, 0.13547759f, 
    -0.02967997f, 0.28306910f, 0.09973199f, 0.11749176f, 0.37533596f, -0.03545672f, 0.07210393f, 0.23469570f, 
    0.04317400f, 0.23763806f, 0.25918835f, 0.04509632f, 0.00127427f, -0.10008754f, -0.06701554f, 0.12129843f, 
    0.19188657f, -0.05849229f, -0.69396132f, 0.14694974f, 0.18346794f, -0.17925833f, 0.17172706f, -0.25260743f, 
    -0.65391159f, 0.07076725f, -0.19245528f, 0.03813994f, -0.14169566f, 0.16673665f, -0.05538925f, -0.32155809f, 
    -0.05576674f, -0.00036488f, -0.07001764f, 0.09621982f, -0.01729758f, -0.07734801f, -0.08696759f, 0.00400105f, 
    0.03883065f, 0.17298381f, 0.07402340f, 0.00567302f, 0.01409239f, -0.22861402f, 0.12583372f, -0.06374938f, 
    -0.18919505f, -0.14750473f, -0.09132543f, -0.10230900f, 0.11065885f, -0.18544692f, -0.06206942f, -0.09952779f, 
    -0.10350963f, 0.12321994f, 0.03098414f, 0.03808374f, 0.08038449f, -0.66017717f, 0.31767043f, 0.07581908f, 
    0.51566893f, 0.02910343f, -0.00275384f, -0.21653706f, -0.16693670f, -0.06891149f, -0.04454685f, -0.32517311f, 
    0.01592671f, -0.48288780f, -0.08510529f, 0.01445176f, 0.00405483f, -0.00574549f, 0.17455907f, -0.12851682f, 
    0.21015663f, -0.02774835f, -0.27538469f, 0.20603742f, -0.16530238f, -0.37247741f, 0.01365937f, -0.07329678f, 
    0.08306865f, 0.01391542f, -0.18458068f, 0.07040311f, -0.20285535f, 0.07068194f, -0.02544246f, -0.14533898f, 
    -0.03126405f, 0.26475325f, 0.16720062f, -0.02244532f, -0.05727972f, 0.01244230f, -0.00220589f, 0.21930948f, 
    0.12090458f, 0.08503415f, 0.00997141f, -0.07485683f, -0.10930280f, -0.09101276f, -0.04891023f, -0.10529491f, 
    0.35530382f, -0.09617420f, 0.05450089f, -0.33082503f, 0.06937227f, -0.05942824f, 0.34536862f, -0.08987873f, 
    0.21273975f, 0.09778219f, -0.15571596f, -0.03897194f, -0.10016738f, 0.12007637f, 0.18174274f, -0.53868169f, 
    -0.39702708f, 0.24082750f, 0.01159583f, 0.00112449f, -0.23286252f, 0.05580581f, -0.01778630f, 0.27056345f, 
    0.22419350f, -0.06907703f, -0.18590626f, -0.07233259f, 0.03148355f, 0.17751515f, -0.21731879f, -0.09810759f, 
    0.12551227f, 0.10502210f, -0.51588005f, -0.05541284f, 0.06755222f, -0.33869603f, 0.17380381f, 0.19790524f, 
    0.18183972f, 0.07626746f, 0.01167351f, 0.03160680f, -0.14894575f, 0.06374256f, 0.03331440f, -0.04426838f, 
    -0.07915240f, -0.24143435f, -0.19771227f, -0.31728566f, 0.14892614f, -0.05382092f, 0.07184082f, -0.04731619f, 
    -0.23574680f, -0.08814573f, -0.02255519f, -0.02672590f, -0.29135504f, 0.19540322f, -0.04862656f, -0.01980691f, 
    0.05661301f, -0.07122763f, 0.11793651f, 0.19322506f, 0.11688372f, 0.03111554f, -0.10387404f, -0.02380426f, 
    0.09665270f, -0.00051216f, 0.15270565f, -0.08813749f, -0.01929627f, 0.12113074f, 0.18894672f, 0.11366673f, 
    -0.17840332f, -0.47058034f, -0.01989446f, 0.11243101f, -0.57405573f, -0.04248759f, -0.09251723f, -0.48051611f, 
    0.05596773f, 0.02880516f, 0.13190274f, -0.05015945f, -0.01675840f, -0.18765737f, 0.20640472f, -0.05482017f, 
    0.21945731f, 0.01004731f, -0.05103628f, -0.39240801f, -0.11979918f, 0.17936826f, 0.16438502f, -0.11588607f, 
    0.17161952f, -0.12615612f, 0.05818258f, -0.33626115f, 0.23094262f, -0.06431081f, 0.08355349f, 0.25146151f, 
    -0.03819119f, -0.12944657f, 0.02652992f, -0.05179837f, 0.05793981f, 0.04762343f, -0.00193538f, -0.01091606f, 
    0.29580715f, -0.06641877f, 0.12336567f, -0.06844411f, -0.05670238f, 0.07106940f, 0.01583092f, 0.05691169f, 
    -0.17027757f, 0.11597142f, 0.06274236f, -0.04930511f, -0.09476373f, 0.52119744f, -0.10101999f, -0.18765987f, 
    -0.22101711f, 0.12618583f, 0.18538038f, -0.00869563f, 0.09593354f, -0.25888330f, -0.24745110f, 0.18114601f, 
    0.22962224f, 0.14670175f, -0.03263742f, 0.05194464f, 0.10034306f, -0.00475113f, -0.04513946f, 0.02699482f, 
    -0.01325890f, -0.29023233f, 0.20846778f, 0.02928261f, 0.02986808f, 0.26461923f, -0.26318833f, -0.09985112f, 
    0.24961363f, 0.07422293f, 0.13208911f, -0.11213109f, 0.16973759f, -0.03598813f, -0.58116692f, -0.51860291f, 
    -0.56353205f, -0.00290631f, -0.05492418f, -0.03706537f, 0.17538260f, -0.37704536f, -0.05199350f, -0.03912538f, 
    0.04786368f, 0.26427010f, -0.57845676f, 0.02466764f, -0.17243923f, 0.03189985f, -0.05199799f, -0.58041519f, 
    -0.75229692f, 0.10585754f, 0.08745421f, 0.03345593f, 0.05685419f, 0.36719018f, 0.09081051f, -0.04824241f, 
    0.06960145f, 0.15555942f, 0.00846526f, -0.19944572f, -0.05640095f, -0.55656493f, 0.33390719f, -0.05690668f, 
    0.26790613f, 0.06909627f, 0.38001066f, 0.03767758f, -0.01519587f, -0.34653947f, -0.02651202f, 0.07241350f, 
    0.26104593f, 0.20286992f, -0.03552481f, -0.45877001f, -0.11173289f, -0.11682767f, 0.04652208f, 0.23445617f, 
    -0.24455790f, 0.19624525f, -0.31363675f, 0.06936032f, -0.11960921f, -0.13749263f, -0.43955269f, -0.51165831f, 
    -0.01766469f, -0.10839990f, -0.08408048f, 0.32625982f, -0.27950460f, 0.04927115f, -0.35584351f, -0.38550034f, 
    0.00696601f, -0.07057349f, -0.29681772f, -0.29410401f, 0.16434383f, 0.10200388f, -0.10514795f, 0.40311188f, 
    0.03179588f, -0.04849298f, 0.27709725f, 0.15507478f, -0.01059492f, -0.02104373f, 0.05125919f, -0.03724013f, 
    -0.16965380f, 0.12686674f, 0.00153166f, 0.02637110f, -0.29583088f, -0.24149385f, 0.11319572f, 0.01604842f, 
    -0.27272004f, 0.15436797f, 0.09954735f, 0.12637112f, -0.03967261f, 0.27721733f, -0.02481890f, -0.04600983f, 
    0.23812212f, 0.04580756f, -0.01778277f, 0.07471933f, -0.07829755f, -0.13415626f, -0.18308310f, 0.14980640f, 
    0.18662804f, -0.28988624f, -0.00414057f, 0.10407989f, 0.17064610f, 0.00328558f, -0.03714623f, -0.28241897f, 
    -0.05338063f, 0.24309723f, 0.34606233f, -0.00245546f, -0.07598804f, -0.40476927f, 0.04210926f, 0.20465198f, 
    -0.12600896f, -0.07446269f, -0.44761148f, -0.21372926f, -0.40859455f, -0.04028589f, -0.51511091f, -0.42367932f, 
    -0.34723073f, 0.01097144f, 0.16673259f, -0.28984728f, 0.00943842f, -0.27380657f, 0.05248512f, 0.22185186f, 
    -0.08786278f, 0.19135222f, 0.24325699f, 0.16091588f, 0.30002576f, -0.00844809f, -0.04001859f, 0.19950368f, 
    -0.12417993f, -0.00702205f, -0.02985143f, -0.07543636f, -0.10653079f, -0.33266419f, 0.12679416f, 0.09061130f, 
    0.17709902f, 0.04121365f, 0.00849310f, -0.23736241f, -0.10783853f, -0.47624511f, -0.09954371f, -0.11345012f, 
    0.15113537f, -0.11172163f, -0.34808233f, -0.03829632f, 0.06784369f, -0.10163185f, -0.56220043f, -0.15252064f, 
    -0.23835428f, 0.07448208f, -0.03796340f, -0.23008339f, 0.14849219f, -0.11528211f, -0.01484181f, 0.20663153f, 
    -0.21625924f, 0.26319784f, -0.46969455f, -0.08318227f, -0.10440546f, 0.21964298f, -0.17428976f, 0.11014185f, 
    -0.19202253f, -0.04079567f, 0.11789655f, -0.05134545f, 0.27727625f, 0.18831673f, -0.26307994f, 0.18642354f, 
    0.06912739f, 0.00703518f, -0.28062627f, -0.20349674f, -0.15246043f, 0.39544529f, 0.12104247f, 0.19048104f, 
    0.09199515f, 0.07229624f, -0.40340951f, -0.15714318f, -0.46696126f, 0.01418477f, -0.06338082f, -0.58393401f, 
    0.31777823f, 0.19304988f, -0.11480374f, -0.06615417f, -0.02591285f, -0.18949914f, -0.09823224f, -0.02392540f, 
    0.10545711f, -0.06322673f, -0.12238670f, -0.22544594f, 0.00787348f, 0.39753360f, -0.45553613f, 0.15023336f, 
    0.08268970f, -0.06904174f, 0.15493740f, 0.07686321f, -0.04192879f, 0.25338900f, 0.06865096f, 0.07588606f, 
    -0.00734561f, -0.41104534f, -0.02898516f, 0.19848545f, 0.02924141f, -0.11277238f, 0.06579204f, -0.32630360f, 
    -0.22656725f, 0.28064048f, 0.31508324f, -0.12411498f, 0.06663729f, 0.05971525f, 0.13332333f, 0.09460720f, 
    -0.26037028f, -0.10821462f, -0.18798609f, -0.34878027f, 0.11709229f, -0.02591746f, -0.04049978f, 0.19772179f, 
    0.17313804f, 0.03174838f, 0.26307812f, 0.14017931f, -0.29880235f, -0.51939118f, -0.03181231f, -0.57664108f, 
    0.04498045f, -0.33539447f, 0.33751610f, 0.09389766f, -0.48907197f, -0.05217467f, -0.03780821f, -0.09258352f, 
    -0.34955287f, -0.26028392f, -0.02267223f, 0.12668745f, -0.02176853f, -0.31984687f, -0.10784872f, -0.03076598f, 
    -0.10482708f, 0.09881911f, -0.10419451f, -0.06658997f, 0.01208185f, -0.14753015f, 0.40563315f, 0.10793838f, 
    0.43494913f, -0.04806782f, 0.10644182f, 0.01313121f, -0.02452907f, -0.20638804f, 0.11995454f, -0.32377881f, 
    -0.20698509f, 0.09849847f, 0.05704157f, 0.00870400f, -0.15190938f, 0.00886029f, 0.01468447f, 0.12630673f, 
    0.10136916f, -0.62321788f, 0.10703463f, 0.07095426f, -0.02980517f, -0.18022525f, 0.13221975f, 0.16224027f, 
    -0.18279693f, 0.02442886f, 0.24991120f, 0.23558363f, -0.27907109f, -0.02680306f, -0.09760404f, 0.00192098f, 
    -0.30107826f, 0.09990042f, 0.10269342f, 0.26979324f, -0.17761950f, -0.53392148f, 0.02349137f, -0.54699165f, 
    -0.06989271f, 0.10445473f, 0.14620334f, -0.20664269f, 0.15014060f, -0.05446229f, -0.07545429f, 0.01253100f, 
    -0.36464429f, -0.02374166f, -0.03227901f, 0.00871829f, 0.31112647f, -0.11388746f, 0.04519466f, -0.06760651f, 
    0.40266794f, 0.13445623f, -0.00716024f, -0.18106581f, -0.06613221f, 0.11152716f, -0.15681249f, 0.38449734f, 
    -0.20640239f, 0.00216366f, -0.18537350f, 0.02404533f, 0.10844071f, -0.26759857f, -0.03036140f, 0.17894047f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16543715f, 0.09219526f, 0.13190690f, -0.08665866f, -0.00507806f, -0.03585547f, -0.02982322f, -0.08132481f, 
    -0.04252121f, -0.05866367f, 0.12773085f, 0.02640020f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
