#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.04558206f, 1.22302973f, -1.53983176f, 0.06299582f, 0.44103590f, -0.37232125f, 0.47344476f, -0.16029185f, 
    0.17438680f, 0.76810038f, -0.39811149f, 0.86233979f, -0.38912615f, -1.42408335f, 1.03372478f, -0.11930011f, 
    -0.37034267f, 0.41659734f, 0.48766053f, -0.00710516f, 0.48295337f, -0.74870491f, -0.95053893f, -1.18460572f, 
    -0.86831343f, 0.35008180f, 0.56565517f, 0.11348243f, 1.32557452f, -0.25486729f, 0.96673089f, -0.74580878f, 
    -0.86360729f, -0.73960823f, -0.40290499f, -0.23642664f, 1.12280679f, 0.37436369f, 0.26485404f, 0.52469641f, 
    1.22658896f, 0.85654294f, -0.61954570f, -0.51667464f, -0.16327228f, -0.80494827f, -0.42445698f, -0.90874755f, 
    0.14676058f, -0.59613073f, 0.50622475f, -0.73652458f, 0.21955651f, -0.58824426f, 0.15150255f, -1.18170750f, 
    -1.02327025f, -1.00104022f, 0.88204044f, -0.41700643f, 0.19655985f, 0.54439378f, 0.42566216f, -0.63666064f, 
    0.02617308f, -0.33916831f, 0.81232184f, 1.51273394f, 0.24253097f, 0.37408939f, -0.09380175f, -0.47434756f, 
    1.12810576f, -0.32918420f, -1.11679065f, 1.25691199f, 0.78847706f, -0.90127939f, 0.00257941f, -0.16896005f, 
    -0.41362840f, -1.13293004f, -0.59116811f, -0.44639337f, 0.82727313f, 0.52981663f, 0.53814954f, 0.80152893f, 
    0.04268643f, 0.18723799f, -1.30750358f, 0.24656163f, -1.08461368f, 0.32773811f, 1.03154254f, -1.23219514f, 
    -0.08284873f, -0.51111758f, 0.39675280f, -0.94589847f, -1.31400871f, -0.78575283f, -0.67203069f, -0.01384626f, 
    0.47123879f, -0.49651355f, -0.08037432f, -0.09827855f, -0.06199864f, -1.46061337f, -1.34677207f, 0.11725950f, 
    -0.07185519f, 0.40945920f, 0.61764622f, -0.13711193f, -0.11163645f, 0.91186446f, 1.21016467f, 0.26875779f, 
    -0.72719312f, -0.85787284f, -0.35729250f, 0.31307846f, 0.67011404f, 0.25348705f, 0.54265976f, -0.97120517f, 
    0.60187387f, 0.85830277f, -0.10748067f, -0.18932483f, 0.57624590f, 0.10501382f, 0.49918354f, -0.45992002f, 
    -0.30532801f, 0.42576420f, -0.85232878f, -0.11815410f, 1.16331685f, 0.42741382f, -0.52422398f, 0.92220694f, 
    -0.16516952f, -1.20990098f, 0.36292732f, 0.11917650f, 0.93332076f, -1.07217956f, 0.58952928f, -0.32038546f, 
    -0.67619550f, 0.92236966f, 1.02788925f, 0.50023830f, 0.01511589f, 0.90297568f, -0.85088497f, -0.10425942f, 
    -0.43917060f, 0.28964540f, -0.06361130f, 0.65441442f, 0.75701308f, -0.51620162f, -1.10786510f, -1.08347082f, 
    0.78649819f, 0.57077855f, -0.09936445f, -0.48291650f, -0.88341016f, -0.66611129f, -0.93701166f, -0.09909090f, 
    -0.85563534f, -0.89287204f, 0.75819796f, -0.51478833f, -0.51198614f, -0.33984706f, 0.09181707f, 0.68665391f, 
    0.10111805f, -1.17952240f, 0.58908242f, 0.61425817f, 0.67040205f, 1.12950730f, -1.24861372f, -0.78649545f, 
    -0.43633813f, -0.76912886f, 0.00718648f, -0.23080947f, 0.11584836f, 1.00064909f, -0.99989802f, 0.48684654f, 
    -0.88851857f, -0.25705314f, -0.60524082f, -0.64612681f, -0.44676498f, 0.79790527f, 0.20740955f, 0.13046768f, 
    -0.29874706f, 0.77164811f, 0.85182017f, 0.70681959f, 1.05641556f, -0.89058518f, 0.42371213f, -0.61976236f, 
    1.10628963f, 0.33366036f, 0.71709287f, 1.04464352f, -0.57498729f, 0.27146110f, 0.43574440f, 0.60953969f, 
    -0.43713170f, 1.27250969f, 0.86628830f, 0.68008447f, -0.94307870f, 1.04439187f, -0.03205270f, -0.02682125f, 
    0.83169788f, 0.30964181f, -1.43632030f, -0.10419856f, 0.89644331f, 1.14125192f, 0.94558305f, -0.00915188f, 
    -0.11113902f, -0.18154633f, -0.01502547f, -0.85472351f, 0.80737752f, -0.63953805f, 0.96332651f, -0.35461110f, 
    -0.01116635f, -0.37601635f, -0.82078892f, -0.64627731f, -0.68058687f, -0.98306072f, -0.37941381f, 0.54113090f, 
    -1.01826870f, -0.52699482f, -0.27077663f, -0.40214953f, -0.66562992f, -1.11134815f, -0.87770033f, -0.82454312f, 
    0.13741979f, 0.50600439f, 0.31357923f, -0.07412122f, -0.27334201f, -0.09859373f, -1.01022124f, -0.29487690f, 
    1.05242944f, 0.28213793f, -0.13605225f, -1.18282866f, 0.11005405f, 0.15587118f, 0.26207614f, 1.11232769f, 
    0.98509258f, 1.63688028f, -0.65783793f, -0.16404356f, -0.86231673f, 0.21431895f, -0.43547186f, -0.50657332f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02209982f, -0.17409593f, 0.02430343f, -0.13893341f, 0.08146677f, -0.33120209f, 0.05602423f, 0.06227633f, 
    0.28538400f, -0.08214325f, -0.14619830f, -0.06783754f, 0.06331037f, -0.09740335f, 0.05872504f, 0.46949461f, 
    -0.26205853f, 0.34270677f, 0.05815115f, 0.51210874f, 0.19625880f, -0.06303269f, 0.33403265f, 0.27044794f, 
    0.24172702f, 0.32081434f, 0.05698614f, -0.34180829f, 0.53242254f, -0.21859904f, 0.13993321f, 0.16410498f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02929884f, 0.03520315f, 0.01721181f, -0.01420439f, -0.05166173f, -0.00873269f, -0.00811950f, -0.06229844f, 
    -0.05290782f, 0.04169505f, 0.00776496f, -0.02587593f, 0.02098140f, 0.04068160f, -0.01530815f, 0.04889371f, 
    0.03903804f, -0.01857804f, 0.03256637f, 0.03818920f, -0.01630622f, 0.00050531f, 0.03621258f, 0.02849451f, 
    0.00430136f, 0.00042293f, -0.01774582f, -0.05240297f, 0.03051529f, 0.03721852f, -0.04000572f, 0.04096780f, 
    -0.00798505f, 0.03798189f, -0.05483575f, 0.00263014f, -0.00214626f, -0.01852501f, 0.00539986f, -0.03579152f, 
    -0.06076824f, -0.00611853f, 0.03723075f, -0.03419831f, -0.00064654f, -0.05025140f, -0.01896667f, 0.03295585f, 
    -0.00279149f, 0.04627018f, -0.02456672f, 0.04279086f, 0.00114992f, -0.04897494f, 0.01074071f, 0.00721255f, 
    0.03316868f, -0.00872559f, 0.02151490f, 0.00813420f, -0.03864131f, -0.01931640f, -0.05305247f, -0.00440299f, 
    -0.05150358f, -0.00053984f, -0.02765040f, 0.02370924f, 0.03103468f, -0.06717695f, -0.03080683f, -0.04435812f, 
    -0.02276476f, -0.01260716f, -0.02770511f, -0.00273122f, -0.03805103f, 0.00346389f, 0.04067728f, 0.03665797f, 
    -0.02708219f, 0.03525513f, 0.04800791f, -0.06557713f, -0.03078065f, 0.03412824f, -0.00336809f, 0.01233832f, 
    0.01046321f, -0.00158604f, -0.03019171f, -0.04535751f, -0.01588237f, -0.05468540f, -0.06219114f, -0.05503946f, 
    0.00143700f, -0.05422578f, -0.02605797f, -0.04016797f, -0.04633163f, -0.00735090f, 0.01496072f, 0.01092435f, 
    -0.05327591f, 0.02840462f, 0.03070033f, -0.02015848f, -0.05493480f, 0.01433150f, -0.05723201f, -0.05063126f, 
    -0.00799495f, 0.04852200f, 0.03553056f, -0.06004671f, 0.03017290f, 0.02174242f, -0.06621666f, -0.06166036f, 
    -0.06350555f, -0.04293390f, 0.03255457f, -0.04937495f, -0.04956094f, -0.03943668f, 0.03823975f, -0.00063798f, 
    -0.03370212f, 0.01394728f, -0.03329924f, -0.05665991f, 0.04985575f, -0.00105681f, -0.06575047f, -0.02796450f, 
    -0.01263491f, 0.00849892f, -0.05608054f, 0.02829803f, 0.03011740f, -0.00407848f, -0.05934112f, -0.06389455f, 
    -0.04240548f, -0.03940813f, 0.01901129f, 0.04835861f, -0.00545585f, -0.01675856f, 0.04843680f, 0.02662710f, 
    0.01162395f, 0.02613807f, -0.02576945f, -0.04583267f, 0.03803751f, -0.02015946f, 0.01522394f, 0.03683288f, 
    0.01979025f, 0.04660974f, -0.05064050f, -0.03305033f, -0.02367384f, -0.03298341f, -0.00917712f, -0.05438000f, 
    0.00882956f, -0.00614765f, -0.05680391f, 0.00764855f, 0.01186145f, 0.04082507f, -0.05731568f, -0.06250999f, 
    -0.05439127f, 0.04041574f, -0.00772647f, -0.04128732f, -0.00332133f, 0.04418338f, 0.02794699f, 0.03118561f, 
    0.04594942f, 0.04908793f, 0.03204893f, -0.05771855f, 0.01931698f, -0.06201810f, 0.01496491f, -0.03095900f, 
    -0.02014915f, -0.03090884f, -0.05064045f, 0.04814669f, -0.02720168f, -0.00197477f, -0.05874855f, -0.06337468f, 
    -0.03306885f, -0.02244586f, -0.05374846f, 0.04635642f, 0.02646570f, -0.04476185f, -0.03635456f, -0.03229232f, 
    -0.03070599f, -0.06499355f, -0.01441869f, -0.05624485f, 0.04075883f, -0.00363516f, -0.04735034f, -0.02857304f, 
    0.01271218f, -0.05757667f, -0.05094183f, -0.03901188f, -0.05102003f, -0.04522065f, -0.05864568f, -0.05395817f, 
    -0.01689347f, -0.05250432f, 0.00869717f, 0.00394738f, -0.04897267f, -0.04040668f, -0.00564615f, 0.00941418f, 
    -0.01502762f, -0.03193348f, -0.03088801f, 0.02016931f, 0.03013942f, 0.04464917f, 0.03334612f, 0.05048759f, 
    0.01120705f, 0.00403105f, 0.02734955f, 0.00416429f, 0.00726389f, -0.03262906f, -0.01316077f, -0.06037619f, 
    0.02909289f, -0.01493146f, 0.03761578f, 0.00461322f, 0.02121580f, 0.02889732f, 0.00094644f, -0.05429966f, 
    -0.04532835f, -0.01672268f, -0.01442432f, -0.02342630f, 0.00270102f, -0.01272534f, -0.00605518f, -0.02397648f, 
    -0.06525076f, 0.03425633f, 0.01749555f, 0.03612830f, -0.00284429f, 0.03079301f, -0.06410293f, 0.03451201f, 
    -0.03280682f, -0.04115906f, 0.02903051f, 0.03702584f, -0.05754561f, -0.00857126f, -0.06189561f, -0.02044057f, 
    0.04160367f, 0.04687198f, -0.06480333f, -0.05461559f, 0.02946160f, -0.02494048f, -0.03957847f, 0.04712793f, 
    0.02682829f, 0.05526922f, 0.00329478f, 0.01116796f, -0.06312680f, -0.05878365f, 0.04433934f, 0.04258403f, 
    -0.06097041f, -0.03272198f, 0.01147261f, 0.04088569f, 0.04560990f, -0.03007787f, -0.01072577f, 0.02061962f, 
    -0.02879812f, -0.03845392f, 0.00949130f, -0.05647748f, -0.03285115f, 0.03034965f, 0.01064916f, 0.04729202f, 
    0.03506103f, -0.02773570f, 0.01761856f, 0.01738030f, -0.01749454f, -0.04514712f, -0.06365386f, 0.02736524f, 
    0.04828886f, -0.00733878f, -0.05618871f, 0.05071514f, 0.01052081f, 0.02522897f, -0.01542134f, -0.05470128f, 
    0.02202211f, 0.03770381f, -0.00894505f, -0.01834667f, 0.02293650f, -0.05795872f, 0.03510260f, -0.04614209f, 
    -0.01242941f, 0.04344141f, -0.04006627f, 0.04478319f, -0.00322635f, -0.00123983f, 0.02739144f, -0.02808622f, 
    -0.02134554f, -0.00074728f, -0.04296543f, 0.00096127f, 0.04241926f, 0.01045567f, -0.02417942f, -0.03840262f, 
    -0.00543628f, -0.04299141f, -0.06167937f, -0.04141974f, -0.03595630f, 0.02905134f, 0.00265915f, -0.03529324f, 
    -0.05084008f, -0.00228808f, -0.02321137f, -0.03308091f, 0.00395651f, 0.04457805f, -0.01988209f, -0.05964265f, 
    -0.05682952f, 0.00464411f, 0.02201231f, 0.01032152f, -0.01978121f, -0.05138174f, -0.01245232f, -0.05459746f, 
    -0.02217541f, -0.00078767f, 0.00602781f, -0.03779000f, 0.02444350f, 0.04286012f, -0.04685383f, -0.01221638f, 
    0.04213110f, 0.01328220f, 0.04322130f, 0.03995426f, -0.05641017f, 0.05815255f, 0.03727529f, -0.06103241f, 
    -0.01388643f, -0.05530923f, -0.06255288f, 0.01699049f, 0.04189093f, 0.03635086f, -0.03333299f, 0.00244290f, 
    0.02391662f, -0.00935667f, -0.05234995f, 0.03154787f, 0.01739557f, 0.01619012f, -0.02470392f, 0.01439882f, 
    -0.03913933f, -0.04247555f, 0.03023507f, -0.00252076f, 0.01204384f, -0.00550732f, -0.01978439f, 0.03607371f, 
    -0.01673064f, 0.04149429f, -0.04094705f, -0.06070764f, 0.04753593f, -0.03301951f, 0.02680721f, -0.00819358f, 
    -0.02855006f, -0.01267204f, -0.02345208f, -0.05198048f, -0.01815640f, 0.00366742f, 0.00546503f, -0.05040331f, 
    -0.04847721f, -0.01434060f, 0.02632269f, 0.02961233f, 0.00147661f, -0.02642852f, -0.00119238f, 0.01407197f, 
    -0.00949340f, 0.03388787f, 0.03355085f, -0.04812016f, 0.00628439f, -0.03814545f, -0.01643706f, -0.02912271f, 
    -0.04232948f, -0.03037081f, -0.06323566f, 0.00103182f, 0.01101821f, 0.04778496f, -0.03155208f, 0.03014187f, 
    0.02985115f, -0.05984233f, -0.00471387f, 0.02646255f, -0.00972185f, -0.05371967f, -0.00174313f, -0.00616556f, 
    0.04377838f, 0.04597166f, -0.00407061f, -0.02202874f, -0.01278238f, -0.03887960f, 0.02581776f, -0.06048962f, 
    -0.01667523f, -0.05593098f, -0.02933190f, 0.02391017f, 0.03523235f, 0.00923585f, -0.03078165f, -0.03689661f, 
    0.03664653f, -0.01031012f, -0.06564716f, 0.02636783f, -0.00264447f, -0.03456052f, 0.03052363f, -0.00072330f, 
    0.00713049f, 0.00695620f, 0.04441237f, 0.01434782f, -0.01931441f, -0.00509669f, -0.06024878f, -0.04454054f, 
    0.00455649f, 0.03412581f, 0.01073836f, 0.03853497f, 0.01037298f, -0.03659607f, 0.01560010f, -0.00490320f, 
    0.01358198f, -0.01623555f, -0.03268615f, -0.05994142f, 0.04753089f, 0.02275108f, 0.01064419f, -0.00955856f, 
    0.00103898f, -0.06480572f, 0.03999118f, 0.03777683f, 0.03824160f, 0.03885625f, 0.00128007f, 0.03756909f, 
    -0.02191955f, -0.01343393f, 0.02730518f, 0.04722312f, -0.03510247f, -0.03686120f, 0.00520557f, -0.02432743f, 
    -0.04578934f, -0.00311034f, -0.00946330f, -0.02771416f, 0.01303129f, 0.01062793f, -0.04531559f, -0.05911936f, 
    0.02819051f, 0.03577972f, -0.06439597f, 0.01848318f, -0.06312760f, -0.03471150f, -0.03471714f, 0.00524840f, 
    -0.02975940f, 0.01797386f, -0.01089897f, 0.05225251f, 0.05273082f, 0.02613375f, -0.06387386f, 0.04488106f, 
    0.03799470f, 0.00782853f, 0.03371058f, -0.05250707f, -0.03284438f, -0.06744730f, -0.05195497f, -0.03339990f, 
    0.02431753f, -0.03828590f, 0.01165369f, -0.02615909f, 0.02371321f, 0.01151404f, -0.05735608f, -0.02507230f, 
    0.01707053f, -0.00885421f, -0.04502951f, -0.03384672f, -0.06372326f, -0.00867327f, 0.04597377f, 0.00009525f, 
    -0.19656363f, 0.09687102f, 0.46232656f, -0.54415148f, 0.01097716f, 0.01852095f, 0.05602658f, -0.07968816f, 
    0.02858407f, -0.15876377f, -0.05478558f, -0.34213039f, -0.11414421f, -0.04211695f, 0.05814212f, -0.20032427f, 
    0.24211501f, 0.01267731f, 0.24624234f, 0.15230498f, -0.19818860f, -0.17905997f, -0.04531018f, -0.09168284f, 
    0.00531713f, 0.00117480f, 0.21879523f, -0.06590836f, 0.17455173f, 0.53205830f, -0.12994717f, -0.04335424f, 
    -0.16520591f, 0.49907765f, 0.12384562f, 0.00567802f, 0.01051059f, 0.08188747f, -0.19824824f, 0.05747935f, 
    0.31204766f, -0.05808168f, 0.15633237f, -0.03201718f, -0.11496047f, -0.12565880f, 0.06972820f, -0.18001282f, 
    0.22846417f, 0.11698778f, 0.05361538f, 0.15168209f, 0.02091167f, 0.19542992f, -0.65291554f, 0.02225239f, 
    -0.02827479f, -0.03732986f, 0.00426211f, 0.00067070f, -0.19335763f, 0.00464374f, -0.05679603f, 0.29879791f, 
    0.24983649f, -0.08780695f, 0.28680825f, 0.21614210f, 0.20545794f, -0.01362390f, -0.26263130f, -0.01414482f, 
    0.00481651f, -0.18840235f, -0.00570654f, -0.18174286f, 0.05088826f, 0.15851015f, 0.14656508f, 0.14661045f, 
    -0.04297442f, -0.32796735f, -0.16169174f, -0.17846277f, 0.16733725f, 0.19326262f, 0.34468874f, 0.01267015f, 
    -0.18923688f, -0.18329796f, 0.52842957f, 0.02430556f, -0.15189765f, 0.09407932f, -0.19062021f, -0.21760763f, 
    0.05063162f, -0.10670517f, -0.12777430f, -0.46923640f, 0.30050942f, -0.38839662f, 0.04550910f, 0.09723561f, 
    -0.01703863f, 0.00548946f, 0.10888782f, 0.02050302f, -0.39566681f, -0.12027782f, -0.29632798f, 0.10073515f, 
    0.26887292f, -0.09814590f, 0.04847385f, 0.06719748f, -0.15071213f, 0.35846364f, 0.50818968f, 0.04345897f, 
    -0.20019116f, -0.02857732f, -0.01310371f, -0.24276248f, -0.11043654f, 0.09985914f, 0.01990012f, -0.10046558f, 
    0.01731471f, -0.01147381f, 0.10937022f, -0.03751890f, 0.01637281f, -0.07164201f, 0.09046587f, -0.41228673f, 
    -0.13174179f, -0.29699874f, -0.05638535f, 0.16065696f, 0.11168029f, 0.07828557f, -0.04439792f, -0.05751470f, 
    -0.24618384f, -0.12788631f, -0.53238273f, -0.13144408f, 0.19159453f, -0.01308578f, 0.07277679f, 0.05970561f, 
    0.06291386f, -0.08196913f, 0.16015849f, 0.13544191f, 0.00720568f, 0.20704551f, -0.01645197f, 0.18763247f, 
    0.08256192f, 0.04666513f, 0.07517919f, 0.23814763f, -0.08032445f, 0.07656565f, -0.04353572f, -0.22664288f, 
    -0.14558344f, 0.04046507f, 0.11835265f, -0.23926197f, -0.11149050f, 0.03266643f, 0.10806639f, 0.01075892f, 
    0.12960847f, -0.08554690f, 0.06919507f, 0.24806440f, -0.06091298f, -0.10626619f, -0.15955098f, 0.06367354f, 
    -0.02408354f, -0.15829395f, -0.06064590f, 0.29743835f, 0.23292109f, -0.31540939f, -0.48250434f, 0.18123804f, 
    0.01468995f, -0.09051451f, -0.16321295f, -0.02221260f, -0.09730569f, 0.32285750f, -0.39239880f, -0.01538722f, 
    0.07674059f, 0.03144266f, -0.00128590f, -0.23127110f, -0.02681474f, 0.15550908f, 0.15472834f, 0.08849691f, 
    0.23317862f, 0.03154712f, 0.15408644f, -0.05005950f, 0.03464019f, 0.02762866f, -0.16610979f, -0.18928243f, 
    0.00912979f, 0.03846429f, 0.25224811f, 0.02545037f, 0.23268880f, -0.04538821f, 0.17702082f, 0.00870127f, 
    -0.29330245f, -0.04261108f, 0.11821471f, -0.23100454f, 0.03608400f, 0.06206314f, 0.01562850f, 0.06512741f, 
    -0.18395525f, 0.00491622f, 0.01634137f, 0.03878295f, 0.51674330f, 0.07133558f, -0.05091340f, 0.10767606f, 
    -0.00934447f, -0.18926650f, -0.03324196f, 0.23781911f, 0.14942181f, 0.37041405f, 0.19631699f, -0.14049727f, 
    0.10263953f, 0.11671329f, 0.09887739f, -0.01614061f, -0.33518472f, -0.16006951f, -0.09355223f, 0.20635578f, 
    0.09400798f, 0.00389616f, 0.25444630f, -0.00518773f, 0.07220437f, -0.17046374f, 0.26287198f, -0.38468993f, 
    0.15583614f, 0.13314621f, 0.11566111f, 0.27875280f, -0.20504491f, 0.02644659f, -0.24225815f, -0.02330588f, 
    -0.05283590f, 0.08284152f, 0.06888400f, -0.24939765f, -0.04508307f, 0.27312160f, -0.00228253f, -0.07166152f, 
    0.17023818f, 0.17831293f, -0.19797942f, 0.12963705f, -0.02593392f, -0.04097948f, -0.00009650f, -0.03023246f, 
    -0.27230942f, 0.29040504f, -0.06218918f, 0.17275484f, -0.19826278f, -0.02127316f, -0.29523712f, 0.09542228f, 
    0.04875095f, 0.59308916f, -0.65599823f, 0.30757889f, -0.07501142f, 0.18868594f, -0.05778968f, -0.05085688f, 
    0.19004293f, 0.02890901f, 0.26711142f, -0.12536678f, 0.14839877f, 0.06327096f, -0.19483186f, 0.11390882f, 
    0.10569385f, -0.18458790f, 0.01001975f, 0.64252269f, 0.02087249f, -0.08803836f, -0.08613218f, -0.23356140f, 
    -0.13394409f, -0.05342758f, 0.23796481f, 0.03754345f, -0.38820970f, -0.38448778f, -0.07625481f, 0.12425957f, 
    0.00263954f, -0.10412491f, 0.19101870f, 0.08392117f, -0.18402448f, 0.25793144f, 0.08091064f, 0.32181051f, 
    -0.22328138f, 0.11383801f, 0.09588981f, 0.00805742f, -0.03892032f, -0.01125714f, -0.30569518f, 0.05670667f, 
    0.20821185f, -0.08890706f, -0.02685143f, -0.12393887f, 0.08081685f, -0.07308926f, -0.17424540f, 0.30903727f, 
    0.40860313f, -0.08108835f, 0.11810424f, -0.06440875f, 0.15004458f, 0.08119372f, 0.25723511f, 0.17282365f, 
    -0.00474446f, 0.12290026f, -0.38643017f, -0.03174351f, 0.10267469f, 0.06751961f, 0.23567197f, 0.19469072f, 
    0.12990561f, 0.11770220f, 0.13473020f, 0.07944121f, 0.01470702f, 0.07668159f, 0.20909840f, -0.02668927f, 
    0.09067503f, 0.00395657f, 0.15176570f, 0.27429813f, 0.00919763f, -0.05491356f, -0.27011773f, 0.14109145f, 
    0.00455670f, 0.12955584f, 0.35535419f, 0.02823295f, -0.11210886f, 0.10473542f, 0.26770633f, -0.21039334f, 
    0.00490254f, 0.16422813f, -0.13856617f, 0.00419500f, -0.13793023f, 0.05714801f, -0.05707695f, 0.01153312f, 
    0.07785864f, -0.05471922f, -0.05778309f, -0.11479782f, 0.15005170f, -0.45579991f, -0.09367906f, -0.12628464f, 
    0.05081305f, -0.10716809f, 0.01473844f, -0.19619851f, 0.08027175f, 0.12643321f, -0.15342097f, 0.10415055f, 
    -0.22038551f, 0.04156273f, -0.16002688f, -0.29087529f, -0.18357359f, 0.02640381f, -0.04819787f, -0.07349078f, 
    -0.21965337f, -0.08785726f, -0.12708923f, -0.09672471f, 0.11543051f, 0.01909575f, 0.25474694f, -0.06178771f, 
    0.25309139f, 0.12822919f, -0.01614838f, -0.09897792f, -0.21127951f, 0.01908453f, 0.15218708f, -0.00979726f, 
    -0.04518591f, -0.31430629f, 0.14084093f, 0.15834898f, -0.16372846f, 0.09394100f, 0.05839517f, 0.01640396f, 
    -0.03210386f, -0.11131620f, 0.04377076f, -0.11226139f, -0.38822898f, 0.10496581f, -0.07646418f, -0.22319105f, 
    -0.14383639f, 0.19095781f, -0.00547286f, -0.01837740f, 0.04877399f, 0.22097562f, 0.21430938f, 0.07185841f, 
    0.06131990f, -0.07692839f, -0.17855126f, 0.05556472f, 0.06449797f, 0.18267721f, -0.17331322f, -0.05138494f, 
    -0.05201065f, 0.04745675f, -0.12002413f, -0.02788406f, -0.21355511f, 0.26850337f, 0.57289666f, 0.06231557f, 
    0.05823079f, -0.32809252f, -0.11983813f, -0.20485049f, -0.02812865f, 0.03812665f, 0.27114683f, 0.01939100f, 
    0.03511780f, -0.17213365f, -0.18539864f, -0.19997475f, 0.03446562f, -0.06635980f, -0.04030466f, -0.06592723f, 
    0.00737568f, 0.06600911f, 0.14891484f, 0.15396109f, 0.05139422f, 0.19566514f, 0.21549794f, -0.06919903f, 
    -0.31578293f, -0.16859825f, -0.05148299f, -0.00425893f, 0.03570828f, -0.01098099f, -0.09588132f, -0.09768708f, 
    -0.15504910f, -0.66186535f, -0.29444134f, -0.08623564f, -0.08795153f, 0.03860170f, 0.15590434f, 0.04602583f, 
    0.09840570f, -0.14118896f, 0.11987662f, 0.23910201f, -0.24034384f, -0.00254786f, -0.15130022f, 0.06598606f, 
    0.13272935f, 0.05043432f, 0.02200963f, 0.54680163f, -0.09788211f, 0.03324648f, -0.06204396f, 0.30452868f, 
    0.20974748f, -0.01001037f, 0.05355429f, -0.00269526f, 0.21783499f, 0.01631707f, 0.15843323f, 0.08968011f, 
    0.07743333f, -0.07287373f, 0.13744202f, 0.08315740f, -0.10425618f, 0.09408411f, 0.13949549f, 0.06142108f, 
    0.19041628f, 0.01131730f, 0.27145284f, -0.06192660f, 0.15309842f, 0.08858668f, 0.21819392f, 0.02896170f, 
    -0.19927374f, 0.02544832f, -0.22043441f, -0.04276415f, 0.08728835f, -0.02384799f, 0.07383856f, -0.65924579f, 
    -0.32483870f, 0.28082344f, -0.23297304f, 0.15920703f, 0.12534450f, -0.02146935f, -0.23609182f, 0.09150410f, 
    0.02077997f, 0.00396790f, -0.02246533f, -0.02694593f, -0.04322135f, -0.03693413f, 0.00048710f, -0.06308207f, 
    0.01703457f, 0.03483574f, -0.05378170f, -0.01132180f, 0.04174438f, -0.04208363f, -0.01672174f, 0.02130137f, 
    -0.04474175f, 0.01282679f, -0.02456285f, 0.02681672f, -0.02759665f, 0.03751652f, -0.00639357f, -0.03798425f, 
    -0.04418371f, -0.00084550f, -0.03877692f, 0.03625891f, -0.01823729f, -0.06053073f, -0.04412536f, -0.01690657f, 
    -0.05844098f, -0.06247566f, 0.01307494f, 0.04665913f, -0.05905849f, 0.00870445f, -0.03188036f, 0.01278081f, 
    -0.02411539f, -0.02497065f, -0.00942882f, 0.01178613f, -0.00783423f, -0.06172486f, 0.02486609f, 0.01775331f, 
    0.03831024f, 0.01783356f, 0.01742780f, -0.05298850f, 0.00146660f, -0.00643063f, 0.02766610f, -0.06395647f, 
    -0.00537311f, 0.00456087f, -0.06548458f, 0.03487020f, -0.03665889f, -0.03480187f, 0.00512286f, 0.03259098f, 
    0.01468062f, -0.03376004f, -0.00510835f, 0.01667891f, 0.02561756f, 0.04406868f, -0.02031393f, -0.00415983f, 
    -0.03842968f, -0.06530064f, 0.01811211f, 0.04742613f, -0.05713119f, -0.05828326f, 0.04522416f, 0.02423347f, 
    -0.03488828f, -0.02741184f, 0.03381620f, -0.05647508f, -0.04174320f, 0.02302935f, -0.05251402f, 0.03181629f, 
    0.04883892f, -0.01459217f, -0.00787407f, -0.02602013f, -0.00794253f, -0.05573627f, -0.02006654f, -0.02927158f, 
    -0.06368244f, -0.00221465f, -0.04746940f, 0.01402531f, -0.01105190f, 0.00013037f, -0.03576513f, 0.01483524f, 
    0.03630399f, 0.04067296f, -0.03734552f, 0.04133804f, 0.00926548f, 0.04380132f, -0.01071393f, 0.00916428f, 
    -0.04181278f, -0.01524919f, -0.01386686f, -0.04092192f, 0.03016355f, 0.03453886f, -0.04450296f, 0.00022736f, 
    0.01363906f, -0.01017873f, -0.06556915f, 0.04323105f, -0.05609041f, -0.02412675f, -0.02044790f, -0.05806544f, 
    0.01968268f, 0.02918059f, -0.04030357f, -0.00502284f, -0.03778807f, -0.01785066f, -0.00875562f, -0.03086659f, 
    -0.06455841f, -0.02502980f, -0.00868365f, -0.00964773f, -0.03349756f, -0.03141916f, 0.03371377f, -0.01732612f, 
    0.02929090f, -0.00959703f, 0.04762713f, -0.05672400f, 0.03135848f, 0.02189366f, -0.06570588f, 0.01375025f, 
    -0.03657185f, -0.02955310f, -0.02821643f, -0.05557267f, 0.00148005f, -0.05812803f, -0.02510563f, -0.05285588f, 
    -0.01722105f, 0.04706663f, -0.01452488f, 0.01663267f, -0.05748181f, -0.06195439f, 0.02025588f, 0.04978816f, 
    -0.00141724f, -0.01840378f, -0.02214926f, -0.04560602f, 0.04417290f, 0.03331172f, 0.02858016f, -0.04111027f, 
    -0.04174741f, 0.03652007f, 0.01698464f, 0.04732354f, -0.01603750f, -0.00634308f, -0.02818741f, 0.02896573f, 
    -0.03751245f, 0.01347236f, -0.06406306f, 0.03045545f, 0.01668749f, 0.01908719f, -0.02275554f, 0.03326252f, 
    -0.04790418f, -0.03255675f, 0.01144474f, 0.01362042f, -0.02767078f, -0.05294582f, -0.00658418f, 0.02814780f, 
    0.04404291f, -0.04102839f, 0.00123998f, -0.05148827f, -0.04915266f, -0.02183380f, 0.03716934f, -0.04594285f, 
    -0.04081554f, -0.00622599f, 0.02311966f, -0.06535088f, 0.00124963f, -0.00467102f, 0.02326713f, 0.01767316f, 
    -0.00165188f, -0.06517404f, 0.00021881f, 0.01426381f, -0.03775349f, 0.02140694f, -0.03537887f, 0.01827521f, 
    0.01402618f, -0.03539774f, 0.00531196f, 0.03297911f, -0.05808188f, 0.04585470f, -0.01405847f, -0.05572920f, 
    0.04553775f, 0.05143142f, 0.04191365f, 0.01983964f, 0.00511390f, -0.00696201f, -0.02416701f, -0.01470236f, 
    -0.00170271f, -0.05653699f, 0.03189804f, -0.00064042f, 0.03575533f, 0.01537517f, -0.04511051f, 0.01773934f, 
    0.01956878f, -0.06360833f, 0.04114077f, 0.01467235f, -0.03577201f, -0.04330093f, -0.04374449f, -0.03299537f, 
    0.00975852f, -0.06515602f, -0.03370830f, -0.03050480f, 0.03490888f, -0.06431766f, -0.00551820f, 0.03636972f, 
    -0.03433696f, -0.04119308f, -0.00621662f, 0.03099410f, 0.01581908f, 0.00942526f, -0.06652435f, -0.04147669f, 
    0.00512221f, 0.01630004f, 0.02098824f, -0.02169622f, 0.00643928f, 0.01122573f, 0.01305449f, 0.01498144f, 
    -0.02860512f, -0.01841808f, 0.02015378f, -0.03779379f, 0.03715521f, 0.00356755f, 0.04649248f, 0.02076657f, 
    0.46534541f, 0.10637983f, -0.09825852f, 0.04374954f, 0.05282606f, 0.08359198f, 0.07320342f, 0.01014115f, 
    0.03035580f, -0.35586330f, 0.02472024f, -0.27344677f, -0.05165504f, -0.19000255f, 0.25534403f, -0.00994791f, 
    -0.05367361f, 0.24241646f, -0.18420996f, -0.13000371f, -0.24831919f, 0.00667528f, 0.09820245f, -0.10087661f, 
    -0.00601917f, 0.07922588f, 0.14329422f, 0.25352657f, -0.32896551f, -0.07245208f, -0.00076009f, 0.43517414f, 
    0.02956195f, -0.17347868f, -0.06714772f, 0.16522774f, -0.36713415f, -0.20498443f, 0.10133618f, 0.09567755f, 
    0.03994250f, -0.00867290f, -0.28073218f, 0.08940954f, 0.24956219f, 0.18316424f, 0.26356950f, 0.11619888f, 
    0.02332363f, -0.01797692f, 0.10328308f, 0.11712392f, 0.09078370f, -0.08427227f, 0.34004000f, 0.04583829f, 
    -0.05538084f, -0.05906896f, 0.35859412f, -0.08018667f, -0.00591880f, -0.10410687f, -0.10773689f, 0.50320786f, 
    0.13111395f, -0.01303696f, -0.22339329f, -0.20387526f, -0.08839089f, 0.02774418f, -0.21193670f, -0.18551032f, 
    -0.23379043f, -0.22260436f, 0.16902576f, -0.03519560f, -0.04625998f, -0.00672628f, -0.05182309f, -0.07217547f, 
    -0.16297592f, 0.14551650f, 0.35520354f, 0.36582530f, -0.18746394f, 0.06772321f, 0.05149345f, 0.18868758f, 
    0.13030538f, 0.07935779f, 0.15551664f, -0.02971416f, -0.21975845f, -0.18492503f, -0.04282152f, 0.01535475f, 
    -0.05798928f, 0.00035681f, -0.04925546f, 0.30852312f, 0.28091264f, -0.29815722f, -0.20901103f, 0.08347251f, 
    -0.03886739f, -0.00368320f, 0.01506014f, 0.15280405f, 0.09473860f, 0.15762089f, -0.02289789f, -0.20357162f, 
    -0.02900984f, -0.22501759f, 0.02030318f, 0.11873018f, -0.09509664f, 0.35131398f, 0.23109061f, 0.25517216f, 
    0.10916501f, -0.00414616f, 0.21143788f, 0.14109355f, 0.05236764f, -0.05577638f, -0.46673867f, -0.05929536f, 
    0.15702054f, -0.12635146f, -0.03573221f, -0.27999097f, 0.14284848f, 0.08919521f, 0.16014279f, -0.02085637f, 
    -0.02835451f, -0.21350312f, 0.02523043f, 0.01779450f, 0.02806576f, -0.12660368f, 0.00684104f, 0.09372807f, 
    0.02484687f, 0.18320043f, -0.33146289f, 0.08640426f, 0.13621607f, 0.00906177f, 0.23090890f, 0.12123353f, 
    0.09103926f, 0.05759777f, -0.14946492f, -0.21467300f, -0.00775774f, 0.07064997f, 0.09394168f, -0.09436283f, 
    0.10052411f, 0.04418767f, 0.20174786f, -0.05011844f, 0.06430325f, 0.07592078f, 0.06572811f, 0.13343473f, 
    0.16172418f, -0.05241385f, -0.21774757f, 0.05305449f, 0.07311592f, -0.32890826f, -0.24444969f, -0.06162097f, 
    0.01014670f, 0.03568294f, -0.17171073f, -0.27602088f, 0.25902492f, 0.04145540f, -0.03624018f, -0.16678712f, 
    0.01128575f, -0.04438398f, 0.04766715f, 0.11181972f, -0.10792132f, 0.18824266f, 0.21438436f, -0.20947945f, 
    0.27490145f, -0.11351483f, 0.09678984f, 0.01005825f, -0.12208038f, -0.30788681f, -0.14462146f, -0.19020076f, 
    -0.22816123f, -0.07979292f, -0.02562104f, 0.04938208f, 0.04511242f, -0.17220832f, -0.13225052f, -0.10598252f, 
    -0.13284677f, -0.10736655f, -0.00638394f, 0.00536057f, 0.06677210f, -0.07533552f, -0.01013504f, 0.09677780f, 
    -0.32412887f, -0.11292853f, -0.04039746f, -0.20483145f, 0.44029868f, 0.10611033f, -0.04492169f, 0.00494732f, 
    0.28253850f, -0.07523560f, 0.06739763f, -0.14071712f, 0.16374204f, -0.06736948f, 0.18558650f, -0.17011997f, 
    0.02676351f, -0.06542913f, 0.29395387f, 0.04869740f, 0.18491381f, -0.06883463f, 0.02843332f, -0.06956214f, 
    -0.07673920f, -0.00897591f, 0.06786309f, 0.06527104f, -0.07772517f, 0.20429929f, 0.10759194f, 0.28029600f, 
    0.06071613f, -0.28757074f, 0.21786608f, 0.23879202f, -0.10275100f, 0.02987197f, 0.27679491f, -0.03187910f, 
    -0.11656083f, 0.00159851f, -0.09043074f, -0.08313669f, -0.10467251f, 0.15380931f, 0.37707403f, 0.03262367f, 
    -0.10733037f, 0.20695274f, -0.09446152f, 0.17913176f, 0.07633422f, 0.18805341f, -0.04118825f, -0.23710258f, 
    -0.12518004f, -0.02429707f, 0.11260234f, -0.16581051f, -0.04385431f, -0.10016927f, -0.13569395f, 0.01213013f, 
    0.27143425f, -0.25722665f, -0.11984307f, 0.14625148f, 0.15675503f, -0.05042331f, -0.21877690f, 0.00892879f, 
    -0.05057864f, -0.03872348f, 0.00161455f, -0.00160061f, 0.03739450f, -0.04973356f, 0.01875897f, -0.06793334f, 
    0.01063237f, -0.03151205f, 0.02427009f, -0.05342548f, -0.05932969f, 0.00107414f, -0.09623344f, -0.00041896f, 
    0.00995175f, 0.00811304f, -0.03009404f, -0.01029239f, -0.01101715f, 0.02488400f, -0.07869267f, -0.05734783f, 
    -0.09726939f, -0.08887509f, -0.02746074f, 0.02222032f, -0.09047447f, -0.05831083f, -0.09544707f, -0.06929049f, 
    -0.06268205f, 0.00330134f, -0.03362260f, 0.02255420f, -0.02911130f, 0.02554969f, 0.01303100f, -0.03455594f, 
    -0.05138608f, -0.04310093f, -0.00389681f, -0.04745218f, -0.09208192f, -0.01305120f, -0.01508954f, -0.00775752f, 
    -0.04347670f, -0.09173550f, -0.01804445f, -0.04480608f, -0.03477966f, 0.01297039f, 0.02044636f, -0.07007903f, 
    -0.02537092f, -0.00393070f, -0.01905435f, -0.08097840f, -0.02261645f, -0.02751242f, 0.01591943f, -0.01350171f, 
    -0.04010594f, 0.00522485f, -0.01605491f, 0.02345103f, -0.04472347f, -0.08870495f, -0.01545575f, -0.05024668f, 
    0.01667874f, -0.06410083f, -0.02274733f, -0.04170184f, 0.01240166f, 0.00779452f, -0.06164839f, 0.03518863f, 
    -0.06901322f, 0.01926901f, -0.00548886f, 0.00226459f, -0.06261822f, -0.00701828f, -0.07323021f, -0.11646220f, 
    0.01292291f, -0.02360500f, -0.06981936f, -0.05936611f, -0.10230190f, 0.00196361f, 0.00887405f, -0.01202301f, 
    -0.06022729f, -0.03726226f, -0.03277806f, -0.02973738f, -0.01829105f, -0.05023256f, -0.08715915f, -0.04323779f, 
    -0.00825145f, -0.01619112f, -0.00763819f, -0.05613809f, 0.03499701f, -0.03059202f, -0.04194677f, -0.08237503f, 
    -0.08033515f, -0.05621149f, -0.07231227f, 0.01211397f, -0.06956195f, -0.03592164f, 0.00105760f, -0.05795161f, 
    -0.06497934f, 0.00422441f, -0.03594032f, 0.03737906f, 0.00461672f, 0.02223168f, -0.07692214f, 0.01520526f, 
    -0.01715690f, -0.02760917f, 0.01241620f, -0.08088564f, -0.01995804f, -0.03022987f, -0.02654458f, -0.06060779f, 
    0.02725349f, -0.01281230f, -0.01605839f, 0.00134757f, -0.06815327f, -0.05322988f, -0.00199026f, -0.03364813f, 
    -0.04378731f, -0.02562426f, 0.00257183f, 0.02230844f, -0.06520903f, -0.03884010f, -0.02117610f, -0.08456268f, 
    -0.05253379f, -0.05627091f, -0.06526236f, -0.07489064f, -0.05903021f, 0.00294618f, -0.08590759f, 0.01044521f, 
    0.02798511f, 0.01478333f, 0.00177651f, -0.00599779f, -0.04910740f, -0.07799188f, -0.01209590f, -0.01324428f, 
    -0.05859227f, 0.00865871f, 0.02582161f, -0.05748884f, -0.07727710f, -0.04450784f, -0.09073694f, 0.01930305f, 
    -0.03692823f, -0.10724894f, -0.01478366f, -0.07820102f, -0.01900186f, 0.02013236f, -0.00881201f, 0.00578824f, 
    -0.04863950f, -0.03046252f, -0.03342561f, -0.02269122f, -0.00179236f, -0.05552062f, 0.01955735f, -0.10384834f, 
    0.03491892f, -0.10404700f, -0.06162168f, 0.00787918f, -0.00121039f, -0.00657991f, -0.01168272f, 0.02651071f, 
    -0.04673688f, -0.04207908f, -0.02533475f, 0.00487099f, -0.03246190f, -0.08000655f, 0.01618984f, -0.03891073f, 
    0.02188373f, -0.04172511f, 0.01941503f, -0.01514726f, -0.01509356f, 0.00876750f, -0.06746210f, -0.07568940f, 
    -0.00467208f, -0.07312228f, -0.02171113f, -0.01977666f, -0.01156005f, -0.06275119f, -0.02873163f, 0.00960072f, 
    0.01460285f, -0.01910576f, -0.06595712f, -0.00529259f, -0.02362619f, -0.02388439f, -0.04052634f, 0.01900541f, 
    0.01063815f, -0.03776373f, 0.03753956f, -0.08383349f, -0.05431159f, 0.00432996f, -0.00939319f, 0.00074669f, 
    -0.02372213f, -0.06597917f, 0.01005006f, 0.00812675f, -0.01198502f, 0.00567768f, -0.04805339f, 0.00152621f, 
    -0.00912835f, -0.03674838f, -0.04482182f, -0.03651759f, -0.01226338f, -0.02981464f, -0.07234402f, -0.07946585f, 
    -0.07188606f, -0.04397294f, -0.06954081f, 0.01402935f, -0.00831660f, -0.05907310f, -0.02267937f, -0.08227080f, 
    -0.10459001f, 0.01228620f, 0.01229986f, -0.07613581f, 0.00054877f, -0.00878025f, -0.00475155f, -0.05406082f, 
    -0.01529415f, -0.02496134f, -0.07207296f, -0.08369785f, -0.05424834f, -0.02251474f, 0.00600023f, -0.06914153f, 
    -0.09818181f, 0.01462568f, -0.04034931f, 0.01896469f, -0.02871627f, 0.00337727f, 0.03284582f, -0.00452189f, 
    -0.23102613f, -0.02915714f, -0.16969344f, -0.07725404f, -0.15084380f, -0.05522927f, -0.19731659f, -0.09983607f, 
    -0.07716532f, -0.21450728f, -0.45971543f, -0.12494612f, 0.01593691f, 0.03076022f, -0.21139164f, 0.02479354f, 
    -0.02730651f, 0.04778720f, -0.37349805f, 0.03945128f, 0.30429399f, -0.21560314f, 0.01535627f, -0.25595158f, 
    -0.13033023f, -0.08743358f, 0.03353157f, 0.20039594f, 0.16692933f, 0.17383777f, -0.06418154f, 0.10758716f, 
    0.09236003f, 0.16135709f, -0.04866686f, 0.09991504f, 0.41076058f, 0.27658159f, 0.29400143f, 0.25103110f, 
    -0.08790573f, 0.05913161f, 0.20578776f, 0.18638656f, 0.12603928f, -0.07056567f, 0.14858842f, -0.12368048f, 
    0.18577175f, -0.08219580f, 0.14549777f, -0.32866740f, -0.12912972f, -0.06223864f, -0.26910457f, 0.22886892f, 
    -0.04764931f, 0.12073053f, 0.07347543f, 0.08509528f, -0.18232436f, 0.01179876f, -0.05613539f, 0.07920352f, 
    0.16222657f, -0.18218516f, 0.04423582f, 0.17265411f, 0.12666084f, 0.21157767f, 0.12500560f, -0.09597383f, 
    -0.09099094f, -0.28074896f, 0.05389548f, -0.04988671f, -0.13298815f, 0.17792404f, -0.07834075f, 0.00215735f, 
    0.14890552f, 0.08332160f, 0.42054620f, -0.23563336f, 0.39127651f, 0.06850211f, -0.01561357f, 0.03114803f, 
    0.09928887f, 0.12163439f, -0.61261058f, 0.04459312f, 0.01385408f, 0.13928925f, 0.15340948f, 0.03737535f, 
    -0.14020449f, -0.16262874f, 0.06487056f, -0.22879377f, 0.24037971f, 0.20820034f, 0.21651646f, 0.05719004f, 
    0.00020926f, 0.11876331f, -0.25819972f, 0.07696334f, -0.11695522f, 0.30147716f, 0.16816939f, 0.14549205f, 
    -0.13753138f, 0.01604429f, 0.43361542f, 0.10041752f, 0.02562499f, -0.70274019f, -0.04272745f, 0.24246019f, 
    -0.31827495f, -0.07430666f, -0.09587803f, -0.11592793f, -0.08148060f, 0.02728252f, -0.48012227f, 0.09397279f, 
    -0.30227485f, 0.18326622f, 0.07068645f, -0.15225218f, -0.22431767f, -0.03275496f, -0.19276100f, -0.03103359f, 
    -0.33023006f, -0.27568248f, -0.11047434f, -0.13784930f, -0.18267110f, -0.01610827f, 0.10772703f, -0.00161192f, 
    -0.35717627f, -0.04583881f, 0.08486814f, -0.19329256f, 0.02719051f, -0.06161376f, 0.07053711f, 0.06425752f, 
    -0.11471003f, -0.12862074f, 0.56518966f, 0.23738369f, 0.20766500f, -0.02749258f, 0.09620676f, 0.08266439f, 
    0.04450773f, 0.13853726f, -0.25076070f, -0.22699684f, 0.24972114f, -0.13569789f, 0.05060054f, -0.23169185f, 
    -0.07242665f, 0.14262310f, 0.05893643f, 0.21243216f, 0.33315232f, 0.28016165f, 0.09601483f, -0.01853997f, 
    0.08561268f, -0.17292912f, -0.11571581f, -0.07986699f, -0.38593730f, 0.04492965f, -0.15006858f, 0.18220927f, 
    0.01359456f, 0.14707740f, 0.00001814f, 0.01371401f, 0.05782658f, 0.33656329f, -0.02608052f, -0.41831782f, 
    -0.20896129f, 0.00917018f, 0.05843994f, 0.09934666f, 0.12132145f, -0.23543075f, -0.03829504f, 0.04172429f, 
    0.13950226f, 0.13675043f, 0.03506069f, -0.04853338f, -0.06144189f, -0.17292276f, -0.33256507f, -0.15089373f, 
    0.28088540f, -0.08552828f, 0.23913427f, 0.11182947f, -0.15404876f, 0.01062129f, 0.00504211f, 0.14809133f, 
    -0.34339035f, 0.10536543f, 0.15668787f, 0.08374657f, 0.25363061f, -0.19807278f, -0.09235350f, -0.10485592f, 
    -0.04046058f, -0.26458845f, 0.29511064f, 0.45496747f, 0.03651630f, 0.08540853f, 0.07192365f, 0.02704175f, 
    -0.03267486f, -0.15443364f, 0.38907361f, 0.34337044f, -0.24646002f, -0.06247803f, 0.15367197f, -0.07876346f, 
    -0.01465095f, 0.03011175f, -0.01697357f, 0.39858609f, -0.06067311f, -0.11143252f, 0.10232823f, 0.38451278f, 
    0.33531964f, 0.06419895f, -0.15125461f, -0.01395519f, -0.04597022f, 0.20877571f, 0.18364455f, 0.22096196f, 
    0.03826283f, -0.05211730f, 0.16359316f, -0.06598730f, -0.07863832f, -0.37468955f, -0.02083398f, 0.05415551f, 
    0.27945867f, 0.25076506f, 0.07540541f, -0.06226316f, -0.12454956f, 0.09370533f, -0.16385546f, -0.00445196f, 
    -0.24438012f, 0.12732407f, 0.00893843f, -0.17800048f, 0.06341503f, 0.09117690f, -0.05038672f, -0.28814775f, 
    0.10287926f, 0.39154065f, 0.16039808f, -0.07320070f, -0.20709591f, 0.25885940f, 0.12238390f, 0.30013877f, 
    0.45524910f, -0.21495652f, -0.26890820f, -0.31536928f, -0.01218272f, -0.14144312f, -0.11472068f, -0.01791721f, 
    -0.13939644f, 0.09822766f, -0.20212661f, -0.07725636f, -0.07541762f, 0.11051033f, 0.13318768f, 0.08558946f, 
    -0.18907765f, 0.06321211f, 0.17855829f, 0.08593126f, 0.17106353f, 0.01233473f, 0.02030917f, -0.00241910f, 
    0.07683619f, -0.17236781f, -0.11215071f, 0.49979225f, -0.32822752f, -0.05960038f, -0.03079088f, 0.05015136f, 
    0.09145106f, 0.01422134f, -0.20778991f, 0.04365454f, 0.02577958f, -0.01642198f, 0.06312416f, 0.00806391f, 
    0.03370759f, -0.13955154f, 0.02640128f, 0.03716496f, 0.28041399f, -0.32632855f, 0.08670115f, -0.13917890f, 
    0.02102639f, 0.06342965f, 0.12926124f, -0.12469734f, 0.21949273f, -0.05216739f, -0.00662075f, 0.07561217f, 
    -0.12381258f, 0.33523706f, -0.18434902f, -0.05835693f, 0.07139135f, -0.06410892f, -0.08736295f, -0.04470074f, 
    -0.04218887f, 0.10891673f, -0.05510034f, -0.07454760f, -0.28519145f, 0.05110879f, 0.04335934f, -0.04233862f, 
    0.29375198f, -0.05490702f, -0.44136277f, -0.34080449f, 0.13903500f, -0.31209624f, -0.06887873f, 0.13555551f, 
    0.14897446f, 0.13107237f, 0.31305161f, 0.03455724f, 0.04784027f, 0.06965366f, -0.08494280f, 0.21054943f, 
    0.28573596f, 0.15635361f, 0.06517887f, 0.17966427f, 0.38011926f, 0.04171540f, 0.14047572f, 0.05019591f, 
    -0.31205010f, 0.06776778f, -0.41088235f, 0.11312968f, 0.32664499f, -0.17708285f, -0.12347873f, -0.12364993f, 
    0.11776658f, -0.02920143f, 0.14657779f, 0.06709460f, 0.37347209f, 0.13069482f, -0.50530487f, 0.09071622f, 
    0.08830805f, 0.08071785f, -0.02735990f, 0.23746122f, 0.00139654f, 0.14284553f, -0.65994906f, 0.01100970f, 
    0.05558538f, 0.00777585f, 0.07383935f, 0.14346936f, -0.12819357f, -0.14530303f, 0.17262059f, -0.10784072f, 
    -0.30360380f, 0.13677092f, -0.02348765f, 0.28099382f, 0.03354593f, 0.29180175f, -0.06504125f, -0.28865048f, 
    0.03932351f, -0.24785715f, -0.05737380f, -0.00798517f, 0.02480379f, -0.20244174f, -0.10025722f, -0.12029203f, 
    -0.28988206f, 0.10248951f, 0.12343655f, 0.05192384f, 0.02449961f, -0.05728276f, -0.02702683f, 0.12071096f, 
    -0.04554710f, -0.37361124f, -0.38804460f, 0.04356984f, -0.08943582f, -0.11326239f, 0.23376489f, -0.04229277f, 
    -0.20683797f, 0.15424211f, 0.19854328f, -0.26621732f, -0.02787351f, 0.39950171f, -0.06541302f, 0.19878188f, 
    -0.02011899f, 0.03159937f, -0.25062230f, 0.02150079f, 0.25587493f, -0.06276095f, -0.07007873f, 0.02026345f, 
    0.14786093f, 0.03518367f, -0.00422399f, -0.12777644f, 0.04676567f, -0.02411642f, 0.28875452f, -0.18167393f, 
    0.04826497f, 0.07479797f, -0.01420373f, 0.08978889f, 0.01136015f, 0.58523726f, 0.27337995f, -0.29452500f, 
    -0.13083738f, -0.16386954f, 0.01888462f, -0.11449923f, -0.12537988f, -0.07232613f, 0.15204081f, 0.10346344f, 
    -0.00463439f, 0.02535752f, -0.11234384f, -0.05654006f, -0.10237636f, 0.12437198f, 0.03449782f, -0.05806939f, 
    -0.28417653f, -0.13478421f, 0.00506226f, 0.08506032f, -0.02576559f, -0.06780393f, 0.24239509f, -0.01983212f, 
    -0.26011476f, -0.27855632f, -0.13816959f, -0.05956645f, -0.09813011f, 0.04047586f, -0.10596541f, -0.14229897f, 
    -0.01465552f, 0.06809907f, -0.40865836f, 0.07546555f, 0.04009484f, -0.00222072f, -0.01798547f, 0.03667270f, 
    -0.18641698f, 0.11871137f, -0.47766748f, 0.03275921f, 0.20340946f, -0.18463790f, 0.04232369f, 0.01457572f, 
    -0.07901504f, 0.14184305f, 0.08283794f, 0.27675033f, 0.15324087f, -0.01914274f, 0.26785371f, 0.26847517f, 
    0.16573018f, 0.00221295f, 0.04341199f, 0.10489237f, -0.12864470f, 0.31256941f, -0.12683418f, 0.04788917f, 
    -0.00891865f, 0.20652153f, -0.03236679f, -0.07976279f, 0.04144516f, 0.36900631f, 0.48885939f, 0.10209244f, 
    -0.01062218f, 0.12226204f, -0.00967413f, -0.07845806f, 0.23538165f, 0.10422032f, -0.03766919f, 0.07671510f, 
    0.13973664f, -0.10593822f, -0.05889334f, -0.04911237f, -0.31392336f, -0.05721837f, -0.07516151f, 0.01319426f, 
    -0.51098621f, 0.32684642f, 0.05171299f, -0.06047434f, 0.13774812f, -0.15574428f, 0.06033704f, 0.00337996f, 
    -0.04821064f, 0.01797720f, -0.00514675f, -0.03328272f, 0.05398835f, -0.00322971f, -0.03743791f, -0.02500815f, 
    0.02178207f, 0.03706138f, -0.01196483f, -0.00821224f, -0.01346751f, -0.03503980f, -0.00950560f, -0.04536871f, 
    0.02392750f, -0.01807574f, 0.00200591f, 0.03337754f, 0.02864387f, -0.04906320f, -0.01016863f, -0.01235650f, 
    0.02731647f, 0.02879242f, 0.02779431f, 0.03031330f, 0.02312405f, 0.04432616f, -0.05066927f, 0.00563956f, 
    -0.04399548f, 0.01731975f, -0.06206806f, 0.01650605f, 0.01856422f, -0.02990218f, 0.02980451f, -0.06582555f, 
    -0.05805148f, 0.04947758f, 0.03716582f, 0.03250156f, -0.02931337f, 0.04547929f, -0.02091211f, -0.05775907f, 
    -0.04861056f, -0.03443199f, -0.03347079f, 0.04849033f, 0.00216522f, 0.03280307f, 0.03690389f, -0.00037515f, 
    0.00479583f, -0.04008959f, 0.03766910f, -0.00655368f, 0.02604179f, -0.00106811f, 0.03874390f, -0.04416485f, 
    -0.04872543f, 0.04866352f, 0.04915125f, -0.00821673f, 0.05790310f, -0.03727075f, -0.04681034f, 0.04759762f, 
    -0.03016284f, -0.03341625f, -0.04395159f, 0.00381764f, -0.05112008f, -0.01343565f, 0.00927189f, 0.00647780f, 
    -0.04036193f, -0.05996915f, -0.00532518f, 0.03724328f, 0.02749180f, 0.03009541f, 0.04279200f, -0.01798639f, 
    -0.04394871f, 0.02316620f, 0.03378447f, -0.03086271f, 0.02593497f, -0.01718177f, 0.04278702f, -0.02212225f, 
    -0.02858761f, 0.03525316f, -0.04930080f, -0.00578501f, 0.03942640f, 0.03658816f, -0.04757690f, -0.01390214f, 
    0.00605027f, -0.02067048f, 0.03075029f, 0.00937260f, 0.05295661f, -0.00396995f, -0.00086275f, 0.02963899f, 
    -0.02032524f, -0.06117132f, -0.04952085f, 0.02050170f, -0.01665479f, -0.04707271f, 0.01079093f, -0.03815892f, 
    -0.05889575f, -0.00833833f, 0.04787628f, 0.05820524f, 0.02290606f, -0.03680375f, 0.01449758f, -0.01860996f, 
    -0.03761453f, 0.02468238f, -0.02262707f, -0.00900757f, -0.02970670f, 0.00548359f, 0.01095901f, 0.00817244f, 
    -0.03556641f, 0.00752648f, 0.00700200f, -0.06059182f, -0.03547816f, -0.01872916f, -0.03857716f, 0.01781101f, 
    0.03691316f, -0.02295499f, -0.05358376f, -0.03780979f, -0.04931808f, -0.02798371f, -0.04117353f, -0.02446229f, 
    0.04346200f, -0.02700967f, -0.03876794f, -0.02621070f, -0.01213531f, -0.04522960f, -0.00376458f, -0.00876303f, 
    0.02790269f, 0.00187280f, -0.01972845f, -0.02518442f, 0.00171551f, -0.01161387f, 0.01733090f, -0.06157444f, 
    -0.02737338f, -0.00860693f, 0.04777609f, -0.06688470f, 0.04023337f, -0.00580589f, 0.03239218f, 0.02802400f, 
    -0.00833946f, 0.00848024f, -0.01102147f, 0.05536272f, 0.01712719f, -0.02688848f, -0.04601628f, 0.02822548f, 
    -0.01186921f, -0.01419017f, -0.04175846f, 0.00914901f, 0.00008409f, -0.01965713f, -0.05682478f, 0.00838734f, 
    -0.02995427f, 0.01208946f, -0.00097162f, -0.03603756f, 0.01709238f, 0.02592174f, -0.01043585f, -0.04147791f, 
    -0.00591631f, 0.03600089f, 0.05183361f, 0.03580227f, -0.03405334f, -0.03207241f, -0.02708376f, 0.05755515f, 
    0.02138457f, 0.01547765f, -0.04768457f, -0.02286329f, -0.00126134f, -0.04774876f, -0.04474168f, 0.04749672f, 
    -0.01682232f, 0.04893312f, 0.01537497f, -0.03939342f, -0.04060349f, -0.00993026f, -0.05442954f, -0.04444034f, 
    -0.00250666f, -0.03816881f, 0.01257017f, -0.01434733f, 0.03098062f, -0.06613237f, -0.05155559f, -0.01841974f, 
    0.04962848f, -0.03216464f, -0.02388264f, -0.02564142f, -0.03807196f, -0.06054351f, -0.05950412f, -0.04504099f, 
    -0.01776810f, 0.00897872f, 0.03019253f, -0.04578299f, -0.00463751f, -0.00987857f, 0.00596573f, 0.04094942f, 
    0.02083477f, -0.05200433f, -0.03278030f, 0.05011988f, -0.01487892f, 0.01570890f, -0.03432843f, -0.01598154f, 
    -0.00938637f, 0.00389308f, 0.02863541f, -0.01670453f, -0.00005717f, -0.01437692f, -0.05616501f, -0.01847130f, 
    -0.05077656f, 0.01714586f, -0.00719090f, 0.04738045f, -0.04096891f, -0.00288622f, -0.02915445f, 0.00637005f, 
    -0.00333899f, -0.06150648f, 0.04203454f, -0.00842709f, -0.06015544f, -0.03201952f, -0.04883637f, 0.02716118f, 
    -0.03048190f, 0.00574636f, -0.04278577f, -0.06054567f, -0.00218152f, 0.04028679f, -0.01127743f, -0.06178663f, 
    0.19009075f, 0.12685063f, 0.24010994f, 0.33930355f, 0.00151353f, 0.06767542f, 0.04354906f, 0.08199776f, 
    -0.12679146f, 0.03630485f, -0.00097154f, -0.62714589f, -0.15920329f, -0.22148253f, 0.32885322f, -0.01072815f, 
    -0.05949223f, 0.01095689f, 0.12385479f, -0.33218914f, -0.41195682f, -0.03043223f, -0.07266134f, -0.15409367f, 
    0.02090395f, 0.20848985f, -0.04959016f, 0.17978679f, 0.16095133f, -0.04790595f, -0.16756147f, 0.06144726f, 
    -0.00249984f, -0.19851510f, -0.20391953f, 0.05436194f, -0.22138819f, -0.11738206f, 0.04522824f, 0.14982621f, 
    -0.01096648f, 0.13864161f, 0.11665234f, -0.12903790f, 0.15749794f, 0.28860658f, 0.24896021f, 0.51217467f, 
    0.39103511f, 0.21124849f, 0.04821017f, -0.18568252f, -0.09769347f, 0.13978206f, 0.00816807f, -0.08218621f, 
    0.33260432f, -0.03840552f, 0.04605784f, -0.01886118f, -0.10138536f, 0.05084137f, -0.02332119f, 0.11515524f, 
    0.05886978f, 0.22744617f, 0.10773589f, 0.11525621f, 0.03964545f, -0.30067739f, 0.24699691f, 0.12520197f, 
    -0.03389347f, -0.15436549f, 0.18730792f, -0.09184124f, 0.06679133f, -0.11427984f, -0.09355249f, 0.08392942f, 
    -0.14510462f, 0.31042978f, -0.05174192f, 0.10788188f, 0.17449294f, 0.15350881f, 0.02952554f, -0.07995781f, 
    0.14471191f, 0.02727897f, -0.28649741f, -0.14455071f, 0.40274334f, -0.00146828f, 0.13929051f, -0.07055981f, 
    0.02373584f, 0.18516076f, 0.24659146f, 0.09965513f, 0.15083952f, 0.28750047f, 0.09498634f, 0.19017157f, 
    -0.19049621f, -0.10790665f, -0.01999504f, 0.29187435f, -0.10581943f, 0.02194672f, 0.44902164f, -0.04637214f, 
    0.03322407f, -0.14718811f, -0.11391810f, -0.01594939f, -0.07648178f, -0.04632213f, 0.00992020f, -0.02192572f, 
    0.06089520f, -0.07621431f, -0.18253787f, -0.11063746f, 0.03863893f, -0.05019397f, -0.05374961f, -0.22706366f, 
    -0.67075765f, 0.00370341f, -0.11435167f, 0.20953499f, -0.37023744f, -0.03118153f, -0.17285715f, -0.11217146f, 
    0.03882647f, -0.18419269f, 0.10068281f, -0.06294460f, -0.00775959f, -0.12817551f, -0.16288403f, -0.06484959f, 
    0.28477347f, -0.00343075f, 0.15904653f, -0.05982248f, -0.05026319f, 0.13004865f, -0.05930994f, -0.10779925f, 
    -0.13356701f, 0.24868476f, -0.02564221f, 0.08686879f, 0.09218819f, -0.03152614f, 0.23589651f, -0.06785257f, 
    0.04554351f, 0.07344939f, -0.25555387f, 0.02328854f, -0.10291921f, -0.11845910f, 0.14553446f, -0.10092187f, 
    -0.02808860f, -0.04732918f, -0.06350651f, 0.00340811f, -0.15208152f, 0.25977552f, -0.05413121f, 0.03497047f, 
    0.04902958f, 0.07178567f, -0.18628326f, 0.05918096f, 0.11009335f, 0.05365820f, -0.04027098f, -0.10254817f, 
    -0.02841059f, 0.19309290f, -0.02215344f, -0.05415129f, -0.06254014f, 0.46223244f, -0.21608929f, 0.16159564f, 
    -0.06119754f, -0.14183669f, -0.25897020f, 0.10115370f, 0.09154550f, -0.10490467f, -0.02946483f, 0.15146397f, 
    0.14650017f, -0.01739419f, -0.03134113f, -0.07850233f, 0.13832286f, -0.09640002f, 0.12120551f, -0.11313543f, 
    -0.30083078f, -0.18379435f, 0.12444551f, 0.11427636f, 0.18131858f, -0.09426192f, -0.09216687f, -0.02020478f, 
    -0.34288812f, -0.04748107f, -0.37119788f, 0.02641434f, 0.18587369f, -0.02192365f, -0.23662984f, 0.02406605f, 
    -0.32605320f, 0.27587309f, -0.04898006f, 0.03741822f, 0.04888550f, 0.04617020f, -0.10016667f, -0.05228213f, 
    0.05644708f, -0.16794245f, 0.28053588f, 0.06344916f, -0.16034503f, 0.16943944f, 0.13918079f, 0.00359547f, 
    -0.00349560f, 0.14286776f, 0.03317034f, -0.04479453f, -0.12088402f, -0.11130399f, 0.18691289f, 0.34331328f, 
    0.05133486f, -0.17302583f, -0.04937879f, 0.15836942f, 0.11454601f, 0.03549537f, -0.12159060f, 0.11271548f, 
    0.12801884f, 0.25270584f, -0.19399588f, -0.23284270f, 0.03677248f, 0.22013797f, 0.05709821f, 0.45717874f, 
    0.28721222f, 0.23284209f, -0.05991495f, -0.12637098f, 0.16472304f, 0.29214177f, 0.03505560f, 0.10336567f, 
    -0.14497223f, -0.09295617f, -0.19318534f, 0.07285132f, 0.00439318f, -0.18169244f, 0.12582584f, 0.20726219f, 
    -0.20054145f, -0.17786273f, -0.03182649f, 0.00319628f, 0.06739936f, -0.02131129f, 0.03720291f, 0.00620155f, 
    -0.20256346f, 0.10364523f, 0.19295858f, -0.12407672f, 0.00693968f, -0.14387071f, 0.05886138f, -0.26449063f, 
    0.04661774f, 0.07451598f, -0.15313953f, -0.01259624f, 0.22998087f, 0.01884629f, 0.07703215f, -0.02836568f, 
    -0.06244138f, 0.02906491f, 0.06293770f, 0.02522539f, -0.15919818f, -0.02552564f, -0.07116210f, 0.15001364f, 
    0.14820310f, 0.41779023f, 0.18145837f, -0.07971078f, 0.07105216f, 0.22437197f, 0.19291931f, 0.03208424f, 
    0.01423740f, 0.08260044f, 0.01875653f, -0.08890717f, -0.18514678f, -0.02558844f, -0.06319399f, -0.05073167f, 
    -0.24222545f, 0.04096442f, -0.01761354f, 0.03360754f, 0.01917234f, -0.16962710f, 0.20528354f, 0.02062516f, 
    0.03981465f, -0.05492150f, 0.01006431f, -0.08960103f, -0.26758417f, 0.02097391f, -0.45332706f, -0.21301511f, 
    0.01405224f, 0.00881245f, 0.03523919f, 0.03596280f, -0.02803775f, -0.15400650f, 0.10558019f, -0.13316083f, 
    -0.24048424f, -0.06752485f, 0.08496681f, -0.00888537f, -0.08281960f, 0.15067972f, 0.13829999f, -0.01795327f, 
    0.00494617f, 0.18363973f, -0.14791599f, 0.17685021f, -0.00281694f, -0.10461927f, 0.00804179f, 0.02247014f, 
    -0.05742756f, -0.44052294f, -0.18449748f, -0.06752843f, -0.11285631f, -0.06884886f, -0.15647903f, 0.02271704f, 
    0.19575186f, -0.15261251f, -0.46265393f, -0.32726309f, 0.59744966f, -0.07602178f, 0.26387933f, 0.04556189f, 
    0.12383316f, 0.07562011f, -0.41189793f, -0.22422694f, 0.07380434f, 0.04462401f, 0.14010233f, 0.22094119f, 
    0.05649605f, -0.05208100f, 0.07966100f, -0.27868032f, -0.43312886f, -0.10578111f, -0.06817686f, 0.17319918f, 
    0.08234578f, -0.02551921f, 0.04665344f, 0.02729844f, 0.15843530f, -0.12686604f, 0.05690647f, 0.03719771f, 
    -0.18563396f, -0.12302507f, 0.20131125f, -0.25019920f, -0.03815632f, -0.02906195f, 0.33147395f, -0.34671411f, 
    -0.18097632f, 0.05620666f, -0.02866986f, 0.08254503f, -0.09718783f, -0.11962472f, -0.03070220f, 0.03921800f, 
    -0.02256631f, -0.28168601f, -0.00663466f, 0.13100408f, 0.24215010f, 0.31708205f, 0.00774494f, 0.00744034f, 
    0.04267837f, -0.43482372f, -0.47056505f, -0.02405057f, 0.21605965f, 0.13910703f, 0.11389711f, 0.11935922f, 
    0.02368886f, -0.02962966f, 0.09692553f, 0.00723329f, 0.05300033f, 0.20382835f, 0.21694028f, 0.11355258f, 
    0.06221440f, -0.09362022f, 0.49609163f, 0.06746996f, 0.04568086f, -0.06886750f, -0.23050013f, -0.02018542f, 
    -0.13032825f, -0.15466796f, 0.15056792f, -0.08082686f, 0.21055655f, -0.09459747f, 0.10163854f, 0.14098850f, 
    0.00771473f, -0.15666166f, 0.13019967f, -0.18433951f, 0.13134959f, -0.06796568f, 0.24306443f, -0.03284551f, 
    -0.16663493f, 0.01862996f, 0.03973581f, 0.17152494f, -0.18390401f, -0.67066532f, -0.38115302f, -0.00867564f, 
    -0.04365362f, -0.16155323f, -0.19453806f, 0.02924222f, -0.20596333f, -0.10014170f, -0.08602829f, -0.02352018f, 
    0.45631847f, -0.04951814f, 0.10096003f, 0.07851870f, 0.03538663f, 0.15713486f, -0.18333963f, 0.19493160f, 
    0.08471349f, -0.15356387f, 0.05624929f, -0.02909875f, 0.17492074f, 0.11162849f, 0.05593762f, 0.15229128f, 
    -0.05334306f, 0.09376549f, -0.00564707f, 0.09995996f, 0.28809023f, 0.31175897f, 0.08946323f, 0.09521319f, 
    -0.08322230f, -0.40714017f, 0.04772345f, 0.30671948f, 0.22433740f, 0.20156556f, 0.22058474f, 0.23144558f, 
    -0.01730294f, 0.21396282f, 0.01413843f, -0.59109652f, -0.38998380f, 0.08772556f, 0.01902672f, -0.17742585f, 
    -0.04464702f, -0.08739705f, 0.10641558f, -0.16825972f, 0.24320133f, 0.19799478f, 0.06281440f, 0.02774693f, 
    -0.22491410f, 0.05710976f, -0.10104828f, -0.25728002f, -0.17930624f, -0.12824407f, 0.01230345f, 0.06814012f, 
    -0.10268676f, 0.11604387f, 0.27795994f, 0.37395307f, -0.01041773f, -0.45826685f, -0.22221127f, -0.03516186f, 
    0.03948730f, 0.11590770f, -0.16655520f, -0.26585796f, -0.01861841f, 0.00039512f, 0.24679428f, -0.34164843f, 
    -0.08142021f, -0.01904753f, 0.07193127f, 0.21605545f, -0.02038397f, 0.02690453f, -0.16006577f, -0.08955830f, 
    0.14691998f, 0.24703276f, 0.17551035f, 0.30275768f, -0.05267633f, 0.02758058f, -0.04663960f, 0.06399777f, 
    0.41909257f, -0.54113519f, -0.23129186f, -0.21979243f, -0.07736062f, 0.07783250f, -0.12121443f, -0.12347583f, 
    0.16659090f, -0.43264508f, 0.05904909f, -0.58414149f, 0.27705932f, -0.05936677f, -0.05684161f, -0.01304043f, 
    -0.03824136f, 0.08074670f, -0.16073155f, -0.17799218f, -0.10648805f, -0.07368574f, 0.16523109f, 0.01399246f, 
    -0.00665021f, 0.12347609f, 0.15832435f, -0.17272758f, -0.55131030f, -0.09635799f, -0.39014068f, 0.12002835f, 
    0.10819437f, -0.08955552f, 0.23532888f, 0.03206972f, 0.26638466f, 0.31437331f, 0.04067360f, -0.11403903f, 
    -0.15182643f, 0.05474943f, 0.30836377f, -0.00348657f, 0.27376327f, -0.34941646f, -0.09140027f, 0.16046278f, 
    0.23818862f, -0.00967119f, 0.13539523f, 0.22298382f, -0.08610760f, 0.14008610f, 0.34059110f, -0.51430845f, 
    0.06983498f, -0.06684177f, 0.08589269f, 0.06617910f, 0.19570541f, 0.03086009f, -0.19939941f, 0.38873118f, 
    -0.03004153f, -0.03715250f, 0.07700513f, 0.08870517f, -0.10896559f, 0.11552426f, 0.09332392f, -0.13431804f, 
    -0.01604459f, -0.76606864f, 0.07789609f, 0.09060233f, -0.10340585f, -0.16122471f, -0.19679530f, 0.17341937f, 
    -0.01745086f, 0.30358770f, 0.58709669f, -0.13516487f, 0.22252643f, 0.06934223f, 0.10576904f, 0.04782345f, 
    0.09463897f, -0.03400195f, 0.26180688f, -0.22197631f, -0.41421965f, 0.03008640f, 0.19927424f, -0.02880775f, 
    0.10863902f, 0.04657836f, 0.01593355f, 0.01219688f, 0.08034758f, 0.43069077f, 0.13456641f, -0.07426171f, 
    -0.14538942f, 0.19503856f, -0.12733860f, 0.28751355f, 0.42974466f, 0.23479331f, 0.13456999f, -0.11088960f, 
    0.18093961f, 0.01954379f, -0.01606918f, 0.11227208f, -0.04439754f, -0.20228297f, -0.01922167f, 0.11415450f, 
    -0.05516846f, -0.35038072f, -0.03707861f, 0.05611562f, -0.17813186f, 0.05807197f, -0.00503363f, -0.14814757f, 
    0.06214942f, 0.08994719f, 0.19653961f, 0.09318500f, -0.04523414f, -0.17356072f, -0.02215266f, 0.00440992f, 
    0.27095869f, -0.43436790f, 0.08417427f, -0.03827767f, -0.08616964f, -0.07999034f, -0.01472678f, -0.03448522f, 
    -0.23824242f, -0.62123388f, -0.44926172f, 0.26972315f, 0.02601465f, 0.11027478f, 0.11243742f, -0.00533317f, 
    0.07477690f, 0.09697311f, 0.10460345f, 0.10820697f, -0.36914328f, -0.01619227f, 0.14132495f, -0.06611552f, 
    0.17586808f, -0.00128850f, -0.52831006f, -0.15425646f, -0.21986765f, -0.18848257f, -0.03163050f, -0.06925436f, 
    -0.10010633f, 0.09369263f, 0.08324205f, -0.12036908f, -0.28678027f, 0.22486226f, 0.20805067f, 0.12687850f, 
    0.16403864f, -0.01703354f, 0.05124943f, 0.15587293f, -0.27451259f, -0.31672543f, -0.03805566f, -0.13585579f, 
    0.03912904f, -0.03383630f, 0.01370362f, -0.00906290f, 0.02330408f, -0.30569404f, -0.57979655f, 0.22815600f, 
    -0.07209369f, 0.29823157f, -0.06838006f, -0.00202915f, -0.08352198f, 0.00797064f, -0.32392484f, -0.09405928f, 
    -0.58909196f, 0.04699096f, -0.01484633f, 0.06083691f, -0.04696766f, -0.05227987f, -0.08735905f, 0.36392954f, 
    0.51380336f, -0.04012692f, -0.08201751f, 0.07912891f, -0.02188282f, 0.02630170f, 0.20250890f, -0.04290523f, 
    -0.05743527f, 0.00141768f, 0.26920563f, -0.08824544f, -0.03987928f, 0.20358112f, -0.23741925f, 0.05437009f, 
    -0.07744023f, 0.21033010f, 0.24960352f, -0.23676212f, 0.18704182f, -0.31119010f, 0.03111200f, -0.07553773f, 
    -0.16926420f, -0.03159204f, 0.15035725f, 0.46400440f, 0.41207665f, -0.07689700f, 0.04714860f, -0.25788620f, 
    -0.00581164f, 0.10929547f, 0.12389036f, 0.09221309f, -0.11267957f, -0.39706981f, -0.01291011f, 0.06563172f, 
    -0.33669201f, 0.46934202f, 0.13150188f, -0.19480050f, 0.06855843f, 0.24690533f, 0.02095100f, 0.20561348f, 
    0.25211447f, 0.06436893f, 0.02752286f, -0.03658351f, -0.16628492f, 0.38355756f, 0.55528712f, 0.12656969f, 
    0.19388635f, 0.02121634f, -0.04440513f, 0.24650553f, 0.03240259f, 0.03559952f, -0.56748426f, -0.18221046f, 
    -0.09110284f, -0.10040716f, 0.12130125f, 0.06775004f, -0.06852742f, -0.05095727f, 0.18695861f, 0.02278670f, 
    -0.04439491f, -0.05055275f, -0.10006661f, -0.00955151f, 0.08404963f, 0.04407987f, 0.13940777f, -0.07793976f, 
    0.28052276f, -0.23359458f, -0.09019267f, -0.00693096f, 0.06383920f, -0.03773382f, 0.16407052f, 0.08353765f, 
    -0.05833533f, 0.13220346f, -0.18872885f, -0.17289157f, -0.17453754f, 0.15351038f, 0.15961084f, 0.11579466f, 
    0.16222604f, -0.32509041f, -0.02758508f, 0.15998581f, 0.13860911f, 0.23119912f, 0.02224313f, -0.33737260f, 
    0.24332638f, 0.04602750f, 0.09361353f, 0.62289697f, 0.00185453f, -0.07470120f, 0.31712398f, -0.10446363f, 
    0.15783113f, 0.10432351f, 0.08264600f, 0.06739266f, -0.58412045f, -0.16708679f, -0.23905654f, 0.10057599f, 
    -0.03103586f, 0.26736751f, -0.01369907f, 0.07283501f, -0.12710468f, -0.04287371f, -0.09965447f, -0.15103677f, 
    -0.30904621f, -0.23832585f, 0.06616950f, -0.04999729f, 0.07699858f, 0.19130866f, -0.24546365f, 0.23757674f, 
    0.03786710f, -0.09417515f, 0.07777750f, -0.37052587f, -0.03359148f, 0.19310360f, -0.02048758f, -0.25814924f, 
    0.09451655f, 0.10519254f, -0.03006347f, 0.15154193f, 0.01789216f, -0.18720472f, 0.25155878f, 0.27716637f, 
    -0.11201254f, 0.17696515f, 0.01606831f, -0.03518873f, -0.09183564f, -0.12590365f, -0.19851096f, 0.13399443f, 
    0.13623461f, -0.02988898f, 0.16661337f, -0.03622467f, 0.03253567f, 0.20288639f, -0.01238000f, -0.04823260f, 
    0.11092506f, -0.10053414f, 0.12393802f, -0.13974985f, 0.19900824f, 0.11948054f, -0.10773094f, -0.18930855f, 
    -0.09245354f, -0.05185170f, 0.05339591f, -0.16105214f, 0.01211662f, -0.18799324f, -0.00136589f, -0.21796174f, 
    -0.09965081f, 0.16335040f, -0.00131726f, 0.12822650f, -0.01221460f, -0.05773524f, -0.23080264f, -0.21482505f, 
    0.08559317f, -0.04234998f, -0.18158928f, -0.13943142f, 0.16770627f, 0.08149292f, -0.23220408f, 0.04301295f, 
    -0.13349999f, 0.08594457f, -0.08478927f, 0.10156889f, 0.05010017f, -0.00647628f, -0.01743116f, -0.30167398f, 
    -0.05408065f, -0.04393641f, 0.09219276f, 0.11522689f, -0.29068920f, 0.14684816f, -0.27377978f, -0.16647547f, 
    0.02694683f, 0.10003968f, -0.27025804f, 0.16098848f, 0.13017820f, 0.22983582f, -0.06007863f, -0.26297739f, 
    -0.26622009f, -0.11186337f, 0.06342345f, 0.07262654f, -0.17802532f, 0.04753228f, -0.02531146f, 0.11720736f, 
    0.26252824f, 0.01435421f, 0.11862544f, -0.07841599f, 0.23243968f, -0.15929815f, 0.19414036f, 0.02244592f, 
    0.14791441f, -0.13837755f, 0.12049239f, 0.07260034f, 0.32881957f, -0.09671216f, -0.16778021f, 0.00330345f, 
    -0.02736516f, 0.06357004f, 0.00882051f, -0.14034569f, 0.37853375f, -0.02894230f, 0.13456035f, 0.07116000f, 
    -0.23818748f, 0.13184936f, 0.06841724f, 0.10637613f, 0.15752864f, 0.19505970f, 0.27183235f, -0.01279599f, 
    -0.05217958f, -0.08152083f, -0.12938949f, 0.15132213f, -0.12493118f, 0.39984089f, 0.23000363f, -0.46281666f, 
    0.08636338f, -0.08067904f, -0.22783850f, 0.21744181f, 0.24040465f, -0.16750467f, 0.21274993f, 0.22903340f, 
    0.36119074f, 0.01539921f, -0.13941413f, -0.15722318f, -0.04287285f, 0.12015235f, 0.10164803f, -0.47207436f, 
    0.02740638f, 0.03568829f, 0.05727498f, 0.10657588f, 0.12949315f, -0.15543368f, -0.15316129f, -0.17667113f, 
    -0.36067972f, -0.52581847f, -0.32031333f, 0.09862882f, 0.08563820f, 0.08039971f, -0.06369295f, -0.01694880f, 
    -0.00021155f, 0.02952750f, -0.23123670f, 0.07513320f, -0.13715133f, 0.10716067f, 0.14832124f, 0.02939751f, 
    -0.01836232f, 0.16732723f, -0.08549288f, -0.03570451f, 0.18342508f, -0.00921572f, 0.10069837f, 0.08941462f, 
    -0.03666183f, 0.10698280f, 0.06430095f, 0.15800500f, -0.04276512f, -0.01803241f, 0.00443070f, -0.05014185f, 
    0.16297647f, -0.11618841f, 0.00554463f, -0.06290511f, -0.07151975f, -0.09225560f, -0.09552857f, -0.18232404f, 
    -0.07683077f, 0.01393210f, 0.09747843f, 0.12185840f, 0.20895638f, -0.25010225f, 0.00619857f, -0.09216183f, 
    -0.33757854f, -0.06611023f, 0.01624340f, 0.06976030f, 0.16869944f, 0.16493393f, 0.19346032f, 0.10857712f, 
    0.11866850f, -0.09045797f, 0.06109621f, 0.23168857f, 0.18281133f, -0.01788358f, 0.15273347f, 0.20121323f, 
    -0.21713856f, 0.24196905f, -0.02702457f, -0.08588200f, 0.07730539f, 0.12518854f, 0.13499196f, -0.11258759f, 
    -0.10115181f, -0.16348855f, -0.64381891f, 0.36664546f, -0.09277918f, -0.10041782f, -0.02870055f, -0.16631106f, 
    -0.22172257f, -0.61432815f, 0.04118676f, 0.04208577f, 0.02741140f, 0.05970058f, -0.12935096f, 0.12303955f, 
    0.15356240f, 0.05238497f, -0.22881004f, -0.49286392f, -0.08042968f, 0.18136139f, 0.21552275f, 0.02333808f, 
    -0.06780500f, 0.23416832f, 0.09036560f, -0.02804446f, -0.57651365f, -0.03437056f, -0.06900199f, 0.04196420f, 
    -0.24099483f, 0.17844538f, -0.23008505f, 0.02453073f, 0.31454489f, 0.09962619f, 0.08586092f, 0.06749792f, 
    -0.06091037f, -0.27580792f, 0.05704661f, 0.17302606f, 0.07892080f, -0.16571262f, -0.01935482f, 0.19498672f, 
    0.01312142f, 0.14473598f, 0.04199528f, 0.06890029f, 0.21726419f, -0.38550711f, -0.15605123f, 0.44740030f, 
    -0.10013907f, 0.00340215f, 0.09185660f, -0.03126731f, 0.05837854f, -0.15915748f, 0.06312509f, 0.19129345f, 
    0.08365565f, -0.14820035f, -0.17207892f, -0.00114232f, 0.03389357f, 0.13507080f, 0.04458888f, 0.00796450f, 
    0.01208766f, 0.16549371f, -0.22587031f, -0.17127070f, 0.19267766f, 0.13156825f, 0.22762969f, -0.12956284f, 
    0.00519127f, 0.19856094f, 0.17902483f, 0.22660197f, -0.32765657f, 0.03085609f, -0.20580146f, -0.05972948f, 
    0.03295351f, 0.05351601f, -0.46244749f, -0.25097001f, -0.33492070f, -0.26585010f, -0.11031059f, 0.14304139f, 
    0.01813932f, 0.29932779f, -0.00366999f, -0.57834709f, 0.16600291f, 0.39680368f, 0.06647703f, 0.16308175f, 
    -0.15725532f, -0.03267301f, 0.08715428f, -0.06917325f, -0.16074628f, 0.39708376f, 0.42238566f, -0.06258899f, 
    -0.14737213f, -0.16123793f, -0.02305053f, 0.03220217f, -0.01928092f, 0.10522512f, -0.27624887f, 0.12476295f, 
    0.10681511f, -0.04098444f, 0.14078932f, 0.12064670f, -0.06712605f, 0.12023102f, 0.18107004f, 0.14785747f, 
    0.12362552f, -0.11122388f, -0.11711869f, -0.12662970f, 0.11327486f, 0.12389409f, 0.30680144f, 0.11277317f, 
    0.08482383f, 0.22058968f, 0.01826635f, -0.12618728f, -0.01136876f, -0.02558512f, 0.02506318f, 0.45741832f, 
    -0.46147791f, 0.04273176f, -0.19167152f, 0.08253870f, 0.01246505f, 0.20488337f, 0.07092353f, -0.18294984f, 
    -0.01338898f, -0.15321510f, -0.19301380f, -0.23056109f, 0.13384272f, 0.06826597f, -0.15635636f, -0.20280524f, 
    -0.06032204f, 0.15828362f, 0.47157973f, -0.19656682f, -0.18983394f, -0.07074348f, 0.03245788f, -0.01756105f, 
    0.11680627f, -0.01925117f, -0.00732927f, -0.14980839f, 0.02939800f, -0.18161555f, 0.28026772f, 0.03884233f, 
    -0.17247674f, -0.00646048f, 0.00685556f, -0.05499129f, 0.11841378f, -0.18773374f, -0.13432695f, -0.21469420f, 
    0.10818247f, -0.02498291f, 0.17788893f, -0.05200614f, 0.19968353f, -0.26825809f, 0.34928307f, -0.40874147f, 
    0.28064299f, -0.07140545f, 0.06658225f, 0.19265643f, 0.06123733f, 0.10084601f, -0.15750383f, -0.33437711f, 
    -0.44090307f, 0.10260802f, 0.24619450f, -0.08938558f, 0.07306997f, -0.08430417f, 0.13356613f, 0.09551208f, 
    0.45806742f, 0.28702652f, 0.03059094f, 0.01163906f, -0.22414611f, 0.30578735f, 0.20135120f, -0.21191898f, 
    -0.11039934f, 0.22722986f, 0.42346478f, 0.34783590f, 0.06609421f, -0.28061286f, 0.25122422f, 0.23946527f, 
    -0.04928628f, -0.09166439f, -0.09876803f, 0.17476805f, 0.19244002f, 0.08991569f, 0.04791550f, 0.11095389f, 
    -0.14033316f, 0.03605893f, 0.09560267f, -0.11024527f, 0.15564661f, -0.20903614f, 0.08250198f, 0.21497270f, 
    -0.07402860f, -0.28278196f, 0.02793461f, 0.13304956f, 0.14815010f, -0.54771692f, -0.06987142f, -0.16545643f, 
    0.04609115f, -0.02277252f, -0.05390124f, 0.16578843f, -0.18767904f, -0.11763310f, 0.08045211f, 0.08083627f, 
    -0.10452385f, -0.04947292f, 0.02495767f, -0.03531991f, 0.00121389f, -0.24714887f, -0.05579542f, 0.47906670f, 
    -0.17576855f, -0.00291536f, -0.08830730f, -0.24856374f, -0.04804853f, -0.15035206f, -0.26639134f, -0.21363655f, 
    -0.09673072f, -0.18709940f, 0.03120705f, -0.10001057f, -0.15244326f, -0.11856423f, 0.06276994f, -0.30895358f, 
    -0.19083281f, 0.35866982f, 0.41348523f, 0.21116003f, 0.19906509f, -0.13330513f, -0.01594847f, 0.05193546f, 
    -0.06082280f, -0.06628823f, -0.02304978f, -0.04347084f, -0.00664527f, 0.02367705f, 0.03350908f, 0.01731557f, 
    0.03658655f, -0.01682737f, 0.00306237f, -0.03442553f, -0.06331107f, -0.05441236f, -0.05296875f, 0.04438157f, 
    -0.02414962f, 0.02629077f, -0.00519877f, -0.02828561f, -0.01559428f, 0.02184168f, 0.01665073f, -0.05800648f, 
    0.00079175f, -0.01185175f, 0.04845862f, -0.02374856f, -0.04899573f, 0.05025595f, -0.04065874f, -0.01362798f, 
    -0.01149068f, -0.02573404f, -0.06408095f, -0.00569073f, 0.01736430f, 0.02852715f, 0.04781609f, -0.05375143f, 
    0.03547884f, -0.05285218f, -0.06269634f, -0.03758910f, 0.01227690f, 0.00074541f, -0.03638750f, 0.04029547f, 
    -0.04216929f, 0.04811874f, -0.02069636f, -0.04155307f, -0.05729000f, 0.01609708f, -0.03464255f, -0.04870231f, 
    0.02345069f, -0.04440952f, 0.01502025f, -0.05730907f, -0.03878901f, 0.04455233f, -0.04258687f, -0.02823056f, 
    -0.02837994f, 0.00540564f, -0.06633588f, -0.00735466f, 0.01904209f, -0.06166828f, 0.04396737f, 0.00872650f, 
    -0.00651025f, 0.04227740f, 0.00105966f, -0.06611052f, -0.05728560f, -0.05701888f, 0.00839756f, -0.06046487f, 
    0.03005476f, 0.04523061f, -0.04005546f, 0.03747062f, 0.01623049f, -0.04035605f, -0.01231617f, -0.01223790f, 
    0.04804355f, 0.00161808f, 0.01357055f, -0.02189661f, 0.02393560f, 0.04171518f, -0.06143811f, 0.01966630f, 
    0.03454556f, -0.05715777f, 0.01224768f, 0.00910112f, 0.01591941f, 0.03368372f, -0.05974625f, 0.02539801f, 
    0.04992189f, 0.03972801f, -0.04776273f, 0.03092746f, -0.04800508f, -0.03381016f, -0.04384054f, -0.02618335f, 
    -0.05862537f, -0.04842344f, 0.04941941f, -0.04239420f, -0.00922744f, 0.03965009f, -0.01669231f, -0.02136186f, 
    0.04198018f, 0.05028438f, -0.03887276f, 0.04048871f, 0.04237485f, -0.01322040f, -0.01447360f, -0.01474687f, 
    0.00698903f, 0.02346221f, -0.02040570f, -0.03923457f, -0.02226749f, 0.01973042f, -0.06227722f, 0.01686425f, 
    -0.02546084f, -0.02011365f, 0.03373860f, 0.00470507f, -0.02435020f, -0.06671780f, -0.06358675f, -0.06175430f, 
    0.03444428f, -0.03497896f, -0.03437486f, -0.01879139f, -0.03296348f, 0.00838608f, 0.01667665f, -0.03612633f, 
    0.04427022f, -0.04212448f, -0.00020071f, -0.00626112f, -0.00945791f, 0.00034842f, 0.02205140f, -0.04619011f, 
    -0.01974154f, -0.05638582f, -0.03178512f, -0.02826601f, 0.00608588f, -0.01705273f, 0.02323029f, 0.00405115f, 
    0.02127116f, 0.03267016f, -0.00776911f, -0.01141246f, -0.01035808f, 0.03734887f, -0.00651754f, -0.02461859f, 
    0.02309204f, 0.01870689f, -0.00156483f, -0.05373396f, -0.06378361f, -0.02475342f, -0.06428693f, -0.06027853f, 
    -0.06349452f, 0.00924465f, -0.00255401f, -0.02638999f, 0.04515333f, -0.05234657f, 0.04141900f, -0.01704823f, 
    0.00283967f, -0.02694692f, -0.01188104f, 0.01599715f, 0.01231028f, -0.05055096f, 0.02106627f, 0.02541110f, 
    0.01383776f, -0.05828996f, 0.03164479f, -0.00510927f, 0.04753133f, -0.03356040f, 0.03633977f, 0.00159263f, 
    0.00404416f, 0.02616880f, -0.05642223f, -0.03374840f, -0.03082315f, -0.02286850f, -0.02003421f, 0.03791460f, 
    -0.06017920f, 0.00796071f, -0.06083645f, -0.02193432f, 0.02225233f, 0.03455156f, -0.03619726f, 0.02067312f, 
    -0.03763984f, -0.06247883f, 0.04869488f, -0.00366745f, 0.00092371f, 0.01111590f, -0.04696360f, -0.06649702f, 
    -0.03075762f, 0.00879420f, 0.00429327f, -0.04690073f, -0.01041314f, -0.00459887f, -0.00270286f, 0.00814701f, 
    -0.05064055f, 0.00012914f, -0.00024660f, -0.03946003f, -0.06192474f, -0.05801001f, -0.01303748f, -0.01176583f, 
    -0.00547660f, 0.04002059f, 0.05537742f, -0.00823459f, 0.02035900f, -0.00220918f, 0.00217392f, 0.02998191f, 
    -0.01482711f, -0.04521723f, -0.04168480f, 0.00163058f, -0.03756980f, -0.00629293f, -0.00068025f, 0.01728650f, 
    0.04478369f, 0.04472700f, 0.00504069f, -0.00361579f, 0.01890906f, 0.00576967f, -0.02177667f, -0.00548331f, 
    0.03102858f, -0.01306033f, -0.02324923f, -0.04906202f, -0.00216193f, -0.05136788f, -0.01943542f, 0.03334020f, 
    -0.06663265f, 0.00632414f, -0.05163738f, 0.05117758f, -0.01615750f, -0.00709749f, 0.00377982f, -0.03488889f, 
    -0.04619233f, -0.03708613f, 0.02356510f, 0.04089103f, -0.02464896f, 0.03628374f, 0.03843880f, -0.05652143f, 
    -0.06075000f, -0.01836896f, -0.04233709f, 0.01696581f, 0.05434832f, -0.05343845f, -0.03398412f, 0.03538454f, 
    0.00419121f, 0.02556417f, -0.01335276f, 0.03969229f, -0.04313154f, -0.04981621f, -0.01129065f, -0.00679355f, 
    -0.01134921f, -0.01111138f, -0.03622305f, 0.01682944f, -0.03520632f, -0.06098341f, 0.04195663f, -0.04905345f, 
    -0.00380246f, -0.05193816f, 0.02642409f, -0.05092588f, -0.05618034f, -0.04815513f, 0.05734237f, 0.01138649f, 
    -0.04978812f, -0.02178305f, 0.01605837f, -0.05685337f, -0.01713355f, 0.02025853f, 0.02874407f, -0.00714691f, 
    0.01769246f, -0.06494840f, 0.04108237f, 0.02847531f, 0.04225704f, -0.05972134f, -0.03067124f, -0.02494697f, 
    -0.01218656f, -0.00331294f, 0.00768327f, -0.06280424f, -0.03749089f, 0.03099182f, 0.02542647f, -0.06094734f, 
    -0.02835838f, 0.02622300f, -0.06696550f, 0.01904358f, -0.04194159f, -0.01562706f, 0.01849607f, 0.00947559f, 
    0.03349137f, -0.06051503f, 0.03294301f, 0.03998579f, -0.03283906f, -0.02865993f, 0.04051092f, -0.00474352f, 
    0.02145975f, 0.04344514f, -0.02315226f, 0.04804271f, -0.04344372f, -0.06658854f, -0.00731967f, 0.03653213f, 
    -0.01366983f, -0.03494029f, 0.00409046f, -0.05354324f, -0.00162602f, 0.04826711f, -0.02458154f, -0.06745315f, 
    0.01832097f, 0.04758229f, -0.00992788f, -0.04023584f, 0.01979363f, -0.04606735f, 0.00474632f, 0.00154542f, 
    0.00733280f, -0.01563071f, 0.03311429f, 0.00709825f, -0.04385014f, -0.03348868f, -0.02125285f, -0.04188684f, 
    -0.03954852f, -0.01775219f, 0.03743381f, -0.02750597f, -0.03198922f, 0.03319094f, -0.02454032f, 0.00323308f, 
    0.00421510f, 0.02009358f, -0.05023412f, 0.00811611f, 0.03614227f, -0.03762530f, -0.02495071f, 0.04803668f, 
    -0.04709389f, -0.01608960f, -0.06292875f, 0.00752552f, 0.03872603f, -0.05760544f, -0.07012922f, 0.04393432f, 
    -0.06352261f, 0.03065543f, -0.00869837f, -0.01197377f, 0.03984573f, 0.02846125f, 0.04243113f, -0.00303946f, 
    -0.00225714f, -0.04688431f, 0.00291922f, 0.03274105f, -0.01208858f, -0.02521800f, -0.01879585f, 0.04470903f, 
    0.01219234f, 0.01517576f, 0.01368729f, 0.05529952f, -0.05228025f, 0.00922963f, -0.06858055f, 0.00973585f, 
    -0.03362563f, 0.02369330f, -0.03402899f, -0.01730343f, -0.02395151f, -0.06252682f, -0.04508308f, -0.03939918f, 
    -0.00950106f, 0.02164815f, -0.04365023f, -0.04571002f, 0.00170946f, 0.02919596f, -0.04290344f, 0.03160096f, 
    -0.02238556f, 0.01391542f, -0.02584694f, 0.04007562f, 0.03903004f, -0.04239127f, -0.00124780f, 0.02399936f, 
    -0.02332614f, 0.02828698f, -0.00904480f, -0.05483953f, -0.06100391f, -0.02023582f, -0.03707679f, 0.03009500f, 
    0.03671865f, 0.01400664f, -0.00890042f, -0.00755121f, 0.01200648f, -0.01401631f, -0.04285515f, 0.03307548f, 
    -0.00980936f, -0.06283797f, -0.02750701f, -0.03155562f, 0.00533211f, -0.05471190f, 0.03115896f, -0.03408918f, 
    -0.00152501f, 0.00527188f, -0.04564216f, -0.01617045f, 0.04163043f, -0.02112158f, -0.00319207f, 0.03691934f, 
    -0.00096651f, -0.05166796f, 0.01078520f, -0.00263966f, 0.03099038f, -0.01549658f, -0.00141853f, 0.04430249f, 
    -0.01840759f, -0.02430341f, 0.02317382f, -0.02293117f, -0.06389882f, 0.00507894f, -0.03831887f, 0.01168869f, 
    0.01454574f, -0.01859461f, 0.01110587f, -0.01339108f, -0.04395632f, 0.01410988f, -0.06685883f, -0.02277820f, 
    -0.04179198f, 0.03946992f, -0.01720431f, -0.00670125f, 0.03888448f, -0.01563976f, -0.03121075f, -0.02025991f, 
    0.04699453f, -0.02879709f, -0.01511243f, 0.02024187f, 0.04251314f, -0.01162004f, 0.04337525f, -0.00584909f, 
    0.01432041f, -0.04583374f, -0.01735329f, 0.03126621f, -0.05332650f, -0.04878265f, -0.03830118f, 0.00381829f, 
    -0.01415376f, -0.01665863f, 0.04675872f, -0.05400234f, 0.00852948f, -0.01375109f, 0.03891807f, -0.04320515f, 
    0.00619288f, -0.01042810f, 0.04000998f, 0.02916764f, -0.06038070f, -0.05774409f, 0.04030980f, 0.00193358f, 
    -0.00779026f, 0.04583715f, -0.03484064f, -0.04608564f, 0.00333662f, 0.01930675f, 0.01632036f, -0.03024509f, 
    0.04257209f, 0.01216202f, 0.01121452f, 0.03479961f, 0.03638652f, -0.05049893f, 0.02239918f, 0.03539025f, 
    -0.02823729f, 0.01304669f, 0.02905008f, -0.04634032f, 0.01956246f, -0.00873166f, 0.02552048f, -0.03363802f, 
    0.01314981f, 0.04406157f, -0.05838925f, -0.04153460f, -0.00135284f, -0.04067561f, 0.02052204f, 0.00698836f, 
    0.05153461f, -0.04726205f, 0.01493153f, 0.02902986f, 0.01589115f, -0.01404296f, -0.00900115f, -0.05927347f, 
    -0.04993487f, -0.05199214f, 0.03416780f, -0.03662411f, 0.03676448f, -0.02798739f, 0.04432486f, -0.02730615f, 
    -0.02546494f, 0.03502061f, -0.02588461f, -0.00582412f, -0.01769022f, 0.00767629f, 0.03114564f, -0.03459472f, 
    0.02223350f, 0.03473292f, 0.00202685f, -0.00999761f, 0.03892735f, 0.04152625f, -0.01826098f, 0.04219515f, 
    0.03458869f, -0.02513282f, -0.01296170f, -0.04382341f, 0.01994351f, -0.03000812f, 0.05447534f, -0.02804075f, 
    0.05026231f, -0.05570452f, -0.05641663f, -0.03299822f, -0.04460586f, -0.00202375f, -0.05570867f, 0.00341342f, 
    -0.04809561f, -0.04017342f, -0.05875994f, -0.01227257f, -0.00782085f, -0.04114821f, 0.05109071f, -0.02723828f, 
    0.00491679f, 0.02750805f, -0.05740494f, 0.01257599f, 0.00390790f, 0.00132527f, 0.02847417f, 0.04757646f, 
    -0.05860912f, 0.00649855f, -0.06492198f, 0.00528942f, -0.01458006f, 0.02622715f, 0.00640146f, 0.04626736f, 
    0.00559288f, -0.00034925f, -0.00212360f, -0.06280170f, 0.04089986f, -0.06087114f, -0.03900225f, 0.02565823f, 
    0.04103035f, 0.04485257f, -0.03498649f, 0.03076977f, -0.03511054f, -0.01606840f, -0.04360981f, 0.00333932f, 
    0.04383033f, -0.05853413f, -0.05017139f, -0.06272599f, 0.00667975f, -0.05299359f, -0.04845699f, 0.01270055f, 
    0.04073823f, 0.03759567f, -0.02894457f, -0.01386208f, -0.00213446f, -0.01978491f, 0.01772706f, 0.00448265f, 
    -0.06193732f, 0.03614265f, -0.04330472f, -0.05968530f, -0.00475738f, 0.04472648f, -0.04332404f, 0.03257667f, 
    0.03171731f, -0.01277064f, -0.02919321f, -0.04527959f, -0.01785933f, 0.00276550f, -0.03020797f, -0.05684940f, 
    -0.01246407f, -0.05120717f, 0.02309561f, -0.03783796f, 0.01657778f, -0.01479089f, 0.04134820f, 0.05309837f, 
    -0.05423072f, -0.00826363f, -0.00933028f, -0.05650737f, 0.04544377f, -0.00618637f, -0.02059331f, 0.04007110f, 
    0.03523701f, -0.05309745f, 0.03775154f, -0.02583336f, 0.01665636f, 0.02308556f, -0.01032744f, -0.06090277f, 
    0.02162256f, -0.03641650f, -0.01091026f, -0.03607369f, 0.01454510f, -0.02650844f, 0.03146615f, -0.04903685f, 
    -0.06322394f, -0.00527924f, -0.00027045f, 0.01985445f, -0.02773996f, 0.04044473f, 0.01339084f, -0.06174906f, 
    0.04618116f, 0.00003743f, 0.04118639f, -0.05959970f, -0.02607641f, -0.05940259f, 0.04651180f, 0.03102347f, 
    -0.01295739f, -0.03468252f, -0.05159999f, 0.02722519f, -0.00510690f, 0.03900786f, 0.00207339f, -0.01652786f, 
    0.00968374f, 0.02899601f, -0.05261124f, 0.03496466f, 0.01275188f, 0.03763276f, -0.05175611f, 0.04580982f, 
    0.05657816f, -0.00468755f, -0.00517850f, 0.05369228f, -0.03818247f, 0.02432588f, 0.01068279f, -0.01453456f, 
    -0.05717452f, 0.04081318f, 0.04314056f, -0.00408609f, 0.02804822f, 0.04907368f, -0.06289944f, -0.06251655f, 
    -0.02169422f, -0.05115956f, 0.00800181f, -0.04531289f, -0.01982663f, -0.03084527f, -0.05067083f, 0.04357542f, 
    -0.01512460f, -0.04897522f, -0.00386856f, -0.00866034f, 0.00736725f, 0.00954785f, 0.03756358f, -0.05360988f, 
    -0.03956162f, -0.02721836f, 0.00150074f, -0.04573271f, 0.01677080f, 0.03209601f, 0.01264371f, 0.02814487f, 
    -0.06178176f, -0.04222572f, 0.00625738f, 0.01109075f, 0.00116245f, 0.02054293f, -0.02811020f, -0.03373916f, 
    0.04658517f, 0.03269389f, -0.03199965f, -0.03591604f, 0.00692905f, -0.00358237f, -0.01736742f, -0.03302108f, 
    0.02663794f, -0.04574381f, 0.04138038f, -0.04160032f, -0.02768273f, -0.04938355f, 0.02755507f, -0.04136052f, 
    0.03906781f, -0.01068018f, 0.03594736f, -0.06058533f, -0.05773604f, 0.00736252f, 0.02745678f, 0.00500563f, 
    0.03863420f, -0.00442734f, 0.03223420f, 0.00709834f, -0.05803494f, 0.00609900f, -0.02976917f, 0.04782549f, 
    0.12518287f, -0.30481514f, 0.59879309f, 0.21388641f, -0.27291864f, -0.28586131f, 0.00300694f, 0.04157396f, 
    0.02056679f, -0.08249108f, 0.37104997f, 0.19638525f, -0.28159165f, 0.12440539f, 0.21692613f, 0.11833157f, 
    -0.13644382f, 0.20859595f, 0.01061779f, 0.10777787f, -0.14566138f, 0.24497941f, 0.15996397f, 0.30076706f, 
    -0.02846682f, 0.11464512f, 0.09467049f, 0.19706558f, 0.02282688f, 0.08772381f, 0.03531539f, 0.16005453f, 
    -0.02141454f, 0.00952715f, 0.06065994f, 0.28292611f, -0.14540119f, 0.45069537f, 0.22758262f, -0.03601314f, 
    0.17366314f, -0.18224953f, -0.07440147f, -0.17743556f, 0.07420185f, -0.09853403f, 0.07662069f, 0.03844697f, 
    -0.10551976f, -0.21917404f, -0.03951179f, -0.16049232f, -0.34178975f, -0.07076345f, 0.07019537f, -0.13884543f, 
    -0.19588929f, 0.07007387f, 0.15787894f, 0.27715540f, -0.09357163f, 0.01762350f, -0.16052616f, -0.25115612f, 
    -0.38274565f, -0.27883309f, -0.09585664f, 0.06553353f, 0.00527112f, 0.09207045f, 0.07937067f, -0.19395830f, 
    -0.32543814f, -0.32327825f, -0.11664484f, -0.01549199f, -0.05651026f, -0.12154410f, -0.01440898f, -0.13514660f, 
    0.10353351f, -0.29935548f, -0.17391276f, -0.14898269f, -0.01649297f, 0.01891559f, -0.07002186f, 0.07231197f, 
    -0.05712542f, -0.12905945f, -0.51884043f, -0.30997476f, -0.20749733f, 0.13427158f, -0.07092656f, 0.25313583f, 
    -0.10582397f, -0.00579503f, -0.04832219f, 0.15773728f, -0.08823497f, -0.11499306f, 0.09434085f, -0.05545817f, 
    0.05769843f, -0.17719215f, -0.10086154f, -0.01451193f, 0.27105355f, 0.12222683f, -0.06984756f, -0.09913208f, 
    -0.03270087f, -0.02826970f, 0.03491923f, 0.16542511f, -0.02699560f, 0.47708789f, 0.19582509f, -0.06020991f, 
    -0.10057361f, 0.04822991f, 0.02330001f, 0.10741676f, -0.13770823f, 0.18699481f, 0.06717249f, -0.33077723f, 
    -0.07756998f, -0.16453880f, 0.07852503f, 0.12489822f, 0.29845700f, -0.07766577f, 0.00768836f, -0.05325938f, 
    0.11930223f, 0.12719990f, 0.16816965f, -0.13334556f, 0.02184882f, 0.08606041f, -0.25716910f, 0.12339494f, 
    0.37256715f, -0.25040984f, -0.10955954f, 0.04771679f, 0.01278416f, 0.11870264f, -0.00525569f, 0.18154487f, 
    -0.09810782f, 0.37870231f, 0.33176920f, 0.11295027f, 0.03709780f, -0.00867527f, 0.09167220f, -0.02225590f, 
    -0.08636932f, -0.07000678f, 0.04290005f, 0.00509820f, -0.17040937f, 0.19410431f, 0.10620708f, 0.06186838f, 
    -0.04319153f, -0.14542572f, 0.17975549f, -0.04762316f, 0.05971294f, -0.32396516f, 0.13372895f, 0.19215971f, 
    0.14149910f, -0.01966685f, 0.01711900f, -0.41015089f, -0.17878805f, -0.18869737f, -0.16751862f, 0.13362646f, 
    -0.02902313f, -0.05130635f, 0.02040120f, -0.10984253f, 0.26639691f, -0.22656846f, -0.02818374f, -0.72978985f, 
    -0.01783871f, -0.05175902f, -0.24803534f, 0.13855641f, 0.08705186f, 0.02893208f, -0.11912987f, -0.04510255f, 
    0.01432441f, -0.05139486f, 0.11144108f, 0.07946824f, 0.00910009f, 0.02044192f, -0.05272204f, -0.00524186f, 
    -0.19263522f, 0.05971533f, 0.19870397f, 0.06777292f, 0.04804561f, -0.05460758f, -0.11735426f, -0.22521441f, 
    0.19266123f, 0.39612421f, 0.14671099f, -0.15802106f, -0.03885600f, 0.46868309f, 0.12267446f, 0.09304679f, 
    -0.15044273f, 0.44234952f, 0.28469947f, 0.20831756f, -0.17496876f, 0.11161673f, 0.05185780f, 0.01422700f, 
    0.07277724f, -0.00858380f, -0.44188100f, -0.39124978f, -0.44363832f, -0.08867577f, -0.00519553f, 0.13419636f, 
    0.09185859f, -0.11910677f, -0.04240137f, -0.22349297f, -0.21435320f, -0.30711660f, 0.04774325f, -0.07797973f, 
    0.02615260f, -0.16672719f, -0.17225894f, -0.18875487f, 0.17792407f, 0.15223369f, -0.43199104f, -0.23391296f, 
    -0.09143645f, 0.07256039f, 0.14174126f, 0.01073802f, -0.02840332f, -0.10072163f, -0.03292614f, -0.13174586f, 
    -0.07042064f, 0.00579774f, -0.06903265f, 0.05882699f, -0.00401011f, -0.12653536f, 0.24557474f, -0.21535510f, 
    -0.15314673f, 0.04174345f, -0.02379151f, 0.04694905f, 0.17621663f, -0.11202186f, 0.18610114f, 0.37733245f, 
    0.40363699f, 0.19207457f, 0.00352530f, 0.02481561f, 0.10120928f, 0.29682839f, -0.07806084f, -0.17273341f, 
    0.03941694f, -0.06105208f, -0.02293570f, -0.00630925f, -0.01197001f, 0.02845388f, -0.01714555f, -0.02704976f, 
    -0.04231663f, -0.03719160f, 0.00931597f, -0.01862333f, -0.06462906f, 0.04602261f, -0.04004901f, -0.02102680f, 
    -0.03563323f, -0.03693852f, -0.01024205f, 0.00180264f, -0.06489845f, 0.02708753f, -0.01625800f, 0.02730211f, 
    0.02340562f, 0.02294820f, 0.04374284f, -0.02883752f, -0.06142410f, -0.03550371f, 0.04654942f, -0.03564375f, 
    -0.02226524f, -0.03253656f, 0.00518742f, 0.00228701f, 0.02147642f, 0.01783630f, -0.00375068f, -0.00798298f, 
    -0.01966890f, 0.04203078f, -0.01830015f, -0.04274932f, -0.05546619f, -0.06464215f, 0.02608178f, -0.06597818f, 
    -0.02341705f, 0.04408371f, -0.06300858f, -0.04057432f, 0.02538659f, -0.03469342f, -0.01475002f, -0.01632781f, 
    0.01435602f, -0.01913009f, 0.02213579f, 0.04208775f, -0.01254967f, 0.04815983f, 0.02033991f, 0.02863977f, 
    -0.06351993f, -0.05728246f, -0.01670806f, -0.05242678f, 0.02031390f, -0.02686038f, 0.00703084f, -0.01758077f, 
    0.00413081f, -0.06863610f, 0.04505277f, 0.03962795f, -0.03462274f, -0.00449697f, 0.00716932f, 0.01468878f, 
    0.04665103f, -0.00687965f, -0.03639856f, -0.04960161f, -0.03363508f, 0.03387383f, 0.04557245f, -0.02929484f, 
    -0.01609362f, -0.03449269f, 0.03134136f, -0.04465967f, -0.01212634f, 0.03661957f, -0.00159856f, -0.03838180f, 
    0.02158347f, 0.04618340f, -0.00891524f, 0.02002037f, 0.04275391f, -0.05086548f, 0.00631438f, -0.03303214f, 
    -0.00917290f, -0.02614728f, -0.03296245f, -0.05601819f, 0.00267826f, 0.01895615f, -0.03941588f, 0.04030603f, 
    0.03685743f, -0.03172860f, -0.03982143f, -0.02839059f, -0.03768775f, 0.02369282f, -0.00848272f, 0.01937852f, 
    -0.02964369f, -0.05470614f, -0.00096812f, 0.02271264f, -0.00822163f, -0.06488027f, -0.02673726f, -0.05684313f, 
    0.03140869f, -0.01650709f, -0.05373741f, 0.01557668f, 0.01069744f, -0.03414913f, -0.04671390f, 0.01504191f, 
    0.00714394f, -0.02705654f, -0.01199974f, -0.01328362f, 0.03475292f, -0.03834722f, -0.02240471f, 0.01248789f, 
    0.04354645f, 0.04699333f, -0.06665491f, 0.04007298f, -0.02079333f, 0.01274414f, -0.02159442f, 0.02241609f, 
    -0.02645390f, -0.03239041f, -0.01734690f, 0.04891958f, 0.03233968f, 0.01901532f, 0.02714186f, 0.04293974f, 
    -0.01265286f, -0.03796696f, -0.06028055f, 0.03363618f, -0.04006129f, -0.03441367f, -0.03447812f, -0.04670039f, 
    -0.00836944f, -0.05202070f, -0.00427089f, 0.03865937f, -0.04877290f, 0.02572230f, -0.05951729f, -0.03074045f, 
    -0.03111177f, 0.00530628f, 0.01050995f, -0.04107090f, -0.04159070f, -0.05583664f, -0.06277232f, 0.00308767f, 
    -0.03999845f, -0.05214543f, -0.03464808f, -0.05660038f, -0.00645948f, 0.03738987f, 0.02416147f, 0.00259673f, 
    -0.02787986f, -0.02937848f, -0.05667084f, 0.02727417f, -0.00761785f, 0.01407405f, -0.05466859f, 0.01102024f, 
    0.00083828f, 0.00988749f, -0.04246692f, -0.06576167f, -0.03485750f, 0.02834344f, 0.02803794f, 0.01155316f, 
    -0.06817150f, -0.02237159f, -0.06499986f, -0.03290543f, -0.00400331f, -0.06070907f, 0.04225535f, 0.00591882f, 
    -0.04523795f, 0.03592822f, 0.03925822f, 0.04665509f, -0.01766153f, -0.03158290f, -0.05014213f, -0.06050169f, 
    -0.06387199f, -0.00311395f, -0.00136324f, -0.01459381f, -0.01171036f, -0.06677186f, 0.01800861f, 0.00881421f, 
    0.02997869f, -0.03025683f, -0.02831913f, -0.05045009f, 0.02144383f, -0.04533481f, -0.00099021f, -0.03566170f, 
    -0.02522925f, -0.05480037f, 0.03769591f, 0.01067081f, 0.00706460f, -0.05782629f, -0.02870615f, 0.02321563f, 
    -0.04690691f, 0.02119854f, -0.00499894f, 0.02108771f, -0.04994220f, -0.00246485f, -0.01577574f, 0.02717069f, 
    0.04993699f, 0.03360659f, 0.01071400f, -0.00917442f, -0.04592059f, 0.00724627f, 0.04337016f, -0.00733122f, 
    0.04351885f, 0.03505516f, 0.04232261f, 0.00067794f, -0.01873287f, -0.05099692f, -0.05442310f, -0.03732067f, 
    -0.04011384f, 0.00184695f, -0.00798055f, -0.00679875f, -0.05210031f, -0.05998059f, 0.02211930f, 0.00205429f, 
    0.03049096f, -0.02532734f, 0.03273057f, -0.02528050f, 0.00007837f, -0.04879355f, 0.00340909f, -0.03599264f, 
    0.00718439f, 0.00810074f, -0.04198264f, -0.02752593f, -0.06103534f, 0.02232409f, 0.03387724f, -0.03374810f, 
    -0.00352241f, 0.02842477f, 0.04169594f, 0.03365511f, -0.05948872f, -0.03456618f, -0.00997078f, -0.05190945f, 
    0.04425355f, -0.05616490f, -0.02180339f, -0.05922113f, 0.03440079f, 0.04448918f, 0.02420241f, -0.04249739f, 
    0.04809878f, -0.05810224f, -0.00689062f, -0.03360173f, 0.03908307f, 0.01614253f, 0.01662532f, -0.05076843f, 
    0.05087410f, 0.01590139f, 0.01980455f, -0.05426608f, 0.02817182f, 0.01531674f, 0.04901809f, 0.05665699f, 
    -0.05562236f, 0.02246128f, 0.02616456f, -0.02391427f, -0.01242288f, -0.01703057f, 0.04647173f, -0.04333519f, 
    -0.04569017f, 0.00247639f, 0.03285170f, 0.01625653f, -0.04577298f, 0.02577004f, 0.00408611f, 0.00916748f, 
    0.02501575f, 0.05093882f, -0.02577059f, 0.02131489f, -0.02967572f, 0.03135745f, -0.06114339f, -0.02895803f, 
    0.04524089f, -0.03604644f, -0.02940600f, 0.04512800f, 0.01789763f, 0.01593163f, -0.02343833f, 0.04753620f, 
    -0.00526817f, -0.05683612f, -0.03839965f, 0.00443024f, -0.02106152f, -0.05837234f, -0.01645396f, -0.04239431f, 
    0.01730954f, -0.04537155f, 0.04762615f, 0.01527177f, -0.02189417f, 0.00129495f, 0.04244366f, -0.03495555f, 
    -0.01728589f, -0.02207868f, -0.01642710f, 0.01660413f, 0.03176744f, -0.03934799f, -0.05011348f, -0.03585020f, 
    0.03388647f, -0.02161505f, -0.03570450f, -0.02646363f, -0.03276592f, -0.05398688f, 0.01282496f, -0.02838047f, 
    -0.01300493f, -0.02366629f, 0.03498465f, -0.02191461f, -0.05436671f, -0.02876250f, 0.02151847f, -0.02025375f, 
    -0.00228353f, -0.06317474f, -0.02276796f, -0.06236777f, -0.03177968f, -0.06473443f, -0.02230402f, 0.04701151f, 
    -0.03605929f, 0.00743282f, -0.02706355f, -0.05300608f, -0.00608763f, 0.01431370f, -0.06226664f, -0.00197916f, 
    0.04170938f, 0.03821762f, 0.03539589f, 0.03470905f, -0.01393500f, -0.05167694f, -0.02523552f, 0.02112584f, 
    0.04744618f, -0.04884357f, 0.04691802f, -0.06240794f, 0.00012723f, 0.01352519f, -0.05258635f, -0.01886155f, 
    -0.00804621f, -0.04761232f, -0.04856355f, -0.04749553f, 0.01924444f, 0.04652775f, -0.04804391f, 0.01885290f, 
    0.03835954f, 0.00643184f, 0.05047494f, -0.00113635f, -0.04195935f, 0.04501505f, -0.04446429f, -0.06197856f, 
    -0.00421161f, 0.03361650f, -0.04276547f, -0.00685938f, -0.04876888f, -0.01352858f, -0.00592831f, 0.01200973f, 
    -0.00585494f, -0.00103804f, -0.01677824f, -0.05322796f, 0.00719150f, -0.03715913f, 0.03760026f, 0.00721056f, 
    0.03433301f, 0.04809390f, -0.03825289f, -0.03712925f, 0.00244439f, -0.04471814f, -0.04345164f, 0.03315979f, 
    -0.03148434f, -0.01743309f, -0.00296292f, 0.01553424f, -0.04188147f, -0.04076255f, -0.00912894f, 0.00494943f, 
    0.00231777f, -0.05074543f, -0.02117940f, 0.02184572f, -0.06331644f, 0.03642745f, -0.01323766f, -0.01726825f, 
    0.03638087f, 0.00558356f, -0.03125225f, -0.05854212f, -0.02651010f, 0.02049472f, 0.02904702f, -0.05163899f, 
    0.03543097f, -0.05231522f, -0.01809047f, -0.06286897f, -0.00882979f, 0.02554489f, -0.04635878f, -0.04769051f, 
    -0.05917484f, -0.06391016f, 0.03076642f, -0.01660286f, 0.01680064f, -0.03748513f, -0.01971136f, 0.01822974f, 
    -0.00771831f, -0.04341505f, 0.03826462f, 0.01955003f, -0.00793943f, -0.01746818f, 0.00879329f, -0.02397948f, 
    0.01317173f, 0.00936126f, -0.04916968f, -0.05080665f, -0.03627023f, -0.02277577f, -0.00589942f, 0.05106848f, 
    -0.04493479f, -0.05637369f, 0.04295494f, -0.05366396f, 0.04152753f, -0.03269523f, -0.04512747f, 0.00787576f, 
    -0.01272017f, 0.03847266f, -0.00913438f, 0.00139880f, 0.04907795f, 0.00735366f, -0.01295500f, -0.03740656f, 
    -0.03719215f, 0.03009270f, 0.01021271f, -0.00059053f, -0.01150544f, 0.03156821f, 0.03893959f, -0.03902931f, 
    -0.01225504f, 0.03401589f, 0.04147325f, 0.01468073f, -0.03935117f, 0.05795215f, -0.04533999f, -0.02996499f, 
    0.03327889f, -0.05175117f, -0.00861133f, 0.04246683f, -0.00850952f, -0.06040838f, 0.00010148f, -0.06452051f, 
    0.04428478f, 0.03247937f, -0.05866858f, -0.05234369f, -0.05243648f, -0.03918585f, -0.01988223f, 0.05128634f, 
    0.28893974f, -0.05252921f, -0.03332107f, 0.16175184f, 0.12251364f, -0.05576173f, -0.02329309f, -0.02047978f, 
    0.19318749f, -0.12722012f, 0.13132738f, -0.28848478f, 0.05766915f, -0.37280089f, 0.12656005f, -0.07514075f, 
    0.32224202f, 0.10214397f, 0.11807905f, 0.09761007f, -0.25047839f, 0.02693674f, -0.17124704f, 0.04599448f, 
    -0.02439074f, 0.02921104f, 0.06016447f, -0.22077520f, -0.37511361f, -0.00048625f, 0.20888124f, 0.07961885f, 
    -0.24579963f, -0.03082465f, -0.19437163f, -0.13504373f, -0.27551410f, -0.40247393f, -0.33408788f, 0.14211084f, 
    0.15571998f, 0.09986623f, 0.02590065f, 0.08663002f, 0.12774676f, 0.61275417f, 0.20472322f, -0.10921612f, 
    0.06917648f, -0.01199149f, 0.26423755f, -0.05600226f, 0.00767042f, 0.15322454f, -0.31243151f, -0.19374964f, 
    -0.10411934f, 0.20482686f, -0.15760872f, -0.02138382f, -0.00222255f, -0.09929205f, -0.12552902f, -0.09553456f, 
    0.03281328f, -0.07112779f, 0.09118951f, 0.15494344f, 0.17277065f, -0.01726265f, 0.06720545f, -0.16441935f, 
    0.15741432f, -0.22861987f, -0.07361861f, 0.02626849f, 0.18740557f, 0.02825647f, 0.02202456f, -0.06231604f, 
    0.00193543f, -0.18182838f, 0.09215731f, 0.02328783f, 0.13978590f, 0.11998594f, 0.06838514f, 0.04136731f, 
    0.10175790f, 0.09478448f, 0.01779467f, -0.21221909f, 0.16527919f, -0.21214262f, 0.33705199f, -0.01730727f, 
    -0.26042601f, -0.01374385f, -0.06335568f, 0.25821206f, 0.28767806f, 0.06431489f, 0.00856707f, -0.01129491f, 
    -0.10764191f, 0.13273303f, 0.17346504f, 0.20998003f, -0.03724740f, -0.10305926f, 0.02037747f, 0.06227440f, 
    0.00225548f, -0.14109124f, 0.01793752f, 0.11810031f, -0.13658877f, 0.50347698f, 0.23236255f, -0.07456439f, 
    0.15630181f, -0.17382875f, 0.01672148f, 0.28749892f, -0.08415013f, -0.10659274f, -0.27232984f, -0.29166692f, 
    -0.06304575f, -0.02695394f, 0.30232647f, -0.07323604f, 0.07717248f, -0.05109210f, -0.36732420f, -0.29941368f, 
    0.43079767f, 0.00554524f, 0.04780891f, 0.11099295f, -0.05103172f, -0.06513213f, 0.04113473f, -0.19829471f, 
    -0.20677882f, 0.03035324f, -0.18723416f, 0.18642789f, -0.11990701f, 0.09181812f, -0.42496422f, 0.21523318f, 
    0.04095319f, 0.35902575f, -0.18250106f, -0.23912856f, 0.08382097f, 0.16598737f, 0.16340737f, 0.06724432f, 
    -0.20263451f, 0.35075450f, 0.45770901f, -0.35661551f, -0.02145241f, 0.03012636f, 0.02037024f, 0.21189918f, 
    0.21963967f, 0.00506064f, -0.37162396f, 0.32483986f, -0.11638829f, -0.07728046f, -0.26370433f, -0.09311980f, 
    -0.00332678f, -0.09986355f, 0.09921096f, -0.02638850f, -0.00532706f, -0.13402446f, -0.23494861f, -0.29582965f, 
    0.14752476f, -0.03004927f, 0.18426159f, 0.15021341f, 0.05265304f, -0.09243821f, -0.03571516f, -0.02243179f, 
    0.01637838f, -0.45815897f, 0.29643661f, 0.25803456f, 0.04848304f, -0.29010627f, 0.30895665f, 0.05158979f, 
    -0.05281835f, 0.13780157f, 0.05766328f, 0.01864226f, 0.03416526f, -0.14433052f, 0.06925642f, -0.23802711f, 
    0.08667409f, -0.12389504f, -0.08131766f, 0.13063331f, 0.05467568f, 0.04443835f, 0.02058159f, -0.03132380f, 
    0.02940477f, -0.66390204f, -0.15977859f, 0.26289493f, -0.00066139f, -0.07036312f, 0.18096887f, 0.13467741f, 
    0.24543099f, 0.12237154f, 0.07656983f, 0.06567306f, -0.07337025f, 0.12510802f, 0.03865677f, -0.06007329f, 
    -0.02922383f, 0.08461788f, -0.55851579f, 0.05640419f, -0.04029742f, 0.11439420f, 0.27201775f, -0.05837226f, 
    -0.02314081f, 0.06298226f, 0.04241289f, -0.27974540f, 0.10895277f, 0.06608804f, 0.03830809f, 0.21419311f, 
    -0.00130553f, -0.14715463f, 0.10808900f, -0.19667895f, 0.09387097f, 0.04610398f, 0.05303400f, -0.12893857f, 
    0.10453251f, 0.09765188f, -0.04753895f, 0.23334831f, -0.15269634f, -0.22843035f, 0.26497751f, -0.00464596f, 
    0.06646851f, -0.00036806f, 0.06656765f, -0.05063989f, -0.01958833f, 0.20975938f, -0.07055777f, 0.02575752f, 
    0.00243832f, -0.33253536f, 0.07246482f, -0.14632048f, -0.06764627f, 0.09978803f, 0.01748215f, 0.77838385f, 
    -0.20461093f, -0.14304288f, 0.03434389f, -0.09837305f, 0.06715823f, -0.01371309f, 0.16845246f, 0.11597794f, 
    0.00588032f, 0.03236317f, -0.05554460f, -0.00569504f, 0.04935649f, 0.04619577f, -0.01750334f, -0.04936272f, 
    -0.04966138f, 0.01896405f, -0.04860647f, 0.04246593f, 0.02628880f, 0.04193147f, 0.00349883f, 0.02803564f, 
    -0.00120016f, 0.03313632f, -0.01843411f, -0.05311133f, -0.03627097f, 0.03068868f, 0.02394924f, 0.04165307f, 
    -0.01038100f, 0.00926256f, 0.01072411f, 0.02626388f, -0.01242654f, -0.05304931f, 0.02318429f, -0.03487131f, 
    -0.05663750f, -0.04366878f, -0.04776200f, -0.04817542f, -0.05309123f, -0.01740216f, -0.03194262f, 0.02549689f, 
    0.02829451f, -0.04342281f, -0.01940508f, -0.05584446f, -0.02223145f, 0.04174190f, -0.00530675f, 0.05249513f, 
    -0.03981877f, -0.05718242f, 0.03780734f, 0.00138015f, 0.03121266f, -0.04639379f, -0.03442085f, 0.02927177f, 
    -0.00678480f, 0.02316078f, -0.01549220f, -0.00689011f, -0.02656552f, -0.04351619f, -0.04557383f, 0.04240970f, 
    -0.00701039f, -0.05536926f, 0.00404709f, -0.03564739f, 0.04600063f, -0.00262536f, 0.03403092f, 0.00588126f, 
    0.03496184f, 0.05115709f, -0.02468209f, -0.03321915f, -0.03584626f, 0.04692260f, -0.02404710f, 0.04197272f, 
    -0.06794415f, -0.04565014f, 0.04715644f, -0.00075973f, 0.02109107f, 0.00446145f, 0.04085053f, -0.03804019f, 
    -0.06525555f, -0.00284670f, 0.04741333f, -0.01062451f, -0.06275692f, 0.04339622f, -0.05264791f, 0.03080569f, 
    -0.01485677f, -0.02774095f, -0.06372158f, -0.02849532f, 0.01456113f, -0.07313366f, 0.01059395f, 0.02166135f, 
    0.00906512f, -0.03560421f, 0.01365934f, 0.00399264f, 0.00385661f, 0.02756734f, 0.01079564f, 0.01570486f, 
    -0.02887378f, 0.03108645f, 0.03261992f, -0.02811637f, -0.05177847f, 0.03881676f, 0.02299313f, 0.00148627f, 
    -0.03932850f, 0.01197051f, -0.02483125f, -0.01139066f, 0.00535034f, -0.02852704f, -0.04945559f, 0.05647140f, 
    0.02354337f, -0.02510152f, 0.01529813f, 0.03534897f, -0.00444655f, -0.04080373f, -0.02465681f, -0.01940168f, 
    0.00423684f, -0.01101280f, 0.01182506f, -0.03063302f, -0.00547927f, 0.02402865f, -0.01315542f, 0.01447573f, 
    0.04638936f, -0.02525082f, 0.02769840f, 0.04995436f, 0.02564353f, 0.02078113f, -0.03210691f, 0.02501222f, 
    0.02919166f, -0.03139634f, 0.01804580f, -0.01094258f, 0.01774882f, 0.02817160f, 0.02280604f, 0.00106523f, 
    0.03336629f, -0.05196648f, 0.01309466f, 0.06128427f, -0.01950712f, 0.03802253f, 0.03284541f, -0.01908180f, 
    -0.05873392f, 0.01018996f, -0.00084988f, -0.00658320f, -0.03342085f, 0.02882148f, 0.05192408f, -0.04716314f, 
    0.00389738f, 0.02400851f, -0.03214977f, -0.02571421f, -0.00366533f, -0.00444630f, -0.00543530f, -0.02024442f, 
    0.03946220f, -0.05016350f, -0.06087097f, -0.04912575f, -0.02108141f, 0.06081216f, -0.05028111f, 0.02649555f, 
    -0.00556171f, 0.02993263f, -0.04463319f, 0.04523705f, -0.04829641f, -0.02711138f, 0.00920514f, -0.04309707f, 
    -0.03648847f, 0.01900887f, 0.02971024f, -0.03984657f, -0.02962839f, 0.00921458f, -0.03936965f, -0.05092226f, 
    -0.03574877f, -0.01981012f, -0.01399723f, -0.04956589f, 0.05504836f, 0.02730922f, 0.05005748f, -0.03199700f, 
    0.05778496f, 0.05822417f, 0.04930035f, 0.03065185f, -0.05717054f, -0.00312415f, -0.03028574f, 0.00799809f, 
    -0.05926820f, 0.00532254f, 0.03682880f, 0.00789567f, -0.05013923f, 0.01245461f, 0.00906934f, 0.03288712f, 
    -0.03775130f, 0.02063726f, -0.05264916f, -0.00782781f, -0.06236314f, -0.03971301f, 0.01155434f, -0.01897926f, 
    0.00840842f, -0.00787930f, -0.05593619f, -0.06020057f, 0.03920031f, -0.05728928f, 0.03407673f, -0.02482759f, 
    -0.01779793f, -0.00312903f, -0.02490967f, -0.04294838f, 0.00394890f, -0.00934782f, -0.07423445f, -0.04388901f, 
    -0.05131004f, 0.01356571f, 0.00643989f, -0.01831047f, -0.01428155f, -0.04123066f, 0.03321245f, -0.02558303f, 
    0.00569448f, -0.03030502f, 0.00350887f, -0.04470154f, -0.04669598f, -0.04247631f, -0.04595672f, -0.02247723f, 
    -0.04405015f, 0.03088509f, 0.01820289f, -0.02942943f, -0.00182776f, -0.02404187f, -0.01001110f, 0.02613781f, 
    0.02914625f, -0.01407074f, -0.04916047f, 0.05062399f, -0.04312821f, 0.02889625f, 0.00995607f, 0.00627037f, 
    0.31445551f, -0.20150200f, -0.29426363f, 0.02329052f, -0.20357606f, 0.01156443f, -0.25458860f, 0.05309101f, 
    -0.08461125f, -0.63951659f, 0.47345370f, 0.31133494f, 0.03741112f, 0.07706758f, -0.07658941f, -0.08856282f, 
    0.05346474f, 0.00039380f, -0.09083248f, 0.29443789f, 0.29558864f, 0.11796898f, 0.11928798f, -0.25703743f, 
    0.13388246f, 0.19536795f, -0.23250195f, -0.17291653f, -0.06513662f, -0.14097464f, -0.10804319f, 0.15577085f, 
    0.05734328f, -0.07795095f, 0.02291333f, 0.03210793f, -0.52958083f, -0.03356189f, 0.18177494f, -0.06082494f, 
    -0.32137778f, 0.14050217f, 0.06226068f, -0.02860414f, 0.25760752f, -0.11059425f, 0.05117739f, -0.22670643f, 
    -0.12860897f, 0.04285066f, -0.16508859f, -0.06616724f, 0.08539680f, 0.05743291f, 0.60415858f, 0.22984086f, 
    -0.05286811f, -0.24050750f, -0.12108429f, 0.14729358f, -0.33124274f, -0.00754241f, -0.06445646f, 0.59360516f, 
    -0.14319970f, 0.08688190f, -0.21811262f, -0.22062996f, 0.14276940f, -0.06371637f, 0.19273768f, 0.15986340f, 
    0.01740265f, -0.27175447f, 0.25108564f, -0.08153165f, -0.18690455f, 0.16520815f, -0.08518808f, 0.22765963f, 
    0.18030287f, 0.48726270f, 0.13699906f, 0.03196493f, -0.29376829f, -0.04190026f, -0.31557035f, -0.05460141f, 
    0.00343250f, -0.08503285f, 0.26755989f, -0.03371346f, -0.04958352f, 0.40353000f, -0.29720399f, -0.37972289f, 
    0.02401717f, 0.10962443f, 0.20699380f, 0.30859983f, -0.26637024f, -0.12418229f, -0.15377162f, 0.09847308f, 
    0.14428538f, 0.08843513f, -0.07000650f, 0.05151577f, 0.20685607f, -0.30348018f, 0.14362042f, -0.24014258f, 
    0.16051896f, -0.00108589f, -0.19860764f, -0.14902860f, 0.06356050f, -0.36214942f, 0.37708122f, 0.12512581f, 
    0.36287603f, 0.20518579f, 0.12309899f, -0.19184855f, 0.11639754f, -0.13293391f, 0.00872537f, -0.24573104f, 
    -0.14848885f, -0.22738180f, 0.13673589f, -0.25287050f, -0.19151072f, 0.00093363f, -0.14791672f, 0.42314330f, 
    -0.08173621f, -0.39700618f, -0.08472507f, -0.08955084f, 0.17726444f, -0.00787202f, 0.08457109f, -0.03408882f, 
    0.22042611f, -0.34274530f, 0.11942545f, 0.03300150f, 0.08291156f, -0.06317481f, -0.10566287f, 0.05339206f, 
    -0.08258035f, -0.32958981f, -0.11631729f, 0.06015382f, 0.00537060f, 0.18618394f, -0.01957177f, 0.03624095f, 
    -0.10170967f, -0.00872487f, 0.29096511f, 0.22104360f, 0.26489338f, 0.31606007f, 0.06749829f, -0.04882749f, 
    -0.22140372f, 0.15401468f, 0.11551578f, 0.04411425f, 0.31986460f, 0.14251855f, 0.09847578f, 0.18926965f, 
    -0.17017466f, -0.03987683f, -0.02816474f, -0.01820832f, 0.56036747f, -0.22161931f, -0.03900015f, 0.17760083f, 
    -0.21112236f, -0.18693559f, -0.19627488f, 0.09211279f, -0.13364576f, 0.36931953f, -0.35018957f, -0.05254869f, 
    -0.14859280f, 0.15714650f, -0.12862419f, -0.06513131f, -0.10850874f, 0.17991303f, -0.26763076f, -0.15220644f, 
    0.26575455f, -0.16798578f, 0.07239146f, -0.14005813f, -0.18213017f, 0.18073697f, 0.16818133f, 0.17785296f, 
    0.20784332f, 0.12727147f, 0.15279639f, -0.07994776f, 0.05573703f, -0.07109427f, -0.07092910f, -0.00276207f, 
    -0.61828822f, 0.07266915f, 0.08937254f, 0.19917831f, 0.19958729f, 0.12776400f, -0.09659419f, -0.07288618f, 
    -0.03541653f, -0.63016313f, 0.38753852f, -0.06833569f, 0.03240062f, 0.05231010f, 0.34509373f, 0.00904503f, 
    -0.09137797f, -0.22725467f, 0.89578539f, -0.10722973f, -0.05041530f, -0.18718110f, -0.19486566f, 0.15143508f, 
    -0.08077249f, 0.04976597f, -0.09008704f, 0.32106784f, 0.14139542f, -0.01143420f, -0.01723525f, 0.18267530f, 
    -0.03334965f, -0.04342440f, 0.08124003f, 0.16930087f, -0.64393437f, -0.07272938f, 0.07134750f, -0.05004276f, 
    0.13423140f, -0.00111737f, 0.16396511f, -0.07194587f, 0.15712394f, 0.23138621f, -0.32374933f, -0.21599728f, 
    -0.16638960f, 0.18056233f, -0.01968742f, 0.14904264f, 0.11934052f, -0.09304526f, 0.70118678f, -0.24229638f, 
    -0.19024685f, -0.26279190f, 0.00612782f, -0.21718134f, -0.02038180f, 0.23613480f, 0.04868516f, -0.21985216f, 
    0.42945638f, 0.12644736f, 0.25326151f, 0.11326332f, -0.07930289f, 0.16808954f, -0.07098145f, -0.04129143f, 
    0.12456804f, 0.13203830f, -0.31216216f, 0.02939945f, -0.04541125f, 0.11073794f, -0.10309170f, 0.09218569f, 
    -0.08778966f, 0.19981886f, -0.07637947f, 0.25276291f, -0.03427426f, 0.11824308f, 0.12838677f, 0.24259929f, 
    -0.10251923f, -0.08519655f, 0.09205125f, 0.05138504f, -0.14220515f, 0.03545662f, 0.00023117f, -0.02329142f, 
    0.18272121f, 0.08098649f, 0.21194789f, -0.33917156f, -0.19308928f, -0.34802288f, 0.22130537f, 0.01026323f, 
    -0.05117989f, 0.15479890f, -0.04173246f, -0.06184324f, 0.48630440f, 0.04094137f, -0.08551297f, -0.13492794f, 
    0.11595097f, -0.03405587f, 0.15873313f, -0.02744543f, -0.08494238f, -0.07552473f, -0.10990378f, -0.33413967f, 
    -0.19277422f, -0.06202670f, -0.02412726f, -0.01941438f, 0.00228729f, 0.10038716f, 0.13095866f, 0.08410539f, 
    -0.22250327f, 0.08471840f, 0.22437413f, -0.02277804f, 0.01932907f, 0.20519494f, 0.13897058f, -0.06792734f, 
    -0.29337001f, -0.03298743f, -0.21061139f, -0.23744306f, -0.03037317f, -0.18799683f, -0.02359785f, 0.08213145f, 
    0.14280540f, -0.07894233f, -0.18739012f, -0.25074425f, -0.17924614f, -0.06588911f, -0.14891237f, -0.02753551f, 
    -0.00580344f, -0.14196952f, -0.02855136f, 0.06644941f, -0.24357511f, -0.25886050f, 0.30391461f, 0.04319618f, 
    0.25809583f, 0.25221869f, -0.02223859f, -0.28609741f, 0.15235397f, -0.08888083f, -0.21667731f, -0.24579826f, 
    0.01275515f, -0.01635205f, 0.16046350f, -0.02694011f, 0.10703643f, -0.02839478f, -0.17857148f, -0.11021078f, 
    0.06661159f, -0.05599825f, 0.00214154f, 0.10349903f, 0.09820268f, 0.25180751f, 0.08326003f, -0.14671718f, 
    -0.01974875f, 0.05758673f, -0.10238729f, 0.05664671f, -0.09298205f, 0.27857190f, 0.08941936f, -0.52752876f, 
    0.19975752f, -0.02638192f, 0.13205239f, 0.26313949f, -0.17654128f, -0.08877486f, 0.12186997f, 0.00277186f, 
    -0.37336099f, 0.27716583f, -0.27691761f, 0.00130720f, 0.01969656f, -0.08473568f, -0.13634627f, 0.17779501f, 
    0.25566408f, 0.15254915f, 0.12984569f, -0.06989611f, -0.06374236f, -0.13440834f, 0.16725791f, 0.09774072f, 
    -0.12813865f, -0.27289060f, -0.04438481f, 0.08710603f, 0.09705649f, 0.20683622f, 0.10009920f, -0.08188979f, 
    0.07797968f, 0.23827031f, 0.05005935f, -0.05675686f, -0.04566386f, -0.21774180f, -0.05922710f, -0.10345550f, 
    0.00127812f, 0.07914978f, 0.38302565f, 0.11493436f, -0.36204356f, -0.09240034f, 0.20019279f, -0.03652628f, 
    0.21071497f, -0.08497282f, 0.02393586f, 0.24038324f, 0.27360582f, -0.23302212f, 0.06028221f, -0.11826417f, 
    -0.15395337f, 0.16742925f, 0.09977898f, 0.38625711f, -0.09773253f, -0.21916558f, -0.08590929f, 0.00870011f, 
    -0.27208838f, 0.00902560f, 0.06370649f, -0.11750741f, 0.04955391f, 0.31972474f, 0.14369568f, 0.11382812f, 
    0.08915249f, 0.29170361f, -0.14683484f, -0.11264080f, -0.08743828f, -0.09088525f, -0.08587396f, 0.11171896f, 
    -0.24106883f, 0.17207718f, -0.03946000f, -0.03798832f, 0.09787260f, 0.04828716f, -0.04690166f, 0.13666661f, 
    -0.28790757f, 0.02599899f, 0.00122993f, -0.08365761f, -0.00808383f, -0.02486478f, 0.05745939f, 0.08629299f, 
    0.26716214f, 0.10088961f, 0.06661382f, 0.12031292f, 0.12909152f, -0.14480592f, 0.00719634f, 0.19689392f, 
    0.05861810f, 0.26703191f, 0.06364978f, -0.15494008f, 0.11232278f, -0.16333114f, 0.12043071f, 0.07652323f, 
    0.08820140f, -0.02721347f, -0.17489059f, -0.11546798f, -0.08703323f, -0.15820268f, -0.08347809f, -0.01470989f, 
    0.08814254f, 0.01275015f, -0.10761351f, -0.54959846f, -0.47220135f, -0.33873892f, 0.09538100f, -0.34627774f, 
    0.07109842f, 0.16108210f, -0.11318658f, 0.06177912f, 0.21163264f, 0.20187557f, -0.05066085f, -0.11049439f, 
    -0.03865611f, 0.09639200f, 0.12183811f, 0.01614993f, -0.07099999f, 0.10115052f, -0.08019654f, 0.22227761f, 
    -0.17960428f, -0.16797304f, -0.13176811f, 0.13532519f, 0.00479192f, 0.04954962f, -0.30642286f, -0.20251247f, 
    0.21108797f, -0.08466103f, 0.33957231f, 0.05583181f, -0.02946065f, -0.09008106f, -0.05214952f, 0.14845252f, 
    0.04702453f, 0.08007219f, 0.14746352f, -0.11785156f, 0.05334942f, -0.10384595f, -0.14455795f, -0.14478870f, 
    0.03054271f, 0.02511230f, -0.01928800f, 0.01862569f, -0.05636213f, -0.01920697f, 0.01538211f, 0.04499443f, 
    0.02172723f, -0.04061052f, -0.03146560f, 0.04259938f, 0.00801344f, -0.02806472f, -0.04148383f, -0.06909136f, 
    -0.06089690f, 0.01782356f, 0.02103040f, -0.04049088f, 0.00481324f, -0.01580602f, -0.04627036f, 0.02387269f, 
    -0.04715114f, 0.01085647f, -0.03891217f, 0.03282034f, -0.03427158f, -0.01983127f, 0.00901239f, -0.01968212f, 
    -0.05369259f, 0.00699410f, -0.01794134f, -0.01549267f, 0.00221272f, -0.02341473f, -0.04434567f, -0.03875471f, 
    -0.04725433f, -0.01908456f, 0.01754184f, -0.03850405f, -0.03822714f, -0.03160333f, -0.01018822f, -0.02805157f, 
    -0.05848113f, 0.02720790f, -0.04341188f, -0.01027899f, 0.03316215f, -0.03017419f, -0.01530142f, -0.03091468f, 
    -0.00825258f, -0.02508293f, -0.02523112f, 0.04301075f, -0.01923170f, 0.01582797f, 0.04361919f, -0.05654471f, 
    -0.03550817f, 0.02750783f, -0.01509534f, -0.02844619f, -0.01712092f, -0.00087415f, 0.03406388f, 0.03426848f, 
    0.00013729f, -0.04995694f, -0.06097111f, -0.02720782f, -0.05000555f, 0.04752757f, -0.00793256f, -0.05842583f, 
    0.01848984f, -0.05939202f, 0.02427774f, -0.04314565f, -0.01099251f, 0.01324209f, -0.02934469f, 0.00164331f, 
    -0.04013378f, -0.02466134f, 0.03941809f, -0.05024473f, -0.06345667f, 0.04313681f, 0.00256460f, -0.05106568f, 
    0.02219600f, -0.06387056f, -0.05606740f, 0.04851497f, -0.00373126f, -0.05110853f, 0.01005663f, -0.03239766f, 
    -0.03195244f, 0.02762703f, -0.05107575f, -0.05255793f, 0.03470869f, 0.02325664f, -0.02077997f, -0.01221241f, 
    -0.06420889f, 0.00568411f, 0.03134380f, -0.02092184f, -0.03836482f, 0.04450329f, -0.02295308f, 0.00806973f, 
    -0.03238657f, -0.00015693f, 0.05355724f, -0.01573133f, -0.01571380f, -0.02028728f, -0.00011458f, -0.05117897f, 
    -0.01353375f, -0.02147313f, -0.01481417f, -0.05115759f, -0.05744120f, -0.04062812f, -0.05714960f, 0.04259332f, 
    0.02193700f, -0.03644519f, 0.03430405f, -0.00770142f, 0.01285396f, -0.00601606f, 0.04073493f, 0.00351276f, 
    -0.01476426f, -0.01946912f, -0.01294676f, 0.01004871f, 0.05199739f, 0.01304792f, -0.02359127f, 0.02257068f, 
    -0.02698551f, -0.04751602f, 0.03149230f, 0.01517476f, -0.02909142f, 0.03735326f, -0.01676074f, 0.01866000f, 
    -0.01088704f, 0.01859847f, 0.04846919f, -0.03187438f, -0.06600926f, -0.01820318f, 0.03337273f, 0.04447067f, 
    -0.02053092f, -0.06468173f, -0.02798602f, 0.00668769f, -0.04147595f, -0.03496966f, 0.04375851f, -0.01116098f, 
    -0.01185356f, -0.01471675f, -0.01471334f, -0.06205309f, -0.02309796f, 0.01089128f, 0.02130741f, -0.00684700f, 
    -0.04869074f, -0.03025513f, 0.03928671f, -0.03088124f, -0.01413574f, 0.00963962f, -0.02413256f, 0.01555204f, 
    -0.01373768f, -0.02625394f, -0.00635096f, 0.00766450f, 0.02506586f, 0.02689569f, -0.00891806f, 0.00615445f, 
    -0.02489475f, 0.00322790f, -0.05503928f, -0.00946228f, 0.02118095f, 0.00795654f, -0.06088122f, 0.04964290f, 
    0.03851783f, -0.00520464f, 0.01998751f, -0.06005183f, -0.04395473f, -0.04179538f, 0.04581119f, 0.00618882f, 
    -0.00107994f, -0.03963006f, -0.03248646f, 0.01414657f, 0.03735629f, -0.03371780f, 0.02240596f, 0.04305906f, 
    -0.01943547f, -0.05334504f, 0.01114531f, 0.00802294f, -0.01317897f, -0.04953210f, -0.03941474f, -0.04479621f, 
    -0.01887040f, 0.03693436f, 0.01699143f, 0.03054062f, 0.01762087f, 0.01471294f, -0.02063009f, -0.04102842f, 
    -0.02927459f, -0.03172341f, -0.05259604f, -0.04667381f, 0.00831026f, 0.04900103f, -0.05923039f, 0.02717401f, 
    0.00436123f, -0.03952140f, 0.00323736f, 0.03327847f, 0.03047624f, -0.04486560f, -0.06542961f, -0.03786798f, 
    0.02840501f, 0.03236039f, -0.05341790f, -0.06556659f, -0.02219866f, -0.04083759f, 0.03249128f, -0.04170401f, 
    0.04629028f, 0.02590073f, 0.04225914f, -0.04366673f, 0.01319519f, 0.06513261f, -0.04391878f, 0.03045583f, 
    0.04660747f, 0.01936468f, -0.04226841f, 0.04467534f, -0.06286195f, -0.01787775f, 0.02308007f, -0.02754699f, 
    -0.03873635f, -0.06739988f, -0.00254065f, -0.04925613f, 0.03490696f, -0.06125993f, -0.03686695f, -0.00552263f, 
    0.12889439f, 0.45941541f, -0.22713785f, -0.17173253f, -0.06942494f, -0.18314880f, -0.03743806f, 0.05163814f, 
    0.01981954f, 0.07055736f, -0.01505663f, -0.33800521f, -0.08279883f, 0.20268647f, -0.08578119f, 0.14056931f, 
    0.11546566f, 0.00517613f, -0.10297445f, -0.13839817f, -0.31700438f, 0.20854563f, 0.00166260f, -0.17894982f, 
    0.27123880f, -0.16629106f, -0.03193189f, -0.03490560f, 0.18572208f, -0.65383941f, -0.02631506f, -0.16237934f, 
    -0.13909486f, -0.01469383f, -0.03725681f, -0.00643935f, 0.14346957f, -0.26801902f, 0.34114820f, -0.00019575f, 
    0.12789769f, -0.11386029f, 0.00157196f, 0.03517541f, 0.06185506f, 0.36513525f, -0.22552669f, 0.21481767f, 
    -0.12362162f, -0.05084987f, 0.13716578f, -0.08821309f, -0.04138220f, 0.15642916f, 0.11361316f, 0.20597219f, 
    -0.06074142f, -0.07519486f, -0.06805407f, 0.24199562f, -0.03608398f, -0.12677808f, -0.06396818f, 0.08987493f, 
    -0.10346265f, 0.01734425f, 0.15887463f, -0.21798475f, 0.13008673f, 0.02277846f, -0.05217750f, -0.04645197f, 
    0.86439848f, 0.00023007f, 0.41097304f, -0.26466030f, -0.10709056f, 0.00124651f, 0.23670076f, 0.03334643f, 
    -0.04943272f, -0.20209001f, -0.26494044f, 0.35208830f, 0.00730192f, -0.13430722f, 0.09920729f, -0.04186672f, 
    -0.04053190f, -0.01155100f, -0.55664271f, -0.17471750f, 0.16130404f, -0.01996028f, -0.05890996f, 0.16843978f, 
    0.08686171f, -0.16033110f, 0.27942935f, 0.03997711f, -0.22455010f, 0.37613261f, 0.31379935f, 0.01586998f, 
    -0.09982832f, -0.02338118f, 0.03193294f, 0.10170097f, 0.03225141f, 0.03526807f, 0.28109896f, 0.06920160f, 
    0.21355364f, -0.14341179f, -0.07617772f, 0.08722144f, 0.02626489f, -0.17763132f, 0.42991662f, -0.10606724f, 
    -0.08088815f, -0.08583415f, -0.12542933f, -0.13354567f, 0.07064162f, -0.14494136f, 0.17085712f, -0.04819716f, 
    -0.15731105f, -0.07988429f, 0.20864083f, -0.10985073f, 0.11841594f, 0.02590456f, 0.21513678f, 0.16981652f, 
    -0.14500132f, 0.17659704f, 0.09015925f, -0.12189833f, 0.08993609f, -0.03143112f, -0.13886246f, 0.13599460f, 
    -0.26938152f, -0.51798117f, -0.03225281f, 0.02170592f, -0.09362008f, -0.07534808f, 0.02357033f, 0.03766892f, 
    0.03948719f, 0.21293634f, -0.02174721f, -0.22903921f, 0.07967528f, 0.04048599f, 0.02591260f, 0.04283922f, 
    -0.09013712f, 0.16786240f, -0.02877912f, 0.44129100f, -0.51056367f, -0.07700650f, 0.08500765f, -0.10528143f, 
    -0.05415058f, 0.00640664f, -0.18423983f, 0.03504522f, 0.27361616f, 0.12255286f, -0.16458556f, -0.14529744f, 
    -0.23670016f, -0.03408466f, 0.03455116f, -0.17728893f, 0.27472767f, -0.39060655f, -0.02079276f, -0.02185002f, 
    -0.12753128f, 0.10388742f, 0.03997923f, 0.04469631f, 0.07741325f, -0.00360940f, -0.06822234f, 0.16500209f, 
    0.11174848f, 0.11608449f, 0.19340895f, 0.02750221f, 0.00419766f, -0.08990826f, -0.65029645f, -0.05114617f, 
    0.10953177f, -0.03284349f, 0.19701536f, -0.04277189f, -0.12644413f, 0.01624160f, -0.15309216f, 0.22349662f, 
    0.13889493f, 0.03940453f, 0.08388702f, 0.04987589f, 0.13104707f, -0.00064028f, 0.13287519f, 0.12092737f, 
    0.17013791f, 0.13271993f, -0.01600223f, 0.00116969f, 0.19387165f, -0.03525618f, 0.13571350f, 0.07801189f, 
    -0.35898629f, -0.17701702f, 0.15758957f, -0.15046881f, -0.01971672f, -0.02060371f, -0.07837687f, -0.08747062f, 
    -0.16461445f, -0.07833125f, -0.19121844f, 0.23604348f, -0.10933478f, 0.00040117f, -0.15048169f, 0.05770386f, 
    0.05800088f, -0.11342090f, 0.04131890f, -0.43226629f, -0.07974147f, -0.26159477f, 0.25918829f, -0.10483866f, 
    0.12476519f, -0.11211662f, -0.04115504f, 0.22760244f, 0.04910896f, -0.32488969f, 0.28907970f, -0.08559018f, 
    -0.26197496f, 0.06421559f, 0.04528479f, 0.18960132f, 0.02896598f, -0.17784098f, -0.61502039f, 0.58884299f, 
    0.16446313f, 0.08843420f, 0.00603621f, 0.06527238f, 0.07613106f, 0.06561058f, -0.01502053f, -0.04908875f, 
    -0.28616709f, -0.03471632f, 0.05237466f, -0.04767399f, -0.03825367f, 0.09366167f, 0.22124711f, -0.32824606f, 
    0.35755017f, -0.37923583f, 0.21118772f, -0.03197517f, 0.09689572f, -0.00532013f, 0.10516517f, 0.13849267f, 
    -0.54894626f, -0.12275897f, -0.14535116f, -0.01611109f, -0.06139480f, -0.13177682f, 0.10476107f, -0.00477504f, 
    -0.15572415f, -0.23960155f, -0.10696446f, -0.24343835f, 0.07025542f, -0.30286637f, -0.07450952f, 0.13247071f, 
    0.12745762f, 0.12942642f, 0.11551975f, 0.03191926f, 0.13545810f, -0.06861609f, 0.15487854f, 0.09210924f, 
    -0.25918475f, 0.02117448f, 0.05354121f, -0.06052363f, 0.17305879f, -0.23658870f, 0.07096016f, 0.14861532f, 
    -0.00101342f, -0.07396954f, -0.09008858f, -0.19318615f, -0.24503723f, -0.30167648f, -0.14816794f, -0.02902199f, 
    0.17930590f, -0.14338118f, -0.04083077f, -0.02209397f, 0.08938867f, 0.40948954f, 0.21932551f, 0.28297374f, 
    0.11842055f, 0.08047559f, 0.01921848f, 0.14718208f, -0.00753206f, -0.17835343f, -0.04011625f, 0.05379605f, 
    -0.30056217f, 0.28855234f, -0.09647326f, 0.15473701f, 0.09919804f, 0.05622496f, -0.07995271f, 0.47259676f, 
    0.19695008f, 0.06103192f, 0.15390137f, -0.02103461f, -0.10563795f, 0.08200508f, 0.06929093f, 0.10477799f, 
    0.10982276f, 0.18002017f, -0.09289757f, 0.02139081f, 0.03084077f, 0.15455121f, 0.08890957f, -0.09996908f, 
    0.10456004f, 0.47103488f, 0.29153961f, 0.34370336f, -0.16300684f, 0.11657929f, 0.16713391f, -0.00175812f, 
    0.11055000f, 0.11981485f, 0.23701534f, 0.01317932f, 0.04830997f, 0.04206651f, 0.04731325f, 0.27089471f, 
    -0.15051846f, 0.17797668f, -0.19794808f, 0.10681839f, 0.32594746f, 0.22491395f, 0.14571902f, -0.19637533f, 
    -0.17069840f, -0.05988510f, 0.15196018f, -0.08874639f, 0.23212723f, 0.23480703f, -0.19995923f, 0.01435709f, 
    0.04938160f, -0.06521511f, -0.05685973f, 0.27304921f, 0.18948182f, -0.06725644f, -0.00849540f, -0.00464707f, 
    0.00680716f, -0.21554546f, -0.04294746f, -0.18066828f, -0.11551385f, 0.15634868f, -0.47008219f, 0.08827207f, 
    0.12701386f, -0.09170631f, -0.18922362f, -0.01384384f, 0.03725458f, -0.01230218f, 0.16825330f, -0.09745865f, 
    0.06751285f, -0.04277541f, -0.10515228f, 0.03008647f, 0.01672443f, 0.06521940f, 0.18535767f, -0.12325259f, 
    -0.05169266f, 0.05607330f, -0.10723423f, -0.22461963f, -0.11742377f, 0.00629615f, 0.07338066f, 0.07729840f, 
    0.08994345f, -0.26510328f, -0.22653486f, -0.30460501f, 0.18053772f, 0.07154246f, -0.05768164f, -0.01800304f, 
    -0.02122050f, -0.05969798f, 0.21540882f, 0.08151761f, -0.09298304f, -0.07545455f, -0.33168453f, 0.10320067f, 
    0.00232410f, 0.00350363f, 0.03405760f, 0.25177041f, 0.10978299f, 0.11673593f, 0.09981894f, -0.15944429f, 
    0.23833746f, -0.23455709f, -0.03482556f, -0.22989391f, 0.17998940f, 0.00851602f, -0.33772373f, -0.24826892f, 
    -0.10425178f, -0.00153030f, 0.08417428f, 0.15533365f, 0.16026251f, -0.14305858f, -0.04124341f, 0.05327674f, 
    -0.16840082f, -0.09657575f, 0.24044500f, 0.19903184f, -0.11217664f, -0.11388552f, 0.37625939f, 0.00628823f, 
    0.01743795f, 0.05077175f, 0.02043432f, 0.06768683f, -0.10091906f, 0.09409358f, -0.08416346f, 0.10618599f, 
    0.19237278f, -0.29442659f, 0.08009226f, 0.08656620f, -0.15628108f, -0.19973549f, 0.15503755f, 0.08144595f, 
    -0.61338848f, -0.45921192f, -0.14451031f, -0.01468216f, -0.02778010f, 0.04370880f, -0.04687446f, 0.11156946f, 
    0.07099137f, -0.97750956f, -0.46654001f, -0.29205441f, 0.20230459f, 0.16073665f, 0.00318069f, 0.12086529f, 
    -0.07493609f, 0.19022594f, 0.19653736f, 0.19914383f, -0.40347478f, -0.08582419f, -0.07811912f, -0.18982901f, 
    0.23501837f, -0.01606444f, 0.09708631f, 0.27668256f, -0.56979609f, -0.08850581f, 0.19030581f, 0.16874121f, 
    0.02503140f, 0.00600516f, -0.03198567f, -0.13138433f, 0.17534384f, -0.09157385f, 0.11032426f, -0.15813878f, 
    0.02269097f, 0.24249068f, -0.14127724f, -0.00859879f, 0.17482544f, 0.39705014f, 0.32166374f, 0.38830513f, 
    -0.27727279f, -0.00116242f, -0.14175400f, -0.10084838f, 0.10707322f, 0.13258108f, -0.21249460f, 0.11219364f, 
    -0.29833561f, -0.20137228f, -0.05986413f, -0.04382430f, -0.05452070f, -0.06951316f, -0.00831281f, -0.66183531f, 
    -0.00564820f, 0.12671766f, 0.08110458f, 0.12429113f, 0.15005523f, -0.05370942f, 0.04420454f, -0.05805494f, 
    -0.03290898f, -0.00157378f, -0.02237399f, 0.01845170f, -0.00336048f, -0.02182919f, 0.00024103f, -0.02829450f, 
    0.02330439f, 0.01356175f, -0.03827279f, 0.02124334f, -0.05236560f, 0.04420650f, 0.05318850f, 0.00628350f, 
    0.04542046f, -0.04028913f, 0.01382807f, -0.03511699f, 0.01682800f, -0.01653289f, -0.05129244f, 0.03189202f, 
    0.01984339f, -0.04392263f, -0.02289540f, -0.05031088f, -0.03320801f, 0.01082580f, -0.02013863f, -0.06335822f, 
    -0.01403605f, 0.02543187f, -0.01773579f, 0.03359611f, -0.03890546f, 0.04234463f, 0.05093645f, 0.03667731f, 
    0.05786456f, 0.04658284f, 0.00091555f, 0.00645848f, -0.03488116f, -0.01183074f, 0.04806114f, -0.06636497f, 
    -0.03621800f, -0.00290178f, -0.05588429f, -0.01170896f, 0.00876210f, -0.06072006f, -0.03752801f, 0.03403206f, 
    -0.05915297f, -0.05647898f, 0.02271310f, 0.03983771f, -0.05277491f, 0.02514757f, 0.03511453f, -0.04696003f, 
    0.01710505f, 0.02498028f, -0.02068228f, -0.04786340f, 0.00046855f, -0.06627761f, -0.02282440f, -0.02012851f, 
    -0.00145095f, -0.03225907f, -0.05941271f, -0.05967990f, -0.06123600f, 0.02438317f, -0.06514132f, -0.02048723f, 
    0.02198065f, -0.04176335f, 0.03372843f, 0.00913552f, 0.02330113f, -0.04149763f, 0.04086132f, 0.04172949f, 
    -0.04828638f, 0.04764853f, 0.03140119f, 0.01329842f, -0.01962423f, 0.00222000f, 0.01604057f, 0.04743393f, 
    -0.01765184f, -0.01765502f, 0.00059797f, -0.05124967f, 0.01763919f, 0.00173631f, 0.01830520f, -0.02124771f, 
    0.03102808f, 0.03055036f, -0.03988441f, -0.00968148f, -0.03455227f, -0.05632895f, 0.03713714f, 0.05121699f, 
    -0.02016043f, 0.03904472f, -0.05009047f, -0.02343949f, -0.05269268f, -0.04722436f, -0.05125901f, -0.03212912f, 
    0.02405439f, -0.04578090f, 0.00150380f, 0.04895667f, 0.02733344f, 0.00210523f, 0.04720328f, -0.05147572f, 
    0.00856277f, 0.03747749f, 0.03419892f, 0.02082051f, -0.00870751f, 0.04577154f, -0.05102327f, 0.04717307f, 
    0.03327499f, -0.02307023f, -0.06092786f, -0.02513042f, 0.02025157f, -0.04685665f, -0.05724439f, -0.05934102f, 
    0.04495829f, -0.02157791f, 0.01098437f, 0.00518013f, -0.02421635f, -0.03805017f, -0.03319038f, 0.02928769f, 
    0.03905366f, -0.03397118f, 0.04222216f, 0.02254130f, -0.03836184f, 0.01506134f, -0.00321180f, -0.01162790f, 
    -0.03482849f, 0.00776472f, -0.04903011f, 0.03163451f, 0.05512962f, 0.05650259f, -0.00272903f, 0.01410239f, 
    0.01027399f, -0.00652049f, 0.03957294f, 0.00409428f, 0.02085308f, -0.00011358f, 0.01862427f, 0.02220383f, 
    0.00642048f, 0.03356809f, 0.01932455f, -0.00667123f, 0.01463298f, -0.00060396f, -0.03980674f, -0.03543610f, 
    -0.04544614f, -0.01672794f, 0.04166459f, -0.03574606f, -0.03167576f, -0.00088414f, 0.03340559f, -0.02725849f, 
    -0.00162519f, 0.04281658f, 0.01871105f, 0.04177279f, -0.04503611f, -0.04874831f, -0.03289424f, -0.05892264f, 
    -0.02924239f, -0.01848197f, -0.04820578f, -0.03310023f, 0.04863306f, 0.02895277f, -0.06536981f, -0.00109212f, 
    0.05443475f, -0.02064164f, -0.03503070f, -0.04250426f, -0.03514812f, -0.04886706f, -0.04952631f, -0.01018586f, 
    -0.00269148f, 0.01391068f, -0.02335749f, -0.05677024f, -0.03842407f, 0.01019364f, -0.00343600f, 0.02647150f, 
    -0.02419074f, 0.00374561f, -0.00183932f, 0.01350023f, 0.03034518f, -0.02625025f, 0.04375335f, -0.00384281f, 
    0.04177165f, -0.00121714f, -0.01500722f, 0.00291265f, 0.01526901f, 0.03649728f, 0.05052330f, 0.00165622f, 
    -0.04919804f, -0.06432270f, -0.06872906f, 0.04964951f, 0.03742593f, -0.00066480f, -0.03809677f, 0.01272471f, 
    -0.01509042f, -0.05076499f, 0.01705265f, -0.05956641f, 0.02625292f, -0.02174188f, -0.03423367f, -0.00637333f, 
    -0.02076464f, 0.01753216f, -0.04213632f, 0.00512079f, 0.01916785f, 0.03679475f, -0.02641356f, -0.04542885f, 
    0.03897659f, -0.04119143f, -0.05875019f, -0.00568042f, -0.00462873f, 0.01483947f, -0.02965941f, 0.03112837f, 
    0.04620767f, 0.05329101f, 0.01441047f, -0.03998312f, -0.02210181f, -0.06330727f, -0.04297309f, -0.04092772f, 
    -0.05408143f, 0.01771570f, -0.01669302f, -0.01444897f, 0.00043277f, -0.04962819f, 0.02331429f, 0.01778590f, 
    -0.01266903f, -0.04521868f, -0.03821837f, -0.02172071f, 0.02943637f, -0.00854267f, -0.02696869f, -0.05036953f, 
    0.03437647f, -0.04568745f, 0.03142565f, 0.05508241f, 0.02523162f, 0.02344748f, -0.01216153f, 0.05190039f, 
    -0.04316167f, -0.00050671f, 0.01004844f, -0.03909196f, -0.05096615f, -0.01698254f, -0.05757486f, 0.00169682f, 
    -0.04994297f, 0.01570326f, 0.03798794f, -0.05470862f, -0.05772679f, -0.01980900f, 0.00076437f, 0.00229778f, 
    -0.00165507f, 0.03572338f, 0.02509339f, -0.03695570f, -0.01688016f, -0.05387322f, 0.05879292f, 0.00382847f, 
    -0.00856525f, 0.03045184f, -0.04469368f, 0.02619301f, 0.01601532f, -0.02572300f, -0.04666246f, -0.00966976f, 
    -0.03178196f, -0.03405282f, 0.01325640f, 0.03853934f, -0.04254838f, -0.01507566f, 0.01514484f, 0.01519935f, 
    -0.05507029f, -0.05738089f, -0.00600448f, 0.01994044f, 0.01188271f, -0.02151184f, 0.03050493f, -0.00583227f, 
    -0.03413871f, -0.00775943f, 0.00557591f, -0.00801039f, -0.01157173f, 0.03643729f, -0.00008945f, 0.01610717f, 
    -0.03334830f, -0.02270636f, 0.03268746f, -0.01800606f, -0.03858363f, -0.05537593f, -0.05234605f, -0.02276933f, 
    -0.00004115f, 0.05248086f, -0.00767304f, 0.00476664f, -0.00391299f, -0.00350905f, -0.02726870f, 0.03531482f, 
    0.00583090f, 0.00814428f, 0.00252315f, -0.03466204f, -0.05995986f, -0.06323474f, 0.02637309f, -0.06821036f, 
    -0.01844946f, -0.00589730f, 0.01780822f, -0.04122355f, 0.03982297f, -0.03543332f, -0.04227315f, 0.00336387f, 
    0.04679151f, -0.00578784f, -0.05900233f, -0.01531555f, -0.03350138f, -0.03728515f, -0.02575423f, 0.00560565f, 
    -0.03334651f, -0.05761980f, 0.05262410f, 0.01290086f, 0.00375391f, 0.04742971f, 0.06251750f, 0.00699549f, 
    0.04631294f, -0.00999257f, -0.02208578f, -0.00640878f, 0.01522175f, 0.01627309f, 0.00684825f, -0.04326142f, 
    -0.05689428f, 0.03266126f, -0.04161263f, 0.06507569f, 0.04068901f, 0.00183234f, 0.01810642f, -0.02401585f, 
    -0.01263048f, 0.00067486f, -0.01521068f, -0.05787905f, -0.02472042f, 0.00485436f, 0.02112069f, -0.03212827f, 
    -0.01439120f, -0.02997552f, 0.03937656f, -0.01872435f, -0.02591220f, 0.05957108f, 0.04091477f, -0.05353672f, 
    -0.02973782f, 0.02016459f, -0.05481296f, 0.01622785f, 0.01884897f, 0.00626047f, -0.03331462f, 0.02924307f, 
    0.00890238f, -0.04859155f, -0.02298812f, -0.00113074f, 0.02422247f, 0.01419087f, -0.01752214f, 0.03532859f, 
    0.01223867f, -0.01746633f, 0.02613033f, 0.03451338f, 0.03801247f, -0.04560519f, -0.00567550f, 0.01834999f, 
    -0.00246701f, -0.01716440f, 0.03630744f, -0.06047890f, -0.07014535f, 0.02305010f, 0.00973153f, -0.05331018f, 
    0.03683275f, 0.00372259f, 0.03323026f, 0.00561704f, 0.01534142f, -0.01042552f, -0.01926485f, -0.02621362f, 
    0.05057292f, 0.01056383f, 0.02630795f, -0.05513846f, -0.02817844f, -0.05237291f, -0.02253020f, -0.02060057f, 
    -0.01799959f, -0.03379490f, -0.01211540f, 0.04580379f, -0.02654465f, -0.05882749f, 0.02147316f, -0.00004347f, 
    0.04022878f, -0.00691171f, -0.05993746f, -0.01840176f, 0.02197724f, -0.03684209f, 0.01721913f, 0.04046965f, 
    -0.03084242f, -0.05760151f, 0.03680208f, -0.03887316f, -0.01100347f, 0.01017194f, 0.02419963f, -0.01021801f, 
    -0.01976949f, -0.01484997f, -0.05530158f, 0.01507130f, 0.00092687f, -0.00891779f, -0.03893510f, -0.03489048f, 
    -0.05742791f, -0.03346885f, 0.01013989f, -0.01191945f, -0.02361513f, 0.03422262f, 0.01170137f, -0.03698857f, 
    0.03062202f, -0.04823661f, -0.02162917f, 0.02187141f, -0.01916694f, -0.01241929f, 0.03871017f, 0.00783109f, 
    0.00210347f, 0.01955276f, 0.01107717f, 0.03096391f, 0.02371516f, 0.01882991f, 0.03671220f, 0.00451171f, 
    0.04190737f, 0.04666909f, -0.04117772f, -0.07177285f, 0.02317150f, 0.02909702f, -0.00580618f, 0.04275057f, 
    -0.05116012f, -0.05677065f, 0.02219241f, -0.00950382f, -0.01049530f, 0.05565276f, -0.01224206f, -0.06573598f, 
    0.00257970f, 0.01272877f, 0.04626060f, 0.02321025f, 0.04067930f, -0.01260411f, -0.05737711f, 0.04696074f, 
    -0.01506400f, -0.04036469f, -0.04586051f, 0.04977741f, 0.03866995f, 0.04289015f, -0.06567264f, 0.04196892f, 
    -0.27124819f, 0.42729771f, 0.01085558f, -0.10947159f, 0.21954513f, 0.14255700f, -0.23722662f, -0.10007865f, 
    0.11282794f, -0.01112917f, 0.22902197f, 0.46425620f, -0.17927679f, -0.23538527f, -0.01407387f, 0.24142002f, 
    0.11306823f, 0.04334825f, 0.24359991f, -0.11368925f, 0.07182451f, 0.07075808f, -0.22224160f, 0.22328182f, 
    -0.16290700f, 0.17323062f, -0.02307971f, -0.40915447f, -0.00275886f, 0.09317957f, 0.21024621f, -0.19058712f, 
    -0.00740450f, 0.05733398f, -0.10407589f, -0.18207239f, 0.05836226f, 0.00499677f, -0.19888835f, -0.08817791f, 
    -0.06530804f, -0.43030548f, 0.02388067f, 0.25681499f, 0.13335782f, -0.10695673f, 0.17094459f, 0.00146396f, 
    0.15453963f, 0.09010536f, 0.10015090f, -0.24610047f, -0.24623960f, -0.16471016f, -0.46498263f, -0.20398119f, 
    0.02796524f, 0.14481489f, -0.16453579f, 0.12111669f, 0.02591928f, 0.16021071f, -0.14490558f, 0.26279929f, 
    0.15529536f, -0.39376020f, -0.02849877f, 0.06086579f, -0.25514436f, 0.14605477f, -0.19028682f, 0.09166090f, 
    -0.14769085f, 0.02706351f, -0.00496198f, 0.03805511f, -0.11231221f, 0.02362835f, -0.16166243f, 0.17471725f, 
    0.20214254f, -0.13572524f, -0.14497839f, -0.12743196f, -0.14013618f, -0.01527529f, -0.05295350f, 0.28161997f, 
    -0.10656764f, 0.25150904f, 0.10667997f, -0.13900983f, -0.10520028f, -0.03391101f, 0.05735362f, 0.21062589f, 
    -0.02075407f, -0.09663859f, -0.16803247f, -0.08831202f, 0.20823143f, -0.25258768f, -0.03972839f, -0.12323657f, 
    0.02722403f, -0.07735973f, -0.15900566f, -0.00468375f, 0.05289922f, 0.03416096f, -0.21759926f, 0.02905493f, 
    0.02770688f, 0.03310975f, 0.24812347f, -0.18614388f, -0.04632114f, 0.20243199f, 0.13747527f, 0.03862123f, 
    0.04038271f, 0.15848538f, 0.14735651f, -0.34887812f, -0.09444901f, 0.14217979f, 0.12770580f, 0.04971728f, 
    0.12236564f, 0.36328200f, 0.20547576f, 0.16405283f, 0.25616506f, 0.23374769f, 0.03557716f, 0.16364668f, 
    0.09030107f, -0.06499231f, -0.01370590f, 0.02894789f, -0.31753716f, 0.05125723f, 0.16220897f, 0.41493338f, 
    -0.00304721f, -0.34152484f, 0.26921424f, -0.00211997f, 0.24549623f, 0.13312259f, -0.14078425f, 0.00907635f, 
    0.07696350f, -0.05947965f, 0.23969929f, 0.03492739f, -0.13605709f, 0.11869392f, -0.08242732f, -0.22652005f, 
    0.14951600f, 0.13304400f, -0.03993009f, 0.05449167f, -0.00931862f, 0.02376876f, -0.12871854f, 0.15352912f, 
    -0.00627942f, -0.01813263f, 0.00466373f, -0.37525985f, -0.09134594f, 0.08273375f, -0.11286658f, -0.04519928f, 
    0.33878326f, -0.05426219f, 0.05055834f, -0.29946670f, -0.21226166f, 0.04224119f, 0.21044312f, 0.02752084f, 
    -0.02737641f, 0.08412922f, 0.15646918f, 0.24075381f, -0.04553156f, -0.57792729f, -0.32746097f, 0.28368551f, 
    -0.01684857f, 0.17771956f, 0.08685157f, -0.16120313f, -0.04751805f, -0.23824573f, -0.19671965f, -0.16950573f, 
    -0.11804157f, 0.10754514f, 0.03737703f, 0.10091310f, 0.14165644f, 0.11377987f, -0.24171619f, 0.34916735f, 
    0.06499250f, 0.00434710f, 0.06961981f, -0.08053873f, -0.15648477f, -0.04893961f, 0.15915133f, -0.02331733f, 
    0.11366077f, 0.15616859f, 0.26080027f, -0.03509389f, -0.02017000f, 0.07664559f, -0.11908485f, 0.26409286f, 
    0.12097111f, 0.16980046f, -0.11917193f, -0.19399993f, 0.05117043f, 0.20350468f, 0.02043339f, -0.00679053f, 
    0.17731851f, 0.20763646f, -0.01641128f, 0.34265295f, 0.17900251f, 0.10326405f, 0.29003045f, -0.16374707f, 
    0.09339683f, -0.09641443f, -0.12442846f, -0.20303392f, 0.04683111f, -0.38162652f, 0.14447698f, 0.03685325f, 
    -0.09109145f, 0.18701656f, -0.52801090f, -0.18492383f, -0.13025105f, -0.01127177f, 0.07730173f, -0.13754052f, 
    0.09152570f, 0.03712283f, 0.01288242f, 0.01014333f, -0.30676788f, 0.11847503f, 0.06726039f, -0.20745409f, 
    -0.23836905f, 0.13717405f, -0.22010571f, 0.03014013f, -0.16631512f, -0.13790421f, -0.21470815f, -0.11636434f, 
    0.25053352f, 0.24813141f, 0.07978170f, 0.08164726f, -0.02479941f, 0.08503591f, -0.35256776f, 0.16757984f, 
    -0.20240393f, -0.05290956f, 0.02246197f, 0.10362212f, 0.20536987f, -0.29919124f, -0.04504612f, 0.03167921f, 
    -0.00990708f, -0.04307243f, 0.02034059f, 0.04648062f, -0.05309952f, 0.00148811f, -0.05502648f, 0.03356943f, 
    -0.06257808f, 0.00488752f, -0.04809592f, -0.06154727f, -0.02363702f, -0.02799176f, -0.02685761f, 0.04421368f, 
    0.01872529f, 0.01883831f, -0.03528592f, 0.00477857f, 0.03221494f, 0.00617381f, 0.01771018f, 0.05068183f, 
    0.00106040f, 0.02798613f, -0.01268426f, 0.02486528f, -0.05369136f, -0.01830790f, -0.03167193f, 0.02055022f, 
    0.05508170f, -0.03984098f, -0.04016878f, -0.03289071f, -0.02691025f, -0.00437911f, -0.02199162f, 0.04730969f, 
    -0.02137325f, 0.04567022f, 0.05439273f, -0.04115120f, -0.01170730f, -0.05716395f, -0.05680782f, 0.03463344f, 
    0.04339412f, -0.03702094f, -0.04121417f, -0.00228704f, 0.00345671f, -0.03066160f, -0.03322946f, 0.01719774f, 
    -0.04928029f, -0.01924877f, -0.01493271f, 0.03571162f, 0.03284480f, 0.03006270f, -0.00107643f, -0.05817220f, 
    -0.06266285f, -0.02724154f, 0.01760456f, 0.00755656f, 0.03506877f, 0.03361822f, 0.05106326f, -0.01651011f, 
    -0.04867831f, -0.02231017f, -0.03374200f, 0.00958439f, -0.00698734f, -0.04125234f, 0.06054731f, -0.04120390f, 
    -0.00245602f, -0.02049688f, -0.04711070f, 0.04464145f, -0.00640298f, -0.06082981f, -0.02446288f, -0.03504197f, 
    0.03712036f, 0.00694018f, -0.04629527f, -0.01616580f, -0.06127243f, -0.02330468f, 0.01403124f, -0.06475478f, 
    -0.01746903f, -0.05098166f, -0.02632039f, -0.04912269f, -0.06029122f, -0.02925696f, -0.04082362f, -0.05608207f, 
    -0.05744973f, 0.01165814f, 0.02262976f, 0.04617691f, -0.04015275f, -0.04894944f, -0.00678248f, 0.00319783f, 
    -0.06377082f, -0.01560443f, -0.00866019f, -0.01262478f, -0.02780239f, 0.00622675f, -0.01366783f, -0.03747869f, 
    -0.02208260f, -0.05714274f, 0.01219880f, 0.01718879f, -0.00846545f, -0.03531404f, -0.01431933f, -0.03833821f, 
    0.05321459f, -0.04582362f, 0.03792484f, 0.03578473f, 0.02094226f, -0.05201286f, 0.04465875f, 0.01803147f, 
    -0.02554664f, 0.05040544f, -0.03402652f, -0.04224810f, 0.03881292f, -0.00864920f, -0.02104958f, -0.00742505f, 
    0.02697281f, 0.01952592f, 0.04782816f, -0.03941876f, -0.03625029f, -0.03944224f, 0.05854967f, 0.00523016f, 
    -0.05376997f, -0.02679630f, 0.01604511f, -0.02247674f, 0.00924781f, -0.03829424f, -0.01098683f, -0.02814724f, 
    -0.03571745f, -0.05505186f, 0.02398644f, -0.02626264f, -0.04930324f, 0.02757412f, 0.04275163f, -0.05953000f, 
    0.02808577f, 0.02780330f, 0.02632458f, -0.05223538f, -0.02116874f, 0.03526860f, -0.03264488f, -0.04278754f, 
    -0.01894951f, -0.01387844f, -0.06409050f, -0.00920153f, -0.05577992f, -0.04053344f, 0.02896918f, 0.04341784f, 
    0.04594902f, 0.01979766f, -0.05118296f, 0.00742090f, 0.01285923f, 0.03517570f, 0.03944333f, -0.00070847f, 
    0.02567598f, 0.02035294f, -0.05140509f, 0.02670634f, -0.02571592f, 0.02098855f, -0.06022733f, 0.02844527f, 
    -0.02634961f, -0.02510685f, 0.01732804f, 0.05103000f, -0.04859306f, -0.01694716f, -0.01733971f, 0.03329052f, 
    -0.03209658f, -0.02431279f, -0.01186852f, -0.02542671f, -0.05810416f, -0.01736472f, -0.00372734f, 0.04035315f, 
    -0.01549655f, -0.02010302f, 0.03457708f, -0.02529572f, -0.03062187f, 0.03642397f, 0.02636270f, 0.03170240f, 
    -0.01561091f, -0.04275467f, 0.03541954f, -0.05671575f, 0.02234078f, -0.04499455f, 0.00323495f, -0.03017525f, 
    0.04835760f, 0.00779411f, -0.06189892f, -0.03151302f, -0.00482864f, 0.01199035f, -0.02495994f, -0.01666320f, 
    0.01274407f, -0.03833003f, 0.03253525f, -0.00617811f, 0.01564059f, 0.03077221f, -0.04502784f, -0.04247326f, 
    -0.01580414f, 0.00945194f, 0.01273492f, 0.01689024f, 0.04022772f, 0.03835854f, -0.05737619f, -0.02861599f, 
    0.04264612f, 0.00670274f, 0.04064905f, 0.00832353f, 0.04009937f, -0.01143470f, -0.01901090f, 0.04201665f, 
    0.05750636f, -0.05961545f, 0.04759886f, 0.04352815f, 0.03684182f, 0.03299704f, -0.03147182f, -0.00044578f, 
    0.00010266f, -0.02277448f, -0.04424883f, -0.00574455f, -0.03835571f, 0.04159068f, -0.02896973f, 0.03737120f, 
    0.00858522f, -0.05611914f, -0.02313319f, -0.04472630f, 0.04501236f, 0.01904682f, 0.05003247f, 0.05218238f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04406729f, -0.00386600f, 0.11591537f, 0.06032778f, 0.00735777f, -0.11919924f, -0.03386025f, 0.10430013f, 
    -0.03449215f, 0.01399371f, -0.12342785f, 0.34153000f, 0.09875778f, 0.01822999f, 0.06940702f, -0.06623246f, 
    -0.06303857f, -0.02262525f, 0.01790089f, 0.02963581f, 0.03128437f, 0.19507237f, 0.01931307f, -0.03125192f, 
    0.01080189f, 0.04100326f, 0.02256361f, 0.16212636f, 0.01048755f, -0.04043904f, 0.15604007f, 0.04312677f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06410198f, -0.07790978f, 0.66515309f, 0.36664113f, -0.02709538f, -0.12199911f, -0.01054055f, 0.10051458f, 
    -0.12323426f, 0.01516123f, -0.27534547f, -0.69731283f, 0.66045135f, -0.07341907f, -0.46284166f, -0.03884370f, 
    -0.12145366f, 0.02966004f, -1.01867592f, 0.00063946f, -0.08879641f, -0.21422349f, -0.10322262f, -0.03421472f, 
    -0.15180022f, -0.14075713f, -0.22611059f, -0.28085196f, -0.13076070f, 0.04359050f, 0.33329430f, -0.13387907f, 
    0.03046970f, -0.08626462f, -0.15459239f, -0.15872605f, -0.09219921f, -0.06715614f, 0.11429533f, 0.02640611f, 
    0.32315788f, -0.14785996f, 0.03840780f, -0.14502259f, 0.80619830f, -0.71437466f, -0.02256438f, 0.01431358f, 
    -0.02795457f, 0.10147922f, 0.34273142f, -0.02423117f, -0.02220463f, -0.19840007f, 0.10781986f, -0.24453016f, 
    0.36524111f, 0.02798209f, -0.63986343f, -0.29772428f, 0.04760949f, 0.15909250f, 0.33366528f, -0.13072662f, 
    0.05461146f, 0.03105209f, -0.10442677f, -0.91035098f, 0.03601651f, 0.48451024f, -0.12000740f, -0.16565706f, 
    -0.86131465f, 0.07968409f, 0.06814086f, -0.66511101f, 0.18441494f, -0.08435319f, -0.14579917f, -0.17231952f, 
    -0.09003463f, 0.04041245f, 0.03527263f, 0.15635403f, -0.02521515f, -0.35487154f, 0.16262846f, 0.79905963f, 
    0.18465388f, -0.13279609f, 0.05493952f, -0.31474781f, 0.12868617f, -0.15980065f, -0.29651377f, 0.09477606f, 
    0.16423157f, -0.08125565f, -0.05586807f, 0.28840390f, -0.00826329f, -0.14802676f, 0.09181838f, -0.49440706f, 
    0.80371886f, -0.15818633f, -0.34221610f, -0.39535016f, -0.67858750f, 0.51793641f, 0.19772902f, 0.13082418f, 
    -0.13974793f, -0.02943546f, -0.38303849f, -0.00202138f, 0.08087555f, -0.21552256f, 0.07904217f, 0.17004672f, 
    -0.15455918f, 0.13040361f, 0.08445033f, -0.01876825f, -0.10006078f, 0.02557934f, -0.17727000f, -0.00622769f, 
    -0.04051973f, 0.08653527f, -0.25826210f, 0.09078326f, 0.02708452f, -0.64675176f, 0.04157132f, 0.86910552f, 
    -0.45327061f, -0.15324400f, 0.26675975f, 0.19976912f, -0.11300658f, 0.23038401f, 0.10384133f, 0.05808086f, 
    -0.03839697f, 0.15322043f, -0.23747635f, -0.08997096f, 0.12321902f, -0.30704302f, -0.14237592f, 0.10029540f, 
    -0.58649635f, 0.01291895f, 0.10406928f, -0.08058453f, 0.10397023f, 0.02007927f, -0.72974199f, -0.11121793f, 
    0.10776453f, -0.14988902f, 0.55190039f, -0.04023159f, -0.01704228f, -0.28693700f, 0.06500991f, 0.10286083f, 
    0.43866611f, 0.08526778f, -0.51373351f, 0.43103847f, -0.21018031f, -0.31712767f, -0.01023933f, 0.09791252f, 
    -0.04584121f, 0.02391682f, 0.20487648f, 0.02693372f, 0.12152891f, 0.30068156f, -0.13167372f, -0.53272855f, 
    -0.84002310f, -0.14515853f, -0.63334483f, 0.00296453f, 0.05942454f, 0.09460680f, 0.34389034f, -0.13127069f, 
    0.16863485f, 0.05002922f, 0.34727874f, 0.10187688f, 0.03664335f, -0.36977991f, 0.08867811f, -0.01444460f, 
    -0.34082025f, -0.03034074f, -0.30872545f, 0.20646666f, -0.57111216f, 0.35527152f, -0.67023337f, 0.02523138f, 
    0.03035509f, -0.05941803f, 0.86208743f, 0.06287524f, -0.10443233f, -0.04857036f, 0.01842121f, 0.20156740f, 
    0.12471361f, -0.16229904f, -0.56557155f, -0.51904541f, 0.14430699f, 0.11409219f, -0.39287326f, -0.12768638f, 
    -0.05803064f, 0.06198750f, -0.47664273f, 0.65316445f, -0.12561722f, 0.55248570f, -0.00320299f, 0.21332249f, 
    0.07761666f, -0.00344354f, 0.60851270f, -0.57278782f, -0.26286379f, -0.19062772f, 0.19220197f, -0.11509221f, 
    -0.11993900f, -0.15985599f, -0.32337728f, -0.09219318f, 0.04306492f, -0.62473321f, -0.03269920f, -0.51449549f, 
    -0.66271579f, 0.15255935f, -0.14561844f, 0.08043158f, -0.05657858f, -0.04089632f, -0.47509319f, 0.01465527f, 
    -0.12834302f, 0.00506441f, -0.54697406f, -0.42685500f, 0.16318664f, 0.36901733f, 0.03926813f, -0.27266440f, 
    0.45656341f, 0.15215534f, -0.57138705f, -0.27081448f, 0.07860107f, -0.40946001f, 1.00835586f, -0.17415339f, 
    -0.09902365f, -0.06093939f, -0.09830915f, 0.01043452f, -0.06832706f, -0.02793180f, -0.05106340f, -0.47152656f, 
    0.27234465f, -0.14610678f, 0.68837720f, 0.02093947f, -0.14036597f, 0.08414597f, 0.10985067f, 0.12029766f, 
    -0.08813461f, 0.08530786f, 0.08990117f, -0.08399210f, 0.01162521f, -0.32422152f, 0.09124389f, -0.24244837f, 
    -0.33215293f, 0.08170056f, 0.33390835f, 0.52485633f, -0.45642039f, -0.16167061f, -0.66221654f, -0.06676051f, 
    0.08478136f, -0.12350082f, 0.03485694f, -0.12887074f, 0.00913706f, -0.33202508f, -0.05513270f, -0.14622861f, 
    0.46435380f, 0.06978787f, 1.17412710f, 0.00402161f, 0.07985711f, -0.10823867f, -0.00018041f, 0.10323803f, 
    -0.04612777f, 0.03059680f, -0.74800450f, 0.16315164f, -0.09165476f, 0.19288321f, 0.05727959f, -0.45741656f, 
    -0.47095627f, -0.06672843f, -0.39321816f, 0.35409051f, -0.49266338f, -0.28557354f, 0.38787264f, 0.02633569f, 
    0.02868726f, -0.07209983f, -0.24115606f, -0.08087377f, -0.10970125f, 0.29633170f, -0.14215615f, 0.10270831f, 
    -0.14977455f, 0.07628252f, -0.35590166f, 1.00289786f, 0.09398853f, 0.02600558f, 0.31381038f, 0.11275458f, 
    0.01490312f, -0.10076231f, -0.34018868f, -0.67637122f, 0.12186976f, 0.21479554f, 0.08535479f, -0.58645779f, 
    0.02884281f, -0.13321525f, 0.39978877f, -0.46071529f, -0.48897883f, 0.43733737f, 0.09307589f, 0.14369999f, 
    -0.07743628f, 0.00706672f, 0.16154025f, -0.13992652f, 0.11154862f, 0.89041585f, 0.04178730f, -0.00300001f, 
    0.26476261f, -0.13842174f, -0.50403309f, -0.39655346f, 0.15860896f, -0.02335745f, -0.32810697f, 0.10716060f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03434457f, -0.05994088f, -0.12599973f, 0.03134436f, 0.02789344f, 0.06374471f, -0.05100606f, -0.51722473f, 
    -0.02383742f, 0.07517450f, 0.07400768f, -0.15441266f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
