#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.74797082f, 0.83919394f, 0.78674209f, -0.22807330f, -0.53084463f, -0.51332122f, 0.07821620f, 0.50224757f, 
    -0.01887365f, 1.11175287f, -0.00078460f, -1.02514696f, 0.30337867f, -0.35206041f, -0.50649625f, 0.55270606f, 
    -0.06699787f, 0.03659905f, 0.11545735f, -1.03427696f, 1.03108680f, 0.19538032f, -0.63695842f, 1.00341296f, 
    0.34833187f, -0.42286476f, -0.15299414f, 0.61277622f, 0.41773990f, 0.35473073f, -0.15344895f, -0.82081068f, 
    0.28297719f, 0.32721376f, 0.45165989f, 0.17814517f, -0.84226137f, 0.45622596f, 0.50123572f, 0.53849846f, 
    0.90377426f, 0.18046929f, -0.19769223f, -0.13788708f, -0.18630968f, 0.82639092f, 0.37766534f, 0.88557285f, 
    0.66069740f, 0.49072504f, 0.11601867f, -0.24814481f, -0.43906263f, 0.20152275f, -1.11904120f, 0.27655116f, 
    -0.63280118f, 0.76102269f, 1.05592656f, 0.21167548f, 0.16172920f, -0.01312366f, 0.60091549f, -0.81255865f, 
    -0.41460726f, -0.44442308f, -0.01021827f, 1.03732347f, -0.45355055f, 0.37757477f, 0.38262776f, -0.53383535f, 
    0.16768637f, 0.99695337f, 0.32001957f, 0.75404483f, -0.67242891f, -0.53744644f, 0.11445525f, -0.61791903f, 
    0.17463499f, -0.71120715f, -0.48900676f, -0.28748092f, 0.08511893f, 0.45509779f, -0.78431469f, -0.14379515f, 
    -0.17478134f, 0.06265647f, 0.18383302f, -0.60849887f, 0.32397139f, -0.20920008f, 0.30348414f, -0.93982196f, 
    -0.36789790f, -0.42593965f, -0.21950155f, -0.82165021f, -0.97209501f, -0.30042541f, 0.00859032f, -0.02883029f, 
    0.05959237f, 0.32174325f, 0.44835579f, 0.07282728f, 0.38081929f, -0.20252560f, 0.61328077f, 0.14683290f, 
    0.36276218f, 0.55510318f, -0.49193144f, 0.14741166f, 0.71570235f, 0.80776870f, 0.68115163f, 0.87681878f, 
    -0.09806517f, -0.33900657f, 0.24027853f, -0.20814769f, -0.16499162f, -0.30674616f, -0.49103418f, -0.59836984f, 
    -0.32523048f, -0.51292706f, -0.20157816f, 0.20440967f, 0.79576236f, -0.47447917f, 0.06397720f, 0.79512548f, 
    -0.70846176f, -0.11592911f, -1.08528185f, -0.26676968f, -0.35479119f, 0.14313072f, 0.74973714f, 0.27593026f, 
    -0.72804648f, -0.66510206f, -0.64221287f, -0.38852596f, 0.39441466f, 0.94406974f, -0.06793611f, -0.11592707f, 
    0.50088876f, -0.12908028f, -1.13376200f, -0.72300559f, 0.71556085f, -0.26375592f, 0.22747582f, -0.03190706f, 
    -0.15991350f, -0.25336406f, -0.79112518f, -1.00433934f, -0.76385212f, -0.77228248f, -0.34917393f, -0.20211786f, 
    0.29538339f, 0.34107831f, 0.29179430f, -0.94882506f, 0.83133191f, 0.48123813f, -0.15168707f, 0.49893439f, 
    0.66167450f, -0.08985093f, 0.41637409f, 0.30187023f, 0.22581448f, 0.66561139f, 0.37786004f, 0.53488791f, 
    -0.14410408f, 0.59905899f, 0.64453918f, -0.10511710f, 0.64373803f, 0.27514017f, 0.19076125f, 0.59964436f, 
    -1.05294228f, -0.30402312f, -0.90997106f, 0.22334342f, -0.42147249f, -0.48806456f, -0.68831038f, 0.80049378f, 
    -0.41280419f, 0.57600135f, -0.56635159f, -1.02574301f, -0.31171286f, 0.34038171f, 0.03579635f, 0.95422298f, 
    -0.93497467f, -0.13655862f, -0.38540944f, -0.41151580f, 0.52996814f, -0.48370817f, -0.38659695f, 0.05126736f, 
    -0.45462960f, -0.59752077f, -0.53567237f, 0.45090121f, 0.83892560f, 0.78417563f, -0.25711945f, -0.31348258f, 
    -0.58609629f, 1.05416954f, 0.55606157f, 0.40883178f, -0.52039164f, 0.73244792f, -0.37543496f, -0.15410213f, 
    -0.07069694f, -0.15758513f, 0.18483686f, -0.57084364f, -0.72093755f, -0.32556197f, -0.48499140f, 0.00514631f, 
    -0.69990647f, -0.07572643f, 0.60752672f, -0.32032269f, -0.64116418f, -0.04885425f, -0.49360201f, -1.03960752f, 
    -0.98058563f, -0.35045579f, 0.10923684f, -0.15401715f, 0.01946081f, 0.69569594f, 0.66522217f, -0.52697146f, 
    0.24585046f, -0.12447938f, -0.36844465f, -0.38522020f, -0.11300133f, -0.35222933f, 0.57140613f, -0.32501850f, 
    -0.85573566f, -0.40237910f, -0.97266048f, 0.56559366f, -0.28338096f, 0.05230450f, -0.73952454f, -0.69000125f, 
    -0.47563258f, -0.45922440f, -0.22311638f, 0.50724405f, -0.68248081f, 0.44518188f, -0.51842922f, 0.78769749f, 
    0.65194720f, -0.66241068f, 0.02391935f, 1.02792561f, 0.05947470f, -0.53193331f, 0.15809636f, 0.27424046f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16167459f, -0.26159364f, -0.18323499f, 0.33935004f, -0.07038622f, 0.15077831f, -0.04784631f, -0.03058737f, 
    -0.26632705f, 0.23125978f, -0.09209455f, 0.06157164f, 0.26447681f, 0.49293256f, 0.06928144f, 0.04596668f, 
    0.07515242f, 0.17682861f, 0.21183272f, -0.10628557f, -0.24056135f, 0.03576462f, -0.04300113f, -0.17261669f, 
    -0.00086171f, -0.19923513f, -0.00709394f, -0.16962156f, 0.20192486f, -0.03411468f, -0.05284901f, -0.50428176f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.11076517f, -0.02098245f, 0.06738593f, 0.07921576f, 0.15037617f, -0.05042111f, 0.03523067f, 0.02222443f, 
    -0.08261280f, 0.03537368f, 0.11112321f, 0.08142483f, -0.12182382f, 0.01525663f, -0.18750370f, -0.05146343f, 
    0.06784758f, 0.13205932f, 0.40300143f, -0.08724232f, -0.33682051f, -0.11458600f, 0.09893177f, -0.04633050f, 
    -0.05548350f, -0.09691928f, -0.12437513f, -0.15304363f, -0.12969254f, 0.00890898f, -0.01692917f, 0.01440016f, 
    -0.14227223f, 0.04615126f, 0.06071459f, -0.09485538f, 0.08782954f, 0.05178857f, -0.20774020f, 0.00034862f, 
    -0.01918682f, 0.05349046f, -0.08833054f, -0.07417145f, -0.11319742f, -0.10752136f, 0.02653073f, -0.37883517f, 
    0.03671563f, -0.02914694f, 0.18477125f, -0.14723870f, -0.09338654f, -0.18424807f, -0.07480547f, -0.03091969f, 
    0.13997373f, 0.09854317f, -0.06798049f, 0.00326443f, 0.06614435f, 0.05574337f, 0.03543513f, 0.10138563f, 
    0.00548902f, 0.19010763f, 0.06768521f, -0.11783955f, -0.09933815f, -0.04817679f, 0.04536679f, 0.17642692f, 
    0.10245244f, 0.10403230f, -0.26787838f, -0.05818938f, -0.01596204f, 0.03779159f, 0.00166261f, -0.04124741f, 
    -0.26712999f, -0.14661518f, -0.15865600f, 0.14161746f, 0.00571457f, -0.12315932f, 0.00100122f, 0.03254252f, 
    0.15567671f, 0.06610015f, 0.07426380f, -0.05793414f, 0.09361432f, 0.06539267f, -0.01565231f, 0.04281900f, 
    -0.06592878f, -0.03643143f, -0.05530792f, 0.11929686f, -0.10512478f, 0.05603353f, 0.03366566f, 0.14937767f, 
    -0.16275908f, 0.15396443f, -0.03064207f, 0.01707441f, -0.22553730f, -0.08613712f, -0.09463568f, -0.10753872f, 
    0.09170038f, 0.16623749f, -0.11757306f, -0.00998562f, -0.12160709f, -0.12761532f, 0.04618737f, -0.10290149f, 
    0.12943062f, 0.04236471f, 0.08576852f, -0.04454331f, -0.04234303f, -0.19525586f, 0.01135429f, -0.06222049f, 
    0.01631488f, -0.02044657f, 0.03286722f, -0.10989281f, 0.10883868f, -0.03155857f, 0.04853866f, 0.34805778f, 
    -0.10371379f, -0.03659202f, -0.05964165f, 0.03259112f, -0.10960972f, 0.22582807f, 0.10512326f, -0.01987543f, 
    -0.05662399f, -0.15613367f, 0.09995417f, -0.06630690f, 0.01146518f, -0.00183672f, 0.03601227f, 0.06529827f, 
    0.00529378f, 0.02922855f, -0.29041684f, 0.30569008f, -0.07595035f, 0.05371056f, -0.18600740f, -0.10904696f, 
    0.08656100f, 0.06592096f, 0.08370876f, -0.07330470f, 0.02452095f, 0.00202732f, 0.12671539f, -0.07126965f, 
    0.11879259f, 0.04003960f, 0.05285299f, -0.11264729f, 0.17094880f, -0.05196816f, -0.11343608f, 0.01199232f, 
    0.08855338f, -0.01766468f, 0.04948805f, 0.07281068f, -0.19233057f, 0.02548326f, 0.04464757f, 0.08677971f, 
    -0.14268157f, 0.06542470f, -0.04947426f, -0.03653176f, -0.04669443f, 0.16841967f, 0.20872584f, 0.01679813f, 
    -0.02936553f, 0.15601835f, -0.06750635f, 0.03745322f, 0.09795887f, 0.01601343f, 0.21054104f, 0.01496908f, 
    0.14936459f, -0.13866623f, -0.14854690f, 0.09400859f, 0.11439715f, -0.07315824f, 0.01420488f, 0.11924441f, 
    0.19715050f, 0.23295254f, -0.21326488f, 0.03252393f, 0.07931730f, -0.08787074f, -0.14759779f, -0.20473680f, 
    -0.16080980f, -0.00578682f, 0.11028517f, 0.06589955f, 0.17997538f, 0.24636011f, -0.04728390f, 0.02141771f, 
    0.05303243f, -0.07526881f, 0.17075716f, -0.27386346f, 0.11571004f, -0.08938268f, 0.13608469f, -0.00527462f, 
    -0.04288637f, -0.03662945f, 0.29491457f, -0.09478106f, 0.21581037f, 0.08129378f, 0.04375558f, 0.07478667f, 
    0.09382263f, 0.00829355f, -0.04751381f, 0.22937462f, -0.17691043f, 0.10349173f, 0.07427859f, 0.09665528f, 
    0.01656774f, 0.20780855f, -0.14521757f, 0.04486240f, -0.11119371f, 0.10542381f, 0.00588122f, -0.02177522f, 
    0.02914121f, -0.01400204f, -0.13649593f, -0.08698298f, -0.04209764f, 0.13415031f, 0.11960118f, -0.02206848f, 
    0.01487310f, 0.01113251f, -0.25437832f, 0.17232621f, 0.10130627f, -0.04747660f, -0.11107879f, -0.10039791f, 
    0.01292163f, -0.05425961f, 0.16104892f, 0.17760386f, -0.04082862f, 0.04949096f, 0.02894067f, -0.25820699f, 
    0.07140306f, 0.19260837f, 0.13546775f, -0.10976447f, 0.04825811f, 0.06580175f, -0.15109566f, -0.16403866f, 
    0.03315170f, -0.21966428f, -0.00848652f, -0.12842228f, 0.09609854f, -0.01724664f, 0.03267208f, -0.05999618f, 
    0.15832753f, -0.29943427f, -0.02426473f, -0.20626518f, 0.10987917f, -0.15571536f, 0.19962741f, 0.01241595f, 
    0.11471456f, 0.11175713f, -0.27960026f, 0.18131191f, 0.11241934f, 0.09082189f, -0.05348866f, -0.08520848f, 
    0.08290473f, -0.03920051f, -0.02001582f, 0.00589575f, 0.06020090f, 0.02354177f, 0.10756087f, -0.12241621f, 
    0.06921861f, 0.08737919f, -0.05160713f, 0.25436208f, -0.21252944f, 0.22194587f, 0.07243747f, 0.18485148f, 
    -0.00022907f, -0.15858454f, 0.04548097f, 0.06310128f, 0.07656822f, 0.09636509f, -0.02760101f, 0.10556664f, 
    0.04475001f, -0.22293164f, -0.25153145f, -0.17707430f, 0.21614982f, -0.01831462f, -0.05473632f, 0.26354846f, 
    -0.04264241f, -0.12198647f, 0.16965248f, -0.13308002f, -0.01141092f, -0.06122935f, -0.02903942f, -0.05678025f, 
    -0.16402562f, -0.09720793f, -0.06293735f, -0.16480850f, 0.05906728f, 0.17796548f, 0.02376929f, 0.01917354f, 
    -0.26329875f, -0.20459212f, 0.12992020f, 0.08274037f, -0.13466804f, -0.05889423f, 0.04650830f, -0.00288549f, 
    -0.02892598f, -0.10783512f, -0.04588880f, -0.04359806f, 0.06485926f, 0.02228228f, 0.09153474f, 0.23423360f, 
    -0.12958992f, -0.14243536f, -0.02916354f, 0.15560092f, -0.12041617f, 0.00858736f, 0.06656304f, 0.09657978f, 
    -0.13060987f, -0.02019400f, -0.08160964f, -0.01647479f, 0.28076702f, -0.01826624f, -0.03003094f, -0.11408320f, 
    0.13021861f, 0.14655733f, -0.05129331f, 0.09473164f, 0.18982829f, 0.14044255f, -0.02851494f, 0.10829163f, 
    -0.10728364f, -0.00646091f, 0.08187246f, 0.17100655f, 0.06070552f, 0.03263238f, -0.01941261f, -0.00264092f, 
    0.00015879f, -0.17847814f, -0.09773868f, -0.04798720f, -0.06109346f, 0.02128483f, 0.17363328f, -0.00423270f, 
    -0.23871671f, -0.13004108f, -0.00621942f, 0.09885290f, 0.25175166f, -0.03833907f, 0.15148368f, -0.44463837f, 
    -0.22210622f, -0.04707449f, 0.13570978f, -0.10349389f, 0.16592515f, -0.11460485f, -0.02582237f, -0.13459170f, 
    0.13506106f, 0.20732746f, -0.14839587f, 0.01785252f, 0.07893184f, -0.11655702f, 0.02459031f, 0.01296178f, 
    0.09980810f, 0.10150036f, 0.18991861f, 0.00971160f, 0.01537392f, 0.07245436f, 0.00350569f, 0.18243015f, 
    0.04182063f, 0.01264782f, 0.03379363f, 0.06647231f, -0.13373333f, -0.04571296f, -0.01878707f, 0.13180976f, 
    0.15669645f, -0.08963225f, -0.06948265f, -0.26665398f, 0.31829032f, -0.10665454f, 0.09223262f, -0.04016396f, 
    -0.09053455f, -0.00107521f, 0.20194565f, 0.08870228f, 0.12455127f, -0.05170506f, 0.14694160f, -0.02104860f, 
    -0.08775306f, -0.22742030f, 0.27191088f, 0.16187473f, 0.11974053f, 0.13732469f, 0.03074137f, 0.10358086f, 
    0.04493803f, -0.00937745f, 0.14247192f, -0.06082545f, 0.07254933f, -0.05525186f, -0.08591740f, -0.31377190f, 
    -0.16021048f, 0.20415835f, 0.00561910f, -0.00153484f, 0.08022245f, -0.12832440f, 0.06028117f, -0.60582447f, 
    0.12675436f, -0.02305134f, 0.26169351f, 0.16716613f, 0.14056173f, -0.00469167f, -0.06560581f, -0.01736325f, 
    0.12559527f, 0.04282124f, -0.02753358f, 0.07115787f, 0.12622103f, -0.17791106f, 0.11425462f, -0.19128853f, 
    -0.04636599f, -0.05570256f, -0.13641283f, 0.04538435f, -0.01246489f, -0.08292423f, -0.01341184f, 0.05131479f, 
    0.12961341f, 0.05960663f, -0.03242912f, -0.13276845f, -0.18295324f, 0.15995076f, 0.01374425f, -0.04692459f, 
    -0.11758985f, 0.00625818f, -0.00210894f, 0.11195138f, -0.07642417f, -0.05108644f, -0.12236091f, 0.02864922f, 
    0.10754304f, 0.11489382f, 0.18342789f, -0.08463424f, -0.07682844f, 0.06089960f, -0.01115905f, 0.00050736f, 
    -0.20777567f, 0.10133709f, -0.15947089f, -0.03390879f, 0.06760651f, 0.14729892f, -0.11790203f, -0.16384906f, 
    0.06050460f, 0.08632937f, 0.32016295f, 0.00215927f, -0.08244636f, -0.01712130f, 0.02293444f, 0.11991636f, 
    -0.00594081f, 0.17011270f, -0.02644216f, -0.00674208f, 0.08635609f, 0.05451831f, 0.03597660f, -0.05255503f, 
    -0.04562725f, -0.14813609f, -0.07277103f, -0.04668074f, -0.19893029f, -0.03838309f, 0.13272834f, 0.19945027f, 
    0.20917225f, -0.50923640f, 0.08254970f, 0.08821122f, 0.03021676f, 0.11006386f, -0.05088496f, 0.01484471f, 
    0.01848982f, 0.31264642f, 0.15200657f, -0.29553282f, -0.04644969f, -0.07671717f, -0.06108157f, -0.17520051f, 
    0.09902152f, 0.00635959f, 0.00726307f, 0.02587434f, -0.07310062f, 0.08995595f, 0.09442669f, 0.10695546f, 
    0.00337872f, 0.02136903f, 0.06777862f, -0.02372026f, -0.32157815f, 0.07142416f, -0.02875972f, 0.02384556f, 
    0.04928309f, 0.10755862f, 0.04717450f, -0.00651571f, -0.28744525f, 0.00633178f, 0.06098822f, -0.04990260f, 
    0.07809429f, -0.10938896f, -0.03600112f, 0.02878652f, 0.06041192f, -0.77346802f, -0.12597482f, -0.17542168f, 
    0.03855751f, 0.06283487f, 0.12316135f, 0.14345758f, -0.02727071f, 0.08875953f, 0.10244560f, 0.01474891f, 
    -0.00578757f, 0.02180980f, 0.04678530f, -0.14516248f, -0.00026766f, -0.05822457f, -0.02907614f, -0.09616282f, 
    0.16238481f, -0.00861206f, -0.02475131f, 0.13941836f, -0.16464216f, 0.09160155f, -0.12787563f, -0.29299563f, 
    0.43775836f, -0.39839768f, -0.23646478f, -0.08595558f, -0.01443335f, 0.08085109f, 0.17443787f, -0.19985962f, 
    -0.03172161f, -0.17907545f, 0.15400764f, 0.07135731f, 0.00978973f, 0.23312190f, 0.10201603f, -0.08009249f, 
    -0.02391254f, -0.14306132f, -0.15782000f, 0.10329230f, 0.22200753f, 0.13956726f, 0.00274274f, 0.10190559f, 
    0.00639655f, -0.13231115f, -0.03411053f, -0.17836608f, 0.12361989f, -0.22037789f, 0.02487619f, -0.09666591f, 
    -0.03482867f, -0.09621012f, 0.06798360f, 0.04235606f, -0.08926868f, -0.16462837f, 0.00353715f, -0.01955710f, 
    -0.08860291f, 0.15100509f, 0.26782995f, 0.12728660f, 0.03417858f, 0.00169816f, -0.51689959f, -0.10265029f, 
    0.02312594f, 0.00504088f, 0.15480506f, -0.02341406f, -0.04314592f, 0.05500045f, -0.24951668f, 0.27030027f, 
    -0.23961130f, -0.07097818f, -0.02949056f, 0.19360133f, 0.12538646f, 0.05153413f, -0.14333162f, 0.00955014f, 
    0.37364504f, 0.01924181f, -0.25653723f, -0.07587449f, -0.17555921f, 0.18911129f, -0.07389202f, -0.06639846f, 
    0.09119639f, 0.03127955f, -0.08989931f, -0.02757955f, 0.00056480f, -0.02792167f, 0.10058822f, 0.08371150f, 
    0.15223955f, 0.20154205f, -0.02184235f, -0.21863726f, 0.11640272f, 0.10551064f, -0.00063555f, -0.15386668f, 
    0.05479502f, 0.20826088f, -0.21054651f, 0.18718685f, -0.20313111f, 0.02188211f, -0.07118201f, 0.08831303f, 
    -0.14907503f, 0.04367848f, -0.12646912f, -0.16047144f, -0.08539390f, -0.08191209f, 0.01901734f, -0.02728804f, 
    -0.09721934f, 0.13300602f, 0.06951162f, -0.04084641f, -0.25055513f, -0.16982673f, 0.06141567f, 0.05919941f, 
    -0.02180677f, -0.06709002f, 0.08562416f, -0.13522337f, 0.01671506f, 0.22522099f, 0.08538836f, 0.09730046f, 
    0.07899073f, 0.02008073f, 0.07757632f, -0.00636156f, -0.02189817f, 0.10105450f, 0.46652219f, -0.13679437f, 
    -0.10050490f, -0.06516388f, -0.03073431f, -0.02430869f, -0.08593882f, -0.08206737f, 0.02328805f, -0.08057212f, 
    0.18199649f, -0.02791653f, -0.06614177f, -0.12544838f, 0.03207525f, 0.03473251f, -0.02458634f, -0.01786747f, 
    0.17096789f, 0.10527107f, 0.10296495f, -0.09164918f, 0.03353075f, -0.21737164f, 0.03342446f, 0.18872409f, 
    0.10811139f, 0.12679698f, -0.31551558f, -0.36873779f, 0.14809299f, 0.01990600f, -0.03662830f, -0.02976996f, 
    -0.05591114f, 0.09032957f, 0.15301779f, 0.01902631f, -0.22975554f, -0.02654443f, -0.14708926f, -0.01666405f, 
    0.14425734f, -0.05906416f, 0.06567553f, -0.08227419f, 0.27457872f, 0.03612339f, -0.00717546f, -0.01071818f, 
    0.00882497f, -0.01990155f, 0.09568056f, -0.00815601f, 0.17073978f, -0.49951574f, 0.13817908f, -0.13926968f, 
    -0.02492803f, 0.07916338f, -0.01154737f, 0.04959145f, 0.00644508f, 0.02565881f, 0.08695436f, -0.00509072f, 
    0.06140192f, 0.07848530f, 0.13841085f, -0.06456253f, -0.01582457f, -0.03840951f, -0.11602531f, 0.24003354f, 
    -0.08918846f, -0.11097541f, -0.06791609f, 0.10333595f, -0.03496084f, 0.06258419f, 0.04503201f, -0.09203238f, 
    0.10506751f, -0.16584341f, -0.08011483f, -0.03566329f, -0.16843529f, 0.00967300f, 0.02918808f, 0.04653256f, 
    -0.34768245f, -0.36770198f, -0.12091688f, -0.16854919f, -0.13870533f, -0.00677791f, -0.12448317f, 0.03898211f, 
    -0.07201912f, -0.29252324f, 0.15089659f, -0.16549775f, -0.12822473f, 0.01488149f, -0.18806837f, -0.11634464f, 
    0.05393067f, 0.10584367f, 0.12310554f, -0.12927036f, -0.00728906f, 0.04591135f, -0.01437956f, -0.05340549f, 
    -0.04757478f, -0.04641959f, 0.06434401f, -0.00194906f, -0.23899192f, -0.22691351f, -0.07676078f, -0.12444817f, 
    -0.03413517f, -0.16303846f, -0.05324496f, -0.09246649f, -0.14803988f, 0.19749275f, 0.01002012f, -0.03423503f, 
    0.01479336f, -0.30548099f, -0.11149532f, 0.09663832f, 0.02111665f, 0.13542216f, 0.12793617f, 0.05432095f, 
    0.04867919f, -0.03176624f, -0.03870476f, 0.01304265f, 0.11670798f, 0.02348332f, 0.27164707f, 0.10344175f, 
    -0.06298330f, -0.05796916f, -0.06144855f, -0.08068139f, 0.12451405f, 0.14780019f, 0.08074231f, 0.50611961f, 
    0.25112838f, -0.05446612f, 0.06291983f, -0.05515222f, 0.10592980f, 0.16848607f, -0.07667803f, 0.06587511f, 
    0.08885797f, 0.21645692f, -0.00002606f, -0.17908108f, 0.00371557f, 0.11120876f, 0.08409449f, 0.06737364f, 
    -0.02730168f, 0.17969470f, 0.31557772f, -0.07261290f, 0.15290055f, 0.02148569f, 0.07904316f, -0.02920260f, 
    -0.00509275f, -0.14106554f, 0.32855788f, 0.12102698f, -0.06231096f, -0.12223073f, -0.02551669f, 0.07522376f, 
    -0.10475899f, -0.06306636f, -0.16882285f, 0.17520726f, 0.14414433f, 0.25161660f, 0.04952555f, -0.05479110f, 
    0.10651391f, 0.09298498f, -0.00234771f, 0.21722165f, 0.04313515f, 0.00922825f, -0.10887450f, 0.02697805f, 
    -0.09941199f, -0.04049062f, -0.15485093f, 0.04852683f, 0.01603517f, -0.06298531f, -0.17952022f, 0.10645060f, 
    -0.18643518f, 0.06162720f, -0.10354957f, -0.07266892f, -0.03736874f, -0.13458340f, 0.06050632f, -0.10002261f, 
    0.01233605f, 0.09979849f, -0.08184794f, 0.18673460f, -0.01592263f, -0.06228091f, -0.23962930f, 0.00454460f, 
    0.01097195f, 0.14873011f, -0.17896014f, -0.06758969f, 0.04132713f, -0.14492719f, 0.09708617f, 0.23974723f, 
    0.03502675f, 0.05973219f, -0.11856392f, 0.09340857f, -0.02967439f, 0.05335126f, 0.09398659f, -0.11593790f, 
    0.13244767f, 0.25177363f, 0.02599069f, 0.06414588f, 0.09334254f, -0.04381282f, 0.06305435f, 0.23307247f, 
    0.14759855f, -0.07513156f, 0.14493187f, 0.12679885f, 0.33426988f, 0.03579232f, 0.06783026f, 0.04653275f, 
    0.01864856f, -0.01832680f, 0.09367213f, -0.09810473f, 0.27407148f, -0.15316200f, 0.02105706f, -0.17102575f, 
    -0.28681448f, -0.07895841f, -0.07392312f, 0.02215557f, 0.03341466f, 0.13769481f, 0.01963356f, 0.07743269f, 
    -0.03330360f, 0.00617054f, -0.07912832f, -0.15936279f, 0.05153138f, -0.11063986f, -0.25900275f, 0.08250908f, 
    -0.10387459f, 0.05397098f, -0.10318363f, -0.06387842f, -0.08199415f, -0.15276645f, 0.22790039f, -0.03559783f, 
    -0.21731053f, -0.00045303f, -0.02325947f, -0.07634328f, 0.07740322f, -0.10792757f, -0.34069112f, 0.18574515f, 
    0.29758844f, -0.07154638f, -0.04246185f, -0.08410684f, -0.13594484f, 0.01975547f, -0.02308148f, 0.09687146f, 
    0.28128311f, 0.27630872f, -0.00088454f, 0.24443075f, -0.08258108f, 0.02048298f, 0.20374441f, 0.21363665f, 
    0.08031304f, -0.15964185f, -0.28502959f, 0.25554132f, -0.14277174f, 0.08189578f, -0.06317916f, 0.01106612f, 
    -0.18362573f, -0.01950392f, 0.13837816f, 0.19644509f, -0.15896758f, 0.01580223f, -0.05127959f, 0.07751316f, 
    -0.10565358f, 0.00370170f, -0.03099876f, 0.11749040f, 0.01102606f, -0.01201853f, 0.00746069f, -0.02744282f, 
    0.11429902f, -0.16815001f, -0.08354674f, -0.08014880f, -0.29163530f, 0.13821366f, -0.02789067f, -0.03380552f, 
    0.10562679f, -0.02536936f, 0.07670324f, -0.16935953f, -0.15221670f, -0.10088015f, -0.08868530f, -0.09252654f, 
    -0.14272317f, 0.14313021f, -0.01580457f, -0.20781514f, -0.02650292f, -0.02909091f, 0.13293903f, 0.11276813f, 
    0.15848537f, 0.17357805f, -0.04131826f, 0.02985648f, 0.14496347f, -0.03460309f, 0.04075583f, -0.12670532f, 
    -0.04491054f, -0.15164386f, 0.12475049f, -0.06608080f, 0.05363363f, 0.08790737f, 0.11639984f, -0.04604300f, 
    -0.15085153f, -0.16773719f, -0.03034593f, 0.00913864f, 0.07540815f, 0.08863924f, 0.09087954f, 0.06627785f, 
    0.03222107f, 0.11971331f, -0.09430560f, -0.15057299f, -0.09360849f, -0.05313936f, -0.11724347f, -0.05427730f, 
    0.05040530f, 0.14090970f, 0.28145635f, -0.29256776f, 0.00919938f, -0.09857859f, -0.02013607f, -0.04739573f, 
    0.02482412f, -0.08479939f, -0.03719354f, -0.00765180f, -0.23338334f, -0.04264511f, -0.07864184f, 0.05908949f, 
    -0.05660920f, 0.12798631f, -0.08243647f, -0.00284714f, -0.05851767f, 0.16821696f, 0.05150083f, 0.02390029f, 
    -0.08855034f, 0.03234759f, -0.10587794f, -0.00043883f, 0.11396237f, -0.49242684f, -0.25600573f, -0.07832006f, 
    0.13781227f, 0.00540443f, 0.13559684f, -0.03353450f, 0.17732249f, -0.00791253f, -0.11880478f, 0.00264504f, 
    0.02973404f, 0.23117116f, 0.12801331f, -0.11734118f, -0.15073994f, 0.09750692f, 0.17156518f, 0.04277699f, 
    0.07806664f, 0.13552731f, 0.15613514f, -0.07598463f, -0.02821364f, -0.10059617f, 0.11986545f, 0.07693792f, 
    0.12919722f, -0.22715457f, -0.16909473f, 0.12814631f, -0.12164187f, 0.15517220f, -0.14233296f, 0.00339434f, 
    -0.09792774f, -0.13291766f, -0.01739947f, 0.06458349f, -0.10068216f, 0.02815787f, -0.01279211f, 0.01892982f, 
    -0.00291298f, -0.02943320f, -0.11530368f, -0.20034418f, 0.04355172f, -0.02915655f, 0.07343078f, 0.05105811f, 
    0.03586749f, 0.06750558f, -0.06550816f, 0.03091588f, 0.06983801f, 0.03677808f, 0.03471979f, -0.02601806f, 
    -0.14042233f, 0.02286632f, 0.15648159f, -0.05129670f, -0.18176226f, -0.24240239f, -0.04336730f, 0.09595430f, 
    0.04313103f, 0.13205446f, 0.06783830f, 0.12424611f, 0.06969666f, -0.15366764f, -0.31195527f, -0.09237456f, 
    0.13189256f, 0.07888700f, 0.05045971f, 0.07772701f, -0.03117232f, -0.03485796f, 0.03573970f, 0.09744711f, 
    -0.09771757f, -0.06283008f, -0.01188815f, -0.10779588f, 0.06250434f, -0.09236974f, 0.03465309f, 0.04540389f, 
    0.02288956f, -0.08128221f, -0.24096073f, -0.05331140f, -0.05720140f, 0.22122934f, 0.04027312f, 0.07091384f, 
    -0.10328345f, 0.05524223f, 0.00376468f, 0.10617186f, 0.01180834f, -0.04525183f, 0.03893516f, 0.08321843f, 
    0.00300070f, 0.10613424f, -0.03411361f, -0.06509863f, -0.06505847f, -0.04054678f, 0.08877122f, -0.10273801f, 
    0.12395051f, 0.04299310f, -0.07562424f, 0.16852380f, -0.07847703f, -0.13304053f, -0.05817800f, -0.17811978f, 
    0.02764362f, -0.01432875f, 0.12875022f, -0.14245041f, -0.04632739f, 0.01219501f, 0.07229485f, -0.11575094f, 
    0.07195395f, -0.02929315f, -0.07955651f, 0.15422952f, -0.34342277f, -0.13106275f, 0.09674124f, 0.18240847f, 
    0.07084058f, 0.09823429f, -0.00104037f, -0.13738821f, -0.04002540f, 0.06565790f, -0.04369358f, 0.03729748f, 
    -0.07069536f, -0.03084610f, -0.04201077f, 0.13256828f, -0.00880579f, 0.05210180f, 0.46734306f, -0.13531202f, 
    0.18756601f, -0.14885242f, -0.10386819f, -0.05667272f, 0.14980096f, 0.10460297f, -0.06429958f, 0.05766356f, 
    0.00295161f, 0.04319901f, -0.15185730f, 0.03336099f, -0.08602344f, 0.17310588f, -0.06075708f, -0.19178218f, 
    -0.09808263f, 0.04871491f, 0.06896934f, 0.05433132f, 0.00568675f, 0.09691133f, 0.09201101f, 0.15090089f, 
    0.08717022f, -0.18335354f, -0.21058823f, 0.03807638f, 0.03120639f, -0.01257974f, 0.15718068f, 0.06606603f, 
    -0.05384874f, 0.04288411f, 0.24471410f, -0.04878922f, 0.02296111f, 0.00291432f, 0.02725540f, -0.03587825f, 
    0.18661009f, 0.09187189f, -0.07497451f, -0.04119660f, -0.00680987f, 0.08767639f, 0.05266561f, 0.02348485f, 
    -0.12338218f, 0.19203518f, -0.15972583f, -0.01434588f, -0.13593626f, -0.05541134f, 0.19546542f, 0.00107212f, 
    -0.18615058f, 0.05409152f, 0.09720401f, 0.02604813f, 0.00382686f, 0.06295234f, 0.07927422f, 0.03581364f, 
    -0.06461123f, -0.08204606f, -0.09632713f, 0.05198900f, 0.07185535f, 0.05579830f, -0.20538512f, 0.05658011f, 
    0.07702251f, -0.02568412f, 0.03449653f, 0.07860492f, -0.07824349f, -0.02788455f, 0.11486396f, -0.00811429f, 
    -0.03626579f, 0.08827019f, 0.15678112f, -0.03531178f, 0.03223966f, 0.27779761f, 0.14121598f, -0.05499936f, 
    0.36218587f, 0.07425383f, 0.04752846f, 0.15093632f, 0.09820733f, 0.15994942f, -0.03175448f, -0.17697707f, 
    -0.05570912f, 0.21412861f, -0.10647313f, 0.00997031f, 0.04024798f, -0.05196758f, -0.06553546f, 0.04576347f, 
    0.07053642f, -0.13542043f, -0.22128217f, 0.24355125f, 0.12665406f, 0.14390759f, -0.04199243f, 0.11915991f, 
    0.08439260f, 0.26831615f, -0.05291112f, 0.18753718f, 0.29829925f, 0.23058988f, 0.15700410f, 0.11726512f, 
    0.07829666f, 0.15737920f, -0.12250589f, -0.05805935f, -0.43651298f, 0.09281845f, -0.16446270f, -0.02209942f, 
    0.04828084f, -0.01587834f, 0.08124417f, 0.08811188f, -0.03859088f, 0.16499665f, -0.04447368f, 0.09796572f, 
    0.01042785f, -0.05779861f, -0.05822645f, -0.01438881f, -0.06763315f, 0.05285498f, -0.21636350f, -0.04747321f, 
    -0.02648235f, -0.04387445f, -0.13291739f, 0.01307257f, -0.02256469f, 0.00471688f, -0.12314527f, -0.08389024f, 
    -0.44188309f, -0.12311784f, -0.09804406f, -0.04633326f, 0.08709112f, 0.00471084f, 0.10690884f, -0.04042115f, 
    0.05411010f, -0.02696159f, -0.17504340f, 0.04290247f, 0.02904160f, 0.00853677f, -0.00905795f, -0.19121325f, 
    0.02113731f, -0.07756426f, -0.16708121f, -0.15536611f, 0.00139976f, 0.07022973f, 0.01503816f, 0.00160114f, 
    -0.04005971f, 0.08913276f, 0.03683740f, -0.04824132f, -0.14726700f, -0.02517298f, 0.01120782f, -0.01138795f, 
    -0.03855354f, -0.02194177f, 0.00926330f, 0.03009194f, 0.19558121f, -0.19147211f, 0.05779530f, -0.05036367f, 
    -0.09464332f, -0.08765024f, -0.00934628f, -0.00411850f, 0.08389942f, -0.07784845f, 0.09877571f, 0.12576582f, 
    -0.05944248f, -0.11384010f, 0.05384234f, -0.04332967f, 0.08246510f, 0.24558926f, 0.05064314f, 0.07661759f, 
    0.09346963f, -0.01579947f, 0.07776020f, 0.01841579f, -0.10859887f, 0.00128934f, -0.03194897f, 0.37045267f, 
    -0.04790771f, 0.06596839f, 0.07132905f, -0.06430496f, 0.17073518f, -0.12861577f, 0.02906256f, 0.11515416f, 
    0.06282149f, -0.22010715f, 0.22563739f, 0.03479627f, 0.17883648f, -0.04908232f, -0.09691118f, -0.21833400f, 
    0.10567104f, 0.08329602f, 0.05978175f, -0.01815582f, 0.00102875f, 0.01922093f, 0.02070834f, 0.05232058f, 
    -0.04687103f, 0.11256421f, 0.09050742f, -0.07637797f, -0.07687411f, 0.20939462f, -0.07842200f, -0.07209806f, 
    -0.05488303f, -0.01682301f, 0.03926701f, 0.26503554f, -0.08815517f, -0.04154840f, -0.00068114f, 0.13845178f, 
    -0.15665554f, -0.08586034f, -0.07693264f, -0.18418290f, 0.00789877f, -0.11660660f, -0.01729372f, 0.05603786f, 
    -0.17564121f, 0.16682938f, 0.03556096f, -0.03385546f, 0.11851408f, -0.07207507f, 0.08487749f, -0.00808122f, 
    -0.17459656f, -0.05296249f, 0.14650603f, -0.08375423f, 0.17807160f, 0.24889944f, 0.09070268f, -0.17273265f, 
    0.12194874f, -0.00879125f, 0.16324973f, -0.02643287f, 0.00610901f, -0.06440671f, -0.28117752f, -0.09176459f, 
    -0.03739829f, -0.05111764f, 0.13832985f, 0.14132036f, -0.01283594f, -0.08136487f, -0.10411825f, 0.21277103f, 
    0.14694856f, -0.07156862f, -0.19599432f, -0.06895955f, 0.00974611f, -0.10432402f, 0.01192482f, -0.09243726f, 
    0.05255758f, -0.00971243f, -0.01869981f, 0.03313290f, 0.09567397f, -0.22266777f, -0.21444857f, 0.02875646f, 
    -0.19966488f, 0.30247623f, -0.24252582f, -0.04009723f, 0.14560138f, -0.05452689f, 0.20241383f, 0.17852785f, 
    -0.09908574f, -0.14068174f, -0.03895514f, -0.06018767f, -0.05548007f, -0.18655346f, -0.01229902f, 0.06685716f, 
    -0.10402457f, -0.13281491f, -0.01282944f, -0.11565480f, 0.21513231f, -0.35424212f, 0.02987713f, 0.20490359f, 
    0.16796602f, -0.14671895f, -0.01897949f, 0.12292527f, 0.13421814f, 0.08483701f, -0.17411061f, -0.02409232f, 
    -0.12782845f, 0.08771367f, -0.06535867f, -0.02382806f, -0.17200863f, 0.25179270f, -0.11753219f, -0.35163122f, 
    0.03845646f, -0.05261806f, 0.16503339f, -0.06465355f, -0.08280282f, -0.19329146f, 0.11008188f, -0.02339511f, 
    -0.07076253f, 0.08011831f, 0.09131927f, -0.06445367f, 0.00403761f, -0.00594098f, 0.06163676f, 0.35618770f, 
    0.18865316f, 0.12444936f, 0.06679838f, 0.08623219f, -0.03500097f, 0.00044226f, -0.07057718f, 0.14267954f, 
    -0.02104026f, 0.02639799f, 0.01920551f, -0.01170488f, -0.00166161f, -0.06232772f, -0.04662289f, 0.04859863f, 
    0.02671727f, -0.07176100f, -0.04131981f, 0.00256232f, -0.00236597f, -0.00610228f, -0.05042326f, -0.04713483f, 
    0.02395438f, -0.01484700f, 0.01930146f, 0.03372787f, 0.00697600f, -0.05489253f, -0.05808845f, -0.00129392f, 
    0.04072015f, -0.06054892f, -0.03911446f, 0.03014259f, -0.01218084f, 0.04013177f, 0.03364884f, -0.06339498f, 
    -0.00743987f, 0.04667683f, 0.00088626f, 0.00662515f, -0.05719700f, 0.02643079f, 0.01949514f, -0.06937893f, 
    -0.00414551f, -0.02379789f, 0.00357220f, -0.01076089f, -0.00089750f, -0.01674889f, 0.00266371f, -0.05055026f, 
    0.01277652f, 0.00211403f, -0.02267393f, -0.04985929f, -0.05998963f, 0.01909477f, -0.04735597f, 0.03494391f, 
    0.02660828f, -0.02947073f, -0.01582015f, 0.01240101f, -0.01101535f, -0.04911824f, -0.06004482f, 0.02412905f, 
    0.01008125f, -0.03315055f, -0.07140234f, 0.03260597f, 0.02996220f, -0.00884433f, -0.03729251f, 0.03655880f, 
    -0.04505273f, -0.04438826f, 0.03912283f, 0.04312391f, -0.06114492f, -0.05520358f, 0.00425302f, -0.04169526f, 
    0.02839829f, 0.01565804f, 0.00127584f, -0.02177522f, 0.00299759f, -0.06585693f, -0.00407903f, -0.01548739f, 
    0.04330793f, -0.03320496f, -0.02702244f, 0.00955517f, 0.02369485f, 0.00419953f, 0.02211344f, 0.01965833f, 
    -0.02602486f, 0.00920010f, 0.03045821f, -0.04663264f, 0.04955084f, -0.00624665f, -0.05076414f, -0.03454952f, 
    0.02576314f, -0.05261081f, 0.01069831f, 0.00220827f, 0.04081865f, -0.03404580f, -0.05908347f, 0.03795191f, 
    -0.03939767f, -0.01444110f, 0.00279072f, -0.00773579f, 0.02944485f, 0.04553138f, -0.05063896f, -0.02042755f, 
    -0.01825451f, -0.01544973f, -0.05161930f, 0.03418569f, -0.03661745f, -0.02551247f, -0.00425536f, -0.04548110f, 
    -0.05884084f, 0.00498477f, 0.04891976f, -0.05831361f, 0.01709707f, -0.06000071f, -0.02757567f, 0.03906998f, 
    0.02334606f, -0.02024539f, 0.03359894f, -0.06338187f, -0.02389628f, -0.02843356f, 0.02141343f, 0.00221102f, 
    0.03463838f, -0.05769493f, -0.05183058f, 0.00688735f, 0.00571599f, 0.00351166f, 0.00558110f, -0.03398541f, 
    0.01056103f, -0.03624843f, -0.01996556f, -0.05072776f, -0.03247938f, 0.04680650f, -0.01490002f, 0.04865814f, 
    -0.04820029f, 0.04848444f, 0.00985298f, -0.02636926f, 0.00439625f, -0.01960411f, -0.01415516f, -0.01193734f, 
    -0.00261504f, -0.04773915f, -0.03131643f, 0.02527719f, 0.00938661f, -0.04552909f, 0.03365895f, 0.02956174f, 
    -0.06147957f, -0.04608843f, -0.02056630f, -0.01320459f, -0.05145655f, 0.03729031f, -0.01481063f, 0.02057834f, 
    0.02454179f, -0.06356838f, 0.02656092f, -0.05197977f, -0.03052435f, -0.02023641f, 0.02447570f, -0.03605679f, 
    0.02325459f, -0.04611739f, -0.03678394f, 0.03721815f, -0.02393593f, -0.06225776f, -0.05895710f, -0.00027643f, 
    0.04144074f, -0.00145508f, 0.00880201f, 0.03991524f, 0.02865117f, -0.06276917f, -0.02897988f, -0.01331122f, 
    0.00974148f, 0.02651772f, -0.00573311f, 0.00840486f, -0.04459891f, -0.00141447f, 0.01636588f, -0.01655043f, 
    -0.00466251f, -0.01168268f, 0.01766671f, -0.05006287f, -0.04121540f, 0.01464656f, 0.04069076f, 0.02760624f, 
    0.04077527f, -0.01916238f, -0.01469671f, -0.04711449f, -0.04401421f, 0.01208559f, 0.03572276f, 0.02393056f, 
    -0.03909596f, -0.03929618f, -0.01432450f, 0.02867885f, 0.00481987f, -0.02063754f, -0.02742377f, -0.06043975f, 
    -0.03840546f, -0.05942667f, -0.00045532f, -0.01761116f, 0.03776095f, -0.03222452f, 0.02368646f, -0.04996990f, 
    -0.03627522f, 0.01047745f, 0.02089136f, 0.01466867f, -0.02836741f, 0.00828502f, 0.03266927f, 0.00484278f, 
    0.03582624f, -0.02204256f, 0.03665971f, -0.06628364f, -0.03751450f, 0.03896674f, -0.00117587f, 0.03680785f, 
    -0.06306338f, -0.01706039f, -0.02108058f, 0.02118458f, 0.03995665f, 0.00434628f, -0.00783157f, -0.04219959f, 
    0.02908735f, 0.02385021f, 0.04080344f, 0.03142534f, -0.04407236f, -0.06229387f, 0.02956325f, 0.02587730f, 
    0.03836666f, 0.01797929f, -0.00129168f, -0.02707652f, -0.07302743f, -0.06380472f, 0.02326784f, -0.00323631f, 
    0.01681480f, -0.08016252f, -0.12727611f, 0.05012266f, 0.00838652f, -0.01047233f, 0.09999503f, -0.10309993f, 
    -0.09086664f, -0.05721010f, 0.04270316f, 0.13389938f, 0.09369667f, -0.09635486f, -0.11460863f, 0.20670348f, 
    -0.03917489f, 0.02797661f, -0.05566311f, 0.01989253f, -0.05083495f, 0.00171914f, -0.15626478f, -0.12218673f, 
    -0.02035481f, 0.00750899f, -0.24974410f, -0.09715967f, -0.01506521f, -0.01552381f, -0.00469675f, -0.16762386f, 
    -0.03077664f, 0.12394809f, 0.01612498f, -0.12029208f, 0.17845200f, 0.04794044f, -0.04739239f, 0.07405931f, 
    -0.06371811f, 0.07947464f, -0.02417453f, 0.14463530f, 0.08307586f, 0.28613654f, -0.14655092f, -0.06052390f, 
    -0.00369980f, 0.03685408f, 0.02579396f, -0.06218265f, -0.06559034f, -0.20649257f, -0.02307775f, 0.03053195f, 
    0.23654214f, -0.01753009f, -0.03258555f, 0.04225248f, -0.08483204f, 0.01138030f, 0.14892302f, 0.16548811f, 
    0.27703339f, 0.25927088f, -0.00387156f, 0.13312173f, -0.08391734f, -0.03029502f, 0.04480809f, -0.14679424f, 
    -0.14351407f, -0.25380206f, 0.13144140f, -0.20198214f, 0.03445289f, -0.11016754f, 0.06754212f, 0.08271553f, 
    -0.04016071f, -0.06496299f, 0.07112829f, 0.20736279f, -0.10477008f, 0.00764146f, 0.14887148f, -0.10811894f, 
    0.06050390f, -0.10848020f, -0.04532487f, 0.02543302f, 0.14671212f, -0.05784282f, 0.15433232f, 0.10995427f, 
    -0.11824603f, 0.05361536f, 0.07943877f, 0.22590320f, 0.16282478f, 0.34337583f, 0.06614391f, 0.00047972f, 
    -0.12975238f, 0.11181658f, -0.02621762f, 0.07348914f, -0.02018299f, -0.01914843f, -0.09684229f, -0.04515799f, 
    0.14501402f, 0.10725931f, -0.02021761f, -0.20149565f, -0.00212987f, 0.05439464f, -0.01605241f, -0.13302779f, 
    0.14013369f, -0.03730127f, -0.00985619f, -0.01967954f, 0.00901018f, -0.02235338f, -0.08024892f, 0.12274115f, 
    0.13200589f, 0.10524890f, 0.06102794f, -0.20007294f, -0.07178897f, -0.02861235f, -0.05362083f, 0.03175790f, 
    0.16603175f, -0.30098465f, -0.10851540f, 0.04455799f, -0.13682023f, 0.04600129f, -0.14421548f, -0.00014501f, 
    0.09626731f, -0.08161230f, 0.31878895f, -0.07557897f, 0.00000237f, 0.00208256f, -0.04038206f, -0.10248046f, 
    0.12940861f, -0.01313617f, 0.17349297f, 0.44441164f, -0.16487287f, -0.00473537f, -0.08398590f, -0.09720255f, 
    0.06029399f, 0.00925008f, 0.12566978f, 0.18658406f, 0.18809012f, -0.14388841f, -0.13750599f, -0.09644714f, 
    0.02911661f, -0.02405169f, 0.02493868f, -0.01144301f, 0.06311981f, 0.16224620f, -0.10708968f, 0.01864558f, 
    -0.02950388f, 0.13496259f, -0.01459889f, -0.07346170f, -0.06935298f, 0.15471695f, 0.19512329f, 0.05236109f, 
    0.02725843f, 0.12779303f, 0.12770790f, -0.20339835f, -0.02090766f, 0.07329347f, -0.34721157f, -0.31995851f, 
    -0.05043945f, 0.19856364f, -0.00070631f, -0.11445219f, 0.08524836f, -0.02604497f, -0.24627781f, -0.08085185f, 
    0.01859489f, -0.05053280f, 0.00597190f, 0.11286797f, 0.00622449f, -0.16350769f, 0.10977926f, 0.06078259f, 
    0.29761547f, -0.00188637f, -0.12555319f, -0.06551402f, -0.04310469f, 0.06392872f, 0.09442996f, 0.03722366f, 
    0.20777300f, 0.08114079f, 0.36692351f, 0.05204588f, 0.01505820f, -0.06943395f, -0.07865441f, 0.23178113f, 
    0.10450885f, 0.24408403f, -0.23040068f, -0.29796427f, 0.07224380f, 0.08971211f, 0.01107804f, -0.11624773f, 
    -0.01752476f, 0.00029290f, 0.13891870f, 0.11221005f, 0.09177788f, -0.03637492f, -0.07596643f, 0.11875942f, 
    -0.08488593f, -0.05608881f, -0.07377473f, 0.13634932f, -0.18809518f, -0.09013479f, -0.10328896f, -0.03675207f, 
    -0.11934002f, -0.01935828f, -0.10054512f, -0.10178605f, -0.06336171f, -0.18566090f, -0.00516362f, -0.00307757f, 
    -0.09370558f, 0.04282364f, 0.12791517f, 0.09699840f, 0.13440673f, -0.11395743f, -0.09280800f, -0.33817688f, 
    0.13360928f, -0.07287809f, -0.22251157f, -0.11793111f, -0.03657571f, -0.01457294f, 0.29096034f, -0.06186691f, 
    0.30039591f, 0.08111703f, -0.00214155f, 0.09982152f, 0.11945456f, -0.09263107f, 0.02613500f, -0.01336319f, 
    -0.12142614f, -0.11036675f, 0.18304728f, 0.04877439f, -0.01319066f, 0.07243922f, 0.03886341f, -0.24490261f, 
    0.25318947f, 0.22849789f, 0.17442732f, -0.21124344f, -0.04089886f, -0.18110155f, -0.04820146f, -0.10467815f, 
    0.10691729f, -0.27055198f, -0.09998687f, -0.12020330f, 0.06947584f, -0.12751372f, -0.16314054f, 0.19575426f, 
    0.01777212f, 0.23272780f, 0.67016977f, -0.13610971f, -0.22371109f, -0.11487488f, -0.03908047f, 0.17543980f, 
    0.13152315f, 0.02760299f, -0.02848326f, 0.01687767f, 0.19893862f, 0.16569334f, -0.15099825f, 0.05410638f, 
    0.00582228f, -0.01849264f, 0.02801898f, 0.12893082f, 0.06801437f, -0.34309492f, 0.00840872f, 0.06638227f, 
    0.07092436f, 0.05613465f, -0.09033611f, -0.04868105f, -0.10738369f, -0.08514449f, -0.01804481f, 0.14439118f, 
    -0.10955363f, 0.07152642f, -0.03434030f, 0.14317682f, 0.02859630f, -0.14903517f, 0.27839023f, -0.24458539f, 
    0.08114776f, 0.15271015f, 0.13471998f, -0.09046330f, 0.02721876f, -0.03004420f, -0.10066770f, -0.42868227f, 
    -0.19818565f, -0.24831879f, 0.14056011f, 0.11898484f, -0.06297316f, 0.12642430f, 0.00046418f, -0.01199520f, 
    -0.27187487f, 0.06511191f, -0.01202184f, 0.10156579f, 0.04703653f, 0.07207546f, 0.08265027f, 0.02264263f, 
    -0.07060558f, -0.10101316f, -0.13871309f, -0.25754574f, 0.14507473f, -0.00251959f, 0.05298214f, 0.10170472f, 
    0.08294721f, -0.06814142f, -0.15808527f, -0.14899349f, -0.22128312f, 0.12053353f, 0.01696048f, 0.27789032f, 
    0.03398921f, 0.05302405f, 0.08115420f, -0.20773159f, 0.00135932f, -0.17118295f, 0.03244750f, 0.04465076f, 
    0.02425237f, 0.07367587f, 0.02791936f, 0.05157656f, 0.00501660f, -0.19852643f, 0.05128403f, 0.03107069f, 
    0.20156306f, 0.00109164f, 0.15847190f, 0.11637279f, -0.08347390f, 0.12756115f, 0.23344943f, 0.28016433f, 
    -0.05141597f, 0.00149403f, -0.08742159f, -0.02438514f, 0.04551411f, -0.08254439f, -0.01419296f, 0.07844076f, 
    0.04120110f, -0.04275246f, -0.09350176f, 0.06436894f, -0.01273581f, 0.01199899f, 0.04052933f, 0.01630593f, 
    0.06260702f, -0.20042673f, -0.08641981f, 0.14000197f, -0.02845457f, -0.10629586f, 0.03515612f, -0.01964920f, 
    0.10660888f, -0.32073271f, -0.11340948f, 0.08548519f, 0.05236440f, 0.15363342f, -0.01246781f, -0.07804815f, 
    0.05274909f, 0.07211293f, 0.13134427f, -0.09669602f, 0.04522327f, 0.02504798f, 0.00389153f, 0.16410711f, 
    -0.02232151f, -0.05456676f, -0.16725264f, 0.09755295f, -0.07156040f, 0.15250877f, 0.03202221f, 0.04072453f, 
    -0.14815363f, -0.02456071f, -0.00259491f, 0.31712836f, -0.43179327f, 0.08682702f, -0.20570278f, 0.07725511f, 
    -0.05930824f, -0.20250040f, 0.12849168f, -0.16692160f, -0.33086389f, -0.31790534f, -0.04229898f, -0.22795886f, 
    0.13084076f, -0.03370127f, -0.09068577f, 0.09343532f, -0.23772773f, -0.07659213f, 0.24114086f, 0.00181249f, 
    -0.05412420f, 0.01575990f, -0.01983983f, 0.20427544f, -0.06311394f, -0.00800227f, -0.26422021f, 0.04294270f, 
    0.11915024f, 0.02367932f, 0.02427034f, 0.01326193f, -0.02034510f, 0.19176444f, 0.16810174f, 0.26145047f, 
    0.14343309f, -0.33718732f, -0.05026226f, 0.07495978f, -0.09281966f, -0.14632638f, 0.13535391f, -0.09836336f, 
    0.08368511f, -0.26362926f, -0.16714199f, 0.03264578f, 0.06790837f, -0.06974765f, 0.00860297f, -0.23612945f, 
    0.06267911f, -0.05145520f, 0.11864188f, 0.15445751f, -0.03491469f, -0.08464140f, 0.06041715f, -0.20366654f, 
    -0.04526140f, -0.03426091f, -0.32427272f, 0.06631056f, -0.25318691f, 0.11265954f, -0.12917136f, 0.14718118f, 
    -0.10066875f, 0.02928436f, -0.12823772f, 0.03977352f, 0.04817308f, -0.30054688f, 0.07731230f, 0.19460154f, 
    0.13158739f, -0.15965465f, 0.07336589f, -0.02759972f, 0.34418744f, -0.00456630f, 0.13688400f, -0.01279859f, 
    -0.10974487f, -0.08527304f, 0.04756742f, 0.10007697f, -0.14250867f, -0.07114147f, 0.10192027f, 0.00575048f, 
    -0.02966301f, 0.00723935f, -0.04321693f, 0.09343708f, -0.07451140f, 0.04553605f, -0.24480550f, 0.06941683f, 
    -0.15639281f, -0.10829280f, 0.09200134f, -0.08770385f, 0.07471611f, 0.15727052f, 0.16554776f, -0.20497558f, 
    -0.11273048f, 0.48227313f, 0.01997668f, 0.12290203f, 0.23838194f, -0.06022323f, 0.01370435f, -0.06444577f, 
    -0.02991098f, -0.07263367f, 0.17608526f, 0.14383180f, 0.07449570f, 0.07549807f, -0.01493214f, 0.14849503f, 
    -0.05606755f, -0.19471794f, -0.33442703f, -0.05235349f, -0.18772653f, -0.16546805f, 0.01909715f, -0.18544504f, 
    0.08216439f, -0.07295769f, -0.10736405f, 0.01082270f, 0.10364915f, -0.00669065f, -0.09614681f, -0.11998510f, 
    -0.20247607f, 0.12925091f, 0.04503957f, -0.19337490f, 0.08959615f, 0.05387424f, 0.06322228f, 0.11501338f, 
    0.02501303f, -0.10620260f, 0.23645669f, -0.11773600f, 0.06596504f, -0.03336092f, -0.12392587f, 0.01572398f, 
    -0.02373090f, 0.10683297f, 0.14050035f, -0.09026634f, 0.01462409f, -0.61859018f, -0.19858052f, 0.11918180f, 
    0.09452901f, 0.12088527f, 0.00569562f, -0.05368108f, -0.06511288f, 0.08051449f, 0.45067227f, 0.07234709f, 
    -0.13511024f, -0.13574816f, -0.12915538f, -0.05487401f, 0.09763443f, -0.09193704f, 0.09790567f, 0.33947027f, 
    -0.10101138f, -0.07761800f, -0.04119552f, -0.02846043f, 0.10777063f, 0.10087797f, 0.06982124f, -0.25900632f, 
    0.02202693f, -0.24245903f, -0.16028188f, 0.16911519f, 0.04939801f, 0.06546512f, 0.04790389f, -0.11935929f, 
    -0.00685714f, -0.03031919f, -0.09079225f, -0.08047750f, 0.03220902f, -0.15300864f, 0.10626187f, 0.10684814f, 
    0.05335710f, -0.02864968f, 0.00122239f, -0.14779343f, 0.31048757f, -0.11157718f, 0.08407967f, 0.00952828f, 
    -0.01329507f, 0.08774453f, -0.06942192f, 0.23378430f, -0.05975410f, -0.03996074f, -0.32456186f, 0.12372385f, 
    -0.06110286f, 0.00937778f, 0.03984096f, -0.02873745f, -0.13883246f, -0.04395491f, 0.00216863f, 0.04535736f, 
    0.06125828f, 0.02198334f, -0.02025815f, 0.06851672f, -0.00437942f, -0.55287504f, -0.18979786f, 0.10632713f, 
    0.14312853f, 0.04571155f, 0.15200685f, 0.07067444f, -0.01920566f, 0.09001885f, 0.00283945f, 0.02214018f, 
    -0.01766624f, -0.07569960f, 0.01440367f, -0.04451947f, -0.00353701f, 0.02445536f, 0.05788934f, 0.31761408f, 
    0.10392291f, -0.11631411f, 0.02155660f, -0.05518970f, 0.08052014f, 0.10507114f, -0.02835166f, 0.00574573f, 
    0.29367459f, 0.05383958f, 0.13053629f, -0.04939349f, 0.04339007f, 0.14932069f, -0.03534508f, 0.10232724f, 
    -0.07848535f, -0.05019080f, -0.04345142f, 0.05408448f, -0.06758590f, 0.17822406f, -0.14308767f, 0.07188893f, 
    -0.01244067f, 0.03193647f, 0.12423540f, -0.14646062f, -0.05164882f, 0.07980794f, -0.02372601f, 0.00200676f, 
    0.02408367f, -0.01654475f, -0.00615962f, -0.15342630f, 0.07318811f, -0.17185645f, -0.10831819f, 0.02150758f, 
    0.00790502f, 0.10087367f, -0.00518244f, -0.04273769f, -0.35421219f, 0.04207027f, -0.15755934f, 0.12177064f, 
    0.11253165f, 0.02199326f, -0.24521326f, -0.15125000f, -0.19560258f, 0.66656512f, 0.12151030f, 0.14744700f, 
    0.09210590f, -0.04727784f, -0.01817591f, 0.00219980f, -0.00729590f, -0.03790411f, 0.29479486f, -0.32272944f, 
    0.07392024f, 0.00545485f, -0.10298233f, -0.09252925f, 0.11737357f, 0.06683733f, 0.12106659f, -0.22433166f, 
    -0.13976003f, 0.03900138f, -0.03955200f, 0.18153250f, -0.16285598f, -0.14962506f, -0.04175700f, 0.04238972f, 
    0.25162700f, 0.07051459f, -0.19479300f, -0.13117649f, 0.10357498f, 0.03157296f, -0.13552977f, 0.00192975f, 
    0.02132275f, -0.17967185f, 0.01108865f, -0.10796615f, 0.15434079f, 0.14335315f, 0.07641779f, 0.12114343f, 
    -0.13157502f, -0.04069494f, -0.04903535f, -0.16330115f, 0.04384122f, 0.11680628f, -0.06732362f, 0.06357671f, 
    0.03594120f, 0.00884706f, 0.10896344f, 0.25686389f, -0.21292156f, 0.17111458f, 0.05199935f, 0.15191697f, 
    -0.14414977f, -0.17306979f, -0.12553120f, 0.09386251f, 0.13800985f, 0.16054718f, 0.11429040f, 0.03811892f, 
    0.01986206f, 0.03167018f, -0.00408201f, -0.04590535f, -0.04475560f, 0.42282712f, -0.00592674f, 0.00152135f, 
    0.14554645f, 0.08344226f, -0.26617500f, 0.10940886f, 0.02353724f, 0.12669535f, 0.06515094f, -0.06981403f, 
    -0.04762912f, -0.25188589f, 0.10359620f, 0.03757949f, -0.17368804f, 0.18824963f, -0.02206708f, -0.25043523f, 
    -0.07714642f, -0.05079987f, -0.01315247f, -0.12025481f, -0.03765687f, 0.02472478f, 0.08083608f, -0.03704912f, 
    -0.01443006f, 0.03917769f, 0.04511442f, 0.04302022f, -0.01540144f, -0.05202457f, -0.00952834f, -0.00753052f, 
    -0.05315832f, 0.03836853f, 0.02601177f, -0.03071669f, -0.01178462f, 0.01745208f, -0.04415569f, 0.03976972f, 
    0.00176453f, -0.05769093f, 0.01940734f, -0.01873262f, 0.05638389f, -0.01238846f, -0.03214284f, 0.04843636f, 
    -0.06092516f, -0.06083143f, 0.02802224f, -0.03350077f, -0.02470442f, -0.02746603f, -0.03905896f, 0.04173780f, 
    -0.00897871f, -0.04887540f, 0.03072719f, 0.01497319f, 0.01012639f, -0.04147790f, -0.02530796f, 0.00718264f, 
    -0.04803920f, -0.00182214f, 0.02111100f, -0.04903857f, -0.03296854f, 0.00562945f, -0.05256329f, -0.02387462f, 
    0.01168560f, -0.03207036f, 0.01752426f, -0.01790671f, -0.02463295f, -0.02148174f, -0.02902929f, 0.02929836f, 
    -0.01821041f, 0.01733987f, 0.02540751f, 0.04133692f, -0.04958975f, -0.04859301f, 0.01802602f, -0.04600643f, 
    0.03827332f, 0.00285437f, -0.01931080f, -0.05792785f, 0.01891940f, -0.05335788f, -0.00432274f, 0.03379718f, 
    0.04824713f, -0.00502458f, -0.02326674f, -0.05624780f, -0.06079363f, -0.02566860f, 0.01249204f, -0.05332277f, 
    0.02114137f, 0.05127005f, -0.03621567f, -0.01117643f, -0.04467586f, 0.04724057f, -0.03322160f, 0.00447590f, 
    -0.02934060f, 0.02472377f, 0.00587472f, -0.02809003f, 0.01680410f, -0.04657954f, -0.05060954f, -0.01572166f, 
    0.04145448f, 0.03939546f, 0.01509802f, 0.03266528f, 0.02493442f, -0.00036895f, 0.00889613f, 0.03450414f, 
    0.01470887f, -0.01495399f, -0.05482346f, 0.04483125f, -0.01776435f, -0.03691560f, -0.04005925f, 0.05037198f, 
    -0.04662319f, -0.04213991f, 0.01293225f, -0.05474644f, -0.05049111f, 0.03574377f, 0.03513526f, -0.04449571f, 
    -0.01004941f, 0.01146600f, -0.04652335f, -0.04034790f, 0.04930891f, 0.04790785f, -0.01985681f, 0.00667728f, 
    -0.06212635f, -0.01552720f, -0.06222094f, -0.04613969f, 0.01468875f, -0.03204030f, -0.03540789f, 0.01127562f, 
    -0.02168127f, 0.01092843f, 0.05100792f, -0.04178359f, -0.04312269f, -0.03429709f, -0.00468143f, -0.03346134f, 
    -0.00383181f, -0.04548829f, -0.04104359f, -0.06354088f, -0.00937492f, -0.03810362f, -0.05424323f, -0.00308966f, 
    -0.00007082f, 0.01356548f, -0.02149602f, 0.01221039f, -0.04252464f, -0.02270418f, -0.01767112f, -0.03014376f, 
    -0.04442101f, -0.05482529f, 0.01959034f, 0.02248496f, 0.00284919f, 0.01641556f, -0.01057039f, -0.02805875f, 
    -0.02111525f, -0.04920348f, -0.02049836f, -0.05813411f, 0.00814146f, 0.00443704f, -0.01884861f, -0.04052749f, 
    -0.02129481f, 0.00741881f, 0.01111303f, 0.01381828f, 0.05208706f, -0.05531451f, 0.00819680f, -0.04681821f, 
    0.00217774f, 0.02225553f, 0.05235157f, 0.01068392f, -0.04156658f, 0.00985432f, -0.06381321f, -0.05297007f, 
    -0.03680287f, -0.04022351f, -0.02735793f, -0.04034946f, 0.01193942f, 0.02327442f, -0.00508996f, 0.03171545f, 
    -0.06181389f, 0.04393595f, -0.05747002f, -0.05099994f, 0.01889264f, -0.03627822f, 0.01865492f, -0.05308178f, 
    0.00197850f, -0.03296443f, 0.01837763f, 0.01199322f, -0.04153641f, -0.05849921f, 0.00647670f, -0.00765251f, 
    -0.00743466f, -0.05292621f, 0.03825980f, 0.02328725f, -0.01995752f, -0.03390146f, -0.05258279f, -0.01045323f, 
    0.01008245f, -0.06306632f, 0.03248220f, -0.00331937f, -0.03602245f, -0.01146249f, 0.04512303f, -0.03141620f, 
    -0.03474274f, 0.02012829f, 0.04719831f, 0.02129448f, 0.01085352f, -0.05165904f, -0.04216989f, -0.02676273f, 
    0.04299272f, 0.04093796f, -0.05799420f, 0.04164425f, -0.06062737f, -0.02980410f, 0.00862078f, -0.06262732f, 
    -0.03535137f, 0.00818287f, 0.04908677f, 0.04872774f, 0.03025641f, 0.02315191f, 0.02456234f, 0.04792317f, 
    0.03384075f, 0.00967272f, -0.02451499f, 0.01216722f, 0.05104016f, -0.05662301f, 0.02754112f, -0.01601611f, 
    -0.00339182f, -0.03388827f, -0.04516826f, 0.05024687f, 0.01544054f, 0.03673470f, -0.03107328f, -0.03920551f, 
    -0.03183899f, 0.04725798f, -0.03394551f, -0.00627270f, 0.02318704f, -0.05419378f, 0.03466450f, 0.03077471f, 
    -0.05476268f, -0.05455395f, 0.00770815f, 0.00878682f, 0.00025308f, 0.01625299f, 0.04769695f, -0.02907618f, 
    0.50316614f, 0.23788604f, -0.23439999f, -0.08213908f, -0.23293456f, -0.16640148f, 0.15471965f, 0.05892384f, 
    0.06066616f, 0.20819843f, -0.13781559f, 0.02081644f, 0.14451630f, -0.05933706f, -0.08508440f, -0.08736784f, 
    -0.00447587f, 0.02692663f, -0.11324210f, -0.06540263f, -0.26121023f, 0.08629395f, 0.18447953f, -0.01711616f, 
    0.00707304f, -0.06101428f, 0.11546125f, 0.18737906f, 0.04977889f, -0.10902335f, 0.08467855f, 0.05268897f, 
    -0.01945394f, 0.02959570f, -0.05430995f, -0.00437907f, 0.00525368f, -0.05698869f, 0.15542911f, -0.09136978f, 
    0.28040060f, 0.08998749f, -0.28044909f, 0.02838659f, 0.04782887f, -0.05873157f, 0.01090126f, 0.12332484f, 
    0.19999263f, -0.04292845f, 0.21102397f, 0.04847514f, 0.10298258f, -0.04981393f, 0.13537326f, -0.19345799f, 
    0.03828146f, 0.22239678f, 0.22871193f, 0.17637874f, -0.04843027f, -0.08818668f, -0.09025117f, 0.02242546f, 
    0.06095605f, -0.08701520f, 0.02097620f, 0.07463254f, 0.10654560f, -0.40605614f, 0.14653106f, 0.25976250f, 
    0.42387718f, 0.00842502f, -0.22600833f, 0.02365354f, -0.16709888f, -0.10722695f, 0.02227735f, 0.31508234f, 
    -0.22128831f, 0.01588064f, 0.08230165f, -0.06346878f, -0.05996079f, 0.04229720f, 0.03662799f, -0.05282353f, 
    -0.18300177f, 0.14338461f, -0.22238500f, -0.10266723f, -0.18502831f, 0.01745962f, -0.02435338f, 0.06668113f, 
    -0.06390719f, -0.23532844f, 0.06864938f, -0.02456759f, 0.32343313f, 0.03612940f, -0.06525809f, 0.06061020f, 
    -0.07381272f, -0.01496839f, -0.03274379f, -0.07944741f, -0.28486943f, -0.26161310f, -0.02077486f, 0.04807616f, 
    0.04349749f, 0.14020383f, 0.06581496f, 0.01370029f, -0.22939096f, 0.38594100f, 0.35348049f, 0.02532005f, 
    -0.18266141f, -0.09453870f, -0.16922845f, 0.16265462f, 0.14826791f, 0.10725728f, -0.16552243f, 0.11248877f, 
    0.08713549f, -0.09039643f, 0.15310286f, -0.09204586f, -0.20742682f, -0.08558125f, 0.17527194f, -0.18461192f, 
    -0.00109645f, -0.09280073f, 0.16246949f, -0.08435424f, -0.28816766f, 0.02764828f, 0.03745640f, -0.14361224f, 
    -0.11846692f, 0.18815942f, -0.19854534f, 0.04155371f, 0.01611258f, 0.16677094f, -0.03429541f, -0.03651698f, 
    -0.02880917f, 0.11051492f, -0.20594451f, 0.00412434f, 0.11724519f, 0.11248063f, 0.11540926f, -0.05854384f, 
    -0.13360021f, -0.03263100f, -0.12262620f, 0.16091090f, 0.00253003f, -0.02187558f, 0.06037491f, -0.08303069f, 
    -0.09048098f, -0.04950091f, 0.05938226f, 0.01235969f, 0.07322954f, -0.01993614f, -0.15601750f, 0.11167418f, 
    0.26426390f, 0.03787677f, -0.06610481f, -0.20170996f, -0.17096569f, -0.28395143f, -0.10623113f, 0.05502304f, 
    0.17054303f, 0.08283364f, -0.10984541f, -0.08252792f, -0.32671076f, 0.26054913f, 0.04352084f, -0.20761473f, 
    0.21770439f, -0.19453034f, -0.12859026f, 0.26780215f, 0.01021278f, 0.07657770f, -0.06501681f, -0.30145600f, 
    -0.05510959f, -0.10874487f, -0.11694965f, 0.04565927f, 0.17394269f, -0.10066467f, 0.04075674f, 0.16519494f, 
    -0.02561185f, 0.05731448f, -0.10901972f, -0.02967868f, 0.12051249f, 0.08942700f, 0.16029413f, -0.01189390f, 
    -0.21307753f, -0.18117535f, -0.01685376f, 0.19687998f, 0.15209655f, 0.10701695f, -0.10133260f, -0.01375022f, 
    0.06902879f, 0.45971742f, 0.28191411f, -0.01966067f, -0.26007968f, -0.10962229f, -0.00165743f, 0.12738568f, 
    0.00118771f, 0.15993400f, 0.23234436f, 0.26712614f, -0.06600799f, 0.01065536f, 0.07525608f, -0.07711883f, 
    0.06667428f, 0.07593617f, 0.02267116f, -0.31606600f, 0.12565750f, -0.05775098f, 0.12324727f, -0.02407662f, 
    0.16665818f, 0.19927597f, -0.17213263f, 0.12622422f, 0.35098714f, 0.29495576f, -0.02849026f, -0.22901046f, 
    0.03278402f, -0.20676541f, 0.09979863f, 0.03425715f, 0.00968503f, -0.13786478f, -0.11143234f, -0.35110331f, 
    0.17717014f, 0.13184834f, -0.09494919f, 0.05193174f, 0.10430586f, 0.13050944f, -0.26755172f, 0.13465519f, 
    0.06979609f, -0.03684495f, -0.01010481f, 0.12668991f, 0.23376517f, 0.02880293f, 0.31701875f, -0.33069742f, 
    0.23859465f, 0.18584755f, 0.04585159f, 0.28576466f, -0.01783917f, -0.25651419f, -0.00276325f, 0.16971481f, 
    0.09086171f, 0.04757814f, -0.02182433f, 0.13491803f, 0.04650893f, -0.12349942f, -0.06101346f, -0.08193848f, 
    0.07665200f, 0.14191344f, 0.29842830f, 0.18771198f, -0.14130454f, -0.07419220f, -0.14472286f, -0.07796533f, 
    -0.05639883f, 0.09538652f, 0.39526528f, 0.03995935f, -0.26874170f, -0.19425787f, -0.21736805f, 0.00464654f, 
    -0.02453504f, 0.13770434f, 0.02759136f, 0.08253767f, 0.22660625f, 0.13424878f, 0.07355006f, 0.21174602f, 
    -0.01594527f, 0.16130766f, 0.12142111f, 0.16232274f, 0.04015485f, -0.00237989f, -0.17337829f, 0.10274284f, 
    -0.10275559f, -0.11769466f, 0.01400662f, 0.01714995f, 0.06056837f, 0.04002446f, 0.16942415f, -0.07009298f, 
    0.00564081f, 0.14482236f, -0.17036769f, -0.00540657f, 0.03136759f, -0.01814963f, -0.06684194f, -0.28051439f, 
    0.06996360f, -0.03970712f, -0.07553311f, 0.14403297f, -0.21568251f, -0.06625375f, 0.14707376f, -0.45589760f, 
    -0.44162521f, -0.18483968f, -0.06762726f, -0.02384334f, 0.09206323f, 0.04546450f, -0.03734544f, -0.17905460f, 
    -0.17026287f, 0.12066430f, -0.06099023f, -0.11523142f, -0.03542716f, -0.07889456f, 0.09162890f, 0.00104745f, 
    0.12511882f, -0.49015975f, -0.32734260f, 0.07055491f, -0.06340595f, 0.06555845f, -0.00843606f, -0.03235986f, 
    0.03193758f, 0.07315215f, -0.14852695f, -0.28538674f, -0.07301825f, -0.05146915f, 0.12534583f, 0.09262051f, 
    0.10792996f, -0.05903111f, 0.11372960f, -0.13242505f, 0.02285413f, 0.20929882f, -0.02231383f, 0.06748419f, 
    -0.00251414f, -0.07177323f, 0.10602079f, 0.07004691f, 0.05682081f, -0.00409861f, -0.07950746f, 0.09291717f, 
    0.05045439f, -0.09662066f, 0.04285696f, 0.10248180f, 0.06558948f, -0.12773152f, 0.04399383f, 0.19798411f, 
    0.06092326f, 0.03976005f, -0.08992843f, 0.08402211f, 0.11065303f, 0.07735407f, -0.18413477f, -0.26375961f, 
    0.12566146f, 0.08415876f, 0.07899968f, -0.03393447f, 0.03076534f, 0.07378818f, 0.07918616f, -0.28609362f, 
    0.14192581f, -0.14678206f, 0.18553156f, 0.10355265f, 0.12287448f, -0.12673040f, -0.04403410f, -0.06931101f, 
    -0.03456173f, -0.07311583f, 0.30352756f, -0.15056995f, -0.19316313f, 0.17718925f, -0.01789352f, 0.02947504f, 
    -0.01256634f, 0.13695005f, 0.10917640f, 0.17947662f, -0.05650195f, -0.03239916f, 0.15866709f, -0.01476266f, 
    0.07268478f, 0.16449803f, -0.72305542f, 0.02183221f, 0.39408442f, 0.04858405f, 0.06937889f, -0.01739918f, 
    -0.14934970f, -0.10128438f, 0.10512626f, 0.15926190f, -0.12657821f, -0.05258853f, 0.05058914f, -0.11006499f, 
    -0.00426135f, 0.01618733f, 0.08905052f, 0.06261513f, 0.23133183f, 0.19583233f, 0.23724836f, -0.00058336f, 
    -0.08481310f, -0.21235807f, -0.00661979f, 0.05476267f, 0.10828625f, -0.09576779f, -0.18046401f, -0.39326617f, 
    0.10697350f, 0.15554897f, 0.17073068f, 0.01331186f, 0.01115630f, 0.19069648f, -0.37162519f, -0.53816557f, 
    -0.37707916f, 0.06279355f, 0.09295341f, 0.11383673f, 0.09781107f, 0.08535760f, 0.09372597f, 0.25436556f, 
    -0.13281785f, -0.06708953f, 0.16013876f, -0.00404425f, 0.14119509f, 0.05799120f, -0.01138689f, -0.02779347f, 
    -0.01547760f, -0.12504487f, 0.03349773f, 0.02861744f, -0.18449074f, -0.17315730f, -0.02906137f, -0.01022208f, 
    -0.09575149f, -0.01791755f, -0.15067789f, -0.13383061f, 0.16764352f, -0.06171961f, 0.03155198f, -0.01525240f, 
    -0.13662802f, -0.05467537f, -0.20248908f, 0.08980407f, -0.04616754f, -0.02186034f, -0.10910189f, -0.04897761f, 
    0.02051226f, -0.07135715f, 0.12168338f, 0.17876571f, -0.35646066f, 0.02255448f, 0.04419862f, -0.15064143f, 
    0.10808273f, 0.12729926f, 0.02175137f, -0.02385243f, -0.32334483f, -0.15894377f, 0.00832506f, 0.24921599f, 
    -0.10147988f, -0.07138656f, 0.03372423f, 0.14605093f, 0.14929087f, -0.15220545f, -0.20064519f, -0.37434331f, 
    0.27957565f, 0.12086994f, 0.09782290f, -0.11641420f, 0.10500514f, 0.01353033f, -0.55909860f, 0.11314901f, 
    0.08959675f, 0.02867187f, -0.11047391f, -0.19681038f, 0.01837835f, 0.05331190f, -0.13404970f, 0.30487508f, 
    0.15495987f, -0.41384807f, 0.09376046f, -0.21342294f, 0.03227125f, 0.12173840f, 0.16539283f, -0.00810687f, 
    0.04006143f, 0.03833126f, 0.01655395f, 0.00475431f, 0.08588137f, 0.05095777f, -0.19289552f, -0.00990156f, 
    0.17345321f, -0.04877303f, 0.05642201f, -0.30840111f, 0.15837736f, 0.01445024f, 0.09591387f, -0.03679918f, 
    -0.10990836f, 0.00080438f, -0.09771211f, 0.20538574f, 0.19945213f, 0.11366111f, -0.07868208f, -0.05409922f, 
    0.01646446f, 0.27592084f, -0.02481834f, 0.08777799f, 0.20591049f, -0.02672485f, -0.00426370f, -0.04891492f, 
    0.09850834f, -0.07780138f, 0.17292957f, 0.15211014f, 0.12623301f, -0.15922487f, -0.12060277f, 0.01228631f, 
    -0.01895916f, -0.36050057f, -0.06307268f, 0.07717841f, 0.14159161f, -0.34835017f, -0.03684593f, 0.15712486f, 
    0.13109523f, 0.06909735f, -0.23563124f, -0.08499511f, 0.07886060f, 0.01797432f, 0.00630274f, 0.06980466f, 
    0.07801323f, -0.35251579f, -0.06527092f, -0.18902317f, 0.09682828f, -0.11883704f, 0.01279987f, 0.10325644f, 
    -0.10686548f, -0.01742389f, -0.24819598f, -0.26556212f, 0.17541596f, 0.17958385f, 0.03110699f, -0.08693506f, 
    -0.11514970f, -0.03040393f, 0.10766502f, 0.09814617f, 0.02705625f, 0.16195813f, 0.00136632f, -0.03401417f, 
    -0.02211040f, -0.05069196f, -0.06068777f, -0.13532332f, 0.02722967f, -0.03706133f, 0.01865355f, 0.30837253f, 
    -0.01440007f, -0.16442017f, 0.02281329f, 0.01050806f, -0.02611022f, 0.13545066f, -0.01519507f, 0.18979889f, 
    0.20557025f, -0.13784680f, -0.08296087f, 0.02121793f, 0.03030010f, 0.02647241f, -0.23161787f, -0.11314024f, 
    0.04942320f, -0.03345935f, -0.01884813f, 0.03039202f, -0.02806720f, -0.07185948f, 0.07430472f, 0.10708670f, 
    -0.00957168f, -0.10846302f, -0.02480338f, -0.00331160f, 0.14651854f, -0.24922155f, -0.02518092f, -0.03038536f, 
    0.09246447f, 0.07863977f, 0.10387338f, -0.12056638f, -0.00635055f, 0.04589704f, -0.03279778f, 0.33924049f, 
    -0.01059274f, -0.05297235f, 0.06473916f, 0.10912691f, -0.00941261f, 0.12163040f, -0.15492119f, 0.37430450f, 
    0.12104023f, -0.01459505f, 0.17869356f, -0.08180192f, 0.11302826f, -0.06807646f, -0.06573761f, -0.05748508f, 
    0.05279664f, 0.17590028f, 0.17861812f, -0.26333681f, 0.13551943f, -0.07601000f, 0.04952136f, 0.05553190f, 
    0.04633958f, -0.11628749f, 0.07745617f, -0.21466032f, -0.05633319f, 0.09733020f, -0.01134093f, 0.04205715f, 
    0.05695226f, 0.01117949f, 0.09789545f, 0.11636627f, -0.09093121f, -0.04942804f, 0.07117768f, 0.09943841f, 
    0.04873328f, -0.03888484f, -0.17530054f, 0.09702130f, -0.28769410f, -0.27758232f, 0.05144354f, -0.02989650f, 
    -0.12713350f, 0.00423254f, 0.09978326f, 0.10344001f, -0.20872629f, 0.04346069f, -0.10529902f, 0.12666772f, 
    -0.25883782f, -0.08196887f, 0.02599466f, 0.09581424f, 0.19265173f, 0.34023336f, 0.19009282f, 0.01326908f, 
    -0.05521843f, 0.05409357f, 0.11091852f, -0.11890797f, -0.01636542f, -0.09242341f, 0.22224851f, -0.17446983f, 
    -0.15783395f, 0.06135216f, 0.04872377f, 0.07547709f, 0.05170801f, -0.01849779f, 0.02456647f, -0.17477991f, 
    -0.01301437f, 0.12301040f, 0.10298948f, -0.01041893f, 0.06401455f, 0.01327009f, -0.04537385f, -0.05565538f, 
    -0.06367254f, -0.07978295f, 0.00335264f, -0.23212071f, -0.04832570f, -0.31261832f, 0.00778581f, -0.02408890f, 
    -0.10023421f, -0.18271990f, 0.09704307f, 0.01213503f, 0.04326727f, 0.01466434f, 0.02224029f, 0.03618247f, 
    -0.03219265f, -0.04370847f, -0.09160139f, -0.11736431f, -0.00575534f, 0.02481453f, 0.07506466f, 0.12869792f, 
    -0.08132631f, -0.05629384f, 0.07538334f, 0.22511213f, 0.05562757f, -0.20458363f, 0.24093653f, -0.02878706f, 
    0.24767399f, -0.09137956f, 0.04887266f, -0.16109470f, 0.15493406f, 0.02221441f, -0.02958057f, 0.12414570f, 
    -0.00630889f, -0.02973183f, -0.08759867f, -0.01043935f, -0.17296964f, 0.22151341f, 0.13271570f, -0.20933281f, 
    0.09981509f, 0.08691356f, 0.01477388f, -0.12433656f, -0.02158726f, 0.08203614f, -0.01257209f, 0.04898075f, 
    0.01745023f, 0.13007532f, -0.07083464f, 0.08886434f, -0.04613865f, -0.04655886f, -0.05832128f, -0.17251559f, 
    -0.03646694f, -0.11907471f, 0.07252479f, 0.04596234f, -0.23897029f, -0.18950273f, -0.08084364f, 0.10527706f, 
    -0.56515545f, -0.09499342f, 0.21871826f, 0.23479530f, 0.07355162f, -0.01654095f, 0.05497771f, 0.03324965f, 
    0.03653539f, -0.14052117f, 0.19643033f, -0.13457696f, 0.06996085f, -0.06205650f, 0.05013359f, 0.01384900f, 
    0.19168694f, 0.11476374f, 0.35232478f, -0.18043622f, 0.04124155f, 0.02190729f, 0.17645945f, -0.09010630f, 
    -0.02928607f, 0.10916945f, -0.09339682f, -0.12047653f, -0.17742617f, 0.11332985f, 0.07151636f, 0.06840868f, 
    -0.15013310f, -0.04821777f, 0.18210050f, 0.02155607f, 0.07774021f, 0.10693910f, -0.14782637f, 0.02238656f, 
    -0.01033507f, 0.10102320f, 0.07386360f, 0.05083686f, -0.31862164f, -0.18070759f, 0.05483406f, -0.24241272f, 
    0.06415501f, 0.08062425f, 0.06907123f, -0.01729649f, 0.11402281f, -0.00615652f, 0.05943263f, 0.06081322f, 
    -0.11550849f, -0.00690159f, -0.03215817f, 0.02267858f, 0.13592075f, 0.08927879f, -0.01138449f, 0.03031474f, 
    0.18017523f, 0.03320649f, 0.00244786f, 0.06624282f, 0.26375398f, -0.15468805f, 0.10358148f, 0.03154451f, 
    -0.07145760f, 0.21552902f, -0.33089584f, 0.18129382f, 0.09681065f, -0.04277545f, -0.15701941f, 0.19987702f, 
    -0.17838651f, -0.09097125f, -0.10058594f, -0.16192175f, -0.10734184f, -0.07381867f, 0.03765686f, -0.04959877f, 
    0.05232739f, 0.17544557f, -0.08120686f, 0.15023635f, 0.19248508f, -0.06537390f, 0.21912438f, -0.24539652f, 
    0.08941145f, 0.08466291f, 0.06862560f, -0.02971398f, 0.09537398f, 0.00968332f, -0.03920779f, -0.04695527f, 
    0.10692357f, -0.09063490f, 0.00029830f, -0.04317668f, 0.08239339f, -0.07459725f, -0.18284138f, 0.06941433f, 
    0.07938752f, 0.03202255f, 0.05388718f, 0.04658012f, 0.09748739f, -0.53287494f, -0.15123560f, 0.02583910f, 
    0.13902773f, 0.08745320f, 0.07198166f, 0.01028472f, -0.03161613f, -0.08120442f, 0.03837623f, -0.02159750f, 
    0.01991856f, -0.03884725f, 0.00883540f, -0.06263212f, -0.18551387f, -0.11470570f, 0.25129673f, 0.08469348f, 
    0.05374055f, -0.05984458f, -0.13201448f, 0.09742929f, -0.00827235f, -0.04451653f, 0.24308600f, -0.03264341f, 
    0.14126700f, -0.15467484f, 0.02301762f, 0.03001087f, 0.01556383f, 0.07475740f, 0.01848848f, 0.00091700f, 
    -0.09295032f, 0.01270945f, 0.09004793f, 0.08307229f, -0.00455454f, -0.01240975f, 0.01097442f, 0.05839045f, 
    -0.00426603f, 0.04403567f, 0.09080494f, -0.11224568f, -0.04770005f, 0.11571491f, -0.06034353f, 0.02810807f, 
    -0.06473189f, 0.04448371f, -0.05464867f, -0.09973884f, -0.01512942f, 0.04946862f, -0.07530563f, 0.13759990f, 
    0.04304202f, 0.07166916f, 0.01413735f, -0.19130170f, -0.07910518f, -0.18633865f, 0.03645867f, 0.18902229f, 
    0.02604541f, 0.03681758f, 0.02695878f, 0.07243601f, 0.02294837f, -0.14021188f, 0.26925674f, 0.47311145f, 
    0.16166908f, -0.13999596f, -0.03152747f, 0.04025119f, -0.07649763f, 0.06148383f, 0.48972088f, 0.06851730f, 
    -0.17895411f, -0.08116824f, -0.12647381f, -0.02452144f, -0.10065175f, 0.03878916f, 0.16489014f, -0.03223994f, 
    -0.05770677f, 0.12031136f, -0.02613324f, 0.12333584f, -0.17934385f, -0.02157647f, -0.00757868f, -0.09805346f, 
    0.21626379f, -0.01618749f, 0.04652147f, 0.00041129f, -0.15258868f, 0.19516239f, 0.03028688f, 0.09299564f, 
    -0.05727676f, -0.61330104f, 0.07764564f, -0.08434732f, -0.11681149f, 0.20149232f, 0.15222938f, 0.11079119f, 
    -0.21823493f, -0.13209836f, 0.15410542f, 0.01326909f, 0.05805542f, -0.09565195f, 0.13397533f, -0.02136576f, 
    0.03467435f, 0.06906100f, 0.17719857f, 0.19865701f, 0.08644909f, 0.08790182f, 0.04951799f, -0.10309477f, 
    -0.06998802f, -0.12843466f, -0.25075564f, 0.10362282f, -0.18460329f, 0.28318346f, 0.27700052f, 0.11175267f, 
    0.11957741f, -0.13532473f, 0.06233108f, -0.09526743f, -0.12560016f, 0.34656680f, 0.25436124f, 0.05813660f, 
    0.17429206f, -0.06397339f, -0.18227391f, -0.16152735f, -0.02684503f, 0.25813153f, 0.02240703f, 0.07946672f, 
    0.12310110f, -0.11271654f, -0.06346024f, 0.09140409f, -0.17084639f, 0.08158395f, -0.13352700f, -0.28682750f, 
    -0.16729286f, 0.03383079f, -0.14782618f, 0.16946633f, 0.08791497f, 0.11696389f, -0.11652558f, -0.10213811f, 
    -0.08425039f, 0.00328468f, -0.11559737f, -0.12962548f, 0.01498764f, -0.02085933f, -0.09202894f, 0.00919354f, 
    0.13530658f, 0.19446850f, 0.39032391f, -0.06760861f, -0.16051292f, 0.16503775f, 0.04988620f, -0.11118536f, 
    -0.00200871f, 0.15441318f, 0.15348512f, 0.00120728f, -0.11681139f, -0.06058794f, 0.13722219f, -0.26230711f, 
    0.14018008f, -0.02085995f, -0.08067377f, -0.03997708f, -0.03504496f, 0.02331561f, -0.06864527f, -0.12052651f, 
    -0.20763712f, -0.07557830f, 0.05946549f, 0.03778461f, 0.07952584f, 0.11206794f, 0.03144803f, 0.07233860f, 
    -0.02981023f, -0.01191599f, -0.05740137f, -0.09104903f, -0.06907132f, 0.18166281f, -0.07707933f, -0.22182260f, 
    -0.14209527f, 0.01594660f, 0.19257006f, 0.04653291f, 0.09926236f, -0.04869989f, -0.22314610f, -0.02864452f, 
    0.10842774f, 0.25151467f, -0.06983738f, 0.10128702f, -0.06728090f, -0.00415427f, -0.03991327f, -0.38628596f, 
    0.10926237f, 0.35582459f, 0.26597607f, -0.01922801f, 0.02963343f, -0.21631828f, -0.04714052f, -0.06886388f, 
    0.00754827f, -0.11123897f, -0.20380205f, -0.12647131f, 0.06648945f, 0.09576886f, -0.02461639f, 0.04540609f, 
    -0.20257521f, -0.20275585f, 0.02900231f, 0.23598476f, 0.21427123f, 0.02091233f, 0.13483073f, -0.13902369f, 
    0.11253712f, 0.04346306f, 0.34963435f, -0.02332087f, 0.04607591f, -0.00445072f, 0.06253243f, 0.05613150f, 
    -0.04399820f, 0.01798876f, 0.03535381f, -0.29126078f, -0.11068208f, 0.21416533f, 0.26947734f, 0.17624110f, 
    -0.01981488f, -0.10749339f, -0.04530284f, 0.00935355f, -0.06900611f, 0.07484027f, -0.18434067f, -0.10088451f, 
    -0.03620892f, 0.00634048f, -0.04919481f, 0.00569480f, -0.14295855f, 0.07333788f, -0.00571027f, 0.01313119f, 
    -0.08189715f, 0.12484151f, 0.12400109f, 0.07982828f, -0.02316312f, 0.02380770f, -0.24004655f, 0.03925375f, 
    0.09343605f, 0.12750106f, 0.13055049f, 0.01710664f, 0.12397949f, -0.03910575f, -0.08270192f, 0.25052580f, 
    0.07635927f, -0.01633059f, -0.15804568f, -0.05463427f, 0.02109900f, -0.11516896f, -0.05675644f, 0.09070016f, 
    -0.04236073f, -0.27850056f, 0.07274805f, 0.17003876f, 0.03490839f, 0.09077922f, -0.01255677f, -0.12881072f, 
    0.05046602f, -0.22876786f, 0.06982381f, 0.30221537f, 0.06699029f, -0.00654546f, -0.06934784f, -0.03052023f, 
    0.04061566f, 0.19017245f, -0.15838133f, -0.01837525f, 0.19938228f, 0.23107147f, 0.13814692f, 0.12549348f, 
    -0.04083068f, 0.06575119f, 0.06300886f, -0.06879824f, 0.04572557f, 0.15077125f, -0.05399929f, 0.00884563f, 
    -0.03805711f, -0.01706927f, -0.07018165f, -0.00778542f, -0.24681200f, -0.19417909f, 0.00143206f, 0.05162166f, 
    0.00042115f, 0.04826397f, -0.05015890f, -0.12617756f, -0.01277203f, 0.19391598f, 0.14540790f, -0.04136630f, 
    -0.01894668f, -0.07454698f, 0.11094148f, 0.02931459f, 0.10802665f, 0.06056144f, 0.01303779f, 0.08759465f, 
    -0.07380068f, -0.07641712f, 0.05482747f, -0.08248164f, -0.16636424f, -0.04274203f, 0.06769548f, 0.47168446f, 
    0.00529952f, 0.28499049f, -0.25793955f, 0.02778104f, 0.01867874f, 0.16562873f, -0.01956463f, 0.15306404f, 
    0.18103409f, 0.07128337f, 0.19644693f, 0.15974028f, -0.02394154f, 0.06221472f, -0.12518553f, 0.23249751f, 
    0.40837660f, -0.04138234f, 0.09892009f, -0.25257698f, -0.07983463f, -0.05643653f, 0.15110990f, -0.11401170f, 
    0.03802984f, -0.16524300f, 0.23007579f, 0.05102691f, 0.12817362f, 0.04479358f, -0.04265874f, 0.30076656f, 
    -0.19536413f, 0.03903997f, 0.13067491f, 0.23867230f, -0.16118804f, 0.06365595f, 0.13599178f, -0.09969285f, 
    0.02088205f, 0.44917589f, -0.12164805f, 0.06420965f, -0.08750564f, 0.01665284f, 0.17608806f, -0.18475893f, 
    0.06678639f, 0.06991384f, 0.10006385f, 0.12290734f, 0.06358032f, 0.05805998f, 0.26684669f, 0.15342273f, 
    0.07228540f, -0.00564272f, -0.17326145f, -0.07166972f, -0.14135604f, 0.10414612f, 0.11467225f, -0.15018584f, 
    0.24244064f, 0.09729398f, 0.00593003f, 0.07090741f, -0.07242567f, -0.00273735f, 0.05071020f, -0.37886107f, 
    0.12506437f, 0.07316951f, 0.10510462f, 0.00350948f, -0.06678882f, 0.23852414f, -0.04488003f, -0.22791210f, 
    0.29664072f, -0.08219735f, -0.01803271f, 0.12832135f, 0.00681265f, 0.08104454f, -0.01333067f, 0.03848219f, 
    0.19011976f, 0.32748964f, 0.08633156f, -0.17619970f, 0.23049128f, -0.04856167f, -0.13263983f, -0.15613660f, 
    0.02966682f, 0.13024150f, -0.34149605f, 0.03464572f, -0.02287764f, 0.10846350f, -0.09355634f, -0.12865299f, 
    0.07951359f, -0.11067574f, -0.00328267f, 0.13701622f, -0.01219581f, 0.06771995f, 0.28081158f, -0.03604861f, 
    0.02928197f, 0.03252378f, 0.24121204f, 0.11881696f, -0.12683646f, -0.20767450f, -0.16726506f, -0.04590667f, 
    0.06826590f, -0.10840207f, -0.05023566f, 0.11412296f, -0.03271086f, 0.43883446f, -0.12681042f, -0.22450629f, 
    0.09507064f, 0.02163837f, -0.10773873f, 0.05328016f, 0.07863559f, -0.00651356f, -0.06000197f, -0.04385216f, 
    0.18459266f, -0.13132341f, 0.13118111f, -0.03763232f, -0.18372750f, 0.14910255f, 0.01108906f, -0.23284648f, 
    -0.09010768f, 0.04387588f, 0.21175978f, -0.14553957f, 0.02962988f, -0.11283284f, 0.15072179f, 0.00639644f, 
    0.02257810f, -0.27813998f, -0.14908917f, 0.05121903f, 0.06245764f, -0.14026333f, -0.04743832f, 0.02792762f, 
    0.06057558f, -0.17725955f, -0.02153898f, -0.24319775f, -0.07556807f, -0.09008820f, -0.10247307f, -0.03358338f, 
    0.03375039f, 0.03573952f, -0.11312222f, 0.11696017f, -0.40165767f, -0.12331957f, -0.05191460f, 0.09393752f, 
    0.13532975f, -0.07683355f, 0.10564591f, 0.08430043f, 0.31350070f, -0.10090078f, 0.05498114f, -0.04517423f, 
    0.05159451f, -0.06915805f, 0.00058175f, 0.01181074f, -0.03511440f, -0.05942467f, -0.07362408f, 0.05985422f, 
    -0.06047009f, 0.07213532f, 0.20865060f, 0.09918501f, -0.01012457f, 0.25803959f, 0.03798030f, 0.07761235f, 
    0.15857923f, -0.00619426f, -0.04725207f, 0.10205800f, 0.00109087f, 0.13887244f, -0.05065938f, 0.24621905f, 
    0.01639571f, 0.05127656f, 0.10163716f, -0.03084048f, -0.10281834f, 0.12023905f, 0.21607822f, 0.20836854f, 
    -0.06761597f, -0.11910926f, 0.01976976f, -0.02271855f, 0.18128334f, -0.16968124f, 0.12763460f, 0.02621543f, 
    0.05391879f, 0.20574029f, 0.09998827f, -0.02908884f, 0.06791709f, 0.03541201f, 0.02775217f, -0.09685124f, 
    0.09135555f, 0.10262846f, 0.20949443f, -0.02178060f, -0.14595221f, 0.11608388f, -0.06388433f, -0.03310538f, 
    0.03362430f, -0.13538750f, 0.34792891f, 0.44371894f, -0.04286726f, -0.00955378f, -0.03278672f, 0.09560605f, 
    -0.10842777f, -0.04465343f, 0.04496643f, -0.05955042f, -0.03743048f, -0.04999177f, -0.02166183f, 0.04544036f, 
    0.06367855f, 0.05291897f, -0.05129301f, -0.02857211f, 0.34411070f, -0.27971578f, -0.04091737f, -0.11845506f, 
    0.03323371f, -0.31601480f, 0.19005330f, 0.10582827f, 0.04904988f, 0.20533422f, 0.05987502f, -0.01752433f, 
    -0.02427369f, 0.01281397f, 0.09420298f, -0.02553577f, 0.04179978f, 0.00316656f, -0.58005422f, -0.03090201f, 
    -0.11047436f, 0.08052517f, -0.03977534f, 0.11023706f, 0.09547538f, -0.12414841f, 0.12699039f, -0.20291099f, 
    -0.02329290f, -0.19733584f, -0.01352559f, -0.10094178f, 0.01439907f, 0.07323442f, -0.05170079f, 0.00146359f, 
    -0.07989430f, -0.00951369f, -0.19074994f, -0.15179220f, -0.00454717f, -0.19597468f, -0.03117083f, -0.00691328f, 
    -0.07600037f, 0.06917407f, -0.02055047f, 0.19276625f, 0.12712839f, -0.13139385f, 0.11019605f, -0.11681014f, 
    0.06931695f, -0.12019034f, 0.03877027f, 0.10267991f, -0.03794533f, -0.11456691f, -0.06907216f, 0.00945774f, 
    0.05185042f, 0.05400210f, -0.19832946f, 0.17115231f, 0.08313631f, -0.04731139f, -0.12470430f, -0.00950401f, 
    0.08651178f, -0.21277548f, -0.07353718f, 0.10732067f, 0.05762240f, 0.18754247f, 0.04206647f, -0.08126520f, 
    -0.09181941f, -0.03656653f, 0.01068295f, -0.08332904f, -0.00855688f, 0.24657978f, -0.01969843f, 0.00326112f, 
    -0.10294802f, 0.08841836f, 0.03693300f, 0.22817636f, 0.03735726f, 0.12162805f, -0.05017252f, 0.23904809f, 
    -0.27510548f, 0.10491074f, -0.10282000f, -0.15593660f, -0.06544322f, 0.05048836f, 0.03905200f, 0.03899601f, 
    -0.28526786f, -0.11393779f, 0.10336614f, -0.07701955f, -0.08550598f, -0.00468576f, -0.22643426f, -0.02812974f, 
    0.31218195f, 0.02330482f, 0.14721483f, 0.08769711f, 0.07413938f, 0.02615050f, -0.13757373f, 0.02049504f, 
    -0.10101793f, 0.06629718f, 0.07445891f, -0.09933621f, -0.02913705f, -0.20509067f, -0.12910993f, -0.17651139f, 
    -0.03178199f, -0.04787342f, -0.02573709f, 0.17895772f, -0.19943407f, 0.12373313f, -0.04906313f, -0.10074910f, 
    -0.08269906f, 0.05514486f, 0.08332936f, 0.03221500f, -0.06031420f, 0.01798286f, 0.05135268f, 0.02031028f, 
    0.05828305f, -0.03802893f, 0.07384004f, -0.03946829f, -0.02241472f, -0.13230489f, -0.15289462f, 0.00885525f, 
    -0.01076078f, -0.01346437f, 0.03075681f, 0.18370223f, 0.10534103f, -0.39291793f, -0.16720152f, -0.11218271f, 
    0.00810317f, 0.01973505f, 0.02590700f, -0.08219346f, 0.14349371f, -0.01989785f, -0.01066607f, 0.03949946f, 
    -0.01532412f, -0.21597125f, -0.05809362f, -0.04625493f, 0.02253809f, 0.10307071f, 0.04553908f, 0.14278512f, 
    -0.00447553f, -0.07076517f, -0.14554720f, 0.07422506f, -0.09768184f, 0.14606833f, -0.01568697f, 0.01283461f, 
    0.51582718f, -0.19370067f, -0.13485403f, 0.06023869f, 0.15324518f, -0.05437926f, -0.10409617f, -0.08908365f, 
    -0.14096542f, -0.15801030f, 0.04656257f, -0.16210522f, -0.00602812f, -0.05214501f, 0.07966868f, 0.09906506f, 
    -0.00176611f, -0.14512046f, -0.41213676f, 0.09701379f, -0.13473734f, 0.08318225f, 0.09832247f, -0.03859808f, 
    0.00340936f, -0.08067452f, 0.04643757f, 0.05467246f, 0.20472923f, 0.07101278f, -0.03792349f, -0.13508348f, 
    -0.02594375f, -0.02572814f, 0.01411687f, 0.04049203f, -0.10267201f, -0.05101887f, 0.03399160f, -0.02774772f, 
    0.01714437f, -0.01466649f, 0.09996361f, 0.25243118f, 0.10377934f, 0.00562581f, -0.08222192f, 0.05433767f, 
    0.13192822f, 0.15296362f, 0.00665864f, -0.10928987f, -0.07425558f, 0.03988772f, -0.08391817f, 0.15482637f, 
    0.07238790f, -0.06809885f, 0.11668541f, -0.09894319f, -0.18954809f, 0.20540264f, 0.08734923f, 0.26556268f, 
    0.19196111f, -0.04810840f, -0.02323301f, 0.02382397f, -0.16234738f, 0.12128321f, 0.04018911f, 0.00974619f, 
    0.08899711f, 0.15638606f, 0.15655307f, -0.29636228f, 0.00065935f, -0.05794632f, 0.06922944f, 0.17091843f, 
    0.07576541f, -0.00933396f, 0.08240998f, 0.11248720f, 0.02847047f, -0.07975274f, 0.08767326f, -0.09898765f, 
    0.17409243f, -0.12293337f, 0.00800583f, 0.22116750f, -0.17891960f, -0.18763091f, -0.10752546f, -0.07782288f, 
    -0.07510328f, 0.02778420f, 0.08070532f, 0.03597770f, -0.08920326f, 0.00596538f, -0.10076211f, 0.02978948f, 
    -0.00062500f, 0.24866569f, 0.00951042f, 0.13569883f, 0.12639247f, 0.06520186f, 0.01833816f, 0.11133081f, 
    0.10025755f, -0.02046700f, 0.03530183f, 0.12422916f, 0.14186200f, 0.16267110f, 0.24512328f, 0.17537552f, 
    -0.03362881f, 0.12280338f, 0.05778695f, -0.16942023f, -0.04535250f, 0.05718267f, 0.18359867f, -0.18677954f, 
    -0.25879753f, -0.03203521f, -0.01130965f, -0.05466142f, -0.11411311f, 0.03679651f, -0.06204734f, -0.06759294f, 
    0.04784903f, 0.01022120f, -0.10125744f, 0.08223414f, 0.08241481f, 0.12239314f, -0.09158991f, -0.24560791f, 
    -0.06693523f, -0.00542689f, 0.17102537f, -0.19457442f, 0.07630588f, 0.03181387f, -0.00527030f, -0.00921387f, 
    -0.04325956f, -0.26894185f, 0.03147070f, -0.20684499f, 0.10260269f, 0.17642777f, 0.13720667f, -0.20770672f, 
    -0.03976782f, -0.01795746f, 0.20424190f, 0.03778180f, -0.16263883f, 0.01745741f, -0.14786817f, -0.05568083f, 
    0.02895780f, 0.08989382f, -0.18120496f, -0.00540594f, 0.14881456f, -0.10511145f, -0.00222802f, -0.16136986f, 
    -0.17053181f, -0.01117093f, 0.12740757f, 0.07851665f, 0.09896461f, -0.16812804f, 0.05846598f, 0.07284336f, 
    0.00507696f, 0.06117526f, -0.05622690f, -0.21453403f, -0.05601507f, 0.12293379f, -0.00540333f, -0.04965175f, 
    -0.16685252f, -0.07903070f, 0.05767911f, -0.01676635f, -0.00913114f, -0.03408374f, -0.04170578f, 0.19816898f, 
    -0.11282515f, -0.15425597f, -0.09338137f, 0.00828751f, 0.09648984f, 0.02684844f, -0.17091091f, -0.10424459f, 
    0.06855714f, -0.10722464f, -0.00112370f, -0.06481294f, 0.08931650f, -0.16784637f, 0.01562443f, -0.21184173f, 
    -0.02864299f, -0.02849133f, -0.01439012f, -0.03215902f, -0.01493938f, 0.03819993f, 0.00831383f, -0.04911012f, 
    -0.03444616f, 0.04840317f, -0.03116906f, 0.04783143f, 0.00548069f, 0.01217467f, 0.02131876f, -0.02832470f, 
    -0.00964743f, -0.03466003f, 0.04611163f, -0.03969967f, -0.03849779f, 0.02732577f, 0.03712535f, 0.02005226f, 
    -0.02054731f, -0.01497910f, 0.00422209f, 0.00179226f, -0.03356862f, 0.00272523f, -0.04210059f, -0.01795532f, 
    0.01974492f, 0.02499530f, -0.00899203f, 0.03440792f, -0.04122030f, -0.04198466f, -0.03408640f, 0.00072749f, 
    -0.06386875f, -0.02453894f, -0.02556395f, -0.03924788f, 0.04755696f, 0.03682591f, 0.01578987f, 0.00188202f, 
    0.00958144f, 0.04393997f, -0.04188931f, -0.04614193f, -0.02294937f, 0.05174309f, 0.00374969f, -0.01773556f, 
    -0.01162345f, 0.02835641f, -0.06034018f, -0.00925589f, -0.04330846f, -0.05010033f, -0.02301257f, -0.01769688f, 
    -0.06199957f, 0.03069332f, 0.00357228f, -0.02095598f, 0.03902235f, 0.00579249f, 0.05359259f, -0.01648184f, 
    0.01560650f, 0.03043140f, -0.01037554f, 0.01107073f, -0.00105338f, 0.00760178f, 0.04508001f, -0.01309220f, 
    -0.03677652f, -0.03266709f, 0.02166706f, -0.00263883f, 0.03640677f, -0.04886181f, -0.05225702f, -0.05210216f, 
    0.04664469f, 0.02335580f, -0.02661438f, -0.05754480f, -0.02641636f, -0.05154984f, -0.01509592f, 0.03829326f, 
    -0.04672616f, 0.02049129f, -0.05824698f, -0.01768820f, -0.03986447f, -0.03295116f, -0.00218036f, -0.01966625f, 
    0.01058602f, -0.01804745f, 0.02709019f, 0.01090109f, 0.00641159f, 0.01980093f, 0.02051015f, -0.04387263f, 
    0.05173916f, -0.02176034f, 0.05099064f, -0.00309652f, -0.04418237f, -0.05260689f, 0.03847269f, 0.04065945f, 
    -0.03773854f, -0.03897887f, -0.05690475f, -0.02415659f, -0.05485934f, 0.02706542f, 0.02097390f, -0.03136458f, 
    -0.06377430f, -0.00253369f, -0.02914491f, 0.01357115f, -0.03345840f, 0.02788474f, -0.04228126f, 0.03212770f, 
    0.00308363f, -0.04675017f, 0.00868946f, -0.01723094f, 0.01448273f, 0.02200088f, -0.03002649f, -0.05063240f, 
    0.04995659f, -0.00144094f, 0.05068163f, 0.00204975f, -0.03925015f, -0.01041298f, -0.01145112f, 0.00661136f, 
    -0.03011702f, 0.04598756f, 0.04192660f, 0.02906391f, 0.01222495f, -0.05431050f, -0.05797380f, -0.01932945f, 
    0.01069789f, 0.01062624f, -0.05792149f, -0.05892320f, 0.03863735f, -0.05611088f, -0.05314488f, 0.02942504f, 
    -0.01760320f, 0.00997222f, -0.05314472f, 0.00500780f, 0.03461915f, -0.03590390f, -0.01033428f, -0.05812912f, 
    0.04125502f, 0.03456881f, 0.05148318f, -0.03797457f, -0.04801318f, -0.06136484f, -0.00043004f, -0.03891350f, 
    0.00838460f, 0.03486775f, -0.00357770f, -0.01099541f, -0.01492553f, -0.02971998f, -0.00962559f, -0.06015788f, 
    0.00395839f, -0.03064056f, 0.01755638f, -0.00574282f, 0.01240023f, -0.03331381f, 0.04435484f, -0.00245125f, 
    -0.00741375f, -0.04701570f, -0.04829745f, -0.00696681f, -0.01761321f, 0.03607656f, -0.03081659f, 0.04004084f, 
    -0.04500178f, 0.01460493f, -0.04184517f, -0.05641033f, 0.01593679f, -0.00842340f, 0.04109791f, 0.01945060f, 
    -0.02758059f, -0.02798919f, -0.03125939f, 0.00543613f, 0.01328173f, -0.05570804f, 0.01351180f, -0.06367497f, 
    -0.01443722f, 0.00872394f, -0.00667662f, 0.04231881f, -0.04856613f, -0.00178521f, 0.00004380f, 0.00228143f, 
    0.04023161f, 0.02166833f, 0.01252548f, -0.03893850f, 0.00017238f, 0.04495636f, 0.01879049f, 0.02449285f, 
    0.02578146f, 0.03887056f, 0.00919262f, -0.06227040f, 0.00081337f, -0.05321169f, -0.05740033f, 0.03598291f, 
    0.02603584f, -0.05424039f, -0.00735102f, -0.04509633f, -0.05468009f, -0.02876994f, -0.02441205f, 0.04894263f, 
    0.05685838f, -0.01079561f, -0.03514174f, -0.00018078f, -0.05557619f, -0.04073352f, -0.01383557f, -0.06292642f, 
    -0.01344378f, -0.03711713f, 0.02100350f, -0.04515684f, 0.02688868f, -0.03681293f, -0.04353857f, -0.05016101f, 
    -0.04039349f, -0.05397056f, -0.04456325f, -0.01234267f, 0.02186828f, 0.03892034f, 0.02960653f, -0.04529161f, 
    0.05071604f, -0.00627320f, -0.04864351f, 0.00290587f, 0.01941871f, 0.00949164f, -0.01006573f, -0.02099086f, 
    0.19327402f, 0.20921579f, -0.03687945f, -0.09576288f, -0.13985308f, -0.21183853f, -0.06695569f, 0.00138787f, 
    0.08395924f, 0.15455465f, -0.13246840f, -0.07620367f, -0.00234103f, 0.03584165f, -0.11531105f, -0.15808715f, 
    -0.00551708f, 0.11206681f, -0.00918333f, -0.27493188f, 0.10642987f, 0.11547152f, -0.06361263f, 0.00800963f, 
    -0.11601888f, -0.19681218f, -0.01300365f, 0.04808867f, 0.21739323f, -0.05258952f, -0.12373499f, -0.03923431f, 
    -0.06514959f, -0.05386136f, 0.12789246f, 0.23585384f, 0.24229923f, 0.43197078f, 0.34458682f, -0.10453925f, 
    -0.07974180f, -0.12877867f, 0.08552697f, 0.11197709f, -0.01885018f, -0.04055155f, 0.15601623f, -0.07931866f, 
    -0.13117890f, -0.10322074f, 0.03416685f, 0.33947596f, 0.13992883f, 0.04321864f, 0.35711572f, 0.39277568f, 
    -0.20919317f, 0.08446434f, -0.09315044f, -0.01070712f, 0.03655528f, -0.11059759f, -0.00766298f, -0.10608794f, 
    0.02286077f, 0.02594779f, -0.09502250f, 0.05069700f, 0.11954670f, -0.07557771f, -0.24177815f, -0.06279248f, 
    -0.08309966f, 0.03185729f, 0.03537564f, -0.13927279f, -0.04453647f, -0.16008648f, 0.04380224f, 0.11261394f, 
    -0.03147688f, -0.05812342f, -0.14207658f, -0.00268794f, -0.00691961f, 0.08681021f, 0.05791471f, -0.11591372f, 
    -0.04818498f, 0.04680615f, -0.14021680f, -0.23777476f, 0.14877720f, 0.25510621f, 0.08012570f, 0.11657034f, 
    0.05803757f, -0.01065220f, 0.10775018f, -0.29852545f, 0.07561644f, 0.17152637f, 0.01555608f, 0.06262238f, 
    0.08701456f, 0.05169664f, -0.08863176f, -0.03669830f, 0.13539863f, 0.04731086f, 0.02460922f, 0.03715181f, 
    0.13809662f, 0.02981991f, 0.05791290f, 0.09878477f, -0.08519296f, 0.19954638f, 0.14187971f, 0.09529439f, 
    -0.18515494f, -0.05524931f, -0.08704085f, 0.14164826f, -0.05547511f, -0.01635350f, -0.06848855f, 0.13491550f, 
    0.06649639f, 0.07489964f, -0.14707239f, -0.05306190f, -0.11532202f, -0.04115980f, 0.09275818f, -0.17762145f, 
    -0.36196372f, -0.03846020f, -0.03053010f, 0.25439268f, 0.02295224f, -0.08163649f, 0.02124492f, -0.03692115f, 
    0.11029100f, 0.18597943f, -0.25715849f, 0.01702694f, -0.10573909f, 0.04781330f, -0.03442333f, 0.00291683f, 
    -0.05367726f, 0.35231364f, 0.15344459f, -0.17138080f, 0.17204505f, 0.05392963f, 0.10703011f, 0.00782412f, 
    -0.20586161f, -0.16992441f, -0.44292095f, -0.04265739f, -0.18669787f, -0.00801044f, 0.04037306f, 0.04955383f, 
    0.02489927f, -0.02624291f, -0.10104958f, 0.20839839f, 0.12701383f, -0.06679662f, -0.00609379f, 0.04106906f, 
    0.06752749f, -0.08160486f, -0.03820825f, 0.09817972f, -0.08686850f, 0.15144841f, -0.26552916f, 0.01065350f, 
    0.08910427f, -0.28880826f, -0.10875564f, -0.07203387f, -0.16056567f, 0.00486807f, -0.11060016f, 0.03838461f, 
    0.14315890f, 0.09265801f, -0.01998842f, 0.23866694f, 0.03790712f, -0.03798114f, -0.35302854f, -0.09089357f, 
    -0.25693437f, 0.09894115f, -0.09561818f, -0.04027509f, 0.00922587f, 0.15114774f, 0.08482019f, -0.16318689f, 
    -0.25046054f, 0.12712573f, -0.03397360f, 0.09907820f, -0.03430738f, 0.10101083f, -0.02283328f, 0.04814350f, 
    0.10387091f, 0.11111428f, -0.20808715f, -0.06142952f, 0.02512458f, 0.06441146f, 0.11571982f, 0.11659268f, 
    -0.03933863f, 0.18415031f, -0.16010824f, -0.27043131f, -0.14647558f, -0.06789190f, -0.20902298f, 0.10931782f, 
    -0.08257328f, 0.04229540f, -0.29271075f, 0.14090157f, -0.15005384f, -0.16363253f, 0.00096661f, 0.01195764f, 
    -0.10005499f, -0.04458616f, -0.23068023f, -0.22716951f, -0.02865124f, 0.12771404f, 0.08801166f, 0.17084415f, 
    -0.16075876f, 0.12909947f, 0.09280626f, 0.03706227f, 0.23042122f, -0.07012878f, 0.02684827f, 0.11151009f, 
    -0.26627672f, -0.01875121f, 0.24667548f, 0.13387115f, 0.05947855f, -0.18415141f, 0.02010341f, -0.20248385f, 
    0.08085990f, 0.09344983f, 0.20016661f, 0.12442274f, 0.10954854f, -0.09814838f, -0.18947399f, 0.02870676f, 
    -0.13687886f, 0.00729626f, -0.01571567f, 0.08792681f, -0.00662487f, 0.14096093f, 0.01752339f, -0.06149063f, 
    -0.17886870f, -0.34980464f, -0.06443001f, 0.09094945f, -0.05677233f, -0.05733763f, -0.02844205f, 0.08622655f, 
    -0.05311869f, -0.01607236f, -0.01296620f, 0.03781225f, -0.03806121f, 0.01926028f, 0.01874194f, 0.00636126f, 
    -0.06064629f, 0.04742943f, 0.00426220f, -0.02802166f, -0.01221124f, -0.02115612f, 0.01445276f, 0.01071024f, 
    0.03119090f, -0.02743471f, 0.01632630f, -0.00189508f, -0.04631441f, -0.04628618f, -0.02534045f, 0.00710242f, 
    -0.01757753f, -0.03853765f, -0.01010999f, 0.04469286f, -0.01996101f, -0.00854776f, -0.02338593f, -0.05762995f, 
    0.01764995f, 0.05043100f, -0.02489740f, 0.03771328f, 0.00312437f, -0.01090306f, -0.01140567f, 0.00460600f, 
    -0.00605690f, -0.01968973f, -0.05173063f, -0.05553722f, 0.01710800f, 0.02824270f, -0.01241529f, -0.05519596f, 
    0.03341413f, -0.02229480f, 0.01586008f, 0.04599530f, -0.03758834f, 0.02197125f, -0.03966206f, -0.05917023f, 
    -0.05930555f, 0.02633467f, -0.04622905f, 0.00043678f, -0.05413226f, -0.03353071f, -0.01390246f, -0.03181848f, 
    0.02242696f, 0.03407107f, -0.06131400f, 0.02003268f, 0.01955493f, 0.03930250f, -0.05210177f, 0.03819336f, 
    -0.01445317f, 0.04300529f, 0.03189784f, 0.03532964f, -0.01492160f, 0.01059627f, 0.00333364f, 0.04555163f, 
    0.00101362f, -0.00028434f, 0.03757226f, 0.02409837f, 0.01471824f, -0.01513212f, -0.00135959f, 0.00257708f, 
    -0.05771112f, -0.00143895f, -0.01904023f, -0.00462837f, -0.03353345f, -0.04347449f, 0.04930106f, 0.04942488f, 
    -0.04286884f, -0.03442580f, -0.06177881f, -0.02572956f, -0.06392580f, 0.02920885f, -0.01051662f, 0.01790735f, 
    0.04907058f, -0.06011964f, -0.02524066f, -0.04061186f, 0.03406780f, 0.03710101f, 0.01105519f, -0.05814822f, 
    0.00751587f, -0.01396848f, -0.04977808f, -0.05238298f, -0.00821661f, -0.04285125f, -0.01812928f, -0.06571075f, 
    -0.02343061f, 0.02885154f, 0.02481883f, -0.00614065f, 0.03927336f, -0.01081082f, 0.03922416f, -0.03360424f, 
    0.03683085f, -0.06025499f, -0.01309208f, 0.00706219f, -0.02551115f, -0.02469007f, 0.02380503f, -0.00707492f, 
    -0.00080089f, 0.01910141f, 0.04141558f, 0.04881901f, 0.02846767f, -0.04254815f, 0.00237333f, -0.00074905f, 
    0.00912333f, -0.01926417f, -0.06215547f, -0.00630638f, -0.02900667f, -0.01943642f, -0.00993221f, -0.05828577f, 
    -0.05051165f, 0.02197555f, 0.04932212f, -0.05112515f, -0.05541415f, -0.01779567f, -0.05012280f, 0.03550357f, 
    -0.04322978f, 0.03357835f, -0.06840191f, 0.00045660f, -0.06237580f, 0.04478196f, 0.04674952f, -0.03099645f, 
    0.01314450f, -0.02934895f, -0.00021736f, -0.02224559f, -0.03607789f, -0.00109971f, 0.01449441f, -0.04650361f, 
    -0.05471718f, -0.00554667f, -0.02644641f, -0.02152542f, 0.05379596f, 0.03253356f, 0.00892163f, -0.01344469f, 
    -0.05970741f, 0.02788055f, 0.02344613f, -0.03397961f, 0.03796254f, -0.00806191f, -0.03991301f, -0.01884184f, 
    0.01648390f, 0.04395326f, 0.02033930f, -0.06209166f, -0.05320292f, 0.01045780f, 0.00079941f, -0.01955865f, 
    -0.00982179f, 0.02221455f, -0.02925710f, 0.03743319f, -0.03966279f, -0.01523990f, 0.02736709f, 0.03690243f, 
    -0.02345648f, 0.02717591f, -0.01345105f, 0.02819776f, -0.02710161f, 0.00816888f, -0.06147530f, -0.02418105f, 
    -0.05204718f, -0.00123007f, 0.01142980f, -0.00643125f, 0.00874860f, 0.04624650f, 0.02634286f, 0.01882513f, 
    0.03615060f, 0.03621983f, -0.02303575f, -0.05811647f, -0.00274007f, 0.01888905f, -0.04325308f, -0.03173696f, 
    0.00871043f, -0.04627015f, 0.03234056f, 0.02849163f, 0.02185320f, -0.05520238f, -0.00407735f, 0.00559187f, 
    -0.00306400f, -0.05147285f, -0.04135696f, 0.02870927f, 0.01885803f, -0.02045081f, -0.00661101f, -0.00575156f, 
    0.01531461f, 0.04074996f, -0.05743252f, 0.02923544f, -0.05356881f, -0.01797707f, -0.01952330f, -0.02966437f, 
    -0.05544405f, -0.00412773f, -0.00100126f, -0.00876116f, 0.03823730f, 0.00950894f, 0.03677701f, -0.03579668f, 
    0.03053094f, 0.00809650f, 0.01729927f, -0.05327454f, -0.01076406f, -0.01735644f, 0.01916828f, 0.04120684f, 
    -0.02460738f, 0.00455528f, -0.02107300f, 0.01039392f, 0.03433983f, 0.01896483f, -0.04354421f, 0.04419061f, 
    -0.05377129f, 0.00127373f, 0.04215935f, 0.01898245f, 0.00507471f, -0.06857143f, -0.05363966f, -0.03227394f, 
    -0.23598698f, 0.06474394f, -0.02966048f, 0.02810980f, 0.08545831f, -0.01277982f, -0.07644969f, -0.07642129f, 
    -0.04691912f, -0.18294093f, -0.26896477f, 0.22741868f, -0.35818097f, 0.06993186f, -0.06124300f, -0.01399071f, 
    -0.07440981f, -0.10367356f, -0.80517191f, 0.16298738f, -0.20270123f, 0.06438524f, 0.02200078f, -0.01178113f, 
    0.00803217f, -0.11383031f, 0.06553206f, -0.26789728f, -0.00699339f, -0.04276921f, -0.00734652f, 0.06160095f, 
    0.01394918f, 0.04553097f, 0.00993313f, 0.04824578f, 0.30602312f, 0.10080152f, 0.17813243f, -0.14466880f, 
    0.01939975f, 0.09009039f, -0.04992642f, 0.05549398f, 0.03825522f, -0.26669893f, -0.03741672f, 0.18458231f, 
    -0.05990232f, -0.07147123f, 0.01240163f, 0.03609022f, 0.01158265f, 0.22750618f, 0.32109952f, 0.09779682f, 
    0.11284264f, 0.03589630f, -0.07267781f, -0.06361475f, 0.09044746f, 0.11175838f, -0.05053775f, 0.29973719f, 
    -0.36988577f, -0.08694671f, 0.02846560f, 0.00982687f, -0.08638650f, 0.24442872f, -0.01814109f, -0.06173982f, 
    -0.08243909f, -0.11178597f, 0.16340481f, -0.09831136f, 0.10938314f, 0.00549573f, -0.23312072f, -0.02235252f, 
    0.09026635f, 0.06731975f, -0.16676159f, -0.31326672f, 0.04610449f, 0.01872712f, -0.00436246f, 0.10158248f, 
    -0.10617561f, 0.02901465f, -0.11915812f, -0.22528686f, -0.25471333f, 0.01649645f, 0.06190677f, -0.03303894f, 
    -0.01835373f, -0.19318178f, 0.20702238f, -0.06623620f, -0.07246324f, 0.25186196f, -0.06375359f, 0.00567430f, 
    -0.06808421f, -0.01246447f, -0.03111718f, -0.11110720f, -0.15133765f, 0.17955460f, -0.07369449f, -0.02797058f, 
    0.05434939f, -0.14641200f, 0.07688649f, 0.08277612f, 0.21047369f, -0.20595674f, 0.03375525f, -0.13143928f, 
    -0.06770742f, -0.08416951f, 0.07472288f, -0.16936119f, -0.03780172f, -0.03745614f, 0.18464608f, -0.06720959f, 
    0.06526241f, -0.05254515f, 0.11808233f, 0.18125008f, -0.02343004f, 0.12200593f, -0.13345981f, 0.25304011f, 
    0.02925787f, -0.08135487f, 0.07427554f, 0.14619948f, 0.05521052f, -0.25977185f, 0.01207401f, -0.16895413f, 
    0.48019502f, 0.23457123f, 0.05291839f, 0.03957262f, -0.08460022f, -0.07045016f, 0.05766325f, -0.01150626f, 
    0.15938655f, 0.04055223f, 0.14738506f, 0.19545722f, -0.00809280f, 0.12844858f, -0.03775419f, 0.12511960f, 
    0.05945791f, -0.13883919f, 0.32103738f, -0.15909080f, 0.23547408f, -0.03840945f, -0.02621691f, 0.10207392f, 
    -0.05937817f, 0.02201297f, -0.07020896f, 0.12607303f, 0.18595718f, -0.12217705f, -0.12388406f, 0.09392546f, 
    0.01001777f, -0.04061321f, -0.04947131f, 0.10280806f, -0.06042139f, 0.25408074f, -0.01444386f, -0.06585749f, 
    0.03826053f, -0.03276785f, 0.03160736f, -0.05475634f, -0.07704914f, -0.15436000f, 0.03447952f, -0.20015118f, 
    0.07742838f, 0.03468652f, -0.16347601f, 0.05952960f, 0.07711886f, 0.02466363f, -0.18261567f, -0.51816267f, 
    -0.32507727f, -0.07256337f, 0.07903420f, -0.03023221f, -0.05142545f, 0.09107127f, 0.06042688f, -0.06076231f, 
    0.02782991f, -0.29868892f, -0.06433594f, -0.10670127f, 0.07519199f, 0.08820870f, 0.02743979f, -0.01257484f, 
    0.30811504f, 0.21530215f, -0.04799610f, 0.13798235f, -0.05022753f, -0.06420647f, 0.24586424f, -0.01986966f, 
    0.07787997f, 0.15213430f, 0.04715583f, -0.26474336f, -0.04649952f, -0.11754156f, 0.10390027f, -0.07309631f, 
    0.02588816f, -0.08816094f, -0.11410205f, -0.24039918f, 0.20064634f, -0.06163917f, -0.03803908f, -0.11765675f, 
    0.06086552f, 0.18206401f, -0.04058980f, -0.34459358f, -0.18566319f, -0.24390043f, 0.06357010f, -0.03086469f, 
    0.29025543f, -0.14187244f, 0.17068274f, 0.26114020f, -0.05878642f, 0.13429192f, -0.32071254f, -0.04707357f, 
    0.13148168f, 0.07391752f, -0.18306866f, -0.08569052f, -0.14748366f, -0.06616894f, -0.14286597f, -0.28978360f, 
    0.04675905f, 0.10708174f, 0.04299118f, 0.00858518f, 0.01846915f, 0.17992933f, -0.07607485f, -0.08522280f, 
    -0.27564061f, 0.10744825f, 0.01456771f, 0.05872626f, 0.24520168f, 0.09506120f, 0.05419226f, 0.28931829f, 
    -0.02739406f, -0.03760411f, -0.12016673f, 0.04459773f, 0.13374269f, -0.04105858f, 0.00818848f, -0.00868280f, 
    -0.10003367f, -0.25469285f, 0.08759329f, -0.19216059f, -0.04140020f, 0.14400767f, 0.00495512f, -0.08118113f, 
    0.00815001f, -0.20325457f, -0.09006000f, -0.00790227f, -0.20238566f, -0.00407629f, -0.02906132f, 0.05653306f, 
    -0.07811277f, -0.29154107f, -0.08762045f, -0.08809204f, 0.32077768f, 0.05851581f, -0.09656595f, -0.10768840f, 
    -0.03227748f, 0.03076055f, 0.12057611f, 0.10563537f, -0.26530662f, 0.07625757f, -0.04934706f, 0.00371474f, 
    0.12701394f, 0.04548700f, 0.02068065f, 0.08944624f, -0.20072183f, -0.06267457f, -0.20013565f, 0.20941085f, 
    0.01075994f, 0.06680631f, 0.02264478f, -0.03783722f, 0.10002203f, -0.30846775f, -0.05507991f, -0.13556287f, 
    0.07195778f, -0.04114925f, 0.00646171f, 0.06569960f, -0.00635530f, 0.15136777f, 0.34033602f, 0.06568459f, 
    -0.05187690f, 0.10920263f, 0.04832259f, 0.01876101f, 0.10091761f, 0.14467029f, -0.06536138f, 0.22797278f, 
    0.18095708f, 0.34456939f, 0.11294960f, 0.02974249f, -0.19159484f, 0.05871157f, 0.11424184f, -0.12693185f, 
    -0.17194559f, 0.06468831f, -0.02339375f, 0.02078609f, -0.01598990f, 0.01319825f, 0.00759917f, -0.11547690f, 
    -0.09607172f, 0.17781541f, 0.18375830f, 0.22914228f, -0.05627132f, 0.04265811f, 0.18190247f, -0.11460432f, 
    0.19394240f, -0.19090822f, 0.04652471f, 0.24026623f, 0.01337379f, 0.13043350f, -0.00507198f, 0.15519163f, 
    -0.24477497f, 0.09536351f, -0.20882984f, 0.18825416f, 0.15723677f, 0.21420352f, -0.01411898f, -0.02425951f, 
    -0.15496874f, -0.02046168f, 0.13404109f, 0.23364690f, -0.18757012f, 0.00548022f, -0.00458600f, 0.08393039f, 
    -0.06382296f, -0.09607858f, -0.01593861f, 0.02002256f, 0.20500550f, -0.10565497f, -0.09928374f, 0.04223464f, 
    -0.17615639f, -0.02603811f, -0.05561975f, -0.08959939f, -0.05094625f, 0.24039331f, 0.20206989f, 0.23659277f, 
    -0.05261368f, 0.12405995f, -0.12529811f, 0.12877148f, 0.06692909f, 0.14376387f, 0.07278796f, 0.04956210f, 
    -0.11608312f, 0.25020194f, 0.02081129f, -0.09921635f, 0.01751205f, -0.07904496f, -0.06358049f, -0.20158556f, 
    0.28395733f, 0.09192439f, 0.16815728f, 0.04664314f, 0.10114998f, -0.01362129f, 0.04643379f, 0.21119173f, 
    0.09112789f, 0.30125016f, 0.02603338f, -0.03812044f, 0.09748186f, 0.18145172f, -0.00965376f, 0.04270668f, 
    0.22963309f, -0.03505645f, 0.21372719f, 0.17794229f, 0.14742856f, 0.05705218f, -0.10654023f, 0.04039013f, 
    0.06095359f, 0.07952303f, -0.04049208f, -0.06754322f, -0.07753917f, -0.06526326f, 0.15497684f, -0.06222052f, 
    -0.05816093f, -0.12861490f, 0.10160523f, 0.09148239f, -0.16029070f, -0.07226547f, -0.01944172f, 0.12211271f, 
    -0.13696970f, -0.14075841f, 0.15413457f, 0.07030067f, 0.22944473f, -0.03181814f, -0.00780360f, 0.20048684f, 
    0.10798384f, 0.02494056f, 0.10699746f, -0.25248566f, 0.08301327f, 0.01812480f, -0.08482110f, 0.03027958f, 
    0.02741608f, -0.07040928f, 0.27166313f, -0.04359728f, -0.06380628f, 0.08582067f, -0.27519798f, -0.17217346f, 
    0.12386215f, 0.15776025f, 0.01410632f, 0.15192053f, -0.25097892f, -0.43247366f, 0.09079658f, -0.10513683f, 
    0.39562449f, -0.03820428f, 0.16467850f, 0.10495722f, 0.27790424f, -0.07683102f, 0.12063514f, -0.15194251f, 
    -0.05050793f, -0.30653015f, -0.18720329f, -0.01490427f, -0.01750865f, 0.07275812f, 0.02439142f, -0.16247348f, 
    0.14360075f, 0.26592943f, 0.03262496f, 0.30516890f, -0.15770052f, -0.06509244f, -0.01506621f, 0.12166353f, 
    -0.29268375f, 0.16710423f, -0.24561794f, 0.33928743f, 0.08855613f, 0.05937343f, -0.12187494f, 0.10538207f, 
    -0.06151525f, -0.11091869f, 0.05524305f, 0.03593531f, -0.14040324f, -0.09691972f, 0.01946094f, -0.17157185f, 
    -0.07427256f, 0.04962163f, -0.28104571f, 0.02999282f, -0.07606262f, -0.04705095f, -0.14295335f, 0.12580687f, 
    -0.01890991f, 0.10485695f, 0.16478798f, -0.19739430f, 0.01326543f, -0.21713185f, 0.21290098f, 0.12229154f, 
    0.15913904f, -0.08286535f, 0.12933412f, -0.09361412f, -0.04581906f, -0.00148407f, -0.16090541f, 0.17430255f, 
    -0.04220285f, 0.06585325f, -0.27591234f, -0.04577045f, -0.01020197f, -0.09203860f, 0.00011687f, 0.24477135f, 
    0.16246538f, 0.22555973f, 0.17192471f, -0.05855049f, 0.13843752f, -0.00686469f, -0.21727312f, -0.04583496f, 
    0.02986199f, 0.05156996f, -0.00949723f, 0.38423368f, -0.14576963f, -0.15496814f, -0.03294440f, 0.09972195f, 
    0.01993667f, 0.19842038f, 0.46708429f, -0.07425918f, -0.26769784f, -0.11452543f, 0.06297213f, -0.05745186f, 
    0.09610184f, 0.04862455f, 0.00225388f, 0.18237589f, 0.14084342f, 0.04202811f, -0.00879182f, 0.04765477f, 
    -0.01634332f, -0.17680702f, -0.01968121f, 0.02759849f, 0.28139472f, 0.12905228f, 0.38388738f, 0.07914205f, 
    -0.00616163f, 0.07504247f, -0.00258371f, 0.00890230f, -0.02980796f, 0.03388967f, 0.08736449f, 0.14674629f, 
    0.09022772f, 0.03505883f, -0.01593599f, 0.16242443f, 0.03123850f, 0.10489039f, 0.51373923f, 0.05183421f, 
    0.07840970f, 0.18221171f, 0.04670034f, 0.11597482f, 0.05674649f, -0.09069271f, -0.02631447f, -0.35231748f, 
    -0.01636762f, -0.09767649f, 0.13633332f, 0.11920244f, -0.05498786f, -0.06831601f, -0.14275275f, -0.14441600f, 
    -0.27539006f, 0.00408688f, 0.10306118f, -0.04452630f, -0.01345171f, 0.03544532f, 0.09553722f, -0.02767207f, 
    -0.19760723f, 0.04728621f, -0.06653396f, 0.01461554f, 0.13552353f, -0.00488582f, -0.01136290f, -0.05987960f, 
    0.08837954f, -0.11676221f, -0.24631779f, -0.09347299f, -0.11674641f, 0.10376146f, -0.01397972f, -0.19973364f, 
    0.04896754f, 0.15408349f, -0.16857824f, -0.41404828f, -0.14635435f, -0.06780110f, -0.02615006f, 0.12480128f, 
    0.00537036f, 0.02149543f, -0.01042073f, -0.07389470f, 0.15187591f, 0.12361448f, -0.20251961f, -0.04443884f, 
    0.05455315f, -0.05619291f, 0.10263210f, 0.03840572f, 0.04816102f, 0.01638783f, 0.04821951f, 0.15817647f, 
    -0.09661083f, 0.15715724f, 0.03255796f, -0.04522474f, 0.03625145f, -0.10615124f, -0.33309698f, -0.09379724f, 
    0.08609281f, -0.07886016f, -0.03691155f, -0.05593475f, 0.06212711f, -0.07668140f, 0.01383418f, -0.04532875f, 
    -0.17690670f, 0.03252588f, -0.22014728f, -0.02470616f, -0.18852343f, 0.01898758f, -0.12522553f, 0.06541362f, 
    -0.26200861f, 0.00955130f, -0.50836444f, 0.15953225f, 0.10422835f, -0.00932086f, 0.20017365f, 0.07714019f, 
    0.04082411f, 0.36572006f, -0.04659381f, -0.05757247f, 0.19567449f, 0.10931719f, -0.05290913f, 0.16422626f, 
    -0.04761551f, 0.05468394f, -0.41617879f, -0.09018638f, 0.21206136f, 0.04396496f, 0.04287797f, -0.08740582f, 
    -0.17745528f, -0.06161959f, 0.04706380f, 0.12017962f, -0.16050127f, 0.23540851f, -0.01594499f, -0.02218105f, 
    0.06780712f, -0.00025242f, 0.05143739f, 0.03126733f, -0.22160439f, 0.05136677f, -0.20757115f, -0.01534006f, 
    0.08895883f, 0.15326269f, -0.00490053f, -0.14234120f, -0.17527476f, 0.07980833f, -0.08203131f, -0.06631394f, 
    -0.30263343f, 0.02704474f, -0.10912394f, 0.01233762f, 0.11506804f, 0.16126527f, -0.13494530f, 0.00397145f, 
    -0.04784734f, -0.07253709f, -0.04333933f, -0.23166092f, 0.00733393f, 0.17432742f, 0.03179798f, 0.24593452f, 
    -0.37546670f, -0.11718857f, 0.02308537f, -0.06788577f, -0.13383961f, -0.15049870f, -0.02407852f, 0.05270616f, 
    0.21720208f, 0.43889353f, -0.61890465f, 0.14817275f, 0.10548008f, 0.10353269f, 0.04642763f, -0.24183677f, 
    0.01468947f, -0.26455775f, -0.08868054f, 0.05322605f, -0.02394906f, 0.05250581f, 0.06187411f, 0.13687353f, 
    -0.08959129f, 0.07219247f, -0.14394496f, -0.15963361f, 0.09618764f, -0.05022727f, 0.14540823f, -0.03894708f, 
    -0.07953370f, 0.08330465f, 0.13647385f, 0.02895900f, 0.08802725f, -0.01798929f, -0.03076638f, 0.03694495f, 
    -0.05397420f, 0.03805945f, 0.08275454f, 0.09767345f, 0.01256815f, -0.10772762f, 0.17102028f, -0.05331615f, 
    0.07644986f, -0.11411269f, 0.13208675f, 0.22606917f, 0.10712849f, -0.00047226f, 0.14917868f, 0.20746681f, 
    -0.13672318f, -0.00538119f, -0.04715301f, 0.18357795f, 0.00058843f, -0.09554094f, -0.14419672f, -0.02174686f, 
    -0.20237009f, -0.03844194f, 0.07940783f, -0.03242061f, 0.07810935f, 0.05011925f, 0.07639313f, -0.34194666f, 
    -0.24882096f, 0.03177726f, -0.08497110f, 0.05521241f, -0.09485491f, 0.14783186f, 0.06756267f, 0.08654825f, 
    0.23801421f, 0.15827259f, 0.21550325f, -0.12998259f, 0.12520429f, 0.10043921f, 0.03892102f, -0.06314328f, 
    0.16289969f, -0.38039866f, -0.36525282f, -0.16969442f, 0.10882334f, 0.19199102f, -0.14718550f, 0.02104991f, 
    -0.16193494f, 0.03285870f, -0.58115840f, -0.16565317f, -0.04598338f, 0.11065062f, 0.04364596f, 0.06649730f, 
    -0.14171189f, -0.10916360f, 0.04930742f, 0.11574776f, 0.18104011f, 0.15070918f, -0.12551135f, 0.13919494f, 
    -0.11479595f, 0.08160114f, -0.10111239f, 0.06183336f, -0.21383990f, 0.11665288f, -0.05521844f, 0.00909561f, 
    0.02099979f, 0.02121239f, -0.01939477f, -0.06045457f, 0.05828267f, 0.28087837f, 0.09911151f, 0.19784874f, 
    0.01627443f, 0.27813852f, -0.00428948f, 0.05898625f, 0.02301263f, 0.01794977f, -0.76214641f, 0.04559292f, 
    0.11962212f, -0.00199865f, -0.09612282f, -0.04513885f, 0.09599515f, 0.01722218f, -0.08933587f, -0.19909854f, 
    -0.04259463f, -0.10104222f, 0.07331546f, 0.00894758f, 0.19085218f, 0.11053159f, -0.04029379f, -0.16580801f, 
    0.07667121f, 0.07801044f, 0.25409448f, 0.15420502f, -0.06855721f, 0.12935017f, 0.12546310f, -0.01469106f, 
    0.09117357f, -0.25144672f, -0.10360938f, -0.25909832f, -0.07476066f, -0.06488282f, -0.08687145f, -0.04198181f, 
    0.02556475f, -0.00884867f, -0.04785166f, 0.12400157f, -0.26214948f, 0.02887811f, 0.07162268f, 0.04142078f, 
    -0.03736178f, 0.09923837f, -0.00350531f, -0.03582182f, -0.00019544f, -0.38316980f, 0.07496653f, -0.04627394f, 
    -0.06916539f, 0.04690993f, 0.09781402f, 0.05470895f, 0.01322802f, 0.07268292f, 0.14546530f, 0.06613901f, 
    -0.04140711f, 0.00255985f, -0.04154351f, 0.00211510f, 0.25159991f, 0.09544910f, 0.18522058f, 0.28330803f, 
    0.18254548f, 0.14625125f, -0.09182700f, 0.18005580f, 0.06885011f, 0.14401504f, -0.00611204f, -0.00679867f, 
    -0.31089222f, 0.16435839f, -0.13734813f, 0.10711095f, 0.01630023f, -0.05307280f, -0.02768777f, -0.06966660f, 
    0.10805123f, -0.41393420f, -0.06203154f, -0.11273896f, 0.05023655f, -0.15187715f, -0.11416141f, 0.14721942f, 
    -0.33664635f, -0.27100563f, 0.01639531f, 0.13679621f, 0.13345291f, -0.02145042f, -0.06846441f, -0.09938625f, 
    0.10752394f, -0.32043737f, 0.06486362f, -0.52258849f, -0.05507764f, 0.10228532f, -0.17007776f, 0.06784426f, 
    0.07509405f, -0.11018544f, 0.08092444f, -0.13462712f, -0.28628087f, 0.23783858f, 0.03303627f, -0.02443916f, 
    -0.12976249f, -0.03431918f, -0.03394112f, -0.01358010f, 0.00537667f, -0.10165969f, 0.10416058f, 0.03381846f, 
    0.02097662f, 0.03466104f, -0.20787352f, 0.05897661f, 0.22327454f, -0.01943471f, 0.19278499f, -0.00002180f, 
    -0.06632835f, -0.14288671f, 0.07792895f, -0.08278920f, -0.16840559f, -0.00396646f, 0.21358730f, -0.00454999f, 
    -0.11490169f, 0.15549482f, -0.06227329f, 0.15280271f, -0.04305706f, -0.00318500f, -0.08976178f, 0.01471795f, 
    -0.15314576f, 0.08094347f, 0.19190314f, -0.12027401f, 0.09446725f, 0.08586057f, 0.20895696f, -0.44905952f, 
    0.00729440f, -0.45339146f, -0.10899165f, 0.19096291f, 0.00150783f, -0.17250943f, 0.01806531f, 0.15411597f, 
    -0.15767258f, -0.08571893f, -0.35220924f, 0.05283161f, 0.04496365f, 0.00752009f, -0.05363500f, 0.04506744f, 
    -0.03195005f, 0.05526129f, 0.32262859f, 0.24116397f, -0.01125328f, 0.15643334f, 0.19976602f, -0.22868530f, 
    0.15843266f, 0.03726530f, -0.19203237f, -0.35069433f, -0.18268996f, -0.12445597f, 0.04650507f, -0.01089047f, 
    -0.09902783f, 0.05079285f, 0.13495998f, 0.15768208f, 0.06051145f, -0.32740617f, -0.09155779f, 0.01954655f, 
    -0.05630256f, 0.15970469f, 0.16341880f, 0.06753729f, 0.09514140f, 0.25102630f, 0.10378828f, -0.03937968f, 
    0.14888471f, 0.03883038f, 0.21580136f, 0.19313544f, -0.00742853f, -0.09637011f, 0.11594585f, 0.08799534f, 
    0.04068167f, -0.04101316f, -0.03088323f, 0.06610274f, -0.10224345f, 0.14919080f, -0.16879177f, 0.27711606f, 
    -0.19786976f, 0.02023140f, 0.16253176f, 0.09240121f, -0.02287953f, 0.02509442f, -0.11003573f, -0.15093873f, 
    -0.07611174f, 0.24002978f, -0.04802455f, -0.04559062f, 0.14085360f, -0.22683866f, -0.12410635f, 0.02334446f, 
    0.04526322f, -0.05832533f, -0.04958170f, 0.03722232f, 0.00252215f, 0.00427438f, 0.02216159f, -0.05963170f, 
    -0.02161926f, -0.02226126f, -0.01485953f, -0.02441366f, -0.00286595f, 0.04934744f, -0.01597783f, -0.02733819f, 
    -0.05460777f, 0.03829340f, -0.03139071f, -0.03658478f, 0.01352040f, 0.02018173f, 0.01022794f, -0.04745628f, 
    0.02606289f, -0.04962195f, 0.02305598f, -0.02634047f, -0.02639213f, 0.03409212f, 0.03937758f, 0.01806173f, 
    -0.06145918f, 0.02164659f, 0.04462204f, -0.04682856f, -0.06789052f, -0.02348382f, -0.00793328f, -0.06258523f, 
    -0.03888854f, 0.00616141f, -0.05556586f, -0.02431091f, 0.03970742f, -0.05460099f, -0.04475716f, 0.04104176f, 
    0.03440449f, 0.02643171f, -0.05806461f, -0.00517767f, -0.03006701f, 0.02496023f, -0.02251510f, -0.04628575f, 
    -0.06291600f, -0.02614341f, -0.00885494f, -0.01918712f, 0.04664667f, -0.05290461f, 0.00616206f, -0.05906599f, 
    0.00940235f, 0.02378224f, 0.04899918f, 0.05068646f, -0.00605259f, -0.03691550f, -0.04381767f, -0.05812372f, 
    0.03938942f, 0.01264358f, -0.06307065f, 0.01179620f, -0.03591511f, 0.04069899f, -0.01421562f, -0.04887260f, 
    0.03037723f, -0.02612954f, -0.03271982f, -0.03932698f, 0.00308017f, 0.02134501f, 0.00242525f, -0.02750947f, 
    0.00552189f, -0.03634031f, -0.06082567f, 0.03082738f, 0.01817847f, 0.04441619f, -0.06389190f, -0.02044025f, 
    -0.01578935f, -0.01319685f, -0.00463019f, -0.06319652f, 0.04855613f, 0.02695856f, -0.05378603f, -0.01549130f, 
    0.01399286f, -0.01441758f, -0.04353870f, -0.03202701f, 0.03453402f, -0.03396986f, 0.03115274f, 0.01706677f, 
    -0.02987263f, -0.03815480f, -0.02275804f, 0.03694726f, -0.05869742f, 0.05219651f, 0.01266024f, 0.03707705f, 
    -0.03629309f, -0.03282231f, -0.04591366f, -0.04885641f, 0.01525984f, -0.00466153f, 0.04519938f, 0.04091753f, 
    0.03974317f, -0.02592683f, -0.05295860f, -0.00270258f, -0.06027089f, -0.02205749f, -0.03528437f, 0.02185544f, 
    -0.01655095f, 0.03689534f, -0.00817726f, 0.02120638f, -0.00091339f, -0.03371643f, -0.03025881f, 0.04005561f, 
    -0.05678768f, -0.02231339f, -0.05891807f, 0.01149813f, -0.02432423f, -0.01081093f, 0.01995926f, -0.04361789f, 
    0.03067164f, 0.02366397f, -0.04120214f, 0.00352922f, 0.00655340f, 0.03205983f, -0.00540703f, -0.02287895f, 
    -0.05498003f, 0.04934837f, 0.04283883f, 0.00332875f, -0.02017951f, 0.03520022f, 0.05125165f, -0.00060288f, 
    -0.06189990f, 0.00240470f, 0.00498853f, 0.03087339f, 0.02207808f, -0.02065429f, -0.00653573f, -0.05114930f, 
    -0.05248431f, -0.05813377f, -0.06013402f, 0.00887086f, -0.06201347f, -0.01791972f, -0.00574664f, 0.03964398f, 
    0.05027642f, 0.04650456f, 0.01851767f, 0.02379344f, -0.03815074f, -0.03364214f, -0.03971536f, -0.06167775f, 
    -0.01886646f, 0.04068576f, -0.03302868f, 0.03072219f, -0.00475898f, 0.01606901f, 0.00504044f, -0.02770019f, 
    -0.02142760f, 0.03333758f, -0.01780132f, 0.04815786f, 0.02128417f, -0.06335152f, -0.03143879f, -0.06853047f, 
    -0.01058626f, 0.04088673f, 0.04391624f, -0.03746133f, 0.00757173f, 0.03368824f, 0.02690819f, 0.00290008f, 
    0.01015463f, 0.03251045f, 0.03520313f, -0.00773335f, -0.02397249f, 0.01572579f, 0.02615643f, 0.02137819f, 
    -0.05310195f, 0.01764157f, 0.04140378f, -0.04788689f, 0.00191304f, 0.01427061f, -0.03188226f, -0.01081784f, 
    0.04142552f, -0.00709916f, -0.06701918f, 0.01504457f, -0.01053299f, -0.03405212f, -0.04090942f, -0.01521836f, 
    -0.03987930f, 0.01237127f, 0.03146176f, -0.05525012f, -0.00850380f, 0.03806064f, -0.05639124f, 0.04267779f, 
    0.00009834f, -0.01639619f, -0.02132300f, -0.02881358f, -0.04355455f, -0.02650916f, -0.05049422f, -0.00424645f, 
    0.01584994f, 0.03021604f, -0.06155909f, 0.01120077f, 0.05074208f, 0.04129029f, 0.00920710f, -0.01165345f, 
    0.01183724f, -0.02905778f, -0.03744711f, 0.05026756f, -0.05433822f, 0.00951577f, -0.03922547f, -0.01185136f, 
    -0.05097128f, 0.00341426f, 0.04775606f, 0.01015758f, -0.02388632f, -0.05015524f, -0.05447850f, 0.01406982f, 
    -0.04994424f, 0.03895978f, -0.04275085f, -0.02577768f, 0.00706243f, 0.03053067f, -0.01409146f, -0.06565869f, 
    -0.14389171f, -0.01457603f, -0.19072476f, 0.15815216f, 0.01763355f, -0.09232178f, -0.02572950f, -0.10238302f, 
    0.02184668f, -0.14003922f, -0.00779244f, 0.00886502f, 0.03514799f, 0.05883890f, -0.14597756f, 0.18544316f, 
    -0.03821499f, -0.25259721f, -0.05691261f, 0.38425380f, 0.11069434f, -0.05486082f, -0.05742563f, -0.15615703f, 
    0.03960002f, 0.05846925f, 0.02801728f, 0.01279694f, 0.09798656f, -0.16621888f, 0.21773715f, 0.04784990f, 
    0.02706081f, 0.14980492f, 0.01897862f, 0.01814636f, 0.29750013f, 0.03477741f, -0.29706120f, -0.03016641f, 
    -0.05253732f, 0.19552428f, -0.06409734f, 0.11186444f, 0.08987349f, 0.15138900f, 0.01328641f, -0.06454840f, 
    0.17461872f, -0.10990655f, -0.03363675f, -0.04565946f, 0.11876840f, -0.02164478f, 0.21432523f, 0.22057453f, 
    0.09873115f, -0.17657585f, -0.05889885f, 0.17605074f, -0.02536578f, -0.00754764f, 0.13552181f, -0.00245952f, 
    -0.10045806f, -0.12648252f, -0.11499398f, 0.03864699f, 0.03276521f, 0.04026189f, 0.03872411f, 0.02943364f, 
    -0.21443966f, 0.00606903f, -0.34329242f, 0.10196549f, -0.03741363f, -0.27158037f, 0.08519471f, -0.07590138f, 
    0.00734286f, -0.15659642f, -0.14467843f, 0.05198038f, -0.11631915f, -0.06728532f, 0.03773568f, 0.00586419f, 
    -0.04109527f, 0.06462519f, -0.08972112f, 0.12927921f, -0.12959248f, -0.04900850f, 0.01305678f, 0.07526492f, 
    -0.06718904f, -0.10869362f, -0.05168726f, 0.03754049f, -0.03083298f, 0.18442188f, 0.02308083f, 0.13411316f, 
    0.04067524f, -0.05494595f, 0.07469053f, 0.13557425f, 0.03441982f, 0.10053494f, 0.17601743f, 0.03385690f, 
    -0.04413869f, 0.14404717f, 0.05068069f, -0.09275477f, 0.30227908f, -0.32845914f, -0.07247351f, -0.10920282f, 
    0.28693196f, 0.03285438f, -0.14692451f, -0.15598689f, -0.03288355f, 0.07097811f, 0.01522654f, -0.13758640f, 
    0.15113702f, 0.21164784f, 0.15005733f, -0.02025911f, -0.00545897f, 0.12987012f, -0.00647782f, 0.11030844f, 
    0.34721804f, -0.09381095f, 0.00221268f, -0.03748538f, 0.04863546f, 0.13292047f, 0.07934998f, -0.03966465f, 
    0.08408883f, 0.12808284f, 0.28757244f, -0.15895775f, 0.12053464f, 0.10173006f, -0.14853878f, 0.05238086f, 
    0.11096022f, -0.16304646f, 0.20240691f, 0.34278813f, 0.08441343f, 0.02463079f, 0.07251440f, -0.12220767f, 
    0.01939174f, -0.16032895f, 0.15352163f, -0.03689030f, 0.00463356f, 0.12762228f, -0.01227110f, -0.15622541f, 
    0.02225523f, 0.08874100f, 0.01802193f, 0.06268662f, 0.05746182f, 0.00229122f, -0.10904107f, 0.11331648f, 
    0.08370028f, 0.16960999f, -0.05636432f, 0.12185597f, 0.19718195f, 0.09070498f, 0.05796488f, 0.13062117f, 
    0.07333306f, -0.13976271f, 0.15815835f, -0.03074715f, 0.02462504f, 0.00241722f, 0.03853896f, -0.09902013f, 
    -0.04692135f, 0.00507956f, 0.09844246f, -0.00406099f, 0.15271781f, -0.11095376f, -0.09905598f, -0.33010146f, 
    -0.15908790f, 0.00086785f, 0.11181065f, -0.23236951f, 0.08217679f, -0.13061586f, 0.18818539f, -0.29393306f, 
    -0.06217659f, -0.11536456f, 0.15157613f, -0.03404500f, -0.05653650f, 0.17754047f, -0.05905484f, 0.02152813f, 
    0.25142658f, 0.21394248f, 0.08416073f, -0.04547755f, 0.08604416f, 0.05328654f, -0.16044421f, -0.00732183f, 
    0.06953076f, -0.25169754f, -0.15886988f, -0.25830990f, 0.21350481f, -0.04621912f, -0.12882408f, 0.09863129f, 
    0.04334985f, -0.03964682f, -0.39977324f, -0.02473422f, 0.06043102f, 0.12261079f, -0.03801508f, -0.03736096f, 
    0.19512907f, -0.13696736f, 0.22624971f, 0.17519541f, -0.07284711f, -0.30108035f, -0.11727952f, -0.02688807f, 
    -0.04926581f, -0.06426107f, 0.06704769f, 0.16935283f, -0.37225577f, -0.27953508f, -0.06526493f, 0.06256215f, 
    -0.02378915f, 0.09216481f, -0.06015714f, -0.08928111f, 0.01422909f, 0.19052939f, -0.11802937f, -0.08202420f, 
    0.07182308f, -0.03032498f, -0.02970420f, -0.03657361f, 0.10123507f, -0.28870901f, -0.06894669f, -0.14305106f, 
    -0.10215592f, 0.11507834f, 0.06526543f, -0.00670271f, 0.25080070f, -0.04666897f, -0.11006115f, 0.02947908f, 
    -0.02746736f, -0.22772989f, 0.09409457f, -0.04878813f, -0.02538260f, -0.08134198f, -0.05073667f, 0.03222045f, 
    0.00033023f, 0.02326859f, 0.03024685f, -0.02944603f, -0.05387734f, -0.04166989f, 0.04920232f, 0.03338128f, 
    -0.04200406f, -0.04082162f, 0.01559029f, -0.01660546f, 0.02024498f, 0.05449193f, 0.00238991f, 0.03915238f, 
    -0.06465908f, 0.02151287f, -0.00475529f, 0.02654755f, -0.04271495f, -0.05684860f, -0.02452372f, -0.01602455f, 
    -0.03862538f, -0.03708386f, 0.00713923f, -0.02661919f, -0.01224035f, 0.02501770f, 0.03030231f, 0.02927596f, 
    -0.01388983f, -0.05766511f, 0.01929564f, -0.00945160f, -0.05606977f, 0.03899387f, -0.05147818f, -0.01888252f, 
    -0.04830292f, -0.01266463f, -0.05450546f, -0.04933496f, -0.00515073f, 0.01142607f, 0.03778741f, 0.01028007f, 
    0.04385814f, -0.02390642f, -0.05768144f, -0.05052387f, 0.00324411f, -0.01742657f, -0.03026899f, -0.05199176f, 
    -0.02556614f, -0.00163776f, 0.01598957f, 0.03989501f, 0.00786927f, -0.02904859f, -0.03863123f, -0.06077828f, 
    -0.05702732f, -0.02810924f, 0.01585745f, -0.00166392f, -0.01146826f, 0.00790994f, -0.03977757f, -0.00319989f, 
    -0.03936432f, -0.04930758f, -0.04345016f, 0.01442676f, 0.03501852f, -0.02880469f, -0.01067059f, 0.01035749f, 
    -0.03527356f, 0.00654076f, -0.01237690f, -0.05791475f, 0.05196818f, -0.03038631f, -0.01647786f, -0.03413010f, 
    -0.01899061f, 0.00908889f, -0.02714672f, -0.01993625f, -0.03471173f, -0.01783223f, -0.01928431f, -0.00854963f, 
    -0.05578260f, 0.00625605f, -0.02341237f, -0.04908443f, -0.06414582f, 0.00162137f, -0.03246034f, 0.04060812f, 
    0.01993444f, -0.00986014f, 0.01902828f, -0.00632564f, -0.00648989f, -0.00726643f, -0.01295607f, -0.01584749f, 
    0.03088116f, -0.00878484f, -0.02704136f, 0.05013230f, 0.04387910f, 0.01560869f, -0.04074178f, -0.02602337f, 
    -0.00339754f, -0.00767784f, -0.04609225f, 0.02249967f, -0.02630533f, -0.02959248f, -0.04888882f, 0.00078214f, 
    0.00286375f, 0.03981466f, -0.04131624f, -0.04871083f, 0.04023452f, -0.01694000f, -0.03807892f, -0.01896007f, 
    -0.02031239f, 0.02775406f, 0.01897193f, -0.01466131f, 0.01939350f, -0.04328244f, -0.02842835f, -0.00029897f, 
    0.05167099f, 0.02476614f, 0.02341057f, -0.04280352f, 0.00982206f, 0.01146628f, 0.02523282f, 0.03445189f, 
    -0.02958074f, -0.02867412f, 0.04955240f, -0.02786254f, -0.02833845f, -0.02377317f, -0.02414081f, -0.00896687f, 
    -0.03321290f, -0.04207386f, -0.00931345f, 0.04343039f, -0.03171195f, -0.06024361f, -0.01834368f, 0.04395697f, 
    -0.02334086f, -0.05687217f, -0.04156833f, 0.00429483f, 0.03231206f, -0.05160821f, 0.03734241f, -0.03340838f, 
    0.00262197f, 0.01094237f, -0.04900808f, 0.03913587f, -0.05538381f, -0.01297661f, -0.02069425f, 0.01943860f, 
    -0.00478820f, 0.04855332f, -0.00988901f, 0.01034116f, -0.01317306f, -0.04826907f, -0.03427883f, -0.00282371f, 
    0.00417985f, -0.02134755f, -0.01441520f, -0.04799561f, -0.01425066f, 0.05131846f, 0.00908450f, 0.02160401f, 
    -0.06276439f, 0.01086657f, 0.03561004f, -0.00828674f, 0.00304557f, -0.03337601f, 0.03918117f, 0.02915383f, 
    0.03933233f, 0.00500957f, -0.02503598f, 0.02161106f, 0.03399276f, -0.02359381f, 0.03693649f, 0.04501477f, 
    -0.05573135f, -0.04131401f, -0.05762275f, -0.04459659f, -0.02764338f, -0.01615670f, 0.01982324f, -0.04223450f, 
    0.00781292f, 0.02016249f, -0.00193962f, -0.02090433f, -0.00317647f, 0.03534584f, -0.05958232f, -0.02091208f, 
    0.02920336f, -0.05348013f, 0.05013725f, -0.00187548f, 0.00869434f, 0.04785882f, -0.02871167f, 0.03828257f, 
    0.04159920f, 0.05182010f, -0.04260400f, -0.04138773f, -0.03559955f, -0.02310780f, -0.03047657f, -0.00326369f, 
    0.02704106f, 0.04661794f, 0.02756030f, -0.02156827f, 0.00907567f, 0.02680559f, -0.01660322f, -0.05248448f, 
    -0.02991243f, 0.05086987f, -0.01957285f, -0.02008312f, -0.04567329f, 0.02293413f, 0.05135908f, 0.04353735f, 
    -0.00363176f, -0.06365918f, 0.03232254f, 0.01943782f, 0.03742595f, -0.02545027f, -0.00165764f, -0.04963018f, 
    -0.03691045f, -0.00111086f, -0.01497189f, 0.02195431f, 0.04208416f, 0.05226629f, 0.05151903f, 0.04828667f, 
    -0.04945601f, -0.01409963f, -0.03673064f, -0.00940448f, -0.05953586f, -0.04138362f, -0.01541354f, -0.05996144f, 
    -0.17036022f, 0.16619611f, 0.28916168f, -0.07731284f, -0.17224191f, -0.08671211f, -0.14619894f, 0.02066874f, 
    0.09019354f, -0.51102060f, -0.12197751f, -0.21230561f, -0.18240757f, 0.15840177f, -0.07951055f, 0.01578383f, 
    0.01684914f, -0.08733015f, -0.45828947f, -0.37339354f, -0.02986731f, 0.11922032f, 0.33029333f, -0.30507728f, 
    0.08339110f, -0.10931725f, 0.03370649f, -0.23872851f, 0.06667072f, 0.21295619f, -0.05766321f, -0.06579442f, 
    -0.04983058f, -0.11566865f, 0.01509611f, 0.07597650f, 0.46084145f, -0.00495140f, -0.05794213f, 0.05147523f, 
    -0.10906711f, 0.02251758f, 0.24347124f, 0.00859009f, 0.06885740f, 0.18083754f, 0.06259243f, -0.16528668f, 
    0.04991791f, -0.16934118f, -0.11190974f, 0.13110952f, 0.25296840f, 0.12838335f, -0.17700294f, 0.22712442f, 
    -0.22365378f, 0.01808871f, 0.02214263f, 0.11186259f, 0.03838788f, 0.15720643f, 0.06796163f, -0.24827908f, 
    0.03693985f, 0.18255232f, 0.30515823f, 0.23130816f, 0.05581547f, -0.03566750f, -0.13255259f, -0.14688949f, 
    -0.12590709f, 0.19779587f, 0.17297415f, 0.09502237f, 0.10595217f, -0.01225722f, -0.00445778f, 0.11779571f, 
    -0.10560345f, -0.43788946f, 0.00159542f, 0.06476710f, 0.19395317f, -0.01608990f, 0.17576952f, 0.08939108f, 
    0.17156677f, -0.09571133f, -0.17853254f, 0.00315979f, -0.00418266f, -0.16633059f, 0.05413101f, 0.11635444f, 
    0.22150783f, 0.13564605f, -0.03109928f, -0.25263390f, -0.09212977f, 0.19749099f, 0.21478599f, 0.04359835f, 
    -0.01067512f, 0.12686925f, 0.07690353f, 0.10582600f, 0.08909064f, -0.05561347f, -0.28361586f, 0.10849174f, 
    0.02011234f, -0.14249212f, 0.16366464f, 0.16480690f, 0.18027377f, 0.03854429f, 0.26502326f, 0.30888975f, 
    0.20058827f, -0.03190361f, -0.26973623f, 0.05825095f, 0.08505719f, 0.10558911f, -0.03263073f, -0.33976048f, 
    0.11341402f, 0.15110821f, 0.10146652f, 0.18735239f, 0.15427238f, 0.02033990f, -0.06499216f, -0.41174379f, 
    -0.23724607f, 0.17901653f, -0.17221040f, 0.08266961f, 0.10104424f, 0.02541265f, -0.04992570f, -0.07362936f, 
    -0.26368636f, -0.04068562f, -0.07531419f, 0.17122835f, 0.32558459f, 0.02016926f, 0.07222193f, -0.04058377f, 
    -0.11133883f, -0.40160167f, 0.21553721f, 0.25043455f, 0.08920345f, -0.06608004f, 0.11090568f, 0.15988040f, 
    -0.09260571f, -0.09957849f, -0.17740677f, -0.05370887f, 0.20233479f, 0.36716667f, 0.04634704f, 0.09449799f, 
    0.17711696f, 0.08259989f, -0.03574538f, 0.07830972f, -0.17401093f, -0.30695355f, -0.11794484f, 0.30920175f, 
    -0.02588161f, 0.12076110f, 0.04474148f, 0.03122177f, 0.12305830f, -0.06992324f, -0.32432577f, -0.00189174f, 
    0.04476170f, -0.00892827f, 0.09230555f, -0.08409522f, 0.01762918f, -0.23938458f, 0.16391033f, 0.26626280f, 
    -0.02715934f, -0.04739671f, -0.00693638f, -0.15579866f, 0.14108075f, 0.12677309f, -0.29411450f, -0.01200769f, 
    -0.11480305f, 0.04129696f, 0.07549085f, 0.07897945f, 0.07867534f, 0.00686855f, 0.03051151f, -0.26166973f, 
    -0.41690394f, -0.06725444f, 0.10852492f, 0.20920737f, -0.24121985f, -0.10234024f, -0.03854117f, -0.08546095f, 
    0.13762213f, 0.18270564f, -0.16784500f, 0.01195789f, -0.00226078f, 0.01340841f, 0.15715377f, -0.09770123f, 
    0.08714212f, -0.26666659f, 0.39878854f, 0.22859612f, 0.19463743f, -0.12489074f, 0.17668326f, -0.19230361f, 
    -0.05969387f, -0.05900778f, -0.15569453f, -0.16636285f, 0.18177743f, -0.01527370f, -0.10059608f, -0.00159465f, 
    -0.16830386f, 0.03578760f, -0.14649305f, -0.04851705f, 0.28442609f, -0.03802579f, 0.06885188f, -0.05161120f, 
    -0.13394904f, 0.24733110f, 0.00192728f, -0.08318190f, 0.03704770f, 0.28506005f, 0.16436882f, 0.09619825f, 
    0.10065155f, -0.09333883f, 0.07573830f, 0.13196203f, 0.07629770f, 0.07943300f, 0.20550726f, 0.33950403f, 
    0.07807902f, 0.11176673f, -0.03591976f, 0.09671302f, 0.06549651f, 0.04884708f, -0.13144445f, -0.00251647f, 
    0.20700829f, 0.11658152f, 0.13754304f, 0.05411765f, -0.09385026f, -0.05774511f, -0.12054811f, -0.08708951f, 
    -0.19156173f, -0.14322472f, -0.07604529f, 0.00756910f, 0.11631917f, -0.18457066f, 0.15598743f, -0.05666324f, 
    0.07835382f, 0.25184241f, 0.23666562f, 0.10234154f, 0.05674703f, -0.15348330f, 0.05194119f, 0.00422405f, 
    -0.15246285f, 0.35145864f, -0.21716848f, -0.07101943f, -0.08045815f, -0.08675539f, 0.09901407f, -0.12202219f, 
    -0.06191001f, -0.07147986f, -0.07846625f, 0.27846998f, -0.20023878f, -0.09251379f, 0.08244644f, 0.20188485f, 
    -0.14195594f, 0.04165694f, -0.03531682f, -0.31086746f, 0.34699699f, 0.07805924f, 0.12192248f, 0.14817004f, 
    -0.05835368f, -0.31820679f, 0.04361430f, -0.12634188f, 0.55892557f, -0.03756329f, 0.05498109f, -0.10177009f, 
    0.05736168f, 0.21052280f, -0.07200447f, 0.04485891f, -0.29698217f, -0.44257703f, -0.08144726f, 0.26054007f, 
    0.10724921f, 0.00170841f, 0.10176649f, 0.12474435f, 0.11470120f, 0.04109244f, 0.54603934f, -0.04209718f, 
    0.17987821f, -0.09098815f, -0.13067381f, -0.11342422f, -0.05254044f, -0.09079471f, -0.15354101f, 0.32784560f, 
    -0.21335688f, -0.03540929f, 0.05452880f, -0.07975205f, -0.10624576f, -0.04932979f, 0.00230737f, 0.14094137f, 
    0.20842403f, 0.24891917f, -0.08273260f, -0.13372885f, 0.32670790f, -0.06189500f, -0.07776910f, 0.04790330f, 
    0.00440321f, 0.15293132f, -0.26626953f, -0.15864211f, 0.13171820f, -0.06569635f, -0.00475884f, 0.13939674f, 
    0.10545436f, 0.11528485f, 0.10796700f, -0.13495781f, -0.22960509f, 0.08623401f, -0.00361712f, -0.04947971f, 
    -0.09062394f, 0.08693858f, 0.20339394f, 0.23820746f, -0.17023405f, 0.14579092f, -0.16877770f, -0.00213543f, 
    0.01518064f, -0.06716829f, -0.10071173f, 0.00545552f, -0.15105003f, -0.05515936f, 0.04589922f, 0.05695736f, 
    0.15614176f, 0.07523855f, -0.07381310f, 0.16916589f, -0.24537791f, -0.10108895f, 0.13779752f, 0.19801164f, 
    -0.03508543f, 0.02561682f, 0.08951887f, 0.17479058f, 0.05088470f, 0.03861659f, 0.16866799f, -0.15957628f, 
    0.16131735f, -0.03612752f, 0.21688126f, -0.01971101f, -0.16585118f, 0.02304502f, 0.07291619f, 0.20363164f, 
    0.25164506f, -0.02419515f, 0.19563712f, 0.23899443f, -0.04968794f, -0.05902822f, -0.06317541f, -0.01200831f, 
    0.24934904f, 0.07771220f, 0.08790307f, -0.25809330f, -0.00722229f, 0.04636730f, 0.01725406f, -0.14672710f, 
    0.00332389f, -0.17446254f, -0.23703380f, 0.12846158f, 0.03104499f, -0.06174972f, 0.17185089f, 0.05565821f, 
    -0.19394438f, 0.19427384f, 0.22992426f, -0.16352405f, 0.09842008f, 0.01548919f, -0.00502020f, 0.06258309f, 
    0.01190087f, -0.21898426f, 0.02572779f, 0.52175987f, 0.12000454f, -0.19524133f, -0.22067535f, 0.19138759f, 
    0.08364666f, -0.13322546f, 0.05372254f, -0.18315187f, 0.02299121f, 0.09834892f, -0.16444786f, -0.23377039f, 
    0.29593217f, 0.03822492f, -0.23975043f, -0.10709687f, -0.15422139f, 0.10917388f, 0.18343315f, 0.24164997f, 
    0.12528254f, 0.00454743f, -0.04630090f, -0.01638872f, 0.02152235f, -0.03777461f, 0.12422732f, -0.06206940f, 
    0.25593001f, -0.07820547f, 0.06245922f, 0.02194705f, -0.14758964f, 0.10270172f, 0.09266400f, 0.43695316f, 
    0.22241436f, -0.11866258f, -0.19187537f, -0.00835211f, 0.03648552f, 0.10148077f, 0.00113079f, -0.03583336f, 
    -0.09315931f, -0.08994661f, -0.00674922f, -0.24568458f, -0.03547066f, 0.15329015f, -0.06847979f, 0.13400602f, 
    0.01897192f, -0.14292309f, 0.42297146f, 0.06941161f, 0.05354013f, -0.13055611f, 0.28883162f, -0.08130857f, 
    0.02520342f, 0.14238036f, -0.19409400f, -0.07633916f, -0.02130643f, -0.05708753f, 0.25647104f, -0.02795845f, 
    0.13305958f, 0.14193779f, 0.08983265f, -0.18852834f, 0.29068664f, 0.26332942f, -0.12898453f, 0.02488385f, 
    0.04973278f, -0.00283101f, -0.16734877f, 0.16569902f, 0.24179421f, 0.33021447f, 0.03416949f, 0.07688566f, 
    0.07098041f, -0.09114322f, 0.13442549f, -0.03164323f, 0.00553580f, 0.14002232f, 0.16334926f, 0.08445480f, 
    -0.06933547f, 0.08906298f, -0.05497672f, -0.08285720f, 0.18134162f, -0.01072951f, 0.03275114f, -0.07311530f, 
    -0.04572180f, -0.21642819f, 0.04533231f, 0.20129032f, 0.15591222f, -0.03054010f, 0.36747742f, -0.04074878f, 
    0.13677946f, -0.13558301f, -0.02183673f, 0.03005708f, 0.13683046f, 0.15602228f, 0.01304056f, -0.00156670f, 
    -0.01391964f, -0.02450200f, 0.03467530f, 0.04287194f, 0.01167250f, -0.04263115f, -0.03738785f, 0.01877158f, 
    -0.01385027f, 0.01342404f, 0.01391315f, -0.00996389f, -0.02406651f, -0.01752840f, -0.02391895f, -0.00589367f, 
    -0.03125891f, 0.04637413f, -0.06181993f, -0.01107270f, -0.02704789f, -0.02805567f, 0.05072901f, -0.04985623f, 
    0.00106282f, -0.02031723f, -0.06508583f, 0.03724930f, -0.05972138f, 0.00709416f, -0.06441906f, 0.04964916f, 
    -0.01139372f, 0.03451450f, -0.01456943f, -0.01965816f, -0.03965754f, -0.02793212f, -0.05902698f, -0.01918610f, 
    0.02803127f, -0.04952471f, -0.02891956f, -0.02653914f, -0.05216769f, 0.02692486f, -0.05921572f, 0.01167198f, 
    -0.03200737f, -0.03769043f, 0.00292506f, -0.05073430f, -0.03798001f, -0.05204841f, -0.04622270f, -0.05998605f, 
    0.05437987f, 0.01256356f, 0.03023831f, 0.05219636f, -0.01232203f, 0.04613604f, -0.02180626f, 0.04767618f, 
    -0.03147000f, -0.02745008f, -0.01029025f, -0.03435009f, -0.04995715f, -0.03629627f, -0.04660458f, -0.02272034f, 
    -0.05633547f, -0.06596561f, 0.01867974f, 0.01976579f, 0.00627946f, 0.02227590f, 0.00022172f, 0.00678396f, 
    0.01655976f, 0.03225658f, -0.02989736f, 0.02992309f, 0.00236986f, 0.00405835f, -0.00536350f, 0.02342812f, 
    -0.04117550f, -0.00666483f, -0.05138458f, -0.02711751f, -0.03375706f, -0.03991902f, 0.00542200f, -0.06290765f, 
    0.01318083f, -0.03297945f, 0.04907708f, -0.01649359f, 0.03628553f, -0.00833954f, -0.05757950f, -0.06539413f, 
    -0.03314868f, -0.05705811f, -0.01545001f, -0.01876592f, 0.00330576f, -0.05812030f, -0.00877022f, -0.00801805f, 
    0.04059126f, 0.01236834f, -0.05968578f, -0.00758045f, -0.06441496f, 0.04628971f, -0.01807125f, 0.03179889f, 
    0.02815856f, -0.00814615f, -0.05839260f, -0.05028063f, -0.04128135f, -0.02175526f, 0.00183638f, -0.04410320f, 
    0.03718942f, 0.01528253f, -0.02318560f, -0.04004177f, -0.06171074f, -0.02518562f, -0.02550434f, -0.01791269f, 
    0.01840238f, -0.06360009f, -0.01152782f, -0.06304304f, 0.01957442f, 0.05022958f, 0.01808218f, 0.01960273f, 
    -0.06066499f, -0.01706101f, 0.02473092f, -0.01817350f, 0.04287289f, 0.02658493f, -0.04205637f, -0.03204558f, 
    -0.03802992f, 0.03469206f, 0.01331171f, 0.03231800f, 0.02029628f, -0.05228875f, -0.00179464f, -0.03791199f, 
    -0.04876797f, -0.06513631f, 0.00332151f, -0.01381203f, -0.05847367f, 0.04074557f, -0.00301938f, 0.03144456f, 
    0.02472268f, -0.01484851f, 0.04262231f, 0.04276375f, 0.01502829f, -0.00291978f, 0.00293310f, -0.01515192f, 
    -0.00824423f, 0.01958751f, 0.03838424f, 0.02362812f, 0.02660847f, 0.00830207f, 0.02531860f, -0.02326737f, 
    -0.01650736f, -0.00139413f, 0.04945162f, 0.03229866f, -0.06339691f, -0.02842421f, -0.00712193f, 0.00645792f, 
    0.04101127f, -0.06382204f, 0.02263615f, -0.03381170f, -0.02372040f, -0.05459839f, -0.06193732f, -0.06519710f, 
    0.04247048f, -0.03704981f, -0.01871655f, 0.04470364f, -0.05303054f, 0.05087563f, 0.04486724f, 0.03069354f, 
    -0.02684658f, 0.04638248f, 0.04493583f, -0.02851082f, -0.04564163f, 0.04621720f, 0.03174751f, 0.04282141f, 
    -0.06244006f, 0.02762187f, 0.00422763f, 0.02846583f, 0.02648980f, 0.02540313f, 0.02987407f, -0.05300485f, 
    0.02015494f, 0.04099883f, -0.00103186f, -0.00394382f, -0.01688993f, -0.05195126f, -0.01516981f, 0.03616850f, 
    -0.00320410f, -0.01424786f, 0.03337202f, 0.02154954f, -0.02498547f, 0.03527423f, -0.02830644f, -0.05202212f, 
    0.03575663f, -0.06412974f, -0.06304590f, -0.06599583f, 0.00492717f, -0.03195393f, -0.03979905f, -0.03195501f, 
    -0.03656695f, -0.05796343f, 0.04517372f, 0.04753030f, 0.01757183f, -0.01745700f, 0.04044729f, 0.01701521f, 
    0.05199338f, 0.01679413f, -0.04320750f, -0.05722190f, 0.03180713f, 0.03537404f, 0.01554773f, 0.00860510f, 
    -0.01789981f, 0.05482159f, -0.00286830f, 0.00550716f, 0.01162722f, -0.04863106f, -0.05428910f, 0.04947744f, 
    -0.03970020f, 0.00201534f, -0.02376650f, 0.02392209f, 0.04782196f, -0.00588768f, 0.02630461f, 0.00195909f, 
    -0.01313385f, 0.03960604f, -0.05401372f, 0.00640357f, -0.06051362f, -0.05230244f, 0.03118693f, -0.01986705f, 
    0.42130932f, 0.17971057f, -0.02931010f, -0.07232055f, -0.04751091f, 0.29919431f, -0.08645096f, 0.06751416f, 
    -0.03952011f, -0.22156626f, -0.33523506f, 0.26694432f, 0.17919156f, 0.05641380f, -0.14608422f, 0.21373114f, 
    -0.06035915f, -0.18136059f, -0.28083503f, -0.13323191f, 0.11063535f, 0.05495886f, 0.13534194f, 0.06953280f, 
    0.17490548f, 0.01839198f, 0.22071536f, 0.34909073f, 0.27104253f, 0.10151982f, 0.04967446f, -0.08530962f, 
    0.19563775f, 0.06601276f, 0.09894022f, 0.03219170f, 0.12047351f, -0.03084918f, -0.01738501f, 0.09949730f, 
    0.23255962f, -0.09870195f, 0.02481722f, -0.02933624f, 0.16082977f, -0.15346058f, 0.06551807f, 0.01679491f, 
    0.11289615f, 0.23591833f, -0.03727332f, 0.01607606f, 0.28770447f, 0.05694448f, -0.07779930f, -0.13522249f, 
    -0.05925624f, -0.01359132f, 0.01164289f, -0.12614195f, 0.09143507f, -0.01055175f, -0.06390123f, 0.14719978f, 
    -0.33258343f, -0.13546941f, -0.07284801f, 0.18070614f, 0.11963718f, -0.00824554f, -0.03244128f, -0.44049865f, 
    -0.05403953f, -0.07168775f, 0.02849767f, -0.06276710f, -0.11355467f, 0.09019256f, -0.02379131f, 0.25006872f, 
    -0.15086353f, -0.03527654f, -0.11793034f, 0.14355801f, -0.00647334f, 0.09459997f, 0.12196525f, 0.00726447f, 
    0.02755501f, -0.18476224f, -0.23028363f, -0.11980122f, -0.05037774f, 0.09333732f, 0.20810497f, -0.06778279f, 
    -0.06690302f, 0.00533799f, -0.11819400f, 0.03673708f, -0.10861389f, -0.14294477f, -0.11767513f, 0.01106813f, 
    -0.06737319f, 0.14364284f, 0.10813593f, -0.18725544f, -0.13777333f, 0.08705258f, 0.03303726f, 0.04899701f, 
    -0.00154523f, 0.06065224f, 0.07734352f, -0.07899301f, 0.28438160f, 0.22739542f, 0.25290498f, 0.04406133f, 
    0.07624932f, -0.15907095f, 0.03666000f, 0.18554066f, 0.15446320f, 0.15303668f, -0.17310001f, 0.11543161f, 
    -0.12739454f, 0.01721506f, -0.02079875f, 0.02425528f, -0.05008570f, 0.12996003f, -0.17065184f, -0.12179773f, 
    -0.01030912f, -0.02575160f, 0.16305433f, -0.02328767f, 0.01009288f, -0.07263122f, -0.03564046f, -0.10821506f, 
    -0.27338281f, -0.22515596f, -0.17412186f, 0.20086153f, 0.05953800f, 0.23381753f, 0.00782211f, 0.01908999f, 
    -0.03006943f, -0.00981005f, -0.06392194f, -0.16983993f, -0.07568473f, 0.13565655f, -0.01892524f, 0.08506022f, 
    0.05050703f, -0.15821852f, -0.29762876f, -0.07674812f, -0.09544789f, -0.06136663f, 0.11908083f, 0.02267455f, 
    -0.00435674f, -0.04956239f, -0.35232183f, 0.01668390f, -0.14980528f, -0.10031696f, -0.07286344f, 0.15007399f, 
    0.02965865f, 0.27170533f, -0.00330567f, 0.14208166f, -0.28245738f, -0.11833981f, -0.09515953f, -0.16542165f, 
    0.05983854f, -0.02882423f, 0.13546592f, 0.05925296f, 0.02560010f, 0.17151183f, 0.03659064f, -0.01730426f, 
    0.02915053f, -0.04013271f, 0.17481111f, -0.07036918f, -0.06496270f, 0.12324311f, -0.06955046f, 0.04624702f, 
    0.05318712f, 0.04280049f, -0.01494885f, 0.01458679f, 0.08488369f, 0.09665459f, -0.00710426f, -0.20367609f, 
    -0.08970015f, -0.01566685f, 0.10114350f, -0.01261850f, 0.00199294f, -0.10421376f, -0.19853698f, 0.08866513f, 
    0.03094858f, -0.16916883f, -0.61510044f, 0.11103844f, -0.12245428f, -0.08275220f, 0.04308937f, -0.16892678f, 
    0.02120072f, 0.07053575f, 0.13416635f, -0.09709686f, -0.02637728f, 0.01283292f, 0.22988309f, -0.21884240f, 
    0.26836845f, 0.05504026f, -0.37428376f, -0.09492667f, 0.00722665f, 0.23557779f, -0.09628938f, 0.06961565f, 
    -0.23859864f, 0.09982620f, 0.01693866f, -0.19081940f, 0.04269143f, 0.04967111f, -0.03017063f, -0.02770682f, 
    0.10759401f, -0.25561863f, 0.31583071f, -0.03702063f, 0.15769720f, 0.06834020f, -0.05466743f, -0.04907408f, 
    0.00185938f, -0.11722954f, 0.14468379f, 0.18101816f, 0.02698905f, 0.14021504f, 0.00715468f, -0.02647733f, 
    0.16568126f, 0.02501528f, 0.23525381f, 0.00424661f, -0.09211532f, -0.00691720f, -0.08236869f, -0.00701688f, 
    -0.02223424f, -0.13108674f, 0.18804155f, 0.00375462f, 0.07102068f, 0.06165310f, -0.07584225f, -0.28555453f, 
    -0.11474761f, 0.01303665f, 0.04234627f, 0.00334281f, 0.15580277f, -0.07751682f, -0.01233241f, 0.16041741f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03363980f, 0.06468385f, 0.02577977f, -0.07110170f, -0.05241429f, 0.06973521f, -0.05353383f, -0.08092124f, 
    0.13360679f, 0.03639669f, 0.01003974f, -0.02638808f, 0.12810312f, 0.06245069f, 0.07511355f, 0.10163623f, 
    0.04568411f, -0.00888778f, -0.00662243f, 0.11085901f, 0.03097772f, 0.01318166f, -0.00186725f, 0.09285264f, 
    0.10480017f, -0.03356639f, 0.10665377f, -0.02582133f, 0.16454582f, 0.09558266f, -0.05225503f, 0.12503624f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00039269f, 0.05888477f, 0.14478403f, -0.03089875f, 0.04056757f, 0.04043951f, 0.02135482f, 0.10403277f, 
    0.01478486f, -0.02091150f, -0.08176948f, -0.04645269f, 0.11843776f, 0.05459129f, -0.00784938f, -0.12289067f, 
    -0.19160014f, -0.06076116f, 0.12809663f, -0.06296748f, -0.06021771f, -0.10145696f, -0.09723851f, -0.13165854f, 
    -0.09875008f, -0.16595802f, -0.00523071f, -0.09701063f, -0.09204482f, 0.07608096f, 0.15533300f, -0.10490319f, 
    -0.19281456f, -0.15992109f, 0.01781468f, 0.10680892f, -0.14308088f, -0.15086778f, 0.05977054f, -0.07311310f, 
    0.01911392f, 0.00461006f, 0.09399851f, -0.02191466f, 0.00531747f, -0.10787030f, 0.09804782f, -0.19155902f, 
    0.11760781f, 0.00463731f, 0.07536206f, 0.10654990f, 0.16647831f, -0.03518302f, 0.04174025f, 0.07241971f, 
    -0.15738426f, 0.05619842f, -0.10254983f, 0.01439735f, -0.10772587f, 0.11013515f, 0.14795694f, -0.14124522f, 
    -0.39301732f, 0.11661834f, -0.07900793f, -0.13307838f, -0.31309080f, 0.34439817f, -0.04860038f, -0.25856847f, 
    0.20352727f, 0.26873791f, 0.17116211f, 0.19897822f, -0.08925320f, 0.39478344f, -0.22654746f, -0.23658614f, 
    0.29588655f, 0.04723028f, -0.05871170f, 0.20964748f, 0.05159220f, 0.33570749f, 0.28145051f, -0.27261949f, 
    0.12450495f, 0.04229099f, 0.02741714f, -0.10449813f, 0.08052244f, 0.24312356f, 0.15135449f, 0.27551681f, 
    -0.09702453f, 0.52545834f, 0.21598832f, 0.24003918f, -0.07753069f, 0.44162288f, 0.13532710f, 0.20546424f, 
    -0.10877402f, -0.16936618f, -0.02052503f, -0.14508012f, 0.56760538f, 0.31693685f, -0.30564684f, -0.08592802f, 
    0.59916079f, 0.07418076f, -0.13286854f, -0.21816450f, -0.04053918f, -0.27153644f, 0.46379557f, -0.23840499f, 
    0.49971735f, -0.16774252f, 0.28078824f, 0.10922712f, 0.13827300f, -0.32691601f, -0.15362562f, 0.17701837f, 
    0.21465307f, -0.07047614f, -0.05315979f, -0.35355073f, 0.17697911f, 0.30925575f, 0.13291904f, 0.10998659f, 
    0.44972780f, -0.19644631f, -0.07583042f, 0.65281302f, -0.32668769f, -0.32086614f, -0.42474443f, 0.09533890f, 
    0.13960233f, -0.32728168f, 0.13715458f, 0.07631090f, -0.06718680f, -0.54855192f, 0.00134316f, 0.63910413f, 
    -0.02180886f, 0.12055884f, -0.36105788f, 0.09116385f, -0.03458810f, 0.22206549f, 0.07527669f, 0.29105598f, 
    0.21575131f, 0.09958933f, 0.02309768f, -0.03764705f, 0.08394881f, -0.33245578f, 0.10767881f, 0.09038093f, 
    0.00109268f, -0.12951370f, 0.14134747f, -0.09731995f, -0.13757046f, 0.08790713f, 0.13935080f, 0.17933813f, 
    -0.03459473f, -0.02233274f, 0.04296387f, -0.07056078f, -0.09373221f, -0.05784346f, -0.33214271f, -0.20697705f, 
    0.36861145f, 0.03135641f, 0.10561156f, -0.01243412f, 0.10582608f, 0.21873419f, 0.08857999f, -0.27514744f, 
    -0.16265416f, 0.07332475f, 0.01180263f, -0.15216209f, -0.06250304f, -0.13096642f, -0.08552860f, 0.07870821f, 
    0.15083453f, -0.14052518f, -0.16127689f, -0.03658327f, -0.09090761f, -0.07984758f, 0.04651805f, -0.13119361f, 
    0.13922916f, -0.06043565f, -0.07230660f, 0.03656496f, 0.02889154f, 0.14528571f, -0.07454009f, 0.15156338f, 
    0.02853628f, 0.00337015f, -0.08279883f, -0.12572594f, -0.15850239f, -0.10979740f, -0.07949943f, -0.13520791f, 
    0.05071684f, 0.29105300f, 0.27337572f, 0.40817338f, 0.18548405f, -0.36978060f, 0.00490867f, -0.38269773f, 
    -0.43979552f, 0.28985685f, -0.09978032f, -0.41013989f, -0.03792479f, -0.02280716f, 0.42443448f, 0.06954738f, 
    -0.45898420f, -0.20703378f, -0.09812077f, 0.39170301f, 0.14716768f, -0.09950109f, 0.36512920f, 0.43794236f, 
    -0.06227582f, 0.01826306f, 0.30443931f, -0.11862250f, 0.32279176f, -0.10970531f, -0.10631634f, -0.02613827f, 
    0.29623535f, -0.36437419f, 0.09371956f, -0.08161905f, 0.16067249f, 0.24246740f, 0.12283641f, 0.13323528f, 
    0.49969047f, -0.00305939f, 0.12523854f, 0.10832755f, 0.53503162f, 0.08330174f, 0.07243958f, 0.09686623f, 
    0.06796478f, 0.26507199f, 0.06139209f, -0.49607995f, -0.06922261f, -0.44321653f, -0.28111178f, -0.01882660f, 
    0.08790144f, 0.09274648f, 0.03210179f, -0.16841263f, -0.12581863f, 0.27237403f, -0.04421154f, -0.17617969f, 
    -0.16483711f, 0.06150638f, 0.12463766f, 0.11202163f, -0.16547868f, -0.07692397f, -0.14775674f, -0.13616574f, 
    -0.06385187f, 0.02368572f, 0.08950553f, -0.03061434f, 0.07988902f, -0.05412723f, 0.12386403f, -0.01653046f, 
    0.07934733f, 0.01469473f, 0.12817872f, -0.17881393f, -0.08298845f, -0.10880015f, -0.05491371f, -0.04213858f, 
    -0.11420339f, -0.00391203f, 0.07192626f, -0.14371452f, -0.16440845f, -0.05327495f, 0.15669242f, -0.17297933f, 
    -0.00661128f, -0.21127112f, 0.52931428f, -0.37646183f, -0.04652563f, 0.04482986f, 0.03940158f, -0.29622349f, 
    0.33780852f, -0.12256249f, -0.08007766f, -0.06338739f, 0.61490703f, 0.30563861f, -0.12825514f, 0.21869771f, 
    0.09506962f, 0.08527207f, -0.11752147f, -0.13981232f, -0.00853395f, -0.79605395f, -0.12601811f, 0.10602961f, 
    0.34350774f, 0.06376218f, 0.03852081f, 0.03866303f, 0.23377262f, 0.11609586f, -0.05828640f, 0.17172751f, 
    0.04118413f, -0.12925462f, -0.17334101f, -0.45133433f, -0.08634639f, -0.19028351f, -0.03034148f, 0.31952918f, 
    -0.00640409f, -0.34832084f, -0.00646250f, 0.14244923f, 0.23992337f, 0.00026038f, -0.13833122f, 0.17149478f, 
    -0.13857955f, 0.32549775f, 0.12715326f, 0.34874919f, 0.16569059f, 0.35367399f, -0.23089385f, 0.09072703f, 
    -0.22248618f, 0.05573129f, 0.40911084f, 0.05381880f, 0.00809445f, 0.36485082f, -0.16836922f, -0.31101584f, 
    0.03456527f, -0.13277233f, -0.51743329f, 0.50485325f, -0.08179156f, -0.26380330f, 0.02907132f, 0.21667373f, 
    0.40004322f, -0.33697680f, -0.08151883f, 0.17813803f, 0.47652045f, -0.31311980f, 0.01953779f, 0.38986585f, 
    0.13270171f, -0.30779603f, 0.08880731f, 0.50605571f, 0.05365051f, 0.13553375f, -0.16999193f, 0.24586825f, 
    -0.56400353f, 0.01909769f, 0.09160477f, 0.00468012f, 0.07647434f, 0.31009454f, 0.06318556f, -0.16703574f, 
    0.49528071f, -0.00560353f, 0.18397929f, -0.35145390f, 0.42063206f, 0.16196075f, 0.02495684f, 0.34762311f, 
    -0.39092347f, 0.34902549f, -0.07134803f, 0.23529081f, -0.13702680f, 0.04747161f, 0.10457291f, 0.08148519f, 
    0.23767024f, 0.45111698f, -0.04944782f, -0.46490803f, -0.07814124f, -0.33224326f, -0.01675628f, -0.51438063f, 
    0.04069049f, 0.11793469f, 0.20923056f, 0.14027199f, -0.09642196f, 0.07110544f, -0.02741025f, -0.13363822f, 
    -0.16164674f, 0.12527104f, 0.14441705f, -0.22989632f, -0.23097630f, 0.49503723f, -0.06976073f, 0.04485678f, 
    0.57466823f, 0.14976017f, 0.08997606f, 0.11933221f, 0.72146839f, 0.31078431f, -0.18888323f, -0.12908687f, 
    0.03352489f, 0.16031586f, -0.09879161f, 0.11966590f, 0.04041851f, 0.29834738f, 0.32759404f, 0.01602692f, 
    -0.49251750f, 0.10284322f, 0.14512588f, -0.09395649f, -0.24116127f, 0.00459622f, -0.02147866f, 0.23154880f, 
    0.01246076f, -0.11261947f, -0.16203606f, 0.10836262f, 0.07375460f, 0.02466876f, 0.13583502f, -0.11996255f, 
    -0.03747546f, 0.14632873f, 0.08284117f, 0.09031346f, -0.07424051f, 0.13636047f, -0.19308135f, -0.18639542f, 
    0.02587529f, -0.02427478f, 0.06469060f, -0.13921331f, -0.03556214f, 0.07376185f, -0.07000034f, 0.15339802f, 
    -0.02443509f, 0.11490464f, 0.07545702f, 0.02764966f, -0.09987633f, -0.10287825f, 0.00783464f, -0.08284765f, 
    -0.27322841f, 0.20395379f, -0.16821249f, 0.20721252f, -0.16524619f, 0.00373541f, -0.16991097f, -0.41695377f, 
    0.18230017f, 0.24122018f, -0.03942966f, 0.30879101f, -0.64919955f, 0.12132706f, 0.25223380f, -0.20188473f, 
    0.07043685f, -0.53881204f, -0.15549947f, 0.69358063f, -0.06089861f, 0.50103372f, 0.12189898f, -0.23299727f, 
    0.32014418f, 0.01957136f, -0.18425855f, 0.13730377f, 0.21941912f, 0.24825129f, -0.15725388f, 0.18035589f, 
    -0.16179171f, 0.19503421f, -0.29034397f, 0.28809339f, -0.07058359f, 0.22458167f, -0.15479790f, 0.03974303f, 
    0.06360470f, -0.18847637f, -0.04225305f, -0.11865502f, -0.18411575f, -0.15481624f, 0.14790104f, 0.22463739f, 
    0.11407228f, 0.05807248f, 0.07449834f, -0.12927775f, 0.01411460f, 0.11970879f, 0.08257131f, 0.15356274f, 
    -0.33409747f, 0.04294435f, 0.10356203f, 0.09479888f, 0.08263444f, -0.14695464f, 0.03072893f, -0.06591834f, 
    -0.13701281f, 0.26403865f, 0.05323405f, 0.27993789f, -0.29720899f, 0.03830318f, -0.13596185f, 0.22877982f, 
    -0.03165519f, -0.15885580f, 0.00225418f, -0.14944917f, 0.69485849f, -0.15091930f, -0.00866720f, -0.08546897f, 
    -0.20314634f, 0.38396907f, 0.02604374f, 0.54006958f, 0.07318386f, 0.83205223f, 0.34123835f, -0.19883884f, 
    -0.17917408f, 0.07830396f, 0.45887345f, -0.04060005f, 0.11606964f, 0.22070897f, -0.02482511f, -0.26588258f, 
    -0.14017081f, 0.44141132f, -0.40347251f, -0.19031344f, -0.26351282f, -0.07074323f, 0.16047014f, 0.23591828f, 
    -0.31478333f, 0.07043754f, -0.13456747f, -0.01155077f, 0.33425337f, 0.12241817f, 0.06745711f, 0.20212898f, 
    0.43936685f, -0.13756120f, -0.09621616f, -0.18508114f, 0.10975327f, -0.14783372f, -0.10783676f, -0.30167234f, 
    0.22404817f, 0.10019886f, 0.61583573f, 0.06528547f, 0.34595138f, -0.25997064f, -0.05139116f, 0.15806444f, 
    0.14750551f, -0.09738456f, -0.71788132f, -0.37796813f, -0.19423316f, 0.09443567f, -0.17845613f, 0.18134291f, 
    0.20266904f, 0.06910587f, 0.13962550f, 0.12211470f, -0.04302692f, 0.13676316f, 0.23541854f, -0.10429648f, 
    0.34735927f, 0.25719583f, 0.04986684f, -0.42833877f, -0.09740772f, 0.01744694f, -0.31489691f, -0.38770276f, 
    -0.06335115f, -0.16468436f, 0.49513042f, -0.01816220f, 0.24612354f, 0.23558807f, 0.00058830f, 0.01245776f, 
    0.12637696f, -0.06811240f, 0.09592649f, 0.04439944f, 0.12473300f, -0.10079763f, 0.08924410f, -0.06076842f, 
    0.11704534f, -0.02948671f, -0.12640598f, -0.18597686f, -0.14941651f, 0.07387643f, 0.08246792f, -0.17869011f, 
    0.11417864f, -0.02784450f, -0.14158955f, -0.01971068f, 0.10450365f, 0.01760212f, -0.11049648f, 0.02834835f, 
    -0.08923002f, 0.15626703f, 0.08844212f, 0.07993013f, -0.17366660f, -0.13407995f, 0.16269016f, -0.02262769f, 
    0.31023869f, 0.16222838f, 0.50709885f, -0.49492472f, 0.14549308f, 0.30803785f, -0.05510382f, -0.33481032f, 
    -0.27871063f, 0.57392895f, 0.13911590f, 0.16308363f, 0.07369379f, 0.42739108f, 0.26522303f, -0.23106444f, 
    -0.01185509f, 0.44963309f, 0.08337841f, -0.43731859f, -0.15669614f, 0.44639412f, -0.03717028f, -0.29866895f, 
    -0.45084545f, -0.15779768f, 0.32566354f, -0.02411120f, -0.30968207f, 0.32376558f, -0.10218908f, 0.00003331f, 
    0.22655423f, 0.00988730f, 0.18166600f, 0.35308325f, 0.51952493f, -0.18412080f, 0.03792019f, 0.36854777f, 
    -0.16079831f, 0.20016563f, 0.04124086f, 0.28300783f, -0.36178923f, -0.16086926f, 0.30667076f, 0.22803713f, 
    -0.03101810f, -0.08829680f, -0.10197359f, 0.09656126f, 0.08084599f, -0.51056451f, 0.00261844f, 0.33266014f, 
    -0.27719703f, 0.16166534f, -0.41475147f, -0.08874123f, 0.07580593f, -0.05762215f, 0.03339334f, 0.10049731f, 
    -0.11697268f, -0.05238140f, 0.08275995f, 0.04072614f, 0.12577695f, -0.08823950f, 0.03961362f, 0.13000706f, 
    -0.11553003f, 0.01467921f, -0.13561974f, -0.15132175f, 0.07395003f, 0.05949498f, 0.15488067f, -0.12834762f, 
    -0.10470042f, -0.02509354f, -0.09281436f, -0.02163660f, 0.04698087f, -0.10695929f, -0.07083750f, 0.09779352f, 
    -0.06734317f, 0.11477447f, 0.04103763f, -0.13365771f, -0.14459656f, -0.11865535f, 0.11256927f, -0.07288779f, 
    0.06211434f, -0.12554215f, -0.04026438f, -0.01473733f, -0.09456398f, 0.23597592f, 0.13639148f, -0.43518722f, 
    0.43527517f, -0.18784446f, -0.06358461f, -0.12410229f, -0.06020404f, 0.07252486f, -0.14970757f, 0.38432294f, 
    -0.06514727f, -0.39664966f, 0.07965796f, -0.01516214f, -0.04336593f, -0.53379369f, 0.07860664f, 0.69100958f, 
    0.42398536f, -0.02288475f, -0.41518372f, 0.15355675f, 0.08729916f, 0.02080393f, -0.08540376f, 0.32410643f, 
    -0.17072959f, -0.07651711f, 0.35336336f, -0.32033384f, -0.04290353f, 0.00834230f, -0.12180664f, -0.04350917f, 
    0.34947720f, -0.05435466f, 0.06638015f, -0.05439474f, 0.03709668f, 0.27803874f, -0.12139208f, 0.17384462f, 
    0.16382591f, 0.08329110f, 0.04734290f, 0.27515554f, -0.07268024f, -0.26611844f, 0.02084777f, 0.70588350f, 
    -0.24859096f, 0.09552971f, 0.31160691f, 0.01249546f, 0.08125150f, -0.20275959f, -0.07867797f, 0.19961382f, 
    -0.19143756f, -0.11830299f, 0.03529088f, -0.07955929f, -0.07137055f, -0.08385068f, -0.13236952f, 0.04131817f, 
    0.06647047f, -0.13930751f, 0.16229807f, 0.04601566f, -0.12562510f, 0.00587598f, -0.19760428f, -0.14522655f, 
    0.09803184f, -0.05872571f, 0.09335076f, -0.04034143f, 0.00020575f, 0.13407573f, 0.09675233f, -0.13971971f, 
    -0.17750359f, -0.15715551f, 0.06128543f, -0.04147812f, -0.08183658f, 0.09656727f, -0.13694635f, -0.06871374f, 
    0.03849450f, 0.30565256f, 0.52802205f, -0.18207327f, 0.02136779f, 0.07265195f, 0.13174786f, 0.20209704f, 
    -0.55793715f, 0.11061020f, 0.04648635f, 0.39014679f, -0.48041070f, -0.16109075f, -0.01230796f, 0.16970348f, 
    0.14973648f, 0.10814489f, -0.10248265f, -0.17752355f, -0.06922273f, -0.07594586f, -0.08593501f, 0.06630776f, 
    -0.36096838f, -0.00142152f, -0.07398117f, 0.14570999f, -0.34214786f, 0.14590599f, 0.07020966f, -0.05900022f, 
    -0.19746834f, -0.36389992f, -0.09185153f, -0.19765693f, -0.18556543f, -0.20311637f, -0.13876113f, -0.23094064f, 
    0.22842890f, 0.30975047f, 0.03527988f, -0.14206086f, -0.59567964f, 0.40024868f, 0.25093350f, 0.08974545f, 
    0.13216856f, -0.38633212f, 0.04356300f, -0.04445844f, -0.17137846f, -0.31818622f, -0.05431332f, 0.34669563f, 
    0.68834102f, -0.05372477f, -0.04794722f, 0.15447375f, 0.21679033f, 0.20606117f, -0.14256601f, 0.31668943f, 
    0.47413710f, -0.35167378f, -0.04408555f, -0.28474447f, 0.44929346f, -0.09145115f, -0.09879864f, -0.05767175f, 
    -0.26392770f, 0.44405460f, -0.07008258f, 0.26535660f, -0.70265377f, -0.12306666f, 0.59495139f, 0.09780914f, 
    0.07538766f, 0.10451078f, -0.06219543f, -0.18132302f, 0.13208565f, -0.23525839f, -0.15896443f, -0.16804540f, 
    -0.14565721f, -0.02733623f, -0.09593453f, -0.03156038f, 0.12697040f, 0.41247383f, 0.07365556f, -0.03358683f, 
    0.33327475f, -0.52206963f, 0.39120227f, 0.40076813f, 0.24837121f, -0.27904919f, 0.04172522f, 0.39452064f, 
    0.11662961f, 0.13872324f, -0.04284594f, -0.31976706f, 0.19516076f, -0.16348478f, 0.24639659f, 0.50509626f, 
    -0.36174390f, 0.30082518f, -0.00953877f, -0.49370429f, -0.10335746f, -0.19636753f, 0.13330407f, 0.16837272f, 
    -0.21108560f, -0.00173153f, 0.04817000f, -0.15607102f, 0.12780543f, -0.02137828f, -0.10274996f, -0.46479437f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13714425f, -0.04404631f, -0.02953153f, 0.11545710f, -0.04362296f, -0.09633616f, -0.03137833f, 0.10286685f, 
    -0.01936658f, 0.06527605f, 0.32641402f, -0.01476936f, 0.12776835f, 0.05837834f, -0.02421038f, -0.04281281f, 
    -0.00420493f, 0.20414017f, -0.10331139f, 0.23227654f, 0.18636657f, 0.06119693f, 0.18594182f, 0.16553675f, 
    -0.15558097f, 0.25880209f, 0.05965026f, -0.16716641f, -0.05969168f, -0.04865452f, 0.21182483f, 0.01641965f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08521055f, 0.03069292f, -0.22960171f, -0.75061446f, 0.25012136f, -0.30619612f, 0.03777095f, 0.44803649f, 
    -0.85429806f, 0.05132013f, -0.45471618f, 0.19451496f, 0.45204055f, -0.34884644f, -0.16716029f, -0.07835731f, 
    0.28327873f, 0.16264756f, 0.07783943f, -0.27063134f, -0.37384811f, 0.04488803f, -0.49741009f, 0.27999651f, 
    0.11594201f, 0.04524697f, 0.29561105f, -0.02747602f, 0.18296112f, -0.04875365f, 0.11115363f, -0.18080080f, 
    -0.04730025f, -0.14202039f, 0.39418516f, 0.32311237f, -0.11001119f, -0.44815496f, 0.09385793f, -0.10068826f, 
    -0.42388627f, 0.10805196f, -0.13637213f, -0.12141497f, 0.15608481f, -0.37217882f, 0.46124113f, -0.14092450f, 
    0.40061334f, 0.08582604f, 0.34676632f, -0.13181576f, -0.25545257f, -0.16963084f, -0.17933710f, -0.32575127f, 
    -0.02140934f, -0.10361461f, -0.24918379f, -0.03017768f, -0.10856916f, -0.17121345f, -0.49218246f, -0.25793451f, 
    0.11941289f, 0.02979289f, 0.28533688f, -0.86230564f, -0.28665203f, 0.03692213f, -0.07471001f, -0.39985406f, 
    0.16425456f, -0.23487441f, -0.26087302f, 0.70568776f, 0.10540539f, -0.14510576f, 0.24028178f, 0.15588136f, 
    0.05491994f, -0.42487192f, 0.37331754f, -0.23867269f, 0.40070581f, 0.07705820f, 0.35797217f, -0.84580868f, 
    -0.17418708f, -0.42585653f, -0.02175555f, -0.03787607f, -0.34845266f, 0.14571254f, 0.03438171f, -0.25167859f, 
    -0.10417721f, 0.06453755f, -0.24541919f, -0.16305012f, -0.44944087f, 0.10333458f, 0.14662147f, 0.21134733f, 
    0.25054729f, 0.12022924f, 0.17947070f, -0.04060449f, -0.71596068f, 0.23501579f, -0.15527757f, -0.15798818f, 
    -0.18063751f, -0.60382754f, -0.19733140f, -0.76176888f, -0.70520055f, -0.06503760f, 0.50150055f, 0.11630959f, 
    -0.10214283f, -0.22813839f, -0.09970255f, -0.00544059f, 0.19410937f, 0.02361918f, 0.37845305f, 0.27139553f, 
    0.00727790f, -0.03961387f, -0.29220769f, -0.21487379f, -0.07129569f, 0.46233055f, -0.09919474f, 0.04331849f, 
    0.09417144f, -0.06957597f, -0.02353115f, 0.15555778f, 0.29917806f, 0.11721142f, -0.79146308f, -0.07934673f, 
    0.09398887f, -0.06892384f, -0.09632660f, 0.37569842f, 0.34626272f, -0.07507565f, -0.46785292f, -0.05217463f, 
    -0.06910435f, -0.19476712f, -0.34059238f, 0.09472062f, -0.56844759f, 0.10659333f, 0.32793543f, 0.06058713f, 
    -0.07850716f, 0.10412811f, -0.01183608f, 0.43878770f, 0.10043741f, -0.17387959f, 0.11817485f, 0.34310302f, 
    -0.44966292f, -0.11375660f, 0.26348040f, -0.46372694f, -0.36667880f, -0.36609948f, -0.19403115f, 0.01440798f, 
    -0.00152879f, 0.17216796f, -0.28338730f, 0.22781539f, -0.28628120f, 0.07297123f, -0.68811566f, -0.15907167f, 
    0.15448989f, 0.47499824f, 0.30545494f, -0.10277759f, 0.11121799f, 0.38287440f, -0.46576586f, 0.14727718f, 
    -0.11711604f, -0.10481893f, 0.15617453f, -0.13797942f, 0.28857407f, 0.05708854f, 0.09375503f, -0.54266506f, 
    0.24130712f, -0.14980073f, 0.11922545f, -0.75084257f, -0.10573748f, 0.05849965f, -0.22022906f, -0.10876419f, 
    0.30059254f, -0.33365566f, -0.83939755f, -0.15836711f, 0.22701283f, -0.00219474f, -0.36833459f, 0.10031025f, 
    -0.17934039f, 0.20767577f, -0.04856732f, 0.11573960f, -0.44318491f, 0.45700139f, 0.27307639f, -0.67906576f, 
    -0.05858772f, -0.11411507f, -0.70997828f, 0.14717093f, -0.31194836f, 0.08419897f, -0.01015372f, 0.11564446f, 
    0.07288191f, 0.05740439f, -0.89848459f, 0.18367139f, 0.29837975f, 0.21960337f, -0.41126367f, -0.12645954f, 
    -0.51676774f, 0.10161813f, 0.11987431f, -0.24719229f, -0.15741244f, -0.09228112f, -0.41095346f, 0.35073656f, 
    -0.05759000f, -0.07239798f, -0.72569805f, 0.08329298f, -0.13915274f, -0.48576224f, 0.05772465f, 0.54120380f, 
    0.14461608f, -0.10212269f, 0.10593867f, 0.57965940f, -0.37701797f, -0.03353029f, -0.03886182f, -0.44334179f, 
    0.03713458f, -0.15026973f, 0.06853264f, 0.13461702f, -0.03692323f, 0.17535315f, 0.27241173f, 0.14366236f, 
    -0.47264886f, -0.01079424f, 0.32081667f, 0.47660670f, 0.21862411f, 0.16636261f, -0.28117120f, -0.33791229f, 
    0.00393995f, -0.73883301f, 0.38049081f, -0.12974945f, 0.16814581f, -0.42595515f, -0.96385103f, -0.32623750f, 
    0.03078818f, -0.08506358f, -0.35100135f, -0.22166060f, 0.31263721f, -0.22452058f, 0.04363554f, -0.23961994f, 
    0.56758326f, -0.06026082f, 0.44458649f, 0.20479979f, 0.41446248f, -0.20782119f, 0.29806632f, -0.16354109f, 
    -0.56054986f, 0.12204508f, -0.29933497f, -0.20273009f, -0.04539741f, 0.05383876f, -0.36953935f, -0.01126372f, 
    -0.08348930f, 0.32263777f, 0.38239688f, 0.02442232f, -0.66584015f, -0.12305942f, -0.18693720f, 0.27435097f, 
    0.00852094f, -0.01852227f, 0.04081296f, 0.16964811f, -1.02965641f, -0.32485613f, -0.04826196f, 0.30495709f, 
    -0.22069605f, 0.14017607f, -0.35740966f, -0.85543138f, -0.49926421f, 0.19221850f, 0.12027027f, -0.10486771f, 
    -0.05349438f, 0.11240274f, -0.03668225f, 0.36429542f, 0.46763664f, 0.10656291f, 0.39531133f, -0.11252043f, 
    0.10015562f, -0.67140198f, -0.14485666f, -0.08791833f, -0.30117431f, -0.09376887f, 0.15644009f, -0.21936443f, 
    -0.11528926f, 0.01419257f, 0.00683257f, 0.11055056f, 0.66472667f, -0.45972061f, -0.08604477f, -0.63581097f, 
    -0.05651722f, -0.02426848f, -0.29998803f, -0.00053154f, -0.24712901f, 0.38800123f, 0.11575093f, 0.06977017f, 
    -0.17837612f, -0.21462736f, -0.33668229f, 0.00998771f, 0.11435038f, 0.15455021f, 0.29153606f, 0.03416007f, 
    0.16502534f, -0.28088483f, -0.08911990f, 0.00945492f, 0.68332314f, -0.42920381f, 0.20752825f, -0.41620821f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05737843f, 0.02803956f, -0.20902146f, 0.11387908f, 0.20700313f, -0.01567659f, 0.07843344f, -0.08014717f, 
    -0.22336473f, 0.07343142f, -0.04860282f, 0.07721727f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
