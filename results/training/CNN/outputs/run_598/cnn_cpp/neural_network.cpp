#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.44155243f, 0.98446453f, -0.70061272f, -0.84959114f, 0.09741732f, 0.25532874f, -0.37587810f, 0.41467664f, 
    -0.76337731f, -0.15856279f, 0.04921786f, -0.33432597f, 0.22376220f, 0.19693755f, 0.03587844f, 0.26747701f, 
    -0.12877926f, -0.35833687f, -0.25422052f, -0.14111084f, -0.14225908f, -0.03131971f, 0.26269481f, -0.20452246f, 
    0.17278668f, -1.29690385f, -0.80093390f, -0.38112614f, 0.45831963f, 0.61212951f, 0.12488262f, 1.44204199f, 
    0.65287131f, -0.45719209f, 0.28816006f, 0.08154090f, -0.24870883f, 0.25871092f, -0.31610292f, 0.27050766f, 
    -0.14676486f, -0.07728402f, -0.22883722f, 0.09713195f, -0.22148514f, 0.04709082f, 0.04795837f, -0.12568013f, 
    0.30029771f, -0.24790159f, -0.35075930f, 0.17662306f, 0.57211185f, -0.23834768f, 0.64032996f, -0.59031624f, 
    0.35134968f, -0.60092998f, -0.76991838f, -0.02111019f, -0.21999355f, 0.49093962f, 0.12604588f, 0.14527619f, 
    0.33719155f, -0.25838214f, -0.42758548f, 0.26899269f, -0.66649193f, -0.43930510f, -0.16441980f, 0.36083573f, 
    0.19447431f, 0.05591063f, 0.08458374f, -1.49104023f, 0.46757096f, 0.54170114f, -0.69502437f, -0.75686216f, 
    0.92615783f, 0.47534418f, 0.02032220f, 0.58437234f, 0.63194227f, 0.02930547f, -0.00954724f, -0.09574071f, 
    -0.01014808f, -0.00481494f, -0.20982753f, -0.10990731f, -0.14578599f, 0.02674851f, -0.15268566f, 0.27931452f, 
    0.24369183f, 0.30330589f, 0.44999054f, 0.17984663f, 0.04132650f, 0.88901818f, -0.44535059f, -0.55675429f, 
    0.62700146f, -0.33047485f, -0.93333298f, -0.27304241f, -0.54523587f, -0.40009889f, 0.43788907f, -0.12279683f, 
    -0.25838402f, 0.31527188f, -0.01048175f, 0.08164214f, 0.03713662f, 0.09999332f, 0.05778885f, -0.02492042f, 
    0.01820557f, 0.08061477f, 0.22449945f, -0.11432821f, 0.12340801f, -1.27749884f, 0.48884585f, 1.28454840f, 
    0.29979858f, 0.83058035f, 0.68469244f, 0.06498428f, 0.04496155f, 0.52560461f, -0.31092888f, 0.00568674f, 
    -0.22515370f, 0.05234268f, 0.20190102f, 0.03301844f, -0.17566121f, -0.10091931f, -0.00474772f, -0.17317940f, 
    0.11107239f, 0.00963343f, -0.00512857f, -0.28246221f, 0.05795647f, -0.03329935f, 1.16074419f, -1.03038740f, 
    1.08621418f, -0.41736451f, 0.15238470f, 1.00109172f, -0.59043306f, 0.70970917f, 0.19490029f, 0.02254343f, 
    -0.00518893f, 0.07917431f, -0.25473669f, 0.23018576f, -0.24671844f, 0.21270499f, -0.04908118f, -0.09106994f, 
    0.00561338f, 0.10261209f, -0.30209476f, -0.13715604f, 0.09310418f, 0.15789156f, 0.03223464f, 0.96020728f, 
    0.99007428f, -0.66921228f, -0.96653157f, -0.39009845f, -0.37174743f, 0.65431839f, 0.04906015f, 0.39973712f, 
    0.56653726f, 0.06241387f, -0.19515535f, -0.33589092f, -0.19107066f, 0.09089500f, -0.05323282f, 0.23167588f, 
    -0.10043086f, -0.10656356f, 0.41474113f, -0.47316602f, -0.30062902f, -0.22702400f, -0.00340224f, -0.24384105f, 
    -0.18079242f, -0.73158848f, 0.73467559f, -0.07485069f, -0.72084028f, -0.55844480f, -0.22842629f, -0.43675911f, 
    0.41793573f, -0.02791414f, 0.03272719f, 0.18295151f, -0.37471762f, -0.48822877f, -0.34094828f, -0.07720697f, 
    0.04754319f, 0.09267477f, 0.26096511f, -0.10996126f, 0.42333630f, 0.44959879f, -0.23800728f, -0.24159753f, 
    -0.47096574f, -0.29943353f, 0.35746896f, 0.50051415f, 0.16354823f, 0.65470576f, -1.01145804f, -0.75355208f, 
    -0.59834391f, -0.99413687f, 0.14129630f, -0.01979535f, 0.68043250f, -0.23096937f, 0.09632845f, -0.03350351f, 
    -0.10163163f, -0.20325406f, -0.01753911f, -0.24321638f, 0.21863891f, 0.35182920f, 0.01244494f, -0.09655601f, 
    0.18339740f, -0.29176596f, 0.94423085f, 0.64893949f, 0.39374548f, 0.61583084f, 0.88672316f, 0.47140837f, 
    0.20818688f, 0.37583542f, -0.24795875f, 0.58914638f, -0.47430119f, 0.03457046f, 0.00349675f, -0.08168155f, 
    0.00349124f, 0.11762808f, -0.24741444f, 0.00990114f, -0.22950360f, -0.12785669f, 0.44778240f, -0.10754389f, 
    0.22274354f, 0.25952652f, 0.06011273f, -0.68815130f, -0.50902128f, -0.41992298f, 0.58369875f, 0.12676474f, 
    -0.89189345f, -0.25630441f, 0.18715915f, 0.11475307f, -0.62608206f, 0.57926428f, 0.57825708f, -0.15550411f, 
    -0.05522714f, 0.29645792f, -0.07738554f, 0.09915423f, 0.36190131f, 0.29890412f, -0.17186360f, 0.26718786f, 
    0.21371752f, -0.21918085f, 0.28373560f, 0.28371471f, 0.05289881f, 0.20611884f, -0.16877770f, 0.25703937f, 
    0.48248532f, 0.16935918f, -0.14594187f, 0.51482332f, -0.08140893f, -0.64379883f, -0.43862376f, -0.76316679f, 
    0.02900657f, 0.11291561f, 0.34370652f, 0.49793547f, 0.25978482f, -0.42093360f, 0.13194495f, 0.08165319f, 
    0.36218870f, 0.56521028f, 0.61648268f, 0.01063321f, 0.37642464f, 1.33304632f, 0.09199297f, -0.83031327f, 
    0.70946413f, 0.49633431f, 0.43235797f, -0.01601900f, -0.07755742f, 0.04202693f, -0.22939441f, -0.04774950f, 
    -0.18180372f, 0.18020545f, -0.39628959f, 0.33124614f, 0.03455874f, -0.53959513f, -0.11879500f, -0.45239779f, 
    -0.12908038f, 0.22009824f, -0.17525676f, 0.24550405f, 0.06332460f, -0.23394507f, -0.03935753f, -0.21296324f, 
    0.80643833f, 1.00048268f, -0.39886746f, 0.55575377f, -0.47887734f, -0.66118926f, -0.61457145f, 0.37227905f, 
    0.38887990f, 0.39097700f, 0.22651179f, 0.53486794f, 0.19458805f, 0.10552330f, 0.08265380f, -0.22930093f, 
    -0.08438486f, -0.11467418f, -0.39843389f, -0.06495441f, 0.08418379f, -0.03423787f, 0.06807428f, -1.00928390f, 
    0.43480670f, -0.20111236f, -0.08581879f, 0.38043505f, -1.15036905f, 0.30016306f, -0.06596927f, -0.37823591f, 
    -0.52177018f, -0.39713916f, -0.05393716f, 0.30526218f, -0.09108937f, -0.41978657f, 0.52951467f, -0.20937538f, 
    0.14047097f, -0.14344123f, -0.01722744f, -0.23556633f, 0.01784106f, -0.03738212f, 0.24300931f, 0.12244563f, 
    0.50815320f, 0.45260122f, 0.56631041f, 1.10469437f, 0.83222473f, -0.12818405f, 0.53384340f, 0.15293394f, 
    -0.25284648f, 0.54184002f, -0.58687103f, -0.47729957f, 0.05517970f, 0.09001393f, -0.03001885f, -0.43931222f, 
    -0.07984126f, -0.02102840f, 0.05140011f, 0.03652441f, -0.21654342f, -0.09994759f, -0.31981647f, 0.14560129f, 
    -0.17728776f, 1.05420208f, 0.46361622f, 0.31834611f, 0.08669849f, -0.98554707f, 0.53173029f, 0.19644381f, 
    -0.02716684f, 0.81582594f, 0.17725447f, 0.31273884f, 0.14277594f, -0.20406768f, -0.28627092f, -0.24127702f, 
    -0.00107794f, -0.27664167f, -0.17710018f, -0.13298269f, -0.11245997f, -0.08199177f, 0.21179657f, 0.11671422f, 
    -0.00014678f, 0.18660782f, -0.11268353f, -0.04076930f, -0.41703734f, -0.92595434f, -0.05841055f, 1.10429239f, 
    -0.37220210f, -0.10447475f, -0.39644152f, -0.60815769f, 0.09164734f, 0.10010402f, 0.52324885f, 0.03233184f, 
    -0.50892919f, -0.57387221f, 0.17175819f, -0.21348029f, -0.07955324f, -0.42054218f, -0.14958589f, -0.06497819f, 
    0.00379131f, -0.06632867f, -0.03076308f, 0.46193922f, -0.35495445f, -0.86042565f, -1.04254448f, -0.43714106f, 
    0.46982741f, 0.98139203f, -0.23807640f, 0.11381926f, 0.38870677f, 0.29204714f, -0.12865950f, -0.29007304f, 
    -0.16581777f, -0.29558674f, -0.15063094f, 0.05558163f, 0.11294442f, 0.22381058f, -0.13014044f, 0.12197408f, 
    0.10853591f, 0.03177106f, -0.00886361f, 0.34188345f, -1.25737989f, 0.36713099f, -0.77712297f, -0.28317621f, 
    -0.40017855f, 0.72562748f, -0.24230258f, -0.12046886f, 0.51479709f, 0.64320076f, 0.05701441f, -0.18662013f, 
    0.27046719f, 0.43795729f, 0.30200553f, 0.41018152f, 0.47293094f, 0.22121647f, -0.02509863f, 0.00144861f, 
    -0.45509514f, -0.26776326f, -0.24534330f, -0.15698919f, 0.08374698f, 1.41640472f, 0.05381348f, -0.84695661f, 
    -0.53422779f, -0.49543193f, -0.50328124f, -0.24731255f, -0.27412319f, 0.24585889f, -0.18842319f, -0.27884245f, 
    -0.10896359f, 0.61549562f, -0.47981605f, -0.59154570f, -0.31610873f, -0.17523882f, -0.02421018f, 0.25062487f, 
    -0.32059667f, -0.00287430f, 0.35151452f, 0.03100237f, -0.00949073f, 0.00254615f, 0.09733390f, 0.30625352f, 
    -1.20175970f, -0.59036684f, 0.21340221f, -0.73588771f, 0.76934004f, 0.09213689f, -0.48609653f, 0.11023505f, 
    0.74233639f, -0.34798250f, 0.10552763f, -0.11351363f, 0.41213745f, -0.19029757f, 0.22080941f, 0.06455417f, 
    0.04699825f, 0.10805643f, 0.08535172f, 0.16169254f, -0.01307181f, -0.00196152f, 0.29448515f, 0.42996716f, 
    0.56589323f, -0.33235371f, -0.14875677f, 0.30636913f, -0.13031721f, -0.42520759f, -0.53678918f, 0.02396634f, 
    0.30109376f, 0.29523662f, 0.60467541f, 0.24793205f, 0.29693729f, -0.04533857f, 0.15669130f, -0.46209145f, 
    -0.05351307f, 0.54826295f, 0.04014413f, 0.36217287f, 0.16373077f, -0.59186429f, 0.23383261f, 0.23900957f, 
    -0.66243964f, -1.01353729f, -0.93644249f, -0.72078192f, -0.65942335f, -0.54885197f, 0.51570678f, 0.53548783f, 
    -0.13281475f, 0.62775105f, -0.17780373f, -0.03891865f, 0.12660053f, -0.17569529f, 0.03347118f, 0.00804108f, 
    -0.13528803f, 0.08224970f, 0.22007155f, 0.29726055f, 0.04305830f, -0.04778196f, -0.13708942f, -0.09850539f, 
    0.11121459f, 0.24770688f, 0.81722057f, 0.67869401f, 0.52586180f, 0.35099497f, -0.05150263f, -0.00280808f, 
    0.18953553f, 0.04758823f, 0.33633834f, 0.51332563f, 0.15283844f, -0.24207568f, 0.18929262f, -0.44640720f, 
    0.48772565f, 0.55397880f, 0.29820588f, 0.04718117f, -0.05552700f, 0.41644681f, 0.06118899f, -0.36211172f, 
    -0.10165657f, 0.61936897f, -0.42790213f, 0.32485792f, 0.53138566f, 0.37853357f, -0.42274597f, -0.91458023f, 
    -0.05745191f, -0.23067966f, 0.19383809f, 0.29050502f, 0.33180296f, 0.44902369f, -0.34820306f, 0.24147731f, 
    0.19322947f, 0.19501129f, 0.46762091f, -0.28330532f, 0.39091933f, 0.37194133f, -0.38736340f, -0.01148647f, 
    0.20256703f, 0.04822797f, 0.04560089f, -0.02765584f, 0.78464139f, 0.82465178f, -0.50068253f, -1.02978504f, 
    -0.96074051f, 0.58679765f, -0.43194306f, -0.79958552f, -0.38757822f, 0.27175137f, 0.53878891f, -0.47093964f, 
    -0.01328668f, -0.33621556f, -0.34497589f, -0.23123273f, 0.12932052f, 0.08584850f, -0.30450758f, -0.02813953f, 
    -0.18124400f, -0.15678698f, 0.15344118f, 0.11910201f, -0.98108321f, 0.61802095f, -0.37664440f, -0.87589902f, 
    -0.63535523f, -0.18200248f, -0.03513774f, -0.74809915f, -0.00726701f, -0.47811800f, -0.29411682f, 0.02272400f, 
    -0.43475914f, 0.29534939f, 0.14405262f, -0.16285323f, 0.35860634f, -0.17021154f, 0.22944118f, 0.07647678f, 
    0.13414970f, -0.08507925f, 0.42126697f, -0.23702675f, -0.20614676f, 1.09891117f, 1.00544786f, 0.43217105f, 
    0.72008765f, 0.48661199f, 0.14382084f, -0.26778132f, -0.76150572f, -0.35202396f, -0.20447126f, 0.16422945f, 
    0.54105979f, 0.07691561f, 0.30175039f, -0.44714901f, 0.30126303f, 0.22848292f, 0.45084617f, 0.08034080f, 
    -0.11882111f, -0.12955314f, 0.02768349f, -0.15838209f, 0.12043197f, 0.32020095f, 0.93996489f, 0.78557014f, 
    1.19891250f, 0.05863229f, 0.13365522f, -0.52283865f, -0.49226904f, -0.17565191f, -0.03660058f, -0.04090550f, 
    0.12360796f, -0.26271316f, -0.19881676f, 0.37212035f, 0.50069469f, -0.05676940f, -0.16887718f, 0.04096944f, 
    0.04880502f, -0.33037943f, 0.31419915f, 0.00085021f, 0.17907278f, 0.21027714f, 0.26025623f, 0.50393033f, 
    0.80410576f, -0.39800850f, 0.38875312f, 0.79553914f, -0.39409456f, -0.77917063f, 0.20937796f, 0.43050402f, 
    0.23767394f, -0.53772306f, -0.48717412f, 0.08137113f, -0.49959713f, 0.08821149f, 0.04303138f, 0.23626824f, 
    0.26968434f, 0.41149414f, 0.53326714f, 0.32527566f, 0.16540934f, 0.10975987f, -0.48582152f, -0.01857834f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23904012f, 0.05336925f, 0.00328108f, -0.11718322f, 0.03179291f, 0.13810371f, 0.02052249f, 0.25543928f, 
    0.00545577f, 0.26820028f, 0.38356352f, 0.27029055f, 0.00982124f, 0.21656568f, -0.08380936f, 0.38353828f, 
    0.24266224f, 0.24152960f, 0.08334912f, 0.19045964f, -0.00089098f, -0.02811715f, 0.20328915f, 0.02063073f, 
    0.21435900f, 0.25355226f, 0.30050629f, 0.08012342f, 0.11768223f, -0.00817594f, 0.13052498f, 0.18264304f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05461903f, -0.06914733f, 0.23949255f, -0.56085479f, -0.12279879f, -0.17433611f, -0.02735439f, 0.18372440f, 
    0.01380353f, 0.04439772f, -0.14945985f, -0.08528720f, -0.30496678f, 0.45699602f, 0.10288965f, -0.14302322f, 
    0.09705808f, -0.00980629f, -0.16826108f, 0.02879838f, -0.05083528f, 0.02575762f, -0.02864942f, 0.01555881f, 
    -0.24634126f, -0.00828984f, 0.02184253f, 0.02703794f, 0.06920148f, -0.01575541f, -0.05704003f, -0.04632242f, 
    -0.06342019f, 0.16233249f, -0.02169858f, 0.05035557f, 0.58281106f, 0.00680863f, 0.06843084f, -0.03700823f, 
    0.06074699f, 0.10312603f, -0.00042433f, -0.06143175f, 0.12141491f, 0.00700646f, 0.04052422f, -0.00284483f, 
    0.20509267f, 0.20705076f, 0.38391477f, -0.13421883f, -0.10563626f, 0.00107435f, 0.02965856f, 0.04683099f, 
    -0.01218118f, -0.04032288f, 0.04994250f, 0.01737861f, -0.40952310f, -0.08317653f, 0.10910098f, 0.13527636f, 
    -0.17749390f, 0.01145744f, 0.07968893f, -0.15871851f, -0.01260607f, -0.17064667f, -0.00541169f, 0.00569897f, 
    0.61150050f, -0.28743383f, 0.08989490f, -0.13024426f, -0.05410603f, 0.03204882f, 0.06624194f, -0.15561128f, 
    -0.09321477f, 0.18557668f, 0.06002962f, 0.03386176f, -0.18891932f, 0.01938082f, 0.14336841f, -0.63924116f, 
    -0.10858218f, 0.01086196f, 0.08376189f, 0.07562205f, -0.04671947f, -0.01318999f, 0.06958230f, 0.01291151f, 
    -0.05497199f, -0.10426391f, -0.04428533f, 0.39562938f, 0.12244095f, -0.01715652f, 0.00915638f, 0.02042902f, 
    -0.06856757f, 0.06418244f, -0.10985713f, -0.15516372f, 0.07638969f, -0.03366938f, 0.14041269f, 0.06735381f, 
    0.04133611f, -0.03414735f, 0.02792809f, -0.13563676f, -0.10193674f, -0.20956755f, -0.01811965f, 0.04758680f, 
    0.23588549f, -0.11060602f, 0.00735106f, 0.18202268f, -0.12530349f, -0.11042900f, 0.01826278f, 0.07827940f, 
    -0.01323505f, 0.01648589f, -0.04831703f, -0.06314845f, -0.41999874f, 0.09923490f, -0.15640873f, 0.08210221f, 
    0.00557034f, -0.11477219f, 0.00611371f, 0.00826301f, 0.06091526f, -0.09767718f, -0.04568417f, -0.03736087f, 
    0.01555665f, -0.04942723f, -0.04173353f, 0.11044184f, 0.01205066f, 0.03997358f, 0.03957999f, -0.05850883f, 
    -0.12954442f, -0.05487068f, 0.06632464f, -0.24115269f, 0.23206115f, -0.21167809f, 0.03134777f, 0.20186290f, 
    -0.12955430f, 0.07941689f, -0.07945767f, 0.07007088f, -0.27161077f, 0.06098901f, 0.04893704f, -0.10542899f, 
    -0.01542953f, -0.02546501f, -0.20686564f, 0.24258099f, -0.04866160f, 0.00070526f, 0.06490885f, 0.04737633f, 
    -0.00797511f, 0.07035735f, 0.07139419f, -0.00155669f, -0.18073054f, -0.18792069f, -0.19459307f, 0.04833008f, 
    -0.06035597f, -0.12987250f, -0.02895941f, 0.12811176f, 0.08012197f, -0.00864067f, 0.10453916f, -0.15005116f, 
    0.15828848f, -0.06011458f, -0.04680108f, 0.40570149f, -0.20749195f, -0.01909993f, 0.01685770f, -0.03147863f, 
    -0.01541428f, -0.01645699f, 0.14696613f, -0.04071008f, 0.11974846f, -0.03425680f, -0.12842922f, 0.10222261f, 
    -0.02091954f, 0.08889395f, -0.21835332f, 0.05584954f, 0.00141213f, -0.08623818f, -0.01206230f, -0.02150439f, 
    -0.19707261f, -0.18205205f, 0.12022550f, -0.26680824f, -0.02642501f, -0.01590714f, -0.00504046f, -0.12530594f, 
    -0.06694403f, 0.17140166f, 0.00374700f, -0.08358338f, 0.03017870f, 0.01603777f, 0.15281083f, -0.54348344f, 
    0.11875641f, -0.06512272f, 0.16828452f, -0.12718233f, -0.06359068f, 0.06232014f, 0.02962454f, 0.10603480f, 
    0.63471073f, -0.10772523f, -0.10121337f, -0.05183387f, 0.03250082f, -0.07934950f, -0.05461407f, 0.02041152f, 
    0.15563893f, 0.03147293f, -0.16226494f, 0.01145409f, -0.28458115f, -0.11264728f, 0.18748741f, -0.10583971f, 
    0.12776358f, -0.12847258f, 0.00005468f, 0.10543793f, -0.05572763f, 0.01783198f, 0.21942492f, 0.02427628f, 
    -0.48677856f, 0.08037708f, 0.23269211f, -0.09164394f, 0.06297549f, 0.01626282f, 0.12146080f, -0.18161105f, 
    -0.01521371f, -0.24451923f, -0.11920115f, 0.12243560f, 0.04827762f, -0.13793489f, 0.21948104f, -0.20342666f, 
    0.01976749f, 0.10969198f, -0.02726009f, -0.01247732f, 0.22725235f, 0.06844364f, 0.12349471f, -0.03807224f, 
    -0.08515056f, 0.02900026f, -0.15775672f, -0.60591716f, 0.06360820f, 0.03739797f, 0.12864876f, 0.07927912f, 
    0.06807448f, -0.10410292f, 0.01069567f, 0.10045512f, -0.18759485f, -0.01674660f, -0.00191354f, -0.06048447f, 
    -0.06142742f, -0.04054548f, 0.02564095f, -0.13433635f, -0.07712715f, 0.09641350f, 0.04249793f, -0.18792965f, 
    -0.18514256f, -0.10904425f, -0.17086127f, 0.24060118f, 0.00920255f, -0.01575550f, -0.00630951f, 0.05064789f, 
    0.06356747f, -0.01426058f, 0.01643425f, 0.02311088f, -0.51350945f, 0.24470359f, 0.20954049f, 0.06012821f, 
    -0.00244624f, 0.14451310f, -0.05276945f, -0.09139361f, -0.18319100f, -0.02550698f, 0.12423980f, -0.06375924f, 
    0.02790644f, -0.10862729f, -0.21298340f, -0.22913146f, 0.20790605f, 0.07529733f, -0.04432648f, 0.03994095f, 
    -0.08312196f, -0.15786344f, 0.05785983f, -0.15806155f, 0.20305252f, 0.06724923f, 0.09425117f, 0.08352581f, 
    -0.33032799f, -0.08651961f, 0.01698982f, 0.15736495f, 0.03938068f, 0.05504996f, -0.14072669f, -0.08605498f, 
    0.23895359f, 0.16990341f, -0.20272216f, -0.22248651f, -0.23887618f, -0.13962696f, 0.02014006f, -0.07198910f, 
    0.03031770f, -0.04737187f, -0.01848028f, -0.13738060f, 0.17910260f, 0.00695360f, 0.10006796f, 0.10545035f, 
    -0.19097225f, 0.03046067f, -0.03724295f, 0.00717346f, -0.09161983f, 0.04457354f, 0.10893317f, 0.07165097f, 
    0.06700788f, 0.05794818f, 0.04116979f, -0.41327462f, 0.00526668f, -0.03537779f, 0.17560276f, 0.03828173f, 
    -0.09830306f, 0.02082883f, -0.01136143f, 0.10926497f, 0.39784986f, 0.11477046f, -0.20056409f, 0.00620162f, 
    0.09913473f, 0.12916100f, -0.08553789f, -0.05263417f, -0.03269164f, -0.01969247f, -0.01509971f, 0.04743091f, 
    -0.00209691f, 0.12816226f, 0.01924412f, -0.28320813f, -0.05380690f, 0.11269683f, 0.15579659f, 0.08627639f, 
    0.11942680f, -0.25393325f, -0.07744344f, -0.12667012f, -0.94996274f, -0.00020969f, -0.20250691f, -0.03173946f, 
    0.01165528f, -0.18150248f, -0.04123512f, 0.06926389f, 0.09020505f, 0.12689520f, -0.12493207f, -0.03203232f, 
    -0.27673930f, -0.09692118f, -0.14274116f, -0.46832559f, -0.00750037f, 0.07219899f, 0.03115284f, -0.07941461f, 
    0.01173323f, 0.04991777f, 0.07357139f, -0.00535095f, -0.06967151f, 0.23679693f, -0.15032816f, 0.07281429f, 
    0.03272397f, 0.08946346f, -0.03406215f, -0.02132198f, -0.12759589f, -0.00120781f, 0.01742270f, -0.02210445f, 
    0.17835851f, -0.05946533f, 0.02978956f, -0.14439826f, -0.04074469f, -0.04048735f, -0.07129430f, -0.05405830f, 
    0.06888603f, 0.07177144f, 0.09595871f, -0.01950032f, 0.39025322f, 0.00136365f, 0.03307685f, -0.39164948f, 
    0.01527548f, -0.20551902f, -0.01872627f, -0.13173433f, -0.08949599f, 0.07780166f, 0.01227035f, 0.10988203f, 
    -0.44854999f, 0.01512991f, -0.12719598f, 0.23244584f, -0.06902711f, -0.16401425f, -0.07933640f, 0.03778436f, 
    0.06080091f, -0.10429345f, -0.02215444f, 0.03917130f, -0.11668400f, -0.11555768f, -0.11336707f, -0.22963160f, 
    0.01179801f, 0.02556464f, 0.00374093f, 0.07034434f, -0.04168249f, 0.18415172f, 0.03610828f, 0.03552031f, 
    0.35489491f, 0.20374681f, 0.06791418f, 0.19033843f, -0.13868463f, 0.05591710f, 0.05049481f, -0.00144766f, 
    0.01288356f, 0.08759826f, 0.05624916f, 0.14151108f, -0.14479871f, -0.16460823f, -0.16973972f, 0.10648753f, 
    0.03539123f, 0.07591602f, -0.15776302f, 0.05004346f, -0.09389520f, 0.01547888f, 0.06209689f, 0.21675354f, 
    -0.07990862f, 0.02515547f, -0.05738101f, 0.05856343f, -0.24034204f, -0.09401737f, 0.00925870f, -0.03862201f, 
    0.25930214f, 0.17240004f, -0.13733985f, 0.13601515f, 0.03784974f, -0.25843185f, 0.25265360f, 0.04923183f, 
    -0.11408524f, 0.03090202f, 0.01758381f, 0.04300399f, 0.03497034f, 0.06732782f, -0.26792255f, 0.02091824f, 
    -0.30995581f, 0.19613354f, 0.13322492f, 0.04365036f, -0.13050517f, -0.07162764f, 0.11187031f, -0.11419954f, 
    0.09965387f, -0.04743946f, -0.06187341f, 0.01624044f, -0.12795848f, -0.05071696f, -0.16880092f, -0.61585224f, 
    0.02649947f, 0.20777807f, -0.01233958f, -0.04652492f, -0.04449588f, -0.11632652f, -0.13920191f, 0.01103171f, 
    0.28678420f, 0.12631749f, 0.06170062f, 0.35106817f, -0.07864115f, 0.11201955f, 0.06577908f, 0.02560757f, 
    0.01446608f, -0.03021214f, -0.02586500f, -0.16714787f, 0.17584978f, -0.08785504f, 0.15661657f, 0.08476921f, 
    -0.07700447f, -0.08235009f, 0.06250446f, -0.00950312f, -0.09215681f, 0.06333090f, -0.10860236f, 0.12965800f, 
    0.14464737f, -0.33817777f, 0.00700174f, -0.12819855f, -0.01112257f, -0.13017602f, 0.08206859f, 0.04894070f, 
    -0.07017782f, -0.16797546f, -0.00175346f, -0.12693813f, 0.24210447f, -0.36876878f, -0.09462404f, -0.27443790f, 
    0.02601248f, -0.04256735f, -0.12501779f, 0.13569434f, 0.05207331f, 0.01141299f, -0.02309942f, -0.04304428f, 
    -0.52856606f, 0.08426731f, -0.04429439f, -0.07157300f, 0.11462016f, 0.04461881f, 0.12882765f, 0.09716358f, 
    0.02208950f, 0.09153384f, 0.04006158f, 0.05989391f, 0.40862712f, -0.46852487f, -0.10663787f, -0.30851021f, 
    0.16773711f, -0.23592831f, 0.07391679f, 0.01911849f, -0.12282234f, -0.20330451f, -0.20147143f, -0.16418542f, 
    0.54329848f, -0.21029167f, -0.30302709f, -0.32736507f, -0.09458129f, 0.07658326f, 0.00861631f, 0.09477477f, 
    0.04895100f, 0.01705354f, 0.13764055f, -0.12994345f, -0.00040963f, -0.08729006f, 0.02365018f, -0.09783325f, 
    0.00261978f, -0.06260552f, 0.11820450f, -0.02361950f, -0.06966040f, 0.18377221f, -0.21519138f, 0.00331631f, 
    0.26095131f, -0.20606157f, 0.05405598f, -0.03460364f, 0.09796058f, -0.17052367f, 0.11135382f, 0.07078400f, 
    0.00128526f, 0.05385772f, 0.03458386f, 0.04783405f, 0.28103241f, -0.02859614f, 0.16402924f, 0.11052035f, 
    -0.16735068f, -0.00915159f, -0.12992558f, 0.05429945f, 0.03657934f, -0.08298171f, -0.09844477f, -0.01197561f, 
    -0.13079746f, 0.00276103f, -0.32914242f, -0.06997778f, -0.11708500f, -0.06661451f, 0.05057683f, -0.07039300f, 
    0.01611507f, 0.06558945f, -0.02108060f, 0.19952102f, -0.40402815f, 0.27089173f, -0.69958532f, -0.15584040f, 
    -0.07738141f, 0.11113208f, -0.04195084f, -0.01033903f, 0.18641905f, -0.03420216f, 0.08705481f, 0.08729272f, 
    -0.45197055f, 0.00592943f, 0.01330295f, -0.16324310f, -0.01405340f, -0.06753954f, 0.04689154f, 0.12831518f, 
    0.08995003f, 0.16668716f, -0.01369723f, 0.04905390f, 0.31197709f, -0.14245340f, 0.17792024f, 0.16747847f, 
    -0.02590189f, -0.02462566f, -0.00174744f, -0.03359025f, 0.09109514f, -0.00093080f, 0.03618317f, 0.02011254f, 
    -0.00187106f, 0.10032912f, 0.01850739f, 0.14680150f, 0.12314108f, -0.07717916f, 0.12941673f, 0.08576964f, 
    0.10094282f, 0.12993938f, -0.05040733f, 0.11372042f, 0.12799600f, -0.08434463f, 0.02721228f, 0.12897156f, 
    0.09973817f, -0.11343122f, 0.01825641f, 0.05870756f, 0.09996434f, -0.21658023f, -0.08448925f, -0.04679048f, 
    -0.32042041f, -0.11343583f, -0.21138580f, -0.19282882f, 0.09324245f, -0.08221858f, 0.02392573f, -0.07688136f, 
    -0.07445317f, 0.04287940f, 0.01984441f, -0.09303729f, 0.37182269f, -0.13366736f, 0.08517576f, 0.10382373f, 
    -0.06996853f, -0.09689665f, -0.08713143f, -0.00360351f, 0.11094525f, -0.00052292f, 0.06047126f, -0.08261911f, 
    0.35129431f, -0.11169540f, -0.22448453f, -0.17567843f, 0.06117624f, -0.02522117f, -0.10274152f, -0.07585227f, 
    0.03491304f, -0.03940778f, -0.07497623f, 0.01764728f, 0.68432987f, 0.18266694f, 0.02975041f, 0.02718447f, 
    -0.06686076f, 0.04828238f, -0.10326993f, 0.09058827f, -0.09322241f, 0.05371988f, -0.02216764f, -0.02721725f, 
    -0.49231547f, 0.04363176f, -0.26456833f, -0.17455985f, 0.05359831f, 0.03686789f, 0.11470599f, -0.11614522f, 
    -0.02965957f, -0.04160736f, -0.05189376f, -0.07861719f, 0.37121418f, 0.02950759f, -0.20850153f, 0.16298331f, 
    -0.13721031f, -0.06403377f, 0.13427033f, -0.08553809f, -0.00392580f, -0.01187045f, -0.04331466f, 0.01045212f, 
    -0.61522001f, 0.32562369f, 0.01734866f, 0.02310925f, 0.03102481f, 0.03662032f, -0.05551310f, 0.11347227f, 
    -0.12042814f, 0.00693601f, 0.06034340f, -0.03699330f, -0.04635382f, -0.24731112f, 0.10511900f, -0.10171693f, 
    -0.07189509f, -0.01607813f, 0.13787542f, 0.05851428f, -0.04034847f, -0.12876283f, -0.00747295f, -0.04156196f, 
    -0.43350363f, -0.11958170f, 0.02730289f, -0.07996051f, -0.24129306f, -0.02577795f, 0.21250530f, -0.03103978f, 
    0.10916985f, -0.01934507f, 0.00449795f, 0.09537454f, 0.19401315f, -0.03111847f, 0.05547505f, 0.09053896f, 
    0.06126714f, 0.10058675f, -0.10734637f, -0.11195713f, 0.02009268f, -0.00073066f, 0.03177177f, -0.18493709f, 
    0.00537595f, -0.01161916f, -0.05431992f, -0.12827678f, 0.12454574f, -0.02109251f, 0.02205348f, -0.05414870f, 
    0.00737497f, 0.03403054f, 0.14386883f, 0.03531799f, 0.38699588f, -0.24700136f, -0.15894632f, -0.10996383f, 
    0.04441800f, -0.06601130f, 0.16939394f, -0.01544886f, -0.13091210f, 0.08428767f, 0.04404510f, -0.11054915f, 
    -0.42910352f, -0.08223064f, -0.24875502f, 0.00757583f, 0.04625431f, -0.13888256f, -0.05224285f, -0.02850780f, 
    0.00105315f, -0.03174456f, 0.16713350f, 0.04409521f, 0.02854291f, -0.07906354f, 0.02430433f, -0.16507000f, 
    0.11979704f, -0.10256242f, -0.02188520f, -0.04141817f, 0.04914682f, 0.06155799f, -0.00134243f, -0.11714225f, 
    0.10874382f, 0.11396023f, -0.10754430f, -0.09030751f, -0.07348656f, 0.28977501f, -0.14272289f, 0.07412617f, 
    0.03191012f, 0.05733500f, -0.24163722f, -0.14207970f, 0.17358205f, -0.07968655f, -0.55383432f, -0.18560261f, 
    0.02606633f, 0.07643966f, -0.09055298f, -0.10169084f, -0.00836322f, 0.04244602f, 0.02249507f, -0.08293620f, 
    -0.05624233f, -0.01799090f, 0.00733249f, 0.07862081f, 0.11787049f, 0.04180375f, -0.01328952f, -0.04356955f, 
    0.05848751f, 0.07950746f, 0.01721736f, 0.06001763f, 0.11830988f, 0.03108739f, 0.09264606f, -0.14618181f, 
    0.08274578f, 0.00849957f, -0.04698570f, 0.17968735f, -0.09182113f, 0.06039381f, 0.07965383f, -0.03062349f, 
    -0.41772616f, -0.05744378f, 0.06517243f, -0.12620479f, 0.09620952f, -0.11066132f, -0.05207798f, -0.07691426f, 
    -0.04382928f, 0.16413881f, -0.11977280f, -0.11640202f, 0.00717550f, -0.08335911f, 0.34135410f, 0.15375860f, 
    -0.01432263f, -0.04523983f, 0.04949933f, -0.06369852f, -0.04784871f, -0.12429806f, 0.12362935f, 0.16689135f, 
    0.28033987f, 0.35580063f, 0.02577086f, 0.17459300f, 0.02567285f, -0.10923552f, -0.00277893f, 0.17939782f, 
    -0.18562022f, -0.01808327f, -0.11479667f, -0.09020745f, -0.42978838f, 0.21106958f, 0.07936225f, -0.07196130f, 
    0.08523321f, -0.03280932f, 0.08166153f, 0.16962110f, -0.07155105f, 0.15077081f, 0.01592253f, 0.08104438f, 
    0.06183873f, 0.04859099f, 0.13488145f, 0.03303710f, 0.10539044f, -0.03298509f, -0.05963445f, -0.08610627f, 
    -0.09094664f, 0.02002491f, 0.02502793f, 0.10768760f, -0.07147635f, 0.01720421f, 0.15508009f, -0.23999235f, 
    0.07224216f, -0.03685864f, 0.10350036f, 0.04995590f, 0.12727453f, 0.00901539f, 0.07332717f, -0.24669372f, 
    0.38241634f, -0.02377839f, 0.13716857f, 0.39197206f, -0.21852115f, -0.14388014f, 0.00862149f, 0.05801894f, 
    -0.05390268f, -0.00231167f, -0.05403310f, -0.01868125f, 0.14217497f, 0.04490869f, -0.03397405f, 0.17975365f, 
    0.11898646f, -0.11112605f, 0.10506944f, -0.19579321f, -0.03469854f, -0.12138761f, -0.11514931f, 0.08201684f, 
    0.13978323f, -0.02569643f, -0.16683330f, -0.04121872f, -0.10610610f, 0.04874751f, -0.10000598f, 0.11060958f, 
    -0.12357209f, -0.13986111f, 0.00055817f, -0.07400130f, 0.06011853f, 0.11622681f, -0.26944032f, -0.37728226f, 
    0.02811370f, 0.15938069f, 0.08832952f, -0.09998781f, -0.01705851f, -0.10054805f, -0.02692597f, -0.04550562f, 
    -0.14083582f, -0.01705078f, -0.48839697f, -0.52187032f, 0.07349021f, 0.05478413f, -0.07609465f, -0.11816842f, 
    -0.09348446f, -0.03674065f, -0.00969938f, 0.03837088f, 0.10677742f, -0.02096825f, 0.09019945f, 0.00455686f, 
    0.13778214f, -0.06995196f, 0.08305497f, -0.00662289f, -0.18298130f, -0.07618364f, -0.06062829f, -0.14226343f, 
    -0.22146972f, 0.15030052f, -0.19634263f, -0.06862952f, 0.08676256f, 0.12504357f, -0.05538379f, -0.08196307f, 
    -0.05121292f, -0.10139044f, 0.03364494f, -0.04651491f, -0.10654072f, -0.16959257f, -0.06637995f, -0.12653166f, 
    0.05989404f, 0.02034988f, 0.07759902f, -0.16513377f, -0.04272875f, -0.09566657f, -0.05425631f, 0.03923007f, 
    0.15909560f, -0.07765000f, -0.02699155f, 0.06534105f, -0.04630258f, -0.03955159f, -0.12996194f, 0.14324728f, 
    0.09999423f, 0.05321884f, -0.01587368f, -0.05051008f, -0.12322508f, 0.11425199f, -0.01710645f, 0.05064009f, 
    0.05522159f, -0.14300223f, -0.02768520f, 0.10352880f, -0.01713086f, 0.08717327f, -0.15546705f, 0.00599139f, 
    -0.16300024f, 0.27272189f, 0.19919854f, 0.15005212f, 0.13227588f, 0.02632070f, -0.22316504f, -0.07366174f, 
    0.02745801f, 0.10071611f, -0.07958889f, 0.14727722f, -0.27641064f, 0.28442231f, 0.22849354f, -0.49034348f, 
    0.05964506f, -0.07528590f, -0.00794302f, 0.06991651f, 0.05627738f, -0.14728950f, -0.04245975f, -0.02806536f, 
    0.34461617f, 0.07951041f, 0.12627764f, 0.12756623f, -0.00965181f, -0.01411332f, -0.06410188f, -0.11774643f, 
    0.01537905f, 0.03223351f, 0.06981393f, -0.34499595f, 0.24276270f, 0.07941616f, 0.11564560f, 0.04708254f, 
    0.14157972f, -0.03232348f, 0.05795347f, 0.01320546f, -0.05352872f, 0.08722696f, 0.01719009f, -0.09439854f, 
    -0.17672789f, -0.08686950f, -0.31960225f, 0.12945440f, -0.06571912f, 0.11999403f, 0.03712288f, 0.10961080f, 
    -0.11090333f, 0.04170239f, -0.05217501f, -0.09189937f, -0.21617737f, -0.06289463f, -0.02619294f, 0.03026523f, 
    -0.18940414f, 0.12728904f, -0.03449744f, 0.08338037f, -0.02647629f, -0.09230483f, 0.00370324f, 0.15543650f, 
    0.03144025f, 0.28169686f, 0.23938070f, -0.05142816f, -0.04633602f, 0.12769340f, -0.07253235f, 0.15162191f, 
    0.01965723f, 0.06786496f, -0.06338049f, 0.16732737f, -0.09287303f, 0.19126867f, 0.03405913f, 0.35760784f, 
    0.18386015f, 0.18733202f, -0.10025732f, -0.14234629f, -0.14915150f, 0.00867742f, -0.00163063f, -0.13121684f, 
    -0.68298858f, -0.54663128f, -0.39246213f, 0.08199777f, -0.10920505f, -0.15600781f, -0.04181797f, -0.11957747f, 
    0.01383535f, -0.19465709f, 0.02883073f, 0.00070833f, 0.01280848f, 0.22269827f, 0.14792369f, 0.05030572f, 
    -0.11254733f, -0.10324688f, -0.07470885f, -0.08977567f, -0.07901809f, -0.06032573f, -0.16717321f, -0.10119103f, 
    0.02513101f, 0.11899950f, -0.03554245f, 0.06180933f, -0.10878222f, 0.08848660f, 0.05274950f, -0.09540582f, 
    0.01200528f, -0.07983182f, 0.10262171f, -0.01910670f, 0.35366473f, 0.04185737f, -0.18220633f, -0.01702899f, 
    0.11551463f, 0.04020082f, -0.04125489f, 0.00215364f, -0.01987805f, -0.02276283f, 0.18017767f, -0.04825166f, 
    -0.12032673f, -0.22090563f, -0.03702472f, 0.14265715f, 0.13474937f, 0.06784597f, 0.21269308f, 0.04097249f, 
    0.06838705f, -0.09493604f, 0.02191808f, -0.00251025f, -0.09636197f, 0.32010961f, 0.30866310f, 0.01511666f, 
    0.03711514f, -0.05995645f, -0.01586709f, 0.07651310f, 0.00580413f, 0.11536583f, -0.09950870f, -0.00160798f, 
    -0.56918621f, -0.55658132f, -0.14931707f, 0.02473113f, -0.22167823f, -0.18037732f, 0.07251672f, -0.05899242f, 
    0.04503328f, 0.02045010f, 0.13058004f, 0.08621527f, -0.17866707f, -0.44122264f, -0.11757634f, -0.18579303f, 
    -0.03387253f, 0.05596926f, -0.08412344f, 0.04633953f, -0.02701811f, 0.08912753f, -0.10487685f, -0.23723622f, 
    0.30067965f, 0.18447050f, -0.02224483f, 0.23710470f, -0.04099611f, -0.00834317f, 0.01002907f, 0.00950600f, 
    -0.01776241f, -0.04605353f, -0.07185193f, 0.02273390f, -0.12186943f, -0.14139879f, -0.12250169f, 0.05186237f, 
    -0.10612101f, -0.02485436f, 0.06499368f, -0.11931684f, -0.18484037f, -0.05952517f, -0.06675515f, 0.19379993f, 
    0.00970739f, 0.22165987f, -0.22567497f, -0.22405636f, -0.12168161f, -0.15744917f, -0.17253625f, -0.00953598f, 
    0.21410550f, -0.13811038f, 0.01089916f, 0.02659568f, 0.25653023f, -0.10417633f, 0.05613185f, 0.07288178f, 
    -0.00515008f, -0.00063647f, 0.01045620f, 0.07200408f, 0.01497069f, 0.02196726f, -0.05387289f, 0.19955027f, 
    -0.11932369f, 0.01510910f, 0.15202628f, -0.02252596f, -0.01664879f, -0.22886842f, -0.04607480f, 0.04765825f, 
    -0.02797304f, 0.06305668f, -0.17738934f, -0.05530581f, 0.00888605f, -0.20620544f, -0.05848732f, 0.09167327f, 
    -0.00659134f, 0.09510525f, 0.11735176f, -0.04158639f, 0.03459580f, -0.04330226f, 0.00507531f, -0.03246319f, 
    0.05926744f, -0.20501779f, -0.06341946f, -0.30216143f, -0.14368632f, -0.08930690f, -0.01326979f, 0.01031613f, 
    -0.08444220f, -0.16502932f, 0.02308042f, 0.05544315f, -0.48842743f, -0.21069972f, -0.25033623f, 0.12528388f, 
    -0.09427718f, -0.07480637f, 0.05730614f, -0.00095527f, -0.10520992f, -0.15378734f, 0.04238894f, -0.06427376f, 
    -0.55450392f, 0.14405933f, 0.00005179f, -0.00788470f, -0.05713644f, 0.12976851f, 0.07736725f, 0.22913097f, 
    -0.04139205f, -0.08931691f, -0.00949017f, 0.12200381f, -0.22602142f, 0.44053206f, 0.11560550f, 0.13185450f, 
    0.08155274f, 0.04473124f, -0.05018070f, 0.04231903f, 0.03059073f, 0.08848832f, 0.04440325f, 0.12846401f, 
    0.38809904f, 0.28171170f, 0.12756401f, -0.05929595f, -0.21792950f, -0.01548788f, -0.03539878f, 0.03158888f, 
    0.06873707f, -0.06224953f, 0.09142134f, 0.22017303f, 0.09910527f, -0.53132540f, -0.29975349f, 0.42870316f, 
    -0.06421969f, 0.02449386f, 0.03987509f, 0.08497633f, -0.02046517f, -0.18725537f, -0.07318927f, -0.08196257f, 
    -0.32560068f, -0.48580533f, -0.21213654f, 0.17716703f, -0.09328657f, -0.06972715f, 0.15911545f, -0.21346498f, 
    -0.05820627f, -0.12833740f, 0.13788122f, -0.08326984f, 0.22761552f, -0.03248072f, -0.18855815f, 0.06790755f, 
    0.01531025f, 0.06900494f, 0.05383578f, -0.14585799f, 0.03912257f, -0.00176802f, -0.07142889f, 0.13004465f, 
    0.11947624f, -0.06407490f, -0.33888617f, 0.20740704f, -0.16967677f, -0.14662975f, -0.02611898f, -0.03739236f, 
    -0.16435544f, 0.02494328f, 0.13663377f, -0.02645880f, -0.83082378f, -0.03206288f, -0.15124312f, -0.18631218f, 
    -0.06876151f, -0.02844892f, 0.09521666f, -0.01005717f, -0.01702683f, -0.07245391f, 0.04997450f, 0.13444892f, 
    -0.36218834f, 0.12153608f, 0.31438407f, 0.10172104f, -0.13359891f, -0.12706764f, -0.12465585f, -0.08377973f, 
    -0.06295542f, -0.01204954f, 0.00626432f, 0.24371317f, 0.29856971f, 0.05589215f, -0.10497390f, -0.01040639f, 
    0.04322918f, 0.03224289f, -0.06642605f, 0.01942741f, -0.06089313f, -0.02942247f, -0.08285438f, -0.05862611f, 
    -0.11471029f, 0.02573480f, -0.14221294f, 0.08332023f, -0.04460494f, -0.13269989f, -0.10927367f, -0.13133731f, 
    -0.14623767f, -0.10231601f, 0.12986362f, -0.04791387f, 0.21859439f, 0.41854650f, -0.36305845f, -0.18562581f, 
    0.03340263f, -0.03606369f, 0.18901552f, -0.01460735f, -0.03874010f, 0.01656904f, -0.02096833f, 0.01246156f, 
    -0.31378511f, 0.08987152f, -0.05912882f, -0.21282578f, 0.11955718f, -0.10779998f, -0.10015918f, -0.01369317f, 
    0.12539834f, -0.09165377f, -0.08572024f, -0.16424164f, -0.08766613f, -0.39884993f, 0.06023699f, 0.13709526f, 
    -0.10853323f, -0.03585703f, 0.05921938f, 0.05791888f, 0.15045008f, -0.07322533f, 0.05645616f, -0.03166719f, 
    0.17587920f, 0.16297877f, -0.05227868f, -0.09909876f, -0.03255399f, 0.15414384f, 0.12425017f, 0.05346188f, 
    0.00967383f, 0.08753148f, 0.07167535f, 0.11365020f, -0.47829422f, -0.13439375f, 0.29371905f, 0.15781057f, 
    -0.21645175f, -0.11750650f, 0.01094646f, -0.09183831f, 0.05218315f, 0.03397067f, 0.02704399f, -0.03928116f, 
    0.20610091f, 0.08825142f, -0.04459836f, 0.16656388f, -0.10625987f, 0.01553409f, 0.01154137f, 0.14061859f, 
    -0.03685933f, -0.01703302f, -0.01173353f, -0.02351957f, -0.28466216f, -0.15753226f, 0.03996504f, 0.00742593f, 
    0.02952929f, -0.03748751f, -0.06336107f, 0.22581793f, 0.04815506f, -0.04561448f, -0.06608619f, -0.21827719f, 
    0.52638382f, -0.11260551f, 0.12369202f, -0.12434687f, 0.02192196f, -0.05294820f, -0.07942895f, 0.07890165f, 
    0.01682892f, -0.19488184f, 0.00949076f, 0.09306820f, 0.53675467f, 0.17861953f, -0.26768416f, 0.01652732f, 
    0.03038216f, -0.08253883f, 0.00594733f, -0.17323627f, -0.17714751f, -0.16374853f, 0.00143047f, -0.01019334f, 
    -0.33542243f, -0.15828747f, 0.14374834f, -0.21503791f, 0.02275492f, -0.01661075f, -0.22462018f, -0.05934106f, 
    0.04814855f, 0.04526684f, -0.05305911f, 0.17035802f, 0.00940738f, 0.09879282f, 0.27929312f, -0.01155485f, 
    -0.00392229f, -0.08447114f, 0.00610653f, -0.05067956f, 0.03734956f, 0.02119665f, -0.05177951f, 0.11594602f, 
    -0.01629148f, 0.32408708f, -0.08345392f, 0.07498864f, 0.00309507f, 0.04824721f, 0.04516092f, 0.16386588f, 
    -0.07658850f, -0.00224367f, 0.18110721f, 0.10475394f, -0.48510173f, 0.14014988f, 0.10780615f, -0.13472320f, 
    -0.05872392f, 0.02992329f, -0.01404675f, -0.00732289f, -0.04625536f, -0.09873112f, 0.06569654f, 0.03133344f, 
    0.01672977f, 0.06360325f, -0.18323608f, 0.02186318f, 0.14753529f, 0.04851451f, 0.10857151f, -0.02219556f, 
    -0.03200205f, -0.04475155f, 0.00511232f, -0.03901859f, -0.62070531f, -0.01304315f, 0.25011697f, 0.16508995f, 
    0.05842855f, 0.12102425f, 0.00323664f, -0.01583218f, -0.07853023f, 0.07194033f, 0.06067929f, -0.10764489f, 
    0.18510762f, -0.21937482f, 0.16707988f, 0.28159767f, -0.03364615f, 0.07677967f, 0.06388146f, 0.04157053f, 
    0.14931373f, -0.08736804f, 0.11661740f, 0.02035657f, -0.09054616f, -0.12780768f, -0.01548801f, -0.06207718f, 
    -0.34029800f, 0.18568766f, 0.19014500f, 0.03099451f, -0.06916773f, 0.05887037f, 0.01693301f, 0.03904616f, 
    0.05665442f, 0.05551263f, -0.02811014f, -0.10636055f, 0.00351193f, 0.05566574f, 0.05296635f, -0.01579084f, 
    -0.00451253f, -0.16452825f, -0.11117259f, 0.01775142f, -0.27779964f, -0.11716431f, -0.31828591f, 0.08692100f, 
    0.01075029f, -0.09792501f, -0.10859916f, -0.01154445f, 0.03929080f, -0.26379785f, -0.05589525f, -0.13541086f, 
    -0.34257105f, -0.02995712f, 0.18070604f, 0.43402323f, 0.07683599f, 0.10459775f, -0.03936435f, 0.17540756f, 
    -0.00659721f, 0.02101812f, 0.02307183f, -0.06445235f, -0.08046462f, -0.06248240f, -0.20678836f, 0.00856045f, 
    -0.04514548f, 0.05629793f, 0.08689515f, 0.11431055f, -0.03616247f, 0.16199578f, -0.12354578f, -0.21831697f, 
    0.04768360f, -0.05628996f, -0.04678476f, -0.03771535f, -0.16167481f, 0.05109512f, -0.08114075f, -0.11053248f, 
    -0.16601174f, 0.09493440f, -0.07184552f, -0.13030952f, -0.11186726f, -0.50210756f, 0.42951623f, -0.28869516f, 
    0.04866660f, -0.01173836f, 0.20956551f, 0.06796430f, 0.13319518f, -0.02142125f, -0.07717529f, -0.08016510f, 
    0.32497507f, 0.12250883f, 0.15318947f, -0.18616568f, 0.00531493f, -0.07885721f, 0.30195740f, 0.02763459f, 
    0.13493927f, -0.02847942f, -0.01150663f, 0.30493450f, -0.06812192f, -0.01841815f, 0.14028962f, 0.03865434f, 
    -0.08913972f, 0.14158005f, 0.04817885f, 0.15553856f, 0.04536824f, -0.08890063f, -0.04656937f, 0.02736708f, 
    -0.23058192f, -0.16676410f, 0.24944457f, 0.08039968f, 0.07267546f, -0.11933131f, -0.02561845f, -0.13695197f, 
    0.10983881f, 0.13712578f, 0.05411942f, -0.04219514f, 0.33664930f, -0.29698950f, 0.04661439f, 0.13107108f, 
    -0.00157816f, 0.09949651f, 0.09135713f, -0.12512887f, 0.09427307f, 0.03164431f, -0.06317000f, 0.08909556f, 
    -0.36702883f, -0.08287635f, 0.25940949f, 0.26744464f, -0.10758149f, 0.04735384f, 0.00517688f, -0.10092871f, 
    0.17844902f, 0.02234515f, -0.00928143f, 0.01687742f, -0.68237936f, 0.23155203f, 0.07794219f, -0.49651498f, 
    0.13398834f, 0.10661166f, 0.14959086f, -0.00885849f, 0.02860233f, 0.03772536f, 0.00550638f, -0.24878561f, 
    0.05738333f, 0.02115454f, 0.10180999f, -0.05554418f, -0.10616588f, 0.09763831f, 0.00232489f, 0.07465851f, 
    -0.27564523f, -0.05426371f, 0.03604346f, -0.19105476f, -0.29588687f, -0.16002972f, -0.17384848f, -0.01225370f, 
    0.02017755f, -0.10113540f, 0.07949691f, -0.14350124f, 0.07328875f, -0.05585798f, -0.02599174f, 0.01635222f, 
    -0.13979846f, 0.01370320f, 0.20457314f, 0.31275523f, -0.11421654f, -0.21274574f, -0.06375588f, 0.05573696f, 
    -0.00703445f, -0.01828305f, -0.04445668f, 0.29634014f, -0.28768277f, -0.18840423f, 0.40984741f, 0.16366661f, 
    0.01472736f, 0.07038281f, -0.05607203f, 0.07329392f, -0.04081927f, 0.11860374f, -0.15057567f, 0.00649174f, 
    -0.41399270f, 0.04749684f, 0.20165581f, 0.24231508f, -0.05821652f, -0.01548503f, -0.02469507f, -0.10965060f, 
    0.04892821f, -0.16002995f, -0.03752132f, 0.06077072f, 0.29241058f, -0.25326109f, -0.18360421f, -0.05024251f, 
    -0.00304383f, -0.08106124f, -0.13486154f, -0.14707121f, -0.22674482f, -0.00040009f, -0.05311116f, -0.10879940f, 
    -0.06745081f, 0.04471732f, -0.23273231f, 0.12461928f, 0.11067428f, -0.04451231f, 0.05441539f, 0.21813895f, 
    0.14315456f, -0.03130041f, 0.00190547f, -0.11236412f, 0.13535570f, 0.01814671f, -0.12403885f, 0.08041018f, 
    -0.07634605f, -0.18321921f, 0.01463569f, 0.05230666f, -0.15101558f, 0.07074063f, -0.18563499f, 0.19831324f, 
    0.02675836f, 0.02051051f, 0.29299989f, -0.22577269f, 0.00633877f, -0.00171302f, -0.02632283f, 0.00993204f, 
    0.08768708f, -0.10150053f, -0.08230905f, -0.04808848f, 0.06238041f, -0.08695547f, -0.17973918f, -0.25870034f, 
    0.01883692f, 0.07855991f, -0.11454659f, -0.03140730f, 0.12033718f, 0.08597812f, 0.12412988f, 0.11943765f, 
    0.07239365f, 0.22174455f, 0.15153962f, 0.10716145f, 0.15943566f, 0.11211617f, 0.33888116f, 0.13448438f, 
    0.24397084f, 0.20883615f, -0.06716036f, 0.13063668f, 0.15072143f, 0.00635091f, 0.15245377f, -0.13103801f, 
    -0.08578435f, -0.07830054f, -0.19590613f, -0.12416105f, 0.12886031f, -0.12423805f, -0.05405658f, -0.12674579f, 
    0.18290409f, -0.12698069f, 0.03302401f, 0.11273322f, -0.00016741f, 0.13603564f, 0.04273885f, -0.01309881f, 
    -0.10301769f, -0.08224733f, 0.08211067f, 0.06856521f, 0.16530323f, -0.20638666f, -0.00983197f, 0.12282711f, 
    0.09012097f, 0.10419336f, 0.02387238f, -0.06777950f, 0.09650861f, 0.07034114f, 0.14860918f, 0.07978842f, 
    0.02946927f, 0.01329240f, 0.33509928f, -0.32331270f, 0.04447985f, 0.02491572f, -0.02047198f, -0.18423711f, 
    -0.01049216f, -0.06626111f, 0.03473954f, -0.10917278f, 0.36214390f, 0.04966814f, -0.28528744f, -0.01950143f, 
    0.03979414f, -0.04424218f, 0.23096858f, -0.14974558f, -0.01771543f, -0.07233492f, -0.11161222f, -0.03427366f, 
    -0.57258254f, -0.18112680f, 0.15768868f, 0.17978591f, 0.02067422f, 0.05828151f, -0.08749907f, 0.01628229f, 
    0.14548169f, -0.17027967f, 0.10675124f, 0.02814802f, 0.25560361f, -0.30243734f, -0.24097863f, -0.04557339f, 
    0.03180964f, 0.07817271f, -0.11496592f, 0.02056354f, 0.17854752f, -0.15810457f, -0.12481019f, -0.00722922f, 
    -0.61848205f, -0.19514130f, 0.12139036f, -0.22090513f, 0.07571552f, 0.13872677f, -0.09132551f, -0.56522822f, 
    -0.00317064f, 0.01867685f, 0.17938624f, 0.03836684f, 0.16683820f, -0.15943086f, 0.07615913f, 0.13362600f, 
    0.10024480f, -0.04209364f, 0.05706136f, -0.02516998f, 0.10712679f, -0.26943919f, -0.08317821f, -0.21721950f, 
    -0.53784508f, -0.14600129f, 0.09307481f, 0.07424070f, -0.06251621f, -0.24156931f, -0.01873233f, 0.05849421f, 
    0.03409472f, 0.15029430f, 0.00925851f, 0.10818630f, 0.01645920f, 0.17860046f, -0.05164404f, 0.02566445f, 
    -0.22082779f, 0.12650150f, 0.06788317f, -0.10377096f, -0.13462032f, -0.15501407f, 0.09394713f, 0.14729701f, 
    -0.57787251f, -0.21310218f, -0.51810390f, 0.08444445f, 0.15124945f, 0.15545158f, -0.01881479f, -0.01904660f, 
    0.13872527f, 0.04302466f, -0.00470926f, -0.02759571f, 0.09349586f, 0.03959137f, 0.12096149f, -0.01105564f, 
    -0.03925030f, 0.08780200f, -0.04976146f, -0.08532310f, 0.12255788f, 0.02672694f, 0.11177877f, 0.28393203f, 
    0.19139823f, -0.09194590f, 0.01719264f, -0.15584071f, 0.07836475f, 0.04401764f, 0.04312654f, 0.09465370f, 
    -0.05364988f, 0.02037616f, 0.08573107f, 0.21111383f, -0.13500671f, 0.03146170f, -0.16482781f, 0.19634578f, 
    -0.29385817f, -0.06582233f, -0.05077530f, 0.05359190f, 0.04113584f, -0.05464681f, -0.05691990f, -0.02680690f, 
    -0.31444150f, -0.32508224f, 0.15480845f, 0.12825902f, 0.11318773f, 0.07479054f, 0.03297685f, 0.07670816f, 
    0.01583987f, 0.07886792f, 0.08584804f, -0.00407854f, 0.02326437f, -0.04706445f, 0.00371467f, 0.12634596f, 
    -0.03599970f, 0.10821988f, 0.12090117f, -0.13532494f, -0.08945896f, -0.10815966f, 0.14620176f, 0.33092219f, 
    0.25280744f, 0.12783234f, 0.04805455f, 0.31100345f, -0.17765167f, 0.11363011f, -0.07891829f, 0.12062585f, 
    -0.10819452f, -0.05555238f, -0.01322412f, -0.06297036f, -0.00953795f, 0.01359653f, 0.13195866f, -0.41925645f, 
    -0.12855837f, -0.22817732f, -0.14494725f, 0.07070890f, -0.15934934f, 0.19194457f, 0.08601560f, 0.02297439f, 
    0.05591155f, 0.22572045f, -0.27294317f, 0.04084064f, 0.06494701f, 0.09035958f, -0.06121250f, -0.23220205f, 
    -0.03861087f, -0.03854405f, 0.03521463f, 0.02843563f, -0.01487509f, -0.71059823f, -0.13032165f, 0.21719728f, 
    -0.09277996f, -0.03863872f, 0.01616141f, 0.10554323f, 0.02855628f, -0.02143287f, -0.01680211f, 0.28283903f, 
    0.07437027f, -0.05661164f, -0.08735196f, -0.00629230f, 0.18753138f, -0.18977548f, 0.09597494f, -0.07269795f, 
    -0.01260735f, 0.12021460f, -0.04514427f, 0.02940806f, 0.32698411f, -0.30443394f, -0.16734414f, 0.16920282f, 
    -0.10371990f, -0.00292042f, -0.09120615f, -0.03593340f, -0.21165738f, 0.15986978f, 0.03712595f, -0.01284953f, 
    0.00075523f, -0.13738327f, -0.14172259f, -0.09841036f, 0.01556340f, 0.04222488f, 0.17732173f, -0.03134022f, 
    -0.01337834f, 0.05057000f, -0.15911740f, 0.04029601f, 0.62167633f, -0.20212016f, 0.00408660f, 0.06818895f, 
    0.02441189f, 0.02246639f, -0.01854540f, 0.00835367f, 0.08439538f, -0.06779615f, -0.12370313f, -0.09449004f, 
    -0.14523570f, -0.03054125f, 0.06269670f, 0.28459272f, -0.06524371f, 0.08102157f, 0.20879914f, 0.05544982f, 
    -0.03933718f, 0.06607444f, -0.09898435f, 0.16757844f, -0.60672849f, 0.12594286f, -0.28820026f, 0.36461955f, 
    0.13323347f, 0.10403276f, 0.13469461f, 0.15162528f, 0.16683879f, -0.06871182f, 0.04002400f, -0.01147834f, 
    0.03387304f, 0.02213675f, -0.03640085f, -0.19797973f, -0.05408509f, -0.17954400f, 0.08377196f, -0.29045740f, 
    -0.14824940f, 0.09725856f, 0.10547535f, -0.04919311f, 0.10872400f, 0.33851859f, -0.19120093f, -0.44219488f, 
    0.04827850f, 0.35114479f, -0.03804147f, 0.00905529f, -0.01165355f, -0.27017421f, 0.07371038f, 0.10373315f, 
    -0.18598919f, 0.14126581f, 0.29259920f, -0.22946528f, -0.13606337f, -0.06543382f, -0.01581349f, 0.13351843f, 
    -0.05555473f, 0.00892303f, 0.08379879f, 0.04078694f, 0.27343133f, -0.01534375f, 0.17290239f, 0.18140997f, 
    0.00102256f, 0.11200289f, 0.23920491f, -0.09100932f, 0.06768154f, 0.02216543f, -0.08201753f, -0.13807724f, 
    -0.44325027f, 0.14414923f, -0.01506246f, -0.02192153f, -0.01766688f, 0.00915802f, -0.29237840f, -0.24797992f, 
    -0.26105618f, -0.09232300f, 0.14958179f, -0.26976600f, -0.25285408f, 0.00231608f, -0.06579923f, -0.11140516f, 
    -0.16302076f, 0.02763995f, 0.15867141f, 0.03574552f, -0.01285239f, 0.10350003f, 0.12031961f, 0.10717382f, 
    0.21067165f, 0.01646826f, 0.10398822f, -0.15629208f, -0.09832346f, -0.25018412f, -0.12494590f, 0.04267725f, 
    0.17341317f, -0.02916558f, -0.03715961f, -0.22441243f, -0.08548072f, 0.06703777f, -0.11647405f, 0.00363651f, 
    0.13099480f, 0.02333829f, -0.01168361f, -0.12190384f, -0.11158598f, 0.02810151f, 0.00980874f, -0.17099781f, 
    0.11034053f, 0.15117730f, 0.23117979f, -0.35257086f, -0.17962106f, -0.00231095f, -0.06491278f, -0.04572992f, 
    -0.03788800f, 0.03828269f, -0.00883927f, 0.13584068f, -0.64839399f, 0.13286343f, 0.04497801f, 0.38097849f, 
    0.10610608f, 0.01856165f, 0.00153701f, -0.13919403f, -0.02369020f, 0.00194506f, 0.12144471f, 0.02023563f, 
    0.41357598f, -0.09309635f, -0.36201903f, 0.11388023f, -0.25282001f, -0.00454675f, -0.01716615f, -0.03747898f, 
    -0.17075679f, 0.11256123f, -0.01301403f, 0.20255421f, -0.03518855f, 0.17571373f, -0.38885394f, -0.00074733f, 
    0.02952694f, -0.00403291f, -0.04497007f, -0.03628466f, 0.00097086f, 0.09314613f, -0.02982683f, -0.04805641f, 
    -0.12444086f, -0.21373640f, -0.08943119f, 0.11440872f, -0.23053780f, -0.02403681f, -0.07863791f, 0.16474015f, 
    -0.13760673f, 0.04644655f, -0.16009733f, 0.08215539f, -0.04961726f, -0.12222052f, -0.16529112f, 0.16465358f, 
    0.16553679f, 0.16816920f, 0.13374133f, -0.06753433f, 0.10401949f, 0.06873646f, 0.08078641f, 0.20418982f, 
    -0.30772394f, -0.02278365f, -0.07945342f, 0.29046738f, 0.06789479f, -0.06691615f, 0.18428200f, 0.05289713f, 
    0.12495637f, -0.11354110f, -0.12720309f, -0.19617061f, -0.08027548f, 0.01663519f, 0.07973394f, 0.07387780f, 
    0.18645981f, 0.09775303f, -0.06388999f, -0.06875025f, -0.13174945f, -0.00489423f, 0.05953829f, -0.21884888f, 
    -0.23589209f, -0.29795891f, -0.30134222f, -0.44244584f, -0.11590237f, -0.04844522f, -0.08078803f, -0.22049357f, 
    0.05826599f, -0.06571355f, 0.18623298f, 0.00316006f, 0.10328884f, 0.38441774f, 0.00048618f, -0.17834495f, 
    -0.06518210f, -0.04537794f, 0.07271492f, 0.08097129f, -0.03007627f, -0.03929621f, 0.01454549f, -0.28834057f, 
    -0.12391227f, 0.12600532f, 0.15214509f, 0.01165413f, -0.01316815f, 0.17416276f, -0.00683280f, -0.02231392f, 
    0.01907226f, -0.00012108f, -0.18985640f, -0.35575247f, 0.02399920f, -0.38842261f, -0.02475570f, 0.04212483f, 
    0.24432394f, -0.07648508f, -0.03049259f, 0.07783413f, -0.10389109f, -0.03134704f, -0.06299381f, 0.06917498f, 
    0.27622664f, -0.07205534f, -0.06385590f, 0.27835643f, -0.21082798f, 0.01959035f, -0.05413888f, -0.03863139f, 
    -0.14236377f, 0.00791139f, 0.10138062f, 0.04107195f, 0.04140430f, 0.24456680f, 0.05742808f, -0.21643102f, 
    -0.12512319f, 0.04685787f, -0.04641988f, 0.09538517f, 0.13098145f, 0.14619757f, -0.21480593f, -0.18002643f, 
    -0.23471951f, 0.32366249f, 0.13171723f, -0.00557465f, -0.00174821f, -0.05064041f, -0.01674181f, 0.10317648f, 
    0.03066600f, -0.02952955f, -0.10999668f, 0.09044968f, -0.33822799f, 0.34696686f, 0.13331603f, -0.32847667f, 
    -0.00730789f, 0.25810292f, 0.22272740f, 0.05393111f, 0.02423517f, -0.13995172f, 0.01283129f, -0.05911940f, 
    -0.23113509f, 0.05518850f, 0.05191999f, 0.20405126f, 0.05683780f, 0.01216011f, -0.03701798f, 0.01425977f, 
    -0.07318201f, -0.05458301f, 0.06008525f, 0.00751004f, 0.11875243f, -0.18031465f, 0.20237511f, -0.01902590f, 
    -0.01397499f, 0.08259663f, 0.04274358f, -0.12270131f, -0.02225507f, 0.05128508f, -0.02279953f, 0.00488151f, 
    0.10421330f, -0.49016970f, 0.12510645f, 0.13191839f, -0.07151026f, -0.06092742f, -0.10301593f, -0.06489278f, 
    -0.10188353f, 0.11543123f, -0.01018203f, -0.01722012f, 0.14843574f, 0.18584335f, 0.10679331f, 0.26271683f, 
    0.20811732f, 0.10785852f, 0.11306541f, 0.04814783f, 0.01504514f, -0.05746232f, 0.02828237f, -0.09056073f, 
    -0.25247595f, 0.00824957f, -0.09405939f, 0.24439424f, 0.11136462f, -0.21661547f, -0.11041664f, -0.08002914f, 
    0.02680097f, -0.01729152f, -0.14067866f, 0.03139829f, -0.17775521f, -0.16474338f, 0.00141269f, -0.25722051f, 
    0.01157166f, 0.04780560f, -0.06522563f, -0.18538295f, -0.09910218f, -0.09031151f, 0.05651392f, -0.08044476f, 
    0.00757081f, -0.14894785f, -0.15832104f, -0.09733547f, -0.04284988f, -0.07221994f, -0.09891510f, -0.00908768f, 
    -0.04059848f, -0.05515734f, -0.09912732f, -0.06763112f, -0.10405688f, 0.13085547f, -0.08768158f, 0.09169919f, 
    0.06290998f, -0.02606802f, -0.08762685f, 0.09776703f, 0.05616772f, -0.03277436f, -0.01741936f, -0.05551397f, 
    0.20101310f, -0.04521341f, 0.12325728f, 0.14881034f, 0.19393191f, 0.09307243f, 0.05750278f, -0.09212178f, 
    -0.17786196f, 0.01368462f, 0.02341307f, -0.07590027f, 0.01246933f, -0.24437778f, -0.07490412f, 0.06503775f, 
    -0.12296497f, -0.11385395f, -0.04331524f, -0.12549962f, 0.00595651f, -0.07305554f, -0.03680660f, 0.00404605f, 
    -0.22302032f, -0.02022251f, -0.13966413f, -0.21922484f, -0.00226399f, -0.04174198f, -0.05125860f, -0.09810065f, 
    -0.10062493f, -0.01173896f, -0.07766689f, -0.14163178f, 0.17758098f, -0.15938868f, 0.21392456f, -0.04756444f, 
    0.03293021f, -0.07601243f, -0.05777073f, -0.09960496f, 0.07130936f, 0.02647276f, 0.07936354f, -0.09876319f, 
    -0.05059831f, -0.04851536f, 0.05860940f, -0.05668118f, -0.14060454f, 0.06389186f, -0.07701667f, 0.02589702f, 
    -0.12832892f, -0.00979479f, -0.03559679f, 0.06154915f, -0.38800597f, 0.14268602f, -0.01090303f, -0.08250464f, 
    0.09382363f, -0.01826769f, -0.09782381f, -0.05670063f, -0.14195248f, -0.04848959f, -0.01705979f, -0.06484749f, 
    0.03427470f, -0.01758098f, -0.14743763f, 0.04005456f, -0.01416348f, -0.02958681f, -0.03324818f, 0.03461065f, 
    -0.14678413f, 0.17388578f, -0.00143338f, -0.03297637f, 0.05951125f, -0.28580281f, 0.17733073f, 0.23075876f, 
    0.05628369f, -0.02054542f, -0.06675114f, -0.02043145f, -0.08535504f, 0.01613113f, -0.04702760f, -0.09383214f, 
    -0.12778784f, -0.09204475f, -0.08621717f, -0.21051016f, -0.19697599f, 0.04476664f, -0.02973129f, -0.10700092f, 
    -0.05068350f, -0.05703925f, -0.05718651f, -0.15095460f, -0.32499248f, 0.11017455f, -0.06135201f, -0.10447818f, 
    -0.20054448f, -0.04091492f, 0.04502784f, -0.04985179f, -0.02856617f, -0.00836163f, 0.01650804f, -0.05732197f, 
    0.13861182f, 0.21652833f, 0.01420357f, 0.16156501f, 0.05725487f, -0.05075742f, -0.02170593f, 0.12878048f, 
    -0.06392474f, 0.02716875f, -0.03160989f, -0.07218394f, -0.11756663f, 0.40158844f, 0.12523898f, 0.19247548f, 
    -0.04474963f, -0.04289254f, -0.03240815f, -0.00771610f, 0.08368290f, 0.02596080f, -0.09197568f, -0.12192600f, 
    -0.18806422f, 0.18515700f, -0.02160987f, 0.14400299f, 0.22437580f, -0.02083103f, 0.05045684f, 0.05174896f, 
    -0.10717946f, 0.01744312f, 0.08203563f, -0.02402201f, 0.20475303f, 0.20513923f, -0.16550539f, 0.24952748f, 
    -0.12147377f, 0.03961267f, -0.07192669f, -0.06191517f, -0.02636181f, 0.12416971f, -0.06314526f, -0.09843270f, 
    0.08059333f, 0.10059028f, 0.10937958f, 0.09047109f, -0.08719279f, -0.04384389f, 0.00713571f, -0.06671128f, 
    -0.10209543f, -0.02187891f, -0.01211422f, -0.04750382f, -0.34161755f, 0.19249459f, -0.05357245f, -0.02427993f, 
    -0.03770461f, -0.15088767f, -0.10690884f, -0.03903140f, -0.11986540f, -0.00081998f, 0.00748986f, 0.01238422f, 
    0.32728675f, 0.25873250f, 0.23833095f, 0.20864078f, 0.19661964f, 0.08918974f, 0.03771424f, -0.12195877f, 
    -0.12439256f, 0.06242784f, -0.12709935f, -0.03928702f, -0.28027612f, -0.06553103f, 0.00850966f, -0.30147016f, 
    0.09071954f, -0.03703232f, 0.00256596f, -0.03644562f, 0.04362177f, 0.02386661f, -0.03418437f, -0.01971605f, 
    0.18674625f, -0.15677577f, -0.01108444f, -0.06713748f, -0.03211117f, -0.09248050f, -0.15589324f, -0.06184085f, 
    -0.06580406f, -0.00943635f, -0.01221061f, -0.09913421f, 0.26956233f, -0.17003834f, 0.27093816f, 0.31170732f, 
    0.09217866f, -0.03664622f, 0.09342032f, -0.04106211f, -0.15102859f, -0.08566225f, -0.01043934f, -0.02398304f, 
    0.24328539f, 0.20385472f, 0.01729967f, 0.33522108f, 0.20309897f, -0.01175901f, 0.03181716f, 0.02949221f, 
    -0.03850346f, -0.08640002f, 0.00470079f, -0.04819291f, -0.77383882f, 0.18394810f, -0.17098030f, -0.05920283f, 
    -0.01030724f, -0.06266116f, -0.01916339f, -0.03894137f, -0.10997404f, 0.12877743f, -0.06189495f, -0.02786575f, 
    -0.05560192f, -0.18081219f, -0.28197616f, -0.17863531f, 0.05004770f, -0.14753687f, 0.02156055f, -0.08025436f, 
    -0.19410063f, 0.08860691f, 0.11357950f, 0.06028976f, -0.00908403f, 0.16851828f, 0.04864230f, -0.18002640f, 
    -0.03463297f, 0.08738646f, -0.25183675f, 0.01375971f, -0.12436156f, 0.04899155f, -0.05911409f, 0.04217112f, 
    0.09112287f, 0.26713005f, -0.31093732f, -0.07694038f, 0.12681709f, 0.08060779f, -0.16669098f, -0.02641515f, 
    0.09086389f, -0.11155678f, -0.01557916f, -0.14808317f, 0.07411299f, -0.18856360f, 0.06689460f, 0.18628731f, 
    -0.20599002f, 0.00768056f, -0.00422732f, -0.27395684f, 0.04282505f, -0.04442061f, -0.01467688f, -0.14848502f, 
    -0.09040752f, 0.04739455f, -0.29855797f, 0.02932245f, -0.05576331f, 0.08092872f, 0.01050247f, -0.05568217f, 
    0.20206422f, 0.02115162f, -0.01711164f, -0.14867885f, 0.09898527f, -0.21373035f, 0.12355797f, 0.10579091f, 
    -0.17457889f, -0.01700817f, 0.26450515f, -0.00547389f, 0.08715868f, -0.14065081f, 0.01894080f, -0.03371885f, 
    -0.22574280f, 0.08747128f, -0.15417466f, -0.21891901f, 0.03181442f, 0.08540999f, -0.21850167f, 0.16950044f, 
    0.02474429f, -0.03556065f, 0.12181541f, 0.10886373f, 0.10493044f, -0.27701446f, 0.14896154f, 0.12174022f, 
    0.00357703f, -0.05594859f, -0.11396806f, -0.07945062f, 0.14643957f, 0.01072063f, -0.06113174f, -0.18646504f, 
    0.10507805f, 0.37806696f, -0.06193466f, 0.01262186f, -0.07285610f, 0.01752151f, -0.09113470f, -0.30260161f, 
    -0.01527710f, 0.03621692f, 0.02312589f, 0.07276770f, -0.02646136f, 0.34596971f, -0.30733308f, 0.08397359f, 
    0.02176999f, 0.11500116f, -0.25431120f, -0.07836723f, -0.01882311f, -0.03012669f, -0.04549417f, 0.09782650f, 
    -0.04716475f, -0.42120600f, 0.05882156f, -0.12706795f, 0.00286327f, 0.02863988f, -0.11954227f, 0.21775588f, 
    -0.01021976f, -0.06059653f, -0.00935047f, 0.00574285f, -0.26561126f, -0.05142756f, -0.30339262f, -0.12149129f, 
    -0.17021731f, 0.01684992f, 0.00720232f, -0.01701559f, 0.03896244f, 0.03696324f, -0.02491783f, -0.07966445f, 
    0.26174179f, -0.02127917f, 0.06396418f, 0.15526569f, 0.03267806f, 0.00358296f, -0.07768069f, -0.05735758f, 
    -0.01021921f, 0.07716949f, -0.06022009f, -0.07659525f, -0.12693559f, -0.18429874f, 0.14773254f, -0.19360873f, 
    -0.04462871f, -0.13071178f, -0.24921040f, 0.10585769f, 0.02755781f, -0.05165255f, -0.03037483f, 0.20500368f, 
    -0.10718474f, 0.05193914f, -0.03461267f, -0.15762305f, 0.06657628f, 0.09552708f, -0.03790884f, 0.06622054f, 
    0.03963263f, 0.05409164f, -0.09982730f, 0.13353574f, -0.09721144f, 0.01916028f, 0.09270023f, 0.05181322f, 
    0.02242853f, 0.04451312f, 0.00160333f, 0.04618635f, 0.11040190f, 0.02415509f, -0.23848884f, -0.11171857f, 
    0.05177419f, -0.25212517f, 0.00708618f, -0.08268729f, -0.03915314f, -0.04089236f, 0.12791568f, -0.01915146f, 
    -0.05211129f, 0.10636915f, 0.15460707f, 0.06933157f, -0.36986518f, -0.05592843f, -0.20361462f, -0.28354862f, 
    -0.02694967f, -0.08368571f, -0.10164695f, -0.07376106f, 0.09190910f, -0.05852572f, 0.09132949f, 0.09468026f, 
    0.20901202f, 0.08786391f, 0.04712625f, 0.36814120f, 0.19602677f, -0.11037592f, -0.06335458f, -0.16262186f, 
    -0.01416201f, -0.00298610f, 0.12409806f, -0.18096699f, 0.29069954f, 0.01320966f, -0.06727453f, 0.06211725f, 
    0.01914347f, 0.00373116f, -0.05539637f, -0.05156493f, 0.00308919f, -0.09504727f, -0.08013716f, -0.03389019f, 
    -0.20194615f, 0.23662668f, -0.03027019f, -0.16016240f, -0.02506458f, 0.12353180f, -0.12118963f, 0.07265285f, 
    0.10818004f, -0.12366805f, 0.02522285f, 0.06118149f, 0.09750230f, 0.34409928f, -0.14927082f, 0.08509523f, 
    -0.05599003f, 0.15243672f, -0.03834730f, -0.03364168f, 0.04104831f, 0.01449050f, -0.05370803f, 0.06201531f, 
    -0.27092999f, -0.12902200f, 0.10062481f, -0.01210552f, 0.02328011f, -0.16019680f, -0.00708366f, -0.15407795f, 
    0.00148810f, -0.00525382f, 0.08524148f, 0.02633875f, -0.29776847f, 0.20367247f, -0.26525801f, -0.25236642f, 
    -0.10566691f, 0.00960321f, -0.13218240f, 0.13436288f, 0.17407227f, -0.13005248f, 0.21074653f, 0.11761147f, 
    0.00146305f, 0.27938658f, -0.24526706f, -0.04000477f, 0.17092478f, 0.14069739f, -0.12900099f, -0.02838581f, 
    -0.07883158f, 0.10518247f, 0.02953866f, 0.15499598f, 0.05719092f, 0.00580301f, -0.15155292f, -0.02234666f, 
    -0.02329247f, -0.01350193f, -0.06627537f, 0.07677998f, -0.02774099f, 0.00334042f, 0.17621769f, 0.16479191f, 
    -0.30246380f, 0.13327155f, 0.22479309f, 0.01687392f, -0.06355713f, -0.00824363f, -0.06662348f, -0.03005873f, 
    -0.07252820f, 0.02126177f, -0.05573129f, -0.13268246f, 0.10603671f, 0.05932632f, -0.10010143f, 0.15209368f, 
    0.12813452f, 0.02843054f, -0.16103464f, 0.03684399f, 0.03744445f, -0.08623962f, 0.15108122f, 0.09259746f, 
    0.08154582f, -0.08155799f, -0.12377034f, -0.03929546f, 0.24037538f, -0.16658488f, 0.00518662f, -0.04606409f, 
    0.04392141f, -0.05310866f, -0.09808127f, 0.20243344f, 0.31899121f, -0.19004934f, -0.58906275f, -0.12099902f, 
    0.06832188f, -0.05818490f, 0.07240298f, -0.14365506f, -0.07037547f, -0.02878879f, -0.05300741f, 0.13288547f, 
    -0.08840721f, -0.08643575f, -0.22632751f, -0.39771411f, 0.08111956f, -0.28542048f, -0.07439996f, -0.04337384f, 
    0.25711611f, -0.03051294f, -0.12591147f, -0.11827505f, -0.04261975f, -0.20453821f, -0.08744860f, 0.15681151f, 
    0.14766486f, 0.14438623f, -0.05139771f, -0.02707406f, -0.00554182f, -0.12140389f, 0.18034227f, 0.15748511f, 
    -0.24130203f, -0.21835934f, -0.08723689f, 0.11072797f, 0.09609044f, 0.06981339f, -0.08657476f, 0.00679932f, 
    0.11334544f, -0.00605738f, 0.12334103f, -0.02659945f, -0.22626695f, -0.24399227f, -0.06604293f, 0.11606010f, 
    0.10596820f, -0.18064517f, -0.15102530f, 0.06249291f, 0.12008425f, 0.14800149f, 0.00346027f, -0.18818103f, 
    0.06358653f, -0.24789728f, 0.33793032f, 0.03270282f, -0.18974042f, 0.15107714f, -0.07100840f, 0.15063117f, 
    0.03292287f, 0.02935895f, 0.13590762f, 0.06487306f, 0.56438106f, -0.30683643f, -0.15562709f, 0.17154524f, 
    0.08229405f, 0.00677043f, -0.10689835f, -0.00473311f, -0.01548553f, 0.02023077f, 0.01837547f, -0.07570309f, 
    -0.01724287f, -0.19753434f, -0.13933720f, -0.17919405f, 0.08440747f, 0.00335543f, -0.02438639f, 0.13948743f, 
    0.05085151f, 0.01330253f, 0.10219478f, 0.11979911f, -0.37542155f, -0.31397212f, 0.11832868f, -0.08968607f, 
    0.22082305f, -0.03547426f, -0.09868538f, -0.12030419f, 0.08361772f, 0.03100831f, 0.19884144f, 0.23197755f, 
    0.02229681f, -0.19422992f, 0.05483951f, -0.34542981f, -0.12265320f, 0.15010898f, -0.04332663f, 0.10827930f, 
    -0.01163451f, 0.02991389f, -0.07671952f, -0.11490965f, -0.14682852f, -0.02052386f, -0.18538876f, -0.14341943f, 
    -0.03971015f, -0.07848512f, -0.01059928f, -0.03094210f, -0.02985907f, -0.07983287f, 0.12370500f, 0.06901692f, 
    0.86264104f, -0.02367989f, -0.29901525f, -0.08778544f, 0.04464267f, -0.01613601f, 0.00231948f, 0.09289459f, 
    0.05916633f, -0.04232426f, 0.14689982f, 0.09945933f, 0.09309145f, 0.09004808f, 0.30626714f, 0.11900421f, 
    -0.02001414f, 0.08187727f, 0.06381401f, 0.05452665f, 0.07390022f, 0.04271631f, 0.01359716f, -0.01299652f, 
    0.30649924f, -0.17659245f, -0.04111139f, -0.35269508f, -0.26354206f, 0.16000660f, 0.04659967f, -0.05985706f, 
    -0.05310453f, -0.07629972f, -0.15476596f, 0.05652819f, 0.02037074f, -0.24089830f, 0.19670662f, -0.35901397f, 
    0.09665769f, 0.10105097f, 0.01336711f, -0.04084932f, 0.05205783f, 0.00033735f, 0.02466118f, -0.12687869f, 
    -0.15764694f, 0.27927557f, -0.37608957f, 0.01875427f, 0.05067629f, 0.17859362f, -0.00486706f, -0.17369600f, 
    -0.03480837f, -0.04231736f, 0.04293465f, -0.03696126f, -0.11738676f, 0.00461123f, -0.08194093f, 0.26780698f, 
    -0.16488394f, 0.11577678f, 0.06280860f, -0.15744857f, 0.11874089f, -0.16190328f, 0.00318934f, -0.22128779f, 
    0.06686968f, -0.08504111f, -0.22116603f, -0.14115518f, -0.02472226f, -0.03827402f, 0.06170035f, 0.01525151f, 
    -0.23817949f, -0.15794462f, -0.02783962f, -0.05082006f, -0.70535380f, 0.43742883f, -0.12823899f, -0.04587621f, 
    0.07104192f, 0.11138761f, -0.02043517f, 0.14401691f, 0.05069277f, -0.08697087f, 0.17195518f, 0.15802996f, 
    0.01735319f, 0.40534866f, -0.24494784f, -0.60822982f, 0.05451882f, 0.08148526f, -0.08317606f, 0.19930598f, 
    -0.07124182f, -0.00392363f, 0.11473329f, -0.15542765f, 0.34818152f, -0.28516611f, -0.03055587f, 0.22908117f, 
    -0.18487257f, -0.02630462f, 0.20416039f, 0.24692665f, -0.01366934f, -0.05486767f, -0.00526399f, -0.00036934f, 
    -0.09382487f, -0.11410125f, -0.14237641f, -0.26343250f, 0.03832739f, 0.05317173f, 0.04449731f, 0.12044340f, 
    -0.04371411f, -0.03424855f, -0.14625318f, 0.13885134f, 0.28472027f, 0.24042112f, 0.26769698f, -0.07234511f, 
    0.07801162f, -0.08271357f, -0.05374397f, -0.06068841f, 0.08059781f, 0.07742715f, 0.00942493f, 0.00298989f, 
    -0.33002135f, 0.12935199f, 0.21402949f, -0.04931897f, 0.10461236f, -0.00220992f, -0.03128670f, 0.02106115f, 
    0.10575030f, 0.07813946f, 0.10013910f, 0.05820500f, -0.31486663f, 0.06868790f, 0.21018028f, 0.14285219f, 
    0.14357100f, -0.00979485f, -0.08022965f, 0.11523781f, -0.02009772f, 0.08818129f, 0.11289290f, 0.13929678f, 
    -0.12175927f, -0.37134612f, 0.06958117f, -0.08709235f, -0.08277652f, 0.06033480f, 0.12922731f, 0.22927570f, 
    -0.03998284f, -0.19149143f, -0.13920674f, 0.00749412f, -0.27735958f, 0.23347478f, 0.06111081f, 0.10411109f, 
    -0.19627291f, 0.11978267f, -0.27600890f, 0.05666125f, -0.10600401f, 0.16423319f, -0.18746777f, -0.06450462f, 
    0.04919431f, -0.31271794f, 0.12920818f, 0.05670032f, -0.06680818f, 0.07162876f, -0.15705754f, 0.01256995f, 
    -0.12198728f, 0.03367589f, 0.03054973f, -0.02531571f, -0.10786555f, 0.24348532f, 0.15165174f, -0.06621335f, 
    -0.01126274f, -0.07357525f, -0.02096436f, -0.13032334f, -0.04806117f, -0.14744522f, -0.12486064f, -0.00362290f, 
    -0.26773036f, -0.17827860f, -0.05763315f, -0.19404213f, 0.09091278f, -0.02975697f, 0.04239538f, 0.01814558f, 
    -0.09502543f, -0.06119549f, 0.00022578f, -0.04622050f, -0.04779005f, -0.05102887f, 0.21402076f, -0.03199205f, 
    -0.01617617f, -0.02322376f, -0.05697737f, 0.09953826f, 0.09085574f, 0.04578094f, -0.06936807f, -0.13850501f, 
    -0.08571188f, -0.07434702f, 0.38224086f, -0.07666922f, 0.05036113f, -0.00195163f, -0.25811684f, 0.00196861f, 
    0.23893102f, -0.06195737f, 0.11430777f, -0.20277494f, 0.19200107f, -0.20856473f, 0.28807306f, -0.06423553f, 
    -0.01365787f, -0.07904992f, -0.13747150f, -0.12672423f, 0.00461126f, 0.15720934f, 0.11262649f, 0.10191125f, 
    -0.35759321f, -0.44638321f, 0.01713445f, 0.17162666f, -0.07365948f, 0.15969579f, -0.14106233f, -0.01742645f, 
    -0.10431072f, -0.13480669f, 0.00273926f, -0.13854203f, -0.28721464f, 0.48638812f, 0.03943737f, -0.52449954f, 
    0.16661733f, -0.06469704f, -0.06141898f, 0.07309233f, -0.03827714f, 0.03341949f, -0.10280678f, -0.33735099f, 
    0.11208057f, -0.31601056f, 0.20804432f, -0.17281345f, 0.03429886f, 0.17986381f, -0.15145203f, -0.05439158f, 
    -0.19194981f, -0.05753306f, -0.02019804f, -0.03569601f, 0.02277976f, -0.10547217f, 0.06054986f, 0.11231730f, 
    -0.05170362f, -0.03010051f, -0.02100140f, -0.16723168f, 0.00292393f, 0.02363281f, -0.03904175f, -0.04447804f, 
    -0.00043456f, -0.08869087f, 0.10692368f, -0.07021682f, 0.05958099f, 0.10667907f, 0.00468019f, -0.05057633f, 
    0.00479566f, -0.07696734f, -0.21188578f, -0.06257953f, 0.29562286f, 0.17393070f, -0.12906419f, 0.20995227f, 
    -0.13214673f, -0.14427423f, -0.06788948f, 0.00499792f, -0.11952560f, -0.15366381f, -0.12784843f, -0.04652123f, 
    0.06012124f, 0.17370068f, -0.15774210f, -0.06468245f, 0.06488983f, 0.07497112f, 0.14502029f, 0.11716022f, 
    0.21116951f, 0.02955583f, 0.01871078f, -0.14364617f, -0.01857559f, 0.10838368f, -0.18981640f, 0.00552490f, 
    -0.25998291f, -0.07692806f, 0.10486591f, -0.09490547f, -0.02999692f, 0.10846125f, -0.02531924f, 0.00504447f, 
    0.24390630f, 0.12159337f, -0.00372539f, -0.10310192f, 0.12762727f, 0.11169361f, -0.01474725f, 0.05301639f, 
    -0.02795157f, -0.05572038f, -0.01311939f, 0.06268728f, -0.48290378f, 0.23556411f, -0.19614863f, -0.35368297f, 
    0.16060048f, -0.00575535f, -0.12640513f, 0.13170736f, 0.13408042f, -0.07383350f, 0.02877153f, 0.02125798f, 
    -0.55385149f, -0.18351409f, 0.16432464f, -0.07415945f, 0.09255464f, -0.07374097f, 0.00863219f, -0.06186794f, 
    0.11126630f, 0.14189060f, 0.04391212f, 0.08879201f, -0.18464965f, -0.15843078f, -0.07315423f, 0.04933708f, 
    0.08796307f, 0.01654438f, -0.03344554f, -0.11648834f, -0.03626340f, 0.07176715f, -0.13729995f, -0.07519232f, 
    0.09167752f, 0.06726547f, 0.10185000f, 0.16417034f, 0.22168042f, -0.15929255f, -0.16011657f, -0.06322876f, 
    -0.05898077f, 0.01584203f, -0.01402436f, -0.07302486f, 0.36007720f, 0.20440549f, 0.11679211f, -0.16590720f, 
    0.04039826f, 0.00586493f, 0.11976337f, 0.12354089f, 0.07131024f, -0.03884872f, -0.07346417f, 0.13509387f, 
    -0.51275837f, -0.23501959f, -0.17207006f, -0.12664028f, 0.03841528f, 0.00997198f, -0.06145499f, 0.00691908f, 
    -0.00154839f, 0.00031202f, 0.07964412f, 0.07869795f, 0.22698289f, 0.23317905f, 0.01988692f, -0.00214246f, 
    0.19646260f, 0.13256203f, 0.08071231f, 0.14994372f, -0.09175530f, 0.19647548f, 0.16476230f, 0.20962745f, 
    -0.03160662f, -0.31141537f, 0.00984979f, -0.11655483f, 0.10346451f, -0.14385816f, 0.07808135f, 0.14967716f, 
    0.07200559f, 0.18989325f, 0.06657684f, 0.16394246f, -0.39943159f, -0.50903136f, 0.07443311f, 0.08306807f, 
    0.04661937f, 0.03695590f, 0.13947514f, -0.01690698f, 0.12948124f, -0.05968301f, -0.13998295f, 0.09210704f, 
    -0.14513710f, -0.28121233f, 0.12114076f, 0.32596359f, 0.02610594f, -0.17439213f, -0.11352564f, -0.17804523f, 
    -0.12159256f, -0.04239812f, -0.01374792f, -0.03114079f, 0.27816433f, 0.02832092f, 0.02919070f, 0.03661832f, 
    0.05181154f, 0.19922669f, 0.04667785f, 0.03517007f, -0.05081338f, -0.01994509f, 0.05920986f, 0.14683457f, 
    -0.52586520f, -0.23815829f, -0.30270520f, -0.23865810f, 0.03640386f, -0.00793848f, -0.20501085f, 0.00747937f, 
    0.07477250f, 0.01857125f, -0.11637404f, -0.11192450f, -0.57024723f, -0.35080618f, -0.02503462f, -0.04653555f, 
    0.04689478f, 0.11550788f, 0.14273654f, -0.01492081f, 0.18521580f, -0.06339805f, -0.06376902f, 0.23665641f, 
    0.00851732f, 0.14076509f, 0.00374730f, -0.14351410f, 0.00721227f, -0.20155331f, -0.03029337f, 0.10049740f, 
    0.02704541f, -0.10241675f, -0.05659098f, -0.11183815f, 0.19225369f, -0.04919916f, -0.15669720f, -0.01069226f, 
    -0.20388228f, -0.10898387f, 0.04175193f, 0.00594947f, 0.15581508f, -0.08533198f, 0.07355008f, -0.17547829f, 
    0.03640217f, 0.01423056f, -0.07101931f, -0.05757098f, -0.08565842f, 0.04200471f, 0.19349447f, -0.18296538f, 
    -0.23215695f, -0.08367207f, 0.01924889f, -0.00315172f, -0.56106746f, -0.36137068f, 0.30793071f, 0.07256351f, 
    0.03852678f, 0.17850786f, 0.07807569f, -0.14555208f, 0.05371120f, -0.12577876f, -0.01823581f, -0.06555074f, 
    0.12177554f, 0.06957324f, -0.10006998f, 0.06603637f, 0.05656475f, 0.20260841f, -0.03778598f, 0.07657602f, 
    0.11582071f, 0.14404646f, 0.08462790f, 0.01929255f, 0.17166163f, -0.24703486f, -0.10955026f, 0.07578711f, 
    0.12760389f, 0.16137813f, -0.11033525f, 0.14328413f, 0.13519819f, 0.21018931f, 0.06885082f, 0.06154222f, 
    0.38449857f, 0.14329256f, 0.01459477f, -0.06622406f, -0.14531827f, 0.04099020f, -0.02347533f, -0.00004302f, 
    0.08134847f, -0.09033819f, -0.05275513f, -0.00508953f, -0.43629438f, -0.02122888f, -0.19765718f, -0.17212044f, 
    0.15329203f, 0.00675758f, -0.10664432f, 0.07191715f, 0.00286340f, 0.14185993f, 0.16230874f, 0.14423490f, 
    0.11817659f, 0.11252210f, 0.22693202f, 0.12596323f, 0.06366077f, -0.05313592f, 0.07786568f, -0.08030269f, 
    -0.01457721f, 0.07401041f, 0.14376861f, 0.11863237f, -0.38071832f, 0.08471987f, -0.01289638f, -0.03427243f, 
    -0.04149015f, 0.02247600f, -0.11335044f, 0.03160152f, -0.08359209f, -0.08198880f, -0.19628839f, -0.18401869f, 
    -0.17066465f, -0.16902325f, -0.01109265f, 0.11948971f, 0.17794719f, 0.03200665f, 0.09365152f, -0.04734495f, 
    -0.01155778f, 0.10256282f, -0.13357328f, -0.10122225f, -0.63280976f, -0.58486217f, -0.12506393f, -0.37172133f, 
    0.03273453f, -0.02371913f, -0.04811757f, -0.13240102f, 0.03163087f, 0.09179946f, 0.11747232f, 0.10904860f, 
    -0.78695935f, 0.09769955f, 0.12815624f, -0.15374793f, 0.04834674f, 0.14932342f, -0.06929304f, 0.04335538f, 
    -0.01770461f, 0.04617451f, -0.11012293f, 0.15978582f, -0.47694176f, -0.25253871f, -0.10556591f, 0.08178790f, 
    0.11936271f, -0.05292301f, -0.11718582f, 0.12261984f, 0.05156688f, 0.08763653f, 0.07318958f, 0.05168680f, 
    0.07392674f, -0.09744126f, -0.19184583f, 0.18775536f, 0.19902647f, 0.06396338f, 0.02063538f, 0.08759717f, 
    0.11020248f, 0.05381498f, 0.09009258f, -0.02938056f, -0.42474821f, -0.10361352f, 0.15866396f, 0.03156406f, 
    0.00480100f, -0.04998329f, 0.01063401f, 0.10230782f, -0.10788874f, 0.03434173f, 0.21268156f, 0.07588284f, 
    0.08711409f, -0.05159341f, -0.22430395f, 0.20421907f, -0.11953792f, -0.11100824f, 0.06302843f, 0.01171190f, 
    -0.00775824f, -0.02387290f, 0.17500764f, -0.00392150f, -0.47068691f, -0.24618499f, -0.05010895f, 0.03370609f, 
    -0.21393263f, 0.19518207f, -0.14511031f, 0.13038479f, -0.04078184f, 0.18084544f, -0.08360995f, 0.02629995f, 
    0.22037183f, -0.11789492f, -0.15492815f, 0.43107218f, 0.09558144f, -0.03687971f, 0.06886268f, 0.08863158f, 
    0.11753551f, -0.01830213f, -0.06026611f, -0.05449695f, -0.27855307f, -0.09828241f, 0.06108952f, -0.09438214f, 
    0.00093648f, -0.00750941f, -0.05112195f, 0.10593466f, 0.00868836f, -0.09618525f, 0.03182632f, 0.16479592f, 
    -0.26768705f, -0.48387095f, -0.21484795f, 0.02467795f, -0.00237111f, -0.11885324f, -0.00889997f, 0.18264560f, 
    -0.10505728f, -0.07175243f, 0.05412735f, -0.12829702f, 0.05349812f, 0.06542908f, 0.07153106f, 0.12673417f, 
    0.01574152f, 0.05600623f, -0.08092690f, -0.11262567f, 0.21181397f, 0.05469175f, -0.02992388f, 0.11043502f, 
    -0.09802246f, -0.00064394f, 0.06196943f, -0.40319830f, 0.15131652f, 0.04696548f, -0.10186040f, -0.05735279f, 
    0.07784574f, -0.15545268f, 0.11236025f, 0.07116447f, 0.14028558f, 0.00455741f, -0.39116684f, 0.19669360f, 
    0.06389464f, -0.22129396f, -0.09545691f, 0.28783807f, 0.02159758f, 0.02556147f, 0.02459064f, -0.11303874f, 
    0.07337965f, -0.05905056f, -0.15866227f, -0.33388168f, 0.05864740f, -0.07911377f, 0.05956065f, 0.00933735f, 
    0.05702631f, 0.01526159f, -0.02146178f, -0.11691315f, -0.36233225f, 0.38132879f, 0.02227465f, -0.11275117f, 
    -0.05509800f, -0.10165220f, 0.06145160f, -0.16059043f, -0.05026834f, -0.12820201f, -0.20502482f, -0.05679090f, 
    -0.00379218f, -0.10336009f, 0.22792202f, 0.03952093f, 0.09056508f, -0.10805507f, -0.23937577f, 0.10128672f, 
    -0.05069020f, -0.25083703f, 0.00381885f, -0.18867728f, -0.17084378f, -0.11493502f, 0.12756103f, 0.09538659f, 
    0.20010464f, -0.01737666f, 0.10043257f, 0.00452433f, 0.11034858f, 0.05397068f, 0.11224352f, 0.13322069f, 
    0.15801439f, -0.30613080f, 0.05019715f, 0.08261184f, 0.17032619f, -0.00122179f, 0.06583291f, -0.07001366f, 
    0.00701862f, 0.00560198f, -0.04352620f, 0.17744385f, -0.47598815f, 0.15099612f, -0.09345004f, 0.05541486f, 
    0.00090638f, -0.03285075f, -0.03704191f, -0.01316625f, -0.04081023f, 0.04176660f, 0.06174419f, -0.02912930f, 
    -0.16668805f, -0.12701371f, -0.32242629f, -0.40358710f, 0.12820238f, -0.10873462f, -0.01760253f, -0.04165714f, 
    0.06908838f, -0.04732667f, -0.11390419f, -0.01736629f, 0.02860181f, -0.25790951f, -0.00012448f, -0.24826671f, 
    0.10200617f, -0.04220497f, -0.14303628f, 0.16380647f, -0.01977556f, 0.13116327f, 0.06924491f, -0.02235482f, 
    0.07665462f, -0.49641588f, -0.10740055f, 0.03986753f, -0.08084851f, 0.08264528f, 0.00869417f, -0.11787181f, 
    0.01052069f, 0.13031872f, -0.02413823f, 0.07510596f, 0.16585846f, -0.10966019f, -0.06589118f, 0.03986514f, 
    -0.11576428f, -0.08905505f, 0.04062555f, -0.02916689f, -0.03401488f, 0.04009603f, -0.04769376f, -0.08426727f, 
    0.39567515f, -0.07760388f, -0.09306004f, 0.08534575f, -0.04176661f, 0.10749707f, 0.09387853f, 0.12738264f, 
    0.02062752f, 0.00891724f, -0.12051567f, -0.13925025f, 0.07201891f, 0.51499265f, -0.21458155f, -0.08916921f, 
    0.01052574f, -0.13716692f, -0.26238102f, -0.17632601f, -0.01903415f, 0.18313627f, -0.00641639f, 0.16093087f, 
    0.15029857f, 0.16542043f, -0.00329193f, 0.12037002f, 0.07562197f, 0.18583915f, 0.10968548f, -0.19447193f, 
    -0.03903560f, -0.01693074f, -0.02745480f, -0.11772697f, 0.27823275f, -0.03192909f, -0.22445580f, 0.15010427f, 
    0.17461009f, -0.12256765f, 0.04053896f, 0.19493544f, -0.06880469f, 0.04053022f, -0.23329560f, 0.02721800f, 
    -0.14625126f, 0.28028563f, -0.06050204f, 0.16650115f, -0.13435684f, -0.08028881f, -0.09332774f, -0.16753583f, 
    0.03152400f, 0.04857184f, -0.06622402f, -0.09564330f, 0.27675527f, -0.08832949f, -0.07057358f, -0.34918952f, 
    0.01080211f, 0.11830474f, 0.07887040f, 0.05582006f, -0.09250040f, -0.08682879f, -0.18432529f, -0.02637711f, 
    0.15477629f, 0.10840205f, -0.02013891f, -0.02781035f, -0.00975618f, -0.01141045f, 0.05550614f, 0.00817614f, 
    -0.05101981f, -0.11107689f, -0.01666776f, -0.00831162f, 0.55297810f, 0.00960068f, -0.13994966f, 0.22656935f, 
    -0.12220531f, -0.07235200f, -0.06951375f, 0.03020718f, 0.14815187f, 0.00538030f, 0.18344414f, 0.03008469f, 
    -0.05794992f, -0.05685626f, -0.09141189f, 0.17539589f, -0.19233216f, 0.01848511f, -0.18239738f, -0.17558788f, 
    -0.02234814f, -0.00825035f, -0.02185098f, -0.12624276f, 0.28216147f, -0.05594106f, -0.21463124f, 0.01399495f, 
    0.08219282f, -0.09648694f, 0.09101723f, -0.14212124f, -0.06180351f, 0.04155593f, -0.03381209f, -0.11616158f, 
    0.58734363f, 0.14405456f, -0.29602224f, -0.26276168f, -0.24373159f, -0.15937027f, 0.00577186f, 0.00636263f, 
    0.13760422f, -0.10459384f, -0.09414495f, 0.10567237f, -0.15522866f, 0.37387148f, -0.23832424f, 0.20494103f, 
    0.00945537f, 0.09371249f, 0.02590429f, -0.01422253f, 0.08250827f, -0.07941742f, -0.03776560f, 0.04907833f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10949492f, 0.04222287f, -0.06040979f, 0.05414405f, 0.04325263f, -0.01816866f, 0.02584976f, -0.04531221f, 
    -0.08735590f, 0.04092923f, 0.10668973f, 0.02865109f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
