#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.79377383f, -0.49468455f, -0.49635488f, 1.08577788f, 0.05644326f, 0.39607248f, -0.22720927f, -0.12349042f, 
    0.41823837f, -0.16915508f, -0.59087938f, -0.94921327f, 0.34612033f, 0.63275760f, 0.35362020f, -0.13855666f, 
    -0.37831122f, -0.67485076f, 0.90629160f, -0.52192092f, -0.36178911f, -0.32616103f, -0.44733757f, -0.23697238f, 
    -0.54843348f, 0.13240975f, -0.61195320f, -0.34718236f, -0.08287624f, 0.67373407f, -0.10725851f, 0.30819085f, 
    -0.01723646f, -0.23572111f, -0.54218233f, 0.93733209f, -0.20792112f, -0.26349428f, 0.19358902f, -0.27020878f, 
    -0.78218383f, -0.74074376f, 0.05378342f, 0.72863686f, 0.44889536f, 0.94745797f, -0.29122230f, -0.45430195f, 
    -0.56569833f, 0.04214675f, 0.81586069f, -0.05517308f, 0.11913590f, 0.27431983f, -0.28464630f, -0.19157110f, 
    -0.25648415f, 0.01365797f, -0.88507175f, -0.85669065f, -0.20831126f, -0.46715018f, 0.41063976f, 0.42539245f, 
    0.16654383f, 0.11827973f, 0.03190444f, 0.27265143f, 0.19550699f, 0.55823994f, 0.48155066f, 0.21043821f, 
    -0.98303890f, -0.67398405f, -0.34321654f, -0.44479364f, -0.29003274f, -0.41442508f, 0.12508637f, -0.28619280f, 
    -0.51525474f, 0.31695485f, 0.40085149f, 0.60703087f, -0.48438078f, 0.54441440f, -0.32354820f, -0.13175528f, 
    -0.77452224f, -0.71309036f, 0.24233748f, -0.09702997f, -0.27095249f, -0.61020505f, 1.33064795f, -0.84474897f, 
    0.14814106f, 0.05888270f, 0.18124060f, 0.05022448f, -0.04720699f, -0.20556870f, -0.54782963f, -0.46226814f, 
    -0.43917564f, 0.12434555f, 0.02088749f, 0.92871034f, 0.94641459f, 1.13407969f, 0.54702109f, -0.50749308f, 
    -0.36961326f, -0.08177882f, 0.13785435f, -0.13002165f, -0.19349205f, 0.87004727f, 0.93866825f, -0.81574166f, 
    -0.06586238f, -0.38378945f, -0.21164028f, -0.08977823f, 0.41274074f, -0.13849893f, -1.04173839f, 0.52569598f, 
    -0.75719589f, -0.16555704f, 0.46582568f, 0.14213333f, -0.06376514f, 0.50363594f, 0.19354139f, 0.82245064f, 
    0.48641700f, 0.24202159f, 0.43720484f, 0.73747885f, 0.17040777f, -0.31046051f, 0.37851980f, -0.21430019f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.20947863f, 0.23718537f, 0.25505680f, 0.08284408f, 0.06013704f, 0.35847557f, -0.04617431f, 0.51184195f, 
    -0.06438205f, -0.16243815f, -0.00306578f, 0.36154333f, 0.08759406f, 0.52751148f, 0.41261068f, 0.09009859f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.13061991f, -0.47137690f, -0.58510876f, 0.07758596f, 0.12467156f, 0.02866006f, -0.09091185f, 0.16464390f, 
    0.07959189f, 0.36240530f, -0.54190165f, -0.37361696f, -0.04954335f, -0.00634938f, 0.12175903f, -0.01181370f, 
    0.06707861f, 0.09699007f, -0.35028294f, 0.19316979f, 0.30796927f, 0.08143726f, 0.21796025f, -0.05576367f, 
    0.01832056f, -0.15888518f, -0.13103695f, 0.19207674f, -0.23619063f, 0.20669082f, 0.25008255f, -0.03323800f, 
    -0.21088926f, 0.04267875f, -0.01031151f, -0.10230067f, 0.15503061f, 0.23455255f, 0.04587481f, 0.02164316f, 
    0.10734706f, 0.02052804f, 0.20487532f, -0.05511952f, 0.16323997f, -0.06616633f, -0.10659879f, -0.36208051f, 
    -0.04250516f, -0.37494454f, 0.09789948f, 0.08996616f, 0.27630496f, 0.01004418f, 0.40273604f, 0.29220560f, 
    -0.04861043f, 0.11156827f, -0.01788213f, -0.06954665f, -0.09728386f, -0.04297774f, 0.01326180f, 0.00709989f, 
    0.10767270f, -0.30862945f, 0.13226286f, -0.01593510f, -0.02532896f, -0.02925878f, -0.03631454f, -0.13969830f, 
    0.44332483f, 0.17259598f, 0.12619777f, 0.24953003f, 0.08237041f, 0.13447446f, -0.09130526f, 0.04179867f, 
    0.04726587f, -0.14945817f, -0.01832318f, 0.32035467f, 0.05234988f, 0.04358469f, -0.12549061f, -0.02246000f, 
    -0.07262608f, 0.00720970f, -0.05516672f, -0.06527721f, -0.06738437f, -0.15028094f, -0.19333544f, 0.29707125f, 
    0.13710642f, 0.27947900f, 0.17482631f, 0.19897369f, 0.26943657f, 0.23173450f, -0.02391919f, -0.13365197f, 
    -0.12829939f, 0.01480485f, -0.01066424f, 0.12433136f, -0.26297933f, -0.35395882f, 0.03860793f, -0.03084964f, 
    -0.19181189f, -0.15341967f, 0.10964686f, -0.04024151f, 0.16419724f, -0.05172537f, 0.10114717f, -0.14554863f, 
    -0.15442672f, -0.03866617f, 0.06912914f, 0.11511988f, -0.09438638f, 0.06762788f, 0.08502114f, -0.00330910f, 
    -0.46020129f, 0.12034892f, -0.27677575f, 0.19427593f, 0.18627115f, -0.03846315f, -0.19948223f, 0.22023679f, 
    -0.26170078f, -0.15958570f, 0.19747199f, 0.14836848f, 0.00725891f, 0.00531056f, -0.21668100f, 0.15901899f, 
    0.05814643f, 0.35301456f, 0.25776693f, -0.11080369f, -0.02303044f, 0.13584983f, 0.09548309f, -0.07194319f, 
    0.06182461f, -0.07839708f, 0.10288796f, -0.02291115f, 0.23991880f, 0.05648264f, -0.07991063f, -0.10018570f, 
    -0.06353161f, 0.02037542f, 0.10738385f, 0.06169216f, 0.13700363f, 0.07014684f, -0.07747235f, -0.08710809f, 
    -0.07255717f, 0.21168424f, 0.23422463f, 0.32996449f, -0.00102320f, -0.30214188f, -0.06291275f, 0.08811333f, 
    0.26120606f, 0.04866140f, 0.23559523f, 0.15878554f, -0.50693911f, -0.30258316f, -0.21775874f, -0.00168753f, 
    0.03663992f, -0.05597476f, 0.10235003f, -0.03852277f, 0.08003898f, 0.09412412f, -0.26205638f, -0.01396563f, 
    -0.15865272f, 0.08945930f, 0.12590505f, 0.13023280f, -0.02697837f, 0.19608282f, -0.21743268f, -0.38447201f, 
    0.07247001f, -0.10681041f, 0.15620044f, -0.07318316f, -0.08549373f, -0.05407386f, 0.08385194f, -0.02295574f, 
    -0.32920197f, -0.05205325f, -0.09013741f, -0.05689276f, 0.00541444f, 0.15145481f, -0.01071113f, 0.02783527f, 
    -0.19304201f, -0.26083949f, -0.27579394f, -0.08309918f, 0.05806461f, -0.03510004f, -0.13626160f, -0.12131049f, 
    -0.30291614f, 0.02382766f, 0.03993490f, 0.06514589f, -0.11763866f, -0.12329207f, -0.33221576f, -0.13086081f, 
    0.22398692f, 0.22071816f, -0.12747777f, -0.22724250f, 0.27840957f, 0.12038375f, -0.01110272f, -0.25543416f, 
    0.06386559f, -0.03211208f, -0.03804068f, -0.32004726f, -0.18191805f, 0.14403903f, 0.03979004f, 0.03227844f, 
    0.01951022f, 0.04579839f, 0.04405546f, 0.24756180f, -0.29384601f, 0.01006594f, -0.02012152f, -0.13488661f, 
    -0.26844862f, -0.01896673f, -0.00470979f, -0.19996548f, -0.08300881f, 0.18873191f, 0.21909450f, -0.10901329f, 
    0.04510524f, 0.03123618f, -0.17367883f, -0.02629537f, 0.10601856f, 0.07537825f, 0.46099344f, 0.42697853f, 
    0.31743130f, -0.12188267f, 0.16189015f, 0.16747791f, 0.18797305f, 0.09280970f, 0.07141224f, 0.29886261f, 
    -0.09451190f, -0.04026524f, -0.02004720f, -0.02524533f, -0.04745023f, -0.12589486f, 0.11708780f, -0.11046150f, 
    -0.44131389f, -0.87373793f, -0.56052327f, 0.02253466f, 0.02825168f, 0.13454208f, -0.03609215f, 0.01040132f, 
    -0.22926337f, -0.18546481f, -0.17322394f, 0.03242539f, 0.17438698f, 0.13749002f, -0.07110865f, 0.05371198f, 
    0.04200198f, 0.17672507f, -0.41762963f, -0.17023765f, -0.00010441f, -0.13411260f, 0.18962175f, -0.08015215f, 
    0.16949040f, 0.04962417f, 0.06351592f, 0.22106594f, -0.03209082f, -0.13063960f, 0.22796291f, -0.09656268f, 
    -0.04374998f, -0.15899132f, -0.21810074f, -0.01713207f, -0.45463243f, 0.00034277f, 0.09509906f, -0.03635821f, 
    -0.09789277f, 0.07149865f, 0.05698061f, -0.00598194f, 0.12958536f, 0.12032583f, -0.03484676f, 0.30298963f, 
    0.10182015f, 0.20272501f, -0.00835348f, 0.08917475f, -0.09310514f, 0.14417154f, -0.31140518f, 0.22980444f, 
    -0.26541492f, 0.00721111f, -0.10955434f, 0.09062245f, 0.11157516f, -0.00069177f, 0.02788488f, 0.16023849f, 
    0.32260033f, 0.04537639f, 0.07991704f, 0.00125366f, 0.07706606f, -0.02247155f, -0.03820660f, -0.03628801f, 
    0.33727428f, -0.82293415f, -0.78912973f, -0.10762911f, -0.11522891f, 0.02662838f, 0.18243402f, -0.11816625f, 
    -0.10490876f, 0.19533609f, 0.43758693f, 0.00345756f, -0.00038324f, -0.04018134f, -0.15920180f, -0.13274367f, 
    -0.12789677f, 0.16468382f, -0.65151924f, 0.87638015f, 0.07163511f, 0.20144141f, 0.38372278f, -0.12523456f, 
    0.18488963f, -0.00845962f, -0.04101315f, -0.48603696f, -0.15742561f, 0.00062584f, 0.08399797f, -0.09082455f, 
    -0.01550012f, 0.09968730f, -0.01282153f, -0.08848191f, 0.30219805f, 0.28171048f, -0.05453816f, -0.02038456f, 
    -0.07025260f, -0.06299206f, -0.13103001f, -0.10100251f, 0.01655633f, -0.07321440f, 0.31698287f, 0.02258119f, 
    -0.22410582f, 0.20546967f, 0.00584721f, 0.15151790f, 0.24540995f, -0.07390614f, -0.00392315f, -0.66525865f, 
    -0.25956646f, 0.21385142f, 0.09017666f, 0.07648170f, 0.11914478f, -0.06113795f, -0.13060264f, 0.11729110f, 
    0.39471805f, 0.00937142f, -0.13187817f, -0.06637221f, -0.11216103f, 0.10085782f, -0.02806371f, -0.07033940f, 
    -0.05942766f, 0.33315855f, 0.21819632f, -0.11550491f, 0.25658563f, 0.18376325f, 0.06431509f, 0.19364740f, 
    0.05727588f, 0.17035224f, 0.70797360f, 0.10231915f, 0.15759094f, 0.09121435f, 0.10396564f, 0.21444741f, 
    -0.15045342f, -0.24546170f, 0.44573066f, 0.06801035f, -0.14491600f, -0.09669838f, -0.01051887f, -0.15287818f, 
    0.06645943f, -0.03291699f, 0.03143212f, -0.00743242f, 0.00056570f, -0.36620647f, -0.00046353f, 0.31166568f, 
    -0.08304410f, 0.09565268f, 0.43820345f, -0.09204467f, -0.25897405f, -0.08982117f, -0.01218598f, -0.11202709f, 
    -0.30548128f, -0.06353165f, -0.26164687f, -0.25138655f, 0.24252661f, 0.67504323f, 0.26281571f, 0.01400633f, 
    0.16547924f, 0.12727012f, -0.11844282f, 0.07783896f, -0.10371976f, 0.09767194f, -0.25475410f, -0.01427197f, 
    0.16598848f, -0.24264120f, -0.12954509f, 0.00131742f, 0.16299897f, 0.06881939f, -0.04563935f, 0.22044450f, 
    -0.09892990f, -0.05390132f, 0.05162691f, 0.03646300f, -0.02884115f, 0.10651303f, -0.31473035f, -0.06603317f, 
    0.25210077f, 0.26350534f, -0.13247994f, -0.08076363f, 0.00466404f, 0.01295086f, -0.04889929f, 0.03848082f, 
    -0.01258171f, -0.35026947f, -0.06782906f, 0.14713408f, -0.03433001f, -0.08208559f, -0.09356864f, 0.00951001f, 
    -0.13415641f, 0.04128808f, -0.68223852f, -0.31735206f, 0.14098354f, -0.34702182f, -0.05799048f, -0.09246310f, 
    -0.13988408f, -0.03119191f, 0.04856613f, -0.17139730f, -0.12253385f, -0.11062592f, 0.00677800f, -0.15567970f, 
    -0.16740960f, 0.03852497f, 0.11355516f, 0.10346916f, -0.93267578f, 0.00824971f, -0.45593825f, -0.05204554f, 
    -0.36871347f, -0.01949493f, -0.01427241f, 0.08106962f, 0.07721440f, -0.25810319f, 0.29398355f, 0.03794364f, 
    0.06379850f, -0.19477215f, -0.06753542f, -0.09751046f, -0.12254365f, 0.01045851f, -0.22357272f, -0.14582336f, 
    0.00734624f, -0.00149011f, 0.13767038f, 0.07348377f, 0.03562941f, 0.17143446f, 0.31128651f, 0.14211637f, 
    -0.09038270f, -0.22795008f, -0.21875261f, -0.12665620f, -0.06447807f, -0.11970621f, 0.16933103f, 0.10332822f, 
    -0.38468829f, -0.44795468f, 0.05154407f, 0.30378526f, -0.03864649f, 0.20247753f, 0.14028832f, -0.03501032f, 
    -0.03102278f, -0.10830860f, -0.02497833f, -0.06431626f, -0.00339815f, 0.15280668f, 0.00238482f, 0.11129192f, 
    0.26168880f, 0.22404838f, 0.03647217f, 0.03882759f, 0.14581019f, 0.22317995f, 0.05642131f, 0.04337113f, 
    0.14524257f, 0.09725609f, 0.26338977f, 0.15857457f, 0.05912923f, -0.14186107f, 0.01016827f, 0.08995305f, 
    0.28920439f, 0.22636333f, -0.12347703f, -0.19362201f, 0.08685711f, -0.05275027f, 0.12062901f, 0.03580350f, 
    0.05431674f, -0.17456010f, -0.00773528f, 0.01247957f, -0.32189116f, -0.30264193f, 0.15885417f, 0.05441340f, 
    0.17611328f, -0.05732274f, -0.03359273f, 0.17098898f, 0.03481713f, -0.08835985f, 0.15768836f, -0.11315913f, 
    0.30928719f, 0.23456746f, 0.07258964f, 0.08203225f, -0.00389520f, 0.16288826f, 0.00350357f, 0.08495791f, 
    -0.01864081f, -0.00822851f, 0.12749818f, -0.09497276f, -0.02725300f, -0.01773346f, -0.37833786f, -0.22976838f, 
    -0.14072779f, -0.02062731f, 0.17598675f, 0.14334697f, 0.17143628f, 0.00776532f, 0.00664959f, 0.06177827f, 
    0.21881831f, 0.28189290f, 0.23892647f, 0.20851752f, 0.30327681f, -0.01843526f, 0.17209491f, 0.29991788f, 
    0.13961160f, 0.30959034f, -0.06531953f, 0.32628426f, 0.04246477f, -0.10934668f, 0.24471539f, 0.05480865f, 
    0.08539632f, -0.09937274f, -0.01488059f, 0.01412329f, 0.09845561f, 0.10743228f, 0.20075773f, -0.02342903f, 
    -0.11969960f, -0.04863888f, -0.21308734f, -0.41315103f, 0.20369561f, 0.41663039f, -0.17070808f, 0.00802268f, 
    -0.31217322f, 0.02460706f, 0.01735321f, 0.04639965f, 0.04460209f, 0.15186815f, 0.09043162f, 0.00923606f, 
    -0.02882619f, -0.01883785f, -0.02231233f, 0.15100770f, -0.11454727f, 0.01954940f, -0.02523470f, 0.12172374f, 
    -0.06150204f, 0.07312192f, -0.01150698f, -0.16809498f, 0.07474579f, -0.19390030f, -0.21720441f, 0.07511405f, 
    -0.00510079f, 0.11782570f, 0.10307379f, 0.09013975f, 0.26441553f, 0.09512217f, -0.21800143f, -0.05964420f, 
    0.40369245f, 0.12725689f, 0.13297202f, -0.28136086f, 0.01712620f, 0.02809732f, -0.06326260f, 0.04032687f, 
    0.00351837f, 0.07797083f, -0.25729504f, -0.03919234f, 0.10577598f, 0.08021659f, -0.02744915f, 0.26406476f, 
    0.09612416f, -0.06564366f, 0.15711270f, 0.14849234f, -0.01859763f, 0.00835290f, 0.03222914f, 0.14544997f, 
    0.07558750f, -0.06919410f, -0.17313668f, -0.44259396f, 0.06886230f, 0.15392990f, 0.08065152f, -0.16221583f, 
    -0.17728136f, 0.11920074f, 0.10123552f, 0.08631521f, 0.13715343f, 0.40210572f, 0.32099268f, -0.15999496f, 
    0.12967017f, -0.06790253f, 0.12488752f, 0.04621122f, 0.11625338f, -0.05515062f, -0.12114704f, -0.21456294f, 
    0.14450462f, -0.23795101f, 0.18392794f, 0.00488713f, -0.07779211f, 0.03646445f, 0.20038243f, 0.34188548f, 
    0.23644282f, -0.04626103f, 0.00157044f, -0.00733519f, 0.04981983f, -0.02439273f, 0.07168368f, -0.13656300f, 
    -0.10299169f, -0.23693128f, 0.12468693f, 0.05843372f, -0.06805119f, 0.12771799f, 0.10463724f, 0.15062505f, 
    0.22406769f, 0.35635135f, 0.20825359f, -0.15966298f, 0.06681621f, 0.20311254f, 0.04249375f, 0.13823886f, 
    -0.12951532f, -0.51410276f, -0.22392517f, 0.16009586f, 0.07046144f, -0.17071216f, -0.06411465f, 0.16702022f, 
    -0.10557334f, -0.17506489f, -0.91299570f, 0.10951767f, 0.29012603f, -0.27693203f, -0.33777308f, 0.08621736f, 
    0.02005267f, 0.13461517f, 0.13698512f, 0.15177849f, 0.16597638f, 0.19185588f, -0.15812863f, -0.02798226f, 
    -0.21853682f, -0.08477102f, -0.01939085f, 0.08481632f, 0.25459999f, -0.64906693f, -0.16123150f, 0.11755972f, 
    0.00245066f, 0.09494764f, -0.08603148f, 0.06466816f, 0.11964484f, -0.14886792f, -0.45245829f, -1.12405825f, 
    0.04160061f, 0.05958603f, 0.08725137f, 0.12950042f, 0.15097708f, -0.05974957f, -0.42019466f, -0.26164550f, 
    -0.34801489f, -0.11460654f, 0.07084674f, 0.32507953f, 0.04194550f, 0.02591364f, 0.16252704f, -0.42094404f, 
    -0.40946588f, -0.31442729f, 0.01158152f, -0.15405415f, -0.13187546f, -0.05829962f, -0.02366667f, -0.11609747f, 
    -0.79729086f, 0.00500826f, -0.23960434f, -0.27680615f, -0.05607823f, -0.09744482f, 0.06043565f, -0.11396826f, 
    -0.26166791f, -0.35713050f, -0.04798859f, -0.33756459f, 0.16303682f, 0.10798999f, -0.06552622f, -0.10064717f, 
    -0.07274953f, 0.09713369f, 0.20169540f, 0.13640247f, 0.11031269f, 0.13133669f, 0.16237183f, 0.36043793f, 
    -0.03848308f, -0.16723859f, -0.02869824f, -0.13410895f, 0.14281826f, -0.07371324f, -0.00327100f, -0.22016802f, 
    -0.31445166f, 0.07025538f, -0.06421723f, -0.07326104f, -0.01938290f, -0.09137424f, 0.63327748f, -0.13227652f, 
    -0.06410159f, -0.16155063f, 0.12520903f, 0.11313733f, 0.11678040f, -0.19753236f, -0.13149105f, -0.07425024f, 
    0.00265048f, -0.12779011f, 0.18381181f, 0.09699747f, 0.12497973f, -0.00621131f, 0.01894176f, 0.14466821f, 
    0.40970716f, -0.12086615f, -0.11474523f, -0.08421478f, 0.02449138f, 0.19089428f, 0.00892384f, 0.15235826f, 
    -0.04872875f, 0.17514004f, 0.06079568f, 0.08477672f, 0.09685136f, -0.00734033f, 0.04748709f, 0.01769422f, 
    -0.22231524f, 0.09314558f, -0.03957717f, -0.35280889f, -0.21703041f, 0.13805322f, 0.05000076f, 0.13658792f, 
    -0.05385865f, -0.15564451f, -0.22150946f, 0.16348977f, 0.12472815f, -0.16200900f, -0.23949346f, -0.23254794f, 
    0.01205144f, 0.14395458f, -0.87440675f, -0.94142276f, 0.71035844f, -0.16608256f, -0.21743669f, 0.00951090f, 
    -0.11566865f, 0.16342419f, -0.09344299f, -0.03240588f, 0.26967579f, -0.03869305f, 0.03126624f, 0.01046908f, 
    -0.01556436f, 0.04530429f, 0.14044535f, -0.07377637f, 0.26889592f, 0.38282973f, 0.08163295f, 0.13813582f, 
    -0.08279299f, -0.05781927f, 0.06446093f, 0.05642137f, 0.07526551f, 0.40180334f, -0.23651293f, -0.02205390f, 
    0.13322479f, 0.01584184f, 0.20707083f, 0.20124273f, 0.12988082f, 0.18468492f, -0.39799467f, 0.07726568f, 
    -0.51122499f, 0.03175411f, 0.06400802f, 0.18711168f, 0.32205492f, 0.05789980f, 0.01532671f, 0.07313021f, 
    -0.17894764f, 0.04169759f, -0.07998965f, -0.14939867f, -0.27473068f, -0.01629146f, 0.16435744f, 0.12746812f, 
    -0.11091165f, 0.28666893f, 0.00500516f, 0.11173751f, 0.21314700f, -0.00160865f, -0.11228982f, 0.17214234f, 
    0.07164723f, 0.23882318f, 0.14344676f, 0.10089297f, -0.11917927f, 0.05905107f, -0.03326032f, -0.08399708f, 
    -0.21105121f, -0.44455436f, 0.02749707f, 0.05315861f, 0.20267749f, -0.08222906f, 0.13877705f, 0.18935166f, 
    0.08580250f, 0.06711120f, -0.33433476f, -0.20874469f, 0.01383985f, 0.06723910f, 0.02397302f, -0.03705033f, 
    -0.26596537f, 0.09358512f, 0.15250362f, 0.19743152f, 0.23205546f, -0.37776577f, 0.01304286f, 0.10658408f, 
    0.31540045f, 0.01057875f, 0.24159443f, 0.13130033f, 0.02054526f, 0.07065610f, -0.21404360f, 0.04917591f, 
    0.05169376f, -0.00549520f, 0.23074567f, -0.04296741f, 0.04211978f, 0.11656657f, -0.11036250f, -0.03118874f, 
    0.11547793f, 0.03598062f, 0.15378658f, -0.09283689f, 0.24308237f, 0.16666690f, -0.12337404f, -0.15497418f, 
    -0.01832053f, -0.06924549f, 0.02021029f, 0.07607993f, 0.04314394f, -0.01404813f, 0.20143496f, 0.02932796f, 
    -0.23844473f, 0.06913820f, -0.01379855f, 0.08634029f, 0.06907431f, 0.30483866f, 0.05928864f, 0.08822841f, 
    -0.04179069f, -0.24225633f, -0.26294583f, 0.09437906f, -0.10376116f, 0.01924949f, 0.05030184f, -0.22570778f, 
    0.04125345f, -0.14923970f, 0.51277500f, 0.42240196f, -0.43416488f, -0.08316685f, 0.05315434f, 0.10555934f, 
    0.19609071f, 0.03442583f, 0.10344725f, 0.15957132f, -0.00788696f, 0.18785386f, 0.15690073f, 0.43758187f, 
    0.08887703f, 0.22394136f, 0.20388909f, 0.28086498f, -0.70718032f, -0.43447146f, -0.05745133f, -0.09662970f, 
    0.04832835f, 0.07794222f, 0.09434208f, 0.03340273f, -0.14171247f, -0.33899748f, 0.05559112f, 0.20377941f, 
    0.04858593f, -0.05099472f, 0.21871004f, 0.04297625f, 0.17648278f, 0.03479947f, 0.32316184f, 0.04100537f, 
    0.38973692f, -0.04747351f, -0.06827269f, -0.22577360f, -0.08749805f, 0.09509201f, 0.12014557f, -0.29054692f, 
    -0.24404669f, -0.34415168f, -0.20299514f, 0.07090516f, 0.14464857f, -0.05159650f, -0.10735912f, -0.27057192f, 
    -0.00433064f, -0.00319460f, -0.11950327f, -0.07061613f, 0.04660989f, -0.06746523f, -0.04663733f, -0.00364664f, 
    -0.06845818f, -0.09864960f, 0.02456909f, -0.10636529f, 0.06417439f, -0.07158633f, -0.01721211f, 0.00655873f, 
    -0.02133627f, -0.09350505f, -0.02935609f, -0.06762059f, -0.10160324f, -0.02229515f, -0.09339146f, -0.05870092f, 
    0.02030594f, -0.09682249f, -0.04373548f, 0.01571929f, -0.08063553f, 0.00824276f, -0.03499360f, -0.01497938f, 
    -0.00757350f, -0.03022495f, -0.00354673f, -0.07044144f, -0.00267364f, 0.01404346f, -0.01866379f, 0.03956178f, 
    0.04626130f, -0.04761400f, -0.09427939f, -0.05312680f, -0.01790135f, 0.04339420f, -0.05064228f, -0.03902495f, 
    -0.08430207f, -0.03872462f, -0.07297119f, -0.08953629f, 0.00419556f, -0.12602077f, 0.01011248f, -0.09644658f, 
    -0.03658802f, 0.02437725f, -0.11507933f, 0.05141678f, 0.06883051f, 0.00625126f, 0.07182768f, -0.03540587f, 
    0.02091857f, -0.01051748f, 0.02668931f, 0.02230753f, 0.04027625f, -0.01039163f, -0.09026781f, -0.05971253f, 
    0.01222020f, 0.00123480f, 0.02837900f, -0.10019177f, -0.09233963f, -0.04202423f, -0.03075318f, -0.00910830f, 
    -0.03882281f, 0.01778496f, -0.05129560f, -0.04292525f, -0.07044984f, -0.04377665f, -0.01817089f, 0.04016617f, 
    0.01870186f, 0.07055003f, -0.06145578f, 0.06734468f, -0.01019832f, -0.00758534f, -0.02789655f, -0.03654956f, 
    -0.08748747f, -0.10759918f, -0.04547476f, -0.11498179f, -0.08337452f, 0.01820441f, 0.04943659f, -0.10434996f, 
    -0.09063508f, 0.00192671f, 0.02213539f, -0.08325194f, -0.01592511f, 0.02211097f, -0.06420435f, -0.08446725f, 
    -0.03227954f, 0.00414538f, 0.07199564f, 0.05059584f, -0.04589378f, 0.00815650f, -0.08780271f, -0.07782514f, 
    0.03087624f, 0.02844587f, 0.03590467f, -0.05135991f, -0.08169934f, -0.03696961f, -0.06711712f, -0.06231082f, 
    -0.00907926f, -0.03504875f, -0.10990667f, -0.05653730f, -0.07440106f, -0.09565813f, 0.00328248f, -0.05912171f, 
    -0.00763073f, -0.03071609f, -0.05391379f, -0.01622904f, -0.04594379f, 0.02409485f, 0.00501062f, -0.09420349f, 
    -0.06507112f, 0.10040011f, 0.28418252f, -0.35305759f, 0.06204757f, -0.24953319f, 0.04222062f, -0.04480737f, 
    0.11345244f, 0.10591431f, -0.03512960f, 0.09421279f, -0.09552474f, -0.38767099f, -0.05571990f, 0.00217157f, 
    -0.01189902f, 0.16757809f, -0.08821087f, 0.19634266f, 0.20028305f, 0.00308515f, -0.12355984f, 0.08806186f, 
    0.01993371f, -0.05101185f, -0.10689811f, 0.11144530f, -0.10712033f, -0.44523406f, -0.06709506f, 0.13403019f, 
    -0.16935344f, -0.06939881f, -0.08165147f, 0.14459206f, 0.33775055f, 0.22331429f, 0.12418746f, -0.23253873f, 
    0.04391542f, -0.01263443f, 0.01395776f, 0.04882831f, 0.12593707f, -0.74290919f, -0.21019827f, -0.38171694f, 
    -0.05168341f, -0.02183665f, 0.03512682f, -0.09667944f, 0.18814600f, -0.06988451f, 0.12835947f, 0.33215368f, 
    0.47033975f, -0.07654938f, 0.14601797f, -0.05631232f, -0.14769439f, 0.08204228f, 0.08231394f, -0.14900489f, 
    0.02081191f, -0.06343073f, -0.00454952f, 0.05497006f, -0.05684635f, 0.30653894f, 0.24059993f, 0.13230135f, 
    0.01392633f, 0.01234448f, 0.32946035f, 0.12750538f, -0.28324178f, -0.11364296f, 0.19623001f, -0.05902252f, 
    0.03021480f, -0.04343551f, -0.08842617f, -0.09919426f, 0.09714836f, -0.22130889f, -0.07218791f, 0.25446185f, 
    -0.14758639f, -0.04507273f, -0.33481297f, -0.23671357f, 0.17278360f, -0.24858481f, -0.15644599f, -0.00091670f, 
    0.09577566f, 0.30312136f, 0.06236123f, 0.17964950f, 0.20624420f, 0.31026375f, -0.15978675f, -0.00351448f, 
    -0.25097021f, 0.07585931f, -0.06698613f, 0.06170864f, -0.29704472f, -0.08787823f, -0.08351635f, 0.16987990f, 
    0.19254570f, -0.12804590f, -0.09484606f, -0.22596794f, -0.19740556f, -0.23022009f, 0.18625326f, -0.33082139f, 
    0.17311576f, 0.06475975f, -0.00274153f, 0.00407699f, 0.06125781f, 0.12676297f, 0.14539085f, 0.03136118f, 
    0.26289576f, -0.30966541f, -0.11971103f, 0.19697256f, 0.03138468f, 0.16249529f, -0.12108705f, 0.04170658f, 
    0.18067530f, 0.26980221f, 0.17491321f, -0.06183590f, -0.14305843f, 0.03264559f, 0.18806486f, 0.15418245f, 
    -0.76195180f, 0.15500888f, 0.15722345f, 0.03070895f, -0.05350375f, -0.08079405f, -0.08653298f, -0.02785840f, 
    0.20900625f, 0.03683357f, 0.16267779f, 0.15978727f, 0.13134895f, -0.01114293f, 0.17173900f, 0.10427245f, 
    0.29063770f, 0.45524830f, -0.11441127f, -0.03561179f, 0.32681206f, 0.15140696f, 0.03014568f, 0.20771796f, 
    0.09888606f, 0.10446602f, 0.23184578f, -0.21920748f, 0.18314311f, -0.11584602f, -0.06108566f, -0.17336369f, 
    -0.29797336f, 0.31552541f, -0.07036988f, 0.16763790f, -0.63411129f, -0.38977313f, -0.14445856f, -0.08921786f, 
    -0.15324818f, -0.22614247f, 0.05269981f, -0.32088628f, 0.02393166f, 0.08204108f, 0.34735161f, -0.25866574f, 
    -0.12195385f, -0.03709964f, -0.18028502f, 0.13485035f, 0.26430392f, 0.04794429f, -0.14436319f, -0.11395802f, 
    0.08205632f, 0.05148755f, -0.26640171f, -0.09617260f, 0.16227727f, 0.09633960f, 0.07375254f, 0.15613273f, 
    0.03330266f, -0.04694675f, -0.01828408f, -0.07132960f, 0.12896165f, -0.00978802f, 0.15900521f, -0.01747024f, 
    -0.27940249f, -0.23136744f, 0.16314043f, 0.00862910f, 0.06004561f, -0.06050290f, -0.08061895f, 0.11816330f, 
    0.02198462f, -0.48633632f, -0.18925679f, -0.36364129f, -0.19692165f, -0.08415108f, -0.15378216f, -0.08762462f, 
    0.07735607f, 0.22538741f, -0.45678657f, -0.31631124f, 0.85143834f, -0.06593084f, -0.18553106f, -0.33782136f, 
    0.19486418f, 0.20490770f, 0.14847006f, -0.11616526f, 0.08086269f, -0.09536403f, -0.00886825f, -0.04273437f, 
    -0.20554304f, 0.04777764f, 0.02298597f, -0.04263926f, 0.27354905f, -0.38188300f, -0.35945383f, -0.20098428f, 
    0.18198928f, -0.06206721f, -0.17428978f, -0.05324379f, -0.00933576f, 0.59368169f, 0.23756041f, -0.08528080f, 
    0.02542559f, 0.11583529f, -0.01540794f, 0.19022775f, 0.03273269f, -0.00829619f, 0.11146294f, 0.41038534f, 
    0.26786703f, 0.06658680f, 0.10670546f, 0.24800517f, 0.10136857f, 0.00405234f, 0.02838636f, -0.03078221f, 
    0.12729202f, 0.15800053f, 0.02353473f, -0.03830415f, -0.04318441f, 0.01363988f, 0.05590717f, 0.01671224f, 
    -0.18011793f, 0.17232871f, 0.11456108f, 0.02369814f, -0.00580886f, -0.30445001f, 0.03720686f, -0.19505015f, 
    0.06850852f, -0.35767791f, 0.11915881f, -0.07058295f, -0.02384795f, -0.19348203f, -0.08594929f, -0.10929401f, 
    -0.23535821f, -0.18699285f, 0.24301451f, -0.17675152f, -0.19892633f, 0.11183003f, 0.16408671f, -0.09573754f, 
    -0.10230571f, 0.06186518f, 0.12590447f, -0.27431116f, -0.09546342f, 0.27834368f, -0.25054675f, -0.04220223f, 
    0.16295034f, 0.21772863f, -0.14570151f, 0.10890722f, 0.01275276f, -0.41665524f, -0.18230295f, 0.05821106f, 
    -0.22400446f, 0.05754699f, 0.17331153f, 0.12718153f, 0.15226403f, 0.31785867f, -0.15894403f, -0.00335455f, 
    -0.01922509f, 0.26230946f, 0.07084664f, 0.04028380f, 0.01124236f, 0.20301495f, -0.10468835f, -0.25319490f, 
    -0.26973242f, -0.11190413f, -0.14697573f, 0.07445933f, 0.23294173f, 0.04662116f, 0.06364026f, 0.06711125f, 
    -0.07858860f, -0.06756379f, 0.08358005f, -0.05977075f, -0.04246574f, 0.06146574f, 0.18722212f, 0.24266703f, 
    -0.61295044f, -0.01796329f, 0.20798720f, -0.12769985f, -0.07440245f, 0.04479233f, -0.09730462f, -0.02007613f, 
    0.01507850f, -0.24581945f, -0.49340546f, 0.00965032f, -0.26870298f, 0.06730273f, 0.15171914f, -0.18166231f, 
    0.13557416f, -0.10481244f, 0.10790488f, -0.38741645f, 0.26564491f, 0.04224444f, 0.09463279f, 0.03362386f, 
    0.19096945f, 0.14682335f, -0.09894351f, -0.10121043f, -0.19461524f, -0.19402210f, 0.03508648f, 0.22434285f, 
    0.12322766f, 0.26390404f, 0.08425145f, 0.13762669f, -0.04471369f, -0.29405960f, -0.07332947f, 0.01431746f, 
    0.01287663f, 0.03405853f, -0.02110369f, 0.15383196f, -0.00436505f, 0.40327585f, -0.06597671f, -0.19601853f, 
    0.06401616f, 0.23448917f, 0.08453488f, 0.17637119f, -0.03011094f, 0.01692702f, -0.20521618f, 0.37910229f, 
    0.29739270f, 0.39919508f, -0.10521854f, 0.11985358f, 0.25437173f, 0.16406731f, 0.27059522f, -0.06321985f, 
    -0.27862662f, 0.14732385f, -0.11824321f, -0.05836837f, 0.02539068f, -0.05608906f, -0.04248871f, 0.02051338f, 
    0.30455408f, 0.08404903f, -0.08557212f, 0.11327930f, -0.10597239f, -0.14507234f, 0.09532329f, 0.12359235f, 
    0.11110065f, 0.31364587f, 0.12245074f, -0.01044305f, -0.18653703f, -0.07733721f, 0.12083646f, -0.22500955f, 
    -0.15838325f, -0.07127895f, 0.26502186f, 0.02914596f, 0.25002238f, -0.13421509f, 0.26346490f, 0.13110349f, 
    0.14470610f, -0.04551280f, -0.21107261f, -0.17033067f, 0.14793615f, -0.12959971f, 0.08034042f, 0.14158738f, 
    -0.22909327f, 0.01519978f, 0.30156854f, -0.08662838f, 0.35682827f, 0.03483790f, 0.32639748f, -0.22198531f, 
    0.08782035f, 0.06340097f, 0.16720821f, -0.16707750f, 0.22411375f, 0.22807591f, 0.02804473f, 0.17925780f, 
    0.04240129f, 0.02970495f, -0.09463143f, -0.08349307f, 0.17585193f, 0.04094301f, -0.03392580f, 0.32255378f, 
    0.19959110f, -0.21489617f, -0.09777793f, -0.10107022f, 0.09794990f, 0.04919234f, -0.20313711f, -0.01652058f, 
    -0.02254324f, 0.06084783f, 0.10583261f, 0.04565877f, 0.04122685f, 0.03736760f, 0.19662872f, 0.05131412f, 
    0.16021760f, -0.00776757f, 0.01669082f, -0.01264540f, 0.00330148f, 0.12263053f, 0.03474844f, 0.14063306f, 
    -0.03748396f, -0.59801596f, 0.03262636f, -0.00809134f, -0.01620256f, -0.03613276f, -0.04514953f, -0.11140115f, 
    -0.04920268f, -0.01514175f, 0.12472196f, -0.14702275f, -0.13972704f, -0.02576912f, 0.34004927f, 0.16178834f, 
    -0.09164252f, -0.32946286f, -0.05058282f, 0.33215547f, 0.31290689f, 0.04541630f, -0.13909265f, 0.17737807f, 
    0.04061859f, 0.30973414f, -0.06967236f, 0.05158726f, -0.57872969f, -0.38666391f, 0.08138658f, 0.06114695f, 
    -0.22145329f, -0.14254218f, -0.03280391f, 0.03767988f, 0.05017866f, -0.43356431f, 0.08217800f, 0.18006960f, 
    0.03303906f, -0.05254377f, 0.01742194f, 0.05080014f, 0.06361897f, 0.08520919f, -0.06542994f, -0.52936006f, 
    -0.12382763f, 0.30234054f, -0.01533139f, -0.08848327f, 0.23992644f, -0.04830653f, 0.06779149f, -0.18763596f, 
    -0.18424931f, 0.05712705f, -0.05018419f, 0.08055029f, -0.14805518f, 0.15822573f, -0.02638813f, -0.20485841f, 
    0.28483939f, 0.10243212f, -0.34804589f, -0.03009489f, 0.12965569f, -0.11334813f, 0.17696735f, 0.01795204f, 
    0.11023054f, -0.22252780f, -0.28227457f, -0.25383893f, 0.00882588f, 0.12469829f, -0.33146065f, -0.23133458f, 
    -0.24234648f, -0.24455135f, 0.05568501f, 0.08280984f, -0.33369449f, 0.17517753f, 0.21685238f, 0.06639756f, 
    -0.16979016f, 0.09973653f, -0.08813240f, 0.15728228f, 0.07688690f, -0.14721775f, 0.04548697f, 0.05539915f, 
    -0.07848018f, -0.12474581f, -0.00717287f, 0.03032717f, -0.18194504f, -0.12517722f, -0.00247033f, 0.01337481f, 
    0.05670498f, 0.14395960f, 0.01156768f, 0.06223651f, 0.26960403f, 0.01788857f, -0.01300044f, -0.39797840f, 
    0.17693564f, -0.32277915f, -0.06324090f, 0.09005314f, -0.07115711f, 0.30889449f, 0.23354465f, 0.28133625f, 
    0.10804670f, -0.00567735f, 0.00977209f, 0.21737018f, 0.00817274f, -0.12345432f, -0.23541896f, 0.04270857f, 
    -0.05485365f, 0.13117792f, -0.11598724f, -0.25024554f, -0.22981770f, 0.02991299f, 0.09113754f, 0.31121325f, 
    0.17083536f, 0.23149300f, -0.04415420f, -0.20655496f, -0.15935631f, -0.07432692f, 0.12446742f, 0.13028331f, 
    0.07763994f, 0.21166782f, 0.32354075f, -0.21520688f, 0.19407742f, -0.05306684f, 0.06314028f, 0.05690262f, 
    0.20456237f, -0.57615620f, -0.07704140f, 0.20022389f, 0.50032479f, -0.04269273f, -0.22012872f, 0.15074079f, 
    -0.07233065f, 0.29959559f, 0.19984746f, -0.32261300f, -0.16696583f, -0.25608382f, -0.15981384f, 0.10036428f, 
    -0.01180586f, 0.19174375f, -0.04315751f, 0.23548228f, 0.11018407f, -0.03819174f, -0.07870662f, 0.27136776f, 
    0.07074621f, 0.15704888f, -0.27764571f, -0.11035830f, 0.21574199f, -0.25484380f, 0.14157405f, -0.13893524f, 
    -0.08278549f, 0.14619839f, 0.09287334f, -0.16427000f, -0.02866702f, -0.04892775f, 0.13431312f, 0.30939484f, 
    0.19358583f, -0.05698478f, -0.09146000f, -0.02651125f, 0.25364819f, 0.10453353f, -0.09133026f, 0.13103984f, 
    0.03721505f, -0.08525277f, 0.15449731f, -0.06353376f, 0.14824723f, -0.06889796f, -0.11413836f, 0.00762774f, 
    -0.52492249f, -0.26308686f, 0.04565768f, -0.01834330f, -0.13310824f, 0.03003585f, -0.14827946f, -0.06316500f, 
    0.03196998f, 0.15351558f, 0.08306574f, -0.17952444f, 0.10384114f, 0.04309403f, -0.32434273f, 0.06306841f, 
    -0.05077222f, -0.17330550f, -0.06941474f, -0.04317745f, -0.76561171f, 0.11663047f, -0.15936951f, -0.03792397f, 
    -0.08104929f, -0.06462716f, 0.09467202f, -0.03197291f, 0.03056751f, 0.43975648f, 0.12156364f, -0.03133472f, 
    0.17203043f, 0.04505876f, 0.08479523f, 0.09968872f, -0.25391868f, -0.38088340f, -0.17493683f, 0.07901119f, 
    -0.19209394f, -0.05379078f, 0.02374635f, -0.14257076f, -0.02474954f, 0.40858153f, 0.01545874f, 0.11841794f, 
    -0.11639271f, 0.29357907f, -0.08478937f, 0.06813442f, -0.13828315f, 0.04188098f, 0.37034395f, -0.26379707f, 
    -0.55480635f, -0.10559282f, 0.09507798f, 0.14637958f, 0.01399301f, -0.00511359f, 0.14833203f, 0.05054262f, 
    0.08249347f, 0.18591708f, 0.14034808f, 0.20421094f, -0.01553112f, -0.22152458f, 0.16411464f, 0.03344713f, 
    0.26170036f, 0.38894019f, 0.07381172f, -0.04236493f, -0.06939079f, -0.09370457f, 0.02417303f, 0.09071279f, 
    0.19196381f, 0.49321276f, -0.27476296f, 0.16969417f, 0.03271275f, 0.02091270f, 0.16473287f, 0.02477949f, 
    0.05236258f, 0.08066086f, -0.40033844f, -1.21794903f, -0.16927423f, -0.14845631f, 0.24755123f, -0.04693664f, 
    -0.00492932f, 0.16372463f, -0.33596402f, 0.19643839f, -0.28522220f, 0.00600189f, -0.05436095f, -0.12196061f, 
    0.05827396f, 0.12941597f, -0.07903259f, 0.21220653f, 0.56953281f, 0.13953479f, 0.21521303f, -0.09495082f, 
    0.00178021f, 0.02668519f, -0.07183179f, 0.13911739f, -0.00832102f, 0.34075856f, -0.12175296f, -0.15606600f, 
    -0.04191005f, 0.12696645f, 0.13474639f, 0.03132446f, 0.04661457f, -0.01399376f, -0.70077175f, -0.03859890f, 
    -0.39900443f, 0.09243889f, -0.08052406f, 0.06229501f, 0.05924246f, 0.00071176f, -0.10816373f, 0.29069278f, 
    -0.03211964f, 0.03858045f, 0.09380724f, 0.17269468f, -0.05447050f, 0.06789711f, 0.00297294f, -0.01405972f, 
    0.05831692f, -0.25151971f, 0.29056078f, 0.14041005f, -0.16714850f, -0.25528237f, -0.08943202f, 0.16851924f, 
    0.03126504f, -0.15920579f, -0.06234835f, -0.07151663f, -0.00059473f, -0.02890786f, -0.17835690f, 0.22361703f, 
    0.05287704f, -0.00839418f, -0.10059295f, 0.20554410f, 0.18038327f, 0.05294837f, -0.00381239f, 0.13320546f, 
    -0.14388289f, 0.23015682f, -0.01782494f, 0.08289966f, -0.15152466f, 0.12667821f, -0.21337728f, -0.07052122f, 
    -0.14375186f, -0.21921858f, -0.15427293f, 0.05710778f, -0.40449542f, 0.10641096f, 0.09132413f, 0.05498674f, 
    0.11587095f, 0.01442694f, -0.01387615f, 0.00219808f, -0.09374496f, -0.61363006f, -0.41226134f, -0.09243300f, 
    0.02677692f, 0.08378523f, 0.06136778f, -0.00050840f, -0.01330932f, -0.17382617f, -0.16761428f, -0.05269340f, 
    0.23789503f, -0.11228023f, -0.03994394f, -0.00136732f, -0.12728167f, -0.07140590f, 0.02444568f, 0.05088805f, 
    -0.07559239f, 0.05241498f, -0.10027416f, 0.10084783f, -0.02281241f, -0.06544188f, -0.21294424f, -0.12527035f, 
    -0.18202777f, 0.20991620f, -0.29613078f, -0.05374842f, -0.08449239f, -0.02447808f, 0.03166090f, 0.10638692f, 
    -0.08689450f, 0.02923189f, -0.13450989f, 0.13637491f, 0.10907379f, 0.07652488f, 0.11317527f, -0.00250485f, 
    -0.10252877f, -0.22346805f, -0.35928029f, -0.25352806f, 0.92970622f, -0.11623468f, 0.11963399f, -0.12382635f, 
    0.08173067f, 0.13436534f, -0.06693006f, -0.30828089f, 0.10967467f, 0.39468363f, 0.07036948f, 0.07517712f, 
    0.00575637f, -0.09195033f, -0.13467291f, 0.02025526f, 0.04946142f, -0.18802221f, -0.08757910f, 0.02455452f, 
    0.06843963f, 0.03154935f, -0.06920716f, 0.15476359f, -0.18249682f, 0.04290224f, -0.08720744f, 0.35961691f, 
    0.09419943f, 0.03651785f, 0.22029285f, 0.11912277f, -0.02674710f, 0.22764994f, 0.49757910f, 0.23218870f, 
    0.15772769f, -0.18819864f, 0.08005916f, 0.20729958f, -0.08734035f, 0.15849712f, 0.12095053f, 0.00676929f, 
    -0.17984670f, 0.42797258f, -0.12732463f, -0.19673190f, -0.20461038f, -0.00003642f, 0.08593248f, 0.09398718f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02076652f, 0.00007913f, 0.11139169f, 0.08695605f, -0.01116061f, -0.06929205f, 0.20590526f, 0.13360153f, 
    -0.04175976f, 0.03199288f, 0.22437391f, 0.40233579f, 0.23380505f, -0.09915321f, 0.18303771f, -0.04208824f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26463011f, 0.12592877f, 0.06760937f, -0.08047248f, -0.12403388f, 0.06105432f, -0.20397331f, 0.12019917f, 
    -0.11811912f, 0.23879425f, -0.12534074f, 0.10344502f, -0.25134856f, -0.13614132f, -0.05430793f, 0.09565091f, 
    -0.11884186f, -0.68391877f, 0.20621224f, -0.35511020f, 0.22502083f, 0.22454539f, -0.16739582f, -0.17118905f, 
    0.17707063f, 0.09105583f, -0.12302899f, 0.42013845f, 0.34937304f, -0.35868856f, 0.05617656f, -0.19447048f, 
    -0.21641921f, 0.05143305f, -0.12107321f, -0.16028059f, -0.07099798f, 0.00351495f, -0.30034360f, 0.04719970f, 
    -0.20260140f, 0.14549989f, -0.14405090f, -0.18041672f, -0.14785300f, -0.18701822f, 0.14973864f, 0.07492745f, 
    -0.09093598f, -0.00822671f, 0.21188812f, 0.56940317f, 0.08345122f, -0.19981526f, -0.04071729f, 0.37714428f, 
    -0.15570323f, -0.25800991f, -0.17187558f, 0.26682326f, 0.48838100f, -0.44341439f, -0.45275468f, -0.77891707f, 
    -0.15106896f, -0.04295483f, -0.14676231f, -0.19267961f, 0.21515706f, 0.00486258f, -0.03202665f, -0.11421642f, 
    -0.09232357f, -0.19721970f, -0.23751870f, -0.24844936f, -0.05420098f, -0.09222585f, -0.21401808f, 0.13617548f, 
    0.43140587f, 0.12910420f, 0.20339504f, -0.19546233f, 0.24296829f, -0.28664464f, -0.14347844f, 0.31592292f, 
    0.09671704f, -0.35416940f, 0.23826711f, 0.44351649f, 0.04770190f, -0.36372533f, -0.27685401f, -0.97542620f, 
    0.42654824f, -0.66086304f, -0.12620889f, -0.04439475f, 0.38720098f, -0.10782948f, 0.05796028f, 0.28838101f, 
    0.11768999f, 0.28221503f, -0.41083899f, 0.09926045f, 0.11688232f, -0.27544686f, -0.12979235f, -0.49205333f, 
    0.22598229f, -0.17477909f, -0.02593473f, -0.20595318f, 0.07602042f, 0.60894966f, 0.05083631f, 0.05492409f, 
    0.18192863f, -0.11688853f, -0.10864200f, 0.43632957f, -0.03864495f, 0.06816868f, 0.01463219f, -0.43232375f, 
    0.57953483f, -0.04556732f, 0.31886378f, 0.04521896f, 0.02498620f, 0.61165679f, 0.36095151f, -0.10269700f, 
    -0.05567951f, 0.38316995f, -0.33484587f, 0.08481755f, 0.08320520f, 0.28999397f, -0.20461418f, -0.34759307f, 
    -0.05862582f, 0.52703369f, -0.41763094f, 0.34612715f, 0.27832332f, -0.51234525f, -0.06882616f, 0.02227215f, 
    0.02214828f, -0.58808124f, 0.38028997f, 0.33961466f, -0.20399591f, 0.09981555f, 0.05250944f, -0.32521719f, 
    0.04133293f, -0.86945295f, 0.31736553f, -0.12641041f, -0.09472175f, -0.09155573f, -0.01625728f, -0.25024492f, 
    0.23832312f, -0.02143118f, 0.19844538f, -0.03756410f, -0.25541690f, -0.28397229f, 0.29672059f, -0.45163053f, 
    -0.31191194f, 0.20439421f, -0.28334841f, 0.49624592f, -0.04695046f, -0.19191556f, -0.10264092f, 0.06856837f, 
    -0.17339092f, 0.28955045f, 0.36321241f, 0.26682013f, 0.12987100f, -0.13440596f, 0.26121926f, 0.09292274f, 
    -0.49509612f, 0.27468622f, -0.24080153f, 0.37287638f, 0.14351732f, -0.18107215f, 0.28997901f, 0.05344995f, 
    -0.05244090f, 0.11032955f, 0.35868910f, -0.12155647f, 0.13523418f, 0.00387799f, 0.03185884f, 0.15777861f, 
    0.06762737f, 0.04991808f, 0.34963474f, 0.32945660f, -0.29857573f, -0.16814604f, -0.30185196f, 0.50074059f, 
    0.18084155f, -0.23910235f, -0.17487749f, 0.22387512f, 0.12276292f, 0.31094664f, -0.31579301f, 0.30420524f, 
    0.20189288f, -0.01345778f, 0.08503155f, -0.64202070f, -0.21228719f, -0.48631406f, 0.55444890f, 0.26440558f, 
    -0.19335561f, -0.26243922f, 0.09482580f, -0.20946915f, 0.07441796f, 0.18942547f, 0.06788787f, -0.14274724f, 
    0.17663835f, 0.43465081f, 0.50904977f, 0.34476954f, 0.11315504f, -0.61777288f, -0.38938606f, 0.40126935f, 
    0.02186321f, -0.06966235f, 0.41429022f, -0.53242481f, 0.13629997f, -0.73494506f, -0.73045993f, 0.47435075f, 
    -0.21885470f, 0.12479855f, 0.28089586f, -0.09514000f, 0.11172555f, 0.16924059f, -0.02118696f, 0.32313487f, 
    0.11952312f, 0.72125512f, -0.43069795f, -0.30688432f, 0.14734839f, -0.17248581f, 0.03735884f, 0.77905333f, 
    -0.15647297f, -0.27142358f, 0.44001654f, -0.25566787f, 0.49985477f, 0.03661588f, -0.10382503f, -0.30866838f, 
    -0.00622881f, 0.61076796f, 0.27301612f, -0.49805680f, 0.03811972f, -0.38761723f, -0.51294011f, 0.61217195f, 
    -0.10267070f, -0.08844143f, 0.51832587f, 0.41239026f, -0.11083882f, 0.78399390f, 0.37728694f, -0.07963351f, 
    0.04412779f, -0.32435879f, 0.29641619f, 0.46990269f, 0.08358527f, -0.27663174f, -0.10355842f, -0.38536054f, 
    -0.15831697f, -0.21173061f, 0.45283639f, 0.05877345f, -0.11197175f, 0.46896425f, 0.45295566f, 0.09122816f, 
    -0.24397692f, -0.42292079f, 0.32540342f, 0.54495698f, -0.08340240f, -0.06573782f, -0.30448723f, 0.30656883f, 
    -0.21863322f, 0.08906637f, -0.16911614f, 0.51269668f, -0.45758659f, -0.37508655f, -0.02909934f, 0.36951482f, 
    0.04309369f, 0.31662047f, 0.06026665f, 0.16476531f, 0.43250078f, -0.03733385f, -0.57783306f, 0.24077083f, 
    0.52441102f, -0.02457276f, -0.47199190f, 0.25310770f, 0.23282641f, 0.14954352f, 0.17144160f, 0.19961381f, 
    0.21800835f, -0.42498687f, -0.14268771f, -0.06799195f, 0.15952982f, 0.14591509f, -0.11675061f, 0.38053298f, 
    -0.47816449f, 0.30395290f, -0.01578172f, 0.25733259f, 0.04389796f, -0.08964860f, 0.36972463f, 0.24229822f, 
    0.13503344f, 0.20164585f, -0.24554238f, -0.18018432f, 0.23384871f, 0.05428972f, 0.11492360f, -0.23827499f, 
    0.38653740f, 0.08614512f, -0.44195443f, 0.53238994f, 0.35798827f, 0.17443100f, -0.33052105f, 0.19521166f, 
    -0.02470139f, 0.12816200f, -0.18481281f, -0.24333414f, 0.11297709f, -0.30654079f, -0.07881559f, -0.37847942f, 
    0.01670646f, 0.06556854f, 0.19322340f, -0.95263004f, -0.06828640f, -0.45117107f, 0.68786728f, 0.11964389f, 
    0.23713431f, -0.61055768f, 0.20481215f, -0.23273019f, 0.27055290f, -0.28681719f, 0.25894052f, 0.36239037f, 
    -0.03529389f, -0.30676100f, -0.03628160f, 0.45300698f, 0.34912014f, 0.53194481f, 0.41168112f, -0.24348034f, 
    0.13961184f, -0.19092947f, -0.09770846f, 0.26280519f, 0.01980793f, -0.22669822f, 0.54477900f, -0.38543573f, 
    -0.08315092f, -0.10095700f, 0.43346184f, 0.05265487f, -0.27102146f, 0.12272792f, 0.31727079f, 0.00852529f, 
    -0.11340858f, 0.20963958f, 0.31479648f, 0.34174535f, -0.05146249f, 0.12840585f, -0.39682785f, 0.09338843f, 
    0.08806906f, 0.17328629f, -0.11242145f, -0.21643907f, -0.16816846f, 0.06237870f, -0.12304402f, -0.16265011f, 
    -0.01725113f, -0.21274255f, -0.24647696f, 0.01267224f, -0.15700786f, 0.16501604f, -0.08688875f, 0.01691198f, 
    0.22510678f, 0.27679065f, -0.23886476f, 0.16073205f, 0.43027148f, -0.46141744f, 0.11072063f, 0.02276752f, 
    0.00940044f, 0.07317634f, 0.44772351f, -0.43408743f, -0.10955156f, -0.54410505f, -0.07781833f, -0.00991309f, 
    -0.10604162f, 0.58163726f, -0.38935712f, 0.20204057f, -0.13246429f, 0.01129540f, 0.75468010f, -0.07558853f, 
    -0.11026152f, 0.25266662f, 0.15753044f, -0.10630905f, 0.03303941f, -0.47824907f, 0.21661322f, 0.35814127f, 
    0.51620394f, 0.10942826f, -0.38239890f, -0.35246947f, 0.17558616f, 0.45613131f, 0.18748951f, 0.16411027f, 
    0.00206379f, 0.60665047f, -0.45668641f, -0.51611203f, 0.58970702f, -0.03812970f, 0.04454093f, 0.01453050f, 
    -0.12658009f, -0.09804639f, -0.09266174f, -0.04754296f, -0.07854179f, 0.22406581f, -0.06936449f, -0.18155524f, 
    -0.21916938f, -0.16725492f, 0.01995090f, -0.08339739f, -0.04967389f, -0.02055281f, 0.03189573f, 0.17720017f, 
    -0.15783447f, -0.07300797f, -0.01778437f, -0.57807976f, 0.03361118f, 0.19331369f, -0.03106542f, 0.07289330f, 
    -0.24905580f, -0.13787983f, -0.43656328f, -0.00538388f, 0.09347128f, 0.29730567f, -0.03550805f, -0.17542484f, 
    -0.47531733f, 0.36372745f, 0.13615452f, -0.39886960f, 0.18491964f, -0.56186795f, -0.55729711f, 0.00161897f, 
    -0.07485682f, 0.04012657f, -0.41571087f, -0.17751975f, 0.00685357f, 0.20806564f, -0.22790833f, 0.02459289f, 
    0.15851064f, 0.05058452f, -0.37833533f, 0.75192595f, -0.09459717f, 0.29463178f, -0.14421961f, -0.31039691f, 
    -0.16251050f, 0.01046548f, -0.02771038f, 0.41263694f, 0.16048448f, 0.11811698f, -0.03646752f, 0.63021499f, 
    0.02043589f, 0.24245378f, 0.41129342f, -0.47505185f, 0.33903971f, -0.49437660f, -0.48822328f, -0.02569962f, 
    -0.22765455f, 0.23775758f, 0.34734255f, 0.31973067f, -0.03880826f, 0.12052437f, -0.40217340f, -0.43176004f, 
    0.08255179f, -0.15330358f, 0.36279622f, -0.72857469f, 0.08295809f, 0.22727589f, 0.56101930f, -0.06113746f, 
    -0.13001004f, -0.21559963f, -0.01620886f, -0.07048321f, -0.03963041f, -0.36721411f, 0.16258053f, 0.00214374f, 
    0.08543712f, -0.12670812f, -0.10243468f, -0.24746326f, -0.49909985f, 0.12541209f, 0.33320561f, 0.66658658f, 
    0.24408558f, -0.24996312f, 0.07700783f, 0.31481904f, 0.49456331f, -0.10337873f, -0.70001292f, 0.10210453f, 
    -0.10039493f, 0.56488132f, -0.57295763f, 0.40343541f, -0.19453299f, 0.01436838f, 0.58857131f, 0.01997151f, 
    0.12048065f, 0.23400640f, 0.10914428f, -0.09085587f, 0.09435033f, -0.06547792f, 0.03853182f, 0.71252209f, 
    0.28647098f, 0.05503888f, -0.40683141f, 0.18930484f, -0.02713806f, 0.34595773f, -0.03365571f, -0.12500007f, 
    0.04536406f, 0.61024487f, -0.19380490f, -0.40139303f, 0.16408715f, 0.14270198f, 0.07793187f, 0.10862520f, 
    -0.06760578f, -0.12185635f, 0.20830584f, 0.21853308f, -0.38092020f, 0.15746973f, 0.42148995f, 0.50491285f, 
    -0.14192934f, -0.46915084f, -0.07461303f, 0.32374296f, 0.34713468f, -0.52266645f, 0.41423881f, -0.25360858f, 
    0.43645620f, -0.08414777f, -0.18370456f, 0.22608759f, -0.01377593f, 0.02986837f, 0.40864515f, 0.36385587f, 
    0.13577305f, 0.48384523f, -0.51361144f, 0.01922676f, 0.38301051f, -0.11377968f, 0.39754078f, 0.18108681f, 
    -0.29621199f, -0.83354145f, -0.03487226f, -0.62483400f, 0.09238537f, -0.05767219f, 0.12526207f, 0.32592297f, 
    -0.10346013f, 0.52770102f, 0.15923978f, -0.07186483f, 0.37371513f, -0.44189957f, 0.03522240f, -0.36184210f, 
    0.17498411f, -0.57407820f, 0.05515102f, -0.98985922f, 0.01207588f, -0.51833385f, 0.51269549f, 0.02362401f, 
    -0.11700819f, -0.34904853f, 0.32582599f, -0.04322776f, -0.03116728f, -0.25985581f, 0.51061565f, 0.23385869f, 
    -0.25645968f, 0.26281747f, -0.31943917f, 0.37175798f, 0.05636968f, -0.54565483f, -0.00011501f, 0.08603891f, 
    0.01526899f, -0.05445109f, 0.78195411f, 0.04003148f, 0.08307815f, -0.66587704f, 0.39933550f, 0.26638097f, 
    0.34600016f, 0.23774299f, 0.22016439f, 0.32765433f, 0.24810638f, -0.39370152f, 0.10796114f, -0.06281161f, 
    -0.18665500f, 0.30469427f, -0.36459556f, -0.50256741f, 0.27548352f, -0.03355088f, 0.07920291f, -0.14721671f, 
    -0.47324482f, -0.18454912f, 0.14068572f, 0.15274048f, 0.15329184f, -0.10511556f, -0.10232991f, -0.49347541f, 
    0.14073931f, 0.12947053f, 0.09526934f, 0.01985244f, -0.26200780f, -0.26904437f, 0.31844762f, -0.26900339f, 
    0.33654946f, 0.46541774f, -0.48168287f, 0.74165905f, 0.02055173f, 0.16761370f, 0.18632595f, 0.32672465f, 
    0.24159247f, 0.17253256f, 0.15806782f, -0.10562598f, -0.11456259f, -0.03966605f, -1.04047275f, 0.13400644f, 
    0.18601333f, -0.07871158f, -0.22967225f, -0.52644998f, 0.21740232f, -0.34922904f, -0.02186178f, 0.11738128f, 
    -0.20796806f, 0.23999816f, 0.23346223f, 0.13289505f, -0.11790063f, -0.11452629f, -0.02919357f, -0.31084821f, 
    0.46483460f, 0.23020956f, -0.57049525f, -0.30748343f, 0.39947194f, 0.04652961f, 0.10108957f, -0.20522647f, 
    -0.09659132f, 0.39393756f, 0.36233053f, 0.27613530f, -0.46518070f, -0.37308925f, -0.08616629f, 0.07304574f, 
    -0.04958703f, -0.23621857f, 0.12018882f, 0.04972868f, -0.05654388f, 0.05853800f, -0.25949526f, -0.08159831f, 
    -0.16996500f, -0.19077255f, -0.21229030f, -0.14534108f, 0.07778314f, -0.03510577f, -0.22948389f, -0.11841752f, 
    -0.00417301f, -0.33069345f, 0.32887277f, 0.58883727f, 0.20899215f, -0.45617956f, 0.00002178f, 0.21561082f, 
    0.15635504f, -0.02126889f, 0.27279285f, 0.37484100f, -0.17080879f, 0.07866567f, -0.25838330f, -0.19849195f, 
    0.19143867f, -0.32464412f, 0.20029406f, -0.06193049f, 0.46103036f, -0.12415098f, 0.37329623f, -0.19559996f, 
    0.00594991f, 0.07134614f, 0.24922343f, 0.03552783f, -0.02331425f, -0.09423723f, -0.16339090f, -0.48260793f, 
    -0.27763489f, 0.08750594f, 0.70461255f, 0.64711934f, -0.37717640f, 0.03047781f, -0.10422904f, 0.20217420f, 
    -0.21173635f, -0.39644405f, 0.42343140f, 0.35270935f, 0.34102762f, -0.23333803f, -0.21448405f, 0.60735404f, 
    0.69731373f, -0.12885824f, 0.50762290f, -0.40543807f, -0.40390381f, 0.19502756f, 0.69784552f, 0.34403381f, 
    -0.06934092f, -0.07216146f, -0.08298896f, -0.12944949f, 0.37293836f, 0.19876097f, -0.29456156f, -0.31599084f, 
    0.40479425f, -0.49279103f, 0.15861991f, -0.03423399f, -0.15691875f, 0.67533445f, 0.09275246f, 0.34542748f, 
    0.14952455f, 0.39455530f, -0.33626929f, 0.27274573f, 0.51099890f, 0.01246542f, 0.24057889f, 0.18935582f, 
    0.07837424f, 0.11120053f, 0.13695198f, -0.34121868f, -0.27504170f, 0.42240250f, 0.38210121f, 0.25037432f, 
    -0.15813576f, 0.06894134f, -0.03725930f, -0.07737794f, 0.13120386f, 0.29393893f, -0.16473356f, 0.50459903f, 
    -0.43316907f, -0.47390530f, 0.27225628f, -0.37337154f, 0.26577243f, 0.00333062f, 0.17301363f, 0.10518058f, 
    0.03324614f, 0.37028372f, 0.35714093f, 0.04692008f, -0.20755829f, -0.14846966f, -0.56226534f, 0.50069654f, 
    -0.38460240f, -0.16497450f, -0.07123160f, -0.32398847f, 0.47029027f, -0.01565491f, 0.06684760f, -0.06870458f, 
    -0.06458148f, 0.31164634f, 0.58220756f, -0.29959601f, -0.00523813f, -0.66034091f, -0.25137922f, 0.08407203f, 
    -0.12895079f, 0.05264030f, -0.05617929f, 0.09682338f, 0.15330283f, 0.06081550f, 0.04450465f, -0.47960597f, 
    -0.10168364f, -0.12299851f, 0.22384319f, -0.44707027f, -0.17600234f, 0.06907101f, -0.00770328f, 0.30556136f, 
    0.04320766f, 0.09872827f, -0.00021938f, -0.02529358f, -0.20165968f, 0.11712971f, -0.12829657f, -0.19169055f, 
    -0.06608276f, -0.09044471f, 0.16599734f, -0.24321312f, -0.19042708f, 0.14706753f, -0.16341525f, -0.08396497f, 
    0.33721462f, 0.07498938f, -0.40858290f, 0.12250153f, 0.09649489f, -0.04613923f, -0.81896704f, 0.06448310f, 
    0.07592054f, -0.04037739f, -0.57126522f, -0.29985571f, 0.27104309f, -0.05819372f, -0.00938903f, -0.13752800f, 
    -0.12002445f, -0.14850403f, -0.23854829f, -0.17023754f, -0.22279961f, -0.17492509f, -0.09494776f, -0.06020668f, 
    0.10349628f, 0.01438532f, 0.09523393f, -0.08263569f, -0.04171120f, 0.01567661f, 0.08718562f, 0.04773739f, 
    -0.46659553f, 0.27305391f, -0.00680225f, -1.07428038f, -0.15170088f, 0.12072515f, 0.33281606f, 0.32360503f, 
    -0.04911455f, 0.01396557f, 0.68539542f, 0.37741289f, -0.29010451f, -0.15517648f, -0.10707591f, 0.28734884f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19909844f, 0.23533559f, -0.12995574f, 0.32163849f, -0.02645019f, 0.20702797f, 0.39626235f, 0.04549087f, 
    -0.00793644f, 0.09538389f, 0.25104943f, 0.22332636f, 0.22574280f, 0.41959286f, 0.16502833f, 0.47507411f, 
    -0.09331393f, 0.02636776f, -0.24923307f, 0.25705206f, 0.17061691f, -0.18102461f, -0.18821850f, 0.13136397f, 
    0.12989286f, 0.24701320f, 0.17593932f, 0.14589238f, 0.13257177f, 0.02176077f, 0.09889741f, -0.22450936f, 
    -0.47235039f, -0.25636527f, 0.01602921f, 0.45386222f, 0.40719578f, 0.34584728f, 0.29891038f, 0.10709656f, 
    0.34085917f, 0.13128868f, 0.52510309f, -0.34367579f, 0.51902425f, -0.19034398f, 0.03073951f, 0.37563300f, 
    0.45554626f, 0.49747151f, -0.10381352f, 0.52751595f, 0.17812161f, 0.41871473f, -0.19785827f, 0.21492180f, 
    -0.14716737f, -0.01060085f, 0.26138428f, -0.26204064f, 0.02869011f, -0.47378531f, -0.13336296f, 0.05774284f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13670325f, 0.16768326f, -0.11317550f, -0.54897994f, -0.05252053f, -0.19368030f, 0.07676152f, 0.16023952f, 
    0.32124093f, -0.05903530f, -0.46408370f, -0.34498790f, -0.46020317f, -0.06772032f, -0.23526204f, -0.55148447f, 
    0.00530964f, 0.07379287f, 0.20736979f, -0.09549818f, -0.90706402f, 0.18861736f, -0.24456228f, 0.17344815f, 
    -1.09379423f, 0.05158936f, -0.38203612f, -0.05804008f, -0.44902286f, -0.29167393f, 0.23405738f, 0.05872667f, 
    -0.01873413f, 0.06053480f, 0.26290566f, 0.01923400f, -0.35211965f, -0.17707731f, -0.14054625f, 0.20777386f, 
    -0.28987017f, 0.09747884f, -0.59585583f, -0.21369943f, 0.54687524f, -0.00946988f, -0.64028752f, 0.06591697f, 
    -0.36797053f, 0.04438470f, 0.05409239f, -0.46100390f, -0.26520044f, -0.33696526f, 0.24348773f, 0.24688032f, 
    0.16018958f, -0.66174155f, -0.35673213f, -0.05971439f, -0.00955870f, 0.44607362f, -0.05609939f, 0.21337917f, 
    0.02713166f, 0.19230573f, 0.00516065f, 0.15362942f, 0.08529311f, -0.13933936f, -0.11972108f, 0.11828385f, 
    0.04199989f, -0.14547612f, -0.06382950f, 0.19625732f, 0.02188582f, 0.13119064f, 0.14094822f, -0.33648881f, 
    -0.15337899f, -1.19212604f, 0.16300914f, 0.11530916f, 0.20529822f, 0.09252830f, 0.06485675f, 0.17277122f, 
    0.59747845f, 0.15822285f, 0.02720012f, 0.10004558f, -0.13646001f, -0.18759376f, -0.13400307f, -0.05100596f, 
    -0.04288632f, -0.18914117f, 0.36633024f, -0.23477110f, 0.41422585f, -0.09659961f, 0.08380311f, 0.09042033f, 
    0.28583810f, 0.07597224f, -0.21056236f, 0.14843652f, -0.05199058f, -0.12508412f, -0.22410022f, 0.09612448f, 
    -0.19743036f, -0.54039478f, -0.00999436f, 0.11864405f, -0.13709162f, 0.32482466f, 0.00715137f, 0.19358730f, 
    -0.05761955f, -0.74814624f, -1.26581061f, -0.37252373f, 0.08607890f, -0.65270334f, 0.08706128f, -0.72690451f, 
    -0.16124061f, -0.65083134f, -0.02777229f, 0.41797805f, -0.07189338f, 0.02447318f, -0.05989141f, -0.15567479f, 
    -0.29479632f, 0.26788098f, -0.08991098f, 0.17233853f, 0.15934837f, 0.05936141f, -0.20469835f, 0.69184971f, 
    -0.04103211f, 0.01516744f, -0.25754979f, -0.24519831f, 0.05983602f, -0.03306113f, 0.14212315f, 0.05480544f, 
    -0.96462983f, 0.12419475f, -0.35399663f, -0.03019436f, 0.29144773f, 0.44646937f, -0.93215394f, -0.05046296f, 
    0.11995301f, 0.04954959f, 0.04781602f, 0.06064413f, -1.11336887f, -0.09586672f, 0.27388388f, -0.58093816f, 
    -0.25339636f, 0.02912026f, -0.89850312f, -0.37471735f, 0.62030989f, 0.23331331f, 0.03507770f, 0.39025745f, 
    -0.11675090f, 0.23860131f, -0.05121436f, 0.09916689f, -0.04657377f, 0.14905205f, -1.07336426f, -0.28370082f, 
    -0.14281496f, -0.14711671f, 0.24607605f, -0.15244499f, -0.10690205f, -0.26797330f, 0.03086370f, -0.26271924f, 
    -0.12149869f, -0.60044676f, 0.00237366f, 0.19521813f, -0.02134854f, 0.09528863f, 0.30796957f, -0.27870688f, 
    -0.05055160f, -0.50945097f, -0.21881714f, -0.04375993f, -0.23219003f, 0.25162184f, -0.40452352f, 0.77586037f, 
    0.10876320f, 0.13366061f, -1.15016031f, -0.84517801f, 0.25155374f, 0.08494174f, 0.01697153f, 0.17558618f, 
    -0.31174380f, -0.43689203f, -0.42569554f, 0.06457637f, 0.39994580f, -0.05024825f, 0.15497987f, -0.08897400f, 
    -0.74786067f, -0.59843373f, -0.20580986f, 0.27956197f, -0.69187891f, -0.09002975f, -0.01660914f, 0.03939078f, 
    -0.23299327f, 0.17973024f, 0.15817788f, -0.69415504f, 0.10677584f, 0.41395891f, 0.03466109f, 0.10721734f, 
    0.40129888f, -0.01262456f, 0.05479652f, 0.04363767f, -0.05054231f, -0.33154219f, 0.12537163f, -0.01807133f, 
    -0.15277158f, -0.27419683f, 0.05239563f, -0.12285022f, 0.01586795f, 0.66705436f, -0.02068903f, -0.40005824f, 
    -0.10330480f, 0.04713362f, -0.00424351f, -0.58277798f, -0.11721131f, -0.63263178f, 0.07688789f, 0.03409532f, 
    0.13195778f, -0.04819680f, 0.21579415f, 0.12866047f, 0.11213301f, -0.51043558f, -0.04448650f, -0.52340865f, 
    0.25969207f, 0.35623321f, -0.22760302f, -0.37344328f, -0.35370171f, -0.01602854f, 0.23849975f, -0.03686839f, 
    -1.00791109f, 0.13458177f, -0.23352785f, 0.02718905f, -0.03548143f, 0.37378928f, 0.27508610f, 0.03759880f, 
    -0.01536954f, -0.24515098f, -0.01809222f, -0.26525429f, -0.10401490f, -0.27021989f, 0.30086195f, 0.20660742f, 
    -0.58483231f, 0.16151886f, 0.28054059f, 0.03420766f, -0.74184316f, 0.12973872f, 0.04358033f, 0.05585892f, 
    0.06912533f, 0.23148328f, 0.04027601f, -0.23589897f, -0.01770668f, -0.70097750f, -0.15878384f, 0.03298490f, 
    0.08509858f, 0.34408271f, 0.20692556f, 0.11178172f, -0.03187517f, -0.98483241f, -0.05323394f, -0.50961369f, 
    -0.27300471f, -0.39425331f, -0.01531037f, 0.08937223f, -0.06724207f, 0.14882301f, 0.08458949f, 0.12489054f, 
    0.15065873f, 0.01429737f, -1.76174009f, -0.08224075f, -0.06062860f, -0.25248194f, 0.06589320f, -0.66115153f, 
    -0.20900111f, -0.28990087f, 0.03649500f, 0.05709464f, 0.03173039f, 0.16665483f, -0.02662991f, -0.11097509f, 
    -0.46696085f, 0.16074829f, -0.01377640f, -0.09428110f, -0.11772218f, 0.15764518f, -0.09001416f, -0.04042271f, 
    -0.19581519f, -0.14768764f, -0.02995683f, -0.06421287f, 0.20170555f, 0.26673982f, 0.16036832f, -0.18933992f, 
    0.15408154f, 0.07847650f, -0.05699491f, 0.02444335f, -0.41202235f, 0.01428366f, -0.83527130f, 0.27977741f, 
    0.12229154f, 0.05343626f, 0.03370520f, -0.15617138f, 0.11453530f, -0.17040606f, 0.38890013f, 0.02233441f, 
    0.13068847f, -0.10692111f, -0.36956552f, 0.06521419f, -0.05513180f, -0.23073240f, -0.09423868f, 0.12911361f, 
    0.01732538f, -0.56254923f, -0.00844410f, -0.71669132f, 0.04227413f, 0.37082916f, -0.93653917f, -0.05146552f, 
    -0.49934897f, 0.46191144f, 0.35377362f, 0.25454903f, 0.13850060f, -0.09843194f, -0.25648439f, -0.07548838f, 
    -0.89498472f, -0.07492724f, -0.13951185f, 0.09681342f, -0.17978324f, -0.29597476f, -0.28889507f, -1.41223478f, 
    -0.19554006f, 0.01073317f, 0.07621412f, -0.00527782f, 0.47013086f, -0.10491657f, -1.35898888f, 0.10130566f, 
    0.10162713f, 0.12569907f, -0.19391119f, 0.36726481f, -0.44746831f, -0.51121181f, -0.35364130f, -0.14632036f, 
    -0.51670241f, -0.92274374f, -0.39246514f, -0.10002853f, 0.54496080f, -0.27790371f, 0.30704501f, -0.84751505f, 
    0.35859856f, 0.69998235f, -0.01558230f, 0.27128211f, 0.15559418f, -0.05955669f, -0.72126091f, -0.96485746f, 
    -0.34209019f, 0.10964349f, 0.35809928f, 0.04704180f, -0.08566757f, -0.12600973f, 0.07314381f, 0.33305630f, 
    -0.17518637f, -0.51440042f, 0.09863353f, 0.07167153f, 0.12178196f, -0.24867585f, -0.78382409f, -0.08705982f, 
    0.32918310f, -0.31068057f, -0.62227708f, -0.23604064f, -0.09379879f, 0.12323578f, -0.00634072f, 0.80329841f, 
    0.09609708f, 0.74968398f, 0.13533232f, 0.20255414f, -0.28745392f, -0.76508045f, 0.12680495f, -0.88829350f, 
    -0.29616001f, -0.02334236f, 0.43516046f, 0.07489129f, 0.14777517f, -0.66686445f, -0.56168598f, 0.02188298f, 
    -0.05475058f, -0.30712485f, -0.51793563f, 0.13721070f, -0.26377821f, -0.97555941f, -0.54432237f, 0.02615378f, 
    -0.63441825f, -0.10088874f, -0.75127828f, -0.11001845f, -1.12149978f, 0.28846624f, -0.14624807f, -1.04588389f, 
    -0.52245462f, -0.79259139f, -0.07507419f, 0.15746830f, 0.12539159f, 0.25446004f, 0.67027795f, -0.14768621f, 
    0.15096661f, 0.28142595f, 0.37568271f, 0.14256789f, -0.08327057f, 0.08594818f, -0.11479968f, -0.04601359f, 
    -0.10580053f, -0.21266815f, 0.09137606f, 0.66935807f, 0.12375171f, 0.23786810f, -0.11867772f, 0.00858604f, 
    -0.03254196f, -0.18148829f, 0.47606489f, -0.05743546f, -0.04624233f, 0.38855439f, 0.14776301f, 0.08282649f, 
    -0.04321974f, -0.67863643f, 0.25040823f, 0.18892005f, 0.06720873f, -0.25203562f, 0.22369996f, -0.87041551f, 
    0.15404655f, -0.34627411f, 0.22104684f, -0.08718058f, -0.70108593f, -0.36302385f, -0.41906670f, -0.11680393f, 
    0.04043281f, 0.19183186f, -0.50968194f, 0.22619662f, 0.23665360f, 0.60485524f, -0.66701001f, -0.51969618f, 
    0.34975383f, -0.21706350f, 0.20650190f, -0.45805272f, -0.31758350f, -0.32464647f, 0.40284559f, -0.40689376f, 
    0.07872274f, -1.04328024f, 0.07167464f, -0.01391034f, -0.17299999f, 0.28159776f, 0.38323587f, 0.02927462f, 
    0.18487787f, 0.15946947f, -0.41142491f, -0.58982885f, 0.03132342f, -0.02478596f, 0.12240119f, 0.32584226f, 
    -0.17552924f, 0.95141429f, 0.09397078f, 0.11785748f, -0.11660449f, 0.08360469f, 0.32057479f, 0.17536974f, 
    -0.21081828f, -0.05102205f, -0.25256789f, -0.02352374f, -0.06706346f, -0.20706788f, -0.55201072f, -0.08567364f, 
    -0.05733521f, 0.38346663f, 0.00671664f, 0.12773114f, -0.36413610f, -0.18597093f, -0.39643076f, 0.16532394f, 
    -0.69569784f, 0.11719841f, 0.07023004f, 0.12051994f, -0.08351837f, -0.55465537f, -0.63065356f, 0.00095165f, 
    -0.46009490f, -0.59035856f, 0.14807779f, 0.31288618f, -0.02072211f, -0.03564929f, -0.58532602f, -0.83628094f, 
    -0.36500153f, -0.26517645f, 0.75296414f, -0.17512643f, -0.13501529f, -0.38193378f, -0.28710616f, -0.04003969f, 
    0.36736399f, 0.26567513f, -0.11293048f, 0.25785866f, 0.24127863f, -0.01412723f, -0.58566642f, 0.02902830f, 
    -0.12835857f, 0.35654852f, 0.38137695f, -0.39169133f, -0.02930276f, -0.58196658f, -0.12330047f, 0.14398167f, 
    0.20523994f, -0.80859149f, -0.10699695f, -0.70830780f, -0.11116958f, -0.46569699f, -0.71454799f, -0.29562578f, 
    -0.50041646f, -0.28299880f, -0.16456251f, 0.19135259f, 0.13369451f, 0.33507526f, -0.11267047f, 0.19463950f, 
    0.27005985f, -0.05052430f, -0.39352378f, 0.16998436f, 0.27776334f, 0.16490002f, -0.18792476f, -0.75274992f, 
    -0.39342824f, -0.86606365f, 0.16776150f, -0.01020982f, -0.35051280f, 0.17187458f, -0.23661886f, -0.11682409f, 
    -0.46205950f, -0.26798272f, 0.26094446f, -0.22602099f, -0.94833696f, 0.40696555f, 0.42078775f, -0.11735050f, 
    -0.01927134f, 0.00977129f, -0.33148786f, -0.60545075f, 0.17743291f, -0.42901281f, 0.08001367f, 0.00889199f, 
    -0.25334677f, -0.05484933f, -0.05168945f, -0.05686170f, -0.64288372f, 0.31593972f, 0.00850371f, 0.04452988f, 
    0.34229070f, 0.24201706f, -0.47056684f, -0.15176812f, 0.11272568f, -0.34202483f, -0.09882411f, 0.35795704f, 
    -0.12723185f, -0.32311821f, -0.06630131f, 0.20428154f, 0.06523429f, -0.19494812f, -0.03204731f, -0.31210110f, 
    -0.73259866f, -0.05646137f, -0.42331913f, 0.03879659f, 0.20972706f, -0.63383967f, 0.10290666f, -0.19912873f, 
    -0.22343048f, -0.43953064f, -0.01802444f, 0.00102635f, -0.01479961f, -0.26871407f, 0.32989201f, 0.15850526f, 
    0.59528470f, 0.16734987f, -0.26545858f, -0.06745826f, 0.04831302f, 0.74599797f, 0.12103965f, 0.11758998f, 
    -0.03903834f, -0.11075318f, -0.77977020f, -0.37854320f, 0.12409097f, 0.16805100f, 0.14040790f, 0.06838660f, 
    0.30744618f, -0.08876672f, 0.60484356f, 0.23390302f, 0.40323588f, -0.06013498f, -0.12376487f, -0.54824042f, 
    -0.17090470f, -0.46532276f, -0.09788519f, -0.08245244f, 0.00765411f, 0.03305302f, 0.08330368f, -0.35799050f, 
    -0.16036649f, -0.08147144f, 0.20882240f, -0.06256102f, -0.06792425f, 0.00061601f, -0.04414970f, 0.37983111f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13730061f, 0.21340756f, 0.14065613f, -0.08507541f, 0.03208423f, -0.16573520f, 0.03708904f, -0.15804601f, 
    0.10802810f, 0.35857347f, -0.00745198f, -0.31991118f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
