#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.88591868f, 0.20216464f, 0.65372568f, 0.52130359f, -0.95896107f, -0.06536084f, 0.35837978f, -0.10189720f, 
    0.14569658f, -0.22771049f, -0.71057355f, -0.33316085f, 0.93640107f, -0.23907658f, 0.98556978f, -0.20994407f, 
    -0.14879960f, -0.13808820f, -1.06137657f, -0.03683680f, -0.42843980f, 0.57954657f, 1.22302771f, -0.23823892f, 
    0.01816971f, -0.18235032f, -0.33997336f, 0.31973749f, 0.88144451f, 1.22956562f, -0.49876282f, -0.32781971f, 
    -0.42304793f, 0.27956942f, -0.40548506f, -0.33272129f, -0.90544474f, -0.57711279f, -1.04136252f, -0.30154705f, 
    0.59764314f, 0.83095145f, 0.34144452f, -0.00240304f, 0.60638565f, -0.75738835f, -0.70392394f, -0.53351855f, 
    -0.35041556f, 0.55476677f, -0.50413460f, -0.35877085f, 0.15329443f, 0.02452166f, -0.93028694f, 0.69065768f, 
    -0.00096305f, -0.37250343f, 0.45982870f, -0.86287576f, -0.15835837f, 0.15348610f, 0.18136992f, -1.09790683f, 
    0.07947678f, 0.37313971f, 0.12275521f, 0.52998650f, 0.67185873f, -0.08203828f, -0.00239888f, -0.53334433f, 
    -0.05481724f, -0.24927031f, 0.59405857f, -0.15237696f, -0.59627104f, -0.70673490f, -0.59987783f, -0.70499653f, 
    -0.03272583f, -0.77146059f, -0.47525787f, -0.22618984f, -0.38327053f, -0.39983085f, -0.75924098f, 0.60289353f, 
    0.07868708f, -0.36358377f, -0.94317913f, 0.34274429f, 0.69957018f, 0.13815951f, -0.57549626f, -0.04324154f, 
    0.39282385f, -0.06366757f, 0.61584169f, 1.06958008f, 0.75202560f, 0.71975356f, -0.49453837f, 0.24406274f, 
    -0.43593755f, -0.07985340f, 0.32272634f, 0.26828411f, -0.42434046f, -0.96697885f, -0.74778897f, -0.19271578f, 
    0.48859125f, 0.51944375f, -0.36543739f, -0.05656487f, -0.60804224f, 0.56070447f, 0.14183465f, 0.59392184f, 
    0.60651946f, 0.66725349f, 0.37898448f, -0.64332414f, -0.10936070f, 0.25966409f, 0.51809388f, 0.55617154f, 
    0.81664842f, 0.10189440f, 0.00722148f, 0.84913737f, 0.20303844f, 0.40447670f, 0.21639980f, 0.39896250f, 
    -0.29562998f, 0.38149846f, -1.00475919f, -0.89601117f, -0.66069525f, -0.06627440f, 0.43404096f, 0.28768235f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10364167f, -0.19268127f, 0.02082885f, -0.27425829f, 0.24549223f, 0.00787183f, -0.06298385f, 0.03781754f, 
    -0.18189429f, -0.30499819f, -0.30797282f, -0.08133116f, 0.04479814f, 0.06848327f, 0.21871975f, 0.29284617f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04666866f, 0.03657928f, 0.20297341f, -0.22380121f, 0.20583774f, -0.03555478f, -0.01673510f, 0.16772065f, 
    0.14232549f, -0.22144644f, -0.14880252f, -0.77531219f, 0.12272633f, 0.18431580f, 0.07221241f, -0.10781632f, 
    -0.22688912f, -0.20011041f, -0.17993866f, -0.18582350f, -0.24908176f, 0.08032775f, 0.03648186f, -0.09578791f, 
    -0.05818722f, -0.05019442f, -0.04164881f, -0.07537817f, 0.13385251f, 0.49733838f, -0.11924314f, -0.05451237f, 
    -0.05136660f, 0.20314077f, 0.06180649f, 0.03786361f, 0.36190408f, -0.05286357f, -0.50650609f, 0.25552428f, 
    0.12848483f, 0.07628214f, 0.22549926f, -0.07413701f, 0.01142300f, -0.13912913f, 0.11656162f, 0.19747148f, 
    0.10350960f, 0.05924534f, 0.09764921f, -0.07793613f, -0.17206055f, 0.11593147f, -0.38932809f, 0.30503401f, 
    -0.34290475f, 0.00790795f, 0.05559037f, -0.11880177f, 0.02394544f, 0.11474656f, 0.04790305f, 0.02936829f, 
    -0.08188386f, -0.31593156f, -0.01224053f, 0.26183525f, -0.14225705f, -0.20389515f, -0.02889439f, -0.12597834f, 
    -0.05683660f, 0.09206152f, 0.15539278f, -0.01450382f, 0.08734480f, -0.18395273f, 0.16721514f, 0.09785442f, 
    0.24605542f, -0.19300447f, -0.04147229f, -0.31492662f, 0.24941407f, 0.05630469f, -0.11613885f, 0.05837991f, 
    -0.00998149f, -0.10953674f, 0.01776759f, -0.20041426f, 0.09560351f, -0.06617135f, 0.02029967f, -0.16155243f, 
    -0.14058422f, -0.06322841f, -0.07180156f, 0.17020442f, 0.28001988f, 0.43013227f, -0.16122523f, -0.12085143f, 
    -0.08156401f, 0.02681118f, -0.11856874f, -0.00254994f, -0.06382272f, -0.20294850f, 0.08816062f, 0.13134333f, 
    0.12298986f, 0.11950628f, 0.03984883f, 0.26361623f, 0.08845891f, -0.05411500f, -0.06656295f, 0.08613361f, 
    0.09232172f, -0.15688622f, -0.09935243f, 0.19113913f, 0.25988644f, 0.00471827f, 0.06404674f, -0.17589289f, 
    0.27267012f, 0.00794580f, 0.13353428f, -0.07841828f, -0.02084368f, -0.16901515f, -0.01205120f, -0.09171221f, 
    -0.09797053f, 0.13569455f, -0.00853588f, -0.06596794f, 0.07577181f, 0.10127499f, -0.04627753f, 0.16658744f, 
    -0.34660539f, 0.07692038f, 0.02379955f, 0.14542286f, 0.00232484f, -0.02565783f, 0.20527448f, 0.18605442f, 
    0.09742565f, -0.09844928f, 0.20192352f, 0.00840541f, -0.25522190f, -0.22029530f, 0.06871540f, -0.01003765f, 
    -0.08813801f, 0.12497824f, 0.44576776f, 0.00053030f, -0.07046461f, -0.22844301f, -0.24610424f, -0.10642873f, 
    -0.11322735f, 0.08410965f, 0.08587472f, 0.29489991f, -0.00196037f, 0.22010878f, 0.04868693f, 0.03947845f, 
    -0.10881873f, 0.08274567f, -0.18320434f, 0.16910215f, 0.03300370f, 0.09429546f, 0.01676022f, 0.05368968f, 
    0.09636118f, -0.05070999f, -0.00044923f, 0.16478543f, -0.16960870f, -0.16138023f, 0.06207080f, -0.11257853f, 
    -0.14049077f, 0.00523448f, -0.12499135f, -0.09060571f, 0.03549616f, 0.29401824f, 0.27644095f, 0.00528623f, 
    -0.01977956f, 0.08389536f, 0.10313014f, 0.19669612f, 0.12127021f, -0.01466676f, -0.25641632f, 0.08278961f, 
    -0.15290850f, -0.14381097f, -0.30188298f, -0.11940002f, 0.03252575f, -0.10629385f, -0.11772778f, 0.03537192f, 
    -0.06076520f, -0.01617265f, 0.02174970f, 0.27642998f, 0.20191574f, -0.13191696f, 0.09130622f, -0.06283075f, 
    0.15029651f, -0.00380172f, 0.08124056f, -0.13323559f, 0.02456699f, -0.04773965f, -0.10209385f, -0.12039972f, 
    0.05765210f, 0.08089309f, 0.43548879f, 0.40793443f, -0.21577953f, 0.00491930f, -0.13431984f, 0.12789951f, 
    -0.11623929f, -0.08378013f, -0.04432239f, -0.14094700f, -0.02568735f, -0.07771462f, 0.25035560f, 0.08032021f, 
    -0.04210224f, 0.09226605f, 0.08972507f, -0.11968374f, -0.11837483f, -0.16566415f, -0.09560002f, -0.30980238f, 
    -0.08421348f, 0.00631698f, -0.02024090f, 0.07685724f, 0.10180937f, -0.43017557f, -0.28986979f, 0.09917030f, 
    -0.07768903f, 0.23412582f, -0.08908329f, 0.13168637f, -0.23806542f, -0.34824646f, -0.35634857f, -0.26718777f, 
    0.00647014f, 0.12028220f, 0.23714784f, 0.17277363f, -0.07951808f, -0.04542561f, -0.07788113f, 0.54330415f, 
    0.38722879f, -0.06318024f, 0.24588750f, 0.04947082f, -0.15808718f, 0.15047471f, 0.15243772f, -0.07619851f, 
    -0.02625814f, 0.01403674f, 0.03268251f, 0.00675240f, -0.07585181f, -0.04695931f, 0.03914245f, -0.06422970f, 
    -0.02821065f, -0.01376594f, -0.01566231f, -0.07492802f, 0.01917584f, -0.07010937f, -0.04782329f, -0.02658691f, 
    -0.05998082f, 0.03611704f, -0.01416228f, 0.01596877f, 0.04817648f, -0.01881897f, 0.05743614f, -0.05030123f, 
    -0.01168601f, -0.07959981f, -0.08117958f, -0.04502495f, -0.02834666f, 0.01170266f, 0.03708640f, 0.00634248f, 
    0.06395401f, -0.08227634f, -0.01136054f, 0.06560522f, -0.07517405f, -0.04595602f, -0.07265409f, -0.06076949f, 
    0.00275209f, 0.03075750f, 0.01226455f, 0.05181038f, -0.02285509f, 0.06072180f, 0.00079309f, 0.01492381f, 
    0.07282168f, 0.04160883f, 0.01650799f, -0.05734362f, 0.02683757f, -0.03600404f, -0.01034578f, -0.06753153f, 
    -0.03757335f, -0.04385298f, -0.07826518f, 0.03198913f, 0.02146860f, -0.06331266f, -0.03964291f, -0.06097962f, 
    -0.02628320f, -0.07333153f, -0.09009408f, -0.03261699f, 0.02063334f, -0.08845400f, -0.05575272f, -0.00117553f, 
    -0.00112930f, 0.05418794f, 0.05096454f, 0.03762302f, -0.06089962f, 0.01023179f, -0.07124560f, -0.00213514f, 
    -0.07140252f, -0.06333811f, -0.07321800f, 0.05235073f, -0.02572764f, 0.05930537f, -0.01728466f, -0.06773744f, 
    0.02782680f, -0.02344463f, -0.08322832f, -0.03222294f, -0.05605304f, -0.09361389f, 0.04740781f, 0.01196877f, 
    -0.03660031f, -0.08168489f, -0.00404950f, -0.03452259f, -0.05884880f, -0.02036823f, 0.05058504f, 0.04395939f, 
    -0.06533155f, 0.02695936f, 0.02299128f, -0.05415950f, -0.05004075f, -0.01746556f, 0.01716492f, 0.05409920f, 
    0.06451511f, -0.02866882f, 0.07542811f, -0.07200787f, 0.02452049f, -0.05660122f, -0.04426604f, 0.05396381f, 
    -0.04186272f, -0.07051526f, -0.01128241f, -0.05919965f, 0.06126155f, 0.00410766f, -0.01467034f, 0.05359999f, 
    0.06189798f, 0.05902655f, 0.02761649f, 0.01064095f, -0.05931571f, 0.03703755f, -0.07316393f, -0.06806760f, 
    -0.08875646f, -0.06845655f, -0.03623544f, 0.04830968f, 0.06644173f, 0.05087160f, -0.02733226f, -0.08931537f, 
    -0.40137827f, 0.14706159f, -0.12117793f, 0.11636159f, 0.03755790f, 0.10006033f, -0.01309521f, 0.04220577f, 
    0.06759714f, 0.11447974f, 0.39757654f, 0.36457968f, -0.06792890f, -0.40250343f, -0.10150462f, -0.03677976f, 
    0.06606421f, -0.07314122f, 0.24831112f, 0.06303086f, 0.19734636f, -0.06733859f, -0.08149664f, -0.09839220f, 
    0.16235206f, 0.25565347f, 0.13030592f, 0.02980922f, 0.16558754f, -0.31598541f, -0.01659390f, 0.24920817f, 
    0.19568774f, -0.18813290f, -0.01765184f, -0.20573790f, 0.37147281f, -0.06334078f, 0.09571164f, -0.06349271f, 
    0.08200245f, -0.05083143f, 0.03124966f, 0.06837998f, 0.01257441f, -0.09668162f, 0.11142144f, 0.26613811f, 
    -0.18148108f, 0.06672065f, 0.10024519f, -0.11177236f, 0.15248524f, -0.10899083f, -0.19122875f, -0.38973817f, 
    -0.61300009f, -0.02306741f, -0.19390106f, 0.07972482f, -0.12312610f, 0.10282584f, -0.01092575f, 0.31549412f, 
    -0.06665963f, -0.10452525f, 0.18333867f, -0.07599424f, -0.05105161f, 0.08295988f, -0.07815101f, 0.03535556f, 
    -0.16069973f, -0.49635515f, -0.15349801f, 0.15752536f, 0.19761391f, 0.01405469f, -0.12576847f, -0.16090609f, 
    0.05535021f, 0.37733236f, -0.05753816f, 0.34294719f, 0.02138846f, 0.16984813f, -0.16027060f, 0.15434049f, 
    0.07934798f, -0.12087739f, -0.04262244f, 0.18379642f, -0.21900904f, -0.23197541f, -0.16688712f, 0.02779635f, 
    0.11839154f, -0.08707596f, 0.14977603f, -0.37754175f, -0.18068656f, -0.01611444f, -0.09634893f, 0.03212118f, 
    -0.00957377f, -0.11229374f, -0.05100491f, 0.17708071f, 0.29137686f, -0.16747634f, 0.46849829f, 0.05745379f, 
    0.00985896f, -0.17506815f, -0.02799673f, 0.08277532f, 0.13972941f, 0.01872879f, -0.09433598f, 0.13841419f, 
    0.11584563f, 0.07585457f, 0.10441540f, 0.09182416f, 0.12571381f, 0.25027734f, -0.34609172f, -0.14377710f, 
    -0.20214145f, 0.14278512f, 0.15058380f, 0.16369367f, -0.12168425f, -0.13572796f, -0.01217860f, 0.09743802f, 
    0.15772523f, -0.26853332f, 0.00584216f, -0.13879962f, 0.19005169f, -0.13314438f, 0.08785618f, -0.11912368f, 
    -0.38638982f, -0.04473409f, 0.03284429f, -0.06472419f, -0.15003656f, -0.12855202f, 0.14870070f, -0.11823888f, 
    0.01204814f, -0.28907308f, -0.13458695f, 0.01420709f, 0.05254870f, 0.01981138f, 0.11020844f, -0.07627325f, 
    -0.12677038f, -0.12423371f, -0.22371067f, -0.03268387f, -0.01053081f, -0.04495368f, 0.08805291f, 0.19465390f, 
    0.02755783f, -0.01075217f, -0.03608855f, 0.01638434f, 0.37377468f, 0.44917548f, -0.01850082f, 0.03497215f, 
    -0.09543448f, 0.10172808f, -0.05832111f, -0.00425324f, -0.58148569f, -0.29771668f, -0.05839704f, 0.21721986f, 
    0.13674520f, 0.09556780f, 0.20069972f, 0.02096216f, 0.04777560f, -0.64882392f, 0.02724133f, -0.49763381f, 
    0.01916810f, -0.06604544f, 0.22330666f, -0.21455581f, -0.04384273f, 0.05965214f, -0.09372701f, -0.20392473f, 
    0.12242504f, 0.13605177f, 0.00159307f, -0.03315061f, 0.09033056f, 0.11454572f, 0.24184455f, 0.27129090f, 
    -0.07905590f, -0.18982486f, 0.07227887f, 0.01945097f, 0.21608901f, 0.08349277f, -0.04965637f, 0.02011378f, 
    0.29279843f, 0.00305259f, -0.06699654f, 0.10844427f, 0.07427444f, 0.14976451f, 0.24781001f, 0.28830501f, 
    0.03190767f, -0.29571006f, -0.03656656f, -0.18782170f, 0.32657656f, -0.08233412f, 0.08657674f, 0.18748479f, 
    0.07065395f, 0.16777816f, 0.07550087f, -0.54587227f, -0.20994700f, -0.11268255f, -0.09741627f, -0.01008852f, 
    0.01317045f, 0.10398993f, -0.09544014f, -0.01793881f, 0.45909217f, 0.31686291f, 0.00293981f, 0.11650869f, 
    0.14208609f, -0.19385950f, 0.02311859f, 0.07404294f, 0.34181595f, 0.36311370f, -0.48639920f, 0.19636500f, 
    -0.08725520f, 0.01583811f, -0.06032772f, -0.09889324f, 0.00255617f, -0.09998556f, -0.17455292f, 0.09268548f, 
    0.12695551f, 0.09463177f, 0.20636220f, 0.10226431f, -0.15398864f, 0.22961371f, -0.30751550f, 0.07657832f, 
    0.28141037f, 0.09016130f, 0.19976088f, 0.22296469f, 0.12285223f, 0.08054055f, -0.04827031f, 0.19763401f, 
    0.08008534f, 0.05323420f, -0.12374818f, -0.08912513f, 0.17737468f, 0.00201184f, 0.07619284f, 0.29268625f, 
    0.26732713f, -0.32627365f, 0.25914958f, 0.08468891f, 0.02272727f, 0.04112838f, 0.17118879f, -0.08552681f, 
    -0.13701549f, 0.03176600f, 0.19846518f, -0.14702268f, -0.11698066f, 0.08973803f, 0.01751176f, -0.02262412f, 
    0.13289300f, -0.21943428f, 0.15712841f, -0.18537021f, 0.17833182f, -0.04901354f, 0.00493493f, -0.09818210f, 
    -0.25703803f, 0.01984766f, 0.08057386f, -0.60141563f, 0.09769631f, -0.11733370f, 0.14292671f, -0.21194404f, 
    0.20030119f, 0.04357838f, -0.10126905f, 0.21108805f, -0.17031644f, 0.39274040f, 0.13788393f, 0.09532867f, 
    -0.05580563f, -0.12750538f, -0.00838397f, 0.11004233f, 0.15980928f, -0.25223550f, 0.33368397f, 0.08173305f, 
    -0.09923775f, -0.18903446f, -0.17138161f, -0.15768614f, 0.06760218f, -0.20165558f, 0.23338863f, -0.49594063f, 
    0.13338017f, 0.00858017f, -0.12351383f, 0.11705294f, 0.03670265f, -0.01950491f, -0.08004870f, -0.06774280f, 
    0.37948725f, 0.41517237f, -0.12702712f, -0.09753391f, -0.05155185f, 0.24132702f, 0.12643369f, -0.11849904f, 
    -0.23414339f, -0.12832062f, -0.12116161f, 0.23786449f, 0.08259687f, -0.16949300f, 0.07613081f, 0.20682913f, 
    0.07236503f, -0.52440518f, 0.19786933f, -0.43009996f, 0.34423220f, 0.11818688f, -0.22421411f, 0.26214921f, 
    0.07335500f, 0.16787955f, -0.44983849f, 0.15417075f, -0.10800004f, 0.13737467f, 0.16955188f, -0.30523393f, 
    -0.15890563f, 0.13378842f, 0.17286643f, -0.18826249f, -0.57930273f, 0.10984918f, 0.29927796f, -0.10102716f, 
    0.01692596f, -0.07526360f, -0.24256110f, 0.24331324f, -0.33378196f, 0.29830995f, 0.26636976f, -0.13244860f, 
    0.14717735f, 0.02439597f, 0.14922529f, 0.12586178f, -0.01499152f, 0.12840864f, -0.08186182f, -0.02874784f, 
    0.04336410f, -0.01496132f, 0.12199498f, -0.19067936f, 0.43985820f, -0.14125660f, -0.00342141f, 0.10247083f, 
    -0.15464196f, 0.26202819f, -0.16227396f, -0.19519348f, 0.06500559f, -0.10621358f, 0.00792422f, -0.03758993f, 
    -0.29247996f, -0.25201875f, -0.23468247f, 0.00756865f, -0.06020331f, 0.22208636f, -0.01127341f, 0.13010810f, 
    -0.14601947f, -0.49479368f, 0.35547158f, 0.13398404f, 0.15303469f, 0.17792112f, -0.00278973f, 0.03511561f, 
    0.07150516f, 0.18210013f, 0.12057084f, -0.31652647f, 0.17803380f, 0.25625125f, 0.04032909f, -0.08691373f, 
    0.30655524f, -0.06505590f, -0.01438225f, 0.00240884f, -0.14082824f, -0.30547881f, 0.05988857f, -0.04495515f, 
    0.24011429f, 0.00054831f, -0.04193931f, -0.00163965f, -0.21337867f, 0.21029550f, -0.10826330f, -0.09341324f, 
    0.24082798f, -0.40312168f, 0.05249184f, -0.07017628f, 0.11750399f, 0.45597368f, -0.24026388f, 0.02732605f, 
    0.01617752f, -0.10442197f, 0.13291660f, 0.12691265f, 0.00597099f, 0.15056485f, 0.22250578f, 0.15951909f, 
    -0.22053955f, 0.17863357f, 0.12533592f, 0.08724950f, 0.06660068f, -0.23561658f, 0.20747817f, -0.07661764f, 
    -0.17298117f, 0.04009803f, -0.02772817f, 0.12988397f, -0.17716506f, -0.09609319f, 0.18832529f, -0.15477638f, 
    0.02880196f, -0.00096704f, 0.23149425f, -0.09794977f, -0.18835044f, 0.00980479f, -0.00483717f, -0.02341201f, 
    -0.34510481f, 0.26205140f, 0.19003268f, -0.05356022f, 0.05809069f, 0.13723096f, -0.11243741f, -0.06854977f, 
    -0.05535841f, -0.15206915f, 0.37688634f, -0.14741011f, -0.03798745f, -0.05626582f, 0.20519233f, -0.01057735f, 
    -0.06783342f, 0.21717872f, -0.33965454f, -0.12607333f, -0.27240506f, 0.00337088f, -0.31107011f, -0.19514591f, 
    -0.01224586f, -0.20984618f, 0.14138521f, -0.10766825f, -0.81999397f, -0.01755862f, 0.09101314f, 0.13048354f, 
    0.16552901f, 0.05215399f, -0.08663581f, 0.05564244f, 0.23902643f, 0.12146197f, 0.09385776f, 0.07081946f, 
    -0.05127727f, -0.23391762f, 0.15631053f, 0.11208582f, 0.02384026f, -0.09131524f, -0.11545700f, 0.01465263f, 
    -0.23028691f, 0.10952687f, 0.03467112f, 0.06956974f, -0.09551056f, -0.01727407f, -0.59716195f, -0.19297653f, 
    0.10747638f, -0.03558966f, -0.15155104f, -0.09007498f, 0.19542770f, 0.17159571f, 0.23710476f, 0.40368810f, 
    0.21304901f, 0.03847861f, 0.10419358f, -0.04792976f, 0.20634808f, 0.05185212f, 0.04466347f, 0.06300006f, 
    0.21901619f, -0.02413658f, -0.31400338f, 0.01543387f, 0.14673553f, -0.15580733f, 0.05260945f, -0.01106526f, 
    -0.00952730f, 0.04399551f, -0.33515731f, 0.31823111f, 0.07876944f, -0.04398405f, 0.14242429f, -0.22268967f, 
    -0.05636423f, 0.14779118f, -0.24163207f, -0.26217648f, 0.04623038f, -0.13143678f, -0.17584980f, 0.10442639f, 
    -0.09179412f, 0.16917132f, -0.03578166f, -0.02826741f, 0.37268987f, -0.41490677f, 0.11292648f, -0.26242086f, 
    -0.04179868f, 0.07340600f, 0.05088170f, -0.07468269f, -0.18414488f, 0.01005202f, 0.29129010f, 0.12191640f, 
    0.20416254f, 0.20025799f, -0.12313579f, -0.22563975f, -0.19723810f, -0.35396767f, 0.07891198f, 0.46271497f, 
    0.22436067f, -0.03882283f, -0.02540992f, -0.00156358f, 0.06906653f, 0.33542475f, -0.11461987f, 0.39567348f, 
    -0.31945890f, 0.11650874f, 0.10663114f, 0.09003805f, 0.05824332f, -0.11881993f, -0.02355397f, -0.02601029f, 
    0.13661897f, -0.03716489f, -0.04521137f, 0.17142928f, 0.07152790f, 0.07318100f, -0.03083842f, 0.06822699f, 
    0.12165980f, -0.08300359f, -0.58128387f, -0.08196241f, -0.04532579f, 0.08520746f, 0.11931068f, -0.10368744f, 
    0.08706964f, 0.06643929f, 0.03357831f, 0.05634011f, 0.15580443f, 0.05531728f, 0.09997614f, 0.11534865f, 
    0.23199078f, 0.18329616f, -0.12613291f, 0.08584940f, -0.18026905f, -0.09976573f, -0.17560981f, 0.00299853f, 
    -0.10947879f, -0.02343895f, -0.13625483f, 0.27584475f, 0.41821200f, -0.11105145f, 0.06729558f, -0.03184665f, 
    -0.06529150f, 0.04660165f, -0.10448340f, -0.04115530f, -0.49225783f, -0.26330033f, 0.30622965f, -0.06575252f, 
    0.06501334f, -0.02436350f, -0.19958527f, 0.25799012f, 0.33293602f, -0.05010581f, -0.15417895f, -0.42302710f, 
    0.22793902f, 0.00469160f, 0.20670705f, 0.10757293f, -0.00645537f, 0.05320284f, -0.18660505f, 0.24221207f, 
    -0.24350908f, -0.05828043f, 0.25205365f, 0.00777668f, 0.06589835f, -0.18926512f, 0.12324970f, 0.00483821f, 
    0.07889416f, -0.22737624f, 0.26924312f, 0.12290017f, -0.08973639f, 0.30196917f, 0.15801466f, -0.07302593f, 
    0.50245225f, 0.19219816f, 0.00462320f, -0.09121145f, -0.06041124f, -0.04336187f, 0.12804846f, 0.14018720f, 
    0.06565815f, 0.36739999f, -0.13999529f, -0.10136047f, -0.13070397f, 0.05115475f, 0.12748879f, -0.09950268f, 
    0.06598008f, -0.03429820f, -0.85398096f, -0.24670993f, 0.04485480f, 0.04213965f, -0.01634154f, -0.05475201f, 
    -0.00746806f, -0.20551895f, -0.08843116f, -0.12038629f, 0.13262235f, 0.02868095f, 0.13356094f, -0.20513558f, 
    0.08764013f, 0.02351518f, -0.01137010f, -0.16920270f, -0.30313471f, -0.27546516f, 0.22742324f, -0.03806383f, 
    -0.06279793f, 0.20732681f, -0.13740587f, -0.02026516f, -0.12394229f, -0.39750662f, 0.04227240f, -0.07943753f, 
    0.14550754f, 0.30017993f, 0.04268246f, -0.06079038f, -0.05290179f, 0.04028617f, -0.31044605f, -0.11364977f, 
    0.20327836f, -0.01212327f, -0.04714119f, 0.17835003f, 0.02352718f, 0.09512553f, 0.11069626f, -0.58772433f, 
    -0.37304568f, 0.29866540f, -0.06923002f, 0.09490389f, -0.32021037f, 0.01135002f, 0.00111123f, -0.04259084f, 
    -0.07664806f, -0.19650340f, -0.20016289f, -0.05745655f, 0.03167177f, 0.05291571f, 0.09175762f, -0.05647877f, 
    0.28628588f, 0.01524796f, -0.17474930f, 0.00094271f, 0.25680441f, 0.12416454f, -0.14916550f, 0.26174462f, 
    0.02682641f, -0.11193759f, -0.25004572f, -0.04992219f, 0.09059285f, 0.00447584f, 0.10594901f, 0.01677594f, 
    0.02300680f, -0.10197195f, 0.02415133f, 0.43348789f, 0.12903002f, -0.08716776f, 0.24597077f, -0.03709767f, 
    -0.16837041f, -0.03020206f, -0.07711378f, 0.17516884f, -0.18041478f, -0.32080400f, -0.34331354f, 0.02146433f, 
    0.17923358f, -0.04780743f, 0.05489904f, 0.01538767f, 0.00689003f, -0.11661100f, 0.13642617f, -0.07632681f, 
    -0.15540479f, -0.05618123f, -0.06599274f, -0.09221736f, -0.01374421f, 0.11528301f, 0.36084726f, 0.22691503f, 
    0.27980945f, 0.37146723f, 0.11539178f, -0.06456639f, 0.09199294f, 0.08534284f, -0.01932063f, 0.13927464f, 
    0.28048649f, -0.11484876f, 0.01213778f, 0.13926032f, 0.14621955f, -0.06704649f, 0.02519282f, 0.00551095f, 
    -0.02815368f, -0.07767589f, -0.08019951f, -0.08490573f, 0.02981727f, -0.07894754f, -0.08233685f, -0.03470540f, 
    0.02031226f, -0.01721784f, -0.04161267f, -0.08841889f, -0.08642680f, -0.00351694f, -0.06679823f, 0.03497147f, 
    -0.09578310f, -0.01425613f, -0.07220496f, -0.08762270f, 0.00706346f, -0.09340402f, -0.05955777f, -0.06519326f, 
    -0.06838008f, 0.03581717f, -0.02467601f, -0.09791566f, -0.05295305f, 0.00342903f, 0.03642970f, -0.10203354f, 
    -0.04804840f, -0.06806645f, -0.05111010f, 0.03327390f, 0.03193253f, 0.01376704f, -0.03275250f, -0.03354157f, 
    -0.05011978f, -0.10998289f, -0.10925487f, -0.03910925f, -0.05569098f, -0.04040696f, -0.07786784f, -0.00649488f, 
    0.01218568f, 0.01572919f, -0.02390569f, -0.08227941f, -0.07619463f, -0.06342340f, 0.00319643f, -0.07029428f, 
    -0.11421031f, -0.01405046f, -0.02599726f, 0.01614464f, 0.01376722f, 0.00622928f, -0.07718568f, -0.02251801f, 
    0.04086385f, 0.02014161f, -0.08808191f, -0.00097132f, -0.06526233f, -0.09534220f, 0.02427047f, 0.03882428f, 
    -0.08798079f, -0.02323122f, 0.01139671f, 0.03453211f, -0.05807881f, -0.05000052f, 0.02573259f, -0.06671306f, 
    -0.11816674f, -0.04791643f, -0.02520540f, -0.03540229f, -0.06595518f, 0.00418027f, -0.09245538f, 0.03349204f, 
    -0.05004439f, -0.09975465f, -0.01518424f, -0.03338203f, 0.03692987f, 0.05080231f, -0.06587717f, -0.10426885f, 
    -0.01180961f, -0.05986908f, -0.01439723f, -0.02102719f, -0.10584074f, -0.02696298f, -0.05800616f, 0.02317021f, 
    0.02184341f, -0.07109447f, -0.03816158f, -0.11392575f, -0.02001055f, -0.03762719f, 0.06460062f, -0.08551373f, 
    0.00533935f, 0.00282424f, -0.07158029f, 0.02634603f, -0.09471779f, -0.03590107f, 0.03073674f, -0.10746336f, 
    -0.07960596f, -0.03581565f, -0.10302300f, -0.10633913f, 0.00296337f, -0.05742512f, -0.09043378f, -0.07580542f, 
    -0.00912841f, 0.00745952f, -0.11179560f, -0.08704764f, 0.01414922f, -0.00233237f, -0.00375256f, -0.01427907f, 
    -0.00351235f, -0.05645192f, -0.05564769f, -0.05718933f, 0.02764949f, -0.05539130f, 0.03705558f, -0.10096825f, 
    0.44443762f, -0.07524406f, -0.06565257f, 0.25744760f, 0.00861666f, -0.13747346f, -0.00798254f, 0.08874757f, 
    -0.11338189f, -0.12774421f, -0.07222294f, 0.10549448f, 0.02083584f, 0.17184137f, 0.17772278f, -0.07656964f, 
    -0.18510285f, -0.03744733f, -0.10555676f, -0.15730067f, 0.08913164f, -0.03907195f, -0.07639542f, -0.01874283f, 
    -0.38455588f, 0.12225841f, 0.01825365f, 0.71337157f, -0.10220935f, -0.07504751f, -0.03028375f, 0.17701666f, 
    -0.18308337f, 0.16758916f, -0.06904411f, -0.06870807f, -0.38892445f, 0.05228853f, 0.13739118f, 0.06289487f, 
    -0.00021639f, 0.00245330f, -0.01503281f, -0.02832669f, 0.07609664f, -0.02626515f, 0.14693248f, -0.35180208f, 
    0.02983925f, 0.00409046f, 0.04503336f, 0.08013275f, 0.01742113f, -0.06036569f, -0.11784819f, -0.18134166f, 
    -0.24336028f, -0.14989699f, 0.07869813f, 0.01372804f, -0.12145885f, -0.10356651f, -0.05274615f, -0.99108440f, 
    0.13817407f, -0.20474815f, 0.14338061f, -0.03387200f, 0.04504027f, -0.01725764f, 0.16465135f, 0.01173753f, 
    -0.16577247f, 0.09000067f, -0.20952578f, 0.00771481f, 0.19149201f, -0.01598388f, -0.19567205f, 0.09953014f, 
    0.22661977f, -0.09428088f, 0.23125468f, -0.25975680f, 0.12004266f, -0.08803871f, -0.06491502f, -0.16204773f, 
    -0.01955933f, 0.19032341f, -0.13398564f, 0.10186362f, -0.11095165f, -0.16171759f, 0.24817614f, 0.05491739f, 
    -0.02870773f, -0.02942289f, -0.26013950f, 0.47106528f, 0.10441346f, -0.04606912f, 0.14994779f, -0.00069999f, 
    0.03729437f, 0.08292477f, 0.02199012f, 0.08101734f, -0.24977748f, 0.20557003f, -0.08548151f, -0.15178423f, 
    -0.01294143f, -0.10286768f, 0.03114029f, -0.01784171f, 0.14632446f, -0.52357531f, -0.27828425f, 0.07958517f, 
    0.06004514f, 0.09322359f, 0.16184101f, 0.02673428f, -0.01676231f, 0.13514327f, 0.31675395f, -0.16530080f, 
    0.08518153f, 0.18292007f, -0.04584899f, -0.11033071f, -0.01129660f, 0.17357472f, 0.09366979f, 0.05185824f, 
    0.18968450f, -0.12331693f, 0.11173248f, -0.15129147f, -0.07920423f, 0.26281178f, 0.06130192f, -0.00292624f, 
    -0.07886027f, -0.12976258f, 0.19669923f, 0.12823713f, 0.24305086f, 0.10226071f, -0.21749242f, 0.23025939f, 
    -0.14328562f, -0.15078461f, -0.10494439f, 0.30866432f, -0.09231814f, -0.01082974f, -0.14332299f, 0.03691408f, 
    -0.09221794f, -0.21858425f, 0.31840268f, -0.05901336f, 0.12407885f, 0.02805922f, 0.06483947f, -0.10290660f, 
    -0.01980387f, 0.14940050f, 0.18674691f, -0.01615351f, -0.00849078f, 0.09152967f, 0.12728685f, -0.03184702f, 
    0.25434032f, 0.06743133f, -0.03913328f, -0.14986922f, -0.17669353f, -0.19000009f, -0.03245604f, -0.29181531f, 
    0.00489957f, 0.08043249f, 0.06028148f, -0.18431410f, 0.18714736f, -0.05426048f, -0.04167217f, -0.11938123f, 
    -0.04911729f, -0.05817394f, -0.12544893f, 0.00604009f, -0.02673927f, 0.09435061f, -0.04683990f, -0.17484637f, 
    0.24025971f, -0.11250630f, -0.16292259f, 0.13764665f, 0.06848262f, 0.14110291f, -0.03971834f, 0.06448294f, 
    0.15378833f, -0.25042096f, -0.30104712f, 0.19201897f, 0.12018685f, 0.08300722f, -0.00327874f, -0.02849942f, 
    -0.06004658f, 0.00440089f, 0.55711734f, 0.05637006f, 0.08813138f, -0.13578977f, -0.33316165f, -0.23355424f, 
    -0.29757890f, 0.45156181f, -0.40437827f, -0.13551152f, 0.01692083f, 0.02120578f, 0.09121436f, -0.05556405f, 
    -0.10130365f, 0.01690283f, 0.22042441f, 0.17438647f, 0.19176674f, -0.01448571f, -0.02814409f, -0.11495669f, 
    0.16498753f, -0.07394497f, 0.13766009f, -0.13384520f, 0.09535225f, 0.20997912f, 0.10738999f, -0.00204170f, 
    0.23692369f, 0.16939656f, -0.21450330f, -0.10091794f, -0.18313256f, -0.14919820f, 0.14475684f, -0.13433592f, 
    0.09331593f, -0.02315578f, 0.04324809f, -0.01338619f, 0.01492494f, -0.19494195f, 0.17661256f, 0.07335895f, 
    0.14282368f, 0.03546158f, 0.17674360f, -0.02172171f, -0.12922859f, -0.01539194f, -0.51037395f, 0.09958586f, 
    -0.04157352f, -0.14386278f, 0.19398619f, 0.33122873f, -0.11785143f, 0.05552040f, -0.05355683f, -0.00248936f, 
    -0.24621420f, 0.16191399f, -0.07242870f, -0.09131804f, -0.43687794f, -0.01456342f, -0.07634918f, 0.01555723f, 
    -0.32096779f, 0.04756553f, -0.53997111f, -0.16235319f, 0.05254164f, -0.00899960f, -0.11357412f, 0.09954095f, 
    -0.11407102f, 0.69064242f, 0.07819035f, 0.03813636f, 0.06130828f, 0.18758486f, 0.13376650f, -0.03774654f, 
    0.04567178f, -0.02499986f, -0.22971855f, 0.50898045f, 0.18270907f, 0.04904598f, -0.13631539f, 0.20505466f, 
    0.11726596f, 0.07112277f, 0.23716570f, 0.17552879f, -0.62921947f, 0.11666164f, -0.15390459f, 0.01196536f, 
    -0.01231842f, 0.06527576f, -0.11086956f, -0.04354582f, 0.31446779f, -0.21250415f, 0.08461034f, 0.06280886f, 
    -0.04837577f, 0.01951732f, 0.01059906f, -0.03964198f, -0.03976291f, -0.23951630f, 0.15497039f, 0.43215579f, 
    0.05173764f, 0.18725140f, -0.03754222f, -0.02853541f, 0.04824219f, -0.00970449f, 0.41407049f, 0.00460220f, 
    0.05208546f, -0.12024457f, -0.11272857f, -0.12067028f, 0.05166244f, -0.15034284f, -0.01736614f, 0.12375808f, 
    0.09193781f, -0.11133654f, 0.03905033f, -0.11588621f, 0.05187096f, 0.12117191f, 0.09410781f, -0.07487400f, 
    0.21709667f, -0.17888716f, 0.16492921f, 0.02672005f, -0.06649850f, -0.10443872f, -0.02336047f, -0.04451127f, 
    -0.10904359f, -0.06411737f, 0.28937167f, 0.08054625f, 0.05182917f, 0.10223628f, -0.02708077f, 0.06853015f, 
    0.05709227f, 0.07426054f, 0.05721417f, -0.13793391f, 0.01199811f, -0.08618522f, -0.20082580f, 0.01230309f, 
    0.12592551f, -0.03448606f, 0.03324695f, -0.11621005f, -0.29937771f, -0.14478976f, -0.37944663f, 0.06826785f, 
    0.11000589f, -0.00153956f, -0.09487394f, 0.07713548f, 0.28892723f, -0.08448747f, 0.26847577f, 0.17719465f, 
    0.13626766f, -0.05830035f, -0.06760165f, 0.15986273f, 0.07537578f, 0.10674951f, -0.30066130f, -0.25314182f, 
    -0.04846337f, 0.27295831f, 0.04732257f, 0.10489970f, -0.03421843f, -0.15977505f, -0.13196641f, -0.04732533f, 
    0.04423445f, 0.02867278f, 0.05465485f, 0.22497374f, 0.07344756f, -0.03776001f, -0.18180285f, 0.15023714f, 
    -0.08091480f, -0.12222987f, -0.49732155f, -0.07116122f, -0.29832834f, -0.16001363f, -0.27812970f, 0.20832402f, 
    -0.17854436f, 0.32232437f, 0.24789488f, 0.07229661f, 0.07048961f, -0.00593168f, 0.09217080f, -0.07826118f, 
    0.02099736f, -0.12186301f, 0.35748482f, -0.15260872f, 0.06451195f, -0.10273027f, -0.08849633f, 0.17169017f, 
    -0.16682400f, -0.23076704f, -0.08516373f, -0.34180182f, -0.22353967f, -0.16300188f, 0.14705193f, 0.12332077f, 
    0.05302853f, -0.11361728f, -0.06561106f, -0.06291065f, -0.07688617f, 0.12648623f, 0.18224692f, -0.20697601f, 
    0.09823737f, -0.05465340f, -0.09460392f, 0.07285283f, 0.35669407f, 0.24882993f, 0.01851382f, 0.06527329f, 
    -0.10572203f, 0.09636843f, 0.03017418f, -0.12266382f, 0.12731385f, -0.03054370f, 0.16784081f, -0.15221541f, 
    0.03077188f, 0.10650914f, 0.07570168f, 0.16440220f, -0.12611805f, 0.15499561f, -0.47285983f, -0.06565904f, 
    -0.46073675f, 0.13719261f, 0.30428880f, 0.07979903f, -0.08448108f, 0.12923281f, -0.02362340f, -0.02235328f, 
    0.08941242f, -0.11409631f, 0.04830597f, 0.04641290f, -0.18630725f, -0.07188090f, -0.03121805f, -0.18054578f, 
    -0.08749244f, 0.05841849f, -0.31397039f, -0.17481202f, 0.25567555f, 0.15617442f, -0.36952940f, 0.10148961f, 
    -0.00219617f, 0.11872379f, -0.11931419f, -0.23448916f, 0.04843015f, 0.12612876f, 0.22768533f, 0.02090284f, 
    0.15323941f, -0.19105911f, -0.10910369f, -0.18831693f, -0.26509318f, -0.08499642f, 0.03262470f, -0.12964909f, 
    0.27372599f, 0.01050088f, 0.02377531f, -0.13334371f, 0.01053786f, -0.02738127f, 0.20585878f, -0.07820461f, 
    -0.06999675f, -0.22226997f, 0.15038376f, 0.13000712f, -0.03328964f, 0.16223989f, 0.01733970f, 0.11895617f, 
    -0.31177950f, -0.18971685f, 0.00664668f, 0.07826164f, -0.21270747f, 0.44524786f, 0.24661306f, 0.04139563f, 
    0.06801710f, -0.36617234f, -0.12886234f, 0.05129144f, 0.27341324f, 0.16316305f, 0.04596542f, 0.04879433f, 
    0.06057718f, 0.28017673f, -0.11707335f, -0.04242694f, 0.07094297f, -0.00926264f, 0.46072093f, -0.34263745f, 
    -0.13883913f, -0.24527270f, 0.16341428f, 0.11312138f, 0.31499130f, -0.00009729f, 0.05078484f, 0.07948525f, 
    -0.08554867f, -0.07519659f, 0.03869957f, -0.08574557f, -0.03646700f, 0.02538518f, -0.05463990f, -0.08985129f, 
    0.06273323f, 0.02519787f, -0.00968688f, 0.06020122f, 0.03209821f, 0.00761313f, -0.09072927f, -0.05219563f, 
    -0.07781231f, 0.05294704f, -0.04464507f, 0.04637663f, 0.01770909f, -0.04331930f, 0.03659314f, 0.00415845f, 
    0.04164930f, 0.05679584f, -0.03287802f, 0.07056603f, 0.04775475f, 0.08132157f, -0.07682156f, 0.05426480f, 
    0.00505631f, -0.01844183f, -0.06671631f, 0.06154639f, -0.06241136f, -0.07096401f, 0.05928623f, 0.04358240f, 
    -0.08646437f, -0.06348510f, -0.01453660f, -0.03422629f, -0.04872955f, -0.01204745f, -0.00106629f, -0.02912315f, 
    -0.00164532f, -0.05523541f, -0.07011508f, 0.03364239f, 0.03006707f, 0.00587393f, 0.05413463f, -0.05934346f, 
    -0.05573513f, -0.05899323f, -0.02120407f, 0.00919759f, -0.09465902f, -0.07877264f, -0.02905226f, -0.05090868f, 
    -0.05026579f, -0.07428262f, 0.01709227f, -0.06943258f, -0.09091946f, 0.05103034f, -0.08233665f, -0.08942973f, 
    0.04476324f, -0.09075179f, -0.06215786f, -0.03379185f, 0.06837159f, 0.05259189f, -0.05141138f, 0.01813076f, 
    -0.00671841f, -0.08850938f, -0.06878242f, -0.00629687f, 0.07774238f, -0.02229711f, 0.05570634f, 0.04109220f, 
    -0.08308464f, -0.02690960f, -0.07009720f, 0.02580965f, -0.00790827f, -0.04425830f, 0.02524310f, 0.04086132f, 
    0.04652261f, -0.03729544f, -0.04657398f, -0.08950347f, 0.04798264f, -0.05407543f, -0.02463459f, -0.03034583f, 
    -0.03563014f, 0.03779476f, -0.01086166f, 0.00550157f, -0.05934304f, 0.01365828f, -0.08437710f, -0.07392468f, 
    -0.07527734f, 0.03078377f, -0.02809725f, 0.01512839f, 0.00821774f, -0.04858838f, 0.02266074f, 0.04772881f, 
    0.04985494f, -0.01949348f, 0.04121800f, 0.08467456f, 0.07533349f, 0.04728684f, 0.00799216f, -0.01453843f, 
    0.04715900f, -0.05040225f, -0.04368479f, -0.08327894f, -0.03616328f, 0.00827321f, 0.03750435f, -0.03090364f, 
    0.03128689f, -0.00591710f, -0.04636262f, -0.01753221f, 0.01039424f, 0.00682194f, -0.04128249f, -0.05274164f, 
    -0.33816096f, -0.28204095f, 0.27071500f, -0.01414162f, 0.04418600f, 0.12131085f, -0.12329748f, 0.10113810f, 
    -0.08918566f, 0.04986481f, 0.27431995f, -0.29833081f, 0.21154876f, -0.00413966f, 0.04493233f, 0.01613136f, 
    -0.24754634f, 0.00724056f, 0.76551378f, -0.18235463f, 0.16302368f, -0.19670646f, -0.02894419f, -0.13994244f, 
    -0.06012163f, -0.08300010f, 0.01851946f, -0.08105308f, 0.20960209f, -0.00871504f, -0.33294383f, -0.01076350f, 
    -0.10970150f, 0.02088027f, -0.06118265f, 0.01444419f, 0.48101419f, 0.24690700f, -0.01980859f, 0.11146727f, 
    0.02578672f, -0.04028871f, 0.10481506f, -0.02936522f, 0.01120737f, -0.07464164f, 0.01573186f, 0.16369735f, 
    0.18982324f, 0.09798416f, 0.00890782f, 0.04769058f, -0.15489915f, -0.11091624f, -0.00527129f, -0.21350875f, 
    -0.57244498f, 0.08428803f, 0.15010855f, 0.14911769f, 0.12306974f, -0.10299081f, 0.08400204f, -0.25777063f, 
    0.27242717f, -0.10794085f, -0.00178433f, -0.00280333f, -0.00252008f, -0.09216926f, -0.03180834f, -0.05856173f, 
    -0.17926471f, -0.07349316f, -0.06874729f, -0.03471268f, 0.16831943f, -0.03446412f, -0.03323951f, -0.01276517f, 
    0.11892012f, -0.66428733f, -0.74064451f, -0.25891960f, 0.09061002f, -0.01345639f, 0.19329597f, 0.14311631f, 
    0.16297695f, 0.10383757f, -0.15275230f, 0.21010132f, -0.49738500f, -0.02203143f, -0.09946144f, 0.07595582f, 
    0.08244465f, 0.09703957f, 0.10448752f, 0.29588833f, 0.19575411f, -0.14469245f, 0.03167863f, -0.29196650f, 
    0.13181889f, 0.07718100f, 0.20072719f, -0.08158965f, -0.13021450f, 0.00956974f, -0.26534340f, -0.04036648f, 
    -0.10670879f, 0.07602423f, 0.22470762f, 0.07768970f, 0.18630022f, 0.05803584f, 0.21922605f, 0.24998388f, 
    -0.13631178f, -0.06695219f, 0.06696744f, 0.01568669f, 0.27544886f, 0.33770457f, -0.24202687f, -0.04667913f, 
    -0.08032495f, 0.10704104f, -0.05982606f, 0.03619435f, -0.03804429f, -0.20301127f, -0.03003953f, 0.09177355f, 
    0.00179068f, 0.10582442f, 0.19188707f, 0.08814853f, 0.03383921f, 0.07687788f, 0.18853283f, 0.10474696f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.20461538f, 0.02807221f, -0.05952405f, 0.03058702f, 0.09531292f, -0.15550721f, -0.01337920f, 0.26593709f, 
    0.04657632f, 0.00425326f, -0.17586465f, -0.15639086f, -0.29147339f, 0.25048262f, -0.05008122f, 0.08211959f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16175546f, 0.31898743f, 0.18592930f, -0.32463813f, 0.03307547f, -0.29158795f, -0.01149763f, 0.39905643f, 
    0.23833086f, -0.11095459f, 0.61954188f, 0.15421045f, -0.12568271f, -0.15654390f, -0.21434349f, 0.49692196f, 
    0.30402857f, 0.53094167f, -0.12808387f, -0.53604954f, 0.04047835f, 0.13751476f, 0.45045745f, 0.19432266f, 
    -0.76806843f, 0.07740792f, 0.47542289f, 0.49313098f, -0.08728951f, -0.25325826f, 0.20843695f, -0.13461253f, 
    -0.59377849f, 0.23360258f, -0.14852640f, 0.40410542f, 0.05668685f, 0.21869205f, -0.03788320f, 0.24865021f, 
    -0.20866174f, 0.17642573f, 0.34733495f, 0.12816088f, -0.56458956f, 0.45496494f, -0.10221357f, -0.06085641f, 
    -0.08129051f, -0.00154456f, -0.20287803f, -0.22030869f, -0.18365842f, 0.18248516f, -0.05403244f, -0.01384848f, 
    0.09059587f, 0.15102524f, -0.08955577f, 0.23354608f, -0.13802525f, -0.24203137f, -0.12079290f, -0.15580693f, 
    0.10854899f, 0.04448382f, 0.09103283f, 0.46919382f, -0.46307653f, 0.03891686f, 0.13960752f, -0.50846756f, 
    -0.06977905f, -0.06124750f, 0.37470615f, -0.01644009f, 0.06081426f, 0.51827449f, -0.13713939f, 0.41206121f, 
    -0.21086335f, 0.49214828f, -0.25347096f, 0.73564720f, 0.18141276f, -0.55707282f, -0.52082741f, 0.47925350f, 
    0.21449849f, 0.24903554f, -0.34231678f, 0.13929525f, 0.12952112f, -0.00697261f, 0.12800685f, 0.14248899f, 
    0.07770614f, 0.07505040f, -0.08042046f, 0.10738517f, -0.24208570f, 0.34836167f, -0.68318862f, 0.47378960f, 
    -0.22904283f, 0.05818601f, -0.23092304f, -0.26051289f, 0.02387813f, -0.02921571f, 0.15231399f, 0.53695107f, 
    -0.24002281f, -0.34240460f, -0.16582698f, 0.60632032f, 0.12691912f, -0.01883400f, 0.35364470f, 0.29205850f, 
    -0.63140142f, 0.09953880f, 0.13744752f, -0.11670152f, 0.24695987f, -0.50536549f, 0.13698699f, -0.34661123f, 
    -0.12342172f, -0.23830567f, 0.04787697f, 0.00149281f, 0.17911875f, 0.01073349f, 0.26339167f, -0.23843974f, 
    -0.33219457f, 0.09822920f, -0.31715792f, 0.32617876f, 0.68832201f, -0.33653048f, 0.20830263f, 0.15703768f, 
    0.21004303f, 0.08603227f, 0.22080784f, -0.08854268f, -0.11315506f, 0.34031698f, 0.00461474f, 0.63798153f, 
    -0.26278907f, 0.04338137f, -0.71693099f, -0.12813179f, 0.39771059f, -0.23885509f, -0.11969166f, -0.20974565f, 
    0.48191732f, -0.39822412f, -0.10987959f, -0.37899807f, 0.41926590f, 0.64597082f, -0.05070407f, -0.14082076f, 
    0.21283413f, -0.08207061f, -0.38521230f, -0.62780100f, -0.11656546f, 0.42988610f, 0.01234794f, 0.17641906f, 
    -0.71848148f, 0.42900860f, 0.13090277f, 0.14024815f, -0.06039184f, -0.18819636f, 0.22695117f, 0.33767918f, 
    -0.16405828f, 0.05580296f, 0.00324607f, -0.28352317f, 0.19936755f, -0.11929277f, 0.12322462f, 0.38019753f, 
    -0.14370254f, -0.06905594f, -0.01169318f, 0.08351023f, 0.39813575f, -0.14925927f, 0.26223290f, 0.06226663f, 
    -0.45473331f, -0.16065730f, -0.64747119f, -0.06060409f, 0.50020951f, -0.09293991f, -0.03726222f, -0.32642362f, 
    0.01616575f, -0.14014255f, -0.17220685f, 0.27106762f, 0.41322574f, -0.54327685f, 0.00805218f, -0.06357370f, 
    -0.11026649f, 0.08125936f, -0.29917657f, -0.72600907f, -0.16600025f, 0.37995893f, 0.19133879f, 0.57868552f, 
    0.38215968f, -0.39105543f, 0.01465957f, 0.09978174f, -0.27068353f, -0.38169760f, 0.38935229f, 0.00664003f, 
    -0.44244051f, 0.23370963f, -0.34136862f, -0.15080222f, 0.04817405f, 0.43795690f, 0.15086630f, 0.51191539f, 
    -0.14283097f, -0.05438225f, 0.14646673f, 0.56476498f, -0.17639434f, 0.38273850f, -0.26263785f, -0.17898534f, 
    -0.34724808f, 0.15819465f, 0.54375398f, 0.19600736f, 0.40724757f, 0.02118267f, -0.08519703f, 0.34704918f, 
    -0.62411642f, 0.22854827f, 0.14694440f, 0.61574441f, -0.50575000f, 0.00800758f, 0.58090287f, -0.14370097f, 
    -0.28710416f, 0.16620944f, 0.48050663f, 0.44434997f, 0.17598870f, 0.26594916f, -0.05056320f, -0.34280306f, 
    -0.14291804f, 0.40067667f, 0.19503750f, -0.12315743f, 0.13599098f, 0.57028276f, 0.34277049f, 0.17858016f, 
    0.48707360f, -0.15827428f, 0.40723109f, -0.09956955f, 0.35984284f, -0.13565822f, 0.08388229f, -0.52441841f, 
    -0.09238878f, 0.26496822f, 0.02043993f, -0.40610710f, -0.19795568f, 0.16651736f, 0.25637442f, 0.55026239f, 
    0.27416968f, 0.07865737f, 0.19029389f, 0.29490930f, -0.37934726f, 0.61829484f, -0.26720756f, -0.26956040f, 
    -0.12225869f, -0.17413074f, -0.22296876f, -0.10968587f, -0.01541380f, 0.22720270f, 0.01539961f, -0.24773252f, 
    -0.17282076f, -0.07738531f, -0.19550240f, 0.13759112f, -0.05037113f, -0.20981346f, -0.16741210f, -0.11683980f, 
    0.38020387f, -0.03430917f, 0.24498919f, -0.30007017f, 0.12810339f, 0.27660668f, -0.20579967f, 0.43547729f, 
    -0.82633626f, -0.14601523f, 0.38342464f, 0.06194227f, 0.24515672f, 0.13707189f, -0.09679373f, -0.11191699f, 
    0.28708208f, 0.22101265f, -0.18254107f, -0.24752633f, -0.23526794f, 0.30327642f, -0.04605104f, 0.56586707f, 
    -0.36713940f, 0.10064445f, 0.18584941f, 0.30807564f, 0.37828237f, -0.54994971f, 0.13917504f, 0.36504471f, 
    0.41406301f, 0.03772398f, 0.18478708f, -0.41431820f, 0.23723955f, -0.44885087f, -0.71853167f, 0.51995081f, 
    0.04858717f, -0.24040590f, 0.56609660f, -0.12823661f, 0.35025513f, 0.22205715f, -0.05301539f, -0.02611973f, 
    0.03467952f, 0.31708854f, 0.06692655f, 0.05410570f, -0.18123932f, 0.14591406f, 0.11862843f, 0.07458745f, 
    0.61453807f, 0.03474974f, 0.36236358f, -0.39262861f, -0.07664909f, -0.06623378f, 0.06430908f, 0.47955206f, 
    0.17418899f, 0.01344972f, 0.04832916f, -0.18117964f, 0.37067053f, 0.03941135f, -0.20179872f, 0.06285441f, 
    -0.18092157f, 0.02817066f, -0.00180178f, -0.25026751f, 0.59051478f, 0.26994121f, 0.06405732f, -0.42730722f, 
    -0.01400882f, 0.05048481f, -0.16973642f, -0.14611797f, 0.37672278f, -0.11602414f, 0.44136274f, 0.18370391f, 
    0.38434047f, -0.04328946f, 0.69535935f, -0.32033226f, -0.53270715f, 0.65623766f, 0.17502925f, -0.42598221f, 
    0.23144849f, -0.38839316f, 0.01270487f, -0.00788805f, 0.05620182f, 0.56397301f, 0.61370528f, -0.09881842f, 
    0.32752815f, -0.01064911f, -0.45855808f, -0.36388737f, -0.38516638f, 0.50852597f, 0.07647029f, 0.05784553f, 
    -0.04839363f, -0.22983053f, -0.22379449f, -0.13013111f, -0.19993997f, 0.05722629f, -0.04407924f, 0.04966056f, 
    -0.21557301f, 0.16883396f, -0.22791304f, -0.02825434f, -0.23222412f, 0.17047516f, 0.02307123f, 0.04975593f, 
    -0.09585702f, -0.30380228f, 0.23216063f, -0.21039498f, 0.28224388f, -0.30757865f, 0.38894224f, -0.31610626f, 
    0.31517598f, 0.03862381f, -0.07392354f, -0.08344781f, 0.55825365f, -0.12774798f, -0.09428014f, 0.30142990f, 
    -0.04422966f, 0.74478030f, -0.10031415f, -0.14611788f, 0.32058522f, -0.06997840f, -0.01121635f, 0.05401014f, 
    -0.17367953f, 0.24237065f, 0.37591338f, 0.40484884f, -0.03997635f, -0.47481230f, 0.19250463f, 0.18637651f, 
    0.16749363f, -0.19318017f, -0.00553957f, -0.61187875f, 0.65100163f, -0.13455908f, -0.18670179f, 0.08714525f, 
    0.87754685f, -0.00074407f, 0.35019135f, -0.80046839f, -0.14825249f, -0.05722359f, 0.17504671f, -0.04774635f, 
    0.42437139f, 0.20180598f, -0.06817875f, -0.37763306f, 0.07694246f, -0.42940572f, -0.14181314f, 0.42479065f, 
    -0.17117086f, -0.17358609f, -0.29837963f, 0.65399373f, 0.18099947f, 0.03949901f, -0.15773137f, 0.26426563f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.27335843f, -0.00573805f, 0.55022824f, -0.21745294f, 0.20064203f, 0.24295802f, -0.05703619f, 0.22738169f, 
    -0.82392818f, 0.26026672f, 0.21074018f, 0.39773241f, 0.03733933f, 0.58976299f, 0.27147934f, 0.00860056f, 
    0.09365635f, 0.09766170f, 0.62144732f, -0.01803024f, 0.26153874f, 0.05049737f, 0.40436196f, -0.18156579f, 
    -0.08916283f, 0.39319670f, 0.11146318f, 0.14580776f, 0.19527993f, 0.32382238f, 0.35559997f, 0.11359353f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02356863f, -0.15474723f, -0.52343774f, 0.15481745f, -0.01500548f, -0.14877552f, 0.52475584f, -0.75775981f, 
    0.22445132f, 0.24846442f, 0.20452970f, 0.09991233f, -0.27292502f, 0.29230952f, 0.33175614f, 0.18418854f, 
    -0.71581626f, -0.23427743f, -0.77602524f, 0.13607606f, 0.29441452f, 0.46144140f, -0.18276864f, 0.13093869f, 
    -0.28475678f, -0.47442141f, -0.06199118f, -0.12829562f, 0.11114937f, 0.10669824f, -0.27357504f, 0.01136291f, 
    0.19098961f, -0.49464330f, -0.43671128f, 0.05441889f, 0.40879175f, -0.26132542f, -0.27731642f, 0.60630566f, 
    -0.19776241f, -0.06572730f, 0.23546490f, -0.57165217f, -0.49508411f, 0.38957742f, 0.54882616f, -0.00027183f, 
    0.28694868f, -0.74481255f, -0.01935102f, -0.03700344f, -0.48757038f, -0.34144285f, 0.20160119f, 0.12221809f, 
    -0.54942697f, 0.15019099f, 0.34714907f, -0.00447432f, 0.18812166f, -0.42626363f, 0.16458987f, -0.02726546f, 
    0.07801835f, -0.59867173f, 0.49190724f, 0.13671407f, 0.09242867f, 0.78321046f, 0.47797891f, -1.38188875f, 
    -1.23745692f, -0.80267316f, -0.54380953f, 0.38228592f, -0.69508678f, 0.27258468f, -0.38937092f, 0.52635896f, 
    -0.97098547f, -0.55052006f, -0.32619184f, -0.17050025f, -0.74359882f, -0.11808107f, 0.05014776f, 0.19739091f, 
    -0.73632592f, -0.04336827f, -0.58947247f, 0.01280717f, -0.61794060f, 0.38614938f, -0.27711302f, -0.18064746f, 
    0.04897118f, 0.69793773f, -0.28391334f, 0.16908243f, 0.00452751f, -0.43652385f, -0.27937832f, -0.09227812f, 
    0.28704742f, 0.15525888f, -0.47177678f, 0.28199977f, 0.14886416f, -0.87735742f, -0.11872754f, -0.17199764f, 
    0.26267031f, 0.16852030f, 0.24470916f, -0.06937991f, -0.30476272f, 0.32546806f, -1.16012168f, -0.08340023f, 
    -0.75667089f, -0.06134304f, -0.06712788f, -0.11462295f, 0.01432142f, 0.34865445f, -1.01302481f, 0.16234380f, 
    -0.28147131f, 0.17456597f, -0.11542058f, -0.13928421f, -0.08294392f, 0.07823065f, 0.18032020f, 0.38701513f, 
    -0.26736557f, 0.40105262f, 0.13120972f, -0.38494197f, 0.29282266f, -0.09095023f, 0.05828992f, -0.10980047f, 
    -0.83032602f, -0.37286702f, 0.11125571f, -0.14433244f, 0.60897762f, 0.11947308f, 0.34934387f, -0.45668769f, 
    0.34393859f, 0.05374553f, -0.10901493f, -0.00882577f, -0.62739432f, 0.03396841f, -0.34084839f, 0.33076864f, 
    -0.20756628f, -0.31486967f, 0.50074869f, -0.06515057f, -0.22682349f, -0.11740220f, -0.48810029f, 0.00410209f, 
    0.72387892f, -0.44323486f, 0.45147407f, -0.05821254f, 0.34953696f, 0.39868245f, -0.04661336f, -0.49610460f, 
    0.06935902f, -0.36768508f, -0.11199075f, 0.11834111f, -0.08659542f, -0.70416361f, -0.01665332f, -0.25259754f, 
    0.32609752f, 0.19297042f, 0.19267896f, -0.05964166f, 0.27127680f, -0.15965746f, 0.55665374f, -0.17026801f, 
    0.13695614f, 0.48624995f, -0.72961485f, 0.11387926f, -0.23734921f, -0.00562386f, -0.87911779f, -1.47719669f, 
    -0.58809507f, -0.34416538f, 0.02817095f, -0.71780813f, -0.22813775f, 0.06290155f, -0.69981068f, -0.17073707f, 
    -0.54928887f, 0.34624562f, -0.27413085f, 0.05014950f, -0.09560121f, 0.05153447f, 0.12644528f, 0.14913595f, 
    0.27897817f, 0.13084801f, -0.11097964f, -0.04416373f, 0.26567456f, 0.51988620f, 0.44710615f, 0.02322653f, 
    -1.09206796f, -0.48820904f, -0.70452714f, -0.04144417f, 0.17463435f, 0.08442368f, 0.26819438f, 0.19618317f, 
    0.47573379f, 0.45768476f, -0.14705704f, -0.05609827f, 0.32571849f, -0.63151932f, 0.03811206f, 0.45083627f, 
    0.29344091f, 0.35653427f, -0.76487094f, -0.02359202f, -0.21120198f, 0.06772452f, -0.32480529f, -0.31465498f, 
    0.71773684f, -0.77912426f, -0.25484127f, -0.13591252f, 0.28115097f, -0.71509099f, -0.41192776f, -0.07792786f, 
    -0.43375427f, -0.43548211f, 0.45836866f, -0.03022428f, 0.09304393f, -1.04458618f, -0.37161803f, -0.77516556f, 
    0.01482666f, -0.38015813f, 0.52003497f, -0.33733889f, -0.18484591f, -0.25930840f, -0.41302544f, 0.20239426f, 
    -0.18585272f, 0.60067940f, 0.39276811f, -0.13185254f, -0.02125942f, -0.53585267f, -0.44186679f, 0.14270751f, 
    0.12361471f, 0.40060559f, 0.63069510f, -0.04580064f, -0.52190059f, -0.54471332f, 0.10472018f, -1.19148088f, 
    0.11838692f, -0.78727955f, -0.11047880f, 0.07413795f, -0.68876863f, 0.33972555f, 0.30870852f, -0.20266464f, 
    0.23818216f, 0.42586070f, -0.17325349f, 0.12698124f, 0.27647004f, -0.17033818f, -0.22006483f, -0.57987589f, 
    -0.35996598f, 0.13746609f, 0.23999050f, -0.06239966f, 0.02170118f, 0.23189650f, 0.27153024f, 0.05816996f, 
    -0.11142208f, 0.11324664f, -0.10377375f, 0.05743308f, -0.26714492f, -0.16381934f, 0.31619382f, -0.04820249f, 
    -0.28319988f, -0.07330265f, 0.39579320f, -0.16865504f, 0.20176098f, 0.27640265f, -1.08119226f, -0.05303732f, 
    -0.85735267f, -0.08318213f, -0.44846350f, 0.30445659f, -0.02880969f, 0.21726499f, 0.23444435f, -0.10843001f, 
    0.63479364f, 0.24716245f, 0.05536950f, -0.17072979f, -0.41149479f, -0.39913025f, -1.16031814f, -0.07436929f, 
    -0.52659214f, 0.20795086f, 0.05207521f, -0.03620350f, -0.18887004f, 0.04892956f, -0.84652555f, -0.41168660f, 
    0.26217431f, 0.36691853f, 0.09312559f, -0.15027744f, 0.15090223f, -0.41467938f, -0.45734006f, -0.09329078f, 
    -0.55490065f, -0.33649629f, -0.54499269f, 0.10185292f, -0.54350364f, -0.11207102f, -0.16674379f, 0.42006224f, 
    0.16988908f, 0.05591227f, -0.06349756f, 0.16546005f, 0.55092627f, 0.29990152f, 0.11853310f, -0.05425962f, 
    0.02093398f, 0.09714715f, -0.56052095f, -0.05062322f, 0.08004628f, 0.12460122f, -0.13940783f, -0.24447021f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05269806f, 0.27685857f, -0.15091623f, -0.27148882f, 0.32150605f, 0.24726026f, -0.04945872f, -0.47602239f, 
    -0.43504271f, 0.14734630f, 0.41451299f, -0.02942954f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
