#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.48553780f, -0.18657762f, 0.49816680f, -1.10034215f, -0.01698137f, 0.08246206f, -0.18924332f, -0.14817542f, 
    0.45836183f, 1.05738318f, 0.80267245f, 0.40983397f, -0.83461326f, 0.09903351f, -0.14571156f, -0.13422309f, 
    0.19022273f, -0.33780393f, -0.60196835f, -0.35758242f, 0.16959725f, -0.60870671f, -0.52240002f, 0.02049487f, 
    0.07196166f, 0.60370588f, -0.26588857f, -0.35606766f, -1.13642263f, 0.41101253f, 0.65869415f, 0.37841904f, 
    0.47284856f, -0.16914436f, -0.39495298f, 0.11830015f, 0.34207672f, -0.60463601f, -0.31559175f, 1.01525247f, 
    1.01570082f, -0.69505394f, -0.33185273f, -0.13534325f, -0.41254273f, 0.84126437f, 0.45006233f, 0.41532308f, 
    0.58929467f, 0.57320046f, 0.33773932f, -0.48348579f, -0.05478873f, -0.38196650f, 0.37865856f, 0.65192884f, 
    0.61920923f, 0.49146220f, -0.62509149f, 0.55609018f, -0.57576084f, -0.32531929f, -0.07232969f, -0.57578099f, 
    0.40683246f, 0.18695574f, 0.64541584f, -0.20905183f, -0.67024881f, 0.57181287f, 0.48897806f, -0.43978840f, 
    -0.72974908f, -0.39622453f, -0.18356039f, 0.62558693f, 1.09811354f, 0.33007035f, -0.09590583f, -0.35206181f, 
    0.29971364f, -0.16638404f, 0.95055443f, 0.95750356f, -1.12354314f, 0.85315883f, -0.07263961f, 0.13200234f, 
    0.44225061f, -0.03170580f, -0.15595473f, -0.91487044f, -0.80056316f, -0.65205789f, 0.15180404f, -0.05077743f, 
    -0.22999699f, 0.08573879f, 0.39095229f, 0.68323398f, 0.78990006f, 0.68052840f, 0.38601416f, -0.61430919f, 
    0.23893748f, 0.35988072f, 0.07310432f, 0.28301042f, 1.10550749f, -1.06381369f, 0.66356170f, 0.18702006f, 
    -0.04376372f, 0.10306944f, -0.05768630f, 0.01272494f, -0.17799337f, 0.09889369f, -0.71418560f, 0.91107237f, 
    0.15677527f, -0.40918818f, 0.72527498f, 0.27621418f, -0.42017493f, -0.07559751f, 0.00984199f, -0.92064363f, 
    -0.53437829f, 0.37752181f, -0.24409623f, 0.83471286f, 0.04391905f, -0.33337736f, 0.14495946f, 0.18652603f, 
    -0.70681232f, -0.40285411f, -0.73595673f, -0.45573804f, -0.02948808f, -0.20775938f, -0.09941038f, 0.62850231f, 
    -0.56992525f, -0.42742071f, -0.45907986f, -0.14949386f, 0.63582301f, 0.07260542f, -0.21129005f, -0.07556693f, 
    -0.64104545f, -0.80266476f, 0.01963460f, -0.57660145f, 0.36314389f, 0.84352535f, -0.63141978f, 0.73418891f, 
    0.08810131f, 0.15063435f, -0.72686595f, -0.36717334f, -0.45071393f, -0.66901016f, -0.14845420f, -0.81602424f, 
    0.38715601f, 0.24826282f, 0.08651671f, 0.24049848f, 0.19805247f, -0.54459769f, -0.20935267f, -0.06049780f, 
    0.81845003f, -0.38207513f, 0.58808738f, -0.58718896f, 0.43209931f, 0.32290918f, 0.85249996f, -0.47378954f, 
    -0.72125292f, -0.96106631f, -0.05557474f, 0.42210716f, 0.01141497f, 0.30662540f, -0.58248335f, -0.48577341f, 
    0.54414135f, -0.76914030f, -0.50197548f, -0.18621248f, -0.23719361f, 0.46640673f, -0.48365781f, -0.65095496f, 
    -0.64094585f, 0.24398617f, -0.46539208f, -0.17262292f, -0.52053130f, -0.00133594f, -0.01039574f, -1.07011676f, 
    0.45086628f, 0.72039706f, 0.64436430f, 0.79479563f, -0.20893246f, 0.15746337f, -0.29553714f, -0.30918667f, 
    0.22720282f, 0.62996441f, 0.30040357f, 0.55225080f, 0.63602179f, 0.53466064f, 0.45240140f, 0.03527927f, 
    -0.18518332f, 0.03425167f, -0.39424172f, -0.07648842f, -0.45213172f, -0.74249274f, -0.27415022f, -0.40328380f, 
    0.24237901f, -0.55224705f, -0.63945037f, -0.76880026f, -0.17650834f, 0.65215278f, -0.23077974f, 0.46297500f, 
    0.02636368f, 0.37789285f, -0.62370521f, -0.03819397f, -0.37852797f, 0.36182609f, 0.38207895f, -0.62380129f, 
    -0.75761944f, -0.34486979f, -0.06454321f, 0.08801414f, -0.63073254f, -0.78046781f, -0.48905358f, -0.26412645f, 
    -0.08387262f, 0.69423890f, -0.23068327f, 0.36368182f, 0.28615040f, 0.10149036f, -0.67110991f, 0.80467105f, 
    -0.11073969f, -0.53061020f, 0.87572986f, -0.20177832f, -0.39548701f, -0.10616900f, 1.02075422f, 0.27143794f, 
    0.06193625f, -0.36712953f, 0.38620853f, -0.01460662f, 0.22947013f, -0.25702092f, 0.41188374f, 0.40086856f, 
    -0.69275194f, -0.82200897f, -0.84327012f, -0.62118340f, -0.29933250f, 0.23477407f, -0.16724353f, -0.33262777f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.42729655f, -0.11238620f, 0.17502142f, -0.12402054f, 0.11602078f, 0.17836547f, 0.00187721f, 0.07505388f, 
    0.04932415f, 0.13810316f, 0.17691673f, 0.23743580f, 0.03687031f, -0.07111482f, 0.09949759f, -0.19043730f, 
    -0.04935587f, 0.19807923f, -0.00993882f, 0.11542454f, 0.03283177f, 0.24860170f, -0.16507475f, 0.18804771f, 
    0.33772299f, 0.16999243f, 0.04532880f, 0.12311730f, -0.26892442f, 0.11652736f, 0.34399995f, 0.19515949f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15798029f, -0.19331639f, 0.04739539f, 0.17541830f, 0.08103219f, 0.05801931f, 0.00381619f, 0.02784874f, 
    -0.04242631f, 0.17303818f, -0.08402465f, 0.05130778f, 0.16471101f, -0.03531419f, 0.03358023f, 0.00571331f, 
    0.01646529f, 0.04473456f, -0.09028495f, 0.06907462f, -0.28471044f, -0.22079140f, 0.43680951f, 0.24133763f, 
    -0.10912921f, -0.02009611f, 0.17046766f, -0.07258578f, -0.06142585f, 0.07404503f, 0.00893216f, -0.11447784f, 
    0.09316462f, -0.04058361f, 0.10080318f, -0.00484391f, -0.16107535f, -0.03646878f, 0.07702565f, -0.02501061f, 
    0.22767371f, -0.01031464f, -0.00546592f, 0.09826354f, 0.21291977f, 0.08364192f, -0.05580167f, -0.02584046f, 
    -0.05260725f, -0.05564480f, 0.15339340f, 0.08473865f, -0.01732627f, 0.11013160f, 0.11496411f, -0.05647992f, 
    0.03003428f, 0.04251082f, 0.11589078f, -0.08475341f, 0.01068362f, -0.14000511f, -0.33949947f, -0.10395062f, 
    0.08006524f, -0.01191936f, -0.04164128f, -0.07369702f, 0.02464411f, 0.01095869f, -0.12923840f, -0.00553912f, 
    0.07385629f, 0.14548014f, 0.09603895f, 0.09369830f, 0.07780918f, -0.00890867f, -0.01827917f, 0.05720979f, 
    -0.34333047f, 0.27225509f, -0.10789257f, -0.07258843f, 0.11934466f, 0.07655357f, 0.03848884f, -0.01527583f, 
    0.04137030f, -0.03634016f, 0.11461610f, 0.00108439f, -0.08299956f, 0.01176115f, 0.09731878f, 0.15055786f, 
    0.12533745f, 0.01631930f, -0.01643080f, -0.04306938f, -0.22430913f, 0.18520777f, 0.13929151f, 0.11623538f, 
    0.01797929f, 0.03129021f, 0.10124590f, -0.03491653f, 0.00683149f, -0.04938207f, 0.02993960f, -0.10509323f, 
    0.01576892f, 0.00072423f, 0.09876325f, 0.15103206f, 0.03686091f, 0.02534355f, -0.00231556f, -0.06977444f, 
    -0.15754803f, 0.13362090f, 0.08538838f, 0.01533445f, -0.08766492f, -0.04307153f, 0.11741151f, -0.03979172f, 
    0.04405076f, -0.02407642f, -0.00952477f, 0.11450758f, 0.10093051f, -0.01293263f, -0.03167620f, -0.03895904f, 
    -0.05566329f, -0.03710778f, 0.01551853f, 0.01600324f, 0.04491967f, 0.14290652f, 0.06918320f, -0.23406386f, 
    0.01884153f, 0.11052477f, 0.01330300f, -0.14874828f, 0.11996890f, 0.01197205f, 0.12103192f, -0.03975016f, 
    0.06330842f, 0.06007300f, 0.09586692f, -0.02491242f, 0.07681583f, 0.05219140f, -0.19522394f, -0.03526694f, 
    -0.38064399f, -0.11980854f, -0.24933305f, -0.09835669f, 0.01231507f, -0.02538338f, -0.03525669f, 0.15429556f, 
    0.00502138f, 0.08982642f, 0.08333461f, -0.08607038f, -0.02775922f, 0.08012103f, 0.09062792f, -0.04097412f, 
    0.14949098f, 0.01496473f, 0.06050351f, 0.07577253f, -0.14424343f, -0.16202179f, 0.25333878f, 0.07283620f, 
    -0.11983325f, 0.02589390f, -0.06390889f, -0.00283071f, 0.05280802f, 0.02919597f, -0.00813200f, 0.06525721f, 
    -0.00581477f, 0.11643120f, 0.07077149f, -0.03938047f, 0.02994801f, -0.04064744f, 0.13225910f, -0.08638388f, 
    -0.42385224f, 0.11404870f, -0.21480101f, -0.01127790f, 0.09795760f, 0.11364404f, 0.06019240f, -0.03932171f, 
    -0.02015951f, 0.02265158f, 0.04755188f, 0.13995828f, -0.01347310f, -0.01815136f, -0.00931143f, 0.06870704f, 
    -0.07876304f, -0.02341708f, 0.03846207f, -0.03227417f, -0.16294163f, 0.01536223f, 0.04935597f, 0.17699338f, 
    -0.17091659f, -0.02144316f, 0.11176226f, -0.11292861f, 0.02973089f, 0.04371421f, -0.03322284f, -0.06202061f, 
    -0.04092890f, -0.04574745f, 0.12753132f, -0.05479774f, -0.00620509f, 0.02472233f, 0.09972512f, 0.04070871f, 
    0.03634542f, 0.01356119f, 0.17108773f, 0.20445664f, -0.08367196f, -0.04226747f, -0.03333311f, -0.08124284f, 
    -0.09537864f, -0.06113255f, -0.08616014f, -0.08048547f, 0.05577949f, 0.11563385f, 0.01388562f, -0.01028294f, 
    -0.00863804f, 0.08679171f, -0.05414565f, -0.02091106f, 0.44848573f, -0.20712560f, -0.05806951f, -0.05639959f, 
    0.00273471f, 0.01746262f, 0.04268296f, -0.07874044f, 0.06555870f, -0.14477453f, -0.03304594f, 0.03405956f, 
    0.02879719f, 0.06726214f, 0.05928828f, 0.01813350f, 0.04359062f, -0.09949403f, -0.13377626f, 0.02345818f, 
    -0.33787915f, -0.22568057f, -0.24505927f, -0.17386709f, 0.05695791f, 0.08521411f, -0.03349381f, 0.03432196f, 
    0.04932242f, -0.05587619f, -0.06580763f, 0.06065669f, -0.01411351f, -0.05756690f, 0.04046081f, 0.05257838f, 
    0.00177361f, 0.02732280f, 0.00457848f, -0.00504030f, -0.13489884f, 0.12908700f, -0.12198666f, 0.22686590f, 
    0.15683752f, 0.02551109f, -0.06643642f, -0.20278330f, -0.03011518f, -0.04164287f, 0.01970766f, 0.07526385f, 
    0.07106259f, 0.08307026f, 0.00437249f, 0.10506104f, 0.03110047f, -0.13722669f, -0.12401715f, 0.17622633f, 
    -0.30219105f, 0.03694687f, 0.02016919f, 0.03326245f, 0.22593942f, 0.11998800f, 0.01775184f, 0.15240340f, 
    0.07823175f, -0.03847397f, -0.04308609f, -0.16565683f, 0.06973770f, 0.09992443f, -0.01537873f, 0.05005877f, 
    -0.01345329f, -0.00729431f, 0.18357301f, 0.07476623f, -0.57154500f, 0.04775539f, 0.09514092f, -0.14868605f, 
    0.08152857f, 0.04454431f, 0.01007927f, 0.14349711f, 0.00227898f, -0.09418102f, -0.06168889f, 0.09196164f, 
    -0.04741308f, 0.04842643f, 0.06588487f, -0.14702006f, 0.08222312f, -0.02916424f, -0.14915144f, 0.13031289f, 
    -0.10785220f, 0.11241302f, 0.12661809f, 0.07540446f, 0.23545636f, 0.08986742f, 0.03198801f, 0.02610478f, 
    0.02269489f, 0.00385211f, 0.04158089f, 0.14877583f, 0.11300556f, 0.14514798f, 0.17336112f, -0.14389378f, 
    0.05885410f, 0.08661097f, 0.03317095f, 0.11625700f, -0.12648667f, 0.01808380f, -0.09537226f, 0.08367299f, 
    -0.07064154f, 0.01215620f, 0.16541572f, 0.05817375f, 0.08649771f, 0.04366526f, 0.03014735f, -0.05984328f, 
    -0.08070390f, 0.06670890f, 0.13754162f, 0.02217486f, -0.13294369f, -0.00450677f, -0.10998551f, 0.02558593f, 
    -0.05338987f, 0.05325864f, 0.21899723f, 0.14285831f, -0.14436060f, -0.07808890f, 0.11493982f, -0.10901793f, 
    0.02561565f, 0.01411617f, -0.09464677f, -0.05067528f, 0.08428025f, 0.21737939f, 0.19260171f, -0.04335448f, 
    -0.04888337f, 0.02662059f, 0.09317124f, 0.02659082f, 0.17420907f, 0.05298433f, -0.22927831f, -0.07036626f, 
    -0.12293982f, -0.01642253f, 0.01516683f, -0.01299345f, 0.00258602f, 0.02101387f, 0.25810906f, 0.04293108f, 
    0.06543376f, -0.01640339f, 0.12359107f, 0.05440595f, -0.01881199f, 0.21440911f, -0.00761177f, 0.15242033f, 
    -0.07022921f, -0.08689523f, -0.19049816f, 0.03255810f, 0.07369690f, 0.11258610f, 0.19808753f, 0.05067633f, 
    0.07647335f, 0.17120509f, 0.05499681f, 0.19723813f, 0.02997004f, -0.08902745f, 0.17551094f, 0.06186076f, 
    0.07264305f, 0.11719625f, 0.10681593f, 0.12688480f, -0.02279971f, 0.10382538f, -0.02883364f, -0.01144085f, 
    -0.14840277f, 0.01315650f, 0.04016053f, -0.03729506f, 0.00940244f, -0.11252426f, 0.01867379f, -0.09259064f, 
    -0.06714570f, 0.01585598f, -0.05810412f, -0.07492426f, 0.09978686f, 0.01720649f, 0.03079363f, 0.08682454f, 
    -0.14237548f, 0.17189993f, -0.13937026f, 0.12199528f, -0.04100368f, 0.07303519f, -0.09109949f, -0.07168986f, 
    0.05487658f, 0.00036745f, 0.08174592f, -0.02806808f, 0.07445680f, -0.04351625f, -0.03429409f, 0.20611419f, 
    0.02950843f, 0.01669300f, 0.05314512f, -0.00259946f, 0.23798512f, 0.01691496f, -0.10658358f, 0.07708070f, 
    0.03988076f, -0.00458251f, 0.02384030f, 0.06377623f, 0.03088550f, 0.11568163f, 0.06519669f, 0.09260463f, 
    0.03620630f, -0.06960978f, 0.08387173f, -0.14289407f, 0.03271931f, -0.03394912f, 0.18666239f, 0.06098213f, 
    -0.28741139f, -0.07778097f, -0.26532641f, -0.10572718f, 0.09527899f, 0.07063787f, -0.06730567f, 0.09644622f, 
    -0.00981030f, 0.00286404f, 0.00541897f, 0.01059945f, -0.04580619f, 0.02229591f, 0.18678652f, 0.08672734f, 
    -0.00004937f, 0.06297983f, 0.00027033f, -0.03710467f, 0.11914884f, 0.16857971f, -0.00523066f, 0.00783667f, 
    -0.00703487f, -0.06671344f, 0.04555457f, -0.02320529f, 0.08082788f, -0.13649286f, 0.17277107f, 0.21621285f, 
    -0.00124337f, 0.07166007f, 0.07686321f, 0.03771772f, 0.13965115f, 0.20394449f, 0.01677477f, 0.03513207f, 
    -0.43437925f, 0.03977974f, -0.26882216f, -0.08077767f, 0.16512555f, 0.08549622f, 0.17307793f, -0.03867051f, 
    0.07244540f, 0.00758540f, 0.03026503f, 0.11354849f, -0.09039093f, 0.00344692f, 0.02700101f, -0.09487333f, 
    0.05062339f, -0.02046969f, 0.03467110f, 0.00295410f, 0.37546575f, -0.12087230f, -0.01246744f, -0.05484722f, 
    0.09215744f, 0.07990262f, 0.08916131f, -0.06604125f, 0.00543251f, -0.02535467f, -0.04058341f, 0.01451295f, 
    -0.06954271f, -0.03418888f, 0.04449511f, -0.01794442f, 0.07148213f, -0.08384636f, -0.07488355f, 0.05001638f, 
    0.04145942f, 0.00199360f, 0.20309383f, 0.04272669f, 0.00618624f, -0.08935216f, 0.15916450f, -0.06393089f, 
    -0.08701263f, 0.03302277f, -0.01931286f, -0.10451269f, 0.11060731f, 0.01281298f, 0.02334340f, 0.05083225f, 
    0.01370976f, -0.06368236f, 0.09907628f, -0.02224734f, -0.11659355f, 0.18713695f, -0.25538930f, 0.09586509f, 
    -0.04746164f, 0.11566923f, -0.00142527f, 0.08638618f, 0.00058699f, 0.01435160f, 0.05470826f, 0.09053145f, 
    0.09514899f, -0.09751011f, 0.14727110f, -0.06054422f, 0.22611532f, -0.02535471f, 0.03053131f, 0.17955384f, 
    0.01779182f, -0.02710086f, 0.01627522f, -0.01794608f, -0.04196806f, 0.02721469f, -0.00694456f, -0.03362127f, 
    0.02319244f, 0.01849084f, -0.00199675f, 0.01908525f, 0.01769711f, 0.03075838f, -0.04178645f, -0.03611314f, 
    0.00270714f, -0.04011765f, 0.00011626f, -0.00632794f, -0.01387240f, 0.02920680f, 0.00384756f, -0.03872247f, 
    0.02268504f, -0.03371119f, 0.01697565f, 0.02120464f, -0.04024906f, -0.00213693f, 0.01594685f, 0.03970128f, 
    0.02433319f, -0.02483307f, -0.01856691f, -0.01186034f, -0.01245186f, -0.03136046f, 0.01495917f, -0.04306334f, 
    -0.00985173f, -0.03201620f, -0.03189328f, 0.00888448f, 0.00963563f, -0.01482342f, -0.01256859f, 0.00549066f, 
    0.00851530f, 0.02071160f, -0.00755460f, 0.01024049f, -0.04747377f, -0.01482728f, 0.02988893f, -0.00756862f, 
    0.01487601f, -0.01345209f, -0.02151366f, -0.02178505f, -0.03115479f, -0.04014735f, -0.01866647f, -0.01231164f, 
    -0.03642244f, -0.00065416f, -0.02249647f, -0.01070164f, -0.00700728f, 0.01960060f, -0.00536792f, -0.03355729f, 
    -0.00972744f, -0.00355543f, -0.00020075f, 0.02192977f, 0.01609210f, 0.00292338f, 0.00115228f, 0.00912840f, 
    0.02405232f, 0.04241886f, -0.04277840f, -0.01645763f, -0.03380837f, -0.02148768f, 0.00908862f, 0.00734687f, 
    0.02424064f, -0.03571564f, -0.00607995f, 0.01809675f, 0.01639587f, 0.01996409f, 0.00615843f, 0.00077799f, 
    0.00770459f, -0.04653597f, 0.01910890f, -0.00928346f, 0.02667416f, -0.00099268f, -0.00822477f, -0.03971349f, 
    0.01182653f, -0.01763440f, 0.02243679f, -0.01473898f, -0.03377981f, -0.01150505f, -0.01805798f, -0.02538768f, 
    0.01387597f, -0.00067651f, 0.00812729f, 0.01878530f, -0.01143395f, -0.00846335f, -0.00275243f, -0.02146405f, 
    -0.03952091f, 0.00313969f, -0.01186411f, 0.00016526f, -0.01680608f, -0.01098073f, 0.00577480f, -0.03806019f, 
    -0.01181666f, -0.02458477f, 0.03629937f, 0.02295052f, -0.01958130f, -0.04156342f, -0.00706061f, 0.02268631f, 
    0.02007322f, 0.01840467f, 0.01007279f, -0.02686812f, -0.02380792f, -0.02569338f, 0.00568249f, -0.00879408f, 
    -0.01727269f, -0.02568923f, -0.01048098f, -0.01438815f, -0.01665841f, -0.02901207f, -0.01601999f, 0.01546830f, 
    0.01569644f, -0.01214223f, 0.01058144f, -0.02961095f, 0.01817133f, 0.00936221f, -0.03685395f, -0.04486474f, 
    -0.02504201f, -0.04036497f, -0.00864098f, -0.00645406f, -0.01582568f, -0.01276259f, 0.01583432f, 0.03364519f, 
    -0.03697614f, 0.01714872f, -0.00654098f, 0.01917939f, 0.01657558f, 0.00272479f, -0.00093622f, 0.02179417f, 
    0.01598281f, -0.02832160f, -0.00246625f, -0.00429045f, -0.00373451f, 0.01860166f, -0.00396609f, -0.03395322f, 
    -0.04106579f, 0.02930495f, 0.02639403f, -0.02193412f, -0.01305510f, -0.00203179f, 0.02144299f, -0.00779781f, 
    0.01205881f, -0.02839162f, -0.03749667f, -0.03561268f, -0.03710390f, 0.01212707f, -0.02331376f, -0.04115659f, 
    -0.01936384f, 0.02324019f, -0.04004515f, 0.00315991f, -0.01351247f, 0.00875422f, 0.00332003f, -0.00759601f, 
    -0.01846143f, -0.04498333f, -0.02979725f, -0.00011713f, -0.03649054f, -0.03924218f, -0.02997618f, -0.00081441f, 
    -0.04127866f, -0.03290272f, -0.02173328f, 0.02356979f, 0.00804984f, 0.02725625f, -0.04212590f, -0.00877094f, 
    -0.02211535f, -0.02781172f, -0.02452971f, -0.04239429f, 0.02438033f, -0.04436828f, -0.02021806f, -0.03429141f, 
    0.02147986f, -0.03766079f, -0.01337875f, 0.00184764f, -0.02585220f, -0.00915556f, -0.00665300f, 0.00018702f, 
    -0.00079072f, 0.01987111f, 0.01701017f, 0.00960558f, 0.00520658f, -0.01604054f, -0.01250456f, 0.02286535f, 
    -0.03912083f, 0.01699106f, -0.04588787f, -0.00830160f, -0.02478947f, 0.01426340f, -0.03732684f, -0.04569056f, 
    -0.04448229f, -0.01174864f, -0.03701007f, 0.01049673f, 0.02405204f, 0.01707238f, 0.01733541f, -0.03519727f, 
    0.01910831f, -0.00907329f, -0.04189441f, -0.02542254f, -0.03305968f, -0.02179408f, 0.03172738f, -0.02733957f, 
    -0.02651693f, -0.00836832f, -0.01573420f, 0.00109384f, 0.01794792f, 0.02447258f, 0.01182009f, -0.00689652f, 
    -0.04718989f, 0.01814684f, 0.01997536f, 0.00176404f, -0.02123259f, -0.03278523f, 0.00288847f, -0.04090346f, 
    0.02514987f, 0.00717805f, -0.04169677f, -0.01974605f, 0.01338660f, -0.03477060f, 0.02332274f, -0.00942481f, 
    -0.00987772f, -0.04355371f, 0.02021671f, 0.00235878f, -0.02006446f, -0.03445464f, 0.00581310f, -0.02071460f, 
    -0.04294463f, -0.02184447f, -0.02459428f, -0.00238106f, -0.03150819f, -0.00327750f, -0.03811732f, 0.00631118f, 
    0.02296171f, -0.00593310f, 0.03055509f, -0.01318625f, -0.02309276f, -0.02686718f, -0.02062364f, 0.00006439f, 
    -0.01259578f, -0.03093170f, -0.02990631f, -0.04734063f, -0.04452207f, -0.02196248f, -0.03703636f, -0.00150404f, 
    -0.04301590f, 0.00847779f, 0.01849996f, -0.03252087f, -0.03310739f, -0.04082653f, 0.00904735f, -0.02028248f, 
    0.01672820f, -0.04655454f, -0.00717286f, -0.00272857f, -0.02260575f, -0.01625329f, 0.02878461f, 0.01704968f, 
    -0.03282487f, 0.00614652f, 0.02315684f, -0.01411994f, -0.02704792f, 0.01399051f, 0.00766329f, 0.00727607f, 
    0.01899293f, 0.01211134f, -0.01470218f, -0.00985838f, 0.01663033f, 0.01222540f, -0.04825095f, -0.04810138f, 
    -0.03142467f, -0.04113932f, -0.01340500f, -0.04583668f, -0.02194814f, -0.02155926f, 0.01509530f, 0.02568481f, 
    -0.04297850f, 0.00689493f, -0.01629946f, 0.02097527f, -0.00765088f, 0.02080576f, 0.01116477f, 0.00499001f, 
    0.00702321f, 0.00663427f, -0.00696232f, -0.01152013f, 0.02279836f, -0.00423686f, 0.03016296f, -0.02676898f, 
    -0.00207148f, -0.04267385f, 0.00827714f, -0.03537386f, -0.03557923f, 0.01126246f, 0.01272125f, 0.02524910f, 
    -0.01569392f, 0.01255524f, -0.00534308f, 0.01988575f, 0.02515004f, 0.01924985f, -0.03273690f, 0.03009400f, 
    0.00590430f, 0.00064350f, -0.01440876f, -0.00432335f, 0.02065916f, -0.03736408f, 0.01793385f, 0.01084993f, 
    0.00923179f, 0.02637808f, -0.00651828f, 0.02671162f, -0.00452545f, -0.02934468f, -0.02834443f, -0.03469794f, 
    0.00630059f, 0.01277920f, -0.00660685f, -0.02575774f, -0.02526548f, -0.00339008f, 0.00034073f, 0.00536122f, 
    -0.01688729f, -0.04199893f, 0.02579116f, 0.02509479f, -0.04596910f, -0.04024503f, -0.04192423f, -0.04279456f, 
    -0.02972943f, -0.01236117f, -0.03350249f, -0.00878890f, 0.01782452f, 0.00892326f, -0.00776948f, 0.02801579f, 
    0.01150546f, -0.03089373f, -0.03412111f, -0.02124730f, -0.03024886f, -0.02706554f, 0.01291631f, -0.04412048f, 
    0.00852571f, -0.04111728f, 0.00761855f, -0.01138898f, -0.01718255f, -0.01164031f, -0.02359567f, 0.00354815f, 
    -0.01918368f, -0.02917722f, -0.00707240f, 0.00019540f, -0.02038556f, -0.02066584f, -0.02320567f, -0.02362634f, 
    0.02845466f, 0.00115009f, -0.02536825f, 0.01956031f, -0.00485902f, 0.02964288f, -0.00131258f, -0.03801940f, 
    0.01295227f, -0.01662828f, -0.00815956f, -0.02195063f, 0.00986486f, -0.01242695f, -0.04315677f, -0.02185795f, 
    0.02194865f, -0.04043742f, -0.03340265f, 0.02218872f, -0.03572020f, -0.03963334f, 0.01045877f, 0.00630617f, 
    0.02613918f, 0.01689370f, -0.00120709f, -0.02926560f, 0.00374838f, -0.02540760f, -0.02024844f, 0.03132328f, 
    -0.00812663f, -0.01863003f, 0.02676779f, 0.03257905f, 0.03688821f, -0.00333315f, 0.03479297f, 0.02312408f, 
    -0.03846814f, -0.02624401f, -0.01585878f, -0.00510239f, -0.00300276f, 0.00568818f, -0.01450749f, 0.02536253f, 
    0.02712439f, 0.02030253f, -0.04083594f, 0.04046585f, -0.01976629f, -0.00099421f, -0.00358206f, -0.04714562f, 
    -0.00050616f, 0.01742798f, 0.01804028f, 0.01331367f, -0.02745063f, 0.01023375f, 0.02931486f, 0.00603795f, 
    -0.02807648f, 0.00100029f, 0.00295977f, -0.04110134f, -0.03044509f, -0.04087132f, -0.01530693f, -0.01628070f, 
    -0.03633999f, -0.02637722f, 0.01556801f, -0.04742670f, 0.04151351f, -0.00045587f, 0.03597457f, 0.02444032f, 
    -0.04148414f, -0.04614639f, 0.01072715f, -0.04699932f, 0.01717656f, -0.04217714f, -0.02899784f, 0.00493463f, 
    -0.03793209f, 0.00451948f, 0.01842073f, -0.03031331f, -0.00363604f, 0.02625218f, 0.03025047f, 0.02776216f, 
    -0.00248438f, 0.01120864f, -0.00438009f, -0.03943175f, -0.04242270f, -0.02889489f, 0.02075290f, -0.00061977f, 
    0.00749266f, -0.00037462f, 0.00515220f, 0.00249146f, 0.00146892f, -0.03368413f, 0.00137203f, 0.01420856f, 
    -0.00943923f, -0.02489384f, 0.02616590f, -0.04738980f, 0.00686934f, -0.03695015f, -0.01881916f, 0.02699376f, 
    -0.01539146f, -0.01040099f, -0.01333726f, 0.01064559f, -0.02929454f, -0.00707006f, -0.02215142f, 0.03311957f, 
    0.01795487f, 0.02363607f, -0.04585565f, 0.00843325f, -0.02500783f, 0.01829215f, 0.01147179f, 0.02063139f, 
    0.00634642f, -0.02452761f, -0.01660421f, -0.00251422f, -0.03569759f, -0.00410489f, 0.01434417f, 0.02104200f, 
    -0.04605476f, 0.00294937f, -0.03059639f, 0.00968115f, -0.04211536f, 0.01924874f, -0.04327974f, -0.03377191f, 
    0.02065863f, -0.02404541f, -0.01169494f, 0.00767226f, -0.00045815f, -0.02844102f, 0.01867696f, 0.01650777f, 
    -0.02390651f, -0.03495609f, 0.01634851f, 0.01459314f, -0.00877547f, -0.01945820f, -0.02542064f, 0.00021702f, 
    0.02055461f, 0.01013853f, 0.01434553f, 0.00492519f, -0.01126901f, -0.00800426f, -0.02112759f, -0.03015589f, 
    -0.04047756f, -0.01196999f, -0.00099248f, -0.01632232f, -0.00927699f, -0.00442431f, -0.03620367f, -0.02756196f, 
    -0.03855352f, 0.01922803f, -0.04115906f, 0.01002370f, -0.01450936f, 0.00463159f, -0.04018299f, 0.02198635f, 
    0.02648002f, -0.01511434f, 0.02501650f, -0.01913939f, 0.01441290f, -0.01255855f, 0.02659250f, -0.00425772f, 
    0.00554887f, 0.00768386f, 0.02051483f, -0.01068205f, -0.02472453f, 0.01215374f, -0.03413709f, 0.02090826f, 
    0.01262863f, 0.01324939f, -0.01321913f, 0.01877664f, 0.01936523f, 0.01873147f, -0.00480084f, 0.02368998f, 
    -0.03674607f, -0.03209930f, -0.03171894f, -0.01638941f, -0.02598520f, -0.02931882f, -0.03631714f, 0.00086225f, 
    0.02680336f, 0.01099358f, -0.03777145f, 0.01941292f, 0.02234669f, 0.03243024f, 0.03004387f, -0.00286630f, 
    -0.01562830f, -0.02117880f, -0.01845471f, 0.02955963f, -0.03113002f, -0.01148371f, -0.04238628f, -0.02735629f, 
    0.01267344f, -0.02530349f, 0.01707386f, -0.02567218f, -0.03008621f, -0.01292591f, 0.03151349f, -0.03657633f, 
    0.01589454f, 0.02174618f, -0.01773838f, 0.01337404f, -0.03812534f, 0.00861220f, 0.00361131f, -0.04048020f, 
    0.01698109f, 0.01351074f, -0.01433371f, 0.00495815f, -0.02866693f, -0.04487024f, -0.03054236f, 0.01042368f, 
    0.02375389f, 0.00625566f, 0.02108020f, 0.02832279f, 0.00966014f, -0.00350873f, 0.01662779f, 0.02584806f, 
    0.02695486f, 0.01471437f, 0.01240408f, 0.01322894f, -0.01783914f, 0.01070274f, -0.01326341f, 0.00739528f, 
    -0.01456710f, 0.00083901f, -0.00035725f, -0.00236322f, -0.03808500f, -0.00019511f, 0.03194354f, -0.00439414f, 
    -0.03532631f, -0.01807177f, -0.00946705f, 0.02550735f, 0.01446127f, -0.01332368f, 0.01268667f, -0.03110537f, 
    -0.02806398f, -0.03397414f, 0.01265256f, -0.00748202f, 0.03240313f, -0.04266572f, 0.01554138f, -0.00629294f, 
    -0.03450507f, -0.01550247f, -0.02077603f, 0.01678650f, -0.00766505f, 0.01010793f, -0.00753982f, -0.00536312f, 
    -0.03417194f, -0.00896910f, -0.00963479f, -0.01997255f, -0.00671484f, 0.01246173f, -0.02626094f, 0.02035538f, 
    0.02106151f, -0.02449532f, 0.02467266f, -0.02896214f, -0.00934442f, 0.00274500f, 0.01275774f, 0.00047499f, 
    0.01025810f, 0.01882435f, 0.00652128f, -0.03006352f, 0.00426006f, -0.02941755f, -0.02499887f, -0.02864717f, 
    -0.00147097f, -0.04342167f, -0.00241077f, -0.03609974f, -0.02317864f, 0.02374009f, -0.00481298f, 0.02167557f, 
    0.00374569f, 0.01082909f, 0.00109368f, 0.01822993f, -0.04427067f, -0.00525347f, -0.00623052f, -0.04151999f, 
    -0.01109075f, -0.02968834f, -0.03327221f, 0.02796157f, -0.00643785f, 0.01605079f, -0.00826690f, 0.02479077f, 
    -0.01158551f, 0.00518503f, -0.03161414f, 0.03068600f, 0.02129095f, -0.03519488f, 0.00682708f, 0.02466104f, 
    -0.00501776f, -0.00047378f, -0.03495668f, -0.03419938f, -0.04227056f, -0.01812098f, -0.00910880f, -0.00875600f, 
    -0.01276941f, 0.02244730f, -0.04178105f, -0.02506892f, -0.02349349f, -0.02545238f, -0.03903043f, 0.00121517f, 
    0.00122062f, -0.02255713f, -0.03137109f, -0.00034376f, 0.00466554f, -0.03804598f, -0.03702071f, -0.00292806f, 
    -0.03043320f, 0.00606524f, -0.02794682f, -0.01780831f, -0.02050897f, -0.03371046f, -0.04018418f, 0.00087594f, 
    -0.03723886f, 0.02294173f, -0.02654445f, -0.01145701f, 0.02733011f, -0.01782536f, -0.02117409f, -0.00615901f, 
    -0.00097035f, -0.01207204f, -0.00105528f, -0.02736338f, 0.02945914f, -0.01498089f, 0.01111721f, -0.00861486f, 
    0.00319790f, -0.03436675f, 0.01200010f, 0.00979242f, 0.01011862f, -0.01358867f, -0.04339649f, -0.03013570f, 
    0.00681790f, 0.03252284f, -0.01449986f, -0.02076425f, -0.04355391f, -0.02632358f, 0.00623991f, -0.01899229f, 
    0.02325731f, 0.01365259f, 0.00964262f, 0.01891481f, 0.00413533f, -0.01387466f, 0.00989751f, -0.00620731f, 
    -0.03094789f, 0.00622633f, 0.00702612f, 0.01473504f, -0.02312830f, -0.04280498f, -0.01586057f, -0.01521569f, 
    -0.04177074f, 0.00075146f, -0.00081096f, -0.02092584f, 0.00299655f, 0.02116126f, 0.01263196f, -0.04034143f, 
    -0.01853423f, -0.04185164f, -0.00503168f, 0.02862409f, 0.00331807f, 0.00729111f, 0.01246370f, -0.02802664f, 
    0.01262606f, 0.00329250f, 0.02522534f, 0.00841368f, -0.00734354f, -0.03569711f, 0.00726871f, -0.03751634f, 
    0.00582456f, 0.01050596f, -0.04444689f, 0.02209517f, -0.01527683f, -0.02105237f, -0.04112890f, 0.03348926f, 
    -0.01997966f, 0.01426336f, -0.00372510f, -0.00634194f, 0.03099395f, 0.02513556f, -0.02601530f, 0.01751333f, 
    0.02844590f, 0.01741812f, -0.03936352f, -0.04380184f, -0.02678256f, 0.02512420f, 0.00264979f, -0.04024433f, 
    0.02184565f, 0.02672283f, -0.00860124f, 0.01662801f, 0.00139354f, -0.01485941f, 0.01443619f, -0.03774656f, 
    -0.03200942f, 0.02807798f, -0.03489881f, -0.00506021f, -0.04090363f, -0.00520153f, 0.00248686f, -0.03551072f, 
    -0.03058960f, -0.03087687f, -0.00416222f, 0.02303997f, -0.01492455f, -0.02135445f, -0.02365966f, -0.04301850f, 
    -0.03574779f, -0.03697992f, -0.01193338f, -0.03345386f, -0.00444564f, -0.02047853f, 0.00404828f, -0.03932837f, 
    0.01447149f, -0.01457294f, -0.02453802f, -0.04173162f, 0.01240281f, -0.02849108f, -0.02633027f, 0.01515737f, 
    0.01989891f, -0.03820629f, 0.03141506f, -0.00653916f, -0.00501406f, -0.03988248f, 0.02312129f, -0.02291710f, 
    0.01844461f, 0.00723508f, -0.02719945f, 0.01026315f, 0.00161419f, 0.02827579f, -0.04516075f, -0.00974569f, 
    -0.03962841f, 0.00787306f, 0.02185320f, 0.00968962f, -0.01906854f, 0.01723113f, 0.02126710f, 0.00239723f, 
    -0.01344392f, 0.01087448f, 0.01941618f, 0.01397725f, -0.03502692f, -0.02198523f, 0.01916820f, 0.03122845f, 
    -0.00326140f, -0.03290437f, 0.03114769f, -0.01880816f, -0.02753069f, -0.04426950f, -0.03956470f, 0.01462362f, 
    0.00419135f, -0.04333826f, -0.03406034f, -0.04156041f, 0.01861405f, -0.02623219f, 0.00741074f, -0.02861203f, 
    -0.03018421f, -0.01810346f, 0.01690495f, -0.00594966f, -0.02897405f, -0.01707210f, 0.01285821f, -0.01155121f, 
    -0.01370666f, 0.02246028f, -0.02976259f, 0.02732632f, -0.02566553f, 0.02949724f, 0.03024933f, -0.01080451f, 
    -0.02171583f, -0.03608822f, -0.00448256f, 0.01302817f, 0.02208219f, -0.03846534f, 0.01476464f, -0.04031283f, 
    -0.04034742f, -0.02667245f, -0.04005179f, 0.00312707f, 0.02282931f, 0.03308597f, -0.04177525f, -0.02460738f, 
    -0.01051999f, -0.04042162f, 0.00408017f, 0.02244161f, 0.01028599f, -0.00282996f, 0.00211890f, 0.00449435f, 
    0.01764211f, -0.03809965f, 0.03255162f, 0.01929930f, -0.00075077f, -0.03524786f, -0.03882532f, -0.03502147f, 
    -0.00494788f, -0.01425507f, -0.03135237f, -0.02863322f, 0.03147650f, -0.00722026f, -0.03559017f, 0.02620550f, 
    0.00484670f, -0.03434117f, 0.02927252f, -0.03564943f, -0.04072205f, -0.04099977f, -0.01228693f, -0.00502535f, 
    -0.01213024f, 0.01322748f, -0.03834251f, -0.04408336f, 0.01010877f, 0.01573541f, -0.04226021f, -0.00033787f, 
    -0.03527904f, -0.00681764f, -0.01356678f, 0.01371330f, 0.00354649f, 0.01407465f, 0.00772999f, -0.02479834f, 
    0.02444881f, -0.02184966f, 0.02181596f, 0.01130422f, -0.02942525f, -0.02779491f, 0.02087189f, -0.00921694f, 
    0.00586887f, -0.01961336f, -0.04440103f, -0.02134255f, -0.01736253f, 0.02304723f, -0.03306834f, 0.00813363f, 
    0.00243868f, 0.02532542f, -0.02216286f, 0.01169872f, -0.00701142f, -0.02537810f, -0.00936058f, -0.00256937f, 
    -0.02403737f, 0.02341868f, 0.01069999f, 0.00560176f, -0.00510245f, 0.02117164f, -0.00504593f, 0.01090004f, 
    -0.01405072f, 0.02547711f, -0.03373005f, 0.00815569f, -0.02511552f, -0.00034443f, -0.00512853f, 0.00154409f, 
    0.01819612f, 0.00476967f, -0.02574152f, -0.02788969f, 0.01989735f, 0.00882540f, 0.00751621f, 0.01225145f, 
    -0.03051632f, 0.03332357f, -0.03785869f, 0.01727747f, -0.01047626f, 0.02223028f, 0.00084251f, 0.01622153f, 
    0.01292196f, -0.00923800f, -0.03671770f, -0.03946190f, 0.01447950f, -0.02543245f, -0.03527217f, 0.00853872f, 
    0.02522076f, -0.02496712f, 0.01783198f, -0.03381249f, -0.02127131f, -0.03304076f, 0.03015028f, -0.00835763f, 
    -0.01360628f, 0.02503123f, 0.00969743f, -0.04358612f, -0.01063618f, -0.02200623f, 0.00726267f, -0.01463106f, 
    0.00242955f, -0.04124876f, -0.04552448f, -0.02632117f, 0.02832578f, 0.01172615f, -0.01709351f, -0.01895300f, 
    0.01930844f, -0.02327017f, 0.03155931f, -0.04520599f, -0.03120983f, -0.00189428f, 0.01621355f, -0.03748062f, 
    0.01444510f, -0.00667706f, 0.01269234f, 0.03157887f, -0.00132047f, -0.01868629f, -0.04119137f, -0.00251123f, 
    0.01988177f, -0.02419690f, -0.03587168f, 0.02066989f, -0.00938280f, -0.04296288f, 0.02091864f, 0.02831804f, 
    0.02143178f, 0.00364736f, -0.01571081f, -0.03439353f, 0.00231923f, -0.04033434f, -0.04033498f, 0.01146834f, 
    0.01369956f, -0.03865432f, 0.00377323f, -0.03467304f, -0.03157833f, 0.02292211f, 0.02242467f, 0.02787006f, 
    -0.02373443f, -0.01448428f, -0.02998343f, -0.03866791f, -0.00081915f, 0.00819717f, -0.01890660f, 0.00559279f, 
    -0.03346821f, -0.00034789f, 0.02818197f, 0.02837102f, -0.03932883f, -0.00971087f, -0.00152577f, -0.01439418f, 
    -0.00377348f, 0.01578204f, -0.00355044f, -0.01865843f, -0.01254714f, -0.03412438f, -0.02254676f, -0.01867414f, 
    -0.03973670f, 0.01688780f, -0.01820834f, -0.03355226f, 0.01967297f, 0.02110183f, -0.01023404f, -0.04170614f, 
    -0.03622650f, -0.00329475f, -0.04139324f, -0.01516172f, -0.04412641f, 0.02698002f, -0.00258845f, 0.01928313f, 
    0.01029586f, -0.00606446f, -0.02130506f, 0.02320224f, -0.02493787f, -0.02681148f, 0.02734379f, -0.04534152f, 
    0.02716751f, 0.01940541f, -0.03601461f, -0.03418146f, 0.00000243f, -0.03636968f, 0.03207690f, -0.00349940f, 
    -0.02116346f, -0.00878773f, 0.01254182f, -0.00924689f, -0.03803326f, -0.00283087f, 0.02489275f, -0.01065336f, 
    0.02712270f, -0.04355351f, 0.00421625f, 0.00021205f, 0.01098430f, -0.01363510f, 0.00022279f, -0.04273826f, 
    0.00222447f, 0.01694505f, 0.01509153f, -0.01736991f, -0.02989887f, 0.02209839f, -0.01814489f, 0.03187463f, 
    -0.01439404f, 0.00405737f, 0.03001576f, -0.00060559f, -0.00657770f, 0.02696295f, -0.03011010f, -0.02707855f, 
    -0.04517255f, 0.03283253f, -0.00351974f, 0.01412871f, -0.01582597f, 0.02559803f, -0.00749189f, 0.02528905f, 
    0.01291658f, 0.02229759f, 0.02320935f, 0.01248378f, -0.03033179f, -0.01241777f, 0.02156570f, -0.03899675f, 
    -0.02313247f, -0.04311464f, -0.01015293f, 0.00306559f, -0.02129733f, 0.00536139f, -0.04140893f, -0.01975796f, 
    0.01773582f, 0.00443018f, 0.00918983f, 0.00523475f, -0.01438022f, -0.02979470f, -0.01167634f, -0.02873727f, 
    0.02174379f, 0.01992897f, 0.02826664f, 0.01684349f, 0.02661038f, -0.01425307f, 0.00173994f, -0.03647514f, 
    0.03224807f, 0.00898932f, 0.02371680f, 0.02680375f, -0.02137789f, 0.01167773f, -0.03392342f, 0.01639509f, 
    -0.01247796f, -0.03138437f, -0.01649511f, 0.02245294f, -0.02162140f, 0.02595168f, -0.03768973f, -0.03108143f, 
    -0.00615512f, -0.03294259f, -0.00790447f, 0.02881216f, 0.03090875f, 0.02199964f, -0.03598737f, 0.02890077f, 
    0.00402272f, 0.02773509f, -0.03724907f, 0.02903100f, 0.02847697f, -0.04506414f, 0.01171171f, -0.01634126f, 
    0.00628670f, -0.00028795f, -0.03409964f, -0.02022645f, 0.00836323f, -0.02250497f, 0.01721442f, -0.04117690f, 
    -0.01855463f, 0.00646261f, -0.02604713f, 0.02968441f, -0.03956887f, 0.02322946f, -0.03261521f, 0.02085370f, 
    0.02651763f, -0.02055339f, 0.02197528f, -0.00013933f, -0.01380639f, 0.01652431f, 0.01377472f, -0.00130837f, 
    0.03058225f, 0.00066786f, 0.00299427f, 0.02416488f, -0.03630650f, -0.02205345f, -0.04082881f, 0.00556160f, 
    -0.04073510f, 0.02249878f, 0.01704691f, -0.03808984f, -0.04089284f, -0.04295812f, 0.01328636f, 0.02731944f, 
    -0.01234079f, -0.02232446f, 0.01250318f, -0.01558198f, 0.00497369f, -0.02808571f, 0.01205873f, -0.01415402f, 
    0.01663328f, -0.04129853f, -0.00328573f, -0.03158668f, -0.02531073f, -0.04528492f, 0.00682304f, -0.00315798f, 
    0.00624762f, 0.01022736f, -0.02187056f, -0.03554713f, 0.01359813f, 0.00340645f, -0.01846569f, -0.04175458f, 
    0.00585907f, 0.01428233f, -0.00664934f, -0.04184668f, -0.00109786f, -0.02775878f, -0.00391548f, -0.02663082f, 
    -0.03051316f, -0.03110279f, -0.04382829f, 0.00490561f, 0.01413974f, -0.02386542f, 0.01595295f, -0.04217858f, 
    0.02858287f, -0.03671740f, 0.02127303f, -0.04266691f, -0.01110839f, -0.01647785f, 0.00672486f, 0.02439472f, 
    -0.02549245f, 0.01008279f, -0.03140229f, -0.02180926f, 0.01542456f, -0.00608332f, 0.01874191f, 0.03283413f, 
    -0.02050960f, 0.00427776f, -0.02869578f, 0.02165737f, 0.01002302f, -0.01192007f, -0.03252601f, 0.01834467f, 
    -0.01436631f, -0.03998677f, -0.01415197f, -0.03281374f, -0.01682449f, -0.03663021f, 0.00394810f, -0.00249016f, 
    -0.00323247f, -0.03093825f, -0.00764273f, -0.01580140f, -0.03148019f, -0.03168477f, -0.01531423f, 0.02438814f, 
    0.01952745f, 0.01762453f, -0.01835991f, 0.02190772f, -0.00025996f, 0.02220859f, -0.01539928f, -0.02584236f, 
    -0.03513552f, 0.02506620f, 0.01457871f, -0.00831226f, -0.02154158f, -0.03068614f, 0.00866708f, -0.02903017f, 
    -0.00045734f, -0.00543921f, -0.00996839f, 0.03166639f, -0.04268904f, 0.02263719f, 0.02780354f, -0.00009567f, 
    0.00955783f, -0.01168794f, -0.03126867f, -0.03934919f, -0.02273134f, -0.02326876f, -0.01693624f, -0.03128670f, 
    -0.03868109f, 0.03315330f, -0.02711045f, 0.00463528f, 0.00169604f, 0.02895389f, -0.02594649f, -0.03897972f, 
    -0.02776626f, -0.03659506f, 0.00518006f, 0.02251022f, -0.03929485f, -0.02017433f, 0.01778146f, -0.04060597f, 
    -0.00286722f, -0.01822722f, -0.02405536f, -0.02653582f, -0.03444827f, 0.01926556f, -0.02797911f, 0.01271695f, 
    -0.02154633f, -0.02967370f, -0.00553766f, -0.00970070f, -0.03376149f, -0.02268233f, -0.03018787f, 0.00964176f, 
    0.01841043f, -0.01224495f, 0.00716222f, -0.01360238f, 0.02573227f, -0.03608798f, -0.03854837f, -0.03727317f, 
    -0.03065888f, 0.02937087f, 0.02060757f, -0.04484033f, 0.01664563f, 0.03224445f, 0.01659606f, -0.01709851f, 
    -0.04281540f, 0.01739002f, 0.02536665f, 0.00776700f, -0.03203366f, 0.02347139f, 0.03270207f, -0.04057750f, 
    -0.00127367f, -0.02013037f, -0.01208371f, 0.03276927f, 0.01701586f, -0.03294713f, -0.04060015f, -0.03011995f, 
    -0.04489758f, -0.04011191f, 0.02107969f, -0.02342088f, -0.01892949f, 0.01301472f, -0.04089474f, 0.00126944f, 
    -0.02086067f, -0.03829516f, -0.03298242f, 0.03094243f, -0.00985116f, -0.00797814f, -0.04479408f, 0.03191650f, 
    -0.01103255f, -0.03933331f, -0.01575532f, -0.01552637f, -0.03680433f, -0.01035262f, 0.00488703f, -0.01243157f, 
    0.02972666f, -0.02873783f, -0.04322144f, 0.00193746f, -0.02267540f, -0.02514673f, 0.02897086f, 0.01221857f, 
    -0.01755980f, -0.00021682f, 0.03103301f, -0.03936824f, 0.00791091f, 0.01788118f, -0.01374186f, 0.01390430f, 
    -0.03203153f, -0.01214864f, 0.02880528f, -0.01699355f, -0.01271611f, -0.02137233f, -0.00149471f, 0.01547928f, 
    -0.01813301f, -0.02490844f, 0.01035623f, -0.01535398f, -0.04512859f, -0.04396797f, 0.04244045f, -0.00502191f, 
    -0.00440641f, 0.02926981f, -0.01935034f, -0.04443316f, -0.00679112f, -0.02202947f, -0.02428561f, -0.01246948f, 
    -0.02337382f, 0.00448402f, -0.00472684f, -0.02174619f, 0.01048601f, 0.01925688f, -0.03811280f, -0.00362814f, 
    -0.03888451f, -0.01387772f, -0.03485138f, -0.02096289f, 0.03334346f, -0.02068360f, -0.01957344f, 0.02024040f, 
    -0.01343067f, -0.01893455f, -0.03626409f, -0.03726869f, -0.02939415f, -0.00378950f, 0.01489893f, -0.02243728f, 
    0.03000632f, -0.00612167f, -0.01420429f, -0.02616096f, -0.00255160f, -0.00476557f, -0.00121624f, 0.01914271f, 
    -0.02574369f, -0.00032089f, -0.02176274f, -0.02604341f, -0.01547972f, 0.01616947f, 0.00982109f, -0.03948260f, 
    -0.03883264f, 0.01630764f, 0.03226697f, 0.00271996f, 0.02679951f, 0.00050115f, 0.03193712f, 0.00653101f, 
    0.02523069f, 0.01673623f, -0.01576844f, 0.01984702f, -0.01932650f, 0.02769256f, -0.01259374f, -0.01988479f, 
    -0.02057615f, 0.02119006f, 0.00838997f, 0.00707926f, 0.00750336f, -0.03630656f, 0.02186387f, -0.02637711f, 
    -0.01660941f, 0.01742865f, 0.00724250f, -0.00461032f, 0.00964968f, 0.02710286f, -0.02494685f, -0.04059247f, 
    -0.02691308f, 0.01566144f, -0.00482975f, 0.00161282f, -0.02173832f, -0.00112358f, -0.02511482f, -0.04065172f, 
    -0.03766284f, -0.03114546f, 0.00747735f, 0.02130550f, -0.00616342f, -0.03342697f, -0.00229093f, 0.01526909f, 
    0.01394250f, 0.02489420f, 0.01176029f, 0.00606409f, 0.00629624f, -0.00894718f, 0.02045719f, 0.03172377f, 
    -0.03828086f, 0.03237598f, -0.01540134f, -0.02228221f, -0.02456491f, -0.03153433f, 0.02255111f, -0.04359733f, 
    0.00744871f, -0.00551112f, 0.03057294f, 0.02238446f, -0.02500273f, 0.00823721f, -0.00533519f, -0.02985255f, 
    0.00190720f, -0.01290615f, -0.00305467f, -0.01913611f, 0.00025392f, 0.01545075f, 0.02968740f, -0.00596814f, 
    0.03091411f, -0.00734404f, -0.03011263f, -0.03726103f, 0.00160135f, 0.02359471f, 0.02770736f, -0.03555891f, 
    0.02853785f, -0.02093788f, -0.00844166f, -0.02364147f, -0.01550566f, -0.01338651f, -0.00677434f, -0.01214651f, 
    -0.01355749f, -0.02080268f, 0.00609280f, -0.02530009f, 0.01784199f, -0.02216541f, -0.02382567f, -0.01838647f, 
    -0.01507411f, 0.01767344f, 0.03299047f, -0.03745244f, 0.00056460f, -0.02234650f, -0.00380759f, 0.02542433f, 
    -0.01994687f, 0.00385329f, 0.02301629f, 0.00485721f, -0.00766564f, -0.03811056f, 0.01707976f, -0.02713707f, 
    0.02502683f, 0.02252933f, -0.01390963f, -0.00299666f, -0.00507572f, 0.02347224f, -0.04294281f, -0.03428669f, 
    -0.00862598f, -0.00732036f, -0.04413499f, -0.01281485f, 0.00269128f, -0.01650080f, 0.01784598f, -0.04114859f, 
    0.01662834f, -0.03512525f, 0.00585760f, 0.00178237f, 0.01631309f, 0.02020614f, -0.01512180f, -0.02225719f, 
    -0.03289650f, 0.00561335f, 0.02476490f, -0.01214192f, 0.00165210f, -0.03167202f, -0.04381062f, -0.02973015f, 
    -0.01264212f, -0.02539657f, -0.03172421f, 0.01407022f, 0.01828923f, 0.00391342f, -0.02958645f, -0.03480154f, 
    -0.00626726f, -0.02512926f, 0.01651902f, -0.03140396f, 0.02280650f, -0.03960217f, -0.03451950f, 0.02176660f, 
    -0.03233865f, -0.01690268f, -0.01979479f, 0.01303186f, -0.01470949f, 0.02162109f, -0.02979350f, -0.01106436f, 
    -0.02069098f, -0.04206919f, 0.02482585f, -0.01142720f, -0.04057756f, -0.02837287f, 0.01007127f, -0.02922783f, 
    0.02879892f, 0.00380695f, -0.02505853f, -0.02784582f, -0.01303815f, 0.01176187f, -0.01981886f, -0.05583782f, 
    -0.05425117f, -0.04844870f, 0.00409689f, -0.03492932f, -0.00457773f, -0.04041837f, -0.02212669f, -0.01468433f, 
    0.01894584f, -0.02580039f, -0.03865044f, -0.02314167f, -0.01247201f, -0.00060146f, -0.01867480f, -0.00305772f, 
    0.01222584f, -0.00392950f, 0.03223129f, 0.05473434f, 0.02000123f, 0.01748800f, -0.00619823f, -0.02492238f, 
    0.04298546f, 0.00616949f, 0.01626554f, -0.01539355f, -0.03904605f, -0.02957959f, -0.01429067f, -0.00208469f, 
    0.01881669f, -0.01012439f, -0.02074803f, 0.00535074f, 0.00809969f, -0.03794990f, 0.00821722f, -0.00252573f, 
    0.01529668f, 0.01258050f, -0.02425713f, -0.03276582f, -0.01941635f, -0.03110510f, 0.02346593f, 0.00490880f, 
    -0.02786566f, -0.00295646f, 0.02108777f, -0.03708740f, -0.01812859f, 0.02144139f, 0.00359691f, 0.01372780f, 
    -0.00507451f, -0.01937809f, 0.02671727f, 0.00922018f, 0.00609651f, 0.00667873f, 0.00279412f, 0.02151150f, 
    -0.01357916f, -0.05418013f, 0.03648533f, 0.00504187f, 0.00569754f, -0.03607537f, 0.03469337f, -0.02236861f, 
    0.00782069f, 0.01884758f, -0.02659380f, 0.00927080f, -0.01733934f, -0.00547836f, 0.02862673f, 0.01515977f, 
    -0.03016543f, -0.05628264f, -0.01364906f, 0.01002890f, -0.03362812f, 0.01975491f, -0.01449508f, -0.00854092f, 
    0.02671920f, -0.04404207f, -0.03610624f, -0.03071243f, 0.00131277f, 0.01436460f, 0.02607857f, -0.01465919f, 
    0.00981216f, -0.02168841f, 0.01062592f, -0.00963850f, -0.04247203f, -0.01181324f, -0.00192105f, 0.01211835f, 
    0.01860180f, -0.00247899f, 0.01835342f, -0.00818222f, -0.02061907f, 0.00904778f, -0.00814621f, -0.00583126f, 
    0.03568708f, -0.00142340f, 0.02110008f, -0.01571825f, -0.03391355f, -0.03329393f, 0.00250594f, -0.02525964f, 
    0.00009570f, 0.01214237f, -0.00487216f, -0.01398750f, -0.03019794f, -0.01581911f, -0.01678089f, -0.04292444f, 
    -0.01357293f, -0.04531258f, -0.02543119f, -0.04624427f, -0.05586173f, 0.02374045f, 0.04084014f, -0.04858385f, 
    -0.04358480f, 0.02716601f, -0.03404902f, -0.02471280f, 0.00587515f, 0.02888860f, 0.00951974f, -0.01111770f, 
    -0.04455803f, 0.02204831f, 0.02778780f, 0.00754180f, -0.04093378f, -0.03111433f, -0.00993238f, -0.04390047f, 
    0.01818832f, -0.05360650f, 0.00618379f, -0.02733369f, 0.02741923f, -0.04185631f, -0.03352402f, -0.03588099f, 
    0.00634727f, 0.00398756f, -0.02035265f, -0.04733133f, -0.00464827f, -0.03158607f, -0.00500755f, -0.02524486f, 
    0.01045176f, 0.01591839f, 0.00423717f, -0.00727546f, -0.03340919f, -0.01294088f, -0.00099381f, -0.00325913f, 
    -0.02107150f, 0.02674405f, -0.00530674f, 0.02062732f, -0.02151130f, -0.02537677f, -0.02079907f, 0.02572092f, 
    -0.03409288f, -0.05508946f, 0.02226664f, -0.00777780f, -0.00412612f, -0.05324222f, -0.05602965f, -0.02078089f, 
    -0.04854667f, -0.00414431f, 0.00071987f, 0.01983270f, -0.02881497f, -0.02406387f, -0.02620083f, -0.02111774f, 
    -0.01053415f, -0.05719823f, -0.00423416f, -0.03492121f, -0.04085629f, -0.03778177f, 0.02169994f, -0.01470255f, 
    -0.00148943f, 0.00169095f, -0.04428747f, -0.00080194f, -0.01387479f, 0.06027230f, 0.02748554f, -0.03693224f, 
    -0.02976907f, 0.01106338f, -0.03704506f, 0.01230830f, 0.02476742f, -0.03300606f, -0.05469613f, -0.01071028f, 
    0.02377429f, -0.03925733f, -0.01848852f, -0.02013682f, -0.03606985f, -0.03724274f, 0.00720035f, -0.03641564f, 
    -0.01587295f, -0.02471675f, -0.00471500f, 0.04432201f, -0.04710961f, -0.01327905f, -0.00174272f, 0.02523451f, 
    -0.03410114f, -0.01788737f, -0.00223198f, 0.00946971f, 0.03111226f, -0.02463821f, -0.04262047f, -0.00994599f, 
    -0.03614195f, -0.02065209f, 0.03841702f, 0.00658845f, 0.01168131f, -0.01682298f, -0.02689896f, -0.01174407f, 
    0.01809409f, -0.03242871f, 0.03363038f, 0.02338116f, 0.02734468f, 0.00408981f, 0.02274908f, -0.03047814f, 
    0.02896649f, 0.03156307f, -0.02830222f, 0.03273660f, -0.03033995f, -0.01297775f, 0.05792835f, -0.02870935f, 
    -0.02977026f, 0.01612250f, -0.04412769f, -0.01656072f, 0.03882859f, -0.00688312f, -0.02411686f, -0.03378662f, 
    -0.00292381f, 0.01184417f, -0.01878121f, 0.03287873f, -0.00845212f, -0.03018474f, 0.00210923f, -0.05518640f, 
    0.01860112f, -0.01860039f, 0.03181319f, -0.01186514f, 0.04947201f, -0.01271299f, 0.02440244f, -0.00185511f, 
    -0.02219550f, -0.00503104f, 0.02727588f, -0.05424940f, -0.03622480f, -0.04625181f, -0.03737426f, -0.03533309f, 
    -0.00817713f, 0.00663434f, 0.02854382f, -0.01239469f, -0.02317060f, -0.04213523f, -0.00592247f, 0.01613926f, 
    -0.03761746f, 0.02611333f, 0.01353672f, 0.02640371f, 0.04092516f, 0.00451297f, 0.01807578f, -0.01655661f, 
    0.02192036f, 0.00856883f, -0.04988837f, 0.00465459f, 0.03886874f, 0.02098816f, 0.03723044f, -0.02089860f, 
    -0.04119726f, -0.00164962f, 0.01643745f, -0.05090502f, 0.00405976f, -0.02842659f, 0.02765069f, -0.02498262f, 
    -0.02632278f, -0.04606377f, 0.02863163f, -0.02041765f, -0.04553616f, -0.01422697f, 0.01143590f, 0.04215321f, 
    0.02575547f, 0.00492375f, -0.03283042f, -0.01944854f, -0.01958393f, 0.01512291f, -0.01436673f, 0.00103815f, 
    0.02059090f, -0.01882731f, 0.01371441f, 0.00873854f, -0.02494108f, -0.00231961f, -0.01988254f, -0.00209786f, 
    -0.05728438f, -0.05168093f, 0.00353102f, -0.01173632f, 0.05447435f, 0.01539775f, 0.04441475f, -0.01458190f, 
    -0.03423976f, 0.02488944f, 0.02776373f, -0.01397582f, -0.02693817f, 0.00810658f, -0.01627630f, -0.02129025f, 
    0.00510335f, -0.02279728f, -0.01236555f, 0.02353582f, -0.04584098f, -0.04331227f, 0.01026474f, -0.02782450f, 
    0.00429964f, -0.00369438f, 0.02535803f, -0.01541422f, -0.00129528f, -0.00818522f, 0.03765003f, 0.01589202f, 
    0.04147506f, 0.01249279f, -0.03413792f, 0.01650547f, -0.01758717f, -0.01446960f, -0.02493801f, -0.03031385f, 
    0.01839265f, -0.00846224f, -0.04016905f, -0.00259326f, 0.00882943f, -0.02432912f, 0.05356276f, -0.05007077f, 
    -0.02734463f, 0.01201293f, 0.02148996f, -0.00459128f, -0.03253737f, -0.04768601f, -0.00604662f, -0.02568559f, 
    0.02008959f, 0.01916097f, -0.04618981f, -0.01537714f, -0.04489267f, -0.03664033f, 0.00536222f, 0.03254901f, 
    -0.03034189f, -0.00634326f, -0.01381453f, -0.03258957f, -0.01702654f, 0.00832613f, 0.00515093f, 0.00051704f, 
    0.02063585f, -0.00456946f, -0.01659793f, 0.03119725f, -0.04287096f, -0.00513079f, 0.01042972f, -0.00486732f, 
    0.00056997f, -0.03704512f, 0.00741897f, 0.00383577f, -0.04470871f, -0.04020334f, -0.00630667f, 0.02419092f, 
    -0.02627259f, -0.02710674f, 0.02087144f, 0.02162383f, 0.01138758f, -0.04144201f, 0.02974876f, -0.02613883f, 
    -0.02933913f, -0.02647351f, -0.02722943f, 0.02807286f, -0.00669950f, -0.04368577f, -0.00010868f, -0.00279132f, 
    0.02272109f, -0.00971040f, -0.01812986f, -0.02306860f, -0.00197712f, -0.02604192f, 0.02317223f, -0.02391713f, 
    -0.03433311f, 0.02640503f, -0.01486388f, 0.01988418f, -0.02639820f, -0.00179085f, -0.01662066f, 0.01699877f, 
    0.02072163f, 0.02354027f, -0.00377659f, 0.02242174f, 0.02434362f, -0.01934058f, 0.02107332f, -0.04352827f, 
    0.03291100f, 0.01779678f, -0.00892714f, 0.03514068f, 0.00660561f, -0.00890976f, -0.02774267f, -0.00723342f, 
    -0.05514247f, 0.01062752f, 0.01550510f, -0.01949079f, -0.00033718f, -0.01387345f, -0.02762793f, 0.02668500f, 
    -0.00873702f, -0.01487284f, -0.02701398f, -0.00790860f, -0.05147700f, -0.03213834f, 0.01587543f, -0.04917810f, 
    -0.00874517f, 0.00544882f, 0.01667727f, 0.01372657f, -0.00673776f, -0.02818752f, -0.00299621f, 0.01366785f, 
    -0.04822092f, -0.02719377f, 0.02345859f, 0.04314731f, 0.01464290f, 0.01053569f, 0.03100139f, -0.04169618f, 
    -0.05464894f, 0.01812769f, 0.02600407f, -0.03082523f, 0.00145559f, 0.00443160f, 0.00282908f, -0.02789381f, 
    -0.00554627f, 0.02785229f, -0.04979848f, -0.03345824f, -0.03469205f, -0.00944460f, 0.00038024f, 0.01633105f, 
    0.02196385f, -0.01395542f, 0.01464275f, -0.02262083f, -0.03591277f, -0.04612932f, -0.03813807f, -0.01733427f, 
    -0.00854922f, 0.00947969f, 0.02291254f, -0.01015468f, 0.04858095f, 0.03867104f, -0.01729317f, -0.01881788f, 
    -0.05950333f, -0.03564401f, 0.03973231f, 0.03764041f, 0.00082800f, -0.00133465f, -0.02140582f, -0.02299102f, 
    -0.00098932f, 0.00747275f, -0.03202394f, 0.00062274f, 0.02437698f, -0.02470231f, 0.01832657f, -0.04588180f, 
    -0.04211273f, -0.02143383f, 0.00588375f, -0.03173661f, -0.02643148f, -0.01055172f, 0.01505498f, -0.04211459f, 
    -0.01435606f, 0.02967708f, -0.03799078f, 0.01084800f, -0.02813834f, -0.05054637f, 0.04029516f, 0.02807840f, 
    0.02647089f, 0.03515270f, -0.00533446f, -0.00884432f, 0.01885166f, -0.01431366f, 0.02111280f, -0.00584775f, 
    -0.05133704f, -0.04889359f, 0.00360256f, -0.03111069f, -0.03261526f, -0.02588898f, -0.04811425f, -0.02852502f, 
    0.01836197f, -0.03629354f, -0.05012235f, -0.04564823f, 0.01851092f, -0.01025040f, -0.02068050f, -0.02140653f, 
    -0.01512139f, 0.02816794f, -0.00843465f, -0.01796173f, -0.01017065f, -0.02675655f, -0.03082847f, -0.03394308f, 
    -0.01183153f, -0.02905140f, 0.02630783f, -0.01656605f, -0.00020342f, 0.04523743f, -0.00004876f, -0.02130810f, 
    -0.01045768f, -0.04040297f, 0.01755812f, 0.01496914f, -0.03038141f, -0.01600061f, -0.02149118f, -0.02973046f, 
    0.00223134f, -0.00571300f, 0.00578133f, 0.01422647f, -0.00958519f, 0.03328266f, -0.02457278f, -0.00596642f, 
    -0.02737523f, 0.01157487f, -0.04129570f, -0.02360220f, -0.02697411f, -0.00865522f, -0.02005886f, -0.01944710f, 
    -0.00767467f, 0.02845603f, -0.00373972f, 0.03028588f, 0.01986311f, 0.01166776f, -0.00828752f, -0.03542580f, 
    -0.03225043f, -0.02552165f, 0.03016968f, -0.01873515f, -0.01573455f, -0.03849503f, -0.00489606f, -0.03317326f, 
    -0.04113571f, 0.02840744f, 0.01189895f, -0.02558004f, 0.02484000f, -0.03221696f, -0.03684051f, -0.01254090f, 
    0.02624920f, 0.02975238f, -0.01521789f, 0.02684331f, -0.01521844f, 0.03178299f, 0.00787321f, 0.00804029f, 
    -0.03007128f, -0.00535832f, -0.02025618f, -0.03459870f, 0.03110520f, -0.00567754f, 0.03237731f, 0.00798770f, 
    0.02054114f, -0.03168608f, -0.01496777f, -0.00970256f, -0.02193402f, 0.01306313f, 0.03772493f, -0.00588139f, 
    -0.01585845f, -0.01908399f, -0.00859590f, 0.02007108f, 0.03338471f, -0.02710116f, -0.00725985f, -0.01769104f, 
    0.01552469f, -0.03245338f, 0.00451620f, -0.00101778f, -0.01845680f, 0.01147192f, -0.02722813f, -0.02905125f, 
    -0.00997555f, 0.00593533f, -0.00244550f, 0.03244990f, -0.02179099f, 0.01751661f, -0.03200982f, 0.00825712f, 
    0.03051720f, 0.00090814f, 0.02135827f, 0.00160360f, -0.03112322f, -0.02071950f, 0.01674079f, -0.00039234f, 
    -0.02849917f, -0.02898067f, 0.01661221f, 0.00941569f, 0.02173621f, -0.01999192f, 0.00496874f, -0.01898774f, 
    0.02249507f, -0.04330654f, 0.01215265f, 0.02451702f, 0.01634912f, 0.00974523f, -0.01538824f, -0.02887322f, 
    0.02260641f, 0.01876832f, 0.02069522f, 0.03570602f, -0.02223502f, 0.03493544f, -0.00800699f, 0.01365320f, 
    -0.00009112f, 0.02280790f, -0.00416816f, -0.00666491f, 0.01696450f, 0.02377869f, -0.02018489f, -0.01900041f, 
    -0.01540164f, 0.02068508f, 0.01763965f, -0.00118343f, -0.02788461f, -0.01862376f, -0.00540982f, 0.03703532f, 
    0.00343410f, 0.02616340f, 0.02141277f, 0.02823729f, 0.02010753f, -0.00616312f, 0.01039918f, 0.00779126f, 
    0.02611724f, -0.01358420f, -0.04013060f, 0.00850855f, -0.03103667f, 0.02804497f, 0.02870749f, 0.00570726f, 
    0.01412400f, -0.00372427f, 0.02041257f, -0.02394721f, -0.03565299f, 0.03531254f, -0.04145452f, -0.01090432f, 
    0.01554764f, 0.01275941f, -0.00016712f, 0.01123954f, -0.02339453f, -0.03804839f, 0.02179270f, -0.00412739f, 
    -0.03659457f, 0.02439367f, 0.01273834f, -0.00337399f, -0.00396579f, -0.04232672f, 0.03978441f, 0.03207272f, 
    -0.02190216f, -0.04165621f, 0.00295495f, -0.01189339f, 0.00333202f, -0.01417990f, -0.01561722f, -0.03932767f, 
    -0.00833613f, -0.02851729f, -0.01943873f, -0.01181135f, -0.02036490f, 0.02622093f, -0.03176465f, -0.01995204f, 
    0.01407687f, -0.03346200f, -0.02686535f, 0.03528930f, 0.00060033f, -0.03841316f, -0.03833134f, -0.02063472f, 
    -0.02439235f, -0.04066211f, 0.02818750f, -0.01140172f, -0.00163856f, -0.00239742f, -0.00539211f, 0.00866298f, 
    -0.01712517f, -0.00520872f, 0.01020310f, -0.04217451f, -0.01074705f, -0.04474289f, 0.02045535f, -0.00047102f, 
    -0.02393664f, -0.04164656f, -0.03580523f, 0.00397693f, -0.01446369f, -0.02550878f, 0.01119968f, 0.01930190f, 
    -0.01066628f, 0.02953445f, 0.00043378f, 0.00099804f, -0.03286478f, 0.03113087f, 0.00296895f, 0.03790295f, 
    -0.01441729f, 0.00804659f, -0.04717825f, -0.01927628f, -0.02511670f, -0.00674994f, 0.00428436f, -0.01363304f, 
    0.02685547f, 0.03391072f, -0.01955716f, -0.03556015f, -0.02458273f, 0.02428070f, 0.00154190f, -0.00601941f, 
    -0.03052821f, 0.03389651f, -0.01013481f, -0.03624371f, 0.02371879f, -0.01622179f, 0.01819489f, 0.03023566f, 
    0.01562303f, -0.03151936f, 0.00465604f, 0.03254027f, -0.00651279f, 0.00598585f, -0.01153498f, -0.01440257f, 
    -0.00496576f, -0.01835212f, -0.01841446f, -0.02708809f, -0.04425358f, 0.01262028f, 0.02138296f, 0.02085192f, 
    -0.00327211f, -0.00909925f, 0.03131019f, 0.01641289f, 0.02419557f, -0.00153503f, 0.00659247f, -0.04205565f, 
    0.01858953f, 0.02901271f, 0.01236227f, 0.02429688f, 0.02680687f, -0.02737936f, -0.00695963f, -0.02656409f, 
    -0.01689751f, 0.01243022f, -0.02515072f, -0.03800144f, -0.01466333f, -0.03545650f, 0.02544106f, 0.03339683f, 
    0.02036029f, 0.00787347f, 0.02496018f, -0.03626622f, -0.02202852f, -0.03883786f, 0.01091378f, -0.04369460f, 
    0.02584084f, 0.02417556f, 0.02797194f, 0.02497772f, 0.02770922f, -0.01674878f, -0.03433457f, 0.02193077f, 
    0.03272939f, -0.01175337f, -0.01810193f, -0.02091866f, 0.01058712f, -0.01049754f, 0.03186980f, -0.02719240f, 
    0.02755983f, 0.01247717f, -0.02783547f, -0.00222637f, -0.01267033f, -0.03688287f, -0.00868917f, -0.03531450f, 
    -0.00416077f, -0.01117060f, -0.00949669f, -0.02422466f, 0.02393322f, -0.02932085f, -0.03104589f, -0.02193466f, 
    -0.01377594f, 0.01971354f, 0.00817368f, 0.02233029f, 0.00407265f, -0.03008223f, -0.03463342f, 0.03330563f, 
    -0.03567645f, -0.01109265f, -0.03940902f, -0.01253833f, 0.01801812f, 0.01335089f, -0.01721886f, -0.00403205f, 
    -0.01816228f, -0.01235010f, -0.03905652f, 0.03270707f, 0.02070295f, -0.02617342f, 0.01708832f, 0.03321715f, 
    -0.01617639f, 0.03242446f, -0.02273398f, 0.02443555f, 0.00843450f, -0.02559880f, -0.00843623f, 0.00372738f, 
    -0.02966110f, -0.00898909f, 0.01440644f, 0.01764677f, -0.03217158f, 0.00703143f, 0.00688631f, 0.00655061f, 
    0.01118700f, -0.01064327f, -0.03372122f, 0.01274242f, 0.00918111f, -0.02729560f, 0.02561290f, 0.02079610f, 
    -0.00070847f, -0.02197312f, 0.02239932f, 0.00184284f, -0.01873104f, -0.03431933f, -0.01075052f, -0.03353855f, 
    -0.02491572f, -0.01133807f, 0.01380307f, -0.00091286f, 0.00976074f, 0.02501492f, 0.00132240f, 0.00391350f, 
    0.02916571f, -0.03947419f, -0.00968439f, 0.03002137f, 0.01012556f, 0.01321657f, -0.00112402f, 0.03031171f, 
    -0.04712412f, 0.02304802f, -0.03571508f, -0.00861210f, -0.01541285f, -0.00066873f, -0.01397589f, 0.03368101f, 
    0.01051626f, -0.03289608f, 0.00944376f, -0.04235829f, 0.02117017f, -0.04217394f, 0.03174249f, -0.02098370f, 
    -0.02793955f, -0.02330103f, 0.00860717f, 0.00748185f, -0.04431768f, -0.02541869f, 0.02794077f, -0.04524317f, 
    0.00044982f, -0.03398617f, -0.01761814f, 0.01513920f, -0.02178686f, -0.01195588f, 0.03337837f, 0.03689970f, 
    -0.02665554f, 0.01566070f, 0.00487448f, -0.03959063f, -0.02610784f, 0.00455534f, -0.00670297f, 0.01369231f, 
    -0.00820390f, -0.01894710f, -0.00023005f, 0.02110603f, -0.04250258f, -0.01600939f, 0.01243129f, -0.00835403f, 
    -0.03415653f, -0.00168166f, -0.01834636f, -0.02516776f, -0.02510185f, 0.01568106f, 0.01947722f, -0.02330755f, 
    -0.03646804f, -0.00879554f, -0.03293276f, 0.02646327f, -0.03052649f, 0.01421238f, -0.00419784f, 0.00493772f, 
    -0.03082859f, -0.00687898f, 0.01143499f, 0.03121183f, -0.02559562f, 0.01140024f, -0.01002003f, -0.00982235f, 
    0.00871030f, -0.00423919f, -0.02046929f, -0.02407241f, 0.01003427f, 0.03540337f, -0.00826140f, -0.02737554f, 
    -0.03208453f, 0.00397688f, 0.03769272f, -0.01243426f, 0.02014194f, 0.02755498f, 0.03174616f, 0.02860530f, 
    -0.00802543f, -0.03542713f, -0.01929729f, -0.01960071f, -0.02356469f, 0.00382090f, -0.04275909f, 0.01022435f, 
    -0.03296812f, -0.01188421f, -0.01560226f, -0.01246975f, -0.00549011f, 0.00175357f, 0.01009299f, -0.03120338f, 
    0.01997373f, 0.02307091f, -0.01348358f, 0.00436530f, -0.04368176f, -0.00431335f, 0.02881202f, -0.02782796f, 
    -0.01345447f, -0.02476337f, 0.00293204f, -0.02760225f, 0.00978534f, 0.01359633f, 0.00073857f, 0.02714448f, 
    0.01765503f, -0.04661306f, -0.03560586f, 0.00514348f, 0.01146418f, 0.01322247f, 0.01415365f, 0.01987459f, 
    -0.03388764f, 0.02016053f, -0.00066819f, 0.03682576f, 0.02899065f, 0.02386300f, 0.00794208f, -0.03016706f, 
    -0.02805005f, -0.02827085f, -0.03472509f, -0.00097297f, -0.02555125f, 0.01678804f, -0.00322978f, 0.02866160f, 
    -0.02674038f, 0.01700996f, -0.03436547f, -0.01055382f, 0.00950715f, -0.04035963f, 0.01699046f, -0.03393132f, 
    0.01612982f, -0.01508005f, 0.01385105f, -0.02679860f, -0.00455539f, -0.03695150f, 0.03637573f, -0.00828530f, 
    0.02352671f, 0.01889527f, 0.03243312f, -0.01896329f, -0.03096776f, -0.00509969f, 0.00841650f, -0.02247524f, 
    0.01616457f, -0.04541747f, 0.02773833f, 0.00099221f, -0.02601185f, 0.00099287f, 0.01316310f, -0.00919419f, 
    0.03132864f, -0.03210581f, 0.00263439f, 0.00617340f, -0.01271191f, -0.01363974f, -0.00426915f, -0.01906843f, 
    -0.04053777f, -0.03974740f, -0.00255362f, -0.01098889f, 0.00477237f, 0.02743123f, -0.03652481f, -0.03600785f, 
    -0.03365278f, -0.03490824f, -0.02453482f, -0.03978472f, 0.01887548f, -0.04456885f, 0.02271366f, -0.01171136f, 
    -0.02375827f, 0.02302057f, 0.01544880f, 0.02307312f, -0.03214724f, -0.03678869f, -0.01296199f, 0.00330650f, 
    0.01595112f, -0.02927287f, -0.03188748f, -0.00855216f, -0.04289755f, -0.02035793f, -0.01795013f, -0.04485099f, 
    0.02387073f, -0.02510288f, -0.04207725f, 0.01940119f, -0.01698192f, 0.00574479f, -0.03733012f, -0.01820844f, 
    0.02098266f, 0.40388870f, -0.03082014f, -0.05365133f, 0.29390410f, 0.08815165f, 0.08016935f, 0.01977448f, 
    0.15316713f, 0.12334773f, 0.04951128f, 0.10869725f, -0.03777017f, 0.08468482f, 0.02435121f, 0.08279070f, 
    0.11836132f, 0.05587437f, 0.00876117f, -0.02166522f, -0.06412800f, 0.31445816f, 0.00000785f, -0.06758893f, 
    -0.26242191f, 0.02947614f, 0.05681213f, 0.10849596f, -0.01480876f, 0.08883940f, 0.15310757f, 0.08078559f, 
    0.08465569f, 0.07903584f, -0.00005903f, 0.10862352f, 0.06939237f, 0.06898023f, -0.16724165f, 0.10263614f, 
    0.27063078f, 0.39979941f, -0.13706897f, -0.13987029f, 0.26998848f, 0.18223311f, 0.11810287f, 0.06007602f, 
    0.18953647f, 0.04179197f, 0.02079894f, 0.03728436f, 0.05725157f, 0.08831599f, 0.15479819f, 0.10311944f, 
    0.00194484f, 0.09485327f, 0.08566707f, -0.00104446f, -0.21037552f, -0.06076244f, -0.12038416f, 0.01479033f, 
    0.15375046f, -0.07566779f, 0.04429796f, -0.05980178f, 0.11363589f, -0.00982157f, -0.03788700f, -0.05987109f, 
    0.05673495f, -0.04515256f, 0.03208473f, -0.09746601f, -0.24218072f, 0.04807198f, 0.04334445f, 0.06107245f, 
    0.31907910f, -0.16121449f, 0.02220227f, 0.10014154f, -0.00313823f, 0.13847998f, 0.03412277f, 0.14807285f, 
    -0.08559027f, 0.09469442f, -0.05312637f, -0.05481981f, 0.05550342f, -0.08560862f, -0.05776914f, -0.00183508f, 
    -0.02207324f, -0.04904603f, 0.02005722f, -0.03200601f, -0.27808544f, -0.15888420f, 0.06464459f, -0.09589110f, 
    -0.30873704f, 0.09885032f, 0.07762805f, 0.13522625f, -0.01513375f, 0.21025920f, 0.09247096f, 0.00483105f, 
    0.13738450f, -0.03763198f, 0.08984409f, -0.02539444f, 0.11540420f, 0.06845387f, 0.04745341f, 0.03690103f, 
    -0.11457353f, 0.00169872f, 0.04313618f, -0.11520920f, -0.27454293f, 0.01023036f, 0.14320612f, 0.01051401f, 
    -0.03537236f, 0.14777480f, 0.04043824f, -0.04145375f, 0.17354609f, -0.10063450f, 0.07316244f, -0.02766138f, 
    -0.05687698f, 0.17777875f, 0.07470972f, 0.00965882f, 0.26205945f, -0.25028646f, 0.05151889f, 0.17975320f, 
    0.00840843f, -0.01416938f, 0.13417573f, 0.07014836f, 0.06078204f, -0.03715119f, 0.02418770f, -0.02737788f, 
    -0.00240919f, 0.03770160f, -0.02108306f, 0.08542062f, 0.10778645f, 0.06156645f, 0.12373896f, 0.03708987f, 
    -0.05366668f, -0.07674326f, -0.22606871f, 0.00066685f, 0.19057634f, 0.05906932f, 0.05511572f, 0.05798551f, 
    0.03244867f, 0.02061128f, 0.02161545f, 0.03805147f, 0.08408841f, 0.04172063f, 0.07274339f, -0.07019771f, 
    -0.03960713f, 0.00141171f, -0.07013488f, 0.07386915f, 0.33970895f, 0.33892184f, -0.25996196f, -0.02872541f, 
    -0.05752296f, -0.09740888f, 0.09315254f, 0.07457295f, 0.06907381f, 0.11016851f, 0.02906659f, 0.11339713f, 
    0.01054271f, 0.10208893f, 0.12752195f, 0.06855847f, -0.01756709f, 0.02358556f, -0.00827232f, 0.13975783f, 
    0.24489814f, -0.01462337f, -0.09080312f, 0.06457303f, 0.15015236f, 0.10365336f, 0.07452434f, 0.04768104f, 
    0.05608998f, -0.08027798f, 0.18231103f, 0.06339457f, 0.08847087f, -0.01800246f, 0.08201551f, 0.00332790f, 
    0.17595890f, 0.03998083f, 0.06833574f, -0.01446755f, 0.07823773f, -0.08086509f, 0.00259214f, 0.02980659f, 
    -0.09331383f, 0.06068898f, 0.04275747f, -0.04799643f, 0.00436855f, 0.16454686f, 0.14121002f, 0.13084409f, 
    0.09109590f, 0.20181420f, 0.19084062f, 0.13340479f, 0.04545625f, 0.04373028f, 0.08111151f, 0.00719514f, 
    -0.60731226f, 0.19431484f, 0.27575153f, -0.16290545f, 0.45853785f, 0.21075706f, -0.06845864f, 0.12570429f, 
    0.09647077f, 0.27905551f, 0.09046122f, -0.00439836f, 0.08917532f, -0.01146920f, 0.20888048f, 0.11193953f, 
    0.08370683f, 0.02703006f, -0.00397459f, 0.02089884f, -0.50687027f, -0.00715617f, 0.10242568f, -0.06431875f, 
    0.13048911f, 0.11583112f, 0.05693536f, -0.09643605f, 0.06631286f, 0.09730987f, -0.03610417f, 0.03144709f, 
    0.09953193f, 0.05574320f, 0.07866529f, 0.04156812f, 0.14693661f, -0.00777213f, -0.11048621f, -0.02395404f, 
    0.00958887f, -0.02343962f, 0.12858517f, 0.05052682f, 0.22196054f, 0.09734099f, -0.18200925f, 0.05192496f, 
    0.04293165f, 0.01923354f, 0.02211040f, 0.07880639f, 0.02488050f, 0.02013411f, -0.04441537f, -0.10504226f, 
    0.08138298f, -0.11640485f, 0.07526636f, -0.00180999f, 0.03365489f, 0.13231103f, -0.18308167f, -0.00278160f, 
    0.13526060f, 0.17718194f, 0.12229190f, -0.03602885f, -0.01927249f, -0.01334872f, 0.13721140f, 0.15898187f, 
    0.02719007f, 0.07695530f, 0.00714999f, -0.00658263f, 0.12039472f, -0.05982145f, -0.06336366f, -0.04468158f, 
    0.25548813f, 0.03059545f, -0.16530478f, 0.05675147f, 0.15730222f, -0.04386760f, -0.18100239f, -0.05088219f, 
    -0.03785923f, -0.19529186f, 0.00983342f, 0.03778525f, 0.14214437f, -0.02104869f, 0.03553227f, 0.00364859f, 
    -0.03005601f, -0.07985931f, -0.07769158f, -0.00955414f, 0.12160359f, -0.16197151f, 0.05853727f, 0.12839389f, 
    -0.03797096f, 0.03300289f, 0.01230554f, 0.11888254f, 0.02482057f, 0.05247877f, -0.01447340f, -0.10424136f, 
    0.13346928f, -0.14253728f, -0.06391355f, 0.08723586f, 0.05396041f, 0.02938669f, 0.05601682f, 0.13898258f, 
    0.35966966f, 0.23845990f, 0.00152910f, -0.05421455f, 0.06805448f, 0.07569864f, 0.10758638f, 0.09337442f, 
    0.22621976f, 0.06543110f, -0.10315143f, -0.02268137f, 0.08030969f, 0.09509555f, 0.03959973f, 0.14179993f, 
    -0.02389173f, -0.06360284f, -0.03533088f, 0.00197083f, -0.02908637f, 0.23281287f, 0.00006276f, 0.18164073f, 
    0.05648443f, 0.13910052f, 0.08309540f, 0.11350852f, 0.15006906f, 0.00987047f, 0.05290753f, 0.07967356f, 
    0.06450349f, 0.01085241f, -0.00537853f, 0.08933443f, 0.13931197f, 0.01823895f, 0.16765422f, 0.02117448f, 
    0.19241790f, 0.19676639f, 0.12260436f, 0.03690158f, 0.15268701f, 0.09895220f, 0.13770106f, 0.05232014f, 
    0.06382139f, 0.11915178f, 0.11330870f, 0.00319840f, 0.16583268f, 0.13759448f, 0.06588456f, 0.17734671f, 
    0.04549753f, -0.05964315f, -0.05494183f, 0.12332587f, 0.25316736f, 0.09077165f, -0.11039639f, 0.11694511f, 
    0.10944159f, 0.05391083f, -0.08242982f, 0.05743481f, 0.06254337f, 0.08500152f, 0.17564751f, -0.04088984f, 
    0.01219354f, 0.00197274f, 0.03826435f, -0.10995481f, 0.01426310f, 0.01482480f, 0.23601960f, 0.14513823f, 
    0.28491163f, 0.12854479f, -0.20246556f, -0.10249041f, 0.08362773f, 0.05035477f, -0.06190115f, 0.02649060f, 
    0.08052452f, -0.11293387f, 0.05790791f, 0.10790925f, 0.13759635f, -0.05667075f, -0.09515114f, -0.08631260f, 
    0.01299359f, -0.09147956f, 0.01824905f, 0.07376986f, -0.11579388f, -0.07220004f, -0.27828029f, -0.05982966f, 
    -0.09334671f, -0.00684238f, 0.15046316f, -0.01663980f, 0.03049732f, 0.12381756f, 0.02544251f, 0.19262426f, 
    0.04427852f, 0.03980876f, 0.12048128f, -0.09647086f, 0.01481593f, 0.16200119f, 0.04054175f, 0.05346917f, 
    0.04176237f, -0.07172944f, -0.12634110f, 0.00327901f, -0.21245404f, 0.07763530f, 0.08994986f, 0.04686635f, 
    0.07392380f, 0.23834406f, 0.08545625f, 0.16313061f, 0.04710335f, -0.04392489f, 0.01290484f, 0.07465508f, 
    0.06163021f, 0.11128438f, -0.02128053f, 0.11029741f, 0.05078030f, 0.16219902f, -0.09329686f, -0.06906010f, 
    0.23698525f, 0.13776799f, 0.03076180f, 0.15496609f, 0.14217003f, -0.00936355f, -0.01334610f, 0.09001888f, 
    0.14720158f, 0.06796126f, 0.06326305f, 0.15115191f, -0.00441702f, 0.00635134f, 0.00721952f, 0.02855260f, 
    0.02591004f, 0.06112975f, 0.08839560f, -0.06337210f, 0.28394485f, 0.01741576f, 0.12765893f, 0.02704623f, 
    0.02571242f, 0.04088556f, 0.04671007f, -0.03909532f, -0.11891888f, 0.08388831f, 0.03588888f, 0.04538003f, 
    -0.01168036f, 0.15603025f, 0.01566699f, -0.02216541f, 0.19585460f, 0.02488645f, 0.11006847f, 0.21367227f, 
    0.04116978f, 0.01650227f, 0.14228816f, 0.15856627f, 0.11054194f, 0.09378224f, 0.14915146f, -0.00917610f, 
    0.10083543f, -0.08695614f, -0.06147632f, -0.02595105f, 0.03239813f, -0.20379549f, 0.14824454f, 0.14479816f, 
    0.06184398f, 0.04458001f, -0.14450429f, -0.02675325f, 0.16522889f, 0.12446535f, 0.02941181f, 0.10493638f, 
    -0.01598096f, 0.03496050f, 0.02922233f, -0.00176127f, 0.08323627f, -0.09390789f, 0.03310218f, -0.16152079f, 
    0.03629484f, -0.04142464f, 0.02268843f, -0.03472824f, -0.40267068f, 0.09615380f, 0.12262605f, -0.13594951f, 
    0.11617923f, 0.08699657f, 0.01024005f, -0.02543082f, 0.10594058f, 0.17511690f, -0.02217883f, 0.01750381f, 
    0.06166120f, 0.09568966f, 0.06307349f, -0.04412374f, 0.07469112f, -0.01980372f, -0.08423927f, -0.05393628f, 
    -0.08638553f, 0.15341626f, 0.07921895f, 0.11775751f, -0.00630296f, 0.16014859f, 0.03927161f, 0.21509868f, 
    0.07803989f, 0.12829271f, 0.15315981f, 0.18972817f, 0.02328778f, 0.13027915f, 0.19092610f, 0.12359390f, 
    0.16714498f, 0.12158705f, 0.03857354f, 0.15651627f, 0.15464960f, -0.00918146f, -0.11944430f, 0.00730331f, 
    0.17676175f, 0.33787215f, 0.11283322f, 0.03126938f, 0.11341614f, 0.03849530f, -0.03209034f, 0.08302505f, 
    0.02652507f, 0.02932847f, -0.04922885f, 0.08703950f, -0.02200447f, -0.07618216f, 0.09368227f, 0.09748749f, 
    -0.32558349f, 0.03860253f, 0.03900306f, 0.03233854f, -0.03995309f, -0.10617168f, -0.01984784f, -0.04379782f, 
    -0.01992811f, -0.06958644f, -0.01367194f, -0.02997760f, 0.01455701f, 0.06207307f, -0.06701640f, -0.01922308f, 
    -0.05165509f, -0.11559205f, 0.06344922f, -0.05062931f, 0.19112329f, -0.33518636f, -0.00626045f, 0.03354201f, 
    0.35748038f, -0.12991968f, -0.08693655f, 0.07686105f, 0.02970116f, 0.03584639f, 0.12775533f, 0.03621297f, 
    -0.06893423f, -0.08421234f, 0.06930236f, 0.05871616f, 0.01333951f, -0.06361844f, 0.02898009f, -0.00399772f, 
    -0.22615317f, -0.02416839f, 0.07484351f, 0.05841441f, 0.01050695f, -0.02080362f, -0.03634777f, -0.04581772f, 
    -0.08022390f, 0.04118079f, -0.04799647f, 0.09637336f, 0.01271207f, 0.04551467f, -0.10691588f, -0.04648492f, 
    0.00047230f, 0.01422564f, 0.07173740f, -0.02873785f, -0.21522933f, 0.04890514f, 0.00094519f, 0.06150050f, 
    0.00000506f, 0.11155979f, -0.00711838f, 0.03968515f, 0.03067696f, 0.00382731f, 0.19185938f, -0.00555696f, 
    -0.01102357f, 0.06482349f, 0.10356066f, 0.08750457f, 0.19480629f, 0.08137898f, 0.03288171f, 0.04513268f, 
    -0.10075841f, -0.02814485f, -0.03538985f, 0.17393501f, -0.16113122f, -0.04173826f, -0.09605763f, -0.06507169f, 
    -0.02945876f, -0.10550111f, -0.14341846f, 0.10733297f, 0.01117430f, 0.11944038f, 0.09391738f, -0.09317964f, 
    -0.06034172f, 0.06287704f, 0.03953413f, 0.06982003f, 0.19859283f, -0.13606295f, -0.03021091f, -0.05077957f, 
    0.10091180f, -0.03260088f, -0.09275748f, -0.02064335f, 0.10433072f, 0.04577740f, -0.05643684f, 0.08924773f, 
    0.02053427f, -0.04338121f, -0.03188391f, 0.00433589f, 0.03539851f, -0.00076183f, -0.05667739f, 0.05913289f, 
    0.26691496f, -0.15104271f, -0.14189884f, 0.05940905f, 0.36299181f, -0.13942841f, -0.05882457f, 0.09877650f, 
    0.09731419f, 0.04689144f, -0.02750826f, 0.08085306f, -0.03038663f, 0.10014560f, -0.02971146f, 0.04277576f, 
    0.09933931f, -0.00637128f, 0.03313967f, 0.07948662f, -0.01995692f, 0.28423122f, 0.06119924f, -0.17797898f, 
    -0.00168037f, -0.02029840f, -0.00015820f, -0.13465819f, 0.05467800f, 0.07103523f, -0.02312364f, 0.03673081f, 
    -0.01474483f, -0.03954066f, 0.04139199f, -0.05868454f, 0.08399438f, -0.06869598f, -0.06632226f, 0.01480809f, 
    -0.27522203f, 0.12938122f, -0.00778979f, 0.15257214f, -0.00363014f, 0.04410598f, -0.04465101f, 0.08462996f, 
    0.04135577f, 0.02100381f, -0.04407920f, 0.02574113f, 0.03387343f, -0.04060254f, -0.04220791f, 0.10686422f, 
    0.10974089f, 0.07842281f, 0.14271522f, 0.05017552f, -0.79708654f, 0.17421412f, 0.11059748f, 0.11658637f, 
    0.30629483f, 0.01225427f, -0.02727901f, 0.06250440f, 0.00999482f, -0.06815150f, 0.00035658f, -0.00611884f, 
    -0.01801628f, -0.05107852f, -0.10031772f, 0.03141504f, 0.09947362f, -0.14005500f, -0.03777602f, 0.01176849f, 
    0.11680708f, 0.20197344f, 0.06241478f, 0.05551297f, -0.06466665f, 0.04132727f, -0.10867558f, -0.10524485f, 
    0.06203940f, 0.16101164f, -0.08216700f, 0.00977274f, 0.07103056f, 0.06467101f, 0.09812498f, 0.06564306f, 
    -0.05388321f, 0.04581193f, -0.00160894f, -0.07762236f, 0.05013752f, -0.30415583f, -0.07369411f, 0.02994738f, 
    0.26810542f, -0.08412144f, -0.05689509f, -0.04664744f, 0.05814546f, 0.03608127f, 0.05569240f, 0.02619730f, 
    0.03725579f, -0.08872463f, -0.07587334f, -0.03001087f, -0.05447726f, -0.03868416f, -0.01466926f, 0.04038944f, 
    -0.00561489f, 0.26135364f, -0.15294249f, -0.00338562f, -0.39101425f, 0.02830069f, 0.12934248f, -0.01569298f, 
    -0.08630919f, -0.06044516f, 0.17769946f, 0.06867202f, -0.12730442f, 0.01071822f, -0.14905541f, -0.07171091f, 
    0.05047011f, -0.07626407f, 0.00133458f, 0.05873245f, 0.16659421f, -0.09477486f, 0.06000445f, -0.12611622f, 
    -0.03255073f, -0.02985853f, 0.03814647f, 0.03923985f, -0.08964936f, 0.03161306f, 0.02544582f, 0.09926299f, 
    -0.03968253f, -0.04391343f, -0.05897861f, -0.08666840f, 0.04277385f, -0.07662422f, 0.07867131f, 0.06489319f, 
    0.10912010f, 0.09872822f, -0.07243061f, 0.15919577f, -0.11544580f, -0.10308591f, 0.10079291f, 0.01910820f, 
    -0.08933835f, 0.16373947f, 0.09779423f, 0.03604985f, 0.02778381f, 0.01292371f, 0.08060379f, -0.03365141f, 
    0.06083110f, 0.04299606f, -0.07806792f, 0.05504543f, 0.21760437f, 0.11776996f, 0.05912415f, 0.05619229f, 
    -0.04790094f, -0.05890157f, -0.08863533f, 0.06380717f, -0.04683753f, 0.02033657f, -0.02248465f, 0.04086179f, 
    0.02631774f, 0.01256265f, 0.02819207f, -0.06756775f, 0.03177036f, 0.01145851f, 0.13030940f, -0.05295405f, 
    -0.15938559f, 0.00226182f, 0.11783670f, -0.02025326f, -0.02354227f, 0.06175468f, -0.05452529f, -0.00379729f, 
    0.06947280f, 0.22594166f, -0.03157392f, 0.15540540f, 0.09453274f, 0.07113925f, 0.05050001f, -0.07588305f, 
    0.19466931f, 0.16671443f, 0.16693103f, -0.01050730f, 0.11781025f, 0.30190077f, -0.11916351f, -0.20455180f, 
    0.00203604f, 0.03293378f, 0.12471584f, -0.06095723f, -0.03507410f, -0.05715450f, -0.04259523f, 0.01168998f, 
    0.04238383f, 0.08929884f, 0.02276410f, -0.03445382f, -0.04610360f, -0.00553685f, 0.01231858f, -0.14238991f, 
    -0.09690137f, 0.01214239f, -0.03314495f, 0.05983042f, -0.05199564f, 0.05720341f, 0.11855879f, 0.00028750f, 
    -0.01419547f, 0.05778162f, 0.15513809f, -0.01290286f, 0.08319685f, -0.02796666f, -0.06292487f, -0.04856313f, 
    0.00367622f, 0.11740367f, -0.02207887f, 0.03729536f, 0.03977916f, -0.26660338f, 0.06428968f, -0.08604709f, 
    0.03443666f, -0.00772472f, -0.03847159f, 0.05321938f, -0.11078647f, 0.11958408f, 0.00103892f, -0.04141644f, 
    0.08971922f, 0.14369261f, 0.06194955f, 0.10239917f, 0.00518300f, -0.00434428f, -0.03456467f, 0.02777472f, 
    -0.19938591f, -0.27977178f, -0.02205357f, 0.39049509f, 0.06406330f, 0.00757614f, 0.04322945f, 0.03149682f, 
    -0.04810775f, -0.03680498f, 0.11071408f, -0.01372041f, -0.06123957f, -0.10555310f, -0.05747201f, -0.07137342f, 
    0.04154344f, 0.09129299f, 0.00479650f, -0.01391665f, 0.09478474f, 0.18587676f, 0.04174953f, 0.14841796f, 
    -0.05688891f, -0.01601941f, 0.09326812f, 0.05170898f, 0.06499641f, -0.04901988f, -0.05118566f, -0.03929900f, 
    0.00095712f, 0.05155273f, 0.05294269f, 0.05150483f, 0.01098125f, -0.09947419f, -0.04721186f, -0.03496605f, 
    0.03944826f, 0.01880525f, -0.01550975f, 0.22987871f, 0.10031237f, -0.09978341f, -0.04763753f, -0.06360804f, 
    0.18693608f, 0.06255643f, 0.15227228f, -0.10932016f, 0.00287287f, 0.07722357f, 0.05236316f, 0.08588527f, 
    -0.07087465f, -0.00825680f, 0.04375449f, 0.07592519f, 0.08817863f, 0.43770713f, -0.11347564f, 0.00840701f, 
    0.11066941f, -0.04262595f, -0.06417288f, 0.06244073f, 0.13852540f, 0.05894446f, -0.03699732f, 0.00267887f, 
    0.03835739f, 0.04723552f, 0.07486938f, 0.02381216f, 0.03033494f, -0.09705120f, 0.02576716f, 0.08402372f, 
    -0.22384495f, -0.05862566f, 0.11731134f, -0.01696994f, 0.15350121f, -0.10307143f, -0.01298836f, 0.06136348f, 
    0.01530003f, -0.00567895f, -0.13858731f, -0.03203326f, 0.03647390f, 0.04312782f, 0.04087508f, 0.00339639f, 
    0.08353295f, -0.11488413f, 0.00174579f, 0.01138305f, -0.00772030f, -0.03410305f, 0.13999318f, 0.22011364f, 
    -0.01703047f, -0.02446469f, 0.06294989f, 0.02635624f, -0.07937734f, 0.06369921f, 0.12095004f, 0.05571739f, 
    -0.02704436f, 0.02907132f, -0.00300478f, 0.00302090f, -0.02542980f, 0.05851635f, 0.02758827f, 0.03181671f, 
    0.07796999f, -0.02723527f, -0.09327261f, 0.10226449f, 0.07228996f, 0.06955796f, -0.06667578f, -0.06157036f, 
    0.09216331f, 0.11010228f, 0.04281931f, -0.02005777f, 0.12945203f, -0.00919893f, -0.06441772f, -0.06082205f, 
    0.09277558f, -0.17822839f, 0.07645345f, 0.04473931f, 0.02182654f, -0.07776593f, -0.02183723f, 0.10564210f, 
    0.07352847f, -0.06173804f, 0.10893842f, -0.12149961f, -0.02870184f, -0.15276729f, -0.02924320f, -0.10604299f, 
    -0.05515891f, 0.07378978f, -0.04665484f, -0.02800277f, 0.02388826f, 0.10918966f, 0.01279938f, -0.01851568f, 
    0.14438823f, 0.14532645f, 0.19051574f, 0.19544646f, 0.01504729f, -0.05407142f, -0.10252540f, -0.20000026f, 
    0.03466404f, 0.17374662f, -0.01768786f, 0.01647843f, 0.10113803f, 0.07436554f, 0.03566352f, 0.14943494f, 
    -0.07280976f, -0.09713940f, -0.02518833f, -0.09455527f, 0.16163886f, -0.18099144f, 0.03912229f, -0.02526258f, 
    0.02780745f, -0.07412558f, 0.04810095f, 0.10195803f, -0.03075330f, -0.03218924f, 0.05092111f, 0.21965210f, 
    -0.00547958f, -0.02670237f, -0.05304607f, -0.03030734f, 0.06526206f, -0.00502412f, 0.09065126f, 0.04640275f, 
    0.32233208f, -0.24302347f, -0.08371343f, -0.10987744f, 0.01226750f, -0.17404746f, -0.08721873f, -0.05311260f, 
    0.03320912f, 0.01946646f, 0.01291198f, 0.02206022f, -0.08948677f, -0.03636594f, 0.10445917f, -0.15686683f, 
    0.06532615f, -0.12841594f, 0.00574920f, -0.10322410f, 0.08733676f, 0.08960523f, -0.01608042f, 0.03341283f, 
    -0.05974201f, -0.11037299f, -0.04960690f, 0.11363897f, -0.00365062f, 0.02875030f, -0.00684582f, 0.04831049f, 
    -0.03707741f, -0.11584314f, -0.00741235f, 0.00978496f, -0.02141229f, 0.07280142f, 0.01220897f, 0.00940458f, 
    -0.01117385f, 0.02190531f, 0.02159177f, 0.01948060f, -0.04179770f, -0.03543008f, -0.04358432f, -0.01217612f, 
    0.02716767f, -0.00007887f, 0.01761508f, -0.00506291f, -0.04299272f, 0.00698654f, 0.03324218f, 0.02265979f, 
    -0.04173935f, 0.00192309f, -0.02387995f, -0.00045495f, 0.03609006f, 0.00324075f, -0.01734670f, -0.03217362f, 
    -0.03718093f, -0.00900014f, 0.01244718f, -0.03553765f, 0.01519740f, 0.00889296f, 0.00487934f, -0.02068659f, 
    0.02296478f, 0.01017863f, -0.02530398f, 0.01063284f, -0.04394473f, 0.01514883f, -0.00332411f, -0.03827076f, 
    -0.04412539f, -0.02239129f, 0.02945960f, -0.02067496f, 0.00418813f, 0.03347308f, 0.01457864f, 0.02329138f, 
    -0.00858315f, 0.01980472f, 0.02514088f, -0.02003380f, -0.01949543f, 0.01709346f, 0.01909739f, -0.03489586f, 
    0.02164552f, -0.02434393f, 0.01532819f, 0.01942600f, -0.00243607f, -0.02771370f, -0.00276246f, -0.04274862f, 
    -0.03256311f, 0.01440526f, -0.02746039f, -0.03630494f, 0.00331454f, 0.02600924f, -0.02265160f, -0.02045251f, 
    0.00460981f, 0.01721426f, 0.02855650f, 0.00879752f, 0.02585234f, 0.02471095f, -0.03819907f, -0.01462381f, 
    -0.02235120f, 0.02623105f, -0.04317413f, 0.02531870f, -0.00809108f, -0.03830780f, -0.00213868f, 0.01750535f, 
    0.02783329f, 0.01667536f, 0.00832880f, 0.02572140f, -0.03458543f, -0.00891698f, -0.03998464f, 0.02767478f, 
    0.02205366f, -0.02309113f, 0.02228335f, -0.03132978f, -0.00620926f, 0.02654898f, -0.03200375f, -0.00963145f, 
    0.02908679f, -0.02639347f, -0.04238201f, -0.02627894f, 0.00089642f, 0.00416681f, 0.00591963f, 0.02302272f, 
    -0.00553392f, -0.00976916f, -0.01405219f, -0.02151235f, -0.01041521f, -0.02822140f, 0.01364932f, -0.03016241f, 
    0.03099430f, 0.03308797f, -0.01977801f, -0.02598568f, 0.00015765f, 0.03218650f, 0.01156714f, 0.00335119f, 
    -0.02161508f, 0.00670479f, -0.00644249f, -0.01598313f, -0.04697854f, -0.02871866f, -0.03162228f, -0.00094366f, 
    -0.02063718f, 0.01956964f, -0.00065467f, 0.01618914f, 0.01360430f, -0.04256795f, -0.02723678f, -0.02954527f, 
    -0.02391475f, 0.00844879f, -0.01338903f, 0.01330521f, 0.01323133f, 0.01623118f, -0.03794342f, -0.02381027f, 
    -0.04289471f, -0.03125766f, -0.01315532f, -0.04489622f, 0.00293750f, 0.01188640f, 0.02154057f, 0.02610354f, 
    0.02415122f, -0.02471185f, 0.00994577f, -0.01303866f, -0.04354133f, -0.02734180f, 0.00805686f, -0.02715373f, 
    0.02479859f, -0.03613884f, -0.04402344f, 0.00820010f, -0.03917960f, -0.02388120f, -0.01359827f, 0.03382951f, 
    -0.03562121f, 0.02975079f, -0.01101319f, -0.01315810f, -0.00329279f, 0.02962122f, -0.01890337f, 0.02705311f, 
    -0.04291648f, 0.02774306f, 0.02492432f, -0.00616943f, -0.01287977f, -0.03458587f, -0.01089612f, -0.03670542f, 
    -0.00512541f, 0.02423510f, 0.02070564f, -0.00001134f, -0.02431786f, 0.03142983f, -0.01791727f, -0.00312475f, 
    -0.00512028f, -0.01486724f, 0.03141525f, -0.00759185f, -0.02798244f, 0.00130417f, -0.01428497f, 0.01240272f, 
    -0.00367833f, 0.01220195f, -0.04338248f, -0.03870079f, -0.02354950f, 0.01120937f, 0.02235031f, 0.01657582f, 
    0.02222355f, -0.01629779f, 0.02221788f, -0.04017337f, -0.00631211f, -0.02093857f, -0.03534875f, 0.02720114f, 
    -0.03116083f, -0.00075487f, -0.03279176f, -0.04603117f, 0.00896892f, -0.02562111f, 0.02576026f, -0.03354259f, 
    -0.03541832f, -0.03307678f, 0.02563933f, 0.00332146f, -0.01328882f, -0.04106085f, 0.02938932f, -0.01538991f, 
    -0.01344003f, 0.01295391f, -0.02475095f, 0.01650439f, 0.00671681f, 0.01572904f, -0.02422026f, 0.03383995f, 
    -0.01004660f, 0.01700009f, -0.02067732f, -0.02599894f, 0.01972422f, -0.02678648f, -0.01822359f, 0.03073094f, 
    0.00029946f, -0.01742035f, -0.02712581f, 0.00536149f, 0.01634820f, 0.00653918f, -0.04314156f, 0.02010138f, 
    0.02944451f, 0.00572738f, -0.03123241f, 0.02592062f, -0.03125989f, -0.03521715f, -0.02004532f, -0.01116219f, 
    -0.00433114f, -0.02170395f, -0.00364801f, 0.01394134f, -0.03432036f, -0.02139384f, 0.01721326f, 0.02268397f, 
    0.02399776f, -0.03060333f, -0.03491655f, -0.00632518f, 0.01267816f, -0.01945837f, -0.04256555f, 0.02855973f, 
    0.03318953f, 0.01536844f, 0.00936653f, -0.03902424f, -0.00368013f, -0.02424149f, -0.04045838f, 0.01688870f, 
    -0.03130448f, 0.00834980f, -0.03866297f, -0.00819302f, -0.03548943f, 0.00989049f, 0.01271027f, -0.01290437f, 
    -0.03024573f, -0.00014278f, -0.01946682f, 0.01024927f, 0.02870826f, 0.03793837f, 0.00037011f, 0.02143049f, 
    0.01200922f, 0.00484753f, -0.00318103f, 0.02677316f, -0.01235153f, -0.01069877f, -0.01198763f, 0.00376756f, 
    -0.01437502f, 0.01408018f, -0.02389842f, 0.00193217f, -0.01059012f, -0.03116867f, -0.01189482f, -0.03672828f, 
    -0.02742473f, -0.05007023f, 0.02492619f, -0.04267731f, -0.03380202f, 0.02557312f, 0.00851115f, 0.00905163f, 
    -0.00324379f, -0.01595880f, 0.01454151f, 0.00025695f, -0.04566994f, 0.02177870f, -0.03339335f, -0.02234220f, 
    -0.00538744f, 0.01777128f, -0.00018485f, -0.00403088f, -0.01112157f, 0.03436814f, 0.00899521f, 0.01184064f, 
    -0.02059474f, -0.02176576f, 0.01576035f, -0.04023634f, -0.02874039f, 0.01565342f, 0.02475568f, 0.01639567f, 
    0.02089084f, 0.01722159f, -0.01309308f, -0.03831806f, -0.03885647f, -0.03340727f, -0.03704804f, 0.02607406f, 
    -0.02036999f, 0.01830291f, -0.01180997f, 0.01464882f, 0.00620697f, -0.00168499f, 0.02239236f, 0.01334797f, 
    -0.04087140f, 0.00606592f, 0.02864625f, -0.03729810f, 0.00108486f, -0.03228721f, -0.02684115f, -0.02889200f, 
    -0.00362422f, -0.00000419f, 0.00133270f, -0.04002638f, -0.01012464f, -0.01215677f, -0.01822461f, -0.02228883f, 
    -0.03127473f, -0.01132787f, -0.03439848f, -0.04069632f, -0.01536778f, -0.00901926f, -0.02454958f, -0.02373351f, 
    -0.04196731f, 0.00824538f, -0.00113992f, 0.02583560f, -0.00568673f, 0.00052825f, 0.02348848f, -0.00885250f, 
    0.02752255f, -0.04489348f, -0.03297305f, 0.01335724f, 0.01706585f, 0.00587685f, -0.02589555f, 0.02013759f, 
    -0.02677986f, -0.03255166f, 0.00311710f, -0.00864185f, 0.01598619f, 0.01567577f, 0.01902003f, 0.00978039f, 
    -0.00276428f, 0.00594547f, -0.02825239f, 0.02230339f, 0.01044410f, 0.03463449f, 0.01999419f, 0.01038384f, 
    0.03407793f, 0.03022815f, 0.00992426f, -0.01248824f, -0.00922231f, -0.01720256f, -0.02634753f, -0.00802687f, 
    -0.02861255f, 0.02761964f, 0.03103726f, -0.01550955f, -0.03139599f, -0.00926273f, -0.02861711f, 0.01051608f, 
    -0.02976205f, 0.01802876f, -0.01855512f, 0.03133035f, 0.00710117f, 0.03790571f, -0.01876030f, -0.02625300f, 
    -0.04089300f, -0.01472903f, 0.00149947f, -0.03293652f, 0.01965270f, -0.02703475f, 0.01088118f, -0.02071651f, 
    0.02324029f, 0.01057003f, -0.00299853f, -0.01614761f, -0.00892524f, -0.02774203f, -0.04438784f, -0.01040137f, 
    -0.02598907f, -0.02473433f, 0.00729882f, 0.02476216f, -0.01185163f, -0.01680500f, 0.00469261f, -0.01739907f, 
    0.00327148f, 0.00481991f, -0.00714686f, 0.01205445f, -0.00298740f, -0.03369454f, -0.04863389f, -0.03981401f, 
    -0.00968943f, -0.03619714f, -0.02046086f, 0.00843570f, -0.00534028f, -0.04406880f, 0.02218464f, 0.03318428f, 
    -0.02584737f, -0.03178864f, 0.02945369f, 0.02608327f, -0.04649774f, 0.00565597f, 0.02528931f, 0.00812779f, 
    -0.02599664f, -0.01043677f, -0.00201360f, -0.00699316f, -0.04111142f, -0.00638337f, 0.01862716f, -0.00481918f, 
    -0.01879469f, -0.01348314f, -0.01798934f, -0.02068246f, 0.02743495f, 0.01537634f, 0.03036138f, 0.01088239f, 
    0.03027873f, 0.01420361f, -0.01122690f, 0.03133969f, -0.00120358f, -0.03792525f, 0.02123127f, -0.02383552f, 
    -0.00827435f, -0.02498158f, -0.02665590f, -0.02602214f, 0.02785021f, 0.00659618f, -0.02939087f, 0.00302737f, 
    0.03604716f, -0.02823259f, -0.03490309f, -0.01544038f, -0.04489995f, -0.02517429f, 0.03172962f, -0.02476373f, 
    0.02461670f, 0.01780172f, 0.00908766f, 0.01186927f, -0.01190362f, -0.00866201f, 0.03211050f, -0.03584836f, 
    -0.00021690f, 0.01259914f, 0.01239128f, 0.01440527f, 0.01262789f, -0.02918358f, -0.02704655f, -0.00373815f, 
    -0.03907442f, 0.02222105f, 0.01163009f, -0.00697216f, 0.02791917f, 0.01348910f, 0.00517175f, 0.02467045f, 
    -0.01162502f, -0.00300807f, -0.04019041f, -0.01372748f, 0.01070837f, -0.00904224f, -0.01892311f, 0.02697434f, 
    -0.01140599f, 0.02818368f, -0.03128788f, -0.00126741f, -0.04826250f, 0.03054057f, -0.03395992f, 0.00073631f, 
    -0.02393517f, -0.03062746f, -0.03178752f, 0.00841476f, -0.02241267f, 0.02550506f, -0.01587948f, -0.01106274f, 
    -0.00775256f, 0.01562793f, -0.01104940f, 0.01638596f, -0.00868657f, -0.01536509f, 0.03531350f, -0.00673618f, 
    -0.00393252f, -0.00088825f, 0.03324863f, -0.01084184f, -0.02326611f, 0.01678891f, -0.04516597f, 0.03065617f, 
    0.01575220f, 0.01088717f, -0.00931626f, 0.00462384f, 0.01035970f, 0.02220032f, 0.01509114f, -0.03969504f, 
    0.01060121f, -0.00660902f, -0.02764976f, -0.00548225f, 0.00794039f, -0.01200032f, 0.02394749f, -0.00115272f, 
    0.01533608f, 0.02193877f, 0.01349356f, -0.00915241f, 0.00798135f, -0.00296707f, -0.01447220f, -0.03216175f, 
    -0.01954912f, 0.03314922f, 0.01423621f, -0.01364602f, 0.00884516f, -0.04390609f, -0.02588631f, 0.01415679f, 
    0.20411104f, -0.33045471f, -0.16899416f, 0.22800225f, -0.16716617f, 0.02914196f, 0.08424641f, 0.00283881f, 
    0.04369117f, 0.06331439f, 0.05234469f, -0.05718246f, 0.03640664f, 0.01404892f, -0.01727508f, -0.04152989f, 
    0.00388834f, -0.02124053f, 0.06274878f, 0.07446924f, 0.11911630f, -0.20495084f, 0.40811071f, 0.04944397f, 
    -0.13339581f, -0.07181645f, -0.08505755f, 0.08959935f, -0.00102335f, 0.02584100f, -0.01043567f, -0.05200282f, 
    -0.01921473f, -0.10902309f, -0.00618515f, 0.05989859f, 0.08550949f, -0.04047341f, 0.08302131f, -0.01550914f, 
    0.06281114f, -0.39556342f, -0.00414782f, 0.11625846f, -0.00949897f, -0.05245550f, 0.08495804f, 0.05743729f, 
    -0.04708107f, 0.09179013f, 0.01228889f, -0.03431407f, 0.04978206f, -0.20528492f, -0.17012881f, -0.14088339f, 
    0.04273646f, 0.00144163f, 0.08700909f, 0.04817314f, -0.06198742f, 0.23651642f, -0.08763318f, -0.04445536f, 
    0.10637180f, 0.21007049f, 0.02140503f, 0.04560578f, 0.04061981f, 0.16022354f, 0.05936191f, 0.05265073f, 
    -0.13275281f, 0.12583964f, -0.01778628f, 0.04664420f, 0.16890937f, -0.07249327f, 0.00034853f, -0.04348429f, 
    -0.51320946f, 0.14193597f, 0.14326988f, 0.06658591f, 0.01156414f, 0.13886437f, -0.04842062f, 0.00337421f, 
    0.04250478f, 0.01294202f, 0.02794687f, 0.13373539f, 0.03041944f, 0.11221670f, 0.01101326f, -0.03879603f, 
    -0.05259250f, 0.12372740f, 0.02489749f, 0.02993114f, 0.13070083f, 0.22736648f, 0.26619160f, -0.02482924f, 
    0.08972924f, 0.04480775f, -0.02863029f, 0.09453583f, 0.05212084f, -0.11627803f, 0.05369097f, 0.15690084f, 
    -0.04741828f, 0.07193423f, -0.08338473f, 0.16210450f, 0.06535176f, -0.03017803f, -0.03148143f, -0.02351673f, 
    0.13896784f, 0.11335918f, 0.23707272f, -0.12423923f, 0.11886180f, -0.07153849f, -0.06492681f, 0.05423886f, 
    0.05991160f, -0.06913955f, -0.06113721f, 0.15774481f, -0.03653610f, 0.08637504f, -0.15744688f, 0.07410588f, 
    0.11075167f, 0.01450366f, -0.10910044f, 0.09909934f, -0.28422886f, 0.14414626f, 0.07572907f, -0.24417673f, 
    -0.02655584f, -0.01527384f, -0.05910400f, -0.03416394f, -0.04519356f, 0.09688113f, -0.05095133f, 0.01810694f, 
    0.13123362f, -0.03632287f, -0.03572959f, 0.05503852f, 0.00222144f, 0.03586476f, -0.02937785f, -0.02088005f, 
    -0.05085003f, 0.18750277f, 0.04428200f, 0.05982642f, 0.07701787f, 0.24439596f, 0.00370305f, 0.10708699f, 
    0.05600716f, 0.12566209f, 0.04704560f, 0.06891441f, 0.02012767f, 0.05119112f, -0.02356425f, 0.03445523f, 
    0.00374901f, 0.08646872f, 0.03746920f, -0.00238373f, -0.23857118f, -0.28566131f, 0.32532656f, 0.03049553f, 
    -0.03840492f, -0.01281724f, 0.02833527f, 0.06296148f, -0.09201192f, 0.09997251f, 0.07576105f, 0.01062163f, 
    0.09590682f, -0.06294669f, -0.02426487f, -0.04091813f, 0.07116253f, -0.02369677f, -0.09846506f, -0.04068252f, 
    0.08729950f, -0.04253488f, -0.03242370f, 0.17744307f, 0.06563908f, 0.10531847f, 0.07112182f, -0.07178712f, 
    0.18007000f, 0.17774181f, -0.09663636f, 0.06491152f, -0.16264679f, -0.02701436f, -0.00852852f, -0.04673343f, 
    -0.06983819f, 0.06637155f, 0.04115165f, -0.08139738f, -0.27927771f, 0.08220788f, 0.36782396f, -0.25757420f, 
    -0.10659999f, -0.15521415f, -0.04873244f, 0.03920244f, 0.01889900f, -0.01317179f, -0.08803368f, -0.04827566f, 
    -0.04214666f, -0.03511499f, -0.03448445f, -0.09120776f, 0.04102080f, -0.15798959f, -0.08639414f, 0.11450869f, 
    0.13191186f, -0.00765231f, -0.17738101f, -0.00574900f, -0.66895127f, 0.06644580f, 0.11836772f, 0.08431552f, 
    -0.02285711f, -0.14621229f, -0.08121342f, -0.00314369f, -0.08103319f, 0.05642075f, -0.10274846f, 0.04358385f, 
    -0.00863404f, 0.07261794f, -0.01546864f, 0.08217236f, 0.47781155f, 0.13496934f, -0.07992180f, -0.17633349f, 
    -0.07996802f, -0.10035238f, -0.02102295f, 0.12461703f, -0.02754511f, -0.07139558f, 0.06995236f, 0.06597250f, 
    -0.07433837f, -0.01112852f, -0.00708761f, 0.04320735f, -0.15197317f, -0.10352946f, 0.08855817f, 0.11649787f, 
    0.02329668f, -0.02053331f, -0.23928508f, 0.08550700f, 0.05063195f, -0.01233812f, 0.05497713f, -0.10295986f, 
    0.11205572f, 0.07538657f, 0.03192715f, -0.05757478f, 0.01989808f, 0.03250245f, 0.09205372f, 0.03376514f, 
    0.03125170f, 0.02690278f, -0.05766790f, -0.01991593f, 0.19453418f, -0.27305013f, -0.01178685f, 0.17550620f, 
    0.06217189f, -0.00580714f, 0.05829138f, 0.05953434f, 0.07262180f, -0.06241985f, -0.13978052f, -0.08639929f, 
    -0.16062300f, 0.03588391f, -0.01168711f, -0.02841934f, 0.02706005f, 0.19303828f, 0.24004863f, -0.01396063f, 
    -0.16835271f, -0.06777836f, 0.15208265f, 0.11266315f, 0.14454414f, 0.12601300f, 0.20192969f, -0.07828319f, 
    0.07493970f, 0.27413592f, 0.01828263f, -0.00489132f, 0.03336061f, 0.13420418f, 0.03762684f, -0.13177446f, 
    0.08359007f, 0.11337601f, 0.07594306f, -0.06821702f, -0.15124755f, -0.15183015f, 0.02351168f, -0.11416809f, 
    0.11561706f, 0.06561964f, 0.06390551f, -0.01084928f, 0.03629205f, 0.04803136f, 0.02081348f, 0.14266005f, 
    -0.01347482f, 0.00131210f, 0.03037850f, 0.01342444f, -0.14380185f, 0.05962576f, 0.07468553f, -0.00128670f, 
    0.00907500f, -0.35726550f, 0.09358122f, 0.13850211f, 0.07373633f, 0.06321100f, 0.11021808f, 0.05936084f, 
    0.00403492f, 0.05435732f, 0.16645829f, 0.00079502f, 0.04755459f, -0.11841437f, -0.03815888f, -0.12812859f, 
    0.00296398f, 0.12828323f, 0.15624885f, 0.14503346f, 0.02285153f, -0.23300220f, 0.04140786f, 0.02050070f, 
    0.00898011f, 0.03768665f, 0.06494662f, -0.05663675f, -0.01561022f, 0.09924544f, 0.02679934f, -0.02773068f, 
    0.20049305f, -0.05865768f, -0.04708857f, -0.09158374f, -0.08028351f, 0.05503527f, -0.12363899f, -0.02489120f, 
    -0.16810410f, -0.11571562f, 0.12823331f, -0.01949914f, -0.29721013f, -0.12032846f, -0.05065358f, -0.13330826f, 
    -0.01858192f, -0.05485401f, -0.06830545f, 0.02460117f, 0.02969239f, 0.00612268f, -0.01867379f, -0.21264268f, 
    0.08946437f, -0.05152759f, 0.04063683f, -0.02436993f, -0.22395620f, -0.08940879f, 0.12767044f, -0.03261207f, 
    0.09013734f, 0.08154677f, -0.00959856f, 0.00378455f, -0.01399201f, -0.04605538f, -0.09133986f, -0.06921066f, 
    0.01710873f, 0.05334179f, -0.01137644f, 0.09284209f, -0.04207866f, 0.08270235f, -0.08312613f, 0.08649632f, 
    -0.29774335f, -0.17797802f, 0.09158307f, 0.40432659f, 0.25054452f, 0.10228069f, 0.08514422f, 0.00773503f, 
    0.09363144f, 0.21802352f, 0.13033731f, -0.15234326f, -0.06414261f, 0.06925587f, 0.07878517f, 0.16714825f, 
    -0.03328974f, -0.00926046f, 0.06367646f, 0.07655058f, 0.18204296f, 0.35537827f, 0.08097845f, -0.08500298f, 
    0.13847376f, 0.04526735f, 0.04526396f, 0.12376663f, 0.02992442f, 0.00863694f, -0.02994776f, -0.02786753f, 
    0.03693374f, 0.06941599f, -0.04476336f, 0.13016833f, 0.03293183f, -0.08886081f, 0.07376223f, -0.04575124f, 
    -0.04669004f, 0.12125788f, 0.30558330f, -0.08756470f, 0.16374549f, -0.01667199f, 0.11187824f, 0.14270160f, 
    -0.05473324f, -0.06169698f, -0.04713771f, 0.01979833f, 0.00499907f, 0.01069089f, 0.03207143f, -0.04558380f, 
    0.03973813f, -0.05674545f, 0.03834601f, 0.01276651f, 0.13024592f, -0.16228177f, 0.00648844f, 0.23402165f, 
    -0.12703270f, -0.05849720f, 0.03177172f, -0.02719377f, 0.01652828f, -0.01404423f, 0.00255699f, -0.05337021f, 
    0.01874997f, -0.00309906f, -0.03933837f, -0.10321604f, 0.07139573f, 0.00327164f, 0.06395540f, 0.03134608f, 
    0.11619694f, -0.12771748f, -0.15377499f, 0.22672687f, 0.07104617f, 0.18805152f, 0.00828395f, -0.01660880f, 
    0.17118466f, 0.15458706f, 0.05338577f, 0.02100647f, 0.06881126f, -0.01869332f, -0.03926700f, 0.01495578f, 
    -0.03746073f, -0.12657657f, 0.12254884f, 0.02428240f, -0.02893354f, 0.06043124f, -0.13319673f, -0.21977489f, 
    0.03862693f, -0.01691866f, 0.00130303f, -0.14701046f, -0.06297875f, -0.08216509f, -0.04542045f, -0.05541142f, 
    0.03680746f, 0.13683005f, -0.06452141f, 0.06913397f, 0.07435411f, 0.09286225f, -0.11031780f, -0.02218092f, 
    0.06117938f, 0.02301149f, 0.02179106f, 0.23491256f, 0.15299658f, 0.05822164f, 0.08567599f, -0.14035471f, 
    0.13804744f, 0.17046674f, -0.03653556f, 0.07832471f, -0.05274680f, -0.01377873f, 0.01899799f, 0.07548790f, 
    -0.06379539f, -0.01592968f, -0.00661635f, -0.00252610f, 0.43552268f, 0.04003964f, -0.11265656f, 0.02701111f, 
    -0.06623095f, -0.09536724f, -0.03444425f, 0.08146758f, -0.01306322f, -0.11122232f, 0.10308138f, 0.12040935f, 
    -0.02647977f, 0.03080167f, -0.08669680f, 0.13665986f, -0.02390183f, -0.07982974f, 0.04785512f, 0.07814288f, 
    0.14984682f, -0.05544516f, 0.24896081f, -0.18822856f, -0.12486985f, -0.24250284f, 0.01625724f, -0.00480479f, 
    -0.04745314f, -0.03093557f, -0.03580266f, -0.00785491f, 0.02155254f, 0.00893384f, 0.04195597f, -0.09850699f, 
    -0.05160899f, -0.04485411f, 0.00388515f, -0.03985722f, 0.05880560f, -0.24243671f, -0.05032631f, 0.18910043f, 
    -0.16795848f, -0.10716034f, 0.09188110f, 0.10809048f, 0.01873377f, -0.02727743f, -0.03395212f, 0.00907549f, 
    0.09126739f, -0.07606861f, -0.01607531f, 0.05828490f, -0.08361834f, 0.10265178f, -0.03742977f, -0.00069857f, 
    -0.00197012f, 0.02580128f, 0.02230322f, 0.01167763f, -0.02710033f, 0.02649620f, 0.02005382f, 0.01863622f, 
    -0.00829233f, -0.02300415f, 0.02808430f, -0.02965630f, -0.00704427f, -0.01438739f, -0.00641311f, 0.00727802f, 
    -0.02537280f, -0.02774229f, -0.03298923f, 0.03026963f, -0.04077734f, 0.02616224f, -0.03617458f, -0.01278336f, 
    -0.01208327f, 0.01767099f, 0.01198610f, 0.00072123f, 0.00831566f, 0.01861855f, -0.00675711f, -0.01722011f, 
    -0.01382020f, 0.01508574f, -0.01975763f, 0.02438659f, 0.00103022f, 0.00225742f, -0.00748557f, -0.03045001f, 
    0.01959949f, 0.00538910f, -0.03355606f, 0.01652027f, -0.00090049f, 0.00144140f, -0.00539473f, 0.02207609f, 
    0.01116394f, 0.01197661f, -0.00993484f, 0.02997903f, 0.00233829f, 0.02037780f, 0.00405705f, -0.04450937f, 
    -0.02121013f, -0.02809882f, -0.03799460f, -0.02612141f, 0.02548641f, -0.01603703f, 0.01829940f, 0.02871075f, 
    0.02347163f, 0.02849986f, 0.02823258f, 0.01647620f, -0.02677790f, 0.01823109f, 0.01571042f, -0.01154203f, 
    -0.00689168f, -0.00523746f, 0.02488010f, -0.03004989f, 0.00453376f, -0.03112725f, -0.04034800f, 0.00966575f, 
    0.02235148f, -0.03445384f, -0.00138641f, -0.00124212f, 0.02799461f, -0.02201601f, -0.02067571f, -0.02784999f, 
    -0.04056008f, -0.04321581f, 0.00571409f, 0.02059374f, 0.00012191f, -0.01413624f, -0.00611289f, -0.03949712f, 
    -0.02876964f, -0.01237195f, 0.02576230f, -0.04223597f, -0.00185113f, -0.01157779f, -0.02718036f, -0.01168199f, 
    -0.00809619f, 0.02988052f, 0.00964347f, -0.01975131f, 0.00821364f, -0.01928008f, -0.02806639f, 0.01042952f, 
    0.00307512f, -0.00119572f, 0.00385216f, 0.01879382f, 0.00123298f, -0.03672008f, 0.02142639f, -0.02866249f, 
    0.00567017f, 0.00820676f, 0.02617221f, -0.02620753f, -0.01939732f, 0.01670866f, -0.03002598f, -0.01033142f, 
    -0.00067464f, -0.03297282f, -0.04719889f, 0.01444838f, 0.01741817f, -0.02972641f, -0.03764213f, 0.00706845f, 
    -0.04256716f, -0.01579144f, 0.00473425f, 0.02336085f, -0.01113715f, -0.00938989f, -0.02663734f, -0.04158071f, 
    0.02846753f, -0.01464162f, 0.00235890f, 0.02527256f, -0.04003289f, -0.03621198f, 0.01145795f, -0.00976322f, 
    -0.02425934f, 0.03105932f, -0.04389826f, -0.01858232f, -0.03678980f, 0.01965559f, -0.01802707f, -0.03465562f, 
    0.00447170f, -0.00254351f, -0.01578001f, -0.00025661f, 0.00092718f, 0.01601884f, -0.02923962f, 0.01596186f, 
    -0.00028089f, 0.01293996f, -0.01041529f, 0.00362160f, -0.01840702f, -0.01871777f, 0.02056655f, 0.02042218f, 
    0.02644637f, -0.00429356f, -0.02542915f, -0.00554650f, -0.01141749f, 0.01451830f, -0.02569676f, -0.01928141f, 
    0.00891745f, 0.01193252f, -0.03245360f, -0.02040099f, 0.03227532f, -0.04797125f, -0.03502827f, -0.01106257f, 
    0.02439372f, -0.02525601f, -0.03967339f, -0.01108010f, 0.01634560f, -0.01138398f, -0.00655947f, 0.01147761f, 
    0.01368996f, 0.02506305f, -0.03570264f, 0.00257710f, -0.01412575f, -0.01033481f, -0.02827868f, 0.00212428f, 
    -0.00764071f, -0.02426221f, 0.02022571f, -0.01315766f, 0.01679727f, 0.00222284f, -0.03330047f, -0.01787319f, 
    -0.00631889f, -0.01758547f, -0.01552202f, -0.00623443f, -0.03787422f, 0.03353288f, -0.02959750f, -0.02435877f, 
    0.01793970f, 0.00276589f, 0.00058345f, -0.01576339f, -0.00460199f, -0.03782395f, -0.03739622f, 0.00332133f, 
    -0.01777256f, -0.03247844f, -0.03739074f, -0.02416691f, -0.00338786f, 0.03260415f, 0.02136174f, -0.00604502f, 
    0.01581153f, -0.00894322f, -0.01397692f, -0.00741820f, -0.04021833f, 0.01044801f, 0.02261782f, 0.03299489f, 
    -0.01806465f, 0.02432794f, 0.00870999f, 0.01482880f, -0.01571384f, -0.03922662f, -0.02575144f, 0.00506157f, 
    -0.02279156f, 0.00722363f, -0.01316849f, 0.03397746f, -0.01217367f, -0.00082233f, -0.01016033f, 0.02879355f, 
    -0.03268313f, 0.01968729f, 0.01877186f, -0.03390881f, 0.01370982f, -0.02453224f, 0.02553474f, 0.00753009f, 
    -0.04217802f, 0.02474857f, -0.02510328f, -0.02660855f, -0.02217905f, -0.01397272f, -0.03787636f, -0.03599047f, 
    0.01106405f, 0.01421715f, -0.04107224f, -0.00850262f, 0.01234435f, 0.00434746f, -0.00170806f, 0.02819948f, 
    -0.04417176f, -0.03920733f, 0.02065758f, 0.02709637f, -0.03145223f, 0.01186753f, -0.02674033f, -0.01097646f, 
    -0.04632302f, -0.03095012f, 0.02865565f, 0.03159190f, 0.02130494f, -0.01549099f, 0.02077441f, -0.00704404f, 
    0.01841247f, -0.00518155f, -0.02131056f, 0.01180995f, -0.02490301f, 0.01678947f, 0.02516931f, -0.01798975f, 
    0.01780055f, -0.00039969f, 0.02679468f, -0.00299529f, -0.02432496f, -0.02955665f, -0.04311964f, -0.02573273f, 
    -0.02146056f, -0.01662333f, 0.01685354f, 0.01792634f, -0.00199368f, -0.00052882f, -0.03076903f, -0.04064954f, 
    -0.01452123f, -0.03040034f, -0.03040947f, -0.03254920f, 0.03029542f, -0.02696116f, -0.03875781f, -0.02529902f, 
    -0.01469106f, 0.02589299f, -0.03614159f, -0.01921953f, -0.01348335f, -0.01693414f, -0.03865505f, -0.03114817f, 
    0.01110567f, -0.03414398f, -0.03487287f, -0.02360570f, -0.04256707f, 0.02238659f, 0.00335536f, -0.03004350f, 
    -0.04836936f, -0.03768613f, -0.04252495f, 0.02771038f, 0.02268906f, 0.02791791f, -0.01495188f, 0.03372538f, 
    -0.01744542f, -0.01363127f, -0.01904490f, 0.03740542f, -0.03326588f, -0.00257257f, 0.01841013f, -0.00277242f, 
    -0.00452469f, -0.02102168f, -0.00891411f, 0.01826302f, 0.02491388f, 0.02761069f, -0.00737512f, -0.03355059f, 
    -0.00819729f, -0.02202280f, -0.00624055f, -0.01974429f, -0.03847839f, -0.02453339f, -0.00129438f, 0.03078543f, 
    0.02616542f, -0.02052272f, -0.02749015f, 0.01037566f, -0.02084320f, 0.01382295f, 0.02147565f, 0.01754312f, 
    0.00112164f, 0.00017155f, -0.01899463f, -0.00399277f, -0.00730011f, 0.02124527f, -0.03782569f, 0.01709027f, 
    0.03233369f, 0.02253451f, 0.01503529f, 0.01612928f, -0.02052694f, -0.03342881f, -0.02226943f, 0.01424200f, 
    -0.00182254f, 0.00420746f, 0.02559987f, 0.01901344f, 0.02172443f, -0.04583881f, -0.02051895f, -0.03387589f, 
    -0.01256989f, 0.02255579f, -0.03532714f, 0.02470670f, 0.00699518f, 0.03759545f, -0.00244758f, -0.00884579f, 
    0.03321560f, -0.04219699f, -0.04518153f, -0.03474560f, 0.02606852f, -0.01484212f, -0.00896786f, 0.01984769f, 
    -0.00762776f, -0.04168583f, -0.01473737f, -0.02167457f, 0.01579234f, -0.01975132f, 0.02727307f, 0.01999214f, 
    0.03487378f, -0.00535176f, -0.00229699f, -0.01483529f, 0.00259270f, 0.02079734f, -0.02906048f, -0.04238961f, 
    -0.00665544f, -0.00691065f, 0.02823052f, -0.02743907f, 0.02427710f, 0.01342684f, 0.02664237f, -0.00677049f, 
    -0.00861675f, -0.03546324f, 0.03211022f, -0.04646743f, 0.02098916f, 0.02622244f, -0.03841796f, -0.03823357f, 
    -0.01944595f, -0.04443502f, 0.02096091f, 0.02085741f, -0.02992209f, -0.04089451f, 0.00637606f, -0.03623616f, 
    -0.04338297f, -0.04566989f, -0.02576273f, -0.03201943f, -0.00501130f, 0.01283796f, -0.02252592f, -0.00191623f, 
    0.03008832f, -0.02476380f, -0.01290861f, -0.04257724f, -0.00903621f, -0.02268891f, -0.01039344f, -0.01994123f, 
    -0.03364549f, 0.02104956f, -0.04668754f, -0.00478222f, -0.00523642f, -0.02755171f, 0.01579404f, 0.00538666f, 
    -0.01607442f, -0.00562740f, 0.00829999f, 0.01032870f, 0.02862058f, 0.01501874f, 0.01727306f, -0.04467409f, 
    -0.03024814f, -0.02909534f, 0.02051410f, -0.01721153f, -0.03053862f, -0.00478966f, -0.04082409f, 0.00043428f, 
    -0.01924517f, -0.03988494f, -0.00551596f, -0.04097265f, -0.01458552f, -0.04105736f, -0.03428911f, -0.01410257f, 
    0.03532590f, -0.03820829f, -0.03153739f, -0.01725612f, -0.01873237f, 0.00927558f, 0.00489696f, -0.03627479f, 
    0.01238247f, -0.03060770f, 0.03160805f, 0.00123210f, -0.00625502f, -0.00442191f, -0.03207173f, -0.02680640f, 
    -0.00231596f, 0.00111028f, 0.03171426f, -0.02706332f, 0.00321034f, -0.01705226f, -0.04349166f, 0.01661761f, 
    -0.01186263f, 0.01125254f, 0.01879361f, 0.00678710f, 0.03461205f, -0.02718945f, -0.04457814f, -0.03843640f, 
    0.02072114f, -0.02621111f, -0.04277172f, -0.03988831f, -0.00448345f, 0.01343967f, -0.02530638f, 0.03571080f, 
    0.01880770f, 0.01947749f, 0.03195786f, 0.00797789f, 0.01648748f, -0.03546042f, 0.00335540f, -0.01342310f, 
    -0.02675591f, 0.03425504f, -0.00757048f, 0.00029570f, 0.00661527f, 0.03129502f, -0.02616923f, 0.02382296f, 
    -0.03210000f, 0.00332631f, -0.02765898f, 0.02326157f, 0.03653137f, -0.02257327f, -0.00470964f, -0.01915812f, 
    -0.02238539f, -0.02134462f, -0.01388010f, -0.03267385f, -0.01220546f, 0.01913927f, 0.02791397f, -0.00015997f, 
    -0.03479164f, 0.00263637f, -0.01664026f, 0.03154440f, -0.00439763f, 0.02183845f, -0.04106017f, -0.00721953f, 
    -0.00103515f, -0.00166542f, 0.01146016f, -0.02504587f, 0.02340239f, -0.01168263f, -0.01895615f, -0.03060068f, 
    -0.03691213f, -0.03505579f, -0.02049591f, -0.01473151f, 0.00721279f, -0.04690311f, 0.01094280f, 0.00343105f, 
    -0.00226559f, 0.00615936f, 0.01895339f, -0.03528957f, 0.02035609f, -0.01823948f, -0.03435469f, -0.02661632f, 
    -0.00781838f, -0.01604593f, -0.02708239f, -0.00792850f, 0.01485482f, 0.03020033f, 0.02389395f, 0.00052040f, 
    -0.01210069f, 0.01909728f, -0.04391566f, -0.02142591f, 0.03762034f, -0.00441412f, -0.02466807f, 0.00537955f, 
    -0.03113468f, -0.04286231f, -0.00484322f, -0.03858243f, 0.00084131f, 0.02414009f, -0.04483733f, -0.02125909f, 
    -0.02304266f, -0.04441126f, -0.00933520f, -0.01662339f, 0.00305635f, -0.02320544f, -0.03278988f, 0.00409790f, 
    -0.03905673f, 0.01319892f, -0.00828568f, -0.03718839f, 0.02249485f, 0.01765734f, 0.01344411f, -0.02989095f, 
    -0.01061679f, -0.03398440f, -0.03700463f, -0.03599815f, 0.00983570f, 0.01094995f, -0.01242412f, -0.02535331f, 
    0.01042240f, -0.01192772f, -0.02609268f, -0.01709438f, 0.02468570f, 0.03281270f, -0.01284251f, 0.01587753f, 
    -0.04344631f, -0.02368778f, -0.03731628f, -0.03299495f, 0.03139417f, 0.02662350f, -0.02826141f, -0.03206540f, 
    0.03050443f, 0.02282834f, 0.03664591f, -0.01437219f, -0.02894429f, 0.02256281f, -0.04201498f, -0.04261314f, 
    -0.04067674f, 0.00476337f, -0.01955069f, 0.01967831f, -0.03140929f, 0.01650061f, 0.00173784f, -0.04495234f, 
    -0.01475716f, -0.01564650f, 0.00131026f, -0.00746171f, -0.02267484f, -0.02864100f, 0.00650270f, -0.04117619f, 
    -0.03399720f, -0.04087674f, -0.03173405f, 0.02506028f, -0.03191888f, -0.02334692f, -0.00877377f, -0.03783882f, 
    -0.01974968f, -0.01040096f, -0.02777873f, 0.00780134f, 0.00103244f, 0.02044945f, -0.02572054f, 0.02425625f, 
    0.02161268f, -0.00585479f, -0.03287582f, 0.02416159f, -0.01339285f, -0.04526697f, -0.02349782f, -0.01467239f, 
    0.00234354f, -0.00196664f, -0.03491746f, 0.01996562f, 0.02263463f, -0.00885924f, -0.03015264f, -0.00381853f, 
    0.02103051f, 0.00403994f, 0.02013611f, 0.01114180f, -0.03462382f, -0.01536154f, 0.00792392f, -0.02012812f, 
    -0.01967569f, -0.02373719f, 0.00715974f, 0.01896646f, -0.00709193f, -0.01272237f, 0.01972590f, -0.00778836f, 
    -0.01614060f, -0.01749910f, 0.01403511f, 0.00788911f, 0.02902151f, -0.03083176f, -0.02131314f, 0.02754771f, 
    -0.03271003f, -0.00447575f, -0.03404867f, 0.02540422f, -0.03415337f, -0.02515980f, -0.02669880f, -0.03082854f, 
    0.00065506f, 0.01733014f, -0.03147109f, -0.01910569f, 0.01011857f, -0.01610205f, 0.03342782f, -0.02638592f, 
    0.00900463f, 0.01495639f, 0.02597293f, 0.00523339f, 0.01361325f, -0.03034111f, -0.00490584f, -0.01229525f, 
    -0.00650843f, -0.03698391f, -0.04383791f, 0.02639046f, 0.01109405f, 0.01515840f, -0.01129018f, -0.03482212f, 
    -0.01378547f, -0.01716551f, 0.03124183f, -0.02455724f, -0.00910415f, -0.00371844f, 0.02247644f, 0.01919666f, 
    -0.02247479f, -0.01101905f, 0.00492093f, -0.03452807f, -0.02523374f, -0.03555816f, 0.01292227f, -0.03829874f, 
    -0.04389780f, -0.04179516f, -0.03960329f, -0.00609830f, -0.00976999f, 0.00346485f, 0.00813073f, 0.00187272f, 
    0.00903205f, -0.00887494f, 0.02121548f, 0.00063384f, 0.01575790f, -0.02427937f, 0.02839418f, -0.03104433f, 
    -0.03792344f, -0.02221695f, 0.00426763f, 0.01877818f, 0.00879890f, -0.04244850f, -0.04221247f, -0.03302338f, 
    -0.02983662f, 0.03170671f, -0.04448246f, -0.00111547f, -0.00703318f, 0.00804578f, 0.01366397f, -0.02257884f, 
    -0.04456005f, 0.01733701f, 0.02648121f, 0.00474618f, 0.02961519f, -0.02758835f, -0.03273707f, 0.01271430f, 
    -0.03275425f, 0.00640027f, 0.01518177f, -0.01864154f, -0.01829778f, -0.01982472f, -0.03988561f, 0.02323437f, 
    -0.02235702f, -0.01238952f, -0.03284683f, -0.01499014f, -0.04324315f, -0.03156989f, -0.01111885f, -0.02117861f, 
    -0.01158962f, -0.00472857f, -0.01232717f, -0.03547468f, -0.01142254f, -0.04121252f, -0.04242958f, -0.02022070f, 
    -0.01151046f, 0.02903629f, 0.02612779f, 0.00555221f, 0.03173680f, -0.01560591f, 0.01318027f, -0.04204370f, 
    -0.03214808f, -0.03648089f, 0.00850973f, -0.03957096f, 0.02839072f, 0.01983128f, -0.01329620f, -0.04159335f, 
    0.03143794f, 0.03066301f, 0.00125779f, 0.02473562f, 0.00092926f, -0.04547064f, 0.00601884f, -0.03530248f, 
    -0.03266171f, -0.04542609f, -0.01817242f, -0.02041376f, 0.01087764f, -0.01663973f, -0.02499802f, -0.03201430f, 
    -0.04485001f, 0.03349739f, 0.03225287f, 0.01229481f, -0.02123984f, 0.02562930f, -0.03491962f, -0.03977964f, 
    -0.01504536f, -0.00035092f, 0.00190423f, 0.03056394f, -0.01964391f, -0.01497148f, -0.01446468f, 0.00268832f, 
    -0.01715630f, 0.03223934f, -0.01536928f, 0.00467974f, -0.01455765f, 0.03048903f, -0.00007503f, -0.01575622f, 
    -0.02172760f, 0.00001354f, -0.03376900f, 0.02658442f, -0.02216510f, 0.02397482f, -0.01870027f, -0.00932320f, 
    -0.01165615f, -0.00578567f, -0.02669407f, -0.03913814f, 0.00006631f, 0.00787531f, -0.04509787f, -0.00695252f, 
    -0.03542118f, 0.00683490f, -0.00981283f, -0.00041904f, -0.00876049f, 0.00253350f, 0.03122995f, -0.00009101f, 
    0.00838886f, 0.00873343f, -0.03146992f, 0.02882706f, -0.01321176f, 0.01050691f, -0.04093438f, -0.03300178f, 
    -0.02618299f, 0.00364955f, -0.03613225f, 0.00887635f, 0.03306901f, 0.00999796f, -0.03769356f, -0.02510868f, 
    0.02634461f, 0.03148519f, -0.00095403f, -0.03782225f, -0.03870424f, 0.02703406f, 0.00732041f, -0.04419411f, 
    -0.02172370f, -0.03721436f, -0.00394080f, -0.02857034f, 0.00600422f, 0.02203709f, -0.02435464f, 0.00175941f, 
    -0.04267325f, 0.01455409f, -0.01950012f, -0.00495205f, -0.00318981f, -0.00816408f, -0.01048494f, -0.03470272f, 
    0.01980491f, 0.00688761f, -0.02446854f, 0.02420736f, 0.01493651f, -0.02775780f, -0.00860774f, -0.00384835f, 
    0.02724827f, 0.03123161f, -0.02068641f, -0.00663138f, 0.01332116f, 0.02836278f, 0.01145703f, -0.00404331f, 
    0.02449388f, 0.01258964f, -0.00980810f, -0.04249883f, 0.02645325f, -0.02617216f, 0.01318857f, -0.01124631f, 
    -0.02472488f, -0.02404772f, -0.03930317f, -0.00226013f, 0.01631481f, 0.02255299f, -0.03805294f, -0.00463059f, 
    0.02480656f, -0.00026127f, -0.00578741f, -0.00244055f, -0.02340884f, 0.00748238f, 0.02477925f, 0.00355186f, 
    -0.00138317f, 0.00215493f, -0.00448801f, -0.03239715f, 0.01521059f, -0.02736450f, -0.00200876f, 0.01714188f, 
    -0.02623196f, -0.00198991f, 0.02378483f, 0.01768155f, -0.01847994f, -0.03538538f, -0.04306745f, -0.03176985f, 
    -0.00728997f, 0.03263588f, -0.00321343f, 0.03182655f, -0.03664573f, -0.04032870f, -0.04190674f, 0.02865474f, 
    -0.02941260f, -0.01122839f, 0.01311708f, 0.01725755f, -0.00554756f, 0.01632618f, 0.00942099f, 0.03286419f, 
    -0.02691454f, -0.01622718f, 0.00504106f, 0.00330967f, 0.02322341f, -0.01377988f, 0.02974088f, -0.01543583f, 
    -0.03612187f, -0.01737923f, 0.01434618f, -0.03253343f, 0.00652775f, -0.01639953f, 0.01210970f, -0.00862752f, 
    0.02914399f, -0.04225257f, -0.00948878f, -0.01713105f, -0.02873644f, -0.01585273f, -0.04401580f, 0.00515513f, 
    -0.04365070f, 0.00714581f, -0.03052543f, -0.00096417f, 0.02261682f, 0.01149989f, 0.02457017f, -0.00874828f, 
    0.02212301f, 0.00980624f, 0.00206753f, 0.01144710f, -0.00099976f, 0.03159496f, 0.00651444f, -0.01867372f, 
    -0.03947848f, -0.01557034f, -0.00089913f, 0.00497643f, -0.00813221f, -0.03657904f, -0.00778643f, -0.00260301f, 
    0.00656522f, 0.02587238f, 0.00534373f, -0.00275795f, -0.00619208f, 0.03124465f, 0.02649904f, 0.02373557f, 
    -0.03155557f, -0.03707695f, 0.01797190f, -0.01733963f, 0.01977283f, -0.01033870f, 0.03296690f, 0.00916300f, 
    0.00378544f, -0.02323819f, 0.01488783f, -0.01232698f, -0.01999005f, 0.02670798f, 0.00475220f, 0.01991686f, 
    -0.04187516f, 0.01902690f, -0.00373721f, -0.03990527f, -0.03137011f, -0.01558016f, -0.03415612f, -0.02117059f, 
    -0.00008309f, -0.01822163f, -0.03879660f, -0.02592244f, 0.00276108f, -0.03376408f, -0.02629598f, -0.01922749f, 
    0.02330373f, -0.00896110f, 0.00606560f, -0.03131316f, 0.01861026f, -0.02644623f, 0.02168515f, -0.01234044f, 
    -0.03251545f, -0.01024391f, -0.00570962f, -0.03556435f, -0.04097871f, 0.00363490f, -0.03337510f, 0.00649969f, 
    -0.00341279f, 0.01619292f, -0.03821080f, 0.03098196f, -0.03422231f, 0.03286041f, 0.02449368f, -0.02192513f, 
    0.02670790f, -0.02902411f, -0.00625252f, 0.03320419f, -0.03490122f, 0.01595572f, -0.01463826f, 0.01013411f, 
    0.00903184f, -0.04167303f, -0.03824310f, -0.02798439f, 0.02058728f, -0.03237116f, 0.01058502f, -0.02020708f, 
    -0.02150995f, -0.02236114f, -0.03546705f, -0.04465875f, -0.00226629f, 0.00455131f, 0.02308207f, 0.02701669f, 
    -0.01468842f, -0.02736166f, -0.01186712f, -0.02370694f, 0.02253554f, -0.03887782f, -0.00859351f, 0.01965276f, 
    0.03306976f, 0.00483739f, -0.00467158f, -0.04375669f, 0.02229987f, -0.02807055f, 0.03084653f, 0.01993483f, 
    0.00594380f, -0.02122136f, -0.01989597f, 0.00269617f, -0.04353616f, 0.02591063f, 0.02065751f, -0.03540260f, 
    0.02084653f, -0.01752806f, 0.01168122f, -0.00016590f, -0.00088574f, 0.00941863f, 0.03326979f, 0.03185798f, 
    -0.04077133f, -0.00570934f, -0.00312574f, 0.02264293f, -0.01186284f, -0.04162828f, -0.01209638f, -0.01716131f, 
    -0.02463029f, 0.00588892f, -0.03792513f, -0.00412028f, 0.00406751f, 0.01768271f, 0.01331098f, -0.03961625f, 
    0.00269181f, -0.04341929f, 0.01379773f, 0.00676008f, -0.00589464f, -0.03673036f, 0.00491625f, 0.01313606f, 
    -0.00786042f, 0.00422456f, 0.02850717f, -0.04326665f, -0.03653991f, -0.01608937f, -0.00941702f, -0.00337633f, 
    -0.02992345f, -0.00981140f, 0.03183791f, -0.01903215f, -0.02757619f, 0.03091086f, -0.04305591f, 0.01870755f, 
    0.02314280f, -0.03498700f, -0.02069718f, -0.00524119f, -0.00577934f, -0.02465932f, 0.01708742f, 0.03813181f, 
    0.03487601f, -0.03957279f, 0.02365483f, -0.02288852f, -0.02100193f, -0.00414695f, 0.00229404f, 0.00087626f, 
    -0.04218271f, 0.03735817f, 0.02941537f, -0.01704456f, 0.00425114f, -0.02586268f, -0.00362405f, 0.02059207f, 
    -0.02514659f, 0.01386598f, 0.02430771f, 0.03485027f, 0.00142293f, -0.03963437f, 0.03538235f, 0.02836343f, 
    -0.03106663f, -0.00360849f, -0.03193686f, 0.03024618f, -0.02523939f, 0.02707945f, -0.03314095f, 0.03236277f, 
    -0.03150618f, -0.02744005f, 0.01705944f, 0.00740566f, 0.00385278f, 0.02248257f, 0.03061689f, 0.03507992f, 
    0.02702884f, -0.00840799f, -0.02560014f, 0.01748598f, 0.01455294f, 0.00480223f, -0.01923415f, 0.01067003f, 
    0.02318658f, -0.01393799f, 0.00388617f, -0.03644547f, 0.03324735f, 0.02687480f, -0.04151569f, -0.03804442f, 
    -0.03589465f, -0.02759287f, 0.01212461f, -0.00184946f, 0.01694387f, -0.03857781f, -0.02335559f, 0.00574637f, 
    -0.01069496f, 0.01632041f, -0.00538785f, -0.02832673f, -0.00806514f, 0.02574568f, 0.00362513f, 0.02664948f, 
    0.00490900f, -0.02042784f, -0.01767367f, -0.03679277f, 0.00481664f, 0.01014856f, -0.03821633f, -0.03097501f, 
    -0.03279508f, -0.01009358f, 0.02708286f, 0.00787025f, -0.04133713f, -0.03340877f, 0.00778402f, -0.03314432f, 
    -0.01781062f, -0.01350653f, 0.01661227f, 0.00778871f, -0.01188715f, -0.02267115f, -0.00194590f, 0.01643736f, 
    -0.03863601f, -0.00223665f, 0.02581175f, 0.00921086f, -0.01044037f, -0.00528058f, -0.03584567f, 0.01904284f, 
    0.01258695f, -0.02120620f, 0.02673567f, 0.02766473f, -0.00455764f, -0.01122716f, 0.01711996f, 0.01786390f, 
    0.02327508f, 0.04274096f, 0.00621110f, 0.00043937f, -0.02747024f, 0.00433501f, -0.01545272f, -0.02899548f, 
    0.02899116f, 0.01422579f, 0.01784892f, -0.04037759f, 0.02525589f, -0.02605640f, -0.00646436f, 0.01762968f, 
    0.02746721f, 0.02133891f, -0.00610103f, 0.03690592f, 0.01689645f, 0.02719523f, 0.03351592f, 0.03162238f, 
    0.00594695f, -0.01862482f, -0.02405794f, -0.04263417f, -0.02627402f, 0.03334818f, -0.00425825f, -0.02860096f, 
    -0.02468325f, 0.01074309f, -0.02051749f, -0.00094464f, -0.00007900f, -0.03045499f, 0.03334248f, -0.04081716f, 
    -0.01189935f, -0.02412008f, -0.02885866f, 0.03338882f, 0.00295823f, 0.03358839f, -0.00218232f, -0.01277542f, 
    -0.01492385f, 0.00643674f, 0.01149377f, 0.03077915f, -0.02559765f, -0.01422735f, -0.03491724f, 0.01821413f, 
    -0.01018873f, -0.01035127f, 0.02236793f, -0.00694359f, 0.02733664f, -0.03057209f, 0.00791623f, -0.00763111f, 
    -0.03799194f, -0.02566221f, 0.01713284f, -0.03578592f, 0.01910283f, -0.04026374f, -0.03443971f, 0.01001047f, 
    -0.02722937f, -0.03696099f, 0.03493675f, -0.03432040f, 0.03795660f, -0.01530577f, 0.03365769f, 0.01767766f, 
    -0.00390874f, -0.03407053f, -0.04269620f, -0.03250064f, 0.02447473f, -0.02735367f, -0.03601139f, 0.01099666f, 
    0.00515506f, -0.01636065f, -0.00611928f, -0.03089269f, 0.00596471f, -0.03814442f, -0.01813664f, 0.01995406f, 
    -0.02839626f, -0.01311016f, -0.01365181f, 0.01389373f, -0.00479575f, 0.03809934f, -0.01799009f, -0.01184623f, 
    -0.00152396f, 0.00518191f, 0.02469836f, -0.02802861f, -0.02773125f, -0.04126266f, 0.01749714f, -0.02628699f, 
    -0.03955508f, -0.03125369f, -0.00957223f, 0.02497984f, 0.03148714f, -0.04197702f, -0.00538211f, 0.02635488f, 
    -0.02753827f, -0.03556393f, 0.01762090f, 0.03567261f, -0.03478901f, -0.02353492f, -0.03344108f, -0.01713326f, 
    -0.01833577f, 0.03191460f, 0.03339494f, 0.03322565f, -0.02276546f, -0.00160122f, -0.02352818f, -0.00271105f, 
    0.01787955f, 0.01236545f, 0.01973092f, 0.02766240f, -0.00961810f, -0.00178200f, 0.01234278f, -0.02747950f, 
    -0.02661437f, 0.03820285f, -0.00926532f, -0.03547245f, -0.03633378f, 0.00026916f, -0.03622765f, -0.01509426f, 
    0.02253633f, -0.01804624f, 0.00066321f, 0.02369538f, 0.00955787f, 0.00860339f, 0.00362622f, 0.03287286f, 
    -0.00897028f, 0.02519315f, 0.02577305f, 0.03121198f, 0.00732522f, 0.02998423f, -0.00507403f, -0.04102698f, 
    -0.02479968f, 0.03069304f, -0.01726118f, 0.00276139f, 0.02531895f, -0.02195097f, -0.01100458f, 0.01579035f, 
    0.02338343f, 0.02097452f, -0.03318777f, -0.03561477f, 0.00570002f, 0.00892811f, -0.03461945f, -0.00846984f, 
    0.02418160f, -0.00013784f, -0.03753927f, -0.03506600f, -0.00325778f, 0.00023764f, 0.03181059f, -0.00921406f, 
    -0.01677721f, 0.02755218f, -0.01334501f, 0.01863843f, -0.00673416f, -0.00299394f, -0.03828461f, -0.00394453f, 
    0.00851280f, -0.03926473f, -0.04319217f, 0.01782417f, 0.01316893f, -0.03148173f, 0.01840343f, 0.03260557f, 
    0.01225124f, -0.00931723f, 0.01263547f, -0.03450538f, -0.01961431f, 0.03228263f, -0.03649388f, -0.02057292f, 
    -0.01867781f, -0.02823919f, 0.02385776f, 0.00666973f, 0.03668531f, 0.01652742f, 0.03310585f, 0.01685735f, 
    -0.00757641f, -0.02930398f, 0.01079124f, 0.00459953f, -0.00037694f, -0.02950334f, 0.03017811f, -0.00589104f, 
    -0.03332436f, -0.01078512f, -0.04146422f, -0.03042811f, 0.00316939f, 0.02343726f, 0.01094302f, -0.01476267f, 
    -0.02491955f, -0.01799462f, -0.00833966f, -0.01689959f, 0.02847581f, 0.01613570f, -0.00754606f, -0.02830071f, 
    0.00881860f, 0.03518623f, 0.02229512f, 0.03052987f, 0.02680266f, -0.02277630f, 0.00251241f, 0.03854790f, 
    -0.01765404f, -0.01557601f, 0.01807138f, -0.01461086f, -0.01720618f, -0.00430042f, 0.02451492f, 0.00689924f, 
    0.02757114f, -0.00452368f, 0.00289232f, 0.00951301f, -0.00822672f, -0.00225882f, -0.03628399f, 0.02944914f, 
    -0.02123807f, -0.03654270f, -0.01766373f, 0.02241441f, -0.00160328f, -0.00791997f, -0.01487233f, 0.03194463f, 
    -0.01280078f, -0.01179645f, -0.03862233f, -0.00761853f, -0.02715486f, -0.00519256f, 0.01738311f, 0.01989757f, 
    0.02259698f, -0.03336912f, -0.02019172f, -0.02768812f, -0.03017916f, -0.03100831f, 0.01005460f, 0.01578961f, 
    0.02203548f, 0.03494716f, 0.03829137f, -0.01407281f, 0.00404913f, -0.04075364f, 0.01833135f, -0.02154977f, 
    0.02394913f, -0.03882345f, 0.01304822f, -0.02132347f, 0.01324546f, -0.04044034f, 0.00825132f, 0.02903820f, 
    -0.03349661f, 0.01466062f, -0.03162729f, -0.02907750f, 0.01921110f, -0.00823252f, -0.00753485f, -0.02753459f, 
    -0.00312419f, 0.00494164f, -0.01367264f, 0.03343439f, -0.01901839f, -0.00085558f, -0.03423243f, -0.00649873f, 
    -0.03543874f, 0.03624284f, 0.00505089f, 0.01427098f, 0.01059966f, 0.02190753f, 0.01858562f, 0.02902352f, 
    -0.00678611f, 0.00216211f, 0.01554711f, 0.00766087f, -0.03185980f, -0.03844309f, 0.03581160f, 0.02709036f, 
    -0.02763288f, -0.01210058f, 0.03030396f, -0.01656693f, 0.01159031f, 0.00148012f, 0.02009962f, -0.00838212f, 
    0.03647784f, 0.02890443f, -0.00973854f, -0.01462758f, -0.04074288f, 0.02607731f, 0.01290321f, -0.00401103f, 
    -0.00440526f, -0.02475756f, 0.00688882f, 0.02393333f, 0.02800657f, -0.02671331f, -0.02219406f, 0.01280480f, 
    0.02238971f, 0.03371601f, -0.04275218f, -0.00636862f, 0.01824826f, -0.01809046f, -0.00167661f, -0.00942074f, 
    0.02073975f, 0.00700084f, -0.03094007f, -0.03952395f, -0.00842914f, 0.00894384f, -0.02838456f, -0.01093678f, 
    0.00629318f, -0.01032801f, 0.01583867f, -0.03104040f, -0.04116099f, -0.00416763f, -0.03750804f, -0.03248500f, 
    -0.02568963f, 0.03098284f, 0.03916851f, 0.02080034f, 0.01573673f, -0.01955376f, 0.03255894f, -0.01037920f, 
    0.03458066f, 0.01671482f, -0.03720331f, 0.00940920f, -0.00268601f, -0.03399305f, -0.03675803f, -0.00891639f, 
    -0.03019748f, 0.01579046f, -0.01848375f, -0.00605026f, -0.01077312f, -0.00539456f, -0.00703106f, -0.03316619f, 
    0.01724132f, -0.03894758f, -0.01091795f, 0.02793551f, -0.01743366f, 0.00927337f, -0.00371510f, 0.01326087f, 
    0.03140197f, -0.03573279f, -0.02329105f, 0.02965268f, -0.01586808f, -0.00735151f, 0.00481531f, 0.00570778f, 
    -0.01105450f, 0.03699129f, 0.01320902f, -0.02585330f, 0.00938941f, 0.03389370f, 0.00572237f, -0.01713954f, 
    -0.03812406f, 0.02242702f, -0.02659554f, 0.02530427f, 0.03356496f, -0.00248325f, 0.02242246f, 0.01311211f, 
    -0.03139774f, -0.00084637f, -0.02033488f, 0.02838040f, -0.00249280f, 0.01286684f, -0.04206118f, -0.00477140f, 
    -0.00282400f, 0.00856493f, -0.00262265f, -0.03493754f, 0.00477095f, -0.03405996f, -0.01012578f, -0.03155171f, 
    0.01468939f, 0.00944826f, -0.00841732f, -0.02166717f, 0.02418213f, 0.00173582f, -0.01586743f, 0.02641709f, 
    0.00687502f, 0.01125061f, 0.01688581f, -0.00435410f, -0.00841243f, 0.01520702f, -0.03891918f, -0.00041644f, 
    0.02136645f, -0.00652618f, 0.00588355f, 0.02231369f, -0.03761750f, -0.03832668f, -0.02506077f, 0.03110196f, 
    -0.03170555f, 0.00273689f, -0.01765312f, 0.03212402f, -0.01030442f, 0.02040647f, 0.02871884f, -0.01341042f, 
    -0.00957556f, 0.00401166f, 0.01131922f, -0.00560633f, -0.01463210f, -0.01090803f, -0.02818272f, -0.02909480f, 
    0.00211536f, -0.00840562f, 0.01566732f, 0.02019375f, -0.04133314f, -0.02747523f, -0.00527676f, -0.02829609f, 
    0.00233407f, 0.02309980f, 0.03250577f, 0.00430785f, -0.01457343f, 0.02837722f, 0.01146370f, -0.00421380f, 
    0.00946198f, -0.04462444f, -0.01764547f, -0.01685111f, 0.00237832f, -0.04383666f, -0.00876745f, -0.02506356f, 
    -0.03338001f, 0.01074114f, 0.01587453f, 0.00109594f, -0.03928278f, -0.02494887f, -0.00849363f, -0.00360928f, 
    0.01113458f, -0.02817698f, -0.01528298f, -0.04201664f, 0.00964604f, -0.01187773f, -0.00940504f, -0.01644120f, 
    0.02544593f, -0.02323571f, 0.02949326f, -0.00725716f, 0.00787007f, 0.01650994f, 0.00011604f, -0.00803995f, 
    0.00759609f, -0.00226822f, 0.01280292f, -0.01223086f, -0.01007241f, -0.02818799f, 0.00897561f, 0.01698812f, 
    -0.02217699f, -0.02373687f, -0.02775484f, 0.01942218f, 0.00435898f, -0.03169435f, -0.03612178f, 0.00246925f, 
    0.02896142f, 0.01069961f, -0.00183428f, 0.02200396f, -0.00089415f, -0.01932705f, 0.00649633f, 0.02115230f, 
    0.02353094f, -0.03719887f, -0.00935525f, -0.01064299f, 0.02378943f, 0.02139409f, 0.00592477f, 0.03131093f, 
    0.00988464f, -0.00396098f, 0.02103450f, -0.00336584f, 0.00150571f, 0.00983014f, -0.00107162f, 0.02440178f, 
    0.02824263f, -0.01187676f, 0.02921423f, -0.00160826f, -0.00268006f, -0.03418975f, 0.01732980f, -0.04073497f, 
    0.02259264f, 0.01958746f, -0.01793654f, -0.04180888f, -0.04195101f, 0.00931982f, 0.00823906f, -0.02298342f, 
    -0.03358257f, -0.02322268f, -0.01027049f, -0.04210059f, 0.01028066f, -0.02940775f, 0.02445704f, 0.01057318f, 
    -0.00263403f, 0.01983090f, -0.00472607f, -0.01715967f, 0.02164437f, -0.00748584f, 0.02115645f, -0.00103079f, 
    0.00176904f, -0.02303352f, 0.00593719f, -0.04463384f, -0.03991602f, 0.01570393f, -0.02456453f, -0.01326759f, 
    -0.02867308f, -0.00749109f, -0.03531705f, -0.01013219f, -0.03172584f, -0.00571368f, 0.01236171f, -0.02703761f, 
    -0.01204156f, -0.01150357f, -0.04244364f, -0.01421775f, 0.00070350f, -0.04449770f, -0.02123610f, -0.03887118f, 
    -0.02615564f, 0.00455300f, -0.00111027f, 0.01037849f, 0.02733860f, 0.01518482f, -0.01079877f, -0.00578889f, 
    -0.01881081f, -0.01480382f, -0.00554510f, -0.00391662f, -0.03438609f, -0.02114207f, -0.00979376f, 0.01772031f, 
    0.02655814f, -0.01597918f, 0.01719984f, -0.01851290f, -0.01895523f, -0.02057831f, -0.02281420f, 0.00876412f, 
    -0.02246539f, -0.02795760f, 0.02783474f, -0.03401293f, -0.02220801f, -0.02394906f, 0.00256219f, -0.00439703f, 
    -0.03570252f, -0.03401944f, 0.02135432f, 0.01300803f, -0.01915096f, 0.01214481f, -0.03482874f, 0.01374412f, 
    0.01485391f, 0.00257233f, -0.02751051f, 0.00187662f, -0.03534967f, -0.03081868f, -0.03211718f, -0.02798454f, 
    0.02008851f, -0.02806619f, -0.01370586f, 0.00450442f, -0.01255581f, -0.04371162f, 0.00373606f, 0.00249357f, 
    0.00065738f, -0.00330449f, 0.01988755f, 0.01672183f, 0.02788929f, 0.01941061f, -0.01229806f, -0.01525576f, 
    0.00928307f, 0.01999187f, 0.02493182f, -0.03551729f, 0.01174889f, 0.02850674f, -0.02674354f, -0.04301451f, 
    0.02715644f, -0.02077136f, 0.01371303f, 0.00151449f, -0.03702071f, 0.01548591f, 0.02644170f, -0.03970096f, 
    -0.03622943f, -0.00290305f, 0.01159345f, 0.00632251f, 0.01436565f, 0.01691156f, 0.00828038f, -0.04182019f, 
    0.02718941f, 0.00176099f, 0.01437384f, -0.02359938f, -0.03287088f, -0.01574594f, 0.00238137f, 0.00787410f, 
    -0.00928977f, 0.01097282f, -0.03176681f, -0.02412734f, -0.02201444f, -0.00856523f, 0.01549967f, -0.00710693f, 
    -0.02082357f, 0.00033738f, -0.03205087f, -0.02705691f, 0.01526412f, -0.02008506f, 0.03097858f, -0.02711961f, 
    -0.03110125f, -0.00548901f, 0.02583980f, 0.02265876f, -0.01062754f, -0.04169403f, 0.01490699f, 0.02649992f, 
    0.02154570f, 0.02122797f, 0.00580517f, 0.01048106f, -0.02960616f, -0.04262167f, 0.03028269f, -0.03618862f, 
    -0.03559969f, 0.03083976f, 0.00777879f, 0.01197342f, -0.00830877f, -0.02061097f, 0.02929273f, -0.03212022f, 
    -0.01522932f, -0.02328455f, 0.00621855f, -0.00144508f, -0.02518021f, -0.01364860f, -0.02040010f, -0.02650037f, 
    -0.04010675f, 0.02051437f, -0.02837657f, 0.00204990f, 0.02953346f, 0.00866364f, -0.01226945f, 0.01177083f, 
    -0.02614605f, -0.03809794f, 0.00524156f, -0.04129992f, -0.04083655f, 0.00495552f, -0.03219448f, 0.00761746f, 
    0.02897221f, 0.01362917f, 0.00232995f, -0.03738475f, -0.00410582f, -0.00273266f, -0.02676458f, 0.00495693f, 
    0.01531173f, -0.03154795f, 0.02791306f, 0.00294662f, -0.00321696f, -0.00120605f, 0.01133948f, -0.00894825f, 
    0.03110873f, 0.00803127f, -0.02387875f, 0.00023958f, 0.00883613f, 0.01345408f, 0.02029246f, -0.03496867f, 
    -0.03036857f, -0.00419542f, -0.01644634f, 0.01631356f, -0.01757037f, 0.00159926f, 0.02789483f, -0.02702008f, 
    -0.01846833f, -0.03791714f, -0.03848226f, -0.01774665f, -0.00462599f, -0.03220461f, -0.00987280f, 0.03084959f, 
    0.02908760f, -0.00242147f, 0.01532823f, -0.04473260f, 0.01190840f, 0.03028688f, 0.01897595f, 0.00279966f, 
    -0.02544831f, -0.00539135f, -0.03709463f, -0.03286686f, -0.02640645f, 0.00009530f, -0.02966789f, 0.02468594f, 
    0.02050667f, 0.00893689f, -0.01926080f, 0.00388129f, -0.02166277f, 0.02551344f, 0.00771774f, 0.03078452f, 
    0.00477862f, -0.01069089f, -0.03336816f, -0.00689899f, 0.02925093f, -0.00901078f, 0.00302520f, -0.00686105f, 
    -0.01717077f, 0.02552650f, 0.02735172f, -0.01814838f, -0.03063581f, -0.02945912f, -0.04002265f, -0.02733703f, 
    0.02222756f, 0.01728429f, -0.01763966f, -0.04035279f, 0.02695929f, -0.03039209f, 0.02394019f, -0.03075006f, 
    0.01631766f, -0.02877569f, -0.03674337f, 0.02268121f, -0.04500181f, -0.04216350f, 0.00250065f, -0.02524628f, 
    -0.01568519f, 0.01335951f, 0.03071736f, 0.03269124f, -0.01485495f, -0.02024021f, 0.02665530f, -0.04353423f, 
    0.01317528f, -0.01489554f, 0.02876418f, 0.01082727f, 0.02230951f, 0.01000075f, -0.02424522f, 0.02577864f, 
    0.01523935f, -0.03512160f, -0.03306130f, 0.02303253f, 0.00630496f, -0.00561025f, -0.00355910f, 0.02173256f, 
    -0.00909750f, -0.00523036f, -0.04097024f, 0.03136786f, 0.00359993f, -0.03190642f, 0.02844371f, 0.02290548f, 
    -0.03808931f, -0.01002180f, -0.04103959f, 0.00393967f, 0.02485923f, 0.03075681f, 0.02986060f, -0.01355074f, 
    -0.00989654f, -0.03915215f, -0.02573909f, 0.02071602f, -0.01020251f, 0.02169265f, -0.03174135f, 0.03085963f, 
    0.00506810f, -0.02866539f, -0.03450226f, -0.04543485f, 0.02737820f, 0.03240877f, -0.00301655f, -0.01176522f, 
    -0.00928674f, -0.00630413f, 0.01949513f, -0.03074965f, -0.00399134f, 0.00967297f, -0.00823314f, -0.01910317f, 
    -0.00748102f, -0.02767476f, -0.03539787f, -0.00846060f, 0.02093180f, 0.00426461f, 0.01811454f, 0.02237260f, 
    -0.03170314f, -0.03271871f, 0.02975529f, 0.02011901f, 0.01687589f, -0.01078003f, -0.03277081f, -0.00374760f, 
    0.00654927f, -0.01403982f, 0.00484296f, -0.02760988f, -0.02860950f, -0.04154965f, 0.01608054f, 0.01495590f, 
    -0.01267781f, 0.03252494f, -0.04356050f, 0.00311181f, -0.01285771f, 0.00173659f, 0.01615258f, -0.00615086f, 
    -0.03008298f, 0.01292686f, 0.02893789f, -0.01481669f, -0.01407744f, -0.01728242f, -0.03789634f, 0.00930778f, 
    0.00453339f, 0.00308050f, 0.03067582f, 0.01386421f, 0.01104466f, -0.01824599f, 0.02488843f, -0.01033684f, 
    0.02020257f, 0.01710501f, -0.03379147f, -0.04419439f, 0.02581662f, 0.01216751f, 0.02440295f, 0.01817305f, 
    -0.03656453f, -0.01111180f, -0.01296917f, -0.03993943f, -0.03757070f, 0.02978889f, 0.00417281f, 0.03304015f, 
    -0.01469922f, -0.03522917f, -0.00762119f, -0.03956030f, -0.03442817f, 0.01826055f, -0.00151453f, -0.02525693f, 
    -0.01718027f, -0.01904948f, -0.00828993f, -0.00496999f, -0.02341696f, 0.01017679f, 0.00352125f, 0.01656874f, 
    0.00322511f, 0.02854286f, -0.03235520f, -0.00321813f, -0.02726628f, -0.01248626f, -0.03000483f, 0.00075259f, 
    0.03014806f, -0.03370328f, -0.04175325f, 0.00714090f, -0.02375041f, 0.00196878f, -0.03919381f, -0.02785859f, 
    -0.01544618f, 0.00549259f, 0.00590352f, -0.01440558f, -0.00217842f, -0.01658063f, 0.01292525f, 0.00460692f, 
    -0.02403175f, -0.03758074f, -0.04277405f, -0.00083879f, -0.01949042f, -0.01419846f, -0.03141379f, 0.00859938f, 
    0.00775851f, 0.02320421f, 0.02897239f, 0.02378036f, -0.02544083f, 0.00926399f, -0.04343103f, -0.01514964f, 
    0.00313652f, 0.02585376f, -0.03352632f, -0.02200674f, -0.00505747f, 0.02049058f, 0.00531417f, -0.02687068f, 
    -0.03638472f, -0.00163843f, -0.03828895f, -0.00754064f, -0.00414380f, 0.02150998f, 0.01070479f, 0.01468477f, 
    -0.02095653f, 0.02455355f, -0.01648250f, 0.01990295f, -0.03489960f, 0.00614199f, -0.04514055f, -0.01622506f, 
    -0.00386040f, -0.03294051f, -0.02990123f, -0.03924403f, 0.00290715f, -0.02312483f, -0.03224534f, 0.02379396f, 
    0.03076229f, 0.02426615f, -0.03221750f, -0.00658562f, -0.01459843f, 0.01714715f, 0.02923815f, -0.03160493f, 
    -0.02449020f, -0.03263186f, -0.03995104f, -0.01804699f, -0.03049954f, -0.02925676f, 0.02998839f, 0.02247548f, 
    -0.00586571f, -0.04297441f, -0.04535622f, -0.02256607f, 0.00793813f, -0.00819190f, 0.01940185f, -0.02321568f, 
    0.02295118f, -0.03056827f, 0.01473315f, 0.00845992f, 0.00502839f, 0.01861879f, 0.00803714f, -0.02998589f, 
    -0.02966850f, 0.01529192f, -0.04418368f, -0.03931413f, -0.04162747f, 0.01294982f, -0.01696346f, -0.02991340f, 
    0.03781087f, 0.00308289f, -0.00366204f, 0.01105411f, 0.01220198f, 0.01177688f, -0.01112519f, -0.02340733f, 
    0.00914700f, 0.02673544f, -0.02430095f, -0.03360826f, -0.01718427f, 0.01329019f, -0.03391828f, 0.00569335f, 
    0.00469246f, 0.00278619f, -0.00240432f, -0.02231057f, -0.01648838f, 0.00206029f, 0.01452100f, -0.00885958f, 
    0.00580418f, 0.00768434f, 0.02140180f, 0.03113843f, -0.01400231f, 0.02999153f, -0.02047800f, -0.00233096f, 
    0.02635370f, -0.02066097f, 0.02981377f, 0.01035354f, -0.02998246f, -0.02055327f, 0.03764644f, -0.01292070f, 
    0.00034937f, 0.03445730f, -0.00219451f, -0.00388799f, -0.02106915f, 0.00010660f, 0.00690043f, 0.00409283f, 
    0.02039601f, 0.02999910f, -0.00823090f, 0.01681704f, 0.02320370f, -0.02379611f, -0.01824316f, 0.00612249f, 
    -0.04597394f, -0.03004135f, 0.01589909f, -0.03460900f, -0.02370333f, -0.01972091f, -0.00988579f, -0.02145864f, 
    -0.00713526f, -0.03083780f, -0.02102289f, 0.02647928f, -0.00008536f, 0.01893606f, -0.01318138f, -0.03294584f, 
    0.03594078f, -0.03502931f, -0.03832490f, -0.01773596f, -0.01706832f, 0.02147454f, 0.00470242f, 0.00803589f, 
    0.01046720f, -0.02272206f, 0.03351753f, -0.02388365f, -0.00236714f, -0.00957916f, -0.03463270f, 0.03314207f, 
    -0.01706920f, -0.00166480f, -0.03702562f, -0.00617262f, 0.03118492f, -0.02205640f, 0.02077829f, -0.02628606f, 
    0.03626528f, -0.03672938f, 0.01856352f, 0.00763866f, -0.03598946f, 0.00318473f, 0.00626623f, 0.00045698f, 
    -0.04655483f, -0.01523384f, -0.00017241f, 0.02406081f, -0.00437874f, 0.02297997f, -0.03464509f, 0.00098265f, 
    0.01495722f, -0.01365525f, 0.02384934f, -0.04042430f, 0.01281638f, -0.01227123f, -0.03866902f, 0.02431925f, 
    0.03144682f, 0.01714863f, -0.02445320f, -0.03722847f, -0.01945141f, -0.01311807f, -0.03159326f, -0.02595460f, 
    -0.00988918f, 0.00885545f, 0.01648706f, 0.02761201f, -0.01794856f, 0.00556244f, 0.02719995f, 0.03201807f, 
    0.01494357f, -0.04234399f, -0.02533784f, -0.04158214f, 0.00289106f, -0.02601984f, -0.03767765f, 0.03301596f, 
    -0.01394612f, 0.03877853f, -0.01069787f, -0.04353410f, -0.03147316f, 0.03445761f, 0.00883084f, -0.01932587f, 
    -0.03139125f, -0.03250077f, -0.02536151f, 0.01268627f, -0.01489068f, -0.01244983f, -0.03878328f, -0.03272969f, 
    -0.00749441f, 0.01867128f, -0.00564009f, 0.02527291f, 0.00194452f, 0.03384987f, -0.03141022f, -0.01866549f, 
    -0.00894896f, -0.00257641f, -0.01025753f, 0.01552193f, -0.03114486f, -0.03873918f, 0.02866165f, -0.02072115f, 
    -0.00173960f, -0.00635909f, 0.02810856f, -0.02579770f, -0.04415890f, 0.00185493f, -0.01604688f, 0.03303865f, 
    -0.02138754f, -0.03561358f, -0.01166176f, -0.04272231f, -0.00470045f, 0.01516746f, 0.00540825f, -0.03013746f, 
    -0.03782158f, 0.02402704f, -0.00029519f, -0.01633113f, -0.00666302f, 0.00374014f, 0.01366992f, 0.00485443f, 
    0.02882158f, -0.02879735f, 0.03923214f, -0.02835954f, 0.00135782f, -0.04018052f, -0.03895903f, 0.02580906f, 
    0.01548196f, 0.02524444f, -0.03558521f, -0.00856336f, -0.01212157f, -0.02185643f, -0.02721524f, 0.01561181f, 
    0.02404051f, -0.02426877f, 0.02024567f, -0.01808715f, 0.01280493f, -0.00062401f, 0.01734473f, 0.00909159f, 
    0.02772925f, 0.02944182f, -0.04047978f, -0.02614754f, -0.02475424f, -0.00085829f, -0.03334175f, -0.04230837f, 
    -0.04220466f, -0.03465262f, -0.00583685f, 0.00751219f, 0.03361070f, -0.00138341f, -0.03496864f, -0.01720938f, 
    0.02031977f, -0.03346123f, 0.02334801f, 0.02250449f, 0.00335204f, 0.02598052f, -0.00013131f, 0.02517828f, 
    0.02539065f, -0.00676691f, 0.00086793f, -0.02257415f, -0.02392796f, 0.00687237f, -0.04233307f, -0.04183529f, 
    -0.03827428f, -0.01883024f, -0.01002141f, 0.00961273f, 0.01649795f, -0.00957807f, 0.01494859f, -0.03390475f, 
    -0.01857799f, -0.03358999f, -0.01970779f, -0.04625479f, 0.00259424f, 0.00611422f, 0.01908315f, -0.03834344f, 
    0.01341311f, -0.00518533f, 0.02938199f, -0.03326506f, -0.01922706f, 0.02015046f, 0.00606544f, -0.01089452f, 
    0.04459783f, 0.02409272f, 0.00629789f, -0.00902639f, -0.01604741f, -0.03728620f, -0.03449852f, -0.03088200f, 
    -0.00514570f, 0.01834309f, -0.00848438f, 0.02314594f, -0.00956100f, -0.01583327f, -0.01225464f, 0.02273408f, 
    -0.01426891f, -0.00940967f, -0.03609958f, -0.00855198f, -0.02281990f, -0.00000506f, -0.01540660f, 0.01750938f, 
    0.03134220f, 0.00677035f, 0.01897079f, -0.01547041f, -0.00870841f, -0.03745661f, -0.04220073f, -0.02809868f, 
    0.03143135f, -0.03950305f, -0.00058905f, -0.04189837f, 0.01287286f, 0.01707992f, -0.02061009f, 0.03058139f, 
    0.03846784f, 0.03876329f, -0.00915314f, 0.03752548f, -0.02805449f, -0.01216978f, 0.03141572f, 0.00033310f, 
    0.01069868f, -0.04218303f, 0.02479948f, 0.00792318f, 0.02656502f, -0.00355494f, -0.01538139f, -0.03537787f, 
    -0.03075975f, -0.02875268f, 0.01047375f, -0.02838154f, -0.01316885f, 0.02236245f, 0.03841643f, -0.03065628f, 
    0.04268008f, -0.01154157f, -0.03566672f, -0.01549424f, 0.00638809f, -0.03541175f, 0.01512697f, 0.02799962f, 
    -0.00689987f, 0.02718155f, -0.02125363f, 0.01891949f, -0.03833077f, -0.01986570f, -0.02555108f, 0.01090543f, 
    -0.02709002f, 0.03684230f, 0.00269723f, 0.01512861f, 0.00396571f, 0.03318875f, 0.01486950f, -0.01223390f, 
    0.01005248f, 0.01954814f, -0.00635326f, 0.01226059f, -0.00806336f, -0.01088674f, -0.01618365f, 0.03841209f, 
    -0.02224603f, -0.00221374f, 0.02119691f, -0.01358309f, -0.04092088f, -0.00994570f, -0.03940314f, -0.03015028f, 
    0.00624483f, -0.03848439f, -0.00558921f, 0.01787382f, 0.00205085f, 0.00580545f, -0.03277645f, -0.03358527f, 
    0.01232860f, -0.00153436f, 0.02848237f, -0.01787210f, -0.03684747f, 0.02666840f, 0.03605039f, -0.01362445f, 
    -0.01759629f, 0.01369480f, 0.01003008f, 0.01342655f, 0.00695284f, 0.01833391f, -0.00131558f, -0.01484520f, 
    0.01092346f, -0.02106686f, -0.03025490f, -0.04186723f, -0.01145981f, -0.03589487f, -0.01951500f, -0.03856290f, 
    0.03204306f, -0.00312388f, -0.00811998f, 0.02053161f, -0.02392221f, 0.01310052f, -0.02359633f, 0.01521667f, 
    0.00176329f, 0.03554631f, -0.01656954f, -0.04128258f, 0.02716577f, 0.01846206f, 0.01923753f, -0.02713176f, 
    -0.02394997f, -0.03691306f, -0.00175896f, 0.02681845f, 0.00762016f, -0.03847824f, -0.01115703f, -0.00121375f, 
    -0.02111239f, 0.03486544f, 0.02102786f, 0.00950956f, 0.00861901f, -0.02487387f, 0.04011359f, 0.02829556f, 
    -0.02358327f, 0.00775435f, 0.02852923f, -0.01820537f, -0.01730864f, 0.02482318f, 0.03076414f, 0.00388106f, 
    -0.00017828f, 0.00382725f, 0.00716779f, 0.01061459f, -0.03710078f, -0.01384000f, 0.01393836f, 0.02116131f, 
    -0.02391413f, 0.03651655f, -0.03641522f, 0.01475712f, -0.03116803f, 0.00492228f, -0.00206529f, 0.02947740f, 
    0.00113588f, 0.02648684f, -0.00753492f, 0.01339626f, 0.00638439f, 0.03059776f, -0.03328950f, -0.03352135f, 
    0.02149993f, 0.03125485f, -0.02761175f, -0.03558663f, 0.02041439f, -0.02355043f, -0.00886287f, -0.04402456f, 
    0.02099642f, -0.01847569f, -0.04053013f, 0.01154527f, -0.04082217f, -0.04169279f, -0.03515354f, -0.03372600f, 
    0.01792569f, -0.03373610f, -0.00621076f, -0.01119236f, 0.03229535f, -0.00860929f, 0.03274960f, 0.03505458f, 
    -0.02733527f, -0.03786875f, -0.02817404f, 0.03676524f, 0.03095574f, 0.01615597f, 0.01566573f, -0.00895417f, 
    -0.01457927f, 0.02505390f, -0.01085255f, 0.01016709f, 0.01189955f, -0.03343375f, -0.00120162f, 0.02896857f, 
    0.02269120f, -0.02211402f, 0.01624120f, 0.01260359f, -0.00722819f, 0.03114590f, 0.01588494f, -0.01340329f, 
    0.03031124f, 0.00589932f, -0.01879269f, 0.02699482f, 0.00899463f, 0.02282947f, -0.02618073f, -0.02468066f, 
    -0.04149687f, 0.01289497f, 0.00302873f, -0.02147763f, 0.02674822f, -0.00638897f, 0.00292163f, -0.03250949f, 
    0.03073147f, 0.01530540f, 0.01560148f, -0.01210715f, -0.01422131f, -0.01289621f, -0.02818745f, -0.00901540f, 
    0.03449873f, -0.03018579f, 0.02499383f, 0.01434967f, 0.03569635f, 0.02509915f, 0.01497854f, 0.00174679f, 
    0.03677581f, -0.04298316f, -0.03275210f, -0.01770245f, -0.02467192f, -0.03072714f, 0.01971374f, -0.03007306f, 
    -0.00147963f, -0.02348950f, 0.00904461f, -0.02476561f, -0.01159812f, 0.02366140f, 0.00256892f, -0.01410443f, 
    0.01850018f, 0.00461856f, -0.00515069f, -0.04323793f, -0.02952346f, 0.00800154f, 0.02200750f, -0.04273164f, 
    0.01639536f, 0.02978571f, 0.00981540f, -0.02749566f, 0.02821814f, -0.01396309f, 0.00832477f, -0.02931587f, 
    0.03572193f, 0.00619470f, -0.01002298f, -0.03939105f, -0.02790079f, 0.00376250f, 0.00130199f, -0.02714900f, 
    0.00803198f, 0.02624811f, -0.02889562f, -0.03221852f, 0.01233828f, 0.00308721f, 0.01229521f, -0.02013709f, 
    -0.03007186f, 0.00312647f, -0.02377685f, -0.01446527f, 0.01561725f, -0.02928006f, 0.00334235f, -0.00654184f, 
    -0.04332721f, 0.03164120f, -0.03491687f, 0.01576602f, 0.03610609f, 0.01703368f, -0.01691225f, 0.02047986f, 
    -0.03476926f, -0.00399506f, 0.02513593f, -0.02255345f, 0.02685697f, 0.02006208f, 0.00676946f, 0.02973650f, 
    -0.00494029f, 0.02920743f, -0.02054517f, -0.04193577f, 0.01169904f, 0.01583814f, -0.01609695f, 0.02048281f, 
    -0.03836349f, 0.12060762f, -0.03489200f, 0.38790491f, 0.02939432f, 0.09727059f, -0.07327411f, 0.08742680f, 
    -0.11110356f, 0.06045585f, 0.05485996f, 0.01258694f, -0.04169250f, -0.03683195f, 0.05180648f, -0.01725065f, 
    0.01456372f, 0.02999568f, -0.00743433f, -0.02138761f, 0.09186243f, 0.42097393f, 0.35093194f, 0.17198208f, 
    0.10079647f, -0.19732028f, -0.05818314f, -0.04968148f, 0.14655608f, 0.04900149f, 0.00976770f, 0.00497910f, 
    0.14992702f, -0.06112065f, 0.01366305f, -0.00777758f, 0.02070410f, -0.13904142f, 0.15637767f, 0.01743245f, 
    -0.10227138f, 0.28307265f, -0.06791895f, 0.17302637f, 0.08395328f, 0.00819701f, 0.01164265f, -0.01620372f, 
    -0.05800378f, -0.01330590f, 0.05353763f, -0.01334130f, 0.08656646f, -0.04513984f, -0.01311665f, -0.03091475f, 
    0.00799100f, 0.05930324f, 0.17423466f, -0.11183842f, -0.17719030f, -0.30032066f, -0.27699831f, -0.03486602f, 
    -0.45119834f, 0.01773241f, 0.18946949f, 0.09723419f, -0.06991268f, 0.02861346f, 0.00254118f, 0.06629426f, 
    0.12939902f, 0.16849327f, 0.04159896f, 0.05647697f, 0.09001378f, 0.02288643f, -0.12064306f, 0.06052574f, 
    -0.03121366f, -0.21205443f, -0.14164379f, -0.05560496f, 0.18839930f, 0.05188145f, 0.06382090f, -0.14426591f, 
    0.08725355f, -0.14913808f, 0.05638937f, 0.07228166f, 0.03463649f, 0.21284997f, 0.09322397f, 0.07930546f, 
    0.13778865f, 0.10454846f, -0.17448704f, 0.08884657f, -0.26483279f, -0.00349663f, 0.12456655f, 0.14215992f, 
    0.06102493f, -0.14671732f, -0.17938513f, 0.00334585f, 0.16813819f, 0.02312496f, 0.03107337f, -0.01440178f, 
    0.04208594f, 0.04755595f, 0.04866555f, 0.13985887f, 0.04577066f, -0.12069160f, -0.10101000f, 0.04322650f, 
    -0.15965997f, 0.13741563f, 0.15006414f, 0.27857268f, -0.05640304f, -0.21423954f, -0.12249907f, 0.18058653f, 
    0.08957099f, 0.10210529f, 0.02540647f, 0.16279106f, -0.08751673f, 0.02566041f, 0.14693783f, 0.16105677f, 
    0.05181713f, -0.21588588f, -0.01432961f, 0.04174133f, 0.11352883f, 0.18451276f, 0.09355333f, 0.00341705f, 
    0.16459103f, 0.03596533f, 0.06562810f, -0.03565445f, -0.05773693f, 0.02605448f, 0.08317824f, 0.11576506f, 
    -0.01746927f, -0.02980490f, 0.01515100f, -0.05096233f, -0.09851093f, 0.00738560f, -0.17941709f, -0.04704239f, 
    -0.13669877f, -0.13102573f, -0.17716151f, -0.17515382f, -0.29296392f, 0.07261448f, 0.07074796f, 0.05722072f, 
    -0.05450737f, -0.01656013f, 0.06337350f, 0.01309878f, 0.07508399f, 0.23958032f, 0.09902462f, 0.04693161f, 
    0.13457349f, 0.04642759f, -0.05555141f, -0.01965673f, -0.18011546f, 0.20548345f, 0.19524203f, 0.11500625f, 
    -0.00620599f, 0.07992124f, -0.11918453f, 0.09929761f, -0.06213718f, -0.05272934f, -0.04644564f, 0.03267069f, 
    0.06456953f, 0.03960853f, 0.05757330f, -0.08081557f, 0.01567605f, 0.03189135f, 0.05826811f, -0.14830768f, 
    -0.41789860f, -0.01560213f, -0.20800585f, -0.14956483f, 0.16047598f, 0.00366922f, -0.12753020f, 0.11321705f, 
    -0.11632548f, -0.04937552f, 0.01843858f, 0.07127582f, 0.01693424f, -0.05240238f, -0.03392911f, 0.03302598f, 
    -0.10744981f, -0.03490516f, 0.09302326f, 0.06147483f, 0.03451016f, 0.04317733f, 0.09506111f, 0.35913229f, 
    -0.00215576f, -0.17839614f, -0.06383284f, 0.07954938f, 0.05923871f, 0.08018036f, -0.01680181f, 0.14402995f, 
    -0.02525416f, -0.12094170f, 0.06673215f, 0.05643294f, 0.05854441f, 0.02225037f, 0.02630156f, -0.00395752f, 
    0.58065218f, -0.04855299f, 0.25736412f, 0.19061896f, 0.31094247f, -0.03596532f, -0.01890753f, 0.03695377f, 
    0.05010135f, -0.01561159f, -0.16294450f, 0.12456468f, 0.01944048f, 0.04014004f, 0.08791910f, 0.05844323f, 
    -0.16756643f, 0.09177243f, 0.01470413f, 0.01628128f, 0.12589802f, -0.45218688f, 0.14414530f, 0.24535331f, 
    -0.18056181f, -0.01110938f, 0.21459244f, 0.17071435f, 0.00291286f, 0.04174145f, -0.01630437f, -0.04935253f, 
    -0.02058877f, 0.02182043f, 0.03108447f, -0.06619630f, -0.02012978f, -0.09466753f, 0.17055170f, -0.04547980f, 
    -0.06806406f, -0.12165361f, -0.33506033f, -0.28863746f, -0.13606910f, 0.22946501f, 0.13041225f, 0.07321872f, 
    -0.12288729f, 0.00876577f, -0.04077509f, 0.08883410f, 0.03707809f, 0.11881188f, -0.01237277f, 0.15234298f, 
    -0.05365967f, 0.07855223f, 0.08052447f, -0.00593269f, -0.19025052f, -0.06236726f, 0.05277104f, 0.19737493f, 
    0.12650713f, 0.04848128f, -0.07273936f, -0.00662712f, 0.01152398f, 0.13089831f, 0.09160153f, 0.00428744f, 
    0.04959721f, -0.09393427f, 0.00299245f, -0.00928092f, -0.08813065f, -0.03332033f, 0.09534518f, -0.02367356f, 
    -0.37241861f, 0.09942774f, -0.04630971f, -0.18620089f, -0.02269458f, 0.15552750f, 0.02506022f, 0.12555762f, 
    0.05154315f, 0.08027770f, -0.11550210f, -0.11929896f, 0.15269321f, 0.12498660f, -0.07849917f, 0.07030183f, 
    0.06025324f, 0.12386223f, 0.06987274f, 0.07553723f, -0.07746504f, 0.19265302f, -0.00072559f, -0.08925886f, 
    0.09922028f, 0.08615421f, 0.10290956f, 0.09226719f, 0.02517658f, -0.10650445f, -0.02251377f, 0.07100330f, 
    0.03810538f, -0.00607702f, 0.18595785f, -0.13820373f, 0.00565320f, 0.07839068f, -0.07465316f, -0.04932616f, 
    -0.44131944f, 0.11123729f, -0.14968766f, 0.15549073f, 0.21996294f, 0.10454862f, 0.06924533f, 0.04132959f, 
    -0.18529353f, 0.02099166f, -0.11604099f, 0.03199515f, -0.04364118f, -0.00724482f, 0.20380980f, -0.00548850f, 
    0.04544853f, 0.11195073f, 0.17742056f, -0.07570983f, -0.11549353f, -0.05338502f, 0.06341887f, -0.24158791f, 
    0.19555020f, 0.03532431f, 0.07083676f, -0.02950226f, -0.00957949f, 0.08298239f, -0.07563692f, -0.09510124f, 
    0.19376677f, -0.00101133f, 0.06920917f, -0.01149076f, -0.05417233f, 0.01703726f, -0.10928596f, 0.02598541f, 
    0.21101078f, 0.38323888f, 0.24401046f, 0.47216058f, -0.07309933f, -0.03602408f, 0.07503687f, -0.01962776f, 
    0.04732701f, 0.04580562f, -0.07653699f, -0.01942485f, -0.09682895f, 0.04766386f, -0.04437083f, 0.20086867f, 
    -0.06295125f, 0.03323391f, 0.05950734f, 0.05724556f, 0.39012069f, -0.16339846f, -0.06864601f, 0.03168517f, 
    0.09616713f, -0.04665999f, 0.09295207f, -0.01493995f, -0.08288304f, -0.02980374f, 0.02270269f, -0.07897968f, 
    0.04883101f, 0.09839595f, -0.02792980f, 0.11620504f, 0.11428918f, 0.17415097f, -0.07348716f, 0.05508049f, 
    -0.01111331f, -0.09244831f, -0.42582384f, -0.27994576f, 0.11531387f, -0.00364567f, -0.03982151f, 0.01211917f, 
    0.03499227f, -0.05588572f, -0.03900675f, 0.07711452f, 0.03103976f, 0.00548878f, 0.15603200f, 0.12049245f, 
    0.04489017f, 0.09508559f, 0.12623759f, 0.12253869f, 0.18293884f, -0.16001764f, 0.24662574f, 0.09176522f, 
    -0.15608300f, -0.02845913f, 0.01846140f, 0.09209322f, -0.01101895f, -0.06118958f, -0.00562712f, -0.02589985f, 
    -0.00424000f, -0.01431496f, -0.06290188f, 0.07026113f, 0.05674249f, 0.05703317f, -0.07229429f, 0.09283983f, 
    -0.32032004f, -0.23514402f, -0.08557739f, 0.13414638f, -0.12882632f, -0.18727101f, -0.11591023f, 0.09724623f, 
    0.12900135f, 0.01888208f, 0.10188480f, 0.00336943f, 0.08318768f, 0.03006288f, 0.00406862f, 0.06929672f, 
    -0.07859392f, -0.12038291f, -0.00647262f, -0.11504090f, 0.28803521f, 0.15705885f, 0.02265602f, 0.22728314f, 
    0.09600161f, -0.00009005f, -0.09844999f, 0.13290459f, -0.04478024f, 0.15970348f, -0.10837106f, -0.09335572f, 
    -0.08416687f, -0.00016895f, 0.07123779f, 0.09303001f, -0.03384979f, 0.07397248f, 0.07761797f, 0.09308269f, 
    -0.16785178f, -0.01073175f, -0.23776825f, -0.32711819f, -0.24619333f, 0.04727390f, 0.02385440f, 0.12615931f, 
    -0.04976299f, -0.00986645f, 0.02652742f, -0.00633450f, 0.09742595f, -0.11042669f, 0.01317276f, -0.00390016f, 
    -0.06487862f, -0.02429644f, -0.04590734f, 0.07953810f, 0.21250705f, 0.15873934f, 0.23998213f, 0.18191354f, 
    0.04530913f, 0.04185287f, -0.02469424f, 0.06930678f, 0.02132029f, -0.00201052f, 0.00651200f, 0.00587010f, 
    -0.10559568f, 0.09844795f, 0.05814700f, 0.13545015f, 0.08046860f, 0.15094690f, -0.01542936f, 0.10043603f, 
    -0.32800516f, 0.16577211f, -0.39553288f, -0.29868200f, -0.07199612f, 0.17320228f, 0.01156941f, -0.13866194f, 
    0.02137796f, -0.03315322f, -0.01927153f, 0.06373694f, 0.03068511f, 0.01680475f, -0.01511413f, -0.07501461f, 
    -0.01867271f, 0.03929884f, -0.05490920f, -0.04049923f, 0.09556147f, -0.29702756f, 0.16261244f, 0.27404255f, 
    0.06441052f, 0.05271263f, 0.13783798f, 0.13085699f, 0.05165232f, 0.03566567f, 0.01510853f, -0.11598687f, 
    -0.01148315f, -0.04149316f, 0.10263785f, 0.05659966f, 0.04148467f, -0.10833950f, 0.14784585f, -0.00974032f, 
    0.12218405f, 0.15788795f, 0.26790658f, 0.12282773f, 0.22707956f, -0.09942821f, -0.05683172f, -0.10530644f, 
    0.12418302f, 0.09067743f, -0.01516339f, 0.02134515f, 0.18949188f, 0.00469243f, -0.04872527f, 0.04821947f, 
    0.02740844f, -0.06405374f, -0.00708739f, -0.09652780f, -0.02214492f, -0.01701855f, -0.09928223f, 0.16524810f, 
    0.20965016f, -0.00831590f, 0.01275119f, 0.12677880f, -0.07882467f, 0.11567309f, -0.03699262f, -0.09813792f, 
    0.01496868f, -0.13827361f, 0.12634493f, -0.01034420f, 0.20135149f, 0.06173278f, 0.16426267f, 0.12118220f, 
    -0.00585922f, 0.00076005f, 0.01898610f, 0.03375820f, -0.00366172f, 0.02767948f, 0.01351357f, -0.01733267f, 
    -0.02725958f, -0.04042303f, -0.00531635f, -0.02628979f, 0.01459990f, -0.00974540f, -0.04352614f, 0.03639001f, 
    -0.03772409f, 0.01972379f, -0.02201091f, 0.00425488f, 0.03124507f, 0.00347362f, -0.03137679f, 0.01835770f, 
    -0.00762567f, 0.01128551f, -0.03974767f, -0.00445604f, -0.02911159f, -0.03529864f, 0.02519453f, -0.04169628f, 
    -0.01469737f, -0.02623140f, -0.00648716f, -0.02570162f, -0.02258765f, 0.01096137f, -0.01874979f, -0.01056596f, 
    0.01769575f, -0.03124693f, -0.01579826f, -0.04151161f, 0.01063507f, -0.04440083f, -0.01999791f, -0.00507960f, 
    0.02626989f, -0.03587748f, 0.02146536f, -0.02139904f, 0.03174451f, 0.02196874f, 0.01254238f, 0.01277498f, 
    0.01882243f, -0.00994122f, -0.01404413f, -0.00798278f, -0.03510371f, -0.02439635f, -0.04154875f, 0.00300671f, 
    -0.01858014f, -0.00238467f, -0.00861318f, -0.04056555f, -0.03671899f, -0.00799342f, -0.03402074f, 0.01185368f, 
    0.01876871f, -0.04112760f, 0.03163052f, -0.01041309f, -0.03832963f, 0.03331407f, -0.01569364f, -0.00565998f, 
    -0.01655272f, 0.02224342f, -0.02864581f, 0.02997489f, -0.00426641f, -0.00903022f, -0.02324078f, -0.03805265f, 
    -0.03048159f, 0.01926018f, -0.04447590f, -0.01717154f, -0.01051093f, -0.04219578f, 0.02724134f, -0.01793864f, 
    0.01552144f, -0.04253100f, -0.02269249f, -0.01235683f, 0.02250327f, -0.02801740f, 0.02147978f, 0.00031057f, 
    -0.02224991f, 0.00385456f, -0.02913787f, 0.02108484f, 0.01342608f, 0.02053701f, -0.04340601f, -0.04066814f, 
    0.02018557f, -0.00418240f, 0.02760562f, -0.02189560f, -0.03620496f, -0.00128826f, -0.03740325f, 0.00910121f, 
    -0.02753406f, -0.02392085f, -0.01357872f, -0.02514330f, 0.01386835f, 0.02954395f, -0.01792254f, -0.02594845f, 
    0.00304502f, -0.01887663f, 0.02956951f, -0.02628701f, 0.01916421f, -0.00562158f, 0.02586810f, 0.00001144f, 
    0.03090584f, 0.00039916f, -0.03147291f, -0.03664080f, -0.02464632f, 0.01651715f, 0.02840352f, -0.02438413f, 
    -0.01472296f, -0.01665230f, -0.01341308f, 0.02481512f, -0.03620536f, 0.02531308f, -0.03054588f, 0.01888913f, 
    0.01400241f, 0.00115572f, -0.03480360f, -0.00249786f, 0.01914542f, -0.04063668f, -0.03075639f, -0.02099913f, 
    -0.01050283f, -0.01439193f, -0.01110661f, -0.02553543f, -0.02096353f, -0.01339656f, -0.01668922f, -0.00226135f, 
    0.02519636f, -0.03607721f, -0.03970325f, -0.03714665f, 0.01317638f, -0.02087542f, -0.00515362f, -0.00555094f, 
    -0.02200623f, -0.00941264f, -0.03829674f, 0.00026780f, 0.00401502f, -0.00840564f, -0.02985935f, -0.00959356f, 
    0.02671364f, 0.03294612f, -0.00371748f, -0.03653912f, 0.01081174f, 0.00430861f, 0.03296867f, -0.01493371f, 
    0.03115132f, -0.04233455f, -0.01073323f, -0.01714223f, -0.01279559f, 0.02639129f, -0.01250501f, 0.03319145f, 
    -0.03524422f, -0.03160907f, -0.03850390f, 0.03065901f, 0.03113697f, -0.00843633f, -0.02373824f, -0.04470937f, 
    -0.01784182f, -0.01480421f, -0.02297536f, -0.03660707f, -0.02144407f, 0.00877930f, -0.00725387f, -0.02865020f, 
    0.02088036f, -0.00975037f, -0.01407264f, -0.04085001f, 0.00382979f, -0.02156832f, 0.00725889f, -0.00079645f, 
    -0.02764551f, -0.02180400f, -0.00864845f, 0.00253060f, -0.02958581f, 0.01174530f, -0.01787933f, -0.03828834f, 
    0.02411766f, 0.02257524f, -0.01397972f, -0.03250742f, 0.01753015f, -0.02713404f, -0.01619151f, 0.02217738f, 
    -0.02815503f, -0.01818741f, -0.01132928f, -0.00713776f, -0.04421551f, -0.01186295f, -0.04336353f, -0.00229409f, 
    0.02468451f, 0.01129406f, 0.00650526f, -0.00422690f, -0.00865635f, 0.00963132f, -0.04234387f, -0.03762554f, 
    -0.01762742f, -0.00159611f, 0.00580880f, -0.00141557f, -0.04451471f, -0.01510837f, -0.00381572f, -0.03940500f, 
    -0.01839166f, -0.03986111f, 0.00015073f, -0.03439261f, -0.00174094f, 0.03142476f, 0.02140261f, 0.01363028f, 
    -0.04204945f, 0.01548561f, -0.02399510f, -0.00159441f, -0.02312899f, 0.00854960f, 0.02500735f, -0.01828143f, 
    0.02656025f, -0.01747906f, 0.03146039f, -0.00669205f, 0.00491166f, -0.01981945f, -0.01703754f, -0.03400049f, 
    -0.03888156f, -0.00900329f, 0.02046928f, 0.02664586f, 0.01722389f, 0.00422147f, 0.01332956f, 0.01919965f, 
    0.02202078f, -0.01914098f, -0.02538471f, 0.02502315f, -0.03094128f, 0.00775856f, -0.03587451f, 0.00010403f, 
    -0.04282117f, 0.02186058f, -0.04465236f, 0.01164552f, 0.00165413f, 0.00259368f, -0.02362581f, 0.02732638f, 
    0.02631557f, -0.00544626f, -0.02235828f, -0.03308770f, 0.01041835f, 0.02341847f, 0.00831512f, 0.02228794f, 
    -0.02685782f, 0.02098640f, 0.02634213f, 0.02758389f, 0.00114213f, -0.04027663f, -0.01962975f, -0.02987747f, 
    -0.02562313f, 0.01120474f, -0.01395682f, 0.00843474f, 0.02360018f, -0.03066852f, -0.03630371f, 0.03892524f, 
    -0.00494022f, -0.02052471f, -0.01967035f, 0.00802006f, 0.02831853f, -0.00829366f, 0.01956287f, 0.02543562f, 
    0.03029958f, -0.01474386f, -0.03373417f, -0.03322609f, -0.03304615f, -0.01883462f, -0.03990259f, -0.02465484f, 
    0.00377189f, 0.02400274f, 0.02784579f, -0.01194317f, 0.01891012f, -0.01958689f, -0.01119326f, -0.03908292f, 
    0.00293796f, -0.03467583f, -0.00429186f, 0.02869358f, -0.01839236f, -0.02192475f, 0.01748743f, 0.02143176f, 
    0.00369327f, 0.01534447f, 0.00512666f, 0.00170840f, -0.00382537f, -0.02616335f, -0.02790919f, 0.00256427f, 
    0.03493538f, -0.02782652f, -0.02235518f, 0.02783244f, 0.02999867f, 0.03120545f, 0.01222771f, -0.00852291f, 
    0.00786814f, 0.02720907f, -0.03657324f, 0.00503417f, 0.01512006f, -0.04443854f, 0.00351480f, 0.01213355f, 
    -0.00199811f, -0.00271317f, -0.03001718f, -0.02994415f, -0.04224258f, -0.00965910f, 0.02817742f, -0.04116884f, 
    -0.00013590f, 0.01603825f, -0.02441596f, -0.01518008f, -0.02630584f, 0.01368520f, -0.00328004f, -0.02397845f, 
    0.01291246f, -0.04546871f, -0.03329609f, -0.00093911f, -0.03091852f, -0.01576494f, -0.03426966f, 0.00847754f, 
    -0.02567389f, -0.02548984f, 0.02387259f, -0.00331610f, 0.02459864f, 0.02983654f, -0.00542342f, 0.00707664f, 
    -0.02088813f, 0.01363049f, -0.03300725f, -0.01103563f, -0.01796847f, -0.04356234f, -0.02347140f, -0.00760736f, 
    0.01488400f, 0.00664706f, 0.03259838f, -0.03540883f, -0.04121657f, 0.00848235f, 0.00870590f, 0.01181034f, 
    0.02731992f, 0.00692313f, -0.04508720f, 0.02148202f, -0.01459869f, 0.01736072f, 0.02739400f, -0.01380209f, 
    0.00822919f, 0.03803667f, -0.03654406f, -0.01759288f, -0.03352359f, -0.02370692f, 0.00221641f, -0.01295116f, 
    0.00741401f, -0.02906212f, 0.01971063f, -0.01833623f, 0.00161882f, -0.02221294f, 0.01923327f, 0.00352248f, 
    -0.01948318f, -0.01676081f, 0.02884198f, 0.02524494f, 0.00999090f, 0.01919533f, -0.00236267f, -0.02871570f, 
    0.02051391f, -0.03480259f, 0.00758882f, -0.02826851f, 0.01885153f, -0.04090310f, -0.02965539f, -0.03306400f, 
    -0.04501501f, 0.01238821f, 0.03304742f, -0.02077399f, 0.02905866f, 0.02428008f, -0.04192739f, 0.00205960f, 
    0.02961283f, 0.00025382f, 0.02775832f, 0.01756274f, 0.00763341f, -0.00961852f, -0.03188660f, 0.00103179f, 
    0.02306414f, -0.03772371f, -0.00720349f, -0.02462970f, -0.02838722f, -0.02434697f, 0.02770510f, -0.02830678f, 
    -0.00280189f, -0.00927896f, -0.03203700f, -0.03665826f, 0.00499453f, -0.04328297f, -0.00432003f, -0.02854977f, 
    -0.02290900f, -0.02702805f, 0.02353755f, 0.00054435f, 0.01077899f, 0.00384501f, -0.00309694f, 0.02322063f, 
    0.02669392f, -0.01121355f, -0.01923033f, 0.02990335f, -0.00707137f, 0.02096537f, 0.01365128f, 0.02819592f, 
    -0.02507582f, -0.00913887f, 0.01555439f, 0.01598961f, -0.02728292f, -0.03280793f, -0.02668953f, 0.00194391f, 
    0.00317595f, -0.00433800f, -0.04242293f, 0.00882777f, -0.02852996f, -0.04462147f, -0.00635695f, 0.03691306f, 
    -0.03143449f, -0.03966956f, 0.02458430f, -0.03595232f, -0.02112762f, -0.03522711f, 0.03034774f, 0.01568977f, 
    -0.01101889f, -0.03890830f, -0.02003608f, 0.02047889f, 0.01796447f, -0.03796468f, 0.02573560f, -0.01828383f, 
    -0.02156820f, 0.01028915f, 0.01353734f, -0.02909900f, -0.03837947f, -0.01022829f, 0.01975083f, -0.00525666f, 
    0.02287699f, -0.02811551f, -0.01942569f, -0.01352961f, -0.04113099f, -0.00399715f, -0.02451554f, -0.01471017f, 
    -0.02130003f, -0.02768781f, -0.02316583f, -0.01561790f, 0.02044285f, 0.01023616f, -0.00042546f, -0.00347838f, 
    -0.00860574f, -0.03975887f, -0.03575493f, -0.03313392f, 0.00122644f, -0.00256580f, 0.00350438f, -0.01170453f, 
    -0.00355825f, -0.04395832f, 0.00004798f, -0.01107497f, -0.00372834f, -0.01523614f, -0.03184516f, 0.02015207f, 
    0.02570060f, -0.03570837f, -0.03490330f, -0.01167475f, 0.02581824f, 0.02482101f, -0.01237109f, 0.02256451f, 
    -0.03914153f, 0.01665755f, -0.02069937f, 0.01447814f, 0.00958754f, -0.02842215f, -0.04526815f, -0.01061509f, 
    -0.01703219f, -0.02202220f, 0.01110257f, 0.01307847f, -0.04013076f, -0.03867041f, -0.00130700f, -0.01784972f, 
    0.02734778f, -0.02047298f, 0.00341260f, -0.00661711f, 0.02759064f, 0.00440116f, -0.00408400f, -0.02853037f, 
    -0.01712780f, 0.03874543f, -0.00378010f, 0.02212016f, 0.03069369f, -0.02964517f, 0.03339044f, 0.01517102f, 
    -0.01362629f, 0.03167610f, -0.01001222f, 0.02231252f, 0.00906580f, -0.00025760f, -0.02144545f, -0.01910614f, 
    -0.03925578f, -0.04275387f, -0.02696287f, 0.03035026f, -0.03891983f, 0.00322009f, 0.02087547f, 0.03087219f, 
    -0.00320476f, -0.00835502f, 0.00721778f, 0.02350364f, -0.01299241f, 0.00384767f, -0.03507913f, 0.02131392f, 
    0.03148897f, -0.03822173f, 0.02917414f, -0.04227491f, 0.00487914f, -0.03232824f, 0.00687652f, 0.00672897f, 
    -0.01162773f, 0.02468218f, 0.03231119f, 0.00881931f, -0.02746149f, -0.01123447f, -0.00287844f, -0.01165004f, 
    -0.02065011f, -0.01745126f, -0.03910699f, -0.02747842f, -0.03329103f, -0.01334991f, -0.03335027f, 0.01590400f, 
    -0.03977244f, 0.01377644f, 0.02260965f, -0.01980681f, -0.00280048f, -0.00634681f, 0.00624299f, 0.00242916f, 
    0.02216094f, -0.04377114f, -0.01956227f, 0.00126749f, 0.02464010f, 0.01442704f, -0.03715252f, -0.03346107f, 
    -0.03799682f, 0.01420539f, -0.02312480f, 0.00612194f, -0.02504043f, -0.01838032f, -0.04222740f, 0.02363428f, 
    -0.03132300f, 0.01198627f, 0.00706107f, 0.00442536f, -0.00983613f, -0.02194881f, 0.00467723f, 0.02896979f, 
    0.00850135f, -0.00972528f, 0.01769090f, -0.00850204f, -0.00381290f, 0.00585139f, 0.01026987f, -0.02638048f, 
    -0.01440220f, 0.02701952f, -0.03415539f, 0.01776908f, -0.04399893f, 0.02337474f, 0.00241084f, 0.00629272f, 
    -0.01201852f, 0.02246849f, 0.00215910f, -0.03317920f, 0.02396478f, -0.00168304f, -0.00652841f, -0.00076615f, 
    -0.03502133f, 0.00004583f, -0.00610317f, 0.00941887f, 0.02902702f, 0.03236489f, -0.03099879f, 0.02721947f, 
    -0.00260039f, 0.00656652f, -0.03181458f, 0.00234718f, -0.03663241f, -0.02526066f, 0.00659930f, -0.02826964f, 
    0.01434548f, 0.00201839f, 0.02637508f, -0.00146697f, -0.04066996f, 0.00535949f, -0.01423446f, 0.02353967f, 
    0.01482525f, 0.00286116f, -0.00782059f, -0.00910044f, 0.02525029f, -0.01406342f, 0.01042410f, -0.01661038f, 
    -0.04409887f, 0.00049280f, -0.03655428f, -0.04004571f, -0.01964035f, -0.04023083f, -0.02513123f, -0.04397113f, 
    0.03238818f, 0.02501562f, 0.01977708f, -0.04220491f, -0.01274133f, 0.03046910f, 0.01027675f, -0.01814597f, 
    0.03162209f, 0.01292021f, -0.01131448f, -0.02950949f, -0.04165723f, 0.02570350f, -0.04044227f, 0.02427435f, 
    -0.01280035f, -0.02282951f, -0.02594834f, -0.03468284f, 0.02819772f, -0.00894168f, -0.00372249f, -0.02590345f, 
    0.02579228f, 0.01417114f, -0.03570686f, -0.03113280f, -0.00923501f, -0.01891519f, -0.02131825f, -0.02825446f, 
    0.01306629f, 0.01307529f, 0.03168059f, -0.00453605f, -0.01816008f, -0.02378392f, 0.02450353f, -0.03400001f, 
    -0.00186639f, -0.03828222f, 0.02275917f, 0.01526019f, -0.02609047f, -0.00321655f, -0.01256907f, -0.00295086f, 
    -0.01088022f, -0.02113142f, 0.00847180f, 0.01915402f, -0.03071325f, 0.01308490f, 0.03203794f, -0.01482371f, 
    0.00679139f, 0.00860380f, -0.01612615f, -0.04463199f, 0.01764237f, -0.02721127f, 0.02312003f, 0.02993239f, 
    0.00797851f, 0.01388623f, 0.03113328f, -0.04103073f, -0.00192456f, -0.01767684f, -0.02190286f, -0.03784965f, 
    -0.02391276f, 0.01819095f, 0.03246912f, -0.03885773f, -0.01269107f, -0.04033232f, -0.00730572f, -0.00764410f, 
    0.02996010f, -0.02448843f, -0.03632118f, -0.03898961f, 0.00779143f, 0.00118121f, 0.02030076f, -0.04024063f, 
    0.00774598f, 0.02257465f, -0.01020907f, 0.02395671f, -0.02806632f, 0.02964005f, -0.00533632f, 0.01162963f, 
    -0.00295909f, -0.02895795f, -0.03404229f, -0.02721674f, -0.02773498f, -0.02952940f, -0.01489866f, -0.00785841f, 
    0.00294573f, 0.02880110f, -0.02131179f, -0.02712181f, -0.02859943f, 0.02201427f, 0.02142052f, 0.00351211f, 
    0.00583896f, 0.00929207f, -0.01833733f, -0.01096523f, 0.01722360f, 0.01531738f, 0.00978118f, -0.01112573f, 
    0.02553958f, -0.01589286f, -0.00847641f, 0.02369045f, -0.01813035f, 0.00171559f, 0.02599152f, 0.02165934f, 
    -0.03234595f, -0.03772380f, -0.00818695f, -0.02440292f, 0.01762139f, -0.00418852f, -0.02032427f, 0.00948309f, 
    -0.01069392f, 0.00854881f, 0.00782696f, -0.02045754f, 0.01341193f, -0.02931421f, 0.01842445f, -0.01546958f, 
    0.02714081f, 0.00863230f, 0.02752650f, -0.02802499f, -0.02973774f, -0.02382831f, -0.02564357f, 0.01562534f, 
    0.00523408f, 0.03225234f, 0.01055555f, -0.01135122f, -0.00697246f, -0.02616552f, -0.00181899f, -0.02594464f, 
    -0.00662864f, 0.00561600f, -0.03224060f, -0.02277074f, 0.00697654f, -0.03008766f, -0.02155738f, -0.03368220f, 
    0.03285342f, 0.00185597f, -0.03672856f, -0.04392257f, -0.01749567f, -0.04288735f, -0.01358202f, -0.01453251f, 
    0.01584595f, -0.01867690f, -0.00947146f, 0.02506902f, 0.00986615f, -0.03127932f, -0.03112854f, 0.02730282f, 
    -0.02540053f, -0.02002963f, 0.01693871f, -0.03559882f, 0.01872155f, 0.02503597f, -0.03719164f, 0.00271758f, 
    0.00817784f, 0.01703630f, -0.02819358f, -0.00949101f, 0.00469028f, -0.03688589f, -0.01930050f, 0.00750374f, 
    0.00760998f, 0.00822005f, -0.01072698f, -0.01475373f, 0.01064140f, -0.01993429f, 0.02992131f, 0.02770525f, 
    0.01975931f, 0.02727778f, -0.01780267f, 0.01300374f, -0.02228412f, -0.03214338f, -0.00647348f, -0.00540277f, 
    -0.00718663f, 0.02402106f, -0.00544282f, 0.02230599f, -0.02817494f, 0.02449325f, -0.03210941f, 0.00449253f, 
    -0.01367742f, 0.01979960f, 0.00674096f, -0.00886748f, 0.01412794f, 0.02261064f, -0.01253823f, -0.00838344f, 
    0.03036474f, -0.01647142f, 0.00081033f, -0.00019836f, -0.02467703f, 0.00796968f, -0.03882476f, 0.00535539f, 
    0.02722320f, -0.00193180f, -0.04059833f, -0.01668432f, 0.02434840f, -0.02878956f, -0.00309973f, 0.00779038f, 
    0.02453685f, 0.01002446f, -0.02084517f, 0.00253991f, 0.02507271f, 0.00893906f, -0.03414772f, -0.01602795f, 
    -0.03121129f, 0.00737306f, -0.03522284f, 0.01615589f, -0.00878897f, -0.04422522f, -0.00024805f, -0.03495868f, 
    -0.01257811f, -0.01041405f, -0.02878875f, -0.04122135f, -0.02780520f, -0.02079696f, -0.00984880f, 0.01908215f, 
    0.02065902f, -0.04178286f, 0.02938145f, -0.03541859f, 0.01149389f, 0.01448378f, -0.03806986f, 0.02460192f, 
    -0.00963580f, 0.02365789f, 0.00563597f, -0.02295713f, 0.00047697f, -0.00879526f, -0.00670498f, 0.03226144f, 
    -0.01981434f, -0.01701193f, 0.00005367f, 0.01620907f, 0.01229572f, 0.01331715f, -0.01288692f, -0.02136011f, 
    0.03050159f, -0.01367250f, 0.01763626f, -0.02673513f, 0.01290474f, 0.02202819f, -0.03440709f, -0.01502304f, 
    0.00717328f, -0.01871953f, 0.01275020f, -0.03329524f, -0.01957462f, -0.04082266f, 0.00864396f, -0.04173901f, 
    -0.04321575f, 0.02858369f, 0.02641834f, -0.01355299f, 0.02050754f, 0.01301541f, 0.01748240f, -0.03109394f, 
    -0.00313843f, -0.03398789f, -0.04049096f, 0.01982519f, 0.00293526f, -0.01766333f, -0.01344080f, 0.02445471f, 
    -0.04221772f, -0.00700657f, -0.03914037f, 0.00468258f, -0.01799388f, 0.03064880f, 0.02299288f, -0.02493764f, 
    -0.02556683f, 0.01457727f, -0.02217241f, 0.01795756f, -0.02847514f, -0.02784583f, 0.01384839f, -0.01711581f, 
    0.00029595f, -0.01108933f, 0.02602900f, 0.00826024f, -0.01359678f, 0.00803407f, -0.00233170f, 0.02465456f, 
    -0.03122016f, -0.00469423f, 0.01209586f, -0.00337740f, -0.00230651f, 0.02685401f, -0.01024971f, 0.02708381f, 
    -0.03670380f, -0.00126507f, -0.02854161f, 0.00254056f, -0.03921210f, -0.02338456f, -0.02551574f, -0.01981682f, 
    -0.01277655f, -0.04115480f, 0.00498107f, -0.04109902f, -0.02930690f, 0.02580844f, -0.03447292f, 0.01438946f, 
    0.03073895f, 0.00561197f, -0.02917866f, -0.00845267f, -0.03417907f, 0.00276883f, 0.00609818f, -0.02929517f, 
    0.00551780f, 0.00435056f, -0.01935071f, -0.04043107f, 0.03353038f, 0.01213564f, -0.02661979f, 0.02443978f, 
    -0.00204391f, -0.01226661f, 0.03203027f, -0.00005600f, -0.01805736f, -0.02948944f, -0.02172659f, 0.02134292f, 
    0.00928185f, 0.01158029f, -0.03798971f, -0.02963815f, 0.03266404f, -0.02168173f, -0.00141568f, 0.02116796f, 
    0.00247965f, -0.03714296f, -0.01822450f, -0.03184364f, -0.02237588f, -0.03806153f, -0.04174453f, 0.02595479f, 
    0.02297070f, 0.02845459f, 0.00112065f, 0.02948599f, -0.02713297f, 0.01414727f, 0.01425806f, 0.01351717f, 
    0.01846790f, -0.02852205f, -0.04350066f, -0.03769398f, 0.00810701f, -0.02636891f, -0.01294835f, 0.00823602f, 
    0.00444968f, -0.00679111f, -0.03789080f, -0.00509594f, 0.02106784f, -0.01682550f, -0.02190969f, -0.02427162f, 
    -0.01606093f, 0.01532747f, -0.04214538f, 0.00754296f, 0.02456317f, 0.02120997f, -0.00664506f, -0.01597699f, 
    -0.02011461f, 0.02726544f, 0.01495746f, 0.02329969f, 0.01112308f, -0.01619155f, 0.00483608f, -0.00724874f, 
    -0.01050621f, 0.01157691f, -0.02207414f, -0.04039237f, -0.00161202f, -0.01227458f, -0.04584340f, -0.01958139f, 
    -0.00853810f, -0.04256478f, 0.02554714f, -0.03172343f, -0.03687443f, 0.02535308f, -0.03052538f, -0.02359831f, 
    -0.03637837f, 0.02881824f, -0.02342144f, 0.01539569f, 0.02946356f, 0.01768158f, 0.01213996f, 0.02934557f, 
    0.01140806f, -0.04374749f, -0.03564241f, -0.01242290f, -0.01075856f, 0.02161765f, -0.01514869f, 0.00328990f, 
    0.02261734f, 0.02554664f, -0.04241475f, -0.01074034f, -0.00764820f, -0.01319378f, -0.02593146f, -0.03868672f, 
    0.00775818f, -0.01702492f, -0.01506257f, -0.00464064f, 0.02615478f, -0.01279005f, 0.00880289f, -0.01502491f, 
    -0.02453438f, 0.02115653f, -0.02314652f, -0.00053008f, -0.02845500f, 0.03574451f, -0.01677677f, -0.03228265f, 
    -0.00872898f, -0.00438996f, 0.01293077f, 0.01738598f, -0.01039342f, -0.00792324f, -0.01093514f, 0.00500037f, 
    -0.02591976f, -0.01820043f, -0.02675471f, 0.01160777f, -0.00872667f, -0.00017977f, -0.01893608f, 0.00154244f, 
    0.02455890f, 0.02072662f, 0.03003049f, 0.01217450f, -0.02479101f, -0.00451335f, -0.01657156f, 0.02641642f, 
    0.01052845f, -0.03008821f, -0.01908471f, -0.02663973f, -0.03385572f, -0.01603986f, 0.01107216f, -0.00034612f, 
    0.00675948f, -0.03981731f, 0.01358230f, -0.02618777f, 0.02220864f, 0.04096270f, -0.02435256f, -0.00824410f, 
    -0.00380111f, -0.01104525f, -0.00894958f, -0.01382936f, 0.00671409f, -0.03341725f, -0.02780922f, 0.01644781f, 
    0.00982626f, -0.03801460f, -0.02084054f, -0.03133846f, -0.01476903f, 0.02945319f, -0.02261233f, -0.01690595f, 
    -0.03968898f, -0.00494946f, 0.03224466f, 0.00569630f, -0.03599801f, -0.01737906f, 0.02145482f, -0.01464547f, 
    -0.01817560f, 0.01592668f, 0.04361625f, -0.02443057f, 0.02492597f, -0.04120588f, -0.02973441f, -0.02101515f, 
    0.01370193f, -0.03335972f, -0.00365271f, -0.03776848f, -0.01759166f, -0.03001653f, 0.04613805f, -0.02150296f, 
    -0.02909103f, 0.00566855f, -0.04228990f, -0.01081173f, 0.01600123f, 0.03572666f, 0.01254063f, -0.01137284f, 
    -0.01241064f, -0.04139303f, 0.01000520f, 0.02774957f, 0.00335173f, -0.04015884f, -0.02059483f, -0.00176899f, 
    0.00589442f, 0.03381383f, 0.03902863f, -0.03377597f, -0.00685914f, 0.01107937f, 0.03161373f, 0.00551902f, 
    0.02228937f, 0.04051358f, 0.00680826f, -0.02335324f, 0.00179982f, -0.01763149f, -0.02925299f, 0.02550631f, 
    -0.02708912f, 0.00817452f, -0.01128589f, -0.03302329f, -0.04474109f, 0.00906414f, 0.01668455f, -0.00939700f, 
    -0.00187030f, 0.02682738f, 0.01414559f, -0.01163883f, 0.01315482f, -0.03356756f, -0.02388780f, -0.00689038f, 
    0.02438642f, 0.03259414f, -0.03646640f, -0.01840327f, 0.00373414f, -0.03267678f, 0.03268413f, -0.02920195f, 
    -0.00062255f, -0.01640542f, -0.04415327f, -0.01236555f, 0.00603974f, -0.00636278f, -0.01060084f, 0.02039748f, 
    -0.00705880f, -0.01880108f, 0.00400285f, 0.02676226f, -0.01247304f, -0.04048502f, -0.02724702f, -0.04023560f, 
    -0.01882740f, 0.02837785f, 0.02861835f, -0.04484011f, -0.03728658f, 0.00893013f, 0.00457339f, 0.00220987f, 
    -0.02564120f, -0.01779855f, 0.00312276f, -0.02175883f, 0.00216190f, -0.01382480f, -0.03781077f, -0.00179013f, 
    0.01289335f, -0.01222163f, -0.04104302f, -0.02783127f, -0.00735147f, 0.01933635f, 0.02054912f, -0.00040174f, 
    0.00240352f, -0.00257793f, 0.01138213f, -0.02269649f, -0.01802797f, 0.00556587f, 0.00767575f, 0.01429878f, 
    -0.03030748f, -0.00755685f, -0.03128554f, -0.04058933f, 0.01477828f, -0.00301389f, 0.02950854f, -0.02405838f, 
    0.02836757f, 0.03748522f, -0.00875832f, 0.01566915f, -0.03397693f, -0.00358496f, -0.00995480f, 0.03434128f, 
    -0.01432325f, 0.04459912f, -0.02026860f, -0.02267568f, 0.02699975f, -0.01805842f, 0.00498636f, 0.00800518f, 
    0.01192638f, 0.02537379f, -0.02673113f, -0.04503975f, 0.00124638f, -0.04152857f, -0.02285240f, -0.00111083f, 
    0.01043678f, 0.02041530f, -0.02891034f, -0.03334025f, 0.01995865f, -0.01836364f, 0.00047446f, -0.02022003f, 
    0.00396209f, 0.01346111f, 0.01661880f, 0.02259371f, 0.00420621f, 0.00669058f, 0.01882111f, 0.02542859f, 
    -0.01322291f, -0.02702033f, -0.02960292f, -0.00087175f, 0.01115060f, -0.01963958f, 0.01119127f, -0.01539864f, 
    0.01304357f, -0.01653336f, 0.02854030f, -0.03590455f, -0.02006970f, 0.03654175f, 0.02570346f, -0.01488998f, 
    0.02268655f, -0.00372462f, -0.02874410f, -0.04219714f, 0.02852830f, 0.03266209f, 0.00986507f, 0.01694179f, 
    0.02020681f, 0.03843364f, 0.00138024f, -0.03158763f, 0.02528256f, -0.01917026f, 0.00624251f, -0.02242334f, 
    -0.00813126f, -0.01133529f, -0.01930954f, 0.00732013f, -0.02043447f, -0.01814892f, 0.00730027f, -0.04150217f, 
    0.03153238f, -0.00108457f, -0.00427018f, -0.02259341f, 0.01682842f, -0.02847256f, 0.01659929f, 0.03370899f, 
    0.03616388f, -0.03344952f, -0.03107170f, -0.00897038f, -0.01523504f, 0.03347558f, 0.01369255f, -0.01163317f, 
    -0.00462361f, 0.03705063f, -0.00973225f, 0.02804200f, 0.03875138f, 0.00314178f, 0.00884106f, 0.01571608f, 
    -0.02983608f, -0.03620236f, 0.01331465f, 0.02511829f, 0.03124479f, -0.01874005f, 0.03043801f, 0.02172170f, 
    0.03101240f, 0.01112916f, 0.03072607f, 0.00925240f, 0.00855089f, 0.04519231f, -0.01070620f, -0.01478725f, 
    0.01719357f, 0.03305192f, 0.03110365f, 0.00564221f, 0.02424048f, 0.01982803f, -0.01362667f, 0.00499095f, 
    -0.01902511f, 0.02871324f, 0.03444537f, 0.02720517f, 0.00175609f, 0.01403511f, -0.02881735f, 0.00872872f, 
    -0.01129841f, 0.01108811f, 0.00995150f, -0.03234986f, 0.01695231f, 0.00488186f, -0.00360092f, 0.01915473f, 
    -0.02361795f, -0.02875510f, -0.02301536f, 0.02907462f, -0.03244674f, 0.04749398f, 0.02976127f, -0.01379774f, 
    -0.03886848f, 0.01485792f, 0.02930263f, -0.01431992f, -0.03412418f, -0.01840496f, 0.01354518f, 0.01664475f, 
    0.02525695f, -0.03428643f, 0.01813841f, -0.01418711f, 0.00067708f, -0.02241055f, -0.03036387f, -0.03038533f, 
    -0.02299695f, 0.00045371f, -0.00413424f, 0.03513579f, -0.00172421f, 0.02390313f, 0.02854561f, -0.02500912f, 
    0.01879359f, -0.01029577f, -0.02731628f, 0.03265896f, 0.03285490f, -0.03177816f, -0.03959523f, -0.01202048f, 
    0.02560166f, -0.03857482f, -0.03644738f, -0.04572156f, -0.00331254f, -0.00986518f, 0.03669881f, -0.02646155f, 
    0.01832507f, -0.01685209f, -0.01958942f, 0.03830921f, -0.00325463f, 0.02872595f, -0.02469712f, -0.03200323f, 
    -0.02644963f, 0.00354381f, -0.02133990f, -0.03126028f, 0.01513586f, -0.02160352f, 0.03130363f, 0.01372820f, 
    -0.00883050f, -0.01012430f, -0.02453580f, -0.01516939f, 0.01695057f, -0.02865549f, -0.00087991f, -0.01219454f, 
    -0.02092672f, -0.02276976f, 0.02624129f, 0.00451436f, 0.02913115f, 0.01418995f, -0.01636967f, -0.00032612f, 
    0.02831944f, -0.03804494f, -0.01922822f, -0.03859033f, 0.03042525f, -0.03179662f, -0.02013265f, -0.02268305f, 
    -0.02028041f, -0.02930057f, 0.00644223f, 0.02694678f, 0.00729950f, -0.03662897f, 0.03624667f, 0.02187690f, 
    -0.03337477f, 0.02736560f, 0.01147133f, 0.02630336f, -0.00958294f, 0.02116885f, -0.03101467f, 0.00258376f, 
    0.01095934f, 0.03657126f, 0.04194234f, -0.01631965f, 0.04563309f, -0.01841444f, 0.00013534f, -0.00372953f, 
    0.01610856f, -0.00363911f, 0.01120668f, -0.01728358f, 0.01019512f, -0.01349463f, 0.01702317f, -0.00919753f, 
    -0.03296975f, -0.04155688f, 0.01816439f, 0.02329608f, 0.00693212f, -0.02246442f, 0.01734386f, -0.00886551f, 
    -0.02467508f, 0.01164921f, 0.00896307f, -0.04048505f, 0.02267587f, -0.04436969f, 0.00843313f, -0.03526351f, 
    0.03499405f, -0.02521854f, -0.00208106f, 0.00144321f, -0.01361957f, -0.02600557f, 0.02282955f, 0.00405336f, 
    0.02705065f, -0.00032431f, 0.02594310f, 0.00061763f, -0.01949115f, -0.03000069f, -0.02364312f, -0.02335806f, 
    -0.02415252f, 0.01305797f, 0.00696996f, 0.01525306f, 0.01428721f, 0.01490248f, 0.02861527f, -0.00602775f, 
    -0.00007034f, -0.02643993f, 0.00084103f, 0.02262105f, -0.03411065f, -0.01650610f, -0.04089490f, -0.03382594f, 
    0.02032742f, -0.03381554f, 0.01201329f, 0.00757050f, -0.01723778f, -0.02278580f, 0.02625731f, -0.03451044f, 
    -0.02978251f, -0.00583133f, -0.03104053f, 0.01969669f, -0.03128108f, -0.02189790f, -0.00695648f, 0.01389621f, 
    -0.03543629f, -0.03179048f, 0.02047765f, -0.00342356f, -0.00805408f, -0.02228869f, 0.02959608f, 0.00852030f, 
    0.03875032f, -0.03483179f, -0.04107947f, 0.02380908f, -0.02827450f, -0.01944456f, -0.03167120f, -0.02714448f, 
    -0.01705497f, -0.00016825f, 0.01242176f, 0.02441701f, -0.02455756f, -0.03165878f, 0.00882610f, 0.04248799f, 
    0.02463250f, -0.01348427f, -0.03012522f, -0.03977551f, 0.02743416f, -0.03610218f, 0.01888728f, 0.02724043f, 
    -0.02849919f, 0.00072421f, -0.00523258f, -0.03079318f, -0.01052947f, -0.01128788f, 0.00972629f, 0.02219198f, 
    -0.02374581f, 0.01075918f, 0.02028942f, -0.02345229f, -0.00129364f, 0.01103293f, -0.03632534f, 0.00541989f, 
    0.02902870f, -0.03462728f, -0.04632614f, 0.00928204f, 0.03036212f, -0.00311728f, -0.02821438f, 0.01879748f, 
    -0.03475511f, -0.01150817f, -0.00149355f, 0.02149000f, 0.01267646f, 0.02758273f, 0.01955598f, 0.00143264f, 
    -0.01763988f, -0.02290720f, 0.02958709f, 0.00033699f, 0.02952875f, -0.00773006f, 0.03014473f, -0.01963214f, 
    -0.02380596f, -0.01553809f, 0.02912541f, -0.02942206f, -0.00657676f, 0.02703588f, 0.02206203f, -0.00563572f, 
    -0.01037805f, 0.03137630f, -0.00193426f, -0.02899086f, 0.02279454f, -0.00295923f, 0.03009952f, -0.02133121f, 
    -0.01323371f, -0.02183045f, -0.00773214f, -0.00278932f, 0.02859573f, 0.02978890f, -0.04504317f, 0.00934729f, 
    -0.01390839f, -0.03904944f, 0.02164040f, 0.01693734f, -0.03683947f, -0.02510284f, -0.02057289f, 0.01782582f, 
    -0.07195207f, 0.17063576f, 0.00544059f, 0.10053473f, 0.12142256f, -0.02721169f, 0.07976401f, 0.09277854f, 
    0.09582061f, -0.01475807f, 0.02954408f, -0.01672125f, -0.00335980f, 0.08186817f, -0.03665645f, 0.12313011f, 
    0.08523334f, 0.18030111f, 0.02076878f, 0.01034454f, -0.31056339f, -0.17222773f, -0.01998718f, -0.09297539f, 
    -0.20596591f, 0.10186559f, 0.13154650f, 0.17952737f, -0.06383187f, -0.04661113f, 0.06380790f, -0.01338551f, 
    -0.04244434f, 0.03745477f, 0.04283705f, 0.00273860f, -0.02020000f, 0.00985624f, -0.13325252f, -0.03346185f, 
    0.05683962f, 0.23129494f, 0.02681314f, 0.12299608f, 0.07487822f, 0.04969392f, 0.05192756f, -0.02785582f, 
    -0.05476138f, 0.03865428f, -0.02004632f, -0.00718254f, 0.04989069f, 0.13048555f, 0.11624983f, 0.04571797f, 
    0.08967444f, -0.00520963f, 0.16378631f, 0.07461450f, 0.77157634f, -0.08976806f, -0.13577199f, -0.00785618f, 
    0.05051204f, 0.03937192f, -0.19713752f, -0.06427964f, -0.02307560f, 0.10758229f, -0.00293090f, 0.05806022f, 
    0.04128802f, -0.01945142f, -0.14807276f, -0.02242555f, -0.08904421f, -0.03519790f, -0.09354292f, -0.04912321f, 
    -0.14755496f, 0.07262121f, -0.33721727f, 0.14224431f, -0.03194819f, 0.10466582f, -0.00842049f, -0.00247696f, 
    0.08327217f, 0.11485882f, -0.15923275f, 0.02267196f, 0.16073640f, -0.12879552f, -0.07684410f, -0.02728870f, 
    -0.06301956f, 0.06710407f, 0.00962381f, 0.02354500f, -0.38927606f, -0.10750232f, -0.18236405f, 0.05009274f, 
    -0.21459398f, 0.03987299f, 0.06132877f, 0.06551185f, -0.02381456f, -0.14981428f, 0.00476838f, -0.10169657f, 
    0.08164926f, -0.04944914f, -0.05443388f, 0.08396805f, -0.10207335f, -0.00399782f, 0.00552088f, 0.05729637f, 
    -0.10091519f, -0.19989626f, -0.26302993f, 0.04135646f, -0.01217557f, 0.02155900f, 0.09291872f, -0.00949512f, 
    -0.03307176f, -0.01883432f, 0.01787751f, -0.12000409f, 0.00107117f, 0.18931337f, -0.01210082f, 0.08409794f, 
    -0.03565299f, -0.00824943f, 0.07640608f, -0.08480203f, 0.05804066f, 0.04186319f, -0.07996844f, 0.10750385f, 
    0.20615754f, 0.01634765f, 0.00720353f, -0.04270210f, 0.12607877f, 0.10469454f, -0.10154803f, -0.03088624f, 
    0.07555504f, -0.01019390f, 0.05155974f, -0.08470103f, 0.04441001f, -0.04855981f, 0.09105863f, 0.00738512f, 
    0.10438503f, -0.04776618f, -0.23948787f, 0.10083015f, -0.06803209f, -0.03421272f, -0.11859248f, 0.03536416f, 
    0.04469591f, 0.01014894f, -0.04455445f, 0.13810660f, -0.03028484f, -0.07870065f, -0.05392161f, -0.11326009f, 
    -0.04644334f, -0.05238717f, -0.03435859f, 0.00175521f, -0.04018488f, 0.03717513f, 0.07084834f, -0.03024592f, 
    0.03395147f, 0.02977159f, 0.08906535f, -0.03484202f, 0.16493762f, 0.07943445f, -0.01552599f, 0.04812772f, 
    0.01409469f, 0.05490584f, -0.06632943f, 0.03695379f, 0.01830516f, -0.05901197f, 0.03924226f, 0.14424336f, 
    0.08891372f, -0.17856236f, -0.12675610f, 0.05701974f, -0.07819952f, -0.07750600f, -0.04204427f, -0.05234474f, 
    -0.05408346f, 0.08490957f, -0.05374238f, 0.07174709f, -0.02088694f, 0.03967600f, 0.20592564f, 0.05970790f, 
    0.11447397f, 0.05924509f, -0.01788726f, 0.09742040f, -0.02822007f, -0.26160634f, -0.17358449f, -0.10995903f, 
    -0.19696093f, 0.04619556f, 0.11629465f, 0.05801650f, 0.01512446f, -0.03623646f, 0.00030133f, 0.00828354f, 
    -0.04702289f, 0.02810689f, 0.07615668f, 0.03403242f, -0.01727360f, 0.00148753f, -0.03201248f, -0.02708143f, 
    -0.15859050f, -0.17527023f, -0.38023621f, 0.05372746f, 0.07393857f, -0.02501548f, 0.13540217f, 0.05313630f, 
    0.09835426f, 0.01102666f, 0.01567365f, -0.05807505f, -0.00798354f, 0.13781291f, 0.13932347f, 0.09158162f, 
    0.08259647f, -0.00024750f, -0.04199994f, 0.07779652f, 0.43280470f, 0.04455464f, -0.10803154f, -0.06408463f, 
    0.22392653f, -0.08207059f, 0.04446449f, 0.07460950f, 0.02881153f, -0.01913750f, -0.02944622f, 0.05394752f, 
    -0.01990180f, 0.08777521f, -0.05428728f, 0.09946369f, 0.00552248f, -0.04482169f, 0.08695716f, 0.01969383f, 
    0.33369261f, 0.07205498f, 0.03351846f, 0.03507422f, -0.02810200f, -0.13443528f, -0.05885493f, 0.09765271f, 
    -0.05748741f, -0.00160556f, -0.05050880f, 0.04523381f, 0.06748544f, 0.03161407f, 0.12585135f, -0.05187142f, 
    -0.01398468f, 0.01101913f, -0.06983549f, 0.03246400f, -0.07679404f, 0.11153783f, -0.08494671f, -0.07116364f, 
    -0.03713678f, -0.06676318f, 0.05620528f, -0.08935977f, -0.08471983f, -0.01009367f, -0.04910407f, 0.03889450f, 
    -0.01757699f, 0.01338373f, 0.03291978f, 0.14350355f, 0.07765312f, 0.02676508f, -0.07660469f, 0.20996223f, 
    0.04380016f, -0.19527216f, -0.13919380f, 0.28315848f, -0.02346092f, -0.23128530f, -0.15892710f, 0.06338138f, 
    -0.04435171f, -0.01205449f, -0.08655512f, 0.10478099f, 0.09191256f, -0.03306131f, 0.03568873f, 0.01050292f, 
    -0.01960177f, -0.14133115f, 0.07791261f, -0.02659645f, -0.06985328f, 0.02639455f, 0.01665716f, 0.09582085f, 
    0.03610930f, 0.05030915f, -0.01978939f, -0.03930178f, -0.01742825f, 0.08052921f, -0.00129720f, 0.09649792f, 
    0.02891481f, -0.01520716f, -0.17194919f, -0.11808146f, 0.07161105f, -0.01182421f, 0.04825258f, 0.11849273f, 
    0.14905471f, 0.26562172f, -0.00408552f, 0.03215194f, 0.05756916f, -0.08677798f, 0.11475179f, 0.07920001f, 
    0.05792782f, 0.03733620f, -0.08976326f, -0.05784320f, 0.01660006f, -0.12669601f, -0.02547964f, 0.00701229f, 
    0.08204699f, 0.01334272f, 0.09943064f, 0.13930467f, -0.05198959f, 0.00788729f, 0.06820928f, 0.19617578f, 
    -0.10044689f, -0.10705115f, -0.02877776f, 0.01234690f, 0.16194785f, -0.09851473f, 0.02237119f, 0.05865446f, 
    -0.03885421f, 0.00161013f, 0.07751086f, 0.04513155f, -0.02079065f, -0.05222878f, -0.02303092f, 0.12331954f, 
    0.01684892f, 0.01895385f, -0.04571947f, -0.08458190f, 0.08623579f, 0.09410875f, 0.22220154f, 0.13478261f, 
    0.03950263f, 0.09936512f, 0.02727109f, 0.13991927f, -0.03775579f, 0.00630534f, -0.04658871f, -0.03140847f, 
    0.08174749f, 0.02618415f, -0.07898585f, -0.04198996f, 0.07197363f, 0.30703014f, -0.18942809f, -0.00416780f, 
    0.10972223f, 0.21953699f, -0.00081739f, 0.01008210f, 0.05708685f, 0.02900166f, 0.02276159f, 0.02052785f, 
    -0.09767894f, 0.03524634f, 0.13633581f, -0.02918170f, 0.01060239f, 0.03087164f, -0.07749467f, 0.03591333f, 
    0.07701900f, 0.18711735f, -0.22910170f, 0.03277454f, -0.12977615f, -0.11525903f, -0.03919739f, -0.06493834f, 
    -0.07858422f, 0.16422118f, -0.02043237f, 0.05763132f, 0.02995570f, 0.05695326f, 0.02456302f, 0.06827907f, 
    -0.06637533f, 0.02314597f, 0.01855659f, -0.14207722f, -0.31885365f, -0.09349562f, -0.17369255f, 0.06821129f, 
    0.16983320f, 0.07892736f, -0.05882946f, -0.13375761f, -0.02033538f, -0.02565248f, 0.02424948f, -0.11971639f, 
    -0.00318548f, -0.00010810f, 0.04512312f, -0.07767091f, 0.02237490f, -0.02442976f, 0.03428819f, 0.10625198f, 
    -0.13578498f, -0.12834814f, -0.00200614f, -0.12111126f, -0.19894117f, 0.03126390f, -0.01901462f, -0.09443580f, 
    0.02683648f, -0.00724025f, 0.03243208f, 0.04154273f, -0.00348787f, -0.07458452f, 0.01242442f, -0.00484762f, 
    0.03317904f, 0.04647224f, -0.00703958f, 0.15428078f, 0.01456032f, 0.17148551f, 0.17574577f, 0.03632876f, 
    -0.04061967f, -0.08081660f, 0.07800347f, 0.15664159f, 0.00869836f, 0.07717878f, 0.10239368f, 0.04720118f, 
    0.05663006f, 0.00538839f, 0.02320408f, 0.10808880f, 0.04039362f, -0.07535802f, 0.12089538f, -0.02688328f, 
    0.21775515f, 0.00061825f, -0.12765470f, 0.10815931f, 0.01169399f, 0.03798034f, -0.07614913f, -0.04234397f, 
    0.01105484f, 0.04995479f, -0.04145282f, 0.05030255f, 0.06968726f, 0.12093265f, 0.05662810f, -0.09432381f, 
    0.15846258f, 0.13510691f, 0.03799605f, -0.09926822f, 0.07168181f, 0.10948544f, -0.16794829f, 0.08273687f, 
    0.18352206f, 0.10815573f, 0.04470976f, 0.02164815f, 0.08142103f, 0.04946915f, 0.08832414f, 0.00999774f, 
    -0.00392494f, 0.01438341f, 0.01931687f, 0.02860980f, 0.09391414f, -0.06523053f, 0.00446369f, 0.03860762f, 
    0.20976944f, -0.21055551f, -0.12749627f, -0.03409402f, -0.25545749f, -0.10460301f, -0.10612386f, -0.03448886f, 
    -0.07851545f, 0.01270894f, -0.10847011f, -0.06668244f, -0.01086858f, -0.01904784f, 0.10971263f, -0.07267988f, 
    0.01256087f, -0.01013336f, -0.04845882f, 0.14779194f, 0.30828175f, 0.08311633f, 0.00259985f, 0.01933625f, 
    0.08837774f, -0.01162517f, 0.07132591f, 0.06199409f, -0.01955928f, 0.00085379f, -0.06579126f, 0.00148807f, 
    0.07274961f, 0.03274166f, -0.01593120f, -0.00857956f, 0.01421250f, -0.03192368f, 0.07575273f, -0.00203863f, 
    -0.41615048f, -0.28753236f, -0.08193564f, 0.01341541f, -0.17136711f, 0.13979325f, 0.16025017f, 0.02689067f, 
    -0.01296092f, -0.03799310f, 0.01406463f, 0.12359871f, -0.06951603f, 0.10516638f, 0.04234157f, 0.16544072f, 
    0.07772361f, 0.13087706f, -0.08427024f, 0.03136336f, -0.00063097f, 0.08348833f, 0.11277504f, -0.05898479f, 
    -0.03366569f, 0.05981099f, 0.06910635f, 0.02056795f, -0.09207606f, 0.15037464f, 0.02552432f, 0.09993734f, 
    0.04367014f, -0.00901899f, 0.09953208f, -0.03929778f, -0.01606818f, -0.09427097f, 0.01251598f, -0.00841994f, 
    -0.18096569f, -0.01346235f, 0.07905169f, -0.29087150f, 0.01492067f, -0.03230496f, -0.00759027f, -0.16782704f, 
    -0.03093962f, -0.01342901f, -0.04456307f, -0.00370572f, -0.02721633f, 0.12563011f, 0.06560408f, -0.06584577f, 
    -0.09029958f, -0.06063427f, 0.02567104f, -0.00351421f, 0.39100477f, 0.09648418f, -0.09513892f, 0.19863370f, 
    0.25619930f, 0.04786700f, -0.05837088f, 0.03138641f, 0.06231701f, -0.00912832f, -0.02495950f, -0.04400465f, 
    0.00273038f, 0.22409093f, -0.00762780f, 0.06040770f, 0.01003311f, 0.06591626f, -0.06745635f, -0.07130742f, 
    -0.13007589f, -0.05464649f, -0.03373858f, -0.11330717f, -0.05233044f, 0.02509522f, -0.07919256f, -0.05258451f, 
    0.19203384f, 0.02747055f, -0.06914429f, 0.03005438f, -0.12207424f, 0.10549521f, -0.03417972f, -0.03116923f, 
    -0.05369233f, 0.03223017f, -0.15802188f, 0.04300851f, -0.37654823f, 0.14265107f, -0.10906748f, 0.09479758f, 
    -0.05333450f, -0.08733717f, 0.04269423f, -0.06162354f, 0.01943178f, -0.05136187f, -0.00906263f, -0.01491765f, 
    0.03468785f, 0.02098661f, 0.09326562f, 0.03642992f, 0.01435881f, 0.01035000f, 0.03606082f, 0.06322472f, 
    0.61660445f, -0.21391344f, 0.06755172f, -0.12786464f, -0.11950197f, -0.00514833f, -0.01522501f, -0.00591056f, 
    -0.03069047f, 0.01120303f, -0.04887583f, -0.05144624f, -0.02727855f, -0.00199841f, 0.13980176f, -0.04043166f, 
    0.03028692f, -0.09653264f, 0.04476357f, 0.03512336f, 0.60435921f, 0.28523490f, 0.22342528f, 0.10567996f, 
    0.19963130f, -0.07721211f, 0.02595259f, -0.00902685f, -0.03424783f, 0.17051657f, 0.00607988f, 0.05910422f, 
    -0.00692037f, -0.01051788f, -0.04105484f, -0.14726922f, 0.13080366f, 0.06892929f, 0.03530631f, -0.05507134f, 
    0.25821191f, 0.24977824f, 0.06552582f, 0.00284446f, 0.26282787f, -0.11297838f, 0.04349651f, 0.03184154f, 
    -0.03167654f, 0.00485165f, 0.06375560f, -0.01186534f, 0.17671248f, -0.07358372f, -0.02869691f, -0.05909630f, 
    -0.01617164f, 0.13431755f, 0.09539242f, -0.01193666f, -0.09554683f, -0.20205650f, 0.04339352f, -0.14478068f, 
    -0.12448387f, 0.05355145f, 0.07793981f, -0.08792415f, 0.06106683f, -0.14083646f, 0.05225127f, -0.04318026f, 
    -0.06604422f, -0.06157276f, -0.03190565f, -0.05594311f, -0.06752079f, 0.01615226f, -0.01891524f, 0.09581956f, 
    -0.26176989f, 0.11094331f, -0.09866199f, -0.02001559f, 0.06432489f, -0.00682717f, 0.00878850f, 0.01128037f, 
    -0.04511453f, 0.00510669f, -0.02799348f, 0.01401613f, -0.01957648f, -0.10722835f, 0.06919454f, 0.08809109f, 
    0.06961557f, -0.05187907f, 0.05353613f, 0.02710854f, -0.13322097f, 0.26218370f, -0.19341981f, -0.00310969f, 
    0.06147359f, -0.05436338f, 0.00768119f, 0.08416409f, 0.00585547f, -0.06841165f, 0.03715279f, -0.02363639f, 
    0.03106650f, 0.04399035f, -0.05486627f, -0.05202800f, -0.02214457f, 0.08189324f, -0.04225807f, 0.01697662f, 
    -0.07556561f, 0.04072614f, 0.07590970f, -0.10639829f, -0.08331618f, 0.10746017f, -0.04083191f, 0.06513860f, 
    0.08968875f, -0.00753548f, 0.04626653f, -0.06858825f, 0.13974994f, 0.03368967f, -0.02843339f, 0.07947408f, 
    0.03716886f, 0.06333566f, 0.06720377f, -0.07176360f, 0.16793622f, 0.15673701f, 0.10290543f, 0.24448210f, 
    0.32005459f, -0.03653664f, -0.03971576f, 0.01158960f, 0.01909284f, 0.05271750f, -0.00645330f, 0.03224250f, 
    0.08348190f, 0.13525026f, -0.07537354f, -0.04594468f, -0.02933414f, 0.05975132f, 0.03159710f, -0.00449290f, 
    0.10443276f, 0.21079630f, 0.24921761f, -0.15379198f, 0.12003507f, 0.07626950f, -0.08829612f, -0.07225528f, 
    -0.14797035f, 0.00016220f, 0.21114394f, -0.04681226f, 0.05579746f, -0.11355293f, -0.13315721f, -0.11204230f, 
    0.02421420f, -0.07365054f, -0.08129699f, -0.11574762f, -0.45971993f, 0.10956216f, 0.10791375f, 0.05052906f, 
    -0.08542653f, 0.10197984f, -0.00920226f, -0.04098462f, -0.00829375f, 0.05212221f, -0.03501298f, -0.00215190f, 
    0.05459626f, 0.00949621f, 0.01600204f, 0.05570716f, 0.01076462f, 0.06577624f, -0.09321567f, 0.02761588f, 
    -0.25508749f, 0.02796908f, 0.00444758f, 0.02017142f, -0.00534870f, -0.07423606f, 0.00906383f, -0.01462694f, 
    0.09456754f, 0.07018621f, 0.13480283f, -0.03867742f, -0.00957555f, -0.06299962f, -0.10214212f, -0.05617693f, 
    0.08962735f, -0.20442319f, 0.07610131f, -0.00128524f, -0.12594715f, -0.09150354f, -0.01167042f, -0.04590716f, 
    0.03733852f, 0.08541273f, -0.05980506f, 0.12717524f, 0.03294826f, -0.05987475f, -0.02591393f, -0.03203365f, 
    -0.01958567f, 0.07800476f, 0.09500680f, -0.11711457f, -0.00925143f, -0.01488256f, 0.10676372f, -0.15723360f, 
    0.11961805f, 0.02404842f, -0.13124937f, -0.15193708f, 0.01749289f, 0.09677573f, 0.01051279f, -0.06235377f, 
    0.02539735f, 0.08445217f, 0.11391685f, 0.04134423f, -0.03993247f, -0.00440076f, 0.08006530f, 0.10872828f, 
    0.03847253f, 0.07071582f, -0.06904148f, 0.10556904f, -0.24390052f, 0.01356644f, -0.29562911f, -0.06542300f, 
    -0.06621087f, 0.05913023f, -0.01064099f, 0.05767412f, 0.09474759f, -0.00269635f, -0.11116720f, -0.12891990f, 
    -0.02255556f, -0.15065333f, -0.05574781f, 0.17659838f, 0.03622763f, -0.06064054f, -0.00485366f, -0.03461847f, 
    -0.07610270f, 0.01843232f, -0.02127927f, -0.08248366f, -0.13724786f, 0.14249656f, 0.01527878f, 0.03063696f, 
    0.12285401f, 0.13198256f, 0.07479313f, 0.09185972f, 0.12555338f, 0.10386256f, 0.09002899f, -0.00156554f, 
    -0.08066099f, -0.05368469f, -0.21174021f, -0.04079473f, -0.06221231f, -0.06664885f, -0.10062723f, -0.06636924f, 
    0.02993232f, 0.10622922f, 0.02677779f, 0.10623694f, -0.03910757f, 0.01667537f, 0.02236011f, 0.07671777f, 
    -0.22643605f, 0.09207650f, -0.06988356f, 0.07872177f, 0.06457232f, 0.02356793f, 0.13351186f, -0.00834555f, 
    -0.13737385f, -0.20055813f, -0.06354387f, 0.20450199f, 0.15132834f, -0.07025377f, -0.04672991f, 0.01003228f, 
    -0.08786605f, -0.14607337f, 0.13527137f, -0.07660007f, 0.08994235f, 0.11471861f, 0.10701478f, 0.04405046f, 
    -0.05619470f, -0.12826841f, -0.06014038f, 0.12161400f, -0.02486468f, -0.11617414f, 0.03499854f, 0.02564785f, 
    -0.08806482f, -0.13583861f, 0.06560488f, 0.11605626f, 0.03187224f, -0.01721186f, 0.02766912f, -0.01160110f, 
    0.05719508f, -0.05062136f, -0.06282694f, -0.11887219f, -0.03685702f, -0.07784669f, 0.21298470f, -0.03101756f, 
    0.07648282f, -0.04254013f, 0.10024393f, -0.07730135f, -0.03914817f, 0.07849797f, 0.05744812f, 0.02220999f, 
    0.03987265f, -0.04358831f, -0.01381439f, 0.09997193f, 0.09940946f, -0.05341659f, -0.01474043f, -0.10959013f, 
    0.19516337f, -0.00754539f, 0.02116094f, 0.07244292f, -0.16266227f, 0.12325081f, -0.09079327f, -0.07352085f, 
    -0.03027448f, -0.00342560f, -0.03293836f, 0.03716428f, -0.04244637f, 0.06756852f, -0.08439836f, 0.11960731f, 
    0.04812055f, -0.07147378f, -0.04697680f, 0.05549373f, -0.02576030f, -0.02406998f, -0.02472359f, -0.01647832f, 
    0.21881653f, 0.30321243f, 0.09081454f, 0.23202007f, 0.21732002f, 0.01941848f, 0.05328422f, -0.00862377f, 
    0.06458320f, 0.01981700f, 0.02645157f, -0.06189305f, 0.02006063f, 0.01943463f, -0.04489652f, 0.04165230f, 
    0.03452357f, 0.05734306f, -0.00042690f, -0.03028357f, -0.21196610f, -0.04272457f, -0.23933697f, -0.17777434f, 
    0.10530816f, 0.14028728f, 0.04007610f, -0.05128743f, 0.02957554f, 0.00055506f, -0.07000897f, 0.02765189f, 
    0.10656837f, 0.10620890f, 0.01176368f, -0.06651068f, 0.04572607f, 0.11137351f, -0.00940591f, 0.04292232f, 
    -0.09506945f, -0.00783340f, -0.13719407f, 0.02523685f, -0.03758204f, 0.01352210f, 0.02322873f, -0.07174306f, 
    -0.03000053f, 0.07493471f, 0.07509471f, 0.10424697f, -0.05396231f, 0.04963337f, -0.01908120f, 0.07396774f, 
    -0.02135207f, -0.00245199f, -0.12125508f, 0.10690986f, -0.09607744f, -0.08199768f, 0.12583792f, 0.06576447f, 
    -0.05769809f, -0.13284056f, 0.07857734f, -0.00120821f, -0.08366017f, -0.03725911f, 0.04253829f, 0.01829278f, 
    0.12824760f, 0.03100032f, 0.12527254f, -0.03453575f, -0.10637962f, -0.01500847f, 0.07894643f, 0.13369609f, 
    -0.12608255f, 0.17118055f, 0.14978623f, 0.02607055f, 0.09754314f, 0.02984199f, 0.02825746f, 0.15139630f, 
    0.08500804f, 0.05919355f, 0.00383578f, -0.00802987f, 0.05934040f, 0.02439916f, -0.08358841f, 0.11463072f, 
    0.11457383f, -0.11280956f, 0.12900071f, -0.07545578f, -0.40698656f, 0.10918825f, -0.02035576f, -0.12644152f, 
    0.03873424f, 0.03817412f, 0.00149186f, -0.02331627f, -0.03566236f, 0.04295884f, 0.01306995f, 0.09482735f, 
    -0.03298548f, 0.01222214f, 0.02319068f, -0.01412963f, 0.00304926f, 0.04525585f, -0.01183559f, 0.00221951f, 
    0.44018880f, 0.09536945f, -0.01010893f, 0.13087098f, 0.12293150f, -0.00272225f, -0.06350601f, 0.04064276f, 
    -0.00059700f, -0.01657214f, 0.03200993f, 0.00630800f, -0.08553240f, -0.07495406f, 0.10378182f, -0.06587853f, 
    0.10729971f, -0.01619796f, -0.01137072f, 0.01978680f, -0.03372952f, 0.02390128f, -0.19650775f, -0.04883727f, 
    0.13217662f, 0.09402490f, -0.03818871f, -0.04687719f, 0.10221961f, -0.01899927f, -0.05383469f, 0.12421302f, 
    -0.03223005f, 0.13112889f, -0.02598803f, 0.05330075f, 0.01184551f, 0.01341328f, -0.11696437f, 0.04574455f, 
    -0.23601927f, -0.14572972f, 0.21461245f, 0.03355718f, 0.24589890f, -0.02199171f, 0.00129014f, 0.07010923f, 
    -0.07574937f, 0.00979896f, -0.03115710f, -0.08442774f, 0.09280472f, -0.00901641f, -0.06798131f, -0.01632808f, 
    -0.00050519f, -0.04145536f, -0.04301786f, -0.07270286f, 0.17693558f, -0.18567379f, 0.03726451f, 0.05558486f, 
    0.02216033f, 0.01212858f, 0.17639244f, -0.10073832f, -0.08394657f, 0.00821081f, 0.13313261f, -0.00879115f, 
    -0.00695707f, -0.14227179f, 0.04773989f, -0.00361916f, -0.02255210f, -0.02620988f, 0.11255640f, 0.07206095f, 
    -0.23805851f, -0.07995965f, 0.10490444f, 0.02765961f, 0.19938046f, -0.00835727f, 0.09390164f, -0.01780707f, 
    -0.14129597f, -0.04410829f, 0.09918191f, 0.05828133f, -0.00574542f, 0.01553646f, 0.11050587f, 0.06407920f, 
    -0.00323779f, -0.03842825f, 0.18841504f, -0.12995629f, 0.12381575f, -0.16065507f, 0.06547859f, -0.07610005f, 
    0.24203910f, 0.04653579f, -0.10946897f, 0.04328585f, 0.04841956f, -0.03064930f, -0.04870177f, 0.01718588f, 
    0.06092937f, 0.08178417f, 0.02329007f, 0.03674897f, 0.05166332f, -0.03092382f, -0.00887675f, 0.05402315f, 
    -0.32174912f, 0.17796963f, 0.04387034f, 0.14091343f, 0.06010732f, -0.09554289f, 0.00888503f, 0.08786659f, 
    -0.00104213f, -0.00759073f, -0.08898429f, 0.02456768f, -0.16306141f, 0.03769013f, 0.00157005f, 0.08583298f, 
    -0.02037896f, 0.08197811f, 0.03317112f, -0.02716302f, -0.15167564f, -0.00599856f, -0.16007459f, 0.02924076f, 
    -0.13340077f, -0.01826975f, 0.00469828f, 0.01049233f, 0.04408477f, -0.05847842f, 0.03830434f, 0.02488258f, 
    -0.07874999f, 0.00913259f, 0.00993352f, 0.10993276f, -0.01582103f, -0.01302448f, -0.10362362f, 0.04760503f, 
    0.32754070f, 0.04523264f, -0.14343652f, -0.03523691f, -0.09345108f, -0.12572001f, 0.06775433f, -0.13303104f, 
    0.08770262f, -0.12535498f, 0.05308193f, 0.07924964f, 0.01444064f, 0.11711429f, -0.03948155f, -0.01940117f, 
    0.06934749f, -0.13496907f, -0.03364213f, -0.02496243f, 0.24070118f, 0.27145401f, -0.00064427f, 0.02916391f, 
    0.00299727f, 0.09571888f, 0.01783637f, 0.00017479f, 0.05978967f, -0.03094368f, 0.05916098f, -0.08258994f, 
    0.05399948f, 0.03862755f, 0.09162899f, 0.08842446f, 0.01562703f, -0.05486643f, -0.10702638f, -0.05794620f, 
    -0.25132906f, -0.21360171f, 0.13807741f, 0.06668499f, 0.00309093f, 0.03050353f, 0.01898340f, 0.11419049f, 
    0.03336833f, 0.18927109f, -0.02453306f, -0.06042616f, 0.00773613f, 0.08381820f, 0.01401181f, -0.07572593f, 
    0.08964515f, 0.02852375f, 0.04526020f, 0.05210596f, 0.34101370f, -0.23847342f, 0.28674021f, 0.18353803f, 
    0.04189153f, 0.10887241f, 0.04458512f, -0.05007280f, -0.00265877f, -0.04836067f, -0.03635007f, 0.07496670f, 
    -0.02243422f, -0.03854167f, -0.01849959f, 0.04892419f, 0.11245744f, -0.13459867f, 0.13306485f, -0.09284816f, 
    -0.10126096f, 0.40193763f, 0.15166841f, -0.07695366f, 0.11816017f, 0.13250436f, 0.06441123f, -0.03381602f, 
    -0.13222784f, 0.01005371f, -0.02886044f, 0.10357402f, 0.01827824f, 0.00840929f, 0.03882454f, 0.00798394f, 
    -0.15055466f, 0.01088991f, 0.04737975f, 0.02322452f, 0.39539421f, 0.05040610f, -0.20417912f, -0.10331073f, 
    -0.13590811f, 0.03046042f, 0.06278044f, -0.13717262f, 0.01414755f, -0.08488993f, 0.02671052f, 0.00478208f, 
    0.00557047f, -0.11367897f, 0.05469170f, -0.08840505f, 0.02332137f, -0.03354675f, 0.05713307f, 0.00730651f, 
    0.05193069f, 0.22354162f, -0.16641144f, 0.01575221f, 0.27418461f, -0.00531386f, 0.03405062f, -0.06263267f, 
    0.07233402f, -0.14069471f, -0.13075174f, 0.03483428f, -0.00818235f, 0.18025188f, 0.00082905f, 0.00898605f, 
    0.05477766f, 0.07158767f, 0.02747961f, -0.03802958f, 0.66725755f, -0.02269577f, -0.06443687f, -0.20495075f, 
    0.23418799f, 0.01762271f, -0.00613363f, -0.06701225f, -0.01651037f, -0.14947665f, 0.04099764f, 0.00196222f, 
    -0.03003978f, 0.01783445f, -0.05400116f, 0.02028773f, -0.03698023f, -0.10401892f, -0.01136595f, -0.06652004f, 
    0.04337212f, -0.03859507f, 0.10070531f, 0.01761959f, -0.06566405f, 0.01819351f, 0.02566395f, 0.04767702f, 
    -0.08803923f, -0.02783594f, 0.01247882f, 0.04218562f, 0.00830231f, -0.07232117f, 0.07392017f, 0.04638180f, 
    -0.11898917f, 0.18378608f, 0.00360393f, 0.02145715f, -0.08518057f, 0.52476680f, 0.00476516f, -0.05062260f, 
    0.24807627f, 0.03039145f, -0.04600948f, -0.10390010f, -0.02888943f, -0.11310685f, 0.05664876f, 0.04308451f, 
    0.13966905f, -0.01669547f, -0.05297788f, 0.05851899f, 0.08685733f, 0.09062248f, 0.01351052f, 0.12800306f, 
    -0.15784630f, 0.15157585f, 0.31646594f, 0.04587426f, 0.11269635f, 0.06399325f, -0.03239463f, 0.11885145f, 
    0.00302410f, -0.03850087f, -0.08605509f, -0.11555964f, 0.03264739f, 0.10639224f, -0.01656000f, 0.07545599f, 
    0.01656484f, -0.00155476f, 0.26267689f, -0.00135893f, -0.15344693f, 0.12983844f, 0.17808205f, -0.05422007f, 
    -0.07601423f, 0.11282623f, 0.10895888f, 0.03945724f, 0.04372580f, 0.00872546f, -0.04577659f, 0.07864495f, 
    0.12216312f, 0.13999720f, -0.06342927f, -0.15609194f, -0.02618106f, -0.03277931f, -0.05213608f, 0.00613204f, 
    -0.45349583f, -0.02096775f, 0.08569800f, -0.15819912f, 0.12177819f, -0.02748132f, 0.01869968f, -0.06981234f, 
    -0.01544520f, -0.06588520f, 0.07694777f, -0.07762761f, -0.01674699f, -0.05683940f, 0.00989458f, -0.03538009f, 
    -0.04927520f, 0.14989956f, 0.27290070f, 0.16321075f, -0.03659786f, 0.17076732f, 0.02925885f, 0.10258237f, 
    -0.15535843f, 0.05301962f, -0.00857945f, 0.07903264f, 0.05865523f, 0.10988016f, 0.07331061f, -0.06097821f, 
    -0.01653518f, 0.05306329f, 0.07680973f, 0.06373094f, -0.13645004f, 0.03730160f, -0.10377263f, -0.10746522f, 
    0.14217205f, -0.15997812f, -0.32425642f, 0.01268127f, 0.15445672f, 0.04507421f, 0.02936187f, -0.08902483f, 
    -0.03619587f, -0.03620017f, 0.05064288f, -0.02631180f, -0.02418070f, 0.00552123f, -0.01516543f, 0.09775867f, 
    -0.00810862f, 0.16710947f, 0.08640240f, 0.00863164f, 0.16306199f, 0.20270894f, -0.07219077f, 0.02319576f, 
    -0.11165392f, -0.07752106f, 0.03807377f, -0.05767299f, 0.09463070f, -0.06429734f, 0.03530097f, -0.05362368f, 
    0.04341276f, 0.03642073f, 0.07087412f, 0.06566548f, 0.00831440f, 0.17338838f, -0.06370448f, 0.02117816f, 
    0.24358548f, 0.14278905f, 0.15105307f, 0.07793709f, 0.16314419f, 0.03440418f, 0.13204280f, -0.02595505f, 
    -0.01353756f, -0.01909908f, 0.01043276f, -0.02947331f, -0.12534150f, 0.03110839f, 0.09919938f, 0.12391420f, 
    -0.05429684f, 0.17635448f, 0.13391513f, 0.01917074f, 0.15115854f, 0.18210925f, 0.08653393f, 0.10011366f, 
    -0.07817649f, 0.04465606f, 0.01167015f, -0.00208577f, 0.09764531f, -0.04060965f, -0.00982243f, -0.06097765f, 
    0.03125836f, 0.05124048f, 0.10271880f, -0.02806787f, 0.14016627f, -0.09589763f, -0.02917202f, 0.07197684f, 
    -0.07663447f, -0.00220675f, -0.07723075f, 0.07993731f, -0.14956775f, -0.05452568f, -0.02810779f, -0.02300101f, 
    0.00007295f, 0.00223133f, -0.01476977f, 0.05547727f, 0.08443093f, 0.04602876f, -0.04134835f, 0.08748819f, 
    0.08321199f, -0.07575253f, 0.01480145f, -0.07301123f, 0.06853634f, 0.09672652f, -0.08244228f, 0.04730709f, 
    0.05843828f, -0.06727697f, 0.05897182f, -0.04568510f, -0.02699001f, 0.02247452f, 0.06194647f, -0.01003759f, 
    -0.05762780f, -0.09556033f, 0.02442893f, 0.01486453f, -0.01265028f, 0.07123862f, 0.21234843f, -0.01475199f, 
    -0.01869939f, -0.00983037f, -0.04794699f, 0.07933048f, 0.18956985f, -0.02983207f, -0.04844504f, -0.02761984f, 
    0.00172405f, -0.03303119f, -0.11757631f, -0.06994677f, 0.00509177f, -0.04525242f, 0.12796278f, -0.03471774f, 
    -0.06671564f, -0.02941758f, 0.08935825f, -0.05329479f, 0.16279949f, -0.08769690f, -0.17756119f, 0.04636266f, 
    0.13570639f, -0.03002444f, 0.05038589f, -0.07278968f, 0.10807905f, -0.12736468f, 0.12154628f, -0.03751066f, 
    -0.05823951f, 0.02705237f, -0.13210213f, 0.06052270f, 0.13133760f, 0.10427561f, 0.04406903f, -0.10928937f, 
    0.04549117f, 0.04890161f, 0.18787009f, 0.03565892f, 0.15746911f, 0.18130259f, 0.03534685f, -0.01309526f, 
    0.02212938f, -0.03863633f, 0.01488513f, 0.10855438f, 0.00442029f, 0.10736482f, 0.09121267f, 0.00182672f, 
    -0.05833374f, 0.04931857f, -0.07510419f, -0.10663262f, 0.47842947f, -0.03924699f, -0.03996209f, -0.15494971f, 
    0.15560724f, 0.07414449f, 0.01232046f, -0.01258032f, -0.00685413f, -0.13209856f, 0.02845741f, -0.06322823f, 
    -0.05963324f, 0.07920928f, -0.07376225f, -0.00023959f, 0.06936064f, -0.03899256f, -0.07704604f, 0.01478181f, 
    0.01217892f, 0.05744760f, -0.14814568f, -0.01219385f, -0.15088716f, 0.05674648f, 0.13917993f, -0.13900697f, 
    -0.08204718f, -0.04680669f, -0.04607389f, -0.05712078f, 0.03919730f, 0.00803694f, 0.01022417f, -0.02425605f, 
    -0.03068767f, -0.01719284f, 0.00888425f, -0.10114689f, -0.14562228f, 0.44434628f, -0.07529178f, -0.28568044f, 
    0.19840069f, -0.09662743f, -0.06895077f, 0.00826177f, -0.08360186f, 0.05538864f, -0.01971078f, 0.05691961f, 
    0.04742407f, -0.16902278f, 0.02615263f, -0.06024615f, 0.11430573f, 0.11584821f, 0.18986662f, 0.05366820f, 
    0.11762691f, 0.03527231f, -0.06242201f, 0.04352462f, -0.12162068f, 0.07303893f, -0.00395250f, -0.13078310f, 
    0.10039439f, -0.03858954f, 0.04712816f, 0.03136455f, 0.08633279f, 0.00375857f, 0.04544397f, 0.02420153f, 
    -0.06489670f, 0.06972730f, -0.05148794f, 0.17280406f, 0.00760217f, -0.27171993f, -0.17303635f, -0.11233143f, 
    0.07430397f, -0.15751275f, -0.07445283f, -0.10697269f, 0.03357925f, 0.06086232f, -0.18113959f, -0.02641891f, 
    -0.00467567f, 0.13301025f, 0.13006866f, -0.01329780f, 0.01136140f, 0.04274339f, 0.02090056f, -0.04266428f, 
    0.15856133f, -0.07597084f, 0.01880053f, 0.13592382f, 0.06212738f, 0.04549440f, -0.13836038f, 0.02109621f, 
    0.12244095f, -0.02067989f, -0.09032699f, -0.08838616f, -0.08033542f, 0.04693129f, 0.10634279f, -0.07166134f, 
    0.10723377f, -0.02012190f, -0.22142960f, 0.05911990f, 0.10428359f, 0.47535411f, 0.04513045f, 0.09314352f, 
    -0.28545722f, 0.06012164f, 0.12182767f, 0.08815491f, -0.05520267f, -0.13138327f, -0.02537907f, -0.02345400f, 
    0.05200550f, -0.05878246f, 0.03755038f, 0.07207425f, 0.04340860f, -0.01398277f, 0.02689508f, 0.03884021f, 
    -0.00219052f, 0.38411036f, -0.15129773f, -0.10193080f, -0.05591691f, 0.08014218f, 0.05758170f, 0.06858931f, 
    -0.02851310f, 0.04039500f, 0.14907558f, 0.05403864f, 0.05088808f, -0.03770134f, -0.01922975f, -0.07016149f, 
    0.17055883f, -0.03085259f, 0.07264475f, 0.04604169f, 0.29877868f, -0.11262569f, 0.04112473f, -0.00804350f, 
    0.09175038f, -0.13566785f, -0.00868716f, -0.03903479f, -0.06857426f, -0.09466980f, -0.03137920f, 0.01598045f, 
    -0.00975746f, 0.14405993f, -0.00849552f, 0.07855360f, 0.04257169f, 0.07585460f, 0.08935007f, 0.08320807f, 
    0.14135408f, -0.13093269f, 0.02275549f, 0.01639748f, -0.09106410f, 0.08349355f, -0.20901260f, 0.04087552f, 
    -0.08331926f, 0.05033851f, -0.00014124f, 0.01184468f, -0.10097136f, 0.05242629f, 0.04210074f, 0.00841575f, 
    -0.04168350f, 0.16489705f, 0.10369902f, 0.08281261f, -0.45141193f, -0.02029406f, -0.01347947f, -0.01763285f, 
    -0.03095946f, 0.01519212f, -0.04889673f, -0.01784058f, -0.04600528f, 0.11156347f, 0.03053518f, 0.13556474f, 
    0.05386899f, -0.05020796f, 0.10453828f, -0.01035884f, 0.08310659f, 0.03040854f, 0.09348558f, 0.01193742f, 
    0.02324148f, 0.48246512f, 0.11970349f, -0.04749857f, -0.29497063f, 0.06061135f, 0.07301372f, 0.06110120f, 
    -0.02165764f, -0.19995977f, 0.00627654f, 0.05760294f, 0.06013402f, -0.10314368f, -0.00223466f, 0.10781281f, 
    0.06710439f, -0.06072693f, 0.06745628f, 0.00163549f, -0.25974479f, -0.18984982f, -0.06417544f, -0.08565041f, 
    -0.07253183f, -0.06365032f, 0.07149784f, -0.16117370f, 0.10467674f, 0.11326967f, 0.07103530f, 0.01999214f, 
    0.00249056f, 0.11444429f, 0.04828244f, -0.01487817f, 0.06773569f, 0.09917963f, -0.06018813f, 0.13747616f, 
    -0.14438790f, -0.18975997f, 0.07002591f, 0.04625585f, -0.04561337f, 0.01676967f, 0.13791397f, -0.00598232f, 
    0.06624184f, -0.03352867f, -0.00621979f, 0.06626157f, 0.00338014f, 0.06315105f, 0.03111010f, -0.13081667f, 
    0.04183918f, 0.01567334f, -0.03338594f, 0.04104250f, -0.24468856f, -0.22139962f, -0.00894090f, -0.10702956f, 
    -0.10404852f, 0.01168935f, -0.11743193f, 0.06264655f, 0.00317249f, 0.04233037f, -0.05000430f, -0.13448171f, 
    -0.07410369f, 0.08118556f, 0.02338542f, 0.05711526f, 0.00687255f, 0.16265862f, -0.06431255f, 0.08380877f, 
    0.23461546f, -0.31051922f, 0.00706292f, 0.35903051f, -0.29033574f, -0.17879927f, -0.01433577f, -0.04714862f, 
    -0.13579567f, 0.00354622f, 0.13731608f, 0.02935184f, -0.05894923f, 0.02744756f, 0.07884613f, 0.02353535f, 
    -0.09162486f, -0.12111762f, -0.12310507f, 0.02851800f, 0.09059739f, -0.04992881f, -0.06250634f, 0.19440866f, 
    -0.02904834f, -0.16939974f, -0.04320187f, -0.03003059f, -0.05798768f, 0.12574777f, 0.06457328f, -0.01560564f, 
    0.01794348f, 0.03679581f, 0.01693027f, 0.01599436f, -0.02239992f, -0.05673850f, 0.01980667f, 0.00128424f, 
    0.13255763f, 0.10590729f, -0.06417076f, -0.13172740f, -0.07272794f, 0.03047618f, 0.16178533f, 0.05927438f, 
    0.13582508f, -0.11552354f, -0.03035888f, 0.04362502f, -0.03731490f, 0.07279606f, -0.00687580f, 0.10604679f, 
    -0.01676401f, -0.03873422f, -0.04364118f, 0.07109525f, 0.11061686f, -0.03545638f, 0.16220711f, 0.00824918f, 
    0.15250175f, 0.00813144f, 0.00587461f, 0.07414181f, -0.04027394f, 0.02361929f, -0.10991500f, -0.21074806f, 
    -0.05472146f, 0.07165931f, -0.03866568f, 0.04847660f, -0.10838301f, -0.05587921f, -0.00857743f, 0.04042849f, 
    0.32589966f, 0.22729731f, 0.14847754f, -0.08564830f, -0.09566130f, 0.11002311f, 0.21694116f, 0.12585160f, 
    0.21301119f, 0.08477043f, 0.09087097f, 0.08620834f, -0.05765182f, -0.12156514f, -0.03602230f, -0.07279693f, 
    -0.07628071f, -0.11607645f, -0.09567051f, 0.06562597f, -0.00206864f, 0.17024264f, 0.03304269f, -0.15059760f, 
    -0.05338007f, -0.11344182f, -0.04131257f, 0.04230003f, 0.05774034f, -0.00732082f, 0.08205377f, 0.05739032f, 
    -0.04725483f, -0.01687686f, 0.04415143f, 0.11247420f, 0.07917257f, -0.09317447f, 0.08193004f, -0.09531934f, 
    0.24425708f, 0.00821348f, 0.11398653f, 0.18500797f, 0.14658862f, -0.03468500f, -0.16860639f, 0.01803950f, 
    0.02192339f, 0.07215196f, 0.03307453f, 0.03206591f, 0.09507885f, 0.06052904f, -0.03366980f, 0.09087656f, 
    -0.03969266f, -0.14605504f, -0.21081202f, -0.04807901f, 0.21359891f, -0.08173020f, 0.12560599f, -0.10513870f, 
    0.10468538f, -0.12546849f, 0.12766889f, -0.13197060f, -0.05828351f, -0.07482623f, -0.08731581f, 0.06652237f, 
    -0.13393651f, 0.01561800f, 0.01037091f, -0.03798508f, 0.06050892f, -0.02382826f, -0.05388290f, 0.06016604f, 
    0.07428808f, 0.01248443f, -0.10389001f, 0.05731931f, 0.09810069f, -0.02411133f, -0.24039283f, 0.01308552f, 
    0.07106231f, 0.03799100f, -0.14387950f, -0.05787981f, -0.11914415f, 0.09562032f, 0.16016437f, -0.09235348f, 
    0.03777753f, -0.11268330f, 0.00759943f, -0.07278467f, 0.17626561f, 0.00423975f, -0.07204849f, 0.09542254f, 
    0.25830835f, 0.05314378f, -0.00704855f, 0.02607226f, -0.03768941f, 0.18512252f, -0.04798038f, 0.08575121f, 
    0.00254414f, -0.00412797f, -0.04842602f, 0.13999568f, -0.04573627f, -0.13574266f, -0.04671163f, -0.23239739f, 
    0.13686173f, 0.24106003f, 0.07787718f, 0.28351778f, -0.06442270f, 0.17735012f, 0.13941154f, 0.16960411f, 
    -0.05345469f, 0.15448841f, -0.06841908f, -0.04224931f, 0.03369259f, 0.05348150f, -0.04688609f, -0.03615400f, 
    -0.00392723f, 0.01793441f, -0.07460862f, -0.15363459f, -0.19401456f, 0.13031249f, 0.33994955f, 0.08099473f, 
    -0.11569557f, 0.04881627f, 0.01049602f, 0.03156602f, -0.12354225f, -0.09764233f, 0.01706797f, -0.01612831f, 
    0.06657933f, 0.04928540f, -0.09273878f, 0.03847101f, -0.10024580f, 0.02709826f, 0.14874667f, -0.10230533f, 
    -0.01111449f, 0.13062316f, 0.19740699f, -0.19911645f, -0.08674254f, 0.02670253f, 0.01453541f, -0.00045976f, 
    -0.13386513f, -0.12103517f, 0.00969172f, -0.01425446f, -0.06165180f, -0.00353352f, 0.02735613f, 0.02788288f, 
    0.02000915f, 0.15576540f, 0.12234531f, 0.06717602f, 0.26604342f, 0.00708690f, 0.08764715f, 0.11731151f, 
    0.10830521f, 0.03472379f, -0.11500664f, 0.00230420f, -0.01242060f, 0.04290465f, -0.06475610f, -0.02850187f, 
    -0.03020069f, 0.01214287f, 0.03945202f, -0.08766987f, 0.11846723f, -0.10408112f, -0.21775988f, -0.10171217f, 
    0.11539824f, 0.21430092f, -0.00277674f, 0.12076712f, -0.31871921f, 0.17908745f, 0.16975030f, 0.08797311f, 
    0.03687597f, 0.01665414f, 0.08812711f, 0.11365751f, 0.05350426f, 0.09676277f, -0.14824662f, 0.07428988f, 
    0.04951603f, 0.10430387f, -0.00064213f, 0.00542173f, 0.07068501f, 0.07500524f, -0.16831134f, 0.07003217f, 
    0.19737092f, 0.02327931f, -0.19292118f, 0.00315088f, -0.11712012f, 0.15554048f, -0.07419297f, 0.01758390f, 
    -0.03143683f, 0.05728651f, 0.08760229f, 0.08775436f, -0.12978643f, -0.02638208f, -0.00890768f, -0.16068611f, 
    0.00610000f, -0.08280843f, 0.07260002f, -0.01650268f, -0.20202681f, -0.04217891f, 0.13259593f, 0.17675611f, 
    -0.00605046f, -0.17466788f, -0.01892706f, 0.06907997f, -0.04472131f, -0.01300872f, 0.03811971f, 0.04228779f, 
    -0.00216319f, -0.06647589f, 0.05746311f, 0.16496243f, 0.14399706f, 0.01481558f, -0.12765869f, 0.17146042f, 
    -0.00049337f, -0.12691294f, -0.05670744f, 0.00180114f, -0.00669724f, 0.03454136f, 0.05466614f, 0.03928633f, 
    0.08617020f, -0.00621763f, 0.02036764f, 0.00837556f, -0.04846314f, -0.05397718f, 0.02455129f, 0.08991634f, 
    -0.07366066f, -0.21956156f, -0.00388051f, -0.11694700f, 0.07972617f, -0.17115146f, -0.12950651f, -0.01359270f, 
    -0.10118184f, 0.01489453f, 0.01097959f, -0.06932511f, -0.10117347f, -0.07192776f, 0.03467843f, 0.04871177f, 
    -0.04835515f, 0.07077293f, -0.03970335f, 0.15497525f, 0.10001107f, -0.13128498f, 0.35318986f, 0.32467031f, 
    0.09847353f, -0.00467536f, -0.05436628f, -0.15540382f, -0.04982980f, -0.01716435f, 0.04026998f, -0.02728450f, 
    0.03006687f, 0.08575591f, -0.01427517f, 0.01772483f, -0.09845826f, -0.08042519f, -0.22910042f, -0.06923740f, 
    -0.03256546f, 0.02394204f, -0.04160841f, -0.02328380f, 0.03149324f, 0.02719695f, -0.02643261f, 0.01999793f, 
    -0.01250096f, -0.00801670f, 0.01161158f, 0.00114234f, -0.01312174f, -0.03921343f, 0.03175499f, -0.00044215f, 
    0.02696563f, 0.01884013f, -0.03415776f, 0.01757703f, -0.00815732f, -0.01986575f, -0.04335872f, 0.01589163f, 
    -0.01463182f, -0.03977094f, -0.01698208f, 0.01124883f, 0.00937950f, 0.01184898f, -0.00591985f, -0.03359879f, 
    -0.04322850f, -0.00013964f, 0.00653455f, 0.00996642f, 0.00596548f, -0.02609096f, 0.02650142f, -0.01809367f, 
    -0.01848708f, -0.03491674f, 0.01720790f, 0.00598819f, 0.02643536f, -0.04260687f, -0.01686465f, -0.00088728f, 
    -0.00981484f, 0.01785677f, 0.01462106f, -0.02460088f, -0.03009326f, -0.03318981f, 0.00985914f, -0.00528508f, 
    -0.01941222f, 0.02483412f, -0.00788854f, -0.02861351f, 0.01555460f, -0.02571239f, 0.01033841f, 0.01527049f, 
    -0.02041976f, -0.01746815f, -0.01704129f, -0.04262912f, -0.04353117f, 0.02158263f, -0.02422527f, 0.00612091f, 
    0.02004283f, -0.03172392f, -0.02782687f, 0.02223860f, 0.02755900f, -0.03305342f, -0.03758082f, 0.00198784f, 
    0.00344615f, -0.03688653f, 0.00602201f, 0.02783550f, -0.03434121f, -0.03724023f, 0.00496502f, 0.03227174f, 
    0.01191330f, -0.01940151f, -0.03656937f, 0.02321952f, 0.01487594f, -0.04350829f, 0.00799572f, 0.03309173f, 
    -0.00828360f, 0.03061719f, 0.03230852f, 0.00459991f, -0.03683148f, -0.03082789f, -0.00419699f, 0.02467212f, 
    -0.04264603f, 0.01814107f, 0.02681814f, -0.03482318f, -0.00092390f, -0.02873277f, -0.02676662f, -0.02433818f, 
    -0.04329756f, 0.01472272f, -0.03308563f, -0.01832099f, -0.02210481f, 0.02956399f, 0.01093535f, -0.00967620f, 
    -0.02223726f, 0.00410908f, 0.02526327f, -0.02400360f, 0.01552181f, 0.03097702f, 0.01760864f, -0.01667859f, 
    0.00299774f, 0.02746113f, 0.02724888f, -0.01188401f, 0.02011199f, -0.00026979f, 0.02273995f, -0.02213644f, 
    0.02113883f, 0.00903882f, -0.02292704f, 0.01754712f, 0.00985692f, -0.00854347f, 0.01286618f, 0.02373404f, 
    -0.01585517f, 0.02778942f, -0.03556928f, -0.04382736f, -0.01703727f, -0.01052134f, 0.01263437f, -0.04152280f, 
    -0.01370129f, -0.03098772f, 0.01062810f, 0.00735756f, -0.02355644f, -0.03323379f, 0.03205992f, -0.02405464f, 
    -0.01372429f, 0.01507597f, 0.02494192f, -0.02389953f, -0.00337130f, -0.01056060f, -0.02716673f, 0.00951033f, 
    -0.03439587f, -0.00454003f, -0.03040828f, 0.03238213f, -0.02370663f, 0.02888484f, 0.01077109f, 0.00583121f, 
    -0.01729749f, -0.02584533f, -0.03731041f, 0.03136698f, -0.01704235f, 0.01041308f, 0.02756730f, 0.02099144f, 
    -0.00493577f, 0.03219973f, -0.02763709f, 0.01415889f, -0.01583226f, -0.03538349f, 0.01032656f, 0.03301072f, 
    -0.03648209f, 0.03041036f, -0.03235003f, -0.01444843f, -0.04552052f, -0.02862621f, -0.02319975f, -0.02690689f, 
    -0.00809642f, -0.01639210f, -0.01440187f, -0.02802072f, -0.01188283f, -0.03212384f, -0.02741591f, -0.02364418f, 
    -0.01774614f, -0.04521256f, 0.01211509f, -0.03984008f, -0.00912451f, -0.01146451f, 0.00898875f, 0.01372395f, 
    -0.03603506f, 0.00301842f, 0.02513941f, -0.02197703f, -0.00954565f, 0.00718071f, -0.01974309f, -0.01106908f, 
    -0.02052748f, -0.03983840f, 0.01625681f, -0.00192553f, -0.01409998f, 0.00840091f, -0.01130148f, -0.03962651f, 
    0.00199803f, -0.00894671f, -0.03075953f, -0.04279777f, 0.03222144f, 0.00039084f, 0.00802101f, -0.02209289f, 
    -0.00938915f, -0.00199967f, -0.00300524f, -0.02670300f, -0.02165970f, -0.00948853f, -0.03790569f, -0.04318944f, 
    -0.01755806f, 0.02360564f, -0.00444613f, 0.00179396f, 0.01974765f, -0.03517016f, 0.01774682f, -0.00363207f, 
    -0.03043164f, -0.01091123f, -0.02154597f, 0.00566849f, 0.00625604f, -0.03624707f, 0.02340573f, 0.00066778f, 
    -0.03772713f, -0.03114698f, -0.03947670f, -0.02072507f, 0.01016124f, 0.02654426f, 0.00049554f, -0.02206861f, 
    0.01025845f, 0.00818479f, 0.01426577f, -0.04543782f, 0.00621434f, 0.01359862f, -0.04371501f, -0.03335588f, 
    -0.02522953f, 0.00865147f, -0.02315683f, -0.01903538f, -0.03892588f, -0.04066974f, -0.01520829f, -0.00230165f, 
    0.03030108f, -0.02726158f, -0.00267118f, 0.02999359f, 0.01119088f, -0.04378588f, 0.01060059f, -0.00042456f, 
    0.00379044f, -0.01914958f, -0.01345488f, -0.04048320f, 0.00006155f, 0.00640114f, -0.03766650f, -0.02504177f, 
    0.01644514f, -0.00526923f, -0.00458631f, 0.00154401f, 0.01707494f, 0.03081412f, -0.03338000f, -0.04033091f, 
    -0.04226514f, -0.03729685f, 0.01364734f, -0.02998502f, -0.00430184f, -0.03120561f, -0.04362433f, 0.02351750f, 
    0.02321914f, 0.02182266f, 0.00501740f, -0.02973102f, 0.00549475f, -0.02637747f, -0.03931473f, -0.00356051f, 
    0.02793484f, -0.00681337f, 0.03295949f, -0.02737666f, 0.02956373f, -0.03711673f, -0.00319850f, -0.00162937f, 
    0.02312449f, -0.02325418f, 0.03197584f, -0.00451855f, -0.02277395f, -0.03241300f, -0.01470857f, 0.02129927f, 
    -0.00171267f, 0.00707120f, 0.01723447f, -0.04145193f, 0.03252522f, -0.03164147f, -0.00144834f, -0.00337260f, 
    -0.00997896f, 0.01129133f, -0.02660949f, -0.01253588f, -0.00745042f, 0.02031484f, -0.03673058f, 0.00842283f, 
    -0.03386867f, 0.00522706f, 0.00113446f, -0.02305894f, -0.01674997f, 0.02983052f, -0.02694236f, 0.03294514f, 
    -0.00110437f, 0.02383937f, 0.02758557f, -0.00026908f, 0.02658206f, -0.02953819f, 0.01834383f, 0.00777208f, 
    -0.01393432f, -0.02125747f, -0.00578248f, 0.02596086f, -0.00017887f, 0.00092929f, -0.02524816f, 0.02728054f, 
    -0.02956745f, -0.00249130f, 0.00068724f, 0.01725571f, -0.00241120f, 0.00853256f, 0.01540238f, 0.01022404f, 
    -0.01558084f, -0.04211748f, -0.00386263f, -0.03791957f, 0.02592473f, -0.01409605f, -0.01968935f, -0.00635064f, 
    -0.01446254f, 0.02167946f, -0.00110825f, -0.04091076f, -0.01511431f, -0.02929363f, 0.03056582f, 0.01536198f, 
    -0.01515241f, -0.01811891f, -0.02532089f, -0.03317245f, -0.03231700f, -0.03057722f, 0.01944028f, -0.02352331f, 
    -0.01863320f, -0.02630300f, -0.03717981f, 0.02840103f, 0.02665428f, -0.00395450f, -0.02977453f, -0.01825835f, 
    -0.04127181f, -0.02713718f, -0.03922632f, 0.01146210f, 0.01076241f, -0.02985075f, -0.01183504f, 0.01360139f, 
    -0.01490806f, -0.03511648f, 0.01905825f, -0.02759109f, -0.02096226f, -0.01290272f, 0.01888500f, 0.01418963f, 
    0.01284777f, 0.01540330f, 0.01241893f, 0.03278757f, -0.00531634f, -0.00951074f, -0.02271603f, 0.00221308f, 
    -0.00312555f, 0.02236556f, -0.02210254f, -0.01483268f, -0.00109657f, -0.04204254f, -0.02431606f, 0.02850538f, 
    0.01774801f, 0.00487782f, 0.03321619f, -0.00015713f, 0.02892273f, 0.01024136f, -0.00705960f, 0.01538736f, 
    0.00973133f, -0.01267584f, -0.02618223f, -0.03442792f, 0.02183561f, 0.00575569f, 0.02568048f, -0.02464388f, 
    -0.04056448f, -0.01649305f, 0.01127976f, 0.01791362f, 0.02145660f, -0.03290287f, -0.03385052f, 0.02199508f, 
    -0.02434984f, -0.01039203f, -0.00839319f, 0.00043189f, -0.01319477f, -0.02756482f, -0.00577982f, -0.01810255f, 
    -0.04145112f, -0.03524620f, 0.02648045f, -0.03810485f, -0.02834304f, 0.03295254f, -0.03916734f, -0.02120419f, 
    -0.03671642f, 0.03151209f, 0.01730323f, -0.04376548f, -0.01837900f, -0.02891146f, -0.02960466f, 0.03336330f, 
    -0.00023719f, -0.00266511f, -0.03873600f, -0.00558641f, 0.00542586f, 0.03092432f, -0.03689290f, 0.02906647f, 
    0.00548734f, 0.02114573f, 0.00747232f, -0.02059443f, 0.01172565f, -0.00520283f, 0.01902649f, 0.00391026f, 
    -0.02791770f, 0.00336454f, -0.01667693f, -0.01356507f, -0.03599818f, -0.04493304f, 0.03050395f, -0.01605543f, 
    0.03116206f, -0.04190570f, -0.01429894f, -0.03597229f, -0.03649554f, -0.03957327f, 0.03045999f, -0.00874663f, 
    -0.01611105f, 0.02164833f, 0.00805620f, 0.00004605f, -0.04057567f, 0.03103345f, -0.03339138f, 0.00070196f, 
    0.01187569f, -0.01571665f, 0.02052798f, 0.00875318f, -0.00987576f, -0.02015959f, -0.01938770f, 0.03265292f, 
    -0.02057422f, -0.03917573f, -0.04350095f, -0.03234253f, 0.00341001f, 0.01359982f, -0.02849618f, -0.00960869f, 
    -0.00136348f, 0.00050446f, -0.03789096f, 0.01868167f, -0.01081724f, -0.00880379f, -0.01393400f, 0.00194145f, 
    0.02529071f, -0.02125711f, 0.03077377f, 0.01687212f, -0.03306743f, -0.01302641f, -0.04516954f, -0.02812454f, 
    -0.03880846f, -0.00832746f, -0.00106317f, 0.01195406f, -0.00907828f, 0.00059250f, -0.02762221f, -0.01305533f, 
    -0.03109992f, 0.02246324f, -0.00030341f, 0.00526372f, -0.04281472f, 0.00483263f, -0.00531963f, -0.02836799f, 
    -0.01749822f, 0.03035243f, -0.03517596f, -0.01397892f, 0.02822163f, -0.01158375f, 0.00765677f, 0.01921740f, 
    0.03240106f, 0.02788109f, 0.02677365f, -0.01269561f, -0.00731256f, -0.04026368f, -0.02646972f, -0.03108536f, 
    -0.01493424f, -0.01848381f, -0.03473018f, -0.01393963f, -0.02050012f, 0.00555677f, -0.00299026f, 0.02718673f, 
    0.03066349f, -0.00261161f, 0.02029808f, 0.00428472f, -0.03525667f, -0.02819084f, 0.01285605f, -0.03189564f, 
    -0.03583263f, -0.03286030f, 0.02179599f, 0.02633590f, -0.01519818f, -0.02293403f, 0.00288718f, -0.01531898f, 
    -0.02496096f, -0.03758263f, 0.01072212f, -0.03208989f, -0.03875336f, -0.02111381f, 0.02091734f, -0.02838963f, 
    0.00082936f, -0.14223321f, 0.10452024f, -0.21636824f, 0.04077213f, 0.04302740f, 0.05498584f, -0.06547461f, 
    -0.00063278f, -0.02851116f, -0.06060309f, 0.02133234f, -0.02161354f, 0.02162478f, 0.05540881f, -0.09547227f, 
    -0.09041017f, -0.05349660f, 0.11413597f, 0.03479826f, 0.47786760f, 0.11657337f, -0.04531614f, 0.03994356f, 
    0.17522852f, 0.10483850f, 0.10519784f, -0.05351025f, -0.01848934f, -0.08171371f, -0.09962922f, -0.05527367f, 
    -0.04002918f, 0.04999905f, -0.11534897f, 0.01930380f, -0.00299962f, 0.06900973f, -0.00892500f, -0.02800553f, 
    -0.13041742f, -0.15181555f, -0.00962796f, -0.08845235f, -0.08801105f, -0.05875190f, 0.08646668f, 0.02177964f, 
    0.05743655f, 0.02606017f, 0.04930539f, -0.01077344f, 0.06540201f, 0.01257023f, -0.05225346f, 0.02781913f, 
    0.02895012f, -0.16765322f, -0.08883128f, 0.04845599f, -0.00884172f, 0.13172519f, 0.11716870f, -0.05942702f, 
    0.12284701f, 0.01262067f, -0.02070352f, 0.06022464f, 0.04246541f, 0.06468838f, 0.02014836f, 0.03557834f, 
    -0.09154714f, 0.08951379f, 0.00574140f, 0.01980823f, 0.11007377f, -0.06004695f, 0.01306126f, 0.00416253f, 
    0.23659323f, -0.02048982f, 0.10718802f, -0.04852533f, 0.03747817f, 0.04017362f, -0.03802139f, 0.03046855f, 
    0.04120226f, 0.22298542f, 0.07390662f, -0.01823812f, -0.07989700f, -0.06654254f, 0.06358641f, 0.17863148f, 
    -0.13374099f, -0.01536096f, 0.00453866f, -0.04629485f, 0.44568428f, 0.24147138f, -0.00502853f, 0.09697452f, 
    0.20435470f, 0.05941441f, 0.02875575f, -0.02639781f, 0.00858469f, 0.04535062f, -0.02121432f, 0.01957184f, 
    -0.04947923f, -0.00691760f, 0.08613018f, -0.06984066f, 0.01615125f, 0.04614122f, 0.03511401f, 0.00324299f, 
    0.22262332f, 0.06132420f, 0.11068612f, -0.05720308f, 0.12451937f, 0.02084289f, 0.07706627f, -0.08538814f, 
    0.00387811f, -0.07038955f, 0.01330973f, 0.03513118f, 0.04456092f, -0.04051419f, -0.12516135f, -0.05808447f, 
    0.07087556f, -0.04792076f, -0.01580659f, -0.05171799f, 0.01509841f, -0.21819331f, -0.02381378f, -0.00689071f, 
    -0.04078487f, -0.00954431f, -0.06341217f, 0.04741221f, -0.04161207f, -0.05002873f, -0.00776545f, -0.08479179f, 
    0.03135175f, 0.05685650f, 0.01453357f, 0.14062655f, -0.04464185f, -0.06840133f, 0.01125347f, 0.06440070f, 
    0.15465108f, -0.06664638f, 0.13687725f, -0.04184637f, 0.13557303f, 0.04677464f, 0.03546432f, -0.01774710f, 
    0.04946619f, 0.14574818f, -0.03722036f, -0.01844652f, -0.07584923f, -0.00322411f, 0.07583157f, -0.01961657f, 
    -0.01784780f, -0.08713090f, 0.00676663f, 0.04888738f, 0.42969072f, -0.24092002f, 0.01259223f, -0.06380793f, 
    0.06652322f, 0.00877381f, 0.01857655f, -0.08281364f, -0.03253822f, -0.07753169f, 0.04508632f, -0.02820730f, 
    0.05133652f, -0.02613210f, 0.04293349f, -0.05516697f, -0.04010336f, -0.03328427f, 0.10428146f, 0.01595448f, 
    0.03896322f, 0.15213144f, 0.10985325f, 0.10126391f, -0.07506210f, 0.11473843f, 0.08094887f, 0.03609033f, 
    0.05202772f, 0.02414551f, 0.00878535f, -0.04856738f, 0.01582466f, 0.06345811f, -0.03723408f, 0.08203799f, 
    0.02794330f, 0.04816637f, -0.02550874f, -0.02470170f, 0.31250143f, 0.28923953f, 0.07849059f, -0.00351433f, 
    0.12736395f, -0.02376849f, 0.08305218f, -0.02397430f, -0.04101397f, -0.06138187f, 0.04726136f, 0.02251077f, 
    -0.01424746f, 0.06556804f, -0.03686186f, 0.03246882f, 0.08229588f, -0.03433479f, -0.01825583f, -0.03492497f, 
    0.33401924f, -0.06567697f, -0.05305189f, -0.23802267f, -0.10112549f, -0.00877776f, -0.09105551f, -0.03364505f, 
    0.00802527f, -0.04791217f, 0.05640279f, -0.01841420f, 0.12491556f, 0.12608296f, -0.13785486f, -0.08895551f, 
    0.21540169f, 0.02226112f, 0.05243917f, -0.00734223f, -0.04226615f, 0.22695197f, -0.02483481f, -0.11660131f, 
    -0.07377594f, 0.12757663f, -0.08875158f, -0.06293181f, 0.02934862f, -0.01257621f, 0.09625262f, 0.05735144f, 
    0.02275192f, 0.06264879f, 0.05356478f, 0.18696290f, 0.00184683f, 0.12842198f, -0.04847990f, 0.13748521f, 
    -0.01934323f, 0.06372228f, 0.10009927f, 0.04844091f, 0.08062762f, 0.00939918f, -0.02371755f, -0.02426441f, 
    0.04346370f, 0.06983722f, 0.10236575f, -0.05867469f, 0.00813171f, 0.01026874f, 0.04228103f, 0.02707994f, 
    0.03102980f, -0.02140975f, 0.07440950f, 0.09272534f, -0.13885313f, 0.05803803f, -0.03266334f, 0.05319475f, 
    -0.09185892f, 0.15422119f, 0.00743893f, 0.09134924f, 0.17743380f, -0.00369703f, -0.04333371f, -0.05410046f, 
    0.03299111f, 0.05258467f, 0.12373794f, -0.00970275f, 0.00222032f, 0.04479163f, 0.01543035f, -0.03931323f, 
    -0.00646597f, 0.12803881f, -0.11942938f, -0.06862509f, -0.02200074f, 0.03042832f, 0.07220624f, 0.03215059f, 
    -0.06760108f, -0.01507038f, 0.07056078f, -0.04703030f, -0.09222778f, 0.06071847f, 0.15167469f, 0.08471561f, 
    -0.02746246f, 0.02004732f, -0.01230801f, 0.02725218f, 0.01758228f, -0.23763332f, -0.01896515f, 0.10996870f, 
    0.04412232f, 0.08524834f, 0.06204230f, -0.09491459f, -0.03616331f, 0.10583097f, 0.00544856f, -0.04757742f, 
    -0.01013916f, 0.04937863f, -0.00091961f, 0.19120374f, 0.04345430f, -0.10538232f, 0.00302981f, 0.15397927f, 
    -0.07771907f, -0.11966959f, -0.03291113f, -0.05016160f, -0.01871929f, -0.01401879f, -0.02571016f, 0.00773661f, 
    0.05102437f, 0.03181857f, 0.04307658f, 0.03810738f, -0.03670826f, 0.07360498f, -0.01297816f, -0.02522916f, 
    0.01295496f, -0.00609147f, -0.06785160f, -0.07246566f, -0.12984842f, 0.20358716f, -0.20161937f, 0.04336438f, 
    -0.17150791f, 0.09655042f, -0.01335800f, 0.08452363f, 0.05242185f, -0.01894020f, 0.05104307f, 0.05895217f, 
    -0.05501182f, 0.05745983f, -0.06808262f, 0.05041606f, 0.03638296f, 0.00935258f, 0.11554980f, -0.04665305f, 
    0.11521328f, 0.01396947f, -0.10430150f, -0.43671519f, -0.01770809f, -0.04657980f, 0.00153579f, 0.03534968f, 
    -0.04503671f, -0.09855970f, 0.19093861f, 0.02145687f, 0.06231321f, -0.04013481f, 0.05639561f, 0.00842838f, 
    0.02151120f, 0.03230994f, 0.00607630f, 0.00536119f, -0.19248140f, -0.16553114f, 0.26768082f, -0.04299776f, 
    -0.21457404f, -0.01180445f, -0.00731411f, -0.01676652f, 0.04590347f, -0.04717427f, 0.09042434f, 0.04009136f, 
    0.03949062f, 0.07153311f, 0.07465497f, -0.07958198f, 0.01222999f, -0.03283888f, -0.00897605f, -0.03903263f, 
    0.01602639f, -0.05447771f, 0.22898616f, 0.03388638f, 0.00364751f, 0.14038400f, 0.05391713f, 0.02875570f, 
    -0.08969570f, -0.02231089f, 0.04052953f, -0.02975232f, 0.01778544f, 0.16017814f, 0.07605693f, 0.01036070f, 
    0.00545833f, -0.02409150f, -0.08633321f, 0.04287001f, 0.01081159f, -0.16857888f, 0.04095374f, -0.06104906f, 
    0.14833677f, 0.01456687f, -0.04217634f, 0.03738911f, -0.00127036f, 0.05243144f, 0.03927669f, 0.05919611f, 
    0.06105849f, 0.04316457f, 0.07610239f, 0.13644123f, 0.02468308f, -0.07369743f, -0.01848960f, -0.00651999f, 
    0.31794673f, 0.18181381f, 0.03038634f, 0.10170539f, 0.23748140f, 0.11279924f, 0.05715914f, -0.01727592f, 
    -0.02497945f, 0.05703818f, -0.01002704f, -0.04106520f, 0.04095460f, -0.02008808f, 0.05763875f, 0.04997503f, 
    0.03842770f, -0.04939706f, 0.00617522f, -0.00739613f, -0.18271908f, -0.09707948f, -0.08522241f, -0.29339385f, 
    -0.15477790f, 0.02588009f, 0.02621055f, -0.03239768f, 0.04402903f, -0.02273733f, 0.06833167f, 0.02938046f, 
    0.14625527f, 0.04592110f, -0.04195443f, -0.05284954f, 0.06440617f, 0.09022277f, 0.04463067f, -0.00776751f, 
    -0.06393744f, 0.02824253f, 0.06798915f, -0.00064300f, 0.05877289f, -0.05917532f, 0.06836335f, 0.05941653f, 
    0.00181141f, 0.00667585f, -0.06339251f, 0.02428889f, 0.00865968f, 0.08260386f, 0.03338902f, 0.10951145f, 
    -0.07779966f, -0.10171168f, 0.00626707f, 0.08773777f, -0.04192566f, -0.07311001f, 0.06012941f, -0.18678667f, 
    -0.22146015f, -0.04345934f, 0.03299801f, 0.07337290f, 0.10113791f, 0.02075247f, 0.10078944f, 0.09249365f, 
    0.14594844f, -0.03927653f, 0.09125664f, -0.05532307f, -0.02871560f, 0.04629751f, -0.06151455f, -0.04251743f, 
    0.01533260f, 0.11678413f, 0.06786420f, 0.20667408f, 0.18133470f, 0.04183842f, 0.01615269f, 0.05102061f, 
    -0.07685526f, 0.04627022f, 0.02187292f, -0.04653408f, 0.06991408f, 0.07977259f, 0.03136052f, 0.15994619f, 
    0.03774547f, -0.05235716f, 0.02817815f, 0.08193993f, -0.07656098f, 0.16260105f, -0.06131500f, -0.12041964f, 
    -0.15352625f, 0.03103751f, -0.05138076f, -0.00474060f, -0.00309810f, 0.00904299f, 0.05076649f, -0.04611454f, 
    0.02513660f, 0.03714233f, 0.01540493f, 0.06068223f, 0.04868106f, 0.08779874f, -0.05338758f, 0.06342137f, 
    0.26528606f, 0.22455294f, -0.10692132f, 0.10965928f, 0.12835510f, 0.17576995f, 0.04231581f, 0.01624797f, 
    0.01381536f, -0.01833036f, -0.00759532f, -0.02541714f, -0.02199854f, -0.03184223f, -0.01509672f, 0.03166136f, 
    -0.08397219f, 0.05891270f, -0.02275088f, 0.01803371f, -0.00823998f, 0.09496927f, -0.02436593f, -0.12455963f, 
    -0.17610632f, 0.04026729f, 0.00046711f, -0.00926833f, 0.09670738f, -0.05480548f, 0.01075578f, 0.08923168f, 
    0.02741928f, 0.20088960f, 0.01278600f, -0.00396259f, 0.02678567f, 0.10462590f, -0.02650586f, -0.07908674f, 
    0.01354881f, 0.00705290f, -0.02517861f, 0.01988537f, 0.00403212f, -0.02115282f, 0.02324962f, -0.00622646f, 
    -0.02537943f, 0.02939501f, 0.02226860f, -0.00457660f, -0.00125863f, 0.01550113f, 0.00833349f, -0.01602999f, 
    -0.03505454f, 0.01290729f, 0.01378648f, -0.03015010f, -0.03016199f, 0.03125924f, -0.00219171f, -0.03026603f, 
    -0.02985519f, -0.02895214f, 0.02141787f, 0.02127216f, -0.02362944f, -0.02305890f, 0.00739990f, 0.02532235f, 
    -0.02575446f, 0.00128271f, -0.02519398f, -0.01075395f, 0.02797023f, -0.01737367f, 0.02199572f, -0.04415712f, 
    0.01474817f, 0.02711077f, 0.00227650f, -0.01273588f, 0.02694015f, 0.03687162f, 0.00853916f, 0.01883791f, 
    -0.04484512f, -0.00991002f, -0.04523336f, -0.01322155f, 0.02245737f, 0.01766533f, 0.00175741f, -0.01272320f, 
    -0.03020024f, 0.03224516f, -0.01481855f, -0.01581955f, -0.02821931f, 0.02007858f, -0.02648770f, 0.03668474f, 
    0.03212404f, -0.03588983f, -0.00850072f, -0.02065656f, -0.01707426f, 0.02473592f, -0.00931680f, 0.01418405f, 
    0.03134678f, 0.00275040f, -0.03357499f, 0.03589880f, 0.02098962f, -0.00458903f, 0.01570543f, -0.00202385f, 
    -0.03323568f, 0.03330474f, 0.01417189f, 0.00222029f, 0.03387194f, -0.01044162f, -0.03413986f, -0.02295793f, 
    -0.01676819f, -0.00116914f, 0.00800291f, 0.00445925f, -0.01226177f, -0.00154873f, -0.03700996f, 0.01467294f, 
    0.03131912f, -0.00304395f, 0.03771335f, 0.02413663f, 0.02939744f, 0.03093475f, 0.01257367f, 0.04372430f, 
    -0.00241087f, -0.02588813f, 0.03445824f, -0.00666634f, 0.03828103f, 0.00244144f, 0.01230309f, -0.00465025f, 
    0.02527909f, -0.03540163f, -0.01704713f, 0.02493512f, 0.03124034f, -0.01292237f, -0.02803435f, -0.02949895f, 
    -0.03559767f, -0.00547054f, 0.01794827f, -0.03224451f, -0.01440362f, 0.03001944f, -0.01406851f, 0.00913920f, 
    0.01192221f, 0.01696398f, 0.03566938f, -0.03150794f, -0.02817003f, -0.00254487f, 0.04091309f, 0.03132497f, 
    -0.02957875f, 0.02109318f, -0.02831654f, -0.02117328f, -0.03823903f, 0.00006460f, 0.03256620f, -0.00720099f, 
    -0.03438997f, 0.01279393f, 0.02533635f, -0.00939871f, 0.00279278f, 0.00038957f, -0.02946728f, 0.01586910f, 
    -0.03895367f, 0.03035925f, 0.01452639f, -0.02447220f, 0.00954334f, 0.01960842f, 0.03435465f, 0.01774779f, 
    -0.03637670f, 0.02663543f, 0.01958770f, -0.01759595f, 0.02987999f, -0.00397699f, -0.03324666f, -0.02902257f, 
    -0.04048110f, -0.04200087f, -0.04197621f, 0.01072840f, -0.04176423f, 0.01804771f, -0.03850648f, -0.00032003f, 
    -0.00508845f, -0.04654589f, 0.03256534f, -0.01621174f, -0.02486133f, -0.01159725f, 0.01449107f, 0.01774393f, 
    -0.01703374f, -0.03954148f, -0.04630217f, -0.03991155f, 0.03165140f, 0.01952582f, -0.01061369f, 0.03483368f, 
    0.00108287f, -0.01187304f, 0.03249702f, -0.04201759f, -0.01082423f, -0.02029310f, -0.03989005f, -0.01502729f, 
    -0.02339418f, -0.03060280f, -0.03978669f, 0.00278064f, -0.00841927f, 0.00387790f, 0.03314181f, 0.02213109f, 
    -0.02668069f, 0.00748463f, -0.02449526f, -0.03316206f, 0.01060357f, 0.00650552f, 0.01810057f, -0.02158150f, 
    -0.02081870f, 0.01359630f, 0.01848948f, 0.01310708f, 0.00226762f, 0.01879762f, 0.00623978f, -0.00654275f, 
    -0.02840859f, 0.02680780f, 0.02934155f, 0.01469834f, -0.03402848f, -0.01596202f, 0.04280303f, -0.01479446f, 
    -0.03767673f, -0.04466785f, 0.01633943f, -0.01784616f, 0.00767334f, 0.02375210f, 0.02557266f, 0.00934009f, 
    -0.03118519f, -0.01457552f, 0.00136790f, 0.00044498f, 0.01202388f, -0.01651261f, -0.04324016f, -0.02932524f, 
    -0.00572219f, -0.03926176f, -0.00885008f, -0.03626751f, 0.01022248f, -0.02015085f, 0.02750250f, -0.02164507f, 
    -0.02635716f, -0.01039610f, -0.02912481f, 0.02545897f, 0.00069900f, 0.03266929f, -0.01892291f, -0.00552134f, 
    -0.03850264f, -0.02371129f, -0.03348293f, -0.00746126f, -0.02354630f, -0.01172193f, 0.01590800f, -0.04441977f, 
    -0.03988405f, 0.02870809f, 0.03202845f, -0.02266649f, -0.04563943f, 0.01260244f, 0.02405695f, -0.04771337f, 
    0.01643570f, -0.02764797f, -0.02088830f, 0.01420482f, -0.03135579f, -0.00585843f, 0.01945360f, -0.01398375f, 
    0.01906540f, -0.01007865f, 0.00851347f, -0.01497595f, -0.03636563f, -0.03989800f, 0.00542976f, -0.00056744f, 
    -0.03597977f, -0.02855088f, 0.00027880f, -0.00890992f, -0.03321163f, -0.02101342f, -0.03713736f, -0.04037492f, 
    0.03548546f, 0.01482279f, 0.01326523f, 0.03146632f, -0.00232662f, -0.00131502f, 0.02726360f, 0.01808892f, 
    -0.03179588f, 0.03688194f, 0.00342336f, -0.00991926f, -0.04212272f, 0.02422347f, -0.02028645f, -0.03415412f, 
    0.00250556f, -0.04720810f, -0.02022805f, 0.01361502f, -0.00738254f, -0.02559404f, -0.01874320f, 0.02766555f, 
    -0.03144700f, -0.00337038f, -0.04160627f, 0.03140582f, -0.02972285f, -0.01660046f, -0.03713651f, 0.01353979f, 
    -0.04355199f, -0.01078129f, 0.02325758f, 0.03212565f, 0.00102000f, -0.03532294f, -0.02512404f, 0.01635181f, 
    -0.03863041f, 0.02193107f, -0.00817784f, 0.01685081f, -0.01890255f, 0.03241353f, 0.01419122f, -0.02643285f, 
    -0.03484327f, -0.02517048f, -0.02222698f, -0.01710298f, 0.00247736f, -0.02402271f, -0.01302900f, 0.00790328f, 
    -0.02470641f, -0.04051008f, 0.00968263f, -0.04175905f, 0.02909096f, -0.02155166f, -0.00824787f, -0.00027915f, 
    0.02403572f, -0.00918640f, 0.01111828f, -0.00973770f, 0.00549535f, 0.00833089f, 0.01347076f, -0.02700980f, 
    0.01979789f, 0.03008982f, 0.02103544f, -0.03000713f, -0.01134105f, -0.03059263f, 0.02307041f, 0.02379995f, 
    -0.00325597f, 0.03723090f, -0.02210578f, 0.02072206f, -0.01613095f, 0.02885059f, 0.00747089f, 0.01909980f, 
    0.00520162f, -0.02166025f, 0.01243719f, 0.00380405f, -0.02413070f, 0.02246690f, -0.02119455f, -0.03195129f, 
    -0.02139735f, -0.04004636f, 0.03210442f, -0.01092106f, 0.03380281f, -0.03657925f, -0.02624906f, 0.00294798f, 
    -0.01521262f, 0.03766160f, 0.00141366f, -0.00970949f, -0.03140177f, 0.00508664f, 0.01982570f, -0.02192746f, 
    -0.02301953f, -0.01205259f, -0.01801649f, 0.03189256f, 0.02405024f, 0.01432121f, -0.00658441f, -0.00802363f, 
    -0.01385403f, -0.01373396f, 0.00813153f, -0.03431608f, -0.03344053f, -0.01173267f, 0.00536891f, 0.03311574f, 
    0.01627512f, 0.02303313f, -0.01333885f, 0.03247110f, -0.03476351f, 0.02356985f, -0.02278386f, -0.01821173f, 
    -0.03225091f, -0.03863099f, -0.02544154f, -0.00456728f, -0.00706295f, -0.00304051f, -0.02682962f, 0.00069338f, 
    -0.03166818f, 0.01118316f, -0.00833462f, -0.01431431f, -0.00981995f, -0.00987595f, -0.02035210f, 0.01498188f, 
    -0.00752085f, 0.00500263f, -0.02684196f, -0.02071036f, 0.00745109f, -0.01249747f, -0.02577948f, 0.03043347f, 
    -0.01727368f, -0.00651645f, -0.04199278f, 0.02770421f, 0.02022666f, -0.01710851f, 0.00436776f, 0.02160501f, 
    0.03417435f, 0.01582823f, 0.00642601f, -0.04684034f, -0.03726471f, -0.00147906f, -0.02549842f, 0.02425849f, 
    -0.01409177f, 0.00545091f, 0.00103449f, -0.03172848f, -0.00080805f, -0.02017120f, -0.01117668f, 0.03497940f, 
    0.01625827f, 0.02453746f, -0.04068020f, -0.03330439f, 0.00510534f, 0.01865603f, -0.02114059f, -0.02233584f, 
    -0.03061589f, -0.03224057f, 0.02745583f, 0.03085894f, -0.00014892f, 0.02917945f, 0.00356768f, 0.02410717f, 
    0.01996182f, -0.04251853f, -0.04504441f, 0.01579404f, -0.01549421f, -0.02941859f, 0.03952574f, 0.00425263f, 
    0.00392645f, 0.00255602f, -0.03185495f, -0.03629025f, -0.01246853f, 0.02281385f, 0.00635595f, 0.01238148f, 
    0.02773280f, -0.01579460f, -0.02673290f, 0.02671398f, 0.02572696f, 0.02814750f, 0.02574583f, 0.01055354f, 
    -0.01825793f, -0.02441750f, -0.01610548f, -0.02686008f, -0.00500209f, 0.00564278f, 0.02663158f, -0.03416422f, 
    0.00920492f, 0.00931401f, -0.01251548f, -0.01792888f, -0.01863209f, -0.00173235f, -0.03308968f, 0.02845312f, 
    -0.00831067f, -0.04504485f, -0.01632042f, -0.01092714f, -0.02271466f, -0.00180403f, -0.00958628f, 0.01224214f, 
    0.00956919f, -0.02086015f, 0.03585877f, 0.01160522f, 0.02949326f, 0.01679909f, -0.01503465f, 0.01487224f, 
    -0.01637184f, -0.01764091f, -0.03133946f, -0.03229009f, -0.02053552f, 0.02105166f, -0.02366127f, -0.00963729f, 
    0.00728821f, -0.02669543f, -0.02766670f, 0.00027732f, -0.00696423f, -0.03280767f, 0.00353573f, -0.00694963f, 
    -0.00067106f, 0.03796994f, -0.00101591f, 0.00295115f, -0.00344203f, 0.01802249f, -0.02901304f, 0.03643942f, 
    0.01229087f, 0.00875730f, 0.02044151f, -0.01512990f, 0.01168812f, -0.02611760f, 0.02105569f, 0.01235087f, 
    -0.00553842f, -0.02292596f, 0.01648687f, 0.03578882f, -0.00180222f, 0.02729662f, 0.02885431f, -0.00593895f, 
    -0.02688421f, 0.03054459f, -0.04053158f, 0.03490217f, -0.01562317f, 0.01659027f, -0.02685633f, -0.00492636f, 
    0.03195637f, 0.01448799f, -0.01447603f, -0.04674461f, 0.00546521f, -0.02837528f, -0.03091037f, -0.02269125f, 
    0.01945940f, 0.01329833f, -0.01003125f, 0.02096115f, -0.00701941f, 0.00125433f, 0.02091511f, 0.00446290f, 
    0.01833608f, -0.04839660f, -0.04076793f, -0.03883367f, -0.03351303f, 0.01434516f, 0.02478292f, -0.00169611f, 
    0.01971714f, 0.00197557f, 0.00544870f, -0.00339002f, -0.01257360f, 0.03067280f, -0.03206025f, -0.00044988f, 
    -0.03583924f, 0.25064650f, -0.20904902f, 0.14914957f, -0.11077439f, -0.03792484f, 0.00485062f, 0.04659763f, 
    0.06885713f, -0.08685151f, 0.06431477f, 0.11597154f, -0.05070082f, 0.04011485f, -0.00881282f, 0.02619283f, 
    0.01930411f, -0.03618520f, 0.19351296f, 0.00746374f, 0.10811794f, 0.36928985f, -0.22210281f, -0.04402404f, 
    0.17253508f, -0.26756972f, -0.08460047f, -0.06931055f, -0.07786081f, -0.02479986f, -0.05820582f, 0.02461564f, 
    -0.00813442f, -0.04923208f, -0.07244182f, 0.03117340f, 0.05140227f, -0.12786809f, 0.03847617f, 0.05354892f, 
    -0.14809673f, 0.07831341f, -0.07480668f, 0.00857300f, -0.27386105f, -0.01170552f, 0.08205511f, -0.01410736f, 
    -0.07952918f, 0.06999055f, 0.04716796f, 0.13689558f, 0.06849798f, -0.17858209f, -0.09902978f, 0.04414326f, 
    0.00795941f, -0.03106261f, 0.07823942f, 0.07082858f, 0.14266805f, 0.08767926f, 0.16942990f, -0.20995425f, 
    -0.22911732f, -0.00739692f, 0.13828495f, -0.01945754f, 0.05942523f, 0.04541400f, -0.01318297f, -0.10286928f, 
    -0.09459526f, 0.01430858f, 0.03215659f, -0.03657862f, 0.10074941f, -0.06215840f, -0.09476845f, 0.00849044f, 
    0.03213705f, -0.24224477f, 0.09671677f, -0.02034917f, 0.01850144f, -0.07676344f, -0.06233855f, -0.02174693f, 
    0.09976147f, -0.07973825f, 0.11513377f, -0.08711170f, 0.06295388f, 0.14115335f, 0.02211450f, 0.04422009f, 
    0.00799500f, 0.11252716f, -0.17342177f, 0.09277347f, -0.08751636f, -0.15605842f, -0.14489685f, -0.14127734f, 
    0.09400117f, -0.04974530f, -0.11787406f, -0.05694539f, -0.05367753f, -0.03350301f, -0.00403663f, 0.03521173f, 
    0.05273793f, 0.04102033f, 0.00110197f, 0.05099423f, -0.02020472f, -0.12556039f, -0.11709748f, 0.11263423f, 
    -0.03456429f, -0.18555500f, -0.11773901f, 0.05294962f, 0.23489328f, -0.12572740f, -0.01366075f, 0.05704114f, 
    -0.02140289f, -0.07590135f, -0.13686344f, 0.01630674f, -0.14330058f, 0.00917707f, 0.16901000f, 0.07741330f, 
    0.15101472f, -0.16760106f, -0.18148901f, -0.09941890f, 0.13846807f, -0.00325961f, 0.09660860f, -0.03289751f, 
    0.09052784f, -0.07468171f, -0.03963197f, 0.11449091f, -0.03122422f, -0.01026766f, 0.02920296f, 0.13467078f, 
    0.02458886f, 0.00104593f, -0.04877326f, -0.03268480f, 0.01442366f, -0.02640381f, 0.09178048f, 0.05130228f, 
    0.52433610f, 0.10468917f, 0.05709625f, -0.03698725f, -0.02316830f, -0.03131524f, -0.05440960f, -0.03520312f, 
    0.16277222f, 0.02996792f, -0.09861600f, -0.08809342f, -0.01627466f, 0.12892015f, 0.01887956f, 0.10431799f, 
    -0.03063785f, 0.06977268f, -0.01016293f, 0.01784301f, -0.06340811f, 0.33776554f, -0.24326590f, 0.03493159f, 
    0.29092973f, 0.00738390f, 0.06931964f, 0.05564935f, -0.06907916f, 0.09501302f, -0.14127928f, -0.02090785f, 
    0.01764309f, -0.09319261f, -0.01342291f, -0.00558572f, -0.00003506f, -0.03811149f, 0.05035112f, 0.04856082f, 
    0.39655352f, -0.03214678f, -0.28192919f, 0.03124081f, -0.11368786f, -0.10437581f, -0.08284523f, 0.00003690f, 
    -0.00563505f, 0.04684192f, 0.06107876f, 0.03230821f, -0.06214299f, 0.02924221f, 0.09472867f, -0.05717307f, 
    0.00507195f, 0.03663246f, 0.02903589f, 0.11046924f, 0.04422147f, -0.10772330f, -0.00853562f, -0.15385295f, 
    0.24237478f, -0.15680599f, -0.07889752f, 0.10412760f, -0.03061912f, -0.06648121f, -0.03888177f, 0.05460306f, 
    -0.07047652f, -0.08479249f, -0.09918012f, 0.07342742f, -0.02143775f, -0.06974649f, -0.08832536f, 0.01397496f, 
    0.33527768f, -0.11165401f, -0.05232141f, -0.17652832f, -0.19071567f, 0.01481664f, 0.02427834f, 0.00962372f, 
    -0.08616450f, 0.11107822f, -0.09675695f, 0.15498018f, -0.00460040f, -0.07335279f, 0.13137817f, -0.02958593f, 
    0.01413186f, -0.04671074f, -0.02048617f, 0.11699498f, -0.07256051f, 0.09739269f, -0.04325673f, -0.02428571f, 
    -0.23818530f, -0.01174213f, 0.09047627f, -0.01674876f, -0.12934698f, 0.17014517f, -0.05724990f, 0.05500663f, 
    0.00440015f, 0.00276337f, 0.07424664f, -0.07875667f, -0.04473388f, -0.11915494f, 0.13058162f, 0.01555824f, 
    0.44072220f, 0.15432143f, -0.23337889f, 0.06731361f, -0.01558794f, -0.00453107f, 0.08484366f, 0.02197600f, 
    -0.02518301f, 0.12588014f, -0.02994586f, -0.00825223f, -0.01287951f, 0.08321220f, 0.11674932f, 0.06830031f, 
    0.00165282f, 0.00040928f, 0.02293633f, -0.05744096f, 0.20407596f, -0.26543808f, -0.13117255f, 0.00821175f, 
    -0.31955951f, 0.07907219f, 0.10328020f, 0.05303007f, 0.04846269f, 0.04328614f, 0.05527468f, 0.18349664f, 
    -0.11376242f, -0.05713597f, 0.15683806f, -0.09502480f, -0.04128364f, 0.10570267f, 0.15966931f, 0.04159571f, 
    0.06038364f, 0.03135457f, -0.23074171f, 0.06359998f, -0.29599440f, -0.04780417f, -0.05568387f, -0.06599330f, 
    -0.01191251f, 0.11940302f, -0.08990569f, 0.10542749f, 0.01650323f, 0.09564091f, 0.03324614f, 0.03142142f, 
    0.01777046f, 0.06478415f, 0.02219232f, 0.00806390f, 0.71819705f, -0.03854754f, -0.13839102f, -0.09601486f, 
    -0.09437785f, 0.00460479f, 0.05356501f, -0.05736241f, 0.08076708f, 0.07139950f, 0.06422398f, -0.02504999f, 
    0.03461755f, -0.01971280f, 0.14920758f, 0.06494077f, -0.13063170f, 0.11870509f, 0.04895430f, -0.08871762f, 
    0.07716491f, -0.16213016f, -0.24708317f, -0.06775519f, -0.29422370f, 0.09840917f, 0.09278688f, 0.00428712f, 
    -0.09610403f, -0.03416386f, 0.05281483f, 0.02659374f, -0.10107391f, -0.08728580f, 0.01061125f, 0.02157565f, 
    0.03292868f, 0.03480606f, 0.18196283f, -0.09401183f, 0.07641277f, -0.03802058f, -0.06988007f, -0.04332203f, 
    0.04014299f, -0.02337948f, -0.09043481f, 0.09317125f, -0.05875053f, 0.08529019f, -0.07319704f, -0.02335167f, 
    0.21927316f, -0.03833878f, -0.03521788f, 0.02192096f, 0.06229756f, -0.05208052f, 0.01046511f, -0.00383517f, 
    0.10683486f, 0.14456919f, 0.16801712f, 0.11355165f, 0.15910424f, 0.05541123f, -0.03907786f, -0.05212500f, 
    0.05218023f, 0.12232981f, 0.10407198f, 0.21866134f, -0.06274819f, -0.05581645f, -0.11820018f, -0.01486105f, 
    -0.05772759f, 0.00129961f, 0.04137035f, 0.03475422f, -0.02800715f, -0.16670674f, 0.17067026f, -0.02243801f, 
    0.07208433f, 0.10959227f, 0.03221955f, 0.01516748f, -0.01489310f, -0.03830709f, -0.09362135f, 0.02422541f, 
    -0.11960300f, 0.05492492f, 0.06967518f, -0.00508998f, 0.06099835f, 0.01036297f, -0.24216303f, 0.01252210f, 
    0.05631265f, -0.19348314f, -0.23249289f, -0.08172900f, -0.11737701f, -0.04945160f, -0.20022051f, -0.03896357f, 
    0.14189897f, -0.05351190f, 0.11004711f, -0.07908097f, -0.04675454f, 0.05901951f, 0.03416702f, 0.02048130f, 
    -0.12708971f, -0.04374915f, -0.11328924f, 0.03145978f, 0.30356082f, -0.07867734f, 0.01108516f, -0.17023949f, 
    0.15339518f, -0.08745334f, 0.00350595f, 0.03991167f, 0.06650195f, 0.04125028f, 0.07041322f, 0.00674253f, 
    0.03732325f, 0.05486640f, 0.16191825f, 0.14632779f, 0.01706446f, -0.10122570f, -0.11259972f, 0.03719750f, 
    -0.13897826f, -0.21766695f, 0.05740930f, -0.23946418f, 0.10857722f, -0.14283375f, 0.09833277f, 0.16609983f, 
    0.00119964f, 0.03822087f, -0.05018054f, -0.00395471f, 0.03573817f, 0.02392262f, 0.12787507f, -0.09997040f, 
    0.05770339f, -0.27160668f, 0.00071709f, -0.05737315f, 0.03081363f, -0.01124918f, 0.17775027f, 0.12380239f, 
    -0.15078954f, -0.06537677f, 0.08124723f, 0.00942836f, -0.04136629f, -0.01054629f, -0.03309216f, -0.00094807f, 
    0.02552178f, 0.01908091f, 0.02862627f, 0.12063460f, -0.08412919f, 0.05811176f, 0.01442146f, 0.04179416f, 
    0.31707135f, -0.02188838f, 0.12479349f, -0.27363023f, -0.09789382f, -0.09822398f, -0.02762285f, -0.02576521f, 
    0.09889518f, 0.04836566f, 0.03086979f, 0.03905915f, 0.13227351f, -0.10462211f, -0.10490468f, -0.06241112f, 
    -0.01331965f, -0.02277619f, 0.07342362f, 0.15539359f, 0.14072266f, -0.08231603f, 0.17300123f, -0.08793595f, 
    -0.03269275f, 0.14862333f, 0.01992748f, -0.07411665f, 0.00884475f, 0.06226779f, -0.01619417f, -0.13359649f, 
    -0.09503485f, 0.08256003f, 0.07156342f, -0.07045761f, -0.06547793f, -0.05437861f, -0.13287936f, -0.03600471f, 
    0.38442075f, 0.11976053f, -0.40720114f, -0.03316769f, -0.15916120f, -0.01825102f, -0.17369907f, -0.15059683f, 
    0.05569113f, 0.10183316f, 0.08016554f, 0.01659243f, 0.08767644f, 0.02174545f, 0.04606099f, 0.09140096f, 
    0.02708064f, -0.06140856f, -0.02991468f, 0.04169248f, -0.04748151f, 0.04653879f, -0.01479294f, 0.18515916f, 
    -0.18112729f, -0.00776113f, 0.03179353f, 0.05574051f, -0.01873326f, 0.04898461f, -0.09163963f, 0.04073197f, 
    0.06792777f, 0.02861653f, 0.07727880f, 0.03819989f, 0.05464419f, -0.06893373f, 0.05708874f, -0.05066687f, 
    -0.01555590f, 0.08367417f, -0.14191826f, -0.01717693f, 0.08609139f, -0.12492850f, -0.11340813f, 0.10546656f, 
    0.04783895f, -0.04156053f, 0.04692927f, 0.07374322f, 0.01769487f, 0.02603577f, -0.00992854f, -0.08498657f, 
    -0.04618299f, -0.01454646f, -0.08025260f, -0.01363794f, 0.28991500f, -0.25156420f, 0.14683296f, 0.05632844f, 
    -0.11868835f, -0.00362940f, 0.09252049f, 0.12504101f, 0.00596150f, 0.01762901f, 0.01790793f, 0.02445951f, 
    -0.05160161f, 0.01138703f, 0.07938045f, -0.00162903f, -0.12880138f, 0.08070905f, 0.11483658f, 0.03018124f, 
    -0.00564965f, -0.03574749f, 0.02323968f, 0.02633452f, -0.03501061f, 0.01945522f, 0.00241223f, -0.02349434f, 
    0.01891247f, -0.03500996f, -0.03826633f, -0.01946306f, -0.00813384f, 0.00769479f, 0.02122552f, 0.02464869f, 
    0.02906581f, 0.02110825f, 0.01538827f, -0.02267251f, -0.03080803f, 0.01596539f, 0.00344330f, -0.03108134f, 
    -0.00245914f, -0.03466466f, 0.03390586f, 0.01616324f, -0.00964304f, 0.01516537f, -0.00723645f, 0.03328063f, 
    0.00114465f, 0.01337295f, 0.00613826f, 0.01999287f, -0.02343521f, -0.04353078f, 0.01987746f, -0.03407436f, 
    -0.01306053f, 0.00739025f, -0.00065505f, -0.03010910f, 0.00398530f, -0.01966310f, 0.00967849f, 0.02015890f, 
    0.02217870f, 0.01251287f, -0.00465342f, -0.02353518f, 0.00926607f, 0.02086704f, 0.01906084f, -0.00173918f, 
    -0.01236155f, 0.00930527f, 0.02578989f, -0.00657449f, -0.00783665f, 0.01081689f, 0.02898838f, -0.02358383f, 
    -0.01420061f, -0.00563029f, -0.02749607f, -0.00608525f, -0.03922027f, -0.01529932f, 0.00594916f, 0.02843119f, 
    -0.00818157f, -0.00033484f, -0.01855304f, -0.00578851f, 0.01624881f, 0.01868078f, -0.02987201f, 0.03527931f, 
    0.02179022f, -0.03333322f, 0.02283546f, -0.03290163f, 0.02302717f, -0.01557954f, 0.00453607f, -0.01352032f, 
    0.01865502f, 0.02183086f, -0.01992888f, -0.00723585f, -0.04401245f, 0.02897532f, -0.01576583f, 0.01563167f, 
    -0.01755654f, 0.01446330f, -0.00625280f, 0.00348260f, -0.02393373f, -0.01911415f, -0.01176658f, -0.00070014f, 
    -0.01637019f, 0.01111750f, -0.01481340f, 0.01343296f, -0.02004352f, 0.00027675f, 0.00256878f, 0.02468219f, 
    -0.02887874f, 0.00363711f, -0.01025075f, -0.02477617f, -0.01827170f, -0.01776301f, -0.02388909f, 0.01024920f, 
    0.01858082f, -0.01923213f, -0.00419374f, 0.02822256f, 0.01222611f, -0.04048919f, -0.04609367f, -0.02801507f, 
    -0.03953423f, 0.00517610f, 0.01975922f, 0.00101474f, 0.03201183f, -0.01456820f, 0.02101392f, -0.03646489f, 
    -0.00979785f, 0.01798261f, -0.01863315f, -0.00546220f, 0.00682757f, -0.01745114f, 0.01470488f, 0.02013499f, 
    0.02145370f, -0.04313421f, 0.03041782f, -0.00587320f, 0.03165845f, 0.02748828f, 0.03333416f, -0.01152064f, 
    0.02494811f, -0.02245772f, -0.02951383f, -0.00856176f, -0.04351728f, 0.00733584f, 0.01760520f, -0.03292731f, 
    0.00804724f, -0.01470965f, -0.00726196f, 0.01887630f, -0.03983160f, -0.04135104f, -0.04352677f, -0.00092884f, 
    -0.01199465f, -0.03775214f, -0.02017727f, -0.02286288f, -0.01750912f, -0.01229288f, 0.00835599f, 0.02665749f, 
    0.00242645f, 0.02106242f, -0.04437733f, -0.01742045f, 0.01133339f, -0.02946003f, -0.02383487f, 0.00007821f, 
    0.00427735f, 0.02182518f, 0.01445692f, 0.01768541f, -0.01237848f, 0.01588041f, 0.02766960f, -0.03649916f, 
    -0.04475568f, -0.02137361f, -0.02514906f, -0.01158356f, 0.03309741f, 0.02850247f, -0.02517166f, -0.00093085f, 
    -0.00664859f, -0.03862736f, -0.03988431f, -0.00608303f, 0.01044647f, -0.01393783f, -0.03953070f, 0.03182083f, 
    0.00687800f, -0.01133213f, -0.00704571f, -0.01203747f, -0.02288181f, 0.00848201f, -0.00129628f, 0.02512209f, 
    -0.00735366f, -0.01922225f, -0.00940907f, -0.00997229f, 0.03092460f, -0.00568063f, -0.00556139f, 0.01506065f, 
    -0.03705825f, -0.02984592f, -0.03045304f, 0.02094661f, 0.03123646f, -0.03134539f, -0.04403315f, -0.03594397f, 
    -0.01697290f, 0.02813101f, -0.00372215f, 0.00168969f, -0.03622442f, -0.02724433f, 0.01758170f, -0.01454929f, 
    0.02059711f, -0.00350407f, 0.01311406f, -0.04412169f, 0.01760918f, -0.04323526f, 0.02775978f, -0.00951015f, 
    0.00261958f, 0.01438887f, -0.01415371f, -0.02925451f, -0.01025811f, 0.01851709f, 0.01142563f, -0.03497582f, 
    -0.01897462f, 0.02885224f, 0.01762904f, -0.03739043f, -0.02899188f, 0.01159623f, -0.01840939f, 0.00324898f, 
    -0.03901055f, 0.00532160f, 0.01016013f, 0.02579644f, 0.02751385f, 0.03259685f, -0.04099082f, 0.03042733f, 
    -0.00449096f, -0.00261882f, 0.01510782f, 0.02236531f, 0.00401095f, -0.00033575f, 0.00927879f, -0.02558161f, 
    0.02875230f, -0.02896553f, 0.03369244f, 0.01602773f, -0.02287889f, 0.02156683f, -0.02889349f, 0.02426698f, 
    0.02209960f, -0.03279840f, 0.00742101f, 0.01912912f, 0.00470977f, 0.00617846f, -0.01541410f, -0.01796845f, 
    -0.04038068f, 0.02154840f, -0.02464690f, -0.01334802f, 0.00214652f, 0.00839605f, 0.01918801f, -0.04388456f, 
    0.00549129f, -0.03719592f, 0.02154328f, -0.01538828f, 0.02697268f, 0.00866148f, -0.01402763f, 0.00778019f, 
    -0.02117462f, 0.02578173f, 0.00082965f, -0.00454383f, -0.04065186f, -0.03067040f, -0.00538288f, 0.01868490f, 
    -0.02871655f, -0.00391485f, 0.02339325f, -0.00734378f, 0.02030678f, -0.04751472f, -0.00562298f, -0.01790865f, 
    -0.00917955f, 0.02938491f, 0.01756509f, -0.01044938f, -0.02622710f, 0.03114882f, -0.03265009f, -0.03735874f, 
    0.01650264f, 0.01165556f, 0.03243937f, 0.01693401f, -0.02305990f, 0.00873720f, 0.02670348f, -0.00015608f, 
    -0.01105092f, -0.00220769f, -0.00479952f, 0.00735388f, -0.01782424f, 0.02899073f, -0.02817877f, 0.00989832f, 
    -0.02451132f, -0.02268713f, -0.04452510f, 0.00771542f, -0.01893384f, 0.01194972f, -0.01917285f, -0.00581188f, 
    0.02849080f, -0.04157275f, -0.02614499f, -0.01988366f, -0.02877207f, 0.02899813f, 0.01678339f, 0.01545557f, 
    -0.00749731f, 0.02677047f, -0.00367350f, -0.01271663f, 0.00736427f, 0.01119772f, -0.02078807f, 0.01903751f, 
    -0.03286627f, -0.02313893f, -0.00957497f, 0.02989727f, 0.00798919f, -0.04052936f, 0.01428535f, -0.01172320f, 
    -0.03789870f, 0.03235909f, 0.00247199f, 0.02568827f, -0.03416896f, -0.03520590f, 0.01972762f, 0.00119698f, 
    0.02860113f, 0.00528856f, 0.01948536f, 0.02778859f, -0.00207906f, -0.04143222f, 0.02296089f, -0.01753929f, 
    -0.04075060f, 0.01573897f, -0.02081638f, -0.03794666f, -0.03611731f, 0.03258953f, 0.01936477f, -0.04325077f, 
    0.00109814f, 0.00518096f, 0.01719229f, -0.01109721f, -0.00991649f, -0.00809945f, -0.02798013f, -0.03425336f, 
    -0.03845705f, -0.01814044f, -0.00853729f, -0.03883751f, 0.01139153f, -0.02730167f, -0.01684265f, 0.02904120f, 
    -0.03410693f, 0.02800087f, -0.00617102f, 0.02572541f, 0.03272953f, -0.02873763f, -0.03101017f, -0.01846943f, 
    -0.04350380f, -0.02306391f, -0.03777992f, -0.02081793f, -0.00538447f, 0.00280762f, -0.00586216f, 0.02037669f, 
    0.00386363f, -0.03980722f, 0.01091466f, 0.02813140f, -0.03195617f, -0.02495365f, -0.02765152f, -0.00959373f, 
    -0.03943713f, -0.02156109f, -0.00333341f, 0.02886482f, 0.00399270f, -0.02657050f, -0.01366806f, -0.02179944f, 
    -0.03813983f, -0.02446829f, -0.01488307f, 0.00154144f, 0.02088395f, 0.00591158f, -0.00688590f, 0.02591924f, 
    -0.00466611f, -0.00697720f, -0.01042874f, -0.01763123f, 0.01281746f, 0.00055964f, -0.03476878f, 0.02126548f, 
    -0.03392006f, -0.00731009f, -0.00379903f, 0.01303709f, -0.00699374f, -0.03733226f, 0.01780066f, 0.01689937f, 
    0.01098565f, -0.04248276f, 0.02237615f, -0.00508111f, -0.02123485f, 0.00108804f, -0.00712170f, 0.00779806f, 
    0.03456701f, 0.02237018f, 0.00690196f, -0.01315937f, 0.01431534f, -0.01690041f, 0.02059419f, 0.03061108f, 
    -0.01669334f, -0.04268474f, -0.00947234f, -0.02649189f, 0.03034961f, -0.01993321f, -0.00119470f, 0.00782033f, 
    -0.00072045f, 0.02238610f, -0.03572617f, -0.04314457f, -0.04343095f, -0.03650743f, 0.01716140f, 0.02542039f, 
    -0.02738892f, 0.00373904f, -0.03443394f, -0.03963021f, -0.01016033f, 0.00665955f, 0.02236971f, 0.03552193f, 
    0.01948622f, 0.03058384f, -0.03233851f, 0.01659573f, 0.01504419f, 0.01048319f, 0.02696756f, 0.02583975f, 
    -0.02920915f, 0.02657212f, -0.03902499f, -0.03736844f, -0.03111745f, -0.00277189f, -0.04039280f, -0.04115025f, 
    -0.01391229f, -0.02213954f, 0.02250160f, 0.01543230f, -0.03800226f, 0.00958569f, 0.02472648f, 0.02035262f, 
    -0.04127101f, 0.01751626f, -0.02510824f, 0.00706034f, -0.00526654f, -0.01980585f, 0.02119697f, -0.02223646f, 
    -0.03259505f, -0.02988864f, -0.00588993f, 0.00751600f, -0.02554400f, -0.02052777f, -0.00174433f, 0.00725787f, 
    -0.01082044f, -0.03085655f, -0.00203935f, -0.04237027f, 0.03182362f, -0.04803493f, -0.03147271f, -0.01294912f, 
    -0.02934686f, -0.02846735f, -0.00021342f, 0.00020256f, 0.00210457f, -0.04857244f, -0.00784475f, -0.01023299f, 
    -0.03221685f, 0.00302702f, -0.01011639f, -0.02663175f, -0.00358107f, -0.01813349f, 0.00658517f, -0.01900341f, 
    -0.03962072f, 0.02533008f, -0.03046813f, -0.02374967f, 0.02321468f, -0.03182452f, -0.04420379f, 0.01125961f, 
    -0.00938386f, -0.00165421f, 0.02344044f, 0.02458746f, -0.02979885f, -0.02623240f, -0.02385935f, -0.03793793f, 
    0.02174916f, -0.01944925f, -0.04511334f, 0.00218221f, 0.02174823f, 0.03446057f, 0.00328074f, -0.01025026f, 
    0.02647296f, 0.02711348f, 0.02815324f, -0.02226876f, -0.02219528f, -0.03348294f, -0.01167826f, 0.03393001f, 
    -0.04271235f, 0.02947240f, -0.02094875f, -0.01460810f, -0.01164162f, 0.02542745f, 0.00621566f, -0.01482265f, 
    -0.03732655f, -0.02789281f, -0.02364703f, 0.01481477f, 0.02866728f, 0.01755464f, -0.00368122f, -0.00792377f, 
    0.02833411f, -0.01598132f, 0.02752693f, 0.00199100f, -0.00712477f, -0.01397537f, -0.03592652f, 0.03458948f, 
    0.11321776f, 0.06211342f, -0.11441319f, -0.07269186f, -0.09856907f, 0.05681003f, 0.05148111f, -0.12004255f, 
    0.01863129f, 0.02142399f, -0.01390079f, 0.06575015f, 0.01958755f, 0.06526593f, 0.06926918f, 0.06744654f, 
    -0.06773258f, 0.05304120f, -0.04069613f, 0.10153946f, 0.07859745f, -0.15861993f, -0.17578888f, 0.12689133f, 
    0.28303555f, -0.03040665f, -0.05967354f, 0.02489891f, -0.00608271f, -0.00186797f, -0.06997323f, 0.05195436f, 
    -0.01367929f, 0.14666781f, 0.13677745f, 0.08991756f, 0.03782196f, 0.14515303f, -0.05896833f, -0.04767336f, 
    0.16985995f, -0.17523627f, 0.00504196f, 0.01115888f, -0.04747849f, 0.05853675f, -0.13161661f, -0.02852755f, 
    0.14930660f, -0.02592819f, -0.12987681f, 0.04154849f, -0.12755324f, 0.06407663f, 0.07393657f, -0.09089493f, 
    0.01192664f, 0.14984024f, -0.22971235f, 0.08621687f, -0.33615369f, 0.40375698f, -0.04424180f, 0.13395050f, 
    -0.17180394f, 0.00810328f, 0.08649728f, -0.05073566f, 0.04913984f, -0.10680781f, 0.05511222f, -0.02848565f, 
    0.04192215f, -0.05630558f, 0.06772936f, 0.15603961f, -0.03629254f, 0.12064858f, 0.10776082f, -0.00576850f, 
    0.25239289f, 0.21513572f, 0.05339764f, -0.22466220f, -0.11924937f, 0.01088894f, -0.00461018f, 0.04681202f, 
    0.04790142f, -0.00963925f, 0.10963996f, -0.04577988f, 0.04103516f, 0.04472100f, 0.07020977f, -0.09234868f, 
    0.10824947f, -0.17685823f, 0.11889472f, 0.05358639f, 0.46414238f, 0.09909192f, 0.14284116f, -0.04328308f, 
    0.15588269f, -0.01424339f, 0.05218672f, -0.05905543f, -0.07585676f, 0.06458052f, 0.01278029f, 0.07559416f, 
    0.03588146f, 0.11038833f, 0.02483057f, 0.02302596f, 0.08250384f, 0.07396975f, 0.05962652f, -0.02848261f, 
    0.18637957f, 0.05232919f, 0.00022125f, -0.03096186f, 0.14237949f, 0.12999710f, -0.06694963f, 0.04897331f, 
    -0.08591527f, 0.07320092f, 0.02226352f, 0.05309677f, 0.08392306f, -0.02203468f, 0.04690541f, 0.02701638f, 
    -0.11041146f, 0.23723684f, 0.12319457f, -0.00100631f, -0.29067931f, -0.05243294f, 0.06310219f, -0.15439926f, 
    -0.14426719f, 0.05197204f, 0.00615785f, -0.10605901f, -0.00353557f, 0.02735922f, -0.00321603f, 0.11916401f, 
    -0.01778734f, -0.06606223f, 0.02987058f, -0.06463642f, 0.14288811f, 0.02449873f, 0.05874209f, 0.05503029f, 
    -0.09915254f, 0.46380129f, 0.00541298f, -0.05546766f, -0.04727878f, 0.00096746f, 0.03848327f, -0.00368061f, 
    0.06076938f, -0.12907149f, 0.00731022f, -0.01220487f, 0.05267066f, -0.12477697f, 0.07654298f, 0.15887493f, 
    0.03644662f, -0.04025659f, 0.10033644f, -0.07911375f, -0.31026343f, 0.17711455f, -0.29594111f, 0.02256189f, 
    0.01413699f, -0.02970623f, 0.07359376f, 0.02549879f, 0.07463812f, -0.02315491f, 0.09869343f, -0.01184239f, 
    -0.00757442f, 0.13600023f, 0.01655205f, 0.04463804f, 0.00654467f, 0.14362885f, -0.02890434f, 0.04932705f, 
    -0.02148475f, -0.25255066f, 0.06326038f, -0.10034106f, -0.11867215f, 0.03487873f, 0.06824068f, 0.00986883f, 
    0.14016154f, 0.00371682f, 0.03992778f, 0.00708553f, 0.03366141f, 0.07904120f, 0.02871260f, -0.05473727f, 
    0.10849368f, 0.07098398f, -0.01260413f, 0.05320876f, -0.17306364f, -0.01010881f, 0.05370718f, 0.14863768f, 
    0.27876651f, 0.11645734f, -0.02580242f, 0.04858592f, -0.05997849f, 0.02405873f, -0.03344809f, -0.08062336f, 
    0.04760291f, 0.10839319f, -0.03202087f, 0.07869737f, -0.00587461f, 0.10102268f, -0.05306823f, 0.03918292f, 
    -0.26922181f, 0.16160561f, 0.18827061f, 0.13842840f, -0.10601548f, -0.02042435f, 0.09248223f, -0.09644745f, 
    -0.18542649f, 0.00757119f, 0.28546646f, -0.01374261f, -0.02903029f, -0.05935384f, -0.02571004f, -0.06651054f, 
    -0.00037527f, -0.06585292f, -0.15580975f, -0.06261345f, -0.36915872f, 0.11069258f, -0.04080715f, 0.11703145f, 
    -0.06037010f, 0.05261675f, 0.01016034f, -0.08446313f, 0.00680947f, 0.13645093f, 0.02793626f, -0.00324462f, 
    0.09123417f, 0.04270096f, 0.00833946f, -0.00954902f, 0.02736175f, 0.02413682f, -0.08030751f, -0.02168124f, 
    -0.18440749f, 0.11225507f, -0.13196924f, -0.00103587f, -0.00681738f, -0.03653602f, 0.09193268f, -0.03001268f, 
    0.19106477f, 0.06303220f, 0.04155001f, -0.03363921f, -0.08418091f, -0.00733644f, -0.02761087f, 0.03751562f, 
    0.13401474f, -0.12324606f, 0.01331888f, 0.01515790f, 0.09831280f, -0.22405203f, 0.05977885f, -0.13036710f, 
    0.03928858f, -0.03091043f, 0.02815277f, 0.06379469f, -0.11757489f, 0.02522328f, -0.05653965f, -0.08645682f, 
    -0.06933514f, 0.09048042f, -0.04719401f, -0.08503069f, 0.01212065f, -0.04390468f, 0.01259697f, 0.02676985f, 
    0.33124262f, 0.08695959f, 0.00083203f, -0.05675108f, 0.04618122f, 0.09552848f, 0.10833666f, 0.01702386f, 
    0.18445779f, 0.08503260f, 0.10764354f, 0.14653678f, -0.08176927f, -0.13068891f, 0.03682935f, -0.05058961f, 
    0.03889410f, -0.06454218f, -0.09926256f, 0.05169432f, -0.20488799f, 0.25336328f, -0.09294038f, -0.22624718f, 
    -0.09988604f, -0.00294867f, -0.10647917f, 0.03836401f, 0.06950903f, -0.02485018f, -0.02689921f, -0.03908087f, 
    -0.06778898f, -0.07987833f, 0.02161439f, 0.15716305f, 0.12339281f, -0.07332804f, 0.05756683f, -0.02212790f, 
    0.25280738f, -0.04753095f, 0.12702580f, 0.01646828f, -0.02596364f, 0.08720367f, -0.09992823f, -0.03736912f, 
    0.07034431f, 0.07644917f, 0.03298108f, 0.12625192f, 0.19245213f, 0.18555909f, 0.05844140f, 0.06161618f, 
    -0.01880358f, -0.07866264f, -0.27610430f, 0.04845348f, 0.24540448f, -0.07312037f, -0.03026108f, -0.05827170f, 
    0.14329995f, -0.02490057f, 0.07159568f, 0.03292898f, -0.06765566f, -0.04602007f, -0.05840582f, 0.15061067f, 
    -0.21741797f, 0.09609443f, -0.04897006f, 0.02502756f, 0.10498776f, 0.00982823f, 0.04931181f, 0.02527305f, 
    -0.09892318f, -0.12621136f, 0.02098887f, 0.29661599f, 0.22885595f, -0.02081187f, -0.09527037f, 0.01198387f, 
    -0.01274988f, -0.14326775f, 0.01750874f, -0.05160852f, 0.04068525f, 0.12465217f, 0.18374671f, -0.11557013f, 
    0.03529344f, -0.11598994f, -0.07620886f, 0.04457871f, 0.00522064f, 0.00819250f, -0.06348070f, 0.05432293f, 
    0.12331941f, -0.03759641f, 0.00364584f, 0.00776905f, -0.03711886f, 0.16128205f, 0.06139658f, 0.12314518f, 
    0.00642387f, 0.00601466f, -0.07016247f, 0.01863196f, 0.03891307f, -0.11922688f, 0.19591081f, -0.04556120f, 
    -0.10687967f, 0.07316274f, 0.06519599f, 0.12885603f, -0.02165512f, 0.14609390f, 0.08407708f, 0.07910499f, 
    -0.01061209f, 0.10916535f, -0.00314931f, 0.01579664f, 0.12815422f, -0.03511641f, -0.05984965f, -0.16729097f, 
    0.15928921f, 0.05037151f, 0.00696565f, -0.04696415f, -0.17494331f, 0.29325488f, 0.08918136f, -0.09762402f, 
    -0.05214281f, 0.05886052f, 0.01224256f, -0.00817501f, 0.00210557f, 0.00610032f, -0.05057044f, 0.11375603f, 
    0.03011369f, -0.05187840f, -0.09508886f, 0.03588312f, -0.05584691f, 0.08726683f, 0.09699240f, -0.10739093f, 
    0.20103520f, 0.28395918f, 0.20255841f, -0.01592951f, 0.13020790f, 0.06822545f, 0.07925105f, 0.01129398f, 
    -0.03597145f, 0.04818781f, 0.05195108f, -0.00691413f, -0.01360240f, 0.03581038f, -0.00262039f, 0.12942091f, 
    0.04595076f, 0.17329535f, 0.09032962f, 0.05453354f, 0.04721470f, -0.07968473f, 0.01129318f, 0.08110441f, 
    0.23234899f, 0.08598454f, -0.10056669f, -0.04615371f, -0.03578135f, 0.01264128f, -0.06076435f, 0.04168510f, 
    0.06356411f, 0.10653140f, 0.06725389f, -0.07086047f, 0.10495079f, -0.02125152f, -0.16730137f, 0.03055181f, 
    -0.06663302f, 0.15363508f, 0.04964685f, 0.08784626f, -0.13377321f, 0.12876976f, 0.07015490f, 0.05924930f, 
    0.05724035f, 0.09687194f, 0.15003523f, 0.06083259f, -0.01072614f, 0.06912008f, -0.07098726f, 0.07844871f, 
    0.15065025f, 0.11436270f, -0.06510840f, 0.01096018f, -0.12294230f, 0.04116121f, -0.01486854f, 0.12195257f, 
    0.13018061f, 0.00492579f, 0.00762499f, -0.07075927f, -0.12661034f, 0.03479025f, -0.02862957f, 0.10624555f, 
    0.03807902f, 0.07155951f, 0.12240759f, -0.02451974f, -0.08919286f, -0.03983271f, 0.06392600f, 0.06605174f, 
    -0.10866342f, -0.02419374f, 0.04977635f, -0.03673539f, -0.07977620f, -0.05574624f, 0.06933551f, 0.18368641f, 
    0.05333462f, -0.01569508f, 0.01616440f, 0.00719358f, -0.00724640f, 0.00165300f, -0.07425776f, 0.11386710f, 
    0.06168349f, -0.00374096f, 0.07309288f, 0.07017421f, -0.23801227f, 0.13029152f, -0.12359892f, 0.05160788f, 
    0.00874703f, 0.06501636f, 0.00972272f, -0.06022551f, -0.01158217f, 0.06321781f, 0.09309696f, 0.13387445f, 
    0.04540765f, 0.00537333f, 0.03728473f, -0.02771183f, -0.07834399f, 0.00437273f, -0.02125727f, -0.00221652f, 
    0.25435942f, -0.08893777f, 0.04392077f, -0.04975172f, 0.20253380f, -0.07222591f, -0.13555479f, 0.11196042f, 
    -0.10602392f, -0.00947695f, 0.07207192f, 0.01011045f, -0.05058873f, -0.04334734f, 0.07944653f, -0.03681542f, 
    0.07449906f, 0.06408333f, -0.02107767f, 0.10371242f, 0.05407470f, -0.22663441f, 0.11450054f, 0.14180328f, 
    0.12411227f, 0.05426430f, -0.01549652f, -0.18899526f, 0.01219645f, -0.06676265f, -0.00783215f, 0.08417146f, 
    -0.01425974f, 0.10887268f, -0.07425037f, 0.08076806f, -0.01040284f, -0.04661910f, -0.23925954f, 0.00907621f, 
    0.15528558f, -0.13310519f, -0.06612962f, 0.00696067f, -0.11323813f, 0.07728672f, 0.09796903f, 0.07261714f, 
    0.06241765f, 0.06427572f, -0.00269458f, 0.08659099f, -0.03354090f, -0.04066802f, 0.01876976f, 0.03937521f, 
    0.04988712f, 0.08068229f, 0.08897574f, 0.07563932f, 0.07424279f, 0.33509883f, 0.25669396f, 0.07293927f, 
    -0.01732045f, 0.13463818f, 0.09577233f, 0.07298788f, -0.02992323f, -0.09719097f, -0.14319611f, -0.02991675f, 
    0.00063346f, 0.16962986f, -0.12347319f, 0.00592073f, 0.02893727f, 0.02370521f, -0.01951622f, -0.07611302f, 
    -0.02906232f, -0.11306421f, -0.06667644f, 0.08054323f, -0.14940126f, 0.01559299f, 0.02630605f, 0.07558572f, 
    0.01271714f, 0.08715486f, 0.00093159f, -0.00106520f, 0.09789739f, -0.05755255f, -0.16829494f, 0.03941217f, 
    0.04458013f, -0.07567210f, 0.05719339f, 0.13500848f, 0.63706583f, -0.02699095f, -0.11299051f, -0.08459131f, 
    -0.12077758f, 0.07320657f, -0.05641610f, 0.05238232f, -0.08541247f, 0.28112781f, -0.01053264f, 0.11850561f, 
    -0.03807889f, 0.07669234f, -0.09225546f, -0.04095705f, 0.14869392f, -0.09138906f, -0.02327070f, -0.04323587f, 
    0.08771944f, -0.13525596f, -0.08499493f, -0.01191341f, 0.08194175f, 0.18746558f, 0.06645179f, -0.03848850f, 
    0.12427560f, 0.16788059f, 0.13718206f, 0.08504209f, 0.14911905f, -0.04048714f, 0.11025582f, 0.16446045f, 
    -0.02077090f, 0.15518254f, -0.00930382f, 0.01302946f, 0.03769850f, 0.33430550f, 0.05770730f, 0.10338161f, 
    0.18866962f, 0.09284868f, 0.12455901f, 0.00127198f, -0.01521688f, -0.10800035f, -0.01790076f, 0.03381472f, 
    0.05204995f, 0.04258106f, 0.12128926f, 0.01366287f, -0.03954478f, 0.02493101f, 0.05666637f, -0.00251477f, 
    -0.13997070f, 0.09833942f, 0.18166892f, 0.08157223f, 0.14504991f, 0.09295665f, 0.16672835f, 0.05540258f, 
    -0.08623835f, -0.02953865f, 0.04314815f, -0.05246744f, -0.05633082f, 0.01589918f, 0.04209676f, 0.11852345f, 
    0.08766554f, -0.11430321f, -0.05077877f, -0.04222565f, -0.11251102f, -0.15332310f, -0.01475486f, 0.01834663f, 
    0.11666677f, 0.03374348f, -0.03652201f, 0.03788265f, -0.04658199f, 0.07697349f, -0.02142527f, 0.10154498f, 
    0.08049744f, 0.07097801f, -0.10731828f, 0.09059601f, -0.07666943f, 0.07650239f, 0.07511987f, 0.04280790f, 
    0.45574903f, -0.13287172f, -0.22681066f, -0.06286146f, -0.06594925f, -0.00469713f, -0.03893472f, -0.11923818f, 
    -0.00885749f, 0.14511824f, -0.02816424f, 0.04803252f, -0.00254001f, 0.09572210f, 0.00128399f, -0.00861507f, 
    -0.03140750f, -0.08203619f, -0.15261972f, -0.06021413f, 0.28985548f, -0.01561299f, 0.07891887f, -0.14246711f, 
    0.06657937f, 0.06667954f, 0.04125256f, 0.04447764f, -0.09982946f, 0.07110807f, 0.05950829f, -0.02102811f, 
    0.13273022f, 0.00507401f, 0.04113809f, -0.01783482f, -0.06064427f, 0.12637304f, 0.01421156f, 0.07535080f, 
    -0.09856410f, -0.29504007f, -0.14999881f, 0.13883100f, -0.04460488f, -0.08258523f, -0.04431018f, 0.09654123f, 
    0.09828753f, 0.12077852f, -0.01726485f, -0.02265689f, 0.01348217f, -0.02614330f, -0.03681971f, 0.12670799f, 
    0.06765640f, 0.01022667f, -0.01800702f, 0.12505515f, 0.13920981f, 0.22981068f, 0.25239772f, 0.00844673f, 
    0.03324110f, -0.05684142f, 0.10607133f, 0.14614868f, -0.04837752f, -0.07200401f, -0.05314659f, 0.04272901f, 
    -0.01336065f, 0.05377549f, -0.03078609f, 0.03527209f, 0.06604657f, -0.03783138f, -0.08152301f, -0.06790837f, 
    0.50758582f, -0.30543503f, -0.08326666f, 0.00109378f, -0.09563657f, 0.03127249f, 0.08516219f, 0.17232671f, 
    0.03056540f, -0.04285929f, -0.04678694f, -0.00917289f, 0.14998771f, 0.15066315f, 0.09466428f, 0.08295404f, 
    0.08665054f, 0.04557841f, 0.12032428f, 0.10273134f, 0.17036429f, 0.17072584f, 0.00128636f, 0.06934833f, 
    -0.15581422f, 0.10432951f, 0.07532043f, 0.13920033f, 0.05162027f, 0.05238681f, 0.12718490f, -0.00306235f, 
    0.02649066f, 0.08438549f, 0.11158483f, 0.18139127f, 0.02422669f, 0.22885282f, 0.09575006f, 0.11734316f, 
    0.06512855f, -0.01387469f, -0.08902389f, -0.05989150f, 0.01940012f, 0.08821398f, -0.01019066f, -0.00225718f, 
    0.06848793f, 0.11705151f, 0.01149330f, 0.00820630f, -0.01355316f, 0.10730167f, 0.04329996f, 0.04357771f, 
    0.10061251f, -0.00425983f, 0.02342890f, -0.00638238f, -0.27263919f, -0.29625949f, -0.05739773f, 0.06687882f, 
    -0.20317478f, 0.02487763f, 0.06931963f, 0.05346984f, 0.16580172f, 0.12695327f, -0.13979110f, -0.05386554f, 
    -0.12434682f, 0.01207560f, 0.15633732f, 0.06217599f, -0.05082723f, 0.05536113f, 0.02996893f, -0.02503872f, 
    -0.11692289f, -0.25582182f, -0.29129443f, 0.07766341f, -0.13369012f, -0.07757118f, -0.01796014f, -0.04491995f, 
    -0.06700704f, 0.15174042f, 0.09189169f, -0.00191255f, -0.07359543f, 0.03262702f, 0.07671166f, 0.10753611f, 
    0.02981077f, 0.01543280f, -0.09790553f, 0.12616602f, -0.08164530f, -0.23979902f, -0.04450275f, 0.16638228f, 
    0.16087031f, 0.00949666f, 0.02788685f, -0.03915614f, -0.03121970f, 0.19312473f, 0.09503504f, 0.05747115f, 
    -0.07705133f, -0.05166362f, -0.03601538f, 0.17606631f, 0.08110651f, 0.03931090f, 0.06169497f, 0.14689985f, 
    -0.04118766f, -0.09977409f, -0.16247411f, 0.09909618f, -0.00224645f, -0.06437980f, 0.04965048f, 0.09275256f, 
    -0.03900100f, 0.03168276f, -0.02339853f, 0.08044406f, -0.11940584f, -0.09726870f, 0.00848856f, 0.00194171f, 
    0.12325828f, -0.01274383f, 0.04491124f, -0.00331668f, -0.15606274f, 0.04912210f, -0.04761854f, -0.04382563f, 
    -0.01031290f, 0.03866236f, -0.12738422f, -0.04538833f, 0.12728560f, -0.07871225f, 0.03664013f, 0.05115408f, 
    0.10709391f, -0.00930593f, -0.02016149f, 0.00506176f, 0.00952797f, -0.00815442f, 0.13544083f, 0.17610522f, 
    0.04940429f, 0.23044884f, 0.20676106f, -0.37817177f, -0.18136890f, -0.06146110f, 0.05502060f, 0.02915455f, 
    0.00478529f, 0.04285291f, 0.08662854f, 0.13739994f, 0.08671448f, -0.00771056f, 0.02853849f, -0.03772487f, 
    0.02552623f, -0.03712205f, -0.03313505f, 0.09456626f, -0.27571985f, -0.13013497f, 0.14350337f, -0.18884946f, 
    0.05085348f, 0.16312529f, 0.03774957f, 0.09585904f, 0.00067865f, 0.05447707f, -0.02770488f, 0.09055447f, 
    -0.00934323f, 0.05350469f, 0.06357045f, -0.02435080f, 0.09381293f, 0.02932065f, 0.02568612f, 0.02763545f, 
    -0.31679687f, -0.22538327f, -0.13326329f, -0.02935842f, -0.10772856f, -0.01227843f, -0.14823653f, -0.03624369f, 
    -0.09981091f, 0.06696893f, -0.03971024f, 0.08450379f, -0.02022288f, 0.06044855f, 0.02127572f, 0.02477749f, 
    0.03553727f, -0.05626894f, -0.07581200f, 0.02235909f, -0.08858559f, -0.44371480f, 0.00653923f, -0.15439931f, 
    0.25206876f, 0.03327458f, 0.06851043f, -0.07454323f, -0.09514819f, 0.12495858f, 0.08764034f, -0.08089530f, 
    -0.02080859f, 0.00769460f, 0.03416024f, 0.15033039f, 0.01049348f, 0.04420172f, -0.01670610f, -0.00610200f, 
    0.15678240f, 0.11193360f, 0.05304144f, 0.00008379f, 0.14964503f, 0.09668636f, 0.11217705f, -0.02545418f, 
    0.02004300f, -0.03429027f, 0.05875426f, 0.01626913f, -0.01232587f, 0.02088558f, 0.05172957f, -0.03682746f, 
    -0.04346070f, 0.06295402f, -0.04063418f, 0.01636246f, -0.14152126f, -0.04169350f, 0.02399757f, -0.10237786f, 
    -0.24809825f, -0.12335288f, 0.03462259f, 0.03688394f, 0.01247247f, 0.01855728f, -0.04741501f, -0.04475335f, 
    0.12566058f, 0.04364372f, -0.05102604f, 0.05756653f, 0.11945921f, 0.01735467f, 0.06419186f, 0.09827908f, 
    0.03955873f, -0.12678957f, -0.15316401f, -0.02393519f, -0.16679570f, -0.02811456f, -0.06124642f, 0.06632649f, 
    -0.00882952f, 0.03720303f, 0.02092313f, 0.08501451f, 0.06262032f, 0.07480136f, 0.06013662f, 0.05709403f, 
    0.05419040f, 0.03673725f, -0.01685336f, 0.12922378f, -0.07956599f, 0.17848922f, 0.10055731f, -0.17466776f, 
    -0.11080639f, -0.01551656f, 0.02461241f, 0.10055841f, 0.04378338f, 0.16993694f, -0.00924606f, 0.06701063f, 
    0.17528740f, 0.00877651f, 0.15282051f, 0.03045687f, -0.01751401f, -0.02243163f, -0.08821513f, 0.12851599f, 
    -0.06286393f, -0.19232708f, -0.20135938f, 0.00036718f, -0.11783955f, -0.01352967f, -0.07709185f, 0.03231852f, 
    0.01113158f, 0.10061812f, -0.05340519f, -0.12499741f, 0.02218884f, -0.03954154f, 0.03418903f, 0.05892741f, 
    0.15366498f, 0.01888102f, -0.01635147f, 0.20580617f, 0.11573292f, 0.17813031f, -0.02252835f, 0.17158741f, 
    -0.09688195f, 0.04720445f, 0.02663681f, 0.13525805f, -0.00580850f, 0.01647272f, 0.03632413f, -0.03027141f, 
    -0.01735994f, 0.09309898f, 0.04784614f, 0.18109868f, 0.04780307f, 0.13008422f, 0.10896122f, 0.08295092f, 
    -0.11855804f, 0.09610726f, 0.10845394f, 0.14402744f, 0.08786150f, 0.17396611f, 0.05249385f, 0.10841696f, 
    -0.00130236f, -0.07389651f, 0.03430433f, 0.01509611f, 0.01712312f, 0.04952575f, -0.05499700f, 0.07476505f, 
    -0.07595117f, 0.01746725f, -0.05246425f, -0.03625268f, -0.07893417f, -0.24025050f, 0.03006977f, 0.06122407f, 
    -0.23715252f, -0.05425008f, 0.08833177f, 0.09241856f, 0.02401176f, 0.06495801f, 0.02006645f, 0.02221997f, 
    0.01760899f, 0.15445192f, 0.14375898f, 0.09031912f, 0.07579318f, -0.01767049f, 0.03773212f, -0.06604942f, 
    -0.00539410f, -0.02575210f, -0.03265190f, -0.02808469f, 0.02350327f, 0.00167037f, -0.04176615f, -0.02636880f, 
    -0.01611986f, -0.01981924f, -0.01865018f, -0.03351391f, -0.01755336f, 0.01429780f, -0.04243033f, 0.00621825f, 
    0.00913707f, -0.01286808f, -0.01554714f, 0.02983514f, -0.02013918f, 0.01086615f, -0.03840562f, -0.00772532f, 
    -0.00102853f, -0.02203836f, -0.00505126f, -0.02759225f, 0.00498800f, 0.01703499f, -0.02002746f, -0.03573128f, 
    -0.01559854f, -0.00071130f, -0.00087813f, 0.01975156f, 0.00460337f, -0.01475967f, -0.04158060f, 0.03044894f, 
    -0.00759800f, 0.01561251f, 0.00286428f, -0.02937140f, -0.03195684f, 0.02737555f, 0.01105926f, -0.00767917f, 
    0.02201898f, 0.00747978f, -0.02119329f, -0.00724311f, -0.04422629f, -0.01695363f, -0.01912267f, 0.03140587f, 
    0.00581285f, -0.02646831f, 0.01143289f, -0.04420505f, 0.02748421f, -0.00620872f, 0.04211579f, 0.02976691f, 
    -0.02082395f, 0.00309835f, -0.01152740f, -0.01991023f, 0.00210485f, -0.00676112f, 0.00232768f, -0.04404395f, 
    0.01609046f, 0.03340759f, -0.02743005f, -0.03303069f, 0.00021573f, -0.01504826f, -0.00892211f, -0.00809767f, 
    -0.02568850f, 0.00395290f, -0.03943592f, -0.03264677f, 0.02696990f, 0.03139711f, -0.00324618f, -0.00288207f, 
    0.01591122f, 0.00644755f, 0.01085719f, -0.01850749f, -0.00628028f, 0.03080223f, 0.01328086f, -0.01005568f, 
    0.01993803f, -0.00219889f, 0.00378882f, 0.03274652f, 0.02659591f, 0.00422407f, -0.02802002f, -0.03207571f, 
    -0.02181162f, -0.02113884f, -0.02474625f, -0.02116304f, -0.02568494f, 0.01024237f, -0.03512036f, 0.01402454f, 
    0.02058905f, -0.02419616f, -0.02332002f, -0.01851034f, -0.01334699f, 0.01673750f, 0.02336448f, 0.01948179f, 
    0.02509519f, -0.00125124f, 0.02666568f, -0.00024840f, 0.00754473f, -0.02966245f, -0.00241576f, 0.01590212f, 
    0.02903373f, -0.03022199f, 0.00788294f, -0.02128723f, 0.01474515f, -0.02399990f, 0.00231940f, -0.03922297f, 
    0.01149523f, 0.01290858f, -0.03753347f, -0.00483950f, -0.03810956f, 0.00895179f, -0.01354842f, -0.00237631f, 
    -0.02496543f, -0.03217871f, 0.02128346f, 0.02673184f, -0.02696487f, -0.01867522f, -0.02481256f, 0.01321995f, 
    -0.03654932f, 0.00463567f, -0.00893681f, -0.04500666f, -0.02699363f, -0.04066418f, -0.02807003f, -0.04390037f, 
    -0.02970237f, -0.03359646f, -0.01005831f, -0.03538739f, -0.01416374f, -0.02418080f, -0.01642449f, -0.04250650f, 
    0.02965481f, -0.03576878f, -0.02743397f, -0.02513806f, -0.01009919f, -0.04413318f, 0.02425715f, -0.03664256f, 
    0.00476988f, -0.00838536f, -0.00438560f, -0.01038918f, -0.04327328f, -0.03590662f, -0.03505585f, -0.04411219f, 
    -0.00963372f, -0.01612493f, 0.01579184f, 0.03296151f, -0.01742770f, -0.00563072f, 0.01986792f, 0.01087894f, 
    -0.02763681f, -0.00879212f, -0.03718887f, 0.03186384f, -0.00250240f, 0.01595904f, 0.00089887f, 0.01390874f, 
    0.01627979f, 0.03303153f, 0.00824278f, -0.03534060f, 0.01867727f, -0.00744091f, -0.00121727f, -0.00470409f, 
    -0.01684967f, 0.03284722f, 0.01023727f, -0.00220119f, -0.04189888f, -0.01922210f, 0.00675515f, -0.01089323f, 
    -0.02304693f, -0.04029019f, 0.01043191f, 0.01448968f, -0.04499783f, 0.01402691f, -0.03804216f, -0.00437778f, 
    0.01841211f, -0.04162749f, -0.03425738f, 0.02164564f, -0.03427757f, -0.03662383f, 0.02778400f, -0.04029940f, 
    -0.02894935f, -0.01250531f, 0.02055874f, -0.02610263f, 0.01141535f, -0.02211114f, -0.03886945f, -0.04323065f, 
    -0.01970602f, -0.03642776f, 0.00871497f, -0.04324890f, -0.02657081f, -0.02082701f, 0.03282934f, -0.01121651f, 
    -0.02374664f, 0.00033027f, -0.00944505f, 0.02634792f, 0.01002766f, -0.03643353f, -0.00309279f, 0.03068991f, 
    -0.04282966f, -0.03809643f, -0.02657276f, 0.02030372f, 0.02925855f, -0.02281672f, -0.01912638f, -0.04038504f, 
    -0.02383307f, -0.02487841f, -0.01052362f, -0.04345006f, 0.01753319f, -0.00030575f, -0.02477792f, 0.01878507f, 
    -0.00529362f, -0.04027674f, -0.01571933f, 0.02991626f, -0.01162270f, -0.00729467f, 0.01332782f, 0.01156873f, 
    0.02627784f, -0.01020240f, -0.00779746f, 0.00113963f, -0.00408316f, 0.02933957f, 0.00242458f, 0.00713343f, 
    -0.03681104f, -0.01754082f, -0.02442929f, -0.02643649f, 0.02591019f, -0.03529137f, 0.02531985f, 0.01807995f, 
    -0.03437062f, 0.00612725f, -0.04507668f, 0.01687196f, -0.01783251f, -0.01854772f, 0.01684407f, 0.02747839f, 
    -0.00891666f, 0.02561040f, 0.01356948f, 0.03136145f, -0.02145597f, 0.02600063f, 0.02674858f, -0.03195104f, 
    0.02426375f, -0.00758496f, -0.02143470f, -0.03678934f, -0.03871037f, 0.00684629f, 0.01059315f, -0.00916646f, 
    -0.02072677f, -0.01411575f, -0.02704353f, 0.02084779f, -0.03188589f, 0.01525139f, -0.01854122f, 0.00464682f, 
    0.00790533f, -0.00235508f, 0.03186113f, -0.04498231f, -0.03694457f, -0.02709638f, -0.02250690f, 0.02138760f, 
    -0.00114844f, -0.02707615f, -0.01097537f, 0.01609154f, -0.04546229f, -0.02970525f, -0.03523581f, 0.01907026f, 
    -0.02183635f, -0.02194304f, -0.03449586f, 0.00941524f, 0.02232481f, 0.02078188f, -0.00967158f, -0.04250491f, 
    -0.01484513f, 0.04498075f, 0.03191927f, -0.00080347f, -0.01456230f, -0.00150165f, -0.01396806f, 0.03344453f, 
    -0.03685363f, 0.02289114f, -0.00324561f, -0.03205473f, -0.01653883f, 0.02060368f, 0.02281386f, -0.01836739f, 
    -0.00845318f, 0.00773998f, 0.02126528f, -0.00457203f, 0.00822352f, 0.03082654f, 0.00036597f, -0.02995156f, 
    0.00980398f, -0.03563359f, -0.01092155f, 0.01460705f, 0.01933182f, 0.02572781f, 0.01454710f, -0.00807425f, 
    -0.03703408f, 0.01086327f, -0.04356585f, -0.02748609f, -0.01014648f, 0.02374291f, 0.00303885f, 0.02600193f, 
    -0.03529885f, 0.00627427f, -0.04236319f, 0.00076360f, -0.03112148f, 0.01953422f, 0.01383539f, -0.03500717f, 
    0.02595762f, 0.03171020f, 0.02508409f, -0.02788908f, 0.01336068f, -0.02685757f, -0.01586365f, 0.01016529f, 
    -0.00812491f, -0.02504801f, -0.02407262f, -0.01877684f, 0.02225196f, 0.02788811f, -0.01826816f, 0.00601237f, 
    0.00530262f, -0.01103858f, -0.01048976f, 0.01951461f, -0.00301855f, -0.03458496f, -0.00823258f, -0.01739250f, 
    -0.02473939f, -0.03827552f, -0.04441266f, -0.03077979f, 0.01677412f, 0.02149199f, -0.00566922f, 0.02172116f, 
    -0.00166080f, -0.01787445f, -0.01091070f, -0.01762328f, 0.02786384f, 0.01974116f, 0.03004062f, 0.03170278f, 
    -0.03658249f, -0.02659957f, -0.01848541f, 0.00945427f, 0.03266783f, 0.01456924f, 0.01478026f, 0.00605117f, 
    -0.02577422f, -0.01388841f, -0.04175273f, -0.04225941f, -0.01434361f, 0.00304784f, -0.00060764f, 0.02158711f, 
    0.02580393f, 0.01180015f, -0.02789578f, 0.01896773f, -0.02251921f, 0.00412673f, -0.01673538f, -0.01152162f, 
    -0.00020173f, 0.02524112f, 0.01517814f, -0.00101777f, -0.01816696f, -0.01856814f, -0.02925710f, 0.02068041f, 
    0.03342893f, -0.03182177f, -0.02832484f, -0.03822663f, 0.01282573f, -0.00880364f, 0.00864106f, 0.00136436f, 
    -0.01738030f, 0.00656431f, -0.03251657f, -0.01377931f, 0.00097085f, 0.01354508f, -0.01329795f, -0.02786464f, 
    0.00541451f, 0.01781517f, 0.01521324f, 0.00697427f, -0.03205932f, 0.03162864f, -0.04268385f, -0.02988198f, 
    0.00436313f, 0.01159909f, 0.00070510f, 0.02399526f, 0.01649704f, 0.00553358f, -0.03733154f, 0.01282092f, 
    0.01322760f, 0.02475052f, 0.02788464f, -0.01947449f, -0.01109148f, 0.00632845f, -0.00782162f, 0.00191786f, 
    -0.03341318f, -0.01177793f, 0.00574556f, -0.02795953f, -0.00946760f, 0.01488116f, -0.00529551f, 0.01007183f, 
    0.01789680f, -0.01090113f, 0.01371120f, -0.03007052f, 0.00341645f, 0.01467043f, 0.00123755f, -0.03288742f, 
    -0.01881582f, 0.02006909f, 0.02628176f, 0.00154112f, 0.02137188f, 0.01339384f, -0.01424769f, -0.02961778f, 
    -0.02288275f, -0.00188858f, -0.03965446f, -0.03875918f, 0.03107851f, -0.04357863f, -0.02079347f, 0.01716313f, 
    -0.00302002f, -0.01484850f, -0.03410672f, 0.01647501f, 0.00589671f, -0.02065098f, -0.01419891f, 0.03085377f, 
    -0.00774761f, 0.00297805f, 0.02704037f, -0.01979394f, -0.02379053f, -0.03607367f, -0.04264798f, -0.00853552f, 
    0.03189794f, 0.00597622f, 0.02860429f, 0.04226538f, -0.04328492f, 0.00369010f, -0.03440057f, -0.02756258f, 
    -0.00692391f, -0.01844661f, 0.03624545f, -0.02774753f, 0.00663976f, -0.01246676f, -0.04415107f, -0.02251578f, 
    -0.02543810f, -0.03480962f, 0.02858637f, 0.02629134f, -0.01628926f, -0.01551360f, 0.01080971f, 0.02680602f, 
    0.02412768f, -0.00348664f, 0.02047703f, -0.03257664f, 0.01169296f, 0.03087079f, 0.00112040f, -0.01783055f, 
    -0.02656437f, -0.02012175f, -0.02202613f, -0.00833576f, -0.00559635f, -0.01271101f, -0.00142388f, -0.00914047f, 
    -0.01337939f, 0.02968564f, -0.00271864f, -0.04095243f, -0.01058834f, -0.03886462f, 0.00549595f, -0.02057380f, 
    0.03042143f, -0.02857155f, -0.03126133f, -0.04173077f, 0.00486493f, 0.01890645f, -0.02365252f, 0.02317178f, 
    -0.00126600f, -0.02767591f, 0.01201561f, 0.01495880f, 0.02394555f, -0.00249778f, 0.00901201f, 0.00649576f, 
    0.00554711f, -0.04066892f, -0.01001208f, 0.02556683f, -0.00888882f, 0.01892526f, 0.01768310f, -0.00742318f, 
    -0.02871217f, -0.01266260f, -0.00875315f, -0.00800972f, -0.02667288f, 0.00247934f, -0.02493957f, -0.01010850f, 
    -0.02448431f, 0.12302623f, -0.09426127f, 0.17574559f, 0.11569836f, -0.10406540f, 0.07167445f, 0.04894869f, 
    0.05803420f, -0.03951198f, -0.01556052f, 0.00584440f, 0.05062221f, -0.02689895f, -0.03316762f, 0.06322709f, 
    0.15859517f, -0.02354457f, 0.01724717f, 0.00779258f, -0.01416117f, -0.01696180f, -0.12638293f, -0.32237989f, 
    0.02354053f, -0.21221381f, 0.07011010f, -0.06121448f, -0.12799612f, -0.00963930f, 0.19820927f, 0.03783502f, 
    0.04264120f, -0.10320323f, 0.11596743f, 0.04366196f, 0.07792142f, 0.02952570f, -0.08460732f, 0.03189051f, 
    0.07531819f, 0.10843127f, -0.05862510f, -0.04711846f, 0.04018182f, -0.02603523f, 0.04361751f, -0.05926819f, 
    -0.04630193f, -0.07516388f, 0.02944223f, 0.09280349f, 0.06389979f, -0.08740502f, 0.13143899f, 0.13716902f, 
    0.00760482f, 0.03903551f, 0.05987456f, 0.01415252f, -0.30746490f, 0.07372492f, 0.25251338f, -0.13988571f, 
    0.15708943f, 0.01475687f, 0.01586342f, -0.00327941f, 0.16172104f, -0.02243825f, -0.00410748f, -0.11069341f, 
    0.02352016f, -0.05715716f, 0.04750635f, -0.00727157f, -0.06525855f, -0.01603405f, -0.03039869f, -0.04621447f, 
    -0.37150589f, 0.21623197f, 0.28738779f, 0.15203333f, -0.06190832f, -0.14039171f, -0.07134525f, 0.18805601f, 
    -0.05061125f, 0.04555767f, 0.00466075f, 0.01579450f, -0.05024002f, 0.02827802f, -0.05040445f, -0.04844869f, 
    -0.01322906f, 0.06342141f, -0.02815689f, -0.02926014f, -0.23600660f, -0.26028025f, -0.20548606f, -0.26886809f, 
    -0.28540847f, 0.09860238f, 0.01528616f, 0.06831653f, -0.14946748f, -0.02427464f, 0.12410537f, 0.05537596f, 
    0.05200726f, 0.04536153f, 0.02454072f, 0.12286510f, 0.05993872f, -0.08851869f, -0.16802056f, 0.06047605f, 
    0.07979674f, -0.26544917f, -0.10265872f, -0.30167732f, -0.17053387f, 0.00413600f, 0.02437594f, -0.16559386f, 
    -0.02978962f, -0.03975117f, 0.01942392f, -0.03547048f, -0.03411302f, 0.08242466f, 0.03982307f, -0.03789458f, 
    -0.01193090f, -0.06031383f, -0.21690483f, 0.08253274f, 0.21055214f, 0.21820430f, 0.06687919f, -0.01033017f, 
    -0.06713881f, 0.04397171f, 0.00266970f, 0.07233068f, -0.02854409f, 0.11884586f, 0.00182749f, 0.03934225f, 
    0.00157227f, 0.09603079f, 0.04647497f, 0.09872974f, 0.12679362f, -0.07154758f, 0.01915173f, 0.03966827f, 
    0.09877936f, 0.08363770f, 0.26030114f, -0.03471087f, 0.08146656f, 0.02995937f, 0.07642273f, 0.13382220f, 
    0.10424274f, 0.14182872f, -0.07082161f, -0.10811079f, 0.03354120f, 0.08614223f, -0.09448825f, -0.02828548f, 
    -0.01424661f, 0.11728124f, 0.02730958f, -0.00492868f, 0.04478186f, 0.00281002f, -0.11557535f, 0.02261822f, 
    0.07327498f, -0.03901219f, 0.05382430f, -0.09236228f, 0.06163354f, 0.01923680f, -0.06669196f, 0.02701497f, 
    -0.03135440f, -0.07485998f, 0.00077374f, 0.11842687f, 0.10120416f, -0.16853364f, 0.08637579f, -0.03095449f, 
    0.14472595f, 0.26304379f, -0.13684289f, 0.06392039f, -0.11316066f, 0.04480102f, -0.06295563f, -0.01602447f, 
    -0.01190414f, -0.03200491f, -0.04238609f, 0.05451488f, 0.03403054f, 0.02144618f, 0.09264735f, -0.17101067f, 
    0.07499140f, 0.03559283f, -0.02893340f, -0.00551089f, 0.04754429f, -0.20856182f, -0.12979184f, -0.38590729f, 
    -0.13730273f, 0.06023619f, 0.04938640f, -0.14713180f, -0.02424231f, -0.09433021f, 0.17498143f, 0.01751453f, 
    -0.08909193f, -0.04895050f, 0.02097802f, 0.07836584f, 0.04045002f, -0.06307294f, -0.07662573f, 0.03104827f, 
    -0.50704825f, 0.21556811f, -0.07040500f, 0.01264620f, -0.15114917f, 0.08070897f, -0.01608975f, -0.00495933f, 
    -0.03571444f, -0.01619937f, 0.04949709f, 0.09095728f, -0.12117440f, 0.05967399f, 0.12202575f, 0.00607645f, 
    0.07130458f, -0.13988577f, -0.07735948f, 0.03260017f, 0.11268615f, 0.01445595f, -0.09667518f, -0.11428040f, 
    0.07243520f, -0.02030981f, -0.04324156f, -0.14492612f, -0.00161941f, -0.06184389f, -0.02281130f, 0.06330571f, 
    0.01347488f, 0.02638498f, 0.01814917f, -0.06745238f, 0.01678481f, -0.31564039f, -0.11137646f, -0.06262586f, 
    0.14977115f, 0.06875723f, -0.00004697f, 0.14353840f, -0.06472190f, -0.01919666f, 0.05801168f, 0.09343304f, 
    0.07501954f, 0.02271869f, -0.01415928f, 0.04712686f, 0.03855497f, -0.04282904f, 0.11217527f, -0.00237425f, 
    -0.01406567f, 0.07204962f, -0.13090119f, 0.05464941f, 0.30775318f, 0.21435378f, -0.21792790f, 0.01458068f, 
    -0.15494885f, 0.08021407f, 0.00149950f, 0.03839220f, -0.13836169f, -0.16428675f, 0.09322897f, 0.12788641f, 
    0.05012884f, -0.01604824f, -0.06262849f, -0.04801390f, 0.15453206f, 0.09052681f, 0.06827011f, 0.16781661f, 
    -0.04668913f, 0.10118102f, 0.24865957f, 0.06219047f, 0.03379717f, -0.03706293f, -0.02605532f, 0.06762043f, 
    0.07729763f, 0.01717581f, -0.13108203f, 0.03695809f, 0.10918783f, 0.11945117f, -0.10586465f, -0.09221361f, 
    0.07584224f, 0.02880981f, 0.17784227f, -0.14056376f, 0.50877482f, 0.02985128f, 0.32098162f, -0.23072311f, 
    -0.11056928f, 0.07219390f, 0.11215154f, -0.02699821f, -0.00342381f, 0.01922809f, 0.03674167f, 0.02824473f, 
    0.11999699f, 0.12825666f, 0.03926015f, 0.00736474f, -0.10130993f, 0.02514573f, 0.00593964f, -0.08190256f, 
    0.01539288f, -0.11141977f, 0.03638417f, -0.13385585f, -0.06186925f, 0.05483409f, 0.04049264f, -0.01550762f, 
    -0.07695389f, -0.12654135f, 0.03033882f, 0.01575851f, -0.04105551f, -0.06639504f, 0.01456377f, -0.00696093f, 
    0.07012019f, 0.15788268f, 0.16249308f, 0.06808218f, 0.11963941f, 0.11863992f, -0.01822419f, 0.09095746f, 
    -0.08877246f, 0.01223028f, 0.06430978f, 0.10897666f, 0.02373143f, 0.06341749f, -0.04463361f, -0.06260344f, 
    0.18080890f, -0.03362961f, 0.06057008f, 0.07771443f, 0.01582674f, -0.08034418f, 0.02904572f, -0.08368801f, 
    0.13738944f, -0.07164671f, -0.02891413f, 0.16143340f, 0.11653183f, 0.06047770f, -0.01246282f, -0.14205198f, 
    -0.04468864f, -0.01113263f, -0.00103950f, 0.09176833f, -0.02832064f, -0.01604101f, -0.02329049f, 0.05850936f, 
    0.13403080f, 0.13342537f, 0.00436630f, -0.09641971f, 0.07487748f, 0.05301262f, -0.03275861f, 0.12617701f, 
    -0.02967411f, 0.07031565f, -0.00636740f, 0.02211378f, 0.08971645f, -0.00925513f, 0.07785862f, 0.00716381f, 
    -0.00258627f, 0.09507995f, 0.14760424f, 0.08586529f, 0.06355409f, 0.00510903f, -0.07978810f, 0.12862939f, 
    0.11511289f, -0.06537377f, -0.06299824f, 0.08658808f, -0.00622978f, -0.09578034f, 0.03020683f, 0.05104009f, 
    0.09195237f, 0.04034251f, 0.16624352f, -0.03106930f, -0.05834428f, -0.01939717f, 0.11800424f, 0.09622382f, 
    -0.10126123f, 0.11360951f, 0.00392827f, 0.13808163f, 0.34205744f, 0.27672148f, 0.01614446f, 0.09258465f, 
    -0.10573681f, -0.00682506f, 0.05208817f, -0.01162894f, 0.10003120f, -0.03440544f, 0.00717004f, 0.06867689f, 
    0.05519062f, 0.19630662f, 0.03328209f, -0.04548154f, 0.05702925f, -0.01736041f, -0.01834065f, -0.01823758f, 
    -0.06427363f, -0.23941104f, -0.06325534f, -0.30377308f, -0.13635619f, 0.04985634f, 0.09341398f, 0.05230328f, 
    -0.07198513f, 0.10187425f, -0.02996588f, 0.05963848f, -0.02441530f, 0.08570302f, -0.01667654f, 0.09726747f, 
    0.00092566f, -0.16889824f, -0.06834746f, -0.04177970f, 0.06436995f, 0.00147353f, 0.05973672f, 0.21213424f, 
    0.02897527f, -0.05299469f, -0.01786160f, -0.01803526f, 0.04150422f, 0.04555612f, 0.06328858f, 0.12929280f, 
    -0.05180039f, -0.03274314f, 0.13968620f, 0.16371001f, 0.01992474f, 0.04641935f, 0.01433132f, -0.02584160f, 
    0.10482194f, 0.00835144f, 0.21731913f, -0.08559161f, 0.18145458f, 0.04591953f, 0.07257157f, 0.08110557f, 
    0.14626834f, 0.11683101f, -0.09297242f, -0.10601719f, -0.04536217f, -0.00633855f, 0.04549239f, -0.00222039f, 
    0.02282744f, -0.02974533f, 0.04344056f, -0.04402912f, 0.06652366f, -0.22194675f, 0.02430605f, 0.11237919f, 
    0.05596476f, 0.09987010f, -0.05538367f, -0.06404994f, 0.07615688f, -0.04463038f, 0.01539225f, 0.01412807f, 
    -0.11809608f, 0.07918542f, -0.03369806f, 0.04791189f, 0.14402135f, -0.01793819f, -0.00747028f, 0.02240516f, 
    0.18241556f, 0.10086686f, -0.09174253f, 0.03966365f, -0.00491108f, 0.08688103f, 0.02351122f, -0.12304492f, 
    0.03864327f, -0.00216661f, 0.03956467f, 0.02199860f, 0.10681023f, -0.04974253f, 0.08668369f, -0.04347502f, 
    -0.09605948f, 0.06168377f, -0.07598425f, -0.01106579f, 0.10100726f, -0.00242039f, -0.15407844f, -0.00898232f, 
    0.02127173f, -0.03774717f, -0.04907912f, -0.08503891f, 0.09030549f, -0.02687886f, -0.08805302f, 0.01053164f, 
    0.16178025f, 0.08758949f, 0.06590445f, -0.05129171f, 0.07071158f, -0.12804864f, -0.10341008f, 0.03398660f, 
    -0.03528468f, -0.01390372f, -0.14525896f, -0.16960385f, -0.04729434f, -0.10189293f, -0.06057391f, 0.00247344f, 
    -0.00820902f, 0.03055546f, 0.05267363f, 0.02515338f, -0.04363765f, 0.01627386f, 0.09498869f, -0.02516816f, 
    -0.01372277f, -0.04229606f, -0.02159617f, 0.03348057f, -0.03053052f, 0.00578245f, 0.10864975f, 0.12093622f, 
    0.00607419f, 0.08051312f, -0.02937830f, 0.07994363f, -0.04810102f, -0.05233150f, -0.11333562f, 0.00814048f, 
    0.06348979f, -0.06922795f, 0.09627744f, -0.04569558f, 0.00164124f, 0.11949250f, 0.10101821f, 0.10359552f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00299425f, -0.01611639f, 0.00044955f, -0.01419480f, 0.01379861f, -0.04581367f, 0.16149728f, -0.03959803f, 
    -0.02382156f, -0.03567880f, -0.03756716f, -0.00535140f, 0.02411349f, 0.01524953f, 0.03067683f, 0.00171665f, 
    -0.00358072f, -0.01518303f, 0.02038113f, 0.09375619f, -0.00874812f, -0.04457885f, 0.00938581f, -0.04295381f, 
    0.01555601f, -0.03250592f, 0.01778200f, -0.03891262f, 0.07034595f, 0.07544044f, -0.01181024f, 0.04401076f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01506636f, -0.15449302f, 0.08573330f, -0.05285508f, -0.07647301f, -0.16597186f, -0.11264563f, -0.03738887f, 
    -0.06399477f, -0.06163515f, -0.10279277f, -0.05622950f, -0.17099692f, 0.08383948f, -0.14419580f, -0.05639980f, 
    -0.09242949f, -0.03905459f, 0.11448491f, 0.03650619f, 0.03179788f, -0.11212505f, -0.11047778f, -0.13231124f, 
    0.03823941f, 0.08964811f, 0.05849656f, -0.13462822f, -0.07844536f, 0.01352874f, -0.13481173f, -0.09302079f, 
    0.08883388f, -0.14581269f, -0.16693586f, 0.04983481f, -0.00325585f, 0.02085411f, 0.03706096f, 0.06435648f, 
    -0.05785479f, 0.20421807f, 0.17405437f, 0.14999917f, 0.13683046f, -0.17057158f, 0.16713461f, -0.13955076f, 
    -0.10107145f, 0.10842456f, 0.06977098f, 0.21881823f, -0.19700681f, 0.20380732f, 0.37695381f, -0.02523717f, 
    -0.00370745f, 0.01788687f, -0.05062042f, 0.04878994f, -0.06229957f, -0.24101664f, 0.15074082f, 0.20131862f, 
    -0.23284502f, 0.14366864f, -0.10164008f, 0.14556347f, 0.05192288f, -0.01890493f, 0.01200802f, 0.11493086f, 
    -0.08047831f, 0.23753288f, -0.02887274f, 0.06982266f, 0.00588389f, -0.09645266f, -0.17312793f, -0.07156174f, 
    0.16775630f, -0.17316234f, 0.01558999f, -0.22212158f, 0.43056422f, -0.55917579f, -0.18490028f, -0.03397961f, 
    0.01952814f, 0.01864743f, 0.40729466f, -0.08922110f, 0.31406683f, 0.21878053f, 0.14047508f, -0.08836126f, 
    0.48026311f, 0.14931405f, 0.14555885f, -0.08214605f, -0.06566871f, 0.01735594f, 0.12009743f, -0.19309141f, 
    0.07498516f, 0.16833775f, 0.11825676f, -0.00311507f, -0.15157807f, -0.15549316f, 0.01804421f, 0.24891849f, 
    0.12990753f, -0.03230848f, 0.09753370f, 0.09395468f, -0.29662782f, 0.05530880f, 0.20154487f, -0.16848403f, 
    -0.35683066f, 0.08253220f, -0.33994454f, -0.16265033f, 0.23770539f, -0.12864201f, -0.13336864f, 0.31158122f, 
    0.30085447f, 0.03860510f, -0.00670764f, -0.03322636f, 0.13443632f, 0.05366517f, -0.24876039f, 0.10179095f, 
    0.09257336f, 0.08371426f, -0.06387801f, -0.05947187f, -0.11610421f, -0.11727791f, 0.02919640f, 0.08099394f, 
    0.13732672f, 0.10424178f, 0.05893855f, -0.16594146f, 0.15743704f, 0.50667733f, 0.49772337f, -0.15818673f, 
    0.25540906f, 0.13730660f, -0.30150041f, -0.12986037f, 0.27032337f, 0.13013576f, 0.02005351f, -0.26300764f, 
    0.17688009f, 0.06301537f, 0.09946474f, -0.14214669f, -0.11948637f, -0.17129837f, 0.07577460f, -0.28268489f, 
    0.10449384f, 0.22446473f, 0.01374043f, 0.11224489f, 0.15456423f, -0.00271166f, -0.03097611f, 0.14134805f, 
    0.02606230f, 0.05352818f, -0.12304035f, -0.34650761f, 0.07176892f, 0.11603808f, -0.41368368f, -0.08115453f, 
    0.07780807f, 0.15633474f, -0.02632958f, 0.13307075f, 0.06201153f, 0.23007055f, 0.12617607f, -0.14061473f, 
    -0.10788728f, 0.05053284f, -0.15714835f, 0.00992972f, 0.16368805f, -0.09985197f, -0.11066812f, 0.14776336f, 
    0.01544875f, 0.20643321f, 0.07873729f, -0.08569115f, 0.13555656f, 0.14975087f, 0.00972982f, 0.04470671f, 
    0.01782306f, -0.02869686f, 0.17795999f, -0.65321487f, -0.03660385f, -0.22343744f, 0.05818656f, 0.10652786f, 
    0.10724065f, 0.14077851f, 0.53186327f, 0.09221786f, 0.17444037f, 0.03086447f, -0.16785751f, 0.40810588f, 
    0.22018412f, 0.00927192f, 0.16401051f, 0.02815222f, -0.08161632f, 0.06112581f, -0.20918666f, 0.29687798f, 
    -0.08931842f, 0.41683978f, 0.05487504f, -0.14260265f, 0.09131271f, 0.01128658f, 0.14396180f, 0.28517193f, 
    -0.14672531f, 0.00955725f, -0.09080300f, 0.24211593f, -0.36267152f, 0.24466261f, -0.16907582f, -0.09874772f, 
    0.06619088f, 0.02177904f, 0.32076365f, 0.05929316f, -0.28027692f, 0.36447203f, -0.06936716f, 0.03749856f, 
    -0.16511005f, 0.06282465f, 0.10118622f, 0.02006453f, 0.02966080f, 0.01201729f, -0.10366201f, -0.11322974f, 
    0.05694773f, -0.02182810f, 0.09124213f, 0.10815714f, 0.10525562f, -0.14231940f, 0.02168752f, -0.08337025f, 
    0.10139581f, 0.05000804f, 0.15994294f, 0.07179189f, 0.06874611f, 0.11500886f, -0.03566564f, 0.03349686f, 
    -0.15035576f, -0.10792461f, 0.08717640f, 0.08766989f, -0.12031843f, -0.09875380f, -0.01877983f, -0.12631674f, 
    -0.05656514f, 0.15113200f, -0.07530826f, 0.10484692f, -0.00515715f, 0.08564711f, 0.05366066f, -0.34352231f, 
    0.05235833f, 0.12431208f, -0.12795408f, 0.02495167f, -0.15356472f, 0.03238127f, 0.15167058f, -0.22571848f, 
    -0.00009201f, 0.09222887f, -0.11674035f, 0.01764231f, -0.08151861f, -0.25001478f, 0.45039740f, -0.04961438f, 
    0.36339056f, 0.08791578f, 0.18238828f, -0.10065244f, -0.05248147f, 0.37293077f, 0.00097552f, 0.00513923f, 
    0.31627637f, -0.15172686f, -0.08059861f, 0.07829624f, -0.19025944f, 0.11066899f, -0.11613002f, 0.08873011f, 
    -0.03015548f, 0.35936576f, -0.09379476f, 0.02670016f, 0.02947632f, -0.09250954f, -0.07015248f, -0.20801470f, 
    0.17189008f, 0.07103494f, -0.17273740f, -0.10972536f, 0.24133310f, 0.10835698f, -0.05016955f, 0.07748190f, 
    0.23945837f, 0.05695475f, -0.17511083f, 0.11843321f, 0.04114294f, 0.23995623f, -0.06672097f, -0.31576112f, 
    0.33627543f, -0.01773430f, 0.06277981f, 0.12204589f, -0.03959296f, 0.06484435f, 0.12310447f, 0.23622537f, 
    0.17100461f, -0.06991874f, -0.13738412f, 0.06832837f, -0.03701813f, -0.15087304f, -0.08751784f, 0.53597558f, 
    -0.10399754f, 0.04427029f, -0.05287213f, 0.02783544f, 0.03498380f, -0.15256839f, 0.06088092f, 0.11183150f, 
    -0.21042310f, 0.05352333f, -0.01437323f, 0.08252838f, -0.12044294f, -0.03093135f, -0.05528764f, -0.16801165f, 
    0.07182375f, 0.11032134f, 0.11062245f, -0.06813196f, -0.11362866f, 0.15296476f, -0.08417902f, -0.07599007f, 
    -0.17488714f, -0.16366822f, -0.11531526f, 0.00751062f, -0.12716040f, -0.00515752f, 0.12167025f, -0.04628337f, 
    0.00464726f, -0.16530395f, -0.05864882f, 0.10587172f, 0.10755055f, -0.15693878f, -0.09519083f, 0.13796550f, 
    0.10255031f, 0.15396725f, -0.11377162f, 0.16810824f, -0.01090634f, -0.10450581f, 0.03420424f, -0.05842248f, 
    0.14376804f, -0.12784730f, 0.04250328f, -0.02877408f, -0.05484147f, 0.12518568f, 0.16216843f, -0.31158569f, 
    0.14276424f, -0.22298868f, 0.06243759f, -0.15871871f, -0.02032645f, 0.09948376f, -0.15015532f, 0.29326162f, 
    0.15654029f, -0.06363417f, -0.11984462f, 0.32797292f, -0.36297163f, -0.22976297f, 0.12627327f, -0.04898378f, 
    -0.18658075f, 0.14198053f, 0.19619901f, -0.15253529f, -0.07807439f, 0.29575855f, 0.06477895f, -0.00673931f, 
    0.06669069f, 0.02398300f, -0.07149900f, 0.02858096f, 0.13611536f, -0.07466978f, 0.24075991f, 0.11601606f, 
    0.15146187f, -0.08096568f, 0.13379699f, -0.10918044f, 0.10540982f, 0.16290227f, 0.13605899f, -0.19804364f, 
    -0.02669217f, 0.04677420f, -0.12677933f, 0.29749760f, -0.23263562f, 0.02167209f, -0.61980599f, -0.07823104f, 
    0.22647141f, -0.16712454f, 0.30703855f, 0.00528356f, -0.15820456f, 0.23157136f, 0.09377001f, 0.18144250f, 
    0.13558888f, -0.02007349f, 0.02843173f, 0.14506665f, 0.10867673f, 0.09422916f, 0.20071165f, -0.09931385f, 
    -0.05526713f, -0.36538705f, 0.07719662f, 0.13694048f, 0.01675529f, -0.03507974f, 0.00434465f, 0.13523968f, 
    -0.10475095f, 0.14489770f, 0.00422551f, 0.20179006f, 0.19992329f, 0.26339403f, -0.45119211f, -0.06786768f, 
    -0.00784992f, -0.14757016f, -0.06126579f, -0.11717180f, -0.00867773f, 0.06508365f, 0.09642718f, -0.21277343f, 
    0.10503612f, -0.02501386f, -0.16344281f, -0.00760002f, -0.12814604f, 0.13636462f, 0.17535920f, -0.00822013f, 
    -0.16338550f, -0.37950712f, -0.05003762f, -0.15932314f, 0.14784381f, -0.07224400f, -0.06387616f, 0.41341639f, 
    -0.16845968f, 0.15822242f, -0.10683676f, -0.41235337f, 0.07007352f, 0.38409564f, -0.33249345f, -0.16055681f, 
    0.04799150f, -0.01447035f, 0.22001900f, 0.01630135f, -0.12338470f, -0.25093240f, 0.16350378f, 0.38132942f, 
    -0.03312163f, -0.09177615f, 0.16727430f, 0.07843379f, -0.05797307f, -0.04586315f, 0.29391563f, -0.24067619f, 
    0.13368914f, -0.27691275f, 0.16054673f, 0.05344349f, -0.13688220f, -0.06381091f, 0.12132382f, -0.06298374f, 
    -0.07611383f, -0.10558270f, 0.01853584f, -0.27668962f, 0.54351294f, -0.13032694f, 0.37745130f, -0.12833460f, 
    0.21646385f, 0.02844388f, -0.32576376f, -0.14996390f, 0.39130473f, -0.03243681f, 0.11968442f, -0.30462179f, 
    0.01693340f, 0.11660514f, 0.02820792f, -0.15910996f, 0.11248336f, -0.17330560f, -0.17273061f, -0.00542568f, 
    -0.01019772f, 0.06179167f, -0.10611256f, 0.01679562f, 0.03977349f, -0.09745296f, 0.02309377f, -0.07286075f, 
    -0.01159843f, 0.13041966f, 0.06166570f, 0.05164841f, -0.06690317f, -0.12064941f, 0.14127170f, -0.05853299f, 
    -0.12417406f, 0.04517573f, -0.13784371f, -0.02949928f, 0.10028769f, -0.14252691f, -0.16599870f, -0.11492717f, 
    0.33970860f, -0.01873493f, -0.01149559f, 0.16945651f, 0.03284940f, -0.15852235f, 0.04870857f, -0.20265169f, 
    -0.17122322f, 0.31945646f, 0.09198949f, 0.05581513f, -0.00469914f, 0.16395585f, 0.08176385f, 0.12098754f, 
    0.14241271f, 0.03469544f, 0.03730350f, -0.18303825f, -0.12958594f, -0.30638337f, -0.10346253f, 0.09798888f, 
    0.18304555f, -0.05150092f, -0.12083536f, -0.02845840f, -0.05193529f, 0.30130041f, -0.01019199f, -0.08597793f, 
    0.02605343f, -0.00660665f, 0.11429818f, 0.11007987f, 0.06903548f, -0.01804180f, -0.08482718f, -0.23895341f, 
    -0.10285630f, 0.36301151f, -0.02032538f, -0.11862230f, -0.08583915f, 0.09537972f, -0.01930586f, 0.39431036f, 
    -0.17305641f, -0.12802759f, -0.09655232f, -0.17938183f, 0.12175778f, -0.40799201f, 0.31152344f, -0.11342141f, 
    0.00283479f, -0.00256339f, 0.11992977f, -0.05874857f, 0.22685596f, 0.29630840f, -0.17341778f, -0.41952202f, 
    -0.01935086f, 0.15586349f, -0.14672643f, -0.01906902f, 0.00985824f, 0.14443550f, 0.29232290f, -0.42917445f, 
    -0.08520897f, -0.26956636f, 0.10458115f, 0.09681921f, 0.06968837f, -0.01921969f, 0.06911665f, -0.05344865f, 
    -0.14736979f, -0.00292256f, 0.05914664f, 0.08483330f, 0.03306361f, -0.25284636f, 0.06207794f, -0.16285302f, 
    -0.10103385f, -0.10126071f, 0.02894148f, -0.13808957f, 0.11002509f, 0.17228608f, -0.03257348f, -0.15926617f, 
    0.00379219f, -0.10754021f, -0.16592927f, -0.12725769f, -0.11479901f, 0.10873532f, 0.29768160f, 0.44558242f, 
    -0.10095824f, 0.09894208f, 0.17719162f, -0.00567891f, -0.08864018f, 0.03716835f, 0.14074340f, -0.30746308f, 
    0.00953687f, -0.07702904f, -0.10083454f, 0.43531415f, 0.25991124f, 0.02034477f, 0.20961358f, 0.03750056f, 
    -0.19920683f, 0.02213698f, -0.10805026f, -0.10875925f, 0.30983350f, -0.21510279f, 0.08847415f, 0.32371992f, 
    -0.23709927f, 0.08409163f, -0.09369090f, 0.12821229f, 0.02733509f, 0.11912203f, 0.12918495f, 0.06771473f, 
    -0.16067040f, 0.06573369f, -0.04979157f, -0.09044703f, 0.13794188f, -0.11636985f, 0.00119597f, -0.37389272f, 
    -0.15426502f, 0.11250975f, 0.08670953f, -0.00265358f, -0.22127210f, 0.00567667f, 0.44192612f, 0.11028224f, 
    0.06300519f, -0.02503925f, 0.26981151f, -0.06815755f, 0.21610892f, 0.20240684f, -0.16114461f, 0.38046041f, 
    0.06072837f, -0.12113984f, -0.03707962f, -0.10256229f, -0.01667259f, -0.11234147f, 0.16722675f, -0.35574296f, 
    -0.11537936f, 0.05414980f, 0.06445239f, 0.09395889f, 0.01274000f, 0.03711626f, 0.07293107f, 0.04659712f, 
    -0.03099884f, -0.05253385f, 0.03977984f, 0.04544960f, -0.33798206f, 0.38851181f, -0.25275546f, -0.01531576f, 
    0.18486583f, 0.14223740f, -0.19684777f, 0.12984356f, -0.20741609f, 0.08889148f, -0.06480023f, 0.54937959f, 
    -0.26015884f, -0.04781574f, -0.02373540f, 0.12591003f, -0.08079477f, 0.04128284f, -0.10896999f, 0.14798149f, 
    -0.14742358f, -0.32484719f, -0.06380805f, -0.08003316f, 0.04283091f, 0.06036955f, -0.10748411f, 0.42742559f, 
    0.01758613f, -0.14233023f, -0.01486012f, -0.00088122f, -0.08587816f, -0.18621975f, 0.40509766f, 0.08456343f, 
    -0.05851503f, -0.05634413f, 0.41759741f, 0.13957128f, 0.26119548f, 0.20649692f, -0.07085547f, -0.05725964f, 
    -0.20509404f, 0.04014412f, 0.16494070f, 0.13344142f, -0.03552661f, 0.00955317f, 0.11301916f, -0.42787531f, 
    -0.09676623f, 0.03662588f, -0.04952200f, 0.11504347f, 0.08065042f, -0.04219481f, -0.05561719f, 0.15422809f, 
    -0.09728313f, -0.03923125f, 0.11116804f, 0.02331058f, -0.11427933f, 0.22097114f, -0.20169397f, 0.01811650f, 
    0.04959962f, 0.15403612f, 0.31214088f, 0.13632672f, -0.35157424f, 0.23100773f, -0.17352508f, 0.01236826f, 
    -0.04308186f, -0.08579435f, 0.14649759f, -0.10051046f, 0.11810752f, 0.13349973f, 0.11643503f, 0.37860936f, 
    0.10115448f, 0.41129175f, 0.14050566f, 0.09672362f, -0.12589549f, -0.11271406f, -0.01490363f, 0.30225429f, 
    -0.09959410f, -0.17721349f, 0.09708764f, -0.29901969f, -0.10223274f, 0.24958426f, 0.14785677f, -0.02649933f, 
    -0.25415102f, -0.13264149f, 0.31322411f, -0.02197352f, 0.01174556f, -0.22138789f, 0.15047036f, 0.46909913f, 
    -0.08303606f, 0.11869148f, 0.11768080f, -0.04024988f, -0.01868001f, 0.05870335f, -0.02787934f, -0.09237080f, 
    -0.14907815f, -0.03963029f, -0.13522722f, -0.00691979f, -0.06599955f, 0.03708612f, -0.00688504f, 0.01392740f, 
    -0.12272317f, -0.16046296f, 0.02704194f, -0.09084313f, 0.10350437f, -0.13965414f, -0.05908893f, 0.15681139f, 
    -0.16721827f, 0.10004032f, -0.16735391f, 0.07406150f, -0.03519439f, -0.08408956f, 0.09747078f, 0.05121765f, 
    -0.02491193f, 0.06492669f, -0.09343468f, -0.05907332f, 0.02169558f, -0.04045421f, 0.17419253f, 0.19427292f, 
    0.09076142f, 0.00021330f, 0.06168507f, 0.00381207f, 0.13665645f, -0.15399152f, -0.12932804f, 0.04095925f, 
    -0.00488854f, -0.06464215f, 0.07968892f, -0.55035490f, 0.68682969f, -0.15955488f, -0.31135038f, -0.02550521f, 
    0.31913292f, 0.15762292f, 0.08359093f, -0.02891328f, 0.14676677f, 0.05825623f, -0.13542700f, -0.14660123f, 
    -0.25117344f, -0.09637228f, -0.16428429f, -0.00810538f, -0.12194286f, -0.01624388f, 0.08106102f, 0.16792060f, 
    0.03856518f, 0.11395892f, -0.01031033f, 0.02103703f, -0.07229465f, -0.07267262f, 0.17703390f, 0.13766372f, 
    0.04697536f, -0.14593680f, -0.15957224f, 0.19985972f, -0.30859378f, -0.12519513f, -0.08640908f, 0.05763392f, 
    0.07440589f, -0.17298913f, 0.68041265f, 0.03284414f, -0.14386605f, 0.18520372f, -0.00332600f, -0.05747717f, 
    0.01195422f, 0.12323878f, 0.12298077f, -0.08218317f, 0.03755636f, -0.05131233f, -0.18345502f, 0.12884000f, 
    -0.08611611f, -0.08373848f, -0.04959677f, 0.04698218f, -0.12326986f, 0.05112911f, 0.15000130f, 0.10951884f, 
    -0.04118493f, -0.12980415f, -0.16991979f, 0.02566840f, -0.15391363f, -0.01926706f, -0.17265487f, 0.17656015f, 
    -0.14160052f, 0.17629835f, -0.10106640f, 0.05364534f, 0.08484769f, -0.01204829f, -0.12880719f, -0.17522372f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14544339f, -0.06722498f, 0.02436254f, 0.14678967f, 0.05026622f, -0.04802687f, 0.02154969f, 0.01278032f, 
    -0.01959472f, -0.07405466f, 0.04402450f, -0.15658762f, -0.07515849f, 0.02913359f, 0.04751104f, 0.22677748f, 
    -0.15859771f, 0.04819633f, 0.05069273f, 0.07639016f, 0.01239066f, 0.12142675f, 0.11234558f, -0.10185330f, 
    -0.07715170f, 0.14455375f, -0.13606630f, -0.15417911f, 0.00012455f, 0.12983325f, -0.02758453f, 0.11055150f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.01726291f, -0.31608886f, 0.11194058f, -0.26912704f, 0.14184739f, -0.11365708f, 0.60347050f, -0.01749519f, 
    0.02150301f, 0.08186085f, -0.19780447f, 0.04882685f, 0.12545930f, -0.10543707f, -0.38510644f, -0.59197205f, 
    0.03537825f, -0.29226011f, 0.15347542f, 0.10409170f, 0.27342424f, -0.35529423f, -0.30235723f, 0.08491558f, 
    -0.41950825f, 0.45752954f, 0.14290386f, 0.25771120f, 0.16650890f, 0.11282317f, 0.18401676f, 0.07064707f, 
    -0.16266024f, 0.30132967f, 0.47985306f, -0.52482516f, 0.07972958f, 0.00118969f, -0.26012033f, -0.16754264f, 
    -0.09684384f, -0.02278845f, 0.10568088f, 0.00253874f, -0.07129667f, -0.25017297f, -0.20069852f, -0.03481090f, 
    -0.54039508f, 0.24071229f, 0.16858159f, 0.09034369f, 0.30199650f, 0.19279195f, 0.11534005f, -0.16382475f, 
    -0.80723161f, 0.19824499f, -0.00250580f, -0.17528017f, -0.01766786f, 0.22847424f, 0.10717221f, -0.16298078f, 
    -0.12482375f, -0.25405121f, 0.24706337f, -0.46894202f, -0.60503501f, 0.07259347f, 0.33721131f, -0.13026889f, 
    0.15382162f, 0.21321493f, -0.25325087f, -0.57597190f, -0.06170917f, -0.06954899f, 0.34250906f, -0.05713582f, 
    -0.18852462f, -0.12383623f, -0.10094079f, 0.14001077f, -0.16830033f, 0.03054069f, -0.02426089f, 0.13354157f, 
    0.17117558f, -0.26123619f, 0.16255762f, -0.01399324f, -0.15045448f, 0.13996205f, 0.23718649f, -0.01743830f, 
    -0.04946590f, 0.08894473f, -0.88313717f, 0.01933677f, 0.02146180f, -0.62869579f, -0.10892879f, 0.38120827f, 
    0.12921782f, -0.59397393f, -0.47543627f, 0.23933540f, -0.00348256f, 0.13745533f, 0.10170121f, 0.28645957f, 
    0.11881129f, -0.48786125f, -0.07835956f, -0.69506419f, -0.47167185f, -0.35373411f, 0.23033577f, -0.17224711f, 
    -0.27240539f, 0.42254642f, -0.38148353f, 0.09599438f, 0.14326413f, -0.30447274f, 0.22639456f, 0.00481629f, 
    0.03344622f, 0.00085096f, 0.02678566f, 0.17825557f, -0.02580516f, 0.10274132f, -0.00758025f, 0.12414607f, 
    0.15060964f, -0.41026443f, 0.16007401f, 0.16552217f, -0.08210719f, -0.22160847f, 0.04626377f, -0.09051393f, 
    0.10560505f, -0.36024880f, -0.12610064f, 0.19380935f, -0.15250286f, -0.57491463f, 0.13842107f, -0.32208404f, 
    -0.04476485f, -0.60619766f, -0.43817818f, 0.26892334f, 0.05588693f, 0.23397234f, -0.17981441f, -0.02136327f, 
    -0.12498355f, -0.04714562f, -0.20441559f, 0.32451117f, 0.25427938f, 0.06831352f, -0.48583657f, -0.32258263f, 
    -0.09061234f, 0.09272763f, -0.09441099f, 0.10785086f, 0.13900283f, 0.13768671f, -0.37181923f, 0.05969246f, 
    -0.13355556f, 0.32835436f, 0.04525295f, 0.22555795f, 0.28658825f, 0.11097170f, -0.20025204f, -0.31700599f, 
    -0.11527968f, -0.02196384f, -0.45175859f, -0.17899095f, -0.10424476f, 0.05812908f, -0.42937836f, 0.10198878f, 
    -0.00476354f, -0.80478072f, -0.59945625f, 0.02435919f, 0.00160379f, 0.21224789f, -0.59069979f, 0.04462088f, 
    0.04187515f, -0.23223078f, -0.11721017f, 0.32602945f, 0.05789173f, 0.15087621f, -0.03752593f, 0.27786797f, 
    0.24506624f, -0.28198463f, 0.01758669f, 0.21263421f, 0.06630502f, 0.18032098f, -0.51885730f, -0.61228985f, 
    0.02387906f, -0.04553600f, 0.46141428f, -0.21022147f, 0.04498858f, 0.06229901f, 0.12044712f, 0.03941761f, 
    -0.12684773f, 0.34757692f, 0.09472959f, 0.27828074f, 0.32574019f, -0.09120433f, -0.20862098f, -0.10855199f, 
    -0.00849386f, -0.34931102f, 0.03569403f, -0.09855128f, 0.09066847f, -0.46622860f, -0.37979090f, -0.28361827f, 
    -0.04372555f, -0.16386265f, -0.13650338f, -0.56192106f, -0.39464983f, -0.32467389f, 0.30186754f, 0.06329415f, 
    0.17005925f, -0.54662508f, -0.11190418f, 0.22738020f, 0.06277600f, -0.38014302f, -0.25107968f, -0.05984544f, 
    0.12238538f, -0.19675580f, -0.06212055f, -0.64949977f, 0.43777436f, 0.08083078f, -0.24652980f, -0.46925214f, 
    -0.03542604f, 0.10665122f, 0.33920118f, -0.47055060f, 0.01588247f, -0.47911867f, 0.07439096f, 0.27700654f, 
    -0.11317411f, 0.31186458f, -0.00313075f, -0.01439531f, -0.31104144f, -0.00772889f, 0.08060848f, -0.05152857f, 
    -0.12906057f, -0.34164786f, -0.45324725f, -0.49810567f, -0.17785078f, 0.35934916f, -0.44748732f, 0.06995194f, 
    -0.05527633f, 0.16578029f, -0.44921216f, -0.02636901f, 0.14609382f, 0.06834849f, -0.35711369f, 0.45215195f, 
    0.16534442f, 0.24501139f, 0.21673593f, -0.19352217f, 0.02332280f, 0.14266597f, 0.09914602f, -0.01182200f, 
    -0.48269963f, -0.55650777f, -0.16462094f, 0.19530663f, 0.02749986f, -0.24428846f, -0.23351996f, -0.08166076f, 
    0.20634903f, -0.43385461f, 0.32353625f, -0.19722486f, -0.00160042f, -0.30964640f, 0.06559742f, 0.01428080f, 
    -0.13447687f, 0.06811170f, -0.12291862f, 0.29219827f, -0.46923479f, -0.52634859f, -0.25659832f, -0.44421682f, 
    -0.16265091f, 0.08031266f, -0.56796825f, 0.01834289f, 0.07692232f, 0.42387125f, 0.01525992f, -0.12013753f, 
    -0.38436380f, -0.00185417f, 0.08776592f, 0.03756652f, -0.20628667f, 0.60916549f, 0.29660958f, 0.21747701f, 
    -0.09927920f, 0.13236003f, -0.24254645f, -0.19462349f, 0.14925794f, -0.31071150f, 0.10592971f, -0.00340078f, 
    -0.07454838f, -0.08357225f, -0.64532882f, -0.14880355f, -0.30510291f, -0.07569653f, -0.28544539f, -0.22415264f, 
    -0.00576004f, -0.12387159f, -0.54670995f, -0.16149463f, 0.10028302f, 0.03277598f, 0.13509716f, 0.34129676f, 
    0.54979116f, 0.06542328f, 0.11609150f, -0.14394949f, -0.70653218f, 0.03630931f, -0.02477296f, -0.10716975f, 
    0.33997798f, -0.23115195f, 0.43459162f, -0.04026674f, -0.14162627f, 0.21253817f, 0.01771162f, 0.09049412f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.02065217f, -0.08517125f, 0.08696596f, 0.16202174f, -0.02309435f, -0.02671431f, -0.19075987f, 0.10243144f, 
    0.20775981f, 0.16485752f, 0.22198263f, -0.00007352f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
