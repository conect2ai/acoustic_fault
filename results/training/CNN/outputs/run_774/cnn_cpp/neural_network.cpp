#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.46325776f, 0.70236331f, 1.01244259f, 1.34697735f, 0.61197847f, 0.94281465f, -0.14303157f, 0.54267269f, 
    0.77040690f, 0.28562966f, -1.05403411f, -0.06886809f, -0.47806758f, -0.10135037f, -0.06442306f, -0.37230876f, 
    0.28560221f, -0.44699568f, 0.00505813f, -0.10487183f, -0.24420990f, -0.29213721f, -0.41082472f, -0.32478553f, 
    -0.09381531f, -1.57185674f, -1.56433856f, -0.24644780f, 1.00106871f, 0.44327968f, 0.09794755f, -0.22913358f, 
    -0.38173681f, 0.04205981f, -0.30659169f, 0.68797940f, 0.24700157f, -0.15305156f, 0.35540563f, 0.01215726f, 
    0.38383874f, 0.60533774f, 0.27955469f, -0.14367113f, -0.17402320f, -0.29227129f, -0.10901567f, 0.32457155f, 
    0.19591096f, -0.04965553f, -0.07461929f, 0.49163830f, -0.81252998f, 0.35550186f, 1.33646953f, 0.79553735f, 
    -0.29688239f, -1.44155967f, 0.42259228f, 0.23280872f, -0.34054762f, -0.51698184f, -0.69763875f, 0.59547764f, 
    -0.45427853f, -0.50218749f, -0.20457567f, 0.17962232f, 0.04868326f, -0.18570635f, 0.37704009f, -0.15175425f, 
    -0.32114428f, -0.11979685f, 0.11270975f, 1.14114928f, 0.40904579f, -0.64061260f, -0.60127157f, -1.01200843f, 
    -0.54398245f, 0.85801411f, 0.08343063f, -0.16721581f, 0.73091900f, 0.46531624f, -0.47350594f, 0.02417594f, 
    -0.56164175f, 0.28810313f, 0.02620542f, 0.14643143f, 0.07637709f, 0.10851365f, 0.27405137f, -0.09022620f, 
    -0.11224577f, -0.07863210f, 0.50931853f, 0.25674924f, -1.14119697f, -0.57114071f, -0.98912722f, -0.50049800f, 
    -0.90903533f, 0.51235110f, 0.58669233f, -1.01840043f, 0.63128936f, 1.12923729f, 0.35658544f, -0.12454150f, 
    -0.03860400f, -0.36481991f, 0.29625651f, -0.03826154f, 0.20206727f, 0.39880943f, 0.53793454f, -0.01515062f, 
    -0.02486179f, 0.27874905f, 0.07320736f, 0.27502957f, -0.00047206f, -0.67227751f, -0.00434038f, 1.55129218f, 
    -0.51519537f, 0.77607805f, 0.79477113f, 0.03502344f, 1.04985809f, -0.31855047f, -1.01696074f, 0.08415673f, 
    0.14527301f, 0.39985549f, 0.08284440f, -0.32042143f, 0.37594667f, 0.45522600f, 0.15355429f, -0.11465704f, 
    0.13060601f, -0.14862597f, 0.13462225f, -0.01399247f, -0.07653105f, 0.04419915f, 0.80599254f, -1.08884966f, 
    0.08523258f, 1.50168860f, -0.28107905f, -1.40529311f, 0.02511209f, 1.04587257f, -0.70515823f, -0.04761741f, 
    0.20782353f, 0.17794381f, 0.02800551f, -0.11525170f, 0.34355986f, -0.01551241f, 0.31948781f, 0.42958993f, 
    0.13185914f, -0.08993187f, 0.16760916f, 0.09179038f, -0.30583981f, 0.08570261f, -0.06436254f, 1.38823116f, 
    -0.35302401f, 0.44732395f, -0.59514791f, -0.06265248f, 0.75652075f, 0.06788012f, 0.67338014f, -0.05255418f, 
    0.60633737f, 0.25387898f, 0.04372557f, -0.02675275f, 0.49589273f, -0.12867299f, 0.30763444f, -0.12375231f, 
    -0.37102872f, 0.10949232f, 0.20324911f, 0.89983386f, 0.33906043f, 0.22418985f, 0.28994876f, 0.27633065f, 
    1.06674135f, 1.35680008f, 0.69993925f, -0.54040718f, -0.78081131f, -0.37616450f, -0.83955657f, -0.05549051f, 
    0.17191638f, 0.29139927f, 0.81859374f, 0.75244391f, -0.41407967f, 0.43356028f, 0.53075451f, 0.60992837f, 
    0.10285309f, 0.14721966f, -0.15764485f, -0.16515125f, 0.27935916f, 0.51947451f, -0.24245021f, -0.09425758f, 
    -0.03299222f, -1.29092205f, -0.27299884f, -1.00169706f, -0.18279409f, 0.44113946f, 0.33702990f, 1.32117558f, 
    1.15097296f, 0.58057141f, 0.56400073f, -0.33098164f, -0.23591323f, -0.10958717f, -0.50168711f, -0.17471164f, 
    -0.24265575f, -0.04291790f, 0.17765902f, 0.04100645f, -0.34556285f, -0.08536098f, -0.14674532f, -0.25063559f, 
    -0.04495296f, -0.25168103f, 1.11773741f, 1.12927842f, 1.19087565f, 1.14279342f, 0.58237791f, -0.61090881f, 
    -0.15345065f, -1.00984573f, -0.93919867f, 0.14551736f, 0.35140622f, 0.20638546f, -0.03807387f, 0.42737922f, 
    -0.09720245f, -0.01316678f, -0.04048657f, 0.18736540f, 0.24152541f, -0.17404392f, 0.11411232f, 0.59256595f, 
    0.06488784f, 0.41617119f, 0.41216695f, 1.23284066f, -0.31279296f, -1.51773906f, 1.27683103f, 0.44649282f, 
    -0.23903994f, 0.52172261f, 0.56661481f, 0.54338127f, -0.15592425f, -0.23669496f, -0.31198180f, 0.11211365f, 
    -0.17692406f, -0.04527313f, -0.06622618f, -0.51203442f, 0.05240045f, -0.24777785f, 0.08675443f, 0.30984485f, 
    0.01446992f, 0.40262786f, 0.03814647f, -0.01875184f, 1.85005319f, 1.11459816f, 0.01736494f, 0.56133926f, 
    0.71737599f, -0.22927651f, -0.03601508f, -0.79838866f, 1.07083666f, 0.29188463f, 0.17761469f, 0.07877973f, 
    0.01917253f, -0.61705732f, -0.33231512f, -0.19161418f, -0.33444932f, -0.39777905f, -0.09531759f, -0.26520067f, 
    -0.02665510f, 0.27326068f, 0.36176372f, -0.19566330f, -0.05147450f, -0.15174952f, -0.76234478f, -0.04328765f, 
    -0.26246545f, -0.46387404f, -1.07224166f, -1.07569277f, -0.71227282f, -0.70967484f, -1.03067434f, -0.49704763f, 
    0.26834849f, 0.53825444f, 0.22953482f, -0.29612952f, -0.49975055f, -0.37871143f, -0.45082125f, 0.02806106f, 
    0.01740146f, 0.21152121f, 0.51263672f, 0.09884574f, 0.07939581f, 0.22156788f, 0.70319837f, -0.93036765f, 
    -1.21528840f, -0.82243317f, -0.18911321f, -0.92361844f, 0.95629632f, -0.05044550f, -0.37747040f, 0.49018967f, 
    -0.13303663f, 0.42978975f, -0.38849050f, -0.33497483f, -0.07494097f, -0.25316983f, 0.18217498f, -0.37339374f, 
    -0.19753760f, -0.13309416f, -0.10031971f, 0.06806495f, 0.56027538f, -0.31838778f, 0.15522382f, -0.74883610f, 
    -1.07765579f, -0.56193578f, 1.09249532f, 0.10907856f, 1.00028586f, 1.52340567f, -0.66874045f, 0.13033076f, 
    -0.13410413f, -0.21171382f, -0.38499832f, -0.16451964f, -0.28216302f, -0.35753098f, -0.55747378f, 0.22769652f, 
    -0.57530838f, -0.24658303f, -0.30756178f, 0.08882298f, -0.18606764f, -0.13987769f, -0.10246234f, -0.21502909f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32947624f, 0.71196097f, 0.23849787f, 0.44644162f, 0.25547007f, 0.37255031f, -0.05836802f, 0.34219199f, 
    0.27081174f, 0.10597457f, 0.02459828f, 0.12656561f, 0.11775986f, 0.15977301f, 0.41821840f, 0.33900353f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18456046f, -0.25520667f, -0.17709233f, 0.41723165f, -0.21518219f, -0.08096085f, 0.08666734f, -0.10283444f, 
    -0.04047049f, 0.07726427f, 0.11787488f, 0.09759454f, -0.70037395f, -0.21967559f, -0.32183397f, 0.29239738f, 
    0.19313610f, -0.08803347f, -0.18211055f, 0.02878984f, 0.25186560f, -0.08522015f, -0.03775354f, -0.03624983f, 
    -0.16181076f, -0.19311294f, 0.64258164f, 0.09132572f, 0.10312033f, 0.06951584f, 0.09349724f, -0.06482748f, 
    -0.13049613f, -0.01510868f, -0.03120234f, -0.05140178f, -0.65264136f, -0.08678284f, 0.14914407f, -0.47779703f, 
    0.08893409f, 0.00987956f, -0.02576385f, -0.02676035f, 0.07788047f, 0.01953918f, 0.02829475f, -0.00732393f, 
    0.95063245f, 0.04979813f, -0.09785260f, -0.39408523f, 0.09181468f, 0.00095516f, 0.11481472f, 0.03414678f, 
    -0.00394473f, -0.01501198f, -0.06586388f, 0.04414795f, -0.93750060f, 0.07016624f, 0.02847037f, -0.29292321f, 
    -0.11639901f, 0.04387943f, 0.21426004f, -0.15041864f, 0.14956762f, 0.02226249f, 0.04125072f, -0.16130650f, 
    0.21832037f, -0.09581180f, -0.20739500f, 0.52204770f, -0.12592717f, 0.13112696f, -0.10205123f, -0.19962607f, 
    0.13093461f, 0.00721876f, 0.07088891f, 0.02640356f, 0.21842220f, -0.45501789f, -0.19004674f, -0.22195560f, 
    0.28095350f, -0.01727050f, 0.15487434f, 0.05794341f, 0.01172619f, 0.24140483f, -0.13895497f, -0.04273782f, 
    -0.34247103f, 0.02108404f, 0.04250095f, -0.21083274f, -0.08744657f, 0.02279133f, -0.00319248f, -0.10072109f, 
    0.01904258f, 0.04182984f, -0.01063693f, 0.17071193f, 0.21303454f, 0.55622834f, 0.16498050f, -0.17122675f, 
    0.12494012f, 0.19768567f, 0.15944305f, -0.04001993f, -0.01769605f, 0.05028516f, -0.10079472f, -0.07778033f, 
    0.38454762f, 0.09511117f, -0.10172093f, 0.13385917f, -0.41568434f, -0.17399968f, -0.02168212f, 0.06668464f, 
    -0.25845560f, 0.08543747f, -0.19855666f, -0.11911649f, -0.18118447f, 0.58997291f, -0.26468042f, 0.56214947f, 
    -0.20722939f, 0.28076285f, -0.12950881f, 0.06746569f, -0.13531850f, 0.09690812f, 0.03157805f, -0.09622908f, 
    0.19226892f, -0.07628045f, -0.08530429f, 0.09116495f, -0.07908963f, -0.11755738f, -0.06683195f, 0.11529642f, 
    -0.11376985f, 0.14177495f, 0.06635942f, -0.13652578f, -0.44148022f, -0.35994253f, 0.21077605f, -0.00412663f, 
    -0.00912590f, 0.06748383f, 0.07131746f, -0.05061893f, 0.00846489f, -0.05037564f, -0.17316355f, -0.15174346f, 
    -0.59483421f, -0.33719185f, 0.29234001f, -0.44976810f, -0.22949883f, -0.11892715f, -0.00029100f, -0.21954779f, 
    -0.18374620f, 0.02979292f, 0.05511954f, -0.10979487f, 0.04518900f, 0.22438918f, 0.10187525f, 0.16691333f, 
    -0.00652849f, -0.00230497f, -0.12461530f, -0.02651393f, -0.25235292f, 0.00251950f, -0.16098359f, -0.02367803f, 
    0.47707251f, 0.13423310f, 0.08798062f, 0.42085341f, -0.09509672f, 0.11233219f, -0.02979278f, 0.12853740f, 
    0.00086680f, -0.08202369f, 0.14948818f, -0.22577974f, 0.21613570f, 0.10285088f, -0.65472782f, 0.10211442f, 
    0.13215126f, -0.02357901f, 0.02530801f, 0.03650580f, -0.16719532f, -0.23371707f, 0.16388288f, 0.31368646f, 
    0.08441993f, -0.20234875f, -0.34712842f, -0.25002322f, 0.11445465f, -0.15891199f, -0.27761781f, 0.11746026f, 
    -0.25915146f, 0.05303470f, -0.15136589f, -0.25416335f, 0.89799052f, -0.16679642f, -0.24182397f, -0.29817685f, 
    -0.12310289f, -0.16930699f, -0.07698233f, 0.06940990f, -0.07971208f, 0.04037081f, 0.05471518f, 0.03822700f, 
    -0.30984473f, -0.21813755f, -0.27631047f, -0.12363480f, 0.02021120f, -0.28387418f, 0.09329955f, 0.06317852f, 
    0.14119242f, -0.02513983f, -0.06937343f, 0.09521239f, -0.08548909f, 0.20028986f, -0.24939518f, -0.15353650f, 
    -0.12619339f, 0.05398415f, -0.04345810f, -0.11507743f, -0.12827827f, 0.02596921f, -0.12121880f, -0.04641706f, 
    -0.53643042f, -0.29963681f, -0.15366466f, 0.45280561f, -0.31680998f, -0.03142201f, -0.11474230f, -0.05567135f, 
    0.10064647f, 0.01948032f, 0.08987967f, 0.15580140f, 0.30899498f, -0.00471179f, 0.13164507f, -0.01216111f, 
    -0.16945972f, -0.02692776f, -0.18336417f, -0.00121622f, -0.02308001f, 0.12866604f, 0.04441722f, 0.13923773f, 
    -0.22444209f, 0.09250981f, -0.13583137f, -0.32367268f, 0.07213879f, -0.12725200f, -0.00788506f, 0.07695946f, 
    -0.07533825f, 0.06326396f, -0.12184259f, 0.17875311f, 0.17632121f, -0.07021645f, -0.09273207f, -0.16439877f, 
    0.09347787f, 0.14010978f, -0.28779233f, 0.13633004f, 0.12396232f, 0.08678439f, -0.03896114f, -0.09323817f, 
    0.28335527f, -0.19219892f, 0.23542367f, 0.33118621f, -0.15267143f, 0.13602093f, 0.08149923f, 0.09204378f, 
    0.13356660f, 0.09769636f, 0.08152220f, -0.05619826f, 0.30845165f, -0.72033674f, 0.27842435f, 0.13270147f, 
    -0.07374667f, 0.10366362f, -0.18716589f, 0.10969679f, 0.04733362f, 0.11545319f, -0.17550622f, 0.06861249f, 
    0.56701410f, -0.11979190f, 0.15762869f, 0.57429487f, 0.01659523f, -0.08672171f, 0.17872192f, 0.07533427f, 
    -0.19087788f, -0.18942818f, -0.28903154f, 0.06449842f, -0.38275120f, -0.44004145f, -0.07494888f, -0.43418038f, 
    0.07534622f, 0.03134461f, 0.01828414f, -0.00254183f, -0.14329492f, 0.13097161f, -0.07340440f, -0.21202216f, 
    0.44322100f, -0.46177429f, 0.03187301f, -0.39403537f, -0.03579223f, -0.09335818f, 0.07773443f, 0.05455737f, 
    -0.14062567f, -0.14955467f, 0.00167076f, -0.12903225f, 0.01126881f, -0.32484749f, -0.46738607f, 0.09007020f, 
    0.20650728f, 0.14882682f, 0.03979808f, 0.01969747f, -0.09709093f, 0.03521645f, 0.15387894f, -0.27024588f, 
    -0.12504828f, -0.12325253f, -0.19517784f, 0.04683245f, 0.09033668f, 0.08934084f, 0.02395288f, -0.15121011f, 
    0.00694356f, 0.08070404f, -0.03198107f, -0.05892099f, 0.47254810f, -0.77190632f, 0.02752174f, 0.03627011f, 
    -0.47613773f, 0.13300259f, -0.49124563f, -0.01369655f, -0.11540544f, 0.04133518f, -0.00762060f, -0.20605890f, 
    -0.01874192f, -0.89415723f, 0.02174603f, -0.02191911f, 0.07285683f, 0.04696877f, 0.09185007f, -0.18673293f, 
    -0.13249886f, 0.16649032f, -0.03433923f, 0.01373371f, -0.03276717f, -0.09266318f, 0.25806335f, 0.05409955f, 
    -0.07859106f, -0.09043265f, 0.00294719f, 0.15750034f, -0.20915630f, 0.05606195f, 0.11491880f, -0.04774154f, 
    0.32701030f, -0.12985957f, 0.41174069f, 0.01804944f, -0.04031805f, -0.26400846f, -0.15727778f, 0.15126838f, 
    -0.14519593f, 0.06137466f, 0.01483622f, -0.07902312f, -0.03677490f, -0.10142285f, -0.13596523f, 0.20000142f, 
    -0.09642223f, -0.14547513f, 0.10993969f, -0.10850960f, -0.08759778f, -0.08775139f, -0.22881295f, -0.20596237f, 
    1.08259547f, -0.07549472f, -0.25047737f, -0.12913516f, 0.04331267f, 0.24552259f, 0.20351230f, 0.08415231f, 
    -0.13397430f, 0.01712191f, 0.13026170f, -0.16342266f, -0.29449701f, 0.22836399f, -0.00455269f, -0.09054291f, 
    -0.00146024f, -0.31684738f, 0.17445993f, -0.16790761f, -0.25118750f, -0.28384665f, 0.00498685f, -0.01011932f, 
    -0.37030184f, -0.21153995f, 0.11731300f, -0.14237557f, -0.03562551f, 0.02074323f, 0.16439176f, -0.02454894f, 
    0.02613391f, -0.06459859f, 0.04200028f, -0.07124068f, 0.56889337f, 0.17903785f, -0.10497165f, 0.39217821f, 
    -0.43177095f, -0.03445433f, -0.01374832f, 0.06398443f, 0.05424070f, -0.08151493f, -0.04243622f, -0.08585730f, 
    -0.00780688f, 0.05950554f, -0.10802063f, 0.09990903f, 0.24491048f, 0.17021753f, -0.02683753f, -0.17012343f, 
    0.06942555f, 0.08570996f, -0.01702936f, 0.05042812f, 0.14972527f, -0.21656793f, -0.25238922f, 0.11889405f, 
    -0.03038676f, -0.00180261f, 0.02863703f, 0.12174495f, 0.09009760f, -0.01787886f, 0.01693819f, -0.08463401f, 
    0.36087647f, 0.08127819f, -0.03704681f, -0.35657534f, 0.27421698f, -0.09759984f, 0.11083311f, -0.03837334f, 
    -0.03618124f, 0.06576249f, 0.03849931f, -0.08656394f, -0.39582649f, -0.05863545f, -0.55591673f, -0.71924341f, 
    -0.06058150f, 0.11049667f, -0.10479839f, -0.07432083f, 0.13161843f, 0.15780653f, -0.19306062f, 0.06276371f, 
    0.27901655f, -0.18181860f, -0.06620526f, -0.05958236f, -0.18564966f, -0.03497428f, -0.00596177f, -0.16292408f, 
    -0.30579734f, -0.04061566f, 0.05760584f, 0.01841917f, 0.26058275f, -0.58878613f, 0.24011199f, -0.11937912f, 
    0.02280001f, -0.04122441f, -0.11802845f, 0.04749847f, 0.04699757f, 0.19515157f, 0.02023289f, 0.17194423f, 
    -0.87405515f, -0.69589597f, -0.77954304f, 0.27582514f, 0.01031637f, -0.25092837f, 0.21580151f, -0.12839302f, 
    0.12561795f, 0.10405267f, -0.00034574f, 0.08277363f, -0.15577763f, 0.19714677f, 0.05137094f, 0.02554999f, 
    -0.29444036f, -0.11481068f, -0.00019524f, 0.13233939f, -0.05206414f, 0.03591879f, 0.00656296f, -0.17501341f, 
    0.98165172f, 0.22979642f, -0.06766304f, 0.18411598f, 0.01165189f, 0.08832240f, -0.00958464f, -0.16628943f, 
    -0.03871224f, -0.12333117f, 0.21103318f, 0.03681727f, -0.18311775f, -0.38485906f, -0.21236865f, 0.14668541f, 
    -0.16515295f, 0.20571156f, -0.30072460f, 0.14121997f, 0.08240465f, -0.03965399f, -0.01573355f, 0.14796601f, 
    -0.08488934f, 0.16505799f, -0.06234580f, -0.44204280f, -0.33923852f, -0.05219711f, -0.09275404f, 0.10484523f, 
    0.10055732f, -0.38240421f, 0.00501890f, 0.08460700f, -0.12702595f, -0.66012156f, 0.25852177f, 0.08405566f, 
    0.13404316f, -0.16718094f, -0.02285572f, 0.07183276f, 0.13331598f, -0.00053017f, 0.02504511f, -0.07533497f, 
    -0.05833149f, -0.01115162f, 0.45181832f, -0.03960612f, 0.11895144f, 0.14066142f, 0.22945841f, 0.14439157f, 
    -0.13809076f, -0.09285954f, -0.09386568f, -0.03224851f, -0.17292969f, -0.18747097f, -0.18527485f, -0.08679788f, 
    0.03897583f, 0.18659270f, 0.13235629f, -0.00484903f, -0.25426430f, 0.12611826f, 0.13380626f, -0.19177893f, 
    -0.29270110f, -0.43891627f, -0.12894960f, 0.07956997f, -0.23447910f, -0.12673514f, -0.07034870f, -0.04080481f, 
    -0.01513333f, 0.02297634f, -0.07741687f, -0.20435701f, -0.37733650f, 0.37402955f, -0.12610449f, -0.26749119f, 
    -0.32801846f, -0.21542491f, 0.01554803f, -0.16602552f, -0.21576634f, -0.18205559f, -0.04635665f, -0.05762668f, 
    -0.70966578f, -0.69256246f, -0.13223711f, 0.49928865f, 0.06687967f, 0.11196315f, 0.02667889f, 0.01279925f, 
    -0.04222169f, -0.15985923f, 0.11920848f, -0.14462574f, 0.40408203f, -0.13772663f, -0.15812327f, -0.17945856f, 
    -0.05560758f, 0.06888092f, -0.03817804f, -0.08138201f, -0.05068720f, -0.11175404f, -0.04203157f, 0.01890955f, 
    0.31580499f, -0.54301625f, -0.27471381f, -0.27004403f, 0.11426391f, 0.16050060f, 0.05292154f, -0.02947732f, 
    0.08721817f, -0.02224108f, 0.09820160f, -0.10450155f, 0.47832149f, 0.40718466f, 0.37028164f, 0.33919170f, 
    -0.20662197f, 0.00274531f, 0.07762996f, 0.03001400f, 0.32551026f, -0.00318191f, -0.00465729f, 0.14028230f, 
    0.14519526f, 0.06161820f, 0.12350476f, 0.26728493f, -0.14591633f, -0.00938202f, -0.04075055f, -0.00081940f, 
    -0.09891215f, 0.14967622f, 0.00910910f, 0.05973998f, 0.11250928f, 0.08886664f, -0.23364557f, 0.09095143f, 
    -0.06751913f, 0.07065748f, 0.16592246f, 0.16615810f, 0.15749690f, 0.00014815f, 0.22158976f, 0.01624161f, 
    0.02243970f, 0.15739115f, -0.14109325f, -0.09613266f, 0.07941262f, 0.06641346f, 0.23593190f, 0.26264840f, 
    0.07293522f, -0.06032247f, 0.10247273f, 0.09899577f, -0.37804294f, 0.07553517f, 0.19954470f, -0.20754285f, 
    0.17916679f, -0.02433022f, -0.12613392f, 0.00540845f, 0.24262713f, -0.11132031f, -0.07131065f, -0.12023052f, 
    0.19889401f, 0.18833065f, -0.31995884f, 0.08820489f, -0.08881194f, -0.00216874f, -0.00134137f, -0.02302563f, 
    -0.04535496f, -0.07271559f, 0.03859226f, 0.13973334f, -0.30576307f, -0.50234526f, 0.12263694f, -0.00645178f, 
    -0.07508305f, 0.06594321f, 0.00705946f, -0.08869232f, 0.11932135f, -0.08177978f, -0.01133556f, 0.01877974f, 
    -0.09734628f, -0.04726643f, 0.10232402f, 0.27384856f, 0.12159817f, 0.13837264f, -0.11044510f, 0.23227984f, 
    -0.20493339f, 0.05940964f, 0.07111244f, 0.06796546f, 0.57550126f, 0.36885568f, -0.42203563f, -0.42709163f, 
    0.09046393f, -0.18791205f, 0.05900487f, 0.12050686f, -0.15601957f, 0.04617795f, 0.11021160f, 0.09890334f, 
    -0.75582516f, 0.00449337f, -0.14061800f, -0.10763523f, 0.04216306f, 0.02374704f, -0.05533242f, -0.06075022f, 
    0.10026363f, 0.02395663f, -0.31877920f, -0.13555551f, -0.58605546f, 0.00680680f, 0.08395550f, -0.27246520f, 
    0.06393003f, -0.02772352f, -0.34651950f, -0.17366873f, 0.02887671f, -0.02945787f, -0.01480201f, -0.12735161f, 
    0.09696413f, -0.73543805f, 0.07172132f, -0.03706145f, -0.40068391f, -0.10512827f, 0.27521801f, -0.13981237f, 
    -0.03048217f, -0.02360061f, 0.03256820f, -0.06389803f, -0.35220119f, -0.14038776f, -0.05008043f, 0.24340948f, 
    0.12667520f, 0.00901711f, 0.30658758f, -0.24927612f, -0.00566401f, 0.03480650f, 0.01949569f, 0.16566630f, 
    -0.61916155f, -0.01122518f, 0.37785584f, 0.09675862f, -0.04713437f, -0.16095676f, -0.08605272f, 0.13049309f, 
    0.34785819f, -0.08870088f, -0.06409659f, -0.10085978f, 0.75492251f, 0.21729699f, -0.24431343f, -0.01985172f, 
    0.12018722f, 0.03898245f, -0.03483316f, -0.15655208f, 0.02417894f, -0.16948418f, 0.03751550f, -0.09586177f, 
    -0.08356962f, -0.09241920f, 0.23850282f, 0.23476735f, -0.43305141f, -0.04860371f, 0.06095295f, 0.16249612f, 
    0.08322369f, 0.02117260f, -0.00145767f, 0.11141431f, -0.14726350f, -0.37261692f, 0.26761469f, 0.19475712f, 
    -0.05587797f, 0.00493965f, -0.08791048f, 0.04171360f, -0.12705337f, -0.03768914f, 0.09900416f, 0.24366128f, 
    -0.61646557f, 0.33042204f, 0.20596346f, 0.12551595f, 0.06410147f, 0.08887428f, 0.17820570f, 0.12614816f, 
    0.00360582f, 0.09598943f, 0.04133460f, -0.02254430f, -0.78219342f, 0.33138922f, -0.11275136f, -0.19046459f, 
    0.00248598f, -0.03103995f, -0.07570983f, 0.07451422f, -0.06990189f, -0.13944359f, 0.03234530f, 0.17645633f, 
    0.04289049f, 0.05410725f, 0.53252476f, 0.00356045f, 0.17648800f, -0.15198945f, -0.09783385f, -0.09850355f, 
    -0.24747369f, 0.03708820f, -0.15722261f, -0.19033462f, -0.28817686f, -0.11607835f, 0.08772587f, -0.25577623f, 
    0.12918997f, 0.13902563f, 0.16744402f, -0.19846636f, 0.15314347f, 0.21653619f, 0.06336470f, 0.20562051f, 
    0.00369211f, -0.25478792f, -0.08785291f, -0.20098791f, -0.24948375f, 0.14856976f, 0.01187031f, 0.25060606f, 
    0.16857538f, 0.02304188f, 0.08938821f, -0.08352420f, -0.07085160f, 0.12453555f, -0.07576092f, -0.02859342f, 
    -0.08343201f, 0.14108394f, 0.14786331f, -0.07619135f, -0.20175381f, -0.05928156f, -0.03586930f, 0.00022702f, 
    -0.75143850f, -0.27432594f, -0.33391166f, 0.23898904f, 0.15445220f, 0.03932852f, 0.03711452f, -0.01501170f, 
    0.15592898f, -0.22058000f, 0.11493862f, -0.13470463f, -0.34984803f, -0.27253002f, 0.56596810f, 0.36651811f, 
    0.34875709f, 0.05225235f, 0.14363325f, -0.06280267f, 0.14911456f, -0.14291759f, 0.02327244f, 0.22076306f, 
    -0.07196298f, 0.05852458f, -0.14721355f, -0.10877650f, -0.05886897f, -0.02266992f, -0.36014375f, 0.25898963f, 
    -0.11468020f, -0.09764597f, 0.19511142f, -0.01553774f, -0.00658209f, 0.15472613f, -0.00239231f, 0.05593460f, 
    -0.09033478f, -0.01317965f, 0.06979712f, 0.31937563f, 0.35389954f, 0.07788466f, -0.21083453f, 0.11900935f, 
    0.15979496f, 0.32260305f, -0.03252272f, 0.03429791f, -0.02382398f, 0.04493679f, -0.05626937f, 0.23283410f, 
    -0.13345516f, 0.03743953f, 0.11336522f, 0.13600855f, -0.24180824f, 0.30578354f, -0.10541158f, -0.42733958f, 
    0.08245274f, 0.12196052f, -0.06090367f, -0.41792405f, 0.10585269f, -0.21145250f, -0.04056600f, -0.14070089f, 
    0.16414763f, 0.08721810f, 0.21057461f, 0.11769320f, -0.16375333f, -0.00703073f, 0.01641865f, -0.07827522f, 
    -0.17881307f, -0.03854635f, 0.08748597f, 0.23448510f, -0.05170135f, 0.29047161f, 0.04618727f, -0.51864368f, 
    0.00423600f, -0.21607558f, -0.25255999f, -0.12329323f, 0.12711978f, -0.13501069f, -0.17021793f, -0.15445250f, 
    -0.03446167f, -0.22080398f, -0.07196430f, -0.18267800f, 0.07865232f, -0.18919340f, -0.04137991f, -0.04765297f, 
    0.17018373f, -0.13962333f, -0.03313609f, -0.09284471f, 0.07561906f, 0.03646620f, -0.06884857f, 0.53465742f, 
    -0.00124058f, 0.02589454f, -0.01723330f, 0.27764508f, -0.08921544f, 0.03707900f, 0.23719297f, -0.04562010f, 
    -0.30293420f, -0.67732936f, -0.34412667f, -0.03334073f, 0.03277620f, -0.06200250f, -0.18157513f, 0.04145696f, 
    0.28896928f, -0.16864222f, -0.25397697f, -0.03226173f, -0.37323603f, 0.42876065f, 0.18785702f, -0.35849747f, 
    -0.01986860f, 0.10794705f, 0.11613794f, 0.03602380f, -0.13379890f, -0.07260375f, -0.02101289f, -0.35212421f, 
    -0.06162062f, 0.37792772f, 0.17003059f, -0.47261661f, -0.42709714f, 0.00624874f, 0.15021016f, 0.06198235f, 
    0.01043990f, 0.03477952f, -0.00471193f, 0.03891372f, 0.09539188f, -0.03505159f, -0.18153125f, -0.45969066f, 
    0.09055837f, -0.09878772f, 0.09837139f, 0.16520688f, -0.11330013f, 0.08556299f, -0.17214869f, -0.46854529f, 
    -0.34588310f, 0.02195070f, 0.27749440f, 0.04345132f, 0.27201122f, -0.02419745f, 0.01748393f, -0.00492201f, 
    0.14707780f, 0.01306928f, -0.08568159f, 0.03444147f, -0.28522128f, 0.04092678f, -0.12428562f, 0.16599111f, 
    0.23414344f, 0.02218694f, -0.10206221f, 0.16495287f, 0.03581458f, 0.00060877f, -0.01655510f, -0.31978279f, 
    -0.16655236f, -0.01336643f, -0.29067323f, -0.24480882f, -0.19856182f, 0.16230191f, -0.01345059f, -0.28903261f, 
    -0.15456647f, 0.38486451f, -0.03996669f, -0.03859219f, 0.02474645f, -0.28682303f, 0.02696844f, 0.45100307f, 
    -0.30127496f, 0.17469759f, -0.13180828f, 0.04999407f, 0.08653230f, -0.02130874f, -0.18800724f, -0.08936095f, 
    0.62366039f, -0.07945351f, 0.41836864f, -0.22631955f, 0.09165436f, 0.01638033f, 0.08420081f, 0.02728859f, 
    -0.08093345f, 0.16012047f, -0.19631414f, -0.02490348f, -0.08710529f, 0.27274358f, 0.16959809f, 0.33677197f, 
    -0.06345022f, 0.07463326f, -0.04236703f, -0.17381285f, -0.08780414f, -0.20888686f, 0.13019863f, -0.32265872f, 
    -0.36214504f, 0.31903154f, -0.37861541f, 0.62266093f, -0.04718774f, -0.06914029f, -0.03015460f, -0.09009933f, 
    0.05303280f, 0.02804969f, -0.00798287f, -0.39484835f, -0.41042957f, -0.86066866f, -0.07253640f, -0.18149357f, 
    0.01330557f, -0.05655736f, -0.14860269f, 0.33038926f, -0.09598738f, 0.02494987f, 0.01554132f, 0.33373886f, 
    0.16006753f, 0.54131013f, 0.04594354f, -0.46806455f, 0.04880101f, -0.10007385f, 0.03451438f, 0.13269562f, 
    0.00535216f, -0.05920873f, -0.09459937f, -0.15663080f, -0.16751975f, -0.09491352f, 0.23160362f, -0.14803483f, 
    0.04229014f, -0.13460621f, 0.30415714f, -0.00202200f, -0.16184603f, -0.06652687f, 0.08547034f, 0.08903461f, 
    -0.88640577f, 0.50426787f, 0.03166066f, -0.09477075f, 0.07021551f, 0.37477845f, 0.00375735f, -0.04062337f, 
    -0.16453256f, 0.02690426f, 0.10924978f, 0.10338467f, -0.17971027f, -0.13138121f, -0.39093509f, -0.25230339f, 
    0.09447368f, -0.12499002f, 0.06341836f, -0.08130646f, -0.09344725f, -0.34104308f, -0.03174498f, -0.05361681f, 
    0.14961597f, -0.03351523f, -0.09014551f, -0.11524767f, 0.15478492f, -0.02370506f, -0.10049379f, -0.01149035f, 
    0.05459859f, -0.09625129f, -0.00844107f, 0.20056725f, 0.72037154f, -0.71669072f, 0.09033950f, 0.11621987f, 
    -0.01999381f, 0.07744061f, -0.13529988f, -0.12673604f, 0.20278607f, 0.04984179f, 0.15088068f, 0.31781259f, 
    0.32161143f, -0.00164359f, -0.12265957f, -0.42941055f, -0.15046996f, 0.06138363f, 0.01659487f, -0.13706188f, 
    0.04843868f, 0.00726926f, -0.14841761f, -0.02855277f, 0.01478285f, -0.08273473f, 0.40456361f, -0.10918228f, 
    0.18988755f, 0.09525067f, -0.06640730f, -0.34896785f, -0.12551685f, 0.04719278f, -0.02949592f, -0.33613336f, 
    -0.51718819f, 0.40491360f, -0.12155832f, -0.07950713f, -0.08713768f, -0.00255518f, 0.02339503f, -0.11435854f, 
    -0.04145100f, 0.06025015f, -0.00619184f, 0.04429840f, -0.17219582f, 0.25700992f, 0.00878747f, -0.05828277f, 
    -0.02250885f, -0.03377339f, 0.00874131f, -0.07615152f, -0.08525692f, -0.03046895f, -0.12359753f, -0.08601539f, 
    0.00428261f, 0.60949606f, 0.24662556f, 0.32674327f, 0.40906593f, 0.12412465f, 0.02446824f, -0.03598940f, 
    -0.05637027f, -0.03927264f, 0.13235393f, -0.14185658f, -0.14683320f, -0.17912342f, 0.00734223f, -0.12051815f, 
    -0.09952416f, -0.11527929f, -0.02530322f, -0.02637981f, 0.14716870f, -0.11264807f, -0.06770781f, -0.24742755f, 
    0.76188725f, 0.37015843f, 0.14387353f, -0.32967469f, -0.23838073f, 0.07003017f, 0.09636690f, -0.05475196f, 
    0.05577032f, 0.05753594f, -0.02594746f, -0.14509697f, -0.53232610f, -0.25866315f, -0.02525267f, -0.14809632f, 
    -0.07151771f, 0.00785171f, 0.05223990f, -0.07519463f, 0.15200436f, -0.12677309f, -0.01953651f, -0.00972663f, 
    -0.69027996f, -0.03461521f, -0.36520350f, 0.12628900f, 0.16537979f, 0.04232425f, -0.00425565f, 0.01755101f, 
    -0.10678997f, -0.06099613f, 0.08863327f, -0.11115230f, -0.15680991f, 0.10485894f, 0.12897617f, 0.00281362f, 
    0.02340911f, 0.02900935f, 0.06089753f, -0.00502088f, -0.07424912f, -0.04327938f, 0.07296577f, 0.08230016f, 
    -0.18653733f, -0.38799077f, -0.61613649f, -0.20649111f, -0.13317069f, -0.17115048f, -0.04459917f, -0.02389974f, 
    -0.17956917f, -0.00379733f, -0.11468695f, 0.03630143f, 0.07267516f, 0.13896947f, 0.01400274f, -0.19134516f, 
    -0.00016710f, 0.05577120f, -0.12270094f, -0.05434944f, -0.06977917f, 0.00219157f, -0.13852964f, -0.30927515f, 
    -0.84393573f, 0.32069200f, -0.25476092f, -0.05238484f, -0.03869152f, 0.16251026f, -0.26719329f, -0.13159716f, 
    -0.03384596f, -0.13973196f, 0.03225835f, -0.06960494f, 0.40987039f, -0.05973656f, 0.02415745f, 0.49868792f, 
    -0.14230901f, -0.15842590f, -0.04458828f, -0.11348797f, -0.08455692f, -0.02751057f, -0.04664421f, 0.04577180f, 
    0.41177744f, 0.22737762f, 0.30481029f, 0.28099093f, -0.05506777f, 0.03935035f, -0.13656475f, 0.04457916f, 
    -0.10145687f, -0.03519747f, -0.19286387f, -0.17026335f, -0.30722183f, 0.24878207f, 0.40627965f, -0.14768481f, 
    -0.03454252f, -0.06607945f, -0.02861610f, 0.02691111f, -0.15615404f, 0.02020710f, -0.09027281f, -0.02125788f, 
    0.33197850f, -0.03131260f, 0.15684257f, 0.21072395f, 0.16588286f, -0.22360487f, -0.22357573f, -0.03822478f, 
    -0.08797054f, 0.00477141f, 0.04484387f, -0.08151763f, -0.68954515f, -0.35474938f, 0.26878443f, -0.13453571f, 
    -0.29151261f, 0.16003734f, 0.08514029f, -0.47984037f, -0.01847877f, 0.16458955f, -0.12526168f, 0.30349150f, 
    -0.11007459f, -0.12688032f, -0.21757391f, 0.23205279f, -0.03024472f, -0.11421251f, -0.37958732f, 0.06647328f, 
    0.12480339f, -0.10446039f, 0.32345846f, -0.07245286f, 0.02583952f, 0.34720427f, -0.72988921f, 0.03087486f, 
    0.02692081f, 0.16759092f, -0.01626612f, -0.14446197f, 0.05460528f, -0.01744837f, 0.05213345f, 0.07047488f, 
    -0.00868618f, 0.05503894f, 0.23690885f, 0.13801429f, -0.10098697f, -0.03133365f, 0.09117902f, -0.05597482f, 
    0.17898576f, 0.00929921f, -0.08371403f, -0.09912698f, 0.27401760f, 0.33564511f, 0.04734712f, 0.00668393f, 
    0.01049567f, -0.31619012f, -0.26891676f, -0.15880316f, -0.03009262f, -0.01409642f, 0.05428133f, 0.08961802f, 
    0.04835713f, -0.29763433f, -0.03341234f, -0.41363713f, 0.15531731f, -0.29316422f, -0.02283789f, 0.04797181f, 
    0.06091749f, 0.00242716f, -0.03673732f, 0.07914668f, 0.22811632f, 0.16908138f, -0.14448053f, 0.23021486f, 
    -0.12051844f, 0.00777513f, 0.16769281f, -0.00283835f, 0.10358635f, -0.12933022f, 0.03523794f, -0.01828480f, 
    0.30042386f, 0.46944025f, -0.41710478f, -0.25582415f, 0.01044796f, -0.03749274f, -0.00856817f, 0.12719811f, 
    0.17404687f, -0.00240644f, 0.03501590f, 0.25275478f, 0.02294351f, -0.04796053f, 0.25788483f, 0.24873422f, 
    -0.30059388f, -0.03858091f, -0.26560092f, -0.34804815f, 0.01773714f, -0.10444874f, -0.16643491f, -0.43070018f, 
    -0.29375988f, -0.25687197f, -0.54580265f, 0.37975895f, 0.26057631f, 0.12565094f, 0.06769465f, -0.04197286f, 
    0.20666711f, 0.05295741f, 0.34459779f, 0.20189962f, -0.07043665f, -0.03009200f, -0.05890249f, 0.01584844f, 
    -0.22442074f, -0.12628654f, 0.16893834f, 0.07092965f, 0.11174974f, -0.13534391f, -0.09579423f, -0.12340353f, 
    -0.14488557f, -0.33938658f, 0.03663639f, 0.18080571f, 0.28944501f, -0.16945116f, -0.06995330f, -0.03344743f, 
    -0.19791104f, 0.08020201f, 0.00751040f, -0.18788534f, -0.22883236f, -0.17779289f, -0.17405999f, -0.57359314f, 
    -0.07840664f, -0.12149248f, 0.06490134f, 0.02380469f, 0.20640303f, -0.05111328f, 0.15556012f, -0.19233550f, 
    -0.28582078f, 0.50803423f, -0.43164265f, -0.41649458f, -0.09585877f, 0.00463536f, 0.05359171f, 0.00237148f, 
    0.14469033f, 0.13973688f, -0.05361671f, 0.23168153f, 0.34853992f, -0.36001074f, 0.13367271f, -0.14949410f, 
    -0.20688003f, -0.11028637f, 0.02932691f, -0.13648142f, 0.13644627f, -0.35210997f, -0.41174850f, -0.19375652f, 
    -0.26162282f, 0.19350900f, -0.06452717f, -0.18404464f, -0.01759734f, 0.05134581f, -0.08161451f, -0.21673317f, 
    0.13964643f, 0.07866912f, 0.08383163f, 0.16131133f, 0.48190591f, 0.16680931f, -0.33119616f, 0.58338612f, 
    -0.07700928f, 0.06464883f, -0.19306120f, 0.00389395f, 0.14389314f, 0.10415274f, -0.01263766f, -0.18496048f, 
    -0.86128449f, 0.73331016f, -0.00002352f, -0.21743734f, -0.03793964f, -0.11299133f, -0.10593207f, -0.07222079f, 
    -0.15357892f, -0.13649146f, -0.02858556f, 0.12542422f, -0.03885220f, 0.32195503f, 0.18949589f, 0.11735945f, 
    -0.09669428f, -0.42627364f, -0.15050782f, 0.09461460f, 0.09851795f, 0.03772340f, -0.07363916f, 0.22182056f, 
    -0.62892300f, -0.76559538f, 0.03428997f, -0.27796689f, 0.12331687f, 0.16557011f, -0.11575755f, -0.01130167f, 
    -0.06124362f, -0.01400298f, 0.01208541f, 0.11286029f, 0.57642794f, 0.03963267f, -0.59528726f, -0.41399801f, 
    -0.06066520f, -0.06467913f, 0.01049333f, 0.11384008f, -0.15546270f, 0.09327337f, 0.08279142f, 0.02377436f, 
    -0.28774390f, 0.12913312f, -0.15425904f, -0.13206124f, 0.22464155f, -0.30009699f, 0.11955336f, 0.10039105f, 
    -0.06239841f, -0.06776313f, 0.12279051f, 0.00381425f, 0.66075331f, 0.37834138f, -0.09903006f, 0.29168883f, 
    -0.07302246f, 0.16119304f, 0.26021174f, -0.33779168f, -0.37734058f, -0.10094922f, 0.07884029f, -0.05072682f, 
    0.62975597f, -0.15524885f, 0.60975999f, -0.15640794f, -0.00387961f, 0.12800498f, 0.01305389f, -0.05880247f, 
    -0.20528820f, -0.04260924f, -0.11632220f, -0.29651541f, 0.66546607f, -0.36731729f, -0.07454778f, 0.21839052f, 
    0.14564352f, 0.23607072f, -0.04663244f, 0.40224510f, -0.16440943f, 0.00556795f, 0.12547216f, 0.08517168f, 
    -0.56231540f, 0.12406071f, -0.08735500f, -0.59545255f, 0.06294335f, 0.02965346f, -0.26259911f, -0.09112974f, 
    -0.20789684f, -0.05592103f, -0.14205313f, -0.17093298f, -0.91121149f, 0.24832691f, 0.08984581f, -0.14331825f, 
    0.10322046f, -0.07064856f, -0.04373748f, -0.07666034f, -0.17815331f, -0.02070522f, 0.22779249f, 0.08802445f, 
    -0.40785733f, 0.36117798f, 0.21572779f, -0.43841800f, -0.29352784f, 0.04039099f, -0.02746298f, -0.16463983f, 
    -0.00466336f, -0.10570700f, -0.09429691f, -0.11135752f, -0.05200961f, -0.00779058f, -0.36612070f, 0.11005888f, 
    -0.01274868f, 0.12837228f, -0.02085015f, -0.00764588f, -0.09257811f, 0.03958348f, -0.21510951f, 0.28985038f, 
    -0.38222998f, -0.11631496f, -0.34184930f, 0.49877045f, 0.01393020f, 0.09951311f, -0.22119007f, 0.07327132f, 
    -0.07973621f, 0.12042736f, 0.15669583f, -0.03435820f, -0.25110686f, -0.01492838f, -0.18522070f, 0.29642886f, 
    0.19515988f, 0.09729233f, -0.13691850f, 0.03803003f, 0.10546394f, 0.23061445f, -0.01306660f, 0.07694948f, 
    -0.69049871f, -0.41233581f, -0.22559361f, -0.56731141f, 0.24603793f, -0.09752641f, -0.37282091f, -0.09195149f, 
    -0.03582199f, -0.24201721f, -0.04583410f, -0.21947677f, 0.33393753f, 0.16509928f, -0.09839633f, 0.12103469f, 
    -0.07205245f, -0.11387762f, 0.08280154f, 0.08564679f, -0.17754421f, -0.14983371f, 0.05720998f, 0.29239246f, 
    -0.14636064f, -0.07339728f, -0.03413312f, 0.01744247f, 0.02216374f, -0.15801097f, 0.06059329f, 0.35023525f, 
    0.13646957f, -0.06386670f, 0.03996508f, -0.01901561f, -0.45630363f, -0.24806915f, 0.15122104f, 0.04829166f, 
    0.08635133f, 0.22718303f, 0.18719368f, -0.09299619f, 0.27389541f, -0.04484963f, -0.00504231f, 0.07132972f, 
    0.21768843f, 0.27773896f, -0.18253607f, 0.11186082f, 0.03423667f, -0.31535926f, 0.23162584f, -0.11425444f, 
    0.12679170f, 0.26391399f, -0.04901085f, 0.02193270f, -0.30365568f, 0.16735148f, -0.21875873f, -0.50710410f, 
    0.01804262f, 0.16960780f, -0.12610440f, 0.09293735f, -0.05972221f, -0.08378908f, 0.12416926f, 0.15723425f, 
    -0.67872971f, -0.10978092f, 0.12877272f, -0.07123398f, 0.20252508f, 0.09724120f, -0.17660345f, -0.08725736f, 
    -0.19199008f, 0.15224941f, 0.00377894f, 0.22291720f, -0.49751168f, -0.45374119f, 0.05769400f, 0.37144762f, 
    0.00828995f, -0.14886087f, 0.04504450f, 0.01857224f, 0.23676473f, 0.17494701f, 0.12949637f, 0.25463870f, 
    -0.30688497f, 0.10051415f, 0.09122498f, 0.24300706f, 0.25134280f, -0.11316022f, -0.01954756f, 0.01513086f, 
    -0.01326049f, 0.12253430f, -0.02538455f, 0.31244439f, 0.35194159f, -0.02812456f, -0.16205882f, -0.02233332f, 
    -0.04139437f, -0.08872889f, -0.09675644f, -0.04757720f, 0.10380010f, -0.09768898f, -0.19480483f, -0.17004685f, 
    -0.63683033f, -0.01493259f, -0.00064220f, -0.55507028f, 0.06294892f, 0.11845738f, 0.00203279f, -0.06650075f, 
    0.09975126f, 0.20680580f, -0.00466215f, 0.11954424f, -0.43249080f, -0.87828386f, -0.33127713f, 0.02155560f, 
    -0.08156566f, -0.01127325f, 0.27827916f, 0.15795472f, 0.16628721f, 0.03216357f, -0.15116952f, 0.07082897f, 
    -1.00937903f, -0.85679626f, 0.00345826f, 0.07335565f, 0.08631102f, -0.05502712f, -0.08385910f, 0.00668549f, 
    0.03764361f, 0.02782830f, -0.02558833f, 0.08063763f, 0.55559689f, 0.29040718f, 0.13075934f, -0.16824812f, 
    0.30895445f, 0.17736073f, 0.11266530f, -0.06971048f, 0.01596005f, 0.13922457f, 0.01648437f, -0.18113074f, 
    0.12307767f, -0.15697362f, -0.10764179f, -0.17510305f, -0.03433397f, 0.13345605f, 0.23822974f, -0.00844234f, 
    0.17457700f, 0.03396747f, -0.02102913f, -0.30617073f, 0.72808498f, 0.21615779f, -0.08428874f, 0.31444409f, 
    -0.14818580f, -0.44168824f, 0.00481537f, -0.00825660f, 0.08769117f, -0.23659350f, -0.18637763f, -0.41552353f, 
    -0.38791847f, -0.48194590f, -0.12134269f, -0.88870496f, -0.10560685f, 0.06326148f, 0.00808793f, 0.20816551f, 
    0.03981154f, -0.13705464f, -0.09988175f, -0.09344620f, 0.05032026f, 0.37038827f, 0.09488254f, -0.15677910f, 
    -0.18431363f, -0.13786393f, 0.07999267f, 0.01481081f, -0.18107297f, 0.00964389f, -0.12483449f, -0.05574862f, 
    0.34459579f, -0.19986567f, -0.16598997f, 0.22865446f, 0.07790524f, -0.02344500f, 0.37668326f, -0.13781998f, 
    0.08342493f, 0.05929482f, -0.06340917f, 0.18898869f, 0.05699887f, 0.18746157f, 0.27104723f, 0.21592273f, 
    0.21647598f, -0.09412895f, -0.01552587f, -0.11542101f, 0.08237292f, 0.08266982f, -0.18537161f, 0.15960297f, 
    0.38655081f, -0.11340868f, 0.22588280f, 0.08698799f, -0.21383017f, -0.08784883f, -0.22783054f, 0.08667458f, 
    -0.14620487f, -0.05212755f, -0.12017911f, -0.19139338f, -0.44071549f, -0.14061080f, 0.19160761f, 0.20906061f, 
    -0.06444730f, 0.08473213f, -0.16329007f, 0.17653804f, -0.04549008f, 0.02458915f, 0.17392541f, -0.15614557f, 
    -0.88177007f, 0.24376158f, -0.00019953f, -0.10975970f, 0.10937841f, -0.21333669f, 0.12237350f, -0.26430294f, 
    0.05326860f, -0.18860663f, -0.27599457f, 0.04180233f, -0.17326082f, -0.28021988f, -0.11158925f, -0.07595131f, 
    0.19909956f, -0.18376023f, -0.02839258f, 0.10262683f, -0.17178151f, -0.04310529f, -0.06950422f, -0.31918654f, 
    0.67285627f, -0.08720770f, 0.07528098f, 0.00442531f, -0.04827577f, 0.14159390f, -0.09701660f, 0.03642171f, 
    0.14205672f, -0.02424836f, -0.11131555f, -0.02994587f, -0.46847397f, -0.30845153f, 0.22055016f, 0.01115265f, 
    0.08590265f, -0.27112353f, 0.12354427f, 0.16130669f, 0.00735199f, 0.17229681f, 0.08072289f, -0.11717860f, 
    0.76312399f, -0.05830248f, -0.59631252f, -0.06882042f, -0.07627261f, -0.23856518f, 0.19447346f, -0.04417462f, 
    -0.08519445f, 0.09615904f, -0.04403321f, -0.02431362f, -0.81368279f, -0.15587460f, 0.17961167f, 0.09019671f, 
    0.16489850f, -0.10540779f, 0.02557984f, 0.04621423f, 0.22031732f, 0.09149653f, 0.20687363f, 0.04753828f, 
    0.40584517f, 0.27007130f, -0.12775186f, -0.14049572f, -0.06616645f, 0.28587660f, -0.12412637f, -0.07334431f, 
    0.01679456f, 0.09205471f, 0.18375327f, 0.02192354f, -0.34836221f, 0.13688144f, -0.11989248f, -0.13466747f, 
    0.15650056f, -0.01496351f, 0.00585729f, -0.08383831f, 0.33529469f, -0.05791431f, -0.13323236f, -0.17081724f, 
    0.01444470f, 0.34669936f, -0.26604503f, 0.00727854f, 0.06254639f, -0.27243891f, 0.05117057f, -0.24997978f, 
    0.05531103f, 0.05200718f, 0.19315623f, 0.03133907f, 0.10335653f, -0.24407801f, -0.01552437f, -0.22363368f, 
    0.04408574f, -0.08933682f, 0.31525165f, -0.20149173f, -0.12760314f, -0.04370204f, 0.00604574f, 0.15722477f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11595374f, -0.04764529f, -0.14324510f, 0.03539587f, -0.03033102f, 0.02374955f, 0.09032697f, -0.13652152f, 
    -0.03674900f, 0.05852061f, 0.15823127f, 0.08354808f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
