#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.23274851f, -0.73657739f, 0.51965928f, -0.70369929f, -1.15778971f, -0.33362001f, 0.44351137f, -0.16799089f, 
    -0.04833721f, 1.24571085f, -0.17130697f, -1.07817388f, 0.06011228f, -0.31249711f, 0.00551545f, 0.67007852f, 
    -0.38783401f, 0.10264989f, -0.37808827f, 0.47604072f, -0.37737754f, -0.59668708f, -0.14142415f, -0.24321756f, 
    0.57025462f, 0.78333002f, -0.06094530f, -0.16487645f, 0.90374154f, -1.12476289f, -0.06619102f, -0.44268385f, 
    -0.89086634f, -0.33758587f, -0.39641306f, -0.66108584f, -0.92479503f, -0.61900282f, -0.67195660f, 0.24987568f, 
    -0.20013869f, -0.31012109f, -0.59198314f, -0.49648941f, -0.54187840f, 0.85951763f, -1.25140774f, 0.62461448f, 
    -0.32402635f, -0.50169104f, 0.64102399f, 0.01553072f, -0.26768467f, 0.37845710f, -0.14192279f, 0.55137771f, 
    0.28866419f, 0.49346745f, 0.58629227f, 0.62122577f, -0.17460370f, 0.18520753f, -0.15016630f, -0.92405027f, 
    0.86534274f, 0.10283006f, -0.89862299f, 0.02736484f, 0.78519249f, 0.07629893f, 0.17747854f, -0.07908490f, 
    -1.22435737f, 0.52624470f, -0.40672728f, 0.25155693f, 0.63587826f, 0.06888543f, 0.18169743f, -0.38884395f, 
    0.18861112f, -0.57786113f, 0.93220830f, -0.29775843f, 0.02607863f, -0.32052296f, 0.35059977f, 0.07255168f, 
    0.23964390f, 0.45619220f, -0.97800022f, -0.92981696f, -0.63556010f, 0.75290436f, 0.29771721f, 0.27952740f, 
    0.43327549f, 0.12685311f, 0.19552021f, -0.79650700f, -0.49581385f, -0.82127428f, -0.15968044f, 0.07415759f, 
    0.51234174f, 0.14357165f, 0.52982563f, 0.02761432f, 0.87162542f, 0.14485860f, -0.11307676f, -0.23777139f, 
    0.02680673f, 0.02773074f, 0.25289103f, 0.42152327f, -0.11121879f, 0.65361851f, 0.10146739f, 0.16233991f, 
    -0.70663500f, -0.87087125f, -1.02043486f, -0.26485318f, 0.55680925f, -0.09560464f, 0.83681643f, -0.44108716f, 
    -0.74232727f, 0.29735193f, 0.78036755f, 0.64515305f, -0.40915108f, 0.43593544f, -0.23769762f, 0.28863883f, 
    -0.59503359f, -0.53645527f, 0.30760580f, -0.15195319f, -0.65473861f, 0.13447130f, 0.63819927f, 0.63542449f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.48055688f, 0.16416787f, 0.30021673f, -0.06091806f, -0.19941001f, 0.09641195f, -0.22220820f, 0.43713850f, 
    0.23545922f, -0.05614174f, 0.33646613f, 0.32732767f, 0.42244846f, 0.32864332f, 0.57517689f, 0.06957799f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01882242f, -0.10479710f, -0.01646595f, 0.35385612f, -0.13460191f, -0.04512449f, 0.11090821f, 0.00524835f, 
    0.06689354f, 0.16996279f, -0.04338663f, -0.03290994f, -0.09476197f, 0.09854910f, -0.00253622f, -0.00864747f, 
    0.03940134f, -0.11634323f, 0.03107543f, -0.00987770f, -0.05920975f, -0.06647640f, 0.05813108f, -0.12280890f, 
    0.03416972f, 0.05979698f, -0.06789343f, -0.01495095f, -0.00588545f, 0.11287978f, 0.06632793f, 0.14031866f, 
    -0.13736211f, 0.02077363f, -0.00835441f, 0.01350961f, 0.09197816f, -0.06053913f, 0.10761444f, -0.04311816f, 
    0.09092168f, 0.05561316f, 0.15441602f, 0.14915435f, 0.03409598f, 0.09397071f, -0.03727998f, -0.00474172f, 
    -0.09708692f, 0.02000671f, 0.04417005f, 0.01548978f, 0.15112188f, -0.06706119f, -0.00970595f, -0.03803109f, 
    -0.01271754f, 0.00148197f, -0.11402796f, -0.14871445f, -0.02687545f, -0.18058473f, 0.13161489f, 0.07145166f, 
    -0.15033500f, -0.09769232f, -0.01402413f, 0.09277568f, 0.08746337f, 0.00829111f, -0.05017867f, -0.03536463f, 
    -0.11641067f, 0.02768197f, -0.10676092f, -0.07830715f, 0.10957585f, 0.15844968f, -0.01182649f, 0.12554033f, 
    -0.36908549f, -0.36773849f, -0.06892098f, 0.23834124f, -0.20458439f, -0.20195194f, 0.06316119f, -0.08990821f, 
    0.01399945f, -0.01875750f, 0.01882196f, 0.00562665f, -0.01910880f, 0.01537176f, -0.00190105f, -0.06550913f, 
    0.07975755f, -0.13986082f, 0.03119936f, 0.03653577f, -0.06004934f, -0.18908960f, -0.10981269f, 0.04355939f, 
    0.12220882f, 0.09232380f, -0.08781900f, 0.02902876f, 0.22148888f, -0.14531785f, 0.07488161f, -0.08042957f, 
    0.13982502f, -0.09378590f, 0.10351145f, -0.06062118f, -0.04118240f, -0.15752305f, 0.20551679f, 0.15021989f, 
    0.06052285f, 0.08187330f, -0.02435428f, -0.05396166f, -0.07435401f, 0.04257924f, 0.01576202f, -0.00603280f, 
    0.03508807f, -0.01076058f, -0.01731510f, -0.12172019f, 0.07957878f, -0.03234029f, -0.12224171f, 0.08626400f, 
    0.06797015f, 0.10350383f, -0.03805247f, 0.05830162f, 0.08966053f, 0.19839156f, -0.13185908f, 0.02948050f, 
    -0.01671712f, -0.05400733f, 0.10340640f, 0.07967204f, -0.10528686f, -0.01156195f, 0.07163523f, 0.07582093f, 
    0.21980140f, 0.04320199f, 0.00635135f, -0.00751163f, -0.08844341f, 0.05730456f, -0.05115264f, 0.01213583f, 
    0.33019343f, -0.06377800f, 0.11521716f, 0.04815673f, 0.01053907f, 0.00986655f, -0.05791370f, -0.04666314f, 
    0.02321437f, 0.06594686f, 0.13432594f, 0.01047379f, -0.00226497f, 0.04388925f, 0.18876468f, 0.09303568f, 
    -0.05883554f, 0.13082522f, -0.04347573f, 0.05429576f, 0.17645356f, 0.07374121f, -0.08161143f, 0.11475614f, 
    -0.03725132f, -0.01641791f, 0.06061928f, 0.01936919f, -0.00738046f, -0.05648990f, 0.05594295f, -0.19929630f, 
    0.10983590f, -0.00357441f, 0.03362331f, 0.10207893f, -0.07157418f, 0.00845658f, -0.03698861f, -0.00270967f, 
    0.35174051f, 0.05000843f, 0.33296984f, 0.16733351f, 0.02428115f, -0.05809906f, -0.07424418f, -0.16143006f, 
    -0.05464526f, 0.03447689f, 0.11162927f, 0.12400548f, 0.09197995f, 0.04475125f, 0.16080086f, 0.08938289f, 
    -0.00908528f, -0.08050612f, 0.00420967f, -0.06959987f, 0.24876121f, 0.22428785f, 0.31570041f, 0.02239460f, 
    -0.09093534f, -0.07017548f, -0.18039584f, -0.24303730f, 0.22228208f, 0.04777010f, 0.07111737f, 0.10965988f, 
    0.08654471f, 0.00448745f, 0.08988984f, -0.06338503f, -0.06026971f, -0.02392819f, 0.00397036f, -0.04318490f, 
    -0.05473963f, -0.01722066f, -0.02202089f, -0.11312983f, 0.06952423f, 0.04130815f, -0.03424901f, 0.03710460f, 
    0.05305260f, 0.09558792f, 0.07501012f, 0.00319610f, 0.08315065f, -0.07612566f, -0.04900831f, 0.06494779f, 
    -0.03837300f, 0.12375370f, -0.00482929f, 0.00632210f, -0.19459844f, -0.12606435f, 0.07972725f, -0.05695153f, 
    -0.01795422f, 0.22323208f, 0.09917786f, 0.08252521f, -0.01186479f, 0.26761240f, 0.02543935f, 0.04248470f, 
    -0.01762185f, 0.00722874f, -0.02895622f, 0.04183637f, 0.05394317f, -0.18410368f, -0.05124167f, 0.04528498f, 
    -0.27832156f, 0.10968493f, 0.29742146f, -0.12135860f, -0.00874997f, -0.02750176f, -0.00420080f, -0.04581061f, 
    -0.05110990f, 0.05445568f, -0.01534169f, -0.03164369f, -0.01519352f, 0.10670979f, -0.00674766f, 0.04209412f, 
    0.10351467f, 0.09841198f, 0.03057740f, 0.01469480f, 0.06044047f, -0.05511329f, 0.28680500f, -0.04944579f, 
    0.02411374f, 0.04594064f, 0.03353817f, -0.24448365f, 0.00948870f, -0.06779174f, -0.01494070f, 0.04531666f, 
    0.10709666f, -0.01909151f, 0.06397790f, 0.07010719f, 0.04061453f, -0.11783034f, 0.06563984f, -0.00879697f, 
    -0.54618984f, -0.38488445f, 0.00166715f, 0.49331337f, -0.05398000f, 0.10071923f, -0.00575317f, 0.19257580f, 
    -0.07534922f, 0.01419812f, 0.11426491f, 0.02375807f, 0.12169079f, 0.03317582f, 0.11313075f, 0.01979143f, 
    0.06182631f, 0.07753199f, 0.17373770f, 0.03050480f, 0.41025662f, 0.19386247f, 0.04479656f, -0.52781570f, 
    -0.14712037f, 0.03348461f, 0.00102327f, -0.03383267f, -0.01181543f, 0.10278209f, 0.27067140f, 0.01452539f, 
    -0.09042017f, -0.12263195f, 0.18175927f, 0.18992709f, 0.09973756f, -0.13399087f, -0.03522939f, 0.06328031f, 
    -0.26374379f, 0.06558225f, 0.23664252f, 0.04800898f, -0.00109075f, -0.00624319f, -0.00399918f, 0.08692770f, 
    0.11991803f, 0.01795213f, 0.05835238f, -0.02512144f, 0.03048864f, 0.02046441f, 0.03454613f, 0.00455202f, 
    0.07827234f, 0.08861452f, 0.16689883f, -0.15556346f, -0.15431245f, 0.12881261f, 0.07762739f, 0.10221245f, 
    -0.20885922f, 0.01995316f, -0.12264981f, -0.19486082f, 0.06989073f, -0.13208669f, 0.08256692f, 0.03023486f, 
    0.16089915f, 0.05242967f, 0.12681022f, 0.04085993f, 0.14879151f, 0.21960570f, 0.01895267f, 0.14208055f, 
    -0.32847914f, -0.16922115f, 0.16665459f, 0.28107855f, -0.15542239f, 0.02399783f, -0.12107738f, -0.12056634f, 
    -0.03641130f, 0.05194067f, 0.06516075f, 0.04316632f, 0.10143703f, 0.05492122f, -0.13121916f, -0.13306375f, 
    0.06583612f, 0.06552799f, 0.11362594f, 0.03548457f, 0.26886585f, 0.18516265f, -0.29834190f, -0.06138358f, 
    -0.03879051f, -0.13250770f, -0.04682147f, -0.03531092f, 0.00128273f, 0.11222668f, -0.01303790f, -0.02750255f, 
    0.08650077f, 0.01769939f, -0.00755893f, -0.04525092f, 0.03034691f, -0.17266309f, 0.11695248f, 0.09813835f, 
    0.03528167f, 0.08462538f, 0.03956715f, 0.01191714f, 0.18857852f, -0.12542264f, -0.09541468f, -0.16992602f, 
    -0.12307155f, -0.09411795f, 0.12095863f, 0.10830993f, -0.01874365f, -0.02165841f, -0.00972316f, -0.07969546f, 
    -0.03499461f, -0.11558050f, 0.00463820f, -0.05896554f, -0.45252657f, -0.08233041f, -0.14948520f, 0.06630141f, 
    0.20589517f, 0.11352581f, -0.00038708f, -0.13357100f, 0.02619666f, 0.23004919f, 0.13407241f, 0.20720127f, 
    0.14948119f, -0.05590202f, 0.03749591f, 0.09963127f, 0.04650539f, 0.00580441f, 0.19674194f, -0.10178588f, 
    -0.51910567f, 0.16748455f, 0.22575256f, 0.03941223f, 0.05114870f, -0.00064355f, -0.03909832f, 0.04293488f, 
    -0.06035957f, -0.00487098f, 0.18572018f, 0.04595881f, 0.03088005f, 0.12833202f, -0.02425285f, 0.03120921f, 
    0.00986695f, -0.03902032f, -0.00019141f, 0.09572372f, -0.21808052f, 0.09814379f, -0.02182370f, -0.03077080f, 
    0.01546210f, -0.04443843f, -0.09695997f, -0.11355153f, -0.01365140f, -0.05176126f, 0.06169338f, -0.04835207f, 
    -0.10706304f, -0.00038948f, 0.00836918f, -0.00111650f, -0.02287688f, -0.17678125f, -0.02948283f, -0.03588935f, 
    -0.37131777f, 0.10926937f, 0.35087436f, -0.04201380f, -0.14946586f, -0.18961647f, -0.09933626f, -0.06515387f, 
    -0.04011070f, 0.11986915f, 0.08554205f, 0.12329476f, 0.03904129f, 0.01794519f, 0.02321636f, 0.00069310f, 
    0.02424870f, 0.04297145f, -0.05280127f, 0.02047409f, -0.62503332f, 0.15090747f, 0.23443775f, 0.14212932f, 
    -0.20069280f, -0.14466785f, -0.02442205f, -0.04340506f, 0.10457429f, 0.23192897f, 0.09333014f, 0.20464329f, 
    0.00807531f, 0.04358796f, -0.03592151f, -0.00231777f, -0.01621971f, -0.02158364f, 0.01099135f, -0.00319976f, 
    0.27783465f, -0.01122048f, -0.11599258f, -0.26891488f, 0.06284856f, 0.09247462f, 0.03985895f, 0.07430244f, 
    -0.02389967f, 0.09251306f, 0.07097312f, -0.07981282f, -0.07981429f, -0.11239457f, -0.05145753f, 0.01433333f, 
    0.04024978f, -0.07975207f, -0.01445782f, -0.05974437f, 0.19007900f, -0.16097087f, -0.49948204f, 0.09822867f, 
    0.14538769f, 0.05177546f, 0.13186075f, 0.20847057f, -0.00091818f, -0.01725127f, 0.09360602f, 0.00664019f, 
    -0.05363834f, -0.07000604f, 0.03137282f, 0.15520379f, 0.10655276f, 0.02696199f, 0.14336585f, 0.07756940f, 
    0.17416827f, 0.05551449f, 0.14215373f, -0.06637739f, 0.18747705f, 0.04393959f, -0.05420793f, -0.02017240f, 
    0.02724404f, -0.03168192f, 0.17182773f, 0.19945547f, 0.28448614f, 0.04910503f, 0.07518269f, 0.06806606f, 
    -0.03331335f, 0.00576266f, -0.02775605f, 0.06955601f, -0.10533033f, 0.07865591f, 0.15674636f, -0.09374140f, 
    -0.15235475f, -0.13228640f, -0.15130405f, -0.06883935f, -0.13018113f, -0.29846352f, 0.06572407f, 0.04853378f, 
    -0.07234758f, 0.02257792f, -0.03517907f, -0.07730318f, 0.01967298f, 0.04722485f, -0.17101942f, 0.01354605f, 
    -0.19100089f, -0.27847537f, -0.20157519f, 0.44954064f, 0.17224847f, -0.15687096f, -0.05144162f, 0.06010415f, 
    -0.09938396f, 0.12917690f, -0.07297503f, 0.02211085f, 0.04117489f, 0.02174103f, -0.07790160f, 0.08385570f, 
    0.01839362f, 0.07519902f, 0.08040588f, 0.00913765f, -0.23449634f, -0.05151207f, 0.36633274f, 0.34906039f, 
    0.03937364f, -0.11076610f, 0.05765078f, -0.02791869f, -0.11038181f, -0.02413051f, -0.11258648f, -0.04092884f, 
    0.16670440f, 0.10530933f, 0.07242841f, 0.10307506f, -0.00596146f, 0.09434716f, 0.04512180f, -0.11711162f, 
    -0.08680946f, -0.11420799f, -0.05096617f, 0.19037071f, 0.27740017f, 0.13552178f, 0.14452365f, 0.15897225f, 
    -0.07796710f, 0.15229098f, 0.17774759f, 0.01168759f, 0.08379500f, -0.15995504f, -0.02888204f, 0.03727749f, 
    -0.09829900f, 0.01227759f, 0.10514615f, 0.05118952f, 0.00388443f, -0.50140822f, -0.16902851f, 0.32953963f, 
    0.23206529f, -0.03385983f, 0.03909115f, 0.09306772f, 0.09145264f, -0.02821630f, -0.03988071f, 0.04658556f, 
    -0.01533643f, -0.04737918f, 0.00681316f, 0.27037001f, 0.07658960f, 0.03614689f, 0.29196075f, 0.20228820f, 
    -0.53558499f, -0.26367304f, -0.28794229f, 0.12586001f, 0.08128781f, -0.16543390f, -0.02518902f, -0.08599377f, 
    -0.08399841f, -0.05947864f, -0.11571693f, 0.01692440f, 0.11173175f, 0.11350473f, -0.08982459f, 0.02276417f, 
    0.25541610f, 0.14779614f, 0.09302697f, 0.16352551f, -0.40913251f, 0.03877075f, 0.00456588f, 0.18820970f, 
    -0.14931159f, 0.09990701f, -0.21289217f, -0.09247450f, 0.32459339f, -0.15615608f, -0.13626406f, 0.02194981f, 
    0.05108489f, 0.02534555f, 0.15409169f, 0.08048599f, -0.06197738f, -0.01077613f, -0.04750770f, -0.05397225f, 
    -0.25144646f, -0.39309612f, -0.28147873f, -0.32772243f, -0.19916406f, -0.00978198f, -0.07826146f, -0.07543202f, 
    -0.06410316f, -0.00309299f, -0.06717876f, 0.05616118f, -0.00003048f, -0.01049811f, -0.03532531f, 0.10607634f, 
    0.02599300f, -0.11747156f, -0.01251518f, 0.02042616f, 0.60995418f, 0.13510154f, -0.15124525f, -0.28971562f, 
    0.15127476f, 0.07995494f, 0.07316713f, 0.11458977f, 0.02375441f, 0.07122453f, -0.04915377f, 0.05787503f, 
    0.09360699f, 0.08967268f, 0.08642793f, -0.01827502f, 0.08051886f, -0.05643175f, 0.09414532f, 0.07805794f, 
    0.33756351f, -0.08510599f, 0.29409906f, 0.18601356f, 0.04956010f, 0.12134978f, -0.00038471f, -0.02348469f, 
    0.01605956f, 0.06231279f, -0.13078380f, -0.02470344f, 0.09318267f, -0.00514630f, 0.00846999f, -0.01074989f, 
    -0.02073276f, -0.01461666f, 0.09146589f, 0.09386082f, -0.02359003f, -0.16480112f, -0.10897982f, -0.08172915f, 
    0.00840580f, 0.05006671f, 0.11651700f, -0.03802595f, 0.03774213f, -0.06303012f, 0.07105291f, 0.10081627f, 
    0.00606418f, -0.16501176f, 0.19357763f, 0.12047347f, -0.18990572f, -0.01010683f, -0.00128905f, -0.17566799f, 
    -0.29079863f, 0.04017651f, 0.39722344f, 0.18839027f, 0.09054798f, 0.05434018f, -0.08884664f, -0.10854954f, 
    0.06877705f, 0.01811062f, -0.15762974f, 0.06460594f, 0.10172693f, -0.07865913f, -0.05862267f, 0.01913156f, 
    -0.06877566f, -0.11380173f, 0.00882896f, 0.01057806f, -0.02297936f, 0.10266628f, 0.33698332f, 0.13344947f, 
    0.32873300f, 0.01290853f, -0.07692567f, -0.18342212f, 0.18388389f, 0.06512507f, -0.02985207f, 0.09791603f, 
    -0.03577066f, -0.07399260f, -0.02003997f, 0.03046660f, -0.07292011f, 0.04025501f, 0.03371705f, -0.00316077f, 
    0.03522184f, 0.01873927f, 0.01159980f, 0.01907014f, -0.15354598f, -0.08841599f, -0.00300264f, 0.01007501f, 
    -0.01161960f, -0.08232860f, -0.00259062f, -0.07335399f, 0.07725836f, -0.03164764f, -0.00141838f, 0.14919500f, 
    0.02765857f, 0.19033484f, -0.09736390f, 0.01233490f, -0.07145326f, -0.19879702f, 0.23414508f, 0.32394126f, 
    0.33705398f, 0.07476578f, 0.05559786f, 0.20915052f, 0.02489577f, -0.02888489f, -0.01621773f, 0.06228042f, 
    -0.00507512f, -0.06964528f, -0.00276145f, 0.00442392f, 0.02479821f, 0.27522692f, 0.11766324f, 0.00076761f, 
    -0.41400769f, 0.21300925f, 0.16072258f, -0.15643927f, 0.07032287f, 0.07972378f, 0.09082763f, 0.00591628f, 
    0.10550064f, -0.09463251f, -0.11166658f, -0.00731813f, 0.17818095f, 0.12111958f, 0.20507431f, -0.00122707f, 
    -0.05437514f, 0.01027658f, -0.06567439f, -0.05616392f, -0.39453489f, -0.13102654f, 0.04784894f, 0.17852497f, 
    0.02175902f, -0.00565488f, -0.01308773f, 0.01763031f, 0.07523320f, -0.00914073f, -0.09370280f, 0.02159736f, 
    -0.11601318f, -0.04613092f, -0.00613067f, 0.08457852f, -0.09391909f, 0.03306819f, -0.09315091f, -0.23085175f, 
    0.01763928f, 0.24840945f, 0.17913951f, 0.01876942f, -0.03018819f, -0.00233607f, -0.09152216f, 0.17719597f, 
    -0.06439967f, 0.07423174f, -0.02591083f, -0.03833247f, 0.01900182f, 0.09627642f, 0.02526923f, 0.15658937f, 
    -0.00714124f, -0.06935649f, 0.04656663f, -0.00274706f, 0.15776592f, -0.39761767f, -0.15343562f, 0.06729286f, 
    -0.28201494f, -0.06567467f, -0.08387119f, 0.08974705f, 0.25671980f, -0.00718005f, 0.01931075f, 0.04958550f, 
    -0.08004820f, 0.07189564f, -0.00014950f, -0.10676912f, -0.08346834f, -0.04156873f, 0.01003980f, 0.10342181f, 
    -0.14511192f, 0.11139514f, 0.32385817f, 0.01065120f, -0.14352095f, -0.17294928f, 0.05070575f, 0.03872937f, 
    -0.01177317f, 0.07380258f, 0.02558045f, 0.20177421f, -0.01990989f, 0.05293635f, -0.05148134f, -0.12461618f, 
    -0.04119876f, 0.07647283f, 0.04956082f, 0.03919646f, -0.09212880f, 0.41209349f, -0.10728823f, 0.06355193f, 
    -0.20958632f, 0.05975912f, 0.01314113f, 0.13472064f, -0.05990877f, 0.19658673f, 0.04904239f, 0.03227739f, 
    0.01462395f, 0.12994558f, 0.03661593f, -0.02010413f, 0.12001441f, 0.06336023f, -0.19961704f, 0.06093973f, 
    0.24740839f, 0.14667097f, 0.20677814f, -0.01001353f, -0.17847238f, -0.03554653f, 0.05741104f, 0.08559258f, 
    -0.01600294f, 0.01583131f, 0.09163384f, -0.08366463f, 0.00396439f, 0.02106887f, -0.00746340f, 0.12186324f, 
    0.05539131f, -0.06076666f, -0.00624014f, -0.10680210f, 0.15742248f, -0.30774373f, 0.15449551f, -0.10748760f, 
    -0.01851340f, -0.02535132f, 0.00338800f, 0.18525694f, 0.15909898f, -0.10470944f, 0.12021166f, -0.14917195f, 
    0.05382674f, 0.11212785f, 0.00402830f, -0.12346152f, 0.08140471f, -0.22452974f, 0.13734987f, 0.11924580f, 
    -0.02150914f, 0.05564781f, 0.18252927f, 0.09874945f, 0.07121814f, -0.08235992f, -0.03236515f, 0.01832357f, 
    0.02014899f, -0.04649664f, 0.25546533f, 0.15504897f, 0.13362813f, 0.08966596f, 0.12614970f, -0.00355763f, 
    -0.06442190f, -0.01156951f, -0.06857582f, -0.01089082f, -0.41437891f, -0.23740126f, 0.26234281f, 0.07830954f, 
    0.08233561f, 0.00577396f, 0.15070587f, 0.09845870f, 0.04664730f, 0.00183043f, 0.17916696f, 0.02506412f, 
    0.10312151f, 0.12021877f, -0.01434612f, 0.04987967f, 0.05593438f, -0.05388168f, 0.02490083f, 0.07204462f, 
    -0.25435948f, -0.16770363f, -0.07923400f, 0.11941469f, -0.16739932f, -0.08766408f, -0.07706150f, -0.05084897f, 
    0.02382603f, 0.16554742f, 0.07741326f, 0.08739423f, -0.16360067f, 0.00674186f, -0.01947935f, 0.03772762f, 
    0.00386961f, 0.06792469f, -0.19695559f, -0.05940934f, -0.18068665f, -0.02673016f, 0.09176596f, 0.05997188f, 
    -0.00014341f, -0.13174132f, -0.07922515f, -0.00291947f, 0.05631905f, 0.01193860f, 0.06420625f, 0.16582039f, 
    -0.02653387f, 0.01748486f, 0.03964584f, -0.13823989f, 0.03049483f, -0.19795176f, 0.02034585f, 0.01809068f, 
    0.31965089f, -0.24690765f, -0.24671829f, 0.15989697f, -0.40638176f, -0.20633258f, 0.04528658f, -0.12023737f, 
    -0.00956977f, 0.12275066f, 0.18701600f, -0.04878075f, -0.10494698f, 0.00899394f, -0.14806175f, -0.00137255f, 
    -0.00290635f, -0.00325691f, -0.07445943f, -0.10883705f, 0.08921917f, -0.05198313f, 0.09157725f, 0.04232899f, 
    -0.39149582f, -0.06243099f, 0.03671078f, -0.10448202f, -0.06273690f, 0.11955108f, 0.06714407f, -0.06145194f, 
    -0.10935595f, -0.18206981f, -0.12433674f, -0.07067870f, 0.04521710f, -0.07138023f, 0.00778474f, -0.03872812f, 
    0.15811585f, 0.02440849f, 0.06574285f, 0.01427875f, 0.04679438f, -0.08665632f, 0.13740991f, 0.03509487f, 
    0.10900760f, -0.04747986f, -0.03214186f, 0.02845573f, 0.04699577f, -0.04444465f, 0.08269318f, -0.02766343f, 
    0.10556263f, 0.11916889f, 0.06291604f, 0.02321521f, 0.38486791f, 0.30355141f, -0.18182094f, -0.05711808f, 
    -0.24173261f, 0.22493096f, -0.07146414f, -0.06777521f, 0.14480375f, 0.07638663f, -0.14926744f, 0.03003161f, 
    0.09504116f, 0.02911375f, -0.01018959f, 0.02791732f, -0.02970146f, -0.06162652f, -0.00039012f, 0.12300403f, 
    0.13579701f, -0.24673969f, 0.01918169f, 0.05159169f, -0.10770497f, -0.01825817f, 0.00753399f, -0.07221960f, 
    0.09316456f, 0.00910466f, 0.08760311f, 0.08453730f, 0.05776120f, -0.00723697f, 0.00384879f, -0.00345889f, 
    0.09129475f, 0.04422734f, -0.02857462f, 0.06544100f, 0.30988064f, 0.06237863f, 0.06718705f, 0.02530979f, 
    -0.13913216f, -0.16413730f, -0.05401761f, -0.03939882f, -0.01088554f, 0.03936084f, 0.13815872f, 0.11950552f, 
    -0.05734428f, -0.03247104f, 0.01665265f, -0.09694480f, 0.06861772f, -0.06920893f, 0.03872914f, -0.02208564f, 
    0.04213829f, -0.01982585f, -0.02100313f, 0.04417804f, -0.00647351f, -0.05714816f, -0.06060368f, -0.04559924f, 
    0.02386467f, 0.02501011f, -0.03743272f, 0.01105010f, 0.02449354f, 0.02377648f, 0.04452604f, 0.02852632f, 
    -0.00771470f, 0.02202194f, -0.03940646f, -0.05673109f, 0.01380277f, 0.02888637f, 0.05586686f, 0.01881308f, 
    -0.03900018f, -0.01959342f, -0.02939548f, -0.03022466f, -0.00729191f, 0.00023677f, 0.03727993f, -0.02538690f, 
    -0.01872068f, 0.04136324f, 0.04008190f, 0.04807287f, 0.01039949f, -0.00812282f, -0.02039519f, 0.04620575f, 
    0.00694816f, 0.02237048f, -0.05706521f, 0.02765199f, -0.01644789f, -0.03066201f, 0.04252515f, -0.03261387f, 
    0.01641616f, 0.03885287f, 0.02882916f, 0.03140943f, -0.02715976f, 0.04478910f, -0.00138248f, -0.03239464f, 
    -0.03584336f, -0.04110007f, -0.01032289f, -0.02065874f, -0.03431537f, -0.01010332f, -0.03101516f, -0.06037693f, 
    0.00924115f, 0.00028137f, -0.03091999f, 0.03063097f, -0.04789050f, 0.04231950f, -0.00953073f, 0.03524535f, 
    -0.03641026f, 0.00096845f, -0.04399709f, -0.04596959f, 0.04366666f, 0.01781498f, -0.02264065f, -0.01663740f, 
    0.00308454f, -0.02386388f, -0.01261143f, 0.01804839f, -0.02828199f, 0.02990500f, -0.00814463f, 0.00977842f, 
    0.00210599f, -0.00340815f, -0.05997115f, -0.00939892f, -0.03721741f, 0.04791851f, -0.00870363f, -0.04193064f, 
    -0.03015935f, 0.04736723f, 0.04763682f, 0.00968020f, -0.00797336f, 0.00031358f, -0.02072492f, -0.04056539f, 
    -0.01432806f, 0.03287923f, -0.01505412f, 0.01400661f, -0.03194389f, -0.03217053f, 0.02261566f, 0.04577779f, 
    0.02377932f, -0.05294628f, -0.01011025f, 0.01769619f, -0.00187654f, -0.02669389f, -0.04396656f, -0.04651991f, 
    -0.02790057f, -0.02166013f, -0.00623153f, -0.00733966f, 0.02744528f, 0.03052712f, 0.04844569f, -0.03090301f, 
    0.05091568f, 0.02403544f, -0.01515036f, 0.02927461f, -0.06319351f, 0.04455344f, 0.04445571f, -0.00607343f, 
    -0.05072581f, -0.06112258f, -0.02847281f, 0.00101189f, -0.05482300f, -0.04415712f, -0.01343492f, 0.00893860f, 
    0.00635693f, -0.06353089f, -0.00738905f, -0.06283141f, 0.04550724f, -0.02353502f, 0.01379512f, 0.02410821f, 
    -0.00307333f, 0.02997116f, 0.03131300f, -0.05872016f, 0.01275710f, -0.03685758f, 0.01798592f, 0.03538980f, 
    -0.03753890f, 0.03773579f, 0.03068157f, 0.03527221f, -0.00935403f, -0.05690728f, 0.01328119f, -0.02038535f, 
    -0.04859389f, -0.00336198f, -0.04215486f, 0.02069934f, -0.01159157f, -0.06232830f, 0.03701096f, -0.04415097f, 
    -0.04808931f, -0.05279256f, 0.03041927f, -0.06357735f, 0.00964034f, -0.01304751f, 0.02549588f, -0.06124470f, 
    -0.00175161f, -0.00018532f, 0.02226306f, -0.05617711f, -0.01046203f, -0.01130662f, -0.02646071f, -0.03908201f, 
    -0.04923173f, -0.02950979f, 0.05478204f, 0.01727313f, 0.03637238f, -0.00070248f, 0.02520225f, -0.04933718f, 
    0.03106627f, -0.01135121f, 0.00339262f, -0.06001839f, -0.01373515f, -0.02278460f, -0.03466146f, -0.01493581f, 
    -0.00604287f, -0.04896520f, 0.04514709f, -0.03307812f, -0.04844350f, 0.04581825f, -0.05410282f, 0.04826371f, 
    -0.02246488f, 0.04561036f, 0.03477874f, -0.03934217f, 0.02194789f, 0.00173873f, 0.03602182f, 0.04352054f, 
    -0.05542907f, 0.00487241f, 0.02319639f, -0.00907755f, -0.05104212f, -0.01104677f, 0.03221652f, 0.03389627f, 
    0.04688059f, -0.05176775f, 0.03585089f, -0.05526513f, -0.00878203f, 0.03345719f, -0.00430645f, -0.00724562f, 
    0.01326512f, -0.03596666f, 0.03705368f, -0.01841958f, -0.02665312f, 0.01944978f, -0.03016422f, 0.01893018f, 
    0.00052779f, -0.01444212f, -0.03407446f, 0.03356936f, 0.00663242f, 0.01163482f, 0.00439728f, -0.05997478f, 
    -0.05365629f, -0.06139855f, -0.01708146f, -0.01696645f, -0.03502712f, 0.01947114f, 0.00263070f, -0.05118269f, 
    -0.03405840f, -0.05496144f, 0.03329273f, -0.05443789f, -0.03181299f, -0.03909839f, -0.02902772f, -0.03341661f, 
    -0.04339958f, 0.01328314f, -0.05242939f, 0.01380695f, -0.06187478f, -0.03980263f, 0.03107836f, 0.01645496f, 
    -0.01606776f, -0.01487132f, -0.05929722f, -0.03648996f, -0.02757845f, -0.00143219f, 0.04084705f, 0.00467915f, 
    -0.01664692f, -0.05533793f, 0.04116692f, -0.03200429f, 0.01336427f, 0.03730274f, -0.04672237f, -0.03227367f, 
    -0.05403370f, 0.02696289f, -0.02239766f, 0.02327524f, 0.03391849f, -0.01869874f, -0.00348202f, 0.01075985f, 
    0.04411171f, -0.00365559f, 0.01616319f, -0.02108199f, 0.05723725f, 0.04485941f, -0.01870483f, 0.02503628f, 
    -0.04933942f, 0.03995633f, 0.02530534f, 0.04805983f, -0.04369093f, -0.02067095f, -0.02682184f, -0.04640000f, 
    -0.01060759f, -0.04591255f, -0.04125120f, -0.01442302f, -0.03427858f, 0.02311024f, -0.00875768f, -0.02518868f, 
    -0.04332285f, 0.02860758f, -0.02091897f, 0.01586208f, -0.02461816f, 0.00709603f, -0.02598978f, 0.01290793f, 
    0.04489480f, -0.04236793f, 0.02279995f, -0.02933454f, -0.01087160f, 0.03922785f, 0.00082564f, -0.07580256f, 
    0.05038431f, -0.05197051f, 0.04183949f, -0.05414413f, 0.03969040f, -0.00092527f, -0.06400495f, 0.03745797f, 
    -0.00921543f, -0.06146804f, 0.03635719f, -0.03867932f, -0.05574715f, 0.02034206f, -0.06120549f, 0.03401678f, 
    0.03841804f, 0.01867698f, -0.00928411f, -0.03054524f, -0.04670047f, -0.01174361f, -0.00985374f, 0.03834022f, 
    0.03678453f, -0.00215419f, 0.00039691f, 0.00733956f, -0.02751255f, -0.04103648f, -0.00498085f, -0.01188289f, 
    0.03975334f, 0.03180274f, 0.01377463f, -0.06370170f, -0.01828130f, -0.04942099f, -0.04341517f, 0.01144660f, 
    0.05282978f, -0.01894653f, 0.00128606f, -0.00842867f, 0.03866455f, 0.01769162f, -0.01771673f, 0.02545966f, 
    -0.00117557f, -0.00993187f, -0.06562442f, -0.01364987f, -0.00175797f, 0.01874170f, 0.03094035f, -0.00473922f, 
    0.06098299f, -0.03768643f, -0.02056626f, 0.02047816f, 0.04739415f, 0.00041251f, 0.02330457f, 0.05751016f, 
    -0.03298453f, -0.02472982f, 0.03659971f, 0.00419028f, -0.05604956f, -0.00704219f, -0.02994001f, -0.01729550f, 
    0.01961786f, -0.04419607f, 0.03535898f, -0.01966343f, -0.02301098f, 0.04432309f, 0.01567113f, 0.01817786f, 
    0.03114900f, 0.00168233f, 0.02187121f, 0.01916360f, -0.06236932f, -0.05373005f, -0.04597988f, -0.00727345f, 
    -0.03030613f, -0.03038866f, -0.01521661f, 0.02916080f, 0.02819974f, 0.04718828f, -0.06003795f, -0.03458879f, 
    -0.00286794f, 0.00809378f, 0.03695034f, -0.04065608f, -0.00425522f, -0.04691553f, 0.03041428f, 0.01826964f, 
    0.02756266f, 0.01643907f, -0.05266714f, -0.04185751f, 0.02839632f, 0.03409157f, 0.01468260f, 0.01313569f, 
    0.03494828f, -0.01550612f, -0.03007686f, 0.03164029f, -0.00463385f, 0.02646141f, -0.06310774f, -0.00661809f, 
    0.04042404f, 0.02590205f, 0.01465298f, 0.03022807f, -0.01147783f, 0.02056023f, 0.03154640f, -0.02397887f, 
    0.02834837f, 0.00432495f, -0.00442440f, -0.05558121f, -0.06054241f, -0.02186983f, 0.01342062f, 0.02343586f, 
    0.01484667f, 0.02946232f, 0.00656243f, 0.00505918f, -0.04637392f, 0.04081894f, -0.00107702f, -0.02351013f, 
    -0.06413931f, -0.01449906f, -0.04394621f, 0.00718298f, -0.04981413f, 0.00129408f, 0.04730429f, -0.04721411f, 
    0.02221607f, -0.05695178f, 0.00106442f, 0.00791684f, -0.01260902f, -0.05764724f, -0.06963873f, -0.02167599f, 
    0.00571482f, -0.05839158f, -0.01412654f, 0.02635896f, -0.00061702f, -0.04872258f, -0.01930199f, 0.01128498f, 
    0.03047281f, -0.04852482f, -0.01963601f, -0.05668934f, 0.02391605f, -0.01316275f, 0.02268768f, -0.03560300f, 
    -0.05140349f, -0.02677879f, 0.03160375f, -0.01736955f, -0.04514067f, -0.01964681f, -0.02829009f, -0.04774920f, 
    0.03140375f, 0.03143271f, -0.00823828f, 0.03124779f, -0.01236742f, 0.00607348f, -0.05420467f, -0.03710920f, 
    0.01900174f, 0.04424623f, -0.00588373f, -0.03203357f, 0.02667895f, -0.05733222f, -0.02607150f, -0.00012013f, 
    0.05124883f, -0.00018151f, 0.00237940f, -0.00873493f, -0.05598246f, -0.02817836f, -0.05209555f, -0.01485435f, 
    -0.01919726f, 0.00257365f, -0.02751719f, -0.05229118f, -0.03506128f, 0.01687272f, 0.01851261f, 0.02775074f, 
    -0.04901172f, -0.04433589f, -0.05781837f, -0.01935638f, -0.02350434f, -0.00882818f, 0.01864299f, -0.00321444f, 
    0.03792718f, -0.05366154f, 0.04143101f, -0.00112897f, -0.02088563f, -0.01727651f, 0.02797545f, 0.01845226f, 
    0.00285514f, 0.03996645f, -0.00398378f, 0.00392322f, 0.04408289f, -0.01811437f, 0.05248378f, -0.02355542f, 
    0.05569900f, -0.04281133f, -0.04403330f, -0.06604604f, -0.00322551f, -0.03007054f, 0.03454105f, 0.01415813f, 
    0.01073320f, -0.06117075f, -0.01231416f, 0.02489739f, -0.02931739f, 0.02190700f, -0.00542548f, 0.00044722f, 
    0.00031909f, 0.03616056f, -0.03832831f, -0.05161887f, -0.05049192f, 0.00243559f, 0.03210358f, 0.03578202f, 
    0.01441425f, -0.02025522f, -0.05722089f, 0.03703267f, 0.02762976f, 0.04459469f, 0.00280413f, 0.04651216f, 
    0.03066217f, -0.01724948f, 0.03458686f, -0.05149128f, -0.00882128f, -0.01806920f, -0.01101323f, 0.02624774f, 
    0.05850073f, 0.00199153f, -0.04768788f, 0.01363419f, 0.01746963f, -0.06046741f, 0.01295648f, 0.04455849f, 
    0.02210249f, 0.03572447f, -0.05674280f, 0.04148043f, 0.02504166f, -0.06119334f, 0.01449487f, -0.02103100f, 
    -0.02600535f, 0.03980696f, 0.03316947f, 0.00266133f, -0.03668103f, 0.02932947f, 0.03124402f, -0.05352272f, 
    -0.01209733f, 0.01059697f, -0.04974380f, 0.04121376f, -0.02839038f, 0.01361856f, -0.00794304f, -0.04929001f, 
    -0.02719198f, -0.04576454f, -0.04411620f, -0.05921885f, -0.03167137f, 0.03878136f, -0.05108462f, -0.04085824f, 
    -0.02434081f, -0.02350954f, 0.00708685f, 0.03214659f, 0.00979698f, 0.04334248f, -0.02168622f, -0.03499825f, 
    0.03925966f, -0.03343749f, 0.00402302f, -0.02271746f, -0.01893222f, 0.02215314f, -0.00441631f, 0.03042600f, 
    0.01990587f, 0.03914645f, -0.05149662f, 0.04842869f, 0.01968814f, -0.04114705f, -0.04362641f, 0.02297601f, 
    0.02421291f, -0.00973598f, -0.02183392f, 0.03550808f, -0.03307968f, -0.02194051f, 0.00227450f, -0.01727067f, 
    -0.06008910f, -0.01637011f, 0.02718357f, 0.04709573f, -0.05603334f, 0.03072136f, 0.02755981f, -0.04858486f, 
    0.01780907f, 0.00337487f, -0.04033164f, -0.04754280f, -0.04680915f, -0.05534934f, 0.02709448f, 0.00005928f, 
    -0.05830889f, 0.01616955f, 0.03503617f, 0.01785837f, 0.04671741f, 0.01287664f, -0.02999888f, -0.05794924f, 
    -0.03642875f, 0.03607836f, 0.02794866f, -0.05297569f, 0.04760309f, 0.02779763f, -0.06009149f, -0.05145427f, 
    0.02037875f, 0.01621131f, 0.00343769f, 0.01050430f, 0.03152087f, 0.00717086f, -0.00405709f, -0.02891186f, 
    -0.04922266f, -0.04844255f, -0.04768529f, -0.04314277f, -0.01779507f, 0.04163181f, 0.01608266f, -0.04061626f, 
    0.01669017f, 0.01879142f, -0.00708071f, 0.00156524f, 0.03619588f, 0.05153438f, -0.03298202f, -0.04039120f, 
    -0.01504486f, 0.03805261f, -0.02876107f, -0.01179117f, 0.01000865f, -0.00857342f, 0.00333951f, 0.03452668f, 
    -0.02475131f, 0.03359088f, 0.03953692f, 0.03725005f, 0.00178541f, -0.01420329f, -0.05524081f, -0.02601609f, 
    -0.02732123f, -0.01647940f, -0.00741668f, 0.01709318f, 0.04388605f, -0.03543716f, 0.04918211f, -0.03092760f, 
    -0.05166235f, -0.00811557f, -0.01655511f, -0.04945770f, 0.01261693f, -0.03066684f, -0.02913006f, -0.00901741f, 
    0.00053362f, -0.02423877f, 0.03741379f, 0.02285606f, 0.00722752f, 0.02868654f, 0.00155075f, -0.02120817f, 
    -0.03249752f, -0.02445971f, 0.00035171f, 0.00889626f, -0.02737057f, -0.04365367f, 0.03928272f, -0.01156496f, 
    0.00728533f, -0.01631292f, -0.05490320f, -0.01876661f, -0.01251675f, -0.03543243f, 0.01783232f, 0.01310369f, 
    -0.05411979f, 0.00934802f, 0.02742564f, -0.03865261f, 0.01433405f, 0.01418989f, -0.04358963f, -0.02048285f, 
    0.00516281f, -0.05072990f, -0.03245390f, 0.03311353f, -0.00400650f, -0.00883008f, -0.02463435f, 0.00595194f, 
    0.02674731f, 0.03213510f, 0.01876657f, -0.00837600f, 0.01189009f, -0.00300946f, -0.02746988f, -0.04603553f, 
    -0.02020356f, 0.03391391f, 0.01411595f, 0.00379263f, -0.00392492f, -0.00845207f, -0.00480787f, -0.00482442f, 
    -0.05956341f, 0.01403786f, 0.06036858f, -0.01510817f, -0.02319307f, 0.04978252f, -0.03438507f, 0.02639693f, 
    -0.02518529f, -0.02970083f, 0.04424130f, -0.03334779f, -0.00324487f, -0.00676329f, 0.01617415f, 0.00916733f, 
    -0.00837133f, -0.04315270f, 0.00561581f, -0.02314723f, -0.00694548f, 0.04474342f, -0.03117345f, 0.01329126f, 
    -0.00229999f, -0.00095218f, 0.01960379f, -0.05557358f, -0.01095239f, -0.02085925f, -0.01115846f, 0.03525756f, 
    -0.02417209f, 0.00486402f, -0.01397017f, 0.01127515f, 0.01738952f, 0.01775669f, 0.00281712f, 0.00573834f, 
    0.03674103f, -0.06044989f, -0.00345091f, -0.00567649f, -0.00161710f, -0.01669530f, 0.01956828f, 0.03736096f, 
    -0.02726554f, -0.02587983f, -0.04223142f, 0.00292065f, -0.04952337f, 0.03163482f, 0.01113617f, -0.03279333f, 
    0.04558778f, 0.00660416f, -0.01065855f, -0.04165955f, 0.04525577f, -0.04523595f, -0.01469558f, -0.02864353f, 
    0.03697534f, 0.04635617f, -0.04948306f, 0.00781251f, -0.00846748f, -0.03118012f, 0.03042017f, -0.04023293f, 
    0.00111089f, 0.01363558f, -0.04434599f, 0.03403065f, -0.04300756f, -0.04083912f, 0.02187532f, -0.06034772f, 
    -0.03480357f, -0.06043977f, 0.02692300f, 0.01296753f, -0.01106018f, 0.00929895f, -0.06092484f, 0.00558653f, 
    -0.02463829f, -0.03772130f, 0.03842134f, -0.01978301f, 0.01565527f, 0.04088451f, -0.00964842f, -0.00193832f, 
    0.00477634f, -0.00509471f, 0.03543890f, -0.04639828f, 0.00058884f, -0.01364306f, -0.01260397f, 0.05035556f, 
    0.05978829f, -0.00420292f, -0.05142631f, -0.05068528f, 0.04502584f, -0.00633031f, 0.02256903f, -0.04318738f, 
    0.02537614f, 0.01187827f, 0.03814372f, 0.04535547f, 0.02195049f, -0.04815052f, -0.02620538f, 0.00141437f, 
    0.48598987f, 0.25864634f, 0.33729449f, -0.04314102f, -0.20742413f, 0.16037370f, 0.06936301f, 0.08885329f, 
    0.08858446f, 0.11789009f, 0.06095650f, 0.00657756f, -0.01719856f, 0.10448954f, 0.04441262f, -0.00704629f, 
    0.09626731f, 0.06754371f, 0.06655907f, 0.16229671f, -0.24864900f, -0.13063462f, -0.11407526f, -0.06909135f, 
    -0.05540534f, -0.07809636f, -0.02148425f, -0.18371610f, 0.02674710f, -0.08896607f, -0.06743563f, -0.16638803f, 
    0.04031552f, 0.07901964f, -0.10528167f, 0.01330695f, 0.08381320f, 0.01947146f, 0.01635255f, -0.02106193f, 
    0.26357949f, 0.35603148f, 0.00045880f, 0.04556640f, -0.02189779f, -0.15030134f, -0.18128896f, 0.14383306f, 
    -0.00752944f, -0.11362810f, -0.19078363f, -0.03585886f, -0.05928636f, 0.07703558f, -0.06129873f, -0.03921433f, 
    0.00887913f, 0.10826649f, -0.00573353f, 0.14729032f, 0.28412256f, 0.19827767f, 0.28609037f, -0.00759488f, 
    0.13656074f, -0.02563728f, -0.13324456f, 0.16363224f, 0.10408146f, -0.03547682f, 0.00459476f, 0.02404976f, 
    0.04620856f, 0.04660184f, -0.02523948f, 0.15896611f, -0.04570070f, -0.17585455f, 0.05420930f, -0.06547318f, 
    -0.08861461f, 0.03570703f, 0.23457290f, 0.06222330f, -0.10029051f, 0.02197698f, -0.08435551f, -0.00712640f, 
    -0.04301245f, -0.16937220f, -0.00150559f, 0.02581684f, -0.01879674f, 0.06292550f, 0.12561923f, 0.18964230f, 
    -0.01889358f, -0.20040530f, -0.10843831f, 0.00693243f, 0.20050742f, -0.10754065f, 0.11458247f, 0.02595037f, 
    -0.12187526f, 0.06070434f, -0.13742048f, -0.04092966f, -0.05608407f, -0.11998466f, 0.12500213f, 0.05518752f, 
    -0.00256490f, -0.02382371f, 0.15458420f, -0.09719500f, -0.10247448f, 0.03420905f, 0.02677924f, 0.05786987f, 
    -0.17185134f, -0.27599153f, -0.29966849f, -0.15858138f, -0.07139960f, 0.00067191f, 0.06951755f, 0.04523494f, 
    0.03437285f, 0.00032166f, -0.00229384f, -0.12316591f, -0.02700983f, 0.16883105f, 0.17281051f, -0.00787065f, 
    0.02458580f, 0.05814625f, -0.05642196f, 0.01800054f, 0.00706294f, 0.02788566f, 0.00937721f, 0.05268630f, 
    0.10732702f, 0.09565216f, -0.12417758f, -0.03542279f, 0.06496917f, 0.00736586f, 0.03354996f, 0.10152975f, 
    -0.12767823f, 0.10061825f, -0.00661902f, 0.10794964f, 0.04870028f, 0.10915760f, -0.10360028f, 0.16464701f, 
    -0.19767636f, -0.07244740f, -0.11488199f, 0.08836942f, 0.03227019f, -0.00731547f, 0.04124032f, -0.00262474f, 
    0.14757706f, 0.00733746f, 0.08473344f, -0.03627667f, 0.02322186f, -0.02510061f, -0.02657281f, -0.02325992f, 
    0.04533022f, 0.09744003f, 0.06274337f, 0.03896000f, -0.03424188f, -0.05480741f, -0.05603673f, 0.01582096f, 
    0.03368642f, 0.00808423f, 0.07124748f, -0.05551153f, -0.00288889f, 0.06580663f, 0.04583400f, -0.04765523f, 
    -0.08436232f, -0.10057365f, -0.04951743f, 0.04754390f, 0.05140675f, 0.05052787f, -0.03344613f, -0.01589327f, 
    -0.25178403f, -0.01240356f, -0.12723097f, 0.07689109f, 0.04555656f, 0.02308827f, -0.01396131f, 0.05050355f, 
    0.15209320f, -0.07135832f, 0.11358690f, -0.09574463f, -0.14732896f, -0.12318724f, -0.10689470f, -0.02532662f, 
    -0.01024358f, 0.09500799f, -0.02428181f, 0.04712027f, 0.04816253f, 0.10831608f, 0.03002298f, 0.01511185f, 
    0.11011507f, 0.08508391f, 0.01123112f, 0.11883727f, 0.04254285f, -0.07604322f, 0.01152917f, -0.08170187f, 
    -0.05331966f, -0.02877382f, -0.00314258f, 0.04014564f, 0.10096092f, 0.03269536f, -0.01256301f, 0.01804379f, 
    -0.16135405f, -0.00014123f, -0.05392472f, 0.11879984f, -0.02297353f, -0.09556145f, -0.03006722f, 0.01590202f, 
    0.05995654f, 0.03807753f, -0.06814777f, -0.03711447f, 0.00805584f, 0.05166180f, -0.00813309f, -0.04059858f, 
    -0.11223047f, -0.04677266f, -0.03857473f, -0.00217193f, 0.28719112f, 0.48617262f, 0.46435258f, -0.01013761f, 
    -0.17442097f, -0.01380864f, -0.01842246f, -0.07547811f, 0.13505460f, 0.02072183f, -0.08429205f, 0.01470456f, 
    -0.02714040f, 0.01105291f, 0.04950053f, 0.05042343f, 0.11118440f, 0.12782612f, 0.06333544f, 0.05917924f, 
    -0.40302420f, -0.20214084f, -0.09853594f, -0.02251675f, 0.09437301f, -0.01727230f, 0.10699949f, 0.03667283f, 
    -0.03962605f, -0.00348269f, 0.00593174f, -0.00221894f, 0.04265549f, 0.16286145f, 0.18266724f, 0.01564880f, 
    -0.01997842f, 0.03626389f, -0.02800391f, -0.05114828f, 0.34798053f, -0.06269546f, -0.02351360f, -0.04604150f, 
    -0.01562058f, -0.05917918f, -0.02505402f, -0.03468911f, 0.15635033f, 0.08313083f, 0.05524350f, -0.09509758f, 
    0.08891940f, -0.12046577f, -0.03393331f, 0.06744100f, 0.01677498f, -0.11800767f, 0.15629649f, 0.03426331f, 
    -0.02994292f, 0.01873703f, 0.02662970f, 0.03065653f, 0.04015721f, 0.00589839f, -0.02772390f, 0.01779622f, 
    -0.01838763f, 0.01426204f, 0.02517477f, -0.03074584f, 0.04430550f, 0.01243156f, -0.05922893f, 0.00066526f, 
    0.03383111f, -0.00847881f, -0.02215138f, -0.04944389f, -0.00510062f, 0.05523392f, 0.01086873f, -0.04778484f, 
    0.02801503f, 0.02271873f, -0.05622821f, -0.02885375f, 0.03272534f, -0.05168951f, -0.05804565f, -0.05613083f, 
    0.02427571f, 0.02322384f, 0.00907145f, -0.03430945f, -0.04981498f, 0.03462098f, -0.04312281f, 0.04612872f, 
    -0.05946687f, 0.02825788f, -0.04314213f, -0.02591193f, -0.05277747f, -0.01414435f, 0.02882730f, -0.03714561f, 
    -0.02074033f, -0.01893999f, 0.00846084f, 0.01408803f, -0.00837694f, -0.04466477f, 0.04370162f, -0.03393539f, 
    -0.05809719f, -0.05275340f, 0.01328437f, 0.03010038f, -0.04600663f, -0.00116022f, -0.02618700f, -0.01067339f, 
    -0.03134668f, 0.00701314f, 0.03944292f, -0.04772125f, 0.04244761f, -0.04049040f, -0.01675003f, -0.01316189f, 
    0.01502227f, 0.02940042f, -0.01240558f, -0.02502220f, 0.01358028f, 0.02457853f, -0.00789214f, -0.02042123f, 
    0.02398151f, -0.05557266f, 0.00209373f, -0.00190194f, 0.02362128f, 0.03140699f, -0.02594210f, -0.02910583f, 
    0.02774918f, 0.01263881f, -0.03171100f, 0.01954819f, 0.04108324f, -0.03869573f, -0.02094539f, -0.01521248f, 
    0.00196856f, 0.04558534f, -0.05566385f, -0.02806813f, -0.03426808f, -0.01955922f, -0.04151871f, 0.01599784f, 
    -0.00503565f, 0.04479054f, -0.05219006f, 0.04122552f, 0.03400343f, 0.03303788f, -0.03088759f, 0.01369797f, 
    0.04160376f, 0.01007042f, -0.02859699f, -0.00273144f, 0.04242615f, -0.02389156f, -0.00419141f, -0.00096042f, 
    -0.03289995f, -0.05023827f, 0.01848918f, 0.00307748f, 0.01564984f, -0.04430037f, -0.02188022f, -0.06052693f, 
    -0.05815497f, 0.04275927f, -0.00035735f, 0.02540069f, -0.02280789f, -0.04503216f, 0.01357122f, -0.05381203f, 
    -0.02366860f, 0.01203987f, -0.04664834f, -0.04121803f, -0.02981240f, 0.02616289f, -0.06390513f, -0.00502651f, 
    0.03798981f, 0.03004449f, -0.00015105f, -0.04692308f, -0.04003165f, 0.00292861f, 0.02435046f, -0.05959726f, 
    0.04563027f, 0.01227015f, -0.01612602f, -0.00099546f, -0.02717529f, 0.02344129f, -0.00593857f, 0.02803867f, 
    -0.03567361f, -0.06266949f, 0.00985219f, -0.06166895f, 0.01484388f, 0.00481654f, 0.04047891f, 0.01170316f, 
    0.03845425f, 0.00736379f, -0.01267887f, 0.04390089f, -0.05565068f, 0.00154595f, -0.05413857f, -0.01259393f, 
    -0.03943938f, 0.01976660f, 0.01786650f, 0.04337635f, -0.02294748f, 0.02744082f, 0.03909189f, -0.03812968f, 
    -0.04037311f, 0.02857352f, -0.05591939f, -0.04220788f, 0.05099677f, 0.03776859f, -0.06340448f, 0.02039069f, 
    -0.05824323f, 0.03143672f, 0.04181963f, -0.00583693f, -0.04072389f, -0.03616560f, 0.04541274f, -0.05934055f, 
    -0.04667418f, -0.03807802f, 0.00273495f, -0.02556666f, 0.00767179f, 0.02934721f, -0.03948340f, 0.00523473f, 
    0.03050571f, -0.00867555f, -0.04385905f, -0.00558206f, -0.04066512f, 0.00128343f, 0.03534451f, -0.02662457f, 
    -0.05528545f, -0.02018339f, 0.00621889f, -0.04133151f, -0.05992236f, -0.00684508f, 0.01493425f, 0.04610734f, 
    0.03301194f, -0.06498285f, 0.03440103f, -0.01296458f, -0.05419613f, -0.02477544f, -0.00675375f, 0.02897122f, 
    -0.00868173f, -0.05810266f, 0.02210489f, 0.00360805f, 0.02839364f, -0.03201331f, -0.02568661f, 0.04605718f, 
    0.00509832f, -0.03288690f, -0.05360929f, 0.02395847f, -0.02365176f, 0.02667077f, -0.02895240f, -0.04581191f, 
    -0.02353372f, 0.03083361f, -0.04006374f, -0.05476050f, 0.00300014f, 0.00235552f, -0.01614785f, 0.00288852f, 
    0.02074130f, -0.05496574f, 0.03646371f, 0.02141668f, -0.04740060f, 0.03238197f, -0.03644656f, -0.01051118f, 
    -0.05098120f, 0.01819615f, 0.01532803f, -0.05466101f, -0.05061556f, -0.03427721f, -0.00140122f, -0.05802907f, 
    0.02162967f, -0.00666504f, 0.00446059f, -0.04489362f, -0.03398195f, -0.05011337f, 0.01506819f, 0.00408326f, 
    -0.00635646f, 0.03292052f, -0.01022668f, -0.02912800f, -0.01494140f, -0.05462677f, 0.01163667f, 0.00516947f, 
    0.04433481f, -0.02542874f, -0.05086386f, -0.01572253f, 0.02804783f, 0.00656825f, 0.00795401f, -0.00901619f, 
    0.01845651f, -0.01159024f, -0.04945839f, -0.06458642f, 0.00675599f, -0.00610081f, 0.01027895f, -0.05054260f, 
    -0.05873760f, 0.01534488f, -0.03894199f, -0.04126516f, 0.00409831f, 0.00438777f, -0.04973988f, -0.02550255f, 
    -0.00730352f, -0.03822737f, 0.01551438f, -0.00120999f, -0.04875362f, 0.03622200f, -0.04575069f, 0.01615798f, 
    -0.02262180f, -0.01179937f, -0.01496768f, 0.03256875f, 0.03421680f, 0.02991895f, -0.01750239f, 0.00167980f, 
    -0.02128687f, -0.00181466f, 0.04291680f, -0.01823578f, -0.03571009f, 0.00729028f, 0.02869893f, -0.01900617f, 
    -0.01898447f, 0.03820118f, 0.03750459f, -0.04741165f, -0.02953889f, -0.02533726f, -0.04397681f, 0.05699865f, 
    0.01826579f, 0.02845652f, 0.03062464f, 0.03271148f, 0.02287435f, 0.01065516f, -0.03674690f, -0.03026824f, 
    -0.00618291f, -0.01872913f, 0.01547540f, 0.01971249f, -0.05370570f, -0.01054643f, -0.01791341f, -0.00745087f, 
    -0.02413816f, -0.01453992f, 0.04516105f, -0.01820441f, -0.06154002f, 0.03253844f, -0.00989446f, -0.04264030f, 
    -0.05506570f, 0.00014586f, 0.03038418f, -0.01575533f, -0.02914381f, 0.00500090f, 0.01157574f, 0.02135764f, 
    0.04064652f, 0.03650462f, -0.01839208f, -0.01269557f, 0.04120184f, -0.03853188f, -0.02515194f, -0.05780173f, 
    -0.06823088f, -0.01185979f, 0.00540979f, 0.02521427f, 0.02085588f, -0.00114176f, 0.04654877f, -0.03571702f, 
    0.01301800f, 0.03717869f, 0.02719002f, -0.05587172f, -0.04059601f, 0.01843559f, 0.00573275f, -0.01128262f, 
    0.03879767f, -0.05245204f, -0.00684659f, 0.00074220f, -0.00616157f, -0.05804073f, 0.00557253f, 0.02804600f, 
    0.03858932f, -0.00159490f, -0.06243350f, -0.05920420f, 0.03441764f, -0.00174077f, 0.03655480f, -0.05117115f, 
    0.04202615f, -0.03924949f, 0.01643466f, -0.04315303f, 0.04013458f, 0.00277180f, -0.05699673f, 0.00442415f, 
    -0.04176284f, -0.03088435f, 0.00531682f, -0.00373485f, 0.02481570f, 0.01602258f, -0.02634738f, -0.05380867f, 
    -0.03691692f, -0.03974265f, -0.04700655f, -0.02356877f, 0.00675785f, 0.00615788f, -0.03122308f, 0.02924901f, 
    0.03104292f, -0.04263875f, -0.04876229f, 0.03345944f, 0.00234060f, -0.02657893f, 0.03083491f, 0.00133525f, 
    0.00789165f, -0.05868753f, -0.02072006f, -0.05407625f, 0.02779453f, 0.00586314f, 0.03837490f, 0.01838120f, 
    -0.05572657f, -0.04201297f, -0.03930049f, 0.04206550f, 0.03211311f, 0.02497598f, 0.03840710f, -0.01072493f, 
    0.02193333f, -0.00970161f, 0.00808383f, -0.05234758f, -0.05685795f, -0.04475078f, 0.02867644f, 0.03793249f, 
    -0.05988067f, -0.02168921f, 0.01291877f, -0.05680474f, -0.05763512f, 0.03053480f, 0.00181642f, -0.05553649f, 
    -0.06079526f, -0.00076056f, -0.04882909f, -0.02198602f, -0.05884431f, -0.04740151f, 0.03081024f, -0.02299837f, 
    -0.02159459f, -0.05472102f, -0.02223361f, -0.04358707f, 0.02478951f, -0.03677181f, -0.05345145f, -0.03126746f, 
    -0.02809607f, -0.06393324f, -0.01706833f, 0.03739046f, -0.03633279f, -0.01109457f, 0.04609190f, 0.00625048f, 
    0.00633668f, -0.00242500f, -0.02226251f, -0.00668253f, 0.02020500f, -0.01421228f, -0.01605630f, 0.02388013f, 
    0.01921561f, 0.01062531f, -0.05607302f, 0.02790880f, -0.04392150f, 0.02632967f, 0.04757011f, -0.04249225f, 
    0.02089664f, 0.04188048f, 0.03445170f, 0.03909391f, 0.03121380f, -0.02993838f, 0.01187105f, 0.00516847f, 
    -0.00946901f, -0.00680407f, 0.04537185f, -0.04969164f, 0.04106390f, -0.02098627f, 0.02412016f, 0.02219065f, 
    0.02697810f, -0.03677883f, -0.05312897f, -0.00846061f, -0.01052676f, 0.00898624f, -0.03678213f, -0.02205192f, 
    -0.03151480f, -0.01865584f, -0.04692433f, 0.02376604f, 0.01008999f, -0.03613798f, 0.03997554f, -0.02314794f, 
    -0.00420635f, 0.03434237f, 0.03766007f, 0.00039250f, -0.02386493f, -0.05213530f, -0.01846849f, 0.01712783f, 
    0.02500619f, 0.00420905f, -0.01452733f, 0.02499205f, -0.03027576f, 0.01964522f, -0.05637053f, 0.01829581f, 
    -0.03946909f, 0.03295046f, -0.03371031f, 0.03557278f, 0.04054875f, -0.00562056f, 0.04441854f, 0.00253281f, 
    -0.05142993f, 0.00248498f, 0.00477101f, 0.04480851f, -0.04812831f, 0.04129183f, -0.00775179f, -0.03093394f, 
    -0.00869949f, -0.04144843f, -0.05024683f, 0.04437191f, 0.03515188f, 0.01968777f, -0.02443495f, -0.00304184f, 
    -0.01686670f, -0.03863898f, -0.01071702f, -0.05188063f, -0.02258614f, -0.04289209f, -0.02477125f, -0.03235405f, 
    0.03015459f, -0.05301234f, -0.03519626f, 0.02788433f, 0.01166734f, -0.06486080f, -0.06079728f, 0.01211974f, 
    -0.05338778f, 0.01124641f, 0.03408148f, -0.06121546f, -0.02058821f, 0.02573880f, -0.01567825f, -0.00268597f, 
    0.02305964f, -0.01403213f, -0.02566276f, -0.04556991f, -0.03200888f, -0.01947902f, 0.03479694f, -0.06073422f, 
    0.00345078f, 0.03311940f, -0.02124389f, 0.03946495f, 0.05003977f, -0.04940867f, -0.01113621f, 0.00154526f, 
    0.00993048f, -0.03704210f, -0.03709606f, -0.03504971f, -0.00867792f, -0.01448581f, -0.02922046f, -0.03286222f, 
    -0.04723210f, -0.28548571f, -0.39461976f, -0.13033922f, 0.13346638f, 0.09680610f, 0.24809793f, 0.09989146f, 
    0.03437994f, 0.01973574f, -0.07340017f, 0.01755889f, 0.09448984f, -0.04986805f, 0.01315476f, 0.04550487f, 
    0.07511408f, 0.00666503f, 0.19382556f, 0.03457668f, -0.05141247f, 0.26477012f, -0.16789213f, 0.13609271f, 
    0.32789415f, 0.09856350f, 0.00754884f, -0.23907942f, 0.05459907f, 0.07277096f, 0.30579391f, 0.15843078f, 
    0.02936114f, -0.03313974f, 0.08117224f, 0.05168188f, 0.02704716f, -0.00607543f, -0.07910136f, 0.20787887f, 
    0.07724378f, -0.16487676f, -0.16450594f, 0.00594416f, 0.03564042f, -0.12934501f, -0.16797446f, -0.22634839f, 
    0.01134746f, -0.21505001f, 0.04310150f, 0.00874695f, -0.02124388f, -0.01307319f, 0.04949245f, 0.04553877f, 
    0.04582801f, 0.09430967f, 0.13459527f, -0.10970584f, -0.08978320f, -0.33859214f, 0.08846961f, -0.10542186f, 
    -0.14220588f, 0.06083302f, 0.14613013f, -0.04343990f, 0.15752307f, -0.31198969f, -0.02179408f, -0.08767170f, 
    0.09343294f, 0.00585889f, 0.15603676f, 0.03009944f, -0.19074710f, 0.16973312f, 0.06345092f, -0.06822976f, 
    -0.11897618f, -0.19218628f, -0.22398254f, -0.09657154f, 0.24064519f, -0.03433744f, -0.10662689f, 0.11495196f, 
    0.05575754f, 0.15415302f, 0.00973285f, 0.01725340f, -0.13058408f, 0.00462853f, -0.09916489f, -0.06476951f, 
    -0.17281640f, 0.07627256f, 0.21315761f, -0.08242781f, 0.37286219f, 0.32669562f, -0.23715360f, 0.14412424f, 
    0.04803390f, -0.01195189f, 0.07782272f, -0.18711786f, 0.08288257f, 0.19780913f, 0.01531073f, 0.03110170f, 
    -0.02463715f, 0.04872148f, -0.11121685f, 0.03939111f, 0.03637682f, -0.09721431f, 0.12559982f, 0.00571331f, 
    -0.06840736f, -0.04527159f, 0.03751794f, -0.09952405f, -0.15020497f, -0.13607207f, -0.04453307f, -0.10896080f, 
    -0.10717744f, -0.09307979f, -0.00916892f, 0.15722626f, 0.07008277f, 0.12699959f, 0.19088905f, 0.04300907f, 
    0.04021206f, 0.02535097f, 0.01335987f, -0.05266039f, 0.40465015f, 0.13179965f, -0.11710048f, 0.01193156f, 
    0.10024034f, -0.05960845f, 0.19421414f, -0.08467235f, 0.08569269f, 0.01087402f, 0.11637501f, 0.15774429f, 
    0.05962485f, 0.11174525f, 0.09913060f, 0.12160475f, 0.00489021f, 0.03398832f, 0.23163661f, -0.07383527f, 
    0.06138602f, 0.10045522f, 0.23622566f, -0.04642221f, 0.16908526f, -0.06531221f, -0.00377582f, 0.07982448f, 
    0.07293370f, -0.02239403f, 0.09590246f, 0.19426095f, 0.16418330f, 0.01395595f, 0.15946971f, -0.02813823f, 
    -0.00604852f, 0.02362609f, 0.02801822f, 0.04159004f, 0.12855023f, -0.08891335f, -0.09998688f, -0.09689520f, 
    -0.07212245f, -0.10010864f, -0.05382434f, -0.02044513f, 0.06007495f, -0.00684752f, -0.00445797f, 0.07175043f, 
    -0.05763050f, 0.04284445f, 0.07059738f, -0.09051692f, 0.11981037f, 0.00482513f, 0.08329174f, 0.07843000f, 
    -0.22695994f, 0.15401082f, 0.17260526f, -0.08949118f, 0.05894081f, -0.08112762f, -0.08222424f, 0.09338882f, 
    0.01712966f, 0.14502530f, -0.04459437f, 0.17285728f, 0.04084568f, 0.03830885f, 0.02185925f, -0.04178156f, 
    0.02278025f, -0.02973915f, 0.02154076f, -0.02532405f, -0.28921148f, 0.12987228f, -0.00219109f, 0.03748427f, 
    0.04310483f, -0.14916709f, 0.02970646f, 0.06020954f, 0.02120121f, 0.22295864f, 0.06533254f, 0.11395784f, 
    -0.00385615f, 0.06492567f, -0.00835272f, 0.03284929f, -0.00165409f, 0.00076040f, 0.04383269f, -0.03586207f, 
    0.03728356f, 0.07743721f, 0.09976527f, 0.09381502f, -0.03547718f, -0.04861161f, -0.10352047f, -0.09679221f, 
    0.00332169f, 0.00425542f, -0.00983307f, 0.00807404f, 0.03217597f, -0.05242211f, -0.05861062f, -0.02116174f, 
    0.02137819f, 0.14782596f, 0.10530052f, 0.11212638f, -0.19393861f, -0.62852710f, -0.25691172f, -0.09377538f, 
    -0.11642937f, 0.11102163f, 0.06838518f, -0.06087638f, -0.07467581f, -0.27676970f, -0.00024941f, 0.05632989f, 
    0.01843560f, -0.03329236f, 0.06924766f, -0.03773797f, 0.10628689f, 0.25467506f, 0.00435419f, 0.01748284f, 
    -0.23314987f, 0.11357121f, 0.19674571f, 0.08000201f, 0.13516366f, -0.08854470f, 0.04134030f, 0.06047975f, 
    -0.04172947f, -0.01235521f, 0.15612358f, 0.05779664f, 0.19384630f, 0.18349540f, -0.00186038f, -0.00098727f, 
    0.00206908f, 0.00859080f, 0.13306966f, -0.02781985f, -0.27120346f, -0.05542933f, -0.15379110f, 0.03490963f, 
    -0.06743070f, -0.14664745f, -0.19083917f, -0.23903981f, -0.09514244f, -0.15349834f, 0.00563625f, 0.03916293f, 
    -0.08719853f, 0.04214296f, 0.05550531f, -0.01333619f, 0.11702261f, 0.09944936f, -0.06197874f, -0.05094842f, 
    -0.03036783f, -0.03724711f, -0.02512893f, -0.03169790f, -0.06457681f, -0.06182154f, -0.01865659f, 0.03961826f, 
    -0.00837124f, -0.05305364f, 0.01798079f, 0.01154113f, -0.00982042f, -0.02194665f, -0.00021631f, -0.05815409f, 
    0.02085344f, -0.00154575f, -0.01404234f, -0.06035450f, 0.00315140f, 0.03641656f, -0.00001633f, 0.00106823f, 
    0.03671728f, -0.04189863f, -0.04533590f, -0.00744013f, 0.00751621f, 0.01724597f, 0.03841799f, 0.03256170f, 
    -0.04662191f, -0.00410516f, -0.05719457f, -0.06323684f, -0.01951192f, -0.01659902f, -0.00965192f, -0.02939601f, 
    -0.04091017f, 0.00478091f, -0.06170228f, -0.04631648f, 0.02617251f, -0.04971058f, 0.03773278f, -0.04068655f, 
    -0.05276152f, 0.04495538f, 0.02046126f, -0.04821935f, -0.03347594f, 0.02352642f, 0.01788299f, -0.02518838f, 
    -0.05199306f, -0.05887582f, 0.03484162f, -0.02611476f, -0.05078831f, -0.00644416f, 0.01008770f, -0.01222046f, 
    0.00606859f, -0.03603171f, 0.00045012f, 0.02152284f, -0.01107342f, -0.03763084f, -0.03400964f, 0.02453282f, 
    0.03953489f, -0.01751007f, -0.02993407f, -0.05738490f, -0.00276773f, -0.02988942f, -0.01969744f, 0.04064057f, 
    -0.03089076f, -0.03112138f, 0.00146654f, 0.02110746f, -0.00652100f, 0.02731565f, 0.01952182f, 0.03132467f, 
    0.03071109f, -0.00611208f, -0.02858598f, -0.03823912f, 0.01524463f, 0.03490583f, 0.04656519f, -0.05940023f, 
    -0.04418001f, 0.00591786f, -0.02537014f, -0.03322167f, 0.02399951f, 0.02553024f, 0.00720028f, -0.05542838f, 
    0.00790922f, 0.00839815f, 0.04041612f, 0.04814748f, -0.00045787f, 0.03503620f, -0.02062163f, -0.06412832f, 
    -0.06197849f, 0.01236704f, 0.01443518f, -0.01023863f, 0.03470008f, 0.01170443f, -0.04626873f, 0.04608206f, 
    0.03374896f, -0.05428869f, -0.01879348f, -0.03016246f, -0.03024482f, 0.00693933f, -0.01404457f, -0.03827802f, 
    0.00481317f, -0.02123365f, 0.03503234f, -0.03231546f, 0.04359566f, -0.01091285f, 0.00230629f, -0.04445170f, 
    0.01417005f, 0.01350390f, -0.02406584f, 0.01995581f, -0.02443141f, -0.04834806f, 0.02568570f, 0.01049926f, 
    -0.05431350f, 0.03787053f, -0.01197342f, -0.03981012f, -0.04156930f, 0.02949035f, -0.06136546f, -0.06400832f, 
    0.02706650f, 0.02998623f, -0.04267706f, -0.00454353f, 0.00913829f, 0.03571462f, -0.03995772f, -0.02334923f, 
    -0.04983182f, -0.02835640f, -0.00490188f, 0.00333606f, -0.00037101f, -0.06295594f, 0.03318464f, -0.04043477f, 
    0.00761575f, 0.00315370f, -0.05788939f, -0.06108172f, 0.04264168f, 0.03785988f, -0.06241954f, -0.04297732f, 
    -0.04717411f, 0.04404197f, -0.03071830f, -0.00422231f, 0.02836945f, 0.05564617f, -0.02695089f, 0.01807704f, 
    -0.00744437f, 0.03226056f, -0.01334826f, 0.03132536f, 0.02122507f, -0.03816999f, 0.00529193f, 0.01846006f, 
    0.01005643f, 0.01815340f, -0.05629502f, 0.02889854f, 0.01038605f, 0.04518177f, -0.05489163f, -0.00227078f, 
    -0.04677444f, -0.03071718f, -0.03498863f, 0.01754155f, -0.03668748f, -0.01006719f, -0.05857627f, -0.00121528f, 
    0.03073393f, -0.05136148f, -0.01490128f, 0.03924818f, -0.01349624f, -0.02851183f, 0.00703741f, -0.02405825f, 
    -0.02539807f, 0.01177905f, 0.03561818f, -0.03843432f, -0.00347382f, -0.02317160f, -0.03289974f, 0.03107231f, 
    0.02389674f, 0.02747244f, -0.05536485f, -0.04224126f, -0.01013668f, 0.01833386f, 0.03772827f, -0.03909467f, 
    0.01377331f, 0.01354089f, 0.00409541f, 0.04075966f, -0.06055406f, 0.00422671f, -0.04427636f, 0.00682021f, 
    -0.05076635f, -0.04335113f, 0.04260890f, -0.03839904f, -0.04214171f, 0.03382616f, -0.02796050f, 0.03548786f, 
    -0.05228088f, -0.02997687f, 0.00686556f, -0.04428995f, -0.05578084f, -0.00497226f, -0.00201522f, -0.03715932f, 
    -0.04056924f, -0.05863515f, -0.06200423f, -0.06033687f, 0.00776519f, -0.03862995f, -0.05614075f, 0.01615931f, 
    -0.05142073f, -0.06078598f, -0.03546582f, 0.00583961f, -0.04034316f, 0.00525033f, 0.02130605f, -0.01771417f, 
    -0.01876601f, -0.04306003f, 0.00648030f, -0.00562996f, 0.02673524f, 0.03008889f, -0.02528146f, 0.01421905f, 
    -0.00161829f, -0.01046126f, 0.02535989f, -0.03691727f, -0.00341300f, -0.02874888f, -0.03948866f, -0.06107659f, 
    0.00240601f, 0.01218573f, 0.04580081f, 0.02984084f, 0.02302429f, -0.04226321f, -0.01043805f, 0.00145961f, 
    -0.01045513f, -0.02553885f, -0.01251299f, -0.01529279f, -0.02537458f, 0.05280903f, -0.04865608f, -0.01274706f, 
    0.03969804f, 0.03142016f, -0.02366772f, -0.02623784f, -0.00244713f, 0.03361904f, -0.03804183f, 0.02767364f, 
    -0.05749682f, 0.03779517f, 0.01435811f, -0.00862991f, 0.03903019f, 0.00816519f, -0.00797588f, 0.05174644f, 
    -0.09147523f, -0.02132997f, 0.20167045f, -0.02218618f, 0.16777547f, -0.07564461f, -0.06522169f, 0.01819786f, 
    -0.32257798f, -0.03868344f, 0.02665050f, 0.02958157f, 0.02299839f, 0.00084195f, -0.03058852f, 0.05944165f, 
    0.01904060f, -0.08193351f, 0.18998854f, 0.07113251f, 0.42894354f, -0.12363081f, -0.15736598f, 0.25472304f, 
    -0.23516974f, -0.14428009f, 0.14635785f, 0.21815865f, 0.26773497f, -0.03370955f, 0.13780209f, -0.04286474f, 
    0.07040484f, 0.03052636f, 0.05299880f, -0.04537562f, -0.01958503f, 0.00428289f, 0.20568684f, -0.05122716f, 
    -0.21619189f, -0.02526561f, 0.20541322f, 0.12615697f, -0.04449092f, -0.11723134f, 0.07044724f, 0.02474648f, 
    0.08024752f, -0.01669835f, 0.13180597f, 0.18115385f, 0.08026672f, -0.03802206f, 0.10512327f, 0.05150605f, 
    -0.07137465f, 0.03315194f, -0.24014336f, -0.11560177f, -0.19892703f, 0.45619783f, -0.17330818f, 0.12212758f, 
    -0.26020691f, 0.06744387f, -0.00141204f, -0.09678154f, 0.22104798f, -0.04253718f, -0.01339407f, 0.08590316f, 
    0.17951787f, 0.06140717f, 0.13961643f, 0.07785140f, 0.10555976f, 0.14337383f, -0.02829825f, 0.12117536f, 
    0.11127098f, 0.03529079f, 0.11924028f, -0.20830081f, -0.01580348f, -0.07768507f, 0.01013082f, 0.08660695f, 
    -0.17728628f, 0.00948409f, -0.02356481f, 0.02003769f, 0.10338318f, 0.06623198f, -0.00219901f, 0.07313816f, 
    -0.07582679f, -0.13983430f, 0.05920425f, 0.05424886f, 0.12136763f, 0.06077994f, 0.34778899f, -0.18357904f, 
    0.32161045f, -0.16567478f, 0.12020761f, 0.25323781f, 0.40622160f, 0.09110674f, -0.13299575f, -0.09969508f, 
    -0.07231933f, 0.07374258f, 0.00442454f, 0.01941008f, 0.06099001f, -0.09395971f, 0.06427700f, -0.01779281f, 
    0.17220895f, 0.07604402f, 0.05464166f, -0.01102669f, 0.05224925f, -0.00241052f, 0.02650973f, -0.09512402f, 
    -0.05092983f, 0.05468688f, -0.01320360f, 0.09939788f, -0.01582642f, -0.01610669f, 0.10730360f, -0.07091296f, 
    -0.08450549f, 0.01140338f, -0.02522882f, -0.02806501f, -0.31515324f, -0.37791762f, 0.26464936f, -0.13037471f, 
    0.26424244f, 0.02800590f, -0.00200830f, 0.01469415f, 0.21930641f, 0.17245634f, 0.08736213f, 0.15902260f, 
    0.12875785f, -0.01124635f, 0.10810402f, 0.02470595f, -0.01639748f, -0.00948840f, -0.07260805f, 0.00288532f, 
    -0.40746492f, -0.12473180f, 0.04479972f, -0.08435703f, -0.11040389f, -0.09123372f, -0.21628144f, 0.05979810f, 
    0.09055782f, 0.14326710f, 0.08033566f, 0.08295386f, -0.08887556f, 0.13738091f, -0.00947971f, -0.00542729f, 
    0.05350181f, 0.13128345f, -0.02683441f, 0.03051797f, -0.14043735f, -0.11787253f, 0.12780455f, -0.06986224f, 
    -0.00713121f, -0.06104505f, 0.03688692f, -0.08891337f, 0.15886058f, 0.03122156f, 0.07340734f, 0.10409825f, 
    -0.02182985f, -0.08334658f, 0.03992349f, -0.09571706f, -0.06430370f, -0.18231049f, -0.12221028f, -0.02440163f, 
    -0.11468238f, 0.11869854f, -0.03284538f, -0.05699099f, -0.21987872f, -0.17049831f, -0.13675615f, -0.06953242f, 
    -0.24172778f, 0.30356511f, -0.02920337f, 0.01444289f, -0.05921201f, -0.01728091f, 0.00925825f, -0.03215379f, 
    0.08681331f, 0.01423397f, -0.03361961f, -0.03063738f, -0.23652412f, 0.18840241f, 0.14890444f, -0.07412480f, 
    -0.22188719f, -0.13870065f, 0.00531598f, -0.06856499f, -0.17052482f, 0.11663046f, 0.03228445f, 0.10453486f, 
    0.08051194f, -0.05808960f, -0.01969684f, -0.04285957f, -0.00035480f, 0.03831170f, -0.05689459f, -0.02963026f, 
    0.44289166f, 0.11747655f, -0.04284137f, 0.08200328f, -0.02391832f, -0.04557331f, 0.05871152f, 0.12812385f, 
    0.03827041f, -0.00293540f, -0.09790337f, -0.02087636f, 0.10023935f, -0.15811700f, 0.08922348f, 0.05802976f, 
    -0.03011470f, 0.03037629f, -0.14938024f, -0.00119854f, 0.19432725f, 0.10909714f, -0.29154176f, 0.16972016f, 
    -0.02647504f, -0.01515303f, -0.01056720f, 0.11169527f, 0.16152181f, -0.12955879f, -0.03703170f, 0.01497491f, 
    0.00157399f, -0.01038000f, 0.10594902f, -0.03354951f, -0.01798672f, 0.11994195f, 0.22328506f, 0.19982801f, 
    -0.07149856f, -0.06252588f, -0.17533322f, 0.15234698f, 0.05145044f, 0.03445118f, 0.02476135f, -0.16366944f, 
    0.10484117f, 0.04179373f, 0.05308527f, 0.00064976f, 0.08596495f, -0.08152696f, -0.01990652f, -0.04450025f, 
    0.14649637f, 0.01406534f, -0.12413070f, 0.06539818f, -0.09802509f, 0.18904409f, -0.09202322f, 0.17860344f, 
    -0.19671351f, -0.04747949f, -0.10381204f, -0.05827815f, -0.06102146f, -0.07943217f, 0.09193660f, -0.05611850f, 
    -0.08267610f, 0.02775877f, 0.11487339f, 0.05977112f, -0.08735136f, -0.07884499f, -0.23964234f, -0.17148517f, 
    0.03006771f, 0.03030045f, 0.02773615f, -0.00120972f, -0.05733316f, -0.00278704f, 0.02621908f, 0.02675831f, 
    -0.04350932f, 0.03224652f, -0.06291354f, -0.05478271f, 0.03554836f, -0.02098112f, -0.02453392f, 0.00316683f, 
    0.04224711f, 0.00639132f, -0.03459305f, -0.01722531f, 0.00820776f, 0.03898517f, -0.02173261f, 0.02298802f, 
    0.01519742f, 0.00312750f, -0.00341106f, -0.01019682f, 0.05765673f, 0.03553282f, 0.02355281f, -0.04548413f, 
    -0.01720611f, 0.02097913f, -0.02574755f, -0.05100704f, 0.02109528f, -0.03924626f, 0.04076801f, 0.01230067f, 
    0.01697536f, -0.04924283f, -0.03768662f, -0.00656427f, 0.00941093f, 0.02033238f, 0.00483797f, 0.00780407f, 
    0.04693005f, -0.04017043f, -0.05339379f, 0.03381305f, -0.03698507f, -0.04057162f, -0.01351429f, 0.01781853f, 
    -0.03644096f, 0.01577028f, -0.02591470f, -0.03959527f, -0.05262934f, -0.05906706f, 0.02388001f, 0.03783941f, 
    0.04047167f, 0.05605615f, -0.03202012f, -0.02871269f, -0.01406060f, 0.03029665f, 0.02726805f, 0.03904563f, 
    0.04123215f, -0.03639031f, 0.02147196f, 0.02619415f, -0.04030472f, -0.05354039f, -0.05243435f, -0.02654700f, 
    0.04082556f, -0.03962548f, -0.01299493f, 0.02304182f, 0.02899387f, -0.03259742f, 0.03102089f, -0.06170124f, 
    -0.00826385f, 0.03905818f, -0.02610482f, 0.02728786f, -0.05903070f, -0.06075016f, -0.04115351f, 0.01164990f, 
    0.03395808f, 0.02218631f, 0.03597945f, 0.02052963f, 0.00709549f, 0.00883861f, 0.00467888f, -0.05903324f, 
    -0.04398417f, -0.02737048f, 0.04587048f, -0.01181496f, -0.01295056f, 0.02329257f, 0.03901016f, -0.01433252f, 
    -0.04083224f, -0.04966882f, -0.03238646f, -0.00522083f, -0.01955857f, 0.01323675f, -0.00562117f, -0.04875182f, 
    -0.03996561f, 0.01735750f, 0.02591529f, -0.00452304f, -0.04611340f, 0.05258222f, -0.01480658f, -0.04663694f, 
    -0.00963921f, -0.02895709f, 0.01648532f, -0.01706786f, 0.03062239f, -0.01772901f, -0.00677090f, 0.01343127f, 
    0.00251010f, 0.02478511f, -0.04998990f, -0.00097442f, -0.01620062f, 0.04196243f, 0.04834379f, -0.04684751f, 
    0.04653140f, -0.03967620f, 0.01022719f, 0.04282906f, 0.01561331f, -0.02194996f, -0.01093649f, -0.05980154f, 
    0.03851337f, -0.02670630f, -0.03721108f, -0.05393905f, -0.04367296f, -0.01604405f, 0.02587856f, 0.03614455f, 
    -0.00816248f, -0.01330809f, 0.04445983f, 0.01313851f, 0.02442707f, -0.03889105f, -0.05337523f, -0.06083558f, 
    -0.05288452f, 0.04033159f, 0.02777893f, -0.04533750f, 0.04025054f, 0.03681225f, 0.02800810f, 0.04629193f, 
    0.03600463f, 0.04604911f, -0.05110330f, 0.02280263f, 0.01225896f, -0.01608257f, -0.02960727f, 0.00560116f, 
    -0.01225145f, -0.03709250f, 0.00020122f, -0.05525847f, -0.03852699f, 0.01654891f, 0.00315661f, -0.02687012f, 
    -0.04498235f, 0.03249603f, -0.05932927f, -0.00210108f, -0.06264028f, -0.03901480f, -0.04907549f, -0.01757202f, 
    -0.05809665f, 0.04016080f, -0.05742717f, 0.04350222f, 0.00813382f, 0.02381258f, -0.01104755f, 0.01190944f, 
    -0.01765665f, -0.00250204f, -0.05412854f, -0.04998637f, -0.05965196f, -0.05095572f, -0.05127433f, -0.05336503f, 
    0.01555447f, 0.04465913f, -0.01990309f, -0.06004414f, 0.04323076f, 0.00282823f, -0.00914065f, -0.05940071f, 
    -0.02807872f, 0.01567828f, 0.00723750f, -0.01059380f, -0.00090584f, 0.04293264f, -0.03128746f, -0.06153624f, 
    -0.04683865f, -0.02225586f, -0.00017256f, 0.01941605f, 0.03690112f, 0.02844737f, -0.01963792f, 0.01281929f, 
    -0.03059956f, 0.01834665f, -0.03629623f, 0.02743184f, -0.02836171f, -0.00103304f, -0.00676002f, 0.02407127f, 
    -0.02559572f, -0.04696313f, 0.04833137f, -0.00523736f, 0.01810307f, -0.04016566f, -0.04012513f, -0.00232069f, 
    -0.06001336f, 0.02905065f, 0.00688505f, -0.02456266f, -0.02832969f, -0.03453860f, 0.02409627f, 0.04388734f, 
    -0.02309091f, 0.03146126f, -0.03984039f, 0.01111367f, -0.00191969f, -0.06113068f, -0.02993498f, 0.00177601f, 
    0.01059037f, -0.01432541f, 0.04475719f, 0.04889566f, 0.03484850f, -0.03551989f, 0.03340727f, -0.04434297f, 
    0.03694287f, 0.00612247f, -0.03851494f, -0.06095378f, 0.03927941f, -0.01491651f, -0.06209509f, 0.02667130f, 
    0.04575005f, 0.02561180f, 0.01323557f, 0.04105775f, -0.03981488f, 0.00559587f, -0.01097226f, 0.04732747f, 
    -0.00064118f, 0.04382051f, -0.00046707f, -0.04018048f, 0.01100128f, -0.02158076f, -0.04612239f, 0.00214232f, 
    0.00822201f, -0.00926132f, -0.04586032f, -0.01833975f, 0.00839697f, -0.04808173f, 0.02663970f, -0.03333220f, 
    -0.02227278f, -0.02156819f, -0.01034278f, -0.03555926f, -0.06950529f, -0.04655356f, -0.03852455f, -0.05431919f, 
    0.13806477f, -0.29366866f, 0.09072805f, -0.32123420f, -0.32174224f, 0.16516358f, -0.02138874f, 0.16400711f, 
    0.02484565f, 0.14946795f, 0.06550625f, -0.01015169f, 0.05870261f, 0.11829800f, -0.01952445f, -0.03325580f, 
    -0.05874798f, 0.01044644f, 0.29836044f, -0.00472678f, -0.09542853f, -0.09459088f, -0.12637006f, 0.17304809f, 
    0.28653723f, 0.04202516f, 0.01291170f, 0.01399526f, 0.22614039f, -0.04687963f, -0.16750509f, 0.07771647f, 
    -0.02245892f, 0.05078040f, 0.11066443f, 0.05562292f, 0.07453252f, 0.19076534f, -0.01484334f, 0.10956402f, 
    -0.00407193f, 0.10919043f, 0.11873143f, -0.11558246f, -0.01715488f, -0.03829926f, -0.15726794f, 0.09267297f, 
    0.09349300f, -0.05478013f, -0.04434308f, 0.12701908f, 0.05782099f, -0.17431132f, 0.03683421f, -0.02063978f, 
    -0.03060478f, 0.15530895f, 0.14724319f, 0.00515711f, 0.10690588f, -0.38425589f, -0.23762603f, 0.06176867f, 
    0.35113680f, -0.15125069f, 0.20084353f, 0.17886576f, -0.04096609f, 0.04589283f, 0.11695962f, -0.01810073f, 
    0.04552368f, -0.02294917f, -0.05245053f, 0.13300608f, 0.05824635f, 0.15065087f, -0.04024658f, -0.25536829f, 
    0.00020689f, -0.04872227f, -0.58784610f, -0.35582945f, -0.14163269f, -0.01908235f, -0.09768175f, -0.07680067f, 
    0.06259790f, 0.06372493f, 0.02331330f, 0.02735762f, 0.06426600f, 0.01670202f, -0.00128984f, -0.00840275f, 
    0.07287757f, 0.11357658f, 0.06140574f, -0.12394900f, 0.19484080f, -0.13964047f, 0.06671821f, 0.05937568f, 
    -0.39270440f, 0.35935593f, -0.17633568f, -0.00626370f, 0.13507284f, -0.11877119f, 0.19767694f, 0.02137561f, 
    0.02262445f, -0.15224859f, 0.26281071f, 0.27720088f, 0.00939819f, -0.13714759f, -0.04841255f, 0.06798713f, 
    -0.30254221f, -0.10758013f, 0.01553374f, -0.07836302f, -0.08604702f, -0.08530549f, -0.03274156f, -0.04051767f, 
    -0.08850402f, -0.14795518f, 0.02751138f, 0.13232675f, 0.15752141f, 0.16383350f, -0.01187395f, 0.09926784f, 
    0.09357490f, 0.06159398f, -0.01955840f, -0.07597570f, 0.14272425f, 0.36973706f, -0.16134612f, 0.10759850f, 
    0.11515554f, -0.02249749f, 0.02068838f, 0.10481209f, -0.05701571f, -0.14067636f, -0.08548748f, 0.09188772f, 
    -0.00686070f, -0.02514922f, 0.12716787f, 0.05451818f, 0.07462190f, -0.00797598f, 0.07349138f, 0.01771637f, 
    0.06859970f, 0.44431898f, -0.02777398f, 0.15374787f, 0.00768892f, -0.05837594f, 0.07143348f, -0.04632446f, 
    -0.00609527f, 0.10695288f, 0.08229782f, 0.10730050f, 0.09470986f, -0.02763747f, -0.00990168f, -0.11628189f, 
    -0.06778833f, 0.01841506f, 0.09349528f, 0.04847027f, -0.09090693f, 0.06917515f, 0.02655089f, -0.00240510f, 
    -0.11887474f, -0.06385653f, -0.01225292f, -0.05979054f, 0.04011030f, 0.05631531f, 0.14968731f, 0.15261763f, 
    0.11084531f, -0.02894606f, 0.03643649f, 0.05469318f, 0.10223344f, 0.06967751f, -0.00567590f, 0.09499345f, 
    -0.19600189f, 0.14199696f, -0.02676907f, -0.12083568f, -0.15294686f, 0.00739315f, -0.05975112f, -0.27477801f, 
    -0.00755019f, 0.15747736f, 0.11284421f, 0.09504910f, 0.05254048f, 0.00640401f, -0.04852827f, -0.08170343f, 
    0.04341091f, -0.10620940f, 0.03264615f, 0.02927095f, 0.02283272f, -0.16269872f, -0.09214415f, -0.04808386f, 
    -0.17490233f, 0.21698397f, -0.13067453f, -0.18300855f, 0.04574839f, 0.01100047f, 0.06982519f, -0.08569256f, 
    0.10252924f, -0.00118114f, -0.06939942f, -0.05695223f, 0.00558304f, 0.00811947f, -0.01669916f, -0.05189304f, 
    -0.04127568f, 0.06129854f, 0.02820922f, 0.11455137f, -0.09883830f, 0.02698332f, 0.08493728f, -0.04057733f, 
    0.06433903f, -0.00828562f, -0.15523022f, 0.07437024f, -0.00885836f, -0.10087444f, 0.03126113f, 0.01514051f, 
    0.11813976f, 0.14465198f, -0.00372496f, 0.04003740f, 0.50067765f, -0.01299373f, -0.06882735f, 0.04138035f, 
    0.04571469f, 0.03505421f, 0.11631299f, 0.30783814f, 0.05393834f, -0.02627957f, -0.02179492f, 0.00322008f, 
    0.02160684f, 0.04114578f, 0.06860799f, 0.00454283f, 0.07670768f, 0.19000922f, 0.08190054f, 0.11168602f, 
    -0.34965083f, 0.08719269f, -0.03773597f, -0.08356688f, 0.04824636f, 0.01707504f, -0.05825342f, 0.05142705f, 
    -0.01155987f, -0.22506686f, 0.09586402f, 0.22562186f, 0.15736249f, 0.16903792f, 0.09915598f, 0.01966494f, 
    -0.03605859f, 0.04269799f, -0.00669029f, 0.05535261f, -0.15903373f, -0.08274542f, 0.16637430f, -0.10098896f, 
    0.00903052f, -0.15734360f, 0.06586997f, -0.08223916f, 0.01347116f, 0.15669779f, 0.06969176f, 0.12460399f, 
    0.00888343f, -0.03994887f, 0.01201862f, -0.03124471f, 0.01612880f, -0.03668229f, -0.09146199f, -0.05879564f, 
    -0.03103257f, -0.30799034f, -0.01635789f, 0.66363257f, -0.02521973f, -0.02747351f, -0.10669693f, 0.09743681f, 
    -0.01847564f, 0.13661489f, 0.05174751f, 0.05678915f, 0.03873334f, 0.04965420f, -0.01349581f, 0.04507777f, 
    0.01966388f, -0.07136796f, 0.09369707f, -0.02679754f, -0.08676106f, -0.22873305f, 0.40991426f, -0.19615400f, 
    0.26844728f, 0.07929455f, -0.10391450f, 0.05658395f, -0.05088440f, 0.13210189f, 0.06358436f, -0.08968727f, 
    0.05412450f, 0.15913674f, -0.12547676f, 0.03519659f, 0.02416276f, -0.06361347f, -0.04623224f, 0.03852158f, 
    0.01517714f, -0.03682476f, -0.01361692f, 0.19588795f, 0.05331971f, 0.13742788f, -0.09468894f, 0.11122201f, 
    -0.14611045f, 0.15063035f, 0.06260942f, 0.02198683f, 0.23189028f, -0.06024089f, 0.01537083f, 0.01998508f, 
    0.04755349f, 0.07612643f, -0.04222555f, -0.16384363f, 0.03112377f, -0.27173281f, 0.09038198f, 0.34376562f, 
    0.27726200f, -0.03509229f, 0.01197028f, 0.05057844f, 0.11014248f, 0.13334911f, 0.03451086f, -0.02323466f, 
    -0.02814698f, 0.03916188f, -0.03128534f, 0.09922744f, 0.16389889f, 0.00874737f, 0.07886027f, 0.03442183f, 
    -0.44015563f, -0.29328099f, -0.10734728f, 0.04711373f, 0.06023655f, -0.06872109f, 0.00830554f, -0.16380364f, 
    0.07311397f, -0.01156744f, 0.04343736f, -0.02800053f, -0.02519357f, 0.07307893f, 0.06817341f, 0.05250146f, 
    0.26725325f, 0.10630777f, 0.06605470f, 0.08951448f, 0.20599212f, -0.27989292f, -0.12734951f, 0.07035183f, 
    -0.07217233f, 0.22178587f, -0.07937246f, -0.09904952f, 0.11998566f, -0.11665574f, 0.08950161f, 0.00971812f, 
    0.17917092f, -0.04078178f, 0.14752035f, 0.13397819f, -0.10291262f, -0.05521072f, 0.07582661f, 0.03265768f, 
    0.11242865f, 0.22192851f, 0.01463178f, -0.00543613f, -0.19995971f, 0.03655418f, 0.07251305f, -0.05694176f, 
    0.01936821f, -0.01452962f, -0.01843398f, -0.02550707f, -0.03077319f, -0.06007566f, -0.08960921f, 0.08087307f, 
    0.06933716f, -0.03076238f, -0.00891706f, -0.02237703f, 0.37111664f, 0.26575902f, -0.20774546f, -0.01781709f, 
    -0.16606107f, 0.11861878f, 0.19592699f, 0.02429615f, -0.14148125f, -0.06781197f, 0.03163749f, -0.01350379f, 
    0.25880328f, 0.08303753f, 0.00178356f, 0.05462210f, -0.10044307f, 0.03331889f, -0.07476885f, -0.06219030f, 
    0.39805675f, 0.19600563f, -0.18197763f, -0.05959841f, -0.20423551f, -0.04236338f, -0.01192079f, -0.05486912f, 
    -0.13058802f, 0.01040117f, 0.04698644f, -0.06016594f, 0.06694995f, -0.00084480f, 0.07564622f, 0.07223519f, 
    -0.05711025f, -0.01714474f, 0.01584637f, 0.04754459f, 0.10017615f, 0.12996992f, -0.10157719f, -0.09262948f, 
    -0.06247722f, -0.03492114f, 0.08341000f, -0.09343114f, -0.03730775f, -0.15194418f, 0.10621211f, -0.02798835f, 
    0.16666849f, 0.00122407f, 0.08428846f, 0.13049681f, 0.01868391f, 0.03922594f, -0.00949997f, -0.00947639f, 
    0.24944559f, -0.15154441f, 0.05035531f, 0.10201578f, -0.06773063f, -0.08803430f, -0.05061017f, -0.12016749f, 
    0.00677114f, 0.07550893f, 0.07677693f, -0.00752759f, 0.03574061f, 0.02738692f, 0.06954535f, 0.03030502f, 
    0.00392725f, -0.05580287f, -0.00663511f, -0.04588009f, 0.26345763f, -0.30254632f, -0.03158924f, -0.07041112f, 
    -0.12335949f, -0.05253592f, -0.16236031f, -0.26538852f, 0.10868987f, 0.00827203f, 0.19990876f, 0.03497289f, 
    0.09369129f, 0.02271660f, -0.03207871f, -0.00831208f, -0.03823075f, -0.01055889f, 0.01913526f, -0.05406690f, 
    -0.00527325f, 0.06357573f, 0.11313443f, 0.04692591f, 0.02996334f, 0.03358794f, 0.04810590f, 0.03965532f, 
    0.02002379f, -0.02878089f, 0.09735931f, -0.04532032f, 0.07013131f, -0.12752943f, 0.04495094f, -0.00495398f, 
    0.08085065f, 0.08953869f, 0.07070631f, 0.01755123f, 0.11951616f, -0.01845020f, 0.34005865f, 0.29304311f, 
    0.30994037f, 0.19981828f, 0.08719830f, 0.09634611f, 0.03023803f, 0.17289780f, 0.06815917f, 0.05875220f, 
    0.04613825f, -0.03591870f, -0.03532521f, -0.01016953f, 0.01032584f, -0.08674278f, 0.10357795f, -0.14504470f, 
    -0.16130166f, 0.13666578f, 0.17838083f, -0.11942966f, -0.09129702f, 0.02363560f, 0.00279926f, -0.01488736f, 
    -0.05448636f, -0.14303954f, -0.14088127f, -0.08583810f, 0.14350185f, 0.18928088f, -0.04185894f, -0.04000842f, 
    0.00011986f, 0.10820238f, -0.07130490f, 0.05674271f, -0.11924303f, -0.19707683f, 0.26838818f, -0.02138173f, 
    -0.00678821f, -0.05045696f, 0.00883771f, -0.01103502f, 0.03969922f, 0.22081544f, 0.00695336f, 0.03455597f, 
    0.03089787f, 0.08632734f, 0.11378709f, 0.05094292f, 0.02315781f, -0.05059082f, -0.08754394f, -0.02175321f, 
    -0.17601974f, -0.02431085f, 0.13511273f, 0.31803712f, -0.07234868f, -0.09662526f, 0.00574282f, 0.08628687f, 
    -0.03820498f, 0.00803507f, 0.12984145f, -0.04286012f, 0.11288713f, -0.06000241f, 0.11254586f, 0.08743266f, 
    0.05025621f, -0.00850689f, 0.18046035f, -0.04742438f, 0.45028728f, -0.05671155f, -0.00224310f, -0.72809547f, 
    -0.43298939f, -0.00740215f, -0.04896905f, 0.01119138f, 0.11496482f, 0.11239423f, 0.21460766f, -0.02230594f, 
    -0.03565538f, -0.07155909f, 0.08439119f, -0.02094077f, -0.12141074f, -0.12926830f, -0.06148494f, -0.02010050f, 
    -0.17359172f, 0.09248933f, 0.38613543f, 0.09884703f, -0.17077857f, 0.05071339f, 0.12677523f, 0.07287094f, 
    0.04401309f, 0.06731818f, 0.06125757f, 0.12479798f, 0.07206649f, -0.02642014f, 0.08226603f, 0.06087148f, 
    0.04706116f, 0.02035349f, 0.03314921f, -0.16840771f, -0.20881748f, 0.28881529f, 0.15692046f, 0.05612979f, 
    -0.35779729f, -0.07651355f, -0.15007250f, -0.07770946f, -0.06378501f, 0.06744341f, 0.02395099f, 0.06981143f, 
    0.04637165f, 0.03638019f, 0.00985982f, -0.14876065f, 0.27020565f, 0.07480928f, -0.13790387f, 0.19610436f, 
    -0.10221881f, 0.00691085f, 0.33443794f, 0.20593458f, -0.21497725f, -0.01161212f, -0.09218293f, -0.10186914f, 
    0.03753874f, 0.00566318f, 0.04642414f, -0.08443658f, 0.09756132f, -0.02294513f, -0.12320945f, -0.10391407f, 
    0.00804778f, -0.00015369f, 0.13420041f, 0.03376857f, 0.26163143f, -0.18595292f, -0.19882378f, -0.32598892f, 
    0.17206769f, -0.20044774f, 0.03253058f, 0.20357946f, -0.08977120f, 0.15183009f, 0.03341879f, -0.07502732f, 
    0.09264497f, 0.10531534f, -0.07949969f, -0.06298994f, 0.00424463f, -0.15492025f, 0.03838832f, 0.14820755f, 
    0.11931825f, 0.26948482f, 0.02712513f, 0.08780711f, 0.21174477f, -0.07668463f, -0.08367313f, -0.04584481f, 
    -0.07066382f, -0.03950747f, 0.15907542f, 0.09756245f, -0.06246302f, -0.07405087f, -0.07665864f, -0.06530397f, 
    -0.16106364f, 0.02369391f, -0.01812318f, 0.05858934f, -0.62381285f, -0.20596699f, 0.03185635f, 0.18749683f, 
    0.04967375f, 0.15719460f, 0.03930122f, 0.01511547f, 0.00319688f, 0.28435692f, 0.16313663f, 0.10294382f, 
    0.16538866f, 0.00209450f, 0.00601310f, -0.02218646f, 0.00593620f, -0.10701331f, 0.05599916f, -0.01401817f, 
    -0.42200235f, 0.08491732f, 0.01616522f, 0.11233655f, -0.07595322f, -0.10713360f, -0.17619623f, -0.08570884f, 
    0.01368042f, 0.08680232f, 0.14071032f, -0.11158911f, -0.03592243f, 0.13310727f, 0.06257961f, 0.12929799f, 
    0.04076832f, 0.07834101f, -0.13182217f, 0.04622701f, -0.11060830f, 0.14063950f, -0.00308778f, 0.00485084f, 
    -0.05658486f, 0.00080243f, -0.07258058f, 0.02165213f, -0.01004311f, -0.05457002f, -0.00204685f, -0.08202779f, 
    0.03682112f, -0.01396721f, -0.02671021f, 0.00416009f, -0.01495207f, -0.13522570f, -0.12625037f, 0.01685113f, 
    0.16639853f, 0.02171910f, 0.21044670f, 0.13466394f, -0.27953416f, -0.25461116f, -0.05104245f, -0.10240777f, 
    -0.03116409f, 0.07074034f, 0.12651724f, -0.00028694f, 0.06619521f, 0.00385821f, -0.01549397f, 0.03815208f, 
    0.01837021f, 0.00070877f, -0.01298598f, -0.03852433f, -0.17642379f, 0.16862185f, 0.30372897f, 0.11267239f, 
    -0.28923282f, -0.03051360f, 0.02568906f, -0.05110513f, -0.06144876f, 0.11666685f, 0.02399014f, 0.10843077f, 
    0.11929131f, 0.03352709f, -0.05869463f, -0.00722432f, 0.03370020f, -0.00553251f, 0.06511167f, -0.01228454f, 
    0.33112067f, -0.00610716f, -0.19747595f, -0.32789856f, 0.04718735f, -0.02042552f, 0.00365769f, 0.15449850f, 
    0.02012039f, 0.06900488f, 0.14017217f, -0.01571340f, 0.00894422f, -0.07511343f, 0.00929941f, 0.05345012f, 
    -0.04967007f, -0.08937840f, -0.01112077f, -0.06513775f, 0.13359912f, -0.03909725f, -0.27305517f, -0.03421473f, 
    -0.15668558f, 0.12660085f, 0.07716523f, 0.04288096f, 0.06949885f, 0.05981128f, -0.05033542f, -0.03051705f, 
    0.01386215f, -0.03353043f, -0.06224155f, 0.17922528f, 0.02111638f, -0.12258764f, 0.03295507f, 0.04620782f, 
    0.29001471f, -0.16609065f, 0.04692071f, -0.06787917f, 0.07408673f, -0.05384767f, -0.09643228f, -0.04256252f, 
    0.11182486f, -0.03733196f, 0.11488095f, 0.01572880f, 0.05613236f, -0.03155392f, 0.03561687f, -0.00728509f, 
    0.10726419f, -0.00184632f, -0.11177130f, 0.12888518f, 0.22732402f, 0.05464554f, 0.27273977f, -0.09704582f, 
    -0.20064750f, -0.10233637f, 0.06807830f, 0.07986108f, -0.11035734f, -0.16486518f, 0.02458094f, -0.00052944f, 
    0.01680560f, 0.06281763f, 0.00908187f, -0.07841158f, -0.03154371f, -0.06009436f, -0.14191101f, 0.00886115f, 
    0.08413866f, 0.05851926f, -0.13113882f, 0.19793543f, 0.05915012f, 0.07930050f, -0.04041700f, 0.08024436f, 
    0.23918462f, 0.05215307f, -0.01249023f, 0.00203839f, -0.01873559f, -0.01363183f, 0.03605808f, 0.05566776f, 
    0.10625184f, 0.10047662f, -0.21436854f, 0.04644801f, -0.09641161f, -0.08443297f, 0.00636121f, -0.00811572f, 
    -0.06385099f, 0.05170891f, -0.08580047f, 0.04671469f, -0.02446499f, 0.09523882f, 0.08375044f, 0.01869280f, 
    -0.05425997f, 0.18977071f, -0.10514955f, 0.10536801f, -0.08340796f, -0.04821546f, 0.10189018f, 0.09849467f, 
    -0.14854565f, -0.19425662f, -0.29136640f, 0.09414259f, -0.02190598f, -0.08613914f, 0.07521527f, -0.04381066f, 
    -0.04324245f, -0.03121561f, 0.03899399f, 0.00119403f, -0.08769765f, 0.13205737f, -0.12336513f, -0.00078730f, 
    0.15211686f, 0.01155607f, 0.12097436f, 0.07138984f, -0.08338823f, 0.26448274f, 0.38560045f, -0.15556265f, 
    -0.35496843f, 0.19720355f, -0.14791068f, 0.22730005f, -0.06277247f, 0.06315338f, 0.08779440f, 0.03781943f, 
    -0.02291722f, 0.06370764f, 0.02704408f, 0.00575142f, -0.03184116f, -0.28368682f, -0.04219959f, -0.11828001f, 
    -0.05739287f, 0.08384830f, 0.46226934f, 0.25198728f, -0.19766830f, 0.09941088f, -0.08920091f, 0.06474607f, 
    0.18018538f, 0.00358650f, 0.10175321f, -0.07292435f, -0.01876272f, -0.10413666f, 0.02515957f, 0.04770546f, 
    0.00943366f, -0.11306521f, -0.06520203f, -0.10392661f, 0.52813298f, 0.01895946f, -0.21411687f, 0.31652245f, 
    -0.04892855f, -0.03258169f, 0.10651413f, 0.00827309f, -0.15209575f, 0.07514615f, 0.04963671f, -0.05769119f, 
    0.10944326f, 0.18008596f, -0.21848808f, -0.08181813f, -0.11341013f, 0.02304431f, 0.09133559f, -0.00231784f, 
    0.10415360f, 0.09191728f, 0.07579635f, 0.03537843f, 0.02461564f, -0.24326365f, -0.08765706f, -0.18045431f, 
    -0.16307037f, -0.22861069f, 0.08619783f, -0.03465175f, -0.17759988f, -0.00605748f, 0.11145622f, 0.01944567f, 
    -0.06209861f, 0.03220502f, 0.02562820f, -0.08060186f, 0.05018406f, -0.07829224f, 0.04799470f, 0.18373796f, 
    0.05296883f, 0.15073577f, 0.22691269f, -0.04095618f, 0.04516413f, 0.12148290f, 0.10031261f, 0.16574901f, 
    0.00579968f, 0.12461124f, -0.04216464f, 0.12568258f, 0.14456239f, 0.12469830f, 0.14977573f, 0.05953331f, 
    -0.06179073f, 0.00145607f, -0.17118613f, 0.03228160f, -0.11602228f, -0.01016655f, -0.00046193f, -0.00217071f, 
    0.07421094f, 0.02808398f, 0.11526959f, 0.14686005f, 0.02088229f, 0.12061308f, 0.01408104f, 0.04090191f, 
    -0.02118357f, 0.00748269f, 0.02550354f, -0.02377230f, 0.15906957f, -0.11693907f, -0.20261687f, 0.01403022f, 
    -0.02921506f, 0.03080432f, -0.00403169f, -0.02442016f, -0.04324792f, -0.09635063f, -0.12710813f, 0.00044406f, 
    0.00657486f, 0.08910497f, -0.13108672f, -0.11765641f, -0.03011430f, -0.03541319f, 0.03070184f, 0.11689884f, 
    0.20734783f, -0.46662223f, -0.29376051f, 0.09305165f, -0.23065914f, -0.12177054f, -0.00464278f, -0.00066704f, 
    0.05130525f, 0.06846890f, 0.12136130f, -0.04089433f, 0.03695209f, 0.00857731f, -0.11970666f, 0.00439091f, 
    0.03403729f, -0.02506392f, -0.01873659f, 0.01248041f, -0.08427935f, -0.12113672f, -0.14178610f, 0.10073351f, 
    -0.24821571f, -0.05488358f, 0.15273803f, 0.01879870f, 0.08980571f, 0.10995468f, 0.12654522f, -0.00610207f, 
    -0.02060191f, 0.03142469f, -0.08979098f, -0.07763058f, 0.05059585f, -0.02151082f, -0.01488474f, 0.03814946f, 
    0.04479032f, 0.15841882f, 0.14266783f, 0.01192866f, -0.04855027f, -0.04047270f, 0.03611889f, -0.05893463f, 
    0.00839973f, -0.02745913f, 0.02187570f, -0.04855140f, -0.01066319f, 0.14728661f, -0.02177618f, 0.06105309f, 
    0.01912376f, 0.14828767f, 0.18824571f, 0.09519871f, -0.08813846f, 0.12564927f, 0.17043431f, 0.00981461f, 
    -0.32732520f, 0.19380195f, -0.08849622f, -0.32380471f, -0.06455754f, -0.03738061f, -0.06276406f, 0.05758781f, 
    -0.00652153f, -0.01522131f, -0.02841714f, 0.15034965f, 0.10083263f, -0.16115622f, -0.04055800f, 0.04795685f, 
    0.24660054f, -0.08497778f, 0.20740893f, 0.11894220f, -0.11723277f, -0.13417205f, -0.00154993f, 0.04476203f, 
    -0.05243838f, 0.09207589f, 0.02215606f, 0.02103172f, 0.08920029f, 0.07921736f, 0.14762460f, 0.04256668f, 
    -0.03593995f, -0.00691131f, 0.16769655f, 0.05593896f, -0.00056558f, -0.34009773f, -0.16443916f, 0.13070999f, 
    -0.15843980f, -0.09452541f, -0.06452602f, -0.03469303f, 0.01234528f, -0.12884799f, -0.02617200f, -0.02757188f, 
    0.11084000f, -0.00418307f, -0.08660764f, -0.07703841f, 0.13065498f, -0.03964265f, 0.11873421f, 0.04701481f, 
    0.13537659f, -0.15516992f, 0.34340778f, -0.28783971f, -0.40598714f, 0.21995384f, 0.06375409f, 0.19260271f, 
    0.02818077f, 0.03794025f, 0.13452049f, 0.02448498f, -0.01188512f, -0.06414513f, -0.01432582f, -0.00973086f, 
    0.01431164f, -0.04156287f, 0.29262504f, 0.17926347f, 0.18620360f, -0.03677725f, -0.18731065f, -0.20804399f, 
    0.22270754f, 0.11256666f, -0.13230902f, 0.06211118f, -0.05815640f, 0.07555284f, -0.20984676f, 0.16106953f, 
    -0.12844910f, -0.28503549f, 0.19868521f, 0.03856783f, 0.12842892f, 0.12731819f, 0.03102914f, 0.21096525f, 
    0.16670485f, 0.19388901f, 0.15057965f, -0.21813901f, -0.07817398f, -0.01621435f, -0.21605392f, 0.15693384f, 
    0.03490243f, -0.16300964f, -0.12948069f, 0.03674037f, 0.01486641f, -0.10979945f, -0.02002227f, 0.07046139f, 
    0.10186248f, 0.08311625f, 0.07008718f, 0.00243608f, 0.26654711f, -0.09623318f, 0.01730371f, -0.25058106f, 
    0.13130413f, -0.16672206f, 0.15631197f, 0.25293717f, 0.01880875f, -0.02314824f, 0.01985039f, 0.01741851f, 
    0.03131070f, -0.09068880f, 0.02505598f, 0.16330157f, -0.02401383f, 0.34099853f, -0.10643581f, -0.28123465f, 
    0.00916383f, 0.02171585f, -0.22028823f, -0.30807561f, -0.23846914f, 0.06301846f, -0.15958764f, 0.00946357f, 
    0.00087695f, 0.09152574f, 0.01514959f, -0.01734426f, -0.00814652f, 0.02785424f, -0.05283409f, 0.14650412f, 
    -0.01461169f, 0.11352582f, 0.03532452f, -0.10045884f, 0.28830618f, -0.24747585f, -0.01138440f, 0.20502803f, 
    -0.31530648f, 0.22867745f, -0.22785558f, 0.01019761f, 0.11675512f, -0.04342213f, 0.14355011f, -0.03824128f, 
    -0.01931340f, -0.13168539f, 0.24211670f, 0.21751013f, 0.02718133f, -0.03176130f, 0.08794758f, 0.21003395f, 
    -0.23160750f, -0.09383375f, -0.08741336f, 0.03609021f, 0.05751931f, -0.04068517f, -0.03243137f, -0.02442302f, 
    -0.09969643f, -0.07956774f, -0.01014283f, 0.05629782f, -0.09485829f, 0.09428523f, -0.01360434f, -0.00167639f, 
    0.00363396f, 0.06564789f, 0.00645326f, 0.02683369f, -0.44633439f, 0.38379538f, -0.24683526f, 0.34278986f, 
    -0.02599943f, -0.02818417f, -0.22572157f, 0.01422135f, 0.05634040f, 0.03312379f, 0.01229386f, 0.11234796f, 
    -0.07773448f, -0.01950462f, 0.12297521f, 0.13642977f, 0.07222465f, 0.04229777f, -0.01474784f, -0.00201221f, 
    -0.37318066f, 0.45866373f, -0.14282033f, 0.10701928f, 0.03240020f, 0.05344315f, 0.15042157f, 0.00085246f, 
    0.06451003f, -0.03391231f, 0.17066580f, -0.01417051f, 0.00653685f, 0.09344631f, -0.03475960f, -0.07487919f, 
    -0.08180994f, 0.04518323f, 0.02416905f, 0.04187893f, -0.16915804f, 0.12984967f, -0.02194584f, 0.09234263f, 
    -0.04729518f, -0.09447273f, 0.01071453f, -0.08705946f, 0.03917288f, 0.12774324f, 0.09909631f, -0.00666503f, 
    -0.09093857f, -0.01333244f, -0.11028582f, 0.14103314f, 0.07311700f, 0.10815622f, -0.00527718f, 0.13668075f, 
    -0.41230085f, 0.20217864f, 0.05013277f, -0.15219602f, -0.12745424f, 0.11575384f, 0.11321153f, -0.12332637f, 
    -0.05734636f, 0.01780620f, -0.05754207f, -0.03018942f, 0.05281258f, -0.07672842f, -0.07096147f, -0.02781309f, 
    0.05965262f, 0.00462038f, 0.02871726f, -0.04993630f, -0.12738407f, 0.13927011f, 0.00218979f, 0.03072907f, 
    -0.33358207f, 0.23424025f, 0.01323017f, -0.05231965f, 0.00521659f, 0.03203741f, -0.07929979f, -0.15729333f, 
    0.12347401f, 0.01864417f, -0.11407008f, 0.04035877f, 0.06299859f, 0.04914405f, -0.02268254f, -0.05238103f, 
    0.06811716f, -0.09927657f, -0.11286700f, -0.03584662f, 0.11425035f, 0.09032597f, 0.02651305f, 0.03201782f, 
    -0.04183227f, 0.01522828f, -0.13011804f, 0.07994024f, 0.01979970f, -0.18112226f, 0.05800248f, 0.00849806f, 
    -0.00537274f, -0.02026079f, -0.11558779f, -0.08730163f, 0.16416609f, -0.03711454f, -0.05827425f, -0.05834424f, 
    -0.03477668f, -0.02763204f, 0.14502862f, 0.22641650f, 0.01598829f, 0.01747346f, 0.05776292f, 0.04011171f, 
    -0.00245548f, -0.01929838f, 0.03897263f, 0.01612263f, -0.05558549f, 0.01669569f, 0.02340035f, 0.04151416f, 
    -0.45744196f, 0.00142342f, -0.26247782f, -0.06919711f, 0.18422788f, 0.04895025f, -0.05441007f, -0.04436630f, 
    -0.12006958f, -0.04419852f, 0.08457143f, 0.11042502f, 0.18335123f, -0.03476650f, 0.11219166f, -0.02409971f, 
    -0.12623264f, 0.11710668f, 0.00750664f, 0.00542468f, -0.00245348f, 0.10503963f, 0.15803471f, -0.20075078f, 
    0.07151963f, -0.09487587f, 0.14649251f, -0.09368784f, -0.05950639f, 0.08879802f, -0.07281283f, -0.01174367f, 
    -0.05943962f, -0.08788852f, -0.09031352f, 0.00571501f, 0.00677189f, -0.03119930f, -0.08574387f, 0.08597746f, 
    -0.00474160f, -0.05043143f, 0.04192998f, 0.01463782f, -0.06192290f, -0.00104994f, -0.00801974f, 0.00128616f, 
    -0.00297040f, -0.02903977f, -0.02566391f, 0.01431042f, 0.00940832f, 0.00737990f, 0.00584822f, -0.01791875f, 
    0.02256192f, -0.01661630f, -0.05517937f, 0.03584292f, -0.00551060f, -0.01848453f, -0.06007303f, 0.02266390f, 
    -0.02655080f, -0.01598525f, -0.03664294f, 0.03020486f, 0.04898342f, -0.02774247f, 0.05645680f, -0.00404047f, 
    0.04797592f, 0.02102960f, 0.04453442f, 0.02122395f, -0.02989366f, -0.01840124f, -0.06111012f, 0.00204746f, 
    0.03017346f, -0.02571580f, -0.00761300f, -0.00010182f, -0.00988850f, -0.03723308f, 0.01601451f, -0.00258690f, 
    -0.05335006f, -0.04846181f, 0.03827780f, 0.05227409f, 0.03345207f, -0.03028831f, -0.02715903f, -0.01315344f, 
    -0.03847354f, -0.05036662f, 0.04964090f, -0.00502193f, 0.01268916f, -0.02114296f, 0.03215459f, 0.03269802f, 
    0.03806050f, -0.01002616f, -0.03122397f, -0.06186247f, 0.04917246f, -0.03196296f, 0.03429570f, 0.00214388f, 
    0.01517910f, -0.02881666f, -0.03872538f, -0.02874023f, 0.00689866f, -0.05219795f, -0.02196739f, 0.03187412f, 
    -0.00993370f, -0.01641111f, -0.00548400f, 0.04298924f, 0.00212912f, -0.05607525f, -0.02107396f, 0.04418740f, 
    -0.04992080f, 0.01646229f, -0.03182249f, -0.05800429f, 0.00597627f, 0.02026736f, 0.01396128f, 0.01683340f, 
    0.00867459f, 0.00014626f, 0.04876587f, 0.03729507f, -0.04119449f, 0.00196062f, -0.05505147f, 0.01574369f, 
    0.01854239f, -0.05789878f, -0.01296923f, 0.01677103f, -0.05127600f, -0.04599466f, -0.05906527f, 0.03380275f, 
    -0.03876458f, 0.04389121f, 0.03116690f, 0.02035364f, -0.01776111f, 0.04176925f, 0.03866237f, 0.01047735f, 
    0.01290017f, -0.00877651f, -0.03840771f, 0.02579294f, 0.01476359f, -0.03150664f, 0.04526702f, 0.02258195f, 
    0.04293388f, 0.02724330f, -0.05174206f, -0.00781428f, -0.00385727f, 0.00354659f, 0.01405172f, 0.04638524f, 
    -0.00529507f, 0.04185917f, -0.01736608f, -0.00700625f, -0.04585212f, -0.05417343f, 0.02371783f, -0.00055238f, 
    -0.00789725f, -0.04782402f, -0.02501252f, -0.02713980f, -0.00625458f, 0.01648188f, -0.02133349f, -0.05283743f, 
    -0.00740975f, 0.02893358f, -0.02679495f, 0.03389776f, 0.00532102f, 0.03495770f, 0.01673230f, 0.04688162f, 
    -0.03764382f, -0.04755213f, -0.01016581f, 0.03602707f, 0.00909144f, -0.00109255f, 0.01252634f, -0.05018846f, 
    -0.01582817f, 0.01288623f, 0.01390860f, 0.05413292f, -0.02006268f, -0.00550405f, -0.00363168f, -0.05471935f, 
    0.05054745f, 0.02526936f, -0.02374016f, -0.01687570f, -0.01562080f, 0.02838361f, -0.03473625f, -0.03533909f, 
    -0.04646152f, -0.05399643f, 0.03481995f, -0.04428331f, 0.04266006f, 0.02956935f, -0.04449111f, -0.01659088f, 
    -0.04327820f, 0.00369220f, 0.01806864f, -0.00018649f, -0.03053517f, 0.05991945f, 0.01760316f, 0.05056383f, 
    0.00162849f, 0.04441665f, -0.00298190f, -0.01999329f, -0.00233638f, 0.00382485f, 0.02883665f, 0.02644508f, 
    0.00711698f, 0.03766236f, -0.02953100f, 0.06024422f, -0.01657270f, -0.03102742f, 0.04211839f, -0.05550529f, 
    -0.04105119f, 0.03807860f, -0.01463231f, -0.01255118f, -0.03953707f, -0.05072583f, -0.05539190f, 0.03899416f, 
    -0.03912790f, -0.03936328f, -0.03765058f, 0.03199751f, 0.03088504f, -0.03434385f, -0.01622610f, 0.02169931f, 
    -0.03419407f, -0.04000765f, -0.04108449f, -0.05841827f, 0.04766105f, -0.02970124f, 0.01318187f, -0.03415437f, 
    -0.02932132f, -0.05200195f, -0.01710304f, -0.02747810f, -0.04677830f, -0.04268824f, -0.04613581f, -0.04631312f, 
    -0.02622048f, -0.01214360f, 0.00350611f, 0.01295952f, -0.02366401f, -0.01264944f, -0.03079938f, 0.04527950f, 
    -0.02715071f, 0.05123770f, -0.02907475f, 0.01937945f, 0.02824384f, -0.01518982f, 0.01728928f, 0.01678720f, 
    0.01131976f, -0.04233513f, 0.04534848f, -0.00246880f, 0.01617539f, -0.02886144f, 0.03077419f, -0.04621324f, 
    0.04255349f, -0.01157194f, 0.02177516f, -0.04076960f, 0.00087555f, -0.02069831f, -0.00196328f, 0.01684096f, 
    -0.02206665f, 0.00567252f, -0.01890770f, -0.04563297f, -0.04725396f, -0.02082724f, -0.03877698f, 0.04639294f, 
    -0.03775108f, 0.03584230f, -0.03115601f, 0.01976248f, -0.03722620f, 0.03134722f, -0.01024650f, -0.04693289f, 
    -0.00820244f, -0.01489964f, -0.04818578f, 0.00414468f, 0.04821418f, -0.05182936f, -0.00506231f, 0.00488252f, 
    0.05239338f, 0.05100159f, 0.01411821f, -0.04925523f, -0.00195824f, -0.02277080f, 0.03621623f, 0.04754404f, 
    0.01948179f, -0.04437671f, 0.03696077f, 0.01719677f, -0.01183714f, -0.04660702f, -0.03892853f, 0.00884543f, 
    -0.14522058f, -0.26264566f, -0.10474864f, 0.04019108f, 0.14281245f, 0.01868941f, 0.15085189f, 0.02503845f, 
    0.09864914f, -0.01123565f, -0.02286772f, 0.01409677f, 0.04474567f, 0.03215782f, 0.01416931f, -0.04486337f, 
    0.07054576f, -0.02028746f, 0.24734394f, 0.12231234f, 0.23608460f, 0.22083628f, -0.17551720f, 0.24932393f, 
    0.35541275f, 0.08621641f, 0.21224782f, -0.07104090f, -0.10685293f, 0.02464718f, 0.22746350f, 0.07370417f, 
    0.13719551f, 0.14031133f, -0.02679931f, 0.15444764f, 0.16016519f, 0.06515149f, 0.08307034f, 0.14339241f, 
    -0.14716321f, -0.40651950f, -0.26325646f, 0.00236305f, -0.01898674f, 0.05279825f, 0.07797124f, 0.08339763f, 
    0.17184417f, -0.09319958f, 0.10443454f, -0.02995390f, 0.08646629f, -0.03948799f, 0.01727194f, 0.02797878f, 
    0.12802893f, 0.08167379f, 0.11535695f, 0.06315313f, -0.03467958f, -0.01463016f, 0.17546974f, -0.14076121f, 
    -0.08886362f, 0.05881624f, 0.02838121f, 0.07116417f, 0.07416894f, -0.11253959f, 0.05437237f, -0.05225496f, 
    0.12072428f, -0.02702713f, 0.07154926f, -0.02410328f, -0.04766331f, -0.05196857f, -0.14516878f, -0.18564901f, 
    -0.09784291f, 0.07718064f, -0.01625025f, -0.15470822f, -0.03376313f, 0.09050526f, -0.17014271f, -0.00815270f, 
    0.09833741f, 0.02338334f, 0.00518924f, -0.00907581f, -0.10491431f, -0.03675603f, 0.02072250f, -0.09242559f, 
    -0.03560780f, 0.00073142f, 0.05262261f, -0.16765261f, 0.31610805f, 0.16388066f, -0.25186610f, 0.08112193f, 
    -0.02951412f, -0.09121096f, -0.00550884f, -0.17801817f, 0.08317538f, 0.26924178f, -0.03480679f, 0.08955869f, 
    0.01042522f, 0.00234365f, 0.07095636f, 0.18053603f, -0.04963000f, 0.19378826f, 0.14474240f, 0.08711580f, 
    0.17343642f, 0.08333015f, 0.13035570f, 0.07587103f, -0.18818703f, -0.14030240f, -0.08163226f, -0.13368806f, 
    -0.13556935f, -0.20364419f, -0.02340919f, 0.14239368f, -0.09959117f, 0.12025497f, 0.03605759f, -0.17483960f, 
    -0.11904832f, -0.00185944f, 0.02355949f, -0.14146139f, 0.27145681f, 0.09823252f, -0.14235745f, 0.03461294f, 
    -0.09393533f, 0.00593772f, -0.01314121f, -0.03051204f, 0.11725036f, 0.20262960f, 0.03093412f, 0.18038493f, 
    0.00809107f, 0.04227742f, -0.02131741f, 0.11263781f, 0.01585160f, 0.14091164f, 0.14046764f, -0.01363169f, 
    0.19287518f, 0.34304667f, 0.00716920f, -0.24300933f, -0.06904682f, 0.00965432f, -0.02154917f, 0.12978826f, 
    0.02027073f, -0.03708587f, 0.01389434f, 0.16677658f, 0.07990479f, 0.10660399f, 0.03382062f, -0.16436310f, 
    -0.05017894f, -0.04748474f, 0.08825923f, 0.01938002f, 0.06191470f, -0.11296214f, -0.06826457f, -0.05942813f, 
    -0.12367360f, -0.04434752f, -0.00278577f, -0.04228565f, -0.02901961f, 0.00520890f, -0.08360831f, 0.02831881f, 
    0.08105820f, 0.10878541f, -0.12827231f, -0.00251545f, 0.09654325f, 0.16162498f, 0.07652196f, 0.05771634f, 
    -0.14586301f, 0.08744416f, -0.19446473f, -0.39856470f, -0.20076922f, -0.04396637f, -0.01082128f, 0.00310275f, 
    0.12975396f, 0.20278990f, -0.04252866f, 0.12277899f, 0.01805535f, -0.05767960f, 0.01001556f, -0.12134960f, 
    -0.02880027f, -0.06074881f, 0.05660420f, -0.00996581f, -0.10269748f, 0.00183720f, -0.20283504f, -0.17327370f, 
    -0.01457313f, 0.01307174f, 0.07737584f, 0.08693747f, 0.12725353f, 0.19536223f, -0.04711542f, 0.04947635f, 
    0.05291905f, 0.06547018f, -0.06473836f, -0.01978299f, 0.08934169f, 0.09537165f, -0.00425664f, -0.01979942f, 
    0.12718023f, 0.08957635f, 0.06905483f, -0.00784143f, -0.04313415f, -0.00327817f, -0.11513717f, -0.05223956f, 
    -0.08072966f, -0.03433759f, -0.01211121f, 0.02504029f, 0.02207886f, 0.03364181f, -0.02490446f, -0.01081651f, 
    0.05545698f, 0.18254191f, 0.17043583f, -0.03657502f, -0.23754810f, -0.34921232f, -0.01323984f, 0.08415602f, 
    0.07220840f, -0.08576665f, -0.02442724f, -0.00861222f, -0.05549946f, -0.19152270f, -0.00207224f, -0.03923304f, 
    0.03816443f, -0.01740848f, 0.11210127f, -0.02413433f, 0.03842895f, 0.10094462f, 0.01290606f, 0.05543587f, 
    0.17822972f, 0.13599297f, -0.01618331f, -0.01609695f, -0.02161632f, 0.05695007f, -0.00179582f, 0.03748741f, 
    -0.05625330f, -0.05868457f, 0.03820736f, 0.10557549f, 0.23476517f, 0.08102541f, 0.09434396f, -0.03214710f, 
    -0.09696724f, -0.05656247f, -0.06646956f, 0.03378493f, -0.45737505f, -0.22963320f, -0.13894184f, -0.08892574f, 
    -0.04236833f, 0.02229609f, 0.01875978f, -0.14960298f, 0.07374824f, -0.07865901f, 0.02921389f, 0.02512053f, 
    0.00054121f, -0.06690220f, -0.03985236f, -0.00284158f, 0.08113793f, 0.11897703f, 0.03020682f, 0.08795822f, 
    -0.00341501f, -0.06277089f, 0.00348455f, 0.00933135f, -0.03789125f, -0.01793890f, -0.00434156f, -0.03335018f, 
    0.03041874f, -0.01269634f, 0.00148008f, -0.01183179f, -0.01166885f, -0.06138011f, -0.05108250f, 0.01951059f, 
    0.02348707f, 0.02070170f, -0.02435663f, -0.02425976f, -0.04034054f, 0.03635659f, -0.06072732f, -0.03682748f, 
    -0.06230184f, -0.03721471f, -0.03965170f, 0.02366248f, 0.05708315f, 0.00329577f, -0.00332486f, -0.03811120f, 
    0.02495930f, 0.01944724f, 0.01954312f, -0.03967873f, 0.04037240f, 0.00926901f, -0.02118381f, -0.05366747f, 
    0.01605466f, -0.04620798f, 0.03232496f, -0.02906624f, -0.01880287f, -0.01022373f, 0.02439796f, -0.03242149f, 
    -0.01781355f, -0.04537097f, 0.04627161f, -0.05269877f, -0.04932405f, -0.00299077f, 0.02985734f, -0.04642970f, 
    0.00779045f, -0.02474623f, -0.05128459f, -0.04672768f, -0.03416130f, 0.03141966f, 0.00176699f, -0.02460869f, 
    -0.02938744f, -0.00784388f, -0.02551094f, 0.00994844f, 0.02050942f, -0.05178643f, -0.01434861f, 0.04770821f, 
    -0.03991911f, -0.02246384f, 0.03560835f, -0.02170326f, -0.03831315f, -0.00044120f, -0.00378391f, -0.04672872f, 
    -0.05166711f, -0.03157750f, -0.06379724f, -0.03213408f, 0.00219138f, -0.03432135f, 0.00408568f, -0.03386956f, 
    0.00414324f, 0.02869675f, -0.03018057f, 0.01769155f, -0.05263554f, -0.02228511f, -0.06267313f, -0.00031536f, 
    0.01749504f, 0.01668588f, -0.01616767f, -0.06092408f, -0.06159845f, 0.02212858f, 0.01501812f, -0.04456792f, 
    0.02680065f, -0.02242239f, 0.00734939f, 0.02896676f, 0.01430414f, 0.05371692f, -0.02848681f, -0.03492821f, 
    -0.04737262f, 0.02444282f, 0.01568707f, -0.03758294f, -0.02292969f, 0.00712325f, -0.00653761f, -0.03874868f, 
    0.01815136f, 0.01669270f, -0.03144984f, -0.01442488f, 0.03538133f, -0.00023133f, -0.00855873f, -0.05150643f, 
    -0.01918562f, 0.00297454f, -0.04569302f, 0.00726497f, -0.02776151f, -0.04522055f, -0.05024416f, -0.01387574f, 
    0.01115615f, -0.02965061f, 0.04308016f, -0.02876151f, -0.05108057f, 0.03735084f, -0.02826502f, 0.02376627f, 
    -0.00329812f, 0.01446098f, -0.00888044f, 0.03474402f, -0.05732669f, 0.02695259f, 0.04477302f, 0.03069319f, 
    0.02793399f, -0.01689725f, 0.04071011f, 0.02503478f, -0.01289174f, -0.00956327f, -0.03381258f, 0.03991851f, 
    -0.00576090f, -0.02838441f, -0.04746513f, -0.02681424f, 0.02606860f, -0.03164981f, 0.04322264f, -0.00761369f, 
    0.03085601f, -0.02406252f, -0.02189829f, -0.01680984f, 0.02710860f, 0.01804529f, 0.03169780f, -0.00236691f, 
    -0.03497070f, 0.03182086f, 0.00062682f, -0.00715578f, 0.01325019f, -0.00975164f, -0.00810111f, 0.03863436f, 
    -0.00365992f, -0.05097808f, 0.00219497f, 0.01329625f, 0.03783992f, 0.00344704f, -0.00244004f, 0.01725770f, 
    -0.01090186f, 0.02962205f, -0.04211038f, 0.00597866f, 0.02517632f, -0.04607325f, 0.02491654f, -0.04356406f, 
    0.00641958f, 0.00090495f, -0.03861053f, 0.05264040f, -0.05691043f, -0.01920088f, 0.03871422f, -0.01480983f, 
    -0.05004664f, 0.02934279f, 0.01328295f, -0.03738617f, 0.03290470f, -0.03252381f, -0.04358921f, -0.02345341f, 
    0.00803176f, 0.01328841f, -0.02634170f, -0.00336126f, -0.03940426f, 0.00059072f, 0.01137364f, 0.02339477f, 
    0.02407022f, 0.04688628f, 0.03452415f, 0.01083290f, -0.02853833f, 0.03504452f, -0.05643965f, 0.04679522f, 
    0.00756578f, -0.05061022f, 0.03384833f, -0.03401651f, 0.00757411f, -0.04208245f, -0.01966647f, 0.00205338f, 
    -0.05216995f, -0.01212135f, 0.02055380f, -0.02867606f, -0.03991728f, 0.04946011f, -0.03379587f, -0.00319013f, 
    -0.05068155f, 0.01561976f, 0.03656037f, -0.03346689f, 0.00260773f, -0.02827623f, -0.03954420f, 0.01155053f, 
    0.03700299f, -0.04032589f, 0.04153291f, -0.02583203f, -0.05454887f, 0.03571903f, 0.01725658f, 0.00335543f, 
    -0.06238664f, -0.03107526f, 0.03556746f, -0.00046261f, 0.02082168f, -0.05775803f, 0.02183964f, -0.00760508f, 
    -0.00580513f, 0.04387181f, 0.00474974f, -0.00236032f, -0.00304295f, -0.03008007f, 0.01531853f, -0.03675878f, 
    -0.02900936f, -0.03189588f, -0.01553521f, -0.05815137f, -0.04141155f, 0.00954285f, -0.06039454f, 0.01912182f, 
    -0.01435678f, 0.01250411f, -0.05593752f, 0.03706849f, -0.00182576f, -0.02226689f, 0.01362229f, -0.00171027f, 
    -0.06184621f, 0.04269059f, -0.05505680f, -0.05157749f, -0.03769391f, 0.04420413f, -0.03742652f, -0.04505600f, 
    -0.03149388f, -0.03962263f, 0.05573222f, -0.02421917f, -0.00787564f, -0.05019956f, 0.05685423f, -0.05360897f, 
    0.01590249f, -0.04680422f, -0.00983922f, 0.00479948f, 0.02698953f, -0.03582476f, 0.02544555f, -0.00917990f, 
    0.20012872f, 0.35157111f, 0.17789569f, -0.14060201f, 0.15185694f, 0.29552564f, 0.27856454f, 0.06278285f, 
    0.32666126f, -0.08870940f, -0.03836738f, 0.03561569f, -0.07301830f, -0.08183636f, 0.04654110f, -0.00662895f, 
    -0.00570557f, -0.00016151f, -0.16005394f, -0.00864342f, -0.15563220f, 0.01577403f, -0.31762946f, 0.22763285f, 
    0.30359527f, -0.00414164f, 0.13978405f, 0.01678475f, -0.02315728f, 0.00403780f, 0.04954638f, 0.15744449f, 
    -0.02922549f, 0.17726231f, 0.01173870f, 0.06948428f, 0.13797338f, 0.03828995f, 0.06595482f, 0.16729099f, 
    0.07186265f, -0.04737461f, -0.18004487f, -0.08594462f, -0.12283550f, 0.17947721f, 0.08331407f, 0.00901500f, 
    0.19041513f, -0.00079578f, -0.08934896f, -0.13212757f, 0.05219982f, 0.18548228f, -0.03260629f, 0.00206855f, 
    0.22709805f, 0.10621881f, 0.14107098f, 0.29844674f, 0.21067245f, 0.26309314f, 0.28403115f, -0.16081415f, 
    0.18540038f, 0.23532224f, 0.17670688f, 0.26310787f, -0.11251725f, 0.05586953f, 0.10583708f, 0.00692941f, 
    -0.06056939f, 0.02471577f, 0.06844264f, -0.11936530f, -0.15165995f, -0.23001751f, -0.28580806f, -0.34653109f, 
    0.28029215f, 0.41737583f, 0.11011787f, 0.05069174f, 0.18851081f, 0.25775069f, 0.10636588f, 0.06541349f, 
    0.07847787f, 0.10060566f, -0.03988689f, 0.06360413f, -0.11963514f, -0.20121817f, 0.04717743f, 0.11942276f, 
    -0.13363926f, -0.13860580f, -0.13501129f, -0.22869271f, 0.00018559f, 0.02298957f, -0.04747093f, -0.01491141f, 
    -0.16569392f, -0.14635277f, 0.16585737f, -0.19835366f, -0.15036309f, 0.07182230f, 0.09346067f, 0.10861120f, 
    -0.06177163f, -0.02355693f, -0.09108091f, 0.15377820f, 0.03468256f, 0.18946844f, 0.08508631f, 0.05443339f, 
    0.18091606f, -0.04497493f, 0.10952789f, 0.10080981f, -0.21451898f, -0.13817382f, -0.18065122f, -0.10741339f, 
    -0.17160590f, -0.20767891f, 0.01820124f, 0.02305927f, -0.09928308f, 0.00435234f, 0.14142726f, -0.09422823f, 
    0.01074996f, -0.03105071f, 0.07469982f, -0.20139614f, 0.16691707f, 0.01628363f, 0.05210843f, 0.12320662f, 
    -0.15341645f, -0.01078177f, -0.11785118f, -0.00098255f, -0.05686397f, 0.05879958f, 0.01846897f, 0.09605894f, 
    -0.12975410f, 0.05659357f, 0.02662458f, 0.12341836f, 0.07905181f, 0.23513465f, -0.05544403f, 0.02583250f, 
    0.27454725f, 0.07597032f, -0.17829417f, -0.22664535f, -0.00645590f, -0.06381693f, 0.03846464f, 0.12232916f, 
    -0.03485386f, -0.15380035f, -0.01780442f, 0.20643023f, 0.10248660f, 0.03045913f, 0.04377086f, -0.04090344f, 
    0.02372322f, 0.02812929f, 0.06892033f, 0.00033072f, 0.00066235f, -0.23541741f, -0.06514534f, 0.00603014f, 
    -0.13348877f, -0.08003502f, -0.11223175f, -0.02669643f, -0.22228166f, 0.00994934f, -0.07955164f, -0.05127069f, 
    0.06246837f, 0.07787255f, -0.10784321f, -0.02837630f, 0.09012081f, 0.26664102f, 0.02244242f, 0.17308140f, 
    0.03128298f, -0.13608830f, -0.50799727f, -0.34737876f, 0.07605582f, 0.00392433f, 0.06280427f, 0.09822553f, 
    0.09406283f, -0.03536399f, 0.01879198f, 0.10948674f, 0.02700312f, -0.00212047f, 0.03058071f, -0.05547965f, 
    -0.00927628f, -0.02410317f, -0.02693815f, 0.05031922f, 0.02259160f, -0.22685954f, -0.35724756f, -0.20123942f, 
    0.14726378f, 0.13267028f, 0.13879707f, 0.14647114f, 0.12771483f, 0.07756284f, 0.00012741f, 0.01903596f, 
    0.01426324f, 0.05194890f, 0.01474576f, 0.07015871f, 0.14982827f, 0.08895733f, 0.02668313f, 0.01919975f, 
    -0.42441741f, -0.16101807f, -0.05903471f, 0.06306943f, -0.01188027f, 0.04829268f, -0.16410695f, -0.18400094f, 
    -0.00484968f, -0.05412427f, 0.00964607f, -0.01542019f, -0.09591933f, 0.08318295f, -0.01452857f, 0.02109709f, 
    0.11645480f, 0.15555611f, 0.14841649f, 0.09187511f, -0.24714096f, 0.13441990f, 0.26277232f, -0.04300858f, 
    0.08230079f, -0.10946770f, -0.04369503f, -0.02635803f, 0.05165847f, 0.12114735f, 0.00704608f, -0.03837501f, 
    -0.07883494f, -0.00064869f, 0.04429990f, -0.07525868f, 0.03511031f, -0.02324377f, -0.09145679f, -0.00512734f, 
    0.44450435f, -0.10052165f, -0.13656245f, -0.03311341f, -0.14321877f, -0.04476502f, -0.09312227f, 0.06431443f, 
    -0.16924697f, -0.03494816f, 0.15535104f, 0.08303223f, -0.02312677f, -0.03943703f, 0.05711777f, -0.07912567f, 
    -0.01901105f, -0.00401367f, 0.11165061f, 0.00161646f, -0.10884295f, -0.10319281f, -0.31470853f, -0.18006054f, 
    0.03420090f, 0.03496849f, -0.01631389f, -0.04059468f, 0.13887396f, 0.15627745f, 0.07432010f, -0.04031960f, 
    0.06101133f, 0.01382093f, -0.08851197f, 0.07791363f, 0.14158943f, 0.02710127f, 0.17370526f, 0.26703465f, 
    -0.06505804f, -0.06471980f, -0.04948338f, 0.05369716f, -0.00865309f, -0.05958837f, -0.00211056f, 0.00503531f, 
    0.02889342f, -0.05042256f, 0.02975992f, 0.00158385f, -0.04449932f, -0.04387165f, -0.03131590f, 0.02364506f, 
    0.04650986f, -0.04054847f, -0.01264763f, 0.05100995f, -0.03556187f, 0.00247967f, 0.03694610f, 0.02109922f, 
    -0.06144009f, -0.01384748f, -0.01028738f, -0.02640655f, -0.01073508f, 0.01946994f, -0.03240842f, -0.01417972f, 
    -0.01835951f, 0.02106833f, 0.00525431f, -0.06051961f, -0.04751679f, -0.09097971f, -0.04041284f, -0.01879071f, 
    -0.06069767f, 0.02305573f, -0.02762488f, -0.03580422f, 0.03237751f, -0.05402650f, -0.03639989f, 0.03140376f, 
    -0.01315331f, -0.00188836f, -0.04058834f, 0.00249641f, -0.00121164f, -0.05291174f, -0.06378967f, -0.02348206f, 
    -0.06733878f, -0.03906007f, 0.02417022f, 0.00436707f, 0.03509858f, 0.02132490f, 0.03266022f, 0.08103695f, 
    -0.02949112f, -0.01492606f, 0.02863389f, 0.01108757f, 0.04955110f, 0.00409498f, -0.05476639f, -0.06281439f, 
    0.00166608f, -0.06177600f, 0.03605339f, 0.05672574f, 0.05337444f, 0.01001447f, -0.01780462f, -0.04903887f, 
    -0.05650609f, -0.00054068f, -0.00480137f, 0.04220343f, 0.06830389f, 0.01975859f, 0.02945525f, 0.00408987f, 
    -0.04130123f, -0.05972379f, 0.00202542f, -0.02540388f, -0.03184925f, 0.00274480f, -0.05846822f, -0.02994699f, 
    0.02636903f, -0.06629082f, 0.03396794f, -0.03136738f, -0.06026117f, -0.01618171f, 0.01463350f, 0.02496354f, 
    0.02481540f, 0.00011536f, 0.01056313f, -0.05872488f, 0.03588719f, -0.00657897f, 0.04303622f, -0.04394902f, 
    0.05874393f, -0.03725049f, 0.01548701f, -0.04412803f, -0.01172457f, 0.02635827f, 0.04658782f, -0.04720739f, 
    -0.00190656f, 0.01489552f, 0.01834030f, 0.03477532f, -0.04832636f, -0.05134014f, -0.01845595f, -0.06240000f, 
    -0.05034636f, -0.06383695f, 0.01239136f, -0.00971311f, -0.01602919f, -0.05189604f, -0.05138564f, 0.02609849f, 
    -0.05614632f, -0.05602391f, -0.01180968f, -0.04444989f, -0.00141068f, 0.00990299f, 0.04060972f, -0.04533803f, 
    -0.04921577f, -0.03320919f, -0.03137771f, 0.00558730f, 0.01592073f, -0.02834674f, -0.04047450f, 0.02145091f, 
    -0.00690176f, 0.01608964f, -0.06652517f, 0.01820288f, 0.01274720f, -0.02467005f, -0.05588312f, -0.03540392f, 
    0.07965867f, -0.03470396f, 0.04148702f, 0.03668467f, -0.02624846f, -0.03786485f, 0.01931462f, -0.05126757f, 
    0.03181852f, -0.00157081f, -0.00566710f, 0.01002557f, -0.03384773f, 0.00626951f, 0.04937866f, -0.02295346f, 
    0.02772283f, 0.00164426f, 0.01377259f, -0.01032847f, 0.06649129f, -0.01357570f, -0.04706367f, 0.00028015f, 
    -0.05888907f, -0.02735939f, -0.04764585f, 0.00539482f, 0.01610565f, -0.00473377f, 0.02229961f, -0.03006480f, 
    -0.01561039f, 0.03241202f, -0.01559983f, -0.04628016f, -0.03848074f, -0.04622862f, -0.02552638f, -0.03690765f, 
    0.02840408f, -0.02347760f, 0.00605889f, -0.03925854f, 0.05989093f, -0.04091387f, -0.02844361f, -0.03639017f, 
    -0.02066364f, 0.03350177f, 0.02950628f, 0.02147876f, -0.05701856f, -0.03532678f, 0.01587002f, -0.02625046f, 
    -0.03617024f, -0.05725287f, -0.01688047f, 0.02593538f, 0.03545139f, -0.01739084f, 0.04817913f, 0.05534596f, 
    0.01400062f, -0.03686434f, -0.00184402f, 0.01750963f, 0.02976939f, 0.02368481f, 0.01888042f, -0.02420466f, 
    -0.04617845f, 0.00803201f, -0.06043128f, 0.01270970f, -0.01770446f, 0.02996443f, -0.01201114f, -0.07126542f, 
    0.00611120f, -0.00161789f, -0.02213798f, -0.03164119f, 0.01788076f, 0.00818551f, -0.01755548f, -0.04073545f, 
    -0.00578274f, 0.00034356f, -0.04697717f, -0.02248435f, 0.02175190f, -0.01101254f, 0.04110734f, -0.06871945f, 
    0.02334749f, -0.06056359f, -0.04993785f, -0.05343557f, -0.03293872f, -0.03414022f, 0.05003561f, 0.01539025f, 
    -0.03374597f, -0.01663309f, 0.04127676f, -0.03705573f, 0.02345356f, -0.03434874f, -0.06277259f, -0.01271090f, 
    0.02797683f, -0.05216583f, 0.00776262f, 0.04747199f, 0.03104811f, -0.01551648f, -0.00854057f, -0.01921942f, 
    0.01296930f, 0.03938355f, 0.07956190f, -0.03537718f, -0.02444392f, -0.05278352f, -0.05670941f, 0.02606153f, 
    -0.00836778f, 0.03658483f, 0.03056920f, -0.02499591f, -0.02085661f, -0.01806922f, -0.02808698f, -0.03514997f, 
    -0.05895109f, 0.01676353f, -0.01575725f, -0.04890867f, 0.02908694f, -0.04045748f, -0.02537225f, 0.03002826f, 
    -0.03392011f, -0.02977803f, -0.03095184f, 0.02080401f, -0.03947982f, -0.02767308f, -0.05491703f, -0.00249216f, 
    -0.00749548f, 0.03129920f, 0.00494871f, 0.02980291f, 0.00098064f, -0.04168898f, 0.04732303f, -0.06682290f, 
    0.11475665f, 0.25444281f, 0.60009629f, -0.08068945f, 0.03343103f, 0.14441451f, -0.03186456f, 0.02836544f, 
    0.06818801f, -0.03547512f, -0.01946422f, -0.06534998f, -0.04644709f, -0.02110704f, 0.03439320f, -0.07195716f, 
    -0.12483959f, -0.12206418f, 0.15084015f, 0.06705213f, 0.37675413f, -0.12281755f, -0.23526913f, -0.01267122f, 
    -0.00874862f, -0.06903288f, -0.01318749f, 0.11127234f, -0.01832533f, 0.12697619f, -0.07607634f, 0.13661881f, 
    0.01199230f, -0.02450781f, 0.19998133f, 0.07524361f, 0.10701357f, 0.16862518f, 0.15526883f, 0.07896201f, 
    -0.08453869f, 0.29004100f, 0.39686316f, -0.01239638f, 0.02827603f, 0.10802043f, -0.09785239f, 0.05140282f, 
    0.07654250f, 0.00119417f, -0.02379929f, 0.01095229f, -0.16478078f, -0.01789122f, 0.00078322f, 0.02141859f, 
    0.03832990f, 0.05509746f, 0.02126253f, 0.09973355f, 0.19711930f, 0.36462924f, 0.22377028f, 0.10125794f, 
    0.36328945f, -0.05702030f, 0.18267292f, 0.14043872f, 0.03161571f, 0.34757152f, -0.00650772f, -0.07039287f, 
    0.00153288f, -0.04862931f, 0.04648781f, -0.01130648f, -0.04955855f, 0.01646313f, -0.26359722f, -0.24337044f, 
    0.22660832f, 0.48738208f, 0.01079225f, 0.06871954f, 0.00160352f, 0.20874384f, 0.14381187f, -0.06463502f, 
    0.01642181f, 0.24829832f, -0.05326067f, 0.02166095f, 0.01856377f, 0.03839924f, 0.15446851f, 0.03751789f, 
    -0.01804851f, -0.00340851f, -0.07026864f, -0.02090011f, -0.42671907f, -0.54724395f, 0.23628660f, -0.08652169f, 
    -0.20329319f, 0.03449955f, 0.10123663f, -0.10387107f, 0.07718880f, -0.05670618f, -0.00767906f, -0.02449106f, 
    -0.02951630f, -0.17275171f, 0.25771475f, 0.21716097f, 0.03034268f, 0.08844507f, 0.05050662f, 0.15156408f, 
    -0.00174500f, -0.16155437f, -0.14231512f, 0.15987124f, 0.00600041f, 0.01187289f, -0.05348627f, 0.03259102f, 
    -0.04414086f, -0.01123948f, 0.05175461f, 0.02020952f, -0.01109193f, 0.13257638f, 0.02589226f, -0.07688804f, 
    0.10182929f, 0.12931377f, 0.02802293f, -0.04602381f, -0.55971283f, 0.01953756f, -0.03274155f, 0.26557240f, 
    -0.10080820f, 0.07277367f, -0.17217563f, 0.08241421f, -0.10359930f, 0.01233639f, -0.03620580f, 0.00254059f, 
    -0.09881324f, 0.04601087f, 0.05329361f, 0.05784433f, 0.06711339f, 0.08461840f, -0.06773999f, 0.00377311f, 
    -0.10125641f, 0.31902495f, -0.10300953f, -0.00836538f, -0.00126546f, 0.00676041f, 0.02581567f, -0.01874598f, 
    0.00269365f, 0.02459111f, 0.11911993f, -0.01617742f, -0.01967748f, 0.02613367f, -0.07104968f, -0.14777015f, 
    -0.06872796f, 0.05112036f, 0.03039881f, -0.01699477f, -0.30268580f, 0.10136116f, 0.09011266f, 0.00838840f, 
    -0.05498836f, -0.08283444f, -0.05157177f, 0.01280397f, -0.11598872f, 0.04399127f, 0.00620466f, 0.00228555f, 
    0.07839134f, 0.00920512f, -0.07247350f, 0.10624542f, 0.13620824f, 0.19093202f, -0.05759540f, 0.06025569f, 
    -0.09511752f, 0.23994385f, -0.14259820f, -0.06587860f, -0.02139326f, 0.11594537f, 0.09652565f, -0.14336997f, 
    -0.01115321f, -0.05221404f, 0.01950933f, 0.04938103f, 0.03734641f, 0.02367963f, -0.05255824f, 0.01868868f, 
    -0.00844512f, 0.02351761f, -0.00153593f, -0.02724983f, 0.10960206f, -0.01455366f, -0.09717286f, 0.01406964f, 
    -0.10213949f, 0.18845165f, -0.02787141f, -0.09496619f, 0.01521733f, -0.11968268f, -0.11272532f, -0.06544255f, 
    0.08377988f, 0.00168343f, -0.13976283f, 0.02719888f, 0.01599503f, 0.04947145f, 0.01808892f, -0.00696193f, 
    -0.03577404f, -0.34936175f, -0.25421995f, -0.14584789f, 0.04254162f, 0.02247992f, 0.03188207f, 0.03728148f, 
    0.02467010f, -0.02755230f, -0.09976555f, 0.09556961f, -0.10120728f, -0.07706092f, 0.06782151f, 0.15392797f, 
    0.02298635f, 0.06458876f, 0.07063532f, -0.11793368f, 0.21200785f, 0.28352988f, 0.17443325f, 0.03509848f, 
    0.12653215f, -0.20008451f, 0.03235546f, 0.14623123f, 0.11744604f, 0.22660774f, 0.01977799f, -0.00603205f, 
    -0.00741553f, -0.03504646f, -0.07022814f, -0.18197902f, -0.16332288f, -0.09602026f, -0.04272426f, 0.11125544f, 
    0.16785507f, -0.21385807f, -0.49459332f, -0.12971628f, -0.08943870f, 0.16173555f, -0.16591860f, 0.04936396f, 
    -0.06342613f, -0.16170013f, -0.01296249f, 0.01831632f, 0.10280762f, 0.02391348f, 0.08444534f, -0.04006753f, 
    -0.11349273f, 0.15709408f, -0.05912663f, 0.04162217f, 0.00779612f, 0.13059820f, 0.28177601f, -0.08544113f, 
    0.19976151f, -0.00813722f, 0.06912522f, -0.11806481f, -0.01836174f, 0.14325909f, 0.04262997f, 0.04172961f, 
    0.00585411f, 0.02817803f, -0.05973241f, 0.06107824f, -0.00980985f, -0.00491484f, 0.00176292f, 0.16087031f, 
    -0.16528852f, 0.03720015f, -0.04743021f, 0.24362591f, 0.15066236f, -0.08156061f, -0.04095419f, -0.09024693f, 
    -0.16498804f, -0.04965279f, -0.03435941f, -0.01721781f, 0.01725452f, 0.03001984f, -0.04105742f, 0.00682617f, 
    -0.00987624f, 0.07744796f, -0.13584059f, 0.10241751f, -0.19204427f, 0.20519130f, 0.37398756f, 0.01648961f, 
    -0.46535301f, -0.13639206f, 0.08855356f, -0.06320104f, -0.15556295f, -0.04286776f, -0.00303101f, -0.00627360f, 
    0.21824151f, 0.11462428f, -0.03388586f, 0.12853098f, 0.26385674f, -0.01390996f, 0.09675958f, -0.20429236f, 
    -0.20752428f, 0.11144468f, 0.01988462f, 0.05265471f, 0.17978191f, 0.13669811f, 0.17007577f, -0.11537664f, 
    -0.17331910f, 0.14171660f, 0.15348089f, 0.00799468f, -0.02473711f, 0.04910409f, 0.00819248f, 0.01464546f, 
    -0.22014198f, -0.14850263f, -0.00171751f, -0.03311900f, 0.13825676f, -0.23588714f, -0.08874185f, 0.16262610f, 
    0.14173034f, 0.00428712f, -0.01396818f, -0.21684447f, 0.15111762f, 0.14492509f, -0.01910930f, 0.03959886f, 
    -0.03355067f, 0.07734984f, -0.00617493f, 0.17402031f, 0.02772149f, -0.02765513f, 0.41022450f, 0.41236916f, 
    -0.20745182f, -0.15544879f, 0.28287876f, 0.31244805f, 0.11092049f, 0.02371939f, 0.05210787f, 0.09055544f, 
    -0.07434853f, -0.02895968f, 0.02618876f, 0.04909787f, 0.11526754f, 0.17480360f, 0.10253831f, -0.03601196f, 
    0.21184047f, 0.00829650f, 0.00131268f, 0.35317287f, -0.74936175f, 0.33080274f, 0.09870582f, -0.05864804f, 
    -0.05786353f, 0.04182306f, 0.07360828f, -0.05703169f, 0.10903317f, -0.21719296f, -0.06756144f, 0.01304238f, 
    0.07609364f, -0.01420900f, -0.00863673f, 0.07072232f, 0.23492253f, 0.06380183f, -0.12690943f, -0.13396861f, 
    -0.10762278f, -0.16594669f, -0.34317052f, -0.16901670f, 0.21951656f, 0.08573857f, 0.04594155f, -0.00232411f, 
    -0.03673423f, 0.04064812f, -0.09278253f, -0.02692894f, 0.11659741f, 0.01296872f, -0.00068866f, 0.11351774f, 
    0.02906706f, -0.03303603f, -0.04779735f, 0.08402412f, -0.15370673f, 0.03387382f, 0.01456821f, -0.19690619f, 
    0.27125981f, 0.07170175f, 0.12285100f, -0.08349252f, -0.08662244f, -0.02358810f, 0.00540502f, 0.00510437f, 
    0.04674798f, 0.09880460f, 0.01274407f, 0.12298847f, 0.07852506f, 0.02889124f, -0.12618802f, 0.13132016f, 
    -0.20391078f, -0.24481381f, 0.25305113f, 0.24846521f, 0.15345238f, 0.13147061f, 0.00859535f, -0.06366190f, 
    -0.05174778f, 0.00607569f, -0.06838101f, -0.01596733f, 0.14930068f, -0.08104618f, 0.08426278f, 0.01539653f, 
    -0.03922272f, 0.02623764f, 0.02016976f, -0.04724553f, -0.37113589f, -0.06024726f, -0.00729241f, 0.05247498f, 
    0.20889395f, 0.01709277f, -0.05057675f, -0.22126645f, -0.04297617f, -0.03307116f, 0.09580051f, 0.07280482f, 
    0.03808792f, -0.03527901f, 0.16397832f, 0.07488123f, -0.08268929f, -0.16078965f, -0.14764869f, -0.21614775f, 
    -0.37830856f, 0.10306746f, 0.53571194f, 0.22864015f, 0.17023693f, 0.00093609f, -0.15242666f, -0.02640005f, 
    -0.06127306f, -0.11163850f, -0.02374688f, 0.08877379f, 0.15383908f, 0.02084698f, -0.00710606f, 0.10763802f, 
    -0.12471789f, -0.00847115f, -0.11873456f, -0.09158767f, -0.26485658f, 0.12043109f, 0.34481880f, 0.21143658f, 
    0.27651140f, -0.02723933f, -0.08196196f, -0.08747993f, -0.07140692f, -0.15826978f, -0.00567470f, 0.11621165f, 
    0.02404647f, 0.00943708f, 0.09466492f, 0.11913596f, -0.05364467f, -0.03101595f, -0.12319654f, 0.01396080f, 
    0.05182011f, 0.06812488f, -0.01428945f, 0.06962102f, 0.05562450f, 0.02289127f, 0.07980852f, 0.08774793f, 
    -0.00075479f, -0.00550822f, 0.06164285f, 0.01063752f, -0.05147098f, 0.11675411f, -0.04853402f, 0.12928277f, 
    0.03463432f, -0.13716161f, -0.03979239f, -0.13063581f, 0.03455565f, 0.12729372f, 0.09225909f, 0.09691167f, 
    0.13934214f, 0.07033445f, 0.25959653f, 0.14392217f, 0.01422055f, 0.14906237f, 0.04701008f, -0.00579116f, 
    -0.02774754f, -0.02650389f, 0.00627719f, -0.02286010f, -0.02586709f, 0.04328150f, 0.09500287f, 0.12821908f, 
    0.17343397f, 0.20452465f, 0.02148926f, -0.10365818f, 0.04952614f, 0.06009810f, -0.00033180f, -0.04138283f, 
    0.03331207f, 0.02595621f, -0.09625236f, -0.05636415f, 0.07340715f, 0.07830092f, 0.15726222f, 0.04888183f, 
    0.06176643f, 0.17427783f, -0.03615189f, -0.02781887f, 0.02118458f, -0.02546819f, 0.06736629f, 0.12553452f, 
    0.04526262f, 0.09189273f, -0.22819689f, -0.03525059f, 0.01162968f, -0.03767605f, -0.02141670f, 0.13383104f, 
    -0.02179619f, -0.01088755f, -0.04285654f, 0.11640234f, -0.17724031f, 0.01595296f, -0.09749247f, -0.29842871f, 
    -0.27984259f, 0.33950862f, -0.14612401f, 0.18614703f, 0.05221795f, -0.15555295f, -0.00605817f, 0.02653866f, 
    -0.01828957f, -0.00579078f, -0.02289939f, 0.07127730f, -0.01093631f, 0.15918000f, 0.11621231f, 0.04969847f, 
    0.01783602f, -0.02336864f, 0.00676591f, 0.05391768f, 0.21441920f, 0.12635460f, -0.26306659f, -0.06092950f, 
    -0.20626286f, 0.05943151f, 0.04867215f, -0.09910106f, -0.08662682f, 0.06566211f, 0.13551050f, -0.03470960f, 
    -0.02586250f, -0.10834881f, 0.01057507f, -0.03001229f, -0.04346189f, -0.19690460f, -0.08455864f, 0.15741980f, 
    -0.17750813f, 0.00384642f, 0.30928549f, -0.09651080f, -0.12493743f, -0.00212455f, 0.23876265f, 0.14945291f, 
    0.08059222f, 0.09531935f, 0.01443971f, -0.05913826f, 0.09529434f, 0.02197313f, 0.03557936f, -0.04333074f, 
    0.02947279f, 0.09869812f, 0.05505363f, -0.01551913f, -0.10804995f, 0.14218800f, -0.05533618f, 0.13151522f, 
    -0.35129079f, 0.15747625f, 0.04757121f, 0.02586659f, -0.01011758f, 0.04470173f, -0.09001485f, -0.01918040f, 
    -0.04471556f, 0.21702228f, 0.07179584f, -0.10982434f, 0.11364592f, 0.09743129f, -0.15912870f, 0.17421894f, 
    -0.12440127f, -0.01053104f, 0.21300197f, 0.33850309f, 0.12693931f, -0.04951316f, 0.08533441f, 0.03208036f, 
    0.04394089f, 0.02223767f, 0.05719923f, 0.03387799f, 0.03194669f, -0.06006944f, 0.02918398f, -0.12167110f, 
    0.11292321f, 0.01269748f, 0.08656337f, 0.06027148f, -0.31588995f, 0.13733514f, -0.20275789f, -0.20960116f, 
    0.24402100f, -0.15297857f, -0.01990821f, 0.22578265f, 0.11551939f, 0.07213253f, -0.05117039f, -0.10546103f, 
    0.05527877f, 0.01117983f, -0.07215758f, -0.15065043f, 0.03632705f, -0.06176100f, 0.17185919f, 0.16049720f, 
    0.12787187f, 0.02978195f, 0.14158612f, 0.00499369f, 0.01558804f, -0.02907863f, -0.16723199f, -0.00248870f, 
    -0.02343992f, 0.06083490f, 0.10740643f, 0.15996382f, 0.09007123f, -0.06158862f, -0.01210827f, 0.02375936f, 
    -0.04529750f, -0.08211067f, 0.00343007f, 0.02727383f, -0.18689775f, -0.28774112f, 0.10356513f, -0.07632032f, 
    0.02601595f, -0.11274190f, 0.05874972f, 0.14562431f, -0.03881793f, 0.05225153f, 0.18860763f, 0.01098620f, 
    0.06842087f, -0.02207802f, -0.00074093f, -0.00656854f, -0.07576920f, -0.07366088f, 0.10219108f, 0.02710463f, 
    0.03950576f, -0.26606253f, 0.37889689f, 0.04931725f, -0.03040316f, -0.08161709f, -0.14132622f, 0.08033203f, 
    0.00434162f, 0.06570253f, 0.10415323f, 0.03507881f, -0.03835243f, -0.04007392f, 0.13538769f, 0.07698913f, 
    0.06619117f, 0.02094287f, -0.17206742f, 0.00287637f, -0.01798124f, -0.01696824f, 0.06135944f, 0.05508620f, 
    -0.00793936f, -0.10272630f, -0.04310577f, 0.17076331f, -0.08949006f, -0.00751402f, 0.02332030f, -0.00722067f, 
    -0.02003689f, -0.10797595f, 0.01679579f, 0.00924953f, 0.05792045f, -0.02261230f, -0.02118090f, 0.07108813f, 
    0.20343295f, 0.01668620f, 0.25177988f, 0.07048893f, 0.15258452f, -0.15841259f, -0.00614552f, -0.06414178f, 
    0.06278098f, -0.02231945f, 0.05348046f, 0.09810511f, 0.02666135f, 0.07373542f, -0.00637283f, 0.05646230f, 
    0.03967592f, 0.05880667f, 0.02804441f, -0.01628279f, -0.05678879f, 0.19125099f, 0.20983182f, 0.06580866f, 
    0.14554946f, -0.33435589f, -0.00903540f, -0.06998245f, 0.08856995f, 0.09670111f, -0.03084647f, 0.09173574f, 
    -0.02706091f, -0.06937905f, 0.01536544f, -0.01564003f, 0.05164247f, -0.07391118f, 0.07298630f, 0.00226397f, 
    -0.04080334f, -0.21075101f, -0.11711524f, -0.35569802f, -0.00942186f, 0.00229558f, -0.04001610f, -0.00849677f, 
    -0.03488689f, 0.03942624f, 0.05500773f, -0.02432469f, 0.03162628f, -0.04911988f, -0.02823154f, 0.05700168f, 
    -0.07870718f, 0.00186103f, 0.07542594f, 0.01035057f, -0.16475077f, 0.01658650f, -0.15919688f, -0.18959123f, 
    0.09814094f, 0.11710987f, 0.07334901f, 0.07413214f, -0.07412718f, 0.13949144f, 0.00357028f, -0.08111031f, 
    0.03893195f, -0.03289727f, -0.02999207f, 0.08327014f, 0.04080470f, -0.02805175f, -0.06422743f, -0.01552561f, 
    0.18051916f, 0.02911379f, 0.33188754f, -0.18722840f, 0.00183540f, -0.05252984f, -0.07074277f, -0.07631369f, 
    -0.02116060f, 0.14730281f, 0.16628172f, 0.06978799f, -0.10985653f, -0.06603628f, 0.03635329f, -0.01962206f, 
    0.05100130f, -0.12827265f, 0.03489176f, -0.14989300f, 0.21660174f, 0.10297576f, 0.05152679f, -0.30734953f, 
    -0.16301462f, 0.18804505f, -0.00321315f, -0.12100291f, -0.07713954f, -0.02374437f, 0.00827515f, -0.00884516f, 
    0.00617148f, 0.06880649f, 0.02620318f, -0.01811782f, -0.00179642f, -0.00278890f, 0.16422087f, 0.18671943f, 
    0.52407199f, 0.31347302f, -0.08284744f, -0.16646832f, 0.25336951f, 0.06938095f, 0.01401665f, -0.11694852f, 
    0.03634679f, -0.01460014f, 0.01725742f, -0.06064021f, 0.04734569f, -0.04042807f, -0.12332115f, 0.02424423f, 
    -0.07067478f, 0.02523602f, -0.20540133f, 0.02875597f, -0.30693933f, -0.32771111f, 0.23918808f, 0.22882946f, 
    0.01420455f, -0.08664307f, 0.11322270f, 0.08882383f, 0.07388213f, -0.23646180f, -0.10691108f, -0.03530931f, 
    0.18923067f, 0.12645018f, -0.21999940f, -0.17769064f, -0.01228877f, 0.09529515f, -0.03572250f, -0.09990276f, 
    0.22865900f, 0.03385963f, -0.28115845f, 0.03777689f, 0.04315292f, 0.01893571f, 0.12042751f, -0.08762489f, 
    -0.16682225f, 0.07272713f, 0.02715701f, 0.16279575f, -0.04213082f, 0.02433236f, 0.00578610f, -0.04043007f, 
    -0.15422967f, -0.08145022f, -0.11768018f, -0.00454533f, -0.00641752f, 0.03636181f, -0.06281509f, -0.03150881f, 
    0.15902331f, 0.12933250f, 0.01498117f, -0.01326561f, 0.08189467f, 0.04019083f, -0.04754929f, 0.00523802f, 
    -0.04242395f, -0.02591420f, -0.05806646f, 0.11030301f, 0.08948463f, -0.10244073f, 0.27840227f, 0.25009748f, 
    0.34194839f, -0.02028040f, 0.19499870f, -0.23804307f, 0.21228518f, -0.02138246f, 0.16834186f, 0.27303132f, 
    -0.03958760f, -0.11389884f, -0.06520488f, -0.05594522f, -0.00982662f, 0.04149826f, 0.18480118f, 0.11287430f, 
    0.05939530f, 0.05472708f, 0.02572165f, 0.13849169f, 0.17996754f, 0.05054829f, 0.19209307f, -0.07910482f, 
    -0.01364273f, -0.01129544f, 0.10853963f, 0.05864426f, -0.22674340f, -0.22000585f, 0.02088322f, 0.07974137f, 
    -0.00883940f, 0.11605977f, -0.05458695f, -0.07860269f, 0.07403601f, 0.11234013f, -0.24313842f, -0.18663624f, 
    -0.15562502f, -0.08459613f, -0.15072739f, -0.13925880f, -0.10008668f, 0.11091666f, 0.14250457f, 0.05987104f, 
    0.09437254f, 0.11302688f, -0.10626101f, -0.13512564f, 0.17787789f, 0.04156542f, 0.07308233f, 0.04199711f, 
    0.11343511f, -0.01388593f, -0.03711287f, 0.09458616f, 0.32124743f, 0.02001445f, 0.17279626f, -0.17445566f, 
    0.11216570f, -0.06590302f, 0.10154270f, -0.01115560f, 0.05096897f, -0.09521107f, 0.09637778f, -0.06475675f, 
    0.00147619f, -0.01331726f, -0.07318943f, 0.01507745f, -0.02707019f, -0.01559080f, -0.10197244f, 0.10109560f, 
    -0.03169741f, -0.32613423f, -0.17992300f, -0.08859010f, 0.06598037f, 0.00124496f, 0.03477206f, -0.01720400f, 
    0.08025146f, 0.03101570f, -0.00131838f, 0.10074379f, 0.05405463f, -0.09682310f, 0.03119416f, -0.02891236f, 
    0.03496594f, -0.03862535f, -0.04306787f, -0.03740491f, 0.07281545f, -0.18107371f, 0.05326657f, -0.07064752f, 
    0.03429238f, 0.00975272f, 0.01429771f, -0.10938521f, 0.11816435f, 0.03866148f, 0.06096964f, 0.16794062f, 
    0.07087563f, -0.04543237f, 0.13044892f, -0.06551969f, 0.01158080f, -0.02297144f, -0.11138786f, -0.10655775f, 
    -0.06147272f, -0.14096121f, -0.23492236f, 0.12497646f, 0.10686700f, 0.06401987f, 0.00214839f, 0.17337166f, 
    -0.03779660f, 0.01900136f, 0.14627391f, -0.06296081f, -0.00162498f, -0.04341510f, 0.00378371f, 0.03078569f, 
    -0.00625343f, 0.04627136f, -0.06524266f, -0.08936472f, 0.33036762f, -0.04896425f, -0.12872903f, 0.01541136f, 
    0.30477142f, -0.01406173f, -0.01346425f, 0.10652782f, -0.16236597f, -0.08249447f, 0.09231253f, -0.08413763f, 
    -0.05269959f, 0.01994175f, 0.01262409f, 0.03495537f, 0.01298200f, -0.06875092f, -0.09670033f, -0.02675039f, 
    -0.14653128f, 0.17360483f, 0.10422815f, 0.21783638f, -0.03571722f, -0.03507733f, 0.08480315f, 0.03937294f, 
    0.00340925f, -0.04365813f, -0.00494185f, 0.05041184f, 0.01539952f, 0.07159165f, 0.06073957f, 0.03749849f, 
    0.12198298f, 0.01741846f, -0.04910661f, 0.00517248f, 0.22743040f, 0.28672671f, 0.32412910f, 0.16753735f, 
    -0.01722247f, 0.07661474f, 0.04411428f, -0.10376914f, 0.15452303f, 0.01972451f, -0.01231247f, -0.02879324f, 
    -0.02571286f, 0.12535788f, 0.04456173f, 0.00282175f, -0.03357316f, 0.08598030f, 0.12987573f, 0.06500255f, 
    -0.18522578f, -0.07113085f, -0.03464016f, 0.12937690f, 0.02372701f, -0.10180713f, 0.16047442f, 0.01916149f, 
    0.03859440f, 0.00632436f, 0.01748997f, -0.05558850f, -0.02414717f, 0.06546331f, 0.10948219f, -0.01740100f, 
    0.05195455f, 0.04557174f, -0.02014302f, 0.00237854f, 0.14647269f, -0.11214366f, -0.23965064f, 0.21072659f, 
    -0.01666744f, 0.09557941f, -0.11847043f, 0.15037274f, 0.05834999f, 0.08144635f, 0.04656726f, 0.01251029f, 
    0.00556734f, -0.05820682f, 0.02387947f, 0.04871164f, -0.02760433f, 0.00895030f, 0.06862559f, -0.23384544f, 
    -0.04178679f, -0.11152423f, -0.45059931f, 0.25933433f, 0.31860530f, -0.13471097f, -0.00479560f, 0.06314307f, 
    -0.07362961f, 0.12284436f, -0.09009467f, 0.06052860f, 0.02482214f, 0.05075846f, -0.08861680f, 0.09545444f, 
    -0.00857205f, 0.01593695f, -0.03913021f, 0.06849337f, -0.30250588f, 0.04549673f, 0.11263102f, 0.41012073f, 
    0.05044977f, -0.02984948f, -0.08847902f, 0.02174806f, 0.12562734f, -0.09921436f, -0.02963045f, 0.03092715f, 
    0.08110416f, 0.15275697f, 0.05146809f, 0.03690211f, -0.05305557f, 0.06704432f, -0.01564982f, 0.09248407f, 
    -0.06429046f, -0.21815155f, -0.09351309f, 0.08593497f, 0.03713674f, -0.01855505f, 0.09762749f, -0.09040168f, 
    -0.14459550f, 0.01419315f, 0.09878108f, 0.08344835f, 0.08523455f, -0.03786909f, -0.04125934f, 0.03135825f, 
    0.00492083f, 0.07041983f, 0.04747782f, -0.01639006f, -0.05422212f, -0.43769073f, -0.05737191f, 0.17059065f, 
    -0.03285259f, 0.03157515f, -0.05374008f, 0.07994482f, 0.11551534f, -0.16924980f, 0.02028381f, 0.01594810f, 
    0.00476164f, 0.06635328f, 0.02786354f, 0.11211033f, -0.06898855f, 0.07604813f, 0.23268841f, 0.13937445f, 
    -0.31249207f, -0.27559236f, -0.10957421f, 0.22422633f, 0.04842957f, -0.14359882f, -0.01169915f, 0.16216302f, 
    0.01989179f, -0.05043857f, 0.00134845f, 0.01455845f, -0.03743008f, 0.03259600f, -0.05892009f, 0.14417006f, 
    0.05125548f, 0.08514124f, 0.17722794f, 0.14612691f, -0.16436420f, 0.15018429f, -0.01424240f, 0.22351570f, 
    -0.01684966f, 0.00349494f, -0.00706140f, -0.03949505f, 0.31787381f, -0.02902156f, -0.04290286f, -0.11680493f, 
    0.14438662f, 0.06804909f, -0.01078663f, 0.04291158f, -0.02823143f, -0.10654175f, 0.12885320f, -0.00094693f, 
    -0.07563938f, -0.21032520f, -0.04222016f, -0.23373517f, -0.23038474f, -0.11802506f, -0.02486026f, -0.05920879f, 
    -0.01414948f, -0.03686222f, -0.00723969f, 0.08024433f, 0.04302678f, 0.07526349f, 0.02193709f, 0.06770501f, 
    0.01791045f, -0.04335703f, -0.05305440f, -0.10693728f, 0.44724670f, 0.02699765f, 0.02924950f, -0.11500828f, 
    0.15468976f, 0.01547203f, 0.20275250f, 0.02459962f, 0.08387525f, 0.00884563f, 0.00650119f, 0.11563664f, 
    0.15928036f, 0.11966805f, 0.02577220f, 0.09638766f, 0.07480762f, 0.07673210f, 0.05620497f, -0.01995408f, 
    0.30566227f, -0.17459205f, 0.18535268f, 0.14252143f, 0.07484436f, -0.00418750f, 0.01432670f, 0.05144960f, 
    -0.02508782f, 0.09447509f, -0.00328215f, 0.02653933f, 0.10046722f, 0.03514449f, 0.12350438f, 0.07978731f, 
    0.01252456f, 0.00964474f, 0.01342248f, 0.09685336f, 0.11650524f, -0.12396131f, -0.04236238f, -0.05894101f, 
    -0.07229369f, -0.04672767f, -0.01767025f, -0.00496648f, 0.03523452f, -0.13111138f, -0.00348320f, 0.03988602f, 
    -0.06346720f, 0.00315350f, 0.01989193f, -0.06528085f, -0.06922510f, -0.02558040f, 0.10544375f, 0.02063563f, 
    0.04618864f, -0.08252968f, 0.22731806f, 0.12696801f, -0.00654096f, -0.12719201f, -0.12232482f, -0.05362124f, 
    0.03138399f, 0.07841878f, 0.02713066f, 0.03386920f, 0.03762450f, -0.06518046f, 0.00395942f, -0.01225958f, 
    -0.09620592f, -0.04613966f, 0.02320627f, 0.02918916f, 0.10616928f, 0.08186436f, 0.20937790f, 0.03278361f, 
    0.02350547f, -0.13171346f, -0.10942721f, -0.12738366f, 0.09637482f, 0.10584418f, 0.11589750f, 0.13830084f, 
    -0.02006365f, -0.08980078f, 0.01852980f, -0.01921761f, -0.06784183f, -0.00288871f, 0.02084620f, -0.06090327f, 
    -0.03136123f, 0.10777906f, 0.18825927f, 0.09887927f, -0.17042689f, -0.13390277f, -0.04278835f, -0.08685411f, 
    0.03625749f, 0.04149462f, 0.03277510f, -0.03584353f, 0.02542684f, 0.01930577f, -0.04139577f, -0.04646239f, 
    -0.05437380f, 0.10717372f, 0.04031591f, 0.02388503f, -0.13706371f, -0.24903303f, 0.20822948f, 0.12885970f, 
    -0.03137192f, 0.21113591f, 0.02329884f, -0.06873825f, -0.02997136f, -0.09375253f, 0.04549761f, 0.03743104f, 
    0.04172326f, -0.00414837f, -0.04226700f, 0.08537715f, -0.00061168f, 0.09584883f, 0.07664067f, 0.02835201f, 
    -0.25542581f, 0.16744612f, 0.26553923f, 0.05080650f, -0.03860012f, -0.00935828f, 0.08260819f, 0.06858891f, 
    0.06260895f, 0.03635644f, -0.08990022f, 0.00430836f, 0.02294056f, 0.14926995f, 0.12354332f, -0.01263634f, 
    0.04305333f, -0.03669267f, 0.07370184f, -0.02023527f, -0.20439804f, -0.11807555f, -0.08413015f, 0.14285333f, 
    -0.08296181f, -0.12258875f, -0.06587093f, -0.14222011f, 0.07748687f, -0.10429803f, -0.10503810f, 0.02240494f, 
    -0.01539946f, -0.09437548f, -0.01229315f, -0.09242538f, -0.01567118f, -0.00370632f, 0.01242476f, -0.11001378f, 
    -0.00072110f, -0.05690015f, -0.26305479f, 0.03442564f, 0.14614175f, 0.10675780f, -0.08152898f, 0.00589946f, 
    0.10346292f, -0.01979903f, -0.03878988f, 0.00505106f, 0.08991661f, -0.06608707f, -0.00658400f, -0.00915424f, 
    0.10518389f, 0.19028047f, -0.16120194f, 0.02360717f, -0.27378088f, 0.13097465f, 0.40843871f, -0.03169449f, 
    0.08193837f, 0.09934603f, 0.01526847f, -0.01565422f, -0.19026658f, -0.05306366f, 0.09065787f, -0.01873601f, 
    0.18529807f, 0.09344193f, -0.08796685f, 0.19635434f, 0.08029547f, 0.12904735f, -0.13319038f, -0.05091294f, 
    -0.04670234f, -0.18876624f, -0.34298995f, 0.00163366f, 0.15438241f, 0.14165443f, 0.14993548f, -0.08602412f, 
    -0.01421018f, 0.09930131f, 0.11258664f, -0.09229998f, -0.12616371f, 0.07887758f, -0.03388030f, -0.07023618f, 
    0.03648686f, -0.02030715f, 0.11711848f, 0.07461588f, -0.06033634f, -0.27812746f, -0.16133121f, 0.06503733f, 
    0.15601677f, 0.10631227f, 0.00033563f, -0.18901357f, 0.04076875f, -0.04325593f, -0.05212351f, 0.06316422f, 
    0.01688175f, -0.00542967f, 0.10410938f, 0.09933219f, 0.03313619f, -0.05058062f, 0.16373569f, 0.05945810f, 
    0.06610325f, -0.06467181f, -0.08678128f, -0.00011044f, 0.18843335f, 0.11254373f, -0.10038877f, 0.03209597f, 
    0.14425009f, 0.06100763f, 0.00649692f, -0.00556512f, -0.06303612f, 0.05298315f, 0.13265075f, -0.00352511f, 
    0.08098690f, 0.18532822f, 0.07489834f, 0.05811483f, -0.03572550f, 0.49172688f, -0.29928851f, 0.05744984f, 
    -0.19926108f, 0.11887040f, 0.07403621f, -0.17430179f, -0.38444695f, 0.04680335f, 0.09705202f, 0.09215219f, 
    0.03535000f, 0.02196459f, -0.05272027f, 0.07028640f, 0.16250421f, 0.15437993f, -0.19233276f, -0.14653379f, 
    -0.29500878f, 0.01955836f, 0.02443790f, 0.00896796f, -0.04782301f, -0.12349997f, -0.01724526f, 0.00890291f, 
    -0.02671276f, -0.10483334f, -0.03616381f, 0.05554767f, 0.08800275f, 0.08515253f, 0.14468405f, 0.02909709f, 
    -0.04604633f, -0.25200611f, -0.08892400f, -0.02791796f, 0.46978661f, 0.26940197f, -0.11539658f, -0.30448467f, 
    0.05618589f, 0.02501055f, 0.13950056f, -0.08228407f, -0.04639257f, -0.10753417f, 0.06634355f, 0.00248526f, 
    -0.02030463f, 0.00922121f, -0.02374316f, 0.02450408f, 0.01388595f, -0.05998344f, 0.18756501f, -0.06685399f, 
    0.11589113f, -0.01769828f, 0.00404848f, 0.00644226f, 0.10523043f, 0.04698928f, 0.09944837f, 0.05266330f, 
    -0.10527717f, -0.10678320f, -0.03238168f, -0.00161979f, 0.11389469f, -0.06254910f, 0.01406715f, 0.02825113f, 
    -0.05959550f, -0.19572216f, 0.05945748f, -0.00264901f, -0.05745863f, -0.14976518f, 0.01088800f, -0.16431133f, 
    -0.01486515f, -0.01452622f, -0.00491723f, -0.14821076f, -0.13144746f, -0.09380370f, -0.01189780f, 0.16901742f, 
    -0.03979125f, 0.12141271f, 0.01907530f, -0.07534745f, 0.07361165f, -0.12860242f, 0.00246221f, -0.08440938f, 
    -0.29567933f, -0.07504399f, 0.04667421f, -0.10941392f, 0.06948994f, -0.02186514f, -0.04913993f, 0.14724381f, 
    0.04880596f, -0.01376510f, 0.02925466f, -0.03071126f, 0.09779924f, 0.04279061f, -0.04160342f, 0.00970609f, 
    -0.07241816f, -0.01611442f, 0.01955793f, 0.01510328f, -0.14114387f, -0.13983054f, -0.19374534f, 0.07032493f, 
    0.29890808f, 0.02045485f, -0.02343986f, 0.15600395f, 0.05647221f, 0.07978720f, 0.04905405f, 0.07987920f, 
    -0.07244784f, 0.05905320f, -0.02092701f, -0.00975406f, -0.04549650f, 0.00411674f, -0.03051228f, 0.04710510f, 
    -0.09076916f, 0.13952738f, 0.20169006f, 0.11693047f, -0.01694509f, 0.05482820f, 0.00743280f, -0.02395997f, 
    -0.00150892f, -0.07483539f, 0.09863916f, 0.00936158f, -0.08735696f, 0.19103573f, 0.02503202f, -0.08187148f, 
    0.08394308f, -0.03921385f, 0.19440196f, -0.00910230f, 0.13545404f, -0.00911901f, 0.02490795f, 0.17334242f, 
    0.09242167f, -0.00340346f, 0.10039454f, 0.07967089f, -0.07974878f, -0.01980390f, 0.03667197f, -0.02950498f, 
    -0.00986566f, 0.05430701f, 0.02935583f, 0.04412983f, 0.05489600f, 0.20804797f, 0.03384621f, -0.11689192f, 
    0.48163220f, 0.14095652f, 0.18395348f, 0.07220713f, -0.04988768f, 0.00194642f, 0.07336628f, 0.14126158f, 
    -0.01280224f, -0.02865899f, 0.05214518f, 0.05772197f, 0.04921018f, 0.04639304f, 0.02789855f, 0.03909266f, 
    -0.05811492f, -0.11426105f, 0.09943059f, -0.03669685f, -0.26917529f, -0.24761467f, -0.17556019f, 0.05421555f, 
    -0.05636058f, -0.02620339f, -0.06274398f, 0.10142969f, 0.04629434f, 0.12058775f, 0.01550370f, 0.10299982f, 
    -0.14735411f, -0.01456898f, -0.10209616f, -0.05873897f, 0.06727523f, 0.25374746f, -0.01402814f, -0.10201949f, 
    -0.36113715f, -0.11666011f, 0.11141840f, 0.55459630f, 0.14871050f, -0.11798230f, -0.23373039f, 0.07334120f, 
    -0.04341788f, 0.09815113f, -0.03412422f, -0.01379480f, -0.01357360f, 0.01069541f, 0.01824130f, 0.06250656f, 
    0.04089132f, -0.03672599f, 0.03869026f, -0.06330695f, 0.27565682f, -0.25494465f, 0.13877244f, 0.11394503f, 
    -0.09627759f, -0.04709795f, -0.03106353f, 0.23617950f, 0.19580698f, 0.09077152f, -0.01582098f, -0.01915515f, 
    -0.01104301f, 0.18841511f, 0.07107319f, 0.08020006f, -0.19171567f, -0.02888961f, 0.05919022f, 0.08402465f, 
    -0.25286946f, -0.16866039f, 0.09781966f, 0.26035309f, -0.01281867f, 0.04041825f, 0.14331931f, 0.17027958f, 
    0.07056811f, 0.07138959f, 0.08819237f, 0.04801173f, 0.13764407f, 0.08200230f, 0.06004160f, 0.09780782f, 
    0.01594299f, 0.01838014f, 0.05868309f, 0.00770882f, -0.09010196f, 0.23839630f, 0.09564775f, 0.28136212f, 
    -0.02935357f, 0.04740816f, -0.10291247f, 0.14573993f, -0.04093512f, 0.24378356f, 0.00690270f, 0.04016902f, 
    -0.02178333f, -0.01297015f, -0.02672937f, -0.06001011f, 0.05624299f, -0.18364024f, -0.11101341f, 0.02656481f, 
    -0.36545336f, 0.04244197f, 0.09855211f, 0.18054615f, -0.27998093f, 0.06952391f, -0.01204832f, -0.11101894f, 
    0.07845705f, 0.13635702f, 0.06854413f, 0.01116250f, -0.03359100f, -0.02967205f, -0.06580216f, 0.03640470f, 
    0.05074721f, -0.07856748f, 0.05243851f, 0.05896069f, 0.04353331f, -0.34149382f, 0.15501326f, 0.00584829f, 
    -0.03224127f, -0.01643359f, 0.10660613f, 0.03880944f, 0.23726039f, 0.12731361f, -0.03295489f, -0.14164819f, 
    0.04964278f, 0.07359028f, 0.04296422f, 0.04703709f, -0.04863311f, -0.01127444f, 0.15366803f, 0.10225885f, 
    0.32448402f, 0.25603330f, 0.16170521f, 0.16939400f, 0.01763017f, -0.03285167f, -0.07180176f, -0.02100412f, 
    -0.10098746f, -0.10969734f, 0.16999693f, -0.03642987f, -0.21760577f, -0.09678175f, -0.07842927f, -0.10165619f, 
    -0.09965914f, -0.02024039f, -0.02738947f, -0.05631185f, -0.04440430f, -0.24631497f, 0.14390939f, 0.07075442f, 
    -0.05685686f, 0.16372317f, 0.12436794f, 0.05227490f, 0.05686359f, 0.16867943f, 0.03501193f, 0.05526417f, 
    0.15930276f, 0.20852137f, -0.05790273f, 0.00502606f, 0.16518518f, 0.04102989f, -0.03315507f, -0.01506953f, 
    0.00105515f, 0.06598572f, -0.16426726f, 0.06280994f, -0.15968692f, -0.03873023f, -0.03498969f, -0.05657280f, 
    -0.06110794f, 0.04601783f, -0.10224784f, -0.05386175f, -0.04086061f, 0.15586439f, -0.19934179f, 0.04557026f, 
    -0.02135764f, 0.06986860f, 0.02763707f, 0.08072529f, 0.07453750f, -0.00941593f, 0.10447925f, -0.06044633f, 
    -0.03083404f, -0.00644425f, 0.06398406f, 0.06238068f, 0.01618704f, -0.04243803f, -0.05423709f, 0.00445056f, 
    0.16893382f, -0.00164806f, -0.07452303f, -0.06333002f, -0.07638970f, 0.09630089f, 0.04142498f, -0.05878741f, 
    0.19742784f, -0.19247927f, -0.26158971f, 0.02389784f, -0.38053095f, -0.13656893f, 0.03771038f, -0.10662152f, 
    -0.02270138f, 0.00169002f, -0.07775667f, -0.02617967f, -0.02473611f, -0.10714694f, -0.11293928f, 0.01967812f, 
    -0.02683794f, -0.06065705f, 0.00296087f, 0.04072305f, -0.04385543f, -0.28922161f, -0.04853207f, -0.00217396f, 
    -0.37339288f, -0.00627335f, 0.01381542f, -0.17681763f, 0.04487431f, 0.04415017f, 0.00336252f, 0.03250222f, 
    0.09647670f, -0.06003067f, -0.15265939f, 0.01652400f, -0.02572004f, 0.02007269f, 0.09953441f, 0.10029443f, 
    0.31503114f, 0.04834689f, 0.07098464f, 0.02524304f, 0.01938677f, 0.01623531f, 0.00388094f, 0.04861113f, 
    0.08684822f, -0.07509524f, -0.05932609f, -0.06482461f, 0.09811271f, 0.02335488f, 0.12134668f, 0.09315145f, 
    0.06054804f, 0.00441587f, 0.07688896f, 0.03712599f, 0.13314186f, 0.17455146f, 0.12109502f, 0.35929310f, 
    0.09579423f, 0.04983693f, -0.17364666f, -0.04021361f, 0.06127111f, 0.09535513f, -0.08541075f, -0.00034762f, 
    0.03478768f, -0.01641025f, -0.05308467f, 0.12183699f, 0.02549221f, -0.18243481f, 0.00288732f, 0.11349444f, 
    0.39326242f, -0.02782454f, 0.01360012f, 0.01783629f, -0.10280657f, 0.04023970f, 0.04865359f, 0.03616343f, 
    0.15838760f, -0.07079068f, -0.12219156f, -0.15452488f, 0.00026055f, -0.03426674f, -0.04627227f, -0.07200655f, 
    -0.02753836f, -0.03090971f, -0.06460633f, 0.16285224f, -0.06888627f, -0.12438161f, 0.20353627f, 0.02071331f, 
    -0.04950533f, -0.07008670f, 0.11570738f, 0.07344257f, 0.05292859f, 0.05302171f, 0.00294666f, -0.01817280f, 
    0.06330156f, -0.02250286f, 0.04736189f, -0.04388600f, 0.01955174f, -0.10089874f, 0.00027523f, 0.01677166f, 
    0.01469147f, -0.04966579f, -0.02588989f, 0.00957113f, 0.02501604f, -0.04489132f, -0.04191370f, 0.00577045f, 
    -0.03205210f, -0.05301824f, 0.03750161f, 0.00908577f, -0.05809603f, -0.00294813f, -0.05427369f, 0.02863331f, 
    0.02110958f, 0.01523096f, -0.06215443f, -0.04595510f, 0.02980190f, -0.04124033f, -0.01844486f, 0.03769688f, 
    0.00602185f, -0.00642728f, -0.02058229f, -0.03564458f, -0.04470958f, -0.01588255f, -0.00229735f, 0.04489786f, 
    -0.04292400f, -0.05502421f, -0.00776460f, 0.03092280f, -0.02236869f, -0.01169098f, 0.02928650f, -0.00208970f, 
    0.03957636f, -0.00078125f, 0.02274612f, 0.04430822f, -0.02179875f, -0.05821975f, 0.01332027f, 0.02316886f, 
    -0.01950751f, 0.02544851f, -0.01071258f, -0.03064280f, 0.00073832f, 0.03566566f, -0.01039388f, 0.03608702f, 
    -0.04356378f, 0.01649777f, 0.01416580f, 0.00386417f, 0.03649212f, 0.03671629f, -0.05720003f, -0.04183485f, 
    -0.00743673f, -0.02761110f, -0.05488197f, 0.04664733f, -0.04822746f, 0.04614901f, -0.01161143f, -0.00641573f, 
    -0.03741572f, 0.04297706f, 0.01114909f, -0.05985906f, 0.04782125f, 0.01324206f, -0.02476258f, 0.04657701f, 
    -0.02013958f, -0.02016836f, 0.04396837f, -0.04859148f, 0.00863610f, 0.01182349f, 0.04341721f, -0.02448433f, 
    0.05814006f, 0.02680708f, 0.03153609f, -0.05925369f, 0.04742245f, -0.03017295f, 0.03202551f, -0.02717065f, 
    0.00598257f, -0.02096445f, -0.04855751f, 0.01884067f, 0.04447637f, 0.01565358f, 0.00377686f, 0.04915151f, 
    -0.05186288f, 0.02116469f, -0.02626547f, 0.01979831f, -0.05706983f, -0.00444492f, 0.04152984f, -0.00551573f, 
    0.03866758f, -0.03131267f, -0.04352275f, -0.00114280f, 0.00139872f, 0.04900562f, 0.02945815f, 0.03543506f, 
    0.03225567f, 0.05045363f, -0.04393155f, -0.05542601f, 0.02958749f, -0.02210537f, 0.03298432f, 0.04587076f, 
    -0.02631913f, -0.05338873f, -0.04817218f, 0.04957481f, -0.05383971f, 0.03777666f, 0.04429031f, -0.06005313f, 
    -0.00332508f, -0.00490746f, 0.03087443f, -0.00281904f, 0.03707665f, -0.03270757f, -0.04918113f, -0.06168645f, 
    -0.00223789f, -0.02920108f, 0.01284104f, -0.05441537f, 0.01989615f, 0.00264129f, -0.02575330f, 0.05388202f, 
    -0.05775332f, 0.01985921f, 0.00925349f, -0.02811947f, 0.03385715f, -0.01411197f, -0.03520996f, -0.02051323f, 
    -0.03701542f, -0.04290156f, -0.00546974f, -0.06118660f, -0.01361256f, -0.03766965f, 0.02620102f, -0.02817195f, 
    0.03960860f, -0.00682695f, 0.00432777f, -0.00399863f, -0.00157422f, 0.05149149f, -0.01685844f, 0.02501285f, 
    -0.02466584f, 0.03157341f, -0.05321284f, 0.03313042f, -0.00866381f, 0.01007287f, 0.01767749f, 0.03827476f, 
    0.03751649f, -0.00871682f, -0.01123246f, 0.00428795f, -0.05818510f, 0.04720687f, -0.03466474f, -0.01052090f, 
    0.00582485f, 0.00524333f, 0.04262189f, -0.00023583f, 0.03559132f, 0.02226633f, 0.04259061f, -0.01610305f, 
    -0.00334428f, 0.04738386f, 0.03548212f, -0.01742443f, 0.02217251f, -0.03613545f, -0.06057538f, 0.04746963f, 
    -0.04930506f, 0.04832647f, -0.04044040f, 0.00147695f, 0.03946190f, -0.05561612f, -0.05654768f, -0.03681083f, 
    0.01833386f, -0.01620447f, -0.00262594f, -0.05496601f, -0.00591589f, -0.03868926f, -0.03729638f, -0.00452973f, 
    0.02819733f, 0.02571156f, 0.02715025f, -0.02923143f, 0.01811548f, -0.03528916f, -0.03968520f, -0.03041335f, 
    -0.05547576f, -0.04328566f, 0.04425881f, 0.04623970f, -0.03676622f, -0.06027896f, -0.00434867f, -0.05572958f, 
    -0.03852519f, 0.02893186f, -0.03996589f, 0.02454316f, -0.00269664f, -0.03823286f, 0.03530742f, 0.01399128f, 
    0.02606730f, 0.01989583f, -0.01455757f, -0.03791653f, -0.03361713f, 0.00459668f, -0.05035698f, -0.05961722f, 
    0.00264365f, 0.00592583f, 0.04763724f, -0.02107589f, -0.03858208f, -0.01466672f, 0.02255842f, 0.05541920f, 
    -0.01633108f, -0.03510675f, 0.03700343f, -0.02734696f, 0.02251590f, -0.04040752f, 0.01289127f, -0.02689685f, 
    0.02449480f, -0.03789888f, -0.05836328f, 0.01861945f, 0.01158134f, -0.05154008f, -0.03480546f, -0.03478453f, 
    0.00253274f, -0.02080446f, -0.05055266f, 0.03295796f, -0.04641889f, 0.02384569f, -0.05457751f, 0.02128295f, 
    -0.02448151f, -0.03077883f, -0.03720446f, 0.04643440f, 0.02999272f, 0.04448328f, -0.03697031f, -0.05048290f, 
    -0.06165532f, -0.03909021f, -0.03178686f, -0.04463882f, -0.03636770f, 0.04943572f, 0.03507417f, 0.00058518f, 
    0.03044029f, 0.03867806f, 0.00358545f, 0.03665970f, 0.04252355f, 0.04039173f, -0.01879153f, 0.01323490f, 
    0.03345561f, -0.03753522f, 0.03557893f, -0.00518743f, 0.02298236f, -0.04763484f, 0.01447829f, -0.00308658f, 
    0.05067591f, 0.03124667f, 0.05366534f, 0.00462874f, -0.03111273f, 0.04888719f, -0.01677744f, 0.01959607f, 
    0.00135445f, -0.02721643f, -0.00744973f, -0.01104350f, -0.04088077f, 0.03335000f, -0.00622993f, -0.04315063f, 
    -0.00890203f, -0.03261572f, -0.06195249f, 0.03614892f, 0.02061003f, 0.03575366f, -0.04518469f, -0.03958738f, 
    -0.05196045f, 0.03605450f, 0.03117742f, -0.03743961f, 0.01065008f, -0.00026392f, 0.04021457f, -0.00239232f, 
    -0.02202420f, 0.03248624f, 0.00096183f, 0.03456425f, -0.03898926f, -0.02221412f, 0.01828607f, 0.03867494f, 
    -0.03030555f, -0.04484146f, 0.03188231f, -0.00669860f, 0.02587921f, 0.02188593f, 0.02538168f, 0.00356976f, 
    -0.03007026f, -0.05389857f, 0.02402907f, -0.05139820f, -0.03303823f, -0.02757480f, 0.00728300f, -0.05575254f, 
    -0.06181752f, -0.03280769f, 0.04028445f, 0.03715227f, -0.05002723f, -0.00649088f, 0.04066588f, -0.00046118f, 
    0.00356770f, -0.05281634f, -0.04390799f, -0.02012629f, 0.01775891f, -0.02399155f, -0.00417281f, 0.03335863f, 
    0.02774927f, 0.02766419f, -0.00292426f, 0.03749247f, -0.03363863f, 0.04062529f, 0.01908251f, 0.04556864f, 
    -0.05035079f, 0.00981241f, 0.02413292f, 0.00888786f, 0.01668177f, -0.00729466f, 0.00367772f, -0.04595476f, 
    -0.00445445f, -0.04002133f, -0.05723169f, 0.00654864f, 0.00655601f, -0.03116340f, 0.00994122f, 0.01939159f, 
    -0.03990246f, -0.03971583f, 0.00029187f, 0.02701548f, -0.05667003f, 0.02694616f, 0.00160123f, -0.01477676f, 
    -0.06819101f, -0.05103633f, -0.04159597f, -0.05649390f, 0.02218341f, -0.04614551f, 0.03094130f, 0.01413231f, 
    -0.00676877f, 0.00108829f, 0.01324363f, -0.03241192f, -0.02652481f, 0.01742226f, -0.03162318f, -0.01375660f, 
    -0.05500485f, 0.03248715f, -0.03681476f, 0.01717419f, -0.01836687f, -0.00908550f, -0.03172656f, 0.00542398f, 
    0.01073727f, 0.01917797f, -0.03340384f, -0.04997360f, 0.02596795f, 0.04167121f, -0.00157039f, -0.01820462f, 
    -0.01865316f, -0.01239139f, -0.04928363f, 0.03314428f, 0.00449149f, 0.01646139f, -0.01478089f, 0.00487902f, 
    -0.01147534f, -0.03740891f, -0.00779516f, -0.00050474f, -0.04339454f, 0.04501834f, 0.05126625f, -0.02657380f, 
    -0.05605282f, 0.02692868f, -0.03626056f, 0.01913185f, -0.01660611f, -0.03277150f, 0.01639250f, 0.02350618f, 
    -0.00237417f, -0.00447426f, 0.02755588f, -0.04879494f, -0.05614789f, 0.00889407f, -0.02265670f, -0.01384897f, 
    0.00255940f, 0.00362959f, -0.02391529f, -0.04927583f, 0.03347137f, -0.06000568f, -0.03118706f, -0.06132713f, 
    -0.06052126f, -0.05084547f, -0.02101404f, -0.01999822f, 0.01731895f, 0.02513742f, -0.00565563f, 0.04883453f, 
    0.01735003f, 0.02420863f, 0.01309210f, -0.04526852f, 0.04223866f, -0.05385853f, 0.04618182f, 0.02999348f, 
    0.03471014f, 0.03504190f, -0.04040384f, -0.00786912f, -0.02838673f, 0.00622023f, 0.03657908f, 0.01041242f, 
    -0.01499114f, 0.01157004f, 0.04690532f, 0.00109501f, -0.05407942f, -0.04229632f, 0.04500676f, -0.05777100f, 
    -0.00278938f, 0.01399139f, 0.00404299f, 0.02804813f, -0.03723662f, -0.05361065f, -0.01326534f, -0.02396549f, 
    -0.01861417f, -0.06146773f, -0.00404743f, -0.02495768f, 0.01503863f, -0.00495618f, -0.05056640f, 0.04858931f, 
    0.02905463f, -0.02318710f, -0.04665383f, -0.05757914f, -0.00491357f, 0.03789410f, -0.04384661f, 0.03377630f, 
    -0.04217574f, -0.03461128f, -0.06200320f, -0.01861634f, -0.01013887f, -0.04837190f, 0.01152608f, -0.05502813f, 
    0.02264631f, 0.02632018f, 0.00348325f, 0.03326335f, -0.00066199f, -0.02548317f, -0.04177836f, -0.00082019f, 
    0.04642180f, -0.03635065f, 0.01375880f, -0.05591893f, -0.03206582f, 0.02938906f, -0.03015884f, 0.00365106f, 
    0.01249780f, 0.02231059f, -0.00673995f, 0.01370016f, 0.01187652f, -0.00959075f, -0.02205665f, -0.02341988f, 
    -0.06540805f, -0.05141389f, -0.01578672f, -0.00409343f, -0.05596706f, -0.02978256f, 0.02501020f, 0.02239715f, 
    0.01235057f, -0.00291418f, -0.05621048f, -0.01953337f, 0.02729937f, 0.04808796f, -0.04673097f, 0.00356735f, 
    0.01416873f, -0.01522880f, 0.03191207f, 0.03557583f, 0.03312210f, -0.01306765f, -0.05669419f, 0.00663071f, 
    -0.00522527f, -0.02052634f, -0.03941923f, -0.05498300f, -0.04270240f, -0.02894023f, 0.03433504f, -0.00861627f, 
    0.02702818f, -0.03880775f, -0.02413863f, 0.03560138f, 0.03227471f, -0.02920935f, -0.05970295f, 0.00742702f, 
    0.05010440f, -0.04102681f, 0.00658794f, 0.03818768f, -0.06486117f, 0.03544760f, -0.05537696f, 0.04929853f, 
    0.04511482f, -0.06282295f, -0.05028734f, -0.04742234f, -0.04483350f, -0.01330447f, -0.06531251f, 0.02337193f, 
    0.04892839f, 0.01781323f, -0.05199985f, 0.02099096f, -0.04463711f, -0.02203134f, 0.00348005f, -0.03759054f, 
    -0.05560672f, -0.06160996f, 0.03179275f, -0.06460018f, -0.00105259f, 0.00129728f, 0.03489166f, -0.06256053f, 
    -0.00288170f, 0.00139997f, -0.05297317f, -0.03693622f, -0.00029658f, -0.06033069f, -0.05473281f, -0.02923726f, 
    0.02886255f, -0.02036080f, 0.04810601f, -0.04765313f, -0.02859908f, -0.05369170f, 0.03601881f, -0.05327273f, 
    0.01404855f, -0.04035842f, -0.03020238f, 0.00634483f, 0.03128069f, 0.05047083f, -0.02440664f, -0.05040986f, 
    -0.02700966f, 0.04018192f, 0.00136537f, 0.00019346f, -0.00544771f, 0.03065565f, -0.03772073f, 0.01442846f, 
    0.04187532f, -0.00732499f, 0.01554037f, -0.04558450f, -0.05850032f, -0.02398484f, -0.02854070f, 0.00451426f, 
    -0.03232244f, 0.00759299f, -0.04012773f, 0.03314789f, -0.00415117f, -0.05468526f, 0.02142164f, -0.03201295f, 
    -0.03262099f, -0.01994856f, -0.06198521f, -0.02893897f, -0.03911693f, -0.04248225f, 0.04122710f, 0.00379870f, 
    -0.04944991f, -0.01700375f, -0.02581463f, 0.01771255f, 0.01781009f, -0.02437624f, -0.03404572f, -0.07038415f, 
    -0.05741414f, -0.00394872f, -0.00654393f, 0.01046808f, -0.01583057f, -0.06290594f, 0.03160066f, -0.00375692f, 
    -0.06359122f, 0.01332263f, -0.01165287f, -0.05673162f, -0.00588284f, -0.01826676f, -0.03560209f, -0.01536702f, 
    -0.00469321f, -0.06935185f, -0.05091013f, 0.03348605f, -0.03350154f, -0.04822677f, 0.03176140f, -0.02847240f, 
    0.02223046f, -0.01203781f, -0.00630352f, -0.00112990f, 0.00973768f, 0.04181542f, 0.00891662f, 0.05287813f, 
    -0.01570787f, -0.05291314f, -0.02068071f, 0.05665090f, 0.03918915f, -0.04675721f, 0.02684217f, -0.02329570f, 
    -0.06501245f, -0.05037445f, -0.04682395f, 0.02645717f, 0.00876464f, 0.04187211f, 0.00478780f, 0.00397138f, 
    -0.04021370f, 0.02778388f, -0.05172600f, -0.02877761f, 0.02273713f, 0.00956957f, 0.00944553f, -0.01599223f, 
    0.03375355f, 0.02079212f, 0.04547497f, -0.00481165f, 0.00355098f, 0.04488872f, -0.02561979f, -0.06007114f, 
    0.02745691f, 0.01747452f, -0.05365864f, 0.03822078f, 0.04571712f, -0.02519885f, 0.01672850f, 0.02905071f, 
    -0.05298852f, -0.06486090f, -0.01052930f, -0.01927324f, 0.00223946f, 0.03243082f, 0.01923946f, -0.01769708f, 
    -0.02123620f, -0.04830720f, -0.05042363f, 0.03413266f, -0.00472418f, 0.04192338f, 0.02447280f, 0.03972733f, 
    0.04200492f, 0.01467750f, -0.05172466f, 0.02850159f, -0.03254300f, -0.01222081f, -0.05685170f, 0.03510065f, 
    0.00651768f, -0.06020361f, -0.03970291f, 0.02521342f, -0.04661067f, -0.03366312f, -0.03090373f, 0.03361588f, 
    -0.05377610f, 0.02534973f, 0.04156352f, 0.04051333f, -0.03074091f, 0.04918891f, 0.03486868f, -0.03032794f, 
    -0.05505378f, 0.03314029f, -0.04004482f, -0.00352771f, -0.01169328f, -0.00399973f, -0.01449010f, -0.02976887f, 
    -0.00294200f, 0.03482900f, -0.00884553f, -0.06704531f, -0.02815746f, -0.05188636f, 0.01044827f, -0.02439675f, 
    -0.05531473f, 0.01191112f, 0.02401898f, -0.01390161f, -0.05400222f, 0.02415865f, -0.05783895f, -0.02811513f, 
    -0.03381025f, 0.02998637f, 0.05964771f, -0.01240150f, -0.05993557f, -0.03237726f, -0.05547883f, -0.05003669f, 
    -0.05717278f, 0.03104440f, -0.01320995f, 0.03399603f, -0.05791077f, 0.00630884f, -0.05882545f, -0.06278536f, 
    -0.04688155f, -0.06359933f, -0.02346732f, -0.00852925f, -0.02507661f, -0.00383125f, -0.04362894f, -0.01001408f, 
    0.00423105f, -0.04108234f, 0.04828177f, 0.04159953f, -0.03600667f, -0.02433935f, 0.02886133f, 0.05066549f, 
    -0.03817333f, -0.05456127f, -0.00266199f, 0.02906412f, -0.02832354f, -0.00527356f, -0.05390843f, -0.00227032f, 
    0.01206037f, -0.03791435f, 0.02118623f, 0.01357845f, 0.02281455f, 0.00820586f, -0.01137932f, -0.00075314f, 
    -0.01244350f, 0.01668528f, -0.06319315f, -0.01670328f, -0.03609744f, 0.00226334f, -0.00193942f, -0.04933474f, 
    0.02278101f, -0.04145506f, -0.03013886f, 0.03124997f, -0.06650342f, -0.03811684f, -0.03412025f, 0.02307077f, 
    -0.02421985f, -0.00869994f, -0.00665046f, 0.02998666f, -0.03123920f, 0.04700745f, 0.02253007f, -0.01820657f, 
    -0.02315808f, -0.04200121f, 0.01069298f, -0.03580603f, 0.00800167f, -0.03626711f, 0.03638595f, -0.05106143f, 
    0.02419858f, -0.05815610f, -0.00428176f, -0.03560295f, -0.03705603f, -0.03476447f, -0.05338115f, -0.04568905f, 
    0.02460697f, -0.02995923f, -0.01486678f, -0.04848439f, 0.02462983f, 0.04866663f, 0.03273155f, 0.04040559f, 
    0.03753054f, 0.00388610f, 0.02927899f, -0.01670082f, 0.02662217f, -0.01246740f, -0.00436080f, -0.05951836f, 
    0.31044981f, 0.07530382f, 0.38431844f, -0.16745906f, -0.00567995f, 0.11773094f, 0.26614729f, 0.04072938f, 
    -0.22137119f, 0.05250400f, 0.14577135f, -0.02452591f, -0.06282354f, 0.02390810f, -0.03488050f, 0.02905093f, 
    -0.00284566f, -0.02720539f, 0.00820245f, 0.18382753f, -0.17623669f, 0.01634763f, -0.23177074f, 0.25862065f, 
    -0.09977797f, -0.09393201f, 0.25384846f, -0.16949759f, -0.06312771f, -0.07728093f, -0.11909044f, -0.00155549f, 
    0.10453675f, 0.05517881f, 0.03450348f, -0.00484610f, 0.02193892f, -0.13870588f, 0.12227102f, 0.02871494f, 
    0.08542188f, 0.22518332f, 0.02717810f, -0.07719909f, 0.11230683f, 0.19634259f, -0.05916050f, 0.19263001f, 
    0.01472648f, 0.00351219f, 0.08343421f, 0.16821249f, 0.00853647f, -0.06373764f, 0.01942764f, -0.00987205f, 
    -0.27755922f, -0.10068607f, -0.21227403f, 0.00584593f, 0.27112034f, -0.02461721f, 0.08606526f, 0.08247235f, 
    0.38307002f, -0.00794281f, 0.15877591f, -0.01211813f, 0.39791647f, 0.04268689f, 0.01876123f, 0.02890963f, 
    0.02191153f, -0.05567766f, -0.04434945f, 0.27564347f, 0.08108152f, 0.11874672f, 0.22538559f, 0.07906984f, 
    -0.13049902f, -0.10933939f, -0.12341589f, -0.08934864f, 0.17775360f, -0.02380328f, 0.11183226f, 0.11804599f, 
    -0.22312178f, 0.00183457f, -0.13630743f, 0.05339238f, 0.05394476f, 0.25040975f, 0.10613646f, 0.25863943f, 
    0.23580889f, 0.03418683f, -0.05773832f, 0.24916621f, -0.51283580f, 0.00031000f, 0.73094708f, -0.24678582f, 
    0.29863736f, 0.15614437f, 0.00343807f, 0.02132986f, 0.31299925f, -0.24209419f, -0.06249728f, 0.22601280f, 
    0.02322855f, -0.00132883f, 0.14428420f, 0.04970215f, -0.03574895f, 0.07984263f, -0.30456740f, -0.21171242f, 
    0.24396472f, -0.19814643f, -0.50104332f, -0.29676348f, -0.05062955f, 0.27173322f, 0.08256899f, 0.00828261f, 
    0.09479813f, 0.29142106f, -0.04340612f, 0.01339956f, 0.17412809f, 0.20221104f, 0.10249063f, -0.13852949f, 
    0.18013586f, 0.20034337f, 0.08520964f, -0.02704081f, 0.06770165f, -0.05250145f, 0.04735576f, -0.13694207f, 
    0.26299238f, -0.22638713f, -0.11787722f, -0.01015900f, 0.10263654f, -0.03549082f, -0.09143462f, -0.03597942f, 
    0.00106659f, 0.06960065f, 0.09155838f, -0.08070482f, -0.04984288f, 0.03857278f, -0.24190950f, 0.01150304f, 
    0.02009099f, 0.07002579f, 0.16735630f, -0.03801162f, 0.03606014f, 0.01170783f, -0.12004494f, -0.01600980f, 
    0.19744810f, 0.08707403f, -0.01431125f, 0.02512592f, 0.03217325f, 0.04243395f, -0.01094928f, -0.33777767f, 
    -0.11285137f, 0.11924433f, 0.19180623f, 0.02007112f, -0.19647938f, -0.01021593f, 0.04998245f, -0.06913728f, 
    0.06024864f, -0.06556924f, 0.03489041f, -0.04093801f, 0.14637396f, 0.07023674f, 0.20354326f, -0.05939147f, 
    0.00278692f, -0.01671525f, 0.11813346f, 0.19757465f, -0.12217365f, 0.02160950f, -0.21430843f, -0.27046248f, 
    -0.34284562f, 0.33976254f, 0.29278746f, 0.04972406f, 0.32869738f, 0.07713060f, -0.11984612f, -0.05378835f, 
    -0.11622790f, 0.02926433f, -0.11719460f, -0.03188929f, -0.11599803f, 0.04180883f, -0.04394102f, -0.05396565f, 
    -0.06517538f, 0.00988418f, -0.14297028f, -0.04373865f, 0.10457961f, 0.22642246f, 0.23597550f, 0.01605666f, 
    0.36783591f, 0.07514682f, -0.00573024f, 0.14865436f, -0.03936245f, -0.12931442f, -0.01898231f, -0.07632568f, 
    -0.02709646f, -0.01118539f, 0.03605735f, 0.08259385f, -0.03396949f, -0.02852539f, -0.15303652f, -0.00976854f, 
    -0.18348151f, -0.13140719f, -0.31777585f, 0.29567623f, 0.15634848f, -0.03387072f, 0.04405770f, 0.06198753f, 
    -0.17098114f, 0.00050686f, -0.12480219f, 0.09583926f, 0.07538607f, 0.02727411f, -0.05976449f, 0.09534299f, 
    -0.03902224f, -0.03662835f, -0.22967467f, -0.09966548f, -0.08752611f, 0.11537468f, 0.34008047f, 0.17228447f, 
    0.40704703f, 0.03951068f, 0.29304984f, 0.18314755f, 0.14413787f, 0.11161117f, -0.02280309f, 0.04907054f, 
    -0.09343709f, 0.00193145f, -0.02567848f, -0.03290005f, -0.05081491f, 0.21465211f, 0.10001980f, 0.14187239f, 
    -0.65090621f, 0.16606790f, -0.34247074f, -0.13974899f, 0.18380108f, 0.07952143f, -0.12483168f, -0.10070788f, 
    0.00054964f, 0.04205302f, 0.07426740f, 0.01549840f, 0.06825256f, 0.06575450f, 0.08232566f, -0.08946797f, 
    0.02606470f, 0.23898521f, 0.04483731f, -0.16117410f, 0.05325303f, 0.27863804f, -0.22519368f, -0.00737312f, 
    0.13845155f, 0.13666584f, -0.09447055f, 0.12802945f, -0.00717633f, 0.01936978f, 0.14149761f, 0.02570608f, 
    -0.06457635f, -0.02001315f, -0.03917901f, 0.16353767f, -0.21177189f, -0.14704505f, -0.22019847f, -0.25751171f, 
    -0.12370006f, 0.13713135f, 0.13993216f, 0.07065684f, -0.13722488f, 0.05741496f, 0.05994013f, -0.18999992f, 
    -0.14164470f, -0.12602839f, -0.01546416f, -0.10227190f, -0.06689896f, -0.03650548f, -0.02670497f, -0.07932921f, 
    -0.15054935f, -0.03704582f, 0.03300611f, -0.02739564f, 0.23454314f, 0.00725696f, -0.00128214f, -0.11246163f, 
    -0.04523269f, -0.00447798f, 0.15371855f, 0.16617016f, -0.14230464f, 0.07703266f, 0.22141327f, 0.12269968f, 
    0.17480591f, -0.29726297f, 0.02355329f, 0.08644293f, 0.13887922f, 0.01401982f, 0.02068263f, -0.09113201f, 
    -0.10242590f, 0.04645237f, 0.08820240f, -0.11378843f, -0.04489483f, 0.14471576f, 0.29372817f, 0.21131822f, 
    -0.04174706f, 0.28825831f, 0.02279563f, -0.10402801f, -0.02809834f, 0.01171253f, 0.04907783f, 0.04015599f, 
    0.03993429f, 0.07046631f, 0.06406895f, 0.13789022f, -0.20096490f, -0.00403300f, 0.19864710f, -0.08360681f, 
    -0.13178813f, -0.26055124f, -0.08190915f, -0.13310750f, -0.01878653f, -0.12780191f, -0.09498107f, -0.03692532f, 
    0.06405763f, -0.00343680f, -0.09419978f, -0.08362746f, -0.00198406f, -0.11890307f, 0.01236738f, 0.15266971f, 
    0.03287974f, -0.04378234f, 0.31834781f, -0.05703342f, 0.11718699f, -0.23222055f, -0.18281990f, -0.11949326f, 
    0.04329529f, -0.12090022f, -0.10211989f, -0.03899253f, 0.01915423f, 0.01657649f, -0.08889394f, -0.05324138f, 
    -0.06220122f, -0.18517767f, -0.17870100f, -0.02817960f, -0.03944821f, 0.08998322f, 0.07700098f, -0.11723968f, 
    0.20560963f, -0.09114748f, -0.03180245f, 0.02432487f, -0.07153935f, 0.02297699f, -0.23753361f, 0.07609105f, 
    -0.00136842f, -0.02348800f, 0.01021106f, 0.07655817f, 0.09293339f, 0.15589347f, -0.11981713f, -0.05717606f, 
    0.14864680f, 0.08813678f, 0.00636978f, 0.07646457f, 0.09584601f, 0.20650166f, 0.05331118f, 0.08848400f, 
    0.04310491f, 0.12454701f, -0.10680055f, -0.19836527f, -0.15247537f, -0.13167039f, -0.07195231f, -0.08557235f, 
    -0.11058404f, -0.11990386f, -0.01699965f, 0.01289251f, -0.12060582f, 0.03016720f, -0.03934198f, 0.13286652f, 
    -0.12537682f, 0.09261188f, -0.18477726f, 0.04191418f, 0.07261179f, 0.20300400f, -0.08690969f, -0.05843171f, 
    -0.23252515f, -0.02816930f, 0.00790737f, -0.07053752f, -0.01815845f, -0.03200042f, -0.09694012f, 0.15556678f, 
    0.11623248f, -0.03346078f, 0.12940121f, -0.04068404f, 0.04810497f, 0.16437949f, 0.07005990f, 0.00411344f, 
    0.02056261f, -0.01936065f, -0.22191367f, -0.09151731f, -0.05886616f, -0.08100343f, 0.00338131f, -0.01535704f, 
    -0.08457290f, -0.01119410f, 0.05122648f, 0.01932335f, -0.00854006f, 0.05795611f, 0.01890390f, 0.05803530f, 
    0.07698691f, 0.10024916f, -0.00997733f, 0.06545691f, -0.00014381f, 0.09853771f, -0.15040451f, -0.14425078f, 
    -0.11633332f, -0.00273898f, -0.11714603f, 0.09917275f, 0.02475357f, -0.01619907f, -0.00491511f, 0.09688366f, 
    0.01553745f, 0.15199679f, 0.08138095f, -0.18282387f, 0.08261240f, 0.15064645f, 0.08699696f, 0.08342417f, 
    0.01497519f, 0.09536190f, -0.18177491f, 0.11382118f, 0.06519182f, -0.05241271f, 0.01432890f, 0.04209983f, 
    0.03335707f, 0.09262572f, 0.06866710f, 0.01755478f, -0.06868081f, 0.17613602f, -0.03523454f, -0.12342563f, 
    0.27289996f, 0.04730197f, 0.06775007f, 0.08338030f, 0.08843913f, 0.21241555f, -0.15353122f, 0.04646988f, 
    0.06752479f, -0.00695484f, -0.01357091f, -0.01897936f, 0.08572832f, 0.04842264f, 0.02653367f, 0.08148567f, 
    0.08776746f, -0.02010256f, 0.02559483f, -0.01831991f, 0.14864658f, -0.00901228f, 0.10111637f, 0.07364544f, 
    0.00994210f, 0.01719203f, 0.03866832f, 0.09881608f, 0.02931513f, -0.03012909f, 0.03855085f, 0.00455426f, 
    -0.02038869f, -0.07854329f, -0.10911021f, -0.01219839f, -0.51921195f, -0.07685965f, 0.04281022f, -0.13147964f, 
    0.20690505f, -0.30598646f, 0.15589872f, 0.06222684f, -0.00452642f, 0.10640555f, 0.05265202f, 0.11721775f, 
    0.01392990f, 0.01268046f, -0.05005044f, -0.11873116f, -0.10920230f, -0.10711521f, 0.06777886f, 0.02763145f, 
    0.25778481f, 0.04494112f, -0.01352651f, 0.00136351f, 0.09988692f, 0.09667094f, 0.05846158f, 0.02040525f, 
    0.08602236f, 0.17216232f, -0.04391354f, -0.08268265f, -0.05319532f, -0.11607955f, -0.04931362f, -0.15991656f, 
    -0.02775220f, -0.08749558f, -0.03956872f, 0.06157754f, 0.02289810f, 0.08911219f, -0.03737578f, -0.20372266f, 
    0.11040327f, 0.23345250f, 0.22565049f, 0.05399313f, -0.01972997f, -0.03294534f, -0.08293174f, -0.09454478f, 
    -0.02582766f, 0.04718654f, -0.03664871f, 0.09520754f, 0.02454694f, 0.07794991f, 0.13345981f, 0.15779802f, 
    0.03019877f, -0.00060595f, 0.02285115f, 0.01958904f, 0.04050441f, -0.03601991f, -0.00197667f, 0.03031066f, 
    0.02523453f, 0.03830134f, -0.04703546f, 0.04226081f, -0.03043203f, -0.00717111f, 0.04376186f, 0.03656127f, 
    0.03030360f, -0.05872748f, -0.01105692f, -0.05139969f, 0.02983982f, -0.01634490f, -0.02564695f, 0.01111943f, 
    0.04158923f, -0.02494551f, -0.04689982f, -0.04604089f, -0.01113653f, 0.03239609f, -0.00952762f, -0.03094571f, 
    0.01724139f, -0.05169934f, -0.04642829f, 0.01489601f, -0.00200002f, 0.00285430f, 0.00881193f, -0.01314558f, 
    0.01852897f, 0.03859754f, -0.03975458f, 0.02756921f, -0.03349046f, 0.02902853f, -0.00770725f, -0.04276264f, 
    -0.00655258f, 0.00122700f, 0.02481428f, 0.00437981f, 0.01145056f, -0.02267608f, 0.02432211f, -0.03591440f, 
    -0.00235717f, -0.01077903f, -0.03061676f, 0.03374680f, -0.01621178f, -0.01770482f, 0.02406443f, -0.04816721f, 
    0.05205865f, -0.01853648f, 0.02369249f, -0.02640749f, -0.04237656f, -0.01558439f, -0.01204491f, 0.03139327f, 
    0.02534586f, 0.03861413f, -0.05419076f, -0.00474123f, -0.01600764f, -0.01656081f, -0.01046562f, -0.04910514f, 
    0.05222905f, -0.03504231f, -0.01887557f, 0.05361447f, 0.00127247f, -0.00647021f, -0.05522367f, 0.04666689f, 
    0.02422221f, -0.04054505f, -0.03005563f, 0.04072264f, 0.03572263f, -0.00810291f, -0.03101435f, -0.02962172f, 
    0.02620781f, -0.05031202f, -0.01286967f, 0.00952722f, -0.03667460f, 0.00419670f, -0.04487020f, -0.02526110f, 
    -0.05546870f, 0.04639644f, 0.03393035f, -0.03304213f, -0.01384581f, -0.00985312f, -0.03324839f, 0.04177155f, 
    -0.03614218f, -0.00611772f, 0.01563389f, -0.03650045f, -0.04051468f, -0.00756316f, 0.04319381f, -0.05852439f, 
    -0.00821545f, 0.00341972f, -0.05011259f, 0.04334852f, 0.00752598f, -0.05320614f, 0.02019730f, 0.04345065f, 
    -0.03118373f, -0.04272956f, -0.01435911f, -0.04595904f, -0.00749743f, -0.05186198f, 0.02907168f, -0.02301749f, 
    0.03415142f, -0.02218628f, -0.05803332f, -0.05582386f, 0.02109857f, -0.01919030f, -0.02329252f, -0.01886331f, 
    -0.05818783f, 0.04777802f, 0.02138897f, -0.00047469f, -0.03834515f, 0.00640148f, -0.02703255f, 0.02959556f, 
    -0.02924316f, 0.00812139f, -0.02962609f, 0.03107158f, -0.01910875f, 0.04670477f, -0.04897759f, -0.00228381f, 
    -0.03770394f, -0.06436574f, 0.02390666f, -0.00157952f, -0.04601106f, 0.01955166f, 0.01664400f, 0.04610764f, 
    -0.04713295f, -0.02309050f, -0.03431304f, -0.04190043f, -0.03350057f, -0.03055724f, -0.05445750f, 0.01444821f, 
    -0.00164867f, -0.00676327f, -0.05621571f, -0.01950697f, -0.04745694f, -0.01201319f, -0.05921748f, 0.00951092f, 
    -0.03005268f, 0.01470082f, 0.05057758f, 0.04081867f, -0.04198009f, 0.03634998f, 0.01704470f, 0.04316438f, 
    -0.00465770f, 0.04350718f, -0.01170838f, -0.04793804f, 0.01217122f, -0.05413410f, -0.03628169f, -0.03165216f, 
    -0.00669116f, 0.02525410f, 0.03889371f, 0.00002112f, -0.01759708f, -0.05402768f, 0.03895932f, -0.03878282f, 
    -0.04972034f, 0.04330378f, -0.03551779f, -0.04154739f, -0.03436900f, 0.04332301f, -0.05544652f, 0.01258239f, 
    0.03221807f, -0.01469265f, 0.00567888f, 0.01682881f, -0.05727379f, -0.02027939f, -0.02478649f, 0.00077361f, 
    -0.04866457f, -0.05056584f, 0.04373591f, -0.03401624f, -0.05722807f, 0.03205587f, 0.00037148f, -0.02905983f, 
    -0.03597901f, -0.04636139f, -0.00142393f, -0.03404581f, 0.02745372f, 0.02696306f, -0.02442924f, -0.03994477f, 
    -0.03020085f, 0.01767477f, 0.01837890f, -0.02091115f, 0.00934657f, 0.00269583f, -0.04994024f, 0.01097254f, 
    -0.02617931f, -0.02969649f, -0.03103751f, -0.02392520f, -0.01573340f, 0.02488398f, 0.03093890f, 0.02236155f, 
    -0.05621650f, -0.04574998f, 0.02160584f, -0.02571405f, 0.01997840f, 0.01359375f, 0.04474990f, -0.02206923f, 
    0.04421877f, -0.00676929f, -0.02011793f, -0.04925926f, -0.03903451f, -0.05363612f, -0.01294241f, 0.01819940f, 
    0.01447462f, -0.00736348f, 0.02581550f, -0.03258218f, -0.02156445f, 0.03304419f, -0.03090885f, -0.01033988f, 
    0.03944923f, -0.04314009f, 0.03151353f, -0.03262792f, -0.05275278f, 0.03946060f, 0.03533606f, 0.01851195f, 
    -0.00384077f, 0.01004512f, -0.04807791f, -0.00671313f, -0.02098072f, 0.05264831f, 0.04137298f, -0.04154438f, 
    0.02572840f, 0.04567691f, -0.00226694f, 0.03868359f, 0.02251448f, -0.03087000f, 0.04661847f, -0.01586774f, 
    -0.04857872f, -0.05983220f, -0.01372012f, 0.00856353f, -0.05138743f, -0.04194466f, -0.01765080f, -0.00356591f, 
    -0.01588061f, 0.01846747f, -0.03500118f, 0.02233029f, -0.00360372f, -0.01877780f, -0.01981791f, -0.00836336f, 
    0.04848896f, 0.01787185f, -0.02100979f, -0.02359111f, 0.02874901f, -0.00135288f, -0.00284134f, 0.01034366f, 
    -0.03983179f, -0.05516811f, -0.02324177f, -0.04179969f, -0.05422925f, -0.02061277f, -0.00490341f, 0.04727224f, 
    0.04136269f, -0.01043594f, -0.01698029f, 0.00366396f, -0.04345546f, -0.04162000f, 0.04839475f, 0.04948732f, 
    0.00399408f, -0.02551899f, 0.03191188f, 0.02359999f, -0.05382977f, -0.04477981f, -0.03352443f, 0.00570939f, 
    -0.05675707f, 0.02536042f, -0.03469202f, -0.03749652f, 0.03384968f, -0.04161501f, 0.00301614f, 0.02620826f, 
    -0.02141977f, -0.04439643f, -0.04564720f, -0.05599904f, -0.02151323f, -0.00073421f, -0.02750738f, -0.03066459f, 
    0.03051485f, 0.00968734f, -0.03668083f, -0.04384028f, -0.00057477f, 0.01694360f, -0.00669733f, -0.01253429f, 
    -0.03179495f, -0.02869652f, 0.03487204f, -0.01601166f, 0.04459697f, 0.03406867f, 0.00502402f, -0.05519849f, 
    0.00350322f, 0.04044111f, -0.00436952f, -0.03868521f, -0.00308945f, -0.00864149f, -0.01273893f, -0.02170554f, 
    -0.01609772f, 0.01723653f, 0.02260652f, 0.01447952f, 0.00049685f, -0.05747972f, 0.04694501f, 0.03901753f, 
    -0.03412097f, 0.00701652f, -0.05141528f, -0.01582279f, -0.02195247f, -0.00779203f, 0.00219603f, 0.02453208f, 
    -0.04529796f, 0.01601759f, 0.02687258f, 0.02146535f, 0.00119579f, 0.04362104f, -0.01328671f, -0.03819560f, 
    0.00049596f, -0.01883946f, 0.01014958f, 0.00598059f, 0.00116088f, -0.01524868f, 0.03765150f, -0.00809515f, 
    -0.04251229f, 0.01885302f, 0.01423648f, -0.05424953f, -0.04757196f, 0.03514166f, -0.03412173f, 0.04604049f, 
    -0.04194109f, 0.02968751f, -0.01342555f, 0.02706951f, -0.03934040f, -0.05212896f, -0.05783634f, -0.01336510f, 
    -0.01694926f, 0.00640819f, 0.01520252f, 0.01313460f, -0.03875038f, 0.00756049f, 0.02230031f, 0.00434389f, 
    -0.05039778f, -0.00731299f, 0.02499716f, 0.03147433f, -0.02267608f, -0.04354702f, -0.05888313f, 0.03023991f, 
    0.01484043f, -0.02306504f, -0.03465810f, -0.05566936f, -0.05700527f, -0.03836779f, -0.05597014f, -0.06120408f, 
    -0.06046774f, -0.03283763f, -0.01905610f, -0.04578172f, 0.01216527f, -0.01003324f, -0.02078692f, 0.01091264f, 
    -0.02624798f, -0.00401507f, 0.00829208f, 0.04999303f, -0.03571230f, 0.02281790f, -0.04761728f, 0.02160997f, 
    -0.00354766f, -0.04781729f, -0.00170734f, 0.00535782f, -0.01833246f, 0.04551952f, 0.03913671f, -0.05289005f, 
    0.04573078f, 0.04668726f, 0.04880760f, -0.03487983f, -0.00697231f, 0.01045238f, -0.06186831f, -0.04620638f, 
    -0.02545119f, -0.00618786f, -0.05642800f, -0.01242755f, -0.02149479f, 0.01475470f, -0.00697783f, 0.04783718f, 
    0.04265670f, -0.00418039f, -0.01219131f, 0.04964578f, 0.04128080f, -0.04068494f, 0.02996670f, 0.00875634f, 
    0.00413045f, -0.03010190f, 0.02876060f, -0.05655615f, 0.03584781f, -0.03697436f, -0.03104733f, 0.03795991f, 
    0.04868864f, 0.01908322f, -0.02192251f, -0.06082414f, 0.00933594f, 0.01125588f, -0.04662082f, -0.02777231f, 
    0.03607243f, -0.04638854f, 0.00606465f, -0.02776545f, 0.02009911f, 0.04840170f, 0.02802129f, -0.04551671f, 
    0.02322222f, -0.01033554f, -0.04167459f, 0.01399511f, 0.02817507f, 0.03545111f, 0.02080343f, -0.01236670f, 
    -0.03182523f, -0.02731298f, -0.04448457f, 0.04733549f, -0.00493038f, 0.04120854f, 0.03463251f, 0.05175611f, 
    -0.00771803f, 0.00839050f, -0.02029814f, 0.01425154f, -0.02217985f, -0.06412939f, -0.04295105f, 0.03169581f, 
    0.03741891f, -0.05272038f, 0.05193721f, 0.03614785f, 0.02551565f, -0.02818450f, -0.01922687f, -0.02276012f, 
    -0.00373142f, 0.01469310f, -0.04764230f, 0.03205682f, 0.01380490f, 0.00901328f, -0.05563673f, -0.05002708f, 
    -0.05779578f, 0.01996621f, -0.00486301f, 0.03679842f, -0.03170340f, 0.01264535f, -0.01126052f, -0.02283318f, 
    -0.01533834f, -0.02834446f, -0.02846754f, 0.01609649f, -0.03727403f, 0.03607776f, 0.03799655f, 0.00431305f, 
    -0.02952584f, -0.06124168f, -0.01353742f, -0.06041966f, -0.00219557f, 0.03282871f, 0.00241203f, -0.04806684f, 
    0.03943570f, -0.03949227f, -0.02230593f, 0.02784414f, 0.03943738f, -0.03345792f, -0.01982531f, -0.04614949f, 
    0.02999298f, -0.02649896f, -0.00537942f, -0.02733390f, -0.03657253f, 0.03474413f, -0.01192274f, -0.01578270f, 
    0.03869133f, -0.02822477f, 0.02118130f, 0.04256051f, 0.02581838f, 0.01453453f, -0.00231165f, -0.00444833f, 
    -0.01221468f, -0.04074170f, -0.06095017f, -0.03557186f, 0.01222783f, 0.04294379f, 0.02477370f, -0.03397446f, 
    0.03342526f, -0.05802237f, 0.01251859f, -0.00773863f, 0.01335633f, -0.02919545f, 0.01400881f, -0.04755232f, 
    -0.23081936f, -0.01755768f, 0.04389723f, 0.23012093f, -0.17005758f, -0.10011262f, -0.25641626f, 0.10575859f, 
    -0.17715435f, 0.06123854f, -0.09628084f, -0.06139512f, -0.08268979f, -0.06243473f, -0.03206756f, -0.11650481f, 
    -0.09101511f, -0.11847313f, -0.17775324f, -0.03137553f, 0.20569851f, -0.20158747f, 0.14775747f, -0.07920738f, 
    -0.12368796f, 0.29123029f, 0.11437050f, -0.03637331f, -0.02376174f, 0.14200565f, 0.23499230f, 0.19489247f, 
    -0.07436278f, -0.02729423f, -0.08796744f, 0.03875052f, 0.08650573f, -0.20142770f, 0.05262110f, -0.02445929f, 
    -0.14051108f, 0.20847064f, 0.31747264f, 0.03675699f, -0.02988565f, 0.14924048f, 0.03339792f, 0.15936384f, 
    0.13332629f, 0.18767850f, 0.09543303f, 0.10725864f, -0.15103877f, 0.02786668f, -0.10895780f, -0.08505443f, 
    -0.12867603f, -0.03784542f, 0.14474653f, -0.06796411f, 0.00616726f, 0.10674585f, 0.05353348f, 0.08748235f, 
    -0.09187088f, -0.24724273f, -0.28531268f, -0.17006542f, -0.06819411f, 0.21909919f, -0.12508947f, 0.08586807f, 
    -0.07175354f, 0.01448619f, -0.17421283f, -0.14381726f, 0.16287330f, -0.32101578f, -0.02440016f, -0.05671035f, 
    -0.22599737f, -0.01392744f, 0.28312868f, 0.16648062f, -0.11723807f, -0.10443593f, -0.11582009f, -0.15866958f, 
    -0.15816969f, -0.10903832f, -0.08951268f, -0.23287742f, -0.02116114f, -0.23168938f, -0.10370787f, -0.04078887f, 
    -0.00633733f, -0.23694924f, -0.21445172f, -0.07726675f, 0.19048801f, -0.01600421f, -0.02875895f, -0.07394499f, 
    0.07383455f, 0.15471159f, 0.07606656f, 0.09289148f, -0.13050297f, -0.00018289f, 0.16361791f, 0.04016909f, 
    0.08781596f, 0.15764904f, -0.13688588f, -0.11194216f, 0.11638325f, -0.08639638f, 0.00470723f, 0.27344450f, 
    0.08468302f, 0.06051488f, 0.09443182f, 0.10656573f, 0.23638898f, 0.04640919f, -0.02656093f, -0.01594224f, 
    0.07800037f, 0.06962480f, 0.27065548f, 0.10392500f, 0.02683642f, 0.12132127f, 0.04280889f, -0.01373040f, 
    -0.07035294f, -0.02799003f, 0.00585421f, 0.09501147f, -0.44152117f, -0.05142620f, -0.02064400f, 0.03385803f, 
    0.14353238f, 0.06658538f, -0.08323613f, 0.06851619f, 0.00487964f, 0.09745408f, 0.14723308f, 0.08425466f, 
    0.04674158f, -0.01565651f, -0.06006817f, 0.12964298f, 0.04491572f, -0.00454300f, -0.00239941f, 0.00016222f, 
    -0.17227332f, 0.02731065f, -0.08852176f, 0.15947162f, -0.07352264f, -0.04813719f, 0.00489082f, -0.09774201f, 
    0.10458260f, 0.04052382f, 0.28810075f, 0.05033386f, 0.11600437f, 0.02053833f, 0.11037192f, 0.05423111f, 
    -0.02395558f, 0.05186406f, -0.09462278f, 0.01943436f, -0.15526031f, 0.03671147f, 0.12979694f, 0.06333461f, 
    0.08802392f, 0.04093123f, 0.03652896f, -0.07204448f, 0.01882099f, -0.04123751f, 0.05649573f, -0.00830667f, 
    -0.07124285f, -0.11091379f, -0.09502591f, 0.01013697f, -0.04624445f, -0.14813887f, -0.00523024f, 0.08116497f, 
    0.03804411f, -0.24097206f, -0.01745738f, 0.14181246f, -0.28722155f, -0.01294004f, -0.01853141f, 0.01614851f, 
    0.04064563f, -0.08213358f, 0.10385875f, -0.05065047f, 0.10914008f, 0.03611876f, 0.00412394f, -0.08549625f, 
    -0.07058617f, 0.01290499f, -0.10728693f, -0.07309602f, -0.27509928f, 0.01149378f, 0.17620833f, 0.17789359f, 
    -0.19977218f, 0.00178861f, -0.03770623f, 0.01808919f, -0.12497033f, 0.08752898f, 0.00971294f, 0.00061190f, 
    -0.05563334f, 0.00377678f, 0.03019944f, -0.10426825f, -0.02502652f, -0.13931240f, -0.10897558f, 0.04345706f, 
    0.12663835f, 0.03933364f, 0.04903758f, 0.02854396f, 0.20793822f, 0.18074454f, 0.16064134f, 0.08897804f, 
    0.06463593f, 0.04778871f, 0.19980600f, 0.09784945f, 0.05538908f, 0.11511850f, 0.07625821f, 0.13880365f, 
    0.11705640f, -0.04067829f, -0.04528803f, -0.06218671f, 0.22433317f, 0.17920157f, -0.18970190f, 0.11817373f, 
    0.05589690f, -0.07278889f, -0.06182915f, 0.02708536f, 0.09212444f, 0.21387784f, -0.04817320f, -0.00535063f, 
    -0.05634017f, 0.01404385f, -0.04871345f, -0.06360888f, 0.06601959f, 0.06522081f, -0.00922248f, -0.07689296f, 
    0.28465900f, -0.02622074f, 0.10131944f, -0.03405393f, 0.11394852f, -0.05709652f, -0.06013299f, -0.05707443f, 
    0.02358444f, 0.02275584f, 0.14352927f, 0.16189350f, 0.16198175f, 0.02034925f, 0.04517234f, -0.01652575f, 
    -0.01837373f, 0.11555247f, 0.02798281f, 0.07161218f, 0.26669118f, -0.09021787f, 0.24308400f, -0.06004833f, 
    -0.08509386f, -0.00066774f, -0.01775308f, -0.00333086f, 0.06009620f, 0.00060487f, 0.17463863f, 0.00318399f, 
    -0.13292059f, -0.03009216f, -0.01876011f, -0.10027546f, -0.06459325f, -0.08498727f, -0.02051348f, -0.07533695f, 
    0.36753184f, 0.29577416f, -0.13508300f, -0.01086623f, -0.02569981f, -0.00302548f, 0.07626355f, -0.00233557f, 
    0.30785364f, 0.15868096f, 0.00229823f, 0.06313742f, 0.04185171f, -0.05405853f, -0.18977372f, 0.12297836f, 
    0.00086037f, 0.05040830f, -0.04942233f, 0.03807204f, -0.68244988f, 0.21871677f, 0.25152498f, -0.29616231f, 
    -0.19303665f, -0.24891540f, -0.09108859f, 0.03457173f, -0.04501581f, -0.06488925f, -0.07722335f, 0.14252527f, 
    0.14142956f, -0.14828266f, 0.03798724f, -0.19505376f, -0.06407348f, -0.01756022f, -0.09326208f, -0.07550484f, 
    0.36424658f, -0.02434439f, -0.26166254f, 0.10025699f, -0.16137429f, 0.09726173f, 0.15543193f, -0.01285629f, 
    0.00652824f, 0.20402558f, 0.12819749f, 0.12285183f, 0.12508920f, 0.00975848f, 0.00479006f, -0.18113969f, 
    -0.10534304f, -0.49110132f, 0.12874360f, -0.13411435f, -0.02735589f, 0.04841874f, 0.16716030f, -0.15564600f, 
    -0.26308438f, 0.01901789f, 0.17275071f, 0.00855670f, 0.02288036f, 0.27484873f, -0.09546461f, -0.04918839f, 
    -0.08594846f, 0.07924496f, -0.01276144f, 0.03932659f, 0.24801630f, 0.01094320f, 0.29736581f, 0.35789740f, 
    0.37187248f, 0.04848507f, 0.35247105f, 0.18199733f, -0.00386009f, -0.05043842f, 0.21226895f, 0.07468686f, 
    0.24853837f, -0.01100842f, 0.01950218f, -0.16202565f, -0.06704148f, 0.01763413f, 0.10499716f, 0.15465270f, 
    0.23998943f, 0.27789798f, 0.11009317f, 0.20995107f, -0.52990478f, -0.01673461f, -0.51423150f, 0.05355189f, 
    0.21263497f, -0.37609905f, 0.17150298f, -0.00987285f, -0.54896057f, -0.30221590f, -0.08430612f, 0.15236555f, 
    -0.02717366f, 0.13038203f, -0.25220358f, -0.11880016f, 0.12301037f, 0.06731950f, -0.17741859f, -0.19078873f, 
    0.03786032f, 0.09651037f, -0.00578686f, -0.13438317f, -0.06342087f, -0.32131842f, -0.55926430f, 0.34944564f, 
    0.23663543f, -0.32773539f, 0.10538121f, -0.09522969f, 0.21696457f, -0.01230810f, -0.09250732f, 0.04926392f, 
    -0.05233106f, -0.19207002f, -0.32411492f, 0.09944159f, 0.19575404f, 0.12541269f, 0.08819507f, 0.13616838f, 
    -0.23812677f, 0.17661929f, 0.01854658f, 0.04536025f, -0.24685365f, -0.15689777f, 0.13552177f, -0.08925426f, 
    -0.05978579f, 0.08399130f, -0.04645227f, 0.00744369f, 0.06356196f, -0.21512139f, 0.03929086f, 0.06162907f, 
    0.53770477f, -0.33507648f, -0.06872869f, 0.07536975f, 0.04621124f, -0.03256801f, -0.01568433f, -0.00052643f, 
    -0.11127832f, -0.15735868f, 0.03056961f, -0.03114697f, 0.04064332f, 0.00011371f, 0.25761962f, 0.23644744f, 
    0.19224714f, -0.10811905f, -0.15704674f, -0.01485556f, 0.56698781f, 0.13705964f, -0.43619823f, 0.32772040f, 
    -0.07327584f, -0.01387405f, -0.42498234f, -0.01192569f, -0.30172956f, -0.44737288f, 0.06781265f, 0.00240765f, 
    0.03110511f, 0.04102299f, 0.10843893f, -0.06597593f, -0.30266267f, -0.33211619f, -0.20715986f, -0.30391759f, 
    0.82984030f, -0.14216752f, 0.05648552f, 0.21139470f, 0.26811436f, -0.08602103f, -0.07388671f, 0.14810830f, 
    0.22447798f, -0.32621628f, 0.10912876f, 0.04799297f, 0.03946135f, -0.02111839f, 0.19292159f, -0.05997968f, 
    0.04472079f, 0.12045439f, 0.03498062f, -0.05512797f, 0.58218670f, 0.02253638f, 0.00534429f, 0.05598729f, 
    0.12643325f, -0.00222940f, -0.07071275f, 0.10668491f, 0.07865692f, -0.08152004f, -0.04028393f, 0.18980952f, 
    -0.09407272f, 0.02567218f, 0.32506278f, 0.03595896f, -0.13101712f, -0.02587389f, 0.10630956f, -0.00264523f, 
    -0.62232262f, -0.09188589f, 0.14553557f, -0.14043710f, 0.00273788f, -0.15179484f, -0.05930641f, -0.14018604f, 
    -0.05154297f, -0.08243392f, 0.10950733f, 0.03565533f, -0.09505668f, 0.09641507f, 0.02899677f, -0.00031180f, 
    -0.04325394f, -0.20469622f, -0.24874963f, -0.06440233f, -0.28968266f, 0.05195174f, 0.19642286f, -0.17855263f, 
    -0.14876030f, 0.24107462f, 0.21408418f, -0.01924779f, -0.02314355f, 0.37495118f, 0.04038293f, 0.00300427f, 
    -0.03044407f, 0.06046050f, -0.12359434f, 0.19843724f, 0.02446608f, -0.14950775f, 0.03594069f, 0.07514752f, 
    0.39669108f, 0.06834445f, 0.22532274f, 0.19080858f, -0.24712864f, -0.14449562f, -0.16610517f, 0.20420292f, 
    -0.11104441f, -0.05940033f, 0.11406323f, 0.13541532f, -0.14741004f, 0.02878907f, 0.16703576f, 0.14725052f, 
    0.20503536f, -0.04436177f, 0.25143003f, 0.07669479f, 0.51607674f, -0.13583018f, 0.00987327f, 0.03688298f, 
    0.00397283f, 0.01532391f, 0.04540525f, 0.10336917f, 0.19080903f, -0.05039861f, 0.08645952f, 0.11937404f, 
    -0.06936193f, -0.09509754f, 0.01657279f, -0.09146342f, -0.24605682f, 0.09702689f, 0.17607053f, -0.32712919f, 
    -0.00681016f, 0.01743669f, -0.04825607f, -0.03958672f, 0.01803803f, 0.05489247f, -0.04316992f, -0.01330676f, 
    -0.02072852f, -0.00351005f, -0.04755335f, -0.02107401f, 0.02109526f, 0.02568576f, 0.00398873f, 0.04102899f, 
    -0.00052257f, 0.02850064f, -0.03802174f, 0.02934474f, -0.02691286f, 0.03451271f, -0.04785175f, -0.00453295f, 
    -0.00583101f, 0.00040237f, -0.02184359f, -0.03350193f, 0.00255102f, 0.01759718f, -0.05457650f, -0.04787885f, 
    0.02315546f, -0.03011763f, -0.00751362f, -0.00392583f, 0.03612080f, 0.00112353f, 0.01027278f, -0.04137591f, 
    0.03205492f, 0.02425721f, -0.02643109f, 0.02046313f, 0.02302667f, 0.04158626f, 0.01914243f, -0.04420971f, 
    0.01519246f, -0.03372965f, -0.02974718f, -0.04802212f, -0.03201168f, 0.02969213f, -0.05807850f, 0.04038556f, 
    -0.02507608f, -0.05657448f, -0.04641639f, -0.02562278f, 0.02215689f, 0.00109638f, 0.04652560f, 0.01348592f, 
    -0.03151582f, 0.03503930f, 0.02775255f, 0.00992357f, -0.00318480f, -0.02685007f, 0.02961340f, 0.03605008f, 
    -0.01324983f, -0.04388545f, -0.00057475f, 0.05100434f, 0.04465762f, 0.02687062f, -0.02004821f, 0.03778803f, 
    -0.02136257f, -0.02931028f, 0.01830453f, -0.00918224f, -0.01733064f, -0.00522756f, -0.02833885f, 0.03843464f, 
    -0.03352799f, -0.03738154f, -0.05843060f, -0.05328163f, -0.03064755f, 0.03829705f, 0.02661617f, 0.00964578f, 
    -0.04627762f, 0.02866705f, -0.05112951f, 0.03935029f, -0.04977235f, -0.04220232f, -0.02537513f, -0.05096726f, 
    -0.03879566f, 0.04729219f, -0.05380981f, 0.02861791f, 0.02388283f, 0.04078100f, -0.01049661f, -0.02158169f, 
    -0.02382908f, -0.04191467f, -0.01936424f, 0.01673228f, 0.01860423f, -0.06277542f, 0.04027550f, -0.00080418f, 
    0.04818416f, 0.03920193f, -0.05646513f, -0.03100878f, -0.04941338f, 0.02490518f, 0.02167957f, 0.03836251f, 
    0.00930733f, 0.02577201f, -0.01975319f, -0.01220695f, 0.03408992f, -0.04889645f, 0.02554674f, -0.00924371f, 
    0.00456815f, 0.02928850f, -0.03756151f, -0.01514770f, -0.02467261f, 0.03568912f, -0.03279729f, -0.00207760f, 
    -0.02976901f, 0.01846924f, 0.04264307f, -0.01092859f, 0.01676782f, -0.00463955f, -0.04815687f, 0.00988290f, 
    0.04445121f, 0.04950142f, 0.04355952f, -0.05524564f, -0.01690901f, 0.02255066f, -0.00654646f, -0.03466869f, 
    -0.04234084f, 0.00440426f, 0.00721661f, 0.03772290f, -0.01741310f, -0.02906589f, -0.00583588f, 0.01854274f, 
    -0.05526236f, 0.04767382f, -0.01510291f, 0.04589574f, 0.02514538f, 0.00164311f, 0.04041450f, 0.04072348f, 
    -0.04945501f, -0.02143586f, -0.02811329f, 0.04461182f, -0.02020257f, -0.00567955f, -0.02951151f, -0.00660360f, 
    -0.06124011f, 0.04040877f, 0.02993705f, -0.04364841f, -0.03005366f, -0.04476025f, 0.02412327f, -0.01935844f, 
    0.02290791f, 0.03043761f, -0.06160138f, 0.02920622f, 0.02559897f, 0.02721734f, 0.00233053f, 0.00750742f, 
    -0.05257548f, -0.04165350f, 0.01730654f, -0.04690734f, -0.03757814f, 0.01292342f, -0.04714582f, -0.02741733f, 
    0.04439302f, -0.01420207f, -0.05725808f, -0.03636088f, -0.01964761f, -0.05716482f, 0.04180459f, -0.00679894f, 
    -0.01434391f, 0.04028195f, -0.05351678f, 0.01492685f, -0.04988960f, 0.01715498f, 0.03813524f, -0.04781617f, 
    0.01426917f, -0.03550820f, -0.02018511f, -0.02439282f, -0.03660711f, -0.00043237f, -0.05148882f, -0.00313091f, 
    -0.00886018f, -0.01662271f, 0.03184324f, 0.04731274f, 0.04798922f, -0.01428023f, 0.01472460f, 0.02199894f, 
    0.04051813f, -0.04830733f, 0.01546855f, 0.01114654f, 0.03963710f, 0.01182331f, -0.05001915f, -0.00569621f, 
    -0.04336535f, 0.04516611f, 0.04068846f, -0.02462612f, 0.05094865f, -0.05256105f, -0.00154331f, -0.02202864f, 
    0.02847256f, -0.01032425f, 0.02233684f, 0.02307235f, 0.03686192f, -0.03768564f, -0.04363409f, 0.04686074f, 
    -0.06088857f, -0.00810789f, -0.02361270f, -0.03033212f, -0.04785759f, -0.04178970f, -0.05376234f, 0.03044498f, 
    -0.02283592f, 0.00681203f, -0.04536778f, 0.03000114f, -0.06174638f, -0.03389037f, -0.03106992f, -0.03052200f, 
    0.00996278f, -0.03670137f, -0.03440576f, 0.02661940f, -0.04161960f, -0.00974754f, -0.02724005f, -0.00374152f, 
    0.04550207f, -0.05974604f, -0.05730844f, 0.03576663f, 0.01994791f, 0.03217001f, -0.03693526f, -0.03172657f, 
    0.03101720f, -0.03664365f, 0.01152168f, -0.05226979f, 0.00140622f, -0.00966821f, 0.03860843f, 0.00648325f, 
    -0.02515456f, -0.04569755f, -0.01222421f, -0.05746667f, -0.01775616f, -0.05276888f, 0.04519202f, -0.03464142f, 
    -0.04972262f, 0.03492279f, -0.00849079f, -0.02361340f, -0.00210393f, 0.02581693f, -0.03057912f, 0.00592175f, 
    -0.02455009f, -0.04013282f, -0.03718537f, -0.01352839f, -0.03690219f, 0.00770441f, -0.05082329f, -0.03437233f, 
    -0.01237468f, -0.05136259f, -0.01150410f, -0.03126904f, -0.06050241f, -0.01978765f, -0.01282719f, -0.05127812f, 
    0.01674484f, 0.00996615f, 0.02485952f, -0.05306085f, 0.01152029f, -0.05253397f, -0.01422048f, -0.05914451f, 
    -0.04105430f, -0.00329109f, -0.01512296f, -0.00964480f, -0.03394137f, -0.04481721f, -0.01735637f, 0.00154210f, 
    -0.00769212f, -0.01285568f, -0.01496904f, 0.00493515f, 0.00520059f, -0.04316924f, 0.04406625f, -0.00697826f, 
    0.04131866f, -0.05331532f, -0.01066868f, 0.00950351f, 0.02238434f, -0.00859839f, 0.01146054f, -0.06206001f, 
    -0.01253069f, -0.05146411f, -0.03750061f, 0.00098840f, -0.02850499f, -0.01910894f, 0.00154251f, 0.01916156f, 
    0.03336595f, 0.00668819f, -0.04090581f, 0.03695121f, -0.00865595f, -0.02140729f, -0.04865185f, -0.05286739f, 
    0.03875226f, -0.04094916f, -0.02811404f, -0.01690236f, -0.04456284f, -0.03887028f, 0.02844049f, -0.02060403f, 
    0.00737259f, -0.05347025f, -0.03314055f, 0.02984472f, -0.04346389f, -0.02098885f, -0.00995085f, 0.04651995f, 
    -0.01656074f, -0.02909223f, 0.01198181f, -0.05454167f, -0.00846489f, -0.05031962f, -0.04438127f, 0.04650635f, 
    -0.01964991f, 0.03759586f, 0.03875080f, -0.05050383f, 0.04375105f, -0.02271931f, 0.01739914f, 0.04130115f, 
    -0.00628416f, 0.02513700f, -0.02735788f, 0.01003808f, 0.01392530f, 0.02487953f, 0.01965657f, -0.05420287f, 
    0.01220430f, 0.00828518f, 0.00149613f, -0.01202848f, -0.04625919f, 0.00905811f, -0.04763243f, -0.00035781f, 
    -0.02805023f, 0.03301375f, -0.00582604f, -0.01540940f, 0.04476980f, 0.00656284f, -0.00868221f, -0.01276504f, 
    -0.04859097f, -0.00343946f, 0.04397663f, 0.01980283f, 0.02635226f, -0.00430221f, -0.04357951f, -0.03885215f, 
    -0.04629158f, 0.03704790f, 0.03024951f, 0.00995967f, 0.03037092f, 0.00688201f, -0.04548776f, 0.01280019f, 
    -0.04474293f, -0.04630773f, -0.02323998f, 0.01841309f, 0.03701084f, 0.02672630f, -0.01661346f, -0.04975595f, 
    0.01135312f, 0.03939778f, -0.05571921f, -0.03485709f, 0.04570222f, -0.05391167f, -0.00319392f, -0.05625352f, 
    -0.04454922f, -0.06001391f, -0.00012128f, 0.04014029f, 0.03880005f, -0.04018473f, -0.05564343f, -0.04514553f, 
    -0.04371902f, 0.03883107f, 0.02524120f, 0.00587558f, -0.00443184f, -0.01892174f, 0.01155263f, 0.03222803f, 
    -0.02751822f, 0.01524359f, 0.00709636f, -0.02611424f, 0.04356311f, -0.03825703f, 0.00679768f, 0.01970334f, 
    -0.03619969f, -0.03007655f, -0.03747660f, 0.02770224f, -0.05848877f, -0.03168314f, -0.01373693f, 0.01073883f, 
    -0.01374976f, 0.04155236f, -0.00520347f, -0.03744381f, 0.02123360f, 0.00704584f, 0.03268243f, -0.06371198f, 
    -0.04446854f, -0.01793092f, -0.02305565f, -0.02275475f, 0.00759314f, 0.02524674f, 0.01338095f, -0.00409794f, 
    -0.03263360f, -0.02884370f, -0.05858596f, 0.00575889f, -0.03681425f, 0.02985833f, -0.02348371f, -0.00564712f, 
    0.01669734f, -0.02151402f, -0.00988956f, -0.03136302f, -0.00229860f, 0.00416332f, -0.00083376f, -0.01600870f, 
    -0.05034127f, -0.01686059f, 0.03483159f, -0.02371308f, 0.02305895f, -0.02840961f, 0.02464821f, -0.03558566f, 
    -0.02293029f, 0.02853658f, 0.03407174f, -0.04059194f, 0.00331735f, -0.01823817f, 0.03218665f, -0.03748778f, 
    0.01769103f, -0.03221978f, -0.02852623f, -0.01259856f, -0.04412793f, 0.00883855f, -0.01067405f, -0.00841000f, 
    0.02482162f, -0.03503794f, 0.00843736f, -0.02741324f, 0.00023005f, -0.01718601f, 0.01408978f, -0.00909661f, 
    0.01069937f, -0.02987408f, 0.03210891f, -0.01870051f, -0.02126640f, 0.02025875f, -0.04008144f, 0.01266734f, 
    0.01633407f, -0.00494415f, -0.03928138f, 0.04683147f, -0.04042365f, 0.02722048f, -0.03066698f, 0.00353686f, 
    0.03398202f, 0.01451575f, -0.01531445f, 0.00892449f, -0.00401749f, -0.06339589f, -0.02026650f, -0.05372114f, 
    -0.05352868f, -0.04594652f, -0.02125876f, -0.00396968f, 0.00901846f, 0.03585956f, -0.02567790f, 0.02732826f, 
    -0.03432060f, 0.01845844f, -0.00578164f, -0.05571621f, -0.03953325f, 0.02013460f, -0.05336334f, -0.03630173f, 
    -0.00938959f, -0.02732850f, -0.04748626f, 0.02155798f, -0.02907161f, -0.03743676f, -0.00851427f, 0.02025414f, 
    -0.01246361f, -0.01360880f, 0.01699556f, -0.05908427f, -0.04304030f, 0.01522961f, -0.00977464f, -0.03107413f, 
    -0.00655501f, -0.00171791f, 0.02965870f, 0.04303190f, -0.02702888f, 0.00854324f, -0.00007369f, 0.00683068f, 
    0.03198742f, -0.05202383f, -0.02794088f, -0.02572703f, 0.04345270f, -0.01812697f, -0.02984842f, -0.02296490f, 
    -0.02814107f, -0.03186521f, -0.00325754f, -0.02617868f, -0.05597571f, 0.02561639f, -0.04464436f, 0.00305026f, 
    -0.01039984f, -0.04015970f, -0.02863317f, -0.03914702f, 0.01546857f, 0.03632345f, -0.06324337f, -0.05452917f, 
    -0.04217320f, -0.01559404f, 0.00983241f, -0.02842665f, 0.02155901f, 0.00416881f, 0.00965714f, 0.00396108f, 
    -0.04633508f, 0.01090004f, 0.02676855f, -0.00872719f, -0.01500601f, -0.05910246f, -0.01463555f, -0.00281022f, 
    -0.00681266f, -0.05010657f, 0.01655008f, -0.02538407f, 0.00925129f, 0.01763827f, 0.01080816f, -0.02996488f, 
    0.03678988f, -0.04255958f, 0.04046227f, -0.04801792f, -0.00738721f, -0.03418196f, -0.01256905f, -0.05820513f, 
    -0.00881122f, 0.00577446f, 0.02048807f, -0.01998212f, 0.01049818f, -0.02809902f, 0.00724710f, 0.00628924f, 
    -0.01980385f, -0.04948762f, 0.02920006f, 0.02557177f, 0.00892299f, -0.04113650f, 0.02938836f, -0.01848632f, 
    0.02983883f, -0.02534618f, 0.03659511f, 0.04237685f, 0.01529062f, 0.04081710f, -0.03254960f, -0.04141226f, 
    -0.00842145f, 0.02978864f, -0.04152549f, -0.06108370f, 0.01998519f, 0.04059006f, 0.00136275f, -0.05592456f, 
    -0.03554827f, -0.02071550f, 0.03902053f, -0.03804832f, 0.02081291f, 0.03572402f, -0.03152525f, -0.03951950f, 
    -0.00715490f, -0.03021921f, -0.00718868f, 0.00692447f, 0.04745136f, 0.00447154f, -0.05059621f, 0.00561896f, 
    -0.06163066f, -0.05106931f, 0.02666084f, -0.01948700f, 0.00739557f, -0.02531728f, 0.00524320f, 0.00041235f, 
    -0.01342108f, -0.00481679f, -0.04125711f, -0.00680063f, -0.01878688f, -0.00130821f, -0.01680425f, -0.03135893f, 
    0.02835271f, -0.03925551f, -0.04690384f, -0.01118476f, 0.02473379f, -0.00590425f, 0.03004398f, -0.06201295f, 
    -0.00036333f, 0.04109097f, 0.01812414f, 0.00167604f, -0.03759619f, 0.01495050f, -0.02863071f, 0.00129768f, 
    0.03540483f, -0.05981624f, 0.05037656f, -0.05656761f, -0.00199088f, -0.04419746f, 0.04394677f, 0.03542183f, 
    0.03708851f, 0.03626202f, -0.02327950f, 0.01986645f, -0.00102621f, -0.05555328f, 0.01662410f, -0.06141524f, 
    -0.02357770f, 0.04811988f, -0.06234543f, 0.00642906f, -0.04837141f, 0.01203469f, -0.05714542f, -0.02777739f, 
    0.01541409f, -0.05358523f, -0.03163052f, -0.00539859f, 0.00106397f, -0.00480825f, 0.03155107f, -0.00640452f, 
    -0.06041469f, -0.04756122f, -0.01091328f, -0.02275608f, 0.00544168f, 0.03685629f, 0.03551602f, 0.00360500f, 
    0.01245612f, 0.02358137f, -0.06266753f, -0.04640340f, -0.00944315f, 0.04320301f, 0.02770777f, -0.02056093f, 
    0.02658777f, -0.02057179f, -0.02341427f, 0.03141610f, 0.03628161f, -0.00744750f, -0.00764505f, -0.03073134f, 
    -0.05249062f, -0.04890142f, 0.01030577f, 0.03951074f, -0.05122980f, 0.04500408f, 0.02957389f, 0.03382744f, 
    -0.01871125f, -0.01291093f, -0.02169102f, -0.03058226f, -0.04583272f, 0.01319185f, 0.01532672f, -0.03344779f, 
    0.02123812f, 0.00438650f, 0.01551142f, 0.02042296f, 0.03819198f, -0.03347229f, -0.01312044f, 0.03652523f, 
    0.03577372f, 0.03469654f, 0.01038575f, 0.00125842f, -0.00084866f, -0.03110709f, -0.05826290f, 0.02472882f, 
    -0.00793096f, -0.00089432f, 0.02619289f, -0.01192413f, 0.00488972f, 0.03689109f, -0.01326787f, -0.01380782f, 
    0.02375890f, -0.05685343f, -0.04819294f, 0.02197433f, 0.00004290f, -0.05472640f, 0.00933462f, -0.04841931f, 
    -0.01689902f, -0.03288750f, 0.00523672f, 0.03004394f, 0.01772039f, -0.05758123f, -0.00340701f, 0.00423874f, 
    -0.05717340f, -0.00909231f, 0.00470101f, -0.05995080f, 0.01968314f, 0.03932991f, -0.02147769f, 0.01831127f, 
    -0.03214942f, -0.01008356f, -0.06306454f, -0.02181000f, -0.02946340f, -0.05457544f, -0.05142875f, 0.01448441f, 
    -0.03448160f, 0.01309175f, -0.04065252f, 0.00087803f, 0.03140985f, -0.02496428f, -0.00219316f, 0.02461488f, 
    0.00356289f, 0.01774896f, -0.04162339f, 0.00816283f, 0.00582506f, 0.02537504f, -0.01023788f, -0.04767244f, 
    0.01338223f, -0.06014841f, 0.03614675f, 0.02103458f, 0.03314344f, -0.05006154f, -0.00480655f, -0.03006808f, 
    -0.05626302f, 0.04412660f, 0.01245752f, -0.02459592f, -0.03237987f, -0.05788404f, -0.00629584f, -0.05987617f, 
    -0.04176357f, 0.01739336f, -0.00573158f, 0.03897764f, 0.03540896f, -0.01390517f, 0.03522346f, -0.01729500f, 
    0.01178483f, 0.01842390f, -0.04304726f, 0.01433942f, -0.02512505f, -0.01493390f, 0.04707926f, 0.02537397f, 
    -0.03735692f, -0.05815244f, -0.00417538f, -0.01281687f, -0.05039830f, 0.02785793f, -0.00962420f, -0.00891604f, 
    -0.04031265f, 0.00025054f, -0.01143068f, 0.01333900f, 0.03131877f, -0.05812416f, 0.03756912f, 0.01476951f, 
    0.09088416f, 0.04278558f, -0.07716075f, -0.22042684f, 0.11046985f, -0.02190302f, -0.06744441f, -0.08490045f, 
    0.11837159f, -0.12636057f, 0.08746921f, -0.08574869f, 0.05877808f, -0.17943469f, 0.02561488f, -0.06032997f, 
    0.04172427f, 0.16157582f, -0.06117772f, -0.04579063f, 0.02949814f, 0.08485572f, 0.17058469f, -0.18397450f, 
    -0.09151143f, 0.04552191f, -0.02790283f, 0.12445512f, 0.16198276f, -0.04527016f, 0.00646424f, 0.09837106f, 
    0.15013871f, 0.01869388f, 0.03401873f, 0.00665563f, -0.04310130f, 0.11962344f, -0.08882970f, -0.06186869f, 
    0.07484750f, -0.10073961f, -0.17585263f, -0.04686629f, -0.01802806f, 0.10803708f, 0.23577623f, -0.03667660f, 
    0.09927286f, 0.17470430f, 0.13734132f, 0.05389087f, -0.09398486f, 0.06660357f, 0.04556469f, -0.08787673f, 
    0.00269426f, -0.07926098f, 0.09720017f, -0.01171043f, -0.14990903f, 0.19179039f, -0.07752933f, -0.16644812f, 
    -0.11184245f, 0.05830263f, -0.00397205f, -0.24405698f, -0.11111549f, 0.16834810f, -0.02411224f, 0.03774048f, 
    0.05161629f, -0.08113611f, 0.01980813f, -0.10351565f, 0.07652413f, 0.05530346f, 0.05404776f, 0.19420081f, 
    0.57095248f, 0.29928967f, 0.08013628f, -0.14457302f, 0.02661388f, 0.17578229f, -0.04442605f, -0.03030778f, 
    0.12964290f, 0.07333711f, 0.05518902f, -0.02132111f, 0.01727366f, -0.08272231f, 0.09159373f, -0.03910107f, 
    0.02698708f, 0.23813696f, 0.15392914f, 0.14793432f, -0.02225311f, 0.15010302f, -0.05591451f, -0.14891516f, 
    -0.01451389f, -0.03875775f, 0.16547862f, 0.02553465f, -0.38443166f, 0.11173993f, 0.10844358f, 0.01569522f, 
    -0.13535485f, 0.16199711f, -0.13008432f, -0.02632326f, 0.15599386f, 0.19315395f, -0.13839255f, -0.17292425f, 
    -0.10451249f, 0.16825949f, 0.10786367f, 0.13746589f, 0.03206471f, -0.06821154f, -0.01445083f, 0.07597830f, 
    -0.06123779f, -0.10740065f, 0.04567726f, 0.03290768f, 0.06844807f, -0.05231100f, -0.05372155f, -0.10146478f, 
    -0.09010552f, -0.12200629f, 0.02100318f, 0.00022224f, -0.03562051f, 0.01211402f, 0.18009809f, 0.03473659f, 
    -0.11593402f, 0.08621997f, 0.11340501f, 0.07760638f, -0.06710976f, -0.03836792f, 0.08036137f, -0.02236451f, 
    -0.06862070f, 0.00789650f, -0.06360652f, -0.05646832f, 0.07782665f, -0.07553089f, 0.06644028f, -0.09877870f, 
    0.03121769f, -0.04409138f, -0.11545347f, -0.10834005f, -0.03103159f, -0.03221744f, 0.08303595f, -0.02357159f, 
    -0.02883041f, -0.07225450f, -0.05814436f, 0.00538848f, 0.08395269f, -0.01617906f, -0.11251938f, 0.08423358f, 
    -0.00589355f, -0.17357388f, 0.06620220f, -0.08646826f, -0.04824176f, 0.05543056f, 0.02296596f, -0.11290438f, 
    -0.00139538f, 0.05946517f, -0.09647215f, -0.01090456f, -0.03560189f, 0.02666058f, 0.05455197f, 0.24313322f, 
    -0.00894933f, 0.12475254f, -0.02011259f, -0.15282254f, -0.07479766f, -0.08429989f, -0.02679794f, -0.07431985f, 
    0.26724899f, -0.03132277f, -0.21215576f, -0.14861988f, -0.07165313f, 0.00950403f, 0.07916314f, 0.10560134f, 
    0.01505124f, -0.08322965f, 0.01041072f, -0.12007421f, 0.04760298f, 0.14188056f, -0.03770433f, -0.01185975f, 
    0.01033000f, 0.06933896f, -0.01230429f, -0.05006998f, 0.14996105f, -0.11268435f, -0.18828566f, 0.00664969f, 
    -0.03491128f, 0.13748445f, 0.14243844f, 0.25082865f, 0.04854032f, -0.03075233f, -0.10937516f, -0.09207179f, 
    -0.00965797f, 0.04441464f, 0.01321354f, -0.04046715f, -0.01645371f, 0.02502552f, -0.02210536f, -0.04085585f, 
    0.09080673f, 0.12380488f, 0.07291579f, 0.03254633f, -0.03748342f, 0.00787456f, -0.04444911f, -0.00663230f, 
    0.08310033f, -0.09343460f, -0.02969162f, -0.01211195f, 0.00163455f, 0.16326052f, 0.01606829f, -0.06669036f, 
    0.06186724f, -0.08133753f, 0.12388393f, -0.00823400f, 0.15675029f, 0.01046973f, -0.21338482f, -0.02501015f, 
    -0.09062427f, 0.00856636f, -0.04046552f, -0.07917487f, -0.03943107f, 0.03519675f, 0.02853136f, -0.06424107f, 
    0.00214101f, 0.06884401f, 0.04283119f, -0.02450854f, 0.06170079f, 0.00405572f, 0.05909020f, 0.06387278f, 
    0.58445585f, 0.00462881f, -0.05600062f, 0.18104498f, -0.04870072f, 0.02844775f, -0.00776820f, 0.07110010f, 
    -0.04882626f, -0.07636467f, 0.08270736f, 0.13941811f, -0.02325391f, 0.01808150f, 0.00585584f, 0.05346476f, 
    0.07592626f, -0.09623036f, 0.05233428f, 0.07450229f, -0.09983216f, -0.00386989f, -0.08153281f, 0.11623006f, 
    0.03249882f, -0.01254790f, 0.17294978f, 0.27035987f, -0.02832785f, 0.01193427f, 0.06590635f, 0.07676303f, 
    -0.09473209f, 0.09076320f, -0.00437891f, -0.11508019f, -0.03647627f, 0.15485942f, -0.03646284f, 0.00536960f, 
    0.03950638f, -0.04463607f, -0.03737009f, -0.02385159f, -0.00509405f, 0.01628399f, -0.04778225f, 0.01070814f, 
    -0.05141563f, 0.03911936f, 0.03441397f, 0.02287021f, -0.01895538f, -0.03537351f, -0.03521542f, 0.01958632f, 
    -0.04979846f, 0.02962003f, -0.02756192f, 0.03423048f, 0.01424497f, 0.01906247f, 0.01027086f, 0.02477324f, 
    -0.01101817f, -0.03906913f, 0.00883185f, -0.04738788f, -0.03244347f, 0.02927963f, 0.03620223f, -0.04910286f, 
    0.03689672f, -0.02738538f, -0.03945568f, -0.03811436f, 0.03956145f, -0.04139321f, -0.05394240f, -0.03457723f, 
    0.03882363f, 0.04284064f, 0.03841972f, -0.02753926f, 0.04344936f, 0.01033678f, -0.00712386f, 0.01231780f, 
    -0.04867688f, -0.02804939f, -0.00054564f, 0.01188103f, 0.03105747f, -0.01925636f, 0.01305080f, -0.04033566f, 
    -0.02943343f, -0.04908643f, -0.06404763f, -0.00099286f, -0.00449758f, -0.05542871f, -0.02737316f, -0.03616766f, 
    -0.00445771f, 0.02490149f, -0.03402412f, -0.02520627f, -0.06332984f, 0.00848524f, 0.04307169f, -0.03604449f, 
    -0.02941140f, -0.04443290f, 0.02206217f, 0.02154763f, -0.04491057f, -0.00720278f, -0.01162783f, 0.05094098f, 
    0.03824682f, 0.02543906f, 0.01066382f, 0.00270977f, 0.02679347f, -0.05580824f, -0.05580705f, -0.03406749f, 
    0.03507852f, -0.04322377f, -0.00767840f, -0.04306513f, -0.01992649f, 0.02614827f, -0.02248081f, -0.03665651f, 
    0.03499384f, -0.03501236f, 0.00304192f, -0.03587683f, 0.05859214f, -0.04346400f, 0.03667331f, 0.04246588f, 
    -0.03297649f, -0.04798650f, 0.01873564f, -0.00329886f, 0.03812283f, -0.05235256f, 0.02375397f, -0.00494095f, 
    0.00791913f, 0.00178857f, 0.02351258f, 0.01775539f, -0.06174729f, -0.04745113f, -0.04804924f, -0.06003812f, 
    0.04710125f, 0.01638765f, -0.00572994f, -0.03393425f, 0.00719213f, 0.03769755f, 0.04815230f, 0.01542143f, 
    -0.02672209f, 0.02616585f, -0.05507066f, 0.03292436f, -0.05977902f, -0.02012395f, -0.04258807f, -0.04238447f, 
    0.02921551f, 0.01915170f, -0.04583028f, 0.04709167f, 0.02277623f, 0.00556962f, -0.06385913f, -0.03651913f, 
    0.00226109f, -0.00604739f, 0.00856580f, -0.00505665f, -0.04071420f, 0.00595609f, 0.04356868f, -0.00583490f, 
    -0.05499076f, -0.04579374f, -0.06112059f, 0.04622573f, -0.02171313f, -0.02380705f, -0.05301287f, -0.06553050f, 
    0.02075793f, 0.03074683f, 0.03859166f, 0.02398146f, -0.02992998f, -0.01123407f, -0.05211327f, 0.04038313f, 
    0.03595597f, 0.01889795f, -0.02343695f, 0.00543319f, -0.00661085f, 0.01320976f, -0.06299964f, -0.02653219f, 
    -0.01896324f, -0.05056147f, -0.02343315f, -0.03803476f, 0.01725643f, -0.01949918f, 0.03777056f, -0.03506469f, 
    -0.03734195f, -0.03667917f, 0.00472105f, -0.00730147f, -0.05798328f, -0.05201964f, -0.02632739f, 0.02780461f, 
    0.01990966f, -0.05300869f, -0.00444161f, 0.04304888f, -0.04005847f, -0.00340533f, -0.01854969f, -0.02975763f, 
    -0.00102838f, -0.00772300f, -0.00464783f, -0.02880298f, 0.03156123f, -0.00435084f, -0.04230149f, 0.04536217f, 
    -0.03033890f, -0.00597361f, 0.01693050f, 0.02805862f, 0.03743202f, -0.04578793f, -0.02279458f, 0.02182261f, 
    -0.04611810f, -0.02714580f, -0.01982325f, -0.05286327f, -0.00683812f, -0.03177032f, -0.03387456f, -0.02618145f, 
    0.03956984f, -0.03010075f, 0.02712257f, -0.00701291f, -0.00196909f, 0.00767657f, -0.04444135f, 0.01770243f, 
    -0.01738405f, 0.02859138f, -0.00233444f, 0.00392057f, 0.04526223f, -0.06356522f, 0.03263333f, -0.01185547f, 
    -0.05045718f, 0.01123636f, -0.04924323f, 0.02015304f, -0.04297270f, 0.04402680f, 0.01928194f, 0.01879124f, 
    0.00577492f, -0.01001819f, -0.04257793f, -0.01418498f, 0.01687455f, -0.05717804f, 0.01342235f, 0.00460547f, 
    0.03144709f, -0.04203685f, -0.04223476f, 0.03348540f, -0.00205982f, 0.03225588f, -0.03388021f, 0.02264976f, 
    -0.03313286f, -0.02474739f, -0.05715974f, 0.02837595f, 0.02299997f, -0.01080801f, -0.05174728f, -0.02429548f, 
    0.04313971f, -0.02487036f, -0.01641391f, -0.01080978f, -0.01933014f, 0.01109188f, -0.03424107f, -0.01533540f, 
    -0.00923128f, -0.05823271f, -0.00264895f, 0.02604769f, 0.01721945f, 0.03297138f, -0.04061187f, -0.05752933f, 
    0.01743813f, -0.03217477f, 0.00970674f, -0.05046796f, -0.01709567f, 0.04517683f, -0.03207816f, 0.00296487f, 
    -0.03524476f, 0.02611165f, 0.04295640f, -0.02041472f, 0.04619153f, 0.04432135f, 0.04506897f, 0.04548075f, 
    -0.02966104f, 0.02712324f, -0.00926293f, -0.04208424f, 0.03384429f, 0.01094758f, -0.04319705f, 0.02357958f, 
    -0.03031746f, 0.02693731f, 0.04364375f, -0.05815901f, -0.00590349f, -0.03461630f, -0.04933308f, -0.05659769f, 
    -0.47185695f, 0.13520423f, -0.14206123f, 0.18012708f, 0.19325063f, 0.05962099f, -0.04517640f, 0.03494628f, 
    0.00043027f, -0.03680320f, -0.06488410f, 0.05783632f, 0.04013915f, 0.06561708f, 0.17820287f, 0.06930473f, 
    -0.05951712f, -0.01600358f, -0.07419537f, 0.09446155f, 0.07542745f, 0.06646793f, -0.08606560f, 0.12299220f, 
    -0.23205049f, -0.08125263f, 0.04015773f, -0.10939183f, -0.25002903f, -0.03101108f, 0.19761643f, -0.20128231f, 
    0.10511819f, 0.13459882f, 0.00984316f, 0.01549803f, -0.04042217f, -0.11582233f, 0.13658558f, 0.03349366f, 
    -0.26582327f, 0.15971048f, 0.11802446f, -0.13517204f, 0.06848361f, 0.09636982f, 0.04763561f, 0.14796479f, 
    0.12702918f, 0.13600302f, 0.06093036f, -0.16323853f, -0.03253835f, 0.05972780f, -0.00036024f, 0.03970218f, 
    0.09980861f, -0.00017528f, 0.12100465f, 0.10739007f, 0.12462340f, 0.01642651f, -0.03935774f, 0.25030142f, 
    0.13127053f, 0.20088939f, 0.12398749f, 0.08374410f, 0.04342643f, 0.16582872f, -0.02419951f, 0.01584985f, 
    -0.04109300f, 0.04697911f, 0.09639724f, 0.01548900f, -0.05553138f, -0.04103094f, -0.07087743f, 0.03416115f, 
    -0.25126863f, 0.11642857f, 0.08744743f, 0.41317424f, 0.27723563f, 0.13374549f, 0.04756695f, 0.02777702f, 
    0.06303348f, 0.11332949f, 0.06065960f, 0.07444111f, 0.00433433f, 0.04808532f, 0.08910614f, -0.09552143f, 
    0.01484494f, -0.08450256f, 0.07718035f, 0.06498865f, -0.53887552f, 0.02935272f, -0.14517619f, -0.14562325f, 
    -0.18169071f, -0.08553779f, -0.04072941f, -0.20725048f, 0.18389805f, 0.05899619f, -0.06028821f, 0.02928185f, 
    0.01550155f, -0.12063242f, 0.07105917f, 0.03543585f, 0.01302156f, 0.05990510f, 0.11998861f, 0.02390711f, 
    0.01201403f, -0.14794821f, -0.05032261f, -0.13855682f, -0.07914539f, 0.03291942f, -0.08292275f, -0.04971463f, 
    -0.09659490f, -0.06728516f, 0.09826168f, 0.10054906f, -0.06991489f, -0.01825028f, 0.13918293f, 0.09437907f, 
    0.08619661f, -0.10314324f, -0.06856447f, -0.09576866f, -0.16260403f, -0.28804368f, -0.04388359f, -0.14284846f, 
    -0.02974506f, 0.11684218f, -0.10422148f, 0.03608847f, -0.03909467f, 0.01686173f, 0.05314828f, -0.03161428f, 
    0.01679176f, -0.05776721f, 0.07251487f, 0.13567908f, 0.09871300f, 0.03696071f, 0.01184944f, 0.06555120f, 
    -0.19820747f, -0.10374100f, 0.18456616f, 0.09398811f, -0.04428647f, 0.08519545f, -0.03737651f, 0.03853058f, 
    -0.13988093f, -0.05866363f, -0.00753741f, 0.11773419f, 0.04203472f, -0.01863420f, 0.00670634f, 0.03411621f, 
    -0.00220047f, 0.03296599f, -0.01665599f, -0.02924185f, -0.34469435f, -0.15845461f, 0.02807536f, -0.02413577f, 
    -0.05621454f, -0.01143929f, 0.03655731f, -0.02627929f, -0.08297965f, -0.03797939f, 0.05922874f, 0.07380330f, 
    -0.00426110f, -0.06775978f, 0.06206897f, -0.02299578f, 0.04368489f, 0.02425257f, 0.08786304f, 0.04024670f, 
    -0.23334590f, 0.08746030f, 0.09271120f, -0.00744159f, 0.09004111f, 0.09057570f, 0.08017686f, 0.01194440f, 
    -0.00819231f, -0.05398347f, 0.04468175f, 0.19950445f, 0.06365886f, -0.08410352f, -0.01147433f, -0.03343759f, 
    -0.04879422f, -0.04248286f, -0.07601722f, -0.01928203f, -0.20192599f, 0.03233368f, 0.05359336f, 0.06316061f, 
    0.20438042f, -0.06147365f, 0.00586599f, 0.07300408f, 0.01315976f, 0.02763915f, 0.06480700f, 0.20250812f, 
    -0.07230446f, 0.01690329f, -0.02206600f, -0.03831549f, 0.07078715f, 0.01323544f, -0.03454908f, 0.02982426f, 
    -0.09140643f, -0.12574935f, -0.18399307f, -0.19860554f, -0.09274244f, 0.09724072f, -0.08775406f, -0.07239592f, 
    -0.10540358f, -0.06480841f, 0.12197853f, -0.03253663f, 0.07690748f, 0.04206123f, -0.00316306f, 0.15354186f, 
    0.09986927f, 0.01251033f, 0.12517773f, -0.05461574f, 0.15541670f, 0.17340870f, 0.04493104f, -0.04418272f, 
    0.35062364f, 0.06053421f, 0.06122296f, 0.16487187f, 0.05869295f, 0.15189461f, -0.04936862f, 0.02772265f, 
    0.04153696f, -0.05027634f, 0.00081835f, -0.05037892f, 0.00919995f, 0.03352095f, 0.02431386f, -0.02579259f, 
    0.47021073f, -0.11119781f, 0.00440711f, -0.20604151f, -0.05853868f, -0.00204137f, 0.03029069f, -0.14477921f, 
    -0.05205735f, -0.07026677f, 0.11448573f, -0.08462470f, 0.05265699f, -0.04702468f, 0.07278538f, -0.03915638f, 
    0.05855313f, -0.13081621f, -0.05160967f, -0.02114020f, 0.21269707f, -0.06579591f, -0.02781241f, -0.18624753f, 
    -0.10571538f, 0.13698520f, -0.01468353f, 0.05520280f, -0.04349389f, 0.07698274f, 0.02858241f, 0.08056943f, 
    0.00446415f, -0.00482118f, -0.13807960f, 0.09390407f, 0.00620879f, 0.04206285f, 0.07609743f, 0.08799635f, 
    -0.01902028f, 0.33145472f, -0.09864029f, -0.25179124f, 0.25706646f, -0.11704327f, -0.07938926f, -0.06384201f, 
    0.12068291f, -0.05887116f, -0.00979901f, -0.00432408f, -0.08003154f, -0.06048173f, -0.02940440f, 0.07292272f, 
    0.01285570f, 0.15637705f, -0.39532018f, -0.12428895f, -0.10878495f, 0.16194861f, -0.13293669f, 0.23426889f, 
    -0.37623250f, -0.13533168f, -0.08924767f, 0.02812012f, 0.12325102f, -0.00601772f, -0.05850695f, 0.07834343f, 
    0.09712826f, -0.03962446f, 0.02768469f, 0.00053201f, -0.06829376f, -0.04181109f, 0.05658270f, 0.09505046f, 
    -0.09054565f, -0.04937612f, 0.02055336f, -0.03267184f, -0.01737605f, 0.07296841f, 0.24590729f, -0.10373476f, 
    0.12508604f, 0.08057685f, 0.03195400f, 0.10368573f, -0.10968848f, 0.18503386f, 0.00237126f, 0.01661829f, 
    -0.05391816f, -0.03473305f, 0.09340160f, 0.19630633f, -0.11377195f, 0.09448796f, -0.13098349f, -0.05238959f, 
    -0.30948567f, 0.01817219f, -0.03387436f, 0.02791468f, -0.28208235f, 0.11908724f, -0.05694667f, 0.00547687f, 
    -0.07393203f, -0.07862110f, 0.01957318f, -0.17040719f, 0.01705416f, -0.03511379f, -0.01001299f, 0.24543749f, 
    0.46905404f, 0.31994608f, 0.25221032f, 0.19620869f, -0.07944171f, 0.04992954f, 0.07703051f, 0.15955295f, 
    0.18918194f, -0.01133059f, 0.02660401f, -0.07921118f, 0.03463589f, -0.19117083f, -0.07081173f, -0.02116193f, 
    0.14202292f, 0.02982832f, 0.00375440f, 0.14410266f, -0.53799206f, 0.09711424f, -0.03196936f, -0.09273729f, 
    -0.00677911f, -0.19418688f, 0.17101867f, 0.01231805f, -0.11684768f, 0.02353349f, -0.03056146f, -0.13255247f, 
    0.04576865f, 0.14040822f, -0.21489912f, -0.10551067f, 0.16449095f, 0.11086471f, -0.03367312f, -0.04661326f, 
    -0.01248001f, -0.10394026f, 0.04847830f, 0.08819179f, 0.02606289f, -0.04130933f, -0.07724778f, 0.04805102f, 
    -0.00434839f, -0.04655699f, 0.08808029f, 0.05850920f, 0.09029673f, 0.02002502f, 0.00627413f, -0.00100199f, 
    -0.10852103f, -0.06860986f, 0.05051821f, -0.04436618f, -0.21519358f, -0.23885404f, 0.34715471f, -0.01224650f, 
    -0.02421472f, 0.02794499f, 0.14856665f, 0.18925647f, 0.01989581f, -0.03208276f, 0.07350928f, 0.01455387f, 
    -0.08601280f, 0.04228459f, -0.01964507f, -0.14735271f, -0.02160863f, 0.07196659f, 0.08709811f, -0.02031954f, 
    0.10595224f, -0.25430512f, 0.23008443f, 0.11239909f, 0.05267420f, 0.07798939f, 0.00274306f, 0.05347649f, 
    -0.05486779f, -0.05528311f, -0.09808954f, 0.01974573f, -0.08323625f, 0.05700868f, -0.04304462f, 0.06267933f, 
    0.01959402f, -0.04150971f, 0.03115824f, -0.01827513f, -0.07605594f, -0.10839774f, 0.07501129f, 0.01325367f, 
    0.00932370f, 0.00587597f, -0.05412009f, 0.10641512f, -0.02213761f, 0.00621849f, -0.11223374f, 0.13401796f, 
    0.03427046f, 0.11145131f, -0.04800089f, -0.11520312f, -0.06065474f, -0.04324006f, 0.02104968f, -0.01115645f, 
    0.43328023f, 0.02556522f, 0.14782584f, 0.24969810f, 0.09187006f, -0.01473283f, 0.02521751f, 0.12978086f, 
    0.08233985f, -0.13969596f, -0.06524490f, -0.02027450f, 0.05310443f, 0.09761143f, -0.02618367f, -0.01569706f, 
    -0.06201601f, 0.00821965f, 0.02495297f, -0.00751202f, 0.12876804f, 0.11946092f, 0.21614911f, 0.11206325f, 
    0.17428602f, 0.04839799f, 0.13720413f, 0.17002672f, 0.10523483f, -0.04936568f, -0.11810887f, 0.00940709f, 
    -0.00626215f, -0.05699119f, -0.02460565f, -0.00893768f, 0.03716911f, -0.01322133f, 0.01634785f, 0.00647243f, 
    -0.11592362f, -0.13360658f, 0.00967906f, -0.03114925f, -0.10087368f, -0.07552350f, 0.01043923f, -0.05429568f, 
    0.08745536f, 0.02663550f, -0.03029121f, 0.04955886f, -0.08092389f, 0.20057671f, 0.02663402f, -0.01530982f, 
    0.03283063f, 0.01901687f, 0.12196919f, -0.02176090f, -0.29076669f, 0.07388314f, -0.14851254f, -0.37007877f, 
    -0.28489828f, 0.01663794f, -0.08257131f, -0.16179924f, 0.00886125f, 0.05306052f, -0.02878379f, -0.10479234f, 
    0.07403942f, 0.08125643f, -0.03955461f, 0.03239171f, -0.01799291f, -0.05386524f, -0.07543655f, 0.05034969f, 
    0.61695623f, -0.04500588f, 0.18697776f, 0.13108739f, -0.09809819f, -0.01347825f, -0.05659097f, 0.01681906f, 
    0.03628888f, 0.02493973f, 0.08090780f, -0.05610695f, -0.21445684f, -0.06195288f, -0.03405033f, -0.00832485f, 
    0.11594670f, -0.09015934f, 0.07260927f, 0.04541436f, 0.08550396f, -0.01013221f, -0.07645229f, 0.03714696f, 
    0.03710796f, 0.09198724f, 0.09924218f, 0.12964059f, 0.02054471f, -0.02590184f, 0.02739854f, 0.04818903f, 
    0.02890172f, 0.02677317f, -0.07453584f, -0.03088992f, 0.00712338f, -0.01703598f, 0.09486330f, 0.10190179f, 
    0.02668804f, -0.39006034f, -0.08878067f, 0.39955273f, -0.05523958f, 0.11747279f, -0.03767832f, -0.02375019f, 
    0.11188696f, 0.05307568f, 0.08906552f, 0.01591305f, 0.14339422f, -0.00888181f, -0.00331992f, -0.05167827f, 
    0.08738401f, 0.07133762f, 0.08483205f, 0.09323388f, -0.07492880f, -0.10446414f, 0.65567780f, -0.25784686f, 
    0.22502246f, 0.16029270f, 0.09127900f, 0.06278173f, -0.12682542f, 0.09829083f, 0.09664072f, 0.04019227f, 
    0.13893206f, 0.14806989f, -0.09209818f, 0.19589080f, 0.23378520f, -0.00432416f, -0.00857005f, -0.04366652f, 
    0.01273940f, -0.10625385f, -0.16449514f, 0.16450825f, 0.13509522f, 0.07144234f, -0.09745864f, -0.07314174f, 
    -0.14551714f, 0.01021135f, 0.03183829f, -0.00209689f, 0.07451927f, -0.05467984f, -0.02717483f, 0.00486586f, 
    -0.00669709f, -0.02589955f, -0.03829938f, -0.12091094f, 0.10846937f, -0.19097708f, 0.21982943f, 0.05292039f, 
    0.29182041f, 0.00242075f, -0.05789303f, -0.12251972f, 0.16680540f, 0.06914306f, 0.00474065f, -0.01790451f, 
    0.02980088f, -0.03523460f, -0.05026932f, 0.17995769f, 0.04014063f, -0.01904284f, 0.26618877f, -0.00531050f, 
    -0.27909327f, -0.17335038f, 0.05159517f, -0.06149217f, 0.02862253f, 0.00940667f, -0.08121884f, -0.14553687f, 
    0.03238712f, -0.04790810f, 0.04265646f, 0.00424048f, 0.01549484f, 0.11833563f, 0.02627114f, -0.05026421f, 
    0.13403890f, 0.10381884f, 0.02791349f, 0.04438527f, 0.51756746f, 0.00510223f, -0.08373039f, 0.20604956f, 
    -0.15128446f, 0.35717580f, 0.11392323f, -0.19264311f, -0.18756583f, -0.13601673f, 0.19080888f, 0.16344546f, 
    0.16445434f, 0.02336328f, 0.10037614f, 0.13361925f, -0.00544704f, 0.02000825f, -0.01516346f, -0.17815618f, 
    0.00589398f, 0.32353419f, 0.02554537f, 0.10857459f, -0.00210305f, -0.01268041f, 0.06594749f, -0.05326989f, 
    -0.00511844f, -0.07926591f, -0.00644885f, -0.11038417f, -0.01470745f, -0.03251637f, -0.01437366f, -0.01767722f, 
    0.00424644f, -0.02637404f, 0.03793615f, -0.00857533f, 0.32476285f, 0.31719911f, -0.29330882f, -0.04241850f, 
    0.07910009f, 0.15091661f, 0.14399916f, -0.20235488f, -0.01641168f, 0.00513245f, 0.03642767f, 0.10672851f, 
    0.09325335f, 0.17532462f, -0.03370605f, 0.13571058f, 0.02665069f, 0.01676217f, -0.00318030f, -0.04411595f, 
    0.01714175f, 0.30358610f, -0.24773283f, -0.06676470f, -0.08555701f, 0.00221363f, 0.03506732f, -0.05426948f, 
    0.00108311f, -0.01613932f, 0.09051929f, -0.06266122f, 0.14816299f, 0.03320907f, -0.03465573f, -0.05825766f, 
    -0.02597620f, -0.09882689f, 0.04584153f, 0.07259744f, 0.14530757f, 0.20647301f, -0.11785950f, -0.07332079f, 
    0.03595372f, -0.00136617f, 0.06920373f, -0.21869527f, -0.03246276f, -0.01586378f, 0.06687199f, -0.04614729f, 
    0.06960124f, 0.04177005f, 0.00276441f, 0.07719652f, 0.01410755f, 0.06218656f, -0.04815424f, -0.16625690f, 
    -0.27543229f, -0.21111618f, -0.12010665f, -0.06279267f, -0.12418205f, -0.05946933f, -0.01842358f, 0.02868814f, 
    0.01331246f, 0.03421978f, 0.07759751f, -0.03245035f, 0.06030026f, 0.01227941f, 0.03435051f, -0.04909999f, 
    -0.09532976f, -0.04721910f, 0.02273202f, -0.03154550f, -0.09908626f, -0.30165559f, -0.19573987f, 0.02063629f, 
    -0.03531955f, 0.00991901f, -0.12969212f, -0.08372140f, -0.06102847f, 0.06479640f, 0.11040374f, 0.06293637f, 
    0.05269371f, 0.09121574f, 0.03537993f, 0.00859414f, -0.04501204f, 0.03854810f, -0.09270846f, -0.06294803f, 
    0.09241604f, 0.26332185f, 0.21610959f, 0.19641510f, 0.17019588f, 0.06142874f, 0.10760272f, 0.04034540f, 
    0.00476236f, 0.00918926f, 0.13071133f, -0.03015200f, 0.00713743f, -0.01506044f, -0.01504767f, -0.01942052f, 
    0.08714058f, 0.02657049f, 0.02281653f, -0.09309529f, 0.14281845f, -0.10158806f, 0.28039765f, 0.40743646f, 
    0.19114958f, 0.05155693f, 0.11979570f, 0.11675061f, 0.09841767f, -0.01340385f, 0.12274471f, 0.05046411f, 
    -0.08644143f, -0.01497189f, 0.07485830f, -0.05662845f, 0.01193554f, -0.04498779f, 0.21043128f, -0.04654112f, 
    -0.01346591f, 0.22265598f, -0.01475185f, 0.06970277f, 0.04570410f, -0.00413278f, 0.10556315f, 0.21369064f, 
    0.05941239f, -0.07513987f, -0.11068837f, 0.03650191f, 0.25160369f, 0.16876404f, 0.10110271f, 0.05807004f, 
    0.00093669f, 0.12367067f, 0.02596131f, 0.10956006f, -0.16754678f, -0.23307303f, 0.13817583f, 0.03684387f, 
    0.01785684f, -0.11956801f, -0.03524246f, -0.04792143f, 0.05387593f, 0.07247870f, 0.06172482f, 0.15553561f, 
    -0.04141040f, -0.05452178f, -0.01448109f, -0.02718783f, -0.00724870f, 0.13584125f, -0.09968432f, -0.18272489f, 
    0.15515763f, 0.26465699f, 0.03382897f, -0.15843581f, 0.00429353f, 0.23665926f, 0.03295361f, 0.16981578f, 
    0.30485600f, 0.05886650f, -0.04995149f, 0.00730513f, 0.03644528f, -0.03287312f, 0.06457809f, 0.00721756f, 
    0.07835659f, -0.00504383f, -0.20265791f, 0.13973911f, -0.18284969f, 0.00011470f, -0.19585572f, 0.19941695f, 
    -0.25552332f, -0.07245649f, 0.07151837f, 0.02435429f, 0.07488586f, 0.07097366f, 0.08826584f, 0.13378337f, 
    -0.01201969f, 0.29602715f, -0.09382819f, 0.02497319f, 0.04097945f, 0.00098844f, 0.22869121f, 0.05451008f, 
    -0.10523719f, -0.09429394f, -0.17296632f, -0.07347650f, -0.17168908f, 0.00108198f, -0.01315153f, -0.08999348f, 
    0.09675603f, -0.06531227f, 0.01333170f, 0.05419208f, -0.10502566f, 0.19236550f, 0.01533347f, 0.09763257f, 
    0.10766838f, 0.02021110f, 0.12386227f, 0.28224081f, -0.05232900f, 0.41556379f, 0.31938931f, -0.32897288f, 
    -0.18470985f, 0.21713668f, -0.17390032f, 0.30992752f, -0.04743285f, 0.04662536f, 0.05853301f, 0.08468108f, 
    0.07217880f, 0.05875085f, 0.09403580f, -0.00256715f, -0.11944631f, -0.27802974f, -0.05263443f, -0.21877828f, 
    0.11645945f, 0.30327189f, 0.37250936f, 0.13222520f, -0.29143026f, 0.21102479f, 0.01003076f, 0.15613058f, 
    0.11985094f, -0.06051594f, 0.05924538f, -0.08718929f, -0.02830072f, -0.00907991f, 0.10896689f, 0.08879648f, 
    -0.12410145f, -0.20623517f, -0.03517615f, -0.01854317f, 0.37763879f, -0.02560411f, 0.01364610f, 0.12505268f, 
    -0.12920840f, -0.07331988f, -0.04125974f, -0.01942137f, -0.17936555f, 0.08757985f, 0.13255662f, -0.07544035f, 
    0.13044870f, 0.05093348f, -0.11610568f, -0.00573082f, -0.03946828f, -0.02558638f, 0.09100098f, 0.14134710f, 
    0.06415305f, -0.11409694f, 0.09848078f, 0.02882851f, 0.08541555f, -0.21137556f, -0.15315127f, -0.16732261f, 
    -0.20891784f, -0.22010605f, 0.03971240f, -0.04323872f, -0.07821914f, 0.10281535f, 0.19839336f, -0.02526948f, 
    0.02472377f, 0.01586925f, -0.01459069f, -0.18194662f, -0.31594434f, -0.06449212f, 0.11189010f, 0.17714787f, 
    0.15832023f, 0.24954993f, 0.12120075f, -0.12011935f, 0.12824413f, 0.13654482f, 0.06409468f, 0.17168804f, 
    0.03277931f, 0.13182040f, 0.04897265f, 0.23322242f, 0.29733798f, 0.16217594f, 0.03560931f, 0.14489225f, 
    -0.24376099f, 0.02427099f, -0.15349355f, 0.05827861f, -0.03972910f, -0.07334617f, 0.07707709f, -0.01254265f, 
    0.04869787f, -0.04879142f, 0.15202646f, 0.15972356f, 0.13102287f, 0.13078646f, 0.02520427f, -0.00729609f, 
    0.01829202f, 0.07992525f, 0.02907797f, -0.07408865f, -0.02423459f, -0.17365527f, -0.09605827f, -0.02836549f, 
    -0.13444710f, -0.05542659f, -0.08806370f, -0.09609998f, -0.08170559f, 0.05435626f, -0.17809625f, 0.06205092f, 
    0.09337447f, 0.16271262f, -0.11198699f, -0.16736026f, 0.12289169f, -0.04321679f, 0.01666028f, 0.12399460f, 
    -0.14150628f, -0.36833730f, -0.45635709f, -0.04200023f, -0.41612679f, -0.05359975f, -0.02999072f, -0.03708585f, 
    -0.01464250f, 0.02574365f, 0.12289178f, 0.02212827f, 0.06480674f, -0.05224068f, -0.10958650f, -0.06553222f, 
    0.04729537f, 0.03673799f, -0.03527784f, -0.01575707f, -0.22319402f, -0.14626348f, -0.23036468f, -0.08906998f, 
    -0.32940817f, 0.16050309f, 0.13531998f, 0.06083697f, 0.05208434f, 0.05240022f, 0.05786331f, 0.07104920f, 
    0.04811215f, -0.02153497f, -0.07156777f, -0.00266729f, 0.17769161f, -0.01716445f, -0.10150591f, 0.04484611f, 
    -0.05387450f, 0.13533069f, 0.01986614f, 0.09320996f, 0.02560429f, -0.08369396f, 0.04320211f, -0.22565724f, 
    -0.02146503f, -0.00522842f, -0.00309730f, -0.04981456f, -0.09066619f, 0.07179826f, 0.05612632f, 0.01732803f, 
    0.02140903f, 0.11432151f, 0.14105026f, 0.07926124f, 0.02805904f, 0.41236550f, 0.15064521f, -0.07900050f, 
    -0.43016750f, 0.18013452f, -0.13900006f, -0.23022582f, 0.18125685f, 0.03585384f, -0.04500585f, -0.00758268f, 
    0.03520161f, 0.05762870f, -0.01476026f, 0.05782359f, 0.01907494f, 0.00090982f, 0.07352787f, 0.13016705f, 
    0.46288329f, -0.13015792f, 0.03937839f, 0.11967009f, -0.01111531f, -0.12141227f, -0.00236866f, 0.00144428f, 
    -0.00058417f, 0.10615574f, 0.01265055f, 0.04234125f, 0.07701044f, 0.13809185f, 0.18515854f, 0.02767199f, 
    -0.08256359f, -0.02065646f, 0.12012433f, 0.05827093f, 0.20045049f, -0.26122350f, -0.31279391f, -0.07187678f, 
    -0.27703983f, -0.13855846f, -0.10448313f, -0.17264365f, -0.03705436f, -0.01157394f, 0.07335757f, 0.01787319f, 
    0.04562357f, -0.02681805f, -0.14164610f, -0.01235410f, 0.13153034f, -0.12088322f, 0.17537215f, 0.07680912f, 
    -0.05617805f, -0.01883622f, -0.00552586f, -0.02906278f, -0.04664198f, -0.02607961f, -0.02990415f, 0.03873920f, 
    -0.06076402f, -0.06327987f, -0.05801057f, 0.03034839f, -0.01411211f, -0.04903770f, 0.04357485f, 0.00852319f, 
    0.00530872f, 0.00852198f, -0.04990258f, 0.01542992f, -0.05441822f, 0.03711557f, -0.06376211f, -0.02822227f, 
    0.00622309f, -0.01487872f, -0.00126366f, -0.02720780f, 0.01071354f, -0.01649214f, 0.01921970f, 0.00441744f, 
    -0.05566577f, 0.02217253f, -0.05910734f, -0.03006863f, 0.03601535f, 0.04498290f, -0.02998319f, 0.04528994f, 
    -0.04436186f, 0.04205553f, 0.04424973f, -0.02716556f, -0.00962325f, 0.04096500f, 0.03654419f, 0.00176393f, 
    0.00436079f, 0.04279358f, -0.05811669f, -0.00486253f, 0.01540519f, -0.05329023f, 0.01115719f, 0.00061598f, 
    0.03025578f, -0.05769444f, -0.00631111f, 0.01069818f, 0.00205996f, -0.03292122f, -0.03724534f, 0.00639743f, 
    -0.03610814f, -0.03307192f, -0.00723756f, 0.03539743f, -0.00844924f, 0.00601825f, -0.04408986f, 0.03637686f, 
    -0.05449100f, -0.05732924f, 0.05002193f, 0.02657889f, -0.06028838f, -0.02874337f, -0.03803795f, -0.00861306f, 
    -0.06095299f, 0.03502849f, 0.03129089f, 0.02376658f, 0.02745062f, -0.00498178f, 0.03419536f, 0.02424558f, 
    -0.06170588f, -0.00971985f, -0.00901463f, 0.00543486f, -0.01452108f, -0.01370818f, 0.02671502f, -0.02024302f, 
    -0.01345940f, 0.03181723f, -0.00782893f, 0.01712136f, -0.00895792f, -0.04578541f, 0.04255031f, 0.02426116f, 
    -0.01037225f, 0.01642616f, -0.00863990f, -0.02704590f, -0.04414990f, 0.02775043f, 0.03766685f, 0.03875622f, 
    -0.03525088f, 0.00470679f, -0.01295788f, 0.00254828f, -0.05670907f, 0.02591181f, 0.00247487f, -0.01538023f, 
    -0.01285535f, 0.02660806f, -0.00184364f, 0.02610449f, -0.02779736f, 0.00788110f, 0.00002791f, 0.04172480f, 
    -0.00356981f, 0.00537714f, 0.01082589f, -0.00872313f, -0.04688831f, -0.03455909f, -0.04280268f, -0.05947867f, 
    0.02206432f, 0.04857957f, 0.03697877f, 0.00414087f, -0.05144988f, -0.01699213f, 0.02760318f, -0.05249042f, 
    -0.03227955f, -0.05262839f, 0.02484882f, -0.05621125f, -0.00307871f, 0.01744130f, 0.00308230f, -0.02165446f, 
    0.03346214f, -0.06358308f, 0.03317270f, 0.00239406f, 0.00256827f, -0.02009903f, -0.05103828f, -0.03678092f, 
    -0.00256132f, 0.03772227f, -0.04955344f, 0.02863437f, 0.04579519f, 0.02280839f, -0.00785788f, -0.06224633f, 
    -0.04054585f, -0.04810940f, 0.02253470f, 0.01053644f, 0.04616361f, 0.00036472f, -0.06281250f, -0.05548498f, 
    -0.06253707f, 0.01433887f, -0.01131855f, -0.00429996f, 0.00110938f, 0.01320037f, -0.04962749f, 0.02493704f, 
    -0.05633748f, 0.03955413f, -0.06286835f, -0.02418101f, 0.00549836f, -0.06118784f, -0.03424947f, 0.01004611f, 
    0.05396263f, -0.02994541f, -0.01305168f, -0.02173287f, 0.03302819f, -0.04994622f, -0.01334625f, 0.02384335f, 
    -0.04590939f, 0.02989221f, 0.02282884f, 0.03095778f, -0.00250683f, 0.02643007f, 0.02924804f, -0.06464639f, 
    -0.02798544f, -0.01607947f, -0.00988368f, -0.01076565f, -0.06099072f, 0.02477783f, -0.01159333f, 0.03431486f, 
    -0.04873886f, 0.02126989f, 0.03784976f, -0.04785477f, -0.01158856f, -0.04105740f, 0.02048695f, -0.04614562f, 
    0.04103970f, 0.00717355f, 0.04424429f, 0.00899537f, 0.00907713f, 0.02171381f, 0.02441230f, -0.02654047f, 
    0.00583472f, 0.01568014f, -0.05550473f, 0.00026530f, -0.02851741f, -0.03280453f, 0.01637803f, -0.03869081f, 
    -0.03082242f, -0.04910842f, -0.04601393f, -0.02035553f, -0.03678498f, -0.03414363f, 0.00353022f, 0.03501912f, 
    0.03759560f, -0.06287698f, -0.04312759f, -0.01070358f, 0.02083338f, 0.00395847f, -0.01720371f, -0.06276730f, 
    -0.03263056f, -0.03826404f, -0.05478074f, 0.01925576f, -0.02511556f, -0.03894498f, 0.00572574f, 0.04108912f, 
    -0.03624854f, -0.04101305f, -0.03851461f, -0.02024936f, -0.01987943f, 0.03188723f, -0.06552286f, 0.04046949f, 
    -0.02673452f, 0.01720542f, -0.04649079f, 0.02370526f, -0.02069489f, -0.01321289f, 0.01372832f, -0.04134966f, 
    -0.00380898f, -0.03970620f, -0.05626577f, -0.00609712f, -0.04610568f, 0.03530282f, 0.02693036f, 0.04635192f, 
    0.00312463f, 0.04212794f, 0.01460635f, 0.03902647f, 0.01491104f, 0.01089252f, -0.01038107f, 0.03144328f, 
    -0.03247471f, 0.02817088f, -0.04597112f, -0.03205289f, 0.04467770f, -0.02747796f, 0.00734358f, -0.02008498f, 
    -0.03263283f, -0.02157258f, -0.03350614f, 0.03660828f, 0.00634572f, 0.02856107f, 0.02427632f, -0.03954605f, 
    0.03078992f, -0.01512066f, 0.00394525f, 0.01876956f, 0.03809708f, 0.01235521f, 0.01455063f, -0.04938935f, 
    0.29951802f, 0.42890698f, 0.24337316f, -0.04690227f, 0.09308523f, 0.19852380f, 0.19237301f, 0.09305228f, 
    0.13985816f, 0.01787694f, 0.02743113f, 0.10918884f, 0.02394136f, 0.06353455f, 0.15371461f, 0.05631352f, 
    0.02572717f, -0.01713182f, 0.17500032f, 0.02270691f, -0.25053951f, -0.23473009f, -0.25795081f, 0.22554652f, 
    0.35432473f, 0.05503996f, 0.05182881f, 0.06285932f, -0.01132220f, -0.00204651f, -0.09701314f, -0.28725737f, 
    -0.04894461f, 0.11728219f, -0.08682097f, -0.16786709f, -0.13178693f, 0.00180499f, -0.05000817f, 0.23804376f, 
    0.19402307f, 0.06825314f, -0.03347400f, 0.02212086f, -0.04261041f, 0.06590855f, -0.00633800f, 0.38122272f, 
    0.14387217f, -0.03731949f, -0.17287619f, -0.01231109f, 0.13240355f, -0.02693870f, -0.05136233f, -0.02826359f, 
    0.09896148f, 0.09929239f, -0.02001726f, 0.18304950f, 0.32813483f, 0.23186491f, 0.13768861f, 0.12319183f, 
    0.44933301f, 0.24256614f, 0.10843232f, 0.39329788f, 0.09160177f, 0.04955125f, 0.05972952f, 0.02608825f, 
    -0.00259419f, 0.07297525f, -0.00774607f, 0.09906317f, 0.07394423f, -0.20505291f, -0.39334768f, -0.37942970f, 
    -0.02358664f, 0.25674361f, -0.20759426f, -0.10237437f, 0.42096803f, 0.15917276f, 0.26124731f, 0.01702330f, 
    0.03973601f, 0.08705000f, -0.02000762f, 0.06632502f, -0.00381471f, 0.03452690f, 0.14931110f, 0.30382252f, 
    0.13475691f, 0.20515211f, -0.03996854f, -0.09986660f, 0.26938045f, -0.35573387f, 0.19285388f, -0.05660143f, 
    -0.08986539f, 0.01616391f, -0.08392331f, 0.03344126f, 0.11281262f, 0.10245595f, 0.17602126f, 0.11593107f, 
    -0.03557860f, -0.01882954f, 0.09190906f, 0.03810330f, -0.29103470f, 0.09567616f, 0.12438492f, 0.08627754f, 
    0.08336456f, -0.04939787f, 0.03834702f, -0.02466893f, -0.26141736f, 0.03864958f, 0.05404907f, 0.04029138f, 
    -0.03420604f, 0.04603967f, 0.00469665f, 0.02533918f, -0.00528863f, 0.00689741f, 0.11767788f, -0.07893618f, 
    -0.00784159f, 0.02756901f, -0.01733566f, -0.05813539f, 0.44535658f, -0.07136030f, -0.03409377f, 0.08169358f, 
    -0.27916309f, -0.00027264f, -0.19027139f, 0.11664090f, 0.10197566f, 0.03822778f, -0.08619760f, -0.09289742f, 
    -0.07840385f, 0.01407267f, 0.00011135f, -0.02205590f, -0.07117341f, 0.12150908f, -0.04682247f, -0.09257466f, 
    0.43182504f, 0.02994518f, -0.20462105f, -0.15379833f, -0.12135837f, -0.01820124f, 0.10761371f, 0.12718530f, 
    0.14881514f, 0.01322771f, -0.02748732f, 0.10882810f, -0.14951093f, -0.00118220f, -0.07918727f, -0.07084350f, 
    0.03734810f, 0.08651830f, 0.04009498f, 0.08069327f, 0.12054256f, -0.16511360f, -0.01962762f, 0.02772808f, 
    -0.12720454f, 0.00349992f, 0.02685420f, 0.11272358f, -0.08638918f, 0.07919381f, 0.02786338f, 0.02866253f, 
    -0.04654409f, -0.07340068f, -0.01837927f, -0.01828284f, 0.08730154f, 0.24699594f, 0.06634713f, 0.16724604f, 
    0.25607586f, -0.19877416f, -0.49677986f, -0.14582002f, 0.10483098f, 0.07856061f, 0.09832125f, 0.09866740f, 
    0.15357637f, 0.13095701f, 0.06002188f, 0.08114678f, -0.16758390f, -0.08882150f, -0.11926482f, -0.05182286f, 
    0.08091691f, -0.01725462f, 0.02976356f, 0.01954179f, 0.38652548f, -0.26900369f, -0.35140666f, -0.21434823f, 
    0.23196822f, 0.10226605f, 0.12998720f, 0.17467402f, 0.17547970f, 0.07914194f, 0.07323974f, -0.07960515f, 
    -0.10156329f, -0.06021898f, -0.14209121f, 0.00052936f, 0.10293763f, 0.01050588f, 0.08244219f, 0.04873062f, 
    -0.22247297f, -0.17524759f, -0.04015828f, 0.02555413f, -0.07468209f, 0.07286443f, -0.12192630f, -0.12637956f, 
    0.02120907f, -0.03778267f, -0.07972364f, 0.04189366f, 0.03864718f, 0.04738056f, 0.12084205f, -0.03985824f, 
    0.04405156f, 0.07733930f, 0.10104764f, 0.01849263f, 0.00878491f, 0.45729870f, 0.56355065f, 0.15809736f, 
    0.33289766f, 0.00853737f, -0.09471071f, -0.04228419f, -0.01126571f, 0.14967893f, -0.04751755f, -0.02014093f, 
    0.05620063f, -0.00810708f, -0.00621423f, -0.07467616f, 0.08003920f, -0.02492502f, -0.11797457f, -0.13377011f, 
    -0.20904925f, -0.19603238f, -0.05880941f, -0.05643931f, -0.21611448f, 0.00973876f, 0.05071834f, -0.00905859f, 
    -0.09746300f, 0.01921736f, 0.15886852f, -0.01807060f, -0.05076060f, 0.00352602f, 0.01263684f, -0.08580002f, 
    -0.00275864f, -0.03029351f, -0.03538567f, -0.06948160f, 0.11041757f, -0.15970622f, -0.13294092f, -0.20318396f, 
    0.03864383f, 0.07641244f, 0.23720264f, 0.19721483f, 0.09023433f, 0.42198277f, 0.14601009f, -0.02935966f, 
    0.08438525f, -0.03631581f, -0.04661293f, 0.04096856f, 0.09378801f, -0.06417108f, 0.10858169f, 0.20301156f, 
    0.03186402f, 0.03730968f, 0.00846180f, -0.03450806f, 0.01489872f, 0.01954421f, -0.00467843f, -0.03452946f, 
    -0.00678205f, -0.04989829f, 0.01475321f, 0.00897575f, 0.00786480f, 0.01556608f, -0.01578828f, 0.04367179f, 
    -0.04202473f, -0.01375566f, 0.03917328f, 0.00570300f, 0.05611049f, -0.03783373f, 0.00432345f, 0.03787587f, 
    -0.01603589f, 0.02817336f, 0.00475403f, 0.02923860f, -0.03435588f, -0.00474464f, -0.03416162f, 0.03898396f, 
    -0.06282922f, 0.03756924f, 0.04213927f, -0.05644368f, 0.01933707f, 0.03029315f, -0.05087976f, -0.04731800f, 
    -0.00017978f, -0.05446061f, -0.04376967f, -0.05697024f, 0.00801473f, -0.04620900f, -0.05873671f, -0.02537127f, 
    -0.04688885f, -0.03561071f, -0.05064425f, 0.04578429f, -0.06212360f, 0.00305380f, -0.05814967f, 0.03174204f, 
    -0.01351367f, -0.00125424f, 0.02756186f, 0.04738992f, 0.03673351f, 0.03138968f, 0.02613698f, -0.03401390f, 
    -0.04221152f, -0.04961644f, 0.01878582f, -0.01874345f, -0.05154428f, 0.01558687f, -0.04701634f, 0.01377309f, 
    -0.04292692f, 0.04638667f, 0.03114285f, -0.01629225f, -0.00130327f, -0.04756491f, 0.03804024f, 0.03584663f, 
    0.03351310f, -0.00228507f, -0.05905053f, 0.02803898f, -0.00723992f, -0.03329450f, 0.02535857f, 0.01581563f, 
    -0.04133805f, 0.03683633f, -0.05721103f, 0.00362971f, -0.01115236f, -0.03846831f, -0.03749539f, 0.04389639f, 
    -0.05526876f, -0.00939610f, -0.05720275f, -0.05506165f, -0.04851767f, -0.02664964f, 0.02127708f, -0.03934459f, 
    0.04277735f, -0.01053662f, -0.06087532f, 0.01906762f, 0.04186384f, 0.01464534f, -0.05448301f, -0.01061255f, 
    0.02488967f, -0.03056847f, -0.02571557f, 0.01068918f, -0.01752704f, -0.02892161f, -0.00691588f, -0.01390116f, 
    0.02786832f, -0.00117692f, 0.00194799f, 0.04192264f, 0.00045272f, -0.00028470f, -0.01922364f, -0.04699109f, 
    -0.03322991f, 0.05122869f, -0.02583862f, -0.05335089f, 0.00132591f, -0.04440363f, 0.03098877f, -0.05251368f, 
    -0.00155759f, -0.06001087f, -0.03781282f, 0.00473237f, 0.03704700f, -0.00639588f, -0.02726700f, -0.06211128f, 
    0.00426197f, -0.05201561f, 0.00487319f, 0.00698292f, 0.03487548f, -0.05413836f, 0.02210975f, 0.04837575f, 
    -0.04407321f, 0.00590274f, -0.05093274f, 0.01998227f, 0.03031010f, 0.04505593f, 0.04503943f, 0.03484699f, 
    0.03757017f, 0.00345597f, -0.05491782f, 0.00642222f, -0.01856522f, 0.01364322f, 0.03590700f, 0.03394015f, 
    -0.01470943f, -0.04483799f, -0.05006200f, 0.03715392f, -0.05615164f, -0.02346428f, -0.03497516f, -0.05796751f, 
    -0.04352508f, -0.00165389f, -0.04460238f, -0.02953500f, -0.00074024f, 0.04425451f, -0.02159352f, 0.00417183f, 
    -0.04554627f, 0.04151531f, 0.02905502f, -0.05974792f, -0.01440960f, 0.01748706f, 0.01292560f, 0.00462546f, 
    0.01323243f, -0.00542672f, -0.00022061f, -0.01389447f, -0.05154835f, 0.02557333f, -0.03536986f, 0.04079652f, 
    -0.01062343f, 0.00212943f, 0.01932442f, -0.04990257f, -0.00279282f, -0.04161768f, 0.02636274f, 0.01234494f, 
    -0.04748585f, -0.04085160f, -0.03479939f, 0.00932397f, 0.04510662f, 0.02308721f, -0.04665975f, 0.03904990f, 
    -0.03715471f, -0.02838576f, -0.02213172f, 0.02337026f, -0.03462537f, -0.00560908f, -0.05919009f, -0.05045049f, 
    0.00765726f, 0.01989039f, 0.04108962f, 0.04139784f, 0.03384102f, -0.01100596f, -0.00376577f, 0.02996706f, 
    -0.00410172f, 0.04231693f, -0.02284187f, 0.04773833f, -0.04753422f, -0.03110624f, -0.02294227f, -0.00088775f, 
    -0.01653261f, -0.00499624f, 0.02977215f, -0.04989221f, -0.00042364f, 0.01027479f, -0.00437817f, -0.03374327f, 
    0.04571811f, -0.02835009f, 0.03197081f, -0.04107967f, 0.02997208f, 0.03255237f, 0.04524172f, 0.01021515f, 
    -0.05515051f, -0.03993987f, -0.06261003f, -0.03481761f, -0.01198528f, -0.02150793f, 0.04453081f, -0.05398297f, 
    -0.03650435f, -0.04603670f, 0.00258030f, -0.04278357f, -0.03404026f, -0.03155793f, 0.00031229f, -0.03640130f, 
    -0.03932018f, 0.02913089f, -0.03881459f, -0.01418407f, -0.04878748f, -0.00924126f, -0.02655512f, -0.03218349f, 
    -0.05271467f, 0.01257306f, 0.03779298f, -0.03545177f, -0.05955119f, 0.04247374f, -0.04468983f, -0.04405325f, 
    -0.04158416f, -0.05393723f, -0.00083621f, -0.05568950f, 0.02057368f, 0.01634016f, 0.04789829f, -0.03247168f, 
    -0.05095163f, 0.00766571f, -0.01747435f, -0.01361478f, 0.01098224f, 0.01159745f, -0.03648758f, -0.05088807f, 
    -0.00614838f, 0.02159563f, 0.01805389f, -0.04670544f, -0.03381384f, 0.01606449f, -0.00287593f, -0.00167160f, 
    0.04661398f, 0.04518342f, -0.02296879f, -0.03507235f, -0.03721154f, 0.00223080f, -0.00878834f, -0.00139752f, 
    -0.02512249f, 0.04437876f, 0.03044878f, 0.02509497f, -0.05861165f, 0.01036815f, 0.00068355f, 0.01749856f, 
    -0.04729041f, 0.01895467f, -0.05263891f, 0.01412378f, 0.02703127f, -0.02671259f, 0.02058338f, -0.02271170f, 
    0.02822399f, -0.04006896f, 0.04605991f, -0.02851603f, -0.00970908f, -0.06061098f, 0.00966646f, -0.01404951f, 
    0.04469510f, -0.03091513f, 0.02016013f, 0.02025644f, -0.02305670f, 0.02041295f, 0.00582338f, -0.01952427f, 
    -0.04307081f, 0.03890188f, -0.02741492f, 0.00485516f, 0.04810564f, -0.00628179f, -0.04856255f, 0.04893701f, 
    0.03397774f, -0.01860543f, -0.01054326f, -0.04781729f, -0.02339552f, -0.05846160f, 0.01681301f, 0.02005102f, 
    0.01756330f, -0.05564621f, -0.04403597f, -0.01016091f, -0.00463297f, -0.04341272f, -0.04125978f, -0.03983419f, 
    0.02962161f, 0.02084139f, -0.00715602f, -0.03798528f, -0.01201521f, 0.01138269f, 0.01429549f, -0.05861522f, 
    0.01441295f, 0.01327024f, 0.04914065f, -0.03268464f, -0.03966944f, 0.03899254f, 0.02188348f, -0.05560277f, 
    -0.00433698f, 0.00701519f, -0.01395098f, 0.00899871f, -0.04840997f, -0.00323120f, -0.05628248f, -0.00032605f, 
    -0.04135007f, 0.00444611f, -0.05129694f, 0.00426609f, 0.00449807f, -0.03962497f, -0.05703339f, 0.00643293f, 
    0.03004253f, 0.02555814f, -0.01459523f, -0.04703502f, -0.01084815f, -0.01591526f, 0.03860429f, 0.00955415f, 
    -0.01262692f, 0.01035761f, -0.03868628f, 0.00483262f, -0.01466676f, 0.00274093f, 0.04421411f, 0.00521327f, 
    0.03636792f, 0.03392109f, 0.04027005f, -0.02846104f, -0.05350139f, 0.00687647f, 0.02430827f, 0.01339744f, 
    -0.04376637f, -0.01949541f, -0.03412958f, -0.02854380f, -0.05661835f, -0.01948198f, 0.01641268f, 0.02608120f, 
    0.03181871f, 0.02429728f, 0.02392695f, -0.02062723f, 0.01182619f, -0.05148683f, -0.00801370f, 0.00912854f, 
    -0.01092330f, -0.05977008f, -0.03434735f, -0.03558781f, 0.02382035f, -0.05452016f, 0.03653058f, 0.03700117f, 
    0.02572357f, -0.00141581f, 0.04442620f, -0.05595529f, 0.02842181f, -0.01578531f, -0.00772317f, 0.03901453f, 
    -0.04596151f, -0.01040055f, 0.04201645f, 0.01443237f, -0.04582898f, -0.03939993f, -0.03517928f, -0.02045977f, 
    0.03498685f, 0.02479983f, -0.05022181f, -0.00717837f, 0.03381832f, 0.03006493f, 0.00218657f, -0.04586406f, 
    -0.02294865f, 0.04153784f, -0.02087630f, 0.03906582f, -0.02634356f, 0.04812900f, -0.00797007f, -0.00984488f, 
    0.04093430f, 0.03118472f, -0.03101388f, -0.04933679f, -0.05607013f, -0.02057423f, 0.01444707f, 0.01896484f, 
    -0.01134316f, -0.01318057f, 0.04035571f, -0.03915538f, 0.01408956f, 0.02128406f, 0.00677113f, 0.01255320f, 
    -0.03991367f, 0.01936553f, 0.04784182f, -0.05825561f, 0.01555366f, -0.04377348f, -0.00761115f, 0.00709682f, 
    0.02577871f, -0.01979987f, 0.01278460f, -0.03677243f, -0.05756856f, 0.04252951f, -0.04689880f, 0.04985149f, 
    0.02599889f, 0.02038259f, -0.00200309f, 0.02200049f, 0.04249151f, 0.05049351f, -0.03928994f, -0.03625288f, 
    -0.00437547f, 0.00634181f, -0.04753603f, -0.00971453f, -0.04160714f, 0.04100524f, 0.01507706f, 0.01954531f, 
    0.03828238f, -0.03345905f, 0.02717796f, 0.02049236f, 0.04894683f, 0.00866046f, 0.00017317f, -0.02315675f, 
    0.04265777f, 0.02014603f, 0.01262327f, -0.05114514f, 0.04635281f, 0.01738127f, 0.04550352f, -0.03520086f, 
    -0.03088549f, -0.01981501f, -0.05384029f, -0.03536038f, 0.00386315f, -0.01529104f, -0.03429858f, -0.00625991f, 
    0.01517939f, -0.05988909f, 0.04229871f, -0.04925812f, -0.05345393f, -0.04731039f, -0.01041938f, -0.05314129f, 
    -0.05451641f, 0.01619681f, -0.03159483f, -0.01074011f, 0.02239154f, -0.02720165f, -0.04571986f, -0.02027952f, 
    -0.02020960f, 0.02367910f, 0.03737009f, 0.01051799f, 0.02980670f, -0.02988897f, -0.05459161f, 0.00358613f, 
    -0.04983964f, -0.04412053f, -0.03411618f, 0.00728521f, -0.05742984f, -0.03638879f, 0.00996324f, 0.04437199f, 
    0.03232387f, -0.04095568f, -0.01912677f, 0.00084842f, -0.03137842f, -0.02987874f, -0.00655938f, -0.03476904f, 
    -0.02906752f, -0.02186908f, -0.00241470f, 0.03049702f, -0.01318012f, 0.03505586f, -0.04831315f, 0.00033067f, 
    -0.04177747f, 0.01311526f, -0.00220292f, -0.02693351f, -0.00569029f, -0.06014882f, 0.03494256f, -0.00167066f, 
    -0.05691344f, -0.05029505f, 0.02786246f, 0.04627126f, -0.04120444f, -0.06117286f, -0.04667486f, -0.01595772f, 
    -0.03254713f, -0.04280667f, -0.03298002f, 0.03653968f, -0.05060120f, 0.00770730f, 0.00470405f, -0.00801046f, 
    -0.05873086f, 0.02617718f, 0.03988068f, -0.00904177f, 0.02407439f, 0.00082211f, 0.04280645f, -0.04398330f, 
    0.36924621f, 0.12451648f, 0.30819318f, -0.00086366f, 0.09036517f, -0.03061040f, -0.01009786f, 0.11430552f, 
    -0.01610679f, 0.17449144f, 0.00968798f, -0.01605053f, -0.13399750f, 0.13025390f, -0.16101553f, 0.03910333f, 
    0.00372950f, 0.00230270f, -0.02611548f, 0.06669511f, -0.00120780f, -0.38349211f, 0.13381413f, 0.32707155f, 
    -0.03440511f, -0.14927725f, -0.01577938f, 0.25691915f, 0.10756035f, -0.04307624f, -0.25694421f, 0.20275532f, 
    0.02839619f, -0.05038837f, 0.23207517f, -0.06311922f, -0.04060864f, 0.15710546f, -0.01737217f, 0.00848016f, 
    0.09930708f, -0.01800113f, 0.12517063f, -0.02192726f, 0.01240656f, 0.04275909f, 0.05777507f, 0.16238154f, 
    0.09449924f, 0.07681369f, 0.19344047f, 0.25553444f, -0.05191671f, -0.13696451f, 0.04794035f, -0.15530959f, 
    -0.13812311f, -0.16541004f, -0.22764829f, -0.19945395f, 0.12105366f, -0.04290631f, -0.11660879f, 0.14445922f, 
    0.27350459f, -0.09399911f, 0.27804735f, 0.22662096f, 0.11894644f, 0.31919673f, 0.00730689f, -0.03226386f, 
    -0.03888093f, -0.07784253f, -0.09239746f, 0.24735510f, 0.16468047f, 0.18023159f, 0.16875315f, 0.29663974f, 
    0.20465374f, 0.06333215f, -0.24627562f, -0.08232135f, 0.10749449f, 0.01559075f, 0.21003488f, -0.00635445f, 
    0.18148366f, 0.19436160f, 0.02624180f, 0.09183052f, 0.17033029f, 0.19539991f, 0.17570373f, 0.14660758f, 
    0.23018976f, 0.22956887f, 0.23578677f, 0.31788093f, -0.78035736f, -0.65760756f, 0.50716257f, 0.04129404f, 
    -0.00156944f, 0.16238172f, 0.01831775f, 0.19734219f, 0.25894561f, -0.54604989f, -0.07216080f, 0.10010669f, 
    -0.06223398f, 0.03142699f, 0.04774237f, 0.14070737f, 0.13943610f, -0.14429881f, -0.05167047f, -0.23531297f, 
    0.17242964f, -0.01355552f, -0.10588802f, 0.11930922f, -0.07058795f, 0.21471532f, 0.12320349f, 0.16922802f, 
    0.04693445f, -0.05387418f, -0.07605265f, 0.05282542f, 0.20411833f, 0.04839386f, -0.10160005f, -0.13908538f, 
    0.02924534f, -0.14963257f, -0.14544252f, -0.02096439f, 0.15227158f, 0.02751840f, 0.18491626f, -0.04104878f, 
    -0.18498862f, -0.04172311f, -0.03876269f, 0.07947329f, -0.00748402f, -0.33599347f, -0.08337869f, 0.15807411f, 
    -0.00591454f, 0.08913923f, 0.09036070f, -0.17199378f, -0.04060096f, -0.11899137f, -0.20567787f, -0.08479825f, 
    0.52300119f, -0.08625354f, -0.00756634f, 0.09048395f, -0.25193000f, 0.01946737f, -0.02397987f, -0.18403049f, 
    -0.05574618f, -0.12687281f, 0.00710584f, -0.02738553f, 0.10321777f, 0.12465523f, -0.14368740f, -0.12235199f, 
    0.03387720f, -0.01619028f, -0.08191057f, -0.06022770f, 0.17068930f, 0.14632042f, -0.10725401f, -0.18980324f, 
    -0.22685578f, 0.01892553f, -0.10566044f, 0.01557102f, 0.14645772f, -0.30180752f, 0.09183826f, 0.16754280f, 
    0.01206277f, -0.03353962f, 0.12488741f, 0.16002271f, -0.09760247f, -0.05833526f, -0.19043431f, -0.53792834f, 
    0.47121397f, 0.09343600f, -0.08468035f, 0.10612898f, -0.07583938f, 0.05799194f, -0.06876014f, -0.14653771f, 
    -0.01062523f, -0.21904206f, 0.03474901f, 0.05603142f, 0.04264541f, 0.06442973f, -0.02256685f, -0.03946668f, 
    0.06925670f, -0.08473459f, -0.07154617f, 0.01378297f, 0.52951831f, -0.08281462f, 0.04550410f, -0.11571886f, 
    -0.08425193f, 0.04384542f, -0.15893158f, -0.19070964f, 0.02234139f, -0.20660581f, 0.01245736f, -0.00173359f, 
    0.03353333f, -0.05528638f, -0.03562258f, -0.07252608f, -0.19987890f, -0.08360801f, 0.03529925f, 0.10558927f, 
    0.02461134f, -0.13831651f, 0.13417777f, 0.22631210f, -0.08577174f, -0.05878767f, -0.02857420f, 0.03963447f, 
    0.08219712f, -0.12854162f, -0.16053510f, 0.11485294f, 0.06280679f, 0.01837276f, 0.06194810f, -0.01077122f, 
    0.04238918f, -0.01095101f, -0.21844207f, -0.19913629f, 0.02242703f, 0.10374093f, 0.38515055f, 0.24809532f, 
    0.20008817f, 0.05923424f, 0.11166539f, 0.24040902f, 0.12220390f, 0.24585781f, 0.04036885f, -0.05486760f, 
    0.03820273f, 0.01148576f, -0.08782075f, 0.08338905f, -0.06582584f, 0.12738129f, 0.11340234f, 0.18549694f, 
    -0.26282665f, 0.08963407f, -0.27146813f, 0.19418415f, -0.27770722f, 0.11194418f, -0.11544789f, 0.05242154f, 
    -0.10162414f, -0.34262091f, -0.15342648f, -0.06901828f, -0.00345669f, 0.07755820f, 0.05868132f, -0.04646912f, 
    0.00568451f, 0.04873797f, -0.05071328f, -0.05141860f, -0.33234906f, 0.16384040f, 0.14337334f, 0.08275764f, 
    0.05848867f, -0.01480097f, 0.09101371f, 0.31594613f, -0.06086074f, 0.10507607f, 0.15643981f, 0.11217387f, 
    -0.18392527f, -0.05666495f, -0.04662659f, -0.06763902f, -0.25924376f, -0.24236090f, -0.38844794f, -0.42839709f, 
    0.12175561f, 0.07537041f, 0.22519432f, -0.13996968f, -0.03696942f, 0.12820226f, 0.10525375f, 0.00574947f, 
    -0.01297231f, -0.02410876f, 0.07416754f, -0.00368133f, -0.05105935f, -0.10988549f, 0.04184552f, 0.00786160f, 
    0.04419806f, -0.03416424f, 0.21000309f, 0.08702409f, 0.40103230f, 0.05109277f, -0.35352275f, -0.28829136f, 
    -0.16731614f, -0.10555799f, 0.04654645f, 0.00023455f, 0.22701465f, -0.05235149f, 0.10210200f, 0.01994338f, 
    -0.06610024f, -0.06136839f, 0.07602634f, -0.08853703f, -0.00574693f, 0.01741531f, 0.08528206f, 0.04037101f, 
    0.09906022f, 0.05248055f, 0.00911079f, 0.01861048f, -0.11495124f, -0.09088721f, -0.02529408f, 0.11076585f, 
    0.16042624f, -0.04299137f, 0.00960597f, 0.12442338f, -0.08055560f, -0.04789997f, 0.05376253f, 0.05405517f, 
    -0.01392679f, -0.01358073f, -0.03980433f, 0.01722136f, -0.05966449f, 0.39743587f, 0.24987651f, -0.20269012f, 
    -0.28112578f, 0.02286552f, -0.06724524f, -0.02898311f, 0.02686925f, 0.00531221f, 0.04500781f, -0.01395925f, 
    0.13294044f, -0.08478037f, 0.00283069f, -0.02999852f, 0.03467658f, 0.06061038f, -0.11619917f, 0.10472782f, 
    0.27539453f, 0.16021758f, 0.33071774f, -0.07923143f, -0.14930011f, 0.12799072f, 0.08238141f, 0.06643572f, 
    -0.06831048f, -0.00006656f, -0.04260834f, -0.03723417f, -0.07411493f, -0.06887095f, -0.07518215f, 0.09343763f, 
    -0.20180261f, -0.14035043f, 0.03303438f, 0.01183367f, 0.48512533f, -0.08274815f, 0.08195017f, -0.16383399f, 
    0.26629436f, -0.27126905f, -0.01164815f, 0.17640340f, -0.04787220f, 0.15516694f, -0.11032367f, 0.05966467f, 
    -0.13480625f, 0.03983852f, -0.09013755f, -0.13747692f, 0.01756041f, 0.05416529f, 0.00091281f, 0.14306404f, 
    0.17243202f, 0.07232048f, -0.10295742f, 0.05219353f, 0.17677426f, 0.03287075f, 0.03376905f, 0.01349950f, 
    -0.01362141f, 0.07941122f, 0.05568406f, -0.03128118f, -0.10306179f, -0.05905933f, -0.00108886f, -0.10937785f, 
    0.00772445f, 0.07670742f, 0.06666127f, 0.01060930f, -0.43006456f, -0.16633244f, 0.15322572f, 0.28213677f, 
    0.05237660f, 0.07919421f, -0.16859105f, 0.03676105f, 0.18145312f, 0.24180026f, 0.06675342f, 0.04598280f, 
    0.04931976f, -0.09773644f, -0.06425991f, -0.04148833f, -0.05611169f, -0.05437184f, -0.03670960f, 0.03595851f, 
    -0.56037533f, 0.10643853f, -0.11070216f, -0.15056564f, 0.06532829f, -0.03712038f, -0.02684201f, 0.03725733f, 
    0.16380110f, 0.01543593f, 0.02689775f, 0.00174721f, 0.03833747f, 0.10125843f, -0.02570434f, -0.02178435f, 
    0.02632624f, 0.01857515f, -0.02229551f, -0.02054754f, 0.08260581f, -0.03649886f, 0.00537466f, 0.05604140f, 
    -0.00371725f, 0.02476854f, -0.08142720f, -0.00756883f, 0.05511828f, 0.03974202f, -0.07541018f, -0.03126523f, 
    -0.07455722f, 0.07662347f, -0.06117171f, -0.10507790f, -0.02899537f, -0.03920904f, -0.03725007f, -0.00777129f, 
    0.01364168f, 0.16963509f, -0.15249319f, -0.02636041f, -0.07261848f, -0.01203810f, 0.09177750f, 0.15587603f, 
    -0.02308364f, 0.09910172f, 0.01300615f, -0.02209369f, -0.11599471f, 0.00928524f, -0.01331887f, 0.00581697f, 
    0.03982747f, 0.07531981f, -0.03053203f, -0.01453349f, -0.04967421f, 0.18213893f, -0.00653631f, 0.02979941f, 
    -0.22586276f, 0.10126924f, 0.14884047f, 0.20338565f, -0.17846748f, 0.02414389f, -0.03611339f, 0.06282242f, 
    -0.01987641f, 0.02898943f, -0.07750018f, 0.02353825f, 0.04856956f, -0.05811231f, -0.09282518f, 0.03048093f, 
    0.20890382f, -0.03056540f, -0.24748437f, -0.06327489f, 0.09382283f, -0.08877056f, 0.04971857f, 0.05002653f, 
    0.07387341f, 0.01383455f, -0.06220219f, -0.04720047f, -0.01111999f, -0.00312044f, 0.00883936f, 0.00706118f, 
    -0.12793323f, -0.08361202f, -0.11537817f, -0.08151081f, 0.01150437f, 0.14539230f, -0.17457230f, -0.02671367f, 
    -0.23198371f, -0.07054327f, -0.02290997f, -0.02583285f, 0.15170780f, 0.01407641f, 0.05112611f, -0.01448725f, 
    0.06390401f, 0.03669657f, 0.03012529f, -0.01851292f, -0.01561256f, -0.02548992f, 0.06404749f, 0.10726024f, 
    -0.08073053f, -0.22366242f, -0.30180469f, 0.15126748f, 0.14550865f, 0.03960683f, -0.02222388f, -0.05185684f, 
    0.04017996f, 0.05257956f, 0.18741786f, 0.06725590f, -0.00075742f, -0.10979766f, 0.01010532f, 0.05544505f, 
    -0.00401557f, 0.01728139f, -0.05429844f, 0.07857565f, 0.15330979f, 0.14659494f, -0.06441024f, 0.06402782f, 
    -0.02391438f, -0.04730168f, 0.03054973f, 0.12711710f, -0.09607124f, -0.27837521f, 0.08117591f, -0.11165345f, 
    -0.07051650f, -0.01819527f, 0.06220797f, -0.03389638f, -0.02757501f, -0.00617961f, -0.09876242f, 0.11961439f, 
    0.04097945f, -0.10966202f, 0.21753894f, 0.25467288f, -0.35744125f, 0.17485224f, 0.29751876f, 0.09340411f, 
    0.12631406f, 0.11123744f, 0.27873516f, 0.01724000f, -0.03749168f, 0.04457351f, 0.16593817f, -0.05032049f, 
    0.09585505f, 0.01999486f, 0.08071549f, 0.19228008f, 0.11963908f, 0.07928640f, -0.10577539f, -0.85621220f, 
    -0.04224079f, 0.20182474f, 0.08244951f, -0.21250792f, -0.16054392f, -0.01536997f, 0.04801780f, 0.00971012f, 
    0.08194091f, -0.10548813f, 0.07081268f, 0.13247602f, 0.10809019f, -0.23389336f, 0.07824991f, 0.01285109f, 
    0.14678237f, 0.34415761f, 0.28825453f, 0.07077356f, -0.18114550f, 0.11372695f, -0.06124390f, 0.09250439f, 
    -0.01042545f, 0.01509156f, -0.09632798f, 0.13790323f, -0.00226501f, -0.08428973f, 0.01729737f, 0.01854979f, 
    0.00471514f, 0.02087530f, -0.09861066f, -0.13780996f, 0.10492577f, 0.09837657f, 0.41522974f, -0.07260729f, 
    -0.12180483f, -0.02551237f, 0.03127263f, 0.13778999f, 0.22878857f, 0.05618206f, 0.00914061f, -0.06454802f, 
    0.05555199f, 0.06199232f, -0.01736958f, 0.21942258f, 0.26675969f, 0.05648346f, 0.15793091f, 0.05454557f, 
    -0.36536056f, -0.13708568f, 0.23515034f, 0.26512110f, -0.16188717f, -0.04790216f, -0.01447842f, -0.07075477f, 
    0.06519427f, 0.08988189f, -0.00875839f, -0.09111308f, -0.03161108f, 0.08100763f, 0.14249508f, 0.10325834f, 
    0.15269881f, 0.05694685f, 0.15371233f, 0.13392624f, 0.26684442f, -0.50223696f, -0.20155303f, -0.20070086f, 
    0.09226492f, -0.05231274f, -0.14231792f, 0.09981135f, -0.21854129f, -0.00964296f, 0.19118221f, 0.12183909f, 
    0.16444018f, -0.05466268f, 0.09462012f, -0.00970247f, -0.17474242f, -0.01029974f, 0.05292410f, 0.23914407f, 
    0.08363637f, 0.09790836f, -0.41211507f, 0.01978083f, 0.24803695f, -0.13889402f, -0.30254644f, -0.30656791f, 
    -0.06460457f, 0.23952872f, 0.21812548f, 0.14263745f, -0.00331223f, 0.13163958f, 0.05916948f, -0.00488447f, 
    0.04119586f, 0.25949225f, 0.12304293f, -0.01364263f, -0.39511895f, 0.35175544f, -0.29062074f, 0.51034069f, 
    0.03553331f, -0.02572489f, -0.20331751f, -0.02091418f, -0.04876822f, 0.23853838f, 0.06593177f, 0.11067057f, 
    0.08485364f, 0.00860991f, -0.01797261f, -0.03886358f, -0.01574934f, 0.18409352f, -0.06145794f, -0.01073685f, 
    -0.13945335f, 0.38999048f, 0.04019649f, 0.01771462f, 0.09455377f, -0.10383315f, -0.18551776f, -0.10021829f, 
    0.20751372f, 0.00868056f, 0.25199369f, 0.01161199f, -0.01022310f, 0.12897184f, -0.01772066f, -0.13379472f, 
    -0.11468247f, 0.10921793f, 0.02595480f, -0.01930615f, 0.01446476f, 0.54177105f, -0.48947072f, 0.28731865f, 
    -0.08227558f, -0.21901502f, -0.10705625f, -0.02692251f, -0.21291128f, 0.03003211f, 0.18749702f, -0.13545352f, 
    0.14005832f, 0.04461631f, -0.08239052f, 0.20331399f, -0.10143938f, -0.15077230f, -0.14764103f, -0.06586406f, 
    0.04413467f, 0.16417050f, 0.50391483f, 0.21627535f, 0.09517777f, -0.09917512f, -0.12608562f, -0.18710299f, 
    0.14974834f, -0.02207355f, 0.15820257f, -0.04307670f, 0.01113652f, 0.10566164f, -0.04690928f, -0.04474466f, 
    -0.16972704f, 0.02603535f, 0.00279540f, -0.05110759f, 0.04355060f, 0.27034187f, 0.37412456f, 0.17593165f, 
    0.00649902f, -0.02876022f, -0.03903936f, 0.14168698f, 0.17262922f, 0.07991759f, 0.07022248f, -0.04561921f, 
    0.09214708f, 0.11704730f, 0.00029554f, -0.10821241f, -0.04703644f, -0.07756571f, -0.14131060f, -0.04189356f, 
    -0.19629131f, -0.30271855f, -0.50417173f, -0.54357135f, 0.21033633f, 0.10814200f, -0.09955326f, 0.02857617f, 
    -0.19907165f, 0.04153766f, 0.09793864f, -0.00729999f, -0.00677350f, -0.02270257f, -0.07357916f, 0.14992107f, 
    -0.11524414f, -0.06511034f, -0.21520199f, -0.21923864f, -0.20137174f, -0.10294454f, 0.04062002f, -0.08186695f, 
    -0.11307482f, 0.01699740f, 0.14667097f, -0.02083003f, -0.00740835f, 0.15954009f, 0.00786209f, -0.10890209f, 
    -0.01695601f, -0.04356790f, -0.05489546f, 0.00950074f, 0.17010055f, 0.05635091f, -0.02960028f, 0.06843771f, 
    -0.49037948f, 0.03937387f, 0.17405115f, -0.41963232f, 0.31527820f, 0.02076375f, -0.45184547f, -0.14171025f, 
    -0.12701167f, 0.07302748f, 0.10429064f, 0.16289620f, 0.08309239f, 0.05037771f, 0.12764409f, 0.02927794f, 
    -0.06492056f, 0.21996918f, -0.09941039f, -0.05558799f, 0.35859290f, 0.00914801f, 0.49560922f, -0.50550407f, 
    -0.01972024f, 0.02426761f, 0.03484656f, -0.17368701f, 0.03566576f, -0.08012643f, 0.07180703f, 0.11977853f, 
    0.09973651f, 0.13597710f, -0.06582087f, 0.07705216f, -0.21463810f, -0.27851740f, -0.17137870f, 0.04484542f, 
    -0.04518897f, -0.04163648f, -0.05623362f, -0.05622675f, -0.06146290f, -0.01121062f, 0.03654600f, -0.05414826f, 
    0.02371383f, -0.03459834f, 0.02160411f, -0.01056426f, -0.06413359f, -0.04156674f, -0.01331282f, 0.02439958f, 
    -0.06283440f, -0.00664753f, -0.00536554f, 0.01974350f, -0.04237368f, -0.00685838f, 0.04353222f, -0.03228568f, 
    -0.04642089f, 0.00886035f, -0.06288178f, -0.02558373f, -0.05197933f, -0.05854217f, -0.02115557f, 0.00820120f, 
    -0.01463725f, 0.04406979f, 0.01485503f, 0.03118035f, -0.04487371f, -0.05588472f, 0.00796890f, -0.03758020f, 
    0.03845247f, -0.01661148f, 0.01387413f, -0.02978354f, 0.02421651f, 0.02690258f, -0.04705391f, -0.02737528f, 
    0.00719088f, 0.00254678f, -0.04604854f, -0.02162576f, 0.00399080f, 0.01347597f, -0.01178624f, -0.06098156f, 
    -0.05191460f, -0.04340789f, -0.02319674f, 0.00632496f, -0.01151458f, -0.00258769f, -0.03591374f, -0.03629987f, 
    0.03578742f, -0.05313649f, -0.05420983f, -0.01983247f, -0.04391069f, -0.02668198f, -0.00373883f, -0.06201457f, 
    -0.03216577f, -0.02284051f, -0.04560642f, -0.05971919f, -0.05597865f, 0.03968374f, 0.00262883f, 0.00710783f, 
    -0.01681003f, -0.01563709f, -0.04443581f, 0.00959121f, 0.01133358f, 0.04562715f, 0.02972511f, -0.02817943f, 
    0.03038254f, -0.04301545f, -0.02287738f, 0.02010775f, -0.02048528f, -0.02840995f, -0.00110430f, -0.04018718f, 
    0.00263586f, -0.06140918f, -0.00147550f, -0.06050239f, -0.02257420f, -0.05354139f, -0.00261495f, 0.00165982f, 
    -0.02912596f, -0.06388677f, -0.03264989f, 0.03504750f, 0.00701457f, 0.04674247f, -0.03473052f, -0.04157216f, 
    0.03339882f, 0.00244215f, 0.02631957f, -0.01664091f, -0.04648442f, 0.01073807f, 0.02702898f, -0.05447042f, 
    -0.05212744f, 0.00883185f, -0.02510148f, -0.05382420f, 0.03411780f, 0.01324556f, 0.00400792f, 0.00095836f, 
    -0.00099612f, -0.01456294f, 0.02870554f, 0.02632040f, -0.04461917f, -0.01700983f, -0.04984017f, -0.01797840f, 
    -0.00983714f, -0.01027812f, 0.00584519f, 0.02146949f, -0.02759923f, -0.06079386f, 0.04593210f, 0.01052719f, 
    0.04135515f, -0.05562474f, -0.00793625f, 0.02822137f, -0.05183817f, -0.04893332f, 0.04210595f, -0.04992988f, 
    -0.01116976f, -0.03668407f, 0.02047779f, -0.02440516f, 0.02460759f, -0.01335707f, 0.03322334f, 0.00964039f, 
    -0.00411093f, -0.02958977f, 0.00731039f, -0.03753865f, -0.04487640f, 0.00211682f, 0.00960357f, 0.01625721f, 
    0.01264129f, 0.03002569f, -0.02684642f, 0.00088476f, -0.02396640f, -0.01932770f, 0.00095103f, -0.03401861f, 
    -0.04265071f, 0.02817095f, -0.03785549f, -0.00665735f, -0.04974761f, -0.03408267f, -0.00122458f, 0.01133478f, 
    0.00612081f, -0.02322399f, 0.04524128f, 0.01629892f, 0.04538312f, -0.02456480f, 0.02214767f, -0.04960025f, 
    -0.01993672f, -0.04872901f, -0.01432501f, -0.04720002f, -0.02882833f, -0.06290557f, 0.02197632f, -0.03146788f, 
    -0.06394144f, 0.01639304f, 0.04208894f, 0.02563879f, -0.00235005f, -0.03543923f, 0.01694290f, 0.02100175f, 
    -0.01262682f, -0.04781802f, 0.00813952f, 0.04489147f, 0.00811551f, 0.02861018f, -0.03471532f, -0.00432782f, 
    0.01309155f, 0.00004414f, -0.00787132f, -0.04408935f, -0.05083285f, 0.01026251f, 0.01481031f, -0.00342445f, 
    -0.04297899f, -0.04747156f, 0.00690935f, -0.01357331f, 0.04129233f, -0.04294572f, 0.01007641f, 0.02338091f, 
    -0.02034970f, -0.02347924f, -0.05490769f, -0.04667743f, 0.02573377f, -0.04569702f, -0.05736275f, -0.04299572f, 
    -0.04035669f, 0.02925950f, -0.05127867f, 0.00662863f, -0.02671602f, -0.02284306f, 0.02544068f, 0.03794926f, 
    0.02180486f, 0.00972663f, -0.05836491f, -0.01153903f, -0.02928928f, 0.01583951f, -0.05065543f, -0.01803730f, 
    -0.00038946f, -0.05556775f, 0.00320884f, 0.02961125f, -0.04061377f, -0.05733829f, -0.02752554f, 0.03985576f, 
    0.03467998f, -0.01678698f, -0.03563203f, -0.02293178f, 0.03555437f, 0.04683201f, -0.01789659f, -0.01405949f, 
    -0.04469675f, -0.05060789f, 0.02463267f, -0.06436745f, -0.04720207f, -0.04232718f, 0.01243626f, -0.03862216f, 
    -0.04369090f, -0.03240209f, -0.01005863f, -0.00021437f, -0.04883179f, -0.02562327f, -0.03961623f, -0.02185567f, 
    -0.01393182f, -0.00446417f, -0.01090184f, -0.03263198f, 0.02214467f, -0.05456353f, -0.03176757f, 0.00319926f, 
    0.03017243f, -0.03625029f, -0.05303318f, -0.01518262f, 0.02628365f, -0.02576267f, -0.02970518f, 0.02031327f, 
    0.05577866f, 0.00598731f, -0.04269734f, 0.02029277f, -0.00846426f, -0.05065965f, -0.01440250f, -0.02764273f, 
    0.01527261f, -0.01810505f, -0.04273946f, -0.02706131f, 0.03543023f, -0.05397692f, -0.02837703f, 0.00782617f, 
    -0.01868136f, -0.04101762f, -0.03563813f, 0.04006615f, -0.05365012f, -0.04217101f, -0.00840021f, -0.04046882f, 
    -0.05596558f, 0.00593331f, -0.01803972f, -0.03198528f, -0.05351505f, 0.02167554f, -0.02452666f, -0.02866599f, 
    0.02799288f, -0.04545395f, -0.00292367f, -0.02655031f, 0.00244380f, 0.03449057f, -0.02488242f, -0.05924322f, 
    0.02218634f, -0.05823664f, 0.02519180f, -0.04493736f, -0.04450940f, -0.00484376f, 0.02539427f, -0.02483927f, 
    -0.04707852f, -0.02818310f, -0.04667303f, -0.02814985f, -0.02603037f, -0.02281173f, 0.02309090f, -0.02830912f, 
    0.03884950f, -0.00524157f, 0.02374098f, -0.04255913f, -0.01150600f, 0.04470748f, -0.05416277f, 0.03087122f, 
    0.01551339f, 0.03545599f, 0.03456356f, -0.05518725f, 0.03470430f, 0.03716788f, -0.02169249f, -0.03042734f, 
    0.00886664f, -0.03941593f, 0.03154749f, 0.01629445f, 0.03388866f, 0.03264072f, -0.01643223f, 0.02889820f, 
    0.01408427f, -0.01308671f, 0.02829977f, -0.05228538f, -0.03858793f, -0.04483664f, -0.02186579f, 0.02992752f, 
    0.01418827f, -0.04518432f, 0.02434744f, -0.02473652f, 0.04078878f, -0.02001408f, -0.03365212f, 0.02776797f, 
    -0.01316713f, -0.02634751f, 0.04695141f, 0.04779381f, -0.02633239f, 0.02452694f, -0.04312030f, -0.05109569f, 
    0.01274680f, 0.03256989f, -0.05287364f, 0.00705714f, -0.04300294f, 0.01456709f, 0.01661631f, -0.03955417f, 
    -0.03379186f, 0.01257971f, 0.04966176f, -0.01058089f, -0.03158940f, 0.02562463f, -0.02621138f, 0.02959325f, 
    0.02075246f, -0.04963183f, -0.05262701f, -0.02064870f, 0.00734077f, -0.06366865f, 0.04471966f, 0.00738595f, 
    -0.03525324f, -0.01288697f, -0.05416636f, -0.04514011f, 0.01776665f, -0.01369588f, 0.02298302f, 0.03860166f, 
    0.00556448f, -0.04269629f, -0.02795929f, -0.02586381f, 0.01756941f, 0.02190612f, 0.02558905f, -0.02974823f, 
    0.03575091f, -0.05108594f, -0.04663977f, -0.00038818f, -0.00814614f, 0.03428490f, -0.00958390f, 0.04119372f, 
    -0.05543708f, 0.04362686f, -0.02747689f, -0.05705648f, -0.03065979f, 0.04328190f, 0.01680439f, 0.03556743f, 
    -0.04816002f, -0.03064230f, -0.05223804f, -0.03855712f, 0.04366132f, 0.04823238f, -0.01769721f, -0.02051605f, 
    -0.00079578f, 0.00961258f, -0.00124473f, -0.04108008f, 0.04092247f, 0.00094198f, 0.00501001f, -0.05865791f, 
    -0.03173767f, 0.00853597f, -0.00175360f, -0.03415077f, -0.00258768f, 0.01546372f, -0.01452809f, 0.02219093f, 
    -0.05537024f, 0.01376769f, -0.01547142f, -0.00614097f, -0.03125782f, -0.05317090f, -0.00200689f, -0.03007645f, 
    -0.00670258f, -0.06199355f, -0.04471399f, -0.00381669f, -0.04976040f, 0.04252651f, -0.03125436f, 0.01800203f, 
    0.03806656f, -0.00966492f, -0.06155136f, -0.01356888f, -0.03407340f, -0.00682599f, -0.03554713f, 0.04905409f, 
    0.02490899f, -0.01061576f, -0.02860834f, 0.02337643f, 0.02973640f, 0.02910291f, -0.00549805f, -0.01533264f, 
    0.02778815f, 0.01080840f, -0.02358479f, 0.00958816f, 0.01067029f, 0.03240015f, -0.04191156f, -0.00717467f, 
    -0.04353252f, 0.03579821f, -0.01682331f, 0.03432968f, -0.03575927f, 0.04673589f, -0.01231985f, 0.04519686f, 
    0.04481831f, 0.04731648f, 0.02079177f, -0.03027609f, -0.05255518f, 0.02980384f, -0.05284488f, -0.02063963f, 
    0.01527678f, 0.00171521f, -0.04821530f, -0.00193688f, 0.05135227f, 0.00642280f, -0.01626537f, -0.03322192f, 
    -0.02348077f, 0.03338676f, -0.05060605f, 0.02982667f, -0.01828597f, -0.05932236f, 0.03095435f, 0.01633282f, 
    0.01626631f, -0.03188120f, 0.01169386f, 0.01657915f, 0.03215435f, -0.01497793f, -0.02601118f, 0.04090993f, 
    -0.00333459f, 0.02500043f, 0.01583459f, -0.02004946f, 0.02265440f, -0.03877498f, -0.01634998f, -0.05661278f, 
    -0.05019546f, -0.01246571f, 0.00003085f, -0.06079892f, 0.02406415f, 0.04764874f, -0.02327810f, -0.04941211f, 
    -0.02453440f, 0.03146627f, 0.03329243f, 0.00475231f, 0.05608199f, -0.01281592f, -0.00652295f, 0.01899455f, 
    -0.04910158f, 0.04459304f, 0.00478175f, -0.00096858f, 0.00533109f, 0.01429141f, 0.01231281f, -0.03032291f, 
    -0.05567530f, -0.05412311f, 0.00114596f, -0.02465115f, 0.00581753f, -0.01084101f, -0.04493626f, -0.05338331f, 
    -0.01225391f, 0.03066011f, -0.04156713f, -0.01005139f, -0.03214369f, 0.03655026f, 0.02468991f, 0.03510831f, 
    0.02061629f, -0.02335394f, 0.04168363f, 0.01812921f, 0.04156308f, -0.05622101f, 0.02866570f, -0.04618652f, 
    0.00929838f, -0.02589919f, 0.00321691f, -0.05211711f, -0.01899264f, -0.02979810f, -0.04216148f, 0.04140942f, 
    -0.03505260f, -0.04918398f, 0.05144150f, 0.01923052f, -0.05373360f, 0.00499967f, 0.01500666f, 0.01102238f, 
    -0.23808175f, -0.15787663f, -0.20586076f, -0.39307302f, -0.26330549f, 0.12376852f, 0.05256594f, 0.15721767f, 
    0.01270115f, 0.08454313f, 0.00866879f, -0.00329806f, 0.06209723f, 0.03861050f, -0.07007200f, 0.09491198f, 
    -0.00034058f, 0.08363435f, 0.13590185f, 0.18003592f, -0.01036481f, 0.31800532f, -0.21293469f, 0.27615947f, 
    -0.05824052f, -0.12828285f, -0.01226250f, -0.18439357f, 0.07478932f, -0.04512794f, -0.02727360f, 0.23841175f, 
    -0.14248601f, -0.07609204f, 0.28326523f, 0.08049213f, 0.20114763f, 0.12251657f, 0.14204802f, 0.18858705f, 
    -0.12600736f, -0.04787346f, -0.02856434f, -0.19409227f, -0.01252716f, -0.13553500f, -0.06869674f, -0.21303393f, 
    0.13425446f, -0.15857938f, 0.06893946f, 0.03281274f, -0.12174220f, 0.00448386f, 0.03082519f, 0.04905267f, 
    0.03247226f, 0.10798239f, 0.19145305f, 0.12120625f, -0.05757215f, -0.44653770f, -0.16501816f, -0.16879968f, 
    -0.14736564f, 0.00245744f, 0.14356956f, -0.03673515f, 0.04413431f, -0.18284024f, 0.02310503f, -0.03133160f, 
    0.05037730f, 0.01626387f, 0.13464963f, 0.04387868f, -0.15270092f, 0.24254289f, 0.20449178f, 0.16597456f, 
    -0.08883400f, -0.01253765f, -0.26017892f, -0.02061796f, -0.17060596f, 0.01303043f, -0.14068085f, 0.12182903f, 
    0.02245186f, 0.10746650f, 0.02316280f, -0.00393329f, 0.05166675f, 0.03787281f, -0.02817030f, -0.05532489f, 
    -0.20874311f, 0.01270768f, -0.01964617f, -0.10167035f, -0.06597017f, 0.55401719f, -0.16770953f, 0.25291604f, 
    -0.20965706f, 0.05984027f, -0.03613753f, -0.14010029f, 0.17299184f, -0.02479625f, 0.03655508f, -0.13615005f, 
    0.02238949f, 0.06315831f, 0.05064343f, 0.02482526f, 0.18578991f, -0.06100007f, 0.12478966f, -0.01580401f, 
    -0.33656067f, -0.26299870f, -0.10933293f, -0.09798708f, 0.07152201f, -0.07495184f, -0.09513035f, -0.16043226f, 
    -0.09983291f, -0.09014241f, -0.12393466f, 0.24234757f, 0.03949340f, 0.08815426f, 0.02256433f, 0.08015956f, 
    0.07179161f, -0.09632494f, 0.02663930f, -0.07687620f, -0.07817768f, 0.14160161f, -0.04479806f, 0.00697742f, 
    0.32606390f, 0.00756841f, 0.18863742f, -0.14361688f, 0.14190450f, 0.02571675f, 0.24561617f, 0.17130429f, 
    0.04290378f, 0.03594623f, 0.06710224f, 0.24644928f, 0.12742427f, 0.00772908f, 0.29876775f, 0.05940978f, 
    -0.23048699f, 0.07451203f, 0.36722386f, 0.24505049f, 0.25720176f, -0.01618812f, 0.05227023f, 0.04577556f, 
    0.00225607f, 0.01777153f, 0.07512070f, 0.23131849f, 0.12886694f, -0.05564601f, 0.02274336f, 0.02897926f, 
    -0.00897476f, 0.01456917f, 0.13884880f, -0.02253598f, -0.21254440f, -0.14363979f, 0.13011180f, 0.01123542f, 
    0.05966322f, -0.07910851f, -0.02090494f, 0.01124495f, 0.10899679f, -0.00784612f, 0.06485555f, 0.04889921f, 
    -0.28154251f, 0.03960921f, 0.05852012f, -0.08869608f, 0.11951058f, -0.08774634f, 0.13472062f, 0.02387556f, 
    -0.38274312f, 0.29676035f, 0.30996746f, -0.01692449f, -0.00568251f, -0.07923730f, -0.09901612f, 0.03865205f, 
    0.03136925f, 0.02118522f, -0.08104241f, 0.09445046f, 0.01410544f, 0.01831115f, -0.03660641f, -0.02806075f, 
    -0.03942261f, -0.02398957f, -0.05111619f, 0.02358678f, -0.43345058f, 0.30237854f, 0.13199894f, -0.00927791f, 
    -0.15381341f, -0.10426947f, -0.07159328f, 0.00466852f, 0.08892856f, 0.06301145f, 0.05292211f, 0.07437684f, 
    -0.02563054f, -0.02598258f, -0.00717900f, 0.03746561f, 0.05791440f, -0.02185841f, 0.02841722f, -0.02420402f, 
    0.03812551f, 0.11923613f, 0.04475773f, 0.11961932f, 0.05153761f, -0.01349657f, 0.07935270f, -0.06680605f, 
    -0.01141077f, 0.05250528f, -0.05261258f, 0.00516257f, -0.01156273f, 0.10205919f, -0.02559178f, -0.10208184f, 
    0.04143811f, 0.09408764f, 0.10015984f, -0.04114159f, 0.11718334f, -0.26207775f, -0.41359377f, -0.14247760f, 
    -0.28767872f, 0.11742432f, 0.20207883f, 0.03981917f, 0.07346991f, -0.13646622f, 0.08062215f, 0.07634674f, 
    0.03785652f, 0.09607457f, 0.13169488f, 0.02883820f, 0.02998049f, 0.32392818f, 0.13334665f, 0.10379057f, 
    0.10386802f, 0.13355471f, 0.19136502f, 0.03283784f, 0.24797991f, -0.00157161f, 0.07722158f, -0.01435808f, 
    0.05157789f, 0.08440680f, -0.05169988f, 0.09725673f, 0.12503619f, 0.14554763f, 0.13065308f, 0.10015180f, 
    -0.02677897f, 0.07305939f, 0.10551520f, -0.08059430f, -0.14806628f, -0.01284805f, -0.19902666f, 0.08543117f, 
    -0.10858297f, -0.15214312f, -0.29453143f, -0.24293347f, -0.04743985f, -0.17769359f, -0.03642296f, 0.08264924f, 
    -0.10425927f, -0.07482958f, -0.03563107f, -0.10906743f, -0.03014466f, 0.11472084f, -0.04790114f, -0.04259885f, 
    0.35307339f, -0.11812849f, 0.45463076f, 0.07627258f, -0.23557369f, 0.15781400f, 0.09469572f, 0.10587724f, 
    -0.01260623f, 0.06155749f, 0.10326526f, -0.06437048f, -0.03571637f, 0.02242698f, 0.03643891f, -0.02880309f, 
    -0.04086206f, -0.09905615f, 0.30024490f, 0.13194157f, 0.30050847f, -0.34817430f, -0.03214787f, -0.51043069f, 
    0.20010431f, 0.03443639f, 0.14703563f, 0.03660531f, 0.09853762f, 0.03262884f, -0.01698544f, -0.05218635f, 
    0.07859419f, -0.09310401f, -0.09682657f, -0.05809730f, -0.00407297f, 0.06025418f, 0.03350886f, -0.05359355f, 
    0.14763279f, 0.17878993f, -0.02325116f, 0.05145821f, -0.00713132f, -0.04843472f, -0.13083296f, 0.13010184f, 
    -0.01885117f, -0.02961731f, 0.00069683f, 0.14258324f, 0.04372374f, -0.09390498f, -0.00431185f, -0.06023022f, 
    0.05701919f, 0.04660852f, -0.11128332f, -0.00894373f, 0.10935788f, 0.50336426f, 0.23987360f, 0.02043870f, 
    0.18710101f, -0.03488595f, 0.04005306f, 0.10607974f, 0.19783789f, 0.13405451f, 0.05727569f, -0.00188608f, 
    0.12213088f, 0.06732772f, -0.06397780f, 0.10675219f, 0.12131340f, 0.11971109f, -0.05985509f, -0.18213746f, 
    0.09599903f, -0.03437115f, 0.21210103f, -0.26340711f, -0.11797114f, 0.09868309f, 0.02686458f, 0.00207204f, 
    -0.05115997f, 0.03979617f, 0.05533569f, -0.03408845f, -0.03555504f, 0.17449115f, 0.14618693f, 0.15203305f, 
    -0.06581436f, -0.06692746f, -0.01585375f, -0.07259726f, 0.82114768f, -0.44850650f, 0.19885670f, -0.09331768f, 
    -0.00184648f, 0.15746781f, -0.02090508f, 0.01630736f, -0.16318059f, -0.05483520f, 0.03563685f, 0.08501659f, 
    -0.03361752f, -0.07101798f, 0.12450674f, -0.05063895f, -0.03108448f, -0.06039413f, -0.06659545f, 0.10608941f, 
    0.09275395f, 0.30236000f, -0.16800329f, 0.01361940f, 0.06421945f, 0.00300727f, 0.05996526f, -0.05255684f, 
    0.12052111f, 0.07412963f, -0.00906888f, -0.04143338f, -0.03041281f, 0.08471520f, 0.07361621f, -0.12376734f, 
    0.01244877f, 0.08454221f, -0.01220084f, 0.05327498f, -0.15209059f, 0.08535329f, -0.11467700f, 0.14079639f, 
    0.03697946f, 0.04720508f, -0.16511074f, -0.04785981f, 0.06913494f, 0.11719289f, 0.05605012f, 0.01961654f, 
    -0.00441107f, 0.01104068f, -0.02850074f, 0.04825442f, -0.03737586f, -0.04642259f, -0.12669882f, 0.03220658f, 
    -0.37404829f, 0.26614892f, -0.40907079f, -0.15296614f, -0.11061268f, -0.08019781f, -0.02269990f, -0.00746189f, 
    0.10586319f, 0.11294037f, 0.19759358f, 0.03633327f, -0.05363080f, 0.05373699f, -0.03863989f, -0.09102380f, 
    0.00344941f, 0.05471926f, -0.00340936f, 0.03585763f, 0.07743964f, 0.12044949f, -0.13637216f, -0.10124370f, 
    -0.02637593f, -0.08284217f, 0.00015654f, -0.17497681f, 0.08847935f, 0.01164878f, 0.05732772f, -0.02912515f, 
    -0.05340661f, -0.14358513f, 0.00869263f, 0.06104520f, -0.03038971f, 0.07221546f, -0.12661211f, 0.01620085f, 
    -0.12316656f, -0.06050476f, -0.37132040f, -0.16011149f, -0.12488617f, -0.05885122f, 0.05688949f, -0.05920012f, 
    -0.08769248f, 0.21216030f, 0.07004201f, -0.02806158f, -0.02446283f, -0.04480760f, 0.00276768f, 0.02677845f, 
    0.05027997f, 0.00250994f, -0.03086947f, -0.03449451f, 0.03953940f, -0.14763515f, -0.21184224f, -0.04056735f, 
    -0.20023257f, 0.13582510f, 0.05934769f, -0.02469997f, -0.03391901f, 0.12626962f, 0.02855881f, -0.04745482f, 
    0.06604504f, -0.05256318f, -0.01524946f, 0.01356409f, -0.03730655f, -0.02452845f, -0.10959391f, -0.01989626f, 
    0.16987911f, 0.07014593f, -0.16408463f, 0.02522362f, 0.14955129f, 0.04243672f, 0.08851545f, 0.05997689f, 
    -0.08883019f, -0.04347828f, -0.08023646f, 0.03283558f, -0.03406831f, -0.07542646f, 0.01200728f, -0.02112337f, 
    -0.00359301f, 0.02786634f, -0.19677289f, -0.12332299f, 0.44571105f, 0.28675297f, 0.11867340f, 0.27202243f, 
    0.11390205f, -0.09431934f, 0.15936901f, 0.07275659f, 0.15783279f, 0.05207277f, -0.03475012f, -0.00109648f, 
    -0.02370390f, 0.02871761f, 0.10028481f, -0.06538270f, 0.03853283f, 0.10735700f, 0.15068054f, -0.00264387f, 
    -0.48131332f, -0.22979411f, -0.36021021f, -0.04516794f, 0.09353475f, 0.01718535f, 0.04217853f, 0.02432407f, 
    0.00876019f, -0.04138226f, 0.04765142f, 0.08300710f, 0.13719118f, 0.04882952f, 0.04827471f, -0.01960505f, 
    -0.09038541f, 0.12994960f, -0.13042895f, 0.10102119f, 0.23331346f, -0.00420984f, 0.01621624f, -0.15590200f, 
    -0.02963697f, -0.10992026f, 0.03193585f, -0.03003292f, -0.04015173f, 0.08815215f, 0.07413722f, 0.05430032f, 
    -0.02303768f, -0.02947856f, 0.07794177f, -0.00100297f, -0.02590037f, 0.02858582f, -0.06762818f, 0.01236915f, 
    -0.32178518f, 0.18560036f, -0.06073412f, -0.03377964f, 0.33918598f, -0.04041143f, 0.06137134f, 0.02061917f, 
    0.14232594f, -0.09982540f, 0.01895006f, -0.02106862f, -0.05331095f, -0.10336576f, -0.04419549f, 0.01928852f, 
    0.07126962f, 0.12126791f, 0.03523669f, -0.11047561f, 0.39281306f, 0.71066171f, 0.06902486f, -0.05850056f, 
    -0.22006579f, 0.01258189f, -0.14553033f, 0.07786922f, -0.14344698f, 0.09425819f, 0.10704334f, -0.02912948f, 
    0.06391607f, -0.07516788f, 0.07097937f, 0.14274892f, -0.06355914f, -0.03212586f, -0.03778534f, 0.04053171f, 
    -0.23872814f, -0.05501662f, 0.27223885f, -0.08416277f, -0.03657762f, 0.02195972f, 0.10036462f, -0.05240925f, 
    0.07972239f, 0.11101687f, 0.23079993f, -0.18330730f, 0.04732403f, -0.02038150f, 0.00489991f, -0.13258500f, 
    -0.02682955f, -0.21888599f, 0.08319020f, -0.10222939f, -0.02265434f, 0.03268307f, -0.23343022f, 0.08527568f, 
    -0.02940064f, 0.06518563f, 0.11692514f, -0.14380382f, 0.04900741f, 0.07613751f, -0.04924696f, 0.03848238f, 
    -0.05322440f, 0.04909643f, -0.01887593f, 0.02437852f, 0.22396617f, 0.14488558f, -0.05166576f, 0.23012410f, 
    0.28250885f, 0.20691930f, 0.04264271f, 0.14050183f, 0.19154643f, 0.19973402f, 0.10443338f, 0.02975070f, 
    0.11985789f, 0.11325117f, 0.07643628f, 0.02298406f, -0.02194460f, -0.05645197f, -0.06706932f, 0.06751225f, 
    0.15059066f, 0.21331009f, 0.07848796f, 0.05216894f, -0.75174373f, 0.36885503f, -0.32670972f, -0.27974114f, 
    0.21410275f, -0.26413354f, 0.19592236f, -0.01589440f, -0.00575919f, 0.25401595f, -0.03347448f, 0.02079120f, 
    -0.08097430f, -0.10165121f, -0.04234349f, -0.08885914f, 0.30215532f, 0.08843432f, 0.01384494f, -0.01523513f, 
    0.19692218f, 0.11064754f, 0.22611311f, 0.17602588f, 0.14565273f, 0.00512600f, -0.17826204f, 0.00483928f, 
    -0.14862749f, -0.03947045f, 0.04474920f, 0.09638494f, 0.11111461f, -0.02325890f, -0.02529546f, 0.03083070f, 
    -0.06654587f, -0.23566598f, 0.04488030f, -0.02108897f, -0.34387404f, -0.18013495f, 0.11655324f, -0.14958955f, 
    -0.14872183f, -0.04364589f, -0.02722475f, 0.08339984f, -0.06261586f, 0.02329418f, 0.06608507f, 0.10908097f, 
    0.04394685f, -0.09520169f, 0.11557517f, -0.07975537f, -0.00554463f, -0.11229307f, 0.15715460f, -0.09093027f, 
    0.14386927f, -0.15022629f, 0.39099613f, -0.10874768f, 0.04914875f, -0.01778729f, -0.10864099f, 0.00356187f, 
    -0.22358885f, -0.16269340f, 0.03978568f, 0.00038007f, 0.06043130f, 0.09235042f, 0.14218988f, 0.09964959f, 
    0.11325102f, -0.09805407f, -0.10603799f, -0.01551218f, -0.39557683f, 0.12760150f, 0.16015844f, 0.02080493f, 
    0.11869809f, -0.09403763f, -0.13200606f, -0.01515270f, -0.31800818f, -0.04350487f, 0.00385461f, 0.04716915f, 
    0.02539682f, 0.04844933f, 0.00421358f, -0.05778194f, -0.16518773f, -0.13504429f, -0.11367898f, -0.22600248f, 
    0.08848985f, 0.35483959f, 0.28213701f, -0.06222288f, 0.20528711f, -0.09011816f, 0.01784377f, -0.04537026f, 
    -0.06239029f, -0.13152409f, 0.00115395f, 0.04930916f, 0.09576599f, 0.15417638f, 0.10583650f, -0.01607936f, 
    0.05797611f, -0.09368625f, 0.00622072f, 0.00294708f, -0.07388040f, 0.09583972f, 0.16925581f, 0.09528147f, 
    0.11158895f, -0.09701150f, -0.03284466f, -0.01217786f, 0.04317087f, 0.02380669f, -0.00228054f, 0.17271738f, 
    0.00820205f, 0.04478794f, 0.05458271f, 0.09403241f, -0.08342837f, -0.06488610f, 0.10182312f, -0.06565513f, 
    0.18754534f, -0.10934770f, -0.01932372f, -0.24033470f, 0.08147886f, 0.08637884f, -0.05255577f, 0.07668182f, 
    0.06092970f, -0.06781733f, 0.05825840f, -0.05825527f, -0.05204810f, -0.06097784f, 0.05868408f, -0.06332838f, 
    -0.04557847f, -0.07439045f, 0.12437548f, 0.04101637f, -0.05900161f, -0.01655982f, -0.40507740f, -0.04975592f, 
    0.29086384f, -0.08817936f, 0.05678211f, 0.26593664f, -0.03151139f, 0.05769883f, 0.09832067f, -0.17530395f, 
    -0.04252756f, 0.02530947f, -0.01215222f, 0.01342767f, 0.00986955f, -0.02495571f, -0.03381777f, 0.08420855f, 
    0.96146852f, 0.28928474f, -0.00413364f, 0.09862737f, -0.11178493f, -0.03088282f, -0.12176650f, -0.12523486f, 
    -0.03280696f, -0.16509873f, 0.05976288f, 0.02048252f, -0.05752935f, -0.06414957f, -0.02490233f, 0.07424583f, 
    0.11265071f, -0.02472218f, 0.06143363f, -0.06756105f, -0.24911286f, 0.44337508f, 0.14688928f, -0.05263564f, 
    -0.08386201f, -0.02780414f, 0.08362181f, 0.02262030f, -0.07602952f, -0.06595683f, 0.05296551f, 0.07564010f, 
    -0.07194518f, 0.08705749f, -0.09820799f, -0.12024933f, -0.12884638f, 0.12167741f, -0.12560619f, -0.14865342f, 
    0.03031523f, -0.04729670f, 0.02722955f, 0.03415366f, 0.01600129f, 0.01482400f, 0.02284503f, 0.02244080f, 
    0.04659962f, -0.01466938f, -0.04889052f, -0.00017578f, -0.04500796f, 0.02267816f, -0.02813904f, -0.02702205f, 
    -0.02237859f, 0.03485160f, -0.04352740f, -0.02530263f, -0.03971549f, -0.01491775f, -0.01329323f, -0.04410034f, 
    -0.03387933f, -0.03247135f, 0.04011326f, -0.03983755f, 0.01914906f, -0.01485193f, -0.05647367f, 0.03086256f, 
    0.01165357f, 0.03925911f, 0.03326904f, 0.01689191f, 0.04949558f, -0.02462315f, 0.01913633f, -0.00554298f, 
    -0.03416964f, -0.02405932f, -0.05741600f, -0.03576324f, -0.03837183f, 0.02153439f, 0.00027377f, -0.05758796f, 
    0.04071043f, -0.01370625f, -0.02771188f, -0.00827158f, 0.00016641f, -0.05626242f, -0.04401525f, -0.01235245f, 
    -0.05203308f, -0.02133556f, -0.05167092f, 0.00899903f, -0.05109519f, -0.05957652f, -0.04070314f, 0.02369757f, 
    -0.00050003f, 0.00748697f, -0.04803861f, 0.01499807f, -0.03525833f, 0.03994160f, 0.01147695f, -0.04469081f, 
    0.01877047f, -0.03047730f, -0.02170181f, -0.05681764f, -0.05584340f, 0.01200129f, -0.03188381f, 0.04596238f, 
    -0.01619675f, 0.03916576f, -0.01214437f, 0.01847157f, -0.00117067f, 0.01855545f, -0.05645631f, 0.00749759f, 
    0.02823592f, -0.05390612f, -0.01446365f, 0.03840483f, 0.00445045f, -0.02385951f, -0.01122806f, 0.04303665f, 
    -0.00547610f, -0.04828788f, -0.01819899f, 0.00258408f, -0.01886984f, -0.03000928f, -0.03879731f, 0.03664364f, 
    0.05390483f, -0.02490308f, 0.04114170f, -0.06163837f, 0.03868091f, -0.04156293f, -0.04458212f, 0.02054801f, 
    0.03002454f, 0.04576509f, 0.01894443f, 0.03937823f, 0.02951703f, -0.03545056f, 0.03629190f, -0.01688268f, 
    -0.03612333f, 0.00043731f, -0.00564116f, -0.03220086f, -0.06078649f, -0.03644810f, -0.03093916f, -0.05202890f, 
    -0.02640200f, -0.03163630f, 0.00199957f, 0.02380383f, -0.00240276f, -0.02923157f, 0.00724589f, 0.02736512f, 
    -0.05286789f, -0.06066370f, -0.03304731f, 0.00151112f, -0.03378056f, 0.01117422f, 0.01995847f, -0.01455294f, 
    -0.03846392f, -0.05963504f, -0.01344418f, 0.01185929f, 0.02644690f, -0.02357789f, 0.04856891f, -0.02253449f, 
    -0.00338979f, -0.01092201f, -0.03392541f, -0.00662019f, -0.00090879f, -0.04538043f, -0.00976956f, 0.03466494f, 
    -0.05782579f, 0.02123040f, -0.05364050f, 0.02514067f, -0.04675568f, 0.02852754f, -0.02646012f, -0.02831486f, 
    -0.05579709f, 0.01735983f, -0.03871015f, -0.04763620f, -0.03694068f, 0.04016817f, -0.04172937f, 0.01703755f, 
    0.04842486f, -0.05392375f, 0.03968763f, -0.04652972f, -0.03433104f, -0.05885896f, -0.01749127f, -0.04593114f, 
    -0.00121787f, 0.01070179f, -0.05404749f, 0.02256879f, -0.00060948f, -0.03962978f, 0.02461178f, -0.03272670f, 
    -0.05496721f, 0.02340238f, 0.02206037f, -0.03799678f, 0.01806490f, 0.03061235f, -0.04211112f, 0.02409936f, 
    0.03271553f, 0.00014384f, 0.03109770f, -0.04870458f, 0.00597338f, -0.05118166f, 0.02333956f, -0.04287892f, 
    -0.03415100f, 0.02834778f, -0.05197722f, 0.01987085f, 0.04295909f, 0.03164070f, 0.01399528f, 0.01189355f, 
    -0.02295072f, -0.03909089f, -0.04094939f, 0.03296217f, -0.03072504f, 0.02094531f, 0.02187314f, 0.04719867f, 
    -0.02317403f, -0.00867402f, -0.05159495f, -0.01704160f, 0.01831522f, -0.02516665f, -0.02099984f, 0.03547616f, 
    -0.01624793f, -0.00944406f, -0.05208197f, 0.01281534f, 0.04275270f, 0.03548610f, -0.00924372f, -0.04754934f, 
    0.01434083f, -0.02647224f, -0.06130127f, -0.02168158f, 0.04852470f, -0.02284570f, 0.03921637f, -0.04259183f, 
    0.04605902f, -0.02893589f, 0.00773099f, -0.01164681f, 0.03340354f, -0.04459352f, -0.01855228f, 0.03073408f, 
    0.02145169f, -0.03701323f, 0.03356892f, -0.06127152f, 0.00316316f, -0.04124215f, -0.00734237f, 0.00788605f, 
    0.02552126f, 0.00660901f, 0.00597919f, 0.01728648f, -0.04903796f, 0.00457195f, -0.00818701f, -0.05729894f, 
    0.00522698f, 0.00942260f, -0.02980679f, -0.03728026f, 0.04968659f, 0.04136758f, 0.01226189f, 0.00665612f, 
    0.03598063f, -0.04720824f, 0.00416687f, -0.04459899f, 0.04679213f, 0.02727235f, -0.00967867f, -0.04913317f, 
    -0.03444178f, -0.01470626f, 0.01995412f, 0.03048695f, -0.06147923f, -0.00490018f, -0.05112462f, -0.01339164f, 
    0.01445038f, 0.03560936f, -0.02325138f, 0.00386244f, -0.05429428f, 0.03530487f, 0.03022545f, 0.05313096f, 
    0.03552414f, 0.01836552f, 0.01344448f, 0.05047237f, -0.00207204f, -0.02906637f, -0.02007268f, -0.01979855f, 
    -0.02391238f, -0.02603192f, 0.03103306f, -0.03175423f, -0.03305645f, 0.04643406f, -0.06007719f, 0.03448534f, 
    -0.06197761f, 0.21508600f, -0.16642311f, -0.21681717f, 0.40218294f, -0.05494009f, -0.18604070f, -0.06080960f, 
    0.03763961f, -0.07730044f, -0.09025804f, -0.02010854f, 0.05479649f, -0.05101426f, -0.08014125f, 0.06077018f, 
    0.00725603f, 0.10839197f, -0.10451020f, -0.02884288f, -0.01444416f, 0.20080295f, 0.13455270f, 0.45683405f, 
    -0.31913513f, -0.12971789f, -0.00821707f, 0.21069615f, 0.15608391f, 0.01728139f, 0.01079397f, 0.12565111f, 
    0.16041917f, 0.18739712f, 0.06229712f, 0.05425210f, 0.00723857f, 0.08735041f, 0.00704435f, 0.00178511f, 
    -0.17550179f, -0.33405414f, -0.17059430f, -0.05793311f, 0.04943693f, 0.01239303f, 0.20438440f, -0.05855129f, 
    0.09188001f, 0.14481840f, 0.18117011f, 0.03540574f, -0.08118337f, 0.10403191f, 0.07265247f, 0.01575111f, 
    -0.05252403f, -0.16144457f, 0.11196814f, 0.06100757f, -0.14700305f, 0.00718111f, -0.18571560f, -0.08848397f, 
    -0.12587237f, 0.05822025f, -0.06802702f, -0.09251698f, -0.15534587f, 0.09728765f, 0.01029598f, 0.09597544f, 
    0.03916751f, 0.08527920f, 0.20609723f, -0.07862289f, -0.03291163f, -0.13701406f, 0.12968746f, 0.11280159f, 
    0.40878654f, 0.31606683f, 0.06804115f, -0.01938397f, 0.08599880f, 0.16480790f, 0.00168624f, 0.08917621f, 
    0.10981952f, -0.00126577f, -0.01440708f, 0.01606741f, -0.01574115f, 0.01763741f, 0.04659870f, 0.06637701f, 
    -0.00629909f, 0.11993318f, 0.15504777f, 0.21082723f, -0.50068069f, 0.47146550f, 0.02985149f, 0.11442015f, 
    -0.10273860f, -0.15040588f, 0.12584741f, -0.01160148f, -0.11449299f, 0.05355380f, -0.03282570f, -0.00522410f, 
    -0.07816504f, 0.06094258f, -0.13469714f, 0.11549102f, 0.29033861f, 0.10509477f, -0.00496255f, -0.07848423f, 
    0.04969176f, 0.01142446f, 0.12361196f, 0.06035025f, 0.11433720f, -0.07650205f, -0.09001470f, 0.04397779f, 
    -0.06442666f, -0.18361396f, 0.06217347f, 0.06031745f, 0.03113526f, 0.07047760f, 0.08352608f, 0.03080251f, 
    -0.17147852f, -0.19491628f, -0.07365071f, -0.13181858f, -0.08057860f, -0.19117959f, 0.24825700f, -0.11803395f, 
    -0.00003491f, 0.09947917f, 0.19512144f, 0.04099745f, 0.00415290f, 0.06094235f, -0.00420370f, 0.02454901f, 
    -0.04547243f, 0.16198526f, 0.06788868f, 0.15046853f, 0.20535998f, -0.12662664f, 0.18030295f, 0.10843275f, 
    -0.03956112f, -0.25174955f, 0.11806794f, 0.08651558f, 0.05655679f, 0.08607712f, 0.03387230f, 0.00299167f, 
    -0.11556534f, -0.08130367f, -0.12163487f, 0.01237500f, 0.14657567f, 0.03348199f, 0.05547441f, 0.09324572f, 
    -0.01698764f, -0.12728715f, 0.06672857f, -0.05652106f, -0.18397491f, -0.24733861f, 0.16896190f, -0.04706156f, 
    0.01256272f, -0.00635800f, -0.09831406f, -0.04260750f, -0.06936741f, -0.04907051f, -0.03623110f, 0.22091389f, 
    -0.03623102f, 0.14869630f, -0.07436560f, -0.23734315f, 0.03868414f, -0.08936294f, -0.07149744f, -0.08701137f, 
    -0.08575230f, -0.03768834f, -0.09226688f, -0.08549065f, -0.14286016f, 0.05168127f, -0.03096328f, 0.17034048f, 
    0.01630036f, -0.12542883f, -0.02719336f, 0.03390416f, 0.13783287f, 0.01064069f, -0.06122968f, 0.01033634f, 
    -0.02483323f, -0.00358553f, -0.07482480f, -0.03879933f, -0.15792723f, -0.11980049f, -0.13005447f, 0.06010352f, 
    -0.05125981f, 0.02692051f, 0.14010219f, 0.08426202f, -0.03302452f, -0.00253065f, -0.05721730f, 0.08180533f, 
    -0.08543595f, 0.06933071f, 0.03412408f, 0.00708707f, -0.00241445f, 0.00064410f, -0.02541529f, 0.06628580f, 
    0.14354391f, 0.14445782f, 0.14486562f, 0.23572078f, -0.03604874f, 0.03681589f, 0.06698429f, -0.07388072f, 
    0.07352787f, -0.08525708f, -0.06032242f, 0.05099280f, -0.01471421f, 0.11587398f, 0.07736994f, -0.00423733f, 
    0.10493542f, -0.01739866f, 0.03520771f, -0.01683727f, 0.09351765f, 0.19321622f, -0.17991023f, 0.02551897f, 
    -0.08145817f, -0.07190380f, -0.12078187f, -0.02864019f, 0.03610094f, -0.04827942f, -0.02387325f, -0.03187558f, 
    -0.03524968f, 0.02557190f, 0.04122466f, 0.01213312f, -0.03165942f, 0.08387753f, -0.04757591f, 0.10845216f, 
    0.80469865f, 0.05330893f, 0.02862622f, 0.23991798f, -0.08660474f, 0.01193144f, 0.12629296f, 0.04738047f, 
    0.01046142f, -0.00893294f, -0.07719114f, 0.05542965f, -0.06292441f, -0.02043877f, -0.04914957f, -0.01476644f, 
    -0.05778179f, -0.10208806f, 0.02815034f, -0.00053598f, -0.16079722f, -0.04746656f, -0.27585915f, 0.22868256f, 
    -0.06470901f, -0.01643546f, -0.05109819f, 0.09673734f, 0.00157388f, 0.02626679f, -0.03344821f, 0.02543620f, 
    -0.13153167f, -0.01824173f, -0.04996299f, -0.01082593f, 0.01251412f, 0.12402352f, 0.06654526f, -0.14257315f, 
    0.02426467f, 0.09699080f, -0.14211300f, -0.19294760f, 0.28534961f, 0.04983318f, 0.25701329f, 0.00757220f, 
    -0.03150658f, -0.07053100f, 0.00367027f, -0.02427564f, 0.07277218f, -0.01307390f, -0.08541057f, 0.03286669f, 
    -0.00233869f, 0.02096320f, -0.08885687f, 0.13070470f, 0.01083144f, 0.11984217f, -0.36512494f, 0.66635734f, 
    0.34415200f, 0.09580462f, 0.20281802f, -0.10717871f, 0.10070026f, -0.04908982f, 0.12674530f, 0.00393278f, 
    0.11736020f, 0.13110976f, 0.03440563f, 0.05650268f, 0.08528294f, -0.12282627f, 0.02784951f, 0.18569823f, 
    0.02844799f, -0.12194372f, -0.17395310f, 0.03741691f, 0.04863569f, -0.03457060f, -0.00906064f, -0.02296867f, 
    0.07684296f, -0.18957448f, -0.02107347f, -0.04529424f, 0.03744341f, 0.04769616f, 0.00659959f, -0.06958856f, 
    0.03357724f, 0.08584210f, -0.05903633f, 0.05621684f, -0.01224088f, 0.05279429f, 0.12326102f, -0.14609461f, 
    -0.06234474f, 0.26924556f, 0.00028385f, 0.06525357f, 0.17708431f, -0.28743508f, -0.06899820f, -0.01527689f, 
    0.04315011f, -0.04702311f, 0.03731585f, 0.13198832f, -0.11944427f, -0.03148987f, 0.04312899f, -0.15102696f, 
    -0.17778370f, -0.03044161f, -0.09675721f, -0.14993882f, 0.29339796f, 0.01185595f, -0.02221806f, 0.25650507f, 
    -0.14906347f, -0.04645341f, -0.18661559f, 0.00848292f, -0.13042091f, -0.04519897f, -0.15834358f, 0.06411849f, 
    -0.02681145f, -0.09296087f, -0.01597324f, -0.01008637f, 0.35584229f, 0.51693738f, 0.14328492f, 0.15304452f, 
    0.21203393f, -0.12662004f, 0.09230878f, -0.04462083f, 0.30210271f, 0.26962265f, -0.03121915f, 0.09686486f, 
    0.14835061f, 0.17285620f, -0.04234281f, 0.06704275f, -0.06720366f, 0.04893888f, 0.04876101f, -0.04421315f, 
    0.09881568f, -0.21610786f, -0.06231875f, -0.16889314f, -0.08286949f, -0.07333379f, 0.01600460f, -0.13804816f, 
    -0.02809735f, -0.03176745f, 0.01008068f, 0.03160233f, 0.01841309f, 0.12896053f, 0.27209595f, -0.07227271f, 
    0.07983383f, 0.04132406f, 0.02654166f, -0.15872671f, 0.50702685f, -0.12388948f, 0.15501188f, -0.17555806f, 
    0.30893257f, -0.12328079f, 0.07728300f, -0.03345224f, 0.33573049f, 0.08611832f, 0.06952704f, 0.02046973f, 
    0.00279847f, 0.13773739f, 0.04776020f, 0.14428398f, 0.06574001f, 0.10430650f, 0.02078665f, 0.03969615f, 
    0.00905438f, -0.00065385f, 0.22677892f, -0.10856500f, 0.21247196f, -0.05846526f, -0.05554715f, 0.20843965f, 
    0.22987077f, 0.06798689f, 0.05831644f, 0.19878006f, 0.07953867f, 0.07432611f, 0.04756838f, -0.19499062f, 
    -0.07697048f, -0.00342092f, 0.10659534f, 0.01730552f, 0.13575342f, -0.25860626f, 0.15837960f, -0.07100575f, 
    0.07996756f, 0.02357882f, 0.04750960f, 0.07033291f, 0.18341069f, 0.08348730f, -0.03552642f, 0.03502237f, 
    0.08871952f, 0.00390820f, -0.00855606f, -0.15395735f, 0.08040677f, 0.07437021f, 0.00302369f, 0.09941390f, 
    -0.35749212f, 0.11883955f, -0.02338697f, -0.16402133f, 0.28367618f, -0.05898209f, -0.08652280f, 0.25807226f, 
    0.02379450f, 0.18913418f, 0.04124662f, 0.07347852f, -0.10109619f, -0.09073064f, -0.09741900f, -0.07600704f, 
    -0.05750851f, 0.00682653f, -0.06033399f, -0.13302238f, -0.19851656f, 0.18157855f, -0.04060870f, -0.05837561f, 
    0.39315903f, -0.06919253f, 0.14370599f, 0.23897667f, 0.03894443f, 0.08753925f, 0.12742299f, 0.04523777f, 
    -0.03193275f, -0.06042527f, -0.01313492f, -0.05687854f, 0.09403101f, -0.00912999f, -0.10385903f, -0.03480031f, 
    0.08379982f, 0.10291354f, -0.03753570f, 0.18924385f, 0.04890574f, 0.06372616f, -0.02869031f, -0.04568159f, 
    -0.07073742f, 0.00290380f, 0.04334008f, -0.01050713f, -0.00088645f, 0.09834350f, 0.12176610f, 0.03372908f, 
    -0.00552920f, 0.11886944f, 0.01620520f, 0.11438699f, -0.25540510f, -0.14792198f, 0.04067311f, -0.03801877f, 
    -0.03416536f, -0.05514017f, -0.00729473f, -0.04445894f, 0.13454898f, -0.26556969f, -0.02525797f, 0.10503546f, 
    0.04227160f, -0.00816212f, 0.16913633f, -0.11162002f, -0.01789707f, 0.13691713f, 0.03174875f, 0.11449089f, 
    -0.06399121f, 0.01549913f, -0.00519872f, 0.18822429f, 0.22229300f, -0.02810512f, 0.16109927f, 0.01749933f, 
    0.03937238f, 0.16394202f, 0.21887845f, -0.02610413f, 0.02878412f, 0.03509986f, 0.03197806f, -0.04017163f, 
    -0.09216841f, 0.00367091f, 0.06610671f, -0.21316239f, -0.20617163f, -0.04470243f, -0.38448864f, 0.15579876f, 
    -0.14167008f, -0.00000169f, -0.19550861f, -0.14806604f, 0.09632128f, -0.06082060f, 0.11817896f, -0.11671257f, 
    0.00679907f, -0.10765606f, -0.07455940f, -0.00554222f, 0.00646102f, -0.01676151f, 0.14082707f, -0.02296740f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07737653f, 0.16044314f, 0.11078350f, 0.14922234f, -0.03509822f, -0.01034169f, -0.04869274f, 0.04168122f, 
    0.00027061f, 0.01509851f, 0.08088905f, -0.04874699f, 0.07843979f, -0.00806874f, -0.00270727f, 0.07281241f, 
    0.12721434f, 0.26248124f, 0.02408257f, 0.00755245f, 0.16414292f, 0.04415580f, 0.11383922f, 0.02492365f, 
    0.00956921f, 0.10519555f, 0.02252297f, -0.00491748f, 0.11322414f, 0.08619475f, 0.11081749f, -0.00828256f, 
    -0.01864855f, -0.00392641f, -0.11321498f, -0.07122000f, -0.06032585f, -0.05460682f, 0.13664074f, -0.01619519f, 
    0.00960658f, -0.00758710f, 0.04274070f, -0.01190717f, 0.00631293f, 0.13395511f, 0.07232279f, 0.07283720f, 
    0.29422772f, -0.02050112f, -0.09173466f, 0.02215754f, -0.01734835f, -0.04825228f, 0.01341315f, 0.10313600f, 
    -0.01277294f, -0.04915389f, 0.17782088f, 0.01307650f, 0.05183591f, 0.00045637f, 0.17645651f, 0.09239063f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04471855f, -0.48121440f, -0.82440490f, 0.22185776f, -0.01479254f, -0.02799134f, 0.02420617f, 0.14942341f, 
    -0.04187084f, -0.00103485f, -0.19631177f, -0.04396060f, 0.16073558f, -0.08962230f, -0.17814258f, -0.53690201f, 
    -0.04754742f, -0.21155238f, 0.06487424f, -0.04829386f, -0.57487363f, 0.01180461f, 0.10599432f, -0.10193778f, 
    0.16919908f, -0.08541651f, 0.03525307f, 0.18309312f, -0.30165687f, -0.33596334f, -0.42309436f, -0.05139184f, 
    -0.08202945f, -0.03513299f, 0.13572749f, 0.14697286f, -0.09141662f, -0.04185084f, -0.46638069f, 0.30115893f, 
    0.04862490f, -0.10976272f, 0.02344342f, 0.17113768f, -0.07041694f, -0.20503010f, 0.29856455f, -0.31109393f, 
    0.00356996f, -0.08975574f, -0.01872755f, -0.11180785f, 0.04863213f, 0.26265791f, 0.22718792f, -0.04606722f, 
    -0.10504333f, 0.01908485f, -0.08525384f, 0.12126330f, 0.10728119f, -0.07390638f, 0.17090918f, -0.03855136f, 
    -0.19708717f, 0.02968399f, -0.46557382f, 0.16288316f, 0.10543224f, 0.01830607f, 0.08028119f, -0.00458035f, 
    -0.10406547f, 0.07540146f, -0.10741239f, -0.05758650f, 0.07672352f, 0.06047538f, -0.47366068f, -0.23200363f, 
    0.12804112f, 0.24017864f, -0.35649547f, 0.02764205f, 0.10002309f, -0.05911630f, 0.21364869f, -0.02255199f, 
    0.00688134f, -0.01874474f, 0.07375167f, -0.07051209f, -0.15421468f, 0.08042981f, 0.10720684f, 0.05201749f, 
    -0.07577393f, -0.05051646f, -0.46084881f, 0.08951399f, -0.11436533f, -0.08391207f, 0.21605641f, 0.01814729f, 
    -0.09864936f, -0.07669317f, -0.11716373f, 0.21731687f, -0.06648761f, 0.21187098f, 0.30054244f, -0.03604272f, 
    0.24703786f, -0.10048579f, -0.05089578f, -0.04521954f, -0.06421257f, -0.52735984f, 0.09008837f, -0.28615668f, 
    -0.00208463f, -0.00776189f, -0.02299157f, -0.15018103f, 0.31823966f, 0.03163910f, 0.53692818f, 0.02344625f, 
    0.11232283f, -0.04451089f, 0.20723546f, -0.47894621f, 0.06396884f, -0.00642521f, 0.02529171f, 0.06275417f, 
    -0.04209446f, -0.01087134f, 0.07961880f, -0.08871430f, -0.40774161f, 0.08155396f, -0.36989653f, -0.10640734f, 
    -0.06420666f, 0.22826853f, -0.17671697f, -0.02592976f, -0.05818816f, 0.03556080f, -0.09656629f, 0.05902276f, 
    -0.75804448f, 0.07903208f, 0.05091658f, 0.02795400f, 0.27192852f, 0.09625468f, -0.31306040f, 0.00906775f, 
    0.05851410f, -0.11552391f, 0.01809262f, 0.07266788f, -0.02078559f, 0.06900557f, -0.04178359f, 0.45960999f, 
    -0.00154020f, -0.06059371f, 0.11033976f, -0.08735138f, -0.09789816f, 0.01075168f, 0.13429102f, 0.04304793f, 
    0.02426641f, 0.08805278f, -0.23035339f, -0.09237093f, 0.08735921f, -0.27195126f, -0.03582491f, 0.39522493f, 
    -0.09896177f, 0.07528936f, 0.21981294f, -0.43527174f, -0.11611266f, -0.10787034f, -0.10379056f, 0.15834545f, 
    -0.26027066f, -0.46663758f, 0.15245672f, -0.64397585f, -0.03315119f, 0.04441715f, 0.11180537f, 0.00829700f, 
    0.11783392f, -0.03430239f, -0.11797053f, -0.05765513f, -0.39556792f, 0.04408153f, 0.12102468f, 0.01840910f, 
    -0.77756262f, -0.52959591f, -0.05157760f, 0.04054104f, 0.10325760f, 0.09028457f, 0.22225912f, -0.02803650f, 
    0.17940451f, 0.18222560f, -0.13035959f, 0.15477630f, -0.11988577f, 0.39732188f, -0.33199516f, -0.00011781f, 
    -0.11578552f, 0.07152227f, 0.20287597f, 0.25190213f, 0.03403253f, 0.03897225f, -0.56147373f, 0.03171127f, 
    0.06258092f, -0.02865213f, -0.11259643f, 0.11333386f, -0.12698124f, 0.20755684f, 0.01505763f, 0.14638090f, 
    -0.38397714f, 0.07452449f, 0.09030212f, -0.11828739f, 0.07257945f, 0.18953751f, -0.51991946f, -0.20452067f, 
    0.04481689f, 0.03239756f, 0.06059057f, -0.15079020f, 0.24805184f, 0.07170494f, 0.17954056f, -0.00263769f, 
    0.19529670f, -0.06232228f, 0.04924937f, 0.12886783f, -0.08009537f, 0.10591068f, -0.04859025f, 0.09568945f, 
    0.05363074f, 0.02319998f, -0.43202645f, -0.12842593f, 0.13999464f, -0.00332436f, -0.37280032f, 0.20716724f, 
    0.20290263f, -0.22692426f, -0.33112514f, -0.01564968f, -0.51938635f, -0.06637869f, -0.26052535f, 0.03543766f, 
    -0.06620097f, 0.09059761f, 0.15542482f, 0.11300775f, -0.06672932f, -0.30151504f, 0.07104322f, 0.10449974f, 
    -0.00537830f, 0.03360197f, 0.18626790f, 0.14744057f, -0.03819669f, -0.00818491f, 0.25076854f, 0.10226619f, 
    0.01441622f, -0.04106910f, 0.03663690f, -0.11891763f, 0.00881131f, 0.12299161f, -0.17335546f, 0.08131623f, 
    -0.40338981f, -0.07155535f, 0.03168733f, -0.05891336f, -0.13269526f, 0.15254906f, -0.02164820f, 0.23312198f, 
    0.05473657f, 0.08095622f, -0.56737751f, 0.21220221f, -0.04383129f, -0.09948325f, -0.55907494f, -0.15340616f, 
    -0.11829828f, 0.04930647f, -0.36546257f, -0.01590738f, 0.07150178f, -0.11113335f, 0.03259577f, 0.16576307f, 
    -0.02099844f, 0.11155065f, -0.07869333f, 0.00288515f, 0.03364145f, -0.05751477f, 0.07961714f, -0.08083937f, 
    0.05093098f, 0.06318706f, 0.48227119f, -0.12305756f, 0.15436150f, -0.08599390f, 0.20901927f, -0.05774385f, 
    0.28560641f, -0.15346308f, -0.09747326f, -0.16083637f, -0.29734978f, -0.23879451f, -0.04012143f, -0.06104088f, 
    0.10254734f, 0.00651855f, 0.03947271f, 0.06950311f, 0.06238351f, -0.08437069f, 0.18231380f, -0.49955022f, 
    0.11261883f, -0.01815355f, -0.04151727f, -0.12086136f, -0.03085052f, 0.04454692f, -0.35432783f, 0.11697470f, 
    0.15515469f, -0.01819947f, 0.02913184f, -0.08277133f, 0.02169671f, -0.28054854f, 0.16747615f, 0.38616961f, 
    0.02152694f, -0.08550481f, 0.02745484f, 0.37791562f, -0.27731356f, 0.11081841f, -0.48208910f, 0.04562900f, 
    -0.02065558f, 0.37572014f, 0.16162942f, -0.26377359f, 0.04045766f, -0.12412615f, 0.06993149f, -0.51517665f, 
    0.12020650f, 0.06783679f, 0.30114880f, -0.11061436f, 0.39847317f, 0.09392273f, 0.01807558f, -0.14777692f, 
    0.21233584f, -0.43445736f, 0.13464375f, -0.11041068f, 0.22317025f, -0.01361770f, -0.58623695f, -0.00162954f, 
    -0.59733719f, -0.01651984f, 0.08575982f, -0.39913711f, 0.04376085f, 0.08529136f, -0.20067596f, -0.13240805f, 
    0.03654354f, -0.02585245f, 0.10133179f, 0.06659020f, -0.12869930f, 0.03495728f, -0.13320021f, -0.76287341f, 
    -0.01359073f, 0.08575877f, -0.13328832f, 0.04184130f, 0.09854083f, 0.04659117f, -0.21035454f, -0.00965810f, 
    -0.71673882f, 0.08415193f, -0.44151396f, 0.09502085f, 0.09479121f, -0.23398846f, 0.11160489f, 0.07675474f, 
    0.02175255f, 0.10396214f, 0.34754926f, -0.07578648f, 0.38450775f, -0.11387840f, -0.08209591f, 0.27229530f, 
    0.24004342f, -0.20220524f, 0.10205365f, -0.19027331f, 0.00546873f, 0.10611825f, -0.08895334f, -0.35146725f, 
    0.05916460f, 0.00550059f, -0.01856581f, -0.01285879f, -0.28920484f, -0.04281945f, -0.07575307f, 0.35952815f, 
    0.05138059f, 0.17099774f, -0.03262440f, 0.05669952f, 0.30663812f, -0.00364964f, 0.19024225f, 0.12376264f, 
    -0.19998351f, -0.49112540f, -0.15979818f, -0.09192768f, 0.11854385f, -0.03710036f, 0.16017453f, 0.04969126f, 
    0.00055157f, -0.00292498f, -0.42732230f, 0.06444131f, 0.06581850f, 0.06407838f, -0.22805867f, 0.29509136f, 
    0.07485351f, -0.03803109f, 0.07764003f, 0.12445976f, 0.10310267f, -0.52351362f, -0.05203686f, 0.25756556f, 
    -0.23968634f, 0.06313028f, 0.02334437f, -0.02374471f, 0.05875632f, 0.43353432f, -0.04817057f, 0.02156695f, 
    0.06238336f, -0.02356216f, -0.52147776f, 0.11828896f, -0.15963267f, -0.11342280f, -0.28345957f, -0.25959727f, 
    -0.11075006f, -0.22691488f, -0.13661681f, 0.16869217f, 0.04291803f, 0.00712797f, 0.10594700f, 0.22110853f, 
    0.09520073f, 0.04027833f, 0.22621742f, -0.03108461f, -0.41442066f, -0.08552115f, 0.24747843f, 0.10608934f, 
    -0.32059735f, 0.21844941f, 0.03768288f, 0.00175887f, 0.10667370f, 0.00326290f, 0.17993629f, -0.00212531f, 
    -0.63876522f, -0.60685021f, -0.05357166f, 0.25440171f, 0.12658131f, 0.26864046f, -0.20077808f, 0.03879108f, 
    -0.06384235f, 0.06410954f, -0.53703684f, -0.31035236f, -0.01847609f, 0.07379685f, -0.02600111f, 0.03897565f, 
    0.00009781f, -0.07673878f, -0.03329082f, 0.11627959f, -0.09524550f, -0.10605198f, -0.23661056f, 0.15967034f, 
    0.15106408f, -0.05191522f, 0.22579844f, -0.09788643f, 0.08169527f, -0.54609209f, -0.20362863f, -0.56899738f, 
    0.10237824f, -0.07200234f, 0.11595652f, 0.15492654f, -0.81255466f, 0.02371403f, -0.10698200f, 0.20775586f, 
    0.26098356f, 0.19684348f, 0.03443970f, 0.30156824f, -0.04987764f, -0.11451964f, -0.07412761f, -0.10920985f, 
    -0.10008644f, -0.10607063f, -0.25071397f, 0.01522770f, -0.21850280f, -0.09638843f, 0.24748832f, 0.15590121f, 
    0.39318731f, -0.07118500f, 0.36224806f, 0.08491821f, -0.26761505f, 0.07030618f, -0.75373644f, -0.03844461f, 
    0.20578837f, 0.10758641f, 0.08763204f, -0.40243685f, -0.06451902f, -0.06455472f, 0.09383188f, 0.02561567f, 
    0.10670447f, 0.02455764f, -0.29558879f, -0.13925773f, -0.00643594f, -0.02103695f, 0.40750948f, 0.02938990f, 
    -0.10574218f, -0.00315871f, -0.00008491f, 0.07701104f, -0.10163109f, 0.01295462f, 0.08705038f, 0.06123101f, 
    -0.21139491f, -0.07279640f, -0.39969054f, 0.03294217f, -0.08370971f, 0.14990346f, -0.22639605f, 0.22553805f, 
    -0.08923598f, -0.12266782f, 0.13642132f, -0.04497831f, 0.18955378f, 0.08183451f, -0.04905026f, -0.95146781f, 
    0.15833640f, -0.23826508f, 0.25006524f, 0.11558928f, 0.01529770f, -0.12467750f, 0.01207558f, -0.01918103f, 
    0.02436187f, 0.06198741f, 0.02872000f, 0.00156502f, 0.02711143f, 0.05159031f, 0.08993873f, -0.06127725f, 
    -0.33817655f, -0.00750489f, 0.00493335f, -0.07642569f, 0.17364575f, 0.04624577f, 0.24046287f, 0.06685800f, 
    0.17310333f, -0.25766015f, 0.25746554f, -0.41470081f, 0.29171020f, -0.42086202f, 0.19416329f, 0.06505205f, 
    -0.12994514f, 0.05722947f, 0.01196610f, -0.11755825f, -0.01118273f, 0.03183518f, -0.22978647f, -0.69963485f, 
    -0.03328928f, -0.02412149f, -0.08462990f, -0.44970319f, 0.08153251f, 0.25800216f, 0.24284941f, -0.53654313f, 
    0.01357950f, 0.09284190f, 0.24422158f, 0.04052643f, -0.04293604f, 0.07789139f, -0.34307709f, -0.41527927f, 
    0.03372279f, 0.05884645f, 0.16837999f, -0.69832850f, -0.00493363f, -0.03931607f, -0.02104762f, 0.19537511f, 
    -0.23761889f, -0.13256483f, 0.26118538f, 0.15160511f, 0.07245207f, -0.02849424f, -0.06109593f, 0.09364775f, 
    0.10899871f, 0.04349703f, -0.06164763f, -0.04650633f, 0.50044358f, 0.03433878f, 0.13361759f, 0.00682274f, 
    -0.13888788f, 0.01274679f, 0.01555419f, -0.07206181f, -0.05528262f, 0.09591066f, -0.55005193f, -0.08121269f, 
    -0.18778308f, 0.20377316f, -0.56529284f, 0.35992262f, 0.20728314f, 0.04002546f, 0.18708368f, 0.03022774f, 
    -0.04048782f, 0.02130394f, 0.16136956f, -0.20548986f, -0.10392556f, -0.10035050f, -0.11955256f, -0.65887016f, 
    0.05105393f, 0.05778783f, -0.08100020f, -0.00350677f, 0.10084897f, -0.21564136f, -0.17162070f, 0.23720944f, 
    0.08123705f, -0.00070513f, -0.35762793f, -0.04767698f, 0.07454064f, 0.31233069f, 0.01940916f, -0.84021270f, 
    -0.08151740f, -0.00057190f, 0.25068551f, 0.16640979f, -0.48931065f, 0.02370705f, 0.32693675f, 0.13034448f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23246428f, 0.09327083f, 0.02018237f, -0.15134674f, 0.09554927f, 0.06789044f, -0.06615283f, -0.00941500f, 
    0.08077388f, 0.06590687f, 0.12430301f, 0.05045264f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
