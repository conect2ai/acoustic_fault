#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.65209270f, 0.59882671f, 0.34116906f, 0.32727382f, -0.60055006f, -0.66774386f, -0.66579413f, 0.47499263f, 
    0.38801548f, -0.27581254f, -0.11539206f, -0.00618969f, 0.02967464f, -0.12534648f, -0.38687456f, -0.05307671f, 
    0.13118044f, -0.43865570f, -0.66430056f, -0.07882997f, 0.14789763f, -0.11267448f, 0.17767932f, -0.07811528f, 
    0.29200158f, 0.07349395f, 0.41726556f, 0.55157042f, 0.37684402f, 0.12999512f, 0.00651622f, 0.24247482f, 
    0.05842126f, 0.02126985f, 0.16800715f, 0.31214783f, -0.06616500f, 0.14062083f, -0.21903482f, 0.06248653f, 
    0.16808744f, 0.26953956f, -0.00499670f, 0.21042104f, 0.15387076f, -0.14085771f, -0.28158712f, -0.10253229f, 
    0.17943992f, 0.30551919f, -0.21535867f, -1.07452822f, -0.66619724f, -0.06243429f, -0.08259649f, -0.13708444f, 
    -0.15084745f, 0.11732561f, -0.32645822f, -1.04803813f, -0.21292478f, -0.45397142f, -0.12284784f, 0.22187032f, 
    0.20004144f, -0.05382652f, 0.34765467f, 0.14979561f, -0.32881269f, 0.26187545f, -0.17895705f, -0.13956903f, 
    0.14551115f, 0.15968856f, 0.08202431f, -1.13395143f, -0.53136647f, -0.30894858f, -0.63582987f, -0.92215604f, 
    0.86155313f, 0.23763303f, -0.40641379f, -0.27404186f, 0.44078812f, -0.14570434f, -0.21475334f, 0.24871045f, 
    0.08207488f, 0.50799406f, -0.25969064f, 0.11927437f, -0.34752631f, -0.30216900f, -0.34503716f, 0.11376243f, 
    0.06029167f, 0.35861996f, -0.07190572f, -0.19706345f, -0.95276159f, -0.16304377f, 0.11855415f, -0.45016277f, 
    -0.13770184f, -0.15387838f, -0.40556183f, 0.26149759f, 0.12781270f, -0.40502152f, 0.00474438f, 0.46296597f, 
    0.16299811f, 0.36988610f, -0.43482357f, -0.03805272f, 0.14136434f, 0.12145080f, -0.03156840f, 0.04171169f, 
    0.26286608f, 0.47733691f, -0.17029400f, 0.01196863f, -0.01575759f, 0.06029018f, -0.45263913f, -0.85421866f, 
    -0.40782493f, 0.32748613f, 0.20879667f, 0.81396312f, -0.53482664f, -0.04193963f, 0.17533959f, -0.05986197f, 
    0.79870087f, -0.33198020f, -0.02933253f, -0.31785092f, -0.64752215f, -0.39713469f, -0.18799640f, -0.40714806f, 
    -0.67275208f, 0.53965646f, -0.26176107f, -0.22236942f, 0.04797062f, 0.45266148f, -0.15790278f, -0.32647666f, 
    -0.53747100f, -0.63021928f, -0.04980614f, -0.40299118f, -0.79986531f, -0.61095572f, -0.58831894f, -0.30505916f, 
    0.20099884f, -0.39762595f, -0.20382425f, -0.09034146f, -0.56175804f, -0.22958882f, 0.04575422f, -0.50581610f, 
    -0.36943975f, -0.62829465f, -0.10642463f, 0.42238680f, 0.48162243f, -0.23152380f, 0.30979258f, -0.57791835f, 
    -0.17234920f, -0.13383950f, 0.55049366f, 0.25982681f, 0.11676995f, -0.53170675f, -0.39557379f, 0.17303349f, 
    0.50310761f, 0.46247372f, 0.26789111f, 0.02319142f, -0.66292638f, 0.03373287f, 0.16308963f, 0.09087423f, 
    -0.19578438f, -0.30462524f, 0.18100718f, 0.47906113f, -0.33638474f, -0.08219638f, 0.15599141f, -0.22739297f, 
    1.16921103f, -0.51664507f, -0.67055517f, -0.12040973f, -0.32759133f, 0.55681211f, 0.26037070f, 0.17798196f, 
    0.12664689f, 0.07716171f, -0.11122801f, 0.25316960f, -0.30497023f, -0.10880224f, 0.19077863f, -0.21640807f, 
    -0.12630005f, -0.01355069f, 0.18322089f, -0.28524801f, 0.19479616f, 0.21063106f, 0.01930743f, -0.25379980f, 
    0.04120288f, -1.49771774f, 0.81987667f, -0.39349702f, -0.49152029f, 0.69783831f, -0.25906408f, 0.56855506f, 
    0.27570730f, 0.26489288f, 0.14074469f, 0.05586820f, -0.29156101f, -0.43879440f, -0.17247313f, 0.35552484f, 
    0.20708844f, 0.00930394f, -0.09645540f, -0.01942875f, 0.00975075f, 0.08440886f, -0.01128789f, 0.08810283f, 
    0.00385007f, -0.28287759f, -0.06968822f, 0.07249713f, -0.09019547f, 0.09978187f, 0.48037153f, -0.56115240f, 
    -0.95804888f, -0.92239851f, -0.69288832f, -0.24352369f, 0.22562639f, 0.07720678f, -0.01320074f, 0.31662992f, 
    0.50554484f, -0.18000668f, 0.05961458f, -0.23613700f, 0.10498168f, 0.00288716f, -0.35820132f, -0.03215104f, 
    0.09636120f, 0.24757338f, -0.19024876f, 0.73200697f, 0.43565801f, -0.61108768f, -0.45090136f, 0.18191852f, 
    -0.15625797f, 0.05259270f, -0.02251680f, -0.51056004f, -0.16297713f, 0.21230641f, -0.06785262f, 0.80538017f, 
    -0.58140129f, -0.12318449f, -0.04362058f, -0.23063627f, -0.32987890f, 0.20623475f, 0.21127722f, -0.28833178f, 
    0.02490546f, 0.03906354f, 0.14152125f, 0.31192192f, -0.92512131f, 0.19323333f, -0.59320879f, -0.98911464f, 
    -0.39709288f, 0.22470601f, 0.06131113f, 0.44901469f, 0.09906037f, 0.22233023f, 0.01062249f, 0.42799553f, 
    -0.19977273f, -0.26245475f, 0.11788990f, 0.23114400f, -0.31269732f, -0.59478253f, -0.48040232f, -0.23437217f, 
    -0.06896190f, -0.15319039f, -0.27150470f, -0.51302093f, -0.23312254f, 0.09477991f, 0.04020338f, -0.05603631f, 
    -0.25705108f, -0.47978529f, 0.36647633f, -0.41267604f, -0.04486439f, -0.22813685f, -0.44321221f, 0.37587532f, 
    0.09152204f, 0.19100329f, 0.11783651f, -0.06810182f, 0.15245612f, 0.30403641f, 0.12168010f, -0.17225827f, 
    0.02276097f, -0.45003012f, -0.30492920f, -0.09035643f, 0.12458675f, -0.36483827f, -1.51087439f, -1.11420572f, 
    -0.41919270f, 0.73435038f, 0.92352408f, 0.36001390f, 0.18399191f, 0.07565673f, 0.18661150f, 0.09684821f, 
    -0.08058297f, 0.01597574f, -0.10097017f, 0.25320765f, -0.57795244f, 0.22177216f, 0.37977910f, -0.18583602f, 
    0.27206907f, 0.18344788f, 0.03116437f, -0.15420663f, -0.08384111f, -0.24217097f, -0.17090042f, -0.92410165f, 
    0.05790013f, -0.60316861f, -0.17555930f, 0.09683520f, -0.58204627f, -0.23781744f, -0.45171046f, -0.58733726f, 
    -0.45111579f, -0.12698705f, -0.51325923f, 0.25680560f, -0.43080190f, -0.01625554f, 0.12178273f, 0.07709718f, 
    -0.05230849f, 0.29484990f, 0.34884086f, 0.04567732f, -0.04670396f, 0.06862666f, -0.09320536f, 0.02608461f, 
    -0.32006648f, 0.20632303f, 0.02174995f, -0.08058923f, -0.28018439f, -0.24305347f, -0.69348472f, -0.34809181f, 
    0.04333859f, -0.50779653f, 0.77037662f, 0.36712626f, 0.13954584f, -0.08921082f, -0.36788246f, -0.59339184f, 
    -0.06496629f, -0.30094576f, -0.58612525f, -0.77794826f, -0.17440552f, -0.18310982f, -0.17637822f, -0.39029002f, 
    -0.36582199f, -0.07642516f, -0.90065992f, -0.89664572f, -0.66080850f, -0.75026512f, -0.39864212f, -0.60227919f, 
    0.32264349f, 0.30438802f, 0.01127520f, -0.16007198f, 0.20285973f, 0.30911729f, 0.35551083f, -0.48476183f, 
    0.02804738f, -0.21452217f, -0.16511972f, -0.09830387f, 0.35433820f, -0.33444816f, -0.29935488f, 0.02960694f, 
    -0.34238294f, -0.07080334f, 0.68969190f, 0.72533542f, 0.58290762f, -0.66736805f, -0.50983024f, -0.70908779f, 
    0.11973465f, -0.25113842f, -0.27903235f, 0.08346787f, -0.06795358f, 0.41919282f, -0.12475605f, 0.13492455f, 
    0.48523137f, -0.00677810f, -0.12663326f, 0.41872922f, 0.11188328f, 0.21674027f, 0.18274651f, 0.21161991f, 
    -0.12308498f, -0.26555711f, -0.13574743f, 0.99356234f, -0.55596066f, -0.64820641f, -0.29279944f, -0.10230982f, 
    0.37381750f, 0.45126945f, 0.51242316f, -0.00058264f, -0.02031942f, 0.13807012f, 0.19080015f, -0.11776341f, 
    -0.45012474f, -0.10934191f, 0.12292433f, 0.15187111f, 0.02570581f, -0.20413780f, -0.12628010f, 0.01936710f, 
    -0.01852399f, -0.22218765f, 0.01732405f, 0.07790277f, -0.00796379f, 0.03386349f, -0.25170964f, 0.02808561f, 
    0.41646996f, -0.30803129f, -0.08428422f, 0.10644925f, -0.06372602f, -0.07102252f, -0.01497132f, -0.02107252f, 
    0.06332691f, -0.10383771f, 0.16999191f, 0.39990830f, -0.20069487f, -0.04333294f, -0.32172015f, 0.20961659f, 
    -0.12300025f, 0.36216411f, 0.24936019f, 0.09136664f, 0.41784459f, 1.26294386f, -0.76671803f, -0.79199624f, 
    -0.59040588f, -0.20609741f, 0.09337790f, 0.27468687f, 0.43699330f, 0.49757421f, -0.32001278f, 0.17893314f, 
    -0.44083840f, 0.05140312f, -0.36380386f, -0.15197816f, -0.25625318f, 0.10712665f, -0.22425608f, 0.05695662f, 
    0.04744926f, -0.22004265f, -0.32004753f, -0.53211337f, 0.42565411f, -0.19887519f, -0.98459238f, -0.17107370f, 
    -0.06215150f, -1.21044874f, -0.59584773f, 0.36095390f, 0.63593453f, -0.38598871f, -0.31857201f, 0.36188972f, 
    -0.08660360f, -0.18073599f, -0.35515878f, -0.48713213f, -0.20061900f, 0.05992885f, 0.38162956f, 0.21301475f, 
    0.15047275f, -0.33737019f, -0.26450795f, -0.24424832f, -0.35539502f, -0.07241954f, -0.14144446f, -0.63222498f, 
    -0.53952748f, -0.75942802f, -0.75964803f, -0.56403303f, 0.88817185f, 0.55981547f, 0.42029646f, 0.32249525f, 
    0.41329423f, 0.22145878f, 0.00868835f, 0.21209598f, 0.00185937f, -0.23255286f, 0.05484597f, 0.03052950f, 
    -0.02521951f, -0.01396109f, -0.19779891f, 0.01114773f, -0.16750725f, 0.26992428f, 0.13326870f, -0.11875365f, 
    -1.10826910f, -0.53118432f, -0.52068543f, 0.39469528f, 0.28210840f, 0.04045029f, -0.58889562f, -0.01423487f, 
    0.66394728f, 0.45620406f, 0.48999313f, 0.27568370f, -0.03868085f, -0.21784326f, -0.16397271f, -0.44101200f, 
    -0.09932840f, 0.21483387f, -0.38087431f, -0.49343559f, 0.01822848f, 0.40044719f, 0.10368071f, 0.35773981f, 
    0.52350932f, -0.49531582f, -0.53689849f, -0.64599478f, -0.85031599f, -0.44628525f, 0.37901717f, -0.33503899f, 
    -0.71072918f, -0.13675542f, -0.21172763f, -0.47168934f, -0.39096791f, 0.02890307f, -0.20384993f, -0.54578751f, 
    0.34949383f, -0.52882570f, -0.32502905f, 0.25757715f, -0.21166608f, -0.01118461f, -0.03950952f, -0.35939261f, 
    -0.09393152f, -0.22360884f, -0.40758136f, -0.68127465f, -0.45211449f, 0.09306470f, -0.29544508f, 0.25225040f, 
    -0.14024727f, -0.29337510f, 0.03690402f, 1.01003146f, -0.08035375f, -0.33594713f, -0.35419571f, -0.42040747f, 
    0.39750969f, -0.03369845f, 0.21204132f, 0.40910935f, -0.05857521f, 0.28640336f, -0.50243360f, -0.43143088f, 
    -0.15805778f, -0.31093904f, -0.18024132f, 0.71123087f, 0.25114703f, 0.11954898f, 0.25553256f, -0.00597737f, 
    -0.10399042f, -0.00012089f, 0.36581615f, 0.24822479f, -0.33371532f, 0.04208170f, 0.23656847f, 0.23844735f, 
    -0.26176992f, -0.44914976f, -0.20013928f, -0.16749181f, 0.17108415f, -0.42710912f, -0.27744740f, 0.19116862f, 
    0.09329457f, -0.06956036f, 0.19024456f, -0.23858982f, -0.25849476f, 0.73696423f, 0.25078225f, -0.75699466f, 
    -0.22970845f, -0.06573090f, -0.02663734f, -0.33982965f, 0.39744270f, -0.32112345f, -0.13685273f, -0.23946340f, 
    0.09372684f, -0.21009025f, 0.08132319f, 0.16855943f, -0.32806689f, 0.13812135f, 0.11981624f, -0.32763308f, 
    -0.19513163f, 0.47321546f, 0.20653282f, 0.00193694f, 0.50398719f, -0.16840532f, -0.67629468f, 0.12784572f, 
    0.31440690f, 0.48931330f, -0.03637057f, -0.12901655f, 0.11369792f, 0.67310107f, 0.38184318f, -0.41101584f, 
    -0.44012710f, 0.19174503f, -0.16998293f, -0.23827770f, 0.16072060f, -0.02382676f, 0.01526054f, -0.24723308f, 
    -0.02302996f, -0.39601156f, -0.13815179f, -0.10317491f, 0.05163804f, -0.15343969f, 0.60986197f, 0.16605799f, 
    -0.21095763f, -0.57482827f, -0.02258371f, 0.09365261f, -0.04858195f, -0.31567568f, 0.00925889f, 0.23679677f, 
    0.07046548f, 0.72293574f, -0.69184744f, -0.16969943f, 0.26946294f, 0.21194923f, -0.26818269f, 0.21316011f, 
    0.03699047f, -0.32529283f, -0.13092908f, -0.04026467f, 0.12589996f, 0.18457611f, -0.04076431f, 0.18385845f, 
    -1.37692750f, 0.21457835f, 1.55917537f, 0.87956911f, -0.44621632f, -0.07107341f, -0.98161477f, -0.81741768f, 
    -0.26068538f, 0.09741908f, 0.00157103f, 0.43586996f, -0.10503028f, 0.42375958f, -0.32124645f, -0.03146654f, 
    0.02278065f, 0.01101485f, -0.06911476f, 0.24427827f, -0.03054547f, -0.10847759f, 0.08069807f, -0.15261890f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.41822040f, 0.12637769f, -0.02548677f, -0.03553108f, 0.17438217f, 0.15834525f, 0.01845123f, 0.47166738f, 
    0.61169422f, 0.50025457f, 0.17027086f, 0.29397830f, 0.07647525f, -0.12663005f, 0.16194351f, -0.17422272f, 
    0.07252122f, -0.05875478f, 0.40239146f, 0.54435140f, 0.45090169f, 0.25867316f, 0.03889580f, 0.21122876f, 
    0.29988253f, -0.26455870f, 0.37654105f, 0.27884376f, 0.40711421f, 0.35438970f, 0.37963936f, 0.18897058f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21870686f, -0.21132690f, 0.46522409f, -0.17258209f, -0.24948438f, -0.17385194f, -0.05577740f, 0.11777164f, 
    -0.02920277f, 0.01402705f, -0.13774265f, -0.00297499f, 0.01387154f, 0.04575536f, -0.00441548f, 0.07607496f, 
    -0.02184013f, 0.01005137f, -0.04953681f, -0.01323732f, -0.10130176f, -0.03083854f, 0.02225216f, -0.03939167f, 
    0.50048906f, -0.10860559f, -0.03962075f, -0.25742438f, 0.11820485f, 0.05870809f, 0.09984788f, 0.08648682f, 
    -0.09678462f, -0.01732666f, -0.02856939f, 0.03304783f, 0.38675222f, 0.03621036f, -0.16812262f, -0.16095072f, 
    -0.02686694f, 0.18293263f, -0.22353865f, -0.20735611f, -0.15187664f, -0.09838855f, -0.03547682f, 0.10139637f, 
    0.15806821f, 0.18938568f, 0.05260925f, -0.01223656f, -0.16221420f, 0.18930379f, -0.19922595f, 0.00612446f, 
    0.01308376f, -0.08489511f, 0.08143584f, 0.03341790f, -0.13234441f, 0.25823137f, -0.42033035f, -0.05347957f, 
    0.06291376f, 0.14370225f, 0.10463896f, -0.22273917f, -0.09386165f, -0.10230760f, -0.24979550f, -0.22176391f, 
    0.29549742f, 0.28016996f, -0.09560492f, -0.41229168f, 0.11052191f, 0.18982568f, -0.01100555f, -0.12245367f, 
    -0.10676323f, -0.04330175f, -0.10875946f, -0.09948777f, -0.07802182f, 0.22970508f, 0.14833264f, -0.17844719f, 
    -0.12305038f, 0.02923237f, 0.00507416f, 0.00561029f, -0.18647721f, -0.01499428f, 0.07317881f, -0.02378180f, 
    -0.45917231f, -0.44317886f, -0.82538605f, 0.10229295f, 0.00407533f, -0.00068199f, -0.02229238f, 0.04141429f, 
    -0.13224322f, -0.11451326f, -0.36434376f, -0.05038083f, -0.50105351f, -0.07828420f, 0.18692151f, -0.06239642f, 
    -0.11397359f, 0.06984545f, 0.07222009f, 0.00845294f, -0.11442906f, 0.01526420f, -0.07322314f, 0.08337317f, 
    0.18944578f, 0.22191870f, -0.11802639f, -0.30304420f, 0.09877543f, -0.10499169f, -0.28930157f, 0.03504227f, 
    -0.01567086f, 0.01944203f, 0.05809017f, 0.02279928f, -0.11837488f, 0.00569295f, -0.93414718f, 0.14252737f, 
    0.04206305f, -0.31119075f, -0.18290013f, -0.09366476f, -0.08167765f, 0.05386741f, -0.03056564f, -0.03324512f, 
    0.00775617f, -0.00599341f, -0.07517125f, -0.12941413f, -0.01926978f, 0.08241248f, -0.05391201f, 0.08248677f, 
    -0.02070992f, 0.07101715f, 0.06454487f, 0.08822393f, 0.22597496f, -0.03094047f, -0.13052751f, 0.06839556f, 
    0.08758016f, -0.12092774f, -0.03470251f, 0.09444801f, -0.09618460f, 0.17947774f, 0.04474877f, 0.03651629f, 
    0.63675469f, 0.15756689f, 0.02485724f, 0.04155665f, 0.07890343f, 0.03884397f, 0.15612543f, -0.01565139f, 
    -0.02064610f, -0.08136330f, -0.16101889f, 0.01595077f, 0.45587820f, 0.33913097f, 0.05002115f, -0.13177590f, 
    0.11100753f, 0.05494106f, 0.04980842f, 0.03098592f, -0.05099468f, 0.00649037f, 0.05460799f, -0.01042919f, 
    0.23986103f, 0.21922217f, -0.08660825f, -0.24365175f, -0.10741587f, -0.06454349f, -0.08546776f, 0.02720547f, 
    -0.14480384f, -0.04806183f, -0.07315011f, 0.12631682f, 0.33775839f, 0.13135861f, -0.07377715f, -0.20954490f, 
    0.16079332f, 0.03565541f, -0.00300175f, -0.04978667f, -0.18694955f, -0.06131384f, 0.08980317f, 0.12642694f, 
    0.01198521f, -0.10394217f, -0.00556990f, 0.02067980f, -0.13489750f, -0.10450631f, -0.09191125f, -0.24513562f, 
    -0.03889326f, 0.01482555f, 0.07249057f, -0.08030690f, -0.29022658f, -0.38073277f, -0.81171823f, 0.10062056f, 
    -0.07221361f, -0.02937668f, 0.02000950f, -0.08320670f, -0.01605813f, -0.08392029f, -0.15252562f, -0.25604224f, 
    -0.02659799f, 0.01931029f, 0.03093713f, 0.05290620f, -0.09121612f, -0.29159126f, 0.02647568f, -0.01088340f, 
    -0.11481567f, -0.02515116f, -0.11918325f, -0.07753728f, 0.09609600f, -0.41670087f, -0.43918273f, -0.06985883f, 
    0.05686960f, 0.06367405f, -0.09642683f, -0.04825030f, -0.05552377f, -0.16402064f, -0.03893858f, -0.00220803f, 
    0.34892198f, 0.34028623f, -0.07651895f, -0.09225264f, 0.02697287f, 0.22386162f, 0.04214785f, 0.31081775f, 
    0.04530280f, 0.02714304f, -0.05040713f, -0.07710309f, 0.02123118f, -0.32331270f, -0.20390330f, 0.14410961f, 
    0.07618390f, 0.18072806f, -0.03070834f, 0.03382419f, -0.06686667f, 0.05655485f, -0.04111186f, 0.00097082f, 
    0.07956202f, 0.43887237f, 0.25246179f, -0.21770282f, 0.06251156f, 0.16558026f, 0.09193798f, -0.16428459f, 
    -0.01411408f, -0.17297733f, -0.02411328f, 0.00369623f, 0.31724638f, 0.31063047f, -0.04261126f, -0.01334234f, 
    0.07390412f, 0.30523932f, 0.10388672f, 0.11504176f, -0.13644098f, -0.06578789f, -0.02173238f, 0.05565220f, 
    0.29354516f, 0.25971749f, 0.08520312f, -0.04975542f, 0.00848575f, -0.00062253f, -0.07225997f, -0.06930725f, 
    -0.00965332f, 0.09703726f, -0.00435534f, 0.07023103f, -0.57164907f, -0.09598938f, -0.36785397f, 0.21661182f, 
    0.09508696f, 0.09457666f, -0.00672801f, 0.07932952f, 0.02271580f, -0.03983887f, 0.01297897f, -0.04405049f, 
    0.02266790f, 0.01601604f, -0.06683587f, -0.11473382f, -0.18101113f, 0.04136571f, -0.20927709f, -0.18300773f, 
    -0.01075423f, -0.08388701f, -0.02719802f, -0.09239763f, 0.06544340f, 0.07220482f, 0.03578343f, -0.03195441f, 
    0.00253444f, 0.05502415f, 0.10940259f, 0.01368139f, 0.06891433f, 0.09776668f, 0.08387760f, -0.09474821f, 
    -0.19732001f, -0.13869007f, -0.27421495f, 0.06901023f, -0.24192423f, -0.11850051f, -0.12364826f, -0.14231774f, 
    -0.16240971f, -0.34147853f, -0.22112766f, -0.10830527f, 0.09706216f, 0.07460050f, 0.08457211f, -0.28643245f, 
    -0.09359872f, -0.04512342f, -0.01749554f, -0.21392889f, 0.00117503f, -0.00987570f, -0.02818397f, -0.04726695f, 
    -0.63950282f, 0.03551402f, -0.09572861f, -0.32167438f, 0.09248579f, 0.03630242f, 0.09556798f, -0.01676281f, 
    -0.00362643f, -0.09990007f, -0.04252350f, -0.03608579f, 0.06856833f, 0.10406509f, 0.11353378f, 0.04281546f, 
    -0.09159115f, -0.01151090f, 0.00177748f, -0.11062142f, 0.06728034f, 0.01123351f, -0.00087792f, 0.04226004f, 
    -0.15815733f, 0.05382234f, 0.43155658f, -0.03112248f, 0.18135127f, -0.01277723f, 0.39277819f, -0.26519492f, 
    0.06909485f, -0.03620158f, -0.01301296f, -0.05685707f, 0.01318369f, 0.08391096f, 0.35828164f, -0.30472037f, 
    0.18890435f, 0.07132025f, -0.08283871f, 0.10051277f, -0.00909406f, -0.02100817f, 0.11220376f, -0.14240775f, 
    -0.32793081f, 0.01460191f, 0.01285724f, 0.13494408f, -0.12823775f, 0.00274250f, 0.03134985f, -0.00071952f, 
    -0.17749834f, -0.01816561f, -0.01949855f, 0.06189699f, 0.01073144f, -0.49794683f, -0.37258634f, -0.05678178f, 
    -0.19925168f, 0.02747228f, -0.03357753f, 0.14420395f, 0.09680181f, -0.23674367f, -0.31218255f, 0.01408282f, 
    0.02176607f, 0.02594364f, -0.03936491f, 0.22358532f, 0.16275337f, 0.04920577f, 0.15117262f, 0.23214528f, 
    -0.04289846f, 0.13091353f, 0.01383820f, 0.02768808f, -0.15018299f, 0.03685037f, 0.00183695f, 0.14143239f, 
    0.10906548f, -0.09009883f, 0.05349649f, -0.07561396f, 0.02984079f, -0.10887906f, -0.01128263f, 0.25316378f, 
    0.79641324f, 0.19924909f, -0.12420835f, 0.03946856f, -0.00402692f, 0.00288042f, -0.10241018f, 0.00338521f, 
    -0.03614320f, 0.23852727f, -0.10049125f, -0.09062712f, -0.47334471f, -0.32688800f, 0.19842069f, -0.04481448f, 
    0.05706681f, 0.08808720f, -0.12887590f, -0.00437913f, 0.06351189f, 0.06268068f, -0.12073241f, 0.06623642f, 
    0.00114993f, 0.02700154f, -0.30185774f, -0.03137019f, -0.17360842f, -0.03546501f, 0.06669606f, 0.27819315f, 
    -0.16657884f, 0.01622389f, 0.06515117f, 0.14163072f, 0.34819055f, -0.23648015f, -0.16732854f, 0.11106791f, 
    -0.10392977f, 0.17470513f, 0.15474261f, 0.02168391f, -0.07542920f, -0.05078442f, -0.05517234f, 0.14613438f, 
    -0.45373917f, -0.20864840f, -0.20926504f, -0.23066220f, 0.08304393f, -0.01149416f, -0.07621635f, 0.05170592f, 
    -0.30746785f, -0.11775817f, -0.01144445f, -0.08025715f, -0.04691296f, -0.01396998f, -0.00611418f, -0.24298222f, 
    0.01917152f, 0.03055383f, 0.21082456f, 0.13379245f, 0.18029973f, 0.22237322f, -0.27028131f, -0.00142998f, 
    -0.06790465f, -0.09505115f, -0.12363633f, 0.05226712f, -0.13422933f, -0.00442958f, 0.11559766f, -0.04565782f, 
    0.14539459f, -0.29591960f, -0.07655771f, -0.01791873f, -0.02036949f, -0.11933892f, 0.15553868f, 0.09546311f, 
    -0.04462630f, -0.19852437f, -0.13720238f, -0.54713118f, 0.00672981f, 0.03381310f, 0.01608813f, 0.00000169f, 
    -0.47332090f, -0.27804896f, -0.19662228f, -0.27899936f, -0.04769655f, -0.00318273f, -0.04386320f, 0.29417890f, 
    -0.10036816f, -0.07326942f, -0.34936953f, 0.12317090f, -0.07846123f, 0.04100252f, -0.05047404f, 0.09300848f, 
    0.04991944f, 0.20577548f, -0.07056724f, -0.41927451f, 0.16509679f, -0.15048608f, 0.07588760f, -0.04674140f, 
    0.07876251f, -0.02321584f, 0.04004734f, -0.10939098f, 0.08645481f, -0.06284788f, -0.21978819f, 0.07386635f, 
    -0.05257387f, 0.07549889f, 0.01596967f, 0.03588187f, 1.02062619f, -0.04832683f, 0.14247014f, -0.03419057f, 
    -0.02946748f, -0.01451658f, 0.04124189f, -0.05295575f, 0.19408113f, 0.00057049f, -0.20203665f, 0.20051274f, 
    -0.00012244f, 0.01805403f, 0.04618708f, 0.06034306f, 0.01231091f, -0.02828867f, 0.01678897f, -0.08314556f, 
    -0.15396513f, 0.12383897f, 0.02056014f, 0.08602712f, 0.42210248f, -0.23107252f, 0.09220649f, 0.25194594f, 
    0.03640081f, -0.11193062f, 0.11777262f, -0.23616089f, 0.17735182f, -0.07798854f, -0.23306601f, -0.12832330f, 
    0.43659276f, 0.00729467f, 0.12197117f, -0.07188234f, 0.15591708f, -0.11396609f, -0.22232462f, -0.23681790f, 
    0.09988772f, -0.04297177f, -0.17875154f, 0.04466062f, 0.32822457f, -0.09531534f, -0.36893937f, -0.26036325f, 
    -0.02877398f, 0.00476422f, 0.04387333f, -0.00439095f, 0.01435297f, 0.12060007f, 0.16361257f, -0.14018629f, 
    -0.64432842f, 0.22003260f, -0.38609990f, -0.20826602f, -0.05692266f, 0.16398583f, -0.02481806f, 0.12998441f, 
    -0.07689019f, 0.15557881f, 0.10701273f, -0.01160121f, 0.18873438f, 0.41351882f, 0.02408032f, 0.33917159f, 
    0.01878031f, 0.15912940f, 0.06229673f, -0.23963326f, -0.01368779f, -0.01782683f, -0.01950626f, -0.03010271f, 
    0.02551492f, 0.23771699f, -0.04658052f, -0.11413022f, 0.10556092f, -0.01621397f, -0.28624478f, -0.44516098f, 
    0.29225361f, -0.10183293f, -0.02819325f, -0.17569971f, 0.40134302f, 0.24784787f, 0.38262808f, 0.12727782f, 
    -0.01189606f, -0.00041006f, -0.02715804f, 0.06869689f, -0.02888060f, -0.04135126f, -0.04955208f, 0.30116513f, 
    -0.03529577f, 0.01321557f, 0.12478730f, -0.05283428f, -0.03327795f, 0.08265640f, 0.16037697f, 0.00544826f, 
    -0.08423236f, 0.22277834f, -0.05541832f, -0.15519984f, -0.08129619f, 0.34907633f, 0.07349284f, 0.18021756f, 
    -0.05881285f, -0.01721770f, -0.01476052f, 0.05211019f, -0.15970124f, 0.14468543f, -0.14836910f, -0.02277977f, 
    0.21327026f, -0.05068442f, 0.08231527f, 0.00847412f, -0.05919080f, 0.05649541f, 0.03788614f, -0.04262907f, 
    0.01310981f, 0.04535287f, 0.06842732f, -0.08228561f, -0.40638566f, 0.19703281f, -0.29643562f, -0.06872831f, 
    -0.35142225f, 0.05596527f, 0.00267049f, 0.03191493f, -0.09935100f, -0.00516032f, 0.04240079f, 0.01843719f, 
    0.34737590f, 0.30757982f, -0.21252884f, -0.09803869f, 0.01518629f, 0.09570089f, -0.02651082f, 0.02382887f, 
    0.02494038f, 0.00007913f, -0.19999294f, 0.08323936f, -0.08908014f, -0.02156420f, -0.00685610f, -0.00810554f, 
    -0.04374081f, 0.00192299f, 0.01700295f, 0.05654166f, -0.10618406f, -0.06967596f, -0.00749895f, 0.03927493f, 
    -0.33100268f, -0.14275262f, 0.15017623f, -0.17109498f, -0.16761065f, 0.04677867f, 0.18785086f, -0.02647036f, 
    0.06290242f, 0.00157963f, -0.02572406f, -0.03757419f, 0.35840052f, -0.19742051f, 0.75830334f, 0.83608645f, 
    -0.15057328f, 0.01770219f, 0.17308488f, 0.03646561f, 0.07631252f, -0.02658615f, -0.06869014f, 0.06442810f, 
    0.07215579f, 0.04151790f, -0.17387389f, 0.12878649f, -0.02320918f, 0.03452707f, -0.02669847f, 0.13093115f, 
    0.03252802f, -0.00907932f, 0.01486291f, 0.04253114f, 0.14860442f, -0.15754020f, 0.08362822f, -0.32718185f, 
    0.10852694f, 0.07317002f, -0.07615349f, -0.03376923f, -0.03846214f, 0.03105550f, -0.22280322f, -0.19494982f, 
    -0.38352847f, -0.33668706f, -0.11261682f, -0.29004133f, 0.16448811f, 0.00693761f, -0.08352891f, -0.18133266f, 
    0.01949109f, -0.07758987f, -0.13152683f, 0.06639667f, 0.09080441f, -0.15303774f, -0.12480466f, 0.17139246f, 
    0.14424354f, -0.04258393f, -0.04712079f, 0.12633155f, -0.01339156f, 0.20387316f, -0.26794216f, 0.11980712f, 
    -0.38151708f, 0.30077636f, 0.08866335f, -0.15043919f, 0.01035252f, 0.08613136f, 0.00123279f, 0.05262140f, 
    -0.05041391f, -0.12984733f, -0.09582048f, 0.06912842f, 0.20701596f, -0.18004321f, 0.06309825f, 0.08022570f, 
    0.07832388f, 0.01390032f, 0.09522359f, 0.03480917f, 0.01674394f, 0.03494706f, -0.02149149f, 0.17321913f, 
    -0.41800177f, -0.26053283f, -0.07009692f, -0.27244172f, 0.11135037f, -0.15884858f, -0.10958430f, -0.14318174f, 
    -0.00909370f, -0.00210845f, -0.09099562f, -0.04227651f, -0.20268856f, -0.34203669f, -0.04609378f, -0.27071416f, 
    -0.09072379f, 0.04851604f, 0.07636999f, 0.04020060f, 0.05524256f, 0.03258883f, 0.05889636f, -0.19908157f, 
    0.34983936f, 0.25688851f, 0.16569552f, 0.35697475f, 0.02157227f, 0.04332006f, 0.13900158f, -0.08192734f, 
    -0.02615042f, 0.09752209f, -0.21978357f, 0.31553650f, -0.03818358f, -0.03434576f, -0.01877267f, -0.10191902f, 
    -0.02604430f, -0.03716078f, 0.08387929f, -0.37504369f, -0.14669453f, 0.15185417f, 0.06473730f, 0.06522036f, 
    0.02057425f, -0.16330902f, 0.03127497f, 0.22635683f, -0.08045816f, 0.05371935f, 0.06357498f, 0.21869162f, 
    0.15555099f, -0.04576174f, 0.15076940f, -0.01870485f, -1.34772360f, -1.00771141f, -0.62061435f, -0.23660004f, 
    0.13070498f, -0.12381451f, 0.10558114f, 0.01609920f, -0.02729183f, 0.00372869f, 0.00225419f, -0.02599691f, 
    -0.27671111f, -0.21957864f, -0.55836493f, -0.35381231f, 0.09078626f, -0.03399111f, -0.08717763f, -0.11884625f, 
    0.05727642f, -0.13394085f, 0.08430405f, 0.14645889f, -0.26361525f, 0.37697828f, -0.32721421f, 0.27563581f, 
    -0.17344899f, 0.03705326f, 0.22681670f, -0.04920698f, -0.02356982f, 0.01326679f, 0.03767604f, -0.07079611f, 
    -0.13280188f, -0.12067523f, 0.12494329f, -0.03246022f, 0.04907604f, -0.20860498f, -0.41593567f, 0.01488603f, 
    0.18042204f, -0.05471053f, -0.10186923f, 0.06327371f, -0.17690350f, 0.36169827f, 0.39156574f, -0.08411664f, 
    0.00980611f, -0.03413730f, -0.05151733f, -0.03022447f, 0.04561649f, -0.03668781f, -0.16276130f, 0.16472210f, 
    0.00817660f, -0.02053652f, -0.04010990f, 0.04882830f, -0.15738285f, 0.03279583f, 0.07121755f, 0.05053302f, 
    0.01166814f, 0.05296687f, -0.09443612f, 0.04088507f, -0.04578055f, 0.58580446f, 0.24759819f, -0.03794983f, 
    0.01463803f, -0.14831449f, 0.07578710f, -0.16508439f, -0.04913502f, 0.11260445f, 0.17723089f, 0.04041937f, 
    0.23056220f, 0.27069545f, 0.32452619f, 0.00774136f, 0.06183076f, 0.00088603f, -0.05174167f, -0.02805831f, 
    0.00550154f, 0.04799188f, 0.02241827f, -0.06042390f, -0.23115517f, 0.40414989f, 0.44029430f, 0.17468970f, 
    0.00067634f, -0.01641764f, 0.19000499f, -0.11433740f, 0.02262331f, -0.18432231f, 0.04928082f, 0.01320957f, 
    -0.12827374f, 0.11388751f, -0.51960903f, 0.00925082f, 0.13147700f, 0.03594099f, -0.16459318f, -0.06990370f, 
    -0.02289839f, -0.24272287f, -0.18014576f, 0.05244800f, -0.33120811f, 0.05878377f, 0.06004132f, 0.33508527f, 
    -0.07111245f, -0.17139465f, 0.15405075f, -0.05361427f, 0.00246109f, 0.01529567f, 0.05889387f, -0.03838233f, 
    -0.06689649f, -0.10916858f, 0.19534142f, 0.14871144f, -0.05782012f, 0.03517248f, 0.00073561f, -0.06761528f, 
    0.02137931f, 0.15106457f, 0.00264417f, 0.13672622f, -0.35487869f, -0.25661737f, 0.02860227f, -0.17434239f, 
    -0.02093768f, -0.05866298f, 0.02263034f, 0.03117240f, -0.01380323f, -0.09742842f, 0.09365075f, -0.00827631f, 
    0.01984906f, -0.11545718f, 0.04371426f, -0.04621014f, 0.14963222f, -0.08816725f, -0.05258507f, 0.06810860f, 
    -0.05966641f, -0.00971423f, -0.05411246f, -0.01953212f, -0.32344604f, -0.00986425f, -0.41791716f, 0.29056069f, 
    0.00739417f, 0.03945003f, -0.05419058f, 0.04234373f, 0.03164658f, 0.02560386f, 0.03408939f, 0.00458991f, 
    0.00008604f, -0.03815587f, 0.02870882f, -0.03266714f, 0.04318332f, -0.00635551f, 0.00510877f, -0.13216637f, 
    0.18201368f, 0.08363047f, -0.26574969f, 0.30505890f, -0.08025154f, 0.35580233f, -0.51992750f, 0.05986971f, 
    -0.33278874f, -0.32336524f, -0.30117875f, 0.10154594f, -0.03222545f, 0.01113062f, -0.01233882f, -0.04913363f, 
    0.25450665f, 0.04617080f, 0.15714788f, -0.12953198f, -0.07506893f, -0.17781416f, -0.10427687f, -0.23716894f, 
    -0.17224765f, 0.07287715f, -0.15293404f, -0.07374442f, -0.15221260f, -0.33079386f, 0.09250502f, -0.11723401f, 
    -0.16963257f, -0.38419834f, -0.07143243f, -0.06759624f, -0.00954595f, 0.08041847f, -0.06400637f, -0.24828020f, 
    -0.13406283f, -0.05591304f, -0.26422101f, 0.12414094f, -0.07590485f, -0.02696772f, -0.17726204f, 0.00297213f, 
    0.04466553f, -0.12522085f, -0.11787193f, -0.18678735f, 0.14847474f, -0.16429161f, 0.09958810f, 0.30085298f, 
    0.13450271f, 0.09473041f, 0.01012812f, -0.08382677f, -0.14596303f, 0.12154959f, -0.03946325f, 0.18356872f, 
    0.18455994f, -0.19608530f, -0.13720006f, -0.01271342f, 0.06209885f, 0.02269157f, 0.00977243f, -0.00035768f, 
    0.03125473f, 0.17003563f, -0.00934932f, 0.13770811f, -0.00630180f, 0.26163846f, -0.23014212f, 0.27878273f, 
    0.18964110f, -0.20602420f, 0.10547906f, -0.07737853f, -0.25035444f, 0.00795362f, -0.05258430f, 0.08553281f, 
    0.01606129f, -0.05184740f, -0.05413928f, 0.26503098f, 0.02678329f, 0.06811531f, 0.07091177f, 0.01608645f, 
    -0.07323389f, 0.14862390f, -0.14703932f, -0.05027055f, -0.05765827f, -0.26338798f, -0.19364487f, -0.72442240f, 
    0.03589033f, 0.18412116f, -0.12922309f, -0.21333164f, -0.06714591f, 0.13638043f, -0.23648226f, 0.05549490f, 
    -0.45311442f, 0.29650348f, 0.01372068f, 0.28596729f, 0.02137234f, 0.04768552f, -0.14980847f, -0.18201046f, 
    -0.16142416f, -0.12657313f, 0.11600585f, -0.03673306f, 1.43626606f, 0.05213099f, -0.53548056f, -0.51349688f, 
    0.06619910f, -0.10908026f, 0.04470631f, -0.24633710f, -0.30580780f, -0.17936684f, -0.07820024f, 0.03679232f, 
    0.08747058f, -0.29494041f, 0.02652044f, 0.27354544f, -0.03037217f, 0.03148016f, 0.11031342f, 0.03490692f, 
    0.02768033f, -0.05058339f, 0.09334180f, 0.08967908f, -0.56852221f, 0.26166052f, -0.01995459f, 0.38262650f, 
    0.07702489f, 0.07264544f, -0.24424291f, -0.15633968f, 0.03893498f, 0.00630183f, 0.01276830f, -0.22528407f, 
    0.20592043f, -0.09924225f, -0.03177892f, 0.29987937f, 0.14618433f, 0.04229648f, 0.01307339f, -0.12471941f, 
    -0.13385011f, 0.11662752f, 0.01265474f, 0.14365442f, -0.14776364f, -0.05450757f, 0.21424606f, 0.22688220f, 
    0.00031703f, -0.00874636f, 0.43893534f, 0.00826009f, 0.00245487f, 0.08342033f, -0.10207796f, 0.23472524f, 
    -0.31260633f, 0.75045443f, -0.51470238f, -0.59532064f, 0.14816101f, 0.17748758f, 0.06741201f, 0.01276369f, 
    -0.31271926f, 0.00589621f, -0.10428622f, -0.00268702f, 0.09419081f, -0.15631370f, -0.23667410f, -0.05108113f, 
    0.05387056f, 0.09977712f, 0.02436177f, -0.12574691f, -0.01032727f, -0.03071091f, -0.08006927f, -0.03644158f, 
    0.00955898f, -0.02403467f, 0.09083532f, 0.03336070f, 0.04320342f, 0.16358188f, -0.05480157f, -0.02327179f, 
    -0.11111398f, 0.10192071f, -0.15222409f, 0.10677363f, -0.20848344f, -0.22762510f, -0.07282057f, 0.20572770f, 
    0.02846011f, 0.03869507f, -0.01681215f, 0.02235112f, 0.05293469f, 0.07716969f, -0.03790606f, 0.06239660f, 
    -0.16033348f, -0.00499432f, 0.38761532f, 0.05651155f, -0.20581546f, -0.07592610f, -0.18576299f, 0.01379518f, 
    0.05734637f, -0.25489691f, -0.18359703f, 0.00962456f, -0.40922806f, 0.55145705f, -0.22514826f, 0.12726660f, 
    0.07482552f, 0.02516689f, 0.23213142f, -0.10885024f, -0.24777213f, 0.08956262f, -0.14375974f, 0.05906735f, 
    0.11691475f, -0.04957873f, -0.15191351f, -0.17328475f, 0.05586960f, -0.08588925f, -0.21502437f, -0.07993589f, 
    0.06730983f, -0.03632211f, 0.16658005f, -0.28245282f, -0.34763840f, 0.27391747f, 0.10258177f, 0.18166208f, 
    -0.09089364f, -0.02800775f, 0.26201746f, -0.11770441f, -0.10821309f, -0.05711294f, -0.12694192f, 0.02691527f, 
    0.29886609f, -0.27326420f, 0.00442132f, 0.33477509f, 0.06500515f, -0.03426925f, 0.01679953f, -0.18913704f, 
    -0.12240156f, 0.01616682f, -0.06387857f, 0.16982004f, 0.26803845f, -0.32194278f, 0.10544325f, 0.15841529f, 
    0.32694533f, 0.15904292f, 0.30368575f, -0.14816035f, 0.01122148f, 0.03565748f, 0.02247838f, 0.00537469f, 
    0.30203325f, -0.11638637f, 0.08817151f, -0.06743690f, 0.14828269f, -0.07418002f, 0.12752002f, -0.04095858f, 
    0.11769044f, 0.21857315f, -0.16186956f, -0.04330616f, 0.01499661f, -0.22927324f, -0.10621802f, 0.20826466f, 
    0.01724567f, -0.00097473f, 0.04238924f, 0.12618779f, 0.08494893f, 0.11060778f, 0.07686447f, 0.10534275f, 
    -0.08719443f, -0.12229627f, -0.11813597f, -0.06711626f, 0.06028504f, 0.04022764f, 0.07909492f, 0.00085105f, 
    0.00727927f, 0.01529323f, -0.13753240f, -0.04567608f, -0.23673412f, -0.23051062f, 0.19146548f, 0.06154555f, 
    0.03737563f, -0.13037913f, 0.03382267f, -0.00678755f, -0.08957817f, 0.27339068f, -0.08738524f, -0.07802565f, 
    0.61204940f, -0.17760135f, 0.17521860f, 0.19439287f, -0.10772252f, 0.17137185f, -0.43768319f, -0.16958894f, 
    -0.05930901f, -0.12874961f, -0.00158967f, -0.09473987f, -0.43379971f, 0.11419413f, -0.38110742f, -0.91300315f, 
    -0.10453667f, 0.15812775f, 0.11111737f, 0.06009598f, -0.18010111f, -0.06127013f, 0.04139442f, -0.26438749f, 
    -0.65295762f, 0.18295403f, -0.34160832f, 0.06479459f, -0.04591663f, -0.15207523f, -0.19815329f, -0.30522230f, 
    -0.03930575f, -0.08920635f, 0.18681161f, -0.03744270f, -0.04843056f, 0.66932154f, -0.43360144f, 0.55279654f, 
    0.02569130f, -0.18089625f, 0.10284036f, 0.05357481f, 0.11720818f, 0.04290283f, -0.03521925f, 0.15523510f, 
    -0.02074969f, -0.08886295f, -0.09086057f, 0.10132513f, -0.16668294f, -0.05712656f, -0.07852877f, 0.16683102f, 
    0.03780762f, -0.06720941f, -0.00413396f, -0.13309783f, 0.04676104f, 0.03788866f, -0.04460666f, 0.04486601f, 
    0.13890122f, 0.07797522f, 0.10926084f, 0.13292271f, -0.00707531f, -0.03829001f, -0.01042107f, -0.00766398f, 
    -0.07605944f, 0.07082789f, 0.16580597f, 0.09485260f, -0.17935586f, 0.07137126f, 0.03677864f, 0.03029668f, 
    -0.04276372f, 0.04669898f, -0.01008079f, -0.01638591f, 0.10140668f, 0.16649443f, -0.00375415f, 0.07492699f, 
    -0.10530249f, -0.26156980f, 0.04915466f, -0.06231210f, 0.17164415f, -0.11234697f, 0.09149165f, 0.09939317f, 
    0.04943111f, -0.10028885f, 0.09803385f, -0.11718649f, -0.08046859f, -0.24919364f, -0.05813619f, -0.04064249f, 
    0.18435214f, -0.03488602f, -0.08343397f, -0.06597370f, 0.34278426f, -0.13240150f, -0.06825674f, 0.20387809f, 
    0.05332565f, -0.00529166f, -0.07423612f, -0.04089763f, -0.17385705f, -0.04558209f, 0.05404215f, -0.16366200f, 
    0.01938873f, 0.09159184f, 0.28113258f, 0.24045889f, -0.00037405f, 0.03019939f, -0.14801697f, 0.08188333f, 
    0.10935263f, -0.10391567f, 0.04687261f, 0.00066254f, 0.20357963f, 0.10762139f, -0.16377099f, -0.06925251f, 
    -0.06451230f, -0.12840778f, -0.06857605f, -0.06827740f, -0.03480994f, -0.00769840f, -0.17188172f, 0.02633285f, 
    -0.29810047f, -0.26707494f, -0.08535833f, -0.35710940f, 0.06556074f, 0.06503541f, 0.09362511f, 0.00443262f, 
    0.08220677f, -0.14993992f, -0.18493959f, 0.12776585f, -0.21007037f, -0.56107104f, -0.39691731f, -0.03233578f, 
    0.08602968f, -0.07796324f, -0.02663549f, 0.06719224f, 0.08788814f, 0.04627731f, 0.06228304f, -0.03581624f, 
    -0.01557807f, 0.31412989f, 0.28404528f, 0.43041724f, -0.05874978f, 0.07285145f, 0.05092556f, 0.26451212f, 
    -0.05315709f, 0.01921184f, -0.04552389f, -0.01756066f, -0.11195873f, 0.04848543f, 0.06232555f, -0.35888362f, 
    -0.12598641f, -0.00611232f, -0.16333739f, -0.15379709f, 0.00448651f, 0.00362431f, 0.02029372f, -0.25582609f, 
    0.14836298f, -0.05127557f, 0.06284346f, 0.20019522f, -0.09345565f, -0.04969806f, 0.00645797f, 0.01642683f, 
    0.28007257f, -0.02530436f, 0.04563303f, 0.13737951f, 0.23252432f, 0.27065775f, 0.13700393f, 0.12121063f, 
    0.12014234f, 0.05852805f, -0.36925122f, -0.05800631f, -0.00553065f, 0.21391030f, 0.04312402f, -0.10305428f, 
    -0.05685997f, -0.40569985f, 0.29315245f, 0.15749890f, -0.42940855f, 0.00210808f, -0.11886693f, -0.03377260f, 
    -0.17255788f, 0.26060224f, -0.04510827f, 0.06251547f, -0.05594932f, 0.04720429f, 0.19434740f, 0.17320885f, 
    -0.10087325f, -0.02628679f, -0.05650868f, 0.13027745f, 0.05364624f, 0.02083213f, 0.02928821f, 0.05699473f, 
    0.18807404f, 0.18724394f, 0.09495682f, 0.21136910f, 0.08900876f, -0.06056777f, 0.05132843f, -0.13535504f, 
    0.15413845f, 0.03697925f, 0.31319615f, -0.00492234f, -0.06486782f, 0.14888275f, 0.28702539f, 0.10596550f, 
    -0.00508280f, -0.11391312f, 0.10161046f, 0.00503779f, 0.06276418f, 0.08229178f, -0.00179056f, 0.08699146f, 
    0.03179859f, 0.08008628f, -0.04947516f, 0.13726209f, 0.13237469f, 0.13210425f, 0.14457063f, -0.31547076f, 
    0.25638455f, 0.05470915f, 0.00131288f, -0.05112364f, -0.14604744f, -0.46749312f, -0.06870851f, -0.18512705f, 
    0.03361034f, 0.14150499f, -0.06434291f, 0.12971835f, -0.02984603f, -0.17556813f, -0.05422137f, -0.01251590f, 
    0.02435818f, -0.04096913f, 0.01249073f, 0.01772335f, -0.05132451f, 0.00726505f, 0.02965056f, 0.10660084f, 
    0.04977312f, -0.21315238f, -0.09734596f, -0.10862237f, -0.18887313f, -0.10289557f, 0.15224077f, -0.27430454f, 
    0.00227313f, 0.12591693f, -0.37926728f, 0.03958036f, -0.09765802f, -0.01859261f, -0.06882829f, 0.09307192f, 
    -0.43130237f, -0.13296442f, -0.08625869f, 0.10315952f, -0.01550896f, -0.05004152f, 0.02609078f, -0.22605067f, 
    -0.13038039f, 0.11041730f, 0.08517127f, 0.02047908f, -0.05056906f, 0.26462671f, 0.11333288f, 0.04278084f, 
    0.01067653f, -0.04937381f, -0.03135321f, 0.16044191f, 0.11455935f, -0.26398253f, -0.07746523f, 0.03684856f, 
    0.15486442f, 0.17979348f, -0.01682203f, 0.17959364f, 0.01772075f, -0.10354834f, -0.08620824f, -0.08697388f, 
    -0.13839909f, -0.26942059f, -0.27616045f, -0.14238532f, -0.13850261f, -0.08741856f, 0.07438353f, 0.02142066f, 
    0.01632527f, -0.00545493f, -0.23029159f, 0.00286143f, -0.03480137f, -0.02830013f, 0.08587337f, 0.04466475f, 
    -0.11677253f, -0.12738554f, -0.17304988f, -0.03305884f, -0.10120606f, -0.02723070f, 0.03190301f, -0.04992549f, 
    -0.32626614f, -0.12186025f, -0.04872075f, 0.11033412f, -0.15333073f, -0.21923801f, -0.45658433f, -0.09260658f, 
    0.01077133f, 0.01151069f, 0.03547807f, 0.02958925f, 0.06160239f, -0.03709424f, 0.03139212f, -0.19608670f, 
    -0.00204140f, 0.05708262f, -0.13893469f, 0.16126400f, 0.00272081f, -0.32909489f, 0.07449641f, -0.04744840f, 
    -0.01315440f, -0.11288702f, -0.07273562f, -0.15120630f, -0.08811533f, -0.41919270f, -0.01479209f, -0.44339517f, 
    0.02971046f, 0.07078186f, 0.06581742f, 0.16030356f, -0.09782382f, 0.03383838f, 0.13862129f, 0.06121980f, 
    0.00313253f, 0.02051738f, -0.20109366f, -0.07955677f, 0.08834069f, -0.03243943f, 0.06433982f, -0.11677119f, 
    -0.10290250f, -0.00761223f, -0.12243346f, -0.13100931f, 0.14352778f, -0.37842900f, 0.57414085f, 0.03953955f, 
    0.25318369f, -0.20372863f, -0.02402936f, -0.02534365f, -0.03980653f, -0.05017515f, 0.07067814f, -0.00636712f, 
    0.22307067f, -0.09001378f, -0.05363964f, 0.35621673f, 0.09641256f, 0.04866318f, -0.04808942f, -0.05925101f, 
    0.03381374f, 0.05751624f, 0.02367938f, 0.06348652f, -0.18700960f, -0.18499315f, -0.09916466f, -0.00322797f, 
    0.23214570f, -0.14453003f, -0.13474499f, 0.00808762f, -0.15692413f, -0.04054227f, -0.03032525f, 0.11084808f, 
    0.25573215f, 0.18977635f, -0.06988290f, 0.08014484f, 0.15015462f, 0.01482546f, -0.21655123f, -0.07981650f, 
    -0.04955715f, 0.00621271f, 0.02729489f, 0.10704117f, -0.34136224f, -0.01592040f, -0.17023484f, -0.22400215f, 
    0.12505054f, 0.09395697f, 0.03697364f, 0.11717995f, 0.11129493f, 0.08018227f, -0.15669012f, -0.12983304f, 
    0.08409722f, 0.06086952f, -0.15406582f, -0.03578646f, 0.21526501f, 0.12893079f, 0.09750240f, 0.07190545f, 
    0.12207636f, 0.05827683f, 0.07735975f, -0.02681685f, -0.23465058f, 0.09264180f, 0.17988640f, -0.56676143f, 
    -0.03534993f, 0.05577960f, 0.05240125f, 0.09626631f, 0.20561512f, -0.12705533f, 0.29518682f, 0.14816058f, 
    0.11280744f, 0.19311866f, 0.26513201f, -0.18387277f, -0.05928241f, 0.10693189f, 0.15313362f, 0.02049008f, 
    0.11393946f, 0.03994686f, 0.11393194f, 0.02025835f, 0.05975590f, 0.03102717f, 0.19914454f, 0.09667725f, 
    -0.03066062f, -0.16276637f, -0.05932145f, 0.16428994f, 0.21480289f, -0.13011445f, 0.27543065f, 0.00585585f, 
    -0.06961992f, -0.18318757f, 0.09155497f, -0.19411646f, 0.00244081f, -0.08247874f, 0.00373499f, 0.01808815f, 
    0.19123209f, 0.14847609f, 0.19126524f, -0.23196860f, -0.74618047f, 0.87929440f, 0.10230549f, 0.18160678f, 
    -0.16580054f, -0.26760513f, 0.02734353f, 0.11649101f, 0.12555102f, -0.08871942f, -0.07112271f, -0.08926733f, 
    -0.19158676f, -0.04739197f, 0.34348810f, -0.30658057f, 0.10189035f, -0.09959716f, 0.03099686f, -0.32154343f, 
    0.06809031f, 0.05494663f, -0.02888886f, 0.00390867f, 0.19752260f, 0.08544171f, -0.18870501f, -0.36785161f, 
    0.17966063f, 0.02932840f, -0.12730797f, -0.19042858f, 0.14176661f, 0.04202755f, -0.08261364f, 0.16122091f, 
    -0.27252057f, 0.23888114f, -0.17421001f, -0.17153664f, 0.04157792f, 0.04133774f, -0.02019434f, -0.06158331f, 
    0.21626219f, -0.24461192f, -0.07791067f, -0.17171904f, 0.05323331f, 0.02567301f, -0.12829927f, -0.11581443f, 
    -0.11922108f, 0.07429059f, -0.17787257f, -0.28077456f, -0.03073483f, -0.56254190f, 0.13407406f, -0.03917872f, 
    -0.39751005f, -0.08194169f, 0.11746967f, -0.06868029f, 0.27811226f, -0.18839972f, 0.00056010f, 0.06025849f, 
    -0.03162698f, -0.00377224f, 0.01981894f, 0.00538968f, -0.14739044f, 0.41356614f, 0.13334905f, 0.02414981f, 
    0.12093241f, 0.11276486f, 0.09101114f, 0.36299962f, 0.06025835f, 0.09535114f, 0.08166759f, 0.12112799f, 
    0.14609875f, 0.22438982f, 0.22836900f, 0.05891546f, -0.01659328f, -0.01266702f, 0.03348842f, -0.15630771f, 
    -0.04984572f, -0.26886669f, 0.04031111f, -0.25057516f, 0.25254613f, -0.00847484f, -0.01996630f, 0.01230931f, 
    0.02699491f, 0.18136042f, -0.25186568f, -0.00128053f, 0.04652580f, -0.03729878f, -0.19427557f, -0.04790744f, 
    -0.07117419f, -0.00932222f, -0.23283106f, 0.17607316f, -0.04076404f, -0.07906874f, 0.18064231f, 0.21371397f, 
    -0.05819318f, 0.02036305f, 0.10025089f, -0.05834086f, -0.24790472f, -0.06510700f, -0.48808473f, -0.12633827f, 
    0.05280992f, 0.01213568f, -0.06017576f, 0.01554672f, 0.09062554f, -0.16508183f, -0.02220375f, -0.02831856f, 
    -0.13892566f, 0.00824687f, 0.00599534f, -0.00179549f, 0.07632193f, 0.20064636f, -0.05001475f, -0.04254563f, 
    0.16978991f, -0.04989998f, -0.02601898f, 0.18313649f, 0.06620455f, -0.03642046f, -0.52863568f, -0.26186213f, 
    -0.11980237f, 0.11853328f, -0.10366759f, -0.02586771f, 0.04780720f, -0.24182406f, -0.07057416f, 0.01718237f, 
    -0.25015727f, 0.21971774f, -0.17873040f, -0.42893994f, -0.16967764f, -0.02550272f, -0.00930973f, 0.12083849f, 
    -0.06177237f, -0.12011598f, 0.07484818f, -0.00246956f, -0.70549279f, -0.39745703f, -0.46682751f, -0.24188393f, 
    -0.03833168f, -0.05724325f, -0.07705446f, -0.03979816f, 0.08973721f, -0.01134689f, -0.01050288f, -0.02972277f, 
    -0.25104639f, -0.40897962f, 0.13884185f, 0.16454685f, -0.33730116f, -0.02494311f, 0.12891981f, -0.05843914f, 
    0.06633305f, -0.01488137f, 0.19179961f, 0.06332020f, 0.05760410f, 0.05998404f, 0.10179355f, -0.30432314f, 
    0.15838934f, -0.17484152f, -0.13790382f, 0.08955310f, -0.06720388f, -0.01261484f, -0.03327754f, 0.08375016f, 
    -0.09347431f, -0.17652118f, 0.14172389f, -0.09804931f, -0.10570075f, 0.01114726f, -0.00205003f, 0.23060794f, 
    -0.34879369f, -0.03610087f, -0.03194755f, -0.09127077f, -0.00111567f, -0.42659357f, -0.40957877f, 0.10261826f, 
    0.03039058f, 0.07300226f, -0.02620130f, -0.06660836f, 0.03372466f, -0.01244501f, 0.17416206f, -0.07851109f, 
    -0.23294327f, 0.11045200f, -0.13741177f, -0.02406389f, 0.18664311f, 0.16864707f, -0.00302681f, 0.21518706f, 
    0.16886598f, -0.02450859f, 0.09842492f, 0.36406991f, 0.32249233f, -0.62736666f, 0.33143613f, 0.12435386f, 
    0.00844052f, -0.00701547f, -0.06422956f, -0.05299588f, 0.06866893f, -0.30140546f, -0.21497032f, 0.06687105f, 
    -0.01088397f, 0.27355531f, -0.14402357f, -0.29678664f, -0.00104076f, 0.00644914f, -0.10673337f, 0.29717374f, 
    0.28206900f, 0.08053676f, -0.02982212f, 0.15181912f, 0.43269086f, -0.27624074f, 0.30888152f, -0.20358077f, 
    0.17533836f, 0.05822415f, 0.04208258f, 0.12180886f, -0.00655601f, -0.00884614f, -0.02379691f, -0.09791965f, 
    -0.16879934f, 0.26646399f, -0.45317423f, -0.65734541f, -0.12543049f, -0.00755809f, 0.14496204f, -0.01805071f, 
    0.02217609f, 0.04870421f, 0.15857387f, -0.14487758f, 0.00726880f, -0.06248993f, -0.01378561f, 0.00913807f, 
    0.04553623f, 0.01404887f, 0.01592408f, 0.01490852f, -0.24457686f, -0.16603965f, -0.08868726f, -0.06727384f, 
    -0.55168742f, -0.69926322f, -0.57692683f, -0.01310281f, 0.03093029f, -0.20492379f, -0.09284516f, -0.24260189f, 
    0.06698102f, -0.06918053f, -0.02467832f, 0.06390861f, -0.85014451f, 0.00994230f, 0.18810628f, -0.43539214f, 
    0.03670886f, -0.19557445f, -0.15673068f, -0.09235130f, -0.05913527f, -0.00379386f, 0.00473889f, 0.08458094f, 
    -0.43614992f, -0.11403286f, 0.31826290f, -0.09977645f, -0.10820061f, -0.07596697f, -0.05725530f, -0.43678722f, 
    0.01756073f, 0.04137139f, -0.11783810f, -0.07317530f, -0.25985941f, -0.06197140f, 0.56838238f, 0.20149289f, 
    -0.02603588f, 0.03030424f, 0.07246759f, 0.00014265f, 0.07783297f, 0.34909973f, -0.01387989f, 0.14992389f, 
    -0.69058239f, -1.04716253f, -0.38853511f, -0.48129171f, -0.24690574f, -0.38511240f, -0.12525672f, -0.15937042f, 
    0.00455731f, 0.05678604f, -0.04342433f, -0.19921716f, 0.10498650f, -0.14009015f, 0.09585236f, 0.10634735f, 
    0.02722780f, 0.21217661f, 0.10499811f, 0.15979350f, 0.11168096f, -0.05328824f, 0.12259591f, -0.21369781f, 
    0.10597120f, 0.31000501f, -0.14123042f, 0.11898458f, 0.10660351f, 0.05247136f, 0.03805179f, 0.01596700f, 
    0.09152719f, -0.11770443f, 0.21262892f, 0.21007325f, 0.01778438f, -0.12651676f, -0.08758792f, 0.02599283f, 
    -0.04026060f, 0.01046349f, -0.00231947f, 0.07150357f, 0.18923578f, -0.04457757f, 0.39255455f, -0.12401908f, 
    -0.51400089f, -0.55950826f, -0.61707705f, 0.34626201f, 0.03058720f, 0.11185906f, -0.11931906f, -0.22203247f, 
    0.08883009f, -0.14252807f, 0.04976598f, 0.05752800f, 0.32309672f, -0.00863726f, -0.08994415f, -0.01480138f, 
    0.05695084f, -0.11354767f, 0.07554957f, 0.11841453f, -0.02661823f, 0.00421017f, -0.11196730f, -0.08197062f, 
    0.04456720f, 0.39647990f, 0.16689877f, 0.06010932f, -0.05243005f, -0.02984044f, 0.02833599f, 0.13784690f, 
    0.05116345f, 0.08114754f, 0.21657750f, -0.02925919f, -0.11091285f, 0.04388554f, -0.00904202f, -0.12596296f, 
    -0.03902747f, -0.08736718f, -0.25155446f, -0.04417011f, 0.21025488f, -0.15703994f, 0.02366828f, 0.03485500f, 
    -0.20686077f, 0.02270492f, 0.28561655f, -0.04449691f, -0.05878006f, -0.19986005f, 0.02232018f, -0.01421791f, 
    -0.05409707f, 0.19157824f, 0.13767153f, -0.16978794f, -0.51785886f, -0.64663005f, -0.78566742f, -0.02787780f, 
    -0.15704149f, -0.12015615f, -0.13921906f, -0.27675855f, 0.01283603f, -0.00968614f, -0.00248761f, 0.08141553f, 
    -0.34112328f, -0.02741081f, 0.20536610f, -0.67464036f, 0.05011596f, 0.09249079f, -0.13231651f, 0.04729246f, 
    0.03884288f, 0.13269161f, 0.03446341f, -0.09168107f, -0.75016284f, -0.02186031f, -0.06545026f, 0.26338756f, 
    -0.32410103f, 0.08331282f, -0.31071213f, 0.09859061f, -0.01023936f, 0.02656196f, -0.01105585f, 0.07176521f, 
    0.34606954f, -0.38585970f, -0.23377614f, 0.07518337f, -0.02372906f, 0.18421152f, 0.28278896f, -0.02972034f, 
    0.16847917f, -0.07787529f, -0.13092586f, 0.01678666f, -0.09341412f, 0.32811525f, -0.14816320f, 0.06434337f, 
    0.02339647f, 0.02629814f, 0.03842231f, 0.15379508f, 0.03774898f, 0.11982328f, 0.13987228f, -0.07595971f, 
    0.01001609f, -0.04368506f, -0.02534036f, 0.03866901f, -0.14306603f, -0.25639227f, 0.01762588f, 0.27570501f, 
    0.00057708f, -0.05936212f, 0.08537521f, -0.11843242f, -0.23203592f, 0.49554327f, -0.37124985f, 0.32268703f, 
    0.02944052f, -0.04017550f, 0.06404826f, 0.08819828f, 0.16783983f, 0.18858026f, 0.25622919f, -0.06423999f, 
    -0.76741415f, -0.10587540f, 0.45002839f, 0.13031781f, -0.24993277f, 0.04984085f, 0.18075351f, -0.01543071f, 
    -0.11566509f, 0.11581085f, 0.06512111f, -0.03361693f, -0.24255013f, 0.49602431f, 0.40423009f, 0.20339099f, 
    -0.06310281f, -0.04433820f, -0.14489304f, 0.01871159f, -0.08911519f, 0.08109896f, -0.13693418f, 0.09130010f, 
    -0.39243689f, -0.06304757f, 0.34242529f, 0.14960355f, -0.15350166f, -0.22004211f, -0.12922552f, 0.10252224f, 
    0.03555705f, -0.05396130f, -0.16971315f, -0.11263471f, -0.42758721f, -0.98331934f, -0.49989340f, -0.12863214f, 
    0.00489294f, -0.06467580f, -0.07254780f, -0.33805084f, 0.01900784f, 0.09774451f, -0.05021415f, 0.10456817f, 
    -0.11204951f, -0.03951668f, 0.00164418f, 0.28634933f, -0.11216950f, 0.05133726f, 0.15581189f, 0.46011931f, 
    0.08462822f, 0.02518062f, 0.30466637f, 0.03540380f, -0.13303499f, 0.00726256f, -0.07087899f, -0.46279410f, 
    0.11585742f, -0.01175683f, 0.02180941f, -0.12101250f, -0.06553207f, 0.08793882f, -0.26210189f, -0.21434028f, 
    -0.22801027f, -0.21570083f, -0.03319325f, -0.13897750f, -0.01169136f, -0.18246616f, 0.06427858f, 0.04854271f, 
    0.01129825f, -0.07012338f, -0.01215611f, -0.11344209f, 0.02017727f, 0.07207724f, 0.04912682f, -0.04690807f, 
    -0.01385871f, 0.03232620f, -0.02609339f, 0.10783496f, 0.03841140f, 0.02316803f, 0.14695346f, 0.16997033f, 
    0.39505133f, -0.02986727f, -0.18322569f, 0.18183693f, 0.23448798f, -0.03739225f, 0.12090294f, 0.15752780f, 
    -0.00954612f, -0.13058251f, -0.11511704f, -0.23583317f, -0.87841499f, -0.90328342f, -0.64235622f, 0.43606904f, 
    0.36076710f, 0.37805289f, 0.02062267f, -0.04218341f, 0.00580141f, -0.05030981f, -0.00981530f, 0.13783771f, 
    -0.20822917f, 0.40065390f, -0.05453487f, 0.36337620f, -0.19529970f, 0.06581352f, -0.22346339f, -0.01837851f, 
    -0.03246906f, 0.08330097f, -0.12011604f, 0.00557213f, 0.12994888f, 0.12093119f, 0.05505486f, -0.04108018f, 
    -0.05101383f, 0.05124053f, -0.05507956f, -0.11258221f, -0.08428580f, 0.02599693f, -0.01907953f, -0.04849449f, 
    -0.54331309f, -0.27703243f, -0.13730308f, -0.43534511f, 0.06118537f, -0.05694974f, 0.14051569f, 0.12825079f, 
    -0.01569076f, 0.11180676f, -0.00818767f, -0.07182081f, 0.34481943f, -0.81598419f, -0.58155644f, -0.80669850f, 
    -0.21667805f, -0.01336120f, -0.05570913f, 0.05962891f, 0.12358441f, -0.00996432f, 0.04745848f, 0.11410229f, 
    0.19209513f, -0.11547899f, -0.00787839f, 0.02793845f, 0.21442597f, 0.01971382f, -0.17743380f, -0.10983578f, 
    0.03347139f, 0.04487588f, 0.01266148f, 0.05235421f, -0.05701223f, 0.00741777f, 0.16293107f, -0.33175141f, 
    -0.06583618f, -0.00228620f, 0.06060876f, 0.07148101f, -0.10952540f, 0.03376433f, -0.06361774f, -0.16690683f, 
    -0.69310313f, -0.50386035f, 0.18509521f, 0.37691930f, -0.17930417f, -0.01019223f, -0.14373082f, -0.10258451f, 
    0.02205547f, -0.06537559f, -0.06599225f, -0.02129033f, 0.21791840f, -0.02987309f, 0.08736873f, -0.10017978f, 
    0.00567023f, 0.05567253f, -0.05502610f, -0.08696919f, -0.12790164f, -0.11841912f, -0.38958174f, -0.03840256f, 
    -0.07794835f, -0.13524924f, 0.11262837f, -0.08701858f, 0.08778854f, -0.06762053f, 0.07413241f, -0.06494553f, 
    -0.05464091f, -0.13115491f, -0.03721306f, -0.05679854f, 0.56676567f, -0.03185934f, 0.01193715f, -0.18858850f, 
    0.03486824f, -0.13528204f, -0.05068307f, -0.16048987f, -0.18853521f, 0.12429507f, -0.16059269f, -0.27064809f, 
    -0.57640582f, -0.51959360f, 0.12160420f, 0.27007538f, 0.00956522f, 0.10299823f, -0.16367829f, 0.01388860f, 
    0.00934057f, 0.02698367f, -0.02071461f, -0.02848205f, -0.50034732f, 0.29522216f, 0.38575497f, 0.20944506f, 
    0.17493813f, -0.32986754f, 0.05034974f, 0.09266172f, 0.09063748f, 0.05347323f, 0.03638015f, -0.03226719f, 
    0.44989389f, -0.62205267f, -0.49836811f, -0.15101527f, -0.04932927f, -0.02459626f, -0.02874529f, 0.07725296f, 
    0.33770561f, -0.04824286f, -0.00437687f, -0.00602493f, -0.07797218f, 0.05894209f, 0.10677923f, 0.01483130f, 
    0.08110065f, 0.09119974f, -0.00163602f, 0.25248030f, 0.14497399f, -0.05256838f, -0.02277654f, 0.03908975f, 
    0.50368387f, 0.09932135f, -0.06620701f, -0.17552449f, 0.12763242f, 0.09901468f, -0.24323879f, -0.04867700f, 
    -0.04311070f, -0.04230728f, -0.15411074f, 0.00885963f, -0.14556666f, -0.31421787f, -0.46460727f, -0.38225010f, 
    0.21287230f, -0.09887293f, -0.18737540f, 0.12204312f, 0.00700379f, -0.03719933f, -0.06440876f, -0.02152957f, 
    0.02863273f, -0.05422770f, 0.12962069f, 0.49396175f, -0.03992060f, -0.03536885f, -0.00051768f, 0.06460391f, 
    0.11577424f, -0.12584250f, 0.14989050f, -0.19579795f, -0.36579353f, -0.59886235f, -0.12191345f, -0.25679570f, 
    0.04925013f, -0.04803830f, 0.24911024f, 0.20628878f, -0.00194538f, -0.01558170f, 0.03202461f, 0.07609006f, 
    -0.13201728f, 0.10216768f, 0.00606151f, 0.01255192f, -0.01631974f, 0.00159444f, 0.06497633f, 0.03159241f, 
    -0.05279894f, 0.01841889f, 0.09950914f, 0.08264766f, -0.20063274f, -0.00007630f, 0.11477386f, -0.01515691f, 
    0.03595153f, -0.05814962f, 0.09181248f, -0.10012557f, -0.22727995f, 0.10688002f, 0.02085483f, -0.27707529f, 
    0.08256245f, 0.00487606f, -0.00949032f, -0.04479192f, -0.07072780f, -0.18199503f, 0.03634043f, -0.05471679f, 
    0.02481319f, -0.00778625f, -0.05237901f, -0.03666935f, -0.19437526f, -0.25439972f, 0.05612888f, 0.11198119f, 
    -0.06840175f, 0.14754389f, 0.20841703f, -0.19838209f, -0.15378533f, 0.21493661f, 0.15860344f, -0.00484510f, 
    -0.47413686f, -0.60360414f, -0.14674242f, -0.09457421f, 0.00473320f, 0.18558425f, -0.07715857f, 0.16207123f, 
    0.09003881f, 0.00932609f, -0.09047058f, 0.04720283f, 0.42623720f, -0.29882222f, -0.30170029f, -0.20131040f, 
    -0.07196625f, -0.02012634f, 0.04714617f, -0.05869244f, 0.11024733f, -0.00890688f, 0.03522598f, 0.12814812f, 
    0.84641761f, -0.71452624f, 0.05434900f, -0.31120357f, -0.00663404f, 0.02949222f, 0.01771579f, -0.07333533f, 
    -0.17245096f, 0.05792276f, 0.15742774f, 0.01029583f, -0.36208227f, -0.35816613f, 0.21730900f, -0.39703903f, 
    -0.15739802f, 0.22141035f, 0.08273985f, 0.29278296f, 0.00885210f, -0.15396906f, -0.04022481f, 0.00673322f, 
    0.18015149f, -0.43610799f, 0.15805092f, -0.29476625f, -0.02515538f, 0.12495663f, -0.05298886f, -0.08976209f, 
    -0.02436935f, 0.03881424f, -0.18953331f, -0.07266371f, -0.02457852f, -0.00890981f, -0.01938306f, 0.02647303f, 
    0.06665735f, -0.01412833f, -0.04688864f, -0.00941411f, 0.04069966f, -0.00638202f, -0.04763597f, -0.15265600f, 
    -0.20357251f, 0.36693943f, -0.09381281f, 0.21229638f, -0.26036915f, 0.24284752f, 0.11700986f, -0.02387522f, 
    0.04980106f, -0.05378181f, 0.03001957f, -0.05393171f, 0.06238221f, -0.02631818f, 0.04602834f, -0.11964595f, 
    0.12535198f, 0.06982519f, -0.03156222f, -0.09425545f, 0.03134959f, 0.04887225f, -0.23344310f, -0.15928742f, 
    -0.18450043f, -0.10129008f, 0.18583059f, -0.02445686f, 0.02102735f, -0.11223998f, 0.04681572f, -0.04789661f, 
    0.04216386f, -0.11964370f, 0.11381698f, -0.06160598f, -0.48772287f, -0.74407637f, 0.47550943f, -0.38644844f, 
    0.05864560f, -0.04171509f, 0.15241045f, 0.12292423f, 0.09618299f, -0.00974331f, -0.05532386f, -0.06104947f, 
    0.64948881f, 0.27364880f, -0.04223900f, 0.32217589f, 0.32647964f, 0.05975597f, -0.16103774f, 0.14447607f, 
    0.05936307f, -0.00751172f, 0.13365802f, 0.16816670f, -0.08592673f, -0.01635598f, -0.04214117f, -0.08948177f, 
    -0.02645053f, -0.07229679f, -0.04105154f, 0.02996469f, 0.02857581f, 0.01658245f, 0.06979521f, -0.05504115f, 
    0.17007141f, -0.30977470f, -0.24376117f, -0.05549001f, 0.00728656f, -0.14367205f, 0.07692885f, -0.04781542f, 
    0.04728910f, -0.12096217f, 0.00865331f, 0.14950033f, -0.42908290f, -1.22385597f, -0.70161623f, -0.01772626f, 
    0.07858247f, 0.26593670f, 0.30605093f, 0.04401272f, -0.12928659f, -0.00621237f, -0.13404858f, 0.04503532f, 
    -0.06776946f, -0.23485570f, -0.40841275f, 0.19205114f, -0.03646225f, -0.04110942f, 0.01764287f, 0.10893127f, 
    -0.05768900f, -0.05901610f, 0.00879230f, 0.07648001f, -0.09429222f, -0.47257355f, -0.10022188f, 0.04974090f, 
    -0.16964070f, 0.05517290f, 0.14304608f, -0.14053628f, 0.05292376f, 0.13096954f, 0.24856013f, -0.03264795f, 
    -0.10014144f, -0.66124636f, -0.41468945f, -0.23695226f, -0.00803445f, -0.24437930f, 0.07018878f, 0.02807298f, 
    -0.00308573f, 0.13706347f, 0.07395129f, 0.13643412f, 0.13036750f, 0.02736157f, -0.09975284f, -0.11577995f, 
    0.01131002f, -0.15426306f, 0.08880942f, -0.10717676f, -0.04032955f, -0.01084763f, 0.13607149f, -0.08199606f, 
    -0.39673635f, -0.13291165f, 0.26555064f, 0.03308199f, -0.00350149f, 0.03380490f, 0.08945556f, -0.06399079f, 
    0.03489289f, 0.05458362f, 0.01353774f, 0.23822068f, 0.27634400f, -0.10121161f, 0.03381994f, -0.46030667f, 
    -0.14458010f, 0.04773175f, -0.05099845f, -0.01564511f, -0.00283849f, 0.16261667f, 0.00163694f, -0.04448780f, 
    0.23254596f, -0.03288585f, 0.01856632f, -0.16250753f, -0.03881704f, -0.08176823f, 0.18154067f, -0.19632630f, 
    -0.02202044f, -0.00121630f, 0.02145063f, -0.04503677f, -0.25074056f, -0.39645070f, -0.23987338f, 0.22223389f, 
    -0.04056006f, -0.00810143f, 0.10312025f, -0.12613435f, 0.05723092f, 0.01776910f, 0.15246893f, 0.11921319f, 
    -0.07915724f, -0.28838477f, 0.09753182f, 0.10374124f, 0.00312944f, 0.07588329f, 0.03679997f, 0.00661955f, 
    -0.33715647f, -0.15121855f, -0.11504143f, -0.48409665f, -0.27418357f, -0.12194145f, -0.15710339f, 0.00056554f, 
    0.06760575f, -0.14084503f, -0.03690721f, 0.03114045f, -0.03675008f, -0.12506869f, -0.18527812f, -0.13191399f, 
    0.16852520f, -0.11300813f, -0.47522676f, -0.35635236f, -0.15364152f, -0.10740680f, 0.03556216f, 0.03187591f, 
    0.16018717f, -0.19881377f, 0.07012958f, -0.03966748f, 0.35426086f, -0.10450831f, -0.60611606f, -0.28432110f, 
    0.03622907f, 0.10392450f, 0.08252899f, -0.07708758f, 0.00968852f, -0.04758162f, -0.03125378f, -0.05798426f, 
    0.26042813f, 0.03817597f, -0.25398383f, -0.48007193f, 0.08092976f, -0.05176118f, 0.16980016f, 0.20004408f, 
    -0.09330022f, 0.20212945f, -0.18279424f, -0.28425014f, 0.16205853f, -0.78978020f, -0.53601587f, 0.14004353f, 
    0.02199792f, 0.06102017f, 0.16987514f, -0.08292595f, -0.05837265f, -0.17356063f, 0.02269417f, -0.00175971f, 
    -0.27412006f, -0.04145649f, 0.10364813f, 0.07410062f, 0.02173731f, 0.08291105f, -0.07146866f, 0.11714397f, 
    -0.15123828f, 0.01633647f, 0.09735087f, 0.02828909f, -0.46016720f, -0.13380404f, 0.11105806f, -0.06416189f, 
    -0.10918291f, 0.06165155f, 0.06923740f, -0.09740538f, 0.18147171f, 0.06579169f, 0.05612474f, 0.26688841f, 
    -0.06518112f, -0.00231342f, -0.00800156f, -0.07824942f, 0.12303367f, 0.03354403f, -0.02230273f, -0.02905376f, 
    0.14595518f, 0.17686391f, 0.14232466f, 0.16877855f, 0.16876364f, -0.25939861f, 0.30573672f, 0.24500364f, 
    0.03835696f, -0.03391037f, 0.05712347f, 0.00889943f, 0.18802243f, -0.08437338f, 0.08200651f, -0.14913973f, 
    0.05311675f, -0.20117612f, -0.21229433f, 0.35615656f, -0.03056769f, 0.22411893f, -0.09189542f, 0.17969175f, 
    -0.03646595f, -0.12345990f, -0.11690428f, -0.26717520f, -0.34774429f, -0.35599944f, -0.19012378f, 0.07333156f, 
    -0.17921086f, 0.11635656f, 0.03069532f, 0.15365089f, 0.11585531f, 0.19688725f, 0.00218373f, 0.04610812f, 
    0.18063618f, -0.27632773f, -0.76081461f, -0.28791746f, 0.21344110f, -0.04062471f, 0.14946452f, 0.04130314f, 
    0.21401322f, 0.04014770f, 0.08668258f, 0.27114162f, 0.20515420f, -0.50511664f, -0.22888115f, -0.07728045f, 
    -0.08106252f, -0.11321148f, 0.09719065f, -0.27451587f, -0.04657963f, -0.02464379f, 0.09430503f, -0.04342270f, 
    0.14636935f, -0.13434973f, -0.20479241f, 0.11586730f, 0.20798965f, 0.07735979f, 0.23071855f, 0.06336302f, 
    0.06502587f, -0.13150495f, -0.18917713f, -0.31439978f, -0.42134351f, 0.15450746f, 0.08250300f, -0.05012852f, 
    -0.07638963f, -0.06384073f, -0.05477245f, -0.07126363f, -0.05238720f, 0.00478050f, -0.05471775f, 0.14441870f, 
    -0.17542414f, -0.02502204f, -0.00222537f, 0.13884580f, 0.25461265f, -0.13688752f, -0.08712924f, 0.07910561f, 
    0.11682099f, 0.21823622f, 0.12555480f, 0.19362226f, 0.19969164f, 0.11402937f, -0.15090413f, -0.19396374f, 
    -0.06295229f, -0.13493989f, -0.06911733f, -0.12547663f, 0.22230062f, 0.02616373f, 0.03427605f, 0.04280727f, 
    -0.36012208f, -0.14120364f, 0.11349246f, 0.10252640f, 0.01633855f, 0.08156283f, 0.10966536f, 0.10545232f, 
    -0.09852096f, 0.07957090f, -0.03655350f, 0.03687509f, 0.83488303f, 0.17125191f, -0.06218756f, -0.22982943f, 
    -0.07862077f, 0.07512636f, -0.08375346f, -0.64032274f, -0.02767189f, 0.00067418f, -0.05409709f, 0.03111893f, 
    -0.73570335f, -0.18555188f, -0.82635254f, 0.20870224f, 0.05300054f, -0.09680580f, 0.14071693f, -0.03552519f, 
    0.07958230f, 0.03770871f, 0.00194775f, -0.10773682f, -0.14752728f, -0.26142988f, -0.21952179f, 0.10538290f, 
    0.05460678f, 0.28279060f, 0.26955336f, 0.12448650f, 0.11452062f, 0.10368307f, -0.06034314f, 0.01793707f, 
    -0.67538267f, -0.11003702f, -0.12581533f, 0.17724951f, -0.12661287f, -0.10356376f, 0.00132923f, 0.34389165f, 
    0.01188914f, -0.02377036f, 0.03153481f, 0.02562424f, 0.12197240f, 0.01181904f, -0.55286312f, -0.25309584f, 
    -0.36190721f, -0.06682507f, -0.10934654f, -0.11384649f, 0.10441710f, -0.13335834f, 0.03674847f, 0.07823288f, 
    -0.22070391f, 0.23789881f, -0.20239352f, -0.04702711f, 0.06129574f, -0.22723225f, 0.15582423f, -0.00222065f, 
    0.05777755f, -0.21465856f, -0.10960659f, -0.07174756f, 0.33917463f, 0.02657147f, 0.27911425f, -0.53606671f, 
    0.06317306f, -0.14581664f, -0.17459159f, -0.11462283f, -0.15372272f, 0.26673377f, 0.01699456f, -0.07405449f, 
    -0.19050895f, -0.11560465f, -0.00921407f, -0.23351504f, -0.08136107f, -0.11241277f, 0.07926159f, 0.18565029f, 
    0.03878672f, 0.12862511f, 0.01440154f, -0.00426555f, -0.19550601f, -0.37548324f, 0.21571676f, 0.22953214f, 
    0.02029078f, 0.31710508f, -0.32126570f, -0.18407360f, -0.08739728f, -0.00791275f, -0.00864545f, -0.10155241f, 
    0.13674222f, -0.32401693f, 0.35612470f, -0.32068384f, 0.02915025f, -0.19299473f, -0.11569279f, -0.06697702f, 
    -0.00647189f, 0.14387435f, -0.06197791f, -0.09331357f, -0.43945733f, 0.27432612f, 0.28613439f, 0.60348207f, 
    0.06276987f, -0.02951901f, 0.00447260f, -0.36959517f, -0.01895656f, -0.09908175f, 0.13032161f, -0.17100878f, 
    0.72332525f, -0.30566293f, -0.08551792f, -0.43025589f, 0.07535345f, 0.11887575f, 0.04804808f, 0.07653786f, 
    -0.07488289f, -0.01215542f, -0.04910880f, -0.12512818f, -0.05877164f, 0.02835321f, -0.30837882f, -0.68501782f, 
    0.03820810f, -0.30143094f, 0.08126581f, 0.18499963f, -0.02446530f, -0.14901856f, -0.05772885f, -0.03414023f, 
    -0.19447003f, 0.14891610f, 0.35603753f, 0.04501643f, 0.02891321f, -0.07349835f, -0.15962136f, -0.07011093f, 
    -0.12444478f, 0.11374587f, 0.02678642f, 0.08054184f, 0.11115490f, 0.00976580f, -0.04230931f, -0.08284607f, 
    -0.02123320f, -0.02909393f, 0.14513437f, 0.31119731f, -0.12863569f, 0.20836209f, 0.20579013f, -0.02805121f, 
    -0.23720385f, -0.05720235f, 0.20657741f, 0.67610091f, -0.06510857f, -0.15375078f, -0.40403524f, 0.13877864f, 
    0.15063734f, -0.06257103f, 0.05513445f, 0.12115132f, -0.31402284f, -0.02046910f, 0.46910426f, 0.01295983f, 
    -0.19710469f, -0.03400126f, -0.11502337f, 0.22292589f, 0.12237375f, -0.04083304f, 0.03179182f, 0.05224756f, 
    0.09557725f, -0.11320734f, -0.11200369f, 0.40951356f, -0.08390539f, 0.03036602f, 0.05928361f, -0.01945004f, 
    0.08785407f, 0.21447134f, 0.07053790f, 0.02456985f, -0.28022501f, 0.05249437f, 0.50743127f, -0.42841688f, 
    -0.02423345f, -0.36969769f, 0.12693621f, -0.00119375f, -0.07797823f, 0.06378654f, 0.13505477f, 0.04953261f, 
    0.08508448f, 0.54182845f, -0.29916802f, -0.29834256f, 0.01820688f, 0.14441690f, 0.12753205f, -0.08849347f, 
    0.02546534f, -0.06146529f, -0.15243198f, -0.01720112f, 0.10035446f, -0.13413128f, 0.40025097f, -0.15177134f, 
    0.16685976f, -0.04195122f, -0.07562464f, -0.01159132f, 0.04833227f, 0.18713935f, 0.07604400f, -0.12324659f, 
    -0.10471148f, -0.05253747f, 0.06518587f, -0.06600576f, 0.19627044f, -0.01066874f, 0.12240469f, -0.02777776f, 
    -0.02771777f, -0.12037534f, -0.08519834f, -0.19101380f, 0.00056856f, -0.34400219f, 0.46179590f, -0.47239587f, 
    0.09866346f, -0.18447924f, -0.01737389f, 0.04763222f, -0.02840673f, -0.05264917f, 0.04524103f, 0.05766633f, 
    -0.03148026f, -0.36707962f, -0.03070501f, -0.14787953f, 0.01387884f, -0.03133366f, -0.04030952f, -0.02743894f, 
    0.20064750f, 0.03335274f, 0.11574119f, 0.10366461f, 0.42664871f, 0.18686819f, 0.29788673f, 0.00837551f, 
    0.04959766f, -0.06118797f, -0.15154739f, -0.20605114f, -0.00181292f, 0.05023513f, -0.08665340f, 0.10527655f, 
    0.10637470f, 0.06737120f, 0.39984414f, 0.24523516f, 0.18324284f, -0.22642696f, -0.19214356f, -0.04547432f, 
    0.06483278f, 0.10985075f, -0.12814674f, 0.05967343f, 0.04402550f, 0.21873687f, 0.12515704f, -0.36131892f, 
    -0.26159522f, 0.08092801f, 0.13560371f, 0.15127876f, 0.10236276f, 0.13384143f, 0.04613842f, -0.04020197f, 
    0.14966097f, -0.27981988f, 0.27968320f, 0.02195791f, -0.24842975f, -0.05178140f, -0.33357409f, -0.14149202f, 
    0.18402272f, -0.07090031f, 0.11123358f, 0.16690326f, -0.11658034f, -0.06732313f, 0.01311382f, 0.42926714f, 
    0.11983161f, 0.06731343f, 0.01513644f, -0.01869431f, 0.14966510f, -0.06209059f, -0.14104161f, -0.17839566f, 
    -0.12614013f, -0.10771164f, -0.49552661f, -0.17825434f, -0.33453569f, -0.21656877f, 0.16508870f, -0.02715461f, 
    0.06727341f, -0.05677495f, -0.16593395f, -0.13336240f, 0.01695165f, 0.29814160f, -0.04818533f, 0.28341877f, 
    0.15430357f, 0.00546932f, 0.01079109f, -0.16726276f, 0.12203103f, 0.08395905f, 0.03528972f, 0.09455949f, 
    0.00279513f, -0.24435760f, 0.23585257f, -0.56309021f, -0.02090358f, -0.16212423f, -0.03116095f, -0.07199354f, 
    0.04114055f, 0.08830447f, -0.15097636f, -0.08603343f, -0.01644692f, -1.45115280f, 0.05057336f, -0.36314857f, 
    0.01836340f, 0.06033698f, -0.02286952f, -0.10985056f, 0.03425400f, -0.02732173f, 0.05033841f, 0.00830148f, 
    0.09372430f, 0.05800020f, 0.09393153f, -0.21354383f, -0.08185088f, 0.33958653f, 0.17653713f, 0.22946872f, 
    -0.01508355f, -0.11316229f, 0.15206410f, 0.06364953f, -0.11214817f, -0.48446116f, -0.06149159f, -0.33556318f, 
    -0.22678719f, -0.13709004f, -0.05609347f, -0.09969429f, 0.00626200f, 0.02156141f, -0.04029378f, 0.00166331f, 
    -0.40935656f, 0.20871852f, -0.44322956f, 0.28290781f, -0.17368947f, 0.09992894f, -0.35300809f, 0.23880441f, 
    0.01444132f, 0.18343388f, 0.03532014f, 0.06930084f, 0.11646841f, 0.29679304f, 0.12001506f, 0.13353561f, 
    0.33094335f, -0.17753038f, -0.12794845f, 0.16787039f, -0.22679885f, 0.25364214f, 0.07308766f, 0.00540811f, 
    0.15205392f, 0.35634539f, 0.33179966f, 0.10590572f, -0.14471981f, -0.01767066f, 0.02680108f, 0.08028791f, 
    -0.21846883f, 0.18439993f, 0.17164083f, -0.00103016f, 0.10260893f, 0.07428823f, 0.35922128f, 0.05252682f, 
    -0.23854943f, 0.05733187f, 0.01549974f, -0.03033717f, 0.13605879f, -0.22419551f, 0.08519078f, -0.14003560f, 
    -0.31081977f, -0.10996726f, -0.53460544f, 0.15028031f, -0.01608889f, -0.01366249f, 0.02056572f, 0.02610749f, 
    0.07604724f, 0.15657240f, 0.07540634f, 0.22186093f, -0.50428694f, 0.13190769f, -0.16560726f, -0.16729832f, 
    -0.02664724f, 0.20965426f, -0.22008885f, 0.09373394f, -0.22446148f, 0.05723216f, 0.04305111f, -0.02627054f, 
    -0.10898276f, 0.29723731f, -0.03506337f, 0.15172754f, -0.12249201f, -0.05251558f, 0.02805861f, 0.04058323f, 
    -0.08014171f, 0.14233035f, 0.04663354f, 0.00535880f, 0.33913961f, -0.20122230f, 0.26365921f, -0.03503554f, 
    -0.25293919f, 0.08124561f, 0.08327273f, 0.07780191f, 0.02477344f, 0.09715048f, -0.12710564f, -0.02637329f, 
    -0.47175986f, 0.07479084f, -0.29753780f, -0.05737968f, -0.16056249f, 0.02886179f, -0.01014498f, -0.25066188f, 
    0.12286338f, 0.08413469f, 0.07414994f, -0.06832272f, 0.03280210f, -0.06239255f, 0.28231886f, 0.46224365f, 
    -0.14604218f, 0.04110612f, 0.02294410f, 0.15537094f, 0.01607670f, -0.39317226f, 0.25189108f, 0.30470037f, 
    0.37439758f, -0.35093632f, 0.28241447f, -0.34119812f, 0.05534967f, -0.14071479f, -0.11781447f, 0.00089304f, 
    -0.29712898f, -0.19589818f, -0.25672123f, -0.38775206f, -0.08353627f, -0.14951347f, -0.07739057f, 0.19647677f, 
    -0.04478191f, -0.06501111f, -0.21827383f, -0.09667108f, -0.26848274f, -0.23260570f, -0.26576596f, -0.26551974f, 
    -0.54019684f, 0.45740440f, -0.32493693f, -0.27870426f, -0.04625010f, 0.21147966f, -0.16431168f, -0.02933475f, 
    -0.23221289f, 0.11982736f, -0.23635800f, -0.29773879f, -0.09259789f, -0.60690123f, -0.08898212f, 0.10957520f, 
    -0.09177424f, 0.16712987f, -0.05770521f, 0.37558302f, 0.02449904f, 0.01388422f, 0.17171589f, -0.02321350f, 
    -0.06131668f, 0.23806795f, -0.06642862f, 0.06268156f, 0.01191610f, -0.11705441f, 0.19769594f, 0.01203910f, 
    -0.06161575f, 0.02763360f, -0.23547511f, -0.14686564f, -0.34273356f, 0.19281961f, -0.02681918f, -0.14696622f, 
    0.12276185f, -0.34158304f, -0.10520825f, -0.07419322f, 0.06169960f, 0.23407796f, -0.16230550f, -0.30681846f, 
    -0.12013298f, -0.33813763f, 0.16962256f, 0.10913872f, -0.04663203f, -0.32856762f, 0.19940197f, 0.02147564f, 
    -0.14555098f, 0.12666519f, 0.12252324f, 0.04951379f, -0.19280703f, 0.06395977f, 0.10020198f, 0.21915066f, 
    -0.08713348f, -0.00092990f, -0.16217923f, 0.10974126f, -0.02546196f, -0.15100946f, 0.02114232f, -0.01575704f, 
    -0.10480195f, -0.06496450f, 0.05287710f, -0.08758142f, -0.12890221f, 0.11924928f, 0.13523982f, 0.11723670f, 
    0.01560498f, 0.15108041f, 0.38177890f, 0.30653116f, -0.11022054f, 0.36527082f, -0.22193849f, 0.32615265f, 
    -0.09313641f, 0.10474195f, -0.26048210f, 0.35771042f, -0.03212560f, -0.10831719f, -0.17367060f, -0.36964771f, 
    0.18612324f, -0.35894540f, 0.23658930f, 0.05063686f, 0.19397123f, -0.05901549f, -0.05303208f, -0.00786807f, 
    -0.13238256f, -0.19024871f, -0.10612188f, -0.46548283f, 0.05873790f, -0.19642277f, 0.08066089f, 0.13071597f, 
    0.03510915f, -0.24566123f, -0.00555848f, 0.05808242f, 0.00821331f, 0.12836401f, -0.08047780f, 0.05667180f, 
    -0.40389210f, 0.17976290f, -0.27467093f, -0.32187703f, -0.04032829f, -0.05298315f, 0.04557997f, -0.13950814f, 
    0.09266254f, -0.07631369f, 0.10535869f, 0.19423775f, 0.10987677f, -0.47410896f, -0.10990136f, -0.16116865f, 
    -0.02761078f, 0.01055907f, -0.19392632f, -0.12230119f, 0.08328480f, 0.08685802f, -0.18883067f, -0.19382493f, 
    -0.53333461f, 0.33545750f, -0.19589651f, 0.08174562f, 0.24328555f, 0.01099731f, -0.00916375f, 0.14826800f, 
    -0.16781224f, -0.02439142f, -0.01720436f, -0.27943966f, -0.42745972f, 0.03509678f, -0.32204020f, -0.17217046f, 
    -0.33310121f, -0.11583169f, -0.09724715f, -0.04398394f, -0.02180395f, -0.12642173f, 0.22432108f, 0.09398734f, 
    0.24542890f, 0.01235607f, 0.32423982f, -0.11760020f, 0.00051945f, 0.20688581f, 0.25591817f, 0.01528868f, 
    0.15837769f, 0.06713583f, 0.11074875f, 0.27454856f, -0.47115698f, 0.26434305f, 0.16153827f, -0.20598170f, 
    -0.22742170f, -0.04332275f, -0.07320972f, -0.07642703f, -0.03691572f, -0.16942053f, -0.15484326f, -0.07141566f, 
    -0.14751619f, 0.17937146f, 0.57622850f, -0.00216774f, 0.01614022f, 0.09622270f, 0.04699337f, -0.00701736f, 
    -0.08077571f, 0.03289427f, 0.33590522f, 0.15114161f, -0.81685978f, 0.17779940f, 0.03506964f, 0.22452492f, 
    -0.28736168f, 0.29510382f, -0.16202432f, 0.11935452f, 0.03857236f, -0.10772767f, 0.21431364f, 0.09730835f, 
    0.32017025f, -0.59694928f, 0.22150774f, 0.05100204f, 0.23490845f, -0.05389529f, -0.01166577f, -0.03996700f, 
    -0.08427702f, 0.25112724f, 0.13382882f, -0.00829765f, 0.20888774f, 0.05708150f, -0.01498834f, -0.08470566f, 
    0.06649619f, -0.09458999f, -0.00969779f, -0.04496350f, -0.06964174f, 0.04818962f, -0.03515318f, -0.16602121f, 
    -0.11039780f, -0.01457911f, 0.28790867f, -0.11875286f, -0.05531250f, 0.12766266f, -0.45302367f, 0.22668889f, 
    -0.08825243f, -0.09493019f, -0.04698506f, -0.04398158f, -0.66384780f, 0.55149841f, -0.22958887f, 0.05452224f, 
    -0.15845525f, -0.32193106f, 0.08415008f, -0.03923470f, 0.02892108f, 0.09352333f, -0.14702827f, -0.16592866f, 
    0.26419839f, -0.31426069f, 0.44692731f, -0.14202049f, -0.02047563f, -0.01032323f, 0.07034606f, -0.00706345f, 
    -0.01661793f, 0.01553975f, -0.11339935f, -0.28083372f, -0.77511197f, -0.16561213f, -0.88982469f, 0.53573132f, 
    0.12079097f, -0.10751788f, -0.09773126f, 0.07967550f, 0.07067442f, 0.07854538f, -0.03317690f, 0.11848381f, 
    -0.32500091f, -0.18700744f, -0.07356198f, -0.10364740f, -0.43424082f, -0.23300186f, -0.30606511f, -0.27881715f, 
    0.03496813f, -0.00553568f, 0.05392602f, -0.07850970f, -0.15170734f, 0.12489302f, -0.15895781f, 0.01320561f, 
    -0.14623642f, -0.22010063f, 0.28823027f, 0.06453562f, 0.08823615f, -0.17576472f, 0.04660622f, -0.15120992f, 
    -0.38840011f, -0.01154401f, -0.16775106f, 0.36832392f, -0.04894409f, 0.04296480f, 0.10343400f, 0.12848824f, 
    -0.16094968f, -0.25522673f, 0.21643378f, -0.09895689f, -0.33872789f, -0.08424058f, -0.31901824f, 0.00394796f, 
    0.08806872f, 0.37211406f, 0.01435279f, 0.16523257f, -0.02056446f, 0.10470559f, 0.16237915f, 0.17101784f, 
    0.32178512f, 0.15827911f, 0.15353887f, -0.06078924f, 0.01733427f, 0.08547657f, -0.07563859f, -0.02205322f, 
    0.06863671f, 0.12905809f, 0.02018848f, 0.00238855f, 0.40939909f, 0.09959529f, 0.95446634f, -0.07151313f, 
    -0.13809122f, 0.31345540f, -0.12357680f, 0.26040557f, -0.15344249f, 0.08155321f, -0.06780099f, -0.04225373f, 
    -0.30350563f, -0.17209581f, -0.19219027f, -0.56833720f, -0.06103727f, -0.04036989f, -0.09939017f, -0.03129121f, 
    -0.01585741f, 0.04655715f, 0.11087638f, 0.03943655f, -0.30729699f, -0.05721244f, 0.25710866f, 0.27187118f, 
    -0.09043720f, 0.04961725f, 0.05451320f, -0.07324603f, -0.00705129f, 0.11607154f, 0.03804459f, 0.18815157f, 
    -0.43416622f, -0.24932425f, -0.46589708f, -0.05328505f, 0.26129255f, 0.20911483f, 0.07955240f, -0.09763447f, 
    0.09135786f, 0.07380807f, 0.23954028f, 0.12252461f, 0.01881403f, -0.08935159f, -0.31212065f, -0.18577288f, 
    -0.16188432f, -0.03624716f, 0.12034807f, -0.12130259f, 0.00784485f, 0.01695949f, -0.20300113f, -0.13228685f, 
    -0.33316946f, -0.47864401f, -0.20868118f, 0.16764268f, 0.01686853f, 0.13144025f, -0.03737300f, -0.04215888f, 
    0.06983092f, 0.15162826f, 0.05034140f, 0.24720407f, 0.19353803f, -0.55273104f, 0.09617776f, -0.71761608f, 
    0.11338390f, -0.23835012f, -0.01832171f, 0.10096701f, 0.06785938f, 0.19549443f, 0.08148360f, -0.01536338f, 
    0.22261274f, 0.19657621f, 0.25808060f, 0.16012134f, 0.05787712f, 0.09742889f, -0.14220974f, -0.07398216f, 
    -0.10410407f, 0.00957244f, -0.08052032f, -0.10207024f, -0.47130117f, 0.03378079f, -0.08512335f, 0.16053489f, 
    -0.05561071f, 0.17293052f, 0.01910047f, 0.17708148f, -0.31796652f, 0.15894204f, 0.26764134f, -0.00156229f, 
    0.15918991f, -0.07290632f, -0.00709930f, -0.07745808f, -0.01089152f, 0.19853939f, -0.34523058f, 0.04520946f, 
    -0.03988577f, -0.14241594f, -0.15828434f, -0.28887755f, 0.05608131f, -0.22526452f, 0.31855810f, 0.07332657f, 
    0.04155513f, 0.18594015f, 0.07700174f, 0.36304253f, -0.24348271f, 0.21279749f, 0.07807452f, 0.07453302f, 
    -0.09162449f, 0.53041053f, -0.32277611f, 0.03440948f, -0.08418895f, -0.15721405f, 0.32604918f, -0.09574381f, 
    -0.09618606f, 0.15343159f, 0.10005315f, 0.09588452f, -0.62332970f, 0.20129536f, -0.00472111f, -0.16387504f, 
    -0.00392962f, -0.12376732f, -0.05521116f, 0.15899415f, -0.35242584f, -0.05979394f, -0.06190807f, -0.18043774f, 
    -0.20888071f, -0.36765525f, -0.24353658f, 0.23728281f, 0.15741166f, -0.17852777f, -0.09557696f, 0.15434447f, 
    -0.14468205f, 0.03817563f, 0.11776994f, -0.33442110f, -0.18929306f, -0.18163300f, 0.23724453f, -0.07042810f, 
    0.01696989f, -0.05612962f, 0.16318013f, 0.05197883f, 0.02687174f, 0.07379124f, 0.11589553f, 0.02698800f, 
    0.14174306f, 0.18764773f, -0.28064671f, -0.04006297f, -0.03984910f, -0.22267649f, 0.21835208f, -0.02593384f, 
    0.19836859f, 0.09712729f, 0.19098312f, 0.11933983f, 0.43280029f, 0.16053744f, 0.26205772f, -0.05676440f, 
    -0.14499085f, 0.06238023f, 0.00862370f, 0.13796212f, -0.13370888f, 0.07180500f, -0.02175354f, -0.20042418f, 
    0.17883919f, -0.21805330f, 0.18539639f, -0.24342833f, 0.11519339f, 0.13946028f, -0.19263078f, 0.05449923f, 
    -0.14231665f, -0.11441709f, -0.06852265f, -0.22037379f, -0.05485877f, -0.28650931f, -0.08376587f, 0.14095175f, 
    -0.00872348f, -0.06197204f, -0.06577114f, 0.05717907f, 0.00640435f, 0.01551672f, 0.08906091f, -0.05514657f, 
    0.08156855f, 0.10999656f, -0.21143083f, 0.52292609f, -0.02683626f, 0.32129902f, -0.13968641f, -0.08007436f, 
    -0.27991000f, 0.04830733f, 0.11624250f, 0.09989525f, -0.16195650f, 0.59334880f, -0.38310573f, -0.01590059f, 
    -0.08931662f, -0.26338059f, 0.09217796f, 0.11084250f, 0.06793854f, -0.00442206f, -0.01983300f, 0.01488103f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16488643f, 0.05729289f, 0.10433830f, -0.15878229f, -0.05900061f, 0.16565101f, 0.04506222f, -0.10708616f, 
    0.12540573f, 0.04757010f, 0.03946762f, -0.02105267f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
