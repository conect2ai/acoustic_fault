#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.08002627f, -0.46594399f, -0.37322924f, 0.56542456f, 0.26394492f, 0.48967490f, -0.35907820f, 0.51838553f, 
    -0.38675007f, 0.10580065f, -0.45758438f, -0.00462644f, 0.39053631f, 0.45328650f, 0.41369364f, -0.03682821f, 
    -0.50848484f, 0.52792418f, 0.86870885f, -1.17004287f, 0.55516511f, -0.19484717f, -0.06638021f, -0.13926095f, 
    -0.03694309f, 0.05273198f, 0.12847549f, 0.60056192f, 0.70403397f, 0.18673770f, -0.21825314f, -0.37309659f, 
    -0.17112215f, 0.15004955f, -0.10091670f, 0.11556485f, -0.10821246f, 1.22284722f, -0.87574434f, -0.01330529f, 
    0.08966932f, -0.08342501f, -0.12329869f, 0.28058487f, 0.11508873f, -0.40944082f, 0.82814455f, -0.22052944f, 
    -0.18545106f, 0.11492866f, -0.49778771f, 0.49957064f, -0.12605567f, 0.36656168f, 0.67664289f, 0.40063107f, 
    0.54661775f, 0.11014838f, 0.33807018f, 0.33661345f, 0.21045035f, 0.48070469f, -0.13038947f, -0.91425812f, 
    -0.09121008f, -0.24334916f, 0.51053816f, 0.34084222f, 0.53671455f, 0.13954443f, 0.34145069f, 0.08823626f, 
    -0.64693028f, -0.39093384f, -0.35598332f, 0.48967195f, 0.48885334f, 0.67863595f, -0.12217145f, -0.40166858f, 
    -0.41050720f, -0.55555016f, 0.83969492f, -0.59903413f, -0.69082940f, -0.66335779f, 0.13722174f, 0.23932633f, 
    -0.08561202f, 0.28079382f, 0.64533657f, -1.32933533f, 0.42742866f, -0.43069524f, -0.46513507f, 0.08120718f, 
    -0.15757342f, -0.23805881f, -0.22200823f, -0.36438113f, -0.02830416f, -0.14171416f, -0.30581623f, -0.42225248f, 
    -0.63796192f, 0.03720112f, 0.52636850f, 0.62950552f, 0.19367753f, -0.27146772f, -0.48949215f, -0.17545956f, 
    -0.37983775f, -0.21102087f, -0.42318755f, -0.49507749f, -0.14254840f, 0.76942211f, -0.31436715f, -0.14625269f, 
    -0.19390437f, -0.32801113f, 0.18365657f, 0.13454904f, 0.17350312f, 0.55281001f, -0.71446615f, -0.70201093f, 
    0.26502708f, 0.49942875f, 0.01874791f, -0.19728045f, -0.47719127f, -0.09526256f, -0.58995527f, -0.31187728f, 
    0.54403311f, 0.58324289f, 0.22993162f, 0.16210358f, -0.40187380f, -0.66525888f, -0.21360467f, -0.21554817f, 
    -1.12924826f, 0.43474913f, 0.62880415f, -0.45302543f, -0.50661141f, 0.62860048f, -0.07968147f, 0.06642067f, 
    -0.25485417f, 0.24657094f, -0.10129555f, 0.10141668f, 1.04953456f, -0.43860936f, -0.52916884f, -0.49327812f, 
    0.16727479f, 0.36110094f, -0.00199996f, 0.73886710f, -0.26883057f, 0.11114395f, 0.39258814f, 0.09604799f, 
    0.05063252f, -0.46405539f, 0.01695310f, 0.02785593f, 0.09389192f, 0.13133657f, 0.01028990f, 0.21670365f, 
    0.60044360f, -0.30123258f, -0.13428062f, 0.49414432f, -0.62324774f, -0.12686554f, 0.39006910f, -0.00315471f, 
    -0.75501895f, -0.41940066f, 0.38136226f, 0.45967117f, -0.18726967f, -0.65933543f, 0.04653677f, 0.42700574f, 
    0.28539270f, 0.13921057f, 0.70025069f, -0.01908114f, 0.24097243f, -0.00541263f, 0.18709688f, -0.24797960f, 
    0.91680998f, -0.10287051f, -0.66962469f, -0.31016046f, 0.39700285f, -0.06864437f, 0.12572265f, -0.40665868f, 
    0.46966398f, -0.21619116f, -0.04033293f, 0.29299694f, -0.49191040f, -0.34663197f, -0.08513828f, -0.50306636f, 
    0.15753786f, 0.46307272f, -0.62377751f, -0.13926664f, -0.02006746f, 0.10124441f, 0.61931890f, -0.27999744f, 
    -0.31075856f, -0.90630430f, -0.27375162f, 0.53061455f, 0.21415932f, 0.21999443f, -0.51535344f, 0.48508397f, 
    0.57622409f, -0.13643214f, 0.56758302f, 0.14702082f, 0.75381213f, -0.00803531f, 0.18207552f, -0.05795943f, 
    0.62020856f, -0.44712281f, -0.40787223f, 0.42829517f, 0.24212261f, 0.03893906f, -0.01408485f, 0.24376230f, 
    -0.78902674f, -0.24121490f, -0.06830583f, 0.11056834f, 0.03410034f, 0.26600003f, 0.04729829f, -0.23258996f, 
    -0.17625715f, -0.58066422f, -0.17807865f, -0.51535845f, -0.52130240f, 0.05268512f, -0.14071913f, 0.17002679f, 
    -0.42345658f, -0.49224395f, -0.91302097f, -0.02484664f, -0.58750808f, 0.71992964f, -0.51067549f, -0.62670392f, 
    -0.34612674f, 1.04931951f, -0.25144330f, -0.58905798f, -0.16349302f, -0.36965388f, 0.03621861f, 0.70263153f, 
    -0.73097044f, -0.58568150f, 0.18397374f, 0.43872178f, 0.36489126f, 0.42870152f, -0.02246163f, 0.15106995f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03884440f, -0.00650752f, -0.00920989f, 0.34999564f, 0.28426421f, -0.19786425f, 0.06949038f, 0.16788131f, 
    0.01384589f, -0.02405875f, 0.14464080f, 0.45865360f, -0.13531472f, 0.48356575f, 0.28130201f, 0.28033367f, 
    0.07117565f, 0.37090224f, 0.03991579f, 0.14561622f, -0.04406466f, -0.26774544f, 0.01422403f, 0.07982295f, 
    0.47397923f, -0.28116429f, 0.14681497f, 0.26479226f, -0.37509456f, -0.03983317f, 0.21062040f, -0.21628447f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.21795638f, 0.24031839f, -0.20086847f, 0.06682248f, -0.09857179f, 0.27969384f, 0.05822082f, -0.01236582f, 
    0.15473974f, 0.00538189f, -0.04993439f, -0.37013087f, 0.11747088f, 0.17503838f, 0.09465059f, -0.11325654f, 
    0.02982532f, -0.03233164f, -0.01222609f, 0.11981981f, -0.20869328f, 0.15416193f, -0.01298997f, -0.19000083f, 
    0.16715162f, 0.19038394f, 0.34437633f, 0.01313205f, -0.03126698f, -0.07566489f, -0.05348840f, -0.03509133f, 
    0.10620848f, 0.07512610f, 0.12117590f, -0.02990260f, 0.01386596f, 0.12269339f, -0.13669102f, 0.06931549f, 
    -0.04157859f, -0.00638934f, -0.01557904f, -0.08665428f, 0.01634825f, -0.04753859f, 0.23599891f, -0.06258136f, 
    0.00025969f, 0.01957173f, 0.21508317f, -0.17105645f, -0.40025038f, -0.14263488f, 0.03592931f, -0.05077674f, 
    -0.12623972f, 0.00606723f, -0.03519103f, 0.09603506f, 0.06405233f, -0.09374394f, 0.07738893f, -0.03980378f, 
    -0.18732288f, 0.27411368f, 0.03458872f, -0.01315525f, 0.12642662f, -0.07649389f, -0.24965024f, -0.06849843f, 
    0.21165872f, -0.09313928f, -0.06810594f, 0.11512869f, 0.08618486f, 0.23572637f, 0.09336263f, 0.05794708f, 
    0.27077404f, 0.12002513f, 0.26168829f, 0.10838725f, 0.06360454f, 0.15908927f, 0.02647857f, -0.00714009f, 
    -0.23117490f, -0.03386725f, -0.20964745f, 0.25692225f, 0.01554829f, 0.09385651f, 0.09812487f, -0.00587103f, 
    -0.01501814f, 0.22713746f, 0.11835087f, 0.02965484f, 0.05585585f, 0.00254257f, 0.20297706f, 0.04219077f, 
    0.18838362f, -0.05397080f, -0.34386045f, -0.14820294f, 0.12750895f, 0.15384492f, 0.27522963f, 0.08528863f, 
    0.22388984f, -0.11301037f, -0.08568513f, 0.00394383f, -0.00751613f, -0.01731332f, 0.08990148f, -0.08084390f, 
    0.13095412f, 0.03483564f, 0.09849395f, 0.11688632f, -0.01440347f, -0.04353059f, 0.15465741f, 0.19761057f, 
    0.01299858f, 0.08242965f, -0.04706969f, 0.03711586f, 0.07766245f, 0.10153901f, 0.21115512f, 0.19075644f, 
    -0.08051441f, -0.11701715f, 0.06924926f, 0.04652425f, 0.00253337f, 0.18511112f, 0.11458009f, 0.04557405f, 
    0.27347717f, 0.24948445f, -0.14173913f, -0.06274115f, -0.00913248f, 0.23256405f, 0.10720365f, 0.07435324f, 
    0.21804306f, 0.27917036f, -0.14165516f, 0.18422110f, 0.07432727f, 0.03234080f, 0.03300351f, -0.03283201f, 
    0.10015734f, 0.03584425f, -0.01877188f, -0.04304259f, -0.40228233f, 0.04976338f, 0.31845456f, 0.20521253f, 
    -0.00035458f, 0.10905409f, -0.06179129f, -0.02076432f, 0.04027607f, -0.26366025f, 0.14478633f, 0.16755386f, 
    0.12698118f, -0.20678604f, -0.01296421f, -0.07181712f, 0.11655419f, -0.06813236f, -0.12651435f, 0.28813282f, 
    0.06952537f, 0.16808623f, -0.00639702f, -0.08815397f, -0.05594420f, -0.06831734f, -0.12561893f, -0.12648956f, 
    0.01753177f, 0.08757236f, 0.07648789f, -0.08101315f, -0.14029472f, -0.05551910f, 0.00830260f, -0.12928273f, 
    -0.26247528f, 0.11246857f, -0.04847395f, -0.07324635f, -0.01645500f, 0.16769518f, -0.08123577f, 0.21814223f, 
    0.20867935f, 0.08981879f, 0.03058393f, -0.01372885f, -0.08986731f, 0.08874222f, 0.07971177f, 0.05882153f, 
    -0.12853625f, 0.04510517f, 0.02978309f, 0.01092152f, 0.27770555f, 0.16929011f, 0.07224067f, 0.07798836f, 
    0.07543051f, 0.16258317f, -0.25648499f, -0.06914277f, 0.25796580f, 0.03203681f, 0.00316511f, 0.19239961f, 
    -0.11225556f, -0.03471045f, -0.02898649f, -0.13614595f, -0.16066532f, -0.01214612f, 0.13652052f, 0.07962947f, 
    0.17644019f, 0.06203588f, 0.00695688f, 0.12211573f, -0.03307676f, 0.39571160f, 0.06214632f, -0.05949814f, 
    -0.07595753f, 0.09549815f, 0.04758099f, 0.03080678f, 0.11832079f, 0.14402366f, 0.36443597f, -0.00491266f, 
    0.03930712f, 0.08106870f, 0.11381171f, 0.05475667f, 0.01039972f, -0.05153953f, 0.20960987f, 0.21503761f, 
    0.24172144f, 0.01358438f, 0.01649342f, 0.00795577f, -0.00343568f, -0.06096479f, 0.10090095f, 0.17688334f, 
    0.07600850f, 0.16591822f, -0.10145351f, -0.05455398f, 0.00992887f, 0.08721779f, 0.37075856f, -0.20531528f, 
    -0.10822365f, 0.23882942f, -0.16807269f, -0.06959679f, 0.12217684f, -0.23906887f, -0.03315852f, -0.39976421f, 
    0.00168832f, -0.06626050f, -0.04858347f, 0.11282741f, 0.03644926f, -0.08017816f, 0.13749187f, 0.07624629f, 
    0.17072704f, -0.01180025f, 0.28376472f, 0.12322793f, 0.03083753f, -0.05500847f, -0.13235432f, 0.00093005f, 
    -0.16643597f, 0.09884078f, 0.29939872f, -0.29757273f, -0.42167243f, 0.04810086f, -0.03691255f, 0.08152685f, 
    0.02855273f, -0.16126589f, -0.10242373f, 0.54705232f, -0.19096543f, -0.17731525f, 0.29357088f, 0.10909308f, 
    0.16200386f, -0.02653481f, 0.00007702f, 0.04953231f, -0.12092262f, 0.12185649f, -0.11366198f, 0.23517635f, 
    -0.05769949f, 0.07588165f, 0.16109508f, 0.00060130f, -0.00153233f, -0.62861067f, -0.39329049f, -0.40339395f, 
    0.12537706f, -0.11241154f, -0.21233563f, 0.02278040f, -0.04483448f, -0.08861696f, 0.09856670f, -0.00958762f, 
    -0.01123101f, -0.04710346f, 0.06738803f, 0.02006196f, -0.05021432f, -0.08269744f, -0.11332915f, -0.27643678f, 
    0.10524574f, 0.12230738f, 0.18599370f, 0.04027507f, -0.01262835f, -0.09861556f, -0.04069220f, 0.12323142f, 
    -0.12166705f, 0.02122333f, 0.13032712f, -0.10663531f, -0.08640175f, -0.08929074f, -0.01342673f, 0.03184482f, 
    0.31451270f, -0.53263628f, 0.07100160f, -0.53521919f, -0.00756597f, -0.06345656f, -0.02956043f, 0.10919727f, 
    -0.07608437f, -0.09171763f, -0.14838067f, -0.33213598f, -0.19650921f, 0.06066547f, 0.08635679f, 0.12129264f, 
    -0.02978750f, -0.02744710f, 0.17109990f, -0.00103340f, -0.05717267f, -0.03416667f, -0.00030886f, 0.06103102f, 
    -0.08766844f, -0.05667536f, 0.07885781f, 0.03554505f, 0.27367142f, 0.03872005f, 0.06712148f, -0.23608120f, 
    -0.18530525f, -0.03365098f, 0.04973499f, -0.01418753f, -0.05950664f, 0.36196232f, 0.28520298f, -0.05106987f, 
    0.04742088f, 0.10204940f, 0.05221285f, 0.04511615f, 0.01241850f, 0.07291303f, 0.27659458f, -0.08060936f, 
    -0.23670129f, 0.13756004f, -0.06077721f, 0.17845011f, 0.04712734f, 0.05205839f, -0.01926998f, -0.30497977f, 
    -0.14758132f, -0.01393598f, 0.00849413f, 0.08123914f, -0.03902159f, -0.10781436f, 0.01008474f, 0.12003673f, 
    -0.51729012f, -0.19392854f, -0.44385079f, 0.00969341f, -0.08481430f, 0.06236460f, 0.14353387f, 0.08136971f, 
    0.18092355f, -0.04796340f, -0.33049053f, 0.19564976f, 0.07824317f, 0.07930443f, 0.23014139f, 0.16620268f, 
    0.13011485f, -0.19983266f, -0.13412547f, -0.09971685f, -0.03756431f, 0.02616335f, -0.17944059f, 0.10634670f, 
    0.05297494f, 0.12654358f, -0.01415094f, 0.01295927f, 0.19372958f, 0.16923243f, 0.11332547f, -0.01816676f, 
    0.00964957f, 0.18891798f, 0.03682900f, -0.07739037f, -0.42801857f, -0.15450054f, -0.06356730f, -0.11114880f, 
    0.06098184f, -0.08309709f, -0.00321333f, -0.10991365f, 0.04557047f, -0.26888022f, 0.10599464f, 0.05505648f, 
    0.04639808f, 0.01902049f, -0.01525951f, 0.17244837f, -0.03010317f, -0.04366004f, 0.68845785f, -0.49330124f, 
    -0.23198968f, 0.04817662f, 0.09057072f, 0.10886482f, 0.03697849f, 0.00470354f, 0.02778452f, 0.10786333f, 
    0.07134306f, -0.21901116f, 0.05225609f, 0.15976819f, -0.00398203f, 0.08612254f, -0.01071087f, 0.21160510f, 
    0.20327276f, 0.04632048f, -0.15943629f, 0.24885976f, 0.00803659f, 0.14870532f, 0.02704970f, -0.02063811f, 
    0.13896327f, -0.62598771f, -0.47644785f, 0.28191808f, -0.09550093f, -0.05767128f, -0.09693485f, -0.17041169f, 
    -0.19133575f, 0.00457525f, 0.08993345f, -0.02878079f, -0.14146781f, 0.06623656f, -0.06729393f, -0.07764061f, 
    -0.02112908f, -0.03424047f, 0.08114921f, 0.16040175f, -0.47441158f, 0.03791318f, 0.20232956f, 0.26039380f, 
    0.00633295f, 0.04991041f, -0.00447215f, 0.05622072f, -0.31179139f, -0.32622895f, -0.42983538f, -0.00894893f, 
    0.06846140f, -0.14966948f, -0.06100856f, -0.06977715f, -0.00329608f, 0.38411388f, -0.04995418f, -0.43170103f, 
    -0.21046102f, -0.12130687f, -0.17933318f, 0.14042789f, -0.02933372f, 0.12398327f, 0.00311961f, -0.48596424f, 
    -0.11859456f, -0.09915841f, 0.00219298f, 0.20010087f, -0.01268018f, 0.05455398f, -0.07640727f, -0.17442000f, 
    0.25150049f, -0.05806304f, 0.03587031f, 0.01838998f, -0.18957877f, -0.10391529f, 0.05037573f, 0.08669168f, 
    -0.03706647f, -0.02023712f, 0.04487706f, -0.00725634f, -0.06475851f, -0.00311233f, -0.00265177f, -0.11059327f, 
    0.01861690f, 0.02221639f, -0.05899531f, -0.01917133f, -0.13849182f, -0.05863245f, -0.02592910f, -0.07159419f, 
    0.00295511f, -0.02930275f, -0.07779785f, -0.01006471f, 0.05752283f, -0.06758782f, -0.01368342f, 0.07801985f, 
    0.03057612f, 0.01548272f, -0.11619528f, -0.09081917f, -0.01278378f, -0.04063734f, 0.03592530f, 0.02473678f, 
    -0.01407450f, -0.03615722f, -0.00605859f, -0.05210324f, -0.02877907f, 0.00724854f, -0.00913450f, -0.08509149f, 
    -0.05160411f, -0.03776686f, -0.07991792f, -0.03432633f, -0.01294280f, -0.10015196f, -0.04052599f, -0.05260307f, 
    -0.00104365f, -0.06315301f, 0.02111021f, 0.05280493f, 0.05776769f, -0.09681533f, 0.00459361f, 0.01191540f, 
    -0.04859216f, 0.00266295f, -0.04747841f, -0.04319233f, -0.00662789f, -0.04393725f, 0.03220938f, 0.06021503f, 
    0.01762998f, -0.00160814f, -0.07324356f, -0.07121617f, -0.06864892f, 0.06082655f, 0.05267050f, -0.07783819f, 
    0.03585567f, 0.05508045f, -0.02850380f, -0.04233061f, -0.03149322f, -0.04502540f, 0.00220550f, 0.03426671f, 
    -0.04124717f, -0.13066621f, -0.01340597f, -0.06920925f, -0.10030618f, 0.04417277f, 0.03405568f, -0.00959370f, 
    0.00362905f, -0.03516484f, -0.11157029f, -0.01444767f, -0.01839497f, 0.00051031f, -0.02377735f, 0.02473121f, 
    -0.05527721f, -0.06619821f, -0.10859416f, 0.00889797f, -0.03294815f, -0.04883932f, -0.14829309f, -0.00303975f, 
    0.06253510f, 0.03940817f, -0.02799357f, -0.05748314f, -0.05941347f, 0.00249865f, -0.04008382f, 0.01200645f, 
    0.02231899f, 0.04710362f, -0.00705373f, -0.03935270f, -0.02689186f, 0.00679240f, -0.03896201f, -0.07101869f, 
    -0.08149625f, -0.05323765f, -0.03481295f, -0.04771571f, -0.02272600f, -0.03911909f, -0.05696924f, 0.02129041f, 
    -0.04658866f, 0.03709866f, 0.01884106f, -0.09401991f, -0.03538517f, -0.04074280f, -0.04857592f, 0.01306273f, 
    0.04298460f, -0.08003984f, 0.02612380f, 0.01736979f, 0.01727064f, -0.10878588f, -0.04691828f, -0.03868018f, 
    -0.04689127f, -0.04210047f, -0.05038076f, -0.05017536f, -0.10503476f, 0.07931174f, -0.06392561f, -0.00548066f, 
    -0.08555803f, -0.06442202f, -0.01570455f, -0.03952245f, -0.10063376f, -0.03324892f, 0.00458937f, -0.13481572f, 
    -0.04652538f, -0.11084608f, -0.04833937f, -0.00467509f, -0.01252664f, -0.01082887f, -0.03058009f, -0.02660583f, 
    -0.10198507f, 0.00001713f, -0.04167369f, -0.01785435f, 0.02062028f, 0.00085289f, -0.01172903f, -0.05011745f, 
    -0.04717684f, -0.04503391f, -0.05889667f, 0.04162077f, -0.11860979f, -0.07158809f, -0.05546741f, -0.16000177f, 
    -0.00131304f, 0.07511479f, -0.01904031f, -0.05112392f, -0.04031043f, -0.01502539f, -0.02413558f, 0.05211464f, 
    -0.04393880f, -0.03366335f, 0.03146283f, 0.02176971f, -0.02529350f, -0.06886947f, -0.08219879f, -0.02518885f, 
    -0.03530373f, -0.05825032f, 0.02246934f, 0.00403928f, -0.02440856f, -0.04556993f, -0.08481958f, 0.01681904f, 
    0.01857496f, -0.08168110f, 0.06022231f, 0.00928651f, -0.09369121f, -0.01894006f, -0.04718921f, -0.03791622f, 
    -0.02123687f, -0.00810774f, -0.04055491f, -0.06765577f, -0.00358091f, -0.05856566f, -0.09404973f, -0.09469112f, 
    -0.05623568f, -0.00528649f, -0.01562205f, -0.00215076f, -0.15773267f, -0.11104995f, 0.04528098f, 0.00384133f, 
    0.02597286f, -0.09188337f, -0.01908031f, -0.01727391f, -0.02583553f, -0.07488265f, -0.03389759f, -0.00015102f, 
    -0.03845871f, -0.05379665f, -0.02591547f, 0.01518922f, 0.03204098f, -0.03431251f, 0.00935116f, -0.05607836f, 
    0.02114229f, -0.07674770f, -0.12900449f, -0.11647140f, 0.01498017f, 0.01841669f, -0.07358438f, -0.00337558f, 
    -0.02895766f, -0.07584663f, 0.00189782f, -0.02372852f, -0.04317753f, -0.11145803f, -0.11959777f, 0.01291027f, 
    -0.09164527f, -0.04811767f, -0.08074836f, 0.00204536f, -0.01822127f, -0.05914007f, -0.07580989f, -0.00781263f, 
    0.00462634f, 0.01055014f, 0.01241394f, -0.01002822f, -0.02327427f, -0.10248033f, -0.11414331f, 0.09190288f, 
    0.04166449f, 0.01507037f, -0.11852404f, -0.02942718f, 0.04720506f, 0.07062107f, 0.01665688f, 0.06535827f, 
    -0.03406688f, 0.02078312f, 0.14255603f, 0.05268380f, 0.03393666f, 0.18652157f, -0.21832499f, -0.13263090f, 
    -0.08429521f, -0.01178627f, 0.14775263f, 0.00390808f, 0.00441629f, 0.05311809f, -0.00188165f, 0.05378999f, 
    0.06857104f, -0.12395836f, -0.01366053f, 0.32814103f, 0.30399168f, 0.00237182f, 0.25948435f, 0.18724626f, 
    -0.30724236f, 0.01444636f, 0.27804542f, -0.06890804f, -0.04298798f, -0.12243490f, -0.00836330f, 0.12508641f, 
    0.00523752f, -0.02575140f, -0.12941407f, -0.01743961f, 0.19442946f, -0.00603878f, 0.18628730f, 0.19633245f, 
    0.02584311f, 0.06544872f, 0.03654326f, -0.08148492f, -0.05841901f, -0.25567502f, 0.17537346f, 0.17634219f, 
    0.09064513f, 0.02517139f, 0.11456069f, 0.05112216f, 0.27775127f, -0.16518228f, 0.04885969f, 0.05791460f, 
    0.09028751f, 0.02361121f, -0.04526999f, -0.04119074f, -0.19081341f, -0.16645305f, -0.06252033f, -0.01138115f, 
    0.04764492f, 0.00824787f, 0.16426457f, 0.05459080f, -0.15084702f, 0.00914830f, 0.05682613f, 0.01954845f, 
    -0.11051565f, -0.07250848f, -0.21769096f, 0.17771944f, 0.00977047f, -0.17953750f, 0.05121690f, -0.11130022f, 
    -0.36675522f, 0.05787684f, -0.19029398f, 0.15303922f, -0.02336390f, 0.01805014f, 0.17879593f, 0.17221457f, 
    0.08567614f, 0.01786907f, 0.11486341f, 0.07378037f, 0.09760650f, 0.05905098f, 0.11952431f, -0.02151236f, 
    -0.26517889f, -0.00824910f, -0.05220883f, -0.02239990f, -0.04383890f, -0.14308044f, 0.04785207f, 0.09600103f, 
    0.01886034f, 0.04487716f, 0.11008198f, 0.08951172f, -0.03872245f, -0.11107692f, -0.23619017f, 0.08447002f, 
    -0.03408125f, -0.05769729f, -0.12624168f, 0.13307653f, -0.01902313f, 0.08320738f, -0.00312132f, -0.05290155f, 
    -0.05511886f, 0.07994089f, 0.05598743f, -0.07083245f, -0.05449833f, 0.11886040f, -0.01821136f, -0.12839410f, 
    0.05882848f, 0.16845810f, 0.10221929f, 0.00931631f, -0.08355104f, -0.21643372f, -0.36428154f, -0.01540766f, 
    -0.01735280f, -0.06909741f, 0.06962645f, 0.05833640f, -0.01867560f, 0.01373387f, -0.00613441f, -0.11605377f, 
    0.05792692f, 0.04146056f, 0.15355554f, -0.02268049f, 0.00869493f, 0.08341559f, 0.03917927f, -0.10857306f, 
    0.06931867f, -0.04251887f, 0.18215397f, 0.00315726f, 0.01255068f, 0.12979369f, 0.00770075f, 0.05681441f, 
    0.10073885f, 0.18283443f, 0.05095206f, 0.09048857f, -0.00282408f, 0.08865573f, -0.14685287f, 0.08910314f, 
    0.00860096f, -0.19329596f, -0.11041779f, -0.05741774f, 0.08898661f, 0.11412213f, 0.07232971f, -0.12051886f, 
    0.02160428f, -0.01521185f, 0.11815790f, -0.02570447f, -0.26754066f, 0.01279273f, 0.04944644f, -0.21273062f, 
    0.08363093f, 0.02460298f, 0.07769018f, 0.02352409f, 0.02200600f, -0.08330545f, 0.02578537f, -0.10252934f, 
    0.23595192f, 0.17045450f, -0.07190542f, 0.01754411f, 0.01840625f, 0.11139910f, -0.14849052f, 0.05959838f, 
    0.02183293f, 0.00637029f, 0.31957653f, 0.00934277f, -0.02430127f, 0.15633121f, 0.20713179f, 0.13049048f, 
    0.11799791f, 0.03856465f, 0.04253393f, 0.11829926f, 0.01899205f, -0.17749536f, -0.31133789f, -0.19180596f, 
    -0.02169989f, 0.14529793f, 0.07426172f, -0.13018006f, 0.05591110f, 0.07441874f, -0.15124600f, -0.17470559f, 
    -0.07770600f, -0.28228736f, 0.07580059f, 0.26628309f, -0.05363848f, 0.12377182f, 0.12382723f, -0.12017229f, 
    -0.04241450f, 0.01826417f, 0.10337141f, 0.03594869f, 0.07409767f, -0.12324647f, 0.04243833f, 0.02552401f, 
    -0.13826598f, -0.08129343f, 0.05752493f, -0.00342715f, 0.05050243f, -0.16530393f, 0.03616294f, 0.00913416f, 
    0.00232931f, 0.15685181f, -0.02943531f, 0.05341027f, -0.11323170f, -0.15560438f, -0.44548482f, 0.07486058f, 
    0.11184377f, 0.12639906f, -0.08724356f, -0.23227727f, -0.15977937f, -0.19044422f, -0.15755832f, -0.08942642f, 
    -0.06699650f, 0.14219829f, 0.08163695f, 0.23803379f, 0.16285349f, 0.08451381f, -0.00313177f, 0.11460098f, 
    0.11174367f, 0.07369756f, 0.03822416f, -0.09375232f, -0.10130406f, -0.09722874f, -0.20141824f, -0.21801965f, 
    0.13422434f, 0.05305268f, -0.05827782f, 0.20236920f, 0.12570721f, -0.15796104f, -0.07585867f, -0.08257409f, 
    0.00168531f, 0.05686004f, -0.05558401f, -0.02809373f, 0.03324319f, 0.00239227f, -0.04940039f, -0.03855559f, 
    -0.05208555f, 0.00964050f, 0.00330811f, 0.02460417f, -0.04737610f, -0.02595360f, -0.04204307f, 0.00076544f, 
    0.00562215f, 0.04840248f, -0.05054206f, 0.02203972f, 0.04372980f, 0.00423368f, -0.03892864f, -0.03650001f, 
    0.04427895f, -0.01391027f, -0.05565038f, -0.05728576f, -0.03671684f, 0.00090330f, 0.02459335f, -0.04031607f, 
    -0.03933937f, 0.01113407f, 0.00577603f, 0.00717951f, 0.03542347f, 0.02523975f, -0.04904369f, -0.00252678f, 
    -0.00138730f, -0.05361590f, -0.01752319f, -0.02834726f, -0.00830559f, 0.04293576f, 0.03606893f, 0.00952630f, 
    -0.05036352f, 0.03523377f, -0.05283101f, 0.04813754f, 0.01476978f, -0.04118447f, 0.01289554f, 0.01793512f, 
    -0.04036103f, 0.04836975f, -0.04949113f, -0.01023936f, 0.00375548f, 0.01670238f, 0.00735738f, -0.05465927f, 
    -0.01198582f, -0.00879976f, -0.03303672f, -0.05167197f, 0.01260484f, 0.01405241f, -0.05283298f, 0.00121401f, 
    -0.01273301f, -0.03947179f, 0.00667133f, -0.01307573f, 0.03998945f, 0.03915034f, 0.05216444f, -0.05542339f, 
    -0.02003334f, -0.00079524f, 0.00932367f, -0.04379155f, -0.04002405f, -0.01398216f, -0.02915216f, 0.01297886f, 
    -0.00065941f, -0.06382272f, 0.03173691f, -0.00536735f, 0.01160876f, -0.03435439f, -0.05776546f, 0.01553011f, 
    -0.02276308f, 0.02412846f, 0.00938250f, 0.02653878f, -0.01139104f, -0.00986894f, -0.03338609f, -0.04248707f, 
    -0.02598946f, -0.03278320f, -0.06269291f, 0.04399516f, 0.01488198f, 0.04832542f, -0.04108014f, 0.00682695f, 
    0.01988476f, -0.00387996f, -0.04779363f, -0.03050563f, 0.00277194f, 0.05076745f, 0.03226760f, 0.01440363f, 
    0.00871264f, 0.01067928f, -0.02639772f, 0.01726970f, 0.04781948f, -0.02453873f, -0.01969618f, -0.04043097f, 
    -0.05635703f, -0.01240745f, -0.02572404f, 0.05092634f, -0.05698447f, 0.05199748f, -0.04292729f, 0.01215817f, 
    0.01284534f, 0.04995992f, -0.01152100f, -0.02410625f, -0.03160532f, 0.01914683f, -0.03055623f, -0.00261714f, 
    -0.03587259f, 0.00028493f, 0.01487991f, -0.06292593f, -0.01851574f, 0.03857810f, -0.05100069f, 0.03855144f, 
    0.03190554f, -0.04500984f, -0.03573330f, 0.04493439f, 0.04207071f, 0.04265448f, -0.04195765f, -0.05710477f, 
    -0.00450561f, -0.05945503f, -0.05267565f, -0.03733463f, -0.01858338f, 0.02019323f, -0.01545873f, -0.04057234f, 
    -0.02612511f, -0.01321028f, -0.05611075f, -0.05247542f, 0.02776163f, 0.00906292f, -0.06022292f, -0.02510212f, 
    0.02871880f, 0.05270902f, -0.01542702f, -0.04345492f, 0.02732775f, -0.05455343f, 0.00621371f, -0.04452377f, 
    -0.01786456f, -0.02459209f, -0.03444279f, 0.04104698f, -0.04161315f, -0.05590100f, -0.03424649f, 0.01820594f, 
    0.00903205f, -0.05197498f, -0.00392381f, 0.03007943f, -0.03214569f, -0.03071812f, -0.02410465f, 0.03656644f, 
    -0.02155774f, -0.02433163f, 0.02334864f, 0.03830503f, 0.04059720f, -0.00142250f, -0.03610936f, -0.04184906f, 
    -0.04073041f, -0.04710759f, 0.04264776f, 0.01639423f, 0.01608232f, 0.02330326f, 0.05019858f, -0.02462291f, 
    -0.01486762f, -0.02236915f, 0.00015534f, 0.04186327f, 0.04397600f, 0.04866518f, -0.02951925f, -0.06217901f, 
    -0.04649751f, -0.01351925f, -0.02219750f, -0.01868190f, 0.00612916f, 0.01715930f, -0.02572467f, -0.06046842f, 
    0.05052569f, 0.03846380f, -0.02075978f, -0.01103056f, -0.03763416f, -0.00841918f, -0.01253346f, 0.03078067f, 
    -0.05022743f, 0.03108993f, 0.00487906f, 0.01586913f, 0.03219714f, -0.01620610f, 0.00471030f, -0.05343881f, 
    -0.04952894f, -0.05119654f, 0.04442495f, -0.03268876f, 0.00070826f, -0.03503286f, -0.02687122f, 0.04816794f, 
    -0.01658002f, -0.00407835f, 0.05381425f, 0.01798864f, -0.00110575f, 0.03766423f, -0.05325637f, 0.02676958f, 
    -0.01025690f, -0.02439056f, 0.01371366f, -0.03633628f, -0.00754234f, -0.06235958f, 0.02610456f, 0.02840342f, 
    0.01130152f, -0.02316459f, 0.00397833f, 0.01986992f, -0.02103169f, -0.03659770f, -0.01222042f, 0.05996810f, 
    0.03082902f, 0.04149579f, -0.01006418f, -0.00134697f, -0.01381128f, -0.05823695f, -0.03603587f, -0.03273740f, 
    -0.03456725f, -0.01891053f, 0.02146651f, 0.02805014f, 0.01026329f, -0.04894981f, 0.04419810f, 0.04872789f, 
    -0.03419239f, -0.01321364f, 0.02908679f, 0.02402826f, -0.05766992f, -0.04926255f, -0.03893094f, -0.05074935f, 
    -0.03665126f, -0.01354507f, 0.04094287f, -0.04016085f, 0.05481686f, -0.01578232f, -0.02427801f, -0.02191891f, 
    0.01371843f, -0.01758554f, 0.03714624f, 0.05451297f, -0.02024270f, -0.00355390f, 0.02480434f, 0.00492831f, 
    -0.01858456f, -0.00348311f, -0.06114805f, -0.00098301f, -0.01884876f, 0.01274883f, -0.06172341f, 0.02400801f, 
    -0.02582036f, -0.04637416f, -0.02609396f, -0.03344554f, -0.00540220f, 0.04820183f, -0.05097111f, 0.05067531f, 
    -0.01738478f, 0.03449836f, -0.04774738f, -0.01981036f, -0.01859194f, 0.01676321f, -0.05428402f, -0.02684441f, 
    -0.01567664f, -0.03178313f, -0.03556833f, 0.01422031f, 0.02553066f, 0.04005201f, -0.00884993f, -0.02759522f, 
    -0.02541781f, -0.03167248f, 0.03007428f, 0.00372496f, -0.04835939f, 0.02181816f, 0.03581509f, -0.01905602f, 
    -0.05299579f, 0.02103664f, -0.00988952f, 0.00481947f, 0.03430557f, -0.00868185f, 0.00703661f, 0.03218094f, 
    0.05071117f, 0.00038495f, -0.00033798f, -0.05528720f, -0.03400882f, 0.00366847f, -0.01077876f, -0.00863390f, 
    0.04978968f, -0.00514582f, -0.02696689f, 0.02514165f, -0.02785269f, -0.01650130f, -0.00303605f, -0.03965266f, 
    -0.05042779f, -0.02651475f, 0.03103578f, -0.00746169f, -0.02384448f, -0.02612019f, -0.02086502f, 0.02012872f, 
    0.00973994f, 0.02397411f, -0.01723622f, -0.00117092f, 0.05072772f, 0.00262181f, 0.03621955f, -0.02255089f, 
    -0.00848250f, -0.04237473f, -0.06476493f, -0.04173599f, -0.02764584f, 0.01494321f, 0.02728499f, -0.03775816f, 
    -0.04192176f, -0.05117885f, -0.03976411f, 0.01884139f, 0.02663284f, -0.02732971f, 0.00685971f, -0.02883296f, 
    -0.05520945f, 0.01283333f, -0.01022543f, 0.04493473f, -0.04809825f, -0.01144829f, -0.00072205f, -0.05053738f, 
    0.03305525f, -0.02864014f, 0.04613165f, 0.04255785f, -0.00358303f, 0.00477748f, 0.00543199f, 0.04451011f, 
    -0.01420504f, -0.00774889f, -0.02014608f, -0.04723926f, 0.05229687f, 0.00798344f, 0.03541050f, 0.03611998f, 
    0.01144624f, -0.06227227f, 0.02012180f, -0.01502077f, 0.03564027f, 0.04984041f, 0.05519946f, -0.01561390f, 
    0.03840852f, 0.00312317f, 0.01163966f, 0.00181847f, -0.04888559f, -0.03515362f, -0.04514346f, -0.01365943f, 
    -0.04950056f, 0.04534537f, -0.05287227f, 0.05404485f, 0.00739105f, -0.05998256f, 0.03314777f, -0.00099861f, 
    -0.05761668f, 0.00684635f, 0.03448381f, -0.05418056f, 0.00123810f, -0.02895918f, -0.04508067f, -0.03102349f, 
    0.01974425f, -0.04301588f, -0.05066966f, 0.03002766f, -0.05835918f, -0.00367480f, 0.04507781f, 0.00850817f, 
    -0.03273709f, 0.05073372f, -0.05102621f, -0.00225168f, -0.04186990f, -0.02678488f, -0.05458132f, -0.01403009f, 
    -0.04963109f, 0.01506174f, 0.03183950f, 0.03909891f, 0.01956762f, -0.01028855f, -0.02318954f, 0.00617217f, 
    0.01644337f, -0.02497986f, -0.03324101f, -0.05823953f, 0.01768016f, -0.06168324f, 0.03012849f, 0.02371184f, 
    0.05554083f, -0.04867093f, 0.05136916f, -0.05183125f, -0.05433319f, 0.04939117f, -0.04903544f, 0.00832404f, 
    -0.01302976f, 0.00932887f, 0.02730948f, 0.03692338f, -0.02530859f, 0.01326939f, -0.02982837f, -0.05763493f, 
    -0.03298220f, -0.04734909f, 0.02398934f, -0.00773120f, -0.00036617f, 0.00658646f, 0.03349358f, 0.02267476f, 
    -0.06043889f, -0.02017040f, 0.04116711f, 0.00127109f, -0.02917582f, -0.04454960f, 0.03779154f, -0.02904819f, 
    0.00775386f, -0.06098380f, 0.04035903f, -0.02379684f, -0.01096512f, 0.02725541f, -0.02629203f, -0.01807257f, 
    -0.03848132f, -0.06026637f, -0.06044616f, -0.04190795f, -0.03075572f, -0.00562834f, 0.05755270f, -0.02966397f, 
    0.00124365f, -0.04109570f, 0.03332249f, -0.00574372f, -0.01490737f, -0.01865643f, -0.00288502f, 0.01938550f, 
    0.05753877f, -0.05465981f, -0.00743890f, 0.04833678f, 0.03357343f, -0.00472087f, 0.02738754f, 0.03873859f, 
    0.04467231f, -0.02893301f, -0.06186038f, -0.00654691f, -0.00707528f, -0.01187154f, 0.02247733f, 0.03163683f, 
    0.01527285f, -0.41463396f, 0.36981073f, 0.12484640f, -0.13280816f, 0.30882165f, -0.03871053f, 0.07361252f, 
    0.07984333f, -0.03449401f, -0.12637728f, -0.14490372f, 0.00499373f, 0.02936860f, -0.00690266f, 0.05386524f, 
    -0.21263829f, 0.01958170f, -0.19685340f, 0.15637527f, 0.76813203f, 0.13460647f, -0.26026344f, -0.00886841f, 
    -0.18374170f, -0.08795832f, 0.07504921f, 0.09071194f, 0.17413560f, 0.14332785f, -0.04525745f, -0.04807421f, 
    -0.07971820f, 0.06158784f, 0.02767805f, 0.00557254f, -0.01974636f, 0.31864837f, 0.21800122f, -0.02741405f, 
    0.05833660f, 0.10526910f, 0.06541789f, 0.29928669f, -0.15061572f, -0.00747234f, 0.24476874f, 0.16054718f, 
    -0.32344821f, -0.14386058f, 0.02157192f, 0.22977214f, 0.06620954f, 0.05689111f, 0.12497202f, 0.02518889f, 
    0.10391290f, 0.12741981f, -0.01041497f, 0.00809950f, 0.03961073f, 0.05243312f, -0.14188519f, -0.11044607f, 
    0.05863606f, 0.04645865f, 0.16801767f, -0.03205081f, -0.23641500f, -0.06502866f, 0.01085315f, -0.07371606f, 
    0.08533968f, -0.11679934f, -0.17804779f, -0.12900533f, 0.00656856f, 0.09105581f, -0.07056327f, -0.06095425f, 
    -0.02238503f, -0.09192718f, 0.28316277f, 0.22879514f, 0.06498903f, -0.01898485f, 0.11130302f, 0.05907751f, 
    0.05228870f, 0.14559929f, -0.09014607f, -0.08977133f, 0.32833213f, 0.03733461f, 0.01221472f, 0.15350394f, 
    -0.02400517f, -0.23023643f, 0.10436701f, 0.02590357f, -0.10956636f, -0.05492671f, -0.02173292f, 0.03642831f, 
    -0.12561224f, -0.03439438f, -0.12390100f, -0.09230983f, 0.04220464f, -0.08127581f, 0.15741968f, 0.21690139f, 
    0.11852822f, 0.23219591f, 0.04816261f, -0.31993005f, 0.08811823f, 0.04698514f, -0.03872077f, 0.32798004f, 
    0.02052201f, -0.11568052f, -0.06335434f, -0.10816217f, 0.06928799f, -0.23851034f, -0.06883220f, 0.18101144f, 
    -0.30131647f, -0.07084832f, 0.21042773f, 0.04729516f, -0.02156125f, 0.05455784f, -0.02306805f, -0.08116657f, 
    0.36632988f, 0.02898841f, -0.14555603f, -0.11869518f, 0.10249745f, -0.03995258f, -0.19061263f, -0.00078221f, 
    -0.39978668f, 0.22342761f, -0.10636334f, -0.22923821f, 0.08173222f, 0.24617830f, -0.08283057f, -0.00358562f, 
    -0.06628738f, 0.01962805f, 0.16390726f, -0.08669732f, -0.06158632f, 0.06117806f, -0.12703113f, -0.04315861f, 
    -0.08029607f, 0.16074033f, 0.04647065f, 0.17749685f, 0.03668438f, 0.00060518f, -0.31718287f, 0.11116037f, 
    0.14294265f, 0.18037809f, -0.01386997f, -0.05206585f, -0.09821918f, -0.14519247f, 0.04006796f, 0.13313676f, 
    -0.04313192f, -0.01413843f, -0.19475046f, -0.20507839f, -0.24677333f, -0.00700761f, -0.03949762f, 0.02185484f, 
    -0.04659177f, 0.00008236f, 0.03514423f, -0.14104088f, -0.07773665f, -0.17304243f, 0.08611130f, -0.02742713f, 
    0.09075774f, 0.07078867f, -0.13982709f, -0.04522443f, 0.09904020f, -0.14971240f, 0.06844527f, 0.55261856f, 
    -0.08668977f, 0.12953615f, 0.04242981f, -0.25255099f, -0.04185107f, -0.07690854f, -0.13132052f, 0.13822053f, 
    0.21310492f, 0.12777437f, -0.07321777f, 0.04190163f, 0.25407982f, -0.12852441f, 0.11584931f, 0.08339423f, 
    0.00504312f, 0.05029608f, 0.08083189f, -0.10891869f, -0.02276284f, 0.29947075f, -0.00542043f, 0.12364060f, 
    -0.17343608f, -0.19347338f, 0.24915518f, -0.01755970f, -0.03925910f, 0.12989749f, -0.38274631f, 0.02151301f, 
    -0.09434037f, -0.06716217f, -0.02245346f, 0.15306820f, 0.21314141f, 0.00145061f, 0.07418793f, 0.02196570f, 
    0.07719455f, -0.01002113f, 0.04066666f, 0.17124994f, 0.02064338f, 0.24106723f, -0.11458635f, -0.07530364f, 
    0.01847248f, 0.02693761f, 0.08387253f, 0.05458642f, 0.24742828f, 0.32575959f, 0.17295831f, 0.11614589f, 
    0.20575656f, 0.04856776f, -0.07646496f, 0.08144039f, -0.06880379f, -0.05109814f, 0.08833419f, -0.15995923f, 
    0.08870225f, 0.09585671f, 0.04490466f, -0.03646857f, -0.45891109f, 0.04737291f, -0.09686104f, -0.08414830f, 
    -0.18994141f, 0.02102267f, -0.04543541f, -0.04023482f, -0.01368045f, -0.02674343f, 0.20220077f, 0.21634211f, 
    0.05109821f, 0.26738763f, -0.03226940f, 0.02437491f, 0.23140004f, 0.09083035f, -0.00943408f, 0.05559177f, 
    0.05094649f, 0.13645978f, 0.16693088f, -0.10282868f, -0.09206486f, -0.25489464f, 0.04389758f, -0.00859419f, 
    -0.08655615f, 0.15084110f, -0.14251687f, 0.09124779f, -0.01541694f, 0.02004530f, -0.27506867f, -0.02054239f, 
    0.03929589f, -0.13093354f, 0.77132660f, -0.41689929f, 0.19452979f, 0.11952991f, 0.02422384f, -0.21176948f, 
    0.22053881f, -0.12472063f, -0.20398860f, 0.13250911f, 0.18915443f, 0.11262263f, 0.09034637f, -0.03336444f, 
    0.00543143f, 0.10663615f, 0.22580506f, 0.09021043f, 0.04653759f, 0.10987485f, -0.06966235f, -0.05144722f, 
    0.01289384f, 0.02635566f, -0.05355945f, -0.00895005f, 0.14655986f, 0.24453814f, 0.37800670f, -0.22438554f, 
    -0.05731210f, 0.26441410f, 0.14909689f, 0.05686321f, 0.31964454f, 0.09484177f, 0.05659355f, 0.25899550f, 
    0.24279483f, -0.02188943f, -0.06409743f, -0.17154627f, 0.16357315f, -0.00335166f, -0.00662876f, 0.12869114f, 
    -0.01878358f, -0.00413279f, 0.05142216f, 0.01946476f, -0.18868655f, 0.05942499f, 0.07638509f, 0.09245027f, 
    0.31898323f, 0.02259378f, 0.14147593f, -0.10319613f, -0.02465731f, -0.20122097f, -0.01797766f, -0.11159323f, 
    -0.11669762f, 0.33758995f, -0.25938153f, -0.10908601f, 0.14327392f, -0.02584602f, -0.02266308f, -0.02536044f, 
    0.03303149f, 0.07346483f, 0.25430122f, -0.41100264f, -0.51541489f, 0.01295455f, -0.12833019f, 0.07558244f, 
    -0.06467514f, 0.02046430f, 0.12069402f, -0.09235022f, -0.16676643f, -0.44169834f, -0.02552906f, -0.08158247f, 
    0.02417489f, 0.12374088f, 0.08932122f, 0.15859158f, -0.12862748f, -0.24129336f, -0.25333592f, -0.05658926f, 
    -0.03011304f, 0.10121965f, 0.20512906f, 0.10670273f, 0.08999065f, -0.05160639f, -0.02797670f, 0.04058041f, 
    0.02539857f, -0.09843563f, -0.17617762f, 0.03956044f, 0.07928661f, 0.07049339f, -0.04349831f, -0.28259099f, 
    -0.42515859f, -0.07365578f, 0.00023826f, -0.06008604f, -0.16806868f, -0.22735031f, -0.06422116f, 0.15507838f, 
    0.02768215f, 0.04909058f, 0.05945827f, -0.00796238f, 0.01132161f, -0.08275618f, -0.08140320f, -0.05769406f, 
    0.22766767f, 0.00199068f, -0.06570484f, -0.11735561f, -0.02967999f, 0.07840018f, 0.13146308f, -0.08034277f, 
    -0.11913788f, -0.19707157f, -0.03196377f, 0.13947813f, 0.03051634f, -0.19677794f, -0.16546427f, -0.03399001f, 
    -0.02464385f, -0.22230522f, 0.18841185f, 0.28657314f, 0.15945649f, 0.08857647f, -0.10814819f, 0.14997391f, 
    -0.19209543f, -0.09187154f, -0.08788590f, 0.00582271f, -0.02903548f, 0.10671748f, -0.12714961f, -0.25630793f, 
    -0.26329029f, 0.00551786f, -0.01964227f, -0.07259216f, 0.24667753f, 0.33072114f, 0.00949751f, 0.04153108f, 
    -0.02577538f, 0.07735879f, 0.08436596f, 0.04036998f, 0.09973433f, 0.17015299f, 0.08572554f, 0.16222608f, 
    -0.23837562f, -0.02934660f, -0.03071113f, 0.03489996f, -0.03725869f, 0.00892067f, 0.48182678f, 0.31009766f, 
    0.34304443f, 0.09855684f, 0.00599644f, -0.05673160f, 0.10608558f, 0.10365245f, -0.18305086f, -0.27050754f, 
    -0.26595211f, -0.10809063f, 0.03262022f, -0.07526220f, 0.16172920f, 0.04893366f, 0.00286935f, 0.18281826f, 
    -0.04706832f, 0.04649346f, 0.03017131f, 0.17780845f, -0.19320689f, 0.02707562f, -0.11069641f, -0.02433695f, 
    -0.13687217f, 0.26758277f, 0.11747146f, -0.12139810f, 0.14592801f, -0.06189021f, 0.08319227f, 0.23425491f, 
    0.08335520f, 0.15250601f, 0.19092230f, 0.11901931f, 0.06120152f, 0.03975498f, -0.02835248f, 0.00533949f, 
    -0.09810354f, 0.13568556f, -0.16911642f, -0.01537692f, 0.02238538f, 0.15262431f, 0.01269441f, 0.01986845f, 
    -0.01138664f, -0.04721402f, 0.00425927f, -0.10527840f, -0.00726278f, -0.16749473f, -0.11847828f, 0.00337072f, 
    -0.05493170f, 0.10739398f, 0.04226407f, 0.23386586f, 0.49577653f, 0.52567923f, 0.34992987f, -0.05956125f, 
    -0.01907950f, -0.14196904f, 0.09394217f, -0.02409817f, 0.10247955f, -0.09843399f, 0.08773188f, -0.15584809f, 
    -1.01446939f, -0.04917978f, -0.06034111f, 0.02057546f, -0.16619331f, -0.09689908f, 0.02810404f, 0.10522021f, 
    -0.14378756f, 0.03406571f, 0.13754538f, -0.01996002f, -0.11545929f, 0.10374098f, 0.10215645f, 0.06118560f, 
    0.90791440f, -0.12094077f, -0.58426005f, -0.02153246f, -0.12564763f, -0.13656232f, -0.06404924f, 0.18083748f, 
    -0.07747392f, -0.23590522f, -0.49884903f, 0.07154914f, 0.00546349f, -0.04158909f, 0.08277123f, 0.10539153f, 
    0.04827427f, 0.16610272f, 0.07249875f, 0.00241013f, -0.60378116f, -0.00891991f, 0.46813139f, 0.01446132f, 
    -0.01991886f, -0.16590855f, 0.20103836f, 0.17529376f, -0.32194117f, -0.13532352f, 0.24904621f, -0.02988265f, 
    -0.10343835f, 0.00388920f, 0.08751805f, 0.22964054f, 0.08502819f, -0.23964807f, -0.56000412f, 0.01898460f, 
    0.02846515f, -0.00778172f, -0.06551839f, 0.15471815f, 0.00073856f, -0.00997572f, 0.09409925f, -0.03997540f, 
    -0.06619769f, -0.30054128f, -0.03582174f, 0.10598598f, 0.06002470f, 0.18602288f, 0.02738889f, -0.27582520f, 
    -0.20618150f, 0.14261024f, 0.02830176f, 0.02429131f, 0.01966120f, 0.04597064f, 0.03976461f, -0.41371289f, 
    -0.33010048f, -0.30887744f, 0.16224146f, 0.08911898f, 0.16504939f, 0.03866004f, 0.04751037f, 0.01380501f, 
    0.13715874f, -0.08092847f, -0.04384676f, 0.17747580f, -0.00097292f, -0.13057369f, 0.15681490f, 0.04333290f, 
    -0.04802265f, -0.11240464f, 0.14228305f, 0.10697894f, 0.02938765f, -0.13758931f, 0.15499441f, -0.03915156f, 
    0.04224107f, -0.05659752f, 0.31757724f, 0.13173212f, -0.23333292f, 0.10871194f, 0.13390027f, 0.07203271f, 
    0.07178427f, -0.03238581f, -0.00905197f, 0.19138131f, 0.16425638f, 0.28074768f, -0.05620625f, -0.07797279f, 
    0.02806858f, 0.03826371f, -0.02732714f, 0.09053263f, 0.22495365f, 0.22533010f, 0.13258974f, 0.13455950f, 
    0.03476970f, 0.02948429f, 0.06602184f, -0.08512773f, -0.00096682f, 0.13514647f, 0.16168830f, 0.00882046f, 
    -0.09932063f, 0.14079995f, -0.16273689f, -0.01175817f, -0.03424361f, 0.04540657f, 0.23082964f, 0.08134469f, 
    0.14561735f, 0.05100558f, -0.03608358f, -0.10872412f, 0.06052082f, -0.05698319f, -0.05488488f, -0.29230240f, 
    -0.37507010f, -0.07266764f, 0.15728448f, -0.09130005f, 0.09643006f, 0.09652115f, 0.03906757f, 0.05367819f, 
    -0.60276711f, -0.01792337f, 0.16476226f, -0.06685849f, -0.04767515f, -0.12257933f, 0.14555457f, 0.04355216f, 
    -0.05052816f, -0.19226201f, -0.16527379f, -0.07525226f, -0.06176026f, -0.02066135f, 0.06602094f, -0.01200943f, 
    0.15808797f, 0.12041289f, 0.11350754f, -0.04429487f, -0.24180117f, 0.15244755f, -0.06194887f, -0.12638654f, 
    -0.14538102f, -0.21587394f, 0.04670296f, -0.15592842f, -0.20104337f, -0.11722209f, 0.02709162f, 0.05421358f, 
    0.05658744f, 0.06757865f, 0.02066319f, -0.02913473f, 0.00111979f, 0.06723818f, 0.29322445f, -0.06590960f, 
    0.02765513f, 0.08453660f, -0.01338096f, -0.04974696f, 0.07877865f, -0.38514656f, -0.51390004f, -0.45365250f, 
    0.00876647f, -0.06333385f, -0.02432233f, 0.12247203f, 0.06412318f, 0.12118677f, -0.03407909f, -0.24748549f, 
    -0.58285457f, -0.22607411f, 0.09568364f, 0.09865452f, -0.09983494f, -0.04102635f, 0.04118834f, -0.16865721f, 
    0.14360872f, 0.17073609f, 0.10039548f, -0.12968944f, 0.03783695f, -0.05977990f, 0.10530925f, -0.14254457f, 
    0.00432211f, -0.10440680f, -0.23082206f, 0.05195053f, 0.05953407f, 0.11878748f, 0.05656679f, 0.04214136f, 
    0.02669462f, 0.00278049f, -0.01286537f, -0.13725169f, 0.05483250f, 0.03884744f, 0.07430027f, -0.04129540f, 
    -0.01219261f, 0.05746509f, 0.13870540f, -0.22719105f, -0.00081562f, 0.19513091f, 0.00926223f, -0.05800341f, 
    0.00539877f, -0.13137276f, -0.03143445f, -0.02115476f, 0.05965865f, -0.06869015f, 0.05582552f, 0.01356652f, 
    -0.04741253f, 0.06099152f, -0.03463650f, 0.06823131f, -0.12855279f, 0.08129378f, -0.10519070f, 0.09586254f, 
    -0.11503995f, 0.00087037f, 0.03361814f, 0.02938968f, 0.03721726f, 0.14330146f, 0.18870595f, 0.14421470f, 
    0.00609048f, -0.07917844f, -0.06130036f, -0.02010038f, -0.08418181f, 0.18659011f, 0.11557641f, 0.09780510f, 
    0.14993392f, 0.23310654f, 0.05952886f, 0.04083581f, 0.10759274f, -0.03193547f, -0.04855590f, 0.05644527f, 
    -0.13327339f, -0.25489539f, -0.03271959f, 0.01439681f, 0.02663759f, -0.21566631f, 0.16983725f, 0.01302466f, 
    -0.12421980f, -0.24448746f, -0.12667446f, 0.20306374f, 0.08823293f, 0.02960145f, -0.01065389f, -0.19249687f, 
    -0.12632032f, -0.02309870f, -0.17114811f, 0.08131305f, 0.10903880f, -0.02009812f, 0.05131353f, -0.14039345f, 
    -0.00692641f, 0.05340020f, -0.34651378f, 0.21819256f, 0.29869711f, 0.10485195f, 0.21304514f, -0.23193465f, 
    -0.07513601f, 0.04713994f, 0.16383885f, -0.26277465f, 0.01475492f, -0.09265991f, 0.03216444f, 0.04112457f, 
    0.10199760f, -0.04622667f, 0.10258941f, 0.09539608f, -0.02761278f, 0.35196382f, 0.06365104f, -0.00841253f, 
    0.04585733f, 0.11545656f, 0.10515889f, 0.20648468f, 0.13211483f, 0.10525263f, 0.47941899f, -0.18270440f, 
    -0.04444043f, 0.00397997f, 0.18424426f, 0.10274801f, 0.41702729f, 0.01538251f, -0.24169372f, -0.19268145f, 
    -0.03203789f, 0.02090965f, 0.15771130f, 0.01701591f, -0.01534721f, 0.00819365f, 0.04538915f, 0.01024298f, 
    -0.02698879f, 0.02493008f, 0.12574373f, -0.04809480f, -0.12281734f, -0.04163994f, 0.12129956f, 0.11132091f, 
    -0.18850885f, -0.07005463f, -0.03236935f, 0.09429868f, -0.08608977f, 0.02638178f, -0.23490179f, -0.12156572f, 
    -0.38422823f, 0.15294382f, 0.43456492f, -0.09812410f, 0.03303855f, 0.06225228f, 0.07963464f, 0.07860345f, 
    0.11166733f, 0.08019882f, 0.10803970f, 0.12679748f, 0.22169600f, 0.17161666f, 0.20663737f, 0.04560433f, 
    -0.04028309f, -0.12890370f, -0.38453075f, -0.04023300f, 0.03537132f, 0.28408906f, 0.05085910f, 0.03962492f, 
    0.12990166f, 0.22259595f, 0.06283909f, 0.32199395f, 0.03124364f, 0.00286500f, -0.12691943f, 0.11559747f, 
    0.01015379f, -0.08036891f, 0.05554424f, -0.00794459f, -0.44124481f, -0.04089648f, -0.17776793f, 0.14370361f, 
    0.01024901f, 0.05136161f, -0.00214871f, 0.12190095f, 0.01066531f, 0.23420085f, -0.18734457f, 0.09016010f, 
    -0.11297751f, 0.14374097f, 0.09760774f, -0.02726506f, -0.09592456f, -0.33426014f, -0.21650106f, -0.24116367f, 
    -0.08705221f, -0.07999084f, 0.10315846f, 0.00967116f, 0.09892161f, -0.16740748f, -0.17628630f, -0.16450322f, 
    0.11432496f, 0.15777776f, 0.19515440f, 0.26441261f, -0.14610732f, 0.04835533f, -0.00607409f, -0.08080973f, 
    -0.15979902f, 0.11748687f, 0.00785439f, -0.16741909f, 0.15452497f, 0.14326411f, 0.00091572f, 0.21043314f, 
    -0.10384576f, 0.14695318f, -0.07235006f, 0.15492123f, -0.12933636f, -0.00979838f, -0.13622671f, 0.13306484f, 
    -0.07546467f, -0.00149597f, -0.19145834f, -0.05351777f, -0.08403733f, 0.04001206f, 0.02024873f, 0.05040398f, 
    0.16768588f, -0.00946429f, 0.00631532f, 0.10899650f, -0.05041211f, 0.01091218f, 0.14254510f, 0.07908308f, 
    0.07613081f, 0.17644349f, 0.06303346f, 0.16322388f, -0.02828467f, -0.16594487f, -0.11271054f, 0.01312925f, 
    0.08153441f, 0.01440416f, -0.09815316f, -0.11811090f, 0.03533379f, -0.03737086f, -0.32101798f, 0.24352622f, 
    0.20447063f, 0.03407652f, 0.00843666f, 0.11792239f, 0.05824731f, 0.32026476f, 0.02095097f, -0.18069744f, 
    0.17918538f, -0.05567693f, 0.04037080f, -0.05045202f, 0.00547027f, -0.12826720f, -0.31406388f, -0.30141699f, 
    0.07817128f, 0.31155035f, -0.14433180f, -0.02641785f, -0.00465907f, 0.12113339f, -0.13411222f, 0.13071778f, 
    0.00065214f, -0.03613243f, 0.25177619f, 0.14544480f, 0.12676084f, -0.01054887f, -0.08885433f, -0.05357168f, 
    0.06858593f, 0.09752905f, -0.09132388f, -0.07308223f, 0.05614594f, 0.06598918f, -0.06002759f, 0.13377225f, 
    -0.15603717f, 0.04148874f, -0.06914179f, -0.09183508f, -0.28532508f, -0.05520318f, -0.00723311f, 0.05768749f, 
    0.00099133f, 0.14082126f, -0.13870423f, -0.04520726f, -0.17982364f, -0.20164374f, -0.38541839f, 0.05567407f, 
    0.12592681f, 0.04741858f, -0.13964909f, -0.38585287f, -0.28931233f, 0.02168775f, 0.00989249f, -0.03726503f, 
    0.13500588f, 0.22975147f, 0.13010526f, 0.12409259f, -0.14555661f, -0.26295567f, 0.14394097f, 0.08255859f, 
    -0.17577460f, 0.10539416f, -0.06564134f, -0.17550176f, -0.12650223f, -0.19556719f, 0.02583140f, 0.10723618f, 
    -0.13407484f, -0.09375697f, 0.15430400f, 0.06715814f, 0.11776488f, -0.27872396f, -0.09307203f, -0.05372889f, 
    -0.03394209f, 0.02336919f, 0.00596153f, -0.03215327f, 0.01886114f, 0.03533322f, 0.00041225f, -0.00880587f, 
    -0.03517812f, -0.05672237f, 0.03052798f, 0.04440711f, 0.04279359f, -0.02638603f, -0.02240782f, 0.00785259f, 
    0.04437752f, -0.02015957f, 0.02942164f, -0.00407816f, -0.05815631f, -0.02653845f, -0.03076833f, -0.06250623f, 
    -0.05975161f, -0.06985063f, -0.04192187f, 0.02802287f, -0.06903818f, -0.07017575f, 0.03082739f, 0.00285447f, 
    -0.05875527f, 0.01245034f, -0.04476474f, 0.04272601f, -0.00046477f, -0.02779320f, -0.03663116f, -0.01578406f, 
    -0.01561017f, 0.00598901f, 0.00033581f, -0.03224869f, -0.05368118f, 0.02126030f, 0.03375852f, -0.02901057f, 
    -0.04910154f, -0.03160992f, -0.05026986f, -0.03677538f, -0.05900031f, 0.01502470f, 0.02947404f, 0.00760540f, 
    -0.03787687f, 0.00022222f, 0.04311993f, -0.03440185f, 0.00178673f, -0.02063337f, -0.03731232f, -0.05736685f, 
    -0.02691847f, -0.05663127f, 0.00343978f, 0.01064195f, -0.00091486f, 0.04325865f, -0.00853494f, -0.03254097f, 
    0.04157451f, -0.00039538f, -0.05360146f, 0.04304646f, 0.01739222f, 0.04379611f, -0.06131562f, -0.04260455f, 
    0.04042937f, 0.01011477f, -0.05272109f, -0.05321913f, 0.03949440f, -0.01373952f, -0.02439123f, -0.06171945f, 
    0.00547888f, -0.06066568f, -0.00800457f, 0.03063964f, -0.02629531f, 0.04197911f, -0.05407664f, 0.00051997f, 
    -0.01789596f, -0.04439890f, 0.03022776f, -0.03250343f, -0.02635838f, 0.01694525f, -0.02195562f, -0.03099127f, 
    -0.01147893f, -0.00455604f, 0.01840297f, 0.03460804f, -0.04906952f, 0.00015181f, -0.04018341f, 0.05964741f, 
    -0.06471290f, -0.04063397f, 0.00960142f, 0.01681882f, -0.04753751f, -0.01093613f, 0.03599525f, 0.00343352f, 
    0.04964044f, -0.00196205f, -0.00594631f, 0.02896187f, -0.01068931f, -0.04828029f, -0.02043891f, 0.01250856f, 
    -0.02622420f, -0.02644826f, 0.04167523f, -0.00774613f, 0.01469170f, -0.04334928f, -0.03154013f, -0.03961061f, 
    0.00817927f, 0.01556731f, -0.06496830f, -0.04834046f, -0.03277469f, 0.02391624f, -0.05502943f, -0.00199803f, 
    0.02349905f, 0.04840706f, -0.06418782f, -0.04100465f, -0.04841359f, -0.04752944f, -0.00597114f, 0.00883034f, 
    -0.04469783f, -0.05054343f, -0.00953135f, -0.05238651f, 0.00682498f, -0.06050119f, -0.03010171f, 0.04531135f, 
    0.03058277f, -0.05482627f, 0.00175976f, -0.05703523f, -0.05036905f, 0.00724532f, -0.04399924f, -0.02893239f, 
    -0.02570365f, 0.03158754f, 0.01796361f, 0.04404542f, 0.00596079f, 0.01411942f, 0.00188927f, -0.01581298f, 
    -0.00874497f, -0.02337949f, -0.04469673f, -0.06387839f, 0.00416664f, 0.00405633f, 0.01002201f, 0.05206765f, 
    -0.01048330f, 0.02766885f, -0.03500654f, -0.02185910f, -0.05925373f, 0.03893120f, -0.00926902f, 0.01098407f, 
    -0.01165975f, -0.05021661f, -0.04112492f, -0.01493372f, -0.03161953f, -0.01127447f, -0.04465964f, -0.04829801f, 
    -0.01953142f, -0.06246300f, -0.02028351f, -0.04047107f, -0.01303327f, 0.00311708f, -0.04841017f, -0.00580401f, 
    0.01738123f, -0.00165366f, -0.01869332f, 0.03915288f, 0.01296047f, -0.00151316f, 0.04413760f, -0.00150607f, 
    0.02932226f, 0.04960026f, -0.05581985f, -0.02224519f, -0.00053005f, -0.04731273f, -0.06826993f, -0.04146352f, 
    0.00655412f, -0.00217777f, 0.02272592f, -0.03569909f, -0.01524103f, 0.04614000f, -0.02947993f, 0.02615832f, 
    0.05907951f, 0.04609811f, 0.02917408f, 0.03476746f, 0.00433134f, -0.06646200f, 0.02385561f, -0.00883906f, 
    -0.02593704f, -0.05686514f, 0.03361650f, 0.02539202f, -0.03007477f, 0.02084121f, 0.00727801f, 0.00780845f, 
    0.00643429f, -0.02630683f, -0.01773689f, -0.04758608f, 0.04898290f, 0.02464146f, -0.01315026f, -0.06338768f, 
    0.04957797f, -0.05402868f, 0.01984496f, 0.00477819f, 0.01848074f, 0.03316829f, 0.00545621f, 0.00871325f, 
    0.04995573f, -0.04987159f, 0.02191268f, -0.02874034f, -0.02956539f, -0.03324483f, 0.04313949f, 0.03758030f, 
    -0.02339654f, 0.05339009f, -0.03733531f, -0.00395948f, -0.06401062f, 0.03781880f, 0.02615324f, 0.03596297f, 
    -0.05672479f, 0.05001418f, -0.04991791f, -0.04625358f, -0.02881887f, -0.05728581f, -0.03202080f, 0.02314324f, 
    0.03648837f, -0.05939078f, -0.10266815f, -0.04370964f, 0.14303367f, 0.24472071f, 0.09721189f, 0.08549296f, 
    0.05108440f, 0.12450151f, -0.01240016f, -0.08240300f, 0.18113689f, 0.12899981f, 0.06128804f, 0.32871795f, 
    -0.11694651f, -0.10571346f, 0.20713764f, -0.06755078f, 0.11564435f, -0.28551748f, -0.27504206f, -0.20224427f, 
    0.26664260f, 0.13650204f, 0.06447733f, 0.09488622f, 0.13589026f, -0.01875270f, 0.00092962f, 0.02695808f, 
    -0.06662447f, -0.11063875f, -0.04217614f, 0.03032065f, 0.12601337f, -0.10945678f, 0.07464638f, 0.04953949f, 
    -0.08295292f, 0.07821435f, 0.27493194f, 0.01535400f, -0.05634921f, -0.05024265f, -0.28370595f, 0.10253648f, 
    0.25573561f, -0.04436376f, -0.16867344f, 0.05346578f, 0.05079954f, 0.21819168f, -0.09352137f, -0.10912555f, 
    -0.20203921f, -0.13608092f, -0.03527015f, -0.01248100f, 0.03316812f, 0.08018343f, -0.06590266f, 0.03235858f, 
    0.04469917f, 0.03508785f, 0.04384595f, 0.12347297f, 0.04381921f, 0.10641896f, -0.04366548f, 0.09564072f, 
    0.09220510f, -0.07170432f, 0.10679238f, -0.00156987f, -0.04107892f, 0.13196638f, 0.17283447f, -0.13270116f, 
    0.05057257f, 0.03464689f, -0.04324662f, 0.05264470f, 0.00836465f, -0.01228700f, 0.00324084f, 0.04853734f, 
    0.04576801f, 0.11484885f, 0.05657408f, 0.05711482f, 0.23073196f, -0.09373422f, 0.11588185f, -0.00736763f, 
    0.01690005f, 0.17315371f, 0.10902227f, -0.06051605f, 0.04182877f, 0.24171381f, 0.12499449f, 0.09028092f, 
    0.01345825f, 0.12215397f, 0.09913630f, 0.18721317f, -0.23026496f, -0.19886121f, 0.06276249f, -0.04961142f, 
    0.10811859f, -0.07561804f, -0.09064218f, 0.07556753f, 0.00411562f, 0.01956446f, 0.04840028f, 0.01530530f, 
    0.08429550f, 0.04396797f, 0.08549774f, 0.35768431f, 0.21941699f, 0.07924818f, 0.06912524f, 0.09286277f, 
    0.12535574f, -0.00234751f, 0.07254118f, 0.12638870f, 0.15500112f, 0.12685652f, 0.18402371f, 0.00020699f, 
    -0.00146156f, -0.05184947f, -0.01314029f, -0.03731154f, 0.11506414f, -0.01135447f, -0.09255458f, -0.17827746f, 
    0.05103790f, -0.17674726f, -0.05355433f, -0.13946824f, 0.06672420f, -0.02079236f, -0.01231362f, -0.01523833f, 
    0.01354080f, 0.11326977f, 0.24128416f, 0.01073989f, 0.21485882f, -0.05588246f, 0.06811651f, 0.09587508f, 
    0.06775296f, -0.07409608f, -0.08385113f, -0.12918477f, -0.16788436f, -0.05742303f, 0.06072280f, -0.00739164f, 
    0.08174128f, 0.10034721f, -0.12464342f, 0.18890890f, 0.00864524f, -0.12356789f, 0.18927661f, 0.03836345f, 
    0.03188194f, 0.30255383f, 0.03023956f, -0.00752953f, -0.16694389f, -0.04759083f, 0.17179960f, 0.03915638f, 
    0.02137330f, -0.09958968f, -0.02473510f, -0.00996629f, 0.06665868f, -0.12487905f, -0.01347138f, -0.17847410f, 
    -0.00117643f, 0.08817665f, -0.05870966f, 0.17109914f, -0.06357053f, -0.09004081f, -0.08738911f, -0.01840149f, 
    0.08668751f, -0.04568316f, -0.03931535f, -0.18107383f, 0.08868897f, 0.01562018f, -0.05931705f, 0.19812284f, 
    -0.08914466f, 0.19097190f, 0.06104931f, -0.01039505f, 0.13396581f, 0.06288940f, 0.07748570f, 0.27500159f, 
    0.20551085f, 0.02246143f, 0.17710474f, 0.14648613f, 0.12901151f, 0.04306073f, 0.09496110f, 0.12139188f, 
    0.11552283f, -0.11144503f, -0.00150304f, -0.01253592f, -0.11294390f, 0.03308129f, -0.31221840f, 0.07055657f, 
    0.02663422f, 0.11422808f, -0.01205050f, -0.02821671f, -0.14784777f, -0.06953895f, 0.03321375f, -0.03378198f, 
    -0.03650771f, 0.10306944f, 0.09447479f, 0.04722813f, 0.24745387f, 0.22983885f, 0.04221003f, 0.05873610f, 
    0.03226244f, 0.00609905f, 0.06516487f, 0.07635694f, -0.00781968f, -0.06762739f, 0.13165173f, 0.05263820f, 
    0.09495699f, -0.00865382f, -0.13304985f, -0.10717271f, -0.02970947f, -0.25436494f, -0.05668958f, 0.04430801f, 
    0.06021873f, 0.20120500f, -0.04955560f, -0.14357218f, 0.08990615f, 0.17379008f, 0.06925558f, 0.12883814f, 
    0.20727856f, 0.09103943f, -0.00658933f, 0.16603224f, -0.01205251f, 0.15247713f, 0.16161808f, -0.06474720f, 
    -0.06746522f, 0.00888771f, 0.05483058f, -0.03527764f, -0.03798352f, 0.09924147f, 0.03531455f, -0.12742102f, 
    -0.01271731f, 0.04686765f, -0.08519553f, -0.13620831f, -0.19928519f, -0.14968498f, 0.05859421f, 0.14207686f, 
    -0.03473442f, 0.22211875f, -0.07905426f, 0.15432921f, -0.18155569f, 0.03679987f, -0.14071673f, -0.02803442f, 
    0.06981678f, 0.08631231f, -0.54916078f, -0.23647137f, -0.13118626f, 0.07927655f, -0.08502009f, -0.02637227f, 
    -0.04905151f, 0.00553169f, -0.06307167f, -0.18964855f, -0.20653588f, -0.29336506f, 0.22733852f, 0.00853461f, 
    0.03362852f, -0.14660813f, -0.22430897f, -0.04490265f, -0.16440171f, 0.18471009f, -0.31320086f, -0.15367238f, 
    0.05770587f, 0.23974541f, 0.08763995f, 0.15707844f, 0.09378202f, 0.25323808f, 0.37292877f, -0.27163267f, 
    -0.15101533f, 0.16955738f, -0.15716192f, -0.05386002f, 0.01566308f, -0.07082055f, -0.02172940f, 0.01149404f, 
    -0.09851592f, 0.06423850f, 0.03926989f, -0.02495804f, 0.16357295f, 0.13128170f, 0.09007285f, 0.02246197f, 
    0.03105579f, 0.12717201f, -0.11260471f, -0.18444897f, -0.20080388f, -0.03447544f, -0.00383305f, 0.11553805f, 
    0.01146122f, -0.05762368f, 0.39210540f, -0.18455005f, -0.07469299f, -0.15269189f, 0.13948421f, 0.09539572f, 
    0.07411848f, 0.05196133f, 0.39724943f, 0.12766199f, 0.09142487f, -0.09100553f, 0.00027028f, -0.07528741f, 
    0.21845585f, -0.21339253f, -0.24502301f, 0.02387322f, 0.06682761f, 0.10854144f, -0.10722101f, 0.10309918f, 
    0.15807942f, -0.06897928f, -0.12414631f, 0.33996323f, 0.23462662f, 0.41128176f, 0.04315312f, -0.03138240f, 
    -0.03636938f, -0.00478028f, 0.09086125f, 0.13661852f, 0.01211457f, 0.26963100f, 0.11704899f, -0.05372131f, 
    -0.03086412f, 0.12321229f, 0.09467411f, -0.02042126f, 0.13017179f, -0.30472362f, 0.06360041f, -0.01692693f, 
    0.04672163f, -0.05292451f, 0.06236522f, -0.05854682f, 0.01848210f, -0.00956113f, -0.00732973f, -0.07707391f, 
    0.13774736f, -0.13453005f, -0.14831908f, 0.08305336f, 0.11488242f, 0.01245815f, 0.13484010f, -0.27667332f, 
    -0.64329851f, -0.10913064f, -0.00318071f, -0.04054302f, 0.11768971f, 0.13214143f, -0.11396739f, -0.06725715f, 
    -0.10451703f, -0.04387648f, 0.11612750f, -0.07539674f, 0.01426319f, -0.07430145f, 0.06224260f, 0.09647964f, 
    0.12610635f, -0.20330313f, -0.21024702f, 0.01658599f, 0.02441366f, -0.13056676f, -0.03955091f, 0.09950919f, 
    0.06410301f, 0.04367668f, 0.07388951f, -0.14497550f, 0.08607507f, -0.01657530f, 0.03812188f, 0.28681466f, 
    0.02561502f, 0.04968443f, 0.16144897f, 0.07817785f, -0.11183210f, 0.06214219f, -0.09072009f, -0.01101338f, 
    -0.02887501f, 0.05648807f, -0.02210795f, 0.22379398f, 0.29209435f, 0.06270761f, 0.34376991f, -0.10889146f, 
    -0.02148543f, 0.06305708f, -0.01322775f, -0.13109058f, 0.13410167f, 0.05736801f, 0.05730942f, -0.06594169f, 
    -0.35214111f, 0.01853718f, 0.08589350f, 0.00331880f, 0.10032992f, -0.01942242f, 0.24515510f, -0.36361897f, 
    -0.30397841f, 0.01608142f, 0.08467195f, -0.00105390f, -0.14006968f, -0.12117418f, 0.01322663f, -0.14225553f, 
    -0.24223699f, 0.03525179f, -0.05753677f, 0.13721094f, 0.20234098f, 0.00265158f, -0.04655223f, -0.08093731f, 
    -0.24522226f, -0.08089406f, 0.01763151f, 0.07808787f, -0.02834066f, 0.08876657f, -0.07106435f, 0.14764033f, 
    -0.03596475f, 0.10966784f, -0.17242990f, 0.17285897f, -0.13054065f, 0.08076264f, -0.14723098f, 0.03452949f, 
    -0.05525814f, 0.04030342f, -0.21209647f, -0.41106495f, -0.12036964f, -0.06481682f, 0.12679812f, -0.00118474f, 
    0.14366624f, 0.00428657f, -0.03191321f, -0.12639835f, -0.17401391f, -0.00567194f, 0.05782867f, 0.04124545f, 
    -0.01526085f, 0.09449165f, -0.10146546f, -0.11096919f, 0.15113437f, -0.06295204f, 0.04834201f, 0.02756659f, 
    0.00731972f, 0.08170839f, 0.04876627f, -0.03664795f, 0.15887149f, 0.16731761f, 0.16834150f, 0.38442209f, 
    0.00380028f, 0.01879464f, -0.15664753f, -0.06547452f, -0.24401779f, -0.08119461f, 0.13630965f, -0.08350052f, 
    0.05376525f, -0.15631855f, -0.06458779f, -0.03613955f, 0.09512107f, 0.00141826f, 0.12388179f, -0.15103211f, 
    -0.01526232f, 0.12509906f, -0.13687083f, -0.27782485f, 0.07322894f, -0.00550389f, 0.03079720f, 0.04830908f, 
    0.54260981f, 0.07469818f, 0.13688886f, -0.11139821f, -0.19313869f, -0.13253073f, -0.00797467f, 0.09075388f, 
    0.04343881f, 0.11821631f, -0.21834706f, 0.01166635f, -0.10806238f, -0.11350701f, 0.00636749f, -0.02547234f, 
    -0.07466450f, 0.07025024f, 0.71432036f, 0.28166446f, -0.09846660f, -0.10099331f, 0.18641981f, 0.10697208f, 
    0.26100689f, 0.03471228f, -0.01652756f, 0.13781370f, -0.24394399f, -0.04533975f, -0.05805260f, 0.03055174f, 
    0.05079258f, 0.14751174f, 0.09938443f, 0.00469685f, 0.13009392f, 0.01218453f, -0.06186429f, -0.01273650f, 
    0.24583422f, 0.23356487f, -0.11016470f, -0.05872194f, -0.09423472f, -0.02339367f, -0.23601803f, 0.05085804f, 
    -0.14815493f, 0.16770931f, -0.03436845f, -0.16390443f, 0.04341831f, 0.09241115f, 0.14352825f, -0.00607371f, 
    0.06191462f, -0.13145767f, -0.10504751f, 0.02933649f, 0.07015334f, 0.00568267f, -0.06079219f, 0.22319198f, 
    0.09624645f, -0.14912085f, -0.16773945f, -0.00459003f, -0.09919742f, -0.05978160f, -0.10129786f, 0.01451667f, 
    -0.11472192f, -0.17393453f, -0.22592311f, -0.05516293f, 0.00343629f, -0.05840437f, 0.09565119f, -0.04374994f, 
    -0.08027734f, -0.84121513f, -0.71515602f, -0.26410499f, -0.14241126f, 0.10686249f, -0.10263764f, -0.08118015f, 
    -0.03448406f, -0.12503403f, -0.30831230f, -0.41517773f, -0.26694575f, 0.01053001f, 0.20463619f, 0.04014316f, 
    0.09322611f, -0.07909247f, -0.04137862f, -0.30269456f, 0.14681712f, -0.08008625f, -0.02584570f, -0.00261261f, 
    -0.06939530f, -0.00457344f, -0.05466841f, -0.03123310f, -0.08564398f, -0.01595041f, -0.11740771f, 0.01541659f, 
    0.10547195f, 0.03711837f, -0.18878558f, -0.01938310f, -0.03177113f, 0.14936836f, -0.05367535f, 0.01898896f, 
    0.01979988f, 0.06680875f, -0.02083191f, 0.15626560f, 0.06184063f, 0.01904631f, -0.42106560f, -0.16175747f, 
    -0.39577907f, -0.01619367f, 0.13940011f, 0.03271459f, 0.17273954f, 0.03007485f, -0.05605282f, 0.00032479f, 
    0.19710480f, 0.02889678f, 0.09495974f, 0.12740822f, -0.08465821f, -0.21779509f, 0.01306243f, 0.16382661f, 
    -0.87904000f, -0.26066041f, 0.20565633f, -0.03455815f, 0.00926576f, -0.06357255f, 0.16758808f, 0.16955946f, 
    -0.09939158f, -0.01907778f, -0.04464550f, -0.05391661f, 0.07659136f, 0.20664093f, 0.21287479f, 0.24290366f, 
    0.20376106f, 0.07879904f, 0.08049727f, 0.07291053f, 0.19439429f, -0.18375938f, 0.00672296f, 0.16505274f, 
    0.11213736f, -0.09925974f, -0.02088152f, 0.05196974f, -0.08680535f, 0.18125875f, -0.12751791f, -0.03948808f, 
    -0.07022411f, -0.14740272f, -0.06053892f, 0.04648168f, -0.69394189f, 0.12629075f, -0.00288670f, 0.07016011f, 
    0.06262404f, -0.17891586f, -0.07718041f, -0.03302959f, -0.18717895f, 0.15287389f, 0.04297031f, 0.02807617f, 
    -0.27836898f, -0.16012754f, -0.26452819f, 0.01027882f, -0.21357362f, -0.00073803f, -0.21049592f, -0.20096655f, 
    0.02533602f, -0.07389251f, 0.10483739f, 0.06903759f, -0.03514337f, -0.06359065f, -0.13700825f, -0.15465955f, 
    0.06871880f, 0.10901836f, 0.11506262f, 0.10867295f, -0.00286454f, -0.22656755f, 0.02831621f, -0.03776783f, 
    0.24021187f, 0.04567023f, 0.09864268f, 0.26743680f, 0.10515133f, 0.27050674f, -0.07821909f, 0.20897421f, 
    0.09789632f, 0.14892399f, 0.04795687f, 0.15948485f, -0.12458029f, -0.15045810f, -0.00889889f, 0.17488454f, 
    0.07297003f, -0.04192805f, 0.22426823f, -0.00850197f, 0.05481261f, 0.14992709f, -0.02590908f, -0.02667274f, 
    0.01019557f, 0.11421650f, -0.01532198f, 0.17288694f, -0.00440097f, 0.02032007f, 0.07197884f, 0.09726825f, 
    -0.00952675f, 0.09552855f, -0.08322580f, 0.17206284f, 0.00812180f, -0.07722536f, -0.04601526f, 0.02460654f, 
    -0.03684772f, -0.10134770f, -0.25669983f, -0.03016479f, 0.03398701f, -0.62448406f, 0.14304967f, 0.08705070f, 
    -0.07823687f, 0.01291178f, -0.10720661f, 0.03960263f, 0.00368362f, 0.09886301f, -0.35267109f, -0.58844441f, 
    -0.49869287f, 0.03982352f, -0.02307086f, 0.10523608f, 0.01401867f, 0.08885118f, -0.00408917f, 0.37227103f, 
    -0.12637886f, -0.22072729f, -0.00979226f, 0.09365730f, -0.01240191f, -0.08370639f, -0.05719282f, -0.00272925f, 
    0.03290378f, 0.05570855f, -0.05033641f, 0.01537099f, 0.04210036f, -0.03103759f, -0.01027253f, -0.03474974f, 
    0.02389543f, 0.03157882f, -0.06037842f, -0.04029113f, -0.06355292f, 0.01574149f, 0.00717763f, 0.04799711f, 
    0.04892850f, 0.05033972f, 0.00165705f, -0.01681262f, -0.01492365f, 0.04924977f, -0.03398833f, 0.00957433f, 
    -0.02795345f, -0.02263726f, 0.06260069f, -0.01640621f, -0.00466724f, 0.03709843f, -0.00172598f, -0.05991580f, 
    -0.01022003f, -0.05441151f, 0.04468644f, -0.06250832f, -0.06114378f, -0.00478035f, -0.05291986f, -0.04620869f, 
    0.03620757f, -0.00435390f, 0.01745834f, -0.00509328f, -0.05405546f, -0.03538062f, 0.03212671f, 0.02693360f, 
    0.03707284f, 0.03906380f, -0.03287841f, -0.01550707f, -0.03873261f, 0.00150143f, 0.04310097f, 0.04833005f, 
    -0.01652559f, 0.02714564f, 0.03824823f, 0.02424851f, -0.00325280f, 0.00005271f, -0.00873144f, 0.00884011f, 
    -0.04357386f, -0.01259486f, -0.01646294f, -0.02155156f, -0.03351416f, -0.06141550f, -0.02113220f, 0.04287856f, 
    0.00962045f, -0.03631952f, 0.02014719f, 0.02363090f, 0.04816028f, -0.03953208f, -0.05812965f, -0.01535721f, 
    -0.04588654f, -0.02588145f, 0.05327729f, -0.02785596f, -0.05492932f, 0.02161315f, -0.01712921f, 0.02295690f, 
    0.00654994f, 0.03464161f, 0.02950934f, -0.05634444f, -0.03140785f, -0.05921838f, 0.04777548f, -0.05013380f, 
    -0.02103492f, -0.00524610f, 0.04785587f, 0.00308097f, -0.00820606f, 0.01345485f, -0.01988364f, 0.03977195f, 
    -0.05506421f, 0.02691076f, 0.04644144f, -0.01984221f, 0.04076851f, -0.05752696f, -0.05719002f, 0.04372197f, 
    -0.04795159f, 0.03553288f, -0.04816436f, -0.05997497f, -0.03288579f, -0.01560107f, 0.03464931f, 0.00534208f, 
    0.01723468f, -0.04604588f, 0.00010199f, 0.01230511f, -0.05006015f, -0.01891894f, 0.00954696f, 0.00362867f, 
    -0.04120175f, -0.05110530f, -0.01796883f, 0.00548313f, -0.03651298f, -0.06567091f, 0.02594326f, 0.05199522f, 
    -0.02615366f, -0.04647225f, -0.02740751f, -0.04118462f, 0.01574730f, -0.02116571f, -0.01278910f, -0.05481978f, 
    0.00461979f, -0.03475165f, 0.04204995f, 0.02769007f, 0.03426822f, -0.02241793f, 0.00059645f, -0.05591007f, 
    -0.05389823f, -0.04624566f, -0.03795186f, -0.03571957f, -0.03960710f, -0.00084998f, 0.01168482f, 0.04851347f, 
    0.01698517f, 0.00406348f, 0.04534313f, -0.01671655f, -0.03496167f, -0.00114881f, -0.03638624f, -0.03062914f, 
    0.03262848f, 0.00517726f, 0.00801360f, 0.03099478f, 0.02004712f, -0.00472284f, 0.00708623f, -0.04656989f, 
    -0.03757191f, -0.05321089f, -0.06857050f, -0.00680052f, -0.05195993f, 0.03112962f, -0.02228553f, 0.00762086f, 
    0.02091491f, -0.03902832f, -0.04773619f, 0.03630191f, 0.04829622f, -0.03799698f, 0.01730854f, 0.02975936f, 
    0.01885076f, -0.03184898f, -0.04436021f, -0.06559618f, -0.02839218f, -0.05916732f, 0.03281274f, -0.04132656f, 
    -0.03997701f, -0.02279980f, -0.04251448f, -0.05112638f, -0.00397228f, -0.03929527f, 0.02531263f, 0.01304449f, 
    -0.05001622f, 0.03067962f, 0.03883872f, -0.05069058f, -0.00220374f, 0.01467920f, -0.04744539f, 0.01391180f, 
    -0.03290972f, -0.02354953f, -0.04176474f, -0.05097136f, -0.05336287f, 0.02756657f, -0.06117515f, -0.01404547f, 
    -0.04220194f, 0.02594613f, 0.05461621f, -0.00305382f, -0.03177201f, 0.00752206f, -0.01231868f, 0.02801229f, 
    0.03090684f, 0.03929015f, -0.03348278f, -0.02249945f, 0.02449327f, 0.00372925f, 0.03481669f, -0.02535804f, 
    -0.05149153f, -0.03723032f, -0.02865582f, 0.03856723f, -0.00514530f, -0.05249364f, -0.00849163f, -0.06081448f, 
    0.02114239f, 0.04851993f, 0.01950952f, 0.02793575f, 0.04461627f, -0.03477062f, 0.03263374f, 0.02494548f, 
    0.04708369f, 0.00363065f, -0.05530174f, 0.04962700f, -0.05674791f, -0.05455062f, 0.00216488f, 0.00213831f, 
    0.03852722f, 0.04430478f, 0.00102729f, -0.05613850f, -0.06261782f, -0.06513901f, -0.03838135f, 0.00843357f, 
    0.00513856f, -0.03417378f, 0.02583328f, -0.06047760f, -0.01243629f, -0.06563339f, 0.03353265f, -0.03050369f, 
    -0.04380262f, 0.03974601f, -0.05949524f, -0.00090456f, -0.00132544f, 0.01563329f, -0.03797182f, -0.00586541f, 
    0.11671894f, -0.01493322f, 0.06748227f, -0.13331750f, 0.02989135f, 0.04534753f, 0.13523073f, -0.06912858f, 
    0.09350260f, -0.12673360f, -0.19079459f, -0.06059995f, -0.29036337f, -0.00225316f, -0.24208292f, 0.04606426f, 
    0.04437247f, 0.03243361f, -0.33895156f, 0.21202090f, 0.08565381f, -0.09666029f, 0.30284324f, 0.03246466f, 
    0.09602928f, 0.19349931f, -0.14853141f, 0.16308911f, 0.02955212f, 0.04233909f, 0.07200223f, -0.01683611f, 
    -0.07264018f, 0.07669812f, 0.08330727f, 0.12054116f, 0.38091305f, -0.08297682f, -0.25254050f, -0.09010792f, 
    0.25291765f, -0.06477189f, -0.09709037f, 0.04663264f, -0.05924452f, 0.36375365f, -0.02044965f, -0.10900291f, 
    0.12160593f, 0.00758230f, 0.08290648f, -0.27565280f, 0.19382043f, -0.21372068f, 0.04025456f, 0.06644063f, 
    0.13254987f, 0.10032652f, -0.01901945f, -0.25505209f, 0.00201432f, -0.03164472f, 0.05338964f, 0.10722827f, 
    -0.04058027f, -0.17399091f, -0.17037809f, -0.17254865f, 0.06620473f, -0.08099330f, -0.08712527f, 0.02482595f, 
    -0.05953251f, -0.00638749f, -0.07109812f, -0.20694700f, -0.12064371f, -0.10132710f, 0.04141976f, -0.06382407f, 
    0.06531131f, -0.12039038f, -0.26976740f, 0.00026118f, -0.11270563f, -0.11849904f, -0.08322313f, -0.02994368f, 
    0.08292527f, -0.13621299f, -0.30210426f, -0.04348003f, 0.22096354f, -0.00601145f, 0.18878917f, -0.10767014f, 
    0.06200857f, 0.12397403f, -0.07229454f, -0.18643710f, -0.04404452f, -0.04021576f, -0.05986845f, 0.12865028f, 
    -0.04002095f, 0.05925715f, -0.13385630f, -0.08157261f, -0.10012587f, 0.09922515f, -0.19616997f, 0.10755585f, 
    0.02216215f, 0.00901286f, -0.15430962f, 0.02614821f, -0.03671514f, -0.02874700f, 0.18375099f, 0.00146934f, 
    -0.03874491f, 0.07714906f, -0.10198588f, 0.00079635f, -0.06286495f, 0.06196206f, -0.42637381f, -0.01220555f, 
    -0.00266467f, -0.02427765f, 0.05476366f, 0.29360855f, 0.04790135f, 0.12915647f, -0.02200477f, 0.24864656f, 
    0.01633528f, -0.02092628f, 0.03383359f, -0.00767441f, -0.01803766f, -0.06690897f, 0.28903934f, 0.03715719f, 
    -0.32364500f, 0.09973565f, 0.63020414f, 0.06268898f, -0.04966575f, 0.09942949f, -0.10589930f, 0.09288475f, 
    0.03198268f, 0.28727248f, 0.24032149f, -0.00443308f, 0.05399423f, -0.02145634f, 0.06845325f, 0.03794328f, 
    0.28383845f, -0.00869855f, 0.18987694f, -0.00781988f, 0.05854347f, -0.00564653f, -0.01164071f, -0.16491276f, 
    -0.04634301f, 0.18376924f, 0.03616304f, 0.07189086f, -0.11735770f, 0.12795433f, -0.33913621f, -0.03375962f, 
    -0.23660938f, -0.03802205f, 0.10443399f, 0.01653935f, -0.28841415f, 0.11966474f, 0.41452286f, 0.13855712f, 
    0.06869468f, 0.03845571f, -0.04152810f, -0.13901941f, -0.10442238f, 0.24389593f, -0.06524958f, -0.14666417f, 
    -0.24712770f, -0.14750336f, -0.08690623f, -0.14284024f, -0.00679717f, 0.00228965f, 0.04152427f, -0.01758824f, 
    0.21952076f, -0.07719601f, -0.04462540f, -0.03251987f, -0.00814554f, 0.03515068f, -0.03812659f, -0.12964761f, 
    -0.15444013f, -0.11640760f, 0.05350016f, 0.02663449f, -0.09287962f, -0.06602892f, -0.04251453f, 0.03606083f, 
    0.16521859f, 0.20020267f, -0.11390040f, 0.00997532f, 0.01478531f, 0.07902519f, 0.12211453f, -0.06187518f, 
    0.18067703f, 0.18180171f, -0.37368411f, -0.22590999f, 0.08365917f, 0.01210936f, 0.12618789f, 0.03488444f, 
    -0.00283116f, -0.20798993f, 0.12158633f, 0.12833716f, 0.09810761f, 0.25764900f, -0.12048038f, -0.15325484f, 
    0.02106061f, -0.20936842f, 0.18741436f, 0.35610268f, 0.21961255f, -0.12936214f, -0.02739960f, -0.09848165f, 
    0.02628831f, -0.00889533f, -0.05689175f, 0.02256146f, 0.07141537f, 0.03594404f, -0.00170333f, 0.00883907f, 
    -0.01767451f, -0.12393294f, -0.09878998f, -0.10467391f, 0.12844977f, -0.19763115f, 0.01149770f, 0.14595588f, 
    -0.13615210f, 0.06393962f, -0.23389111f, -0.08227521f, 0.00149514f, 0.10025799f, -0.41937175f, 0.06859802f, 
    0.14076725f, 0.02669683f, 0.09088802f, 0.15734430f, -0.08327585f, 0.15633415f, -0.02905220f, -0.11002255f, 
    -0.10788486f, -0.18535760f, -0.39505041f, 0.12385692f, 0.11883523f, 0.01016785f, -0.03819275f, -0.03990155f, 
    0.02747324f, 0.03802709f, -0.01583945f, 0.04499772f, -0.03524569f, -0.01308534f, -0.03335574f, -0.05178399f, 
    -0.04913832f, -0.02508440f, 0.03556411f, 0.03304389f, 0.00608709f, -0.04686663f, -0.00188106f, -0.05312175f, 
    0.04241245f, 0.03344275f, -0.05481971f, -0.06185664f, -0.00491830f, -0.00578373f, 0.01178107f, 0.01887177f, 
    0.03754570f, -0.02028786f, 0.02885871f, -0.02512719f, -0.06544726f, 0.01151113f, -0.00868282f, 0.04979315f, 
    0.01232505f, 0.00230616f, -0.01037622f, 0.02138727f, -0.03366612f, -0.06360607f, -0.04009091f, 0.05180513f, 
    0.01223452f, 0.00163116f, 0.02642599f, -0.03069752f, -0.01099592f, -0.04503932f, -0.03025624f, 0.04345768f, 
    0.02411692f, -0.02267988f, -0.05386039f, -0.02106699f, 0.03250962f, -0.00592320f, 0.04695374f, -0.05014061f, 
    0.03547774f, -0.06745073f, -0.01145287f, -0.06911817f, 0.01441198f, -0.03032495f, 0.00824782f, -0.03313393f, 
    -0.04870156f, 0.01136142f, -0.04126921f, 0.03153153f, -0.00685695f, -0.05428121f, 0.00630084f, 0.00462701f, 
    -0.05731170f, -0.00938574f, 0.04866476f, -0.06686173f, 0.02678669f, 0.01536680f, -0.05167462f, 0.02599006f, 
    -0.02924997f, -0.04917072f, 0.00857712f, -0.04211683f, 0.03512356f, -0.05329262f, -0.07000569f, -0.02266410f, 
    0.01914035f, -0.03922408f, -0.00271942f, 0.04808345f, 0.03059953f, 0.01545642f, 0.00746778f, -0.03398907f, 
    -0.03733892f, -0.00747244f, 0.01552700f, 0.00217083f, 0.04944135f, 0.02145286f, 0.01598572f, 0.03194714f, 
    0.02565783f, -0.04793641f, 0.00639256f, -0.05763548f, 0.00260285f, 0.00757559f, -0.01247411f, 0.04044419f, 
    -0.02072363f, 0.02412925f, 0.00307454f, -0.01453455f, -0.00750210f, -0.01929240f, -0.02942245f, -0.06272135f, 
    -0.01319381f, 0.00609703f, 0.02811522f, -0.03264899f, -0.04100998f, -0.02353841f, -0.02260221f, 0.05395214f, 
    -0.04834979f, -0.00527619f, -0.04605717f, -0.01843939f, 0.00607154f, -0.06048276f, -0.02686336f, 0.03216812f, 
    0.04511067f, -0.05401462f, 0.04759925f, 0.00118349f, -0.00829173f, 0.03933905f, -0.05564439f, -0.05251269f, 
    0.05606070f, 0.01188311f, -0.01125214f, -0.02578369f, -0.01310497f, -0.03671912f, -0.07731189f, -0.02851169f, 
    -0.02854445f, -0.02287621f, -0.03031410f, -0.01139419f, 0.00324379f, 0.03062253f, -0.03354225f, 0.04590425f, 
    -0.00654761f, -0.02205565f, 0.01202289f, 0.00271965f, 0.02364995f, -0.01971948f, 0.03684428f, 0.00285203f, 
    -0.04689697f, 0.03541794f, -0.03551055f, -0.04441474f, 0.04178425f, -0.03252418f, 0.00506814f, -0.04547196f, 
    0.00807844f, 0.03771764f, -0.05024966f, 0.04011492f, -0.01117729f, 0.00386075f, -0.00971753f, -0.00974426f, 
    0.01085652f, -0.04539144f, -0.02798247f, -0.03817326f, 0.03067810f, -0.06376716f, 0.04421126f, 0.03577411f, 
    -0.03698504f, 0.01631887f, 0.00759800f, -0.02143697f, -0.06594301f, -0.00650931f, -0.05939829f, 0.03588979f, 
    -0.03803612f, -0.01865917f, -0.03311346f, 0.03673432f, 0.01726194f, 0.04142359f, -0.00080199f, 0.02924338f, 
    -0.01022626f, -0.00848038f, 0.00586559f, -0.03186170f, -0.02093825f, 0.04350381f, -0.06556972f, -0.00048086f, 
    -0.04267564f, 0.01348628f, -0.03333139f, 0.02786614f, 0.03897781f, 0.01461606f, 0.01979319f, 0.02402363f, 
    -0.02146146f, 0.00945510f, -0.04963707f, 0.00263037f, 0.03259282f, -0.00213701f, -0.05990484f, -0.01803730f, 
    0.03868306f, 0.01013030f, -0.02449482f, -0.05711130f, -0.04508660f, 0.04519730f, -0.00577068f, -0.06856645f, 
    0.03093105f, 0.01658236f, 0.03579066f, -0.04247656f, -0.06703882f, -0.01571909f, -0.00166691f, 0.03447638f, 
    0.01606689f, -0.06299182f, 0.02698830f, -0.04461267f, -0.03686215f, -0.01139190f, -0.04958220f, 0.04589256f, 
    0.01505602f, 0.02391603f, 0.04201910f, 0.00325577f, -0.07098013f, 0.05094890f, 0.00280810f, 0.04067943f, 
    -0.05126978f, -0.03354087f, -0.02609185f, -0.01871124f, -0.04116862f, -0.03568270f, 0.05118569f, 0.04924074f, 
    -0.01943261f, -0.02683047f, -0.01303451f, 0.04472367f, -0.07339665f, -0.03026858f, -0.06714049f, -0.05892917f, 
    -0.04394460f, 0.00744978f, 0.05077752f, -0.06383175f, 0.01420323f, -0.02482926f, -0.03597388f, 0.00692257f, 
    -0.24648917f, -0.28847980f, 0.18680747f, -0.06356441f, 0.01194813f, -0.08108377f, -0.06761478f, 0.02016516f, 
    0.10865576f, -0.27522600f, -0.37445450f, 0.11579622f, -0.14968716f, 0.04942091f, -0.12767516f, -0.20064129f, 
    -0.12868892f, -0.05516642f, 1.29296958f, -0.50213647f, -0.47338128f, -0.06039441f, -0.19516458f, -0.09742695f, 
    -0.04371533f, -0.24039468f, -0.04600150f, 0.45176655f, 0.20226859f, -0.09625428f, 0.12717949f, 0.03079936f, 
    0.13871758f, 0.01566403f, 0.09157169f, 0.09320151f, 0.14909194f, -0.11433320f, -0.37108129f, 0.03660309f, 
    -0.01365900f, 0.11709125f, 0.10804126f, 0.10266322f, 0.08079153f, -0.08047759f, -0.30775589f, -0.33919856f, 
    -0.05777497f, -0.24513622f, 0.05618565f, 0.07034513f, 0.00049518f, -0.00803928f, -0.08660326f, 0.25617114f, 
    0.36645138f, -0.11928868f, 0.06896243f, -0.17439041f, 0.06309015f, 0.03062569f, 0.13546158f, -0.35562387f, 
    -0.16380496f, -0.23769735f, -0.06420138f, 0.21367817f, 0.10585245f, 0.23525247f, 0.06120202f, 0.17859477f, 
    -0.19298896f, 0.09600525f, -0.22977366f, -0.16311912f, -0.00027675f, -0.08216959f, -0.05233197f, -0.03726688f, 
    0.00560691f, 0.04411656f, -0.22253628f, -0.30615395f, -0.05503638f, -0.17064561f, 0.04438224f, 0.14870389f, 
    -0.03858085f, -0.08588296f, 0.71461147f, -0.10626743f, -0.00696364f, 0.09417196f, 0.04575530f, 0.03384346f, 
    0.05346809f, 0.02252076f, 0.05092627f, 0.05212584f, -0.09524396f, 0.09833930f, 0.04135237f, 0.04834579f, 
    0.01907160f, 0.05012050f, 0.09622280f, 0.02116225f, -0.06131271f, 0.01727272f, 0.04191916f, -0.02102832f, 
    -0.08879420f, -0.12904505f, 0.14622608f, 0.11902981f, 0.15290262f, 0.36070588f, 0.10381497f, -0.17543645f, 
    0.07453723f, 0.12267175f, 0.01905376f, 0.06424107f, 0.11389851f, 0.07790195f, -0.11606392f, 0.08340052f, 
    -0.09780355f, -0.08539220f, -0.03457285f, 0.03292385f, -0.02672979f, 0.05056653f, 0.02071985f, -0.30879638f, 
    0.06603413f, 0.23691572f, -0.06359304f, -0.04683438f, -0.04455971f, -0.02050619f, 0.02242287f, 0.01679523f, 
    -0.09452609f, -0.18074287f, 0.18350524f, 0.01605510f, -0.11570586f, -0.19501786f, 0.05219953f, 0.19558705f, 
    0.06302950f, -0.22258849f, -0.30297622f, 0.06773306f, -0.07583882f, -0.15085696f, -0.05730677f, 0.17913134f, 
    0.19571708f, 0.04449995f, 0.13866395f, 0.20018229f, 0.00851339f, -0.07600003f, -0.21348907f, -0.20609537f, 
    -0.01164954f, 0.04710486f, -0.20897928f, -0.11230999f, -0.00111188f, 0.12608360f, -0.08596569f, 0.04971528f, 
    -0.01290457f, -0.08548668f, 0.07289821f, 0.05806050f, -0.03550507f, -0.30432031f, 0.19567850f, -0.12577836f, 
    -0.14861140f, -0.29218134f, -0.12000210f, -0.18305713f, -0.01270100f, -0.35317937f, -0.24848293f, -0.08411892f, 
    -0.01929212f, 0.01976385f, -0.20249961f, 0.00528518f, -0.14918151f, 0.22104268f, 0.57325512f, -0.32002455f, 
    -0.01990253f, 0.00276022f, -0.03881974f, -0.13987641f, -0.01383348f, 0.01119555f, 0.11151946f, -0.25248951f, 
    0.24920058f, 0.18887052f, 0.05429560f, -0.18670686f, 0.15225220f, 0.05540866f, 0.08381707f, 0.02853812f, 
    0.41163537f, -0.04838295f, -0.14960012f, 0.04765025f, -0.01190087f, 0.14450078f, 0.22040555f, 0.03018384f, 
    0.13891512f, -0.05150835f, -0.42852437f, -0.02187795f, -0.11066427f, -0.18393372f, -0.14651591f, 0.09517912f, 
    -0.22507277f, 0.06017109f, 0.07048030f, 0.24810363f, 0.12035322f, 0.08146168f, 0.05557221f, -0.10631539f, 
    0.04528537f, 0.07655104f, 0.18340430f, -0.03657386f, -0.17388727f, 0.06727336f, 0.02633588f, 0.15849388f, 
    0.02637559f, 0.20692271f, 0.03257482f, 0.02037197f, -0.18105866f, -0.06703690f, 0.09237326f, -0.06724993f, 
    -0.14708962f, -0.20178004f, -0.00203498f, 0.00311861f, 0.04607651f, -0.08704032f, -0.13876927f, 0.09456678f, 
    -0.03714449f, 0.17721134f, -0.02002503f, 0.03317859f, -0.09978653f, 0.07449716f, -0.15103698f, 0.07284588f, 
    -0.13233265f, 0.01333611f, -0.02520166f, 0.02056524f, 0.10035111f, -0.00199657f, 0.00781530f, -0.47797620f, 
    -0.26248375f, -0.02505346f, -0.13114284f, -0.05510362f, -0.21061641f, 0.07412783f, 0.07959755f, 0.01531426f, 
    -0.00964212f, -0.02288762f, -0.06662843f, 0.00117145f, -0.03144515f, -0.05854443f, -0.03229600f, 0.03641810f, 
    -0.04699052f, 0.00623689f, 0.02012952f, 0.04120703f, -0.04705795f, 0.05421709f, -0.00302207f, -0.06047228f, 
    0.03331859f, -0.04817263f, -0.04348285f, 0.03512959f, 0.03884007f, -0.05481041f, -0.04882457f, 0.01794208f, 
    0.01660931f, -0.00385878f, -0.02146703f, 0.03977327f, 0.03533651f, 0.02841036f, -0.02190574f, -0.04752219f, 
    -0.04619750f, 0.02881782f, 0.03305463f, -0.03311847f, -0.06658330f, 0.00108977f, 0.02248741f, -0.03601550f, 
    0.01230676f, -0.02143596f, 0.03179307f, 0.00971825f, -0.01373468f, 0.03278200f, 0.01533797f, -0.00423464f, 
    -0.01770951f, 0.03225414f, 0.01251214f, 0.01742867f, -0.01813014f, -0.04319754f, -0.01243319f, 0.03726057f, 
    0.03021657f, -0.02287608f, 0.00394099f, -0.03153855f, 0.01575981f, -0.02937971f, -0.03470697f, 0.01999002f, 
    -0.00871364f, 0.01164034f, 0.00007300f, 0.01192396f, 0.03579162f, -0.05026004f, -0.06875112f, 0.04591886f, 
    0.00138124f, -0.02044485f, -0.05561167f, -0.04584265f, 0.01945470f, 0.04086321f, -0.05814131f, -0.02766420f, 
    -0.02492524f, -0.04039887f, -0.02043393f, -0.03014053f, 0.03791892f, 0.01593239f, -0.05649130f, 0.03862595f, 
    -0.02434369f, 0.00341668f, -0.03757091f, 0.05370672f, -0.03991866f, 0.04459151f, 0.01322546f, 0.03843716f, 
    0.01305935f, 0.03808880f, -0.02407666f, 0.04332497f, -0.00336641f, 0.00788035f, -0.00154783f, -0.06010542f, 
    -0.05011412f, -0.02477065f, 0.01329132f, -0.02598190f, 0.05420832f, -0.01003948f, 0.02554214f, -0.05279289f, 
    0.02886618f, -0.00475432f, 0.01942132f, 0.03754202f, -0.04026040f, 0.03826622f, 0.04305286f, -0.04514158f, 
    -0.02489479f, 0.00259293f, -0.00203884f, 0.01536563f, -0.02523846f, 0.02116086f, -0.03795457f, -0.02096091f, 
    0.00514330f, -0.04198490f, -0.06516331f, -0.05341101f, -0.03164192f, -0.03970655f, 0.01225609f, -0.07000753f, 
    -0.07136502f, 0.03047031f, 0.03231003f, 0.04674025f, -0.04043306f, -0.05400320f, 0.02679232f, 0.02008036f, 
    -0.01480029f, 0.04505297f, -0.05181894f, -0.04055706f, -0.00135144f, 0.00161071f, -0.02265247f, 0.01844216f, 
    0.01085562f, -0.06393117f, 0.01152398f, -0.03916571f, -0.04252058f, -0.04270382f, -0.04139016f, -0.06432900f, 
    0.00013898f, 0.00057039f, 0.04199161f, -0.02344646f, 0.00979679f, -0.01536880f, -0.04658042f, -0.02077723f, 
    0.01143358f, 0.02644652f, -0.00147038f, 0.00143527f, -0.01103431f, -0.02384630f, 0.02573156f, 0.01422333f, 
    -0.01209161f, -0.03606069f, -0.02528599f, 0.00791310f, 0.03258399f, 0.03274145f, 0.04907181f, -0.06545074f, 
    0.04647982f, -0.01524312f, 0.03412692f, -0.03845496f, -0.05694607f, 0.04415203f, -0.05263704f, -0.06718215f, 
    -0.01835292f, -0.04431878f, 0.04008253f, -0.01903752f, -0.05159513f, -0.00656971f, 0.02648400f, 0.02098957f, 
    0.00556960f, 0.03348577f, -0.05912491f, -0.01430129f, -0.02877757f, 0.03641294f, -0.05993508f, -0.06192001f, 
    -0.02560155f, -0.06238379f, -0.00892703f, -0.00213190f, 0.02517323f, -0.04615476f, -0.00160010f, -0.00764612f, 
    0.01734809f, -0.00603984f, -0.03478220f, 0.00617499f, 0.01950742f, -0.02233265f, -0.05321692f, 0.04292046f, 
    0.01890083f, -0.02073227f, -0.01164757f, -0.02429893f, 0.00089476f, 0.05271928f, 0.00100327f, -0.05975857f, 
    -0.06343753f, -0.03118258f, 0.01052804f, -0.00323106f, -0.01104462f, 0.02773424f, 0.00860519f, 0.04277128f, 
    0.00007219f, -0.03363952f, -0.05577825f, 0.04904064f, -0.01631252f, -0.02511080f, 0.00148035f, -0.05430955f, 
    -0.06525378f, 0.02100004f, -0.06258406f, -0.03312537f, 0.03873294f, -0.00470084f, 0.03621636f, 0.02284327f, 
    -0.04679085f, -0.06438681f, -0.05103084f, -0.01135135f, -0.01311973f, -0.00903426f, 0.00046626f, -0.03582382f, 
    -0.03271057f, 0.04386934f, -0.00365294f, 0.03420452f, -0.02478188f, 0.01872189f, -0.01865431f, 0.02849071f, 
    0.02873043f, -0.04352102f, 0.04338320f, 0.00827144f, -0.04558553f, -0.01379533f, 0.03115127f, -0.03496728f, 
    0.04699243f, -0.02471543f, 0.04234950f, 0.03824841f, 0.00098207f, -0.03553024f, 0.02717507f, -0.05749209f, 
    0.01110029f, 0.04033409f, -0.01989644f, 0.00532814f, -0.00356135f, -0.00569680f, 0.03560295f, -0.04564304f, 
    0.03193394f, -0.03753982f, 0.00826955f, -0.00234040f, 0.03168922f, 0.02047795f, -0.05780019f, 0.00653661f, 
    -0.04814217f, 0.03760264f, 0.02665374f, -0.01109791f, 0.00908718f, -0.00588357f, -0.00536720f, 0.00806103f, 
    0.00589537f, -0.03610022f, 0.02148172f, -0.02729622f, 0.01483443f, 0.01242484f, -0.02298337f, 0.02833279f, 
    -0.05897236f, 0.04176774f, 0.00896682f, -0.04660365f, -0.05002661f, -0.06317642f, -0.03966426f, -0.00793756f, 
    -0.06312847f, -0.01852871f, -0.03322932f, -0.02428420f, 0.00408756f, 0.03605742f, 0.03857497f, -0.06115871f, 
    -0.04461819f, -0.06416418f, -0.05685508f, 0.01203219f, 0.01820658f, -0.00393616f, 0.00398412f, 0.01690089f, 
    0.03521223f, -0.00458011f, -0.04231649f, -0.06883910f, 0.00694608f, -0.07009578f, -0.04484277f, -0.02773419f, 
    -0.04790087f, 0.01943042f, -0.03215866f, 0.00644829f, 0.03001201f, -0.03278419f, -0.00319182f, -0.04845128f, 
    -0.05185609f, -0.04705104f, 0.02830530f, -0.01421262f, 0.04302282f, -0.06241374f, -0.03517872f, -0.04376889f, 
    0.03761426f, 0.02639818f, 0.01500070f, -0.00420530f, 0.02028383f, 0.00565613f, -0.03940484f, -0.03659158f, 
    -0.00477881f, -0.03153175f, -0.04924283f, -0.05828926f, -0.03085535f, 0.05892089f, -0.04159097f, -0.05259917f, 
    -0.05184862f, 0.00932476f, -0.04516133f, -0.03589505f, -0.05342958f, -0.06971870f, 0.03899261f, 0.00826561f, 
    -0.02284164f, -0.06517412f, -0.05863250f, -0.04907884f, -0.05823188f, 0.04213421f, -0.05512219f, -0.00180212f, 
    -0.01965497f, -0.02043909f, 0.04400147f, 0.00847044f, 0.03712495f, -0.04657846f, 0.03554359f, -0.05478487f, 
    -0.04707256f, 0.01548433f, 0.02088392f, 0.03852488f, 0.01184679f, -0.00958416f, -0.00917220f, -0.02310183f, 
    0.02468944f, -0.04329078f, -0.03781224f, -0.06372818f, -0.01143858f, 0.00003085f, -0.04382223f, -0.03493341f, 
    -0.03013973f, 0.00636309f, -0.05437132f, -0.01480196f, 0.02809196f, -0.04194465f, -0.03200702f, -0.05029995f, 
    -0.01240632f, -0.01044913f, -0.01072061f, 0.04003886f, -0.01492742f, 0.02630241f, 0.00175934f, -0.02407581f, 
    -0.03031799f, 0.02783975f, -0.07219081f, -0.05734938f, 0.00776631f, -0.00283910f, 0.03880972f, 0.02308219f, 
    0.00863068f, 0.00898355f, -0.04133428f, 0.01074717f, -0.04200461f, -0.06091753f, -0.02093758f, -0.02514884f, 
    -0.03252577f, -0.05079589f, -0.03763120f, -0.04268190f, -0.03869282f, -0.05061644f, -0.05240956f, 0.04273915f, 
    -0.07291608f, -0.06699046f, -0.04370387f, -0.02657508f, 0.02311145f, 0.01350096f, -0.03028434f, 0.04688140f, 
    0.04235745f, -0.00258648f, -0.00894060f, -0.06039432f, 0.00235938f, -0.04644685f, 0.01280484f, 0.04004601f, 
    0.01255352f, -0.06565806f, 0.03530313f, 0.01584724f, -0.01949141f, -0.05625692f, 0.02989925f, -0.04015290f, 
    0.00198553f, -0.05725361f, 0.00910403f, -0.06615146f, -0.05270990f, -0.03599898f, 0.04020847f, -0.05666032f, 
    0.01453876f, -0.03659925f, 0.03099786f, -0.04206247f, -0.04489895f, -0.02121620f, -0.02433378f, -0.00033861f, 
    -0.02395285f, -0.03940594f, -0.07009174f, -0.03639291f, -0.06620883f, -0.04915760f, -0.04123104f, -0.05702757f, 
    -0.03989948f, -0.04026918f, 0.01578065f, 0.01287958f, -0.00274643f, 0.01026101f, 0.00139810f, 0.02909070f, 
    -0.00686146f, -0.04837814f, -0.05065519f, -0.07250869f, 0.00001180f, 0.04456993f, 0.03671566f, -0.03920587f, 
    0.02346407f, 0.01304878f, -0.02735929f, -0.06669154f, -0.02120046f, -0.03665273f, 0.04340815f, 0.03195547f, 
    -0.02982833f, 0.00346151f, -0.02566893f, -0.03826735f, 0.02621402f, 0.02474657f, 0.02827242f, -0.02043644f, 
    -0.04758236f, -0.00519065f, -0.01319721f, 0.02193824f, -0.02499761f, 0.04035942f, 0.00888620f, -0.00140282f, 
    -0.03513536f, 0.01336843f, -0.03119390f, -0.03629028f, -0.01361633f, -0.05052847f, 0.02801808f, -0.02934948f, 
    -0.03433990f, -0.03056745f, -0.04478060f, -0.04604533f, -0.05877405f, 0.00137399f, 0.02539868f, 0.01847231f, 
    0.01790999f, -0.00085511f, -0.02930686f, -0.06018653f, 0.02554180f, 0.04319102f, 0.02998795f, 0.01291981f, 
    -0.01524978f, -0.02781385f, -0.00780182f, -0.05038710f, 0.04288122f, -0.00821213f, -0.05048116f, 0.04356109f, 
    0.03401952f, 0.01845904f, 0.00597202f, 0.00378436f, -0.05689318f, 0.04318020f, -0.04930194f, -0.02669219f, 
    0.04034217f, -0.00701031f, 0.06388097f, -0.05154901f, 0.01568548f, 0.01445720f, 0.00281625f, 0.02586110f, 
    0.04752325f, -0.01725095f, -0.00872202f, 0.03053401f, 0.03366783f, -0.04072340f, -0.00373829f, -0.01135900f, 
    0.02398794f, -0.00644410f, -0.05836894f, 0.04121429f, 0.03445129f, -0.03088392f, -0.03678431f, 0.01408934f, 
    0.00626956f, -0.02762404f, 0.04142271f, -0.01100830f, 0.04581288f, -0.02684030f, -0.02040564f, -0.06019694f, 
    -0.03299335f, 0.02373785f, 0.01763874f, -0.01167178f, -0.05244765f, 0.01245128f, 0.04951000f, -0.03403962f, 
    -0.05553946f, -0.03837183f, 0.04723210f, -0.05418672f, -0.06355345f, -0.02058162f, -0.04698424f, 0.03959577f, 
    0.00402958f, 0.03903528f, -0.02494611f, -0.02249457f, -0.01532748f, 0.02218690f, 0.02224342f, -0.04484592f, 
    0.02131052f, 0.02407471f, -0.02264460f, 0.05348109f, 0.04959890f, -0.01951138f, 0.02989888f, -0.02499458f, 
    -0.06281041f, -0.03504462f, 0.04164616f, -0.03014677f, 0.03016914f, -0.01238600f, -0.04509242f, -0.05862095f, 
    -0.01534481f, 0.05000117f, 0.03053714f, -0.06253175f, -0.04612469f, 0.02242294f, 0.03133387f, -0.03473980f, 
    0.04994881f, -0.04350234f, -0.00218327f, -0.05383590f, -0.04272778f, -0.05414169f, -0.02136403f, -0.02918913f, 
    0.00192623f, -0.00875062f, -0.02827093f, -0.00106584f, 0.00709580f, -0.02461250f, -0.03604072f, 0.00101980f, 
    0.02806993f, -0.01404056f, -0.02887723f, -0.03350561f, -0.01188886f, -0.04905907f, -0.03991347f, -0.04382579f, 
    -0.05700574f, -0.05885046f, 0.00274604f, -0.03648501f, -0.00993994f, -0.04848167f, -0.05106771f, 0.00320155f, 
    0.00010318f, -0.02922371f, 0.04191380f, -0.05267525f, -0.00299659f, 0.00567340f, -0.05483489f, -0.01894720f, 
    0.00411170f, 0.04595846f, -0.03760116f, -0.00903197f, -0.06090211f, -0.01170194f, 0.05078725f, 0.02666357f, 
    -0.03925969f, 0.00325584f, -0.01202220f, -0.03340742f, 0.04620024f, -0.01595915f, 0.02279227f, -0.02388115f, 
    -0.01529612f, -0.03653039f, 0.03384611f, -0.05634087f, -0.02781109f, -0.04502030f, -0.02868452f, -0.01271714f, 
    0.01427825f, 0.02638079f, -0.03481252f, 0.03391553f, 0.04571288f, -0.03357885f, -0.04918449f, -0.01967029f, 
    0.02653573f, -0.00182642f, 0.03234626f, -0.02594436f, 0.00341745f, 0.00423808f, -0.01102030f, 0.05270386f, 
    0.03361633f, -0.00441265f, 0.04755582f, 0.04142222f, 0.01957322f, -0.03748403f, -0.02824827f, 0.04203888f, 
    -0.00858159f, -0.03248762f, 0.02049426f, 0.02722034f, -0.04505213f, -0.04701217f, 0.00138628f, -0.03721222f, 
    0.00632807f, 0.00436204f, 0.03225471f, 0.00430006f, 0.04173055f, 0.04351436f, 0.02539847f, 0.00728766f, 
    0.02838147f, 0.02347548f, 0.01433057f, -0.03473200f, -0.02581047f, -0.06088703f, 0.01815536f, 0.00098755f, 
    -0.01663195f, -0.00348190f, -0.01709109f, 0.02006993f, -0.05106719f, 0.02817575f, 0.00218648f, -0.05062073f, 
    0.01667486f, 0.02406152f, 0.03566406f, -0.05681514f, -0.01532014f, 0.05204702f, -0.00459739f, -0.01608063f, 
    0.04360798f, 0.02515844f, 0.04002405f, -0.05732641f, 0.05069769f, -0.04507447f, -0.04304168f, -0.03524452f, 
    0.04923388f, 0.03063536f, -0.05521699f, 0.01517434f, 0.02662224f, 0.05573572f, -0.04590981f, 0.04512285f, 
    -0.02928463f, 0.03003687f, -0.00347171f, 0.01249429f, -0.03443326f, 0.05271142f, -0.03882269f, -0.02027816f, 
    0.05162196f, -0.01793221f, 0.01092415f, 0.03684666f, -0.02730389f, 0.02136394f, 0.03793655f, 0.04664849f, 
    -0.05559713f, -0.02990992f, 0.00945260f, -0.06066458f, -0.03191247f, -0.00531358f, 0.03741441f, 0.03955428f, 
    -0.01338781f, -0.00229699f, -0.05324049f, -0.02722658f, -0.02931356f, -0.00888651f, -0.06237349f, 0.00522463f, 
    -0.00551601f, -0.02571360f, 0.00126800f, 0.01337962f, 0.04858847f, 0.02732548f, 0.04559527f, -0.01403739f, 
    0.04287197f, -0.05920526f, -0.04414064f, 0.05740647f, 0.00564858f, -0.02913957f, -0.06268653f, -0.03826433f, 
    -0.36352703f, 0.09169989f, 0.17410697f, 0.12324009f, 0.06586929f, 0.16353537f, -0.17780292f, 0.02773003f, 
    0.31663460f, -0.11944544f, -0.03312053f, -0.00997940f, 0.13839141f, 0.14467812f, -0.10523335f, -0.02937902f, 
    -0.02350434f, -0.00380942f, 0.33521429f, -0.03532882f, -0.21981682f, 0.10076428f, 0.11442647f, 0.37201181f, 
    0.04396292f, -0.11850296f, -0.17226826f, 0.41322210f, 0.17893320f, -0.10708589f, 0.04566624f, -0.07678560f, 
    -0.08810563f, 0.08846935f, 0.16665764f, 0.08180835f, 0.47442693f, -0.16105841f, -0.05873895f, 0.17661591f, 
    -0.02962445f, 0.26386625f, 0.01948299f, -0.07559005f, 0.02464309f, -0.04563175f, -0.42584431f, -0.17067774f, 
    0.18720324f, -0.06185168f, 0.10976506f, -0.16140372f, 0.08831490f, 0.11502279f, 0.28360286f, 0.19264260f, 
    0.15338919f, -0.16027883f, -0.14288679f, -0.11110698f, -0.04647059f, 0.12860006f, 0.03928939f, -0.11450172f, 
    0.08511553f, -0.11417909f, -0.10405961f, 0.02834998f, -0.01617406f, -0.27399600f, -0.08602860f, 0.03484222f, 
    -0.51142192f, -0.24244615f, -0.31432644f, 0.09543283f, 0.20668481f, -0.06324568f, -0.26586351f, -0.10702341f, 
    0.22204204f, -0.25384855f, -0.20188038f, -0.48394793f, 0.01602631f, -0.09103776f, 0.03955875f, -0.01100988f, 
    -0.03418696f, -0.18123721f, 0.05193520f, -0.12749085f, -0.03925760f, -0.10048202f, 0.00449502f, 0.23180187f, 
    0.01250587f, 0.09419245f, -0.12369641f, -0.41814673f, -0.18704700f, 0.04397633f, 0.06087555f, 0.08005921f, 
    -0.16757846f, 0.04144221f, 0.03382138f, -0.08342931f, -0.04789271f, -0.01151549f, -0.18237570f, -0.20938429f, 
    -0.10130366f, 0.03978375f, -0.03602286f, 0.02266091f, -0.05076870f, 0.02658076f, 0.06163051f, -0.19328003f, 
    0.08636189f, 0.19490848f, 0.14239398f, 0.12649877f, 0.00562136f, 0.01066350f, -0.17136887f, -0.27311191f, 
    -0.04744626f, -0.04397134f, 0.11465521f, 0.09480954f, -0.04168569f, -0.02534555f, 0.23880427f, 0.13261960f, 
    -0.00648685f, -0.08114128f, -0.14853515f, 0.00382886f, -0.10903081f, 0.10145531f, 0.05628136f, 0.08545899f, 
    0.06504887f, 0.18585065f, -0.05662271f, -0.13038112f, 0.07634743f, -0.04539983f, -0.05385192f, 0.17453100f, 
    0.21614857f, 0.03238212f, 0.25150022f, 0.21299429f, -0.00329197f, -0.11963496f, -0.08925717f, 0.15848707f, 
    0.24405511f, 0.03750312f, 0.27968493f, -0.11829640f, 0.14744137f, 0.06865048f, -0.14508787f, 0.05135996f, 
    0.09042092f, 0.19828713f, 0.05907689f, 0.07546611f, 0.11209287f, -0.22322391f, 0.19685337f, 0.20984523f, 
    -0.08125398f, 0.02531736f, -0.01400440f, -0.01826818f, -0.26143879f, -0.26284024f, 0.28720713f, 0.24020354f, 
    0.07212028f, -0.25803816f, 0.13269128f, 0.17285305f, -0.03188514f, 0.04079016f, 0.04562609f, -0.45762134f, 
    0.01625350f, 0.03347679f, -0.04763170f, -0.05498889f, -0.19535379f, -0.07497371f, 0.02938707f, -0.02768811f, 
    0.06441814f, 0.06352291f, 0.10346578f, -0.11809839f, 0.11884988f, 0.03360491f, -0.07000010f, 0.02504982f, 
    -0.11598012f, -0.04217520f, -0.05574053f, -0.09399948f, 0.02247809f, 0.08764251f, -0.13817436f, 0.13139638f, 
    0.24246064f, -0.02515814f, 0.04838618f, 0.12160574f, -0.04992956f, 0.01579865f, 0.03061261f, 0.19874698f, 
    0.20429066f, 0.12730132f, -0.67173094f, 0.16073030f, 0.08607687f, -0.03552150f, -0.05245459f, 0.06674927f, 
    0.07992603f, -0.01544774f, 0.11335079f, 0.26493877f, 0.28722566f, 0.01222371f, -0.25483382f, -0.11139216f, 
    0.03828683f, 0.13889953f, 0.11060110f, 0.18879679f, 0.08826906f, -0.02091271f, -0.12027792f, 0.03835810f, 
    -0.22193031f, 0.08997343f, 0.04745455f, 0.09399759f, -0.03829972f, 0.12372966f, -0.20069346f, -0.02056474f, 
    -0.04889828f, -0.23608275f, 0.05961334f, -0.08866134f, -0.06938331f, -0.49669799f, -0.16039397f, 0.04816248f, 
    -0.13499744f, -0.00076964f, -0.21470854f, -0.04610626f, 0.02696922f, 0.14530990f, -0.24121577f, -0.28403142f, 
    0.42324090f, 0.14211221f, -0.02294423f, -0.05781545f, -0.11260458f, 0.17429738f, 0.10744554f, -0.16604209f, 
    -0.02386095f, -0.06180371f, -0.39219949f, -0.02893434f, 0.05417760f, -0.05243683f, -0.07415084f, 0.02891932f, 
    0.08870335f, 0.19435136f, -0.04754662f, 0.02770906f, -0.05838885f, -0.05992576f, -0.03722667f, 0.09435096f, 
    0.22468632f, -0.11844546f, 0.22954351f, 0.15707931f, -0.06684405f, -0.03888431f, 0.03615684f, 0.05035778f, 
    0.10972442f, 0.09005677f, 0.30351740f, 0.35362056f, -1.02449048f, 0.13335191f, -0.01343804f, 0.16651395f, 
    0.00969430f, -0.19081225f, -0.16374983f, 0.22116473f, -0.30407479f, 0.03333595f, 0.15220743f, 0.13003795f, 
    0.12829280f, 0.07878561f, 0.13538422f, 0.04828747f, 0.17300676f, 0.00118172f, 0.00521831f, 0.28457743f, 
    -0.21792285f, 0.06445427f, 0.00984200f, -0.08061890f, -0.13852461f, -0.20821474f, -0.79053319f, -0.23855992f, 
    0.01623147f, 0.01110573f, -0.18361481f, -0.06137827f, -0.08816449f, -0.23954263f, 0.00563646f, -0.07734225f, 
    0.01350381f, -0.02385798f, -0.01652674f, -0.15197477f, -0.01354479f, -0.01449818f, 0.09138726f, -0.09890825f, 
    0.18589269f, 0.24221611f, -0.07630739f, -0.08360329f, 0.16995797f, 0.10599297f, 0.05924201f, 0.06913445f, 
    -0.24462563f, -0.08705715f, 0.22248992f, -0.01919174f, -0.03039644f, -0.06572300f, -0.02162892f, 0.10223790f, 
    0.20040086f, -0.30771530f, 0.00317134f, -0.36080354f, -0.10347017f, -0.05576027f, -0.10930671f, -0.00471481f, 
    -0.08323692f, -0.14958750f, -0.10161383f, -0.02586032f, -0.29346105f, -0.05277694f, 0.07215037f, 0.06487782f, 
    -0.08485314f, -0.00861681f, 0.11410207f, -0.06844616f, 0.03128977f, 0.00339390f, 0.07090015f, 0.02085068f, 
    0.00191068f, -0.09597816f, 0.03020011f, -0.12310687f, 0.00012490f, -0.03289898f, -0.18780857f, -0.05641245f, 
    -0.08773404f, -0.08374519f, -0.04357545f, 0.05138878f, 0.04179268f, 0.29954585f, 0.23515938f, -0.26449880f, 
    0.18033738f, 0.12001833f, 0.07289273f, 0.09083889f, 0.05419118f, -0.01782012f, 0.31286374f, -0.04674716f, 
    0.27218252f, 0.02399410f, -0.01654822f, 0.02635223f, 0.03966637f, 0.01249912f, 0.14285080f, -0.08601685f, 
    0.05131999f, 0.06537133f, 0.02795334f, -0.02916844f, -0.04806498f, -0.05425872f, -0.03644326f, 0.13875921f, 
    -0.06073141f, -0.33895165f, -0.55134362f, -0.06822152f, -0.11692362f, 0.19156361f, -0.07925124f, 0.12059785f, 
    0.19943111f, 0.03902694f, -0.33439502f, 0.02087176f, -0.01166902f, 0.11120449f, 0.12471478f, 0.12855467f, 
    0.13633884f, 0.11001097f, -0.12830518f, -0.06783658f, -0.07767192f, -0.04163481f, -0.21194804f, 0.13554296f, 
    0.06958473f, -0.07680605f, 0.06232208f, -0.04743230f, -0.00774883f, 0.10320594f, 0.00528055f, 0.04297086f, 
    0.14419961f, 0.07503008f, 0.02580001f, 0.02974578f, -0.30661604f, -0.35094967f, -0.00382403f, -0.07670464f, 
    0.04232277f, -0.02060287f, -0.03865916f, -0.04815975f, -0.00229091f, -0.16247793f, -0.07909522f, 0.01817002f, 
    -0.15635636f, -0.22105457f, 0.01251981f, 0.18767309f, 0.08155438f, 0.06690874f, 0.26890534f, -0.79219216f, 
    -0.26188260f, 0.03307358f, 0.10058169f, 0.05794877f, 0.18756971f, 0.00134876f, -0.02324762f, 0.14575651f, 
    -0.00038842f, -0.25139004f, 0.06273835f, 0.08806217f, -0.17052644f, -0.00498384f, 0.00486530f, 0.12790363f, 
    0.29458788f, 0.16493706f, -0.13477543f, 0.05031847f, 0.00893605f, 0.03243998f, 0.20409283f, -0.17261942f, 
    0.24423006f, -0.48882231f, -0.42092565f, 0.46650147f, -0.22558379f, -0.14435381f, -0.03693442f, 0.02543437f, 
    -0.11386903f, 0.10944600f, -0.01572612f, -0.13789514f, -0.07820122f, 0.14794484f, 0.00264195f, -0.10094037f, 
    0.03717698f, -0.06871633f, 0.18071948f, 0.00709204f, -0.47898704f, 0.10280856f, 0.10882084f, 0.15276289f, 
    -0.03632642f, 0.17348112f, 0.07368440f, -0.00387152f, -0.22243781f, -0.08330809f, -0.43689379f, 0.00113244f, 
    0.05622959f, -0.08392669f, 0.08890893f, 0.03182110f, 0.16426203f, -0.14921571f, -0.57720876f, -0.37526181f, 
    -0.05210618f, -0.11423467f, -0.18499865f, 0.08423697f, 0.04465309f, 0.03740996f, -0.02364826f, -0.03768340f, 
    0.23504703f, -0.03741390f, -0.12156401f, -0.02330523f, -0.00702479f, 0.13117200f, 0.05944081f, 0.07354907f, 
    0.36982286f, -0.06028091f, -0.25938833f, -0.11182781f, -0.22083741f, -0.04990990f, -0.02647564f, 0.07742441f, 
    -0.02371027f, -0.00302423f, 0.04404172f, -0.04079306f, 0.03842008f, -0.04927550f, -0.03707793f, 0.01623763f, 
    0.04724901f, -0.01003749f, 0.02882240f, 0.03961901f, 0.02320396f, 0.01451604f, -0.02566500f, -0.04665017f, 
    0.05275802f, 0.05385501f, 0.03452143f, -0.04223792f, -0.01200056f, 0.01298479f, 0.00434439f, 0.04556956f, 
    0.04306777f, -0.02190105f, -0.05312473f, 0.01456433f, 0.04927927f, 0.04454249f, -0.03982624f, 0.04092097f, 
    -0.03748168f, 0.01086764f, -0.04273601f, -0.02838417f, -0.04567489f, 0.04890244f, 0.05192640f, 0.01845406f, 
    -0.05668775f, -0.04170768f, 0.04899833f, -0.01887842f, 0.05034152f, -0.05780775f, 0.03775434f, -0.01315028f, 
    0.01440488f, -0.03248025f, -0.01757276f, 0.05328174f, -0.05248194f, -0.06280098f, -0.00369814f, -0.05612181f, 
    0.00586721f, -0.01100256f, -0.02186766f, -0.03795540f, -0.01249809f, -0.04970688f, -0.00074464f, 0.01274760f, 
    0.01464329f, -0.01388474f, -0.03009443f, 0.04295964f, -0.03594256f, 0.01987502f, -0.03984592f, 0.04892578f, 
    0.04556570f, -0.05533070f, 0.02197652f, -0.04473922f, -0.06534135f, -0.02886911f, 0.01894969f, 0.02780972f, 
    0.00961957f, -0.01133656f, 0.01928088f, -0.01907818f, -0.03479851f, 0.03593582f, -0.01201567f, -0.00867027f, 
    -0.03620363f, -0.00326524f, -0.00200695f, 0.00158400f, -0.04447510f, 0.03481634f, 0.00222606f, 0.01551468f, 
    -0.03776895f, 0.01438054f, 0.05181348f, -0.03455146f, -0.00038297f, 0.00295242f, -0.00483019f, -0.00730146f, 
    -0.04421625f, -0.03896136f, -0.00117672f, 0.01883102f, 0.03994485f, -0.02241070f, -0.00573044f, 0.05105790f, 
    -0.03128131f, -0.05451992f, -0.04512630f, 0.00919082f, -0.03112018f, 0.02173132f, 0.00997325f, -0.03649510f, 
    -0.04242221f, 0.02678238f, 0.00282648f, -0.02755737f, -0.05556747f, -0.05494148f, 0.02567283f, 0.01546898f, 
    -0.05309911f, 0.01602538f, 0.02522961f, 0.00684908f, -0.02026249f, -0.04857495f, -0.02681901f, -0.02343889f, 
    0.05227441f, -0.05834683f, 0.04550231f, -0.00604556f, 0.04316689f, 0.00897868f, 0.04398861f, 0.01304246f, 
    0.01881396f, -0.03647879f, -0.03943061f, 0.02796488f, -0.03198035f, -0.05146698f, -0.03654825f, -0.05249652f, 
    -0.04422980f, -0.01741214f, 0.05003619f, -0.05338045f, -0.02271997f, -0.06082136f, 0.03210774f, -0.04409000f, 
    -0.02334484f, 0.01553727f, 0.00788374f, -0.04552382f, -0.05120382f, -0.02569154f, -0.02525334f, -0.01494466f, 
    0.02422983f, -0.03263114f, 0.03194409f, 0.02790647f, -0.00736624f, -0.05975344f, -0.04893863f, -0.04711760f, 
    0.01306076f, -0.03294476f, -0.05210073f, -0.05525728f, 0.03025390f, -0.02737154f, -0.00407101f, 0.00490421f, 
    0.03085405f, -0.00427890f, -0.02725081f, -0.01731429f, -0.06022076f, 0.00380028f, -0.02882350f, -0.01702568f, 
    0.01450989f, -0.05132183f, 0.03238223f, -0.01500131f, 0.01191848f, -0.00920855f, 0.01050313f, -0.04220211f, 
    0.02552596f, -0.02846060f, 0.04687579f, 0.05131441f, 0.02237274f, -0.03820334f, 0.04831026f, 0.00923308f, 
    -0.00624065f, -0.04609259f, -0.00965904f, -0.05370585f, -0.00462483f, -0.01554496f, 0.00241829f, 0.01641265f, 
    -0.02480890f, -0.01672222f, 0.01090651f, 0.03129303f, -0.04679098f, 0.02288802f, 0.01436286f, 0.03713187f, 
    -0.01434165f, -0.03672190f, 0.03650232f, -0.01730344f, 0.00651930f, -0.02168815f, -0.03602755f, 0.00179736f, 
    -0.06048690f, 0.03560136f, -0.05481150f, -0.00379552f, -0.01229172f, 0.01226463f, 0.02713091f, -0.04904219f, 
    -0.00244531f, 0.04048266f, -0.00661884f, 0.00356681f, 0.04411332f, 0.01789946f, -0.01414381f, 0.00842149f, 
    0.00664017f, 0.00858450f, -0.05128260f, 0.04350027f, 0.04380821f, 0.04233968f, 0.03176169f, 0.04946868f, 
    -0.06005673f, 0.04436150f, 0.02472850f, -0.01302672f, -0.02941348f, -0.01468796f, -0.01981338f, -0.00259482f, 
    -0.00245820f, -0.05155068f, -0.04017528f, -0.00351935f, 0.05039586f, 0.03914046f, -0.03656800f, -0.05488732f, 
    0.01163944f, -0.06577897f, -0.02248705f, 0.00485571f, 0.03108677f, -0.00200646f, -0.06256379f, 0.04099546f, 
    0.05491385f, -0.06196906f, -0.04593980f, -0.04797854f, 0.04526955f, -0.04648524f, -0.00831935f, -0.05415676f, 
    0.28156829f, -0.18015291f, 0.17534852f, -0.04629366f, -0.32435700f, 0.01641691f, -0.00674538f, 0.06643137f, 
    0.12805234f, 0.06958504f, 0.08483403f, -0.05688030f, -0.23651142f, -0.11824556f, -0.07312615f, -0.04205438f, 
    -0.01828595f, -0.10559040f, -0.13794088f, -0.16963820f, -0.01841617f, -0.15628049f, 0.00151572f, 0.02085680f, 
    0.12861796f, 0.09279774f, 0.24375241f, -0.13543898f, -0.22116883f, -0.16896540f, 0.10080890f, 0.03275474f, 
    0.11722197f, 0.03740944f, -0.15298626f, 0.09417655f, -0.09887531f, 0.32885203f, -0.04842242f, -0.09954068f, 
    0.08499824f, 0.21474607f, 0.10632195f, -0.11993692f, -0.12418990f, -0.17065158f, 0.16456196f, -0.15652491f, 
    -0.05199704f, 0.25634131f, 0.13877697f, 0.06054526f, 0.00361730f, -0.09789507f, -0.12539968f, -0.04230832f, 
    -0.01811439f, -0.02181101f, 0.03835136f, -0.09218770f, 0.06034349f, 0.09474029f, 0.22085200f, 0.09234761f, 
    0.13922819f, 0.02256582f, -0.02523346f, 0.13046366f, -0.27184311f, 0.10577070f, -0.04420725f, -0.12457983f, 
    0.21869747f, 0.16855723f, 0.10079937f, 0.07208093f, -0.08033217f, -0.31390095f, 0.10263732f, -0.12896034f, 
    0.17717735f, -0.33859023f, 0.15902154f, -0.17091037f, 0.08091774f, -0.17870218f, -0.03196815f, 0.00749385f, 
    0.03690255f, -0.01340444f, -0.35173389f, -0.15428066f, -0.32297647f, 0.04734764f, -0.01482171f, -0.07158736f, 
    0.04256805f, 0.20453225f, -0.20029929f, 0.25171316f, 0.03742813f, 0.10937093f, -0.25737673f, -0.04274725f, 
    0.06766684f, 0.08371592f, 0.07518444f, 0.09196170f, 0.16644147f, 0.01613434f, -0.20176573f, 0.02371358f, 
    0.03169606f, 0.06482226f, 0.03499209f, 0.11014144f, 0.12351584f, 0.08562720f, 0.02099057f, 0.20968135f, 
    0.06338514f, 0.00168634f, 0.19034363f, -0.03329211f, -0.05812599f, 0.15812983f, 0.20374821f, 0.04504241f, 
    -0.13090570f, 0.02508714f, 0.05835144f, -0.12072229f, 0.03423679f, -0.23710756f, 0.11800974f, -0.02823583f, 
    -0.17736851f, -0.07999587f, 0.16490845f, -0.01765450f, -0.02096893f, 0.09917250f, -0.05324640f, -0.02451115f, 
    -0.22632393f, 0.03715297f, 0.08672015f, 0.05339631f, -0.13599752f, -0.05176679f, 0.00395219f, 0.20931120f, 
    0.17111711f, -0.03130167f, -0.12646343f, 0.11128288f, -0.03749750f, -0.01513187f, 0.10910770f, 0.24000320f, 
    0.16946127f, -0.01126053f, -0.00911826f, -0.02068305f, 0.10522855f, -0.21527372f, -0.15117967f, 0.15968199f, 
    0.07662200f, 0.08668758f, -0.10102309f, -0.06862121f, 0.09960427f, 0.00165296f, 0.01607899f, -0.09060222f, 
    -0.04645508f, 0.11116456f, -0.02004976f, -0.08298670f, -0.01502983f, 0.05564282f, 0.29160097f, -0.20180061f, 
    -0.15571198f, 0.04805481f, 0.03761345f, -0.04063895f, -0.05990831f, -0.12757549f, 0.31015620f, 0.06049265f, 
    -0.22764254f, 0.14704092f, -0.27247947f, 0.09898702f, -0.01839810f, -0.04490285f, 0.19103943f, 0.05368773f, 
    -0.32935268f, -0.05006128f, -0.02758407f, 0.10261019f, -0.14492841f, 0.17109202f, 0.03046073f, 0.10845152f, 
    -0.16183993f, -0.30880478f, 0.06210249f, -0.01097556f, -0.02672823f, -0.10441927f, -0.17390217f, -0.02534505f, 
    -0.00647435f, 0.09633581f, 0.11326255f, 0.19506834f, 0.06033116f, 0.13961278f, -0.19400322f, -0.01130244f, 
    -0.24689277f, -0.05546679f, -0.17302866f, -0.04168615f, -0.07591108f, 0.25233105f, 0.08328422f, 0.09659962f, 
    -0.08353408f, -0.22500564f, -0.00256398f, -0.37011030f, -0.07751145f, -0.11601243f, 0.07465883f, 0.06270359f, 
    -0.03557635f, 0.14886594f, 0.22263639f, 0.23892473f, -0.36021277f, 0.04391903f, 0.05414044f, 0.08489895f, 
    0.06536525f, 0.09174020f, -0.02042010f, -0.20647135f, -0.00699234f, -0.30064783f, -0.07704490f, 0.02897520f, 
    0.01651460f, -0.07197231f, -0.10325307f, 0.11034063f, 0.11994158f, -0.05501290f, -0.00733956f, -0.13749427f, 
    -0.06408938f, 0.09289382f, -0.24477804f, 0.08438823f, 0.00861097f, 0.07267129f, 0.07891168f, -0.20694505f, 
    -0.32758865f, -0.19390878f, 0.17831776f, -0.04507491f, 0.05464111f, -0.01726237f, 0.06614281f, -0.07322945f, 
    -0.19688709f, 0.10482799f, -0.00177219f, -0.16125977f, 0.21086013f, -0.01874426f, -0.11841846f, -0.05926872f, 
    0.04037700f, -0.05951438f, -0.01387372f, -0.06433147f, -0.04566965f, -0.05901247f, 0.04636758f, 0.03143986f, 
    -0.05608327f, 0.03391427f, 0.03066203f, 0.03047933f, -0.03475005f, 0.03568199f, -0.04119954f, -0.03360689f, 
    -0.02073651f, -0.01871082f, -0.04552015f, -0.04050792f, 0.03879814f, 0.05918993f, 0.02793683f, 0.03485907f, 
    -0.02513973f, 0.03534383f, -0.03643819f, -0.03521162f, 0.00150925f, -0.05822559f, -0.01778855f, 0.02211274f, 
    -0.03858179f, 0.01169897f, -0.01683304f, -0.01771167f, 0.00004896f, -0.05939176f, -0.00553167f, 0.04788357f, 
    -0.02615249f, 0.00109931f, -0.05411953f, -0.05359881f, 0.03680347f, -0.02598158f, 0.03545584f, -0.02497190f, 
    0.02272720f, -0.06836329f, -0.00480457f, -0.05430482f, -0.05245930f, -0.02456191f, 0.03153641f, -0.04138006f, 
    -0.01034486f, -0.03988219f, -0.04967722f, -0.04474934f, -0.03039723f, -0.00561220f, 0.03350552f, -0.06020536f, 
    0.03065795f, -0.05673503f, 0.00779232f, -0.04916172f, 0.03258215f, -0.02629852f, -0.04026533f, 0.01850270f, 
    0.04300338f, -0.05676584f, 0.00400999f, -0.00914468f, 0.04911133f, -0.04577615f, 0.04953476f, 0.02321080f, 
    0.04812121f, 0.03721628f, 0.05366894f, -0.04411171f, -0.05380346f, 0.00895887f, -0.01445154f, 0.05441331f, 
    -0.05481851f, 0.01475391f, -0.03338600f, 0.01919910f, -0.05163964f, -0.01555735f, -0.05889831f, -0.00670765f, 
    -0.04673846f, 0.03359830f, 0.02755938f, -0.05947616f, -0.05836566f, -0.01433509f, 0.01935070f, 0.05071706f, 
    0.00257709f, -0.04925682f, 0.01472684f, 0.00745332f, -0.00453108f, -0.00688792f, -0.01490636f, -0.02572336f, 
    0.04086468f, 0.00481396f, -0.05211403f, -0.00066279f, -0.01713731f, 0.01174378f, 0.00731054f, 0.00426642f, 
    0.02747995f, 0.00620083f, 0.03915101f, -0.03620446f, -0.03178718f, -0.02028112f, 0.04218959f, -0.04609087f, 
    0.04388518f, -0.04891536f, -0.04355606f, -0.02187444f, -0.05968358f, -0.04735399f, -0.04421636f, -0.01710792f, 
    -0.03083131f, -0.02449474f, 0.02889457f, 0.00197227f, -0.01415902f, 0.00894839f, -0.05618757f, 0.01471190f, 
    0.02399181f, -0.00126430f, 0.03776061f, 0.02634915f, -0.01849585f, -0.00945028f, 0.03273965f, -0.04046232f, 
    0.04085919f, 0.00791520f, -0.01321259f, 0.04076385f, 0.01661329f, -0.04137287f, 0.03758872f, -0.01817855f, 
    0.02593527f, -0.03632212f, 0.02345785f, -0.03127507f, 0.05399686f, -0.02106127f, -0.06257188f, -0.06535002f, 
    0.01077725f, -0.00580174f, -0.00709237f, 0.02764090f, 0.03003646f, 0.00665842f, -0.00255427f, -0.04491246f, 
    -0.01514338f, 0.01030362f, -0.02871668f, -0.03194461f, 0.01164798f, 0.01820810f, -0.03838477f, -0.00720691f, 
    -0.00968181f, 0.00414131f, 0.00989864f, -0.00987227f, 0.04002211f, -0.00450218f, 0.02317910f, 0.02163730f, 
    -0.06249111f, 0.00154424f, -0.07063488f, 0.03498698f, 0.05478125f, -0.02562045f, 0.04410145f, -0.03247742f, 
    -0.04498110f, -0.03219469f, 0.00891376f, 0.01467987f, -0.02228128f, -0.05193198f, -0.06129514f, 0.04989764f, 
    -0.02013448f, 0.00671896f, 0.02219729f, 0.00431650f, 0.02064154f, -0.05776998f, -0.02885888f, 0.04587829f, 
    0.04586194f, -0.03236898f, -0.02667585f, 0.04811133f, -0.04752887f, 0.03729071f, 0.01549468f, -0.02018349f, 
    -0.03834107f, 0.04849203f, -0.00883651f, 0.00834657f, 0.02375598f, 0.02872776f, -0.02170347f, 0.05265851f, 
    0.01391016f, -0.02549796f, 0.00853902f, -0.04282570f, 0.04866384f, 0.00881722f, -0.04736767f, -0.04011208f, 
    -0.02500231f, -0.01399326f, 0.03577523f, 0.00624960f, 0.04545760f, -0.05187661f, -0.03257200f, -0.02770820f, 
    -0.03170358f, -0.01890524f, -0.05948795f, 0.01339130f, 0.00178674f, 0.03479561f, -0.05267658f, -0.04333191f, 
    0.02772800f, 0.01188061f, -0.02870699f, 0.04700691f, -0.00874167f, -0.02543972f, -0.04727856f, -0.06230886f, 
    -0.01824166f, 0.00621115f, 0.00419508f, -0.03347558f, -0.03109093f, -0.03996136f, -0.05635299f, 0.00606588f, 
    -0.01003151f, 0.05112870f, 0.04645476f, 0.03058410f, -0.01294849f, -0.05177108f, -0.03162030f, 0.00596466f, 
    -0.04521128f, -0.04018579f, 0.02367423f, 0.02953705f, -0.00762624f, -0.02254184f, -0.01652073f, -0.01280397f, 
    0.04357781f, 0.03809836f, -0.01996157f, 0.04698042f, 0.00812405f, 0.04334556f, -0.05578519f, 0.02872259f, 
    -0.06058234f, -0.05378696f, -0.05602871f, -0.04990113f, -0.05804967f, -0.02534761f, -0.01760340f, -0.06228561f, 
    -0.02440366f, -0.00243434f, -0.05958622f, -0.03733420f, 0.04490305f, 0.03993092f, 0.00673591f, 0.05231768f, 
    -0.02609703f, -0.06415176f, -0.04868865f, -0.00152664f, -0.03470083f, 0.00048916f, -0.06274409f, -0.01836656f, 
    0.04315525f, -0.01504475f, -0.05218326f, -0.02274609f, -0.03570334f, 0.05374952f, -0.02884206f, 0.03858285f, 
    0.02536724f, 0.01316414f, 0.03171696f, -0.00346549f, -0.00517070f, 0.04028634f, 0.00678418f, 0.03536126f, 
    0.03674810f, 0.04323156f, -0.00326221f, 0.01222975f, -0.04161706f, 0.04631321f, -0.01365909f, 0.04713330f, 
    0.03595421f, -0.02904374f, -0.05314521f, 0.02812640f, -0.03380866f, 0.00011976f, 0.01666725f, 0.02183529f, 
    0.01120829f, -0.05192545f, 0.01593101f, -0.06193297f, -0.02544894f, 0.04170562f, 0.02034525f, -0.00423164f, 
    0.00733290f, 0.00163337f, -0.03796689f, 0.04798344f, 0.05419436f, 0.00903890f, 0.04478206f, -0.03581417f, 
    0.01068841f, 0.00385817f, -0.06236140f, -0.04422164f, 0.00495245f, -0.02050393f, -0.03134825f, -0.00224970f, 
    0.01283392f, 0.02735193f, 0.03049245f, 0.03961141f, 0.05998053f, -0.04630837f, -0.04397218f, -0.03223198f, 
    0.00074788f, -0.05014935f, -0.04305813f, -0.02323552f, -0.04413924f, -0.04817740f, 0.00148279f, -0.01134000f, 
    -0.00476771f, -0.01001154f, -0.00629028f, -0.00541912f, 0.03376106f, -0.02497434f, -0.05597595f, 0.02570582f, 
    0.04921833f, -0.05287793f, -0.01785116f, -0.04589436f, 0.03463610f, -0.03165993f, -0.06513659f, 0.03866285f, 
    0.04596122f, -0.05203549f, -0.02717373f, 0.03591555f, -0.02942970f, -0.02778945f, 0.02331760f, -0.05384470f, 
    -0.02526113f, -0.03461758f, 0.03589092f, -0.04248250f, -0.05691081f, -0.03690699f, 0.00066732f, 0.01150505f, 
    0.03969645f, 0.02894284f, -0.05474066f, -0.06080255f, -0.01273147f, 0.01568965f, -0.06304920f, -0.06034631f, 
    0.00995968f, -0.05110669f, -0.01296792f, -0.00959899f, -0.01801619f, 0.02135147f, 0.04292113f, 0.03928728f, 
    -0.03872064f, -0.04140624f, 0.05144583f, 0.01882625f, -0.04010274f, -0.00437787f, -0.02702707f, 0.02990812f, 
    -0.05677794f, 0.04125171f, -0.02880911f, 0.02985975f, 0.00008062f, -0.02351143f, -0.03498299f, 0.00132307f, 
    -0.05158135f, -0.05529427f, -0.04146288f, -0.03249247f, 0.03904660f, -0.00601007f, 0.00586133f, -0.02370252f, 
    0.01339775f, 0.00994222f, 0.02659160f, 0.01279711f, -0.01357805f, 0.03592091f, -0.02366978f, -0.02970662f, 
    0.05407740f, 0.01280663f, -0.01991942f, 0.04497793f, 0.01833512f, 0.02409330f, -0.02210557f, -0.04038239f, 
    0.04708950f, -0.05294812f, 0.02868325f, 0.03237262f, 0.00149618f, -0.02922400f, 0.02496335f, -0.04703988f, 
    0.04755923f, -0.03765742f, -0.05614399f, -0.06318183f, 0.02661554f, -0.06602988f, -0.01374673f, 0.02420961f, 
    -0.03022245f, -0.02921949f, 0.02955951f, -0.03711061f, -0.02654932f, -0.00721506f, 0.05765098f, -0.05081935f, 
    0.02884092f, 0.01839678f, 0.01800955f, -0.00133302f, -0.01996698f, -0.03798081f, 0.01035545f, 0.02449341f, 
    0.04144573f, 0.03134165f, 0.04440987f, -0.03904331f, 0.05775601f, 0.02335496f, 0.03930576f, -0.05595623f, 
    0.05197430f, -0.01439396f, -0.00539011f, -0.06602619f, 0.00700369f, -0.04602893f, 0.00859104f, -0.05660042f, 
    -0.04910483f, 0.02728434f, 0.02213486f, -0.04001883f, -0.03245724f, -0.02772558f, 0.02596094f, 0.00493619f, 
    0.00649286f, -0.02547143f, -0.02171765f, -0.04743721f, -0.03215023f, 0.03608895f, -0.03903393f, -0.00234316f, 
    -0.00881551f, 0.03539931f, 0.00665751f, 0.05065725f, 0.05978033f, -0.02012108f, 0.01064854f, -0.01287521f, 
    0.03845769f, 0.03325238f, -0.01851079f, -0.04824402f, -0.03235469f, 0.05378269f, -0.00926392f, 0.03550407f, 
    -0.01518157f, 0.04751228f, 0.02621811f, -0.02997714f, -0.00544585f, 0.00020465f, 0.03302737f, -0.04849988f, 
    -0.01875505f, 0.00863875f, -0.06206153f, -0.06240189f, 0.04842499f, -0.01706164f, -0.05559516f, 0.03139167f, 
    0.33907992f, 0.14605722f, -0.44076210f, 0.03605669f, -0.21598092f, -0.08318718f, 0.07007434f, 0.04993729f, 
    -0.11738478f, 0.08013075f, -0.17064801f, 0.10474096f, -0.20825517f, 0.02618800f, 0.05660447f, 0.00839732f, 
    0.00281473f, -0.01761381f, 0.24118246f, -0.32283831f, -0.08583179f, -0.16060223f, 0.17268650f, 0.07741057f, 
    0.00450256f, 0.01716179f, 0.01364905f, 0.17538694f, -0.33311704f, 0.03917928f, 0.02381319f, 0.15157022f, 
    -0.17744197f, -0.01626726f, 0.01177643f, 0.00759620f, 0.16380359f, -0.39224890f, -1.08744681f, -0.06846237f, 
    -0.04339166f, 0.20450570f, 0.04143965f, 0.04606327f, -0.00392073f, -0.05461594f, -0.02178277f, -0.18491210f, 
    -0.12229383f, -0.06951357f, -0.00095194f, 0.22702390f, 0.20935665f, 0.16195877f, -0.26294795f, -0.31658971f, 
    -0.31099042f, 0.23146616f, -0.04508969f, -0.00329242f, 0.15095592f, -0.01064627f, 0.25321138f, 0.00444584f, 
    -0.21646492f, -0.15510258f, -0.17479132f, -0.15837574f, 0.14122157f, 0.05302287f, -0.04405331f, 0.00959228f, 
    -0.00668807f, -0.53183770f, 0.04414893f, -0.26341507f, 0.06327326f, 0.11068096f, 0.00235566f, 0.10144847f, 
    0.05678920f, -0.00197656f, 0.10876502f, 0.16835244f, -0.24590820f, 0.05152018f, -0.00369385f, 0.13352606f, 
    0.06286254f, -0.04669249f, 0.37327638f, -0.08690564f, 0.06187983f, -0.10279208f, -0.00024666f, 0.06064996f, 
    -0.03079814f, -0.04185310f, 0.04951126f, 0.20176210f, 0.16986401f, 0.22961792f, -0.00503978f, 0.06638386f, 
    -0.11657692f, 0.09930342f, 0.02469900f, 0.04636713f, 0.15461311f, 0.08951466f, 0.28618363f, -0.05640336f, 
    0.09384988f, -0.07316293f, 0.05480196f, 0.05270252f, 0.03075202f, -0.06520541f, -0.13825540f, -0.10173976f, 
    -0.09675205f, 0.14784768f, -0.06094589f, 0.06172399f, 0.11742639f, 0.02672409f, 0.23449953f, -0.13734172f, 
    0.11417689f, -0.06574841f, -0.04333561f, 0.20413078f, 0.06300087f, 0.01026013f, -0.00801879f, -0.37990433f, 
    -0.21445514f, -0.34624556f, -0.06221831f, -0.29212904f, -0.05737923f, 0.16956818f, 0.10191300f, -0.25564909f, 
    -0.37439761f, -0.04312134f, 0.35963148f, -0.04550003f, 0.12575173f, -0.04795188f, 0.00589145f, 0.08146466f, 
    0.09869013f, -0.20637073f, -0.21705274f, -0.12314776f, -0.00864463f, -0.14187290f, 0.06212597f, 0.02507618f, 
    -0.02356491f, -0.04107478f, 0.43477461f, 0.04391161f, -0.10209141f, -0.03968699f, -0.28842974f, -0.08875798f, 
    0.08082092f, -0.14865890f, 0.02743102f, 0.10466984f, -0.22312386f, 0.18985589f, -0.00367001f, 0.13364962f, 
    -0.07150362f, 0.15449184f, -0.03133416f, -0.02839323f, 0.00651049f, 0.22941083f, 0.30376387f, -0.13721670f, 
    0.17146935f, -0.12951121f, 0.04433498f, 0.26097676f, 0.05808470f, 0.12437998f, -0.20358118f, -0.32231131f, 
    -0.07970767f, -0.05061947f, 0.16802889f, 0.12666161f, 0.03761357f, 0.23299824f, -0.23995870f, -0.38476506f, 
    -0.55589998f, -0.06937934f, 0.06734266f, -0.06610233f, -0.07334109f, 0.02989728f, 0.07628971f, -0.22850482f, 
    -0.01069562f, 0.12488624f, -0.01275787f, -0.03108920f, 0.14971285f, 0.15816608f, 0.13059032f, 0.06959379f, 
    -0.04586253f, 0.01102290f, -0.34149572f, -0.00040244f, -0.03978109f, 0.07621181f, 0.11075374f, 0.02736109f, 
    -0.10202787f, -0.03536464f, 0.24649808f, 0.18349758f, -0.07079783f, -0.06802770f, -0.09453412f, 0.04101136f, 
    0.14856192f, 0.03019179f, -0.02275112f, -0.22032195f, 0.10030389f, 0.06664859f, -0.05248743f, -0.21168944f, 
    0.00324472f, -0.04602402f, -0.15780050f, -0.05513321f, -0.16375902f, 0.13041851f, 0.00298692f, -0.07059163f, 
    -0.05657333f, -0.02776794f, -0.01246607f, -0.04773327f, -0.06747196f, 0.15941174f, -0.06445905f, -0.07492714f, 
    -0.11422623f, 0.06538579f, 0.12785882f, 0.16688095f, 0.07451780f, 0.18807718f, 0.16253357f, 0.29997981f, 
    -0.06172502f, 0.05935073f, -0.15945125f, 0.03052687f, -0.12888038f, -0.05631576f, 0.26095086f, -0.07311048f, 
    -0.07215523f, -0.12993307f, 0.01508274f, 0.17137116f, 0.12651470f, 0.02770812f, 0.02549113f, -0.09817968f, 
    0.30500048f, -0.33121353f, 0.10190925f, 0.05634639f, 0.03215392f, -0.09389133f, 0.15153183f, -0.12847878f, 
    -0.11602911f, -0.10322951f, -0.14577040f, -0.11986076f, 0.09744462f, -0.02540168f, -0.02636949f, -0.17194900f, 
    0.04744700f, -0.20224811f, -0.05828575f, 0.11010368f, -0.01649676f, 0.05685460f, -0.02036986f, 0.03420300f, 
    0.01611699f, 0.06546220f, 0.28599390f, -0.12814225f, -0.16643254f, -0.25365862f, -0.33687463f, 0.07928170f, 
    -0.01352198f, -0.34230626f, 0.06827072f, -0.07598932f, 0.01654430f, 0.07303575f, 0.08138079f, 0.09516673f, 
    -0.03528977f, -0.00539035f, -0.00409764f, 0.02522126f, 0.14702967f, 0.08644272f, 0.08060632f, 0.09407808f, 
    -0.03490135f, 0.12185466f, 0.08376189f, 0.17417273f, -0.01581699f, -0.16112627f, 0.15125251f, -0.22419763f, 
    -0.09281863f, -0.40386277f, -0.00203165f, -0.13455920f, 0.30430824f, 0.07066414f, -0.14728741f, -0.02941077f, 
    -0.01806282f, -0.09000515f, -0.01852081f, -0.00645552f, -0.11019198f, -0.00910429f, -0.06514790f, -0.10541608f, 
    0.06359039f, 0.05203201f, 0.01370317f, 0.09820019f, 0.11747508f, 0.05489196f, 0.15539135f, 0.15419166f, 
    -0.16383512f, -0.06330936f, -0.01477479f, -0.21246326f, -0.29715306f, 0.04275121f, -0.24002747f, -0.08902766f, 
    -0.28979155f, -0.01520096f, 0.00091417f, -0.17825232f, -0.07337768f, -0.10271987f, 0.06441250f, 0.03332664f, 
    0.03712654f, 0.22119096f, 0.11642863f, -0.19798574f, 0.00321106f, -0.02192514f, 0.14938335f, 0.20640293f, 
    0.01953239f, -0.05766252f, 0.00114046f, 0.13555980f, -0.04119053f, -0.03449368f, 0.03040347f, 0.09661565f, 
    -0.03196365f, 0.24414493f, 0.08705142f, 0.20557000f, -0.27484539f, -0.24323371f, -0.12016947f, 0.09807289f, 
    0.09415835f, 0.06119098f, 0.13470156f, -0.10296213f, -0.11496799f, 0.23297320f, 0.08419221f, 0.09550060f, 
    -0.09792202f, 0.06068537f, -0.05153885f, 0.29475918f, 0.05293210f, 0.20227379f, 0.11788786f, -0.03951139f, 
    0.23115271f, -0.16972628f, -0.00110377f, 0.04765470f, -0.10167728f, -0.10228521f, -0.00824928f, -0.31911877f, 
    -0.06732140f, 0.12551056f, 0.12347357f, -0.06337599f, 0.03000906f, 0.07245423f, 0.05145250f, -0.13835019f, 
    0.00472284f, -0.13685310f, 0.02342086f, 0.08901723f, 0.06993204f, 0.06803686f, -0.02922674f, -0.01476806f, 
    0.04960874f, 0.05985277f, -0.07540478f, -0.01930651f, 0.15889344f, 0.07284116f, -0.06363849f, 0.14833215f, 
    0.18470448f, 0.12857398f, -0.08507418f, -0.05973909f, -0.14782917f, 0.07270528f, -0.04477808f, 0.00846256f, 
    -0.10989565f, 0.16611354f, -0.10847563f, 0.04929566f, -0.11590286f, 0.10817646f, -0.02716088f, 0.08927035f, 
    0.08506415f, 0.13155052f, -0.02537740f, 0.21158336f, -0.23451056f, -0.13018829f, -0.38651288f, 0.05552819f, 
    -0.15564758f, 0.03982753f, -0.03916186f, 0.05364560f, 0.13159937f, -0.23550673f, -0.20340687f, -0.19680789f, 
    0.06317422f, -0.04549359f, 0.06868908f, -0.14679490f, -0.06883142f, 0.03664739f, -0.16757064f, 0.08512360f, 
    -0.10679697f, -0.04357313f, -0.17874137f, -0.01912226f, -0.05982452f, 0.10469992f, 0.16603117f, -0.19569841f, 
    0.05585017f, 0.23856650f, 0.04900103f, 0.03736328f, -0.01444096f, 0.00110773f, -0.02714138f, -0.06614087f, 
    0.13790739f, 0.08227290f, 0.03431164f, 0.10827505f, 0.14684258f, -0.01518351f, 0.07063593f, 0.08180964f, 
    0.14198115f, -0.06879902f, 0.10171383f, -0.11536028f, -0.15207000f, 0.07531730f, -0.17432062f, -0.07742218f, 
    0.08790591f, 0.06875278f, -0.25354263f, -0.08306596f, 0.05021334f, -0.02805216f, 0.07032126f, -0.05468885f, 
    0.03283752f, 0.11593401f, 0.01092196f, -0.24741051f, 0.03328404f, 0.06455968f, 0.06037246f, 0.08073951f, 
    0.11839446f, 0.02818648f, 0.19779553f, -0.10219258f, -0.51467174f, -0.25014800f, 0.00935149f, 0.10421276f, 
    0.01311236f, -0.07053982f, 0.10828440f, -0.08002868f, -0.16935138f, -0.25179175f, -0.34651256f, -0.04835808f, 
    -0.04651201f, 0.07469533f, 0.08070040f, 0.07884692f, 0.05801312f, 0.14799537f, -0.17124447f, -0.00411879f, 
    0.21924593f, -0.08562122f, -0.02614396f, -0.04507573f, 0.05927335f, -0.09096297f, -0.01071694f, -0.02247302f, 
    -0.06945776f, 0.04547280f, 0.02224000f, 0.01600110f, -0.05842324f, -0.19923775f, 0.14990564f, -0.17818104f, 
    0.11946479f, -0.47506928f, 0.15227170f, 0.02923451f, -0.18095323f, -0.14483388f, 0.10128256f, -0.02153319f, 
    0.06265584f, -0.02130097f, 0.23933209f, -0.21707827f, -0.04703680f, -0.06130267f, -0.05402697f, 0.07635891f, 
    -0.22694799f, 0.12057823f, -0.31028378f, 0.04276246f, -0.15526821f, 0.02015034f, 0.18340306f, 0.19982399f, 
    0.15228821f, 0.24580377f, -0.00029828f, -0.37860021f, -0.22125876f, 0.09091497f, -0.26026037f, -0.05698631f, 
    0.03891894f, 0.07925031f, 0.01955707f, 0.03074185f, 0.02106021f, -0.23950826f, -0.20749402f, -0.03366096f, 
    -0.24096002f, -0.01167773f, -0.01867949f, -0.10212424f, -0.15621933f, 0.15957212f, 0.02909434f, 0.08357114f, 
    -0.03152579f, -0.14195439f, -0.04859437f, -0.15479308f, 0.13700573f, 0.20466085f, -0.47005737f, 0.13723680f, 
    0.19518055f, -0.15057430f, -0.03716471f, -0.12432889f, -0.08529061f, 0.04941265f, 0.16826691f, -0.01717475f, 
    -0.19477676f, -0.34008071f, 0.02678287f, -0.09678673f, 0.15204939f, -0.12234923f, 0.08785165f, 0.03834051f, 
    0.66730046f, 0.05988818f, -0.31937271f, -0.08580684f, 0.16846634f, 0.10792952f, -0.00904083f, 0.01339909f, 
    -0.11687522f, 0.11884380f, 0.05474874f, 0.07353447f, -0.19445513f, -0.08711717f, 0.01741848f, 0.11686675f, 
    -0.00158807f, -0.03197253f, 0.05823487f, 0.02712346f, 0.09239847f, 0.00325701f, -0.10763767f, 0.02007992f, 
    -0.00391546f, 0.00223593f, -0.24057257f, 0.08602400f, 0.12162825f, -0.12044621f, 0.01222827f, -0.04700352f, 
    0.00285936f, -0.02349984f, -0.12498835f, 0.09177831f, 0.14005984f, -0.03501684f, 0.09863573f, -0.05210758f, 
    0.04978167f, 0.07264464f, 0.01084050f, -0.03003707f, -0.06333243f, -0.14291559f, 0.01609327f, -0.19168837f, 
    0.01668895f, 0.05471218f, -0.07968913f, -0.10201755f, 0.15671852f, -0.02522726f, 0.42551365f, 0.27372599f, 
    -0.03208707f, -0.07846201f, 0.03022736f, 0.17705750f, -0.07908197f, 0.05850061f, -0.02593292f, -0.48894060f, 
    0.29941654f, -0.00025423f, 0.04652785f, -0.02860720f, -0.23622924f, -0.02523543f, 0.09932977f, -0.11771081f, 
    0.15582679f, 0.31569386f, 0.26324189f, -0.00698275f, -0.07677249f, 0.07231850f, -0.01323070f, 0.04050635f, 
    -0.11380761f, 0.01420774f, -0.11768568f, -0.72844833f, 0.03811160f, -0.08929992f, 0.12705147f, 0.18489569f, 
    0.11014134f, 0.00603758f, -0.31238168f, -0.51343268f, -0.18130489f, -0.04429784f, -0.27420646f, -0.17689215f, 
    0.02721926f, -0.14117223f, -0.09670503f, -0.28219134f, -0.03705926f, 0.29570782f, 0.08455440f, -0.08044999f, 
    -0.21053988f, 0.14547266f, -0.01297375f, 0.05460742f, 0.21910268f, 0.15929811f, -0.01450189f, 0.03178448f, 
    -0.02681196f, 0.04135787f, 0.11171457f, 0.05875114f, 0.16496237f, -0.36228070f, 0.07813141f, 0.51213568f, 
    -0.08462773f, -0.00482192f, -0.04220935f, -0.00068196f, 0.18295270f, -0.03404230f, 0.07917208f, 0.05535197f, 
    0.03967747f, -0.02393808f, -0.04441812f, 0.14007472f, 0.08017569f, 0.15377201f, 0.02168915f, 0.06559537f, 
    0.14625095f, -0.11357251f, 0.03222249f, 0.07897500f, 0.03219339f, -0.14446428f, -0.06188308f, 0.06718037f, 
    -0.09079871f, -0.17411692f, -0.39658424f, 0.07097149f, -0.02329457f, -0.12847649f, -0.04361917f, -0.13327394f, 
    0.08409365f, 0.20934922f, 0.26961565f, 0.15753092f, 0.03702673f, -0.01287070f, 0.27018321f, 0.00521079f, 
    0.03409032f, 0.12042510f, -0.53202939f, -0.19169399f, 0.15611838f, 0.04019769f, 0.16681394f, 0.20763898f, 
    0.11257938f, -0.07800131f, 0.02574144f, -0.31979749f, -0.01412095f, -0.26815915f, -0.06544407f, -0.20230699f, 
    -0.18520881f, 0.01111864f, 0.06579672f, 0.06203456f, -0.17384173f, 0.06040193f, 0.09012418f, -0.13194157f, 
    0.03082138f, -0.10817891f, -0.05881564f, 0.00810282f, -0.03020374f, 0.07554270f, 0.03799107f, -0.15457727f, 
    -0.04553920f, -0.16545506f, -0.16506952f, 0.11683390f, 0.10596994f, 0.14096269f, 0.35548374f, 0.13714652f, 
    -0.10977939f, -0.03217328f, 0.09154318f, 0.07758573f, -0.02101997f, 0.10917045f, 0.16571978f, 0.08588169f, 
    -0.41731223f, -0.34322539f, -0.04474689f, -0.19014123f, -0.10405999f, -0.06672689f, 0.03095208f, 0.06149762f, 
    0.27347723f, -0.19658726f, -0.08373637f, 0.09369522f, -0.00967855f, 0.01139218f, -0.13454811f, 0.03755764f, 
    -0.16164161f, -0.07798582f, 0.05848808f, -0.01325515f, -0.13580948f, -0.03723230f, -0.00299557f, -0.05471152f, 
    -0.01250880f, -0.17727332f, 0.23791045f, -0.25909200f, -0.02589363f, -0.17419563f, 0.18528908f, 0.25103289f, 
    -0.02414894f, -0.11432255f, 0.07558391f, 0.03022676f, 0.17166616f, 0.15699816f, -0.12966311f, -0.26360229f, 
    -0.00206187f, 0.12346862f, 0.07915998f, 0.14725178f, -0.19573790f, -0.16636305f, 0.08844075f, 0.08382799f, 
    0.07048757f, 0.04534413f, 0.00940203f, 0.05729958f, -0.05043376f, -0.51898956f, 0.03366438f, 0.19790775f, 
    0.20211650f, -0.17400153f, 0.11206750f, 0.11321770f, 0.18329923f, 0.00402510f, 0.00443229f, 0.11944973f, 
    0.19439340f, -0.10744463f, -0.10376127f, -0.06607770f, 0.05655796f, 0.02056197f, 0.12696478f, -0.22800840f, 
    -0.12510917f, -0.25703257f, -0.00065534f, 0.03319208f, -0.10890654f, -0.05734515f, 0.06624528f, 0.00268772f, 
    -0.06392211f, -0.10562625f, -0.42755875f, 0.02015472f, -0.00960058f, -0.22405592f, -0.10285102f, -0.15353733f, 
    0.00100802f, -0.37496829f, -0.09145163f, -0.10670122f, 0.07577296f, -0.07160202f, 0.12120696f, 0.10527804f, 
    0.13115421f, 0.10010282f, -0.08475129f, -0.00309798f, -0.21109810f, -0.02744418f, -0.07501913f, 0.04661067f, 
    0.03994117f, -0.07798363f, -0.13616757f, -0.18997377f, -0.02358199f, 0.04383694f, 0.20128934f, 0.07397492f, 
    0.08467128f, 0.08565901f, 0.26151109f, 0.17505914f, -0.02508740f, -0.04425477f, -0.24246463f, 0.10420274f, 
    -0.03732076f, 0.11239245f, 0.06696729f, 0.02702550f, -0.20285638f, -0.00231523f, -0.00169270f, -0.05832987f, 
    0.04544261f, 0.05401205f, 0.15706977f, 0.14148274f, 0.09677887f, 0.07704768f, 0.07494117f, -0.13988073f, 
    0.05040589f, -0.02382050f, -0.05415050f, -0.05183104f, -0.17073049f, -0.11843098f, 0.04802978f, -0.16458182f, 
    -0.00809561f, 0.24568222f, -0.03507795f, 0.09687471f, -0.09152233f, 0.10782148f, 0.03028866f, 0.09929744f, 
    -0.42406601f, 0.14698665f, 0.34098729f, 0.05829610f, -0.11784051f, -0.18062010f, -0.17215362f, -0.04746184f, 
    -0.01319106f, -0.08921977f, 0.00607194f, 0.35644832f, 0.06810487f, 0.04615685f, 0.01959426f, 0.12713961f, 
    0.15832701f, -0.03219643f, -0.11329211f, 0.13114612f, 0.15617375f, -0.09680379f, -0.16595773f, -0.14461580f, 
    -0.01006955f, -0.09658753f, 0.05374928f, 0.00230389f, 0.17789249f, -0.00850763f, -0.12469833f, -0.07677157f, 
    0.05491509f, -0.12393064f, -0.10926022f, -0.01306560f, -0.35210150f, -0.13433279f, 0.24143130f, -0.12427647f, 
    0.17251351f, -0.16498874f, -0.22337373f, 0.18969296f, 0.06756730f, -0.22195724f, 0.08062330f, -0.01727164f, 
    0.04422455f, 0.03738820f, -0.15732136f, -0.04483442f, -0.22344117f, 0.21886936f, -0.09618120f, 0.09764385f, 
    0.30232388f, -0.16291155f, 0.13125022f, -0.02649506f, -0.01091954f, 0.06206489f, 0.20804720f, -0.13164993f, 
    -0.08246277f, 0.15315825f, 0.07920989f, 0.10371327f, -0.06923085f, 0.02251343f, -0.12340003f, -0.13437586f, 
    -0.11492137f, 0.08867049f, 0.19103201f, 0.04491036f, 0.02430419f, 0.09148410f, -0.07369776f, 0.02771592f, 
    -0.06466348f, -0.19417372f, -0.25632018f, 0.13052048f, -0.04496670f, 0.28918755f, 0.03126419f, -0.12910302f, 
    0.13126513f, 0.03268021f, 0.06647070f, 0.06776575f, 0.28547823f, -0.00937228f, 0.02066736f, -0.13981695f, 
    -0.05083188f, 0.23907392f, 0.11518717f, 0.01761262f, -0.06834149f, 0.02448053f, -0.04939043f, -0.20117682f, 
    -0.08307170f, 0.07462808f, -0.05717256f, 0.23639125f, -0.06315596f, -0.21976630f, -0.16020472f, 0.00509218f, 
    -0.03634587f, -0.06860475f, -0.02288670f, 0.01413052f, -0.13673967f, 0.01112100f, -0.07986343f, 0.09134993f, 
    -0.12864473f, -0.14313589f, 0.01801050f, 0.21986516f, 0.13888079f, 0.03410925f, 0.19101089f, 0.30529091f, 
    0.06886755f, 0.02619286f, -0.05259849f, 0.01113634f, -0.09734331f, 0.04241318f, -0.21076380f, -0.25858840f, 
    -0.30154419f, -0.24408749f, -0.09815983f, 0.14476307f, 0.04565843f, 0.01854910f, 0.09238996f, -0.18245178f, 
    0.02316591f, 0.00342984f, -0.05783463f, -0.01380888f, -0.00345232f, -0.05871984f, 0.02325589f, -0.03569501f, 
    0.00633050f, -0.02990025f, 0.00060586f, -0.01744692f, -0.03320184f, -0.04657606f, 0.00586792f, -0.05756819f, 
    -0.05279616f, -0.01046106f, 0.04501236f, 0.00226080f, 0.03167732f, -0.02490101f, -0.02294007f, 0.03574071f, 
    -0.04108978f, -0.04359241f, -0.00155266f, -0.05161664f, -0.04139596f, 0.04755354f, -0.00078054f, -0.01316160f, 
    -0.06213738f, -0.04449586f, -0.01008868f, -0.01066690f, 0.05073857f, 0.04127477f, -0.04135814f, 0.02146168f, 
    -0.02756288f, 0.03341703f, -0.03463750f, -0.02392367f, 0.04886995f, 0.02535449f, 0.03380081f, 0.01662294f, 
    -0.03920687f, -0.03872973f, -0.03226704f, 0.04369880f, 0.02119146f, -0.05438561f, -0.03100486f, 0.02142522f, 
    -0.02668897f, -0.05589471f, -0.05344561f, 0.04464925f, 0.03255867f, -0.05891810f, 0.02161535f, -0.04509791f, 
    0.02990671f, 0.04671680f, 0.03027513f, -0.02037032f, 0.04209070f, 0.00913394f, -0.05567880f, 0.00655285f, 
    0.02997911f, -0.02300600f, 0.00694092f, 0.01021387f, -0.03544050f, -0.00477264f, 0.03029999f, 0.02625330f, 
    -0.01403005f, -0.03048498f, -0.04519241f, -0.04743169f, 0.04862527f, -0.00231859f, -0.02814601f, -0.01315839f, 
    -0.06100728f, -0.04563012f, 0.01343800f, 0.02669282f, -0.00323516f, 0.03960909f, -0.00247106f, 0.02648115f, 
    -0.00567904f, -0.01832004f, 0.04923598f, 0.02109138f, -0.00970187f, -0.04752107f, -0.03454067f, 0.04687018f, 
    -0.03322122f, 0.02261263f, -0.06104720f, 0.02705777f, 0.01208928f, 0.00743857f, -0.04414997f, 0.04163216f, 
    -0.04811687f, 0.02685503f, 0.04693227f, -0.02471318f, -0.02224427f, 0.04676645f, 0.00512143f, -0.05155280f, 
    -0.02644154f, -0.02370016f, 0.04448435f, -0.02881136f, 0.03152121f, 0.01824477f, -0.01295532f, 0.00047928f, 
    0.04511850f, -0.03434382f, -0.02434160f, 0.02959455f, 0.04388242f, -0.04931999f, -0.05791016f, 0.02720061f, 
    0.04388506f, -0.00115260f, 0.01650213f, -0.01105001f, -0.02181813f, -0.00293397f, -0.05610591f, 0.02143668f, 
    -0.02610165f, -0.03163602f, -0.04844848f, 0.03530473f, -0.05720387f, 0.02119775f, -0.02936700f, 0.02496237f, 
    -0.06238128f, -0.02547788f, 0.04184466f, 0.02324319f, -0.05257349f, -0.02936877f, -0.00670946f, -0.04452788f, 
    0.05279239f, 0.03938116f, -0.01341736f, 0.04733922f, 0.05143080f, 0.01289446f, 0.03920594f, -0.00576448f, 
    -0.06382663f, -0.00805899f, -0.03784284f, -0.02057893f, -0.04420407f, -0.06173110f, -0.05823565f, 0.02083444f, 
    -0.02125523f, -0.05252352f, 0.03794448f, 0.00744004f, 0.02099804f, 0.03381702f, -0.01515158f, -0.01419244f, 
    0.02335072f, -0.03110058f, -0.04267082f, -0.02267383f, -0.04611881f, -0.04907437f, -0.00571552f, 0.04867575f, 
    -0.00638013f, 0.05590071f, 0.01651792f, 0.03762869f, 0.02325896f, -0.04602982f, -0.02894221f, -0.02466287f, 
    -0.03210228f, 0.05138691f, -0.03331238f, 0.00650953f, -0.05948717f, 0.02629766f, 0.01312135f, -0.01665673f, 
    -0.03544131f, -0.04637176f, -0.02448812f, -0.02486585f, -0.06020024f, 0.00719924f, -0.01999231f, -0.00468280f, 
    0.02025543f, 0.04814256f, -0.00643907f, 0.02753802f, -0.00271967f, -0.04218225f, -0.03733017f, -0.06139017f, 
    0.01932779f, 0.04697274f, -0.01142740f, -0.02529010f, -0.05196168f, 0.02946442f, -0.00143300f, -0.05312829f, 
    -0.00314557f, -0.01121393f, -0.02604695f, -0.05444496f, -0.06009308f, -0.01527106f, -0.03265283f, 0.03409171f, 
    -0.04168377f, -0.00703449f, -0.04304642f, -0.00214457f, 0.00192397f, -0.01714661f, 0.05103153f, -0.03976482f, 
    -0.05452640f, 0.01348311f, -0.00139872f, -0.01124526f, 0.01935362f, -0.01261999f, -0.03590765f, 0.02527278f, 
    0.02940846f, -0.02376468f, 0.03506487f, 0.00964397f, -0.03544926f, -0.03821259f, 0.02168106f, -0.03062700f, 
    -0.00987224f, -0.02106451f, 0.03193308f, 0.02773762f, 0.05064089f, -0.02881566f, -0.04613191f, -0.03713340f, 
    -0.02787179f, -0.04527470f, -0.03718499f, 0.01637963f, 0.00904120f, -0.05893249f, -0.04106596f, 0.00177963f, 
    -0.05981524f, 0.03156749f, 0.00587873f, -0.04391753f, -0.00583850f, 0.00268086f, 0.04528413f, -0.04806974f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.04985417f, 0.19950776f, -0.01855206f, -0.01921829f, -0.03090702f, -0.03837476f, -0.05171624f, -0.12289694f, 
    0.10824393f, 0.06062402f, 0.01293227f, 0.21940288f, 0.04617519f, 0.18894997f, 0.04306940f, 0.15874708f, 
    -0.02922858f, 0.25402230f, -0.03199053f, -0.05496674f, -0.04960598f, 0.17534599f, 0.25340933f, -0.00344463f, 
    0.12745412f, -0.04856896f, -0.01130844f, -0.01017199f, 0.27502280f, -0.06460606f, 0.01971570f, -0.00430221f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.22725722f, 0.40821368f, -0.16049717f, 0.20240821f, 0.10604468f, -0.16027763f, 0.35871071f, -0.19716443f, 
    0.08369789f, -0.15700722f, -0.10099428f, 0.14775690f, 0.04546190f, -0.01991676f, -0.06198442f, 0.25939491f, 
    -0.11483078f, 0.58224773f, 0.04192996f, -0.08004024f, -0.13158539f, 0.26652014f, 0.09111054f, -0.14072914f, 
    0.18629512f, 0.16627879f, -0.03576122f, 0.16686745f, 0.30324286f, -0.19799717f, 0.29514158f, -0.15725890f, 
    -0.04237165f, 0.32518953f, 0.12556033f, 0.17511818f, 0.16335410f, 0.09106150f, 0.09166443f, -0.02307962f, 
    0.29666415f, -0.11439642f, 0.14529251f, 0.18926275f, -0.38261417f, -0.02949754f, -0.07383408f, 0.01293377f, 
    -0.03125768f, 0.64157224f, 0.11525055f, -0.06077747f, 0.04750869f, 0.38495770f, 0.03962926f, 0.04414068f, 
    -0.39968714f, 0.02844917f, -0.07486108f, 0.12912399f, 0.13779567f, -0.31415346f, -0.11462529f, 0.06047092f, 
    0.08384451f, -0.11828084f, 0.10786877f, -0.01546155f, 0.02690278f, -0.09544982f, 0.26171535f, -0.07908372f, 
    -0.28669888f, 0.25840643f, -0.00117465f, 0.04502157f, 0.34289312f, -0.34020638f, -0.03543481f, 0.13800827f, 
    0.07513747f, 0.47219488f, -0.12689765f, -0.10061670f, 0.08750340f, 0.15094668f, 0.08681071f, -0.00923364f, 
    -0.18212743f, 0.10150454f, 0.05866325f, -0.09723894f, 0.23218799f, -0.45791942f, -0.42017883f, 0.01815447f, 
    -0.21511984f, -0.33241144f, 0.04667523f, 0.30431500f, -0.13601755f, 0.09151560f, -0.12808114f, -0.26268080f, 
    0.24061258f, 0.21526964f, -0.02520742f, 0.22021490f, -0.15994376f, 0.13595560f, -0.07272615f, -0.16610610f, 
    0.04871631f, 0.64474678f, 0.10247044f, 0.16146438f, 0.00949723f, 0.27484721f, -0.21808356f, -0.01064722f, 
    -0.11864727f, -0.11732554f, 0.08273844f, -0.23619395f, 0.22646704f, -0.07284334f, 0.70633960f, -0.12613817f, 
    0.35513458f, -0.28596202f, -0.02567744f, -0.21695775f, -0.15525493f, -0.04566736f, 0.06342851f, -0.19940002f, 
    -0.04275196f, 0.07248738f, -0.11745419f, 0.01448065f, -0.33656010f, -0.99380153f, -0.01075312f, 0.17111121f, 
    0.12640573f, 0.32722518f, -0.03387306f, -0.09824550f, 0.02961205f, 0.59653062f, -0.20885472f, -0.02832564f, 
    -0.51762897f, 0.11149626f, -0.08009834f, -0.25023118f, 0.29071900f, 0.41119614f, -0.04394231f, -0.07181496f, 
    0.19879355f, -0.51392680f, 0.02025435f, -0.41075820f, -0.02015115f, 0.16323474f, -0.24431281f, -0.07725269f, 
    -0.03689679f, -0.32153124f, 0.10739934f, 0.19980493f, 0.26960453f, -0.04643844f, 0.02737303f, 0.59800661f, 
    0.06056064f, -0.16919769f, 0.01147586f, -0.07988465f, -0.14266844f, 0.27703363f, -0.12158291f, 0.14535211f, 
    0.22474022f, 0.07095453f, 0.03881916f, -0.12801535f, 0.04126237f, -0.19954422f, -0.82927984f, -0.13684011f, 
    -0.20193173f, -0.17380880f, 0.05035109f, -0.05528763f, -0.16393501f, -0.02598703f, -0.10897879f, 0.16815582f, 
    0.07686728f, -0.05009075f, -0.13536280f, 0.06645752f, 0.01593289f, -0.17592987f, -0.06224976f, -0.19509006f, 
    -0.15111552f, 0.03697290f, -0.06077942f, 0.08008112f, 0.16555181f, -0.07021695f, -0.02382582f, 0.01778430f, 
    -0.04787264f, -0.13708557f, 0.07312313f, -0.01412444f, -0.04882564f, -0.04746581f, -0.13389225f, -0.09208237f, 
    -0.12686811f, 0.39753038f, 0.01197067f, -0.31639582f, 0.15089652f, -0.11482898f, 0.14738172f, -0.16265836f, 
    -0.15241621f, -0.22712067f, 0.00028447f, 0.06062065f, 0.24407193f, 0.21595262f, 0.12343769f, 0.22609612f, 
    0.16545027f, 0.29792881f, -0.09186841f, -0.07434198f, -0.16934444f, 0.36863804f, 0.01312587f, 0.03038697f, 
    0.12326860f, -0.11968430f, 0.01527581f, 0.23139419f, -0.17312579f, 0.11909253f, -0.11049131f, 0.16411904f, 
    0.18389194f, 0.15604441f, -0.12249214f, -0.02177792f, -0.09940787f, -0.07946866f, 0.02169825f, 0.03346986f, 
    -0.26416090f, -0.26182455f, 0.08007051f, -0.04187720f, -0.04878422f, -0.26500574f, 0.18893690f, -0.01674613f, 
    -0.00129777f, 0.24663804f, 0.01808367f, 0.03999567f, -0.04239250f, 0.03511172f, 0.28171343f, 0.15289336f, 
    0.04322485f, 0.01614993f, -0.03991226f, -0.18034507f, 0.11694432f, 0.00436754f, -0.04175290f, 0.14740156f, 
    -0.18124139f, -0.25621209f, -0.04773865f, 0.24571674f, 0.10872473f, 0.00304612f, -0.08878207f, -0.19096519f, 
    0.28320366f, 0.35312572f, 0.00583770f, 0.21374719f, 0.22192159f, 0.15658319f, 0.04800052f, -0.28181964f, 
    -0.09778479f, 0.57811975f, 0.11138398f, 0.08530925f, -0.05227465f, -0.05361393f, 0.25274321f, -0.01130352f, 
    -0.11573575f, 0.04970711f, -0.05793704f, -0.33929285f, 0.32496172f, -0.38023770f, 0.22123915f, 0.11109365f, 
    -0.07058796f, -0.29929814f, 0.04390507f, 0.12744491f, 0.10048372f, 0.03128839f, 0.34768721f, 0.18119612f, 
    0.11996974f, 0.21861480f, 0.00950147f, -0.05826226f, 0.27759686f, -0.04563679f, 0.08308129f, 0.05100768f, 
    0.01536960f, 0.08088767f, -0.05741399f, -0.04373062f, 0.06095262f, 0.16252361f, -0.36692649f, 0.02038653f, 
    -0.00534089f, -0.14293218f, 0.12088303f, 0.18490456f, 0.09702167f, -0.26985154f, 0.23819199f, -0.14187728f, 
    0.12331058f, 0.12425128f, 0.00295127f, 0.02990283f, 0.02697650f, -0.09656981f, 0.44653666f, -0.21241206f, 
    -0.12864569f, 0.22854595f, -0.10264857f, 0.10495470f, 0.12280541f, -0.19701563f, -0.00986336f, 0.01735507f, 
    -0.00360012f, -0.41963238f, -0.00053736f, -0.08293861f, 0.07798415f, 0.06941237f, -0.38774502f, -0.06699256f, 
    0.16183470f, 0.02254805f, 0.07799573f, -0.40363225f, -0.00401479f, 0.18954095f, 0.15905973f, -0.06112842f, 
    -0.19541292f, -0.15734242f, -0.06943998f, -0.11323987f, 0.03138604f, 0.01072073f, -0.11492287f, -0.08641477f, 
    0.55986392f, 0.14584461f, 0.06696868f, -0.03688260f, -0.06282391f, 0.24524973f, 0.10709929f, 0.11314551f, 
    -0.12010766f, 0.16967155f, -0.06048484f, -0.13399801f, 0.15009566f, 0.16467673f, 0.18387544f, 0.09086622f, 
    -0.01339120f, -0.07070526f, 0.07768349f, 0.61107498f, -0.03248365f, -0.07132392f, 0.12579130f, -0.04317104f, 
    0.20103219f, 0.10842582f, -0.08725028f, -0.27292556f, 0.08257113f, 0.13962065f, 0.20972329f, 0.05463478f, 
    -0.25630629f, 0.14462958f, 0.16918848f, 0.23706697f, -0.07181954f, -0.40655354f, -0.08637749f, -0.29147246f, 
    -0.15605831f, 0.56857884f, 0.01817778f, -0.11178838f, 0.03631201f, 0.12883243f, -0.24014172f, 0.04118653f, 
    -0.09959152f, -0.14812784f, 0.03567891f, -0.34418908f, -0.01068658f, -0.30249384f, 0.02655144f, -0.04460211f, 
    0.07694237f, 0.26196742f, -0.18278028f, -0.11629600f, 0.13566442f, 0.15791418f, -0.07361858f, 0.08415221f, 
    -0.16927442f, -0.05192797f, 0.08094826f, 0.15699404f, 0.06436112f, -0.20006600f, -0.16492304f, -0.19184567f, 
    0.15151593f, 0.38043058f, 0.07486647f, 0.01148547f, 0.04461494f, 0.07608654f, 0.14893508f, -0.17066953f, 
    -0.17288183f, -0.04578090f, 0.11578161f, 0.26019695f, -0.02875877f, 0.18541135f, -0.56375301f, -0.05711047f, 
    -0.10242699f, -0.07081313f, 0.05132188f, -0.07194875f, 0.03496009f, 0.04924171f, 0.00181801f, 0.01835698f, 
    -0.03048328f, -0.17023593f, 0.08764441f, -0.00392294f, 0.04568940f, 0.10708620f, 0.13617535f, -0.03158591f, 
    0.14757006f, -0.15246969f, 0.07541447f, 0.08401372f, 0.10600560f, -0.11354193f, 0.03019588f, -0.09999335f, 
    -0.03723108f, -0.15156862f, -0.04032791f, 0.06745501f, -0.05920997f, -0.17194939f, 0.08776322f, -0.08097263f, 
    0.03210162f, -0.22422737f, 0.10863715f, -0.24686620f, -0.17212379f, 0.11582310f, -0.27693906f, 0.12293708f, 
    -0.14998569f, 0.17420025f, 0.05556301f, -0.09582125f, 0.06898071f, 0.28831455f, -0.16474031f, 0.42852119f, 
    0.05532566f, 0.30563158f, 0.03333769f, 0.07796061f, -0.07975069f, 0.25575906f, -0.23683098f, 0.06826247f, 
    0.37470436f, 0.16643755f, 0.03229218f, -0.28781265f, -0.13982080f, -0.17096221f, 0.01755887f, -0.02672519f, 
    -0.18964785f, 0.23589745f, 0.09971140f, 0.23867618f, 0.15542494f, -0.17755905f, 0.34222552f, 0.06565276f, 
    0.36337030f, 0.01774958f, -0.15860666f, 0.08259837f, -0.13927391f, -0.02920458f, -0.14916839f, -0.34168625f, 
    -0.00376662f, 0.22016692f, 0.09938098f, -0.06568044f, -0.01715405f, -0.11465230f, 0.14305845f, -0.04999236f, 
    -0.16524108f, 0.05416973f, -0.07775042f, 0.18776320f, 0.14244117f, -0.37093788f, 0.29324403f, -0.15202677f, 
    0.15853067f, -0.20313714f, 0.11276498f, -0.21096177f, 0.02673207f, 0.17284124f, -0.05332432f, 0.10923518f, 
    0.41747537f, 0.14555781f, -0.06758725f, -0.09519830f, 0.04900587f, 0.29490778f, -0.03832876f, 0.23756894f, 
    0.01960000f, -0.06204898f, 0.03331929f, -0.13965045f, -0.15524100f, 0.00620933f, 0.23690259f, -0.09971902f, 
    0.04069884f, 0.04986428f, -0.03678665f, 0.38225207f, -0.06940497f, -0.66152781f, -0.25436628f, 0.12807398f, 
    0.02592454f, -0.16388474f, -0.13792187f, 0.05360842f, 0.02639380f, -0.05187178f, -0.25102940f, -0.19217952f, 
    0.36901000f, 0.29758841f, -0.01286459f, 0.13228154f, 0.20269479f, -0.17755680f, -0.08115288f, -0.03007170f, 
    0.02206797f, -0.47816321f, 0.07676131f, 0.09617569f, 0.09549946f, -0.48822588f, -0.24890625f, -0.13625360f, 
    0.52170473f, -0.11046948f, -0.03462799f, 0.29315957f, -0.20100616f, 0.74901634f, 0.50252634f, 0.04619029f, 
    -0.17174481f, 0.15639417f, -0.17887038f, -0.13866057f, 0.15610002f, -0.14458843f, -0.09602628f, 0.00703757f, 
    0.02723309f, -0.18366653f, 0.07987107f, -0.11851872f, 0.08801200f, -0.08297947f, 0.11749032f, -0.00582292f, 
    0.12138403f, -0.17326738f, 0.14334631f, -0.16025010f, 0.05907099f, 0.00944616f, 0.08139278f, 0.12898536f, 
    -0.09298214f, 0.11615206f, -0.12813479f, 0.14176960f, -0.17304875f, -0.07004042f, 0.00080718f, -0.02996685f, 
    0.04136085f, 0.23208979f, 0.04290516f, -0.06743973f, -0.15931898f, -0.15625642f, -0.16421475f, -0.16543388f, 
    -0.08283673f, -0.03017889f, 0.07009607f, -0.06110009f, 0.13324754f, 0.21929915f, 0.06073586f, 0.45468196f, 
    -0.02262713f, -0.02738631f, 0.06763692f, -0.13261208f, 0.14922261f, 0.02779880f, 0.41912007f, -0.06235706f, 
    0.17245547f, 0.06812904f, 0.06481338f, 0.26980188f, 0.24001443f, -0.03179680f, -0.29315701f, 0.01663300f, 
    0.06589277f, -0.07862149f, 0.03252813f, -0.05270343f, 0.12785688f, 0.11081114f, 0.22006540f, 0.04174155f, 
    -0.09411168f, 0.02108093f, 0.07669166f, -0.15010405f, 0.37007803f, -0.05800792f, 0.07792499f, 0.23407851f, 
    0.08225297f, 0.14475009f, 0.10714158f, -0.14891551f, 0.00283551f, 0.43961200f, -0.43931940f, 0.16544828f, 
    0.23768167f, 0.16135898f, 0.12049293f, 0.30435151f, -0.31836265f, -0.24321589f, 0.36764655f, -0.16887671f, 
    -0.18536438f, 0.01838513f, -0.07229628f, 0.08088297f, 0.16964146f, 0.11716603f, 0.47354010f, 0.04257378f, 
    -0.15274498f, 0.30330473f, -0.00742522f, 0.23129460f, 0.27729148f, -0.23898830f, -0.00806586f, -0.19496697f, 
    0.09351256f, 0.30107585f, 0.14238752f, 0.12693210f, 0.10108583f, -0.14702488f, -0.26285103f, 0.13661322f, 
    -0.37169796f, -0.15077172f, 0.08987410f, -0.06325787f, 0.09104449f, -0.11229949f, -0.05338142f, 0.14739789f, 
    0.12669238f, -0.51415265f, 0.08390424f, 0.00133112f, -0.02444673f, 0.00959494f, 0.11934482f, -0.18595211f, 
    0.07516553f, -0.31203809f, 0.11227848f, 0.14152338f, 0.13157421f, -0.31803349f, 0.10125773f, 0.35561812f, 
    -0.03626475f, 0.05301189f, 0.12663335f, 0.13439541f, -0.10342550f, 0.27285084f, -0.32197610f, -0.14390898f, 
    -0.24232341f, 0.00814951f, 0.14761521f, 0.05934177f, -0.05722280f, -0.61623693f, 0.03175640f, 0.01988400f, 
    0.21675847f, -0.09381492f, -0.02971617f, -0.02435296f, -0.16908881f, -0.17065579f, -0.04142668f, -0.04317871f, 
    -0.19828433f, 0.21675110f, -0.09511809f, 0.12739812f, -0.02407192f, -0.15852849f, 0.05597570f, 0.09200441f, 
    0.08142203f, -0.45040840f, 0.11882561f, 0.08812634f, -0.09423766f, -0.45773542f, 0.29713929f, -0.12085423f, 
    0.04219645f, -0.14583676f, 0.00169714f, -0.37736318f, 0.34895423f, 0.50670522f, -0.35724366f, -0.03061520f, 
    0.27610523f, 0.45608613f, -0.06617169f, -0.13717650f, 0.11736268f, -0.07936937f, -0.14498062f, -0.20708367f, 
    -0.40663725f, -0.24592549f, 0.12789935f, 0.31555206f, -0.19012660f, -0.11489265f, 0.16509694f, -0.25799710f, 
    -0.07007155f, -0.02143067f, 0.17598793f, -0.18005541f, -0.01988668f, 0.10155180f, 0.32595897f, -0.10171819f, 
    0.07404932f, -0.05529482f, -0.16155803f, -0.52029043f, -0.04998490f, 0.39372885f, -0.23635671f, -0.07541063f, 
    0.41189840f, 0.20382354f, -0.02820287f, -0.27874747f, -0.11703476f, -0.18147956f, 0.49981496f, -0.68376613f, 
    -0.19326939f, -0.40325165f, -0.15975809f, 0.02705959f, 0.01647881f, -0.28588527f, -0.06749668f, 0.23708288f, 
    0.00630150f, -0.19231099f, 0.17611776f, -0.12700327f, -0.03233846f, 0.30286554f, 0.38198677f, -0.11973076f, 
    -0.20967521f, -0.13322505f, -0.09425914f, 0.16484217f, 0.06837035f, -0.38356900f, -0.23696610f, -0.09901188f, 
    0.12526511f, -0.13773356f, -0.00111939f, -0.21530560f, -0.05186785f, -0.18336402f, 0.01517911f, 0.06881891f, 
    -0.20874430f, 0.12988211f, 0.01492057f, -0.05627713f, 0.47711879f, -0.00888970f, 0.02224056f, 0.47080472f, 
    0.02556303f, -0.37531510f, -0.12570754f, 0.14988160f, 0.14045285f, 0.18462515f, 0.02006099f, 0.08620580f, 
    0.01721116f, 0.08074711f, 0.07426669f, 0.43160540f, -0.23581621f, -0.07313566f, 0.00168282f, 0.01999735f, 
    0.03939284f, 0.36495030f, 0.10006576f, -0.40065020f, -0.06899285f, -0.05460679f, 0.24982367f, -0.25933480f, 
    0.36306742f, -0.30149102f, -0.15576325f, 0.17070179f, 0.18636255f, 0.12535581f, -0.13086304f, 0.18231839f, 
    -0.11827314f, 0.34381068f, -0.12541547f, -0.14949095f, 0.08128106f, -0.38100928f, 0.10541309f, 0.02523445f, 
    0.10894282f, 0.01714240f, -0.01156909f, 0.34599721f, 0.04533409f, -0.75447142f, -0.01127264f, -0.13601127f, 
    0.04058226f, -0.09796754f, 0.16571115f, -0.03854949f, 0.11939017f, -0.16689235f, 0.05365380f, 0.09964018f, 
    0.50694513f, -0.13975057f, -0.04483955f, -0.15687759f, 0.20111619f, 0.17377771f, 0.06807627f, 0.28332880f, 
    0.07246841f, -0.25249648f, -0.14559172f, -0.01728853f, 0.09337462f, 0.16475031f, 0.00274595f, 0.05615375f, 
    0.30767924f, 0.01485195f, 0.02460572f, 0.68133181f, -0.24392337f, -0.14991851f, 0.31957641f, -0.13002978f, 
    -0.06262862f, 0.13708884f, -0.10570713f, -0.01949894f, -0.12237340f, 0.08616054f, -0.06520402f, 0.11866435f, 
    0.53735954f, 0.12018315f, 0.17315345f, 0.11352336f, 0.70901030f, -0.25402305f, 0.02247849f, -0.07064184f, 
    0.01899978f, 0.46462163f, 0.03772351f, 0.13638708f, 0.14849323f, -0.38868925f, -0.17647944f, 0.13176338f, 
    0.28274140f, 0.14674631f, -0.02950493f, 0.83285803f, 0.15104772f, 0.00675274f, -0.01916532f, -0.17054869f, 
    0.08810287f, -0.11000902f, 0.18450096f, -0.04922397f, -0.11625036f, 0.10841685f, 0.02979712f, -0.37879881f, 
    -0.06548011f, 0.24126334f, 0.16450927f, 0.09281756f, 0.17090790f, -0.09061199f, -0.12303098f, -0.23686792f, 
    -0.14632609f, -0.68028027f, -0.15102156f, 0.02754236f, 0.06727705f, -0.19015861f, 0.20795538f, -0.09277655f, 
    0.61889839f, 0.16127801f, 0.10548303f, -0.39107963f, -0.03824488f, 0.31445926f, 0.23394515f, 0.02451111f, 
    0.06428497f, 0.07329192f, 0.01837773f, -0.18629366f, -0.17540039f, 0.01923852f, -0.12638786f, -0.12162746f, 
    0.13153827f, -0.00931049f, 0.10751631f, -0.17887232f, -0.09953579f, -0.10571165f, -0.05049091f, -0.12100805f, 
    -0.09716421f, 0.03548365f, -0.04075750f, -0.06978574f, -0.12318504f, -0.15116577f, -0.00943689f, -0.09787029f, 
    0.01430477f, 0.17081949f, -0.11391996f, -0.12905182f, -0.01577548f, -0.15281229f, 0.06985655f, 0.08880084f, 
    -0.33444858f, 0.07272248f, -0.10391654f, 0.14846343f, 0.03062527f, 0.12906815f, 0.11240759f, -0.10131472f, 
    -0.56610936f, 0.06818195f, -0.12968281f, -0.09288228f, -0.27659690f, 0.32260129f, -0.04326495f, -0.04149886f, 
    0.03591392f, -0.20391504f, 0.01146514f, -0.15513825f, 0.02385587f, 0.21848559f, 0.04465366f, 0.01156073f, 
    -0.13233495f, 0.14116499f, -0.12508999f, -0.46788889f, -0.08504932f, -0.14486346f, 0.03487584f, -0.10779541f, 
    -0.15195903f, 0.03322065f, 0.17113423f, -0.12659512f, -0.07352243f, 0.11227158f, 0.13307644f, 0.02059671f, 
    0.10827236f, -0.05094558f, 0.03783419f, -0.11943628f, -0.01006810f, 0.24859442f, 0.05971553f, -0.19579750f, 
    -0.03160569f, 0.49646333f, -0.09619947f, -0.02475883f, 0.02119399f, 0.28741139f, -0.07141297f, 0.05390707f, 
    -0.20319583f, -0.14720292f, -0.17077558f, -0.10922088f, -0.07407027f, 0.08291364f, 0.14299071f, -0.03142203f, 
    -0.05660617f, -0.11157720f, -0.09800594f, 0.07702509f, 0.03943396f, 0.17149860f, -0.07223470f, -0.13587573f, 
    -0.03571822f, -0.07115559f, -0.00759528f, 0.06042752f, -0.11835845f, -0.12144041f, 0.13395035f, -0.11519156f, 
    0.06342985f, -0.15132152f, -0.11987168f, 0.07742319f, -0.06401233f, 0.13273992f, -0.11370295f, 0.00991368f, 
    -0.10081623f, 0.10259423f, 0.04527136f, -0.15595284f, -0.02396148f, 0.06508885f, 0.02563364f, 0.14990433f, 
    0.34661889f, 0.36636704f, 0.11769763f, -0.51205957f, 0.17669520f, 0.09237222f, 0.14938381f, -0.42931166f, 
    0.17071505f, -0.44533581f, 0.06251357f, 0.20250586f, 0.00413386f, -0.38688594f, -0.10304140f, -0.17208494f, 
    0.03826111f, -0.09934089f, 0.14321207f, 0.01974776f, -0.09824493f, 0.16792475f, 0.60286945f, 0.06646483f, 
    -0.35041073f, -0.09871650f, 0.09943216f, 0.30243325f, -0.01970521f, -0.09516402f, -0.48161942f, 0.18070665f, 
    -0.22268865f, 0.18587859f, -0.04819069f, 0.10268120f, -0.11941705f, -0.11504228f, 0.25937092f, -0.26511055f, 
    0.43569210f, 0.26497257f, -0.11125591f, -0.05100976f, -0.15094291f, 0.25388882f, 0.06970497f, -0.06697972f, 
    -0.17240287f, 0.42678452f, 0.12798780f, -0.03461974f, -0.11469371f, 0.11580514f, -0.16410831f, 0.05348063f, 
    -0.15468973f, -0.02178960f, 0.06411913f, 0.10574353f, 0.20997910f, 0.51399922f, 0.58532691f, 0.14129217f, 
    -0.02961021f, -0.25382066f, -0.09886359f, -0.27547470f, 0.11636456f, -0.08625821f, 0.24548410f, -0.04423417f, 
    0.22468753f, -0.08821511f, 0.14781635f, -0.24029908f, 0.30431724f, -0.23253417f, -0.01518317f, 0.14079298f, 
    -0.00016404f, 0.35909185f, 0.12629153f, 0.03099155f, -0.07014498f, -0.09455130f, -0.03731093f, -0.13665701f, 
    0.22137697f, 0.14260165f, -0.05474475f, 0.53785354f, -0.49500194f, 0.09413593f, -0.33984712f, -0.00809066f, 
    0.07342796f, -0.42112720f, 0.11663358f, 0.15433820f, -0.08592118f, 0.13498394f, -0.10947693f, -0.03704663f, 
    0.41301253f, 0.53265488f, -0.01854703f, 0.03209329f, 0.13626744f, -0.05462716f, -0.14638889f, 0.07781954f, 
    0.10176134f, 0.63519675f, -0.16077447f, 0.11240269f, 0.15828189f, -0.01462927f, -0.37186202f, -0.08102420f, 
    -0.38801461f, 0.16866077f, 0.01393406f, -0.07527425f, 0.09114745f, -0.40263227f, 0.16773833f, 0.03191719f, 
    0.15101667f, -0.04893246f, -0.10048252f, 0.08986407f, -0.16548784f, -0.03526196f, 0.15261503f, -0.34400302f, 
    -0.18664339f, -0.07340842f, -0.07547804f, 0.23440360f, 0.35899761f, -0.01880813f, 0.12167335f, -0.14057323f, 
    -0.06255927f, 0.05535192f, -0.04128861f, 0.06038726f, -0.00530647f, 0.15861152f, 0.11716078f, -0.08781274f, 
    0.19373013f, 0.03989461f, 0.00418244f, -0.21070090f, -0.18832816f, -0.53260249f, -0.17340262f, -0.10674248f, 
    -0.13970441f, 0.10396575f, 0.05195447f, 0.13049234f, 0.12542658f, 0.08906560f, 0.10054196f, 0.12891795f, 
    -0.00053031f, -0.16128075f, -0.05852505f, 0.05506060f, -0.19704953f, 0.02893626f, -0.02771233f, 0.02722745f, 
    -0.16309749f, -0.10240723f, 0.06436388f, -0.10233973f, -0.11233730f, -0.20470507f, -0.04997174f, -0.16469491f, 
    -0.07347631f, 0.15626760f, 0.03950806f, -0.00604652f, -0.15540618f, -0.17474650f, -0.11499459f, 0.10308953f, 
    0.30788258f, -0.40325820f, -0.26640326f, -0.44969958f, -0.11392976f, -0.06489586f, 0.17579024f, 0.36394626f, 
    0.12367792f, -0.16444333f, -0.16569367f, -0.04378534f, 0.14741892f, -0.14232270f, 0.04820084f, -0.27851239f, 
    0.13954885f, 0.12824963f, 0.07602318f, 0.16123614f, -0.02919729f, -0.01300861f, -0.62315649f, -0.10207370f, 
    -0.22640228f, 0.08518892f, -0.05747363f, -0.13046733f, -0.02179876f, 0.49279201f, -0.12303609f, 0.10464811f, 
    0.14417966f, -0.14022538f, 0.14028153f, -0.15897515f, 0.06671513f, 0.14613077f, -0.08000161f, 0.06948963f, 
    0.07953958f, -0.00406450f, -0.10534035f, 0.12003005f, 0.15300164f, 0.12791103f, 0.15903102f, 0.04339830f, 
    -0.04495601f, -0.43135759f, 0.17386477f, 0.17581880f, 0.08605899f, 0.07794884f, -0.40232721f, 0.10437959f, 
    0.19861159f, -0.06954364f, 0.14371425f, 0.36237764f, -0.44196975f, 0.51722044f, -0.20356180f, 0.03997253f, 
    0.16788250f, -0.31233820f, 0.09181575f, 0.03332542f, 0.10078181f, 0.01644336f, 0.13408171f, -0.27158237f, 
    -0.20196840f, 0.02730309f, -0.13116625f, 0.14594355f, -0.21344161f, 0.00197861f, -0.09788503f, 0.10786825f, 
    -0.04480553f, -0.27424896f, -0.13847849f, 0.03728290f, 0.12304902f, 0.03173294f, -0.06205833f, 0.15542085f, 
    0.08477022f, -0.01684751f, 0.15577450f, -0.49554968f, -0.06207993f, 0.26980355f, 0.13892238f, 0.05756358f, 
    0.17070700f, -0.26421273f, -0.16812217f, -0.14097895f, 0.01895380f, -0.15581903f, -0.21732594f, -0.01811970f, 
    -0.06050653f, -0.09941422f, 0.02141488f, 0.16160785f, -0.14383820f, -0.03643100f, -0.05867366f, -0.07836546f, 
    -0.11460111f, -0.06902106f, 0.12560552f, 0.12898260f, -0.12878281f, 0.22116518f, 0.09539249f, 0.11654533f, 
    0.15338807f, 0.08782575f, 0.10218670f, -0.12642525f, -0.10712148f, -0.02671913f, -0.10068280f, 0.01209096f, 
    -0.03745802f, -0.16269866f, 0.10563833f, -0.06816110f, 0.12700076f, 0.11774815f, 0.19454670f, 0.09513954f, 
    -0.33656019f, -0.20943277f, -0.15617359f, -0.16185060f, -0.11147857f, 0.12157642f, 0.09814717f, -0.09878372f, 
    -0.05056402f, -0.36060750f, -0.13352089f, -0.04133476f, -0.05730303f, 0.17575407f, -0.26058677f, -0.12704173f, 
    -0.07504423f, -0.14254303f, -0.10327251f, -0.06261072f, -0.18804653f, -0.04307414f, -0.15718272f, -0.02207743f, 
    0.08914669f, 0.22675693f, 0.02998809f, -0.18773830f, 0.13385823f, 0.16426481f, 0.08885758f, -0.03488914f, 
    0.16153109f, -0.06593113f, 0.13026114f, 0.11606058f, 0.45388490f, -0.09618366f, 0.15530902f, 0.21670836f, 
    0.03432789f, -0.13572736f, -0.03439423f, 0.02300398f, -0.03933706f, -0.60892767f, -0.18393381f, 0.00947886f, 
    0.60779440f, 0.11825190f, 0.02399742f, 0.38254848f, -0.19082919f, -0.59074646f, -0.22045645f, 0.06930853f, 
    -0.03113132f, -0.22411007f, 0.09392717f, 0.17802602f, 0.14084822f, 0.06057477f, 0.06960832f, -0.10262664f, 
    0.18198852f, 0.17562874f, 0.03601482f, 0.27320051f, -0.06125269f, -0.43592104f, -0.05881697f, -0.08806977f, 
    -0.05631502f, 0.64412558f, 0.17489521f, 0.04737929f, 0.10164275f, 0.19869573f, -0.67023093f, -0.09552701f, 
    -0.41591838f, -0.00760149f, -0.04760659f, -0.31403181f, 0.11492498f, -0.32332334f, 0.51964122f, 0.02242888f, 
    0.24477093f, -0.28578907f, -0.07778925f, -0.39543861f, 0.17320891f, 0.02403700f, 0.07141677f, -0.19106036f, 
    0.16632196f, 0.50132269f, -0.03559347f, 0.09425449f, 0.56659824f, -0.53960431f, -0.09995532f, -0.10551810f, 
    0.00916141f, 0.08172611f, 0.07918374f, -0.02639613f, -0.13934350f, -0.22618072f, -0.09591493f, 0.03102293f, 
    0.12256595f, 0.14195585f, -0.08176871f, 0.02235161f, 0.36261743f, -0.39824784f, -0.36731482f, 0.05149033f, 
    0.12854213f, -0.27124041f, -0.04077689f, -0.07641282f, -0.07690144f, 0.15701741f, 0.13808031f, -0.27523980f, 
    0.51638567f, 0.37066147f, 0.11345316f, -0.03696388f, 0.21387927f, 0.15144908f, 0.01611529f, 0.20134275f, 
    -0.01490131f, -0.14165467f, -0.11548178f, -0.08546504f, -0.04831596f, -0.58809632f, -0.00888959f, -0.04389238f, 
    0.01747134f, 0.09888647f, 0.15710032f, -0.03937080f, 0.18724099f, -0.83691716f, 0.21973260f, 0.13342144f, 
    0.04024637f, 0.22960272f, 0.20283081f, 0.10980871f, -0.03087858f, 0.03436600f, -0.32745317f, -0.20642620f, 
    0.16401872f, -0.22415826f, 0.08095607f, 0.26653618f, -0.14684665f, -0.31286734f, -0.13667449f, -0.06118241f, 
    -0.04271757f, 0.29412681f, -0.16962126f, -0.00770300f, 0.04973556f, 0.41458642f, 0.11660095f, 0.04393851f, 
    0.11613279f, -0.02958723f, 0.14107439f, -0.27018961f, 0.04417436f, 0.53018641f, 0.38225096f, 0.11042818f, 
    -0.03397869f, -0.08282980f, 0.18072356f, 0.01202053f, -0.03642328f, 0.01256117f, -0.06845775f, 0.29155165f, 
    0.22856614f, 0.21409045f, -0.09235691f, 0.00987742f, 0.02980080f, -0.12039202f, -0.08284284f, -0.39860964f, 
    0.07185715f, 0.22369513f, -0.01615576f, 0.17688015f, -0.07346193f, 0.17532276f, 0.06812052f, -0.13322507f, 
    -0.32121357f, -0.10318050f, 0.04232341f, 0.33414933f, 0.08936539f, 0.50400603f, -0.03670143f, -0.00427266f, 
    0.17021383f, -0.48208368f, -0.01158986f, 0.11846249f, 0.14300723f, -0.12968540f, -0.28656119f, -0.31494164f, 
    0.08048721f, 0.56162941f, -0.08574791f, 0.11043306f, 0.01919695f, -0.61350751f, -0.14539920f, -0.15555428f, 
    -0.08698130f, 0.32190755f, -0.14672968f, 0.12357663f, 0.08858361f, -0.04987785f, 0.07543024f, 0.12371248f, 
    -0.27033436f, -0.07226560f, -0.01242564f, -0.28001836f, 0.47764340f, -0.31731170f, -0.16365434f, -0.13034981f, 
    -0.00052654f, 0.02532368f, -0.15521988f, -0.16164869f, 0.04175657f, -0.12851585f, -0.11333219f, -0.07364143f, 
    -0.07456268f, -0.08351222f, 0.12624945f, -0.06072523f, -0.15631269f, 0.11042939f, -0.05320114f, -0.08078820f, 
    0.13396068f, 0.06133719f, -0.05960224f, -0.14754884f, 0.12369088f, -0.09921446f, 0.05107239f, 0.17139617f, 
    -0.19217220f, 0.06065520f, -0.09592060f, -0.07524978f, 0.07652957f, -0.01336527f, 0.03551188f, -0.00592218f, 
    -0.11829539f, -0.10124724f, -0.10421291f, -0.17500335f, -0.10131571f, -0.13845962f, 0.12786557f, -0.02341890f, 
    -0.03577483f, -0.03761882f, 0.12798029f, -0.02685280f, 0.02534728f, 0.03626627f, 0.01264844f, -0.04466367f, 
    0.06691322f, -0.02275740f, -0.13372371f, -0.09980652f, 0.09760997f, 0.08837372f, -0.12923519f, -0.09673846f, 
    -0.11551747f, -0.10206485f, 0.04119623f, -0.11081163f, -0.14731175f, -0.14806660f, -0.00283167f, 0.14291897f, 
    0.15815982f, -0.31067595f, 0.02620909f, 0.26267228f, 0.01769114f, -0.06975338f, -0.29179165f, -0.13163148f, 
    0.46797359f, -0.17525528f, 0.13699177f, 0.20543280f, 0.16321850f, -0.29648563f, 0.03798909f, -0.26098695f, 
    -0.00082508f, -0.40504271f, -0.03446110f, 0.13060711f, -0.03335588f, -0.76209795f, -0.25182649f, -0.00848742f, 
    0.05298882f, 0.07541429f, -0.05167555f, 0.25669754f, -0.42346203f, 0.11178866f, 0.28966695f, -0.00332322f, 
    0.02104981f, -0.36900985f, 0.17644937f, 0.07442040f, -0.09571379f, -0.00295286f, 0.00455534f, 0.12380739f, 
    -0.02624365f, 0.12217459f, -0.17818844f, -0.01052914f, 0.30295020f, 0.07022031f, -0.04196887f, 0.14712502f, 
    -0.06718775f, -0.47463027f, 0.04245838f, 0.12743087f, 0.01382700f, -0.21935318f, -0.15072794f, -0.10612344f, 
    0.26961040f, 0.08346599f, -0.09503292f, 0.21708418f, -0.18252949f, 0.67022681f, 0.19074917f, -0.00850904f, 
    0.05992329f, -0.25521901f, -0.01782788f, 0.24150950f, -0.02735396f, -0.01073211f, -0.13744648f, -0.36469525f, 
    0.45459837f, 0.22495110f, 0.08410128f, 0.05589751f, 0.11647921f, -0.00444539f, -0.17976606f, -0.28798446f, 
    -0.05277823f, -0.53683627f, -0.13493891f, 0.13253179f, -0.13660173f, -0.45591450f, -0.02518558f, -0.09627753f, 
    0.28072625f, -0.11292512f, -0.14161804f, 0.32119337f, -0.19998747f, 0.77069426f, 0.34729552f, 0.06634810f, 
    0.25550583f, 0.01236025f, -0.11456823f, -0.01413606f, -0.03860631f, 0.10807508f, -0.03160814f, -0.17554902f, 
    0.05765671f, -0.15192543f, -0.06361427f, -0.06603909f, 0.14596792f, 0.11746061f, -0.02294220f, 0.43699372f, 
    0.02419753f, -0.52124476f, -0.11136705f, -0.12168241f, -0.09959304f, -0.10146876f, 0.18216702f, -0.00348852f, 
    0.52931631f, 0.15233967f, -0.10784233f, 0.13508445f, -0.23066981f, 0.00545402f, 0.15306804f, -0.11371531f, 
    0.18393852f, -0.23201211f, -0.07749952f, 0.17437504f, 0.05212600f, -0.03966385f, -0.29240352f, 0.07685306f, 
    0.09514911f, 0.42660141f, 0.14281745f, -0.18068478f, 0.06715033f, 0.05071151f, -0.10126699f, 0.00559928f, 
    0.17878486f, -0.05881575f, 0.14134780f, -0.15134200f, 0.11060888f, -0.03213809f, -0.02686930f, -0.01274240f, 
    0.06741024f, -0.10429278f, -0.02520163f, 0.18325299f, -0.01571184f, 0.64194244f, 0.34776416f, 0.02320852f, 
    -0.18952261f, -0.13360731f, 0.22091375f, -0.05383434f, 0.16235474f, 0.16541468f, -0.08998148f, 0.11952343f, 
    -0.36734915f, 0.19099015f, 0.17086111f, -0.04972757f, -0.15591091f, 0.15522730f, -0.04800370f, 0.03785731f, 
    0.12335660f, -0.07253378f, 0.12409262f, -0.15373147f, 0.14562851f, 0.17360744f, 0.00006423f, 0.02928658f, 
    -0.09014444f, -0.10234898f, -0.05852593f, -0.27646369f, -0.19042130f, 0.10840459f, 0.09172969f, 0.11115559f, 
    -0.12375286f, 0.08263905f, -0.11815334f, -0.06924600f, -0.10493743f, -0.08951122f, 0.19652383f, 0.14439431f, 
    -0.05432987f, -0.00072186f, 0.12633967f, -0.03621946f, -0.19476834f, -0.09934190f, 0.11394628f, 0.20091310f, 
    -0.02103278f, 0.11387778f, -0.05393735f, -0.14016376f, -0.13960917f, 0.00196377f, -0.05038458f, 0.07530830f, 
    -0.04236356f, 0.02705140f, 0.09915775f, 0.01110665f, 0.07155812f, 0.15728205f, -0.00537504f, 0.11795329f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.23630278f, 0.02283700f, 0.06405080f, 0.04012649f, 0.07864235f, 0.35017583f, -0.02432697f, 0.18275407f, 
    0.15875416f, 0.45815685f, 0.02631305f, -0.12281583f, -0.13082445f, 0.04293821f, 0.17954247f, -0.02835099f, 
    0.03167176f, 0.08013549f, 0.07406070f, 0.09915137f, 0.07837980f, 0.30346665f, -0.07469182f, 0.00163371f, 
    0.10696011f, 0.10799589f, 0.28595576f, -0.06533988f, -0.19274709f, 0.18117282f, 0.14243056f, 0.26168278f, 
    0.16278651f, -0.06366989f, 0.17358379f, 0.36889228f, -0.20311727f, 0.25365269f, 0.24460639f, -0.05280686f, 
    0.26656571f, 0.36423406f, -0.11422192f, -0.11614723f, 0.09342413f, 0.01762040f, -0.05173457f, 0.18697499f, 
    0.15134640f, 0.13175876f, 0.37306637f, 0.36125287f, 0.17017540f, -0.18801443f, 0.51386750f, -0.15593421f, 
    -0.03416875f, -0.12057412f, -0.02194885f, -0.13136803f, 0.09399815f, -0.03062916f, -0.00751495f, 0.08047218f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.31776047f, -0.31334895f, -0.39752501f, -0.40591735f, -0.08014003f, -0.11789500f, -0.01226120f, 0.21672632f, 
    -0.00096410f, -0.51739138f, -0.13657492f, -0.09129581f, 0.27064586f, -0.67006224f, -0.01358865f, -0.03797083f, 
    -0.05645023f, -0.16468120f, 0.02835258f, 0.26658663f, -0.04461611f, 0.10683670f, -0.00013451f, -0.17744809f, 
    -0.29214945f, 0.12703995f, -0.02818734f, -0.07095321f, 0.17513247f, -0.25511754f, 0.11167368f, 0.17706855f, 
    -0.02933551f, -0.00273659f, -0.34842864f, -0.19923060f, 0.00301822f, 0.04371212f, 0.16000563f, 0.45332149f, 
    -0.17512694f, -0.53895575f, 0.09400547f, 0.02488434f, 0.33767551f, -0.00887083f, -0.10052611f, -0.11795068f, 
    -0.05156820f, -0.89484608f, -0.16890550f, -0.32239828f, 0.13456130f, 0.09545956f, -0.18984374f, 0.08939986f, 
    0.03174047f, 0.09579047f, 0.24752989f, 0.28038812f, 0.23177634f, 0.26030490f, -0.25803983f, -0.11045366f, 
    0.06053758f, 0.03206579f, -0.37482801f, 0.29226243f, -0.78697336f, -0.73380452f, 0.05844987f, 0.39656377f, 
    0.03934876f, 0.18912277f, -0.10048164f, -0.46231568f, 0.34381279f, -0.26315755f, -0.28090531f, -0.01602511f, 
    0.10299820f, 0.10860304f, 0.06577308f, 0.34795895f, 0.10632803f, 0.04901344f, -0.16360006f, -0.26353142f, 
    -0.24919698f, -0.09007654f, -0.15788722f, -0.83247375f, -0.32217339f, 0.16734917f, 0.16309220f, 0.14125195f, 
    0.16855726f, -0.05736781f, 0.31572181f, 0.21782880f, 0.08711324f, -0.37002155f, 0.30780941f, -1.11767936f, 
    0.10214362f, -0.02287679f, -0.08397753f, -1.01871562f, -0.12906799f, 0.02341169f, 0.04719980f, 0.10072095f, 
    0.18736756f, -0.02463760f, -0.17639717f, 0.23099999f, 0.14753230f, -0.03681204f, 0.04210503f, 0.07311895f, 
    0.07456471f, 0.51109529f, -0.02395195f, 0.36564189f, 0.14345349f, 0.08196291f, 0.08922126f, 0.06148906f, 
    -0.11018731f, 0.00251316f, 0.13237695f, -0.17633176f, 0.57623470f, 0.69920522f, -0.07581349f, -0.80346090f, 
    0.11981209f, 0.13706166f, -0.15505232f, -0.61403865f, -0.20585953f, -0.10467858f, 0.04012879f, -0.12213868f, 
    -0.03118714f, -0.04419419f, 0.19079699f, -0.95531446f, -0.11461862f, 0.17075449f, -0.90080911f, -0.09770381f, 
    0.26089060f, 0.34541389f, 0.09354465f, 0.29983401f, -0.02433696f, -0.08822833f, -0.20021759f, -0.20178971f, 
    0.10036798f, -0.00956099f, -0.14656641f, 0.11968657f, -0.04505977f, 0.40993074f, -0.60634971f, 0.02902161f, 
    0.04013174f, 0.09431315f, -0.01261833f, -0.64046699f, -0.67605501f, 0.17730680f, 0.03675706f, 0.03440855f, 
    -0.70981985f, -0.09539182f, 0.18981715f, -0.00470719f, 0.00928626f, -0.07958084f, 0.54049116f, 0.01039876f, 
    0.05696580f, -0.26569203f, -0.07778608f, -0.59856242f, 0.03540341f, -0.03617062f, 0.09447532f, 0.06813502f, 
    -0.59433168f, -0.40819001f, -0.19724773f, -0.28746191f, 0.37471333f, 0.36900643f, 0.00632548f, -1.31982112f, 
    0.03495171f, -0.21047908f, -0.13352251f, 0.29826725f, -0.37916774f, 0.30170742f, 0.00601696f, -0.04023517f, 
    0.03846221f, -0.50249201f, -0.05809866f, 0.10832712f, 0.05377327f, -0.92804110f, -0.03587549f, -0.07853521f, 
    0.09012169f, 0.15911667f, 0.30650678f, 0.02719191f, 0.04305562f, -0.07549926f, -0.14885896f, -0.09817492f, 
    0.21540260f, -0.03432005f, -0.22876731f, -0.48328796f, -0.10946730f, 0.07858463f, -0.53085577f, -0.40789247f, 
    -0.06762283f, 0.04560043f, -0.00917254f, 0.40941262f, 0.21298964f, 0.30144072f, 0.32080790f, -0.15847874f, 
    -0.06677178f, 0.05998341f, 0.13879171f, -0.05652404f, 0.05395813f, 0.01977929f, 0.17131026f, 0.06660375f, 
    0.01627760f, 0.12965402f, 0.02089531f, 0.11422050f, 0.09531916f, 0.08492940f, -0.53967875f, -0.15455365f, 
    -0.10179690f, -0.03974796f, 0.10090289f, -0.55797893f, -0.39303377f, 0.01550633f, 0.03846575f, -0.26904625f, 
    -0.06509075f, -0.07926051f, 0.12708764f, -0.17693160f, 0.16030093f, -0.10839042f, -0.07833397f, 0.08535168f, 
    0.06534386f, 0.06933954f, 0.22662243f, -0.11896735f, -0.11392129f, -0.12193004f, 0.26354519f, 0.03870810f, 
    0.09207305f, -0.24373686f, -0.40258965f, 0.12066869f, 0.25801799f, 0.27757990f, 0.16308476f, 0.20968069f, 
    -0.28213874f, 0.04542710f, -0.02432062f, 0.02674184f, -0.06521360f, 0.10110769f, -0.47314724f, 0.38529038f, 
    0.14172594f, 0.14315681f, -0.19378646f, -0.02908497f, 0.12051577f, -0.25287443f, -0.03759766f, -0.08350141f, 
    0.46987870f, -0.26333025f, 0.07406764f, 0.24904782f, -0.69995570f, 0.05947868f, -0.08565527f, -0.04539990f, 
    -0.01761465f, 0.11608178f, -0.09494332f, -0.03578582f, 0.06037008f, -0.04619958f, -0.07061922f, -0.07632244f, 
    0.02686726f, 0.17757232f, 0.00558346f, 0.05756944f, 0.21142493f, -0.41451380f, 0.05407803f, -0.78175783f, 
    -0.21318895f, -0.00631813f, 0.16771820f, -0.29609019f, 0.24728864f, 0.06573344f, 0.04048298f, -0.13843773f, 
    0.07413263f, 0.08836184f, 0.11529874f, -0.08691212f, -0.04121776f, -0.24222010f, -0.03177552f, 0.15543835f, 
    0.01226835f, -0.11907858f, -0.44845656f, -0.26673377f, -0.12762024f, 0.17120090f, 0.04196839f, 0.16359298f, 
    -0.54953355f, -0.06548824f, -0.80726522f, -0.26152310f, -0.11631586f, -0.05776925f, 0.23121907f, 0.06618698f, 
    0.29116708f, -0.23304941f, 0.07051380f, 0.03609128f, -0.19398642f, -0.15822594f, -0.07606225f, -0.02717528f, 
    -0.45237088f, 0.17024356f, 0.20957777f, 0.12367533f, -0.21149477f, 0.17756379f, 0.24361898f, -0.04829431f, 
    0.05313088f, -0.25088605f, -0.13187899f, -0.05382150f, -0.31546965f, 0.10054666f, -0.08694544f, -0.13074750f, 
    0.03964487f, 0.26947263f, 0.01413978f, -0.17961207f, -0.30398560f, -0.72682124f, 0.06306832f, 0.08200090f, 
    0.22771376f, -0.06494406f, -0.47896856f, -0.02619960f, -0.03329524f, 0.12323591f, 0.20808700f, 0.01472112f, 
    -0.65421712f, 0.15969169f, -0.02341637f, -0.46066561f, 0.04678513f, 0.09710832f, -0.61280268f, -0.09091094f, 
    -0.60741222f, 0.03671030f, 0.36839944f, 0.61425692f, -0.29913154f, 0.20713834f, -0.12124296f, -0.81757152f, 
    -0.09931193f, -0.11278001f, -0.40561566f, -0.06337621f, 0.00864874f, 0.72471756f, -0.01313676f, -0.04093806f, 
    -0.73423553f, 0.23281865f, -0.00832616f, -0.74104351f, -0.10022365f, 0.02476342f, 0.06585634f, 0.06742319f, 
    -1.01326692f, -0.57818699f, -1.12675941f, -0.55365592f, 0.19894373f, -0.03889993f, -0.80463755f, -0.03408823f, 
    0.01070388f, -0.48740742f, -0.13569289f, -0.31895092f, -0.01494310f, -0.21597078f, -0.20226963f, -0.16810793f, 
    0.00079118f, -0.10251407f, 0.07170152f, -0.03571979f, 0.21675456f, 0.84545392f, -0.03259267f, -0.09146484f, 
    0.03783716f, -0.36078724f, -0.06395761f, 0.12716484f, 0.12387514f, -0.08308344f, -0.15835910f, 0.12602450f, 
    0.20267962f, -0.29657075f, 0.06410536f, -0.60760349f, 0.09825929f, 0.11054383f, 0.25769341f, -0.31510308f, 
    0.64393085f, -0.34206557f, -0.18432118f, 0.27504596f, 0.44443607f, -0.64149249f, 0.20903407f, -0.78029591f, 
    -0.12695712f, -0.11865040f, -0.24832992f, -0.15565421f, 0.04495547f, -0.28562871f, -0.30947089f, 0.08413807f, 
    -0.05285659f, 0.13600102f, -0.10947430f, 0.07545134f, 0.23197600f, 0.03902141f, 0.06804073f, -0.18466893f, 
    -0.02445406f, -0.13369839f, -0.41562507f, -0.45351821f, 0.13851863f, -0.13021605f, -0.99585766f, 0.07087512f, 
    0.07127440f, -0.38596177f, 0.02216480f, -0.26097679f, 0.21322609f, 0.07048920f, -0.06773637f, -0.22333820f, 
    0.05883865f, 0.13309614f, 0.28231826f, 0.24977712f, 0.19505332f, -0.09524301f, 0.08691965f, -0.07405914f, 
    0.13216449f, 0.29059714f, -0.11983786f, -0.55432069f, -0.13181892f, 0.28099141f, 0.33211607f, -0.13235824f, 
    -0.06398444f, 0.01506807f, -0.27661365f, -0.41113651f, 0.07737235f, -0.11574139f, -0.08328544f, 0.17906564f, 
    -0.27441213f, -0.16088013f, 0.17741421f, -1.09289956f, -0.39644879f, -0.71375191f, -0.49184093f, 0.30093420f, 
    -0.24157667f, 0.01904780f, 0.24424772f, 0.12488446f, -0.03985664f, -0.58182573f, 0.03817112f, -0.45517799f, 
    0.32605672f, 0.08662213f, -0.10613300f, 0.21242382f, -0.36819819f, -0.22431675f, -0.06739976f, -0.13701051f, 
    -0.37208712f, 0.43386105f, -0.12311134f, -0.78735441f, 0.25275093f, 0.24538377f, 0.20491950f, -0.06062914f, 
    -0.08923310f, -0.26161686f, -0.21930572f, -0.62927490f, -0.59891152f, -0.04354431f, -0.13592072f, 0.09498318f, 
    0.13429227f, -0.09386095f, 0.04324840f, -0.54026395f, -0.43729186f, 0.14249593f, -0.04027196f, 0.23240893f, 
    0.13955463f, -0.29806292f, -0.28253892f, -0.08835229f, -0.27798569f, 0.08577667f, 0.19764790f, -0.06244560f, 
    0.27455598f, -0.11494087f, 0.01057058f, -0.25492135f, -0.01446454f, 0.26926342f, 0.05443337f, -0.00913047f, 
    -0.32830778f, 0.07152066f, 0.14157641f, 0.14407635f, 0.14743836f, 0.46807644f, 0.04257010f, 0.46266097f, 
    0.21386673f, -0.12364528f, -0.31326923f, 0.08105572f, 0.05844912f, 0.12626339f, -0.30491295f, -0.73630869f, 
    -0.51577020f, 0.18255331f, -0.08440809f, -0.29227403f, -0.38239279f, -0.14913338f, -0.04190580f, -0.23050837f, 
    0.50351727f, -0.43270710f, 0.12150741f, -0.08481546f, -0.07550851f, -0.45166081f, -0.24252114f, 0.09461585f, 
    0.07954121f, -0.11977601f, -0.44031146f, -0.15890807f, 0.31734440f, -0.54374856f, -0.39287373f, 0.19189721f, 
    0.00291042f, -0.36966252f, 0.17526738f, 0.12338301f, -0.19968791f, -0.74812597f, -0.10659729f, -0.22254556f, 
    -0.25591040f, 0.31868225f, 0.30111608f, 0.52626616f, -0.44834277f, 0.05664758f, -0.72027314f, 0.07390373f, 
    -0.68018806f, 0.02233573f, -0.36219051f, -0.05062342f, 0.03320296f, 0.01947583f, -0.16406436f, 0.33559585f, 
    -0.32972127f, 0.30752757f, -0.44184324f, -0.24350594f, 0.01316610f, -0.56407684f, -0.33468577f, -0.13500161f, 
    0.42009708f, -0.02385242f, -0.35556915f, -0.85440642f, -0.10006858f, -0.94741958f, 0.30280215f, -0.15948452f, 
    0.15255250f, 0.18620454f, -0.00043878f, -0.32310131f, -0.67127341f, 0.22027835f, -0.36405811f, 0.00936181f, 
    -0.29334724f, 0.14357997f, 0.20306541f, 0.38592911f, -0.39252666f, -0.13921657f, 0.19613904f, -0.07262661f, 
    -0.07915717f, -0.58251351f, 0.25937140f, 0.02397510f, -0.18489748f, 0.20013224f, -0.42478493f, -0.06003581f, 
    0.24109286f, 0.17637937f, 0.03556637f, 0.22666867f, 0.42598727f, -0.37083304f, -0.03226266f, -0.02407228f, 
    0.10738329f, -0.18009521f, 0.04603482f, 0.35885581f, -0.27948910f, 0.18324304f, -0.10587844f, 0.00193392f, 
    -0.38189065f, 0.16292755f, -0.56932223f, -0.07144984f, 0.10694512f, -0.43582508f, 0.16697025f, 0.19211836f, 
    0.48161060f, -0.33153263f, 0.09824964f, 0.16426243f, -0.40118510f, -0.06486319f, -0.23780248f, -0.73852539f, 
    -0.38304397f, 0.00315290f, -0.18950541f, 0.15073337f, -0.02384399f, -0.04915711f, 0.06461791f, -0.29760641f, 
    -0.31018990f, 0.08066213f, -0.00118914f, -0.35709581f, -0.62448311f, 0.21053937f, -0.07064302f, -0.26841596f, 
    -0.67941183f, 0.49586314f, -0.31457293f, -0.57307017f, 0.22286759f, -0.19665761f, -0.29532269f, -0.06242637f, 
    0.02920866f, 0.04562511f, -0.44512445f, -0.14954162f, -0.13286160f, -0.42671824f, -0.10856001f, -0.05827042f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12659805f, 0.11705122f, 0.28547868f, 0.08950684f, 0.03193118f, -0.11046889f, -0.09674873f, -0.14814916f, 
    0.09211470f, 0.12598430f, 0.09368841f, -0.03877730f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
