#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.35648263f, 0.01169608f, -0.03648812f, -0.08505964f, 0.20235197f, -0.09923836f, -0.30070728f, -0.21186355f, 
    0.47510448f, 0.13629656f, -0.06616849f, -0.00135260f, -0.05203000f, -0.16057764f, -0.05561435f, 0.23495889f, 
    0.02521933f, 0.07994370f, 0.01830233f, 0.15012951f, -0.15001656f, -0.20191057f, -0.14712949f, 0.24859190f, 
    0.26229379f, 0.35144559f, 0.32694083f, -0.03629718f, 0.13615026f, -0.28812093f, -0.10595791f, -0.50309038f, 
    -0.02066273f, 0.18451931f, 0.11807083f, -0.00800435f, -0.23034447f, 0.32880485f, -0.00950059f, -0.25708696f, 
    -0.17184365f, 0.17316179f, 0.34666401f, -0.17493540f, -0.12744254f, -0.20486178f, 0.15199956f, -0.18043885f, 
    0.16988853f, -0.38245034f, 0.05250853f, 0.68933862f, 0.15489967f, -0.41969401f, -0.56931341f, -0.52207345f, 
    -0.11594198f, 0.26415637f, 0.03782955f, -0.23029464f, -0.03178113f, 0.27548209f, 0.14952011f, 0.54253083f, 
    -0.21252024f, -0.22113001f, 0.03778258f, -0.20309566f, 0.10361894f, -0.28182897f, 0.19411443f, -0.03740238f, 
    -0.11682847f, 0.05529781f, -0.06031911f, -0.01217650f, -0.27044374f, -0.64948756f, -0.16440275f, 0.28538275f, 
    -0.24582845f, -0.13530810f, -0.24347027f, -0.41659343f, -0.45615461f, -0.08033134f, 0.60049015f, -0.16034852f, 
    -0.20742798f, -0.39382562f, 0.02151353f, 0.34789711f, 0.05255775f, 0.23308855f, 0.34684876f, -0.12013943f, 
    -0.08630394f, -0.18593727f, -0.19391418f, -0.16642499f, 0.02148911f, -0.09414885f, 0.38697273f, -0.25955272f, 
    -0.52229309f, -0.12873471f, -0.01877592f, 0.11074041f, 0.09360076f, 0.37635192f, -0.11718593f, -0.37802047f, 
    0.32808444f, -0.53100514f, 0.26712939f, -0.27085298f, -0.21801694f, 0.25715300f, 0.22061802f, -0.11796204f, 
    0.12124422f, 0.15343533f, 0.04306935f, -0.04789893f, 0.11063071f, -0.26364595f, -0.54752743f, -0.40097976f, 
    -0.19491377f, -0.29336709f, -0.64732051f, -0.70032752f, -0.57198626f, -0.62097484f, -0.17158264f, -0.02678097f, 
    -0.10507771f, 0.33109236f, 0.58864146f, 0.18529673f, 0.10519108f, -0.16403143f, -0.19639061f, -0.32470584f, 
    -0.24834131f, -0.18293488f, -0.03776638f, -0.05222442f, 0.06453239f, -0.36993071f, 0.52346140f, 0.16433421f, 
    0.11974443f, 0.14861064f, -0.56109494f, -0.22003175f, 0.14352557f, 0.40454102f, -0.45038465f, -0.13190611f, 
    -0.21196836f, 0.26000667f, -0.08745764f, 0.09127340f, -0.39663085f, 0.11746031f, 0.13248813f, -0.10227454f, 
    -0.17078397f, 0.10459476f, 0.09498890f, -0.29079458f, -0.12135840f, 0.11702484f, 0.02239829f, -0.45039228f, 
    -0.72942781f, -0.30272475f, 0.46520233f, 0.45796663f, 0.06474383f, -0.22001044f, -0.68903750f, -0.60694718f, 
    -0.57628405f, -0.03271224f, -0.33156267f, -0.03984063f, 0.21924591f, -0.14877199f, -0.24308100f, -0.27806437f, 
    0.00661411f, 0.11842541f, -0.09388588f, -0.03890803f, -0.30248317f, -0.14770901f, 0.08553703f, 0.26741487f, 
    0.09528146f, -0.27600920f, -0.52308321f, -0.27787110f, -0.47678187f, 0.43158662f, -0.44653922f, -0.36709154f, 
    0.14105938f, 0.27373466f, 0.04982253f, 0.22165135f, 0.00314243f, -0.30926862f, 0.04421202f, 0.06152366f, 
    0.20066927f, 0.20487760f, 0.01708047f, 0.05221212f, 0.08123516f, -0.14466295f, 0.01998023f, -0.09365380f, 
    -0.43501356f, -0.85273099f, -0.12362885f, -0.18231015f, 0.98079652f, 0.37831032f, 0.38278010f, -0.01383802f, 
    -0.33823711f, -0.74293250f, -0.75218052f, -0.17996204f, 0.02590936f, -0.21080279f, -0.20185624f, -0.07570522f, 
    -0.11379565f, 0.17996415f, 0.20574167f, 0.07202104f, 0.08842744f, 0.19315684f, -0.30031186f, 0.29200146f, 
    -0.26208693f, -0.48717141f, 0.33792076f, 0.46803436f, -0.48330367f, -0.18305543f, 0.00809135f, -0.14197129f, 
    -0.19357184f, -0.26760557f, -0.13278863f, 0.14082015f, 0.27976272f, 0.15740585f, 0.16355415f, -0.09247482f, 
    -0.05929868f, 0.33344251f, -0.02333050f, -0.11684967f, -0.40590465f, -0.13977362f, 0.14854558f, 0.03033952f, 
    0.13025057f, -0.01823625f, 0.30067128f, 0.23438510f, 0.26464757f, 0.30108339f, -0.52040374f, 0.08471421f, 
    -0.19944634f, 0.10176993f, -0.22971392f, 0.23564973f, -0.24266820f, 0.25930610f, -0.25929633f, -0.10519627f, 
    0.02047114f, 0.35327259f, 0.00975181f, -0.08635627f, -0.15963906f, -0.24055789f, 0.27882642f, -0.29450718f, 
    0.33598191f, 0.00009059f, -0.16230200f, -0.00541447f, -0.49320713f, -0.37347120f, -0.58264273f, -0.46440399f, 
    -0.00685767f, -0.41521111f, -0.59647381f, -0.27809119f, 0.00033359f, 0.00777081f, -0.40755823f, -0.51515275f, 
    -0.06761011f, -0.06144788f, -0.19216307f, -0.16301528f, -0.06154782f, -0.27948552f, -0.15628426f, -0.44611466f, 
    -0.38071764f, -0.00929100f, -0.26725349f, -0.30598554f, -0.29617214f, -0.48233205f, 0.77858061f, 0.62655550f, 
    -0.87974864f, -0.48657465f, 0.31673944f, -0.33210158f, -0.00122168f, 0.51618886f, -0.06170525f, 0.20947254f, 
    -0.39774689f, -0.19762646f, -0.30103853f, -0.28586078f, 0.30168432f, 0.03871229f, -0.19128087f, -0.09931941f, 
    -0.29850513f, -0.19911794f, -0.22837225f, -0.22093056f, -0.36854896f, -0.42110184f, 0.44422430f, 0.49445581f, 
    -0.67469740f, -0.10960070f, -0.03236088f, -0.13456070f, 0.32798827f, 0.02361024f, -0.05942590f, -0.14609414f, 
    -0.26639545f, 0.20899187f, 0.01303974f, 0.15995654f, -0.04317471f, 0.14656821f, -0.22979726f, -0.14753231f, 
    0.03121150f, -0.16168945f, 0.14370313f, 0.06151363f, -0.05308580f, 0.02437892f, -0.08069088f, 0.79229313f, 
    0.10129374f, 0.31149268f, 0.44387627f, -0.32812518f, -0.07610706f, -0.29620603f, -0.07990487f, -0.20461808f, 
    -0.45752105f, 0.18012406f, -0.06296297f, 0.07533315f, -0.01593472f, -0.32038096f, -0.12950325f, -0.18312274f, 
    0.19992766f, -0.11098927f, 0.27119040f, 0.08790150f, 0.07761544f, -0.14146660f, 0.12793015f, 0.02666180f, 
    0.37843093f, -0.11195592f, -0.22142354f, 0.02681990f, 0.15364774f, 0.05719233f, -0.18300797f, -0.00205904f, 
    -0.19800505f, -0.05758022f, -0.12929402f, -0.02579547f, 0.22460935f, 0.08830894f, -0.09328833f, 0.21444166f, 
    -0.00992052f, -0.00260956f, -0.14261825f, -0.47195786f, -0.11833487f, 0.19306894f, 0.16384506f, 0.30405661f, 
    0.17875698f, -0.07914962f, -0.00939537f, -0.19545747f, -0.48145810f, -0.28757769f, 0.23186029f, 0.04462241f, 
    0.22779572f, -0.39061844f, -0.61532497f, 0.05944843f, -0.10530639f, 0.09932321f, 0.13696808f, -0.42060137f, 
    0.03618395f, -0.28023282f, 0.18431613f, -0.19886604f, -0.00377924f, 0.18245201f, 0.07334362f, 0.12091120f, 
    0.23159550f, 0.25278273f, 0.36274737f, -0.05323329f, 0.38601485f, -0.12334678f, -0.11916426f, -0.38550267f, 
    -0.05599416f, 0.23631306f, 0.23531377f, 0.02565851f, 0.28530946f, -0.16676429f, 0.03818386f, -0.45992079f, 
    -0.13425392f, 0.23515157f, 0.21752246f, 0.04719920f, -0.25903025f, -0.33422542f, 0.08211175f, 0.39395541f, 
    0.17113334f, -0.27907777f, -0.22592519f, 0.32837924f, -0.76119387f, -0.81947100f, -0.58877301f, -0.04596697f, 
    0.55319810f, 0.43803304f, 0.54760683f, 0.30104211f, 0.09733452f, 0.07198011f, 0.00804763f, 0.18444017f, 
    -0.24616987f, 0.20536928f, -0.11112367f, 0.07533083f, -0.03069492f, -0.22844459f, 0.14032336f, 0.15012527f, 
    -0.22654316f, -0.09183477f, 0.15234154f, 0.14769833f, -0.05493413f, -0.45352516f, -0.54459125f, 0.29387733f, 
    0.54868484f, 0.17333364f, 0.29840380f, 0.37130573f, 0.02484492f, 0.02562023f, -0.38626367f, -0.38673672f, 
    -0.33154628f, -0.29065567f, 0.28522035f, 0.10690098f, 0.21821424f, -0.02542460f, -0.17026609f, -0.17353156f, 
    0.04978421f, -0.19233483f, -0.27590075f, -0.33924958f, -0.11637149f, -0.56263298f, -0.10752460f, 0.14215064f, 
    0.16762774f, 0.31967041f, -0.51000375f, -0.26569593f, 0.59966880f, 0.10922721f, -0.04175113f, 0.06507584f, 
    0.02290473f, 0.15019755f, -0.05654635f, -0.21368451f, -0.21491209f, 0.15566257f, 0.23495108f, -0.33083898f, 
    0.00184970f, 0.05085286f, -0.34828541f, -0.07491663f, 0.31371203f, 0.11534987f, -0.44894329f, 0.05201518f, 
    -0.49938068f, 0.01446333f, -0.22919980f, -0.02553486f, -0.03281711f, -0.14799520f, 0.22427413f, 0.62448436f, 
    0.22294772f, 0.02688766f, -0.39656496f, -0.08668030f, 0.35359514f, -0.43514344f, 0.09805353f, -0.00507020f, 
    0.13939519f, -0.29943961f, 0.18788156f, -0.13220528f, 0.24766994f, 0.38866088f, -0.19633055f, 0.40973401f, 
    -0.15754876f, -0.39356330f, 0.02299321f, 0.78310871f, 0.47777757f, -0.01796623f, -0.60627526f, -0.48813847f, 
    -0.57882655f, 0.27366552f, 0.30604985f, 0.48270413f, -0.28062123f, -0.08391874f, -0.07955728f, -0.13605542f, 
    0.10398792f, -0.04513702f, 0.29619920f, -0.26508534f, 0.17228219f, -0.06477112f, 0.15839584f, -0.20593536f, 
    -1.05109215f, 0.53735650f, 0.07264939f, -0.00134140f, 0.16196522f, -0.31625420f, 0.39226836f, -0.06658771f, 
    -0.11936217f, 0.15973885f, -0.28193212f, 0.22256233f, -0.00762849f, -0.37167531f, -0.18428425f, 0.01073442f, 
    0.10740743f, 0.22539012f, 0.00853980f, -0.20922577f, 0.05053833f, -0.19568267f, -0.21716012f, -0.01633351f, 
    0.10010466f, -0.65548223f, -0.26827800f, -0.08605471f, 0.06838035f, 0.06669948f, 0.11431061f, 0.15624636f, 
    0.20819300f, 0.20637144f, 0.26415735f, -0.04529468f, -0.22636546f, 0.18433473f, -0.03898665f, -0.08801737f, 
    0.10775602f, 0.13544975f, -0.53092098f, 0.11358012f, 0.10722671f, 0.35544389f, 0.08300301f, 0.32675961f, 
    -0.12983814f, -0.31926566f, 0.00867970f, 0.19615488f, 0.11598966f, -0.25264642f, 0.17781666f, -0.08783766f, 
    0.15677898f, -0.04481996f, -0.19038311f, 0.11733995f, -0.07652189f, -0.18011534f, 0.12437534f, -0.02679287f, 
    -0.22874674f, 0.11242798f, 0.35835832f, -0.27837235f, -0.06056132f, -0.15502614f, -0.06999981f, 0.19348697f, 
    0.22904606f, 0.11988001f, -0.18646879f, -0.92602533f, -0.90132540f, -0.31612158f, 0.26842046f, 0.78444058f, 
    0.59175503f, 0.61539745f, 0.26289183f, -0.12167875f, -0.02134023f, -0.21077207f, -0.33761123f, -0.30277717f, 
    -0.22365102f, 0.33360034f, 0.10922921f, 0.06059803f, 0.10236292f, 0.08805824f, -0.12566952f, 0.14108865f, 
    -0.12970391f, 0.01879568f, -0.11047290f, -0.11879109f, -0.82700413f, -0.57188433f, -0.51409107f, 0.41059732f, 
    0.02967058f, -0.03947480f, -0.28795698f, 0.10700644f, 0.32355937f, 0.41822696f, 0.19510362f, 0.17432816f, 
    -0.16807045f, 0.19987208f, 0.12180868f, 0.06165602f, -0.09145792f, -0.19390222f, 0.14671965f, 0.02744863f, 
    -0.19294250f, -0.20442703f, -0.07826237f, 0.20307922f, -0.17885488f, 0.62465155f, 0.24083757f, -0.34458306f, 
    -0.12751952f, -0.43809879f, -0.20217171f, 0.06490859f, 0.29347593f, -0.01002040f, -0.10919596f, -0.19816108f, 
    -0.12396951f, -0.03506197f, 0.41419500f, 0.08443367f, 0.28139028f, -0.34994650f, -0.36774707f, 0.36939344f, 
    -0.29907927f, -0.22068271f, 0.00125239f, 0.09083879f, 0.16963668f, -0.28690577f, -0.31668052f, -0.57869959f, 
    -0.20953868f, -0.21810618f, 0.56202608f, 0.39544231f, 0.22840434f, -0.21587537f, -0.14717500f, 0.04746550f, 
    0.21466775f, -0.18840411f, 0.34108630f, -0.48259610f, -0.08196798f, -0.07835932f, -0.25921500f, 0.08242943f, 
    0.23703545f, 0.07298207f, -0.46846661f, 0.10151795f, -0.20235886f, -0.33193195f, -0.17111304f, 0.35306549f, 
    0.49367630f, 0.43718845f, 0.40498036f, 0.42364803f, -0.00818118f, -0.07710097f, -0.13767669f, 0.11786672f, 
    -0.16045111f, -0.17721774f, -0.23816369f, 0.10789777f, 0.14208630f, -0.04660976f, -0.16426869f, -0.01464157f, 
    -0.20320562f, -0.05555387f, 0.13108554f, 0.03232063f, -0.01492055f, -0.11479781f, 0.06067082f, -0.14973941f, 
    0.16943100f, -0.46512112f, -0.07953599f, 0.44951588f, 0.45165685f, -0.46078500f, -0.34915933f, -0.28097546f, 
    -0.34964934f, -0.01797026f, 0.32522738f, 0.02247948f, -0.03665364f, 0.23223858f, 0.32577917f, -0.13655436f, 
    0.33928531f, -0.07929718f, 0.08658552f, 0.07683773f, -0.17686364f, -0.23531543f, 0.09217092f, 0.15512070f, 
    -0.29379073f, 0.07661393f, 0.64081907f, -0.23701233f, -0.50442070f, -0.10718359f, 0.01471354f, -0.09619278f, 
    0.09182014f, 0.32110468f, -0.38529748f, 0.01209162f, -0.19166222f, -0.00268361f, -0.03959237f, -0.31276706f, 
    -0.11314332f, -0.16516204f, 0.03683482f, -0.35307050f, 0.02387277f, 0.14103375f, 0.30506179f, 0.21001917f, 
    0.10354000f, -0.09655739f, -0.40343687f, -0.79056346f, -0.65212959f, -0.62301385f, -0.60855174f, 0.80104327f, 
    0.54584986f, -0.02487701f, 0.27223936f, 0.30252451f, 0.04493207f, 0.11278943f, -0.41147307f, -0.06184128f, 
    -0.50160229f, -0.01887521f, 0.15950632f, 0.04162306f, -0.04792682f, -0.32182744f, -0.01934313f, -0.11838798f, 
    -0.14449458f, -0.16674408f, -0.14392930f, 0.65688068f, 0.39887094f, -0.09596421f, -0.37250501f, -0.59337366f, 
    0.12714431f, 0.02901402f, -0.08811079f, -0.28601313f, 0.03377997f, 0.16931592f, -0.14606623f, 0.16803765f, 
    -0.06129548f, -0.10631744f, -0.23385008f, 0.10601970f, -0.04298808f, -0.30677399f, -0.50926316f, -0.42891660f, 
    -0.49568546f, -0.33736429f, -0.47609818f, -0.50515777f, -0.27583474f, 0.26028833f, 0.51812124f, 0.19125910f, 
    -0.14113088f, -0.65078992f, -0.44966134f, 0.33300588f, -0.14545102f, -0.07726762f, -0.31357691f, -0.15928595f, 
    0.09491744f, 0.43299803f, -0.17182179f, 0.29656428f, 0.02187346f, 0.24485162f, -0.28890663f, -0.14419071f, 
    -0.07509375f, -0.03132202f, -0.20439798f, -0.32666746f, -0.34289271f, 0.19665520f, -0.34283578f, -0.56181705f, 
    0.08298595f, -0.55551499f, 0.78056133f, 0.07504340f, 0.03687375f, -0.04825229f, 0.46413860f, -0.04302692f, 
    0.23388797f, -0.17955035f, 0.01284534f, 0.02987799f, 0.00212280f, -0.24755746f, 0.14335138f, 0.00083037f, 
    -0.29006684f, -0.15274759f, 0.00660182f, -0.16100550f, 0.01099415f, 0.28926817f, 0.61737049f, 0.32860324f, 
    -0.30746910f, -0.05863351f, -0.61821568f, -0.06412606f, 0.03296468f, 0.25150868f, 0.13705662f, -0.20500140f, 
    0.20650521f, 0.11129869f, -0.03686767f, 0.12025103f, -0.26828602f, -0.18705755f, -0.18518597f, 0.34825501f, 
    -0.13339007f, -0.10869053f, 0.16304490f, -0.02296240f, -0.23211865f, 0.14879379f, 0.27203411f, 0.45504355f, 
    0.33068198f, -0.01220570f, -0.32738379f, -0.00917622f, -0.05010550f, 0.01977459f, -0.19046518f, -0.23576161f, 
    -0.16967474f, -0.05506061f, 0.26486579f, -0.13849770f, 0.11909213f, 0.21328993f, -0.29296622f, -0.39815286f, 
    0.30904576f, 0.08548948f, 0.09323887f, 0.05097841f, 0.13714644f, 0.01090038f, -0.50936288f, 0.08127162f, 
    -0.93649757f, -0.78199589f, -0.58726054f, -0.08463462f, -0.52901739f, 0.11989029f, 0.53695929f, 0.10520348f, 
    -0.59868866f, -0.38344336f, 0.14355461f, -0.31445718f, -0.38983297f, 0.00718752f, -0.10048504f, -0.11517504f, 
    0.26341376f, -0.27954429f, -0.49683127f, 0.02949119f, 0.01118905f, -0.29377738f, 0.11143955f, 0.37943366f, 
    -0.24431042f, -1.04766560f, -0.30174825f, 0.16882281f, 0.55078566f, 0.71511281f, 0.21248701f, -0.74072754f, 
    -0.41581878f, -0.20086212f, 0.33295721f, 0.04000427f, 0.15673389f, -0.25380129f, 0.44069397f, 0.02798036f, 
    0.09183306f, -0.19780472f, 0.01404110f, 0.18160069f, -0.18388639f, -0.03954865f, -0.12912001f, 0.17103781f, 
    -0.03190849f, -0.30053163f, -0.62778246f, 0.56813884f, 0.19267152f, -0.12973063f, 0.18162556f, -0.41818485f, 
    -0.43387243f, 0.25323901f, -0.04349413f, -0.23787758f, -0.27901134f, -0.46707463f, 0.34526351f, -0.26339477f, 
    -0.07515280f, 0.40211293f, 0.12957110f, -0.09147441f, -0.02147698f, -0.26928344f, -0.17096522f, -0.14402226f, 
    -0.20140868f, 0.01995699f, -0.30169576f, 0.21254022f, -0.22412564f, -0.09753601f, 0.26247972f, 0.26193357f, 
    -0.01283718f, -0.10078374f, -0.36285836f, -0.53105825f, 0.02947541f, 0.13245048f, 0.38951594f, -0.60117203f, 
    0.19740489f, 0.23235844f, 0.20790172f, 0.10698971f, 0.14425278f, 0.03368862f, -0.41323721f, -0.20481865f, 
    0.04731952f, 0.15579459f, 0.12304682f, -0.17844884f, 0.12615338f, -0.63600755f, 0.00438164f, 0.10697064f, 
    -0.66951561f, -0.80032772f, -0.73114055f, -0.54995829f, -0.29585505f, -0.77755344f, 0.56625587f, 0.18675919f, 
    0.22529580f, 0.31831375f, 0.03641852f, -0.15615802f, 0.14235784f, -0.04090513f, -0.08473913f, -0.35498336f, 
    -0.02231050f, 0.11442374f, 0.15042318f, 0.07007784f, -0.20523472f, 0.37123814f, 0.18542187f, 0.00519638f, 
    0.20869371f, -0.21056540f, -0.27315551f, 0.06204642f, 0.08455970f, -0.20390069f, 0.24649726f, 0.27944270f, 
    0.07608488f, 0.18442142f, -0.23519510f, -0.22997811f, 0.13809437f, -0.27439880f, 0.19478604f, 0.15159869f, 
    -0.24882570f, 0.26134279f, 0.09252350f, -0.09008142f, -0.06622171f, -0.17820500f, -0.23252077f, 0.08194999f, 
    0.08509606f, 0.27167940f, -0.11316984f, 0.08994883f, 0.49951848f, 0.18075892f, 0.12947254f, 0.09260248f, 
    0.10857376f, 0.11823014f, 0.12253312f, -0.02160681f, -0.34146297f, 0.07833432f, 0.06444932f, -0.13348652f, 
    0.03861428f, -0.16321696f, 0.22163589f, -0.13147593f, -0.00016963f, -0.09297615f, 0.13908155f, 0.42977098f, 
    0.26956975f, 0.03469524f, -0.23573704f, -0.05534237f, -0.15540643f, 0.08090986f, 0.05188162f, 0.14187226f, 
    0.26332319f, -0.03445211f, -0.10265645f, 0.21412134f, -0.31449142f, -0.15263435f, 0.16379602f, -0.24379544f, 
    -0.06758825f, -0.01444493f, -0.24978250f, -0.03315454f, -0.00283758f, 0.00878199f, 0.17001116f, -0.08113369f, 
    0.67708093f, -0.48856801f, -0.67725158f, -0.64754176f, -0.39156303f, -0.23077153f, -0.34094679f, 0.10153264f, 
    0.23628937f, 0.28440237f, -0.05899404f, 0.33464998f, 0.54401296f, -0.19119482f, 0.00197108f, -0.11863018f, 
    -0.16105278f, 0.15961660f, -0.04152855f, 0.05869969f, -0.05337847f, -0.45543423f, -0.34434211f, 0.39742699f, 
    0.00020693f, 0.92579603f, 0.23930939f, -0.32615092f, -0.31108487f, 0.17293805f, 0.36995268f, -0.46914443f, 
    -0.32293656f, -0.39467648f, -0.73584962f, 0.02796036f, 0.26747507f, -0.14605805f, 0.02287414f, 0.40655294f, 
    0.01887603f, 0.18078181f, 0.14373556f, -0.15897371f, -0.05494203f, -0.18158707f, -0.07391978f, 0.14458576f, 
    0.09346252f, -0.03053070f, -0.07735815f, -0.12765132f, -0.22172299f, -0.43080881f, -0.52711970f, -0.02586773f, 
    0.43221942f, -0.43971118f, 0.85240763f, -0.19144292f, -0.10261060f, 0.15588838f, -0.22085655f, -0.19556323f, 
    -0.40241000f, 0.05307635f, -0.69696206f, -0.38266706f, 0.19648848f, 0.55724663f, -0.19553259f, 0.01657719f, 
    0.13461839f, -0.12852082f, 0.21780404f, -0.11407935f, 0.04016299f, -0.00589582f, -0.39439926f, -0.08217835f, 
    0.13251525f, 0.14814819f, 0.21966040f, 0.05062423f, -0.07941411f, -0.02780801f, 0.54070348f, -0.26468572f, 
    -0.41823640f, 0.22697014f, -0.35449567f, -0.11829410f, -0.08818310f, -0.24708889f, 0.33365765f, 0.03454986f, 
    0.25691730f, -0.02112327f, 0.19772302f, 0.18798923f, -0.06843890f, 0.60910869f, -0.01020093f, -0.47044966f, 
    -0.38850236f, 0.25112280f, 0.42248973f, 0.08535928f, -0.20680512f, -0.24518174f, -0.16637555f, 0.47251150f, 
    -0.35882181f, -0.02328641f, 0.15363492f, 0.34204400f, -0.03917081f, 0.06457806f, -0.07411423f, -0.40365288f, 
    -0.12687428f, 0.08764172f, 0.27093473f, 0.16332804f, -0.17691559f, -0.42660317f, -0.37316164f, -0.32721317f, 
    -0.45304617f, -0.44768962f, 0.12624623f, -0.13544115f, -0.56245470f, -0.28932232f, 0.26905292f, -0.14009212f, 
    -0.05929929f, 0.03207704f, -0.25288257f, 0.30067733f, 0.12931445f, 0.20549878f, 0.04620219f, 0.26565325f, 
    0.19473122f, -0.21936227f, 0.07465813f, 0.21904515f, -0.27888054f, -0.28876901f, 0.32246032f, -0.00776240f, 
    0.18906333f, 0.25060055f, 0.17802139f, 0.15102851f, 0.19650662f, -0.00187446f, -0.07749508f, -0.16039541f, 
    0.06603672f, 0.01486175f, 0.12524204f, 0.04025272f, 0.25852138f, -0.09342133f, -0.26330939f, 0.18789969f, 
    -0.02832684f, -0.03619287f, -0.05323656f, 0.12824962f, 0.01535216f, -0.06444225f, -0.05806959f, -0.54580009f, 
    -0.32616985f, -0.35462293f, -0.27072018f, -0.24246742f, -0.33542806f, -0.46716103f, -0.30169484f, -0.35022706f, 
    -0.08272982f, 0.17336017f, -0.00366383f, 0.22705460f, -0.15083511f, -0.13445851f, 0.02344070f, -0.16900246f, 
    -0.00863823f, 0.02487271f, 0.00011428f, 0.29065716f, 0.26514852f, 0.23951285f, 0.26765168f, 0.09829655f, 
    -1.11237967f, -0.55226564f, -0.38372913f, -0.79683888f, -0.04781657f, 0.06334610f, -0.11585872f, 0.43511441f, 
    0.56156617f, 0.26580882f, -0.06658521f, 0.04923403f, -0.02635728f, -0.02062221f, 0.25617179f, 0.03725025f, 
    -0.08337113f, -0.06383550f, 0.06305099f, -0.30032799f, -0.26275489f, 0.39095396f, -0.07500621f, -0.02688803f, 
    -0.13918379f, 0.19267741f, -0.87719083f, -0.54472101f, 0.11688434f, 0.09114191f, 0.60693914f, 0.56955528f, 
    -0.29967552f, -0.00476236f, -0.14156474f, -0.29185849f, 0.06562503f, 0.05400225f, 0.16071168f, 0.08247626f, 
    0.01621623f, 0.06368077f, -0.21979819f, -0.20274429f, 0.08979429f, 0.00641833f, -0.01993641f, 0.04674927f, 
    0.28192329f, -0.01705771f, -0.54992151f, -0.18718989f, -0.41292739f, -0.29901755f, 0.07835156f, -0.25825894f, 
    -0.34227923f, -0.18150941f, -0.00052446f, -0.17380987f, 0.44397905f, 0.15933999f, 0.05463731f, -0.11846083f, 
    0.03012382f, -0.16827485f, -0.03270209f, 0.12268447f, 0.19658118f, 0.04205884f, -0.20813026f, 0.01580761f, 
    -0.04919735f, -0.16247708f, -0.33138570f, 0.44444817f, 0.35658225f, 0.16633503f, -0.53703308f, -0.35107714f, 
    0.27922893f, 0.15918609f, 0.02321399f, -0.58652395f, -0.67161942f, -0.20835887f, -0.23933989f, -0.04469146f, 
    0.20554452f, -0.25680098f, -0.02039603f, -0.07270955f, 0.14153486f, -0.31194013f, -0.18764092f, -0.39520019f, 
    -0.33847514f, -0.18896817f, 0.29603696f, 0.04849043f, -0.16408315f, -0.48423269f, -0.10445777f, 0.23406504f, 
    0.04068931f, -0.20160650f, 0.19638988f, 0.32102251f, 0.07042611f, 0.19059774f, -0.22691025f, -0.11492375f, 
    -0.02752020f, 0.00341921f, 0.07298200f, -0.26202047f, 0.07383429f, -0.03289361f, 0.21363884f, -0.26329610f, 
    0.28088179f, 0.33713311f, 0.29753658f, -0.18448193f, 0.09429112f, 0.38831815f, 0.21743996f, -0.48853967f, 
    0.26242000f, -0.36371270f, -0.37678701f, -0.32306334f, -0.07076327f, -0.10864380f, 0.19376802f, 0.16533700f, 
    -0.49621123f, -0.00716097f, 0.24200711f, -0.42307281f, 0.04354052f, 0.12836379f, 0.22192459f, 0.04409140f, 
    -0.15980503f, -0.23649183f, -0.06154165f, 0.22348376f, 0.05449849f, 0.35599351f, -0.98326093f, 0.14749864f, 
    0.47772297f, 0.19880523f, 0.25706193f, -0.15491383f, 0.18440974f, 0.00839372f, -0.23496553f, 0.14204787f, 
    0.21571116f, -0.14250015f, -0.30108896f, 0.39202648f, -0.17967105f, -0.13541144f, 0.08565322f, -0.25042334f, 
    0.01704931f, 0.29435402f, -0.15180622f, -0.02178317f, 0.12428714f, 0.09804164f, -0.23716342f, -1.03254497f, 
    -0.57776332f, -0.19308561f, 0.32724133f, 0.19785199f, 0.21282925f, -0.05976231f, 0.13232133f, 0.36215669f, 
    0.33668882f, 0.14347257f, 0.07401995f, -0.12242392f, 0.22104096f, -0.17011213f, -0.00521576f, 0.08036400f, 
    -0.35948479f, -0.12833965f, -0.09679838f, 0.29890352f, -0.10370746f, 0.22656308f, 0.17571840f, -0.01064379f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05706177f, 0.28103736f, 0.05918029f, -0.19328947f, 0.12590837f, -0.36201862f, 0.24273852f, 0.19843106f, 
    0.03395282f, -0.17450322f, 0.23762698f, 0.14137965f, -0.07891154f, -0.06785274f, 0.18737690f, 0.18174437f, 
    0.24350460f, 0.07638585f, 0.31420076f, 0.00705026f, 0.10142948f, 0.28538355f, 0.19190420f, 0.06337025f, 
    0.05743921f, -0.13024053f, -0.07678555f, 0.01785008f, -0.04478949f, 0.14552079f, -0.01481721f, -0.26502833f, 
    -0.15756823f, -0.15860175f, 0.05228509f, -0.09115984f, -0.02184367f, 0.10700639f, 0.37896448f, -0.03595926f, 
    -0.26138297f, 0.23164500f, 0.13100205f, 0.03327484f, 0.11466058f, -0.20581646f, -0.14973769f, 0.37599924f, 
    0.42284110f, -0.06148355f, 0.29462966f, 0.04375209f, 0.18811004f, -0.24069592f, -0.17404482f, -0.35387301f, 
    0.13473295f, 0.21172123f, -0.36814412f, 0.19540992f, -0.25706348f, 0.17524816f, 0.15893029f, 0.04250067f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07858931f, 0.14695889f, 0.02193042f, -0.16096142f, -0.14433445f, 0.04574798f, -0.03010508f, -0.02162900f, 
    0.04294943f, -0.01758803f, 0.00023934f, -0.06099152f, -0.56986082f, -0.08642548f, 0.15977943f, -0.09286180f, 
    0.05155156f, 0.00533722f, -0.02834331f, -0.04415230f, -0.03560163f, -0.10334638f, -0.04045171f, 0.10010945f, 
    0.03859449f, -0.37577552f, 0.04208725f, 0.05955387f, 0.03711824f, -0.02400644f, -0.09631563f, 0.03817015f, 
    -0.00856077f, 0.03068196f, -0.01245916f, -0.06671824f, 0.32438532f, 0.11855184f, -0.16101283f, -0.04797120f, 
    0.22914557f, 0.05191126f, 0.14914359f, 0.00461945f, -0.02685210f, 0.05756512f, 0.11012578f, 0.04625389f, 
    -0.01129076f, -0.00275783f, 0.12410644f, -0.05945566f, -0.01614088f, -0.03109899f, -0.07236292f, -0.05027728f, 
    0.02878710f, -0.11225194f, -0.01236697f, -0.11042478f, 0.30062425f, 0.25799349f, 0.01964355f, -0.26745155f, 
    0.00865795f, 0.04789539f, -0.03611359f, 0.01196725f, -0.13143447f, -0.05178682f, -0.00617456f, 0.00799650f, 
    -0.44218481f, -0.39799425f, 0.04017657f, -0.22024125f, 0.00619519f, 0.05121871f, -0.01561224f, 0.02070970f, 
    -0.03365590f, -0.03440015f, -0.05675725f, 0.00902871f, 0.39036080f, 0.00648989f, -0.10225000f, -0.24730031f, 
    0.12199178f, -0.02027385f, 0.07459560f, -0.08482242f, -0.05386980f, -0.09337152f, -0.07024845f, -0.08527682f, 
    0.22812055f, 0.14038830f, -0.03258925f, 0.03078034f, 0.04247253f, 0.04334059f, -0.04148327f, -0.03863136f, 
    0.02282220f, 0.12885170f, 0.04830045f, 0.09344231f, 0.42551646f, 0.10205660f, 0.01395193f, 0.08451518f, 
    0.11540933f, -0.00001290f, 0.15075511f, -0.01401477f, -0.03426968f, -0.04584010f, 0.03014824f, 0.02049463f, 
    0.11309208f, 0.11235500f, -0.28744721f, -0.02170839f, -0.09846459f, -0.05601579f, -0.05447122f, -0.29647040f, 
    -0.07613099f, 0.00502782f, -0.09513018f, -0.08300682f, -0.05594242f, -0.24238424f, -0.05434905f, -0.13551563f, 
    -0.08135202f, 0.01408866f, -0.09952246f, -0.01320457f, -0.05214800f, 0.07611898f, -0.02523376f, -0.14147018f, 
    0.24389653f, 0.17806064f, 0.20578797f, 0.01729392f, 0.12285394f, 0.16200085f, 0.09331395f, -0.02100004f, 
    -0.18827996f, -0.18237518f, -0.15326977f, 0.02306439f, -0.24219848f, 0.01497981f, -0.06814577f, -0.05465501f, 
    0.02332533f, 0.11226071f, -0.15579696f, 0.01494728f, -0.02287556f, -0.00780936f, 0.10189445f, -0.05729607f, 
    -0.26140836f, -0.11478972f, -0.46857727f, 0.13725728f, -0.01406616f, 0.03873240f, -0.05609287f, -0.10631838f, 
    0.00203146f, -0.08547574f, -0.15919864f, -0.15989378f, -0.28126669f, -0.42839897f, 0.01405492f, -0.34258974f, 
    -0.00007502f, 0.04558294f, -0.15196329f, 0.03739847f, 0.03919097f, 0.01659760f, 0.05530378f, 0.05176452f, 
    -0.02988911f, 0.04090733f, -0.05092778f, 0.01173579f, -0.09436928f, -0.16251561f, -0.05743913f, -0.06291943f, 
    -0.00654985f, -0.07002585f, -0.10093382f, -0.03167027f, 0.15367107f, -0.08679879f, -0.15649888f, -0.13543545f, 
    0.08520717f, 0.16127875f, -0.08957796f, 0.00872772f, -0.03315258f, -0.10283975f, -0.01252087f, -0.01043068f, 
    -0.27159247f, -0.41831249f, -0.05807658f, -0.02897652f, -0.00351603f, -0.02508703f, -0.06758359f, 0.01925451f, 
    -0.04932301f, -0.10635769f, -0.00366219f, 0.07723457f, 0.12455431f, -0.20342271f, -0.16315773f, 0.10576075f, 
    0.05150650f, 0.08770526f, -0.03517535f, -0.07215731f, -0.02420422f, -0.08209311f, 0.01858917f, 0.00122520f, 
    0.12579593f, -0.20296386f, 0.16561745f, 0.01567132f, 0.01686937f, 0.02055969f, 0.05880108f, -0.00642059f, 
    0.02707707f, 0.12244260f, 0.06789181f, 0.08165292f, -0.01967490f, -0.02786198f, 0.27254081f, -0.22802000f, 
    -0.11338957f, -0.04609631f, 0.07989658f, 0.10564466f, -0.12125427f, -0.15835845f, -0.05932335f, -0.02101626f, 
    -0.06607988f, -0.04028931f, 0.07407168f, 0.07640167f, -0.00163829f, 0.02242861f, -0.04953448f, -0.07645392f, 
    -0.04030616f, -0.12817003f, -0.12569165f, -0.07575221f, 0.22032185f, 0.04599932f, -0.77175897f, 0.13593012f, 
    0.00345405f, -0.28525758f, -0.14488676f, -0.00346616f, -0.11263858f, 0.01285816f, 0.02292909f, -0.00426869f, 
    0.03910135f, 0.36185992f, 0.06193186f, 0.02155244f, -0.20143633f, -0.09336735f, 0.16855386f, 0.16172561f, 
    0.04478282f, -0.01592343f, -0.06206158f, -0.06448618f, -0.01521779f, 0.02648353f, 0.01511318f, -0.13572764f, 
    0.06577687f, 0.02007624f, 0.04943892f, 0.02370026f, -0.11923937f, 0.10058315f, -0.15567294f, -0.07931120f, 
    -0.14661317f, 0.09652276f, -0.06090770f, 0.11329434f, -0.01293186f, -0.10065669f, 0.01850841f, 0.04536259f, 
    -0.02579705f, 0.02594472f, 0.01256873f, -0.00356034f, 0.49378633f, -0.04125217f, -0.33131999f, -0.06202152f, 
    -0.05584657f, 0.00881158f, 0.12148768f, -0.13855731f, -0.01459912f, 0.05745041f, -0.04123756f, 0.15826996f, 
    0.10537478f, 0.17315148f, 0.11097584f, -0.02903409f, 0.08236220f, 0.02846033f, 0.09646469f, 0.01549550f, 
    0.12214924f, 0.00605269f, 0.01853033f, 0.14107974f, -0.27703303f, -0.29281786f, 0.11237862f, 0.09581839f, 
    0.02428014f, -0.01203937f, -0.05039563f, -0.09259706f, -0.03397960f, -0.01254889f, -0.15941733f, 0.00000533f, 
    0.23458870f, -0.04382171f, -0.22286381f, -0.03084930f, 0.01084849f, 0.05669406f, 0.08150981f, -0.14960855f, 
    0.06759897f, 0.02386164f, -0.00821628f, 0.15838788f, -0.36145362f, -0.50361073f, -0.02947573f, 0.19919765f, 
    0.04756863f, 0.03001389f, -0.00797472f, 0.06453644f, -0.00258923f, 0.05733334f, 0.02018159f, 0.08217313f, 
    0.06004369f, 0.16572472f, 0.13570999f, -0.18910743f, -0.01061426f, -0.02883247f, -0.07369879f, -0.11823063f, 
    0.10614365f, 0.14115493f, -0.06420043f, -0.01234007f, -0.20201430f, -0.28020909f, -0.33883849f, 0.04502397f, 
    -0.07128806f, 0.10825092f, 0.03589212f, 0.04912427f, 0.02023339f, -0.01530806f, -0.01518136f, -0.04345625f, 
    0.27281168f, 0.06474786f, -0.32057709f, -0.08402462f, 0.11778612f, 0.14687987f, -0.01916397f, 0.01211400f, 
    0.02306837f, 0.10718168f, -0.02875172f, 0.07207466f, -0.05849738f, -0.21956038f, -0.31592628f, 0.07215878f, 
    0.01145636f, -0.02913508f, -0.05575640f, -0.01933463f, -0.05303169f, 0.09978154f, 0.10823471f, 0.28582239f, 
    -0.06314896f, 0.06530611f, 0.18762021f, -0.10457389f, -0.16665919f, -0.05611090f, -0.09415764f, 0.11205766f, 
    -0.04012254f, -0.09790550f, -0.02196461f, 0.10844473f, -0.17553763f, -0.16077834f, -0.16395117f, 0.12420736f, 
    -0.01373812f, 0.04151649f, 0.04720922f, -0.02333416f, -0.01926208f, 0.06466698f, -0.10784958f, 0.01790699f, 
    -0.23118092f, -0.71343267f, -0.58940762f, 0.06101444f, -0.01671740f, 0.09970032f, -0.07974330f, -0.04368408f, 
    -0.02508838f, -0.02656471f, -0.09384172f, -0.04313154f, -0.04133592f, -0.10616992f, -0.08578844f, 0.04671982f, 
    -0.03929154f, -0.19916371f, -0.04972636f, 0.08416151f, -0.06953149f, 0.03751814f, 0.05145564f, -0.08648964f, 
    0.34001681f, -0.04706979f, -0.16572268f, -0.14739434f, 0.16960607f, 0.21258849f, 0.13558283f, 0.02286814f, 
    -0.08453163f, -0.04574357f, -0.01385051f, 0.05518575f, 0.26758051f, 0.17829016f, 0.03227217f, -0.20990610f, 
    -0.02430706f, 0.14041430f, 0.00450773f, -0.04774449f, -0.06303010f, -0.08115213f, -0.22154897f, -0.09228585f, 
    -0.10429925f, 0.26878482f, 0.13771275f, 0.11936556f, -0.16899692f, -0.08793334f, -0.05569958f, 0.11452460f, 
    -0.02411293f, -0.07838473f, -0.11179762f, 0.00086158f, -0.03849297f, 0.04910090f, -0.10246635f, -0.08478075f, 
    0.03380880f, -0.09125358f, -0.14028089f, -0.24207042f, -0.04942055f, 0.08312697f, 0.01809948f, -0.04956438f, 
    0.24956104f, 0.06482742f, -0.10560833f, -0.36294046f, 0.04571202f, -0.00429256f, -0.03634862f, 0.15548092f, 
    0.02543285f, 0.03754225f, -0.01390134f, 0.01180414f, -0.06344325f, -0.03961245f, -0.06092745f, 0.08427731f, 
    0.03558461f, 0.00955497f, 0.01912783f, 0.04881760f, -0.05055144f, -0.04205016f, -0.02348701f, 0.03392430f, 
    0.01260538f, -0.06789493f, 0.00318293f, 0.03546343f, -0.02802914f, -0.00465302f, 0.02106416f, 0.08464123f, 
    -0.22343509f, -0.15202421f, -0.12852871f, -0.05185248f, -0.59218639f, -0.32178068f, -0.11311952f, 0.28264704f, 
    0.01065340f, 0.00376949f, -0.01130075f, 0.04929124f, -0.05356804f, -0.03152930f, 0.01600870f, 0.10174669f, 
    0.20384966f, -0.01777413f, -0.11001014f, 0.03163976f, 0.10779275f, -0.01868319f, -0.21960124f, -0.15658110f, 
    -0.19635731f, -0.13858274f, 0.02780268f, 0.12425209f, 0.16946697f, -0.10855613f, -0.42896295f, 0.12736358f, 
    -0.07775076f, -0.06958752f, -0.03834145f, 0.12683257f, -0.01247450f, 0.06325629f, 0.01716702f, -0.10643929f, 
    0.02650176f, 0.09224522f, -0.03531952f, -0.18771887f, 0.03838773f, -0.09838094f, -0.10383768f, 0.07944461f, 
    0.05246054f, -0.22780703f, -0.05492070f, -0.07607807f, -0.02199890f, -0.06226048f, -0.01589147f, -0.01823809f, 
    0.01435545f, 0.01713262f, -0.01253097f, 0.04054647f, -0.15885782f, -0.13517056f, 0.02128498f, -0.22649746f, 
    0.08046515f, -0.31338543f, -0.07067418f, 0.09521177f, -0.07320073f, 0.05908552f, -0.01456475f, -0.03010566f, 
    -0.15679893f, -0.12196153f, -0.16814031f, 0.01982150f, 0.29897749f, 0.22755614f, -0.02445943f, -0.14741726f, 
    0.06965018f, 0.19468407f, 0.08860773f, -0.07501397f, 0.03559317f, 0.04961549f, 0.04911587f, 0.06117777f, 
    0.00252285f, -0.02200758f, -0.00598169f, 0.06752639f, -0.01167573f, 0.01709253f, 0.03084669f, 0.02707602f, 
    -0.01395229f, 0.05264712f, 0.08256545f, 0.02287728f, 0.26821586f, 0.21359403f, -0.01872000f, -0.21530807f, 
    0.10581486f, 0.06955842f, 0.06332192f, 0.01627542f, -0.00072330f, -0.06311724f, 0.00485438f, -0.02458468f, 
    0.12742910f, 0.07532528f, 0.14657013f, -0.12074634f, 0.05458279f, 0.16924542f, 0.08014182f, -0.16186605f, 
    -0.03118977f, -0.05313921f, -0.04423942f, 0.03856733f, 0.21869642f, 0.02906810f, -0.16524164f, 0.04351784f, 
    0.10918715f, -0.06956495f, -0.05950551f, -0.31449881f, -0.12478594f, -0.12386174f, -0.01818614f, -0.02509059f, 
    0.31777015f, 0.26118946f, -0.03621367f, -0.11027829f, 0.14201747f, 0.08132008f, 0.10058705f, 0.07952820f, 
    0.00955514f, 0.00076997f, -0.10197473f, 0.01110844f, 0.08989258f, -0.11175907f, -0.15791978f, -0.03067512f, 
    -0.01199938f, -0.07947840f, -0.21756421f, -0.02507280f, -0.07457684f, -0.03071497f, -0.03650530f, 0.09009998f, 
    -0.01577591f, 0.10252466f, 0.10765977f, 0.01121549f, -0.09891951f, -0.25716105f, 0.01972722f, -0.01699368f, 
    -0.03264302f, -0.02122436f, -0.08356379f, -0.11730292f, 0.01396828f, 0.17038162f, -0.03152798f, -0.36756712f, 
    -0.00346724f, 0.02488112f, -0.17224501f, -0.04101190f, -0.03793493f, 0.01954968f, 0.02779073f, -0.03288466f, 
    -0.10606658f, -0.18704811f, 0.20857818f, -0.12224556f, 0.01552577f, -0.05795332f, 0.03766114f, 0.02195529f, 
    -0.06229246f, -0.02901881f, -0.08261659f, -0.00161256f, 0.01301528f, 0.16484919f, 0.20707677f, -0.11493427f, 
    0.04727361f, 0.06387011f, 0.09213527f, 0.01568192f, -0.16046247f, -0.09582230f, -0.15836079f, -0.15545526f, 
    -0.12578435f, 0.03220460f, 0.00272401f, -0.01951043f, -0.00852558f, -0.02430690f, 0.00695995f, -0.08800334f, 
    0.01612081f, -0.04739651f, -0.06340384f, 0.02812949f, -0.10286591f, 0.08337445f, 0.16735674f, -0.08113804f, 
    0.06392964f, -0.04294934f, -0.03865871f, 0.04860597f, -0.02897812f, 0.09237549f, 0.02653759f, 0.13868566f, 
    0.00347910f, -0.47087735f, 0.00900630f, -0.19485591f, 0.01725170f, 0.05763828f, -0.01600587f, 0.01490176f, 
    0.21321552f, -0.03404672f, -0.02066878f, 0.19965914f, 0.08008711f, 0.19025177f, -0.33876556f, 0.05873472f, 
    -0.30294132f, -0.06636435f, -0.04001769f, -0.23884551f, -0.01112933f, -0.02066483f, 0.00966543f, 0.07956235f, 
    -0.07581570f, 0.14902559f, 0.00394188f, -0.20456146f, -0.08892666f, 0.18921752f, -0.06082501f, -0.01392764f, 
    -0.10768540f, 0.09202510f, -0.08667829f, -0.07109538f, -0.11117171f, 0.00844042f, 0.10495088f, 0.25338703f, 
    0.08737770f, -0.03154093f, 0.03717327f, 0.05568543f, -0.00789777f, 0.02372947f, 0.09636382f, 0.00260777f, 
    0.36697179f, -0.00300797f, 0.17355719f, -0.03228191f, -0.00950826f, -0.01767000f, 0.09204603f, -0.04683052f, 
    0.01038808f, -0.08373200f, 0.05968322f, 0.08515011f, -0.12718743f, -0.10927831f, 0.03963565f, -0.05171500f, 
    -0.00880434f, 0.02310589f, 0.15615661f, -0.19510569f, 0.15116554f, -0.04060799f, 0.05110621f, 0.10936792f, 
    -0.03114781f, 0.00578622f, 0.06057142f, -0.08727280f, -0.20239770f, -0.09026148f, -0.08639123f, -0.11464579f, 
    -0.01487855f, -0.11725002f, -0.07001577f, -0.04570222f, -0.40726820f, -0.16309498f, 0.00442811f, -0.48595905f, 
    0.06433274f, 0.00038044f, -0.07747564f, 0.15121967f, 0.09447607f, -0.00659838f, -0.03659336f, -0.00446580f, 
    -0.04680691f, -0.08515154f, -0.06622215f, -0.01723265f, 0.10964375f, 0.10185946f, 0.11929606f, 0.01650356f, 
    -0.02494813f, -0.02034026f, -0.02589101f, 0.14366871f, 0.31246540f, -0.00125634f, -0.06534281f, 0.01022721f, 
    0.00735092f, -0.00085323f, -0.14407094f, 0.08340292f, -0.03800932f, 0.16674280f, 0.01612321f, -0.03220692f, 
    0.11727174f, 0.21138515f, 0.00992364f, 0.17784548f, 0.04627615f, -0.08344065f, -0.06846310f, 0.05046427f, 
    -0.00088806f, 0.10272413f, -0.03505856f, -0.02551874f, -0.16303277f, 0.12899408f, 0.19701594f, -0.24015906f, 
    0.03992151f, -0.06344879f, -0.05934555f, 0.04681229f, -0.19823419f, -0.11816622f, -0.48485410f, -0.08197822f, 
    0.13976251f, 0.03414648f, 0.10142498f, 0.06633153f, -0.04848805f, 0.03532191f, 0.02568015f, 0.04349633f, 
    -0.02325574f, -0.01224031f, 0.06129270f, 0.18624187f, 0.37344098f, 0.27485064f, 0.04052809f, -0.16619781f, 
    -0.09312079f, -0.11142503f, -0.20855127f, -0.07754905f, -0.02157743f, -0.02690117f, 0.02201636f, 0.03178620f, 
    0.10578091f, -0.00112243f, -0.00387828f, 0.00674104f, -0.05156093f, -0.08270477f, 0.07440712f, -0.03504482f, 
    -0.05358000f, 0.02752002f, 0.07507862f, 0.04519401f, 0.05972800f, -0.04983773f, 0.24212065f, -0.04682769f, 
    -0.03834068f, 0.12303598f, 0.16472894f, 0.09675846f, -0.06011755f, 0.03542133f, -0.01482377f, 0.00151951f, 
    0.16258663f, 0.08997928f, 0.24319816f, 0.13512738f, 0.00997384f, 0.03660189f, -0.08241712f, 0.03650260f, 
    -0.09201863f, 0.15593861f, -0.23534228f, 0.05769061f, 0.46099216f, -0.20656808f, -0.15339430f, -0.06522331f, 
    -0.07466093f, -0.00768098f, 0.03395629f, -0.09846623f, 0.13369083f, 0.04263684f, -0.01725875f, -0.15609717f, 
    0.10851884f, 0.02214850f, 0.16269223f, 0.20823665f, 0.03018990f, -0.00481306f, -0.03043866f, -0.02534518f, 
    0.10091047f, -0.06473359f, -0.30569240f, -0.07445984f, -0.55792367f, 0.07878994f, 0.21795543f, 0.05474228f, 
    -0.03762854f, 0.00973013f, 0.13039003f, -0.05863617f, 0.10277244f, 0.08908121f, 0.03589312f, 0.12477855f, 
    -0.21073729f, 0.13804209f, 0.10350173f, -0.24793668f, -0.05248187f, 0.01291298f, -0.05308755f, 0.12206212f, 
    0.02190734f, -0.07595503f, 0.08197726f, -0.00670964f, 0.17889251f, 0.03952631f, -0.39724573f, 0.12063237f, 
    0.07878122f, -0.08514048f, 0.08459566f, -0.03453621f, -0.05521312f, 0.04723235f, -0.06776713f, 0.16175641f, 
    -0.24772023f, -0.28137383f, 0.07939667f, -0.19404647f, -0.08530512f, 0.11687621f, -0.02343648f, -0.26159051f, 
    0.22237092f, -0.08282896f, -0.04964839f, 0.00267483f, -0.13400531f, 0.01523866f, 0.05393710f, 0.08449401f, 
    -0.04042492f, 0.09070383f, 0.00624052f, 0.00512582f, -0.20469138f, -0.05411856f, -0.08966158f, 0.10836094f, 
    0.16704014f, -0.03365944f, 0.03136191f, 0.02762347f, -0.02054662f, -0.09231788f, 0.08625033f, 0.03141294f, 
    -0.07576638f, 0.02863244f, -0.04525070f, 0.08685802f, 0.11460238f, -0.29675213f, 0.16672161f, 0.15697300f, 
    0.05124675f, 0.04891412f, -0.06371990f, 0.00207614f, 0.20990692f, -0.14289339f, -0.03396045f, -0.05511745f, 
    -0.14438263f, 0.03080194f, -0.06450409f, -0.07305766f, -0.01829604f, -0.01757795f, 0.04346021f, -0.03454592f, 
    -0.16062321f, -0.10717460f, 0.02300117f, 0.00873126f, 0.15250261f, -0.08408010f, 0.04660864f, 0.07491174f, 
    -0.01730087f, -0.04170911f, 0.08396956f, -0.03737037f, 0.07011399f, -0.12529743f, 0.02765115f, 0.07915770f, 
    0.08901965f, -0.04088937f, -0.26204979f, 0.12260627f, -0.00075102f, -0.05781556f, 0.00680905f, -0.02152522f, 
    -0.20584232f, -0.27988201f, -0.19200219f, -0.27489328f, 0.21730523f, 0.30674085f, 0.12542306f, 0.23816536f, 
    -0.02974905f, -0.02908526f, -0.03400470f, -0.04877036f, -0.01494700f, 0.02932653f, 0.01305293f, -0.06950812f, 
    -0.17718868f, 0.03794310f, -0.10866920f, 0.03556438f, -0.21535280f, -0.08956921f, 0.21077724f, -0.06128718f, 
    -0.08000588f, 0.00026849f, 0.03834973f, 0.12671238f, 0.00033804f, 0.01581663f, -0.10768715f, 0.01443925f, 
    0.00857422f, -0.04632751f, 0.01140378f, 0.01492084f, -0.06783596f, -0.02750026f, -0.07660261f, 0.01633324f, 
    0.37336120f, 0.03825502f, -0.41305587f, -0.24852279f, -0.02521243f, -0.03389117f, -0.02158705f, -0.01767813f, 
    0.11915525f, -0.02947877f, -0.16775358f, 0.01202684f, 0.13014142f, -0.09381064f, 0.10945660f, -0.18841997f, 
    -0.02899145f, 0.00737958f, -0.01899531f, -0.00122973f, -0.11501577f, -0.35151938f, -0.28614429f, -0.14740856f, 
    -0.23467438f, -0.06387339f, -0.07544910f, -0.10116942f, 0.17871499f, -0.09473151f, 0.03156454f, 0.10064711f, 
    -0.01735649f, 0.16931239f, -0.11615416f, -0.20633271f, 0.42908362f, 0.05913681f, -0.21292379f, -0.11009458f, 
    -0.03887783f, 0.04191235f, 0.01819804f, -0.06908757f, 0.08198447f, -0.02671683f, 0.04752249f, -0.04896928f, 
    0.32285732f, 0.00325984f, 0.26126349f, -0.20295964f, -0.06023997f, 0.01669933f, -0.00618114f, 0.04155422f, 
    0.04673386f, 0.01228240f, -0.07045250f, 0.12146860f, 0.21083423f, -0.02358397f, -0.00808015f, -0.02791579f, 
    -0.04201143f, -0.03757198f, -0.05350907f, 0.08491716f, -0.03857145f, -0.01015664f, -0.01078432f, 0.00682228f, 
    0.31475407f, 0.00836800f, 0.51559114f, -0.09604263f, 0.14852570f, 0.08012721f, 0.16757073f, -0.23591371f, 
    0.03742883f, 0.00672293f, 0.00096358f, -0.09441204f, -0.14746135f, 0.08874012f, -0.16641362f, 0.07735463f, 
    -0.03459001f, -0.03137686f, 0.12760288f, 0.20367485f, -0.11239319f, -0.00846716f, 0.10463855f, -0.07380348f, 
    -0.31482452f, -0.28253558f, -0.20367259f, -0.08314442f, 0.10127859f, -0.07073020f, 0.02831773f, -0.04890008f, 
    0.02507592f, 0.07871182f, -0.15877023f, -0.00287744f, 0.06161729f, 0.03631256f, -0.07752607f, -0.02315880f, 
    -0.17887121f, 0.11429708f, 0.07059324f, 0.04344944f, -0.03227973f, 0.11832967f, -0.00819285f, 0.05769551f, 
    -0.23493789f, 0.13682421f, -0.02234663f, -0.11182491f, -0.19776182f, -0.11745267f, 0.03218532f, 0.11022746f, 
    -0.03490564f, -0.06019437f, 0.06176763f, 0.03104375f, 0.08875201f, 0.09343871f, 0.07286334f, 0.04365940f, 
    0.00389909f, 0.05122061f, -0.03761374f, -0.06011492f, -0.06875710f, -0.04799913f, 0.08878363f, -0.03819855f, 
    0.07395412f, 0.06415076f, 0.07247469f, 0.07895886f, -0.07632253f, 0.00921487f, -0.03305865f, -0.04247882f, 
    0.08799089f, -0.04058835f, -0.02747619f, 0.04781361f, 0.24873346f, 0.20766941f, 0.26934916f, 0.13517256f, 
    -0.02931872f, -0.02417515f, 0.05301468f, 0.02285730f, -0.05819845f, 0.04078725f, 0.01982448f, 0.05411816f, 
    0.05066469f, -0.25485811f, 0.01218651f, -0.04749215f, 0.16574261f, 0.10691065f, 0.04773512f, -0.14509089f, 
    0.24669029f, 0.13028316f, 0.02883082f, -0.00031544f, 0.26201940f, -0.03784113f, -0.20855057f, -0.06659763f, 
    -0.13078412f, -0.14131516f, 0.20362480f, -0.06534927f, -0.03169918f, 0.12490130f, -0.02136075f, 0.10896510f, 
    -0.16004078f, 0.14855148f, -0.40142849f, -0.28374103f, -0.12177148f, 0.00742224f, 0.06943594f, 0.03271027f, 
    0.04326484f, 0.02345626f, -0.18143541f, -0.20245881f, 0.01402641f, 0.06268211f, 0.01729849f, 0.04217305f, 
    0.10295341f, -0.04250877f, -0.01782700f, 0.08116149f, 0.03156100f, 0.15479283f, -0.21311304f, -0.02374366f, 
    0.13413870f, -0.34510800f, 0.21077850f, 0.01944879f, -0.00882984f, 0.01315853f, 0.08183142f, 0.00753983f, 
    0.00265836f, 0.11033928f, -0.05824235f, -0.09814955f, 0.09830172f, 0.20555395f, 0.22513929f, 0.01129021f, 
    -0.07042199f, 0.06691033f, -0.25581598f, -0.16441236f, -0.02436223f, 0.00177966f, 0.00450486f, -0.07637049f, 
    0.12672308f, 0.01563578f, 0.09670601f, 0.16839118f, -0.02608436f, -0.07414822f, -0.08348373f, -0.01443534f, 
    -0.00729169f, 0.02412631f, 0.01483960f, 0.00355112f, 0.09771967f, 0.17662019f, 0.16083720f, 0.20741734f, 
    -0.03258082f, 0.15263732f, -0.03614159f, 0.03811684f, -0.06438839f, -0.01207110f, -0.02179766f, 0.02348363f, 
    -0.34825042f, 0.16677926f, -0.09091146f, -0.09291945f, 0.05591117f, 0.08179010f, -0.11843660f, -0.06976211f, 
    -0.13960718f, 0.04818163f, 0.00320299f, -0.07934260f, 0.34404302f, -0.31771398f, -0.00659839f, 0.00625940f, 
    0.07286960f, -0.02209439f, 0.15815873f, 0.02615897f, 0.12080407f, -0.01484950f, 0.15007001f, -0.09077343f, 
    -0.05763224f, 0.04513989f, 0.04416941f, 0.07365930f, -0.22105736f, 0.08996870f, 0.11122908f, 0.00380720f, 
    -0.06138778f, -0.05733921f, -0.08257937f, 0.07275125f, 0.41148651f, -0.32917643f, 0.14768957f, 0.03783024f, 
    0.05610633f, -0.16734888f, 0.06377288f, -0.05901150f, 0.07049403f, -0.02332945f, -0.13143958f, 0.02340170f, 
    -0.14901179f, 0.07742802f, 0.02069721f, 0.06473378f, -0.06786351f, 0.16830519f, -0.01051462f, 0.04046735f, 
    -0.16433756f, -0.03831321f, 0.00310504f, -0.04287435f, -0.01012993f, 0.11173005f, -0.03075122f, -0.24364848f, 
    0.07871193f, -0.16593046f, 0.08639743f, -0.23558620f, 0.03178853f, -0.03327237f, 0.01275309f, 0.00697246f, 
    0.09511748f, -0.02367229f, -0.13052666f, -0.00913366f, 0.03912082f, -0.02078915f, 0.06442104f, 0.03278963f, 
    -0.01583563f, 0.01732134f, 0.08787520f, -0.01800116f, -0.09048416f, 0.01152852f, -0.02624217f, -0.03007717f, 
    -0.02676069f, -0.00974203f, 0.06403749f, 0.02177816f, -0.05877467f, -0.09838789f, 0.06998428f, 0.02433651f, 
    0.00498680f, -0.00660647f, -0.01004482f, 0.08928108f, 0.00708615f, 0.01122035f, 0.09697028f, 0.08619660f, 
    -0.08127856f, 0.05596298f, 0.02513268f, -0.05441866f, -0.37102902f, 0.15615252f, 0.07374015f, 0.08232335f, 
    -0.00699082f, -0.00360406f, 0.03598123f, 0.01278488f, 0.06015860f, -0.06183430f, 0.09123806f, 0.04280616f, 
    0.05561763f, -0.03072574f, -0.05868295f, -0.02066079f, -0.07075698f, -0.00217687f, -0.08060746f, -0.13194822f, 
    0.05126853f, -0.14823057f, -0.17683318f, 0.08521441f, -0.33167419f, -0.18021290f, -0.18383792f, -0.20406161f, 
    0.02962852f, 0.05357099f, 0.01005624f, -0.03287763f, 0.02960773f, 0.01883325f, -0.00613435f, 0.02311514f, 
    0.01654746f, 0.03297696f, 0.01448147f, 0.05227801f, -0.05187359f, 0.18286036f, -0.17940277f, 0.13566287f, 
    0.03401113f, 0.04233744f, -0.01921452f, -0.17489481f, -0.54837543f, -0.94326097f, -0.21406095f, -0.23277067f, 
    -0.04890464f, -0.05672384f, 0.00686582f, -0.20324667f, -0.03672136f, 0.00320304f, 0.02896359f, -0.05824289f, 
    -0.24981572f, 0.05390439f, -0.08460123f, -0.06954955f, -0.03061180f, 0.01052652f, 0.01760004f, 0.08528066f, 
    -0.02185794f, 0.00208812f, -0.01661004f, 0.03076949f, -0.19282342f, 0.20001313f, -0.19737257f, -0.12014909f, 
    0.07350561f, -0.03201454f, 0.01821092f, 0.10890940f, -0.09135078f, 0.00009107f, -0.00205139f, -0.09429304f, 
    0.02993219f, 0.05611909f, 0.01233390f, 0.10900977f, 0.01452158f, -0.09957079f, 0.04765681f, -0.09121952f, 
    0.10245629f, 0.14262447f, 0.00409451f, 0.09023137f, -0.17581658f, 0.28254259f, -0.33281404f, -0.20034309f, 
    -0.06616126f, -0.34972981f, 0.11756748f, 0.00701220f, 0.04720828f, 0.01474770f, -0.03940329f, 0.03963359f, 
    -0.06710223f, -0.28624579f, 0.11169832f, -0.02220572f, -0.00527137f, 0.00941255f, -0.05257017f, -0.07260125f, 
    0.01961644f, -0.00201433f, -0.06178678f, 0.06270465f, -0.05013239f, -0.06414176f, -0.04143504f, -0.01479908f, 
    0.06226195f, -0.04946020f, -0.05508220f, -0.05341597f, 0.05628728f, 0.03065822f, -0.12828609f, 0.15542637f, 
    -0.37616473f, 0.10945927f, 0.02678136f, 0.14668077f, -0.04620805f, -0.09785085f, -0.08381580f, -0.03192115f, 
    -0.04744499f, -0.00565512f, 0.01635256f, -0.03126116f, 0.19637492f, 0.17672925f, -0.09077858f, 0.03334557f, 
    -0.04269121f, -0.08857873f, 0.06859432f, -0.05103498f, 0.08925002f, 0.18462949f, 0.06528795f, 0.18314302f, 
    0.05783918f, -0.17898117f, -0.01997008f, -0.12665366f, -0.02293743f, -0.06326154f, -0.01565705f, -0.00809492f, 
    -0.01686485f, -0.06629396f, -0.04393184f, 0.12667681f, -0.75407672f, 0.35883710f, 0.01344991f, -0.46895763f, 
    0.03007743f, 0.07173504f, 0.06361712f, 0.06434961f, -0.01497771f, -0.01797660f, 0.00451519f, 0.03552542f, 
    -0.02980529f, -0.09031288f, 0.00867116f, 0.06899945f, -0.16334490f, 0.08794008f, 0.05515769f, -0.07468941f, 
    -0.03464898f, -0.01984799f, 0.00723644f, -0.01845284f, -0.30602553f, 0.01789865f, 0.12087995f, -0.25885201f, 
    0.02752757f, 0.08433758f, 0.15947765f, -0.18576148f, -0.00483323f, -0.07434499f, 0.02549572f, -0.10245990f, 
    -0.11082996f, -0.16121967f, -0.05299872f, -0.06315451f, 0.02815689f, 0.03044003f, 0.00681227f, 0.00812080f, 
    0.05754915f, 0.03523010f, -0.09626137f, 0.08013634f, -0.06334400f, 0.32301927f, 0.37567702f, 0.20156464f, 
    -0.03448163f, 0.01405235f, 0.05147158f, 0.03332732f, -0.04996708f, 0.08592511f, -0.20279004f, -0.08949390f, 
    -0.01265735f, -0.20985413f, -0.06087371f, 0.11248304f, 0.01138877f, 0.00431574f, 0.03760387f, 0.08108746f, 
    0.29424220f, 0.20649336f, -0.00545677f, 0.10312574f, 0.09921113f, 0.04928490f, -0.30752566f, 0.03889870f, 
    0.04590093f, 0.01566181f, 0.08786387f, 0.05627728f, -0.03976104f, -0.02805662f, 0.06021943f, 0.08642091f, 
    0.02704095f, -0.07059052f, 0.17476884f, 0.02740218f, 0.06164790f, 0.07293651f, 0.01048289f, -0.03444848f, 
    -0.17597507f, 0.07678271f, -0.07186112f, 0.24260439f, -0.15306945f, 0.05497418f, -0.24536464f, -0.22800307f, 
    -0.08095771f, -0.15248345f, -0.06241778f, 0.18739003f, 0.00456534f, 0.03469226f, -0.00985288f, -0.07778103f, 
    0.27343634f, -0.19368714f, -0.06527935f, -0.16201982f, 0.06493524f, 0.03703792f, -0.09918447f, -0.10290367f, 
    -0.00530311f, 0.06921997f, 0.11338290f, -0.10482828f, 0.01032445f, -0.21388948f, 0.05580978f, 0.23682392f, 
    0.09144113f, -0.03321321f, 0.15279704f, -0.04954140f, 0.21409121f, -0.07196683f, 0.00807095f, -0.07420540f, 
    0.02953781f, -0.26638508f, 0.02088672f, -0.20765421f, 0.07448981f, -0.01070974f, 0.04988381f, 0.04303518f, 
    0.01491162f, -0.04285420f, -0.06853160f, 0.03971231f, -0.12708251f, -0.08843390f, 0.45716596f, 0.16589242f, 
    0.04893805f, -0.04868525f, 0.06155245f, 0.10440031f, 0.11391965f, 0.08892574f, -0.01198110f, -0.04179576f, 
    0.14437746f, 0.05185100f, 0.01108283f, 0.17328188f, -0.02468335f, -0.03613419f, 0.00845456f, 0.02158180f, 
    -0.16956662f, 0.04299305f, 0.02391363f, 0.11627583f, -0.16566485f, 0.00380559f, 0.04144454f, 0.02163543f, 
    -0.00757238f, 0.10401607f, 0.06995429f, -0.18002288f, -0.00313102f, -0.24054559f, 0.10352577f, 0.02478240f, 
    -0.09637055f, -0.04458357f, -0.03543968f, 0.14586894f, -0.05455736f, -0.07946989f, -0.01964335f, 0.04814339f, 
    0.06435897f, -0.03074444f, 0.14058812f, -0.12067398f, -0.57337832f, 0.06767371f, -0.15550199f, -0.38595313f, 
    -0.04450569f, -0.06120683f, 0.06288897f, 0.04244042f, 0.00946750f, 0.00792261f, 0.01546344f, 0.00675355f, 
    -0.05596835f, -0.04547047f, -0.05511658f, 0.12209670f, -0.24149968f, -0.15206657f, -0.17589150f, -0.07201628f, 
    -0.05851642f, -0.00184992f, 0.02235245f, 0.00799949f, 0.03611342f, -0.08904088f, 0.26428622f, -0.28401312f, 
    0.03753008f, -0.01729794f, 0.01760844f, -0.04054124f, 0.00630837f, -0.04819852f, -0.05281248f, -0.01234393f, 
    -0.14960225f, 0.41017869f, 0.57528347f, 0.20927861f, -0.01815892f, -0.05737476f, 0.05766390f, -0.00980386f, 
    0.13508439f, -0.01567540f, 0.01939331f, 0.06066851f, -0.00948825f, 0.01051387f, 0.11423318f, -0.18292977f, 
    -0.01359298f, -0.04978597f, -0.05388633f, -0.14499660f, 0.19286621f, 0.12039033f, 0.15050974f, 0.14542581f, 
    0.06172882f, -0.09988092f, -0.16771474f, -0.03838030f, 0.03464192f, 0.00361509f, -0.10060872f, 0.01726977f, 
    0.02540599f, -0.15441290f, 0.10910080f, 0.04722136f, 0.08101259f, 0.20389125f, 0.29399735f, 0.00074632f, 
    0.03370383f, 0.00609054f, 0.03328558f, 0.00685789f, -0.15493271f, -0.07100412f, 0.07912383f, 0.14143597f, 
    -0.32146946f, 0.20151125f, -0.03469549f, -0.29002243f, 0.04718930f, 0.01614046f, -0.01579291f, 0.02529375f, 
    0.00038690f, -0.02965699f, 0.10174718f, 0.01859857f, -0.04348770f, 0.00341050f, 0.11975630f, -0.18875983f, 
    0.01244510f, -0.05832593f, -0.11275992f, 0.02727883f, 0.05323376f, -0.02839135f, -0.06156227f, -0.11668720f, 
    -0.00491359f, -0.03302633f, 0.67993414f, -0.05308113f, -0.11194293f, -0.14541072f, 0.08428495f, -0.01031178f, 
    -0.02303720f, -0.00291387f, 0.02034121f, 0.01959597f, 0.17804252f, 0.01494152f, -0.07854187f, 0.25097039f, 
    0.02446158f, -0.10453379f, -0.03120048f, 0.04037183f, -0.00690323f, -0.17302063f, 0.07064852f, 0.03396659f, 
    0.13303669f, -0.04775489f, -0.09356424f, 0.10954873f, 0.03060204f, 0.03252742f, 0.07166036f, -0.10590246f, 
    -0.02105343f, 0.03554985f, 0.06160653f, -0.01570551f, -0.00848367f, -0.06737680f, -0.01185864f, 0.09047105f, 
    -0.10322221f, -0.22242506f, -0.07129171f, -0.01652429f, 0.08489593f, -0.08875351f, -0.06827603f, 0.08682719f, 
    -0.42998320f, -0.32015324f, -0.37448189f, -0.32071823f, -0.02942012f, 0.05662432f, 0.06089516f, -0.17734699f, 
    0.06963736f, -0.02777726f, -0.01240734f, 0.01612528f, -0.21215573f, -0.13527454f, 0.12585661f, -0.00464621f, 
    0.03605963f, -0.01338054f, -0.03550613f, 0.06514837f, 0.04588935f, -0.21269967f, 0.09665758f, 0.02369231f, 
    -0.05631459f, -0.15072730f, -0.07672755f, 0.03584616f, -0.01583045f, -0.03118127f, 0.02785414f, 0.07603105f, 
    -0.14183974f, -0.07108933f, 0.13072532f, 0.05718919f, 0.09088241f, -0.06657279f, 0.17481837f, -0.02002617f, 
    0.01850519f, -0.00831289f, 0.01474670f, -0.00049374f, 0.01455743f, -0.01122238f, 0.04639148f, -0.02931843f, 
    -0.04143874f, 0.31368035f, 0.00654548f, 0.19054374f, -0.07891961f, 0.07792597f, -0.03561511f, -0.14798243f, 
    -0.00572997f, 0.15242203f, 0.12883708f, 0.02119303f, -0.34817994f, -0.05902765f, 0.05797649f, -0.04279644f, 
    -0.16740182f, -0.18705301f, -0.27282858f, -0.21599688f, -0.00240006f, 0.04607945f, -0.10890741f, 0.01342347f, 
    -0.08979034f, 0.29179296f, -0.07837941f, 0.29248348f, 0.00780893f, 0.01249124f, -0.05331807f, 0.09186956f, 
    0.02619070f, 0.02268721f, 0.01961884f, -0.00587318f, 0.10373650f, -0.07183044f, -0.10686266f, -0.15303922f, 
    -0.01076045f, 0.04589283f, -0.07196482f, 0.05553204f, -0.02172784f, 0.00748886f, -0.30651325f, -0.05775561f, 
    0.13837463f, -0.17169569f, 0.10762620f, -0.13921724f, 0.06630494f, -0.07241041f, 0.06014875f, -0.11614197f, 
    -0.03242385f, -0.08016672f, -0.24078907f, 0.15976487f, -0.20355377f, -0.32223454f, 0.00256310f, 0.29009217f, 
    -0.08564004f, 0.02623760f, 0.03886954f, -0.02873587f, -0.00215670f, 0.08322396f, -0.00386940f, 0.03468138f, 
    -0.14987580f, 0.05570423f, -0.06535643f, -0.02339768f, -0.02952111f, -0.04987807f, 0.03128764f, 0.02604978f, 
    -0.06964927f, 0.06101447f, -0.02262624f, -0.09050274f, -0.31915593f, -0.23223566f, -0.33303410f, -0.10475753f, 
    -0.01001317f, -0.08090827f, 0.10854103f, -0.01928603f, 0.00464808f, -0.02821926f, 0.00855129f, -0.01710563f, 
    0.04452758f, 0.53320199f, 0.18144305f, 0.36650720f, -0.02762016f, 0.03533847f, 0.00788771f, 0.16280600f, 
    0.02792478f, -0.01410728f, 0.02858240f, 0.11140076f, -0.00205080f, -0.07851669f, 0.29549965f, 0.03281618f, 
    0.03352540f, 0.02228730f, 0.07053767f, -0.03858526f, 0.07487110f, -0.05542791f, 0.06422057f, -0.09800623f, 
    -0.15535623f, -0.02086009f, -0.03432766f, 0.13593115f, -0.10657008f, -0.09436977f, -0.09593960f, 0.00954352f, 
    0.03923719f, 0.08631653f, 0.00817078f, 0.01828463f, -0.10437005f, -0.06111655f, -0.00154220f, -0.32785815f, 
    0.04680957f, -0.08559219f, 0.10159060f, -0.10163523f, -0.02493634f, 0.07895809f, -0.03369200f, -0.08132354f, 
    -0.04806000f, 0.04369147f, -0.03056561f, 0.12480479f, -0.06156451f, 0.15385650f, -0.07890186f, -0.02078073f, 
    0.05524963f, -0.13659787f, -0.03287125f, -0.12987517f, -0.28014469f, 0.04101413f, 0.22121949f, -0.15480654f, 
    -0.03666472f, 0.06902792f, -0.02362047f, 0.00102154f, -0.04556878f, -0.06848452f, 0.05227219f, -0.03927257f, 
    0.20625873f, 0.07270105f, -0.20143797f, 0.01587969f, 0.06460987f, -0.00447806f, 0.04311369f, 0.06420850f, 
    -0.09785471f, 0.08648174f, 0.01371057f, 0.14206171f, 0.01001748f, -0.23056175f, 0.05479075f, 0.17637764f, 
    -0.02351560f, 0.03058830f, 0.04504384f, 0.10900410f, -0.15495130f, -0.14757469f, -0.20485933f, 0.09483373f, 
    0.35702285f, -0.09239446f, 0.04422816f, -0.14547010f, -0.09786261f, -0.13218729f, -0.01943160f, -0.01136517f, 
    -0.01165576f, -0.06284259f, -0.03339769f, -0.02389872f, -0.28043324f, -0.12565407f, -0.02297044f, -0.32468212f, 
    -0.25994200f, -0.04555052f, -0.16173175f, 0.02332188f, -0.03009189f, 0.09827689f, 0.08162565f, 0.02541533f, 
    0.08692297f, 0.06037573f, 0.01451841f, 0.06634267f, 0.01056892f, -0.04700010f, -0.03774386f, 0.06779269f, 
    0.01135713f, 0.01210041f, 0.08013751f, -0.13521218f, -0.00869955f, -0.01630220f, -0.04926257f, 0.18346366f, 
    0.00603638f, 0.01827415f, 0.11244206f, 0.10295607f, 0.11901746f, 0.03339323f, -0.04979493f, 0.09839281f, 
    0.20807636f, -0.04171691f, 0.05424179f, 0.12854075f, -0.03274847f, 0.09286326f, -0.13749439f, -0.03740199f, 
    0.00273508f, -0.13586709f, 0.19849946f, -0.06221426f, -0.06059968f, -0.11607978f, -0.09543975f, 0.19958280f, 
    0.08454651f, 0.08031065f, 0.13523132f, 0.12122031f, -0.03147566f, 0.07960424f, -0.03439111f, -0.07267484f, 
    -0.12484457f, -0.09361321f, 0.12096288f, -0.08353075f, -0.07295769f, -0.24879055f, 0.15366578f, -0.08769856f, 
    0.01137627f, 0.02537031f, 0.02172763f, 0.07806081f, -0.11647297f, 0.15159264f, -0.22970693f, 0.24376839f, 
    0.03387506f, 0.04109696f, 0.04263652f, 0.01955431f, -0.07197848f, -0.12604393f, 0.03777842f, 0.01653045f, 
    -0.19862023f, -0.13775069f, -0.12108772f, 0.18212245f, 0.02214790f, 0.11640711f, 0.04819565f, -0.07134397f, 
    -0.08297148f, 0.02835085f, -0.13790414f, 0.17553347f, -0.12893640f, 0.24406087f, -0.16892311f, 0.23884162f, 
    0.11505263f, 0.25025681f, -0.04986017f, 0.08559915f, 0.01331276f, 0.05952158f, -0.03581966f, 0.19740838f, 
    -0.12778781f, -0.03041486f, 0.15388314f, 0.13237864f, -0.00587193f, 0.01541919f, -0.10700012f, -0.03926824f, 
    -0.05255547f, -0.01844511f, -0.03919629f, -0.10688135f, 0.05007289f, -0.28115296f, 0.16543400f, -0.33568981f, 
    -0.12860587f, 0.10261717f, -0.29377499f, 0.03963221f, -0.12872250f, -0.13358150f, -0.00705556f, -0.22832149f, 
    0.00559367f, -0.12919809f, -0.12109873f, 0.08981039f, 0.02173749f, -0.05542103f, -0.04657520f, 0.05730586f, 
    -0.04845737f, 0.04482045f, 0.03519473f, 0.01447587f, 0.58258092f, -0.21256989f, 0.30023229f, 0.07584879f, 
    -0.13552046f, 0.13922587f, -0.10095889f, 0.06071068f, 0.05398739f, 0.13014570f, 0.07346792f, 0.03754476f, 
    0.13264094f, 0.14469351f, 0.24146891f, 0.28533381f, 0.05890656f, -0.03591793f, -0.11223776f, 0.03505731f, 
    -0.13309561f, -0.15195233f, 0.07206017f, 0.00447200f, -0.32756141f, -0.09912496f, 0.19126068f, 0.38546562f, 
    0.02627246f, -0.00992792f, -0.04158681f, -0.08913106f, 0.12514214f, 0.03513998f, -0.06388056f, 0.06785135f, 
    -0.09898262f, -0.00299847f, 0.03239910f, 0.11553737f, -0.11320491f, -0.20549621f, -0.11421778f, -0.21817744f, 
    -0.13347578f, 0.04761885f, -0.04729594f, -0.20770927f, 0.05439019f, -0.10769325f, 0.00106511f, 0.23443596f, 
    -0.02783347f, -0.04470070f, -0.07441092f, 0.06061572f, 0.05352978f, 0.10927893f, 0.05394843f, -0.04903150f, 
    -0.04826164f, -0.19883847f, 0.06943794f, -0.06618369f, -0.17087741f, -0.00285018f, -0.03399972f, -0.05638048f, 
    -0.18384020f, 0.11773406f, -0.08702734f, -0.19761932f, -0.06528500f, 0.37703085f, -0.11593437f, 0.14954261f, 
    0.22539078f, 0.07921482f, 0.31429553f, -0.00036830f, -0.03053882f, 0.01717146f, -0.08605967f, 0.01759205f, 
    0.24001803f, 0.42725867f, -0.42362511f, -0.17972231f, 0.05765299f, -0.04684794f, 0.10452728f, 0.00737334f, 
    -0.18551488f, 0.12126248f, -0.06378163f, -0.03456817f, 0.07521478f, 0.03765962f, -0.20670284f, -0.42206290f, 
    -0.05842651f, -0.09086493f, -0.12497438f, -0.02755467f, -0.04687154f, 0.02632236f, -0.25712165f, -0.00209754f, 
    0.26823434f, -0.15609783f, -0.01456573f, 0.05079593f, 0.01237403f, -0.00804884f, -0.00874533f, -0.39653432f, 
    0.01324692f, 0.09513156f, -0.06618208f, 0.08150594f, -0.24953370f, 0.29370201f, 0.26118439f, 0.27606511f, 
    0.07827579f, -0.02469235f, -0.04465121f, 0.01862933f, -0.08023997f, 0.03760021f, -0.06225092f, -0.00941775f, 
    0.28462592f, 0.04036602f, -0.05774526f, -0.38973004f, 0.03082428f, -0.02966161f, -0.01194747f, -0.12937236f, 
    -0.28383583f, 0.06086674f, -0.12050958f, 0.13129054f, 0.40442634f, 0.13893723f, 0.13775988f, -0.12682907f, 
    0.14985049f, 0.05267160f, -0.07373695f, 0.02373601f, -0.02758686f, 0.06597072f, 0.15508784f, -0.04040194f, 
    0.25028408f, -0.02785656f, 0.02069366f, 0.11162004f, -0.14644422f, 0.07412753f, -0.13274489f, 0.07770489f, 
    0.00851574f, -0.10389227f, 0.00872380f, -0.07956143f, -0.17485033f, 0.69167399f, -0.37705815f, -0.42689219f, 
    0.32869866f, 0.02274409f, 0.02568949f, -0.04820195f, -0.30281013f, -0.06530554f, 0.01726296f, -0.04186291f, 
    -0.10189701f, -0.04634397f, -0.13005555f, -0.24509014f, 0.21993262f, -0.00449515f, -0.00401971f, -0.29015175f, 
    -0.08794199f, -0.06285698f, -0.03029861f, -0.18750422f, -0.48260763f, -0.11012716f, -0.17612734f, 0.17802051f, 
    -0.23456584f, -0.02299133f, -0.11345368f, -0.00883490f, -0.03924131f, -0.14637795f, 0.22764947f, -0.05724123f, 
    -0.26225078f, 0.27693433f, -0.26158884f, -0.06103554f, 0.13783845f, -0.08251389f, -0.04249667f, 0.02332676f, 
    0.11184656f, -0.00204526f, -0.02787089f, -0.09225866f, -0.27327517f, -0.32840917f, -0.09172501f, -0.27512607f, 
    -0.06952284f, -0.13919173f, -0.11945154f, -0.03911461f, 0.10846476f, 0.05560586f, 0.11258454f, -0.08210302f, 
    0.25498992f, -0.05583405f, -0.24598524f, 0.25420243f, -0.06594319f, -0.00514159f, 0.05466507f, -0.03969365f, 
    0.03128196f, -0.00603765f, 0.10791229f, 0.31478903f, 0.28852111f, -0.05623462f, 0.28502426f, 0.29559952f, 
    -0.12771472f, 0.02944185f, -0.22348048f, -0.02338953f, 0.06332061f, 0.10449834f, -0.03256048f, -0.12677667f, 
    -0.08000123f, -0.08394485f, -0.03201930f, 0.19831277f, 0.07431907f, 0.08495884f, 0.07879705f, 0.05330934f, 
    -0.06303129f, 0.01626522f, 0.01123664f, 0.13893096f, -0.24451347f, -0.05083853f, 0.18009567f, 0.16806783f, 
    -0.17044668f, 0.05233445f, -0.04140777f, -0.01597202f, 0.07953747f, 0.08521809f, -0.05828115f, 0.05954499f, 
    0.26792532f, 0.02905169f, 0.10370049f, 0.03753018f, -0.14347017f, -0.06719928f, 0.06647209f, 0.06615815f, 
    0.05398585f, 0.10968617f, 0.17279862f, 0.04020910f, -0.44642189f, -0.31660938f, 0.02778372f, 0.04524508f, 
    0.30107653f, 0.07924980f, -0.08046247f, -0.02048558f, -0.04664589f, 0.00524449f, 0.16764061f, -0.21172746f, 
    -0.21851088f, -0.02298068f, 0.06464940f, 0.26832917f, 0.03796974f, -0.07412928f, -0.07612887f, -0.02317884f, 
    -0.03549136f, 0.10235617f, 0.13799272f, -0.17401269f, -0.26643145f, -0.08195025f, 0.32740220f, 0.09620544f, 
    0.01006297f, 0.21598083f, -0.29283217f, -0.10218645f, 0.05343141f, -0.34109759f, 0.05141674f, -0.08500212f, 
    -0.20311174f, 0.05058599f, -0.01140890f, 0.11675256f, 0.05616054f, -0.02076322f, -0.10490019f, 0.03380878f, 
    -0.04177111f, 0.00117336f, -0.08560398f, 0.12272466f, -0.10608429f, 0.46842203f, -0.34642446f, -0.20285942f, 
    0.02572848f, 0.01803826f, -0.12865873f, -0.06415951f, -0.02385953f, -0.14596525f, 0.00270064f, 0.06637373f, 
    0.24758217f, -0.16636398f, 0.04875683f, -0.12943932f, -0.16301101f, 0.05895709f, -0.02535172f, 0.03465514f, 
    -0.04162119f, 0.11629378f, 0.06061021f, -0.00386963f, 0.20906420f, -0.01095528f, -0.39844656f, 0.19427435f, 
    -0.03705783f, -0.08492379f, -0.08443281f, -0.04345420f, -0.00413258f, 0.04020732f, 0.07040126f, 0.20186417f, 
    -0.04394949f, -0.19170991f, -0.00541384f, 0.18364507f, 0.02421461f, 0.05991524f, 0.04416866f, 0.10729945f, 
    0.00493852f, 0.00728678f, 0.03512653f, -0.00487084f, -0.11105547f, -0.18223231f, -0.24880850f, -0.08916765f, 
    0.05347953f, 0.10917644f, -0.08949866f, 0.00763689f, -0.02829472f, 0.15276171f, 0.11910231f, -0.11247230f, 
    -0.17163810f, -0.23455241f, -0.04339966f, -0.26838619f, 0.39764822f, -0.03728734f, 0.10259786f, -0.07841100f, 
    -0.05477896f, -0.02124946f, 0.01073679f, -0.27962059f, -0.12919012f, 0.08368084f, -0.12678155f, -0.11641552f, 
    0.00249933f, 0.02353860f, -0.15932921f, -0.00228164f, -0.14453141f, 0.08476441f, 0.07833496f, -0.08799046f, 
    -0.40342194f, -0.00370280f, -0.06575090f, 0.17238551f, -0.07125540f, -0.13511193f, 0.09165803f, -0.10832576f, 
    -0.03627665f, 0.03374690f, -0.00758722f, 0.00125111f, -0.40187842f, -0.33080316f, 0.50301999f, 0.36418492f, 
    0.04757727f, -0.01458102f, 0.04197257f, -0.10208359f, -0.04079483f, -0.05196290f, -0.13622059f, 0.02435658f, 
    0.17044187f, -0.16359386f, -0.11828058f, 0.08188746f, -0.02225328f, 0.09647889f, -0.05348358f, 0.07767367f, 
    -0.04273967f, -0.06344606f, 0.06030697f, -0.05175779f, 0.15332901f, -0.06388609f, -0.19070318f, 0.14438029f, 
    0.12012129f, -0.21549959f, -0.03287044f, -0.04156855f, -0.04083071f, 0.18699177f, -0.18795878f, 0.03118957f, 
    0.03526133f, 0.08051149f, -0.18394905f, 0.27416152f, 0.17811112f, -0.00843565f, -0.22869276f, -0.19990954f, 
    -0.16263729f, -0.12791690f, 0.16271590f, -0.02344188f, 0.05454374f, -0.15083224f, -0.01449974f, 0.17133528f, 
    0.04224562f, -0.05371033f, 0.14528343f, -0.14604278f, 0.10383943f, 0.05955567f, -0.10195707f, 0.15279984f, 
    -0.51068580f, -0.37986550f, -0.17590037f, -0.11267673f, -0.01596718f, -0.14553168f, -0.17266254f, -0.11805991f, 
    -0.03269691f, 0.01140847f, -0.03184174f, -0.02612315f, 0.05508463f, -0.05244665f, -0.05499547f, 0.17332035f, 
    0.03651719f, 0.04349682f, 0.08102880f, -0.02047013f, 0.01321773f, 0.10622147f, 0.01851634f, 0.00337195f, 
    0.39015421f, -0.03179432f, -0.05913443f, 0.11159170f, 0.05552065f, -0.02768496f, 0.04919542f, -0.04879506f, 
    -0.05128383f, 0.00680680f, 0.01515260f, 0.08297288f, -0.34386042f, 0.43226054f, -0.17997572f, -0.09768652f, 
    0.07325502f, 0.06695444f, -0.05818753f, -0.10938232f, -0.11971529f, 0.05216339f, -0.18240499f, 0.01648739f, 
    0.12273610f, -0.14807093f, -0.11227354f, -0.01856725f, 0.11559801f, 0.09499139f, 0.02215422f, 0.02824587f, 
    0.00803630f, 0.00011367f, 0.07646714f, 0.12496132f, -0.01968773f, -0.11512517f, 0.14271411f, 0.10459369f, 
    -0.10079254f, -0.03006764f, 0.05564024f, -0.02285123f, 0.04390458f, -0.01649732f, 0.05557128f, -0.04641957f, 
    0.04775217f, 0.26343256f, 0.06324525f, -0.19068453f, 0.00803173f, 0.07617659f, -0.03812509f, -0.25342831f, 
    0.20975055f, 0.14115278f, 0.32205248f, 0.04455625f, -0.06008952f, -0.10785316f, -0.06390723f, 0.20731433f, 
    -0.12664188f, -0.02424232f, -0.18770452f, -0.21916381f, -0.07100338f, -0.01499345f, -0.02642199f, -0.21717632f, 
    0.16186979f, 0.66199654f, -0.23788202f, -0.49634081f, -0.05477582f, 0.11947240f, -0.04063995f, -0.05898597f, 
    -0.03940025f, -0.11654572f, 0.08609152f, -0.08118761f, -0.13094249f, 0.01036697f, 0.03556178f, -0.40466383f, 
    0.13912256f, 0.11801510f, -0.02015399f, -0.07094559f, -0.15508245f, 0.08834468f, -0.03788447f, 0.08273010f, 
    -0.16326745f, -0.08293909f, 0.01859257f, 0.08365005f, -0.09030066f, -0.00619352f, 0.06979454f, 0.11999378f, 
    -0.03271401f, 0.02342706f, -0.06360319f, -0.06562225f, 0.25410578f, -0.24340427f, -0.08517069f, 0.13141860f, 
    -0.01281936f, -0.07218869f, 0.07030350f, -0.05935573f, 0.04519779f, -0.02981824f, -0.02091601f, -0.05865699f, 
    -0.07198551f, 0.02988250f, 0.02357312f, 0.03689750f, 0.07486825f, 0.04240461f, -0.05533731f, -0.10828703f, 
    -0.07679620f, -0.05562526f, 0.02270688f, -0.13364026f, 0.00027238f, -0.01871504f, 0.20498848f, 0.12952502f, 
    0.01381547f, 0.01179553f, -0.12979652f, 0.06397475f, 0.01377486f, 0.03179917f, 0.02074753f, -0.16283885f, 
    -0.17233980f, 0.01739112f, -0.17287321f, -0.14036925f, 0.04367460f, -0.10976429f, 0.06849494f, -0.05592827f, 
    0.02905032f, 0.00081350f, -0.03586029f, -0.01486515f, 0.20145267f, 0.25671390f, 0.21841837f, 0.16664048f, 
    -0.24274011f, 0.04101023f, 0.01901191f, 0.16940652f, 0.03956584f, 0.09347702f, 0.04931038f, 0.09179968f, 
    -0.10780051f, 0.04438144f, -0.35238016f, 0.01466870f, 0.04126966f, 0.08265990f, -0.11385677f, 0.07378021f, 
    -0.00393266f, 0.03650434f, -0.01973407f, -0.11471031f, 0.00823232f, -0.00615095f, 0.23643990f, -0.00258936f, 
    -0.02305265f, 0.12670994f, -0.11554627f, 0.04579149f, -0.17291859f, 0.04564911f, -0.11493549f, -0.04500835f, 
    0.01771185f, 0.04169795f, 0.02149187f, 0.03001895f, 0.02274567f, -0.19670810f, -0.16135877f, -0.15872416f, 
    0.05077126f, -0.07886807f, -0.02539802f, 0.07602018f, 0.11080174f, -0.16685773f, 0.28846461f, 0.25226253f, 
    0.06887551f, -0.18967749f, -0.00005373f, 0.01151100f, -0.06516024f, -0.04773206f, 0.03923288f, -0.00298825f, 
    0.06130568f, 0.11305621f, -0.07448972f, 0.05058992f, -0.02690824f, -0.05910286f, -0.13807850f, 0.08816067f, 
    -0.01380549f, -0.02581479f, 0.01714032f, -0.15209676f, -0.20963109f, 0.00371600f, 0.01739779f, 0.19912264f, 
    -0.02949027f, 0.11259954f, 0.04720962f, -0.02320521f, 0.05794412f, -0.09592205f, 0.07553163f, -0.00081368f, 
    -0.07370311f, -0.01286724f, 0.01523733f, -0.00431500f, -0.05556508f, 0.06602018f, 0.00339356f, 0.00912938f, 
    0.02077395f, -0.01917167f, 0.12920363f, 0.11048834f, 0.25676376f, -0.05112975f, -0.33741599f, 0.10380721f, 
    0.10817821f, -0.14864379f, 0.07342368f, -0.15042104f, 0.08348428f, -0.14586820f, 0.23894638f, 0.19815436f, 
    -0.41299900f, -0.28298831f, -0.40034929f, -0.10346001f, -0.03156856f, 0.04556404f, -0.06185585f, 0.02161625f, 
    0.00498712f, 0.04240772f, 0.13061681f, -0.09807438f, 0.25206044f, 0.08787372f, 0.05706263f, 0.21512264f, 
    0.01353653f, 0.01268579f, 0.09186896f, 0.18853940f, 0.03760647f, -0.00636392f, -0.00087606f, -0.00750551f, 
    0.03109469f, 0.02086537f, 0.09511086f, 0.04865139f, 0.08026624f, 0.14042574f, -0.05695698f, 0.08943854f, 
    0.01362943f, -0.11990334f, -0.01964291f, -0.11621878f, 0.01675500f, 0.12035977f, 0.00095030f, 0.06820766f, 
    0.01228630f, -0.08639964f, -0.07002503f, -0.10556506f, -0.03067317f, -0.05128292f, 0.04483425f, -0.02394367f, 
    -0.00505078f, -0.07654379f, -0.10685136f, -0.41699937f, -0.01661355f, -0.05192820f, 0.05010530f, 0.03232023f, 
    0.09870409f, -0.05805877f, 0.01722109f, -0.12373014f, -0.14102115f, -0.16182679f, 0.09263586f, 0.00673652f, 
    -0.06689137f, 0.04341592f, -0.04419712f, 0.04681346f, -0.03234929f, -0.10308792f, -0.09416695f, 0.13842130f, 
    -0.21710578f, -0.29863533f, -0.04984149f, -0.27525678f, 0.02755140f, 0.11925700f, -0.06270030f, 0.02506258f, 
    0.07632192f, 0.09337727f, 0.14270732f, 0.19651084f, 0.01863286f, -0.04773920f, -0.04727771f, -0.07624856f, 
    -0.03782687f, -0.03056592f, -0.08449701f, -0.05859527f, -0.23074013f, -0.12746306f, 0.01512373f, -0.19824997f, 
    -0.05401323f, 0.14325447f, -0.24418233f, 0.02734436f, 0.01806841f, -0.08403552f, 0.08568338f, -0.01433511f, 
    -0.13901784f, -0.16343208f, -0.26736528f, 0.06551648f, 0.19412524f, -0.20806581f, 0.20829922f, -0.12070408f, 
    0.06437649f, -0.13139954f, -0.02160409f, -0.03610559f, -0.03472608f, -0.01796980f, 0.04630608f, -0.02596319f, 
    0.12063231f, -0.24003874f, -0.09036491f, 0.26093912f, 0.05895869f, -0.08511419f, 0.01797790f, -0.12918314f, 
    -0.02477064f, -0.07479618f, -0.02845029f, -0.01529481f, 0.04279188f, 0.03634743f, 0.00801493f, -0.17311086f, 
    -0.19417961f, -0.05117287f, 0.10674639f, -0.01613403f, 0.01756598f, -0.01029902f, -0.10465515f, -0.09001636f, 
    0.13573013f, 0.06024989f, -0.02214583f, 0.09642414f, 0.07647468f, 0.10880485f, 0.03342779f, 0.05453362f, 
    0.04155723f, -0.03530645f, -0.01893951f, -0.09855531f, -0.16476212f, -0.62661570f, -0.06240296f, -0.07514375f, 
    -0.07263228f, 0.07070377f, -0.06609586f, -0.03771583f, 0.00937672f, 0.05168551f, -0.05211435f, -0.02078306f, 
    0.06955440f, -0.00139183f, -0.07457589f, 0.06308009f, -0.06648090f, -0.02797019f, -0.00329245f, 0.02173941f, 
    -0.06319991f, 0.13513528f, -0.17218684f, 0.04610339f, -0.19172992f, 0.06770372f, -0.02101827f, 0.00791166f, 
    0.00605659f, 0.08066640f, -0.15587725f, -0.02683212f, -0.08517790f, -0.06127487f, -0.20875171f, 0.20181070f, 
    -0.04792119f, -0.22479734f, 0.07673874f, -0.09186144f, -0.15709044f, 0.00758374f, -0.05188391f, 0.02551438f, 
    -0.14420563f, 0.14944005f, 0.12428255f, 0.07526544f, 0.03162712f, -0.05888418f, 0.01386284f, 0.26416764f, 
    0.07990170f, 0.07414398f, 0.02916702f, 0.05920896f, 0.09486195f, 0.04991628f, 0.02636066f, 0.09319913f, 
    0.10212290f, 0.06205982f, 0.16865872f, 0.11206653f, -0.08500021f, -0.09855673f, 0.05533879f, 0.13639568f, 
    -0.12424340f, -0.08942945f, 0.02126362f, 0.03022407f, 0.12866238f, -0.06396069f, 0.03337409f, 0.12160782f, 
    0.11742224f, -0.01393759f, 0.00030580f, 0.05494127f, 0.02439185f, -0.10201739f, 0.00145108f, -0.06532334f, 
    -0.05080544f, 0.00721831f, 0.15152986f, 0.20998806f, -0.12958719f, -0.06131697f, -0.01957882f, 0.02504807f, 
    -0.04857891f, -0.06243491f, 0.07465907f, 0.03696953f, 0.00891976f, 0.08849292f, -0.07472283f, 0.19569907f, 
    0.10316318f, -0.03919650f, 0.00192997f, -0.06457494f, 0.06104657f, 0.11552460f, 0.19918446f, 0.36259457f, 
    -0.01445965f, 0.06782401f, 0.02497505f, 0.15245724f, -0.12604478f, 0.16553001f, -0.07122325f, -0.20685121f, 
    0.06961045f, -0.17404260f, 0.01227693f, 0.10618349f, 0.13135555f, 0.34179577f, -0.11664522f, 0.08718319f, 
    -0.06280358f, -0.03155802f, -0.00566973f, 0.08650146f, -0.01127544f, -0.04750363f, -0.02232380f, 0.17905797f, 
    -0.36645895f, -0.07826687f, 0.03735051f, -0.15427366f, 0.04459981f, -0.07369743f, -0.02109991f, -0.00128950f, 
    -0.06421328f, 0.06813015f, -0.03236039f, -0.19172932f, -0.00873644f, -0.05515998f, -0.07416929f, 0.12024554f, 
    0.04946368f, 0.09381058f, 0.23656131f, -0.08982783f, 0.01331815f, 0.02991039f, -0.01836517f, -0.09935933f, 
    0.04528865f, -0.00494464f, 0.01380487f, 0.09174144f, -0.16327515f, -0.20237420f, 0.06730533f, -0.13843511f, 
    -0.02119802f, 0.05583189f, 0.01373253f, 0.01648805f, -0.18492234f, -0.18666686f, 0.14790018f, 0.16450144f, 
    0.10952669f, -0.16053699f, -0.04339864f, -0.10088409f, -0.09262328f, 0.12840830f, -0.06064231f, 0.19275841f, 
    0.19751291f, 0.00845146f, -0.02080757f, 0.05217075f, 0.07617286f, 0.00446053f, -0.05681647f, -0.12968533f, 
    0.10449882f, -0.14597054f, 0.02786564f, 0.06251594f, 0.02155910f, -0.00311450f, 0.09478006f, 0.13150954f, 
    -0.00531814f, 0.00898459f, 0.16305819f, 0.05459898f, -0.07313302f, -0.09451577f, -0.21680328f, -0.03124213f, 
    0.13840245f, 0.23696287f, 0.34874135f, 0.27437130f, -0.09248189f, -0.06370029f, 0.05002598f, 0.06888677f, 
    0.05298574f, 0.03258940f, -0.01104074f, -0.02400696f, -0.01987018f, 0.08502506f, 0.01660844f, -0.01109916f, 
    0.06472502f, -0.04721974f, 0.05366777f, -0.03391906f, 0.15683597f, -0.01941529f, 0.00426612f, -0.01325982f, 
    0.12825666f, 0.09954550f, -0.02593240f, -0.01069372f, 0.03236627f, 0.08542749f, 0.06162967f, 0.01613031f, 
    -0.06808788f, -0.10170319f, -0.17072716f, -0.19647069f, -0.08431257f, -0.38596478f, -0.35976821f, -0.32999840f, 
    0.06285532f, 0.03558958f, 0.02404520f, 0.04644626f, 0.06788069f, -0.07898895f, -0.05983419f, -0.01655060f, 
    -0.08897751f, 0.00004015f, 0.05015341f, -0.06232657f, 0.02876917f, -0.07289827f, -0.12701774f, -0.11505397f, 
    -0.01742110f, -0.11537500f, -0.06698941f, -0.10978591f, 0.21305884f, 0.22597554f, -0.02029804f, -0.01007904f, 
    0.20278749f, 0.19370447f, 0.23745419f, 0.07313795f, 0.08203018f, -0.10996193f, -0.01764114f, 0.01154222f, 
    -0.12006517f, -0.09753983f, 0.07202844f, 0.10016367f, 0.03879509f, -0.09372868f, -0.20580567f, -0.08370064f, 
    -0.08080456f, -0.09557845f, -0.16661656f, -0.09421900f, 0.11604634f, 0.10216981f, 0.03566572f, -0.01985276f, 
    -0.00539711f, 0.04243083f, 0.05246893f, -0.02309404f, -0.18302196f, -0.26475483f, -0.14219101f, -0.06904657f, 
    0.16378696f, 0.12088499f, -0.36804312f, 0.05733422f, 0.07129937f, -0.05286978f, -0.09135925f, 0.05829417f, 
    0.06857074f, -0.06193065f, 0.05726169f, -0.18227018f, -0.10115681f, 0.00725036f, 0.05195058f, 0.11790372f, 
    -0.14719775f, -0.07805918f, -0.06487637f, -0.02590790f, -0.00402020f, -0.02896929f, -0.01502090f, 0.02147697f, 
    -0.00742559f, -0.03562565f, 0.01570446f, 0.01734765f, 0.11899000f, 0.09468424f, 0.06049844f, 0.02882162f, 
    0.07904097f, 0.02786839f, 0.04131318f, 0.05033473f, 0.03219856f, 0.17809479f, 0.20279276f, 0.12549120f, 
    -0.05988173f, -0.12923951f, -0.05877860f, 0.01465597f, 0.11157227f, 0.05253670f, 0.00027801f, 0.02886465f, 
    -0.15127093f, 0.02159974f, 0.07200339f, 0.12847500f, -0.12860006f, -0.00913086f, -0.12432615f, -0.02957326f, 
    -0.01991918f, -0.04596383f, -0.02949017f, -0.00770772f, 0.11027993f, -0.35033193f, 0.01795645f, -0.02168473f, 
    -0.12306798f, -0.01739443f, -0.06431825f, -0.09334472f, -0.00585133f, -0.03523977f, -0.02666007f, -0.01005244f, 
    0.00123234f, -0.02036730f, 0.12292641f, 0.16098642f, -0.02178397f, -0.05161344f, -0.09237975f, 0.02329670f, 
    0.13201593f, 0.01603924f, 0.14122625f, 0.03805013f, -0.09476942f, 0.29086876f, -0.08563170f, 0.04261952f, 
    -0.04354055f, 0.12205260f, -0.05847286f, 0.18443133f, -0.06254289f, 0.06356798f, -0.00612475f, -0.18561138f, 
    0.10784287f, 0.01637271f, 0.00211627f, -0.04917779f, 0.06736719f, -0.01782716f, -0.02709271f, 0.05912722f, 
    0.12840468f, -0.04685201f, -0.13238342f, -0.06483886f, -0.20740260f, -0.08278240f, 0.07619809f, 0.16466993f, 
    0.09079256f, -0.02741836f, -0.01341597f, 0.21073745f, 0.06372299f, -0.03439442f, -0.07524894f, -0.04872378f, 
    -0.07897351f, -0.40879294f, 0.09085893f, 0.18319844f, -0.07733259f, -0.00596924f, -0.01966648f, -0.10779587f, 
    0.02834436f, -0.07456053f, -0.11749144f, 0.11404603f, 0.19839071f, 0.01094666f, -0.11802664f, 0.07381417f, 
    -0.05282032f, -0.04846571f, -0.01584336f, -0.04808935f, 0.18461809f, -0.02374996f, -0.18132448f, -0.01978244f, 
    -0.00812816f, -0.03304734f, 0.10346352f, 0.05865574f, 0.08348689f, 0.08432320f, -0.09538759f, -0.03676661f, 
    0.01379899f, -0.00150388f, 0.08513693f, 0.11479811f, 0.23458642f, -0.10313108f, -0.15642880f, 0.05838956f, 
    0.05740979f, 0.17758070f, 0.03641409f, 0.01306998f, 0.05626652f, -0.11135432f, -0.01041539f, -0.16824940f, 
    0.04993977f, 0.21646893f, -0.34374267f, 0.17273584f, -0.02908586f, -0.06429147f, 0.03651774f, -0.04561606f, 
    -0.30139542f, 0.07649106f, -0.06837774f, -0.12410112f, 0.04648662f, 0.14907509f, 0.15601864f, -0.17279747f, 
    0.13139553f, 0.07061302f, -0.02356433f, 0.14896365f, -0.04957338f, -0.05175747f, 0.10253062f, 0.09427842f, 
    0.00634164f, -0.09579496f, 0.04490253f, 0.10201937f, 0.15451762f, -0.19280402f, 0.03910464f, -0.06826153f, 
    0.01646392f, 0.11598374f, 0.08925808f, 0.09641334f, -0.02238520f, 0.06507108f, 0.10582691f, -0.12224652f, 
    0.20439644f, 0.07877899f, -0.10413821f, -0.22530851f, 0.01489605f, -0.06115582f, -0.08746588f, 0.01594410f, 
    -0.02516363f, -0.09943672f, -0.31564206f, 0.39105579f, 0.03668300f, -0.04208488f, -0.00630311f, 0.01623507f, 
    0.03808990f, 0.09830990f, 0.03646844f, -0.04935787f, 0.16888022f, 0.21425064f, 0.16014525f, -0.05017196f, 
    0.03854460f, 0.04682660f, 0.04633120f, 0.06355033f, 0.00937395f, 0.04715414f, 0.00326511f, 0.09674186f, 
    0.03398226f, -0.06585026f, 0.04979430f, -0.15451555f, 0.13918526f, -0.00790260f, -0.03378431f, 0.27485272f, 
    -0.05322143f, 0.05791918f, 0.23743662f, -0.09468459f, 0.07081312f, 0.18344772f, -0.03606832f, -0.04046908f, 
    -0.23444958f, -0.04936721f, 0.06665264f, -0.03686216f, -0.06128757f, -0.00951814f, 0.01427654f, -0.10345222f, 
    0.12869054f, 0.12317732f, 0.01061704f, -0.11513237f, 0.00051997f, 0.03880530f, -0.08159399f, 0.04645310f, 
    0.04939456f, -0.02206450f, -0.03665796f, 0.06420721f, -0.29656827f, 0.08124965f, -0.21370111f, 0.11194879f, 
    0.09582946f, -0.11073171f, 0.19147877f, 0.00841333f, 0.06514692f, -0.08768004f, -0.00672572f, 0.13451084f, 
    0.03804849f, 0.08078252f, 0.20121400f, -0.03454219f, -0.07217791f, -0.06638481f, 0.04011772f, 0.08126070f, 
    0.15587841f, -0.06624989f, -0.08378674f, -0.05182001f, -0.46041471f, -0.10274788f, -0.19031490f, -0.05508954f, 
    -0.01042318f, 0.05223821f, 0.02865789f, 0.04780525f, -0.03796783f, -0.29952493f, -0.31973556f, -0.11403602f, 
    0.31204590f, 0.09728628f, -0.08886100f, -0.09138146f, 0.09899601f, -0.02425854f, 0.05790780f, -0.12646033f, 
    0.07673405f, 0.07593368f, -0.13377857f, -0.19308290f, 0.13462803f, -0.44229928f, -0.64715016f, 0.20337725f, 
    0.07786600f, 0.10209531f, 0.06664398f, -0.02308844f, 0.01805755f, 0.02432333f, -0.02856582f, 0.01774719f, 
    -0.02133462f, -0.00596654f, -0.02587058f, -0.10925640f, 0.04822061f, 0.22302154f, -0.02198915f, -0.01844866f, 
    0.08669304f, -0.04814909f, 0.02538043f, 0.13380279f, -0.00051675f, 0.23761341f, -0.15398878f, -0.09832248f, 
    0.13107148f, 0.01440582f, 0.08967996f, -0.02961162f, 0.06494655f, 0.04937510f, 0.04820962f, 0.03496950f, 
    0.11741012f, 0.04295187f, -0.36524993f, 0.11714565f, 0.03935813f, 0.09412726f, 0.05937851f, -0.05336729f, 
    0.11873847f, -0.17094152f, 0.38599074f, 0.03416860f, -0.36303404f, -0.40382183f, -0.36729050f, -0.20527600f, 
    0.07817340f, -0.04134091f, -0.07122696f, 0.07558043f, 0.08339147f, -0.08013697f, 0.12660606f, 0.07162342f, 
    -0.27109638f, 0.02760547f, 0.06750216f, -0.10324563f, -0.00819445f, -0.06470545f, 0.02515569f, 0.02561762f, 
    -0.29907224f, -0.35960662f, -0.09031776f, -0.20631291f, 0.34694019f, -0.25421333f, -0.09091824f, 0.31145310f, 
    0.01480153f, 0.03443524f, -0.06009852f, 0.15656312f, -0.02371745f, 0.00039907f, 0.01772699f, -0.04657052f, 
    -0.31057888f, -0.16222146f, -0.03806737f, 0.09767319f, -0.05450470f, -0.00767409f, 0.02711591f, 0.06127068f, 
    0.19428289f, 0.12725089f, 0.26824149f, -0.19574967f, 0.03987944f, 0.19657050f, 0.13280460f, -0.30203789f, 
    -0.15918462f, 0.18109483f, 0.06571758f, -0.10503338f, 0.08755201f, -0.04607370f, -0.01045499f, 0.06431372f, 
    -0.52191210f, 0.23698772f, 0.03373441f, 0.22909856f, 0.04054318f, -0.12118192f, -0.15607852f, 0.19596462f, 
    -0.10688031f, -0.07078516f, 0.09396427f, 0.03520407f, -0.19028176f, -0.13557602f, -0.08603479f, 0.06600990f, 
    0.22892249f, -0.11587170f, 0.06177773f, 0.00799333f, 0.14358465f, 0.07385304f, 0.04894555f, -0.01451591f, 
    -0.16552155f, 0.13030133f, 0.02839508f, 0.18905571f, 0.11222770f, 0.08032710f, -0.04086531f, 0.00426566f, 
    0.03221637f, 0.00019078f, 0.12398902f, 0.05351516f, -0.25345862f, 0.26323515f, 0.07403665f, -0.32055992f, 
    -0.15940495f, -0.16033277f, -0.02536443f, -0.03725366f, -0.13048267f, -0.09885284f, -0.27166179f, -0.13317324f, 
    -0.11457293f, -0.14141403f, 0.08589543f, -0.01315392f, -0.02748838f, -0.05155043f, -0.00099692f, 0.11064034f, 
    0.04542852f, -0.02630777f, 0.03595347f, -0.17976512f, 0.26244015f, -0.00567179f, -0.14135474f, -0.17605530f, 
    0.09109547f, 0.03092798f, 0.02751818f, 0.09372261f, 0.05640989f, 0.38471967f, -0.01578116f, -0.36566675f, 
    -0.03646109f, 0.04533821f, 0.10736991f, -0.19795160f, -0.03890576f, 0.08438586f, -0.03176700f, 0.07007591f, 
    0.04007607f, 0.13605109f, -0.20971221f, 0.17173938f, -0.15370062f, -0.23519143f, 0.11223635f, 0.09847713f, 
    0.02608628f, 0.08240558f, 0.02473664f, 0.00959116f, -0.05189372f, -0.06134050f, -0.05011306f, -0.02554167f, 
    0.00083659f, -0.08816525f, 0.17804462f, -0.21679477f, 0.24418835f, 0.04086646f, -0.03244816f, 0.03733444f, 
    -0.11573444f, -0.03177697f, 0.05361793f, -0.09833362f, 0.06772108f, 0.26547831f, -0.28976578f, -0.18522808f, 
    0.09533067f, -0.02503861f, -0.08636872f, -0.06633832f, 0.01265841f, 0.04317256f, 0.10833772f, 0.14453150f, 
    -0.25057903f, -0.06820409f, -0.02193054f, -0.40483743f, 0.02632755f, -0.00525998f, -0.08202257f, -0.12145442f, 
    -0.06052118f, -0.26963198f, 0.10853105f, -0.05678104f, 0.09424593f, 0.01377987f, -0.19945616f, -0.15679097f, 
    0.08305617f, 0.13008636f, 0.05706078f, 0.01967546f, -0.02149888f, -0.38471165f, -0.16756117f, -0.65460598f, 
    -0.03412720f, -0.15081252f, 0.07459106f, 0.16260327f, 0.03573475f, -0.10795953f, -0.02696439f, -0.10617619f, 
    0.05253239f, 0.01818066f, -0.01860464f, -0.26343611f, -0.32936555f, -0.29520935f, -0.06040161f, -0.32548904f, 
    -0.01191129f, 0.06496999f, 0.03066962f, 0.08283140f, 0.07071526f, -0.08364480f, -0.10590862f, -0.01620950f, 
    0.13362661f, -0.03606035f, -0.36381227f, 0.23585394f, 0.00050168f, 0.01719723f, -0.00769676f, -0.04215046f, 
    0.01263462f, -0.18956652f, 0.01138804f, 0.12088189f, -0.05276063f, -0.02863722f, -0.27513745f, 0.06880890f, 
    -0.04393161f, 0.00707074f, 0.21109475f, 0.01363040f, -0.03678184f, -0.00939790f, 0.00401495f, 0.11621238f, 
    -0.13667144f, 0.17897213f, -0.25813037f, 0.13712218f, 0.02882243f, 0.04637591f, -0.15155387f, 0.10870750f, 
    0.06842162f, 0.01784327f, 0.03001877f, 0.06471351f, 0.00052671f, -0.01958583f, 0.47979552f, -0.22065358f, 
    -0.11189611f, -0.11787669f, 0.02852262f, -0.01952619f, 0.23751929f, -0.11888566f, -0.00187005f, -0.00913336f, 
    -0.16758363f, 0.19013061f, 0.16906266f, 0.04132890f, 0.02561597f, 0.05477089f, -0.05681486f, 0.07612595f, 
    0.03580221f, -0.07837719f, 0.13046177f, -0.11395848f, -0.09021588f, 0.00197424f, 0.17508787f, -0.29176170f, 
    0.26365012f, -0.04666569f, 0.04141506f, -0.05881977f, 0.08966733f, -0.13318500f, 0.22708014f, 0.05721256f, 
    0.26711515f, 0.08807936f, 0.03159196f, 0.01715750f, 0.21086971f, 0.17091613f, -0.08251657f, -0.25367352f, 
    -0.04389263f, 0.02719198f, -0.00109647f, -0.06760371f, 0.09249047f, -0.12124223f, -0.10442628f, 0.12035461f, 
    0.08183672f, -0.14191619f, -0.11075027f, 0.01417426f, 0.04786077f, 0.02337681f, -0.04298674f, 0.05637991f, 
    0.00388229f, -0.04732640f, -0.03030489f, 0.08649972f, 0.04592397f, -0.09084038f, -0.08730508f, -0.04834655f, 
    -0.00811644f, -0.01179393f, 0.20087141f, 0.18757363f, 0.16685362f, -0.02328991f, -0.25604019f, 0.07530206f, 
    0.02910366f, 0.00502018f, -0.00447282f, -0.02074683f, 0.08717761f, -0.00884947f, -0.03685893f, 0.12711807f, 
    0.16475250f, -0.13513826f, -0.00928302f, -0.06047544f, -0.12620325f, 0.05359134f, -0.05553650f, 0.18085502f, 
    0.00528620f, -0.08639646f, -0.02539717f, 0.00467671f, -0.23572573f, 0.05671062f, -0.20874737f, -0.27427340f, 
    0.12200172f, 0.07128357f, -0.07956088f, -0.11614648f, 0.00457490f, -0.02112720f, 0.11454418f, -0.00567381f, 
    0.17390905f, -0.07073666f, 0.05336539f, 0.15712875f, -0.03742533f, 0.09696131f, 0.06983499f, -0.07384325f, 
    -0.02231307f, 0.13241494f, 0.03512405f, 0.25105381f, -0.10947452f, -0.20209987f, -0.13090704f, 0.01362628f, 
    -0.09747668f, 0.01077225f, -0.04286561f, -0.04904188f, 0.27233636f, -0.09610086f, 0.32664010f, 0.12501030f, 
    -0.21308164f, 0.46929982f, -0.35529855f, -0.15037680f, 0.14185533f, -0.07431657f, -0.02778183f, -0.02264583f, 
    0.17380416f, -0.01337941f, -0.03095337f, 0.07948937f, -0.13054365f, 0.04459365f, 0.00187328f, -0.15288414f, 
    0.20436375f, -0.04553834f, 0.09013270f, 0.33344159f, -0.02166307f, 0.01055437f, 0.08016646f, 0.05569106f, 
    0.00654058f, -0.03154333f, -0.08153766f, 0.00692414f, 0.01744207f, -0.01877662f, -0.02229809f, -0.03187515f, 
    0.02752196f, -0.06317905f, -0.12317756f, 0.06753745f, -0.04933932f, -0.07651273f, 0.01352464f, -0.05670322f, 
    0.12318660f, 0.17908040f, 0.21879895f, 0.06726068f, 0.06332637f, 0.03750527f, 0.02457014f, 0.00129495f, 
    -0.24198708f, -0.14787284f, -0.01036487f, -0.13252255f, 0.01979555f, -0.04070212f, 0.12338915f, 0.01025899f, 
    0.16051194f, -0.05805484f, -0.04646751f, -0.06588279f, -0.15055448f, 0.16144739f, -0.11052087f, -0.04389375f, 
    0.01163227f, 0.00035678f, -0.05177383f, -0.06534372f, 0.17583363f, 0.08084477f, -0.10163733f, -0.09894536f, 
    -0.05434693f, 0.14111352f, 0.09191344f, -0.02884702f, 0.05315315f, -0.09311058f, -0.09542172f, -0.09310697f, 
    -0.03549695f, -0.04419723f, 0.00254552f, -0.14037338f, -0.00019830f, 0.18970902f, -0.28535649f, -0.11372608f, 
    0.07821584f, 0.17717974f, -0.10297204f, -0.07236932f, 0.00534452f, -0.12139013f, 0.11202084f, 0.02161530f, 
    0.07762827f, -0.26575100f, 0.05839626f, 0.03221969f, -0.08623076f, -0.20799461f, -0.07759451f, -0.03034185f, 
    0.05070999f, 0.04724129f, 0.03787357f, 0.01131381f, 0.42312598f, 0.08547971f, -0.04923166f, 0.08544250f, 
    0.01068994f, 0.17129923f, -0.13346234f, 0.08078329f, 0.02540994f, 0.05264966f, 0.07627700f, 0.11562465f, 
    -0.39267388f, -0.13387287f, 0.25994545f, 0.24325310f, 0.15211940f, -0.11737157f, -0.00512551f, 0.12727199f, 
    0.22194648f, 0.00432921f, -0.20197007f, -0.07195609f, -0.17632204f, -0.18712382f, 0.12705915f, 0.11726641f, 
    0.04506320f, -0.08687989f, -0.01691272f, 0.00978195f, 0.15201187f, 0.09338249f, 0.05501363f, -0.02857986f, 
    -0.04510500f, -0.11516395f, -0.11706468f, 0.10571062f, -0.13352233f, -0.04799105f, 0.11133371f, 0.21095033f, 
    0.02316635f, -0.00733503f, 0.03872314f, -0.02313673f, 0.23659438f, 0.03246671f, -0.15825975f, -0.02709657f, 
    -0.05023232f, 0.06745604f, 0.05168999f, 0.09249547f, -0.11410043f, 0.10433319f, -0.13153253f, 0.03895251f, 
    0.44055235f, 0.19878115f, -0.02522781f, -0.23124966f, -0.04552732f, -0.03713024f, 0.09864844f, 0.07350013f, 
    0.00895361f, 0.06074235f, -0.02817425f, 0.04366235f, -0.35349596f, -0.31437311f, -0.13758716f, 0.11106784f, 
    -0.28551307f, 0.07740986f, 0.06043900f, -0.27228859f, 0.06508585f, 0.08655265f, -0.00050489f, -0.01386314f, 
    0.08339895f, -0.10732387f, -0.17915815f, 0.30278173f, -0.05089881f, -0.05320889f, 0.09325030f, 0.06421803f, 
    0.04814969f, -0.00212113f, -0.09772177f, 0.08704236f, -0.61428237f, -0.37981552f, -0.46068555f, -0.13108726f, 
    -0.28229955f, -0.09531824f, -0.25380737f, -0.24989580f, 0.01082097f, -0.00872069f, 0.02667152f, 0.07676943f, 
    0.02894364f, -0.02994805f, 0.06309738f, -0.27508312f, 0.04331063f, 0.04542258f, 0.10466447f, -0.06445289f, 
    -0.04242117f, 0.02350687f, -0.06496996f, 0.03089420f, -0.34640363f, -0.80365366f, -0.48479787f, 0.35031596f, 
    -0.02220542f, -0.30343479f, -0.15423806f, -0.12891790f, -0.06999412f, -0.02859833f, -0.01131144f, 0.02576062f, 
    0.00230447f, 0.00004799f, -0.04449611f, 0.03940834f, 0.01544222f, 0.13386554f, -0.02362929f, 0.12482275f, 
    0.05833799f, 0.06698276f, 0.05453067f, -0.01220302f, -0.25063351f, -0.66066688f, -0.09775344f, 0.45515129f, 
    0.16482976f, 0.04351774f, 0.01289405f, -0.34170702f, 0.01231235f, 0.04460475f, 0.09432561f, 0.06093988f, 
    0.22489765f, -0.11125716f, -0.14782630f, 0.00887203f, -0.09819040f, -0.12550676f, 0.03743967f, 0.20754460f, 
    0.01933884f, 0.01558114f, -0.05269038f, -0.18001388f, 0.12469333f, -0.02622280f, 0.08652295f, 0.06344927f, 
    0.03758403f, 0.04600741f, 0.08932373f, -0.06305884f, -0.00249788f, -0.11978547f, 0.19702575f, -0.04248599f, 
    -0.28278154f, -0.71550936f, -0.52829790f, -0.23013635f, -0.17099197f, 0.00605175f, -0.00578124f, -0.16857837f, 
    -0.04916700f, -0.01475988f, 0.00875844f, 0.13203511f, 0.10452437f, -0.01189581f, 0.16401869f, -0.04182158f, 
    -0.01168537f, 0.07202516f, 0.00193208f, 0.05714490f, 0.13839915f, 0.22376201f, 0.16656877f, -0.08139202f, 
    0.24910805f, 0.15498580f, 0.07449158f, 0.01534868f, 0.06895552f, 0.00557129f, 0.05413912f, 0.07872390f, 
    0.01411032f, 0.07237033f, -0.00522724f, -0.11015437f, 0.06931707f, -0.17545503f, -0.11065564f, -0.22299077f, 
    0.10556564f, 0.06845020f, 0.18897685f, -0.14658017f, 0.06897207f, 0.00736578f, -0.03311516f, 0.05043396f, 
    -0.02691059f, -0.00523891f, -0.01815833f, -0.05859772f, -0.11816792f, -0.11078490f, 0.02909984f, 0.11193388f, 
    0.01077515f, 0.03559973f, -0.05937523f, -0.07011928f, -0.49484864f, -0.38832355f, -0.02935430f, -0.28688446f, 
    -0.09987669f, -0.41846988f, -0.26514393f, -0.13752526f, -0.02199826f, 0.05945954f, -0.06680550f, 0.02744577f, 
    0.21947530f, -0.02882858f, -0.19410458f, -0.10306577f, -0.04421315f, -0.04303498f, -0.05368499f, 0.01676416f, 
    0.01553016f, 0.03451365f, -0.06178434f, -0.20240493f, -0.24967475f, 0.44909534f, 0.14940989f, 0.14054757f, 
    -0.03243768f, -0.07908002f, -0.04805778f, 0.03002477f, 0.02317242f, 0.01503402f, 0.08370738f, 0.03367207f, 
    0.00806912f, -0.04984554f, 0.02577359f, 0.02180178f, 0.01664915f, 0.00568179f, 0.01534389f, 0.05518585f, 
    0.02626260f, -0.00728290f, 0.20807619f, 0.10918305f, 0.07562830f, -0.07143016f, -0.05043616f, 0.06887635f, 
    0.02112680f, 0.02194012f, -0.09309153f, 0.05317404f, -0.03556465f, -0.01559793f, -0.09500621f, 0.00311613f, 
    -0.03044152f, 0.02041472f, -0.06923170f, 0.27493936f, 0.04408690f, 0.04726611f, -0.07238995f, -0.00500032f, 
    0.13297914f, -0.01028944f, 0.11260226f, -0.01236988f, -0.61296523f, -0.21226953f, 0.07890052f, 0.20843849f, 
    0.14460881f, 0.01441723f, -0.04002142f, -0.19511279f, 0.04468135f, -0.00838495f, 0.02774386f, 0.04971551f, 
    -0.09388624f, -0.08960702f, 0.10878945f, -0.12877429f, 0.05521034f, 0.03815123f, 0.13999610f, -0.00665367f, 
    -0.01593350f, 0.08579000f, -0.02716378f, 0.11488546f, -0.05982599f, -0.04774813f, 0.00019328f, 0.00933328f, 
    0.00261715f, 0.08399567f, -0.13500001f, -0.02361427f, 0.04482185f, 0.09176788f, -0.01908336f, 0.06764672f, 
    0.01861536f, -0.09220374f, -0.14052318f, -0.17946808f, 0.02248341f, 0.12215947f, -0.06757244f, 0.03919094f, 
    -0.01416105f, 0.00444613f, -0.01858467f, -0.03798953f, -0.14211667f, -0.12110921f, 0.04428508f, 0.05259196f, 
    -0.08145482f, -0.01730686f, -0.00008231f, 0.02918099f, -0.04182219f, 0.04390087f, 0.16711102f, -0.01560437f, 
    -0.26452789f, 0.13800006f, 0.10446166f, 0.10651511f, -0.03990541f, 0.00614194f, -0.03334072f, 0.13134684f, 
    -0.01895587f, 0.03870053f, 0.22098839f, 0.01062444f, 0.28613585f, 0.31067532f, -0.19586749f, -0.09133124f, 
    -0.01568763f, -0.00729088f, 0.12374439f, 0.05883164f, 0.03777846f, -0.10572658f, 0.10258951f, -0.05511969f, 
    -0.17151672f, 0.13461740f, 0.30159748f, 0.07840747f, 0.04789739f, -0.04750311f, 0.04311290f, 0.07617523f, 
    0.11894891f, 0.07289038f, 0.07789605f, 0.06323095f, -0.29459411f, -0.08716307f, -0.15306142f, 0.01049048f, 
    0.04988738f, 0.08494013f, 0.01481467f, -0.04267576f, -0.05375082f, -0.00637507f, -0.00145979f, 0.06716171f, 
    -0.17076504f, -0.11025450f, -0.10198488f, 0.05747046f, 0.00352091f, -0.00739474f, 0.06082406f, 0.04892797f, 
    0.03156691f, -0.13812748f, 0.03162392f, -0.03537527f, -0.47038451f, -0.09041417f, 0.07838080f, -0.51437831f, 
    0.00196772f, 0.02277957f, -0.00616732f, 0.01991356f, 0.01134518f, 0.00854895f, 0.08319761f, -0.10066231f, 
    -0.37347087f, -0.02786441f, 0.43312901f, 0.26126805f, 0.00471054f, -0.07052603f, 0.02594483f, -0.09203350f, 
    0.01958074f, 0.18682462f, -0.00888496f, 0.07201318f, 0.27386382f, 0.06853489f, 0.05766938f, -0.04137593f, 
    0.02503864f, -0.00878822f, 0.06319989f, 0.05489748f, 0.01489204f, 0.24010769f, 0.02626693f, 0.18318957f, 
    0.00801054f, -0.20022184f, -0.30930707f, -0.14693332f, -0.16375802f, 0.24251401f, 0.08634986f, -0.05063733f, 
    -0.07489859f, -0.06515025f, 0.01214157f, 0.06980989f, -0.17459908f, 0.15397049f, 0.16277853f, 0.23357895f, 
    0.06102997f, -0.07390409f, 0.03805729f, 0.03169069f, 0.09910394f, 0.10244098f, 0.04942057f, 0.06706814f, 
    0.30911449f, 0.17271250f, -0.01736965f, -0.21102776f, 0.06229524f, -0.06532137f, 0.17732987f, -0.00451613f, 
    0.11863548f, 0.10289963f, -0.15784855f, 0.02251117f, 0.12533686f, -0.17206979f, -0.08660048f, 0.11631091f, 
    0.02625060f, 0.11499295f, 0.23472337f, 0.00127405f, -0.04670687f, -0.15737514f, -0.05855321f, 0.14498256f, 
    -0.58393949f, -0.68353385f, -0.15829796f, -0.19469821f, -0.29436648f, -0.15127492f, -0.08612578f, -0.23676896f, 
    -0.01561888f, -0.02735617f, 0.09308392f, -0.00268858f, -0.17749371f, -0.25953835f, -0.08143029f, 0.35299328f, 
    0.03892584f, 0.12744848f, 0.09562791f, 0.10401168f, 0.18883640f, 0.09880431f, 0.08781190f, -0.02097186f, 
    -0.14835721f, -0.07475762f, -0.33677626f, -0.25386193f, -0.04990998f, 0.13650715f, -0.00497121f, -0.04405616f, 
    -0.01330838f, 0.01703854f, 0.04369341f, 0.03959749f, -0.01444035f, -0.30260265f, -0.06116384f, 0.06266782f, 
    0.07135890f, 0.08454423f, -0.00704460f, -0.07734145f, 0.01172435f, -0.11052620f, 0.05899234f, -0.06746500f, 
    -0.48583975f, -0.46199813f, -0.14054437f, -0.53494698f, -0.06078869f, -0.15278172f, -0.23472504f, -0.37462050f, 
    0.02381456f, -0.04109735f, -0.05133936f, 0.01404510f, 0.20957972f, -0.04289211f, -0.15593636f, -0.16462938f, 
    0.08767911f, -0.06981876f, 0.11356247f, -0.01540376f, -0.03027266f, 0.08953673f, -0.16080807f, -0.12523182f, 
    -0.00582222f, -0.03253968f, 0.10716058f, -0.02896459f, 0.00432294f, -0.04413630f, 0.08592913f, -0.08254395f, 
    -0.08293305f, -0.00218328f, -0.09515726f, 0.01794885f, 0.07024108f, -0.05125129f, -0.25548878f, -0.12978834f, 
    -0.00020809f, 0.00728949f, 0.03602618f, 0.02227013f, -0.05078517f, 0.06242702f, -0.07939483f, -0.22239034f, 
    0.28956172f, 0.40272048f, -0.24413441f, 0.02114170f, -0.07373115f, -0.09184714f, 0.03192970f, 0.30574867f, 
    0.09877409f, 0.04929318f, -0.16943659f, -0.01948296f, 0.02755281f, -0.13567699f, 0.13074265f, -0.03874960f, 
    0.11639577f, 0.02537359f, 0.18920390f, -0.19058117f, 0.10643534f, -0.15352128f, 0.02968358f, 0.01671728f, 
    -0.01079039f, 0.09877672f, 0.17762937f, 0.46079865f, 0.00734519f, -0.04579264f, 0.02512405f, -0.05039408f, 
    0.02691664f, 0.06676304f, 0.10658031f, 0.04795292f, -0.11505307f, -0.01412361f, -0.03400038f, 0.13153918f, 
    0.05002286f, -0.14216766f, 0.04798231f, -0.03915126f, -0.04137170f, -0.18528855f, 0.12141418f, 0.01350797f, 
    0.22234726f, -0.13136482f, 0.22531466f, -0.02706606f, 0.01053445f, -0.08040345f, -0.05943754f, 0.06050530f, 
    0.08371895f, -0.03925169f, 0.13331005f, -0.16436747f, -0.38207439f, -0.29324928f, -0.29597017f, -0.23171397f, 
    0.03931877f, 0.15860264f, -0.00885570f, 0.03324701f, 0.06204498f, -0.02527864f, 0.02566231f, 0.04608412f, 
    -0.03702595f, -0.08400173f, -0.01153595f, 0.06087438f, 0.03162278f, 0.09405043f, 0.06563485f, 0.00545263f, 
    -0.07650771f, -0.11307906f, -0.12044898f, -0.02295646f, -0.45183995f, -0.53158367f, -0.36172917f, -0.31349814f, 
    -0.34930652f, -0.13958755f, -0.24891031f, -0.33407405f, -0.02229722f, -0.03477957f, -0.09212149f, -0.05516848f, 
    -0.31335533f, 0.18016097f, 0.11140418f, 0.04800957f, -0.07381143f, 0.00559636f, -0.07269260f, 0.07288188f, 
    0.00811847f, 0.07721720f, 0.08886016f, 0.06130096f, -0.43618831f, 0.24119079f, 0.11149560f, -0.03430334f, 
    0.00691636f, 0.01026929f, -0.05762710f, 0.10632256f, -0.01041132f, 0.02295081f, 0.06832142f, 0.10920224f, 
    -0.29774258f, -0.21699871f, 0.10785418f, -0.18806182f, -0.36310595f, 0.11015130f, -0.02593380f, -0.22066976f, 
    -0.05659086f, 0.01989175f, 0.02487872f, 0.02227584f, -0.23595516f, -0.36025798f, 0.15843381f, -0.43210506f, 
    0.04531450f, 0.07205343f, 0.01646433f, -0.20683579f, 0.04894925f, 0.07052188f, -0.09769373f, 0.15093707f, 
    -0.11538333f, 0.01816572f, -0.17242834f, -0.07806558f, -0.18536179f, -0.13512336f, -0.08495998f, 0.09246949f, 
    0.02064213f, 0.03786090f, 0.01282146f, 0.03932931f, 0.01224880f, -0.01515801f, -0.30825931f, -0.19219570f, 
    -0.22826780f, -0.13430643f, 0.22149780f, 0.21387558f, 0.01542340f, -0.00912535f, -0.07424658f, 0.01578031f, 
    -0.06052617f, -0.04356621f, -0.05257996f, -0.04745708f, 0.04409814f, 0.03858842f, -0.02191964f, 0.11931375f, 
    -0.07484201f, 0.03295314f, 0.16878088f, -0.02017666f, -0.18399915f, -0.02639137f, 0.20232743f, -0.01627892f, 
    -0.04939780f, 0.02903931f, -0.09979250f, -0.01188542f, -0.07729378f, 0.11828180f, 0.06619976f, -0.08130050f, 
    0.10317043f, -0.03388765f, 0.01423127f, -0.06308744f, -0.02787790f, 0.10187662f, -0.13411209f, -0.00822653f, 
    -0.00542006f, 0.04965797f, -0.03350090f, 0.02247498f, -0.03102905f, 0.06113100f, 0.03029777f, -0.07339228f, 
    -0.06071014f, -0.02041339f, -0.04389004f, -0.04134188f, -0.00835713f, -0.13629504f, 0.06916071f, -0.07021935f, 
    -0.24843198f, 0.09193771f, -0.22509019f, 0.16631141f, 0.00456721f, -0.05554342f, 0.03696262f, 0.01712006f, 
    -0.05245828f, -0.02155854f, 0.15052569f, 0.05662161f, -0.21357924f, -0.13678387f, -0.04826521f, -0.17112064f, 
    0.11143099f, 0.04015969f, 0.09307798f, 0.19876535f, -0.02259986f, -0.08640195f, -0.03238919f, 0.05018018f, 
    -0.10992775f, -0.26179203f, -0.15794408f, 0.06479509f, 0.06866928f, 0.22658075f, -0.00298609f, 0.04632975f, 
    0.07066318f, -0.01240740f, -0.01114780f, -0.10054397f, -0.25616670f, -0.36849418f, 0.06591114f, 0.23913001f, 
    0.06537889f, 0.13525091f, 0.04712715f, 0.10616333f, 0.06275557f, 0.05238719f, -0.02021892f, -0.07977917f, 
    -0.04930063f, 0.13692749f, -0.17046280f, 0.03364230f, -0.06948619f, -0.01173875f, -0.01682445f, -0.08323012f, 
    -0.01440378f, 0.03720638f, -0.02255892f, 0.01902876f, -0.25800750f, -0.34325522f, 0.64400339f, -0.16963580f, 
    -0.08913476f, -0.10373191f, 0.00472917f, 0.23261353f, -0.09788754f, -0.00412323f, -0.07843198f, -0.03329556f, 
    -0.17110308f, -0.10385275f, 0.14840524f, -0.14654179f, -0.18388747f, 0.29310259f, -0.06258703f, -0.06810369f, 
    -0.01161375f, -0.05684035f, -0.09246946f, -0.05991720f, 0.21648075f, -0.14590469f, 0.01700971f, -0.31004021f, 
    -0.01719951f, 0.06516714f, -0.08829640f, 0.04976064f, -0.08803189f, -0.00152893f, 0.07413890f, -0.07816587f, 
    -0.19840135f, -0.09526963f, 0.19691314f, 0.04440613f, -0.10367968f, -0.15483367f, -0.05251248f, 0.02047571f, 
    0.00247152f, -0.06730781f, 0.01573696f, -0.01952481f, -0.09365446f, 0.12036323f, 0.08468040f, 0.07934123f, 
    0.02020843f, 0.01902250f, 0.04387402f, 0.02948828f, 0.07867515f, 0.03581143f, -0.01185421f, -0.22043094f, 
    -0.19094807f, -0.30087534f, -0.04482577f, 0.23135883f, 0.00026334f, -0.05878671f, 0.12575772f, 0.07738785f, 
    0.01293390f, -0.10006946f, -0.08262333f, -0.01194746f, 0.06655409f, 0.25333598f, 0.25021362f, 0.20533918f, 
    0.01283066f, 0.11046900f, -0.11388636f, 0.02645404f, 0.06067205f, 0.09913722f, 0.06196308f, -0.02143748f, 
    -0.23095191f, 0.09555977f, 0.07005346f, 0.09885407f, -0.01396909f, -0.11866239f, -0.00653925f, 0.01795166f, 
    0.06788687f, -0.05057095f, -0.01640808f, -0.03636641f, -0.03919388f, -0.01213064f, -0.11142448f, -0.09450964f, 
    -0.00126569f, -0.03170832f, -0.00296058f, -0.10275681f, 0.05681887f, 0.03598542f, 0.08166414f, 0.02518104f, 
    -0.01588105f, 0.06390002f, 0.05607281f, -0.02881508f, -0.06057889f, -0.01614486f, 0.09026027f, 0.02019651f, 
    -0.01658613f, -0.00604046f, 0.00170053f, -0.01442408f, -0.56975645f, 0.34290925f, -0.19192167f, 0.06129989f, 
    0.15449522f, -0.06592028f, 0.06116425f, 0.12427994f, -0.00497907f, -0.01260755f, -0.03745553f, 0.03383091f, 
    -0.13152176f, -0.02923144f, 0.13169678f, 0.01262251f, 0.01058464f, 0.06274724f, -0.05865800f, -0.00994657f, 
    0.04929791f, -0.04325163f, -0.10104597f, -0.01074715f, 0.13135841f, -0.16003045f, -0.09927436f, -0.05492397f, 
    -0.06095922f, -0.04493856f, 0.05782132f, -0.03374625f, -0.05864084f, 0.04707095f, -0.10214285f, 0.05624650f, 
    0.01610767f, -0.25485587f, -0.02506086f, -0.01768922f, 0.06810349f, 0.00769282f, 0.01035090f, -0.06674188f, 
    0.04461619f, 0.04395693f, 0.04479774f, -0.13536471f, 0.16664548f, 0.16435906f, -0.12414276f, -0.00392468f, 
    -0.10380905f, -0.00876556f, -0.02943514f, -0.12380634f, -0.06728250f, -0.03068266f, -0.10893504f, -0.07552999f, 
    0.33167860f, -0.30054146f, 0.03522442f, -0.21792123f, 0.04066587f, 0.00463009f, -0.07377557f, -0.06974833f, 
    -0.20719145f, -0.00876146f, -0.09087462f, -0.13105468f, -0.38539070f, 0.14246084f, 0.26796332f, -0.17749836f, 
    -0.01382072f, 0.14535294f, 0.13720061f, 0.16302979f, 0.00553615f, 0.06613340f, 0.07499749f, -0.04514568f, 
    0.20939200f, 0.17678446f, -0.08993160f, 0.13652551f, 0.01074395f, -0.05921797f, -0.04769403f, 0.02164014f, 
    -0.12852928f, -0.10276841f, -0.00803067f, 0.06396306f, 0.29047531f, 0.04963418f, -0.09972232f, -0.05542588f, 
    0.04716521f, -0.09128983f, -0.13071306f, 0.05455596f, -0.06811903f, -0.04209761f, 0.12463856f, 0.02138459f, 
    -0.04168164f, 0.03705239f, -0.02346718f, 0.01042371f, 0.05574723f, 0.03564977f, 0.00915055f, -0.00487431f, 
    0.05464306f, -0.02197832f, 0.03517930f, -0.00697334f, 0.42526454f, -0.28087604f, -0.23348981f, -0.16864361f, 
    0.06742053f, -0.03376953f, -0.02931862f, 0.12829004f, 0.05644050f, 0.06045257f, 0.04940304f, -0.11757741f, 
    0.45064107f, -0.17587906f, -0.09015554f, -0.15972205f, 0.05754762f, -0.00869331f, -0.02950284f, -0.02374606f, 
    0.20022543f, 0.08058458f, -0.08726481f, -0.11037813f, -0.09559739f, 0.17950366f, -0.14821276f, 0.10790215f, 
    -0.00225579f, -0.02299648f, 0.03217410f, -0.01796072f, -0.02377946f, 0.06137720f, 0.01844054f, -0.06564055f, 
    0.05890469f, 0.11005396f, -0.06701072f, -0.24498923f, 0.01661736f, -0.02942581f, 0.05551746f, 0.05318752f, 
    0.12772185f, -0.06957911f, 0.13117319f, -0.12498555f, 0.05617834f, -0.03357995f, -0.01286079f, -0.13217302f, 
    0.03053313f, -0.03774489f, -0.02103057f, -0.02090875f, 0.08237083f, 0.07978691f, 0.03170255f, 0.00412098f, 
    0.09533413f, -0.07398685f, -0.00089478f, -0.05620408f, 0.14741299f, 0.26879507f, 0.02673259f, 0.05888678f, 
    0.07269634f, 0.07737625f, 0.08059420f, 0.00806307f, -0.28434554f, 0.37216389f, -0.15351896f, 0.21874362f, 
    0.02414928f, 0.04586554f, 0.19757867f, 0.00967603f, 0.00362083f, -0.01456248f, 0.01447992f, -0.13863130f, 
    0.01084948f, -0.62922943f, -0.53098303f, -0.25049639f, -0.01268625f, -0.11590152f, 0.05205183f, 0.14404327f, 
    0.06861223f, 0.02307102f, 0.04325842f, -0.03502028f, -0.06574611f, -0.03875853f, -0.00737547f, 0.04714274f, 
    -0.05963405f, 0.01666523f, -0.01586388f, 0.04028137f, 0.15439533f, 0.18668520f, 0.15107521f, 0.01879012f, 
    -0.07264664f, 0.14588593f, -0.28364569f, 0.11927763f, -0.16556561f, 0.08093541f, 0.11109998f, -0.21261439f, 
    0.07923181f, -0.06732079f, -0.10307710f, 0.16290659f, 0.03497264f, -0.10908560f, 0.25300351f, 0.00215018f, 
    -0.02836511f, 0.06217043f, -0.03374687f, 0.01595123f, 0.01795638f, -0.00493268f, -0.12910856f, -0.01569401f, 
    -0.02668239f, 0.00486834f, -0.16197854f, -0.02083574f, -0.00060989f, -0.01481717f, -0.04279082f, -0.06474779f, 
    -0.03598788f, -0.04244215f, 0.02507304f, -0.12129275f, -0.09806828f, 0.20942371f, 0.04837145f, -0.04625314f, 
    -0.06581030f, 0.01779294f, -0.02040134f, 0.02135134f, 0.05571268f, 0.06243494f, 0.07002404f, -0.05259722f, 
    0.17988156f, -0.28900099f, -0.37498602f, -0.39259645f, 0.04213610f, -0.17769030f, 0.06684415f, 0.28333065f, 
    0.03477486f, 0.08494370f, -0.03412907f, -0.03067285f, 0.35789680f, -0.41967928f, 0.05640160f, -0.08647329f, 
    0.01556929f, 0.19569337f, -0.06451015f, -0.04618210f, -0.07236262f, 0.16032900f, -0.02425475f, -0.12912185f, 
    -0.19005892f, 0.23992558f, -0.17568420f, 0.17987113f, -0.07083897f, -0.15749036f, -0.08650807f, -0.07923420f, 
    -0.01943744f, -0.01675457f, -0.00715540f, -0.02418803f, 0.03302266f, -0.08437485f, 0.12798220f, -0.06654613f, 
    -0.05124772f, 0.04484450f, -0.04959099f, -0.07877676f, 0.06278403f, -0.05018563f, 0.06934348f, -0.00556046f, 
    -0.47812396f, -0.40455365f, -0.11051374f, 0.64925969f, 0.07289109f, 0.00092660f, 0.01405529f, -0.00612182f, 
    0.07110867f, -0.04807521f, 0.01153705f, 0.06893709f, -0.02049734f, 0.02328785f, 0.05652152f, -0.05698908f, 
    -0.05595737f, 0.03559634f, -0.05904185f, 0.01242842f, 0.06860048f, 0.04907308f, 0.03063828f, 0.01409221f, 
    0.07216776f, 0.06417500f, -0.02035542f, -0.02851103f, -0.00940765f, 0.09672295f, 0.01531328f, 0.01625971f, 
    -0.07873426f, -0.14440389f, -0.34064505f, -0.18733020f, -0.15441020f, -0.05373626f, -0.03880639f, -0.02925592f, 
    0.02183989f, 0.03738940f, -0.02195623f, -0.00740494f, 0.02203318f, -0.07119214f, -0.04161897f, -0.09760689f, 
    -0.42008880f, -0.22494048f, -0.17549597f, -0.15978506f, -0.11137123f, -0.05235039f, 0.01847893f, -0.08557753f, 
    -0.20874338f, 0.01003842f, -0.02836823f, -0.02005983f, -0.13696776f, 0.18634214f, 0.25309405f, -0.15357913f, 
    -0.03847042f, -0.13792062f, -0.06134171f, 0.11413255f, 0.01408881f, -0.02689710f, 0.12904292f, -0.05067620f, 
    -0.41926643f, 0.10273796f, -0.40905875f, -0.34366614f, -0.04541711f, -0.01607294f, -0.02611093f, -0.13519838f, 
    -0.05921001f, -0.02999224f, 0.03507674f, -0.03100246f, 0.09057512f, 0.03574187f, -0.01009089f, -0.02220965f, 
    0.03037199f, 0.04873823f, 0.07855801f, 0.02426456f, -0.11770528f, -0.00161435f, 0.07922874f, -0.06634089f, 
    -0.06312547f, 0.22813484f, 0.05216610f, 0.06484916f, -0.07662092f, 0.03414870f, 0.11372957f, 0.04183489f, 
    -0.02356442f, -0.20952292f, 0.04866773f, -0.05471066f, -0.11284297f, -0.13701758f, -0.23334776f, -0.23917805f, 
    0.04477410f, 0.10524142f, -0.02815086f, 0.09111319f, 0.05815685f, -0.00979226f, 0.03801682f, -0.03746023f, 
    -0.02125032f, 0.05890939f, 0.01639050f, -0.05054208f, 0.00471279f, 0.00536415f, 0.04270338f, -0.01934102f, 
    0.05743223f, 0.01185961f, 0.02357868f, -0.02696997f, -0.23347980f, -0.45651034f, -0.30029652f, 0.05208785f, 
    0.07113072f, -0.09947761f, -0.12755868f, 0.02518509f, 0.01752438f, 0.03224031f, 0.05314771f, 0.05944562f, 
    0.51911789f, -0.36892721f, -0.38867733f, -0.54477835f, -0.08778922f, -0.16531043f, -0.16362219f, 0.05702734f, 
    0.11036936f, -0.04218916f, 0.01873919f, 0.01830474f, 0.07626154f, 0.01451588f, 0.14930877f, -0.20567781f, 
    -0.21988012f, 0.12768938f, 0.04514461f, 0.15034489f, -0.06569260f, 0.09744675f, 0.04007613f, 0.04727642f, 
    0.29782555f, -0.33859092f, -0.33091167f, 0.06185783f, 0.10055894f, 0.22860785f, 0.07976838f, 0.08767042f, 
    0.00414594f, -0.19013658f, 0.06704988f, 0.01700260f, -0.13731998f, 0.43020982f, -0.03755317f, 0.12687662f, 
    -0.12450467f, 0.01234798f, -0.05042753f, 0.14650984f, -0.03194180f, -0.04413911f, -0.00901719f, -0.03875804f, 
    0.20166151f, 0.00772961f, 0.00331567f, -0.01088999f, -0.07062472f, -0.03253239f, 0.18361905f, 0.06634768f, 
    0.02735446f, -0.02447126f, 0.03793620f, -0.04301387f, -0.38351852f, -0.26335099f, 0.13970268f, -0.08862017f, 
    0.02777526f, 0.09012897f, -0.06808249f, 0.01502946f, -0.02376568f, -0.00136800f, 0.01829778f, 0.00785032f, 
    0.20570116f, 0.16592281f, -0.05296386f, -0.05753711f, -0.09088080f, 0.02167515f, -0.00047220f, -0.02968761f, 
    -0.12838304f, 0.07387818f, -0.08381485f, -0.15752330f, 0.26894063f, 0.03634412f, -0.14608532f, -0.14831269f, 
    -0.00379057f, 0.03592013f, -0.05884105f, -0.00046473f, -0.10124318f, 0.15348582f, 0.06368933f, -0.00686110f, 
    0.12940219f, 0.10809447f, -0.00432693f, -0.04272567f, 0.05358506f, -0.02719877f, 0.10836673f, -0.00658566f, 
    0.09269967f, 0.01724681f, 0.10109021f, 0.03123070f, -0.16416490f, 0.13258561f, -0.09799452f, 0.04357770f, 
    0.06163313f, -0.01136220f, 0.02094197f, -0.02159985f, -0.10314665f, -0.03155013f, -0.15956588f, -0.03853257f, 
    -0.17302163f, 0.15155694f, 0.04936969f, 0.18359119f, 0.07087640f, 0.02772408f, -0.08549204f, 0.20138606f, 
    -0.21256526f, -0.07428005f, 0.09655257f, -0.02088758f, 0.12357266f, -0.04490903f, -0.23876597f, 0.08973351f, 
    -0.03146368f, 0.07370600f, -0.05763529f, -0.37629646f, 0.02866535f, -0.05317202f, -0.03513795f, -0.09840754f, 
    0.04039403f, -0.09770117f, -0.12546830f, 0.40686974f, 0.05737581f, -0.08203349f, -0.06203649f, -0.00978267f, 
    -0.03494512f, -0.09604894f, -0.01332251f, 0.15318312f, -0.08304563f, -0.62559617f, -0.38516638f, -0.34952858f, 
    -0.04301684f, 0.03534698f, 0.11523737f, 0.08469377f, 0.05983483f, -0.06294338f, 0.01524630f, -0.06021628f, 
    -0.35939056f, 0.02897076f, 0.08239617f, 0.13810432f, -0.04864515f, -0.03233913f, -0.06440897f, -0.08587793f, 
    -0.03881912f, -0.12229595f, 0.00145454f, -0.03701250f, 0.32038760f, 0.04523124f, -0.28833628f, -0.23539449f, 
    -0.15685777f, -0.26130432f, 0.05012242f, -0.19915216f, 0.08605860f, 0.05265766f, 0.06245025f, 0.12517938f, 
    -0.17633799f, -0.11925234f, -0.17062700f, 0.13287385f, 0.16182674f, 0.10450713f, 0.14600469f, 0.10043751f, 
    -0.04763529f, -0.13343596f, -0.15819594f, -0.11596777f, 0.35027400f, 0.38412610f, -0.13156702f, -0.21980394f, 
    0.02866855f, -0.21065526f, -0.05150611f, -0.42208481f, -0.00852534f, 0.04327487f, -0.14223459f, 0.07081003f, 
    -0.24989834f, -0.09230167f, -0.03293227f, 0.06167307f, 0.03244187f, -0.02096154f, 0.01155573f, -0.06889140f, 
    0.05201637f, 0.11042552f, 0.13963361f, 0.06386059f, -0.28857762f, 0.02856063f, 0.04724722f, -0.17067179f, 
    0.06623264f, -0.06168865f, -0.10008337f, 0.04665006f, -0.07260250f, 0.00650922f, 0.04269962f, 0.14602767f, 
    0.09325577f, -0.19913395f, -0.28046250f, -0.41236734f, 0.20085569f, 0.08728106f, -0.03565817f, -0.06006055f, 
    0.10618283f, 0.03982705f, -0.05227865f, -0.04119046f, -0.42966592f, -0.06666743f, -0.05935143f, 0.13838403f, 
    0.04115485f, -0.00879242f, 0.01618448f, 0.13862106f, -0.09999420f, 0.03565406f, -0.09682078f, -0.39571434f, 
    -0.56131417f, -0.01132895f, 0.10526711f, -0.16154253f, -0.01129113f, 0.10740004f, -0.09622245f, 0.02645098f, 
    -0.14896061f, 0.07328192f, 0.12092515f, 0.21040820f, -0.29955810f, 0.19172511f, 0.17725746f, 0.11814989f, 
    0.02934889f, -0.06845902f, -0.09354645f, -0.14999209f, -0.10991558f, -0.02775330f, 0.02051298f, -0.08407748f, 
    -0.16149545f, -0.06423254f, 0.02273047f, 0.00952466f, 0.18656899f, -0.06300487f, -0.09731785f, -0.02436274f, 
    0.10725439f, 0.19918616f, 0.11227335f, 0.15318410f, -0.28495288f, -0.37834907f, -0.02801394f, 0.10394847f, 
    -0.02041066f, -0.00510955f, 0.08301394f, -0.15591337f, -0.04638015f, 0.00611897f, 0.04471248f, 0.11982444f, 
    -0.17017570f, 0.24019013f, -0.01027622f, -0.02462596f, 0.02064313f, -0.09397195f, -0.05061181f, -0.00934313f, 
    -0.01035231f, 0.11673628f, -0.16720836f, 0.21308944f, -0.30433831f, -0.27738571f, -0.04211340f, 0.03929130f, 
    -0.04447621f, 0.04081466f, 0.08329611f, 0.08710231f, 0.14820112f, -0.00781286f, 0.13605352f, -0.02891394f, 
    0.08849692f, -0.05417738f, -0.00280032f, -0.25626358f, -0.11174495f, -0.08534776f, 0.01202372f, -0.05574555f, 
    0.00620707f, 0.09334073f, 0.00621539f, -0.28616512f, 0.34835476f, 0.06016189f, -0.20635308f, -0.04731078f, 
    0.02218427f, -0.01023422f, 0.04120444f, -0.06127903f, 0.29809532f, -0.02128623f, 0.05435396f, 0.16198951f, 
    0.01169075f, -0.11944740f, -0.06881309f, -0.00149582f, 0.10430781f, 0.04786762f, 0.14421585f, 0.04481449f, 
    0.09347320f, -0.05706867f, 0.09250788f, 0.10016574f, 0.01908015f, -0.00056664f, -0.05013826f, 0.12541221f, 
    -0.22337809f, -0.15968299f, -0.07006028f, -0.19894764f, 0.09186861f, -0.00953584f, -0.05171202f, 0.01308203f, 
    0.41676387f, 0.20597336f, 0.02151703f, -0.16847874f, -0.09833904f, 0.07454338f, 0.11407562f, 0.14615311f, 
    0.21632443f, 0.06344388f, -0.00922765f, -0.08398652f, -0.03516434f, -0.08337040f, -0.08910842f, -0.08475345f, 
    -0.06221798f, 0.02240955f, 0.15734069f, -0.02140441f, 0.03704566f, 0.01186868f, 0.01564891f, 0.01197502f, 
    -0.18922706f, 0.10503916f, 0.10966434f, -0.03431829f, -0.06814991f, -0.13278897f, -0.04255274f, -0.12469846f, 
    0.05487734f, 0.12036418f, -0.05553341f, 0.06664609f, 0.13454242f, -0.02747550f, -0.31804094f, -0.19579376f, 
    -0.12437672f, -0.08117227f, -0.00008286f, 0.08033951f, 0.05365165f, 0.02341460f, -0.00432235f, 0.05294207f, 
    -0.00436997f, -0.08644687f, -0.24367252f, -0.19417192f, 0.00775597f, 0.03993014f, 0.06704243f, -0.02046441f, 
    0.13581902f, -0.17849469f, -0.07427637f, -0.03637596f, -0.37654421f, 0.04468394f, 0.18598917f, 0.03644522f, 
    0.08341097f, 0.08197183f, -0.18291600f, 0.06898735f, 0.08963742f, -0.11253139f, 0.12548627f, 0.11112025f, 
    0.23519617f, 0.02176025f, -0.12935552f, 0.04115131f, 0.02824052f, -0.05246825f, 0.05057546f, 0.06804326f, 
    -0.06258418f, -0.17463754f, -0.07468686f, -0.29182911f, -0.13982281f, 0.09411647f, 0.22541168f, -0.14639711f, 
    -0.02200319f, -0.06943122f, 0.03940148f, -0.02853375f, -0.06786671f, -0.02120968f, -0.03602085f, -0.02018601f, 
    0.21374197f, 0.00498534f, -0.06058892f, -0.01303311f, -0.07976612f, -0.03240539f, -0.08066071f, -0.33583188f, 
    0.13451961f, -0.02915990f, -0.07218343f, -0.21523266f, -0.57223427f, -0.04738643f, 0.06159849f, 0.27301762f, 
    -0.17757687f, -0.13223445f, -0.10911907f, -0.07608445f, -0.00617067f, 0.10674665f, 0.03380932f, 0.12553196f, 
    -0.13264585f, -0.24885851f, -0.18660994f, 0.33988145f, 0.01580992f, 0.13644554f, 0.17776895f, 0.07299468f, 
    -0.04920026f, 0.01044816f, -0.16441727f, -0.16863303f, -0.24769041f, -0.01517124f, 0.00112989f, 0.06486522f, 
    -0.02624075f, -0.01466991f, 0.01976812f, 0.01106985f, -0.23287359f, 0.02307648f, -0.16921343f, -0.52520853f, 
    0.07422214f, 0.06532475f, -0.00673241f, 0.06155023f, 0.19977060f, 0.20619884f, 0.08771982f, 0.15201904f, 
    -0.22487549f, -0.06928806f, 0.08506190f, -0.10903654f, -0.34561339f, -0.33524123f, 0.04081718f, 0.19692162f, 
    0.00149745f, 0.03733524f, 0.05132164f, -0.03047011f, 0.05289959f, 0.08243559f, -0.03658636f, 0.00067740f, 
    -0.56958944f, 0.18635902f, 0.14850309f, 0.12228592f, 0.08008654f, 0.04129723f, 0.03421148f, 0.02833408f, 
    0.02870947f, 0.08482094f, 0.09965130f, 0.12140983f, -0.25523600f, -0.01010153f, 0.09089196f, -0.10260826f, 
    0.02577033f, -0.02451147f, -0.07868095f, 0.01148434f, -0.09698708f, 0.01698257f, -0.01856940f, 0.03569491f, 
    -0.28852692f, -0.15831937f, -0.70545197f, -0.39916590f, -0.06914735f, 0.13397925f, 0.12194667f, -0.14889400f, 
    0.01863870f, -0.11679946f, -0.05363042f, 0.11936080f, 0.32471251f, 0.09190997f, -0.14420807f, -0.36222535f, 
    0.00893364f, -0.02390628f, 0.01371478f, -0.09445900f, -0.13473502f, 0.08566236f, 0.00458587f, 0.00109522f, 
    0.32691088f, 0.07742507f, -0.01050733f, 0.01995873f, 0.11687613f, -0.03763944f, 0.02649879f, 0.06449201f, 
    0.07097830f, 0.02534352f, 0.03125343f, 0.02843816f, -0.08132638f, 0.07615142f, 0.09009437f, -0.07099742f, 
    -0.10559306f, -0.00630548f, 0.00352879f, 0.08850087f, 0.11628675f, 0.09423390f, -0.08555736f, -0.01990805f, 
    0.07665407f, -0.40649986f, -0.28200290f, -0.12317811f, 0.10679296f, 0.04903426f, -0.06038136f, 0.13120607f, 
    -0.00293139f, 0.03343669f, 0.01983910f, 0.00037272f, -0.11958036f, 0.07712315f, -0.00361652f, -0.03788754f, 
    -0.04913259f, -0.01938556f, -0.04954722f, -0.03289619f, -0.12844288f, 0.01762454f, -0.01381940f, 0.03227386f, 
    -0.13661098f, -0.03802019f, -0.03440602f, -0.05767626f, -0.07081205f, -0.01701841f, -0.03106710f, -0.00409465f, 
    0.11413850f, 0.10916688f, 0.16491722f, 0.13922240f, -0.11233612f, 0.18083383f, -0.01008059f, 0.04343669f, 
    -0.04462019f, -0.06659807f, -0.05320446f, -0.02227406f, -0.01997674f, 0.02450346f, 0.01644014f, 0.11286270f, 
    0.10476214f, -0.31340280f, -0.01899434f, 0.21950403f, 0.16184096f, -0.00016881f, 0.13938214f, 0.12084468f, 
    0.08234689f, -0.17223790f, 0.09034327f, 0.10818878f, -0.42819649f, -0.09479851f, 0.11839560f, -0.00566875f, 
    -0.00211433f, 0.02155314f, -0.16898458f, 0.09103880f, 0.12046323f, -0.04251494f, -0.04030408f, 0.03878711f, 
    0.27792099f, 0.01686238f, 0.04678416f, 0.18124913f, -0.06450634f, 0.04971025f, 0.14116405f, 0.06947139f, 
    -0.05964163f, 0.08969161f, 0.20398659f, -0.00902129f, -0.13101532f, -0.08318304f, 0.06275449f, -0.00962320f, 
    -0.08818409f, 0.11943923f, 0.06142724f, 0.00164270f, 0.07520778f, 0.00988562f, 0.23607095f, 0.12219092f, 
    -0.35858250f, -0.05711028f, 0.11720607f, 0.12225152f, -0.05386463f, 0.12002808f, -0.07746257f, 0.10377476f, 
    0.05160131f, 0.12214569f, 0.02424174f, 0.00999196f, 0.06784827f, -0.11122409f, -0.08976748f, 0.11424369f, 
    0.01272795f, 0.05525783f, -0.02869694f, -0.01922299f, -0.02898669f, -0.03083047f, -0.08379402f, -0.08349132f, 
    -0.07396949f, 0.03473464f, 0.06433416f, -0.03513751f, -0.02853649f, -0.02396395f, 0.00282911f, -0.03255037f, 
    -0.00114279f, -0.05272731f, 0.01961674f, 0.05244254f, -0.08869907f, -0.50300366f, -0.55802327f, -0.03304629f, 
    0.07832600f, 0.00274124f, 0.01779291f, -0.06915520f, -0.09072499f, -0.01154710f, 0.05873200f, 0.03189583f, 
    -0.29575059f, -0.39816543f, -0.63025093f, -0.12219125f, 0.23127946f, 0.15112431f, 0.24519850f, 0.14242829f, 
    -0.06462743f, 0.10875160f, -0.09987457f, 0.05587204f, -0.06687412f, -0.25829878f, -0.11416082f, -0.05275488f, 
    -0.07508080f, 0.13066751f, 0.08940250f, 0.04095374f, 0.05630245f, -0.11882995f, 0.07926778f, 0.07324471f, 
    0.09517712f, 0.01800830f, -0.09721817f, -0.06995716f, 0.10622326f, -0.08901096f, 0.00107275f, -0.07658814f, 
    -0.13110703f, -0.06028600f, -0.18336770f, -0.13597214f, -0.73377222f, -0.12582047f, 0.10132258f, 0.28169394f, 
    0.09028210f, -0.00705391f, -0.01762252f, 0.02434876f, 0.11844622f, -0.01945556f, 0.10430463f, 0.08466115f, 
    -0.05520790f, -0.02353949f, -0.04025327f, -0.08972050f, 0.09226365f, 0.05890944f, 0.00949168f, 0.03245134f, 
    -0.02930948f, -0.03320760f, 0.05343675f, 0.22075212f, -0.16484879f, -0.00848454f, 0.23852517f, 0.19391473f, 
    0.04165461f, 0.01158279f, -0.04182397f, -0.05405769f, 0.05803814f, 0.01983531f, 0.05299329f, 0.03702974f, 
    0.28745121f, 0.09576995f, -0.21778162f, -0.33022481f, 0.03073841f, -0.00980466f, -0.04413322f, -0.02676906f, 
    0.12737623f, -0.03305817f, 0.04469885f, 0.00769754f, -0.04235436f, -0.24000241f, -0.28956407f, -0.19108777f, 
    -0.00924078f, 0.07649280f, 0.07772562f, 0.01699334f, 0.17181334f, 0.02705196f, 0.17902371f, 0.07580661f, 
    -0.21537247f, -0.04367545f, -0.08352137f, -0.01217812f, 0.12716989f, -0.03868482f, 0.09564564f, -0.07954891f, 
    0.06282815f, -0.01310332f, -0.06416930f, -0.02612272f, 0.00795315f, 0.04841408f, -0.25784731f, 0.09982127f, 
    0.12085648f, -0.00434047f, 0.00065056f, -0.10900804f, 0.05285210f, 0.03129445f, -0.03565986f, 0.02702701f, 
    -0.30715218f, 0.47542599f, -0.27568415f, -0.08216430f, 0.04246659f, -0.14280337f, 0.06130505f, 0.01303948f, 
    0.27459827f, -0.01901941f, 0.05531177f, 0.01858480f, -0.17502505f, -0.04570893f, 0.24027343f, -0.44386169f, 
    -0.06476896f, -0.18847466f, 0.05874431f, 0.24985109f, 0.05502934f, 0.10445084f, 0.02923881f, 0.04231149f, 
    0.11019839f, -0.08706180f, -0.37724668f, -0.37910104f, -0.16076866f, -0.03665093f, 0.04607120f, -0.05941679f, 
    0.10396174f, -0.19675426f, -0.08491765f, 0.11972214f, -0.08586763f, 0.12382179f, 0.03261693f, 0.12307191f, 
    -0.16572742f, -0.03891042f, 0.08390398f, 0.06591275f, -0.00821803f, 0.07867926f, 0.00929715f, 0.04911516f, 
    -0.18490511f, -0.07693616f, -0.19756469f, 0.03776476f, 0.17639373f, 0.03566864f, 0.09017756f, 0.01467528f, 
    0.04523315f, 0.01677062f, -0.10697831f, -0.05609309f, -0.49664006f, -0.56352884f, 0.03754163f, -0.13250329f, 
    0.14325772f, 0.01981817f, -0.13069592f, 0.20582788f, -0.03625866f, 0.01450531f, 0.09628188f, -0.10511870f, 
    0.12367767f, 0.01938721f, 0.26398560f, -0.36299112f, -0.23164080f, 0.05996783f, -0.05864965f, -0.03758488f, 
    0.06724202f, 0.03504798f, -0.00556579f, 0.03757065f, -0.27444771f, -0.36982125f, 0.14371952f, -0.13285318f, 
    -0.00535312f, 0.10318738f, -0.29638189f, 0.19407009f, 0.02345803f, -0.00095505f, 0.03591936f, 0.06504615f, 
    -0.07605489f, 0.20549704f, 0.12019925f, -0.09414433f, -0.00985957f, -0.00610993f, 0.05250904f, -0.03950693f, 
    0.08198093f, 0.07825434f, 0.00509492f, -0.10262610f, 0.06491377f, -0.07479016f, -0.17551434f, -0.12089380f, 
    0.11695772f, -0.05585908f, 0.00958552f, -0.00642283f, -0.01745554f, -0.07887181f, 0.02915714f, -0.07559112f, 
    0.02972878f, -0.01910435f, 0.12535860f, 0.04491648f, 0.01648356f, -0.02097476f, 0.01289986f, 0.06015693f, 
    0.02497780f, 0.13787685f, 0.09361614f, -0.00720170f, -0.31065071f, -0.04219092f, -0.31534335f, -0.07542488f, 
    -0.05872911f, -0.13022283f, 0.06319145f, -0.05858741f, -0.05064871f, 0.06745533f, 0.18713260f, 0.10719607f, 
    -0.25938562f, 0.08519077f, 0.06723053f, -0.46606851f, -0.02072183f, -0.11574406f, -0.02635656f, -0.10788826f, 
    0.15132917f, 0.05945822f, -0.10797321f, 0.03371418f, -0.02329767f, -0.20473221f, -0.21090341f, 0.18640786f, 
    -0.01730625f, 0.19858330f, 0.12434226f, 0.15491340f, 0.01845969f, 0.03136634f, -0.00784142f, -0.00479805f, 
    0.03910138f, -0.05513792f, 0.02663786f, -0.02688955f, 0.11061835f, -0.07169814f, 0.05263632f, 0.08331558f, 
    0.03177683f, -0.13051011f, -0.14101654f, -0.08528900f, -0.18417627f, 0.03153960f, -0.04237096f, -0.34142032f, 
    -0.14190106f, 0.01554296f, 0.04578755f, 0.19551213f, -0.00096567f, -0.09027485f, 0.01501095f, -0.10015745f, 
    -0.11003599f, 0.19731832f, -0.25614342f, 0.10657728f, 0.02627676f, 0.03023002f, 0.05483219f, 0.02851123f, 
    0.09134473f, 0.03939103f, -0.00211004f, -0.11425168f, 0.31299973f, 0.05176060f, 0.32718065f, -0.02761348f, 
    0.13152795f, -0.11424531f, -0.01140240f, -0.14157636f, -0.12012413f, -0.07282538f, 0.07808047f, 0.09793507f, 
    0.10662714f, 0.00664138f, 0.11309133f, 0.24555296f, 0.10834936f, 0.01036316f, 0.11742215f, -0.00885291f, 
    0.05227152f, 0.07900872f, 0.09928369f, 0.12702532f, -0.36047515f, -0.05981982f, -0.13593066f, 0.24332148f, 
    0.09057734f, 0.01302448f, -0.09173979f, -0.07209123f, -0.08358050f, 0.01635996f, -0.08554561f, -0.15890059f, 
    0.26569280f, -0.03641675f, 0.28894347f, 0.00205424f, -0.01171032f, -0.17543414f, -0.16060823f, -0.16379368f, 
    -0.03442458f, -0.02649679f, -0.09299909f, 0.02147170f, 0.42794302f, -0.62163323f, 0.18040520f, -0.25366911f, 
    0.14048445f, 0.02578698f, -0.03786248f, 0.18002594f, 0.10976850f, -0.10889478f, 0.00801985f, -0.08226220f, 
    -0.52551723f, -0.20308366f, -0.12212159f, -0.00668241f, -0.01306757f, -0.00469314f, 0.01336184f, -0.09837995f, 
    0.14294715f, 0.03433802f, -0.06317633f, -0.05496611f, -0.20595627f, 0.33435735f, 0.06854246f, 0.39397824f, 
    -0.20878658f, 0.07097023f, -0.30424097f, 0.03996980f, 0.11579616f, -0.11207487f, -0.00878870f, -0.02330590f, 
    -0.17448361f, -0.11869624f, -0.03007415f, 0.06592999f, 0.11945810f, 0.04352365f, 0.12938739f, -0.01744012f, 
    0.01131863f, -0.02568944f, -0.06161538f, -0.04273181f, -0.05042977f, 0.06223697f, 0.24738981f, 0.58818096f, 
    0.08698536f, 0.00237019f, -0.19217414f, 0.01066328f, 0.06371255f, 0.02743949f, 0.11772408f, 0.02413289f, 
    0.14802426f, 0.00760730f, 0.35256645f, 0.31244546f, 0.03478467f, -0.17345418f, -0.19590318f, -0.15312184f, 
    0.06121479f, 0.00921274f, 0.11788982f, 0.09061737f, -0.08238450f, 0.03805919f, 0.07610191f, -0.19032957f, 
    0.10390238f, -0.20139693f, -0.07741503f, 0.02841645f, 0.09086590f, 0.05828384f, 0.05714446f, 0.12592684f, 
    0.12174238f, -0.14558956f, 0.17297330f, 0.03968969f, -0.04585277f, -0.03536842f, -0.02552058f, -0.10578162f, 
    0.14171958f, 0.04372731f, 0.03005865f, 0.19705640f, -0.08636535f, -0.25805140f, -0.17222418f, -0.02260107f, 
    0.12313721f, 0.08036680f, 0.14081390f, 0.09388112f, 0.05043526f, -0.01389096f, 0.05627888f, 0.03765071f, 
    0.26533592f, -0.26130706f, 0.02844669f, -0.16966020f, 0.07902645f, 0.11669926f, -0.11678513f, 0.12049560f, 
    -0.01265228f, 0.01836703f, -0.20692390f, -0.00798676f, -0.28284499f, -0.12465805f, -0.20872580f, 0.12463143f, 
    -0.03150240f, -0.12392684f, 0.20426024f, -0.04614882f, 0.02371806f, 0.09903786f, -0.08881056f, -0.11471866f, 
    0.20063700f, 0.01411445f, 0.03203672f, -0.13104950f, -0.01239801f, 0.03378145f, -0.15044446f, 0.01834469f, 
    0.04910254f, 0.00259487f, 0.03829427f, 0.03836934f, 0.08314830f, 0.22292285f, 0.08695401f, -0.22722699f, 
    -0.06007991f, 0.03829144f, 0.08354113f, 0.04805459f, 0.03431149f, 0.15689261f, 0.15576240f, 0.15136954f, 
    -0.12410852f, 0.24373634f, -0.52652389f, 0.05135029f, 0.21097851f, -0.13631766f, 0.13408050f, 0.07410976f, 
    -0.02527265f, 0.07705355f, -0.07220520f, 0.07409930f, 0.32652569f, -0.11587826f, 0.16007563f, -0.27553472f, 
    -0.05428240f, -0.16709061f, -0.15751313f, 0.07942709f, -0.09309248f, 0.10056559f, -0.02031265f, -0.03197965f, 
    -0.08676520f, 0.04727387f, -0.04073813f, -0.00477492f, -0.06897217f, 0.02935193f, -0.04196519f, -0.02600568f, 
    0.00538927f, 0.03832164f, -0.08316934f, -0.10040677f, -0.06293698f, 0.20785142f, 0.10324685f, -0.18483418f, 
    0.14123598f, -0.12697743f, -0.08369606f, -0.07762710f, 0.06166945f, 0.01401914f, -0.11710262f, -0.01007776f, 
    -0.50639659f, 0.07589996f, -0.34438798f, 0.11870491f, 0.05094482f, -0.03702964f, -0.12799147f, 0.20378152f, 
    0.07955072f, -0.02140139f, 0.05875804f, -0.09515722f, -0.04458176f, -0.42942241f, 0.07064333f, -0.01236815f, 
    -0.06298681f, 0.10668097f, -0.05746028f, -0.14778951f, -0.06908651f, -0.01893412f, -0.07868420f, -0.09906422f, 
    -0.46861354f, 0.01293214f, -0.36715254f, 0.19621049f, 0.09028406f, -0.07276250f, 0.06905892f, 0.00586940f, 
    0.02667633f, -0.01449839f, -0.01407524f, 0.00742549f, 0.23065424f, -0.49051258f, -0.08418558f, -0.10307726f, 
    0.01989301f, 0.09195550f, -0.05428473f, 0.17909655f, -0.05395038f, 0.07842131f, -0.19070560f, -0.18418223f, 
    0.22944008f, 0.28706250f, -0.08217330f, -0.09045789f, -0.04305355f, -0.02073204f, 0.10085958f, 0.20080747f, 
    0.03818054f, 0.05462509f, 0.00231510f, -0.05648240f, -0.16071954f, -0.11043432f, -0.10483430f, -0.07723179f, 
    -0.10167926f, 0.26738209f, 0.10785337f, -0.01989398f, 0.17768021f, 0.13275029f, -0.18414202f, -0.08224721f, 
    -0.05829985f, -0.03166701f, 0.00135241f, 0.21041632f, 0.02106947f, 0.06481488f, -0.00470740f, -0.02032005f, 
    0.10990602f, 0.15797055f, -0.01510622f, -0.06420674f, -0.14702179f, 0.03539314f, -0.04759301f, 0.02592997f, 
    0.06762429f, 0.02419678f, 0.10728615f, -0.06115768f, 0.04168991f, 0.04061778f, -0.03269979f, -0.07760041f, 
    -0.05736108f, 0.16935453f, 0.61539936f, -0.45206636f, 0.07874639f, -0.28873089f, 0.04246534f, -0.15475674f, 
    -0.30552864f, -0.02293858f, 0.00475713f, 0.06426698f, 0.32451290f, -0.31420743f, -0.06136752f, -0.09932546f, 
    -0.00279046f, 0.04540225f, -0.00393234f, 0.07269554f, -0.05058903f, -0.14553548f, -0.11726192f, -0.10178559f, 
    -0.40619442f, -0.14470372f, -0.02377190f, -0.63283157f, 0.00456731f, -0.13889255f, 0.05378443f, 0.03101303f, 
    -0.08475059f, 0.04673379f, 0.01743454f, 0.06380280f, -0.14143534f, 0.12730365f, 0.05260472f, -0.16298378f, 
    0.16311674f, -0.08311769f, -0.02811528f, -0.04226721f, -0.11767766f, 0.09849012f, -0.05610044f, 0.03613510f, 
    -0.33529964f, 0.16587391f, -0.10626823f, -0.33234397f, -0.04538423f, -0.05075178f, 0.10398512f, -0.13041617f, 
    0.06653107f, 0.08119059f, -0.09224036f, -0.05290413f, 0.02563382f, -0.21722439f, 0.02993981f, -0.18905893f, 
    -0.30366495f, -0.02547534f, -0.25841761f, 0.04911585f, 0.16726093f, -0.06691036f, 0.07582096f, 0.09675860f, 
    0.08278868f, -0.16252688f, 0.20290908f, -0.16232559f, 0.09641380f, 0.11462359f, -0.02754291f, -0.01780644f, 
    0.14498888f, 0.02242656f, 0.04466007f, -0.00406469f, -0.19447695f, -0.08689723f, 0.05670896f, -0.13987909f, 
    -0.18108426f, -0.23730263f, -0.05658486f, 0.13125086f, 0.03139355f, -0.05900008f, 0.00638294f, -0.02368476f, 
    0.04907703f, -0.19694445f, 0.16538571f, 0.28295505f, 0.00358670f, -0.17250958f, -0.11381773f, -0.14223450f, 
    0.07682502f, -0.00380972f, 0.04380399f, 0.05852363f, 0.03506342f, 0.01562119f, -0.22131053f, 0.03278596f, 
    -0.10211428f, -0.03484604f, -0.26211539f, 0.00051711f, -0.09732487f, -0.13230734f, 0.02338675f, 0.03935783f, 
    -0.13605186f, -0.14198445f, 0.24608397f, -0.15507220f, 0.09753826f, -0.10121326f, 0.14025284f, 0.02476366f, 
    0.10860042f, 0.02190233f, 0.00423140f, 0.04653405f, -0.20770408f, 0.07557047f, 0.04335327f, -0.07844732f, 
    0.00871344f, 0.00209750f, 0.16905424f, 0.09236649f, 0.05179470f, 0.04833992f, 0.03877255f, -0.07763735f, 
    0.16108516f, -0.00309280f, 0.12652728f, 0.09934441f, 0.21421237f, 0.00957048f, -0.13590750f, 0.10020868f, 
    -0.03440210f, -0.09662506f, -0.02154490f, 0.00750964f, -0.04183184f, -0.26523200f, -0.24669087f, -0.07675998f, 
    0.02456180f, -0.03084989f, 0.02425273f, 0.13648178f, -0.13780537f, 0.02784138f, -0.04031369f, -0.04794501f, 
    -0.44144723f, -0.26843679f, -0.19218977f, 0.24005656f, 0.01707610f, 0.09793711f, -0.15187384f, -0.14074349f, 
    -0.19041121f, -0.10585928f, 0.05671681f, -0.10406473f, 0.09449426f, 0.22945544f, 0.26725706f, 0.49202850f, 
    0.02368503f, -0.00613096f, -0.19535968f, -0.04109478f, 0.02564687f, -0.11609813f, 0.02202699f, 0.01545947f, 
    -0.06291708f, 0.06553942f, -0.20793089f, 0.00322229f, -0.01564175f, 0.07353901f, 0.04454498f, -0.23835231f, 
    -0.01364352f, -0.01144717f, 0.07926812f, -0.00842179f, -0.01957022f, -0.03354601f, -0.20626763f, 0.26270869f, 
    -0.06207158f, 0.03770934f, 0.13556311f, -0.02434201f, -0.11231225f, 0.00293201f, -0.07336771f, 0.05286707f, 
    0.01041930f, 0.08532716f, 0.16605406f, -0.06470495f, -0.09245096f, -0.01900407f, 0.20433094f, -0.05675980f, 
    0.01205774f, 0.07177554f, -0.03441344f, -0.00673314f, -0.13273057f, -0.20300499f, 0.29538545f, 0.12165945f, 
    0.07370584f, -0.00205322f, -0.23421276f, -0.10541221f, -0.15239696f, 0.10586738f, -0.00613774f, -0.19867451f, 
    -0.06968039f, 0.11995818f, 0.39845815f, 0.11678196f, -0.02440544f, -0.10855554f, 0.03448934f, 0.01879738f, 
    -0.01185045f, 0.00531935f, 0.13574560f, 0.13903852f, -0.28087795f, 0.07084377f, -0.27209502f, -0.07499437f, 
    -0.03605345f, 0.01684952f, 0.02246404f, 0.00178412f, 0.00015721f, 0.09973549f, -0.07755432f, 0.04125116f, 
    -0.03239527f, -0.15160254f, 0.25876358f, -0.08379257f, -0.00911076f, 0.11201722f, -0.10745563f, 0.01138155f, 
    0.03201745f, 0.00082682f, 0.01780522f, -0.00865416f, -0.34073201f, -0.01228895f, -0.37865812f, 0.19237721f, 
    -0.06800254f, 0.11870512f, -0.31816819f, -0.17343168f, 0.10228944f, 0.07815004f, 0.13294902f, 0.03091896f, 
    -0.12983155f, 0.07566931f, -0.22709717f, 0.17822684f, 0.14455226f, -0.09092709f, 0.03121450f, 0.11968558f, 
    -0.15534298f, -0.12653111f, -0.05407001f, -0.11556605f, -0.06958017f, -0.39238417f, -0.07332368f, -0.20192051f, 
    -0.07333157f, 0.26285502f, -0.09353451f, 0.04538742f, -0.02616988f, -0.13278884f, -0.10023263f, -0.10264709f, 
    -0.11363966f, -0.08755494f, 0.00047066f, 0.06633011f, 0.00695233f, 0.00309821f, 0.12585279f, -0.03016747f, 
    -0.06537715f, 0.00408486f, 0.14323527f, 0.10334017f, 0.02073619f, 0.09688630f, 0.06529006f, 0.01553324f, 
    -0.06419278f, -0.03788440f, 0.15996161f, 0.01542061f, -0.08746564f, 0.15134354f, -0.08219465f, 0.01743701f, 
    -0.11609802f, -0.10100755f, -0.30459100f, -0.12600723f, 0.03625618f, 0.11719020f, 0.12161247f, 0.00512427f, 
    0.02433843f, 0.06496730f, -0.12380849f, -0.13851321f, 0.36564314f, -0.01806163f, -0.11885544f, 0.13295904f, 
    -0.07256541f, -0.02530602f, 0.01371799f, -0.05948116f, -0.07606912f, -0.07542861f, -0.36102745f, -0.06897876f, 
    0.02737665f, -0.01107033f, 0.29233283f, 0.00555501f, 0.07308628f, 0.00532191f, 0.26696765f, 0.02448567f, 
    0.02222727f, -0.03354965f, -0.11410900f, 0.01034641f, -0.21218649f, -0.07139264f, -0.24160518f, 0.08901671f, 
    -0.11082226f, -0.00142441f, -0.01978160f, 0.09531374f, 0.02606565f, 0.00584585f, 0.06960522f, -0.06118937f, 
    -0.13976042f, -0.05385213f, -0.10499103f, 0.09060923f, 0.03599363f, 0.08272673f, 0.01604650f, 0.07337344f, 
    -0.01014802f, 0.14438580f, 0.11245081f, 0.18293916f, 0.14413974f, -0.02943914f, 0.09626887f, 0.21739288f, 
    -0.17191820f, -0.06161262f, -0.13943070f, 0.09978066f, 0.13290343f, 0.03125256f, 0.07403344f, 0.11120322f, 
    -0.17257312f, 0.06810478f, 0.13834578f, -0.01421257f, -0.02656590f, -0.20672671f, 0.04847141f, 0.09665614f, 
    -0.12983558f, -0.21027000f, 0.05011542f, 0.06755900f, -0.11779760f, 0.34025761f, 0.00346427f, -0.03421032f, 
    -0.04871883f, -0.08713578f, -0.15372115f, 0.13427609f, -0.04110347f, -0.02368841f, 0.05930734f, -0.06296258f, 
    -0.28164145f, 0.24411209f, 0.07701623f, -0.22912659f, -0.04444464f, 0.01756683f, -0.06424972f, 0.01371689f, 
    -0.03024252f, -0.15014504f, -0.01908037f, -0.10636853f, -0.23315115f, 0.17171440f, 0.25718182f, -0.04252694f, 
    -0.02740597f, 0.06577995f, -0.14643997f, -0.08034377f, 0.03287265f, -0.05862601f, 0.07338998f, 0.10110930f, 
    -0.19175269f, 0.31521335f, -0.04360978f, -0.08212280f, -0.02731302f, 0.12926605f, 0.12987259f, 0.08545648f, 
    -0.09618337f, 0.09437670f, -0.08179788f, -0.05177186f, -0.13361819f, -0.28677219f, -0.06809769f, 0.19269356f, 
    0.03970531f, 0.16051713f, -0.03403679f, 0.12424161f, 0.14581394f, -0.09959620f, 0.07717749f, -0.05085870f, 
    0.12696470f, -0.10208421f, 0.23084247f, 0.09045279f, -0.01862269f, 0.04590576f, 0.04533233f, 0.17090707f, 
    -0.11799221f, -0.22582522f, -0.01386119f, -0.19174023f, -0.06564800f, 0.11706723f, 0.25143969f, -0.34895000f, 
    -0.12585667f, -0.06478723f, -0.08788420f, 0.07798738f, -0.08276596f, 0.03821701f, 0.02790346f, -0.11085366f, 
    -0.05754249f, -0.07188591f, -0.13849252f, -0.00778712f, -0.18584408f, 0.14661178f, -0.05016602f, -0.07629935f, 
    -0.07937573f, 0.11377383f, 0.01838895f, 0.13691479f, -0.09865829f, 0.18345906f, -0.06515499f, -0.12470454f, 
    0.02191363f, 0.02762514f, 0.01616124f, 0.00872869f, -0.09635895f, 0.05453197f, -0.03687251f, -0.03728824f, 
    -0.79176849f, 0.25743684f, -0.01080897f, -0.43100098f, 0.03670862f, 0.14970368f, -0.19604692f, 0.09660481f, 
    -0.08880469f, -0.00281948f, -0.04796044f, -0.18354231f, -0.22045751f, -0.12294813f, 0.09122985f, -0.29227471f, 
    -0.05438958f, 0.03879257f, 0.13947934f, -0.01604050f, 0.00045267f, 0.06304467f, -0.26939988f, -0.05463429f, 
    -0.12788995f, 0.00782043f, 0.06413970f, 0.08849356f, 0.05113580f, 0.04874484f, 0.15894568f, -0.04617773f, 
    -0.03836520f, -0.15662336f, -0.06967235f, -0.23607235f, -0.22272624f, -0.31943882f, -0.65240937f, -0.35274160f, 
    -0.23911200f, -0.02409817f, -0.03076713f, -0.07219701f, -0.04364805f, -0.03107446f, -0.14756103f, -0.17190750f, 
    -0.57893586f, 0.14123242f, -0.10455064f, -0.06059206f, 0.05457469f, 0.17730102f, -0.15010695f, 0.11031151f, 
    -0.11041116f, 0.04230910f, 0.01362516f, -0.10277844f, 0.30599454f, 0.04841712f, -0.07731416f, 0.06425874f, 
    -0.17629068f, -0.06967802f, 0.17066324f, -0.12321316f, 0.05318012f, 0.01237685f, 0.06191500f, 0.19241349f, 
    0.03442668f, -0.04027062f, -0.01844346f, -0.00775321f, 0.09319434f, -0.12508221f, -0.01968987f, 0.00585430f, 
    -0.13955988f, -0.03459194f, -0.19100221f, -0.41709188f, -0.08333185f, 0.00286662f, -0.13153991f, 0.25515589f, 
    -0.05793293f, -0.11843016f, 0.00917008f, 0.05790471f, -0.21299517f, -0.31202024f, -0.38510245f, -0.48578933f, 
    -0.01766276f, 0.22964478f, 0.04066577f, -0.10372016f, -0.19502805f, -0.08914059f, -0.06681842f, 0.09887099f, 
    -0.23838204f, -0.05087817f, -0.20900537f, 0.01130742f, -0.00610757f, 0.33560532f, -0.12338776f, 0.25533286f, 
    0.05960667f, 0.10733987f, 0.05789544f, -0.13310762f, -0.09842170f, -0.02276583f, -0.07861802f, -0.08403461f, 
    0.13023177f, 0.03637982f, 0.04295578f, 0.06834723f, -0.09676857f, -0.06616423f, 0.14792272f, -0.04888296f, 
    0.12922356f, -0.10765895f, 0.13525328f, -0.04609152f, -0.17431770f, -0.21837619f, 0.06313424f, 0.08165382f, 
    -0.06108280f, -0.06740882f, 0.18598519f, -0.08541664f, 0.06024252f, 0.08870451f, 0.05581725f, 0.00725580f, 
    -0.17875890f, -0.04415977f, -0.19538103f, 0.04179761f, -0.01418863f, 0.12872209f, -0.26435286f, 0.09578726f, 
    0.05117182f, 0.11723261f, 0.08716547f, -0.07556559f, -0.52068776f, 0.29589140f, -0.16210531f, 0.03927567f, 
    -0.07465103f, 0.08270676f, 0.06232075f, -0.00832846f, 0.02993263f, -0.00502455f, -0.02784645f, 0.05255117f, 
    0.15980256f, -0.32378718f, 0.10211881f, -0.01309591f, -0.12969844f, 0.15379897f, 0.01678579f, -0.00354150f, 
    -0.04943522f, 0.01504578f, -0.14167896f, -0.05119361f, -0.40820098f, 0.14724045f, 0.23010859f, 0.07439467f, 
    0.14867599f, 0.14132105f, -0.02284204f, 0.01515011f, -0.17181560f, 0.06976766f, 0.16256855f, 0.03807865f, 
    -0.26167887f, -0.01035971f, -0.06628012f, 0.11586040f, 0.04910900f, 0.00520338f, 0.03444707f, 0.04987458f, 
    -0.05164396f, 0.12087649f, -0.01526037f, -0.00587254f, -0.34411669f, 0.08783935f, -0.17038229f, -0.12581304f, 
    -0.04749766f, 0.00328332f, -0.09449533f, -0.00041107f, -0.03725088f, -0.09335470f, 0.02294426f, -0.01655526f, 
    -0.05198298f, -0.18077850f, 0.19144839f, -0.41075069f, -0.08290744f, -0.03253528f, -0.16895492f, 0.10862553f, 
    0.13342966f, -0.05294678f, 0.00896591f, 0.02496247f, -0.12433688f, 0.05413155f, -0.03321422f, -0.13393968f, 
    -0.08468515f, 0.00280504f, -0.02684745f, -0.00353531f, -0.04347558f, -0.04171882f, 0.06333381f, 0.06937835f, 
    -0.32646301f, 0.07579813f, -0.02498192f, 0.13332658f, -0.04299149f, -0.00271688f, -0.21969385f, 0.22480735f, 
    0.11146020f, -0.02507889f, 0.10752398f, 0.00938706f, -0.34755686f, 0.26820940f, 0.15324476f, 0.20284162f, 
    0.11297181f, -0.14742815f, -0.14455658f, 0.12571763f, -0.01246738f, 0.02774550f, 0.17367856f, -0.00998244f, 
    0.07896353f, 0.16972269f, 0.51582748f, -0.05683177f, 0.10979499f, 0.07201166f, -0.00383113f, 0.00299910f, 
    0.07178395f, -0.05039594f, -0.12128104f, -0.07991574f, 0.18184264f, -0.15972638f, 0.32901219f, -0.06737190f, 
    -0.33667618f, -0.06826630f, 0.18133521f, 0.05170584f, 0.17730558f, 0.06403720f, 0.28955597f, 0.14110591f, 
    0.34980145f, -0.34562582f, 0.35911623f, 0.10673063f, -0.05344765f, 0.17979582f, 0.08834946f, 0.10328535f, 
    -0.03317574f, 0.09551673f, -0.00074985f, 0.18742268f, -0.07713173f, 0.02767181f, -0.03520186f, 0.05366951f, 
    0.06585194f, -0.36396450f, 0.02623443f, 0.01697685f, -0.09390724f, 0.06572369f, 0.07906888f, 0.00721209f, 
    -0.33489454f, -0.13911723f, -0.10913461f, -0.17879692f, -0.16328245f, -0.05643780f, -0.03904805f, 0.02166173f, 
    0.00478685f, 0.01548751f, 0.02152754f, 0.05056227f, -0.19285962f, -0.20830929f, 0.10537242f, -0.01415637f, 
    -0.10710557f, -0.11983915f, -0.11214212f, 0.06939265f, -0.02955485f, 0.04504014f, 0.13223022f, 0.16601916f, 
    0.24875918f, 0.00594811f, 0.01933278f, -0.13758712f, -0.11493171f, -0.03266230f, 0.21112597f, 0.03844395f, 
    -0.08950552f, 0.06267708f, -0.05465513f, -0.22336589f, -0.03738113f, 0.30010226f, 0.06410052f, 0.13668081f, 
    0.09732646f, -0.06263854f, -0.06571176f, 0.14962403f, -0.08879007f, 0.10865713f, -0.00742325f, 0.12495228f, 
    -0.13618566f, -0.11377669f, -0.23322573f, 0.10441957f, -0.03024240f, -0.01216998f, 0.07470442f, 0.15426266f, 
    -0.11007050f, 0.01924801f, -0.10179840f, -0.11589409f, 0.09699595f, -0.24864411f, -0.02187711f, 0.15104026f, 
    -0.00139459f, 0.06304087f, -0.10904554f, 0.03141702f, 0.00765166f, 0.00970159f, -0.08035240f, -0.05240904f, 
    -0.28503802f, 0.05669026f, 0.02720397f, -0.00911948f, 0.02662888f, -0.16882768f, -0.08092231f, 0.01404902f, 
    0.07585054f, 0.19105545f, 0.10469835f, 0.17851073f, 0.03746019f, 0.04393465f, -0.35439560f, 0.20595418f, 
    -0.06018352f, 0.03059947f, 0.29129422f, -0.06567111f, 0.06751892f, 0.21227105f, -0.03989221f, 0.17366104f, 
    -0.08548702f, 0.30203477f, 0.30279553f, -0.17727655f, -0.20366299f, 0.02966196f, 0.05999326f, 0.01198425f, 
    0.09913902f, 0.10761452f, -0.05910844f, -0.06395996f, -0.13603505f, 0.33222815f, 0.01729763f, -0.31210265f, 
    0.09723343f, 0.01752312f, -0.07962704f, 0.11248194f, -0.00121626f, -0.00437425f, 0.11381223f, 0.02521012f, 
    0.11379575f, -0.09952157f, 0.20190035f, 0.07602259f, 0.09134227f, -0.03735609f, -0.08971944f, 0.02935407f, 
    -0.07271829f, -0.10697126f, -0.13143465f, -0.13828491f, 0.25104728f, -0.10181607f, 0.25032914f, 0.07500689f, 
    -0.04770990f, -0.06930254f, 0.00211590f, 0.05762422f, -0.01530713f, 0.10750932f, 0.08511987f, -0.16494922f, 
    0.16989106f, -0.42333212f, 0.48824894f, -0.19647872f, 0.09583040f, 0.06478783f, -0.01709486f, 0.05159977f, 
    -0.05683068f, 0.04384540f, 0.08340659f, 0.16157149f, -0.25038177f, -0.13023518f, -0.02609317f, 0.15134358f, 
    -0.23977089f, 0.04001437f, -0.00640163f, -0.01766227f, -0.01304609f, 0.02719500f, -0.13097171f, -0.06587935f, 
    0.13104695f, 0.09843371f, 0.19086577f, -0.14573307f, 0.04444104f, 0.00452432f, 0.16816992f, -0.20708251f, 
    0.02897396f, 0.04777364f, 0.10351279f, -0.01197632f, -0.23874532f, -0.18954907f, -0.26700011f, -0.18910083f, 
    -0.07822375f, -0.30094042f, -0.14462343f, -0.11057792f, 0.01259042f, 0.02076150f, 0.01913557f, 0.05027760f, 
    0.27586666f, 0.08270543f, 0.16238488f, -0.05414962f, -0.03795772f, -0.10011832f, 0.02360541f, 0.15935497f, 
    -0.05448892f, 0.05563523f, 0.06751895f, -0.11339495f, -0.21246900f, -0.32877642f, -0.01038877f, 0.33292243f, 
    -0.15373290f, -0.04034765f, -0.12777224f, -0.04567831f, 0.02842835f, 0.01995755f, 0.03010250f, -0.01751233f, 
    -0.05557104f, -0.05060735f, -0.04445093f, 0.32146177f, -0.07868170f, -0.04162287f, 0.13421945f, -0.11784139f, 
    0.00863350f, 0.09057042f, -0.11964658f, -0.09884413f, -0.50315458f, 0.28027880f, -0.01124576f, -0.04032007f, 
    -0.06852907f, 0.00580884f, 0.18419693f, -0.07199733f, 0.03415644f, 0.02284212f, -0.02409272f, 0.01278051f, 
    0.10623959f, 0.02570983f, 0.14458366f, 0.01844017f, 0.00892799f, 0.10135500f, -0.00925385f, 0.13758370f, 
    -0.15808208f, 0.07376188f, 0.04450161f, -0.11154960f, 0.21656369f, 0.13170873f, 0.12036075f, -0.00183088f, 
    -0.09618063f, 0.18522921f, 0.00996564f, -0.05414524f, 0.06137937f, -0.05276272f, -0.01075746f, 0.04014511f, 
    -0.01576327f, -0.15935758f, -0.04605190f, -0.29946363f, -0.02808782f, -0.15252917f, -0.11210931f, -0.14317574f, 
    -0.00883960f, 0.10611033f, 0.14603673f, 0.02932841f, -0.07893241f, -0.10844366f, 0.25088039f, -0.17304520f, 
    0.08185126f, 0.03478245f, 0.03723644f, -0.03082200f, -0.02123325f, 0.06658115f, 0.17872839f, 0.03143605f, 
    0.15330423f, -0.14654353f, -0.00751713f, 0.13274062f, -0.10977966f, 0.13660386f, -0.10631879f, 0.18843530f, 
    0.02505599f, 0.05161139f, 0.02833235f, 0.02893882f, 0.34627709f, 0.26976430f, 0.46064940f, 0.11716446f, 
    -0.17242073f, -0.13772939f, -0.10596069f, 0.10145799f, -0.02606985f, 0.00381037f, -0.01958816f, -0.02137652f, 
    0.09299362f, 0.08762598f, 0.02616250f, -0.11835731f, -0.02995908f, 0.03899737f, 0.01545546f, 0.12897849f, 
    -0.07468419f, -0.07401509f, -0.09099372f, -0.21536268f, 0.07056383f, -0.02418376f, 0.20209140f, -0.08550160f, 
    -0.06749966f, -0.01212389f, -0.20006251f, 0.03243449f, 0.01829931f, 0.00632724f, -0.09923651f, -0.15500753f, 
    0.01505413f, -0.08574203f, 0.08965186f, 0.01557066f, -0.04628437f, 0.17463407f, 0.05395790f, -0.06852046f, 
    -0.05841089f, 0.02090259f, 0.17216775f, -0.22047387f, -0.51875925f, -0.27720007f, 0.14149491f, -0.19687925f, 
    -0.02491147f, 0.01196987f, -0.04661397f, 0.11378606f, -0.14812407f, -0.05736980f, -0.06689475f, -0.08320458f, 
    -0.06413186f, 0.07012161f, -0.24081005f, 0.06726030f, 0.00548732f, 0.08887616f, 0.10188374f, 0.00555265f, 
    0.14593989f, 0.06135088f, 0.05882045f, 0.08863322f, 0.03892330f, -0.11059533f, 0.14418018f, -0.21729153f, 
    0.07610358f, 0.04993701f, -0.11558841f, 0.10812911f, -0.02940870f, 0.12714384f, 0.13543545f, -0.13291398f, 
    -0.19094996f, 0.22967955f, -0.37863633f, 0.13921849f, 0.13803647f, -0.11217015f, 0.11244158f, 0.04146036f, 
    -0.03005780f, 0.06829415f, -0.16578588f, 0.04905692f, 0.00201560f, 0.22007497f, 0.18215507f, -0.10359292f, 
    -0.32626444f, 0.15342109f, -0.03012226f, -0.01164380f, -0.08729180f, 0.03905996f, -0.01241989f, -0.04101204f, 
    -0.10995601f, -0.03255110f, -0.13498931f, 0.10931708f, 0.07213209f, 0.07877900f, -0.04167524f, 0.12568916f, 
    -0.08353502f, 0.15823342f, 0.11792524f, 0.04827704f, -0.06929728f, -0.15642981f, -0.18715829f, -0.07335787f, 
    0.11494208f, -0.03612668f, -0.02016887f, -0.08640535f, 0.03493338f, -0.13077427f, -0.00470399f, -0.02127736f, 
    0.09855420f, 0.11191856f, 0.07479761f, -0.16504996f, -0.06602194f, 0.08480914f, -0.20030423f, -0.00142035f, 
    -0.06582984f, -0.12263642f, 0.10765210f, -0.14007336f, -0.53133756f, 0.10685588f, -0.31792960f, 0.11109362f, 
    0.14282523f, 0.21384202f, 0.13457581f, -0.15894954f, -0.13362294f, 0.03291859f, 0.11673682f, 0.15631211f, 
    0.00749680f, -0.20064121f, -0.12897483f, 0.06204385f, 0.13735701f, -0.09112592f, 0.04671597f, -0.10041193f, 
    0.04051510f, 0.13893373f, -0.04005099f, 0.21197562f, 0.30072710f, -0.27898428f, 0.06319794f, 0.04970857f, 
    -0.06157167f, 0.09782379f, 0.03218956f, 0.16839822f, -0.10152806f, 0.01951671f, -0.05641184f, 0.17548645f, 
    -0.14972551f, 0.03822358f, -0.12284597f, -0.03116081f, 0.02953638f, 0.05040541f, 0.06815962f, 0.01458921f, 
    -0.05861170f, 0.15129344f, 0.17480117f, 0.14564139f, 0.59021658f, 0.16356084f, 0.13923074f, -0.33022371f, 
    -0.06412517f, 0.00609152f, -0.09955890f, 0.08147256f, -0.01309242f, 0.02086397f, -0.04614944f, -0.02468403f, 
    0.19572160f, 0.04877004f, -0.05273983f, 0.14273725f, -0.01639749f, 0.00434965f, -0.07963166f, 0.04924090f, 
    0.21018380f, 0.05482309f, -0.00801202f, -0.01550396f, 0.15722297f, -0.42825815f, 0.19146194f, -0.43340391f, 
    -0.04092978f, 0.16938606f, -0.22110777f, 0.12424453f, -0.03415607f, 0.15637814f, -0.00186349f, -0.08183188f, 
    -0.36550829f, 0.32950768f, -0.32160240f, -0.13082963f, 0.02741038f, 0.04989448f, 0.01571803f, -0.06215707f, 
    -0.07842567f, 0.03508438f, 0.11222677f, -0.00340303f, -0.23254009f, 0.04671570f, 0.08300985f, -0.08271182f, 
    -0.03719963f, -0.01389762f, 0.00698428f, -0.00286729f, -0.07376401f, 0.04315341f, 0.12678066f, 0.10622954f, 
    0.39719382f, -0.15341051f, 0.40819800f, -0.16805445f, 0.13814718f, 0.03130026f, -0.08691774f, 0.16787036f, 
    0.08523425f, 0.13211961f, 0.19193268f, 0.05335192f, -0.52111447f, 0.34359804f, -0.34939551f, 0.16390359f, 
    -0.02837828f, -0.11905194f, 0.04401797f, 0.05068151f, -0.10967887f, -0.10823544f, -0.09686985f, -0.02906068f, 
    0.04477480f, -0.15993732f, 0.21643218f, 0.16137190f, 0.03950511f, 0.03265708f, -0.05096112f, 0.06175505f, 
    -0.16979940f, 0.03381392f, -0.01443602f, -0.03052213f, 0.13424248f, 0.21472348f, 0.18614484f, 0.19940270f, 
    -0.03955668f, 0.08836032f, -0.15092346f, -0.10892671f, 0.10299691f, 0.00799578f, 0.18581074f, 0.11196206f, 
    -0.24607757f, 0.01884370f, 0.17450875f, 0.11264834f, -0.24850185f, 0.00012187f, -0.00897573f, 0.01957716f, 
    -0.06111952f, -0.01903388f, -0.11939345f, 0.03209329f, -0.30287048f, -0.02917237f, -0.26111114f, 0.14691299f, 
    0.06362418f, -0.16041459f, 0.00658670f, -0.20418505f, -0.01247335f, 0.02222330f, 0.11419710f, 0.09614493f, 
    0.28754029f, -0.21321045f, 0.35430703f, -0.33729169f, -0.03619060f, -0.00717886f, -0.03637042f, 0.08542144f, 
    -0.01753597f, 0.02994571f, 0.00235129f, 0.12029068f, 0.00375635f, 0.28200716f, -0.22645386f, 0.15171146f, 
    -0.04702819f, -0.03744371f, -0.09876738f, 0.02519665f, 0.02340340f, 0.01620998f, 0.06103250f, -0.09179454f, 
    -0.16489004f, -0.40009233f, 0.03046801f, 0.16689406f, -0.11577440f, -0.06695767f, 0.03469135f, -0.08149913f, 
    -0.02873029f, -0.04403046f, -0.05154850f, 0.04302830f, 0.09722205f, 0.16483739f, 0.16556539f, 0.06898490f, 
    -0.12461711f, 0.06306688f, 0.13644986f, 0.10757448f, -0.06041446f, -0.05623587f, -0.02169177f, -0.04415791f, 
    -0.21858388f, -0.00723905f, -0.08231992f, -0.12169304f, 0.05842819f, -0.05887146f, 0.07045839f, 0.12196585f, 
    -0.05743374f, 0.12908359f, 0.06756552f, 0.02837596f, 0.11829632f, -0.08795907f, 0.32942030f, -0.02397776f, 
    -0.00515781f, 0.02034175f, -0.10512323f, 0.02400007f, -0.15345977f, 0.01872494f, -0.01935535f, -0.11718927f, 
    -0.11161000f, -0.30480972f, 0.27182859f, -0.00698424f, 0.03636186f, 0.02569479f, -0.07006460f, 0.03982626f, 
    -0.15679684f, 0.14010914f, -0.07768199f, -0.17771882f, 0.16747682f, 0.06719834f, 0.10681829f, 0.17721462f, 
    -0.04314435f, 0.13231279f, -0.24267611f, 0.06710120f, -0.10842743f, 0.08081443f, -0.04965320f, 0.06162136f, 
    0.13450651f, -0.38253370f, 0.28857890f, -0.18791582f, 0.08945527f, 0.07378750f, -0.04008050f, -0.04327701f, 
    0.12534511f, -0.01688288f, 0.12434172f, 0.01910589f, 0.01590189f, 0.09732705f, -0.06192806f, 0.04464509f, 
    0.10101669f, 0.18159629f, -0.06928714f, 0.13000268f, -0.24900232f, 0.01310308f, -0.15258345f, 0.00183541f, 
    -0.25716031f, 0.06082828f, -0.10997892f, 0.00131787f, -0.08107936f, 0.13302214f, -0.08143319f, 0.00854953f, 
    -0.20094419f, -0.00012821f, 0.11124374f, 0.10069000f, 0.11511070f, 0.09445243f, -0.35515156f, -0.03884316f, 
    -0.18414041f, -0.05138334f, 0.11913201f, -0.26975703f, 0.04689052f, -0.00758355f, -0.10203126f, -0.06118533f, 
    0.22189836f, 0.34277850f, -0.15579593f, -0.10365745f, 0.00192517f, 0.02905091f, 0.04748594f, 0.05462921f, 
    -0.05617331f, -0.02178850f, 0.03904273f, -0.04028670f, 0.14893399f, -0.06407512f, -0.00789141f, -0.15288872f, 
    -0.06432618f, -0.22820844f, -0.15137795f, -0.12043200f, 0.02723755f, -0.01767918f, -0.11198196f, -0.12981425f, 
    0.21005796f, -0.13215181f, 0.19182864f, -0.58727187f, -0.03759214f, -0.06028040f, -0.08308324f, -0.00540547f, 
    -0.04726509f, -0.02517943f, 0.10693853f, -0.09482576f, -0.66420227f, -0.07005727f, 0.01151087f, 0.22917914f, 
    0.19304045f, -0.07511029f, 0.00121155f, 0.18063498f, -0.19263181f, -0.11505621f, -0.23678018f, 0.02239832f, 
    0.01967020f, -0.23523940f, -0.27719596f, -0.21045342f, -0.12432387f, -0.14701173f, -0.17856915f, -0.09231251f, 
    0.04753914f, 0.12358531f, -0.03812559f, -0.04822671f, -0.12952507f, 0.24200530f, 0.12820069f, -0.11044157f, 
    -0.02550234f, 0.06170316f, -0.00913233f, -0.05554898f, 0.03984414f, 0.10353944f, 0.09171893f, 0.08597532f, 
    -0.07156005f, -0.05331118f, -0.16986677f, 0.04487749f, 0.06675898f, 0.13939542f, 0.32927290f, -0.08004516f, 
    0.01823970f, -0.16358155f, 0.04752896f, -0.16584712f, 0.13296622f, -0.04108462f, 0.25439477f, 0.27564269f, 
    -0.01638531f, -0.21818042f, -0.01354101f, -0.02729037f, -0.12230065f, -0.15778278f, 0.01730714f, -0.18895178f, 
    -0.22959730f, -0.10847800f, 0.16368064f, 0.09513462f, 0.01808326f, 0.05647866f, 0.09399709f, -0.10476062f, 
    0.01701231f, -0.08844592f, -0.00197655f, 0.04720494f, -0.33905092f, -0.13548315f, -0.24792629f, 0.10224775f, 
    0.13290885f, -0.12839977f, 0.09420636f, -0.01450344f, -0.06601013f, -0.03657236f, -0.00606751f, -0.02361135f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12096475f, 0.11002303f, 0.05622028f, -0.09783293f, -0.07283612f, 0.09647168f, -0.02028550f, -0.11138869f, 
    0.08611690f, -0.00788573f, 0.03598517f, -0.03838278f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
