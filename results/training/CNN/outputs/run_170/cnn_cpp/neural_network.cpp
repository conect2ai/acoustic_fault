#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.80380225f, -0.40086249f, -0.51246428f, -0.15228823f, -0.26182178f, 0.62590158f, 0.44894996f, -0.26094353f, 
    0.01745073f, 0.18854374f, -0.24405444f, -0.28822860f, 0.02710424f, -0.10108904f, 0.38254085f, -0.14691150f, 
    0.21172571f, 0.12783781f, 0.00493381f, -0.12827715f, -0.10371028f, -0.16321763f, -0.27107692f, -0.12447129f, 
    -0.14491919f, 0.87051886f, 0.55347461f, 0.25418347f, 0.29199657f, -0.16373694f, 0.09368053f, 0.15389831f, 
    -0.51144201f, 0.05356994f, 0.32297298f, -0.00530610f, 0.43954498f, -0.06573873f, 0.03415986f, 0.12884438f, 
    0.17132957f, -0.31092140f, 0.14182174f, -0.03225810f, 0.14476258f, -0.22533964f, 0.22552720f, -0.03572521f, 
    -0.07335659f, 0.04656139f, -0.21422681f, -0.02584735f, -0.46052706f, -0.18025582f, 0.26458880f, -0.40115711f, 
    -0.37113959f, -0.85611588f, -0.67044336f, -0.16942266f, -0.01384104f, 0.14222597f, 0.42258340f, -0.03923093f, 
    0.25983924f, 0.30562115f, 0.14128199f, 0.25197127f, 0.13933188f, -0.18555038f, 0.14914364f, -0.16782926f, 
    -0.00655514f, -0.08128709f, 0.11124904f, -0.65194923f, -0.94337893f, -0.53815860f, -0.01877266f, -0.02933294f, 
    -0.40140709f, -0.24860924f, 0.30378497f, 0.11247444f, 0.23855817f, 0.18405245f, 0.12477560f, -0.04902519f, 
    0.09608637f, -0.25262246f, 0.12766550f, 0.18518722f, 0.26055542f, -0.30321908f, -0.37212139f, -0.35767895f, 
    -0.19039422f, 0.05270707f, -0.11346836f, -0.20482902f, -0.25518969f, 0.14387524f, -0.31035349f, -0.46558237f, 
    0.05348025f, 0.17773069f, 0.23076707f, -0.41698989f, 0.23081332f, -0.28538042f, 0.31052214f, -0.23221608f, 
    0.29715905f, 0.03302659f, 0.19435015f, -0.50158948f, -0.42550626f, -0.11662706f, -0.40102243f, -0.28492743f, 
    0.16081728f, -0.01124318f, 0.18644817f, 0.09567738f, -0.39872253f, -0.46163100f, -0.30712095f, -0.59955561f, 
    0.20122184f, 0.24158184f, -0.39635137f, 0.70943654f, 0.70685822f, -0.12091569f, 0.51759452f, 0.14490035f, 
    -0.04836383f, 0.44233370f, -0.31256044f, 0.03153227f, -0.10535556f, 0.13372596f, -0.20502570f, 0.28952003f, 
    0.03207489f, 0.19350728f, 0.13680838f, -0.01900294f, 0.25557622f, 0.11909266f, 0.91318053f, -0.04828209f, 
    0.14946689f, 0.43204635f, 0.54326665f, 0.02636846f, 0.15446745f, 0.14068088f, -0.12249392f, -0.59388751f, 
    -0.13129233f, -0.29464898f, -0.23665851f, -0.22706488f, -0.23875387f, 0.03706407f, 0.15037613f, -0.03196155f, 
    0.22346307f, 0.02016719f, -0.09508019f, 0.19712025f, 0.15491714f, -0.21616986f, -0.10771305f, 0.71997809f, 
    0.56992435f, 0.55233163f, 0.41688433f, 0.35473707f, -0.26002967f, 0.01171969f, 0.22433314f, 0.10799423f, 
    0.20312205f, -0.13666809f, -0.21032314f, -0.16757633f, 0.41342160f, 0.29363263f, -0.24017334f, -0.27058408f, 
    -0.18593931f, 0.24532770f, 0.09920423f, 0.22696909f, 0.16936259f, -0.28435713f, 0.07894720f, 0.30009827f, 
    0.15227705f, 0.44621730f, 0.48511973f, 0.75630701f, 0.31330669f, -0.86909169f, 0.09373289f, -0.01308127f, 
    -0.24445483f, 0.05157584f, 0.46488550f, 0.06273505f, -0.46467602f, -0.09373004f, -0.21193919f, -0.07002105f, 
    -0.22743832f, -0.14247039f, 0.10807483f, -0.10520589f, -0.00279713f, -0.08081158f, 0.23338196f, 0.15698008f, 
    -0.20691290f, 0.62658954f, 0.38213238f, -0.48466372f, -0.22004882f, 0.17034027f, -0.16264403f, 0.08985601f, 
    0.48401809f, 0.34640396f, 0.50326103f, -0.13033214f, 0.30275708f, -0.31315458f, -0.56251079f, -0.05112648f, 
    0.16270807f, -0.35742003f, 0.09721238f, -0.16437188f, -0.05835683f, -0.04404635f, -0.09382703f, -0.04623213f, 
    0.04076750f, -0.32146230f, -0.81306350f, 0.63520473f, 0.60535502f, -0.90340179f, 0.39897826f, 0.59626991f, 
    0.08910497f, -0.57489693f, -0.16345665f, -0.55276132f, 0.07441328f, 0.29716682f, -0.03376714f, 0.21658120f, 
    -0.05798616f, -0.05495110f, 0.03322065f, -0.21528980f, -0.08595616f, 0.05529989f, 0.17571369f, 0.03692714f, 
    0.18993589f, 0.00073328f, 0.08962015f, -0.67005199f, -0.07224181f, 0.65155727f, 0.60615838f, -0.70942926f, 
    0.39106569f, -0.31425291f, -0.11378184f, -0.39241028f, 0.10592911f, -0.15936756f, 0.15578941f, -0.27018017f, 
    0.21058702f, -0.02763823f, -0.39279386f, 0.42971382f, -0.26626641f, 0.08400171f, -0.29124790f, -0.23558807f, 
    -0.24233793f, -0.13613853f, -0.18612486f, -0.17603897f, 0.79970992f, 0.66181093f, 0.36037663f, -0.32900757f, 
    0.31666458f, -0.12200334f, -0.16391826f, 0.01771984f, 0.26205394f, 0.02856871f, 0.19532940f, 0.11543486f, 
    0.04934775f, 0.12662464f, -0.32192379f, 0.26315859f, -0.06722961f, -0.19875599f, 0.02760710f, -0.42469093f, 
    0.11667135f, -0.05905832f, 0.37947172f, 0.20318569f, 0.07827817f, 0.01552775f, -0.59886187f, -0.36001626f, 
    0.49473312f, 0.08393056f, -0.11705331f, -0.54087991f, -0.39074424f, -0.21857910f, -0.24926524f, 0.05240273f, 
    0.41060600f, 0.39265898f, 0.30645299f, -0.31238151f, 0.03073772f, -0.22594105f, 0.24870180f, -0.10158704f, 
    0.45129207f, 0.18488255f, -0.26446798f, -0.33795422f, 0.03933192f, 0.12408086f, 0.05853129f, -0.91762036f, 
    -0.22706588f, 0.36898774f, -0.26517755f, 0.26683843f, 0.64618188f, -0.65723193f, 0.41687891f, 0.30971038f, 
    0.12872788f, 0.20446660f, -0.18067671f, 0.27440894f, -0.11854805f, -0.19602054f, -0.26942047f, -0.07695916f, 
    -0.12009651f, 0.16744147f, 0.22039272f, 0.40001372f, -0.19430214f, 0.17471166f, -0.15388896f, -0.56124097f, 
    -0.37466669f, 0.64346462f, 0.57715869f, 0.48196030f, -0.00103979f, 0.53357613f, 0.25844374f, -0.22993562f, 
    0.33415869f, -0.38080016f, 0.00088835f, 0.05232138f, -0.33279133f, -0.16863714f, -0.23824567f, -0.13323812f, 
    -0.10691828f, 0.24851888f, -0.18603225f, 0.15620396f, -0.11697075f, -0.01804630f, -0.20993012f, 0.06528857f, 
    0.85245246f, 0.81744277f, -0.70279986f, -0.04216922f, -0.91733098f, -0.00894872f, -0.20951021f, -0.31595707f, 
    -0.04454574f, -0.19588682f, 0.02644223f, -0.00211947f, 0.21074323f, 0.19261895f, -0.02319969f, -0.09523688f, 
    -0.17046630f, 0.00782070f, 0.09731987f, -0.11722532f, 0.03394265f, -0.10290331f, 0.00101216f, 0.00094096f, 
    0.19013241f, -0.61256540f, -0.04580895f, 0.41290802f, -0.23844607f, 0.27460727f, -0.27729696f, 0.42778978f, 
    -0.37788004f, -0.15181297f, -0.45489857f, 0.11574623f, -0.20130852f, 0.06802556f, -0.27678391f, -0.35489157f, 
    -0.11194284f, 0.09462737f, 0.19793956f, -0.25483745f, 0.08291095f, -0.03895704f, -0.03355005f, -0.24345180f, 
    -0.11826374f, 0.13333376f, 0.02963769f, 0.17318502f, -0.02906690f, 0.48576054f, 0.02773383f, 0.59445149f, 
    0.55295187f, 0.40696773f, 0.36588949f, 0.50096399f, -0.08033158f, -0.31402731f, 0.10869423f, -0.36728784f, 
    0.08443603f, -0.26189241f, -0.31333447f, -0.24063578f, -0.12382885f, -0.29058832f, -0.22348759f, -0.36251807f, 
    -0.02561434f, 0.11842783f, -0.01351779f, 0.56564635f, -0.60910738f, -0.08176140f, -0.82530439f, 0.32063821f, 
    0.09300934f, 0.07682891f, -0.47978377f, -0.47632590f, -0.55263543f, -0.13873680f, 0.07316119f, -0.06456690f, 
    -0.24226685f, -0.54238129f, 0.19866508f, -0.10518919f, -0.10037185f, 0.07633971f, -0.42461473f, 0.02478824f, 
    -0.10092392f, -0.15911198f, 0.17976263f, 0.18159471f, -0.27880898f, 0.15482093f, 0.07863583f, -0.44398859f, 
    0.07071102f, -0.73840463f, 0.01217152f, -0.19051950f, -0.64930266f, 0.06838350f, -0.12368111f, 0.34418848f, 
    0.09199218f, 0.24408634f, -0.24122480f, -0.09409339f, -0.31560668f, 0.20436886f, -0.18206500f, 0.24858497f, 
    0.26570496f, -0.00055260f, -0.08997022f, 0.22039540f, -0.06813424f, 0.61996728f, 0.49119720f, 0.22359473f, 
    0.44351706f, 0.72599792f, 0.45781553f, 0.23682834f, 0.13855278f, 0.31294653f, 0.29804474f, -0.12498462f, 
    0.32933170f, 0.04829111f, -0.13771552f, -0.34239948f, -0.28639063f, 0.20347776f, 0.31661963f, 0.17997682f, 
    -0.17046139f, -0.18674585f, -0.05514766f, -0.03583696f, -0.08480129f, 0.19669212f, -0.59649891f, -0.43553439f, 
    -0.36028191f, -0.53858060f, -0.45836577f, 0.43362799f, 0.23042521f, 0.15844594f, 0.29235393f, 0.35896501f, 
    0.01439771f, -0.34874311f, 0.38335243f, 0.20937966f, -0.13108034f, -0.15422150f, -0.05371290f, 0.12677173f, 
    0.15493020f, -0.24254264f, 0.09208483f, -0.00284371f, 0.14440569f, 0.21672820f, 0.34862956f, 0.70272666f, 
    0.30368814f, 0.44275898f, 0.85734493f, 0.72500926f, 0.48260552f, 0.03528943f, -0.26484945f, -0.33149588f, 
    -0.24891663f, 0.17916754f, 0.17705628f, 0.01083419f, 0.04400761f, -0.14262155f, 0.08286538f, 0.20073657f, 
    0.21317165f, -0.16202761f, 0.14714068f, 0.04897404f, 0.26970464f, 0.01938243f, 0.03395400f, -0.04573217f, 
    -0.55238611f, 1.12298906f, -0.58239102f, -0.87489903f, 0.23771158f, 0.19432212f, -0.17732063f, 0.06234008f, 
    0.26466545f, 0.22852741f, 0.13071032f, -0.23027687f, -0.32546616f, 0.02901744f, -0.10755402f, -0.10586620f, 
    0.12823667f, 0.03299263f, 0.03947924f, -0.13199599f, -0.24900866f, -0.20442957f, -0.07591334f, -0.11746474f, 
    0.08739053f, -0.22110678f, 1.07195187f, 0.69538921f, -0.33711225f, 0.02416612f, -0.96563673f, 0.69351375f, 
    -0.35882306f, -0.62622911f, -0.32038411f, 0.01155807f, 0.32506314f, 0.11151903f, -0.14014101f, 0.28763646f, 
    -0.01365000f, -0.21417148f, -0.09032068f, -0.14363252f, -0.06822889f, 0.02888501f, 0.23228557f, 0.09518844f, 
    0.10896656f, 0.04047302f, -0.37956211f, -0.90209365f, -0.49237853f, -0.05610118f, -0.18328536f, -0.56574202f, 
    0.43985617f, 0.37299970f, -0.54901779f, 0.14364050f, 0.09170301f, -0.25851160f, -0.16294174f, 0.02846638f, 
    0.32158729f, -0.23318733f, -0.12473392f, -0.01557256f, -0.42962036f, -0.04534784f, 0.03975472f, 0.01090614f, 
    0.04233713f, 0.28762019f, 0.02195585f, -0.37463897f, -0.43256804f, -0.49449018f, -0.29141065f, 0.02002060f, 
    0.57290322f, 0.32633078f, -0.06655747f, -0.22820774f, -0.19758731f, 0.00428285f, 0.35367316f, 0.14311045f, 
    0.07544225f, -0.40213388f, 0.25681514f, 0.27645507f, -0.29881841f, -0.18677744f, 0.29396477f, -0.01111166f, 
    -0.10845859f, -0.05518538f, 0.23821925f, 0.19335675f, 0.76013458f, -0.39166343f, -0.33721629f, -0.72522718f, 
    -0.61510694f, 0.56151432f, 0.18321496f, 0.28371462f, 0.42547336f, 0.20557556f, 0.01796484f, -0.23534356f, 
    -0.44108650f, -0.21651968f, -0.26487657f, 0.07414135f, 0.08472102f, -0.25098446f, -0.05531498f, 0.11287267f, 
    -0.01501461f, -0.06492092f, -0.15484132f, -0.00580749f, -0.23699637f, 0.30629325f, 0.66207749f, 0.53820348f, 
    0.27132705f, 0.59022260f, -0.01696600f, -0.46999565f, -0.47315726f, -0.51540947f, -0.30927485f, 0.25294906f, 
    -0.05981456f, 0.01480034f, 0.38031304f, 0.07998319f, -0.05070911f, 0.21052337f, -0.02748541f, -0.06374952f, 
    0.23201787f, -0.18372343f, -0.20447053f, -0.07203163f, -0.02755232f, 0.03119853f, -0.15037581f, -0.04396538f, 
    -0.50289935f, -0.41988465f, -0.46786919f, -0.33598796f, -0.48642182f, 0.06230560f, 0.03055364f, 0.17179283f, 
    0.05186307f, -0.07779510f, -0.32594615f, -0.06979825f, 0.05840375f, 0.25287238f, 0.10684824f, -0.03525469f, 
    0.30704451f, 0.33388963f, 0.48052546f, 0.19721590f, 0.42653611f, -0.19827443f, 0.07635888f, -0.30504373f, 
    -0.28193688f, -0.28688633f, -0.61767286f, 0.66244143f, -0.47351012f, 0.45597675f, 0.50596005f, 0.15367550f, 
    -0.07437549f, -0.30794612f, 0.09113614f, -0.42922890f, -0.09365410f, -0.16743422f, -0.08683816f, -0.04164831f, 
    -0.11101477f, -0.02440846f, 0.13547724f, 0.29460141f, -0.07883731f, 0.37172827f, -0.13227993f, 0.12317085f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00362252f, 0.04970220f, 0.31588063f, 0.09145121f, 0.12159548f, 0.01596273f, -0.17266096f, 0.30352765f, 
    0.00284964f, -0.04694351f, 0.07197022f, -0.02468283f, 0.01741031f, 0.19530080f, 0.18731748f, 0.04614132f, 
    0.12771292f, 0.13374530f, 0.17286888f, 0.32187164f, 0.15769623f, 0.11793824f, 0.20445246f, 0.18596914f, 
    -0.04085750f, 0.20461966f, -0.01903788f, 0.02008651f, 0.08388842f, 0.08137043f, 0.13558134f, 0.19407125f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.29518259f, 0.05609991f, 0.10038098f, 0.08823821f, 0.06149750f, 0.16170721f, -0.00996747f, -0.19940902f, 
    0.02208132f, -0.02483369f, 0.05068412f, -0.13941367f, 0.13697578f, -0.06777456f, -0.02855589f, 0.04766854f, 
    0.12543637f, 0.05217002f, 0.04511141f, -0.07787438f, -0.09370574f, 0.01669817f, 0.07865532f, 0.04811420f, 
    -0.08577347f, 0.01496971f, -0.18895525f, 0.17188247f, -0.05399236f, -0.11855559f, -0.04672122f, 0.05793480f, 
    0.02348580f, 0.07057934f, 0.25383908f, -0.00775399f, -0.18661173f, 0.19906199f, 0.09172643f, -0.04936419f, 
    0.16252398f, 0.10600522f, 0.08378571f, -0.16252914f, 0.04364875f, -0.02913755f, 0.02420915f, 0.05593605f, 
    -0.19285609f, -0.04917635f, -0.01914517f, 0.13508484f, -0.02797885f, 0.04278539f, 0.00668400f, 0.11658637f, 
    0.11948074f, 0.03550379f, 0.05535529f, -0.09258476f, -0.18799518f, 0.07729397f, 0.04081997f, -0.03890890f, 
    0.03622659f, 0.04529094f, 0.05348922f, 0.08290929f, 0.12386761f, 0.01176011f, -0.01402303f, -0.03978229f, 
    -0.06359390f, 0.01187850f, -0.02565628f, -0.02746669f, -0.10797612f, -0.10792395f, -0.01125557f, -0.15439196f, 
    0.03987671f, 0.01809052f, -0.04826920f, -0.01587020f, 0.16341853f, -0.03547541f, -0.01135331f, -0.00244778f, 
    0.07232789f, 0.13627191f, -0.08258459f, 0.05446597f, 0.00214602f, 0.01533248f, 0.01842035f, -0.05302337f, 
    0.28020614f, -0.10109217f, -0.09721918f, -0.20747629f, 0.02079277f, -0.08900177f, -0.06482747f, 0.08105809f, 
    0.07014572f, -0.09011272f, -0.08855300f, 0.08840744f, 0.06005484f, 0.18544650f, -0.06928615f, -0.11173327f, 
    0.07429317f, -0.03503951f, -0.06974369f, -0.16010956f, -0.05866909f, -0.00317050f, -0.06053054f, 0.01301009f, 
    -0.35481340f, -0.07092213f, 0.13822901f, 0.39872605f, -0.02206280f, -0.02350481f, 0.05670749f, 0.00633318f, 
    -0.00183309f, -0.05164140f, 0.01746278f, 0.10319524f, 0.10185927f, -0.02999845f, 0.12694858f, 0.01666760f, 
    0.07220972f, -0.02655001f, -0.07348102f, -0.02074334f, -0.02194718f, -0.00055758f, -0.04576188f, -0.05224811f, 
    0.04189191f, 0.05174915f, -0.05743851f, 0.05727210f, 0.05856438f, 0.05953978f, 0.01343157f, 0.02260923f, 
    0.05612929f, -0.14071310f, -0.06202782f, 0.13389522f, -0.02970218f, 0.04342739f, -0.06994158f, -0.01270032f, 
    0.00792893f, 0.03739640f, 0.03266288f, 0.00726435f, 0.05848286f, 0.13113995f, 0.19125535f, 0.22296819f, 
    -0.08015153f, 0.07417969f, 0.00490910f, 0.04151872f, 0.06198118f, -0.00338657f, -0.06686738f, 0.08253534f, 
    0.01176225f, -0.02915451f, 0.00343439f, -0.07157545f, -0.08454230f, -0.00561430f, -0.12574567f, -0.34097338f, 
    0.04135340f, -0.04283754f, -0.06311695f, -0.06206601f, -0.05873813f, 0.00461613f, 0.09193148f, -0.11639512f, 
    -0.02398891f, 0.34709492f, -0.08189090f, 0.10694318f, -0.02440809f, 0.00752553f, -0.01771733f, 0.00689574f, 
    -0.03615421f, 0.02456369f, 0.10699872f, -0.03932248f, -0.06282354f, -0.05017646f, 0.06435807f, 0.09588049f, 
    -0.01328894f, -0.02548795f, -0.16668461f, -0.02762374f, 0.03660138f, -0.03034980f, 0.06878261f, -0.06443579f, 
    -0.01758003f, 0.01230201f, 0.02290259f, -0.10436777f, 0.00273918f, -0.00315755f, 0.00420383f, -0.08253019f, 
    -0.03313184f, -0.10292897f, -0.09354669f, -0.14888623f, 0.18295611f, -0.05377693f, -0.00950796f, 0.23401302f, 
    -0.03222242f, 0.06289195f, -0.05491498f, 0.09290382f, 0.02872003f, 0.06720705f, -0.05165840f, 0.10666797f, 
    0.21373037f, 0.01380727f, -0.01046801f, 0.19985238f, -0.07008385f, -0.07047277f, 0.03484774f, 0.08883416f, 
    -0.08685812f, 0.09645885f, 0.03261042f, -0.08816379f, -0.02485621f, 0.06036688f, 0.03837787f, -0.05679248f, 
    0.15302326f, 0.09693605f, -0.07789890f, -0.04636642f, 0.07037220f, -0.08347811f, 0.05656519f, -0.07306180f, 
    -0.16222179f, -0.02661592f, -0.02090023f, 0.25004947f, 0.09665249f, 0.07048523f, 0.08456446f, -0.01553759f, 
    0.09253816f, -0.05132421f, 0.12696840f, -0.05811249f, 0.01530997f, 0.01566902f, 0.11372991f, -0.09671236f, 
    0.01947981f, 0.03632208f, 0.02564971f, -0.12555295f, 0.03800046f, 0.09499169f, 0.08192553f, 0.09960777f, 
    -0.19473328f, -0.04218074f, -0.06986386f, 0.38774198f, 0.12344611f, 0.03003529f, -0.18915431f, -0.09198988f, 
    0.02894580f, 0.00582711f, 0.11026514f, 0.05651957f, 0.33481207f, -0.27712819f, -0.10769799f, 0.25193775f, 
    -0.13695820f, -0.05275606f, -0.01514229f, -0.01534678f, 0.03457303f, -0.01284864f, 0.00325353f, 0.01845418f, 
    -0.19828485f, 0.16561285f, 0.15720636f, -0.05057839f, 0.13326049f, 0.03554699f, 0.08212675f, 0.10374316f, 
    -0.07019531f, 0.15032028f, -0.04001239f, 0.01270929f, 0.03268553f, 0.10164901f, 0.22472358f, 0.07296196f, 
    -0.01251499f, 0.10906801f, 0.14036408f, -0.08014505f, 0.03164606f, -0.00344316f, -0.02460790f, 0.11324240f, 
    0.12952900f, 0.01772623f, -0.11779232f, -0.04883139f, 0.01611625f, -0.13999216f, -0.04561396f, -0.16593730f, 
    -0.01460886f, 0.03252899f, -0.16020471f, -0.03610779f, -0.04475812f, -0.12898688f, -0.03476442f, 0.13644993f, 
    -0.06371130f, -0.07623591f, -0.01650699f, -0.09160487f, -0.06323847f, 0.04618760f, 0.03411885f, 0.21217750f, 
    0.11976140f, 0.16988595f, 0.07071138f, 0.20136186f, 0.15267801f, -0.08438809f, -0.07522938f, -0.13721214f, 
    -0.07493328f, 0.17386514f, -0.16234352f, -0.07402873f, 0.06445484f, -0.11722592f, 0.01904693f, -0.05488517f, 
    0.01539885f, 0.00773849f, -0.10277975f, 0.05606304f, 0.04263219f, 0.03379668f, 0.06275113f, 0.00867774f, 
    -0.06233622f, -0.04047768f, 0.05754657f, 0.10797174f, -0.02175587f, -0.09197912f, 0.17990576f, 0.01396544f, 
    0.00626549f, 0.00564430f, -0.00522679f, 0.10609140f, -0.25637987f, -0.07142150f, -0.13012163f, -0.00600433f, 
    0.00089650f, -0.00862849f, -0.01006969f, 0.05023570f, 0.04562021f, -0.05854017f, 0.04872729f, -0.08226792f, 
    0.14740606f, -0.00246681f, 0.12705864f, 0.05775497f, 0.04290690f, 0.06947707f, -0.02730382f, -0.04639437f, 
    0.10105763f, -0.02866645f, -0.15756613f, -0.03915902f, 0.16468006f, -0.02378370f, 0.12961517f, 0.10644859f, 
    -0.01216866f, 0.06723841f, 0.01229168f, 0.11583040f, 0.06940450f, 0.19691430f, 0.09027182f, -0.01119779f, 
    0.08479939f, 0.14681588f, 0.00940852f, 0.04566899f, 0.04206097f, 0.03830099f, -0.02443605f, 0.07464729f, 
    -0.05063006f, 0.13166612f, 0.07831377f, 0.04976696f, 0.07238513f, 0.01589571f, 0.07719765f, 0.02758942f, 
    -0.11109445f, -0.09237771f, -0.05869544f, -0.01135735f, -0.11223183f, 0.02500189f, 0.00991812f, -0.08495098f, 
    -0.17396888f, 0.03757498f, 0.02652386f, -0.06950622f, 0.11913753f, 0.04508322f, -0.03784972f, 0.02860824f, 
    0.11398684f, -0.10238843f, 0.04799787f, 0.05997049f, -0.19346121f, -0.14429301f, -0.09414792f, -0.12971942f, 
    0.12098632f, 0.01625509f, 0.09146821f, -0.13716128f, -0.01469776f, -0.03726633f, 0.20161055f, -0.04598683f, 
    -0.30933800f, -0.09418071f, 0.00928849f, 0.00423071f, 0.09681135f, 0.11892955f, 0.01224558f, -0.01469139f, 
    0.00389505f, 0.06207043f, 0.11554847f, -0.14446904f, -0.00195637f, -0.00593619f, -0.06521844f, 0.22513674f, 
    -0.02181526f, 0.13668668f, 0.05900331f, 0.03609803f, -0.02327110f, 0.05701162f, 0.14050524f, -0.11611480f, 
    0.50694996f, 0.27716559f, -0.02861047f, -0.03416470f, 0.10612345f, -0.12815493f, -0.05807010f, -0.04779729f, 
    0.00879092f, -0.10111792f, 0.05182236f, -0.06521676f, 0.18386720f, -0.15291891f, 0.00733987f, -0.17775488f, 
    0.11928180f, 0.25882423f, -0.04561046f, 0.09401253f, 0.00009241f, 0.07192618f, 0.02023085f, 0.08517358f, 
    0.05963613f, -0.18038820f, -0.12342655f, -0.07407920f, -0.00662996f, 0.04344772f, -0.02791739f, -0.10255274f, 
    -0.02146836f, 0.07100046f, -0.02061982f, -0.03903832f, 0.03226462f, 0.16229966f, 0.07497151f, 0.07185028f, 
    0.11530013f, -0.04229372f, -0.03770746f, -0.06593464f, 0.02323468f, -0.02152809f, -0.13856857f, -0.07945281f, 
    -0.15293971f, 0.19273713f, 0.03904597f, -0.05705163f, 0.02359119f, -0.00457917f, 0.06012429f, 0.05544342f, 
    0.05261433f, -0.05122513f, -0.04811964f, -0.00701140f, -0.12248374f, 0.02575082f, 0.06638748f, -0.06145459f, 
    0.05590916f, -0.03184598f, 0.01412614f, -0.01644932f, 0.11151391f, 0.04586114f, 0.04954162f, 0.10974877f, 
    -0.05833900f, -0.09853990f, -0.01830314f, -0.07883789f, -0.01790310f, 0.09879496f, 0.02355964f, -0.00105226f, 
    0.04092622f, 0.04859702f, 0.01218267f, -0.00422496f, 0.00969807f, 0.13634144f, 0.05904370f, 0.07953897f, 
    0.15248294f, 0.03002576f, 0.08927587f, 0.05474373f, 0.01928346f, 0.08463149f, -0.08474478f, 0.09384196f, 
    -0.24439584f, 0.04798098f, -0.04736835f, -0.11992968f, 0.03491742f, -0.13474423f, 0.03980967f, 0.09043104f, 
    0.04917032f, 0.12657255f, 0.02391603f, -0.01552416f, -0.16991395f, -0.02153252f, -0.03097665f, 0.24176538f, 
    0.09045721f, -0.07594951f, -0.06991817f, -0.05322918f, -0.00727949f, 0.09558605f, 0.06296049f, 0.02589492f, 
    0.10815379f, 0.04158758f, 0.10910405f, 0.13516799f, -0.00488982f, 0.00290127f, 0.04955730f, -0.10068330f, 
    0.00334194f, 0.04565392f, -0.05490267f, -0.01951007f, -0.16483076f, -0.05103616f, -0.16667593f, -0.04007455f, 
    0.00602254f, -0.01105258f, 0.10876043f, -0.00378079f, -0.09708576f, 0.08260765f, -0.07712073f, -0.07258815f, 
    0.02155290f, 0.09895961f, 0.10506950f, 0.19322041f, -0.01044797f, -0.08914082f, -0.02460695f, 0.01069475f, 
    -0.05022021f, -0.02914362f, -0.02519936f, 0.02984033f, -0.13339432f, 0.00906424f, -0.16084540f, 0.03561228f, 
    0.05478970f, -0.04313171f, -0.01446098f, -0.02824033f, -0.02587062f, -0.08085769f, -0.01286303f, -0.00567359f, 
    0.31297144f, 0.17316943f, -0.09558899f, 0.05389605f, 0.01475675f, 0.04455947f, 0.15117696f, 0.13199438f, 
    0.00262213f, -0.00748467f, -0.04622724f, 0.14986098f, 0.02271018f, 0.02599969f, 0.20544511f, 0.05712099f, 
    -0.00813694f, 0.05073161f, 0.01970259f, 0.01866431f, -0.14856382f, -0.03237368f, -0.06258747f, 0.07778832f, 
    0.20584522f, 0.06500228f, 0.11882277f, 0.03465368f, 0.07409359f, 0.05658067f, 0.03290169f, 0.09428331f, 
    0.09809538f, 0.01185055f, 0.07287415f, 0.03041064f, 0.01770676f, -0.03776127f, 0.08970951f, 0.21986175f, 
    0.11548238f, -0.13313089f, -0.06648134f, 0.16960657f, -0.02462724f, -0.02002700f, 0.01146305f, -0.04536070f, 
    -0.21778695f, 0.14761065f, 0.21107021f, 0.26830733f, -0.11840370f, 0.04867375f, 0.09984840f, 0.17657205f, 
    0.08307827f, 0.09163595f, 0.12020322f, 0.01738823f, -0.07887036f, -0.10391819f, -0.01492080f, 0.17518151f, 
    0.13718991f, 0.08975893f, -0.03628303f, 0.01625034f, -0.02133229f, -0.05256560f, 0.03322468f, -0.06055275f, 
    0.21157026f, -0.02228051f, -0.00348757f, 0.07729248f, -0.02202038f, -0.05688541f, 0.03368972f, -0.01458407f, 
    0.02992242f, 0.00400314f, -0.03568420f, 0.00880709f, -0.04544183f, -0.02489176f, -0.03434360f, 0.30446720f, 
    0.03596000f, -0.08640511f, 0.09507293f, -0.04386663f, -0.05100719f, -0.03387402f, 0.07479080f, 0.07006118f, 
    -0.01811440f, -0.09781931f, -0.05869679f, -0.23741378f, 0.00276853f, 0.19812614f, -0.12516665f, -0.01490300f, 
    0.08760058f, -0.03503062f, 0.04926543f, 0.08051308f, 0.17923617f, 0.23130277f, 0.02000710f, 0.06747670f, 
    -0.11118545f, 0.13923720f, 0.01264085f, 0.13365950f, -0.00062038f, 0.00558594f, 0.02623677f, 0.00857142f, 
    -0.07953096f, 0.00061028f, 0.06318892f, -0.02096132f, -0.03150305f, -0.02174328f, -0.00337636f, 0.03111521f, 
    -0.12973821f, -0.00244237f, -0.01158151f, 0.04593330f, -0.22702038f, -0.16566564f, -0.10775696f, -0.27411962f, 
    -0.01914263f, 0.04926695f, 0.04927475f, 0.06394675f, -0.00902932f, 0.17494652f, -0.01222320f, -0.07500824f, 
    -0.04253285f, -0.01779548f, 0.10978469f, 0.08751009f, -0.10981660f, -0.06296515f, -0.02273965f, 0.00352162f, 
    0.05895310f, 0.10088585f, 0.09440237f, 0.04555506f, -0.21823031f, -0.13023430f, 0.01881965f, -0.11002045f, 
    0.06938045f, -0.03886395f, 0.09253373f, 0.06145068f, 0.08357888f, -0.08890997f, -0.06943917f, 0.05524027f, 
    -0.01037970f, 0.05330042f, -0.01151167f, 0.11754015f, -0.09038557f, 0.02463863f, 0.00387825f, -0.02160388f, 
    -0.01012736f, -0.11677540f, 0.04664803f, 0.10070052f, 0.08044083f, 0.12863149f, 0.12991050f, -0.10916536f, 
    0.04305729f, 0.13295512f, -0.01308395f, 0.04023402f, -0.05677733f, -0.14470470f, 0.03627297f, -0.04963825f, 
    0.18816252f, 0.10084738f, 0.14833513f, -0.03410702f, -0.00267271f, -0.04486403f, -0.00689852f, -0.01345628f, 
    0.08949744f, -0.05017738f, 0.06438646f, 0.02127941f, -0.11056592f, 0.14026296f, 0.10092385f, -0.18452308f, 
    0.06848463f, -0.02743817f, -0.10175323f, 0.11355562f, -0.04350397f, -0.04923725f, 0.10684551f, 0.13431560f, 
    -0.04859899f, -0.30931139f, 0.28942263f, 0.17085546f, 0.02639294f, 0.02209219f, -0.00407044f, 0.03659800f, 
    -0.04357052f, -0.03648961f, -0.08495523f, 0.00266327f, 0.03228733f, 0.11775904f, 0.04700906f, -0.03447189f, 
    0.02480681f, 0.00863983f, 0.05389819f, 0.14102426f, 0.03510819f, -0.03646732f, 0.07781217f, 0.14482881f, 
    0.02492695f, 0.09761124f, -0.01442380f, -0.02313268f, 0.04134526f, -0.00628088f, -0.08408761f, 0.00893865f, 
    -0.05164725f, 0.01503568f, 0.07574251f, -0.05109612f, -0.02612496f, -0.01499961f, 0.03049494f, -0.01776701f, 
    0.05593897f, -0.01915903f, 0.02082847f, -0.02095888f, -0.01397513f, -0.07127693f, -0.05700349f, 0.04458354f, 
    -0.02384635f, -0.17149086f, -0.08432509f, -0.06972048f, -0.07479700f, 0.02105335f, 0.12984902f, -0.12470704f, 
    -0.09992898f, 0.04861241f, 0.09663291f, -0.01150890f, 0.11516014f, -0.13439386f, 0.20509313f, 0.17519245f, 
    0.02949787f, 0.02749093f, 0.07688662f, 0.00552087f, 0.03219258f, -0.01806239f, -0.10898316f, 0.10590746f, 
    0.19193748f, 0.24884425f, 0.04218528f, 0.24567360f, 0.02082783f, 0.01066819f, 0.05276208f, 0.10675287f, 
    0.01913307f, -0.09683165f, 0.00447752f, 0.06209387f, 0.10958707f, -0.08580310f, 0.09588553f, 0.12795775f, 
    0.01076909f, -0.09064387f, 0.05688829f, 0.03562915f, 0.06026643f, 0.08904991f, 0.02644870f, -0.02422133f, 
    0.09334570f, -0.08565126f, 0.05515631f, -0.06022239f, -0.01362418f, 0.11900865f, 0.05009869f, -0.02057093f, 
    0.00756676f, 0.06554278f, 0.13904007f, 0.08303693f, 0.13292667f, 0.07832780f, -0.05976881f, -0.01462962f, 
    0.01279519f, 0.00436463f, 0.11221977f, 0.05047745f, 0.04007449f, 0.14468093f, 0.08767985f, 0.10164356f, 
    -0.20957094f, -0.09526891f, -0.08996670f, 0.05346194f, 0.07506856f, 0.04357462f, -0.03774304f, 0.06282848f, 
    -0.11096294f, -0.09310842f, -0.05782957f, 0.12368065f, 0.03494512f, 0.16921793f, 0.18964940f, 0.01279798f, 
    0.05680151f, 0.05097967f, 0.05205081f, 0.03408272f, 0.20641874f, 0.17130524f, -0.00999825f, 0.09005495f, 
    -0.07553349f, -0.10752041f, -0.17166492f, -0.28227365f, -0.02436109f, 0.08930262f, 0.04369725f, -0.09513346f, 
    -0.07229356f, 0.01648407f, -0.01097876f, 0.13701819f, 0.18276550f, 0.02142049f, 0.07995473f, 0.06821839f, 
    -0.03065781f, 0.06261200f, 0.02738012f, 0.02717227f, 0.03531173f, 0.06051369f, -0.04350796f, -0.02883905f, 
    0.05139453f, -0.03304681f, 0.37608555f, -0.00084828f, 0.01325003f, -0.04795086f, 0.06054331f, -0.04807511f, 
    -0.06427963f, 0.00873206f, 0.01979220f, -0.06710621f, 0.20084588f, 0.05530151f, -0.04322569f, 0.11724182f, 
    0.11656343f, 0.00578179f, -0.01399846f, 0.12219771f, -0.04791725f, -0.01748601f, 0.00844658f, -0.03968572f, 
    -0.22304240f, 0.00428966f, -0.00768715f, -0.14178385f, 0.02811855f, -0.02374531f, 0.02926290f, -0.09147704f, 
    -0.05193691f, 0.04933099f, 0.03162368f, -0.10132024f, 0.00749001f, -0.11153333f, -0.19651406f, -0.15757905f, 
    0.08777250f, 0.22784904f, 0.00342733f, -0.06046065f, 0.07984597f, 0.05740917f, -0.05323675f, -0.09074216f, 
    0.26226643f, 0.03543582f, -0.29623574f, -0.06160458f, 0.12335015f, 0.07074915f, -0.01507263f, 0.03458909f, 
    -0.12486015f, 0.07386444f, 0.03555694f, 0.08340206f, 0.27960223f, 0.12055510f, 0.15290120f, -0.06070817f, 
    -0.00768553f, -0.06019443f, 0.01534734f, 0.10744975f, 0.08056942f, -0.08401018f, -0.00112749f, 0.04939266f, 
    -0.21074581f, -0.11260329f, -0.09257391f, 0.04537156f, -0.02402854f, 0.02677905f, -0.02080026f, 0.06594959f, 
    -0.11999809f, -0.05288204f, 0.07489959f, -0.03330867f, -0.17472716f, 0.04729946f, -0.02915726f, 0.09344048f, 
    -0.06652032f, 0.02449669f, -0.04770704f, -0.06233618f, -0.00536351f, 0.02988972f, -0.12079998f, -0.00654404f, 
    -0.22721651f, 0.07713564f, 0.09153189f, 0.03682390f, -0.04166611f, 0.03484773f, 0.03481354f, -0.05208376f, 
    0.04306480f, -0.00803731f, -0.02369932f, -0.13546437f, -0.39167359f, 0.02914415f, 0.14165334f, -0.19449486f, 
    0.06414188f, 0.07485604f, 0.13732857f, -0.03758852f, 0.01821382f, -0.02810780f, 0.06305228f, -0.08651774f, 
    0.10309189f, -0.04455750f, -0.04194353f, 0.01046717f, -0.01683187f, 0.02181174f, -0.11199447f, 0.07945782f, 
    -0.07346123f, 0.00860365f, 0.13555078f, -0.02114854f, 0.00360619f, -0.07789587f, -0.15309069f, 0.08254994f, 
    0.02905087f, 0.18925723f, 0.12726077f, -0.03579468f, 0.05867385f, -0.05223421f, -0.03522535f, 0.05655806f, 
    -0.21968834f, -0.01875376f, -0.04719465f, 0.03346757f, -0.03137667f, -0.04693023f, 0.07438834f, 0.23876043f, 
    0.02925388f, 0.04273426f, -0.01284590f, -0.17606892f, 0.11152457f, -0.09961481f, 0.01434261f, -0.00961718f, 
    -0.13831237f, -0.02420512f, -0.00402041f, 0.12369158f, 0.04145301f, 0.03099471f, 0.06979900f, -0.03976548f, 
    -0.28515354f, 0.23641908f, -0.04859308f, -0.18036702f, 0.02876180f, -0.13659503f, -0.04792700f, -0.10475753f, 
    -0.03591582f, 0.01684874f, -0.02054944f, 0.01157346f, -0.13691048f, 0.09381991f, 0.02504883f, -0.19222637f, 
    0.21174778f, 0.14690737f, 0.09650499f, 0.01969372f, -0.00346942f, 0.07428165f, 0.01493048f, 0.09608622f, 
    0.08718766f, 0.03141876f, -0.02534893f, -0.20049302f, -0.03665902f, -0.03838442f, -0.07744102f, -0.00548223f, 
    0.02640492f, -0.06294472f, -0.06274004f, 0.01832483f, 0.15363669f, -0.06770705f, 0.00871446f, -0.02800440f, 
    -0.08091673f, 0.03006045f, -0.03399368f, -0.00272593f, 0.02452322f, -0.07912415f, 0.00193020f, -0.04994153f, 
    -0.10818516f, -0.15051973f, -0.03965052f, 0.11872649f, -0.01502844f, 0.01494217f, -0.01228783f, 0.03488475f, 
    -0.06979235f, -0.05924043f, 0.02309963f, -0.01463954f, 0.12433079f, 0.00252224f, -0.02300935f, -0.13496995f, 
    0.07150219f, 0.15745854f, -0.18213239f, 0.15193430f, 0.04819957f, 0.03564276f, 0.01885803f, -0.14640324f, 
    -0.15491803f, 0.09524270f, 0.12811854f, 0.08407908f, 0.06956330f, 0.02643422f, 0.03273594f, -0.01679120f, 
    0.02693857f, -0.11489002f, 0.04450258f, 0.00989921f, 0.05936906f, 0.10081739f, -0.10457719f, 0.00913544f, 
    0.03040098f, 0.03585738f, 0.01412182f, 0.02528603f, -0.03528737f, 0.05796502f, 0.06184207f, 0.06022131f, 
    -0.07059933f, 0.00787854f, 0.13288200f, -0.14237258f, 0.09662777f, -0.08245314f, 0.03713080f, -0.03511746f, 
    0.15699676f, 0.04970513f, 0.11924537f, 0.00769063f, 0.27916291f, -0.06227449f, 0.04821394f, -0.22486390f, 
    0.01634616f, -0.03790545f, 0.06107880f, -0.15760244f, 0.05087331f, 0.00978747f, 0.11075842f, -0.09103537f, 
    -0.46492231f, 0.13598816f, 0.17712241f, 0.11080319f, 0.04891391f, 0.02163197f, 0.15536572f, -0.04137075f, 
    -0.00340526f, -0.03291793f, 0.08907396f, -0.14049779f, 0.23162982f, -0.13885981f, -0.08707264f, 0.03998024f, 
    -0.02034391f, -0.06723677f, -0.00270366f, -0.00369467f, 0.15962660f, 0.02769684f, -0.06325903f, -0.03296344f, 
    0.14274985f, 0.15767808f, 0.08426004f, -0.14227535f, 0.02788850f, -0.11598188f, 0.01444319f, -0.05364766f, 
    0.00888132f, -0.06451931f, -0.01144359f, -0.11790980f, 0.10072795f, 0.11413346f, -0.07741197f, 0.06639460f, 
    0.07447329f, 0.04296323f, 0.03280605f, 0.03169589f, 0.09094467f, 0.00912869f, 0.05228294f, -0.00047249f, 
    0.22348098f, -0.13154854f, 0.00056416f, 0.20848632f, 0.01484594f, -0.00955007f, 0.05375171f, -0.04835080f, 
    -0.11503755f, 0.04465790f, -0.04791683f, -0.07141251f, -0.07641548f, 0.09434626f, 0.11928029f, -0.22849458f, 
    0.03981256f, 0.12794003f, -0.00237156f, -0.05747488f, -0.04039377f, -0.07872773f, 0.02617502f, 0.07571538f, 
    0.03397112f, 0.04488535f, -0.01980975f, 0.16479662f, 0.02506823f, 0.06303148f, 0.03024338f, -0.06874120f, 
    0.06857061f, 0.07412797f, 0.08825572f, 0.00646547f, -0.20382932f, 0.24727026f, -0.01851715f, -0.19196311f, 
    0.14070758f, -0.02728664f, 0.03185211f, -0.08106060f, 0.07874108f, 0.03346357f, 0.00847059f, 0.09677892f, 
    -0.00379341f, -0.36863086f, -0.08991285f, 0.35010862f, -0.00040245f, -0.06840749f, 0.12309955f, -0.09602004f, 
    -0.14562203f, 0.11369152f, 0.04793227f, 0.07717102f, 0.26196563f, -0.08219153f, -0.03117230f, 0.00658634f, 
    -0.03503789f, 0.01519781f, -0.01869946f, 0.06396134f, 0.01880740f, -0.04645973f, -0.01457476f, -0.00117404f, 
    0.09259885f, -0.00212600f, -0.11205020f, -0.13759805f, 0.09414987f, -0.01057931f, 0.15422761f, 0.20724382f, 
    0.01332544f, 0.12594125f, 0.08900981f, 0.00415903f, 0.13762601f, 0.08398487f, 0.16135578f, 0.10505163f, 
    -0.00965550f, 0.10388528f, 0.03476220f, 0.05377965f, 0.10767595f, 0.12156767f, 0.08230224f, 0.00031163f, 
    -0.01081231f, 0.25559404f, -0.07818677f, 0.14251125f, 0.01748053f, -0.15113558f, 0.03837322f, -0.02473699f, 
    0.04963875f, -0.01926504f, -0.04756469f, -0.10121428f, -0.07958762f, 0.17990871f, -0.05346473f, -0.03959621f, 
    0.05319809f, 0.00901396f, -0.03572815f, -0.01192686f, -0.04481877f, -0.03833617f, -0.07317174f, 0.08501680f, 
    -0.07862552f, -0.19764632f, 0.18894297f, 0.18221231f, 0.10752457f, -0.09668801f, -0.03336084f, -0.04665085f, 
    -0.02954367f, 0.10198390f, 0.00498988f, 0.00788188f, 0.36565825f, -0.07582539f, -0.09609143f, 0.02825710f, 
    0.06805838f, 0.00065696f, 0.01111227f, -0.02799843f, -0.02490185f, -0.01539957f, 0.06581374f, 0.02510081f, 
    0.01337101f, 0.04919891f, -0.02045663f, -0.01019146f, 0.01224654f, 0.00074683f, -0.02857038f, -0.00674898f, 
    0.03488713f, -0.00650022f, 0.00817647f, 0.04732705f, -0.03007084f, -0.02831876f, 0.00820388f, -0.02698203f, 
    0.00164492f, 0.00451339f, 0.02360079f, 0.00886247f, -0.01769319f, 0.03735474f, 0.00754390f, -0.05350887f, 
    0.00725916f, -0.04024554f, -0.04164151f, -0.04831332f, 0.03630223f, -0.00567136f, -0.05086836f, 0.04172098f, 
    -0.03969751f, 0.03255724f, 0.00166728f, -0.04503462f, -0.04894476f, 0.04113221f, -0.02141396f, 0.00790856f, 
    0.03387662f, -0.03592100f, -0.03054479f, -0.04440304f, -0.01744292f, -0.00054123f, -0.02290396f, 0.02583111f, 
    0.03162647f, -0.02346998f, -0.00344550f, -0.03975325f, 0.04449518f, 0.02448498f, -0.01295294f, -0.01556267f, 
    -0.04757204f, -0.01676925f, 0.02353034f, -0.02529144f, -0.01971496f, -0.00658595f, -0.04482048f, 0.01670416f, 
    -0.00835282f, -0.02592184f, 0.03772754f, 0.04134458f, -0.05427234f, -0.04240013f, -0.03905784f, 0.00440413f, 
    -0.03951679f, 0.02744468f, 0.01187799f, -0.03535582f, 0.01458570f, 0.01773843f, 0.01434775f, 0.01004440f, 
    0.03236722f, -0.01070182f, -0.00124764f, -0.03245279f, -0.00874231f, -0.04627092f, -0.01717238f, -0.00350610f, 
    -0.00612678f, 0.00587655f, 0.01106218f, 0.02019992f, -0.03520881f, -0.00126335f, 0.04349994f, -0.00563393f, 
    0.00320601f, -0.04341921f, -0.01371015f, -0.03731904f, 0.01262140f, 0.03092540f, -0.05073332f, -0.02099549f, 
    -0.01791780f, -0.01829384f, -0.01147388f, -0.03776082f, -0.00882282f, 0.03789027f, -0.03693034f, -0.04414435f, 
    -0.01907756f, -0.00505167f, 0.04174703f, -0.02012056f, -0.02330052f, 0.01944586f, -0.04093926f, 0.01934199f, 
    -0.00837388f, -0.00358483f, 0.01292085f, -0.04401357f, -0.03523458f, 0.04278549f, -0.01600923f, 0.01120454f, 
    -0.00578162f, -0.00516965f, 0.02968352f, 0.00210682f, 0.03329517f, 0.03123089f, 0.00547492f, -0.03594146f, 
    0.02807738f, -0.05063551f, 0.02695254f, -0.04567590f, -0.01327917f, 0.00690616f, -0.01386358f, 0.00464677f, 
    -0.02585584f, -0.01097124f, 0.03150369f, -0.02937493f, 0.02363880f, -0.04949946f, -0.01367345f, 0.04047776f, 
    0.03026859f, -0.04523018f, 0.03243214f, -0.03003138f, -0.01070063f, 0.01136036f, -0.02532314f, -0.02998479f, 
    0.00998248f, -0.00798593f, 0.01176792f, 0.00640184f, -0.01243207f, -0.02144135f, -0.02572157f, 0.03873952f, 
    0.02134623f, -0.03912154f, -0.05723802f, 0.03440217f, -0.02601269f, -0.05207174f, -0.00475925f, 0.03419822f, 
    0.03316051f, 0.02344768f, 0.02408326f, 0.03061537f, 0.03312498f, 0.02472136f, -0.04902941f, -0.00171940f, 
    0.00530126f, 0.00723246f, -0.01567823f, 0.04361147f, 0.03810612f, 0.04512957f, 0.04448713f, 0.04071283f, 
    -0.03472054f, 0.02709992f, 0.04746244f, 0.01399691f, -0.00075538f, -0.02288298f, -0.02715777f, 0.03915510f, 
    -0.00393257f, -0.01789112f, 0.03802391f, 0.01752094f, 0.01416650f, -0.02749825f, 0.02238506f, -0.04847550f, 
    0.00724520f, -0.04659389f, 0.02750173f, 0.02877752f, 0.02495944f, -0.00561247f, 0.03148863f, -0.01927937f, 
    -0.03782427f, 0.01004362f, -0.05015612f, -0.04477983f, -0.02454748f, 0.01943262f, -0.00204422f, -0.04368683f, 
    -0.02493900f, 0.03142709f, -0.04571515f, 0.00604545f, -0.02103074f, -0.04950004f, -0.03658096f, 0.01754380f, 
    -0.00280870f, 0.03495714f, -0.02601340f, -0.03895800f, 0.04764080f, -0.03668388f, 0.00157700f, -0.04121288f, 
    -0.04556822f, -0.04685147f, 0.00948005f, -0.03714764f, 0.00908267f, -0.01413723f, -0.00529737f, -0.00841147f, 
    -0.05105917f, 0.04186098f, 0.00888052f, -0.03509904f, -0.05315578f, 0.02289188f, -0.03046568f, -0.04654774f, 
    0.00097494f, -0.04062611f, -0.02228215f, 0.00853275f, 0.02018324f, -0.00148118f, 0.01663222f, -0.01337397f, 
    -0.01294562f, 0.01127376f, -0.00581223f, -0.02241112f, 0.04478219f, -0.03617653f, 0.00802324f, -0.04658760f, 
    -0.01697905f, 0.04527164f, -0.05217095f, -0.05806861f, -0.00659741f, 0.02914339f, 0.02343425f, -0.02894711f, 
    -0.02678232f, 0.00572267f, 0.00317289f, 0.01715506f, 0.03382050f, 0.01661685f, 0.00267485f, -0.02654232f, 
    -0.00758420f, -0.04631516f, -0.00307971f, -0.03592097f, 0.00226236f, -0.04542855f, -0.00853148f, -0.05801695f, 
    0.03668744f, 0.01937869f, -0.01736606f, -0.01253554f, 0.00055322f, -0.01872643f, 0.01910413f, -0.00076176f, 
    -0.03789647f, -0.03601922f, 0.01409622f, 0.01840967f, -0.02476867f, 0.00018349f, 0.03532967f, 0.03646270f, 
    -0.01388712f, 0.02893187f, 0.01121690f, 0.04432082f, 0.02691715f, -0.01528821f, -0.05211370f, 0.02302501f, 
    -0.01875096f, -0.03718370f, -0.00605581f, 0.03093016f, -0.02711937f, 0.03269367f, -0.02331825f, -0.01471471f, 
    -0.02435295f, 0.00906292f, -0.01480141f, -0.04766757f, -0.01376290f, 0.01662399f, 0.01252887f, -0.05009689f, 
    0.00556179f, -0.00190365f, 0.04981496f, 0.01477274f, -0.01421126f, -0.02054522f, -0.01131359f, 0.02264718f, 
    0.00675961f, 0.01686149f, 0.01394934f, -0.02081045f, -0.01491257f, -0.03048289f, -0.05673353f, -0.02225525f, 
    0.00289402f, 0.04213313f, -0.04892904f, -0.02784020f, -0.03408862f, -0.04392541f, -0.00988667f, -0.02288643f, 
    -0.02836683f, -0.05052660f, -0.04460024f, 0.00417470f, 0.04027039f, 0.03499484f, -0.02031514f, -0.02439900f, 
    0.01415016f, 0.04056802f, -0.03695418f, 0.02195240f, 0.04336226f, -0.00524604f, 0.03029981f, -0.02977006f, 
    0.04157385f, -0.01368045f, 0.01088270f, -0.03635969f, -0.04026825f, 0.03463307f, 0.02640947f, -0.04925682f, 
    0.39818528f, -0.05931056f, -0.06857180f, 0.12671064f, -0.01253520f, 0.01157065f, 0.07558537f, 0.00201364f, 
    -0.11670211f, -0.03233116f, -0.01456204f, 0.07925931f, 0.02323975f, 0.18670139f, 0.09463112f, 0.05626312f, 
    0.09071953f, 0.10386644f, -0.04478357f, 0.04742754f, 0.05584256f, -0.04311911f, 0.00884572f, 0.01333174f, 
    0.12689349f, 0.05331262f, -0.16142540f, -0.02952841f, 0.09348745f, 0.14378318f, 0.04655663f, 0.00522466f, 
    0.02096211f, 0.02525097f, -0.11457710f, -0.06842597f, 0.30390987f, -0.03118718f, -0.01774224f, -0.21922943f, 
    -0.04935914f, -0.11202460f, -0.00148721f, 0.00568504f, -0.17617957f, -0.01261826f, 0.08346485f, -0.11294726f, 
    0.12164173f, -0.04735151f, 0.03733099f, 0.21733031f, 0.06346718f, 0.07086482f, -0.07164296f, -0.01675943f, 
    -0.02728109f, 0.02292965f, 0.05665411f, 0.08176938f, 0.19672319f, -0.34119606f, 0.02466570f, 0.03692668f, 
    0.07021140f, -0.04043124f, 0.09038161f, 0.00087406f, 0.02082647f, -0.00760180f, -0.06445134f, -0.00028930f, 
    -0.15986821f, -0.16438752f, -0.08478955f, -0.12628737f, 0.10409368f, 0.03674192f, -0.03603809f, 0.05617515f, 
    -0.11691348f, 0.11915050f, -0.06283624f, 0.01983099f, -0.20725916f, 0.03086902f, -0.00204075f, -0.09045292f, 
    0.06239489f, 0.04558213f, 0.01082836f, 0.10422253f, 0.04912459f, -0.12461674f, -0.16660936f, 0.05880668f, 
    0.15103495f, 0.00095458f, -0.10287836f, -0.20986408f, 0.06044728f, 0.07929163f, -0.05711052f, -0.03237952f, 
    -0.00504391f, 0.01498418f, 0.15678915f, 0.04100054f, -0.24492277f, 0.14333375f, 0.03432742f, 0.15393215f, 
    0.07196733f, 0.08450340f, 0.08728059f, 0.25657564f, 0.11436944f, 0.00340499f, 0.16183774f, 0.16930954f, 
    0.13519983f, -0.00349119f, -0.16058443f, 0.15814583f, 0.04820269f, -0.00720073f, -0.04497783f, 0.04013438f, 
    0.00981571f, 0.00906482f, -0.06944291f, -0.04645517f, 0.21505411f, 0.01226014f, 0.15074340f, 0.27075729f, 
    -0.02353026f, -0.00686387f, 0.02393958f, -0.06655964f, 0.06061681f, 0.04739795f, 0.09193479f, 0.07897516f, 
    -0.04629913f, 0.05779156f, 0.09097442f, 0.09917022f, 0.09923034f, 0.08673305f, -0.13798216f, -0.00680508f, 
    -0.13638060f, 0.14048800f, 0.07208765f, 0.00248211f, 0.15171953f, 0.23965025f, -0.00622260f, -0.04961037f, 
    -0.01582803f, 0.01667906f, 0.01442712f, -0.04587888f, 0.04191662f, -0.05643654f, -0.15082550f, -0.12663069f, 
    0.36186609f, -0.05904624f, 0.04168036f, -0.12633020f, 0.05336708f, 0.08614414f, 0.10536811f, -0.13910967f, 
    0.05871665f, 0.08958027f, -0.04205156f, 0.13441700f, 0.19855389f, -0.24034393f, -0.00428643f, -0.12854691f, 
    0.05865824f, 0.10576108f, 0.02500695f, 0.06623644f, 0.00686155f, 0.01828439f, -0.08675937f, 0.13331451f, 
    0.04417112f, -0.09178690f, 0.10442929f, 0.20531587f, 0.09105600f, -0.04490996f, 0.01308799f, 0.11094082f, 
    0.06864776f, 0.07311714f, -0.06287182f, 0.04720285f, 0.23736976f, 0.02780076f, 0.00364750f, 0.12638293f, 
    -0.10674180f, 0.06500499f, 0.04092108f, 0.10545443f, -0.09337708f, 0.01977512f, 0.05132570f, 0.05692441f, 
    -0.21527207f, -0.19304907f, -0.01756677f, -0.12039071f, 0.07089725f, -0.03353633f, -0.06105763f, 0.01740630f, 
    0.14514895f, 0.09508691f, 0.07270815f, 0.21341312f, 0.09443289f, -0.00394859f, -0.24437778f, 0.00357856f, 
    0.01554901f, -0.10041390f, 0.07105345f, -0.06097232f, -0.03785876f, 0.08246829f, -0.04079891f, 0.10946328f, 
    0.13834976f, 0.09683552f, -0.11650740f, -0.07764535f, 0.02890693f, 0.16197209f, -0.07303203f, -0.03606394f, 
    0.12434521f, -0.05970845f, -0.01288590f, 0.03755622f, -0.26892695f, 0.16341920f, 0.02054135f, -0.08971237f, 
    -0.00657787f, -0.03478700f, 0.03375047f, 0.05745016f, 0.05223933f, 0.08048968f, -0.05456426f, 0.00324598f, 
    0.04202441f, -0.02981192f, 0.05033780f, -0.04712540f, -0.05257631f, -0.00534286f, -0.00633172f, 0.02446242f, 
    -0.08681819f, 0.15022549f, -0.05721216f, 0.06471990f, -0.06815141f, 0.00506599f, -0.17467470f, -0.28785303f, 
    -0.01191493f, -0.00561787f, -0.02405064f, -0.01126541f, 0.02453608f, -0.04734756f, -0.01006807f, -0.18668981f, 
    -0.44163767f, -0.07045334f, 0.06249673f, -0.04129400f, 0.05900616f, 0.12063055f, -0.00776496f, 0.08390488f, 
    0.10901630f, 0.06658135f, -0.04177697f, 0.00752965f, 0.30400655f, -0.19917597f, -0.01773554f, -0.08859810f, 
    0.01165802f, 0.05904826f, 0.03748885f, 0.13760231f, 0.00460859f, -0.03609411f, 0.02594152f, 0.05788331f, 
    0.60602897f, 0.08150127f, 0.16037795f, 0.06417341f, -0.07815778f, 0.03458411f, -0.06088218f, -0.13288288f, 
    0.02510196f, 0.02840214f, 0.09904037f, -0.08579484f, 0.25319129f, 0.04997016f, -0.12858862f, 0.08560847f, 
    -0.06609069f, 0.05592539f, -0.10268203f, 0.00489362f, 0.02029398f, -0.08834641f, 0.02575725f, 0.06976041f, 
    -0.04510731f, -0.00934161f, -0.08435731f, 0.04484741f, 0.02372073f, 0.01712745f, 0.08095798f, 0.19291905f, 
    -0.06323729f, 0.06959299f, 0.04344653f, -0.01789293f, 0.13452454f, -0.01537844f, -0.05557970f, -0.13263831f, 
    0.04782465f, -0.03218783f, -0.06835978f, -0.00791475f, 0.11778744f, -0.00221167f, -0.03617108f, -0.10732865f, 
    0.05402812f, 0.16023904f, 0.07730075f, 0.05362604f, -0.04670162f, 0.08781876f, -0.13871160f, -0.05047084f, 
    0.01659542f, -0.11095889f, 0.18186671f, 0.01591813f, -0.06720447f, -0.21464530f, 0.01677454f, 0.26625341f, 
    0.10950983f, -0.09386583f, -0.02713746f, 0.09356946f, -0.01909991f, 0.08454619f, 0.06504904f, -0.04005074f, 
    0.02358221f, 0.01207403f, -0.02315483f, 0.02190070f, 0.03185065f, 0.02687253f, -0.02717533f, 0.01622075f, 
    0.03571058f, -0.03743888f, -0.00985618f, 0.00018457f, -0.02632158f, -0.00775620f, 0.00330516f, 0.02313114f, 
    0.01970700f, 0.00755395f, -0.04850350f, -0.05194528f, 0.03999627f, -0.03788711f, 0.00164525f, -0.03326989f, 
    0.00917170f, -0.02006303f, -0.01400401f, 0.02044060f, 0.00210737f, 0.03038898f, -0.03803803f, 0.00683286f, 
    -0.02810446f, 0.02800688f, -0.01534479f, 0.02422131f, -0.04385009f, -0.02367271f, 0.01687111f, -0.00658577f, 
    0.03863586f, -0.04451272f, 0.02516342f, -0.04336286f, -0.04846239f, 0.03288571f, -0.02651708f, 0.01510461f, 
    -0.04196183f, 0.02926261f, -0.04082964f, 0.03369778f, -0.00851207f, -0.04807168f, -0.00085579f, 0.04165036f, 
    -0.05372849f, 0.03671268f, 0.01598126f, -0.00243856f, -0.03014421f, -0.00617300f, 0.05530623f, -0.02399337f, 
    -0.03751599f, 0.03457674f, 0.03422138f, 0.00188965f, -0.04474057f, 0.04125200f, -0.02263777f, 0.00025090f, 
    -0.04139379f, 0.00149233f, -0.03522157f, 0.00265476f, -0.01336869f, 0.02028553f, 0.01165524f, -0.00846913f, 
    0.03930852f, -0.02332540f, -0.02114972f, -0.01391870f, 0.00266655f, 0.00457171f, -0.03727318f, 0.02673928f, 
    0.02832012f, 0.01462717f, -0.03945607f, -0.02965569f, 0.00283520f, -0.00840190f, 0.00381827f, -0.03593309f, 
    -0.01342241f, 0.00049624f, -0.05790457f, -0.01673729f, 0.00505973f, -0.03049855f, -0.03861236f, -0.00177474f, 
    0.01213273f, -0.03277636f, -0.02835062f, -0.03243156f, -0.02196398f, 0.01518383f, -0.02813002f, -0.05288987f, 
    -0.03945751f, -0.02063324f, 0.00277488f, 0.03843260f, 0.00269584f, -0.03738661f, -0.00704724f, 0.00974424f, 
    -0.01242990f, 0.01126343f, 0.04393221f, -0.01108124f, -0.02960542f, -0.02853172f, 0.03462476f, 0.04617012f, 
    0.03274710f, 0.03903924f, -0.01220004f, 0.03450591f, -0.01508487f, -0.00892053f, -0.02810589f, 0.03196216f, 
    0.01040125f, -0.02059661f, -0.03421023f, 0.04303569f, 0.00221334f, -0.02089254f, 0.00974415f, -0.04308285f, 
    0.03031981f, -0.04228454f, -0.03265350f, 0.00396047f, -0.05379044f, -0.03276992f, -0.02526444f, -0.00784217f, 
    0.02555638f, -0.00772623f, 0.00113338f, -0.03239667f, -0.04022119f, 0.01945042f, -0.03277033f, -0.00288931f, 
    0.01478917f, 0.03522336f, 0.02168806f, -0.05703612f, 0.03209037f, -0.04206291f, -0.03108739f, 0.00967481f, 
    0.04253800f, 0.03295773f, 0.04366744f, -0.00931290f, -0.03123515f, -0.00419854f, -0.03482886f, 0.00702025f, 
    -0.02360998f, -0.03679467f, 0.01971320f, 0.02897742f, 0.00376265f, 0.02771365f, -0.03775622f, 0.03654092f, 
    -0.02479169f, -0.04252089f, 0.02413697f, -0.04367120f, 0.02669204f, -0.01627208f, 0.02133860f, -0.02139596f, 
    0.02870290f, -0.03206621f, -0.01879828f, 0.01701849f, 0.01144996f, -0.05276056f, 0.03572166f, 0.01457709f, 
    -0.05432765f, 0.03733453f, 0.04135459f, -0.03054557f, 0.02750338f, -0.01283243f, 0.02994191f, -0.00615593f, 
    -0.05221142f, 0.03750832f, 0.04342047f, 0.03300388f, -0.00578780f, 0.02678178f, -0.05854209f, 0.01390831f, 
    0.00455212f, -0.00430326f, -0.03185548f, -0.04751647f, -0.00423484f, 0.01418585f, 0.02447412f, -0.03951956f, 
    0.01799251f, -0.04113934f, -0.00030249f, -0.01956050f, 0.01807638f, 0.01232874f, 0.01637099f, -0.04352719f, 
    -0.00300087f, -0.00929695f, -0.00641168f, -0.00375562f, -0.03081406f, 0.03015889f, -0.00768672f, -0.02992793f, 
    0.02864918f, -0.05553195f, -0.02139595f, -0.04993948f, -0.04640143f, 0.00861894f, 0.04369223f, -0.02613715f, 
    -0.04821004f, -0.00546975f, 0.01090584f, 0.00109512f, -0.04431453f, 0.01527485f, -0.00404659f, 0.01161872f, 
    -0.01882883f, -0.04815333f, -0.04446171f, -0.01347034f, -0.05508008f, -0.02571066f, 0.00569013f, 0.03280704f, 
    0.01462714f, -0.04709704f, -0.01827466f, -0.02556877f, 0.04373288f, 0.01570288f, 0.04155898f, -0.02833609f, 
    0.01454129f, 0.00286523f, -0.04674922f, -0.04961444f, -0.05298972f, 0.03631233f, 0.00046866f, -0.02298935f, 
    -0.02050293f, 0.02338257f, -0.02667524f, 0.02682474f, -0.03286694f, -0.02446575f, -0.00915345f, 0.03888984f, 
    -0.04536665f, 0.02076454f, -0.05628904f, -0.04120746f, -0.04060653f, 0.00220996f, -0.04087681f, 0.04020211f, 
    0.01005152f, -0.03178814f, -0.02012396f, 0.03181114f, 0.01289163f, 0.00132084f, -0.01056214f, 0.01037890f, 
    0.04571973f, 0.02461401f, -0.02987503f, -0.02374799f, 0.04310514f, -0.03527347f, 0.00902128f, 0.02219968f, 
    -0.02056924f, -0.04536283f, -0.04199046f, -0.01240381f, -0.01430256f, -0.04930296f, -0.01475298f, -0.00751997f, 
    0.03864416f, -0.03020461f, -0.02803567f, 0.03879891f, -0.03813372f, -0.01378162f, 0.04131342f, -0.01857788f, 
    0.02437269f, 0.04182752f, 0.03712175f, 0.02737621f, -0.03569663f, -0.03663340f, -0.04794424f, 0.00717665f, 
    -0.00254275f, -0.01036385f, -0.01707085f, 0.00787456f, -0.04578524f, 0.01367137f, -0.05652408f, -0.05394540f, 
    -0.05882240f, -0.03298654f, -0.03773122f, 0.03348834f, 0.03395268f, 0.01359266f, 0.01474025f, -0.03336356f, 
    0.03813804f, 0.03032945f, -0.03690538f, -0.01186839f, -0.04216744f, -0.02013920f, -0.00619016f, 0.01565641f, 
    -0.01031325f, 0.02972225f, -0.03952513f, -0.03445123f, 0.03585826f, 0.01214553f, -0.04359978f, -0.02194093f, 
    0.00390919f, 0.03174488f, -0.00184590f, 0.03606421f, 0.00019672f, -0.02257652f, -0.04495036f, 0.03048315f, 
    -0.04176851f, 0.02586095f, 0.00561239f, 0.02901943f, -0.03193210f, -0.03819209f, -0.04654041f, -0.02715845f, 
    -0.32781667f, 0.09800785f, 0.06531627f, 0.15723430f, 0.16341990f, 0.07979432f, 0.12871143f, -0.09134830f, 
    0.06148380f, -0.01785411f, 0.03869628f, 0.03772845f, -0.04124674f, -0.00962919f, 0.09895747f, -0.04376141f, 
    -0.06643327f, -0.02584353f, -0.03792167f, 0.06560072f, 0.02316055f, 0.02927092f, 0.01346168f, 0.13066663f, 
    -0.18078642f, -0.07183044f, 0.23790020f, 0.25329572f, -0.00218154f, -0.07580899f, 0.02830601f, 0.09859657f, 
    0.03132244f, 0.05203746f, 0.08315560f, 0.09641249f, 0.05846739f, 0.07880525f, -0.11138221f, 0.20566395f, 
    0.20789944f, 0.19656572f, 0.02578939f, -0.01571747f, 0.02335237f, 0.07438726f, 0.05577427f, 0.07882717f, 
    -0.21169330f, -0.06118108f, 0.08545507f, 0.10186668f, -0.04746012f, -0.03029772f, -0.01774092f, 0.05468834f, 
    0.12712294f, -0.01821133f, 0.06316052f, 0.02493484f, -0.23082718f, 0.10246245f, -0.03752764f, -0.18064822f, 
    0.13456970f, -0.04354764f, -0.05913456f, 0.09516627f, -0.02128728f, 0.04808968f, -0.01643442f, -0.09617756f, 
    0.24601495f, 0.10597523f, -0.07919261f, 0.16649541f, -0.08639086f, -0.06334440f, 0.09732290f, -0.07993376f, 
    0.06331223f, -0.05872030f, -0.03159956f, -0.02456718f, 0.12637694f, -0.03207473f, 0.09518687f, 0.00573455f, 
    -0.11323410f, 0.04577131f, 0.09519511f, -0.08984158f, -0.03013454f, -0.00570602f, 0.04849682f, -0.06290315f, 
    0.04979543f, -0.16926265f, 0.11342390f, 0.03521107f, -0.15349151f, -0.04015088f, -0.03175944f, 0.00998364f, 
    0.04051203f, -0.04868271f, 0.01029828f, -0.03924725f, 0.18471588f, -0.05932784f, 0.00508132f, -0.12633075f, 
    -0.00138221f, 0.06324968f, -0.10554563f, -0.15843928f, -0.05853502f, -0.00521183f, 0.06708756f, -0.07669955f, 
    -0.22640154f, 0.08848082f, 0.25497693f, -0.05156138f, -0.05437997f, -0.00300733f, -0.03116472f, -0.02726533f, 
    -0.01465199f, -0.05260447f, 0.06911779f, -0.00540581f, -0.09689776f, 0.22002223f, -0.09608426f, 0.10830728f, 
    0.16964182f, 0.06322851f, -0.11781058f, -0.03670460f, -0.10477135f, 0.08456035f, -0.00812317f, 0.04816597f, 
    0.10620170f, -0.12796359f, 0.06031057f, 0.00526329f, -0.05453013f, -0.04048916f, -0.08466120f, 0.05014404f, 
    0.10823370f, -0.09363315f, -0.03578670f, 0.00867651f, -0.09792753f, 0.03579468f, 0.01624136f, 0.12541179f, 
    0.08948202f, 0.03244092f, 0.10027204f, -0.02509671f, 0.02603401f, 0.06993596f, 0.07630525f, 0.14304423f, 
    -0.46735722f, 0.26613739f, -0.13920335f, 0.07987777f, 0.03112943f, -0.01035458f, -0.02594708f, 0.06747993f, 
    -0.01807335f, 0.00840475f, -0.14702994f, -0.04920172f, -0.27288640f, 0.22321396f, 0.05760869f, -0.19965830f, 
    0.10948169f, -0.01972586f, -0.02188360f, -0.03651102f, -0.02280082f, -0.02534318f, 0.01925768f, -0.03614672f, 
    -0.04069505f, 0.27645907f, 0.19861484f, -0.02149696f, -0.07944571f, 0.01607609f, 0.05768905f, -0.00411386f, 
    -0.04912626f, -0.07978963f, 0.08336373f, -0.00034167f, -0.04055185f, 0.12719828f, 0.16348308f, 0.00583481f, 
    0.10803796f, 0.04722536f, 0.06448572f, 0.04331373f, 0.03793431f, 0.05570933f, 0.05430666f, -0.03511555f, 
    -0.21732520f, 0.08734784f, 0.01406602f, -0.00754590f, 0.09110231f, 0.03847850f, 0.04238379f, 0.04966513f, 
    0.01335100f, 0.04943714f, -0.00543816f, -0.03446109f, 0.09047424f, -0.03949466f, 0.23168296f, 0.32030392f, 
    0.06840257f, 0.06939138f, 0.04028726f, 0.08457377f, -0.03828527f, 0.05839951f, 0.01468860f, -0.01701917f, 
    0.12143922f, -0.26146626f, 0.19681042f, 0.21831059f, 0.00583538f, -0.02472650f, 0.10317658f, 0.07970949f, 
    -0.14388286f, 0.03309922f, -0.04659518f, -0.03252625f, 0.01301539f, -0.01723143f, 0.02379979f, -0.01144817f, 
    -0.02456557f, -0.01113347f, 0.07598099f, 0.02338472f, 0.09747035f, 0.04057400f, -0.02802006f, -0.08330172f, 
    -0.11503562f, -0.06212974f, -0.13886581f, 0.02056723f, 0.23575966f, -0.02112659f, 0.03586959f, 0.06027373f, 
    0.13013336f, -0.04329626f, 0.01968899f, 0.02921643f, 0.02687046f, 0.09789470f, -0.02451801f, -0.07016905f, 
    -0.05030312f, 0.05336073f, 0.01197620f, -0.00955021f, -0.07576998f, 0.02691629f, -0.01768862f, 0.02080703f, 
    0.27574268f, -0.13000070f, 0.10844991f, -0.06093657f, -0.01167010f, -0.06350732f, 0.07316975f, 0.05462256f, 
    0.02517829f, -0.00236088f, 0.04165372f, 0.01665170f, -0.07330013f, -0.17571081f, 0.19468294f, 0.12874225f, 
    -0.00949154f, -0.02915289f, -0.08043880f, -0.00967230f, -0.00437294f, 0.02466160f, -0.04024288f, 0.08085438f, 
    -0.43262646f, 0.05204747f, -0.12525383f, 0.04448695f, 0.13957271f, 0.04835533f, 0.05828340f, 0.07701281f, 
    -0.00956211f, -0.09194013f, 0.00467869f, 0.02411001f, -0.17664213f, 0.00765818f, -0.05031294f, 0.20564242f, 
    0.21236853f, 0.07454930f, 0.11899323f, 0.12806943f, 0.06647906f, 0.14153990f, -0.02364541f, -0.10045575f, 
    0.21007243f, 0.01318560f, -0.00321756f, 0.05246229f, 0.09841535f, 0.05190240f, -0.04439306f, -0.03845717f, 
    -0.00259715f, 0.08237517f, -0.00655589f, 0.01849649f, -0.10388780f, -0.05036858f, 0.13030051f, 0.01198843f, 
    -0.09687401f, -0.05223073f, 0.02557175f, 0.04288441f, -0.06132673f, -0.03469254f, 0.06948392f, 0.02139763f, 
    0.27291238f, -0.08261786f, -0.02650125f, 0.07912774f, 0.08849251f, -0.14544299f, 0.01565423f, 0.03306055f, 
    0.01226520f, 0.04463971f, -0.02282028f, -0.04561875f, -0.00617568f, -0.02560960f, -0.03858228f, 0.03046315f, 
    -0.00481217f, 0.04880810f, -0.02294539f, 0.00049335f, 0.02841162f, 0.00175041f, 0.11460940f, -0.10493075f, 
    -0.32982755f, -0.00702827f, 0.15683110f, 0.01439210f, -0.02994045f, 0.10054287f, 0.09768824f, -0.14676233f, 
    0.05563361f, 0.06680535f, 0.01097620f, -0.01416960f, -0.34591711f, 0.11428766f, -0.01655326f, 0.13038678f, 
    -0.01916088f, 0.00488087f, -0.06934164f, 0.14054787f, -0.00745895f, -0.02357640f, 0.04964994f, 0.00830999f, 
    -0.19137520f, -0.01825827f, 0.03806529f, 0.18948698f, -0.05995739f, -0.00382107f, -0.11105613f, 0.08854714f, 
    0.03381276f, -0.00808143f, 0.09943104f, 0.07820754f, -0.28645107f, 0.00045511f, 0.07679277f, -0.06568839f, 
    0.17673753f, 0.18960929f, 0.01750372f, 0.03939952f, 0.03704519f, 0.11739794f, 0.02495145f, 0.06629197f, 
    -0.23016529f, 0.18248862f, -0.03601398f, 0.06444494f, -0.05231102f, -0.06168902f, 0.11925066f, 0.08402592f, 
    -0.00050548f, 0.09409215f, 0.05465120f, 0.04422319f, -0.35790214f, -0.05654776f, 0.03958187f, -0.08694437f, 
    -0.03071962f, 0.03210798f, 0.09732296f, 0.01403111f, -0.02446870f, 0.03460309f, 0.07880192f, -0.08203479f, 
    0.13213691f, 0.22784971f, 0.01621960f, 0.06411437f, -0.13237116f, 0.03531826f, 0.06125838f, 0.09677882f, 
    0.08038830f, -0.03343681f, 0.10010672f, 0.06005992f, 0.01373434f, 0.06123671f, 0.13769081f, 0.02802415f, 
    0.08272113f, 0.06220336f, -0.08771104f, -0.04227742f, 0.02858906f, 0.00398972f, 0.08908685f, -0.08527007f, 
    0.04321888f, -0.00351181f, 0.21750566f, -0.14665794f, -0.03592900f, -0.08678582f, 0.03916094f, 0.01093967f, 
    0.02731296f, 0.03677815f, -0.01940648f, -0.02156623f, -0.18097378f, 0.00422874f, -0.00361072f, -0.07924573f, 
    0.03587649f, -0.05882792f, -0.12413130f, -0.03870765f, -0.08352234f, -0.05464014f, 0.03542172f, -0.04901849f, 
    0.00335817f, 0.02480997f, 0.10062116f, 0.01090473f, -0.03240220f, 0.05099273f, 0.00440349f, -0.01370578f, 
    0.07548608f, -0.03537191f, 0.02961711f, 0.06944410f, 0.14746858f, -0.07929667f, 0.10083584f, -0.19747403f, 
    0.15577255f, -0.02279106f, 0.02420109f, 0.09891949f, 0.02447040f, 0.03610580f, 0.08592709f, 0.03808903f, 
    -0.14515148f, -0.00316640f, -0.04271132f, -0.01686645f, -0.14407051f, 0.00647879f, -0.04227871f, 0.07782627f, 
    0.04243689f, -0.01076860f, 0.05742574f, -0.00430954f, -0.06369521f, 0.14402397f, -0.02362284f, -0.03313580f, 
    0.11076328f, -0.08472306f, 0.04650924f, -0.08955944f, -0.01235964f, -0.04789597f, 0.11363044f, 0.14884980f, 
    -0.23475830f, 0.20391370f, 0.05164892f, 0.01403498f, -0.06877086f, -0.06423960f, -0.02208734f, 0.05291576f, 
    -0.03395686f, -0.10095149f, 0.10895056f, -0.03749712f, 0.03435572f, 0.06009956f, 0.03354910f, -0.14096087f, 
    0.06025370f, 0.00638362f, 0.04227901f, -0.04482054f, -0.04251241f, -0.02489423f, 0.02735716f, -0.05669899f, 
    -0.10155356f, 0.26447207f, -0.01023831f, 0.22663268f, 0.02582938f, 0.01988929f, 0.03451937f, -0.00845527f, 
    0.08326060f, -0.03901675f, 0.01859491f, -0.06899849f, 0.06669579f, 0.07708675f, 0.04247653f, -0.05777061f, 
    0.10195851f, 0.02576933f, 0.01393269f, -0.03925660f, 0.08814725f, 0.16310565f, -0.10043440f, 0.03837158f, 
    -0.04071882f, -0.04552817f, 0.08572987f, -0.01459289f, -0.00095057f, -0.03937769f, 0.05769882f, -0.00919669f, 
    -0.12942056f, 0.00896637f, -0.07757211f, -0.03983492f, 0.14835735f, 0.08062866f, 0.01900972f, 0.09880926f, 
    -0.04324935f, 0.01848640f, -0.02292852f, 0.15805753f, 0.08473857f, -0.07445416f, 0.07990387f, 0.01125993f, 
    -0.02671376f, -0.19841260f, 0.16294488f, 0.26781756f, 0.00004637f, -0.06493010f, 0.12396449f, 0.02668595f, 
    -0.05391638f, -0.07563296f, -0.01888516f, 0.02287452f, -0.08509734f, 0.01358492f, 0.09254727f, -0.07600769f, 
    -0.03497959f, 0.06258449f, -0.01772283f, -0.01237225f, 0.04964289f, 0.06566075f, 0.03699623f, -0.08084917f, 
    0.00758111f, -0.05256598f, -0.03422396f, 0.08381997f, 0.02054434f, 0.08681098f, 0.04160719f, -0.12232266f, 
    0.02455358f, -0.03688965f, 0.07698094f, -0.04325374f, -0.00897628f, 0.22759770f, -0.05850963f, -0.12557523f, 
    -0.04154750f, 0.03105089f, 0.03502156f, 0.07368024f, 0.05669016f, 0.03988553f, 0.01199001f, 0.01643516f, 
    0.03294233f, 0.03614902f, -0.01296389f, 0.43838817f, 0.15219210f, -0.01395497f, -0.04070150f, -0.04768413f, 
    -0.01517589f, -0.05672652f, 0.05941951f, 0.06082377f, -0.13542454f, -0.22983159f, 0.26222423f, 0.21409552f, 
    0.04270491f, -0.04729064f, 0.04768047f, 0.03653080f, -0.06493662f, 0.01194757f, 0.02855375f, 0.11168737f, 
    -0.54303056f, 0.11554693f, 0.02738971f, -0.32561260f, 0.14450529f, 0.01470931f, 0.22693555f, 0.03130791f, 
    -0.05162804f, -0.10077851f, -0.05854132f, 0.02375431f, -0.18032143f, -0.01852940f, -0.11152829f, 0.05030481f, 
    0.06224496f, 0.14863630f, 0.09610017f, 0.02777382f, 0.05002033f, 0.08002903f, 0.00105247f, -0.00379726f, 
    -0.06725975f, 0.17343424f, -0.19287497f, 0.14632067f, -0.01289913f, -0.02911347f, -0.06776628f, -0.10973886f, 
    0.12341523f, -0.06950859f, -0.03356519f, 0.02659371f, -0.15577553f, 0.02746415f, 0.08064500f, -0.12223689f, 
    -0.13810594f, -0.04385953f, 0.00416270f, 0.06422675f, 0.04775909f, 0.04593351f, 0.07478855f, 0.03249692f, 
    0.05643609f, 0.05506377f, -0.02473190f, 0.22959907f, 0.01043043f, -0.09652101f, 0.06566639f, 0.06642764f, 
    -0.03836581f, 0.08680529f, 0.04827608f, -0.07259674f, -0.05655200f, -0.07252622f, 0.10745787f, 0.01111053f, 
    0.03643370f, 0.06135015f, -0.02572579f, -0.00697561f, -0.02413004f, 0.03419114f, 0.03616771f, 0.00049667f, 
    -0.19473565f, -0.18354174f, 0.03045000f, -0.23336264f, -0.03934891f, 0.09519585f, -0.08030506f, 0.04574781f, 
    0.03100773f, 0.04391677f, 0.08719088f, 0.20244518f, 0.33847630f, 0.17228116f, -0.26208007f, 0.17042860f, 
    -0.01378946f, -0.00463063f, 0.02607819f, 0.04999566f, -0.03034334f, -0.09901938f, 0.03181868f, -0.02556758f, 
    -0.16663532f, -0.05037182f, 0.03428606f, 0.02023097f, -0.01807034f, 0.00929834f, -0.00067556f, -0.10689656f, 
    0.09806179f, -0.03578085f, -0.00664221f, -0.04350574f, -0.15044190f, -0.12299580f, 0.08439460f, -0.05625121f, 
    -0.04848900f, 0.02944005f, 0.01470410f, 0.08297678f, 0.14777537f, 0.19865170f, 0.08569492f, -0.00689721f, 
    -0.00525075f, 0.07679243f, 0.08472656f, -0.00244629f, 0.01236288f, -0.02125489f, 0.05727778f, -0.01924820f, 
    -0.02754288f, 0.15722793f, 0.15462300f, 0.25967142f, -0.25833640f, -0.05559884f, 0.13640065f, 0.11911663f, 
    -0.03750667f, -0.05203907f, 0.01858120f, -0.11018992f, 0.00837359f, -0.07574557f, -0.07565733f, -0.05230490f, 
    0.07900354f, 0.11505233f, 0.11074828f, 0.22602904f, 0.03707380f, 0.16258344f, -0.00998646f, 0.08028804f, 
    0.15798680f, -0.18621096f, 0.12769523f, 0.07920618f, 0.12489116f, -0.01186842f, 0.00792028f, -0.06953634f, 
    0.05111125f, -0.02248508f, 0.00469101f, 0.00235044f, -0.05039786f, -0.10910562f, 0.19010915f, -0.12306577f, 
    -0.11465649f, -0.02365371f, 0.15757275f, 0.17166966f, 0.06499329f, 0.02370058f, 0.06051037f, -0.00535110f, 
    0.09323099f, 0.08096469f, 0.00654198f, -0.04265929f, -0.07999466f, 0.13654904f, -0.07424048f, 0.12221559f, 
    -0.00410044f, -0.00079274f, -0.08943450f, 0.05682906f, -0.11588009f, 0.13998814f, 0.11773794f, 0.06971259f, 
    0.54347247f, -0.10548679f, 0.26599792f, 0.14650916f, 0.05798051f, -0.08142484f, -0.02486086f, 0.02276771f, 
    -0.00526846f, -0.13474131f, -0.13874602f, -0.01819221f, 0.11206401f, -0.14513738f, 0.07219460f, -0.37179783f, 
    0.07217257f, 0.10895833f, 0.09888720f, 0.20337725f, 0.00122640f, 0.01681655f, 0.04997759f, 0.24252903f, 
    0.24948846f, 0.07569484f, -0.18860450f, 0.00587866f, -0.01836915f, 0.04957711f, 0.02762952f, -0.02930103f, 
    -0.02183161f, 0.09345011f, -0.03749808f, -0.04797407f, -0.08305871f, -0.03786355f, 0.00697034f, 0.05975663f, 
    0.11124178f, -0.07153647f, -0.01893031f, -0.07695554f, -0.03389757f, -0.08272433f, -0.02867191f, -0.09722444f, 
    0.00653352f, 0.00993086f, 0.02474376f, -0.02431108f, -0.03651361f, -0.00678624f, 0.08252772f, -0.09257758f, 
    -0.15597418f, -0.10927131f, 0.04413980f, -0.11955301f, -0.25816354f, -0.10859298f, 0.11861253f, 0.16967253f, 
    -0.04510935f, -0.05004201f, 0.21754427f, 0.08417292f, -0.01959435f, -0.03967140f, -0.03302307f, 0.02618366f, 
    0.46707022f, 0.00875167f, -0.32590970f, 0.00753302f, 0.00583604f, 0.02921120f, 0.01927462f, -0.01577133f, 
    0.02094269f, -0.04706877f, 0.04879938f, -0.06184617f, -0.13713555f, -0.04782426f, 0.12626280f, 0.02975148f, 
    0.13887070f, -0.11444549f, 0.09993262f, -0.02951349f, 0.01668033f, 0.11078466f, 0.00773407f, 0.06547654f, 
    0.03089966f, 0.01722210f, -0.07265781f, -0.02470797f, -0.03035717f, -0.03266395f, 0.14554989f, 0.04625950f, 
    -0.06700487f, 0.06246592f, 0.18572046f, -0.03065954f, -0.08316299f, -0.07643186f, -0.09687059f, 0.03669516f, 
    -0.00209928f, 0.06365554f, -0.04099976f, -0.03932314f, 0.04094656f, 0.11172707f, 0.03736939f, 0.08926682f, 
    -0.28785861f, -0.00691542f, -0.05007796f, 0.11176974f, 0.02252629f, -0.06014440f, 0.00816176f, -0.01371886f, 
    -0.05403943f, -0.06806853f, 0.00403622f, 0.11872248f, 0.12357775f, -0.02318246f, 0.00623310f, 0.04398162f, 
    0.00170401f, -0.00814710f, 0.06459713f, 0.00551855f, 0.16247551f, 0.18392654f, 0.01408607f, 0.01166864f, 
    -0.00991566f, -0.02899989f, 0.06631014f, -0.00869354f, -0.06077266f, 0.04128067f, 0.01876983f, -0.13799271f, 
    -0.13659316f, -0.07221125f, 0.02547824f, 0.04343613f, 0.22318742f, -0.11937428f, 0.05450784f, 0.36698681f, 
    0.04159586f, 0.08337581f, -0.04298804f, 0.08155230f, 0.04433718f, -0.11232729f, -0.07340005f, 0.00242949f, 
    0.38660288f, 0.28411797f, 0.07432602f, 0.11353313f, -0.00064908f, 0.03310648f, -0.05452809f, 0.08457895f, 
    0.04188292f, -0.04820469f, 0.11472175f, 0.13225672f, -0.00598759f, 0.07985962f, 0.06359247f, 0.12252524f, 
    0.07196806f, -0.06946775f, -0.05225431f, 0.12025574f, -0.14445087f, -0.02891597f, -0.02683304f, -0.02115528f, 
    -0.14868389f, 0.02673113f, 0.08580673f, -0.13533084f, 0.13673083f, -0.09115832f, 0.07918342f, 0.03301638f, 
    -0.03525342f, -0.01307263f, -0.00504400f, -0.07167882f, -0.14145733f, -0.15131292f, -0.00145494f, -0.06741077f, 
    0.07064921f, -0.08859946f, -0.01913965f, 0.00554316f, 0.04132501f, -0.06173568f, -0.10725388f, -0.08160840f, 
    -0.04664477f, 0.15810107f, 0.01128123f, 0.10148909f, -0.02412787f, 0.06619296f, -0.10598201f, 0.16615702f, 
    -0.01645547f, 0.14226440f, 0.17368653f, 0.12355517f, 0.27720827f, -0.15951373f, -0.01207070f, 0.25032300f, 
    -0.02488032f, 0.06402002f, 0.04440674f, 0.03017877f, 0.05229357f, -0.01069572f, 0.07654948f, -0.04831646f, 
    -0.01917127f, 0.03376227f, -0.16118084f, -0.06378752f, -0.00742328f, 0.02898140f, 0.02145547f, 0.10305741f, 
    -0.07703039f, 0.01807564f, -0.10136654f, -0.01554606f, -0.29449439f, 0.08276623f, 0.05374746f, 0.06373060f, 
    -0.05254703f, -0.00324195f, 0.02361840f, -0.06940818f, -0.05142666f, -0.06677520f, -0.04458658f, 0.03897529f, 
    0.03537752f, 0.02785315f, -0.02034949f, 0.03546186f, 0.01448319f, 0.04437289f, -0.03383547f, -0.01801161f, 
    0.02891557f, 0.02776061f, -0.02858115f, 0.01971814f, -0.06179966f, 0.01113502f, -0.04609651f, -0.01710261f, 
    0.00791684f, 0.02153824f, -0.03622478f, -0.02160317f, -0.02641967f, -0.02889741f, -0.03116997f, 0.00223247f, 
    -0.05357304f, -0.04962369f, -0.01954234f, 0.00917182f, -0.04739369f, 0.00268033f, 0.00323511f, -0.05370443f, 
    0.03506548f, -0.04036785f, -0.02325331f, -0.04916763f, -0.01593096f, -0.02769269f, -0.02133977f, 0.00652483f, 
    0.02345393f, 0.03518895f, -0.05061173f, 0.00588705f, 0.00507297f, -0.04737333f, -0.01389081f, 0.02440434f, 
    0.02698774f, 0.02157361f, -0.04852992f, 0.02686405f, -0.05106195f, -0.04385372f, 0.03678612f, 0.03081866f, 
    -0.01704939f, -0.04033006f, -0.00154984f, 0.01541162f, -0.04871968f, 0.00638568f, 0.04083637f, 0.00623774f, 
    0.02879343f, -0.00585621f, 0.03650258f, 0.04258330f, 0.01425587f, 0.02178720f, 0.01197075f, 0.02062976f, 
    0.00407362f, -0.05718208f, 0.03938741f, 0.03972851f, -0.00796788f, -0.03923282f, 0.00179340f, -0.02315052f, 
    -0.04259527f, 0.01304934f, -0.02526435f, 0.02649721f, -0.04374626f, 0.02616185f, -0.00584964f, -0.02877446f, 
    -0.02311944f, 0.02716939f, 0.00965405f, 0.03243776f, 0.04518215f, 0.02570094f, 0.00412746f, -0.04354097f, 
    -0.04332479f, 0.03121076f, -0.02735526f, -0.05961003f, -0.03202268f, -0.02933273f, -0.04660310f, -0.05551131f, 
    -0.02320742f, -0.03593427f, 0.00609776f, 0.02951841f, -0.03077963f, -0.00812578f, 0.04209571f, -0.04728907f, 
    -0.02950907f, -0.01577859f, 0.01845655f, -0.03935065f, -0.03695929f, 0.02212436f, -0.02824069f, 0.03431271f, 
    -0.02322611f, -0.02535579f, -0.05013645f, -0.05691631f, 0.04535593f, -0.00582315f, 0.00244408f, -0.00546908f, 
    -0.03067065f, -0.00100484f, 0.03771282f, 0.00605591f, 0.00868283f, 0.00364187f, 0.00324766f, -0.04239466f, 
    -0.01770625f, 0.01191842f, -0.05168486f, -0.04116964f, -0.04727403f, -0.05039684f, -0.04391437f, -0.01122241f, 
    -0.02582342f, 0.01057723f, -0.03519624f, 0.00998535f, 0.03374973f, 0.00913340f, -0.01444872f, -0.01063858f, 
    -0.00576858f, 0.01844730f, 0.00927217f, 0.02152195f, -0.05890169f, 0.01829614f, -0.02245408f, 0.02818906f, 
    0.02257048f, -0.04182905f, -0.00981347f, -0.04818932f, -0.05572680f, -0.00115056f, -0.00049100f, 0.02779074f, 
    0.01363783f, -0.01808227f, -0.03223652f, 0.03494392f, 0.00328887f, 0.03179440f, 0.02912465f, -0.02376896f, 
    -0.03412336f, -0.00273051f, 0.02499628f, 0.02656430f, -0.06028033f, 0.04152391f, 0.00541303f, -0.00614208f, 
    0.03979726f, 0.02287265f, 0.02284050f, 0.03114570f, -0.01831256f, 0.03991717f, -0.01690206f, -0.03618466f, 
    0.02472241f, -0.03963816f, 0.03665628f, 0.01159911f, -0.03387826f, -0.05998877f, -0.04113314f, -0.04659680f, 
    0.00698624f, -0.03147303f, 0.03163057f, -0.04695481f, -0.01563400f, -0.04404787f, -0.06071661f, 0.02319221f, 
    0.03477266f, -0.02605060f, -0.04585882f, -0.00767644f, 0.01075475f, 0.03764562f, 0.02947561f, 0.00062290f, 
    0.01242341f, 0.02174539f, -0.02940977f, -0.03830398f, 0.00047716f, -0.00079885f, -0.00651946f, 0.03467988f, 
    -0.03529681f, -0.03084884f, 0.00404320f, -0.03618804f, -0.03159834f, 0.01381336f, -0.01013251f, -0.04582343f, 
    -0.05592178f, 0.04203437f, 0.00904596f, -0.04967742f, 0.00993408f, -0.04026191f, -0.03676204f, -0.04077927f, 
    0.01259807f, 0.01563634f, 0.00278045f, -0.01225584f, -0.00986370f, -0.04602211f, 0.01149356f, 0.00881455f, 
    -0.02328197f, -0.02620413f, -0.05695399f, 0.00430948f, 0.00422427f, 0.01593025f, 0.01218924f, -0.04468515f, 
    0.01697217f, -0.02206200f, -0.01589030f, 0.01650590f, -0.02337768f, 0.02098176f, -0.03142733f, 0.00493461f, 
    -0.00414106f, -0.01078306f, 0.00858605f, 0.03729085f, 0.03835855f, -0.04762742f, -0.02846058f, 0.03892498f, 
    -0.02879752f, 0.03182590f, -0.04426293f, 0.01614634f, -0.04870065f, 0.03722123f, -0.05473767f, 0.02545225f, 
    -0.04197851f, -0.05732125f, 0.01912994f, -0.03795378f, 0.01618029f, -0.03352007f, -0.00186665f, 0.02867191f, 
    -0.00366102f, -0.03499153f, -0.02976703f, 0.02946778f, -0.03356315f, 0.01094008f, -0.03841237f, -0.05926059f, 
    -0.05606389f, 0.01538291f, 0.02363338f, 0.01259377f, 0.04064328f, -0.06011389f, -0.01109400f, -0.02404619f, 
    -0.05291618f, 0.02047144f, -0.01699213f, -0.02443588f, 0.04309753f, 0.01051553f, -0.02161299f, 0.03767565f, 
    0.00144165f, -0.02040293f, 0.01987451f, -0.03187617f, 0.02892184f, 0.01066014f, -0.02235684f, 0.04085891f, 
    -0.00890178f, 0.01488105f, 0.00209851f, -0.06008451f, -0.03494829f, -0.06083487f, -0.01719547f, 0.01903903f, 
    0.01098407f, 0.01033073f, -0.00280433f, 0.03624825f, -0.04809643f, 0.02083671f, -0.03503576f, 0.04081028f, 
    0.01225302f, 0.03690003f, 0.03961749f, 0.01150055f, -0.01732253f, 0.02622701f, 0.03905270f, -0.03546849f, 
    0.03366613f, -0.00982409f, -0.05298602f, -0.05920075f, -0.02363347f, 0.02100084f, 0.04295688f, -0.06024372f, 
    -0.04627087f, -0.01736210f, -0.02861603f, -0.03056738f, -0.01815371f, -0.00547607f, -0.00437789f, -0.00040497f, 
    -0.00985976f, 0.02536493f, -0.00409149f, 0.00292543f, -0.03642013f, -0.04594752f, 0.03122061f, -0.04303899f, 
    0.01462670f, 0.02395414f, -0.02883720f, -0.00238727f, -0.04333758f, 0.01641409f, -0.00896179f, 0.03958043f, 
    -0.06008071f, 0.02667470f, -0.04517518f, 0.00054883f, -0.05695083f, -0.02288574f, -0.05212336f, -0.03352316f, 
    0.02159676f, 0.02573439f, -0.00160643f, 0.03553365f, -0.03066375f, -0.00249794f, -0.01575853f, -0.03009185f, 
    0.01553897f, -0.02415628f, 0.01593934f, -0.02165493f, -0.02999177f, -0.05237367f, -0.01187446f, -0.05321920f, 
    -0.03484675f, -0.00624424f, 0.04897660f, -0.01019217f, -0.02207905f, 0.01346958f, -0.01066997f, 0.01358738f, 
    -0.04508419f, 0.02707778f, 0.03386714f, -0.01650530f, 0.00709012f, -0.02257689f, -0.00241324f, -0.04491862f, 
    -0.05134340f, -0.00001554f, -0.01158311f, -0.04171054f, 0.00356617f, -0.01308223f, 0.03120788f, 0.00593779f, 
    -0.04820683f, -0.00572297f, -0.05295515f, -0.01124436f, -0.01664911f, -0.02238814f, 0.01872627f, 0.04034407f, 
    -0.00797889f, 0.00628759f, 0.00046626f, 0.01648716f, -0.05150934f, 0.03765310f, -0.05127614f, -0.02077549f, 
    -0.01423427f, 0.01784022f, -0.01289904f, -0.01734625f, -0.03404330f, -0.04406460f, -0.01318661f, -0.01548247f, 
    0.03910365f, -0.04157856f, 0.00673992f, 0.02192122f, 0.04107454f, -0.02952483f, 0.03697225f, -0.03630504f, 
    0.03950640f, -0.00722914f, -0.05013905f, -0.04154924f, 0.01700397f, -0.05463934f, -0.01095456f, -0.01104143f, 
    -0.01765736f, -0.03525335f, -0.03437755f, -0.01280434f, -0.03173514f, 0.00421786f, -0.00246256f, -0.02224379f, 
    0.00509752f, 0.01504314f, 0.02846400f, 0.03454411f, -0.00200768f, 0.03214383f, -0.03899227f, 0.01269548f, 
    0.00528494f, -0.04251208f, 0.00043273f, -0.05428419f, 0.01645803f, -0.01526518f, 0.01857961f, -0.02389092f, 
    -0.02396497f, -0.03899986f, -0.00901140f, -0.02901153f, 0.04095668f, 0.03541628f, -0.03736050f, -0.04893654f, 
    0.02818683f, 0.03879929f, 0.01458369f, 0.01100988f, 0.00063097f, -0.02156682f, -0.00322419f, -0.01270379f, 
    0.02048060f, 0.03068765f, -0.01670697f, 0.02226476f, -0.00800688f, -0.03160612f, -0.05702129f, 0.03790132f, 
    0.01059090f, -0.05667145f, -0.01811572f, 0.02735270f, -0.00627756f, -0.05226431f, 0.01634305f, -0.05313790f, 
    -0.01717108f, -0.03895727f, -0.05293020f, -0.04739475f, 0.02386505f, 0.00975979f, -0.03867823f, -0.03209801f, 
    0.03268878f, 0.04450781f, -0.00861267f, -0.01666939f, -0.00020147f, 0.00399307f, -0.00803535f, 0.02803640f, 
    -0.05577002f, 0.01014451f, 0.01806323f, -0.04746331f, -0.00929629f, -0.05478692f, -0.00882473f, 0.02228358f, 
    0.00688605f, -0.03348615f, -0.04088130f, -0.05554542f, -0.01851190f, -0.03379275f, 0.00352558f, -0.04729874f, 
    -0.00194985f, -0.05266695f, 0.02817936f, 0.01349712f, 0.02277293f, -0.03382707f, 0.04332293f, -0.04283841f, 
    0.02133938f, 0.01109096f, 0.01212449f, 0.01177988f, -0.02114612f, -0.03979803f, -0.04820839f, -0.04361168f, 
    0.01886645f, 0.03565129f, 0.02570209f, -0.00091721f, -0.04177512f, 0.03652056f, -0.04349441f, 0.03312150f, 
    0.04335833f, 0.04094424f, -0.01801137f, -0.02019486f, -0.01417401f, -0.03259937f, 0.03582555f, 0.03171788f, 
    0.03933683f, -0.02102953f, -0.05371147f, 0.02800016f, 0.00587019f, 0.02517703f, 0.02607703f, -0.00774061f, 
    0.02015227f, -0.04727156f, 0.02325788f, -0.00283741f, 0.01120127f, -0.04533827f, -0.04035312f, -0.00069618f, 
    -0.01928547f, 0.00578156f, 0.01938927f, -0.01203179f, 0.02553722f, -0.01541459f, -0.03155113f, -0.00895500f, 
    0.03756325f, -0.01279860f, 0.00453029f, 0.04680301f, 0.02731569f, -0.04924734f, 0.03161414f, -0.01655912f, 
    0.02248707f, -0.01757470f, 0.02119347f, -0.00245918f, -0.03268853f, 0.03445549f, -0.04934173f, -0.02171341f, 
    -0.04153018f, -0.00617449f, 0.00578245f, -0.00216523f, 0.04024901f, -0.00088606f, -0.04004397f, -0.02943163f, 
    0.01243895f, 0.01687888f, -0.01689749f, 0.03635570f, -0.00115922f, -0.03991555f, -0.04426469f, -0.03886335f, 
    -0.03106058f, 0.01386704f, 0.02846408f, -0.04546158f, 0.00549394f, 0.01165420f, 0.00857391f, 0.03807540f, 
    -0.02419104f, 0.03862059f, -0.03033748f, -0.00296356f, 0.01505409f, 0.01039680f, -0.01787474f, -0.00447775f, 
    -0.04627509f, 0.01531496f, 0.02244776f, -0.01793228f, 0.02041444f, 0.03585084f, 0.04212628f, -0.04175722f, 
    -0.00757083f, 0.05055342f, -0.02671975f, -0.04803905f, 0.01684133f, -0.04785584f, -0.01075820f, 0.00793193f, 
    -0.01310957f, 0.01700235f, -0.04838479f, 0.02787853f, 0.00933341f, -0.03787869f, -0.02763267f, -0.01062848f, 
    -0.02897166f, -0.05037710f, -0.00603314f, -0.01171722f, -0.03929766f, -0.02311023f, -0.02227650f, -0.01734748f, 
    -0.05863523f, 0.03272673f, -0.02507219f, 0.04277967f, -0.02514764f, 0.01507188f, -0.01291702f, -0.02984283f, 
    0.00936622f, -0.02415002f, -0.05422268f, -0.04223611f, 0.03124776f, 0.04064064f, -0.04636349f, 0.04014950f, 
    -0.03209916f, -0.00656143f, 0.04188783f, 0.04397892f, 0.00958998f, -0.04328353f, -0.01450017f, -0.00353067f, 
    -0.03271410f, -0.05527545f, -0.03567052f, -0.01612597f, -0.01224952f, -0.04579283f, -0.05409660f, 0.01863726f, 
    0.00278923f, -0.00133639f, -0.02155719f, 0.01090149f, -0.00575016f, -0.01154057f, -0.02178690f, 0.00504396f, 
    -0.03688781f, -0.00602285f, 0.02081075f, 0.04805226f, 0.00735182f, -0.02260922f, -0.05794602f, -0.00119355f, 
    -0.04274388f, -0.02526229f, -0.04914687f, 0.03151668f, 0.00888170f, -0.01984487f, -0.02091836f, -0.05328881f, 
    -0.04815130f, -0.02733348f, 0.02856753f, 0.03011218f, 0.01041681f, 0.00685179f, -0.03298080f, 0.02947511f, 
    0.03606161f, 0.00934953f, 0.01084280f, -0.03397396f, -0.03833913f, 0.00828799f, 0.03047335f, -0.03081215f, 
    -0.00785696f, -0.01714059f, -0.05293822f, 0.00936162f, -0.01601603f, -0.04452762f, 0.02566971f, -0.01996433f, 
    -0.00856140f, 0.02869663f, -0.01984643f, -0.03251376f, -0.00768303f, -0.02811775f, -0.00250084f, 0.02362242f, 
    -0.01303129f, 0.02809468f, 0.03671812f, 0.02360950f, 0.00791264f, -0.05129325f, 0.00891490f, 0.00974914f, 
    0.00247817f, 0.03273394f, 0.02184360f, 0.03437800f, -0.03874153f, 0.03663651f, -0.03110232f, -0.00119262f, 
    0.01931524f, -0.03239137f, -0.00386538f, -0.00122164f, -0.01048992f, 0.02801304f, -0.01360783f, 0.02602541f, 
    0.03603977f, 0.01135320f, -0.01515039f, 0.03473757f, -0.03335970f, -0.05832260f, -0.02941743f, 0.00277901f, 
    -0.05274588f, 0.04167782f, 0.00096139f, -0.01816968f, -0.02062117f, 0.03746039f, -0.00315586f, -0.02104022f, 
    0.04468669f, -0.01665611f, -0.01874293f, 0.04398476f, 0.01781860f, -0.01789381f, -0.05732968f, -0.01602093f, 
    -0.00480713f, -0.01063639f, -0.00182761f, -0.02834240f, 0.01913004f, -0.05291859f, 0.05542771f, 0.01178593f, 
    -0.00397966f, -0.00915159f, 0.01603580f, -0.00701164f, -0.00229494f, -0.01217392f, 0.02129000f, 0.03211349f, 
    -0.05375386f, 0.03680784f, 0.02051177f, -0.05764364f, -0.03534774f, 0.03880001f, -0.04214440f, -0.04548879f, 
    -0.02259358f, -0.00765988f, -0.05774689f, 0.00649756f, -0.01983570f, 0.01475010f, 0.01982869f, -0.00838713f, 
    0.04717201f, -0.02828897f, 0.01654923f, 0.01052635f, -0.00413905f, 0.00567506f, 0.01528859f, -0.05362884f, 
    0.01575731f, -0.01637887f, -0.05782294f, 0.04011558f, -0.02962652f, 0.02356316f, 0.00131422f, 0.01637810f, 
    0.01892073f, 0.04609129f, -0.05269072f, -0.03709074f, -0.02517349f, 0.02043980f, -0.01140566f, -0.03669665f, 
    -0.02777481f, -0.03227569f, -0.04870736f, -0.03241859f, 0.04331665f, -0.00569846f, 0.03961652f, 0.02504607f, 
    0.02506925f, -0.02025724f, 0.03067554f, 0.00792065f, 0.01723045f, 0.04005886f, 0.00006290f, -0.03526606f, 
    0.01408160f, 0.02296237f, 0.01511795f, 0.00078434f, -0.05194989f, -0.03165223f, -0.03884978f, -0.05965126f, 
    0.01957135f, 0.00420525f, 0.01495013f, -0.00949330f, 0.01278112f, 0.01838427f, -0.05502553f, 0.01673582f, 
    -0.02559340f, 0.03951274f, -0.04798350f, -0.00032167f, -0.04316225f, -0.04537221f, -0.01036919f, 0.01599802f, 
    -0.00903072f, 0.03243482f, 0.01648390f, 0.02377129f, 0.03006222f, 0.01977394f, -0.01799913f, 0.01543036f, 
    -0.02700405f, -0.04997753f, -0.01012603f, -0.05031563f, 0.03431005f, -0.04744264f, 0.03855085f, 0.02906676f, 
    -0.00990777f, 0.02359601f, 0.01650397f, 0.02201365f, 0.03463782f, -0.00906919f, -0.00295923f, 0.03651850f, 
    0.01152095f, -0.03960950f, -0.00057219f, 0.01204237f, 0.02735929f, -0.00299384f, -0.05341777f, -0.03192383f, 
    0.02314056f, -0.02149917f, -0.01967339f, -0.03453947f, -0.02341309f, -0.04788934f, -0.01026887f, 0.01148124f, 
    0.02193645f, 0.04112985f, 0.03505780f, -0.04661382f, -0.01446357f, 0.04152527f, 0.03003661f, -0.00132682f, 
    0.00872317f, 0.00628069f, 0.01197955f, 0.00232858f, -0.05623615f, 0.02864241f, -0.00071759f, -0.06083059f, 
    -0.03349264f, 0.04026852f, -0.01160187f, -0.04948408f, 0.03665719f, 0.00094886f, 0.01597714f, -0.01240578f, 
    0.00292951f, -0.03247712f, -0.04552477f, -0.01633707f, 0.00216405f, -0.01118255f, -0.03593522f, -0.02112412f, 
    0.00224810f, -0.01053416f, 0.03929391f, -0.02505372f, 0.00918701f, 0.02713224f, -0.02602765f, 0.03515865f, 
    0.00389826f, -0.03220931f, -0.00666141f, -0.03792701f, -0.01344472f, 0.03822142f, 0.01192975f, 0.01990585f, 
    -0.03130925f, -0.04099639f, -0.04279117f, -0.00631782f, -0.05185541f, -0.05498972f, -0.05767886f, -0.01393960f, 
    -0.03785159f, -0.04029435f, -0.00564713f, 0.00969587f, 0.03600670f, -0.03516985f, 0.03819818f, -0.00859878f, 
    -0.01509386f, 0.03854141f, -0.03563580f, -0.01288431f, 0.00120353f, -0.02175005f, 0.02669396f, 0.01716100f, 
    0.03673138f, -0.03541537f, -0.01153306f, 0.00522299f, 0.01082698f, 0.00876350f, -0.03129350f, 0.03514390f, 
    -0.05021714f, 0.02342523f, 0.01661563f, -0.03451290f, 0.00963788f, -0.05267848f, -0.00402603f, -0.00391547f, 
    -0.03817128f, -0.03116012f, 0.02438798f, 0.03986276f, -0.00924984f, 0.01434453f, 0.04133937f, 0.04364770f, 
    -0.00672844f, -0.04394043f, -0.00827387f, 0.00317614f, 0.01972765f, -0.01412202f, -0.04151743f, -0.00306328f, 
    0.01742062f, 0.00530549f, -0.05948552f, -0.04613575f, -0.01879723f, -0.01787565f, -0.01381328f, -0.05492754f, 
    -0.01027877f, -0.04820927f, 0.00323721f, -0.04716902f, -0.02708407f, -0.03082603f, 0.01466194f, 0.00502097f, 
    0.00496300f, -0.02878775f, -0.00893481f, 0.03987358f, -0.04222271f, -0.03310241f, -0.03208624f, -0.01587137f, 
    -0.02924884f, 0.03862743f, -0.02706860f, 0.02173498f, 0.03561385f, 0.00735438f, -0.01138300f, -0.05488608f, 
    -0.00697565f, 0.01196346f, -0.05571106f, 0.03851275f, 0.00286670f, 0.01601887f, -0.01610173f, 0.01340675f, 
    -0.05081163f, -0.04956926f, -0.00600518f, -0.00324437f, -0.02697462f, 0.01581968f, -0.00632098f, 0.02985851f, 
    -0.04507571f, -0.03031417f, 0.02819815f, -0.03105484f, 0.02445847f, -0.05309066f, -0.03355233f, 0.01189467f, 
    -0.01020442f, 0.02648832f, -0.04177908f, 0.02996896f, 0.03981837f, 0.04165628f, -0.02983032f, 0.01570922f, 
    0.02257140f, 0.00736130f, -0.03054530f, 0.01654264f, -0.01942457f, -0.04359530f, 0.02894779f, -0.02320518f, 
    0.00367614f, -0.01486437f, -0.05586635f, 0.00290916f, -0.03294545f, -0.01681822f, 0.00895416f, -0.02691424f, 
    -0.04925568f, 0.03102358f, -0.03914446f, -0.01615859f, -0.00710307f, -0.05765726f, 0.02552148f, -0.03251098f, 
    -0.18691495f, 0.14043610f, -0.00294971f, 0.04806189f, 0.20642196f, 0.03463477f, -0.09313070f, 0.06252991f, 
    0.06484970f, -0.03882528f, 0.05282996f, -0.00418922f, 0.26273745f, 0.17922810f, 0.16974838f, -0.11065485f, 
    -0.13857052f, -0.09351625f, 0.05210258f, 0.03346983f, -0.05499391f, 0.11846581f, -0.03556903f, 0.02851194f, 
    -0.12420442f, -0.12609056f, 0.08253034f, -0.12153952f, 0.01050659f, -0.09170247f, 0.04805180f, 0.01050176f, 
    0.07112470f, 0.03984671f, 0.06554299f, 0.03185228f, 0.16333878f, -0.10922857f, -0.18698247f, 0.25509927f, 
    0.01131606f, 0.05275313f, -0.03072313f, 0.04661461f, 0.00087818f, -0.09631795f, 0.00137370f, 0.05231896f, 
    -0.08192099f, -0.18451057f, 0.04112485f, -0.08240671f, -0.02171760f, -0.02236492f, -0.03335293f, 0.04277693f, 
    0.09932008f, -0.05679722f, -0.10660663f, -0.10384484f, 0.30354279f, -0.03699662f, -0.03482535f, -0.07167529f, 
    0.02351953f, 0.05050560f, -0.09668246f, 0.04027766f, -0.03266537f, -0.06468087f, 0.01338138f, 0.06923120f, 
    0.17644228f, 0.06904121f, -0.00346424f, 0.16688584f, -0.04233301f, -0.09430019f, 0.06619592f, 0.00165824f, 
    0.02018188f, 0.00916019f, -0.05441269f, 0.05637880f, 0.17467202f, 0.04224634f, 0.08335900f, 0.09526648f, 
    -0.05164690f, 0.04828422f, 0.13532411f, -0.04205951f, -0.07483649f, 0.05456051f, -0.03160110f, 0.06054707f, 
    0.15935102f, -0.07668975f, 0.07007653f, 0.25059059f, -0.08295847f, -0.03652466f, -0.02153635f, 0.01761369f, 
    0.04134310f, -0.06039809f, 0.02705409f, 0.05976060f, 0.37781063f, -0.01023393f, 0.12227190f, -0.03798928f, 
    -0.05253015f, 0.03853626f, -0.03117156f, -0.05665265f, -0.00831503f, -0.02505208f, -0.08628565f, -0.06705223f, 
    -0.37936386f, -0.13364188f, 0.11001594f, -0.18055506f, -0.09858567f, -0.00092923f, -0.01288620f, -0.05109173f, 
    -0.05371788f, 0.01992179f, 0.05276687f, 0.00924709f, -0.22233132f, 0.16289106f, -0.15229379f, 0.10244978f, 
    -0.03406291f, 0.05742037f, -0.01248399f, -0.03996224f, -0.05687228f, 0.04420781f, 0.06216444f, -0.00876260f, 
    0.19688049f, 0.20061316f, 0.14132228f, 0.00078679f, 0.03076630f, -0.08195686f, 0.06260594f, -0.00749792f, 
    -0.04612647f, -0.05277773f, 0.06744167f, 0.03028119f, -0.22966501f, -0.17353107f, 0.00053759f, 0.06045542f, 
    -0.03474889f, 0.05357164f, 0.03193727f, 0.04597208f, -0.01027540f, 0.09006335f, -0.00667868f, 0.06933107f, 
    -0.06181076f, -0.09959356f, -0.11180582f, -0.06803002f, -0.04629866f, 0.03361182f, -0.07261582f, 0.00580873f, 
    0.03702568f, 0.15214585f, -0.09487488f, -0.02101300f, 0.09175404f, 0.03145101f, 0.01807806f, 0.05474924f, 
    -0.01101468f, 0.08388920f, -0.02600313f, -0.05463320f, -0.00204592f, -0.00979225f, 0.01320767f, -0.02417371f, 
    0.07315926f, 0.17131433f, 0.24611321f, -0.26587209f, -0.09700865f, -0.06259450f, 0.09585356f, 0.07549333f, 
    -0.12475417f, -0.09618846f, 0.03911356f, 0.05252787f, -0.01457286f, -0.20020153f, -0.02088638f, -0.01054319f, 
    -0.04312943f, 0.07398626f, -0.05162068f, 0.00877464f, 0.06145158f, -0.07074694f, 0.11811075f, -0.02065100f, 
    0.08326367f, 0.11894663f, 0.11808970f, 0.03414908f, 0.07286059f, 0.13049117f, -0.04959324f, 0.03353890f, 
    0.09409929f, 0.08925135f, 0.08184503f, -0.01239790f, 0.00459154f, -0.07643518f, 0.11286321f, -0.10794201f, 
    0.12784453f, -0.00118283f, 0.05073036f, -0.04706998f, 0.00680349f, 0.07570072f, -0.05049525f, 0.00978617f, 
    -0.05572590f, -0.19024986f, 0.06026068f, -0.16485865f, 0.04345750f, -0.03442075f, 0.00175123f, 0.07592512f, 
    -0.06598210f, 0.02468974f, 0.04232096f, 0.00231398f, 0.23636620f, 0.19967294f, 0.06812774f, 0.07680437f, 
    0.02594036f, -0.06749209f, 0.05850236f, -0.00623490f, 0.02695283f, -0.08633131f, -0.01888514f, -0.01949967f, 
    -0.11020344f, -0.02413782f, -0.04528050f, -0.07069313f, 0.20545059f, -0.06844894f, -0.00246306f, 0.19299187f, 
    0.04283005f, -0.04355970f, -0.05817008f, 0.07452721f, 0.07790581f, 0.08124410f, 0.05180949f, 0.00905376f, 
    0.06729914f, 0.00886742f, 0.01726776f, 0.02750173f, -0.02631371f, 0.03235828f, 0.04807526f, -0.04635923f, 
    0.09294841f, -0.15839195f, 0.11366712f, -0.40848038f, -0.14043523f, -0.05061365f, 0.00391345f, 0.05265224f, 
    0.01533208f, -0.04553707f, 0.04376580f, -0.08480766f, 0.10101569f, 0.02195628f, -0.03200300f, -0.11933526f, 
    0.08869376f, 0.03786084f, 0.00410446f, -0.02754760f, 0.03861487f, 0.01310212f, 0.08370014f, -0.05530088f, 
    0.01488018f, -0.10335297f, -0.12952903f, 0.18805882f, -0.02578819f, 0.03827039f, -0.15426336f, 0.12668855f, 
    -0.00348025f, -0.03156297f, -0.02081698f, 0.01489587f, -0.09137942f, -0.01604504f, -0.02678853f, -0.02825780f, 
    0.07343213f, 0.09163290f, 0.00891050f, 0.11911558f, 0.09059494f, 0.16393818f, -0.08549462f, -0.05993148f, 
    0.27074334f, -0.01309210f, -0.02242369f, -0.10333955f, 0.10103105f, -0.03101306f, 0.03421149f, 0.10428193f, 
    -0.05099295f, 0.04831585f, -0.00618294f, 0.05957498f, 0.02759572f, 0.05047029f, 0.16762921f, -0.00243182f, 
    0.02168546f, 0.06662233f, 0.03771911f, -0.04870934f, -0.04974069f, -0.11379076f, -0.02305728f, 0.08039275f, 
    -0.12551266f, -0.18700917f, 0.09238309f, -0.04097516f, -0.04860817f, -0.02308004f, -0.01538613f, 0.03589648f, 
    0.02404342f, -0.08949175f, 0.02468216f, 0.04326931f, 0.06989918f, -0.07579074f, -0.06612076f, -0.15851553f, 
    -0.01627780f, 0.06885179f, -0.01108500f, 0.05577935f, 0.10948405f, 0.05051123f, 0.07130092f, 0.00427130f, 
    0.34287176f, 0.11556459f, 0.04281655f, 0.12661891f, 0.10062727f, -0.12278312f, 0.10765692f, 0.20171878f, 
    0.04047783f, -0.06154988f, -0.04077698f, 0.09216218f, 0.09011072f, 0.00600886f, 0.07861325f, -0.08130270f, 
    -0.04342275f, -0.17892356f, -0.08190969f, 0.09097941f, 0.05085387f, 0.06456942f, -0.05602566f, 0.00414891f, 
    0.00449769f, -0.07955538f, 0.17675294f, -0.11468901f, 0.02944184f, -0.02596027f, 0.09980401f, -0.02672309f, 
    0.03361651f, 0.04677089f, -0.14773661f, -0.07504568f, 0.38516665f, -0.02663477f, 0.01340986f, 0.38222101f, 
    -0.09957719f, 0.01093679f, -0.02081294f, 0.09318261f, -0.01256993f, 0.06279176f, -0.01034602f, -0.01282949f, 
    0.10365365f, -0.01528340f, 0.00789958f, -0.15936057f, 0.08091574f, 0.05748093f, 0.08936049f, -0.12743126f, 
    -0.01788030f, -0.12284054f, -0.08726264f, 0.00418369f, 0.24964370f, 0.28979734f, 0.01727997f, 0.06620546f, 
    0.03698689f, -0.02796686f, -0.08960388f, 0.02676324f, -0.08015718f, 0.04260826f, 0.02911296f, 0.04454523f, 
    0.18541786f, -0.04518030f, -0.05191668f, 0.07156376f, 0.06965616f, 0.07007366f, -0.05286012f, 0.01147966f, 
    -0.03045937f, 0.00585458f, -0.00441966f, -0.10310153f, 0.12824598f, -0.03052630f, -0.06875856f, 0.07721990f, 
    -0.14988895f, -0.20455174f, 0.07641394f, -0.02965803f, 0.06028542f, 0.09843826f, 0.02217228f, 0.09791753f, 
    -0.10245970f, 0.04110700f, -0.02514199f, 0.32741401f, -0.05274806f, 0.07566077f, -0.00778767f, -0.05155014f, 
    -0.02468460f, 0.03923210f, 0.07289433f, -0.02608635f, 0.19455543f, -0.14252722f, -0.01821337f, 0.11414574f, 
    0.01921837f, 0.03838148f, 0.14197461f, -0.00256336f, 0.01259572f, 0.08379579f, 0.02775932f, -0.08550251f, 
    0.01945392f, 0.30736390f, -0.11719768f, -0.36525422f, 0.06345230f, -0.00407575f, 0.04405604f, -0.08635749f, 
    -0.00065218f, 0.00551726f, 0.10008696f, -0.00795211f, -0.11929266f, -0.02863948f, -0.26156285f, 0.13223119f, 
    -0.03669303f, 0.12547339f, 0.06010336f, -0.09878757f, 0.00984026f, 0.03971650f, -0.06461027f, -0.01828192f, 
    0.09783867f, -0.01323409f, 0.08316211f, -0.12103046f, -0.03461888f, -0.09752788f, 0.07011462f, 0.02671957f, 
    0.06247317f, 0.11681742f, 0.07956423f, -0.12309946f, -0.04583067f, -0.11073220f, 0.12913525f, 0.07269192f, 
    -0.09820008f, 0.04633612f, -0.02075109f, 0.00725690f, 0.05316420f, 0.03985306f, -0.13243999f, -0.18817623f, 
    -0.06835084f, 0.13295184f, 0.02237552f, 0.11157409f, -0.08460478f, 0.03059138f, -0.01173891f, 0.15893282f, 
    0.03965340f, 0.04261270f, -0.10660800f, 0.05992804f, -0.07659797f, 0.06948120f, 0.02993983f, 0.13606516f, 
    -0.05021803f, -0.00158228f, -0.09116016f, 0.07289917f, 0.07236566f, 0.12078503f, 0.00608318f, 0.09014549f, 
    -0.14136496f, -0.16489640f, 0.06600680f, -0.32442087f, -0.10359193f, -0.00292341f, 0.04313487f, -0.05501413f, 
    -0.05090510f, 0.03982940f, -0.02552216f, 0.06674788f, -0.08738208f, 0.05374825f, 0.11404669f, -0.13504930f, 
    -0.04511435f, 0.05730867f, 0.02948811f, 0.04243908f, -0.07432930f, -0.06018326f, -0.06192424f, 0.08122906f, 
    -0.02025832f, 0.12656650f, -0.03616129f, 0.15032138f, 0.07864673f, 0.04653540f, -0.02220619f, 0.14345792f, 
    0.03129032f, 0.10937933f, 0.03999054f, 0.10358208f, -0.26466256f, -0.13174030f, 0.24265373f, -0.11554053f, 
    0.02773285f, -0.04458043f, -0.03448222f, -0.07290602f, -0.04790885f, -0.01169222f, -0.00240555f, -0.04306527f, 
    -0.06581377f, 0.01008630f, 0.13182615f, -0.15601164f, -0.03004013f, 0.01958852f, 0.03667172f, -0.04575017f, 
    0.13539314f, 0.01913885f, -0.00720727f, -0.07112505f, 0.11525422f, -0.13856775f, -0.09611801f, 0.14784390f, 
    0.00142325f, 0.03234017f, 0.04175104f, 0.08483060f, -0.09713645f, -0.01810335f, -0.04731845f, -0.01388511f, 
    0.14416587f, 0.18251611f, 0.04645076f, 0.04474625f, 0.08426766f, -0.10345403f, 0.02922133f, 0.21005505f, 
    0.04154876f, 0.00909511f, -0.11475707f, -0.03450000f, 0.05399733f, -0.06265584f, -0.11758804f, 0.12349089f, 
    -0.02986378f, -0.10672408f, -0.00713831f, 0.06117704f, -0.09020133f, -0.03470518f, -0.02844192f, 0.02627962f, 
    0.19766763f, -0.00512224f, 0.06024969f, -0.41689473f, -0.02364053f, 0.02493181f, 0.14176998f, 0.10764129f, 
    0.00016180f, -0.02666462f, -0.07998785f, -0.11052658f, -0.23794809f, 0.19779065f, 0.04797356f, -0.12277646f, 
    0.01151225f, 0.01674700f, -0.03542168f, -0.11730559f, -0.03111264f, 0.04614151f, 0.05656645f, 0.02142135f, 
    0.15937628f, -0.08497345f, 0.05937404f, 0.28444472f, -0.01721554f, 0.11849111f, -0.17385140f, -0.01946189f, 
    0.09605113f, -0.13041024f, 0.07829687f, 0.09050103f, -0.07100325f, 0.06104867f, 0.12992673f, -0.00320665f, 
    0.09398338f, -0.11579257f, -0.02999708f, 0.08666199f, -0.01132326f, -0.05640595f, -0.01539657f, -0.11741447f, 
    -0.11427052f, -0.04994776f, 0.38612422f, -0.00986643f, -0.03082294f, 0.11860391f, 0.07564838f, 0.11994358f, 
    -0.06133570f, 0.01594524f, 0.15050291f, 0.04299412f, -0.13521639f, 0.04977392f, 0.02712698f, 0.01008977f, 
    0.03918615f, -0.00391526f, -0.03679027f, 0.00193020f, 0.00479678f, 0.03651452f, 0.08074424f, -0.08596452f, 
    0.11823779f, -0.05039240f, 0.04768804f, -0.11379552f, -0.01044067f, 0.00575476f, 0.07873721f, -0.06168259f, 
    0.12691997f, -0.15548253f, 0.11357235f, 0.01000423f, -0.07217910f, 0.15060784f, -0.04915098f, -0.04979811f, 
    -0.02438518f, 0.08560140f, 0.07454582f, 0.08713141f, 0.02356744f, 0.04135060f, 0.06511089f, -0.03666702f, 
    -0.03158972f, 0.03739613f, 0.04500851f, -0.01707231f, -0.03094863f, 0.01516998f, -0.00291590f, 0.03132304f, 
    0.01377644f, -0.00854054f, 0.04996855f, -0.02510308f, 0.02085877f, 0.04330662f, -0.03106619f, -0.03362938f, 
    -0.01373871f, -0.03635734f, -0.02951720f, -0.02047404f, -0.02643487f, 0.03546201f, 0.03617346f, 0.01549315f, 
    -0.04380059f, -0.03340104f, -0.03734477f, 0.05167059f, -0.02728816f, 0.00485953f, -0.00896290f, 0.03891595f, 
    0.04405315f, -0.04065054f, -0.04574533f, 0.05034790f, 0.00703409f, 0.00732621f, 0.03283471f, 0.01744534f, 
    -0.01346381f, -0.03603537f, -0.05108401f, -0.04730202f, -0.04123427f, -0.00762180f, 0.02265082f, -0.04340859f, 
    -0.00920584f, 0.02353839f, -0.01644468f, 0.03983951f, -0.00605431f, -0.00028328f, -0.05118269f, -0.01983553f, 
    0.01538005f, 0.01241782f, 0.01197273f, -0.02578469f, 0.04054378f, 0.01001923f, -0.03393945f, 0.03933132f, 
    -0.04439243f, -0.03301978f, -0.00691252f, 0.02284425f, -0.00271916f, -0.03497423f, 0.03003105f, -0.00402445f, 
    0.00482124f, 0.02034443f, -0.03695452f, 0.00926929f, -0.00880884f, -0.02694166f, -0.00364215f, 0.01247608f, 
    -0.04521471f, 0.03316646f, -0.04063240f, -0.01021099f, 0.00970163f, 0.03501473f, -0.01249953f, 0.01669084f, 
    0.01246856f, -0.03206923f, -0.04503405f, 0.02102427f, -0.02950424f, 0.00162453f, -0.00522891f, 0.00121444f, 
    0.00474494f, 0.02056059f, -0.01189128f, 0.02978413f, 0.03165606f, 0.01674518f, -0.00437019f, -0.02469052f, 
    0.01305389f, 0.04846365f, -0.04889404f, 0.03911316f, 0.00234223f, -0.01170526f, -0.04164358f, 0.00840989f, 
    0.00923781f, -0.02374936f, -0.03223932f, -0.02591478f, 0.03668030f, -0.04458949f, -0.01714409f, -0.01458757f, 
    -0.04405855f, -0.00652526f, -0.02560696f, -0.01703518f, 0.02751279f, 0.03498919f, 0.02474843f, -0.00792678f, 
    -0.00501115f, -0.04096473f, 0.02420351f, 0.02308826f, 0.04036063f, -0.00593541f, -0.03029098f, -0.01884863f, 
    0.01135054f, -0.03991358f, 0.00022910f, 0.02891565f, -0.03691541f, -0.05511660f, 0.00944027f, -0.03492321f, 
    0.01796458f, 0.03647640f, -0.00886752f, 0.00978146f, 0.02017739f, -0.03320178f, -0.02328468f, 0.01163758f, 
    -0.05275490f, -0.04560015f, -0.00017588f, -0.02160038f, -0.04501896f, 0.00977474f, 0.01934564f, 0.05060417f, 
    -0.02660996f, 0.02150251f, 0.01406925f, -0.02066215f, -0.05862519f, 0.00844666f, 0.00537623f, 0.00598679f, 
    -0.02982100f, 0.01729484f, -0.02282643f, -0.01226545f, -0.02242570f, -0.01746760f, 0.00542749f, -0.01357205f, 
    -0.03481756f, -0.04205888f, 0.03695230f, -0.01726786f, 0.04254701f, -0.02936926f, 0.00649677f, -0.00645754f, 
    -0.01423546f, -0.00788129f, -0.05246821f, -0.01007986f, -0.03180061f, 0.02340921f, 0.04434814f, 0.03754745f, 
    -0.01861841f, -0.00181236f, 0.01100213f, 0.00692299f, -0.00230315f, -0.01440285f, 0.03773329f, 0.02872571f, 
    -0.01122400f, 0.01343620f, 0.01478560f, -0.01020361f, 0.04661440f, 0.02015558f, -0.01761633f, -0.04378009f, 
    0.04785051f, 0.00999191f, -0.03491081f, 0.03387830f, 0.02545940f, -0.05480120f, -0.05099915f, -0.04332156f, 
    -0.02876325f, -0.03915792f, -0.01597334f, -0.05006240f, 0.00881591f, -0.04920147f, 0.01753844f, 0.02276061f, 
    -0.05097512f, -0.00710705f, 0.04527440f, 0.02090307f, -0.01656230f, 0.01552391f, -0.02110600f, 0.03240374f, 
    0.03845794f, -0.00873480f, 0.02062451f, 0.02523393f, -0.03259956f, 0.00898750f, 0.02755205f, -0.04716923f, 
    -0.02512894f, -0.04447256f, 0.03480005f, 0.03257736f, -0.00241518f, 0.00955641f, 0.02810259f, -0.01837830f, 
    -0.01802511f, -0.02346543f, -0.00436221f, -0.05049864f, 0.00939099f, -0.02295469f, -0.05886064f, 0.01936816f, 
    -0.02997580f, 0.01551390f, -0.05151397f, -0.03316085f, 0.01300315f, -0.00612142f, -0.00652938f, 0.04277119f, 
    0.02666268f, 0.03725746f, 0.01002054f, -0.01228476f, -0.03271698f, -0.04933373f, -0.01933925f, 0.05615139f, 
    -0.02128914f, -0.03540733f, 0.04011521f, 0.01084759f, -0.03550449f, -0.03460712f, -0.01758257f, -0.01468962f, 
    0.01718094f, -0.01586303f, -0.01736718f, 0.01316363f, 0.01061345f, -0.01106292f, -0.03774459f, -0.01265761f, 
    0.04296333f, 0.02672753f, 0.00647794f, -0.04663851f, 0.03178611f, 0.01582418f, -0.05074066f, -0.03283368f, 
    -0.05487266f, 0.00343695f, 0.02970697f, -0.04123386f, 0.04599131f, 0.02924661f, -0.02453219f, -0.03784618f, 
    -0.00402670f, 0.02407319f, 0.03240627f, -0.01147208f, -0.04228841f, 0.04292532f, -0.03081595f, -0.05079399f, 
    -0.04982296f, 0.02773586f, -0.00714679f, -0.03319003f, 0.01932932f, -0.01894159f, 0.01707537f, 0.03954669f, 
    0.00709240f, 0.01785611f, -0.02820343f, 0.01634828f, 0.02282193f, 0.02440378f, 0.00094458f, -0.01086341f, 
    0.00457861f, -0.01505409f, -0.00979945f, 0.02523288f, -0.04813981f, 0.02581918f, 0.01622220f, 0.00823126f, 
    -0.01262765f, -0.01435020f, -0.03250282f, -0.03274024f, -0.03188913f, -0.04062576f, -0.03069886f, 0.01925841f, 
    0.03165442f, -0.01054932f, 0.04631652f, -0.00061794f, 0.01701672f, 0.02710696f, -0.04897101f, -0.03665801f, 
    -0.05690256f, -0.05758312f, 0.03853619f, -0.02603420f, -0.05891716f, 0.03453084f, -0.01665230f, -0.03756221f, 
    -0.00421053f, 0.03319854f, -0.02750158f, 0.04375283f, 0.02444373f, -0.02815584f, -0.00174617f, -0.01448212f, 
    -0.00977542f, 0.00811209f, 0.02473944f, -0.01188598f, -0.05887490f, 0.03675231f, -0.05409706f, -0.03250195f, 
    0.03294775f, 0.01430461f, -0.00685412f, -0.01500965f, -0.01862933f, 0.01677734f, 0.02458203f, -0.00445828f, 
    -0.10083748f, 0.01779683f, -0.20098984f, -0.05856850f, 0.15734707f, 0.13330543f, 0.03796102f, -0.03392164f, 
    0.07083940f, 0.03079349f, -0.07314789f, -0.01123034f, -0.03563335f, 0.27820265f, 0.19405095f, -0.00865833f, 
    -0.10468996f, 0.02587598f, 0.08591431f, 0.07545242f, -0.02870291f, 0.08948244f, 0.05652267f, 0.08080913f, 
    -0.13426445f, -0.08218502f, 0.16143702f, 0.07157957f, -0.00063969f, -0.07306141f, -0.02894478f, 0.04582599f, 
    0.04218638f, 0.02921140f, 0.00138745f, -0.00972086f, -0.06440595f, -0.26104081f, -0.29974642f, -0.08795846f, 
    0.09916117f, 0.06588095f, -0.02045348f, 0.08310179f, 0.02595816f, 0.08581033f, -0.01711899f, -0.12106969f, 
    -0.21816324f, -0.09929345f, 0.07881005f, 0.09145623f, 0.01247054f, 0.02877601f, 0.00032261f, 0.15579818f, 
    0.07090942f, -0.00155228f, 0.05646624f, -0.03637432f, 0.07198843f, -0.09551453f, -0.09505195f, -0.12834989f, 
    0.13239273f, 0.00728959f, -0.00896035f, 0.08717757f, 0.05222910f, 0.04454857f, -0.03426671f, 0.02568546f, 
    0.04751863f, 0.12955011f, -0.08938681f, 0.09588601f, -0.05998643f, -0.11356364f, 0.02866393f, -0.07312112f, 
    -0.07328267f, -0.00719017f, -0.06571727f, 0.09421378f, 0.09969496f, 0.10886523f, 0.21111548f, -0.03578920f, 
    -0.03557971f, 0.06389014f, 0.08635185f, 0.00587106f, -0.05514501f, 0.04242716f, -0.02100470f, 0.05366486f, 
    0.23227768f, 0.03387935f, 0.15291017f, 0.01899302f, -0.08942433f, -0.00676005f, -0.06293078f, -0.09330636f, 
    0.13427943f, -0.09692956f, 0.11861742f, 0.10667992f, 0.14023612f, 0.00998403f, 0.16502517f, -0.16128209f, 
    0.05162924f, 0.02946400f, -0.09947071f, -0.00014454f, 0.03011880f, -0.06800309f, 0.05907889f, -0.02487052f, 
    -0.34107628f, -0.24964520f, 0.20711666f, 0.03545182f, -0.00194608f, 0.00401036f, -0.02583621f, 0.03260484f, 
    -0.08462230f, -0.02992949f, 0.04884166f, 0.07017347f, -0.10336315f, 0.31448573f, -0.05779948f, 0.20266369f, 
    -0.01216468f, -0.01842809f, -0.11724848f, -0.00747084f, -0.02875338f, 0.01670681f, 0.11825498f, 0.02787176f, 
    0.09454254f, 0.09375452f, 0.17775291f, 0.09250935f, 0.04146959f, -0.03147201f, -0.13403402f, -0.00487909f, 
    -0.07909352f, -0.04041820f, 0.16425247f, 0.03017813f, -0.11686288f, -0.02676209f, 0.06125159f, 0.05335850f, 
    0.01988484f, 0.04623126f, -0.02350673f, 0.02515135f, 0.07047328f, -0.01878932f, 0.01291598f, 0.17315654f, 
    -0.14919196f, -0.11137564f, -0.12812360f, -0.12113860f, 0.03980534f, 0.03468432f, 0.10162728f, -0.08964922f, 
    -0.06423851f, 0.15460135f, -0.02483947f, 0.09104080f, 0.15629934f, -0.05149670f, 0.12683359f, -0.02113250f, 
    0.05410765f, 0.17391217f, 0.01060420f, -0.06729579f, 0.02442502f, -0.02821635f, -0.09515098f, 0.03804718f, 
    -0.13200143f, 0.27172732f, 0.40959266f, 0.15178193f, -0.06852282f, -0.07221745f, 0.12178741f, 0.09353330f, 
    -0.09379978f, -0.07719844f, 0.04409327f, 0.04664255f, 0.01854502f, -0.20526318f, -0.00721152f, 0.06697885f, 
    -0.02458686f, 0.03789886f, -0.01894887f, 0.00982787f, 0.01088106f, -0.00318377f, 0.04247297f, -0.03185519f, 
    0.02017617f, 0.12763113f, 0.09726585f, -0.09110271f, 0.10130858f, 0.17038672f, -0.07184615f, -0.01685973f, 
    0.03736113f, 0.09826266f, 0.01481149f, 0.10420642f, 0.12737136f, 0.09309008f, 0.02290893f, 0.03091680f, 
    0.04527092f, 0.00425135f, 0.03928482f, -0.04830808f, 0.02293196f, 0.01490864f, 0.03957696f, -0.01717896f, 
    -0.03440151f, -0.29566911f, -0.04445289f, 0.01573049f, 0.01330036f, 0.03668575f, -0.08607117f, -0.00501167f, 
    -0.09479912f, -0.00775476f, -0.05809895f, -0.02126555f, -0.06580035f, 0.26296961f, 0.22919659f, 0.03144025f, 
    -0.01479810f, 0.05663528f, 0.11405318f, 0.05947724f, 0.10458814f, 0.14512725f, 0.03753881f, 0.07486344f, 
    -0.10897449f, -0.08569189f, -0.16362381f, -0.22591327f, 0.13399348f, 0.01747341f, -0.00788287f, 0.04085636f, 
    0.04097869f, -0.01882245f, -0.10878967f, 0.07801197f, 0.00231924f, 0.23068061f, 0.03773601f, -0.08514640f, 
    -0.03755926f, 0.02761736f, 0.02614446f, 0.00912934f, 0.00995081f, 0.03883088f, 0.00549885f, -0.06998192f, 
    0.04011769f, -0.32783163f, 0.26080009f, -0.17894869f, -0.06915344f, -0.02795063f, 0.07462990f, 0.01754078f, 
    -0.10507847f, 0.03206482f, -0.03267659f, -0.16481309f, 0.23133084f, -0.08005523f, 0.04042450f, 0.00806741f, 
    0.06112865f, -0.02066229f, 0.02107683f, 0.07560908f, -0.04356646f, -0.02079154f, 0.10665443f, -0.01459228f, 
    -0.28401139f, -0.02464718f, -0.25118566f, -0.02488541f, 0.07130191f, 0.01098489f, -0.09755404f, 0.04754175f, 
    -0.06182872f, -0.02601173f, 0.05725348f, -0.11403015f, -0.12518317f, -0.11036453f, -0.13681391f, -0.02772017f, 
    0.17184234f, 0.19116963f, -0.03453170f, 0.12239599f, 0.01433548f, 0.14794326f, 0.01817408f, -0.09468326f, 
    0.30562785f, -0.01635596f, -0.20858867f, -0.01832974f, 0.15457788f, -0.00626614f, -0.01650159f, 0.04364759f, 
    -0.01103120f, 0.00195980f, -0.03740213f, -0.01443637f, 0.15736367f, 0.11823624f, 0.13803822f, -0.13711967f, 
    -0.05356408f, -0.07257355f, 0.02821073f, 0.05499781f, 0.03680210f, -0.07049515f, 0.01622492f, -0.01170700f, 
    -0.12154450f, -0.29156369f, 0.03300053f, 0.03754446f, -0.08575361f, -0.04271592f, -0.07341335f, 0.04894104f, 
    -0.05844536f, -0.13631992f, 0.15479033f, -0.03301549f, 0.06869080f, -0.11071637f, -0.02336416f, -0.00213235f, 
    0.03047804f, 0.05107593f, -0.03197896f, 0.04868755f, 0.01251487f, 0.06734791f, 0.03319113f, -0.10728815f, 
    -0.04790225f, -0.04529036f, 0.03495704f, -0.03722777f, 0.02749246f, -0.03691931f, -0.02874441f, -0.00362164f, 
    0.02608345f, 0.03255446f, -0.04206865f, 0.03266374f, 0.05374939f, -0.00251887f, -0.02191158f, -0.02390983f, 
    0.01100944f, 0.02216473f, 0.02138074f, 0.02697214f, 0.01363769f, -0.02403607f, 0.03171184f, 0.03733183f, 
    0.00564462f, -0.00518769f, -0.01987029f, -0.05412305f, 0.01992118f, 0.00285157f, -0.04235346f, 0.03150254f, 
    -0.03522545f, 0.02611389f, -0.04455709f, -0.03133759f, -0.02474686f, -0.04203767f, -0.00594693f, -0.05103920f, 
    0.00292630f, 0.02142853f, -0.02868543f, -0.01698332f, 0.02531035f, -0.05738203f, -0.02700925f, 0.01311589f, 
    -0.00864771f, 0.03329440f, -0.00151797f, -0.01210176f, 0.03492758f, -0.05265230f, -0.05766921f, -0.03532431f, 
    0.04356752f, -0.02227405f, -0.03367267f, -0.01766933f, -0.05581257f, 0.00158373f, 0.02068909f, -0.01520529f, 
    0.00797080f, -0.04875607f, -0.01248409f, -0.03341592f, -0.02018734f, -0.00708121f, 0.03332561f, -0.01719142f, 
    -0.00437494f, -0.03010166f, -0.03800386f, 0.02937154f, 0.03904906f, 0.03700958f, 0.03355951f, -0.04214698f, 
    0.01709236f, -0.03273434f, -0.04016408f, -0.03410850f, -0.01813396f, -0.02288259f, -0.00925055f, -0.02548962f, 
    -0.03396373f, 0.00705701f, -0.04500289f, -0.02468267f, 0.02109787f, 0.04065788f, 0.00909302f, -0.00987282f, 
    -0.00200988f, 0.00961931f, -0.02325900f, 0.03874120f, -0.05576083f, -0.04911428f, 0.02089540f, -0.02255780f, 
    -0.02527123f, -0.01711792f, 0.01265589f, -0.02321617f, 0.02419726f, 0.00074269f, -0.03752457f, -0.02357809f, 
    -0.01538007f, 0.00709673f, -0.03734486f, -0.03228389f, -0.05053328f, 0.00114878f, -0.02350372f, -0.05580928f, 
    0.00692954f, -0.02957691f, -0.04368654f, 0.03285688f, -0.00822761f, -0.04472747f, 0.03442749f, -0.02868575f, 
    0.00448795f, -0.04674197f, -0.04790831f, -0.00993842f, 0.00776024f, -0.01354818f, -0.00303940f, 0.02443394f, 
    0.04194471f, -0.01728940f, -0.01459076f, 0.00196618f, -0.04406014f, -0.03174989f, 0.04113218f, 0.02827705f, 
    0.04454255f, 0.01831758f, 0.01753069f, -0.03870520f, 0.00305574f, 0.02578622f, 0.03291553f, -0.05665750f, 
    -0.02647819f, 0.01740320f, -0.03271994f, 0.03975305f, 0.03616977f, 0.03475053f, 0.03346011f, 0.00787395f, 
    -0.02807070f, -0.00685639f, 0.00620359f, -0.04333850f, 0.02349782f, 0.00380345f, -0.00295103f, -0.01995846f, 
    0.00996068f, -0.03745066f, 0.03037683f, -0.05818864f, 0.03768108f, 0.00846840f, 0.00489602f, -0.03873351f, 
    -0.04425798f, -0.02088600f, 0.03778629f, 0.02817667f, -0.05919849f, 0.03526219f, 0.00268315f, 0.03738168f, 
    -0.03959741f, 0.04107498f, 0.01704409f, -0.01216975f, -0.01149743f, 0.01037126f, -0.03722206f, 0.00989932f, 
    0.03935855f, 0.03520124f, 0.01025457f, 0.04462367f, -0.00717056f, 0.03937009f, -0.04930905f, -0.02568405f, 
    0.02020234f, -0.04199528f, 0.02046211f, -0.02918615f, 0.00857180f, -0.05160270f, 0.02139094f, -0.05171233f, 
    0.00253313f, 0.03540209f, 0.00813551f, -0.01366542f, -0.01912277f, -0.04836551f, -0.02316455f, 0.04572466f, 
    -0.00801801f, -0.04406460f, -0.04307039f, -0.00264932f, 0.01642745f, 0.03421463f, 0.04703546f, 0.02928630f, 
    -0.04508374f, -0.01609164f, 0.00774653f, 0.01889872f, -0.00521412f, 0.02527170f, -0.02500036f, -0.02537616f, 
    -0.02441062f, -0.01323459f, -0.02966226f, 0.00013970f, -0.01083430f, 0.02417506f, -0.01300680f, -0.01240652f, 
    -0.02433314f, 0.03716297f, -0.02893135f, 0.02218012f, 0.01890112f, -0.02192159f, 0.03191998f, -0.03422664f, 
    -0.05274405f, 0.00284875f, 0.03054610f, -0.02002348f, 0.00353777f, -0.02722498f, -0.03378167f, 0.03889935f, 
    -0.01001635f, -0.04786693f, -0.05320700f, -0.01736446f, 0.04787417f, 0.00069403f, -0.02847136f, 0.02112988f, 
    -0.01096601f, -0.03876191f, 0.00631402f, 0.02206447f, -0.03320911f, 0.00602514f, 0.01773096f, 0.02652584f, 
    -0.03934574f, -0.01532507f, -0.04737169f, 0.02047606f, 0.04475307f, -0.04332184f, -0.02073728f, -0.00964767f, 
    0.00445709f, 0.04770767f, -0.03747842f, 0.01556067f, -0.02276292f, -0.01974679f, 0.02801105f, -0.00351880f, 
    0.02298962f, 0.00243917f, 0.02656149f, -0.02708901f, -0.03065074f, -0.01483126f, -0.00730135f, 0.03831021f, 
    -0.05781158f, -0.00235668f, -0.05191365f, -0.00413694f, 0.01326714f, 0.00062571f, -0.05284590f, -0.00123665f, 
    0.00097981f, -0.01997939f, -0.00359072f, 0.00023629f, -0.00743540f, 0.03803179f, -0.00671937f, -0.02144792f, 
    0.03060772f, -0.02373225f, 0.00182148f, -0.02658172f, -0.05069422f, -0.05480521f, 0.00832087f, 0.01381268f, 
    -0.01242512f, -0.04508449f, 0.02372616f, -0.03425043f, -0.02394132f, 0.02002622f, -0.01565368f, -0.05272780f, 
    0.01407650f, -0.01288298f, -0.03851420f, -0.00945620f, -0.01284187f, 0.03026889f, 0.03806505f, -0.03932725f, 
    0.00884090f, -0.05299582f, -0.04224605f, -0.04447376f, -0.00085935f, 0.04865716f, -0.03914018f, 0.03562422f, 
    0.04194746f, 0.02523115f, 0.00247520f, -0.04819968f, -0.02820116f, 0.04041151f, -0.05858786f, 0.03787318f, 
    0.04194840f, 0.02930136f, -0.01356370f, 0.01212848f, -0.03514734f, 0.00605758f, -0.04117066f, 0.04147212f, 
    0.03432237f, 0.04048259f, -0.00731691f, -0.00073705f, -0.01995469f, -0.04682883f, -0.02967353f, -0.01059581f, 
    -0.05682633f, -0.03392648f, -0.05703932f, -0.05312597f, -0.01029159f, 0.00791187f, 0.04916902f, -0.02354467f, 
    0.01564858f, 0.02436126f, -0.00385684f, 0.02745602f, 0.02040363f, -0.05596956f, -0.04752219f, 0.01922381f, 
    0.61742508f, 0.00021685f, -0.02309456f, -0.10661173f, -0.07250260f, -0.04772721f, -0.01667523f, 0.22146837f, 
    -0.03514956f, 0.03586079f, -0.00821572f, 0.14627086f, -0.05252793f, 0.11870030f, -0.04743617f, -0.00509254f, 
    -0.14891706f, 0.05927755f, -0.05205591f, 0.13079759f, -0.06791350f, 0.01338481f, -0.05931095f, -0.08794013f, 
    -0.06650872f, -0.00583298f, 0.01352050f, -0.17617963f, 0.10361870f, -0.01415369f, 0.01443282f, -0.01380546f, 
    -0.00533733f, 0.02412079f, -0.17575058f, -0.02618192f, 0.10386557f, -0.21611430f, 0.13338442f, -0.15547158f, 
    -0.10827508f, -0.07638675f, 0.00194102f, 0.06887990f, -0.06523532f, 0.02272712f, -0.02003791f, -0.10106570f, 
    0.26937360f, 0.21493152f, 0.19193277f, 0.00820780f, -0.06053130f, 0.06160930f, -0.07335608f, -0.05953351f, 
    -0.04640093f, -0.04676820f, -0.02983844f, 0.05310433f, 0.15509678f, -0.07124959f, 0.06270569f, -0.00046806f, 
    0.01678403f, -0.07180887f, 0.04117104f, -0.08401599f, -0.01504813f, 0.04914882f, -0.04705976f, 0.15057060f, 
    0.00763542f, -0.14536731f, 0.02614081f, 0.08752372f, 0.01751053f, 0.13351274f, -0.03416488f, 0.11655175f, 
    -0.09844711f, -0.09614655f, 0.02290881f, 0.04002141f, -0.13361585f, 0.02549614f, -0.12470809f, -0.12982374f, 
    -0.10548000f, -0.08963445f, -0.02780347f, 0.02653724f, -0.13871051f, -0.07873977f, -0.11960223f, 0.01810920f, 
    0.04882627f, 0.06808172f, -0.08579232f, 0.09940933f, 0.09207082f, 0.09383151f, 0.05136373f, -0.09772862f, 
    -0.02722718f, 0.03774235f, 0.16996720f, 0.07130513f, -0.20350474f, 0.02928136f, 0.08219995f, -0.00546462f, 
    0.04522153f, -0.04843048f, 0.05680768f, 0.14460324f, 0.01850768f, 0.02429800f, 0.11902808f, 0.13173620f, 
    0.09669284f, -0.03882752f, 0.03774480f, -0.12003426f, 0.07891339f, 0.09857558f, 0.01507568f, 0.11966687f, 
    0.05429693f, 0.02532735f, 0.05063258f, -0.00127194f, 0.09227995f, 0.11322751f, -0.04705441f, 0.31524956f, 
    -0.00900325f, -0.10287092f, 0.15667407f, 0.00416416f, 0.09999708f, 0.03994021f, 0.04650407f, 0.05588567f, 
    -0.22351849f, 0.00647796f, 0.00680623f, -0.05844196f, 0.09649244f, -0.00292397f, -0.08491712f, 0.02853428f, 
    -0.08080943f, 0.09180685f, 0.17496526f, -0.12325852f, 0.15011050f, 0.04567825f, 0.14218263f, -0.06317740f, 
    -0.03943570f, -0.01015315f, -0.04840529f, -0.04926398f, 0.05734679f, -0.04749137f, -0.19478360f, -0.09796220f, 
    0.35294372f, -0.12201479f, 0.10584375f, -0.05626978f, -0.08726361f, 0.00054212f, 0.10470175f, -0.03408454f, 
    -0.01994433f, 0.06040312f, -0.05275131f, 0.08454561f, 0.09168315f, -0.21741723f, 0.10418237f, 0.30719557f, 
    -0.04927830f, 0.10194471f, 0.04158917f, -0.01016698f, 0.00630702f, -0.06381913f, -0.03568500f, 0.12831889f, 
    -0.00709933f, -0.19232228f, 0.06477883f, 0.10851797f, -0.00494249f, -0.05226307f, 0.02536626f, 0.08415511f, 
    0.00318956f, 0.01091368f, -0.05413982f, 0.12737706f, 0.12823065f, -0.03792107f, 0.19714367f, 0.15519327f, 
    -0.07662643f, 0.07124525f, 0.10221794f, 0.13664296f, -0.05207011f, -0.01314829f, 0.05142829f, 0.03592291f, 
    0.07550392f, -0.06487869f, -0.03143664f, 0.00158753f, -0.07689956f, 0.09173381f, -0.00993771f, -0.00490148f, 
    -0.00641320f, 0.06445815f, 0.07460794f, 0.18265060f, -0.06640447f, -0.01861755f, -0.09920263f, -0.23008558f, 
    0.03536444f, 0.00111168f, 0.05407554f, -0.00706721f, 0.03697197f, 0.02922610f, 0.02961244f, -0.02730629f, 
    -0.24104078f, 0.04351018f, -0.07183420f, -0.18926682f, 0.05449039f, 0.15368427f, -0.10718944f, 0.03430054f, 
    0.10709458f, -0.02389160f, 0.03533445f, 0.11314769f, -0.02565414f, 0.04364200f, -0.03927569f, 0.00107997f, 
    -0.13777746f, -0.05101923f, 0.07550790f, -0.00759407f, 0.04923780f, 0.11279695f, -0.00058860f, 0.02425662f, 
    0.20428428f, 0.11684015f, 0.04336753f, -0.35139349f, -0.03317967f, -0.01908935f, 0.01542628f, 0.02956260f, 
    -0.04486061f, 0.03010849f, -0.08975872f, 0.07865443f, -0.04507555f, -0.05935561f, -0.08357839f, 0.03878586f, 
    -0.13062011f, -0.11127470f, -0.02309482f, 0.01785291f, -0.01591058f, -0.03310094f, -0.07593193f, -0.18134314f, 
    -0.17904496f, 0.26568896f, 0.22035818f, -0.25784776f, -0.03220662f, 0.10940328f, 0.05700883f, 0.03154895f, 
    0.10328506f, 0.00427505f, -0.08795273f, -0.11073618f, -0.05780330f, 0.06988703f, -0.03252688f, -0.11202969f, 
    0.21484129f, 0.11028261f, 0.05201589f, 0.08467897f, -0.02951389f, -0.02321339f, 0.03075643f, -0.00504168f, 
    0.53807092f, 0.07002281f, 0.15847975f, 0.07067140f, -0.07842703f, -0.00107507f, -0.11940182f, -0.16255309f, 
    0.09287286f, 0.09073602f, 0.13502029f, 0.04313648f, 0.10753854f, 0.12387294f, -0.06207646f, -0.12601821f, 
    -0.04715997f, 0.00002531f, -0.04106637f, -0.03038349f, -0.04819728f, -0.10676146f, -0.01243969f, -0.01210903f, 
    0.01987569f, 0.09832580f, -0.13561319f, -0.17047271f, -0.09382485f, 0.18429108f, 0.09707017f, 0.16445164f, 
    -0.11601327f, 0.04285762f, 0.06259690f, 0.02772918f, 0.07216974f, -0.00713333f, -0.03679480f, -0.14223745f, 
    0.02971550f, -0.09545570f, 0.10998010f, 0.11297726f, 0.12309315f, -0.01649952f, 0.04692675f, -0.14929774f, 
    -0.21979506f, 0.10194256f, -0.01220589f, -0.06403768f, -0.07386143f, 0.03827430f, -0.01017167f, 0.07869704f, 
    -0.01296389f, -0.06452951f, 0.20328319f, -0.01709308f, -0.15375593f, 0.03071856f, 0.03970094f, 0.22618291f, 
    -0.06723984f, -0.02838344f, 0.05605431f, 0.01180447f, 0.01113487f, 0.05439693f, -0.01060748f, 0.02220111f, 
    -0.00849793f, 0.02846562f, 0.01855815f, 0.03799160f, -0.05419812f, 0.01466176f, -0.00709927f, 0.00897692f, 
    -0.02457742f, 0.02440137f, -0.02150960f, 0.02799083f, -0.00672903f, -0.04528132f, -0.03771100f, -0.03212428f, 
    -0.03565061f, -0.00137517f, 0.01094566f, 0.00120208f, -0.05832966f, 0.04353394f, 0.04074893f, -0.04213062f, 
    0.02418290f, -0.02278567f, -0.01706081f, -0.03721561f, 0.02127827f, -0.03692357f, 0.01561373f, 0.01641199f, 
    -0.01875977f, -0.00718004f, -0.00170170f, -0.05942957f, 0.01816037f, 0.00182021f, 0.01780545f, -0.02353211f, 
    -0.01315489f, -0.00699714f, -0.04091917f, 0.00282468f, -0.04164496f, 0.01924773f, -0.00093372f, -0.01350663f, 
    -0.04419751f, -0.05841288f, 0.03725075f, 0.00981628f, -0.01022331f, -0.00455042f, -0.04907664f, -0.03470929f, 
    -0.05366513f, -0.02074802f, 0.04075489f, 0.01713982f, 0.01629562f, -0.00225856f, -0.00510596f, -0.05156456f, 
    0.04056170f, -0.03211339f, -0.01380769f, 0.02679959f, -0.04084837f, 0.00241883f, 0.03280803f, 0.00617440f, 
    -0.04495829f, -0.02314406f, 0.03851710f, 0.02900910f, 0.00210833f, -0.01150370f, 0.00317202f, 0.03738771f, 
    -0.04209542f, -0.00821458f, -0.01988069f, 0.03594118f, 0.04326460f, -0.04551885f, -0.02759905f, 0.01441317f, 
    0.01297997f, -0.01925447f, 0.03025001f, 0.04044549f, -0.01449754f, -0.01808557f, -0.06064472f, -0.00053639f, 
    -0.01524506f, 0.02276184f, 0.02484183f, -0.03657934f, -0.01980500f, 0.00068433f, 0.02183536f, 0.03439617f, 
    -0.05081768f, -0.01121289f, 0.01059546f, 0.03773050f, -0.00721026f, 0.03810095f, -0.04872836f, -0.03585085f, 
    0.00723218f, -0.04507420f, -0.00760698f, 0.00217648f, -0.03859863f, 0.02535334f, 0.02245237f, -0.03242441f, 
    0.04470834f, -0.00763226f, -0.00882308f, -0.00727477f, 0.00396369f, 0.00900961f, -0.03914474f, -0.00535119f, 
    -0.02111446f, 0.01387443f, 0.00911540f, -0.01929974f, -0.00001399f, 0.00943160f, 0.00790781f, 0.00250132f, 
    -0.04488323f, -0.03437871f, -0.02281773f, -0.01880326f, 0.03744910f, -0.01392475f, -0.03022696f, -0.01442726f, 
    0.00800188f, 0.04311422f, -0.04637352f, 0.02875810f, -0.00176059f, -0.02552231f, 0.03310340f, -0.03546403f, 
    0.02282167f, -0.00899386f, 0.01820526f, 0.04447703f, -0.06156110f, -0.04572906f, -0.03866373f, 0.00350438f, 
    -0.04007208f, 0.00775757f, 0.02308505f, -0.02659844f, 0.04454992f, 0.03802863f, 0.04256576f, -0.01728236f, 
    -0.05869848f, 0.01706171f, -0.04702292f, -0.06060467f, 0.01153262f, 0.01757676f, 0.03806962f, 0.01146017f, 
    0.01989993f, -0.02225866f, 0.03813072f, 0.03072254f, -0.05586038f, 0.00097595f, -0.03755622f, 0.01469783f, 
    -0.01419277f, -0.00643776f, -0.03530863f, -0.01006422f, -0.00088051f, 0.02198274f, 0.00839836f, -0.01728324f, 
    -0.02038621f, -0.02702192f, -0.01237664f, 0.00822924f, 0.00667734f, -0.05603888f, -0.05216792f, 0.03952913f, 
    -0.01191800f, 0.04619427f, -0.00823062f, -0.00766849f, -0.02189370f, 0.01731403f, 0.03177419f, -0.01740071f, 
    -0.03629948f, -0.02099587f, -0.00100676f, -0.04199598f, -0.02498456f, -0.03606608f, 0.02505342f, -0.00892855f, 
    -0.02317145f, 0.01931666f, 0.01425294f, 0.01058823f, -0.02131183f, 0.03607051f, 0.00952168f, 0.05010140f, 
    0.01541068f, -0.04559770f, 0.03850964f, 0.00472421f, 0.00831925f, -0.05039208f, 0.01328130f, -0.05950671f, 
    -0.04296426f, -0.01210094f, -0.01128114f, 0.04012261f, 0.03731833f, -0.04734163f, 0.04821505f, -0.02950940f, 
    0.02938759f, -0.03518652f, 0.00447887f, -0.04164048f, -0.01605567f, 0.00041881f, -0.00490913f, -0.04862040f, 
    -0.05284134f, -0.03357606f, 0.00033331f, 0.00383617f, -0.03191296f, -0.03136598f, 0.01943762f, -0.05173161f, 
    0.03828583f, 0.04259572f, -0.01282202f, -0.04486404f, -0.00316963f, -0.04862393f, -0.01910835f, -0.02389051f, 
    0.02450325f, -0.04931168f, -0.04045838f, -0.01913430f, -0.02759304f, -0.01248150f, -0.03835504f, -0.01042264f, 
    -0.01486141f, -0.01994123f, -0.05654997f, -0.04479147f, 0.03815151f, 0.01983138f, -0.02186761f, 0.03571429f, 
    0.02795155f, 0.01107931f, -0.01069628f, 0.02266276f, -0.04728866f, 0.03035996f, 0.03449703f, -0.05207841f, 
    0.00268775f, 0.04131428f, -0.01456222f, 0.01550846f, -0.04882880f, -0.00196618f, -0.00225950f, -0.00156393f, 
    -0.01116743f, -0.04408818f, -0.01424246f, 0.01530257f, 0.02961188f, 0.02887367f, 0.00397416f, 0.03341830f, 
    -0.00510315f, 0.02994472f, 0.03198199f, 0.02166380f, -0.00667990f, -0.00659043f, -0.02833415f, -0.00891013f, 
    -0.01187788f, -0.04570461f, -0.01480778f, 0.00381396f, -0.04737081f, -0.02348990f, 0.04153743f, 0.00930668f, 
    -0.00346213f, 0.03792010f, 0.00387198f, -0.02617095f, 0.03009756f, 0.04323933f, -0.02016274f, 0.01912824f, 
    -0.04601382f, -0.02419541f, -0.02464982f, -0.04586049f, -0.02174588f, -0.02865730f, 0.00014972f, 0.01311153f, 
    0.00378563f, 0.00513179f, 0.00904505f, -0.01412487f, -0.01852904f, 0.00089359f, -0.04397336f, -0.01326355f, 
    -0.01323152f, 0.01847039f, -0.00607060f, 0.01882466f, -0.05247216f, -0.02734494f, 0.04066914f, -0.03774793f, 
    0.01760643f, 0.03164576f, -0.01942333f, 0.00800877f, 0.02480261f, 0.03878404f, -0.00804707f, 0.03797186f, 
    0.02902733f, 0.02529960f, 0.04176415f, -0.00813520f, -0.02307315f, -0.04091507f, 0.01983997f, -0.00493026f, 
    -0.03547343f, 0.02691977f, -0.05458358f, -0.01119328f, -0.00698016f, -0.03865993f, 0.01879484f, -0.00767774f, 
    -0.00555141f, -0.02977447f, 0.00213403f, 0.00670757f, -0.04734255f, 0.00379102f, 0.01297426f, 0.00523984f, 
    0.00226364f, 0.04541377f, -0.01528743f, 0.02598131f, -0.01460630f, 0.01521141f, -0.02381769f, -0.02752257f, 
    -0.04446579f, -0.02714020f, 0.05023923f, 0.04219992f, 0.02060182f, 0.04265842f, 0.03203284f, -0.01418920f, 
    -0.00086758f, -0.00328407f, -0.04832539f, -0.01525901f, -0.04790163f, 0.04273713f, -0.03887979f, -0.04877974f, 
    -0.02573955f, -0.01167774f, -0.04476512f, -0.04242072f, -0.01278339f, -0.03618290f, -0.05055129f, -0.01657918f, 
    0.01551353f, 0.00115513f, -0.05239315f, 0.02015963f, 0.01883460f, 0.01490899f, 0.02408997f, -0.00697025f, 
    0.03056516f, 0.04383475f, -0.03071339f, -0.05209761f, 0.00890655f, -0.00647927f, 0.02280869f, 0.00353025f, 
    -0.01795626f, -0.04397799f, -0.03182008f, 0.04421880f, -0.00098306f, 0.03404037f, -0.02604993f, -0.02797577f, 
    0.01928624f, -0.00900015f, -0.00277616f, -0.05359960f, 0.03599877f, -0.00805687f, -0.01753996f, 0.03443686f, 
    0.03974306f, -0.04103682f, 0.01469214f, -0.00072768f, -0.05645215f, -0.03679547f, -0.04126637f, -0.05307255f, 
    -0.00754398f, -0.02607413f, 0.03155708f, -0.04759075f, -0.05261104f, -0.03278276f, -0.00823486f, 0.01682266f, 
    0.04104652f, -0.00928062f, -0.01993439f, -0.04862246f, -0.02642650f, -0.02587697f, 0.02907868f, 0.02681325f, 
    0.00910730f, 0.02094582f, -0.04476491f, -0.03945349f, -0.04458898f, 0.01237309f, -0.05327263f, -0.04935813f, 
    -0.04342149f, 0.03986583f, 0.03250653f, -0.05645980f, 0.04007345f, -0.01338218f, -0.01958192f, -0.05239366f, 
    0.02244952f, -0.01668394f, -0.02997746f, -0.03522514f, 0.03727815f, -0.03534425f, 0.00299263f, 0.01776602f, 
    -0.03680184f, 0.03263515f, 0.04478710f, 0.02596156f, -0.03554197f, -0.03786731f, -0.02049214f, 0.01819856f, 
    -0.04004433f, -0.04301706f, -0.02872905f, 0.02332715f, 0.03642194f, 0.04326582f, -0.01828866f, 0.03434270f, 
    -0.05128502f, -0.00494363f, 0.01812522f, -0.01734265f, -0.02545814f, -0.05214413f, 0.02672398f, -0.04322193f, 
    -0.01061460f, 0.04363536f, 0.01099241f, 0.01741790f, 0.01343546f, 0.00519681f, -0.01713375f, 0.00557237f, 
    -0.00184146f, -0.05701431f, -0.05413739f, -0.00223642f, -0.00130843f, 0.01471787f, -0.01711368f, -0.05471087f, 
    -0.03631179f, -0.03426944f, -0.01579519f, -0.05210999f, -0.01899248f, 0.00696898f, 0.02844564f, 0.00561470f, 
    -0.02440337f, 0.03987161f, 0.00910446f, -0.00928611f, 0.01022787f, -0.02045943f, 0.01410880f, 0.03599434f, 
    -0.01937633f, -0.02049537f, 0.04327359f, 0.03146688f, -0.02643328f, 0.01928928f, -0.03372990f, -0.03698630f, 
    -0.02437813f, -0.01782387f, 0.03186334f, -0.04020762f, 0.01422403f, 0.02701438f, 0.03729994f, -0.05357724f, 
    0.01556573f, -0.05269074f, -0.03693537f, 0.01657737f, -0.00157409f, 0.03955053f, -0.03487685f, -0.01065578f, 
    -0.04637627f, -0.04200638f, -0.02616089f, -0.01440743f, 0.02324861f, -0.04809161f, 0.03835555f, -0.01360189f, 
    -0.04175844f, -0.01046549f, -0.01718191f, -0.02564094f, -0.04880783f, 0.01675952f, 0.04292039f, 0.00741307f, 
    -0.03317202f, 0.03599695f, -0.04745381f, 0.02883617f, -0.00739460f, -0.02117147f, -0.01967390f, 0.00778908f, 
    -0.02270794f, -0.03881489f, 0.00363834f, 0.03538989f, 0.00783328f, -0.02779472f, 0.01936082f, 0.03761936f, 
    -0.03162986f, -0.02825913f, -0.04704332f, -0.04934123f, -0.01421462f, -0.00133244f, -0.02435517f, 0.02531445f, 
    0.02582536f, -0.00676842f, 0.02526642f, -0.04375352f, -0.04596740f, 0.01481261f, 0.00276022f, 0.04030375f, 
    -0.02130998f, 0.00007122f, 0.03083933f, 0.04443400f, -0.00961827f, 0.01857635f, -0.01322809f, -0.01279500f, 
    -0.00319422f, 0.03214678f, -0.01245122f, 0.02972162f, 0.03272036f, -0.01127580f, -0.00002841f, 0.02465646f, 
    0.00502911f, -0.04170470f, 0.01606802f, 0.03150097f, -0.01444587f, -0.04799920f, 0.00789993f, -0.00221367f, 
    0.03499470f, -0.04095226f, -0.02697925f, 0.00536704f, -0.01632704f, -0.01364470f, -0.02488249f, -0.05555718f, 
    0.00125740f, -0.03587878f, -0.01096947f, -0.00932266f, -0.01918668f, -0.00118511f, -0.05074005f, 0.03769219f, 
    -0.02339540f, -0.03781760f, 0.03512871f, 0.01726663f, -0.01733052f, 0.04488963f, 0.02266837f, 0.03128821f, 
    0.04105069f, 0.04007851f, -0.00934179f, -0.02994256f, 0.01095392f, 0.01878334f, 0.01093992f, 0.04336925f, 
    -0.02217467f, -0.05090206f, 0.03384596f, -0.01170695f, 0.02329086f, 0.01502413f, -0.02747090f, -0.05090398f, 
    0.01744570f, 0.02404671f, -0.04828556f, -0.00234433f, 0.01523687f, -0.01802135f, 0.00180338f, -0.01279193f, 
    0.00617215f, -0.02762423f, -0.03751469f, -0.00686640f, 0.03056877f, -0.01675919f, 0.01718417f, 0.01850600f, 
    -0.02427185f, -0.04658229f, -0.00803722f, -0.04976833f, -0.04101859f, -0.04947977f, -0.04565546f, -0.04312845f, 
    0.02569067f, -0.01519025f, 0.00064532f, -0.01805678f, -0.02035551f, 0.00054554f, -0.03638753f, -0.03625010f, 
    -0.02803197f, -0.02975133f, 0.01067433f, -0.03363581f, -0.00920358f, 0.05362022f, 0.02235962f, -0.00936776f, 
    0.02729774f, 0.03267049f, -0.04899580f, 0.02713179f, -0.03610552f, -0.00598445f, -0.01549658f, -0.04005551f, 
    -0.00170763f, 0.02132774f, 0.04083367f, -0.05379464f, -0.02019616f, -0.00947944f, -0.02787130f, -0.01306105f, 
    -0.04748264f, 0.01916089f, -0.03721667f, 0.01232328f, 0.03201284f, 0.04236682f, -0.04050215f, -0.02587836f, 
    0.02415159f, -0.02362668f, -0.01950233f, -0.01934496f, 0.01719422f, -0.00889520f, 0.01985395f, -0.04703299f, 
    -0.03343685f, 0.02962717f, 0.04303374f, -0.02879498f, 0.00324266f, -0.01557945f, -0.00643787f, 0.03930200f, 
    -0.10267078f, -0.07969920f, 0.01787390f, 0.04834281f, -0.04130816f, -0.02099817f, -0.03516098f, 0.00895791f, 
    -0.01095639f, 0.00532987f, 0.05787084f, 0.04284277f, 0.32094461f, -0.12338392f, -0.03274913f, 0.10602552f, 
    0.01615080f, -0.01683712f, 0.11479203f, -0.12543631f, 0.08866243f, -0.09361305f, -0.09919477f, 0.07931087f, 
    -0.09279198f, 0.07085255f, -0.23210482f, 0.00313753f, -0.01970463f, 0.03118249f, 0.00473466f, -0.10695168f, 
    0.09411775f, 0.00433224f, 0.08184079f, -0.00113927f, 0.00799411f, 0.26392755f, 0.06727494f, -0.14789860f, 
    0.00186800f, -0.12640290f, -0.00177110f, -0.08879881f, -0.09806224f, -0.06281456f, 0.10986876f, 0.02171862f, 
    0.10180771f, -0.04493943f, -0.08208066f, 0.04624367f, 0.01878115f, 0.08258102f, 0.00614234f, -0.10038457f, 
    -0.03272228f, 0.02437317f, -0.00012212f, 0.00569501f, -0.07591968f, 0.03164771f, 0.07110160f, -0.00207715f, 
    0.05960178f, 0.01826458f, 0.05553254f, -0.02249744f, 0.03751179f, -0.06610986f, -0.01504506f, -0.01960544f, 
    0.01056957f, -0.11136720f, 0.15018342f, -0.01942160f, 0.15735701f, 0.10794708f, -0.06519785f, -0.03696502f, 
    0.03000081f, 0.08994754f, -0.06722675f, -0.01708530f, 0.18569356f, 0.12315232f, -0.03283285f, 0.16734205f, 
    -0.03803652f, -0.07924357f, -0.01736066f, 0.13481151f, 0.08446426f, -0.00522061f, -0.04850140f, 0.06179193f, 
    0.15387665f, -0.03375457f, -0.14243039f, -0.00869942f, 0.08655791f, 0.04206717f, 0.09316766f, 0.14691252f, 
    -0.07295090f, 0.07897912f, -0.12255949f, 0.07011661f, -0.11812056f, 0.07363158f, 0.06006817f, 0.02126402f, 
    0.07177762f, 0.01996069f, 0.08278071f, -0.00496647f, 0.04039564f, 0.04564638f, -0.15235861f, 0.17276818f, 
    0.12305734f, -0.01564856f, -0.11345012f, 0.29617870f, -0.05282383f, 0.00671951f, 0.03257151f, 0.00940825f, 
    0.04954280f, 0.03561173f, -0.04134277f, -0.02272772f, 0.15847979f, -0.12755719f, 0.07811246f, -0.23277764f, 
    -0.09650119f, 0.00809592f, 0.03964888f, -0.11515930f, -0.02346745f, -0.00303896f, -0.09661105f, 0.02019419f, 
    0.10739184f, 0.14411639f, -0.10613793f, 0.18581752f, 0.02170131f, -0.07034019f, 0.12232902f, 0.15214548f, 
    0.05736285f, 0.01693746f, -0.17957473f, 0.15048002f, -0.03142347f, -0.08351534f, -0.06057752f, 0.02034741f, 
    -0.01614318f, 0.03351387f, -0.03788927f, -0.04293302f, 0.08518088f, 0.04107458f, 0.09625057f, -0.07003981f, 
    0.29196754f, -0.06442209f, 0.05470388f, -0.02183396f, 0.05486869f, 0.15507554f, -0.04384902f, -0.01332691f, 
    0.00111009f, -0.09909175f, -0.03765647f, -0.10903852f, -0.06470723f, 0.08350547f, -0.15798718f, -0.04590642f, 
    -0.03566620f, 0.04562110f, -0.00669738f, 0.15357624f, -0.06751500f, 0.09143350f, 0.11898458f, -0.07459740f, 
    0.51451927f, -0.09791459f, -0.47905388f, 0.05885421f, -0.00065138f, 0.01758209f, 0.02836843f, 0.03678962f, 
    0.10781281f, 0.04475389f, 0.04377086f, -0.02443849f, -0.09309389f, 0.07212126f, -0.16661543f, 0.03162551f, 
    0.01189414f, 0.03167992f, -0.11043426f, -0.12994380f, -0.01708451f, -0.06226769f, 0.01756443f, -0.08846127f, 
    0.01343585f, -0.15660381f, 0.02282792f, -0.00645357f, -0.06165252f, -0.00345884f, 0.06448042f, 0.08678528f, 
    -0.00094239f, -0.11477498f, -0.09884996f, 0.05161044f, 0.07638146f, -0.15826635f, -0.07580229f, 0.13346916f, 
    0.02450624f, 0.05171485f, 0.03907042f, 0.02867756f, 0.09176142f, 0.01803865f, -0.12741084f, 0.03127167f, 
    0.04227951f, 0.20460570f, -0.13670239f, 0.05463912f, -0.01059120f, -0.02571389f, -0.02086895f, 0.04366586f, 
    0.01347895f, 0.13735464f, 0.09816770f, -0.01833913f, 0.15643270f, -0.07368308f, 0.08355959f, 0.05728954f, 
    0.00162162f, -0.02052259f, -0.05864139f, -0.04170112f, -0.02951366f, -0.13839558f, 0.02714928f, -0.02765589f, 
    -0.13125004f, -0.04492659f, -0.02919756f, 0.15009673f, -0.01672291f, 0.06135609f, -0.01774582f, -0.02588072f, 
    -0.10045748f, -0.01470484f, 0.08577842f, -0.11354057f, 0.22137342f, -0.16171098f, 0.32148230f, 0.13272537f, 
    -0.03624387f, 0.05811996f, 0.02794115f, -0.06226140f, 0.02119652f, 0.00074628f, 0.08002577f, 0.06620269f, 
    -0.34624168f, 0.24033502f, -0.29348233f, 0.25057179f, 0.09789398f, 0.06639364f, -0.10332993f, -0.04560048f, 
    0.15860929f, 0.01714857f, 0.09289990f, 0.08502339f, 0.01382055f, 0.05559968f, -0.13719682f, 0.14420675f, 
    -0.14964409f, -0.04714129f, 0.08602957f, 0.02216800f, 0.17269109f, 0.08154425f, -0.00300785f, -0.03931243f, 
    0.20941053f, 0.03809057f, 0.04465670f, 0.05789278f, -0.00761681f, 0.00658290f, 0.11619701f, 0.02912661f, 
    -0.04100731f, 0.05271687f, 0.03087978f, 0.03766429f, 0.06025462f, -0.08288506f, 0.08406620f, -0.06719029f, 
    -0.10735534f, -0.04401135f, 0.06004819f, -0.12787506f, -0.08361582f, -0.03498937f, -0.00312136f, 0.12677339f, 
    -0.16788973f, -0.30657017f, 0.04614986f, -0.01865541f, 0.03424518f, -0.10833882f, -0.03929442f, -0.08772674f, 
    0.07454911f, 0.10731510f, -0.10322255f, -0.05027484f, 0.11345213f, -0.10271539f, -0.02202467f, 0.33407384f, 
    0.00233471f, 0.06353964f, 0.00247439f, -0.06373250f, 0.03156488f, 0.05107858f, 0.05182685f, 0.11675268f, 
    0.06714498f, 0.19947879f, -0.12638971f, 0.04845235f, 0.04374987f, 0.03382442f, -0.06796381f, -0.05668664f, 
    0.00127772f, 0.11843668f, -0.10519115f, -0.00511367f, -0.00301840f, -0.04269263f, 0.02185908f, -0.13202970f, 
    0.08776250f, -0.08933602f, -0.08030422f, 0.05156112f, 0.00603866f, -0.07089661f, 0.03867384f, 0.05547128f, 
    -0.09910519f, 0.00413197f, -0.09662345f, 0.04143452f, 0.07595568f, -0.09203241f, 0.04924730f, -0.05879261f, 
    0.03835594f, 0.16568270f, -0.03760112f, 0.01488276f, -0.28159690f, 0.08478612f, 0.08059536f, 0.04858726f, 
    0.04514118f, -0.06725758f, -0.05495752f, -0.01815606f, 0.04675382f, 0.13415445f, -0.09903044f, 0.12169036f, 
    0.00691131f, 0.06178607f, 0.05286971f, -0.06353345f, -0.04449864f, 0.07325799f, 0.08695298f, 0.07223889f, 
    0.11043641f, 0.05240585f, 0.02301209f, 0.03741103f, -0.08350804f, -0.06454314f, 0.10989010f, 0.16284153f, 
    -0.03145896f, -0.05527860f, -0.03790752f, 0.14467284f, -0.04529972f, -0.12434455f, -0.05750500f, 0.06477016f, 
    0.03236090f, 0.05840627f, -0.06204191f, -0.08191893f, 0.04729301f, 0.06845465f, 0.00921687f, 0.02190652f, 
    -0.00820545f, 0.01409177f, -0.02977342f, -0.07803985f, 0.23343550f, -0.14376055f, 0.00603730f, -0.00373651f, 
    0.00897266f, 0.01899515f, 0.00610082f, 0.04345350f, -0.06129637f, 0.00221621f, 0.09535161f, 0.12773678f, 
    0.27121258f, 0.04299941f, 0.00359419f, 0.03658841f, -0.02482058f, 0.04505884f, 0.07253136f, 0.11031061f, 
    -0.01699757f, 0.11089487f, 0.02874507f, 0.15495285f, -0.01411571f, -0.00795211f, 0.11558877f, 0.24869026f, 
    0.01866323f, -0.04873765f, 0.00520679f, -0.01381052f, 0.06054428f, 0.09615055f, -0.05235397f, 0.00082851f, 
    -0.27844834f, -0.08275118f, 0.23762783f, 0.20717719f, -0.05323943f, -0.03837506f, 0.03215769f, -0.04275910f, 
    0.01473936f, 0.03552983f, -0.02286917f, 0.05718528f, -0.03632458f, -0.15107843f, 0.02952760f, 0.13477261f, 
    -0.03818827f, 0.02831762f, -0.00952904f, 0.07803548f, 0.05770013f, -0.01820392f, -0.06997696f, 0.00230685f, 
    -0.05948767f, 0.30499876f, -0.29575816f, -0.37821823f, 0.04907142f, 0.01910939f, 0.01828204f, 0.00386441f, 
    0.07980409f, 0.06686354f, 0.07160721f, -0.02317375f, -0.05442705f, 0.12160280f, 0.02792335f, 0.10260353f, 
    -0.04837947f, -0.10194719f, -0.00839912f, -0.05186749f, -0.08572385f, -0.02368806f, -0.00058665f, 0.04934040f, 
    -0.06136772f, -0.05935957f, 0.12417340f, -0.00191782f, -0.00705287f, -0.00066576f, 0.02941597f, -0.01747877f, 
    -0.00199626f, 0.06648351f, 0.06118950f, 0.09634091f, -0.00866373f, 0.09634871f, 0.07701400f, -0.02953821f, 
    -0.11038464f, -0.01762998f, 0.02854766f, -0.00640299f, 0.06534573f, 0.01325674f, 0.09741209f, 0.07227147f, 
    -0.02877942f, 0.12336011f, -0.08144613f, 0.08056641f, 0.01353719f, 0.03531032f, 0.05005530f, 0.08153671f, 
    0.10264396f, 0.06085184f, 0.06473377f, 0.11843042f, 0.13482170f, 0.14219315f, 0.05116654f, 0.19428284f, 
    0.08560724f, 0.03306254f, -0.09392589f, -0.00795489f, -0.00107702f, -0.06821635f, 0.00608081f, 0.01022257f, 
    -0.20131642f, -0.17603818f, 0.26039433f, -0.03129774f, 0.10699279f, 0.10964892f, -0.05899721f, 0.02097086f, 
    0.00890747f, -0.03432998f, -0.04766691f, -0.01968570f, 0.01844150f, 0.08181852f, 0.01068205f, -0.21509683f, 
    0.01032691f, 0.10641554f, -0.01482870f, -0.00230470f, 0.08149900f, -0.00460071f, -0.05207999f, 0.08614735f, 
    0.09551919f, -0.08019305f, 0.00511559f, 0.16997558f, 0.08092539f, 0.07917137f, -0.01699879f, -0.01355923f, 
    0.04327094f, 0.07545719f, 0.01739596f, 0.12257287f, 0.13928135f, 0.13977510f, 0.06854422f, -0.13264613f, 
    0.03342050f, 0.01628771f, -0.00577367f, 0.05611227f, 0.04485649f, -0.12673497f, 0.05416939f, 0.00277964f, 
    -0.07301167f, -0.08153602f, 0.15024447f, -0.16002867f, 0.03528786f, 0.10922198f, 0.15909395f, -0.03591614f, 
    0.05055668f, 0.05194432f, 0.06683553f, -0.04465950f, 0.06851092f, -0.01021339f, -0.06654491f, 0.11937458f, 
    -0.00624289f, -0.07931039f, -0.11626902f, 0.03491050f, -0.06049124f, -0.11381954f, -0.00846436f, 0.04763687f, 
    0.09547589f, -0.09784225f, 0.01535994f, -0.15902868f, -0.05057567f, -0.08631079f, -0.03983892f, 0.09751286f, 
    0.04931183f, 0.01574726f, -0.03482376f, 0.05409010f, -0.09439986f, 0.22065724f, -0.16860980f, -0.12876795f, 
    0.03448228f, 0.00803013f, 0.01432370f, 0.10477835f, -0.01511276f, 0.05120354f, 0.10559843f, -0.03116763f, 
    -0.12594596f, -0.01554385f, -0.13649972f, -0.23335189f, -0.16362740f, 0.01200778f, -0.06564643f, 0.10695668f, 
    -0.02666881f, -0.01726063f, 0.00891599f, -0.10891218f, -0.36712664f, -0.03215394f, 0.08427633f, -0.19492055f, 
    0.11662150f, 0.07148284f, 0.05090829f, -0.09239552f, 0.11558700f, 0.06746624f, 0.04677153f, 0.18245718f, 
    -0.24700144f, -0.16701809f, -0.09688900f, 0.01294379f, -0.00342648f, 0.05620019f, 0.05209140f, -0.01988163f, 
    0.08455736f, -0.05192375f, -0.08954781f, 0.10375658f, -0.08821614f, 0.11600323f, -0.22364256f, 0.07476514f, 
    0.00179408f, -0.11858667f, 0.03000504f, 0.04938174f, 0.00970057f, -0.02223623f, -0.01172710f, 0.07264161f, 
    0.04255437f, -0.06174646f, 0.11682574f, 0.01982143f, 0.04666138f, 0.12898219f, 0.04749245f, 0.02672983f, 
    0.10444300f, -0.14847137f, 0.03928239f, 0.09824730f, -0.21346332f, 0.01543806f, 0.07346173f, -0.24086648f, 
    0.04241337f, -0.04519885f, -0.08601298f, 0.05864152f, 0.07375773f, 0.01919140f, 0.05162844f, -0.06281128f, 
    -0.04673936f, -0.04145984f, -0.01479067f, -0.12552941f, -0.09580164f, 0.04285487f, 0.09234489f, 0.11054666f, 
    0.14686510f, 0.02575447f, 0.09868881f, 0.01670816f, 0.08285689f, -0.09416696f, 0.02056312f, -0.00958861f, 
    0.00633384f, -0.00935608f, 0.02522500f, 0.04712920f, 0.07498480f, 0.01019474f, 0.04082048f, -0.02191418f, 
    0.39313784f, 0.00217105f, 0.21601984f, 0.08011038f, 0.00246566f, -0.05361159f, 0.10236514f, 0.24972077f, 
    0.04996407f, -0.07075685f, -0.02099573f, 0.09071867f, 0.24312188f, -0.02354880f, -0.05835173f, -0.06410192f, 
    -0.02051442f, -0.06635667f, -0.08802404f, 0.03069898f, 0.04372189f, -0.00006975f, 0.00465040f, -0.03814570f, 
    -0.07317253f, 0.01802916f, 0.05847161f, 0.01675964f, 0.04433734f, -0.05639398f, 0.02868125f, -0.05035697f, 
    0.00829359f, 0.02444515f, -0.08824948f, -0.09907010f, 0.11152510f, 0.21863103f, 0.14098696f, 0.06990215f, 
    -0.05755712f, -0.00731334f, -0.04978091f, 0.12704299f, -0.00198135f, 0.25144160f, 0.07169920f, -0.07504024f, 
    0.12664494f, 0.04979692f, 0.01330804f, -0.07863320f, 0.08103067f, 0.04874204f, 0.07440486f, -0.13409753f, 
    0.09090423f, 0.08921054f, 0.10516202f, 0.07342669f, -0.18178053f, 0.27710962f, 0.10276784f, 0.14028375f, 
    0.02707281f, 0.01947576f, 0.03509453f, -0.01956032f, -0.05544756f, 0.07187275f, 0.00460578f, -0.05957017f, 
    0.06253553f, 0.01769502f, -0.07818878f, 0.01132099f, 0.05691490f, 0.11669163f, -0.06283917f, 0.05368079f, 
    0.01758257f, -0.10453420f, 0.02532502f, -0.14262241f, 0.14279146f, -0.03260601f, -0.11866386f, -0.07541630f, 
    0.01083894f, -0.13557225f, 0.00283838f, -0.03625574f, 0.07637756f, -0.05187384f, -0.01674194f, 0.00412760f, 
    0.15586489f, 0.01685860f, -0.12787238f, 0.11467650f, 0.02718834f, 0.06811347f, 0.02320766f, -0.03777410f, 
    -0.04474485f, 0.01286712f, 0.13781561f, -0.01015900f, -0.15025558f, 0.18214689f, -0.12409443f, 0.01150763f, 
    0.03317935f, -0.01035768f, 0.13612337f, 0.03502347f, -0.01751472f, 0.17103171f, 0.13479808f, 0.00160936f, 
    0.10806233f, 0.13376541f, 0.00927940f, 0.10437534f, 0.04252257f, -0.00625248f, 0.04448212f, -0.08571182f, 
    0.03829764f, -0.07750330f, 0.08211133f, 0.00637926f, 0.10925239f, -0.09822453f, -0.13590547f, -0.01305845f, 
    -0.05392747f, 0.15433045f, 0.04885887f, -0.05906976f, 0.00031963f, 0.11729952f, -0.05666953f, -0.02409621f, 
    0.18837892f, -0.07542380f, -0.14621696f, -0.24427190f, -0.01397024f, -0.02793025f, 0.01700545f, -0.03372514f, 
    0.04417128f, 0.01586710f, 0.05756165f, -0.07978335f, -0.04052296f, 0.03430751f, 0.11998621f, 0.00989719f, 
    0.03417976f, 0.04180968f, 0.00443226f, 0.05174812f, 0.10550659f, -0.03922176f, -0.10126346f, -0.15227091f, 
    -0.00971799f, 0.07780760f, 0.12689409f, 0.12262639f, -0.04512699f, 0.03636413f, 0.07360319f, 0.05610613f, 
    -0.02216005f, -0.05910471f, -0.09292179f, 0.01587804f, -0.28287441f, -0.03757347f, -0.04901719f, -0.04907539f, 
    -0.13675486f, -0.03131244f, -0.03493460f, 0.10078732f, 0.01157931f, 0.10122804f, 0.01171566f, 0.11542425f, 
    -0.05748841f, 0.12094659f, -0.16229339f, -0.24564357f, -0.06049941f, -0.01759299f, -0.02349891f, -0.11061983f, 
    -0.02595600f, 0.02194844f, 0.03372965f, 0.08353824f, -0.11825500f, 0.11627451f, 0.15546519f, -0.00739160f, 
    -0.02018343f, 0.04007047f, 0.07916184f, 0.01152164f, -0.09421369f, 0.10726090f, -0.03184927f, 0.07620566f, 
    -0.01834379f, -0.03265028f, -0.09038011f, 0.02596954f, -0.00125704f, -0.04054910f, -0.00284485f, 0.15038534f, 
    -0.06353637f, -0.03019674f, -0.03537359f, 0.01640247f, -0.27688137f, -0.09535442f, 0.12058211f, 0.05592173f, 
    -0.00513179f, -0.13384125f, -0.06720338f, -0.06038012f, -0.07915410f, 0.10277128f, 0.01191563f, -0.02084078f, 
    -0.00636445f, 0.05314481f, 0.06656181f, 0.01444829f, 0.00820172f, -0.05424714f, -0.03219311f, 0.03579125f, 
    0.20909576f, -0.00369863f, -0.04403168f, 0.03226039f, -0.00412205f, -0.17280045f, -0.21907443f, 0.03748621f, 
    0.00717584f, 0.10727978f, 0.05687483f, 0.02760695f, -0.01601492f, 0.08396100f, -0.01515327f, 0.01459328f, 
    0.14812195f, 0.23063083f, 0.15441962f, 0.14693834f, -0.01279022f, -0.00768299f, -0.00209318f, 0.04685207f, 
    0.01374511f, 0.04477160f, -0.07570819f, -0.02229585f, 0.17038691f, -0.11692623f, -0.14797676f, 0.11228138f, 
    0.00477962f, -0.04407787f, 0.00582989f, 0.00929336f, -0.04473555f, -0.07319456f, -0.05490785f, -0.04247732f, 
    0.17949772f, 0.17018920f, 0.00125093f, 0.16326696f, 0.14969610f, 0.14250904f, 0.17860100f, 0.01808152f, 
    0.11615673f, 0.03818011f, -0.10593219f, 0.05165201f, 0.10999592f, -0.03136665f, -0.00016681f, 0.10610805f, 
    -0.07557002f, 0.01582209f, -0.09588581f, -0.05540700f, -0.09565430f, 0.02176377f, -0.01089867f, -0.04345636f, 
    -0.00177358f, 0.10970658f, 0.17844918f, 0.12645929f, -0.04170802f, 0.10379878f, -0.11858704f, -0.04860322f, 
    0.03756134f, -0.05707938f, 0.09405674f, -0.03905168f, -0.02815865f, 0.09797053f, 0.30289385f, -0.02599020f, 
    0.10214012f, 0.00273449f, -0.02411795f, 0.09196368f, 0.00833322f, -0.05485206f, -0.02481295f, -0.06476197f, 
    -0.04623937f, 0.07735040f, 0.25428101f, 0.00503847f, -0.00838372f, 0.00628153f, 0.04935211f, -0.00370151f, 
    -0.12164821f, 0.08683166f, 0.08997461f, 0.05921273f, 0.00899995f, -0.03191555f, -0.04756561f, 0.03977558f, 
    -0.04565086f, -0.06219541f, -0.02337134f, 0.03025746f, 0.05753336f, 0.11836005f, 0.08091894f, -0.03242947f, 
    0.24008617f, 0.18665712f, -0.06507951f, -0.01229130f, 0.03255704f, 0.03099232f, 0.01604731f, -0.09839272f, 
    -0.04958558f, -0.09408814f, 0.12143373f, -0.05765204f, -0.23024721f, 0.20961092f, 0.00720273f, 0.06966490f, 
    -0.04362606f, -0.00555364f, 0.04601271f, 0.03480287f, -0.06978978f, -0.00586811f, 0.10024334f, 0.00226655f, 
    0.07427408f, 0.06486154f, 0.01561933f, -0.03457846f, 0.05388850f, -0.08836349f, 0.01991175f, -0.04391187f, 
    0.02481996f, -0.11490335f, -0.00696310f, -0.03038366f, 0.53429794f, -0.01489513f, 0.05195494f, -0.11997591f, 
    0.11776584f, -0.04816874f, 0.02957934f, -0.19644932f, 0.03683472f, 0.08210295f, -0.07508653f, 0.05090068f, 
    0.01451443f, 0.02656717f, -0.07083341f, -0.05444637f, 0.01664541f, -0.08900023f, 0.09674279f, -0.00714470f, 
    0.00038555f, 0.08598869f, 0.12057786f, -0.03358283f, -0.01271849f, 0.11851594f, -0.04683284f, 0.12525880f, 
    -0.07659735f, -0.02732332f, -0.03858310f, 0.00841493f, -0.00304941f, -0.01495986f, -0.07863211f, 0.09719066f, 
    0.04681843f, -0.19939631f, 0.09707493f, 0.00592561f, 0.02029301f, 0.03356819f, 0.00014688f, 0.00661537f, 
    0.20832194f, -0.06347936f, -0.01057025f, -0.11809759f, 0.26667845f, 0.20214303f, -0.06040862f, 0.13649900f, 
    0.01993590f, -0.02422806f, -0.07093403f, 0.06633304f, 0.08030904f, -0.10573599f, 0.06281382f, 0.04918892f, 
    -0.10743854f, 0.02633894f, -0.16390321f, 0.02519327f, 0.01902461f, -0.07004993f, -0.03095412f, -0.10695334f, 
    0.03869033f, 0.02647506f, -0.06545410f, 0.00980442f, 0.20911923f, -0.14315787f, -0.09977917f, 0.13506745f, 
    0.09899120f, 0.09709918f, 0.02490121f, 0.03625623f, 0.04797532f, 0.06419767f, -0.01427961f, 0.10052855f, 
    0.04855376f, 0.03374566f, -0.19729821f, 0.14733511f, 0.10543153f, -0.07996967f, -0.03361305f, 0.00654064f, 
    0.04908391f, -0.07543304f, -0.05346280f, 0.05209871f, 0.31633645f, 0.05307179f, -0.05657643f, 0.02667800f, 
    0.08015224f, 0.08257876f, 0.08024005f, -0.07183424f, 0.06061485f, 0.02254530f, -0.14461543f, -0.03995198f, 
    -0.35455623f, 0.02225470f, 0.03714642f, -0.08054151f, 0.00535783f, -0.01691279f, 0.09397873f, -0.03711821f, 
    0.00621034f, 0.05036291f, 0.09365521f, 0.09285669f, -0.33221248f, 0.08811787f, -0.17395432f, 0.13378695f, 
    -0.06099786f, -0.04312751f, -0.01558925f, -0.05276031f, -0.10010453f, -0.02263095f, -0.00870700f, 0.02691681f, 
    0.35901651f, 0.01181260f, 0.08914109f, -0.12236752f, 0.13828640f, 0.02541544f, 0.09334306f, -0.09962756f, 
    0.06140460f, -0.02741633f, 0.07887804f, 0.06381974f, -0.07126696f, -0.22805293f, 0.02503627f, 0.05854952f, 
    -0.03946561f, 0.02395063f, 0.09716222f, 0.13684058f, 0.04540281f, 0.10179911f, 0.07669190f, 0.13226125f, 
    0.13995405f, -0.16920152f, -0.03651891f, 0.07179506f, 0.08832821f, -0.04032807f, -0.01259952f, 0.04122585f, 
    0.07402326f, 0.05174189f, -0.03122825f, 0.05498883f, -0.02248922f, -0.00985201f, -0.05622417f, 0.09782748f, 
    0.03925786f, -0.04667853f, -0.09284069f, -0.04348309f, -0.03084747f, 0.02485465f, 0.00389618f, 0.01919063f, 
    -0.04026009f, 0.12331416f, 0.13843252f, -0.30531964f, -0.03669368f, -0.05244684f, 0.07261342f, -0.09225971f, 
    -0.05839871f, 0.02442220f, 0.12431878f, 0.06388585f, -0.15651157f, -0.19809972f, -0.03986355f, -0.05711697f, 
    -0.05365952f, -0.04056005f, -0.06594849f, -0.02191643f, -0.04464159f, -0.06082124f, 0.06256395f, 0.00044775f, 
    0.15586938f, 0.05844636f, 0.01445884f, -0.00945369f, 0.02283528f, 0.05716220f, -0.09546411f, -0.05657068f, 
    0.02306219f, 0.00194572f, -0.00952550f, -0.10058138f, -0.13535446f, 0.07152185f, 0.07467283f, -0.09427879f, 
    0.04511632f, 0.02119092f, 0.03792186f, 0.02706226f, -0.07544380f, 0.05850361f, -0.00490687f, -0.00926925f, 
    0.00746389f, 0.02579896f, -0.06408390f, -0.18988174f, -0.06346133f, -0.02647587f, 0.05589977f, 0.12130306f, 
    0.08473065f, 0.07038830f, 0.02193467f, -0.05422774f, 0.15035240f, -0.04024368f, -0.13389589f, 0.03311144f, 
    0.17952532f, 0.10192825f, 0.00802655f, -0.04389592f, 0.04563783f, -0.09937578f, 0.13660711f, 0.06596804f, 
    0.01037661f, 0.04898657f, 0.08918498f, -0.09538630f, -0.04245771f, -0.01882755f, 0.06721473f, 0.23638488f, 
    0.04246729f, 0.04282453f, 0.05275870f, 0.01873784f, 0.10586965f, -0.07928054f, 0.03039372f, 0.07931336f, 
    0.13303457f, -0.07445588f, 0.04850889f, -0.03239466f, -0.03156764f, 0.09557059f, 0.05756881f, 0.16070148f, 
    0.06560338f, -0.17280725f, 0.13052474f, -0.33978617f, -0.07104658f, -0.01101625f, -0.06259421f, -0.02715699f, 
    -0.02919441f, -0.00600048f, 0.09356592f, -0.04745330f, 0.18592913f, 0.14979938f, -0.19294439f, -0.10701402f, 
    0.01180308f, 0.05656538f, 0.02905065f, -0.03103259f, 0.05728350f, 0.05300938f, 0.01975467f, 0.02392702f, 
    -0.03205089f, 0.00048559f, 0.01466838f, 0.23979442f, -0.08089507f, -0.02623009f, -0.08303528f, 0.05937569f, 
    0.00676355f, 0.02849514f, -0.09352803f, 0.05251259f, 0.06515384f, 0.12674168f, 0.20043631f, -0.15980788f, 
    -0.02516396f, -0.04520265f, 0.00961305f, 0.12277789f, 0.05529067f, 0.01601787f, 0.04043850f, 0.07400177f, 
    0.29839441f, -0.05803724f, 0.12804779f, -0.18441872f, 0.01945687f, -0.06541533f, 0.10537840f, -0.02901772f, 
    -0.12427559f, 0.00189602f, -0.01486621f, 0.01587435f, 0.03288315f, -0.04243266f, -0.02661374f, -0.03170088f, 
    0.14376359f, 0.04529689f, 0.01112532f, -0.03329771f, -0.03950450f, 0.00296266f, 0.01625130f, 0.16577461f, 
    -0.11366383f, -0.05016248f, 0.13578631f, -0.08436918f, 0.01896496f, 0.00124606f, -0.01187869f, -0.01080061f, 
    0.05138403f, 0.05685331f, 0.00235515f, 0.07917104f, -0.00610679f, 0.10834353f, -0.05132158f, -0.22240885f, 
    -0.00579169f, 0.07213754f, 0.07642099f, 0.00304096f, 0.11146953f, 0.09998850f, -0.01037031f, 0.01736459f, 
    -0.27231783f, -0.06878095f, -0.01168202f, 0.01080580f, -0.11726394f, 0.01986449f, 0.10649703f, -0.21350232f, 
    -0.05342177f, 0.06500485f, 0.02840917f, -0.07991073f, -0.40019858f, 0.12020457f, 0.08278347f, 0.05518516f, 
    0.26870343f, 0.11991443f, 0.02828944f, -0.03349898f, 0.02782247f, -0.01671495f, 0.08668566f, -0.01785625f, 
    0.03378449f, 0.06393686f, -0.20748003f, 0.07158042f, 0.02476854f, 0.07148380f, -0.09909894f, 0.13738452f, 
    0.04326502f, 0.00984174f, 0.06606576f, 0.05517790f, -0.16737951f, -0.04412407f, 0.06597574f, -0.11168378f, 
    0.07256042f, 0.05216861f, 0.11755320f, -0.01882203f, 0.02473426f, -0.02654224f, 0.03031176f, 0.04971868f, 
    -0.16725388f, -0.01570652f, -0.07108427f, 0.07933420f, 0.00593092f, -0.00075018f, 0.04752651f, 0.17431891f, 
    -0.01314005f, 0.08650696f, 0.05071303f, -0.01998056f, -0.04122248f, -0.31391022f, 0.13158914f, 0.03883038f, 
    -0.05897046f, -0.00757904f, 0.13697608f, 0.04042793f, 0.10854787f, 0.02858520f, 0.11830262f, -0.07452188f, 
    -0.11028314f, 0.16229227f, -0.05331974f, -0.21659110f, 0.00195172f, -0.06520366f, 0.09780654f, -0.03557280f, 
    0.01609898f, 0.06838600f, 0.11436023f, 0.07772461f, -0.20642249f, 0.14226787f, 0.10297421f, -0.01034293f, 
    0.25663280f, 0.15972471f, -0.02186544f, 0.05754692f, 0.07313103f, 0.06619024f, -0.01885306f, -0.03729980f, 
    -0.03942702f, 0.07152598f, 0.08407162f, -0.26593468f, 0.07547598f, 0.01583850f, -0.05588031f, 0.04522472f, 
    0.00029620f, 0.03744549f, -0.06407024f, 0.03697453f, -0.13096033f, 0.04797198f, -0.06757604f, 0.12801605f, 
    0.01171872f, 0.01162600f, -0.00148321f, -0.00318358f, 0.07001898f, -0.01439147f, 0.09071938f, 0.02222748f, 
    -0.02587533f, 0.07287098f, -0.20572150f, 0.12974389f, 0.05101989f, -0.00438934f, 0.03625658f, -0.01536477f, 
    0.05242560f, 0.07016104f, 0.00658170f, 0.04334644f, 0.21111088f, -0.08875482f, 0.20417106f, -0.23855175f, 
    0.07062606f, 0.00530609f, -0.09496074f, 0.11634050f, 0.02583045f, 0.01367038f, 0.05591425f, -0.00905473f, 
    -0.18721554f, 0.00661909f, 0.04379170f, 0.13145515f, 0.08127131f, 0.13995670f, -0.00492927f, 0.06878223f, 
    -0.08829872f, -0.02778611f, -0.03842159f, 0.16792290f, 0.00752986f, 0.16777615f, -0.10252548f, -0.07999051f, 
    0.05204939f, -0.00590308f, 0.00351660f, 0.00065137f, 0.00155319f, 0.05723321f, 0.10507219f, 0.09092704f, 
    -0.01102485f, 0.12025165f, 0.13994747f, -0.01195678f, 0.10292158f, 0.01236922f, 0.00279207f, -0.00266414f, 
    0.14323451f, 0.00431974f, 0.10317045f, 0.08434123f, 0.37340698f, -0.05070585f, 0.00004932f, -0.11717457f, 
    0.06307773f, 0.00294031f, 0.00771150f, -0.06059832f, 0.03390400f, -0.02176107f, 0.07788295f, -0.07124835f, 
    -0.34511405f, 0.01326684f, 0.08570990f, 0.31952545f, 0.15088591f, 0.10611039f, -0.00782800f, -0.01720646f, 
    0.09182841f, -0.03917903f, 0.02895595f, -0.12525316f, 0.23949225f, -0.01602867f, -0.17154090f, -0.08777121f, 
    0.03103559f, 0.02267331f, -0.02171207f, -0.01100767f, 0.16580178f, 0.03090919f, -0.03505467f, -0.00694295f, 
    0.06835723f, -0.04640796f, 0.03843911f, -0.02551934f, 0.05101829f, -0.15319179f, 0.01532312f, -0.02024809f, 
    -0.01888140f, 0.02317009f, -0.01390713f, -0.01027303f, 0.20921281f, 0.11850223f, -0.13502367f, 0.02969692f, 
    -0.00505864f, -0.00123060f, 0.07658435f, 0.04258293f, 0.05339201f, -0.07250857f, -0.00052968f, -0.00702187f, 
    0.20158568f, -0.13880415f, -0.07451318f, 0.24217200f, -0.00820922f, 0.02515682f, 0.07206921f, -0.00701156f, 
    -0.02802140f, 0.04942703f, -0.03686449f, -0.05740345f, -0.13692227f, 0.22455323f, 0.07744458f, -0.11964324f, 
    0.09259009f, -0.02674680f, -0.03847753f, -0.02760746f, -0.06485419f, -0.03008450f, 0.04261386f, -0.04965714f, 
    0.03328257f, -0.09766223f, 0.01006707f, 0.20623989f, -0.07044263f, 0.02468052f, 0.01729350f, -0.08150715f, 
    0.00167227f, 0.09192183f, 0.13358979f, 0.01785079f, -0.11425593f, 0.36508244f, -0.04922615f, -0.32818151f, 
    0.13152471f, 0.05223342f, 0.03975410f, 0.03733088f, 0.06902165f, 0.02911958f, 0.03285063f, 0.08774831f, 
    -0.24923702f, -0.21462981f, -0.21976952f, 0.41787070f, 0.07603031f, 0.00756619f, -0.04575939f, 0.04393703f, 
    -0.06190131f, 0.04930482f, 0.12157091f, 0.06533884f, 0.17937364f, -0.26694560f, 0.01162989f, -0.00439606f, 
    -0.03372830f, 0.00892741f, 0.01108558f, 0.04780239f, 0.07856762f, 0.00651277f, -0.01115348f, 0.09004024f, 
    -0.21298319f, -0.04168127f, 0.02835565f, -0.26953790f, 0.10228457f, 0.07927156f, 0.19223008f, 0.04210714f, 
    0.00140020f, 0.04462642f, -0.03068992f, -0.00418639f, 0.00663026f, -0.05080534f, -0.05158246f, 0.20110038f, 
    -0.05066697f, 0.04609924f, 0.02522772f, -0.01721883f, 0.13122278f, -0.00809659f, 0.08913480f, 0.15421799f, 
    -0.16356459f, 0.27736625f, -0.09117632f, 0.27437598f, 0.00877214f, -0.05411613f, 0.00519756f, -0.03286967f, 
    0.20999208f, -0.09686880f, -0.12618361f, -0.05192104f, -0.19812587f, 0.08997917f, -0.09361634f, -0.09690861f, 
    0.11639049f, 0.00382364f, -0.03710566f, -0.00996104f, -0.01171940f, 0.03149318f, -0.06083544f, 0.05573273f, 
    -0.08297355f, 0.06295664f, 0.03704166f, 0.20638578f, 0.08207958f, -0.00136451f, -0.03064327f, -0.01001182f, 
    0.02167598f, 0.12725076f, -0.06407797f, -0.01324127f, 0.23330680f, -0.25551397f, 0.01878219f, 0.17664342f, 
    0.04193052f, -0.05904311f, -0.00510165f, -0.03762970f, -0.03021797f, 0.02181708f, 0.03513739f, 0.05932286f, 
    -0.00123114f, 0.02393988f, -0.00930142f, 0.00980197f, 0.01263155f, 0.01063060f, 0.04578580f, -0.03519798f, 
    0.02407647f, -0.03749846f, -0.01431505f, 0.04037498f, -0.04828047f, -0.00392924f, -0.04020257f, 0.01391904f, 
    -0.04859209f, 0.02100392f, -0.00485236f, -0.02127855f, -0.03954956f, -0.01875442f, 0.02462778f, 0.04097024f, 
    0.03843883f, 0.03651805f, -0.02182685f, 0.02644451f, -0.04656971f, 0.00617672f, -0.04335270f, 0.00863823f, 
    0.00255533f, 0.04415445f, -0.00976693f, -0.02707632f, -0.00549953f, 0.03898200f, -0.03412980f, -0.01656017f, 
    -0.01621257f, 0.02711075f, 0.02465981f, 0.01931771f, 0.01260957f, -0.01623763f, -0.00091579f, -0.00891450f, 
    0.04596530f, -0.01229859f, -0.02470211f, -0.04319979f, -0.05094545f, -0.00324414f, -0.00758484f, -0.00300419f, 
    -0.01483274f, 0.04536527f, -0.03420670f, -0.00884342f, 0.03256578f, -0.02295469f, -0.01417515f, -0.04547748f, 
    0.04015519f, 0.03663698f, -0.04000133f, -0.04465216f, 0.00458997f, -0.01292203f, -0.02533712f, 0.04268168f, 
    -0.05787791f, 0.02425193f, -0.02884090f, -0.02029074f, -0.03006064f, 0.02630304f, 0.02658295f, 0.04392824f, 
    -0.04098167f, -0.04627556f, -0.05735155f, -0.04862786f, -0.00905010f, -0.04341182f, 0.03510415f, 0.02113116f, 
    0.04351109f, -0.03012573f, 0.04317083f, 0.02171545f, -0.01065831f, -0.00067381f, 0.00900996f, -0.02064724f, 
    -0.04043834f, 0.02185640f, 0.03462300f, -0.03243773f, 0.01046707f, 0.00868314f, 0.03236737f, 0.00022758f, 
    -0.02782228f, 0.03698147f, -0.03432420f, -0.04168608f, -0.04203255f, 0.01992326f, 0.04754065f, -0.02972572f, 
    -0.01867618f, 0.04110369f, -0.04516136f, -0.03524548f, 0.03639191f, 0.00620303f, 0.03151864f, 0.00497064f, 
    0.02988981f, 0.03117597f, 0.02829953f, -0.01306055f, -0.00324726f, 0.02186975f, 0.00323791f, -0.04996063f, 
    -0.03566250f, -0.01059157f, -0.00406089f, -0.03691287f, 0.01336615f, -0.01593967f, 0.04508327f, -0.05246190f, 
    0.02652617f, 0.03645610f, -0.01367951f, -0.00309900f, -0.02741956f, -0.00630461f, -0.01791861f, -0.04146257f, 
    -0.03240953f, -0.03104679f, -0.04356757f, 0.01286102f, -0.01978464f, -0.04669354f, -0.01395373f, 0.05012610f, 
    0.00797491f, -0.03130763f, 0.01057335f, -0.03389347f, 0.00433892f, -0.04307751f, 0.03941598f, -0.05506214f, 
    0.00216514f, 0.04364896f, 0.02017570f, -0.02432982f, 0.00449384f, 0.01123941f, 0.00366801f, -0.02252644f, 
    -0.01405948f, 0.00174943f, -0.02874972f, 0.04040708f, -0.02665712f, -0.00535505f, -0.00779618f, -0.03720558f, 
    0.03378566f, -0.00469706f, 0.00227315f, -0.04915956f, 0.01804286f, -0.01319411f, -0.01107986f, -0.05369401f, 
    0.03010815f, 0.03853833f, 0.00882436f, -0.01239864f, -0.04768163f, 0.00979052f, -0.02753644f, -0.03870133f, 
    -0.05114086f, -0.00709058f, 0.02074784f, 0.01506415f, -0.03601174f, -0.01296021f, -0.04525862f, -0.02186693f, 
    -0.03262518f, 0.00185623f, 0.04346810f, 0.02716918f, -0.03763395f, -0.04455429f, -0.03822084f, -0.00819359f, 
    0.02182903f, -0.03912672f, -0.00552071f, 0.01683927f, -0.03450615f, -0.02299424f, 0.00519045f, 0.01592100f, 
    -0.02248519f, -0.00772503f, -0.03079210f, 0.02493567f, 0.04372145f, -0.02901572f, -0.02454120f, 0.04482782f, 
    0.00838938f, -0.02398929f, -0.02643770f, 0.04365911f, 0.03745871f, 0.01830844f, -0.02960048f, -0.01304085f, 
    -0.00932499f, -0.00502205f, -0.05362970f, -0.04644192f, -0.05651903f, 0.01479409f, 0.04460770f, -0.02727755f, 
    -0.03771094f, -0.01855395f, 0.01646280f, 0.04276222f, -0.01025565f, 0.00747883f, 0.00188796f, 0.00596461f, 
    -0.04312756f, -0.03782591f, -0.02920659f, 0.03781341f, 0.02787142f, 0.01358793f, -0.05028021f, -0.02913578f, 
    -0.02583366f, 0.00628512f, -0.01039610f, -0.03027057f, 0.00503324f, 0.01957683f, 0.00977922f, 0.04265790f, 
    0.00253734f, -0.05355706f, -0.04264922f, -0.00018740f, -0.02444782f, -0.01060030f, 0.03860995f, 0.02695607f, 
    -0.00181081f, 0.00534428f, 0.01832414f, 0.02636099f, -0.00648768f, -0.00911826f, -0.02804474f, 0.02197637f, 
    0.00687052f, -0.03479074f, -0.02521912f, 0.03611096f, 0.01489084f, 0.00203566f, -0.01668939f, -0.03157698f, 
    -0.05399414f, -0.03400315f, -0.03774825f, -0.03794827f, 0.03121046f, 0.04388220f, 0.00092497f, -0.03964015f, 
    -0.04166006f, 0.02171145f, -0.05571338f, 0.01213440f, 0.02450627f, 0.04132857f, -0.02173193f, 0.02668181f, 
    0.00253424f, 0.03671421f, 0.04165133f, 0.00277726f, 0.04326553f, 0.04116967f, -0.01806073f, 0.00364422f, 
    0.04272984f, 0.03042901f, -0.04732927f, 0.05294605f, -0.03155841f, 0.03991365f, 0.00284046f, 0.02801458f, 
    0.01044518f, 0.03001358f, 0.00993354f, 0.02027717f, 0.04504513f, -0.03728839f, -0.03656296f, 0.00036342f, 
    0.00020694f, -0.01697834f, 0.03134957f, 0.03817179f, -0.04168539f, 0.01564506f, 0.02973432f, -0.01928590f, 
    0.03322513f, -0.04655158f, -0.02882359f, 0.02666638f, -0.01106655f, -0.02598490f, -0.02212198f, 0.01190175f, 
    0.00447201f, -0.04912406f, 0.00549716f, -0.04990527f, 0.04684949f, -0.04173178f, -0.00958472f, -0.05714208f, 
    -0.02822097f, -0.03180604f, -0.01492425f, 0.03901444f, 0.03315950f, -0.02394830f, 0.03965687f, 0.02132889f, 
    0.01956945f, 0.00131459f, -0.01401058f, 0.01479197f, -0.03813075f, -0.03801996f, -0.03376764f, 0.03736312f, 
    0.00311549f, 0.03219434f, -0.05323504f, -0.02160807f, -0.03302784f, -0.01005682f, -0.02319670f, -0.02435993f, 
    0.00333699f, -0.00502316f, -0.03649211f, 0.03483513f, -0.03980396f, 0.00380897f, -0.05588426f, 0.00759787f, 
    0.11955291f, 0.08895362f, 0.14545915f, -0.04936749f, 0.02573056f, 0.05333507f, -0.11220992f, 0.17763355f, 
    -0.05137315f, 0.02001396f, -0.07866374f, 0.10216893f, 0.40934211f, 0.37506852f, 0.24242270f, -0.03045304f, 
    -0.06587750f, 0.02039935f, 0.06983340f, 0.03699648f, -0.00884414f, 0.09243003f, -0.05409338f, -0.07746296f, 
    -0.12583093f, -0.04247905f, -0.09782332f, -0.17987734f, 0.05370387f, 0.00350576f, -0.02368565f, 0.02090623f, 
    0.00994988f, -0.00781252f, -0.09383936f, -0.03233351f, 0.11446729f, -0.20615318f, -0.02585180f, 0.10644404f, 
    -0.10937396f, 0.00946937f, -0.02310103f, 0.07973938f, -0.04732049f, -0.06044056f, -0.06413820f, -0.05960818f, 
    -0.00322372f, -0.14595246f, 0.00825013f, 0.03546548f, -0.01464380f, 0.02484023f, -0.08666765f, -0.02995290f, 
    0.01888658f, -0.01550639f, -0.07766804f, -0.02256233f, 0.29171541f, -0.13471770f, 0.06663124f, 0.12656380f, 
    0.03639125f, -0.00303811f, -0.02167799f, -0.04088354f, 0.03807385f, -0.00138348f, 0.01853506f, 0.05978675f, 
    0.06531976f, 0.05268952f, -0.09586750f, 0.13991375f, 0.06625141f, 0.05983681f, 0.02234586f, 0.06400610f, 
    -0.08240669f, 0.10058376f, -0.01902708f, 0.00517227f, 0.14813201f, 0.19915961f, 0.06488052f, 0.14531669f, 
    -0.02318944f, 0.03538430f, 0.05089236f, 0.01124395f, -0.04761699f, -0.00410550f, -0.16841027f, 0.03540019f, 
    0.32716376f, 0.03696842f, 0.02790218f, 0.05358367f, -0.08316259f, 0.00102540f, 0.02786718f, -0.05758737f, 
    0.09053215f, 0.04312070f, 0.17509255f, 0.02993636f, 0.11517280f, 0.10915945f, 0.16250113f, 0.14044444f, 
    0.01373786f, -0.08960924f, 0.06149435f, 0.20045687f, 0.09971898f, -0.01151496f, 0.08255940f, 0.01021946f, 
    -0.22284245f, -0.17130761f, -0.06992842f, 0.01351281f, 0.05024704f, -0.00030733f, 0.07099620f, -0.07047400f, 
    -0.00599234f, 0.02061930f, -0.03018470f, -0.02487172f, -0.07636669f, 0.09182385f, -0.05523656f, -0.01542103f, 
    -0.05511955f, -0.11657596f, 0.01825836f, -0.07624784f, 0.01910017f, 0.06520431f, -0.02336715f, -0.02837984f, 
    0.19962746f, 0.35177863f, 0.21372949f, 0.00884529f, 0.12072325f, -0.00884493f, 0.00673713f, -0.05845371f, 
    -0.02503557f, 0.01378037f, 0.20420834f, -0.09100822f, -0.20005837f, -0.08346622f, -0.04112722f, -0.01162072f, 
    -0.00241113f, 0.03825147f, -0.04768612f, 0.03243164f, 0.02962869f, 0.03261762f, -0.16576621f, -0.12954493f, 
    0.27740267f, -0.17894366f, 0.14131936f, -0.08782674f, -0.11057282f, 0.07329118f, -0.00634942f, -0.02547706f, 
    -0.04260568f, 0.16093157f, -0.04475692f, 0.07205349f, 0.41147736f, -0.19905996f, 0.13610527f, 0.20447882f, 
    0.01194139f, 0.10644259f, -0.01073155f, -0.02577525f, -0.06994728f, 0.03375315f, -0.10665729f, 0.06828807f, 
    0.13259363f, 0.03771891f, 0.13112453f, -0.05357778f, -0.03765042f, -0.07104157f, 0.02662639f, 0.03981890f, 
    -0.02037219f, 0.01364863f, 0.01625000f, 0.05338330f, 0.07382102f, -0.19811431f, -0.06656665f, -0.00363779f, 
    -0.07084379f, 0.06016986f, -0.03765680f, 0.02892911f, -0.03480681f, -0.05184987f, 0.07162904f, 0.01427212f, 
    0.12623769f, 0.06819469f, 0.07362494f, 0.12197750f, -0.01792817f, 0.06677692f, 0.00341054f, 0.09485880f, 
    0.04524108f, 0.06683431f, 0.11567625f, 0.15959544f, -0.07678989f, -0.05337637f, -0.18322450f, -0.28900954f, 
    0.03419476f, -0.10516793f, 0.03622452f, -0.07332299f, -0.01287435f, 0.03847176f, -0.04268145f, 0.07765552f, 
    -0.13534679f, -0.10279600f, -0.20137522f, -0.33536297f, 0.01505180f, 0.02956907f, -0.00905403f, 0.03613400f, 
    -0.01918365f, -0.03561164f, 0.04803281f, 0.01575205f, 0.21828799f, 0.30773717f, 0.17071839f, 0.19578977f, 
    0.04767424f, -0.07048775f, 0.02416840f, 0.04457841f, 0.08026037f, 0.08440962f, -0.06190799f, -0.00638187f, 
    -0.02594248f, 0.11526662f, 0.09992617f, -0.04337037f, 0.03126494f, -0.01210228f, -0.06762394f, 0.09886933f, 
    -0.04667444f, 0.10879933f, -0.07484254f, -0.00930651f, 0.07570383f, 0.16273600f, 0.02355936f, -0.03689360f, 
    -0.01598654f, 0.00112421f, 0.01214815f, 0.01642999f, 0.04530649f, 0.07581577f, -0.01519902f, -0.16111180f, 
    -0.17859708f, -0.17352024f, 0.04489408f, -0.26119477f, -0.08202454f, 0.01466196f, 0.01862313f, 0.00098340f, 
    -0.04307740f, -0.02966484f, 0.05491367f, -0.12900765f, 0.36027959f, -0.08828160f, -0.16954541f, -0.25708970f, 
    0.07376973f, 0.10342697f, 0.00325275f, -0.07845099f, 0.12645118f, 0.01856856f, -0.00178161f, 0.05473371f, 
    0.16772138f, 0.03846376f, 0.02898694f, 0.03839731f, -0.15232386f, 0.03547509f, -0.11300214f, 0.01734004f, 
    0.01540477f, 0.01484446f, 0.07772160f, -0.03733620f, 0.11652479f, -0.02920272f, 0.12818617f, -0.09231372f, 
    -0.03271268f, 0.14186046f, -0.09025508f, 0.01883268f, 0.07075692f, 0.08630244f, -0.09000837f, -0.03050395f, 
    0.25452730f, 0.14037952f, 0.00026189f, 0.00829944f, 0.11449468f, 0.05270038f, 0.08045527f, 0.10074254f, 
    -0.09932369f, 0.00374199f, 0.07611065f, 0.04614823f, 0.13056605f, 0.12833692f, -0.01971546f, -0.16368127f, 
    -0.01057154f, 0.00837702f, -0.00559728f, -0.01455797f, -0.00394714f, -0.03865682f, -0.00874319f, -0.03198016f, 
    -0.14912915f, -0.03733382f, -0.01453417f, -0.08952393f, -0.07089574f, 0.09505932f, -0.03467302f, 0.01665360f, 
    0.01612167f, -0.20416401f, 0.19895020f, 0.09815504f, -0.04891945f, -0.07800923f, 0.03968971f, 0.02072660f, 
    -0.00528515f, 0.03161174f, -0.14596844f, 0.05740217f, 0.07260079f, -0.02855642f, -0.03066212f, 0.02878953f, 
    -0.19407155f, -0.02756597f, 0.13602346f, 0.04075603f, 0.17846294f, 0.04302375f, 0.03159881f, -0.09374800f, 
    -0.06510554f, 0.04840064f, 0.07624997f, 0.03977358f, 0.44442287f, 0.19806273f, 0.05321138f, 0.05789524f, 
    0.08433273f, -0.03972775f, 0.01787293f, -0.09474081f, -0.04128747f, -0.00165527f, -0.07259052f, -0.00285932f, 
    -0.17020082f, 0.00010168f, -0.18799719f, 0.03929364f, 0.01392899f, -0.01791112f, 0.04400814f, -0.04245912f, 
    0.17209636f, 0.05412231f, 0.07565024f, -0.03679200f, 0.06006627f, 0.01396176f, 0.01875105f, 0.15156367f, 
    0.07853408f, 0.07970263f, 0.07087307f, -0.06799906f, -0.12635614f, -0.07061478f, 0.01941881f, 0.00465578f, 
    -0.11630022f, -0.15639856f, 0.09248003f, 0.11115050f, 0.07227428f, 0.12021740f, -0.02912272f, 0.07515012f, 
    0.02304894f, 0.03143396f, 0.00847291f, -0.00134334f, 0.21569148f, -0.20770045f, 0.05733290f, 0.14075808f, 
    0.11922508f, -0.04638398f, 0.00384603f, 0.01879714f, -0.02559381f, 0.01906994f, -0.06093377f, -0.00367831f, 
    0.10536729f, -0.04743418f, -0.12231770f, 0.15306655f, 0.08447029f, 0.02195900f, 0.05146391f, -0.03910752f, 
    0.08458071f, 0.03470072f, -0.10348082f, 0.04661607f, 0.11699364f, -0.00526329f, -0.06507640f, 0.19412144f, 
    0.09478270f, 0.07390243f, 0.07445075f, 0.03620589f, 0.00925517f, -0.09292036f, -0.07954122f, 0.03215993f, 
    0.15444186f, -0.17256300f, -0.05073658f, -0.05884230f, 0.07121734f, -0.03217293f, -0.01667741f, 0.01908720f, 
    0.09617825f, -0.08396534f, -0.02553998f, -0.02537729f, 0.16401918f, 0.22876930f, 0.01110345f, 0.12650958f, 
    0.06023788f, 0.05492038f, 0.00592930f, 0.02059107f, -0.01962166f, 0.07536044f, -0.01776609f, 0.03694679f, 
    -0.23876809f, -0.01883776f, -0.12326241f, 0.12951915f, 0.02094245f, -0.13097963f, -0.00403190f, -0.09009647f, 
    -0.04726940f, 0.02516164f, 0.02855561f, -0.06212800f, 0.03328043f, 0.10059298f, -0.00450733f, -0.15304014f, 
    0.02186322f, -0.10410662f, -0.07854524f, -0.09594689f, 0.01735397f, -0.00324565f, -0.00669663f, 0.12373911f, 
    0.34769571f, 0.10357747f, 0.05259557f, 0.11340462f, 0.06288026f, 0.03875249f, -0.08389959f, -0.12640643f, 
    -0.13240030f, -0.04833372f, 0.01054171f, 0.01637346f, -0.17957330f, 0.03543382f, -0.04242969f, 0.00319346f, 
    -0.05156102f, 0.03124890f, 0.01571116f, 0.05138447f, 0.00975267f, 0.05251234f, -0.12369201f, -0.00784326f, 
    0.11615045f, 0.00121989f, -0.01105253f, -0.05340029f, 0.08931565f, 0.16189083f, 0.02509299f, -0.04766689f, 
    -0.01087333f, 0.10706348f, -0.14241116f, 0.06507358f, 0.08671989f, -0.04897796f, -0.03482991f, -0.03513650f, 
    0.09979387f, 0.01351546f, -0.04444427f, 0.00527123f, -0.11806044f, -0.00736136f, 0.03229110f, -0.00011763f, 
    0.26548928f, 0.21565625f, -0.01725690f, -0.03312939f, -0.06876472f, -0.02253888f, -0.00149289f, 0.06414748f, 
    -0.00726430f, -0.03176234f, 0.02743164f, 0.04618439f, 0.00557590f, -0.15973130f, -0.04879185f, -0.01184049f, 
    0.07175369f, 0.04796709f, -0.05601457f, -0.02855642f, -0.06015453f, 0.01776890f, 0.08897094f, -0.01694174f, 
    -0.13436706f, -0.05583432f, 0.02916252f, 0.05070464f, 0.11476547f, -0.02553437f, -0.09540682f, -0.00132151f, 
    0.07039585f, 0.09642040f, 0.01213113f, -0.00835238f, 0.05957669f, 0.00665644f, -0.19468148f, 0.04679721f, 
    0.01161477f, -0.00876073f, 0.03214448f, -0.14325225f, -0.04076485f, 0.03388874f, 0.01222011f, 0.11716364f, 
    0.01679769f, -0.11161195f, -0.07969084f, -0.02960305f, 0.01455348f, -0.08324859f, 0.02153718f, 0.04162319f, 
    -0.00063923f, 0.03950685f, -0.04628173f, -0.02199895f, 0.12138823f, 0.25514010f, -0.00209377f, 0.14347221f, 
    0.16088746f, -0.06622386f, -0.06976178f, -0.02477023f, 0.01378767f, -0.04431887f, -0.07259659f, -0.05159391f, 
    -0.21114835f, -0.13464360f, 0.17033471f, 0.11373643f, 0.07384036f, -0.04103313f, 0.05161501f, 0.17526422f, 
    -0.05918054f, 0.02695947f, 0.08028892f, -0.01073800f, 0.00198670f, 0.14393334f, -0.01241508f, -0.02215993f, 
    0.01541112f, -0.02615354f, 0.06859405f, -0.01712550f, 0.01392316f, 0.07431368f, 0.02331606f, -0.09403446f, 
    -0.22622134f, -0.10957877f, -0.01732351f, -0.19834568f, -0.08045141f, 0.02637768f, -0.13479117f, 0.15970279f, 
    0.03830462f, -0.07444168f, 0.16346404f, -0.01401052f, 0.40177429f, -0.36641315f, -0.11725555f, -0.11436497f, 
    -0.06477127f, 0.06563795f, -0.00622016f, -0.01478343f, 0.07449319f, -0.00943134f, 0.07666557f, 0.12160116f, 
    0.08657834f, 0.06909133f, 0.18174401f, 0.10912791f, -0.04107596f, 0.05690964f, -0.00785304f, -0.01037158f, 
    -0.01627739f, 0.08558503f, -0.02704626f, -0.06163094f, 0.00088358f, -0.05950815f, 0.06977831f, 0.11446916f, 
    0.09712997f, 0.06214381f, -0.03338858f, 0.03638916f, 0.05889047f, 0.00783178f, -0.06785286f, 0.04030478f, 
    0.23155238f, 0.08448540f, 0.01160181f, 0.12450275f, 0.02863557f, -0.02877085f, 0.00239490f, 0.11609181f, 
    0.05867586f, 0.10881202f, -0.03334203f, 0.05722531f, -0.02128077f, -0.14130741f, -0.13524200f, -0.05509847f, 
    0.03930751f, -0.04979740f, -0.09597965f, -0.04352216f, -0.05028337f, -0.03764508f, 0.01342434f, -0.01490508f, 
    0.05182179f, 0.10443303f, -0.01189040f, -0.08729853f, -0.02477750f, 0.00006160f, -0.12773529f, -0.01471668f, 
    -0.00606100f, -0.07116111f, -0.02970748f, 0.04172307f, -0.05109181f, -0.15809943f, 0.02176472f, 0.00628877f, 
    0.05806101f, -0.09091758f, -0.11800318f, 0.03736396f, 0.06634734f, -0.02673627f, 0.06248115f, 0.00781991f, 
    -0.34125841f, -0.09949043f, -0.03168438f, -0.11154485f, -0.09013855f, 0.01263307f, -0.02721624f, 0.02920515f, 
    0.16588767f, 0.09693944f, 0.05870487f, -0.00366802f, -0.15678082f, -0.07415318f, -0.08312328f, 0.16473041f, 
    0.10587209f, -0.00002381f, -0.02797626f, -0.05639824f, 0.10653649f, -0.02628322f, 0.03140704f, 0.06729074f, 
    -0.03358759f, 0.11294213f, 0.07244353f, 0.05899323f, -0.04193856f, 0.10691895f, -0.04631392f, 0.03745085f, 
    0.03340330f, -0.02400305f, 0.05144639f, 0.10782910f, -0.29090658f, 0.06213362f, 0.14534605f, -0.11743231f, 
    0.04979397f, -0.04065727f, -0.00425790f, 0.02366357f, 0.06565896f, 0.02080603f, -0.02627392f, 0.09585057f, 
    0.01942090f, 0.20552382f, -0.12245280f, -0.11959908f, 0.08154412f, -0.06017542f, 0.09754182f, 0.03555522f, 
    -0.12490600f, 0.01258233f, -0.01640272f, 0.09492568f, -0.20625477f, 0.05738474f, -0.01640345f, -0.00462694f, 
    -0.04299614f, 0.07301413f, 0.06652467f, -0.02041609f, 0.06659047f, 0.02321433f, 0.10908522f, -0.03769368f, 
    0.07176369f, 0.01707183f, 0.25824350f, -0.00644675f, 0.01627390f, 0.00405780f, -0.04224259f, 0.07743162f, 
    0.05830536f, 0.00775211f, 0.13819060f, 0.14234409f, 0.09236579f, 0.10863441f, 0.11165331f, 0.05706488f, 
    -0.06571653f, -0.07569727f, -0.10593304f, 0.04884560f, 0.10728203f, 0.01212342f, 0.11456348f, 0.01114834f, 
    -0.21524258f, 0.04554359f, 0.12833945f, 0.10102614f, 0.02200085f, 0.03479695f, 0.11479712f, 0.02762840f, 
    -0.07014909f, 0.17400084f, -0.11995570f, 0.07251782f, -0.21679442f, -0.15390851f, -0.07586600f, 0.01080199f, 
    -0.05729390f, -0.05011097f, 0.05371895f, -0.14900984f, -0.06555086f, 0.00629010f, -0.07567658f, 0.07920487f, 
    0.23590291f, 0.08689818f, -0.05257336f, -0.03068662f, 0.03145461f, -0.05522121f, -0.02154532f, 0.05383813f, 
    0.10758131f, 0.07192114f, -0.00982821f, -0.01681682f, 0.05858512f, -0.21607879f, 0.11619846f, -0.27627200f, 
    0.03915622f, 0.04555272f, 0.04256544f, 0.04707932f, 0.07090590f, -0.06442685f, 0.01323383f, 0.00307773f, 
    -0.10309266f, -0.05847186f, -0.10382444f, 0.09142736f, -0.10149797f, 0.04090047f, 0.10012994f, 0.14663087f, 
    0.02315239f, 0.03530356f, -0.10336889f, 0.11396568f, 0.00077928f, -0.04304202f, -0.00497008f, 0.00081488f, 
    -0.01810896f, -0.02203488f, 0.02958325f, 0.02270140f, 0.03931570f, -0.07845773f, 0.20251198f, 0.03329160f, 
    0.02763304f, 0.09487221f, 0.03648375f, 0.05160663f, 0.08071166f, 0.03116756f, -0.02101648f, 0.08575306f, 
    0.04467567f, -0.12857786f, 0.10474408f, -0.05863908f, -0.03092849f, 0.13559537f, -0.11255609f, 0.12361157f, 
    -0.02980267f, -0.05269740f, -0.06024488f, 0.05769922f, 0.06618040f, -0.00155622f, 0.08835088f, -0.01506112f, 
    0.17292373f, -0.19061996f, -0.16747269f, 0.13537298f, 0.07717121f, 0.07055230f, -0.01584623f, -0.01613220f, 
    0.14540473f, -0.00728425f, 0.03676996f, -0.03299681f, -0.06637218f, 0.11485991f, -0.11234570f, -0.10878918f, 
    0.14740455f, -0.05767228f, -0.03990859f, -0.09911320f, 0.14126940f, 0.05147344f, -0.06696954f, 0.06113191f, 
    0.08503080f, -0.09824196f, 0.01138099f, 0.10097641f, -0.08560354f, 0.02255089f, 0.17020677f, -0.02308077f, 
    -0.02373867f, -0.03934542f, -0.02620877f, 0.05294181f, 0.07647199f, 0.07641199f, 0.16084349f, 0.00208137f, 
    0.00975283f, 0.07189412f, -0.00347065f, 0.16014762f, 0.13919166f, -0.07803834f, -0.04923568f, -0.03376581f, 
    -0.11820041f, 0.10668007f, 0.00473782f, 0.09941634f, 0.02554897f, -0.02229797f, 0.04668598f, 0.01193359f, 
    -0.01994213f, 0.04109789f, 0.07515647f, 0.10057459f, 0.09843482f, -0.15917288f, -0.00777521f, 0.01203130f, 
    -0.05342917f, -0.04217460f, -0.08387509f, 0.02424753f, -0.00764498f, -0.03570361f, 0.03991604f, 0.04052077f, 
    0.03338283f, -0.10446307f, 0.00740863f, -0.00223402f, -0.07587985f, 0.05072542f, 0.04148483f, -0.14103156f, 
    0.00745878f, -0.07452501f, 0.08872321f, -0.03513864f, 0.15621991f, 0.00280349f, 0.15837656f, 0.13594325f, 
    0.01268047f, -0.01780767f, -0.07123104f, 0.01668024f, 0.04875451f, 0.03375207f, 0.12049238f, 0.06195968f, 
    -0.00425773f, 0.21789619f, -0.20497355f, 0.25201789f, 0.10170809f, -0.01357838f, -0.05554703f, -0.06554116f, 
    -0.02924901f, 0.02915477f, 0.06743112f, 0.10181583f, -0.47540691f, 0.15224425f, 0.09543958f, 0.13488126f, 
    0.02476186f, -0.02337209f, 0.11085230f, 0.03744488f, 0.03096779f, 0.03126338f, -0.02539251f, 0.05237114f, 
    -0.31132549f, -0.11327219f, -0.11789293f, -0.16394545f, 0.10259623f, -0.05157967f, 0.18211056f, -0.00882925f, 
    0.02233076f, -0.06517197f, -0.06225475f, 0.09205375f, -0.17073828f, -0.00315049f, -0.14044578f, -0.12245599f, 
    -0.06016073f, -0.15437567f, 0.11428615f, -0.05513910f, -0.03272985f, -0.05848287f, 0.07600860f, 0.08126952f, 
    -0.30716407f, -0.09985101f, 0.01481056f, 0.02909057f, -0.05798735f, -0.03565634f, -0.06285193f, -0.09021351f, 
    0.11159052f, -0.02045750f, 0.00964295f, 0.02301906f, -0.05528419f, 0.01963755f, 0.09338165f, 0.16453215f, 
    -0.02881919f, 0.03152340f, -0.01205869f, 0.02466630f, 0.00358611f, 0.04052297f, 0.08345227f, 0.04701303f, 
    -0.04647533f, 0.06758103f, -0.07003672f, 0.03794739f, -0.01682080f, 0.02040414f, 0.14379744f, 0.03422050f, 
    0.09116870f, 0.12344050f, -0.12082427f, 0.02880221f, -0.03193412f, 0.04063813f, 0.03055929f, -0.06165202f, 
    0.02570033f, -0.06081075f, 0.10200368f, 0.02651195f, 0.02402900f, -0.06737429f, -0.05198523f, 0.08550029f, 
    -0.02325562f, -0.00943824f, 0.00240333f, -0.02373157f, -0.04629259f, -0.03434721f, -0.03369610f, -0.01358895f, 
    0.03118891f, -0.03578513f, -0.04683144f, 0.02194857f, 0.04218310f, -0.02986566f, 0.04627438f, 0.00404271f, 
    0.02801416f, -0.00391890f, -0.04398768f, -0.02220019f, -0.04661287f, 0.02874604f, 0.03456790f, -0.02588861f, 
    0.02187962f, -0.03866819f, -0.03500315f, -0.03286677f, -0.05407281f, 0.03766584f, 0.03705095f, -0.03203843f, 
    0.01827320f, -0.03549984f, 0.00584586f, 0.01274405f, -0.04130433f, -0.02500340f, -0.03787203f, 0.04144216f, 
    -0.00734205f, -0.05019544f, 0.03272223f, 0.01333250f, -0.04045356f, -0.02085081f, 0.01046269f, -0.04786317f, 
    0.04641286f, -0.02676406f, 0.03464925f, 0.01120494f, 0.02560487f, 0.03596488f, -0.03037508f, -0.04216202f, 
    0.01881352f, -0.00450889f, -0.01469891f, 0.03518797f, 0.00002958f, 0.00543367f, 0.02810884f, -0.02724172f, 
    -0.01416977f, -0.04720704f, -0.03388667f, -0.04979513f, -0.01309777f, 0.01113368f, 0.04028402f, -0.00256492f, 
    -0.00164720f, 0.01228140f, -0.04289163f, -0.03255810f, 0.02576452f, 0.01078480f, -0.04471647f, 0.00942602f, 
    0.00381069f, 0.04642552f, -0.01846525f, -0.04575824f, -0.00144306f, -0.00067252f, 0.04562596f, 0.01234568f, 
    -0.01760214f, 0.00006104f, 0.00836267f, 0.00357965f, 0.02946938f, -0.00469109f, 0.02271609f, -0.00345698f, 
    0.04049369f, -0.04834057f, 0.00842283f, -0.01862456f, -0.00768032f, -0.00457617f, -0.00743645f, -0.02795634f, 
    -0.04217676f, 0.02415318f, -0.05517591f, -0.01298883f, 0.02039916f, -0.01656904f, -0.01764035f, -0.05550976f, 
    0.02580266f, 0.00063840f, -0.04834588f, 0.01043952f, -0.03084088f, -0.04592774f, -0.03223205f, 0.03825416f, 
    -0.02198476f, -0.04117475f, -0.00134543f, -0.02959243f, -0.01155658f, 0.00741670f, -0.00336653f, -0.04472278f, 
    -0.03890091f, -0.04796230f, -0.02192929f, -0.04743655f, -0.01235763f, 0.04315980f, -0.03400993f, -0.04565548f, 
    -0.00507300f, 0.03056613f, -0.02551360f, 0.00068465f, 0.01885949f, 0.02860084f, -0.02498617f, -0.00826469f, 
    0.00534268f, -0.00703126f, 0.01007324f, -0.02647353f, 0.00234454f, -0.05106921f, -0.01385370f, 0.03568658f, 
    0.04441551f, -0.02116867f, 0.01435621f, 0.04302731f, -0.04694863f, -0.02488782f, -0.04324860f, 0.00427971f, 
    -0.04957807f, 0.01400695f, 0.00590130f, -0.04260170f, -0.04415109f, -0.00646935f, -0.00104080f, 0.02602395f, 
    -0.00138984f, 0.04728059f, 0.03376891f, 0.01815116f, 0.04541423f, 0.04184122f, -0.00474466f, 0.00952321f, 
    0.02924314f, -0.00374051f, 0.02918291f, -0.00484360f, -0.00935458f, -0.00727372f, -0.02526283f, 0.04092892f, 
    -0.03506497f, -0.05747421f, -0.04144264f, -0.05464011f, 0.01910112f, -0.01378643f, -0.01603416f, -0.02296945f, 
    0.01972361f, -0.02747466f, -0.01224863f, -0.03373938f, 0.00436082f, 0.02753177f, -0.00125698f, -0.03975965f, 
    -0.05135886f, -0.03880119f, 0.01524497f, 0.04188753f, -0.03035736f, -0.02883550f, 0.00625760f, -0.01045621f, 
    -0.00125423f, -0.05487392f, -0.04953261f, 0.04451891f, -0.03430370f, -0.04449340f, -0.04571765f, -0.02469052f, 
    -0.01906353f, -0.01825059f, 0.01620199f, -0.03907965f, -0.04076679f, -0.02844961f, 0.04684363f, -0.04796297f, 
    0.02018687f, 0.03844820f, -0.00478594f, 0.00611311f, 0.03482808f, -0.01964297f, -0.00555960f, 0.03504621f, 
    0.02971449f, -0.01969192f, 0.04368537f, -0.03330266f, 0.02088560f, -0.00797335f, 0.03754419f, 0.00904980f, 
    0.02102255f, 0.01902935f, -0.03562041f, 0.03186398f, -0.01673896f, -0.03114416f, -0.00580029f, -0.04898263f, 
    0.02809020f, -0.02133314f, 0.00992217f, -0.00631524f, 0.04215939f, 0.02131896f, 0.00079057f, 0.00475976f, 
    -0.01569345f, 0.03559844f, -0.04931853f, 0.00602416f, -0.02032413f, -0.04614291f, 0.01786449f, -0.02212623f, 
    0.03865292f, 0.01339364f, -0.01990429f, 0.02888757f, -0.00521532f, -0.03399073f, -0.04159580f, -0.03458637f, 
    0.02267055f, -0.02730208f, -0.04401959f, 0.01244573f, 0.03892138f, -0.03427242f, -0.03823812f, -0.04050719f, 
    0.02853883f, -0.04140745f, 0.03567667f, -0.01321167f, 0.01288964f, -0.03208673f, 0.01593633f, 0.00998932f, 
    0.03220523f, 0.00674951f, -0.02777974f, -0.05296253f, -0.03752585f, -0.02406770f, 0.02201614f, -0.01010583f, 
    0.01151413f, 0.02831696f, -0.03932980f, -0.05168653f, 0.03120601f, -0.00449755f, -0.05039071f, -0.04916739f, 
    0.00261001f, 0.04515975f, 0.02959431f, 0.01358264f, 0.00812227f, -0.04430043f, -0.00572008f, -0.00056760f, 
    0.02146619f, -0.04561144f, -0.03326387f, 0.04225562f, -0.02769120f, -0.01322023f, 0.04595365f, -0.02942546f, 
    -0.05324828f, 0.02198477f, -0.04529312f, -0.00036522f, 0.02681944f, -0.01325353f, -0.02676933f, 0.03809657f, 
    0.00185434f, -0.00465527f, -0.04099140f, -0.00215581f, -0.01113737f, -0.03041486f, 0.04150893f, -0.04465895f, 
    -0.04919747f, -0.01155007f, 0.03931865f, 0.00492355f, -0.02146332f, -0.00243725f, 0.03915037f, 0.02288099f, 
    0.01758656f, -0.00744198f, 0.02983171f, -0.00453718f, 0.00288968f, -0.04350735f, 0.00956892f, -0.03064812f, 
    -0.05224438f, -0.03225335f, -0.03689454f, -0.01892402f, -0.01374978f, 0.03400020f, 0.02476797f, -0.00290120f, 
    -0.00624261f, -0.03649037f, -0.03495062f, 0.01077879f, 0.02566761f, -0.04681456f, 0.00247993f, -0.05194318f, 
    -0.04225830f, 0.01470163f, -0.03910139f, 0.04769647f, -0.02596266f, -0.01343736f, 0.02253774f, -0.00019495f, 
    0.00325572f, -0.04822022f, -0.05497156f, -0.02687844f, -0.02085660f, -0.03484556f, -0.02791249f, 0.04225016f, 
    0.01209055f, 0.04894452f, -0.04191305f, -0.03933525f, -0.04799086f, -0.04613480f, 0.03191804f, 0.02085450f, 
    0.01331384f, 0.00629049f, -0.02781985f, 0.01588794f, 0.02336645f, -0.00444216f, 0.03778780f, -0.01532849f, 
    0.04542480f, 0.00228964f, 0.02297052f, -0.01973861f, 0.03252171f, -0.02689516f, 0.02499809f, -0.03274403f, 
    -0.05371717f, 0.00967694f, -0.04240816f, 0.00935775f, 0.02115286f, 0.01129556f, 0.03114680f, -0.00542575f, 
    -0.00819560f, -0.02648359f, -0.04239427f, -0.04266216f, 0.00440103f, -0.04950490f, 0.04662075f, 0.00245044f, 
    0.04077564f, -0.00327312f, -0.01367994f, -0.00659884f, -0.01049769f, 0.03252851f, -0.02233418f, -0.03280750f, 
    -0.03094344f, 0.03409360f, 0.03039090f, 0.04209809f, -0.00883706f, -0.03156385f, -0.03385235f, -0.05030236f, 
    -0.04394830f, -0.02445692f, 0.02049647f, -0.03679611f, -0.04645088f, 0.01926097f, 0.04847707f, -0.02989169f, 
    0.03004062f, -0.04716429f, -0.05532972f, 0.03573516f, 0.02087050f, -0.00548297f, 0.02400487f, -0.03396970f, 
    -0.00495799f, -0.04347208f, -0.05521090f, -0.00789524f, 0.01471519f, 0.00441763f, -0.05579320f, 0.03651343f, 
    -0.02197765f, 0.03346586f, -0.02875024f, -0.05459119f, 0.03443303f, -0.04507571f, 0.02433708f, -0.02255206f, 
    0.03558932f, -0.05277524f, -0.03169261f, -0.03795820f, 0.04057572f, -0.03931387f, -0.02836899f, 0.01231696f, 
    0.00492356f, -0.03390745f, 0.03486656f, 0.02154190f, 0.03002837f, -0.00163148f, 0.04721420f, -0.05591156f, 
    -0.02280997f, 0.02020783f, 0.02451967f, -0.02459485f, -0.04805731f, -0.04126910f, 0.00976063f, -0.03070257f, 
    0.01205641f, -0.04735994f, -0.03884257f, -0.00663868f, 0.00152132f, -0.02297238f, -0.01127025f, -0.04382486f, 
    0.00519539f, -0.03820505f, 0.00369577f, 0.00914281f, 0.00715195f, -0.01854804f, -0.02710604f, -0.05024071f, 
    0.00518792f, 0.02110069f, -0.00315332f, -0.01490257f, 0.03670581f, 0.03604695f, -0.04008851f, -0.03271434f, 
    -0.00998401f, -0.05356243f, -0.02731385f, -0.04606154f, -0.00769172f, 0.00012272f, -0.02617104f, 0.04425780f, 
    0.00401227f, 0.02304366f, -0.03589131f, 0.01587833f, -0.02597664f, -0.02162435f, -0.05301225f, 0.01671760f, 
    -0.03577780f, 0.00046463f, 0.03226725f, 0.00674507f, 0.00547259f, -0.05217727f, -0.02526844f, 0.02170709f, 
    0.01157242f, -0.03481512f, -0.01839878f, -0.02972016f, -0.02780719f, -0.02143887f, -0.05072146f, 0.00808677f, 
    0.02304908f, -0.00192390f, -0.05385751f, -0.05165669f, 0.04056566f, -0.01855599f, 0.03858754f, 0.03981908f, 
    -0.02523809f, -0.04425184f, -0.01458737f, -0.01200569f, -0.00263775f, 0.02011047f, -0.04346964f, -0.02247292f, 
    0.02286174f, 0.01578652f, 0.02837557f, 0.01816304f, 0.03474349f, -0.00602188f, -0.01719062f, 0.04206261f, 
    0.04157146f, -0.02084757f, -0.02567032f, -0.04105262f, 0.03517079f, -0.00504913f, 0.03831913f, 0.04210293f, 
    -0.02694826f, -0.03076297f, -0.04416968f, 0.02837184f, 0.00827887f, -0.05628509f, 0.00057334f, 0.00676002f, 
    0.01251618f, 0.03041263f, -0.03187022f, 0.04173227f, -0.02290757f, -0.01513980f, 0.02120636f, 0.01477179f, 
    0.00945329f, -0.03260416f, -0.00184932f, 0.01762978f, -0.01787737f, -0.00844908f, 0.03214652f, 0.03801368f, 
    -0.00431410f, 0.03279332f, -0.00926349f, -0.00326775f, -0.03110165f, -0.01521983f, 0.04471201f, 0.04188524f, 
    -0.03280127f, 0.01843395f, -0.02643324f, -0.03108520f, -0.03389664f, -0.04177380f, -0.01840936f, -0.01024563f, 
    -0.03913227f, -0.03471813f, 0.01590195f, 0.03744603f, 0.04331324f, -0.00793493f, -0.00186991f, 0.03922676f, 
    -0.03212662f, -0.01236616f, 0.01086737f, 0.01854616f, -0.02106204f, -0.03584868f, 0.00526032f, 0.00787931f, 
    -0.03727106f, -0.01919895f, -0.04066561f, 0.02072120f, -0.01739453f, -0.01712849f, 0.01945312f, 0.03877869f, 
    0.04409220f, -0.03343409f, -0.04597508f, -0.01537997f, -0.00530593f, -0.05248638f, -0.00401897f, -0.01900226f, 
    0.00945017f, -0.02429886f, 0.01411490f, -0.01396345f, -0.03073978f, 0.03680815f, -0.03433733f, 0.01645246f, 
    0.00195841f, -0.00916423f, 0.02111938f, -0.03188213f, 0.01528159f, 0.00105920f, -0.02789672f, -0.05283619f, 
    -0.02823067f, -0.04399837f, 0.03621493f, -0.01207901f, -0.02690862f, -0.01992326f, -0.01949892f, 0.03157451f, 
    -0.04524263f, 0.02001613f, -0.00374372f, -0.02344469f, 0.03093992f, -0.02867683f, -0.00956028f, 0.00203197f, 
    -0.03827097f, -0.03838780f, 0.00455327f, 0.00460644f, 0.00242120f, -0.02487238f, -0.00056927f, -0.01386391f, 
    -0.03613203f, -0.01018087f, 0.01223244f, 0.00391341f, 0.04301191f, -0.00907664f, -0.01550990f, 0.01000531f, 
    -0.02171937f, -0.02949710f, 0.02596535f, -0.02817979f, 0.00066121f, 0.00246140f, 0.01786065f, -0.05110574f, 
    -0.02549282f, 0.03497718f, -0.03473611f, 0.01884631f, -0.03697680f, 0.00371350f, -0.03842138f, -0.02938190f, 
    -0.02887734f, -0.01332261f, 0.02473932f, -0.04944756f, 0.00078223f, -0.01355283f, -0.04401513f, -0.01750793f, 
    0.00735033f, -0.00848338f, -0.02267788f, 0.00846932f, -0.04274561f, 0.01816095f, -0.02284976f, -0.03604373f, 
    -0.01057514f, 0.04372030f, -0.00493948f, 0.02383765f, -0.00754724f, 0.02838015f, -0.00496951f, -0.03980722f, 
    -0.03334929f, -0.03921192f, -0.03211023f, -0.01581234f, -0.04302099f, -0.03764998f, -0.03816794f, -0.04572216f, 
    -0.02420566f, -0.03093148f, -0.02513987f, 0.04518932f, 0.03476166f, -0.00348987f, 0.01589292f, -0.04442054f, 
    -0.03882771f, -0.04505150f, -0.00359912f, -0.03117039f, 0.02796848f, -0.01831348f, 0.03980045f, 0.03922839f, 
    0.02465764f, 0.01482857f, 0.03340367f, 0.01983595f, -0.00665647f, -0.04253280f, -0.05643386f, -0.02601141f, 
    -0.03284480f, 0.02604947f, -0.01000146f, -0.02088605f, -0.00792927f, 0.03234239f, -0.01057148f, 0.02065532f, 
    -0.02268108f, -0.01997903f, -0.05353441f, -0.02614601f, -0.02616152f, -0.01915065f, -0.03298959f, -0.00382707f, 
    -0.02154549f, -0.02885340f, -0.00108253f, 0.02316011f, -0.04815070f, 0.04186829f, 0.03618197f, -0.03942671f, 
    0.01785449f, -0.00019862f, -0.01304111f, -0.04744633f, 0.02702929f, -0.04889398f, -0.00940372f, 0.03818924f, 
    -0.04592961f, 0.01075864f, -0.01609065f, -0.05390248f, 0.03356307f, 0.02767357f, -0.01670700f, -0.01072278f, 
    0.02494475f, 0.03475662f, -0.02085981f, 0.02785683f, -0.05438168f, 0.00767139f, -0.00963797f, 0.03814006f, 
    -0.03118508f, -0.01975290f, -0.00413229f, -0.00368217f, -0.01589382f, -0.04011926f, -0.01677426f, -0.01274898f, 
    0.01254378f, -0.05179100f, 0.00703986f, -0.04249731f, 0.03756564f, -0.04886938f, 0.00139854f, -0.00938031f, 
    -0.01144540f, 0.00755510f, 0.01117429f, -0.04050157f, 0.04155606f, -0.05303201f, -0.04938379f, 0.01715140f, 
    0.02631505f, -0.01439669f, 0.00863878f, -0.04586360f, 0.01938844f, -0.02278293f, 0.00496795f, 0.01602527f, 
    0.00709815f, 0.01119062f, -0.01607410f, -0.01372193f, -0.00693456f, -0.00411413f, 0.01130105f, 0.01975741f, 
    -0.04088564f, 0.00698673f, -0.02122696f, -0.02644905f, 0.00040297f, -0.05453786f, 0.02073018f, 0.04293107f, 
    -0.04896841f, 0.01755803f, 0.02642497f, -0.02743766f, 0.01967178f, 0.02481505f, 0.02628247f, 0.04383698f, 
    -0.02511466f, 0.01942301f, 0.01340241f, -0.05634258f, 0.00583655f, -0.02862318f, -0.03917338f, -0.04851371f, 
    0.03389874f, -0.03950182f, -0.04058003f, 0.01377278f, 0.01859059f, 0.03577667f, -0.01436862f, -0.05624257f, 
    -0.03040899f, 0.04337303f, -0.01770045f, -0.02088898f, 0.03923272f, 0.04149348f, 0.02854452f, 0.02073508f, 
    -0.04127691f, -0.01348252f, -0.05003034f, -0.02699449f, 0.03833253f, 0.03473778f, -0.04672829f, 0.00483731f, 
    -0.04967010f, 0.03178161f, -0.02033447f, 0.04332308f, -0.01571600f, -0.02956145f, 0.00875064f, 0.03048035f, 
    0.04489829f, -0.02768606f, -0.04963224f, 0.02689632f, 0.00610558f, -0.01780341f, -0.05670695f, -0.03566053f, 
    -0.03705618f, 0.00464524f, -0.01550541f, -0.04760785f, -0.03965081f, 0.03522773f, -0.04310435f, -0.00090780f, 
    -0.03834803f, -0.03738775f, 0.02255092f, 0.01794587f, 0.01209328f, 0.01301700f, 0.02802440f, -0.01679652f, 
    0.02694034f, 0.04456010f, 0.04065611f, 0.02216675f, -0.01553373f, -0.03115302f, 0.01877807f, -0.05031871f, 
    -0.00431998f, -0.02955841f, -0.04109554f, -0.02405909f, -0.00590972f, -0.04149840f, 0.00086978f, -0.01127485f, 
    -0.04424209f, -0.03325085f, -0.02562325f, -0.00917880f, -0.03799493f, 0.00080239f, 0.04028552f, -0.02505344f, 
    0.01474300f, 0.02280826f, 0.03922187f, -0.02269210f, -0.03666015f, -0.02637988f, -0.05604170f, -0.01892603f, 
    0.00442914f, 0.02976453f, -0.02332070f, -0.02758252f, 0.02760463f, -0.02528915f, -0.05369649f, 0.01340664f, 
    -0.02634281f, -0.02990361f, 0.01001227f, -0.05126939f, 0.03981512f, 0.01909776f, 0.00623705f, 0.02246835f, 
    -0.01392591f, 0.01739155f, -0.02534399f, 0.01714296f, 0.00717751f, -0.04450206f, 0.02762992f, 0.02592108f, 
    0.04236319f, -0.05530583f, -0.05187976f, 0.04499056f, -0.02076033f, 0.03437283f, 0.04350025f, 0.02375627f, 
    -0.02083970f, -0.02411416f, -0.00219869f, 0.03088155f, 0.00368321f, -0.04862705f, 0.03225048f, 0.01032685f, 
    -0.02656366f, -0.02270096f, 0.01693189f, -0.02269029f, 0.04448060f, 0.01021937f, -0.03224576f, 0.02421560f, 
    -0.01571946f, -0.02526681f, -0.05047338f, 0.01403998f, -0.00358017f, 0.03915371f, -0.04489072f, -0.04808725f, 
    0.00279641f, -0.02272844f, -0.04959761f, 0.02299688f, -0.05445789f, 0.02987791f, -0.05047388f, 0.01434791f, 
    -0.04443191f, 0.03897845f, 0.03509380f, -0.00827377f, -0.01910746f, -0.03627606f, -0.04914515f, -0.01014003f, 
    -0.03354306f, -0.01046955f, -0.04526849f, -0.02825026f, -0.00710331f, 0.01892162f, 0.03120970f, -0.02192994f, 
    0.03346336f, 0.04237258f, -0.00250452f, 0.00949299f, -0.03940998f, -0.05307415f, 0.02940037f, 0.02487152f, 
    0.01265609f, -0.03484266f, -0.03984063f, -0.04184242f, 0.01375205f, 0.01558759f, 0.02417415f, -0.00721645f, 
    -0.03846742f, -0.00992278f, -0.01732417f, -0.02110879f, -0.03184398f, -0.04743529f, -0.01347411f, -0.01000693f, 
    0.02974821f, -0.02950140f, -0.03154689f, 0.05087876f, -0.01774809f, -0.03938883f, -0.03761279f, -0.04480588f, 
    -0.04915153f, -0.03824341f, 0.04361992f, 0.02736240f, -0.03265280f, -0.05166102f, -0.02315098f, 0.01558946f, 
    -0.00278353f, 0.01907163f, -0.03166024f, -0.05273094f, -0.05528625f, -0.03379702f, -0.03893292f, -0.01729550f, 
    -0.04316315f, 0.00939326f, 0.02357502f, 0.00999667f, -0.01853637f, 0.01499045f, 0.03688047f, 0.00234578f, 
    0.04087001f, 0.00081002f, -0.02006385f, 0.03159255f, -0.03388194f, -0.05008619f, 0.00075408f, 0.04316773f, 
    -0.00685098f, -0.05373946f, -0.03325851f, 0.00186913f, 0.00443715f, -0.02593848f, -0.01746439f, 0.03541950f, 
    0.03637020f, 0.00020235f, -0.01817103f, -0.05620842f, -0.01816401f, 0.03583097f, -0.04866347f, -0.01667250f, 
    -0.00985919f, 0.03955973f, -0.01721143f, 0.00719708f, -0.02293121f, -0.05484266f, 0.03281218f, -0.01861778f, 
    0.03059582f, -0.00848850f, 0.00970121f, 0.01370063f, -0.05357479f, -0.04218587f, -0.03524208f, -0.03513620f, 
    0.02096231f, 0.17199947f, -0.09789134f, -0.05453015f, -0.00781174f, 0.01262360f, -0.12069241f, 0.11544183f, 
    0.03475715f, -0.02888860f, 0.03928806f, -0.12360884f, -0.07421391f, -0.30199549f, -0.08466162f, 0.10521311f, 
    0.06129676f, 0.03884159f, 0.05672714f, -0.00987677f, -0.10001329f, 0.02918890f, 0.00413505f, 0.04951347f, 
    0.20432553f, 0.09488887f, -0.01624671f, -0.13855043f, 0.08550894f, -0.00749994f, -0.08127305f, -0.02258896f, 
    -0.06163379f, -0.03896993f, 0.18799120f, -0.06551679f, 0.00214760f, 0.03271173f, 0.19408247f, -0.08258682f, 
    0.00907569f, -0.13665996f, 0.01438534f, -0.17431247f, -0.02150116f, -0.10596213f, 0.01516385f, 0.04945554f, 
    0.18677929f, 0.06745328f, -0.00859124f, 0.04887224f, -0.08975896f, -0.07571741f, 0.00084556f, 0.04636942f, 
    0.04196332f, -0.05809031f, -0.05989137f, -0.06022798f, 0.22674108f, 0.01002232f, 0.13477460f, -0.03015004f, 
    -0.06970155f, 0.11081101f, 0.07846568f, 0.00913975f, 0.11797111f, -0.05244768f, -0.00292074f, 0.10242963f, 
    -0.28466696f, -0.23488632f, 0.29969251f, -0.02092360f, -0.05397936f, -0.08283453f, -0.02583576f, -0.09064317f, 
    -0.02519204f, 0.17731071f, -0.00229459f, 0.10325836f, -0.06396814f, -0.02982683f, -0.13969731f, -0.02448927f, 
    -0.05235101f, 0.08399769f, 0.01073355f, 0.07836797f, 0.01574905f, 0.05535479f, 0.09474318f, 0.05624506f, 
    0.00464011f, 0.06736839f, -0.16943099f, 0.01695712f, 0.10442386f, 0.07803636f, -0.01160006f, 0.05700279f, 
    -0.10534449f, 0.00015942f, -0.01788330f, 0.05767691f, 0.07848907f, -0.11967641f, 0.02639326f, -0.08006530f, 
    -0.00768760f, -0.07840327f, 0.02800981f, -0.06021471f, -0.02789860f, -0.04317266f, -0.08108998f, 0.05321003f, 
    0.19577184f, -0.10403935f, 0.05346673f, 0.28879404f, -0.05014847f, 0.00462484f, 0.05832485f, 0.09183335f, 
    0.08203639f, 0.09378430f, -0.13887267f, 0.02744929f, -0.01639135f, -0.07693470f, -0.00431050f, 0.34803841f, 
    0.03434974f, -0.10649904f, 0.11377563f, -0.06082301f, 0.01353638f, 0.00247173f, -0.02554347f, -0.14302352f, 
    -0.34805915f, 0.05518485f, -0.06757631f, 0.17858464f, 0.14898908f, -0.01445825f, 0.12966490f, 0.11992867f, 
    -0.02502961f, 0.02893077f, -0.07257137f, 0.13495739f, 0.31975669f, -0.06301348f, -0.03614548f, -0.01157175f, 
    -0.12550262f, 0.11365609f, -0.01788194f, 0.07664233f, -0.05240976f, 0.05049726f, 0.13458507f, -0.02115546f, 
    0.39708063f, -0.16022998f, 0.01886009f, 0.07455663f, -0.00398776f, -0.02626312f, 0.04926410f, 0.04544445f, 
    0.05845032f, 0.04652849f, 0.11442799f, -0.06876544f, 0.03106232f, -0.06019768f, -0.04052067f, 0.12451296f, 
    -0.07390397f, 0.00554773f, -0.05349248f, 0.04659253f, 0.02854155f, 0.09692004f, 0.11409552f, -0.14747791f, 
    0.10151555f, -0.27328461f, -0.25754440f, 0.01817174f, 0.04497876f, -0.05199821f, -0.01069675f, 0.04613167f, 
    0.00808477f, 0.06716652f, 0.08326457f, 0.03394097f, 0.03291009f, 0.03806651f, 0.03671059f, 0.26212671f, 
    -0.03835089f, -0.03184529f, -0.06137292f, -0.02440744f, 0.03039735f, -0.10524644f, 0.06445450f, -0.08158251f, 
    0.25068465f, 0.07491790f, -0.02761273f, -0.09368030f, -0.13633834f, -0.04079451f, 0.00178732f, -0.08869428f, 
    0.03896251f, -0.09384193f, -0.06385981f, -0.08521698f, 0.10829321f, -0.02912042f, 0.13181691f, 0.04196731f, 
    -0.07180221f, 0.14396365f, -0.01297363f, 0.09718841f, 0.18954951f, 0.04671772f, -0.07436705f, 0.05235726f, 
    0.05802384f, 0.33088076f, -0.04187585f, -0.02012871f, 0.08602658f, 0.10371716f, -0.14004886f, 0.07260710f, 
    0.05811645f, 0.03359041f, 0.12732053f, 0.06783257f, 0.05014275f, -0.09837413f, 0.09211004f, -0.05768483f, 
    -0.09577573f, 0.07422895f, -0.07966790f, -0.13078120f, -0.00810239f, -0.15034325f, 0.14523795f, 0.07788102f, 
    0.13289316f, 0.20415349f, 0.00366972f, -0.03399912f, -0.10207532f, 0.06395150f, 0.10212719f, -0.05276760f, 
    0.00224918f, -0.02037818f, 0.14329462f, -0.07257696f, -0.04644046f, -0.28973892f, 0.29165208f, 0.30053630f, 
    -0.02026742f, 0.06161211f, 0.02102374f, -0.06511020f, 0.08796973f, 0.11682029f, 0.06528562f, 0.19637683f, 
    -0.31748059f, 0.42836282f, -0.00934324f, 0.10252061f, 0.11852057f, -0.07898028f, -0.11624823f, -0.10575639f, 
    0.09331631f, 0.05111970f, 0.00795799f, -0.01639840f, -0.04654638f, 0.28839993f, -0.24057569f, 0.09331660f, 
    0.10997111f, 0.03895968f, 0.08183222f, 0.11277141f, 0.08288758f, 0.01140512f, -0.01696370f, -0.01449047f, 
    0.62157238f, -0.01736562f, 0.15032355f, 0.14993203f, 0.01001484f, -0.04944891f, -0.03670261f, -0.02812261f, 
    0.03224055f, 0.14323139f, 0.04187408f, 0.09050934f, 0.21687564f, 0.18972026f, 0.10402238f, -0.08917910f, 
    -0.23555990f, -0.08810534f, 0.18985355f, -0.08590262f, -0.03296646f, -0.04457295f, 0.05193633f, 0.14056721f, 
    0.02258203f, -0.14162686f, -0.01500115f, -0.17775682f, -0.09659103f, -0.11075606f, -0.01875575f, 0.00616398f, 
    0.05884827f, 0.00281683f, -0.12486251f, -0.09846295f, 0.08905996f, -0.04763224f, 0.07376163f, 0.27302870f, 
    0.05713030f, 0.10118434f, 0.15311775f, -0.08077801f, -0.02581154f, -0.01572897f, -0.02627376f, 0.09851144f, 
    -0.14403124f, 0.07063217f, 0.07167064f, -0.00177191f, 0.09132531f, 0.11721737f, 0.00145898f, -0.04521875f, 
    0.02797957f, 0.21368676f, -0.09562741f, 0.03472223f, 0.24415258f, 0.00761198f, 0.12570927f, -0.10369233f, 
    -0.01840629f, 0.02386717f, 0.06123069f, -0.02385240f, 0.00533046f, 0.06439304f, -0.12446632f, 0.06972810f, 
    -0.05899134f, 0.04151563f, -0.03191083f, 0.02439622f, -0.03696353f, -0.03506444f, 0.03848219f, 0.01024803f, 
    -0.02438967f, -0.04109030f, -0.01541648f, -0.04415620f, -0.04108161f, 0.00664362f, -0.04552056f, -0.01440174f, 
    0.02761099f, 0.03505085f, 0.04568405f, -0.01508343f, -0.02511824f, 0.01225646f, 0.01051249f, -0.00950186f, 
    -0.01514105f, 0.01092631f, -0.03620752f, -0.02432960f, 0.00069619f, 0.03283484f, -0.05174524f, 0.00648495f, 
    -0.03458224f, -0.03205870f, 0.03345527f, -0.02999934f, -0.02694399f, -0.05707802f, 0.02005909f, -0.04698959f, 
    -0.01285474f, 0.02276093f, -0.02870690f, -0.04964742f, 0.04668907f, -0.04401351f, 0.02318070f, -0.00566443f, 
    0.04258642f, -0.01690351f, -0.03837379f, -0.02152115f, -0.01284605f, 0.00485022f, -0.00591285f, 0.03355348f, 
    -0.03356966f, 0.00736154f, -0.05244438f, -0.05536883f, 0.02232596f, -0.04966104f, 0.01530740f, 0.03980697f, 
    0.01341953f, 0.02959025f, 0.03562355f, 0.04937492f, -0.03706968f, 0.03920332f, -0.03669117f, 0.02639483f, 
    -0.00674165f, 0.03358410f, -0.01214748f, -0.03268474f, 0.03428024f, -0.00646418f, -0.04125913f, 0.00337253f, 
    -0.00098300f, -0.02034487f, -0.03282980f, -0.01836413f, 0.03607193f, 0.03879221f, -0.04881307f, -0.01519735f, 
    -0.05627622f, 0.02235374f, 0.04216737f, -0.04259079f, 0.01871763f, 0.02568748f, 0.02590740f, 0.04364070f, 
    -0.04719189f, -0.02605815f, 0.02890466f, -0.02765952f, -0.00416753f, 0.02711811f, -0.01699689f, -0.04168382f, 
    -0.00595888f, 0.00370550f, -0.02268728f, 0.05225004f, -0.02046103f, -0.00741387f, 0.02869817f, 0.03911320f, 
    -0.00797642f, -0.01549944f, 0.00319800f, -0.04214259f, -0.03356987f, -0.00851077f, -0.03616932f, -0.03677949f, 
    0.00493084f, 0.00653792f, -0.03345291f, 0.04894790f, -0.02357487f, -0.01932021f, -0.02617863f, -0.03316853f, 
    -0.04563142f, 0.03600888f, -0.00046072f, -0.02074122f, 0.00949322f, 0.00742050f, 0.04132475f, 0.01551664f, 
    -0.02694722f, 0.04306987f, -0.01927288f, -0.02830210f, -0.05127017f, -0.02498995f, 0.02454894f, 0.02120863f, 
    -0.05290102f, -0.03196909f, 0.03524598f, -0.02848981f, -0.00102401f, -0.03585231f, -0.02836340f, 0.01063009f, 
    -0.03497937f, -0.02736405f, 0.02096097f, 0.00052436f, 0.03312631f, 0.02607018f, 0.03658928f, -0.01393299f, 
    0.04254573f, -0.01482811f, -0.01306871f, -0.03761881f, 0.03359777f, 0.00217690f, -0.02799623f, -0.01546880f, 
    -0.04474859f, -0.01858632f, 0.03430074f, -0.03629528f, 0.02602693f, -0.04533275f, -0.02146383f, 0.01129477f, 
    -0.04358448f, 0.00060940f, -0.04849106f, -0.01563658f, -0.02069551f, 0.01290341f, -0.02041652f, -0.04470995f, 
    -0.03309721f, 0.01821190f, 0.01591334f, -0.00286106f, 0.00617696f, 0.01486803f, -0.04229366f, -0.01921380f, 
    -0.04696364f, -0.02812889f, 0.03952448f, -0.01314232f, 0.04464293f, 0.00119792f, 0.04354583f, -0.02519422f, 
    0.01568417f, 0.00295660f, -0.02491907f, 0.02305093f, -0.03145854f, 0.03331649f, 0.01591248f, -0.02956143f, 
    -0.03700800f, -0.04645011f, -0.03260828f, 0.01104577f, -0.05057483f, 0.04211568f, 0.03931726f, 0.02133785f, 
    -0.05002290f, -0.04157222f, 0.04927332f, -0.01131312f, -0.01565587f, -0.01762609f, -0.03693788f, -0.03792934f, 
    0.03344800f, -0.02048594f, 0.00154776f, -0.02948998f, -0.03904800f, -0.04527555f, 0.02753141f, -0.01647768f, 
    -0.02973199f, -0.01187842f, -0.03922379f, -0.01067351f, 0.00024280f, 0.00797225f, -0.01255925f, 0.03801702f, 
    -0.03701234f, -0.02739839f, -0.03607565f, -0.03185312f, 0.01244804f, 0.00065826f, -0.04725374f, 0.00126098f, 
    0.00217595f, -0.03426092f, -0.01872418f, -0.01446658f, -0.05028412f, 0.03975593f, 0.02203046f, 0.03739281f, 
    -0.01635468f, -0.05594711f, 0.02993834f, -0.00919623f, -0.01208150f, -0.05711318f, 0.01471537f, 0.04068295f, 
    -0.05311421f, -0.00418470f, -0.01603311f, -0.03319418f, -0.04249355f, -0.02500810f, 0.00862729f, 0.04076178f, 
    0.00628408f, 0.00507633f, -0.02040641f, 0.02334847f, 0.00921820f, -0.03924707f, -0.01281100f, 0.00819293f, 
    -0.00286589f, 0.02541946f, 0.00552115f, -0.01662591f, 0.02123366f, -0.01457037f, -0.03078906f, -0.01167657f, 
    -0.03010325f, 0.01384713f, 0.00159033f, 0.03433185f, 0.03310180f, -0.04463156f, -0.02310904f, 0.03431375f, 
    -0.02914636f, -0.05568973f, -0.04273994f, -0.01759259f, -0.02301757f, -0.04482228f, -0.02834103f, -0.01059944f, 
    -0.02110627f, 0.02544480f, 0.03582697f, 0.01792004f, -0.02776279f, 0.02060783f, -0.00734143f, -0.03186087f, 
    0.00434385f, 0.01813214f, -0.01682095f, -0.03661928f, 0.01079461f, -0.03033644f, -0.01204959f, -0.04375267f, 
    0.03625109f, -0.00738427f, -0.01866869f, 0.00031577f, -0.02958915f, 0.00060689f, -0.02712461f, -0.05411382f, 
    0.03833068f, 0.01426348f, -0.02105395f, -0.03312708f, -0.00424687f, 0.04610853f, -0.02496280f, -0.05644788f, 
    -0.02218523f, -0.02698084f, 0.03531485f, -0.00097531f, -0.02084019f, 0.01342783f, 0.02686816f, 0.00544426f, 
    -0.05255403f, 0.00205869f, -0.00697439f, -0.03500168f, -0.02216103f, 0.04247625f, 0.00498229f, 0.03418339f, 
    0.00250872f, -0.00721751f, 0.00289704f, -0.03090694f, -0.02066213f, -0.05202242f, 0.00448933f, 0.02841256f, 
    -0.03546177f, -0.02104145f, -0.02386506f, 0.02080896f, 0.02263921f, -0.00736220f, 0.02165852f, -0.02264276f, 
    -0.02917201f, -0.04596557f, -0.05025361f, 0.03758472f, -0.04144910f, 0.00802776f, 0.04260146f, 0.04156212f, 
    -0.03185266f, 0.02561496f, 0.02560489f, -0.04475295f, 0.04666850f, 0.02721200f, -0.05245765f, -0.05693826f, 
    0.28055599f, -0.07178645f, 0.16123442f, 0.08216385f, -0.05369138f, -0.02160978f, 0.16735928f, 0.17293027f, 
    0.02211191f, -0.02687189f, -0.08036015f, 0.22995648f, -0.27431944f, 0.15482676f, 0.03057531f, -0.00010314f, 
    -0.08117456f, 0.07195071f, -0.11783925f, 0.04396712f, 0.12712076f, -0.10553706f, -0.06717861f, -0.04058798f, 
    -0.06314982f, -0.04371931f, 0.15293337f, 0.10193825f, 0.01339490f, -0.05670746f, -0.02612566f, -0.10404851f, 
    0.08285048f, -0.07517642f, -0.20248862f, 0.03050174f, 0.12914155f, 0.01828722f, 0.11754615f, 0.23736320f, 
    0.07977140f, 0.03961107f, -0.00257054f, 0.21749458f, 0.02547865f, 0.21845149f, 0.01909189f, -0.08028027f, 
    0.08306872f, 0.18534349f, -0.12628895f, -0.17775556f, 0.10140754f, 0.04155811f, 0.15843374f, -0.06554413f, 
    -0.02852085f, 0.07959452f, 0.03152573f, 0.09536198f, -0.07488328f, 0.01478389f, -0.02112820f, 0.02669522f, 
    0.06112225f, 0.04536625f, -0.06046414f, -0.07078076f, -0.14720888f, -0.04787941f, 0.05091721f, -0.11769140f, 
    0.26438603f, 0.18685691f, 0.10563949f, 0.01503820f, 0.03018695f, 0.07245550f, -0.07755710f, -0.06210890f, 
    -0.05267711f, -0.05380980f, 0.20189479f, 0.04690658f, 0.13990366f, 0.06318017f, 0.01673606f, 0.01460962f, 
    -0.10072675f, -0.16618674f, -0.05506034f, -0.18093750f, 0.01140973f, -0.17182942f, 0.05832680f, 0.03612253f, 
    -0.04409008f, -0.00762893f, 0.16453527f, 0.13140389f, 0.08343802f, -0.01173058f, -0.01155174f, -0.13904873f, 
    -0.03484683f, 0.13280192f, 0.13622041f, -0.08578847f, -0.23752056f, -0.30245528f, -0.03315374f, 0.07978171f, 
    -0.01142814f, 0.09119070f, 0.08217459f, -0.05055397f, -0.09183714f, 0.03207440f, 0.22426340f, 0.06093241f, 
    0.37233242f, 0.17893852f, -0.02639501f, -0.29674625f, 0.06421936f, -0.07117582f, -0.06319382f, 0.00794140f, 
    0.07770408f, 0.06172912f, 0.04159115f, -0.04881140f, 0.21852538f, -0.13235603f, -0.01385034f, -0.20580719f, 
    -0.05161818f, 0.13231981f, -0.03244029f, 0.12419120f, 0.06972074f, 0.03919096f, -0.02028579f, 0.13371260f, 
    -0.14929882f, -0.07961810f, -0.03045505f, -0.10951239f, -0.03897579f, -0.09469620f, -0.05677908f, -0.07573473f, 
    0.00864220f, 0.05512669f, 0.03739055f, -0.14408429f, -0.03953106f, 0.11121812f, 0.00094794f, 0.02749444f, 
    0.04706189f, -0.14072557f, 0.00207725f, -0.05336923f, 0.19363526f, -0.15470335f, -0.16248210f, -0.09929091f, 
    -0.11580715f, 0.25415909f, 0.11268557f, -0.06319287f, 0.02327447f, 0.04797957f, 0.01077223f, 0.11070129f, 
    -0.05009506f, -0.12309806f, -0.05037405f, -0.00781155f, 0.00282857f, 0.05849354f, -0.03760318f, 0.12077166f, 
    -0.00593549f, 0.02485157f, -0.02495835f, 0.06356990f, -0.00846661f, 0.01152882f, 0.12037804f, 0.10031005f, 
    -0.01125636f, -0.10793850f, -0.03705356f, 0.11563306f, -0.16459662f, -0.00597180f, 0.12038231f, -0.22989340f, 
    0.06863140f, 0.01918032f, -0.00652148f, 0.02484353f, -0.00387397f, 0.17029691f, 0.11010647f, -0.09779368f, 
    -0.01504171f, 0.00907973f, 0.02407609f, 0.03648771f, 0.01580457f, 0.09972130f, -0.03056231f, 0.13024087f, 
    -0.10199233f, -0.11067790f, -0.17085972f, 0.06965194f, 0.06142007f, 0.05173943f, 0.11497726f, 0.09340846f, 
    -0.02526620f, 0.08438384f, 0.14961687f, 0.13609333f, -0.16113546f, -0.05498997f, 0.10267513f, 0.01920843f, 
    -0.03504549f, -0.18407436f, 0.01730164f, -0.01340390f, 0.04343507f, -0.02145599f, 0.11008083f, -0.02930160f, 
    -0.06658831f, -0.04553977f, 0.08062182f, 0.09828591f, 0.01429848f, -0.12012702f, -0.03406302f, -0.10768031f, 
    0.01091952f, -0.10308803f, -0.01717828f, -0.00935341f, 0.00061741f, -0.01746465f, -0.04847062f, -0.09950563f, 
    -0.02928407f, -0.07295091f, 0.02353989f, 0.05065660f, -0.05133541f, 0.17426156f, -0.05870337f, -0.05197690f, 
    0.23675531f, 0.14313245f, -0.06571182f, -0.00092237f, 0.07941035f, -0.06506914f, -0.11067522f, 0.02281527f, 
    -0.02081889f, -0.07961074f, -0.17551678f, -0.03361961f, 0.15826461f, 0.15930137f, -0.03208435f, -0.01358092f, 
    0.11376072f, -0.06976831f, -0.07649770f, -0.04095071f, -0.01830900f, -0.19708617f, -0.00523271f, -0.11642105f, 
    0.27445278f, 0.15330586f, 0.02611071f, 0.12276104f, 0.04169840f, -0.15659286f, 0.15278514f, 0.05346443f, 
    0.00512286f, -0.00405622f, -0.07055338f, 0.06347557f, -0.27791473f, -0.05412210f, 0.24575761f, 0.02586814f, 
    -0.03672738f, 0.02726803f, -0.05580759f, -0.12046396f, -0.06245428f, -0.04679476f, -0.01528075f, 0.00792922f, 
    -0.12762006f, 0.00011295f, -0.03129815f, -0.09164677f, 0.02967127f, -0.02047780f, 0.00838156f, 0.00241498f, 
    0.07735933f, -0.14867453f, 0.13171580f, 0.15274344f, -0.13001670f, 0.02991463f, 0.03570206f, -0.00978411f, 
    0.18806162f, -0.13556817f, 0.03308958f, 0.12395899f, 0.05164743f, -0.01645288f, -0.05030626f, -0.08045921f, 
    -0.31767362f, 0.17200680f, 0.21632445f, 0.12685156f, -0.03749526f, 0.15260646f, 0.12778290f, 0.16903432f, 
    0.02186649f, -0.01500809f, 0.19928640f, 0.15455663f, -0.05627204f, 0.13284332f, 0.10431034f, 0.01344959f, 
    0.04574575f, 0.01613666f, -0.04307560f, 0.02203475f, -0.00358737f, -0.00512326f, 0.04074259f, -0.16002335f, 
    0.23288624f, 0.04956526f, -0.03760916f, 0.07634413f, -0.05483758f, 0.03689330f, 0.02467854f, -0.01892640f, 
    -0.07540947f, -0.16312917f, 0.10459430f, -0.12271231f, -0.03859303f, 0.03769319f, -0.05095831f, 0.18647674f, 
    -0.00618712f, 0.00420081f, 0.01399722f, -0.11386698f, -0.11151272f, -0.13470060f, 0.17421280f, 0.07354791f, 
    0.11632374f, 0.10420677f, -0.08283770f, 0.05276671f, 0.03577288f, 0.00152726f, 0.00880152f, -0.10066970f, 
    0.06771034f, -0.09094058f, -0.00574398f, -0.18894388f, 0.15452352f, -0.27442929f, -0.05877577f, 0.00854976f, 
    0.06190214f, 0.03074100f, -0.04023596f, -0.05611531f, -0.03150246f, 0.13979563f, 0.06434079f, 0.07108095f, 
    0.10174361f, 0.06294104f, 0.03002429f, 0.16179898f, -0.03381415f, -0.08300950f, 0.05065285f, 0.06327575f, 
    -0.03263215f, 0.10699850f, 0.23913953f, 0.07677194f, -0.09198183f, 0.32154438f, -0.02450805f, -0.11833958f, 
    0.14389214f, -0.05908358f, 0.04141612f, -0.15645392f, 0.03449124f, 0.03594024f, 0.01483324f, 0.06186096f, 
    0.06647631f, -0.18775499f, 0.06981856f, 0.12489302f, -0.06201673f, 0.05922458f, 0.03395231f, 0.02216616f, 
    0.22801484f, 0.00866436f, 0.01916396f, -0.13963783f, -0.16092783f, 0.22829381f, -0.07337613f, -0.05686899f, 
    0.02911111f, 0.04134937f, 0.06867985f, 0.19853176f, 0.02744468f, 0.06225499f, -0.00430267f, 0.09222392f, 
    -0.17066033f, -0.09194084f, -0.04838841f, 0.03126431f, -0.18175223f, -0.18943222f, 0.07458483f, -0.17494033f, 
    0.01176780f, -0.04375360f, -0.05340594f, -0.04770865f, 0.06335221f, -0.18192324f, -0.12998053f, -0.01903278f, 
    0.01480577f, 0.13663603f, -0.08661488f, -0.04408149f, 0.01943207f, 0.11818860f, 0.07090463f, 0.02995372f, 
    0.02784600f, -0.01659266f, -0.11821443f, -0.12116407f, 0.03634582f, -0.09191936f, -0.06977422f, 0.08787183f, 
    0.06756262f, -0.09524683f, -0.01940312f, 0.07672679f, 0.05294366f, 0.15603603f, -0.08911620f, -0.18405032f, 
    0.11382595f, 0.07035129f, -0.10331511f, -0.10144214f, -0.03916357f, 0.00039790f, -0.08392563f, -0.10771443f, 
    -0.39093634f, -0.03818553f, 0.25932115f, 0.17810394f, 0.05502341f, 0.12806301f, 0.12607588f, 0.07209637f, 
    0.02985785f, -0.02673877f, 0.11028168f, 0.12361143f, -0.20169389f, 0.20097515f, -0.00024414f, 0.38731861f, 
    0.08797234f, -0.04717778f, -0.00119485f, -0.04139476f, -0.10472471f, 0.02297070f, 0.06893592f, 0.01148253f, 
    0.05742990f, -0.17091680f, -0.04177404f, -0.11500685f, -0.00919260f, 0.06866721f, -0.00119033f, 0.03974858f, 
    0.07723034f, -0.09644286f, 0.01370400f, 0.11311362f, 0.24967286f, -0.08581261f, -0.03723986f, 0.04127022f, 
    0.05605358f, -0.00466998f, 0.12728482f, 0.10769912f, 0.09156382f, 0.13450059f, 0.16971529f, 0.23070240f, 
    -0.07685836f, -0.06519005f, -0.15867789f, 0.08880801f, 0.06259034f, 0.00145211f, 0.00597167f, 0.07550278f, 
    0.09650823f, 0.10549323f, 0.00277433f, 0.01651434f, -0.27303705f, 0.14656855f, 0.00395070f, -0.17468615f, 
    0.08470498f, -0.09872405f, -0.10300071f, -0.01552723f, 0.00047539f, -0.03183953f, 0.00115495f, -0.06560434f, 
    -0.19963884f, 0.22964831f, 0.13410439f, -0.13476382f, 0.00085031f, 0.01269829f, -0.01386363f, -0.04119233f, 
    0.00167005f, -0.02126692f, 0.07418972f, 0.09488597f, -0.14610863f, 0.02565049f, 0.10741004f, 0.10179279f, 
    -0.03131491f, 0.04251846f, -0.07446533f, 0.10101806f, 0.04192467f, -0.04853582f, 0.05173604f, -0.05895456f, 
    -0.04917824f, 0.02830150f, 0.00100217f, -0.13838911f, 0.06995624f, -0.02760971f, -0.06142008f, -0.11039580f, 
    -0.02003443f, -0.08336884f, -0.11954124f, -0.13111524f, 0.06212497f, 0.07819033f, 0.25383508f, 0.27131251f, 
    0.03248474f, 0.08621559f, 0.03656003f, 0.13572282f, 0.03990594f, 0.01448629f, 0.05902518f, 0.04207343f, 
    0.22575459f, 0.04202399f, 0.04837660f, 0.12817627f, -0.03532436f, 0.02756597f, 0.09927774f, 0.09527644f, 
    0.03465229f, 0.12761211f, -0.01610278f, 0.02244515f, -0.12582317f, -0.10993510f, -0.00164831f, -0.03244093f, 
    0.14753473f, 0.09841733f, -0.03899686f, -0.05121571f, 0.09409323f, -0.06157494f, 0.04811362f, 0.02258058f, 
    0.05613552f, 0.07264742f, -0.06943265f, -0.03436413f, 0.04945021f, 0.07974042f, 0.05019355f, 0.11337688f, 
    0.10847752f, -0.04440198f, 0.16202590f, 0.07674982f, -0.01451535f, -0.15741903f, -0.06562738f, -0.00461783f, 
    -0.05588329f, 0.01679507f, 0.05916172f, -0.02523144f, 0.06586913f, 0.08914959f, 0.11438349f, 0.17153904f, 
    0.02706635f, -0.07114318f, 0.27298096f, 0.03265701f, 0.03025818f, 0.02070732f, -0.08662243f, -0.04925929f, 
    0.02445365f, 0.10681264f, -0.00633059f, -0.02322128f, 0.06887355f, 0.06586043f, -0.04508991f, 0.12328193f, 
    -0.01915461f, -0.04949574f, -0.02811504f, 0.04655112f, 0.04999002f, 0.08769538f, 0.03839484f, 0.01855763f, 
    -0.19515169f, 0.09133691f, -0.02354581f, 0.14749426f, 0.07638833f, 0.02181201f, -0.03596394f, 0.02629795f, 
    0.02816033f, 0.08351766f, -0.10673661f, 0.05053845f, 0.10628378f, 0.25691786f, 0.10871954f, -0.00160691f, 
    -0.03073394f, 0.07692186f, 0.15476207f, 0.07360693f, 0.05668793f, 0.00958171f, 0.07500082f, 0.03876234f, 
    0.25798869f, -0.15043564f, -0.09432624f, -0.30890483f, 0.08695095f, -0.07106769f, -0.02937471f, -0.18422128f, 
    -0.07061201f, -0.00566083f, -0.13596784f, -0.10431632f, 0.03316517f, -0.08297396f, 0.01198176f, 0.01679766f, 
    -0.00916000f, -0.05484848f, 0.03243798f, -0.05730171f, -0.03521324f, 0.03858019f, 0.05225404f, 0.19112922f, 
    0.04084639f, 0.08100740f, 0.04896940f, -0.02895205f, 0.14265171f, -0.06231356f, -0.02965320f, -0.10924635f, 
    -0.07468024f, 0.15707140f, -0.05984009f, -0.00790043f, 0.05449361f, 0.14824213f, 0.04188719f, -0.17324820f, 
    0.00257428f, 0.11897795f, 0.03278075f, 0.05611604f, 0.11877421f, 0.21845388f, -0.00987642f, -0.08020536f, 
    0.01558907f, 0.20195831f, 0.16624708f, 0.27917680f, 0.09128091f, 0.00193497f, 0.12665728f, 0.01366193f, 
    -0.15816864f, -0.00131172f, 0.14569026f, -0.03084111f, -0.00432818f, -0.02940195f, -0.16962101f, -0.00171229f, 
    0.02038326f, -0.14576657f, -0.01562762f, -0.05930798f, -0.03638950f, -0.18526596f, -0.03203784f, -0.06635587f, 
    0.16324398f, 0.22031431f, -0.02357702f, 0.19120876f, 0.05276955f, 0.21448757f, 0.07414311f, -0.03132992f, 
    0.06278402f, -0.05034251f, -0.08177885f, -0.13053076f, 0.32137966f, 0.40130839f, 0.13409410f, 0.20716636f, 
    0.09468344f, -0.06209530f, 0.11060859f, 0.09876720f, -0.13530469f, -0.10034721f, 0.02414670f, 0.05120162f, 
    0.09793343f, -0.00182818f, -0.04365468f, 0.18715563f, -0.00824327f, 0.13419460f, -0.04788188f, 0.11425033f, 
    0.17012686f, -0.00351843f, -0.04828889f, 0.05354176f, -0.05463819f, -0.04820670f, 0.06922539f, 0.03216242f, 
    -0.04228950f, 0.02783612f, -0.02363810f, 0.05394710f, -0.16929209f, -0.03558140f, -0.08203971f, -0.02739239f, 
    0.09564366f, -0.25130808f, -0.06035984f, -0.02339887f, -0.01308696f, 0.02870425f, -0.08919656f, 0.01178167f, 
    -0.01808895f, 0.03741725f, -0.06465276f, -0.08196361f, -0.06635648f, -0.13930179f, -0.11401355f, -0.16011277f, 
    0.12353411f, -0.12596931f, 0.02763341f, 0.02352764f, 0.05634923f, -0.07338270f, -0.03174026f, 0.10608421f, 
    -0.14699586f, -0.25214303f, -0.07835636f, -0.27984384f, 0.01714768f, -0.04385946f, -0.09065953f, 0.01099862f, 
    -0.02825235f, 0.02100500f, -0.03611462f, 0.03827888f, 0.05094859f, 0.06458453f, -0.00374253f, 0.05425598f, 
    0.04731367f, 0.12603368f, 0.14323388f, 0.03549637f, 0.16928396f, -0.00899532f, 0.04582852f, 0.01022253f, 
    -0.03984392f, 0.12294408f, -0.22110479f, 0.22275901f, -0.02130193f, -0.15624426f, -0.06135885f, -0.10328804f, 
    -0.25832871f, -0.00058905f, -0.13221197f, -0.00595233f, -0.09575389f, -0.07700045f, 0.15383764f, 0.08763684f, 
    -0.05680657f, -0.03583423f, 0.00154503f, -0.05512479f, -0.04388627f, 0.06057011f, -0.08965220f, 0.25612622f, 
    0.09804332f, -0.04878600f, -0.04953777f, 0.10053083f, 0.03814275f, -0.04024551f, -0.01656180f, -0.03979577f, 
    -0.07879005f, 0.01225969f, 0.02932944f, 0.05320244f, 0.16062877f, 0.20891881f, -0.07287990f, -0.05205653f, 
    -0.05245992f, 0.11112261f, -0.09823316f, -0.00781005f, -0.03865214f, -0.01542203f, -0.15925093f, -0.15445668f, 
    0.20009282f, 0.10329738f, -0.04063572f, -0.08793730f, 0.09194531f, 0.11805709f, -0.02664977f, 0.01389664f, 
    0.08732193f, -0.08891553f, -0.04600272f, -0.03731836f, -0.15552105f, -0.07376987f, -0.08965079f, -0.29696849f, 
    0.06465821f, 0.01765872f, -0.05705101f, 0.16898425f, 0.00867386f, 0.18552434f, 0.10917891f, 0.04554454f, 
    0.39672777f, -0.01387731f, -0.10910429f, 0.20057197f, -0.07126991f, 0.00401784f, -0.17742857f, 0.10490938f, 
    0.12984461f, 0.03913787f, -0.03331345f, 0.13773690f, 0.06317092f, 0.17400487f, -0.02257941f, 0.11091468f, 
    -0.04360008f, 0.14396800f, 0.00051944f, 0.03285067f, -0.14949210f, -0.03971530f, 0.02184428f, 0.07844943f, 
    -0.37550059f, -0.18493275f, -0.02452350f, -0.07263321f, 0.05144911f, -0.07940539f, 0.02385798f, 0.13946919f, 
    0.22762206f, 0.18274958f, 0.18336046f, 0.19703779f, 0.29459247f, 0.06279235f, -0.09924615f, 0.18486592f, 
    -0.06750157f, 0.01677456f, -0.10004147f, 0.00358170f, 0.01080606f, 0.09521977f, 0.03720628f, 0.04176929f, 
    0.17876862f, 0.03752470f, 0.12684962f, 0.13020580f, -0.02377910f, 0.04709116f, -0.00843470f, 0.05345491f, 
    -0.05948275f, 0.07446226f, -0.01997490f, -0.03300464f, -0.09999051f, 0.01828857f, -0.21019241f, -0.09905048f, 
    -0.08178438f, -0.03871801f, -0.05057723f, 0.05775812f, 0.02404563f, -0.02730755f, 0.00039869f, 0.00972592f, 
    0.00738361f, 0.09232207f, 0.33404943f, 0.21633080f, -0.00966872f, -0.00579513f, 0.01890298f, 0.07581041f, 
    0.00803668f, -0.09484778f, -0.08084621f, -0.06541935f, -0.07837100f, -0.06515450f, -0.13508151f, -0.16666216f, 
    -0.02279330f, -0.02708034f, 0.02380740f, -0.04011128f, -0.22521329f, -0.04832390f, 0.07391310f, -0.18248467f, 
    -0.34180269f, 0.13148209f, -0.04999732f, 0.00640483f, -0.05009796f, -0.08894283f, -0.07997768f, 0.31807625f, 
    0.15216912f, -0.03361791f, 0.12640209f, 0.12305828f, 0.08488902f, -0.15005198f, 0.05865484f, -0.03872045f, 
    -0.12664598f, -0.03594064f, -0.05003430f, 0.06240094f, -0.11460268f, 0.04240450f, 0.03292623f, 0.09760499f, 
    0.31893441f, 0.13063549f, 0.26388031f, 0.34870854f, 0.02178663f, -0.07841879f, -0.00800383f, 0.03892707f, 
    0.00481655f, 0.06111433f, -0.02500506f, -0.00363978f, 0.23052633f, 0.17897542f, 0.17674769f, 0.35476381f, 
    0.01758602f, -0.04027713f, -0.00114164f, 0.07374089f, -0.18705498f, -0.08591712f, -0.10345046f, -0.01779646f, 
    0.22831245f, 0.01450562f, 0.17446914f, 0.20525703f, 0.00845341f, -0.08704775f, 0.07625015f, 0.08912976f, 
    -0.00966762f, 0.05892055f, -0.02656643f, -0.01336310f, 0.01889611f, -0.13532273f, -0.21028304f, 0.06689187f, 
    0.09680606f, -0.00177093f, 0.02305324f, -0.11483659f, -0.08179627f, -0.13972142f, -0.02604396f, -0.11005215f, 
    0.28430617f, 0.15206227f, 0.15391652f, 0.07054006f, 0.05691381f, 0.04123440f, -0.11091115f, -0.16438204f, 
    -0.05707479f, 0.02271082f, -0.16735071f, 0.04466826f, 0.00904746f, -0.17268930f, 0.14755313f, 0.28465953f, 
    0.07879953f, -0.10795992f, 0.00238053f, -0.01056206f, -0.08399747f, -0.00931654f, 0.00572984f, -0.02195039f, 
    0.17724055f, -0.09657044f, -0.06476460f, -0.04610457f, -0.09446773f, -0.03252840f, -0.08998600f, 0.08105781f, 
    -0.00951375f, 0.08007608f, 0.05641674f, 0.18313783f, 0.22302069f, 0.06744078f, 0.12377913f, 0.10835505f, 
    -0.08429290f, -0.03360559f, -0.05578854f, 0.00809050f, 0.16832346f, 0.00604527f, -0.05054113f, 0.04396673f, 
    0.04181662f, 0.04327643f, 0.06342071f, 0.09400601f, 0.08722612f, 0.09891290f, 0.13468549f, -0.02351750f, 
    0.07850260f, -0.00539559f, -0.07370842f, 0.12234847f, 0.02088154f, 0.19737560f, -0.18989085f, -0.12673250f, 
    -0.01681484f, -0.10967714f, -0.04107041f, 0.17378534f, 0.00002476f, 0.09088942f, 0.07386585f, -0.04972103f, 
    0.18845972f, 0.00743535f, -0.06022619f, -0.07832115f, 0.06819684f, 0.04145685f, -0.00178656f, -0.13293622f, 
    -0.04618597f, 0.01535823f, -0.04387914f, 0.15386990f, -0.23288384f, -0.01727067f, -0.06935512f, -0.05938756f, 
    0.09849880f, 0.10541966f, 0.01500777f, -0.06076663f, 0.01969174f, -0.03550508f, 0.04526102f, -0.09476474f, 
    0.20314845f, -0.04198931f, 0.11417870f, -0.07988631f, 0.22509821f, 0.12067827f, -0.06688815f, 0.12892060f, 
    0.00128341f, 0.10379800f, -0.03225643f, 0.03601817f, 0.14462686f, 0.24727708f, 0.19262326f, 0.11290561f, 
    -0.13557099f, -0.20289774f, -0.05426832f, 0.13913842f, 0.15234892f, -0.01245012f, -0.03382433f, 0.03776177f, 
    0.08220427f, 0.14958110f, 0.08716766f, 0.02710755f, 0.02945672f, 0.07958350f, 0.12476618f, 0.09350946f, 
    0.01235361f, 0.20600350f, 0.00201950f, 0.01911027f, -0.28516141f, -0.05740900f, 0.17406005f, -0.06980573f, 
    0.02758426f, 0.02647666f, 0.11161993f, 0.12220393f, 0.12703194f, 0.01758901f, 0.03723045f, 0.21025579f, 
    0.07789479f, -0.04939005f, -0.12427071f, -0.03119455f, -0.05687080f, 0.02765384f, -0.01992623f, 0.09941661f, 
    -0.00284774f, 0.07576533f, -0.05812879f, -0.01532358f, 0.06702039f, -0.02249624f, 0.12049321f, -0.26747733f, 
    -0.14985391f, 0.14247462f, 0.02252015f, -0.02325391f, 0.13462253f, -0.01152834f, 0.05489426f, 0.06040486f, 
    0.16501488f, 0.15461774f, 0.10860676f, 0.15132181f, -0.13399075f, -0.10333517f, 0.05675271f, 0.06232226f, 
    -0.00811470f, 0.16542213f, -0.06142507f, -0.04121069f, -0.04812923f, 0.01071276f, -0.00867816f, 0.07667640f, 
    -0.00218400f, -0.03270621f, 0.04765841f, -0.04786586f, 0.07607849f, -0.06370378f, -0.01061263f, -0.11957372f, 
    0.20542029f, -0.08748407f, -0.05306682f, -0.04032753f, 0.11496109f, 0.08952924f, 0.03365379f, 0.00968914f, 
    -0.07648151f, -0.01358213f, 0.07255718f, 0.00229367f, 0.00163500f, 0.10759952f, -0.11166260f, 0.04706839f, 
    -0.06175712f, 0.09547841f, -0.01422908f, 0.28520814f, 0.02463571f, 0.06824341f, -0.01585586f, 0.16085422f, 
    0.45386377f, -0.18175019f, -0.08340835f, 0.17104410f, 0.07082548f, -0.00558221f, -0.00227583f, 0.02620845f, 
    0.10059186f, 0.01134130f, -0.08670267f, 0.06653431f, 0.02998337f, 0.18410964f, -0.22552225f, -0.09076466f, 
    0.03381904f, 0.06736701f, 0.06500777f, 0.03177269f, -0.06759015f, 0.00252028f, 0.04919667f, 0.09653407f, 
    -0.09862632f, -0.16347706f, -0.01075669f, 0.11759046f, 0.05055854f, 0.02604156f, 0.17400621f, 0.18765742f, 
    -0.01605768f, 0.04920499f, 0.11653578f, 0.25521114f, 0.09456084f, -0.07602245f, 0.09851636f, -0.04700746f, 
    0.05883479f, -0.00508655f, 0.05838403f, -0.00390926f, 0.04977499f, 0.03106263f, -0.00248228f, 0.07939430f, 
    -0.20891547f, 0.03080161f, -0.14859004f, 0.00735027f, 0.03857975f, 0.03742958f, 0.01783075f, 0.01135774f, 
    0.08280555f, 0.00124935f, 0.07593615f, 0.06495390f, 0.07535349f, -0.09712356f, 0.03595574f, 0.02322776f, 
    -0.07372541f, -0.06367245f, 0.00709360f, 0.07967600f, 0.08355082f, 0.12868737f, -0.06991781f, 0.02135380f, 
    -0.04322014f, -0.11754550f, -0.08438829f, -0.06533535f, -0.10522041f, -0.05423674f, -0.12113752f, -0.02720931f, 
    -0.07305453f, -0.00142524f, -0.06115914f, 0.04084269f, 0.34430838f, -0.09370499f, 0.20056856f, 0.02495802f, 
    -0.04236566f, -0.01797801f, -0.03311251f, -0.00265810f, -0.02921032f, 0.00225274f, 0.05236784f, -0.05271612f, 
    -0.07926509f, -0.08841801f, -0.19045074f, 0.03902464f, -0.03154802f, 0.02396274f, 0.05529629f, 0.01110550f, 
    0.06993103f, 0.05110638f, -0.02010862f, 0.12672728f, -0.24634115f, 0.22236207f, -0.02384650f, 0.08006227f, 
    0.02681192f, -0.04700821f, 0.12507120f, -0.02096670f, 0.07769286f, 0.01240407f, 0.08935829f, -0.03860854f, 
    -0.14434607f, -0.08909565f, -0.19555925f, -0.06368406f, -0.04182864f, 0.00804301f, 0.00924384f, -0.03776065f, 
    0.00635547f, -0.12101810f, 0.09810867f, 0.05856286f, 0.02443320f, -0.11973462f, -0.14514469f, -0.09666933f, 
    -0.08163857f, -0.03857187f, -0.13024898f, -0.18013859f, -0.05755279f, 0.01315018f, 0.09669480f, 0.09845042f, 
    -0.25735405f, -0.36093432f, 0.13573417f, -0.01771030f, 0.02884422f, 0.00611263f, 0.04593128f, -0.03781158f, 
    0.07153318f, 0.06077489f, 0.20903625f, 0.09474450f, 0.26494148f, 0.05372379f, 0.06540905f, 0.10182539f, 
    -0.11759327f, 0.05818547f, 0.01904151f, 0.02533204f, 0.13815220f, 0.05333007f, 0.00877579f, -0.06031553f, 
    0.04429098f, 0.09684941f, -0.11610314f, -0.00339960f, -0.13174364f, 0.04969860f, 0.08000274f, -0.01791289f, 
    0.07347141f, -0.00511079f, 0.04495245f, 0.06701728f, -0.15742178f, 0.13480051f, 0.00598384f, -0.05136026f, 
    0.04784355f, -0.13802049f, 0.02331568f, 0.09094298f, -0.02527288f, -0.14331605f, 0.12238903f, 0.00591344f, 
    0.14468515f, 0.09324356f, -0.08039738f, -0.01357181f, 0.04658259f, -0.10696949f, -0.11636436f, 0.06143282f, 
    -0.02161408f, 0.04813434f, -0.09856399f, -0.02757251f, 0.13520262f, -0.17404634f, -0.06690640f, 0.07901834f, 
    0.08520114f, -0.00224117f, 0.01607473f, -0.08196802f, -0.00327308f, 0.08955647f, -0.04450369f, -0.02657686f, 
    0.23115127f, 0.09472668f, -0.12685728f, -0.17761482f, 0.02883261f, 0.00465116f, 0.07347471f, -0.04877477f, 
    0.03482150f, 0.07235289f, 0.03546079f, -0.02481990f, 0.11436574f, -0.09874345f, 0.11465614f, -0.02257291f, 
    -0.09206736f, -0.12399595f, 0.02282826f, -0.03792150f, -0.11801371f, -0.25220346f, 0.01403791f, 0.02121929f, 
    0.13331956f, -0.04604420f, -0.01593635f, -0.06831099f, 0.05485037f, 0.04218917f, -0.04154545f, 0.00950352f, 
    0.00643945f, -0.01272401f, -0.15536694f, -0.13981408f, 0.35993826f, -0.11210232f, 0.05583448f, 0.14053623f, 
    -0.04449929f, 0.07906762f, 0.01118435f, 0.03428938f, 0.06244833f, -0.07892634f, -0.00844019f, 0.13403483f, 
    -0.11871731f, -0.15601467f, 0.21945973f, -0.01376385f, 0.00551133f, -0.02897633f, -0.08897088f, -0.01728190f, 
    -0.02182813f, 0.18089999f, -0.02646348f, 0.03548530f, -0.09400250f, -0.05835342f, -0.14421849f, 0.05169807f, 
    0.04245434f, -0.02121069f, 0.00904786f, 0.09037229f, 0.04316337f, 0.01093321f, -0.01197828f, 0.11084150f, 
    -0.02513924f, 0.06459662f, -0.14884259f, 0.18913154f, 0.13327286f, -0.02637417f, 0.00354373f, -0.02822216f, 
    -0.03820019f, 0.04182820f, 0.01991779f, 0.06723278f, 0.11336052f, -0.02118836f, 0.07157912f, 0.06212454f, 
    0.05380206f, -0.02854751f, 0.07467140f, 0.00695787f, 0.11089735f, -0.08498409f, -0.16846122f, 0.10942528f, 
    0.11321647f, 0.01219403f, -0.13451451f, -0.07616877f, 0.02695950f, 0.00615777f, 0.00823173f, 0.03031582f, 
    0.09480599f, 0.11084482f, -0.07545147f, -0.00413861f, -0.12592326f, 0.03128749f, -0.05568739f, 0.25330314f, 
    -0.09162839f, -0.10434704f, 0.10677038f, -0.11875621f, 0.04197213f, -0.06170940f, -0.06317955f, -0.09363651f, 
    -0.17174077f, 0.03415811f, 0.00923268f, 0.07813274f, 0.13550738f, 0.07524387f, 0.07651099f, -0.01027396f, 
    -0.05971782f, 0.06301334f, 0.00529089f, 0.13193293f, 0.14565094f, -0.13203812f, 0.01701654f, -0.11342584f, 
    -0.10042305f, 0.09708445f, -0.08089282f, 0.06393270f, -0.01786274f, 0.06797251f, 0.08284298f, -0.08810050f, 
    0.41792080f, -0.20460783f, 0.05280385f, -0.04184281f, 0.02084392f, 0.02967006f, -0.02491853f, 0.07846752f, 
    0.16847758f, 0.07022581f, 0.04903232f, 0.01062308f, 0.28240043f, -0.06550493f, -0.06109145f, 0.19305596f, 
    -0.04752600f, 0.06309635f, -0.04115012f, 0.03848315f, 0.04759941f, 0.04001198f, 0.02273807f, -0.08611576f, 
    0.09938385f, -0.32956177f, -0.10771121f, -0.03195761f, 0.05324083f, -0.03491021f, -0.01245407f, 0.06259319f, 
    0.07960825f, 0.04232052f, -0.00744019f, 0.05244775f, 0.01715525f, -0.02743268f, -0.09218995f, 0.02225227f, 
    -0.03319984f, 0.03881742f, -0.02529698f, 0.01151498f, -0.02055351f, -0.11987720f, 0.01486018f, 0.01085111f, 
    0.23106322f, 0.03872811f, 0.03791020f, -0.01960767f, -0.07101066f, 0.03032665f, -0.00556289f, -0.08676459f, 
    0.08639522f, -0.06512614f, 0.03503066f, 0.01903109f, -0.01212839f, 0.09561050f, -0.00585825f, -0.20905207f, 
    0.04645412f, 0.06518657f, -0.00369861f, 0.02102349f, 0.09105604f, -0.01709349f, -0.12626667f, 0.02417929f, 
    0.01336488f, 0.33799869f, -0.08161876f, -0.18561010f, 0.09416468f, 0.07874789f, -0.05736202f, 0.02111278f, 
    0.10936486f, 0.09270652f, 0.18154855f, -0.00871393f, 0.20936950f, 0.01290705f, 0.00697327f, 0.06587101f, 
    -0.06744364f, -0.00706881f, -0.08950450f, -0.02132791f, -0.07940894f, -0.12734851f, 0.11346637f, 0.06654308f, 
    0.07862467f, 0.11299797f, 0.02778376f, -0.03099021f, -0.12748800f, 0.00359106f, 0.04278615f, 0.06355125f, 
    -0.04740275f, 0.03941640f, 0.02788068f, -0.04642396f, -0.03933095f, -0.20246403f, 0.17067900f, 0.15061986f, 
    -0.01382963f, -0.03403649f, -0.03123360f, 0.02940721f, 0.06365354f, 0.08614045f, 0.08315105f, 0.10176126f, 
    -0.36031595f, 0.24553537f, -0.10199008f, -0.18103279f, 0.02559437f, -0.00698756f, -0.04950814f, -0.01033435f, 
    0.05562774f, 0.00811179f, -0.00750545f, -0.08957600f, -0.02768023f, 0.28836954f, -0.20147453f, -0.20267224f, 
    0.07058556f, 0.08616637f, 0.03008456f, -0.02236233f, 0.14572728f, 0.08828075f, -0.03722344f, -0.00295081f, 
    0.60489988f, -0.09494943f, 0.04262428f, 0.11781769f, -0.05264558f, -0.02040400f, -0.05872656f, -0.04296007f, 
    0.08870385f, 0.08165280f, 0.01287348f, 0.08580317f, 0.20784749f, 0.07628151f, 0.05324871f, -0.07895290f, 
    -0.25005397f, -0.08876893f, 0.01377730f, -0.09327936f, -0.02377992f, -0.13278694f, -0.00556373f, 0.10223579f, 
    0.03440363f, -0.08060687f, 0.10659732f, -0.14943956f, -0.07783883f, -0.01374860f, 0.12724096f, 0.08355501f, 
    0.07592804f, -0.04610516f, -0.11358626f, -0.03005809f, 0.02460626f, 0.09517483f, 0.01992045f, 0.13354300f, 
    0.04921433f, 0.09718697f, 0.02330968f, -0.07736697f, -0.03227267f, 0.03884379f, -0.04281097f, 0.05937730f, 
    -0.24101421f, 0.09656586f, 0.08217002f, -0.12922938f, -0.01675453f, 0.16375953f, 0.02676062f, 0.00053116f, 
    0.10124688f, 0.03196999f, -0.03782550f, 0.10907106f, 0.16357529f, 0.01046892f, -0.02053784f, -0.01747851f, 
    0.06851592f, 0.00026865f, -0.02754710f, 0.04613300f, 0.08802549f, 0.06194283f, -0.09013373f, 0.16903976f, 
    -0.04128414f, -0.00612058f, -0.04182242f, -0.01125032f, 0.02222856f, -0.02778004f, -0.01341633f, 0.01473906f, 
    0.03297602f, -0.00734603f, -0.01298696f, -0.04241874f, 0.03980290f, 0.01349794f, 0.00318639f, -0.03247924f, 
    0.02349269f, -0.05204548f, -0.00176860f, -0.02715724f, -0.04255619f, -0.04601059f, -0.04525369f, 0.03510436f, 
    -0.03333401f, -0.03860604f, 0.02291548f, 0.00283716f, 0.03592750f, 0.03297827f, 0.00285933f, 0.03330775f, 
    0.02050804f, -0.01082122f, -0.03383887f, -0.02735711f, -0.03416519f, -0.05353434f, 0.00745690f, -0.05645410f, 
    0.03215212f, -0.04500766f, -0.01025193f, -0.00368267f, -0.04851038f, -0.03653209f, -0.01423530f, -0.05246318f, 
    -0.04125796f, 0.02448132f, 0.03713108f, 0.03554701f, -0.01890746f, -0.04551951f, 0.00034679f, 0.03780601f, 
    -0.00247935f, -0.00794841f, -0.03168520f, -0.05887464f, 0.01626096f, -0.01009957f, 0.00245596f, 0.03813170f, 
    -0.05413831f, -0.04495701f, 0.02695330f, 0.03915636f, -0.00069820f, -0.04162329f, 0.02163106f, -0.02934012f, 
    0.04214069f, -0.03814536f, -0.04792085f, 0.04128048f, 0.00988895f, 0.00063496f, -0.01759389f, -0.00821115f, 
    0.00889308f, -0.04372703f, -0.05082082f, 0.01176328f, -0.03242362f, 0.02472413f, -0.00979086f, -0.04038575f, 
    -0.03120182f, -0.03985193f, -0.01370967f, -0.00227913f, 0.02870651f, 0.01608273f, -0.03005105f, -0.04088796f, 
    0.00224239f, -0.03113444f, -0.03183362f, 0.00521232f, -0.01042176f, 0.00177492f, 0.03710718f, -0.01036528f, 
    -0.05563466f, 0.01178730f, 0.00195914f, -0.05750521f, -0.03325479f, 0.02528744f, 0.03723742f, 0.03804785f, 
    -0.05105489f, -0.02761259f, -0.01350783f, 0.01198878f, 0.04205780f, 0.01824196f, -0.05034196f, -0.02073277f, 
    0.02857544f, -0.04700090f, -0.02472163f, 0.03991181f, 0.01655666f, 0.01420526f, -0.05101285f, -0.05878638f, 
    -0.04537276f, 0.00242386f, 0.03118061f, 0.02228431f, -0.02292918f, 0.01518788f, -0.00030329f, -0.00083807f, 
    0.01115445f, 0.00531431f, -0.00770087f, -0.02040683f, 0.03399367f, 0.01516824f, -0.01006605f, -0.00266992f, 
    0.03270523f, 0.04159460f, 0.03714979f, 0.00739231f, 0.04124509f, 0.01968233f, 0.01638523f, -0.04387382f, 
    0.00588175f, -0.04755874f, -0.03458209f, 0.02072114f, -0.02507390f, 0.01741898f, -0.00364929f, 0.00566194f, 
    -0.04887797f, 0.01582378f, 0.00592902f, -0.05871299f, -0.05212004f, -0.01390780f, -0.02640975f, -0.04681659f, 
    -0.01929662f, -0.04489800f, -0.03702210f, -0.00834814f, -0.04750287f, 0.03683300f, -0.00102919f, 0.03486415f, 
    -0.01753437f, 0.00310125f, -0.02209441f, -0.00569783f, -0.03720673f, 0.00434940f, 0.02137190f, -0.03292516f, 
    -0.01653695f, -0.03926459f, -0.02695553f, 0.03423384f, -0.04780386f, 0.00083738f, 0.03849246f, -0.01568054f, 
    0.04186344f, 0.03489202f, 0.03300504f, -0.05467106f, -0.01561223f, 0.03142911f, 0.00333492f, -0.03153730f, 
    0.03357443f, 0.02697252f, 0.00847998f, 0.03422700f, -0.01200004f, -0.00980803f, 0.03484171f, -0.05065484f, 
    -0.04303821f, -0.02438832f, -0.02160157f, -0.02039870f, 0.00962917f, 0.03667689f, -0.04360886f, 0.02281202f, 
    -0.00942169f, -0.03767905f, -0.01457022f, 0.01719747f, 0.03729088f, -0.04765554f, -0.03410030f, -0.03495758f, 
    -0.05977831f, -0.00214691f, -0.01083205f, -0.03171108f, 0.01628612f, -0.04816207f, 0.02956367f, 0.02889972f, 
    -0.05596744f, -0.04310116f, -0.01965798f, 0.03407872f, -0.00784344f, -0.05299974f, 0.04359502f, 0.02450743f, 
    -0.01725845f, -0.05305594f, -0.04111330f, -0.04604649f, 0.01766984f, 0.03638682f, 0.04223347f, -0.02803706f, 
    -0.05745921f, -0.00275984f, -0.01308140f, 0.02351298f, -0.00992755f, 0.03581161f, 0.02025176f, 0.03905714f, 
    0.01687499f, -0.05420112f, -0.05444744f, 0.04361537f, -0.05960688f, -0.00020613f, 0.02364955f, -0.02933596f, 
    0.01615744f, -0.04630328f, -0.02138922f, -0.05997784f, 0.00826769f, -0.05068151f, -0.00057074f, -0.04708622f, 
    0.00675541f, 0.03162535f, -0.05126062f, 0.02464107f, 0.02982295f, 0.00299841f, -0.02619788f, 0.03675722f, 
    -0.00331566f, -0.02510203f, 0.04188712f, -0.03375622f, -0.04835922f, -0.02482028f, -0.02920713f, 0.00950977f, 
    0.03999141f, 0.01747177f, -0.04676957f, 0.01225325f, -0.02701447f, -0.01448621f, -0.04200777f, -0.01311302f, 
    0.03188128f, 0.00907699f, 0.01642800f, -0.05532627f, -0.05888193f, -0.02249709f, -0.01436404f, -0.02576464f, 
    0.02881318f, 0.00189019f, 0.00542786f, -0.02604754f, -0.01334121f, 0.02351472f, 0.02496674f, -0.03398244f, 
    -0.04571766f, -0.03033075f, 0.02968994f, 0.00862617f, -0.01763272f, 0.01522730f, 0.00566672f, -0.00943783f, 
    -0.01908857f, -0.04936295f, -0.02988867f, 0.01772952f, 0.03323731f, 0.03171173f, -0.00522430f, 0.02021969f, 
    0.01315315f, -0.00158190f, -0.04860019f, 0.01550455f, -0.00333229f, 0.00549344f, -0.05580985f, -0.00873590f, 
    -0.00843713f, 0.00853231f, 0.01083005f, -0.03833146f, -0.01544207f, 0.03031848f, -0.05091086f, 0.00032807f, 
    -0.00092886f, -0.02498279f, 0.02966556f, -0.00087830f, 0.02463631f, 0.01304683f, 0.00785076f, -0.00006011f, 
    -0.03237936f, 0.00144918f, -0.02998302f, 0.01143655f, -0.03505740f, -0.01673960f, 0.00560574f, 0.00773090f, 
    -0.03732416f, -0.01911960f, 0.03048105f, 0.00885922f, 0.01423515f, 0.00957537f, -0.04076517f, -0.04263920f, 
    0.03126130f, -0.05412285f, -0.00588841f, 0.02371816f, -0.02934772f, -0.05150726f, 0.03947629f, 0.00370427f, 
    -0.05154628f, 0.03713054f, -0.03928882f, -0.01560240f, -0.02161331f, -0.05678296f, 0.02314867f, -0.02235003f, 
    0.02371747f, 0.01401078f, -0.05284786f, 0.03872393f, 0.02700781f, -0.05130921f, 0.00060499f, -0.03924412f, 
    -0.04417453f, 0.03210177f, 0.00484299f, -0.04141348f, 0.02921636f, -0.00524176f, 0.02523701f, 0.02578620f, 
    -0.05604727f, -0.05054381f, 0.01360978f, -0.04522095f, -0.05446497f, -0.03226736f, -0.02702596f, 0.00259962f, 
    -0.00634784f, -0.01436426f, -0.00937536f, 0.00239017f, -0.05212975f, 0.02192972f, 0.01049638f, 0.02874481f, 
    -0.03427979f, -0.01967089f, -0.03337434f, 0.03464956f, -0.05064984f, -0.01951909f, -0.03095813f, 0.03240380f, 
    0.02712871f, -0.01572565f, 0.04369812f, -0.04184405f, 0.01359901f, 0.00561261f, -0.02081824f, -0.01800911f, 
    -0.04506284f, -0.03990785f, 0.01120263f, -0.00771590f, -0.02572212f, 0.02104797f, -0.05566369f, -0.00549704f, 
    0.03934612f, 0.02038991f, 0.01439962f, -0.02477026f, 0.03684865f, -0.00711809f, 0.00125532f, -0.04829851f, 
    -0.04391722f, -0.00985947f, 0.03456683f, -0.01429643f, -0.03293819f, 0.02485854f, 0.01824250f, -0.05080196f, 
    0.02884793f, -0.02731623f, -0.02769791f, -0.01009548f, -0.02548709f, 0.00440533f, -0.00503359f, -0.05179694f, 
    -0.03883148f, 0.01035147f, 0.00339868f, -0.03644499f, 0.01622068f, 0.01735981f, -0.00193278f, 0.02598419f, 
    0.04235093f, 0.03774847f, 0.00729113f, -0.00161750f, 0.04099165f, -0.03761039f, -0.02552813f, -0.00270948f, 
    -0.00159547f, 0.02064180f, -0.01422450f, 0.00139480f, 0.02412737f, -0.00656612f, -0.00222457f, -0.02322680f, 
    0.00372867f, -0.00159942f, -0.03715337f, 0.02163335f, -0.04020725f, -0.02701206f, -0.00944402f, 0.00335625f, 
    0.04057571f, 0.04037452f, 0.04495126f, -0.00058996f, -0.04179268f, -0.05373792f, 0.04290246f, 0.02677510f, 
    0.02607126f, -0.05143750f, -0.04126291f, 0.00361284f, -0.01345535f, -0.04127169f, -0.02794290f, 0.03039646f, 
    0.02216700f, -0.00454256f, 0.02893286f, 0.02141541f, -0.03989449f, 0.00941522f, -0.02021172f, 0.01350001f, 
    0.02783091f, 0.04408598f, 0.04214277f, -0.04628752f, 0.03077360f, 0.02897097f, 0.04401920f, -0.01112664f, 
    -0.03526908f, -0.04282493f, -0.04631064f, -0.02579106f, -0.05574878f, 0.04034695f, 0.00399453f, 0.04048442f, 
    -0.02601727f, 0.02673350f, -0.00868443f, -0.01905034f, 0.00185373f, 0.03438294f, -0.02740440f, -0.02934430f, 
    -0.00279191f, -0.05266036f, -0.01281652f, -0.04961084f, 0.00930522f, -0.02137575f, -0.03664352f, -0.05274933f, 
    -0.01889503f, -0.03996795f, -0.01862637f, 0.02260043f, 0.03058625f, -0.02755125f, 0.02245335f, 0.03272915f, 
    -0.00846358f, 0.01692241f, -0.04217465f, 0.04289656f, -0.04593294f, -0.01037244f, -0.02255422f, -0.04454331f, 
    -0.00078737f, -0.02034347f, 0.02928578f, 0.00769992f, 0.00239112f, 0.02425251f, -0.03384494f, 0.00675369f, 
    -0.05487056f, 0.00962448f, -0.02109995f, -0.00343948f, -0.04567122f, -0.04018497f, -0.02333767f, 0.02911432f, 
    0.00726853f, -0.05377315f, 0.00243358f, 0.01637998f, -0.01528178f, -0.01021469f, 0.02249979f, -0.02774913f, 
    -0.02389737f, -0.05486654f, -0.00793800f, -0.05158387f, -0.04010270f, 0.01346894f, 0.02320885f, -0.00486704f, 
    0.00124844f, 0.01758428f, -0.02975246f, 0.02853974f, 0.02622293f, -0.00462891f, -0.04774062f, 0.02156857f, 
    0.03491359f, 0.03979030f, -0.04447775f, 0.03111725f, 0.01521014f, -0.04255613f, 0.01238068f, 0.02043561f, 
    -0.01806970f, 0.00301163f, 0.01986533f, 0.00750310f, 0.03797598f, 0.04158199f, -0.01404800f, -0.05472497f, 
    -0.01210617f, -0.03236385f, 0.01573323f, -0.03496595f, -0.01588974f, 0.02508654f, 0.00835781f, -0.00404022f, 
    0.00198968f, -0.03722821f, -0.05155010f, -0.01293715f, 0.02358289f, 0.03532958f, -0.02055513f, -0.03674687f, 
    -0.01634699f, -0.04072893f, -0.01722501f, 0.03085376f, 0.04216914f, -0.05366348f, -0.05077353f, -0.02859305f, 
    -0.04887883f, -0.05115547f, -0.00112033f, 0.02511125f, -0.02609976f, -0.02534878f, -0.00940693f, 0.00786466f, 
    -0.01104128f, 0.03282564f, -0.03865268f, -0.04661546f, 0.03114841f, 0.01516001f, 0.04260680f, -0.04412169f, 
    0.00300185f, -0.00376277f, 0.02426312f, 0.02997275f, -0.03114214f, -0.02316543f, -0.04332630f, -0.04617409f, 
    0.00477257f, 0.02217070f, 0.01424031f, -0.00409932f, 0.02654404f, -0.03489115f, -0.05245369f, -0.03993442f, 
    -0.05168673f, -0.00206020f, -0.05481369f, -0.01122410f, -0.00960499f, -0.04291420f, -0.03501213f, -0.03342762f, 
    0.01169221f, 0.02149667f, -0.01983586f, 0.02796265f, -0.02775963f, -0.05392837f, -0.01894169f, -0.02739623f, 
    -0.04436818f, -0.03896661f, -0.03597391f, -0.02771086f, -0.01071225f, 0.03209025f, 0.02039193f, 0.02267774f, 
    0.02862426f, 0.03740963f, -0.00827378f, -0.01462484f, -0.00559702f, 0.01969582f, -0.05601081f, 0.01489491f, 
    0.00621832f, -0.04590232f, -0.00015404f, 0.02426808f, -0.02972894f, 0.03605281f, 0.01335854f, -0.00336826f, 
    -0.02217891f, 0.01775019f, -0.00261766f, -0.02510536f, -0.03710985f, -0.03864764f, 0.01501669f, -0.01038664f, 
    -0.01090104f, 0.00413451f, -0.04666496f, 0.00515638f, 0.01678075f, -0.02922306f, 0.01876480f, -0.02174261f, 
    -0.04864383f, 0.03301760f, -0.02711455f, -0.00071598f, 0.02992857f, 0.01058322f, -0.03885005f, 0.01348026f, 
    -0.03129835f, -0.03204395f, -0.05265529f, -0.05251416f, -0.04078485f, 0.03201814f, -0.00017962f, 0.03141351f, 
    -0.02784734f, 0.02263096f, -0.02022969f, 0.01031547f, 0.02246565f, 0.01502922f, -0.05339306f, 0.03546636f, 
    -0.02907135f, 0.04200539f, 0.00752461f, -0.02294290f, -0.01463795f, -0.03376771f, 0.03063515f, 0.03227631f, 
    -0.01090299f, -0.02603041f, 0.02552692f, -0.02254684f, 0.02330516f, -0.03111884f, -0.01754798f, 0.01672858f, 
    -0.03452508f, -0.04865704f, 0.02074935f, -0.03288673f, -0.04424309f, 0.01694667f, -0.01139850f, -0.03706024f, 
    0.02981584f, -0.00012408f, -0.03990993f, -0.03244087f, 0.03213152f, -0.03074723f, -0.02087721f, -0.05078202f, 
    -0.02044327f, -0.02988412f, -0.04460417f, 0.00190154f, -0.02867956f, 0.04108475f, -0.04149158f, -0.03246775f, 
    -0.04415558f, -0.05493698f, 0.04318552f, -0.00989745f, 0.04251311f, 0.04675589f, 0.02866056f, -0.01886514f, 
    0.02894535f, 0.03375921f, -0.03819694f, -0.00643059f, 0.00748722f, -0.05056904f, 0.01944930f, 0.01388660f, 
    -0.05254208f, 0.00116097f, 0.01652350f, -0.02248444f, 0.01082590f, 0.00324074f, 0.03617981f, 0.00715682f, 
    0.01983749f, -0.02549884f, -0.02224220f, 0.01072891f, -0.00201785f, -0.02341256f, -0.02739744f, 0.02245595f, 
    0.03769008f, 0.02494480f, -0.03490982f, -0.02120550f, 0.04286411f, 0.03994280f, -0.00489723f, 0.02066288f, 
    0.01173243f, -0.02718901f, 0.02623045f, 0.02205029f, -0.00888295f, -0.00904110f, 0.01637353f, -0.02707729f, 
    0.03322977f, -0.00710930f, 0.01024278f, -0.05343070f, -0.04086182f, -0.03199652f, 0.00167807f, -0.04088285f, 
    -0.05535427f, -0.00357045f, 0.03949522f, -0.02918049f, 0.02534545f, 0.02982224f, -0.04642829f, -0.02142895f, 
    0.00233521f, 0.02227590f, 0.01302113f, -0.03394321f, -0.04558183f, -0.03353098f, 0.02660346f, -0.04368278f, 
    -0.01773000f, -0.04802785f, 0.00688294f, -0.05043774f, -0.05233426f, 0.03039858f, -0.00716334f, 0.00806108f, 
    -0.02535117f, -0.01028227f, -0.05225161f, -0.01106072f, -0.01184781f, 0.04205854f, 0.04145784f, -0.00863811f, 
    -0.01584818f, -0.03595088f, 0.02562032f, 0.00379101f, -0.04059462f, -0.02863793f, -0.00860428f, 0.04323791f, 
    0.02666733f, -0.01873163f, -0.02846050f, -0.04984453f, 0.03697736f, -0.01747006f, -0.04939215f, -0.01753654f, 
    0.00339422f, -0.02035814f, 0.00836712f, -0.04740188f, -0.01088400f, -0.02985755f, -0.03244242f, -0.05217991f, 
    -0.04538212f, -0.02036699f, 0.02027483f, -0.05504743f, 0.01367790f, -0.00410636f, 0.01533893f, 0.00432025f, 
    -0.03423895f, -0.04977838f, -0.02775453f, 0.04119274f, 0.03949077f, -0.02922473f, -0.02075726f, -0.02740551f, 
    -0.05387356f, 0.03421679f, 0.02854319f, -0.00778974f, -0.03386186f, -0.00580796f, 0.01228388f, 0.00976466f, 
    0.03734808f, -0.02020231f, 0.00018252f, 0.02716777f, 0.01390096f, -0.00334913f, -0.02732904f, -0.03419442f, 
    -0.00168433f, -0.02713254f, -0.00018067f, 0.00541338f, -0.04206310f, -0.04387723f, 0.02518003f, 0.01320463f, 
    -0.03965215f, 0.03658812f, -0.01586048f, 0.00068393f, 0.01465648f, 0.01112016f, -0.02723538f, -0.04775825f, 
    -0.01962427f, 0.00781703f, -0.03421854f, 0.01067770f, 0.01949563f, -0.00277069f, -0.04816999f, 0.04249852f, 
    -0.01697831f, -0.00705682f, -0.00198421f, 0.01559845f, 0.04444060f, 0.00973995f, 0.02066186f, 0.02319301f, 
    0.01122313f, -0.04817719f, 0.00204407f, -0.00893195f, -0.03071404f, -0.02931811f, 0.03731602f, -0.04789288f, 
    0.04076155f, -0.02287069f, -0.04479358f, 0.03191163f, -0.02651269f, 0.04514522f, 0.00493771f, 0.01148693f, 
    -0.04819798f, 0.01637972f, -0.02244652f, -0.03871918f, -0.03556953f, -0.03061574f, -0.01703846f, -0.00842548f, 
    -0.04330083f, 0.02738319f, -0.04733479f, -0.02655548f, 0.03747783f, -0.02885604f, 0.04426268f, -0.01699749f, 
    0.04057818f, -0.02533784f, -0.04130396f, 0.00684068f, -0.03614651f, 0.00932734f, -0.01627359f, 0.01677699f, 
    -0.01259556f, -0.03712796f, -0.01598372f, -0.04540740f, -0.03804760f, 0.02108323f, 0.03352262f, -0.01592122f, 
    -0.01963083f, -0.04257257f, -0.03508695f, 0.04304674f, 0.02893436f, 0.03520934f, -0.00336203f, 0.00045233f, 
    -0.02504759f, -0.05062969f, -0.01327171f, -0.00721479f, -0.04852995f, -0.05355927f, -0.04770535f, 0.00656084f, 
    0.03165055f, -0.01235540f, 0.00437355f, 0.02765387f, -0.02798669f, 0.00752148f, 0.03653473f, 0.00886487f, 
    -0.01855149f, -0.03598925f, -0.02195239f, -0.05108556f, -0.04216628f, 0.03877460f, -0.02375409f, -0.04764812f, 
    0.03716389f, -0.02686915f, -0.00723215f, 0.03776158f, -0.02326250f, -0.04430271f, -0.00893845f, -0.01031155f, 
    -0.02303857f, 0.02297481f, -0.00050095f, -0.02214718f, -0.03121749f, -0.03011623f, 0.03767782f, 0.02685025f, 
    -0.04677984f, -0.00118700f, 0.01642397f, -0.04649155f, 0.03975588f, 0.01264082f, -0.02172664f, -0.02868452f, 
    -0.04710126f, 0.02728632f, -0.04817882f, 0.00197125f, 0.00364398f, -0.03430787f, -0.05214171f, -0.04629536f, 
    -0.02113667f, -0.00619419f, -0.04830719f, 0.02141568f, 0.01251839f, -0.02664977f, -0.03910381f, 0.00128610f, 
    -0.00874824f, -0.03938998f, -0.04916702f, -0.02307195f, -0.03190847f, 0.02354824f, -0.03766119f, 0.02937413f, 
    0.02502831f, 0.01741453f, -0.01325680f, -0.05188164f, 0.00679936f, -0.00350237f, -0.01205206f, 0.02536817f, 
    -0.01589530f, -0.01441592f, -0.03170706f, 0.02125035f, -0.01403164f, 0.01987288f, -0.04242003f, -0.00886976f, 
    0.03027792f, 0.04376354f, 0.00003055f, 0.00222555f, -0.00635295f, -0.01229441f, -0.01388260f, 0.01185644f, 
    0.02184034f, 0.02226737f, 0.01010644f, 0.03869693f, 0.03503172f, -0.05444372f, -0.00104153f, 0.04125589f, 
    0.00295492f, 0.04440907f, -0.03219469f, -0.03503159f, 0.03528234f, -0.04363957f, -0.01449899f, 0.01185438f, 
    0.02235125f, -0.02780997f, -0.03179000f, -0.02569601f, 0.00558431f, 0.04085284f, -0.02270099f, -0.00500239f, 
    -0.04862380f, 0.02245137f, -0.01082164f, -0.01085645f, 0.00690370f, -0.00394462f, -0.01897288f, 0.03313177f, 
    -0.03449425f, -0.05112993f, 0.02522088f, -0.05013435f, -0.05869434f, -0.07387049f, -0.01305365f, 0.01220301f, 
    0.01102243f, -0.00050093f, 0.02142021f, -0.05423119f, -0.04745409f, 0.00756551f, -0.02131736f, -0.04272787f, 
    0.01955802f, 0.03676290f, -0.03219736f, 0.01171221f, -0.06379513f, -0.02425373f, -0.01183537f, -0.03182643f, 
    0.02725101f, 0.02351701f, 0.03368750f, -0.07447268f, -0.01192256f, 0.03117756f, -0.02363039f, -0.05529610f, 
    -0.01741875f, 0.00936032f, -0.03298499f, 0.01130761f, -0.01785564f, 0.02057970f, -0.01235642f, -0.03815556f, 
    -0.02992870f, -0.01927279f, -0.01160237f, 0.03025443f, -0.00776172f, -0.05298893f, 0.03657066f, -0.02062663f, 
    0.02713538f, -0.01921675f, -0.06819144f, -0.00833809f, 0.02575918f, -0.07112494f, 0.01320196f, -0.05529693f, 
    -0.06292132f, -0.04862437f, -0.05064125f, 0.04434900f, -0.00310031f, -0.03780073f, 0.02724282f, -0.01838519f, 
    0.02422477f, 0.00316121f, 0.00794195f, 0.01072090f, 0.02085169f, 0.02844201f, 0.01413750f, 0.00705279f, 
    -0.02084766f, -0.02071144f, -0.01390778f, -0.01780655f, -0.03335714f, -0.01118242f, -0.08713740f, -0.05302997f, 
    -0.04896499f, -0.01289310f, -0.01121806f, 0.00582329f, -0.03923267f, -0.01797879f, 0.02893733f, 0.00786934f, 
    0.01154026f, -0.01850920f, 0.00337787f, 0.00108759f, -0.02696300f, 0.00539119f, -0.04207190f, -0.05329428f, 
    -0.04024526f, 0.00817726f, -0.01078889f, 0.04921062f, -0.06790113f, 0.01437457f, 0.01403295f, 0.01984177f, 
    -0.00483991f, -0.03150609f, -0.02545329f, 0.01817626f, -0.01368697f, -0.00657615f, -0.00836739f, -0.05462174f, 
    -0.02581750f, 0.02233797f, -0.05849443f, 0.01762019f, 0.01002998f, 0.00120718f, 0.03184215f, -0.03223647f, 
    -0.02146183f, -0.00534482f, -0.02106055f, -0.01653151f, -0.02782489f, -0.02464632f, -0.01762159f, -0.00772505f, 
    -0.01158316f, 0.00055377f, -0.03149793f, -0.00103940f, -0.05190163f, -0.06232547f, -0.03925208f, -0.03766564f, 
    -0.01717267f, -0.02616716f, -0.01734245f, -0.05217169f, -0.02354891f, 0.02108199f, -0.02861926f, 0.03384399f, 
    -0.05539819f, 0.01187255f, -0.00274726f, 0.03240769f, 0.02419636f, 0.00644508f, -0.01172425f, 0.02847942f, 
    -0.01373900f, -0.03698814f, -0.01213517f, 0.03686216f, 0.01463730f, -0.04101630f, -0.02239525f, 0.03706362f, 
    0.01796315f, -0.01570440f, 0.00702821f, 0.03256862f, -0.02108625f, -0.03485749f, -0.04518763f, -0.05998931f, 
    -0.03475333f, -0.05576211f, -0.03098908f, -0.00443065f, 0.00527452f, 0.00308195f, -0.05820744f, -0.05562414f, 
    -0.05574038f, 0.01466446f, -0.05400150f, -0.03101132f, -0.02842346f, -0.00660894f, 0.02818945f, -0.05486916f, 
    -0.00179610f, 0.03441452f, 0.03598279f, -0.06181343f, -0.03721710f, 0.04423864f, 0.02850746f, -0.01832031f, 
    -0.03277738f, -0.05161057f, -0.05294659f, 0.02662724f, -0.04279269f, -0.03114403f, -0.04625071f, 0.00912954f, 
    -0.02001593f, -0.05813532f, 0.02387010f, -0.02655071f, -0.03858192f, -0.05921499f, 0.00796470f, -0.04944202f, 
    -0.03592103f, 0.02430274f, 0.01063100f, 0.00780372f, 0.04081930f, -0.06618776f, 0.03491439f, -0.01400976f, 
    -0.01068187f, 0.01698773f, 0.01544601f, -0.06448211f, -0.05385607f, 0.04319897f, 0.01967286f, 0.04257840f, 
    -0.02811193f, -0.02462171f, -0.00554198f, -0.01030305f, 0.02798345f, 0.01112891f, -0.01313111f, 0.02905140f, 
    -0.04832337f, -0.02133594f, 0.02217007f, 0.01268970f, -0.05981720f, -0.03908331f, -0.02553437f, -0.04612444f, 
    -0.02850103f, -0.01959364f, 0.00229487f, -0.04843584f, -0.06556139f, -0.03563019f, -0.08201230f, -0.04917172f, 
    0.00473427f, 0.01155506f, 0.01997504f, 0.01205472f, -0.03215244f, -0.06634890f, 0.02376488f, 0.03745241f, 
    -0.00337498f, 0.01568329f, 0.03619604f, 0.03511105f, 0.00819996f, -0.00610562f, -0.01504199f, 0.01849107f, 
    -0.04519137f, 0.01440935f, -0.04235339f, 0.02557613f, -0.00473406f, -0.07246746f, -0.02243190f, 0.01974818f, 
    -0.03323209f, -0.03983427f, -0.01573475f, -0.04849920f, -0.03094404f, 0.02698645f, 0.03208118f, -0.03026493f, 
    -0.02593111f, 0.00755279f, -0.00029111f, 0.00177057f, 0.03128199f, 0.00767994f, 0.02476333f, 0.02035087f, 
    0.01836777f, -0.01196297f, -0.02061338f, -0.00636968f, 0.05827181f, -0.02775457f, -0.03801024f, -0.01077659f, 
    -0.01129507f, -0.01090231f, -0.02852662f, -0.03332741f, 0.01059012f, 0.03793107f, -0.03949524f, -0.04874338f, 
    -0.02012633f, 0.03602830f, 0.06491287f, 0.00828441f, 0.00963294f, 0.02704867f, 0.04362462f, -0.01279608f, 
    0.00069564f, -0.00994280f, 0.02435011f, 0.02580091f, -0.01362738f, 0.01266796f, 0.03813494f, -0.00184980f, 
    -0.06198278f, 0.01839866f, -0.02746409f, -0.00781388f, 0.02712677f, -0.02166002f, -0.02554912f, -0.00300598f, 
    -0.04211616f, 0.04303891f, -0.02010087f, 0.02169684f, -0.04686065f, 0.02849263f, 0.01027681f, 0.01584585f, 
    -0.02264141f, 0.00515095f, 0.02136144f, -0.05442326f, 0.00819055f, -0.03842023f, -0.03294263f, -0.01402719f, 
    -0.00915501f, 0.03385143f, -0.03672871f, 0.01302913f, 0.01111524f, 0.02101438f, -0.04508439f, 0.01916284f, 
    0.00523846f, -0.04061324f, -0.03989759f, -0.00656946f, 0.00967858f, -0.00003172f, 0.00695759f, 0.02447108f, 
    -0.05195049f, 0.03188867f, 0.01728569f, -0.03083068f, 0.01077024f, 0.02509267f, 0.02010421f, -0.04481091f, 
    -0.02741301f, 0.04473847f, -0.05945832f, 0.02546103f, -0.04171366f, 0.02893546f, -0.02837762f, 0.00900377f, 
    0.26861665f, 0.07373016f, -0.22679918f, -0.04388950f, -0.04907575f, 0.06219570f, -0.11297441f, 0.04829066f, 
    0.04529513f, -0.07398007f, -0.08150089f, 0.03828263f, -0.21654035f, 0.07260528f, 0.22389738f, -0.07843141f, 
    -0.07310947f, 0.09547641f, 0.03959445f, 0.06023575f, 0.05643557f, 0.09630483f, 0.04656104f, 0.04448882f, 
    0.16914190f, -0.07706569f, 0.12213360f, -0.06769906f, 0.07719136f, 0.08512048f, 0.04295140f, 0.09808448f, 
    -0.04449094f, 0.06338829f, 0.00028125f, 0.05317878f, 0.07817508f, -0.09850293f, -0.22143011f, -0.09957914f, 
    -0.00324305f, -0.05382364f, 0.01116758f, 0.14211716f, -0.01278718f, 0.00828554f, -0.04334815f, -0.01284759f, 
    0.12146704f, 0.00089817f, 0.14385265f, -0.00956104f, -0.00894190f, -0.10773879f, -0.00725236f, 0.10189895f, 
    -0.00040808f, -0.09012622f, -0.01848525f, -0.01108561f, 0.00754379f, 0.00057988f, -0.13518059f, -0.08752156f, 
    -0.00470445f, -0.02611711f, 0.00002008f, 0.11591648f, 0.05506542f, -0.05758835f, 0.02201374f, 0.09786119f, 
    -0.11600398f, 0.01383006f, -0.08190020f, -0.08275622f, -0.02343555f, -0.09800161f, 0.00561120f, 0.04843347f, 
    -0.12841453f, -0.02751765f, -0.07809854f, -0.00480771f, -0.16438390f, 0.03927162f, 0.13333929f, -0.10312615f, 
    -0.07761407f, 0.11764795f, 0.00807666f, 0.05929525f, -0.06084728f, 0.03424158f, 0.02185870f, 0.02178833f, 
    -0.04303252f, 0.22660178f, 0.07721556f, 0.03246937f, -0.08336347f, -0.04662352f, -0.01861565f, 0.00789196f, 
    0.04064460f, -0.06400727f, 0.02920225f, 0.10757608f, 0.03343977f, -0.15193358f, 0.08776589f, -0.18339549f, 
    0.05640617f, 0.05056524f, 0.02397231f, 0.05536673f, 0.04717557f, -0.06542322f, 0.10476930f, -0.01482433f, 
    -0.25707927f, -0.16109256f, 0.10503821f, -0.17125724f, 0.08471272f, 0.08918772f, -0.00613613f, 0.06599747f, 
    -0.03781647f, -0.02832546f, 0.03395379f, 0.06412754f, -0.26513225f, 0.23320039f, -0.03018276f, 0.29515824f, 
    0.00615728f, 0.03147457f, 0.03397157f, 0.03240648f, -0.02571676f, 0.03278663f, 0.15198582f, -0.03005675f, 
    -0.13644154f, -0.04621209f, 0.19294877f, 0.00136312f, -0.03027128f, -0.07212717f, 0.01112229f, 0.03011572f, 
    0.02610985f, 0.04590489f, 0.16185318f, -0.04927584f, 0.20459302f, -0.01098013f, 0.07583380f, 0.09868085f, 
    -0.02711806f, -0.00275252f, 0.09258671f, 0.09856296f, 0.00329267f, -0.02845508f, 0.06588443f, 0.11901587f, 
    -0.11055707f, -0.14325766f, -0.11020362f, 0.02830693f, 0.00659916f, -0.11444331f, 0.10027962f, -0.05445675f, 
    0.00797023f, 0.12105168f, 0.14515962f, 0.06274832f, 0.06674479f, 0.01286198f, 0.12158822f, 0.08799527f, 
    0.05110497f, 0.08564711f, 0.02042462f, -0.00587912f, 0.13099812f, 0.00808690f, -0.01790309f, 0.06571353f, 
    -0.18107851f, -0.06799844f, 0.45393217f, 0.04661093f, 0.03890458f, -0.01861818f, 0.04829258f, 0.03736940f, 
    -0.02696728f, -0.05441333f, -0.09749984f, 0.12621428f, 0.06636512f, 0.07791524f, -0.01147580f, 0.00907739f, 
    -0.03074173f, 0.00168037f, 0.04488911f, 0.09717066f, 0.12782477f, -0.01824239f, 0.05173940f, -0.00347547f, 
    0.07304941f, 0.05455448f, 0.10800628f, 0.01055433f, 0.10433890f, 0.13130024f, 0.02941152f, -0.00597438f, 
    0.10030536f, 0.05566218f, 0.10712922f, 0.14082330f, 0.11552665f, 0.11382679f, 0.12784180f, -0.11402061f, 
    0.04449084f, 0.02602387f, 0.11356481f, 0.08818085f, 0.02967508f, 0.03280801f, 0.11397621f, 0.02679623f, 
    -0.03411216f, -0.01151971f, 0.02452354f, -0.07936696f, -0.02444253f, 0.09191249f, 0.02916184f, 0.04010792f, 
    -0.00134482f, -0.04508271f, 0.05549655f, 0.06436076f, -0.08908484f, 0.03296554f, 0.07315778f, -0.08967746f, 
    0.03148263f, 0.04498519f, 0.05670656f, 0.04669078f, 0.09706989f, 0.06424426f, -0.03034987f, 0.11697666f, 
    0.22496021f, 0.00372908f, -0.10083961f, -0.29257509f, -0.02149085f, -0.07081927f, -0.05419076f, 0.05119925f, 
    0.03220214f, 0.02888934f, -0.08344115f, 0.10928506f, 0.03492171f, -0.00041275f, -0.02137387f, -0.11575968f, 
    0.01937840f, 0.00451911f, 0.01026607f, 0.03129879f, -0.02601095f, -0.01407784f, 0.05780832f, 0.00585089f, 
    0.12268257f, -0.18930735f, 0.32746193f, -0.26832363f, -0.05687687f, -0.07212853f, 0.23886780f, -0.04707523f, 
    -0.05644037f, 0.01561833f, -0.11926344f, -0.14223585f, -0.10063931f, 0.33579820f, -0.08168423f, -0.03026341f, 
    0.17932686f, 0.03770398f, 0.05219929f, 0.08196212f, -0.01658743f, -0.02773846f, 0.07389409f, -0.06563127f, 
    -0.01063887f, -0.12766764f, -0.25236973f, 0.00001746f, -0.06955722f, -0.06505800f, -0.06320512f, -0.03928324f, 
    -0.02349410f, 0.00651018f, 0.00110982f, -0.01255867f, 0.10247417f, 0.08447685f, -0.20624666f, -0.06184196f, 
    -0.04580767f, 0.16588061f, 0.01019463f, 0.05708440f, -0.01706801f, 0.03938180f, 0.07172617f, -0.03797324f, 
    0.12299355f, -0.15915377f, -0.09314996f, -0.14066535f, 0.13299190f, 0.04773248f, 0.11066914f, -0.01923094f, 
    -0.09495295f, -0.08079781f, 0.01570459f, 0.01422101f, 0.15987003f, 0.20468876f, 0.14819710f, -0.22101982f, 
    -0.01477913f, -0.00661224f, 0.07121368f, 0.01410914f, 0.09337069f, -0.00387971f, -0.07409567f, 0.01110325f, 
    -0.13431887f, -0.18110211f, -0.02542478f, -0.02881597f, -0.05097067f, -0.00016783f, 0.04131152f, 0.08861256f, 
    -0.01462852f, 0.06429923f, 0.15426300f, 0.07746252f, 0.10788672f, 0.12440881f, -0.00155097f, -0.05066113f, 
    0.00450585f, 0.03683694f, 0.03466596f, -0.00805710f, 0.09516082f, 0.08302449f, -0.03724974f, -0.04239115f, 
    0.09773007f, -0.04709154f, 0.07504161f, 0.13381097f, -0.03878398f, -0.01834935f, 0.20310737f, 0.07069478f, 
    -0.04991638f, -0.00486165f, 0.04431910f, 0.16299875f, 0.03462127f, 0.09712990f, -0.09651885f, -0.09087656f, 
    -0.01764116f, 0.00613343f, -0.08081663f, 0.07871366f, 0.12127936f, 0.02179519f, 0.06262817f, -0.04579254f, 
    -0.02698174f, 0.01577473f, 0.07786862f, 0.20136470f, 0.03204649f, 0.00852316f, 0.02677357f, 0.03813412f, 
    0.04018396f, 0.03297857f, -0.16997589f, -0.02088529f, 0.06865656f, 0.00551239f, 0.06802282f, 0.15425463f, 
    -0.02265843f, 0.09243797f, 0.02641931f, 0.12605509f, 0.08283957f, 0.25344029f, -0.00054999f, -0.04234317f, 
    0.00056465f, 0.01723460f, 0.10999840f, 0.06211907f, 0.01114919f, 0.02083067f, 0.03504829f, -0.06439362f, 
    0.06397903f, 0.16252787f, 0.21256594f, 0.15055583f, -0.23910989f, 0.10729779f, 0.02780592f, 0.08949766f, 
    0.05386253f, -0.06871805f, 0.00571577f, 0.03080817f, -0.07089695f, 0.01772640f, -0.04418191f, -0.10062789f, 
    0.05587274f, 0.14257286f, -0.18119481f, 0.09064607f, 0.02669802f, 0.03589133f, 0.04183966f, 0.07013208f, 
    0.15260023f, -0.17824876f, 0.09272278f, -0.08941613f, 0.08230681f, -0.09437194f, -0.00410828f, -0.07283875f, 
    0.05426873f, -0.01971008f, 0.04135717f, -0.09154394f, 0.05629994f, -0.00407640f, 0.04887558f, 0.00379958f, 
    -0.09213573f, -0.12695502f, 0.10764325f, -0.00968682f, 0.03700539f, 0.05145822f, -0.08385012f, 0.01734427f, 
    0.10846119f, -0.01477748f, 0.13108779f, -0.02144656f, -0.22107738f, 0.10688896f, -0.13386668f, 0.09637595f, 
    0.02537918f, 0.07353505f, -0.03179218f, 0.10488962f, -0.03645500f, 0.15960988f, 0.19291396f, -0.02844413f, 
    0.16074194f, 0.16177130f, 0.10439020f, -0.08729056f, 0.15110376f, 0.00523709f, -0.06615495f, 0.02228006f, 
    0.03376533f, -0.12316542f, 0.05956519f, 0.01859786f, 0.05818421f, -0.04344188f, 0.07930215f, -0.19649677f, 
    0.01965171f, 0.09330182f, -0.00855310f, 0.05060693f, 0.02513682f, 0.03978398f, -0.01803943f, 0.20222022f, 
    0.29079333f, -0.16705586f, -0.13837180f, -0.26006231f, -0.04843013f, -0.02007213f, -0.09048101f, -0.06660639f, 
    0.05613367f, -0.01531429f, 0.09347972f, -0.08141626f, -0.07767521f, 0.13576880f, 0.06839448f, 0.11237846f, 
    0.10866165f, -0.03360970f, 0.04179505f, -0.07274015f, 0.06047649f, 0.00311690f, -0.10524129f, -0.04198015f, 
    -0.20410290f, 0.22434627f, -0.02033850f, 0.07621660f, -0.01759841f, 0.05247044f, 0.03769546f, 0.01025563f, 
    -0.08212598f, -0.04627327f, -0.12461094f, -0.00322146f, -0.24947053f, -0.00894566f, 0.02805360f, -0.09690866f, 
    -0.00354915f, -0.05825631f, 0.06498103f, -0.01627780f, 0.05127515f, 0.01987812f, -0.02820939f, 0.15036574f, 
    -0.10284294f, 0.16328132f, 0.07512485f, -0.11220793f, -0.03449571f, 0.00261998f, -0.00278705f, -0.12399718f, 
    0.04948736f, -0.02837836f, 0.05632653f, 0.02362830f, -0.14643697f, 0.11223578f, 0.20471679f, 0.01183064f, 
    0.07873028f, 0.06100298f, 0.13603482f, 0.12856749f, -0.07165708f, 0.16346754f, 0.03009218f, 0.11743034f, 
    -0.22208184f, -0.05921130f, -0.08036175f, -0.03761657f, 0.17320195f, -0.07104655f, 0.02293374f, 0.09907473f, 
    0.00485343f, 0.10318838f, 0.09567486f, 0.05398869f, -0.19674797f, 0.01700032f, 0.03146488f, 0.16777724f, 
    0.04173089f, -0.04353729f, 0.03726481f, -0.13139968f, -0.06798891f, 0.05778863f, 0.12150641f, -0.02416695f, 
    -0.03216908f, -0.12237015f, 0.13069955f, 0.06585985f, -0.01843249f, -0.04894302f, 0.06730390f, 0.00313139f, 
    0.09367574f, -0.01978850f, -0.09766637f, 0.00887429f, -0.22947958f, -0.08123741f, -0.17375450f, -0.03354553f, 
    0.07565699f, 0.06198477f, 0.03783486f, 0.09506053f, -0.01182809f, 0.14647292f, -0.02321875f, -0.02966299f, 
    0.06299277f, 0.00987361f, 0.13033117f, 0.04376324f, 0.07920638f, 0.00454533f, -0.06126677f, 0.04253891f, 
    0.00626548f, 0.01023419f, -0.03082585f, 0.08940560f, 0.02498366f, 0.13461326f, -0.32067585f, -0.03619188f, 
    0.09890726f, 0.02562178f, 0.06909987f, -0.00657538f, -0.01418552f, -0.09026901f, -0.06793175f, -0.10761508f, 
    0.42548433f, -0.04096494f, 0.07989358f, 0.05904258f, -0.01910739f, 0.04882526f, 0.15708648f, 0.17761363f, 
    0.00565058f, -0.00964621f, 0.02032420f, 0.04034379f, 0.03849765f, -0.22309658f, 0.25543961f, 0.11521447f, 
    -0.04452582f, 0.06266861f, -0.04476493f, -0.01597112f, -0.10392275f, 0.05481225f, 0.02039105f, 0.00063428f, 
    -0.35132504f, 0.03337682f, 0.11946958f, 0.05391333f, 0.04004690f, 0.04690212f, -0.05313962f, -0.02636766f, 
    0.08074195f, -0.03734936f, 0.05927243f, 0.00416686f, -0.11401894f, -0.01297245f, 0.07002327f, 0.19736621f, 
    0.20531979f, 0.06497666f, -0.06108015f, 0.18131153f, 0.03617118f, -0.00238833f, -0.04325444f, -0.14525720f, 
    -0.07219394f, 0.27160549f, 0.15415484f, 0.09815310f, -0.02179633f, 0.17129353f, 0.08442344f, 0.11578643f, 
    -0.07082306f, 0.05579485f, 0.20476131f, 0.12621664f, -0.01984600f, -0.09326259f, -0.01702906f, -0.15217534f, 
    -0.04007622f, -0.11199322f, -0.07240945f, 0.05978832f, 0.05598818f, 0.03543640f, 0.07907318f, -0.11317895f, 
    0.23833974f, 0.06630512f, 0.00229946f, 0.05751748f, -0.05089963f, -0.10204392f, 0.04893494f, -0.06156524f, 
    0.04032798f, -0.16172323f, 0.10529456f, -0.04351062f, -0.26164228f, 0.11389769f, 0.01446200f, 0.23392600f, 
    -0.09509072f, -0.02324291f, 0.03974728f, 0.03361855f, -0.06984340f, -0.00883338f, 0.17092501f, -0.05751109f, 
    0.01886361f, -0.00759692f, 0.01778869f, -0.00656207f, 0.04195930f, -0.01768302f, -0.00678500f, 0.03089214f, 
    -0.04688081f, 0.03155607f, 0.02817970f, 0.02727851f, -0.03119262f, 0.03098635f, -0.00027120f, 0.00218911f, 
    -0.00218542f, 0.00115059f, 0.03723421f, -0.05006556f, 0.05003671f, 0.00768021f, -0.01209932f, -0.02372282f, 
    -0.02472882f, 0.01461035f, 0.04486230f, -0.05112282f, -0.01640927f, -0.04572019f, -0.03727336f, 0.03181939f, 
    0.03368369f, 0.00013169f, -0.01497075f, -0.05345789f, -0.05489095f, -0.04329401f, 0.01342880f, 0.00809857f, 
    -0.00742793f, 0.04070168f, 0.01015950f, -0.00974512f, -0.03411048f, 0.03310376f, 0.03670977f, -0.02152876f, 
    0.00733687f, 0.04238930f, 0.04058129f, 0.02257247f, 0.02403439f, -0.03510915f, -0.01835390f, 0.01777453f, 
    -0.05815470f, -0.03667874f, 0.01261225f, -0.05329214f, 0.02290540f, -0.01251508f, 0.01977896f, -0.03614759f, 
    0.02363504f, 0.00143488f, -0.01010456f, 0.03981789f, 0.00152869f, -0.02349556f, 0.00053304f, -0.00760875f, 
    -0.00135141f, -0.03406289f, -0.01193025f, 0.01630159f, -0.04746948f, -0.00281296f, -0.01146375f, 0.02189826f, 
    -0.00713763f, -0.01281410f, 0.03452097f, 0.00416458f, -0.04047704f, -0.00545237f, -0.03696622f, -0.02471937f, 
    -0.04352532f, 0.03042803f, -0.01270977f, -0.04040052f, -0.03007491f, 0.03579742f, 0.00572682f, 0.01342164f, 
    0.00934323f, 0.03564257f, 0.00465849f, -0.02012659f, -0.02369664f, -0.00282244f, -0.02276726f, 0.01521744f, 
    -0.02383731f, 0.01472149f, 0.02353812f, -0.00293373f, 0.03496703f, -0.00657219f, 0.02159293f, -0.05109461f, 
    -0.03960391f, -0.05245576f, -0.05460798f, 0.01032835f, 0.01602982f, -0.04767921f, -0.02601920f, -0.04827047f, 
    0.03915336f, -0.03447481f, -0.02844990f, 0.00131597f, 0.02916410f, -0.02637842f, -0.02647658f, -0.01646964f, 
    -0.04821105f, 0.03958074f, 0.03425372f, 0.02559102f, -0.03565805f, -0.03118399f, -0.02517783f, -0.00942663f, 
    0.01524992f, -0.05236926f, -0.03868668f, -0.00541725f, -0.01572197f, -0.04009954f, -0.04860060f, -0.05192273f, 
    -0.00565613f, 0.01275539f, -0.00289942f, -0.00668569f, -0.02743502f, -0.03984465f, -0.01715380f, 0.03465477f, 
    0.02945114f, -0.01063599f, -0.00960393f, -0.01033024f, -0.03711670f, -0.01466528f, -0.02035303f, 0.01594297f, 
    0.03830138f, -0.04080272f, -0.02180943f, -0.02814483f, 0.03716048f, 0.02160317f, -0.04002520f, 0.00814353f, 
    -0.01949625f, -0.04452465f, -0.03185273f, -0.03955518f, 0.02841990f, -0.01756108f, 0.03447038f, 0.01678286f, 
    0.00961824f, -0.02261767f, 0.01313993f, -0.03446968f, -0.01309410f, -0.01465687f, -0.01934742f, -0.01278317f, 
    0.02173274f, 0.00121404f, 0.01775267f, 0.02400224f, -0.01700605f, 0.00109171f, -0.00670040f, 0.00116861f, 
    -0.02967172f, -0.00179188f, 0.02141075f, 0.00982665f, -0.05686139f, 0.00303089f, -0.03645669f, 0.02443361f, 
    0.01540394f, 0.02494717f, -0.01750957f, -0.01680404f, -0.05111052f, 0.03998615f, -0.00026865f, 0.00611957f, 
    0.02608616f, -0.05081738f, 0.00884739f, -0.04958955f, 0.03305809f, -0.00111053f, -0.00920403f, 0.00596055f, 
    -0.01721935f, -0.04166002f, 0.00643240f, 0.00591893f, 0.00806020f, 0.02297484f, 0.01067012f, 0.02699703f, 
    -0.00630127f, -0.05123386f, -0.01950209f, -0.03616165f, 0.03029876f, -0.02161153f, 0.01636422f, 0.00237662f, 
    -0.05426087f, 0.00002931f, -0.02170023f, 0.02778382f, 0.00664283f, -0.02196816f, -0.05792441f, 0.03218363f, 
    -0.01726172f, -0.01768371f, 0.01825330f, -0.02101729f, -0.04312376f, 0.03147290f, 0.02862603f, 0.02048714f, 
    -0.01087927f, 0.01835503f, -0.01928257f, 0.02457544f, -0.04247614f, -0.04274153f, -0.01559482f, 0.04333483f, 
    -0.02017795f, -0.05112435f, 0.03036062f, -0.05645650f, 0.03039929f, 0.02938789f, 0.00787146f, -0.01666396f, 
    0.03650035f, -0.03566324f, 0.04326522f, 0.02442376f, -0.05880272f, -0.02055722f, 0.03542196f, 0.00017839f, 
    -0.00500563f, -0.01562769f, 0.03215608f, -0.04490970f, -0.01733641f, 0.00838365f, 0.00703610f, -0.02138953f, 
    -0.05578638f, -0.04507816f, -0.03601389f, -0.02820121f, -0.00904155f, -0.05429609f, -0.04733719f, -0.00700923f, 
    0.03018874f, 0.01546501f, 0.00405897f, 0.01180493f, 0.02578395f, -0.04656572f, -0.03022907f, -0.04650999f, 
    -0.04098961f, -0.04492826f, -0.00458074f, 0.01165258f, -0.00686838f, -0.05382452f, 0.04087364f, -0.04917718f, 
    0.04077718f, 0.01281667f, 0.03969715f, -0.03372660f, -0.05319150f, 0.02100518f, -0.00297871f, 0.02008406f, 
    -0.04704006f, 0.00449109f, -0.01586344f, -0.01256982f, 0.01755263f, -0.05148325f, -0.03560948f, -0.03827855f, 
    -0.03258305f, -0.05023742f, 0.04745435f, -0.00261212f, -0.01989644f, 0.03034235f, 0.01848725f, 0.03125944f, 
    -0.02132989f, 0.04039693f, -0.03632908f, -0.04891327f, 0.00593865f, -0.02689543f, 0.02947680f, 0.01103839f, 
    -0.00714563f, -0.00582439f, 0.04158024f, -0.00082246f, -0.02558379f, 0.03920508f, -0.00395803f, 0.03509152f, 
    -0.05536308f, -0.02603715f, 0.02001720f, 0.03009721f, -0.03611724f, 0.01890150f, -0.02855083f, 0.03650837f, 
    -0.04675294f, 0.00503737f, -0.01941190f, -0.04039393f, -0.02252392f, -0.00898275f, -0.04859750f, 0.01794174f, 
    -0.03281559f, -0.05441463f, 0.02696141f, 0.03760835f, -0.02736688f, -0.01307774f, -0.03029617f, -0.04184239f, 
    0.00137334f, -0.03024153f, 0.03983637f, -0.00412421f, 0.03229172f, -0.00538877f, -0.00883054f, 0.03340027f, 
    -0.02376333f, -0.02633467f, 0.02032695f, -0.05521625f, -0.03574905f, -0.00418213f, -0.03871395f, 0.01537086f, 
    0.00140756f, -0.00113578f, -0.01045894f, 0.00728657f, -0.04835616f, -0.04094560f, 0.00135963f, 0.04663284f, 
    0.03369244f, -0.03887381f, -0.04919802f, 0.03576928f, -0.00633123f, 0.01357054f, 0.04221262f, -0.04957129f, 
    0.02159345f, -0.04660764f, -0.04237648f, -0.03176088f, -0.03185851f, 0.02992168f, -0.04521761f, -0.00023485f, 
    -0.02426237f, -0.02007675f, 0.00839092f, -0.02163669f, -0.01412522f, -0.01653573f, -0.02186411f, -0.00065087f, 
    -0.00527673f, -0.02476767f, -0.00375665f, -0.04835627f, -0.02198705f, -0.04531053f, -0.03956921f, -0.03320122f, 
    -0.03212026f, 0.03002034f, -0.02707197f, -0.04608246f, -0.02283459f, 0.04676925f, -0.02998607f, 0.03568793f, 
    0.03833813f, -0.03864221f, -0.01547425f, 0.04327658f, 0.02360881f, -0.03788989f, -0.03328443f, -0.02642077f, 
    0.01338085f, -0.03551557f, 0.02190095f, -0.00374918f, 0.00143352f, -0.01211747f, -0.02644505f, -0.02695267f, 
    -0.02530966f, 0.03398661f, 0.01715689f, 0.03029197f, 0.04409100f, -0.01720683f, 0.01203389f, -0.03374728f, 
    0.01875607f, 0.00288024f, 0.01686390f, -0.00707190f, -0.02500250f, -0.03961626f, -0.00566481f, -0.02287347f, 
    -0.02847742f, -0.04790068f, 0.04114360f, 0.01633254f, -0.04608444f, 0.02531772f, -0.03544207f, -0.01394789f, 
    -0.04818016f, -0.00387427f, 0.02270021f, 0.02383587f, 0.03981297f, -0.03372171f, -0.03244342f, 0.01346249f, 
    0.03791721f, -0.02937665f, -0.03658976f, 0.03161111f, -0.04493492f, 0.01284728f, 0.02798334f, -0.00926255f, 
    0.03194971f, -0.03282348f, -0.04498716f, -0.00828253f, -0.03360691f, -0.01807825f, 0.03677009f, -0.01961367f, 
    0.01743674f, -0.00681874f, -0.03194787f, -0.00728888f, -0.02401902f, -0.01854086f, -0.02702968f, -0.04255050f, 
    -0.02163316f, -0.02449803f, -0.01930401f, -0.01371974f, -0.02689022f, 0.00679786f, 0.04316723f, 0.03308428f, 
    0.03066389f, -0.05040940f, 0.01546049f, -0.04060218f, 0.04392131f, 0.00361514f, 0.03829381f, -0.03685479f, 
    -0.01051710f, 0.00276078f, 0.00176466f, -0.04542148f, -0.04796740f, 0.04287244f, 0.04130771f, -0.01882857f, 
    0.04600568f, 0.02266209f, 0.02234205f, 0.02482674f, 0.02260824f, 0.04982149f, -0.00584286f, 0.04588627f, 
    0.03032643f, -0.03686745f, 0.03907130f, 0.00287032f, -0.00889812f, -0.04758919f, 0.04604053f, 0.01540027f, 
    0.04112364f, 0.04758473f, -0.00510217f, 0.04056324f, -0.01897722f, -0.02582055f, -0.03670596f, 0.01619965f, 
    -0.02566171f, 0.03346738f, -0.03601713f, 0.00183800f, -0.01606262f, 0.04360289f, 0.03098890f, -0.03337922f, 
    -0.03952327f, -0.04129880f, -0.04711816f, -0.04327904f, 0.04242069f, 0.00408311f, -0.04057263f, 0.00213932f, 
    0.02257073f, 0.00750163f, 0.04670861f, 0.01226464f, 0.01834870f, -0.00613230f, -0.03541571f, -0.03682602f, 
    0.01829194f, -0.02017720f, -0.04167491f, -0.02663887f, 0.00503881f, -0.03123678f, -0.04431112f, 0.05001919f, 
    -0.02071779f, -0.05081712f, -0.04340981f, -0.03959360f, -0.02220051f, 0.03200741f, 0.02659578f, 0.00565823f, 
    0.01783848f, 0.00287227f, -0.00671999f, 0.00823933f, -0.02916772f, 0.03236981f, 0.00987114f, -0.01372871f, 
    -0.03476531f, 0.01393535f, -0.00633500f, 0.02621697f, -0.03296773f, 0.01514990f, 0.02329136f, -0.03034450f, 
    -0.02787469f, 0.04403725f, 0.03065351f, 0.00263813f, -0.02505522f, 0.02925954f, -0.01960943f, -0.04625483f, 
    0.03444032f, 0.03027536f, 0.02343376f, 0.01107840f, 0.03912380f, -0.03364121f, 0.01751694f, 0.03646153f, 
    -0.02859053f, 0.02449919f, -0.02678036f, -0.02902306f, -0.00387044f, 0.02982400f, -0.04949579f, -0.00667645f, 
    -0.00383715f, 0.02432388f, 0.02600978f, -0.00268241f, 0.00823887f, -0.01755204f, 0.02816633f, 0.00408798f, 
    0.04986876f, 0.04029905f, 0.00259672f, -0.03321673f, -0.00043031f, -0.04114916f, 0.02788457f, -0.04234166f, 
    -0.02141282f, 0.04172845f, -0.04588535f, -0.01052222f, 0.01649374f, -0.03891698f, 0.02860738f, -0.00572686f, 
    0.01808365f, 0.03007093f, 0.02926060f, -0.02761232f, -0.02335865f, -0.00977163f, -0.04297009f, -0.03489421f, 
    0.00338072f, 0.00611079f, 0.04444914f, -0.02327787f, 0.02935547f, 0.04880472f, 0.04890031f, 0.02464075f, 
    -0.03553138f, 0.01561865f, -0.04142366f, 0.00590653f, -0.00770795f, -0.04601678f, 0.03566849f, 0.02203318f, 
    0.01040000f, 0.02374601f, 0.03046439f, 0.01996732f, 0.02240842f, -0.01932056f, -0.03894472f, -0.02932682f, 
    -0.04356936f, 0.03996229f, -0.02229644f, 0.05077801f, -0.01311426f, -0.04886352f, -0.01247168f, -0.04559431f, 
    -0.01786212f, -0.00270520f, 0.00761169f, 0.03921101f, -0.02819872f, -0.04373601f, -0.01316081f, -0.00419005f, 
    0.00256667f, -0.04128465f, 0.01208292f, 0.03532334f, 0.04188805f, -0.01209318f, -0.03191803f, -0.03601716f, 
    0.03686262f, -0.02248114f, 0.03883562f, -0.04768845f, 0.04320063f, -0.03296321f, -0.01958249f, -0.05055707f, 
    0.01239719f, -0.00950987f, -0.00470609f, -0.00604296f, 0.02062184f, 0.00774938f, -0.00760392f, -0.01608793f, 
    0.03797634f, -0.04861846f, -0.00050876f, -0.01859487f, -0.00858068f, -0.04468709f, -0.00701336f, 0.01898541f, 
    -0.04589612f, 0.03153045f, -0.03160340f, 0.01026937f, -0.04979419f, 0.02496642f, -0.03174765f, -0.03145634f, 
    0.00360517f, 0.00476700f, -0.04289339f, 0.04216802f, 0.02075095f, 0.03579519f, -0.01423377f, -0.04889508f, 
    0.01232874f, 0.00045246f, 0.01299768f, 0.04504176f, -0.02362908f, 0.02207707f, -0.03842189f, 0.00382143f, 
    -0.01835813f, -0.03349744f, -0.02968575f, -0.01498095f, -0.01162454f, 0.04429902f, -0.03040644f, -0.05102520f, 
    0.09444157f, -0.01213295f, 0.13283131f, 0.04187635f, -0.21360567f, 0.06557289f, 0.04018548f, -0.02072768f, 
    0.00225201f, 0.03994534f, -0.03233456f, 0.06299933f, -0.52730256f, 0.10632466f, -0.08188422f, -0.01814835f, 
    0.13736512f, 0.16395658f, -0.01431673f, 0.09408091f, 0.01721071f, -0.08446517f, 0.11433544f, -0.05887987f, 
    0.06882820f, 0.08323372f, -0.09638791f, -0.04237519f, 0.07401158f, 0.04609336f, -0.17786163f, 0.01238104f, 
    -0.12235922f, -0.10536773f, -0.05251195f, -0.05109432f, -0.05874142f, -0.16183601f, 0.20383318f, -0.11951091f, 
    -0.05047053f, 0.05818321f, 0.00823512f, 0.04213282f, 0.02281215f, 0.11327799f, 0.02724975f, -0.01737778f, 
    -0.01524526f, 0.24566320f, -0.07804256f, 0.06035908f, 0.01158920f, -0.03614938f, 0.01432991f, 0.03582782f, 
    -0.15422820f, 0.07234075f, 0.01614952f, 0.09709117f, -0.04352203f, -0.12529926f, 0.10625831f, 0.11346138f, 
    -0.09866636f, 0.00482901f, 0.07687268f, -0.02167745f, 0.01188059f, -0.01096773f, 0.02224731f, -0.03208403f, 
    -0.19816737f, 0.16843611f, 0.05280331f, -0.22254530f, 0.06843848f, 0.03706923f, -0.02172495f, 0.07557029f, 
    -0.04509382f, -0.02536468f, 0.12654266f, 0.05402595f, -0.27838516f, 0.08652454f, 0.01384783f, -0.22529654f, 
    0.20192082f, 0.05463924f, -0.00623819f, 0.04568953f, 0.00331161f, 0.00105140f, 0.03131216f, 0.01138481f, 
    0.02113455f, 0.14825772f, 0.07674777f, -0.18936487f, 0.08418661f, 0.06802326f, 0.01711231f, 0.01981249f, 
    -0.01568259f, 0.07778715f, 0.09558617f, 0.03447495f, -0.31855890f, 0.01600553f, -0.03488212f, 0.14492120f, 
    -0.04059066f, -0.13067526f, 0.05073804f, 0.08637774f, 0.04972314f, -0.01366150f, 0.12801711f, 0.04777505f, 
    0.38417211f, 0.04931244f, -0.11921174f, 0.13510202f, 0.11182670f, 0.01519720f, 0.02452336f, 0.09181779f, 
    0.01329618f, -0.02533102f, -0.04983290f, 0.06251337f, 0.35914823f, -0.11041746f, 0.16246469f, -0.07891783f, 
    0.12496224f, -0.00088086f, 0.00966904f, 0.14333344f, 0.11929299f, 0.04595729f, 0.05858230f, -0.07882210f, 
    -0.40599307f, 0.00577675f, -0.02334768f, -0.03274682f, 0.06233575f, 0.05861536f, -0.00217221f, 0.02724160f, 
    -0.07634528f, 0.05903875f, 0.10902340f, -0.05193264f, 0.19265935f, 0.33067095f, -0.04306474f, -0.12844500f, 
    0.02419840f, -0.03294686f, -0.12127345f, -0.04872994f, -0.03452891f, -0.05818648f, -0.03132037f, -0.03619997f, 
    0.06700613f, 0.05967423f, 0.23438746f, -0.04508700f, -0.00171729f, -0.00483458f, 0.12161037f, -0.00520158f, 
    0.01493665f, 0.03105031f, 0.14112367f, 0.01573648f, 0.24403995f, -0.23051636f, 0.05285793f, -0.09745643f, 
    -0.06661258f, 0.02222171f, 0.02499075f, -0.03256711f, 0.09000733f, -0.01177897f, -0.03154120f, -0.00408057f, 
    -0.25038612f, -0.03040534f, 0.00833774f, 0.38525602f, 0.14467344f, -0.01583753f, 0.03576441f, -0.03847274f, 
    0.09468912f, 0.05562671f, -0.03713930f, -0.01502474f, 0.25583279f, 0.04787683f, -0.06728965f, 0.06861571f, 
    0.00296261f, -0.03336186f, 0.03426019f, 0.06263789f, 0.09537906f, 0.12791227f, -0.08565943f, 0.05005742f, 
    0.10030891f, -0.09569348f, -0.05166612f, -0.08137622f, -0.05538008f, -0.06713097f, 0.01093320f, -0.03590241f, 
    -0.03136904f, -0.06665066f, -0.05751082f, -0.02132420f, -0.06288079f, 0.09360856f, -0.22282554f, -0.03341974f, 
    -0.12887217f, -0.02754745f, -0.01748927f, 0.04644204f, 0.00296601f, -0.00030427f, 0.00770496f, -0.05074419f, 
    0.09171711f, 0.02149604f, 0.00993679f, 0.18597390f, 0.03984401f, 0.04164539f, -0.03000362f, -0.06964996f, 
    0.02477580f, -0.02380790f, -0.05894331f, 0.00096985f, -0.22020276f, 0.06457842f, 0.01008185f, -0.17732276f, 
    -0.02080286f, 0.04324969f, 0.04516589f, -0.01702082f, -0.02011261f, 0.15611836f, 0.00763544f, 0.01177342f, 
    0.13367905f, 0.19503276f, 0.08268785f, 0.09775559f, -0.18754196f, 0.07173090f, 0.03210821f, -0.18677071f, 
    -0.06388342f, 0.06041896f, 0.00524312f, -0.01466139f, -0.14405984f, 0.18738537f, -0.13840607f, -0.24483660f, 
    0.05095232f, -0.05853529f, 0.00475466f, 0.04956145f, 0.04318129f, -0.11252600f, 0.04181168f, -0.06183951f, 
    -0.10147936f, 0.10917079f, -0.16089684f, 0.47745496f, 0.14746343f, 0.02877178f, 0.12982574f, -0.03452626f, 
    -0.12813371f, 0.04714156f, 0.00625313f, 0.09541567f, 0.19884731f, -0.12437467f, 0.11235266f, 0.03103291f, 
    0.05365571f, 0.02830965f, 0.00333248f, 0.11900869f, -0.05544841f, 0.00335224f, -0.01032279f, 0.02513912f, 
    0.19157484f, 0.11955414f, 0.16546574f, -0.20513406f, 0.09044712f, -0.01068093f, 0.07794637f, -0.07570345f, 
    0.06469147f, 0.08262651f, 0.06080335f, -0.02577315f, 0.12694749f, 0.04948701f, 0.02852565f, 0.04614330f, 
    -0.04492670f, 0.02447463f, -0.00715286f, -0.06174681f, 0.05316621f, -0.08783361f, 0.05155733f, 0.01140432f, 
    -0.22458394f, 0.38341194f, -0.08964553f, 0.24046989f, -0.08783750f, -0.02496918f, 0.00327045f, 0.09677691f, 
    0.03720885f, -0.06551901f, -0.02188433f, 0.02342938f, -0.04795023f, 0.16897884f, -0.11114963f, -0.05722173f, 
    0.01279401f, -0.07613178f, 0.00665985f, 0.05542095f, 0.09065074f, 0.09895819f, 0.04495228f, -0.10952508f, 
    -0.02470007f, 0.11240396f, 0.04158713f, 0.23223126f, 0.03014445f, -0.01951651f, 0.05100060f, -0.03426388f, 
    -0.01885182f, -0.04809536f, 0.14322953f, -0.01248548f, 0.04429018f, -0.08408961f, 0.09358580f, 0.26484168f, 
    0.03390803f, -0.00963313f, -0.05325475f, -0.05027055f, -0.10440623f, -0.03942798f, -0.00557562f, 0.07546632f, 
    -0.20385920f, -0.07332715f, -0.13041048f, 0.02711019f, -0.08912705f, -0.05094336f, -0.02658488f, -0.10728341f, 
    0.05000475f, -0.09311116f, 0.14814906f, -0.01945745f, 0.10845123f, -0.27576151f, 0.06544609f, 0.05907172f, 
    0.07880684f, 0.06313451f, 0.13058728f, -0.00447962f, 0.05014804f, -0.07509018f, 0.04416575f, 0.12887383f, 
    0.18929622f, -0.03875595f, 0.10278151f, 0.18702482f, 0.02766371f, 0.09626464f, 0.08531112f, -0.01050947f, 
    -0.00253361f, 0.01447088f, 0.10676676f, 0.06129555f, 0.17202398f, 0.25416100f, -0.23861663f, -0.07175718f, 
    0.00283135f, -0.02421056f, -0.00506987f, -0.02450233f, 0.08897685f, 0.02253377f, 0.09576435f, 0.05962494f, 
    0.11771199f, -0.08108250f, -0.05813704f, -0.01740054f, 0.01492820f, 0.04691817f, -0.00749672f, 0.02453160f, 
    0.04868534f, 0.06281405f, 0.01265925f, 0.05482376f, -0.11803523f, 0.12737739f, -0.12819231f, -0.08679166f, 
    -0.00569864f, 0.03011100f, -0.03300220f, 0.02929250f, -0.01044461f, -0.03563987f, 0.02161269f, 0.00343423f, 
    -0.08707960f, -0.05865859f, 0.13662723f, -0.12570702f, 0.08757608f, -0.00394764f, -0.03880861f, -0.07859514f, 
    0.09596356f, 0.08983486f, -0.08083069f, 0.04079071f, 0.09150499f, -0.01435545f, 0.07639144f, 0.09506116f, 
    -0.02984131f, 0.02175415f, 0.01263703f, 0.05485627f, 0.13433059f, 0.04757123f, 0.14913289f, 0.10022475f, 
    -0.10215290f, 0.06344642f, -0.03553471f, 0.03467481f, 0.00601539f, 0.05157500f, 0.08627642f, 0.15353942f, 
    -0.00512608f, 0.06726716f, -0.05401553f, 0.03593490f, 0.19010082f, -0.13657838f, 0.08914001f, -0.09546161f, 
    -0.04397757f, 0.08633435f, 0.08798991f, -0.12296107f, -0.01251861f, 0.04440148f, -0.11552530f, 0.08361627f, 
    0.10877223f, 0.06711489f, 0.11102387f, 0.14045599f, -0.13921121f, -0.00669411f, -0.00398367f, 0.01766810f, 
    0.03692656f, -0.00604250f, -0.01429625f, 0.01847138f, -0.01802283f, -0.06525236f, 0.05704985f, -0.09677801f, 
    -0.03968072f, 0.22905047f, -0.11982746f, -0.04167870f, -0.07083809f, -0.05244678f, 0.02186634f, 0.02887139f, 
    0.12415653f, -0.04603807f, -0.02572415f, 0.24430969f, -0.13846536f, 0.01108562f, 0.15031350f, 0.09259969f, 
    0.09974908f, -0.00766818f, -0.24964543f, 0.06556300f, 0.10108391f, -0.10038914f, -0.07242040f, 0.15158798f, 
    0.12192243f, 0.00442627f, 0.03111571f, 0.02778513f, 0.08371927f, 0.07888389f, 0.12340119f, 0.14414132f, 
    -0.03196979f, -0.00679428f, -0.09666068f, 0.01457921f, 0.13812408f, 0.04687214f, -0.08376610f, 0.05142548f, 
    0.06756008f, -0.00414255f, 0.05618273f, 0.01129960f, -0.23646191f, 0.24638735f, -0.03872515f, -0.09459776f, 
    -0.01482420f, -0.03566321f, -0.02354348f, 0.25063393f, 0.01305243f, 0.03055283f, 0.18162540f, -0.05528841f, 
    0.26930681f, -0.20493525f, -0.08399911f, -0.07982808f, -0.00346621f, 0.04891684f, 0.12599242f, 0.04114885f, 
    0.05811578f, 0.05942423f, 0.01527204f, 0.04976890f, -0.16128711f, 0.27281988f, -0.17759754f, -0.00106112f, 
    0.05767467f, 0.00510194f, 0.02599171f, 0.02033786f, 0.06338248f, 0.02026898f, 0.00654738f, -0.03943302f, 
    -0.15549424f, -0.00306473f, 0.05895517f, -0.06378832f, 0.08321266f, -0.02994739f, 0.14265509f, 0.13811997f, 
    0.00343374f, 0.01270895f, -0.03192666f, -0.03700791f, 0.08018498f, -0.03404497f, 0.19823845f, 0.25119108f, 
    0.10148791f, 0.09475468f, -0.01347829f, 0.05178247f, 0.07842962f, 0.14025532f, -0.04138532f, 0.07217801f, 
    0.00096230f, 0.14846733f, -0.02333887f, 0.19914742f, 0.03558261f, 0.02651193f, 0.02968610f, 0.00744392f, 
    -0.08485290f, 0.12257039f, 0.13199459f, 0.01235254f, 0.04863215f, -0.15367307f, 0.04082874f, -0.02448449f, 
    0.05093217f, 0.08059600f, 0.00295357f, 0.00540752f, 0.04521399f, -0.00525712f, 0.05013178f, 0.06191009f, 
    -0.08352716f, -0.10117305f, -0.19247346f, 0.03333949f, 0.00823543f, 0.00263545f, 0.01125440f, -0.03336614f, 
    0.02107436f, -0.08059406f, 0.04494375f, 0.03674503f, 0.14468008f, -0.15571733f, 0.23730294f, 0.15051152f, 
    0.08376081f, 0.05208434f, 0.09133378f, -0.01773614f, -0.00441299f, 0.01435641f, 0.11275642f, 0.14217745f, 
    0.18209533f, -0.03939297f, -0.16416740f, 0.09218576f, -0.05967370f, -0.04202675f, 0.00792311f, 0.04913173f, 
    0.02144077f, 0.06842117f, -0.00561469f, 0.15773498f, -0.21120612f, 0.36714467f, 0.02417295f, 0.12284672f, 
    -0.12796894f, -0.03141253f, 0.03666401f, 0.11087365f, 0.06461725f, 0.02915590f, 0.01233719f, 0.00897522f, 
    -0.04704484f, -0.07233320f, -0.24169229f, 0.04034853f, 0.05827735f, -0.01472086f, 0.06585036f, 0.09914822f, 
    -0.03007989f, -0.01618697f, 0.02325247f, 0.08535268f, 0.09629527f, -0.00432247f, -0.11003457f, 0.02454201f, 
    -0.04349922f, -0.07481495f, 0.03082510f, -0.03026401f, -0.02206041f, 0.02818009f, 0.04323700f, 0.06072934f, 
    -0.18528894f, -0.39355180f, 0.17285933f, 0.00889036f, 0.06223936f, -0.10939744f, 0.04367533f, -0.03224536f, 
    0.09659150f, 0.05996783f, -0.00466565f, 0.02675277f, 0.21098264f, -0.04322467f, 0.13228679f, 0.34342483f, 
    -0.01489024f, 0.17953801f, 0.03372409f, 0.00762337f, -0.09242979f, 0.02608330f, -0.02601643f, 0.11507386f, 
    0.17877710f, -0.10674524f, -0.04637723f, 0.00459300f, 0.05074431f, -0.07567270f, -0.00043370f, -0.02689729f, 
    0.06545006f, 0.19123369f, -0.15224077f, 0.10768172f, 0.05616697f, 0.19572954f, -0.16914074f, -0.10753741f, 
    0.03831170f, -0.02387527f, 0.01272218f, -0.03169081f, 0.01803585f, -0.01805928f, 0.03836448f, 0.06664162f, 
    -0.41643420f, 0.04906558f, 0.02044972f, -0.23318452f, 0.13514198f, 0.06780995f, -0.09088015f, -0.05145658f, 
    0.14428501f, 0.01496542f, 0.08908758f, 0.02077973f, 0.15671048f, -0.05983132f, -0.20370087f, 0.15189540f, 
    -0.04657817f, -0.00427533f, -0.05920155f, 0.06054641f, -0.14535944f, 0.01596219f, -0.00424602f, 0.02326097f, 
    -0.21598089f, -0.05388767f, 0.15918595f, -0.04038689f, -0.11727655f, -0.09951916f, -0.09897732f, -0.02290935f, 
    0.00348510f, 0.00551239f, 0.19726183f, 0.06714447f, -0.24537176f, -0.13575163f, 0.11854458f, 0.05180647f, 
    0.13751486f, 0.12081632f, -0.05737579f, -0.08343541f, 0.09261346f, 0.06856026f, 0.02364638f, 0.09741151f, 
    -0.06239283f, 0.05849994f, 0.04929149f, -0.03150497f, -0.05572392f, -0.07897490f, 0.02306331f, 0.06298825f, 
    0.07967595f, -0.01202635f, 0.06771960f, -0.00014609f, -0.10276619f, 0.10370685f, 0.08190223f, -0.07583228f, 
    -0.02325866f, 0.01877041f, -0.01370184f, 0.04412972f, 0.00726867f, 0.00599963f, 0.00058610f, 0.06940435f, 
    0.13337292f, -0.01900013f, 0.19164638f, 0.27865505f, -0.22628833f, -0.06526411f, 0.13025780f, -0.06779971f, 
    0.11721818f, -0.15802532f, 0.09896671f, 0.02825265f, 0.17683689f, -0.13334326f, -0.03582792f, 0.03834208f, 
    -0.09730215f, 0.08487185f, -0.00261222f, -0.02732661f, -0.04221835f, 0.07178405f, 0.10897086f, -0.14874138f, 
    -0.06946071f, -0.10884656f, 0.23110823f, 0.19729805f, 0.04366866f, -0.09234443f, 0.05372184f, 0.01157387f, 
    0.04339769f, -0.10045248f, -0.11939919f, 0.01783179f, 0.19145074f, -0.03097603f, -0.05245543f, -0.17500533f, 
    -0.07688468f, -0.02991565f, -0.20147124f, -0.14169857f, -0.11346446f, -0.01574285f, -0.15451346f, -0.00525273f, 
    0.00840260f, -0.11010458f, 0.37639311f, -0.00722033f, 0.01843734f, 0.02442079f, 0.02864633f, 0.08301583f, 
    0.06527463f, -0.02827771f, -0.03003786f, 0.00773715f, -0.19719341f, 0.13887785f, 0.02481523f, 0.15264009f, 
    0.18560651f, -0.12821691f, 0.15095969f, 0.12112965f, -0.04214316f, -0.01801894f, 0.02851568f, 0.12539227f, 
    0.00677589f, -0.00059636f, -0.07991361f, 0.02473022f, -0.04083726f, -0.03931338f, 0.06675969f, 0.06196425f, 
    -0.00877853f, -0.10407419f, -0.04444730f, 0.03470198f, 0.00995563f, -0.15513225f, 0.03109324f, 0.01702121f, 
    -0.00331326f, 0.02535769f, 0.07431781f, -0.02712357f, -0.01748275f, 0.04876330f, 0.15999831f, 0.18366428f, 
    -0.21988519f, 0.06409319f, -0.12084532f, 0.04198125f, -0.08272007f, -0.06116754f, -0.01030582f, 0.05104638f, 
    -0.07169104f, -0.03679135f, 0.04519859f, -0.13871905f, -0.22683844f, 0.02049109f, 0.17252247f, 0.17787196f, 
    0.08909003f, -0.01473472f, 0.09440700f, -0.09343981f, -0.08346646f, -0.08703503f, 0.02547925f, -0.13459709f, 
    0.25163722f, 0.18007655f, -0.14615375f, 0.00573443f, -0.01769944f, 0.06302645f, 0.00720922f, 0.10938484f, 
    -0.00615420f, -0.07815416f, 0.03781019f, 0.08444361f, -0.18359275f, -0.09272786f, 0.18251666f, -0.00316105f, 
    0.09791282f, -0.00947551f, 0.01731315f, -0.01284163f, 0.11419336f, -0.01536783f, 0.02171547f, -0.11072793f, 
    0.14626458f, 0.16130872f, 0.08547248f, 0.07187331f, -0.04288886f, 0.13693738f, 0.06268556f, -0.16663724f, 
    0.02921465f, 0.01202095f, 0.05008049f, -0.10050284f, 0.05280618f, 0.07943394f, 0.11046724f, 0.11015651f, 
    0.02867231f, 0.24251613f, 0.04980037f, 0.06314553f, 0.11143545f, -0.02339227f, 0.03240720f, -0.00817193f, 
    -0.11285754f, 0.03238504f, 0.07664984f, 0.08536343f, 0.00229256f, -0.05584918f, -0.05908107f, 0.03904592f, 
    -0.12943198f, -0.03107151f, 0.00768270f, 0.00483917f, 0.13722198f, -0.04093651f, 0.13143732f, 0.15154295f, 
    0.02409395f, -0.00603977f, -0.02523566f, -0.09629412f, 0.05666683f, -0.04063241f, 0.10657459f, 0.03204411f, 
    -0.09593472f, -0.08547287f, -0.04138240f, -0.15788262f, 0.05305086f, 0.10964091f, 0.11170314f, -0.04761646f, 
    0.00084199f, -0.08009318f, 0.14952858f, 0.08514406f, 0.02921712f, -0.10246504f, 0.12025913f, 0.33657098f, 
    -0.05161085f, 0.06964369f, -0.00867085f, 0.09469914f, 0.03211557f, 0.04059661f, -0.03833487f, 0.04330629f, 
    0.24814868f, 0.41028967f, 0.26690930f, -0.09905852f, -0.05544409f, -0.07722420f, -0.13211271f, -0.04042773f, 
    -0.01550428f, -0.08488069f, 0.06773685f, -0.02530156f, -0.14975694f, 0.11390335f, 0.08819851f, 0.09267359f, 
    0.10403830f, -0.06478335f, -0.01762751f, 0.05970394f, -0.04926717f, 0.08080754f, -0.05445499f, -0.04833300f, 
    -0.29218116f, 0.01605783f, 0.08621401f, -0.05799237f, 0.14337558f, -0.14103445f, 0.07780807f, 0.03732570f, 
    -0.00519762f, 0.09104760f, -0.04252838f, 0.01091278f, -0.17560677f, 0.04327463f, -0.11907271f, -0.09853844f, 
    0.06366242f, -0.01045573f, 0.22243410f, -0.00694009f, 0.02231713f, 0.04272264f, -0.09840007f, -0.01176524f, 
    0.33363020f, 0.02289632f, -0.22421031f, -0.11204463f, 0.00236710f, 0.07843747f, -0.19436519f, -0.02201771f, 
    0.00495303f, 0.10738241f, -0.12032519f, 0.04922735f, 0.07105064f, -0.12262721f, 0.08606996f, 0.17165026f, 
    -0.09171888f, 0.05439744f, 0.10705360f, 0.04418616f, -0.05533886f, -0.01122762f, -0.00315573f, 0.10136177f, 
    -0.09914243f, -0.01330166f, -0.01004068f, -0.10479921f, 0.03521496f, -0.00008237f, 0.01787451f, 0.13286732f, 
    -0.08039400f, 0.09737312f, -0.11404274f, 0.01332489f, 0.01007616f, 0.03846609f, 0.12857279f, -0.11968352f, 
    -0.12482367f, 0.18914889f, 0.09105340f, 0.02314132f, 0.10704158f, 0.00734351f, -0.18104742f, -0.05638805f, 
    -0.01912003f, -0.00916092f, -0.00656392f, 0.04218134f, -0.04366608f, 0.00205163f, 0.02024822f, 0.01348634f, 
    -0.00684044f, -0.05500478f, 0.01949730f, -0.05855315f, -0.03181539f, -0.01741526f, -0.04954867f, -0.03960026f, 
    0.04130518f, 0.03826943f, 0.02151000f, 0.03070133f, 0.00728248f, -0.02575561f, -0.03376685f, 0.02875162f, 
    -0.03737641f, 0.00513744f, -0.03826737f, 0.03765136f, 0.00928883f, 0.00350971f, -0.01167717f, -0.02264265f, 
    -0.03149084f, 0.00855141f, 0.03383899f, 0.02300405f, -0.05113523f, -0.02485828f, -0.04572231f, 0.01840033f, 
    -0.01436135f, -0.02654444f, 0.03785729f, 0.01131746f, -0.01331447f, -0.02156128f, -0.02008395f, -0.01556428f, 
    0.02174523f, 0.00911859f, 0.02701442f, 0.02443096f, 0.01733048f, -0.01744485f, 0.04368676f, 0.04316666f, 
    -0.05224913f, 0.01714600f, -0.00654388f, -0.05198198f, -0.01347632f, -0.03135000f, -0.01963919f, -0.05592773f, 
    0.04385133f, 0.01351721f, -0.03981959f, 0.00592582f, 0.00938385f, -0.05286476f, -0.04308704f, 0.03711432f, 
    0.00087578f, -0.05333077f, -0.01486099f, 0.01200051f, 0.02092132f, 0.03967141f, 0.03644002f, 0.02535486f, 
    0.00721109f, 0.00312883f, -0.03737452f, 0.02982281f, 0.03708000f, 0.00652790f, 0.02329364f, -0.01208304f, 
    -0.05337952f, -0.03554607f, 0.01565681f, 0.00240613f, -0.00115093f, -0.00044209f, -0.03628748f, -0.03350987f, 
    -0.03306849f, 0.02481132f, -0.04027870f, 0.02019756f, 0.03244934f, -0.04327393f, -0.04473018f, 0.01534707f, 
    -0.02014078f, 0.01945572f, 0.02799648f, -0.04676552f, 0.01541971f, -0.02674424f, 0.01495435f, 0.03949858f, 
    -0.00103229f, 0.03856435f, 0.01575203f, -0.00914815f, -0.00935025f, -0.03878367f, 0.00770273f, -0.01512140f, 
    0.03725720f, 0.03411848f, -0.00877617f, 0.00298323f, -0.01506293f, -0.00405163f, -0.03266064f, -0.03255913f, 
    0.00906520f, -0.01887667f, -0.05712718f, -0.03478267f, -0.02643037f, -0.05336742f, -0.02003772f, -0.04894416f, 
    0.03515920f, -0.00074663f, -0.00236595f, 0.03887032f, -0.02417082f, 0.04629228f, 0.03529789f, -0.05960240f, 
    0.00943578f, -0.01803614f, -0.05761778f, -0.01457352f, -0.03978444f, 0.00842222f, 0.02848681f, 0.03699112f, 
    0.03983552f, -0.04714680f, 0.01954938f, 0.00162058f, -0.03200503f, 0.03709779f, 0.01959261f, 0.01827529f, 
    0.01434860f, -0.01339949f, 0.03894717f, -0.05506939f, -0.03887323f, 0.03468382f, 0.02593772f, -0.01953408f, 
    0.01364177f, -0.00163800f, 0.04433478f, 0.02395693f, 0.05163887f, 0.02328491f, -0.05610346f, -0.00731411f, 
    0.01300738f, 0.00421345f, 0.00913888f, -0.05119302f, -0.01311198f, -0.01614822f, 0.01851991f, 0.01169117f, 
    -0.02022505f, 0.03371422f, 0.04199347f, -0.02315297f, -0.04291971f, 0.03963112f, -0.05739924f, -0.04436740f, 
    -0.01128482f, 0.02414257f, -0.04933254f, 0.02574107f, 0.01876731f, -0.05530295f, 0.02468742f, -0.03643329f, 
    -0.05010787f, -0.01818768f, -0.02626499f, 0.03180815f, -0.06000952f, 0.01968073f, 0.01049624f, -0.05310285f, 
    0.00187378f, -0.04181613f, 0.03858084f, 0.00686700f, -0.00716369f, 0.03056074f, 0.00306363f, -0.01286526f, 
    -0.02206894f, -0.03036324f, -0.04825034f, -0.00468284f, -0.02483263f, 0.01039416f, -0.00838140f, -0.01695270f, 
    -0.01564409f, 0.01776413f, -0.00871416f, -0.04319626f, -0.03216795f, -0.05089742f, -0.04444674f, 0.02911427f, 
    -0.03961831f, 0.02494089f, -0.00980846f, -0.01176302f, -0.00925413f, -0.01856222f, 0.01138985f, 0.00209580f, 
    -0.00146831f, -0.01323343f, -0.01574473f, -0.03505181f, -0.05521649f, -0.01861252f, -0.03852288f, -0.00892586f, 
    0.03901910f, -0.02613865f, -0.00125271f, 0.01919789f, -0.04123415f, 0.00625601f, -0.04735151f, 0.02730366f, 
    0.03254423f, -0.03386519f, -0.04945764f, -0.01204590f, 0.03348041f, 0.04389721f, 0.03933280f, 0.01651799f, 
    0.01488882f, 0.00927257f, -0.00981889f, -0.05528935f, -0.05179138f, -0.03890936f, 0.01515285f, -0.03304515f, 
    -0.05074798f, -0.04620517f, -0.00390648f, 0.02846714f, -0.02843614f, 0.03697001f, -0.02496306f, 0.02572352f, 
    0.00265762f, -0.00581702f, 0.01068684f, -0.00982736f, 0.03848652f, 0.03833557f, -0.03221432f, -0.03329469f, 
    0.00327065f, -0.03288916f, -0.04288804f, 0.03365503f, -0.00081511f, -0.01638569f, 0.00055240f, -0.05100306f, 
    -0.05237590f, -0.04932817f, -0.04355104f, 0.00389474f, -0.05006488f, -0.00629651f, 0.00086743f, 0.01692786f, 
    -0.00654009f, -0.01677038f, -0.00066668f, 0.03476064f, 0.00578463f, 0.04091356f, 0.00205962f, -0.04947047f, 
    0.02848734f, 0.00410810f, -0.02470713f, -0.01394440f, -0.03822578f, -0.02992437f, -0.00496313f, 0.02248350f, 
    -0.03249598f, -0.04949925f, -0.01682923f, 0.04076247f, -0.01530342f, -0.00441451f, 0.00808076f, -0.01365359f, 
    -0.02925073f, -0.03360434f, -0.01322758f, -0.01062943f, -0.01696621f, 0.00805408f, 0.03939752f, 0.03022966f, 
    -0.01863194f, -0.05672328f, 0.02172489f, -0.00768966f, -0.02724328f, -0.04281523f, 0.01090123f, -0.01770232f, 
    0.01876373f, 0.02843403f, -0.00052902f, 0.00841293f, 0.00273084f, -0.02783597f, 0.01708444f, 0.04113506f, 
    -0.04297760f, -0.02556942f, -0.03461844f, 0.03465834f, 0.04470417f, -0.04529463f, -0.01422417f, -0.05856257f, 
    0.03350379f, 0.02547033f, -0.04672801f, -0.03042229f, -0.03595774f, 0.04077072f, -0.04607031f, 0.00908859f, 
    -0.03033288f, 0.01936750f, -0.04681088f, 0.00734492f, 0.03082450f, 0.01400866f, 0.01595654f, 0.01356143f, 
    0.02365305f, -0.03680575f, 0.02139008f, 0.03508335f, 0.02509326f, -0.02591525f, 0.00508222f, 0.00356345f, 
    -0.08549566f, 0.01394096f, 0.07402574f, 0.06887643f, 0.07875003f, -0.16367009f, 0.11158077f, -0.07879141f, 
    -0.05586075f, -0.04850691f, -0.02860565f, -0.09085578f, 0.00514816f, -0.07562032f, 0.02342424f, -0.07011633f, 
    0.13932435f, -0.02329352f, 0.08347549f, -0.16292527f, -0.02955767f, 0.05686888f, -0.03383093f, -0.04950281f, 
    0.11195187f, 0.02593869f, -0.21010068f, -0.18017146f, 0.02285744f, -0.00866436f, -0.02049449f, 0.03442633f, 
    0.17191741f, 0.10909954f, 0.03973850f, -0.07081486f, 0.16440268f, -0.10095039f, 0.21165453f, 0.20891161f, 
    -0.11113815f, 0.01729969f, 0.01219789f, -0.02721266f, -0.08546975f, -0.10191664f, -0.01985672f, 0.08039287f, 
    -0.07005824f, -0.10269178f, -0.04105120f, 0.06496750f, 0.02907903f, 0.00357037f, -0.03628926f, 0.09920481f, 
    0.12199123f, -0.00159727f, -0.01997789f, -0.18667988f, 0.55258870f, -0.09537601f, 0.08360767f, 0.23941305f, 
    -0.12142389f, -0.03975433f, 0.00567644f, 0.01905748f, -0.04028354f, 0.01662489f, -0.02128930f, 0.10944054f, 
    -0.28339547f, -0.04199668f, -0.17452525f, 0.00438746f, 0.03947407f, -0.13710554f, 0.03712858f, -0.16567844f, 
    0.04018589f, 0.04879419f, -0.02339217f, 0.00125707f, -0.12181215f, -0.18932103f, -0.10868581f, 0.13587436f, 
    0.16011763f, 0.15082228f, 0.10231766f, -0.10886852f, 0.02577876f, 0.06872490f, -0.02288855f, 0.03688326f, 
    -0.12881924f, -0.05006265f, -0.17440492f, 0.10610820f, 0.06438987f, 0.06241055f, -0.09549867f, -0.11129188f, 
    0.02498029f, -0.13040160f, -0.02919753f, -0.07818445f, 0.26696262f, 0.08996812f, -0.05732153f, 0.27953851f, 
    0.02145199f, 0.05950315f, 0.09146968f, 0.05898737f, 0.00218565f, 0.02230172f, -0.04070905f, -0.10352872f, 
    0.03159235f, 0.21607240f, -0.17330977f, -0.13771865f, 0.02555224f, -0.04544240f, -0.01593160f, -0.02264640f, 
    0.02837922f, 0.05551843f, 0.10612743f, -0.05013197f, -0.06109689f, -0.01910413f, -0.04564162f, 0.05642159f, 
    -0.08353245f, -0.05187893f, -0.02665712f, 0.02640005f, -0.06278739f, -0.01143178f, -0.01831477f, 0.01186834f, 
    0.13180712f, -0.06659391f, -0.02021581f, 0.00399153f, 0.12626874f, 0.16132808f, 0.01931852f, -0.09429008f, 
    -0.13258694f, -0.04729757f, -0.02225818f, 0.13259462f, 0.05997393f, -0.00460584f, -0.00871776f, -0.10377580f, 
    -0.06881844f, 0.05895267f, -0.06215702f, 0.05823784f, -0.04247754f, 0.21548256f, -0.00680508f, 0.09178316f, 
    0.22591643f, -0.06986181f, 0.04994547f, 0.03311063f, 0.07752345f, 0.09115561f, -0.08399474f, 0.07628143f, 
    0.19728923f, 0.02064566f, -0.00346601f, 0.12641768f, 0.15135095f, 0.03232630f, 0.03490233f, -0.02456578f, 
    0.07187890f, -0.00344146f, -0.06591624f, -0.10806767f, -0.06342591f, -0.00234160f, 0.04222644f, -0.07228406f, 
    -0.40790945f, -0.12512188f, 0.22597025f, -0.26518756f, 0.02979373f, -0.04529981f, 0.02301690f, -0.08910699f, 
    0.04362266f, 0.02278883f, 0.07858893f, 0.06896843f, -0.01984135f, -0.16319489f, 0.03581882f, 0.03056547f, 
    0.05132546f, 0.00320958f, -0.04736425f, 0.05722731f, -0.05175024f, -0.03484868f, 0.08635838f, 0.03837444f, 
    0.00897523f, 0.10207710f, 0.00864358f, -0.05817344f, 0.03925994f, -0.09359736f, -0.14157952f, 0.01782397f, 
    0.11092868f, 0.06915712f, 0.00659085f, -0.11656390f, -0.22994931f, 0.04230895f, -0.09677595f, -0.08183082f, 
    0.07075061f, 0.00626258f, -0.04040117f, -0.01939228f, -0.03891620f, 0.00053275f, 0.04628390f, 0.01350253f, 
    0.12845209f, 0.05534346f, 0.02575213f, -0.15275490f, 0.04362068f, 0.04816897f, 0.05260963f, -0.00832378f, 
    0.11119135f, 0.20441017f, -0.06048411f, -0.01622330f, 0.01152195f, 0.18680285f, -0.13128729f, 0.17387100f, 
    0.17490964f, -0.05377489f, -0.06392859f, -0.08947946f, -0.06973445f, -0.18454370f, 0.07080090f, -0.01111006f, 
    -0.00998144f, 0.08829968f, 0.22393158f, 0.07161557f, -0.00273931f, -0.10583720f, 0.03033241f, 0.11493389f, 
    0.00032831f, 0.00950639f, 0.13136463f, -0.06693547f, -0.32619235f, 0.05702448f, -0.07106492f, -0.00846783f, 
    0.17504452f, -0.05497896f, -0.00283843f, -0.00673430f, 0.02122674f, 0.00725794f, 0.04136074f, 0.01993383f, 
    -0.05236908f, 0.12399157f, -0.07646474f, -0.20260869f, -0.07068520f, -0.02085492f, -0.07168196f, 0.14648247f, 
    0.02487437f, 0.01959671f, 0.10235056f, 0.00602063f, 0.24463491f, -0.11082827f, -0.16021939f, -0.17553255f, 
    0.04429039f, 0.18872266f, -0.05428002f, -0.00729512f, 0.10667855f, 0.09836894f, 0.02338929f, 0.11553713f, 
    0.41413400f, -0.11652777f, 0.17225221f, 0.16631691f, 0.02288267f, -0.01980417f, -0.01716865f, 0.08879092f, 
    0.07540898f, 0.22295363f, -0.02373002f, -0.00436290f, 0.03640734f, 0.12033433f, 0.20804441f, 0.08245882f, 
    -0.05721107f, -0.13058197f, 0.05489061f, 0.07622352f, 0.01068979f, -0.06125725f, 0.01534214f, 0.01620201f, 
    0.03553407f, 0.25243515f, 0.20684415f, 0.05433453f, -0.11421518f, -0.02018807f, 0.04350152f, 0.05474962f, 
    0.11951396f, -0.02592444f, -0.08559795f, -0.01522798f, -0.23168850f, -0.10830441f, -0.12042587f, 0.06861926f, 
    0.18339506f, -0.01200395f, -0.01640669f, -0.05644873f, -0.10454644f, -0.02436713f, -0.05325074f, -0.00121670f, 
    -0.04821283f, -0.11071926f, 0.15994160f, -0.11535931f, 0.08808707f, -0.00903315f, -0.05391325f, -0.02011751f, 
    0.00281013f, 0.04150457f, -0.06990842f, 0.13476102f, 0.26118070f, -0.08816852f, -0.13477941f, 0.03038612f, 
    0.02552674f, 0.04019636f, 0.04525032f, 0.03894174f, -0.00479517f, 0.01814583f, 0.04122724f, 0.06464856f, 
    -0.15939987f, 0.08722341f, -0.07547601f, 0.07352048f, 0.08969678f, 0.00656597f, 0.16761337f, -0.10366490f, 
    -0.02736629f, -0.09951309f, 0.07618663f, -0.14026786f, -0.37397522f, -0.19830367f, -0.06181108f, -0.03150566f, 
    0.00872927f, 0.09909154f, 0.03778230f, 0.06866675f, -0.08462128f, -0.02561891f, 0.03359946f, 0.07661997f, 
    0.18051071f, -0.02863890f, 0.19510350f, 0.19025865f, -0.00014692f, 0.03436680f, -0.05170348f, 0.02632936f, 
    -0.03267013f, 0.11865482f, 0.07903580f, 0.08105139f, 0.19375178f, 0.14489540f, 0.00473838f, 0.08306450f, 
    0.08833400f, 0.08708002f, 0.02529257f, -0.00659636f, 0.04392872f, 0.04650278f, 0.06323101f, 0.02430425f, 
    -0.03709655f, 0.11144356f, 0.03804208f, 0.12208855f, -0.02942728f, -0.04485453f, 0.01913380f, 0.17370494f, 
    0.11562681f, 0.01911053f, 0.03996455f, -0.03828001f, 0.05487797f, 0.02164925f, -0.02801248f, -0.05989182f, 
    -0.08798825f, -0.08720345f, -0.01126780f, 0.05732761f, -0.02235375f, 0.08926423f, -0.04628853f, -0.00626837f, 
    -0.26266176f, -0.03933652f, -0.02669641f, 0.02677345f, -0.12076461f, -0.08293241f, 0.04742023f, -0.08454127f, 
    0.07650278f, -0.11923867f, -0.04938886f, -0.01745348f, -0.17386553f, -0.22914505f, -0.09850808f, -0.11476788f, 
    0.02235736f, 0.11522179f, 0.09282364f, -0.14821127f, -0.00416753f, 0.02089782f, 0.17326720f, -0.05867058f, 
    -0.25633886f, -0.18202499f, 0.06479444f, -0.02753242f, -0.06749646f, 0.06478854f, -0.02117682f, 0.01372713f, 
    0.04435189f, -0.08651410f, -0.05814567f, -0.01394944f, 0.18379374f, -0.03178589f, -0.08831468f, -0.06971840f, 
    -0.02923164f, 0.12562081f, -0.05475752f, -0.06568993f, -0.02936175f, 0.02592762f, 0.09404855f, -0.15495454f, 
    0.12493391f, 0.13768886f, 0.20178947f, 0.04777289f, 0.11124217f, 0.01320061f, -0.04389639f, 0.00570825f, 
    -0.06735441f, -0.06533300f, 0.06543801f, -0.00725549f, -0.03445917f, 0.11890304f, 0.03901104f, 0.23259865f, 
    0.17875682f, 0.12138031f, -0.12822297f, 0.08578994f, -0.05756471f, 0.05024314f, 0.02333799f, 0.05869552f, 
    -0.14085053f, -0.24788557f, -0.05846607f, 0.04735978f, 0.00490620f, 0.00946277f, -0.02466297f, -0.01520371f, 
    0.07901973f, -0.13106878f, -0.09204989f, 0.03334618f, 0.24938865f, 0.14494136f, -0.00473585f, 0.04980636f, 
    0.07279428f, 0.01886215f, -0.01117110f, 0.03371979f, -0.04252000f, 0.05334486f, 0.07256945f, 0.13645764f, 
    -0.40197811f, 0.15517041f, -0.06791367f, 0.05046507f, 0.01927788f, -0.00024997f, 0.03409767f, 0.07508590f, 
    0.05804257f, -0.03390075f, 0.02782600f, 0.03833333f, -0.28760806f, 0.08929193f, 0.08058616f, -0.18010789f, 
    0.10667115f, -0.01704317f, 0.01385313f, -0.05694894f, 0.05548619f, -0.02497295f, 0.05780572f, -0.05443581f, 
    -0.22743842f, 0.06805078f, 0.25807992f, -0.03943278f, -0.08585583f, 0.10536896f, 0.03191283f, 0.00098619f, 
    -0.06713799f, 0.04428050f, 0.05717760f, 0.07764251f, -0.00929428f, 0.15547523f, 0.16353679f, 0.12141070f, 
    0.05798613f, 0.09810079f, 0.05877652f, 0.14038658f, 0.12630087f, 0.11049823f, 0.04878204f, 0.03874275f, 
    -0.18732503f, 0.07207233f, -0.04932493f, -0.11997307f, 0.04318631f, -0.13436559f, 0.00138478f, -0.05851350f, 
    -0.00441060f, 0.03827545f, -0.02957020f, -0.11837154f, 0.02099511f, 0.11962099f, 0.19484052f, 0.37703621f, 
    0.06250140f, 0.08515473f, -0.01139221f, 0.07406648f, -0.03777313f, 0.09048038f, 0.09593228f, 0.03835202f, 
    0.29491583f, -0.02207451f, 0.25110888f, 0.26827538f, -0.02970361f, -0.02025964f, 0.10671874f, -0.01070237f, 
    -0.09334273f, 0.05273911f, -0.04450354f, -0.02589250f, -0.22472383f, 0.00164168f, -0.10643391f, -0.08014140f, 
    0.01436850f, 0.09402320f, 0.01512361f, -0.02681511f, -0.00290699f, 0.01459814f, 0.00330345f, 0.01684912f, 
    0.04414290f, 0.09889651f, -0.10137422f, 0.05640560f, 0.15154850f, -0.05333319f, -0.00119985f, 0.02517202f, 
    0.08422496f, 0.01432705f, 0.01519582f, 0.00903174f, -0.27182674f, -0.05474593f, -0.16521929f, 0.00263016f, 
    0.02583224f, 0.04354545f, 0.01992375f, 0.03254979f, -0.03134234f, 0.07188559f, 0.04533394f, 0.01749962f, 
    0.24344215f, -0.04529663f, 0.13391787f, -0.04436306f, 0.02936446f, -0.10023387f, 0.03269128f, 0.12683269f, 
    0.01674740f, 0.00594637f, 0.01340474f, 0.06794326f, 0.03497798f, -0.03358227f, 0.19336839f, 0.13250323f, 
    -0.04833110f, 0.06650379f, -0.00917203f, 0.05065367f, -0.10734520f, 0.05455581f, -0.01462695f, 0.00865101f, 
    0.10048858f, -0.00147767f, -0.04191012f, 0.05413070f, 0.12615594f, -0.02066278f, 0.04499587f, 0.09707543f, 
    0.05054520f, 0.04035925f, -0.00275375f, 0.02606044f, 0.04641395f, 0.14685570f, 0.00387134f, 0.18909183f, 
    0.07317095f, 0.02979682f, 0.11424931f, 0.18750510f, 0.02258762f, 0.09387840f, 0.05999191f, -0.06181614f, 
    0.01213992f, -0.04359014f, 0.00821423f, 0.10753851f, -0.02043235f, 0.03592738f, 0.01853594f, 0.02727038f, 
    -0.00855367f, 0.04917049f, -0.11547831f, -0.07805223f, -0.14016503f, -0.11044645f, 0.01145010f, 0.02468637f, 
    0.06363687f, 0.04301366f, 0.03715644f, 0.02346467f, -0.07175914f, -0.04724757f, -0.00197910f, 0.06074808f, 
    0.25349277f, -0.11693920f, 0.09028412f, 0.04037086f, 0.13090144f, -0.06859647f, -0.03632931f, -0.07389298f, 
    -0.01785772f, 0.13223156f, -0.09829669f, 0.01322557f, 0.15187930f, -0.01122832f, -0.04000848f, 0.13974075f, 
    0.03258086f, 0.02726673f, 0.05659386f, -0.02210658f, -0.00811546f, 0.09441881f, 0.03349804f, -0.07794426f, 
    0.37248829f, 0.00644273f, 0.04199939f, -0.06712404f, -0.13025258f, 0.00367540f, -0.10658122f, 0.07404364f, 
    0.03313183f, 0.03821253f, -0.04791826f, -0.01976242f, 0.25571400f, 0.08468313f, 0.10165200f, -0.03824627f, 
    0.06894936f, -0.00386265f, -0.01334988f, -0.06311914f, 0.04578833f, 0.04710692f, -0.01207231f, 0.02552844f, 
    0.02679746f, 0.11684015f, -0.11538183f, -0.12898220f, 0.09304900f, -0.01889415f, 0.16306524f, 0.03957078f, 
    -0.04732215f, 0.01982331f, 0.08238388f, 0.07047555f, -0.16434616f, 0.15544185f, -0.11975574f, -0.19700454f, 
    -0.00818310f, -0.14334583f, -0.02164200f, 0.06897546f, 0.00112532f, -0.05813112f, -0.06391212f, 0.01222075f, 
    0.17276914f, -0.11537836f, 0.02423416f, -0.01344124f, 0.05860975f, 0.01910852f, 0.01955579f, -0.02685771f, 
    0.02416539f, -0.04168652f, -0.08304839f, -0.02461725f, -0.07304189f, 0.15240236f, 0.01232280f, 0.14211762f, 
    0.08885324f, 0.05880171f, 0.11274482f, 0.12489731f, 0.15957269f, -0.06399246f, 0.10597757f, 0.05227679f, 
    -0.06266108f, 0.04832065f, -0.06686526f, -0.13302730f, 0.09383605f, -0.06144155f, -0.10351326f, 0.04092209f, 
    -0.13163915f, 0.05625534f, -0.02568183f, -0.00663286f, 0.07069369f, 0.23024659f, 0.04845792f, 0.04422265f, 
    0.08806524f, 0.03283944f, -0.14217930f, 0.17366286f, 0.12796824f, 0.04729094f, -0.17873062f, 0.10064719f, 
    0.34853631f, 0.31510571f, -0.18869004f, -0.05851135f, 0.07231800f, -0.00620455f, -0.01185362f, 0.09408117f, 
    -0.02767921f, 0.07113669f, -0.01469829f, 0.13339806f, -0.25613579f, 0.11917171f, 0.04432143f, -0.09127270f, 
    0.13995047f, -0.13616820f, 0.13718081f, 0.04496451f, 0.08317193f, 0.06098511f, -0.03001152f, 0.09580579f, 
    -0.34430116f, -0.11785175f, -0.13647556f, 0.10263820f, -0.00482373f, 0.13660236f, 0.04162414f, 0.01428266f, 
    0.12083859f, 0.04163133f, 0.00930411f, 0.05094592f, -0.10022246f, -0.01116991f, 0.06919109f, -0.04151160f, 
    -0.19271497f, -0.07838947f, -0.00446640f, -0.10294519f, 0.11983439f, -0.05168877f, 0.00805386f, -0.08947367f, 
    0.02773581f, 0.19032055f, 0.15283625f, -0.02718733f, 0.03931501f, -0.01347298f, 0.00034815f, 0.09637956f, 
    0.07119022f, 0.05479372f, 0.08760522f, 0.11457089f, 0.01528055f, -0.11537986f, -0.00030058f, -0.06839062f, 
    0.03548797f, 0.06773841f, 0.09991056f, 0.08352345f, 0.08207470f, 0.00887312f, 0.02456859f, 0.00447653f, 
    0.44342145f, -0.18757348f, 0.08582036f, 0.06511946f, 0.11943301f, 0.03939305f, 0.08431783f, 0.01737384f, 
    0.06293621f, 0.12047869f, 0.06916135f, 0.04724540f, 0.14386724f, -0.11247922f, -0.08858168f, 0.08592739f, 
    -0.05359238f, 0.02186247f, -0.03335650f, 0.06945790f, 0.05751225f, 0.04186024f, -0.06840963f, 0.04820877f, 
    -0.05800572f, 0.06902782f, -0.04307372f, 0.04863765f, 0.14524551f, -0.07866572f, -0.06428510f, -0.02639198f, 
    0.02838171f, 0.04017058f, -0.01143468f, 0.06405707f, 0.00457903f, -0.05308789f, -0.12851645f, -0.01104894f, 
    -0.11579658f, -0.04309155f, -0.08818877f, -0.00477170f, -0.00411725f, -0.08583893f, 0.01389498f, -0.04575172f, 
    0.31644601f, -0.14690700f, 0.04988658f, 0.14015426f, -0.06726252f, 0.07316423f, -0.02747372f, 0.04819151f, 
    -0.07471752f, -0.09219693f, -0.00670282f, 0.09894009f, 0.01379497f, -0.00115968f, -0.01228223f, -0.25978535f, 
    -0.00970262f, 0.01299868f, 0.11807314f, 0.08994614f, 0.07172678f, -0.05835155f, 0.01090005f, 0.05273537f, 
    -0.04768421f, 0.13346054f, -0.22159901f, -0.16164483f, -0.07055262f, 0.10531041f, -0.03609613f, 0.11800749f, 
    0.14232151f, 0.02260329f, 0.12303443f, 0.01936912f, 0.05152528f, -0.15216184f, 0.10974058f, -0.04234713f, 
    0.09885292f, -0.00461321f, -0.03137586f, 0.00224815f, 0.06232071f, -0.04547180f, 0.07950788f, 0.13714413f, 
    0.18752046f, 0.04906622f, 0.04634456f, -0.05723969f, -0.19625114f, 0.11260770f, 0.03133032f, -0.01004360f, 
    0.01792736f, 0.03579450f, 0.04941373f, -0.04704937f, 0.29181075f, -0.08108643f, 0.14839195f, -0.05033163f, 
    0.04988319f, -0.05459602f, 0.07090193f, -0.00373979f, 0.09006202f, 0.04033654f, 0.08765215f, 0.06988155f, 
    -0.21191323f, -0.21440464f, 0.00715305f, 0.14892331f, 0.05402847f, 0.08391539f, -0.01525672f, -0.16789895f, 
    -0.01692125f, 0.09158104f, -0.02530571f, -0.03104143f, 0.09580310f, 0.17207207f, -0.21849950f, -0.01855524f, 
    -0.00117756f, -0.00980032f, 0.09736388f, -0.03576082f, 0.09502799f, 0.00290163f, 0.02888498f, -0.00087937f, 
    -0.07759288f, 0.00363536f, -0.01638407f, -0.01282410f, -0.04750653f, 0.03833206f, -0.03373682f, -0.07499862f, 
    0.00645364f, -0.00734470f, -0.02492726f, -0.00432266f, 0.17141052f, 0.11699898f, 0.02169020f, -0.16380745f, 
    -0.20596181f, 0.10633893f, 0.06493632f, -0.16083953f, 0.02301225f, -0.09403098f, 0.05425990f, 0.17104724f, 
    -0.04565292f, -0.07668117f, 0.01136448f, -0.21296157f, 0.06083344f, -0.16258058f, 0.06786313f, -0.11322463f, 
    -0.10569128f, -0.15066926f, -0.03107299f, 0.01845973f, 0.22625309f, 0.24368660f, 0.02294447f, -0.10243154f, 
    -0.01670393f, -0.00821522f, -0.00631074f, -0.00571229f, 0.13817957f, 0.05989712f, 0.04867172f, 0.13197160f, 
    -0.14772537f, 0.05595803f, 0.07838438f, -0.00490337f, -0.01652366f, 0.06167988f, 0.09748118f, -0.00848775f, 
    -0.02957662f, -0.00672233f, 0.13294576f, 0.05998252f, 0.01989674f, 0.14353371f, 0.02883432f, -0.16153835f, 
    0.02505422f, 0.04800949f, 0.02938310f, 0.05710735f, 0.10575332f, 0.08222391f, 0.03497425f, 0.13962479f, 
    0.01463135f, -0.02503312f, -0.00217965f, -0.02699556f, 0.01046679f, 0.03360552f, -0.03151706f, 0.02069367f, 
    0.01391306f, 0.03454432f, 0.02278194f, -0.04807908f, 0.00791393f, -0.01364801f, -0.04718416f, 0.01785567f, 
    0.02489355f, -0.01268129f, 0.01152033f, 0.02025487f, 0.02697880f, 0.01940472f, 0.02035616f, 0.00206989f, 
    0.01122148f, 0.01326323f, -0.02822820f, 0.02630970f, -0.02776867f, -0.03625952f, -0.04158239f, -0.03920835f, 
    0.00960344f, 0.03661522f, -0.01109331f, 0.01168249f, 0.04305428f, 0.03281310f, -0.04578437f, -0.01811599f, 
    -0.01578439f, 0.03050386f, -0.03967792f, 0.00064731f, -0.01254652f, -0.04428128f, 0.03533841f, 0.01521749f, 
    0.01276933f, 0.03267628f, 0.00554063f, -0.01564097f, -0.04753200f, 0.02609505f, 0.01988097f, -0.03251763f, 
    -0.03749384f, -0.02557263f, -0.02234812f, 0.00750656f, -0.01546680f, 0.04487178f, -0.01533234f, -0.00094020f, 
    -0.05133278f, 0.01862048f, 0.02957789f, 0.02096094f, -0.00839787f, 0.00799872f, -0.05493689f, -0.03317561f, 
    -0.04892763f, -0.02189373f, 0.02060469f, -0.01105952f, 0.04329888f, 0.03437317f, -0.00992812f, 0.02889406f, 
    -0.04829056f, 0.04493919f, -0.02353183f, 0.01094137f, -0.00585869f, -0.00444315f, -0.01972660f, 0.03769407f, 
    0.00040774f, 0.01974173f, -0.01703127f, -0.05408816f, 0.04235067f, -0.05481518f, -0.03396181f, 0.02398570f, 
    -0.04764407f, 0.03006170f, 0.03262445f, 0.01809351f, 0.02750036f, -0.05147823f, -0.03662088f, -0.00619057f, 
    -0.00267738f, 0.01626409f, -0.03182712f, -0.01045766f, -0.03191910f, 0.00755835f, 0.04107901f, -0.02531365f, 
    -0.01302760f, -0.02925158f, 0.00202058f, -0.02548888f, -0.00415351f, -0.01380983f, 0.01281488f, 0.00395853f, 
    -0.03603939f, -0.05493510f, 0.01251521f, -0.04978098f, 0.00841922f, 0.01174764f, -0.03345793f, 0.00386810f, 
    -0.04163946f, -0.01593795f, 0.03176842f, -0.00335898f, -0.05125939f, 0.00616298f, 0.03569420f, 0.02500206f, 
    -0.04825198f, 0.03298353f, -0.03871347f, -0.04918890f, -0.02031519f, -0.01028880f, -0.02017818f, 0.03314600f, 
    0.04046891f, -0.02165053f, 0.03134603f, -0.00039263f, -0.01331159f, -0.03695080f, 0.04470372f, 0.02522436f, 
    0.04195251f, -0.04799964f, 0.00354569f, -0.03900607f, -0.04720395f, 0.01552397f, 0.02799693f, -0.05318601f, 
    0.01306767f, -0.03892801f, -0.05398189f, -0.02410340f, -0.05395162f, 0.01694730f, -0.02416625f, -0.02929020f, 
    -0.05136594f, -0.00192398f, -0.02532571f, -0.00115074f, -0.01404592f, -0.01636493f, 0.01172947f, 0.01304422f, 
    0.04015472f, 0.03101139f, -0.03810775f, -0.00263376f, 0.04204369f, -0.02684395f, -0.01186728f, -0.00202898f, 
    0.02070127f, -0.01336646f, -0.03613754f, -0.02648643f, -0.03182216f, -0.05100369f, 0.01607697f, 0.04410737f, 
    -0.03769622f, -0.02414127f, 0.02964474f, -0.01821581f, -0.04155450f, 0.01394915f, -0.05177847f, -0.04242981f, 
    0.00811121f, 0.02123386f, 0.01079088f, -0.02860039f, -0.01351972f, -0.00743224f, 0.01055305f, 0.03086351f, 
    -0.03259508f, 0.00808874f, -0.05283852f, 0.00315852f, -0.03870062f, -0.04800662f, -0.04599523f, 0.03300088f, 
    0.03826275f, -0.01590287f, 0.02733828f, 0.02755122f, -0.00928240f, 0.03148989f, -0.04255923f, -0.04418307f, 
    0.02963628f, 0.03950616f, -0.03804145f, 0.00145725f, -0.01380813f, 0.02456546f, -0.03581148f, -0.03727005f, 
    -0.05273320f, 0.02309712f, -0.05436265f, 0.03085729f, -0.02214032f, -0.00623993f, 0.02322441f, -0.05497515f, 
    -0.02582993f, -0.03564312f, 0.02347744f, 0.00103764f, 0.02167597f, -0.03660851f, -0.04375909f, -0.01712151f, 
    0.03354659f, -0.01565492f, 0.02935147f, -0.01497036f, 0.01965570f, -0.03681756f, -0.03961146f, 0.01649500f, 
    0.02741148f, -0.00786482f, -0.03255896f, -0.01212561f, -0.02356842f, 0.01458857f, 0.00297600f, -0.00258062f, 
    -0.05507120f, -0.04496265f, -0.02138965f, -0.01394373f, -0.02078178f, 0.01405597f, -0.01331488f, 0.03042372f, 
    0.02938130f, 0.03810471f, -0.01187698f, -0.03125606f, -0.03020534f, -0.00911632f, -0.00891484f, 0.00617241f, 
    -0.04379550f, 0.04064360f, -0.02462555f, 0.00904515f, 0.03163297f, 0.02354883f, -0.05146353f, 0.00977131f, 
    0.03712478f, -0.01274782f, -0.03495777f, 0.02459362f, 0.03919226f, -0.02147565f, 0.01476777f, -0.03553899f, 
    -0.04905707f, -0.01450134f, 0.00579774f, -0.04541920f, -0.03818225f, -0.04266218f, 0.04019157f, 0.02298942f, 
    -0.04503921f, -0.04918902f, 0.03948667f, 0.02312868f, 0.00840259f, -0.03642930f, 0.00758077f, -0.04108147f, 
    -0.01370959f, 0.03455922f, 0.03052912f, 0.04540760f, -0.04130811f, -0.03956468f, 0.01076414f, -0.03391325f, 
    -0.00195082f, 0.02559712f, -0.04270505f, -0.00281833f, -0.03746872f, 0.02034122f, 0.00917505f, -0.01302616f, 
    -0.02219468f, -0.03023917f, -0.04102636f, 0.03501791f, -0.01753928f, 0.04297688f, 0.02203362f, 0.00935732f, 
    0.02104620f, 0.00803580f, -0.05007255f, -0.02134945f, -0.01584935f, 0.00333644f, -0.04314623f, -0.04138521f, 
    -0.05410507f, -0.02480473f, 0.01746581f, -0.03246437f, -0.00709269f, 0.03021119f, 0.00376256f, 0.01883644f, 
    0.00961255f, -0.01222924f, -0.01103469f, -0.02790705f, -0.01130952f, -0.02437585f, -0.04116577f, -0.02371950f, 
    -0.02241204f, -0.01075562f, 0.03383101f, 0.01987424f, -0.01954376f, 0.02293255f, -0.05113069f, -0.04638460f, 
    0.00278896f, -0.01697143f, -0.00227684f, 0.02553030f, -0.00459187f, 0.00410572f, 0.03329395f, -0.01077829f, 
    -0.05117136f, 0.01402611f, -0.04209266f, -0.00568997f, 0.00145322f, -0.02612469f, -0.03986367f, 0.02025000f, 
    0.01443216f, 0.03532435f, -0.02893653f, 0.04929222f, -0.01378871f, -0.00493681f, 0.02197192f, 0.03448405f, 
    -0.00859877f, -0.02079143f, -0.04985696f, 0.02029050f, -0.03080441f, -0.03470702f, 0.03479400f, 0.03666236f, 
    -0.00020847f, 0.00583372f, -0.00140938f, -0.02525111f, 0.02550682f, 0.03004522f, -0.03747405f, -0.04008512f, 
    -0.04918561f, -0.02478656f, 0.04161687f, -0.01155748f, -0.03485474f, 0.02052704f, -0.01978969f, -0.01871529f, 
    -0.01661193f, 0.00070538f, 0.00488809f, -0.03283756f, -0.04249507f, -0.01356036f, 0.01650892f, -0.04147108f, 
    0.02948578f, -0.01619131f, -0.04580560f, -0.00045928f, -0.04773320f, 0.02242529f, -0.01046641f, 0.04444214f, 
    -0.02249446f, -0.04031794f, 0.00480488f, -0.04143655f, 0.00520413f, 0.00605888f, -0.05246034f, -0.01519251f, 
    0.02475791f, 0.00307451f, 0.03275258f, 0.00891453f, 0.00552066f, 0.00598962f, -0.01784968f, 0.03021058f, 
    0.01181011f, -0.04497968f, -0.05188983f, -0.05546074f, -0.03555410f, -0.04708446f, -0.00802923f, -0.05532684f, 
    -0.02994177f, -0.02764238f, -0.00514941f, 0.02273771f, 0.01959960f, -0.03297452f, 0.00834960f, 0.00057085f, 
    0.00187870f, -0.03721149f, 0.03780646f, -0.00271052f, -0.04128229f, 0.00626827f, 0.01868203f, 0.02637853f, 
    0.01986239f, -0.04693473f, 0.02621509f, 0.02438694f, 0.00543354f, 0.03977284f, 0.01436581f, 0.01232331f, 
    -0.02618877f, -0.04120567f, -0.05142338f, -0.01067004f, 0.00373864f, -0.02295959f, -0.02921620f, -0.05425910f, 
    -0.04713391f, -0.04223036f, 0.03051567f, 0.04022718f, 0.02206517f, 0.01896132f, -0.00425630f, 0.02486462f, 
    0.02457232f, -0.01330537f, 0.00724801f, -0.00056274f, 0.02743820f, -0.04631307f, 0.03949514f, 0.03813773f, 
    0.02193616f, -0.04533889f, -0.00843867f, -0.00593182f, -0.03759900f, 0.04243305f, -0.04035627f, 0.01489285f, 
    -0.00101340f, -0.00563327f, -0.00236144f, 0.02350082f, 0.00932378f, 0.03761492f, 0.01033276f, -0.05059318f, 
    -0.03578429f, -0.04155395f, -0.01551946f, 0.03536447f, -0.00469368f, -0.04623789f, 0.02976980f, -0.03000434f, 
    -0.02436805f, 0.03229549f, 0.03650726f, -0.01585525f, -0.05779614f, -0.04123020f, -0.00342896f, 0.00953403f, 
    -0.00495990f, -0.05237010f, -0.03785248f, 0.02395676f, 0.00297398f, 0.00410007f, 0.02230234f, -0.05516217f, 
    -0.01585138f, -0.02935692f, 0.00206445f, -0.05211820f, 0.02846747f, -0.04423678f, -0.02670094f, -0.01560991f, 
    0.02970005f, 0.01854909f, 0.00028340f, 0.02875020f, -0.05397258f, -0.02530696f, -0.00917501f, 0.03989520f, 
    0.01710315f, -0.05345506f, -0.02188630f, 0.00629680f, -0.02589409f, 0.04180123f, -0.04533084f, -0.00322966f, 
    -0.03980628f, 0.03533483f, -0.04896825f, -0.05192749f, 0.03256036f, -0.04553553f, 0.04001014f, 0.01114188f, 
    -0.01487094f, -0.01925925f, -0.02050549f, -0.04878903f, 0.03152184f, -0.03945333f, 0.00897564f, 0.02316650f, 
    -0.00109945f, -0.01645266f, -0.01721370f, 0.01363089f, -0.01346535f, -0.00475961f, -0.04978059f, -0.03730587f, 
    0.04037255f, -0.01532292f, 0.02944862f, -0.04891984f, 0.01323471f, -0.02939751f, 0.02295762f, -0.02846081f, 
    -0.02159073f, -0.01513814f, -0.00569242f, -0.00897481f, 0.02317213f, -0.02691359f, -0.00083968f, -0.05211385f, 
    0.02058760f, -0.03618877f, 0.03256447f, -0.01682586f, 0.00527382f, 0.00931806f, -0.01558118f, -0.03336441f, 
    -0.04986277f, 0.00900509f, -0.04671912f, -0.03471017f, 0.00961402f, -0.04564375f, -0.04608192f, 0.03681761f, 
    0.03939263f, 0.00091810f, 0.04836944f, 0.02952268f, -0.02074785f, -0.01618391f, -0.04981003f, -0.00701934f, 
    0.01023134f, -0.02576045f, 0.01944523f, -0.05070743f, -0.00854254f, 0.03821134f, -0.03378648f, 0.03540892f, 
    0.04276764f, -0.01812545f, -0.04492680f, -0.00482045f, -0.02763970f, -0.03976001f, 0.01330704f, -0.04389471f, 
    -0.03319714f, -0.04592333f, 0.01029873f, -0.00478893f, 0.02496491f, 0.04506500f, -0.00724545f, 0.03954531f, 
    0.01279277f, -0.00332053f, -0.05017338f, 0.01218191f, -0.01199658f, -0.05867030f, -0.03406056f, -0.02493444f, 
    -0.05027720f, -0.04641913f, 0.01975821f, -0.02353383f, -0.00556603f, 0.01885753f, -0.02022779f, 0.02777771f, 
    -0.02887916f, 0.01505784f, 0.01680848f, -0.00934468f, -0.01327699f, 0.00413872f, -0.00887587f, -0.01037762f, 
    0.00641844f, -0.04366835f, 0.02716197f, 0.02747175f, 0.00516859f, -0.00041031f, -0.03897483f, -0.03840131f, 
    0.00932738f, 0.02365886f, -0.05589638f, 0.00377657f, 0.03345525f, 0.01050736f, 0.01989809f, -0.00983677f, 
    0.00771860f, 0.04287923f, 0.03719600f, 0.02171057f, -0.04740718f, 0.02676467f, -0.02688764f, -0.02115595f, 
    -0.00915102f, 0.01890480f, 0.02871014f, -0.03718108f, -0.03970872f, -0.05942765f, 0.01834822f, 0.04063859f, 
    -0.03044347f, 0.02935119f, 0.02019936f, -0.04431762f, -0.00311379f, 0.01332924f, -0.03606241f, -0.05470460f, 
    -0.02943479f, 0.01430050f, -0.02226242f, 0.03643376f, -0.01007078f, -0.02496069f, 0.02115914f, -0.00820618f, 
    0.04734722f, -0.02873508f, -0.00652115f, -0.00792138f, 0.02037574f, -0.01355614f, -0.05243632f, -0.01713219f, 
    0.00167941f, 0.00312526f, 0.02219320f, 0.00833323f, 0.03961824f, -0.00479049f, -0.00432583f, -0.01715471f, 
    0.00578867f, 0.00605554f, -0.01956515f, -0.02222738f, -0.00225436f, -0.03892052f, -0.01392580f, -0.02794169f, 
    0.01610143f, -0.05116174f, 0.02555634f, -0.03284508f, -0.00004754f, 0.04124400f, 0.03371765f, 0.04301191f, 
    -0.01239034f, -0.03417214f, 0.00130608f, -0.00665469f, 0.02575309f, -0.04941750f, 0.01108673f, -0.04235031f, 
    0.02171958f, 0.18802699f, 0.01543468f, 0.10975721f, -0.01076103f, 0.02334009f, 0.01779024f, 0.08277991f, 
    0.01611410f, 0.07639854f, 0.01162525f, 0.02980686f, -0.37664226f, 0.01599833f, 0.18720470f, 0.02108766f, 
    -0.09100787f, 0.01677666f, 0.01593359f, 0.09049531f, 0.08885265f, 0.02955643f, -0.07129877f, 0.04006010f, 
    0.01509817f, 0.02114535f, 0.18538225f, 0.03041923f, 0.07985118f, -0.00180210f, 0.01860710f, 0.01730251f, 
    0.02598590f, -0.06749797f, -0.04699955f, 0.13597894f, 0.06712718f, -0.02548627f, -0.03397836f, 0.07499766f, 
    0.03912058f, 0.07045231f, -0.04828016f, 0.10018032f, -0.03097751f, -0.09321456f, 0.01568672f, 0.07411775f, 
    -0.03673169f, 0.13032603f, -0.07716149f, -0.07243511f, -0.00277767f, 0.00103596f, 0.06827427f, 0.00955576f, 
    -0.15793850f, -0.13934629f, -0.18004303f, 0.05045516f, 0.06551494f, -0.04747311f, 0.02614214f, -0.13995047f, 
    0.03096271f, 0.11711659f, -0.04662816f, -0.08702856f, 0.02838249f, 0.01866820f, 0.07588752f, 0.05873510f, 
    0.36929291f, -0.01409685f, 0.24095386f, -0.08104851f, 0.03435367f, 0.08715522f, 0.03949212f, 0.11072489f, 
    -0.09577167f, 0.16427377f, 0.03727113f, -0.00631064f, -0.05046573f, 0.14892825f, 0.17941263f, 0.06868171f, 
    -0.12578049f, -0.14186071f, -0.04493126f, 0.03461287f, 0.01790836f, 0.04103418f, -0.14182071f, 0.01785125f, 
    0.02402237f, 0.06656716f, 0.07212988f, -0.00979726f, -0.10046548f, 0.08586339f, 0.11638246f, 0.00975729f, 
    -0.14190473f, 0.05657834f, -0.01686883f, 0.05424648f, -0.13526256f, -0.28956828f, 0.15694484f, -0.04056694f, 
    -0.07513110f, -0.04286475f, -0.00494935f, -0.00858173f, 0.07211869f, -0.12793484f, 0.05299864f, 0.03027406f, 
    -0.06384192f, 0.02571956f, -0.16058911f, -0.09514365f, -0.05883930f, 0.09353227f, 0.02317537f, 0.01566813f, 
    0.03241196f, 0.15406439f, 0.00645195f, -0.02963505f, 0.09737110f, -0.00278265f, 0.02786093f, 0.24339409f, 
    0.04417271f, 0.02870111f, -0.01879146f, -0.05653734f, 0.00897129f, 0.09281480f, 0.06401380f, -0.16784395f, 
    -0.35687554f, 0.04255402f, 0.14036998f, 0.14481995f, -0.06696413f, -0.11379860f, 0.06310960f, 0.18556203f, 
    -0.00237988f, 0.10006651f, 0.06720521f, -0.02299506f, -0.01377732f, 0.06874935f, 0.07474907f, 0.01707043f, 
    -0.02518790f, 0.01253730f, -0.09627911f, 0.03122536f, -0.01343254f, -0.10890017f, 0.07418133f, -0.06831677f, 
    -0.11040565f, 0.17565468f, 0.02505857f, -0.02040417f, -0.04060652f, 0.04098658f, -0.02090721f, 0.04913306f, 
    -0.02615000f, 0.03340738f, 0.06039082f, 0.03246414f, 0.18087605f, 0.09403139f, -0.05670772f, 0.00388677f, 
    -0.07225935f, 0.12763627f, -0.00516299f, 0.06337778f, 0.01647895f, 0.05438265f, 0.06518555f, 0.03050517f, 
    -0.07866676f, -0.14089337f, 0.03449849f, 0.22032353f, -0.04047016f, 0.00770896f, 0.05595709f, 0.06571323f, 
    -0.07138743f, 0.05450127f, -0.10998067f, -0.01009756f, 0.18327624f, 0.17402455f, 0.02095566f, -0.05321027f, 
    -0.00309149f, 0.03394740f, 0.06274646f, -0.01450932f, 0.01903890f, -0.07690191f, -0.09266371f, -0.02803967f, 
    0.08360527f, -0.00418208f, 0.13472541f, 0.13659216f, -0.06326469f, 0.06144258f, 0.03226462f, 0.02154627f, 
    -0.05311418f, 0.04129102f, 0.04805220f, 0.16679063f, 0.20367859f, -0.07792287f, 0.22535267f, -0.05528805f, 
    -0.05312900f, -0.01689808f, -0.01319904f, 0.09139346f, 0.03184304f, -0.11279989f, -0.03643117f, -0.02598714f, 
    0.05686272f, -0.02888985f, 0.10540775f, 0.07452214f, 0.09378745f, 0.03005639f, -0.03123453f, -0.00359719f, 
    -0.01502718f, -0.04577095f, 0.07711359f, 0.03985899f, 0.02126934f, 0.00337277f, 0.14834890f, -0.07893895f, 
    -0.20159481f, -0.09158505f, -0.03964553f, 0.01594668f, -0.08337786f, 0.06200942f, 0.00056609f, 0.04116998f, 
    0.04279136f, 0.10280377f, -0.13568449f, 0.01299202f, 0.04870330f, -0.03090004f, 0.04433158f, -0.07578739f, 
    0.08498368f, 0.01494104f, -0.16330002f, -0.01940182f, 0.10383874f, 0.02706531f, 0.04547338f, -0.12641862f, 
    -0.14948651f, 0.03411572f, -0.02231041f, 0.02340544f, -0.05382242f, -0.08656357f, 0.04695141f, -0.04507328f, 
    -0.18737175f, -0.02394086f, -0.10047138f, 0.06937581f, 0.08054630f, 0.00891174f, 0.12172394f, -0.02192571f, 
    0.03588510f, 0.01600754f, -0.10676405f, -0.01223000f, -0.34217298f, 0.02402143f, 0.13683049f, -0.02617389f, 
    0.09095551f, -0.05754683f, 0.02605633f, -0.08161654f, 0.08669095f, 0.00668534f, 0.07105152f, -0.00910937f, 
    0.09825333f, 0.00293335f, -0.10864185f, -0.05052327f, -0.07474904f, 0.07090687f, 0.03322274f, -0.04165418f, 
    0.01936895f, -0.17278184f, 0.07988178f, 0.12938547f, 0.04954897f, -0.03437256f, -0.12095316f, 0.04729245f, 
    0.02999022f, 0.02399367f, 0.00330875f, -0.05966403f, -0.00791919f, 0.12353870f, 0.01155855f, 0.07043722f, 
    -0.16598292f, -0.13929112f, -0.01159641f, 0.07287209f, 0.07161011f, 0.06246740f, -0.01431831f, -0.01239360f, 
    0.06624454f, -0.05006198f, -0.02420345f, -0.00430332f, -0.13028139f, 0.23246562f, 0.11117495f, -0.10155509f, 
    -0.12877288f, -0.02208479f, 0.12062746f, 0.00423618f, 0.04763920f, 0.10141390f, 0.04641518f, -0.04408053f, 
    -0.02899568f, 0.09039228f, -0.02993046f, 0.12601839f, -0.07967587f, 0.05547025f, 0.13986498f, 0.05575557f, 
    0.03045312f, 0.01435291f, 0.16615200f, 0.06908731f, 0.10748735f, -0.13294348f, 0.09751941f, 0.00162630f, 
    0.03701583f, 0.06756913f, -0.05866197f, 0.07893297f, -0.00402282f, -0.02531685f, 0.04122676f, -0.01550833f, 
    0.12997313f, -0.08604304f, 0.05446688f, -0.09551995f, 0.03897914f, 0.10377356f, 0.05302085f, -0.02992950f, 
    0.00294643f, 0.02788589f, -0.02744278f, 0.01228298f, 0.17858395f, 0.21022910f, 0.04843390f, 0.09728009f, 
    0.01421646f, 0.12639008f, -0.01904446f, 0.02738670f, -0.00724114f, 0.03709063f, 0.07324076f, -0.02032923f, 
    -0.12912533f, -0.04650722f, -0.03085770f, 0.07293272f, -0.04466975f, -0.07866195f, 0.02603825f, 0.10322164f, 
    -0.10351974f, 0.11309295f, 0.05074819f, -0.01194316f, -0.32216096f, -0.06454992f, -0.15824381f, -0.25501105f, 
    0.07411155f, -0.00058087f, 0.04704346f, 0.00754594f, 0.02907794f, 0.08650229f, 0.02944027f, -0.09210847f, 
    -0.09724432f, -0.09930734f, 0.17654265f, 0.12794966f, -0.00651801f, 0.06771250f, -0.01561770f, 0.01198593f, 
    0.13405995f, 0.04092519f, 0.11796916f, 0.04617953f, -0.28915662f, -0.01701574f, -0.03618073f, -0.01109303f, 
    0.06833694f, 0.03410006f, 0.06217408f, 0.09270126f, 0.07652162f, -0.05225894f, -0.03122205f, 0.03103152f, 
    0.05942984f, 0.16381751f, -0.19118698f, 0.14928713f, -0.03975540f, -0.03687060f, 0.02905878f, 0.00998210f, 
    -0.07257120f, -0.13559794f, -0.01599007f, -0.01895237f, 0.09237618f, 0.08506956f, 0.13106987f, -0.00037259f, 
    0.05904404f, 0.15507613f, -0.03047379f, 0.04757690f, -0.07531348f, -0.04511712f, -0.13269491f, -0.05005269f, 
    0.28738827f, 0.04111429f, 0.09042215f, -0.11128170f, 0.00079624f, -0.04193525f, -0.05614833f, 0.03863810f, 
    0.12218591f, -0.01662728f, 0.09298720f, 0.05209067f, -0.22487473f, 0.25538507f, -0.03106789f, -0.13552360f, 
    0.07953447f, -0.03391970f, -0.09715167f, 0.02788889f, -0.01244887f, 0.04784222f, 0.07413817f, 0.01209328f, 
    -0.45400724f, -0.18395907f, 0.19547728f, 0.21005610f, 0.03302107f, 0.10672776f, 0.03642844f, -0.02019515f, 
    0.04016081f, -0.08472963f, 0.03761880f, 0.07598972f, -0.10329311f, 0.16831125f, 0.05135258f, 0.03268507f, 
    0.04482414f, -0.13480029f, -0.01727515f, 0.08459720f, 0.08586189f, -0.04425857f, 0.10238540f, 0.07825841f, 
    0.19750640f, 0.08015531f, 0.13411517f, -0.10223439f, 0.00458544f, 0.05662439f, -0.23004259f, -0.04152508f, 
    0.03914913f, -0.05504680f, 0.11418586f, -0.01625434f, -0.02906840f, 0.09265065f, 0.03555155f, 0.03880414f, 
    0.07660520f, -0.02856126f, 0.11056770f, 0.01810073f, 0.02288278f, 0.00784432f, 0.01579512f, 0.13095121f, 
    -0.08045684f, -0.09112498f, -0.01742011f, 0.04377763f, 0.04197040f, -0.04288336f, 0.09029062f, -0.14646904f, 
    -0.01193858f, 0.11798656f, -0.05314439f, 0.05027535f, 0.02401339f, -0.05302540f, 0.05544029f, -0.04463324f, 
    0.11149160f, -0.06607552f, -0.03071295f, -0.10605884f, -0.06356716f, -0.07449293f, -0.08839776f, 0.14348066f, 
    -0.11119010f, 0.43260050f, 0.24048470f, 0.21300241f, -0.00885241f, -0.00802573f, -0.06442623f, -0.02782580f, 
    0.03258219f, -0.08619573f, -0.00079144f, 0.06911812f, 0.02530846f, -0.14198247f, 0.07896555f, -0.03870079f, 
    -0.11146195f, -0.08428299f, -0.00866417f, 0.01206360f, -0.01548905f, 0.08542162f, 0.11046817f, -0.02389433f, 
    0.00688968f, -0.10936039f, 0.06005479f, -0.01139811f, 0.04157426f, 0.07577763f, -0.03851323f, -0.05912656f, 
    -0.02109078f, 0.02725051f, 0.06453159f, 0.04598428f, 0.06212305f, 0.10972562f, -0.08363780f, 0.07713766f, 
    -0.07509352f, 0.02194938f, 0.11931135f, 0.01182694f, 0.00782481f, 0.05177042f, 0.08082148f, 0.03872757f, 
    -0.01806236f, -0.25736374f, -0.11471242f, 0.01610607f, -0.07998437f, -0.03562156f, 0.02012644f, 0.06965578f, 
    -0.04789403f, -0.08702500f, -0.04204489f, 0.02110030f, -0.07667539f, 0.19884242f, 0.06093676f, 0.03507754f, 
    0.11421691f, 0.06992797f, -0.00239203f, -0.04675816f, 0.16897754f, 0.14597411f, 0.01597384f, -0.00306616f, 
    -0.05841280f, -0.19852637f, -0.02477578f, -0.14355177f, 0.08005363f, 0.04915953f, 0.01090403f, 0.04440711f, 
    -0.02551048f, 0.10567565f, 0.00494040f, 0.08178447f, 0.07923042f, 0.16534446f, -0.05542080f, -0.15103687f, 
    -0.01549423f, 0.02921802f, 0.11865943f, 0.02807363f, 0.05932793f, 0.04421202f, -0.02863172f, -0.04544283f, 
    0.04085433f, -0.24217322f, 0.31830737f, 0.09048352f, -0.05295263f, -0.00991995f, 0.04073667f, 0.02342849f, 
    0.03529707f, 0.01013482f, 0.06145049f, -0.05691691f, 0.32981649f, -0.18833101f, 0.03032580f, 0.09920276f, 
    0.05431488f, 0.00112712f, -0.05270791f, 0.02379596f, -0.08248015f, 0.04652169f, 0.05054923f, -0.03626588f, 
    -0.52494264f, 0.13544765f, -0.05928495f, -0.18014705f, 0.04470510f, 0.06163156f, 0.00478262f, -0.03708462f, 
    -0.03321961f, 0.05509682f, 0.01738550f, -0.09758981f, -0.04310166f, -0.00366772f, -0.05559584f, 0.01420595f, 
    0.13627079f, 0.19617870f, -0.00698987f, 0.03505246f, 0.09579503f, 0.05572853f, -0.04631446f, 0.00357526f, 
    0.31344965f, 0.09571179f, -0.27653629f, -0.15349168f, 0.11438601f, -0.00058748f, -0.03066945f, -0.08090325f, 
    -0.12611841f, -0.02842796f, -0.03771022f, 0.06757966f, 0.22099662f, 0.12477442f, 0.08123507f, -0.20999041f, 
    -0.08251258f, -0.16172309f, -0.02130729f, 0.02588522f, 0.13946113f, -0.01266448f, 0.01419181f, 0.07641967f, 
    -0.03428179f, -0.02625404f, 0.00270171f, 0.01031465f, -0.02324333f, -0.05463072f, -0.01522315f, -0.05241599f, 
    -0.10200628f, -0.07515582f, 0.14384441f, -0.03835911f, -0.12050061f, 0.03110835f, 0.03311829f, -0.00196357f, 
    -0.06373667f, 0.02850186f, -0.04646175f, 0.02620600f, 0.05772502f, 0.09833869f, 0.04266090f, -0.02851692f, 
    0.06671162f, 0.09429393f, 0.24999601f, -0.10889251f, 0.02733298f, 0.11002509f, -0.10010917f, 0.19972824f, 
    0.14196993f, 0.02532011f, -0.01905742f, 0.00989719f, 0.41082066f, -0.01583312f, -0.04299252f, -0.01132407f, 
    -0.07889887f, -0.06478520f, 0.07149535f, 0.00458454f, -0.05107526f, -0.02382294f, -0.02551274f, 0.02601509f, 
    -0.21910042f, -0.05135009f, -0.05185886f, -0.09263927f, -0.00663140f, -0.07937720f, 0.03248111f, -0.01651754f, 
    -0.05927349f, -0.04697052f, 0.10043664f, -0.00801892f, -0.24900343f, 0.03782098f, 0.04961016f, 0.09972008f, 
    0.09024809f, 0.10241974f, -0.07258590f, -0.05187726f, 0.14889500f, 0.07995535f, -0.06635521f, 0.07633029f, 
    -0.00943297f, 0.03908028f, -0.02433014f, -0.10416844f, -0.06065033f, -0.01073149f, 0.09704377f, -0.07579555f, 
    -0.01045473f, -0.02279842f, -0.04323906f, -0.03108435f, -0.19917075f, 0.39389029f, 0.09109330f, -0.04560967f, 
    -0.04698459f, 0.11337183f, -0.05352835f, -0.03053528f, 0.10118375f, 0.02149997f, -0.00781448f, 0.00598669f, 
    0.19258684f, 0.10950040f, 0.21995381f, 0.25732094f, -0.07978460f, -0.02268801f, -0.02421722f, 0.04659351f, 
    0.03714554f, -0.01868269f, -0.02900974f, -0.04401568f, 0.39192489f, 0.16288179f, -0.06918772f, 0.11195617f, 
    -0.03873424f, -0.04734306f, -0.05360808f, 0.05384270f, -0.04582882f, 0.03312429f, 0.06776163f, 0.01779002f, 
    0.34715059f, 0.09048053f, -0.04364510f, 0.13209309f, 0.04968183f, 0.04042532f, 0.10473061f, -0.01200827f, 
    -0.04603966f, -0.02692842f, 0.00198389f, 0.00004077f, 0.07024801f, 0.07692590f, 0.10326590f, -0.14154053f, 
    -0.03278248f, -0.09759779f, 0.02359838f, -0.11459967f, -0.09966455f, -0.02384160f, -0.13992788f, -0.01641646f, 
    -0.18506916f, -0.24657300f, 0.22912082f, 0.17380896f, -0.12077170f, 0.10003844f, 0.04548460f, -0.05071413f, 
    0.02427837f, 0.00606616f, -0.04633120f, 0.02038472f, -0.04085379f, -0.00887118f, -0.28104421f, -0.05498303f, 
    -0.02061590f, -0.02685607f, 0.07953931f, -0.06148221f, 0.03191976f, 0.01890018f, -0.05455541f, -0.06674346f, 
    0.02766304f, 0.19465619f, -0.06959316f, -0.08340039f, -0.03777692f, -0.01704577f, 0.19080555f, 0.13075428f, 
    0.11540830f, 0.01934475f, -0.01039068f, -0.06365713f, -0.15226167f, -0.20809092f, -0.05116725f, -0.00908319f, 
    -0.00336753f, 0.09112499f, 0.00442985f, 0.03452458f, 0.00738798f, 0.01440076f, 0.11680084f, -0.00876040f, 
    0.10124260f, 0.00749537f, 0.15708615f, 0.04498146f, -0.03055047f, -0.04231172f, -0.06410554f, 0.03810885f, 
    -0.12192291f, -0.00528391f, -0.00353967f, -0.14299375f, -0.07655947f, 0.04973670f, -0.02473036f, 0.12900978f, 
    -0.14185561f, -0.04338340f, 0.08768156f, 0.05240265f, -0.04432747f, 0.08340672f, 0.00827583f, -0.06769792f, 
    0.29997292f, 0.19618498f, -0.30235016f, -0.18065196f, -0.12554771f, -0.06920727f, -0.01029403f, -0.01631229f, 
    -0.06757724f, -0.03227164f, 0.09414181f, 0.00402919f, -0.15964597f, -0.19151460f, 0.09662779f, -0.02991725f, 
    0.01673790f, -0.05328400f, -0.11537171f, -0.10972198f, 0.01355015f, -0.10900101f, -0.02115745f, -0.08756030f, 
    0.33346590f, 0.10907175f, 0.05686214f, 0.16772640f, -0.14448094f, 0.04376609f, -0.01451198f, -0.04503697f, 
    -0.04953289f, -0.12591529f, 0.00032856f, -0.06319974f, -0.12255432f, -0.18531042f, 0.10836922f, -0.09180917f, 
    -0.05041896f, 0.00752453f, -0.02409117f, 0.06570456f, 0.05049448f, 0.03566449f, -0.00963006f, -0.06738423f, 
    -0.14817455f, 0.08245170f, -0.08915002f, -0.02485691f, 0.00115195f, -0.07750049f, -0.02119086f, 0.12111545f, 
    -0.00914316f, -0.04246951f, 0.13324514f, -0.03551278f, 0.35573226f, -0.08428443f, 0.21673980f, 0.13037358f, 
    0.01861007f, 0.12984672f, 0.04696177f, 0.01029516f, -0.01236457f, 0.01507755f, 0.07133137f, 0.01402076f, 
    0.06719744f, 0.15367569f, -0.00900242f, 0.05845736f, 0.05678912f, 0.15579154f, 0.10024637f, 0.02222478f, 
    -0.02721799f, -0.04683716f, 0.04340688f, -0.07634973f, 0.28341520f, -0.07426672f, 0.25694066f, 0.30332103f, 
    -0.08449778f, 0.03928586f, 0.04499210f, -0.03323879f, 0.08201204f, 0.01832532f, -0.06841846f, 0.16207102f, 
    0.05987313f, 0.20658371f, 0.07675770f, 0.13581438f, 0.09105518f, 0.03158743f, -0.02994577f, -0.19303060f, 
    0.01191172f, 0.03278076f, -0.01418878f, -0.04844299f, 0.09490446f, 0.14154862f, -0.10071407f, 0.19343355f, 
    -0.07968973f, -0.06912629f, 0.03068288f, -0.08263329f, -0.01829176f, 0.02277257f, -0.00436289f, -0.09473904f, 
    -0.15479548f, 0.14716716f, 0.10571394f, 0.01615166f, -0.02370632f, -0.03264579f, -0.06785249f, 0.01322458f, 
    -0.00482397f, -0.00003248f, -0.03979864f, 0.03413646f, -0.05867071f, 0.05903178f, 0.32038224f, -0.22692221f, 
    -0.03094883f, 0.02516810f, 0.16451523f, -0.06216412f, -0.03351412f, -0.01255627f, -0.02189264f, -0.00245114f, 
    0.20923997f, 0.05877972f, -0.00465251f, -0.15944715f, 0.00717858f, -0.11218819f, -0.09760723f, -0.12504499f, 
    -0.03551472f, 0.09869090f, 0.02804357f, -0.05791917f, 0.15866111f, 0.11687190f, 0.04120317f, 0.22561541f, 
    -0.07370878f, 0.03629240f, 0.08712946f, -0.05668619f, -0.00691305f, 0.09232828f, 0.00078999f, 0.14986582f, 
    -0.06578485f, 0.07034280f, -0.00961579f, -0.01361075f, 0.07681273f, 0.05782120f, 0.05669511f, 0.05037041f, 
    0.00836857f, 0.00556034f, -0.05588345f, -0.02149779f, -0.02684917f, 0.24112189f, 0.05197096f, -0.31245467f, 
    -0.13813855f, 0.18038368f, -0.01133821f, 0.01254431f, 0.05508601f, -0.06733453f, -0.14588095f, -0.01184467f, 
    -0.27524322f, -0.27572817f, 0.03196337f, -0.02770948f, -0.02139937f, -0.02465190f, 0.16251844f, -0.03123587f, 
    -0.13468254f, -0.03257863f, -0.01426348f, 0.13703971f, -0.01308924f, 0.31865260f, 0.11435665f, 0.02854228f, 
    0.14238000f, 0.10700528f, 0.02863772f, -0.05947134f, 0.03141250f, -0.01956281f, -0.00310017f, -0.12830222f, 
    -0.09462853f, 0.01048039f, -0.24934864f, -0.12978534f, -0.01573055f, -0.00188369f, -0.02427982f, 0.03876617f, 
    0.04504387f, 0.00323792f, -0.04284249f, -0.06143505f, 0.04105324f, -0.30608106f, 0.17537953f, 0.06644379f, 
    -0.07707945f, 0.09360874f, 0.09074030f, 0.01108788f, -0.07464226f, -0.02548326f, 0.07439087f, -0.07187612f, 
    -0.10053513f, -0.02680067f, -0.07218213f, 0.00070368f, 0.03325852f, 0.02629591f, -0.00476398f, 0.10569282f, 
    -0.07853208f, 0.17161453f, 0.05053740f, -0.02853755f, 0.29570851f, -0.33347139f, 0.15136011f, 0.23464720f, 
    -0.08424014f, -0.10147592f, 0.04126243f, -0.06592257f, 0.02748295f, -0.03329623f, 0.07091576f, -0.00486087f, 
    -0.22529276f, 0.19226803f, -0.05019996f, 0.00194603f, 0.14162190f, 0.05766150f, 0.01731681f, -0.00194230f, 
    0.01823891f, 0.00226758f, 0.04188723f, 0.02270475f, -0.08021991f, 0.09557518f, 0.04752266f, 0.05628047f, 
    0.30903801f, 0.15017144f, 0.03649711f, -0.05762475f, 0.04860711f, -0.06061362f, 0.01914006f, 0.12132932f, 
    0.09537956f, 0.01088261f, 0.08314337f, -0.10876258f, 0.07928365f, -0.01876881f, -0.10414758f, -0.07674117f, 
    0.04731904f, 0.08252169f, 0.11903116f, -0.03233984f, -0.02791200f, 0.13761738f, -0.05471700f, 0.28067100f, 
    0.00980110f, 0.03590046f, 0.05522102f, 0.18678224f, 0.03122456f, 0.07871079f, 0.19273444f, -0.01448380f, 
    0.30134892f, -0.02308451f, -0.24785013f, -0.01219479f, 0.09773017f, -0.11233065f, -0.03898009f, 0.00779059f, 
    -0.06437857f, -0.02666376f, 0.02696270f, -0.07455379f, 0.23140433f, -0.14747636f, 0.04046005f, -0.46871296f, 
    -0.01105966f, 0.12375257f, -0.12898163f, 0.18935469f, 0.05033745f, 0.05690201f, -0.02495611f, 0.08809868f, 
    0.14238879f, 0.15052244f, 0.00695633f, 0.10252876f, 0.16237511f, 0.15133893f, -0.05489118f, -0.13587943f, 
    -0.17295097f, 0.09306937f, 0.02298426f, 0.01093778f, -0.20099339f, 0.22999537f, -0.14991112f, -0.13780211f, 
    0.09085482f, -0.04089804f, -0.04298291f, 0.02496740f, -0.08514603f, 0.01622986f, -0.12924631f, -0.12312064f, 
    0.14295253f, 0.02198152f, 0.23636949f, -0.18315408f, 0.05083796f, 0.05012057f, 0.06156659f, -0.07895314f, 
    0.12955187f, 0.00178700f, 0.00127680f, 0.06597620f, 0.33529037f, -0.22623296f, 0.06785639f, 0.06822255f, 
    0.09522235f, 0.01236285f, 0.02914385f, -0.04462600f, -0.02359679f, -0.00195727f, 0.02463607f, 0.05525606f, 
    -0.20882306f, 0.10944130f, 0.10151066f, 0.10060551f, 0.11668362f, -0.03134030f, 0.10856807f, -0.10645968f, 
    0.06433783f, 0.05543625f, 0.01526060f, -0.08476131f, 0.14976245f, -0.15664057f, -0.10983192f, 0.05253320f, 
    0.01956864f, -0.01173627f, -0.01202753f, 0.01774702f, 0.00491690f, 0.06064053f, -0.03958694f, 0.08766578f, 
    0.07799239f, 0.00702713f, -0.03822115f, -0.03165959f, 0.04257881f, -0.06439874f, 0.05532290f, 0.10693505f, 
    0.06144761f, 0.09334537f, 0.08031102f, 0.03992995f, -0.14559436f, 0.09629734f, -0.37107560f, -0.01227479f, 
    -0.04364705f, -0.05881671f, 0.04044580f, -0.16964644f, -0.08166355f, 0.13742079f, 0.08154108f, 0.02285345f, 
    0.02613824f, -0.15224047f, -0.08354755f, -0.08222530f, 0.00766538f, -0.00601365f, 0.04997368f, -0.07214053f, 
    -0.09621182f, 0.02689341f, -0.15172420f, 0.03191854f, 0.05061089f, 0.24744992f, 0.03484259f, 0.06075292f, 
    0.06738237f, 0.00346849f, 0.01412960f, -0.01361943f, -0.09747894f, 0.10569478f, -0.02243272f, -0.07026420f, 
    -0.08129638f, -0.04202976f, 0.15186974f, 0.13028361f, -0.02767337f, -0.02462238f, -0.03037480f, -0.02860578f, 
    -0.15539871f, 0.07161548f, 0.10109549f, -0.00548731f, -0.16904609f, 0.27346969f, -0.03652956f, -0.05761745f, 
    0.17418909f, 0.02053682f, -0.01700014f, -0.06869297f, 0.01793093f, -0.03179301f, -0.04619599f, -0.05599260f, 
    -0.07929216f, -0.13466927f, -0.16525435f, 0.16647618f, -0.03244496f, 0.04319163f, 0.03823537f, 0.07966018f, 
    -0.13357478f, -0.03303247f, 0.07665274f, 0.14032482f, 0.48945555f, -0.31123665f, -0.03769744f, -0.15254813f, 
    0.01860817f, 0.14174052f, 0.00161554f, -0.07891867f, 0.05480810f, 0.01248723f, 0.01363226f, 0.09562621f, 
    0.24986194f, -0.11174639f, 0.16875172f, -0.12659419f, 0.06074689f, -0.03282867f, 0.01737897f, 0.05875367f, 
    -0.02538396f, 0.04356626f, 0.09085395f, -0.04599521f, 0.10251543f, -0.16742611f, 0.05948274f, 0.18366778f, 
    0.05104091f, -0.03826511f, -0.13222127f, 0.03595098f, 0.09299938f, -0.00089752f, -0.01179060f, -0.00568990f, 
    -0.12477052f, 0.47039482f, -0.05319100f, 0.32411176f, -0.07669289f, 0.05704831f, 0.07620595f, 0.22508115f, 
    0.03826100f, -0.03385041f, 0.14962561f, 0.10837562f, -0.05817186f, 0.07371908f, -0.08936819f, 0.00368445f, 
    0.12166034f, 0.01053000f, -0.08881148f, -0.02680930f, 0.00203841f, 0.00004737f, -0.08420451f, 0.02062407f, 
    -0.08540897f, -0.08433552f, 0.04771490f, 0.05879524f, -0.01781970f, 0.04401083f, -0.04130581f, -0.03643498f, 
    -0.05719489f, -0.08550044f, 0.01495575f, 0.02812352f, 0.07714112f, -0.26026899f, -0.16593193f, 0.26300153f, 
    0.05856919f, -0.03032481f, -0.09490918f, -0.02197699f, -0.08142524f, -0.05638709f, 0.12242883f, 0.11089376f, 
    -0.42681995f, -0.08317094f, -0.02820181f, 0.01341637f, 0.07464208f, -0.11798694f, -0.00214560f, -0.11545803f, 
    -0.01325259f, 0.12449858f, 0.03206046f, 0.02044033f, -0.16283007f, 0.15810102f, 0.06610397f, -0.02580896f, 
    0.09035241f, 0.00608515f, 0.15063344f, -0.04977276f, -0.03770979f, 0.01273488f, -0.01421077f, 0.05322026f, 
    -0.02538081f, 0.05639269f, -0.06517576f, -0.14406693f, -0.03708475f, 0.06239091f, 0.02892618f, 0.03420670f, 
    0.16933988f, 0.00002331f, 0.09785799f, 0.02598294f, 0.01460868f, -0.15133826f, 0.02665450f, 0.27741390f, 
    -0.01657206f, 0.07701078f, 0.07447024f, -0.03006574f, 0.00996483f, -0.17084944f, 0.01581954f, 0.17464243f, 
    -0.12494281f, 0.01260263f, -0.04112675f, -0.09953023f, 0.08474520f, -0.02429152f, -0.08145461f, 0.16434276f, 
    -0.03124114f, 0.02240204f, -0.06464212f, -0.17132749f, 0.45785940f, -0.23361991f, 0.04292099f, 0.19748393f, 
    -0.08905669f, -0.03451588f, -0.08682290f, -0.04036865f, -0.03016333f, -0.03415411f, 0.03753074f, 0.00284440f, 
    0.05099819f, 0.18253514f, 0.01022676f, -0.06114918f, 0.03847871f, -0.04943898f, 0.07094260f, -0.00920405f, 
    0.06179883f, 0.20076193f, 0.02426711f, 0.19185409f, -0.08332689f, 0.05246488f, 0.09916496f, 0.11233033f, 
    0.14083409f, 0.07398183f, 0.10110032f, -0.02737699f, -0.01675544f, 0.05918578f, 0.05277294f, 0.01667215f, 
    -0.19532473f, -0.13208389f, 0.07138306f, 0.08575562f, 0.05958546f, -0.03240509f, 0.06633529f, 0.02360439f, 
    0.10343837f, 0.06488595f, -0.04127656f, 0.00231158f, 0.31038266f, -0.10443801f, -0.01181801f, 0.21050031f, 
    -0.03244168f, 0.06056123f, 0.05410026f, -0.02354806f, 0.03454078f, -0.06413575f, -0.06086798f, -0.08909206f, 
    0.16098408f, 0.05647112f, -0.29633206f, -0.30220836f, -0.00960808f, -0.09956707f, -0.00340892f, -0.05826464f, 
    0.00059173f, 0.10936574f, -0.00921429f, -0.03946908f, 0.02681206f, -0.06921095f, 0.05577078f, -0.40779194f, 
    -0.08081973f, 0.10086902f, -0.11229455f, 0.02317169f, -0.08689741f, 0.00154549f, 0.02991243f, -0.08851290f, 
    -0.03044704f, 0.07602527f, 0.00740543f, 0.22214846f, 0.06107481f, 0.11512528f, 0.14007540f, -0.03572743f, 
    -0.07766911f, -0.05384712f, -0.05972914f, 0.06264754f, -0.17228901f, 0.01156010f, -0.01477361f, -0.03116728f, 
    -0.10506489f, -0.03130842f, -0.03818404f, 0.04318994f, -0.05492615f, 0.04941220f, 0.09810539f, 0.05324004f, 
    0.02737694f, 0.01332829f, 0.01873972f, -0.06060911f, 0.07906843f, 0.08792324f, -0.11204203f, 0.03573954f, 
    0.17908089f, 0.04577444f, 0.00921426f, 0.02002810f, 0.31697896f, 0.03835079f, -0.01236986f, 0.10184213f, 
    0.12515366f, 0.07836302f, 0.00659198f, -0.01342975f, -0.07766362f, 0.03715358f, 0.15185386f, -0.14241864f, 
    -0.04247072f, -0.12514324f, 0.00600314f, -0.02476819f, 0.08867150f, 0.01562578f, 0.13359816f, 0.00238012f, 
    0.00246834f, -0.03131210f, 0.09888224f, -0.13482100f, 0.09163968f, -0.14471510f, -0.23704095f, -0.13267897f, 
    0.06818155f, 0.07736688f, -0.06415198f, 0.00117822f, 0.17522681f, -0.02869887f, -0.00866291f, 0.06851558f, 
    0.07765882f, 0.13734555f, 0.00394470f, 0.12393016f, -0.02346592f, -0.00689864f, 0.03247374f, 0.06083288f, 
    0.04745721f, 0.06413177f, 0.00907962f, -0.05061396f, 0.00442375f, 0.05588400f, -0.11469716f, -0.13244483f, 
    0.05957190f, 0.00812907f, 0.02311114f, 0.03491887f, 0.06521125f, -0.03935478f, 0.02084443f, -0.02202190f, 
    0.00212108f, -0.11988059f, 0.03671329f, -0.02143600f, 0.09357081f, -0.08636877f, 0.08995578f, -0.02658734f, 
    -0.10331228f, 0.08484036f, -0.01015142f, -0.03673270f, 0.17214108f, 0.15511966f, -0.03803102f, 0.13143003f, 
    0.01288276f, -0.05930871f, -0.07466323f, -0.00356669f, -0.10994556f, -0.18405698f, 0.06910083f, -0.03691452f, 
    -0.13997170f, -0.05356644f, 0.13749830f, 0.15355864f, -0.02844495f, -0.09490527f, 0.02458860f, 0.07677902f, 
    0.00544099f, -0.04055510f, 0.00180553f, 0.02910170f, -0.10034204f, 0.21111785f, 0.10158346f, -0.00736405f, 
    0.21384738f, -0.02765586f, -0.06071020f, 0.07790416f, -0.00546836f, 0.07415573f, 0.07921573f, 0.04852313f, 
    -0.01798004f, -0.15259349f, -0.28974536f, -0.05934069f, -0.09628975f, -0.03223267f, -0.10516680f, 0.13205892f, 
    -0.07054284f, 0.00410297f, 0.22617449f, -0.03040263f, -0.05906128f, -0.08059003f, -0.06824869f, -0.22530447f, 
    0.10682990f, 0.07013029f, 0.05729679f, -0.14065412f, 0.15389074f, 0.06514748f, -0.02349130f, 0.03920368f, 
    0.01340501f, -0.24390726f, -0.12497592f, 0.05421653f, 0.03386265f, -0.06714858f, 0.08015192f, 0.07337552f, 
    -0.00139555f, 0.04860914f, 0.04680464f, 0.00661004f, -0.05676192f, -0.12023100f, -0.03931728f, 0.05664327f, 
    -0.02491360f, -0.17175622f, -0.00594764f, 0.03647080f, 0.12767248f, 0.05087033f, 0.02495456f, 0.07760224f, 
    -0.03541864f, 0.13593265f, 0.17793271f, 0.29144785f, 0.05277055f, 0.03657654f, 0.06973843f, 0.10605495f, 
    0.27211401f, -0.08289229f, 0.00808260f, 0.10048078f, -0.24612629f, -0.03160607f, 0.05151968f, 0.07845940f, 
    0.18064709f, 0.10029384f, -0.04322185f, -0.04014285f, -0.12281251f, 0.02728717f, -0.08014726f, 0.02825223f, 
    -0.13466793f, -0.10833914f, 0.06742699f, -0.03419345f, 0.00753152f, -0.01595451f, -0.05407609f, 0.04318238f, 
    -0.00721023f, 0.07320389f, -0.07637050f, 0.14069135f, 0.31568733f, -0.15474731f, -0.08541756f, 0.05981260f, 
    0.08332386f, -0.01638264f, -0.03805522f, -0.01813792f, 0.02324492f, -0.05821791f, 0.02183461f, 0.06757306f, 
    -0.11775064f, -0.01943938f, 0.01219039f, -0.05497218f, 0.17154448f, 0.00443550f, -0.00350333f, 0.06845568f, 
    0.14608915f, -0.02308729f, -0.02749309f, 0.08949052f, 0.12978190f, 0.06848371f, 0.06218860f, -0.04215340f, 
    -0.04804768f, -0.14061704f, 0.04341701f, 0.04463203f, 0.03875123f, 0.04973466f, -0.02273134f, -0.03280844f, 
    -0.10388038f, -0.04696355f, 0.21147381f, -0.08458530f, -0.06286668f, -0.04371254f, 0.09555064f, -0.00923691f, 
    0.10703484f, -0.04098260f, -0.02085204f, 0.03608758f, 0.04842215f, -0.09422485f, -0.08550620f, 0.34223565f, 
    -0.07992636f, 0.07943484f, -0.06116450f, 0.13697429f, 0.08205461f, 0.03805373f, -0.04775239f, 0.09014508f, 
    0.00042786f, -0.03275767f, 0.05246440f, -0.16412574f, 0.07199672f, -0.04113169f, 0.01508002f, 0.01096154f, 
    0.09413268f, 0.01056889f, -0.05465883f, -0.03826999f, 0.15774219f, 0.22366957f, -0.07916993f, 0.07253171f, 
    -0.07775815f, -0.00201333f, -0.16670795f, -0.01725905f, -0.02073525f, -0.00228890f, 0.03777141f, -0.00070540f, 
    0.23733036f, 0.14111237f, -0.00492798f, 0.12100516f, -0.01129823f, 0.03146164f, 0.05489089f, 0.00672849f, 
    0.13884057f, -0.05224786f, 0.03915590f, 0.00004526f, 0.18008822f, -0.04632872f, 0.06117360f, 0.09920026f, 
    -0.06135355f, 0.00419840f, 0.05760207f, -0.09436297f, -0.01143113f, 0.02013071f, 0.08325796f, -0.00916785f, 
    -0.19543073f, -0.04598631f, 0.12807913f, 0.43047187f, -0.07652510f, -0.04903098f, 0.03249307f, -0.05326823f, 
    0.08157923f, -0.01810523f, 0.02834114f, -0.02614580f, 0.37862447f, -0.19794421f, 0.04914727f, 0.02707554f, 
    -0.12960209f, 0.01198136f, 0.10865213f, -0.09988941f, -0.06026060f, 0.02386855f, -0.00190455f, -0.11378466f, 
    0.07409433f, 0.09403290f, 0.06775465f, -0.39949197f, -0.01688261f, -0.02728230f, 0.00505758f, -0.08843683f, 
    0.02794535f, -0.01234116f, 0.00567776f, -0.00520596f, -0.16373798f, 0.04147224f, -0.25173447f, -0.24999836f, 
    -0.05687247f, 0.18956275f, -0.06584679f, 0.03276396f, -0.11522656f, -0.00920395f, -0.06547736f, 0.07939801f, 
    0.20804156f, 0.06826729f, 0.05028602f, -0.11421400f, -0.09269285f, -0.06208036f, 0.07154782f, -0.00641562f, 
    0.10780518f, -0.00262458f, -0.02149603f, -0.04835168f, -0.23506686f, -0.15113004f, 0.11105262f, 0.15697120f, 
    0.00527446f, 0.03160614f, 0.03049843f, 0.08786578f, 0.08928882f, 0.00180442f, -0.01827388f, -0.02567315f, 
    -0.27454236f, -0.00319746f, -0.02178681f, 0.09956471f, -0.01145471f, 0.02594387f, -0.00781297f, 0.07955834f, 
    0.02304596f, 0.04354976f, -0.02233766f, -0.02882627f, -0.14375471f, 0.15687285f, 0.02389493f, 0.19556315f, 
    -0.05163093f, -0.00758648f, 0.07927954f, 0.04024623f, -0.02128737f, 0.01271673f, 0.06780978f, 0.03170485f, 
    0.08689632f, -0.02356730f, 0.01206356f, -0.37635198f, -0.08753005f, 0.00566256f, 0.06830882f, -0.05527041f, 
    -0.05244311f, -0.06454416f, 0.05465242f, -0.04336558f, -0.15678741f, -0.06586958f, 0.04511439f, -0.08698875f, 
    0.10839311f, -0.00244724f, 0.04630272f, -0.00614681f, 0.08646483f, 0.04046906f, -0.04838501f, 0.07096014f, 
    0.06132982f, 0.20091823f, 0.05271562f, 0.15925558f, 0.05747280f, 0.05956965f, 0.04717828f, 0.08628599f, 
    0.04008900f, 0.12702329f, 0.14495701f, -0.05910549f, -0.16063420f, -0.02411426f, 0.24056624f, -0.18920548f, 
    0.14494719f, 0.06259327f, 0.04632924f, -0.06885845f, -0.02299369f, -0.02668944f, 0.01846047f, -0.05583829f, 
    -0.12989861f, -0.06561358f, 0.08998363f, -0.06993289f, -0.00519985f, -0.08930945f, 0.05523171f, 0.03457364f, 
    -0.02407062f, -0.00878895f, 0.05064845f, 0.00083317f, 0.35874510f, -0.11605859f, -0.03805193f, 0.17110941f, 
    0.01294369f, 0.03395773f, 0.02394017f, 0.04095564f, -0.05438602f, -0.07909681f, 0.05675123f, 0.03020906f, 
    0.04842836f, 0.05613095f, 0.05193866f, -0.00545506f, 0.13011400f, -0.00193821f, 0.03384933f, 0.15876082f, 
    0.06049207f, -0.06255663f, -0.01357407f, 0.08075853f, 0.12618722f, 0.04457146f, 0.02919166f, 0.21495533f, 
    0.06441864f, 0.03139200f, -0.05821669f, 0.09299865f, 0.01727813f, -0.04861839f, -0.04380537f, 0.04930172f, 
    0.53715265f, -0.03066858f, 0.02939479f, -0.34354404f, -0.19279292f, -0.06017828f, 0.10436190f, 0.09750213f, 
    -0.09853726f, -0.05428711f, 0.06627070f, -0.01897147f, -0.30137169f, 0.35147190f, 0.09078404f, -0.04963351f, 
    0.01951401f, 0.06657108f, 0.00760806f, -0.11171418f, 0.02405310f, -0.00209359f, -0.01498198f, -0.06539034f, 
    -0.20263083f, -0.14312524f, -0.06737503f, 0.10804511f, -0.00159143f, 0.01589074f, -0.05223903f, 0.15729994f, 
    -0.01016321f, -0.11856028f, 0.03855707f, 0.02609373f, -0.16631328f, -0.10630690f, 0.04826295f, -0.05880687f, 
    0.16868141f, -0.06864697f, 0.02353322f, 0.10738253f, 0.08379823f, 0.11009758f, -0.01264165f, -0.07411014f, 
    0.05456321f, -0.01745384f, 0.28661773f, -0.03200776f, 0.00073567f, 0.04886201f, 0.01611164f, 0.02904123f, 
    0.03264445f, 0.00862930f, 0.13823341f, 0.11376298f, -0.05012978f, 0.10736812f, 0.10878146f, 0.02447660f, 
    0.03350310f, 0.06516363f, 0.04765631f, -0.00978928f, -0.11101669f, -0.03188318f, 0.05916359f, 0.09061187f, 
    -0.01785747f, -0.19608176f, 0.02676370f, -0.12313642f, -0.06634162f, 0.01060390f, 0.10070058f, 0.07241175f, 
    0.07499291f, -0.00563008f, -0.08774576f, 0.06551223f, 0.00823921f, 0.16097946f, -0.10214411f, -0.15875793f, 
    0.01425985f, 0.05518129f, 0.11814316f, -0.05234946f, 0.05762652f, -0.09706207f, -0.00487640f, 0.03356913f, 
    -0.36826977f, 0.19491976f, -0.04874708f, 0.01743989f, 0.17110240f, 0.00637759f, -0.04158614f, -0.05845380f, 
    0.11809780f, 0.08120255f, -0.03248514f, -0.04917033f, -0.01276526f, -0.06954264f, 0.01401824f, 0.18167336f, 
    -0.04431993f, -0.14258732f, 0.00842862f, 0.00405763f, -0.05477681f, 0.06607802f, -0.05873893f, 0.12333266f, 
    -0.10528737f, 0.09751774f, 0.14501809f, -0.04461226f, -0.09123578f, -0.05794790f, 0.04654719f, -0.02772490f, 
    0.12825240f, 0.06233783f, 0.16060203f, 0.07530544f, -0.18851982f, 0.02130331f, 0.20323382f, 0.22687167f, 
    0.10237092f, 0.05730548f, -0.01792959f, -0.01183133f, 0.00320486f, -0.15018322f, -0.00671271f, 0.19417946f, 
    -0.10682958f, 0.08505718f, -0.11427516f, -0.06063069f, 0.09472027f, -0.07041329f, 0.00389340f, 0.02445325f, 
    0.05304047f, -0.04995508f, -0.11720004f, -0.10904463f, 0.09863220f, 0.06734816f, 0.03576530f, -0.10372617f, 
    -0.02020117f, 0.11382844f, -0.09482750f, 0.05398213f, 0.01578764f, 0.08149990f, 0.05283892f, 0.02866129f, 
    0.44642076f, -0.06236498f, 0.24299613f, 0.28067058f, -0.14570992f, -0.02539865f, 0.05878738f, 0.00650626f, 
    0.02489247f, 0.11600458f, 0.07548711f, 0.12048455f, 0.13022426f, -0.07989807f, 0.04666317f, 0.25748175f, 
    -0.11904547f, 0.00586978f, -0.01216806f, -0.00492519f, 0.03417092f, 0.13729155f, 0.04011559f, -0.03517172f, 
    -0.23117691f, -0.18489587f, 0.20418805f, 0.26816854f, 0.00748471f, -0.10075331f, 0.02544484f, 0.00285389f, 
    -0.05052384f, 0.00757305f, -0.09498418f, 0.04923313f, 0.28539056f, -0.25425529f, -0.00328136f, -0.00702799f, 
    -0.06094516f, -0.02173657f, -0.07482211f, -0.12193352f, -0.12860845f, -0.02906585f, -0.13358730f, -0.00678119f, 
    -0.02482149f, 0.20319453f, -0.01021782f, -0.22767726f, -0.03509583f, 0.01256818f, 0.08075466f, -0.00018953f, 
    0.06293499f, 0.08370478f, 0.05432894f, -0.03364382f, -0.12222368f, 0.04120700f, -0.03772224f, 0.21153957f, 
    0.07608999f, -0.06391969f, 0.01763052f, -0.05263034f, -0.07834220f, -0.07290588f, -0.04408406f, -0.01129984f, 
    -0.17338310f, -0.04600179f, 0.06461843f, 0.03517640f, -0.03086263f, 0.00621734f, 0.08891621f, 0.08579312f, 
    0.09644574f, -0.08774615f, -0.06826992f, 0.12028787f, -0.08432478f, -0.10584202f, 0.06658831f, -0.03785749f, 
    -0.13582627f, 0.05332131f, -0.00729229f, -0.02172303f, 0.00078385f, 0.09855548f, 0.23959199f, 0.05373206f, 
    -0.08484413f, 0.17769901f, -0.03334065f, 0.08855314f, -0.09736902f, 0.05414382f, -0.08667007f, 0.14671351f, 
    0.10118040f, 0.00503341f, 0.04876965f, -0.00383930f, -0.10681896f, 0.20883583f, 0.00918552f, 0.16682762f, 
    0.05713095f, 0.01681701f, -0.09832088f, -0.01841643f, -0.09639029f, -0.08126468f, 0.09887196f, -0.16019939f, 
    0.06449234f, -0.09818552f, -0.00036303f, -0.07829501f, -0.01677049f, 0.04448780f, -0.01716603f, 0.06435075f, 
    -0.06868008f, -0.05733940f, 0.07927421f, 0.01135465f, -0.18392342f, 0.03167445f, 0.15087505f, -0.10363657f, 
    0.14205232f, 0.01271483f, -0.05148746f, -0.02237385f, 0.09521110f, -0.02361775f, -0.00682158f, 0.00764253f, 
    0.19524942f, 0.15829577f, 0.02188327f, 0.14632262f, -0.06303510f, 0.09773993f, -0.01543269f, -0.05998914f, 
    0.02129759f, -0.03990620f, -0.04238557f, -0.01744233f, 0.11301902f, 0.04987276f, 0.26936358f, -0.00524698f, 
    0.04764134f, 0.15028477f, -0.03322655f, 0.10669220f, 0.07600945f, -0.11228722f, -0.04194871f, -0.01746339f, 
    0.02011164f, 0.08243399f, 0.15590046f, 0.05167046f, 0.02728275f, -0.03978849f, 0.02876753f, -0.02193227f, 
    -0.11226413f, 0.04031112f, 0.13962233f, 0.03277608f, 0.26058102f, -0.00965973f, 0.04815668f, 0.21404578f, 
    -0.03480830f, -0.07513952f, -0.11870942f, -0.05056824f, -0.01859353f, -0.13255899f, 0.12010982f, -0.02017078f, 
    -0.04218596f, 0.02008915f, -0.04583245f, -0.07490126f, 0.11398806f, 0.08750181f, 0.14513880f, 0.02635998f, 
    0.07169606f, -0.04400879f, 0.02676887f, -0.04410842f, -0.01309341f, -0.02869174f, 0.19165535f, 0.17172167f, 
    -0.12031414f, 0.02977355f, -0.04083213f, 0.04415630f, 0.01707979f, 0.08368850f, 0.11200730f, 0.14195576f, 
    0.01201903f, 0.30370387f, -0.10470477f, -0.15439269f, 0.01356372f, -0.08500191f, -0.14015205f, -0.00619442f, 
    0.05693332f, -0.07646403f, 0.13207124f, -0.07678490f, -0.37190068f, 0.14953317f, 0.13486207f, 0.01362007f, 
    0.03185401f, -0.03383964f, 0.03897362f, -0.08395818f, 0.13006702f, 0.05866011f, -0.05890657f, 0.05417311f, 
    -0.26643887f, -0.08329212f, -0.08675029f, 0.02614141f, 0.05878795f, -0.02720255f, 0.08731384f, 0.05262774f, 
    0.05180399f, -0.08172177f, -0.10286111f, 0.17102881f, -0.18890324f, 0.11422312f, -0.06977633f, -0.02296713f, 
    0.03642794f, -0.09603006f, 0.15165211f, 0.00104296f, -0.02843458f, 0.04887003f, -0.00145478f, 0.05261501f, 
    0.15043017f, -0.14232907f, -0.03752864f, -0.14414300f, -0.05810324f, 0.11199613f, -0.12364470f, -0.03504846f, 
    0.19073522f, -0.01841822f, -0.05422281f, 0.00330432f, -0.18296468f, -0.04720008f, 0.18909849f, 0.05826329f, 
    -0.01791507f, 0.04259135f, 0.01833740f, -0.02762021f, -0.06478743f, 0.06074667f, 0.03383531f, 0.10673721f, 
    -0.03226156f, 0.04746005f, -0.05729559f, -0.08484410f, 0.04285708f, 0.03334698f, 0.10813665f, 0.09432393f, 
    0.06762400f, 0.11058889f, -0.09835069f, -0.02285103f, 0.16674577f, -0.07378388f, 0.13752303f, -0.28437379f, 
    0.04036008f, 0.07097825f, 0.02322789f, 0.06218600f, 0.04422648f, -0.01605859f, -0.01492363f, -0.03600829f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04254907f, 0.02250574f, -0.02572649f, 0.03360722f, -0.00644455f, 0.02717657f, -0.03480739f, 0.01220601f, 
    0.00956076f, -0.10056873f, -0.02401905f, 0.02208161f, -0.04506261f, -0.03159456f, 0.00717499f, -0.02781823f, 
    -0.02206143f, -0.03902227f, -0.07337109f, -0.05177834f, 0.01568186f, 0.03001893f, 0.02249728f, 0.00367241f, 
    0.00924457f, 0.06294236f, 0.00520833f, -0.06646333f, 0.01298447f, -0.00321717f, 0.03307220f, 0.00666316f, 
    0.00544740f, 0.01926353f, 0.00952472f, -0.01391359f, 0.05377205f, 0.06074766f, 0.06004898f, 0.05275415f, 
    0.02773507f, -0.05503530f, -0.05456235f, -0.03175061f, 0.07167798f, 0.02480017f, -0.03320862f, 0.04349633f, 
    -0.06406873f, 0.09907924f, 0.02271622f, -0.00813059f, 0.01314255f, 0.06643748f, 0.06600324f, -0.03799859f, 
    0.02699521f, -0.02249608f, 0.03808088f, -0.04879014f, 0.05105218f, 0.05260921f, -0.02873325f, 0.06797557f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.24445419f, -0.25913560f, 0.19222890f, -0.26577994f, 0.04637438f, -0.23356168f, -0.10013205f, 0.17298387f, 
    -0.00739494f, 0.02000735f, -0.06603667f, 0.09613605f, -0.02167126f, 0.15859078f, 0.28664738f, 0.05478983f, 
    0.20183994f, 0.02011426f, 0.32561323f, -0.01784528f, -0.07191816f, -0.32642105f, 0.02235967f, 0.24375479f, 
    0.18649310f, -0.45310038f, -0.05564327f, 0.12377710f, -0.16418612f, -0.21390522f, -0.07457609f, -0.12455658f, 
    0.04786467f, -0.14592771f, 0.00744704f, 0.14986862f, 0.15454741f, -0.66172200f, -0.03326588f, -0.19807570f, 
    -0.12664025f, -0.01543317f, 0.02971819f, -0.00488647f, 0.19898845f, 0.18533395f, -0.10083448f, -0.11325356f, 
    -0.31194088f, -0.15825482f, 0.19260821f, -0.10143732f, -0.40798384f, -0.07580336f, 0.12040376f, 0.05809852f, 
    0.05856478f, 0.03363993f, 0.29134291f, 0.26684338f, -0.63578886f, -0.38263121f, 0.22609408f, 0.10078051f, 
    -0.11815493f, -0.32680804f, -0.03389554f, -0.17700236f, 0.06647101f, -0.03106622f, 0.09891825f, 0.01014165f, 
    -0.30560234f, -0.13168435f, -0.03395832f, 0.08462260f, 0.09934443f, 0.28937072f, 0.11043638f, -0.03401054f, 
    0.09276428f, 0.11572491f, 0.06512650f, -0.10012674f, 0.00603419f, 0.17095961f, 0.15425356f, -0.21091892f, 
    0.18417023f, -0.20374317f, -0.09172973f, 0.21727961f, 0.18415990f, -0.05289199f, 0.05867068f, 0.04208430f, 
    0.04316442f, 0.13445216f, 0.00780771f, -0.42373073f, -0.07166012f, 0.36431754f, 0.13405934f, 0.23795903f, 
    -0.01064479f, -0.01842591f, -0.08370837f, -0.08386278f, 0.02920863f, -0.41512921f, -0.06403984f, 0.08412057f, 
    -0.58505589f, 0.10128073f, 0.03523414f, 0.04431919f, 0.02118558f, -0.14257549f, 0.06430276f, 0.02471993f, 
    0.00099929f, 0.13059942f, -0.17003122f, 0.08103801f, -0.27867407f, 0.16398178f, 0.14322788f, 0.28463602f, 
    -0.35617757f, 0.15781726f, -0.10147887f, 0.31427902f, -0.06892198f, 0.03373445f, 0.00633797f, -0.33747670f, 
    -0.46374670f, 0.01267021f, 0.03422448f, 0.03689042f, -0.00364719f, 0.07352974f, 0.22858508f, -0.10073820f, 
    -0.11449352f, 0.07551648f, 0.13536227f, -0.02644082f, -0.05118832f, -0.11060282f, -0.28905547f, 0.15959567f, 
    0.16398434f, -0.01796640f, 0.09120071f, 0.28363785f, -0.07585988f, -0.32074618f, -0.08984195f, 0.09267034f, 
    0.10646426f, 0.12725726f, -0.06768582f, 0.07316744f, -0.36871439f, -0.21005446f, -0.13825889f, 0.18755634f, 
    0.01398729f, 0.03114584f, -0.03767112f, 0.07761873f, 0.02633232f, -0.11321755f, 0.09436963f, -0.04642347f, 
    0.19486298f, -0.02212316f, -0.44825837f, 0.06196468f, 0.22041370f, -0.08128525f, 0.11028592f, -0.06748189f, 
    0.10637515f, -0.10467447f, -0.36306247f, 0.10179697f, 0.34936598f, 0.19238356f, 0.19755262f, -0.41700962f, 
    -0.38110727f, 0.30429730f, 0.04930613f, -0.38500798f, -0.11932425f, 0.07843847f, -0.12526856f, -0.01918910f, 
    -0.15333191f, 0.35476294f, -0.01372085f, 0.02831211f, -0.08136579f, -0.48116773f, 0.06154080f, -0.05502639f, 
    -0.39492759f, -0.09278052f, 0.29242277f, 0.00829756f, 0.05497193f, -0.01508778f, -0.10078891f, 0.04305794f, 
    -0.19919929f, -0.28363964f, -0.06918160f, -0.69279426f, -0.37309176f, 0.12280948f, 0.04968067f, 0.05259340f, 
    0.09031294f, 0.24496599f, 0.09829391f, 0.09655739f, -0.00004939f, 0.11597846f, 0.03183744f, 0.10673397f, 
    0.04524284f, 0.02327256f, 0.05614033f, 0.05057839f, 0.07362698f, 0.12409271f, -0.03189985f, 0.00067538f, 
    -0.02027418f, 0.22606069f, 0.23623936f, -0.06369232f, -0.01571464f, 0.16429722f, -0.34358835f, -0.06120265f, 
    -0.05979504f, -0.11632673f, -0.59753257f, -0.31728059f, -0.35506189f, -0.20784844f, 0.05068935f, 0.03482925f, 
    -0.16203980f, 0.18088952f, -0.22265643f, -0.03406430f, -0.02272066f, -0.29479808f, -0.08139082f, 0.22991914f, 
    0.24538937f, 0.09132674f, -0.05890027f, 0.05812721f, -0.02198140f, -0.11327174f, 0.21330005f, 0.09523285f, 
    -0.14100841f, 0.02333905f, -0.41559455f, -0.08520106f, 0.01785497f, -0.03004408f, 0.22476889f, 0.08752057f, 
    -0.19980016f, 0.11222803f, -0.01189786f, -0.26162040f, -0.12054614f, 0.30288097f, -0.10497865f, -0.05660788f, 
    -0.08939452f, -0.34594461f, 0.09639645f, 0.47405839f, -0.24599144f, -0.04687984f, 0.17230824f, -0.39603946f, 
    0.10078757f, -0.04053147f, -0.10178410f, -0.06480423f, -0.11058116f, 0.24333328f, 0.04323263f, -0.02361482f, 
    -0.04959068f, 0.14669460f, -0.08894248f, -0.08987063f, -0.19339272f, 0.01760634f, -0.17173964f, 0.10004051f, 
    0.10897650f, 0.19118653f, -0.24822767f, -0.09811454f, -0.04357385f, 0.19628297f, 0.27476841f, 0.20518461f, 
    0.36148912f, -0.21243539f, 0.20221205f, 0.30354553f, -0.00656119f, -0.33453268f, -0.12054630f, 0.26253867f, 
    0.25163329f, 0.03394031f, 0.03727165f, -0.02339188f, -0.09833620f, 0.07926776f, -0.47393173f, -0.01203297f, 
    0.17748606f, 0.02106343f, -0.51923406f, -0.05429856f, -0.02992958f, -0.02603906f, -0.19534262f, -0.26737601f, 
    0.04001076f, 0.17704803f, -0.03475362f, -0.16351657f, -0.05819369f, 0.04631512f, 0.08273616f, 0.10069511f, 
    0.08225682f, 0.08922374f, -0.09934807f, -0.43023986f, 0.26784399f, -0.38151088f, -0.14543092f, -0.26250854f, 
    0.11183283f, -0.11874674f, -0.02874233f, 0.08271862f, 0.08023872f, -0.20041496f, -0.04954446f, 0.04007219f, 
    -0.12846693f, 0.18816945f, 0.31135786f, 0.07318276f, -0.21338768f, 0.11612868f, -0.00621803f, -0.02460942f, 
    0.04122024f, -0.04964177f, 0.19600603f, 0.15361317f, -0.17356677f, 0.01821733f, 0.01735231f, 0.12903410f, 
    -0.19609867f, -0.18873304f, 0.26296392f, 0.08351180f, 0.04850154f, 0.27619112f, -0.04161161f, -0.15352361f, 
    0.20643723f, 0.05951438f, -0.05762507f, -0.00505066f, 0.03942769f, -0.22002508f, -0.39674905f, 0.00255388f, 
    0.12484215f, -0.08635719f, 0.38455999f, 0.11766864f, -0.00148107f, 0.00307700f, 0.04604948f, -0.20763090f, 
    -0.38239163f, 0.25822085f, 0.09600020f, 0.13059083f, -0.11086971f, 0.11616573f, 0.05691183f, -0.10024790f, 
    -0.09898014f, -0.01042860f, -0.10620453f, 0.10287555f, -0.34384617f, -0.17459185f, 0.23529834f, -0.05298398f, 
    0.03834881f, 0.06481338f, 0.01191140f, 0.00574588f, 0.11283433f, -0.14945644f, 0.03553110f, -0.04060832f, 
    0.37172532f, -0.10878926f, -0.18653545f, -0.08705281f, -0.59345120f, -0.19690792f, 0.16794655f, 0.09212869f, 
    0.02510187f, 0.26455638f, 0.15718129f, -0.13868573f, 0.10864490f, -0.06399001f, -0.28322616f, -0.19538976f, 
    0.26979867f, 0.16204013f, -0.27467200f, 0.09617331f, 0.07889155f, 0.21160519f, 0.11398145f, 0.20010060f, 
    0.13345771f, -0.17060739f, -0.11370711f, -0.11121822f, 0.02100890f, -0.09266875f, 0.04044920f, 0.11498422f, 
    -0.03601069f, -0.09245375f, 0.14059456f, 0.04867752f, 0.01191885f, 0.01141562f, -0.26641455f, 0.18228938f, 
    -0.32933313f, 0.11218761f, 0.10516569f, 0.09707075f, 0.14421579f, -0.42351463f, 0.04032297f, -0.11961967f, 
    0.09101453f, 0.11303736f, -0.07476281f, 0.12919413f, 0.00180958f, 0.20824343f, -0.51670420f, -0.13593216f, 
    0.04084956f, 0.02666390f, -0.11174332f, 0.06728036f, -0.36317953f, 0.11802587f, -0.00016059f, -0.11460406f, 
    0.21055563f, -0.25942019f, -0.09372917f, -0.11802287f, 0.10538083f, 0.12938429f, -0.39570045f, 0.11500203f, 
    -0.11579877f, 0.15324515f, -0.13192862f, 0.01310709f, 0.10087687f, -0.18053085f, -0.46373534f, 0.01505311f, 
    0.12743226f, -0.13686690f, -0.06346210f, -0.14847720f, -0.02917212f, -0.23907509f, 0.01746645f, -0.37552160f, 
    0.07305140f, 0.28524977f, -0.04557166f, -0.01564300f, 0.05914735f, -0.26558417f, -0.21283942f, -0.05352667f, 
    -0.54579788f, 0.00495214f, -0.03031502f, 0.05605890f, -0.06342436f, 0.18615583f, 0.04725679f, 0.05650380f, 
    0.16602625f, 0.16680136f, 0.00778723f, 0.01838604f, 0.19996023f, 0.23715340f, 0.06136181f, 0.06090298f, 
    0.00520229f, 0.15022142f, 0.04389639f, -0.25186771f, -0.10436758f, -0.10862403f, -0.22109483f, 0.20167328f, 
    -0.06676546f, -0.08426599f, -0.02364601f, 0.03494021f, -0.43941849f, -0.11449612f, -0.08040086f, 0.03742655f, 
    0.05762921f, -0.21833760f, 0.24172637f, -0.11573692f, 0.24021578f, -0.25572979f, 0.13662325f, 0.08267961f, 
    -0.10648546f, -0.40197095f, -0.02919741f, 0.27903163f, 0.28725949f, 0.17934611f, -0.00771077f, 0.21812491f, 
    -0.08155764f, 0.04999281f, 0.10966536f, 0.15685926f, -0.04143038f, 0.19156107f, -0.05912999f, 0.16766705f, 
    0.01215674f, -0.07342051f, -0.09682105f, -0.03710186f, 0.03125949f, 0.16219242f, -0.07480000f, 0.10211840f, 
    0.28959471f, -0.13099775f, 0.03181704f, -0.01796143f, 0.05668995f, -0.47860643f, 0.17599060f, -0.15609263f, 
    0.11234225f, 0.21264552f, 0.06962510f, 0.19341111f, 0.33561912f, -0.45650727f, 0.12121662f, -0.00298237f, 
    -0.05833511f, -0.46651965f, 0.06305937f, -0.12683687f, -0.05070598f, 0.13373902f, -0.21532750f, -0.29245448f, 
    -0.03748140f, -0.11230630f, -0.01260546f, -0.00225693f, 0.08847334f, 0.24404784f, -0.08509874f, 0.10233542f, 
    -0.03151233f, -0.16904886f, -0.15198067f, -0.10020617f, 0.24894823f, 0.07640652f, -0.15907602f, -0.00671098f, 
    -0.03777173f, -0.18942653f, 0.26834443f, -0.55167675f, 0.32862455f, 0.16171446f, 0.01074864f, -0.19510913f, 
    0.01393720f, -0.04588620f, -0.53243732f, 0.23515122f, -0.06562246f, 0.11539590f, 0.07638370f, -0.11430252f, 
    -0.05641549f, -0.73870492f, -0.10631401f, -0.00612219f, 0.10469695f, -0.38550153f, 0.07584509f, -0.10339540f, 
    -0.27360451f, 0.05059462f, 0.03735180f, -0.02365918f, -0.02505013f, -0.13024482f, 0.31064698f, -0.03018152f, 
    0.13922994f, 0.28911266f, 0.08507157f, -0.35210636f, -0.40802521f, 0.00681492f, -0.05497433f, -0.00738955f, 
    0.11317007f, 0.25997731f, 0.05549939f, -0.26847744f, 0.31712767f, 0.09299259f, -0.17094156f, 0.26499459f, 
    0.11932240f, -0.05656523f, -0.02296793f, 0.13277517f, 0.21899483f, -0.18843919f, -0.06287247f, 0.06212515f, 
    0.14782117f, 0.07847926f, -0.40030557f, -0.09447960f, 0.27656370f, 0.12574448f, 0.24857371f, -0.02895212f, 
    0.08037379f, 0.15987812f, -0.24391812f, -0.42303300f, -0.38141093f, 0.01900353f, -0.30412996f, 0.08357774f, 
    0.25651556f, -0.05129990f, 0.04802193f, -0.18191008f, 0.05855288f, 0.23028155f, -0.10223895f, 0.01855559f, 
    -0.11725774f, 0.10715962f, -0.09719938f, 0.00240951f, -0.06527249f, -0.30062190f, -0.14820740f, -0.00678051f, 
    -0.14253440f, 0.11535750f, -0.13223600f, 0.11070140f, -0.08598726f, 0.36258057f, -0.49947518f, 0.30284223f, 
    0.12322784f, -0.04342457f, 0.05008852f, -0.05019140f, 0.23910752f, -0.15355578f, 0.08598262f, -0.08056874f, 
    0.01171651f, -0.07251610f, -0.02891626f, -0.20651835f, 0.18497868f, 0.22628723f, 0.28395653f, -0.20471294f, 
    -0.12731799f, 0.04779149f, 0.00136187f, 0.04341285f, -0.15076172f, 0.19996995f, -0.01754579f, -0.01317966f, 
    -0.15864828f, 0.22491923f, -0.34747526f, 0.10288832f, -0.21001315f, -0.07939548f, 0.24345997f, -0.09689265f, 
    0.02395905f, -0.27514637f, 0.20292132f, 0.06972336f, -0.11364033f, -0.46284831f, -0.27829883f, -0.51660550f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01084683f, -0.01735560f, -0.07491362f, -0.02484526f, -0.01134763f, -0.02746473f, 0.08041870f, -0.14013307f, 
    -0.07841095f, 0.03763748f, -0.00986836f, 0.10234201f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
