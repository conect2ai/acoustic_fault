#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.25604966f, -0.61512965f, 0.33215138f, -0.69283760f, 0.07998595f, -0.94933051f, -0.35416251f, -0.22528042f, 
    0.21083231f, 0.09863892f, 0.43217814f, -0.24209899f, 0.58975673f, 0.14313540f, 0.29555252f, -0.01168801f, 
    0.91169834f, -0.75620407f, -0.03357600f, 0.02832530f, -0.59642541f, -0.64197433f, 1.31885743f, -0.79418969f, 
    -0.05066852f, 0.01963816f, -0.37520805f, -0.78970677f, -0.05684434f, -0.24555242f, 0.25983444f, 0.71918547f, 
    0.81375033f, 0.26367629f, 0.73456115f, 0.50254190f, -0.43739051f, -0.62965322f, -0.73473585f, 0.25237674f, 
    0.62855774f, 0.66961581f, -0.02837338f, -0.28809747f, -0.45657334f, -0.58434290f, -0.35508248f, 0.45115018f, 
    0.82221419f, 0.60569251f, 0.17287050f, 0.01962855f, -0.43271819f, -0.28820738f, 0.52467632f, 0.97893840f, 
    -0.38211343f, -0.46751466f, -0.36701205f, 0.46426508f, -0.11854717f, -0.36688501f, -0.58213359f, -0.06509485f, 
    -0.52329010f, 0.09159445f, -1.22509277f, -0.38481078f, -0.50094384f, 0.74549913f, -0.36635113f, -0.23771697f, 
    -0.26128909f, 0.08854201f, 0.30388242f, -0.59873855f, -0.47951120f, -0.81609040f, 0.22766455f, 0.55378973f, 
    0.76788759f, 0.67745191f, -0.33496219f, 0.86558670f, -0.36702555f, -0.18248725f, 0.58355904f, 0.29468444f, 
    0.17434603f, -0.21758403f, 1.29246092f, -1.11638629f, -1.04067302f, 0.71136689f, -0.07201447f, -0.14379820f, 
    0.44217262f, 0.11973468f, -0.03663768f, 0.56460732f, -0.80954981f, -0.01811205f, 0.23037675f, 0.21044943f, 
    -0.02185796f, -0.17391573f, -0.36675212f, -0.67453969f, -0.44888270f, -0.52162683f, -0.61113125f, 0.09641118f, 
    -0.45152292f, -0.93445623f, -0.32912686f, -0.18743995f, -0.34122106f, 0.47759247f, -0.33544427f, -0.16008659f, 
    0.57593566f, -0.07457110f, 0.30461207f, 0.22478911f, 0.02765933f, 0.53790092f, 0.09488824f, -0.00953599f, 
    1.06702375f, 0.71539271f, -0.96369356f, -0.57678008f, -0.03443434f, -0.05462573f, 0.27328721f, -0.99852091f, 
    -0.64029819f, -0.59140241f, -0.03571096f, -0.55789787f, 0.05456644f, 0.48070121f, -0.26968092f, 0.68042535f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.62122756f, 0.18550386f, 0.34909421f, 0.42829251f, -0.22550318f, 0.35827690f, 0.00181376f, 0.52092153f, 
    0.23066111f, 0.33818817f, 0.39925650f, 0.41765928f, -0.37709197f, 0.02257616f, -0.03027225f, -0.26888269f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.10010585f, 0.14538693f, -0.17478465f, 0.10021379f, -0.10518891f, -0.09646998f, 0.02555843f, 0.04304535f, 
    0.03122967f, 0.01480005f, 0.02838344f, -0.10565679f, -0.05485431f, 0.01761743f, 0.10218614f, 0.17213508f, 
    -0.18650280f, -0.11735171f, -0.01903085f, -0.00367194f, -0.10609493f, 0.18347901f, 0.21801460f, 0.24222834f, 
    0.01732856f, 0.10338285f, 0.08031506f, -0.18888146f, 0.07042973f, 0.18313672f, -0.01515021f, 0.00381294f, 
    -0.08844887f, -0.20078129f, -0.17476450f, -0.36143190f, 0.47372669f, -0.04994404f, 0.19144519f, -0.04987973f, 
    0.10327941f, 0.13546823f, 0.18402180f, 0.24514307f, 0.27672866f, -0.08239643f, -0.05426822f, -0.39050245f, 
    -0.21397561f, 0.20368928f, 0.05164364f, 0.18243679f, -0.06891751f, 0.28584301f, -0.34707823f, 0.25251928f, 
    0.15615079f, -0.06102419f, -0.13261026f, 0.14033942f, 0.34829146f, 0.20107277f, 0.19358449f, -0.15003967f, 
    0.04134298f, 0.11827551f, 0.20478582f, 0.13022883f, -0.02753582f, 0.06030272f, 0.00660896f, -0.12495843f, 
    -0.10528712f, -0.02899950f, -0.16387160f, 0.13078058f, -0.14463402f, 0.00562295f, -0.57505494f, -0.35438251f, 
    -0.49977559f, 0.06061660f, 0.31109056f, -0.12212383f, -0.09628851f, 0.03958474f, -0.12706202f, 0.19376534f, 
    -0.01224643f, -0.08274120f, 0.08770235f, 0.15353078f, 0.28922650f, 0.17972855f, 0.05641245f, 0.04932746f, 
    -0.15927266f, 0.00406073f, 0.03699082f, -0.31949803f, -0.05526473f, -0.12180924f, 0.07076481f, 0.01896052f, 
    0.24160232f, 0.17597017f, 0.14478287f, 0.35332513f, 0.30323496f, -0.30136910f, 0.01339411f, 0.28224763f, 
    0.17460589f, -0.04764058f, -0.13074191f, -0.00219953f, 0.10065988f, 0.05652565f, 0.03219763f, -0.04812472f, 
    0.09534881f, 0.13096587f, 0.03011636f, 0.05400273f, 0.06801449f, -0.56085062f, 0.39078787f, 0.23443337f, 
    0.22823474f, -0.10666765f, -0.06631982f, 0.08696724f, -0.05117248f, -0.11171645f, -0.40554595f, 0.22521889f, 
    -0.19321904f, -0.44217968f, 0.03303139f, -0.10357300f, 0.01241255f, 0.18821806f, -0.03847450f, -0.12557578f, 
    0.09387328f, 0.32193261f, 0.34970620f, 0.04637300f, 0.06657193f, -0.00524180f, -0.01224204f, -0.06243058f, 
    -0.11155498f, -0.23337072f, 0.25272661f, 0.07641627f, -0.01226263f, -0.05394496f, 0.04400887f, -0.22908151f, 
    0.26807523f, -0.08128284f, -0.01893191f, 0.57630044f, 0.26733801f, -0.10103052f, -0.12562847f, -0.06460983f, 
    -0.04663446f, 0.14436853f, -0.17170784f, -0.08804511f, 0.00867012f, 0.06404157f, -0.07866719f, -0.27755111f, 
    -0.01422253f, 0.10274773f, -0.03136062f, 0.08656856f, -0.37878898f, 0.14550824f, 0.16192570f, -0.07683468f, 
    -0.30668509f, -0.11895995f, 0.01450463f, 0.04090432f, -0.04215540f, -0.22891374f, 0.04157890f, -0.10806057f, 
    -0.13141581f, 0.07162131f, -0.38934439f, -0.13941307f, -0.23915833f, -0.03115620f, -0.13903764f, -0.22024609f, 
    -0.02047910f, 0.07035501f, 0.06301044f, 0.04527139f, -0.35208637f, 0.09190114f, -0.10542757f, 0.18365456f, 
    -0.21309876f, 0.66863883f, 0.02979357f, -0.13907826f, 0.14843562f, 0.07097208f, 0.00155919f, 0.15620501f, 
    0.01778367f, 0.33027342f, 0.15011258f, 0.04911844f, 0.36666012f, 0.11930651f, 0.02395246f, 0.13172926f, 
    0.15047707f, -0.52985138f, -0.01442618f, -0.30807209f, -0.06331065f, 0.10197823f, 0.08718067f, 0.15236135f, 
    0.25590006f, -0.08296001f, -0.12269618f, -0.05560968f, 0.50416833f, 0.05903081f, -0.18752871f, -0.17549919f, 
    0.03964785f, -0.19444412f, 0.08134671f, -0.01182366f, -0.23403873f, -0.02946504f, -0.10599837f, -0.16972589f, 
    -0.07270795f, -0.12991194f, -0.22384143f, -0.16677110f, -0.06438787f, -0.07030381f, 0.48129189f, -0.13158286f, 
    -0.04629935f, -0.01836797f, 0.06431469f, 0.10224427f, -0.09727851f, -0.04522043f, 0.15198794f, 0.13657787f, 
    0.07165553f, -0.19898382f, -0.31857288f, -0.02083520f, 0.02566156f, 0.11496145f, -0.44559470f, -0.07587920f, 
    -0.14696333f, -0.08143746f, 0.21919616f, -0.21234187f, 0.12490527f, 0.25704387f, 0.29365045f, 0.39140120f, 
    0.13780092f, 0.32281688f, 0.06125347f, 0.02985966f, -0.06033722f, 0.20763054f, 0.05523833f, 0.14344767f, 
    0.03094489f, 0.04257366f, 0.04293582f, -0.00621838f, 0.03934147f, -0.02282988f, -0.01021118f, -0.06950860f, 
    -0.04654143f, 0.01797754f, -0.05992342f, -0.05626551f, -0.03250818f, 0.06468457f, -0.08344590f, -0.08296516f, 
    -0.07983811f, 0.01189433f, -0.08057474f, 0.01213456f, -0.05746807f, 0.00233080f, 0.05001900f, -0.08558553f, 
    -0.03616985f, -0.01952725f, -0.04959172f, 0.01927955f, -0.07654700f, -0.00139199f, -0.01945115f, -0.03220221f, 
    0.02797985f, 0.04474376f, -0.01033397f, -0.04059260f, -0.09237392f, 0.03001457f, -0.05425987f, -0.03566931f, 
    -0.00637975f, -0.03717999f, -0.03502098f, -0.03681641f, -0.03466410f, 0.06735915f, -0.05248138f, -0.09131826f, 
    0.03290271f, 0.01677099f, 0.06120175f, -0.03868124f, 0.04446230f, -0.06389507f, 0.01108983f, -0.05060892f, 
    -0.07384768f, 0.07162521f, 0.06184148f, 0.06598908f, 0.05581013f, 0.00512709f, 0.01244993f, -0.04567253f, 
    -0.02185012f, -0.07142726f, 0.06358252f, 0.04047937f, 0.02118471f, -0.02948372f, -0.04211884f, 0.02983350f, 
    -0.06252061f, 0.04094375f, 0.00056597f, 0.06439166f, -0.05135510f, -0.03915406f, 0.07998049f, -0.03458445f, 
    -0.05493378f, -0.02455297f, 0.01768618f, -0.07597320f, 0.06798193f, -0.00480553f, 0.07411841f, -0.03877112f, 
    0.04369372f, 0.04217945f, 0.03845436f, 0.02941916f, 0.00985935f, -0.08446719f, 0.00066963f, -0.06524307f, 
    0.06030932f, -0.02148785f, -0.06110227f, 0.05737126f, -0.01204846f, -0.09157843f, -0.04404992f, -0.09594129f, 
    -0.02238408f, -0.07130850f, 0.04328081f, 0.03757574f, -0.02313497f, 0.01318758f, -0.06548113f, -0.07011884f, 
    -0.05778310f, -0.03559149f, -0.07621979f, 0.06334703f, 0.02533802f, 0.01598723f, -0.04837386f, 0.06411385f, 
    0.02173612f, -0.06933771f, -0.07294673f, -0.02103963f, -0.09044332f, -0.07167600f, 0.03439088f, -0.05164115f, 
    -0.01582296f, -0.05304066f, -0.00657902f, -0.04263516f, -0.07053724f, 0.06507315f, 0.03549823f, 0.02412402f, 
    0.02479291f, -0.00969147f, 0.03451792f, -0.03836927f, 0.01479817f, 0.00695160f, 0.00944576f, -0.06046719f, 
    -0.04040096f, 0.13536325f, 0.12546498f, 0.32418782f, -0.02332913f, -0.15291020f, 0.04384980f, 0.07929811f, 
    -0.00966505f, 0.18858458f, -0.19873793f, -0.41964066f, 0.07031419f, 0.09668230f, 0.07174518f, 0.28461647f, 
    -0.09106449f, 0.41029271f, 0.04332488f, -0.04152510f, 0.33270824f, -0.05914615f, -0.12884364f, 0.04584363f, 
    0.05440257f, 0.04907715f, 0.25833794f, -0.05967440f, 0.27335504f, -0.01062973f, 0.02513397f, 0.18777078f, 
    0.15472871f, -0.14153796f, 0.02479649f, 0.03045441f, -0.18126443f, -0.07036716f, -0.28747758f, 0.15264000f, 
    0.21990842f, 0.14849697f, -0.33035222f, 0.20137322f, 0.03413337f, -0.15887299f, 0.27878332f, -0.33896288f, 
    0.26055846f, 0.07542229f, 0.15217932f, 0.32871628f, 0.07023268f, 0.04597277f, 0.74236262f, -0.48759088f, 
    -0.20835556f, 0.17447934f, 0.10388608f, -0.17795494f, 0.03194441f, 0.13100383f, 0.20343368f, 0.18314192f, 
    -0.06691796f, 0.01166670f, -0.23705955f, -0.00381101f, 0.16727619f, 0.02830355f, 0.04662511f, -0.01429569f, 
    0.20295770f, -0.26298720f, -0.00373839f, -0.11934920f, -0.24385945f, -0.10731930f, -0.08941375f, -0.26823145f, 
    -0.34804258f, 0.21400881f, -0.13129990f, -0.48637396f, 0.07676492f, -0.05829232f, -0.39317447f, 0.15871194f, 
    0.08742612f, -0.07199396f, -0.09793863f, 0.32987601f, 0.01996240f, -0.07544964f, -0.01096782f, -0.03004666f, 
    0.22215196f, 0.01381760f, 0.35138282f, -0.07344649f, 0.41488358f, 0.11232796f, -0.12317335f, 0.21465909f, 
    0.21527398f, -0.04848186f, 0.38680768f, 0.36213836f, 0.02353916f, 0.12167501f, 0.44851217f, 0.02439666f, 
    -0.11099143f, -0.42359272f, -0.01336664f, 0.32817513f, -0.15384661f, 0.12992390f, 0.18981928f, 0.19500060f, 
    0.05197292f, 0.07629602f, 0.03704504f, 0.01766917f, 0.10919134f, -0.01902314f, -0.10014100f, -0.00587794f, 
    0.10177133f, -0.03371133f, -0.00713047f, -0.29458693f, 0.05268457f, 0.16632718f, -0.14235611f, -0.00000209f, 
    -0.46744201f, 0.07237643f, 0.42102209f, -0.12283703f, 0.45384452f, 0.19629973f, 0.10483000f, -0.16610207f, 
    0.21978676f, -0.19479507f, -0.01088842f, 0.11380097f, 0.10230607f, 0.29554510f, 0.10111246f, 0.06595590f, 
    0.24630927f, 0.05627749f, 0.00462647f, 0.27196565f, 0.21176840f, 0.13495651f, 0.25700712f, 0.12432611f, 
    0.25273988f, 0.01806484f, 0.22582529f, 0.16608563f, 0.13592291f, 0.01042159f, 0.06917974f, 0.10108884f, 
    0.07319195f, 0.29393625f, -0.03810969f, -0.01251436f, 0.15613219f, 0.01149536f, 0.12714295f, 0.05811450f, 
    0.07920823f, 0.03836729f, 0.14569293f, 0.33154309f, -0.41038778f, -0.22932908f, -0.24716100f, -0.10438353f, 
    -0.10884611f, -0.24232733f, -0.18166249f, -0.36048803f, 0.00750984f, -0.21257243f, 0.06395892f, -0.02624922f, 
    0.21136308f, 0.06072997f, 0.09788460f, 0.05192134f, -0.26808250f, -0.17542151f, -0.09112771f, -0.29115501f, 
    -0.23736508f, -0.06844186f, 0.04369460f, 0.09030779f, -0.25662711f, -0.01116939f, -0.09033765f, -0.08821826f, 
    0.07061108f, -0.33931363f, 0.08874669f, 0.22468795f, 0.05721790f, 0.08941150f, 0.29228199f, 0.13065621f, 
    0.10509784f, -0.07091045f, -0.37246853f, 0.08149859f, 0.14863488f, -0.11363567f, 0.28025615f, 0.25853127f, 
    0.19899541f, -0.01943237f, -0.13453746f, 0.04132604f, 0.18704125f, 0.10574159f, 0.08487622f, -0.06539873f, 
    0.00862977f, 0.35006791f, -0.11190830f, 0.23071641f, -0.11448120f, 0.06120423f, 0.17893262f, 0.17557122f, 
    -0.18532823f, 0.02164616f, -0.02963542f, 0.20977296f, 0.04405291f, -0.07146468f, -0.10489356f, -0.06894561f, 
    0.04874953f, -0.14557394f, -0.06167425f, -0.20735864f, -0.37580439f, -0.37191534f, 0.29274794f, -0.10442089f, 
    0.07155608f, 0.07676317f, 0.01025104f, -0.19903708f, -0.02860360f, -0.00777314f, 0.26405859f, -0.04666479f, 
    -0.02552555f, -0.07893452f, 0.06275263f, 0.03385382f, 0.12988569f, 0.07445637f, -0.02245502f, -0.17379241f, 
    0.23857416f, 0.32697585f, 0.21085849f, -0.09649559f, 0.36576033f, 0.05758671f, 0.17180474f, -0.62611192f, 
    0.12725489f, 0.11908942f, -0.22053760f, 0.22810274f, -0.00384912f, 0.01602058f, 0.06869585f, -0.09104609f, 
    0.39205238f, 0.06628678f, 0.23003305f, -0.17524558f, -0.12637614f, 0.06638848f, 0.00128531f, 0.15394527f, 
    -0.02708041f, -0.01263670f, 0.12906294f, -0.25335947f, 0.00899354f, -0.11548552f, 0.07043410f, -0.03706615f, 
    -0.01802490f, -0.08777235f, -0.19717495f, -0.06221130f, 0.20292063f, 0.04214340f, -0.16898587f, 0.01117288f, 
    0.16305332f, 0.09624750f, 0.06528965f, -0.26918256f, -0.66923290f, -0.66116071f, -0.11954791f, -0.00338322f, 
    0.05586905f, 0.03084800f, 0.00058028f, 0.15848780f, 0.33252931f, -0.27253634f, -0.04889847f, 0.32173955f, 
    0.10463290f, 0.21647561f, 0.24323618f, 0.15396518f, 0.03410687f, 0.28123158f, -0.03645084f, 0.24701650f, 
    -0.20066071f, -0.11387321f, -0.20589107f, 0.09561359f, 0.19030531f, 0.02533980f, -0.17254458f, 0.10777768f, 
    -0.22020517f, 0.22269629f, -0.16819482f, 0.07538815f, 0.03919311f, -0.05158183f, -0.11729193f, -0.07646617f, 
    0.21798101f, 0.12394285f, -0.17774278f, -0.04159036f, -0.23112486f, -0.05256481f, -0.10541018f, -0.03677773f, 
    0.08866087f, 0.32115042f, 0.40979803f, -0.01660154f, 0.03191528f, -0.20280837f, -0.16750179f, -0.01174669f, 
    0.12680723f, -0.41971061f, -0.47574991f, -0.28137475f, -0.18747637f, 0.15894212f, -0.09408167f, -0.08093966f, 
    0.02794908f, 0.31428128f, 0.44825491f, 0.23814932f, -0.59709400f, -0.04406253f, -0.05487643f, 0.02690093f, 
    -0.07852928f, 0.18599196f, -0.00251484f, 0.55879170f, -0.09799952f, 0.06328782f, 0.05183460f, -0.13037579f, 
    -0.04070919f, 0.36329821f, -0.04011180f, -0.06351013f, 0.35789463f, 0.39117011f, 0.43258831f, -0.24154036f, 
    0.05459053f, 0.06133965f, 0.15451080f, -0.08363985f, -0.09672215f, 0.02278630f, -0.03219811f, -0.38528612f, 
    -0.18094605f, 0.14243178f, -0.10953485f, -0.01477733f, 0.24973141f, 0.13066332f, -0.77666819f, -0.57705939f, 
    -0.66964668f, -0.31324503f, -0.05786677f, 0.00098284f, 0.07580455f, 0.14291614f, 0.03333367f, 0.14495634f, 
    0.19679248f, 0.32320744f, -0.09631441f, -0.06811181f, 0.18016911f, 0.12424681f, -0.00957047f, 0.02390137f, 
    0.00476320f, -0.07964678f, -0.03621021f, -0.02791443f, -0.01700109f, -0.00329866f, -0.07763969f, -0.06118632f, 
    -0.02466680f, 0.05908535f, -0.08102986f, 0.04386263f, -0.07047193f, -0.03828301f, 0.00828437f, -0.03511609f, 
    0.03273098f, 0.02056454f, 0.07398524f, 0.01864098f, -0.06991857f, -0.04357855f, 0.06093998f, 0.02974080f, 
    -0.03183947f, -0.04633320f, -0.07700586f, 0.06936067f, 0.00792142f, 0.07019772f, 0.05118585f, -0.04049686f, 
    -0.07264408f, 0.02309378f, 0.01396847f, -0.05521341f, -0.06765917f, 0.02298395f, 0.04784663f, -0.06379452f, 
    0.07342893f, -0.03266326f, -0.08089136f, -0.05179702f, 0.01723831f, -0.00905565f, 0.05244033f, -0.03795177f, 
    -0.06219617f, -0.05622858f, -0.01863683f, -0.02481238f, -0.06269589f, -0.02412545f, -0.03851957f, -0.03948941f, 
    0.06206408f, -0.07462563f, -0.06264228f, 0.00949791f, -0.03470710f, -0.08180379f, 0.05410709f, 0.02554433f, 
    -0.06192569f, -0.01956013f, -0.06370922f, -0.00994705f, -0.05607166f, 0.02475420f, -0.00721060f, 0.01326253f, 
    0.00077393f, 0.05737867f, -0.06482881f, -0.07260174f, -0.04005201f, -0.00303915f, -0.01117725f, -0.06088150f, 
    -0.00652374f, 0.05749758f, -0.01928382f, -0.02653585f, -0.07926355f, -0.06627320f, -0.06128873f, -0.01545697f, 
    0.00016896f, -0.04748771f, -0.00074930f, 0.05765485f, 0.03109694f, -0.00638924f, 0.05129883f, -0.04201424f, 
    -0.02180829f, -0.01437025f, -0.08052531f, 0.00621240f, 0.07772619f, -0.02613133f, 0.02476348f, -0.04266527f, 
    0.07862431f, 0.07027610f, 0.05031435f, 0.00778040f, -0.04971905f, 0.03961357f, -0.07069038f, -0.06825342f, 
    -0.04256366f, -0.06029887f, -0.01585325f, 0.08061963f, 0.07184131f, -0.02258809f, -0.08141312f, -0.02268525f, 
    0.05342662f, 0.06281792f, -0.02021891f, -0.00243341f, -0.01684435f, -0.03930257f, -0.00751919f, -0.02591398f, 
    0.07866996f, -0.01739485f, -0.00180964f, -0.03749567f, -0.04043188f, 0.06495774f, -0.02320401f, 0.00266589f, 
    0.07545139f, 0.00614758f, 0.01742678f, 0.00309142f, 0.03353751f, -0.01483497f, -0.04386326f, -0.04209450f, 
    0.00276618f, -0.02508504f, 0.02712215f, -0.00498969f, 0.06739826f, 0.04213884f, -0.06346992f, -0.08589868f, 
    -0.07052796f, 0.04903420f, 0.05889686f, -0.00369800f, -0.00136327f, 0.06372965f, 0.07415866f, -0.01866328f, 
    0.07279574f, -0.07358380f, -0.06401519f, 0.05183269f, -0.03203636f, -0.03172722f, -0.01411790f, 0.04030751f, 
    0.05940587f, -0.00838832f, -0.02505760f, -0.00312454f, 0.03889728f, 0.06241538f, -0.06672852f, -0.05829488f, 
    -0.04734640f, 0.04827205f, 0.03918399f, -0.06500028f, -0.07120177f, -0.03044242f, 0.01462341f, 0.00318781f, 
    0.02736488f, -0.06073422f, 0.05763373f, -0.09356824f, 0.00267904f, -0.07788764f, -0.00290787f, -0.02669214f, 
    -0.04381590f, -0.02034719f, -0.02526169f, -0.03691607f, -0.00728731f, 0.02625318f, 0.00975452f, -0.02045237f, 
    -0.00076008f, -0.06546860f, -0.07199518f, -0.01338554f, -0.00857733f, -0.01746507f, -0.04657009f, -0.05988821f, 
    0.03412341f, -0.05354403f, -0.05510477f, 0.00006500f, 0.07702582f, 0.00649602f, 0.06259215f, -0.02096062f, 
    0.00681871f, -0.06342534f, 0.01246386f, -0.03613981f, -0.00348228f, -0.00933793f, 0.02440681f, -0.08427346f, 
    0.05179821f, 0.03301688f, -0.03828426f, 0.07453904f, -0.03730721f, -0.05542370f, -0.07281329f, 0.01955590f, 
    -0.00199966f, 0.04005839f, 0.03688064f, -0.04412613f, -0.02334882f, 0.07453007f, -0.05562009f, 0.00553816f, 
    -0.01337182f, -0.07172894f, -0.01041588f, -0.08211657f, -0.04703949f, 0.01355773f, -0.05344359f, 0.04768349f, 
    0.01706122f, 0.02202731f, 0.05321525f, -0.08523919f, -0.08115128f, -0.00938326f, 0.05333909f, 0.06535982f, 
    0.06885248f, -0.05103634f, -0.06341154f, -0.06516836f, -0.01293743f, -0.07127362f, 0.03345867f, -0.05802928f, 
    -0.03327065f, 0.01191991f, 0.05569812f, -0.01143911f, -0.02324681f, 0.01311377f, -0.07229037f, -0.02684630f, 
    -0.05717218f, -0.05018996f, 0.03890050f, -0.06918059f, 0.04939401f, -0.07029995f, -0.01366008f, -0.04247169f, 
    -0.07801842f, -0.06945255f, -0.00180615f, -0.03761633f, 0.05062888f, -0.05280747f, -0.02407930f, -0.01019302f, 
    0.32931611f, 0.30990773f, -0.02977308f, 0.02686977f, -0.10459636f, -0.10716353f, 0.07830100f, -0.06665158f, 
    -0.05338773f, -0.14602511f, 0.10533585f, 0.45089614f, 0.18652956f, -0.06416254f, -0.04735490f, -0.34743208f, 
    -0.23870507f, 0.05337417f, -0.10001428f, -0.08675147f, 0.11350096f, -0.04766719f, 0.02074381f, 0.06260524f, 
    -0.16936594f, -0.05331646f, 0.04865646f, 0.19182162f, -0.10553186f, -0.01951135f, -0.04437692f, -0.01914727f, 
    -0.37588584f, 0.07279964f, 0.08540083f, 0.09681664f, 0.12850098f, -0.20819810f, -0.28165376f, -0.00578188f, 
    0.03795454f, -0.37394926f, -0.02823665f, -0.14540075f, -0.11226128f, 0.04287999f, -0.07856786f, 0.14679365f, 
    0.14328952f, 0.03747875f, 0.04165215f, -0.38666973f, -0.16830902f, -0.41942903f, -0.21243605f, -0.13369711f, 
    0.23185660f, 0.11703107f, 0.15108326f, 0.02101683f, 0.03068568f, -0.33589274f, -0.13847291f, 0.07068618f, 
    0.28281471f, -0.29935190f, 0.01184861f, 0.23420040f, 0.01564361f, -0.14224713f, -0.01404853f, -0.06870590f, 
    0.08724207f, -0.14507134f, 0.28486484f, -0.05196211f, 0.16129443f, 0.11228621f, 0.27212361f, 0.16060442f, 
    0.32624775f, 0.19512379f, 0.18186024f, 0.10128207f, -0.03190561f, 0.03142564f, -0.02930090f, 0.12137644f, 
    0.15953651f, 0.10983102f, 0.35088316f, 0.13519238f, -0.66696262f, -0.05126911f, -0.05179789f, 0.27218944f, 
    0.17965794f, 0.06381276f, 0.23350538f, -0.14092343f, -0.07452618f, -0.14173780f, 0.01406086f, -0.12439971f, 
    0.00729856f, 0.09662453f, -0.34036803f, -0.52203768f, 0.42485493f, 0.46345633f, -0.36017048f, -0.06241589f, 
    0.04448045f, -0.03986913f, -0.04506348f, 0.05237965f, -0.06612450f, 0.27642667f, 0.04735836f, -0.20224914f, 
    -0.11407407f, 0.08616378f, -0.25955260f, 0.09319519f, 0.12151055f, 0.04957276f, -0.11150380f, -0.09339117f, 
    -0.05895351f, -0.06648149f, 0.10510705f, -0.05990427f, -0.03315127f, 0.29425842f, 0.00865425f, 0.13321377f, 
    0.08839629f, -0.09440795f, 0.00754525f, -0.10688033f, -0.04176025f, 0.04264958f, 0.07282913f, 0.00212160f, 
    -0.55522794f, -0.48941177f, -0.15659748f, -0.04836022f, 0.10930588f, 0.22397469f, -0.03315967f, -0.03263675f, 
    -0.05165843f, 0.16368595f, 0.14648984f, 0.26354247f, -0.06359525f, 0.06841920f, -0.10306958f, -0.00173537f, 
    0.08304980f, -0.13695335f, -0.44370183f, 0.29617235f, -0.08267822f, -0.00760694f, -0.05887755f, -0.00163712f, 
    0.15962639f, 0.06882612f, -0.32458091f, 0.34089610f, 0.20698822f, -0.19683476f, 0.10756595f, 0.03331119f, 
    -0.11366411f, 0.05179176f, -0.15682593f, -0.06479730f, -0.28852528f, -0.67896914f, -0.60216516f, 0.13113637f, 
    -0.08254003f, -0.31930867f, 0.07111399f, 0.17546846f, -0.27510196f, 0.43057051f, 0.17867550f, 0.06357609f, 
    -0.24046671f, -0.27058557f, -0.31856564f, 0.12242801f, -0.01006867f, 0.15495139f, 0.37270513f, 0.16074674f, 
    -0.44495001f, 0.16729884f, 0.10080856f, 0.09239692f, 0.27159363f, 0.18350030f, -0.16519780f, -0.69137657f, 
    -0.41205782f, -0.27131423f, 0.08004308f, -0.07559013f, 0.02741800f, -0.12556164f, -0.21212786f, -0.01583474f, 
    -0.25899267f, 0.14392650f, 0.03584055f, 0.05627877f, -0.06768496f, 0.27651089f, -0.09617524f, -0.00360064f, 
    0.27427432f, 0.20595853f, -0.00037890f, 0.25095090f, 0.01852958f, 0.15559933f, 0.05853613f, -0.08203876f, 
    0.35343274f, 0.10286038f, 0.58131444f, -0.27957702f, 0.10986438f, 0.02994836f, -0.00902310f, 0.11650423f, 
    0.15941207f, -0.20191975f, 0.17028682f, 0.03964638f, -0.19306019f, -0.09095792f, 0.25412682f, -0.01516104f, 
    0.08269133f, -0.23001041f, 0.00849907f, -0.13261883f, 0.23904777f, -0.17417105f, 0.20179157f, -0.03153603f, 
    0.00668747f, -0.19594477f, 0.17764860f, 0.01583445f, 0.21192674f, 0.33102769f, -0.12585326f, -0.25414944f, 
    -0.06855468f, 0.23795804f, 0.02276339f, 0.03339853f, -0.19376327f, 0.09120042f, -0.45098746f, 0.57108027f, 
    0.40869799f, 0.00409159f, 0.16932425f, 0.19440232f, 0.11600360f, 0.18164328f, 0.25571188f, 0.55101156f, 
    -0.09936951f, -0.19658037f, -0.01716017f, 0.22856641f, 0.07680965f, 0.09649497f, -0.04419545f, -0.03789512f, 
    -0.34306160f, -0.26867193f, 0.07395330f, -0.08780865f, 0.44201714f, -0.07319038f, 0.09752200f, -0.02346034f, 
    0.04839677f, 0.09655197f, 0.12909357f, 0.23886147f, 0.03009382f, -0.04504574f, -0.22012343f, -0.08699748f, 
    0.12925774f, -0.01530623f, -0.08104982f, -0.58682138f, 0.68457127f, 0.19208579f, 0.18411829f, 0.09784994f, 
    0.01581841f, 0.01781001f, -0.18930170f, 0.06036365f, 0.03992946f, -0.47013500f, 0.10170568f, -0.00777314f, 
    0.09012340f, 0.20619893f, -0.04986828f, 0.10169548f, 0.16435911f, -0.07931226f, -0.63332200f, 0.13880342f, 
    -0.08080062f, 0.02414860f, -0.11988296f, -0.03595112f, -0.16055369f, 0.04094337f, -0.40257862f, -0.27789944f, 
    0.05150346f, 0.18591891f, -0.10909732f, -0.13872351f, -0.09887756f, 0.23253995f, -0.29038432f, 0.18350671f, 
    0.06212944f, -0.06248597f, -0.23024990f, 0.09803123f, -0.07505307f, -0.11462182f, 0.03938248f, -0.61388355f, 
    -0.41239408f, 0.08447991f, -0.40343922f, 0.10634695f, -0.05977815f, -0.00455313f, 0.29040253f, -0.14688914f, 
    -0.46402159f, -0.12465245f, 0.02310761f, -0.05043534f, 0.09187526f, -0.23169127f, 0.04617825f, 0.07780518f, 
    0.08793434f, 0.54707503f, 0.04755182f, 0.51027614f, -0.04045055f, 0.19154802f, 0.06295454f, 0.06595694f, 
    0.02499781f, -0.09520679f, -0.47184351f, -0.62114894f, 0.38416490f, 0.06208290f, 0.26279771f, 0.42356119f, 
    0.08132011f, 0.08364732f, -0.02241824f, 0.17984253f, -0.51163369f, -0.08687956f, 0.24271919f, 0.10253332f, 
    0.16124842f, -0.18008365f, -0.11377454f, 0.22835073f, 0.19097801f, 0.34894249f, -0.05347129f, -0.13745864f, 
    0.00634630f, -0.09266414f, -0.02465223f, 0.01608674f, 0.03784321f, -0.17992923f, 0.00605902f, -0.23822719f, 
    0.03031044f, 0.04247822f, -0.07668339f, 0.15016457f, -0.00645222f, -0.11931589f, 0.01017728f, 0.32512730f, 
    0.38341627f, -0.29083169f, 0.05594904f, -0.31126121f, 0.11645987f, 0.18457440f, -0.08253964f, 0.65306747f, 
    0.11881331f, -0.25135061f, 0.17442252f, 0.16097564f, -0.21482301f, 0.05050931f, -0.12660000f, -0.18728070f, 
    -0.18759196f, -0.19407119f, -0.12338122f, -0.05658809f, 0.01256322f, 0.07143515f, -0.03476195f, 0.01905320f, 
    0.11091863f, 0.13710542f, 0.33287305f, -0.04353843f, -0.28078634f, -0.08029021f, -0.32110786f, 0.21842377f, 
    0.14395194f, -0.09872676f, -0.75968027f, 0.13611372f, -0.37186053f, -0.11772996f, -0.12236948f, 0.14982462f, 
    0.04815115f, -0.03413337f, 0.00752687f, 0.38539910f, 0.22235778f, 0.11204525f, -0.28004429f, -0.22607864f, 
    -0.07206741f, 0.17142595f, 0.15643457f, 0.28433549f, 0.00363958f, 0.06608042f, 0.22039634f, -0.00400074f, 
    -0.11433329f, 0.04224422f, -0.06284995f, 0.00919503f, -0.00131232f, 0.04136131f, 0.20972514f, 0.28765288f, 
    -0.21125205f, -0.26645404f, -0.12043403f, -0.01105721f, 0.14446460f, -0.03179975f, 0.31326628f, -0.22598949f, 
    -0.03515869f, -0.02088287f, 0.21587487f, -0.12016182f, 0.26352605f, -0.00415607f, 0.32033530f, 0.13721390f, 
    0.13566807f, 0.23706655f, -0.15001041f, 0.05042765f, -0.13641196f, 0.12337710f, -0.14682455f, -0.00462726f, 
    0.30088750f, 0.11174564f, -0.08290271f, -0.03186394f, 0.09967238f, -0.12145606f, 0.05018065f, 0.09225971f, 
    -0.16893692f, -0.25514770f, -0.39387876f, -0.16499762f, 0.32686254f, 0.05007469f, -0.06753510f, 0.02561271f, 
    0.12792239f, -0.28687972f, -0.51481956f, 0.17077492f, -0.70934325f, 0.17884581f, 0.08776207f, 0.03387484f, 
    0.13827522f, 0.00640578f, -0.05012743f, -0.01160992f, -0.24819019f, -0.14250030f, -0.00917717f, 0.21050143f, 
    0.21690278f, 0.03737057f, -0.16396312f, 0.05589974f, -0.26307821f, 0.40745482f, 0.09477661f, -0.28249514f, 
    -0.15351520f, 0.03505031f, 0.08859043f, 0.18475631f, 0.05687325f, 0.03204412f, 0.29041868f, -0.01490605f, 
    -0.23880106f, -0.24518906f, 0.00393332f, 0.24873087f, 0.06545848f, 0.26279020f, -0.41705033f, -0.17093010f, 
    -0.02279514f, -0.24979411f, -0.02699015f, -0.18642329f, 0.08704200f, -0.06303667f, -0.04090396f, 0.43283296f, 
    0.72926140f, 0.20720664f, 0.03088212f, -0.13714814f, 0.01322164f, -0.11767198f, -0.07690013f, 0.05948407f, 
    -0.07307809f, -0.03797454f, 0.03441362f, -0.09992562f, 0.02936651f, 0.01060517f, 0.03753592f, -0.01937877f, 
    -0.05959565f, -0.10215799f, -0.10641125f, 0.01753126f, -0.02544808f, -0.07200911f, 0.00588543f, -0.08658591f, 
    -0.06379931f, 0.03492814f, -0.07149708f, -0.00893860f, 0.05064116f, 0.02216087f, -0.00128865f, 0.00578026f, 
    -0.05664461f, -0.11356620f, 0.01887929f, 0.04130720f, 0.00778983f, 0.04560488f, -0.07150670f, -0.01600746f, 
    -0.09294920f, -0.02183617f, -0.02390109f, -0.04249684f, -0.04811861f, 0.01633702f, 0.02185683f, -0.01523210f, 
    -0.06574720f, 0.02314170f, -0.01395050f, -0.04080433f, -0.00101703f, -0.00656688f, -0.05303170f, -0.00564081f, 
    -0.04617165f, -0.08670807f, -0.05939739f, 0.06190342f, -0.06485754f, -0.10724266f, -0.04380376f, -0.07507282f, 
    0.02668454f, -0.03718160f, -0.01941387f, -0.07505334f, -0.09340677f, -0.03154293f, -0.06536577f, 0.03695825f, 
    0.01672436f, -0.04067832f, -0.04907070f, -0.01589517f, -0.07344361f, -0.04202064f, -0.11421902f, 0.03469938f, 
    -0.04557589f, 0.02864157f, -0.01202561f, 0.00048426f, -0.09394090f, 0.02790417f, -0.02120559f, 0.01806548f, 
    0.03525042f, -0.07406365f, -0.06388544f, -0.08802798f, 0.01968285f, -0.05142404f, -0.11496282f, 0.04229743f, 
    0.01757875f, -0.04804334f, -0.08539040f, 0.00544491f, -0.05170630f, -0.03926392f, 0.01395616f, 0.01215957f, 
    -0.06920810f, -0.08333164f, -0.04507901f, 0.02865585f, -0.03347760f, 0.05648768f, -0.07865538f, -0.09646706f, 
    -0.11598426f, -0.04152167f, -0.10050440f, -0.12192338f, -0.01156519f, 0.00659240f, -0.06540345f, -0.00918872f, 
    -0.04227359f, -0.11190250f, -0.02306376f, -0.07051035f, 0.01022504f, -0.06587116f, 0.02377587f, -0.06356716f, 
    -0.08906730f, -0.04988345f, -0.07820142f, 0.02543952f, 0.00354711f, -0.07318879f, -0.11689281f, 0.03780156f, 
    -0.00110204f, -0.07241376f, 0.00169620f, -0.02412331f, -0.00827277f, -0.08485798f, -0.05683437f, -0.08657874f, 
    0.04757703f, -0.03584869f, -0.08242749f, -0.05428868f, -0.00616339f, -0.01831690f, 0.03299674f, 0.00554491f, 
    0.02987553f, -0.01232586f, -0.08226342f, -0.03388366f, 0.00193818f, 0.05128553f, 0.04421488f, -0.08283474f, 
    0.00944914f, -0.04507410f, -0.09562358f, -0.03011396f, 0.00562567f, -0.05957603f, 0.01137993f, -0.00592108f, 
    0.00871460f, 0.06601439f, -0.04519350f, -0.07041279f, -0.01983375f, -0.03949760f, 0.02537773f, 0.00278410f, 
    -0.07316560f, -0.00291292f, 0.02023900f, 0.05927100f, 0.06559854f, 0.05251035f, -0.05289812f, -0.05391232f, 
    -0.06907844f, -0.01493504f, 0.01828736f, 0.05392775f, -0.05488136f, 0.00086086f, 0.07956281f, -0.01190783f, 
    -0.00683170f, 0.06132435f, -0.05328653f, -0.01928935f, -0.06893893f, -0.01494250f, 0.06295527f, 0.03279479f, 
    -0.07816614f, 0.04335133f, -0.09638134f, 0.06393254f, -0.03667526f, -0.01527162f, -0.00802928f, 0.04316736f, 
    0.00917210f, -0.05451874f, -0.00493929f, -0.09347931f, -0.01135470f, -0.09213084f, -0.01765871f, 0.06333895f, 
    -0.05757535f, -0.04624977f, 0.05779324f, -0.02865209f, 0.03331422f, 0.03501879f, 0.01933379f, -0.09413739f, 
    -0.08676032f, -0.03983343f, -0.03594179f, -0.03646568f, -0.02491660f, -0.06579158f, 0.02927754f, 0.03491601f, 
    -0.06590718f, 0.02121122f, -0.08700967f, -0.01247927f, 0.02044819f, -0.05460311f, 0.01073457f, 0.04840763f, 
    -0.00311883f, -0.08372935f, -0.03815173f, 0.06271596f, 0.05876826f, 0.04224943f, -0.04088886f, -0.08605421f, 
    -0.02716319f, 0.03144218f, 0.04170385f, -0.07138911f, 0.00216088f, 0.04273296f, -0.06359404f, 0.04740234f, 
    -0.01235802f, -0.04962252f, 0.05671638f, 0.05932446f, 0.03564275f, -0.07095835f, 0.02136583f, -0.08629434f, 
    -0.08668257f, -0.01959759f, 0.04867785f, -0.03672813f, 0.03334627f, -0.03825848f, -0.01854156f, -0.06894353f, 
    0.05196977f, -0.06004319f, 0.02956413f, -0.04489234f, 0.06271739f, -0.08052441f, -0.04605456f, -0.09088332f, 
    0.06249962f, -0.02065217f, 0.02875724f, -0.06146566f, 0.01807992f, -0.06340240f, -0.08169475f, -0.03153227f, 
    -0.09000154f, 0.04366226f, -0.00477719f, -0.04186604f, -0.03788941f, -0.03082410f, 0.00739047f, -0.04910259f, 
    -0.13562766f, -0.05289257f, 0.26512262f, -0.13613395f, 0.26104194f, -0.01165632f, -0.05805250f, -0.09961718f, 
    0.09303909f, -0.29692549f, -0.28577629f, 0.16781697f, -0.04145408f, -0.16370156f, -0.16473536f, 0.05147012f, 
    0.04719578f, 0.35831520f, -0.44291493f, -0.13913551f, 0.71254277f, 0.09744924f, 0.25120598f, 0.23713633f, 
    0.07837596f, -0.01346068f, -0.10901707f, -0.02522083f, 0.30119687f, 0.13507229f, -0.25894913f, -0.01503862f, 
    0.02515587f, 0.09010018f, 0.06174982f, 0.09244487f, -0.61252213f, 0.21348158f, 0.47556624f, 0.02411691f, 
    -0.02560871f, 0.05024754f, 0.09133485f, 0.13781221f, -0.04309466f, 0.04219507f, 0.32991377f, 0.19686328f, 
    -0.09732411f, -0.08186790f, -0.04736835f, 0.04374607f, 0.07331182f, 0.08234905f, 0.44514158f, -0.55711246f, 
    -0.19207935f, -0.10627159f, 0.17648357f, -0.12643692f, 0.11795177f, 0.10190027f, 0.00741090f, -0.46172118f, 
    0.01242342f, -0.24233606f, -0.02218031f, 0.07793263f, -0.07924225f, 0.02681539f, 0.00274356f, -0.03379655f, 
    -0.19947806f, -0.54011542f, -0.23084068f, -0.14630517f, 0.02892198f, -0.25901425f, -0.02363054f, -0.15266018f, 
    -0.07470165f, -0.10646775f, -0.24677724f, -0.12043631f, 0.00488523f, -0.18269983f, 0.21288408f, 0.00935740f, 
    -0.07060274f, 0.16108602f, -0.13501635f, 0.60813004f, -0.21977153f, 0.01070202f, 0.08193614f, 0.03381270f, 
    -0.06156626f, 0.06816534f, 0.04752989f, 0.29036510f, 0.26972577f, 0.18467943f, 0.17673901f, 0.19036984f, 
    0.19385348f, 0.06577412f, -0.14720801f, 0.29295257f, -0.32767147f, 0.10757670f, 0.29336262f, -0.37931690f, 
    -0.05731349f, -0.16619548f, 0.04722160f, 0.09738942f, 0.04256183f, -0.36727157f, -0.01466344f, 0.00946225f, 
    -0.06348633f, -0.14225838f, -0.20143577f, -0.15024975f, -0.06267590f, 0.22310548f, -0.03947606f, -1.00394964f, 
    -0.38077676f, -0.14721543f, -0.15183043f, -0.20627406f, 0.11827736f, -0.01968904f, 0.11650790f, 0.01700969f, 
    0.21545850f, 0.40886250f, 0.01734760f, -0.21352240f, -0.38966191f, -0.04559552f, -0.07483566f, -0.19667146f, 
    0.03931068f, 0.05030857f, 0.00809952f, 0.02434742f, 0.04372102f, -0.01846876f, -0.00896153f, 0.00427437f, 
    -0.00996403f, 0.01081830f, -0.04717460f, 0.04778464f, -0.01897151f, 0.00071367f, -0.10406216f, -0.00605056f, 
    -0.08125073f, -0.06961061f, -0.00097676f, -0.08293312f, -0.01843098f, -0.06209245f, -0.12076461f, -0.00008093f, 
    0.02465599f, -0.03955069f, 0.01779060f, -0.06337944f, -0.04647478f, -0.01545616f, -0.07615644f, 0.00466128f, 
    -0.11139189f, -0.04987398f, -0.10239803f, -0.08322475f, -0.01816400f, -0.01765808f, 0.08575858f, 0.03459359f, 
    -0.03439150f, -0.03485706f, -0.00747026f, 0.03305905f, -0.00724559f, -0.10384773f, -0.11680114f, 0.04695546f, 
    0.03201631f, -0.07897608f, -0.03427786f, -0.02736529f, -0.10471995f, 0.04011221f, -0.10116262f, -0.07346462f, 
    -0.07525934f, -0.10461999f, -0.02653938f, -0.02534558f, 0.06633680f, -0.01059893f, -0.10201234f, -0.02757285f, 
    0.08716749f, -0.08253491f, 0.01211105f, -0.08807598f, -0.00718076f, -0.06465220f, -0.01499434f, -0.09216265f, 
    -0.03234059f, 0.09744050f, -0.01381493f, -0.01718298f, -0.08198921f, -0.01524488f, -0.00448237f, 0.02947829f, 
    -0.09390245f, -0.08413938f, 0.00093308f, 0.00108713f, 0.04836942f, -0.01746612f, -0.01856836f, 0.08273844f, 
    0.06586872f, 0.00888371f, 0.01431550f, 0.04504966f, -0.10214486f, -0.06810550f, -0.00095316f, -0.06204078f, 
    -0.04402741f, 0.03120907f, -0.07942992f, -0.02570279f, -0.02515147f, 0.00334379f, -0.02944786f, -0.08267535f, 
    -0.03847563f, -0.04528147f, -0.09089373f, -0.07974496f, -0.07369032f, 0.07553162f, -0.01462506f, -0.06224168f, 
    0.02101970f, -0.11723349f, 0.00774065f, -0.06034661f, 0.00584024f, -0.03482820f, -0.06228857f, -0.06445516f, 
    0.07341754f, -0.06794327f, -0.10031923f, -0.05338813f, -0.05149795f, -0.06099260f, -0.00698935f, -0.03686840f, 
    0.03937880f, 0.00419103f, 0.02324930f, -0.04703562f, -0.04377924f, -0.01567041f, 0.00405150f, -0.05827464f, 
    0.00249553f, -0.04200808f, -0.07939637f, -0.01256366f, 0.00256630f, 0.01555115f, -0.10166815f, 0.00608708f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.08936106f, -0.02756877f, -0.00592529f, 0.29469290f, 0.39558974f, -0.12634692f, 0.00444001f, 0.05745943f, 
    0.05021753f, -0.07546905f, 0.16836683f, 0.11275999f, -0.10190099f, -0.06974488f, 0.36365315f, -0.10928700f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12280545f, -0.17102945f, 0.14272037f, -0.15097412f, -0.00934091f, -0.20616528f, -0.07804814f, 0.09786612f, 
    0.21048570f, -0.24848455f, 0.13215560f, 0.14960429f, -0.05674481f, 0.03408104f, 0.01470026f, -0.24866775f, 
    0.18338202f, 0.43014306f, 0.20276506f, 0.12658329f, -0.31614819f, 0.27226576f, 0.04374135f, 0.00048549f, 
    0.21400639f, 0.42401224f, -0.37121728f, 0.29772544f, 0.11616277f, 0.03820362f, 0.41227958f, -0.04978675f, 
    -0.27397624f, -0.29146400f, 0.22564000f, 0.12796988f, 0.35416579f, 0.16406779f, -0.17652482f, -0.17879066f, 
    -0.21046074f, 0.07997857f, -0.50634778f, -0.10378263f, -0.10595705f, -0.07436479f, 1.08178365f, -0.05848422f, 
    -0.13100220f, -0.23734261f, -0.18258879f, 0.24220455f, 0.05118981f, 0.51548356f, -0.08148012f, -0.13240574f, 
    0.45048094f, -0.02901530f, -0.21348052f, 0.22456482f, 0.11098889f, -0.01145920f, 0.19420117f, -0.06102270f, 
    0.33438268f, -0.01345883f, -0.06582663f, 0.26009709f, 0.20575044f, 0.29673862f, 0.22557610f, -0.18792790f, 
    -0.01326180f, -0.34651685f, -0.59188122f, 0.06745902f, -0.08011707f, -0.15443771f, 0.19679883f, -0.03940398f, 
    -0.38329008f, 0.02971267f, -0.01235805f, -0.13537548f, 0.32001460f, -0.59957290f, -0.16422483f, 0.14184427f, 
    0.38163546f, -0.10146420f, 0.27889141f, -0.11868844f, 0.14822961f, 0.07770452f, -0.10603669f, 0.17638330f, 
    0.11947714f, 0.23232269f, 0.05384188f, -0.20876537f, 0.18942100f, 0.36301190f, 0.08574441f, 0.16033325f, 
    0.32189500f, 0.13114117f, 0.52806300f, -0.28125539f, 0.12293970f, 0.16100891f, -0.44207704f, 0.21371725f, 
    -0.32182884f, 0.26116008f, 0.12099883f, 0.26833215f, 0.23413654f, 0.53870010f, -0.23790818f, 0.21554992f, 
    0.38133219f, -0.51445240f, -0.14113903f, -0.02140133f, 0.22977230f, 0.11502333f, -0.42007944f, 0.03598325f, 
    -0.26809543f, 0.55944371f, 0.24475074f, -0.10785581f, 0.00461849f, -0.03494764f, 0.24686384f, -0.03277297f, 
    -0.14715543f, 0.06708885f, -0.09605985f, 0.28809154f, -0.02277796f, -0.18655404f, 0.25469491f, -0.04265299f, 
    0.73252732f, 0.18861826f, -0.10492950f, 0.38162845f, -0.32986438f, -0.30186525f, 0.14347169f, 0.12893493f, 
    -0.88389391f, -0.50599897f, 0.56524479f, -0.02829828f, -0.03142609f, 0.10586184f, 0.66264474f, -0.00182299f, 
    -0.19349851f, -0.11101216f, -0.02105886f, -0.12851807f, 0.07262985f, 0.18010625f, 0.17091930f, -0.10757895f, 
    0.09627445f, 0.18037184f, -0.62924856f, 0.08650321f, -0.22797006f, 0.22632216f, 0.05731900f, 0.26734602f, 
    0.04732573f, 0.08014033f, -0.15566140f, 0.26915836f, -0.24138400f, 0.08010651f, -0.05745894f, 0.03458482f, 
    -0.10073164f, 0.10921005f, 0.27549106f, 0.18257284f, -0.06394529f, 0.07193792f, -0.32728153f, 0.11562639f, 
    -0.15702167f, -0.25935057f, 0.20258620f, 0.00563155f, -0.25990674f, 0.43692645f, -0.18339354f, -0.12198561f, 
    0.46629179f, 0.39972192f, 0.44709286f, 0.22845592f, -0.05924009f, 0.21597674f, -0.73110348f, -0.06005469f, 
    0.40523350f, -0.14999723f, 0.17989628f, 0.15258211f, 0.11931930f, -0.37903783f, -0.08383662f, 0.20865649f, 
    -0.30008790f, 0.02574015f, 0.83150309f, -0.01813083f, 0.07601692f, -0.04851121f, -0.53556830f, 0.02051793f, 
    -0.35732150f, 0.06805450f, -0.01499048f, 0.04261506f, 0.20065285f, 0.01605578f, 0.03594810f, -0.20699184f, 
    0.02040995f, 0.11300319f, 0.28234383f, -0.43487751f, -0.07795566f, -0.18166809f, 0.36278367f, 0.11644232f, 
    -0.15840398f, 0.28104863f, -0.17963691f, -0.16306071f, 0.19315994f, -0.03811503f, -0.10377550f, 0.17154121f, 
    0.23032685f, 0.31861240f, -0.24466068f, -0.42988104f, -0.19024658f, -0.01954133f, 0.79885340f, 0.09735683f, 
    0.46706998f, -0.25414717f, 0.04416462f, 0.41310838f, -0.37129578f, 0.54132485f, 0.06123194f, -0.17067209f, 
    -0.34218198f, 0.01088862f, 0.14761429f, 0.48265547f, -0.18269485f, -0.17052986f, 0.20541704f, -0.05313713f, 
    -0.18758193f, 0.04865059f, 0.06478286f, -0.13620430f, -0.10148323f, -0.18381369f, -0.16122150f, 0.15022716f, 
    -0.21111009f, -0.22568408f, -0.09433025f, 0.10851777f, -0.21137714f, -0.11071151f, -0.17522186f, -0.07365480f, 
    -0.46934047f, 0.42415801f, 0.10986172f, 0.12590933f, 0.32663885f, -0.09661317f, 0.11416724f, 0.09025962f, 
    0.47128516f, -0.20112167f, 0.57222772f, -0.61501926f, -0.14861400f, -0.22381160f, -0.22895549f, -0.14798367f, 
    0.01503351f, 0.19458763f, 0.18974766f, -0.39585078f, -0.05925452f, 0.63222450f, -0.10338694f, -0.25002077f, 
    -0.01594347f, 0.23161431f, 0.40214264f, 0.05943822f, 0.02655208f, -0.11027827f, 0.57855433f, 0.20063995f, 
    -0.21031196f, -0.13563076f, 0.13155827f, 0.51615715f, 0.04979248f, 0.04500070f, 0.05494291f, -0.11867432f, 
    -0.02024399f, -0.01253730f, -0.32122153f, -1.01817322f, -0.17262083f, -0.21168178f, 0.67724681f, 0.01927687f, 
    0.21589559f, 0.19831762f, -0.06224908f, 0.39287803f, -0.27804410f, 0.58078408f, -0.21977469f, -0.07559969f, 
    -0.38908154f, -0.40153855f, -0.02615821f, 0.71691340f, -0.06091615f, 0.06809362f, -0.63945520f, -0.25262681f, 
    0.18837389f, 0.45697325f, -0.03428367f, 0.09327643f, 0.00030588f, 0.47899687f, -0.01115292f, -0.15055473f, 
    0.32152694f, -0.50017679f, -0.14185934f, -0.21252966f, 0.16090886f, -0.05660009f, -1.05676198f, -0.13451220f, 
    -0.20391220f, 0.62576640f, -0.18316564f, -0.02460355f, -0.24299066f, 0.31969732f, -0.16454041f, 0.00573530f, 
    0.09862886f, 0.47707561f, 0.00018677f, 0.29285675f, 0.14755049f, -0.03579281f, 0.03222911f, -0.15095963f, 
    0.12933572f, -0.13960764f, -0.23734757f, -0.12460883f, -0.42436105f, 0.53765589f, 0.02884823f, 0.19860961f, 
    0.60058296f, 0.06855594f, 0.40416986f, -0.25437319f, 0.00287399f, -0.07262357f, -0.61857009f, 0.21131502f, 
    0.28296438f, -0.25986427f, -0.19514833f, -0.09941544f, -0.00208173f, 0.35173139f, -0.10025874f, 0.02950224f, 
    -0.35090449f, 0.31247759f, 0.12866934f, 0.20666938f, -0.12403852f, -0.18057072f, 0.68090272f, -0.13695817f, 
    0.25323212f, -0.24499111f, 0.04586782f, 0.36391863f, 0.39625323f, -0.71280801f, -0.21671745f, -0.21571262f, 
    -0.17241813f, -0.22297162f, -0.29610249f, 0.24613905f, 0.18997058f, -0.20918037f, 0.21806858f, 0.24581964f, 
    -0.24606636f, 0.52051675f, 0.15350561f, 0.37853512f, -0.01015450f, -0.45050588f, 0.17377904f, -0.13941438f, 
    0.18363589f, -0.72240388f, 0.31700122f, -0.44814250f, -0.10741695f, 0.14554434f, 0.48871994f, -0.09948221f, 
    0.50228274f, -0.29570949f, 0.23076597f, 0.04330771f, 0.46085516f, -0.58907127f, 0.24314252f, 0.13995938f, 
    -0.19628109f, -0.19691254f, -0.35529068f, 0.42314640f, -0.10328347f, 0.01691976f, 0.80758661f, 0.01487420f, 
    -0.10701496f, -0.49128154f, -0.00959827f, 0.29234859f, 0.07632059f, 0.48483860f, -0.07325125f, 0.24659714f, 
    -0.43857253f, 0.20877071f, 0.14964506f, 0.18792783f, -0.01431462f, -0.14671360f, 0.27340281f, -0.26575148f, 
    -0.00613243f, 0.17625882f, -0.10244789f, 0.43100971f, 0.30704448f, -0.35793027f, 0.24118665f, -0.09006891f, 
    -0.34517717f, -0.24179776f, 0.77964467f, -0.08081470f, 0.09232455f, -0.04305461f, -0.85627240f, 0.24087745f, 
    0.20585792f, 0.30307060f, -0.13233563f, -0.30986905f, 0.53539515f, -0.18808036f, -0.10733521f, -0.06506576f, 
    -0.35682437f, 0.05344408f, 0.17524850f, -0.04896440f, 0.19370766f, 0.02679956f, 0.86484659f, -0.18717946f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20013502f, -0.31376612f, 0.47878247f, 0.47527906f, 0.08538877f, -0.07892658f, 0.39036682f, 0.23659168f, 
    0.17601550f, 0.43617991f, 0.26043564f, -0.49044403f, -0.01603575f, 0.04328130f, 0.13608134f, 0.06547978f, 
    -0.37097603f, -0.08546016f, -0.06610350f, -0.12876421f, 0.36262563f, -0.05680737f, 0.01435188f, 0.09062064f, 
    -0.46281382f, -0.17837507f, 0.33901712f, 0.12984894f, 0.30017108f, 0.08390731f, 0.11251912f, 0.61843246f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02112590f, 0.09495012f, 0.04227847f, 0.25671566f, 0.15480912f, -0.07632264f, 0.20394485f, 0.08458983f, 
    -0.18572006f, -0.88918030f, 0.02129775f, 0.13302760f, 0.13989101f, -0.32868263f, -0.39191112f, -0.01916006f, 
    0.14222284f, -0.09003250f, -0.24410652f, 0.27216804f, -0.56000549f, 0.18835820f, 0.33388665f, -0.03948593f, 
    1.24626672f, 0.01468650f, -0.11461592f, -0.85404629f, 0.07106100f, -0.10845705f, -0.54224360f, -0.26221272f, 
    -0.11435085f, -0.26341072f, 0.24850011f, 0.28210756f, 0.09532344f, -0.19204712f, 0.21942791f, 0.20613068f, 
    -0.11618280f, -1.62884057f, -0.07549150f, -0.33013123f, 0.31097126f, 0.15957668f, 0.20431378f, 0.20576106f, 
    -0.33080882f, 0.02026448f, 0.14122225f, 0.35415971f, 0.36761147f, -0.12293176f, 0.36335090f, 0.01156409f, 
    -0.97733861f, -0.00795784f, -0.48148727f, -0.50072676f, -0.39661106f, 0.11693927f, -0.04228167f, 0.10261885f, 
    0.02845555f, -0.06694566f, 0.32509229f, 0.22758709f, 0.37050453f, -0.02069310f, -0.58486176f, -0.15038954f, 
    -0.36013290f, 0.39306459f, 0.15712988f, -0.21225399f, 0.28726196f, -0.67173183f, -0.26343289f, 0.13573620f, 
    -0.29064792f, -0.10758168f, -0.45314652f, -0.80929518f, 0.69577754f, -0.20587842f, -1.32668900f, -0.45313182f, 
    -0.51650035f, -0.06243436f, 0.31431213f, 0.52498049f, 0.18198146f, -0.09513558f, -0.22063164f, 0.02475389f, 
    0.10447060f, 0.04208889f, -0.63456261f, 0.11032967f, 0.02175396f, 0.02322287f, -0.07650748f, -0.00424774f, 
    -0.03971998f, 0.49177325f, 0.25904945f, 0.30011854f, 0.62839907f, -0.81031704f, -0.20186459f, -0.40368935f, 
    0.04437599f, 0.09728588f, 0.09511034f, -0.37941283f, 0.43344545f, 0.26655185f, 0.35626712f, 0.07681575f, 
    -0.24341333f, -0.73129928f, 0.22345741f, 0.17138256f, -0.18192966f, -0.19757898f, 0.37397006f, -0.58419478f, 
    0.04751722f, 0.35376945f, -0.41871950f, -0.05916826f, 0.18811530f, 0.07885399f, -0.11239474f, -0.00774330f, 
    0.14065136f, 0.12331562f, -0.05155548f, 0.20532377f, 0.17280982f, 0.11545452f, -0.25767669f, -0.04558833f, 
    0.14364013f, 0.14422217f, -0.44171530f, 0.08173299f, -0.72873437f, 0.32305959f, 0.04190549f, 0.34664431f, 
    -0.97677869f, -0.09865372f, -0.29541057f, -0.03146824f, -0.28149956f, -0.07979775f, 0.02673036f, -0.10079710f, 
    0.15428993f, -0.10707625f, 0.17628710f, 0.32914278f, 0.17262037f, -0.45516610f, -0.20249277f, 0.24605627f, 
    0.10191178f, -0.96595842f, -0.48818678f, -0.01637512f, 0.07133033f, -0.21913673f, -0.04197508f, -0.17117816f, 
    0.08662336f, 0.07355078f, 0.20785332f, -0.04641972f, 0.37383360f, 0.03177369f, -0.11097489f, -0.01118077f, 
    -0.34656841f, -0.07120949f, 0.03609013f, 0.27476531f, -0.18643641f, 0.20719606f, 0.09021764f, -0.17205420f, 
    -0.14410433f, -0.25860000f, 0.40281293f, -0.13774769f, -0.11076058f, 0.03853715f, -0.41654408f, -2.42533779f, 
    -0.53783178f, 0.28642520f, 0.12551089f, -0.05407031f, -0.67254013f, -0.06404059f, 0.03480037f, 0.17558503f, 
    0.17072080f, -0.13844603f, -0.58930379f, -0.46010002f, 0.02960708f, -1.20442355f, -0.71782410f, -0.36715999f, 
    -0.14632098f, 0.33275136f, 0.35838035f, -1.16539729f, 0.60559827f, 0.34677726f, -0.03284027f, 0.24623662f, 
    -0.05517119f, -0.07133667f, -0.27043507f, -0.05411008f, -1.43047190f, -0.21716371f, 0.02305807f, -0.70078802f, 
    0.60512573f, 0.85023403f, 0.23912200f, 0.44205731f, 0.08579484f, 0.30814090f, 0.01234137f, 0.05798800f, 
    0.40748385f, -0.07942849f, -0.05428325f, 0.33401841f, -1.09648740f, 0.12205461f, -0.21033892f, 0.17864385f, 
    -0.42342794f, 0.15157548f, -0.40647799f, -0.41535717f, -0.34930590f, 0.19677140f, 0.19140694f, -0.01712827f, 
    0.01485898f, -0.48498985f, -0.19365865f, -0.05928293f, -0.10390258f, 0.46710625f, 0.34565836f, 0.27357098f, 
    -0.16987902f, -0.66213435f, -0.04082904f, -0.38942289f, -0.41094682f, 0.30231762f, 0.07203744f, -0.09851383f, 
    -0.96916956f, 0.04398650f, 0.44568580f, -0.02747968f, -0.42449689f, -0.58765632f, 0.11392514f, -0.44669288f, 
    -0.97742450f, -0.53726619f, 0.09025110f, 0.49489394f, 0.10149386f, -0.34287512f, 0.37243930f, 0.24873304f, 
    -0.14927241f, -0.21415401f, 0.08710704f, -0.08050397f, 0.23659788f, -0.35831881f, -0.27146941f, -0.43419525f, 
    0.38680843f, 0.23277645f, -0.19170929f, -0.15873449f, -0.45773298f, 0.05367567f, -0.41970620f, -0.23928025f, 
    0.19398963f, 0.12111877f, -0.95112365f, -0.10987095f, -1.92943263f, 0.45253944f, -0.37434274f, -0.35627860f, 
    -0.60929292f, 0.11590954f, 0.36613023f, -0.65681589f, 0.54187888f, 0.19383846f, 0.07433477f, 0.33822265f, 
    -0.06922304f, 0.39339226f, 0.13401949f, -0.13350350f, -0.19803756f, 0.08672274f, -0.01648059f, -0.14446920f, 
    0.38499451f, -0.36998603f, -0.05763563f, -0.38855121f, -0.43284279f, -0.60571444f, 0.11944779f, 0.66827446f, 
    -0.68441314f, -0.00733224f, 0.33121476f, 0.08867082f, 0.43245324f, -1.33831990f, -0.36145234f, 0.40824455f, 
    -0.84810817f, -0.36659664f, -0.22116753f, 0.45979840f, -0.17728548f, -0.72978532f, -0.26945218f, 0.37049633f, 
    0.07932530f, -1.09896863f, 0.07620560f, -0.97180718f, -0.48950782f, 0.22324742f, 0.02019367f, -0.41152802f, 
    -0.49756488f, 0.64599913f, -0.08408392f, 0.16357546f, -0.19446948f, 0.43463176f, 0.07054832f, 0.08022741f, 
    -0.41161430f, 0.10499199f, 0.38610989f, -0.44086218f, -0.01835920f, 0.35481948f, -0.12641592f, -0.51947123f, 
    -0.05790183f, -0.02991821f, 0.08521483f, 0.27366388f, -0.10138234f, 0.02749517f, 0.48364362f, 0.20336026f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23541224f, 0.63110512f, -0.23203662f, 0.12138592f, -0.22543798f, -0.37481126f, -0.12421077f, -0.50832075f, 
    0.09430965f, 0.59349537f, 0.16208889f, 0.01805183f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
