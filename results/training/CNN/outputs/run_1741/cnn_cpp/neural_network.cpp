#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.03744912f, -0.34260023f, -0.02270903f, -0.03382474f, -0.03276054f, -0.49834913f, 0.16992503f, 0.01892800f, 
    -0.46613798f, 0.43828124f, 0.69452268f, -0.64277220f, -0.10320683f, -0.07392946f, -0.25484368f, -0.21925254f, 
    0.22240010f, 0.08728684f, -0.59756738f, -0.46936727f, 0.95032758f, -0.17093997f, -0.67576402f, -0.32844794f, 
    0.14789523f, 0.57608521f, 0.12890533f, -0.21509969f, 0.13715664f, -0.23788150f, 0.07493959f, 0.23516880f, 
    -0.61366558f, 0.26981619f, 0.22276405f, 0.65967673f, 0.74080700f, -0.23966190f, 0.76334727f, -0.10100962f, 
    0.14665069f, -0.51503283f, 0.08351830f, 0.04886503f, 0.08758538f, 1.36785710f, -0.43991259f, -0.05885160f, 
    0.03933353f, 0.20458078f, 0.25672156f, 0.45178044f, -0.43227750f, -0.04534670f, -0.67558098f, 0.92482853f, 
    -0.10561228f, -0.05818490f, 0.60721004f, 0.34384814f, 0.42354262f, -0.47423014f, 0.01173604f, 0.25957462f, 
    -0.02920942f, 0.58689618f, 0.69848651f, 0.11710346f, 0.81805414f, 0.22467247f, 0.04207407f, 0.02363071f, 
    -0.66109645f, -0.27542645f, 0.44399062f, 0.51223421f, -0.62170577f, 0.85271150f, -0.32966900f, -0.17314151f, 
    -0.42668557f, 0.29016265f, -0.43424535f, -0.01238478f, -0.64071912f, 0.15574385f, 0.54816180f, 0.19350170f, 
    0.43754309f, 0.68017167f, -0.13644351f, -0.13281912f, 0.07665880f, -0.87201369f, -0.14214009f, 1.08676040f, 
    0.21806450f, -0.38753030f, -0.03956796f, 0.83121896f, 0.71047068f, 0.07548791f, 0.32006803f, 0.29582682f, 
    0.00575611f, 0.45790675f, 0.43645677f, 0.22965093f, -0.29694298f, 0.25023189f, 0.05003093f, -0.21583527f, 
    -1.05303049f, -0.68750304f, -0.46247107f, -0.17928013f, -0.38600212f, -0.55189490f, -0.83780873f, -0.24184680f, 
    0.24547744f, 0.26665410f, -0.17192176f, -0.60825902f, -0.39288646f, -0.22166975f, 0.03457154f, 0.41861403f, 
    -0.40728539f, -0.68141484f, -0.54656112f, -0.46011934f, 0.49446043f, 0.36338282f, 0.26518875f, -0.85694659f, 
    -0.10420512f, -0.26340476f, 1.01158595f, 0.34361508f, 0.39721459f, 0.05414874f, 0.00418890f, 0.14958018f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32309175f, 0.51432955f, 0.19177406f, 0.21710473f, 0.43488872f, 0.04315517f, 0.00062896f, 0.16065712f, 
    -0.15080959f, 0.39273059f, 0.03178781f, 0.39821604f, 0.18702717f, 0.30225036f, 0.03472478f, -0.43700102f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.49296254f, -0.10879515f, -0.20039453f, 0.01052762f, -0.15638019f, -0.04024921f, 0.11469894f, -0.04627694f, 
    0.08231363f, -0.34301156f, 0.17025432f, -0.10530414f, -0.12826781f, 0.18472375f, 0.17694846f, -0.05429656f, 
    -0.09429935f, -0.10693140f, 0.51642996f, 0.42235601f, -0.43662426f, -0.04707431f, 0.08479171f, -0.05530668f, 
    0.06089182f, -0.01703228f, -0.01035504f, 0.35116532f, 0.02770587f, 0.07632015f, -0.28343713f, -0.00459031f, 
    0.00764239f, 0.13259648f, 0.14471301f, 0.23297992f, -0.48963079f, 0.08044911f, 0.26069155f, 0.07515230f, 
    0.12719586f, 0.05398472f, 0.31314567f, -0.04340088f, -0.08192080f, -0.33607286f, -0.21462549f, 0.00086840f, 
    -0.30926079f, 0.04166939f, -0.11997157f, 0.19260994f, -0.02693841f, -0.05375256f, 0.12246083f, 0.13492501f, 
    0.22197782f, -0.16390653f, -0.11160391f, -0.08457997f, -0.02538728f, 0.14953239f, -0.16363285f, 0.14713527f, 
    0.29753974f, 0.13554214f, -0.14754260f, -0.09796584f, -0.36710340f, 0.14314319f, -0.16541274f, 0.12785168f, 
    0.32839996f, 0.17177327f, -0.31578901f, 0.20643398f, 0.06089015f, -0.06864064f, 0.07984065f, -0.20214276f, 
    -0.14895235f, -0.25945288f, -0.23890997f, 0.08101355f, 0.14631876f, 0.09482716f, -0.05935419f, 0.11441381f, 
    -0.00958762f, 0.08810487f, -0.32921913f, -0.06359906f, -0.12267059f, -0.23217750f, -0.16631219f, -0.08874308f, 
    -0.04385238f, -0.00614445f, -0.06126278f, -0.07235219f, 0.16019560f, 0.13711800f, 0.01587841f, 0.06735316f, 
    0.22452417f, 0.15250812f, 0.19167005f, 0.09063857f, 0.42341918f, 0.14898132f, -0.26963523f, 0.04421017f, 
    -0.13012326f, -0.00797652f, 0.03716869f, 0.04720108f, -0.00713355f, 0.13609506f, -0.10264335f, -0.32522762f, 
    0.03518814f, 0.12279578f, -0.19841067f, 0.06251242f, -0.05197571f, 0.04681883f, 0.17367554f, 0.20475622f, 
    -0.00857297f, -0.17507599f, -0.11341155f, 0.07921140f, -0.01780513f, 0.11220070f, 0.06739014f, 0.18997578f, 
    -0.04460719f, 0.00294280f, -0.34225485f, -0.25268143f, -0.16786569f, 0.04091487f, -0.06556888f, 0.13382225f, 
    -0.55122507f, -0.26340407f, -0.12308636f, -0.04487236f, -0.04287675f, -0.05992138f, 0.19623879f, -0.16098113f, 
    0.01036461f, 0.11926922f, -0.09911432f, 0.03875532f, 0.13409899f, 0.07242563f, 0.33174926f, 0.16075675f, 
    -0.06989492f, 0.13449062f, -0.63465208f, -0.42012221f, 0.27940699f, 0.09931424f, 0.02626242f, 0.05920481f, 
    -0.02343636f, -0.01950408f, 0.14273013f, -0.09158846f, 0.21943791f, 0.11194087f, 0.00107970f, 0.21953322f, 
    0.09522088f, 0.07225337f, -0.10547892f, -0.06090027f, 0.17350647f, -0.02193223f, -0.24067269f, 0.14542328f, 
    -0.01199076f, -0.10955784f, 0.26833445f, -0.08189753f, 0.06115731f, 0.17336889f, -0.09173088f, -0.03205954f, 
    -0.00174800f, -0.06286089f, 0.10353235f, -0.01207582f, 0.00999615f, -0.24520454f, 0.15481380f, 0.48896292f, 
    -0.08089241f, -0.10464950f, -0.14218618f, -0.00209451f, -0.00444361f, 0.04563027f, -0.08333016f, 0.15159968f, 
    0.21286881f, -0.15109889f, -0.09809535f, -0.21481669f, -0.07438467f, -0.02356623f, -0.06892136f, -0.12960964f, 
    0.04888964f, 0.11096469f, 0.02906136f, -0.03843497f, -0.09753849f, -0.11941855f, 0.04713119f, 0.12389438f, 
    0.01852498f, 0.15553302f, 0.01810894f, -0.22965081f, 0.05919369f, 0.16285138f, 0.20271997f, 0.05530146f, 
    0.06315938f, 0.02327034f, -0.02279821f, 0.24751574f, 0.45810845f, 0.03230900f, -0.05047727f, 0.16063061f, 
    0.21956700f, 0.20735654f, -0.10060284f, 0.34193379f, 0.20375171f, 0.01955568f, 0.05786396f, -0.03987802f, 
    0.20737873f, 0.08834371f, -0.01401929f, 0.04816301f, 0.01019648f, -0.40162081f, 0.13964024f, -0.00677480f, 
    -0.07564732f, 0.13348544f, 0.02795589f, -0.04473697f, 0.03244854f, 0.05306675f, -0.46851191f, -0.63337237f, 
    -0.01499863f, 0.03125821f, 0.19611353f, 0.06381638f, 0.10396784f, 0.05988076f, 0.28858015f, -0.11414008f, 
    -0.58329320f, -0.11661892f, -0.01297583f, -0.16447611f, 0.08273681f, -0.10203370f, 0.15746953f, -0.24994448f, 
    -0.06489471f, -0.49587342f, -0.01535106f, -0.15734652f, 0.03441772f, 0.01613268f, -0.17558125f, 0.05779969f, 
    0.13904196f, 0.06034019f, 0.04234348f, 0.00439994f, 0.01152909f, 0.07464184f, 0.20487605f, 0.03389646f, 
    -0.01534039f, 0.11716404f, -0.15245336f, -0.09864752f, -0.01987857f, 0.02572045f, 0.14167927f, 0.11635713f, 
    0.26544055f, 0.06680397f, -0.30437478f, 0.19534090f, 0.24237131f, -0.07422502f, -0.18516603f, 0.05120622f, 
    -0.25463256f, 0.07856848f, 0.09330483f, 0.04434676f, 0.04003191f, 0.31388888f, 0.08121877f, -0.09063942f, 
    0.01913970f, 0.02018010f, -0.18923336f, 0.11012150f, -0.11969397f, -0.13247351f, -0.43606579f, -0.06198010f, 
    0.06260908f, 0.06315717f, 0.02975823f, -0.04481904f, 0.12747326f, 0.29900467f, -0.06380934f, -0.06050289f, 
    0.03048667f, 0.05446489f, -0.09812155f, -0.08876144f, 0.02539053f, 0.11794791f, -0.19975987f, -0.41628900f, 
    -0.15033694f, -0.06961777f, -0.05639634f, -0.10461824f, -0.10568880f, -0.10348520f, 0.10878631f, -0.14126661f, 
    -0.05213374f, -0.01521029f, -0.20676026f, -0.08352156f, -0.24454425f, 0.08721441f, 0.06420670f, 0.02086486f, 
    -0.50414503f, 0.03025388f, -0.15686812f, -0.03824048f, 0.10430841f, -0.26107517f, 0.20926285f, -0.07419906f, 
    -0.16287708f, 0.08579348f, -0.06052073f, -0.02279935f, -0.03961466f, 0.23093650f, 0.13962662f, 0.11320577f, 
    -0.13231900f, 0.00675639f, -0.32470244f, 0.15379244f, 0.01044449f, 0.12661219f, 0.15473717f, -0.01471104f, 
    0.07812446f, 0.13567473f, -0.06457385f, -0.39062232f, -0.37208590f, 0.02991229f, 0.26434344f, 0.03243104f, 
    -0.05430305f, 0.15268040f, 0.12855254f, 0.23734054f, -0.03740096f, 0.05140560f, 0.11785147f, 0.05237483f, 
    0.05749027f, -0.04418425f, -0.00782607f, -0.05260123f, -0.08116725f, -0.07401076f, 0.27857462f, 0.17538036f, 
    0.11640923f, 0.09592012f, 0.00035316f, 0.40040061f, 0.14124918f, -0.14106084f, -0.40898955f, -0.01560949f, 
    0.18160991f, 0.01636349f, 0.00433581f, -0.02211640f, -0.07053559f, -0.17694843f, -0.03885382f, 0.04444260f, 
    0.03767078f, 0.39461437f, -0.00505357f, -0.07047231f, -0.19818300f, -0.13567175f, 0.10639960f, 0.16519645f, 
    -0.06384493f, -0.21127304f, 0.05014642f, 0.07215931f, 0.19460468f, 0.20156641f, 0.11647686f, -0.19121529f, 
    0.16969950f, -0.02192486f, 0.05700427f, 0.03809408f, 0.09459833f, -0.10041947f, 0.18025769f, -0.10741803f, 
    0.06367781f, 0.01377482f, 0.29328945f, -0.05859907f, -0.08230772f, 0.13300414f, 0.04018389f, -0.11758655f, 
    0.14348236f, -0.04223381f, -0.02320956f, 0.22872390f, 0.11642474f, 0.00727273f, 0.20367320f, 0.04050573f, 
    0.15355310f, -0.10900692f, -0.31415766f, -0.23647012f, 0.26947421f, 0.06958636f, -0.17578669f, 0.08045778f, 
    0.11219727f, 0.02402619f, 0.10883739f, 0.11276840f, -0.07078378f, -0.13042983f, 0.14691316f, -0.15931033f, 
    0.01031524f, 0.04319092f, 0.07436499f, 0.12424127f, 0.10677806f, -0.01543746f, -0.06857811f, 0.34390867f, 
    -0.26217526f, 0.00425808f, 0.19852030f, -0.06621840f, -0.09508064f, -0.27185476f, 0.00279982f, 0.14029157f, 
    -0.13790385f, 0.02547790f, 0.03209104f, 0.03960944f, 0.02774004f, 0.02509093f, -0.19499579f, -0.18882743f, 
    0.20769447f, -0.18134277f, -0.16219017f, -0.04040183f, 0.06233519f, 0.14273819f, 0.10311297f, -0.05345343f, 
    0.06975529f, 0.03184050f, -0.15875837f, 0.01266337f, 0.18170150f, 0.09296594f, 0.02297941f, -0.23083454f, 
    -0.22967784f, -0.07676912f, 0.15517697f, 0.07889233f, 0.00052925f, -0.04605541f, 0.05207842f, 0.07934514f, 
    0.06341518f, 0.10314916f, 0.09269749f, 0.04283376f, 0.06794181f, 0.07180687f, 0.03909540f, -0.00259370f, 
    0.07439502f, -0.01725050f, 0.10751110f, -0.24489884f, 0.26526076f, 0.26831153f, 0.12127190f, 0.19555502f, 
    -0.07946603f, -0.04375409f, -0.06058192f, 0.08299865f, 0.00389564f, -0.02901633f, -0.00384666f, 0.11058471f, 
    0.03380477f, 0.03607264f, 0.09785429f, -0.02969569f, 0.17983641f, 0.02787869f, 0.25872803f, 0.28841785f, 
    -0.05135332f, 0.36552614f, 0.22235985f, -0.03287192f, -0.11544175f, -0.02302606f, -0.15309693f, 0.05577006f, 
    0.21472619f, 0.16323039f, -0.04664365f, -0.07216590f, 0.10968575f, 0.17298350f, -0.22386543f, 0.10583292f, 
    -0.00382353f, -0.04802504f, 0.12324768f, -0.02310684f, 0.12659487f, 0.12658243f, -0.02477492f, -0.01170879f, 
    0.08006448f, 0.61216050f, -0.01364340f, 0.21045399f, 0.00799802f, 0.10431956f, 0.31328896f, 0.20916124f, 
    0.06000626f, 0.20886225f, 0.27344576f, -0.36082271f, 0.12102858f, 0.04509407f, -0.12149107f, 0.06937838f, 
    0.10093136f, 0.15088849f, 0.05392476f, -0.06326732f, -0.17316778f, 0.24663606f, -0.22814295f, 0.06489535f, 
    -0.00909133f, 0.21216956f, 0.09710852f, 0.05648194f, 0.16043104f, -0.18307255f, -0.19232042f, 0.24957554f, 
    0.10691974f, 0.08746150f, 0.11341114f, -0.02420763f, -0.07781185f, 0.45890662f, 0.19086926f, -0.00601358f, 
    -0.11549199f, -0.13215901f, -0.24261861f, -0.09071793f, -0.08487225f, -0.09484088f, 0.03474700f, -0.21847536f, 
    -0.22850752f, 0.09848017f, 0.03855736f, -0.16304043f, -0.02256929f, 0.00134175f, -0.18109074f, -0.19135666f, 
    -0.56947094f, -0.10322016f, 0.00134364f, -0.00208237f, -0.03075833f, -0.10707416f, -0.17734453f, -0.00444430f, 
    -0.24007259f, -0.12114124f, -0.27091590f, -0.13197888f, -0.11718652f, 0.17158161f, -0.41351762f, -0.16273808f, 
    -0.08246355f, 0.25866157f, -0.10773341f, -0.13157012f, -0.01572241f, -0.07398898f, 0.02652102f, 0.14897804f, 
    0.19637124f, 0.06580026f, -0.16494009f, -0.00802504f, -0.03820374f, -0.25174314f, 0.10796003f, 0.07748037f, 
    0.31407428f, -0.04807987f, 0.12848033f, -0.45737743f, -0.05663023f, -0.35264519f, -0.08167348f, 0.10793552f, 
    -0.00034998f, 0.07872187f, 0.22019351f, 0.13469909f, -0.07258075f, -0.25127271f, 0.11445154f, 0.07151529f, 
    0.07881397f, -0.03613010f, 0.05895923f, 0.25276741f, 0.02816378f, -0.10248601f, 0.10461400f, 0.01411224f, 
    0.10011932f, -0.05839525f, 0.03424877f, -0.07935211f, 0.00268527f, -0.05502050f, -0.06205602f, -0.02575102f, 
    -0.08905879f, 0.08018237f, -0.23026663f, 0.12093370f, 0.02123309f, -0.00138133f, -0.13069402f, -0.12463395f, 
    0.18592963f, -0.01829969f, -0.29955041f, -0.15964831f, 0.00147717f, 0.08472624f, 0.09549125f, -0.00290511f, 
    -0.11896309f, 0.06477591f, 0.19610962f, 0.07217532f, -0.01259941f, -0.00914008f, -0.01884910f, -0.02247996f, 
    -0.04375309f, -0.00052047f, 0.33158284f, -0.08049976f, -0.10048732f, 0.02814596f, 0.06943750f, 0.20037730f, 
    0.11970279f, -0.03392152f, 0.06546187f, 0.32662630f, 0.22001243f, 0.08681712f, 0.22259399f, 0.19060999f, 
    0.02273019f, -0.04379809f, -0.03716224f, 0.13755335f, 0.23810196f, 0.14162844f, -0.14856295f, -0.08415674f, 
    -0.02358576f, 0.19334470f, 0.29147640f, 0.08983796f, -0.06789378f, 0.05774054f, 0.04027975f, 0.07117610f, 
    0.10484441f, 0.01667455f, -0.10967918f, 0.05408872f, 0.07084648f, 0.08977417f, 0.02628070f, 0.19294631f, 
    0.21424995f, 0.03545941f, -0.11988798f, -0.13357192f, -0.07510300f, 0.03225635f, 0.10751422f, 0.02055672f, 
    0.10025378f, 0.07564335f, -0.02714366f, 0.17260264f, -0.08482738f, 0.17832914f, -0.09302778f, -0.26035893f, 
    -0.24112597f, -0.11878003f, 0.23546158f, 0.07560993f, 0.01337471f, -0.14530747f, 0.05950727f, 0.17403640f, 
    -0.06259622f, -0.16408747f, -0.11287054f, 0.24818511f, 0.12963417f, 0.13277444f, -0.30331531f, -0.11298141f, 
    -0.38542041f, 0.17864029f, -0.10865790f, 0.14700621f, -0.23502250f, -0.13721526f, -0.18883601f, 0.36537570f, 
    0.04921493f, 0.14249791f, 0.24658228f, -0.23405293f, 0.04318091f, 0.06571443f, 0.02662837f, 0.31706351f, 
    -0.17324449f, 0.02060329f, -0.11918711f, 0.01006246f, 0.06516434f, -0.07610483f, 0.15465984f, -0.05077279f, 
    0.05411839f, 0.05463536f, 0.09307437f, 0.12121762f, -0.15715085f, 0.00083168f, -0.05562480f, 0.11355095f, 
    -0.01143617f, -0.00002870f, 0.01080089f, 0.03903073f, -0.06061218f, -0.12877001f, 0.17140718f, 0.04110059f, 
    0.10598443f, -0.09190152f, -0.07272579f, -0.03233849f, -0.12076581f, -0.19369736f, -0.12906142f, 0.15602787f, 
    -0.16514333f, -0.09313628f, 0.08645678f, 0.05584523f, 0.17148538f, 0.13283171f, -0.04764920f, 0.04875501f, 
    0.03537098f, -0.12844375f, 0.29668090f, 0.05341946f, 0.05806239f, -0.20414214f, -0.02510196f, 0.00732779f, 
    0.46049201f, 0.09293326f, 0.30684513f, -0.07419464f, 0.06719241f, 0.04088199f, 0.06895634f, 0.14298619f, 
    0.08008983f, -0.10318036f, -0.08125807f, -0.54226279f, 0.27458632f, -0.02513649f, -0.03113898f, 0.09501593f, 
    0.05082638f, -0.11424191f, -0.04589862f, 0.05948216f, 0.46437755f, -0.05382596f, -0.16875041f, -0.03033680f, 
    0.12856537f, 0.06895868f, 0.21509136f, 0.21747278f, 0.13397057f, 0.27057052f, 0.04142987f, -0.06119954f, 
    -0.15894185f, 0.16929969f, -0.12681828f, -0.06598066f, -0.39683682f, -0.45404792f, -0.20707129f, -0.07967073f, 
    -0.08199669f, -0.01682742f, 0.07402304f, 0.04990778f, 0.05967195f, -0.15531911f, 0.07034583f, -0.36618158f, 
    0.12389790f, -0.12826678f, 0.06769814f, 0.01777119f, 0.19465168f, 0.14364228f, -0.00974962f, -0.10072684f, 
    0.24684902f, -0.09169673f, -0.19759692f, -0.07838018f, -0.24794525f, -0.00906198f, -0.12552759f, -0.03326029f, 
    0.11195125f, 0.04894912f, -0.07084141f, 0.02956771f, 0.19513910f, 0.09376942f, 0.06589596f, 0.05526743f, 
    0.15778388f, 0.16234952f, 0.41929600f, 0.01607273f, -0.01948540f, -0.11794709f, 0.04481753f, -0.19815589f, 
    -0.00216973f, -0.13624787f, -0.07077987f, -0.28293371f, 0.01384093f, 0.04808047f, 0.09413904f, 0.12225637f, 
    0.02618980f, -0.02848397f, -0.16248469f, -0.04646482f, -0.20031253f, 0.12298577f, 0.05708632f, -0.22829592f, 
    -0.06708305f, 0.19421569f, 0.14812090f, -0.07735255f, -0.11571319f, -0.13770138f, 0.08298194f, 0.01403131f, 
    0.13039212f, 0.01855450f, -0.05196873f, 0.07968952f, -0.10511284f, 0.14915681f, 0.16837181f, -0.16354528f, 
    0.13860132f, -0.07026576f, 0.02008190f, -0.13870504f, -0.02194128f, 0.40709138f, 0.06098939f, 0.23965454f, 
    0.02602718f, 0.00448728f, 0.16168575f, -0.01534231f, -0.02541791f, -0.05257538f, 0.25222617f, 0.16256915f, 
    -0.09126125f, -0.17609575f, -0.02961827f, -0.10060085f, -0.16109693f, -0.01115151f, -0.09169898f, 0.00665431f, 
    -0.19984637f, -0.04076299f, -0.03026998f, -0.09408903f, -0.08872324f, -0.20128196f, 0.23377578f, -0.07046542f, 
    0.20459726f, -0.16812097f, -0.09161989f, -0.18960711f, 0.10399551f, -0.09088425f, 0.10398632f, -0.07207659f, 
    -0.13250042f, 0.05319765f, -0.16003208f, 0.11289043f, -0.02602430f, 0.15418155f, -0.08792960f, -0.08647756f, 
    0.02497083f, -0.14199141f, 0.05580799f, 0.48372629f, 0.01641571f, 0.16622491f, 0.15711823f, 0.06400307f, 
    -0.06975298f, 0.03469550f, -0.24678272f, 0.36118150f, 0.09570754f, 0.02320486f, -0.26887557f, 0.12481812f, 
    0.10667472f, -0.05143948f, 0.19756846f, -0.00801541f, -0.04889373f, 0.09651515f, -0.09834690f, -0.10992070f, 
    0.21399848f, 0.23514853f, 0.06129145f, -0.00146821f, -0.05576906f, 0.21555282f, -0.24637373f, 0.29291627f, 
    0.14299981f, -0.09930558f, 0.19165443f, -0.17672087f, -0.25470200f, -0.15080173f, 0.32822454f, 0.48346564f, 
    0.12321290f, 0.12484962f, -0.08152032f, 0.15830433f, 0.07803988f, -0.23784295f, -0.06554466f, 0.21932721f, 
    0.24823543f, 0.25532424f, -0.41439885f, 0.02565829f, -0.36254147f, -0.01427259f, 0.04384704f, 0.02754932f, 
    -0.45323321f, 0.34891546f, 0.10906000f, 0.14598368f, 0.21896812f, -0.07185548f, -0.00914315f, 0.00286446f, 
    -0.08177789f, -0.32796258f, -0.06643360f, -0.01089329f, 0.01195114f, -0.06366658f, 0.07549533f, -0.11166791f, 
    -0.08638407f, -0.16080256f, -0.55670947f, 0.16260855f, 0.24751800f, 0.00442570f, -0.16300410f, -0.18150455f, 
    0.02350518f, 0.10520487f, 0.14940770f, 0.14550227f, 0.12551169f, 0.36862370f, 0.01697637f, -0.07633752f, 
    -0.15635934f, 0.24069910f, -0.05230698f, 0.10395966f, 0.33211577f, -0.17054608f, 0.04854264f, -0.10047299f, 
    -0.09017462f, -0.05486047f, -0.15438206f, 0.10270815f, 0.16821560f, 0.02325054f, 0.08601667f, -0.24479713f, 
    -0.04771965f, 0.07119492f, -0.00876366f, 0.03862374f, -0.03706829f, 0.14973921f, -0.11692686f, -0.01110554f, 
    -0.07389694f, -0.18999280f, 0.09578269f, 0.18268645f, -0.08235414f, 0.12705430f, 0.18551129f, 0.40864801f, 
    -0.33185706f, -0.19663484f, -0.09155048f, -0.22494194f, -0.34401640f, -0.02021967f, 0.04911942f, -0.03193223f, 
    0.12988113f, -0.12079778f, 0.06407060f, 0.06485428f, 0.06680792f, 0.00698569f, -0.07851590f, 0.03376961f, 
    -0.09546982f, 0.15053709f, -0.11086684f, -0.09040476f, 0.09264155f, 0.08256026f, -0.03084487f, 0.28404406f, 
    0.22467764f, -0.02042342f, 0.23339888f, -0.18036859f, -0.75760406f, 0.08562718f, -0.08003566f, -0.05487559f, 
    0.03436403f, 0.06526665f, 0.15408954f, -0.23587506f, -0.29710883f, -0.07477945f, -0.08301570f, -0.05991089f, 
    0.17146112f, 0.15763642f, 0.05705680f, 0.14182067f, 0.16802984f, 0.11557074f, 0.27970698f, 0.03796029f, 
    0.10171132f, 0.09910344f, 0.07273783f, 0.08374587f, 0.25761181f, 0.09988556f, 0.28282294f, 0.17459539f, 
    -0.13783339f, -0.01554175f, -0.21570115f, 0.05489549f, 0.08278398f, 0.07749268f, -0.22233109f, 0.00959893f, 
    -0.20754175f, -0.01728255f, -0.24019298f, -0.04765398f, 0.02268484f, -0.06197675f, -0.29264048f, -0.12422548f, 
    -0.02328003f, 0.17741731f, 0.04198191f, 0.19016489f, 0.11507470f, -0.00717429f, 0.02709671f, 0.04629944f, 
    -0.09270748f, -0.26201338f, 0.31441969f, 0.19275917f, 0.09345797f, -0.03752619f, -0.17627960f, -0.11581924f, 
    -0.19363481f, 0.33114907f, 0.09325373f, 0.20129740f, -0.09791487f, 0.11793219f, -0.02642300f, 0.28040707f, 
    0.08397326f, 0.27502704f, 0.06483978f, -0.12981054f, 0.23897402f, -0.14580357f, -0.11896751f, -0.20015700f, 
    -0.10267238f, 0.10478863f, -0.02433776f, 0.08534458f, 0.24011746f, 0.14207371f, 0.03468078f, 0.00831392f, 
    0.01140424f, -0.24180385f, -0.04305755f, -0.04973191f, -0.13382314f, -0.07128108f, -0.25406960f, -0.05822851f, 
    -0.07385101f, -0.08477648f, 0.09635002f, -0.04218635f, 0.19392817f, 0.09553983f, 0.01752635f, 0.15699400f, 
    -0.16095129f, -0.02229002f, -0.01502476f, 0.01607116f, -0.07692724f, -0.15546024f, -0.15474191f, -0.48586732f, 
    -0.42064732f, 0.07015327f, 0.06447256f, 0.16236851f, 0.14358781f, 0.05046634f, 0.14598079f, -0.55107254f, 
    -0.16215463f, -0.00105248f, -0.01806475f, -0.02179661f, 0.00753330f, -0.04377938f, 0.00183895f, -0.08278340f, 
    0.01583594f, 0.01120422f, -0.04429593f, -0.06370860f, 0.07089312f, 0.01426472f, 0.04157202f, -0.06974284f, 
    -0.05128847f, -0.03804924f, -0.01542278f, -0.01596871f, -0.00358602f, -0.09133513f, 0.04315140f, -0.01221483f, 
    0.06177684f, 0.05401676f, -0.00895717f, 0.05679708f, 0.00024972f, 0.01517642f, -0.01194181f, -0.06853447f, 
    -0.07535975f, -0.08433428f, -0.06949383f, -0.02162538f, -0.07961806f, -0.03882986f, -0.03622998f, -0.02482607f, 
    0.05124195f, -0.00148621f, 0.00910235f, -0.05860609f, -0.07070041f, -0.04204749f, -0.03645701f, -0.04629917f, 
    -0.08443806f, -0.05442378f, -0.07053009f, -0.02332894f, -0.05167392f, 0.02720501f, -0.05547357f, 0.01559141f, 
    -0.03478987f, -0.00926800f, 0.04133382f, 0.00226758f, -0.08859810f, 0.04411789f, 0.07064087f, 0.06287084f, 
    -0.05333924f, -0.04250272f, -0.02542728f, -0.03364981f, -0.08296987f, -0.06143027f, -0.06938121f, 0.03056465f, 
    -0.06367880f, -0.04120414f, -0.01777572f, -0.05534831f, -0.03113507f, 0.02815929f, -0.00132576f, 0.03888057f, 
    0.03404828f, -0.01289823f, 0.02817141f, -0.02969277f, 0.04455698f, -0.02208263f, 0.00426985f, 0.05276655f, 
    0.06552904f, 0.02191082f, 0.04869255f, 0.00437734f, -0.00850359f, -0.08600418f, 0.03178323f, -0.03097461f, 
    -0.02954254f, -0.00056989f, -0.00969627f, -0.05735918f, -0.01798802f, 0.06678974f, 0.00938712f, -0.05887924f, 
    0.06934325f, -0.06803860f, -0.00551153f, -0.01380132f, 0.06149361f, 0.06472038f, -0.01243755f, -0.05298717f, 
    -0.06952531f, -0.03284492f, 0.01005284f, -0.03838622f, 0.01434516f, -0.04904812f, -0.04242752f, -0.08484520f, 
    -0.03965431f, -0.01495584f, -0.01531231f, -0.07736698f, -0.05207695f, -0.06560063f, -0.01979669f, 0.01193422f, 
    -0.07468560f, 0.00001498f, 0.04382130f, 0.06358952f, -0.02773803f, 0.07077315f, 0.06924475f, -0.01543362f, 
    -0.06818101f, -0.07918210f, -0.03177695f, -0.07684414f, -0.01814285f, -0.03491708f, -0.04412384f, -0.03098053f, 
    -0.03234513f, -0.05196532f, -0.01253952f, -0.01414627f, 0.05649199f, -0.00975508f, 0.01871742f, 0.04185015f, 
    0.19091302f, -0.11343111f, 0.18309014f, 0.06611683f, -0.06086923f, 0.14137879f, 0.13629471f, 0.07327287f, 
    -0.09364328f, 0.02534528f, -0.14994311f, 0.00158933f, -0.09732606f, 0.27574277f, 0.01869398f, -0.06339540f, 
    0.05539257f, 0.08437750f, -0.04091053f, 0.01143528f, -0.13010632f, -0.04205405f, 0.30952567f, -0.28097856f, 
    0.07303793f, 0.17471147f, 0.02493143f, 0.07022975f, 0.14923128f, -0.09296720f, -0.06966900f, 0.08289780f, 
    -0.08705281f, 0.14238177f, 0.25033274f, 0.22270250f, -0.22583823f, 0.19262318f, -0.36058602f, -0.02544389f, 
    0.05743539f, 0.06293569f, -0.16755734f, 0.05450511f, 0.03042697f, -0.00191607f, -0.43797770f, 0.45927420f, 
    0.03495162f, -0.08527092f, 0.28322580f, -0.06166515f, -0.12910613f, -0.04141994f, -0.42230913f, -0.08798164f, 
    0.08976415f, 0.11256558f, 0.38957474f, -0.03590050f, 0.02293278f, 0.00982369f, 0.12829061f, -0.36602843f, 
    0.03565335f, -0.03873719f, 0.02226640f, 0.15499106f, 0.01062297f, 0.03920338f, -0.07662512f, -0.05028546f, 
    0.14787066f, 0.42879742f, 0.04796419f, 0.10260274f, 0.26919341f, -0.00757189f, 0.14594865f, -0.04567488f, 
    0.04968107f, 0.08376765f, 0.09033116f, -0.13450302f, -0.12576626f, -0.04706895f, 0.09500443f, -0.01827253f, 
    -0.12335455f, -0.05374857f, -0.05996274f, 0.46602070f, -0.12133291f, 0.07017803f, -0.24137498f, 0.20771703f, 
    -0.12241787f, -0.25733754f, -0.06095490f, -0.34073135f, -0.28794539f, 0.01349296f, 0.01544188f, 0.10001094f, 
    -0.15624817f, -0.04670637f, 0.03145221f, 0.09798595f, -0.02068356f, -0.27588943f, 0.16722439f, 0.00802785f, 
    0.06120133f, -0.04600167f, 0.12692209f, 0.03194403f, -0.14638622f, 0.14109729f, 0.11653842f, 0.20340338f, 
    0.08790806f, -0.03099016f, -0.10422509f, 0.09886048f, 0.14102903f, -0.14760271f, -0.22915319f, -0.15659726f, 
    0.04145430f, 0.09168451f, 0.14707868f, 0.06001383f, -0.01291973f, 0.10951453f, 0.21538422f, 0.03677789f, 
    -0.08542593f, 0.34091896f, 0.23470263f, -0.11505767f, -0.06971820f, -0.01094289f, -0.15779088f, -0.32348433f, 
    -0.08198927f, -0.15040903f, -0.02836346f, -0.06993398f, 0.08950556f, -0.09163591f, -0.18215783f, -0.02767787f, 
    0.12347961f, 0.26084605f, 0.09458353f, 0.41900271f, -0.12327017f, -0.14653713f, 0.21218073f, 0.15469369f, 
    0.07339438f, 0.08944920f, -0.31163803f, -0.15431219f, 0.09653506f, 0.13610528f, 0.10653161f, -0.04013505f, 
    0.04982108f, 0.02219786f, -0.16872299f, -0.29811096f, 0.28347409f, 0.06762841f, 0.03650609f, 0.02261293f, 
    -0.12701125f, -0.07653210f, -0.06032506f, -0.19834752f, 0.54290056f, 0.31483662f, 0.16252625f, -0.00740636f, 
    -0.14574161f, 0.01471240f, 0.04340937f, 0.17846939f, -0.15597369f, -0.13597246f, -0.10460174f, 0.48058373f, 
    -0.01749310f, 0.04174346f, 0.03216901f, 0.02248927f, -0.05156296f, 0.07290767f, -0.24819107f, -0.33716276f, 
    0.05081761f, -0.04432258f, 0.11099172f, 0.33139402f, -0.18268861f, 0.18458273f, 0.06643357f, -0.12888901f, 
    -0.23285200f, -0.02449780f, 0.05030346f, 0.32129714f, -0.01636007f, -0.00125636f, 0.05570335f, -0.09725140f, 
    -0.00014308f, 0.13988528f, 0.01305351f, -0.08644564f, -0.02821416f, 0.06037191f, -0.14556763f, -0.15523708f, 
    -0.17736539f, 0.20461829f, 0.13183285f, -0.09133035f, -0.07159723f, 0.14803180f, 0.02375567f, 0.17441297f, 
    -0.04576045f, -0.33140007f, -0.05651893f, 0.60773325f, 0.19387628f, -0.04480417f, -0.26161128f, -0.08294807f, 
    0.08208147f, -0.13601965f, 0.19782659f, 0.41295350f, 0.26536116f, 0.07513653f, -0.01716893f, -0.00004030f, 
    0.06154997f, 0.00869678f, 0.18094158f, 0.12805876f, -0.02592149f, 0.00891581f, 0.08110428f, -0.24777356f, 
    0.03669655f, -0.11890913f, 0.02446624f, 0.01640409f, -0.01909535f, -0.06103674f, -0.08144667f, 0.02622652f, 
    0.16913174f, 0.14808136f, -0.17974080f, -0.04182461f, 0.04565902f, 0.45778644f, -0.01407854f, -0.01967920f, 
    -0.35854855f, 0.16376662f, 0.21799606f, -0.07530477f, -0.30688724f, 0.07132798f, -0.15945783f, -0.82077426f, 
    -0.00822000f, 0.19836578f, 0.09475414f, -0.00457189f, -0.09721724f, -0.29783183f, -0.20547436f, -0.16889450f, 
    0.13744855f, 0.07082602f, -0.25641999f, 0.02428391f, 0.22325169f, -0.13293967f, 0.22463948f, 0.04818523f, 
    0.18411370f, 0.15640257f, 0.66015166f, 0.40900913f, 0.25843257f, 0.27923608f, 0.04906361f, 0.03799409f, 
    0.11330968f, 0.28157300f, -0.01285666f, 0.18967314f, 0.19526334f, -0.08697601f, -0.00243017f, 0.11520502f, 
    -0.01334665f, 0.11414346f, -0.01485623f, -0.00662373f, 0.05486009f, 0.01843754f, -0.04684807f, -0.06561978f, 
    0.03894476f, -0.15812218f, -0.09895599f, 0.00170754f, -0.05114064f, 0.18965447f, 0.34847948f, -0.21116991f, 
    0.10953148f, 0.04784885f, -0.00000795f, 0.07129698f, 0.02494507f, -0.16293153f, -0.17230980f, 0.29065144f, 
    0.10017941f, -0.04950012f, 0.39707437f, 0.32355067f, 0.01002286f, 0.23881419f, -0.13691480f, 0.03382369f, 
    0.14088215f, -0.10378331f, 0.26128522f, 0.05867044f, 0.13534355f, -0.08930778f, 0.11857953f, -0.02039132f, 
    -0.08867203f, 0.16125743f, 0.09917251f, 0.10668232f, 0.12689903f, -0.06989003f, 0.37559775f, 0.02558036f, 
    -0.24402396f, -0.14119779f, -0.35791042f, -0.24493083f, 0.19800898f, -0.05964150f, 0.17204817f, 0.11309737f, 
    0.08931589f, -0.28889161f, 0.14190143f, -0.01472141f, 0.03492974f, 0.06728757f, -0.09692974f, -0.11155888f, 
    0.14069535f, -0.19909775f, -0.03943473f, 0.55750304f, -0.11948142f, 0.27392760f, 0.07504781f, 0.37670839f, 
    0.04101121f, 0.12931524f, 0.12037803f, -0.01146833f, 0.21742837f, 0.07937079f, -0.13257985f, -0.00870116f, 
    -0.10784006f, 0.02139760f, 0.01323724f, -0.00768406f, 0.54760683f, 0.24201269f, 0.45462281f, 0.28648660f, 
    0.18120562f, 0.11374284f, 0.14577444f, 0.02268415f, 0.10812905f, -0.11440498f, -0.09210838f, 0.13646862f, 
    0.15986365f, -0.00111088f, -0.10008851f, -0.00693704f, 0.10737896f, 0.05156174f, 0.03622520f, 0.20339128f, 
    0.08331852f, 0.17734301f, -0.07382347f, 0.04344240f, -0.20907946f, -0.29600510f, -0.31571874f, -0.68421888f, 
    -0.79184645f, 0.22210534f, 0.04265921f, -0.26789021f, 0.07089192f, -0.25683737f, 0.18943563f, -0.08445136f, 
    0.34519249f, 0.12604049f, 0.26554483f, -0.04490534f, -0.08515514f, 0.02858942f, 0.07856933f, 0.02391464f, 
    -0.03736738f, -0.13039573f, -0.40775621f, -0.77413100f, 0.08856934f, 0.05701899f, -0.08651174f, 0.08670341f, 
    0.09048040f, 0.03109369f, 0.02273006f, 0.22462004f, 0.24720100f, -0.24225301f, -0.07707909f, -0.02699973f, 
    0.02530147f, 0.06337322f, 0.01668108f, 0.32728460f, 0.27687517f, 0.06474996f, 0.07651692f, -0.18386877f, 
    -0.08182643f, -0.10323130f, 0.06964369f, 0.28235587f, -0.13674930f, -0.74459225f, -0.62829286f, 0.01220643f, 
    -0.02841529f, -0.20774786f, -0.01637245f, 0.03994895f, -0.07626267f, 0.24035130f, 0.03676055f, -0.51618773f, 
    -0.28500673f, -0.06762397f, 0.02384332f, 0.09089387f, -0.02411279f, 0.02593940f, -0.13461149f, -0.04801745f, 
    -0.71590805f, -0.18124443f, -0.22449766f, -0.33322486f, 0.06368130f, -0.16823310f, 0.06417168f, 0.45610487f, 
    -0.07212998f, -0.31167608f, -0.30781868f, -0.11034150f, 0.30620643f, 0.24315421f, 0.08811729f, 0.07099888f, 
    -0.50330520f, -0.16540974f, 0.08335358f, -0.11024847f, -0.03818242f, 0.17645581f, 0.11581656f, 0.10047992f, 
    -0.10716555f, -0.03374068f, -0.21729517f, -0.25057048f, -0.14190176f, -0.06493957f, -0.01228604f, 0.14387564f, 
    0.10147020f, 0.11717913f, -0.56436330f, -0.11511365f, -0.00603530f, -0.10966992f, -0.08702739f, 0.06878363f, 
    0.11683871f, 0.01488542f, 0.00231680f, 0.00166223f, -0.11294309f, -0.41623303f, 0.03112456f, -0.10647216f, 
    0.16011052f, 0.14831142f, 0.16085535f, 0.12642391f, 0.07940799f, 0.14010708f, 0.08788790f, -0.03951215f, 
    0.08125100f, -0.10076508f, 0.07507509f, 0.06436097f, 0.11342583f, 0.26252705f, -0.20553009f, 0.12986997f, 
    -0.06553213f, 0.00602951f, 0.19435513f, 0.15283348f, 0.00932641f, 0.11080422f, 0.28374422f, 0.30599457f, 
    0.03780571f, -0.16582838f, -0.14210097f, -0.18218404f, 0.01958669f, 0.09713329f, 0.00722103f, 0.19821368f, 
    0.04751049f, -0.39387047f, -0.46458876f, 0.01272726f, 0.09297808f, 0.11488757f, 0.09480064f, 0.03824474f, 
    0.32764375f, -0.06334046f, -0.53651226f, -0.07785446f, -0.01483252f, 0.17664282f, 0.12449662f, -0.10309120f, 
    -0.02024196f, -0.20189503f, -0.23846970f, 0.01249733f, 0.09429013f, 0.22155844f, 0.29183221f, 0.26650256f, 
    0.05129248f, -0.06445865f, 0.11880876f, -0.49330479f, 0.10370831f, 0.16468780f, -0.06606106f, 0.02879982f, 
    0.04251815f, 0.06822644f, -0.03656929f, -0.33407292f, -0.54065835f, -0.13055483f, -0.01485318f, 0.19576350f, 
    -0.03700903f, 0.11814568f, 0.01637522f, 0.01396003f, 0.69107342f, 0.30210483f, 0.26479065f, 0.02608272f, 
    0.27743122f, 0.02476405f, 0.18049973f, 0.00757751f, 0.02769474f, 0.01806653f, 0.03333637f, 0.04708598f, 
    -0.09429248f, 0.14922343f, -0.10025525f, -0.10611501f, -0.09335111f, 0.11942495f, 0.31319126f, 0.11932884f, 
    -0.19156380f, -0.12124802f, 0.11829868f, -0.13586517f, -0.14635810f, -0.08223526f, -0.09428816f, -0.27574152f, 
    -0.13806397f, 0.25009784f, -0.17290570f, 0.00406336f, -0.01100230f, -0.03278781f, 0.10199404f, 0.04295189f, 
    -0.28828505f, -0.25893664f, -0.27882630f, -0.08813696f, -0.21007963f, -0.01907119f, -0.05490742f, -0.24802271f, 
    -0.03141505f, 0.00250164f, -0.14687575f, -0.29258054f, 0.04641633f, 0.03401636f, 0.11230668f, 0.15680434f, 
    0.17893486f, 0.01016510f, -0.13088620f, -0.42697138f, 0.30265170f, 0.17467803f, 0.13366811f, 0.12673049f, 
    0.11511174f, -0.01735136f, 0.03783096f, 0.00991195f, 0.26586175f, 0.28450105f, -0.11655825f, 0.05006226f, 
    -0.01901140f, 0.14771946f, 0.02005290f, 0.01578485f, -0.24104670f, 0.12248410f, 0.23175706f, -0.02848830f, 
    -0.15902971f, 0.02750273f, 0.10673258f, 0.11776423f, 0.08981534f, 0.13354656f, -0.29849207f, -0.59353805f, 
    -0.09256913f, 0.04796267f, -0.09852684f, 0.04524528f, -0.09180369f, -0.19813965f, 0.07934525f, -0.30656794f, 
    -0.15220706f, -0.05586816f, -0.16044864f, -0.10600059f, -0.07527121f, 0.00229534f, 0.02194543f, -0.14024365f, 
    -0.55226332f, -1.19761992f, -0.32586250f, 0.05704651f, -0.15522087f, -0.09506743f, -0.17962264f, -0.10136665f, 
    -0.08353873f, 0.03807032f, 0.02261020f, 0.08842676f, 0.03352655f, 0.03308626f, 0.13537230f, 0.06412117f, 
    0.26121068f, 0.47671136f, 0.35834613f, 0.05007751f, 0.04966055f, -0.02469774f, 0.03210020f, 0.06461400f, 
    0.07820068f, 0.04151034f, 0.45878953f, -0.32718462f, -0.02984029f, 0.13684450f, 0.05825013f, -0.08225166f, 
    0.06833818f, 0.07156447f, -0.05252807f, -0.13582428f, -0.24419913f, 0.04322807f, -0.13187180f, -0.13597123f, 
    0.14667594f, 0.07225354f, -0.11836246f, -0.12483820f, 0.08872984f, -0.32145205f, -0.38791052f, -0.18026128f, 
    0.17345463f, -0.06320976f, 0.15887250f, -0.25910184f, -0.09708055f, -0.34116098f, -0.15188678f, -0.21830662f, 
    0.17007428f, -0.21997468f, 0.06640335f, 0.13249053f, 0.23462753f, 0.06592932f, 0.23506504f, -0.08077840f, 
    -0.61843550f, 0.00024366f, -0.01218868f, 0.04652832f, 0.07612482f, 0.00792989f, 0.29596168f, 0.29315540f, 
    0.21409507f, -0.43943688f, -0.01253174f, -0.07512114f, 0.03107023f, 0.23066629f, 0.11261798f, 0.19134697f, 
    -0.15325671f, -0.03425556f, -0.12988460f, -0.23114026f, -0.30553466f, 0.28379384f, 0.38685781f, 0.17349362f, 
    -0.01692652f, 0.03575557f, -0.02243433f, -0.24280719f, -0.06705914f, -0.02170977f, 0.09721810f, -0.06765208f, 
    0.00237922f, -0.12549964f, 0.32131273f, -0.78823924f, -0.42894980f, 0.26707008f, 0.07445519f, 0.05851896f, 
    -0.21700332f, 0.10153097f, 0.03797876f, 0.30655470f, 0.13700588f, -0.16291648f, -0.01156385f, -0.02500681f, 
    0.12133069f, 0.08601135f, -0.00346510f, 0.01871204f, 0.39933923f, 0.17821890f, 0.65866691f, 0.03310695f, 
    0.05363562f, 0.28029928f, 0.04128698f, -0.03473065f, 0.10597709f, -0.26144433f, 0.02318851f, 0.03857491f, 
    -0.08462172f, -0.16536598f, 0.18760194f, 0.09861432f, 0.04890802f, 0.08519725f, 0.31883568f, 0.18020263f, 
    0.04535531f, 0.03805027f, -0.11457735f, 0.04890479f, 0.02936652f, -0.23232344f, -0.15435398f, -0.01577122f, 
    -0.48032442f, -0.19380862f, 0.04593081f, 0.15032133f, -0.00259654f, -0.17810743f, -0.10804532f, 0.27447999f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.07241471f, 0.09872021f, 0.20874642f, -0.09797901f, 0.29019588f, 0.11388473f, -0.04495346f, -0.11091390f, 
    0.17125060f, 0.02547556f, -0.02485382f, 0.13174821f, 0.34108558f, -0.13585807f, 0.35762107f, 0.15535271f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02352193f, 0.21615212f, -0.29513034f, 0.29529104f, 0.17290322f, -0.24383777f, 0.17604327f, -0.27930883f, 
    -0.41508406f, -0.11001057f, -0.28815883f, 0.11120683f, 0.12610814f, 0.63558692f, 0.09718572f, 0.39213526f, 
    -0.14569353f, -0.40889966f, 0.11294211f, -0.28780144f, 0.16891557f, 0.06176482f, -0.35639486f, -0.18653534f, 
    -0.31662634f, 0.15796030f, 0.25576177f, -0.56421369f, 0.07709005f, 0.07945218f, 0.12504168f, -0.00925434f, 
    -0.19116510f, -0.15396728f, -0.14704965f, 0.15661432f, -0.17168255f, -0.08249888f, 0.44741794f, 0.15262561f, 
    -0.48099354f, 0.10413369f, -0.23358111f, 0.40365329f, 0.18375330f, 0.61382157f, -0.03380609f, 0.34632277f, 
    0.44779602f, -0.16940171f, -0.27524918f, 0.35703567f, 0.24712710f, -0.00373372f, -0.31914663f, -0.66375464f, 
    0.04822863f, 0.02890024f, -0.30154061f, 0.23545165f, 0.07245568f, 0.03799530f, 0.00002203f, 0.39778414f, 
    -0.09995037f, -0.07266477f, 0.22337031f, -0.18760288f, 0.12724382f, -0.00499797f, -0.20303908f, 0.15380186f, 
    -0.19152591f, 0.00413889f, -0.16013309f, -0.15052369f, -0.21642897f, -0.24098250f, 0.10653847f, -0.16600746f, 
    -0.02830067f, 0.10770644f, -0.08255211f, 0.01611351f, -0.13583589f, -0.00808711f, -0.16605030f, -0.13296810f, 
    -0.18900563f, -0.11658594f, 0.04947972f, 0.04582205f, -0.05033920f, 0.04886138f, -0.14212742f, 0.06897686f, 
    -0.43352339f, 0.11630291f, 0.12654907f, 0.25300637f, 0.55538774f, 0.09612084f, -0.39848495f, -0.17925139f, 
    0.46963075f, 0.24773876f, 0.18095055f, 0.27579367f, 0.06350645f, -0.30591315f, 0.06581628f, 0.05043433f, 
    0.26002198f, 0.24305697f, 0.24504457f, -0.06481070f, -0.13075213f, 0.18385544f, -0.12241684f, -0.06042450f, 
    0.01527233f, 0.12710498f, 0.29367930f, -0.23951550f, -0.26511851f, 0.12115394f, 0.04648675f, 0.07684574f, 
    0.20314698f, 0.35362417f, 0.28509653f, 0.11545049f, -0.00265266f, 0.05327169f, 0.41254041f, 0.36951607f, 
    -0.27362755f, 0.00855136f, -0.12629524f, -0.42823565f, -0.19361256f, 0.75704229f, 0.09794099f, 0.25725946f, 
    -0.04571415f, 0.00122805f, 0.05242812f, -0.15906768f, 0.28426313f, 0.31031451f, -0.14958446f, -0.17402989f, 
    0.30402860f, -0.02580043f, 0.45256159f, 0.32665774f, 0.05259446f, -0.57260841f, 0.04945749f, 0.02527387f, 
    -0.42353129f, 0.32032582f, 0.25770164f, -0.31254697f, 0.50708246f, 0.27541560f, -0.14576866f, 0.03344849f, 
    0.16182183f, 0.19154078f, -0.03810266f, 0.17831996f, 0.08000416f, 0.28871992f, 0.21619028f, -0.19642057f, 
    -0.06388257f, 0.46647409f, 0.37899595f, -0.00268790f, 0.11607053f, 0.16722700f, 0.22597966f, 0.15787277f, 
    -0.21461247f, -0.01496089f, -0.16731012f, -0.23774679f, -0.16755420f, 0.47399345f, 0.48048577f, -0.07761923f, 
    -0.12384425f, -0.26168227f, 0.10112973f, 0.15756418f, -0.22342677f, 0.00487765f, -0.02871781f, 0.21254541f, 
    -0.04493818f, 0.00405499f, 0.13686690f, -0.18153901f, -0.13690791f, -0.06498209f, -0.01513422f, -0.20635939f, 
    -0.10597471f, -0.09707402f, -0.08092356f, -0.37758130f, 0.22569592f, 0.08913372f, 0.16558379f, 0.21602504f, 
    -0.06467890f, 0.11730623f, -0.80675715f, 0.13496614f, -0.14779305f, -0.15436609f, 0.49913585f, -0.02418776f, 
    -0.07519844f, -0.27562842f, 0.25444615f, -0.01137134f, 0.63064730f, 0.41133219f, -0.02612926f, -0.60670483f, 
    0.31267107f, 0.03767168f, 0.15949884f, -0.38257691f, -0.26426157f, 0.10271245f, 0.69674474f, 0.20930113f, 
    0.43179074f, -0.36207098f, 0.23519213f, 0.03083152f, -0.26062414f, 0.02290192f, 0.57307434f, 0.28813866f, 
    -0.13134958f, 0.21060835f, 0.01980427f, -0.20654204f, 0.36899078f, 0.47492084f, -0.38312468f, -0.04171792f, 
    -0.42285484f, 0.07475840f, 0.49348488f, -0.21390603f, -0.04000579f, -0.05295337f, 0.26285189f, -0.01107406f, 
    0.41217688f, 0.10219609f, -0.34992078f, 0.15031749f, -0.15656792f, 0.18670581f, 0.62798560f, 0.20476906f, 
    -0.46556959f, 0.10649595f, 0.43992758f, -0.18634818f, 0.32060903f, 0.17114000f, 0.14037530f, 0.20100413f, 
    -0.26309714f, -0.20463564f, 0.37181404f, 0.19466281f, -0.12386403f, 0.32798612f, 0.91709983f, -0.23399778f, 
    -0.63102937f, 0.36036819f, 0.57265437f, 0.04302986f, -0.08655404f, -0.30599037f, 0.11195189f, -0.06808369f, 
    -0.04533195f, 0.07737366f, -0.45631289f, 0.46491712f, 0.34017944f, 0.35859910f, -0.31140596f, 0.03833072f, 
    -0.50905246f, 0.43617651f, -0.29627028f, -0.00606172f, 0.35965809f, -0.28821197f, -0.17093432f, -0.70484066f, 
    -0.07381330f, -0.05888573f, -0.10256395f, 0.29450494f, 0.44811288f, -0.28794557f, 0.06201509f, 0.36819753f, 
    0.25940767f, 0.05446053f, -0.37554497f, -0.21310677f, 0.39421669f, 0.16694067f, 0.02686982f, 0.32636061f, 
    0.07757939f, -0.17558479f, 0.38723949f, 0.21457964f, -0.23789589f, -0.19141841f, 0.97836769f, 0.40067577f, 
    0.00484223f, 0.29729050f, -0.29170275f, -0.10060042f, 0.00692957f, 0.11441529f, -0.21296333f, -0.30978036f, 
    0.12321931f, -0.03122734f, 0.12485241f, 0.15455836f, 0.30829254f, -0.52995247f, -0.02872079f, 0.18542874f, 
    -0.42633945f, -0.40975472f, 0.03555471f, -0.42815244f, 0.29420739f, 0.35454103f, 0.04387693f, 0.02124164f, 
    0.22092927f, 0.08642009f, 0.53514016f, -0.02703647f, -0.00007023f, -0.18426381f, 0.66400647f, 0.20837444f, 
    0.03776628f, -0.14012498f, -0.12485415f, -0.13881192f, -0.13170403f, -0.06392393f, -0.15897614f, 0.09467447f, 
    0.06382877f, -0.20035943f, -0.16845205f, 0.01747411f, -0.14871055f, -0.15325010f, -0.11099127f, -0.04059336f, 
    0.07256839f, 0.30415237f, -0.31380332f, -0.04408465f, -0.21964452f, 0.29043940f, 0.09739007f, 0.11053342f, 
    0.03578696f, 0.10781340f, 0.19126178f, 0.24915011f, 0.10932491f, -0.52744520f, 0.76522619f, -0.35099986f, 
    -0.21369490f, -0.03145781f, 0.00194775f, 0.10492256f, -0.17605945f, 0.20450413f, -0.14695214f, -0.19558299f, 
    -0.15618341f, -0.00147548f, -0.15961920f, -0.17261712f, -0.05324949f, -0.07669914f, 0.18426512f, -0.21117157f, 
    0.21460254f, -0.54185820f, 0.05583650f, 0.17998405f, -0.29074889f, 0.05742438f, 0.03958585f, -0.04810425f, 
    0.00888276f, -0.22767937f, -0.37407780f, -0.10360654f, 0.36963302f, -0.46721503f, -0.55819780f, 0.51043499f, 
    0.39961940f, -0.46157277f, 0.53181541f, -0.19501317f, 0.12513883f, 0.09163058f, 0.33526704f, -0.17413191f, 
    0.01992189f, 0.22353092f, 0.25694340f, -0.39104167f, 0.29045257f, -0.10203784f, -0.55786437f, -0.14555825f, 
    -0.40448156f, -0.63688034f, 0.76016653f, -0.38752857f, 0.27506578f, 0.32387891f, 0.23400891f, 0.14803113f, 
    -0.05206777f, -0.23577598f, 0.23218152f, 0.02319444f, 0.21054924f, 0.22358851f, -0.12780607f, 0.27503780f, 
    0.09203802f, 0.32271859f, -0.30764344f, 0.26503158f, -0.31583318f, -0.26264066f, 0.28287071f, 0.29895240f, 
    -0.45109215f, 0.23626167f, 0.08404974f, 0.26165166f, 0.08442658f, 0.53078640f, 0.53102291f, -0.13469616f, 
    0.43878704f, 0.00325304f, -0.12913254f, 0.05694450f, -0.36966163f, -0.00348383f, 0.40780222f, 0.31522298f, 
    -0.08540278f, 0.20672461f, 0.41150472f, 0.36612159f, -0.27591509f, 0.14717689f, -0.48413309f, -0.18348125f, 
    0.55844051f, 0.17909133f, -0.13877510f, 0.13901900f, -0.19254759f, -0.20961884f, 0.30178696f, -0.14521018f, 
    -0.57722503f, 0.20936105f, -0.18232182f, -0.16847631f, 0.12258919f, 0.26740029f, 0.38200754f, 0.45380622f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08883761f, 0.15790747f, 0.04544128f, 0.29074600f, -0.05923629f, -0.14060140f, 0.54053092f, 0.00804186f, 
    0.06099450f, 0.25183192f, -0.06281725f, 0.20111221f, -0.17368928f, 0.38147518f, 0.29901019f, -0.17536996f, 
    0.13038224f, 0.43800783f, 0.10780884f, 0.50353724f, -0.28256404f, 0.14044580f, 0.30930668f, 0.11254197f, 
    -0.16785066f, -0.05572490f, 0.18260449f, 0.12565412f, -0.09022389f, -0.26400807f, -0.66463107f, -0.20653704f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.24878816f, -0.09749991f, 0.10707155f, -0.00140020f, -0.02681871f, -0.03610548f, -0.04517988f, -0.06998128f, 
    -0.26362348f, -0.19307755f, 0.04841975f, -0.18970188f, -0.03963494f, 0.02474402f, -0.01880580f, -0.17267269f, 
    0.00723765f, -0.10489270f, 0.04477365f, -0.21953201f, 0.09054253f, -0.21043992f, -0.15745315f, -0.17502482f, 
    0.13285775f, -0.01282326f, -0.24762316f, -0.10101864f, -0.17509504f, 0.08162044f, -0.06500452f, 0.09220617f, 
    0.27907363f, -0.55162054f, 0.18495767f, -0.08810207f, -0.14685521f, -0.06492189f, 0.01228787f, -0.32758981f, 
    0.51888239f, -0.29105446f, 0.11469501f, 0.47617096f, -0.01570907f, 0.00760612f, -0.02426556f, 0.26018012f, 
    0.07400594f, -0.06026267f, 0.51717323f, -0.04397633f, -0.25296339f, 0.02990125f, -0.12085577f, -0.06377115f, 
    -0.34462675f, -0.11996491f, 0.36385444f, -0.08368828f, 0.04988828f, 0.05140271f, -0.06949160f, 0.33741540f, 
    0.35602388f, -0.31116775f, 0.27175969f, -0.05693638f, -0.16313589f, 0.11877476f, -0.13288473f, 0.04256286f, 
    0.42126033f, -0.01455836f, 0.09697838f, 0.08750687f, -0.03513055f, 0.04547694f, -0.56658649f, 0.11547549f, 
    -0.84345883f, 0.17298023f, -0.07724360f, 0.30360606f, 0.10199472f, 0.20917477f, -0.52897042f, 0.09117421f, 
    0.15705411f, -0.01079336f, -0.21799991f, -0.07140724f, -0.23591489f, 0.38682091f, -0.10197940f, 0.71721977f, 
    0.14666136f, -0.07972359f, 0.47216430f, 0.39898774f, 0.04722938f, 0.11449669f, -0.00369424f, 0.27807555f, 
    -0.13097097f, -0.01644667f, -0.05977106f, -0.66392732f, -0.03797205f, 0.60738438f, -0.28290305f, 0.04555539f, 
    -0.35909659f, -0.04989804f, 0.55469322f, 0.80914730f, -0.31090125f, 0.03247419f, -0.31042135f, 0.02687591f, 
    -0.33974230f, -0.06632263f, 0.38901678f, 0.03668691f, -0.00788899f, -0.15826093f, 0.08305974f, 0.22609481f, 
    -0.14102750f, -0.06922504f, -0.04610958f, 0.10179788f, 0.00257077f, -0.07800648f, 0.23557599f, -0.14278999f, 
    -0.26604304f, 0.32438505f, -0.00231261f, -0.47662395f, 0.16474625f, 0.04602693f, 0.66283160f, -0.00491747f, 
    0.71462756f, 0.20316277f, 0.12350991f, -0.01168271f, 0.05483912f, 0.21346879f, 0.79675728f, 0.13807690f, 
    -0.00261995f, 0.08873669f, 0.29408664f, 0.25770703f, 0.39018491f, -0.32470700f, -0.10638240f, -0.60624832f, 
    0.17699495f, -0.42101234f, -0.14501421f, -0.16599083f, 0.12568122f, -0.13242711f, -0.16638285f, -0.29468876f, 
    0.44038239f, -0.02013964f, 0.13226920f, 0.08038045f, 0.01493878f, 0.44456014f, -0.25523439f, 0.33497390f, 
    -0.13888265f, -0.16813001f, -0.24269310f, -0.29741275f, 0.27122235f, 0.23507878f, 0.18991746f, 0.06021276f, 
    0.03941394f, 0.13379483f, 0.05702499f, 0.22828570f, 0.37093839f, 0.02499258f, 0.10357952f, 0.30482531f, 
    -0.07859843f, 0.00006090f, -0.01451253f, 0.01464266f, 0.02234757f, 0.06660444f, -0.10156962f, -0.16331360f, 
    -0.03969125f, -0.15471646f, 0.14097595f, -0.00228491f, -0.16018157f, -0.00399211f, 0.10525122f, 0.10412779f, 
    0.02658006f, -0.10168378f, 0.02386041f, -0.06356052f, -0.14506191f, 0.02281070f, 0.11752461f, -0.08429245f, 
    -0.02286037f, -0.13057353f, -0.12894109f, -0.13281287f, -0.02085742f, -0.16042089f, 0.13139600f, -0.04363063f, 
    0.11592640f, -0.11631278f, 0.13781652f, -0.09788895f, 0.13878344f, 0.12196374f, -0.07719299f, -0.17147808f, 
    -0.35512793f, -0.02103374f, 0.13528809f, -0.00466785f, -0.11155096f, 0.45302686f, -0.55822974f, -0.23062821f, 
    0.54181558f, 0.27351236f, 0.24367827f, 0.22191048f, 0.12576187f, 0.21142849f, 0.40338483f, -0.03698500f, 
    0.18139981f, -0.06008793f, 0.08882646f, -0.59071010f, -0.06501786f, 0.33270937f, -0.40591228f, 0.44070655f, 
    -0.11031174f, -0.14691883f, 0.07083452f, -0.02779577f, -0.01374314f, -0.10001295f, -0.02882485f, -0.15262863f, 
    0.00687490f, 0.17922305f, 0.08299453f, 0.22172384f, 0.14441080f, -0.26858392f, -0.68840766f, 0.17782691f, 
    0.17100006f, -0.34580100f, -0.02810883f, 0.07505976f, -0.21906030f, 0.22481319f, -0.36478156f, 0.00950428f, 
    -0.03042307f, -0.14796254f, 0.42531216f, -0.13999218f, -0.18191284f, -0.07325522f, -0.43481308f, -0.00331983f, 
    -0.03606675f, -0.22059125f, 0.34514698f, 0.05669497f, 0.14001460f, -0.00146857f, -0.05958947f, 0.17488320f, 
    0.31472772f, -0.12482882f, 0.20808434f, 0.48055562f, 0.10192432f, 0.10361388f, 0.03614265f, 0.09113953f, 
    0.41059923f, 0.16754785f, 0.33460343f, -0.38858214f, -0.10866028f, 0.00231771f, 0.05819224f, 0.05974554f, 
    0.11772591f, -0.13084075f, 0.00645352f, -0.15745255f, 0.40109530f, 0.13816094f, -0.03106652f, 0.20801677f, 
    0.25450319f, -0.35320207f, 0.01730435f, 0.69713950f, 0.09899782f, -0.01055689f, 0.39864784f, 0.17185837f, 
    -0.09202179f, 0.00231244f, 0.11215796f, -0.58521992f, 0.12761396f, -0.59552646f, 0.41945657f, -0.20185126f, 
    0.42555755f, -0.34259269f, 0.12548061f, 0.48117208f, 0.18642691f, 0.13902432f, -0.06174026f, -0.02464360f, 
    -0.20824994f, 0.06161119f, 0.28510016f, 0.05287039f, 0.14151371f, -0.55649334f, 0.15125680f, -0.20192483f, 
    -0.07450840f, 0.16348720f, 0.27202243f, -0.56003761f, 0.10071643f, 0.16432969f, 0.11412614f, -0.21551882f, 
    -0.14594509f, -0.00982449f, 0.14464417f, 0.10368250f, -0.08306856f, 0.46012819f, -0.42057854f, 0.21096933f, 
    0.32842547f, 0.25582084f, 0.56911737f, -0.16657472f, -0.38056022f, -0.05085533f, 0.33438423f, -0.03752941f, 
    0.09752537f, -0.16149870f, 0.07318965f, 0.21383786f, 0.23668532f, 0.15330067f, -0.13348562f, -0.59939343f, 
    -0.00682460f, 0.11135782f, -0.06352480f, -0.28673223f, 0.08353800f, 0.06284202f, -0.00733625f, 0.05668079f, 
    -0.14158033f, -0.08013669f, 0.26451010f, 0.15090796f, 0.14970244f, 0.20611800f, -0.41014707f, -0.26718673f, 
    0.58582383f, 0.01700484f, 0.59047651f, 0.28824183f, 0.23362009f, 0.16241828f, 0.17686482f, 0.06673403f, 
    -0.08752359f, 0.04424004f, -0.24584228f, -0.57154030f, -0.03817964f, 0.20103982f, 0.02443758f, -0.07617769f, 
    0.09166618f, -0.29923627f, 0.15424117f, -0.26537067f, 0.05763141f, -0.12640721f, 0.22426251f, -0.17421997f, 
    0.21129584f, -0.08827527f, 0.57852876f, 0.54483056f, 0.07712813f, -0.24167740f, 0.37540472f, -0.20221725f, 
    0.23661946f, 0.74335963f, -0.02527905f, -0.05620072f, 0.19566043f, -0.33384484f, 0.48346728f, -0.03815053f, 
    0.25460956f, 0.00781135f, -0.54510343f, -0.15271661f, 0.26264003f, 0.32922396f, -0.60486490f, -0.19904581f, 
    0.13641278f, -0.49241406f, 0.21846704f, 0.09661321f, -0.10341480f, 0.06457411f, 0.28389645f, -0.05207523f, 
    -0.29073778f, 0.10741697f, 0.08330150f, -0.50374645f, 0.10702468f, -0.39979070f, -0.36422321f, 0.14163418f, 
    -0.35526285f, -0.03861469f, 0.15191251f, 0.51089829f, -0.04001819f, 0.06250612f, 0.17708601f, -0.07087332f, 
    -0.01242645f, 0.03637422f, 0.03403542f, -0.06178540f, 0.12826589f, 0.04793265f, 0.06461776f, -0.28551826f, 
    -0.05519833f, 0.06349665f, 0.01355736f, -0.15800133f, 0.05225128f, -0.07044312f, 0.08013070f, -0.13313253f, 
    -0.14343341f, -0.13457955f, 0.00922084f, -0.15107873f, 0.06596544f, 0.01296926f, -0.03481352f, -0.11696754f, 
    0.12186934f, -0.09445112f, -0.05673254f, 0.10934848f, -0.14339729f, 0.07749385f, -0.14780669f, -0.10114501f, 
    -0.14473625f, -0.05680668f, 0.04325655f, -0.14766553f, 0.00111018f, -0.17094505f, 0.12638484f, 0.10497327f, 
    0.09607441f, 0.28849351f, 0.10149375f, -0.19603771f, 0.03744889f, -0.09461574f, -0.18459721f, 0.09965771f, 
    0.45291594f, -0.37616101f, 0.15035501f, 0.62564963f, 0.15275958f, -0.08605515f, 0.52682889f, 0.29537824f, 
    0.19035575f, 0.24242948f, -0.11793934f, -0.72124147f, -0.29968929f, -0.41311470f, -0.08752120f, 0.01631167f, 
    -0.42377478f, -0.09978750f, 0.02965035f, 0.17106499f, 0.32974494f, -0.61914146f, -0.67033947f, -0.11680651f, 
    0.12858492f, 0.48676449f, -0.16489214f, 0.29221877f, -0.06934476f, -0.15389784f, 0.25276402f, 0.26132846f, 
    -0.38958165f, 0.05881369f, 0.20202431f, -0.24584615f, -0.10008782f, -0.14411332f, 0.39334688f, 0.08110824f, 
    0.06518868f, 0.26945069f, 0.20800941f, 0.51196826f, -0.12893473f, 0.27939540f, 0.19055706f, 0.09155528f, 
    0.27317330f, 0.18807547f, 0.07955366f, 0.22482200f, -0.10521241f, -0.20054437f, -0.10938568f, -0.05041480f, 
    -0.14648165f, 0.64846170f, -0.05030779f, -0.10952303f, 0.11876383f, -0.15275192f, 0.00658152f, 0.23431173f, 
    -0.06530729f, -0.09504233f, -0.10217905f, -0.16337802f, -0.15515135f, 0.22181284f, 0.11280999f, 0.36684713f, 
    0.73846096f, 0.04161377f, 0.17668195f, -0.20322932f, 0.08183225f, -0.15154994f, 0.24563064f, -0.16284914f, 
    0.10683620f, -0.11161008f, 0.50012887f, 0.70469540f, 0.42201722f, -0.18683557f, 0.12733394f, 0.06941035f, 
    0.09799168f, -0.31661192f, 0.12799756f, 0.32572910f, -0.09487197f, 0.10521859f, -0.22136432f, 0.04618746f, 
    -0.05292695f, 0.12761274f, -0.15775043f, -0.39769351f, 0.02869648f, -0.47168005f, 0.32572100f, 0.16597804f, 
    0.01772476f, 0.13610958f, -0.22841021f, -0.34348914f, 0.16325735f, -0.04525181f, 0.87727183f, 0.02111349f, 
    -0.16966967f, 0.04362220f, 0.44005370f, 0.14356242f, 0.53076422f, -0.21994136f, -0.05960528f, 0.28969219f, 
    -0.00187328f, -0.17595273f, -0.11196539f, 0.04359974f, -0.06238235f, -0.17830050f, 0.08955325f, -0.03539845f, 
    0.17725843f, 0.22057267f, 0.10680018f, 0.26673451f, 0.13405664f, -0.08708264f, 0.98743445f, 0.02254084f, 
    0.25184324f, 0.05753637f, -0.57938844f, -0.09952466f, 0.33547613f, 0.14894164f, 0.86990631f, 0.14658010f, 
    -0.02350421f, -0.06869236f, 0.00357379f, 0.08991129f, 0.24346918f, -0.51164007f, -0.77001464f, 0.08805132f, 
    0.10234201f, -0.26770815f, 0.39159486f, 0.33267638f, 0.14833167f, 0.13988188f, -0.35823223f, 0.26248491f, 
    0.12913761f, -0.03931705f, -0.59112948f, -0.30449390f, -0.07732157f, -0.05508884f, 0.04905770f, 0.23522349f, 
    -0.26588723f, 0.08499736f, -0.24296376f, 0.05339016f, 0.39081997f, -0.01727607f, 0.15077767f, -0.15143213f, 
    -0.43148631f, 0.06088854f, 0.25602454f, 0.17012027f, 0.08577725f, 0.04765568f, -0.27474278f, 0.51898563f, 
    0.19619216f, -0.53039855f, 0.07564608f, 0.04110595f, 0.07136193f, -0.14695944f, 0.23833114f, -0.05123001f, 
    0.32798237f, 0.06879269f, 0.60581166f, 0.49466896f, -0.12129760f, -0.40257052f, 0.29137492f, -0.20306697f, 
    -0.23264508f, 0.43118590f, 0.23358363f, 0.17683168f, -0.01941305f, 0.12355840f, 0.09831702f, -0.11370137f, 
    0.14450794f, -0.00168146f, -0.12933166f, -0.31433883f, -0.16178277f, 0.08229739f, -0.23041685f, 0.07140147f, 
    0.31724274f, 0.10832243f, 0.39234534f, 0.12062647f, -0.04745141f, 0.17500398f, -0.72577316f, -0.18875268f, 
    0.01589220f, -0.48956144f, -0.37443131f, -0.02090153f, -0.04214803f, 0.61424154f, -0.29168865f, 0.29657021f, 
    0.29625514f, -0.15488851f, 0.01121149f, -0.44775385f, -0.10867883f, -0.01314320f, -0.13932145f, 0.00302793f, 
    -0.06567624f, -0.03051175f, -0.02406796f, -0.02239165f, 0.02668875f, 0.41851258f, 0.15356350f, 0.39996082f, 
    0.01466404f, -0.10393847f, 0.04259514f, -0.00793452f, 0.03195656f, 0.02210526f, -0.05298417f, -0.07241648f, 
    -0.12879163f, -0.03853482f, -0.03476454f, 0.11721051f, 0.05138601f, -0.03925395f, -0.07239468f, -0.00267797f, 
    -0.11586461f, -0.13511688f, 0.02887992f, -0.01568530f, -0.16190514f, 0.04983135f, -0.00360636f, 0.09049891f, 
    -0.07350650f, 0.13451792f, 0.04476990f, -0.09435935f, -0.16751154f, -0.11144108f, 0.04766910f, -0.00030280f, 
    0.20136188f, 0.41699082f, 0.15581544f, 0.11606799f, 0.10044707f, 0.16770802f, -0.16159657f, 0.38412490f, 
    0.68523562f, -0.21877465f, -0.00019385f, 0.84024471f, 0.19145937f, -0.05902955f, 0.14021154f, 0.19010644f, 
    -0.31482846f, 0.06237643f, 0.11018795f, -0.10239477f, 0.07573196f, -0.21917678f, -0.37039757f, -0.11023626f, 
    -0.07053544f, 0.18583007f, 0.11101935f, -0.00537448f, 0.00027292f, 0.31664294f, -0.31440550f, 0.92206931f, 
    0.25970116f, -0.14596635f, -0.00546072f, 0.33688974f, 0.05987246f, -0.06334348f, 0.12417985f, -0.06393065f, 
    -0.05839391f, 0.03113255f, 0.36915019f, -0.17442009f, 0.05089590f, 0.21355958f, -0.15232103f, 0.06599875f, 
    -0.19340833f, -0.06166188f, 0.69745147f, 0.70093161f, -0.55122924f, 0.09711720f, -0.31007093f, -0.17653583f, 
    -0.33268100f, 0.05664590f, 0.06254762f, 0.12205668f, 0.29052737f, -0.67437828f, -0.32025647f, -0.03427441f, 
    -0.32681131f, -0.05403202f, -0.03083811f, -0.36300522f, -0.07920868f, 0.00037473f, 0.02430354f, -0.20912355f, 
    0.13770047f, 0.08427624f, -0.29839677f, -0.29473534f, -0.12131107f, 0.63570851f, -0.57954574f, 0.33342314f, 
    0.32166919f, -0.10366607f, -0.23261824f, -0.66349965f, 0.03471494f, -0.14553677f, -0.41382438f, -0.01991371f, 
    0.14403635f, -0.05960770f, 0.27782756f, 0.04318482f, -0.21627124f, 0.27729380f, 0.37439677f, -0.02539486f, 
    0.16017677f, 0.18670672f, 0.21888371f, -0.14342089f, -0.05710822f, -0.11467613f, -0.47363126f, 0.02771118f, 
    0.29125178f, -0.39829621f, -0.10312971f, -0.01633312f, 0.05888407f, 0.05279317f, -0.33410087f, 0.33750474f, 
    -0.39777672f, 0.06803067f, 0.32962707f, -0.35897326f, -0.46743518f, -0.02323718f, -0.26207450f, 0.08883424f, 
    -0.21392354f, -0.16342577f, 0.12358822f, 0.26649988f, 0.11849497f, 0.28439683f, 0.28479758f, 0.10646720f, 
    0.31001803f, 0.07398030f, 0.15773347f, 0.49259913f, -0.09477460f, -0.09652118f, 0.37059754f, 0.16813120f, 
    -0.34144920f, 0.21751675f, -0.23011439f, -0.40602911f, 0.02405552f, -0.14077191f, 0.09993254f, -0.19660826f, 
    -0.02910172f, 0.10724919f, 0.48469865f, 0.78788155f, -0.39193636f, 0.06964103f, -0.17217566f, 0.01253173f, 
    -0.06836041f, 0.11853334f, 0.18295342f, 0.08198655f, 0.02563101f, -0.05745107f, -0.09766835f, -0.00280420f, 
    0.20972355f, -0.04201004f, 0.24032861f, 0.11992648f, 0.06570274f, -0.09990697f, -0.55144614f, -0.12505722f, 
    -0.03930766f, -0.39399967f, -0.34791851f, -0.00490566f, -0.05006293f, 0.62461478f, -0.34247094f, -0.01518566f, 
    -0.13901834f, -0.32711536f, 0.19551465f, -0.05352832f, -0.01558802f, -0.25951880f, -0.40904480f, -0.02601493f, 
    -0.14921726f, 0.13616252f, 0.25615889f, 0.08436906f, 0.18859746f, 0.29037529f, 0.29692090f, 0.53773987f, 
    -0.41778177f, 0.56667703f, -0.52161479f, -0.21541281f, -0.07369174f, 0.10158741f, 0.06598513f, -0.13180758f, 
    0.18857814f, 0.01133107f, 0.35446325f, 0.27289581f, -0.14074567f, 0.35330030f, 0.64574981f, 0.24114291f, 
    0.04944803f, 0.22451650f, -0.25973606f, -0.06695367f, -0.11209375f, 0.11591154f, 0.47010782f, 0.17620969f, 
    -0.00061021f, 0.01359241f, 0.03846123f, 0.59134668f, 0.27665579f, -0.69138432f, -0.46466413f, -0.33360979f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.20027699f, 0.07754646f, 0.10064030f, 0.23722859f, 0.21546453f, 0.08351101f, -0.03027549f, 0.17364436f, 
    -0.03861900f, -0.07653575f, 0.17782956f, 0.18151307f, -0.30212069f, 0.05885251f, 0.07858194f, -0.09435166f, 
    -0.01110812f, 0.75190043f, 0.21593873f, 0.22632849f, -0.05065395f, 0.19490948f, -0.12608837f, -0.40239501f, 
    -0.03746188f, 0.14167647f, 0.37564409f, -0.49471971f, -0.02128721f, 0.13396180f, -0.22548914f, 0.06655008f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.02072407f, 0.04039993f, 0.30730358f, 0.01521749f, -0.55038422f, 0.23913221f, -0.17283826f, -0.64895862f, 
    0.00711277f, -0.11050243f, -0.52204454f, -0.23210904f, -0.02516506f, -0.25696722f, -0.34323826f, -0.15138246f, 
    0.07022528f, -0.62642682f, 0.00597844f, 0.08462109f, -0.38672721f, 0.04704981f, -0.40095773f, 0.45892838f, 
    -0.10225990f, 0.11736017f, -0.24775121f, -0.10546509f, 0.35878479f, -0.66301799f, 0.35330474f, -0.27071437f, 
    0.10193370f, 0.09815616f, -0.18511629f, -0.53719813f, 0.07595802f, 0.00500821f, -0.13194029f, 0.45872316f, 
    -0.22712226f, 0.24042700f, -0.38827839f, 0.21360216f, 0.26594225f, 0.20739616f, -0.38276967f, 0.06311861f, 
    0.55291778f, 0.01011686f, 0.13892621f, -0.07546895f, 0.10166199f, -0.34515256f, -0.05053664f, -1.61961126f, 
    0.14895910f, 0.13975003f, -0.04811347f, 0.10362310f, 0.07872595f, -0.23340830f, -1.66834843f, 0.42592114f, 
    0.02656114f, 0.08625937f, -0.67347461f, 0.19279259f, 0.21906981f, -0.26697788f, 0.00070392f, -0.91012371f, 
    -0.26543885f, -0.15912589f, 0.27751559f, -0.18608408f, -0.31364805f, -0.50248700f, 0.08680625f, -0.06707790f, 
    -0.44127104f, 0.13345440f, 0.20813912f, -0.10454429f, -0.21048978f, -0.56924605f, -0.32652217f, -0.43971217f, 
    0.14106210f, -0.42288718f, 0.68203610f, 0.39042911f, -0.93992174f, 0.27996805f, -0.43004695f, -0.03848363f, 
    -0.14250687f, -0.06099227f, 0.03766563f, 0.08706788f, -0.03151295f, 0.13355951f, -0.07533383f, -1.25523198f, 
    -0.82471257f, -0.04221694f, 0.17366987f, -0.53611135f, -0.59842885f, -1.04938602f, -0.06390606f, -0.02638208f, 
    0.02185798f, -0.10059352f, 0.14103702f, 0.17447539f, -0.03047998f, 0.42462000f, -0.66672891f, -0.00882265f, 
    0.03112233f, 0.11158904f, 0.11150023f, -0.29778495f, -0.04984740f, 0.06997115f, 0.23264085f, 0.01816855f, 
    -0.12813070f, 0.17504388f, 0.09323108f, -0.08804185f, 0.05774955f, 0.12924901f, 0.14621982f, -0.20725693f, 
    -0.17009941f, 0.18804604f, -0.32245499f, 0.12109394f, 0.30479598f, 0.18851990f, 0.11941951f, 0.12129947f, 
    0.10695172f, -0.17042857f, 0.01065697f, 0.11404035f, -0.45525357f, 0.00374020f, -0.08760533f, -0.25319704f, 
    -0.09727928f, 0.02306059f, 0.13073342f, -0.20542988f, 0.19720659f, -0.23029701f, -0.02314863f, -0.15389116f, 
    -0.14593166f, 0.14149350f, -0.29335544f, -0.40666154f, 0.15651424f, 0.08103972f, 0.03054405f, -0.21836923f, 
    0.57483977f, 0.25115055f, 0.09673493f, -0.15499835f, 0.11595616f, 0.17258497f, -0.04119919f, 0.08660412f, 
    0.20281681f, -0.17968765f, -0.00404471f, 0.14878184f, 0.33181915f, 0.03165197f, 0.19626072f, -0.21677023f, 
    -0.15754713f, 0.08709583f, -0.09534603f, 0.03206414f, -0.56695312f, -0.17567864f, -0.33377063f, 0.08118747f, 
    -0.08778972f, -0.30927914f, 0.15566216f, 0.31578928f, -0.05049560f, -0.53191525f, -0.03201949f, -0.21317606f, 
    0.05351111f, -0.53517389f, 0.33630738f, -0.25166804f, 0.01653894f, -0.17101008f, 0.35212573f, -0.04990768f, 
    -0.14235525f, 0.24973357f, -0.68838835f, -1.35787857f, -1.02754486f, -0.97939241f, 0.18901162f, -0.38474885f, 
    -0.13687001f, -0.40172160f, 0.49212337f, 0.25862321f, -0.98475897f, 0.28962731f, -1.04573905f, -0.95953256f, 
    0.07021046f, 0.30157214f, 0.60512930f, -0.01131804f, -0.73664379f, -0.14072046f, -0.17271528f, -0.03547809f, 
    -0.13033120f, 0.03451207f, -1.00313354f, -0.01192040f, -0.16814461f, 0.36097842f, -0.11183185f, -0.10511169f, 
    -0.60880035f, -0.06587879f, -0.45073766f, -0.39773357f, -0.02606760f, 0.49994087f, 0.28785709f, -0.79694432f, 
    0.09813580f, 0.44238809f, -0.11149835f, -0.17206676f, -0.70298010f, -0.07212745f, -0.42836121f, -0.38109371f, 
    0.09524132f, -0.79187441f, -0.25239930f, -1.23249209f, 0.32417139f, -0.07530487f, 0.14210269f, -0.15607087f, 
    -0.14569582f, -0.15610510f, 0.04662578f, -1.08981252f, -0.43903553f, 0.55015838f, -0.09192079f, 0.11097489f, 
    -0.53372788f, 0.39239696f, -0.15734057f, 0.14331631f, 0.60187513f, -0.32641935f, 0.26313818f, -0.33259481f, 
    -0.18631116f, 0.08050558f, -1.21792018f, -0.16026387f, -0.56938046f, -0.12400740f, -0.19292484f, 0.17646053f, 
    -0.05274690f, 0.19320847f, 0.30320543f, 0.17378151f, -0.26953673f, -0.15024152f, -0.05500358f, -0.14636989f, 
    0.04504997f, 0.15705185f, 0.00277627f, -0.16600029f, -0.40483975f, -0.26374725f, 0.08949260f, 0.08348572f, 
    -0.34491652f, 0.29178527f, 0.02091581f, -0.21068062f, -0.79218513f, 0.04661428f, 0.00303415f, -1.75276887f, 
    0.12143661f, 0.25188151f, 0.28088349f, -0.35063136f, -0.25005808f, 0.14115059f, -0.30625230f, -0.94088954f, 
    -0.00538722f, -0.59779835f, -0.62447089f, -0.62415779f, 0.42345715f, 0.25559792f, -0.06467737f, -0.40293711f, 
    -0.26144499f, -0.12852053f, -0.61823815f, 0.69617659f, -0.77638781f, 0.01930404f, 0.20442984f, -0.02083488f, 
    -0.60819042f, 0.08926181f, 0.31481209f, 0.11801375f, 0.17977417f, -0.60432607f, -0.27505186f, -0.44944713f, 
    0.06860910f, -0.59205526f, -0.26641712f, -0.29693922f, -0.21272679f, -0.28456149f, -0.62870711f, 0.58123201f, 
    -0.17828684f, -0.46706539f, -0.30751812f, -0.12700930f, 0.33108762f, -0.56743670f, 0.14815226f, 0.24769729f, 
    -0.41762224f, 0.06742740f, 0.09836086f, 0.39726096f, 0.11005277f, 0.31354228f, 0.27183357f, -0.13178156f, 
    -0.38429311f, 0.16910034f, 0.10187228f, 0.02861266f, -0.19196385f, 0.11448460f, -0.04756965f, -0.12203681f, 
    0.10841095f, -0.51710677f, -0.40472767f, -0.39675876f, -1.66232562f, 0.22214200f, -0.89489079f, -0.96174532f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.19205083f, 0.16044755f, -0.03091360f, -0.04826926f, -0.18417966f, -0.13376540f, -0.12232728f, -0.24606524f, 
    0.08490910f, 0.29304042f, 0.19687460f, 0.09782847f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
