#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01760621f, 0.21077609f, -0.79264617f, -0.34294182f, 0.40882301f, -0.76581872f, -0.17087008f, -0.02245998f, 
    -0.71684021f, 0.63323170f, -0.20767520f, 0.30307627f, 0.50561595f, -0.23112375f, 0.41888222f, 0.23325442f, 
    0.31139219f, -0.39997944f, -1.29867208f, 0.62337393f, -0.27060893f, -0.29864514f, -0.26524922f, 1.15809357f, 
    -0.46354797f, 0.09831064f, 0.28741601f, -0.74243903f, -0.34103271f, 0.89508867f, -0.45348269f, -0.55248660f, 
    -0.70217419f, -0.30615243f, 0.03448518f, -0.67355663f, 0.01425418f, -0.25059345f, 0.41964933f, 0.30317986f, 
    -0.38195696f, 0.52231103f, 0.08508167f, -0.20776491f, 0.34595212f, -0.15519533f, 0.43979761f, 0.49857000f, 
    -0.88872206f, -0.41434565f, 0.75156802f, 0.11333872f, 0.17221740f, 0.13847743f, 0.89264554f, 0.63128668f, 
    0.06886683f, -0.14355479f, -0.11543273f, -0.10196731f, -0.60878628f, 0.41663274f, -0.07020295f, -1.39087510f, 
    0.89244157f, -0.07837766f, -0.12279206f, 0.66386843f, 0.10225745f, 0.48666212f, -0.46430132f, -0.20440523f, 
    -0.15561834f, 0.74396348f, -0.03011492f, -0.73121411f, -0.81089550f, -0.95915318f, 0.34616840f, 0.32627553f, 
    -0.11499628f, 0.27515727f, -0.81574005f, -0.55838966f, -0.30399075f, 0.51989442f, -0.28389236f, -0.44069922f, 
    -0.75387955f, 0.61954504f, -0.19877063f, -0.35725996f, 0.66623545f, 0.12365270f, 0.80943298f, -0.60798329f, 
    -0.33989951f, -0.13567886f, 0.07355722f, -0.22615632f, -0.08441000f, 0.35836244f, 0.43784890f, -0.77887195f, 
    -0.66635823f, -0.06812035f, 0.60283583f, 0.61160451f, -0.86856234f, -0.80994177f, -0.46230811f, 0.82984793f, 
    -0.52015489f, -0.38745737f, -0.22241320f, -0.44709960f, -0.62239820f, 0.61969638f, 0.81678075f, 0.57312274f, 
    -0.60198045f, -0.20390262f, -0.27510527f, 0.42029020f, 0.01463358f, -0.24280567f, 0.50362021f, -0.62727791f, 
    -1.08082855f, 0.39485124f, 0.77223229f, 0.38027269f, -0.23057818f, 0.04263000f, -0.18005666f, -0.91432548f, 
    -0.34919921f, -0.43668199f, -0.09080870f, 0.70834768f, -0.71059763f, 0.45311114f, 0.42750552f, 0.26512513f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37288022f, 0.10023879f, 0.20765324f, -0.20328672f, 0.24439287f, 0.20864379f, 0.17131990f, 0.05430710f, 
    0.25987867f, -0.09194481f, 0.15845139f, -0.09123524f, -0.11482093f, 0.00379323f, 0.36332783f, -0.02694276f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04700479f, 0.09385812f, 0.14503062f, -0.14055112f, -0.03244865f, 0.05421824f, -0.02155512f, 0.04961368f, 
    0.04475388f, 0.14420103f, -0.03537085f, 0.00029321f, -0.05576631f, -0.06111100f, -0.10593557f, -0.01514568f, 
    0.15204152f, -0.07025305f, 0.00721475f, 0.16452570f, 0.04094140f, 0.11881418f, -0.01247496f, -0.08875088f, 
    0.09072790f, 0.01701483f, 0.02625485f, -0.03897895f, 0.05506663f, -0.06027902f, 0.06959104f, 0.03599569f, 
    0.04955138f, 0.01842424f, 0.09229910f, 0.06016951f, -0.13583004f, -0.07762536f, 0.05817187f, 0.03691344f, 
    -0.38156170f, 0.13608183f, 0.10262643f, 0.21141627f, -0.27249348f, -0.14483236f, -0.08901726f, -0.05667742f, 
    -0.08657514f, 0.02416997f, 0.16797772f, -0.14379819f, 0.17855008f, -0.04957404f, 0.14311960f, -0.15157712f, 
    -0.18743144f, -0.02894654f, -0.07595013f, 0.07184170f, 0.14983547f, -0.05232632f, 0.08525384f, 0.02682170f, 
    -0.22229970f, 0.04800831f, -0.06353474f, 0.03301465f, 0.08555537f, 0.12530638f, 0.04233827f, -0.02138155f, 
    -0.03945582f, -0.05854461f, -0.08819810f, 0.03353319f, 0.08500242f, -0.09300920f, 0.24402505f, 0.09918242f, 
    0.18898636f, 0.13470708f, -0.09336411f, -0.05096275f, 0.18344791f, -0.03927580f, 0.01460504f, 0.01772807f, 
    0.02759379f, -0.05018321f, 0.01100873f, -0.08113971f, -0.12462649f, -0.00340790f, -0.08727663f, -0.02634376f, 
    -0.12528187f, -0.03289670f, 0.03799134f, 0.06900940f, -0.23569646f, 0.16362168f, -0.07990955f, 0.14444944f, 
    -0.00839893f, -0.01963112f, 0.14487503f, 0.09100580f, -0.06903481f, 0.02400954f, 0.14541292f, -0.00986523f, 
    -0.02759007f, 0.05102846f, -0.01724148f, -0.05264172f, 0.06702086f, 0.03018656f, -0.04360148f, 0.08912925f, 
    0.00674106f, 0.17549255f, -0.49567837f, -0.04200236f, -0.06218997f, 0.12971441f, -0.05446011f, 0.13766038f, 
    0.05161203f, 0.12600361f, 0.08820057f, -0.01290980f, -0.03235381f, 0.05349750f, 0.05674867f, -0.02016320f, 
    0.02255710f, -0.03386775f, 0.00592844f, -0.06850670f, -0.29838318f, -0.01434079f, -0.08777341f, -0.01102104f, 
    -0.17321268f, -0.03085435f, 0.02646567f, -0.13278909f, -0.02735229f, -0.16977796f, 0.15708564f, -0.02031358f, 
    -0.09574294f, -0.05337398f, 0.04013271f, 0.19459000f, 0.03404986f, 0.07871888f, -0.21832146f, 0.04302315f, 
    0.01087167f, 0.34348187f, -0.07697232f, 0.12779188f, -0.19953768f, 0.01939879f, 0.08557997f, -0.04353845f, 
    0.00826793f, 0.23903814f, -0.00517229f, -0.03032835f, -0.05654800f, 0.03598910f, -0.02959179f, 0.03456446f, 
    0.13162977f, 0.04020930f, 0.11966435f, -0.00970752f, 0.24776818f, -0.21305768f, 0.24330325f, -0.12992825f, 
    -0.12252743f, 0.08890700f, 0.07662479f, 0.23313545f, -0.13532546f, 0.03780194f, -0.06583701f, -0.11906922f, 
    0.07487593f, -0.00366161f, 0.04892883f, -0.01527846f, 0.15067668f, 0.03403150f, -0.03434675f, -0.14301479f, 
    0.27723676f, -0.35044241f, -0.22914989f, -0.18887566f, 0.20505512f, 0.03896792f, -0.07863352f, -0.03082379f, 
    0.07704136f, 0.05187690f, -0.04955925f, 0.17605992f, 0.10558878f, -0.00085508f, -0.02648225f, -0.03881181f, 
    -0.03419163f, -0.10281447f, -0.01770604f, 0.16043900f, 0.18785910f, 0.09534813f, -0.03309273f, -0.06321901f, 
    -0.11916879f, -0.02997375f, 0.09247747f, -0.00072688f, 0.00147179f, 0.02464239f, -0.00045415f, 0.04322045f, 
    0.17086737f, -0.00632741f, -0.01723736f, 0.11788014f, -0.01730001f, -0.12872021f, -0.03415978f, -0.10046647f, 
    0.35245767f, -0.02404962f, 0.40526667f, -0.02492307f, -0.16939528f, -0.08777499f, 0.04962826f, -0.09390093f, 
    0.06579240f, -0.02604611f, 0.15399288f, -0.07124857f, -0.01084525f, -0.01297096f, 0.06864582f, 0.02564636f, 
    0.06227253f, -0.07880896f, 0.05105193f, 0.01545909f, -0.18270665f, 0.26223928f, -0.15373106f, 0.13677084f, 
    0.03396263f, 0.03013770f, 0.09751023f, 0.05607378f, -0.03446303f, -0.02338754f, 0.13255908f, 0.05952909f, 
    -0.01090043f, 0.05329644f, 0.09177019f, -0.02837916f, 0.09949123f, 0.06694784f, -0.00076063f, -0.05240215f, 
    0.07384750f, -0.52148014f, 0.16206621f, -0.01403021f, -0.12368391f, -0.12518336f, -0.12830530f, -0.05641723f, 
    -0.01485082f, 0.02578974f, 0.05071113f, 0.02429436f, -0.04049591f, 0.08051857f, -0.05928003f, 0.06491704f, 
    0.18240693f, 0.04513001f, 0.01337726f, 0.06712055f, 0.61550224f, 0.12691432f, -0.05668544f, 0.02076475f, 
    -0.22350605f, 0.06685360f, 0.09278831f, -0.08113058f, -0.03999326f, 0.05755450f, 0.26555684f, -0.11650065f, 
    0.06462480f, 0.10825335f, 0.02590017f, -0.05253461f, -0.04795902f, -0.04234612f, -0.12934354f, 0.01870105f, 
    0.09586177f, -0.05803970f, -0.00124717f, 0.02513796f, -0.17277291f, 0.03214033f, -0.09826349f, -0.19230762f, 
    -0.03065700f, 0.09604811f, -0.00423629f, 0.02770254f, -0.06108433f, -0.18278512f, -0.06484242f, -0.08092368f, 
    0.06562184f, -0.08948479f, 0.09221891f, 0.14408004f, 0.12092918f, -0.01897432f, 0.05329940f, -0.01632937f, 
    -0.00232182f, -0.02728384f, -0.05809316f, -0.00754242f, 0.01408155f, 0.02168407f, -0.15500353f, 0.02733557f, 
    -0.05074209f, 0.04476712f, -0.07038478f, -0.02970396f, -0.13466555f, 0.04578494f, 0.07586207f, -0.10267755f, 
    0.17142335f, 0.11169698f, 0.30325249f, -0.02046523f, 0.11395399f, 0.04827608f, 0.09595069f, 0.21423817f, 
    -0.23586884f, -0.17894402f, -0.11489461f, -0.03859048f, 0.06483737f, 0.15058061f, -0.04901802f, -0.09251032f, 
    0.01292320f, 0.20561169f, -0.08637120f, -0.12429169f, -0.01766262f, 0.22389422f, -0.22957942f, -0.02672182f, 
    0.40140492f, 0.12631157f, -0.06705564f, -0.11567432f, 0.18361866f, 0.01561918f, -0.00631411f, 0.01609990f, 
    -0.04172720f, -0.12259784f, 0.00310337f, -0.00443611f, -0.10009627f, 0.12617059f, -0.17358601f, -0.01721714f, 
    0.10070556f, 0.04407578f, -0.07424954f, 0.01626828f, 0.04381687f, -0.05200595f, 0.00785848f, -0.03207240f, 
    -0.00995831f, -0.00488434f, -0.05392678f, -0.02045181f, -0.01229517f, -0.09055419f, -0.07481783f, -0.07330292f, 
    -0.10167257f, 0.17280859f, 0.01641637f, -0.06268471f, -0.00824179f, -0.14097930f, 0.18489592f, -0.15909252f, 
    -0.08108309f, 0.01405737f, 0.08700963f, 0.02849929f, -0.00874531f, 0.07211480f, 0.10932037f, 0.01346056f, 
    0.01054825f, 0.08855875f, -0.04996036f, 0.06612534f, -0.07164555f, 0.15995552f, -0.04172979f, -0.13089043f, 
    0.03908980f, 0.04642946f, 0.10407365f, -0.22475228f, -0.09235786f, -0.18224443f, -0.05208104f, -0.11295445f, 
    0.07890936f, -0.01477343f, -0.01012375f, 0.07106803f, 0.03770651f, 0.10500383f, 0.02251130f, 0.02298940f, 
    0.08016076f, -0.02948575f, 0.23243679f, 0.03382608f, 0.41243717f, -0.26684597f, 0.09011112f, -0.26211801f, 
    0.21262644f, 0.10029943f, 0.02575859f, 0.08363315f, 0.03382329f, 0.08695187f, -0.29851839f, -0.01809281f, 
    -0.00230047f, 0.08557264f, 0.04197916f, 0.05726881f, -0.00497438f, -0.10020661f, 0.12348194f, -0.00431749f, 
    -0.27140129f, -0.32852891f, 0.26154086f, -0.04198755f, -0.09008728f, 0.04123762f, -0.00903289f, -0.24108352f, 
    0.06378315f, 0.01689468f, -0.07015653f, -0.10797374f, 0.10916086f, 0.04261813f, -0.06727391f, 0.02120583f, 
    -0.02762949f, -0.05008158f, -0.01548862f, -0.05034484f, 0.02650114f, 0.23953296f, 0.32960668f, 0.27910519f, 
    -0.03710807f, 0.05760177f, -0.02331893f, 0.14007989f, -0.04573037f, -0.12528282f, -0.08019795f, -0.08021240f, 
    0.16171746f, -0.37396821f, -0.02421421f, -0.05838653f, 0.17474799f, -0.07947294f, 0.13766570f, -0.01744086f, 
    0.15652175f, 0.21079187f, 0.06224451f, -0.16730818f, 0.16120791f, 0.06318069f, -0.04575146f, 0.07337906f, 
    -0.04871453f, 0.03797926f, -0.09467497f, 0.15249172f, 0.08253382f, -0.05385901f, -0.08858527f, -0.03254186f, 
    0.04856171f, 0.03995318f, 0.05963387f, -0.12758102f, -0.22576892f, 0.07699339f, 0.13810205f, 0.10519934f, 
    0.13514373f, 0.29575789f, 0.02737784f, 0.10171051f, 0.09624612f, 0.18503460f, -0.04874124f, 0.02166291f, 
    0.08671360f, 0.04221907f, -0.07528631f, -0.12371764f, -0.09673239f, 0.13530612f, -0.18757571f, -0.02024546f, 
    0.20462464f, 0.32964513f, 0.27822560f, 0.09132674f, 0.21014763f, 0.12308764f, 0.05658605f, -0.03046733f, 
    0.18583462f, 0.04298175f, -0.07600233f, 0.00116022f, -0.02660728f, -0.06560695f, 0.08428457f, -0.11963375f, 
    0.03206835f, 0.17546126f, -0.02045592f, 0.05809611f, 0.00305514f, -0.10652519f, 0.28100082f, -0.01318327f, 
    -0.15499410f, -0.07173898f, -0.02203811f, -0.14890878f, 0.00629620f, 0.05346830f, 0.01595699f, 0.04058355f, 
    0.07305469f, 0.09741499f, 0.02864774f, 0.04274781f, -0.05394833f, -0.20283884f, 0.12646937f, -0.04569945f, 
    0.57078332f, 0.33661950f, 0.13195978f, 0.26693657f, -0.09393290f, 0.10656555f, 0.09777772f, 0.08183692f, 
    0.02148449f, 0.07113402f, -0.04538490f, -0.06297714f, -0.03310985f, -0.04107082f, 0.02090822f, 0.00185187f, 
    0.03801994f, -0.22666775f, 0.03228929f, 0.00205787f, 0.51149857f, -0.05682494f, -0.10908108f, 0.07554452f, 
    0.34721115f, 0.17014717f, -0.00921033f, 0.12782630f, 0.14808446f, -0.18086894f, -0.06172911f, -0.00777627f, 
    0.04732387f, 0.11223821f, -0.02692816f, 0.02920734f, -0.01710321f, -0.14327581f, 0.03572713f, -0.02173773f, 
    -0.36145118f, -0.15350641f, -0.00068902f, 0.10066183f, -0.08823375f, 0.02840651f, -0.05694189f, -0.09945512f, 
    0.08323976f, -0.05951754f, -0.06864952f, -0.06220568f, 0.01047956f, 0.14068064f, -0.05100258f, 0.03365692f, 
    0.03224120f, 0.02182343f, 0.19404934f, -0.10334183f, 0.32338095f, 0.07518994f, 0.21576647f, 0.15003335f, 
    0.08040429f, 0.06808187f, -0.04174676f, 0.02970471f, -0.07697744f, 0.02338566f, 0.23333965f, 0.05125420f, 
    -0.03153764f, -0.00950342f, 0.09669090f, -0.11536697f, -0.18036294f, -0.07454862f, 0.02091041f, 0.01146539f, 
    -0.07588961f, -0.23512098f, -0.20570669f, -0.46413544f, 0.07089001f, -0.32268569f, 0.06259043f, 0.13387148f, 
    0.17550354f, 0.34958279f, -0.00093421f, -0.04935591f, 0.00528948f, -0.05029775f, -0.06989989f, -0.05905414f, 
    0.12892373f, -0.07907687f, -0.01716931f, -0.01839189f, -0.47844318f, -0.40166220f, -0.14656869f, 0.07765333f, 
    0.23219413f, 0.06729614f, 0.19512893f, -0.07299385f, -0.10353749f, -0.11841951f, -0.10662712f, -0.07514612f, 
    -0.01570245f, 0.00893941f, 0.02889643f, -0.09740593f, 0.12146727f, -0.02166509f, 0.07878424f, -0.03009704f, 
    0.14814244f, 0.05951751f, 0.09959601f, 0.07567573f, 0.02528250f, -0.05179434f, 0.00439313f, -0.02011985f, 
    -0.02844039f, 0.04190646f, 0.07888845f, 0.09272365f, -0.00091843f, -0.01209600f, 0.08637013f, 0.02393887f, 
    -0.10569016f, -0.06409108f, -0.05051554f, -0.04072876f, 0.08451419f, 0.06631692f, 0.14605992f, 0.06273139f, 
    0.06767015f, 0.00350993f, 0.07413052f, -0.10531482f, 0.05259944f, 0.08322044f, 0.09198546f, -0.04458809f, 
    -0.03652030f, -0.05676964f, 0.03144259f, 0.07668878f, -0.00920908f, -0.06422600f, -0.00209165f, -0.01403793f, 
    0.41692212f, 0.28505921f, 0.26869127f, 0.21377240f, 0.39060849f, -0.06872491f, -0.05593784f, 0.07672609f, 
    -0.06523890f, -0.05036507f, 0.00530743f, -0.01853092f, -0.03252004f, -0.03700492f, 0.02581930f, 0.05924206f, 
    0.07937492f, -0.07386369f, 0.11345315f, 0.00846155f, 0.47618192f, 0.09420270f, 0.22323836f, -0.30732855f, 
    -0.43831897f, -0.15102598f, -0.14026563f, 0.17521694f, 0.18031015f, 0.07882542f, -0.00659491f, 0.10501090f, 
    0.15038927f, 0.22244498f, 0.05699950f, -0.11099438f, -0.02681855f, 0.00352938f, -0.02579413f, -0.11707324f, 
    -0.39000630f, -0.21364716f, 0.05582751f, 0.14123642f, 0.08818836f, 0.12568203f, 0.11544544f, 0.02988808f, 
    0.05211996f, 0.06633689f, -0.08258232f, -0.07546297f, -0.02920919f, -0.04065191f, 0.09468859f, 0.03486729f, 
    0.06937589f, 0.19752622f, 0.25098115f, -0.09765805f, -0.50496197f, -0.25993413f, -0.30741724f, -0.32488209f, 
    0.16111620f, 0.12046788f, 0.13314690f, -0.04680134f, -0.06650962f, 0.02617178f, -0.02831082f, -0.03363674f, 
    -0.00088244f, 0.11527833f, -0.04254485f, -0.03945502f, 0.28727770f, -0.04483126f, 0.12103004f, -0.06906014f, 
    0.35692278f, 0.00019573f, 0.27984682f, 0.35141033f, 0.02351200f, -0.16070721f, 0.08995628f, 0.09982085f, 
    -0.09581329f, -0.05370319f, 0.04130436f, 0.04539997f, 0.10343684f, 0.10896243f, -0.09532521f, 0.06801616f, 
    0.07224621f, -0.03510745f, -0.16686295f, -0.06571507f, -0.33315080f, 0.02846279f, 0.13296399f, -0.08506575f, 
    -0.05357761f, 0.30102947f, 0.09376790f, -0.07865998f, 0.12426841f, 0.08918480f, 0.09646610f, 0.00249713f, 
    0.05701731f, 0.05982102f, -0.00989419f, -0.08609716f, 0.06955174f, 0.07398575f, 0.00043321f, 0.09654148f, 
    -0.08732528f, -0.17879243f, -0.48772687f, -0.74328798f, 0.08661065f, 0.09978184f, -0.02697679f, -0.14509948f, 
    -0.03278544f, 0.05710758f, -0.08875711f, -0.02529549f, 0.05750972f, -0.18106660f, -0.02727549f, 0.03383893f, 
    0.06275433f, -0.03967383f, 0.02674744f, 0.11131292f, 0.38458714f, 0.09381468f, 0.18644287f, 0.22162868f, 
    0.31359595f, -0.04749811f, -0.08694754f, -0.01107153f, 0.00030392f, -0.06369342f, 0.02050634f, 0.01402964f, 
    -0.04135188f, -0.08859508f, 0.02399976f, 0.06164498f, -0.00703435f, 0.01879424f, 0.08335256f, -0.10101178f, 
    0.24262968f, -0.16392098f, -0.25401178f, -0.13042176f, -0.02491217f, -0.03896671f, -0.12072832f, -0.05905295f, 
    -0.04274417f, 0.06619425f, 0.12180512f, 0.17293896f, 0.10831044f, -0.01460659f, 0.02274937f, -0.01689215f, 
    -0.03284914f, -0.04805136f, 0.05131331f, -0.00455701f, -0.15194210f, -0.07468867f, 0.07927178f, -0.21217984f, 
    -0.21900848f, 0.01318340f, -0.04050976f, 0.18193537f, 0.00367475f, 0.03853650f, -0.20844170f, 0.04607333f, 
    -0.04059261f, 0.04532606f, 0.03095688f, -0.05532494f, 0.06819309f, 0.01096414f, 0.01765054f, -0.08876635f, 
    -0.06289048f, 0.03721018f, 0.01092558f, -0.00035832f, -0.05860531f, -0.01705131f, -0.04596289f, -0.01864458f, 
    -0.02762767f, 0.03597296f, 0.00820479f, 0.01593448f, 0.01227026f, -0.03758782f, -0.03795594f, 0.05178723f, 
    0.00921616f, 0.02863744f, 0.04912880f, 0.00317520f, -0.04347147f, 0.04016490f, -0.03116359f, -0.04035852f, 
    -0.04145135f, 0.01084818f, -0.00203118f, -0.02547707f, -0.04563178f, -0.03139070f, 0.03718644f, -0.05807668f, 
    0.04309702f, -0.04428051f, -0.01484587f, -0.01308254f, 0.02573933f, -0.00719753f, -0.01666129f, -0.01713110f, 
    0.01910775f, -0.04158815f, -0.04963276f, -0.04619028f, -0.00192348f, 0.01319683f, -0.02750697f, 0.03415499f, 
    -0.01031390f, -0.05557925f, 0.05589416f, -0.02652554f, 0.00790048f, 0.03491356f, 0.04318493f, -0.01133045f, 
    -0.00230537f, 0.02438309f, -0.00970770f, 0.04662758f, -0.04569425f, -0.04315363f, 0.01336329f, -0.04386622f, 
    -0.03864677f, -0.02196638f, -0.03991424f, 0.03813059f, -0.04968320f, -0.04352654f, 0.04081035f, 0.04419310f, 
    0.02169224f, 0.00772306f, -0.06203284f, -0.05224989f, 0.02831313f, 0.02512287f, -0.02217392f, 0.03169226f, 
    -0.00529941f, 0.03112122f, -0.04039764f, 0.02158872f, -0.05004262f, -0.00433418f, 0.00616206f, -0.04872423f, 
    0.03619587f, 0.01099829f, -0.02080736f, 0.02220673f, 0.03278092f, 0.04834474f, -0.03555270f, -0.00262981f, 
    -0.01946422f, -0.03578218f, 0.01659140f, 0.04379633f, -0.04826723f, -0.04642650f, -0.01530058f, 0.00449105f, 
    0.01850911f, 0.04690068f, 0.04251769f, 0.01743056f, 0.04497959f, -0.01881243f, -0.02315684f, 0.01410314f, 
    -0.03741918f, 0.00505402f, -0.05630705f, -0.04979733f, -0.01495402f, -0.00458096f, -0.03199653f, -0.04623637f, 
    -0.02042476f, 0.03708107f, -0.01254698f, 0.03846253f, -0.02125173f, -0.01966745f, -0.01270707f, -0.03131261f, 
    -0.03521557f, -0.04593512f, 0.04010423f, 0.04253834f, 0.04606966f, 0.04282722f, -0.04019798f, -0.03775088f, 
    0.00503181f, -0.02517930f, -0.01217356f, -0.00671937f, -0.05659945f, 0.02631775f, -0.01573770f, -0.03138388f, 
    -0.00932931f, 0.03695418f, 0.04043230f, 0.01834294f, -0.00014127f, -0.03096347f, -0.04027621f, -0.04598533f, 
    0.02360960f, -0.01814328f, 0.01075493f, -0.03160847f, -0.04059907f, 0.03794860f, -0.04409742f, -0.03019913f, 
    -0.00674903f, 0.04510332f, 0.01902027f, 0.02530248f, -0.06591223f, -0.00544020f, -0.04119661f, -0.02810442f, 
    -0.04484197f, -0.04285102f, -0.05743879f, -0.04475344f, -0.03081621f, 0.01343411f, 0.02876161f, 0.05578704f, 
    0.03613596f, -0.05147793f, -0.06047935f, -0.06171646f, 0.01457191f, 0.03848593f, -0.06150362f, 0.02603581f, 
    -0.00205446f, 0.01593803f, -0.05351863f, 0.03843419f, -0.00946968f, 0.03195735f, -0.02992634f, -0.01401386f, 
    -0.03163429f, -0.03439181f, -0.03643684f, 0.00636685f, 0.02367604f, -0.01277099f, 0.04710140f, -0.04160000f, 
    -0.05096031f, 0.00398131f, 0.03385596f, -0.00473558f, 0.00846382f, 0.01835634f, 0.02560418f, -0.01595192f, 
    -0.04176207f, -0.04832729f, 0.05035116f, -0.01341098f, 0.00003279f, -0.04074014f, 0.03858219f, 0.02712506f, 
    0.03918020f, -0.02489047f, 0.00511501f, -0.05634356f, -0.00960850f, -0.01208337f, 0.00333793f, -0.00072397f, 
    0.01868224f, -0.00680253f, -0.01770801f, 0.01083409f, 0.01465159f, -0.06057545f, -0.01239154f, -0.02766065f, 
    -0.01474261f, -0.04882831f, -0.02890804f, -0.03481355f, 0.00593399f, 0.04894988f, 0.03562967f, 0.02318426f, 
    0.00482153f, -0.06583320f, 0.00215969f, -0.00849632f, -0.03509232f, -0.00333969f, 0.00813770f, -0.01280828f, 
    0.02364153f, -0.04024612f, 0.01728550f, 0.04271588f, -0.05232394f, -0.05893824f, 0.01885697f, 0.02214805f, 
    0.00198460f, 0.03699210f, 0.00086855f, 0.04427396f, -0.05746121f, -0.01746698f, -0.03023501f, -0.00260235f, 
    -0.03424236f, 0.05857249f, -0.01413159f, 0.03819250f, -0.00245440f, -0.04700711f, 0.00880687f, -0.04206355f, 
    -0.04081271f, -0.04838199f, -0.05812391f, -0.04911324f, -0.02761868f, -0.02073139f, 0.01078267f, 0.00139468f, 
    0.04871002f, 0.02295515f, -0.04816987f, 0.02137378f, 0.01633441f, -0.00969899f, 0.00114389f, 0.01475385f, 
    -0.05786619f, 0.02633639f, 0.01526548f, -0.01690639f, -0.02710648f, 0.00870532f, 0.00470588f, -0.02622316f, 
    0.00509183f, 0.02668724f, -0.00519253f, 0.01053239f, 0.02984621f, -0.01492222f, -0.02133728f, -0.00693430f, 
    -0.03932928f, 0.01043712f, -0.05671378f, -0.04677717f, -0.03711454f, 0.01380046f, 0.04389676f, -0.01677315f, 
    0.03856387f, 0.01053564f, 0.05921192f, 0.00863437f, 0.00019947f, -0.04326167f, 0.02433841f, 0.00316854f, 
    0.06665489f, 0.05151159f, 0.14455013f, 0.00776499f, 0.25432265f, 0.06668708f, 0.02649278f, 0.25721884f, 
    0.10191028f, 0.06996536f, -0.02568693f, -0.00913757f, 0.06513267f, -0.05422776f, 0.06202208f, -0.00276544f, 
    -0.07726475f, -0.00476777f, 0.00603301f, -0.18123779f, 0.00801455f, 0.11934870f, 0.11646225f, -0.00329308f, 
    -0.03657070f, -0.09400198f, -0.05747073f, -0.15577687f, -0.11884820f, -0.12828106f, 0.04861176f, -0.05484511f, 
    0.13271931f, 0.04264816f, 0.06583494f, -0.09506695f, 0.05443151f, 0.00803743f, 0.04129133f, -0.00513705f, 
    0.03596450f, -0.03066935f, -0.17717639f, -0.13219073f, -0.35759628f, 0.25565144f, 0.07946624f, 0.06756911f, 
    -0.01733042f, 0.10583672f, 0.02508052f, -0.03407643f, -0.02203875f, -0.04297902f, -0.11061878f, 0.03798377f, 
    0.06153941f, 0.12491285f, 0.09456655f, 0.08301310f, -0.23494086f, -0.18958288f, 0.13795918f, 0.04686746f, 
    -0.24599682f, 0.12504984f, -0.15591879f, -0.09631161f, 0.17771655f, 0.05817203f, 0.03497181f, 0.04005838f, 
    0.05191895f, -0.08377797f, 0.04108099f, -0.08714371f, -0.09354502f, -0.10502218f, -0.26474920f, -0.31301904f, 
    0.02427334f, -0.00664978f, 0.04217144f, 0.09630842f, -0.07409074f, -0.07841174f, 0.00672247f, -0.06401349f, 
    -0.09206198f, -0.10272293f, 0.21244763f, 0.00224211f, 0.03292716f, 0.17088163f, 0.15852571f, 0.09862328f, 
    0.05809850f, 0.03094484f, 0.07805001f, 0.11801511f, -0.03057840f, 0.05532169f, 0.00264155f, 0.07712158f, 
    -0.16998982f, 0.17422190f, 0.00372564f, 0.03508172f, -0.04914339f, -0.09131083f, -0.03542567f, 0.00487158f, 
    0.06268667f, 0.04029245f, -0.05232058f, 0.06339796f, 0.07009362f, 0.21397443f, 0.07233384f, 0.09359393f, 
    0.35218319f, 0.23360023f, 0.19438341f, 0.24427448f, 0.00789245f, -0.07527186f, -0.05414976f, -0.11755265f, 
    -0.05819152f, -0.11275692f, -0.05660175f, -0.06687579f, 0.01855521f, -0.06063573f, -0.10869485f, -0.09562080f, 
    -0.02829198f, -0.00031682f, -0.03343996f, -0.11537400f, 0.16752349f, 0.69811857f, -0.15404740f, 0.02260936f, 
    -0.06054824f, -0.01851867f, 0.20853627f, -0.02423502f, -0.08255062f, -0.01246038f, 0.14099090f, 0.07965302f, 
    -0.11550661f, 0.09029298f, -0.02249392f, -0.01304004f, -0.11698846f, 0.03387455f, 0.16325869f, -0.02122353f, 
    -0.05532211f, 0.01320706f, 0.21466634f, 0.08862509f, -0.06116639f, 0.05786959f, -0.12307984f, 0.03627020f, 
    0.07514506f, 0.02658761f, -0.12827714f, 0.02105096f, -0.07223959f, -0.07394513f, 0.05095111f, 0.10566139f, 
    0.07878771f, -0.01992613f, -0.03967676f, -0.01403501f, 0.05275252f, -0.01184925f, -0.06466004f, 0.05743844f, 
    0.00684157f, 0.18475628f, -0.05775879f, 0.05151792f, 0.18921685f, 0.24686834f, 0.03504133f, -0.03037420f, 
    0.00862412f, -0.04122631f, -0.03955829f, 0.17732036f, -0.15396857f, 0.08315884f, 0.03857267f, 0.33683291f, 
    0.01760491f, 0.15536873f, 0.02262490f, 0.33375621f, 0.26368618f, -0.06198461f, 0.05852897f, -0.14321285f, 
    0.02324429f, -0.11123302f, 0.05948274f, 0.11746681f, 0.00449419f, 0.09853055f, 0.04800282f, 0.11687230f, 
    -0.06909408f, 0.08106240f, -0.07730096f, 0.05223818f, -0.19935714f, -0.17441066f, 0.05364259f, -0.05798325f, 
    -0.25188982f, -0.02181892f, 0.03653094f, 0.07742828f, -0.06933349f, -0.16125728f, -0.14602569f, 0.03926502f, 
    0.04837345f, -0.03821654f, 0.03312022f, 0.09872981f, 0.24914339f, 0.07136459f, 0.18129832f, 0.28926855f, 
    -0.03429059f, 0.11761762f, -0.05582981f, -0.05178041f, -0.01494590f, 0.10952526f, -0.02994897f, 0.09149607f, 
    0.09030912f, 0.11460605f, 0.01308520f, -0.00571676f, -0.00339692f, -0.01287252f, 0.07912538f, -0.03597860f, 
    -0.06860854f, -0.27086464f, -0.03382238f, -0.12680595f, 0.01205333f, 0.25138700f, 0.09615655f, 0.16427432f, 
    -0.04737037f, -0.06207987f, -0.06823118f, -0.09270339f, -0.10515331f, -0.13096356f, -0.10161534f, 0.00735320f, 
    -0.03134147f, -0.01605213f, -0.02408779f, -0.00092516f, -0.09881649f, 0.22551192f, -0.00988843f, -0.05415599f, 
    0.20096682f, -0.07020177f, -0.06803033f, -0.13147035f, -0.24653584f, -0.10655317f, -0.05163640f, 0.00948365f, 
    -0.01155862f, -0.10615271f, 0.11885581f, 0.15539469f, 0.10990924f, 0.02000042f, 0.08523931f, 0.04376373f, 
    -0.08530889f, 0.00516848f, 0.01550388f, 0.03144785f, -0.18070732f, -0.40982097f, -0.26454571f, -0.19879927f, 
    -0.30341583f, -0.13622950f, 0.11689116f, -0.03733239f, 0.24066657f, 0.16781506f, -0.04704500f, -0.01451850f, 
    -0.03416169f, -0.01403379f, -0.07935479f, 0.00561536f, 0.09468646f, 0.00335481f, 0.04563269f, 0.07803185f, 
    0.15386167f, 0.36665526f, 0.22609556f, 0.02924782f, 0.09443207f, 0.11529727f, 0.02561580f, 0.15227459f, 
    0.05488318f, 0.12181807f, -0.00243894f, 0.04360225f, -0.03720648f, 0.04505792f, 0.08118984f, -0.06832927f, 
    -0.06174600f, 0.00004259f, 0.06558401f, 0.00085819f, -0.16701680f, -0.38503695f, -0.23466837f, -0.22377881f, 
    0.01464711f, 0.00065405f, -0.02070799f, -0.04720444f, -0.02625936f, -0.10704797f, 0.08461358f, 0.00263022f, 
    0.03159951f, -0.00688837f, 0.06888852f, -0.01399506f, -0.06755960f, -0.05408404f, 0.02463752f, -0.03153298f, 
    -0.59556967f, 0.21429434f, 0.08784086f, 0.15269355f, -0.09372707f, -0.00607100f, 0.12354003f, 0.05634132f, 
    0.02445420f, 0.22954080f, -0.00466084f, 0.02722017f, 0.01817151f, -0.03433295f, -0.07261512f, 0.00867738f, 
    -0.01296658f, -0.08775156f, -0.09743409f, 0.11068119f, 0.23981182f, 0.03156591f, 0.37734523f, 0.08568056f, 
    -0.08013711f, -0.15735768f, -0.03999751f, -0.08843881f, 0.09214657f, -0.02019412f, 0.03788016f, -0.00214992f, 
    0.08362945f, 0.04421929f, 0.01208783f, -0.04421321f, 0.12322002f, -0.06151323f, 0.09472220f, -0.05659666f, 
    -0.40294540f, -0.11919626f, -0.05459115f, -0.02945421f, -0.12401262f, -0.10953819f, 0.09645092f, -0.01057508f, 
    -0.07721383f, 0.02191507f, 0.15863210f, 0.07193928f, -0.07258587f, 0.05630437f, 0.09378040f, -0.08083223f, 
    0.06448756f, -0.10538857f, 0.04488788f, 0.22104216f, -0.46361262f, -0.16422166f, -0.17245710f, 0.10307299f, 
    -0.08851738f, 0.01317629f, 0.13258448f, 0.01724220f, -0.00428152f, 0.06204727f, -0.05714444f, 0.05639265f, 
    0.11439148f, 0.05010698f, 0.05516728f, -0.01084326f, 0.06894740f, -0.09288841f, 0.00305336f, 0.04272069f, 
    0.40468201f, -0.51838076f, -1.13410449f, 0.07902466f, -0.39159825f, 0.02306529f, -0.20753577f, -0.01360368f, 
    -0.15791172f, 0.01152717f, -0.03408170f, -0.08150715f, -0.08140111f, -0.07728034f, 0.06599507f, -0.08744822f, 
    0.00739499f, -0.08133762f, 0.00811251f, 0.03904271f, -0.86361074f, 0.22413181f, -0.14753443f, 0.01971622f, 
    0.06500589f, -0.00445496f, 0.00130031f, -0.00774152f, 0.07758996f, 0.13676810f, 0.15066303f, -0.03781435f, 
    0.17078751f, -0.07591801f, 0.12659928f, -0.03123781f, -0.00289551f, 0.12724784f, -0.06417457f, -0.19207118f, 
    0.21862879f, 0.46238694f, 0.10977961f, 0.06958084f, -0.28376809f, -0.13714424f, -0.11018262f, -0.14032774f, 
    0.12233101f, 0.04607000f, -0.04369407f, 0.00794770f, 0.00269722f, 0.05827960f, 0.07395583f, -0.00760697f, 
    0.06478439f, 0.10080964f, 0.08076990f, 0.13147107f, 0.40188804f, 0.23809405f, 0.37034997f, -0.05509113f, 
    0.00173960f, 0.19719286f, 0.07174677f, 0.13608384f, 0.06611594f, 0.20399371f, -0.05177426f, -0.09467965f, 
    0.03367240f, 0.11234113f, -0.08532830f, -0.00757199f, 0.04541171f, 0.09110671f, 0.01633593f, 0.15608405f, 
    -0.07216939f, -0.56180876f, -0.45443007f, -0.04524440f, 0.14651151f, -0.15856086f, -0.02543131f, -0.08619680f, 
    0.03601452f, -0.08354301f, 0.04080696f, 0.01575437f, -0.01291406f, 0.16600196f, -0.00558764f, -0.00663611f, 
    -0.06082268f, -0.04037347f, -0.08326462f, 0.19274251f, 0.09326617f, 0.23959585f, 0.12136629f, -0.03758975f, 
    -0.20796475f, -0.03914011f, 0.05892157f, -0.02810520f, 0.01566623f, -0.08304642f, -0.08234120f, -0.02026015f, 
    0.20327619f, -0.03236171f, -0.02471624f, 0.02188211f, 0.24769782f, -0.04627763f, 0.14085242f, 0.25667897f, 
    0.50251728f, 0.35910797f, 0.43358603f, -0.16269679f, -0.02225979f, 0.00728457f, 0.13321261f, 0.14797466f, 
    0.01527205f, 0.01838297f, 0.10392972f, -0.04134681f, 0.09542564f, 0.07334491f, 0.03336850f, -0.01272889f, 
    -0.06561337f, -0.11380110f, -0.01396154f, -0.05960286f, -0.11867017f, -0.13642099f, -0.67176908f, 0.03332151f, 
    -0.31747490f, -0.02846287f, -0.05798119f, 0.02929704f, -0.01406346f, 0.00399656f, -0.06824367f, -0.03687109f, 
    -0.08030166f, -0.10662135f, -0.05891185f, -0.02254958f, 0.02624222f, 0.10774598f, 0.04538170f, -0.02804254f, 
    0.16888875f, -0.34036663f, -0.60406840f, -0.14377473f, -0.28685576f, -0.03373066f, 0.05362612f, 0.07504161f, 
    -0.04544372f, 0.01732631f, 0.17320119f, 0.05373618f, 0.00715123f, 0.05588652f, 0.02219914f, 0.00179888f, 
    0.06928083f, 0.11444769f, -0.05174509f, 0.09325466f, 0.11669068f, 0.24797074f, 0.09693302f, 0.04661595f, 
    -0.24868311f, -0.08723544f, 0.05115480f, 0.05249158f, 0.06697792f, 0.19357973f, 0.02229633f, -0.08438847f, 
    -0.17656685f, -0.15322259f, -0.08300728f, -0.02687473f, 0.20912193f, -0.01021328f, -0.00108271f, 0.12277704f, 
    -0.08452675f, -0.08849598f, -0.14714158f, 0.00130343f, -0.13087282f, -0.02018548f, 0.13021594f, -0.04827967f, 
    -0.00360397f, 0.00303702f, 0.00150345f, 0.07421396f, 0.00201278f, -0.04050692f, 0.05385492f, -0.02220585f, 
    0.02160602f, 0.13277982f, 0.07378254f, 0.28561765f, 0.03938786f, 0.06855896f, 0.06352928f, -0.01296928f, 
    -0.07907376f, -0.04158122f, 0.03073725f, 0.07762231f, 0.05313116f, 0.02058343f, -0.04124354f, -0.02432254f, 
    -0.08855024f, -0.13983658f, -0.12331229f, 0.04971625f, -0.13392998f, -0.00168961f, -0.07643788f, 0.01633588f, 
    -0.29026854f, -0.00745916f, 0.23642066f, -0.15440418f, 0.07547896f, -0.01876171f, -0.07330726f, -0.04749025f, 
    -0.09710428f, 0.08177743f, 0.04150302f, 0.05214868f, 0.19841897f, 0.07674053f, 0.16482663f, -0.13933145f, 
    0.06280087f, -0.04008993f, 0.04172011f, 0.02309368f, 0.11372268f, -0.05246615f, -0.35784370f, -0.15198259f, 
    0.12789635f, -0.05479386f, -0.05653238f, -0.01847879f, -0.04572974f, 0.06079109f, -0.02216185f, -0.04388834f, 
    -0.03353098f, 0.09879971f, -0.00648715f, -0.01448438f, 0.08170170f, 0.14009447f, 0.34361294f, 0.13984111f, 
    0.03505591f, 0.08816151f, 0.06154545f, -0.08319812f, 0.04982993f, -0.02722352f, 0.02680134f, 0.05809321f, 
    0.04678134f, -0.06224596f, 0.03753811f, -0.05538397f, 0.05172028f, -0.01840638f, -0.09126303f, -0.00084326f, 
    -0.00514807f, -0.12815280f, -0.11348925f, -0.15397730f, 0.10808674f, 0.14818923f, -0.04068680f, -0.03373059f, 
    0.16917850f, 0.02850061f, 0.13497640f, 0.09607318f, 0.06703815f, -0.06227061f, -0.04854630f, 0.03729753f, 
    -0.03882143f, -0.03651460f, 0.00004892f, -0.03419177f, 0.09774422f, -0.08252782f, 0.05424790f, 0.01653220f, 
    0.09802314f, 0.05073181f, -0.13365811f, -0.13949043f, -0.15104702f, 0.00927513f, 0.01573045f, 0.12014471f, 
    -0.03808934f, 0.00576091f, 0.00825167f, -0.04007904f, -0.12922375f, 0.04194054f, -0.04119957f, 0.05343127f, 
    0.21964794f, 0.10211466f, 0.14960317f, 0.17121804f, -0.44523054f, -0.22588275f, 0.16406168f, 0.12834819f, 
    0.00049996f, -0.05575493f, 0.14796904f, 0.01006263f, -0.00954918f, 0.19359292f, -0.02159101f, 0.00948612f, 
    0.33635539f, -0.09121147f, 0.12842825f, 0.07545770f, 0.06730094f, -0.02854983f, 0.01720456f, -0.03858729f, 
    0.11381826f, -0.07511595f, -0.36584386f, 0.01961371f, -0.13824505f, 0.05133211f, 0.08872972f, -0.06205421f, 
    0.05394597f, -0.04619121f, -0.01014400f, -0.12272935f, 0.06705824f, -0.04959550f, -0.04607112f, 0.07000230f, 
    0.18826410f, 0.00570583f, 0.17675069f, 0.10850693f, 0.19777493f, -0.10643142f, -0.04562458f, 0.06506836f, 
    -0.13660741f, 0.04921887f, -0.01676118f, 0.12458546f, -0.10366353f, -0.06550430f, -0.00238413f, 0.06737545f, 
    -0.04233195f, 0.05514960f, -0.03416347f, -0.11858097f, -0.03060739f, -0.08659822f, -0.05764328f, 0.06954695f, 
    -0.09020489f, -0.03231965f, -0.11139342f, -0.09427423f, 0.18506245f, 0.04553329f, 0.03570758f, -0.01896538f, 
    0.04331394f, 0.07658867f, -0.01034512f, 0.02865788f, 0.03251134f, 0.02991578f, -0.15616633f, 0.10360526f, 
    0.11746952f, 0.07091025f, 0.24033763f, -0.01602009f, 0.07097642f, -0.07531897f, -0.11219263f, 0.05160459f, 
    -0.13557717f, -0.06183229f, 0.02277537f, 0.08132243f, 0.01480395f, -0.14126727f, 0.05433895f, 0.00519971f, 
    -0.01963086f, 0.06225234f, -0.00194929f, -0.06822278f, -0.06366770f, -0.00892913f, -0.02575839f, -0.33094469f, 
    0.37805182f, -0.10943034f, 0.14366989f, 0.03424035f, -0.19137554f, -0.07909962f, -0.08008487f, 0.00628782f, 
    0.04682567f, 0.03380745f, -0.04572558f, -0.02000323f, 0.12171135f, -0.03922350f, -0.08781189f, 0.01298805f, 
    0.10957227f, 0.19357228f, 0.04182038f, -0.02115682f, 0.25426710f, 0.03370292f, -0.08635323f, -0.01223165f, 
    -0.12294610f, -0.02493793f, 0.08023150f, 0.10594337f, 0.01391580f, 0.00587377f, -0.05111629f, -0.03974294f, 
    -0.05313987f, -0.03052636f, -0.00110774f, -0.02177894f, 0.21575908f, -0.05761684f, 0.20349628f, 0.15703672f, 
    -0.07749475f, 0.01905614f, 0.03698718f, 0.23152241f, 0.04256843f, -0.00347786f, -0.08918439f, -0.02808231f, 
    0.12619874f, -0.06943347f, 0.00087503f, 0.13306345f, 0.18129760f, 0.15586466f, -0.09754913f, 0.13138317f, 
    0.11165283f, 0.04324926f, 0.07037164f, 0.15639646f, 0.04570776f, 0.11208276f, -0.01328710f, 0.12860854f, 
    -0.23026033f, -0.05101413f, -0.04277655f, -0.22480005f, -0.24463183f, -0.02225761f, -0.02907589f, -0.08323101f, 
    0.08009274f, 0.10501294f, 0.03670283f, -0.00999642f, -0.10206539f, -0.17792721f, -0.15476745f, -0.12349018f, 
    0.06565170f, -0.30422157f, -0.10038903f, -0.14874128f, 0.20438024f, -0.00025307f, -0.01239031f, 0.03039420f, 
    0.03449738f, 0.02873840f, 0.03301999f, -0.02874528f, 0.03972691f, 0.00669066f, 0.13258338f, 0.20489790f, 
    0.00361564f, 0.05461374f, -0.01964581f, 0.03773621f, -0.19045866f, 0.20230977f, 0.05899261f, -0.09842079f, 
    -0.04315753f, -0.01611082f, 0.05648501f, -0.00376993f, 0.00071554f, 0.07035786f, -0.01780797f, -0.02856810f, 
    0.05418397f, 0.16835870f, 0.02116088f, 0.06357390f, 0.14427800f, 0.01512856f, 0.03871982f, -0.01789140f, 
    0.72746944f, -0.23633870f, -0.21403717f, 0.00863334f, -0.04388584f, 0.08344953f, -0.01113830f, 0.03098465f, 
    0.02573256f, -0.05479565f, 0.05314969f, -0.06465507f, 0.05616830f, 0.12185723f, 0.07269396f, 0.04814846f, 
    0.09053969f, -0.01777502f, -0.00006874f, -0.10310714f, 0.36605772f, -0.16321662f, -0.11598086f, -0.32622698f, 
    -0.18193793f, -0.08528197f, -0.24040486f, -0.13221803f, 0.09083088f, -0.14365782f, 0.01743946f, 0.02499509f, 
    -0.01889063f, -0.01698936f, -0.03180590f, 0.02321043f, 0.11126538f, 0.11703020f, 0.12717113f, -0.08281230f, 
    0.02647483f, 0.16866380f, -0.02768533f, -0.01656295f, -0.06453460f, 0.02594024f, 0.07486404f, -0.00385103f, 
    -0.01259324f, -0.00614960f, 0.08612397f, 0.10003116f, 0.10393338f, 0.12694310f, 0.09322196f, 0.09688585f, 
    0.10094934f, 0.00650715f, 0.06264986f, -0.03790228f, 0.26252544f, 0.32175881f, -0.01577631f, 0.00119977f, 
    0.01876707f, 0.11156026f, 0.16155660f, 0.02502237f, 0.05504539f, -0.15617582f, -0.02467757f, -0.01678466f, 
    0.07718520f, 0.00184138f, -0.02703622f, -0.05400090f, 0.01354717f, 0.03930467f, 0.01287608f, -0.07122967f, 
    -0.39667517f, 0.15382661f, 0.25484207f, 0.07542896f, -0.23753154f, 0.05528805f, 0.09759174f, -0.06816652f, 
    0.09362687f, 0.05300329f, -0.02564619f, -0.04890362f, 0.01981357f, -0.04412873f, -0.00905047f, 0.07566324f, 
    0.04635900f, 0.05530191f, -0.08248285f, -0.04323203f, 0.15865007f, 0.19261949f, -0.28062776f, -0.20907219f, 
    0.13647579f, 0.03892801f, 0.22586626f, -0.11616068f, 0.07911111f, -0.06913094f, 0.00411203f, 0.19589792f, 
    0.10157252f, -0.04221875f, 0.07176468f, 0.07043412f, -0.10073654f, -0.08965756f, 0.03524470f, 0.06617851f, 
    0.23640807f, -0.20278031f, 0.05608027f, -0.07597082f, -0.15180647f, 0.02492193f, 0.10065074f, 0.02847075f, 
    0.00654594f, -0.14868844f, -0.03982522f, 0.04981898f, 0.03491230f, -0.00873703f, -0.06607169f, -0.02253450f, 
    0.06595184f, 0.06949389f, 0.00121699f, 0.14084581f, 0.30749643f, -0.67678738f, -0.24464434f, -0.09324932f, 
    0.12991926f, 0.03403034f, 0.06037382f, 0.17241530f, -0.18759488f, 0.13413119f, 0.09935440f, 0.01009399f, 
    -0.09836336f, -0.05778379f, 0.10644762f, 0.13700554f, -0.02698129f, -0.02982885f, 0.06196631f, 0.04249844f, 
    0.01184814f, 0.39017653f, -0.20974788f, 0.01282154f, 0.07552329f, 0.08555068f, -0.02548321f, -0.07544314f, 
    -0.05246973f, 0.01338242f, -0.04805909f, 0.02833147f, -0.02697643f, -0.03512952f, 0.11303023f, 0.20023654f, 
    0.04163460f, 0.02503720f, 0.04495276f, 0.02892015f, 0.20203517f, -0.09848236f, 0.03542376f, 0.09128518f, 
    -0.09675051f, -0.23135754f, -0.09453949f, -0.13267310f, -0.09573878f, 0.03390588f, -0.06221062f, 0.14112146f, 
    0.01854778f, -0.08230450f, 0.00412504f, 0.04506697f, 0.16473734f, 0.16789158f, 0.08578139f, 0.15610908f, 
    -0.06817751f, -0.63413149f, 0.06500190f, -0.17240371f, -0.23561741f, -0.03097368f, -0.19086608f, 0.15851282f, 
    0.15199505f, -0.13341594f, 0.06782763f, -0.06459029f, -0.04368134f, 0.13927382f, 0.14829244f, 0.01803240f, 
    0.01083811f, 0.23966819f, 0.13043682f, -0.07597901f, -0.24741271f, 0.25866452f, 0.21165738f, 0.07896916f, 
    -0.18846157f, -0.01210986f, 0.04003691f, -0.02200576f, 0.05514845f, -0.01635530f, -0.03072388f, -0.08542334f, 
    -0.02765580f, 0.00961621f, -0.07604087f, -0.16561058f, 0.06024045f, 0.18873116f, 0.01551344f, 0.00905111f, 
    -0.49452424f, -0.14045535f, 0.28080207f, 0.05528509f, 0.15044166f, -0.08778615f, 0.14912018f, 0.08900095f, 
    0.01747411f, 0.00856758f, 0.07276758f, 0.06833835f, 0.14040962f, 0.21207799f, 0.07210637f, 0.07787196f, 
    0.08683676f, 0.02209328f, 0.12299573f, -0.05686259f, 0.25791067f, -0.29488701f, -0.32760745f, -0.00108446f, 
    -0.13235235f, -0.29532707f, -0.05277705f, -0.03921814f, 0.07284398f, 0.16637731f, 0.24937847f, -0.09227927f, 
    -0.14496998f, -0.08298990f, -0.03041730f, -0.11064692f, 0.03937493f, -0.00557990f, 0.02447026f, -0.15964258f, 
    -0.24480656f, -0.12042382f, 0.23478809f, 0.23259389f, -0.09539794f, 0.08857669f, 0.04965970f, -0.03173199f, 
    0.02215420f, -0.06005288f, 0.03207538f, -0.05269345f, -0.04756384f, 0.01090287f, 0.07635938f, 0.00529153f, 
    0.02069351f, 0.25781593f, -0.06336621f, 0.12234300f, 0.20685269f, 0.12301238f, 0.11150999f, 0.03027851f, 
    -0.16209272f, 0.01885788f, -0.00761376f, 0.05741309f, 0.01217831f, -0.00498542f, 0.03658450f, 0.03917865f, 
    -0.05744474f, -0.15905175f, -0.09921376f, 0.04766703f, 0.02133884f, -0.03356018f, 0.08127741f, 0.07827993f, 
    0.54645801f, -0.16329958f, 0.14969303f, -0.21056709f, 0.30511394f, -0.25700611f, 0.05258643f, 0.05000969f, 
    0.07662885f, 0.08382906f, 0.10646532f, 0.09930052f, 0.01481586f, -0.04989827f, -0.00283438f, -0.06327609f, 
    -0.00051378f, -0.01172392f, 0.05609009f, -0.14842214f, -0.25710002f, -0.26729095f, -0.13026974f, 0.36735559f, 
    0.28201061f, 0.06458823f, 0.11507205f, -0.00622386f, -0.17595194f, -0.07354294f, -0.02261465f, -0.04750425f, 
    0.04887421f, -0.01550738f, -0.03997657f, 0.12658687f, 0.05206630f, -0.08042538f, 0.02846604f, 0.07273368f, 
    0.11130872f, 0.12139677f, 0.06732210f, 0.01911983f, -0.09872568f, 0.04046541f, 0.02659060f, 0.06411038f, 
    -0.00840982f, 0.00323960f, -0.11450840f, 0.03137643f, -0.04329116f, -0.02331966f, 0.00078841f, 0.04684628f, 
    -0.00466514f, 0.01313743f, 0.02891093f, -0.02364334f, 0.22677311f, 0.01149442f, 0.02373846f, -0.15072152f, 
    -0.04935057f, -0.09770014f, 0.08231571f, 0.04823039f, -0.04682968f, 0.01936194f, 0.04609109f, -0.04433668f, 
    0.09767531f, 0.01244434f, 0.03337368f, 0.14137413f, -0.00154108f, -0.01131599f, 0.09430135f, 0.04722449f, 
    0.16487682f, 0.13407741f, 0.06375013f, -0.13973539f, 0.00024254f, -0.06087548f, -0.06342486f, 0.02889928f, 
    -0.06271398f, -0.03775654f, -0.03081954f, 0.07780476f, 0.07169908f, -0.04499336f, -0.07854358f, -0.01651321f, 
    -0.00952069f, -0.04934658f, 0.08558423f, 0.18044248f, 0.71133417f, -0.27390438f, 0.26304135f, -0.03019381f, 
    -0.08862743f, -0.06954061f, -0.15933724f, 0.02363308f, -0.05896803f, 0.20653817f, -0.08023135f, 0.05327438f, 
    0.06650790f, 0.07073227f, 0.15688923f, 0.03229434f, 0.13014060f, -0.01854562f, -0.09871456f, 0.18114720f, 
    -0.30554372f, -0.36666888f, -0.07919140f, 0.14416327f, 0.10857370f, 0.05001854f, -0.02171640f, 0.03048721f, 
    -0.11499683f, -0.13895881f, -0.03525303f, 0.00916384f, 0.06462867f, 0.01321530f, 0.05704539f, -0.03563052f, 
    0.06272887f, -0.05202050f, 0.06358834f, 0.06080848f, -0.32218614f, -0.18478088f, 0.23984817f, 0.14816487f, 
    0.28520462f, -0.12961972f, 0.10219862f, 0.18182018f, 0.16696705f, -0.34441113f, 0.04520018f, -0.01600839f, 
    -0.01730196f, 0.02889442f, 0.10284234f, -0.06953930f, 0.08656382f, 0.07571550f, 0.11565302f, -0.03220822f, 
    0.18454312f, -0.08777387f, 0.30943242f, -0.05070746f, 0.04593470f, 0.11008182f, 0.04204259f, -0.01275594f, 
    -0.04131175f, -0.04098952f, -0.05233360f, -0.02217606f, -0.02799221f, 0.00559363f, -0.14094019f, -0.05909161f, 
    0.12523639f, 0.01865898f, -0.05603585f, -0.10850350f, -0.31530517f, -0.08267528f, 0.01168751f, 0.02822257f, 
    0.03686972f, 0.19332884f, -0.05682296f, -0.09233076f, 0.12205406f, 0.13599563f, -0.10447872f, -0.01599176f, 
    0.10272321f, 0.04969451f, -0.01658347f, 0.00257216f, 0.05435209f, 0.14265077f, 0.07068919f, 0.00486585f, 
    -0.07404380f, -0.05551358f, 0.00140728f, 0.31024551f, 0.16081204f, -0.06624822f, -0.08875756f, -0.11385987f, 
    0.09925686f, -0.02562332f, -0.07000030f, 0.07836451f, -0.05090963f, -0.05567621f, -0.07959931f, -0.05913732f, 
    0.00653433f, -0.03136805f, 0.14402887f, 0.07121348f, 0.27161282f, -0.03124359f, 0.11763435f, -0.14920959f, 
    -0.07241336f, -0.07197119f, -0.07744735f, 0.08597576f, -0.05067708f, -0.00624456f, 0.07481627f, 0.02768939f, 
    0.02000376f, -0.01412172f, -0.00552015f, -0.15860768f, -0.09665782f, -0.08771221f, 0.15609276f, 0.12223705f, 
    -0.06826399f, 0.26447955f, 0.39450982f, -0.01327749f, 0.01575083f, -0.07675926f, -0.01859352f, -0.01119306f, 
    0.06934189f, 0.17674419f, 0.03186480f, 0.05710470f, 0.04084169f, 0.06429040f, -0.04922581f, -0.06161988f, 
    -0.05944828f, -0.00053912f, -0.05580636f, 0.03115967f, 0.15632069f, -0.24899454f, 0.28094080f, 0.06567863f, 
    -0.03494000f, -0.19940442f, -0.22975083f, -0.11950779f, -0.11938974f, 0.01129238f, -0.07817654f, 0.18048497f, 
    0.11364295f, 0.04615530f, 0.05781499f, 0.03947710f, 0.02072087f, 0.00641752f, -0.09356460f, -0.11755047f, 
    -0.07287174f, -0.18924265f, -0.06248374f, 0.07677259f, 0.23392022f, -0.11925440f, -0.02008602f, 0.00620974f, 
    0.08965395f, -0.11338124f, -0.04822428f, 0.03221772f, 0.10599463f, 0.04147300f, -0.00785277f, 0.09252711f, 
    0.12569980f, 0.22325017f, 0.09235946f, 0.00113046f, -0.19678776f, -0.10956428f, 0.03551963f, -0.27864867f, 
    -0.07661892f, 0.06385019f, 0.09960802f, 0.03760813f, -0.13903846f, -0.02412899f, 0.05066358f, 0.11855022f, 
    0.07077197f, -0.07210944f, 0.00407437f, 0.15639517f, 0.03275730f, -0.06640056f, -0.06788783f, -0.06254620f, 
    0.58392978f, 0.21910171f, -0.34530911f, 0.14806208f, 0.11868361f, 0.17203885f, -0.09001368f, -0.04499995f, 
    -0.02212427f, 0.09464743f, 0.08080792f, -0.02636139f, -0.02072374f, -0.04697633f, -0.11775531f, 0.03850053f, 
    -0.04542430f, 0.04729709f, -0.04325169f, -0.06692298f, -0.25779095f, -0.06276038f, 0.02295630f, 0.38015449f, 
    0.02373767f, -0.06938899f, 0.17292975f, -0.00703549f, -0.22412916f, 0.01382186f, 0.05508452f, 0.01206633f, 
    -0.03282407f, 0.08053939f, -0.05363546f, -0.06203594f, 0.15861461f, 0.06618242f, 0.11087673f, 0.19683163f, 
    -0.10911001f, 0.09531449f, -0.05006272f, -0.03763483f, -0.07888774f, 0.07128537f, -0.00099379f, -0.17516993f, 
    0.00247203f, -0.01058693f, -0.01917620f, 0.02055069f, 0.06762887f, -0.00215832f, 0.08839612f, 0.08844201f, 
    -0.09035189f, -0.12613966f, -0.18026558f, -0.07772412f, -0.00194312f, 0.18487436f, -0.63253814f, -0.05757269f, 
    -0.05902850f, -0.11968148f, 0.08869677f, 0.08402927f, -0.10029688f, 0.00055439f, -0.01287465f, 0.07717985f, 
    0.11949413f, -0.08005989f, 0.04663931f, -0.08594160f, -0.01535885f, -0.13003024f, -0.09402801f, -0.12657075f, 
    -0.02733494f, -0.07419316f, -0.07823630f, -0.16666664f, 0.02936306f, 0.15578687f, -0.05906034f, 0.30301532f, 
    -0.08059946f, -0.04780363f, 0.04646021f, -0.09343262f, 0.11813886f, -0.02347202f, -0.01941797f, 0.11925308f, 
    -0.04548972f, 0.12605411f, -0.15214373f, -0.09230117f, 0.37489188f, 0.47614112f, 0.27642798f, 0.55045992f, 
    -0.31706980f, -0.01273105f, -0.15211175f, 0.12807408f, 0.01713060f, 0.10093572f, 0.12075847f, -0.08295966f, 
    0.28259861f, -0.04074734f, -0.02754651f, -0.05482605f, -0.07065085f, -0.02193546f, 0.05294815f, 0.01797117f, 
    0.09087460f, -0.04141463f, -0.12459235f, 0.34587350f, 0.34199616f, -0.13859037f, 0.15087923f, 0.11503166f, 
    0.08013768f, 0.11684276f, 0.07771025f, 0.02781528f, -0.01018264f, -0.19535126f, -0.05283374f, -0.04983956f, 
    -0.03321785f, 0.07666309f, 0.12118291f, -0.00438142f, -0.25963554f, 0.12418589f, -0.27438262f, -0.12898864f, 
    -0.08079106f, -0.02910703f, -0.02526493f, -0.09774648f, 0.05082073f, 0.02716172f, 0.05616178f, 0.11817312f, 
    -0.04799432f, 0.08854699f, -0.08912238f, 0.03168457f, 0.07422254f, -0.04383967f, 0.01934211f, 0.16054849f, 
    -0.34616995f, 0.07744217f, 0.15913337f, -0.01252378f, -0.27651620f, 0.03102507f, 0.07134441f, -0.06484956f, 
    -0.07169307f, -0.06063089f, -0.02766545f, 0.09044787f, -0.02836373f, -0.03209748f, 0.03123904f, 0.10661139f, 
    0.14914766f, -0.01976380f, -0.01872235f, 0.16847974f, -0.05865234f, -0.09158086f, 0.18039028f, 0.05984157f, 
    0.22065827f, -0.03791452f, 0.12504926f, 0.13026112f, 0.07833692f, 0.06504636f, 0.16090174f, -0.02877853f, 
    -0.19805917f, 0.02644687f, 0.02417312f, 0.02969436f, -0.20117220f, 0.20156035f, -0.16879533f, -0.18290570f, 
    -0.29327399f, -0.28378895f, -0.17790839f, 0.14077406f, 0.10058163f, -0.04216634f, -0.02014451f, -0.16141400f, 
    0.04726209f, -0.03468090f, -0.06875484f, 0.06089050f, -0.02425144f, 0.12051996f, -0.12783411f, 0.06073536f, 
    0.16823846f, 0.10107958f, 0.03148382f, -0.03328151f, 0.22703999f, -0.13264358f, -0.38466230f, -0.16616814f, 
    -0.00338697f, 0.15455176f, 0.27990335f, 0.27529573f, -0.03542963f, 0.15143603f, 0.07756551f, 0.01819705f, 
    0.00030434f, -0.10881706f, 0.02175413f, 0.07111447f, -0.03972326f, -0.01048723f, -0.11283249f, -0.08375166f, 
    -0.22043261f, 0.45958856f, 0.23490573f, -0.12491381f, 0.23719348f, 0.07625055f, -0.12891772f, -0.11902337f, 
    0.06583329f, -0.10518393f, -0.10811343f, 0.02935852f, 0.27340731f, 0.08859707f, 0.01962336f, -0.06501628f, 
    -0.02789328f, 0.05691016f, -0.10628796f, 0.04283871f, -0.36234856f, -0.01216799f, 0.40832481f, 0.13599592f, 
    0.14957944f, 0.07183266f, 0.07454704f, -0.08262592f, 0.05908184f, 0.11853492f, 0.03051368f, 0.05960358f, 
    0.02613291f, 0.01132129f, -0.08630819f, 0.02591132f, -0.06622709f, 0.09712186f, -0.02732052f, -0.00063678f, 
    -0.00825313f, 0.01681146f, 0.02838526f, -0.04424470f, 0.02829063f, -0.00442776f, -0.01079815f, -0.01798367f, 
    0.00902976f, 0.03345319f, -0.00802579f, 0.00430433f, -0.02828541f, -0.04582114f, -0.00731193f, 0.04071892f, 
    -0.02896389f, -0.02444777f, 0.01258079f, 0.04526158f, 0.00964824f, 0.01414839f, -0.00197226f, -0.04604193f, 
    0.03570894f, 0.01256373f, -0.02560548f, 0.04900696f, -0.04640909f, 0.01817585f, -0.00701560f, -0.00070676f, 
    -0.06447465f, 0.00273256f, 0.02493115f, 0.03293121f, -0.06166848f, 0.02633995f, -0.02749545f, 0.04652712f, 
    0.03410223f, -0.04516635f, 0.00434789f, -0.03414655f, 0.02443717f, 0.00493135f, 0.02866912f, 0.04410234f, 
    0.02615686f, -0.00636227f, 0.01374143f, 0.00109256f, -0.00758645f, -0.03507154f, -0.05247011f, -0.02410437f, 
    -0.02424050f, -0.00339598f, -0.03508961f, -0.04850165f, 0.03380858f, -0.01725293f, 0.00500536f, 0.00752203f, 
    0.00972264f, -0.01270769f, -0.00076213f, 0.03256017f, -0.05331337f, 0.04422535f, 0.01148944f, -0.01986834f, 
    -0.00629150f, 0.00457191f, -0.01037323f, -0.01409963f, -0.01433915f, 0.00193849f, 0.02241346f, -0.00308536f, 
    0.00849020f, -0.03559134f, -0.00411238f, 0.01798247f, -0.00858181f, -0.05790612f, 0.00753835f, -0.01205061f, 
    -0.00614180f, -0.00472345f, -0.06521245f, -0.04273517f, 0.01473268f, -0.00124729f, -0.00758648f, -0.06079523f, 
    -0.05154220f, -0.02004571f, 0.02589903f, -0.00200109f, 0.00018415f, 0.00587539f, 0.02223507f, -0.01146441f, 
    0.05067822f, -0.01527972f, -0.00211089f, 0.03573693f, -0.00957712f, 0.03695969f, -0.04584329f, 0.00407504f, 
    0.04273093f, -0.03331110f, -0.02132741f, -0.05283486f, 0.01412531f, 0.02483567f, -0.01321640f, -0.05920207f, 
    -0.01822206f, -0.04112598f, 0.03895102f, 0.03902726f, -0.02846855f, -0.01255028f, -0.05924150f, -0.00094658f, 
    -0.02482913f, -0.05408299f, -0.04308061f, -0.02842426f, 0.04680706f, 0.02826780f, 0.02770924f, 0.02485309f, 
    -0.01142282f, -0.02531692f, -0.00818720f, 0.01721106f, -0.03413687f, 0.03746074f, 0.01608745f, 0.02852774f, 
    0.01365850f, -0.05322668f, 0.01027607f, -0.04860480f, -0.04434194f, -0.00694052f, 0.00631817f, -0.03635984f, 
    0.00517978f, -0.01335625f, 0.00788432f, 0.03904776f, 0.04591586f, -0.01622248f, 0.02194173f, -0.05473957f, 
    -0.01815052f, 0.03963207f, -0.05220928f, -0.03872776f, -0.02181638f, 0.01324737f, 0.04554573f, -0.03842469f, 
    0.02217840f, 0.00609102f, -0.01685937f, -0.04647988f, -0.02135734f, -0.05343883f, -0.06189525f, 0.02879534f, 
    0.04082872f, -0.02563371f, 0.02336081f, 0.00670525f, 0.03152715f, -0.03456087f, -0.05411413f, 0.00813798f, 
    0.03417175f, 0.00643028f, 0.03661953f, 0.00828861f, 0.02943674f, -0.04636266f, -0.02018648f, -0.04915524f, 
    -0.00361332f, 0.04793712f, 0.02534435f, -0.01693978f, -0.03176265f, -0.05416248f, -0.06132060f, 0.00637683f, 
    0.03558731f, 0.02523958f, -0.03004131f, 0.03272597f, 0.02509046f, 0.03257367f, 0.04561362f, 0.04054676f, 
    0.00366159f, -0.03413740f, -0.00853679f, 0.03876504f, -0.05547430f, -0.05029925f, -0.02650536f, -0.05419450f, 
    -0.05555825f, 0.01461796f, -0.01408824f, -0.04759235f, 0.02184092f, -0.03343200f, 0.01444649f, 0.01112393f, 
    -0.04918087f, -0.05423304f, -0.02027126f, 0.02710298f, -0.03156012f, -0.01645167f, -0.05143331f, 0.01947692f, 
    -0.03693204f, -0.03101868f, 0.03764778f, -0.04765998f, 0.03698586f, 0.03358214f, 0.00877628f, -0.02007111f, 
    -0.01316694f, 0.00662995f, -0.04615570f, 0.02366520f, 0.00321281f, 0.01152193f, 0.02946185f, 0.02816976f, 
    -0.05266890f, -0.04036688f, -0.02307495f, 0.02494288f, -0.03272907f, 0.00328818f, 0.02815415f, -0.00381421f, 
    -0.06257743f, 0.00821059f, -0.03055674f, 0.00434531f, 0.04301106f, 0.01601697f, -0.04558079f, 0.00208095f, 
    -0.04438683f, -0.05320656f, 0.00597370f, -0.03702698f, 0.03983450f, 0.01846836f, 0.02556919f, 0.01171851f, 
    -0.00042912f, -0.01354476f, 0.01850597f, 0.01690924f, 0.04187412f, 0.01385048f, -0.00035506f, 0.01368284f, 
    -0.05121144f, 0.04042621f, -0.05336187f, -0.04854972f, 0.02156048f, -0.05788780f, -0.06424181f, 0.02844043f, 
    -0.02303195f, -0.05677344f, -0.05744503f, 0.00487994f, -0.03209250f, -0.02896127f, -0.04167441f, 0.00137663f, 
    -0.02754259f, -0.03505367f, 0.03610682f, 0.01225088f, 0.00085679f, 0.03438014f, 0.02054106f, -0.02236591f, 
    -0.04880308f, -0.00596681f, -0.03764372f, -0.01214588f, 0.02213082f, 0.02612871f, -0.05035976f, -0.00648867f, 
    -0.04967150f, -0.03251202f, -0.01179486f, 0.00021566f, 0.04616896f, -0.03806781f, -0.04906685f, 0.04607153f, 
    -0.03967446f, 0.04075712f, 0.00676450f, -0.02179658f, 0.00219225f, -0.05057214f, -0.02351795f, 0.00972760f, 
    0.02401132f, -0.00482364f, -0.04930469f, -0.01554270f, -0.05284831f, 0.00017326f, 0.01716452f, -0.03407489f, 
    0.04780351f, -0.02768940f, -0.02416909f, -0.05982188f, -0.00307745f, -0.05177940f, -0.04483626f, -0.02667607f, 
    -0.02860050f, -0.04550503f, -0.01294896f, 0.02403373f, 0.01992875f, -0.01055765f, -0.05187301f, -0.04306998f, 
    0.03156531f, 0.04663745f, -0.03404851f, -0.05698705f, -0.00636900f, 0.02303371f, -0.06258583f, -0.03624764f, 
    0.02152296f, 0.05333836f, 0.03573869f, 0.04607341f, -0.03663892f, -0.03279740f, -0.01708356f, -0.03428499f, 
    -0.02017648f, -0.02229200f, -0.05977062f, 0.04021333f, -0.02585429f, -0.04555884f, 0.05161573f, -0.04296065f, 
    -0.03861565f, 0.04439210f, -0.05345294f, -0.05179012f, -0.05298153f, -0.02247922f, 0.03366553f, -0.03750192f, 
    0.02843555f, -0.02286925f, -0.05967145f, -0.00862329f, -0.04762924f, 0.01099794f, -0.04161771f, -0.01416726f, 
    -0.01924866f, 0.01118713f, 0.01831632f, 0.04410509f, -0.01354417f, -0.02580389f, 0.01674499f, 0.01746656f, 
    -0.05340234f, -0.05152483f, -0.06394750f, -0.02613361f, 0.02754454f, 0.03013983f, 0.02311489f, 0.02795428f, 
    -0.03029271f, 0.03977405f, -0.05074401f, -0.04075056f, 0.03861219f, -0.06048700f, 0.02765858f, -0.04827464f, 
    -0.02573650f, 0.04208634f, -0.01459722f, -0.03530750f, 0.01082328f, -0.00023596f, -0.01360342f, 0.01568498f, 
    -0.05799878f, 0.00656848f, 0.00472772f, 0.04140332f, -0.04629019f, -0.04886758f, 0.00377598f, -0.02192753f, 
    0.01898311f, 0.04851418f, -0.05888973f, -0.01343644f, -0.04203848f, -0.00189418f, 0.00856877f, -0.02113689f, 
    -0.04349817f, 0.02733546f, -0.00394743f, -0.03167221f, -0.04888611f, 0.00091579f, -0.00873857f, -0.05512623f, 
    -0.02407664f, -0.02453567f, 0.01460448f, -0.02765951f, -0.03897049f, -0.04216535f, -0.05060589f, -0.02590278f, 
    -0.05568060f, -0.02482840f, -0.00710171f, 0.00573481f, -0.00835194f, 0.00586218f, -0.00300794f, -0.02559382f, 
    -0.01835027f, -0.01561106f, -0.03775179f, -0.01511694f, -0.04967519f, 0.00698233f, -0.05763744f, -0.02220379f, 
    0.02172420f, -0.01864586f, -0.01291904f, -0.01648607f, -0.01910148f, -0.00369959f, 0.04280543f, -0.04130820f, 
    -0.03210311f, -0.01806291f, 0.01604093f, 0.01056760f, -0.01415722f, -0.05118742f, 0.04465256f, 0.04527443f, 
    0.02936584f, 0.03158706f, -0.03740873f, -0.06076719f, 0.02769408f, -0.03706598f, -0.00097968f, -0.02967225f, 
    0.03607972f, -0.06078712f, 0.01210399f, -0.03044342f, 0.00117344f, 0.02106066f, -0.01243529f, 0.04866406f, 
    -0.03499372f, 0.03514434f, 0.02058665f, 0.04404373f, -0.05404760f, 0.03656704f, -0.00213192f, -0.04194329f, 
    0.04391110f, -0.02250693f, 0.02102180f, -0.02839279f, 0.03214392f, 0.04362498f, -0.00445331f, 0.01139482f, 
    -0.01021257f, 0.04545798f, 0.01300773f, 0.03006736f, -0.05156770f, -0.02373003f, 0.01473228f, -0.03717112f, 
    0.02087674f, -0.03089690f, 0.04245089f, -0.05015778f, 0.04443295f, 0.04241867f, 0.03813190f, -0.02852888f, 
    -0.05452551f, -0.00134416f, -0.04027024f, 0.04571693f, -0.00112784f, 0.00744203f, 0.00261722f, -0.01935975f, 
    0.00217200f, 0.01722406f, 0.01159809f, -0.01811654f, -0.01916978f, -0.06117835f, -0.03877323f, -0.04889934f, 
    0.01232047f, -0.01597716f, -0.05113332f, -0.01552636f, -0.01381033f, -0.03256630f, -0.01921445f, 0.03442140f, 
    0.03448068f, 0.01410825f, -0.01540544f, -0.02757516f, 0.02629417f, 0.02318442f, -0.03535469f, -0.03174423f, 
    -0.05726147f, -0.02534091f, -0.06309590f, 0.03006152f, -0.02180960f, -0.00430473f, -0.03946559f, 0.05195877f, 
    -0.02981842f, -0.04118451f, -0.03572888f, 0.00916476f, -0.03404001f, 0.04180520f, -0.01538915f, 0.02772931f, 
    0.04939687f, -0.02114038f, 0.01266577f, -0.02937996f, -0.03032005f, 0.04349541f, 0.04538416f, -0.01347310f, 
    -0.05258476f, 0.02812304f, 0.01930211f, -0.05584666f, -0.01191006f, -0.00585380f, -0.00165515f, -0.03253162f, 
    0.01896991f, -0.03067955f, 0.04783307f, -0.04575940f, -0.00078399f, -0.02475295f, 0.04005367f, -0.06040529f, 
    0.00363787f, -0.04422361f, 0.04324421f, -0.04766141f, 0.04608105f, -0.01455703f, -0.02041530f, -0.06173555f, 
    0.02082535f, -0.05395795f, -0.01662085f, -0.00051872f, 0.00951831f, 0.00728990f, 0.04692188f, -0.06012598f, 
    -0.00528334f, -0.02055130f, -0.02429133f, 0.01684576f, -0.03544184f, -0.02733877f, -0.02101163f, 0.02262180f, 
    0.03996021f, 0.02935656f, 0.01055928f, -0.02496863f, 0.01654460f, -0.05053396f, -0.06327045f, 0.04593704f, 
    0.10552164f, 0.15625821f, 0.07326450f, 0.03870908f, 0.00891041f, 0.03208068f, 0.01397164f, -0.13310926f, 
    -0.10428018f, 0.25835475f, 0.00419685f, 0.09275584f, -0.00621980f, -0.06913913f, -0.10998736f, -0.15749846f, 
    0.13347602f, 0.05933223f, -0.08940004f, 0.33027196f, -0.13181356f, -0.40152687f, -0.35447401f, -0.30389932f, 
    -0.05399569f, -0.01678009f, 0.06115504f, 0.06550280f, -0.05273260f, -0.10438136f, -0.13067955f, 0.04110859f, 
    -0.06941000f, -0.11516755f, -0.06512415f, 0.08303005f, -0.01898841f, -0.02404664f, -0.02662845f, -0.01791154f, 
    -0.00361926f, 0.05129001f, 0.18020527f, 0.32595554f, 0.05949381f, 0.03602692f, 0.07685748f, -0.02011266f, 
    -0.11097679f, -0.34703183f, 0.05591658f, 0.01332653f, 0.02608712f, 0.04138338f, 0.13258293f, -0.04104545f, 
    -0.08710067f, 0.03127274f, -0.11674770f, -0.05707975f, 0.12069917f, 0.16118576f, -0.06699803f, 0.30521801f, 
    0.35477129f, 0.08905660f, 0.02261839f, 0.07580236f, 0.03167167f, 0.14579090f, 0.06499461f, 0.05379292f, 
    0.07878966f, -0.08624290f, -0.02250005f, -0.00006566f, 0.01199312f, 0.13798992f, -0.04026524f, 0.11963198f, 
    -0.31378058f, -0.24069317f, -0.22704393f, -0.30490375f, -0.05475323f, -0.03717778f, 0.02769350f, -0.04064466f, 
    -0.06369261f, -0.16854647f, 0.01392660f, 0.15596716f, -0.16396229f, -0.03449872f, -0.01482046f, -0.05247093f, 
    0.01068068f, -0.03300259f, -0.12754278f, -0.13385661f, -0.31874147f, -0.24723849f, -0.20291908f, -0.21813166f, 
    -0.27613509f, 0.09631512f, 0.07992543f, 0.04314740f, -0.04068349f, -0.23557834f, 0.19984919f, -0.06147033f, 
    0.10193709f, 0.04241887f, 0.00519223f, -0.01830959f, -0.12422945f, -0.14099720f, -0.00831574f, -0.07833969f, 
    -0.58474106f, -0.70986271f, -0.69918221f, -0.54276830f, -0.27324015f, 0.14193311f, -0.03372233f, 0.18699591f, 
    -0.04062746f, 0.01759537f, 0.05234453f, 0.10992363f, -0.04408148f, 0.01441952f, 0.01954350f, 0.01045264f, 
    0.15937221f, 0.08125151f, -0.04485061f, 0.07022414f, -0.07383538f, -0.59631383f, 0.07539487f, -0.27374616f, 
    0.16374950f, 0.10922346f, -0.00439662f, -0.19209130f, -0.13552530f, 0.02472846f, -0.13617569f, -0.04122609f, 
    0.19379976f, -0.07114042f, 0.19859122f, 0.23770015f, 0.01419327f, -0.26310956f, -0.13007645f, 0.18766648f, 
    0.10644819f, 0.16835259f, 0.14253618f, 0.35896742f, 0.15319853f, 0.01501024f, 0.19133686f, 0.01472222f, 
    0.03304065f, 0.24263485f, 0.03625821f, -0.06197724f, 0.01136663f, 0.10686732f, 0.03146077f, -0.05729672f, 
    0.00463616f, -0.04590102f, -0.10070327f, 0.08467063f, 0.00313631f, 0.31567526f, 0.40916449f, 0.23929758f, 
    0.15704884f, 0.06140505f, 0.19032477f, 0.18754067f, 0.13412884f, -0.15488248f, 0.06150189f, -0.09839929f, 
    0.04910587f, -0.03913265f, 0.05706153f, -0.20904829f, 0.09462155f, 0.14460288f, 0.03229191f, -0.29036793f, 
    -0.34960589f, -0.38023674f, -0.05780615f, -0.33882856f, -0.11650342f, -0.01978968f, -0.00173204f, 0.03366561f, 
    0.00190523f, 0.09524395f, 0.04442212f, -0.06726920f, 0.13541532f, -0.10500312f, -0.16532099f, -0.11699442f, 
    0.03158521f, -0.04496667f, -0.07296563f, -0.06107064f, 0.13196857f, 0.49504709f, 0.08654314f, 0.04422894f, 
    0.13569434f, 0.12807366f, 0.00074460f, 0.20212384f, 0.13575095f, 0.16922678f, -0.18491505f, 0.10256688f, 
    -0.08489808f, 0.08689111f, -0.09060606f, -0.21240528f, -0.14464147f, 0.00424145f, -0.18866763f, -0.28553489f, 
    0.35319009f, 0.31636620f, 0.35283989f, 0.16051994f, 0.27876458f, 0.00737295f, 0.06733741f, 0.07773189f, 
    0.10621053f, 0.03736178f, 0.08341735f, 0.04681282f, 0.05859549f, 0.02390075f, 0.03676545f, 0.04423432f, 
    0.08666647f, 0.21385963f, -0.00257378f, 0.08642982f, -0.40988579f, -0.48457682f, -0.63583076f, -0.20935312f, 
    -0.08647788f, 0.02779355f, 0.25689083f, 0.12334248f, 0.09906165f, 0.01311796f, 0.14730579f, -0.00916522f, 
    0.08673409f, 0.00949881f, 0.14433339f, 0.00167851f, 0.08790477f, -0.09020294f, 0.05087616f, -0.00907061f, 
    0.52075899f, 0.03998138f, 0.03623470f, 0.29908109f, -0.04498614f, 0.07744285f, -0.03590367f, -0.03209379f, 
    -0.00913406f, -0.07651486f, 0.04721413f, -0.12656741f, 0.00196344f, 0.14693542f, -0.00626965f, 0.04896661f, 
    0.05611123f, -0.11012442f, -0.03139867f, 0.06000560f, 0.51742601f, 0.33476201f, 0.07019522f, 0.23705760f, 
    0.35212627f, 0.10307270f, 0.10477815f, 0.13025695f, 0.00530216f, 0.13604920f, 0.10374535f, 0.09163831f, 
    0.05363791f, 0.10396482f, 0.12373442f, -0.01249664f, -0.05932700f, -0.00060760f, -0.14352918f, -0.10270891f, 
    -0.01215195f, 0.14573674f, 0.05553859f, -0.09374458f, 0.22197482f, -0.04504762f, 0.03406688f, 0.15546978f, 
    0.02487704f, 0.07296918f, 0.01065964f, 0.03643246f, 0.08202143f, -0.01330614f, 0.05951111f, 0.01756322f, 
    0.03036918f, -0.06992799f, -0.09100059f, -0.06909675f, 0.11636961f, 0.06945970f, 0.02146839f, 0.04102531f, 
    0.06990836f, 0.04379722f, -0.01396612f, -0.12698089f, -0.03863484f, -0.06263138f, 0.06069545f, -0.12733054f, 
    0.08514696f, -0.02444912f, -0.00626633f, -0.01996293f, -0.02263363f, -0.03538965f, -0.02124328f, -0.03650206f, 
    -0.53557938f, 0.14449939f, -0.16203757f, 0.12498116f, -0.42977345f, 0.16547918f, -0.09153070f, -0.14460546f, 
    -0.05872647f, 0.10083310f, 0.02011459f, -0.00657567f, -0.02756995f, 0.04362418f, -0.16229559f, -0.01481265f, 
    -0.02495337f, 0.04542501f, 0.12180268f, 0.04293912f, -0.16267858f, -0.21316828f, 0.33656207f, 0.33331400f, 
    -0.31495562f, 0.03169204f, 0.07153301f, 0.09854644f, 0.03044461f, 0.09137828f, 0.09151930f, 0.08900517f, 
    0.04679847f, -0.01286094f, 0.10172714f, -0.01428415f, -0.01050289f, -0.14925279f, -0.07587899f, -0.08698050f, 
    0.05731774f, -0.03026931f, 0.08713058f, 0.05582862f, 0.02884512f, 0.00643004f, -0.01011290f, -0.12431145f, 
    -0.02165356f, -0.00442803f, 0.11020691f, -0.00922485f, -0.05655155f, 0.05071144f, -0.00625095f, 0.04415948f, 
    0.05986339f, 0.01340918f, 0.02061969f, 0.06831405f, -0.09978653f, 0.01998791f, -0.12184128f, 0.20215014f, 
    -0.00479936f, 0.07380308f, -0.01452320f, -0.00009599f, -0.04163982f, 0.05365490f, -0.10065050f, 0.01660188f, 
    -0.00903213f, 0.00563199f, 0.06170109f, -0.04395971f, 0.04763468f, 0.03396701f, 0.00370901f, 0.04294117f, 
    0.51427716f, 0.17000955f, -0.19122359f, 0.39368644f, 0.18447599f, -0.01215928f, -0.03392627f, 0.09741747f, 
    -0.04357188f, -0.09089667f, 0.09983255f, -0.03248129f, -0.01516397f, 0.02420757f, -0.07219294f, -0.04590094f, 
    -0.04190934f, 0.10551894f, 0.03336456f, -0.03280465f, -0.28240919f, 0.82391632f, -0.00804000f, 0.25225279f, 
    -0.32513189f, 0.00580878f, -0.14862357f, -0.18768622f, -0.02707534f, 0.04730882f, 0.06105521f, -0.07473841f, 
    -0.15341222f, -0.00895282f, 0.07900519f, 0.03200455f, -0.04631606f, 0.02234059f, 0.12223239f, -0.13945231f, 
    0.06540626f, 0.34200302f, -0.02337499f, 0.25897032f, 0.13127550f, -0.11075644f, -0.12473464f, 0.06188661f, 
    -0.01991300f, 0.18830344f, -0.04260321f, 0.01151056f, -0.10261153f, -0.04811199f, 0.09378021f, 0.04735495f, 
    0.02401554f, -0.07604965f, -0.03678645f, -0.03510110f, -0.08292972f, 0.10321126f, -0.00319192f, -0.17304392f, 
    -0.09106650f, 0.08799345f, 0.02657568f, -0.06650999f, 0.19064905f, 0.17428751f, 0.04210074f, 0.11949754f, 
    0.05310130f, 0.15343462f, -0.05487306f, 0.07419573f, -0.08839709f, 0.19194296f, -0.12302235f, 0.24784820f, 
    -0.07061405f, -0.20570758f, -0.06341047f, 0.25351945f, 0.22948155f, 0.02863629f, -0.00581337f, -0.02818723f, 
    -0.03767931f, 0.02074691f, 0.09343393f, 0.00693234f, -0.04222139f, 0.13300610f, 0.01578522f, 0.02560777f, 
    -0.01241814f, -0.02130226f, -0.01583414f, -0.03843269f, -0.00813988f, -0.01766788f, 0.06692956f, -0.09727285f, 
    0.01827951f, -0.08963387f, 0.15593275f, 0.21686734f, 0.10486398f, -0.19227780f, -0.01540792f, -0.03538467f, 
    0.10430828f, 0.03752181f, 0.03832643f, 0.02055354f, -0.03775317f, -0.12043809f, -0.13699260f, -0.01013209f, 
    -0.11521524f, 0.02854072f, -0.03393907f, -0.19467618f, -0.11473401f, 0.02911200f, 0.08890599f, -0.02961952f, 
    0.03472165f, 0.05908978f, 0.07307355f, 0.03377241f, 0.05701169f, -0.03056715f, 0.07609041f, 0.08680034f, 
    -0.04634110f, -0.21504082f, 0.00628375f, 0.01357841f, 0.14831762f, 0.17004725f, -0.20411283f, 0.23674352f, 
    0.22424589f, 0.07560726f, 0.00462621f, -0.02332627f, 0.02512987f, -0.08992142f, 0.03839063f, 0.02870085f, 
    -0.02711972f, -0.05487907f, -0.03244026f, 0.12272113f, -0.01066297f, 0.20600756f, -0.00614863f, 0.01616429f, 
    0.20122722f, -0.13428356f, -0.41238061f, -0.15139417f, -0.17025302f, 0.03891417f, -0.06064697f, -0.10373555f, 
    -0.03973685f, -0.11556652f, -0.00933381f, 0.01169491f, 0.06730725f, 0.00595398f, 0.02924092f, -0.00621076f, 
    -0.08002935f, 0.10279125f, -0.02059523f, 0.15964106f, -0.28445792f, -0.10807101f, 0.04267705f, -0.09748131f, 
    -0.18044642f, 0.04481261f, 0.05015707f, -0.06645070f, 0.11301412f, 0.17289510f, 0.01849122f, 0.10889459f, 
    -0.03300065f, -0.02144577f, 0.03591510f, 0.04933084f, 0.07494963f, 0.10968350f, -0.00783668f, 0.04809961f, 
    0.00677095f, -0.07264198f, -0.12717417f, 0.34767440f, 0.05163909f, -0.05660755f, 0.07980377f, 0.06148754f, 
    0.00182165f, -0.25927237f, 0.03531997f, -0.04134353f, 0.06872302f, 0.10337885f, 0.14076202f, 0.14715314f, 
    -0.09539613f, 0.25275311f, 0.09415311f, -0.07768591f, -0.17407188f, -0.03879102f, -0.00175595f, 0.06127867f, 
    -0.13046984f, -0.03535912f, 0.03529552f, 0.06750169f, 0.05435733f, 0.09204635f, -0.06477315f, -0.01048886f, 
    -0.01946799f, -0.00918322f, -0.07910954f, 0.02267470f, 0.06532051f, 0.01520981f, -0.03281216f, 0.03471752f, 
    0.55662721f, -0.02615741f, 0.19109432f, -0.19942994f, 0.46601743f, -0.09510467f, 0.17729385f, 0.08644903f, 
    0.20354357f, 0.22741862f, -0.04901337f, 0.07970702f, -0.02802755f, -0.01062310f, 0.12416548f, 0.16343234f, 
    0.15621482f, -0.03491956f, 0.05402066f, 0.02538258f, 0.12333862f, 0.22156727f, -0.01138822f, -0.28239289f, 
    0.04446473f, -0.15239821f, 0.10588135f, 0.13468575f, -0.21074007f, -0.07567458f, -0.05251881f, -0.10813478f, 
    -0.00684325f, 0.12040710f, 0.05005875f, 0.12780440f, -0.03481519f, 0.05507236f, 0.17268907f, 0.14751334f, 
    -0.09400098f, -0.04058368f, 0.09055497f, 0.06828299f, -0.03234696f, 0.04770382f, 0.05457047f, 0.03775154f, 
    0.04313258f, 0.04590208f, -0.03943010f, -0.03586960f, 0.03880940f, 0.08715897f, 0.04216018f, 0.05530699f, 
    0.05594165f, -0.09545130f, -0.04716028f, -0.06218072f, 0.07063872f, -0.00650798f, -0.06554790f, -0.06506877f, 
    0.02024204f, -0.14194317f, -0.02710070f, 0.04272221f, 0.07152244f, 0.05405147f, -0.19871889f, -0.00677048f, 
    -0.05019441f, 0.05840470f, -0.06304544f, 0.07561776f, 0.06401612f, -0.06571257f, -0.03471729f, 0.01476749f, 
    -0.21077316f, -0.17849608f, 0.17098908f, 0.04564661f, -0.02978018f, -0.00601379f, 0.05800556f, 0.00697631f, 
    0.07949708f, -0.01859685f, -0.07998636f, -0.05014413f, -0.03218494f, -0.06427914f, 0.01675661f, -0.04262088f, 
    0.04382037f, 0.15628821f, -0.08417207f, 0.08608096f, -0.10751409f, -0.25600982f, 0.23374768f, 0.10473759f, 
    0.12330119f, -0.10705125f, 0.14140037f, 0.33607653f, -0.02497416f, 0.05019127f, -0.00556120f, -0.00963250f, 
    0.06910694f, 0.10485143f, -0.06436206f, -0.08029927f, 0.06739210f, 0.14574021f, -0.03127094f, 0.06593800f, 
    0.18549386f, -0.22482470f, -0.16418473f, -0.20734197f, 0.21476094f, 0.13813142f, 0.06112713f, 0.22117296f, 
    -0.05877100f, -0.19256061f, -0.00731867f, 0.04570594f, 0.00479799f, -0.05015082f, -0.04588643f, 0.01856864f, 
    0.04841169f, 0.13300639f, 0.13143128f, 0.19829352f, -0.00413716f, 0.16053383f, -0.28017443f, 0.09846096f, 
    0.08186607f, -0.06164939f, -0.07183205f, -0.28212652f, 0.03695956f, -0.11736200f, 0.00737813f, 0.03141270f, 
    -0.01944980f, 0.13832429f, 0.08075072f, 0.04068335f, -0.05948504f, -0.03167625f, 0.12744598f, 0.08525279f, 
    -0.23252708f, 0.24127112f, 0.17793000f, -0.01697511f, -0.19971167f, -0.03290084f, -0.04784919f, 0.04858616f, 
    0.05508739f, -0.01891455f, -0.00924284f, -0.15738419f, -0.16631190f, 0.04997047f, 0.05610023f, 0.07833461f, 
    -0.01418585f, 0.20313679f, 0.24759883f, 0.05688159f, 0.12118360f, -0.02424005f, -0.03587197f, 0.09555279f, 
    0.07296921f, -0.11058050f, 0.01500833f, -0.07237599f, -0.12531918f, -0.18775380f, 0.17955755f, 0.00535418f, 
    -0.06821121f, 0.04200637f, 0.04503287f, 0.06507423f, 0.03276695f, 0.01065350f, 0.16789851f, 0.01241684f, 
    -0.24878974f, -0.17355347f, -0.48760819f, 0.08327755f, 0.04646092f, -0.03665546f, 0.03190503f, 0.00824973f, 
    -0.23148321f, -0.00649787f, -0.06866448f, -0.02800023f, 0.00495553f, 0.13573909f, -0.05511650f, 0.05360302f, 
    0.04208074f, 0.09999298f, 0.16240808f, -0.01914038f, 0.02694480f, -0.13299622f, -0.03044617f, -0.13984735f, 
    -0.06744452f, -0.01150477f, 0.00384392f, 0.16741110f, 0.03498981f, 0.09593460f, -0.09862878f, 0.00008268f, 
    -0.06927427f, -0.00909037f, -0.03754543f, -0.00433785f, -0.05268891f, -0.05184275f, -0.11466103f, 0.08323973f, 
    -0.65846610f, 0.23606379f, -0.13454665f, 0.04102128f, 0.21877651f, 0.05795409f, 0.02719706f, 0.07068484f, 
    0.01708756f, -0.05132389f, 0.00111161f, 0.14841107f, 0.07890431f, 0.05756798f, 0.18408304f, -0.05540713f, 
    0.01808280f, 0.14940679f, 0.00763538f, -0.10689709f, -0.27613896f, 0.14885233f, 0.23043875f, 0.09374398f, 
    0.07387578f, -0.03786894f, -0.13434534f, -0.12227036f, -0.20823759f, -0.06917065f, -0.18953565f, 0.04154507f, 
    -0.05988943f, -0.04047992f, -0.05666409f, -0.00022184f, 0.00078052f, -0.00416206f, -0.01223455f, 0.00555077f, 
    0.22912158f, -0.15595357f, -0.12296339f, -0.15195037f, -0.00893368f, 0.02820893f, -0.00294800f, 0.11674504f, 
    0.19665059f, 0.13508841f, -0.01020829f, -0.07364716f, 0.08799758f, 0.06960134f, -0.00429766f, -0.00150681f, 
    0.24341139f, 0.04208406f, 0.16999771f, 0.06372264f, -0.11970044f, -0.17506935f, -0.15396607f, -0.15293384f, 
    0.26504657f, 0.00106227f, 0.03032169f, -0.16832471f, -0.16632584f, -0.13878250f, 0.00761570f, 0.10013714f, 
    0.10151491f, 0.06652550f, 0.15807983f, 0.10393085f, 0.01819788f, 0.09742585f, 0.07688051f, -0.20977317f, 
    -0.03248239f, 0.53168410f, -0.37348565f, 0.39187434f, -0.13076849f, 0.10768845f, -0.22197105f, 0.02266172f, 
    -0.22145888f, -0.10408780f, 0.05036731f, -0.01887896f, 0.06320547f, 0.08848246f, 0.06243315f, 0.01988002f, 
    -0.03702173f, 0.18229555f, 0.04679462f, 0.15213324f, 0.01718263f, 0.21267867f, -0.04053453f, -0.04448681f, 
    -0.07626723f, -0.04914850f, 0.16271791f, -0.02250655f, 0.14362764f, 0.18720174f, -0.02948910f, 0.00089406f, 
    -0.05990017f, -0.08235188f, -0.02250892f, 0.12233619f, -0.04807022f, 0.12410726f, 0.08668127f, 0.18032701f, 
    0.12258524f, 0.08644578f, -0.05747428f, -0.17767797f, 0.18602949f, 0.01339495f, -0.00324878f, -0.09338254f, 
    -0.06058418f, -0.15412097f, 0.04932256f, 0.01849510f, 0.15258625f, 0.05271767f, 0.01229290f, 0.06772528f, 
    0.00223422f, 0.08742163f, -0.02887470f, -0.13157287f, -0.50623983f, -0.09645086f, -0.43986541f, 0.27323651f, 
    -0.01386072f, -0.05880079f, -0.09309326f, 0.02851402f, -0.27734420f, 0.01598479f, 0.02943208f, 0.15795647f, 
    -0.08499481f, -0.00446356f, -0.05811835f, 0.00852664f, 0.08781795f, -0.01654350f, -0.02021058f, -0.13893460f, 
    -0.23160578f, -0.00436878f, 0.07339667f, -0.10560538f, 0.24814281f, 0.02304807f, -0.04706389f, 0.03679404f, 
    -0.06050181f, -0.09245917f, 0.15744071f, -0.14651886f, -0.16597410f, 0.04575320f, -0.03235321f, 0.16132358f, 
    0.05527917f, 0.10695951f, 0.08323848f, -0.12396447f, 0.12546399f, 0.21603036f, 0.22470048f, 0.38603544f, 
    0.08724478f, 0.04706537f, 0.00226293f, -0.09847485f, -0.17970179f, -0.13584182f, -0.00913433f, -0.06040889f, 
    0.13762099f, 0.03112147f, 0.08967419f, 0.00743871f, -0.01209267f, -0.31300089f, 0.07551263f, -0.04625414f, 
    -0.03970343f, 0.09595322f, -0.06723100f, -0.11389478f, 0.03081954f, 0.08994968f, 0.20810908f, 0.06278928f, 
    0.16789126f, 0.16192415f, 0.03965057f, -0.06697983f, -0.13531981f, -0.01880920f, -0.07767060f, 0.01945717f, 
    -0.06382074f, -0.00892507f, -0.03558205f, -0.00557746f, 0.00467878f, 0.27525529f, -0.19972235f, -0.09927704f, 
    -0.22261845f, -0.04286254f, -0.16973028f, -0.14110641f, -0.07713385f, 0.09621178f, 0.03884992f, 0.15516037f, 
    -0.00762741f, -0.08868954f, 0.02861474f, -0.07366797f, 0.11942843f, 0.02074443f, 0.14957364f, 0.15803483f, 
    -0.01771599f, 0.28193951f, 0.09364306f, -0.15062369f, 0.12427932f, 0.00317483f, -0.04963034f, -0.07771780f, 
    0.00474039f, 0.05176810f, 0.02316124f, 0.00132948f, 0.13117419f, -0.02981906f, 0.02672705f, 0.09461896f, 
    0.02410915f, 0.04164349f, 0.14030612f, 0.10304142f, 0.12092708f, -0.05531429f, -0.04170467f, -0.12656005f, 
    0.10584462f, 0.09460010f, 0.17252006f, 0.02722459f, 0.01323259f, 0.03024509f, 0.21208480f, -0.02977464f, 
    -0.10199206f, -0.13736784f, -0.08239326f, 0.03335855f, -0.25978103f, -0.05722804f, -0.12658262f, -0.13585463f, 
    -0.19653620f, -0.07981522f, 0.18162628f, -0.01347061f, -0.00728547f, -0.01583808f, 0.04485270f, -0.08694644f, 
    0.08221788f, 0.05207255f, 0.01551692f, 0.02828383f, 0.07266565f, 0.07711670f, 0.06513153f, -0.00527834f, 
    0.07694770f, 0.09491992f, 0.12241320f, 0.17771925f, -0.34471244f, -0.17920449f, -0.27304173f, -0.04648710f, 
    0.29195929f, -0.00505641f, 0.05777506f, 0.11575349f, 0.18395962f, 0.16095999f, -0.01148906f, -0.04398567f, 
    -0.19690241f, 0.03311136f, -0.14204742f, 0.21570998f, 0.01773357f, -0.00774175f, 0.07227256f, -0.07179810f, 
    0.36786333f, 0.50996274f, 0.32263163f, -0.11794562f, -0.09911289f, 0.16788225f, -0.29685217f, 0.10486278f, 
    0.05291118f, -0.02736061f, -0.06645335f, 0.07923600f, 0.03889382f, 0.02282016f, 0.10419562f, 0.05073494f, 
    -0.04314037f, 0.09494224f, 0.11355549f, 0.12684105f, -0.15026884f, -0.22636707f, 0.24170922f, -0.29130998f, 
    0.11279999f, 0.27393767f, -0.08079610f, -0.20379087f, 0.09113719f, -0.08921511f, 0.01478121f, 0.03890869f, 
    0.05598328f, 0.09985121f, -0.03282553f, -0.02944781f, -0.13823903f, -0.14897968f, 0.01671960f, 0.09203966f, 
    0.10583935f, -0.14310706f, -0.05360915f, 0.19506298f, 0.11585058f, -0.01057804f, 0.08980810f, 0.09684597f, 
    0.07144736f, -0.04333362f, 0.06909519f, -0.01849415f, -0.01277974f, 0.01707964f, 0.06425664f, 0.03162312f, 
    -0.07750234f, 0.12870534f, 0.10435767f, -0.12293621f, -0.13869250f, 0.07296073f, 0.16170481f, 0.13733681f, 
    -0.23095083f, -0.17315514f, -0.02797690f, -0.06583349f, -0.12503059f, -0.06705749f, -0.07662240f, 0.04019468f, 
    -0.03835952f, 0.00158104f, -0.10530272f, -0.16021325f, 0.02941404f, -0.00437090f, -0.02322880f, 0.02908828f, 
    0.43044242f, -0.04643633f, 0.05980150f, -0.35494569f, 0.14156380f, 0.24579661f, 0.11272556f, 0.12640789f, 
    0.20194171f, 0.13249548f, -0.11100223f, 0.00293861f, 0.05515002f, 0.07799011f, -0.04208159f, 0.15738952f, 
    0.15300646f, 0.09427147f, 0.16902727f, 0.00486854f, -0.04772533f, 0.13666351f, -0.21988213f, -0.17753883f, 
    0.17963074f, 0.03428542f, -0.11931860f, 0.00214542f, -0.04530673f, -0.14529738f, -0.00008948f, -0.05483439f, 
    -0.03192782f, -0.04479346f, 0.01419747f, -0.03301504f, -0.13626158f, 0.01016829f, -0.05918119f, -0.09733691f, 
    -0.11378708f, -0.02060875f, 0.13234086f, 0.01605296f, -0.19954875f, -0.07861634f, -0.05509222f, -0.00389834f, 
    -0.06813412f, -0.04398232f, 0.06882593f, 0.06082807f, 0.00977631f, 0.09909136f, -0.02453295f, 0.06092525f, 
    0.06439318f, -0.02194773f, -0.00816174f, -0.07994659f, 0.38923541f, 0.09205692f, 0.32997695f, -0.24923210f, 
    -0.10379361f, 0.02408314f, -0.07542880f, 0.02322218f, 0.05582307f, -0.09973211f, -0.12847938f, 0.03680792f, 
    0.00043665f, 0.02727743f, 0.06916214f, 0.03543099f, 0.03462036f, 0.06058396f, 0.06810833f, -0.03340007f, 
    -0.11112420f, 0.01870594f, 0.62944198f, 0.18089725f, -0.15354471f, -0.10858266f, -0.02196492f, -0.16134411f, 
    -0.00566076f, -0.10472776f, -0.13151993f, -0.02320968f, 0.04898645f, 0.05989215f, 0.02220461f, -0.14532830f, 
    0.04404711f, 0.00039451f, 0.02207119f, -0.03549144f, 0.35353467f, 0.13558328f, 0.01465248f, -0.08627309f, 
    0.32137570f, -0.06264447f, 0.32095122f, 0.22391309f, -0.00451842f, 0.05968900f, -0.00029107f, 0.12243856f, 
    0.19536285f, 0.09805398f, 0.17577614f, -0.18237722f, -0.18563779f, 0.05912944f, 0.08759046f, 0.00169985f, 
    0.13890886f, -0.22167687f, 0.07798008f, -0.08485276f, 0.08835510f, 0.10861202f, -0.04365210f, 0.03575516f, 
    0.08854800f, -0.10651346f, -0.04395765f, 0.06102202f, 0.09666985f, 0.02920615f, 0.07495078f, 0.04211683f, 
    -0.01815769f, 0.21552871f, 0.03408813f, 0.12426501f, -0.04942072f, 0.06676740f, -0.16229239f, 0.19613504f, 
    0.08838182f, 0.16695453f, 0.01630618f, 0.11820417f, 0.11072408f, 0.12056459f, -0.02266229f, 0.00611660f, 
    -0.10103854f, -0.12259047f, 0.04637367f, 0.21598819f, -0.15556239f, 0.06473505f, 0.02447107f, 0.23707758f, 
    0.04290266f, 0.55994344f, 0.22274795f, 0.34050789f, -0.00129634f, 0.00669895f, 0.01464841f, 0.03329608f, 
    0.00320936f, -0.02607757f, 0.03205619f, -0.01434384f, 0.01682292f, 0.16667587f, 0.14175017f, 0.10635965f, 
    0.05119794f, 0.09977283f, 0.00414209f, -0.04461001f, -0.03192794f, -0.26636082f, -0.05294704f, 0.16071703f, 
    -0.14547676f, 0.01242845f, 0.02817280f, -0.06427222f, -0.09282359f, -0.08750406f, -0.09871085f, -0.00346213f, 
    0.04659533f, -0.11376592f, 0.07641606f, -0.14907007f, 0.27944195f, 0.03857635f, 0.19888175f, 0.28867260f, 
    -0.02976795f, 0.11967127f, -0.39366096f, -0.05584516f, 0.10475897f, 0.07412911f, -0.05256625f, 0.19649161f, 
    0.01195895f, 0.05229662f, -0.13267742f, 0.01198243f, -0.00069109f, -0.02206841f, -0.02021800f, 0.00191577f, 
    -0.02019450f, 0.15605219f, 0.06514304f, -0.12103901f, 0.07392900f, 0.06456985f, 0.34514198f, -0.06818780f, 
    -0.21729437f, -0.09258065f, -0.19610183f, -0.17717855f, -0.01515327f, -0.10978841f, -0.24197915f, -0.01896084f, 
    -0.03277938f, -0.01635723f, -0.06063497f, -0.08811098f, -0.08109379f, 0.08198991f, 0.02511551f, -0.00046415f, 
    -0.05160109f, 0.20805922f, -0.16644521f, 0.29421768f, 0.08724592f, -0.05390618f, 0.05908639f, 0.08283030f, 
    0.06538669f, 0.03440963f, -0.10034025f, 0.06622803f, 0.16369756f, 0.11285554f, 0.11242244f, 0.06181148f, 
    -0.18051142f, -0.07433281f, -0.03865772f, -0.05920586f, -0.40321124f, -0.23822144f, -0.23490144f, -0.17119583f, 
    -0.15723996f, -0.09974705f, 0.09050899f, -0.01839419f, 0.07218372f, 0.10588396f, -0.06465852f, -0.00783785f, 
    -0.10246322f, -0.10997950f, -0.14792140f, -0.03781623f, 0.04421045f, -0.10792959f, 0.15830010f, 0.11727972f, 
    -0.00378481f, 0.09712355f, 0.36793384f, 0.08670277f, -0.11550694f, 0.13552389f, 0.14548619f, 0.03482509f, 
    0.06231762f, -0.00607216f, 0.10613173f, 0.02684254f, -0.03323352f, 0.05421745f, 0.10214642f, 0.04112203f, 
    0.05355348f, 0.07651869f, 0.01780212f, 0.13621487f, 0.09483232f, 0.03090450f, 0.08098030f, -0.00599015f, 
    -0.00474425f, -0.04226085f, -0.12861806f, 0.01301849f, -0.02275616f, -0.07256612f, 0.02551627f, -0.12449747f, 
    -0.04452413f, -0.02212776f, -0.02069808f, -0.10972264f, -0.03640630f, -0.03288386f, 0.12393691f, 0.09278876f, 
    -0.55460793f, -0.03517362f, 0.26169598f, 0.11056019f, 0.04424975f, -0.05749770f, 0.04118995f, 0.23804761f, 
    0.04246925f, 0.14135410f, 0.00962808f, 0.15380010f, -0.04649803f, -0.04080641f, -0.10609476f, 0.03612471f, 
    0.11024047f, -0.01654043f, 0.14495237f, -0.07738025f, -0.16032843f, -0.22139387f, -0.10636981f, 0.00552789f, 
    -0.00310236f, 0.10435619f, -0.06494457f, -0.09653177f, 0.12509897f, -0.12838298f, 0.02889796f, 0.07975119f, 
    0.12116969f, 0.02255388f, 0.03210564f, -0.04798554f, 0.10056967f, -0.13081068f, 0.04191293f, -0.04149115f, 
    0.01729519f, 0.03033171f, 0.01548453f, 0.02633781f, 0.08207741f, -0.02355568f, -0.06651466f, -0.02231688f, 
    0.03943970f, 0.06345280f, 0.03610971f, 0.04887404f, 0.07569671f, 0.20273577f, 0.06728826f, -0.04742125f, 
    -0.06373435f, 0.03474307f, 0.07928640f, 0.15288877f, 0.04902919f, -0.17975186f, 0.00548228f, -0.10343171f, 
    0.11553726f, -0.08524327f, -0.15157400f, 0.07145510f, 0.02205933f, -0.04245516f, -0.01105907f, -0.03498819f, 
    -0.03568589f, 0.03070732f, -0.02040346f, 0.13662313f, 0.01713458f, 0.07322284f, 0.17522314f, 0.00501051f, 
    0.18874606f, 0.02557731f, -0.26719281f, -0.25113761f, -0.18061803f, -0.02140316f, -0.05839372f, -0.04835050f, 
    -0.06568434f, -0.07948868f, -0.17490640f, -0.07880170f, -0.07469307f, -0.03507636f, -0.02402659f, 0.00442702f, 
    0.03095224f, -0.12707643f, 0.10077163f, 0.09779144f, -0.22735277f, -0.31385326f, 0.17291939f, 0.04106911f, 
    0.24113142f, -0.05336825f, -0.12895985f, 0.02010754f, 0.05063492f, -0.00811180f, 0.05010110f, 0.17319934f, 
    -0.12564079f, 0.08466998f, 0.25251791f, 0.20869133f, 0.17691158f, -0.04918187f, -0.07970362f, 0.02011254f, 
    -0.31990945f, -0.20270543f, -0.17227510f, -0.04324124f, -0.23755184f, 0.18327029f, -0.08908066f, 0.08926636f, 
    -0.02133747f, -0.09502506f, 0.04884688f, -0.04171885f, 0.00868973f, 0.02414896f, 0.07955644f, 0.13663638f, 
    0.14920710f, 0.17547697f, 0.11836331f, 0.02403534f, 0.09977935f, -0.30231437f, 0.35976028f, -0.01519765f, 
    0.14697182f, -0.00821276f, 0.20967960f, 0.25291905f, 0.11617251f, -0.11597629f, 0.11219703f, -0.12231465f, 
    -0.00652841f, -0.03693997f, 0.02583193f, 0.09982082f, 0.17436044f, -0.00951977f, -0.06863370f, -0.06296133f, 
    0.35754448f, -0.47940990f, 0.30407834f, -0.00956122f, 0.37209034f, 0.00404602f, 0.05341799f, -0.07414302f, 
    0.06454339f, -0.14989300f, -0.00457561f, 0.10241533f, 0.15448205f, 0.02485550f, -0.11270312f, 0.11606961f, 
    0.14199752f, 0.01366577f, -0.06107573f, 0.02217082f, -0.14845242f, -0.21338825f, -0.05522553f, 0.05415897f, 
    -0.13831100f, 0.12619738f, -0.14191885f, -0.08800790f, -0.05676768f, -0.22039099f, -0.06989832f, -0.06687159f, 
    0.14934590f, 0.12113578f, 0.02868491f, -0.03052993f, 0.25693244f, 0.07757358f, 0.06965426f, 0.14579849f, 
    0.11481986f, 0.07437982f, 0.07926449f, 0.21781132f, -0.09344267f, -0.00324515f, -0.01613822f, -0.02903004f, 
    0.11941624f, 0.08954917f, 0.06523975f, 0.06627756f, 0.00666278f, -0.19017230f, -0.02343471f, 0.00960581f, 
    0.12399889f, -0.09921136f, -0.15960149f, -0.09110127f, 0.04235621f, -0.23818760f, -0.18840073f, -0.27848405f, 
    -0.08941362f, -0.00729737f, -0.07584162f, 0.02946065f, -0.06418183f, -0.12057676f, -0.12364268f, -0.05932910f, 
    -0.08164264f, -0.06559421f, -0.01642898f, -0.07338312f, -0.13797721f, -0.06062625f, 0.14469996f, 0.00234096f, 
    0.46624485f, -0.16419141f, 0.49462643f, 0.00038191f, -0.02691670f, -0.14164639f, 0.00029302f, -0.01148990f, 
    -0.03027852f, 0.01257926f, 0.22344567f, 0.02844977f, -0.05006747f, 0.03926544f, 0.06232619f, 0.12505478f, 
    0.07347561f, -0.07531550f, 0.10740153f, 0.05748874f, 0.04435687f, -0.15480877f, 0.38700137f, -0.01472126f, 
    -0.14858127f, -0.25482672f, -0.01611573f, 0.00074636f, 0.17037889f, -0.07371707f, -0.02598972f, 0.01348193f, 
    -0.05775585f, 0.03045739f, -0.01591473f, -0.03069740f, 0.05964163f, -0.02111960f, -0.02217052f, -0.02026157f, 
    -0.04623758f, 0.25190952f, 0.02486663f, 0.06297100f, 0.12472936f, 0.02973114f, 0.02712872f, 0.06104401f, 
    -0.00944576f, -0.09111402f, -0.03894795f, 0.02899070f, 0.03873466f, 0.11209019f, -0.00573564f, 0.01800996f, 
    -0.07132185f, -0.12014779f, 0.07433321f, -0.06958916f, 0.06655397f, 0.04168288f, -0.08533790f, 0.03512925f, 
    0.05558366f, -0.01024758f, -0.07488821f, 0.00702849f, 0.01741893f, -0.02200794f, 0.12272702f, 0.02436179f, 
    0.00319647f, 0.10079201f, 0.05075593f, 0.03205856f, 0.06450006f, -0.02102238f, -0.04908573f, -0.06190263f, 
    -0.51740712f, -0.09396426f, -0.08193403f, 0.03337371f, 0.12390818f, 0.15160765f, 0.06534951f, 0.10443383f, 
    0.15734015f, 0.11739682f, 0.10665420f, 0.01006041f, -0.08265769f, -0.03023723f, 0.00243700f, -0.07329025f, 
    -0.01493811f, 0.00657573f, -0.00027098f, 0.03909452f, -0.10845653f, -0.30625576f, 0.36708248f, 0.12762265f, 
    -0.11956280f, -0.00619235f, 0.08346698f, -0.03066128f, -0.01470919f, -0.15324847f, -0.02032442f, -0.07197736f, 
    -0.00350651f, -0.02077596f, 0.03277996f, -0.12213535f, 0.12235045f, 0.16036205f, -0.17183219f, -0.02430870f, 
    -0.04798895f, -0.01209621f, -0.06580257f, 0.06595390f, -0.04958189f, 0.01669328f, -0.00562452f, 0.03691600f, 
    -0.00179019f, 0.08668140f, 0.10721571f, 0.15439358f, 0.09783895f, 0.07852146f, 0.15916584f, 0.03543355f, 
    -0.05056449f, 0.01657047f, -0.08859656f, 0.00939893f, 0.05630576f, -0.07408699f, 0.01433790f, -0.03582064f, 
    0.09971665f, 0.04948165f, -0.00740008f, 0.01061843f, -0.02933972f, 0.07653563f, 0.01881614f, -0.02384549f, 
    0.02583662f, -0.00043151f, -0.04256369f, 0.04750814f, -0.07188293f, -0.00345450f, -0.01968961f, -0.04897807f, 
    0.41169459f, -0.01000597f, -0.03795884f, 0.14335802f, 0.15853554f, -0.05084265f, 0.03230821f, -0.00752534f, 
    -0.04041709f, -0.02690480f, 0.01327663f, -0.04685472f, -0.08546266f, -0.06441417f, -0.01140763f, 0.14411990f, 
    -0.01006285f, 0.06256475f, -0.00464561f, -0.03914089f, -0.35579133f, 0.16630219f, -0.25257632f, -0.15174639f, 
    -0.04176459f, 0.12258857f, -0.04949999f, -0.01484897f, 0.04502099f, 0.09957311f, 0.13278547f, 0.02011261f, 
    0.01326332f, 0.04743055f, 0.04617378f, 0.04494607f, -0.05209719f, 0.03849526f, 0.05037150f, -0.12750366f, 
    0.09206353f, 0.04278672f, 0.33381355f, 0.10466044f, 0.16464676f, 0.03777424f, 0.01309314f, -0.01512942f, 
    0.05232641f, -0.10284655f, -0.06350099f, -0.00975631f, -0.06215455f, -0.02842192f, 0.08075374f, -0.02582810f, 
    -0.01220742f, 0.04017847f, -0.00007218f, 0.03653598f, 0.05686977f, 0.01155744f, 0.10234915f, 0.02190585f, 
    0.26476094f, -0.08392975f, 0.10960934f, -0.03033786f, 0.10787421f, 0.07637967f, 0.00788136f, -0.11552557f, 
    0.02762466f, 0.05381649f, -0.05277708f, 0.02056634f, -0.04444255f, -0.07318646f, -0.09442671f, 0.08236451f, 
    0.12341799f, -0.09530171f, -0.11577792f, 0.19889313f, 0.22350375f, -0.03403965f, -0.02150468f, -0.00013988f, 
    -0.09095339f, -0.06280320f, 0.02928535f, 0.01637917f, 0.07395609f, 0.00887764f, 0.06908834f, 0.20726766f, 
    0.04945880f, 0.04266007f, -0.01976033f, -0.08401675f, 0.01132356f, 0.00067366f, 0.02281485f, -0.03798380f, 
    0.04922562f, 0.03662171f, -0.14047945f, -0.13005002f, 0.02798653f, -0.10811019f, -0.01223564f, -0.03249133f, 
    -0.00948143f, 0.04142378f, -0.00650325f, -0.02593905f, -0.03006854f, -0.04205128f, -0.10548152f, 0.08289544f, 
    -0.23856200f, 0.05322476f, 0.17337134f, 0.00709363f, 0.01198575f, 0.11976706f, 0.03198989f, 0.05704276f, 
    -0.02112044f, -0.08838344f, 0.02673795f, -0.04234264f, 0.03899119f, -0.00792554f, -0.04464547f, -0.05565779f, 
    -0.01545347f, -0.11022078f, -0.14206001f, -0.00801207f, 0.09318826f, 0.01902700f, 0.05326838f, 0.05386917f, 
    0.12166899f, 0.11323483f, 0.02248387f, -0.01491978f, 0.02591023f, -0.02064894f, -0.02238328f, -0.09839414f, 
    -0.06228871f, -0.06709892f, -0.06204543f, 0.06876308f, 0.03008298f, 0.12776846f, 0.01746398f, -0.11879278f, 
    0.05774557f, -0.02105493f, -0.01185915f, -0.10019935f, -0.00181136f, -0.07168853f, 0.17281932f, -0.01578340f, 
    -0.03725181f, -0.02930667f, 0.12113161f, 0.05166013f, 0.15847343f, 0.01253795f, 0.06101955f, -0.03628056f, 
    -0.00774699f, -0.02147246f, -0.04666768f, -0.06527361f, -0.30771884f, 0.06750605f, 0.00098421f, 0.24450310f, 
    0.09378751f, 0.04734979f, 0.14309289f, 0.14052321f, 0.00613324f, 0.04936141f, 0.00992076f, 0.11677717f, 
    -0.16610694f, -0.01749229f, -0.09333681f, -0.04878210f, -0.01367727f, -0.03613894f, -0.03477567f, -0.12317638f, 
    -0.19861558f, -0.21548837f, -0.20668967f, 0.13608423f, 0.02238413f, 0.03641521f, 0.15492219f, -0.06967185f, 
    -0.00220849f, 0.09970970f, 0.04814287f, 0.02075291f, 0.00762814f, 0.00512156f, 0.07218762f, 0.02268264f, 
    0.20966057f, 0.24554539f, 0.20237473f, 0.37832385f, 0.25798747f, 0.07582470f, 0.05926466f, 0.01948080f, 
    -0.17265654f, 0.03944425f, -0.07591359f, 0.23522134f, 0.15711011f, 0.06925885f, -0.09475062f, -0.11340296f, 
    -0.07818422f, -0.11352716f, -0.13949671f, 0.07338408f, -0.03576985f, -0.18913227f, -0.30343354f, -0.09001342f, 
    0.22848627f, -0.21997194f, -0.02714138f, -0.14170162f, 0.23439565f, -0.11577125f, -0.13978785f, -0.09934817f, 
    0.07430959f, -0.15306829f, -0.16493554f, 0.05802985f, 0.03909665f, 0.24857929f, 0.16614647f, -0.09652027f, 
    -0.00357687f, -0.05623897f, 0.19405243f, 0.03994549f, -0.13389994f, -0.17265658f, -0.26948383f, 0.19862732f, 
    0.22327621f, 0.09747749f, 0.08457436f, 0.05742162f, -0.04176229f, 0.12267946f, -0.09085516f, 0.01935580f, 
    -0.04774463f, 0.08470038f, -0.09052704f, 0.05220034f, 0.12801452f, 0.17424722f, 0.10606230f, 0.21880294f, 
    0.05822777f, 0.18493284f, -0.05373931f, -0.10553793f, 0.09301952f, -0.17679565f, 0.06519309f, 0.09759223f, 
    -0.02082726f, -0.09772115f, -0.00883502f, 0.01066739f, -0.02659660f, 0.00626382f, 0.12488481f, -0.11042831f, 
    -0.03895162f, -0.26671487f, -0.18190233f, -0.12386395f, 0.24569663f, 0.12641107f, 0.04984808f, -0.15676464f, 
    0.13990773f, -0.01551933f, 0.10560632f, -0.01374661f, 0.06844734f, 0.01432837f, -0.10076717f, -0.12955384f, 
    0.01158459f, 0.02450741f, -0.09427782f, -0.00937439f, -0.08891878f, -0.22841735f, -0.21957029f, 0.12092583f, 
    0.26816988f, 0.13895184f, 0.21363924f, -0.13656417f, -0.04276831f, 0.08493002f, -0.12709376f, 0.04863147f, 
    0.02614856f, -0.08007306f, -0.21573439f, -0.07870839f, -0.06209279f, 0.02629768f, -0.00705959f, 0.00816986f, 
    0.10050513f, 0.14960097f, -0.09712558f, 0.10285177f, 0.31472382f, -0.29733804f, 0.08696382f, -0.12774277f, 
    -0.12377952f, 0.14406802f, -0.26033765f, -0.06688646f, -0.18935399f, 0.24860777f, 0.02738594f, 0.01598976f, 
    0.17744157f, 0.00737238f, -0.10440832f, 0.14626572f, 0.07105512f, -0.08230111f, 0.05278792f, 0.18540214f, 
    0.04325475f, -0.20310022f, 0.00937099f, 0.27242309f, 0.06918924f, -0.04358541f, 0.09382260f, 0.06437252f, 
    0.05230192f, 0.23455024f, 0.05245184f, -0.20977731f, -0.00247171f, 0.00423733f, -0.01487317f, -0.08131081f, 
    0.08926440f, -0.05020235f, 0.09374482f, 0.22615416f, -0.20033245f, -0.16578047f, -0.18105306f, 0.22407620f, 
    0.14975350f, -0.07977696f, 0.14367341f, 0.24928045f, 0.31397545f, -0.19038993f, -0.15200789f, 0.03640270f, 
    -0.12141697f, 0.03955030f, 0.04050345f, 0.03389695f, 0.03651549f, 0.07421459f, -0.02056133f, -0.03123152f, 
    -0.15607573f, 0.17762409f, 0.02982726f, 0.00882400f, 0.08633882f, 0.27488917f, 0.15042248f, 0.03237435f, 
    -0.04972745f, -0.06335831f, 0.03403392f, 0.03243128f, 0.02119901f, 0.09151652f, -0.12541670f, 0.09102587f, 
    0.18508302f, -0.05143889f, 0.00985059f, -0.06513544f, -0.17515115f, 0.17725170f, -0.05647479f, -0.00425608f, 
    0.04633596f, -0.20851390f, 0.05345076f, 0.23168562f, 0.09648038f, 0.09352282f, -0.03831390f, 0.02011015f, 
    -0.04518270f, 0.01089174f, -0.05298091f, -0.04875729f, -0.40944552f, -0.03701612f, -0.19421211f, -0.22658178f, 
    -0.07763354f, -0.20755760f, 0.13278566f, 0.27654374f, -0.16223495f, -0.03607109f, 0.05101943f, 0.02018597f, 
    0.15999620f, 0.15776891f, -0.01518137f, -0.05324132f, 0.01375570f, -0.08493516f, 0.00658039f, 0.16426532f, 
    0.21715827f, 0.26940596f, 0.15264121f, 0.07666031f, 0.46434894f, -0.05255269f, 0.33945999f, 0.00221363f, 
    -0.12180200f, -0.08046930f, 0.01461710f, -0.07383622f, -0.02664094f, -0.04302915f, -0.04359842f, -0.26207131f, 
    -0.02303681f, -0.12831455f, -0.01774377f, -0.04741433f, 0.06802742f, -0.18767746f, -0.10930698f, -0.00256641f, 
    0.05638579f, 0.07607687f, 0.35912690f, 0.08848399f, 0.04139985f, -0.05157769f, 0.02857991f, -0.02341099f, 
    -0.01683448f, -0.14936458f, 0.07860695f, 0.09467059f, 0.18385577f, 0.11340103f, 0.16587739f, 0.15251614f, 
    -0.00289057f, -0.16260387f, -0.13020012f, 0.00991953f, 0.14603721f, -0.03794146f, -0.04864299f, 0.26638335f, 
    0.15898621f, -0.22885022f, -0.25871786f, -0.00362996f, -0.11855004f, 0.08575265f, 0.01773598f, 0.10189373f, 
    0.23394576f, -0.04510935f, 0.02865782f, 0.00773284f, -0.15288821f, 0.03651462f, -0.15939522f, -0.31917316f, 
    0.00604253f, -0.01874740f, -0.04374612f, 0.00874997f, -0.04233877f, -0.04889265f, -0.01951168f, -0.04328971f, 
    0.04658356f, -0.01293400f, -0.01494745f, 0.00039428f, -0.06048908f, -0.04153559f, -0.04293963f, -0.02182223f, 
    0.04991857f, -0.05610289f, 0.04220162f, 0.01504072f, 0.04604437f, -0.02483023f, 0.00650906f, 0.04816190f, 
    0.02464992f, -0.05340708f, -0.01258717f, -0.05923194f, -0.03475676f, -0.05675582f, 0.04778707f, 0.05041225f, 
    0.04928204f, 0.02060357f, 0.00594424f, -0.02194009f, 0.04367120f, -0.00508644f, 0.00478192f, -0.03595420f, 
    0.00996439f, -0.03693087f, 0.04899877f, 0.00241816f, 0.01156857f, -0.04415571f, -0.04832620f, 0.01676195f, 
    -0.00270518f, 0.03700805f, -0.05893556f, -0.04399539f, -0.03150616f, -0.06107085f, -0.01309569f, 0.03087009f, 
    0.02904572f, -0.03636431f, 0.03446861f, -0.04824059f, -0.00425880f, -0.05859761f, 0.04849578f, 0.04362415f, 
    -0.03714617f, 0.04719328f, -0.04639135f, -0.03646915f, -0.04001488f, 0.03229095f, 0.03818154f, 0.03179884f, 
    -0.05475775f, -0.00441837f, -0.02426409f, -0.05603291f, 0.01366533f, -0.05144717f, 0.03004232f, -0.04889218f, 
    0.00002368f, -0.05794003f, -0.01230553f, 0.04034488f, -0.04383462f, -0.04677217f, 0.02969774f, 0.05050106f, 
    0.04497048f, -0.05242991f, -0.00969433f, -0.03494475f, 0.03373358f, 0.02553282f, -0.04726390f, -0.03272175f, 
    -0.01969707f, -0.05858437f, -0.04063229f, -0.05074294f, -0.01963894f, -0.02596741f, -0.02308371f, -0.00023574f, 
    -0.02182991f, -0.01541253f, 0.03774693f, 0.02152930f, -0.03147779f, 0.04124663f, -0.01453542f, -0.01855021f, 
    -0.03573437f, -0.05416658f, 0.02705107f, -0.00314294f, 0.03351356f, 0.02920767f, 0.00808569f, 0.04476739f, 
    -0.05027235f, 0.03402903f, -0.02797182f, 0.04099786f, -0.00454472f, -0.02768970f, 0.01047976f, -0.06062619f, 
    -0.05050839f, 0.04891036f, -0.05338732f, -0.01644752f, -0.04408994f, 0.01756183f, 0.00537884f, 0.02826440f, 
    -0.06033444f, -0.00447048f, -0.00359307f, 0.03130021f, 0.02824602f, 0.04911235f, -0.05816698f, -0.00595188f, 
    0.03444181f, 0.00521791f, 0.00689076f, -0.01635669f, 0.00434991f, 0.01374282f, -0.04335830f, -0.01687989f, 
    0.00069435f, 0.02986287f, 0.02232239f, 0.03276787f, 0.03850621f, -0.04586772f, 0.00798293f, -0.03929111f, 
    -0.03060132f, -0.00500824f, -0.04661354f, 0.04393775f, -0.02717019f, 0.00198124f, 0.03873928f, -0.01256553f, 
    -0.05686129f, 0.03328417f, -0.01680291f, 0.04255870f, 0.00810754f, 0.05257702f, -0.00203333f, 0.04027050f, 
    -0.05279172f, -0.04181359f, -0.04556376f, -0.02915518f, 0.02917526f, -0.04288438f, -0.05655223f, 0.02677515f, 
    -0.05025249f, 0.02242416f, -0.02130452f, -0.03652633f, -0.02322872f, -0.03675373f, -0.05915300f, 0.03219069f, 
    0.01840303f, 0.03632625f, 0.01768964f, -0.04568544f, -0.00286880f, 0.03143977f, 0.04896352f, 0.04500962f, 
    -0.04138304f, -0.01175179f, 0.03876717f, -0.00101235f, -0.00694616f, -0.05051972f, 0.02890808f, -0.00695905f, 
    0.02554313f, 0.02047610f, 0.03639117f, -0.05740169f, 0.01793383f, 0.00391709f, -0.00633962f, -0.00899728f, 
    0.01785291f, 0.04831794f, 0.02016305f, -0.05521661f, -0.03401760f, -0.01780876f, -0.05509880f, -0.03890515f, 
    -0.01194125f, -0.03614195f, 0.02184273f, -0.04811546f, 0.01704041f, 0.02914093f, -0.01577242f, -0.05560542f, 
    -0.02249493f, 0.04140171f, -0.03336069f, 0.00089331f, 0.02767605f, -0.00014180f, -0.01025767f, 0.00121271f, 
    -0.03741360f, -0.04708774f, 0.01417125f, 0.01663603f, -0.03076796f, -0.05191524f, -0.02291718f, -0.00011728f, 
    -0.02003038f, -0.06116660f, 0.03281826f, 0.01179122f, -0.00959034f, 0.00645906f, 0.00233480f, 0.00884776f, 
    -0.01092185f, 0.00095812f, -0.03803554f, -0.01467485f, -0.04136559f, -0.04993518f, -0.01853816f, -0.00737754f, 
    0.04871140f, 0.01843901f, -0.01811606f, -0.05361076f, 0.01355958f, -0.04191212f, 0.02561147f, 0.04379754f, 
    0.01882903f, -0.02956337f, -0.03693522f, -0.05480795f, 0.04478855f, -0.01002659f, -0.05587855f, 0.04038603f, 
    -0.04813169f, 0.02922483f, -0.03913096f, -0.05916993f, 0.04158523f, 0.02252113f, 0.00505662f, -0.02397918f, 
    0.02066821f, 0.01914521f, -0.03389010f, 0.02981337f, 0.00128797f, -0.00940582f, -0.01468885f, -0.04677239f, 
    0.02427457f, 0.00116018f, -0.05270118f, 0.02182351f, 0.01035748f, -0.05423673f, -0.05902087f, 0.04318053f, 
    -0.00697775f, -0.04116676f, 0.00694867f, 0.05197945f, 0.03979250f, -0.01518919f, -0.01279723f, 0.03144561f, 
    0.01493184f, -0.02282339f, -0.04938244f, -0.01181941f, -0.00818377f, 0.01835175f, -0.00042712f, -0.05203221f, 
    0.11019733f, -0.01877727f, 0.10326497f, -0.05215710f, 0.00022883f, 0.08492173f, -0.06057105f, 0.05386923f, 
    0.14682238f, 0.00488835f, 0.05550862f, -0.03421077f, 0.09867425f, 0.05378469f, -0.03785098f, 0.01749228f, 
    -0.05630736f, -0.14738454f, 0.06815008f, -0.16163313f, 0.10845214f, 0.08479086f, 0.04557298f, -0.06953275f, 
    -0.03204503f, -0.00276489f, -0.13241352f, -0.18364668f, -0.12320811f, -0.03172969f, 0.06431846f, -0.00748230f, 
    -0.00798559f, 0.08414028f, 0.03270775f, -0.09979855f, 0.01777671f, 0.03758093f, 0.11968978f, -0.10632297f, 
    0.12613788f, 0.14682743f, -0.35638016f, 0.11184669f, -0.09335721f, 0.10089789f, 0.03538700f, 0.25080058f, 
    -0.15080282f, -0.08936833f, -0.06270276f, -0.04852759f, -0.11454367f, 0.16921805f, -0.01193151f, -0.01977296f, 
    0.08225840f, 0.18544054f, -0.04745572f, 0.09775990f, -0.05182904f, 0.01452325f, 0.12040023f, -0.01931053f, 
    0.10594861f, 0.08883366f, 0.07796773f, -0.20741715f, 0.29474568f, -0.04583479f, -0.06852260f, 0.05420714f, 
    0.06912358f, 0.00708217f, 0.07997707f, -0.06954889f, 0.03643395f, 0.06546255f, -0.18050086f, -0.10521565f, 
    0.08322904f, -0.01015363f, -0.14435267f, -0.08178069f, -0.01818158f, -0.05960511f, -0.06222708f, -0.09902823f, 
    -0.08873443f, -0.08415762f, 0.03915833f, -0.00225229f, -0.01615448f, -0.05681670f, -0.04085819f, 0.01731792f, 
    0.05035468f, 0.12932003f, 0.01274434f, -0.05695681f, 0.02692970f, 0.03830782f, 0.02328251f, 0.05664328f, 
    -0.09660614f, 0.05249268f, -0.12509337f, -0.05384174f, -0.05755841f, 0.06439596f, 0.02293026f, 0.01430875f, 
    -0.07708788f, 0.02651567f, 0.07034317f, -0.01763744f, -0.03425692f, 0.20017368f, -0.02910304f, -0.08598424f, 
    0.06229383f, 0.13569218f, 0.33473539f, -0.08246440f, 0.02827215f, -0.13229227f, -0.16384527f, -0.12987268f, 
    -0.05251030f, -0.05974779f, 0.10187419f, 0.02850039f, -0.05654103f, 0.09661432f, 0.04190914f, 0.15445432f, 
    -0.11516710f, -0.09081753f, 0.03528664f, -0.10215302f, 0.47412041f, 0.22969624f, -0.13447496f, -0.38328752f, 
    -0.07409531f, 0.23416789f, 0.06298286f, 0.01861463f, -0.02078559f, -0.07499789f, -0.13058744f, 0.09519582f, 
    0.02343189f, 0.03643376f, 0.12944132f, 0.01637430f, -0.10028754f, -0.05783333f, 0.12334355f, -0.06939609f, 
    -0.19976744f, -0.25920770f, 0.23274817f, -0.10402663f, 0.00918137f, 0.07379743f, 0.10293098f, -0.10977473f, 
    0.20523091f, -0.11756632f, -0.05728484f, 0.01545652f, -0.02918186f, 0.02879064f, 0.02057569f, 0.08603325f, 
    -0.00481146f, -0.07256911f, -0.02799031f, -0.02794139f, 0.02731326f, 0.11199093f, 0.02775121f, -0.05035329f, 
    0.11399387f, 0.07102198f, 0.03759608f, 0.15483017f, -0.07206647f, 0.18588038f, 0.09761548f, 0.09636598f, 
    0.10134035f, -0.16861437f, 0.01813110f, 0.01794227f, 0.00370419f, -0.00462074f, -0.00503732f, 0.07673288f, 
    0.27611610f, 0.34548569f, -0.06679296f, 0.11565000f, 0.15483944f, -0.03105292f, 0.04187041f, -0.10381065f, 
    -0.00873198f, 0.03319007f, 0.05978405f, -0.05775929f, 0.11593356f, -0.07052003f, -0.02459135f, 0.13031468f, 
    0.03479441f, -0.02727091f, -0.05916991f, -0.09930890f, -0.16940500f, -0.16476807f, 0.06863575f, 0.02849900f, 
    -0.00670944f, 0.16938506f, 0.02167295f, -0.07544129f, 0.08909871f, -0.03790400f, -0.04409887f, -0.04542658f, 
    0.14332244f, -0.01737484f, -0.06368307f, -0.01429342f, 0.16969554f, 0.00817917f, 0.06206449f, 0.24846517f, 
    -0.11034111f, 0.22728439f, 0.24720693f, -0.17193037f, 0.21577868f, 0.13356580f, 0.01917041f, 0.01855923f, 
    0.31098780f, 0.02640843f, -0.03045280f, 0.03050606f, -0.02954035f, -0.00151045f, 0.06616890f, -0.15272714f, 
    -0.10970008f, -0.04318831f, -0.00989074f, -0.03422700f, -0.10945151f, 0.01787610f, 0.14913735f, -0.01390609f, 
    0.08134166f, -0.04216281f, -0.16350833f, -0.21077752f, 0.05529009f, -0.08043664f, 0.04942260f, -0.03560274f, 
    -0.02494230f, -0.02756231f, -0.05273514f, 0.01015269f, -0.13015179f, 0.04412032f, 0.05452681f, -0.12517348f, 
    0.35029864f, 0.13910924f, 0.12461504f, -0.15797010f, -0.06538247f, 0.07655814f, 0.03416157f, 0.09660519f, 
    -0.03418925f, 0.02099840f, 0.09023929f, -0.04930741f, 0.06719048f, -0.06951326f, 0.07538985f, 0.06453608f, 
    -0.02756591f, -0.11042006f, 0.04553735f, -0.06603110f, 0.09763377f, -0.38666505f, -0.21982658f, -0.35664767f, 
    0.06123472f, 0.03764214f, 0.12952456f, 0.19970326f, 0.27190354f, 0.01523473f, 0.03487869f, 0.05975147f, 
    0.02241069f, 0.00147781f, -0.03283907f, -0.01960182f, 0.06208756f, -0.03055122f, 0.12594977f, 0.04741167f, 
    0.11093543f, 0.10184898f, 0.34561908f, -0.09882742f, -0.15504935f, 0.17556185f, 0.03841167f, 0.05552329f, 
    0.05898561f, 0.20525217f, 0.09245258f, 0.00934112f, -0.00428121f, 0.00387082f, 0.00314643f, -0.12122379f, 
    0.14759587f, -0.09404227f, 0.01764941f, 0.19287580f, 0.17183536f, -0.03948611f, 0.00177845f, 0.08629243f, 
    0.15832104f, -0.12072994f, -0.07558773f, -0.05249153f, -0.00994076f, -0.07561877f, -0.01197150f, 0.08171519f, 
    0.10602990f, 0.07195956f, 0.10278577f, 0.05432673f, -0.01786330f, 0.05901233f, 0.12328058f, 0.03117713f, 
    -1.02584994f, 0.27672741f, 0.25849921f, 0.41477188f, -0.24539398f, 0.04203356f, -0.11548943f, 0.10704856f, 
    -0.19707116f, 0.03147313f, 0.00854090f, 0.01178148f, -0.07689565f, -0.04758064f, -0.02788878f, -0.03980707f, 
    -0.02527358f, 0.08433892f, 0.02221038f, 0.03294272f, -0.19923456f, -0.19706480f, -0.11831031f, 0.00230649f, 
    -0.28476623f, 0.11158530f, -0.15038179f, -0.04972258f, 0.23034118f, 0.05760794f, 0.08103621f, 0.06744880f, 
    0.12022201f, -0.14572501f, 0.02096390f, -0.05427843f, 0.00594621f, -0.12108909f, -0.13056700f, -0.03454499f, 
    0.03665947f, 0.02543643f, -0.01081224f, 0.06120190f, 0.12968753f, -0.04623275f, -0.01931945f, -0.00886073f, 
    0.00129166f, -0.01757120f, 0.11279622f, 0.11961516f, 0.14479439f, 0.12548395f, -0.00282082f, -0.01347344f, 
    -0.01738499f, 0.06502275f, 0.11340629f, 0.03270272f, -0.15521994f, -0.17989267f, 0.07757087f, 0.02843471f, 
    0.04715110f, 0.07098906f, 0.04436570f, 0.06158796f, -0.04878745f, 0.01042831f, 0.00138925f, -0.01157174f, 
    -0.09162094f, 0.01825320f, -0.01056139f, 0.13653728f, -0.01424743f, 0.06503610f, 0.07199405f, -0.02925599f, 
    0.29385510f, -0.03382788f, -0.22448078f, -0.13431568f, 0.07693870f, -0.02661556f, -0.04832107f, -0.07850105f, 
    -0.00654041f, -0.02017596f, -0.07601707f, -0.02478760f, 0.00387809f, -0.02829613f, -0.03042720f, 0.02186430f, 
    0.06079645f, -0.07609978f, 0.11822877f, 0.01300160f, -0.54952216f, -0.22030562f, 0.07557506f, 0.25680438f, 
    0.29466781f, -0.00556762f, -0.07553843f, -0.05638215f, -0.07238977f, -0.02715240f, 0.05544253f, 0.05202347f, 
    -0.26558304f, 0.22908430f, 0.20932613f, 0.14355235f, 0.08771927f, 0.01691887f, 0.06557709f, -0.03175970f, 
    -0.30562723f, 0.00335881f, 0.02426711f, -0.05431734f, -0.33717895f, 0.14819491f, -0.05144391f, -0.01649441f, 
    0.09354122f, 0.13035116f, -0.09407410f, -0.07281259f, -0.03084011f, 0.00664510f, -0.00970208f, 0.10200291f, 
    -0.05358701f, 0.06919695f, 0.08583920f, -0.03520831f, 0.16877528f, 0.01254312f, 0.42180353f, 0.11291058f, 
    -0.04646458f, 0.03171998f, -0.02580953f, 0.12961721f, 0.17120914f, -0.00711485f, -0.02986199f, -0.08438910f, 
    0.10239527f, -0.17226894f, 0.05629469f, 0.03984251f, 0.19899932f, -0.04427670f, -0.01582982f, -0.10177846f, 
    0.22414604f, -0.37712198f, 0.11776806f, 0.04763880f, 0.47993824f, 0.05881521f, 0.02511994f, -0.02089261f, 
    0.08002799f, -0.10277716f, 0.07916932f, 0.22779416f, 0.26897228f, 0.02302334f, 0.01570264f, 0.09728154f, 
    0.13776027f, 0.04349530f, 0.03550879f, 0.02594657f, -0.16059260f, -0.09825356f, -0.02948377f, -0.01722901f, 
    -0.04972430f, 0.21733524f, -0.07587895f, 0.09757768f, 0.02493041f, -0.08121935f, -0.09696425f, -0.11283455f, 
    0.07731159f, 0.03742219f, -0.02151210f, -0.02823989f, 0.09039138f, -0.01033600f, 0.02391186f, 0.20368256f, 
    0.04884314f, 0.21874972f, 0.32899371f, 0.30056816f, -0.15337269f, 0.05050364f, 0.03118452f, -0.06001507f, 
    0.15854731f, 0.06465757f, 0.09031481f, -0.04488475f, -0.08938548f, -0.19948860f, -0.08407362f, 0.00809358f, 
    -0.00643209f, -0.25262824f, -0.05521106f, -0.02810091f, 0.01455066f, -0.16482568f, -0.11582974f, 0.04566393f, 
    0.10504562f, -0.09883378f, -0.02167374f, 0.01759202f, -0.04399893f, -0.04676144f, -0.08217058f, -0.08900035f, 
    -0.03585979f, 0.02984951f, -0.02342802f, 0.13372901f, -0.03204805f, -0.12507716f, 0.09319564f, -0.10326098f, 
    0.74972939f, 0.03500915f, 0.38885713f, 0.02380061f, -0.16505659f, -0.02756971f, -0.06724463f, 0.06074980f, 
    0.04596435f, -0.02208692f, 0.06326189f, -0.00840662f, -0.04838790f, -0.03501804f, 0.06001861f, 0.10996740f, 
    0.03456810f, 0.00398253f, 0.04370714f, 0.07518373f, 0.01162810f, -0.23144682f, 0.27786392f, -0.05759826f, 
    -0.18438555f, -0.12789182f, 0.05794438f, -0.10709453f, 0.19425565f, -0.13899291f, -0.07772531f, -0.14257707f, 
    -0.04364887f, -0.00124418f, -0.05937861f, -0.02762636f, 0.04341409f, -0.08604939f, -0.02097374f, 0.01266047f, 
    0.03065095f, 0.12077199f, 0.03363783f, -0.10935506f, 0.01167788f, 0.07566121f, -0.00498085f, -0.00540301f, 
    -0.01775154f, 0.22548983f, 0.06095247f, 0.08315910f, -0.06487340f, -0.07788500f, -0.12462778f, 0.02169007f, 
    0.09598487f, -0.02079447f, 0.00140333f, 0.18489738f, 0.04236048f, -0.06024842f, 0.00529863f, 0.13069084f, 
    0.00013282f, -0.00369070f, 0.02762555f, -0.00276324f, -0.01022587f, -0.06069811f, -0.10982069f, 0.06581885f, 
    0.00492419f, 0.01593068f, -0.00810326f, -0.06311340f, -0.09150723f, -0.00501529f, -0.08219347f, 0.02240782f, 
    -0.42648357f, -0.13191997f, 0.56720477f, -0.27751130f, -0.26111397f, 0.24885015f, 0.12568046f, 0.05117111f, 
    -0.04500328f, -0.18112189f, -0.06485542f, -0.05385689f, 0.03404827f, -0.04965920f, -0.02877855f, 0.04448920f, 
    -0.04149754f, 0.03350731f, -0.07489452f, -0.00735647f, 0.10694791f, 0.23179588f, -0.03258933f, -0.02075177f, 
    0.15925299f, 0.22439775f, -0.16681704f, 0.23858526f, -0.01394077f, 0.12886247f, 0.15217444f, 0.05199789f, 
    0.00638639f, -0.02875303f, -0.02857889f, 0.01266756f, -0.01575335f, 0.02138758f, -0.13040684f, -0.08457321f, 
    -0.05581228f, -0.05557950f, 0.06462372f, 0.00391126f, -0.01319572f, -0.08243846f, -0.02882147f, 0.00425503f, 
    -0.08225729f, -0.05411015f, 0.03959219f, 0.08063369f, -0.08592036f, -0.01406228f, -0.01290734f, -0.10513046f, 
    -0.03134811f, -0.01879286f, -0.04917421f, -0.01967380f, -0.09203629f, -0.08159078f, 0.29210958f, -0.01543215f, 
    -0.10882492f, 0.07323007f, 0.04799168f, 0.04962907f, -0.04310039f, -0.10076314f, 0.07300790f, -0.08872930f, 
    0.00922599f, 0.09316197f, 0.08386505f, 0.13771127f, 0.06145630f, 0.07769745f, -0.04081469f, 0.05076873f, 
    0.27559176f, 0.10367912f, -0.01163806f, 0.22307178f, -0.06430196f, -0.00069430f, -0.06027607f, -0.05459910f, 
    0.01049237f, 0.00592946f, -0.12382349f, 0.00938098f, -0.00169343f, -0.01657006f, 0.03719270f, -0.08892023f, 
    0.27284646f, 0.04179034f, 0.06304977f, -0.01954828f, -0.18189724f, -0.15258558f, -0.07861992f, 0.05258542f, 
    -0.13268654f, -0.09819610f, 0.11509086f, 0.04613115f, 0.02292457f, 0.19071440f, -0.04842757f, -0.00495416f, 
    -0.04847462f, 0.05937804f, -0.10537779f, -0.09321251f, 0.03251082f, 0.09067354f, -0.02785565f, -0.09687103f, 
    0.17043293f, 0.37251106f, 0.19780663f, 0.16117221f, -0.06507467f, 0.04830348f, -0.19379479f, -0.11481293f, 
    0.07683924f, 0.22388853f, -0.08552331f, 0.02466567f, 0.01837574f, 0.07486705f, 0.03502995f, 0.08888232f, 
    -0.04849583f, -0.01492417f, -0.04306219f, -0.02621356f, 0.18128799f, 0.21113490f, 0.28290227f, 0.16915286f, 
    -0.21447830f, 0.25312188f, 0.03846813f, 0.15631469f, 0.19603391f, 0.08198730f, -0.13425657f, -0.03011242f, 
    0.07876917f, -0.06192998f, -0.06020688f, 0.12162451f, 0.09084373f, 0.03443853f, 0.00658646f, 0.04143824f, 
    -0.13158248f, -0.15635596f, 0.06758340f, 0.05730241f, 0.16350080f, -0.01468989f, -0.11105466f, 0.21399382f, 
    -0.08596279f, -0.08020656f, 0.00746717f, 0.13306385f, -0.03021357f, 0.04723316f, -0.02937630f, -0.01669087f, 
    0.05574561f, 0.00513310f, -0.05893864f, -0.04374203f, -0.08571514f, 0.17091413f, 0.01630538f, -0.01266669f, 
    -0.13626604f, 0.09386262f, 0.07760283f, 0.20737149f, -0.07271267f, -0.01865361f, -0.13981740f, 0.10709134f, 
    0.10071302f, 0.04728127f, 0.02480955f, -0.07931942f, -0.02821533f, -0.05556330f, -0.11190276f, -0.03155813f, 
    0.52032727f, 0.41195333f, -0.02593357f, -0.01008217f, 0.04611581f, 0.06749263f, 0.14893788f, 0.11172865f, 
    0.01118231f, 0.10549038f, 0.01532460f, -0.05584507f, 0.07484567f, -0.10594740f, 0.16166006f, 0.21050985f, 
    0.09974407f, 0.05179329f, -0.00472602f, 0.12012164f, 0.07811984f, 0.10289185f, 0.15558459f, 0.20599914f, 
    -0.08433068f, -0.14403635f, -0.02457623f, -0.06992230f, -0.03837151f, -0.09777628f, -0.00783901f, 0.03213937f, 
    0.01087203f, 0.03089186f, 0.03200709f, 0.19930401f, 0.25337827f, -0.00354900f, 0.05395768f, -0.01744461f, 
    0.49459663f, -0.25520834f, -0.49595326f, 0.16268945f, -0.28021351f, -0.02930979f, 0.05857616f, -0.12364063f, 
    0.02190364f, -0.06844163f, -0.05845650f, -0.08258528f, -0.15202361f, -0.02559980f, -0.13431866f, -0.05226577f, 
    0.02124145f, -0.08992328f, -0.01141280f, 0.11111938f, 0.35662425f, 0.27367684f, -0.19297418f, 0.19189017f, 
    0.02167189f, 0.06697326f, 0.27480081f, 0.13023776f, 0.07195929f, 0.09066571f, -0.07131408f, -0.13791448f, 
    -0.06461186f, -0.02252548f, -0.11384174f, 0.02298357f, 0.07703941f, -0.04154086f, -0.04327399f, 0.16089681f, 
    0.00582836f, -0.21558341f, -0.02372105f, -0.04213623f, 0.23063549f, -0.04496309f, -0.03592312f, 0.03885447f, 
    0.04714285f, 0.02937657f, 0.03517447f, -0.03992879f, 0.08395241f, 0.10307459f, 0.00436483f, 0.01282415f, 
    0.11969443f, 0.10889431f, -0.00828701f, -0.12376477f, -0.27027196f, -0.10626883f, 0.02654191f, -0.23310106f, 
    -0.13164462f, -0.02955530f, -0.17403579f, -0.09577542f, -0.14036638f, -0.15139732f, 0.09805662f, 0.04163077f, 
    -0.04961598f, 0.02758606f, -0.02723716f, -0.03485753f, 0.02817022f, -0.12151907f, 0.12840196f, 0.05027897f, 
    0.90765238f, 0.03665332f, -0.45276237f, 0.19955385f, -0.02933732f, 0.13637345f, -0.05158920f, 0.22068641f, 
    0.07956201f, -0.09841948f, 0.08519070f, -0.02800858f, 0.01979858f, 0.09702041f, -0.06776900f, -0.00306558f, 
    -0.01000237f, 0.14427279f, 0.03631954f, -0.06712410f, -0.09796882f, -0.02134926f, 0.01561391f, 0.26611951f, 
    0.14713325f, 0.00287988f, 0.02243175f, -0.16219309f, 0.09098970f, 0.02940514f, 0.02314444f, 0.07881801f, 
    0.03642079f, 0.04273686f, -0.00826861f, 0.05457926f, 0.02421412f, -0.03549485f, -0.11957862f, 0.01519190f, 
    -0.10412604f, -0.03166535f, -0.22939363f, -0.09916279f, -0.12574880f, -0.09184066f, -0.07096020f, -0.15396750f, 
    -0.06311630f, -0.18003991f, -0.02394366f, 0.13067621f, 0.09269363f, 0.03094937f, 0.09300858f, 0.07918006f, 
    0.08559931f, 0.05316633f, -0.00814094f, 0.03014489f, -0.04957996f, 0.18693405f, -0.29355001f, 0.03133731f, 
    -0.36137107f, -0.07917609f, -0.01880217f, -0.02781464f, -0.09299012f, -0.13322191f, 0.05423986f, -0.09773937f, 
    -0.04143278f, -0.10138258f, 0.00708030f, -0.14390232f, -0.03502604f, 0.11997774f, 0.10841450f, -0.05890696f, 
    -0.59946072f, 0.18330219f, 0.43061793f, -0.15938757f, -0.22282153f, 0.02136488f, -0.16181251f, -0.04095613f, 
    -0.04948095f, 0.00393389f, 0.06648828f, -0.10362920f, 0.02707289f, 0.04650554f, -0.11059754f, 0.22223367f, 
    -0.07366445f, 0.11614835f, 0.00132693f, 0.05872737f, 1.04442286f, 0.31154180f, -0.06296879f, -0.17779037f, 
    -0.21852799f, 0.20936018f, 0.00581963f, 0.04934838f, -0.09796678f, -0.09429366f, -0.00431155f, 0.05317410f, 
    0.09581357f, 0.01877830f, -0.02360223f, -0.08851568f, -0.04355837f, -0.08844759f, 0.15083615f, 0.13926068f, 
    0.00469460f, -0.12959948f, 0.13646241f, 0.13982414f, 0.29126525f, -0.05145964f, 0.20707124f, 0.07087155f, 
    0.07952072f, 0.07075243f, 0.04201340f, 0.02034628f, 0.01811928f, -0.04035082f, -0.02198631f, 0.05845273f, 
    0.00999633f, -0.02634953f, -0.02367166f, -0.04365033f, -0.22615711f, -0.07500261f, -0.28727755f, -0.08134962f, 
    0.12261484f, -0.11076625f, 0.02974990f, 0.06710000f, -0.02128494f, 0.05164135f, 0.11853972f, 0.09793478f, 
    -0.07208466f, 0.07041049f, -0.10922883f, 0.05201745f, 0.05031431f, -0.02180102f, 0.04870311f, -0.02731209f, 
    -0.05749340f, 0.46274441f, 0.25286475f, 0.06567165f, -0.27328154f, -0.00548516f, 0.01557353f, -0.20545799f, 
    0.05835981f, 0.05012468f, -0.02804915f, -0.04296038f, 0.01792732f, -0.09471811f, 0.09983792f, 0.09365904f, 
    0.02721719f, -0.03997899f, -0.16746157f, -0.07349848f, -0.11825062f, -0.13846517f, 0.12710051f, -0.04869817f, 
    0.17153549f, 0.07387323f, -0.01875664f, -0.01553464f, 0.12551418f, 0.17953475f, 0.04766299f, 0.14711241f, 
    0.02108295f, 0.01876228f, 0.03718586f, 0.14573103f, 0.05873062f, 0.26486453f, 0.06613795f, 0.09545214f, 
    -0.25132409f, -0.18064868f, -0.05708931f, -0.06114610f, 0.24679315f, -0.03769293f, -0.07045775f, -0.06721680f, 
    0.13177255f, -0.04132095f, 0.05989040f, 0.08846243f, -0.03355621f, 0.05716525f, 0.05564953f, -0.09924695f, 
    0.09540116f, 0.03199843f, -0.02203909f, -0.01101217f, -0.40953329f, 0.07051680f, -0.01019202f, -0.12489282f, 
    -0.10817744f, -0.09391494f, -0.10193482f, -0.05920557f, 0.01291955f, -0.05408616f, 0.01358951f, -0.09518795f, 
    -0.03816788f, -0.08299508f, -0.07596759f, -0.01216943f, 0.05710212f, 0.20065357f, 0.04056956f, -0.00324835f, 
    -0.10302433f, 0.24447104f, 0.64976263f, -0.09728131f, 0.12860923f, 0.01801577f, -0.06347315f, 0.08810063f, 
    -0.05495649f, -0.11667701f, 0.04970383f, -0.00179268f, 0.03955133f, 0.10070062f, 0.12451828f, 0.05506986f, 
    -0.04998553f, 0.03752078f, 0.09619023f, -0.02181997f, 0.12864843f, -0.30048686f, -0.15272813f, 0.01779324f, 
    0.31829774f, 0.17419626f, 0.08848892f, 0.02406806f, 0.03396955f, 0.18309443f, 0.06675988f, 0.09036145f, 
    0.12765786f, 0.08936614f, 0.13373519f, 0.05997812f, 0.05802270f, 0.13364688f, 0.12540410f, 0.03672214f, 
    -0.17807162f, -0.02801263f, 0.01836700f, 0.08880660f, 0.05618947f, -0.01572973f, 0.04988274f, 0.03212387f, 
    0.00448831f, -0.02579989f, -0.00124955f, 0.01241429f, 0.09719090f, 0.16022415f, 0.11229203f, 0.05218102f, 
    0.18060312f, 0.20851673f, 0.02121428f, 0.22645834f, -0.11886817f, -0.09967222f, -0.19302526f, -0.09997226f, 
    -0.13485005f, -0.00920213f, -0.03320699f, 0.05121011f, -0.00231969f, -0.03982428f, -0.00774386f, 0.09570544f, 
    0.07111736f, -0.05334020f, -0.03056273f, 0.19639206f, 0.14668268f, -0.01377587f, -0.10483422f, -0.02827392f, 
    0.00933713f, -0.11228747f, 0.14572014f, -0.00017329f, 0.14132510f, 0.02349688f, -0.02264158f, -0.12386118f, 
    0.22011016f, 0.15976244f, 0.14745715f, 0.09153818f, -0.07674077f, -0.09972546f, 0.12448031f, -0.05606638f, 
    -0.06658491f, -0.08570146f, -0.05140077f, -0.00587464f, -0.31634226f, -0.33340287f, -0.16130868f, 0.29636520f, 
    0.05413786f, 0.05873740f, 0.06027353f, 0.12707646f, -0.27375489f, -0.05543441f, -0.04284211f, 0.06553558f, 
    0.08587552f, 0.03081288f, 0.08297639f, 0.06622265f, 0.06849146f, 0.01170402f, -0.16416298f, 0.19917886f, 
    -0.16469760f, -0.08360457f, 0.02613816f, 0.05375265f, -0.08974775f, 0.05068760f, 0.01576849f, -0.02339186f, 
    -0.01400745f, 0.06576537f, 0.00291163f, 0.07372107f, 0.13788705f, 0.02487470f, 0.18083967f, 0.06727464f, 
    -0.04830163f, 0.00660906f, -0.07768124f, -0.04091436f, -0.09606239f, -0.04294001f, -0.19377851f, -0.25474468f, 
    -0.00852902f, 0.00639444f, 0.14800917f, 0.05428928f, 0.02482234f, -0.00905133f, -0.07834566f, -0.03636450f, 
    0.06814498f, -0.07535880f, 0.03672317f, 0.07549563f, 0.02462672f, -0.02263170f, -0.04706726f, 0.05785874f, 
    0.34335566f, -0.20524886f, -0.37270805f, -0.20147130f, 0.00987515f, 0.03757752f, 0.10852101f, 0.08849005f, 
    -0.00213406f, -0.00085823f, 0.01344103f, 0.05908792f, 0.05321902f, -0.05961443f, -0.02515025f, 0.00312747f, 
    0.11207006f, 0.19271931f, -0.00965519f, 0.00753832f, -0.28118151f, -0.25694427f, 0.05483472f, 0.45101798f, 
    0.06313728f, 0.06895875f, -0.06320508f, 0.01256417f, -0.11346252f, 0.08179784f, 0.04200335f, -0.05194839f, 
    0.01737673f, 0.14852019f, 0.02701159f, 0.08786920f, 0.02058603f, 0.10110100f, 0.01927069f, 0.09319351f, 
    0.05097157f, 0.10246941f, -0.00528117f, 0.19003762f, 0.25560623f, 0.01260538f, -0.01691836f, 0.15340544f, 
    -0.04902289f, 0.05783131f, -0.00212373f, 0.00635647f, 0.02154831f, -0.07170966f, -0.05227294f, -0.05714833f, 
    -0.07121523f, -0.02493119f, 0.07359500f, 0.07338601f, -0.27289471f, -0.00864714f, 0.07544567f, 0.07280701f, 
    0.04323104f, -0.15481739f, -0.04001489f, -0.18531041f, 0.25784123f, -0.15554118f, 0.01402191f, -0.08858100f, 
    0.06811560f, 0.04267968f, 0.02997584f, -0.00480516f, 0.08568548f, 0.03301530f, 0.03724232f, 0.03867444f, 
    -0.28549370f, -0.27825728f, 0.18076020f, 0.00323106f, 0.01509235f, 0.16310471f, 0.16142666f, 0.08011594f, 
    0.05012716f, -0.08546032f, -0.01662123f, -0.03048183f, -0.13218261f, -0.06426638f, 0.04977808f, 0.04970001f, 
    0.16179284f, 0.07044583f, 0.06048044f, 0.03181768f, -0.12901330f, 0.11153375f, -0.10429767f, 0.05426519f, 
    0.15458179f, 0.07830155f, -0.15211976f, 0.07174372f, 0.00624884f, 0.05529312f, 0.11663310f, -0.01397435f, 
    -0.02358923f, 0.05524718f, -0.00482693f, -0.07476788f, -0.14966996f, 0.05065644f, -0.15263528f, -0.16419038f, 
    -0.16001520f, -0.20650636f, -0.17035027f, 0.43618873f, 0.01078065f, 0.01249019f, -0.08150989f, -0.08423343f, 
    -0.15166457f, -0.06263459f, -0.07613877f, 0.00500992f, 0.06856173f, 0.03965835f, 0.03465817f, 0.08213168f, 
    0.20604454f, -0.08217189f, 0.10965228f, 0.02392073f, 0.33101737f, -0.14467433f, -0.25401220f, -0.25418633f, 
    0.03716842f, -0.02632276f, 0.07691063f, 0.15097955f, -0.02924407f, 0.08847801f, -0.04535419f, -0.08191820f, 
    -0.12269206f, -0.10075818f, 0.04647373f, 0.07834204f, 0.02937744f, 0.05073984f, -0.09044777f, 0.08596572f, 
    0.06204665f, 0.48034069f, 0.54329151f, -0.05198767f, 0.00906122f, -0.00154823f, 0.11107108f, -0.24845980f, 
    0.00745730f, 0.12545139f, -0.00757476f, 0.04089508f, 0.18096216f, 0.14134352f, 0.00428558f, -0.07599147f, 
    -0.02558731f, -0.01925096f, -0.18967536f, 0.08644087f, -0.31967288f, 0.09864250f, 0.34146756f, 0.40064231f, 
    0.12062009f, -0.02061929f, 0.05377987f, -0.14248404f, -0.14767581f, 0.08937978f, -0.08136737f, 0.17540817f, 
    0.07986631f, 0.03693401f, 0.02262156f, -0.00483589f, -0.08519766f, 0.02563366f, -0.19148472f, -0.04576960f, 
    -0.04210448f, -0.04197441f, 0.02600379f, 0.04284013f, 0.00005349f, -0.01319594f, 0.02515635f, 0.00961216f, 
    0.04392489f, -0.02498879f, -0.00683596f, -0.06002493f, -0.06000081f, -0.03152094f, 0.00922711f, -0.01259422f, 
    -0.00054339f, -0.03445268f, -0.05974312f, -0.02251750f, 0.03020697f, -0.01048292f, -0.02383120f, 0.04287286f, 
    -0.01220203f, -0.03253694f, 0.00343622f, -0.04547312f, -0.06425453f, 0.01197772f, 0.03457741f, -0.00353977f, 
    -0.00818786f, 0.04551092f, -0.04433566f, 0.02736632f, -0.01025186f, 0.01644865f, -0.00977226f, -0.01396685f, 
    0.04708151f, 0.03944128f, -0.03574010f, -0.04874236f, -0.02562984f, 0.03117989f, 0.00066232f, -0.02465192f, 
    0.01854431f, -0.02018731f, -0.02247365f, 0.03238614f, 0.04418592f, -0.00187267f, 0.00414380f, 0.02685277f, 
    0.00923640f, -0.05285526f, -0.04114087f, -0.05652273f, 0.00847921f, 0.00234663f, 0.00925104f, -0.04713272f, 
    0.03284892f, -0.02485995f, 0.00158246f, -0.03945514f, -0.04827793f, -0.03385517f, -0.05775056f, -0.05741505f, 
    -0.02808308f, 0.00206653f, -0.01098085f, 0.03472174f, -0.00550744f, -0.04718009f, -0.04450985f, -0.04526976f, 
    -0.03451675f, -0.04685614f, -0.03094796f, 0.03361170f, 0.01104222f, 0.03115075f, -0.04227255f, -0.03143364f, 
    -0.01730460f, 0.03761998f, -0.06045084f, -0.02114403f, -0.03519787f, -0.00793882f, 0.01523367f, -0.02267829f, 
    -0.04613687f, -0.01563575f, 0.04652965f, -0.02224696f, 0.02239725f, 0.04208325f, -0.05826342f, -0.05470518f, 
    -0.00717220f, 0.03982574f, 0.04364897f, 0.02791121f, -0.03092648f, 0.00214169f, -0.03064614f, -0.01203806f, 
    0.03140305f, -0.04921548f, 0.01367723f, 0.03268209f, 0.03731349f, 0.01596635f, -0.02446715f, 0.00795090f, 
    -0.02685761f, -0.04677767f, -0.00131117f, -0.05058609f, 0.04512429f, 0.01739454f, -0.06145139f, -0.06380919f, 
    0.01651141f, 0.04242281f, 0.02278502f, -0.05915759f, 0.01052542f, -0.03576709f, 0.04049216f, -0.06019650f, 
    0.01959762f, 0.00446010f, -0.02129151f, 0.01779443f, 0.04726373f, -0.03115446f, -0.02829855f, -0.06066225f, 
    -0.01491927f, 0.00282637f, -0.01162720f, -0.02810085f, 0.00308115f, -0.01773852f, -0.02908499f, -0.05418656f, 
    -0.02633880f, 0.04198345f, 0.04064311f, -0.02877246f, -0.02127797f, 0.04497701f, -0.05593707f, -0.03329543f, 
    0.04229329f, -0.05525967f, -0.03901853f, 0.00335001f, 0.00927814f, -0.03754922f, -0.05340469f, -0.03009797f, 
    -0.02464445f, -0.01276260f, -0.00433344f, -0.03301118f, -0.03693683f, -0.05019811f, -0.01010290f, -0.03797223f, 
    -0.05783607f, -0.04764066f, -0.06203549f, -0.03617800f, 0.03318642f, -0.00415623f, -0.05548045f, -0.02287024f, 
    0.00849883f, -0.05671155f, 0.01045731f, 0.04708694f, 0.05069024f, 0.00420052f, 0.03734913f, 0.01187237f, 
    0.03601310f, 0.01181872f, 0.04320801f, 0.00861500f, 0.04617429f, -0.04734640f, -0.02988470f, -0.04372979f, 
    -0.04250723f, 0.03588532f, 0.02757883f, -0.01863770f, 0.01170719f, -0.06216014f, 0.01987900f, -0.02533605f, 
    -0.01663684f, -0.02957739f, -0.02727451f, -0.03560927f, -0.04702902f, 0.02848247f, 0.00445659f, -0.04769784f, 
    0.03722132f, -0.01701552f, -0.05180753f, -0.04310464f, -0.01617686f, 0.03845553f, -0.03395665f, -0.02045794f, 
    -0.01380676f, -0.04424864f, -0.04178164f, 0.01062815f, -0.02605860f, -0.01770137f, 0.01546094f, -0.03092723f, 
    0.00067630f, -0.05552860f, 0.00108209f, 0.02697141f, 0.02470529f, 0.04756548f, -0.02915747f, 0.02473931f, 
    0.04828665f, 0.01316950f, 0.05382645f, 0.01533225f, 0.05113548f, 0.02513645f, -0.01103859f, -0.02687987f, 
    0.04315219f, -0.05142906f, -0.02574752f, -0.00545697f, -0.05501149f, -0.01976187f, -0.04240294f, -0.05516103f, 
    0.00803716f, -0.01398003f, 0.04827410f, -0.03221653f, 0.04411908f, -0.03587033f, -0.00061557f, -0.01041481f, 
    0.03879799f, 0.00320668f, -0.02258425f, -0.02601127f, 0.01047904f, 0.00693121f, -0.03928390f, 0.00351582f, 
    -0.04953317f, 0.01802542f, -0.00527890f, 0.02284708f, -0.05169883f, 0.03922759f, 0.03383622f, 0.00976169f, 
    0.03071071f, 0.00063138f, -0.01769752f, 0.00231899f, -0.04648615f, -0.03140486f, -0.01139541f, 0.00071691f, 
    0.03056238f, -0.01718843f, -0.02327782f, -0.05616838f, 0.01280803f, -0.01714100f, -0.06000747f, 0.00810459f, 
    0.03074372f, -0.03271584f, -0.00923177f, -0.00301869f, -0.01754849f, 0.01419525f, -0.04657185f, -0.04520754f, 
    -0.04694283f, 0.05386914f, 0.03937992f, -0.00684054f, -0.01345363f, -0.00440789f, -0.02785297f, -0.04378476f, 
    0.04644218f, 0.00453835f, 0.00130110f, -0.05348118f, -0.00036462f, 0.04506041f, 0.00158809f, -0.02874301f, 
    0.02793224f, 0.14558151f, 0.05037810f, 0.01906604f, 0.26072666f, -0.08797575f, -0.00992514f, 0.10577510f, 
    -0.00426682f, -0.00527603f, -0.13310526f, -0.06803841f, 0.02255697f, 0.06509872f, -0.06313690f, 0.13827899f, 
    0.02666486f, 0.09640973f, -0.06413601f, -0.18948033f, -0.17976491f, -0.16171351f, 0.05705040f, -0.01580417f, 
    0.05056494f, 0.01034253f, 0.06023707f, -0.02409391f, -0.12827846f, -0.02649323f, 0.04490963f, 0.01682647f, 
    0.12013154f, 0.01428763f, 0.09761259f, 0.03614036f, -0.02204838f, -0.04529331f, 0.00684347f, -0.03280063f, 
    0.70794916f, 0.05482766f, 0.27821836f, -0.25802425f, -0.06554825f, 0.07751087f, 0.09144258f, 0.04949141f, 
    0.19380100f, 0.10800780f, 0.08500664f, -0.13437797f, 0.05189417f, -0.01939521f, -0.13514400f, 0.08030003f, 
    -0.09631044f, -0.06336032f, -0.04115818f, 0.04927503f, 0.14857352f, 0.24990527f, 0.50229132f, 0.27329868f, 
    -0.08102380f, -0.08453509f, 0.17157225f, 0.24434006f, -0.14841679f, 0.18095188f, 0.07032270f, 0.00875851f, 
    -0.07989401f, 0.02945477f, 0.01788138f, 0.10550858f, 0.05939944f, 0.09471916f, 0.18078002f, 0.12188601f, 
    0.02167603f, -0.07858316f, 0.18791112f, 0.04411174f, -0.20887969f, -0.01141219f, -0.09401855f, -0.16591948f, 
    -0.03752594f, -0.07695094f, -0.02046934f, -0.08345473f, 0.05988643f, -0.01668372f, 0.07953550f, -0.01536405f, 
    -0.08551603f, -0.19764222f, 0.00585326f, -0.07589154f, -0.20891474f, -0.09887788f, -0.08297179f, 0.18162251f, 
    -0.19656172f, -0.11553489f, 0.00207402f, -0.17487513f, -0.00667811f, -0.15198734f, -0.06761701f, 0.02466034f, 
    0.05428866f, 0.04973457f, 0.05943741f, -0.02995205f, 0.01824379f, 0.06536585f, -0.12276620f, -0.11600681f, 
    0.02299479f, -0.09896666f, -0.19061714f, 0.34835964f, 0.06898916f, 0.06421188f, 0.00651740f, 0.09096456f, 
    0.07829610f, -0.06840375f, 0.04345973f, -0.05037184f, 0.06086283f, -0.11954726f, -0.02751313f, -0.05374137f, 
    0.01509735f, 0.27708668f, 0.06525723f, -0.03231036f, 0.26863047f, 0.68538773f, 0.29484442f, 0.32392251f, 
    -0.51875252f, -0.21550137f, -0.06661684f, 0.20959561f, 0.18522762f, 0.14015827f, 0.07728028f, -0.14717083f, 
    0.06016102f, 0.08106013f, -0.19210827f, -0.47766772f, 0.05428605f, 0.25196412f, -0.09829705f, -0.08193248f, 
    0.23326589f, 0.35451999f, 0.08336806f, 0.22104089f, 0.24699667f, -0.09233357f, -0.00196585f, 0.11856496f, 
    -0.04520490f, 0.19544972f, 0.06297754f, -0.00856224f, -0.00215740f, -0.17089398f, 0.01396672f, 0.00272434f, 
    -0.15555140f, 0.19458103f, 0.01601764f, 0.07676134f, 0.06471761f, 0.25292736f, 0.05545301f, -0.08885176f, 
    -0.06147130f, 0.10292573f, -0.10952960f, -0.15066732f, 0.09545381f, 0.09754228f, -0.05435855f, 0.16499598f, 
    -0.06933774f, 0.20047897f, 0.00764110f, 0.05361513f, 0.02256932f, -0.01193556f, 0.09008037f, 0.15759669f, 
    -0.16196558f, 0.03213881f, -0.02225739f, -0.02538723f, -0.25048882f, -0.07749540f, -0.24985786f, 0.13699073f, 
    -0.20100415f, -0.20346852f, -0.05301369f, 0.00074382f, -0.29195949f, 0.05508990f, 0.10420576f, -0.01597737f, 
    0.05724976f, 0.15370336f, -0.07506544f, 0.26494193f, 0.01173653f, 0.18484348f, 0.31978458f, -0.07985084f, 
    -0.00176046f, -0.12118485f, 0.15847324f, 0.12336741f, -0.09793980f, -0.08475471f, 0.23588976f, -0.00795133f, 
    -0.11937804f, 0.10597599f, -0.00426019f, 0.11011196f, -0.18828787f, -0.02383032f, -0.09898036f, 0.06481387f, 
    -0.01446464f, -0.12311454f, -0.12151818f, -0.21930037f, 0.04193344f, 0.02899886f, 0.27076426f, 0.00627676f, 
    -0.16646509f, 0.15980305f, -0.07815560f, -0.02794116f, -0.01517341f, 0.22618198f, 0.04480491f, 0.06838300f, 
    0.04366221f, 0.09970057f, 0.07852776f, -0.00345939f, 0.02800991f, -0.11728550f, -0.06723788f, 0.10702051f, 
    -0.16965427f, 0.12061238f, 0.16739406f, 0.12452211f, -0.01936219f, 0.14757128f, -0.14827119f, -0.01249205f, 
    0.02482585f, -0.09067191f, 0.04369180f, 0.07591702f, 0.02498216f, 0.13362175f, -0.06903018f, 0.05568109f, 
    -0.63565558f, -0.10908753f, -0.81885874f, -0.14018364f, -0.09400283f, 0.13537404f, -0.23983787f, -0.06433319f, 
    -0.00517989f, -0.02879803f, -0.11792393f, 0.04655445f, 0.04405317f, 0.04030911f, 0.19384612f, -0.31282580f, 
    -0.13144752f, 0.28281280f, -0.02797395f, 0.11882121f, 0.17652050f, 0.37252739f, 0.18361060f, 0.13194779f, 
    0.00659190f, 0.23162760f, -0.09869938f, 0.00034358f, 0.09271263f, 0.16428983f, 0.06927855f, -0.00144737f, 
    0.03714666f, 0.00555284f, -0.13731106f, -0.17567261f, -0.08405196f, 0.04622239f, -0.00337043f, 0.22361767f, 
    0.05128450f, -0.03819247f, -0.02498552f, -0.00417574f, -0.00543530f, -0.02648924f, -0.01931103f, 0.03465928f, 
    -0.05230882f, 0.03049332f, -0.03528287f, -0.04503004f, -0.05707434f, -0.06004720f, -0.04704068f, 0.00162080f, 
    0.01196627f, -0.00019560f, 0.01795453f, -0.02709953f, -0.01608631f, 0.01592486f, -0.01716375f, 0.00292729f, 
    -0.04578856f, 0.01707985f, -0.01906599f, 0.00792214f, 0.02721064f, -0.03822983f, 0.00725205f, 0.03413752f, 
    -0.03649613f, -0.04646480f, 0.04732957f, -0.05710659f, 0.04678173f, -0.01932419f, 0.04303087f, 0.02079760f, 
    -0.02997505f, -0.01793982f, -0.00812253f, 0.04431279f, 0.03227608f, 0.00011885f, -0.02819576f, -0.01957505f, 
    0.01353303f, 0.01037779f, -0.03213165f, -0.01990838f, -0.04418533f, 0.04017368f, -0.00124613f, 0.00582761f, 
    -0.01560081f, 0.00216181f, 0.00997091f, 0.04197223f, -0.01758142f, -0.04487919f, 0.04811330f, -0.06093809f, 
    0.04871853f, -0.04533147f, 0.01133068f, 0.04347852f, -0.00118821f, -0.05250921f, -0.02686933f, 0.03538564f, 
    -0.06416078f, -0.03555754f, 0.01752626f, 0.04284223f, -0.02381911f, 0.04523328f, -0.03853943f, -0.04967252f, 
    0.03495955f, 0.03278432f, -0.04299553f, 0.02101729f, -0.05624295f, 0.02344913f, 0.02474473f, -0.04888464f, 
    -0.04356362f, 0.02917377f, -0.05763338f, -0.05027177f, -0.03853260f, 0.04003803f, 0.03760368f, -0.05561461f, 
    -0.05859794f, -0.03911374f, -0.05061349f, 0.00636361f, -0.00000049f, -0.00548539f, -0.02965014f, 0.03768998f, 
    -0.03341990f, 0.00984575f, 0.05073139f, -0.02882268f, 0.04846948f, 0.01865645f, -0.04369118f, -0.02649927f, 
    0.04076563f, -0.00079889f, 0.00598042f, 0.02729743f, -0.00885533f, 0.04504152f, -0.05523261f, 0.03973815f, 
    0.00124086f, -0.00150739f, -0.03056613f, 0.04100377f, 0.03019777f, 0.03364635f, 0.04819611f, -0.03496774f, 
    -0.03750379f, -0.02073481f, -0.02192964f, -0.04439883f, 0.01290894f, -0.03073349f, -0.02830710f, 0.04607724f, 
    -0.02658593f, -0.04274997f, -0.04226530f, -0.03233955f, 0.01318213f, 0.00162231f, 0.02399201f, 0.03692851f, 
    -0.00712599f, -0.00017975f, 0.03920724f, -0.05250910f, 0.00538742f, -0.04302710f, 0.02095875f, -0.01620144f, 
    0.00164302f, 0.00091960f, 0.01616839f, 0.04499707f, 0.01075920f, -0.05465538f, 0.03791314f, 0.00343206f, 
    -0.04325822f, -0.00850849f, 0.04586582f, 0.01807304f, -0.01542413f, -0.00154459f, 0.03909564f, 0.02771069f, 
    -0.01419286f, -0.04361262f, 0.03974998f, -0.04693289f, -0.01040293f, -0.00097555f, 0.02672893f, -0.01892315f, 
    0.03359627f, 0.03219580f, 0.02156937f, -0.05134291f, 0.00884577f, 0.00768644f, 0.04064519f, -0.00975087f, 
    0.00467659f, 0.01067353f, -0.06099639f, -0.00735205f, -0.04161432f, -0.03627058f, -0.03097409f, -0.05027210f, 
    0.01047854f, 0.01637601f, 0.04506604f, -0.05203947f, 0.01911644f, -0.03902582f, -0.02803406f, -0.01124929f, 
    -0.04942631f, 0.04099769f, -0.05294246f, 0.01764817f, 0.05463211f, 0.02559041f, -0.03974713f, -0.01192401f, 
    -0.01900925f, 0.01097186f, -0.01146257f, 0.01401843f, -0.03654013f, 0.01831335f, -0.04502446f, 0.02884730f, 
    -0.04575435f, 0.04846634f, 0.00403145f, 0.00305496f, -0.00697946f, -0.00138306f, 0.00312497f, 0.04430566f, 
    -0.04474342f, 0.01522942f, -0.04226369f, -0.03742675f, 0.00781170f, -0.01035344f, -0.05603633f, 0.02029220f, 
    0.01505705f, -0.03595331f, -0.00333994f, -0.05043850f, -0.01087514f, 0.04082856f, 0.03264280f, 0.04107700f, 
    -0.02493147f, -0.01990214f, 0.00538270f, 0.00209577f, 0.00768844f, 0.04776006f, 0.03149980f, -0.05121215f, 
    -0.05091020f, -0.05994138f, 0.02696606f, -0.01278212f, -0.05968846f, 0.02127014f, 0.04236585f, -0.06143395f, 
    0.04770591f, -0.02852778f, -0.02441355f, -0.02614213f, -0.01936649f, 0.03311181f, -0.00306701f, 0.04305318f, 
    0.00091695f, -0.04942768f, 0.00203221f, 0.03546806f, -0.04335531f, -0.03610719f, 0.00305953f, 0.05271973f, 
    -0.05613117f, -0.02270582f, 0.01495040f, 0.04957901f, -0.03519984f, -0.01280396f, 0.00848450f, -0.01665455f, 
    -0.04059773f, 0.00246237f, -0.05122624f, 0.02189082f, 0.00879736f, -0.03769747f, -0.05046141f, 0.01726533f, 
    0.03472085f, -0.03928263f, 0.00617274f, -0.05134916f, -0.02950847f, -0.04052259f, 0.02719154f, -0.00870984f, 
    -0.01441467f, -0.05129951f, -0.04960360f, -0.03031243f, -0.00934611f, -0.04712033f, -0.02066797f, -0.05387298f, 
    0.05226321f, 0.00978890f, 0.04189935f, -0.01136196f, -0.00748244f, 0.01882012f, 0.04201587f, 0.02697427f, 
    0.02381738f, -0.03963814f, -0.00533027f, 0.00702526f, -0.00048896f, -0.01107279f, -0.05404253f, 0.02514572f, 
    -0.05512543f, 0.00753464f, -0.01998936f, -0.01875874f, 0.00554392f, -0.00884729f, 0.01726501f, 0.00858594f, 
    0.03167769f, -0.00262307f, -0.06037398f, 0.02783380f, 0.03651424f, 0.04141981f, -0.04037865f, -0.05694276f, 
    0.00388736f, 0.01490785f, 0.01838720f, -0.00621750f, -0.04717924f, 0.05096257f, -0.06037762f, -0.02917372f, 
    -0.03412484f, -0.04946737f, -0.05053871f, -0.06130052f, 0.03180655f, 0.00698363f, -0.00957081f, 0.03102733f, 
    -0.00373338f, -0.05562465f, -0.00004705f, -0.00478769f, -0.03525936f, 0.01639736f, -0.00815628f, 0.03317792f, 
    -0.02874911f, -0.03955610f, 0.02035871f, 0.01085047f, -0.04913807f, 0.00376271f, -0.06112752f, -0.02578940f, 
    -0.01414511f, -0.05295352f, 0.01845039f, -0.03471655f, -0.04079184f, 0.02225812f, -0.03601044f, -0.02932920f, 
    -0.05976185f, 0.00229305f, 0.03234738f, 0.00107856f, 0.03032169f, 0.05081847f, -0.01665008f, 0.04260087f, 
    -0.04441064f, -0.03990396f, -0.04862043f, 0.03755791f, -0.05024451f, -0.03165798f, 0.04519949f, -0.02904615f, 
    0.00639948f, 0.02694743f, 0.00062308f, 0.01659309f, -0.02674290f, -0.02396865f, -0.04417843f, -0.01325486f, 
    0.01100012f, 0.00349210f, 0.03867058f, -0.02745868f, -0.02019221f, -0.04660793f, 0.04218374f, -0.01023814f, 
    0.00676988f, 0.01265145f, -0.02477486f, 0.00596844f, -0.05209598f, -0.00557182f, 0.03578170f, -0.01305814f, 
    0.02149770f, -0.00441153f, 0.01618387f, -0.00138248f, 0.01102586f, -0.00611221f, -0.06915537f, 0.01018170f, 
    -0.03350082f, 0.02246204f, -0.00793362f, 0.04711929f, -0.01970268f, -0.04681057f, 0.00095055f, 0.01708128f, 
    -0.03159188f, -0.01741701f, 0.01768924f, -0.00971070f, -0.03051218f, -0.02982643f, -0.03250283f, 0.00548919f, 
    -0.01875192f, -0.04434123f, 0.00847883f, 0.02411045f, 0.02180748f, 0.02732656f, 0.04950131f, 0.01254790f, 
    -0.05029245f, -0.05797226f, -0.04611835f, -0.01160478f, 0.02181834f, -0.03624764f, -0.04585440f, -0.02412569f, 
    -0.01048850f, -0.03510702f, -0.02588017f, -0.01896103f, -0.03444963f, -0.02816094f, -0.06914721f, -0.05367780f, 
    -0.05913618f, -0.00608494f, -0.04704754f, -0.01660608f, 0.01186757f, 0.03997445f, 0.03313012f, -0.02336319f, 
    -0.02469074f, 0.02672962f, -0.02555286f, -0.02691973f, 0.01301187f, -0.06300538f, -0.02821777f, 0.00939582f, 
    -0.00130585f, 0.02643310f, -0.00406490f, 0.02451778f, 0.00540919f, 0.03609302f, -0.03632205f, 0.02104416f, 
    0.01931263f, -0.03733494f, -0.06119263f, 0.04283701f, -0.06522120f, -0.05345853f, -0.01456830f, -0.01824658f, 
    -0.05666164f, 0.03290479f, 0.02810466f, -0.02556133f, 0.04384091f, -0.05905642f, -0.03343508f, -0.01717607f, 
    -0.02049300f, -0.05941876f, -0.03745879f, -0.02091669f, 0.03378635f, -0.01652650f, 0.01975985f, -0.03811059f, 
    0.01051196f, 0.01351502f, -0.00246060f, -0.06294975f, -0.01271329f, -0.01164676f, -0.01523994f, 0.01390088f, 
    0.00231818f, 0.03570123f, 0.02968521f, -0.06701916f, 0.02832547f, -0.02252434f, -0.03152256f, -0.03051871f, 
    -0.03315962f, 0.01310242f, -0.04883607f, 0.04309291f, -0.06660700f, -0.05097398f, 0.04101749f, -0.01172853f, 
    0.02867933f, -0.00960307f, 0.01310723f, -0.05422844f, -0.04446468f, -0.04746829f, -0.00786876f, -0.03070894f, 
    -0.05851936f, 0.03801777f, -0.05086042f, -0.01333963f, 0.02241927f, 0.03283326f, 0.04447082f, -0.05454488f, 
    0.01036580f, 0.01674691f, 0.01593905f, 0.02904706f, -0.05728411f, 0.03205156f, 0.03376615f, 0.02758147f, 
    -0.01766794f, 0.00255427f, 0.01856714f, -0.00605542f, 0.00031289f, 0.04562078f, 0.00702273f, 0.03757887f, 
    0.01588993f, 0.03947480f, 0.03956006f, 0.04848528f, -0.05998546f, 0.01040281f, -0.00008532f, 0.01561784f, 
    0.01413681f, -0.03705446f, -0.01327436f, -0.00786172f, -0.03264504f, 0.03161610f, 0.01545230f, -0.04721746f, 
    0.02499660f, 0.04499590f, -0.02274065f, 0.03545065f, -0.06686582f, -0.00022820f, 0.02430295f, -0.03935827f, 
    -0.04393524f, 0.02461797f, -0.00912795f, 0.02194183f, -0.04586761f, 0.00969673f, 0.02122791f, -0.03333749f, 
    0.00511869f, 0.03511810f, -0.04220232f, -0.04307748f, 0.04240211f, 0.02752204f, 0.00329228f, 0.01878363f, 
    -0.01463984f, -0.03255406f, 0.02531461f, 0.01342371f, -0.05976052f, 0.05354150f, -0.01148338f, -0.06217583f, 
    -0.02795515f, -0.00437049f, -0.02702379f, 0.02884163f, 0.02218947f, 0.00489510f, -0.01416571f, -0.05998963f, 
    0.03219067f, -0.03382537f, 0.03974194f, 0.04886241f, -0.03498160f, 0.03056090f, 0.01684066f, 0.01403610f, 
    -0.01992662f, 0.01935826f, -0.00058458f, -0.02155984f, 0.03822343f, 0.03137925f, -0.04702776f, 0.02829332f, 
    0.02536767f, -0.04889798f, -0.00048765f, -0.03392135f, -0.01162750f, 0.01123937f, -0.05486969f, -0.00673118f, 
    0.02388322f, 0.03729166f, 0.02570136f, 0.00671108f, -0.02914215f, 0.03586784f, -0.01616061f, -0.04426463f, 
    -0.04418759f, 0.02374549f, 0.04627740f, 0.03293634f, 0.03935711f, 0.00463134f, -0.05335320f, -0.04728675f, 
    -0.05827421f, -0.04571773f, -0.05491298f, -0.06430770f, 0.02701907f, -0.04230172f, 0.04450475f, 0.00338590f, 
    -0.01779588f, 0.04813603f, -0.04751861f, -0.01189301f, -0.01132591f, 0.03494833f, -0.00499950f, -0.03433068f, 
    0.02071708f, -0.03941360f, -0.00153928f, -0.00590396f, -0.03675855f, -0.01893710f, 0.04941583f, -0.03445570f, 
    -0.00679409f, -0.00882361f, 0.02127535f, 0.01554158f, -0.01594461f, -0.00421323f, -0.05058009f, -0.03191996f, 
    -0.03319986f, -0.01182836f, -0.04188060f, -0.06023051f, -0.00548602f, -0.02548745f, -0.05270690f, 0.02102158f, 
    0.01078560f, -0.03876116f, 0.05309337f, 0.01359663f, 0.01197715f, 0.00857774f, 0.02407233f, -0.04123261f, 
    -0.00694425f, -0.03894518f, -0.00695329f, -0.01599464f, 0.02079925f, -0.02364376f, -0.04163731f, 0.04413467f, 
    -0.02651932f, -0.05026552f, -0.01774229f, 0.04714776f, -0.02300027f, 0.01028890f, -0.04653283f, 0.04296755f, 
    -0.03375965f, -0.04011852f, -0.04491738f, 0.03515857f, -0.04350726f, 0.00192507f, -0.02349368f, 0.00723129f, 
    -0.02645734f, 0.04292431f, 0.01453843f, -0.01791741f, 0.02660771f, -0.05712272f, -0.05583658f, 0.04275627f, 
    -0.02380140f, 0.03777091f, 0.00066948f, -0.03906263f, -0.04104052f, 0.03983630f, -0.03982208f, -0.05074988f, 
    0.03883186f, -0.03826110f, -0.00427630f, 0.03003518f, 0.03422942f, 0.04512591f, 0.04820243f, 0.04280563f, 
    0.00368777f, -0.04454850f, -0.02036257f, 0.01401560f, -0.02256162f, 0.01437952f, -0.04434506f, -0.03634094f, 
    0.00695263f, -0.03308200f, -0.05310077f, -0.06420884f, 0.03157679f, 0.01084753f, 0.02203023f, 0.04713271f, 
    -0.05373555f, -0.02267520f, -0.01861594f, -0.01703230f, 0.02942451f, -0.00915450f, 0.02548625f, -0.01474396f, 
    -0.04648047f, -0.04767349f, 0.02573387f, 0.01585031f, -0.01680635f, 0.01217747f, 0.03530900f, 0.00825472f, 
    -0.03824682f, 0.02817612f, 0.03686742f, 0.04579789f, -0.04705105f, -0.00948826f, -0.04555319f, -0.05648153f, 
    -0.04745580f, 0.05248645f, 0.03529148f, -0.02922885f, -0.04381940f, 0.00301831f, 0.02698193f, -0.01783852f, 
    -0.04273098f, 0.02780149f, 0.01977467f, -0.03290269f, -0.03589836f, 0.01416587f, 0.02584476f, 0.02267933f, 
    -0.03490718f, -0.05802195f, -0.01729671f, -0.02737976f, 0.03052725f, -0.02768246f, 0.01474631f, 0.03840300f, 
    0.05367808f, -0.05526075f, 0.03203375f, -0.01373401f, 0.02063046f, 0.00099906f, -0.05436148f, 0.04642500f, 
    -0.03504547f, 0.02764096f, -0.05214086f, 0.00408152f, -0.03201814f, -0.04245419f, 0.04519008f, 0.01702923f, 
    -0.03209441f, -0.05594932f, 0.01639273f, -0.05538576f, -0.04347871f, -0.04723530f, -0.02188680f, 0.02509831f, 
    0.03667467f, -0.05236952f, -0.04025669f, 0.03264886f, -0.03793842f, 0.04360460f, -0.03351406f, 0.04134991f, 
    0.03670187f, -0.05922232f, -0.01280064f, 0.01112364f, 0.03028892f, -0.02277818f, 0.01237009f, -0.00142377f, 
    0.03184536f, -0.03987414f, 0.02793005f, 0.00309837f, 0.00313368f, 0.00913634f, 0.03270563f, -0.01979417f, 
    0.04794754f, 0.04318585f, 0.00205518f, 0.01893254f, -0.02232423f, -0.03646859f, -0.02763463f, 0.04372543f, 
    -0.05408038f, -0.01395610f, -0.03527336f, -0.02847888f, 0.03854644f, -0.05253700f, 0.02418627f, -0.02472074f, 
    -0.02661229f, -0.00958932f, -0.01028306f, -0.05971486f, -0.03209072f, -0.05810415f, -0.00567859f, 0.01157208f, 
    0.01256753f, -0.03608196f, -0.02276485f, 0.04205443f, 0.00315800f, -0.05881844f, 0.03426392f, -0.01547865f, 
    -0.06083385f, 0.04827389f, 0.05857784f, 0.00000357f, -0.01225079f, 0.01110623f, -0.03797785f, -0.02060880f, 
    0.01223730f, 0.00429460f, 0.04044841f, -0.05346270f, -0.00857875f, -0.00058368f, -0.04648397f, -0.00831361f, 
    0.00928668f, 0.02704579f, -0.02064258f, -0.01865132f, -0.01853372f, -0.04770429f, 0.03509214f, 0.02379582f, 
    0.01578510f, -0.03431225f, 0.05097983f, 0.00365309f, -0.00618320f, -0.02464478f, 0.01712660f, -0.01232468f, 
    0.00453718f, -0.05413613f, 0.04806075f, 0.00558120f, 0.02248793f, -0.04357560f, -0.00035778f, -0.00931022f, 
    0.01136880f, 0.01754589f, 0.01049326f, 0.03043346f, 0.03858253f, -0.05884594f, 0.03378179f, 0.03438934f, 
    -0.02419720f, 0.00071959f, -0.03385529f, -0.06271683f, -0.02313894f, -0.06152407f, -0.03325420f, 0.00529992f, 
    0.06799519f, 0.31229064f, 0.23745416f, -0.05729390f, -0.03145174f, 0.12164421f, 0.04104723f, 0.12610142f, 
    0.08745345f, 0.03720963f, -0.01453861f, 0.06391651f, -0.00236395f, 0.12207086f, 0.00998229f, 0.10944112f, 
    0.03558092f, -0.01731504f, 0.11476701f, 0.00509331f, -0.14633283f, 0.08616645f, -0.23370920f, -0.05240539f, 
    -0.04432977f, -0.17463675f, -0.36756396f, -0.11346582f, -0.10072017f, -0.01808286f, 0.14182647f, -0.02101769f, 
    -0.04774045f, 0.11016852f, 0.12497901f, 0.06225983f, -0.17383552f, 0.12489884f, 0.07957673f, -0.02092878f, 
    -0.26606441f, 0.03442420f, 0.21398017f, 0.09867916f, 0.11597311f, -0.11422282f, 0.12533520f, 0.11649955f, 
    0.17001246f, 0.15756947f, -0.03487499f, -0.00934310f, 0.16975212f, 0.06583126f, 0.12773795f, -0.00390662f, 
    0.13485189f, 0.06470282f, -0.03424517f, 0.08100525f, 0.39594319f, 0.12571594f, 0.36800733f, -0.19289254f, 
    -0.22066453f, 0.01801026f, 0.06027485f, 0.02487043f, 0.24267745f, 0.08255270f, 0.07534464f, -0.03988298f, 
    -0.00785387f, -0.01224366f, 0.02453711f, 0.06571819f, 0.15813586f, 0.16072609f, 0.10355604f, 0.02243116f, 
    0.09516770f, -0.10955714f, -0.10446181f, -0.08222353f, 0.02563396f, -0.10852442f, -0.16388951f, 0.09311216f, 
    -0.07336476f, 0.10500076f, -0.02815511f, 0.00888823f, 0.09189893f, -0.02508305f, -0.08212523f, -0.10715438f, 
    -0.05501791f, 0.10708586f, 0.07587646f, 0.04774498f, -0.07175554f, -0.26327586f, 0.29069158f, 0.05297281f, 
    0.08193335f, -0.12176659f, -0.09129553f, -0.17569128f, -0.26784867f, 0.22979774f, 0.05422104f, -0.02364911f, 
    -0.08420242f, 0.02964199f, 0.00691034f, -0.07453319f, -0.07573700f, 0.10869028f, -0.07869925f, 0.01415266f, 
    -0.21896012f, -0.05909149f, -0.01430903f, 0.09291088f, 0.11723073f, -0.13339339f, -0.00449131f, -0.46612799f, 
    -0.01561759f, -0.03293033f, 0.00084053f, -0.00732940f, -0.15564559f, -0.09423292f, 0.08471331f, 0.09740579f, 
    -0.07445978f, 0.00872303f, 0.06052075f, 0.06228045f, -0.16119744f, 0.06148918f, -0.35939771f, -0.29821572f, 
    0.09340922f, -0.21599481f, -0.02212901f, 0.03616697f, 0.39586198f, -0.05682053f, 0.03985777f, 0.07718237f, 
    -0.05871424f, 0.11492466f, 0.06344556f, 0.17680728f, 0.00141831f, 0.06139447f, -0.07788714f, -0.01652957f, 
    -0.05118418f, 0.06814647f, 0.33524817f, -0.17745669f, -0.10878035f, 0.20467247f, 0.08251341f, -0.05260877f, 
    0.10145658f, -0.04730943f, -0.02444087f, -0.02692069f, 0.01268919f, -0.02283488f, 0.00691522f, -0.02457489f, 
    0.06180297f, 0.01115256f, -0.06239367f, 0.12775256f, 0.46897662f, -0.04200711f, 0.38713118f, -0.09667968f, 
    0.26370195f, -0.07762205f, 0.08685587f, 0.12330642f, -0.15990233f, 0.01666931f, -0.09708927f, -0.05577158f, 
    0.01897697f, 0.04067855f, 0.06531175f, 0.08686276f, 0.05487575f, -0.00442901f, -0.05493831f, -0.06477361f, 
    0.51661789f, 0.19670612f, -0.35539335f, -0.08784187f, 0.17567201f, -0.02442429f, -0.29329982f, 0.03987527f, 
    -0.06982463f, 0.08078603f, 0.05696073f, 0.11307427f, 0.16694458f, 0.00296949f, 0.11395013f, -0.00668611f, 
    -0.03351811f, 0.00670078f, 0.23517641f, 0.14580230f, 0.25757995f, -0.12902334f, -0.16881889f, -0.19954102f, 
    -0.20304245f, 0.19385920f, -0.02317777f, -0.24442212f, 0.08772266f, 0.02840573f, 0.07494058f, 0.14321406f, 
    0.08085260f, 0.03151538f, 0.01334197f, 0.02976482f, -0.14872307f, -0.19158424f, 0.12094268f, 0.06128489f, 
    0.05294970f, 0.14058647f, 0.51127988f, -0.12225943f, -0.10303907f, 0.03209200f, 0.17300968f, 0.09675214f, 
    -0.03601196f, -0.12775677f, -0.04263095f, -0.07195846f, -0.07280815f, 0.07892001f, 0.02098846f, 0.05680547f, 
    0.05542683f, 0.04892564f, -0.09812190f, -0.00455302f, -0.57681519f, -0.13339607f, 0.54649079f, 0.09993949f, 
    0.11055735f, 0.04588197f, -0.23087840f, -0.31807652f, -0.15846190f, -0.18107684f, -0.02950980f, -0.02645264f, 
    0.08848386f, -0.05309767f, -0.04258993f, 0.06862491f, -0.02503572f, 0.15301836f, 0.08288143f, 0.02461943f, 
    -0.26389533f, -0.16045767f, 0.08648980f, -0.09156279f, 0.09614228f, -0.15092947f, 0.04510063f, 0.11708003f, 
    -0.03786832f, 0.07543004f, 0.13603811f, 0.10703663f, -0.12433966f, -0.03757238f, 0.10918518f, 0.02517197f, 
    0.08422941f, 0.04727216f, 0.13084389f, -0.15330608f, 0.53547728f, 0.16658960f, -0.11559454f, -0.00254570f, 
    -0.04850933f, 0.09908887f, -0.05082896f, 0.16281874f, 0.17926803f, -0.08617527f, 0.06668677f, -0.08250263f, 
    -0.03259815f, -0.01674845f, 0.14424036f, 0.01812446f, 0.04681303f, -0.14214022f, -0.09191705f, -0.06559823f, 
    0.13192655f, 0.22994226f, 0.07555231f, 0.02190794f, -0.05802022f, 0.09555381f, 0.14637880f, 0.16120978f, 
    0.05324332f, 0.08661984f, -0.05742531f, 0.03156294f, 0.07750963f, 0.05296313f, 0.07152224f, 0.05213082f, 
    -0.16522613f, -0.12377901f, -0.04613429f, -0.16757336f, 0.01173883f, 0.04193655f, 0.10075404f, 0.17309268f, 
    0.05089123f, -0.00195629f, -0.05288311f, 0.00354291f, -0.02065819f, -0.03028880f, 0.05599703f, 0.03559039f, 
    0.02886255f, 0.14798124f, 0.09128772f, -0.17394677f, -0.05534870f, 0.05309297f, -0.02838981f, -0.03872827f, 
    -0.55337262f, -0.24775115f, 0.34183672f, -0.19968265f, 0.11995417f, 0.08263346f, 0.33251727f, 0.17817628f, 
    0.16238295f, 0.09330794f, -0.06392986f, -0.11314297f, -0.06471678f, -0.05908645f, 0.00651301f, 0.09752672f, 
    0.05988972f, -0.00763440f, 0.00729559f, 0.00189334f, 0.16871513f, 0.17980549f, 0.15142085f, -0.39609545f, 
    -0.12873417f, 0.12361200f, -0.14869165f, 0.05112368f, 0.15220198f, -0.04162601f, 0.02080901f, -0.02069113f, 
    0.02838872f, -0.04183000f, 0.00956156f, 0.04526465f, -0.05259426f, -0.00591226f, -0.11573737f, -0.20392443f, 
    0.00473915f, -0.05785452f, 0.05595208f, 0.15799272f, 0.07721708f, 0.04659993f, 0.00584725f, 0.03063143f, 
    0.03059091f, 0.00425152f, 0.22130208f, 0.12227692f, 0.13002583f, 0.22255053f, 0.12790267f, -0.03609031f, 
    0.02722144f, -0.02576415f, 0.11937281f, 0.10879887f, 0.14385815f, -0.04079479f, 0.35407773f, 0.06466592f, 
    0.05974147f, 0.00236314f, -0.00177707f, 0.04229300f, -0.02766550f, 0.06033441f, -0.05356403f, -0.04567709f, 
    0.02343717f, 0.12254810f, 0.08504465f, 0.21693707f, -0.05830916f, 0.09231056f, 0.02164670f, -0.01917965f, 
    0.17219140f, 0.06171900f, 0.19801466f, 0.26797214f, 0.11249993f, -0.07238743f, -0.02082167f, -0.09318557f, 
    0.04398189f, 0.06046812f, -0.14045283f, 0.00454784f, 0.00174223f, -0.00394060f, 0.00584874f, 0.00356308f, 
    0.18443428f, -0.01047863f, -0.01916181f, 0.01427889f, -0.44062987f, -0.13496551f, -0.12203108f, -0.27730069f, 
    0.27147418f, -0.13123927f, 0.16499865f, 0.15836425f, 0.25000018f, -0.02673219f, 0.15202326f, 0.15943947f, 
    -0.10232776f, 0.14164750f, 0.09036340f, -0.11577225f, -0.07568453f, 0.01648220f, 0.09644660f, -0.09546841f, 
    0.03665675f, 0.05410982f, 0.21444103f, -0.21052696f, -0.21089752f, 0.15181077f, -0.11634710f, -0.00180291f, 
    0.03941786f, -0.09923895f, -0.19488120f, 0.03311127f, 0.00253949f, -0.04060805f, 0.05050810f, 0.02540440f, 
    -0.03640901f, 0.17368114f, -0.01999464f, 0.09888757f, 0.34179485f, 0.00553730f, 0.14302845f, 0.11960217f, 
    0.04210940f, 0.21579215f, 0.04137341f, 0.09783652f, 0.03085806f, 0.18017797f, -0.06636298f, -0.10604063f, 
    -0.05468147f, -0.04574282f, 0.08649873f, 0.07638807f, -0.03583298f, -0.07284208f, 0.03461273f, 0.06015892f, 
    0.34310314f, -0.00268124f, 0.07354549f, 0.22014192f, 0.18056399f, -0.10968603f, -0.10229215f, 0.08523431f, 
    0.02183540f, -0.09993676f, 0.02290650f, 0.07231538f, 0.03681811f, 0.13921373f, 0.09609007f, 0.06939036f, 
    0.02640292f, 0.01461720f, 0.06915510f, 0.07212418f, 0.05038516f, -0.05457429f, 0.07345376f, 0.02764309f, 
    -0.18787631f, 0.01874102f, -0.04604635f, -0.20135078f, -0.09756918f, -0.16613288f, 0.03497159f, -0.01814936f, 
    0.04835569f, -0.11028437f, 0.00382153f, -0.13030761f, 0.11608586f, -0.09857782f, 0.24498253f, 0.23957507f, 
    0.21261114f, 0.28842306f, -0.04230071f, -0.17938328f, -0.10527121f, 0.08645386f, 0.09500799f, 0.19188055f, 
    -0.12508011f, 0.14022239f, -0.10721051f, -0.10277275f, -0.05601749f, -0.05139976f, 0.04733738f, 0.11477072f, 
    -0.07086783f, -0.06880216f, -0.03152584f, 0.05824002f, 0.04952042f, 0.13949700f, 0.23968077f, 0.24770699f, 
    0.01857969f, -0.00302033f, -0.06562802f, -0.09191447f, -0.04535161f, -0.07868429f, -0.18617158f, 0.00932015f, 
    -0.03008082f, 0.00066312f, -0.00368864f, 0.10904227f, 0.05080299f, 0.10121444f, 0.00283750f, 0.03194223f, 
    0.13592011f, -0.37124470f, -0.47324073f, -0.01381623f, -0.01575866f, 0.03701424f, 0.06829538f, 0.13944492f, 
    -0.03794413f, 0.03023746f, 0.13984923f, 0.02088670f, -0.05092894f, 0.00913387f, 0.07136469f, -0.06837221f, 
    -0.01939605f, -0.02440708f, 0.02094496f, -0.12135101f, -0.04152986f, 0.12509011f, -0.08687322f, -0.04863343f, 
    -0.17211780f, -0.10222469f, 0.08731074f, 0.21164663f, 0.12396271f, -0.11596472f, -0.01466848f, -0.09679516f, 
    -0.15460807f, -0.16281191f, -0.08768503f, -0.09159464f, -0.00516400f, -0.04621318f, 0.00080957f, 0.02459388f, 
    -0.01422024f, 0.13306440f, 0.18845876f, 0.04458528f, -0.00263818f, 0.02355137f, 0.07125238f, 0.20776644f, 
    0.05140616f, -0.09159553f, -0.02097728f, -0.00231593f, 0.06906081f, 0.05075746f, 0.06334672f, 0.07946317f, 
    0.06942669f, 0.13922606f, 0.00349993f, -0.05355025f, -0.02362925f, -0.06296273f, -0.12794080f, -0.06184009f, 
    0.16634499f, 0.02154388f, -0.01560303f, -0.08524358f, -0.02477021f, 0.03667700f, 0.10967274f, -0.09716401f, 
    0.02569980f, -0.07130139f, -0.04170206f, 0.12527137f, 0.04989181f, 0.01113921f, 0.00520022f, -0.06391475f, 
    -0.64277542f, 0.28307930f, -0.07276299f, 0.36929250f, -0.09003859f, -0.12707920f, -0.06003096f, -0.07165763f, 
    0.09308300f, 0.32317734f, 0.08583164f, 0.04608824f, 0.04239326f, 0.08022398f, 0.00507202f, -0.00596501f, 
    -0.05898256f, -0.02420313f, 0.13127318f, 0.15525192f, -0.07387078f, -0.28513533f, 0.19520600f, 0.11263864f, 
    -0.37720925f, 0.03285645f, 0.13921700f, 0.02307699f, -0.06843161f, -0.02423679f, -0.02486048f, -0.01110758f, 
    0.00055139f, 0.06946584f, 0.04211630f, -0.02304484f, -0.01992893f, -0.01476489f, 0.25096405f, 0.06171334f, 
    0.07079951f, 0.01027328f, 0.06830406f, 0.07424859f, 0.01043098f, -0.05663037f, -0.05361236f, -0.04463993f, 
    0.04885590f, 0.00465681f, 0.03233626f, -0.03876043f, 0.04488665f, 0.13752268f, 0.09313860f, 0.00056900f, 
    -0.02459277f, -0.12669095f, 0.05714402f, 0.06785136f, -0.19096993f, -0.15867697f, -0.37373105f, 0.15819514f, 
    0.12266245f, -0.06450316f, 0.05306621f, 0.04254267f, 0.03699224f, 0.11960470f, -0.12955715f, 0.08777958f, 
    0.00736912f, -0.04504738f, -0.09062589f, -0.04645558f, 0.02654271f, -0.13017538f, -0.03540573f, 0.00579553f, 
    0.25372607f, -0.24762009f, -0.61178148f, -0.04180631f, 0.18482414f, 0.04515698f, 0.11834627f, 0.18897195f, 
    0.05474940f, -0.05149816f, 0.06080807f, -0.05042886f, -0.04495066f, -0.07046983f, -0.01509967f, 0.00533064f, 
    -0.09549470f, 0.01328852f, -0.06623439f, 0.02400596f, -0.81357968f, 0.43014622f, 0.21005900f, 0.58409381f, 
    0.06018119f, -0.07018810f, -0.15955038f, -0.06089836f, -0.02173111f, 0.06644703f, 0.23377979f, -0.03673272f, 
    0.02186252f, 0.07797717f, -0.03027633f, -0.05049755f, -0.00864614f, 0.06906855f, -0.07135082f, -0.04248444f, 
    0.02326169f, 0.02916566f, -0.20695204f, 0.01026785f, -0.02835464f, 0.12235214f, 0.15927958f, 0.13182968f, 
    -0.00797785f, -0.01700081f, 0.02603929f, 0.04809518f, -0.03622577f, -0.01380838f, -0.00742161f, 0.08357386f, 
    0.06720934f, 0.04830461f, 0.12441802f, 0.07935253f, 0.00972084f, -0.10055037f, -0.02292962f, -0.06489811f, 
    -0.11547019f, 0.05167032f, -0.02318007f, -0.09727031f, -0.00567730f, 0.06180191f, 0.04466172f, 0.13400064f, 
    -0.00961758f, 0.25672749f, -0.01695188f, -0.04487824f, -0.00107864f, 0.05546166f, 0.01303474f, 0.13031876f, 
    0.00427586f, -0.47512496f, -0.11121912f, 0.00157164f, 0.20148474f, 0.03747232f, 0.01275783f, -0.04966005f, 
    0.08410350f, -0.04945911f, 0.13566305f, -0.07871538f, -0.03660620f, 0.13531449f, 0.14819302f, 0.07265343f, 
    0.05582966f, 0.07327780f, 0.20959221f, 0.18346345f, 0.13412513f, -0.13785975f, -0.02157469f, -0.02141468f, 
    0.06461950f, -0.27694613f, 0.03586069f, 0.00182348f, -0.04904141f, -0.21561132f, 0.16364025f, -0.12276459f, 
    0.01106345f, -0.05813040f, 0.02223209f, 0.13614145f, -0.00797459f, -0.05350114f, 0.11070247f, 0.00134057f, 
    -0.23270468f, -0.23242703f, 0.14531253f, 0.10959973f, -0.28756610f, 0.00088981f, 0.04964434f, -0.09393014f, 
    -0.13064982f, -0.04958916f, -0.03354703f, 0.02037592f, 0.06681176f, 0.11704433f, -0.14804986f, 0.06404079f, 
    -0.00646599f, -0.12186392f, 0.13897842f, -0.01664621f, 0.10045650f, -0.20514065f, -0.47105426f, -0.15829888f, 
    0.14611505f, 0.08548482f, 0.14229727f, 0.17620565f, -0.05063832f, 0.17253287f, -0.03726865f, -0.06664965f, 
    -0.00086161f, -0.03126061f, -0.04440242f, 0.00862121f, -0.09832039f, 0.05643240f, -0.11360721f, 0.04110476f, 
    -0.32847086f, -0.03260068f, 0.03068201f, -0.20580900f, 0.14769988f, 0.01060869f, -0.06266776f, -0.08541021f, 
    -0.08647417f, -0.02091333f, 0.13309422f, 0.24654055f, 0.13744493f, 0.09290333f, 0.14206266f, 0.04152741f, 
    -0.00445256f, 0.17856355f, -0.04818709f, 0.04084789f, -0.37473002f, -0.00252079f, 0.49303293f, -0.02425296f, 
    -0.19365904f, -0.00270303f, -0.14562203f, -0.21571605f, 0.08773994f, -0.08288891f, 0.02042636f, 0.06684091f, 
    0.00443813f, -0.07550010f, -0.00959861f, 0.03342351f, -0.04040297f, 0.06779430f, 0.05835378f, 0.04111236f, 
    0.14119363f, 0.12958910f, -0.10109530f, 0.07178165f, 0.09737641f, -0.02504625f, 0.11002047f, 0.17030853f, 
    0.16119313f, -0.12856871f, -0.00418400f, 0.03557913f, 0.06189653f, -0.03536957f, 0.07806826f, 0.05891018f, 
    -0.10269395f, -0.04005102f, 0.14980105f, -0.18747368f, -0.09557106f, -0.08814821f, -0.23037951f, -0.00073237f, 
    -0.00531636f, -0.06611687f, -0.03850370f, -0.21012527f, -0.15621850f, -0.04495406f, -0.05589158f, -0.07954057f, 
    -0.03527610f, 0.15982191f, 0.02458891f, -0.09121183f, 0.06110581f, 0.12802105f, -0.01809413f, -0.05257921f, 
    -0.10181426f, 0.14798969f, -0.27236450f, -0.01641491f, 0.08632757f, 0.18800561f, 0.06565537f, 0.05926684f, 
    0.07383583f, 0.08659678f, -0.10951968f, 0.07464813f, 0.03955104f, 0.15078042f, -0.01858240f, 0.11613436f, 
    0.18871002f, 0.10056830f, 0.01580879f, 0.18086554f, 0.01942705f, 0.17902716f, 0.17296721f, -0.20719269f, 
    -0.07395661f, 0.00414530f, 0.04713729f, -0.03940422f, 0.15004911f, -0.06306890f, 0.00143525f, -0.02418229f, 
    -0.04131148f, -0.01138846f, 0.07747760f, -0.07048492f, 0.03922714f, 0.21000135f, -0.05561883f, -0.12258254f, 
    -0.10884578f, -0.13553435f, -0.07151449f, -0.07581113f, -0.00414351f, 0.06573232f, -0.05526991f, -0.06130338f, 
    -0.09536373f, 0.03245877f, 0.11791712f, 0.01579040f, 0.11375071f, 0.08434608f, 0.01867749f, 0.07278755f, 
    0.09630372f, 0.08765223f, -0.04056352f, 0.02279877f, 0.06442632f, -0.10979778f, -0.00683447f, -0.03455270f, 
    0.09404925f, 0.05820486f, -0.19834736f, -0.17701434f, -0.02128729f, 0.12769265f, -0.04291657f, 0.08806843f, 
    -0.02159244f, 0.03415089f, -0.00093530f, -0.03423332f, -0.10827360f, 0.07728533f, 0.02314872f, -0.04345490f, 
    0.02390690f, -0.18201704f, 0.23136277f, 0.09467747f, 0.11310521f, -0.12700996f, 0.11625899f, -0.17357741f, 
    -0.04618319f, -0.08350044f, -0.02185380f, -0.08763938f, -0.00676589f, 0.05463695f, 0.11214112f, 0.07280003f, 
    -0.05123007f, 0.10158648f, 0.10773647f, -0.08238919f, -0.33444420f, 0.41106820f, -0.22946720f, -0.18401389f, 
    0.21026950f, 0.16415001f, 0.06290679f, 0.06688149f, 0.07334372f, -0.03364839f, 0.01564080f, 0.00557575f, 
    0.04012400f, 0.11605173f, 0.10369338f, -0.10150485f, -0.08468572f, 0.02961315f, 0.13712077f, -0.15723212f, 
    0.01191605f, -0.10347192f, 0.13898925f, -0.24549370f, 0.14085998f, 0.09730730f, 0.04338450f, -0.06786043f, 
    0.15970831f, -0.14055537f, 0.01070235f, -0.01339241f, 0.01313546f, 0.05861665f, 0.06276034f, 0.03941368f, 
    -0.04365445f, 0.07815310f, 0.01122595f, 0.10467885f, 0.20196821f, 0.21958773f, -0.23667498f, 0.04775828f, 
    -0.00425162f, 0.07428389f, -0.11050043f, -0.13019629f, -0.13067050f, 0.22465011f, 0.10693856f, 0.04535439f, 
    0.01017954f, -0.00489976f, -0.07678010f, 0.09338909f, -0.08375598f, -0.06292666f, 0.06519541f, 0.15017493f, 
    0.14003411f, 0.44089571f, -0.21500695f, 0.15184812f, 0.05138925f, -0.00481136f, -0.03390202f, -0.01878002f, 
    -0.10066872f, 0.01636284f, 0.02426345f, -0.04900451f, 0.03879189f, 0.00940499f, 0.21564196f, 0.17675601f, 
    -0.02100250f, 0.15152499f, 0.08619218f, 0.04098696f, 0.12667735f, -0.19684514f, -0.16677247f, 0.02790183f, 
    -0.03679948f, -0.08079797f, 0.00955581f, -0.12769185f, 0.08868660f, -0.08170871f, 0.16218241f, -0.13283511f, 
    -0.03660604f, -0.09917907f, -0.04340930f, 0.08719887f, 0.08168525f, 0.05162193f, 0.01550588f, 0.20752093f, 
    -0.17189366f, 0.13680698f, 0.11012357f, -0.16363382f, 0.02889208f, 0.14692825f, 0.00617035f, 0.12661766f, 
    0.01304610f, 0.04350479f, 0.04908255f, 0.05268482f, 0.03068997f, 0.07694413f, 0.03257849f, -0.05925541f, 
    -0.11564897f, 0.04452098f, 0.01373209f, -0.05883203f, -0.19083418f, -0.15932149f, 0.10946319f, 0.01639453f, 
    0.11058419f, 0.10964911f, -0.07191245f, -0.26381937f, -0.07362103f, -0.06460144f, -0.02489885f, -0.04445987f, 
    -0.08989622f, -0.03201137f, -0.00083246f, 0.07958433f, -0.07601909f, 0.11888321f, 0.05125489f, -0.11604812f, 
    -0.05947626f, 0.33419639f, -0.30907303f, -0.16014908f, 0.10085270f, 0.05157631f, 0.09988843f, 0.03276191f, 
    -0.06776732f, 0.01160563f, 0.00003958f, 0.03035384f, 0.15313247f, 0.04545207f, 0.12768321f, 0.04626503f, 
    -0.03971501f, 0.02486486f, 0.07781574f, -0.10464213f, -0.57507181f, -0.14223631f, -0.15660088f, -0.23409703f, 
    -0.02085403f, 0.13003221f, 0.10118094f, 0.17210144f, 0.16031815f, 0.02496550f, -0.01054229f, -0.02533934f, 
    -0.14022467f, -0.01442671f, -0.09767019f, 0.01165783f, 0.03827863f, -0.06711510f, 0.12034588f, 0.02913701f, 
    -0.00236764f, -0.05949492f, 0.04826593f, -0.02658524f, -0.05595320f, 0.02551199f, 0.03156302f, -0.03650643f, 
    -0.02996533f, -0.04109191f, -0.03801531f, 0.04441652f, 0.00745982f, -0.04196518f, -0.04780966f, 0.03314609f, 
    0.01621133f, -0.03131887f, -0.03293718f, -0.01453999f, 0.00685467f, 0.04009317f, -0.03366831f, -0.06033387f, 
    -0.01417772f, -0.02269688f, 0.04261129f, -0.03838135f, 0.03171819f, 0.03707352f, 0.03174475f, -0.03440154f, 
    -0.02269013f, 0.00840933f, -0.01493432f, -0.00890938f, -0.01225641f, 0.01605609f, -0.02020452f, 0.04006759f, 
    0.02238001f, 0.04820129f, 0.02929629f, -0.00286295f, 0.03405517f, -0.04684639f, 0.03348128f, 0.00696123f, 
    -0.01997253f, 0.03998690f, 0.01118592f, 0.02222882f, 0.05531311f, 0.02773470f, 0.00115594f, 0.00572300f, 
    -0.05298655f, 0.00087974f, -0.00041708f, 0.02893576f, -0.03856738f, -0.02089182f, 0.03397740f, 0.04957632f, 
    -0.04903609f, -0.00006157f, -0.02337948f, -0.05447927f, 0.00940946f, -0.02931230f, -0.02137482f, -0.06048233f, 
    -0.05460747f, 0.00214552f, 0.01355597f, 0.02005881f, 0.02951805f, 0.01945024f, 0.02553518f, -0.02363073f, 
    0.01955104f, -0.00375021f, 0.03908300f, -0.01172177f, 0.01673476f, -0.05160429f, -0.00091828f, -0.02909512f, 
    -0.03325092f, -0.03426310f, -0.04462274f, 0.04258553f, -0.02831642f, -0.04850142f, -0.02182637f, 0.00644687f, 
    -0.02948461f, -0.03978981f, 0.00177657f, 0.04604726f, -0.05027542f, 0.05540544f, -0.02353560f, 0.02192280f, 
    0.00005600f, 0.02244853f, 0.03089265f, 0.01742822f, 0.00918228f, -0.00404367f, -0.04567136f, -0.04651006f, 
    0.02057255f, -0.05257333f, 0.02400609f, 0.00239636f, -0.01241980f, -0.01138788f, 0.01945367f, 0.01381062f, 
    -0.05371824f, 0.02771034f, -0.00147674f, -0.00247790f, -0.00953205f, -0.04785908f, -0.01290069f, -0.01632379f, 
    0.03912865f, -0.04059667f, 0.01454161f, -0.05297902f, 0.02159438f, 0.01751854f, 0.02933820f, 0.04234971f, 
    0.03181086f, 0.00554184f, -0.00245662f, -0.03554100f, 0.00380546f, -0.02975641f, -0.02244270f, 0.03208786f, 
    0.02976492f, 0.01012390f, -0.00041261f, -0.05559903f, 0.04680262f, 0.04947282f, -0.01502213f, -0.04536980f, 
    0.05281254f, 0.00561359f, 0.01150923f, 0.00478155f, -0.03024898f, -0.04545600f, -0.03577965f, -0.01612741f, 
    -0.04121571f, 0.00901772f, -0.02152937f, -0.01925786f, -0.05495035f, -0.01037928f, -0.03119766f, -0.00098769f, 
    0.03043595f, 0.02033373f, 0.04481481f, 0.01725841f, -0.01926399f, -0.01226605f, 0.00368570f, -0.01283981f, 
    -0.04547945f, -0.03000845f, -0.03363327f, -0.06086841f, -0.03065755f, 0.04917486f, 0.01111190f, -0.04196908f, 
    -0.00287133f, -0.03269644f, -0.04314591f, 0.05001884f, 0.04810720f, -0.04331158f, -0.01684307f, -0.01219515f, 
    0.00288929f, 0.04420034f, 0.00062362f, 0.04820019f, -0.00009486f, 0.02695519f, 0.01529528f, 0.02866581f, 
    -0.00970251f, 0.00435284f, 0.02594837f, -0.03997882f, -0.03426866f, -0.03105895f, -0.01407551f, -0.04618134f, 
    -0.00711622f, 0.01895382f, 0.03305932f, -0.00340032f, -0.03460079f, 0.03141722f, -0.00515869f, 0.01811126f, 
    0.02590034f, -0.02421881f, -0.03347664f, -0.02080138f, -0.02682299f, -0.02108371f, -0.02627117f, 0.04982975f, 
    -0.00483406f, -0.01257597f, -0.05442658f, -0.03666979f, -0.05316264f, 0.02326543f, -0.03263854f, -0.04565557f, 
    0.01663694f, -0.01544061f, 0.01998152f, -0.01040032f, -0.00181558f, 0.01595831f, -0.05476007f, -0.05304715f, 
    -0.00420368f, 0.03031806f, 0.00779534f, 0.01299604f, 0.03612369f, 0.02943355f, -0.04363817f, -0.02024075f, 
    0.00265337f, -0.04577134f, -0.04876624f, -0.01967490f, 0.02087897f, -0.03742775f, -0.03508297f, 0.00019563f, 
    -0.03145395f, 0.03989001f, -0.00812065f, 0.03768754f, -0.04353624f, -0.00119436f, -0.03407700f, 0.00780343f, 
    -0.01084440f, -0.04989176f, -0.00202289f, -0.01312234f, -0.03616935f, 0.03483660f, -0.03189801f, -0.00828964f, 
    -0.02568946f, 0.04737342f, 0.01478079f, -0.01578975f, -0.01143498f, 0.02376479f, 0.04759947f, 0.03784450f, 
    -0.05699959f, -0.02747057f, -0.03515664f, -0.04379467f, -0.00056432f, 0.01693692f, -0.01901234f, -0.01080795f, 
    -0.00215503f, -0.01212614f, 0.05032587f, -0.04927045f, -0.06098734f, -0.02797044f, 0.05018555f, -0.05094623f, 
    -0.06044490f, 0.04797891f, 0.03494022f, -0.05391254f, 0.02624756f, 0.02071152f, 0.01339670f, -0.02949222f, 
    0.03365141f, -0.00750170f, 0.02427271f, -0.01356844f, 0.04911382f, 0.03624721f, 0.04271989f, 0.00580568f, 
    -0.05241481f, -0.06075363f, 0.02498139f, -0.06039681f, -0.03888850f, -0.02978174f, -0.00261571f, 0.00822946f, 
    0.04541413f, 0.09638501f, 0.00016983f, -0.15225914f, 0.03360517f, 0.03667542f, -0.06377637f, 0.14266999f, 
    0.14761116f, 0.08475658f, 0.03722649f, -0.02291414f, 0.03540676f, 0.08789404f, 0.06530068f, -0.05387284f, 
    0.04176954f, -0.19728553f, -0.00133887f, -0.05956692f, 0.09124884f, -0.04224616f, -0.01584384f, -0.05596134f, 
    0.10512137f, 0.02268854f, -0.00915080f, -0.07249390f, -0.06566279f, -0.05925791f, -0.02451639f, -0.05525288f, 
    0.00743020f, 0.00361334f, 0.01989279f, -0.12094676f, -0.08689159f, -0.11671163f, 0.01622268f, -0.06251891f, 
    -0.93773776f, 0.18033816f, -0.20085806f, 0.15507142f, -0.15636763f, 0.21346034f, -0.01253565f, 0.05989330f, 
    -0.14276920f, 0.07758870f, 0.07172490f, -0.03181846f, -0.05302633f, 0.10784831f, -0.10878104f, 0.03834647f, 
    0.05488523f, 0.03838376f, 0.04833473f, 0.03280913f, 0.07663998f, 0.06016663f, 0.15667959f, -0.04659520f, 
    -0.10857805f, 0.04768864f, 0.00968271f, -0.02682608f, 0.24554193f, 0.06116373f, 0.04789159f, 0.02218411f, 
    0.02974606f, -0.00686205f, 0.04673151f, -0.09441912f, 0.11598723f, -0.03238542f, 0.22855453f, -0.08371978f, 
    0.00763371f, 0.00570097f, 0.01059995f, -0.05752631f, 0.09483840f, -0.09509948f, 0.00566301f, -0.04728453f, 
    -0.08103643f, -0.00475103f, 0.10356434f, 0.08198312f, 0.00215390f, 0.05942063f, -0.03201889f, -0.07711417f, 
    -0.04245788f, -0.01864231f, -0.04033253f, -0.02663874f, -0.03173548f, 0.03988883f, -0.08662975f, 0.19330752f, 
    0.01595150f, 0.00659941f, -0.04887155f, -0.00979815f, -0.03904969f, 0.06685746f, 0.03330912f, 0.02929067f, 
    -0.02428571f, -0.04074483f, 0.00453735f, 0.00111027f, 0.01310835f, -0.02565998f, 0.03384994f, -0.05757564f, 
    0.28374147f, 0.02137199f, -0.31915545f, 0.03739055f, 0.03590823f, 0.09943826f, 0.00708222f, 0.00356044f, 
    -0.11334105f, -0.08541715f, -0.04336696f, -0.10598215f, -0.10785473f, -0.06849623f, -0.04650462f, 0.07885261f, 
    0.08292399f, -0.00501864f, 0.02469116f, -0.06468496f, -0.63128585f, 0.49382356f, 0.03096549f, 0.05722697f, 
    -0.11509753f, 0.11632984f, 0.06013304f, -0.08450053f, 0.02285645f, 0.02223977f, 0.11740208f, -0.03185878f, 
    0.16918579f, -0.03360007f, 0.09905874f, -0.00918052f, -0.03705091f, -0.10429247f, 0.10101886f, -0.18861933f, 
    0.10438097f, 0.34602299f, -0.18238737f, 0.06965763f, -0.09703401f, 0.06814101f, 0.05761024f, -0.11967316f, 
    0.15018360f, 0.04439552f, -0.02747752f, 0.00173887f, -0.00086125f, -0.03773796f, 0.06940469f, 0.01463657f, 
    -0.00097768f, 0.12019455f, 0.03353595f, 0.04605995f, 0.29045847f, 0.14133386f, 0.00490781f, -0.20414704f, 
    -0.17428970f, 0.20254666f, 0.01740250f, 0.10899592f, -0.12524261f, 0.34374467f, 0.06132125f, 0.02173956f, 
    -0.07216933f, 0.06079998f, -0.08673695f, 0.01585840f, -0.04748177f, -0.01134328f, -0.03815965f, 0.08326381f, 
    0.09221583f, -0.26759091f, -0.15776610f, 0.06682613f, 0.27300450f, -0.03534654f, 0.07729419f, -0.15717299f, 
    0.00505876f, -0.03718762f, 0.10229675f, -0.01233335f, 0.02329743f, 0.01379909f, -0.08348230f, 0.18065660f, 
    0.02091573f, -0.00207560f, 0.01675939f, 0.10405058f, 0.07688209f, 0.01140053f, 0.07245582f, -0.10586375f, 
    0.02040598f, -0.07050741f, 0.16230907f, 0.00198631f, 0.05083998f, -0.19532615f, 0.05065145f, -0.10313818f, 
    -0.01143888f, 0.03766651f, -0.00216373f, -0.03323497f, 0.06201605f, 0.03116884f, -0.06454238f, 0.04831127f, 
    0.28943333f, 0.25244185f, 0.21938010f, -0.37623700f, -0.19215332f, 0.07653763f, 0.01455441f, 0.06628786f, 
    0.14690991f, 0.10552520f, 0.08110241f, -0.01450098f, 0.07229324f, -0.01672722f, 0.08621681f, -0.02689618f, 
    0.00598558f, -0.00764657f, -0.05810457f, 0.01112306f, 0.10381041f, 0.03560915f, -0.25856584f, 0.07511341f, 
    0.14173499f, 0.08057754f, 0.11206943f, -0.00906971f, -0.07479118f, -0.01573086f, -0.02121869f, -0.03055208f, 
    -0.08351773f, -0.04082149f, -0.05381865f, 0.10910384f, 0.07731806f, 0.09579737f, 0.02027612f, -0.07031222f, 
    0.45222378f, -0.16171107f, -0.29322952f, -0.07436235f, -0.03639141f, 0.05028640f, -0.07719119f, 0.03604271f, 
    -0.05593298f, -0.04216265f, 0.04167933f, 0.11660182f, 0.14171228f, -0.00262580f, 0.03989282f, 0.04983290f, 
    0.00605310f, 0.05735363f, -0.04682308f, 0.13617562f, -0.02300699f, 0.04427343f, 0.01062595f, -0.25209999f, 
    -0.19600831f, 0.04320687f, 0.17601830f, 0.03477178f, 0.09172218f, 0.17558546f, 0.08232640f, -0.02035223f, 
    -0.04736434f, 0.00472056f, 0.03423721f, -0.03921636f, 0.06338799f, -0.01495142f, -0.03653171f, 0.01714153f, 
    -0.13103734f, -0.07378293f, -0.22654271f, 0.10592916f, 0.05350416f, 0.00730727f, 0.17809029f, -0.00705907f, 
    -0.04659927f, 0.05818166f, 0.00659515f, 0.02485289f, 0.09071246f, 0.07556747f, 0.19047727f, 0.09580788f, 
    0.15486230f, 0.12831092f, 0.11033226f, 0.18362789f, 0.05826083f, -0.00656725f, 0.01979926f, 0.07910596f, 
    0.01274719f, -0.06385004f, 0.03932803f, 0.02425818f, 0.05946678f, -0.06348050f, -0.04624154f, 0.08241814f, 
    0.06547946f, 0.05155726f, 0.03864092f, -0.06253012f, -0.01577433f, -0.07358535f, -0.06838818f, -0.04232719f, 
    -0.60583639f, -0.31254280f, 0.15818226f, -0.27827725f, 0.11033434f, 0.16628674f, 0.00142404f, -0.09967090f, 
    0.11470425f, 0.01288210f, 0.06739037f, 0.14663443f, -0.01465571f, -0.05662813f, -0.09685554f, 0.01314751f, 
    0.12532701f, -0.07649644f, 0.10916074f, 0.02241271f, -0.30703986f, -0.23226438f, -0.43589929f, -0.16164264f, 
    0.16144687f, -0.00559902f, -0.18616675f, 0.04367465f, -0.18649742f, -0.25319672f, 0.04859112f, 0.03316526f, 
    0.12915626f, 0.11985600f, 0.07647840f, -0.02893591f, 0.06268229f, 0.10346027f, -0.11200007f, -0.06580442f, 
    -0.10385002f, -0.02790344f, 0.13144228f, 0.04731828f, -0.00507174f, -0.05388944f, 0.04644652f, 0.03959843f, 
    -0.04146415f, 0.02751257f, 0.33200243f, 0.22477455f, 0.14992717f, 0.21624987f, 0.16098675f, -0.01319122f, 
    0.04539457f, -0.12870060f, -0.01413629f, -0.00115064f, 0.13600475f, 0.08829696f, 0.16499241f, -0.09255543f, 
    0.12913068f, 0.06931929f, 0.10750129f, 0.02789518f, 0.05281754f, -0.05011381f, 0.04864910f, -0.02085223f, 
    -0.01531684f, 0.06406661f, 0.01021212f, 0.11845437f, 0.19186065f, -0.19737843f, 0.07844684f, 0.02157077f, 
    0.25383055f, -0.01131207f, 0.08324486f, 0.01402615f, -0.07611994f, 0.03934379f, 0.01479869f, 0.00999149f, 
    0.03051745f, -0.05526151f, -0.12694505f, -0.03072687f, -0.09517067f, 0.02837574f, -0.01973335f, 0.15799093f, 
    0.37286553f, 0.17790192f, 0.00982231f, 0.11443807f, -0.52128667f, -0.40048000f, -0.01249998f, 0.10312383f, 
    0.14618509f, -0.07666463f, 0.05577710f, -0.01548922f, 0.00405857f, 0.19407611f, 0.12225389f, 0.12477789f, 
    0.32662755f, -0.04967967f, -0.00411985f, -0.02340044f, -0.08701938f, -0.09757631f, 0.15540232f, 0.02632149f, 
    0.19126564f, -0.04408415f, -0.03547334f, 0.06361586f, -0.00162638f, 0.01668020f, -0.15755059f, 0.11305650f, 
    -0.07991485f, -0.06450934f, 0.02314264f, -0.06718680f, 0.01858500f, 0.04221588f, 0.07184862f, 0.12314245f, 
    0.05705879f, 0.13578548f, 0.14928117f, 0.08820558f, -0.04550124f, -0.09183256f, -0.17155303f, 0.19205430f, 
    -0.00849226f, 0.01325983f, 0.05100202f, 0.09329703f, 0.12053743f, -0.07461973f, 0.00149056f, -0.02869523f, 
    -0.04265385f, 0.08596835f, 0.02163822f, 0.05220952f, 0.04303752f, -0.01294918f, 0.08336631f, -0.00375589f, 
    -0.18859103f, -0.23686838f, 0.20998311f, 0.27220437f, 0.15403247f, -0.04044368f, 0.14482634f, 0.01986685f, 
    -0.01460528f, -0.05899955f, -0.00968427f, 0.01575935f, 0.10138520f, 0.06505193f, -0.09515659f, 0.30102983f, 
    0.05168868f, 0.04725090f, 0.04315357f, -0.02878278f, -0.09171785f, -0.04499494f, -0.00934390f, 0.08567697f, 
    -0.08217085f, 0.12734969f, -0.10983346f, 0.05969032f, -0.00218181f, -0.01682756f, -0.04329860f, -0.01906810f, 
    -0.05498885f, 0.03618452f, 0.05955186f, -0.05890298f, -0.00625972f, 0.07498053f, -0.09955131f, -0.15300466f, 
    0.25037691f, 0.02880187f, -0.33192170f, 0.19637506f, -0.16863769f, 0.07867409f, -0.18373670f, 0.08908091f, 
    -0.05570995f, 0.04799842f, -0.00843005f, -0.04680783f, 0.09354426f, -0.06545844f, 0.00156475f, 0.14899515f, 
    0.20449762f, 0.22139414f, 0.03162029f, 0.07463551f, 0.23463072f, 0.09647015f, 0.10172376f, 0.05666184f, 
    0.00250520f, -0.02552917f, -0.01483915f, 0.09028832f, -0.00477935f, -0.06699056f, -0.10057792f, -0.09113952f, 
    -0.01634970f, -0.04616188f, -0.03416638f, 0.11638641f, 0.23658182f, 0.06496789f, 0.04987085f, 0.07624417f, 
    0.23521154f, 0.08487446f, 0.14929481f, 0.17392346f, -0.04954590f, -0.10269846f, 0.00675742f, -0.06255056f, 
    0.10298344f, -0.09613475f, 0.14209646f, 0.02665544f, 0.21114025f, 0.07800758f, -0.05165220f, 0.09486008f, 
    -0.00545556f, -0.05656939f, -0.05925481f, 0.09749617f, -0.49631372f, -0.06044499f, -0.05578960f, 0.17705074f, 
    -0.10032215f, -0.26773033f, 0.07731625f, -0.05445893f, -0.04439635f, 0.10878754f, -0.09143897f, 0.01655377f, 
    -0.11262078f, -0.03819276f, -0.04846021f, -0.04612677f, -0.05554464f, -0.05477447f, -0.06938362f, 0.00263390f, 
    -0.01995251f, 0.03803777f, -0.02588609f, 0.03309903f, 0.01484351f, 0.00393287f, 0.03669664f, 0.01126643f, 
    0.04544085f, 0.00177756f, -0.01097325f, -0.01458322f, -0.00506920f, -0.04196642f, 0.01660951f, -0.01902366f, 
    0.00564985f, -0.00478315f, 0.04574662f, 0.02753613f, -0.00234842f, 0.04510201f, -0.01502767f, 0.01529563f, 
    -0.03108038f, 0.01543032f, -0.02716284f, -0.01822510f, 0.00011579f, -0.06106312f, -0.00502884f, 0.00518003f, 
    -0.02476860f, 0.01851375f, -0.04141825f, 0.00483933f, 0.01989388f, -0.00894051f, 0.01377576f, -0.00202221f, 
    -0.01649444f, -0.02076409f, -0.02832226f, 0.05380897f, 0.02931546f, -0.00435973f, 0.02334802f, 0.01661456f, 
    -0.05185647f, 0.01896794f, 0.01871001f, -0.01057997f, -0.00169365f, -0.05432724f, 0.02120883f, 0.02361073f, 
    0.00896757f, -0.04687265f, -0.04330077f, 0.03060179f, -0.04456112f, -0.00830592f, 0.01493741f, 0.00564920f, 
    -0.03801140f, -0.01015125f, 0.03878496f, 0.01978517f, 0.01819807f, -0.00159931f, -0.03442836f, -0.03192513f, 
    -0.00066847f, -0.02460223f, 0.02128879f, -0.03287943f, 0.00863832f, -0.03997333f, 0.03753250f, -0.03660206f, 
    0.02049110f, -0.01361084f, 0.03445081f, 0.01785183f, 0.01062797f, -0.01762065f, -0.06082628f, 0.03234293f, 
    0.04490281f, 0.04696575f, -0.00392527f, 0.03322116f, -0.00172797f, -0.05408964f, -0.00078614f, -0.03465854f, 
    0.02779904f, 0.03295901f, 0.00926543f, -0.03279591f, 0.02138222f, -0.01941015f, -0.05542959f, -0.00412917f, 
    0.04644989f, 0.01209346f, -0.04920122f, 0.02498860f, 0.02128525f, -0.02086153f, 0.03290837f, 0.01258060f, 
    -0.02734108f, -0.05413957f, 0.02442347f, -0.05352237f, -0.02410604f, -0.02480868f, -0.00453895f, 0.01539243f, 
    0.02045627f, 0.03558976f, -0.01855268f, 0.02779837f, 0.00869832f, -0.02103948f, -0.03016953f, 0.00395751f, 
    -0.04980814f, -0.05340245f, -0.05013338f, 0.01184560f, -0.06422208f, -0.06320800f, -0.04272251f, -0.03418134f, 
    -0.03495482f, -0.00212267f, 0.03402813f, -0.00873889f, -0.03242536f, -0.01165821f, -0.03829984f, -0.04161001f, 
    -0.03096650f, -0.02751427f, -0.00244083f, -0.04105865f, -0.02996318f, -0.05481656f, -0.00249861f, -0.01967720f, 
    -0.02755212f, 0.00861743f, 0.03877490f, -0.03201459f, 0.01998833f, -0.00677452f, 0.04015508f, 0.03388130f, 
    0.01551747f, 0.01072977f, -0.03274256f, 0.01196373f, -0.03437880f, -0.04341360f, -0.01819640f, -0.05283899f, 
    0.04528690f, 0.00300287f, 0.02980120f, 0.04821977f, -0.02205091f, -0.01625907f, -0.00454260f, 0.02194053f, 
    -0.03028969f, -0.01001588f, 0.04575925f, -0.04516055f, 0.04763696f, -0.02064031f, 0.01280314f, 0.00532077f, 
    0.02268957f, -0.04821728f, -0.04840821f, 0.01694779f, -0.02426305f, 0.00928837f, -0.00616669f, -0.06145554f, 
    -0.06063917f, 0.04551501f, -0.01694126f, 0.04030861f, -0.01168102f, 0.01530045f, 0.03253311f, -0.04231660f, 
    -0.06184060f, 0.00873994f, -0.00262070f, -0.03130894f, -0.01776211f, -0.03255928f, -0.01022536f, 0.02584931f, 
    -0.04608642f, -0.00350723f, 0.02556335f, 0.02858991f, -0.03571537f, -0.00908247f, -0.05611471f, 0.00717576f, 
    0.01137526f, -0.01309044f, -0.01999391f, -0.02374095f, 0.03967774f, -0.03098521f, -0.00047223f, -0.04658570f, 
    0.01119371f, 0.01337928f, -0.02060752f, -0.05704262f, 0.04633688f, -0.01603865f, -0.02759323f, 0.03517662f, 
    -0.03676997f, 0.04482403f, 0.01512872f, -0.05290546f, 0.00384775f, 0.01292439f, -0.03241611f, 0.00108353f, 
    0.02859426f, -0.02821827f, 0.02561732f, -0.02198384f, 0.03225347f, -0.05166433f, -0.04933255f, -0.02290293f, 
    0.02749091f, -0.01508422f, 0.03184440f, -0.02461839f, 0.01763925f, -0.02486910f, 0.04313346f, -0.06614599f, 
    0.01844890f, -0.02783068f, -0.03511456f, 0.04231423f, -0.00133313f, -0.03972702f, -0.01016865f, -0.05912291f, 
    -0.02407038f, -0.04157947f, -0.00619377f, -0.03112369f, -0.01155966f, -0.03853617f, -0.01402681f, -0.01632926f, 
    0.03632570f, 0.01079502f, 0.02379969f, -0.00485697f, -0.04072550f, 0.00295810f, -0.03263592f, 0.03729297f, 
    0.01765114f, -0.06214479f, -0.05892979f, -0.03781307f, -0.04989154f, 0.02819379f, 0.02112609f, -0.05150951f, 
    -0.03754114f, -0.05765522f, -0.05706869f, 0.00518695f, -0.04339698f, 0.04738584f, -0.05426394f, 0.01332281f, 
    -0.04298364f, -0.03480149f, 0.03564883f, 0.02841452f, -0.03000198f, -0.04823471f, -0.00141186f, -0.04864232f, 
    0.01409595f, -0.02181756f, 0.03817959f, -0.04440296f, -0.03052591f, -0.05211431f, 0.00447854f, -0.05209536f, 
    0.04379563f, 0.01401606f, -0.02491617f, -0.01829959f, 0.02209106f, -0.03448837f, 0.03996739f, 0.02783004f, 
    -0.06238512f, 0.20832296f, 0.34097493f, -0.03722174f, 0.04858395f, 0.06523959f, 0.01718098f, 0.11634993f, 
    0.01777814f, -0.03891413f, -0.00697378f, -0.00652593f, -0.01617491f, 0.02029217f, -0.09758773f, 0.05930935f, 
    -0.02926044f, -0.02956039f, -0.08713328f, -0.04352644f, 0.00388634f, -0.03858298f, -0.02995219f, 0.00519923f, 
    0.02355432f, -0.00862594f, -0.02524342f, -0.06887902f, 0.03425616f, 0.02305361f, 0.05218060f, -0.03787725f, 
    -0.01199598f, -0.10253637f, 0.05448699f, 0.17445171f, 0.04099864f, -0.03827846f, 0.09902872f, 0.00200529f, 
    -0.26300848f, 0.06675284f, 0.28766072f, 0.21423550f, -0.12093694f, -0.18219845f, 0.01609568f, -0.07865287f, 
    0.18674210f, 0.21004936f, 0.06982921f, -0.03942804f, 0.05883477f, -0.12031311f, 0.08260282f, 0.05655469f, 
    -0.19652657f, -0.08057410f, 0.00300586f, 0.15016831f, 0.01822486f, -0.13828313f, 0.45652735f, 0.15445533f, 
    -0.36047766f, 0.02199066f, 0.02922017f, 0.13072759f, 0.13155334f, 0.16219722f, -0.01066935f, 0.02950901f, 
    0.02102882f, 0.04532623f, 0.02929164f, 0.10709406f, 0.03592191f, -0.07995191f, 0.14599738f, 0.05985893f, 
    0.08974051f, 0.00064736f, 0.04447317f, 0.13355689f, 0.07849511f, 0.05944562f, -0.05054147f, -0.02207702f, 
    0.02161056f, 0.01907449f, -0.05968045f, -0.12162989f, -0.08408003f, -0.02625330f, 0.01746019f, -0.03737821f, 
    -0.07229242f, -0.04170328f, 0.11549336f, 0.16502109f, -0.20997100f, -0.13601173f, -0.06067115f, 0.12544660f, 
    0.04454556f, 0.02071217f, -0.17340228f, 0.07144113f, -0.05183526f, 0.05790506f, -0.08569577f, 0.01792562f, 
    0.06594911f, 0.07023288f, 0.07142759f, 0.00485775f, -0.02271196f, 0.14157538f, -0.08255097f, 0.04033570f, 
    0.19358532f, 0.02453349f, -0.34575510f, 0.17996666f, 0.13410112f, 0.11655661f, 0.03999449f, -0.04630474f, 
    0.02342722f, 0.10802680f, 0.06464959f, 0.08833174f, 0.03617453f, -0.02802206f, 0.00244992f, -0.13457856f, 
    -0.18906556f, 0.03199338f, -0.07762183f, -0.10251299f, -0.16183956f, 0.36864236f, 0.03550304f, 0.17956935f, 
    -0.13510066f, -0.10319838f, -0.18879731f, -0.01722315f, 0.10131837f, -0.09108696f, 0.11968274f, -0.02926958f, 
    -0.26891166f, 0.13253452f, -0.08140624f, -0.05192213f, 0.00279327f, 0.30327955f, -0.25443333f, 0.04078136f, 
    -0.09887172f, 0.27121732f, 0.14941867f, 0.11651863f, -0.19179848f, 0.00614361f, 0.00626494f, 0.15040331f, 
    -0.00342610f, 0.07515849f, 0.07884046f, 0.07690433f, -0.05143021f, -0.03915497f, -0.00822711f, -0.01640546f, 
    0.00635478f, -0.02076090f, 0.05062462f, 0.07867036f, 0.08886335f, -0.15783346f, 0.32031709f, -0.06002289f, 
    0.03105384f, -0.00378027f, 0.10415921f, 0.04681470f, 0.10649762f, -0.00236330f, -0.01717128f, 0.04298433f, 
    0.06766564f, 0.19554274f, 0.05136091f, 0.06873546f, -0.01991679f, 0.13056207f, -0.05890687f, 0.04429824f, 
    0.23606510f, -0.33001745f, -0.12951708f, -0.03468745f, 0.05738958f, 0.10290016f, -0.11990123f, -0.00775042f, 
    0.15385076f, -0.01968373f, -0.01199004f, 0.02208555f, 0.02127090f, 0.06223778f, 0.11926009f, -0.17783107f, 
    -0.03930250f, -0.04197551f, -0.00468924f, 0.15391432f, 0.18018758f, -0.06892864f, 0.06406349f, -0.03348255f, 
    -0.04843932f, -0.18478969f, 0.10729209f, -0.11750763f, -0.10913980f, -0.03332274f, 0.01400665f, 0.05512196f, 
    0.14377224f, -0.06123530f, -0.03364069f, 0.08650388f, 0.01475644f, -0.14832382f, 0.14236924f, 0.06015782f, 
    -0.10178868f, -0.11322404f, 0.29620361f, 0.07921461f, -0.12090649f, -0.08855335f, 0.07805072f, -0.06672233f, 
    -0.08127008f, -0.00821524f, 0.04246294f, -0.03447854f, -0.07919744f, 0.09942710f, -0.00426507f, 0.06099537f, 
    -0.06213064f, -0.29179105f, 0.07678570f, 0.04048273f, -0.14791942f, 0.03772449f, -0.06248382f, 0.13140371f, 
    0.05770250f, 0.14572199f, 0.00997581f, 0.05655992f, -0.03408018f, 0.01624670f, 0.04466935f, 0.02517609f, 
    0.04600023f, -0.01225091f, -0.05195243f, 0.05084674f, -0.05604909f, 0.15837078f, -0.22746296f, -0.09753639f, 
    -0.43501386f, -0.49014774f, 0.03066239f, -0.28637913f, 0.02089286f, 0.01822630f, -0.03794445f, -0.04434976f, 
    -0.12222306f, 0.05529874f, 0.01586894f, 0.11414380f, -0.08604639f, -0.03033747f, 0.05957248f, -0.05883619f, 
    0.02574730f, 0.18340120f, -0.10329647f, -0.01756011f, 0.40444732f, 0.08559766f, 0.27552557f, 0.10972467f, 
    -0.20663528f, -0.02000679f, -0.11444803f, -0.05691560f, 0.14163776f, -0.02743105f, 0.24702577f, 0.01886064f, 
    0.04860864f, -0.02894059f, -0.00074404f, 0.01632551f, 0.06086008f, 0.15939826f, -0.07992037f, 0.03894117f, 
    0.04739559f, 0.02543944f, 0.20654745f, 0.06065197f, -0.01748925f, 0.17877467f, 0.13090840f, 0.16624029f, 
    0.07433675f, 0.03293929f, 0.07014568f, -0.03959515f, -0.02857602f, -0.02002773f, 0.06013201f, 0.11152915f, 
    -0.10975514f, 0.00165127f, 0.09510899f, -0.18862154f, -0.01042375f, 0.03353341f, 0.16037092f, 0.11181786f, 
    -0.21269298f, -0.17344910f, -0.08283770f, -0.09869447f, -0.00733778f, -0.06207202f, 0.06685335f, -0.06654242f, 
    -0.04229764f, 0.10957597f, 0.05020996f, -0.05482678f, 0.06107499f, 0.03600522f, 0.03472707f, 0.10443219f, 
    0.06647743f, 0.02944074f, 0.17941667f, -0.17577040f, 0.01209377f, 0.12490601f, 0.17705254f, 0.24998257f, 
    0.06395340f, 0.16088070f, -0.00661565f, 0.01113394f, -0.11921099f, -0.12593450f, 0.00044334f, 0.04516145f, 
    0.04660210f, 0.10341558f, 0.07344900f, 0.05166638f, -0.17511827f, -0.20501420f, 0.06623068f, 0.00536438f, 
    -0.09823880f, 0.18940602f, -0.18135719f, -0.07063030f, 0.19463702f, -0.12124383f, -0.05655372f, 0.02380703f, 
    0.04387995f, -0.04317215f, 0.05780675f, -0.10443330f, -0.04001888f, -0.12000401f, -0.26043442f, -0.32841682f, 
    0.04198233f, -0.03236762f, 0.02386044f, 0.07656766f, -0.10907360f, -0.06862795f, -0.07661603f, -0.06742176f, 
    -0.05320543f, -0.05298037f, 0.17310132f, 0.02923017f, 0.12283086f, 0.17810576f, 0.08531372f, 0.04368904f, 
    0.07279244f, 0.08765336f, 0.13403511f, 0.09004252f, 0.18537059f, -0.04404126f, 0.21954741f, -0.08885123f, 
    -0.11078340f, 0.11456974f, -0.08017074f, 0.07439862f, -0.01162965f, -0.08047386f, -0.05467988f, 0.00945670f, 
    0.00144929f, 0.03303650f, 0.02466698f, 0.12917526f, 0.06102172f, 0.23084006f, 0.01528393f, 0.11218747f, 
    0.24229740f, 0.14081796f, 0.28276464f, 0.08217153f, -0.14789017f, -0.20703237f, -0.09708098f, -0.19546798f, 
    -0.08610664f, -0.01658955f, -0.17973296f, 0.02408106f, 0.00205411f, -0.02067450f, -0.02652526f, -0.06615555f, 
    0.01140087f, -0.00385325f, 0.10566633f, -0.07006152f, 0.30242386f, 0.17430125f, -0.12776560f, -0.14200495f, 
    0.21915111f, -0.11233525f, 0.16392952f, 0.13988571f, -0.00338993f, 0.09232733f, 0.16563565f, 0.11181768f, 
    -0.08894958f, 0.09485228f, 0.11609463f, -0.01182251f, -0.03976459f, 0.19531126f, 0.02943669f, 0.01582130f, 
    -0.10541347f, -0.27142730f, 0.25268966f, -0.03140019f, -0.10443424f, 0.08014129f, -0.14681304f, -0.00747309f, 
    -0.05352443f, -0.12857328f, -0.10431716f, -0.00051929f, -0.06611145f, 0.01277419f, 0.07729239f, 0.07542357f, 
    0.01308429f, 0.02423195f, 0.04434773f, 0.10205119f, -0.00644542f, -0.12927788f, 0.18717520f, 0.15951155f, 
    0.09808742f, 0.05720326f, 0.03784502f, 0.20889306f, 0.22910027f, 0.03530816f, -0.02635539f, -0.07811963f, 
    0.01015672f, -0.05189402f, -0.02586779f, 0.24685368f, -0.13336119f, 0.07818806f, 0.02119386f, 0.27039382f, 
    0.35286078f, 0.21802868f, 0.17681265f, 0.34146023f, 0.32712668f, 0.06936279f, -0.00430632f, -0.09858105f, 
    0.07117621f, -0.08161786f, 0.06924880f, 0.06872977f, 0.06165008f, 0.06460077f, 0.20046069f, 0.03755286f, 
    0.02143691f, 0.02707654f, 0.03851065f, 0.00526913f, -0.13746276f, -0.30989689f, 0.04067544f, 0.14543806f, 
    -0.21306169f, 0.06913715f, 0.06980295f, -0.14727403f, -0.18408228f, -0.09185494f, -0.14620610f, -0.00724703f, 
    0.18248835f, -0.09041984f, 0.05207717f, 0.07062209f, 0.24832872f, 0.02466250f, 0.27256566f, 0.38839343f, 
    -0.09247994f, 0.13766378f, -0.05879702f, 0.16168007f, -0.08146971f, 0.10867672f, -0.00875360f, 0.05314811f, 
    0.04106289f, 0.09523530f, -0.07487821f, 0.02334827f, -0.07423452f, -0.12783194f, 0.00894058f, 0.00112667f, 
    -0.03791304f, -0.11356683f, 0.07780215f, -0.06805772f, 0.02811233f, 0.10351242f, 0.31210592f, -0.15194461f, 
    -0.24440221f, -0.13989353f, -0.19654363f, -0.23846480f, -0.02317555f, -0.13990285f, -0.18595925f, 0.02496529f, 
    -0.06785542f, -0.07989642f, -0.12971783f, -0.06356538f, -0.13464448f, 0.10955244f, -0.00636129f, 0.01652280f, 
    0.13271628f, -0.08875100f, 0.08507749f, -0.00969401f, -0.06567461f, -0.07596540f, -0.00418387f, 0.05999277f, 
    -0.04661941f, -0.06440073f, 0.09215451f, 0.10195399f, 0.04033038f, 0.05613327f, 0.16781756f, -0.02742570f, 
    -0.04957106f, -0.00069100f, 0.01464759f, -0.01753476f, 0.09635131f, -0.46994966f, -0.09589416f, -0.00809859f, 
    -0.18593293f, -0.17856361f, 0.08340403f, -0.09047568f, 0.13929492f, 0.00060802f, 0.03578029f, 0.05478068f, 
    -0.07821236f, -0.09613396f, -0.08324278f, 0.03959785f, 0.14246029f, 0.03348570f, 0.08732650f, 0.03498779f, 
    0.17449322f, 0.17627014f, 0.18781260f, -0.00178215f, 0.28054342f, 0.05949463f, -0.00566850f, 0.21284543f, 
    0.03379958f, -0.00815043f, -0.04270550f, -0.01600575f, -0.03415830f, 0.06748832f, -0.09697995f, 0.05506869f, 
    0.01291417f, 0.08907200f, -0.18208855f, -0.31369475f, -0.17400998f, 0.04320539f, 0.00703456f, 0.00365251f, 
    0.02293909f, 0.06360865f, -0.02078406f, -0.08453013f, -0.06464047f, -0.00209729f, 0.07458264f, -0.00513880f, 
    0.09096851f, -0.07213726f, 0.10329510f, 0.09046514f, 0.12016162f, 0.00797707f, 0.04857988f, 0.06026798f, 
    1.06128323f, -0.04068360f, -0.14506428f, 0.02505823f, -0.19668183f, -0.10016593f, 0.04802808f, 0.08601157f, 
    0.18107253f, 0.01792458f, -0.02800518f, 0.03116436f, -0.02466266f, -0.09846550f, -0.04581863f, 0.13180381f, 
    -0.09684224f, -0.01560597f, 0.04486033f, -0.01893650f, 0.25343132f, 0.32935145f, 0.52305686f, 0.13327204f, 
    -0.17894907f, -0.03867209f, 0.16258632f, 0.10630044f, 0.07824415f, 0.11878340f, -0.01695600f, -0.01213681f, 
    -0.01075844f, -0.03247153f, 0.03188070f, 0.14935277f, 0.01994886f, -0.09033380f, 0.01358739f, -0.10309618f, 
    0.01275855f, -0.01260228f, 0.05298373f, 0.01613265f, -0.05611553f, -0.01167673f, -0.04621906f, -0.10044476f, 
    0.00434948f, -0.05990512f, -0.04205187f, -0.00600716f, -0.14235581f, 0.02642535f, 0.05998046f, 0.11454174f, 
    0.11128800f, 0.02494065f, 0.08135287f, 0.16286160f, -0.15669252f, 0.12391131f, -0.02694402f, 0.14895926f, 
    -0.17943344f, -0.04177328f, -0.05347380f, 0.00480921f, -0.07470404f, -0.01357509f, -0.03718221f, 0.07332683f, 
    0.02760977f, -0.03214519f, 0.08884788f, 0.00978523f, 0.08985461f, 0.09792410f, 0.03458340f, 0.01023786f, 
    -0.28055155f, 0.10047247f, 0.19385980f, 0.18762539f, 0.06558421f, 0.08711661f, 0.01177213f, -0.03680401f, 
    0.01272255f, 0.05671433f, 0.08666204f, 0.04777166f, 0.05014939f, -0.06623911f, 0.00039571f, 0.01252156f, 
    -0.06344294f, -0.07825249f, -0.15978962f, -0.10025299f, 0.68634254f, 0.32089090f, 0.02677603f, -0.00692602f, 
    -0.46097231f, 0.00506434f, 0.03700425f, 0.00693580f, -0.00494678f, -0.18994050f, 0.06219188f, 0.09503508f, 
    -0.10451920f, 0.00877737f, 0.06123000f, -0.14301877f, -0.10952611f, 0.20042357f, -0.23198432f, 0.00104495f, 
    0.28958777f, 0.57990211f, 0.05001727f, -0.01181673f, 0.29660696f, 0.06894522f, 0.13704579f, 0.28178591f, 
    -0.05010042f, 0.11991881f, -0.01577786f, 0.02187337f, -0.01528253f, -0.00751158f, 0.02301068f, -0.05846191f, 
    0.09927882f, 0.01504377f, -0.09125329f, -0.07813565f, -0.04112229f, 0.03327886f, -0.11105815f, -0.13873498f, 
    0.22705145f, 0.06335326f, 0.09496617f, -0.03571579f, -0.03795177f, 0.23363085f, -0.02465571f, 0.08402613f, 
    -0.08006842f, 0.23312058f, -0.04238642f, 0.13050660f, -0.15555410f, 0.05901041f, 0.01583487f, -0.00535614f, 
    0.06277327f, 0.12344466f, 0.17630394f, 0.10248319f, -0.33362249f, -0.07209039f, -0.10278862f, 0.01783738f, 
    -0.01186353f, 0.01212223f, 0.06823948f, -0.08407440f, -0.08162611f, 0.10052245f, 0.08312549f, -0.14566274f, 
    -0.10363407f, -0.14618979f, -0.03553341f, 0.06175829f, 0.11338620f, -0.07607760f, -0.03043772f, -0.14939509f, 
    -0.03341959f, -0.11121009f, 0.14195544f, -0.00411940f, -0.07754846f, 0.04843145f, 0.09028931f, 0.10503778f, 
    0.06021167f, -0.08964300f, 0.02837875f, 0.11778952f, 0.13954744f, -0.04405929f, 0.18884413f, 0.24788947f, 
    -0.00716207f, -0.02971583f, -0.33157218f, -0.27663288f, 0.24214748f, -0.02904484f, 0.15148877f, 0.12650698f, 
    -0.15745592f, 0.06480750f, 0.00285962f, -0.05608116f, -0.11990862f, 0.00557540f, 0.15617785f, 0.02894866f, 
    -0.18050078f, -0.16085868f, 0.02457317f, -0.02132726f, -0.32488281f, 0.18302736f, -0.11707455f, 0.05716238f, 
    0.14706558f, 0.05018257f, -0.03288614f, -0.00924672f, -0.07666758f, -0.09278826f, 0.01243896f, 0.08212818f, 
    -0.00691152f, -0.05808777f, 0.02364399f, -0.02140354f, 0.02761772f, 0.16938485f, -0.10206640f, -0.01395795f, 
    -0.29634124f, -0.31868735f, -0.22765112f, -0.16579238f, 0.00082418f, -0.01518964f, -0.00754844f, -0.06180355f, 
    -0.05351707f, -0.02393744f, -0.01822314f, 0.12524228f, -0.09653384f, 0.10808064f, 0.01278109f, -0.01399198f, 
    0.03226067f, 0.11748868f, -0.06500626f, -0.07577913f, 0.24927099f, 0.02959218f, -0.10340601f, -0.21462704f, 
    -0.04016721f, 0.09760964f, 0.07957833f, 0.09238043f, 0.06838635f, 0.27286699f, 0.16519299f, 0.00085807f, 
    -0.01589851f, -0.11358799f, -0.03438199f, -0.00203689f, 0.15992935f, 0.17289580f, 0.01799250f, 0.12632485f, 
    -0.02159278f, 0.04335153f, -0.01895830f, 0.00076440f, -0.05083982f, -0.05803014f, -0.04531862f, -0.02866774f, 
    -0.01705829f, -0.05485847f, -0.05009652f, 0.04574815f, -0.06118689f, 0.01186835f, -0.02621517f, -0.02402769f, 
    -0.05133908f, -0.02131819f, 0.00302814f, -0.05494605f, -0.00544967f, 0.04519257f, -0.05859357f, -0.01577904f, 
    -0.05028144f, -0.05140165f, 0.00339964f, 0.03073212f, 0.04601571f, -0.00643290f, 0.01923142f, -0.01986916f, 
    -0.05691556f, -0.00592741f, -0.05461397f, 0.02939401f, -0.02519550f, 0.00152470f, -0.02509681f, 0.01868742f, 
    0.02481526f, 0.01554569f, 0.04846308f, 0.04683963f, -0.02724300f, -0.01337606f, -0.02240053f, -0.02580043f, 
    0.04221638f, -0.02039977f, -0.03666129f, 0.01286209f, -0.02265110f, 0.04153315f, -0.02985340f, -0.06063267f, 
    -0.02452077f, 0.02989424f, -0.03697750f, -0.01558367f, 0.03483291f, 0.03793299f, -0.01793023f, -0.00557053f, 
    -0.04780178f, 0.01303599f, -0.03114351f, 0.01483581f, -0.05159086f, 0.02611092f, 0.00090736f, -0.04523136f, 
    -0.02834752f, 0.03437232f, 0.01105430f, -0.00371815f, 0.04648554f, 0.01792751f, 0.01452834f, 0.02617662f, 
    0.00812661f, 0.02991793f, 0.02541748f, 0.04002525f, -0.01196399f, -0.05422885f, -0.06092960f, -0.00195500f, 
    -0.05062136f, 0.00314028f, 0.00796833f, -0.04434428f, -0.04005556f, -0.04212394f, 0.02863851f, -0.00277946f, 
    0.02903548f, 0.00929257f, 0.01705526f, 0.02546606f, 0.02141178f, 0.04709691f, -0.02324540f, -0.04156491f, 
    0.03512862f, 0.01766498f, -0.06156482f, -0.04450417f, -0.05967248f, 0.02922098f, 0.00779272f, -0.03654824f, 
    -0.01743006f, 0.02443641f, 0.02535443f, 0.01347078f, 0.00994713f, 0.04855826f, -0.01367287f, 0.00828635f, 
    0.04256031f, 0.03256723f, 0.01295766f, 0.03013189f, -0.04766023f, -0.04082718f, 0.04444019f, 0.00950857f, 
    -0.02093868f, -0.02332046f, -0.01465335f, 0.04684983f, 0.03597941f, -0.00674826f, 0.00564805f, 0.02148176f, 
    -0.03996159f, -0.04436503f, -0.00446565f, 0.00022557f, 0.03608064f, 0.01471048f, 0.01284428f, -0.02601953f, 
    0.02684700f, -0.05723015f, -0.02492462f, -0.00950920f, -0.01766890f, -0.02365123f, -0.00126728f, -0.06002296f, 
    0.02730769f, 0.03930471f, 0.03911450f, -0.00883426f, 0.02228935f, 0.00809467f, -0.05259040f, -0.00276451f, 
    -0.01359645f, -0.05295900f, 0.02144452f, -0.04643148f, -0.01162288f, -0.01142848f, 0.04978332f, -0.01110070f, 
    -0.04310235f, -0.03024904f, 0.01542249f, -0.01993803f, -0.04987156f, -0.04652130f, -0.01718962f, -0.03657186f, 
    0.03296752f, 0.01809948f, -0.05922100f, 0.01465353f, 0.04651517f, 0.01596348f, 0.01317595f, 0.00103202f, 
    -0.05030887f, -0.02691866f, 0.02758470f, -0.00074734f, 0.00161038f, -0.05179819f, 0.04087764f, 0.04149865f, 
    0.00027193f, -0.01168986f, -0.00228924f, -0.02249497f, 0.00871163f, -0.05550978f, 0.03799906f, 0.01096535f, 
    0.04880275f, -0.04684094f, -0.05515094f, 0.01187233f, -0.02581405f, -0.04409207f, -0.06122873f, 0.01392196f, 
    0.00729591f, -0.03273604f, -0.05050521f, -0.02703695f, 0.02998485f, 0.04258763f, 0.01289090f, -0.03024483f, 
    0.04874201f, -0.03482711f, 0.00843129f, -0.02605347f, 0.01926824f, -0.03710765f, -0.02582364f, 0.00959809f, 
    0.03641455f, -0.00638519f, -0.05314284f, 0.02023945f, -0.01438529f, 0.04806018f, -0.05402199f, 0.04877078f, 
    0.02748002f, -0.04327127f, 0.02862107f, -0.02440023f, -0.03977160f, 0.03931676f, -0.01241567f, -0.06147333f, 
    0.01922135f, -0.00036615f, -0.04945461f, -0.04360965f, -0.03199898f, -0.03730667f, -0.01186533f, -0.00628993f, 
    0.00629772f, 0.01427464f, -0.03282093f, 0.02451975f, 0.01829624f, -0.02250295f, -0.03863395f, 0.01942896f, 
    0.00141766f, -0.01027384f, 0.02636023f, -0.00555956f, -0.02774836f, 0.00866574f, -0.02962249f, -0.04847677f, 
    0.01216640f, -0.03622687f, 0.01411570f, 0.04242503f, -0.02689951f, 0.02363727f, 0.02662090f, -0.05089089f, 
    -0.06116639f, 0.03103161f, -0.00389857f, 0.02333122f, 0.02606406f, 0.02478772f, -0.04027808f, -0.01966846f, 
    -0.00523791f, 0.04988334f, -0.00204723f, 0.01847800f, 0.01560700f, 0.03800508f, -0.04965983f, -0.03345988f, 
    -0.03452161f, -0.02971802f, -0.04154975f, -0.01883226f, 0.04592358f, 0.00650980f, -0.06063295f, -0.02925618f, 
    0.00085931f, 0.04957767f, -0.02708918f, -0.03527274f, 0.00512464f, -0.03551905f, 0.00374556f, 0.04139929f, 
    -0.04602467f, 0.00179821f, -0.02196470f, -0.02980819f, -0.05006359f, -0.02820356f, -0.02346948f, -0.02194874f, 
    0.01284039f, 0.04776383f, -0.01263694f, 0.02755867f, -0.03733938f, -0.05421248f, 0.00331212f, 0.00741656f, 
    0.05096300f, -0.14617766f, 0.08197740f, 0.25480554f, -0.09973335f, -0.00938603f, 0.14384918f, 0.00651099f, 
    0.10282443f, -0.05286587f, -0.00949504f, -0.00009126f, 0.00488629f, 0.12356529f, 0.11181752f, 0.05512540f, 
    0.01969054f, 0.32129410f, -0.05083115f, -0.06283104f, -0.09451528f, -0.13156249f, -0.00568095f, -0.06307650f, 
    -0.12713718f, -0.00485558f, -0.11988014f, -0.02845439f, -0.03835051f, 0.00103187f, -0.03818680f, 0.06719784f, 
    0.10933654f, -0.13647559f, 0.02383980f, -0.01235965f, 0.01617638f, -0.04602023f, 0.04683523f, 0.04211204f, 
    0.56548822f, 0.00881178f, 0.00700862f, 0.02573812f, 0.42600647f, -0.15624638f, 0.02205757f, 0.19815074f, 
    0.21259773f, 0.14874755f, 0.04134359f, 0.12865365f, -0.03913872f, -0.02068078f, 0.02576636f, 0.09538013f, 
    0.09054432f, -0.05258821f, 0.07214387f, -0.06296753f, -0.19102955f, 0.08688397f, -0.29302707f, 0.00197347f, 
    0.26485014f, -0.04849222f, 0.21815352f, -0.00020321f, -0.15731151f, -0.10131938f, -0.02943651f, -0.00949302f, 
    0.09397052f, 0.06301092f, 0.12875603f, 0.10999588f, 0.00494264f, -0.00112464f, 0.04994485f, -0.01729449f, 
    -0.09951358f, -0.10179193f, 0.08353907f, 0.04013473f, -0.06592295f, 0.01814099f, -0.05726975f, -0.04179209f, 
    -0.00214351f, 0.04436308f, -0.02642861f, 0.05923824f, 0.09433568f, 0.08205445f, 0.03381499f, 0.02309767f, 
    0.01710844f, -0.05733860f, 0.00868848f, 0.08389360f, -0.01193848f, -0.08034672f, -0.09271996f, -0.20339662f, 
    -0.08755569f, -0.13039987f, -0.14447926f, 0.15145655f, -0.03661783f, 0.01719991f, -0.04487326f, -0.10262728f, 
    0.04617094f, -0.07561921f, -0.01776060f, 0.12686369f, 0.03234218f, -0.04511655f, 0.04084402f, -0.01984653f, 
    -0.45401391f, -0.19345918f, 0.20501654f, -0.34728187f, -0.00786608f, -0.04758922f, 0.00046893f, 0.00292955f, 
    -0.08968689f, -0.09575773f, -0.11953840f, -0.07749891f, -0.07871537f, 0.00672196f, -0.00266640f, 0.06481662f, 
    0.08499425f, -0.01134588f, -0.08138897f, 0.02926408f, 0.46676260f, -0.36817622f, 0.51621062f, 0.10305611f, 
    0.01819599f, -0.08464435f, -0.08338460f, 0.13435885f, 0.00268332f, -0.05842821f, -0.00483943f, 0.16490021f, 
    0.10746302f, 0.16365336f, 0.12568909f, -0.05552923f, 0.04681120f, 0.06944810f, -0.21206722f, 0.13553728f, 
    -0.08541871f, -0.26638255f, -0.28590080f, -0.12715219f, 0.28860620f, 0.19182956f, 0.14798269f, 0.27130893f, 
    -0.10718274f, -0.07792682f, 0.03396807f, 0.02331330f, 0.06328779f, 0.06108804f, 0.04341377f, 0.10152993f, 
    0.04990013f, 0.12416811f, 0.08135977f, 0.01228248f, -0.35914823f, 0.06055325f, -0.16854016f, 0.06519835f, 
    0.23706836f, -0.08120473f, 0.14612803f, -0.02321485f, 0.09610537f, -0.05175178f, 0.14816087f, 0.04617719f, 
    0.00170500f, 0.08925357f, 0.10185991f, 0.03917545f, 0.02574101f, 0.06961209f, 0.04282996f, -0.08337653f, 
    -0.04654665f, -0.13191283f, 0.57559472f, -0.05078963f, -0.26546308f, -0.04414967f, 0.06888503f, -0.05597464f, 
    -0.03326341f, -0.03228812f, 0.03471946f, -0.11523499f, -0.05661641f, -0.00262913f, 0.02661183f, 0.09065565f, 
    0.17002338f, 0.04778727f, -0.12659371f, -0.07040934f, -0.16173613f, -0.27897424f, -0.21799639f, -0.06890763f, 
    0.12106624f, 0.09694190f, -0.08872788f, 0.01317865f, 0.03037964f, 0.02397585f, 0.15393707f, 0.00753438f, 
    0.01808019f, 0.03692198f, 0.06136582f, -0.02481369f, 0.09566545f, 0.16105546f, 0.12868910f, 0.17480636f, 
    -0.09873308f, -0.03710270f, -0.57731736f, 0.13249893f, 0.28846872f, -0.03000326f, -0.12944974f, -0.03757995f, 
    -0.01459976f, 0.03696261f, -0.10181573f, 0.01686781f, -0.08312727f, -0.02756396f, 0.05114210f, 0.09817490f, 
    0.00086440f, 0.08127331f, 0.05693714f, 0.06692473f, -0.02070723f, -0.29821727f, -0.37981665f, -0.36873075f, 
    0.01484151f, 0.03124446f, -0.09545829f, 0.10350804f, -0.13434026f, -0.07315068f, -0.07620997f, 0.01445773f, 
    -0.01456744f, -0.06054871f, -0.01442079f, 0.01357101f, 0.01216142f, -0.03244363f, -0.07443329f, -0.01812597f, 
    0.15857190f, 0.33597383f, 0.36288297f, 0.00818758f, 0.26478121f, -0.04362179f, -0.07691614f, -0.07458442f, 
    -0.05520711f, -0.00408284f, 0.14098659f, 0.09789289f, 0.04001847f, 0.05895936f, -0.05157363f, 0.02646376f, 
    -0.01411669f, -0.10870152f, -0.03006248f, -0.08536166f, -0.32377243f, 0.01755383f, 0.38226917f, -0.07284991f, 
    0.14828359f, -0.06868636f, -0.00776895f, 0.09639806f, -0.04461112f, 0.05976818f, -0.17607392f, 0.19466016f, 
    0.00889000f, 0.00453761f, 0.02648300f, -0.04040151f, 0.00354627f, 0.13495331f, 0.08744787f, -0.02835608f, 
    0.12680535f, -0.07138893f, -0.00676866f, 0.06652752f, 0.11072619f, 0.04193205f, 0.07490891f, 0.17147918f, 
    0.13716328f, -0.06377624f, -0.06456992f, -0.04437018f, 0.15535291f, 0.01365138f, 0.04175786f, 0.19690390f, 
    0.13805489f, 0.09076544f, 0.21322986f, 0.02153443f, -0.32365820f, 0.05535511f, -0.04911350f, -0.05443766f, 
    0.07818622f, 0.00484951f, 0.00230991f, -0.15088135f, -0.03475552f, 0.03695782f, 0.12711760f, 0.01177205f, 
    0.10367610f, 0.09287539f, 0.09844184f, 0.05993321f, -0.03494758f, -0.02722189f, 0.07254535f, -0.08021325f, 
    -0.10148332f, 0.34879264f, -0.27871743f, 0.30785576f, -0.12749697f, 0.19620210f, -0.06444648f, 0.00076208f, 
    0.08529667f, 0.30049935f, 0.09491838f, -0.10048783f, 0.04862693f, 0.07028611f, -0.11613222f, 0.04344559f, 
    -0.03010103f, -0.01158884f, 0.08275368f, 0.04585798f, -0.08216315f, -0.27043718f, -0.01133341f, -0.00706290f, 
    -0.52431273f, -0.04813991f, 0.00871827f, -0.13406871f, -0.05581160f, 0.03712841f, 0.03544017f, 0.00865001f, 
    -0.01886491f, -0.01109145f, -0.01235940f, -0.00105989f, 0.15924786f, 0.18057884f, 0.18598993f, 0.13414092f, 
    0.07056496f, 0.06346063f, 0.05774586f, 0.04813797f, -0.04366621f, 0.06348599f, -0.08011195f, -0.03961717f, 
    -0.01587748f, -0.00545962f, 0.08565222f, -0.06527508f, 0.26979819f, 0.14992425f, 0.14876629f, 0.02353650f, 
    0.00519960f, -0.07795596f, 0.02127932f, 0.05415115f, 0.01497668f, 0.11631272f, -0.33943257f, 0.20223498f, 
    0.04879102f, 0.00837690f, 0.04658341f, 0.00470390f, -0.04673757f, -0.05840815f, 0.01876154f, 0.04009814f, 
    0.02098288f, 0.04341536f, -0.16034992f, -0.12507319f, 0.03853618f, 0.04523465f, 0.02928358f, -0.06496214f, 
    -0.02179147f, -0.07335243f, -0.02074415f, -0.07267682f, -0.16690050f, -0.02872044f, 0.00951278f, 0.01983327f, 
    0.06973487f, -0.04532955f, 0.02598017f, -0.17399134f, 0.02481342f, 0.00711442f, 0.00777273f, 0.07565758f, 
    -0.13110572f, 0.12480507f, -0.00116509f, -0.12040237f, -0.51834524f, 0.62768686f, -0.06245891f, 0.44755235f, 
    0.09200316f, -0.07372670f, 0.18944907f, 0.01942182f, -0.00960053f, 0.09723964f, 0.16751471f, 0.00777960f, 
    0.05045038f, 0.07550705f, 0.00804647f, -0.14076379f, 0.03050510f, 0.05604366f, 0.19172490f, -0.19035403f, 
    0.04187313f, -0.08756577f, -0.12449586f, -0.01434409f, -0.08051657f, -0.01398373f, 0.03901445f, 0.02420289f, 
    0.02900054f, -0.13356453f, 0.01844715f, 0.07793166f, 0.00633605f, -0.04716704f, 0.02436813f, 0.06349549f, 
    0.04507398f, 0.14421190f, 0.16227829f, 0.05912891f, 0.15336637f, -0.09417965f, -0.20590723f, -0.21391374f, 
    -0.10933898f, -0.02467955f, -0.09371939f, -0.10269725f, 0.01156902f, 0.22373790f, 0.06585329f, 0.05700824f, 
    0.08028778f, -0.01744022f, -0.11453551f, 0.16400355f, -0.05628830f, 0.01771136f, 0.05414540f, 0.30494153f, 
    -0.03651306f, 0.14839780f, -0.20345511f, 0.15778147f, 0.03104794f, 0.01561478f, 0.04811618f, -0.09788375f, 
    0.07187039f, 0.05563786f, 0.04734610f, 0.11261623f, 0.04695091f, 0.09477831f, 0.08225321f, 0.18235314f, 
    -0.01049744f, 0.05809415f, 0.16016895f, 0.13560055f, 0.14741397f, -0.42148581f, -0.06237090f, 0.06983547f, 
    -0.02211834f, -0.15334725f, 0.04193494f, -0.11948475f, -0.18198779f, -0.25163150f, 0.15512134f, 0.09854384f, 
    0.06522717f, -0.17001352f, 0.02327506f, 0.15098894f, 0.04994049f, -0.12029131f, 0.03563868f, 0.08417629f, 
    -0.36373249f, -0.32532385f, 0.04045290f, 0.10060477f, -0.26078773f, 0.02071217f, -0.07159889f, -0.01785867f, 
    0.04159212f, -0.03031335f, -0.01669214f, -0.08352935f, 0.01651757f, 0.06223411f, -0.03316035f, -0.02196713f, 
    0.05498104f, 0.12730540f, 0.11471635f, -0.00643272f, -0.18335684f, 0.02864592f, -0.24535321f, -0.13267517f, 
    -0.16751133f, -0.08027533f, 0.04158405f, 0.06166472f, -0.02865780f, -0.05308631f, -0.00103327f, -0.01681062f, 
    -0.12558483f, 0.05368829f, -0.16410245f, -0.03166580f, -0.13811000f, 0.11767773f, -0.08705788f, -0.00833862f, 
    -0.41830179f, 0.16029724f, 0.32283357f, -0.12367480f, 0.09939004f, 0.03265148f, -0.04168560f, -0.02477634f, 
    0.12049253f, -0.06517593f, -0.03136120f, 0.19357125f, 0.21621521f, 0.13666239f, 0.19233140f, 0.01227200f, 
    -0.00566042f, 0.16309732f, 0.07934054f, 0.09703397f, -0.54019940f, -0.41475552f, 0.19089015f, -0.15070292f, 
    -0.24192111f, -0.01697851f, 0.00047683f, -0.32091394f, 0.05710203f, -0.08800067f, 0.09248236f, -0.06223689f, 
    -0.06819699f, -0.02374196f, -0.14940487f, -0.05023868f, -0.11430418f, 0.00123786f, 0.02451579f, 0.11592326f, 
    -0.03350985f, 0.03012817f, 0.01329420f, 0.02725385f, 0.01893845f, 0.02432504f, -0.02979232f, -0.04520132f, 
    -0.03198983f, 0.01198152f, 0.04735860f, -0.01792017f, 0.00228509f, 0.00289280f, 0.04410160f, -0.03263118f, 
    0.01390931f, -0.01747307f, 0.04251927f, 0.04028627f, -0.02580911f, -0.01790410f, -0.04465180f, -0.05192635f, 
    -0.00266667f, 0.02996153f, -0.04592704f, 0.03065111f, -0.05136487f, -0.03452484f, -0.00110361f, 0.01738889f, 
    -0.01346596f, -0.03293162f, -0.03189022f, -0.02214586f, -0.05710342f, -0.00758555f, -0.03409791f, 0.00606679f, 
    -0.04175356f, 0.03194572f, -0.05788695f, -0.05347414f, -0.00695778f, -0.04602124f, -0.01463913f, -0.04798226f, 
    0.01593443f, -0.00673697f, -0.01708668f, -0.01363226f, -0.00264425f, 0.03948314f, 0.02589960f, 0.00217687f, 
    -0.00243431f, 0.02437347f, -0.03456382f, 0.02944248f, 0.04616769f, 0.02204203f, -0.00288648f, -0.01480001f, 
    0.00289830f, -0.01114950f, -0.03826703f, 0.00784643f, 0.02395855f, 0.00559816f, 0.02809805f, 0.01766981f, 
    0.03271792f, 0.00935860f, -0.01755089f, 0.00101015f, -0.00600552f, -0.05676974f, -0.01726680f, -0.01668704f, 
    0.03694583f, -0.02723345f, -0.04633459f, 0.02541954f, 0.03548691f, -0.06140503f, 0.01202554f, 0.02370554f, 
    0.02010675f, 0.04390423f, 0.03498383f, -0.04416555f, 0.02452522f, -0.04848338f, -0.03649145f, -0.06151405f, 
    -0.04528606f, -0.01176276f, -0.03168801f, -0.04598420f, -0.02572496f, -0.04306893f, -0.04114397f, 0.05587668f, 
    0.00301142f, -0.06314728f, -0.02522744f, 0.03782797f, 0.01313608f, -0.04024944f, 0.00285618f, 0.03384263f, 
    -0.00954119f, -0.02423429f, -0.04562033f, 0.00616654f, -0.06134536f, 0.02661198f, 0.01449012f, -0.04786536f, 
    0.00965396f, 0.04789449f, -0.01138534f, 0.03679955f, 0.04667589f, -0.00433656f, 0.02412169f, -0.03233810f, 
    0.03244584f, 0.02665409f, -0.02100723f, 0.00399353f, 0.05043548f, -0.02758712f, 0.04239849f, -0.04074224f, 
    -0.01880690f, -0.05730311f, -0.03213638f, -0.01003478f, 0.02096145f, -0.02788610f, -0.01972563f, 0.04205012f, 
    0.05293741f, 0.00508167f, 0.04257400f, 0.04768613f, -0.01435217f, 0.03143680f, -0.04447045f, -0.02365248f, 
    -0.02646419f, -0.02082880f, -0.00240945f, -0.05129706f, 0.01066850f, -0.01746689f, -0.05193591f, -0.00854913f, 
    -0.00255962f, -0.01531570f, 0.01937101f, -0.02054521f, 0.03725566f, 0.02659501f, -0.06358755f, -0.05255169f, 
    -0.05970716f, -0.05004898f, -0.01124017f, 0.03878003f, -0.05337003f, 0.04767102f, -0.00178964f, 0.03375939f, 
    -0.02785408f, -0.03457266f, -0.00918135f, -0.01126323f, -0.01934455f, -0.01333244f, -0.00553046f, -0.06872838f, 
    -0.03278400f, 0.04227749f, -0.00014646f, 0.01723496f, -0.02009482f, -0.01901718f, 0.02589945f, 0.04162329f, 
    0.04564922f, -0.00172026f, -0.03763486f, -0.03108536f, 0.03798898f, 0.04384379f, -0.02853729f, 0.04229237f, 
    0.01807152f, -0.04236236f, 0.04204121f, -0.00300754f, 0.01425086f, -0.02660754f, -0.03727134f, -0.04115020f, 
    0.02772628f, -0.06482308f, -0.00545157f, 0.02473708f, -0.00698421f, -0.04495855f, 0.00990943f, -0.04779096f, 
    -0.04700657f, -0.05999674f, -0.03600959f, 0.02535175f, 0.02603023f, 0.01367101f, -0.05097285f, -0.06080937f, 
    0.04126451f, -0.02181608f, -0.00188625f, 0.02382140f, -0.05140295f, -0.04880694f, 0.03768812f, -0.01256984f, 
    0.01760513f, -0.00876562f, -0.03267297f, -0.05028733f, 0.05530716f, -0.05134324f, 0.02128839f, 0.01401077f, 
    -0.04325948f, 0.03072101f, 0.02102251f, -0.02709081f, 0.02745096f, -0.03169439f, -0.01858753f, -0.01202699f, 
    -0.03269034f, 0.01437765f, -0.03302014f, 0.00687450f, -0.05087398f, 0.03121300f, -0.00243365f, -0.00009133f, 
    -0.03381241f, 0.00833599f, 0.00979126f, -0.00629602f, 0.03395712f, -0.02170485f, -0.03312381f, -0.03349675f, 
    0.03253202f, -0.06642067f, 0.04291010f, -0.04498952f, -0.00327424f, 0.00528953f, -0.03415847f, 0.03339679f, 
    -0.03696771f, 0.01914106f, 0.05040172f, -0.04013591f, -0.01926478f, 0.01970593f, -0.04745957f, -0.03930066f, 
    -0.05386652f, -0.01887880f, 0.01343036f, -0.03286005f, -0.01478200f, -0.02540042f, -0.05211398f, -0.04389146f, 
    0.04992542f, 0.01844634f, 0.00356087f, -0.00035430f, -0.05442153f, -0.02033821f, -0.00480053f, 0.00455363f, 
    -0.04940952f, -0.05443132f, -0.03756819f, -0.04791237f, 0.00357790f, -0.03796910f, -0.01133200f, -0.05283963f, 
    -0.01363583f, -0.05301026f, -0.01868683f, 0.03226835f, -0.01067920f, -0.05411546f, 0.02817020f, 0.03561290f, 
    -0.03818475f, -0.04286537f, -0.03158046f, -0.05709088f, 0.03406448f, -0.00767710f, 0.00974352f, 0.05281312f, 
    0.04788027f, 0.05171914f, 0.13609770f, 0.07497302f, 0.31011006f, 0.04219486f, -0.02826340f, 0.11355451f, 
    0.00828193f, -0.11354511f, -0.00177469f, -0.00876622f, 0.05543375f, 0.10442970f, 0.02883919f, 0.22067295f, 
    -0.00909716f, 0.04089884f, -0.03455277f, -0.24751388f, -0.22968811f, 0.02377188f, -0.09029049f, -0.09307094f, 
    -0.11102757f, -0.01090722f, -0.09588838f, -0.01865023f, -0.03007578f, 0.03305267f, 0.04476355f, -0.00858105f, 
    0.02609977f, 0.08205744f, 0.08661166f, 0.08299498f, 0.14730637f, 0.06977958f, 0.09451257f, 0.04178288f, 
    1.00842655f, 0.01028996f, -0.20742112f, 0.08842228f, 0.08181134f, 0.09808331f, 0.12894189f, 0.13766930f, 
    0.26142874f, 0.07472420f, -0.02501391f, -0.03805062f, 0.00415873f, 0.00883481f, -0.01567230f, 0.09303930f, 
    -0.08005738f, 0.04123418f, -0.07477353f, 0.03276700f, -0.08427525f, -0.15987816f, 0.36062649f, 0.17219038f, 
    -0.18373437f, -0.02671971f, 0.01105111f, -0.00002750f, 0.06376977f, -0.09644245f, 0.00639065f, 0.09292869f, 
    -0.05030776f, -0.04636612f, 0.06232630f, 0.03482710f, 0.14867690f, 0.10770644f, -0.15744829f, -0.04768538f, 
    -0.05134967f, -0.05646298f, -0.12745862f, -0.00498869f, -0.08378604f, 0.02099970f, -0.03788707f, 0.00417274f, 
    -0.01432502f, 0.00494795f, 0.08870269f, 0.00879939f, 0.14068525f, 0.09711745f, 0.12936459f, 0.04158844f, 
    0.03002962f, 0.03145587f, 0.10122481f, 0.08969508f, 0.02596684f, -0.01993802f, -0.11058723f, 0.06956871f, 
    -0.16967268f, 0.03874747f, -0.04946048f, -0.12205011f, -0.06456043f, -0.01969377f, -0.09513357f, -0.07227830f, 
    -0.01707652f, 0.05729597f, -0.05510502f, -0.03951226f, -0.08819456f, 0.17754504f, -0.08551691f, 0.00727402f, 
    -0.36048397f, 0.05731774f, 0.32282403f, 0.13113296f, 0.00178005f, -0.09827006f, 0.00037841f, -0.16895087f, 
    0.03577242f, 0.06082406f, 0.00266201f, -0.01722011f, 0.08135558f, -0.04591752f, -0.06185447f, 0.07576543f, 
    -0.09327438f, 0.14850222f, -0.05960780f, -0.07186995f, 0.74431401f, 0.52573168f, -0.27619898f, -0.26454914f, 
    -0.09063237f, 0.10889557f, -0.07057475f, -0.02883258f, 0.09463217f, 0.00544376f, -0.02733006f, 0.10048045f, 
    -0.15323071f, 0.19846228f, -0.18225391f, -0.12258544f, -0.04356684f, 0.09806950f, 0.01145533f, 0.08216082f, 
    0.06297112f, -0.08783288f, 0.38325080f, 0.04252526f, 0.21889874f, 0.03568489f, 0.10421112f, 0.06316856f, 
    -0.00623560f, -0.04278357f, -0.00417215f, 0.05526783f, -0.06790918f, -0.09558088f, 0.00444440f, 0.02585001f, 
    -0.00312121f, 0.04641125f, -0.08286604f, 0.13302934f, -0.10066518f, -0.16321473f, -0.08684248f, 0.06130444f, 
    0.35031277f, -0.13024813f, 0.12592562f, -0.03910489f, 0.05232175f, 0.01716768f, 0.01301581f, -0.03899492f, 
    -0.03738550f, 0.08644642f, 0.05575112f, 0.16052932f, 0.02612785f, -0.06854276f, -0.00379105f, 0.16772974f, 
    0.13375618f, 0.52995473f, -0.03993443f, 0.14044183f, -0.14631604f, 0.02760576f, -0.10836712f, -0.08589421f, 
    -0.02147395f, -0.01349778f, 0.03911211f, 0.02148516f, -0.03294191f, -0.05371929f, 0.18202960f, -0.03975471f, 
    -0.00436889f, -0.02452543f, -0.02044351f, 0.04233199f, 0.03483844f, -0.12551475f, 0.13386221f, -0.06372914f, 
    -0.02941541f, -0.03402940f, -0.04897999f, -0.15262881f, -0.09000000f, 0.03703120f, -0.01851046f, 0.09866192f, 
    0.04161630f, -0.05589986f, 0.00953042f, 0.04315522f, 0.01863659f, 0.02174052f, 0.17459704f, 0.17138694f, 
    -0.45527419f, -0.23151024f, -0.00482038f, 0.17022301f, 0.17489572f, 0.03169999f, 0.05472222f, 0.01689978f, 
    -0.09395262f, -0.16974352f, 0.00463576f, -0.00434574f, -0.04770236f, 0.14646815f, 0.08508232f, -0.00263903f, 
    0.00398595f, -0.08654214f, -0.05894198f, -0.07707762f, -0.42766026f, 0.07967916f, 0.30966976f, -0.06795999f, 
    -0.13429107f, 0.01500219f, -0.14111264f, -0.14426252f, -0.04165052f, -0.00086176f, -0.02321496f, 0.01189022f, 
    -0.06126924f, -0.06414252f, -0.02228947f, -0.01970987f, -0.08180254f, 0.19364369f, -0.08434003f, 0.00381814f, 
    -0.51836598f, 0.04591877f, 0.22419249f, -0.19305873f, 0.09595618f, -0.06288070f, 0.09533822f, 0.07706423f, 
    -0.05614963f, 0.06735595f, 0.00433826f, -0.01561102f, 0.02798056f, 0.08490299f, 0.15036318f, -0.11537695f, 
    -0.11512575f, 0.07501293f, 0.01489845f, -0.13952717f, 0.04900417f, -0.25566074f, -0.03790477f, 0.07401790f, 
    0.06521610f, 0.01428508f, -0.11071066f, 0.09999250f, 0.15668528f, 0.15723915f, 0.02388768f, 0.08640135f, 
    0.01082718f, -0.05049054f, -0.02456457f, -0.07731520f, 0.03648245f, 0.11062898f, 0.07619122f, -0.03603949f, 
    -0.19863874f, -0.04352288f, 0.02761389f, 0.21663623f, 0.06341013f, 0.02479429f, 0.02170606f, -0.12765291f, 
    -0.03632833f, 0.00594823f, 0.04089453f, 0.02693129f, 0.00895857f, 0.05072866f, 0.15626714f, 0.09792854f, 
    0.00189472f, 0.11538946f, 0.02036755f, 0.14721563f, 0.11028786f, 0.08632674f, 0.10658301f, 0.00317470f, 
    -0.23461139f, 0.05386976f, -0.05217300f, 0.07245176f, 0.04406762f, -0.07155099f, 0.02621361f, -0.08166911f, 
    -0.05770231f, -0.05000353f, -0.15516925f, -0.00969856f, 0.04326217f, -0.00058475f, -0.14140718f, -0.00947267f, 
    0.32049614f, -0.34829742f, 0.04998657f, -0.31129867f, 0.22564277f, -0.11386158f, 0.04699157f, -0.09981723f, 
    0.16317901f, 0.00895983f, 0.17504524f, 0.05966220f, 0.07441197f, 0.00429803f, -0.00256611f, -0.04410548f, 
    -0.02386566f, -0.03590331f, -0.01655729f, -0.00711739f, -0.12836237f, -0.31098762f, 0.01479242f, 0.36274087f, 
    0.20398574f, 0.08535895f, -0.09504987f, 0.04821657f, -0.11955807f, -0.08511657f, -0.01494675f, 0.02145225f, 
    -0.02369139f, 0.03257798f, 0.06394595f, 0.08119881f, 0.23375812f, 0.18013661f, -0.11805605f, 0.07478831f, 
    0.02725597f, 0.03070177f, -0.02985381f, -0.03331478f, -0.10296807f, 0.05665524f, -0.03348412f, 0.03703475f, 
    -0.02562945f, 0.02205774f, 0.03492331f, 0.11091325f, 0.03242271f, -0.03289433f, 0.17108038f, 0.05584524f, 
    -0.04786912f, -0.07730165f, -0.08942191f, -0.09476738f, 0.33892015f, -0.00095768f, 0.06582254f, -0.16712774f, 
    0.07297191f, 0.05368321f, 0.16986908f, -0.13004763f, -0.01767172f, -0.08755986f, -0.03350610f, -0.03022490f, 
    0.04883434f, -0.08874126f, -0.01424364f, -0.07956591f, -0.02505709f, 0.00488501f, -0.08022897f, 0.01182351f, 
    0.40356126f, 0.15244363f, 0.15502544f, 0.04529126f, -0.01465517f, -0.04948616f, 0.03413806f, -0.02968718f, 
    0.03119615f, -0.06756321f, -0.07685717f, 0.07283363f, -0.02182025f, -0.02568250f, -0.01338971f, 0.08810301f, 
    -0.01566887f, 0.20998567f, -0.06466909f, 0.12842777f, 0.29368952f, -0.11346941f, -0.28950953f, -0.14618272f, 
    -0.14175105f, 0.01295044f, -0.13110566f, -0.05912488f, 0.00445478f, 0.27960661f, -0.05924014f, 0.04791757f, 
    0.15410919f, 0.07071197f, 0.00556414f, 0.01084390f, 0.04871557f, 0.04989474f, 0.04379245f, 0.05821510f, 
    -0.01333022f, -0.23059379f, 0.23705921f, 0.38502908f, 0.17994288f, -0.01353716f, -0.11084642f, -0.06472600f, 
    -0.04544477f, -0.07303242f, -0.04944454f, -0.01254888f, 0.04192754f, -0.06228711f, 0.04193051f, -0.03718978f, 
    0.00180017f, -0.09831218f, 0.03879617f, 0.06143619f, -0.15909484f, -0.17151026f, 0.13842413f, 0.20345405f, 
    0.29463699f, -0.12000199f, 0.14424482f, 0.13692793f, 0.22231409f, -0.26128644f, -0.07512157f, -0.11472209f, 
    0.03804444f, 0.01592594f, 0.11207458f, 0.08301452f, 0.04386009f, 0.02209803f, 0.00691487f, 0.04751580f, 
    0.07210300f, 0.08594833f, -0.09926942f, 0.13193803f, 0.15352575f, 0.15268131f, 0.05060810f, 0.11877862f, 
    -0.10608459f, -0.08771234f, 0.01701192f, -0.03787188f, -0.03059550f, -0.04491070f, -0.12915285f, 0.07568218f, 
    0.08515175f, 0.09286109f, -0.08354248f, -0.06021207f, -0.18326065f, -0.00384079f, 0.10785181f, 0.13565914f, 
    -0.06158060f, 0.01826299f, -0.12316285f, -0.01338746f, -0.00951691f, 0.05022080f, -0.14389467f, 0.07078739f, 
    0.05764533f, 0.01929842f, 0.03934864f, -0.01363261f, -0.09383284f, 0.04413620f, -0.05841822f, -0.20666380f, 
    -0.21086344f, -0.10917532f, 0.08909633f, 0.37185940f, -0.01533118f, -0.00133730f, -0.03100454f, 0.06855966f, 
    -0.01391485f, -0.09245681f, -0.03032676f, -0.01377122f, 0.09438027f, 0.09572680f, 0.01268101f, 0.03010417f, 
    0.21296977f, 0.06397985f, 0.09649665f, 0.01782286f, 0.35228565f, 0.14886045f, 0.28077438f, 0.00602293f, 
    -0.13472132f, -0.07426814f, -0.02520288f, 0.00434362f, 0.03960244f, -0.00430569f, -0.02874712f, -0.01505860f, 
    -0.03677610f, -0.05719924f, -0.04582154f, -0.13098940f, 0.04211338f, 0.03795356f, 0.00684230f, 0.10609993f, 
    -0.43841797f, 0.00758632f, 0.16191992f, -0.03303001f, 0.01537942f, -0.16266616f, 0.06950510f, -0.04867313f, 
    0.13395655f, 0.07026751f, 0.00240340f, 0.02868670f, 0.09570742f, 0.07421481f, -0.02476663f, -0.06246536f, 
    -0.08973457f, -0.02026736f, -0.02054838f, -0.05581306f, -0.11654285f, -0.18486939f, -0.03478507f, 0.34449860f, 
    -0.01167887f, -0.18259785f, -0.10914743f, -0.06950019f, -0.08327744f, 0.07209390f, 0.06539433f, 0.16409680f, 
    0.00897634f, -0.03842809f, -0.05974574f, 0.01524293f, -0.06074769f, 0.04322214f, -0.17148665f, -0.19550990f, 
    0.02344334f, 0.08385491f, 0.14125703f, -0.11868586f, -0.10454353f, 0.06379297f, 0.02283280f, -0.05145211f, 
    -0.03132451f, 0.22850777f, -0.01663589f, -0.02166829f, -0.14260244f, -0.06334968f, -0.17271015f, -0.08190699f, 
    0.08137178f, 0.02893791f, -0.18977167f, 0.26747379f, -0.07875447f, -0.14556207f, 0.02010228f, 0.03211664f, 
    0.01847157f, 0.00929551f, 0.02903324f, 0.03699166f, 0.04376772f, -0.07929111f, -0.05623473f, 0.14934836f, 
    -0.02563929f, -0.14959240f, 0.03443722f, -0.01540069f, -0.10018164f, -0.02577924f, -0.00176579f, 0.02431533f, 
    0.05178759f, -0.01853692f, 0.37420842f, 0.10653342f, -0.07222865f, -0.08686896f, -0.00886757f, 0.10501559f, 
    0.04319496f, -0.12097992f, 0.02960813f, 0.04420459f, -0.05885573f, -0.05539968f, 0.14150482f, 0.06245463f, 
    -0.06123255f, -0.01214414f, -0.08727101f, -0.06013050f, 0.21748771f, 0.26389661f, -0.08814675f, 0.04558313f, 
    0.20479010f, 0.08652801f, 0.04939428f, 0.19990101f, 0.11389263f, 0.18424134f, 0.07039065f, -0.03380269f, 
    0.04447398f, -0.05713731f, -0.03957564f, 0.17299357f, -0.10257105f, -0.00621122f, 0.07052828f, 0.06080029f, 
    -0.03492725f, -0.05225006f, 0.07559235f, -0.06587867f, -0.01409358f, -0.03888051f, -0.05986750f, 0.05438287f, 
    0.00531401f, -0.06384086f, -0.03852872f, -0.02341556f, -0.19658467f, -0.13727172f, -0.08526697f, -0.02722654f, 
    -0.00738239f, -0.03354295f, 0.00459667f, 0.03690962f, -0.18568978f, -0.01881636f, 0.05861198f, -0.00223313f, 
    -0.10258706f, -0.08749188f, 0.06545751f, 0.03446579f, -0.01099974f, -0.04230512f, 0.12649754f, -0.01793538f, 
    -0.04817953f, 0.03106814f, 0.09247550f, 0.02438467f, 0.04912587f, -0.05204276f, 0.00679152f, -0.00295384f, 
    -0.46660656f, -0.18629096f, -0.36268729f, -0.17741863f, 0.02278567f, 0.01675200f, -0.09332183f, -0.01758391f, 
    0.02311859f, 0.05342628f, -0.05521812f, 0.09002915f, -0.01255778f, -0.05246315f, 0.06129738f, -0.05340195f, 
    0.21150255f, -0.04271304f, 0.06387419f, -0.01657053f, 0.18261066f, -0.56648850f, 0.42518818f, 0.06460365f, 
    -0.08367588f, -0.14507033f, 0.03015017f, 0.09871943f, -0.03524996f, -0.07026692f, -0.02156103f, 0.00570353f, 
    0.01534388f, -0.08042457f, 0.02710990f, 0.00618347f, 0.08121741f, 0.00908360f, -0.21184038f, 0.09741425f, 
    0.12608442f, 0.30608815f, 0.00126065f, 0.08103660f, -0.09981661f, 0.05661204f, 0.12617919f, 0.09826706f, 
    -0.06497283f, 0.28727546f, 0.02828622f, 0.01925976f, 0.06833541f, 0.10320048f, -0.09001130f, -0.07863685f, 
    0.05891977f, -0.01857049f, 0.01038279f, 0.05492087f, 0.05628421f, 0.07581567f, 0.24398378f, 0.07419638f, 
    -0.10976767f, 0.08029906f, 0.04629057f, 0.23407373f, 0.03635365f, -0.08953576f, -0.06155635f, -0.06299479f, 
    0.02323481f, 0.02330483f, 0.13137639f, -0.02640453f, 0.06592912f, 0.04267609f, 0.02140358f, -0.25236937f, 
    0.01227942f, -0.42542011f, 0.31602389f, -0.14510722f, -0.09379012f, -0.03097302f, -0.07837559f, 0.06023412f, 
    -0.00026725f, 0.05428560f, -0.06971619f, 0.01820134f, 0.05439490f, 0.03105540f, -0.10191160f, -0.14038326f, 
    0.03182154f, -0.03820509f, -0.05193283f, 0.05800259f, 0.02205719f, 0.18889739f, 0.01116923f, -0.06642250f, 
    -0.11780175f, 0.14980327f, 0.01874525f, 0.08758695f, 0.00628411f, 0.14871976f, 0.01036554f, 0.18608101f, 
    0.05421761f, -0.03038520f, 0.02293341f, -0.07655337f, -0.07888985f, -0.01378142f, 0.05829750f, -0.04210133f, 
    0.53555834f, 0.21879999f, 0.05293424f, 0.03576776f, 0.11512908f, -0.12915532f, 0.15576079f, 0.01386462f, 
    0.05239228f, 0.12170579f, 0.01222687f, 0.05065050f, -0.03924480f, -0.10236939f, 0.11893065f, 0.07437956f, 
    0.05078458f, 0.02446570f, 0.04636165f, 0.07759685f, -0.30011684f, -0.09788666f, -0.22983328f, -0.01012674f, 
    0.02956150f, -0.05307835f, 0.02623093f, 0.07944208f, -0.06064538f, -0.10090019f, -0.01313104f, 0.04479931f, 
    0.00419483f, -0.00523290f, 0.02988233f, 0.07952381f, 0.22193097f, -0.10300098f, -0.02807420f, -0.06596325f, 
    0.43239623f, -0.14258270f, 0.04237201f, 0.11875451f, -0.10299190f, -0.02622003f, -0.11016175f, -0.06359732f, 
    0.02717963f, -0.00640382f, 0.01348299f, -0.01381987f, -0.16853064f, 0.06718771f, -0.06695685f, -0.00207796f, 
    0.10253042f, -0.04551863f, 0.01457062f, 0.01806381f, 0.56104505f, 0.29220006f, 0.02974077f, 0.10364792f, 
    0.08177507f, -0.01740500f, 0.10073722f, 0.07225329f, -0.10270450f, 0.03650589f, 0.03520573f, -0.08979438f, 
    0.12928395f, 0.08292290f, 0.04012474f, -0.06429696f, -0.01831895f, -0.01574387f, -0.03876401f, 0.01405744f, 
    0.16125475f, -0.14272587f, 0.10073467f, 0.04611895f, -0.10774153f, 0.03461824f, 0.13105130f, 0.11306837f, 
    0.16663775f, 0.05860177f, 0.01907849f, 0.05489751f, 0.11975212f, 0.09375954f, 0.14776990f, -0.04876857f, 
    0.08065914f, 0.13373591f, 0.07839026f, 0.04017807f, 0.03319838f, -0.02240931f, 0.05303553f, -0.09719573f, 
    0.01354251f, -0.05632324f, 0.00630469f, -0.09769170f, -0.06275991f, -0.05261912f, -0.01283298f, -0.06874593f, 
    0.06222200f, -0.06482258f, -0.04414189f, -0.02771712f, -0.03829733f, -0.00927097f, -0.03266263f, -0.03298549f, 
    -0.60760635f, 0.29661795f, -0.24469757f, 0.25720844f, 0.13067894f, 0.08222099f, -0.10452741f, 0.19655791f, 
    -0.10187674f, 0.03404338f, 0.00776711f, 0.09485734f, -0.03800100f, 0.14058152f, -0.04178260f, 0.05076934f, 
    0.07042906f, 0.00796580f, 0.15209740f, -0.01515872f, -0.22246696f, -0.12999380f, -0.40657336f, -0.16415362f, 
    -0.04740791f, -0.02286275f, 0.05992704f, -0.14216034f, 0.04885368f, -0.04991443f, 0.02900027f, 0.01499323f, 
    0.12419061f, 0.04706781f, 0.02583333f, -0.08116689f, -0.00604164f, -0.08244076f, 0.08308034f, -0.16350263f, 
    -0.05341347f, -0.01114917f, -0.04806297f, -0.05455479f, 0.00896404f, -0.01352265f, -0.00741725f, -0.04052141f, 
    -0.01431615f, 0.00973574f, 0.08336768f, 0.17360845f, 0.12026831f, 0.14329012f, 0.00249501f, 0.06329967f, 
    0.06132588f, -0.04025881f, 0.04778255f, 0.00030704f, 0.06345070f, 0.02658765f, -0.14629067f, -0.13440073f, 
    0.07751953f, -0.05430377f, -0.03650105f, 0.08353802f, -0.01918237f, 0.00534416f, -0.00595959f, 0.04771845f, 
    -0.00942424f, -0.01635820f, -0.06538207f, 0.12336899f, 0.08391190f, -0.07169334f, 0.20911241f, -0.04964309f, 
    -0.02260083f, -0.01001045f, 0.00223978f, -0.28811064f, -0.11734533f, 0.00499038f, -0.06153263f, 0.07355826f, 
    -0.12966812f, -0.05090998f, -0.04307774f, -0.10258718f, -0.05984283f, -0.00709353f, -0.09342425f, 0.14643508f, 
    0.17008059f, -0.07060678f, 0.16471168f, 0.07174739f, -0.39435560f, -0.11497671f, 0.26422158f, 0.18485318f, 
    0.21751538f, -0.00624586f, -0.02669164f, 0.00906828f, -0.11471298f, -0.04417100f, 0.05201581f, 0.19932057f, 
    0.28339508f, 0.02972644f, 0.31238174f, 0.13258171f, 0.08093292f, -0.17605376f, 0.04466787f, -0.02318539f, 
    -0.21028499f, -0.31621662f, -0.36697567f, -0.25655687f, -0.19459473f, 0.06291270f, 0.07794367f, 0.08710035f, 
    0.07544971f, -0.18244341f, 0.07566982f, 0.00674299f, -0.04167660f, 0.07008280f, 0.01221958f, 0.07308778f, 
    0.11843327f, 0.07868026f, 0.07900346f, -0.05212194f, 0.03693087f, -0.01732622f, -0.20600615f, 0.00216881f, 
    -0.06097807f, 0.05372490f, -0.00366936f, 0.12264141f, 0.00848747f, 0.06648299f, 0.11439900f, 0.04368926f, 
    -0.04131430f, 0.02731992f, -0.11891437f, 0.06705517f, 0.04118731f, 0.00748334f, -0.03339439f, -0.00262141f, 
    0.03150593f, -0.16363370f, 0.19339032f, -0.00035969f, 0.16247538f, -0.03195025f, 0.09512096f, -0.15712200f, 
    0.07282712f, -0.00293039f, 0.02709414f, 0.04767021f, 0.11453341f, 0.05311847f, -0.08599081f, 0.18189521f, 
    0.21142897f, 0.05314149f, 0.07903087f, -0.07062870f, -0.10038796f, -0.24948291f, -0.15169893f, 0.03651243f, 
    -0.01868068f, -0.01827045f, -0.10893151f, 0.03227925f, 0.00375447f, -0.24452703f, 0.06813582f, -0.08094619f, 
    0.03170610f, -0.03161328f, -0.02684479f, -0.01939804f, 0.14295326f, 0.08166128f, 0.07852418f, 0.05994264f, 
    0.10155097f, 0.07526761f, -0.13561337f, 0.03999115f, -0.11538465f, 0.09743362f, -0.09046620f, -0.00109340f, 
    0.25474194f, 0.09471307f, 0.07596710f, 0.03068542f, 0.01622307f, -0.16848531f, -0.07771796f, -0.04871713f, 
    0.03837157f, 0.05991200f, -0.10743914f, -0.10365301f, 0.09698128f, -0.16724078f, -0.36220321f, -0.21982177f, 
    -0.01205331f, -0.07415050f, 0.03933894f, 0.05519423f, -0.10184690f, -0.06911355f, -0.07390847f, -0.07526323f, 
    -0.10570109f, -0.08042391f, -0.09908182f, 0.01288295f, 0.01139693f, -0.03920260f, 0.10862511f, 0.03256379f, 
    0.64758748f, 0.23877503f, 0.36188379f, 0.06746515f, 0.11697744f, 0.01503349f, -0.01342079f, -0.01535180f, 
    0.03308177f, -0.10221937f, 0.22782561f, 0.07136036f, 0.20805857f, 0.06745929f, 0.06499908f, 0.10602514f, 
    0.04997661f, -0.05037737f, 0.05214542f, 0.02855842f, -0.42761195f, -0.21341169f, 0.14952414f, -0.29484701f, 
    -0.13991311f, -0.15909329f, 0.00671303f, -0.07069812f, -0.05379164f, -0.04185750f, -0.04158700f, -0.00179183f, 
    -0.03377078f, -0.01542291f, -0.02019631f, -0.05339842f, -0.00615352f, -0.06285736f, 0.02308424f, 0.00354612f, 
    -0.00122754f, 0.04768370f, -0.01803852f, 0.02988076f, -0.03194539f, 0.01561078f, -0.02850542f, -0.02021496f, 
    -0.05412170f, -0.02423990f, -0.02079600f, -0.06018835f, -0.02900680f, -0.04018775f, 0.00708172f, -0.04907005f, 
    0.00607543f, 0.02605739f, 0.00585495f, 0.00999369f, 0.03788912f, -0.01452773f, 0.03614265f, 0.03893504f, 
    -0.02853507f, -0.05690754f, 0.01821746f, -0.06240733f, 0.00805885f, -0.01113540f, -0.01240624f, -0.01857119f, 
    -0.05535739f, -0.05534659f, -0.04317160f, 0.00719117f, -0.01194461f, -0.01537983f, 0.01050840f, -0.02850527f, 
    0.04393902f, 0.03959939f, -0.05619062f, 0.06134959f, -0.03632060f, 0.04474816f, -0.04055950f, 0.03443628f, 
    -0.01332959f, -0.05903275f, -0.03968454f, -0.06116914f, -0.00776790f, -0.05504031f, -0.01263069f, -0.04525398f, 
    0.03565577f, -0.00750532f, 0.00007367f, -0.01995177f, 0.02465108f, -0.00821327f, -0.05570627f, -0.01806212f, 
    -0.02907898f, -0.04291333f, -0.06165554f, 0.00383627f, 0.00495896f, -0.04774418f, -0.03609153f, -0.05656022f, 
    0.02694988f, -0.03151602f, 0.00727069f, 0.03565463f, 0.02388149f, 0.03516091f, -0.02670644f, 0.00372711f, 
    -0.04237943f, 0.03325658f, -0.02363850f, -0.02053271f, -0.03733314f, -0.03358363f, -0.00736446f, -0.05240809f, 
    0.03577073f, 0.04634268f, 0.04961482f, 0.04504892f, 0.02208658f, -0.02178963f, -0.05239493f, 0.04003518f, 
    -0.01106478f, 0.01516872f, -0.01483225f, 0.03523090f, -0.03896787f, -0.01789719f, 0.04280420f, -0.03241589f, 
    -0.03753832f, -0.05137458f, 0.02113855f, -0.02600505f, -0.04346380f, -0.01281902f, 0.03245015f, 0.04299695f, 
    0.01407320f, -0.03758757f, -0.03445832f, -0.00362686f, 0.01507884f, 0.01831284f, 0.00377779f, -0.02152802f, 
    -0.02306532f, -0.05683153f, 0.04239542f, 0.00612537f, 0.04486198f, -0.00235670f, -0.05799206f, -0.01420285f, 
    -0.00274486f, -0.01532206f, 0.03873551f, 0.04173442f, 0.01953695f, -0.04371725f, 0.04687088f, 0.03305988f, 
    -0.02763896f, -0.00484708f, 0.04003353f, -0.01121881f, 0.03931929f, 0.00388011f, 0.03545399f, 0.04869264f, 
    -0.00612297f, 0.00100047f, -0.00423277f, -0.05586245f, 0.00965879f, 0.01175768f, 0.02197392f, -0.03535295f, 
    -0.03639619f, -0.04197230f, 0.02811880f, -0.02182214f, -0.00554861f, 0.02136412f, 0.03054167f, 0.01882144f, 
    -0.01010347f, 0.01556035f, 0.04805195f, 0.03519711f, -0.04576395f, 0.03018560f, -0.05545071f, -0.02739445f, 
    0.01301439f, 0.00135355f, -0.01536238f, 0.03995247f, 0.00700671f, -0.02097030f, -0.04962946f, -0.01657957f, 
    -0.02837227f, 0.00882791f, 0.04008265f, 0.00550652f, 0.01930815f, 0.00829235f, 0.01217593f, 0.00638698f, 
    0.04749658f, -0.03236073f, 0.04386573f, -0.01340265f, -0.01423158f, 0.00755989f, 0.03734438f, 0.01271105f, 
    0.00222325f, 0.03865740f, 0.01208340f, -0.02870424f, -0.05580379f, -0.01341955f, -0.01662690f, -0.03551646f, 
    -0.04680198f, -0.04539616f, -0.03506083f, 0.04484046f, 0.01817920f, -0.04128170f, -0.03914212f, -0.04935947f, 
    -0.04280914f, 0.00257623f, -0.05971880f, -0.04459035f, -0.02882443f, -0.04883851f, -0.03149273f, 0.01740623f, 
    -0.00765309f, 0.02918510f, -0.05548479f, 0.02840413f, 0.02642250f, 0.01312147f, -0.05858082f, 0.02264991f, 
    -0.04286803f, 0.04760378f, -0.02940450f, -0.01968139f, -0.03896362f, -0.02796122f, -0.03750335f, 0.01902737f, 
    0.01801937f, -0.04399457f, 0.03818087f, -0.01261131f, 0.04490349f, -0.01509066f, 0.01513722f, -0.01418820f, 
    -0.00624675f, -0.03312243f, -0.04504020f, 0.00344913f, -0.02393305f, 0.00724973f, 0.03916318f, 0.05051817f, 
    0.00205248f, 0.01444410f, -0.01384971f, 0.00988306f, 0.03612585f, -0.04626289f, 0.02013356f, -0.01679833f, 
    -0.04470740f, -0.03128212f, -0.05411071f, 0.02162562f, -0.05894371f, -0.05616719f, 0.00259240f, 0.02045265f, 
    -0.04607780f, -0.06184743f, -0.02369365f, -0.01866794f, 0.03775394f, -0.05089008f, 0.00658142f, 0.01535632f, 
    0.01490933f, 0.03774139f, 0.04760826f, -0.02191588f, -0.05393304f, -0.00801319f, 0.04218958f, 0.00406763f, 
    0.03896565f, -0.02416210f, -0.01573228f, 0.01175236f, 0.04374615f, 0.01049142f, -0.03110844f, -0.02804794f, 
    0.01778825f, 0.01982522f, 0.01099503f, 0.00292793f, -0.05515154f, -0.02963579f, -0.03149642f, -0.01387756f, 
    -0.04944764f, 0.03719179f, 0.01269404f, -0.04402888f, 0.00329439f, 0.02220737f, -0.01681178f, 0.04195574f, 
    -0.04682757f, 0.04950052f, 0.04012414f, 0.03720324f, 0.00428407f, -0.01941646f, 0.00708624f, 0.02623934f, 
    0.03865155f, -0.01465295f, 0.03197228f, 0.01370764f, 0.01667853f, -0.04162791f, -0.04599298f, -0.04309680f, 
    0.00493372f, 0.08247341f, 0.15139526f, 0.03090156f, 0.15341507f, 0.07212081f, 0.00027480f, 0.14358269f, 
    0.04671850f, 0.07106534f, 0.02946852f, 0.03605196f, 0.06224034f, 0.00290890f, 0.03408821f, 0.07654771f, 
    0.21153682f, 0.09768965f, 0.13117851f, 0.00721998f, -0.22894315f, -0.30272827f, -0.26481274f, -0.26260158f, 
    0.08890706f, -0.06309748f, -0.05426644f, -0.14511450f, -0.03192405f, -0.06859344f, 0.07037129f, 0.09222055f, 
    0.03262561f, 0.07519555f, 0.03731861f, 0.26335236f, 0.08974390f, 0.08546375f, 0.10744353f, 0.05290835f, 
    0.12465068f, 0.28389683f, -0.10769267f, 0.47116199f, -0.06732057f, -0.04405203f, -0.13758412f, -0.07284598f, 
    -0.00941358f, -0.01371154f, 0.05096160f, 0.04762289f, 0.05627516f, 0.05784849f, 0.06691597f, -0.07846806f, 
    -0.11897749f, 0.11378999f, -0.04212735f, 0.12081911f, -0.20164080f, -0.11750475f, 0.19852120f, 0.35068053f, 
    -0.24753994f, 0.02161231f, 0.02831811f, 0.11531743f, 0.05337238f, 0.11058086f, -0.02444739f, 0.08980167f, 
    0.00285246f, -0.03061990f, -0.09526687f, 0.02633095f, 0.05696253f, 0.00462628f, -0.05721147f, 0.05370394f, 
    -0.12383769f, -0.19294263f, -0.22742590f, -0.08295608f, -0.04337480f, -0.05365627f, -0.04960296f, -0.07369209f, 
    -0.05427872f, -0.10143729f, -0.02589412f, 0.01191994f, 0.04736060f, 0.06448040f, 0.22788945f, 0.14150597f, 
    0.08489130f, 0.08571633f, 0.03970386f, 0.05073151f, -0.59289759f, -0.23569514f, -0.48199773f, 0.04239240f, 
    -0.15984714f, -0.06238275f, 0.04705721f, -0.04122771f, -0.12702410f, -0.04064387f, 0.09593122f, -0.02047945f, 
    -0.01444810f, -0.02202507f, 0.06474049f, 0.06358857f, 0.01828790f, 0.10763743f, 0.05422399f, 0.03131261f, 
    -0.33545187f, -0.38661841f, -0.40476340f, -0.20003834f, -0.01352904f, 0.01315706f, -0.07649982f, -0.00412558f, 
    -0.07531010f, 0.08005738f, 0.02813503f, 0.01513035f, -0.00824694f, -0.02282375f, 0.00412111f, 0.02307233f, 
    0.00918938f, 0.10751706f, 0.05927047f, 0.07646336f, -0.03905700f, 0.19636406f, -0.07839627f, 0.32908100f, 
    -0.04981774f, 0.17784974f, -0.11651680f, -0.09969761f, -0.08635890f, -0.04971413f, -0.04934777f, -0.12120359f, 
    -0.03285702f, -0.05211730f, 0.10237225f, -0.04896588f, 0.08076011f, 0.01239154f, -0.00831153f, 0.04422933f, 
    0.04647589f, 0.28340197f, 0.20893832f, 0.24812549f, 0.11283495f, 0.03292271f, 0.10950784f, 0.08038440f, 
    0.03826824f, 0.27945411f, -0.06895247f, -0.00989586f, -0.08137589f, -0.00702159f, -0.00190599f, -0.03112836f, 
    0.00663700f, -0.04984588f, -0.05020569f, -0.05558535f, -0.14593810f, 0.01295643f, -0.06377192f, 0.05535640f, 
    0.00610230f, -0.02634927f, 0.04231500f, -0.05617861f, 0.10262881f, 0.07810129f, 0.03563945f, 0.02052243f, 
    0.03673058f, 0.02389178f, -0.02815077f, -0.08855494f, 0.21803343f, -0.08046193f, 0.00138201f, 0.03088395f, 
    -0.40022856f, -0.23439516f, -0.01151861f, -0.18901044f, -0.09031267f, 0.03731986f, -0.01345584f, -0.05370146f, 
    0.05264406f, -0.00197835f, 0.05588095f, 0.02175213f, -0.02811418f, -0.04488088f, 0.20341262f, -0.04305805f, 
    -0.04494026f, -0.00779567f, 0.11770556f, 0.02688014f, 0.05117746f, 0.08701541f, -0.02471128f, -0.17505844f, 
    0.19520353f, 0.03207385f, -0.02269113f, 0.12744361f, 0.09262198f, 0.07430100f, 0.02702592f, 0.00171197f, 
    -0.01418827f, 0.07779846f, 0.04696581f, 0.20257185f, -0.10389375f, 0.03768580f, -0.10078728f, -0.10900406f, 
    -0.32612020f, -0.15934965f, 0.12352411f, 0.30413494f, 0.04075568f, -0.00043124f, 0.07846794f, -0.03485068f, 
    0.00718296f, -0.05933195f, 0.11735759f, -0.06411514f, -0.01357113f, 0.08243450f, 0.05373228f, 0.11481319f, 
    0.14963439f, -0.07357933f, 0.00536553f, 0.01639037f, -0.58455235f, -0.28221521f, -0.57148254f, -0.07622178f, 
    -0.08288281f, -0.02716493f, 0.06573414f, 0.07432070f, -0.04996721f, -0.02832655f, 0.09436247f, -0.00025425f, 
    -0.03632462f, 0.04057824f, -0.01998068f, 0.04725307f, 0.04947788f, 0.05019395f, -0.06089611f, -0.03240345f, 
    0.09490602f, 0.01760045f, 0.31812403f, -0.12624943f, -0.08747686f, -0.01915725f, -0.18448727f, -0.04128182f, 
    -0.02598457f, -0.12872118f, -0.03515110f, -0.01743065f, 0.11909637f, 0.10527026f, 0.16216958f, -0.00242311f, 
    -0.06900851f, 0.06406395f, 0.04469804f, 0.00258343f, -0.02837077f, -0.00552639f, 0.24268955f, 0.17845121f, 
    0.19211982f, 0.13737191f, 0.00264691f, -0.06407663f, 0.20020814f, 0.08266854f, 0.03021829f, 0.03835115f, 
    0.19552548f, 0.14839981f, -0.02714276f, 0.08142166f, 0.01214772f, 0.08900833f, 0.03233451f, 0.10185800f, 
    0.17832869f, -0.07295326f, -0.35731584f, -0.04788157f, 0.14204203f, -0.09288615f, 0.05248865f, 0.04727040f, 
    0.02453399f, 0.17862383f, 0.09516608f, 0.10121635f, 0.06213894f, 0.11354417f, 0.01550028f, -0.00449829f, 
    0.11519095f, -0.08948460f, 0.13477470f, -0.00295994f, -0.17952783f, -0.15157156f, -0.12476513f, -0.11411252f, 
    -0.01131742f, -0.01907776f, -0.01983266f, -0.09690434f, -0.08410536f, -0.03845061f, -0.07943940f, 0.08576789f, 
    -0.00220633f, 0.01047185f, -0.04537664f, -0.06287758f, 0.03609402f, -0.06026115f, -0.12039226f, -0.00010686f, 
    0.04926331f, -0.09724463f, -0.21970455f, -0.04543569f, -0.00881778f, 0.41183496f, -0.11290395f, -0.04834953f, 
    0.02326694f, -0.19163619f, 0.00753922f, 0.12012727f, -0.03554906f, 0.13755530f, 0.02795435f, 0.12727784f, 
    0.04869081f, -0.06216176f, 0.07111724f, 0.13036925f, 0.10467261f, 0.24424151f, -0.07089134f, -0.10860960f, 
    0.06678741f, -0.01013520f, -0.19787627f, -0.07158651f, 0.07505892f, 0.01023010f, 0.08285217f, 0.12244786f, 
    0.09614326f, 0.08310090f, 0.00179085f, 0.00505829f, 0.05010604f, 0.14624724f, -0.13396053f, -0.06015841f, 
    -0.16968064f, -0.11888998f, -0.08489511f, -0.14400104f, -0.07823039f, -0.05158829f, -0.00451958f, 0.03150108f, 
    -0.08163381f, -0.06003313f, 0.11786802f, 0.10604021f, -0.03389705f, 0.02959152f, 0.10807797f, 0.06105353f, 
    0.07038691f, 0.00790963f, -0.10724626f, -0.05492598f, 0.06929909f, 0.09275750f, 0.01169022f, 0.03147494f, 
    -0.06110747f, 0.03772191f, -0.00743870f, 0.04460282f, -0.08539743f, -0.11998107f, 0.09100671f, -0.04386798f, 
    -0.13402592f, 0.04311556f, 0.02277814f, -0.08852284f, 0.16968918f, -0.04860887f, 0.05263012f, 0.01614772f, 
    -0.27025610f, -0.02864534f, 0.05622787f, 0.00392458f, -0.22628222f, 0.08813404f, 0.02086627f, -0.07692727f, 
    -0.01334318f, -0.02605524f, -0.06641234f, -0.07527219f, -0.04594336f, 0.03850793f, 0.01499441f, 0.12933446f, 
    0.17733788f, 0.03836072f, -0.05002677f, -0.00918530f, -0.32354310f, -0.06766701f, -0.42445254f, -0.06705830f, 
    0.05151950f, 0.08780105f, 0.25613084f, -0.06336390f, -0.04482697f, 0.01333793f, 0.03678687f, 0.05913850f, 
    0.24819224f, -0.13812281f, 0.04391971f, 0.06949387f, -0.07349008f, -0.16065119f, 0.15954883f, -0.03263824f, 
    0.43893018f, 0.39613435f, 0.19658476f, 0.11384719f, 0.09617286f, -0.02874000f, 0.01354160f, 0.02909834f, 
    0.14121403f, 0.12501797f, -0.00932553f, 0.01867815f, 0.00160209f, 0.08638004f, -0.01865279f, -0.01425975f, 
    0.02368777f, 0.11850177f, -0.06802373f, -0.02701572f, 0.07961389f, 0.22732423f, -0.29357737f, -0.01435634f, 
    -0.05036070f, 0.10727900f, -0.02270227f, 0.04819107f, 0.06515097f, 0.25489065f, 0.07594647f, -0.04987511f, 
    -0.02967660f, -0.05460785f, -0.06579294f, 0.08729926f, -0.01713735f, 0.09780019f, -0.01125759f, 0.01837942f, 
    -0.23354055f, 0.07600398f, -0.11120237f, 0.11272274f, -0.10730618f, -0.03990266f, 0.01523063f, -0.11399662f, 
    -0.02696194f, -0.00846658f, -0.10271862f, 0.03493397f, 0.10281778f, 0.06149569f, 0.01430468f, 0.04846579f, 
    -0.01323666f, -0.05529888f, -0.18577279f, -0.04402592f, 0.21173228f, 0.14719325f, -0.11651112f, -0.00003987f, 
    0.03275101f, -0.14625046f, -0.04443413f, 0.09099209f, 0.01171239f, 0.10255817f, -0.23367810f, -0.15728633f, 
    -0.02658420f, -0.01623558f, 0.09998542f, -0.00076470f, 0.14542384f, 0.09601863f, -0.17938945f, 0.13886507f, 
    0.13407190f, 0.14249839f, -0.16715667f, -0.15409453f, 0.10375916f, 0.02729951f, -0.05177570f, 0.25405195f, 
    0.17644790f, 0.00770051f, 0.13374728f, -0.00762008f, 0.16420558f, 0.09489305f, 0.11942385f, 0.10644677f, 
    -0.00898460f, 0.17940809f, -0.03969498f, 0.08258205f, -0.18106171f, 0.25168356f, -0.04808353f, 0.02730063f, 
    -0.09856581f, -0.11820496f, -0.00069193f, -0.02134616f, -0.05472887f, -0.05118564f, -0.06541087f, 0.00415784f, 
    0.00511644f, 0.04575466f, 0.05278881f, 0.03490695f, 0.19779544f, 0.04470059f, 0.09032694f, -0.06552447f, 
    0.38285625f, -0.06729328f, -0.14972109f, 0.15856384f, -0.10045692f, 0.01078022f, 0.13924119f, -0.03373467f, 
    -0.04524725f, -0.09920155f, -0.13955678f, -0.10201344f, 0.14177114f, 0.09255078f, -0.09155026f, 0.05775133f, 
    -0.01912209f, -0.11566319f, -0.00911595f, -0.00617665f, -0.27831972f, 0.10532916f, -0.47578430f, -0.01612438f, 
    0.17274612f, 0.05813210f, 0.30765364f, 0.22090054f, -0.13348047f, 0.22769332f, 0.02072039f, -0.18714410f, 
    -0.03959277f, 0.08671256f, -0.07222349f, 0.05225426f, 0.02429868f, -0.06534573f, 0.09998155f, 0.10554219f, 
    -0.03838829f, 0.04638388f, -0.05165765f, 0.08839010f, 0.06607410f, 0.02808362f, 0.06511075f, -0.03181968f, 
    0.02331729f, -0.08939406f, -0.10706292f, -0.00679618f, 0.06752456f, 0.13611455f, 0.08740623f, 0.17151202f, 
    0.19893378f, 0.15411243f, 0.20452178f, 0.08886736f, -0.13158269f, -0.12174013f, -0.21364312f, -0.14386457f, 
    0.03796767f, 0.06169941f, 0.00355778f, 0.04822277f, 0.00242024f, 0.02662480f, -0.01626823f, 0.00058370f, 
    -0.04759061f, 0.01735795f, -0.02660066f, 0.18416432f, 0.04779354f, -0.01633490f, -0.11257267f, -0.02725215f, 
    0.23544194f, 0.12801167f, -0.14727300f, 0.21390933f, 0.13768150f, -0.02751016f, 0.01479311f, -0.07994101f, 
    0.11061846f, 0.24225006f, 0.12060737f, -0.10057862f, 0.03682270f, -0.01223462f, 0.17671631f, -0.11306490f, 
    -0.05156901f, -0.06402887f, -0.07233313f, 0.03172298f, -0.10484568f, -0.14386797f, 0.04246612f, 0.22815715f, 
    -0.07136828f, -0.02630821f, 0.07485484f, 0.12950049f, -0.18590076f, 0.00952042f, -0.01547686f, -0.07019071f, 
    -0.06163086f, 0.01216545f, -0.04199064f, 0.04897572f, 0.18771158f, 0.21943542f, 0.08749586f, 0.29478461f, 
    -0.05321147f, -0.05761907f, -0.11934691f, -0.01980307f, -0.03437602f, 0.08781026f, 0.00698485f, -0.03020580f, 
    0.03412174f, 0.02292465f, -0.04604211f, 0.01508356f, 0.10481957f, 0.01737882f, 0.13851814f, 0.08891387f, 
    0.00893645f, -0.05427507f, -0.10843895f, -0.07870330f, -0.03979225f, -0.00171578f, -0.31294927f, -0.10703097f, 
    0.12901436f, 0.00922589f, 0.13758244f, -0.09882005f, -0.02664697f, 0.09435724f, -0.00001664f, -0.03636432f, 
    0.03576499f, -0.05392198f, -0.08048208f, -0.10557837f, -0.05020521f, -0.07493722f, -0.13964334f, -0.05784965f, 
    -0.01681421f, -0.08670115f, -0.20170034f, -0.10847869f, 0.17013724f, 0.05516643f, 0.12006945f, 0.12420373f, 
    0.03307946f, -0.00223945f, 0.04626704f, 0.02223795f, -0.09148009f, -0.07220642f, 0.00146488f, 0.11180881f, 
    -0.09497322f, 0.13962996f, -0.02884663f, -0.00287497f, -0.22419246f, 0.11231111f, -0.05090723f, 0.23870137f, 
    0.00061965f, -0.00036435f, -0.03063425f, 0.04994740f, -0.10300499f, 0.00892778f, 0.08317024f, -0.06642647f, 
    0.15199891f, 0.07466726f, -0.15331991f, 0.07492255f, 0.09273896f, 0.04059518f, -0.01403926f, -0.00609780f, 
    0.15632589f, 0.11281728f, -0.02242985f, 0.25028348f, 0.29900619f, -0.03883264f, 0.09057614f, 0.06244792f, 
    0.11740676f, 0.05070359f, 0.05735391f, -0.02128023f, -0.00421248f, -0.07909071f, -0.04420790f, -0.03861015f, 
    -0.02446735f, -0.09069388f, 0.10778576f, 0.02986716f, -0.12310325f, -0.04422144f, -0.11687048f, -0.02328331f, 
    0.03741462f, -0.16811360f, 0.01163729f, -0.25278181f, 0.09698581f, -0.04038645f, 0.01437136f, 0.04777514f, 
    0.02881798f, -0.00204364f, 0.02955322f, -0.14259672f, 0.05072005f, -0.05699209f, -0.03202764f, 0.10765291f, 
    -0.15429656f, 0.01348958f, -0.18956327f, -0.05778800f, -0.10592812f, 0.14323957f, 0.09538920f, 0.01245632f, 
    -0.07815739f, 0.02613512f, -0.04838486f, -0.05571594f, -0.08241859f, -0.05952661f, 0.07854328f, 0.05521324f, 
    0.06357735f, 0.02993447f, 0.14962819f, 0.09941532f, 0.12458086f, 0.06252702f, -0.10528825f, -0.04680594f, 
    0.10033190f, 0.02523380f, -0.04242660f, -0.08444760f, 0.03286549f, 0.09013015f, 0.12309126f, 0.00493933f, 
    -0.06421335f, -0.01565230f, -0.02034710f, 0.07635142f, -0.19001818f, -0.00046207f, -0.17630696f, -0.27111256f, 
    -0.31075665f, -0.28097326f, 0.07716198f, 0.26474693f, 0.01253694f, 0.02457188f, 0.06164538f, -0.08294535f, 
    -0.07293447f, -0.10807664f, -0.00737194f, 0.05520516f, -0.02602468f, 0.19115321f, -0.03740279f, 0.03452563f, 
    0.15379959f, 0.13389798f, 0.08300252f, 0.03230789f, 0.09070111f, -0.07536046f, -0.11472947f, -0.09992300f, 
    0.06697624f, 0.02062377f, 0.16011067f, 0.11217983f, 0.03407362f, 0.13703671f, 0.04000678f, -0.00515241f, 
    -0.06494439f, -0.02382303f, -0.05036794f, 0.03415453f, -0.11556954f, -0.07284598f, -0.10417600f, -0.05159348f, 
    -0.34013072f, 0.34171706f, 0.48260066f, -0.12359917f, 0.07121880f, -0.04807173f, -0.02999745f, -0.12281483f, 
    0.05213764f, -0.01691621f, -0.11866732f, -0.03842608f, 0.14626548f, 0.11518788f, -0.00469881f, 0.00438834f, 
    0.03529098f, 0.12571672f, -0.02326684f, -0.04416084f, -0.23631471f, 0.01697136f, 0.20371696f, 0.31368217f, 
    0.14925529f, 0.05014556f, -0.13609369f, -0.09074236f, -0.12311243f, 0.06964258f, 0.00577085f, 0.07214954f, 
    -0.00633141f, 0.02500924f, 0.03071653f, 0.01220917f, -0.15830502f, -0.03055885f, -0.16074882f, -0.17062050f, 
    0.20002320f, 0.05619536f, -0.16587484f, 0.21475132f, -0.04174099f, 0.01380245f, 0.08217055f, 0.01019069f, 
    0.10824201f, -0.03205235f, 0.06259090f, 0.04908853f, 0.08278364f, -0.04301412f, 0.12670392f, 0.02550237f, 
    -0.13868679f, -0.00173540f, 0.24769644f, -0.02963320f, -0.07312626f, -0.07658469f, -0.18572761f, 0.00205567f, 
    -0.14740667f, -0.00599828f, -0.08503734f, -0.05238066f, 0.00948919f, 0.02421085f, -0.08835004f, 0.01114906f, 
    -0.07510065f, 0.08063564f, -0.10696019f, -0.15901025f, -0.05288209f, 0.17453985f, -0.02800457f, -0.00731159f, 
    -0.22642693f, -0.10436271f, -0.06794865f, -0.17007087f, 0.46330202f, 0.23991698f, 0.14829835f, 0.21153837f, 
    0.12384194f, -0.04244049f, -0.11864738f, 0.14139634f, -0.07009958f, 0.12923443f, -0.01610668f, 0.11544141f, 
    0.28743866f, 0.05544399f, 0.03073443f, 0.11483870f, 0.21013132f, 0.26872838f, -0.06817415f, -0.30029723f, 
    0.25038543f, 0.00198824f, 0.02815498f, 0.00679840f, 0.04175910f, -0.09976909f, 0.03764122f, -0.03436989f, 
    0.00805787f, -0.03948141f, 0.05312737f, -0.14645480f, -0.03407622f, 0.26314005f, -0.02285584f, -0.02356705f, 
    -0.20282842f, -0.16562943f, -0.13276899f, -0.02988517f, 0.02821884f, -0.01740625f, -0.02725460f, -0.03336990f, 
    0.01504418f, 0.13039795f, 0.05058076f, 0.07053810f, 0.11407960f, 0.06595301f, -0.02383534f, -0.07703272f, 
    0.02049080f, 0.09804820f, 0.04137749f, -0.09327170f, 0.26684272f, -0.17613430f, 0.24720979f, -0.21605606f, 
    0.09089927f, -0.10722689f, -0.20021255f, -0.18814442f, 0.07256245f, 0.14590307f, 0.01853783f, 0.03247992f, 
    -0.04691708f, 0.03758754f, -0.01354179f, 0.01577151f, -0.06091838f, 0.02212437f, 0.07289395f, -0.06387265f, 
    -0.04674987f, -0.17149873f, 0.29191369f, -0.06001011f, -0.07643050f, -0.20193277f, 0.09136029f, -0.13338375f, 
    0.00648070f, 0.01510975f, -0.06281394f, 0.03422366f, -0.00079308f, 0.07624853f, 0.11664633f, 0.06055206f, 
    0.06674597f, 0.06387053f, 0.03543167f, 0.06917888f, -0.32900816f, -0.30910170f, -0.20041978f, -0.36557311f, 
    0.49380982f, 0.07907103f, 0.15124071f, 0.20035534f, 0.15875898f, 0.10191943f, -0.02400689f, 0.17234404f, 
    0.14320689f, 0.11409948f, -0.00138142f, -0.03725751f, 0.00986044f, -0.10236280f, 0.23461443f, -0.06815515f, 
    0.08552303f, -0.28877801f, 0.12133611f, -0.23897608f, 0.09598655f, 0.11952048f, 0.04276808f, -0.10126041f, 
    0.15156600f, -0.18466651f, -0.00259017f, 0.02154273f, 0.07908960f, 0.06813262f, 0.15159360f, 0.05297699f, 
    -0.00346393f, 0.19792025f, -0.03825079f, 0.11384200f, 0.16470516f, 0.32100257f, -0.15316465f, 0.21994103f, 
    0.18795407f, 0.05125836f, 0.05253870f, 0.01604683f, -0.06693038f, 0.03271797f, 0.09894067f, 0.00922871f, 
    -0.01431491f, -0.13345392f, 0.03333225f, 0.03482160f, -0.00275444f, -0.21792352f, 0.11379792f, -0.02044486f, 
    0.03899033f, 0.37250566f, -0.07899189f, 0.10050849f, -0.05259036f, -0.05984747f, 0.01416396f, 0.09027936f, 
    -0.04197425f, -0.01491954f, -0.02197273f, -0.00879765f, 0.10614386f, 0.02127756f, 0.10787291f, 0.21305382f, 
    -0.02224393f, 0.07382768f, 0.12810272f, -0.00506590f, -0.00103357f, 0.00941283f, -0.09657232f, 0.15725070f, 
    0.10539853f, 0.17781171f, -0.17196572f, -0.05812230f, 0.05154501f, -0.06954484f, 0.07822973f, -0.02617404f, 
    -0.05921451f, 0.05850741f, 0.07675723f, -0.10070287f, 0.03518543f, 0.14194876f, 0.07840793f, 0.07638279f, 
    -0.08788355f, 0.24400246f, 0.01870577f, -0.01976071f, 0.19558588f, 0.13488163f, -0.00410213f, 0.12231959f, 
    -0.04351791f, 0.06483691f, -0.11457440f, 0.08321984f, 0.09818828f, 0.04011724f, -0.05039539f, -0.08287127f, 
    -0.05014453f, 0.27144131f, -0.02101027f, -0.00299493f, 0.09552610f, -0.25217927f, 0.22478430f, -0.08695953f, 
    -0.12223513f, -0.02353753f, -0.16515784f, -0.17557119f, -0.04845760f, 0.03724468f, -0.07952885f, -0.03668158f, 
    0.01716464f, 0.01263842f, -0.05079561f, -0.00462023f, 0.02275318f, -0.05661242f, 0.03404536f, -0.03209314f, 
    -0.03489859f, 0.27796483f, -0.29668164f, 0.12924293f, 0.23382606f, 0.11834282f, 0.22085975f, 0.10351263f, 
    0.00336088f, 0.07210981f, 0.09213226f, -0.02317933f, 0.13194694f, -0.08954618f, 0.07449150f, 0.03620556f, 
    -0.03487573f, -0.13953018f, 0.09938351f, -0.08245149f, -0.35009953f, 0.21112548f, -0.09221572f, 0.02042081f, 
    0.35933214f, 0.08753699f, 0.06463705f, 0.39694101f, 0.12490618f, -0.05423547f, -0.15062809f, -0.03630644f, 
    -0.16082725f, -0.08829992f, -0.09253065f, 0.01900033f, 0.04126653f, -0.14132474f, 0.13537394f, -0.04581396f, 
    0.03822568f, 0.02881530f, -0.15263480f, 0.04041564f, -0.06784336f, -0.07254599f, -0.06641997f, -0.14289576f, 
    0.09416247f, -0.06435346f, -0.09746011f, -0.02815447f, -0.08513606f, -0.13442908f, -0.00874986f, 0.04193547f, 
    -0.14212459f, -0.05983670f, 0.11120894f, 0.06886958f, 0.09561689f, 0.11245378f, 0.02950706f, -0.04441240f, 
    -0.12924975f, 0.03855555f, -0.01547488f, 0.03021717f, -0.00297134f, -0.03545208f, -0.10587307f, -0.05259923f, 
    0.01212702f, -0.06828363f, -0.17011459f, -0.00115579f, -0.10219328f, 0.02275047f, -0.10524259f, -0.07841696f, 
    0.22401904f, -0.00878242f, 0.18614128f, -0.19857652f, 0.10468348f, 0.18598276f, 0.14320670f, 0.08849284f, 
    -0.09919179f, -0.04682197f, -0.08563518f, -0.13801295f, 0.10931611f, 0.20986846f, 0.08558457f, 0.05501188f, 
    0.00988655f, 0.04506518f, -0.14437121f, -0.10274957f, 0.33371866f, 0.31848091f, 0.01568401f, -0.06164204f, 
    0.34305710f, 0.05261330f, 0.15924698f, -0.02052141f, 0.15458603f, 0.06335673f, 0.01991153f, -0.10516848f, 
    -0.12072112f, 0.02162261f, -0.00065418f, -0.07853692f, 0.05537430f, 0.18022877f, 0.27787608f, 0.10011974f, 
    0.03427784f, 0.06904946f, -0.00823065f, -0.09627143f, -0.04977959f, 0.01907748f, 0.09362383f, -0.05666529f, 
    0.00518028f, 0.07138647f, -0.16390578f, -0.09735239f, -0.14029688f, -0.24104570f, -0.13106358f, -0.06945557f, 
    -0.01597904f, -0.05441473f, -0.07895890f, -0.10695618f, 0.17075987f, -0.05715112f, 0.04621835f, -0.09060691f, 
    0.02216588f, 0.03709291f, 0.00176049f, -0.07477743f, 0.06288095f, 0.10283790f, 0.00456287f, 0.08791900f, 
    -0.03924902f, -0.01381077f, 0.04586219f, -0.07580549f, -0.00496355f, -0.08115432f, -0.02551290f, -0.07244119f, 
    0.17569678f, -0.01077003f, 0.08299035f, 0.02403633f, -0.05351562f, -0.07262406f, 0.02548492f, -0.05112480f, 
    -0.04271718f, -0.02721669f, -0.04167857f, 0.04617206f, -0.01494721f, 0.04889157f, -0.00837778f, -0.01640564f, 
    0.02902772f, 0.07872987f, 0.05729891f, 0.18321319f, 0.13504851f, 0.19158097f, 0.05636579f, -0.30399126f, 
    -0.19791123f, 0.13037920f, 0.04598231f, 0.13706575f, 0.13382576f, 0.31276217f, -0.23480970f, -0.03893194f, 
    0.25090247f, -0.05676508f, 0.02029598f, -0.00451749f, 0.03855935f, -0.01761339f, 0.08571787f, -0.18068677f, 
    -0.00977673f, -0.15019225f, 0.12378885f, -0.01933469f, 0.05264622f, -0.00640330f, 0.16043688f, -0.14866006f, 
    0.10209736f, -0.02190602f, -0.02520967f, -0.02462145f, 0.08213609f, 0.04366561f, 0.01400111f, -0.05114448f, 
    0.02354559f, -0.02036934f, 0.06877387f, 0.19514717f, 0.13257861f, 0.30305961f, 0.09384378f, 0.07102171f, 
    0.00293448f, 0.19014733f, 0.03930375f, 0.10452808f, -0.10124362f, 0.06255569f, -0.05534690f, 0.04908545f, 
    -0.03125833f, -0.00240955f, -0.03309567f, -0.00702440f, -0.03668869f, -0.05525520f, -0.11286829f, 0.01818922f, 
    0.09693220f, 0.38447708f, -0.25942284f, -0.10618591f, 0.03099715f, -0.01803858f, -0.07529575f, 0.03905672f, 
    -0.13293800f, 0.08664103f, 0.00266789f, 0.08272680f, -0.04205387f, 0.03765543f, -0.12048873f, 0.09429555f, 
    0.07365681f, -0.08856881f, 0.22034419f, 0.05377419f, -0.03229797f, 0.08593877f, 0.10711566f, 0.11285333f, 
    -0.01069701f, -0.01332527f, 0.25627249f, 0.03701978f, 0.09921608f, -0.08983453f, 0.09247532f, 0.11209430f, 
    -0.07182361f, 0.06457295f, -0.00742113f, -0.07629434f, -0.11145071f, -0.00986736f, -0.08182493f, -0.04432843f, 
    0.24695370f, 0.23977172f, 0.37319413f, -0.27925086f, 0.13777958f, 0.07716181f, 0.00668140f, 0.05400717f, 
    0.09145568f, 0.05456972f, -0.12121172f, -0.03702420f, -0.03457758f, 0.00493256f, 0.06582870f, -0.07802226f, 
    0.02006514f, 0.29483962f, 0.08054478f, 0.06046420f, 0.10835291f, -0.00673218f, 0.18634810f, 0.05431721f, 
    -0.06927580f, -0.04839779f, 0.06180796f, -0.15780832f, -0.01603220f, -0.05742985f, 0.04689912f, 0.06973629f, 
    0.09075417f, 0.01591771f, 0.03679720f, -0.07997633f, 0.00333105f, -0.10423721f, 0.08755124f, 0.04320527f, 
    -0.11321513f, 0.08736055f, -0.50462061f, 0.12536387f, 0.03870893f, 0.12406446f, 0.06173471f, 0.07448360f, 
    0.07941533f, -0.00913011f, -0.07092943f, -0.00964420f, 0.03026197f, -0.00614427f, -0.02875111f, 0.05826229f, 
    0.08928657f, -0.07795481f, -0.00324474f, 0.06823489f, 0.39044222f, 0.27273223f, -0.25127950f, -0.02652053f, 
    0.13271546f, 0.16584380f, 0.12771291f, 0.24765486f, -0.00763656f, 0.00676147f, -0.11799271f, -0.14136092f, 
    0.01731362f, -0.03193378f, 0.10655120f, 0.07396229f, -0.01592288f, -0.09426183f, -0.07308579f, -0.07430452f, 
    -0.02135389f, 0.01373925f, 0.00661992f, -0.01813393f, -0.04660406f, 0.01757105f, 0.04661473f, -0.03287837f, 
    0.01314502f, -0.04664467f, 0.02626467f, -0.03311076f, 0.03617567f, 0.00822337f, -0.05907045f, -0.02284827f, 
    -0.06243415f, -0.01185578f, -0.01224770f, -0.03581808f, 0.03342989f, -0.04147253f, -0.04704978f, -0.02134540f, 
    -0.04058863f, 0.00512768f, -0.00011949f, -0.02640955f, 0.01259436f, -0.01319664f, -0.00971439f, -0.01976328f, 
    -0.00619710f, -0.05341528f, -0.01005360f, 0.00841025f, 0.01829246f, -0.01765882f, -0.00653176f, -0.02607953f, 
    -0.00393758f, -0.00647021f, -0.06193067f, -0.03090121f, 0.00918449f, -0.00111130f, -0.01528003f, -0.00355995f, 
    -0.00352446f, 0.01731475f, 0.00845022f, 0.01895921f, 0.02458218f, -0.03771666f, 0.02865722f, -0.02277180f, 
    -0.01142020f, 0.00397788f, 0.03368803f, -0.03083440f, -0.00179602f, 0.04587103f, -0.00444209f, -0.03845022f, 
    -0.01280029f, 0.00813417f, -0.03345127f, -0.00636072f, -0.05541478f, 0.02880345f, 0.01726379f, 0.01839664f, 
    0.01242342f, 0.02883896f, -0.04251810f, -0.03293760f, 0.01906008f, -0.04931910f, 0.00452196f, -0.00788616f, 
    0.05784040f, 0.00765190f, 0.03357047f, -0.00140005f, 0.02763018f, -0.00258885f, -0.05946923f, 0.02184086f, 
    0.04987060f, -0.04941049f, -0.04285027f, -0.02478976f, 0.04617203f, -0.01716682f, -0.04129164f, 0.04315909f, 
    0.03115819f, -0.01816668f, 0.00083029f, -0.03838988f, -0.02382848f, 0.02015258f, 0.01324067f, -0.03664625f, 
    -0.00521767f, 0.02463518f, -0.04838920f, -0.02121994f, -0.05211141f, -0.04247331f, 0.00281111f, 0.05891673f, 
    -0.02504486f, 0.02522040f, 0.02622808f, -0.00472569f, -0.02129404f, -0.03402022f, -0.00022688f, -0.02164253f, 
    0.00839644f, 0.04702234f, 0.03835113f, 0.03625171f, 0.05531739f, 0.04219811f, -0.00477276f, 0.01959724f, 
    0.02866919f, -0.06122480f, -0.01017309f, -0.02193108f, 0.01325548f, -0.02602080f, -0.03605236f, -0.00700366f, 
    -0.04265811f, 0.02938176f, -0.00829779f, -0.01301586f, 0.01110553f, -0.01999758f, -0.03744069f, -0.05747192f, 
    -0.00266767f, 0.00790317f, 0.03316263f, -0.01193417f, 0.01116264f, 0.03876042f, -0.04034377f, 0.01442269f, 
    -0.01830816f, -0.02518584f, 0.00022537f, 0.00794044f, -0.05489875f, -0.03084340f, 0.04340184f, -0.00198796f, 
    0.00203591f, 0.03792150f, 0.05281360f, -0.05924995f, -0.05685654f, 0.02302326f, 0.01422663f, -0.04943369f, 
    -0.05846346f, 0.04593990f, 0.04603990f, -0.00164051f, -0.05397011f, -0.06009655f, -0.05129150f, -0.04216177f, 
    0.03462703f, 0.02886187f, 0.04001838f, 0.03196982f, 0.03673469f, -0.04150648f, -0.04163399f, -0.04880248f, 
    -0.01789826f, -0.04799282f, -0.06118365f, 0.03602792f, -0.04454101f, -0.05777761f, 0.02638927f, 0.01082646f, 
    -0.05776156f, -0.02345046f, -0.04883415f, 0.01675515f, 0.00543678f, -0.01756446f, 0.03446046f, -0.01757717f, 
    -0.02147010f, 0.01477800f, 0.01597579f, 0.01169599f, 0.01830341f, -0.03763581f, 0.00791750f, -0.04288934f, 
    -0.05487089f, -0.02595929f, -0.01679800f, -0.05714282f, -0.03242957f, 0.01429919f, -0.00589620f, 0.03834281f, 
    0.02653813f, 0.02407078f, 0.03820371f, -0.05043099f, -0.03735704f, 0.02174960f, 0.02891169f, -0.01089030f, 
    0.00875071f, -0.01406234f, -0.01737121f, 0.01749383f, 0.02947078f, 0.00694559f, 0.03657085f, 0.05396115f, 
    0.02029011f, -0.01098945f, -0.00099501f, -0.05924063f, -0.01060172f, 0.03264884f, -0.03093549f, -0.01281774f, 
    0.04472278f, 0.02014166f, -0.03489028f, -0.04181126f, 0.04763097f, -0.01136652f, 0.03050219f, 0.01013475f, 
    -0.00024048f, 0.00769023f, -0.04783271f, -0.03048803f, 0.05491551f, 0.00818172f, -0.01026910f, 0.00794874f, 
    0.02983375f, 0.05475647f, -0.00370596f, -0.04487333f, 0.05229003f, -0.00543780f, -0.00755446f, -0.03712283f, 
    -0.01100221f, -0.03449321f, -0.03092564f, 0.03331706f, -0.05491275f, -0.01355310f, -0.01774026f, 0.00837011f, 
    -0.02198840f, 0.04803648f, 0.02631055f, 0.00551645f, -0.02283831f, -0.03272211f, -0.02973570f, -0.00107943f, 
    -0.02993963f, 0.02356284f, -0.05216820f, 0.04611211f, 0.03384225f, 0.00052049f, -0.04413864f, 0.01721383f, 
    0.03166146f, -0.00625878f, -0.03517165f, 0.03290446f, 0.00175169f, 0.04537088f, -0.04586171f, 0.04773811f, 
    -0.03329996f, 0.03650388f, 0.01835650f, 0.00125016f, 0.00602681f, 0.03733020f, 0.03090661f, -0.03533439f, 
    -0.00221704f, -0.01778262f, 0.04812930f, 0.00021002f, -0.03536514f, 0.01683009f, -0.03684430f, -0.04163799f, 
    -0.02089624f, 0.03933040f, -0.05450752f, -0.01287676f, -0.02983727f, -0.04741494f, 0.00251300f, -0.01369565f, 
    -0.02543261f, 0.34278539f, 0.23251799f, 0.19576479f, 0.30509976f, 0.00384952f, 0.01404623f, 0.22701998f, 
    0.05184342f, -0.07270890f, 0.00764180f, 0.02192123f, 0.01080467f, 0.09158559f, 0.00505381f, 0.18095680f, 
    -0.01023043f, 0.07928483f, -0.00325551f, -0.33258978f, -0.30913419f, -0.27103534f, -0.20053704f, 0.02511999f, 
    -0.01665773f, 0.02297530f, -0.05648312f, -0.04544432f, -0.03076445f, -0.01416154f, 0.29134601f, 0.01099189f, 
    0.11158499f, 0.01308461f, 0.26951990f, 0.14117159f, 0.05157894f, -0.02231313f, 0.09347649f, 0.11515040f, 
    0.20618969f, 0.00612289f, 0.15625553f, 0.06992862f, -0.05097298f, 0.01337721f, 0.08468679f, 0.00377023f, 
    0.22604083f, 0.27920091f, 0.06691961f, -0.10697117f, 0.05255327f, -0.20278859f, -0.20206852f, 0.04328351f, 
    -0.04842047f, 0.03404003f, -0.03775172f, 0.03975761f, 0.02144776f, -0.02804337f, 0.55566549f, 0.23935851f, 
    -0.26705369f, -0.10396182f, 0.09777245f, 0.19563611f, -0.10834120f, 0.00198682f, -0.00689814f, 0.08656880f, 
    0.00691686f, 0.00460859f, 0.08164105f, 0.06091383f, 0.10667129f, -0.01167156f, -0.04011398f, -0.10855874f, 
    -0.22103208f, -0.23651077f, 0.03826739f, 0.08839253f, -0.20301831f, -0.01501862f, -0.08126189f, -0.05550665f, 
    -0.06995935f, -0.00118097f, 0.04384199f, 0.07614264f, 0.02359050f, 0.19889785f, 0.20789416f, 0.15619999f, 
    -0.01808216f, -0.01085708f, 0.07722367f, 0.14864199f, -0.38383150f, -0.13785768f, -0.24809477f, 0.01974653f, 
    -0.19191872f, -0.21795779f, -0.12224275f, -0.05807410f, -0.09637178f, 0.02505917f, -0.17233425f, -0.03252468f, 
    0.03531190f, 0.14725344f, 0.08777211f, 0.05299077f, 0.01328213f, 0.14167096f, 0.01186447f, 0.00909477f, 
    0.02003566f, -0.25948828f, -0.42844796f, 0.27637872f, 0.00304413f, -0.00961531f, -0.09033135f, -0.13973717f, 
    -0.03378882f, -0.01641816f, 0.12259880f, -0.08326004f, 0.00055796f, -0.06340474f, 0.03300065f, -0.02484866f, 
    -0.05892235f, 0.13818987f, 0.10945167f, 0.05462085f, 0.04241681f, 0.62950534f, -0.16873175f, 0.32079357f, 
    -0.41785234f, -0.17599021f, -0.19120106f, 0.09317347f, 0.14024277f, 0.05649833f, 0.09683891f, -0.12023598f, 
    -0.19906713f, 0.15804762f, -0.03592039f, -0.15166098f, 0.00846748f, 0.34803945f, -0.09292389f, -0.08172210f, 
    0.22953056f, 0.31161264f, 0.11570407f, 0.16867444f, 0.09547332f, -0.05847440f, -0.08306534f, 0.15134029f, 
    0.01307775f, 0.08562198f, -0.06525020f, -0.03308124f, -0.11417405f, -0.09333594f, 0.04666580f, 0.04669908f, 
    0.04453713f, 0.10311669f, -0.05584111f, -0.08369488f, 0.00992864f, 0.04403799f, 0.02086967f, -0.03221804f, 
    0.15988624f, -0.03960354f, 0.16904873f, -0.30628946f, 0.16163780f, 0.17782676f, -0.00128339f, 0.01157380f, 
    0.08938618f, 0.09417585f, -0.05927500f, 0.06566244f, 0.03859418f, -0.12914151f, 0.03535423f, 0.12877899f, 
    -0.25421715f, -0.36185971f, -0.12425623f, -0.01710926f, -0.28101000f, -0.10561135f, -0.14423850f, -0.00307857f, 
    -0.10959458f, -0.08826753f, -0.01535395f, 0.06426983f, -0.09701851f, 0.11047172f, 0.12554727f, -0.01042104f, 
    -0.08826337f, 0.03408036f, -0.02074994f, 0.15861404f, 0.00144482f, -0.00409047f, -0.03294393f, -0.17511280f, 
    -0.00493256f, -0.14368448f, -0.02859927f, -0.08377741f, -0.00713126f, 0.05590480f, 0.06858005f, 0.01767696f, 
    0.07032400f, 0.11314167f, 0.15947881f, 0.18183726f, 0.15203975f, -0.08689410f, 0.04842859f, 0.06918808f, 
    -0.24037662f, -0.06763561f, -0.08937049f, 0.03478855f, 0.03478423f, 0.01619115f, 0.11709821f, 0.07259458f, 
    -0.25302500f, 0.02476084f, 0.01326224f, -0.05530186f, -0.05719678f, 0.10162936f, 0.01667907f, 0.10390870f, 
    -0.02004959f, -0.35665557f, -0.12006313f, -0.08361254f, -0.27668864f, 0.00571258f, -0.40025294f, -0.04559093f, 
    -0.11687072f, 0.04383158f, -0.22010098f, 0.02382579f, -0.09500663f, -0.07654944f, -0.02337438f, -0.02172817f, 
    -0.06803373f, -0.00101734f, 0.02976475f, 0.06447984f, 0.03576647f, 0.16647275f, -0.00160201f, 0.01465428f, 
    -0.52339083f, -0.26265645f, -0.26559496f, -0.34922984f, -0.10149552f, -0.09092049f, 0.00185219f, -0.18366313f, 
    -0.19524994f, 0.02346203f, -0.01670551f, 0.11768067f, 0.10712587f, -0.00350743f, 0.21318434f, -0.06607727f, 
    -0.06411967f, 0.13436936f, -0.04979440f, -0.06730655f, -0.14510500f, 0.14439549f, 0.14829582f, 0.25502530f, 
    -0.03894875f, 0.03572685f, 0.00906790f, 0.10712919f, 0.13190879f, 0.24761431f, -0.03045437f, -0.05803605f, 
    -0.11246917f, 0.02594848f, -0.03437779f, -0.00503290f, 0.08526305f, 0.17451452f, 0.02169124f, 0.15112527f, 
    -0.00329608f, -0.00418833f, 0.06896044f, -0.01283723f, 0.02020561f, 0.07150280f, 0.10013640f, 0.08314479f, 
    0.04188112f, 0.18756840f, -0.11706178f, 0.08139502f, 0.01554776f, 0.03483473f, 0.13444063f, 0.12701812f, 
    0.12495291f, 0.04158242f, 0.09270202f, 0.24461538f, -0.09290364f, 0.14388089f, -0.07588382f, -0.12963995f, 
    0.08443567f, 0.04448520f, -0.00884385f, 0.04420610f, 0.07821590f, -0.00574440f, 0.15869853f, 0.03131782f, 
    0.06601021f, 0.13215047f, 0.08974206f, 0.14786109f, 0.05248214f, 0.03521457f, -0.09266324f, -0.01906718f, 
    -0.43142706f, 0.16337772f, -0.10300127f, 0.40728620f, -0.12627931f, 0.08226767f, -0.17605507f, -0.06013098f, 
    0.02739049f, 0.10863918f, 0.09909537f, -0.02870088f, 0.03476245f, -0.04311655f, 0.05566415f, -0.11589813f, 
    -0.01364700f, -0.21459392f, -0.02863322f, 0.09745657f, -0.11467922f, -0.35834900f, -0.11539234f, -0.04834686f, 
    -0.28136542f, 0.07065731f, -0.16877513f, 0.02798857f, -0.01854309f, 0.04612099f, -0.12586021f, 0.00198128f, 
    0.09544702f, 0.00789993f, -0.01683497f, -0.01939123f, 0.09225907f, 0.06447083f, -0.02815366f, 0.08860495f, 
    0.09746736f, 0.05880486f, -0.10830357f, 0.01897395f, 0.05264900f, 0.00163976f, 0.03002436f, 0.08946240f, 
    -0.03732902f, -0.04738201f, 0.15949421f, 0.04200983f, 0.14223547f, 0.13602880f, 0.14589337f, 0.03176358f, 
    -0.04605938f, 0.01217769f, -0.08658411f, -0.03897138f, 0.07049400f, 0.10101262f, -0.20037556f, 0.02646357f, 
    0.16036834f, 0.10458338f, 0.18770096f, 0.12204779f, 0.00696395f, -0.02467901f, -0.06029931f, 0.03292495f, 
    0.06900358f, 0.01902363f, -0.07964400f, -0.00622230f, 0.09617655f, -0.08210213f, -0.03388926f, 0.09322580f, 
    0.09685924f, 0.06808470f, -0.16641672f, -0.05304610f, -0.11967476f, 0.05813809f, 0.02810781f, 0.00108634f, 
    0.04387019f, 0.07392097f, 0.04582431f, -0.05701331f, -0.07157649f, 0.08887717f, -0.04004205f, 0.08219313f, 
    0.05591911f, 0.04651123f, -0.10518976f, -0.09728833f, -0.58004457f, 0.03687928f, -0.26780450f, 0.33277327f, 
    0.20445706f, 0.05183807f, 0.12704650f, -0.21127076f, -0.03225481f, -0.06545714f, 0.11300442f, 0.12596133f, 
    -0.02583467f, 0.08129838f, 0.06280869f, 0.19472760f, -0.00107163f, -0.10691085f, 0.11611535f, -0.00481577f, 
    0.16504157f, 0.19360927f, -0.00109053f, 0.11305877f, -0.14576918f, 0.02598568f, 0.00060686f, 0.05030774f, 
    0.01933539f, 0.15239054f, -0.05046239f, -0.02639286f, 0.00501125f, 0.02265768f, -0.04418260f, -0.08485423f, 
    0.00083646f, -0.01746274f, 0.09671270f, 0.10766603f, 0.14999720f, -0.39765090f, -0.02019915f, 0.03775694f, 
    -0.01065290f, -0.10588627f, 0.04978501f, 0.04676642f, 0.04508909f, 0.02418652f, -0.02350584f, -0.14488912f, 
    -0.01827629f, -0.04636142f, -0.02097836f, 0.02293657f, 0.07186633f, -0.00873084f, -0.06429469f, 0.04881549f, 
    -0.02353278f, -0.11032018f, -0.20906192f, 0.03796867f, 0.31010726f, 0.09085295f, 0.04610637f, -0.13139749f, 
    0.19350165f, 0.08268862f, 0.05058680f, 0.10247999f, 0.13036497f, -0.02812652f, 0.10587429f, 0.14154367f, 
    0.09882860f, -0.04673416f, 0.09627912f, -0.00894591f, 0.20495029f, -0.01895470f, -0.18654974f, -0.01137828f, 
    -0.07805178f, -0.04801695f, -0.04941030f, 0.14555798f, 0.01406245f, -0.03940315f, -0.11428853f, 0.20035614f, 
    -0.02657820f, -0.11465349f, -0.00161461f, -0.02018392f, -0.11573857f, -0.02323726f, -0.04239124f, -0.17032327f, 
    -0.12321174f, -0.25309661f, 0.25795653f, 0.46659732f, -0.26165208f, -0.06898750f, -0.06803219f, -0.05556446f, 
    0.02816179f, -0.03292951f, -0.01690713f, -0.19630617f, 0.06188734f, 0.05881836f, 0.00978067f, 0.05206799f, 
    0.14823559f, 0.05394082f, 0.08222105f, 0.02466553f, -0.09478094f, 0.26475608f, -0.01540822f, 0.05519919f, 
    -0.00065450f, 0.01589897f, 0.15075862f, 0.14238892f, 0.01284718f, 0.06708396f, -0.04957174f, -0.04670432f, 
    -0.00654723f, -0.00820967f, -0.06858990f, -0.00834841f, 0.05225350f, -0.01253841f, -0.14199704f, -0.03446240f, 
    0.00008477f, -0.10173273f, 0.64854109f, -0.05277299f, -0.07340313f, -0.12037692f, 0.03204380f, -0.01263572f, 
    0.06316923f, 0.03224886f, 0.14358333f, 0.20087643f, 0.21067205f, 0.18399818f, 0.10734527f, 0.02660219f, 
    0.09273631f, 0.00975534f, -0.00134065f, 0.07345338f, -0.14189811f, -0.20091905f, 0.08797017f, 0.27040115f, 
    -0.21152873f, -0.09023645f, 0.10235099f, -0.28415096f, -0.01245209f, 0.04467144f, 0.06277049f, 0.00202427f, 
    0.02773945f, -0.09979105f, -0.06603297f, -0.12584890f, -0.17004496f, -0.08933171f, -0.13754597f, -0.09627165f, 
    0.18767247f, 0.00141372f, -0.05501184f, -0.18229206f, -0.01334448f, 0.07202045f, 0.02757382f, 0.13754942f, 
    0.04388744f, 0.30326739f, 0.01661420f, 0.00562776f, 0.01056561f, -0.00576699f, -0.08186495f, 0.04660008f, 
    0.24470240f, 0.11185326f, 0.16792572f, 0.27412975f, -0.19092454f, 0.08012871f, -0.01733705f, -0.12235834f, 
    0.17289448f, -0.25173074f, 0.03066837f, -0.14849816f, -0.36969993f, -0.32068923f, -0.00215857f, 0.11205798f, 
    -0.01229868f, 0.15735593f, 0.16353942f, -0.02342102f, -0.16491517f, -0.01457801f, -0.16065586f, -0.23873466f, 
    0.68331814f, 0.14553986f, 0.08590753f, 0.38191035f, -0.14976814f, 0.12500674f, -0.00843284f, 0.09668285f, 
    -0.10862612f, -0.27802935f, 0.07798290f, -0.00829427f, 0.13355474f, 0.06624192f, 0.12428847f, -0.09472223f, 
    -0.00191417f, -0.03455419f, -0.10390884f, -0.03425953f, 0.30982956f, 0.40144235f, 0.26608813f, 0.03697103f, 
    0.01827587f, 0.00739860f, 0.15065841f, 0.28826788f, 0.13238707f, 0.29550424f, 0.08624513f, 0.08972266f, 
    -0.00181304f, -0.02280403f, -0.13676214f, 0.11120139f, 0.07872126f, 0.14361508f, 0.07646818f, 0.26325107f, 
    0.18877657f, 0.11222269f, -0.09919190f, -0.14190084f, 0.04859695f, -0.01084402f, -0.16852722f, -0.21378042f, 
    -0.10701105f, -0.65961850f, 0.06034380f, -0.04383887f, 0.05885341f, 0.01570150f, -0.18658955f, -0.18938325f, 
    -0.14074522f, -0.04346386f, -0.20392720f, -0.54317391f, -0.31704739f, 0.21380767f, -0.04871514f, 0.46259123f, 
    -0.08763765f, -0.11019760f, 0.06872466f, -0.24854837f, -0.23598571f, -0.42775068f, 0.11884806f, 0.00692189f, 
    -0.18261433f, -0.00906484f, -0.15429249f, -0.08858618f, -0.00761965f, -0.06413958f, -0.25905070f, -0.17480379f, 
    -0.24684191f, 0.18427925f, 0.11888325f, 0.21844512f, 0.19734636f, 0.27525276f, -0.12408093f, -0.18434507f, 
    -0.05883317f, -0.15221508f, 0.05077112f, -0.03948056f, -0.08024063f, -0.08542380f, -0.10023087f, 0.22498283f, 
    -0.01651175f, 0.19920424f, -0.09700101f, -0.06150620f, 0.49058169f, 0.24084532f, 0.19419803f, 0.13148904f, 
    -0.08694933f, -0.19506809f, -0.10480923f, -0.11163402f, 0.06760094f, -0.08554067f, 0.03736964f, -0.12647513f, 
    0.11599632f, 0.13938682f, -0.16636194f, -0.10571829f, 0.11757156f, -0.21112582f, -0.02086355f, -0.00966442f, 
    0.14840879f, 0.34238353f, 0.21954916f, 0.24790546f, 0.13882615f, -0.12828995f, 0.11655929f, 0.08858668f, 
    0.07085129f, 0.25426504f, 0.00632973f, -0.06123890f, -0.04581362f, -0.14811400f, -0.26765090f, -0.02947987f, 
    -0.06369837f, -0.03123958f, -0.01792194f, -0.05373000f, 0.13004234f, 0.12906468f, 0.09884164f, -0.10233907f, 
    -0.22186483f, 0.11360125f, -0.09119209f, 0.07257216f, -0.08120742f, -0.00397065f, -0.03060073f, 0.22396028f, 
    -0.09259440f, -0.03515960f, 0.28075427f, -0.06701364f, 0.19626650f, 0.05181693f, 0.18864676f, 0.10540982f, 
    -0.07111908f, 0.27308029f, -0.00685462f, -0.12063912f, 0.00985945f, -0.09381756f, -0.22441283f, 0.13082561f, 
    -0.07097664f, -0.14143272f, -0.12180275f, 0.14794703f, -0.08654142f, -0.18211567f, 0.12828512f, -0.08037452f, 
    0.06205625f, 0.10194882f, 0.10553528f, 0.22137116f, 0.29612824f, 0.22354570f, 0.31515393f, -0.21414946f, 
    -0.00745854f, -0.15478322f, 0.11055066f, 0.13734466f, 0.14630266f, 0.27053624f, 0.14060426f, 0.09058157f, 
    -0.17910056f, 0.11653514f, -0.13803643f, 0.00488853f, -0.53958046f, -0.26265931f, -0.41868484f, -0.57952422f, 
    0.05946957f, -0.11613835f, 0.22687417f, -0.10571231f, 0.09953942f, 0.01760207f, 0.27906871f, -0.06161409f, 
    0.03035237f, 0.15749620f, 0.10039336f, 0.04144242f, 0.16453873f, 0.18997268f, 0.04313352f, -0.06122686f, 
    0.18501613f, 0.15381305f, 0.34211960f, 0.25952736f, -0.38602039f, 0.23507985f, 0.28381512f, 0.28269833f, 
    -0.00293480f, -0.08582452f, 0.11253695f, -0.11142492f, -0.06826697f, 0.08892714f, -0.07911245f, -0.12593961f, 
    0.04523559f, 0.00713187f, -0.12181133f, 0.10885752f, 0.15978037f, -0.01252547f, -0.02546640f, 0.02767728f, 
    -0.32921752f, -0.00663343f, 0.07657999f, 0.10320027f, -0.07336910f, -0.01273100f, -0.29704326f, 0.02105471f, 
    -0.07623460f, -0.28330550f, -0.03758088f, 0.03136995f, 0.02775624f, 0.09699069f, 0.21391839f, -0.12571520f, 
    -0.04187225f, 0.10279266f, 0.00486426f, 0.08011415f, 0.56977397f, 0.10441968f, -0.02965316f, -0.02838043f, 
    0.11057330f, 0.13141339f, -0.17407267f, -0.10117026f, 0.09736284f, 0.00804563f, 0.13726230f, -0.05447502f, 
    0.10184261f, 0.10738170f, 0.03857176f, 0.08614145f, -0.38450104f, -0.31254092f, -0.21319383f, -0.15083215f, 
    -0.14293681f, 0.12733188f, 0.03821776f, 0.06587854f, 0.14687552f, 0.15974110f, -0.00040039f, -0.01250849f, 
    -0.00171464f, 0.27685720f, 0.09626976f, 0.04862566f, -0.02318115f, 0.01275933f, -0.00333412f, -0.01402595f, 
    0.12027621f, -0.02671628f, 0.06410053f, 0.18747717f, 0.07182242f, 0.02859617f, -0.11926389f, 0.02192646f, 
    0.02477121f, -0.08608959f, -0.00604509f, -0.03884646f, 0.07772233f, -0.08863787f, -0.08856102f, 0.03866874f, 
    0.01485652f, 0.02989701f, -0.04989289f, 0.07387023f, 0.06322521f, 0.06512641f, -0.08563133f, -0.05328239f, 
    -0.37080795f, -0.09283990f, 0.36991620f, 0.01321661f, -0.24686632f, 0.17206913f, -0.03526511f, -0.16802147f, 
    -0.10458762f, -0.17486064f, -0.04783580f, 0.14734471f, -0.08112360f, -0.04643410f, 0.16758002f, -0.04347147f, 
    -0.06370126f, 0.06274510f, -0.09365050f, 0.12826583f, -0.29007035f, -0.27843270f, -0.01706214f, 0.21961640f, 
    -0.00148146f, 0.18105021f, -0.15281264f, 0.21995154f, -0.00127273f, 0.04267316f, -0.08820526f, 0.11852068f, 
    -0.01004021f, -0.05603027f, -0.02167232f, -0.02951160f, -0.07982334f, 0.05959186f, -0.40510395f, 0.02464736f, 
    -0.03835016f, -0.17026471f, -0.09173828f, 0.01857542f, -0.04760367f, -0.03878042f, -0.07224313f, 0.06196699f, 
    -0.08754852f, -0.16686946f, -0.04367360f, 0.05765542f, 0.04292740f, -0.03376435f, 0.07515001f, 0.00678858f, 
    0.01145790f, 0.09373316f, -0.05856644f, -0.11040383f, -0.15268958f, -0.11734260f, 0.20141189f, -0.12804715f, 
    -0.01308267f, 0.20487995f, 0.02661845f, -0.11446472f, -0.06392651f, -0.01946644f, -0.09653659f, 0.03522031f, 
    0.04850430f, 0.01469707f, -0.02453534f, 0.16229613f, 0.03440424f, 0.08958469f, -0.07826538f, 0.08892809f, 
    0.45999357f, 0.07984288f, -0.00488296f, 0.16069075f, 0.08289009f, -0.11737386f, 0.04287741f, -0.10169412f, 
    0.02434894f, -0.01603561f, -0.12372733f, 0.03599238f, 0.05280448f, -0.05089111f, -0.06718157f, 0.02822891f, 
    0.10141458f, 0.11679572f, 0.11679690f, 0.06524879f, -0.32312545f, -0.16731355f, -0.30999789f, 0.25744653f, 
    0.15641634f, 0.11081643f, 0.00245702f, -0.02122331f, -0.17372169f, 0.08777156f, -0.03749625f, 0.06710489f, 
    -0.20440131f, 0.16843098f, -0.06618331f, 0.04163687f, 0.08592504f, 0.07768586f, 0.11096945f, 0.06528307f, 
    0.01938682f, 0.08041114f, 0.45866334f, 0.25788304f, -0.01746359f, -0.03919497f, -0.16955987f, -0.00720090f, 
    0.08816233f, 0.29925075f, 0.06489819f, 0.08639430f, -0.02390960f, 0.03596012f, -0.07069555f, 0.00700675f, 
    -0.12722774f, -0.12022742f, -0.02249148f, 0.11071254f, -0.16311885f, 0.18254273f, 0.25837791f, 0.30355650f, 
    -0.08839402f, -0.11952568f, -0.00160630f, -0.07418635f, 0.36300814f, -0.01666737f, -0.10857034f, -0.03709389f, 
    0.05029405f, -0.07040059f, 0.12251151f, 0.10836880f, 0.00356049f, -0.08040193f, 0.10328157f, 0.22719665f, 
    -0.20757490f, -0.07117060f, -0.00638337f, -0.02317470f, 0.38368794f, 0.22875963f, -0.02520493f, 0.22856244f, 
    -0.05975031f, -0.08813507f, -0.02537931f, 0.08044651f, 0.03292120f, -0.12197154f, 0.06196505f, 0.04795121f, 
    0.02059916f, 0.14420001f, 0.09268381f, -0.08097479f, -0.15385231f, 0.16041060f, -0.02678536f, 0.06979840f, 
    0.05074173f, 0.08030755f, 0.04474207f, 0.15141229f, -0.01058812f, 0.20596763f, -0.13234663f, 0.07389794f, 
    -0.07825794f, 0.01148255f, -0.03620631f, 0.05109225f, -0.18858631f, -0.05195982f, -0.11197373f, -0.18469220f, 
    -0.26290983f, 0.05447832f, 0.09021302f, 0.62413877f, -0.11995602f, 0.12764326f, 0.07151248f, -0.02741217f, 
    -0.07675622f, 0.03070365f, 0.04912909f, 0.03611781f, 0.06562398f, 0.00319905f, 0.07427261f, 0.09263697f, 
    0.04697094f, -0.15810603f, 0.19927672f, 0.15202649f, 0.14054178f, 0.12218367f, 0.26140517f, 0.14011775f, 
    -0.17451906f, -0.16737527f, -0.03085170f, -0.06026993f, 0.04003185f, -0.04373518f, -0.08483011f, 0.00813508f, 
    -0.05508703f, -0.10096313f, -0.08361784f, 0.16173343f, -0.02910674f, -0.02612830f, 0.09130790f, -0.03601198f, 
    0.20478229f, 0.07126029f, 0.29377866f, 0.04824079f, -0.31135672f, 0.09155965f, 0.04175707f, -0.15685140f, 
    -0.04853057f, 0.05079064f, 0.04438594f, -0.02480232f, 0.03437027f, 0.01198473f, 0.02946201f, -0.07353491f, 
    -0.10163925f, -0.00083888f, -0.03442516f, 0.04753078f, -0.01169251f, -0.20542511f, -0.11504954f, 0.39250782f, 
    0.18568745f, -0.03010156f, 0.04534242f, -0.07117247f, -0.11091235f, -0.06403076f, -0.14684650f, 0.08420774f, 
    0.02461383f, 0.04545484f, -0.05841292f, 0.11430078f, 0.01961290f, -0.07529296f, -0.16455735f, -0.02112893f, 
    -0.01741004f, 0.01689728f, -0.00451581f, 0.04044259f, 0.03512924f, -0.01065093f, 0.03876779f, -0.01675324f, 
    0.01960784f, -0.05687463f, 0.02952695f, -0.06355078f, -0.04577701f, -0.02118887f, -0.00413457f, 0.04017745f, 
    0.04669472f, -0.05782548f, -0.05164392f, 0.02902981f, -0.01698996f, -0.05298157f, -0.01036314f, 0.02431891f, 
    -0.05331722f, 0.01160518f, 0.04462619f, -0.03520704f, -0.02618502f, -0.02084041f, -0.00334290f, 0.00621729f, 
    -0.05372777f, 0.00969679f, -0.02306792f, -0.05773244f, 0.02651745f, -0.02530817f, -0.03788905f, 0.01033750f, 
    -0.00189978f, -0.00900720f, -0.04033517f, -0.05539159f, 0.00346547f, 0.04766497f, -0.05266463f, -0.00575749f, 
    0.01709585f, -0.01004557f, -0.01604814f, -0.03944172f, -0.01015132f, 0.00671968f, 0.04440038f, -0.05134433f, 
    -0.00379792f, 0.02472450f, 0.02324658f, -0.01662578f, 0.03040846f, -0.02364653f, 0.01853338f, -0.00634380f, 
    0.00681236f, 0.00638590f, -0.03548247f, -0.02921037f, -0.02791679f, -0.04511797f, 0.00989898f, 0.03699271f, 
    -0.03695837f, 0.00383495f, -0.01566198f, 0.03372838f, 0.00204386f, -0.03082899f, 0.00630392f, -0.02777512f, 
    0.03326396f, -0.03080713f, -0.04970673f, -0.05187598f, 0.01170459f, -0.02692215f, 0.04782243f, -0.05290345f, 
    -0.00758972f, -0.02805739f, -0.00848567f, -0.03027444f, -0.03637281f, 0.03496893f, 0.02162865f, 0.00353390f, 
    -0.00148068f, -0.05276493f, -0.05272177f, -0.02051317f, -0.00505358f, -0.02508986f, 0.03841904f, 0.01248202f, 
    -0.01023856f, 0.04435541f, -0.01889350f, 0.04522319f, -0.00944039f, 0.01866747f, -0.01090333f, -0.02553732f, 
    -0.05151804f, 0.01085183f, 0.04055953f, 0.02137672f, -0.01049165f, -0.06083571f, -0.02031735f, -0.05446452f, 
    -0.01089924f, 0.03934382f, -0.02215898f, -0.06061666f, -0.00013977f, -0.03061020f, 0.01140085f, 0.03944750f, 
    0.01809952f, 0.04328915f, 0.03727238f, 0.00605921f, 0.01302565f, -0.00295783f, 0.00806977f, -0.03127909f, 
    -0.06010495f, 0.01992891f, 0.02814462f, -0.04912077f, -0.04963378f, 0.03352569f, -0.05526902f, -0.03479596f, 
    0.00805240f, 0.03223387f, 0.03447331f, -0.02211074f, -0.04901473f, -0.04982624f, 0.00641528f, -0.06275208f, 
    0.04186007f, 0.02456160f, -0.02594774f, 0.02946451f, -0.03720598f, 0.00996917f, 0.01078172f, 0.02514444f, 
    -0.04722587f, 0.04581168f, -0.05192292f, -0.00796523f, 0.03322963f, -0.06612156f, -0.02841087f, -0.02046132f, 
    0.00616507f, 0.03148444f, -0.01340707f, -0.01345848f, -0.03975991f, 0.02683656f, -0.04551805f, 0.00795196f, 
    -0.00005807f, -0.00219632f, -0.00842953f, 0.00119403f, -0.00205630f, 0.01393513f, -0.04541380f, -0.00297634f, 
    0.04267028f, -0.00158695f, -0.02028314f, -0.00422559f, 0.01569349f, 0.00227163f, -0.04173750f, 0.03784912f, 
    -0.05540806f, -0.01496135f, -0.03431619f, -0.01073418f, 0.03958578f, -0.03783140f, -0.04104758f, 0.00262591f, 
    -0.01292461f, 0.03931968f, -0.01340402f, -0.04091511f, -0.01667906f, 0.03968056f, 0.04556178f, -0.04327035f, 
    0.03308858f, -0.02511143f, 0.01128879f, -0.01528048f, -0.06175829f, 0.03799827f, -0.04194115f, 0.00427337f, 
    -0.03115501f, -0.00735015f, -0.05365073f, 0.03505458f, 0.04212797f, -0.01896184f, 0.02569994f, -0.03746665f, 
    0.02123773f, -0.05278173f, 0.03970652f, -0.01136674f, -0.00862130f, -0.02066053f, -0.02279942f, -0.00385672f, 
    -0.02630843f, -0.03958352f, 0.03977045f, -0.02956585f, 0.02958563f, 0.02650229f, -0.01975384f, 0.00934214f, 
    0.00939940f, -0.02614241f, 0.05054333f, 0.04608068f, 0.04428106f, -0.02906662f, -0.04259736f, 0.02281249f, 
    -0.03419410f, -0.05546734f, -0.05965241f, -0.05031214f, -0.02164816f, 0.02850380f, -0.01507119f, -0.00997071f, 
    0.00881477f, 0.04585978f, 0.00377690f, -0.05934331f, -0.06521021f, -0.02511886f, -0.02014716f, 0.03212538f, 
    -0.05508085f, 0.04226192f, -0.02935396f, 0.01306977f, 0.02835722f, -0.05056190f, -0.00219227f, 0.03151472f, 
    0.00799818f, 0.04637923f, -0.04997033f, 0.04538641f, 0.03166909f, -0.04641321f, 0.00798624f, -0.01791598f, 
    0.03752816f, -0.01309225f, 0.01587468f, -0.00996668f, 0.00234097f, -0.04925670f, -0.04005864f, 0.01030376f, 
    0.00284260f, 0.00219208f, -0.03238370f, -0.01801202f, 0.02496259f, -0.03228484f, -0.02742571f, 0.03367820f, 
    -0.01036432f, -0.05399055f, -0.04851668f, -0.03270263f, 0.03100994f, 0.01309703f, 0.00913080f, -0.04810417f, 
    -0.02938320f, -0.01010137f, 0.03321569f, -0.00693926f, 0.05222447f, -0.04245677f, 0.02650376f, 0.04151622f, 
    0.00028253f, 0.02429972f, 0.00684905f, -0.05498650f, 0.03009601f, -0.05289809f, -0.02180627f, -0.00688318f, 
    -0.03163148f, -0.04154994f, 0.03770265f, -0.03254750f, 0.04317641f, 0.01338183f, 0.04577397f, -0.00465476f, 
    -0.03519285f, 0.00706498f, 0.03868825f, -0.03219210f, -0.05118207f, 0.00873195f, 0.01765177f, 0.03003497f, 
    -0.02576182f, -0.04683207f, 0.01794419f, -0.01595195f, 0.04091812f, -0.02163300f, -0.04715863f, -0.02922346f, 
    -0.03186668f, -0.01607157f, 0.03922776f, 0.01328417f, 0.01386543f, -0.00435808f, 0.00812352f, 0.04628937f, 
    0.01770592f, -0.02299100f, -0.00592709f, -0.01945612f, 0.01553461f, -0.01390277f, 0.02442299f, -0.00673762f, 
    -0.02129068f, 0.02472782f, 0.01714146f, 0.04805535f, 0.05912880f, 0.02578917f, -0.05046660f, -0.00689492f, 
    0.00928120f, -0.03002264f, -0.00332827f, 0.03652806f, -0.01066107f, 0.01893203f, 0.00452249f, -0.03081653f, 
    0.02419959f, 0.00654735f, 0.01690297f, 0.01484572f, -0.04209439f, 0.00569665f, -0.05261829f, 0.02563308f, 
    -0.05052775f, 0.00795793f, -0.00426714f, -0.04111728f, 0.02881267f, 0.00904793f, 0.00454919f, -0.05373892f, 
    -0.05473224f, -0.03111968f, -0.04192521f, -0.05024813f, -0.01976349f, 0.03388627f, -0.05533043f, -0.04960071f, 
    0.04148262f, -0.04947075f, -0.01067834f, -0.01663665f, -0.04015652f, -0.04666932f, -0.02859475f, -0.02702649f, 
    -0.01719559f, -0.00835192f, 0.02181495f, -0.04065823f, -0.02855961f, 0.02393295f, -0.00715004f, -0.00383292f, 
    0.04762325f, 0.02965538f, 0.00765659f, -0.04117112f, -0.01526136f, 0.03403566f, 0.02031731f, -0.02390929f, 
    0.02330902f, -0.02763945f, -0.02399786f, 0.02036983f, -0.05555910f, -0.02517544f, -0.01716695f, 0.00051186f, 
    0.02336516f, 0.03123532f, 0.00851421f, 0.00086093f, 0.01411203f, -0.05847472f, 0.00155760f, -0.03046300f, 
    -0.02780272f, 0.00973273f, -0.03002698f, 0.02922943f, -0.02755032f, 0.05383543f, 0.01595474f, -0.02851476f, 
    -0.02773095f, -0.01605580f, -0.00399291f, -0.03764157f, -0.05810117f, -0.01173551f, -0.04842582f, -0.01982748f, 
    -0.02934039f, 0.00479849f, 0.02772600f, -0.02469418f, 0.01736484f, -0.01040380f, 0.00715397f, -0.01808034f, 
    0.04406705f, -0.04367004f, 0.04781031f, -0.04114204f, -0.01823762f, -0.05221200f, 0.01867061f, -0.02552107f, 
    -0.04313819f, -0.03701388f, 0.04825192f, -0.00671037f, 0.03066945f, 0.03784043f, -0.03491743f, -0.04838408f, 
    -0.03987699f, -0.06092219f, -0.00342665f, -0.03515074f, -0.01739778f, -0.05093090f, 0.00412118f, -0.02922938f, 
    0.01578221f, -0.05764906f, -0.00944433f, -0.04117607f, -0.05538251f, -0.04513034f, -0.01256753f, 0.00371691f, 
    -0.00798209f, -0.03272925f, 0.02550342f, 0.02623653f, 0.00820021f, 0.00718223f, -0.05674835f, 0.02649801f, 
    0.01023038f, -0.03414143f, -0.04629853f, -0.00665900f, -0.04805182f, -0.00822649f, 0.03398261f, 0.05514290f, 
    -0.06126511f, 0.02134646f, 0.02462129f, -0.04767245f, -0.03020481f, -0.02425764f, -0.02845296f, 0.04842315f, 
    -0.02395301f, -0.00080461f, 0.02660766f, 0.01333723f, -0.02963977f, 0.00137354f, 0.02258556f, 0.04311827f, 
    0.04288672f, 0.01976042f, 0.05015613f, 0.02570732f, -0.05421366f, -0.00808236f, 0.02409780f, 0.00920758f, 
    -0.06074373f, 0.01106851f, -0.04803064f, 0.03045143f, -0.03010361f, -0.03877778f, -0.03069465f, -0.02964151f, 
    0.02115109f, 0.04175927f, 0.04061241f, -0.00732498f, -0.05920074f, 0.01927261f, -0.02201997f, 0.05178706f, 
    -0.02025849f, 0.04250029f, -0.02121824f, 0.01196802f, 0.04623690f, -0.05202348f, 0.00019761f, -0.02621742f, 
    -0.00245771f, -0.03328951f, -0.03892537f, 0.01621187f, 0.00691710f, -0.04612013f, -0.00358933f, 0.00632550f, 
    0.02661906f, 0.02211150f, 0.04304908f, -0.03504045f, 0.01319830f, -0.03219717f, -0.00956377f, -0.03199553f, 
    -0.02474716f, 0.01892465f, 0.00637557f, 0.00051365f, -0.01046398f, 0.02941488f, -0.03032327f, 0.03863681f, 
    -0.01307057f, -0.00345079f, 0.03230523f, 0.03113872f, 0.02534413f, -0.05605874f, 0.01662439f, 0.00081147f, 
    0.04324728f, -0.03522833f, -0.01926048f, 0.03995192f, 0.00320148f, 0.01955341f, -0.02391481f, 0.01780904f, 
    -0.04006580f, -0.00065848f, -0.04771928f, 0.00327632f, -0.03645910f, 0.04693019f, -0.04527952f, 0.01972278f, 
    -0.01364533f, 0.00872489f, -0.01521039f, -0.01890646f, 0.01634837f, -0.00228035f, 0.02222809f, -0.05144864f, 
    -0.04914506f, 0.02915932f, -0.00770162f, -0.03494473f, -0.04562262f, -0.00137828f, 0.04804994f, 0.00206208f, 
    -0.02867924f, 0.02006163f, -0.02299896f, -0.00396619f, -0.00724611f, 0.02360376f, 0.00412134f, -0.04084364f, 
    -0.04581595f, -0.05871987f, 0.04392339f, 0.00485149f, -0.02536603f, -0.03231616f, 0.01301574f, 0.05380298f, 
    0.18578938f, 0.19169772f, -0.09921245f, -0.33706531f, -0.12282141f, 0.04281799f, -0.03099560f, 0.16685978f, 
    0.18954726f, 0.32747889f, -0.07913799f, 0.00449389f, 0.14087418f, 0.05222045f, -0.04698259f, -0.10714393f, 
    0.08157419f, -0.09545791f, 0.06812693f, 0.23551303f, 0.10120000f, 0.02384724f, -0.00955594f, 0.05949807f, 
    0.14518775f, 0.02484601f, -0.01641633f, -0.03287514f, 0.02279397f, 0.07832824f, 0.03177064f, -0.00621207f, 
    -0.06231236f, 0.01092434f, 0.06550691f, -0.17835121f, -0.09413312f, -0.09656499f, -0.04015243f, -0.09166515f, 
    -1.20519614f, -0.32157901f, -0.10347149f, -0.05471355f, -0.08778071f, -0.14808197f, -0.07998385f, 0.26867053f, 
    0.02051766f, -0.04520286f, -0.02054309f, -0.14021663f, -0.05206062f, 0.09420114f, -0.02753896f, -0.01780136f, 
    0.06405124f, 0.01496168f, 0.02981734f, 0.00470069f, -0.13189057f, 0.06006931f, -0.25977084f, -0.72577149f, 
    -0.14990877f, 0.11607541f, 0.15606827f, 0.17288418f, 0.26951954f, 0.21428558f, -0.01722156f, 0.02344740f, 
    0.07798764f, -0.03222850f, 0.05684392f, -0.08746623f, -0.10692718f, 0.03541442f, -0.07176609f, 0.07235998f, 
    -0.00423595f, -0.03789228f, 0.11720525f, 0.13225803f, 0.05736599f, -0.07920353f, -0.07950534f, 0.03656745f, 
    0.10014877f, 0.07304247f, 0.00780324f, 0.04498120f, -0.03328809f, 0.08945591f, -0.09180550f, -0.12755287f, 
    -0.12101865f, -0.03725382f, 0.04275670f, -0.03644854f, -0.06126439f, 0.03143183f, 0.19865130f, 0.09082011f, 
    0.09432898f, -0.05860251f, -0.03110462f, -0.04672834f, 0.03041694f, 0.09542666f, 0.09336475f, -0.04143569f, 
    -0.03878481f, 0.12287376f, -0.07653484f, -0.02658774f, -0.18669917f, 0.00373254f, 0.02174536f, -0.08720666f, 
    0.14091448f, 0.03652630f, 0.02630945f, 0.00825784f, 0.13955100f, 0.02958245f, 0.04520743f, 0.01025815f, 
    0.06739854f, 0.07353982f, 0.00745227f, -0.05344491f, 0.01161290f, 0.07422516f, 0.06955038f, 0.09412395f, 
    0.09242117f, -0.16913582f, -0.04509437f, -0.13793103f, -0.06742913f, -0.27927816f, 0.00151210f, 0.04256029f, 
    0.27234486f, -0.09915216f, -0.06318495f, 0.13320880f, 0.15284181f, -0.16444091f, 0.03871590f, 0.12304164f, 
    -0.07447754f, 0.05885501f, -0.19473428f, 0.02502723f, -0.10301204f, -0.07680997f, 0.04414739f, 0.05099975f, 
    -0.17673644f, 0.29055789f, 0.10114473f, -0.24230489f, -0.04766048f, 0.11044204f, 0.20522808f, 0.20295590f, 
    0.15405172f, 0.12289896f, 0.02255895f, -0.01962851f, -0.00589677f, -0.02117362f, 0.04906490f, 0.01212377f, 
    -0.11673497f, 0.21950504f, -0.08357364f, -0.11467063f, -0.13593945f, -0.22630145f, -0.33708042f, -0.58498567f, 
    -0.07419328f, 0.00980345f, -0.04268135f, -0.11489382f, -0.00488884f, 0.28441659f, -0.00610412f, -0.08540406f, 
    0.01085472f, -0.01530169f, 0.04659653f, -0.17038821f, 0.25853208f, -0.04830019f, 0.08738285f, -0.23888312f, 
    0.24853404f, -0.14191605f, 0.22517468f, 0.14063691f, 0.03571075f, -0.04993602f, 0.12803592f, 0.01477595f, 
    0.02164603f, -0.12821834f, 0.06414685f, 0.11842863f, 0.23351647f, -0.11229071f, 0.08049981f, 0.15013902f, 
    -0.05475615f, 0.02162376f, -0.23320873f, 0.11043832f, -0.07988249f, 0.10078528f, 0.02805759f, -0.09056564f, 
    0.14847918f, 0.19431113f, -0.25916240f, -0.08330608f, 0.08383366f, 0.05660845f, 0.16109304f, -0.10408783f, 
    -0.04419005f, 0.07007258f, -0.07731750f, -0.06742130f, 0.03033269f, 0.00196415f, -0.10491087f, 0.05702014f, 
    -0.21075796f, 0.06344361f, -0.55915272f, -0.18221031f, -0.09563874f, 0.09074884f, 0.05539076f, -0.00133216f, 
    0.13197361f, 0.18728076f, 0.00748688f, -0.04823108f, 0.01048627f, 0.03549646f, -0.07504494f, -0.21963808f, 
    -0.05372374f, -0.12731700f, -0.15896797f, 0.12941055f, 0.09215791f, 0.05605926f, 0.02759365f, 0.05162766f, 
    0.16119219f, 0.01669190f, 0.03310729f, 0.09813656f, -0.10011677f, 0.05536431f, -0.02925329f, 0.00220127f, 
    0.03269789f, 0.06755728f, -0.01068551f, 0.04575951f, -0.06120270f, -0.18701005f, -0.13031338f, -0.12985311f, 
    0.44568127f, -0.04539577f, 0.17341353f, 0.08871152f, 0.09337105f, 0.00765309f, 0.05973845f, 0.05469389f, 
    -0.12923601f, 0.04379226f, 0.15445980f, -0.06639036f, -0.04885864f, -0.18761535f, 0.01037788f, -0.05765160f, 
    -0.00218436f, -0.13329372f, 0.02652519f, -0.09687321f, -0.14468943f, 0.12531057f, 0.08529072f, -0.01924686f, 
    0.18320170f, 0.06150433f, 0.13514276f, 0.20753603f, 0.05712771f, -0.10643149f, 0.05030817f, 0.04506740f, 
    0.06768590f, -0.03403234f, 0.00615821f, -0.05237010f, -0.06659044f, 0.00706126f, 0.03398501f, 0.08427911f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04816122f, -0.05380087f, 0.10526756f, -0.03781560f, 0.20093659f, 0.05644047f, -0.01958949f, 0.04907279f, 
    0.03735898f, -0.04343303f, -0.01176205f, 0.02551535f, -0.08341723f, 0.03527741f, -0.05989100f, 0.01705911f, 
    0.11595620f, 0.17054018f, 0.15384990f, 0.07837278f, -0.06120288f, 0.07536905f, 0.24903902f, -0.07468770f, 
    0.04725920f, 0.07071266f, -0.03913257f, -0.09634718f, 0.03421856f, -0.05346505f, -0.03996143f, 0.08316129f, 
    0.10149089f, 0.17170119f, 0.10357213f, -0.05757748f, 0.09573504f, 0.10463709f, -0.01528717f, -0.00094434f, 
    0.19468626f, -0.10715640f, 0.02014435f, 0.08554271f, 0.14326081f, 0.02076363f, 0.01078903f, 0.01010160f, 
    -0.07847940f, 0.22513784f, -0.04655567f, 0.08634265f, 0.00071762f, 0.08741110f, -0.02469541f, -0.09599369f, 
    -0.03123681f, 0.10079291f, 0.16815212f, -0.11619489f, 0.16529849f, -0.02218980f, 0.00609395f, 0.17619614f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.18934007f, 0.12446732f, -0.22746587f, -0.12028903f, -0.37577140f, 0.25229490f, 0.03336496f, -0.08336405f, 
    -0.23644860f, -0.55959362f, -0.02530845f, -0.04736501f, 0.09374223f, -0.14371464f, 0.02405906f, 0.09408800f, 
    -0.05965789f, -0.07816789f, -0.20191146f, -0.31357983f, -0.08577333f, -0.14171462f, -0.03550607f, 0.24508703f, 
    -0.60951138f, -0.50045133f, -0.06254335f, 0.20743899f, -0.01482723f, 0.08661787f, 0.09500473f, 0.27920276f, 
    0.24957624f, -0.12419595f, -0.02577972f, 0.06936303f, 0.08877806f, -0.21499203f, 0.03676210f, 0.12191270f, 
    -0.25454813f, 0.06718434f, 0.06617136f, -0.19842958f, -0.42987868f, -0.00859427f, -0.44764304f, -0.42170998f, 
    0.23879647f, -0.20926844f, -0.10374801f, -0.18145716f, -0.02040065f, -0.26239809f, 0.11827473f, 0.15747818f, 
    -0.04564839f, -0.08790684f, -0.36126065f, 0.33388531f, -0.25545734f, 0.07885566f, 0.01092763f, 0.06202218f, 
    0.04411955f, 0.18949202f, 0.32920468f, 0.02695618f, 0.14432561f, 0.28209344f, -0.04777437f, -0.15841383f, 
    -0.06397031f, -0.64899766f, -0.11888433f, 0.07015316f, 0.27209970f, 0.07051884f, -0.22668654f, -0.13694341f, 
    -0.06024192f, 0.19901100f, 0.15160790f, 0.12398823f, -0.08191379f, 0.24051528f, 0.33640489f, 0.16952901f, 
    -0.26530275f, -0.01845357f, -0.05524762f, -0.65767509f, 0.06381629f, -0.02503489f, 0.01379055f, -0.01004555f, 
    0.13647737f, -0.11924543f, 0.00001457f, 0.08256344f, 0.15579034f, 0.03282974f, -0.00811317f, -0.05435080f, 
    0.10663375f, -0.20991713f, -0.01568093f, -0.20858246f, -0.31330588f, 0.06578933f, -0.29108974f, -0.00605851f, 
    0.04755515f, 0.08931281f, 0.11408781f, -0.03803525f, 0.07786716f, -0.31289145f, 0.10390104f, 0.03614655f, 
    -0.11387721f, -0.22869614f, 0.00351555f, -0.73211217f, 0.22126812f, 0.09269257f, -0.00001183f, 0.15645202f, 
    0.10193877f, 0.22595608f, -0.61726356f, 0.03988134f, -0.20929700f, -0.91094798f, -0.05178755f, 0.09496224f, 
    0.04625647f, -0.23136273f, -0.12328333f, -0.00028434f, -0.15304480f, -0.42959708f, 0.06286194f, 0.28750241f, 
    -0.13189958f, 0.14695932f, -0.02944444f, 0.06262785f, 0.10622160f, 0.20721519f, 0.20184241f, -0.30367893f, 
    0.17662852f, -0.03713410f, 0.00516994f, -0.66388971f, -0.12283587f, -0.03849401f, -0.01860117f, 0.41784331f, 
    -0.09647369f, 0.00546621f, 0.07471571f, -0.12202902f, -0.17931630f, -0.21273267f, 0.09910078f, 0.12355004f, 
    0.04911189f, -0.20937844f, -0.01967245f, -0.06621408f, 0.20008826f, 0.04612163f, 0.24521059f, -0.01490666f, 
    -0.09560975f, 0.02157810f, -0.03636796f, 0.06588253f, -0.19112566f, 0.16484761f, 0.10297893f, -0.01617201f, 
    0.08074014f, -0.21806358f, 0.18309924f, 0.16095546f, 0.09722102f, -0.03776939f, -0.05100579f, 0.19652177f, 
    -0.48927411f, 0.22017212f, -0.32453287f, 0.01505845f, -0.16590397f, -0.29797953f, -0.22874884f, -0.09134878f, 
    -0.12590523f, 0.23860946f, 0.03259363f, 0.11169750f, 0.16505682f, -0.12172530f, 0.10060019f, 0.26520792f, 
    0.11310463f, -0.67049795f, -0.03223825f, 0.03023405f, -0.12735298f, 0.27454421f, -0.65126866f, -0.06255870f, 
    0.53561133f, -0.03793378f, 0.01487448f, 0.07498967f, -0.01454323f, 0.01315579f, -0.08703879f, -0.12145237f, 
    -0.25460050f, -0.72853065f, 0.24822463f, 0.10089465f, -0.12636997f, -0.18807960f, 0.06296360f, -0.66611892f, 
    -0.26956806f, 0.12357041f, 0.05684297f, 0.10440974f, -0.17273605f, -0.09528990f, 0.19921850f, -0.04799392f, 
    -0.07673983f, -0.07367650f, 0.11685508f, 0.14432456f, 0.25160298f, 0.13487725f, 0.27963629f, 0.15082197f, 
    -0.00459190f, -0.05179814f, -0.38172132f, 0.23526607f, 0.00894018f, -0.00903631f, -0.01957732f, -0.18954733f, 
    0.16053928f, -0.11407571f, 0.24049741f, -0.02684824f, -0.32667449f, -0.03010690f, -0.08609321f, -0.13942654f, 
    0.13526712f, 0.09683489f, -0.05953127f, 0.04599288f, 0.23760627f, 0.10102703f, -0.05318501f, -0.18455121f, 
    -0.56593800f, -0.08987084f, 0.07664760f, 0.18473850f, -0.07980640f, -0.29516926f, -0.15884207f, 0.01818107f, 
    0.03047139f, 0.33411479f, 0.04951656f, 0.11933971f, 0.09423333f, 0.02562761f, -0.00245074f, 0.04557272f, 
    -0.17984097f, -0.06783098f, -0.41205585f, -0.00503855f, -0.08186481f, -0.09739995f, -0.06827004f, 0.24110855f, 
    -0.31244260f, 0.08234031f, -0.04812541f, -0.05764420f, -0.58677620f, 0.04185428f, 0.11199842f, 0.20570074f, 
    0.08634764f, -0.46320549f, -0.08635441f, 0.24645229f, -0.12126692f, 0.24138367f, -0.23649341f, -0.05725178f, 
    -0.06284097f, 0.21192954f, -0.02322724f, 0.16078340f, 0.14519460f, -0.00182612f, -0.08034026f, 0.00122617f, 
    0.02379860f, -0.31299359f, -0.18962732f, 0.00801926f, 0.14891568f, 0.31730616f, -0.17007296f, -0.02724078f, 
    -0.26862341f, 0.00020352f, -0.08252284f, 0.00460577f, -0.21924327f, 0.25779694f, 0.00063025f, 0.04264358f, 
    -0.10907647f, -0.03984797f, 0.18608373f, -0.87364656f, -0.07368629f, 0.08282329f, -0.01172781f, -0.09992702f, 
    -0.17309718f, -0.12980217f, -0.09631334f, 0.28870440f, 0.08653917f, -0.04376667f, 0.01007081f, 0.12865366f, 
    0.10353720f, 0.30902958f, 0.25625077f, 0.11427697f, 0.16659950f, -0.17232090f, 0.04281509f, 0.28227428f, 
    0.03403347f, 0.10046674f, -0.09091467f, -0.29171455f, 0.29429349f, -0.03956252f, 0.12856899f, -0.12732112f, 
    -0.28290668f, -0.10585748f, -0.09109413f, 0.12079513f, -0.02949461f, 0.06645150f, -0.00469504f, -0.07116325f, 
    -0.05551512f, 0.39022207f, -0.04620128f, -0.12010413f, -0.01442418f, -0.06804708f, -0.07457125f, 0.08843578f, 
    -0.09197898f, -0.17574655f, 0.15118583f, 0.01588004f, -0.27074340f, -0.49507338f, 0.19883160f, -0.09190381f, 
    0.18447728f, 0.45355573f, -0.01657632f, 0.03907244f, -0.54350144f, -0.00497347f, 0.29817355f, -0.03574339f, 
    0.05081943f, 0.21823068f, 0.01492222f, 0.14893110f, 0.03119856f, -0.21367545f, -0.09204628f, -0.49466503f, 
    -0.12898429f, 0.28954294f, -0.03757105f, -0.12097935f, 0.05875861f, 0.09239952f, 0.10220299f, -0.39839688f, 
    -0.23070143f, 0.33829138f, 0.00814005f, -0.07631206f, 0.06838034f, 0.11524566f, -0.05481837f, -0.16611400f, 
    -0.22695597f, -0.34625259f, -0.04193110f, 0.41100243f, 0.18342838f, 0.02420766f, -0.35600263f, 0.05786638f, 
    -0.36561272f, 0.27685192f, -0.01132635f, -0.35401100f, -0.31977230f, 0.23527218f, 0.13818689f, 0.04375223f, 
    -0.12511919f, -0.42528632f, -0.03632767f, -0.63191473f, -0.58654362f, 0.08127172f, 0.05958493f, -0.05279784f, 
    0.14536023f, 0.22211531f, 0.14278549f, 0.08322065f, 0.18255326f, -0.41802368f, -0.00511351f, 0.05966988f, 
    0.15321599f, 0.18701129f, 0.02702059f, 0.09006242f, -0.34446815f, 0.13866101f, -0.28009471f, -0.10460255f, 
    0.00981555f, -0.01914627f, -0.16779096f, 0.20103590f, -0.10005239f, 0.22183309f, -0.11627395f, 0.06534959f, 
    0.50269759f, -0.55714649f, 0.00015334f, 0.34923592f, -0.02395432f, -0.07006546f, 0.00935481f, -0.23051131f, 
    -0.30744123f, -0.22760046f, -0.42595640f, 0.10034911f, -0.00382952f, -0.33990258f, 0.02689854f, 0.11543783f, 
    0.12962444f, 0.12722760f, 0.09387592f, -0.21029124f, -0.04260856f, -0.04771766f, 0.16785976f, 0.14567730f, 
    -0.02236989f, -0.21312213f, 0.01620894f, -0.29218888f, -0.37173182f, -0.24895032f, -0.41744670f, 0.17315257f, 
    0.04090654f, -0.36019731f, -0.26313600f, 0.41958490f, -0.34195283f, -0.02488977f, 0.07454780f, -0.20759384f, 
    -0.06917636f, -0.36892462f, 0.00024561f, 0.00373175f, 0.17851757f, -0.15562198f, -0.09389685f, 0.40383336f, 
    -0.12744299f, -0.37155902f, -0.08913641f, 0.00982908f, -0.58179140f, -0.15078509f, 0.09690560f, -0.56849438f, 
    0.38797608f, 0.09566905f, 0.02446673f, -0.23499247f, 0.04213304f, 0.10064098f, -0.41587338f, -0.11463693f, 
    0.37843469f, -0.46210623f, 0.02929142f, -0.33049250f, -0.07284454f, 0.02845214f, -0.07384805f, 0.08430386f, 
    0.24059413f, -0.29260552f, 0.02678445f, 0.02743506f, -0.00119221f, 0.07536463f, -0.05574350f, -0.17613535f, 
    0.15719140f, 0.32716575f, -0.02502973f, 0.18139024f, 0.06231524f, 0.13015954f, 0.33349407f, 0.00839683f, 
    -0.13835312f, 0.06379221f, -0.06998823f, -0.39442211f, 0.29895726f, -0.31698471f, 0.07563324f, -0.15675335f, 
    -0.03774924f, 0.00332314f, 0.05499775f, -0.28596312f, -0.54613233f, 0.07218306f, -0.04850793f, -0.11591432f, 
    0.30235940f, -0.25651041f, -0.28594229f, 0.01964919f, 0.05246178f, 0.12680541f, 0.17332016f, -0.01183677f, 
    -0.19569694f, 0.28858262f, 0.06906594f, 0.10225921f, 0.05092341f, 0.19617838f, -0.14297275f, 0.34557852f, 
    -0.22182840f, 0.03835203f, -0.20008674f, 0.01732178f, 0.02400877f, -0.34387675f, 0.26682886f, 0.01360601f, 
    0.06025817f, 0.16703357f, 0.02967123f, -0.15606253f, 0.05910372f, 0.10640534f, 0.04509373f, -0.60481840f, 
    -0.37315860f, 0.26704276f, -0.35367200f, -0.04039056f, 0.16962709f, 0.09121139f, -0.09150201f, -0.03280586f, 
    -0.31385171f, -0.17477509f, 0.09718587f, -0.15543631f, 0.26867178f, -0.11096931f, -0.58390504f, -0.24699868f, 
    0.04834698f, 0.18833126f, 0.10308059f, 0.28715545f, 0.17355961f, 0.14807557f, -0.56076515f, -0.38407409f, 
    0.08566224f, -0.08391692f, 0.29332352f, 0.21443172f, 0.08871777f, -0.07529261f, -0.09756481f, 0.02686729f, 
    -0.51992851f, 0.06893439f, -0.03546894f, -0.11224758f, 0.14538091f, -0.41326043f, -0.41347229f, -0.53035194f, 
    0.25098193f, -0.04031281f, -0.03417061f, -0.07779822f, -0.21105480f, -0.12310603f, 0.27583173f, -0.13832583f, 
    0.27299801f, 0.23450448f, -0.23531042f, -0.28341123f, 0.01100080f, -0.17221792f, 0.20154047f, 0.16575475f, 
    -0.02953900f, 0.24376291f, 0.03972589f, 0.13596717f, -0.09608121f, -0.09068765f, -0.05933867f, -0.25417387f, 
    0.12343068f, -0.07750001f, -0.18828468f, -0.02617322f, -0.56233031f, -0.06915801f, -0.00951554f, 0.15456796f, 
    0.23686668f, 0.22775713f, 0.08978786f, 0.44102472f, -0.17316099f, -0.05811217f, 0.12370750f, -0.11255916f, 
    0.14313656f, -0.00414785f, -0.00140909f, 0.09540941f, -0.31885281f, -0.30294389f, -0.13054201f, -0.38391173f, 
    0.04559318f, 0.18795544f, -0.36840820f, -0.41178373f, 0.26159245f, -0.06519138f, 0.04172403f, -0.38220659f, 
    -0.18001109f, 0.01434956f, -0.15346210f, -0.10816314f, 0.08617453f, -0.11441232f, 0.18094558f, 0.12450644f, 
    -0.05152700f, -0.16542535f, 0.04410093f, 0.00863262f, -0.43507290f, -0.08609341f, 0.29638711f, -0.63689649f, 
    0.34800240f, -0.14251101f, 0.12235953f, 0.22952273f, 0.09756111f, -0.42411777f, -0.35582295f, 0.27006155f, 
    -0.53740567f, 0.20959760f, -0.08154365f, 0.15532638f, -0.02372583f, -0.08894462f, 0.01055358f, -0.18890758f, 
    0.14654869f, -0.11425549f, 0.08944181f, -0.08694711f, -0.16683628f, 0.27062759f, -0.10167313f, -0.17155352f, 
    0.13396525f, -0.53311646f, -0.01869561f, -0.47497797f, 0.07157221f, -0.08701241f, -0.02403078f, 0.39834136f, 
    -0.29215786f, -0.23428632f, -0.05784887f, -0.62309933f, 0.10751597f, 0.06202725f, 0.28578535f, 0.15702479f, 
    0.00910888f, -0.25355250f, 0.06505223f, -0.17218298f, 0.43018362f, -0.02481773f, -0.10798004f, -0.44122463f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21118650f, 0.13770151f, 0.16997419f, -0.04357511f, -0.11185198f, -0.04224409f, -0.06896527f, -0.16818121f, 
    -0.01451151f, -0.09807657f, -0.04935350f, 0.05813278f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
