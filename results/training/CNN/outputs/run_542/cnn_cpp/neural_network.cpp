#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.81505150f, -0.76270115f, -0.57249111f, 0.73336017f, 0.05505788f, 1.12459660f, -0.03788739f, 0.25106430f, 
    -0.44903460f, 1.27456808f, 0.88021129f, 1.44406855f, -0.58567381f, 0.87034589f, -0.47919217f, 0.16413587f, 
    0.06697615f, -0.08757925f, 0.79709417f, 0.84594530f, 0.85291684f, -0.58936483f, -1.16700411f, 0.00971065f, 
    0.18630539f, 0.59775567f, 0.19847627f, -1.26342583f, 1.52096605f, -0.99251765f, 0.53024799f, 0.14134236f, 
    -1.03511989f, -0.00494312f, 0.07911381f, 0.11976381f, -0.40512258f, -1.11552095f, 1.05647874f, 0.19332524f, 
    -0.52262241f, 0.81787652f, -0.03354846f, -0.49448675f, -0.33284068f, -1.24299383f, -0.15426667f, -1.09358406f, 
    -0.29407579f, 1.15101433f, 0.63502824f, 0.08910901f, -0.19790223f, 0.01333001f, 0.90277135f, -0.87044770f, 
    -0.52061176f, 1.26929784f, 0.59250641f, -0.05886230f, -0.19800837f, -0.35883868f, -0.33470497f, 0.72952682f, 
    0.36730424f, 0.34874213f, -0.65243411f, -1.35683465f, -1.06271613f, -0.31111920f, -0.43132266f, 0.07577847f, 
    0.20890144f, -1.12878025f, -0.49401906f, 0.00500759f, 0.34685516f, 0.32362291f, 0.54454333f, 1.15274417f, 
    -0.20422645f, 0.21393187f, -0.56561780f, -0.65301418f, -1.06588805f, 0.37226540f, 1.01862359f, 0.20373708f, 
    -0.13483748f, 0.87033170f, -0.67571491f, -1.34350693f, -0.98592877f, 0.23623550f, 0.16419309f, 0.42196923f, 
    -0.87104630f, 0.00099252f, -0.18670847f, 1.14884460f, 0.64365119f, 0.86224860f, 0.65570337f, -0.53157324f, 
    0.62136900f, -0.11194804f, 0.04355282f, -0.73542875f, -0.20557296f, -0.86581898f, -0.79312390f, 0.52753109f, 
    -0.92864299f, -0.93218017f, -0.34174204f, -0.11126758f, 0.28593385f, -1.24671566f, -1.29554057f, -1.24092960f, 
    -0.80824775f, -0.15574984f, -0.19433342f, 0.38386580f, -0.24565434f, -0.28429615f, 0.82270181f, 0.63657314f, 
    0.66672659f, 1.35555887f, 1.15853608f, 0.06584682f, 0.36223590f, 0.05381748f, 0.22272788f, 1.27585924f, 
    1.07063115f, 0.25653306f, 0.08786757f, 0.67341840f, 0.33043468f, -0.22544512f, 0.55349010f, 0.51138842f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35140753f, 0.19762793f, 0.27309993f, 0.01072828f, 0.48540893f, 0.31078616f, -0.32458183f, 0.61514622f, 
    0.06047568f, -0.00845606f, -0.58125341f, 0.90227222f, 0.34970334f, 0.35186428f, -0.04931723f, 0.60586858f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.14401208f, 0.14104342f, 0.06112644f, 0.19835734f, -0.12747800f, 0.03901259f, 0.31774005f, -0.11206120f, 
    -0.14707334f, -0.10730455f, -0.20914450f, -0.01700605f, 0.24452235f, 0.04559330f, -0.13329062f, 0.12242199f, 
    0.05467970f, 0.13935757f, -0.30127096f, -0.00590650f, -0.09036420f, 0.02062238f, -0.04795219f, 0.04279273f, 
    -0.11906254f, 0.10556936f, 0.20299707f, -0.60262072f, -0.46422136f, -0.20311728f, 0.17311130f, 0.08439434f, 
    0.04264324f, 0.08740193f, -0.12433557f, -0.00073094f, 0.17136255f, 0.26502007f, 0.07142498f, 0.10567664f, 
    0.01605275f, -0.17308956f, -0.11394464f, -0.01776081f, -0.11057980f, -0.35080457f, -0.31471318f, -0.05834820f, 
    0.28256965f, 0.06641541f, -0.04117919f, -0.00135160f, 0.01967092f, -0.03084891f, -0.06462245f, 0.02858283f, 
    0.05962877f, -0.24356864f, 0.13244614f, -0.13722476f, 0.06990799f, 0.12205319f, 0.14732513f, -0.35058397f, 
    -0.00506331f, 0.05189864f, 0.19750975f, 0.00197907f, -0.17323683f, -0.19669470f, 0.15853073f, 0.24501674f, 
    -0.04538593f, 0.07219082f, -0.18011944f, -0.14130783f, 0.03388110f, 0.00180189f, 0.09823093f, 0.25317523f, 
    0.20613910f, 0.05645004f, 0.05430036f, 0.11089464f, -0.08852363f, 0.16220212f, -0.19520126f, 0.05344252f, 
    0.15157309f, -0.05001676f, -0.01261845f, 0.18543155f, 0.22861113f, -0.03088012f, -0.16969581f, -0.14680795f, 
    0.03410333f, -0.11924525f, -0.16897865f, -0.00632402f, 0.33588368f, 0.11441083f, -0.00465312f, 0.13991614f, 
    -0.04702599f, -0.13749014f, -0.04094042f, 0.29462874f, 0.07776695f, 0.11049796f, 0.03563694f, 0.03450985f, 
    0.06264959f, 0.10451868f, 0.12458964f, 0.12246229f, -0.22221123f, 0.08284269f, 0.03306350f, 0.53123116f, 
    0.44097087f, 0.05440348f, 0.20049220f, -0.26793370f, 0.05772136f, -0.06228985f, 0.33857593f, 0.46510217f, 
    -0.15454155f, 0.05925677f, -0.36279741f, -0.28486213f, -0.05238060f, 0.32483736f, 0.14995588f, 0.04173772f, 
    0.10858259f, -0.22048250f, 0.32980841f, -0.30836394f, -0.05928363f, 0.12951159f, 0.04672926f, 0.13839833f, 
    0.18727401f, 0.04675892f, -0.51730919f, 0.00670073f, 0.21614708f, 0.22151414f, -0.03955764f, -0.20671076f, 
    -0.21178615f, -0.33202952f, 0.11267134f, 0.57868600f, 0.17999439f, 0.08215440f, -0.03146312f, -0.10655195f, 
    -0.01327600f, -0.13513729f, -0.03108904f, -0.11916510f, 0.26761729f, -0.38873696f, -0.18788871f, 0.09892063f, 
    0.19943048f, 0.05207528f, 0.12638171f, -0.50227630f, -0.05304402f, -0.04537633f, 0.05583927f, 0.26097542f, 
    -0.04764429f, 0.02635091f, -0.08261994f, -0.06707570f, -0.24049900f, -0.29341194f, -0.27025780f, 0.12121396f, 
    -0.16208586f, -0.14781980f, -0.12279882f, 0.16200973f, -0.12370027f, -0.59547561f, -0.06263511f, -0.20412150f, 
    0.13942954f, 0.16237125f, 0.12187150f, 0.16406715f, -0.26190558f, 0.12535791f, -0.43825865f, -0.43381950f, 
    -0.33977434f, 0.00503979f, -0.00907074f, 0.17139229f, 0.00830362f, -0.24247912f, -0.09796060f, 0.10141830f, 
    0.19638902f, 0.35299221f, -0.14942819f, 0.22232868f, 0.11390840f, 0.16537550f, 0.16922975f, 0.33686116f, 
    -0.48436722f, 0.38173711f, -0.29975200f, -0.09859877f, -0.35370043f, -0.15236248f, 0.14074056f, 0.28075176f, 
    -0.10196203f, -0.02351120f, -0.48775467f, -0.33428580f, 0.00130533f, -0.02471952f, 0.03894474f, -0.04402558f, 
    -0.28179780f, 0.19614570f, -0.35942897f, 0.32012120f, -0.13277385f, 0.05548199f, 0.05386039f, -0.21601589f, 
    -0.15570292f, 0.09442651f, 0.15716699f, -0.09081439f, 0.19115309f, 0.33068204f, 0.08346224f, 0.37515023f, 
    0.12972803f, 0.44567174f, 0.04472940f, 0.06307820f, -0.04947744f, 0.08065634f, -0.12782873f, 0.16443463f, 
    0.19035423f, -0.15549533f, 0.34045061f, -0.12961479f, 0.10406998f, -0.33223844f, -0.11174610f, -0.37178007f, 
    0.46512410f, 0.23146205f, 0.04119992f, 0.18142073f, 0.00611782f, -0.17225440f, -0.24944364f, 0.08452601f, 
    0.19352342f, -0.01223354f, 0.14000790f, -0.13025159f, 0.09050712f, 0.07717668f, -0.18765479f, -0.03079974f, 
    0.28176191f, 0.09845657f, 0.11873775f, -0.07614062f, 0.03329685f, 0.11734747f, 0.08185913f, 0.13926144f, 
    0.05044704f, -0.04420197f, 0.00969125f, -0.03831508f, -0.02938956f, 0.04526672f, 0.00648672f, -0.00211592f, 
    0.03433941f, 0.04798319f, 0.06886502f, -0.04978670f, -0.03365020f, -0.02915741f, -0.08901245f, 0.04920060f, 
    -0.06153266f, 0.03325271f, -0.05139265f, -0.09082619f, -0.06888258f, -0.04939461f, 0.02327375f, -0.04371872f, 
    0.05892790f, -0.09197830f, 0.01313064f, 0.03016568f, -0.00275559f, -0.02148629f, -0.05763289f, -0.01102536f, 
    -0.07032385f, -0.00076236f, 0.04326028f, 0.00409392f, -0.06868535f, -0.04804562f, -0.02665073f, 0.00874159f, 
    0.05732677f, -0.00197991f, -0.03912280f, -0.06926114f, -0.03298476f, 0.02258753f, -0.04588084f, 0.03180512f, 
    0.02099805f, 0.02047473f, 0.06694848f, 0.06496445f, 0.00376561f, 0.01988774f, 0.03880105f, 0.04137889f, 
    0.01676297f, -0.03903110f, -0.05472918f, -0.09265660f, -0.00460652f, -0.05064955f, -0.05431584f, 0.02407494f, 
    0.04989401f, -0.03616766f, -0.02993898f, 0.01335015f, 0.02001962f, -0.01725444f, 0.06167060f, 0.06189483f, 
    0.03242351f, 0.01345375f, -0.06551423f, -0.05079602f, 0.04906495f, -0.05251184f, -0.03860142f, -0.01787491f, 
    0.00025320f, 0.01254363f, 0.02175592f, 0.01143732f, -0.00352512f, -0.02685799f, -0.05094435f, -0.07595453f, 
    0.05933172f, 0.04172584f, -0.02076413f, 0.02716875f, -0.07873891f, 0.03798551f, -0.03509124f, 0.03913036f, 
    -0.08857109f, 0.00660482f, -0.07010997f, -0.07562657f, 0.06801385f, -0.07047799f, -0.06173277f, -0.06955737f, 
    -0.00061531f, -0.06366687f, -0.06572057f, -0.04432145f, -0.08581460f, -0.05829897f, -0.01505726f, -0.02711845f, 
    -0.04105815f, -0.07961255f, 0.03549933f, -0.09587019f, -0.07811040f, -0.07426189f, 0.02049577f, -0.01000644f, 
    0.06569239f, -0.08422565f, 0.02077990f, 0.03709111f, 0.04470345f, 0.06293291f, 0.06027917f, -0.02271500f, 
    -0.07609814f, 0.06138420f, -0.04502640f, -0.03143648f, 0.05798827f, 0.00865640f, 0.02202259f, -0.06894440f, 
    0.06516013f, 0.06437194f, 0.04580085f, 0.05770868f, -0.01658913f, 0.00220681f, -0.01305186f, 0.03152513f, 
    0.02392447f, -0.10301579f, -0.15918116f, 0.01904916f, 0.01943595f, -0.05122085f, 0.00430637f, 0.13073184f, 
    0.23061131f, 0.35725871f, -0.45684713f, 0.12601434f, 0.09037384f, -0.10244422f, 0.00992638f, 0.13709253f, 
    0.00881907f, -0.13959342f, -0.18174715f, -0.25323054f, 0.43391651f, 0.19044012f, 0.13191900f, -0.08939639f, 
    0.28624180f, 0.07472465f, -0.31244001f, 0.77989227f, -0.57622993f, -0.16438131f, 0.11308390f, -0.14291306f, 
    -0.03720907f, 0.03577393f, 0.14487363f, -0.04787460f, -0.05688357f, 0.06717645f, 0.01619034f, 0.12740436f, 
    -0.16401783f, -0.11278608f, 0.11986316f, 0.11909118f, -0.07163989f, 0.44305333f, 0.24489351f, 0.06976026f, 
    -0.19585812f, -0.03331815f, 0.03879570f, -0.00948801f, -0.16882622f, 0.19946143f, 0.31429723f, -0.50526243f, 
    0.16392003f, -0.23924014f, -0.16446108f, 0.01313022f, 0.13804632f, 0.03901057f, -0.22066191f, 0.60019165f, 
    0.17959082f, 0.23828429f, 0.28372070f, 0.12540574f, -0.14063391f, 0.10582589f, 0.11297867f, 0.02514692f, 
    0.06786494f, -0.32516834f, 0.13478652f, 0.05378110f, 0.12221912f, -0.08409993f, -0.16238675f, 0.18095501f, 
    0.01396503f, -0.14936396f, -0.01222287f, -0.11612594f, 0.13210942f, 0.12865254f, -0.09948378f, 0.09262703f, 
    0.05193133f, -0.02518813f, -0.14284782f, -0.40186337f, -0.04569518f, -0.21761389f, -0.23265390f, -0.09388699f, 
    0.04430512f, 0.14396974f, 0.22125052f, -0.25195906f, -0.27467787f, 0.16806889f, 0.05172914f, -0.07668278f, 
    0.03066724f, -0.09266783f, 0.05433877f, -0.01583820f, -0.30115682f, -0.31763455f, 0.22655275f, -0.21726644f, 
    -0.17201807f, 0.17465873f, 0.08998177f, -0.00368180f, 0.00387300f, 0.08034365f, 0.00758460f, 0.00550188f, 
    -0.27602786f, -0.05255999f, 0.05490823f, -0.01046255f, -0.07803148f, 0.21763164f, -0.32407048f, -0.38704959f, 
    0.16363496f, -0.14580958f, 0.19260059f, 0.41074416f, -0.14800072f, 0.05239830f, -0.15354313f, -0.36875653f, 
    -0.55635703f, -0.06745038f, -0.11861619f, -0.10981230f, 0.13324182f, 0.04003937f, 0.18042804f, -0.12950982f, 
    0.11453059f, 0.45731315f, -0.25036496f, 0.12785135f, 0.38319218f, 0.17145386f, -0.05140460f, -0.18522261f, 
    0.10338905f, -0.47070000f, 0.04979244f, 0.08118264f, -0.14436871f, -0.24263905f, -0.10876049f, -0.05372739f, 
    0.22601378f, 0.06857031f, -0.02155197f, -0.48038211f, -0.25042358f, -0.18623959f, -0.15263693f, 0.10780992f, 
    0.02086756f, -0.06605967f, 0.03584795f, 0.56234550f, -0.36604694f, -0.14322104f, -0.18722713f, -0.24232809f, 
    -0.08800304f, 0.11058026f, 0.05434883f, 0.13729014f, -0.15479510f, 0.02635745f, -0.18681169f, -0.10848779f, 
    0.21385901f, -0.38156563f, -0.22240525f, 0.05299164f, 0.07583454f, 0.19059296f, 0.54671484f, 0.13934670f, 
    0.05599755f, -0.11154824f, -0.02898376f, 0.06517017f, 0.07957755f, -0.00673275f, 0.10603753f, -0.07268023f, 
    0.03166200f, -0.13476805f, -0.06439355f, -0.32924274f, -0.11034960f, 0.01393556f, 0.03403764f, -0.02348116f, 
    -0.61513340f, 0.42473856f, -0.22350433f, -0.04281020f, 0.04042326f, 0.14616483f, 0.03709073f, 0.23864822f, 
    0.22201301f, 0.16799790f, 0.01398610f, -0.14035870f, 0.02651803f, -0.19502403f, 0.00758664f, 0.09032597f, 
    0.22430621f, -0.41583109f, 0.28218818f, -0.30138156f, 0.03499255f, 0.11028611f, 0.21780542f, 0.05853879f, 
    -0.07179023f, -0.11941036f, -0.02168483f, 0.60309124f, -0.05152310f, 0.30972815f, -0.18224862f, 0.27228338f, 
    0.27867454f, -0.00186747f, 0.00106139f, 0.25407955f, -0.19296716f, -0.02273933f, -0.09730789f, -0.07459339f, 
    -0.10699689f, -0.06245289f, 0.04899109f, -0.16198583f, -0.48349085f, 0.13310322f, -0.32765785f, -0.07169025f, 
    0.00600755f, -0.25294620f, -0.09435356f, -0.19884822f, -0.11842466f, -0.49505839f, 0.77156669f, 0.04520876f, 
    0.36548546f, -0.01310073f, 0.02200029f, 0.01719091f, -0.06705320f, 0.07088108f, -0.06943880f, 0.42981684f, 
    0.56868416f, -0.01383698f, 0.13854170f, 0.09034155f, 0.04699376f, -0.01862285f, -0.14489397f, 0.13118193f, 
    0.18724589f, 0.08813833f, 0.02505358f, -0.19633621f, -0.05057388f, -0.00058267f, -0.08336295f, 0.08962148f, 
    -0.70744145f, -0.17344844f, -0.12449914f, 0.09847891f, 0.10355578f, 0.04967887f, 0.01369558f, 0.06456615f, 
    -0.08007608f, 0.63552183f, 0.47063693f, 0.12670614f, -0.21964790f, -0.08273662f, 0.02091778f, 0.01568297f, 
    0.10709389f, -0.07362414f, 0.86426842f, 0.26989815f, -0.00447531f, -0.03192566f, -0.10744070f, 0.16766267f, 
    0.20548922f, -0.09544442f, 0.00428066f, -0.23342359f, 0.02931300f, 0.13953939f, 0.12755923f, -0.13840079f, 
    -0.03025197f, 0.09130472f, 0.01457500f, -0.03269357f, -0.81819278f, 0.14573154f, 0.09551904f, -0.12766565f, 
    0.17085892f, -0.13673265f, 0.08340592f, -0.03562771f, -0.05303652f, -0.07671252f, 0.27077943f, -0.11200722f, 
    0.04784716f, 0.09917002f, -0.10166842f, -0.09431972f, -0.10440480f, -0.19022015f, -0.50199962f, -0.10651504f, 
    -0.11062741f, 0.15628792f, 0.20379819f, 0.04497987f, -0.11947127f, 0.05208760f, 0.14641099f, 0.12912250f, 
    0.01460182f, 0.04200633f, 0.14231747f, -0.09561670f, 0.01237124f, -0.02400986f, 0.04592361f, 0.10512710f, 
    0.15432575f, 0.06213562f, -0.29079163f, 0.13435179f, 0.05224139f, 0.02349852f, -0.04015552f, -0.07740998f, 
    0.04076253f, -0.17421903f, -0.03288453f, -0.11360472f, 0.05828983f, 0.03921475f, -0.01836006f, 0.03218380f, 
    0.02316998f, 0.08938251f, -0.16424352f, -0.05287321f, -0.86417496f, -0.13195346f, -0.07629996f, -0.04176934f, 
    0.12271767f, 0.05247914f, 0.19453399f, 0.38308373f, -0.12157322f, 0.30844948f, -0.01627123f, -0.11628778f, 
    0.02329503f, 0.15951528f, 0.01643309f, -0.11327502f, -0.48896173f, -0.14349011f, -0.12310261f, -0.07341786f, 
    -0.02832176f, -0.12354884f, 0.06869046f, -0.14010149f, 0.02329970f, 0.22144344f, -0.07450851f, -0.07795173f, 
    -0.10004921f, 0.04667021f, -0.05539652f, 0.12122206f, 0.15035744f, -0.23979338f, -0.21639319f, 0.02327629f, 
    0.19462936f, -0.13082823f, 0.17238285f, 0.12738580f, 0.08224285f, -0.01654601f, 0.03933495f, 0.69703269f, 
    0.06726053f, 0.00400955f, -0.23423913f, -0.07863633f, -0.25931025f, -0.12287015f, -0.05227615f, -0.01805903f, 
    -0.04250425f, -0.07463070f, -0.06210741f, -0.08308020f, -0.02100816f, 0.06206286f, 0.00476269f, -0.07727347f, 
    0.06428225f, 0.00996091f, -0.08070914f, 0.07206233f, 0.01273385f, -0.04825312f, -0.02421109f, 0.02509857f, 
    0.00804105f, 0.02719506f, -0.07509270f, -0.06630724f, 0.02222064f, 0.00806590f, -0.03763787f, -0.08173177f, 
    -0.00605123f, -0.06559850f, -0.04611769f, -0.07980945f, -0.05532825f, -0.04025717f, 0.03974385f, -0.05465220f, 
    0.00147070f, -0.06690817f, 0.04998491f, -0.02926970f, -0.09078722f, -0.04187844f, -0.05369631f, -0.01914720f, 
    0.00754519f, -0.00142215f, 0.00111560f, 0.02577999f, 0.06151359f, -0.02648133f, -0.05956605f, -0.09113206f, 
    0.04668060f, -0.07388155f, 0.05615539f, 0.05549130f, 0.00721383f, -0.08520694f, -0.00277893f, 0.06054300f, 
    -0.04496748f, -0.01190110f, -0.05127645f, -0.04689594f, -0.03311231f, -0.09105153f, -0.02589112f, 0.03480750f, 
    -0.05769546f, -0.07039071f, 0.06499935f, -0.09450988f, -0.01290826f, -0.00437770f, 0.03403076f, 0.05211596f, 
    0.04214912f, 0.00339871f, -0.02719482f, 0.02785779f, 0.02261411f, -0.06721015f, 0.00283570f, 0.06729268f, 
    -0.04928638f, 0.01741550f, 0.03002971f, -0.03181266f, -0.00892500f, -0.05656821f, -0.06020629f, -0.06028858f, 
    -0.08888122f, -0.02973693f, 0.04552642f, 0.06489752f, -0.02584996f, -0.06388421f, -0.04323452f, 0.02443282f, 
    -0.08787445f, -0.05117282f, 0.07577170f, -0.06813925f, -0.03202294f, -0.05666435f, 0.01413836f, 0.03455309f, 
    0.02822769f, -0.01805400f, 0.04798374f, 0.02035499f, -0.02948891f, -0.08135875f, 0.03539762f, 0.00633478f, 
    -0.08523697f, -0.00078725f, 0.01925834f, 0.05246986f, -0.05961201f, 0.06767216f, 0.00551248f, 0.04961262f, 
    -0.00814805f, -0.05578015f, 0.07247974f, -0.01842149f, 0.06766991f, -0.02027296f, -0.00879248f, -0.04349507f, 
    0.06439070f, 0.04851950f, 0.03585168f, 0.02940422f, -0.05606824f, -0.08489061f, 0.05834633f, -0.07924316f, 
    -0.02752878f, 0.01517344f, -0.01762404f, 0.03491180f, -0.06147698f, -0.05922350f, -0.01380167f, 0.06723377f, 
    -0.00466588f, -0.01406634f, 0.01842415f, -0.01593589f, -0.01257099f, -0.01594546f, -0.09924413f, -0.03947502f, 
    0.02522514f, 0.02127752f, -0.06181185f, -0.00815678f, 0.05208352f, 0.01235265f, -0.04305282f, -0.03811873f, 
    -0.08959430f, -0.00611849f, 0.00839344f, 0.00653118f, 0.03617305f, -0.02644711f, -0.01395248f, 0.01195706f, 
    -0.04356704f, 0.05337778f, -0.00376696f, -0.00153024f, 0.04009536f, -0.02443384f, 0.04305853f, -0.10352327f, 
    -0.06388038f, 0.02441955f, 0.06691420f, -0.05116932f, -0.10333115f, -0.01104305f, -0.03893733f, -0.06208603f, 
    -0.07450233f, -0.06480464f, 0.04961980f, -0.05808039f, -0.00791709f, -0.06657013f, 0.03877232f, -0.01246936f, 
    0.01615142f, 0.01635838f, -0.08061838f, -0.08351753f, 0.05777368f, -0.08129239f, -0.03568040f, -0.04991153f, 
    -0.00486540f, 0.04502302f, 0.01244141f, -0.07908922f, -0.04971456f, -0.03006955f, -0.09512845f, 0.02548231f, 
    0.05066294f, -0.00474259f, 0.01619037f, -0.00702133f, 0.04022225f, -0.05915510f, -0.05752738f, 0.04869885f, 
    0.04804328f, 0.02944962f, -0.06854162f, -0.06402329f, -0.01172023f, 0.04995623f, -0.00718572f, -0.01515138f, 
    -0.06387579f, -0.10420409f, -0.05057525f, 0.04067240f, 0.03874555f, -0.04156331f, 0.03221464f, -0.07363205f, 
    -0.07833655f, -0.01198530f, -0.10102171f, 0.01458345f, 0.01692845f, 0.01142169f, 0.06023896f, -0.04836452f, 
    -0.04743002f, -0.04597286f, -0.05284330f, -0.08045045f, 0.03864190f, -0.02766464f, -0.08584984f, 0.02394668f, 
    0.00288743f, -0.00368744f, 0.00903454f, -0.10499010f, -0.07802391f, -0.05953043f, -0.03554586f, -0.02446778f, 
    -0.02501649f, -0.06413785f, -0.06112240f, 0.01210082f, -0.10402430f, 0.05040876f, -0.00650843f, 0.01772397f, 
    -0.07815826f, 0.01505703f, 0.04715414f, -0.07877509f, -0.05628170f, 0.00230004f, -0.09534555f, -0.08775334f, 
    -0.00198782f, -0.00109511f, 0.01938017f, -0.10229392f, 0.02633005f, 0.05934583f, -0.08265341f, 0.05671795f, 
    -0.00458290f, -0.05136915f, -0.01705665f, 0.05103097f, 0.01953113f, -0.00895335f, -0.08770803f, -0.02950665f, 
    0.07341940f, 0.38760176f, 0.19667877f, 0.03654099f, 0.22716586f, 0.25688124f, 0.10013976f, -0.33311033f, 
    0.16533366f, -0.11788779f, 0.45734462f, -0.01517816f, -0.02517704f, -0.13456063f, 0.12629685f, 0.10332721f, 
    -0.03670266f, -0.18561989f, -0.29973134f, -0.31647214f, -0.12062305f, -0.10104764f, 0.02785972f, -0.14634895f, 
    -0.05481450f, 0.10350970f, -0.13241760f, 0.60348207f, 0.11309952f, 0.30595347f, -0.35546631f, 0.05430968f, 
    0.02499300f, 0.04810827f, -0.06841815f, 0.17545001f, 0.27792200f, -0.09538501f, -0.21206279f, -0.21635440f, 
    0.04513830f, 0.07280763f, -0.00408350f, -0.07636447f, 0.00033355f, -0.10224909f, 0.14650272f, 0.18960743f, 
    0.04235482f, 0.03865336f, 0.09632762f, 0.05689692f, 0.06325942f, 0.27802914f, -0.14119735f, 0.39573032f, 
    0.23585103f, -0.21858132f, -0.07537111f, 0.14862391f, -0.20749381f, 0.19999146f, -0.19112644f, 0.28601480f, 
    -0.00792270f, -0.26633370f, 0.02861730f, 0.02029764f, -0.29647249f, 0.07140606f, -0.07498700f, 0.10914218f, 
    -0.06488700f, 0.30992541f, -0.20164923f, 0.35261223f, 0.12241501f, 0.17507802f, 0.11190662f, -0.15663663f, 
    -0.30818206f, -0.12668343f, -0.14220969f, -0.08723509f, 0.11303679f, 0.31352004f, -0.16165043f, 0.18188170f, 
    -0.14558986f, -0.60688663f, -0.33742699f, -0.20273171f, 0.41644722f, 0.04094740f, 0.05856499f, 0.39469826f, 
    -0.07346794f, -0.18614323f, 0.19497028f, 0.00015569f, -0.14276163f, -0.23061118f, -0.14416945f, 0.24008016f, 
    0.12988012f, 0.11093432f, -0.27191338f, -0.42047587f, 0.15159827f, 0.17354986f, 0.08957328f, 0.02549425f, 
    -0.05818370f, 0.13888626f, 0.10763268f, 0.04693043f, -0.06909975f, -0.24390373f, -0.34817913f, 0.09462165f, 
    0.09294326f, 0.09486157f, -0.13530995f, -0.12109421f, -0.13003856f, 0.23206057f, -0.48264983f, -0.19079009f, 
    -0.02552650f, 0.45557383f, -0.01294075f, 0.35242581f, -0.30963415f, 0.01684424f, -0.44875911f, -0.10471204f, 
    0.23807807f, 0.11129979f, -0.06897677f, 0.24648747f, -0.02690651f, -0.15287302f, 0.09216686f, 0.01715438f, 
    0.54357535f, 0.19858059f, 0.35482684f, 0.12358506f, 0.31667033f, -0.04512287f, 0.03617835f, 0.18838426f, 
    0.19391371f, -0.94042313f, -0.45194614f, 0.09691963f, 0.06902548f, 0.19722383f, 0.23782742f, -0.11339669f, 
    -0.10009532f, 0.08142065f, 0.23016463f, -0.40269080f, -0.25387350f, -0.10347815f, -0.08426718f, -0.02825479f, 
    -0.13620192f, 0.16014005f, 0.17180327f, 0.88758564f, -0.20678172f, -0.11020342f, -0.06493061f, 0.23107284f, 
    -0.11378706f, 0.08567880f, 0.01792893f, -0.21340269f, 0.00259749f, -0.16393286f, 0.26429471f, -0.03649955f, 
    -0.11375664f, 0.10621718f, -0.07993064f, 0.07741266f, 0.10564837f, 0.16738957f, 0.13451427f, 0.05162790f, 
    0.28388739f, -0.01218248f, -0.15311001f, 0.17788254f, 0.24224569f, -0.09557553f, 0.04538860f, 0.09141372f, 
    -0.67720318f, 0.08969614f, 0.14803416f, -0.14976421f, 0.05200392f, 0.28677413f, 0.09858431f, 0.15606315f, 
    -0.12134083f, 0.37595710f, -0.11497484f, 0.02952325f, 0.18150584f, -0.24530008f, -0.07165620f, 0.01734081f, 
    0.13704938f, 0.18566263f, -0.29239619f, -0.38887286f, -0.23303266f, -0.36423334f, 0.15773028f, 0.17088936f, 
    0.09685896f, -0.10094165f, -0.03702985f, -0.06264799f, -0.06542417f, 0.03198667f, -0.11797561f, 0.27542108f, 
    0.24729472f, -0.03955479f, 0.50036067f, 0.46959800f, 0.22038049f, -0.11482191f, 0.08665160f, -0.22533168f, 
    -0.27050871f, 0.36011061f, 0.03477104f, -0.96852916f, -0.96077991f, -0.08391840f, 0.05340685f, 0.14049289f, 
    0.30120608f, -0.06417423f, -0.05927395f, 0.00109953f, 0.48623422f, 0.06986235f, -0.15563439f, -0.05276890f, 
    0.00645061f, 0.21517676f, -0.14201224f, -0.07855342f, -0.18356237f, -0.39246362f, 0.12881176f, -0.01667691f, 
    0.14243917f, -0.16972068f, -0.14558588f, -0.08207246f, -0.18238695f, -0.13936083f, -0.37311849f, 0.08079760f, 
    -0.34296900f, 0.03553001f, -0.02835580f, -0.09650721f, 0.32488841f, 0.03030927f, 0.14861858f, -0.87221479f, 
    -0.35040537f, -0.07141273f, -0.13431561f, 0.01578193f, -0.10264652f, 0.01293926f, 0.30070239f, 0.09718978f, 
    0.01281387f, -0.04139343f, 0.00740202f, -0.02635684f, -0.02818270f, 0.04688234f, 0.04653929f, -0.05635683f, 
    -0.05618724f, 0.01403973f, -0.07795966f, -0.04558589f, -0.04040914f, 0.01930963f, -0.02710799f, 0.00223824f, 
    0.04851669f, 0.02905014f, -0.00870757f, 0.04492122f, -0.00730160f, -0.05107479f, -0.08120792f, -0.03842587f, 
    0.01513740f, -0.04873567f, -0.08725704f, -0.07992627f, 0.01207993f, -0.04703686f, -0.01766823f, -0.07272825f, 
    -0.05727449f, 0.00740932f, 0.03463526f, 0.01129847f, 0.05236277f, -0.02408900f, -0.07873756f, 0.05832268f, 
    -0.07035531f, 0.01120281f, -0.08751242f, -0.08769549f, -0.00814334f, -0.05009628f, -0.09050653f, -0.08671020f, 
    0.06356549f, 0.05769464f, 0.03340286f, 0.05328943f, -0.05583142f, 0.00719851f, 0.04366534f, -0.04385179f, 
    -0.06282546f, 0.00273171f, -0.03939334f, -0.02199078f, 0.04731464f, 0.03129638f, 0.05560096f, -0.00446654f, 
    -0.02178917f, 0.06763313f, 0.02844494f, 0.00307242f, 0.02815394f, -0.08834209f, -0.04247098f, 0.05940957f, 
    -0.08933032f, -0.01454841f, -0.04007278f, 0.01720461f, -0.04229873f, -0.00260986f, -0.00867264f, -0.01058269f, 
    -0.06340566f, 0.05451391f, 0.00409120f, 0.05845285f, -0.04718973f, 0.06306037f, 0.00427937f, 0.05125906f, 
    -0.02474290f, 0.03479216f, 0.04490767f, -0.04750963f, -0.05154607f, -0.09760752f, -0.01268718f, -0.05702075f, 
    -0.03973397f, -0.07515307f, -0.02658532f, 0.02229607f, -0.04755589f, -0.08843515f, 0.04364518f, 0.01412943f, 
    -0.02763608f, -0.08725382f, 0.03767932f, 0.02389184f, -0.01346521f, 0.04195442f, 0.04896047f, 0.01091023f, 
    -0.05241375f, -0.03232963f, -0.09166986f, -0.07137128f, -0.01466754f, 0.02807787f, 0.04384714f, 0.00239376f, 
    0.03062635f, -0.01232604f, -0.06814396f, 0.04907147f, 0.04774738f, 0.00957613f, 0.01215092f, 0.05845105f, 
    -0.09158432f, 0.04140316f, 0.01722362f, -0.00151394f, 0.04577756f, -0.01702598f, -0.04877723f, -0.08705102f, 
    -0.09577262f, 0.04442001f, -0.03558609f, -0.01018333f, 0.06833174f, 0.00190304f, 0.00412014f, 0.04537256f, 
    -0.09216950f, -0.05747110f, -0.04463161f, 0.01444514f, -0.06997880f, -0.01402038f, -0.07252144f, -0.07145584f, 
    -0.05859524f, -0.07233297f, 0.05153612f, 0.06475459f, 0.07294020f, 0.02621447f, -0.07009652f, 0.06201014f, 
    0.07355212f, 0.04477151f, -0.03178258f, -0.08443028f, 0.02161511f, -0.03663659f, -0.08628062f, -0.04441895f, 
    0.03431084f, -0.02285663f, -0.00468836f, 0.06173844f, -0.05150153f, -0.01412732f, -0.04234211f, 0.01628490f, 
    -0.06636787f, 0.05844063f, -0.04601254f, -0.02276901f, -0.08368600f, 0.05836517f, 0.04101508f, 0.01974850f, 
    -0.06934126f, 0.01605549f, 0.04359681f, 0.00989821f, 0.02928654f, 0.06419647f, -0.04889584f, -0.03291272f, 
    -0.08257668f, 0.04346284f, -0.00316457f, 0.06651324f, 0.03317731f, 0.02875111f, -0.06414699f, -0.01999952f, 
    -0.01158184f, 0.06249884f, 0.04972539f, 0.06449937f, -0.05163046f, -0.06847417f, 0.03281529f, 0.04750487f, 
    -0.03210391f, -0.05020645f, -0.05546292f, 0.02205586f, -0.08292393f, 0.01349703f, -0.04112688f, 0.04526412f, 
    -0.05260583f, -0.02880458f, 0.00265030f, 0.04801722f, 0.00270622f, -0.06987491f, -0.04782398f, -0.00456956f, 
    0.03503675f, -0.04577702f, -0.06772559f, -0.03700501f, 0.05803987f, 0.00327856f, 0.02646697f, -0.00138845f, 
    -0.00928446f, -0.04823226f, 0.01386792f, 0.05248742f, 0.04610176f, 0.06154725f, 0.03822786f, 0.03236666f, 
    0.07352404f, 0.06807566f, 0.00087597f, 0.00361268f, -0.03436982f, -0.06438677f, -0.06600341f, 0.02669155f, 
    -0.08028439f, 0.06057723f, 0.04738769f, -0.07583302f, -0.07897855f, -0.05130222f, -0.05138799f, -0.00849062f, 
    0.05048879f, 0.05467471f, -0.00588875f, -0.02486155f, -0.06619936f, -0.00680337f, -0.04771380f, 0.01971502f, 
    -0.06625821f, 0.06978547f, -0.08809388f, -0.05205699f, -0.02374270f, 0.02012033f, -0.05364837f, -0.05770113f, 
    -0.07635643f, -0.00795920f, 0.00627570f, 0.00837033f, -0.07618877f, -0.06977981f, -0.07803539f, -0.02467504f, 
    -0.04864019f, -0.03189686f, -0.05790874f, 0.02581419f, 0.01440582f, -0.08603175f, 0.06762590f, -0.05509783f, 
    -0.10403690f, 0.02611271f, 0.25937298f, -0.49321005f, 0.07131656f, -0.06377333f, -0.06982937f, -0.25220630f, 
    0.16395162f, -0.06375080f, 0.20553526f, -0.34810328f, 0.34435409f, 0.39358681f, 0.06490708f, -0.07398761f, 
    -0.18178453f, 0.00258732f, 0.09869385f, 0.30066398f, 0.01131669f, 0.30156365f, -0.01726564f, 0.05305044f, 
    0.32680774f, -0.05129225f, -0.36357340f, -0.05330650f, -0.09540027f, -0.82080775f, -0.02151109f, -0.41124797f, 
    -0.08253161f, -0.08360144f, -0.14047605f, 0.13493153f, -0.06164173f, 0.02347603f, -0.10852814f, 0.01876982f, 
    -0.16161959f, 0.01403999f, 0.13056883f, 0.08646823f, 0.00048805f, -0.53496760f, 0.04938498f, 0.30467108f, 
    -0.36465326f, -0.06109024f, -0.05017948f, 0.11512953f, 0.12290042f, 0.13791612f, 0.64527953f, 0.28477073f, 
    0.74512112f, -0.11370362f, -0.13810232f, -0.01237117f, -0.09863412f, -0.03569923f, -0.04120932f, 0.01959775f, 
    0.26867825f, -0.42298827f, 0.20236878f, -0.13961354f, -0.17901778f, 0.04328234f, 0.17397928f, 0.07204816f, 
    0.10959502f, 0.26017967f, -0.08811363f, -0.27820086f, -0.13352595f, -0.04592135f, -0.07709011f, 0.08064716f, 
    -0.08664422f, 0.16599183f, -0.15964012f, 0.07118127f, -0.28594366f, 0.10267792f, 0.04803819f, -0.23742464f, 
    0.02876028f, 0.10703003f, -0.13242894f, -0.29005489f, 0.56885052f, -0.08992355f, 0.14921136f, -0.19025624f, 
    -0.03219557f, 0.06831074f, 0.03527571f, 0.08305433f, -0.00495248f, 0.01601422f, 0.19737105f, 0.33256465f, 
    -0.11853397f, -0.02742472f, -0.14985095f, -0.09346408f, -0.12244165f, -0.13049942f, 0.09464152f, 0.05293329f, 
    -0.23514691f, -0.25529814f, -0.00779500f, 0.08932934f, 0.13003764f, -0.13226272f, -0.12276158f, 0.26318023f, 
    0.28189033f, 0.17244278f, -0.27015698f, -0.01071192f, 0.06349469f, 0.09191744f, 0.21675104f, -0.04428326f, 
    -0.09177898f, 0.05427709f, 0.01729210f, 0.21494216f, 0.13790427f, 0.12892599f, 0.18117121f, -0.41481027f, 
    -0.16341107f, 0.19441414f, 0.38137257f, -0.16858099f, 0.08358198f, -0.00017976f, -0.02922444f, 0.03756874f, 
    0.04314042f, 0.39269018f, -0.16986957f, 0.21067002f, 0.16255350f, 0.06725626f, -0.31642297f, -0.13350429f, 
    0.06974006f, -0.09607523f, -0.17964132f, 0.24510531f, 0.05668150f, 0.27502674f, 0.06917811f, -0.22480470f, 
    0.01989561f, -0.03161094f, 0.29141152f, 0.43454769f, 0.17763935f, -0.10350350f, -0.20126717f, 0.02699379f, 
    -0.04623572f, -0.16098359f, 0.06839229f, -0.21678920f, -0.69732779f, 0.15450671f, -0.11264031f, -0.11929488f, 
    -0.17248362f, 0.03869293f, -0.20174673f, -0.11473692f, 0.80307591f, 0.13100615f, -0.37008297f, 0.01675491f, 
    0.17305744f, 0.12348147f, 0.08606438f, 0.18126045f, 0.12385657f, 0.37064090f, -0.09903572f, -0.32587758f, 
    0.13861275f, 0.00469484f, 0.08064575f, 0.07025892f, -0.07276338f, -0.26976496f, 0.48870519f, -0.01941192f, 
    -0.37895972f, 0.30493146f, 0.03181497f, -0.14793883f, 0.33804318f, 0.16169684f, 0.11016236f, 0.07162248f, 
    0.19231567f, -0.01099727f, 0.06162893f, 0.11666311f, 0.18893248f, -0.12964539f, 0.21444401f, 0.23875926f, 
    0.02707329f, -0.34840801f, -0.23989026f, -0.03707200f, 0.07988700f, 0.00607638f, 0.38882858f, -0.01563564f, 
    -0.04099479f, -0.73927414f, -0.18825372f, -0.36572710f, 0.16101702f, 0.06974604f, -0.08643933f, -0.04086015f, 
    -0.14900000f, 0.10679606f, 0.10834408f, 0.04581106f, -0.61041534f, -0.21314885f, 0.32116383f, -0.15522102f, 
    0.00404007f, 0.09748007f, -0.04559217f, 0.30259761f, 0.36946550f, 0.19084677f, -0.17085631f, 0.19276056f, 
    0.05103523f, -0.06122509f, 0.21819308f, 0.06690951f, -0.60363221f, -0.38717759f, -0.13446039f, 0.13327219f, 
    0.22318996f, -0.30200624f, 0.13602605f, 0.06127241f, -0.00368868f, -0.67023486f, 0.06559151f, -0.10844401f, 
    -0.22037266f, 0.05916430f, 0.15949401f, 0.01953342f, 0.11184125f, -0.14110596f, -0.19971487f, 0.34855658f, 
    0.14992225f, 0.03801692f, 0.27149230f, 0.08622044f, 0.10071148f, 0.16996339f, -0.05471657f, -0.18163924f, 
    0.19219528f, -0.00086394f, 0.17921281f, 0.12446854f, -0.11538368f, 0.06505814f, 0.11187096f, 0.08962084f, 
    -0.09904788f, -0.05931987f, 0.03493620f, -0.02877239f, 0.11310467f, -0.15166362f, 0.19995435f, -0.02041642f, 
    -0.05218880f, 0.70434511f, -0.02628895f, 0.08105698f, -0.14240676f, 0.15119483f, 0.26361814f, 0.19832489f, 
    -0.01083793f, 0.13296290f, 0.51813197f, -0.02028999f, -0.01936189f, 0.21244422f, -0.20322648f, 0.16009893f, 
    0.24541551f, 0.08852660f, -0.04549186f, -0.31496990f, -0.17809430f, 0.09200737f, -0.04653903f, 0.08006375f, 
    -0.12900443f, -0.07972605f, 0.01889666f, -0.09052189f, -0.47646064f, -0.00129289f, -0.28174987f, 0.07873981f, 
    -0.06974731f, 0.22904401f, -0.23602335f, 0.00702629f, -0.15178601f, -0.30472934f, 0.14439914f, -0.00707913f, 
    -0.18548091f, 0.00868850f, -0.03468443f, -0.10642628f, 0.08346368f, -0.07261974f, -0.38310605f, -0.50902653f, 
    -0.26120982f, 0.21874042f, 0.06415619f, -0.01692601f, -0.23225872f, -0.22876783f, -0.10463811f, 0.64531898f, 
    0.13415317f, 0.14590591f, 0.06487264f, -0.06887152f, 0.09303056f, -0.07149520f, 0.13346069f, 0.13313875f, 
    -0.39818749f, 0.03844641f, -0.43412063f, -0.03758339f, -0.32263434f, -0.04105773f, -0.04697447f, 0.48057118f, 
    -0.11608621f, -0.37052846f, 0.14430645f, 0.05738556f, 0.16411375f, 0.07941513f, -0.06463444f, 0.08807669f, 
    0.06168383f, 0.09774593f, 0.40640515f, 0.18555850f, 0.16308820f, -0.32825881f, 0.12841044f, 0.04687590f, 
    -0.03200098f, 0.04244065f, -0.02845826f, 0.10086940f, -0.40480036f, -0.07719118f, 0.26993614f, 0.21028863f, 
    0.01580679f, 0.07025439f, 0.02352590f, 0.02713703f, 0.38326308f, -0.19987683f, -0.28838632f, 0.10840817f, 
    0.21612160f, -0.15744935f, 0.16451727f, -0.12110910f, -0.16149992f, -0.18071185f, 0.17476454f, -0.28056565f, 
    -0.15141584f, 0.13341890f, 0.08010836f, -0.07875658f, 0.10533112f, 0.06389773f, -0.13844082f, -0.47206178f, 
    -0.06557189f, 0.15127875f, 0.30559129f, 0.15542495f, 0.11772720f, 0.16486453f, 0.03879709f, -0.21084461f, 
    0.10455391f, 0.10950852f, 0.38675913f, 0.16544549f, -0.00705075f, -0.08957955f, -0.00017930f, 0.08769873f, 
    0.44330254f, 0.22611862f, 0.17807044f, 0.33428282f, -0.03236056f, 0.10954545f, 0.16995102f, -0.04087632f, 
    0.07789173f, 0.06334861f, 0.11351703f, -0.11532554f, -0.04120933f, 0.19896565f, 0.15156725f, -0.21967950f, 
    0.02072601f, -0.11202247f, -0.71736026f, 0.18087268f, -0.31119987f, 0.01316126f, 0.08690066f, 0.08646059f, 
    0.02420264f, -0.07139746f, 0.09762107f, -0.15589212f, -0.41611907f, -0.60430741f, -0.08391985f, 0.00641124f, 
    -0.22767687f, -0.02337604f, -0.02345254f, -0.03332583f, -0.55749208f, 0.06214349f, 0.03193923f, 0.06216811f, 
    0.06595921f, -0.04214020f, 0.03634425f, 0.09443479f, 0.13174072f, 0.57047403f, 0.33695167f, -0.37847522f, 
    0.00879766f, 0.19920653f, 0.03242036f, 0.08119663f, -0.08096587f, -0.06430624f, 0.15379411f, -0.53683674f, 
    -0.03350405f, 0.04989222f, -0.18122990f, 0.03201200f, 0.09717980f, -0.09369819f, -0.17498744f, -0.26860338f, 
    0.09148229f, -0.18549722f, -0.04832909f, -0.10728034f, 0.22881320f, -0.33763367f, 0.05845910f, 0.00603642f, 
    -0.14672606f, -0.27393356f, 0.16827668f, 0.03794551f, 0.20843089f, 0.24100535f, 0.07412110f, -0.02622667f, 
    -0.07882053f, 0.76970661f, -0.07586956f, -0.42815000f, 0.17296304f, -0.27092537f, -0.08606501f, -0.12869576f, 
    -0.09698950f, 0.12648380f, 0.06317738f, 0.18738146f, 0.52848059f, 0.33056980f, -0.02829365f, -0.22001794f, 
    0.10472697f, 0.08571001f, 0.22574364f, -0.07231604f, 0.01816159f, -0.16472791f, 0.10468026f, 0.18680698f, 
    -0.04567370f, -0.00498370f, 0.10202068f, 0.11813407f, -0.61188275f, -0.39859980f, -0.13188593f, -0.05532978f, 
    0.25003323f, -0.24711394f, -0.10022533f, 0.14461316f, -0.10483030f, 0.55704993f, -0.06990653f, 0.10865862f, 
    -0.14194427f, 0.00569168f, 0.02093751f, 0.07800097f, 0.20378515f, 0.08371366f, -0.22414149f, -0.00455983f, 
    0.48064914f, 0.02442550f, -0.19212598f, -0.30297333f, -0.13862216f, 0.18584456f, 0.16878299f, 0.35841435f, 
    0.58950913f, 0.29193830f, -0.00394091f, -0.18893139f, -0.05886843f, -0.00070702f, 0.16402847f, 0.22240196f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.19388860f, 0.44000033f, 0.05725474f, 0.13601638f, -0.23549688f, -0.30418953f, 0.05749668f, -0.04213080f, 
    0.12107603f, -0.09170662f, 0.00913396f, -0.05372800f, -0.07419590f, 0.33170038f, -0.04244566f, -0.13304847f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11014629f, -0.22395410f, -0.13603272f, 0.45495477f, 0.54835761f, 0.07563055f, -0.04115518f, 0.15285772f, 
    0.15942591f, -0.30621973f, 0.24193905f, 0.07585790f, -0.39461762f, 0.44110608f, -0.63932371f, -0.04872077f, 
    0.06479228f, 0.11960471f, -0.17715146f, 0.13580172f, -0.11913413f, 0.01987169f, 0.23156588f, -0.19509880f, 
    -0.49646437f, -0.33606386f, -0.13564359f, -0.20653406f, -0.49341539f, 0.18926314f, -0.35404071f, 0.66748643f, 
    -0.40079376f, -0.45958459f, 0.02214357f, 0.29247814f, -1.07678390f, 0.40983832f, 0.17072763f, -0.07819711f, 
    0.11668134f, -0.73577523f, 0.18374661f, -0.03168219f, 0.50947052f, -0.34332782f, -0.20755737f, 1.02926457f, 
    -0.60599196f, -0.32320598f, -0.11662195f, 0.67560434f, -0.15079919f, -0.25244915f, -0.01274831f, 0.10289823f, 
    0.42048109f, 0.46286592f, 0.16066349f, -0.05402886f, 0.29865846f, -0.12780602f, 0.19294676f, -0.45479932f, 
    0.19134502f, 0.79033947f, -0.11671937f, 0.01100155f, -0.21397844f, -0.48783520f, -0.22723828f, -0.21847707f, 
    0.51100624f, -0.27926841f, 0.22061621f, -0.12099970f, 0.29201129f, -0.45978531f, -0.17453228f, -0.25998729f, 
    0.06909666f, 0.57999605f, 0.16941173f, -0.65980464f, -0.11332707f, -0.25461072f, 0.01632837f, 0.20990634f, 
    -0.30569142f, -0.06283432f, -0.06601743f, -0.22202477f, -0.60204566f, 0.34607372f, 0.13995603f, -0.02077117f, 
    -0.35567123f, 0.44746795f, 0.23614447f, 0.20366107f, -0.08164266f, 0.71606964f, -0.02640999f, 0.01161200f, 
    0.12683627f, -0.46292689f, 0.05509698f, -0.24792936f, -0.49252108f, -0.04527134f, 0.27069813f, -0.58769989f, 
    0.35329443f, -0.39976382f, -0.13881977f, -0.83596182f, 0.45334056f, -0.23598315f, -0.19492947f, -0.01032311f, 
    0.27018464f, 0.55817193f, -0.18656091f, -0.14640680f, 0.18679400f, -0.46690977f, -0.78422636f, 0.40720308f, 
    0.49504143f, -0.17601697f, 0.08393087f, -0.21463238f, 0.76370865f, 0.23660235f, -0.17870525f, 0.24393129f, 
    -0.92330873f, -0.39863440f, -0.07243607f, 0.18008797f, 0.66253227f, -0.16836204f, -0.07437810f, -0.50949806f, 
    0.21259747f, 0.06137498f, -0.00774723f, -0.16852412f, -0.46643478f, -0.84670883f, 0.04929497f, 0.17387028f, 
    0.27979824f, -0.28643668f, -0.05986700f, 0.08935580f, 0.34014565f, 0.86508030f, -0.51102442f, -0.62644178f, 
    0.25542390f, -0.48037642f, -0.16275777f, 0.00830576f, -1.02244627f, -0.10281058f, -0.03169104f, -0.12980263f, 
    -0.35899913f, 0.52137774f, -0.06922344f, 0.17449388f, 0.37114897f, -0.13299045f, 0.24229389f, 0.06955706f, 
    -0.68524128f, -0.35596523f, -0.16698875f, 0.49174681f, -0.20132573f, -0.12698779f, -0.22589503f, -0.22136107f, 
    0.20909403f, -0.19925688f, 0.12804213f, -0.05320377f, 0.12551630f, -0.08759151f, 1.16889000f, -0.19995774f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22387746f, 0.21424060f, -0.10561743f, -0.00362786f, 0.52069962f, 0.30605900f, -0.19857797f, -0.58155781f, 
    -0.63086563f, 0.07575613f, 0.63547617f, -0.16078779f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
