#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.71668124f, 0.19822477f, -0.59320104f, -0.95773131f, -0.94611365f, 0.62442362f, 0.41131076f, -0.37468553f, 
    0.36851943f, 0.81539702f, -0.18367627f, -0.22650911f, -0.03294031f, -0.28581852f, -0.08182462f, 0.06538230f, 
    0.42639461f, 0.26829708f, -0.04387755f, 0.23097733f, 0.06597145f, -0.36059612f, 0.15594728f, -0.25548154f, 
    0.48373991f, -0.80828142f, -1.30251586f, 0.15725608f, -0.05348888f, -0.44873285f, 0.63992339f, 0.34868464f, 
    0.73017919f, -0.23616067f, -0.54922348f, -0.43783513f, 0.26581901f, -0.04750393f, 0.13201128f, -0.01953868f, 
    -0.11371042f, 0.10525939f, -0.13233225f, -0.21483168f, 0.17225456f, -0.11272555f, -0.22112869f, 0.37452024f, 
    0.36401498f, 0.04380406f, 0.76164931f, -1.35473347f, -1.21593380f, 0.73300719f, 0.05649273f, -1.08042836f, 
    0.66859353f, 0.21128693f, -0.31200811f, 0.14438784f, 0.38279882f, 0.65779966f, -0.08483440f, 0.02446814f, 
    0.38494962f, 0.06231186f, 0.23011826f, -0.09102115f, -0.20904563f, -0.11203744f, 0.25136817f, 0.04430150f, 
    -0.03449975f, 0.25647318f, 0.20279500f, -1.38141990f, 0.02592676f, 0.59407908f, -0.07067469f, -0.15229931f, 
    1.02302957f, 1.06201470f, 0.33602193f, 0.14503913f, 0.30365232f, -0.43503973f, -0.50493234f, -0.25714514f, 
    -0.31982130f, 0.07430916f, -0.22344147f, -0.19564290f, -0.28239286f, -0.00419138f, -0.29901442f, -0.16505697f, 
    -0.12660709f, -0.07038224f, 0.01541823f, 0.03513725f, 1.12609649f, 0.72149330f, 0.66070366f, 1.43934095f, 
    0.76342267f, 0.76704693f, 0.24178168f, -0.26490882f, -0.33902201f, -0.62135470f, 0.07312453f, 0.39388183f, 
    -0.12232003f, 0.07464641f, -0.24800391f, 0.01306023f, 0.19490676f, 0.37602475f, 0.02146512f, 0.02438761f, 
    0.03002434f, -0.02790102f, -0.19665289f, -0.08607426f, 0.13891029f, 1.11830759f, -0.00751354f, 0.66983664f, 
    0.28351918f, -0.34428629f, 0.91496086f, -0.19152115f, -0.22167568f, 0.25961998f, -0.16374217f, 0.47705451f, 
    -0.00236452f, -0.47949737f, 0.12260512f, -0.52382970f, 0.53080165f, -0.31666973f, -0.11550730f, -0.17775641f, 
    0.36219898f, -0.06930541f, -0.27934563f, 0.21322758f, -0.28164908f, 0.42789692f, -0.00086761f, -0.12207753f, 
    -1.42914569f, -0.67043757f, 0.62458909f, 0.05568205f, -0.63216245f, 0.53715557f, 0.32170221f, 0.57008272f, 
    -0.67385864f, -0.30338979f, -0.10655939f, -0.43928272f, -0.68862551f, 0.00408325f, -0.19587505f, -0.08022919f, 
    0.04638692f, -0.10285652f, -0.15507016f, 0.25244880f, -0.35621104f, 0.27898324f, -0.17443915f, 0.60523236f, 
    -0.36779854f, 0.64247602f, 1.13934052f, 0.93875855f, 0.19453551f, 0.67510605f, 0.43874314f, 0.25846076f, 
    0.40520713f, -0.31059471f, -0.46456298f, -0.47903025f, 0.35383514f, 0.21110323f, -0.29425964f, -0.30770674f, 
    -0.23017268f, 0.17897469f, -0.00298471f, 0.22505209f, -0.10877182f, -0.34414795f, -0.15185890f, -0.03719098f, 
    -0.81078589f, 0.64383733f, 0.69043022f, 0.49793026f, -0.32646400f, -0.93594068f, 0.06897281f, -0.38047975f, 
    -0.40824559f, -0.43255836f, 0.34515017f, 0.07575523f, 0.27154717f, 0.19879074f, 0.48023435f, -0.43454015f, 
    0.17542580f, 0.48514685f, -0.34868890f, 0.65439701f, 0.50917143f, -0.10904229f, -0.03266954f, -0.05551265f, 
    0.28111115f, -0.18354784f, 0.15711583f, 0.15032083f, -1.16144145f, -0.15537459f, -0.32454011f, -0.74264497f, 
    -0.17711096f, 0.38520378f, -0.69551355f, -0.24463141f, 0.29176873f, 0.39815268f, -0.22240072f, 0.15133247f, 
    0.16550289f, 0.30043012f, -0.58781147f, -0.09320970f, 0.08672349f, 0.53535628f, -0.24458353f, -0.16554637f, 
    -0.29809347f, -0.10569344f, 0.02115957f, -0.95415604f, 0.19207375f, 0.56850970f, 0.17140463f, 0.70935071f, 
    0.14871517f, -0.33253098f, 0.78980768f, 0.30057198f, 0.25976759f, 0.41798761f, 0.11282293f, 0.74319404f, 
    0.48334163f, 0.46543524f, -0.01009565f, 0.20259002f, 0.07270461f, 0.04614224f, 0.22931816f, 0.17197561f, 
    0.19618283f, 0.15221411f, 0.26843536f, 0.80175275f, 0.79997683f, -0.00280741f, 0.57063615f, -0.54627657f, 
    -0.32308313f, 0.13094717f, 0.50971216f, 0.46577463f, 0.53007132f, -0.32967606f, 0.10036054f, -0.21058048f, 
    0.04407367f, 0.24175164f, 0.43495768f, -0.23490955f, -0.15148263f, -0.35947672f, 0.44662726f, 0.12282997f, 
    -0.05856446f, 0.59598434f, -0.36440885f, -0.53524029f, 0.94168562f, 0.28300738f, 0.31762034f, 1.13027787f, 
    0.41983518f, -0.05947690f, -0.36104596f, -0.56525648f, 0.38363019f, -0.04703428f, -0.47013187f, -0.56759989f, 
    -0.31506741f, -0.07057196f, 0.09980758f, 0.35706398f, -0.00595196f, 0.16759640f, 0.20935434f, 0.41828597f, 
    -0.27100196f, 0.26894724f, 0.19743955f, -0.38810530f, 0.07715165f, -0.97717094f, -0.76917231f, -0.03875029f, 
    -0.03824575f, -0.35852048f, -0.28838286f, -0.04125054f, 0.14528780f, -0.46685895f, 0.44492990f, -0.06748054f, 
    0.30568224f, -0.46731961f, -0.27950653f, 0.06773491f, 0.00077657f, 0.31575674f, 0.32737535f, -0.50086766f, 
    -0.64436114f, -0.42504916f, -0.64098072f, 0.27177572f, -0.26292121f, -0.07572519f, 0.87038308f, 0.78925997f, 
    0.85989064f, 0.65310967f, 0.18020888f, -0.43373924f, 0.11657546f, -0.37336123f, 0.17830653f, 0.46033314f, 
    0.38463628f, -0.06037100f, 0.01351826f, 0.00240860f, -0.54106468f, -0.34237385f, -0.13430859f, 0.20496014f, 
    -0.00557781f, -0.24298142f, -0.06197058f, 0.35968190f, 0.19845393f, 0.17412619f, -0.03332907f, -1.05934060f, 
    -0.26613197f, -0.84238058f, -0.75367409f, 0.19256417f, -0.17390348f, 0.22215334f, 0.41614547f, 0.60835767f, 
    0.76443410f, 0.39171356f, -0.27164122f, 0.24313696f, -0.34711742f, 0.31802562f, 0.07694446f, 0.08328204f, 
    0.07596151f, 0.40377724f, -0.14906913f, -0.43670493f, -0.34793296f, -0.58839822f, 0.01086723f, 0.04043764f, 
    0.47491929f, 1.51466966f, 1.12203562f, 0.00608941f, -0.38187346f, -0.91204828f, 1.03957784f, -0.53235215f, 
    -0.69217640f, 0.15742059f, 0.18058906f, 0.38883793f, 0.13544598f, 0.36559162f, -0.00488057f, 0.25518164f, 
    -0.28911138f, 0.06784248f, 0.14877358f, -0.17479874f, 0.15870915f, 0.29599717f, 0.09188260f, 0.22146508f, 
    0.01941632f, -0.81097257f, -1.34145975f, -0.51701945f, 0.19735874f, -0.12681429f, 0.80015087f, 1.05648923f, 
    0.17428221f, 0.37845054f, 0.18004434f, 0.02361180f, 0.04263014f, 0.42224902f, 0.40143237f, -0.07633952f, 
    -0.58352453f, 0.04544343f, 0.22968277f, -0.43343911f, -0.19779719f, -0.05835304f, -0.06605782f, 0.07020890f, 
    -0.51612788f, -0.31218198f, 1.03197873f, -0.49351177f, -0.39464071f, -0.41040498f, 0.90834475f, 1.09802496f, 
    0.00370127f, -0.35348794f, -0.07977594f, 0.26795596f, -0.50420409f, 0.14077555f, -0.05750052f, 0.35978034f, 
    0.01228362f, -0.13721345f, 0.32119352f, -0.01113436f, 0.17448466f, -0.14343165f, -0.15504095f, 0.15312707f, 
    -0.39464277f, -0.12051874f, -0.12939069f, 1.33219039f, 0.41173422f, -1.16132390f, -0.78295654f, -0.73810351f, 
    -0.45105210f, 0.10284872f, -0.42090774f, -0.37143779f, -0.64315206f, -0.10172032f, -0.06064651f, 0.51707345f, 
    0.04423342f, -0.56765586f, -0.25360385f, -0.14752223f, -0.00791255f, -0.03914549f, 0.07369529f, 0.07059592f, 
    0.34041199f, 0.32644752f, 0.10342380f, 0.04588648f, -0.10710429f, 0.24413206f, 0.11130110f, -1.11831748f, 
    -0.67797405f, 0.68444300f, -0.55847287f, -0.24093294f, -0.80332816f, -0.35709760f, 0.58747935f, 0.65593177f, 
    0.03319979f, -0.04634031f, 0.51175821f, -0.58962995f, -0.24917591f, -0.32933274f, -0.07659949f, 0.12505542f, 
    0.22178613f, 0.18965897f, 0.03615961f, 0.43657216f, 0.12866722f, 1.18513083f, -0.39936519f, 0.04253405f, 
    0.51843101f, 1.16280890f, 0.68520623f, 0.59163356f, 0.31766310f, 0.30407384f, 0.48625326f, -0.25084642f, 
    0.36911941f, -0.05357350f, 0.43729591f, 0.05424483f, 0.14956638f, -0.03798953f, 0.16701774f, 0.07927854f, 
    -0.08168004f, 0.12363034f, 0.12193560f, 0.21995895f, 0.28788444f, 0.06036149f, -0.77197164f, -0.24864276f, 
    -0.64012253f, -0.67260575f, -0.35202736f, -0.73331839f, -0.15051198f, -0.01867978f, -0.37042508f, 0.59250569f, 
    -0.33523539f, 0.43582430f, 0.02234841f, 0.38962883f, 0.34486610f, 0.49436632f, -0.12195289f, -0.11487150f, 
    0.58223337f, 0.38716543f, -0.29450998f, 0.10708036f, 0.22300896f, -0.40350160f, -0.24240924f, 0.78063631f, 
    -0.62122524f, 0.80898827f, 0.63421011f, 1.14288080f, -0.52011520f, -0.32244530f, -0.64325118f, -0.95906091f, 
    0.04262504f, 0.63643700f, 0.50044835f, -0.09866461f, 0.30549285f, 0.10083448f, -0.31181750f, -0.03583642f, 
    -0.17878757f, 0.19282913f, -0.14468117f, -0.03946339f, 0.09772687f, 0.10298154f, -0.06792647f, -0.08794744f, 
    -0.08441921f, 0.52085024f, 0.47300401f, 0.55314559f, 0.60755640f, 0.16972356f, 0.08091934f, 0.44406280f, 
    0.29740515f, 0.54357779f, -0.73291242f, -0.11127730f, -0.51366794f, -0.27599150f, -0.54962766f, -0.02985623f, 
    0.30335701f, -0.50391966f, 0.37911260f, -0.28374928f, -0.09674191f, 0.10031628f, 0.16270259f, -0.09180924f, 
    -0.07935762f, 1.25724566f, 1.14733231f, 0.02083068f, 0.10213288f, 0.10195600f, -0.33796367f, -0.19696409f, 
    0.46565777f, 0.40540323f, 0.64147961f, -0.76658463f, 0.25002956f, 0.18553667f, -0.63610786f, -0.32281172f, 
    0.06826792f, -0.06662308f, -0.23340347f, 0.06259707f, 0.02325954f, -0.10923874f, -0.13466267f, -0.01936064f, 
    -0.27473262f, 0.03997992f, -0.08270504f, 0.96796495f, -0.05700453f, -0.17714785f, 1.07773697f, 0.24554707f, 
    -1.10086095f, -0.54973948f, -0.53111237f, -0.01892252f, -0.09110448f, -0.29195338f, -0.02186666f, -0.08085998f, 
    -0.60344148f, 0.28042963f, -0.06820966f, -0.44235775f, -0.37601188f, -0.17083678f, 0.26779246f, 0.32401890f, 
    0.45999122f, -0.43094885f, -0.03801893f, -0.93689811f, -0.10844367f, -0.97419935f, 0.15424398f, -0.07730214f, 
    0.68524593f, 0.92625290f, -0.07599083f, 0.30848831f, 0.26528525f, 0.19672287f, -0.39542809f, -0.12897600f, 
    -0.29600072f, 0.61572039f, 0.12445414f, -0.10235576f, 0.02188933f, 0.02795516f, 0.06628777f, 0.25072870f, 
    0.44776401f, 0.33906162f, 0.60843128f, 0.09977441f, -0.71536660f, 0.54218048f, 0.15856473f, 0.50072598f, 
    -0.70608079f, -0.44591242f, -0.37853426f, 0.43610287f, 0.19663979f, 0.39350298f, 0.42299557f, 0.19829728f, 
    0.04554142f, -0.36526158f, -0.30949429f, 0.21409597f, 0.41747302f, 0.77207553f, 0.46835458f, -0.53794086f, 
    0.02953110f, 0.16419642f, -0.58222324f, -0.05813725f, 0.10309228f, -0.96102905f, -0.31321087f, -0.24797937f, 
    0.46352628f, 0.75057018f, -1.12313581f, 0.31657445f, 0.21032250f, -0.44889030f, -0.74434769f, -0.08186910f, 
    0.34226608f, 0.17638819f, 0.08442403f, 0.35861027f, -0.14936784f, 0.24882260f, -0.00235233f, 0.06051842f, 
    -0.21465707f, 0.03127664f, -0.05241985f, -0.22857030f, 0.03537645f, -0.28279814f, -0.48501685f, 0.31324458f, 
    0.34771904f, -0.57037657f, 0.34384564f, 0.18917046f, -0.98784864f, -1.01702023f, -1.06254852f, -0.70247883f, 
    -0.45802140f, 0.49105006f, 0.45504743f, -0.04065417f, -0.10092152f, 0.07425289f, 0.15708551f, 0.23603277f, 
    0.38959435f, -0.23343129f, -0.09674763f, 0.02778005f, -0.07057025f, 0.09917024f, 0.18354666f, 0.09840429f, 
    -0.51618820f, 0.11799319f, 1.33659041f, -1.21425104f, 0.06653805f, 0.09874273f, 0.73269737f, -0.65456569f, 
    0.21447869f, 0.02230754f, -0.13053145f, 0.09317152f, 0.11424734f, 0.05532819f, -0.43933234f, -0.45411128f, 
    0.01123932f, -0.13776927f, -0.34392479f, 0.09008551f, 0.04976620f, -0.01384799f, 0.34169477f, 0.03416030f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17972198f, 0.06538185f, 0.28066370f, -0.08484482f, 0.24184974f, 0.32607248f, 0.38904688f, 0.19260553f, 
    0.30844060f, 0.16845438f, 0.05102340f, 0.12340963f, -0.09821959f, 0.20125280f, 0.31951922f, 0.32211649f, 
    0.14234196f, 0.00178901f, 0.12153813f, 0.35623714f, 0.30123863f, 0.09682152f, 0.07856036f, 0.18011454f, 
    -0.02783351f, 0.32283163f, 0.14996406f, 0.10851166f, 0.13859269f, 0.16657354f, 0.03577362f, -0.04035180f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.63150370f, 0.02005356f, -0.18247667f, -0.52254629f, 0.08086791f, 0.01656438f, -0.05970385f, 0.06906660f, 
    0.10777834f, 0.02738625f, -0.00032383f, 0.13243373f, -0.27901927f, 0.23541123f, 0.19581869f, -0.20503737f, 
    0.09469104f, 0.18025473f, -0.19242810f, 0.07159959f, 0.06256542f, 0.08201275f, 0.04233968f, -0.18351507f, 
    -0.20320781f, -0.46143439f, 0.16097307f, 0.30371091f, -0.05456353f, -0.18956687f, -0.10902032f, -0.19409111f, 
    -0.05537867f, 0.12704131f, 0.02676652f, -0.04225884f, 0.58494365f, 0.13404550f, 0.37625605f, 0.09809440f, 
    0.08786011f, 0.07066752f, 0.07963067f, 0.05051638f, -0.00558390f, -0.00485931f, -0.08487245f, 0.00994015f, 
    0.08702166f, -0.08530631f, -0.24729149f, 0.19354901f, -0.23916712f, 0.05806083f, 0.09888642f, 0.15794773f, 
    -0.00465357f, -0.01812135f, -0.05235468f, -0.06675792f, 0.15916662f, -0.19865374f, -0.01567372f, 0.21555133f, 
    -0.27560759f, -0.05801779f, -0.12716153f, 0.05090167f, 0.04867240f, 0.06448285f, -0.18814282f, -0.08094103f, 
    0.10418467f, 0.05246911f, 0.13462378f, -0.17901324f, -0.03535164f, 0.07952975f, 0.09940275f, -0.21304181f, 
    -0.18439199f, 0.04582870f, -0.03355742f, 0.08863083f, 0.01286266f, -0.14076194f, -0.09255688f, 0.31322742f, 
    -0.09417400f, 0.06012426f, 0.05395050f, -0.00723969f, -0.01336488f, -0.04624952f, 0.07239491f, 0.02190616f, 
    -0.25646695f, 0.08710397f, -0.14256053f, 0.10871375f, 0.02995387f, -0.01123312f, 0.11623189f, -0.08944343f, 
    -0.09035461f, -0.15017317f, 0.03566580f, 0.05682959f, -0.60892457f, 0.08406565f, 0.08664507f, -0.17571083f, 
    0.03382014f, 0.13202110f, -0.00788795f, 0.09562079f, -0.05865371f, -0.21898873f, 0.05434689f, -0.10725773f, 
    -0.37183318f, 0.00556203f, -0.27021530f, 0.22150753f, 0.01101581f, -0.02951160f, -0.12233211f, -0.09371630f, 
    0.06137741f, 0.02259798f, 0.09131169f, -0.04190855f, -0.07700107f, 0.01889727f, -0.36314321f, 0.07123897f, 
    -0.23346578f, 0.02461139f, -0.14752433f, -0.07773801f, 0.07250910f, -0.04334874f, 0.14879271f, -0.01788747f, 
    0.12533142f, -0.12757950f, -0.16569127f, 0.34585419f, -0.15810262f, 0.07814869f, -0.16948019f, 0.11543808f, 
    -0.03240604f, -0.05858093f, -0.06975263f, 0.04930777f, -0.28631970f, -0.13559373f, -0.07107638f, 0.08997856f, 
    0.00740027f, -0.03317247f, -0.14355466f, 0.10063880f, 0.11893962f, 0.18867682f, -0.06745160f, -0.07857119f, 
    0.13578178f, 0.06770837f, -0.12413238f, 0.13370770f, -0.08001287f, -0.18786275f, -0.07119755f, 0.00922876f, 
    -0.06966510f, 0.06618915f, -0.00864155f, -0.01966616f, 0.21877821f, 0.22009377f, -0.12842588f, -0.15432124f, 
    0.02542575f, 0.04276209f, -0.03487184f, -0.05074151f, 0.00508071f, -0.04061829f, -0.11605331f, 0.03992324f, 
    -0.14405732f, 0.12906270f, 0.10217975f, -0.15401301f, -0.18178979f, 0.05420347f, -0.07179660f, -0.10618596f, 
    -0.20052832f, -0.00458620f, -0.09237736f, -0.16830355f, -0.12095167f, 0.16657174f, -0.04886268f, -0.19499175f, 
    0.19770075f, 0.08113167f, -0.12810624f, 0.08308361f, -0.01993036f, 0.05404456f, -0.08825993f, 0.18542095f, 
    0.24992955f, -0.22816963f, 0.20286225f, -0.05434256f, 0.06882861f, -0.00346742f, 0.14009354f, -0.01626150f, 
    -0.16723518f, 0.14445809f, 0.05933468f, 0.07246470f, -0.45326793f, 0.13731404f, 0.28535739f, -0.18703069f, 
    -0.18541227f, 0.07543952f, 0.01298946f, -0.03167600f, -0.09636845f, 0.02339442f, 0.02685482f, -0.00751603f, 
    -0.46781713f, -0.00868880f, 0.18012097f, 0.00743880f, -0.10433949f, 0.11984230f, 0.22165422f, -0.11020006f, 
    0.00651245f, -0.09713210f, 0.15028684f, 0.14728576f, 0.28832504f, -0.03011744f, -0.01268923f, 0.19372955f, 
    0.04689343f, -0.03614785f, -0.17227671f, 0.05177379f, -0.16865623f, 0.10566577f, 0.14685477f, -0.19598331f, 
    -0.22347514f, -0.25997105f, 0.03661807f, -0.35183311f, -0.05752823f, -0.08616769f, 0.14655545f, -0.04647519f, 
    0.00419077f, -0.16509546f, -0.00715646f, -0.01427843f, 0.39669070f, -0.15825070f, -0.02908363f, 0.14390968f, 
    -0.31904668f, -0.10607968f, 0.06080511f, 0.01032699f, -0.13698174f, 0.14589114f, -0.15877123f, 0.06634881f, 
    0.02386035f, 0.03557159f, 0.09097436f, 0.11268789f, -0.06143574f, -0.01358911f, 0.00463690f, -0.06341814f, 
    0.05174732f, -0.04223487f, 0.04198218f, 0.06506620f, 0.11133293f, -0.02086992f, -0.04293364f, -0.20485209f, 
    -0.17029263f, -0.23665461f, -0.09474904f, 0.15345709f, 0.01335557f, -0.00003204f, 0.07688061f, -0.01348924f, 
    0.13051930f, -0.06235787f, 0.34733781f, -0.17727904f, -0.10521744f, 0.02465314f, -0.12063488f, -0.07644062f, 
    0.06039140f, -0.17613359f, 0.07987652f, -0.17466256f, 0.54121476f, 0.16528688f, 0.13131438f, -0.18103275f, 
    0.06946240f, 0.07159683f, 0.07575273f, 0.00542117f, 0.11212215f, -0.04726317f, -0.00146305f, 0.09665895f, 
    -0.11958124f, 0.23091429f, -0.10234708f, -0.06414481f, -0.08385186f, -0.05828308f, 0.09059006f, -0.15694053f, 
    0.04464168f, -0.01187908f, -0.21902797f, 0.03949716f, -0.33984551f, 0.19067734f, -0.09923414f, 0.07511327f, 
    -0.03293295f, -0.15223184f, -0.07863726f, -0.03636840f, 0.03351667f, -0.06453048f, 0.02163029f, -0.01437885f, 
    -0.76749462f, 0.16792937f, 0.33492845f, -0.00993637f, -0.07812922f, -0.08431026f, -0.01968897f, -0.01966109f, 
    0.00326232f, 0.04474140f, -0.12851007f, 0.07074558f, -0.28118804f, 0.15091039f, -0.20261785f, 0.27384290f, 
    -0.16484225f, 0.06648521f, -0.06294467f, -0.05690026f, 0.00324775f, -0.04687184f, 0.06391389f, 0.02782930f, 
    -0.43589878f, -0.14473622f, 0.05655755f, -0.38163766f, 0.04308168f, -0.14497803f, 0.14903975f, 0.05729295f, 
    0.09106704f, 0.05253585f, 0.07130684f, -0.07885864f, 0.04648365f, -0.05808876f, -0.14506197f, 0.11362287f, 
    -0.21888304f, -0.12986937f, 0.06209034f, -0.11371399f, 0.05157839f, 0.00334087f, 0.02171942f, 0.17592987f, 
    0.31930134f, -0.70336980f, -0.03134826f, 0.07263449f, -0.25514689f, 0.18301879f, -0.16986932f, 0.13027683f, 
    0.04127544f, -0.01415273f, -0.05959278f, 0.21844937f, -0.63270372f, 0.05538723f, -0.15979850f, 0.02982686f, 
    0.15566084f, 0.02158343f, -0.08687332f, -0.19861171f, -0.01822506f, 0.18955165f, -0.08610407f, -0.20426612f, 
    0.15843377f, -0.07366928f, 0.33528960f, 0.27053398f, -0.08432284f, 0.03350818f, -0.06410464f, -0.09875388f, 
    -0.04737533f, -0.00958291f, 0.01517402f, 0.10274382f, 0.24805726f, -0.05895107f, 0.17642868f, -0.13405591f, 
    -0.03923839f, -0.06671119f, 0.08310677f, -0.03270803f, -0.22022103f, 0.01452026f, 0.06113867f, 0.06322502f, 
    0.06379235f, -0.12868196f, 0.16120781f, -0.48505521f, 0.07214028f, -0.11349577f, 0.01503599f, 0.09411154f, 
    0.16852331f, -0.17505522f, -0.11905374f, 0.02612138f, 0.38467547f, 0.00492759f, 0.00119583f, 0.26065162f, 
    -0.10596365f, 0.02910922f, -0.00074104f, -0.05371043f, 0.01442063f, 0.27198064f, -0.02514630f, -0.03274896f, 
    -0.49726865f, -0.02211906f, -0.21129826f, -0.15191190f, -0.03628359f, 0.06139484f, -0.07419478f, -0.03618718f, 
    -0.01262247f, -0.09235266f, 0.33412784f, 0.15977725f, -0.28756845f, 0.01494948f, 0.15595751f, -0.17148077f, 
    -0.07662488f, -0.26300085f, -0.01815943f, 0.07863206f, -0.07225839f, 0.04440741f, -0.14834173f, -0.04541298f, 
    0.29583439f, -0.03429293f, -0.05711149f, -0.04180101f, -0.12233200f, 0.13270025f, -0.02990586f, 0.01600151f, 
    -0.02244705f, -0.05034086f, -0.11369230f, 0.12351497f, 0.15874945f, -0.03344036f, 0.20684679f, 0.14734019f, 
    -0.14762737f, -0.31734654f, -0.00579212f, 0.00735277f, 0.11305919f, 0.12546679f, -0.21974041f, 0.29822502f, 
    0.18388736f, -0.21280955f, -0.03434109f, 0.17052415f, -0.02711711f, -0.10428080f, 0.15864198f, -0.01630533f, 
    -0.05301821f, -0.07924086f, 0.05113106f, 0.02089010f, 0.10111053f, 0.10551061f, -0.24411435f, 0.14805691f, 
    -0.14613621f, -0.11808435f, -0.14300516f, -0.09888711f, -0.02934437f, -0.17697103f, 0.06903143f, 0.00281947f, 
    0.32715195f, 0.02413276f, 0.15848356f, 0.35006607f, -0.08011741f, 0.02620825f, 0.14697453f, 0.05856371f, 
    0.01868421f, -0.11715620f, 0.07120312f, 0.03813217f, 0.28218400f, 0.11144138f, -0.03322082f, -0.17700589f, 
    0.08057117f, 0.07696645f, -0.17051184f, 0.15761657f, 0.04497059f, -0.04710526f, -0.05891401f, -0.00049945f, 
    0.02281645f, 0.31343418f, -0.12785715f, -0.20524582f, -0.18535140f, -0.00286088f, 0.02110536f, -0.07083013f, 
    0.18280368f, 0.05560901f, 0.09298626f, 0.17094645f, 0.25681227f, 0.03335267f, -0.22561254f, 0.10308151f, 
    0.04266663f, 0.07773541f, -0.01156454f, 0.11043108f, -0.14836369f, -0.12385410f, 0.01942408f, -0.11746594f, 
    0.40996781f, -0.41760466f, -0.01307099f, -0.18441823f, -0.01958546f, -0.00373590f, -0.21378763f, 0.03825613f, 
    -0.03216060f, -0.04828511f, 0.03529080f, -0.09123962f, 0.43153062f, -0.30186892f, -0.09208675f, -0.59696615f, 
    0.11620458f, -0.13817549f, 0.05592363f, 0.10150717f, -0.14307669f, -0.07064202f, 0.08263258f, -0.02301172f, 
    -0.06437847f, 0.03114148f, -0.07245673f, -0.08444713f, -0.04235429f, -0.02191364f, -0.23269807f, 0.11587366f, 
    -0.01135402f, 0.06853370f, -0.07357594f, -0.21708409f, 0.55683208f, -0.20222604f, -0.03913124f, 0.07389176f, 
    -0.17040032f, 0.06809009f, -0.04604312f, 0.02102738f, 0.14432482f, 0.01586458f, -0.10733202f, 0.19391640f, 
    -0.03025316f, 0.03870586f, -0.00670249f, -0.03642537f, 0.02996840f, 0.07472420f, 0.07566229f, 0.01948163f, 
    -0.05878793f, 0.22182509f, -0.01455854f, -0.05552237f, -0.28991625f, -0.13158213f, 0.17314337f, 0.08466806f, 
    0.01910669f, -0.08631334f, -0.00276582f, 0.06683411f, 0.06007625f, -0.00524316f, 0.06697185f, -0.09526027f, 
    0.19914065f, 0.09795680f, 0.09178255f, 0.26025993f, 0.11640926f, 0.08515872f, -0.01047469f, 0.14055428f, 
    0.10115512f, -0.11236311f, 0.00015058f, -0.15608612f, 0.32319960f, 0.08757019f, 0.20535773f, 0.17351681f, 
    0.19377619f, -0.07508425f, -0.00886801f, 0.01021897f, -0.15243340f, -0.30150545f, -0.09822603f, -0.06535885f, 
    0.10138524f, -0.31309602f, -0.14510092f, -0.31370628f, 0.05909552f, -0.09595960f, 0.10670958f, -0.05541444f, 
    0.03281299f, -0.02173977f, -0.20884496f, 0.09996058f, -0.02027672f, 0.12788962f, -0.32308909f, -0.12586771f, 
    -0.01596568f, -0.09026144f, -0.19508433f, -0.15014604f, 0.10128822f, 0.11568505f, -0.10211781f, 0.03988244f, 
    -0.29313698f, -0.15567684f, -0.22824812f, 0.04202724f, 0.03087197f, 0.01995825f, -0.20419921f, 0.18233483f, 
    -0.14089066f, -0.06017928f, 0.02251915f, 0.11156262f, -0.23538408f, -0.07480175f, -0.12045661f, -0.23392080f, 
    0.07671931f, 0.04929429f, -0.25370044f, -0.16925138f, -0.06939889f, -0.04500834f, 0.00186230f, -0.08812194f, 
    0.37070879f, -0.13559459f, -0.05087540f, -0.30602428f, -0.07243368f, 0.04273259f, 0.06702371f, -0.01074929f, 
    0.19541867f, 0.08871605f, 0.18363670f, -0.01295331f, -0.31626919f, 0.04604856f, -0.14411972f, 0.50028890f, 
    -0.15168862f, 0.13072267f, 0.03085073f, 0.03191502f, 0.08153218f, -0.23689725f, -0.13578147f, -0.03118451f, 
    0.14089237f, 0.07147524f, 0.30121025f, 0.23503497f, 0.20187524f, 0.00941942f, -0.05420886f, 0.12344027f, 
    -0.10896228f, -0.00254881f, 0.07254890f, -0.10590152f, 0.14420626f, -0.06617454f, 0.08873846f, -0.11902438f, 
    -0.27119017f, -0.17239408f, -0.24018319f, -0.01191468f, 0.07866353f, 0.05360001f, 0.00291109f, -0.12686338f, 
    0.77827537f, -0.26052892f, -0.01527919f, -0.17033064f, 0.03550793f, 0.05520220f, 0.09676809f, -0.08684893f, 
    -0.01789229f, 0.03842096f, 0.12448208f, -0.14971916f, 0.55804670f, -0.09101159f, 0.03763666f, 0.08850051f, 
    -0.03899257f, -0.09538707f, 0.08078661f, 0.20379914f, 0.01767833f, 0.08450374f, -0.00709461f, -0.00454074f, 
    0.15479000f, -0.18038049f, 0.02351696f, 0.14758475f, 0.12246896f, 0.04205706f, 0.01402935f, -0.04158168f, 
    0.07497918f, 0.02452927f, -0.09757353f, 0.01784589f, -0.08577242f, -0.11757652f, -0.08967248f, 0.02075545f, 
    0.02065060f, -0.07110691f, 0.04609764f, 0.18384051f, -0.12460922f, -0.02692923f, -0.05209699f, -0.12281874f, 
    -0.25679693f, -0.27488148f, 0.00089844f, 0.16397193f, 0.03669012f, 0.02252466f, 0.00862559f, -0.04270950f, 
    0.07719916f, 0.03186369f, -0.15642531f, 0.06875420f, -0.23079056f, 0.10930059f, 0.01586518f, -0.11462989f, 
    0.16390772f, 0.01085911f, -0.04094550f, 0.04245466f, 0.11455832f, 0.01411236f, 0.09810417f, -0.11954460f, 
    0.23922271f, 0.18261078f, -0.65802145f, 0.08580163f, -0.11743706f, 0.05989387f, -0.02337479f, 0.03697702f, 
    -0.08634502f, -0.01204507f, -0.18687302f, 0.03415838f, -0.59322894f, 0.13114487f, -0.25284380f, -0.15216868f, 
    0.07241361f, -0.15235363f, 0.12770189f, 0.01273696f, 0.03650270f, 0.01918939f, -0.19021903f, -0.09857600f, 
    0.41957694f, -0.13946989f, -0.06170521f, -0.07746501f, -0.17545161f, 0.15964264f, -0.11169024f, 0.11637671f, 
    -0.07656269f, 0.04603425f, 0.07986724f, -0.14306390f, 0.05803038f, -0.00617626f, -0.19031334f, -0.04786517f, 
    -0.05966980f, 0.06500676f, 0.00740637f, 0.12239622f, -0.10695260f, -0.14135145f, -0.02843291f, -0.25390050f, 
    -0.14219829f, -0.06520273f, -0.04400511f, -0.07486833f, -0.02406407f, 0.10032379f, -0.24930856f, 0.12749860f, 
    -0.03916729f, 0.02348291f, 0.10795277f, 0.05253447f, 0.28814647f, -0.11284010f, -0.22264385f, 0.11172628f, 
    -0.05577270f, 0.06749007f, 0.04905660f, 0.10033250f, 0.00859440f, -0.00527714f, -0.03949824f, -0.08710580f, 
    0.00204229f, 0.20829193f, 0.03949114f, 0.05461563f, 0.08925427f, 0.08841230f, -0.01227526f, -0.05353528f, 
    -0.02502977f, 0.12293125f, 0.00131582f, -0.03636985f, 0.06205333f, 0.05356456f, 0.12704006f, 0.22363135f, 
    -0.13044818f, -0.11496746f, -0.00154205f, 0.02495773f, -0.08359454f, 0.02925008f, -0.07359861f, -0.06955466f, 
    0.11575904f, 0.28039795f, -0.16738720f, -0.39555240f, 0.04121159f, 0.10326877f, -0.00651110f, -0.19046427f, 
    -0.08897647f, -0.09308001f, -0.00462365f, -0.14123231f, 0.28912783f, 0.08596129f, 0.19668649f, 0.12877648f, 
    -0.22005627f, -0.13801150f, -0.19580521f, 0.09579328f, 0.12459755f, -0.06382305f, -0.11539478f, 0.00614335f, 
    -0.49057710f, -0.21536317f, 0.21889168f, -0.27362573f, 0.04262555f, -0.02000895f, 0.00100415f, -0.20017534f, 
    -0.06284890f, -0.09520695f, -0.08523274f, 0.04876796f, -0.46452549f, 0.13403352f, -0.30063069f, -0.30214265f, 
    -0.00429468f, -0.04899836f, 0.15162458f, -0.18461646f, -0.09019856f, 0.01631343f, 0.03849721f, -0.09677272f, 
    -0.40563419f, -0.12388554f, 0.13238122f, -0.64750034f, -0.01264358f, -0.05792959f, 0.04306953f, 0.00617011f, 
    0.03363499f, -0.13738555f, -0.01625845f, -0.17865454f, -0.13556707f, -0.00279312f, 0.17373647f, -0.21664031f, 
    0.13761859f, 0.09416390f, 0.07855722f, 0.07490654f, -0.07806210f, -0.02250224f, 0.06602497f, 0.02558625f, 
    0.04464305f, -0.03767351f, -0.00748729f, -0.04358925f, -0.14983177f, 0.01174618f, -0.09177350f, 0.13622804f, 
    -0.00179025f, -0.08845511f, -0.08228000f, 0.00845170f, 0.07897206f, 0.05768017f, -0.06424643f, 0.05356175f, 
    0.11656174f, 0.15858476f, 0.00873664f, -0.00865759f, -0.14328356f, 0.03122120f, 0.06390207f, -0.10026723f, 
    0.08158464f, -0.10093804f, -0.05310044f, 0.10541321f, -0.01676063f, 0.04927626f, 0.06761385f, -0.05669612f, 
    -0.04944684f, 0.08373876f, 0.03166540f, 0.03678654f, 0.07387909f, 0.12744001f, 0.00628250f, -0.13758892f, 
    0.03638158f, -0.04853155f, 0.13896433f, -0.01775323f, -0.03952809f, 0.07909129f, 0.12801410f, 0.03111947f, 
    -0.07441030f, 0.05584510f, -0.13738403f, -0.17032897f, 0.09397753f, 0.01928191f, 0.07334151f, -0.21908312f, 
    0.04122256f, 0.07277595f, 0.02731538f, -0.06920340f, 0.25092733f, -0.11709275f, 0.12404584f, 0.19303945f, 
    -0.09176522f, -0.06214583f, -0.11641473f, 0.03120704f, 0.03548887f, -0.05736727f, 0.00540908f, 0.11756279f, 
    -0.05695784f, -0.00724651f, -0.05341482f, 0.12078660f, 0.01834117f, -0.12829342f, 0.14510956f, -0.03318082f, 
    -0.13726394f, -0.03293924f, -0.07038891f, -0.06651444f, 0.70522416f, -0.12523109f, -0.15197931f, -0.28516635f, 
    0.03889951f, 0.12338691f, -0.22632441f, -0.12739988f, 0.00436010f, -0.07714517f, -0.01479527f, -0.11005279f, 
    -0.24281090f, -0.13185182f, -0.22136545f, -0.17557800f, 0.10855965f, -0.09068600f, -0.06692140f, 0.06287513f, 
    -0.26620844f, 0.22162059f, -0.19582337f, -0.06623918f, 0.01039016f, -0.00427592f, -0.14254734f, -0.09434261f, 
    -0.09876288f, 0.05524935f, -0.00970539f, 0.03766137f, 0.06137295f, 0.12826531f, -0.00026729f, -0.14911151f, 
    -0.17468615f, -0.03693510f, -0.05393181f, -0.30230668f, -0.14362486f, -0.00909603f, 0.03672058f, 0.02156180f, 
    0.01045202f, -0.09273682f, -0.08807735f, 0.15333456f, 0.34748459f, -0.11952975f, -0.00072965f, -0.16596709f, 
    -0.03435340f, -0.12872663f, -0.01848935f, 0.03444517f, -0.21802880f, -0.10578036f, -0.00190335f, 0.02369210f, 
    0.20457655f, 0.05161117f, 0.16009645f, 0.14914592f, -0.00353003f, -0.09882424f, 0.09696818f, -0.17123649f, 
    -0.05596630f, 0.04402778f, -0.09094903f, -0.00847130f, -0.47600138f, -0.03373528f, 0.01643777f, -0.10681345f, 
    0.02505803f, -0.14925039f, 0.01902121f, 0.10888184f, 0.02533732f, -0.13699800f, -0.05037474f, -0.08131552f, 
    -0.21168432f, -0.67904907f, 0.03083074f, 0.39658946f, -0.01683577f, -0.11744170f, 0.02543331f, -0.02997619f, 
    -0.01212645f, -0.14205042f, -0.01297048f, 0.02952232f, 0.05426135f, -0.04502594f, -0.53992927f, 0.03072068f, 
    -0.12420128f, 0.00144627f, -0.11035098f, 0.17284374f, -0.03888467f, -0.03568252f, 0.04962206f, -0.08205193f, 
    0.05816588f, 0.20831162f, -0.07331513f, 0.16712806f, -0.18057361f, -0.08570614f, 0.06872430f, -0.09267186f, 
    -0.14036517f, 0.05109444f, 0.04029042f, -0.00116503f, -0.66296273f, -0.27244282f, -0.06014834f, -0.15664212f, 
    -0.12317834f, 0.06379421f, -0.05455601f, -0.10503615f, 0.05927306f, 0.02183758f, 0.12918180f, -0.08659894f, 
    -0.36044636f, 0.27305323f, 0.01206009f, -0.01854788f, 0.06091471f, -0.07153831f, 0.05841151f, 0.13013384f, 
    -0.02269755f, -0.00736566f, -0.03244765f, -0.02531124f, -0.02424558f, 0.08709792f, 0.13445488f, 0.06093434f, 
    -0.05325039f, -0.01238555f, 0.10530282f, -0.09195469f, 0.21049379f, 0.21024670f, 0.03704089f, 0.02177976f, 
    -0.11958154f, -0.01488336f, -0.20347698f, -0.13540126f, 0.18595219f, 0.06645583f, -0.08090544f, -0.07938429f, 
    0.07715628f, -0.04354567f, 0.01687277f, -0.10498452f, -0.06674311f, -0.28790307f, -0.13356881f, 0.07018910f, 
    -0.08628274f, -0.11133644f, -0.05336394f, 0.08581793f, -0.05880309f, -0.09373619f, -0.18516296f, -0.06757220f, 
    0.11626461f, -0.32992673f, -0.27687976f, 0.16058820f, 0.12916748f, 0.17183901f, 0.10228281f, 0.01378443f, 
    -0.07376949f, -0.19435792f, 0.14390726f, 0.04532539f, 0.01276254f, 0.08068608f, 0.27954993f, -0.16375433f, 
    0.11940452f, -0.01045459f, -0.00485496f, 0.06344929f, 0.07905803f, 0.14739235f, 0.08395546f, 0.12599424f, 
    -0.55340534f, -0.56481504f, -0.32614765f, 0.17352010f, 0.00664597f, 0.03301318f, -0.01925146f, -0.09297188f, 
    -0.03528531f, 0.06390430f, 0.06405567f, -0.09689479f, -0.25316539f, 0.18581016f, 0.00355676f, -0.23796596f, 
    -0.13897878f, -0.24772444f, 0.04309951f, -0.00503584f, 0.01481143f, -0.04837371f, -0.04489070f, 0.00499211f, 
    -0.57319778f, 0.14324023f, 0.13751242f, 0.14947848f, -0.03822931f, 0.05420140f, -0.06535985f, -0.02336733f, 
    -0.17405276f, -0.05434401f, -0.00220848f, -0.10314245f, 0.18016593f, -0.03898560f, -0.26866418f, -0.12516756f, 
    -0.02023006f, -0.05761028f, 0.08531742f, 0.00654517f, -0.05241806f, 0.01853864f, 0.11522348f, 0.04532142f, 
    -0.16162834f, 0.06420779f, -0.02369279f, 0.20683490f, -0.11409306f, 0.05137740f, 0.07053295f, -0.07235671f, 
    -0.04679611f, -0.08512767f, 0.02271495f, 0.19928908f, 0.29810482f, -0.15449552f, 0.13293551f, -0.01986915f, 
    -0.13868012f, 0.08339901f, -0.03899926f, 0.13441616f, 0.00791502f, 0.14897896f, -0.06337258f, 0.13822933f, 
    0.36621532f, 0.04484607f, 0.13994505f, -0.07492698f, -0.02994822f, -0.09424209f, 0.12089580f, 0.03656211f, 
    0.04600014f, 0.11036659f, 0.04626409f, -0.08430809f, -0.41327307f, -0.09039017f, -0.41524786f, -0.23788816f, 
    -0.04615913f, 0.03666724f, -0.00815749f, -0.07566017f, -0.08449078f, -0.07746691f, 0.08546534f, 0.09549789f, 
    -0.16084935f, 0.04737421f, 0.02679780f, -0.04451199f, -0.04851871f, -0.00487022f, -0.08835424f, 0.10671822f, 
    -0.01839493f, 0.02262970f, 0.13349314f, 0.17998824f, -0.38158068f, -0.08833174f, 0.14682095f, 0.34055129f, 
    0.18263429f, 0.26721653f, 0.00358935f, -0.11137823f, 0.05875481f, 0.08463726f, 0.01554945f, -0.12789248f, 
    -0.61881405f, -0.09836655f, -0.25535622f, -0.08336548f, -0.15344724f, -0.10136832f, -0.06346377f, -0.05509914f, 
    -0.04409439f, 0.03041535f, 0.16791897f, 0.06630736f, 0.11841002f, -0.36347488f, -0.34577733f, 0.13384457f, 
    -0.05079898f, -0.00699395f, 0.05379215f, 0.06911524f, 0.02665489f, 0.07108953f, -0.07987692f, 0.07903162f, 
    0.69741368f, 0.02365004f, -0.18399711f, 0.16341618f, -0.01036269f, 0.04688629f, -0.23885536f, 0.01056636f, 
    0.02018365f, 0.10213440f, -0.07195263f, -0.11127833f, -0.00985082f, 0.21548273f, -0.11967681f, -0.20784308f, 
    -0.09687702f, -0.16192362f, 0.08795775f, 0.07073259f, -0.04924565f, -0.31841981f, -0.05392382f, -0.08429084f, 
    -0.08413617f, 0.30583072f, -0.13539684f, 0.07899887f, -0.09376629f, 0.14614259f, 0.08128875f, 0.07249618f, 
    -0.16451444f, 0.04727250f, -0.05139594f, -0.10267904f, -0.29747349f, 0.30570108f, 0.24507898f, 0.10792986f, 
    0.13134366f, 0.10863412f, 0.16502821f, 0.02278618f, 0.01167590f, 0.10614587f, -0.12334207f, 0.12367819f, 
    0.38341135f, 0.00721511f, 0.10728141f, 0.26439747f, 0.16930628f, 0.09571119f, -0.07339630f, 0.10133009f, 
    -0.04781748f, -0.07423074f, -0.36012775f, 0.00442227f, 0.34733340f, -0.09764599f, 0.14796957f, -0.20384054f, 
    0.05571096f, 0.13685723f, 0.22589019f, 0.05109939f, -0.00446521f, -0.02811258f, -0.00326166f, 0.00356275f, 
    -0.20326498f, -0.13915917f, 0.24280676f, 0.42179483f, -0.03431582f, -0.09932359f, 0.10499359f, 0.08506433f, 
    -0.12310214f, 0.07533789f, 0.05289733f, 0.06895377f, -0.43204024f, -0.08345500f, -0.10843586f, -0.09904518f, 
    0.02325915f, 0.01695659f, -0.06927828f, 0.10811505f, -0.01753726f, -0.09578794f, -0.07332789f, -0.03010405f, 
    -0.29440755f, 0.43913433f, -0.19203356f, -0.05401978f, -0.04182889f, -0.11777177f, 0.07746655f, -0.03768131f, 
    -0.10870362f, 0.03961098f, -0.09748155f, -0.10123394f, -0.00544285f, 0.13920341f, -0.21292064f, 0.06739143f, 
    -0.02832728f, -0.10490873f, 0.26254746f, 0.06986443f, -0.01635534f, 0.10459171f, -0.02176920f, 0.13547610f, 
    0.23817413f, 0.24146293f, -0.06984462f, -0.19386634f, -0.17247580f, -0.05529931f, 0.00607989f, 0.14541808f, 
    -0.02111281f, -0.01249671f, 0.11049374f, -0.10700087f, -0.23056100f, 0.34393424f, 0.22636443f, -0.24595992f, 
    -0.00604958f, 0.03992834f, -0.04041224f, -0.06691852f, -0.05154179f, -0.12271808f, 0.11507311f, -0.23431209f, 
    0.17829359f, -0.36956498f, -0.32643357f, 0.37079579f, 0.05712559f, 0.01551272f, 0.00237690f, -0.04577067f, 
    -0.16297349f, 0.14951327f, 0.05005767f, -0.06265966f, -0.02066865f, 0.21967815f, -0.17699428f, 0.04814220f, 
    -0.02699083f, -0.12149791f, 0.19743542f, 0.12796733f, -0.03947242f, 0.07816132f, 0.15875009f, 0.04051032f, 
    -0.23946692f, -0.28325874f, 0.20284978f, -0.01325118f, 0.06060782f, 0.10997711f, -0.05127393f, -0.13067640f, 
    -0.02270650f, -0.08576063f, -0.30877188f, -0.04246274f, 0.36764809f, -0.09358092f, -0.09219074f, -0.07340895f, 
    -0.03072610f, 0.06203780f, 0.08815065f, 0.06116750f, -0.03010515f, -0.09690818f, -0.00657744f, 0.07696275f, 
    -0.26747912f, 0.11012194f, 0.20028743f, -0.00301643f, -0.10859405f, 0.00297757f, -0.04909223f, -0.08067426f, 
    0.07899468f, -0.30236605f, -0.08560722f, 0.00586183f, 0.04759780f, -0.21341710f, 0.00670189f, -0.08377662f, 
    0.03807379f, 0.04343612f, -0.01590648f, 0.11092687f, 0.05717988f, 0.11644319f, 0.03811178f, -0.12397754f, 
    0.22577056f, 0.27317178f, 0.03744633f, 0.17709808f, 0.03372424f, 0.12984823f, 0.00435670f, 0.12099554f, 
    0.15342896f, -0.11541953f, 0.09931684f, -0.03777642f, 0.06576272f, -0.01091271f, 0.23233768f, 0.00989837f, 
    -0.04892618f, 0.07568300f, -0.00621494f, 0.13754201f, -0.13738872f, -0.03733244f, -0.05483553f, 0.32898045f, 
    -0.26580086f, 0.12796506f, 0.10548100f, 0.00528661f, -0.17581309f, 0.03818891f, -0.03491173f, 0.13389963f, 
    0.11819763f, 0.02983403f, -0.07061751f, -0.04826977f, 0.03678143f, 0.03774273f, -0.03862210f, 0.32578096f, 
    0.06845079f, -0.14775966f, 0.14193787f, 0.10086743f, 0.01654499f, 0.01246837f, 0.10312156f, 0.01509780f, 
    -0.92285675f, -0.10253377f, 0.17065048f, 0.03947455f, 0.09092194f, -0.12326387f, 0.00735540f, 0.02407798f, 
    0.21111725f, -0.00233780f, 0.01256674f, -0.20556578f, -0.80669522f, 0.15280579f, -0.03713321f, 0.01819597f, 
    0.03198522f, 0.05042025f, 0.09045573f, -0.04631739f, 0.11185052f, 0.08326935f, -0.07264325f, 0.01178857f, 
    -0.29847461f, -0.01355180f, -0.24714874f, -0.00180864f, 0.08964010f, -0.01879501f, 0.03121917f, -0.04228961f, 
    0.05061275f, 0.01131532f, -0.26598462f, -0.08448181f, 0.17717019f, -0.16724147f, -0.08911782f, 0.01618082f, 
    -0.21275978f, 0.00270302f, 0.19390099f, -0.04376365f, 0.01916944f, 0.03804089f, -0.01219429f, -0.05462460f, 
    -0.03390574f, -0.14377509f, 0.03789246f, -0.19666024f, 0.18974169f, 0.12478607f, -0.00723448f, -0.07468536f, 
    0.01187331f, -0.05679950f, -0.01822514f, -0.01787551f, -0.12711293f, -0.01856987f, -0.30136186f, 0.00595359f, 
    0.03200870f, -0.12029848f, -0.00636590f, 0.04892663f, -0.01793415f, -0.03090097f, -0.05768527f, 0.04407335f, 
    0.45300180f, -0.00909819f, 0.04553594f, 0.51649421f, -0.07694831f, -0.12676127f, 0.07600269f, 0.18280974f, 
    0.08824127f, 0.09771399f, -0.09247670f, 0.08930352f, -0.42570862f, -0.17978431f, 0.25394264f, -0.04229029f, 
    0.22090459f, -0.03227283f, -0.17209899f, -0.10273553f, 0.18836267f, 0.01406205f, -0.11670168f, -0.04277282f, 
    0.26048729f, 0.10211179f, -0.01007785f, 0.13161786f, -0.10050628f, 0.05507941f, 0.01520133f, 0.10731402f, 
    -0.02988370f, 0.12692097f, 0.11623189f, 0.01134596f, 0.12101517f, -0.36394030f, 0.12979726f, -0.01500545f, 
    -0.10800652f, 0.01279166f, 0.19046918f, -0.14448571f, 0.05757581f, 0.13759658f, 0.05903332f, -0.00674190f, 
    -0.02530111f, 0.12401340f, 0.04824524f, 0.38167247f, -0.15496439f, 0.01078884f, -0.16029221f, 0.07532836f, 
    -0.13748527f, 0.08557308f, -0.01628483f, 0.13897516f, -0.38795298f, -0.25017697f, -0.07567317f, -0.06851275f, 
    0.02570202f, 0.10538611f, -0.09018779f, -0.03764629f, -0.11841596f, -0.23127669f, 0.04412300f, -0.12346735f, 
    0.07593475f, -0.34585422f, 0.12025576f, -0.45438340f, 0.10464685f, -0.15517022f, 0.13624923f, 0.12647571f, 
    0.16945045f, 0.27062574f, 0.04293046f, 0.01157307f, -0.48375446f, 0.00846323f, 0.16637625f, 0.14764115f, 
    0.02720999f, -0.05957566f, 0.00298794f, 0.00078872f, -0.03125060f, -0.03322034f, 0.06683391f, 0.05866099f, 
    -0.17182364f, 0.01757868f, 0.36771113f, -0.01470505f, -0.10009756f, 0.13204208f, -0.16278666f, 0.12489050f, 
    -0.02167285f, -0.06538383f, -0.02480725f, 0.08568590f, -0.41872561f, -0.21910638f, 0.20471515f, -0.44659597f, 
    -0.00031882f, -0.05286675f, -0.29505664f, -0.00264878f, 0.00062764f, -0.16104381f, -0.14631586f, 0.06721539f, 
    -0.05830900f, -0.12084258f, -0.28912580f, -0.03989595f, 0.10563750f, 0.16993475f, -0.15970390f, -0.20632151f, 
    0.10872802f, -0.17301352f, 0.02847187f, 0.03187937f, -0.64315784f, -0.00761511f, -0.25455415f, 0.02641777f, 
    0.05611787f, -0.01407465f, 0.13070036f, -0.09402153f, 0.05258294f, 0.18882820f, 0.01054858f, 0.04444401f, 
    -0.58225238f, -0.09342086f, 0.13761875f, -0.05541206f, 0.09306783f, -0.06500275f, -0.02005979f, 0.11842385f, 
    0.03760491f, -0.18774925f, -0.08587427f, 0.08405411f, -0.29379702f, 0.24150899f, 0.21913747f, 0.00344347f, 
    -0.17109644f, 0.08494073f, 0.00118255f, -0.23007472f, 0.02419249f, -0.01965903f, -0.05647763f, -0.12763141f, 
    0.02720538f, -0.03936284f, 0.12741823f, 0.04046850f, 0.11001688f, 0.06845275f, 0.05609524f, -0.07651046f, 
    0.01326320f, 0.13753153f, 0.02913092f, 0.23128244f, -0.18837526f, -0.01561562f, -0.19034900f, 0.30347687f, 
    0.02112134f, 0.05566540f, 0.05489198f, -0.20462044f, 0.04553626f, -0.16796875f, -0.24010795f, 0.15951398f, 
    0.14488663f, 0.04697627f, 0.05820102f, -0.45383945f, 0.07246404f, 0.14752917f, -0.21285813f, 0.04671494f, 
    -0.05406547f, -0.15194559f, 0.08484840f, -0.35598946f, -0.17720975f, 0.23822275f, 0.19852138f, -0.30358550f, 
    0.04171431f, -0.00003160f, -0.24862239f, -0.00698961f, 0.06409863f, -0.10924789f, -0.14307021f, -0.12243094f, 
    0.13926576f, -0.03009716f, 0.08466627f, 0.10330058f, -0.09833831f, -0.12888619f, -0.16382162f, 0.07357989f, 
    -0.05917407f, 0.18966222f, 0.04445083f, 0.12351996f, -0.05497039f, -0.16331062f, 0.02500173f, 0.24483763f, 
    0.21529184f, -0.14658254f, -0.01342627f, -0.17469622f, -0.01106169f, 0.12711550f, 0.07974626f, 0.09133773f, 
    -0.29180381f, 0.20866551f, -0.08059949f, 0.06844842f, -0.04196605f, -0.11147173f, -0.02516557f, 0.15998486f, 
    0.16738011f, 0.26570836f, 0.09500093f, 0.15420721f, 0.34987950f, 0.14816898f, 0.00142815f, -0.08403441f, 
    0.10825607f, 0.03668144f, 0.07787992f, -0.09138455f, -0.04495142f, 0.02012880f, -0.20048477f, 0.01315521f, 
    0.10872491f, 0.05919728f, 0.06291549f, -0.08861800f, 0.07143528f, -0.07360112f, -0.02391057f, -0.10332687f, 
    0.07177401f, 0.34412384f, 0.04140707f, 0.12566549f, -0.20063861f, 0.23560278f, -0.24024871f, -0.15330739f, 
    0.22031914f, -0.02297117f, 0.14438982f, -0.07604265f, 0.20371653f, -0.12285236f, 0.05056647f, -0.08109024f, 
    -0.06603502f, -0.09016258f, -0.03288428f, -0.03332763f, -0.01380777f, -0.11119822f, 0.01273058f, -0.04822630f, 
    -0.05738407f, -0.19985472f, -0.02165954f, -0.07369262f, -0.26791817f, -0.09657345f, -0.10570010f, -0.24138860f, 
    0.16121666f, 0.03457278f, -0.07802964f, -0.35298985f, 0.01277723f, 0.06026376f, 0.11780582f, 0.10943178f, 
    0.11290933f, -0.10133746f, -0.02760455f, 0.21095958f, -0.09097261f, 0.08867488f, -0.01711543f, 0.01308461f, 
    0.01935967f, 0.00819798f, 0.10587742f, 0.19592416f, -0.70805019f, -0.03495666f, -0.22249311f, -0.25464660f, 
    0.03528357f, 0.03507615f, -0.09299179f, -0.20619890f, -0.05192833f, -0.09367410f, 0.07421637f, -0.15930755f, 
    0.11053547f, 0.08389745f, 0.27628586f, -0.03326340f, -0.02564474f, -0.08481942f, -0.06366222f, 0.02267126f, 
    0.18894508f, -0.11661680f, 0.04432030f, 0.12411430f, 0.00654367f, 0.11477710f, 0.05719152f, 0.20070226f, 
    0.08090002f, -0.16350728f, 0.02045025f, 0.03980991f, 0.10511262f, -0.08456260f, 0.01253850f, -0.10541195f, 
    -0.39196241f, -0.21563751f, 0.04633671f, 0.40206796f, -0.18618135f, -0.18952900f, -0.01173896f, 0.10981900f, 
    0.03187922f, 0.05802084f, -0.00216025f, 0.08709455f, -0.26998201f, 0.19602700f, 0.27482471f, -0.14913520f, 
    0.04313201f, -0.08709247f, -0.00003500f, -0.06128020f, 0.14545493f, -0.07219405f, -0.02456650f, 0.06898669f, 
    -0.33872065f, -0.39444399f, -0.04686614f, -0.08960682f, 0.10313576f, 0.07152665f, 0.06923288f, -0.18549660f, 
    -0.10676234f, -0.02448802f, 0.16269976f, 0.05134540f, 0.12497008f, -0.01445937f, 0.19694428f, -0.01516683f, 
    -0.06993780f, 0.01293682f, 0.05432450f, 0.08961922f, -0.14883664f, -0.19471589f, 0.17075002f, 0.06949016f, 
    -0.01497547f, 0.08458219f, 0.08964023f, -0.22889702f, 0.11496003f, -0.20406166f, 0.11814698f, -0.01950667f, 
    -0.15064256f, -0.00245488f, -0.16592026f, -0.01826268f, 0.19143769f, -0.17293888f, 0.10037461f, -0.13022585f, 
    0.00870509f, 0.05768454f, -0.12233958f, -0.11096368f, -0.12055138f, -0.13901082f, 0.00842859f, 0.02723942f, 
    -0.18444790f, 0.01812958f, 0.14443463f, 0.46584165f, -0.06589974f, -0.02529432f, 0.19504294f, 0.11742574f, 
    0.10069352f, 0.18951537f, -0.14773983f, 0.10467828f, -0.46368498f, 0.18585557f, -0.02258213f, -0.33021381f, 
    0.08153339f, 0.06583885f, 0.29836833f, 0.15155610f, 0.14186342f, 0.10512039f, -0.05451887f, -0.06740037f, 
    0.20597099f, -0.01446857f, -0.17705414f, 0.01075957f, -0.06409191f, 0.24199757f, -0.29857028f, 0.17954242f, 
    0.37818104f, -0.19388564f, 0.06244770f, 0.22679457f, -0.02188188f, -0.10563967f, -0.19294085f, -0.33107749f, 
    0.12573789f, -0.08187740f, 0.03271494f, 0.03819686f, 0.00518189f, 0.10899004f, 0.02557033f, 0.06597845f, 
    0.06641296f, 0.01787472f, -0.08122262f, 0.11727674f, 0.01739004f, -0.14628294f, 0.05467322f, 0.02133536f, 
    -0.24884160f, 0.00182426f, 0.35637590f, 0.18013851f, 0.11133138f, 0.08713600f, -0.01654310f, -0.30792984f, 
    0.02400156f, -0.24358976f, -0.01881009f, 0.25389093f, -0.24833967f, -0.20260081f, 0.12079013f, -0.38064909f, 
    0.00258501f, 0.09238128f, -0.60841382f, 0.22400789f, -0.16405679f, -0.05268366f, 0.00613562f, -0.04559325f, 
    -0.02690065f, 0.07367045f, -0.00502971f, -0.08883683f, 0.13195819f, -0.44501922f, 0.03391114f, -0.33240589f, 
    -0.07896534f, 0.09511853f, -0.00269181f, -0.14096351f, 0.21219285f, 0.03607242f, -0.11626200f, 0.13125987f, 
    0.35455340f, 0.07424156f, 0.03167262f, -0.16056637f, -0.13672772f, -0.07885014f, 0.05016905f, -0.01333201f, 
    0.00168279f, -0.02781777f, 0.10332816f, -0.24190922f, 0.23628460f, -0.68349594f, -0.32326224f, 0.07636844f, 
    -0.04799309f, 0.21273348f, 0.03645473f, 0.07895952f, 0.03949504f, -0.08497310f, 0.06442574f, 0.22103482f, 
    0.12341378f, 0.11128987f, 0.09538610f, -0.49325213f, -0.12152708f, 0.05446410f, 0.01290767f, 0.05657512f, 
    0.11722964f, -0.16697890f, 0.02679501f, -0.18320487f, -0.09272940f, 0.19983900f, -0.01564688f, 0.10307015f, 
    -0.12008435f, 0.03250296f, 0.08158125f, 0.10535053f, 0.07695036f, 0.03339384f, 0.16300055f, -0.00594793f, 
    -0.52311140f, -0.07808261f, 0.05659798f, -0.33410022f, -0.02948702f, -0.00871583f, 0.06400889f, 0.04540901f, 
    0.08322931f, 0.07082252f, 0.01785794f, 0.20202926f, 0.33944198f, -0.14100017f, 0.32359639f, -0.18276745f, 
    -0.01165134f, -0.00453898f, 0.02353768f, 0.12454852f, 0.00249637f, -0.07650552f, 0.04659716f, 0.15566555f, 
    0.31751814f, -0.03822067f, 0.15587187f, -0.09008756f, 0.08764155f, -0.03002352f, 0.10306682f, 0.05644900f, 
    0.03405893f, -0.20140657f, -0.12362047f, -0.31424290f, 0.10719895f, -0.40304402f, -0.33363745f, 0.13476545f, 
    -0.07274693f, 0.04665392f, -0.16407943f, -0.12307958f, -0.08169897f, 0.04406786f, 0.16275491f, -0.02451976f, 
    -0.33183157f, -0.18931736f, -0.04171850f, -0.18931001f, 0.01948502f, -0.00908382f, -0.00439617f, -0.21577378f, 
    -0.11440307f, -0.08092235f, 0.00358145f, -0.34311730f, -0.44986019f, 0.20746212f, 0.26312977f, 0.00900154f, 
    -0.12730849f, 0.09761301f, 0.00339910f, 0.09328071f, -0.09852602f, -0.00515688f, 0.19821481f, -0.04076557f, 
    -0.08037660f, 0.34096277f, -0.03044586f, -0.38187438f, -0.15728503f, 0.20439194f, 0.05141188f, 0.13181850f, 
    0.00851827f, -0.13179870f, -0.18335842f, -0.26213068f, 0.01227103f, -0.18518360f, -0.06941919f, -0.23647304f, 
    -0.09139881f, -0.02177308f, -0.02746964f, 0.17355818f, -0.04183266f, 0.15060204f, 0.04183418f, 0.06932332f, 
    -0.03703014f, 0.33858061f, 0.10664869f, -0.17257690f, -0.04643822f, 0.01583388f, -0.03030024f, -0.00910376f, 
    -0.06350730f, 0.19002025f, 0.14099783f, 0.16236758f, -0.61818743f, -0.29650977f, -0.04023465f, -0.03556195f, 
    0.01834142f, 0.08407359f, -0.10290202f, 0.05638833f, -0.04371053f, 0.00151514f, -0.03684729f, 0.06866597f, 
    -0.10452607f, 0.01064416f, 0.21876468f, 0.10042322f, 0.22425409f, 0.01424519f, 0.05635782f, 0.01028754f, 
    -0.06887095f, -0.01029984f, -0.14286856f, -0.09281383f, 0.14043796f, -0.32898161f, 0.04126946f, -0.20743555f, 
    -0.17973597f, -0.11474603f, 0.04897703f, 0.03627744f, 0.10447707f, 0.07851397f, -0.00842643f, 0.13977358f, 
    -0.03036595f, -0.21614704f, -0.08730975f, -0.14346990f, -0.09576489f, 0.02970069f, 0.03241491f, 0.01146853f, 
    -0.04437514f, 0.06985735f, 0.01320149f, -0.10175641f, -0.18729781f, -0.44886199f, -0.38055226f, 0.31292376f, 
    0.16536641f, 0.06714606f, -0.11515969f, 0.06394141f, 0.06754608f, 0.02049848f, -0.02937581f, 0.09358568f, 
    0.04885886f, 0.01375842f, -0.34897134f, 0.05324656f, 0.03068966f, 0.07431351f, -0.04560294f, 0.07852520f, 
    -0.10935692f, -0.15555315f, -0.11609481f, -0.00646456f, -0.02104387f, -0.26363054f, 0.36656809f, -0.01123386f, 
    -0.05019264f, -0.01436068f, -0.08467937f, 0.11892456f, -0.03416887f, -0.00946754f, 0.05676142f, -0.03086674f, 
    -0.21755837f, 0.17620759f, -0.01406646f, -0.02805470f, -0.29901552f, 0.08140132f, 0.02447505f, 0.13951391f, 
    -0.01253673f, -0.09636969f, 0.05805838f, -0.13619559f, 0.50911874f, 0.24198559f, 0.03918270f, -0.25881618f, 
    -0.06519738f, 0.03678795f, 0.01733202f, 0.05809953f, -0.00900658f, 0.04255860f, -0.11883894f, 0.07403311f, 
    -0.09409219f, 0.15020646f, 0.12676881f, -0.13780156f, -0.05317107f, -0.00746276f, 0.10894399f, 0.04284984f, 
    0.03080144f, 0.02020683f, 0.05528016f, 0.17159478f, -0.71987700f, 0.45338517f, 0.17846008f, 0.14171486f, 
    -0.07356779f, 0.09977322f, 0.11992643f, 0.05567213f, 0.00760127f, 0.07348417f, 0.06613646f, 0.07460425f, 
    -0.05570477f, 0.11670621f, -0.15118685f, -0.34085548f, 0.01633853f, 0.04308162f, 0.03282072f, -0.09853970f, 
    -0.30470783f, 0.02249788f, 0.17559882f, -0.12937815f, 0.25559753f, -0.10669117f, 0.06172005f, 0.05900922f, 
    -0.06277862f, 0.01503712f, -0.07977114f, -0.22945386f, -0.09831558f, -0.04673120f, -0.09611854f, 0.02255110f, 
    0.10609699f, -0.03234399f, 0.34895995f, -0.03010581f, 0.06706060f, -0.09151985f, 0.11424490f, -0.21473831f, 
    0.04024168f, -0.05443566f, -0.20458646f, -0.32670209f, 0.18858761f, 0.10715406f, 0.01071127f, 0.23550142f, 
    -0.03367983f, 0.23374353f, 0.12363383f, 0.01308160f, 0.00899251f, 0.00060998f, 0.07990590f, -0.00971041f, 
    -0.07489993f, -0.13206297f, -0.09772344f, -0.12802990f, 0.03023294f, 0.01671560f, 0.01123591f, 0.02353629f, 
    0.01859730f, -0.16010807f, -0.08855016f, 0.03400882f, 0.31260952f, -0.11195710f, 0.45737678f, -0.27714989f, 
    0.08548886f, -0.05946056f, 0.13032584f, -0.01944762f, -0.01761242f, 0.07103272f, 0.11508494f, 0.26896691f, 
    0.03548010f, 0.30872524f, 0.06333136f, 0.29464746f, 0.19747108f, 0.03544023f, 0.14168823f, 0.04157803f, 
    0.11110787f, 0.00369500f, 0.05343951f, 0.01381552f, 0.28894961f, 0.14850903f, 0.22416015f, 0.26156503f, 
    0.20682728f, 0.14406370f, 0.14288895f, 0.07716393f, -0.04547197f, 0.06448340f, -0.13595837f, -0.08980460f, 
    0.17941204f, 0.26117128f, 0.13659586f, -0.09813123f, -0.24865755f, 0.03336475f, -0.12693734f, 0.01407377f, 
    0.00113412f, 0.06610510f, -0.05805924f, -0.00696102f, 0.05969175f, 0.30888608f, 0.04562339f, 0.01408259f, 
    0.01292400f, -0.03296399f, 0.01249469f, -0.08225600f, 0.01567383f, -0.07990176f, 0.19981335f, -0.03172708f, 
    -0.54811376f, 0.27195612f, 0.05950236f, -0.09415273f, -0.20133621f, 0.03299693f, -0.03542628f, -0.10879031f, 
    -0.01213782f, -0.02289715f, -0.05899166f, -0.13653791f, -0.38594773f, -0.02839533f, -0.00493335f, -0.09855510f, 
    -0.19808358f, -0.10215124f, -0.09887465f, -0.05577304f, 0.00295485f, -0.04118941f, -0.15638880f, 0.01602675f, 
    0.23884593f, 0.11957572f, 0.11446415f, 0.25927362f, -0.01156405f, -0.02416713f, -0.08771521f, -0.01137314f, 
    -0.11499789f, -0.00228008f, -0.09131268f, -0.00286610f, -0.02339096f, -0.04055431f, -0.11288071f, -0.13569759f, 
    -0.09764905f, 0.03700942f, 0.04045122f, -0.20998250f, 0.05455876f, -0.00789580f, -0.07241675f, -0.14271000f, 
    0.31420729f, -0.40097532f, 0.13147685f, 0.14118418f, 0.04601346f, -0.21495591f, 0.00951860f, -0.05476090f, 
    -0.02895530f, -0.06470491f, -0.08279092f, -0.06946693f, 0.35264003f, 0.08778982f, 0.00353315f, 0.29672149f, 
    0.04049611f, -0.07974630f, -0.01655653f, 0.09032565f, 0.08328682f, -0.14773111f, 0.01855482f, -0.10905296f, 
    -0.15091266f, 0.20508739f, 0.19778100f, 0.02434148f, -0.11045179f, -0.09258482f, -0.07650866f, -0.06662045f, 
    -0.04987822f, -0.03994480f, -0.05215792f, -0.10431190f, -0.15051678f, -0.02216304f, -0.08224148f, -0.26397753f, 
    -0.15478747f, 0.11356233f, -0.06110553f, -0.08580314f, 0.07410367f, -0.10169943f, 0.10280150f, -0.18109593f, 
    0.00737322f, 0.15563406f, 0.06629144f, -0.03767234f, -0.13539536f, 0.01069558f, -0.03741801f, -0.00610867f, 
    0.01738293f, -0.01638677f, 0.01583897f, 0.01750798f, 0.25968951f, -0.06755014f, 0.26036599f, 0.19323424f, 
    0.11707586f, 0.05936296f, 0.09855886f, 0.01013605f, -0.17825617f, -0.07421752f, -0.05162178f, -0.15299936f, 
    -0.15275632f, -0.12771162f, -0.16917165f, -0.34027079f, -0.09557026f, 0.01981209f, -0.03927270f, -0.05732960f, 
    -0.07629193f, -0.02910321f, 0.01251177f, -0.12909411f, -0.20398018f, 0.09007430f, 0.04920107f, 0.02071717f, 
    0.04002613f, -0.03743267f, 0.06911700f, -0.08978510f, 0.01633576f, -0.09605894f, 0.00951506f, -0.08424904f, 
    0.17096570f, -0.58948594f, -0.04813270f, 0.04732371f, -0.02667497f, -0.00728656f, 0.07520506f, -0.00336536f, 
    -0.05778157f, -0.09418411f, -0.00788316f, 0.04902881f, -0.21771821f, 0.21078320f, 0.21404240f, 0.00431605f, 
    0.07273138f, 0.09278586f, 0.03705387f, -0.10327772f, -0.08398490f, 0.13154657f, -0.02758171f, -0.01201376f, 
    -0.03229401f, 0.09633579f, -0.20873550f, -0.10394549f, -0.15862174f, -0.01474369f, 0.02700078f, -0.09571511f, 
    -0.10682516f, -0.08822878f, -0.06852268f, -0.01362403f, -0.00913521f, 0.16458772f, -0.03890853f, 0.17234573f, 
    -0.07420409f, -0.01687153f, -0.05245812f, -0.04366438f, -0.07959225f, 0.01106926f, -0.03731761f, -0.10629608f, 
    0.19890101f, 0.14324144f, -0.16522197f, 0.31221366f, -0.03590061f, -0.08116884f, 0.00526855f, 0.01010498f, 
    -0.07834861f, -0.04171155f, -0.11889623f, -0.02320811f, -0.25975892f, 0.06829933f, -0.00039307f, 0.00784301f, 
    -0.07521186f, 0.00249264f, -0.03133004f, -0.11073290f, -0.04244462f, 0.02989849f, -0.20201941f, -0.21543910f, 
    0.26405320f, 0.08386336f, 0.29533932f, 0.16830678f, 0.10355688f, -0.01667171f, -0.00786344f, -0.06332736f, 
    0.04341516f, -0.07431217f, -0.11084361f, -0.08101889f, 0.01237753f, -0.22673053f, -0.43117714f, 0.00873592f, 
    -0.16692939f, -0.04284210f, -0.06275444f, -0.11853412f, -0.00725287f, -0.05644232f, -0.08220068f, -0.04344089f, 
    -0.07471766f, -0.01286922f, -0.03321873f, -0.28488523f, -0.12609755f, 0.02924017f, -0.05608281f, -0.12053898f, 
    -0.05690717f, -0.06687739f, 0.03491632f, 0.08698235f, -0.08476442f, 0.01371263f, -0.07422952f, -0.13524954f, 
    -0.11897314f, 0.00972391f, -0.11908856f, -0.00784498f, -0.09700238f, -0.04134912f, 0.00612354f, -0.06231612f, 
    -0.55617839f, 0.12353513f, -0.02852193f, 0.21885569f, 0.00234035f, -0.05347560f, -0.18861476f, -0.00091473f, 
    -0.07683317f, 0.03425590f, 0.07452016f, -0.05692660f, -0.30010319f, 0.07671164f, 0.19596322f, -0.03482382f, 
    0.10296513f, -0.01913607f, 0.08477937f, 0.08879808f, -0.13143083f, 0.02066139f, 0.24241991f, 0.02814433f, 
    -0.00722244f, -0.05747525f, -0.03304901f, -0.18599837f, 0.11907665f, -0.07217029f, 0.05903696f, -0.16255037f, 
    -0.05931782f, -0.04271534f, 0.06390575f, -0.02807450f, 0.33323580f, -0.48024023f, 0.22543561f, -0.09637281f, 
    -0.00648751f, -0.09534509f, -0.03084770f, -0.05715897f, 0.01014385f, -0.02617134f, -0.06844184f, 0.03572466f, 
    0.16262843f, -0.09329317f, -0.01983788f, 0.32304388f, 0.01927520f, -0.12538591f, -0.08752818f, -0.05664268f, 
    0.00522271f, 0.02346995f, -0.06329883f, -0.22540525f, 0.29079938f, 0.06567304f, -0.06929863f, -0.12531003f, 
    -0.11462408f, -0.02248920f, -0.04674587f, -0.07489266f, 0.10775698f, 0.06063802f, -0.01268129f, -0.11577599f, 
    -0.04156419f, 0.19619727f, 0.02683801f, 0.00486435f, -0.13294494f, 0.06863334f, -0.03296661f, -0.09279190f, 
    -0.05483759f, 0.03680478f, -0.04731491f, 0.07287430f, -0.25326291f, -0.11545140f, 0.19814786f, -0.22463804f, 
    -0.07520659f, -0.06386049f, 0.23569527f, -0.17150356f, -0.03109494f, -0.11183652f, -0.09505786f, 0.01361046f, 
    -0.17075077f, 0.37429604f, -0.11649109f, -0.18821776f, 0.05645138f, -0.05421072f, -0.04890376f, 0.12584057f, 
    0.07385383f, -0.10445616f, 0.00509713f, 0.13843299f, 0.25277159f, -0.09973516f, -0.00696332f, 0.15566246f, 
    -0.12216081f, -0.11350398f, -0.11079744f, 0.02897415f, -0.01756319f, -0.19610320f, -0.13838029f, -0.21566349f, 
    0.09603974f, -0.06346103f, 0.09602092f, 0.31068358f, -0.05718169f, -0.01574684f, -0.06896529f, -0.09978067f, 
    0.02622210f, -0.00457286f, 0.11586986f, 0.07487670f, 0.07497045f, 0.13458861f, 0.09531076f, 0.08376314f, 
    0.08420551f, 0.11072331f, -0.06159804f, -0.12194815f, -0.07738638f, 0.01569394f, -0.02049052f, 0.12029166f, 
    -0.47046298f, 0.10179736f, 0.14285274f, 0.04539136f, -0.21800739f, -0.08666627f, -0.08483216f, -0.00435398f, 
    0.00920627f, -0.10895038f, -0.13374473f, -0.21940175f, 0.19652332f, 0.05230100f, 0.04071362f, 0.21225542f, 
    -0.02702833f, -0.06273121f, -0.00040268f, 0.00149460f, -0.05801012f, -0.13545127f, 0.13119459f, -0.16008660f, 
    0.31977972f, -0.26430240f, -0.01851197f, -0.20016050f, 0.05701154f, -0.04351685f, 0.02930629f, -0.00834808f, 
    0.10668906f, 0.22477920f, 0.07320312f, 0.00076824f, 0.06298092f, -0.11190207f, -0.09958184f, -0.32616091f, 
    0.08873804f, -0.05616755f, -0.12430520f, 0.11550177f, 0.06687871f, 0.10089657f, -0.03236149f, 0.13221464f, 
    0.15446658f, -0.25231534f, 0.23131125f, 0.10405651f, -0.03395893f, 0.05981341f, 0.07341038f, -0.06753720f, 
    -0.01829553f, 0.06665489f, 0.17988504f, 0.05961415f, 0.22392333f, -0.05805605f, -0.18907793f, 0.18250987f, 
    0.15556154f, -0.26821691f, -0.07965242f, -0.05514303f, 0.04328511f, 0.15846135f, -0.35065651f, -0.07978137f, 
    -0.04974375f, -0.32123691f, 0.22203644f, 0.22187413f, 0.10848553f, -0.13030110f, 0.02859867f, -0.09430254f, 
    0.03944076f, 0.12466527f, 0.03203154f, -0.05806665f, -0.27133399f, -0.34983325f, 0.12383936f, 0.01318137f, 
    -0.01952772f, -0.01915490f, 0.14409421f, -0.34120375f, -0.07033319f, 0.10928494f, -0.10378633f, 0.04127765f, 
    0.16864187f, -0.15584335f, -0.12115994f, 0.19813684f, 0.21977660f, 0.01619047f, -0.07310675f, 0.02443225f, 
    0.03387593f, -0.08100794f, 0.05893387f, -0.13464543f, -0.24055757f, -0.06882381f, 0.23121591f, 0.17520730f, 
    -0.15707070f, 0.06525760f, -0.20911376f, -0.22541063f, 0.00077936f, 0.03825225f, 0.01861061f, -0.09208777f, 
    0.33225954f, -0.06561428f, -0.52699941f, 0.15842333f, 0.07302618f, -0.04034359f, 0.08774554f, -0.07702653f, 
    -0.00953518f, 0.01642066f, 0.19153294f, 0.08753217f, 0.00322917f, -0.21631151f, 0.38149607f, 0.01409315f, 
    -0.08479090f, -0.16783586f, -0.03110469f, 0.08820938f, -0.00524255f, -0.02186406f, 0.06501436f, -0.24859571f, 
    -0.09492259f, 0.13128285f, 0.05651410f, -0.04736320f, -0.13054566f, -0.06708952f, -0.08158372f, -0.03936478f, 
    0.03059433f, -0.09240128f, 0.02592954f, 0.06149409f, -0.16411030f, 0.16886580f, -0.37283504f, -0.15336113f, 
    -0.00412218f, 0.04346999f, -0.13447607f, -0.06644463f, 0.17693394f, 0.02342861f, 0.06346242f, -0.30614957f, 
    0.19263597f, 0.35417420f, -0.28277853f, -0.22265837f, 0.02174293f, -0.04829409f, 0.15215217f, 0.01791430f, 
    0.06091775f, -0.01521140f, -0.03343850f, 0.14536758f, 0.21463498f, 0.13516851f, 0.03356919f, 0.14636666f, 
    -0.00051194f, 0.00430862f, 0.08540439f, -0.13718042f, -0.05147358f, -0.05464237f, 0.08268024f, -0.01212083f, 
    -0.25000158f, 0.11805823f, 0.03718214f, -0.04991886f, 0.19949611f, -0.11496790f, 0.02292339f, -0.04522190f, 
    0.07804103f, 0.01572050f, 0.16508320f, 0.04810208f, -0.26608604f, -0.00436413f, -0.30007330f, 0.01546141f, 
    0.02920171f, -0.07688542f, 0.03461805f, -0.08208258f, -0.04435373f, 0.00305683f, 0.14703727f, 0.07213397f, 
    0.25562978f, 0.01694360f, -0.06070842f, 0.02414300f, 0.09878069f, -0.13906589f, 0.01649413f, 0.02221382f, 
    0.06938402f, -0.09645435f, -0.17924838f, -0.08045997f, 0.21393578f, 0.06458119f, -0.17263633f, -0.03550008f, 
    0.09194070f, -0.11218363f, -0.23647192f, -0.03998475f, -0.00244159f, 0.01918681f, 0.05282675f, -0.03572582f, 
    -0.29352605f, -0.03441222f, -0.09264453f, -0.01373537f, 0.10410594f, -0.00875928f, -0.04429165f, 0.00479804f, 
    0.16258635f, 0.03998068f, -0.01111203f, -0.14024471f, -0.09207445f, 0.01296423f, 0.01129797f, 0.14849368f, 
    -0.18252595f, -0.05860705f, 0.10378155f, 0.02541102f, 0.04179433f, 0.01313963f, -0.12933062f, 0.09160818f, 
    0.17016558f, -0.11812906f, 0.09630253f, 0.05037414f, -0.09802931f, -0.12518129f, -0.13462852f, -0.00755904f, 
    -0.11020430f, -0.10463739f, 0.10594346f, -0.02713175f, -0.32607040f, -0.11267180f, -0.07023816f, -0.19822535f, 
    -0.09503900f, 0.01208820f, -0.01211483f, -0.33060378f, 0.06006708f, 0.09664724f, -0.11768278f, 0.18686000f, 
    -0.18838380f, -0.22493100f, -0.27566728f, -0.42204088f, -0.03014610f, -0.01445674f, -0.03284177f, -0.04687667f, 
    0.13948718f, -0.05422800f, 0.08579329f, -0.14243390f, 0.26295981f, -0.21521351f, 0.01543561f, -0.13049771f, 
    -0.06501898f, -0.08488780f, 0.00145079f, -0.03388673f, -0.03005602f, 0.05390192f, -0.07832824f, -0.08338758f, 
    -0.32281864f, -0.43444702f, 0.22794272f, -0.15317439f, 0.13936016f, 0.02847110f, 0.07008755f, 0.13440466f, 
    -0.08372015f, -0.06927553f, 0.02515516f, 0.09635798f, 0.53543949f, 0.01419822f, -0.10983856f, 0.28182125f, 
    0.24679756f, -0.13453345f, -0.10841423f, 0.17421244f, -0.21703927f, -0.02385462f, 0.18082857f, 0.01547311f, 
    -0.55038655f, 0.03977686f, -0.23752226f, 0.14996836f, 0.03428382f, 0.04379829f, -0.02726514f, -0.08467195f, 
    0.01847545f, 0.01620414f, 0.03510911f, 0.03111299f, 0.04025926f, -0.11837857f, 0.16787173f, -0.07512426f, 
    0.25375956f, -0.04187367f, -0.02127923f, -0.10744225f, -0.03421719f, 0.03468826f, 0.17104447f, 0.20053737f, 
    -0.39713305f, 0.39487699f, -0.43790412f, -0.34433922f, 0.22314207f, -0.11941598f, 0.02655557f, -0.01909245f, 
    -0.00488475f, 0.10886595f, -0.07426184f, -0.17845637f, 0.30879736f, 0.17238334f, 0.16811788f, -0.36547506f, 
    0.13956597f, -0.13360436f, -0.02436543f, 0.10463247f, 0.08437809f, 0.09149598f, 0.16923577f, -0.02253578f, 
    -0.02460311f, -0.04059982f, -0.05199279f, 0.16031125f, -0.12788558f, 0.09744358f, -0.00772625f, 0.15257113f, 
    -0.07967496f, 0.05966345f, 0.16714007f, 0.10567453f, -0.20273989f, 0.07976853f, -0.15151496f, -0.17783737f, 
    0.04943363f, 0.04502955f, 0.17070009f, -0.14011009f, -0.02470786f, -0.04368781f, -0.03087952f, 0.12520100f, 
    0.22649089f, -0.05106646f, -0.01086135f, -0.06990431f, 0.01830473f, -0.01829065f, 0.16046320f, -0.05140606f, 
    0.12662615f, -0.00569809f, -0.12677628f, -0.26141793f, -0.12941964f, -0.12575814f, 0.01137593f, -0.02002299f, 
    -0.15002480f, 0.06870569f, 0.12575570f, 0.13740557f, 0.02737629f, 0.03618286f, 0.11908510f, -0.03905537f, 
    0.18395020f, 0.12011235f, -0.32986128f, -0.34488624f, 0.03925892f, -0.12912087f, 0.00047010f, -0.10996997f, 
    -0.06751582f, 0.02598679f, -0.15850548f, -0.02706422f, -0.05083688f, 0.16554599f, 0.25617394f, 0.04519754f, 
    0.17069717f, 0.12864277f, 0.08915216f, -0.27514869f, -0.10619844f, -0.15732194f, 0.25990781f, 0.09215701f, 
    -0.19359984f, 0.01643376f, 0.08269666f, -0.34617546f, 0.03903488f, -0.00025751f, -0.01077355f, -0.08090493f, 
    -0.13650574f, -0.12771152f, -0.11434922f, -0.06826945f, 0.01448113f, -0.20396569f, -0.13057272f, 0.20693812f, 
    0.02790055f, 0.09697483f, 0.05689495f, -0.28141549f, 0.04608683f, -0.01369622f, 0.16173166f, -0.31545505f, 
    -0.16855046f, 0.04980035f, 0.22620624f, -0.37619653f, -0.07880024f, 0.13889964f, -0.00663141f, -0.04005230f, 
    -0.04156394f, -0.03587968f, -0.19209601f, 0.06472673f, 0.11667466f, -0.68495643f, -0.12779050f, -0.08724071f, 
    -0.01775298f, 0.01734307f, 0.21087779f, 0.20031045f, -0.07007144f, -0.14635965f, 0.05889228f, -0.18232726f, 
    0.23854418f, -0.23338787f, 0.22252111f, -0.15474825f, 0.01764761f, 0.02378038f, 0.01596504f, 0.04782809f, 
    -0.06253214f, -0.00238274f, -0.23613919f, 0.02154431f, 0.12357682f, -0.16246307f, 0.05688787f, 0.38702404f, 
    0.15222116f, -0.03229677f, -0.20651203f, 0.02561504f, 0.15601596f, 0.23550557f, -0.15436928f, -0.01509973f, 
    -0.12086167f, 0.68813860f, -0.25611511f, 0.15366173f, 0.07929592f, 0.15033551f, -0.01438349f, 0.18781841f, 
    -0.12642288f, 0.00554408f, 0.05351952f, 0.04834995f, -0.35597563f, 0.18388489f, 0.27771994f, 0.06537699f, 
    0.05769300f, 0.12045847f, -0.06698150f, -0.06433281f, -0.12089396f, -0.03666319f, -0.04387173f, 0.09525701f, 
    0.05897433f, 0.20440343f, 0.14319934f, -0.03067923f, 0.01299219f, -0.14530772f, -0.04214483f, -0.09759029f, 
    0.03194219f, 0.09941041f, 0.21403573f, 0.14147560f, -0.21732299f, 0.59959143f, -0.57451850f, 0.04046103f, 
    0.05645470f, 0.03063356f, 0.02319974f, 0.07238320f, -0.06853081f, -0.00606390f, -0.02666164f, -0.19855292f, 
    -0.21486007f, -0.53189826f, -0.18284288f, -0.20016159f, 0.05752245f, -0.03318384f, -0.14279109f, -0.10173741f, 
    -0.14997111f, -0.18572247f, -0.10993259f, -0.14249295f, -0.39050803f, 0.26917619f, -0.23841907f, -0.48971862f, 
    0.00349310f, -0.00591778f, 0.08881894f, -0.06022862f, 0.00841625f, 0.00482863f, 0.05351966f, 0.06499933f, 
    -0.01336474f, -0.14239991f, 0.05973846f, 0.06397956f, 0.00708502f, 0.08803046f, 0.00038860f, -0.25195777f, 
    0.07556488f, -0.05607876f, -0.02387203f, 0.05173385f, 0.00067323f, -0.01515754f, -0.05718027f, 0.10629100f, 
    -0.01152652f, -0.02339062f, 0.11672161f, -0.04333897f, 0.02536647f, 0.07253339f, -0.14884177f, -0.03391244f, 
    -0.27368140f, 0.08844188f, -0.04512434f, -0.45961338f, -0.16902128f, 0.22615673f, -0.10393495f, -0.11025802f, 
    -0.02092357f, -0.18761574f, 0.04183970f, 0.06771208f, -0.22107717f, -0.25075936f, -0.01511734f, 0.22772641f, 
    0.13168627f, 0.01825359f, -0.07887660f, -0.07705136f, -0.16487747f, -0.04442431f, 0.09273738f, -0.04694494f, 
    0.06196662f, -0.03453452f, 0.13103029f, 0.43123296f, -0.15337272f, 0.02875641f, 0.13441184f, -0.03124592f, 
    -0.24687886f, 0.02622503f, 0.15489702f, -0.14764017f, 0.33270225f, -0.30320707f, -0.13678777f, 0.20201932f, 
    -0.31572193f, -0.12968102f, 0.14169043f, 0.12142868f, 0.10892348f, -0.00166392f, 0.03567939f, -0.05641605f, 
    0.05046649f, 0.10905504f, -0.17297472f, -0.32249850f, 0.06229090f, -0.12411839f, 0.12655632f, 0.01491802f, 
    0.11506183f, 0.02082767f, -0.26204261f, 0.03326253f, -0.07298841f, 0.30610231f, -0.29630798f, -0.00494545f, 
    0.05827527f, 0.13164014f, 0.17410897f, -0.12673196f, -0.03773017f, 0.27331865f, 0.04592715f, 0.17364348f, 
    0.06144475f, 0.08459298f, -0.09467293f, 0.02710782f, -0.14199288f, -0.04428834f, -0.03542395f, -0.13202573f, 
    -0.01763423f, -0.01102474f, 0.13011600f, -0.03596100f, 0.07989848f, 0.10325330f, 0.02083904f, 0.06133745f, 
    -0.12254415f, 0.05732947f, 0.09241959f, -0.06118796f, 0.02512418f, -0.12195611f, 0.01109829f, -0.09728918f, 
    -0.17671245f, -0.37356704f, -0.16105528f, 0.04802647f, 0.10547979f, 0.16970544f, -0.05784534f, 0.16776590f, 
    0.02412179f, -0.03170626f, 0.04299007f, 0.25699708f, 0.08830085f, 0.18298654f, -0.27165109f, -0.12075983f, 
    -0.08065028f, -0.01605445f, -0.17708139f, -0.04696191f, -0.01527842f, 0.01717759f, -0.16194616f, -0.17917672f, 
    -0.75881863f, -0.26684567f, -0.28861079f, -0.41390973f, -0.00593718f, -0.03561759f, -0.09130889f, 0.02541177f, 
    0.07959187f, 0.00149425f, 0.15801859f, 0.04717918f, -0.54525316f, -0.31170985f, 0.17214234f, -0.09117202f, 
    0.16546507f, 0.07265744f, -0.00702487f, -0.19992213f, 0.14641131f, 0.01758442f, -0.01390385f, 0.15417638f, 
    0.02102916f, -0.07871417f, -0.04209040f, 0.09989585f, 0.01058426f, 0.03932616f, 0.07914231f, 0.06537893f, 
    0.18256906f, -0.06783523f, -0.07845305f, -0.06004200f, 0.01388275f, -0.09986717f, -0.22611912f, -0.10701087f, 
    -0.00315631f, -0.09243532f, -0.08096358f, 0.05461941f, -0.13282849f, -0.00261797f, -0.21258996f, 0.01530007f, 
    -0.05034325f, 0.26570463f, -0.00931620f, 0.02418904f, 0.00400618f, 0.02016730f, 0.02282630f, 0.07905094f, 
    0.02163562f, 0.28193128f, 0.18360400f, 0.10463490f, 0.21747722f, -0.02229350f, -0.03983505f, -0.32359385f, 
    0.14968531f, -0.00867283f, -0.15533198f, 0.16545686f, -0.13683504f, -0.03196472f, -0.03458022f, 0.17461103f, 
    -0.15993647f, -0.09409315f, -0.00071047f, 0.23667422f, -0.01775469f, 0.01120977f, 0.08870250f, 0.16131036f, 
    0.05159011f, 0.05821300f, 0.07677279f, 0.15232942f, -0.66108334f, -0.23799738f, -0.10353273f, -0.02525016f, 
    0.09562986f, -0.05938091f, 0.02326879f, -0.09802991f, 0.07603513f, 0.02988273f, 0.03049764f, 0.19885962f, 
    -0.74877107f, -0.36217105f, 0.17725694f, -0.22159672f, -0.03803962f, -0.20388083f, -0.08386614f, -0.15367579f, 
    0.16865915f, 0.13729887f, -0.03597710f, -0.00446338f, 0.03398593f, 0.11012322f, -0.08412989f, 0.12542586f, 
    0.00534864f, 0.06127778f, -0.01062334f, -0.16840686f, -0.09160677f, -0.23020001f, -0.08503789f, -0.07329662f, 
    -0.53625995f, -0.31523600f, -0.08277564f, -0.22016875f, 0.18458585f, 0.03957848f, -0.01160402f, -0.05450385f, 
    0.05697859f, -0.01913647f, 0.03219762f, 0.04051780f, 0.25101694f, 0.11179537f, 0.05550157f, 0.00960784f, 
    -0.02855406f, -0.08263988f, 0.00643231f, -0.02737685f, -0.06203276f, -0.01665530f, -0.16657799f, 0.02660600f, 
    -0.82572997f, -0.20447907f, -0.08900091f, -0.08122185f, 0.05887476f, -0.00298984f, -0.03086130f, 0.09197672f, 
    0.07066684f, 0.03589393f, -0.06800510f, 0.13713245f, 0.42320329f, 0.22336571f, -0.16469395f, 0.02335249f, 
    -0.13010085f, -0.25012240f, 0.04736758f, 0.13318554f, -0.10197809f, -0.19105655f, -0.00610389f, -0.08548337f, 
    -0.31511927f, -0.02287594f, 0.02177134f, 0.07589778f, 0.09809791f, -0.07288607f, 0.07959003f, 0.07048138f, 
    0.08255862f, -0.04462139f, -0.01664101f, -0.08134482f, -0.40552697f, -0.21722201f, 0.30149898f, 0.14088464f, 
    0.01133067f, 0.22891335f, 0.00800021f, -0.19075085f, 0.12354875f, -0.03616853f, 0.11134477f, -0.04825471f, 
    0.12936161f, -0.00169518f, -0.09332372f, 0.09573776f, 0.16909219f, 0.15319756f, 0.04731354f, -0.04247622f, 
    0.06613158f, 0.08138487f, -0.09187756f, 0.02925074f, -0.18366554f, -0.29758000f, -0.11907257f, 0.06994002f, 
    -0.04272502f, 0.02040336f, 0.10108466f, -0.00844978f, 0.05221691f, 0.15955412f, 0.13527523f, 0.09168056f, 
    0.30436948f, 0.11896616f, -0.13766764f, -0.18266095f, 0.07358649f, 0.09059496f, 0.06357526f, 0.03315940f, 
    0.08940688f, 0.02225747f, 0.02283616f, 0.01620753f, 0.15644372f, -0.01561042f, 0.01006175f, -0.25551176f, 
    -0.07693954f, -0.09509388f, -0.02123941f, 0.08943983f, -0.02888661f, -0.00741831f, 0.04676287f, -0.00943798f, 
    -0.15395668f, -0.10605466f, -0.23662674f, -0.24936913f, 0.13849257f, -0.00435182f, -0.05617595f, 0.02592381f, 
    -0.01615965f, -0.10113958f, -0.14999902f, -0.04462297f, -0.88312376f, -0.45063725f, 0.03325460f, -0.10659908f, 
    0.05819445f, 0.08041360f, -0.11651863f, -0.19671348f, 0.12473051f, -0.23235114f, -0.00081048f, 0.04764491f, 
    0.16158827f, 0.11047646f, -0.00692050f, -0.29913992f, 0.27301449f, -0.15509056f, 0.11589305f, 0.08686657f, 
    0.06670031f, -0.06544137f, 0.07158209f, 0.12051938f, 0.36340657f, 0.00415361f, -0.16639535f, 0.16314255f, 
    -0.03715619f, -0.05056348f, 0.02358324f, 0.07198086f, 0.09754462f, 0.39658847f, -0.04481358f, 0.16950156f, 
    -0.24864769f, 0.23029377f, 0.00436846f, -0.06097566f, 0.13346852f, -0.03915557f, -0.02920618f, -0.11471152f, 
    -0.06790119f, -0.03491684f, 0.25590265f, 0.05192542f, 0.21875969f, 0.11079371f, -0.19010638f, 0.16112101f, 
    -0.03190862f, 0.02348967f, -0.08398078f, 0.11570291f, -0.13381052f, 0.01265360f, -0.14235900f, -0.00429074f, 
    0.34106135f, 0.27699679f, -0.07587884f, -0.14801367f, 0.14901137f, 0.15614426f, 0.10063255f, -0.11527330f, 
    0.07324132f, 0.00781411f, 0.19002624f, -0.13802746f, -0.16494265f, -0.14306299f, -0.06294937f, 0.31245467f, 
    -0.01816108f, 0.07444355f, -0.08898811f, 0.02581923f, 0.14008866f, 0.07547427f, -0.00804286f, 0.01666384f, 
    0.24685675f, -0.01518854f, -0.13865830f, 0.00546769f, -0.21731137f, 0.03780751f, -0.08002105f, -0.05185404f, 
    -0.09507543f, 0.02493855f, -0.10258133f, -0.20673218f, -0.30827755f, 0.03506819f, -0.00869965f, -0.06840988f, 
    -0.17009166f, 0.05085367f, -0.16637063f, 0.02519557f, 0.06735878f, 0.02791040f, 0.12782604f, 0.05269860f, 
    -0.23545761f, 0.29824352f, -0.11770046f, -0.08333037f, 0.34190965f, -0.01430740f, 0.15650518f, -0.19613653f, 
    0.02038705f, 0.06837013f, -0.06677570f, -0.11832920f, -0.58163828f, -0.43008116f, -0.00694506f, -0.07546789f, 
    -0.17380840f, 0.08861254f, 0.02005655f, 0.25719896f, -0.11091473f, 0.06350184f, 0.13279757f, 0.09389582f, 
    0.24093293f, -0.34238654f, 0.09474151f, -0.13669448f, 0.10653594f, -0.04008318f, -0.03225282f, -0.07717700f, 
    -0.05308491f, 0.02138158f, -0.13223371f, -0.04260508f, 0.30458099f, -0.63458717f, 0.00951374f, -0.06151691f, 
    0.13830289f, -0.06195414f, -0.02699686f, 0.08404648f, -0.05581176f, 0.02003634f, 0.02444980f, 0.01729126f, 
    0.01466968f, 0.28885067f, -0.24378493f, 0.10562348f, 0.10849505f, -0.23433454f, 0.00044129f, -0.05690537f, 
    0.13200514f, 0.07727251f, 0.03073529f, 0.05326754f, -0.27561975f, -0.40369037f, -0.07319776f, -0.35667214f, 
    0.03630088f, -0.04626877f, 0.00765919f, 0.06700363f, 0.04565684f, 0.04077853f, -0.09556166f, 0.20520273f, 
    0.05323572f, 0.11107818f, -0.10333677f, 0.17362346f, -0.21396692f, 0.01481370f, -0.10094094f, -0.07113735f, 
    0.07582365f, -0.10864335f, -0.10000626f, -0.03058350f, 0.00012953f, 0.22684798f, -0.10818693f, 0.08717807f, 
    -0.25106052f, 0.22115809f, -0.01456439f, -0.08075787f, 0.05244696f, 0.03082158f, -0.10222540f, -0.09558286f, 
    -0.00495664f, -0.13748734f, 0.16594014f, 0.03172236f, 0.07394183f, -0.01435001f, 0.09261908f, 0.12507749f, 
    -0.08433650f, -0.09667194f, -0.13733877f, 0.08474622f, -0.02350932f, 0.11309602f, 0.02994309f, -0.10065083f, 
    0.08878023f, 0.13204591f, 0.00830033f, 0.04280036f, -0.00220251f, -0.09555065f, 0.11965765f, -0.06121197f, 
    0.09596626f, -0.00931242f, -0.02574681f, -0.09731767f, 0.01393659f, 0.00391385f, -0.00794402f, 0.04728224f, 
    0.05361803f, -0.20334980f, -0.09963460f, -0.03540582f, -0.09962266f, 0.29645827f, -0.14850588f, -0.22774045f, 
    -0.17749520f, -0.14727755f, -0.05873892f, 0.09154619f, -0.14313319f, 0.08581503f, -0.05287747f, 0.05435202f, 
    0.57900119f, 0.09066078f, -0.23036388f, -0.34069702f, 0.05168996f, -0.06339538f, -0.00108122f, -0.00996127f, 
    0.06380620f, 0.02101630f, 0.05518685f, 0.09162776f, 0.09834116f, 0.03371190f, 0.08526637f, 0.05470699f, 
    -0.21745871f, 0.02093518f, 0.06356183f, 0.11955617f, -0.01602373f, 0.10752798f, -0.08750099f, -0.13240093f, 
    0.71985608f, -0.06193560f, -0.32115561f, 0.14767618f, -0.00474983f, -0.18269309f, -0.05139832f, -0.01490294f, 
    0.01939937f, 0.03855878f, 0.08274601f, 0.01097569f, 0.06758124f, -0.29459465f, 0.09278998f, -0.04800060f, 
    0.20829023f, 0.20919795f, 0.14154813f, -0.09112971f, -0.01558932f, -0.14890067f, 0.07618836f, 0.17833708f, 
    0.03567113f, -0.36231244f, -0.14003327f, 0.29955807f, -0.09111110f, 0.03686763f, 0.09687202f, 0.03847748f, 
    -0.03718120f, 0.14873430f, 0.04477892f, -0.18078144f, 0.21448265f, 0.33372211f, -0.17744914f, 0.03422214f, 
    0.11569246f, -0.05326191f, -0.14287527f, -0.04522187f, -0.01837862f, 0.01409953f, -0.11102154f, 0.08555200f, 
    0.05365733f, -0.33955255f, -0.00269870f, 0.08250037f, -0.02351382f, 0.09042888f, -0.07056171f, -0.17392579f, 
    0.01276854f, -0.00294723f, 0.07239991f, -0.02122644f, -0.35210249f, -0.44475353f, -0.09573200f, -0.05680492f, 
    -0.06763508f, 0.06296345f, 0.08779492f, -0.01098597f, -0.08862954f, 0.10743041f, -0.10487849f, -0.19584370f, 
    0.10324995f, 0.33051583f, -0.13508524f, -0.02161127f, 0.13751711f, -0.00612387f, -0.14059404f, 0.04696799f, 
    -0.01994692f, 0.09404930f, -0.17557737f, -0.13135831f, 0.18903019f, 0.05480623f, -0.46497568f, 0.26728371f, 
    0.13737068f, -0.03641897f, 0.14886890f, 0.06845950f, -0.01344212f, 0.06078811f, -0.04383638f, 0.07497685f, 
    -0.32962993f, -0.02837734f, -0.12580495f, -0.33715564f, -0.06676120f, 0.09298046f, -0.01547132f, 0.13207735f, 
    0.15141487f, -0.09586933f, 0.02039171f, -0.22483534f, -0.15435973f, 0.42328933f, -0.17976059f, 0.01724761f, 
    0.05485955f, -0.03186789f, -0.08567591f, 0.14961660f, 0.18953660f, 0.04357116f, 0.08191701f, -0.06989645f, 
    0.20319127f, -0.10322085f, -0.19969931f, 0.30861324f, 0.10283239f, -0.06791802f, -0.00443852f, 0.15181510f, 
    0.03028968f, -0.07104573f, 0.19225644f, 0.07192525f, 0.05826195f, -0.17125076f, 0.07910974f, 0.12129780f, 
    -0.17469722f, 0.03504007f, -0.18474853f, 0.17977473f, -0.25210378f, -0.15056635f, -0.01945287f, -0.11602636f, 
    0.03281752f, 0.19682731f, -0.03250900f, -0.22899492f, -0.18420601f, 0.06189137f, 0.02320356f, -0.06572883f, 
    -0.03145236f, 0.17250809f, -0.27728701f, -0.02214591f, -0.37050900f, 0.20696409f, 0.02426095f, -0.20706506f, 
    0.09287783f, -0.09494632f, 0.02318192f, 0.15640606f, -0.06379308f, -0.09856812f, 0.08822828f, 0.03449517f, 
    -0.14316604f, -0.17249757f, -0.25085604f, 0.38124707f, -0.14538842f, 0.00098076f, 0.14128202f, 0.00136056f, 
    0.07332473f, -0.01084897f, -0.11515211f, -0.18758802f, -0.25640005f, -0.08635943f, 0.07335059f, 0.22506793f, 
    0.08288661f, -0.10586300f, -0.02890304f, -0.09233983f, 0.15187787f, 0.03278499f, 0.05130443f, -0.10626779f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09965489f, -0.02748344f, -0.03750641f, -0.00124928f, -0.03740333f, 0.04464164f, 0.01938591f, -0.04612349f, 
    -0.07066076f, 0.01564039f, 0.12780431f, 0.08789124f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
