#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.35026693f, -0.45197821f, -0.26749912f, 0.44260737f, 0.25885931f, 0.09572673f, -0.39699030f, -0.18172416f, 
    0.25077781f, 0.11944619f, 0.73482209f, -0.24669597f, 0.21639761f, 0.07086905f, -0.10197466f, -0.26341456f, 
    0.15081686f, 0.29811990f, 0.14680138f, 0.16177475f, 0.00909375f, 0.28473565f, 0.45577258f, 0.04458251f, 
    0.20669976f, -0.63724142f, -0.34346837f, 0.40058449f, 0.72262931f, 0.36832732f, -0.14038952f, -0.08659768f, 
    -0.38598093f, 0.19943674f, 0.44909307f, -0.17615244f, 0.36367500f, -0.41463992f, 0.11739668f, -0.07737122f, 
    0.10069385f, -0.17068875f, -0.07163754f, -0.16379811f, -0.04230078f, -0.44249055f, -0.25590920f, -0.20306748f, 
    -0.45796418f, -0.53121775f, -0.45045066f, 0.30731571f, -0.61361271f, 0.39731583f, 0.29918656f, 0.09608806f, 
    -0.06619681f, -0.13254355f, -0.18473254f, 0.11607172f, 0.36928448f, -0.66424316f, 0.29868770f, -0.31694716f, 
    0.44205096f, -0.29329365f, -0.06867143f, 0.28323084f, 0.03780409f, -0.29798093f, -0.13704462f, -0.14898309f, 
    0.16734703f, 0.01922845f, 0.52135247f, -0.89776587f, -0.56431228f, -0.42157683f, -0.68881124f, -0.36651865f, 
    0.45487389f, -0.04587134f, -0.39741603f, -0.76704329f, -0.16783883f, -0.20438932f, -0.08164193f, 0.12220360f, 
    0.54227453f, -0.10840232f, 0.17330292f, -0.26656982f, -0.14182331f, 0.19280764f, -0.12924619f, -0.03902401f, 
    0.34205726f, 0.25119749f, 0.17966713f, 0.12649733f, -0.71064913f, -0.72085243f, -0.77772313f, 0.23864764f, 
    0.40498388f, 0.14790764f, 0.49686420f, 0.13872416f, -0.04779490f, -0.01715505f, 0.49213719f, 0.36288652f, 
    0.46811855f, -0.17269818f, -0.09653588f, -0.04516659f, -0.18622780f, 0.07589257f, 0.12663560f, 0.22825988f, 
    0.05150960f, -0.17452304f, -0.00670838f, -0.28943548f, -0.26872188f, -0.84971428f, -0.55049843f, -0.01053950f, 
    0.06854754f, -0.25145662f, -0.27565688f, -0.70979381f, -0.88601762f, -0.20338547f, -0.42460653f, -0.19048446f, 
    -0.07093559f, -0.39004979f, -0.53453386f, -0.59820360f, -0.22051835f, 0.06323583f, -0.05087426f, -0.26366645f, 
    -0.17098646f, -0.02518714f, 0.07292607f, 0.19157515f, -0.15536027f, 0.01194739f, 0.64958996f, 0.24778542f, 
    0.39772710f, 0.37278438f, 0.60355681f, 0.15369880f, 0.12899376f, -0.15285136f, -0.16300160f, 0.14649825f, 
    -0.16346784f, 0.29394618f, 0.11660365f, -0.23088786f, -0.33168581f, -0.22360966f, -0.21726699f, -0.01928349f, 
    0.09803672f, 0.00241549f, -0.08885207f, -0.07623143f, -0.29907340f, 0.09415638f, 0.16775687f, -0.62960654f, 
    -1.20688975f, -0.24863526f, 0.58356547f, 0.47752640f, 0.71359801f, 1.06892991f, -0.04174018f, -0.51594383f, 
    -0.32926050f, 0.19646491f, 0.07426551f, -0.27961108f, -0.45106381f, -0.48647168f, 0.22615518f, 0.43773457f, 
    -0.08531316f, -0.09195831f, 0.03176147f, 0.17857653f, -0.23552725f, -0.09964035f, 0.27958360f, -0.19467041f, 
    0.06206286f, -1.33744502f, -0.28845972f, 0.68320346f, 0.77253681f, -1.05605209f, -0.56786245f, -0.45652944f, 
    0.09488708f, 0.16519512f, 0.16261376f, 0.04596981f, 0.54969782f, -0.06094071f, -0.04434042f, 0.13822940f, 
    0.07801319f, -0.20749979f, -0.04324255f, -0.17470098f, 0.17034818f, -0.25721809f, -0.01998796f, 0.04453204f, 
    0.24749820f, 0.52113968f, 0.81559670f, 0.44257897f, 0.12917465f, -0.43017727f, -0.50226378f, -0.48328781f, 
    -0.15918952f, 0.00698284f, -0.42890707f, -0.07476076f, -0.26623431f, 0.03296932f, 0.64930969f, -0.63299137f, 
    -0.03222106f, -0.11874827f, -0.01487035f, 0.28103551f, -0.04536037f, 0.06916348f, -0.12295707f, 0.06601196f, 
    -0.12805855f, 0.28502175f, -0.04304923f, 0.04994116f, -0.19628620f, 0.24624258f, -0.44332948f, -0.42840445f, 
    -0.13975561f, -0.37794659f, -0.59896082f, -0.36286533f, -0.05945430f, 0.07881506f, -0.31317651f, -0.34116542f, 
    -0.20841388f, 0.11221327f, 0.13799395f, 0.54307592f, 0.20297778f, 0.16623878f, -0.22563884f, -0.40305436f, 
    -0.35682034f, -0.28951448f, -0.18187335f, -0.47764608f, -0.15939587f, 0.21279630f, 0.26979110f, 0.03524137f, 
    0.59401864f, -0.11378966f, -0.49104306f, 0.17698690f, 0.46330950f, -0.25929633f, 0.48232299f, -0.06589669f, 
    -0.27821532f, 0.19650939f, -0.38012993f, -0.22054315f, 0.01780332f, -0.04186164f, -0.01840875f, 0.19749002f, 
    0.38829988f, -0.10191772f, 0.29312146f, -0.03060467f, -0.34606415f, -0.44140306f, -0.74564588f, -0.44515961f, 
    -0.21420275f, 0.22864142f, 0.11180843f, 0.01539391f, 0.57818824f, 0.46344069f, -0.08645526f, 0.33002797f, 
    -0.24524865f, 0.37829709f, -0.13498583f, -0.27062395f, -0.31939980f, -0.32415953f, 0.29716930f, -0.29282993f, 
    0.10644846f, 0.17139070f, 0.09970170f, 0.06194253f, 0.30425712f, 0.22671060f, 0.29042003f, 0.17827076f, 
    -0.00118882f, 0.36863017f, 0.41362765f, 0.47273824f, 0.00078385f, 0.25142652f, -0.12220772f, 0.11691582f, 
    0.04046854f, -0.01873171f, -0.14976485f, 0.07119944f, 0.07097633f, 0.01664512f, -0.01517821f, -0.26149043f, 
    0.06148417f, -0.02491104f, 0.23827508f, -0.04621422f, -0.17320733f, -0.01697381f, -1.18322766f, 0.49452004f, 
    0.10580067f, -0.23467557f, 0.62775296f, 0.16991298f, -0.50362313f, 0.16003048f, 0.35110107f, 0.28241098f, 
    -0.04322720f, 0.10161482f, -0.26656100f, -0.11172675f, 0.21955989f, 0.03892257f, -0.28460413f, -0.03125525f, 
    -0.16107298f, 0.15799689f, -0.02188664f, 0.04922120f, 0.21967424f, 0.15669058f, -0.18791407f, 0.25425127f, 
    -1.36851513f, -1.00425708f, -0.80980778f, 0.01802515f, 0.03447591f, -0.01356401f, -0.00741710f, 0.54372430f, 
    0.34333241f, -0.01762343f, -0.17929640f, -0.09827040f, -0.07485678f, 0.50820071f, -0.29719359f, 0.04836382f, 
    -0.14768547f, -0.00632358f, -0.27767053f, -0.35588357f, -0.16635169f, -0.34556872f, 0.00197682f, -0.10051131f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14828342f, -0.03195299f, 0.20929834f, 0.01281589f, -0.00696062f, 0.08056894f, 0.38495997f, 0.33650234f, 
    0.41316497f, 0.24686952f, 0.13529053f, 0.09142877f, 0.47504923f, -0.11331331f, 0.55486125f, 0.20361175f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06253408f, 0.05943810f, -0.06031814f, -0.05681692f, 0.03102459f, -0.00475395f, -0.04268836f, 0.03196485f, 
    0.03238986f, -0.00757923f, -0.09250987f, -0.03181115f, 0.09812953f, -0.45502013f, 0.15194124f, 0.10506799f, 
    0.07125956f, -0.11468387f, 0.00217814f, -0.03026070f, 0.10745074f, -0.01630147f, 0.04305004f, 0.00353968f, 
    -0.20343858f, -0.10527842f, 0.03113580f, -0.15272811f, 0.10625198f, 0.12232240f, 0.00695668f, 0.16373911f, 
    -0.11035076f, 0.00274108f, -0.20788208f, 0.05123670f, -0.15096518f, 0.10508426f, 0.41991642f, -0.10875057f, 
    0.02459645f, 0.00313389f, 0.05172347f, 0.03254757f, 0.10697843f, -0.16412681f, -0.02071480f, -0.08295497f, 
    0.11918728f, -0.13290367f, 0.08765630f, -0.04782283f, -0.01068176f, -0.23406316f, -0.00363804f, -0.07472235f, 
    -0.02982027f, 0.07275750f, 0.14368871f, 0.09771217f, -0.16915241f, 0.13425171f, 0.18129291f, -0.04444449f, 
    0.01466411f, 0.07060829f, 0.03917418f, 0.07738293f, 0.11721602f, 0.02405781f, 0.15617608f, -0.00083071f, 
    0.13369590f, -0.10017730f, 0.19681963f, 0.11594403f, -0.03839176f, -0.02597542f, 0.00849792f, -0.00032677f, 
    0.00240854f, -0.06665038f, -0.00773906f, -0.15124540f, 0.27044475f, -0.60307801f, 0.34776232f, 0.03158329f, 
    -0.15160671f, -0.07168920f, 0.06834654f, 0.03190934f, 0.28403065f, -0.07309952f, 0.10130540f, 0.02135466f, 
    -0.12536421f, -0.19703081f, 0.15632343f, -0.03744994f, -0.02276342f, 0.11391354f, 0.06357401f, -0.06436893f, 
    0.08137602f, -0.02191922f, -0.09074747f, 0.08077089f, -0.10276516f, 0.01849699f, -0.36582729f, -0.02770022f, 
    0.18125221f, 0.05177876f, -0.06465833f, -0.05938948f, 0.06031391f, -0.12005866f, -0.08160386f, -0.04930658f, 
    -0.15718746f, 0.17293650f, 0.04815996f, -0.13509132f, 0.11649309f, -0.01295563f, -0.03350232f, -0.06969741f, 
    0.10801914f, 0.01265249f, 0.03351581f, -0.04721717f, 0.26513156f, -0.11339907f, 0.12900425f, 0.14617126f, 
    -0.11911847f, -0.24109001f, -0.17627847f, 0.15317182f, -0.00927268f, -0.11785775f, 0.06213971f, -0.16571313f, 
    0.11526405f, 0.07159314f, 0.08608727f, -0.08758742f, -0.19982997f, -0.02317440f, -0.08124550f, 0.13505435f, 
    0.10629763f, -0.05937038f, 0.06934129f, 0.05621402f, 0.10163691f, 0.10044552f, 0.01141608f, 0.24025242f, 
    -0.01292279f, -0.07360756f, -0.05469027f, 0.00955326f, 0.09538320f, 0.02368027f, -0.01376718f, 0.09827522f, 
    -0.60140234f, 0.14510886f, 0.13107325f, 0.47496092f, 0.04810967f, -0.05586245f, -0.09847857f, -0.01267591f, 
    0.21378106f, -0.06170132f, 0.07502469f, 0.10242835f, 0.10263452f, -0.15237209f, 0.40060148f, -0.06758442f, 
    -0.07992012f, 0.00478926f, 0.08095662f, -0.04537857f, 0.15879944f, 0.11056167f, 0.15847088f, 0.00581163f, 
    -0.11366825f, 0.07432357f, -0.04366644f, 0.04193722f, 0.27466053f, 0.01298879f, 0.06782763f, 0.24621171f, 
    -0.17321104f, 0.01506107f, 0.03913710f, 0.09780345f, -0.16815168f, 0.12457046f, -0.11557756f, 0.03860326f, 
    -0.07314328f, 0.10851850f, -0.00307817f, 0.01270338f, 0.00416002f, -0.04715322f, -0.06287514f, -0.01550496f, 
    -0.28866458f, 0.21453494f, 0.07009751f, 0.07557909f, 0.25448889f, 0.07288808f, 0.16398528f, 0.10961083f, 
    0.19547682f, 0.22362779f, 0.06383730f, 0.04072669f, -0.02151342f, -0.09478644f, 0.35149148f, 0.31896448f, 
    -0.22478203f, -0.06582369f, 0.10713738f, 0.11486427f, -0.01168501f, 0.01599144f, 0.04346897f, 0.01218986f, 
    -0.30000114f, -0.11293316f, -0.01950137f, 0.07478225f, -0.22678797f, 0.00338561f, 0.01072172f, 0.02472747f, 
    -0.01374735f, 0.07020054f, -0.07783635f, -0.09760893f, -0.26191664f, -0.09676665f, -0.25642323f, 0.01875272f, 
    0.03682181f, -0.13584222f, -0.10160732f, -0.02754156f, 0.05675174f, 0.06979731f, -0.05015217f, 0.24479240f, 
    0.09654552f, 0.08024036f, 0.11650378f, 0.14571778f, -0.08532988f, 0.01837669f, -0.01662030f, -0.04992794f, 
    -0.04106461f, -0.01126222f, -0.03455834f, 0.03501463f, 0.03549849f, -0.25196549f, 0.22606015f, 0.16802563f, 
    0.05745533f, -0.03383151f, -0.02917213f, -0.03532470f, 0.07886821f, 0.00701019f, 0.18758535f, -0.12205684f, 
    -0.23921567f, -0.11466936f, -0.58342099f, 0.16601929f, -0.09896281f, -0.17125426f, 0.08746853f, 0.05575084f, 
    0.02185473f, 0.10037063f, 0.15366758f, 0.02993806f, 0.11972975f, 0.13192277f, 0.19780178f, -0.32859650f, 
    -0.01947073f, -0.07169787f, 0.26998675f, -0.20336501f, -0.07979110f, -0.03611774f, -0.02385347f, 0.07070659f, 
    -0.23998642f, -0.10419217f, 0.14701426f, -0.19555391f, -0.17824192f, 0.08740599f, -0.16687256f, -0.15259369f, 
    0.02011150f, -0.10303707f, -0.12359430f, 0.09128419f, -0.16346559f, 0.10483775f, -0.24407768f, 0.23675267f, 
    -0.03075079f, -0.08344828f, 0.01959962f, 0.07415895f, 0.04659009f, 0.03364291f, 0.08207647f, 0.23801339f, 
    -0.12679560f, 0.17196272f, 0.05853019f, 0.09187103f, -0.01455551f, 0.12188577f, -0.07314498f, 0.26530299f, 
    0.09542439f, 0.05006588f, 0.05816993f, -0.13581696f, -0.02611650f, 0.04027214f, 0.06137896f, 0.06939810f, 
    -0.09828254f, 0.01303820f, -0.07126001f, 0.04103214f, -0.11434253f, 0.13409467f, 0.05495805f, 0.05935006f, 
    -0.20004831f, 0.09723397f, -0.19179055f, 0.26830667f, 0.09064955f, -0.00879839f, -0.06831831f, 0.11477578f, 
    0.11971077f, 0.11207703f, 0.31146640f, 0.11036015f, -0.13242701f, 0.27888933f, 0.07655583f, 0.10889655f, 
    0.04737691f, 0.09119868f, -0.02121738f, -0.05780015f, 0.08527953f, 0.06279852f, 0.18068045f, -0.07179485f, 
    -0.05376955f, 0.04334030f, 0.02190746f, -0.03183750f, 0.06552717f, -0.06917130f, 0.01855247f, 0.01925424f, 
    -0.04214214f, 0.02320980f, 0.01169638f, -0.02079158f, -0.03771801f, 0.04983548f, -0.03725992f, 0.03398203f, 
    0.05957513f, 0.04850904f, -0.06030254f, 0.03991033f, -0.05012372f, -0.04165422f, 0.05835746f, 0.03999548f, 
    -0.02300891f, 0.00228570f, -0.03388017f, 0.03539103f, -0.02470151f, -0.05168200f, -0.03711620f, 0.06691838f, 
    -0.02030923f, 0.06346136f, -0.04915239f, 0.02328165f, -0.00506619f, -0.00055676f, -0.03859302f, -0.04431063f, 
    -0.03932071f, 0.00841554f, 0.01928586f, 0.03544835f, -0.04685408f, -0.07230352f, -0.00636445f, -0.07101672f, 
    -0.00872012f, -0.03774782f, 0.00651404f, -0.03373969f, 0.00793153f, -0.05238414f, -0.04139147f, -0.04461781f, 
    -0.04803561f, -0.04919564f, 0.01702704f, -0.06038838f, 0.04322045f, -0.00663638f, -0.00297491f, -0.01800778f, 
    -0.06263330f, -0.05187830f, -0.02630474f, 0.06436285f, 0.05152136f, -0.03802722f, -0.00860643f, -0.03260421f, 
    -0.07851578f, 0.05416771f, 0.03738036f, -0.01145662f, 0.04723294f, -0.02470066f, 0.00799689f, 0.04465448f, 
    0.00064654f, -0.02420918f, -0.07618935f, -0.00675737f, 0.05052717f, -0.05894360f, -0.02590154f, -0.01430350f, 
    0.00724067f, -0.00269682f, -0.06205133f, 0.00278431f, -0.01828607f, -0.04454893f, 0.01451164f, -0.00116716f, 
    -0.01258075f, 0.02716555f, -0.03713234f, -0.06905516f, 0.02127312f, 0.06131452f, -0.00985781f, -0.02749722f, 
    0.05408881f, -0.05134455f, 0.00011482f, -0.06171869f, -0.03890046f, 0.04281799f, 0.05666002f, -0.00606025f, 
    -0.04230801f, 0.00697113f, -0.01970900f, 0.01572368f, -0.06388070f, 0.03479891f, -0.05597218f, 0.01753404f, 
    0.02033242f, 0.05982897f, 0.03145554f, -0.06898092f, -0.01093777f, -0.01116750f, 0.02626631f, 0.01960996f, 
    0.03396477f, -0.07366937f, 0.01760276f, -0.03047683f, -0.01923003f, 0.03860318f, 0.05345580f, 0.00172278f, 
    0.03537819f, -0.07302926f, 0.05836182f, -0.00853293f, -0.00055610f, -0.06024884f, -0.00329751f, -0.01725258f, 
    0.03491198f, -0.05132819f, 0.03226319f, 0.00037180f, -0.00659176f, -0.05761545f, 0.01885859f, -0.01301703f, 
    -0.06176919f, -0.02669031f, -0.03235018f, -0.02009090f, 0.02125236f, -0.07429201f, -0.05243320f, -0.05717550f, 
    0.04789816f, 0.05244135f, 0.02110785f, 0.04486379f, 0.00323211f, -0.03935037f, 0.06055002f, -0.03700134f, 
    -0.03767505f, -0.01755256f, 0.00299830f, -0.00979089f, 0.02337005f, -0.01271271f, 0.00626467f, -0.07627778f, 
    -0.06056261f, -0.02048479f, -0.00174490f, 0.04114703f, 0.03352795f, -0.07794551f, 0.06493284f, -0.03111523f, 
    -0.04645135f, 0.01309224f, -0.04108002f, -0.02269489f, -0.00986258f, -0.07200833f, 0.05770704f, -0.04716748f, 
    -0.29324493f, 0.14883834f, -0.14288734f, 0.06736339f, 0.01359923f, 0.03612312f, 0.02740190f, 0.06734025f, 
    -0.00247604f, -0.08235638f, -0.11289001f, 0.03880212f, -0.18372373f, 0.50946522f, -0.33414263f, -0.01265481f, 
    -0.11486875f, -0.05827330f, -0.10501850f, 0.02045458f, 0.04190368f, 0.04299672f, -0.00778086f, 0.12429779f, 
    -0.18622337f, -0.05609043f, -0.03328798f, 0.15290841f, 0.12897550f, -0.13656089f, 0.10254326f, -0.02290837f, 
    0.09050105f, 0.09173136f, 0.20716654f, -0.11669905f, 0.14515913f, 0.10973269f, 0.02111017f, 0.50347131f, 
    -0.13923098f, -0.16033378f, -0.09373031f, -0.01539715f, -0.11662148f, 0.08177320f, 0.01454702f, 0.09215520f, 
    -0.40083414f, 0.14837965f, -0.21199813f, 0.04314850f, -0.09184911f, 0.23960876f, 0.06772659f, -0.05648435f, 
    0.07060748f, 0.09738300f, -0.10812475f, -0.04896991f, 0.03705324f, -0.14745679f, -0.44680342f, 0.05283013f, 
    0.13143152f, -0.05640420f, -0.10747322f, -0.06224060f, 0.07612051f, 0.04554622f, -0.02518684f, 0.13742478f, 
    0.12705112f, 0.18091124f, -0.01696962f, 0.12430498f, -0.07930987f, -0.00794648f, -0.16852443f, -0.06382363f, 
    -0.01323948f, 0.08510319f, -0.07312770f, -0.04149696f, 0.06998295f, 0.05273557f, 0.19771571f, 0.17957786f, 
    0.12573731f, 0.05134938f, 0.21347049f, 0.03193416f, -0.02437947f, 0.17373821f, 0.09026305f, 0.02425812f, 
    -0.36939678f, 0.34089118f, -0.45048565f, 0.16007283f, -0.11218248f, -0.12401091f, -0.01170607f, 0.09741905f, 
    -0.00178578f, -0.03349165f, 0.10958149f, -0.09475716f, 0.32193479f, -0.16730656f, 0.40183020f, -0.36503655f, 
    0.07049067f, -0.07797607f, 0.04850548f, -0.04655711f, -0.07294293f, -0.07176214f, -0.04409453f, 0.01484617f, 
    -0.01036694f, -0.18474062f, -0.03564738f, 0.03227985f, -0.15966500f, 0.01786548f, -0.06611653f, -0.00775507f, 
    0.11964023f, -0.06012696f, -0.07508998f, 0.10070428f, -0.27846920f, 0.27589136f, -0.16725744f, -0.01843231f, 
    0.22029404f, 0.04757040f, 0.19025728f, 0.04773970f, -0.01267166f, -0.07645049f, -0.26799908f, 0.11787594f, 
    -0.01940826f, 0.38007128f, -0.08164474f, 0.37094259f, 0.20023046f, 0.00853209f, -0.08036543f, 0.08597140f, 
    0.03363672f, -0.06394686f, 0.09153090f, -0.00418640f, 0.09458376f, -0.04599845f, 0.06245344f, -0.01884974f, 
    -0.07513560f, 0.03718894f, -0.14488779f, -0.11358517f, -0.24586745f, 0.06921953f, 0.12974158f, -0.12050932f, 
    0.05360382f, -0.03218936f, -0.28867424f, -0.07915873f, 0.30945304f, 0.00516461f, 0.02002885f, 0.05226155f, 
    -0.15272386f, 0.03669765f, 0.06041753f, 0.00527577f, -0.23047771f, 0.65206152f, -0.31485257f, 0.14300954f, 
    0.16009410f, 0.09914604f, -0.11042883f, 0.08676336f, 0.00087786f, 0.15219843f, 0.07914741f, 0.04562186f, 
    -0.27362707f, -0.01649820f, 0.18501504f, -0.30376586f, 0.01757354f, 0.07081039f, -0.17779908f, 0.03894413f, 
    0.06994119f, -0.01563566f, 0.01300039f, -0.15951401f, -0.21931554f, -0.06424165f, -0.15286805f, -0.11715717f, 
    0.02752376f, -0.09918305f, -0.05729004f, 0.07775375f, -0.09330793f, -0.15382157f, -0.10545205f, -0.12949060f, 
    -0.23890975f, -0.12870616f, -0.27083632f, -0.59316707f, 0.13036115f, 0.02777115f, -0.20625494f, -0.26213756f, 
    0.14162317f, 0.08650447f, 0.18107684f, 0.11710227f, 0.19106348f, 0.08617397f, 0.37242547f, 0.21587300f, 
    0.15535007f, 0.15040171f, 0.02042288f, -0.03620371f, -0.03788173f, -0.03092535f, -0.04335569f, -0.03874774f, 
    -0.09869511f, 0.34224308f, -0.24872084f, 0.07687040f, 0.14612177f, -0.06728631f, 0.13633463f, 0.00509384f, 
    0.00312113f, 0.10699514f, 0.02072663f, 0.11901315f, 0.18724187f, 0.34616220f, 0.16284741f, -0.04732019f, 
    0.10065664f, 0.13212250f, 0.00629756f, 0.25351048f, 0.05682611f, -0.07456052f, -0.18917467f, 0.00506444f, 
    -0.29730794f, 0.04706494f, -0.25901625f, -0.17892230f, 0.00639191f, -0.09170489f, -0.08225102f, -0.11898040f, 
    -0.21901244f, 0.04272868f, 0.01360387f, 0.06725196f, 0.21809387f, 0.31178540f, 0.25406626f, -0.10036815f, 
    0.15436508f, -0.06581402f, 0.36270556f, 0.05193954f, 0.17373651f, 0.14336577f, -0.05187058f, 0.00659454f, 
    -0.01777938f, 0.42255822f, -0.11385003f, 0.07940415f, 0.00799243f, 0.08652800f, 0.01394786f, -0.02632325f, 
    0.02509836f, -0.09129925f, -0.02342521f, 0.00394592f, -0.38405508f, -0.57858062f, 0.02332627f, -0.16208641f, 
    0.09966765f, 0.01882647f, -0.14392877f, 0.01502606f, -0.01601470f, -0.05142373f, 0.06376211f, 0.05482396f, 
    0.06096375f, 0.21471843f, 0.08120269f, -0.03239822f, 0.09998199f, -0.06355467f, 0.01093267f, 0.12961945f, 
    0.05127634f, 0.02860793f, -0.06937936f, 0.02445633f, -0.04442953f, -0.18166462f, 0.09662807f, -0.32629344f, 
    0.24527140f, -0.17708308f, -0.02570820f, 0.39795741f, -0.07622600f, 0.05931265f, -0.24082160f, -0.05606383f, 
    0.03478710f, 0.06240655f, 0.13840406f, 0.13545701f, 0.11455331f, 0.31504980f, 0.11247107f, -0.03650951f, 
    -0.03785907f, -0.10428789f, -0.02722751f, 0.02045838f, 0.00885158f, -0.57208365f, -0.37712261f, 0.05458688f, 
    0.07706173f, -0.12105662f, -0.23284659f, -0.19706291f, -0.03772515f, 0.06278310f, 0.18173480f, 0.08251202f, 
    -0.13788231f, -0.21962141f, -0.31241357f, -0.05122840f, 0.10345285f, -0.11466386f, -0.15271272f, 0.06983946f, 
    -0.05110374f, 0.10326222f, -0.12252472f, -0.10499056f, 0.16465397f, 0.29779631f, 0.27103019f, 0.09910927f, 
    0.21129571f, 0.13492858f, -0.09849599f, -0.16133381f, -0.01185396f, 0.18298417f, -0.01584519f, 0.07358589f, 
    -0.12790126f, 0.08641001f, 0.06877058f, 0.08752647f, 0.08736572f, 0.02792810f, -0.16006021f, 0.17713614f, 
    -0.06260189f, -0.06598121f, -0.01690119f, -0.07889907f, -0.06958248f, 0.00376804f, -0.19405036f, -0.01432082f, 
    -0.03000339f, 0.08416298f, 0.01224731f, 0.10039639f, 0.01428392f, 0.15231782f, 0.23598382f, 0.16931561f, 
    -0.18134438f, -0.10718005f, 0.07047652f, -0.18757229f, 0.13120742f, -0.00105897f, -0.01582235f, -0.12793194f, 
    0.10460247f, 0.00559426f, 0.13963774f, -0.25639674f, 0.15938595f, -0.21884443f, 0.14567658f, 0.17222799f, 
    -0.13210082f, -0.09252550f, 0.04733654f, 0.01719527f, -0.11445710f, -0.19443259f, 0.02471796f, -0.05380393f, 
    -0.19783090f, 0.04498171f, -0.09635086f, 0.21173145f, -0.04134238f, -0.05222174f, 0.12877493f, -0.00539567f, 
    0.16862790f, 0.00660858f, 0.05688193f, 0.04883563f, 0.08961984f, 0.10540430f, -0.24328573f, -0.28861445f, 
    -0.05828913f, 0.01117311f, 0.00891106f, 0.05619955f, 0.02855585f, -0.05135575f, -0.12243979f, 0.07139084f, 
    -0.00211322f, -0.00341671f, 0.03584958f, 0.06863589f, -0.07548925f, 0.08974433f, 0.04629393f, 0.07206315f, 
    -0.06710257f, 0.05560163f, -0.01156506f, -0.03526115f, 0.45152941f, -0.31302744f, 0.09253823f, -0.00539275f, 
    -0.00014480f, -0.16144709f, 0.20764075f, -0.07522061f, 0.15912241f, 0.07899474f, 0.10026333f, -0.04261478f, 
    0.17062981f, 0.10761821f, -0.53596449f, -0.05213907f, -0.03871340f, -0.16197513f, -0.02787994f, -0.05775005f, 
    0.05906980f, -0.04303354f, 0.04249876f, -0.04710724f, -0.03300553f, -0.15702696f, 0.40627268f, -0.34617558f, 
    0.02827462f, -0.08746225f, -0.03906069f, 0.03145112f, -0.03196937f, -0.22460188f, 0.14133742f, -0.10949441f, 
    -0.06356724f, 0.12041701f, -0.09598248f, -0.14805581f, -0.02382605f, 0.03699137f, -0.06464925f, 0.03212086f, 
    0.13723937f, 0.12867850f, -0.13824220f, 0.03402574f, -0.05983031f, 0.01321596f, -0.20624849f, -0.01524162f, 
    0.07911527f, -0.11555988f, -0.03251526f, 0.25188002f, 0.03571681f, -0.08446026f, 0.01100702f, 0.16464911f, 
    -0.12835851f, 0.21085012f, -0.13416813f, 0.30139023f, 0.13731024f, 0.13546158f, -0.07513897f, 0.10816180f, 
    -0.09210972f, -0.12666690f, -0.09181625f, -0.00925532f, -0.14738426f, -0.07846192f, 0.06464131f, 0.02328764f, 
    0.00780069f, 0.06549966f, 0.00232894f, 0.13235131f, -0.18282001f, 0.12505609f, 0.04533975f, 0.12724636f, 
    0.06054463f, -0.21578607f, -0.22677264f, 0.02590946f, 0.18340263f, 0.01111824f, 0.08351331f, 0.23895863f, 
    0.24742037f, 0.01858911f, 0.15063283f, 0.07446484f, 0.19532704f, 0.23044878f, 0.12175687f, 0.04702463f, 
    0.13009457f, 0.17202982f, 0.03268608f, -0.04009540f, -0.06755456f, 0.15910804f, 0.13606113f, 0.17714730f, 
    0.19215611f, -0.00757510f, 0.03908191f, -0.02384936f, -0.06694061f, -0.04213162f, -0.01165030f, 0.10004070f, 
    0.11725776f, -0.02029193f, 0.00545967f, 0.06492252f, 0.22561680f, -0.27006698f, 0.08837426f, 0.08664436f, 
    -0.07198828f, -0.04477576f, -0.08385268f, 0.00615304f, 0.20874311f, 0.33387238f, 0.19831255f, 0.20231895f, 
    0.18230902f, -0.09301063f, 0.10527425f, -0.08966657f, 0.19137757f, -0.15781583f, -0.00832082f, 0.21496546f, 
    -0.22465658f, -0.03246100f, -0.19926549f, -0.10243481f, -0.06984741f, 0.00981726f, 0.14603113f, -0.06790490f, 
    -0.12087923f, 0.05156464f, 0.00837385f, 0.05034691f, 0.02567409f, 0.11309453f, 0.03103484f, 0.00824434f, 
    -0.06498096f, -0.13881183f, 0.19574875f, 0.02044500f, -0.17499511f, -0.01911655f, -0.14150302f, -0.13129698f, 
    0.03413887f, -0.05345124f, -0.02427844f, 0.23396336f, -0.23314020f, -0.18621297f, 0.08675450f, 0.15199165f, 
    0.01151381f, 0.01424697f, 0.06269260f, -0.05441776f, 0.04898541f, -0.01009324f, 0.14765391f, 0.06786889f, 
    0.16187309f, -0.02461600f, 0.13839735f, -0.01488011f, 0.17698532f, -0.03020775f, -0.03056814f, -0.05615219f, 
    0.05769600f, 0.09350529f, -0.11771888f, -0.14673440f, 0.10700948f, -0.60727286f, 0.20949967f, 0.31863341f, 
    -0.10883958f, 0.10247835f, -0.16558804f, 0.12540127f, 0.06518542f, 0.00936565f, 0.04248210f, -0.13112724f, 
    -0.03792568f, -0.38343596f, 0.24384296f, 0.12137321f, -0.12337463f, -0.07309432f, -0.07675994f, 0.05381094f, 
    0.00328302f, 0.10049037f, -0.01567179f, 0.01091454f, -0.02170512f, 0.22935894f, -0.23474725f, 0.12897988f, 
    0.08815165f, 0.03875140f, 0.24526365f, 0.07917020f, 0.06879766f, -0.05744420f, -0.14549175f, 0.08163638f, 
    -0.08010548f, -0.00089290f, -0.01619298f, 0.03904877f, 0.03163345f, 0.20353466f, 0.10233453f, 0.02018857f, 
    0.06569981f, -0.08155309f, 0.15260084f, 0.07651441f, 0.36394146f, 0.00306085f, 0.07034679f, 0.04869899f, 
    0.08791320f, 0.00872490f, 0.09714122f, -0.09614518f, -0.01089267f, -0.01862419f, -0.13257259f, 0.02080240f, 
    0.38514498f, 0.01068143f, 0.01952782f, -0.03669836f, -0.07907914f, -0.20751005f, -0.09117473f, 0.33996612f, 
    -0.05619464f, 0.04216643f, -0.05106069f, 0.18223545f, 0.21405146f, 0.21883261f, 0.05453299f, -0.04623755f, 
    0.06460798f, 0.03080710f, 0.04545303f, 0.02222711f, 0.18145190f, -0.07072260f, 0.07629586f, 0.00019120f, 
    0.05784823f, -0.03390880f, -0.10124260f, 0.15855344f, 0.06221716f, -0.14123203f, -0.06664218f, -0.10691904f, 
    0.08425307f, -0.14697850f, -0.07916044f, 0.07615145f, 0.09012696f, -0.21916386f, 0.24803907f, 0.01725528f, 
    -0.16452606f, -0.07127272f, -0.04489391f, 0.09646633f, 0.00010829f, -0.03206695f, 0.23014852f, 0.05622252f, 
    0.05267871f, -0.10754341f, 0.02543070f, -0.01281636f, -0.02656457f, 0.01854991f, 0.01556886f, -0.00369201f, 
    -0.06049209f, 0.06571558f, -0.03486184f, 0.10117234f, 0.15611561f, -0.12665530f, -0.00598319f, 0.13108222f, 
    -0.07101041f, 0.00296981f, 0.04344793f, 0.04502172f, 0.24949077f, 0.38352820f, 0.20204519f, 0.14855832f, 
    0.00416879f, -0.12468033f, 0.01626479f, 0.40939298f, 0.01496199f, 0.02779159f, 0.09233283f, 0.18335678f, 
    -0.22480601f, -0.04925979f, 0.02691536f, 0.11212622f, -0.43373105f, -0.00220979f, 0.02994413f, -0.11977255f, 
    -0.02129878f, -0.02372387f, -0.07920481f, -0.17659894f, 0.06247002f, 0.14096165f, 0.00395068f, 0.06657121f, 
    -0.15156411f, 0.05992310f, 0.45560569f, -0.08350176f, 0.04326043f, -0.00421731f, -0.12198027f, 0.01371836f, 
    0.00534893f, 0.09115366f, 0.00511035f, 0.02623286f, -0.35816225f, -0.31271189f, -0.02305942f, 0.21216394f, 
    -0.02502580f, 0.04312355f, 0.06864646f, -0.07867640f, -0.00131223f, 0.01092992f, 0.22111584f, 0.15373474f, 
    -0.24987064f, -0.26262829f, 0.07034161f, -0.15361807f, 0.06727007f, 0.00483872f, 0.02151809f, 0.04195149f, 
    0.02719004f, -0.09282118f, -0.07713907f, -0.06161812f, -0.38365674f, 0.00584035f, 0.14055449f, 0.07662039f, 
    0.21238457f, 0.14667211f, -0.19239914f, 0.07665841f, -0.03956246f, 0.03114373f, -0.02255306f, -0.09205180f, 
    0.03804461f, -0.25544918f, 0.20264407f, 0.08909663f, 0.03373780f, 0.10505250f, 0.06998312f, 0.22089881f, 
    -0.04698834f, 0.16337734f, -0.00315820f, 0.12793343f, -0.09347266f, 0.09152879f, -0.35448867f, 0.30540204f, 
    -0.02783174f, 0.46670467f, 0.44816020f, 0.16692643f, -0.04575410f, 0.04126949f, -0.09088816f, 0.08929299f, 
    -0.15029484f, -0.29638955f, -0.01834442f, 0.19895163f, 0.06554618f, 0.17259961f, 0.32579398f, 0.00860415f, 
    -0.03788807f, 0.00125786f, 0.25103197f, 0.05849569f, -0.05694064f, -0.20508610f, -0.15872298f, 0.04539375f, 
    -0.05329692f, 0.04134139f, -0.04340449f, -0.16854978f, 0.10058925f, -0.01799462f, 0.04915854f, 0.03825426f, 
    -0.04769192f, 0.18514162f, 0.35273448f, 0.08510694f, -0.05736919f, -0.11702398f, 0.00194527f, -0.13705218f, 
    -0.01086008f, 0.20851883f, 0.11300445f, 0.08258442f, -0.11128620f, -0.10371000f, -0.13695820f, -0.05168474f, 
    0.04380760f, -0.10993668f, -0.04498225f, 0.02834487f, 0.09348658f, -0.34263036f, -0.07145087f, -0.11451848f, 
    0.05382375f, 0.03784367f, 0.01812660f, 0.25111520f, -0.08779512f, 0.04290511f, -0.04274542f, -0.07854594f, 
    0.00734392f, -0.10025469f, 0.12844919f, 0.17967968f, -0.34512979f, 0.02785343f, 0.10900194f, 0.04879973f, 
    -0.00954317f, -0.03788015f, 0.11813828f, 0.27528501f, 0.06626529f, 0.06139505f, -0.01059245f, 0.10405743f, 
    -0.16720477f, 0.01565562f, -0.02753208f, -0.13145968f, -0.00258537f, -0.13686951f, -0.09563294f, 0.10786083f, 
    -0.14219914f, -0.01500306f, 0.05041023f, 0.06289265f, 0.03242808f, -0.07343692f, 0.04234853f, 0.00095465f, 
    -0.04743341f, 0.04764691f, 0.04139455f, 0.05187490f, 0.03089034f, -0.17395484f, -0.07083905f, -0.24901606f, 
    -0.14083393f, -0.05516999f, 0.12629004f, 0.00318673f, 0.12465827f, 0.20975730f, 0.20070758f, -0.12539293f, 
    0.27380770f, 0.12971388f, 0.06169746f, 0.22051665f, -0.17696227f, -0.11796837f, 0.24126531f, -0.04279194f, 
    0.12048628f, 0.01115943f, 0.07186731f, 0.18849656f, -0.08213919f, 0.05143242f, -0.05447700f, 0.02779035f, 
    -0.07165538f, 0.08800030f, 0.15263729f, -0.05452072f, -0.11194276f, 0.01727368f, 0.00824433f, -0.07787190f, 
    -0.03021337f, -0.05620609f, -0.12189856f, 0.08380020f, -0.08106953f, 0.13597147f, -0.21635599f, -0.05602989f, 
    0.09136701f, 0.04611591f, -0.05271944f, 0.25628072f, -0.08946919f, 0.07424777f, -0.11930670f, -0.01156305f, 
    -0.02524889f, 0.10809180f, 0.04890661f, 0.05901755f, -0.00002183f, -0.11912610f, -0.01570705f, -0.14021824f, 
    0.08092691f, -0.00256956f, 0.09666745f, 0.10164890f, 0.29751700f, -0.13713926f, 0.32413960f, 0.09660205f, 
    0.15317769f, -0.06238836f, 0.05395542f, 0.10539249f, 0.13969991f, -0.08038943f, 0.08904994f, -0.03154654f, 
    -0.65447408f, -0.11612701f, -0.38880861f, 0.11812856f, 0.01948827f, 0.09399994f, 0.18337962f, -0.13290034f, 
    0.08222249f, 0.14770623f, 0.01662721f, 0.17003313f, -0.07790968f, 0.14474417f, -0.46831900f, -0.32824698f, 
    0.14172839f, 0.16318767f, 0.23315781f, -0.30462283f, -0.05825073f, 0.02399380f, 0.07832810f, 0.06393674f, 
    -0.22595358f, -0.02915616f, -0.11833389f, -0.18413392f, 0.12406556f, 0.12182331f, -0.12277021f, -0.03294365f, 
    -0.01679112f, -0.12754534f, -0.10465480f, 0.10375717f, -0.00910899f, -0.04300581f, 0.00866050f, 0.04650271f, 
    -0.07964879f, 0.04579124f, -0.02350976f, 0.19248727f, 0.14039887f, 0.14845163f, 0.16888276f, -0.01974743f, 
    0.01639079f, 0.08779030f, 0.18487144f, -0.11680910f, -0.06691857f, 0.03073128f, -0.02960008f, 0.33179969f, 
    0.06240294f, 0.17683874f, 0.10848778f, 0.01844879f, 0.04367301f, -0.02489002f, 0.12040932f, 0.05656840f, 
    -0.09616419f, -0.09515470f, -0.07097205f, -0.09566045f, 0.11435927f, 0.06025163f, -0.09096788f, 0.06247559f, 
    -0.03622588f, 0.10565198f, 0.09184886f, 0.16016960f, 0.01508056f, -0.09315203f, 0.00541887f, 0.10786697f, 
    -0.01801035f, 0.20266812f, 0.27364486f, -0.09263831f, 0.13465676f, 0.33707806f, -0.11426668f, -0.08754581f, 
    -0.03705036f, 0.16037214f, -0.07552563f, -0.02776976f, 0.20295081f, -0.07162872f, 0.10173348f, -0.16112003f, 
    -0.02473829f, 0.00609680f, -0.10923395f, 0.02089040f, -0.09352645f, -0.05841536f, 0.10753564f, -0.09801772f, 
    -0.08675765f, 0.01107026f, -0.05338242f, 0.05380139f, -0.20254198f, -0.03394656f, 0.05288559f, -0.04047116f, 
    0.05729003f, 0.06412245f, 0.14102250f, 0.01740719f, 0.04071313f, 0.04250726f, 0.01019893f, 0.08516899f, 
    0.04016735f, 0.14808892f, 0.01317283f, 0.16345176f, 0.09534359f, -0.20107165f, 0.13951556f, 0.16662757f, 
    0.05212221f, -0.09453541f, -0.13476510f, 0.15411352f, 0.14268588f, 0.29073334f, -0.18965775f, -0.10346738f, 
    -0.19198956f, 0.10348416f, 0.20428389f, -0.00471780f, -0.07011564f, -0.00685176f, 0.05765382f, 0.03262101f, 
    -0.05318443f, -0.02872954f, -0.07174364f, 0.00563801f, -0.12072264f, 0.01367608f, -0.06859832f, -0.01995385f, 
    0.02296555f, -0.01019134f, 0.01783173f, 0.02092170f, 0.18777114f, 0.14170630f, 0.06874951f, -0.03107462f, 
    0.04058069f, 0.01466477f, 0.18730079f, -0.00884238f, 0.03235474f, 0.06382841f, 0.13104455f, 0.07123209f, 
    -0.15879066f, -0.37759492f, -0.15887144f, -0.05997381f, -0.04148570f, 0.03545111f, -0.02478055f, -0.08392499f, 
    -0.06148645f, -0.05442858f, -0.03270264f, 0.07189596f, 0.10709234f, -0.33379966f, -0.12442034f, 0.06402811f, 
    -0.14993076f, 0.03409347f, -0.08633453f, -0.04267798f, 0.04447564f, 0.00849299f, 0.10014655f, 0.00362105f, 
    0.13272899f, 0.15518904f, 0.30672917f, -0.23486291f, 0.02675360f, -0.00503527f, -0.01542688f, 0.04117412f, 
    0.06860279f, -0.04392655f, 0.08928581f, 0.11398812f, 0.08122576f, 0.33655831f, -0.25984955f, -0.01905284f, 
    0.06817622f, -0.09283768f, -0.00931629f, -0.05393672f, -0.06236275f, 0.04009984f, -0.02453682f, 0.08381810f, 
    0.20002630f, 0.17491174f, -0.00447625f, 0.09037341f, 0.06066772f, 0.05372974f, 0.01396023f, 0.01797679f, 
    0.07373580f, 0.09820975f, 0.10089330f, -0.00654770f, -0.08763114f, 0.01322639f, -0.09418958f, 0.02558219f, 
    -0.19719742f, 0.03080635f, -0.06614148f, -0.04563564f, 0.00877646f, 0.02502555f, 0.03719431f, 0.08477951f, 
    -0.04914168f, -0.00504180f, 0.02479115f, -0.19034663f, -0.07187990f, -0.04740008f, -0.10707871f, 0.05745386f, 
    -0.08348083f, -0.04292805f, -0.13128911f, -0.02085733f, -0.19558343f, -0.09664100f, -0.15261598f, -0.07585493f, 
    -0.08163846f, 0.00149022f, 0.01443864f, 0.00857254f, 0.03117858f, 0.08373519f, -0.02326010f, 0.13938665f, 
    -0.51529312f, 0.09418410f, 0.08940277f, -0.05039001f, -0.09509632f, 0.08853673f, -0.03736514f, -0.04593452f, 
    0.09956233f, 0.06825523f, 0.03407615f, 0.06932591f, 0.45608398f, 0.05542457f, -0.23457395f, -0.07990726f, 
    0.07640842f, 0.08348560f, 0.03560463f, 0.08513930f, 0.17019768f, -0.13544466f, -0.03940648f, -0.01412699f, 
    -0.07310376f, 0.09677896f, -0.06350977f, 0.00440916f, 0.10661981f, -0.06514151f, 0.01089773f, -0.05047868f, 
    -0.17268969f, -0.02641736f, -0.02367944f, 0.02476515f, -0.23456304f, 0.23456298f, 0.12111243f, -0.05677666f, 
    -0.18786475f, 0.11210464f, -0.03496599f, -0.01013315f, -0.15658481f, -0.15981555f, -0.17583212f, -0.00176812f, 
    -0.06810838f, 0.17467272f, 0.00365829f, 0.24623808f, 0.10171771f, 0.21508044f, 0.16145323f, -0.31429932f, 
    0.05948228f, 0.14963979f, 0.04020778f, 0.10387942f, 0.32216462f, 0.35516986f, 0.06413303f, 0.43588337f, 
    0.07479277f, 0.04222765f, 0.16173106f, 0.35125744f, -0.03669198f, -0.02125448f, 0.06122921f, -0.05671573f, 
    -0.00130004f, -0.12032262f, -0.08457531f, 0.03607427f, 0.01788328f, 0.02353938f, -0.06346256f, 0.02520411f, 
    -0.03188223f, -0.02254910f, -0.01733153f, 0.10464666f, 0.16642661f, 0.11775716f, -0.31108516f, 0.22147477f, 
    0.25652727f, 0.14135142f, 0.13804235f, 0.36683524f, 0.02803753f, 0.08868800f, -0.23836657f, -0.01954980f, 
    -0.06228064f, 0.03834548f, 0.19821413f, 0.08648576f, -0.02809639f, -0.13007487f, -0.02066949f, 0.00207892f, 
    0.05983473f, 0.05471943f, 0.03143541f, 0.03756855f, 0.00335200f, -0.01214150f, 0.13766214f, -0.03324859f, 
    0.03138069f, 0.11312721f, -0.08438158f, -0.07293803f, -0.19652008f, -0.15737727f, -0.00410766f, -0.02059074f, 
    -0.71564621f, 0.44658926f, -0.06541523f, 0.10122340f, 0.05044052f, 0.13757567f, 0.07881280f, 0.06926275f, 
    -0.04110053f, -0.13487150f, 0.00474409f, -0.02458567f, -0.00811314f, 0.17838834f, -0.26693454f, 0.05845441f, 
    -0.07343527f, -0.13679826f, 0.03078156f, -0.07669821f, -0.08686486f, -0.02207594f, -0.01761668f, 0.03944533f, 
    0.14504991f, -0.10593875f, 0.02212709f, 0.01288366f, 0.04018077f, 0.09406307f, -0.09902227f, 0.14430255f, 
    -0.09991122f, -0.10977896f, -0.14519669f, -0.02940792f, -0.04640289f, 0.28160793f, 0.14301857f, 0.08194237f, 
    -0.06447543f, 0.10207196f, -0.06746959f, -0.03300677f, -0.09229255f, 0.05595936f, 0.03429085f, 0.06250621f, 
    0.23075773f, 0.25350237f, -0.04419860f, -0.07971283f, -0.15844953f, 0.03017526f, 0.07744657f, -0.04731725f, 
    0.05966695f, 0.02638135f, 0.00779282f, -0.07144970f, 0.15612857f, 0.09404837f, 0.02682410f, 0.14798081f, 
    -0.01258801f, -0.10961597f, 0.01062744f, -0.04881485f, -0.06159710f, 0.03986020f, 0.17049140f, 0.11979479f, 
    -0.00924736f, 0.37742344f, 0.11810794f, 0.14275227f, 0.03461017f, 0.08502340f, -0.01978342f, -0.06680565f, 
    -0.11526125f, 0.00635335f, 0.02125948f, -0.04901793f, 0.04288369f, 0.25207859f, -0.20839015f, 0.29646587f, 
    -0.02335625f, 0.01777438f, -0.11386730f, -0.11353908f, 0.06626234f, 0.00845652f, -0.10443448f, -0.06668895f, 
    0.14563303f, -0.02889977f, 0.10300638f, 0.02520913f, 0.01264179f, 0.09490459f, 0.10939630f, -0.05006813f, 
    0.09803505f, 0.17098749f, 0.05604268f, -0.01555928f, -0.25505927f, -0.16457777f, 0.12213859f, -0.00814895f, 
    -0.00753293f, 0.05868736f, -0.06708539f, -0.07709299f, -0.01266249f, 0.05762147f, 0.01570390f, 0.08774087f, 
    0.12451231f, 0.12930185f, 0.09270136f, 0.21757157f, -0.08257865f, 0.24184790f, 0.02048075f, 0.21681419f, 
    -0.19101733f, 0.07682078f, -0.08033912f, -0.01760823f, 0.04278681f, 0.41419554f, 0.05828501f, -0.00889503f, 
    -0.08321831f, -0.02000774f, 0.00752180f, 0.12744498f, 0.08651643f, 0.00960280f, -0.03602190f, -0.04919956f, 
    0.03086703f, -0.30831841f, 0.09033585f, 0.01989478f, 0.10688872f, -0.07189605f, -0.14120039f, 0.02458323f, 
    -0.11517758f, 0.08160707f, -0.01351665f, 0.08224129f, -0.09066607f, -0.05272341f, 0.27436501f, 0.25268605f, 
    0.06405713f, 0.12068540f, 0.12579516f, 0.00116081f, 0.00582085f, 0.02890857f, 0.02790497f, -0.00642028f, 
    -0.35333797f, -0.64591718f, -0.15519215f, -0.30897582f, 0.13671005f, -0.02034553f, -0.04915673f, 0.06040200f, 
    0.08350231f, -0.04575123f, -0.00406014f, 0.06133672f, -0.35426185f, 0.19506437f, -0.00766717f, 0.02500703f, 
    -0.00625414f, 0.08206263f, -0.16256104f, 0.15459847f, -0.17803833f, -0.08830480f, -0.02416425f, 0.11787722f, 
    -0.05262041f, 0.19637139f, 0.62503082f, 0.11647864f, -0.06147567f, 0.17899629f, 0.01011317f, 0.17248711f, 
    0.01443095f, -0.01603680f, -0.11111411f, -0.02228864f, 0.14800169f, 0.21276413f, -0.21956618f, 0.45383245f, 
    -0.08487280f, 0.13332245f, 0.20252265f, 0.15128784f, 0.07124173f, 0.19848377f, -0.06311013f, 0.02008644f, 
    0.18811905f, 0.18613175f, 0.28069150f, 0.33919778f, 0.07818318f, 0.08450811f, 0.12957776f, 0.15567765f, 
    -0.07929406f, -0.02194931f, 0.05422689f, -0.05212909f, -0.16111797f, -0.13882081f, -0.06575879f, -0.09616490f, 
    -0.18913282f, 0.11645139f, -0.11775790f, -0.35876620f, -0.01160661f, 0.03589682f, 0.09158339f, -0.00082177f, 
    0.24534886f, 0.18489519f, 0.15509324f, -0.05425106f, -0.03779995f, -0.02725435f, 0.08272335f, 0.03271051f, 
    -0.00285644f, 0.11206511f, 0.03550976f, -0.07996368f, -0.24200317f, -0.34554359f, -0.46263352f, 0.00941432f, 
    0.16228782f, 0.05796066f, 0.02676428f, 0.08172281f, 0.16786642f, -0.08730920f, 0.14027478f, 0.10834299f, 
    -0.56832916f, 0.26606473f, 0.22638871f, 0.15606396f, -0.04803167f, -0.00965571f, 0.01681169f, -0.26822105f, 
    0.05772986f, -0.02749894f, -0.06469229f, 0.08559623f, 0.17460154f, -0.04411060f, 0.38732499f, 0.21768099f, 
    0.00164082f, -0.12953113f, -0.07021799f, -0.07807098f, -0.10310674f, 0.00850769f, -0.02388727f, -0.03506118f, 
    -0.01997017f, 0.01988084f, 0.01148149f, 0.06148732f, -0.20307052f, 0.06357287f, 0.12239493f, -0.17021583f, 
    0.05949607f, 0.09697644f, -0.01372435f, 0.05524183f, -0.07648532f, -0.26708001f, 0.04130896f, -0.11552426f, 
    0.05410026f, -0.07961161f, 0.02674414f, 0.04323266f, -0.13622598f, -0.02850736f, -0.13564356f, 0.05899003f, 
    -0.07357502f, 0.22338322f, 0.07076024f, 0.47866541f, -0.00652733f, 0.06778955f, 0.26690325f, 0.30090761f, 
    -0.17684282f, -0.02794612f, -0.07171439f, 0.24779242f, 0.12686108f, 0.22624449f, 0.09119676f, -0.16062380f, 
    -0.03721113f, 0.01484242f, 0.07664258f, 0.12857789f, -0.02853939f, 0.13721026f, -0.04586044f, -0.01896792f, 
    0.06913897f, -0.08306598f, -0.01769027f, -0.01747156f, 0.02708462f, -0.07066331f, -0.02716654f, 0.09339703f, 
    -0.01129933f, -0.06255496f, 0.01539500f, 0.02252663f, 0.07132076f, 0.08138755f, 0.13623536f, 0.02546735f, 
    -0.00724790f, 0.02465378f, 0.01990948f, -0.07874916f, 0.11735238f, 0.07725248f, 0.06594703f, -0.09726810f, 
    -0.04244094f, -0.11163320f, -0.23518170f, 0.00093693f, 0.03359934f, 0.05215990f, -0.11256616f, 0.05260612f, 
    0.09722142f, -0.00259774f, 0.09993204f, 0.10032581f, 0.10601448f, -0.25901705f, -0.03275674f, 0.14799985f, 
    -0.16768302f, 0.13738978f, -0.09821834f, 0.03034163f, -0.10437937f, -0.13259843f, -0.03457040f, 0.06715946f, 
    -0.02373617f, 0.02448196f, 0.56460840f, -0.02863184f, -0.12917864f, 0.23376198f, -0.02968135f, -0.03596736f, 
    -0.07152262f, -0.08534151f, -0.03950879f, 0.18152824f, 0.15497327f, 0.35131231f, -0.22885905f, 0.18721358f, 
    -0.13670751f, -0.08857381f, -0.09266130f, 0.08294017f, -0.03372836f, 0.06403180f, -0.04049172f, 0.04441815f, 
    0.19452123f, 0.14979672f, 0.08572835f, 0.10599983f, 0.14308663f, 0.04804884f, 0.04858544f, -0.00381237f, 
    -0.15972528f, -0.06742036f, 0.10053992f, -0.15292096f, 0.01784515f, -0.01342668f, -0.03166173f, 0.06565164f, 
    -0.15316689f, -0.00440793f, 0.08394042f, -0.04370267f, -0.01150643f, 0.08965714f, 0.01392881f, -0.09482063f, 
    0.02461994f, 0.06441846f, 0.10524841f, -0.28774643f, -0.16035654f, -0.00639026f, 0.02224819f, 0.01031633f, 
    0.01243504f, 0.00193617f, 0.02046258f, -0.00131096f, 0.09622827f, 0.07989607f, -0.16017370f, -0.01949793f, 
    0.04301001f, 0.05161241f, 0.01819438f, -0.07270203f, 0.12788664f, -0.08281852f, 0.05489418f, 0.02100385f, 
    -0.47554806f, 0.11686899f, 0.21858941f, 0.14534841f, -0.25565800f, 0.06549389f, 0.07619904f, 0.02045576f, 
    -0.03711667f, -0.01748916f, -0.10699286f, 0.02653507f, 0.14798686f, 0.14634907f, -0.08145538f, -0.07428645f, 
    -0.02803602f, -0.01885096f, -0.05330892f, 0.10940585f, 0.02130041f, -0.23383528f, -0.11882965f, -0.11579880f, 
    -0.11255974f, 0.16128327f, -0.14273784f, 0.13873540f, -0.10531455f, -0.04584647f, 0.01411881f, -0.01247906f, 
    0.01561177f, -0.03866640f, -0.00191725f, -0.26533481f, 0.02584263f, -0.08938925f, -0.19878575f, -0.00562187f, 
    -0.06508754f, -0.06872590f, 0.04286506f, -0.12905565f, 0.03569781f, 0.27063140f, 0.03133307f, 0.38732255f, 
    -0.04694015f, 0.26704553f, 0.00486467f, 0.04861270f, 0.27850023f, 0.00975454f, 0.12168012f, 0.26982018f, 
    -0.29528719f, 0.06891461f, 0.00661022f, -0.43087989f, 0.20885618f, -0.01196130f, -0.10580275f, 0.11186831f, 
    -0.15551411f, -0.10406797f, -0.08260807f, 0.10848792f, 0.01614594f, -0.06506071f, -0.17485707f, 0.02538613f, 
    0.08015854f, -0.09847368f, -0.20315123f, 0.14630760f, 0.04162033f, -0.17374912f, 0.06389280f, 0.24696785f, 
    0.10010627f, 0.08071145f, 0.09607457f, -0.20725891f, -0.01867362f, -0.06081619f, -0.12559028f, -0.01765029f, 
    -0.01684914f, 0.03633019f, 0.08732643f, -0.07813450f, -0.02589871f, -0.11014222f, -0.04826702f, 0.06880960f, 
    0.19909132f, 0.42236793f, 0.12191019f, -0.00879455f, -0.19286965f, -0.13722672f, -0.13807067f, 0.16690642f, 
    -0.18807207f, -0.03256223f, -0.07887848f, -0.23556201f, 0.04401246f, -0.02332162f, 0.21259731f, 0.10148248f, 
    0.08005267f, 0.02788461f, 0.06317357f, 0.05016094f, -0.22398935f, 0.00948078f, 0.08781879f, 0.15258421f, 
    0.23877412f, 0.06209610f, 0.07628793f, 0.17828993f, -0.06196736f, 0.08414038f, -0.16672902f, 0.11329750f, 
    -0.22197430f, 0.00261945f, 0.06035293f, -0.11978172f, 0.06621932f, 0.00334719f, 0.99381375f, -0.05311433f, 
    0.16277826f, 0.05916510f, -0.33165842f, 0.11304393f, 0.00477031f, -0.20400713f, 0.03317981f, -0.34167901f, 
    -0.00479345f, 0.02023491f, 0.01848374f, 0.03170964f, -0.06519199f, 0.17637065f, -0.00742064f, -0.01678047f, 
    0.19119780f, 0.07346804f, 0.11773914f, -0.01890770f, -0.00072622f, 0.48997104f, -0.42558488f, 0.02880665f, 
    0.20833904f, -0.10267317f, 0.16184002f, -0.07705888f, -0.21324961f, -0.18384306f, -0.09574943f, -0.09447002f, 
    0.07806396f, 0.25988019f, -0.09870456f, 0.17456803f, -0.05859730f, 0.03673884f, 0.02519057f, 0.19979768f, 
    0.02715527f, -0.13302141f, -0.11257786f, -0.11358368f, 0.08985548f, -0.03301433f, -0.09896185f, -0.36284789f, 
    0.03815063f, 0.23403752f, 0.07563996f, 0.27568433f, -0.07255778f, -0.00992403f, 0.02208318f, -0.02863155f, 
    0.32310998f, -0.06522384f, -0.07205401f, 0.13439807f, 0.19753431f, -0.02483176f, 0.04208455f, 0.17647423f, 
    0.00333431f, 0.00962487f, -0.09544516f, 0.10196007f, -0.25303051f, 0.30911151f, 0.06338017f, 0.07957547f, 
    0.01575630f, 0.00457614f, 0.08164150f, 0.10854752f, 0.00848790f, 0.17091611f, 0.11778465f, 0.21212727f, 
    0.07564764f, -0.40017956f, 0.23589307f, -0.36467308f, -0.03878780f, 0.02327134f, -0.19641355f, 0.04804137f, 
    -0.15336710f, -0.16251324f, 0.14673220f, -0.31175634f, 0.28519851f, -0.05512493f, -0.03529749f, -0.03536861f, 
    -0.19672446f, 0.06284787f, 0.11920433f, -0.02972214f, 0.24708779f, 0.30286029f, 0.26729670f, 0.33107841f, 
    0.36419767f, -0.13048933f, 0.19950557f, -0.13987613f, -0.20202145f, 0.05883894f, -0.03479145f, -0.32382494f, 
    -0.19526853f, -0.19340165f, 0.02746309f, -0.21918987f, -0.01152043f, -0.18855980f, -0.33191594f, -0.15720630f, 
    0.11501698f, 0.05702649f, -0.05503229f, 0.17701773f, -0.13654469f, -0.06667319f, -0.03036860f, 0.02572739f, 
    0.52206820f, 0.44105664f, 0.28764436f, -0.33497763f, 0.27004087f, -0.29170308f, 0.06805498f, 0.13372034f, 
    0.18334280f, 0.10340285f, 0.13372621f, -0.01811165f, 0.20108761f, 0.01819280f, -0.00947378f, -0.09645875f, 
    0.02602318f, 0.12780719f, -0.04195865f, 0.14949785f, -0.19873601f, 0.01998438f, 0.05489708f, 0.01243331f, 
    -0.13452029f, 0.16747276f, 0.17342238f, -0.05988925f, -0.00459733f, -0.37798136f, -0.03184943f, 0.03287934f, 
    -0.12449348f, -0.14244124f, 0.09266755f, 0.03842694f, 0.08394046f, 0.18940696f, -0.14034642f, -0.42360857f, 
    0.19255906f, 0.04503919f, 0.23371238f, 0.13210729f, -0.08355612f, -0.15160316f, 0.09304879f, 0.00937455f, 
    0.30771986f, 0.17864113f, 0.15988640f, -0.03693599f, 0.05085665f, 0.12712397f, 0.05257058f, -0.03284740f, 
    -0.08788327f, 0.05021125f, -0.09697608f, -0.07990168f, -0.72574991f, 0.11401797f, -0.03205049f, -0.10411484f, 
    0.03571054f, 0.08994042f, -0.14677061f, -0.09679040f, -0.09135576f, -0.01859191f, -0.00834539f, -0.24561335f, 
    -0.02659289f, -0.07971199f, -0.09959090f, 0.15364252f, 0.13425040f, 0.09559480f, 0.17203616f, 0.14286058f, 
    0.06822637f, 0.19335887f, 0.18016061f, 0.07284530f, 0.30215067f, 0.03775078f, 0.06917610f, -0.28317729f, 
    0.09699695f, 0.06488065f, -0.29095688f, 0.02542718f, -0.05497666f, 0.01436176f, 0.13609207f, -0.02178312f, 
    0.17158765f, 0.04608945f, 0.06720912f, 0.15796256f, 0.05810319f, 0.03401978f, 0.13629517f, -0.16667664f, 
    -0.05644377f, -0.09158432f, -0.07029058f, 0.03401786f, 0.02569073f, 0.01558818f, 0.00971697f, -0.17964101f, 
    -0.02328374f, -0.12980135f, 0.05927966f, 0.25397864f, -0.02993086f, -0.10128341f, 0.01684273f, -0.05679075f, 
    0.76429427f, -0.04062006f, -0.03997085f, -0.21811855f, -0.14393726f, 0.04588714f, 0.05113692f, 0.00802804f, 
    0.17287913f, -0.06639580f, -0.06218343f, -0.07469717f, 0.00124840f, 0.16826294f, 0.14980982f, 0.22467713f, 
    0.03104038f, 0.02751565f, 0.19107829f, 0.00516237f, 0.21282397f, 0.08124919f, 0.04319644f, 0.28473192f, 
    -0.00725533f, -0.02473948f, -0.06441865f, -0.02745704f, -0.01134586f, -0.03066601f, 0.07537418f, 0.06105129f, 
    -0.02603774f, 0.00218368f, -0.03230172f, -0.04178074f, -0.09027464f, -0.00776107f, -0.05643045f, -0.04140649f, 
    -0.05299435f, -0.05616015f, 0.02090464f, -0.02578372f, 0.08927611f, 0.01869479f, -0.01512994f, 0.03040713f, 
    0.00973352f, -0.08111837f, -0.01360362f, -0.08582116f, 0.05735169f, -0.09957667f, -0.04219130f, -0.08163270f, 
    0.03735933f, -0.01890902f, -0.05035571f, -0.06068159f, -0.04614019f, 0.01376394f, -0.04465297f, 0.00689085f, 
    -0.05249849f, -0.03670988f, 0.04932483f, -0.00802624f, -0.06132302f, -0.02438340f, -0.08663642f, -0.05500109f, 
    -0.02979652f, -0.05703043f, -0.00603428f, -0.09576336f, -0.08527502f, -0.05780594f, -0.05946136f, -0.06606468f, 
    0.06780388f, -0.00255668f, -0.06865400f, -0.07482334f, -0.00461802f, -0.06360278f, -0.02965574f, -0.04044462f, 
    -0.04643805f, -0.01428486f, -0.06711884f, -0.03184605f, -0.08673356f, 0.03311469f, -0.00506872f, -0.10131706f, 
    -0.08472191f, -0.05262687f, 0.01363765f, -0.07799389f, -0.06002849f, -0.03425331f, 0.00216771f, 0.03920195f, 
    -0.06181886f, 0.02271998f, 0.02464360f, 0.04154173f, 0.05148020f, 0.05255620f, -0.05220891f, -0.00581408f, 
    -0.05806739f, 0.01133840f, -0.05926409f, -0.00980824f, 0.01832964f, -0.06743743f, -0.02903678f, 0.05790500f, 
    -0.01915372f, 0.08915525f, 0.01198750f, 0.01079925f, 0.03504946f, -0.06798024f, -0.02995905f, 0.03117847f, 
    -0.05151184f, -0.10570380f, -0.01485234f, -0.01604384f, 0.03330510f, 0.04513118f, -0.04857508f, -0.05682257f, 
    0.07215255f, 0.05717071f, 0.03265726f, 0.04606269f, -0.05106604f, 0.02707647f, 0.02186888f, 0.04438440f, 
    0.00600125f, -0.01479249f, -0.05967407f, 0.05637378f, 0.06532286f, -0.02186876f, 0.01423023f, -0.06579364f, 
    -0.06978162f, -0.09488074f, -0.07123107f, -0.05804384f, -0.04523452f, 0.01880701f, -0.03945114f, 0.00470892f, 
    -0.03997283f, 0.00829625f, -0.09304050f, -0.04585935f, -0.06006632f, 0.01104454f, -0.02783697f, 0.02954230f, 
    -0.08603155f, 0.02326066f, -0.03650945f, -0.05649502f, -0.05808478f, -0.05708593f, -0.07039382f, 0.00391482f, 
    -0.07520517f, -0.06585206f, 0.02886367f, 0.00760277f, -0.00074318f, -0.07355680f, 0.01212123f, -0.01429015f, 
    0.01264345f, -0.01129005f, -0.00138505f, -0.05608714f, 0.05227021f, -0.02115940f, 0.01593785f, -0.07033651f, 
    -0.05526356f, -0.03150924f, -0.08829760f, 0.02978963f, 0.01917915f, 0.00793785f, -0.09974471f, -0.00889519f, 
    -0.04430538f, -0.00144940f, -0.04946251f, 0.03349701f, -0.01002537f, 0.01161970f, -0.01687450f, -0.00714323f, 
    0.00329045f, -0.06686307f, -0.06718220f, -0.01438850f, -0.01500057f, 0.02096712f, -0.02213987f, -0.02965705f, 
    0.10235502f, -0.04306409f, -0.12840010f, 0.00575373f, 0.06811805f, -0.05067629f, 0.09213552f, 0.08942094f, 
    0.03523748f, 0.15440795f, 0.04486836f, 0.09716728f, 0.15458512f, 0.06714711f, -0.16754159f, -0.08972165f, 
    0.07864338f, -0.04438124f, 0.05009480f, -0.06174477f, -0.01580307f, 0.04442314f, -0.13650678f, -0.09929632f, 
    0.21046691f, 0.19247344f, -0.02943738f, 0.28773889f, 0.00392392f, 0.03119083f, 0.18096441f, 0.18773426f, 
    0.01702151f, 0.03821770f, 0.09886910f, 0.04472848f, -0.10893574f, 0.07043066f, 0.00170101f, 0.23498929f, 
    0.09790358f, -0.08061641f, 0.02618654f, 0.03047729f, -0.02623164f, 0.11463303f, -0.00061987f, 0.17023566f, 
    -0.06870298f, 0.03855421f, -0.11315341f, -0.13517900f, -0.01529024f, 0.12503782f, 0.03702707f, 0.01463292f, 
    0.10665509f, -0.06502766f, -0.02497141f, -0.17494377f, -0.19539738f, -0.17025624f, -0.01595907f, 0.33099583f, 
    -0.04710386f, -0.07792320f, 0.04606519f, -0.03821943f, -0.05427369f, 0.01344690f, 0.11875983f, 0.14467864f, 
    0.05245803f, 0.33579671f, 0.13676989f, -0.08284105f, -0.05517377f, -0.07881510f, -0.07903302f, 0.04588091f, 
    0.00046247f, 0.00784736f, 0.06775447f, 0.00217205f, -0.29476315f, 0.32467130f, -0.00901527f, 0.21184334f, 
    0.07721613f, -0.03452570f, 0.02919944f, -0.06047769f, -0.29748628f, -0.06564183f, -0.03784374f, 0.07348698f, 
    0.36541405f, -0.13943727f, 0.02991605f, 0.23786798f, -0.08944964f, 0.15551555f, -0.11235896f, 0.11691149f, 
    -0.05167306f, 0.05973731f, 0.08996969f, 0.01646655f, 0.18414240f, -0.20127009f, 0.41148821f, 0.23798379f, 
    -0.03328597f, 0.24766362f, 0.16243079f, 0.07706968f, 0.05725342f, 0.03262004f, -0.02401811f, -0.03375280f, 
    -0.04864135f, -0.21416499f, -0.05539565f, 0.43686667f, -0.11538687f, 0.04784678f, -0.01693656f, -0.09055949f, 
    -0.00371676f, -0.03881481f, 0.02624846f, 0.04024290f, 0.12396424f, 0.16479136f, 0.01299002f, -0.07815868f, 
    0.02051393f, -0.01939089f, 0.12710233f, -0.05489772f, 0.14943452f, 0.11522401f, 0.09600223f, -0.00772425f, 
    -0.07091481f, 0.00164909f, -0.14234290f, 0.09139226f, -0.04186690f, -0.05806498f, 0.06238566f, 0.18323937f, 
    0.11074823f, 0.12701754f, 0.11882264f, -0.04466396f, -0.07919998f, 0.07852954f, -0.03820812f, -0.14147419f, 
    -0.03929397f, -0.04697271f, -0.03736614f, -0.07916543f, 0.04245603f, -0.10345360f, 0.05058721f, -0.03489170f, 
    0.67487878f, -0.04944922f, -0.21071447f, -0.25722802f, 0.07247123f, -0.06956489f, 0.00379964f, -0.01685634f, 
    -0.11249318f, 0.06341419f, -0.03292638f, 0.00318075f, -0.44634333f, 0.11201823f, -0.52267671f, -0.03363327f, 
    0.04789973f, 0.01166717f, 0.08396655f, 0.42808548f, 0.07531206f, -0.06825583f, -0.13416828f, 0.02607469f, 
    0.05731549f, 0.02257487f, -0.04562615f, -0.02850884f, -0.01760934f, 0.03577749f, -0.07213180f, -0.06416526f, 
    0.05153073f, -0.07131951f, 0.02555405f, 0.06344447f, -0.06709917f, -0.05870398f, 0.03511460f, 0.04112064f, 
    -0.05681098f, -0.02325304f, -0.01613705f, 0.00169153f, -0.01793037f, -0.07600974f, -0.06966624f, 0.05445107f, 
    0.06601059f, -0.01229324f, -0.01232670f, 0.00684604f, -0.06768446f, 0.00994396f, 0.01866066f, 0.04988268f, 
    -0.00148926f, 0.05201589f, -0.05365112f, -0.00006963f, -0.04094801f, -0.07177655f, 0.02301795f, 0.01048123f, 
    -0.05861363f, -0.00993405f, -0.04858136f, 0.06363889f, -0.04064753f, -0.07521040f, -0.02818607f, -0.03731626f, 
    0.03416088f, -0.01245893f, 0.00140005f, 0.00567038f, 0.02079755f, 0.01678772f, 0.01309485f, -0.05763921f, 
    -0.00437874f, 0.02139425f, 0.03403802f, -0.05005854f, 0.00846058f, -0.05802937f, 0.02380354f, -0.07509698f, 
    -0.05485057f, -0.07138566f, 0.05391150f, 0.01726760f, -0.03696186f, -0.07647372f, -0.01720536f, -0.04204903f, 
    -0.02348504f, 0.01378448f, 0.00807689f, 0.01515755f, 0.04515703f, -0.05993845f, -0.05386398f, -0.02491492f, 
    -0.04476425f, 0.04549211f, 0.03872218f, -0.01877392f, 0.06772511f, -0.05722265f, 0.05429979f, 0.01691582f, 
    -0.04801925f, 0.03114189f, -0.02059983f, 0.00232468f, 0.02220802f, -0.05006842f, -0.01564083f, -0.01561777f, 
    0.01429616f, 0.03176316f, 0.04118133f, 0.03257100f, 0.00745965f, 0.01192014f, -0.05958335f, -0.05794989f, 
    0.04762702f, 0.05411432f, 0.05976241f, -0.05520786f, -0.05733751f, 0.05331846f, -0.03220920f, -0.01847000f, 
    0.00581355f, -0.07157221f, 0.03166207f, -0.01925316f, -0.04124911f, -0.02161008f, -0.05088807f, -0.05009868f, 
    0.03172670f, -0.05596029f, 0.01224011f, -0.03029706f, -0.06165661f, -0.00636505f, 0.05225779f, -0.00978539f, 
    -0.02504802f, 0.00469323f, -0.00850263f, -0.00084752f, 0.00346721f, -0.05032479f, -0.01102936f, -0.04018675f, 
    -0.04040969f, 0.01968237f, 0.05151954f, -0.06111074f, 0.02505450f, -0.05873938f, 0.06390007f, -0.03019337f, 
    -0.04887960f, -0.01711472f, 0.01439699f, -0.05084736f, 0.01709574f, -0.07360879f, 0.04929730f, 0.04487246f, 
    -0.06821433f, -0.03288916f, -0.01174690f, 0.02282008f, 0.00658412f, -0.03109303f, -0.02324178f, -0.05262912f, 
    0.02843856f, -0.02664619f, -0.06325267f, -0.01561964f, -0.00215480f, -0.06561608f, -0.05440231f, 0.02389470f, 
    0.02110506f, -0.06066883f, 0.03055868f, -0.05111022f, 0.01183766f, -0.01584249f, -0.00248645f, -0.07301863f, 
    -0.03149728f, 0.05662121f, 0.03425984f, -0.04050924f, 0.01313829f, -0.06030657f, -0.01665575f, -0.02426445f, 
    -0.06107695f, -0.03597512f, -0.05499939f, -0.03596573f, 0.01894415f, -0.00590097f, 0.03920761f, 0.02184951f, 
    -0.06723601f, 0.08001308f, -0.15092795f, 0.00849034f, 0.02434680f, -0.02608933f, 0.00693732f, 0.14139596f, 
    -0.06932466f, 0.01461757f, 0.04204459f, 0.15535606f, 0.02746519f, 0.25928211f, 0.13486332f, -0.06184199f, 
    -0.12136553f, 0.07408335f, -0.05970722f, -0.10799848f, 0.03100187f, -0.12215706f, -0.10610747f, -0.02823482f, 
    0.13793391f, -0.09233280f, -0.02793872f, 0.21387053f, 0.13247000f, 0.11369947f, 0.27243754f, -0.35513031f, 
    0.29146564f, 0.18187700f, 0.15244563f, -0.04554576f, 0.18116122f, 0.06710773f, -0.10041285f, 0.06894744f, 
    -0.08456153f, -0.00029244f, 0.00469380f, 0.30765811f, 0.04142345f, -0.04348999f, 0.08779551f, -0.00209988f, 
    0.20836717f, -0.22024110f, 0.04754237f, 0.07524229f, -0.01957676f, 0.07407140f, -0.08086354f, -0.12254467f, 
    0.03893695f, -0.16119681f, -0.02922101f, 0.11724342f, 0.13917567f, 0.17741509f, -0.29587373f, 0.01345981f, 
    0.12125985f, -0.08793114f, 0.05595324f, 0.16430537f, 0.07152903f, 0.12484854f, -0.11093610f, 0.04880033f, 
    0.00105631f, 0.01084478f, -0.01271830f, -0.12210728f, -0.14999382f, -0.00841421f, -0.01862490f, -0.09204282f, 
    -0.02707894f, 0.00199940f, 0.05547367f, -0.11580933f, 0.14849427f, -0.00105602f, 0.12551647f, 0.18788621f, 
    0.02077931f, 0.07216439f, -0.15949158f, 0.14943278f, 0.17849913f, -0.02334364f, 0.13878492f, 0.12230679f, 
    -0.46164501f, 0.06951016f, -0.05344274f, 0.13177581f, 0.17545545f, 0.01951159f, 0.05869244f, -0.07796451f, 
    0.12829351f, -0.04179183f, 0.01574311f, 0.01160894f, -0.32227173f, 0.27591705f, -0.15174000f, -0.31510508f, 
    0.05646970f, -0.10469010f, 0.17798433f, 0.15885705f, -0.03053075f, 0.07317090f, -0.06102256f, 0.01498984f, 
    0.05759342f, -0.11295401f, -0.07336655f, -0.18880013f, 0.00795728f, -0.04041606f, -0.07028047f, 0.05466729f, 
    0.00252036f, -0.10973493f, 0.02665348f, 0.09773020f, -0.05495153f, 0.13318789f, 0.10112698f, -0.20751071f, 
    -0.10721956f, 0.06854629f, 0.03562403f, -0.01394762f, 0.07735430f, 0.09790237f, 0.08030734f, 0.09850314f, 
    0.21052310f, -0.07860615f, 0.05237279f, -0.21646529f, -0.00271172f, -0.03550702f, 0.06916308f, -0.07350247f, 
    -0.12656371f, -0.08881544f, 0.03182521f, 0.07839224f, -0.00685164f, 0.07535663f, 0.00196765f, -0.07312334f, 
    -0.12467577f, -0.05746054f, 0.05688261f, -0.07304114f, -0.19758064f, 0.11994196f, -0.00271365f, 0.04236777f, 
    0.21507151f, -0.02560427f, 0.03825213f, -0.08502109f, -0.08260469f, 0.14453694f, 0.05485813f, -0.21897009f, 
    0.00292286f, 0.12351558f, 0.08722812f, -0.00657349f, 0.15183447f, 0.25494987f, 0.02728542f, 0.06098806f, 
    0.08103113f, -0.10913476f, 0.02792597f, -0.06301567f, -0.08635945f, 0.11158200f, -0.02210978f, -0.04995689f, 
    -0.04450881f, -0.04450825f, 0.05923099f, 0.04272892f, 0.02248112f, -0.07066831f, -0.07852596f, -0.03893866f, 
    -0.01265746f, -0.01172026f, -0.00049572f, -0.06571934f, -0.05268244f, 0.03703482f, 0.01532183f, 0.04853642f, 
    -0.03624504f, -0.06267004f, 0.01802845f, -0.02077693f, 0.00105492f, 0.02458840f, 0.05006710f, -0.07119461f, 
    -0.01601956f, 0.03677134f, -0.07150431f, -0.01388586f, -0.03071375f, -0.07859345f, -0.00527517f, -0.01819661f, 
    0.04045790f, -0.02334947f, -0.00749516f, 0.04918242f, 0.00294167f, -0.03320215f, -0.04628062f, -0.02255258f, 
    0.01937765f, 0.00083234f, -0.03217019f, -0.01217077f, 0.03770270f, -0.01794441f, -0.06430342f, -0.00313232f, 
    -0.00906445f, -0.02922500f, -0.02587759f, 0.03963305f, -0.04025124f, 0.00834003f, -0.03052014f, -0.07501546f, 
    -0.02529743f, 0.02449831f, -0.05097108f, 0.06546425f, -0.04775712f, -0.03879118f, -0.03189780f, 0.05363118f, 
    0.04175949f, 0.01962736f, -0.00910196f, -0.02887688f, -0.05913176f, -0.03165259f, -0.03670979f, 0.05651312f, 
    0.02203214f, -0.04652091f, 0.02996989f, 0.01409714f, -0.03581519f, -0.04845634f, 0.05152489f, 0.05702696f, 
    0.00464109f, 0.02301889f, 0.03446982f, -0.00660509f, 0.00224943f, -0.03941437f, 0.00763211f, 0.05936407f, 
    -0.01861457f, 0.02928206f, 0.02423304f, 0.02316435f, 0.04205636f, -0.05478417f, -0.05696290f, -0.02008187f, 
    0.03752012f, -0.09233288f, -0.00793873f, 0.03904634f, -0.03888017f, 0.00627045f, -0.01203373f, 0.04117895f, 
    0.01568544f, 0.03599549f, -0.01543682f, 0.00073685f, 0.01295451f, -0.04960213f, -0.02995831f, -0.02095710f, 
    -0.00861735f, -0.04225925f, 0.04234814f, -0.02321053f, 0.05912562f, 0.02547565f, 0.05681994f, -0.06834318f, 
    -0.00618690f, 0.04200422f, -0.05529511f, -0.02565683f, -0.08139141f, 0.00726844f, -0.01858495f, -0.00338183f, 
    0.04355482f, -0.00180563f, 0.02268837f, -0.03827201f, 0.02075882f, -0.01698617f, -0.01880433f, 0.03880640f, 
    -0.05973313f, -0.06241755f, 0.05570414f, 0.05193399f, -0.04755720f, 0.01825147f, -0.04392351f, 0.04784926f, 
    0.06463829f, 0.00397406f, -0.03742756f, -0.02702583f, -0.01226495f, -0.00132808f, -0.01432317f, -0.06436522f, 
    0.05403841f, -0.04086046f, -0.07457414f, -0.04100094f, -0.03355178f, -0.02082575f, -0.03783089f, -0.04788432f, 
    -0.02350582f, -0.06897015f, -0.04991009f, -0.06454621f, -0.05978609f, -0.03340710f, -0.04390587f, -0.02550498f, 
    0.05761746f, -0.04345497f, 0.07326344f, 0.03133793f, 0.00651190f, -0.05534917f, -0.00014385f, -0.00875245f, 
    -0.05776962f, 0.04332161f, -0.05540628f, 0.01848976f, 0.05466051f, 0.01161633f, 0.00590924f, -0.08593047f, 
    -0.02556800f, 0.04548672f, 0.03482968f, -0.01096171f, 0.00540864f, -0.08177729f, 0.03451293f, 0.04737595f, 
    0.04825028f, -0.06239968f, 0.00660642f, -0.00917049f, -0.01134315f, -0.02384682f, 0.04005013f, 0.02078782f, 
    0.03324307f, 0.04763147f, -0.01712873f, -0.01868392f, 0.03976594f, -0.06785077f, -0.08480970f, -0.05872951f, 
    -0.06982665f, 0.00995732f, 0.04711256f, 0.03374649f, 0.06347240f, -0.02870728f, 0.01189435f, 0.00884249f, 
    -0.00774642f, -0.01617654f, 0.01829747f, -0.03437808f, 0.03899142f, -0.03228619f, -0.03088349f, -0.00652839f, 
    -0.08165056f, -0.03514149f, -0.06277052f, 0.02958792f, -0.07132725f, -0.06258626f, -0.04507529f, 0.05135236f, 
    0.03787903f, -0.07701472f, -0.00979594f, 0.00352202f, 0.05729159f, 0.04636969f, 0.05317120f, -0.03424939f, 
    0.06022049f, -0.03656023f, -0.03895018f, 0.05613454f, 0.03320174f, -0.02286479f, 0.02347946f, 0.04349152f, 
    -0.04791738f, -0.00055490f, 0.04938679f, 0.04670649f, -0.03783556f, 0.00409502f, 0.01740799f, 0.05543013f, 
    0.00377116f, -0.06753944f, 0.03151628f, -0.01080180f, -0.05641120f, -0.06319956f, -0.02634571f, 0.01425889f, 
    0.04188106f, -0.08146696f, -0.00931785f, -0.05967922f, -0.06436496f, 0.05785310f, 0.01862638f, -0.06539861f, 
    0.04496768f, -0.02504291f, -0.02827514f, 0.02374429f, 0.00799947f, 0.04229464f, -0.07495893f, -0.03504274f, 
    -0.07932408f, 0.03432918f, 0.02234138f, -0.06246735f, -0.06975909f, -0.03361385f, 0.01503501f, -0.00527751f, 
    0.00825317f, -0.04909878f, -0.05330203f, -0.01023185f, 0.02429336f, -0.07976332f, -0.06528307f, 0.04842192f, 
    0.01821229f, -0.00256371f, -0.02882878f, -0.05030835f, 0.00081573f, -0.01895367f, -0.01820429f, -0.06391250f, 
    -0.01361349f, 0.04871303f, 0.00265381f, 0.00827283f, -0.06285862f, 0.01109668f, -0.06358813f, -0.01373997f, 
    -0.07515628f, 0.00392882f, 0.03522519f, -0.05624933f, 0.05430343f, 0.06878810f, 0.03876453f, -0.01371382f, 
    -0.08066858f, -0.00070149f, 0.05867266f, -0.07634680f, 0.03970667f, -0.03709282f, -0.07359990f, -0.05594287f, 
    -0.00307189f, -0.05755085f, 0.01074731f, -0.02012692f, -0.00954305f, 0.03890908f, 0.04714367f, -0.01438905f, 
    -0.06048168f, -0.02843661f, -0.07699328f, 0.04264671f, -0.08103459f, 0.05510006f, 0.04696786f, -0.00895570f, 
    0.00805199f, 0.01050456f, 0.01740582f, -0.00615868f, -0.07079776f, -0.07331722f, 0.04390945f, 0.01353191f, 
    -0.04802769f, -0.03444214f, 0.04710096f, -0.05541749f, 0.05699085f, -0.07418568f, 0.00053416f, 0.04851313f, 
    0.02698002f, 0.05006197f, -0.07187662f, 0.02462890f, -0.04124324f, 0.02084116f, -0.03636353f, 0.01971081f, 
    -0.04042602f, 0.05244156f, -0.05355667f, -0.02335919f, -0.05411428f, -0.01290093f, 0.03417905f, 0.06198756f, 
    0.00071771f, -0.05901428f, -0.01963281f, -0.06052761f, 0.03565453f, -0.07188993f, -0.06555278f, -0.02589791f, 
    0.02093040f, -0.00908515f, -0.02007634f, -0.04302317f, -0.00338935f, 0.02598667f, -0.00646650f, -0.06325720f, 
    0.01439494f, 0.01140637f, -0.05464881f, -0.06251646f, 0.00993698f, -0.04711154f, -0.00839940f, -0.01072357f, 
    -0.06522215f, -0.06176229f, 0.00324710f, -0.01072445f, 0.07106513f, -0.03783232f, -0.00382749f, 0.04739298f, 
    -0.01716483f, -0.00040036f, 0.04845753f, -0.07496841f, -0.04085217f, -0.02690519f, -0.00152022f, 0.03381667f, 
    -0.04086963f, -0.02392519f, -0.07178266f, -0.01790329f, 0.00310625f, 0.03663410f, -0.07664035f, -0.00586486f, 
    0.02787621f, 0.06054895f, 0.01967163f, -0.05873058f, 0.03035764f, 0.01747359f, -0.02882196f, 0.01015886f, 
    -0.00346146f, -0.00822753f, 0.06062378f, -0.01059661f, 0.05819289f, -0.03952690f, -0.07326808f, 0.02748675f, 
    -0.03288332f, 0.01151825f, -0.03951501f, 0.02538474f, 0.00284969f, 0.03775579f, 0.04018483f, 0.01358934f, 
    0.00266857f, -0.05847296f, -0.05158384f, -0.04589564f, -0.00246516f, -0.01633688f, 0.02549651f, -0.02129507f, 
    -0.04966809f, -0.00346626f, -0.04810938f, -0.04795107f, 0.04912225f, 0.06331332f, 0.01819885f, 0.03861267f, 
    0.00737632f, 0.01895765f, 0.00572765f, -0.04707763f, 0.01604072f, -0.00747373f, -0.03062456f, -0.05797590f, 
    -0.02525541f, -0.03227172f, -0.05244857f, -0.02742185f, 0.02206148f, -0.05228649f, 0.03971660f, 0.05217357f, 
    -0.02050146f, -0.05709562f, -0.05138707f, -0.06135512f, -0.05711648f, -0.05882426f, 0.00893712f, -0.06035011f, 
    0.00233525f, 0.00414524f, -0.05623900f, -0.06258508f, -0.01857974f, -0.06912480f, -0.05329352f, 0.01685118f, 
    -0.06226259f, 0.04534521f, -0.01572603f, 0.05291783f, 0.03189844f, -0.03552621f, 0.05337377f, 0.05243756f, 
    -0.06360791f, -0.02909789f, 0.00937382f, -0.03000281f, 0.06760321f, 0.00403982f, 0.04293643f, -0.03787233f, 
    0.00388966f, -0.07284193f, 0.06261485f, -0.04109997f, -0.02036312f, 0.04918826f, -0.02761484f, -0.02809799f, 
    0.04630026f, -0.02820766f, 0.00074408f, -0.02625762f, -0.00032034f, -0.02314019f, 0.01978953f, 0.05917238f, 
    -0.06261913f, -0.06679363f, 0.01755166f, -0.06155967f, -0.01223673f, -0.06176236f, -0.04343306f, 0.02076246f, 
    0.03646063f, -0.06438807f, 0.05527310f, -0.02356223f, 0.02122417f, 0.05915434f, 0.01683760f, -0.06098572f, 
    -0.07565717f, 0.01454874f, -0.04874497f, -0.03658584f, 0.02056423f, 0.03106778f, 0.04399355f, -0.01794450f, 
    -0.04344250f, -0.06404876f, -0.05739877f, -0.02595420f, -0.00360222f, 0.01684365f, -0.07112771f, -0.02383894f, 
    0.05276375f, 0.03805584f, -0.05892039f, 0.06599271f, -0.04808856f, -0.04388835f, 0.06394961f, -0.07629789f, 
    0.00059227f, -0.04285673f, 0.03782547f, -0.03132726f, 0.02013390f, 0.06976178f, -0.02712093f, -0.02411480f, 
    -0.03844079f, -0.01857741f, 0.02091783f, 0.07003109f, -0.24704298f, -0.13876922f, 0.01733270f, -0.07843959f, 
    -0.12491141f, -0.10632589f, -0.13425070f, -0.18880183f, 0.11798018f, 0.21024132f, -0.11035278f, 0.06226137f, 
    0.00479817f, 0.09177388f, 0.07270461f, 0.00516059f, 0.01640420f, 0.23433129f, 0.10576361f, 0.17982176f, 
    -0.08238190f, 0.17330711f, 0.08307058f, -0.18007141f, 0.03606379f, 0.08572403f, 0.08762988f, 0.20188621f, 
    -0.05576170f, 0.09814245f, 0.02483731f, -0.34768400f, -0.00679750f, 0.08384509f, 0.39455259f, 0.31793833f, 
    -0.06455558f, -0.11007711f, 0.03055441f, -0.00517844f, 0.00483053f, 0.01203658f, -0.02383304f, 0.01660666f, 
    -0.02095432f, 0.10712503f, -0.16634111f, 0.09475012f, -0.10840952f, -0.07172748f, 0.05789495f, 0.00316617f, 
    -0.03935472f, -0.01793636f, -0.03972813f, 0.06150045f, -0.17390923f, -0.25470120f, 0.05222590f, 0.31407022f, 
    -0.01859488f, 0.03828109f, -0.08997036f, 0.05189879f, -0.00246052f, 0.01243057f, 0.02714722f, -0.03633018f, 
    0.33638155f, 0.32245401f, 0.03720936f, 0.00110054f, 0.01493446f, -0.07582983f, -0.15651047f, -0.00600063f, 
    -0.08311440f, 0.13679478f, -0.03798986f, -0.02558180f, -0.14544390f, -0.06183824f, 0.15291899f, 0.15068974f, 
    -0.09895368f, 0.01198042f, 0.07297377f, 0.00902849f, -0.11186612f, 0.03048111f, 0.07523517f, -0.10586277f, 
    -0.28975034f, -0.07427955f, 0.01869512f, 0.35798460f, -0.27738389f, -0.14104339f, -0.10723880f, 0.05375474f, 
    -0.08615448f, -0.03632113f, 0.07200107f, -0.02485480f, 0.38726157f, -0.11685817f, 0.38952756f, -0.16456173f, 
    0.06359830f, 0.05931847f, -0.22264275f, -0.03977732f, -0.03278985f, -0.10266804f, -0.02006643f, -0.08348834f, 
    -0.05159025f, 0.11181998f, 0.17284696f, 0.10068909f, 0.00398933f, 0.09991861f, -0.04468391f, -0.01405155f, 
    0.18445233f, -0.05324287f, 0.02766090f, 0.14154784f, 0.11080743f, 0.37754282f, -0.03917088f, -0.02270898f, 
    0.10747039f, -0.07895923f, 0.05857617f, 0.06560662f, -0.17139514f, -0.12628102f, -0.04555209f, -0.14012997f, 
    0.06289271f, 0.06401410f, -0.24939211f, 0.15875101f, -0.19399925f, -0.00681576f, 0.01499205f, 0.25666392f, 
    -0.03285511f, 0.00230226f, -0.01228376f, -0.12196552f, 0.23272458f, 0.05776356f, 0.09233803f, -0.07670531f, 
    0.04428726f, 0.01472867f, -0.02027952f, 0.05204828f, -0.01460618f, -0.05437066f, 0.01496348f, -0.26218048f, 
    0.26159379f, -0.02290767f, -0.27002427f, -0.07460281f, 0.15452108f, -0.03981960f, 0.00304472f, 0.09178248f, 
    -0.02601223f, 0.00476940f, -0.03179289f, -0.15887713f, -0.33652788f, 0.17239514f, -0.06146799f, 0.20931707f, 
    -0.01185278f, 0.10718554f, 0.02868309f, 0.13599452f, 0.04479316f, 0.27661201f, 0.25084776f, 0.02054855f, 
    0.04567250f, 0.00008621f, 0.05099243f, -0.02575323f, -0.04494525f, -0.04140990f, 0.03402682f, 0.01455588f, 
    0.03574911f, -0.00345506f, 0.05757874f, 0.01304829f, 0.03178666f, 0.04659513f, -0.07338456f, -0.03239024f, 
    0.04268359f, -0.00224208f, -0.05044397f, 0.00851593f, 0.05666948f, 0.05709618f, -0.04157569f, 0.01227682f, 
    0.01538013f, -0.04432176f, -0.04797046f, 0.05183436f, -0.02460718f, -0.00781463f, -0.05588746f, 0.04876861f, 
    -0.03942641f, -0.01279292f, 0.02526498f, 0.03706365f, -0.01754012f, -0.03435976f, 0.03437874f, -0.05053440f, 
    -0.05037420f, 0.04030123f, -0.05036912f, 0.05858140f, 0.02833529f, -0.04580116f, -0.07336687f, -0.07323051f, 
    -0.07543975f, -0.06923849f, -0.02893546f, -0.03123242f, 0.04043055f, -0.04402429f, -0.03397650f, 0.02548721f, 
    -0.00073428f, -0.05854349f, 0.04111363f, 0.02780810f, -0.05509613f, -0.07440243f, 0.05480215f, -0.00188437f, 
    -0.01213674f, 0.05948177f, -0.06376225f, -0.05869086f, 0.06431144f, -0.00757323f, -0.03344515f, 0.05826151f, 
    0.06522677f, 0.00421135f, 0.04780615f, -0.06812593f, -0.03386924f, -0.04116853f, 0.01052801f, 0.04060053f, 
    -0.05313420f, -0.05667610f, -0.02680927f, -0.06728027f, -0.07270111f, 0.00323082f, -0.05963439f, 0.03691843f, 
    -0.02827625f, -0.05948379f, 0.06473802f, -0.02992935f, -0.03072519f, 0.00999941f, -0.00621192f, -0.03292461f, 
    0.00953018f, -0.03232696f, -0.04370341f, -0.07388099f, 0.03341790f, -0.01376970f, -0.05570483f, -0.00418704f, 
    -0.05855044f, 0.06345177f, 0.02619332f, 0.00221958f, 0.06570686f, 0.04606082f, 0.03346028f, 0.06178747f, 
    -0.03694351f, -0.01197233f, 0.00034613f, 0.00378865f, -0.05977360f, -0.06863335f, -0.04724711f, 0.02414376f, 
    0.00948054f, -0.03125840f, -0.03739657f, -0.07548950f, -0.07477310f, -0.04811483f, -0.04049864f, 0.04879213f, 
    -0.02799395f, -0.02605732f, -0.07730246f, 0.01554872f, -0.05110437f, 0.02425690f, 0.02030484f, -0.02964530f, 
    -0.04299219f, 0.04803334f, 0.02343634f, -0.04357994f, 0.01123271f, -0.01196771f, -0.01579895f, 0.03513427f, 
    0.02378824f, 0.00312337f, -0.02115912f, 0.05033420f, -0.00437592f, 0.02708704f, -0.05993546f, -0.00854013f, 
    -0.01240402f, 0.00696036f, -0.02085998f, -0.02314043f, 0.00201557f, 0.01996654f, 0.05385965f, 0.04532937f, 
    -0.04902272f, -0.06598510f, -0.03555677f, -0.03346226f, -0.01811785f, 0.02230973f, 0.04782487f, -0.03667399f, 
    -0.04118188f, -0.01710039f, -0.05383945f, -0.02721058f, 0.01443007f, -0.06785094f, 0.01651167f, -0.05156340f, 
    0.04345481f, 0.01820212f, -0.07394948f, 0.01267397f, -0.00592603f, 0.02071651f, -0.01475511f, 0.02512754f, 
    -0.03389277f, 0.01510575f, 0.03083267f, 0.01481105f, -0.01529475f, -0.06677301f, -0.05728965f, 0.01028251f, 
    0.02680609f, -0.25017041f, -0.18357903f, -0.01830327f, 0.22547507f, 0.07482807f, 0.24708202f, 0.12260224f, 
    -0.01003790f, -0.02120379f, 0.12253064f, 0.14467038f, -0.10519510f, -0.06847610f, -0.06319049f, -0.01037308f, 
    0.08715273f, -0.01012425f, -0.04092141f, 0.03528693f, 0.00924096f, -0.37990031f, -0.19548999f, -0.29589987f, 
    0.21679954f, 0.00722936f, -0.05415006f, 0.06521352f, -0.15429489f, 0.18893085f, 0.04938260f, 0.18547900f, 
    0.16121200f, 0.12371027f, 0.17037773f, 0.19758852f, -0.27808899f, -0.18654472f, 0.10250084f, -0.06320006f, 
    0.16198777f, 0.11814705f, 0.06028046f, 0.03642180f, -0.06145108f, 0.01927589f, 0.05555077f, 0.04344895f, 
    -0.17617853f, -0.07749342f, -0.15531622f, -0.21721013f, -0.03165665f, -0.07102705f, -0.08818445f, 0.11331514f, 
    -0.11038089f, 0.03594586f, 0.13100913f, -0.05741904f, -0.06898845f, 0.01924858f, 0.13251881f, -0.02966687f, 
    0.02142012f, -0.03628397f, 0.12195861f, 0.08512850f, 0.04848580f, 0.10750529f, -0.03068789f, -0.03877779f, 
    0.04130523f, 0.15644288f, 0.11335856f, -0.21742034f, -0.14485550f, -0.03527825f, 0.06455052f, 0.00224430f, 
    0.09146640f, -0.04626044f, 0.06748278f, 0.04216332f, -0.33959913f, 0.46939075f, -0.09469738f, -0.07444776f, 
    0.09377984f, 0.14070450f, -0.03781322f, 0.08614400f, 0.06005123f, -0.04496326f, 0.02750253f, 0.07614388f, 
    0.39739966f, -0.17557244f, -0.00194327f, 0.21528643f, 0.19941089f, 0.17481132f, 0.07875687f, 0.18465880f, 
    0.17320481f, 0.00238458f, 0.07370465f, 0.06632094f, -0.03047240f, -0.09786164f, 0.19447851f, 0.01783436f, 
    -0.00078336f, -0.02554484f, -0.06030865f, -0.16682763f, 0.02662567f, 0.09071855f, 0.05085548f, 0.01983322f, 
    -0.05628694f, -0.16201717f, -0.05007658f, 0.03574422f, -0.00950364f, -0.10051807f, 0.00581536f, -0.01479683f, 
    -0.18540336f, -0.06082600f, 0.02094823f, -0.06520983f, -0.18086940f, -0.27329341f, -0.09472321f, -0.03213376f, 
    -0.13163163f, -0.12677221f, -0.05778535f, -0.13561378f, 0.06669666f, -0.01387867f, 0.17897539f, -0.10833336f, 
    -0.13822104f, -0.20442076f, 0.21187189f, 0.01448397f, 0.00637874f, -0.01817196f, 0.04183815f, -0.14836960f, 
    0.01343407f, 0.16144541f, 0.20196681f, -0.00663315f, -0.30357921f, -0.06080178f, -0.07896646f, -0.06438346f, 
    -0.15849593f, -0.07892744f, -0.15531431f, -0.13323678f, -0.09174364f, -0.02667665f, -0.15387537f, -0.03621278f, 
    0.22687496f, 0.06783089f, 0.08208735f, 0.06936390f, -0.08264732f, 0.03513253f, 0.06006812f, 0.01554876f, 
    -0.01400817f, 0.17404902f, 0.11343761f, 0.21887016f, -0.00982709f, -0.16163428f, 0.08767078f, -0.03112663f, 
    -0.01583302f, -0.06113839f, 0.08576703f, 0.15992458f, -0.02201653f, -0.03683085f, -0.13196950f, -0.06405310f, 
    -0.07743569f, 0.05191460f, -0.00664655f, 0.03724679f, -0.05706448f, 0.03004360f, 0.03933717f, -0.06681018f, 
    -0.00545596f, -0.05026878f, 0.04243342f, -0.03671739f, 0.04750637f, 0.02377881f, 0.00338911f, -0.05327322f, 
    -0.01200843f, 0.02232181f, 0.05421931f, -0.06577029f, -0.07550511f, 0.04711925f, -0.04802158f, 0.03827173f, 
    -0.05487167f, -0.03177503f, -0.03782500f, -0.05846040f, 0.01241341f, -0.00763446f, 0.02469776f, -0.01747919f, 
    0.04862304f, -0.05522859f, -0.06504708f, 0.02419489f, 0.05873808f, 0.03139194f, -0.05212449f, -0.03522535f, 
    -0.00263435f, -0.04612753f, -0.03424336f, -0.04018681f, 0.05078073f, -0.04394050f, -0.05405412f, 0.02545003f, 
    -0.04297088f, -0.05413176f, -0.01944802f, -0.05504389f, 0.00173015f, 0.05382847f, 0.06269073f, -0.03856485f, 
    -0.04059514f, 0.03934771f, 0.03366726f, -0.01335574f, -0.02831309f, -0.01932679f, 0.01846223f, 0.04132716f, 
    -0.03247874f, 0.06578197f, -0.05287970f, 0.02999807f, 0.04725668f, -0.00376938f, -0.01340731f, 0.03711575f, 
    -0.06212282f, -0.02904114f, 0.03305901f, 0.07148301f, -0.05837273f, 0.00600981f, -0.05186347f, -0.00877937f, 
    0.02769245f, -0.07216311f, -0.03524573f, 0.06039635f, -0.00485729f, -0.03295628f, -0.07091691f, 0.03007950f, 
    -0.02005747f, -0.05400532f, -0.05413392f, -0.00390805f, 0.04696101f, -0.00591367f, -0.00868487f, -0.00232977f, 
    0.03734411f, 0.06359988f, -0.05311270f, -0.05079597f, -0.06816530f, -0.02960422f, -0.05430168f, -0.05502860f, 
    -0.07285318f, -0.05277933f, -0.06501879f, -0.01960330f, 0.02612871f, 0.04231950f, 0.01669293f, -0.05870409f, 
    0.01384487f, -0.06353990f, 0.06315512f, 0.00367664f, 0.01780930f, -0.03059837f, -0.06953778f, -0.05472932f, 
    0.02977966f, -0.01589672f, 0.03010347f, -0.00505043f, -0.00098582f, 0.03237622f, 0.03670855f, -0.06176709f, 
    0.05274428f, -0.05662577f, -0.05353367f, 0.02188325f, -0.06964483f, -0.00192411f, 0.00139388f, -0.01675249f, 
    0.05082947f, 0.01445703f, -0.06623232f, 0.04458943f, -0.00464526f, 0.02073483f, -0.03039419f, -0.05103117f, 
    -0.05531757f, 0.03975489f, -0.01052274f, -0.02019764f, 0.04203902f, 0.00556179f, 0.04156810f, 0.01030277f, 
    0.05772628f, -0.00842824f, 0.04103224f, -0.02901643f, 0.01258453f, -0.01660938f, -0.06656761f, 0.01289703f, 
    -0.00107356f, 0.01132597f, -0.01326556f, -0.05895719f, -0.07591132f, 0.01877625f, -0.03240754f, -0.02466391f, 
    -0.06591757f, 0.01506080f, 0.01067711f, -0.06962579f, -0.02696546f, -0.04902015f, -0.02729867f, 0.04933618f, 
    -0.01828054f, -0.02416783f, 0.04185805f, 0.03507817f, 0.01050364f, -0.06468569f, 0.02939291f, -0.01907598f, 
    -0.03583496f, 0.05471339f, -0.00024786f, -0.03932458f, -0.07425524f, -0.03197533f, -0.05161898f, -0.05056055f, 
    0.05838612f, -0.02538444f, 0.01096059f, 0.03679729f, 0.03603967f, -0.03321510f, -0.06375262f, -0.06334107f, 
    0.05623301f, -0.02333634f, -0.07236688f, 0.01230611f, -0.00488723f, -0.08002723f, 0.02157593f, -0.03051462f, 
    0.01831903f, -0.04472755f, -0.02556225f, -0.01040312f, 0.02451975f, -0.04932738f, 0.00126130f, 0.00912207f, 
    0.04059127f, -0.02641683f, -0.02656872f, 0.02875359f, -0.06666251f, 0.05917540f, 0.05790545f, -0.00887982f, 
    -0.05316609f, -0.05125329f, 0.01524516f, -0.07862330f, 0.03643266f, -0.03639295f, 0.01637977f, -0.04342474f, 
    -0.04984028f, 0.01241657f, 0.01496260f, -0.05402197f, -0.07097835f, -0.00150881f, 0.02609594f, -0.04702378f, 
    -0.04457700f, -0.05520727f, 0.00519446f, -0.04718827f, -0.04168621f, -0.00522914f, -0.04815358f, -0.06092031f, 
    0.03032523f, -0.02428660f, -0.03438386f, 0.01642320f, -0.05941911f, 0.01593441f, 0.01464585f, -0.05522452f, 
    -0.00561463f, 0.00679185f, 0.04988073f, 0.00293614f, 0.03082627f, 0.04558621f, -0.06753413f, -0.06036828f, 
    0.01447307f, -0.03213960f, 0.04628118f, -0.04962521f, 0.03670182f, -0.02274855f, 0.01181441f, 0.05867733f, 
    -0.04857615f, -0.04457792f, -0.02509017f, -0.02594884f, -0.01313873f, 0.04846406f, -0.05661725f, 0.03590645f, 
    0.02008963f, 0.01850585f, -0.03475009f, -0.07798772f, -0.05724670f, -0.00705872f, 0.01380676f, 0.06246975f, 
    -0.03883877f, 0.01722747f, -0.06563939f, -0.05243743f, 0.02766093f, 0.00635967f, 0.02390083f, 0.03421119f, 
    -0.07517333f, 0.05643431f, -0.06337386f, -0.01941974f, 0.01771742f, 0.07559528f, -0.06356611f, -0.01575792f, 
    0.03104994f, -0.00495635f, -0.03577585f, -0.06732903f, -0.05769847f, 0.06087130f, -0.03462790f, -0.00898932f, 
    -0.03871428f, -0.01389283f, -0.05064686f, 0.06123225f, -0.01215474f, -0.07108120f, -0.00006379f, 0.02094693f, 
    -0.02544717f, -0.03516496f, 0.01482019f, 0.00477050f, 0.04468368f, 0.03628217f, -0.01931244f, -0.04733292f, 
    0.01603070f, -0.06191088f, 0.02866900f, -0.00291659f, 0.03437223f, -0.03415194f, -0.03330502f, 0.01115458f, 
    -0.04215096f, 0.02419572f, -0.07655577f, -0.02354947f, 0.03303900f, -0.01715964f, -0.03022763f, -0.01069096f, 
    0.06119760f, 0.04774778f, -0.06233551f, 0.05048876f, 0.06113554f, 0.02780063f, -0.02787059f, -0.03478844f, 
    -0.01807107f, -0.05734543f, 0.00919611f, 0.05181034f, -0.04770913f, -0.06953220f, 0.00092174f, -0.07396511f, 
    0.02490319f, 0.03003304f, -0.04889207f, -0.03305819f, -0.07951763f, -0.01036868f, -0.00606271f, -0.03131149f, 
    -0.06156892f, 0.06760073f, 0.03973064f, -0.01144268f, -0.04205545f, -0.03352093f, 0.02767286f, 0.03082511f, 
    -0.03666366f, -0.03766148f, -0.01178519f, 0.02363848f, -0.03377172f, -0.01510180f, -0.07695107f, 0.04719657f, 
    -0.17732616f, -0.00287457f, 0.00507209f, 0.18146315f, 0.04462867f, 0.17841235f, 0.04622614f, -0.08420218f, 
    0.11800124f, -0.08967009f, -0.07050494f, -0.20518926f, -0.16306415f, -0.06313362f, -0.14650497f, 0.26403305f, 
    0.02230425f, 0.00899346f, -0.01304312f, 0.11952293f, 0.33474228f, 0.21150440f, 0.18798344f, 0.20674405f, 
    -0.14710203f, 0.08010494f, 0.18770091f, 0.47857517f, 0.17480984f, 0.15509675f, 0.07911786f, 0.30333692f, 
    -0.26740214f, -0.00125056f, -0.14003558f, -0.13781637f, -0.19776414f, 0.21916646f, -0.13767587f, 0.00790841f, 
    0.03178727f, -0.00628687f, -0.01419799f, -0.30283380f, 0.05482484f, -0.02475604f, -0.08225087f, -0.11905942f, 
    -0.27213171f, 0.07296724f, 0.53525305f, 0.10698373f, -0.04061068f, -0.02856700f, -0.13217054f, 0.02437082f, 
    -0.00580787f, 0.19280414f, 0.12064684f, 0.07617883f, -0.25279561f, -0.18783736f, -0.06491390f, -0.05713229f, 
    0.04077630f, 0.18374242f, 0.09012930f, -0.09999353f, -0.07360194f, -0.10615293f, 0.12989403f, 0.03580896f, 
    -0.10441507f, -0.16135177f, -0.15916529f, 0.05379669f, 0.03272868f, 0.12560336f, -0.01847334f, 0.02841671f, 
    -0.06917492f, -0.13540018f, -0.08062177f, -0.06489748f, -0.36889842f, 0.19414400f, 0.16184483f, 0.12581293f, 
    0.34458372f, 0.11149333f, -0.13781719f, -0.03961283f, -0.20629083f, -0.01632666f, 0.02729798f, 0.08322553f, 
    -0.01815142f, 0.01809433f, 0.11629669f, 0.04461348f, -0.03711805f, 0.03213793f, -0.03045613f, 0.23277873f, 
    -0.11520540f, -0.10791443f, -0.06182541f, -0.02827124f, 0.20910652f, -0.14092430f, -0.01323154f, 0.12574208f, 
    0.18074074f, 0.13968843f, 0.20123433f, 0.09577838f, 0.05354938f, 0.01158445f, -0.09470985f, -0.18219590f, 
    -0.02502017f, -0.16299298f, 0.11869592f, 0.26889035f, 0.05062398f, 0.19673760f, 0.16219209f, 0.09883737f, 
    0.05440395f, 0.15938647f, 0.22937588f, -0.02886614f, -0.26965454f, 0.12469302f, -0.22873366f, 0.20756088f, 
    0.13916780f, -0.00760314f, -0.13083641f, -0.19836292f, 0.12652695f, -0.02513907f, 0.00656835f, -0.06225874f, 
    0.02808659f, 0.56648684f, 0.47786388f, 0.33517802f, 0.04300304f, -0.17726563f, -0.10867271f, 0.07939437f, 
    -0.00189311f, -0.07228960f, -0.05265792f, -0.03914990f, -0.02129381f, -0.17943186f, -0.23305884f, -0.03529679f, 
    0.05881164f, 0.05528242f, -0.01120437f, 0.04139387f, 0.13898683f, -0.02336845f, 0.12446541f, -0.08904004f, 
    -0.33752254f, 0.23197109f, 0.28526056f, 0.32601100f, -0.01391032f, 0.01486310f, 0.03323844f, 0.02393281f, 
    0.08696038f, -0.00050398f, -0.04090906f, 0.14293964f, -0.36303782f, 0.44879383f, 0.18360803f, 0.19072491f, 
    0.02281080f, -0.03895246f, -0.05354430f, 0.10597947f, 0.13752179f, 0.24833602f, 0.10439567f, 0.16793883f, 
    0.19498661f, -0.26643893f, 0.15525348f, -0.32536843f, 0.03342289f, -0.00812160f, -0.01939994f, 0.11841538f, 
    -0.13778864f, -0.19934678f, -0.05360131f, -0.18482508f, 0.24415645f, -0.13633585f, 0.03542819f, 0.18622153f, 
    -0.16783147f, 0.14357047f, 0.08982379f, -0.19397271f, 0.21407516f, 0.30675223f, 0.18485188f, 0.38225833f, 
    0.10891306f, -0.19468608f, 0.07646093f, -0.41082406f, 0.13981375f, 0.05652298f, -0.45402327f, -0.28596994f, 
    -0.21322925f, -0.11350960f, -0.16342524f, -0.28784084f, -0.01871042f, 0.04430795f, 0.31342259f, 0.29227751f, 
    0.06663923f, 0.17607097f, 0.03522502f, 0.17637655f, 0.05118597f, -0.09581268f, -0.08440548f, 0.04445345f, 
    0.47711372f, -0.24449690f, 0.33622301f, 0.06811194f, 0.06392384f, -0.05493825f, -0.14767727f, 0.00626481f, 
    0.12521245f, -0.02615367f, 0.07796817f, 0.14308040f, -0.17277226f, -0.15512012f, 0.05381068f, 0.20263012f, 
    0.02875944f, 0.07869840f, 0.04439509f, 0.19254696f, 0.01894502f, 0.00807789f, 0.04297822f, -0.07711118f, 
    0.03823995f, -0.11082257f, 0.12893365f, -0.19283494f, 0.13927366f, -0.27114126f, 0.00314032f, -0.00601001f, 
    -0.01652569f, 0.10671574f, 0.02310397f, -0.03669143f, 0.02272438f, -0.15485550f, 0.19022544f, -0.14218998f, 
    -0.02072432f, 0.03014063f, 0.05988272f, 0.15997957f, 0.01422869f, 0.09364494f, 0.10033068f, -0.04569890f, 
    -0.12933712f, -0.10009158f, 0.04070730f, 0.23283319f, 0.07096259f, 0.04068359f, 0.02836519f, 0.08500922f, 
    -0.13686717f, -0.00049824f, 0.01950363f, -0.08327913f, -0.46075457f, 0.05367135f, -0.25920534f, 0.19030195f, 
    0.07980897f, 0.08657530f, 0.01204309f, 0.08694620f, -0.05543760f, -0.15381071f, -0.07253441f, -0.15682662f, 
    -0.14319375f, 0.03207460f, 0.15285267f, 0.17335299f, 0.07181201f, 0.11928178f, -0.05210923f, 0.05592738f, 
    0.18151404f, 0.05970254f, 0.04971372f, 0.05054828f, 0.39819750f, -0.03418550f, 0.18186668f, -0.43421316f, 
    0.06875771f, 0.04862139f, -0.05409548f, 0.09202548f, -0.30132404f, 0.09990272f, -0.08787537f, 0.09058727f, 
    0.40137744f, 0.02184618f, 0.04485231f, 0.09536516f, -0.08733347f, -0.03743517f, -0.03305848f, 0.01280233f, 
    -0.04335090f, -0.17637613f, -0.19755739f, 0.07131668f, 0.21749155f, -0.06344987f, 0.01244808f, 0.02759473f, 
    -0.02283397f, -0.32818493f, 0.19615899f, 0.07051564f, 0.08415954f, 0.17695737f, 0.25653350f, 0.08933768f, 
    0.28836414f, 0.17568915f, -0.10335210f, -0.01959512f, 0.12971562f, -0.21824916f, -0.10156579f, -0.23783101f, 
    0.02435587f, -0.12953958f, -0.05609139f, -0.01581640f, -0.04885871f, -0.13633846f, 0.34920946f, 0.45721081f, 
    -0.07900318f, -0.00318055f, 0.11640852f, -0.13571613f, 0.09066450f, 0.14408414f, 0.06580739f, 0.18362044f, 
    0.04124685f, -0.04816427f, -0.00559415f, -0.04091149f, 0.07885168f, 0.00159141f, 0.16759525f, -0.02948110f, 
    -0.06793708f, -0.01640549f, -0.04374922f, -0.06106577f, 0.10571137f, 0.02940478f, 0.12671398f, -0.11375377f, 
    0.09442956f, -0.01947002f, -0.01614385f, -0.06899658f, -0.07180025f, -0.26329434f, -0.06661751f, -0.26872826f, 
    0.42126513f, 0.13808732f, -0.20083910f, -0.14226452f, -0.07247023f, -0.11438265f, -0.03876514f, 0.14098781f, 
    0.24451275f, 0.17593803f, 0.03752105f, 0.23429061f, -0.05634628f, 0.24590811f, -0.21616068f, -0.25787866f, 
    0.11495831f, 0.08117178f, 0.14794593f, -0.00530155f, -0.02191114f, 0.02508462f, -0.03732423f, 0.03051156f, 
    0.16550820f, -0.07509704f, -0.27319795f, -0.15743054f, -0.03503022f, -0.02957157f, 0.10356926f, 0.04219719f, 
    0.07381901f, 0.07147633f, 0.19037983f, -0.05529947f, 0.33607310f, 0.22884203f, 0.36499014f, 0.11847484f, 
    0.10234749f, 0.03700843f, 0.07982454f, 0.06446152f, 0.04388322f, 0.12555489f, 0.12753746f, -0.00377070f, 
    0.31870192f, 0.08327555f, 0.15583077f, 0.04691906f, -0.00796847f, 0.01625078f, 0.00211329f, -0.06269726f, 
    0.03298263f, 0.03248025f, -0.01322827f, 0.04592365f, -0.07389457f, 0.43788353f, -0.40933573f, 0.04669757f, 
    0.04198920f, 0.13987996f, 0.12922257f, 0.10541283f, 0.00318451f, -0.11307675f, 0.10059916f, 0.20289865f, 
    0.30146238f, -0.03303821f, 0.57191581f, -0.17090173f, 0.30705625f, 0.08631139f, 0.14917716f, -0.06499866f, 
    0.05050408f, 0.02372688f, 0.14392869f, 0.07776625f, 0.20364656f, 0.03262853f, 0.01694446f, 0.38343185f, 
    0.28008270f, -0.14329162f, -0.04819816f, -0.11408667f, 0.01042689f, 0.06800651f, 0.02152666f, -0.02884921f, 
    0.21553522f, 0.15228336f, 0.08529744f, 0.11546864f, 0.13220164f, 0.00462699f, 0.14190257f, 0.09413181f, 
    -0.13958295f, -0.01804902f, 0.06167312f, 0.01076335f, 0.09885579f, 0.15316871f, 0.31410950f, -0.10829461f, 
    -0.14354227f, 0.10938156f, -0.01325373f, -0.13353017f, 0.07985252f, 0.09611268f, 0.09635404f, -0.05240441f, 
    0.16029695f, -0.55822289f, -0.11577885f, -0.31033877f, 0.05219759f, -0.06454872f, 0.09057464f, 0.13310136f, 
    0.07559925f, 0.22806683f, 0.13643216f, -0.08367159f, 0.08134650f, 0.24799135f, 0.10135306f, 0.07343514f, 
    -0.06042085f, 0.02055788f, -0.02607196f, -0.16820462f, 0.04676471f, -0.02369323f, 0.00353792f, 0.10035921f, 
    0.07425477f, 0.04945769f, 0.29476184f, -0.28013542f, -0.07565124f, 0.02303534f, 0.00008124f, -0.12160222f, 
    -0.04327145f, 0.11628208f, 0.02893630f, 0.04850827f, 0.43874803f, -0.63647908f, -0.33622110f, -0.35658234f, 
    0.04828855f, -0.07646377f, 0.14550498f, 0.09117091f, 0.18328910f, -0.15835942f, -0.17181621f, -0.05341274f, 
    0.08970209f, -0.08547410f, -0.02425897f, -0.05871367f, 0.23482323f, 0.04774867f, 0.22702457f, 0.29732749f, 
    -0.14376505f, 0.03912629f, 0.04491012f, 0.06643277f, 0.03157814f, -0.11190159f, 0.06850372f, 0.02146609f, 
    0.01402280f, -0.07175501f, -0.03083101f, -0.07926167f, 0.02416930f, -0.24718989f, 0.01262444f, -0.20056617f, 
    0.20657881f, -0.09039424f, -0.20946522f, -0.20802051f, -0.00993094f, 0.14589541f, 0.03316247f, 0.03020783f, 
    0.17152336f, 0.14447565f, 0.05336884f, 0.00531437f, -0.22721507f, -0.24027716f, 0.16891964f, -0.03944913f, 
    -0.00076996f, 0.11863188f, 0.17265017f, 0.13346110f, -0.05019950f, -0.10278104f, -0.05008982f, -0.07344870f, 
    -0.01223218f, -0.15170553f, -0.08719741f, 0.01893159f, -0.10024738f, 0.00753633f, 0.02122228f, -0.02021001f, 
    -0.07685592f, 0.04963494f, 0.16944243f, -0.06240407f, -0.11077270f, -0.00121956f, 0.06131420f, -0.00145217f, 
    -0.01170863f, -0.15060489f, -0.00742059f, 0.10760187f, 0.10199000f, 0.18592505f, 0.02805204f, 0.00200160f, 
    0.22431353f, 0.06526466f, 0.15714771f, -0.05125922f, 0.01585200f, -0.04942066f, 0.02682331f, -0.08650489f, 
    -0.03472354f, -0.04528948f, -0.04168268f, 0.04550183f, -0.11817233f, 0.23976454f, -0.12185416f, 0.15694375f, 
    0.13218038f, 0.01507476f, 0.01107647f, 0.20299664f, 0.12589076f, -0.10163241f, 0.14275119f, 0.18904939f, 
    0.09726693f, -0.30359513f, -0.22561172f, 0.00685417f, 0.26388845f, -0.12076600f, 0.14433500f, -0.08857567f, 
    0.21533750f, 0.07374467f, 0.10455602f, 0.09292652f, -0.16811298f, -0.10690796f, -0.07161596f, -0.03848316f, 
    0.24116443f, -0.10071226f, 0.16516161f, -0.12168703f, 0.00971475f, -0.05553197f, -0.00989421f, -0.07872243f, 
    -0.04311090f, 0.06463197f, 0.12195478f, -0.20991763f, -0.03561139f, -0.15652914f, 0.05643801f, 0.03125129f, 
    -0.00961817f, 0.03140095f, -0.01077053f, 0.05027525f, -0.12413824f, 0.00189712f, 0.12399021f, -0.04298205f, 
    -0.02289445f, -0.03313400f, -0.10288118f, -0.03683230f, 0.08917188f, -0.00775982f, 0.06046862f, -0.01713180f, 
    0.11225259f, -0.25810120f, 0.16509192f, -0.22295776f, -0.04734569f, -0.07774906f, 0.09652134f, 0.08681659f, 
    -0.00078478f, -0.00156702f, 0.11115732f, -0.05064612f, -0.08408482f, 0.04011318f, 0.06896169f, 0.01569457f, 
    -0.08870354f, -0.07239257f, -0.02030919f, -0.01503898f, -0.00424508f, 0.10103711f, -0.01528895f, 0.12784904f, 
    -0.02892266f, 0.08506480f, 0.14092782f, 0.13081057f, 0.12996507f, -0.03511468f, 0.04378714f, -0.06004324f, 
    0.08151156f, 0.18983608f, 0.14271338f, 0.14353165f, 0.32871696f, -0.37095255f, 0.33091804f, -0.05383947f, 
    0.06884116f, -0.12275940f, 0.06019442f, -0.10104906f, 0.01512193f, -0.02192163f, 0.05449081f, -0.06541429f, 
    0.17230301f, -0.21943402f, 0.31758472f, 0.19895831f, -0.02221363f, 0.10079210f, 0.02621630f, -0.01747895f, 
    0.05789652f, -0.21777897f, -0.20792352f, -0.52448004f, 0.09843914f, -0.20777436f, -0.07754532f, 0.22789879f, 
    0.09225541f, 0.07930584f, 0.04556933f, -0.00310253f, 0.21930090f, 0.30212468f, 0.25834334f, 0.20415048f, 
    0.23924328f, 0.19194226f, 0.19053108f, -0.23643003f, -0.11091867f, 0.02167328f, -0.28682792f, 0.42810735f, 
    -0.24478488f, -0.08258706f, -0.15723048f, -0.14505538f, -0.00017226f, 0.07129835f, -0.09761995f, -0.21588907f, 
    0.04263212f, 0.07676358f, -0.12722112f, -0.09976654f, 0.02710065f, -0.22693652f, -0.11978690f, -0.06354249f, 
    0.08982193f, 0.06212786f, -0.05059022f, 0.03698500f, 0.00983712f, -0.01204515f, -0.01881405f, 0.05845044f, 
    0.06486799f, 0.16601862f, 0.27468890f, -0.06705493f, 0.09601314f, -0.05471630f, 0.40852383f, 0.15565859f, 
    -0.13368979f, 0.06724335f, 0.11367470f, -0.12555045f, 0.01535877f, -0.00824971f, 0.22844385f, -0.04241593f, 
    0.10915104f, -0.01927095f, 0.08470787f, -0.08235996f, 0.03339331f, 0.08972465f, 0.03356966f, 0.14735295f, 
    -0.12312012f, -0.03764487f, -0.09033170f, -0.12018224f, -0.36554638f, 0.22000411f, -0.22542980f, 0.00609231f, 
    0.07488883f, 0.19460629f, 0.11969178f, 0.17065240f, -0.10883283f, -0.08155294f, 0.06976133f, 0.12588100f, 
    0.40978596f, -0.10568135f, 0.42716053f, 0.07071663f, 0.08419214f, -0.00950900f, 0.05576107f, 0.12711754f, 
    -0.08250509f, -0.01837952f, -0.02473226f, -0.11825432f, 0.21004659f, -0.15818301f, 0.38999382f, 0.36136305f, 
    0.15888700f, -0.10067362f, -0.18667226f, 0.11075465f, -0.03630983f, -0.16017719f, -0.10782097f, -0.10022672f, 
    0.08933302f, 0.14360291f, 0.19805318f, 0.20012188f, 0.06629416f, -0.03137126f, 0.23463075f, 0.07297233f, 
    0.06594711f, 0.33178079f, 0.12013075f, 0.02645341f, 0.01172671f, 0.07581090f, -0.04196395f, -0.11013801f, 
    -0.07934639f, -0.07696611f, -0.17655069f, -0.28438577f, -0.00934131f, -0.10066392f, -0.02305462f, -0.06966493f, 
    0.11286743f, -0.19863608f, 0.05140169f, 0.10614050f, 0.12194433f, -0.16133440f, -0.04242047f, 0.05353355f, 
    -0.05508659f, -0.03794412f, -0.09854492f, -0.03767301f, -0.13083792f, -0.11785327f, -0.18769345f, 0.03174430f, 
    -0.02117037f, 0.27431712f, 0.09700101f, 0.15414116f, 0.08345196f, -0.05567724f, -0.02515282f, -0.09154441f, 
    -0.02876184f, -0.03450242f, 0.13470943f, -0.00553905f, -0.01013894f, 0.20429534f, -0.09629498f, -0.13728838f, 
    0.17498994f, -0.17035164f, 0.09445182f, 0.08230961f, 0.16174176f, -0.53250039f, 0.45715788f, 0.01373479f, 
    0.06810802f, -0.14547208f, 0.02000411f, 0.15207630f, 0.06862845f, 0.12201490f, 0.16688596f, 0.26350144f, 
    0.08902759f, 0.01736793f, 0.01660425f, -0.08824488f, 0.04439918f, -0.02815826f, 0.03959362f, -0.02202390f, 
    0.02937571f, 0.03090229f, -0.05572086f, 0.05310978f, 0.00237280f, -0.28808373f, 0.20211326f, 0.11624050f, 
    0.02796675f, 0.04127713f, -0.06904545f, 0.02409003f, -0.15279584f, 0.02382229f, -0.10020998f, 0.05974703f, 
    0.03872529f, -0.09892713f, -0.00979400f, -0.08987796f, 0.07621616f, -0.02007278f, -0.11932884f, 0.05536038f, 
    -0.14862901f, -0.01258270f, -0.18299317f, 0.19569449f, 0.14484389f, 0.06888269f, 0.18172331f, -0.20717056f, 
    -0.11980011f, 0.16140006f, 0.14075406f, 0.13975345f, 0.04004811f, -0.07202783f, 0.02865567f, -0.01733780f, 
    0.23210126f, -0.28724900f, -0.09262000f, 0.15952322f, 0.00616751f, -0.15904388f, 0.00190039f, 0.26342452f, 
    0.12249620f, 0.00091873f, 0.03330950f, -0.04793906f, 0.04115962f, 0.24419275f, 0.16591637f, -0.20666833f, 
    0.08073449f, 0.11748906f, 0.13013940f, 0.13640875f, 0.13226317f, -0.00699127f, 0.03648084f, 0.10043168f, 
    0.11354079f, -0.24303591f, 0.11065952f, 0.12092297f, 0.02724040f, 0.00617300f, -0.00344976f, 0.05524030f, 
    0.04968769f, 0.00917392f, 0.14854467f, 0.09776432f, 0.40947482f, -0.50930911f, 0.04297377f, -0.19255291f, 
    -0.27396020f, 0.03095118f, -0.14955848f, 0.07238368f, 0.29719150f, -0.08529979f, -0.00531755f, 0.06933236f, 
    0.10432692f, -0.01323617f, 0.23405932f, -0.13210951f, -0.00654263f, 0.03615940f, 0.00296287f, -0.10737497f, 
    0.01529513f, -0.07526405f, 0.06806853f, 0.09012753f, -0.19127831f, 0.33719015f, -0.30400544f, 0.26969853f, 
    0.08062810f, -0.16364065f, -0.10394924f, 0.15424511f, -0.07244479f, -0.03638984f, -0.00942111f, -0.03236828f, 
    0.10143422f, 0.36723414f, 0.12446612f, -0.06919805f, 0.15387551f, 0.06453080f, 0.03460219f, -0.00180713f, 
    -0.09244122f, -0.09045504f, -0.00525249f, -0.16561502f, 0.16591576f, -0.04728289f, -0.00737592f, 0.01968796f, 
    -0.18853876f, -0.04253632f, -0.09775628f, 0.08174059f, -0.14694981f, -0.07224540f, 0.07506298f, 0.03433101f, 
    0.05157088f, -0.11475632f, -0.11374161f, -0.20738216f, -0.14537784f, 0.15311772f, 0.13972642f, -0.07200617f, 
    0.12022726f, -0.10482237f, -0.07094215f, 0.00376298f, 0.08882993f, 0.08899267f, 0.03278903f, 0.13143174f, 
    -0.00470369f, -0.03675255f, 0.06259923f, -0.05704007f, 0.09889949f, 0.11093500f, 0.11646530f, 0.23611115f, 
    -0.37179857f, 0.08064133f, 0.14000912f, 0.31349176f, -0.08283970f, -0.04980399f, 0.04339929f, -0.04387486f, 
    0.21418652f, 0.03430530f, -0.09668174f, 0.18854102f, 0.47554964f, -0.27602974f, 0.36638623f, -0.00024027f, 
    -0.07623217f, 0.06393632f, 0.12456328f, -0.17094815f, 0.10933572f, 0.03999699f, -0.09542989f, 0.00304683f, 
    -0.04624691f, 0.06212603f, -0.04418886f, -0.02326438f, -0.03592987f, -0.04121457f, 0.01607199f, 0.02555683f, 
    -0.02097483f, -0.05682100f, -0.01608181f, -0.00860329f, 0.02021416f, 0.02197214f, -0.07673143f, -0.02452621f, 
    -0.03994717f, 0.03739527f, 0.00579192f, -0.02033756f, 0.00392287f, 0.03741840f, -0.04799660f, 0.01323112f, 
    -0.04284759f, -0.07099069f, -0.04818682f, 0.03274379f, -0.03365752f, 0.01847098f, -0.01891359f, -0.06147766f, 
    0.00056766f, -0.01181372f, 0.01093619f, -0.06977274f, -0.01960592f, -0.00508170f, -0.00358399f, -0.02233681f, 
    0.04328604f, 0.01678055f, 0.06026648f, 0.07212981f, -0.07189769f, -0.01746506f, -0.00852519f, -0.07021657f, 
    0.00042366f, 0.02287224f, -0.04906154f, -0.01191259f, 0.04990357f, -0.09227391f, -0.07895946f, 0.00451674f, 
    0.03605028f, 0.02752203f, 0.02695749f, 0.05472980f, -0.06490669f, 0.04490682f, 0.05752772f, -0.06119291f, 
    -0.06037875f, -0.01451358f, -0.04945341f, -0.01984616f, -0.04658155f, -0.03055477f, 0.03902962f, -0.03885778f, 
    -0.06618692f, 0.00603338f, 0.00310875f, -0.07772800f, 0.05068956f, 0.04769820f, 0.02519554f, -0.00625502f, 
    0.03544252f, 0.01164525f, -0.07405812f, 0.01916491f, -0.01952045f, -0.07699781f, 0.02918344f, -0.05419577f, 
    -0.05942055f, -0.01108850f, 0.01619981f, -0.07486372f, -0.01783859f, -0.06385463f, 0.00176443f, -0.04205412f, 
    -0.07138928f, 0.02405753f, 0.04149687f, 0.04013546f, -0.01555766f, -0.01356775f, 0.05422264f, 0.02781626f, 
    -0.03422842f, 0.02354775f, 0.02159574f, 0.00851781f, -0.06302743f, -0.03956410f, -0.06607868f, 0.04502087f, 
    -0.05371148f, 0.05988201f, -0.00358573f, 0.02338757f, -0.06343771f, -0.07652489f, -0.00082626f, 0.06055596f, 
    -0.02547426f, 0.05877137f, 0.01909406f, -0.03148209f, -0.02224712f, 0.00561170f, -0.04745512f, -0.01999677f, 
    -0.02254382f, 0.04212117f, 0.06383639f, -0.05571157f, -0.00493459f, 0.00538169f, -0.04979073f, -0.00846175f, 
    0.05507038f, -0.07025070f, -0.04903279f, -0.05891389f, -0.04425811f, -0.07866648f, -0.01736208f, -0.02942002f, 
    0.06155946f, -0.04900238f, -0.07692350f, 0.06114637f, 0.00001322f, 0.03215741f, -0.04450310f, -0.06723942f, 
    -0.06184807f, -0.06979045f, 0.01115148f, -0.05740937f, 0.05615010f, 0.03917099f, 0.05725142f, 0.01851203f, 
    -0.01824083f, 0.03279058f, 0.00977468f, -0.06252957f, -0.01394676f, -0.00669889f, 0.02570345f, 0.01933306f, 
    -0.05975126f, 0.02432439f, -0.00197127f, -0.04969028f, -0.02119462f, -0.07636492f, -0.02126278f, 0.04553159f, 
    -0.00410847f, -0.02991420f, -0.07142242f, 0.01715726f, -0.07515047f, -0.03977866f, 0.05553295f, 0.00369874f, 
    0.03458005f, 0.01523319f, -0.01175729f, -0.03267884f, -0.05765685f, -0.03449070f, 0.02048365f, -0.00218387f, 
    0.04441720f, -0.05409561f, -0.02311395f, -0.20587325f, 0.22727439f, 0.07959318f, 0.01009951f, 0.00312923f, 
    0.04286292f, 0.04485709f, 0.04562738f, 0.07074738f, -0.03423853f, -0.00146799f, -0.06101149f, -0.08548594f, 
    -0.03803285f, -0.13791645f, 0.00546926f, -0.11408576f, -0.27512607f, -0.22155800f, 0.05002325f, -0.15926386f, 
    0.31008223f, 0.16357207f, -0.14014900f, -0.07759615f, 0.01634910f, -0.26826081f, -0.18138300f, 0.16651587f, 
    0.14412975f, 0.01713690f, 0.08574054f, 0.08528960f, 0.32748443f, 0.23248270f, -0.23818250f, 0.23937556f, 
    0.01785726f, 0.01864863f, -0.02662005f, -0.02132540f, -0.09586703f, -0.04964256f, 0.06415451f, 0.09717923f, 
    -0.10710230f, -0.21860890f, -0.47252190f, -0.16512766f, -0.05235743f, -0.05344642f, 0.05005514f, -0.12215325f, 
    -0.02076260f, 0.09235039f, 0.19758919f, -0.04091269f, 0.41334924f, 0.17928265f, 0.34082648f, -0.03152203f, 
    -0.01490020f, 0.06035901f, 0.24227202f, 0.04837932f, -0.04329560f, 0.03567075f, 0.06923725f, 0.08384349f, 
    0.05312354f, -0.16867957f, -0.05225196f, 0.02635008f, -0.01500241f, -0.07642449f, -0.03474355f, -0.02360663f, 
    -0.01440828f, -0.05309508f, 0.01857035f, 0.09029930f, 0.15818805f, 0.48194030f, -0.35628244f, -0.05610905f, 
    0.02518457f, 0.09333492f, 0.18983179f, -0.02586344f, -0.00847577f, 0.00722716f, 0.04561764f, 0.20988253f, 
    0.86131340f, 0.37072870f, 0.40024635f, -0.12332632f, 0.18795897f, 0.02635367f, 0.11689813f, 0.03419583f, 
    -0.01163760f, 0.05103511f, 0.04738503f, 0.08600706f, 0.18254367f, 0.00068944f, 0.25180203f, 0.42974293f, 
    0.17513001f, -0.08579589f, -0.12803560f, 0.03206382f, 0.06078121f, -0.06459055f, 0.02625026f, 0.03320389f, 
    0.39806449f, 0.32701856f, 0.18937977f, 0.39468223f, -0.03130274f, -0.03832801f, 0.06050896f, 0.10428399f, 
    -0.12339555f, -0.01313995f, -0.04481079f, -0.06279592f, -0.06391338f, -0.08986253f, -0.03005898f, -0.18035415f, 
    -0.00000585f, -0.08026337f, -0.11025077f, -0.07212345f, -0.04092379f, -0.12390982f, 0.05619984f, 0.13471578f, 
    -0.04254933f, -0.18169266f, -0.20883048f, 0.19161165f, 0.04330986f, 0.18067753f, 0.08328048f, 0.06694041f, 
    0.19023894f, 0.09188702f, 0.09445423f, 0.04998735f, -0.22422808f, 0.05336681f, -0.09324866f, -0.02667006f, 
    -0.02661952f, -0.00163928f, -0.07623582f, -0.00155233f, -0.02983571f, 0.14135231f, -0.05164544f, 0.14344609f, 
    0.03786030f, -0.07102857f, -0.07117188f, -0.38127643f, 0.01906043f, -0.01163658f, -0.06164848f, 0.02326830f, 
    0.08245766f, 0.10230153f, -0.05923100f, 0.23123632f, 0.39309874f, -0.47941577f, -0.24067394f, 0.00290093f, 
    0.09478165f, 0.08253316f, 0.02515674f, 0.01459528f, -0.13286062f, -0.17723240f, -0.15713274f, -0.05960446f, 
    -0.13613126f, -0.05730808f, 0.10060922f, -0.03510188f, -0.00184411f, 0.04102603f, -0.14129606f, -0.05872596f, 
    -0.14090531f, -0.21529858f, -0.09018320f, -0.07612973f, 0.04280088f, 0.11061285f, -0.06122710f, 0.01592124f, 
    -0.14899254f, 0.01119849f, 0.10119563f, 0.16714060f, 0.27620178f, 0.11408560f, 0.14197814f, 0.04669266f, 
    -0.02388713f, -0.10648756f, 0.09707773f, 0.17982127f, -0.02361059f, -0.03756981f, 0.00975139f, -0.00707939f, 
    -0.09498607f, -0.03345444f, 0.01009462f, 0.11834976f, -0.14345643f, -0.31559122f, -0.52946353f, -1.03092515f, 
    0.17321235f, -0.13352129f, 0.14070754f, -0.09927600f, -0.20882516f, -0.08892192f, -0.12727234f, -0.19962922f, 
    -0.22521785f, 0.39071697f, 0.19737265f, -0.26026645f, -0.14193000f, 0.09573171f, -0.03133182f, -0.18941562f, 
    0.04597044f, 0.07993592f, -0.03100848f, 0.11007640f, -0.26077378f, -0.58104789f, -0.48913804f, -0.20878467f, 
    -0.04789821f, 0.11504835f, -0.01120738f, -0.20769866f, -0.12670228f, -0.02317802f, 0.05117587f, 0.02377178f, 
    0.05092134f, 0.00753300f, 0.08686945f, 0.27536258f, 0.08311117f, 0.05644368f, -0.04386020f, -0.14102726f, 
    0.05076218f, 0.07991955f, -0.06882523f, 0.09515760f, 0.16567464f, 0.09922229f, -0.09326317f, 0.14428926f, 
    0.10970169f, 0.29428589f, 0.13163364f, -0.01120822f, -0.04053896f, 0.05863832f, 0.11024708f, 0.08215959f, 
    -0.51053542f, 0.20689818f, 0.03081523f, -0.11744217f, -0.01782845f, -0.03257355f, 0.00713447f, 0.20567027f, 
    0.01960461f, 0.10249220f, -0.18217099f, -0.00396840f, 0.58158886f, -0.11408168f, -0.49407083f, -0.00524004f, 
    0.00967005f, 0.24705157f, 0.28081784f, -0.22308517f, -0.04410027f, -0.24449663f, -0.16677637f, 0.11140036f, 
    -0.08003803f, -0.38331112f, -0.11080056f, 0.27079943f, -0.13781695f, 0.00089431f, 0.25642753f, -0.04894506f, 
    0.00023889f, -0.03976120f, -0.00528900f, 0.10567101f, 0.13508303f, -0.02541999f, 0.13573796f, 0.16974351f, 
    0.00247707f, 0.16150104f, -0.05939844f, -0.02970587f, 0.19188650f, -0.00141553f, -0.06443536f, 0.15800171f, 
    -0.01522773f, 0.20017482f, 0.16565681f, 0.09868817f, -0.03980531f, -0.10937424f, -0.00675802f, -0.00376764f, 
    0.09827774f, 0.11805204f, 0.10179923f, 0.13386279f, 0.09666470f, 0.06095645f, 0.21138522f, 0.05468962f, 
    0.09933995f, -0.01696481f, -0.15592350f, -0.06416387f, 0.03987681f, 0.06127502f, -0.04693903f, -0.07682463f, 
    0.15488888f, 0.21560892f, 0.08129004f, -0.05652419f, -0.05293453f, 0.02558405f, -0.00859996f, 0.09815212f, 
    0.20866241f, 0.05756893f, 0.18342307f, -0.10705499f, -0.23806599f, 0.05184098f, -0.61848474f, -0.33937508f, 
    -0.45328191f, 0.04727617f, 0.05334361f, 0.29588148f, 0.16694167f, 0.02067801f, 0.15157725f, 0.14663479f, 
    -0.09253869f, 0.11143815f, 0.11107665f, 0.06819795f, 0.17689240f, 0.07261915f, -0.02268171f, 0.12258374f, 
    -0.07559404f, -0.06113793f, -0.05250033f, -0.08723353f, -0.03162144f, -0.13252451f, -0.10367812f, 0.16572401f, 
    -0.06647237f, 0.04569883f, 0.05520712f, 0.03591502f, 0.13132280f, 0.22264834f, 0.24246505f, 0.30013990f, 
    -0.25403816f, -0.04560529f, 0.13313299f, -0.03730737f, 0.32818106f, -0.03691979f, -0.01856283f, 0.33580118f, 
    -0.13664259f, 0.01277435f, -0.04530923f, -0.11745499f, 0.05384017f, -0.06584689f, 0.29649171f, 0.06877443f, 
    -0.16387656f, -0.12464951f, -0.07381758f, -0.13262773f, 0.02193892f, -0.09915940f, 0.02208457f, 0.02626901f, 
    -0.15474407f, 0.03031711f, 0.17661195f, 0.17653227f, 0.01160817f, 0.00908550f, 0.01342274f, 0.06713513f, 
    0.05214454f, 0.18090396f, 0.07681261f, 0.14748509f, -0.15200271f, -0.14169341f, -0.07384890f, -0.10411917f, 
    -0.10556303f, -0.09812759f, -0.18043964f, -0.23742796f, 0.07596701f, -0.10786165f, 0.01131744f, 0.15592843f, 
    0.18658882f, -0.04983848f, 0.05726371f, 0.15654019f, 0.09923517f, 0.10530074f, 0.11145581f, 0.01329770f, 
    0.04391413f, 0.03213622f, -0.09079248f, -0.13197637f, 0.10826248f, -0.71220225f, 0.29061717f, 0.19139592f, 
    -0.06039327f, 0.07056317f, -0.00754167f, -0.02704630f, 0.06591880f, 0.04214705f, 0.08524778f, -0.16588770f, 
    -0.22508085f, -0.15854105f, -0.16338228f, 0.03239977f, -0.17248520f, -0.12352382f, 0.04385551f, 0.04871827f, 
    -0.03518378f, -0.06578631f, 0.12165657f, -0.07994193f, 0.10612703f, 0.19356301f, 0.05606486f, -0.18106408f, 
    -0.01471497f, -0.08040085f, 0.09042714f, 0.07053857f, 0.00939906f, -0.13255595f, -0.03701225f, 0.03249950f, 
    -0.23429140f, 0.00744623f, 0.15101343f, -0.19871914f, -0.06160105f, 0.11071242f, -0.05011340f, -0.08956009f, 
    0.08851382f, 0.07403687f, 0.00985091f, 0.05932279f, 0.06861312f, 0.06901262f, -0.19900000f, 0.08313010f, 
    0.01416243f, 0.03028636f, 0.07888126f, 0.07141928f, 0.03403666f, -0.14020580f, -0.09383723f, 0.01472300f, 
    -0.06559140f, 0.26140183f, 0.08211012f, 0.09286724f, -0.02648679f, 0.04090770f, -0.03438332f, 0.18600103f, 
    -0.03147003f, -0.02069354f, -0.07296731f, -0.02430359f, 0.15070489f, -0.02857145f, -0.02464913f, -0.01272388f, 
    0.07228746f, 0.12332764f, -0.05648312f, 0.12947866f, 0.03923262f, 0.02400315f, -0.00261883f, 0.01003658f, 
    -0.45002332f, -0.05509343f, -0.08423977f, 0.36470774f, 0.20540731f, 0.10864779f, 0.01094863f, 0.07293282f, 
    0.12684242f, -0.08769164f, 0.07782092f, 0.07144395f, 0.01222268f, 0.12206651f, 0.47904488f, 0.19463247f, 
    -0.11297617f, -0.00809752f, -0.13108911f, -0.03418703f, -0.04215945f, 0.21199967f, 0.28975046f, 0.12003679f, 
    0.13232084f, 0.06245555f, 0.09625761f, -0.06067810f, -0.11233388f, 0.05055062f, -0.13121319f, -0.05288297f, 
    0.18376705f, 0.12318660f, 0.11218358f, 0.06684690f, 0.08465306f, -0.05406406f, -0.06445627f, -0.06246595f, 
    0.00226409f, -0.04328158f, -0.00443145f, -0.00933811f, -0.13571648f, -0.01635376f, -0.39889118f, -0.16633512f, 
    0.05198355f, -0.05441328f, -0.10449796f, 0.05053468f, -0.18540008f, 0.16592684f, 0.01949837f, -0.32041889f, 
    -0.05977420f, 0.03510673f, 0.06904986f, -0.01802355f, 0.29421920f, 0.21923558f, -0.01064535f, 0.23275493f, 
    -0.08311988f, -0.09910713f, -0.19631702f, -0.43459842f, 0.11292554f, 0.01290282f, 0.07358504f, 0.00948652f, 
    -0.08982856f, -0.00656020f, 0.05760181f, -0.06186796f, 0.16765004f, 0.01268728f, -0.01378640f, -0.07674014f, 
    -0.44590604f, -0.27419075f, -0.14941828f, 0.12920517f, 0.04433298f, 0.05166286f, 0.05903127f, 0.00739951f, 
    -0.11048295f, -0.12116652f, -0.48138598f, -0.55694985f, -0.07131112f, -0.16498117f, -0.05311183f, -0.12868962f, 
    -0.11612158f, -0.04534047f, -0.17936817f, -0.18807356f, -0.06794009f, 0.01864842f, 0.01272966f, 0.02038826f, 
    0.17196734f, 0.08258810f, -0.03149467f, -0.02588851f, 0.17656182f, 0.12680729f, 0.27633944f, 0.20954031f, 
    0.11467291f, 0.14225385f, 0.09096116f, -0.06785394f, -0.07024709f, -0.06297527f, -0.15941206f, 0.18127099f, 
    -0.13330942f, 0.16468200f, 0.03612124f, -0.07640138f, 0.11535278f, 0.17436090f, 0.21908660f, 0.33221495f, 
    0.01608628f, -0.03597770f, -0.09576929f, -0.02990756f, -0.05222834f, -0.21771146f, -0.09607721f, -0.00139732f, 
    -0.35925981f, -0.22453243f, -0.29521516f, 0.09643874f, 0.09137022f, 0.15031250f, 0.09486028f, 0.11302644f, 
    0.11913744f, 0.02839109f, 0.08596966f, 0.06327263f, -0.43775043f, -0.42577887f, -0.31101224f, -0.44382027f, 
    -0.13897470f, -0.07523752f, -0.02649741f, 0.02207960f, 0.08659028f, 0.00063411f, 0.16690065f, -0.25940061f, 
    0.18487620f, 0.05276077f, 0.05825594f, 0.06816757f, -0.05807245f, 0.07698339f, -0.00823011f, 0.02704810f, 
    0.61733788f, 0.16247445f, -0.05150846f, 0.01201700f, 0.26929381f, 0.10222246f, 0.05311322f, 0.15554416f, 
    -0.04229706f, 0.19218428f, 0.11930392f, 0.26748070f, -0.03496853f, -0.04890130f, -0.00798436f, -0.02933088f, 
    0.02702851f, 0.10642399f, 0.06063478f, 0.08858690f, 0.09273949f, 0.04778447f, -0.09667023f, -0.18899192f, 
    0.22117071f, -0.16796868f, -0.17625305f, -0.11155597f, 0.06916003f, -0.03419477f, 0.13322748f, 0.13050224f, 
    -0.22719762f, -0.20262933f, -0.29728302f, 0.04926234f, -0.35548010f, -0.20886372f, -0.02935889f, 0.00758779f, 
    -0.08815347f, -0.22654730f, -0.09434173f, 0.31754163f, -0.63629651f, -0.01082980f, 0.00631672f, -0.11106977f, 
    -0.27143079f, 0.12279512f, -0.10450595f, 0.17421496f, 0.00516612f, 0.07754914f, 0.12140111f, -0.04338430f, 
    -0.05182062f, -0.01974931f, 0.01851512f, -0.10128604f, -0.31119645f, 0.03046032f, 0.03936539f, -0.00862558f, 
    0.07607910f, -0.06359407f, 0.05889235f, 0.09895279f, -0.13981156f, -0.23256747f, -0.11764310f, -0.18457507f, 
    -0.30441624f, 0.33103949f, 0.18334533f, 0.30224657f, -0.02623080f, 0.00496530f, 0.06916344f, 0.38847581f, 
    0.17954464f, -0.04447391f, 0.11638827f, 0.38911644f, 0.05957340f, 0.05364479f, 0.10204391f, -0.23587365f, 
    0.21050143f, -0.09322132f, 0.09311321f, -0.11948877f, -0.07059085f, 0.03199275f, -0.00847501f, 0.02294439f, 
    -0.11687277f, 0.16861583f, -0.19433533f, 0.06279758f, 0.05224199f, 0.00342897f, 0.10502179f, 0.22341235f, 
    0.00912729f, 0.12022711f, 0.16735497f, -0.14380863f, 0.19778368f, 0.30562475f, 0.04953064f, -0.25533444f, 
    -0.02126141f, 0.12347678f, 0.01370677f, -0.03096780f, 0.10187826f, 0.08529010f, -0.04475901f, -0.11691461f, 
    0.00832716f, 0.10220604f, -0.09100166f, 0.16214538f, -0.03389840f, -0.05133318f, -0.09923305f, 0.06232720f, 
    -0.02825005f, -0.10557420f, 0.05894846f, 0.05850022f, 0.05577154f, -0.11643430f, 0.04430968f, 0.01074673f, 
    0.06824374f, -0.03342945f, 0.15110458f, 0.02238708f, 0.00941605f, 0.05696485f, 0.12294004f, 0.08253242f, 
    -0.11815403f, 0.20399195f, 0.17437232f, -0.16795273f, 0.11126953f, 0.25122395f, 0.06980111f, -0.08535075f, 
    0.09745892f, 0.06148512f, -0.03216733f, 0.09312374f, 0.38153872f, -0.11773667f, 0.23578605f, -0.26828769f, 
    0.00946180f, 0.02665500f, -0.00316727f, -0.03009507f, 0.00495237f, -0.06570126f, 0.00040177f, 0.01656228f, 
    0.00625834f, 0.10119493f, -0.01534229f, -0.16694696f, 0.11726201f, 0.00008245f, -0.01892402f, -0.04923842f, 
    -0.10352735f, 0.07552219f, -0.00724820f, -0.13270403f, -0.25817776f, 0.05616075f, -0.05717031f, 0.23467274f, 
    -0.05640965f, -0.04387588f, -0.05776506f, 0.00504935f, 0.12354250f, -0.12644272f, 0.05543876f, -0.16528051f, 
    -0.46477041f, 0.01549288f, -0.03098572f, -0.16107821f, 0.08084545f, 0.12521037f, 0.08335544f, 0.02345006f, 
    0.07141910f, 0.05480164f, -0.03686017f, -0.14055794f, -0.05403727f, -0.16063546f, -0.08738893f, 0.13237487f, 
    0.02838804f, 0.05780909f, -0.04292405f, -0.10583033f, -0.00180637f, -0.09305935f, -0.04419284f, -0.03838122f, 
    -0.51873344f, 0.07681712f, 0.20575762f, 0.19706658f, -0.14324856f, 0.16236040f, 0.05536608f, 0.18489760f, 
    0.04386479f, 0.23768422f, 0.14222468f, -0.09199804f, 0.04779298f, 0.29963392f, -0.30509609f, -0.43606344f, 
    0.09095271f, 0.14817582f, -0.03874524f, 0.06065362f, 0.21303268f, -0.08663162f, -0.05010691f, -0.16867077f, 
    -0.27818844f, -0.04643361f, -0.15722214f, 0.18310417f, 0.02574041f, 0.11611901f, 0.14650062f, 0.04041082f, 
    0.17010254f, 0.04722161f, 0.13073498f, 0.06574232f, -0.12934804f, 0.31063101f, -0.22368458f, -0.15797091f, 
    -0.11746916f, 0.07684235f, -0.00092280f, 0.05197478f, 0.18932782f, 0.12849994f, -0.00767035f, 0.09157364f, 
    0.05557805f, -0.12186395f, 0.07055672f, -0.10499068f, -0.03463946f, 0.18372118f, 0.23207894f, -0.03178984f, 
    0.25925606f, -0.05340022f, 0.25238717f, -0.11532174f, -0.17723447f, -0.29248586f, 0.11264693f, 0.08286645f, 
    0.10034047f, -0.06958427f, -0.06305624f, 0.00509419f, -0.05135912f, 0.04315129f, -0.04890213f, -0.13559081f, 
    -0.26432717f, 0.47497946f, -0.11120945f, -0.16830844f, 0.03658801f, 0.11855451f, 0.03753867f, -0.00089132f, 
    -0.07620720f, 0.00648982f, 0.07905400f, -0.04167658f, -0.15539560f, -0.17071868f, -0.18690737f, 0.12316633f, 
    0.07571736f, -0.04781837f, -0.11394162f, 0.11629348f, 0.07023366f, -0.00762494f, -0.01413064f, -0.08029055f, 
    0.12699933f, 0.29459783f, -0.06188986f, -0.16546285f, -0.33204496f, -0.14738171f, -0.06879738f, 0.02937116f, 
    0.07967839f, 0.01720169f, 0.00982961f, -0.07818206f, -0.13868505f, 0.37624809f, 0.18659084f, 0.05521075f, 
    0.21883164f, 0.05984493f, 0.19350603f, 0.09708323f, -0.04753233f, 0.05092606f, 0.11733290f, 0.06554300f, 
    -0.45479688f, -0.04823998f, -0.26528403f, 0.26212552f, 0.05967684f, 0.20087962f, 0.07286671f, 0.14405069f, 
    0.03310523f, -0.06980708f, -0.02816516f, -0.02915294f, 0.08917715f, -0.32384655f, 0.50593507f, -0.58184993f, 
    0.03408996f, -0.21028337f, -0.16233656f, -0.07189383f, -0.10244768f, 0.08253989f, 0.19697265f, 0.05698989f, 
    -0.09073079f, -0.26117924f, -0.05661783f, -0.13736741f, -0.08796342f, -0.02685084f, 0.12339108f, 0.00455186f, 
    0.00308043f, 0.01701873f, 0.03479871f, -0.01378705f, -0.11249802f, 0.20996945f, 0.04022174f, 0.02171761f, 
    0.15604012f, 0.00340168f, 0.05393062f, 0.23264037f, 0.16452357f, 0.06309360f, 0.02432710f, -0.01293331f, 
    -0.02422620f, 0.05337148f, 0.11947371f, 0.15697183f, 0.02543749f, -0.02547942f, -0.01446284f, 0.03132014f, 
    -0.01219245f, 0.18885657f, 0.12802465f, -0.06055255f, -0.07777300f, -0.07763182f, -0.01028925f, -0.19390047f, 
    -0.33731055f, 0.00986138f, -0.22485524f, -0.02994350f, -0.21539043f, 0.05844875f, 0.15120298f, -0.15198912f, 
    0.44710830f, 0.17795095f, -0.20585930f, -0.11300826f, -0.07709509f, 0.00758760f, -0.09452203f, 0.18062292f, 
    -0.07947195f, 0.05059657f, 0.18865924f, -0.09939655f, -0.22053614f, 0.34593484f, -0.19989279f, 0.02813491f, 
    -0.00612554f, -0.08535212f, -0.01238281f, 0.21096554f, 0.00270390f, 0.11905638f, 0.09362337f, 0.11685482f, 
    0.04786218f, -0.02896514f, -0.05466874f, -0.12404405f, 0.11742153f, -0.03892809f, -0.00170843f, 0.14349571f, 
    -0.08637960f, 0.02560796f, 0.04869597f, -0.04929140f, 0.04588294f, 0.01197056f, -0.28811345f, -0.08249214f, 
    -0.00128659f, -0.05056414f, 0.01656298f, -0.06436075f, 0.04611216f, 0.26107275f, 0.00501275f, 0.13825387f, 
    0.03812596f, 0.09018628f, -0.00276122f, -0.18688625f, 0.14652053f, 0.00484101f, -0.04786268f, 0.01067844f, 
    -0.15433848f, 0.07915495f, 0.08643961f, -0.38671523f, -0.11758114f, -0.21878411f, 0.19225572f, 0.34636495f, 
    -0.01409766f, -0.09523463f, 0.04885430f, 0.00605574f, -0.02717042f, 0.01736325f, -0.05854350f, -0.02070382f, 
    -0.08569701f, -0.08121238f, -0.16440295f, -0.03219893f, -0.04664591f, 0.02439162f, 0.05896663f, 0.09131017f, 
    0.01860417f, -0.06225700f, 0.02975123f, -0.03297975f, -0.20211983f, -0.31016344f, 0.03512059f, 0.19461413f, 
    -0.02922380f, -0.11759359f, -0.05310083f, 0.01253619f, -0.09059331f, -0.13817182f, -0.05834620f, 0.11079186f, 
    0.13142443f, 0.33018208f, 0.05263016f, -0.19381732f, -0.13033567f, -0.18654312f, -0.06185951f, 0.10280935f, 
    0.01362320f, 0.15274821f, 0.00079540f, -0.04386531f, -0.02407112f, 0.21203443f, 0.19550857f, 0.04204496f, 
    0.06534863f, 0.04697885f, 0.25041041f, 0.06098332f, -0.01676976f, 0.03461669f, 0.04410293f, 0.01651695f, 
    0.36630562f, -0.17972949f, -0.23007375f, 0.33271050f, -0.16093946f, -0.03977414f, 0.02734388f, 0.05062051f, 
    -0.06148053f, 0.15160674f, 0.08724262f, -0.07179987f, 0.04309839f, -0.24133575f, 0.60494697f, 0.12325174f, 
    -0.00665886f, 0.09151824f, -0.21089414f, 0.09594306f, 0.06224840f, -0.04509519f, 0.18092851f, -0.15418260f, 
    -0.15981595f, -0.07329499f, -0.04174995f, 0.17381729f, -0.10757142f, 0.07324937f, -0.02857278f, -0.14060386f, 
    0.13763301f, -0.00661927f, -0.07996158f, 0.01076096f, 0.15394290f, 0.14482006f, -0.23785560f, -0.02272151f, 
    0.16809306f, -0.14579344f, 0.29359320f, 0.20208816f, -0.21964176f, -0.05255126f, -0.10981893f, 0.07529550f, 
    0.07313605f, 0.16896588f, 0.03237763f, 0.43910792f, -0.16133414f, 0.11217912f, 0.04197618f, 0.15400362f, 
    0.10759049f, 0.01327674f, 0.13383015f, -0.03874395f, -0.11307724f, -0.03212263f, -0.03351315f, -0.29583976f, 
    -0.10365058f, 0.04177428f, -0.11828902f, -0.03993652f, -0.06195122f, -0.01689234f, 0.02240497f, -0.08904979f, 
    0.74336326f, 0.07706233f, -0.34287795f, 0.02577630f, 0.23955828f, -0.21606569f, -0.01206342f, 0.09116726f, 
    0.00389865f, 0.08567131f, -0.00510722f, 0.25520507f, -0.32131824f, 0.10770981f, -0.05784773f, 0.26118246f, 
    0.01133845f, 0.12036107f, 0.10212326f, 0.03879420f, 0.09541187f, 0.03029196f, -0.05618665f, 0.08691947f, 
    -0.05537397f, -0.13081996f, -0.20822828f, -0.06238038f, 0.13078029f, 0.03183390f, 0.08374576f, 0.18473381f, 
    -0.03227161f, -0.04831627f, 0.11139952f, 0.08892972f, -0.04359314f, 0.23398757f, -0.25238174f, -0.07139073f, 
    0.09140728f, 0.10364852f, -0.06165218f, -0.11689023f, 0.09293218f, 0.01874557f, -0.01100546f, -0.02357744f, 
    0.11477081f, 0.07117645f, -0.15855442f, -0.12396248f, 0.07776392f, 0.18725984f, 0.02859401f, -0.12570563f, 
    0.28886184f, 0.20915490f, 0.15553378f, -0.13389353f, 0.02542999f, -0.17959519f, 0.05935823f, 0.34906593f, 
    0.00691360f, -0.00825915f, 0.00058671f, 0.04757845f, -0.00441607f, 0.07974046f, 0.08029418f, 0.09729462f, 
    -0.13924842f, -0.20654225f, -0.20386878f, -0.03073257f, -0.10370903f, 0.10995682f, 0.09430638f, 0.03175417f, 
    0.01179384f, 0.02352432f, -0.01862893f, -0.16743745f, -0.19656011f, -0.11797996f, -0.09370250f, 0.11063544f, 
    -0.00846320f, -0.09586683f, 0.01113925f, -0.00097614f, 0.02048157f, 0.12575933f, -0.02987886f, 0.08171718f, 
    0.08571190f, 0.35673174f, 0.05780138f, -0.24003433f, -0.21857700f, -0.03035815f, -0.02072942f, 0.06923306f, 
    0.00345437f, -0.03314400f, -0.09658520f, 0.04172385f, -0.26492667f, 0.47674069f, -0.01538005f, 0.02555688f, 
    0.02773290f, 0.00016811f, 0.16734076f, 0.00225894f, -0.02510927f, -0.06004588f, 0.07089087f, 0.08017973f, 
    0.22014831f, -0.13091065f, -0.30393216f, 0.37600261f, 0.07405984f, 0.00378140f, 0.11032556f, 0.15901642f, 
    0.06966109f, 0.11045653f, 0.07852918f, 0.01305217f, -0.04701244f, -0.26804543f, 0.61176521f, -0.02346639f, 
    -0.07688427f, -0.05978597f, -0.10281951f, -0.07853483f, -0.07708770f, 0.03099166f, 0.11646973f, -0.08701941f, 
    -0.06094488f, -0.11932148f, 0.11875089f, 0.20645869f, -0.17187108f, -0.07041182f, -0.11732743f, -0.00887855f, 
    0.04198163f, 0.03074681f, -0.00948621f, 0.12970971f, -0.11543281f, 0.15750392f, -0.22919559f, -0.17089984f, 
    0.06080943f, -0.17441484f, 0.06165633f, 0.02977147f, -0.04481348f, 0.07047655f, -0.06812571f, 0.05416874f, 
    0.03545456f, 0.01080305f, -0.01482072f, 0.31222856f, -0.08827528f, -0.01506583f, 0.07064568f, 0.11639221f, 
    -0.02365860f, 0.03980577f, 0.07706442f, 0.03625878f, -0.22094780f, -0.09882661f, -0.12575503f, -0.25306085f, 
    -0.20517986f, 0.03063952f, -0.00351233f, -0.04225315f, -0.27027908f, -0.00763327f, -0.04916247f, -0.09511139f, 
    0.61436045f, 0.08688315f, -0.28538436f, -0.17043358f, 0.18329710f, -0.12096485f, 0.03188007f, -0.05656717f, 
    0.03429268f, 0.10178235f, 0.01879846f, 0.14615873f, -0.19208807f, 0.10291711f, -0.09875166f, 0.29671371f, 
    0.08838169f, 0.02728171f, -0.01200870f, 0.02796507f, -0.10454565f, 0.04598219f, -0.10044632f, 0.05410448f, 
    -0.00828605f, -0.30703184f, -0.12391610f, -0.20248955f, 0.17482731f, 0.04372296f, 0.15345000f, 0.16497527f, 
    -0.00965040f, -0.12563761f, 0.10626537f, 0.13102996f, -0.01210096f, 0.08592520f, 0.04741644f, -0.10215886f, 
    0.09396591f, 0.00950974f, -0.05063424f, -0.00837225f, 0.06467619f, -0.31464240f, -0.01565984f, -0.24228488f, 
    0.37805587f, 0.01923215f, -0.14205755f, -0.25582203f, -0.24737032f, 0.06337629f, -0.08509382f, -0.03730698f, 
    0.35105646f, 0.04386295f, 0.29519981f, 0.28205568f, -0.08883696f, -0.13007669f, -0.08119494f, 0.02247030f, 
    0.22286320f, 0.16335529f, -0.02535618f, -0.00034355f, -0.08945192f, 0.01423180f, 0.03478702f, 0.06529097f, 
    -0.05856064f, 0.05033880f, -0.40644237f, -0.24904643f, 0.00269712f, 0.05161167f, 0.03026421f, -0.05515350f, 
    0.00845547f, 0.04276191f, 0.10545192f, -0.06375168f, 0.04313400f, 0.05094581f, 0.22783546f, 0.01617146f, 
    -0.06455113f, -0.00350634f, 0.02796728f, 0.05296224f, 0.06453326f, 0.11433260f, -0.01958445f, 0.05701335f, 
    0.10929047f, 0.19717652f, 0.14746337f, -0.06890108f, -0.14459166f, -0.04748322f, 0.04968069f, -0.20187871f, 
    0.01993956f, -0.00775697f, -0.03512996f, 0.14132744f, -0.10343050f, 0.57039720f, -0.31795135f, -0.14940165f, 
    0.00634978f, 0.09585604f, 0.19430435f, -0.05009288f, -0.02367254f, -0.05716945f, -0.05875845f, 0.09738339f, 
    0.35219064f, -0.03580393f, -0.00149631f, -0.02603248f, 0.29466605f, 0.03936291f, 0.14103100f, 0.05254646f, 
    0.18058950f, 0.01803749f, 0.04755080f, 0.06272087f, -0.03760745f, -0.18371578f, 0.17978589f, 0.05681122f, 
    0.00610144f, -0.07366307f, -0.01004281f, -0.13105030f, 0.06816766f, 0.02791075f, 0.09841892f, 0.07494191f, 
    0.11195154f, -0.01082940f, 0.04546456f, 0.10201134f, 0.00111612f, -0.08430123f, 0.03551215f, 0.02592446f, 
    -0.17928386f, -0.00404377f, -0.06443918f, 0.04654507f, 0.01619255f, -0.13463618f, 0.18575026f, -0.10697173f, 
    -0.16606288f, -0.03850104f, -0.06146496f, 0.00035744f, 0.17184208f, 0.04175060f, 0.09300814f, -0.02236690f, 
    -0.11998014f, -0.36557427f, -0.05772645f, -0.04427423f, 0.14223899f, 0.06607149f, 0.06502524f, -0.13580075f, 
    0.08351050f, 0.11418051f, 0.21313959f, 0.05648623f, -0.26873216f, -0.03791434f, 0.06614399f, -0.00765059f, 
    -0.15202236f, -0.07227629f, -0.04817204f, -0.22674634f, -0.08012120f, 0.00467574f, -0.08883581f, 0.04353693f, 
    0.42433912f, -0.05046501f, 0.06747714f, -0.32598549f, -0.07508685f, -0.04700624f, 0.05368837f, -0.08223333f, 
    0.09177715f, 0.18232515f, 0.10952444f, 0.06946722f, 0.14045486f, -0.22542623f, -0.05485735f, -0.11234786f, 
    0.17144513f, 0.01168669f, 0.11087165f, 0.01256936f, 0.05157977f, 0.02423647f, -0.05036943f, 0.00252813f, 
    0.02772671f, 0.03460301f, -0.04806220f, -0.01499169f, 0.02742111f, 0.01444031f, -0.03254969f, -0.05477573f, 
    -0.01044868f, -0.08880853f, -0.02300316f, -0.04480208f, 0.01101424f, -0.00298183f, -0.07961952f, -0.05682994f, 
    -0.05480392f, -0.07111170f, -0.04480218f, -0.08678843f, -0.00678233f, -0.05710113f, -0.00761506f, 0.02645882f, 
    0.09422942f, 0.03732914f, -0.06308249f, 0.10119191f, -0.04730655f, -0.05473476f, 0.01035408f, -0.07846288f, 
    -0.06361517f, -0.00161195f, -0.09893106f, 0.00449165f, 0.06359185f, 0.07626564f, 0.08553807f, 0.05407245f, 
    -0.04694327f, -0.01616789f, 0.04681233f, 0.05769569f, -0.08305556f, 0.00941603f, -0.02436256f, -0.11420071f, 
    -0.02211795f, 0.02875393f, -0.04381543f, 0.01279012f, -0.00319152f, -0.00592334f, -0.07161788f, 0.04672231f, 
    0.06101285f, -0.00804472f, 0.01468602f, -0.04643148f, 0.04241407f, 0.00757562f, -0.00456436f, 0.01957204f, 
    0.00578664f, -0.04278569f, -0.00045818f, 0.00975378f, -0.08822565f, -0.07439286f, -0.13888602f, -0.13915108f, 
    -0.06420895f, -0.13975480f, -0.11268968f, -0.11953769f, -0.09481257f, -0.04409821f, -0.02502166f, -0.03675614f, 
    0.03928608f, -0.02204126f, -0.07083239f, -0.06313060f, 0.00736246f, 0.01414085f, -0.00115863f, -0.04301366f, 
    0.04862208f, 0.04969372f, 0.05477234f, 0.05144475f, 0.04308879f, -0.01180808f, -0.00764596f, 0.07446346f, 
    0.09847961f, 0.01298219f, 0.01343850f, 0.04535391f, 0.02629841f, 0.03553321f, 0.01939727f, -0.00886607f, 
    -0.07994973f, -0.01771380f, -0.10498908f, -0.11017413f, 0.02619432f, -0.02515508f, -0.04124968f, -0.03154263f, 
    -0.03014971f, -0.05313011f, -0.05520586f, 0.03215401f, -0.00392922f, -0.08519587f, -0.06537412f, -0.05359505f, 
    -0.00422843f, -0.00751905f, -0.04720078f, 0.03351686f, 0.07523753f, -0.04448931f, 0.08127313f, 0.00638444f, 
    -0.02192247f, -0.04624779f, -0.04889612f, -0.01738038f, 0.05930758f, -0.03829861f, -0.07357870f, -0.01618878f, 
    0.00418700f, -0.01124075f, -0.03624438f, -0.02114582f, 0.01908771f, 0.03808679f, -0.05714749f, 0.04941449f, 
    0.03355677f, -0.02694963f, 0.06477116f, -0.01611240f, 0.01132532f, -0.02775461f, 0.00591076f, -0.08434105f, 
    0.03521724f, 0.08270004f, 0.02435887f, -0.00570993f, -0.08623243f, 0.02091012f, -0.09219713f, 0.01157477f, 
    0.02477209f, -0.06492411f, -0.05863820f, 0.01257449f, -0.04360932f, -0.04800804f, -0.06694193f, -0.05548588f, 
    -0.05797658f, -0.07500880f, 0.04142877f, 0.07719528f, -0.08092880f, -0.04448450f, -0.04972399f, 0.02939776f, 
    0.01340545f, 0.05803540f, 0.02222179f, 0.01846570f, 0.09852196f, -0.01511153f, -0.04122933f, 0.03392643f, 
    -0.05849742f, -0.07998242f, 0.00780751f, -0.01583018f, -0.05261296f, -0.01269009f, -0.04360598f, -0.06371921f, 
    0.42896947f, -0.46777752f, 0.10800854f, -0.07360310f, 0.06889980f, -0.08727595f, -0.08682705f, -0.09058521f, 
    -0.13001505f, -0.04872748f, -0.03338207f, -0.02295962f, 0.01931080f, 0.06577621f, -0.01617130f, 0.04100837f, 
    -0.06051158f, 0.26666859f, 0.03739132f, -0.21603437f, 0.15295009f, 0.27922088f, 0.23223370f, 0.19915196f, 
    0.41573060f, -0.08058865f, 0.02289232f, 0.04631435f, -0.10586632f, -0.04433862f, -0.13093258f, 0.07565467f, 
    -0.03043325f, -0.01963519f, -0.05606139f, -0.14922133f, -0.18756101f, 0.00370493f, -0.08086399f, 0.13875188f, 
    -0.01348246f, 0.02714013f, -0.00737100f, 0.19928795f, 0.08058792f, 0.01281492f, -0.18923685f, -0.06486359f, 
    -0.04433179f, 0.01598034f, 0.32647735f, 0.00985265f, 0.12136178f, 0.19684011f, -0.06800257f, -0.08414017f, 
    0.02033189f, 0.01900641f, 0.05390721f, 0.06208778f, -0.26570770f, -0.27602649f, 0.11768840f, 0.42901558f, 
    -0.01194364f, -0.00171509f, 0.07892628f, 0.13429986f, 0.02851647f, 0.18966080f, -0.05838871f, 0.00839756f, 
    0.02140011f, -0.16655311f, 0.06021444f, -0.19246386f, 0.03454169f, 0.04015302f, 0.24369012f, 0.05329025f, 
    0.07615555f, 0.04116613f, -0.00446280f, 0.02663645f, -0.65498924f, 0.45836741f, 0.00068827f, -0.03313826f, 
    0.09967285f, 0.12963058f, -0.15205257f, -0.03154110f, -0.06080832f, 0.07068862f, -0.01557090f, 0.02893893f, 
    0.02664373f, -0.25884429f, 0.14118020f, 0.27992648f, 0.05703201f, -0.18719575f, 0.02832978f, 0.14052181f, 
    -0.02282410f, 0.17603612f, -0.06138172f, -0.28734821f, 0.11827035f, 0.40404433f, -0.06590910f, 0.40963411f, 
    0.06475650f, 0.31320339f, 0.15306683f, -0.07166632f, -0.16097835f, 0.13898438f, 0.07384620f, -0.06028306f, 
    -0.07419071f, -0.09047827f, 0.07599562f, 0.26049843f, 0.08863999f, 0.08801594f, 0.25141671f, 0.10589971f, 
    -0.09241146f, -0.03062238f, -0.07104203f, 0.04383389f, -0.01141886f, -0.11368765f, -0.11812866f, -0.14960907f, 
    0.01137688f, 0.16534132f, -0.18313500f, -0.53621417f, -0.06943744f, 0.15524749f, -0.04652217f, 0.04816724f, 
    0.07068276f, 0.02964833f, 0.18445233f, 0.10270965f, -0.04783941f, -0.25999764f, -0.14091934f, -0.30024266f, 
    -0.11614522f, 0.02326623f, -0.04218353f, -0.07535005f, 0.02491218f, 0.04542305f, -0.13981988f, -0.17608958f, 
    -0.03419410f, -0.02541307f, -0.03881313f, 0.06518335f, 0.11918257f, -0.08316195f, 0.15341300f, -0.10980400f, 
    0.30909637f, 0.15462792f, -0.10052872f, -0.01738445f, -0.05097574f, -0.07326572f, -0.09379455f, -0.29624298f, 
    0.06979079f, -0.06285275f, 0.08922219f, 0.02186177f, -0.18227556f, -0.20482266f, 0.12180819f, 0.14891045f, 
    0.12018005f, -0.04334363f, 0.00975880f, 0.01797676f, 0.01128043f, 0.17434549f, -0.06456297f, 0.08742920f, 
    -0.08099251f, -0.05845106f, 0.06332963f, -0.02942084f, 0.09016707f, 0.19015886f, 0.05792241f, -0.02940376f, 
    -0.02041124f, -0.16252986f, -0.14887142f, -0.11934442f, 0.16688780f, 0.02628122f, 0.17550750f, 0.24211411f, 
    0.00159626f, 0.03123342f, 0.01101980f, 0.02189628f, 0.32289901f, 0.03336162f, 0.18549693f, 0.01839228f, 
    0.01252152f, -0.02970363f, 0.09001347f, -0.15951467f, 0.02036681f, 0.02484942f, -0.02810378f, 0.10494369f, 
    -0.15131591f, -0.10847947f, -0.14955020f, -0.09343899f, -0.30158445f, -0.12820657f, -0.23177080f, -0.66769463f, 
    -0.08892868f, -0.12180110f, -0.17865723f, -0.22598031f, -0.03242778f, -0.09535177f, -0.00462926f, -0.05123324f, 
    -0.04376397f, 0.10986128f, 0.14450355f, -0.08159962f, -0.05928027f, -0.00345572f, -0.10387016f, -0.20721552f, 
    0.11000220f, 0.08376216f, -0.00476043f, 0.15737349f, -0.07680584f, -0.35437810f, -0.29661399f, -0.14141822f, 
    0.00197781f, -0.12712486f, -0.06651793f, -0.11347476f, 0.02521506f, 0.02350882f, 0.18753174f, -0.00006378f, 
    0.29577160f, 0.00899593f, 0.13590470f, 0.26652640f, 0.07445484f, 0.02361390f, -0.02216717f, -0.08456364f, 
    -0.00822433f, 0.08338163f, -0.05147298f, -0.09695351f, -0.05520409f, -0.00668979f, -0.03349828f, 0.30517599f, 
    0.21007641f, 0.30615160f, -0.01154035f, 0.24421647f, 0.10387328f, 0.15538681f, 0.25199285f, -0.10709606f, 
    -0.35254437f, -0.06501403f, 0.13129342f, -0.02975289f, 0.14610198f, -0.29848048f, 0.06361249f, 0.27871099f, 
    0.05088403f, 0.01227118f, -0.07186151f, -0.08395416f, 0.31888208f, 0.11707987f, -0.20287062f, 0.00226479f, 
    0.19939727f, 0.02421945f, 0.16703618f, -0.09420183f, -0.02582887f, -0.03548623f, -0.08888093f, 0.00543205f, 
    0.08621354f, 0.00122181f, 0.05383180f, -0.10166567f, -0.14091170f, -0.04681287f, 0.20933041f, 0.05501994f, 
    0.09578238f, 0.01790195f, 0.13400678f, 0.21073285f, 0.06274925f, 0.04032560f, 0.07664479f, 0.12585196f, 
    0.01230285f, 0.06338155f, -0.07763772f, -0.05692707f, 0.03033730f, -0.15059708f, -0.14113098f, -0.05310210f, 
    0.06549087f, 0.01029287f, 0.21614465f, 0.04250550f, 0.05103323f, -0.22682206f, -0.17475249f, 0.20538363f, 
    -0.08173258f, 0.06182056f, -0.03243297f, 0.06884118f, 0.18169382f, 0.09200450f, 0.09111140f, 0.15098506f, 
    -0.04959224f, 0.03861817f, -0.09014171f, -0.10914057f, 0.04073706f, -0.00353868f, 0.05370378f, -0.14176150f, 
    -0.31191239f, 0.06936754f, 0.34205544f, 0.29116607f, 0.03659537f, 0.05851701f, -0.09651321f, -0.06225813f, 
    0.07843008f, -0.12169833f, 0.35727191f, -0.08451653f, 0.05263077f, -0.34313810f, 0.29053861f, -0.06255303f, 
    -0.05074482f, -0.12892030f, 0.02767126f, -0.01033613f, -0.07398058f, 0.14637046f, 0.28933376f, 0.09994405f, 
    0.01811378f, 0.05578558f, -0.02593921f, -0.02129047f, 0.06446981f, -0.08840547f, 0.07210160f, -0.20125130f, 
    -0.05765951f, -0.11386840f, 0.01396253f, -0.07517737f, 0.12829293f, 0.23065682f, 0.24649496f, 0.14601387f, 
    -0.11639974f, 0.05861606f, 0.01878378f, -0.06616677f, 0.03385126f, -0.04697270f, -0.07253735f, 0.08740292f, 
    -0.17786607f, 0.23538685f, -0.04113292f, -0.09936652f, -0.06958560f, 0.25581932f, -0.11943591f, -0.09576016f, 
    0.07038391f, 0.08007996f, -0.06767303f, -0.01281927f, 0.04374513f, 0.07210242f, -0.38696256f, -0.20282429f, 
    0.14722297f, 0.24143834f, 0.05672381f, 0.29250666f, -0.00265194f, -0.11970590f, -0.02378664f, -0.04858941f, 
    0.15518776f, -0.05548110f, -0.09078418f, 0.14768502f, -0.03302094f, -0.16601577f, -0.06850494f, -0.05097985f, 
    -0.08140026f, 0.02944581f, 0.15187886f, 0.12636758f, -0.19511095f, -0.00231928f, -0.10291228f, -0.46867830f, 
    0.16602884f, 0.06028986f, 0.12531206f, 0.15080106f, 0.04442829f, 0.01319499f, -0.09778260f, -0.09414871f, 
    0.27278930f, 0.25983217f, 0.32864228f, 0.30792746f, -0.03600236f, -0.01209441f, 0.03286941f, 0.02000283f, 
    -0.02539083f, 0.03032350f, -0.02532723f, 0.03575647f, 0.09018066f, 0.07333126f, -0.19391985f, -0.25077823f, 
    -0.09926357f, 0.13376507f, -0.06980353f, 0.05063552f, 0.05849281f, -0.10378736f, 0.02325567f, 0.03615199f, 
    -0.50595349f, 0.32009402f, 0.12302741f, -0.42410439f, 0.27197063f, 0.13296460f, 0.00172998f, 0.06268587f, 
    -0.12101977f, -0.04403462f, 0.07761659f, -0.00798228f, 0.11499503f, 0.15713593f, 0.12077892f, 0.23739658f, 
    0.04130374f, -0.10913317f, -0.11811105f, -0.03092402f, -0.07639067f, -0.11105237f, -0.01168652f, 0.00641762f, 
    0.16779226f, -0.02941658f, -0.01484753f, -0.56208169f, 0.20762496f, 0.03743834f, 0.02233892f, 0.30924079f, 
    0.00002756f, 0.00536762f, -0.09568975f, -0.01107237f, 0.03016008f, 0.29125723f, 0.06652460f, 0.16183887f, 
    0.00682025f, -0.14247252f, -0.08133315f, 0.03605247f, -0.25945586f, -0.14723301f, -0.10277243f, 0.02246891f, 
    0.05594970f, -0.20717677f, -0.36520359f, -0.24722509f, -0.16638041f, 0.06311078f, -0.15294321f, -0.17630531f, 
    0.14394487f, 0.07012506f, -0.00235716f, 0.07378752f, 0.21174838f, 0.11535008f, 0.13572064f, 0.20521240f, 
    -0.09515845f, -0.02390415f, -0.07578947f, -0.04990562f, -0.01663262f, 0.02854030f, 0.03824127f, 0.00776540f, 
    -0.11729450f, 0.47230923f, 0.18984649f, 0.14962360f, 0.02621562f, 0.11087649f, -0.03369597f, -0.00141475f, 
    0.00820004f, -0.04828863f, -0.04373310f, 0.10569267f, 0.27778739f, -0.30978569f, -0.10580843f, -0.00959609f, 
    -0.15116702f, -0.02313030f, -0.09488174f, -0.30677369f, -0.02045645f, 0.15064703f, 0.06707142f, 0.09094633f, 
    0.02779698f, -0.09711273f, 0.01814235f, -0.01938466f, 0.16445176f, 0.04880371f, 0.15494780f, 0.11001328f, 
    0.15856852f, -0.02548160f, -0.00789500f, 0.00624363f, -0.08382864f, 0.00404955f, -0.19595549f, -0.03583294f, 
    0.00566451f, -0.04397159f, 0.00536489f, 0.01707186f, 0.24956824f, -0.02234880f, 0.08546642f, -0.14481770f, 
    0.20592618f, 0.00268975f, -0.10169985f, 0.00215693f, -0.02465238f, -0.12831594f, -0.11107424f, 0.19512421f, 
    -0.00621910f, -0.04301712f, 0.03152465f, 0.11823615f, -0.26973936f, -0.20527336f, -0.22683424f, -0.21853186f, 
    0.18345694f, -0.04162608f, -0.07206818f, -0.27285981f, -0.10480027f, 0.07187667f, -0.11288515f, -0.03071509f, 
    -0.31661871f, 0.08520297f, -0.08261152f, -0.17669156f, -0.09156377f, -0.02335273f, 0.05041792f, -0.07830748f, 
    0.11080617f, 0.18469958f, 0.08324455f, -0.15601394f, 0.00594214f, -0.06403048f, 0.17564356f, -0.05623731f, 
    -0.02062799f, 0.01515885f, 0.08319495f, -0.11986820f, -0.03677206f, 0.02466518f, 0.07204524f, 0.07965338f, 
    -0.08359839f, -0.10902686f, -0.07887128f, 0.02244327f, 0.02072655f, 0.04475394f, 0.03384291f, 0.04813604f, 
    -0.10566279f, -0.10100889f, -0.05405061f, -0.02176855f, -0.24953327f, 0.56637257f, -0.35907027f, -0.06261262f, 
    0.17718685f, 0.00271740f, 0.20203891f, -0.07931752f, -0.07684589f, 0.09770320f, 0.05237060f, 0.15059778f, 
    0.76908255f, -0.01950842f, -0.00589120f, -0.07815876f, 0.18975756f, 0.02296366f, 0.07277295f, 0.11898202f, 
    0.03504929f, 0.11885479f, 0.02692874f, -0.04129098f, 0.08688334f, -0.22938773f, 0.23665412f, 0.21790619f, 
    -0.01090177f, 0.10965628f, 0.10502431f, -0.04872963f, 0.08716194f, -0.05151082f, 0.02333108f, -0.05189011f, 
    0.06508486f, -0.08512832f, -0.04059315f, 0.28200105f, -0.06162348f, -0.08976611f, 0.20814629f, 0.03854199f, 
    -0.02691357f, 0.12322734f, 0.14276233f, -0.06922273f, -0.26779360f, -0.14634292f, -0.06219237f, 0.07014374f, 
    0.05243159f, -0.00554862f, -0.02395525f, -0.12337869f, 0.19452889f, -0.00317240f, 0.12233946f, 0.01087778f, 
    -0.41587958f, -0.09415364f, 0.27115059f, 0.31501180f, 0.14402224f, 0.07431972f, 0.03828242f, -0.05007900f, 
    0.14053085f, 0.02380851f, 0.03593545f, -0.06088295f, -0.22481756f, -0.06133603f, -0.08969512f, -0.08054934f, 
    -0.00627893f, 0.07926597f, 0.00172027f, -0.00902139f, -0.07447039f, -0.07041039f, 0.02262185f, 0.08914728f, 
    0.12759964f, -0.12579212f, 0.03664795f, -0.08815970f, -0.05776811f, 0.03382446f, 0.05729766f, -0.04655039f, 
    0.22322476f, 0.08945744f, 0.06306534f, 0.15604877f, -0.14222242f, -0.16757426f, -0.08235896f, -0.10632221f, 
    0.15521933f, -0.02756751f, 0.12417382f, 0.14692527f, 0.04756828f, -0.02721962f, 0.01858776f, 0.18294215f, 
    -0.09934489f, -0.21202539f, 0.17973748f, -0.33729950f, -0.12985571f, 0.06514597f, -0.21534364f, 0.07500726f, 
    0.18371581f, -0.21379295f, 0.02327046f, -0.36619309f, 0.09035280f, -0.11197399f, -0.06163469f, 0.17200868f, 
    0.03442279f, -0.04715420f, 0.07616504f, -0.05800511f, 0.15836702f, 0.13872635f, 0.03591840f, 0.25715700f, 
    -0.13217826f, -0.07722386f, -0.07995878f, -0.54327476f, 0.01001118f, 0.03928994f, -0.32949054f, -0.31467167f, 
    -0.04119245f, -0.08351798f, 0.11934404f, -0.28426522f, 0.24387701f, 0.05901486f, 0.24815166f, 0.26816884f, 
    0.27182809f, 0.08580459f, -0.06120926f, 0.16095048f, -0.00487628f, -0.10611087f, -0.01797399f, -0.06403227f, 
    0.37111133f, 0.15782028f, -0.18760078f, 0.10433288f, 0.37281987f, -0.20299134f, 0.09639723f, 0.03044666f, 
    0.05412223f, 0.07533815f, 0.11407916f, 0.03491571f, 0.20117237f, 0.19973302f, 0.10526848f, -0.03081977f, 
    -0.00783474f, 0.11518476f, -0.00023310f, 0.17978494f, 0.06976475f, -0.12578900f, -0.02872584f, -0.05397099f, 
    -0.07412127f, 0.02248644f, 0.13017416f, -0.02702140f, -0.02486076f, -0.25701761f, -0.09909220f, -0.01354863f, 
    -0.17089827f, -0.05701119f, 0.06854300f, -0.05421372f, 0.27735329f, 0.07951816f, -0.01427996f, -0.24791813f, 
    0.06781354f, -0.15225205f, 0.24955501f, 0.04335632f, -0.05575472f, 0.10301855f, 0.02690223f, 0.00426141f, 
    0.09256534f, 0.30666119f, 0.05269970f, -0.03885849f, 0.07780655f, 0.15811205f, -0.02048733f, -0.00981125f, 
    -0.13980451f, -0.15951675f, -0.00930041f, -0.01961156f, -0.56103253f, -0.22273396f, 0.27635640f, -0.11015996f, 
    0.10551566f, -0.08901405f, -0.34738329f, 0.12374680f, 0.08373591f, -0.17459738f, 0.08232302f, -0.04063726f, 
    0.13600940f, 0.13099483f, 0.06029180f, 0.00226267f, 0.22538042f, 0.03223511f, 0.04140131f, 0.28166080f, 
    0.21989603f, 0.21747172f, 0.01743685f, 0.09681654f, 0.38827282f, 0.02834902f, 0.04470714f, -0.36715984f, 
    0.20139886f, -0.32341227f, -0.09548219f, 0.31287092f, -0.28358018f, -0.16796225f, -0.13157207f, 0.04508747f, 
    0.06350267f, 0.11909526f, -0.03388920f, 0.23815355f, 0.08419950f, 0.11725660f, 0.03536834f, 0.04299887f, 
    0.01539749f, -0.14963292f, -0.08719070f, -0.02865959f, 0.28260723f, -0.43488571f, -0.22036935f, 0.08403048f, 
    0.01358958f, -0.21283594f, -0.06880032f, 0.00132069f, 0.06133999f, 0.03979075f, 0.17326534f, 0.03598974f, 
    0.25372002f, -0.13210922f, -0.17458290f, -0.08516508f, 0.10704481f, -0.13933715f, -0.19651468f, -0.07678470f, 
    0.04640220f, -0.03475586f, -0.13521335f, -0.05678215f, 0.14746802f, 0.01335295f, 0.41631961f, 0.23693246f, 
    0.13073710f, 0.21199220f, 0.16340309f, -0.12981774f, -0.02294112f, 0.15832241f, 0.06318574f, 0.36167070f, 
    -0.11316843f, 0.08891170f, -0.01123061f, 0.19886629f, 0.12692180f, 0.21467765f, 0.30024135f, 0.13694808f, 
    0.05248876f, 0.09177085f, -0.09955304f, -0.13712166f, -0.19791842f, -0.53200227f, -0.04518893f, 0.11958924f, 
    0.21212529f, -0.11460511f, -0.05739168f, 0.19718440f, -0.02645320f, -0.15111943f, 0.01856543f, -0.07702307f, 
    -0.25694448f, 0.01405257f, 0.13736312f, 0.22524430f, 0.13963838f, 0.22383051f, 0.16612536f, 0.56019700f, 
    -0.00937403f, 0.03188992f, -0.12555179f, 0.30619484f, -0.28292418f, 0.02062953f, 0.36177090f, -0.20929942f, 
    0.07728244f, -0.03438367f, 0.14367239f, -0.16118211f, 0.18194994f, -0.06899013f, -0.06980931f, -0.16315119f, 
    -0.31736073f, 0.02053268f, 0.24581620f, -0.01039284f, -0.03093532f, -0.10592467f, -0.01812479f, 0.09871435f, 
    0.03476692f, 0.16859342f, 0.12026250f, 0.11210858f, -0.36062261f, 0.05831936f, 0.15735522f, 0.00277350f, 
    -0.14678204f, -0.03770063f, 0.06126561f, -0.10179295f, 0.12401875f, 0.00239495f, 0.11343164f, 0.03826279f, 
    0.11922015f, -0.20089075f, -0.08402427f, 0.08890057f, -0.06311017f, 0.16285449f, -0.10083576f, -0.02358157f, 
    0.08162160f, -0.10262136f, -0.05128556f, -0.13098916f, -0.29135883f, -0.32850105f, 0.39943895f, 0.19728293f, 
    -0.00966556f, 0.04706857f, -0.05558608f, 0.14987315f, 0.12943485f, 0.01579110f, 0.02159335f, 0.00975037f, 
    -0.27617541f, -0.28895059f, 0.25337809f, -0.03213436f, 0.00513106f, 0.15727775f, 0.07695190f, 0.09479481f, 
    0.01234790f, 0.03398735f, -0.05595237f, 0.17311537f, 0.40352100f, -0.02161354f, -0.28535375f, -0.11682504f, 
    0.00687488f, 0.16434820f, 0.10284134f, 0.00417513f, 0.06432407f, -0.08704038f, -0.05140777f, -0.09008098f, 
    -0.11354427f, 0.07935698f, 0.04593454f, -0.12632696f, 0.19566759f, 0.00752892f, 0.09137969f, -0.11125667f, 
    -0.02541271f, -0.01139139f, 0.08673237f, -0.01415501f, -0.15331322f, -0.24360785f, -0.24703115f, 0.48924103f, 
    -0.10008442f, 0.04988606f, -0.02054329f, -0.08965866f, 0.27608508f, 0.03027575f, 0.11260533f, -0.16670291f, 
    -0.22936749f, 0.07611873f, 0.36557281f, -0.03587177f, -0.12951523f, -0.03710229f, 0.00004128f, 0.11308645f, 
    -0.02581555f, 0.21164970f, 0.07849772f, -0.02004410f, 0.06504819f, -0.20426285f, -0.16454175f, -0.04864216f, 
    -0.08660896f, 0.01842244f, -0.13338628f, -0.04954484f, 0.34603551f, -0.13739215f, -0.09449086f, 0.00545600f, 
    -0.76564342f, 0.02552999f, 0.23172742f, 0.63226795f, -0.02323609f, 0.07449315f, -0.03835484f, 0.13191718f, 
    0.16546696f, 0.19035897f, 0.14158572f, 0.05787246f, -0.12632178f, 0.08855569f, 0.16065925f, -0.14712758f, 
    -0.16068898f, 0.01694047f, -0.10740453f, 0.23108105f, 0.14155723f, 0.01885138f, 0.13439135f, -0.09938771f, 
    -0.07590055f, 0.05377912f, -0.11786794f, 0.03865162f, -0.00977922f, 0.02388202f, 0.05841524f, -0.09097784f, 
    0.09601493f, 0.05024568f, 0.03036832f, 0.19765745f, -0.29387504f, 0.22839910f, 0.04988376f, -0.05060517f, 
    0.02749708f, 0.09710333f, 0.05625423f, 0.00746337f, 0.06778467f, -0.21352991f, -0.18194273f, -0.06676862f, 
    -0.09285995f, -0.07377993f, -0.07769020f, 0.26622188f, -0.01040462f, 0.10358135f, -0.00832305f, -0.15528074f, 
    0.12639721f, -0.01669451f, 0.05867641f, 0.21569601f, 0.15642153f, 0.14358427f, -0.09503634f, -0.00910532f, 
    0.06408992f, 0.21459351f, 0.14231376f, 0.21287635f, -0.00497669f, 0.03427918f, 0.07669570f, -0.05630974f, 
    0.00233695f, 0.02968023f, -0.02447820f, -0.00529439f, 0.17611296f, -0.03514881f, -0.01972297f, 0.14540984f, 
    -0.13815255f, 0.04604280f, 0.05921982f, -0.05735881f, 0.20171580f, 0.36565936f, -0.10821277f, -0.26792803f, 
    0.23815487f, 0.17144570f, 0.19317110f, 0.20700574f, -0.01445305f, -0.02039208f, -0.01938186f, 0.07289287f, 
    -0.30666789f, -0.40254229f, -0.25666139f, -0.13271025f, -0.03807458f, 0.00987388f, -0.05310689f, -0.03708452f, 
    0.00045302f, -0.13989438f, 0.08151588f, 0.18602812f, 0.23582320f, 0.29241890f, -0.09430773f, -0.25967789f, 
    0.11359829f, -0.11930932f, -0.01452565f, 0.00705210f, 0.01908308f, 0.06721140f, 0.05539521f, 0.05371384f, 
    0.19461738f, 0.47672871f, 0.05266006f, -0.24713869f, 0.18025525f, 0.24471296f, 0.03336997f, -0.09002914f, 
    0.05184223f, 0.02588772f, 0.03669276f, 0.12920094f, -0.23868601f, 0.08260997f, -0.43414015f, -0.10294110f, 
    0.09208540f, 0.08182041f, 0.00436669f, 0.16569425f, -0.03569043f, 0.06315266f, 0.06076478f, 0.05617351f, 
    0.19471760f, 0.03818524f, 0.05065262f, -0.01896084f, 0.14023454f, -0.02608789f, 0.04171868f, -0.00105818f, 
    -0.00675615f, 0.01727045f, 0.06633230f, -0.05529620f, -0.24461409f, -0.23422197f, -0.03241034f, -0.05801697f, 
    -0.15738334f, -0.02746311f, -0.08693189f, -0.03129513f, 0.11305255f, 0.09002279f, 0.23485412f, 0.09121450f, 
    -0.09407544f, 0.07942903f, 0.29027808f, -0.12049794f, 0.06586754f, 0.19568320f, 0.13631830f, -0.14984994f, 
    0.09770941f, -0.14423695f, 0.11720697f, 0.04320953f, -0.27853644f, -0.18712772f, -0.10725562f, -0.03787359f, 
    -0.08176585f, -0.08629601f, 0.05645531f, -0.03276357f, -0.17085983f, 0.05144434f, 0.08722711f, 0.15885620f, 
    -0.28364184f, 0.12166490f, 0.10256799f, 0.07011944f, -0.13606507f, 0.05500749f, 0.06713881f, -0.00008814f, 
    0.13193914f, 0.17750642f, 0.08082020f, 0.08429954f, 0.27668297f, 0.28609684f, 0.00447206f, 0.15974355f, 
    0.18152541f, 0.11502003f, 0.14434867f, -0.11959539f, -0.00773178f, -0.09194479f, -0.19980413f, -0.08436020f, 
    0.03262925f, 0.07516345f, 0.06650396f, -0.05645282f, -0.11107362f, -0.10271497f, -0.08496241f, 0.02955190f, 
    -0.00228873f, -0.06129031f, 0.00963668f, -0.01176019f, -0.09356464f, -0.04618948f, -0.06914109f, -0.14259796f, 
    -0.01760643f, -0.01264849f, 0.01296059f, -0.04982917f, -0.09871045f, 0.19073170f, 0.14285578f, 0.15869878f, 
    -0.06353479f, -0.01652624f, -0.05557209f, -0.28762373f, 0.22545232f, -0.32977787f, -0.09661781f, -0.06021344f, 
    -0.05127385f, -0.08052724f, -0.08382161f, -0.13064241f, 0.35869712f, 0.23965096f, 0.37110454f, 0.37727743f, 
    -0.15279634f, 0.04978823f, 0.00957451f, 0.10530697f, -0.09809850f, -0.02297355f, 0.06118434f, 0.02526981f, 
    0.09734751f, -0.02849486f, -0.20308061f, 0.11243690f, 0.02892065f, -0.01540440f, 0.13701367f, -0.07176460f, 
    -0.10699015f, 0.00475412f, 0.00831642f, 0.03305648f, 0.21175255f, 0.29864261f, 0.00865166f, 0.09408031f, 
    0.01152832f, 0.04674429f, -0.02276672f, 0.26942176f, 0.11539238f, 0.05321296f, -0.13923353f, -0.00949186f, 
    -0.26542157f, -0.48072562f, -0.42210189f, -0.41055793f, 0.05181231f, 0.02575374f, -0.02887013f, -0.04690652f, 
    -0.06768850f, 0.10153794f, 0.06781024f, 0.03613951f, 0.40926152f, -0.03057345f, 0.18192774f, 0.13588408f, 
    -0.32003808f, -0.17709725f, 0.13951050f, -0.05593515f, 0.07056090f, 0.01936504f, 0.07545431f, -0.00246400f, 
    -0.04182248f, 0.28240943f, -0.08033691f, 0.08126834f, -0.15153119f, -0.09719167f, 0.08590961f, -0.10298532f, 
    0.08916185f, -0.03401503f, 0.01245217f, 0.00466986f, -0.21694529f, -0.19453271f, -0.03425702f, -0.18766880f, 
    0.25535423f, -0.22732711f, -0.19811055f, -0.07182351f, -0.02411621f, -0.10410380f, -0.01493996f, 0.06588624f, 
    0.13078237f, 0.19951272f, 0.07024958f, -0.00099570f, 0.08389931f, -0.01426150f, -0.19645907f, 0.01842332f, 
    0.11528592f, -0.05541382f, -0.05370196f, 0.04242386f, -0.06265748f, -0.00594065f, -0.06154386f, -0.16767712f, 
    0.02275229f, -0.02450311f, -0.00264566f, 0.15365833f, -0.12286669f, -0.04946534f, -0.10432119f, 0.12742509f, 
    0.29825565f, 0.01076283f, -0.06942984f, 0.13408014f, 0.02934141f, 0.06627163f, 0.02669692f, 0.11948540f, 
    -0.13326389f, -0.11067971f, -0.08842327f, 0.04529054f, -0.13477515f, -0.08006243f, -0.14235044f, -0.05094976f, 
    0.06506999f, 0.00089837f, 0.01821381f, 0.05904106f, -0.15449581f, 0.17629857f, 0.03042513f, -0.00036532f, 
    -0.25576296f, -0.11350220f, -0.25194204f, -0.26377329f, 0.05934279f, -0.13198549f, -0.06834169f, 0.11653152f, 
    -0.19525756f, -0.03446374f, -0.04375610f, -0.20292863f, 0.37442949f, 0.14716655f, 0.11698667f, 0.23753136f, 
    0.19342744f, 0.14906788f, -0.06424448f, -0.30686986f, 0.06567364f, 0.03538752f, 0.12572367f, 0.21935950f, 
    0.09903744f, -0.18496788f, 0.07019224f, -0.04574071f, -0.04839060f, -0.00144935f, -0.06121470f, 0.20144840f, 
    -0.00447143f, -0.00834713f, -0.00651030f, -0.03185449f, 0.23639044f, 0.01256367f, -0.08260228f, 0.00553922f, 
    -0.02730781f, 0.00755727f, -0.03917366f, -0.06447312f, 0.39287546f, 0.17753005f, 0.19958568f, 0.11599397f, 
    0.11802147f, -0.13873647f, -0.08903530f, -0.19485623f, -0.15846382f, 0.20027012f, -0.20126326f, -0.13886680f, 
    -0.03459954f, 0.02271439f, 0.03695792f, -0.12975720f, -0.38234401f, -0.28642392f, -0.00022751f, -0.00306778f, 
    0.21576506f, 0.11780345f, -0.17669113f, -0.04385796f, 0.00623403f, -0.01664250f, 0.05462145f, -0.04859092f, 
    0.02047366f, 0.12806435f, 0.18553728f, -0.11885125f, 0.10764040f, -0.05662756f, 0.01571406f, -0.02045464f, 
    -0.13409498f, -0.03286467f, 0.03299747f, 0.07273058f, -0.23821723f, -0.19139850f, 0.05094707f, 0.05166888f, 
    0.02863548f, -0.04103534f, 0.03366745f, 0.05484819f, -0.08068059f, -0.11764038f, -0.04577833f, -0.03983835f, 
    -0.04053913f, -0.01456233f, 0.05226166f, -0.12934737f, 0.03248296f, -0.00046531f, 0.04223313f, -0.00718782f, 
    -0.06501633f, 0.04201208f, -0.02214453f, -0.03128922f, -0.26798680f, 0.31386784f, 0.08408848f, 0.03140382f, 
    0.24603170f, 0.02332596f, 0.18114832f, 0.05698695f, -0.00352269f, 0.09195856f, -0.03509048f, 0.06418210f, 
    0.24194799f, -0.37066418f, -0.07416344f, 0.10164377f, 0.15282443f, 0.14964952f, 0.09080704f, 0.10025456f, 
    0.03533981f, 0.09392124f, -0.04171872f, -0.07120162f, -0.20190646f, -0.18183398f, -0.04624550f, -0.12291861f, 
    0.15905042f, 0.34808686f, 0.20651713f, 0.19048923f, -0.02685984f, 0.03487369f, -0.00572180f, -0.02368735f, 
    -0.18707624f, -0.13758902f, -0.06265733f, 0.07707965f, 0.19674517f, -0.05930565f, 0.20901114f, 0.00327511f, 
    0.06552373f, 0.00582840f, 0.03829449f, 0.04909622f, 0.07259981f, -0.14530456f, 0.09782697f, -0.17688605f, 
    0.12966219f, 0.04544899f, -0.02382676f, 0.02379764f, -0.05303081f, 0.07542820f, -0.01428374f, -0.13795216f, 
    0.03204169f, -0.13255554f, 0.18507475f, 0.13142796f, 0.15014508f, -0.06214028f, 0.00724712f, -0.02873481f, 
    -0.03722096f, 0.10279264f, 0.13648538f, 0.09068751f, -0.08891664f, -0.10827171f, -0.01995981f, -0.02551762f, 
    -0.00847610f, -0.05402035f, -0.07163928f, -0.05850639f, -0.00673869f, -0.13919786f, -0.04764583f, -0.07181736f, 
    0.30621412f, -0.00826549f, -0.01495014f, 0.00977526f, 0.04427619f, -0.07657221f, -0.01107095f, -0.02543107f, 
    -0.03981003f, -0.09428255f, 0.04884412f, 0.04433428f, -0.11141947f, -0.04337544f, 0.18167031f, 0.06182761f, 
    0.00818466f, -0.14374992f, 0.03406103f, -0.01165497f, 0.00326031f, 0.08846260f, -0.01665348f, 0.08429568f, 
    0.03130584f, 0.02639058f, 0.05196759f, -0.08562502f, 0.00371072f, -0.01636888f, 0.03502760f, 0.00988518f, 
    0.00657502f, -0.08343510f, 0.04648234f, -0.01721539f, -0.01449508f, -0.01318480f, 0.04105240f, -0.04657866f, 
    -0.08618265f, 0.02177278f, -0.06177489f, 0.01825705f, 0.06050463f, -0.02172928f, -0.02505101f, -0.06759355f, 
    -0.03416159f, -0.05771996f, 0.02738851f, 0.04652620f, -0.08237963f, -0.00335507f, 0.00138171f, -0.06500219f, 
    -0.00141889f, -0.07717642f, 0.05082835f, -0.04196441f, -0.02068397f, 0.05166186f, 0.00403506f, 0.03327169f, 
    -0.05369949f, -0.03432895f, 0.06664041f, 0.05055136f, 0.02433716f, 0.03470829f, 0.04366475f, -0.05566945f, 
    -0.07495391f, -0.08746564f, 0.04711014f, -0.05991136f, 0.03389536f, 0.05056858f, 0.04106183f, 0.05136126f, 
    0.01747046f, -0.03976636f, -0.01974058f, -0.03248410f, -0.03015797f, -0.06626239f, 0.02460585f, 0.01881670f, 
    0.04513120f, 0.05384700f, -0.06327523f, 0.00942459f, -0.01442534f, 0.01087506f, -0.02923631f, -0.02537069f, 
    -0.04746553f, 0.01020094f, -0.08662890f, -0.06029714f, -0.06575341f, -0.00120012f, -0.02469561f, 0.01845624f, 
    -0.03402068f, -0.00156297f, -0.02872880f, 0.01357926f, 0.05149550f, 0.01054262f, 0.02673648f, -0.03077072f, 
    0.00834602f, -0.00450512f, -0.05271452f, 0.03500469f, 0.03595094f, 0.01704821f, -0.05154368f, -0.02593736f, 
    -0.04355539f, -0.00940595f, -0.04671768f, 0.03346384f, 0.02447782f, -0.01164820f, -0.00723669f, -0.06735003f, 
    0.03578371f, 0.05136530f, -0.07322636f, 0.02081321f, 0.03369802f, -0.07706176f, 0.05017564f, 0.01790556f, 
    -0.07388742f, -0.05831993f, -0.06046029f, -0.05661579f, -0.07724702f, 0.00608136f, 0.01348555f, -0.03229115f, 
    0.00762756f, -0.07693621f, -0.00300367f, -0.06664526f, -0.00066186f, -0.07011176f, -0.01119504f, -0.05577978f, 
    0.05406947f, 0.03495084f, -0.01418738f, -0.03010034f, 0.01375343f, -0.04686535f, 0.04721923f, -0.01165755f, 
    -0.05635135f, -0.08927104f, 0.03995457f, 0.02447214f, 0.05481146f, 0.03350642f, 0.04702447f, -0.06423198f, 
    -0.03568644f, -0.04453363f, 0.04006724f, -0.01878162f, -0.06983408f, 0.04121017f, 0.03888079f, -0.00871307f, 
    0.04673485f, -0.05815472f, 0.00154209f, -0.06823037f, -0.02399099f, 0.02620720f, -0.02189286f, 0.04166185f, 
    0.03149178f, -0.07943407f, -0.02865391f, -0.07835821f, 0.05001284f, -0.00295838f, 0.00346611f, -0.03019220f, 
    0.04891802f, -0.01947324f, 0.04590560f, 0.04779667f, -0.03251660f, -0.06147845f, 0.02065780f, 0.01676241f, 
    0.05588209f, -0.07284399f, -0.04911738f, 0.02195413f, 0.05905215f, 0.02730676f, 0.04227166f, -0.04286410f, 
    -0.07385528f, 0.03442398f, 0.03064006f, -0.07822454f, 0.03963209f, 0.03910355f, -0.01326628f, 0.03284295f, 
    -0.11776437f, -0.06455249f, 0.03953413f, 0.05895464f, 0.08411642f, 0.02079516f, 0.13102323f, 0.02104395f, 
    -0.14815991f, -0.04971926f, 0.08625320f, -0.18443692f, -0.00793372f, -0.21327204f, 0.05624739f, 0.08367430f, 
    0.10898863f, -0.08360203f, -0.03268827f, 0.17079344f, -0.07224484f, -0.26714563f, -0.09822118f, -0.16414534f, 
    -0.20133364f, 0.27056789f, 0.13810225f, -0.07649275f, -0.07382262f, -0.04952747f, 0.05054725f, 0.48731142f, 
    0.01679332f, 0.01342539f, 0.05855528f, 0.30475238f, -0.10463435f, -0.01714089f, 0.28988522f, -0.28010193f, 
    0.19485614f, 0.06922638f, 0.15304546f, -0.17688838f, 0.05770375f, 0.03359668f, -0.06220183f, -0.09741674f, 
    -0.01422647f, -0.01516551f, -0.23784535f, -0.08433884f, 0.02709076f, -0.03663559f, 0.09821323f, 0.22270356f, 
    -0.07884392f, 0.12197285f, 0.15201207f, -0.11542477f, -0.04368449f, 0.16927364f, 0.29782140f, -0.05561424f, 
    -0.01586456f, -0.02138707f, 0.08784661f, -0.09564875f, 0.12493441f, 0.04972349f, 0.07634760f, -0.07777254f, 
    0.35083428f, 0.28125188f, 0.13829140f, 0.22871237f, -0.02659383f, -0.00362619f, -0.02628653f, -0.01138014f, 
    0.09213095f, 0.02013486f, 0.03280338f, -0.00440753f, -0.02514480f, -0.11334915f, -0.07296707f, 0.01324477f, 
    0.05442739f, -0.01119911f, 0.11389761f, 0.06652384f, 0.09433754f, -0.07112267f, -0.00394288f, 0.08645339f, 
    -0.03388424f, -0.10144673f, 0.31688991f, -0.14770709f, 0.03213325f, 0.24544933f, 0.07512566f, -0.01484720f, 
    0.09152383f, 0.01164836f, 0.00303677f, 0.07412542f, 0.38505155f, -0.06378792f, 0.08055642f, 0.01372066f, 
    0.05234485f, 0.04395693f, -0.17954865f, -0.10831454f, -0.06430519f, -0.05110566f, -0.02173130f, 0.09739080f, 
    -0.05267138f, 0.29779983f, 0.01629752f, -0.08917630f, 0.11327329f, -0.08278815f, 0.07337295f, 0.05939111f, 
    -0.03387860f, -0.07298645f, 0.16350648f, -0.09306851f, -0.13995561f, -0.00855439f, -0.04206653f, 0.22061659f, 
    -0.12666383f, -0.03316997f, 0.00518780f, -0.01106554f, 0.12769577f, -0.06850366f, 0.05738179f, -0.21190894f, 
    -0.36027959f, -0.22454646f, 0.03497976f, -0.19231182f, -0.12600996f, 0.13925168f, -0.02621361f, 0.16889240f, 
    0.20351890f, 0.17537422f, 0.01344021f, -0.05115969f, 0.14602579f, -0.06325116f, -0.02198511f, 0.16825609f, 
    -0.07813210f, 0.04035304f, -0.08452834f, -0.06650970f, 0.16167177f, -0.21902163f, -0.09536394f, -0.01097764f, 
    -0.70599931f, -0.03291774f, 0.31133965f, 0.32949725f, -0.05475011f, -0.03312711f, -0.05592314f, 0.11124524f, 
    0.06396548f, 0.20444278f, 0.22271536f, 0.02919014f, 0.06666906f, -0.20147713f, -0.02618914f, -0.27655822f, 
    -0.09030940f, 0.07439143f, 0.02604095f, 0.08290588f, 0.12354007f, -0.08485655f, 0.03323447f, -0.09990919f, 
    0.03324166f, -0.03968985f, -0.07911418f, 0.07814732f, 0.14932854f, 0.10689588f, 0.18514536f, 0.11306196f, 
    0.04190136f, 0.04925123f, 0.00316860f, 0.06372633f, 0.04823350f, -0.24926037f, -0.08993538f, -0.06090054f, 
    -0.00853996f, -0.07614011f, -0.12951642f, -0.15325019f, 0.15854153f, 0.26551211f, 0.14855243f, 0.09731393f, 
    0.25248337f, -0.01025459f, -0.02105291f, 0.07868634f, 0.23165922f, -0.00600225f, 0.08359008f, 0.22602670f, 
    -0.01036419f, 0.11434714f, -0.15262511f, -0.02925727f, -0.11475789f, -0.10096182f, 0.01601763f, -0.08224479f, 
    -0.31747207f, 0.00677772f, 0.05046449f, 0.10855112f, 0.01759747f, -0.04604416f, 0.01218659f, -0.04306081f, 
    -0.05262088f, -0.36273038f, 0.06144050f, 0.11999401f, -0.15548578f, -0.06561398f, -0.02814328f, -0.03460883f, 
    0.18776613f, 0.05387438f, 0.11465740f, -0.06743280f, -0.21476378f, -0.17827711f, -0.02636786f, -0.04733107f, 
    -0.02955446f, -0.09017199f, -0.03793345f, -0.15043955f, 0.08149590f, 0.04282223f, 0.09190937f, 0.22490004f, 
    0.02251985f, -0.13591048f, 0.10089982f, -0.16251852f, 0.02722895f, 0.13074271f, 0.03636495f, 0.01783475f, 
    -0.08339947f, -0.07113286f, -0.09102692f, -0.08026774f, -0.21535744f, -0.30024207f, 0.13029967f, 0.36850837f, 
    -0.08639871f, 0.11498114f, -0.15324777f, 0.25293344f, 0.15083432f, 0.03366029f, 0.05200631f, 0.07757641f, 
    0.41726893f, -0.43612868f, 0.06717571f, 0.05547234f, 0.01003536f, -0.11887660f, 0.07534385f, 0.03443469f, 
    0.11409511f, 0.12598272f, 0.05803388f, -0.07747452f, -0.14692095f, 0.22988679f, 0.07514323f, 0.06899384f, 
    0.06181429f, 0.10720398f, 0.30236858f, 0.30625841f, -0.03727722f, 0.00163162f, -0.09820496f, -0.11486441f, 
    -0.12787393f, -0.01666583f, 0.06303463f, 0.00021005f, 0.01418564f, 0.14912336f, 0.03387258f, 0.01149013f, 
    0.03347989f, 0.01875534f, 0.05621815f, -0.06564517f, -0.03895957f, -0.10904101f, -0.09679670f, -0.08274502f, 
    0.00536025f, 0.08608878f, -0.04781699f, -0.11555638f, 0.03650109f, -0.00052481f, 0.11504833f, 0.19729948f, 
    0.19266699f, -0.12120531f, 0.20149614f, -0.03900275f, -0.01641901f, 0.02118996f, 0.03041163f, 0.12851675f, 
    0.02979839f, -0.01989002f, -0.10806055f, 0.03461102f, -0.11545887f, 0.01427865f, -0.05957106f, -0.17404971f, 
    -0.09992710f, -0.03551074f, 0.10676564f, 0.00442332f, 0.02296815f, 0.03613196f, 0.10593475f, 0.08834922f, 
    -0.09543863f, -0.11846628f, 0.07113013f, 0.22102624f, 0.09471579f, 0.08254642f, -0.02263783f, -0.12220898f, 
    0.13926966f, 0.07212308f, 0.15813977f, 0.27614158f, 0.18502897f, -0.24290602f, 0.26156709f, 0.10681368f, 
    0.01519250f, -0.20053554f, 0.07363983f, 0.19583505f, -0.02664165f, 0.07177498f, 0.05152889f, -0.04695793f, 
    0.00090738f, 0.00577124f, 0.10714037f, 0.07311901f, -0.21042033f, -0.01934196f, -0.16980709f, -0.13778643f, 
    0.07592204f, -0.01886766f, -0.05936813f, -0.00382203f, 0.05962699f, 0.18186766f, -0.01623702f, 0.06432675f, 
    -0.04704195f, -0.01455355f, 0.09496377f, 0.00863731f, 0.17184211f, 0.49117708f, 0.28538758f, 0.33715725f, 
    0.05643481f, -0.03478247f, 0.16392611f, 0.30438265f, -0.02108693f, -0.02260737f, 0.02854218f, -0.10545509f, 
    -0.18177329f, -0.08336934f, 0.01218297f, -0.13406758f, 0.11994363f, 0.08579309f, -0.33026293f, 0.03372558f, 
    -0.16994812f, -0.06257913f, -0.15331672f, -0.21235597f, -0.00167565f, 0.05719796f, -0.07991277f, 0.02968310f, 
    -0.02957228f, 0.18428898f, 0.27098340f, 0.07313681f, -0.01842086f, 0.02513145f, -0.06486854f, -0.14919919f, 
    0.17705412f, 0.10754405f, -0.04812672f, 0.04310527f, 0.13569295f, -0.19071816f, -0.18516383f, 0.00652566f, 
    0.12760593f, 0.08281320f, 0.06018097f, -0.22250311f, -0.15272577f, -0.00528191f, 0.06362044f, 0.03301931f, 
    -0.27036169f, -0.17794067f, -0.15154821f, 0.02903558f, 0.05218172f, -0.01393556f, -0.06751005f, 0.03015802f, 
    -0.03433045f, 0.03083619f, -0.08127729f, 0.00426337f, 0.00233560f, -0.05722667f, 0.04297584f, 0.00271671f, 
    0.21689612f, 0.03171789f, -0.17886207f, -0.04698610f, -0.04634660f, 0.01899807f, 0.12422889f, -0.15054825f, 
    -0.10842560f, 0.14912809f, 0.05578317f, -0.11619508f, -0.10031763f, -0.07012203f, 0.01917484f, 0.01156981f, 
    -0.10430161f, 0.06567243f, -0.13616025f, -0.16100280f, -0.04800333f, 0.02526864f, -0.08564296f, 0.11016973f, 
    0.07796761f, 0.20491831f, 0.13559781f, -0.06364977f, -0.03111452f, 0.00441239f, -0.17704383f, -0.09363796f, 
    -0.02169394f, -0.07013740f, -0.05149574f, 0.25314602f, -0.00270847f, 0.14657053f, 0.16543913f, 0.06986761f, 
    0.00372858f, 0.09698422f, 0.05983070f, 0.13595490f, 0.01278947f, 0.10041352f, -0.07922563f, 0.04264325f, 
    0.11499799f, 0.07725722f, -0.00029315f, -0.12156572f, 0.06275754f, -0.02975209f, 0.04644622f, 0.07379223f, 
    0.18052372f, 0.49299839f, 0.24227171f, 0.31571871f, -0.07027571f, -0.13007487f, -0.13011339f, -0.06018880f, 
    0.07020003f, 0.00664067f, -0.12057306f, 0.00093387f, -0.02231451f, -0.01124626f, -0.04011188f, -0.00709427f, 
    0.03986706f, -0.03266866f, -0.01982749f, 0.03563377f, 0.08726271f, 0.02803832f, 0.07042761f, -0.09029421f, 
    0.27441522f, -0.01029714f, 0.04354063f, 0.01098635f, -0.14960383f, -0.02809701f, 0.03406337f, 0.00862250f, 
    -0.00754098f, -0.13122284f, 0.00637910f, -0.07112443f, -0.24361023f, 0.46702373f, -0.10014582f, 0.21885474f, 
    -0.09028263f, 0.10614759f, -0.02709239f, 0.05308253f, 0.15585461f, 0.04182087f, 0.07333747f, 0.19502069f, 
    -0.05115860f, 0.06317430f, -0.01913146f, 0.00764021f, 0.04499619f, -0.01833436f, 0.01730983f, 0.02064589f, 
    0.03885870f, -0.04148828f, -0.03201916f, -0.01108062f, 0.07046721f, 0.03731026f, 0.04754173f, 0.00898348f, 
    0.00847117f, -0.04123286f, -0.04195873f, 0.04622197f, 0.05061697f, -0.00276165f, -0.05695603f, -0.07203093f, 
    0.02445412f, 0.04342719f, -0.03064013f, -0.04169372f, -0.01058475f, 0.03092099f, -0.00962466f, 0.05229418f, 
    -0.03202996f, 0.04141223f, -0.02186689f, 0.04134045f, -0.02804493f, -0.03313939f, 0.06459568f, 0.01215420f, 
    -0.01176010f, 0.03373664f, -0.07698274f, -0.07236645f, -0.04822416f, -0.01038563f, -0.07781956f, 0.02542825f, 
    -0.03043974f, -0.06280343f, 0.00825114f, 0.06337842f, 0.01528095f, -0.06806424f, -0.01648605f, 0.03490996f, 
    -0.06097035f, 0.04727115f, -0.07379943f, -0.00497121f, -0.06215390f, 0.02917776f, 0.04425213f, -0.06884091f, 
    0.01669203f, 0.02807301f, 0.00121014f, -0.05443849f, 0.01590729f, 0.05494036f, 0.02034295f, 0.04630229f, 
    -0.06323618f, 0.05618186f, -0.02068688f, -0.03390428f, 0.02709220f, 0.02590273f, -0.07951847f, 0.05858409f, 
    -0.07752407f, 0.02061747f, 0.04011790f, 0.04907905f, -0.06930289f, -0.07035045f, -0.01771391f, -0.01813759f, 
    -0.01978495f, -0.04058927f, -0.04627112f, -0.01741131f, -0.07742770f, 0.05339519f, -0.04678592f, -0.03190001f, 
    -0.06366486f, -0.04872826f, -0.05795161f, 0.02810935f, -0.02895696f, -0.01137484f, -0.03770215f, -0.03330901f, 
    -0.06129462f, -0.05492816f, -0.00596078f, 0.02253163f, -0.04383632f, -0.02944004f, -0.01474166f, -0.01542648f, 
    -0.05141950f, 0.04241489f, -0.06071306f, -0.02809950f, -0.06698196f, -0.04667341f, 0.02644417f, -0.03888177f, 
    -0.03845698f, -0.06486812f, 0.04302839f, 0.01442815f, 0.03201690f, -0.06189571f, -0.07490178f, 0.00451865f, 
    -0.07015675f, 0.02547845f, -0.00782838f, -0.06457686f, -0.04920137f, -0.07855163f, -0.05379986f, 0.05033124f, 
    -0.03370272f, 0.02704269f, -0.04717477f, 0.01414802f, -0.03883913f, 0.06404498f, 0.04344499f, 0.05028878f, 
    -0.04064421f, -0.04455430f, -0.00255596f, -0.02746246f, -0.03750991f, -0.03514514f, -0.01292195f, -0.02518930f, 
    0.02084338f, -0.07163052f, -0.08133482f, -0.00224000f, -0.05018116f, -0.03226998f, -0.04956987f, -0.00224655f, 
    0.02672603f, 0.04862503f, 0.02999421f, -0.02956262f, 0.00991182f, 0.01850942f, -0.07423282f, -0.00605855f, 
    0.02357239f, 0.04411964f, -0.07506234f, -0.02448069f, -0.03108337f, 0.02528686f, -0.05810628f, -0.04900649f, 
    0.00594364f, -0.02098729f, 0.06365679f, -0.04850217f, -0.05209021f, 0.04354735f, 0.05980310f, 0.05671457f, 
    0.05080602f, -0.02522768f, 0.03755035f, 0.06084840f, 0.04600760f, -0.01106235f, -0.03590497f, -0.05473989f, 
    -0.00934859f, 0.04378412f, 0.13746271f, -0.01452945f, 0.27155191f, -0.04464994f, -0.05674295f, 0.08492426f, 
    -0.15948345f, -0.32944998f, -0.17572346f, -0.08068784f, -0.06015662f, 0.21451592f, -0.14668825f, -0.07402015f, 
    -0.15726295f, 0.08036791f, 0.03294060f, 0.05428819f, 0.16694506f, 0.19740121f, 0.28893685f, 0.02712116f, 
    0.07548252f, -0.26757160f, 0.15787067f, -0.18876947f, 0.07861216f, -0.16738001f, -0.06573361f, -0.12814479f, 
    0.15438128f, -0.09336455f, -0.07764545f, -0.30996624f, -0.27319092f, -0.24705304f, -0.22321878f, -0.29606327f, 
    -0.31720480f, -0.04094547f, 0.02011044f, -0.02491781f, -0.16613539f, -0.06138160f, -0.16113523f, -0.13640229f, 
    -0.23435849f, 0.01190892f, 0.31859839f, -0.02353177f, -0.09582104f, 0.13205381f, -0.02157927f, -0.10231239f, 
    0.07226461f, -0.05676557f, -0.06095495f, -0.10824400f, -0.13163137f, -0.10407069f, -0.28654161f, -0.00766730f, 
    0.06803606f, 0.06860630f, -0.01927137f, 0.38085255f, -0.07235609f, 0.17500588f, 0.06436747f, 0.08196092f, 
    0.15227449f, 0.09536002f, 0.15350609f, 0.16305786f, -0.04770453f, -0.02156527f, 0.08143105f, 0.04061109f, 
    0.01182085f, 0.13731171f, 0.02792193f, -0.08006863f, -0.06711216f, 0.01576616f, 0.19960663f, 0.07320759f, 
    0.35822225f, 0.13121431f, -0.10974447f, 0.39937583f, -0.20008694f, 0.13968027f, 0.34206662f, 0.01759983f, 
    -0.40122467f, -0.08435326f, -0.32978886f, -0.00544486f, 0.01500691f, -0.28086472f, 0.07572584f, 0.13256270f, 
    -0.19286458f, 0.19069256f, -0.14336713f, -0.04760054f, 0.11930946f, 0.14512120f, 0.00596837f, -0.16827762f, 
    -0.24512158f, -0.28888449f, 0.24837632f, -0.18798791f, -0.02120937f, -0.19534893f, -0.08012440f, 0.17400698f, 
    -0.09811027f, -0.10972849f, 0.27004594f, -0.01737165f, -0.14919420f, -0.00385198f, 0.30487081f, 0.13078031f, 
    0.04649207f, 0.01971491f, 0.15355860f, 0.16551515f, -0.03385321f, 0.00156303f, 0.17526868f, 0.13462409f, 
    0.03209621f, 0.17403708f, -0.10273827f, 0.02981495f, 0.07800312f, -0.17786570f, -0.06217982f, 0.04631720f, 
    0.17435421f, 0.04482559f, 0.18240419f, 0.00630768f, -0.03568644f, -0.24292108f, -0.04457015f, 0.08238224f, 
    -0.02275172f, -0.00131191f, 0.02536830f, 0.02903726f, -0.04465512f, 0.03408708f, 0.18417338f, 0.13208625f, 
    0.02749939f, 0.03269520f, 0.06339251f, -0.02617884f, 0.09767544f, 0.17304607f, 0.16308989f, -0.02141182f, 
    0.11913707f, 0.17937468f, 0.14848408f, 0.18229741f, 0.14674060f, 0.17777994f, -0.13827807f, 0.07193559f, 
    0.04013558f, -0.12650347f, 0.16267484f, -0.08154940f, 0.15060209f, 0.08056385f, 0.24799985f, 0.27369836f, 
    -0.12735197f, -0.16706511f, -0.02053688f, 0.20179391f, -0.06901051f, 0.15120798f, 0.33905324f, 0.11270028f, 
    -0.00826270f, -0.06386309f, 0.05675572f, -0.05968838f, 0.03832188f, 0.02295566f, -0.02841207f, 0.05778608f, 
    0.03973652f, 0.00322676f, 0.00931652f, -0.01144999f, -0.01742082f, -0.01226542f, 0.00301341f, -0.03905394f, 
    -0.03765162f, -0.03555969f, 0.06151799f, -0.05260880f, 0.01679776f, -0.03814987f, 0.00315775f, -0.06314754f, 
    -0.00573497f, 0.04086398f, -0.01659286f, -0.06488360f, -0.07736089f, -0.04758772f, -0.03040062f, -0.04208048f, 
    0.06528987f, -0.06982084f, -0.02904279f, 0.00421532f, 0.06312556f, 0.00601695f, -0.06203311f, -0.06501042f, 
    0.06313298f, -0.01286757f, -0.04870109f, -0.03610328f, 0.00593421f, -0.03892872f, -0.00767056f, 0.04071907f, 
    -0.06062539f, 0.02690358f, -0.03055527f, 0.05118509f, -0.04715718f, 0.06063894f, 0.03665069f, -0.02051917f, 
    0.05695987f, -0.06664316f, -0.02164786f, -0.04970777f, 0.04374545f, 0.00340352f, 0.01602641f, -0.00752850f, 
    0.03154324f, 0.01327951f, -0.00267946f, -0.05112551f, -0.05152522f, 0.06361900f, 0.03299106f, 0.03820183f, 
    0.03087275f, -0.05173339f, 0.01374451f, -0.06484573f, 0.03164790f, 0.00110420f, -0.03815230f, -0.06803552f, 
    -0.05042648f, 0.04562394f, -0.07142342f, 0.02442462f, -0.06997342f, -0.03685769f, -0.02782168f, -0.04528498f, 
    -0.01974083f, 0.00217706f, -0.07500974f, -0.07485398f, 0.03544185f, 0.06450635f, 0.03933532f, -0.05510031f, 
    -0.05344740f, 0.06184909f, -0.01748474f, -0.05000168f, 0.01161561f, -0.06798467f, 0.05206731f, -0.07005631f, 
    -0.02177451f, -0.06970700f, -0.05993312f, -0.04604419f, 0.06951012f, 0.02748786f, -0.05850989f, 0.05450063f, 
    0.04950104f, -0.06558494f, -0.02482040f, -0.02524703f, -0.04096857f, -0.04666794f, -0.03274116f, 0.00567139f, 
    0.00657904f, -0.04612777f, 0.06067836f, 0.02773627f, 0.00540312f, -0.04070748f, 0.01606572f, -0.01116222f, 
    -0.06496020f, -0.04398982f, -0.07295879f, -0.06456243f, 0.05510236f, -0.01964585f, 0.06805371f, 0.01779795f, 
    -0.00947837f, -0.06341499f, -0.06838018f, -0.02833463f, 0.01775413f, -0.02976860f, -0.00756866f, 0.01285617f, 
    0.06212058f, -0.03778894f, 0.04214259f, -0.04370819f, -0.04826761f, -0.02962109f, -0.01927579f, -0.00498405f, 
    -0.06311343f, -0.07398985f, -0.03322180f, -0.00157858f, 0.05409210f, 0.06809829f, 0.02393149f, -0.02363718f, 
    0.04867923f, -0.06361216f, -0.03544210f, -0.05889192f, -0.03034712f, -0.00313757f, 0.03710744f, 0.03115595f, 
    -0.00064791f, 0.00967038f, -0.04664796f, -0.00866524f, -0.01505861f, 0.06102238f, 0.03684475f, 0.04430182f, 
    -0.07100589f, -0.02266042f, -0.00407901f, -0.06959011f, -0.07367940f, -0.02489315f, 0.05388993f, -0.07448923f, 
    -0.04226260f, 0.01073295f, -0.05775865f, -0.00370946f, 0.01260500f, -0.00735715f, -0.04206869f, 0.04984930f, 
    -0.17977613f, 0.12030695f, -0.20564944f, -0.05323578f, -0.03285554f, -0.00436068f, 0.03144182f, 0.09604067f, 
    -0.11310436f, 0.04733026f, 0.07956078f, 0.02658177f, 0.03274487f, 0.05759057f, 0.03000043f, -0.14872265f, 
    -0.06640779f, -0.11586218f, -0.04792633f, 0.02287236f, -0.14400414f, -0.16385390f, -0.15778504f, -0.08603463f, 
    -0.15615505f, 0.02476703f, -0.02836502f, 0.03231998f, -0.04153611f, 0.20005031f, 0.21390037f, -0.22806747f, 
    0.28823128f, 0.10266595f, 0.20236832f, 0.19129397f, 0.18109664f, -0.10784032f, 0.27791944f, 0.11277431f, 
    0.09545140f, -0.00011034f, 0.02316214f, 0.21729231f, -0.08926759f, 0.05886123f, -0.03724379f, 0.00034907f, 
    0.05790014f, 0.07604603f, -0.37291402f, -0.20977119f, -0.08998338f, -0.00235432f, 0.21205762f, 0.09277474f, 
    0.00461949f, -0.04681446f, -0.12734570f, 0.02652467f, 0.06494867f, 0.09825430f, -0.14707518f, -0.05402881f, 
    -0.01843240f, -0.07971551f, -0.04320884f, 0.20190194f, 0.03119120f, 0.00386605f, -0.06795152f, 0.13559282f, 
    0.15524617f, 0.46978539f, 0.09439496f, 0.23594280f, -0.27579260f, -0.15716283f, -0.20507625f, -0.12293216f, 
    0.04095330f, 0.05345808f, 0.07820772f, -0.05884673f, 0.52200145f, -0.27394226f, 0.18015665f, 0.00602359f, 
    -0.09060945f, -0.13889031f, 0.25067678f, 0.00617307f, 0.13583644f, 0.05756517f, 0.11578283f, 0.00894521f, 
    -0.33087686f, 0.14194797f, -0.18460432f, 0.05732808f, -0.06712587f, 0.23464081f, 0.01949261f, -0.09504481f, 
    0.06698264f, -0.06997459f, 0.13963409f, 0.15842362f, 0.14593002f, 0.17030679f, 0.23640989f, -0.47397348f, 
    -0.11101084f, -0.03214918f, -0.06091076f, -0.02874469f, -0.02158157f, -0.00494341f, 0.05923029f, -0.01612181f, 
    0.04249175f, 0.00849529f, -0.19700073f, -0.26273403f, 0.06787016f, 0.02276132f, -0.17456634f, -0.02062409f, 
    -0.00432344f, -0.17836593f, 0.03020417f, 0.05214494f, 0.20666590f, 0.06964490f, -0.04264954f, -0.05391087f, 
    -0.04291246f, -0.12796368f, 0.06964033f, 0.17993300f, 0.07398021f, 0.11517952f, 0.05339739f, 0.07577488f, 
    -0.12793112f, 0.07544753f, -0.24253005f, -0.07288959f, -0.05426552f, 0.19395226f, 0.14089739f, 0.11041113f, 
    0.03092309f, 0.06238037f, 0.05849734f, 0.00317636f, 0.16121738f, 0.11455603f, 0.16354938f, -0.15540712f, 
    -0.13664849f, -0.22491446f, -0.20693865f, -0.13673003f, 0.02793634f, -0.00963710f, -0.05936787f, -0.04723152f, 
    0.31921673f, -0.02359016f, -0.18042405f, -0.00420628f, 0.03541551f, -0.10732559f, 0.07634316f, 0.18708830f, 
    0.00988001f, 0.29400194f, 0.04319574f, 0.03209439f, 0.00935449f, 0.43108770f, -0.31130311f, -0.08632450f, 
    0.01686846f, 0.11030023f, 0.07406193f, 0.18485065f, 0.08603609f, 0.03038125f, -0.00850856f, -0.07055741f, 
    -0.17474681f, 0.21400763f, -0.36943060f, -0.31517312f, 0.24425495f, 0.06447296f, 0.13915829f, 0.17716093f, 
    0.00376674f, 0.11504029f, 0.27719977f, 0.28129855f, -0.17491511f, 0.19702791f, 0.09650902f, -0.01956360f, 
    0.06574847f, -0.04992776f, -0.19808081f, -0.10729484f, -0.13720208f, -0.32190463f, -0.17989548f, -0.15790614f, 
    -0.29588985f, -0.10339320f, -0.34461892f, -0.09097975f, 0.15537779f, 0.33875465f, 0.03142522f, -0.19370429f, 
    0.18177229f, 0.13005060f, 0.16933149f, 0.09389369f, 0.05059227f, 0.03788672f, 0.33430049f, 0.42145124f, 
    0.03565723f, 0.04514955f, 0.09782107f, 0.37582892f, -0.02045367f, -0.00490340f, 0.08900660f, -0.09991442f, 
    -0.06397014f, -0.50263882f, -0.24928071f, 0.01202120f, 0.15832129f, -0.12299244f, -0.07512716f, -0.04533749f, 
    -0.15369420f, 0.02851033f, -0.04937321f, 0.19010836f, -0.05586241f, 0.19715463f, -0.13229312f, -0.13530427f, 
    0.19230747f, 0.06555831f, 0.15982434f, 0.29328716f, 0.06405053f, -0.02821513f, -0.22364330f, 0.10467553f, 
    -0.15315400f, -0.02947903f, 0.03913806f, 0.08763366f, -0.25891399f, -0.18913561f, -0.11288420f, 0.02014058f, 
    0.01525783f, 0.01928657f, -0.00931655f, -0.02884918f, 0.23212600f, 0.13529767f, 0.25987500f, -0.07660393f, 
    0.00903996f, -0.00097042f, 0.01288146f, -0.07418237f, 0.03083869f, -0.03504430f, -0.05518502f, 0.19346622f, 
    0.16117352f, 0.38004038f, -0.22604835f, 0.14641675f, 0.03670043f, 0.24682897f, 0.13962437f, 0.02416899f, 
    -0.00956290f, 0.00147565f, 0.06909996f, 0.13895455f, -0.26609075f, -0.13714963f, 0.15103817f, 0.09442533f, 
    -0.02474364f, -0.02251898f, -0.11254668f, 0.21969064f, 0.19298118f, 0.09186030f, 0.04331805f, -0.15315993f, 
    0.03691585f, -0.12498832f, 0.04164085f, -0.07399197f, 0.01242048f, -0.06477281f, -0.22783208f, -0.01546043f, 
    0.11858787f, -0.04529999f, -0.03176128f, -0.05561834f, -0.13249481f, 0.00591055f, -0.02845181f, -0.03069583f, 
    0.06343514f, -0.16104132f, -0.07230793f, 0.19970551f, -0.19278379f, -0.06872351f, -0.00210765f, 0.05019729f, 
    0.13606748f, 0.22002226f, 0.09147815f, 0.13759667f, -0.06794375f, 0.32436594f, 0.16419768f, -0.06473254f, 
    0.08215121f, -0.06021947f, 0.23716530f, 0.02871052f, -0.15970120f, -0.12906541f, -0.11512490f, -0.06983478f, 
    -0.10180300f, -0.36639127f, -0.21018916f, -0.29607841f, -0.18029198f, 0.04059701f, 0.08096713f, 0.19970533f, 
    -0.12918641f, 0.09423795f, -0.08284801f, 0.14956315f, 0.16698678f, -0.05775871f, 0.01283685f, 0.06894717f, 
    -0.11341432f, 0.06710297f, -0.13232033f, 0.29217663f, 0.09245665f, 0.37925667f, 0.08884902f, 0.33664694f, 
    0.14569996f, 0.08053216f, -0.15652442f, -0.19445233f, -0.03015631f, 0.06956448f, -0.16473447f, -0.01343526f, 
    -0.13000998f, 0.20138524f, 0.05947875f, 0.15750881f, 0.02541508f, 0.12944928f, 0.02178756f, -0.13496266f, 
    0.10977266f, -0.10136987f, -0.23603395f, -0.37313047f, -0.06881239f, 0.25527707f, 0.02577462f, 0.18951170f, 
    -0.00198177f, 0.04867218f, -0.06081639f, -0.25779873f, 0.02770938f, 0.16694452f, 0.16878194f, 0.18984830f, 
    -0.22419831f, 0.40682563f, -0.26577836f, -0.12098352f, 0.12998961f, -0.03400983f, -0.14537151f, 0.07612049f, 
    0.05335934f, 0.26497707f, -0.24930978f, -0.24014463f, 0.32447067f, 0.35564810f, -0.10266282f, 0.10172702f, 
    0.02723026f, 0.14414042f, 0.12191922f, -0.15101899f, 0.03468057f, -0.16794437f, -0.01722652f, -0.04403595f, 
    -0.03663195f, -0.23615365f, -0.61503565f, 0.41735849f, 0.01908678f, 0.03796615f, 0.02722468f, -0.21976224f, 
    0.10913432f, 0.12934025f, 0.15966722f, 0.11757401f, 0.30601758f, 0.14114828f, 0.14213023f, 0.04380302f, 
    0.19722813f, 0.17355585f, 0.07973897f, 0.00380404f, -0.04608375f, -0.16026324f, -0.10200056f, 0.00260388f, 
    0.26426363f, 0.08239976f, 0.03147503f, 0.29866269f, 0.03604424f, 0.13590537f, -0.09532133f, -0.05694225f, 
    -0.20915914f, 0.12022902f, -0.16996238f, -0.15320334f, 0.04228627f, -0.10880550f, -0.33266103f, 0.37232932f, 
    0.03411681f, 0.01073448f, 0.18732816f, 0.01673364f, 0.05656189f, 0.12895422f, -0.01577344f, 0.13721967f, 
    -0.04491144f, 0.27307332f, 0.28825575f, -0.13613491f, 0.08449275f, -0.00313980f, 0.06180069f, 0.05032964f, 
    -0.01474242f, -0.16661656f, 0.09525663f, 0.00150341f, 0.46673450f, -0.09850588f, 0.48018324f, 0.10228352f, 
    0.06698204f, -0.13509753f, -0.03452306f, 0.22020590f, -0.15742184f, -0.12072012f, -0.17909813f, -0.02032336f, 
    0.33162501f, 0.32538196f, 0.12971874f, -0.05856471f, 0.04517787f, 0.03689734f, 0.21778661f, 0.30857396f, 
    0.06115797f, 0.17670205f, 0.08970966f, 0.00313087f, -0.16340801f, 0.32293743f, -0.04472842f, 0.03085940f, 
    0.00536816f, -0.03311533f, 0.05082889f, -0.22614242f, -0.02790764f, -0.17062461f, -0.29851258f, -0.10931675f, 
    0.19830216f, 0.03267306f, -0.26688960f, -0.04945708f, 0.24980941f, 0.09710772f, -0.23779902f, 0.03186151f, 
    0.07033818f, -0.11666006f, -0.26644623f, -0.03497605f, 0.11650807f, 0.05167051f, -0.04569316f, 0.28976807f, 
    0.04824428f, 0.22981164f, 0.05871787f, 0.14277196f, -0.03521663f, 0.11048512f, 0.06611481f, 0.00213587f, 
    -0.62703753f, -0.13442129f, 0.19383588f, -0.20506991f, 0.12819153f, 0.14241889f, -0.17522877f, -0.02678727f, 
    -0.13505012f, -0.07325854f, -0.11318208f, -0.13090800f, 0.27846012f, -0.21087414f, 0.08283023f, -0.05966072f, 
    0.19314817f, -0.02849335f, -0.26575631f, -0.04244858f, -0.05033866f, -0.07222968f, 0.03176932f, 0.16279472f, 
    -0.02584410f, -0.11513359f, -0.10968764f, 0.10955874f, 0.15263523f, 0.10881688f, 0.20518032f, 0.18365233f, 
    0.03178032f, 0.14276749f, 0.05309915f, 0.20281938f, -0.30655584f, -0.36443400f, -0.08758362f, -0.06302115f, 
    -0.01128382f, -0.08929811f, 0.00260859f, 0.02291265f, -0.36370382f, -0.41460869f, -0.13123503f, -0.18602456f, 
    -0.12924233f, 0.04802222f, -0.09553382f, 0.14816585f, 0.14052281f, 0.00848692f, 0.08096953f, 0.31605312f, 
    0.12267432f, 0.07939233f, 0.16950829f, 0.30621234f, -0.10996341f, 0.18200754f, 0.44590613f, 0.24341948f, 
    -0.03202644f, -0.04754004f, 0.10817786f, 0.01815347f, 0.12131375f, -0.00213287f, 0.01324280f, -0.11424437f, 
    -0.23668092f, -0.24016181f, -0.23780896f, -0.03015318f, -0.11368275f, 0.07546265f, -0.10515210f, -0.08787230f, 
    -0.14256725f, 0.00735786f, -0.03326505f, 0.06034745f, -0.05254610f, 0.00855832f, 0.19617568f, 0.26116365f, 
    -0.12200382f, -0.00187525f, 0.10881788f, 0.16634414f, 0.05032247f, 0.01745152f, -0.04444201f, -0.04537381f, 
    -0.21629369f, -0.38667589f, -0.25065359f, -0.27523336f, -0.05317886f, 0.05528664f, -0.13219324f, 0.01687167f, 
    0.12826876f, -0.10626206f, 0.08377365f, -0.03099223f, 0.00011505f, -0.01023967f, 0.26336223f, 0.22737260f, 
    -0.08234119f, 0.22899309f, 0.06339214f, -0.08148438f, 0.15797620f, 0.13420270f, -0.20734745f, -0.06194409f, 
    -0.12660371f, -0.09591436f, 0.19469485f, 0.22998469f, -0.22275820f, 0.00239058f, 0.09703156f, 0.10938190f, 
    0.06062390f, -0.01310604f, 0.06667985f, 0.09502240f, 0.11224121f, 0.07871263f, -0.30999953f, -0.04974474f, 
    -0.27732840f, 0.09667363f, 0.20591791f, 0.09209425f, -0.01432309f, 0.00206108f, -0.08909509f, 0.11573401f, 
    0.09126838f, 0.04411032f, 0.08011191f, 0.02639327f, 0.05400373f, -0.04695088f, 0.02584383f, 0.01321243f, 
    -0.02755381f, -0.23809999f, -0.00640568f, 0.02333041f, -0.14996044f, -0.17027572f, -0.11628638f, -0.03967554f, 
    -0.03235264f, -0.07128329f, 0.07628754f, 0.13973893f, 0.09870600f, 0.25131610f, 0.02476141f, 0.04388025f, 
    -0.07303433f, 0.01069698f, 0.04866804f, -0.05703306f, -0.07828087f, 0.14847574f, 0.08375805f, 0.09182465f, 
    0.10226893f, 0.15562327f, 0.10014866f, 0.05771580f, -0.03615908f, -0.31797454f, -0.21175042f, -0.14732003f, 
    0.05296572f, 0.01690833f, -0.12871665f, -0.18887338f, 0.05624488f, -0.05972155f, 0.00405935f, -0.09076602f, 
    -0.49535367f, 0.22093984f, -0.13150322f, 0.34460735f, -0.01157863f, -0.16277793f, 0.03328458f, -0.00417136f, 
    0.00955057f, 0.06713658f, 0.10923100f, 0.14678964f, 0.12648281f, -0.00059252f, 0.01365598f, 0.01065037f, 
    0.00908763f, 0.04513737f, -0.14480230f, -0.05470974f, 0.01469925f, -0.16008781f, 0.05788323f, -0.25011986f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.24001376f, 0.21990892f, -0.06866962f, -0.01464798f, -0.05291096f, 0.08590693f, 0.08775778f, 0.16179763f, 
    0.21207228f, -0.07812910f, 0.07077348f, 0.02700517f, 0.05733430f, 0.08124987f, 0.00676372f, -0.00065397f, 
    0.07569116f, -0.03739461f, -0.04658956f, 0.05617058f, -0.00114603f, -0.06493531f, 0.02090737f, 0.03965294f, 
    0.13241610f, -0.03699524f, -0.03033500f, 0.16049254f, 0.01294338f, -0.09186245f, 0.10744312f, -0.00193724f, 
    0.01296791f, 0.02083635f, -0.05226905f, 0.10559215f, 0.14249007f, -0.09756497f, 0.15104209f, 0.13111700f, 
    0.13980862f, 0.15942971f, 0.11638930f, -0.02200747f, 0.00568293f, 0.16674779f, 0.15867206f, 0.12877341f, 
    -0.03235701f, 0.23563002f, 0.02835861f, -0.24821609f, 0.05281769f, -0.03489291f, 0.22750865f, 0.15014878f, 
    -0.06659215f, -0.02329520f, 0.12672748f, 0.06228457f, 0.10982379f, 0.14538082f, -0.13540179f, 0.17762303f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.11993127f, -0.25548077f, 0.07384983f, -0.03181027f, 0.21745600f, 0.20182787f, -0.41853774f, -0.53808403f, 
    -0.12001736f, 0.18454608f, -0.01964689f, -0.07705843f, 0.09662658f, 0.07655707f, 0.33455104f, 0.05266310f, 
    -0.32368666f, -0.08100800f, -0.00102159f, -0.04877144f, -0.03437892f, -0.00223629f, -0.44284353f, -0.04967404f, 
    -0.52979207f, -0.08206003f, -0.06516321f, -0.06760874f, -0.12886973f, 0.05081430f, -0.24198642f, 0.04752471f, 
    0.15645280f, 0.03075435f, 0.13918437f, -0.32529891f, -0.08899844f, 0.06329723f, 0.18064860f, -0.55048132f, 
    -0.59373277f, -0.66634601f, -0.08288455f, -0.08333042f, -0.77905452f, 0.14104354f, -0.24461660f, -0.01872564f, 
    0.30552360f, -0.41806033f, 0.26344174f, 0.32086214f, -0.31842163f, 0.10168426f, -0.11989725f, -0.31761640f, 
    0.12995848f, -0.10414589f, 0.13363822f, -0.03255939f, 0.12946337f, 0.02143014f, 0.29519296f, -0.30721405f, 
    0.23844407f, 0.21187744f, -0.04245507f, 0.27532959f, 0.31594685f, 0.12102409f, -0.08733223f, -0.32700977f, 
    0.22209512f, 0.01081395f, 0.13451371f, -0.21433069f, 0.00935955f, -0.42684740f, -0.52874190f, -0.02913442f, 
    -0.03470512f, -0.11847783f, 0.01043343f, 0.01439427f, -0.08041029f, 0.10258856f, 0.22990613f, 0.08832960f, 
    -0.11820731f, -0.10334313f, 0.05027449f, -0.29172787f, -0.02958323f, 0.01246886f, 0.07115148f, -0.54930854f, 
    0.11790926f, -0.04023374f, 0.03001872f, 0.34676373f, 0.06270082f, -0.06394867f, 0.12282313f, -0.05608547f, 
    -0.01986915f, -0.00739675f, 0.00340505f, 0.00019750f, -0.96667969f, 0.18467343f, 0.30335391f, -0.30576178f, 
    0.07219885f, 0.03010012f, 0.00534767f, 0.35041869f, -0.26477939f, -0.06840506f, 0.12083762f, -0.19115064f, 
    -0.32917976f, 0.02001098f, 0.28776932f, 0.00714589f, 0.32510537f, 0.23594815f, -0.01304384f, 0.31560805f, 
    0.30688065f, 0.15055183f, 0.08673976f, -0.06101438f, 0.11466429f, 0.23543495f, -0.08159708f, 0.10610899f, 
    0.03223214f, -0.09283878f, -0.20740534f, -0.24674574f, -0.16144054f, 0.54180133f, 0.16547784f, -0.04106747f, 
    -0.08940564f, -0.06166283f, 0.00494192f, -0.10976600f, -0.03124472f, 0.04366462f, -0.06700996f, -0.08887602f, 
    0.11760388f, -0.10475856f, 0.06567674f, 0.13366616f, 0.16669388f, -0.61969596f, 0.04819910f, -0.13488460f, 
    0.10698820f, -0.09420548f, -0.48920676f, -0.90870905f, 0.19468473f, 0.05726228f, 0.02879694f, 0.23123272f, 
    0.34440431f, 0.08878554f, -0.28570268f, -0.03160618f, -0.18177785f, -0.19659673f, 0.00974040f, -0.05894906f, 
    0.21350531f, 0.13605709f, 0.09364249f, -0.24487124f, 0.09842701f, 0.06292820f, -0.10939949f, 0.06444672f, 
    -0.10200171f, 0.06071194f, 0.03200480f, -0.07374842f, 0.12627839f, 0.25055146f, -0.72721481f, -0.40810466f, 
    -0.72390026f, -0.16510995f, -0.04215026f, 0.26219407f, 0.19722675f, -0.13645999f, -0.45394838f, -0.04847657f, 
    -0.24214172f, -0.13477580f, 0.10977130f, 0.03618595f, -0.25225201f, -0.00760046f, 0.17663381f, -0.09344672f, 
    0.21170288f, -0.09308217f, -0.14451715f, -0.05707129f, 0.00339845f, -0.05096889f, 0.13945490f, 0.11022440f, 
    0.02175111f, 0.08520011f, 0.10970560f, 0.08147319f, 0.18920325f, -0.08398905f, -0.19329566f, -0.01202469f, 
    -0.32292205f, 0.00510257f, 0.15102269f, -0.21182656f, -0.59551215f, 0.44015762f, -0.25464520f, 0.30319297f, 
    0.30715019f, 0.35092422f, 0.20726345f, 0.05306375f, 0.37090442f, -0.45868331f, 0.42655379f, 0.20417565f, 
    0.23217271f, -0.68073308f, 0.05686830f, 0.04958251f, 0.06977930f, 0.07408381f, -0.64634532f, -0.43394732f, 
    0.13076404f, 0.09331834f, 0.09696895f, 0.04884003f, -0.14951095f, 0.13891874f, -0.05900318f, -0.06981707f, 
    0.20110634f, -0.07333922f, 0.02127774f, -0.14821371f, -0.01904984f, -0.14088982f, 0.25721321f, 0.05316339f, 
    -0.25283593f, 0.09980653f, -0.02379448f, 0.22573954f, 0.15135983f, 0.27545059f, -0.03924261f, -0.10106648f, 
    0.05595625f, -0.08240966f, -0.36099988f, -0.02141343f, 0.10483810f, -0.00340982f, 0.21096155f, 0.04675135f, 
    -0.42650455f, 0.08085975f, -0.00428863f, 0.16769159f, 0.22338645f, -0.04864312f, -0.29647484f, 0.13246769f, 
    0.20792577f, -0.04679236f, 0.07771377f, -0.03416163f, 0.14653260f, 0.06717075f, -0.09890449f, -0.75766027f, 
    0.23464370f, -0.17082404f, -0.48465797f, -0.04684804f, 0.10072318f, -0.42445135f, 0.19447185f, -0.07528079f, 
    0.12511037f, -0.03247893f, -0.12637626f, 0.05778140f, -0.20934223f, -0.13535866f, -0.03062205f, -0.00676657f, 
    0.14692079f, 0.08123942f, -0.72657531f, -0.04585244f, -0.22572513f, -0.00928445f, 0.13463251f, 0.00795022f, 
    0.25038752f, -0.15535976f, 0.07081512f, -0.57459229f, 0.07176651f, -0.40461478f, -0.06560349f, 0.10168175f, 
    -0.04391422f, 0.07733088f, -0.09847914f, 0.19905262f, 0.18251400f, -0.56716406f, -0.21469738f, -0.11289015f, 
    0.01358858f, -0.04836531f, -0.23409052f, -0.02384309f, -0.08569816f, -0.06037208f, -0.41506550f, 0.10888710f, 
    0.31628925f, 0.04800387f, -0.12975457f, 0.03925753f, -0.20573716f, 0.29681307f, 0.07359840f, 0.08147686f, 
    0.14989230f, -0.08993355f, 0.14946856f, -0.27405250f, -0.23636292f, -0.15318334f, 0.21668570f, -0.27517730f, 
    -0.35023782f, -0.30751911f, 0.28424695f, 0.09093359f, 0.03613140f, 0.00857147f, 0.19916394f, 0.25041687f, 
    -0.05928129f, 0.32336259f, 0.08850996f, -0.24413313f, 0.00425765f, 0.02364987f, 0.33284569f, -0.10287101f, 
    -0.18591456f, -0.02099257f, -0.70694232f, -0.02608049f, -0.13492003f, 0.01816343f, -0.08438934f, 0.27220091f, 
    0.00454150f, 0.16480035f, -0.12558512f, 0.39267498f, -0.49730453f, 0.09626703f, 0.13084257f, 0.26010591f, 
    0.25169173f, -0.08950280f, -0.44403145f, -0.58819455f, -0.27774134f, -0.17093493f, 0.00440122f, 0.04179991f, 
    0.00835429f, -0.04127163f, -0.21328050f, -0.06026109f, -0.00860776f, 0.02942058f, 0.03400829f, -0.00182763f, 
    -0.15129043f, 0.02371316f, -0.02827642f, 0.32955492f, -0.20072424f, -0.43904370f, -0.12921463f, -0.13385461f, 
    -0.35366884f, -0.12301926f, -0.75646305f, 0.53658873f, 0.19501318f, -0.02405263f, 0.08556245f, 0.28798440f, 
    0.13633737f, -0.22307880f, -0.26977375f, -0.10940305f, 0.03365268f, 0.19622807f, -0.52627635f, 0.24740610f, 
    -0.36089927f, 0.32130671f, -0.17651080f, -0.46761456f, 0.10140127f, -0.11528704f, -0.04979517f, -0.09253463f, 
    0.30652383f, 0.08157635f, 0.20730516f, 0.00626280f, -0.03455321f, -0.54475665f, -0.74610853f, -0.36829850f, 
    0.00749903f, -0.20342709f, -0.10693999f, -0.56921983f, -0.40260470f, -0.21862604f, 0.19897988f, -0.11884736f, 
    0.13935706f, -0.33775312f, -0.09341220f, -0.43082622f, 0.02872047f, -0.24390255f, 0.47640422f, -0.06653204f, 
    0.17708284f, -0.03433660f, 0.22398797f, -0.01011613f, -0.11422988f, 0.11855507f, 0.14163867f, 0.03927705f, 
    -0.06106370f, 0.03495263f, 0.07484256f, -0.77932805f, 0.45095706f, 0.21659869f, 0.09097968f, 0.16273943f, 
    -0.00308316f, -0.11986255f, -0.20439091f, -0.05269451f, -0.09618247f, 0.17578387f, -0.21654375f, 0.14987272f, 
    0.06432962f, -0.00611160f, 0.17089365f, 0.01615066f, 0.25204897f, 0.00597424f, -0.08835420f, -0.30189633f, 
    0.19741254f, -0.11286763f, -0.47938204f, -0.13321356f, 0.18291689f, 0.06295009f, -0.04669305f, -0.00080326f, 
    -0.19717148f, 0.08530366f, -0.12129741f, 0.10339217f, 0.24356098f, -0.69374633f, -0.45954207f, -0.11301636f, 
    -0.27633792f, 0.15008423f, 0.06611077f, -0.19395094f, -0.37946028f, 0.19141974f, -0.02913200f, 0.01456896f, 
    -0.02714111f, 0.13448130f, -0.19906142f, -0.90249139f, -0.19639325f, -0.10324702f, 0.03233743f, 0.03854001f, 
    0.23611476f, 0.06570778f, -0.00729554f, 0.00145810f, -0.05324762f, -0.00416123f, -0.35856229f, 0.04288093f, 
    0.34428480f, 0.08885591f, 0.00859736f, -0.59175837f, -0.44283196f, 0.24546558f, 0.22795664f, -0.23363115f, 
    0.08318259f, -0.01536238f, 0.35428703f, -0.06568012f, -0.13749923f, -0.28771275f, -0.05298942f, -0.24198964f, 
    0.33119398f, 0.31056643f, 0.33668038f, -0.06737586f, 0.05329980f, -0.26902151f, -0.08728625f, 0.39144042f, 
    -0.30007911f, -0.37628996f, 0.07532533f, -0.00556595f, -0.01735155f, -0.06544246f, -0.13977066f, 0.26544473f, 
    -0.25413457f, -0.07284724f, 0.03385466f, 0.11622326f, 0.10388155f, 0.09775687f, -0.58890843f, -0.31773555f, 
    0.17616414f, 0.04514063f, 0.11863822f, -0.30214015f, -0.40490589f, -0.27061340f, 0.29760402f, 0.20962697f, 
    -0.01510404f, 0.19921575f, -0.01910619f, 0.37995166f, -0.06795124f, -0.40089574f, -0.02857303f, -0.04576588f, 
    -0.49373630f, -0.01964048f, 0.19895856f, 0.10823582f, -0.04744505f, 0.02412296f, -0.32453960f, 0.06860784f, 
    -0.15054718f, -0.03741839f, -0.07750878f, 0.12491368f, 0.33947065f, -0.04890445f, 0.23577988f, 0.22485971f, 
    0.24136533f, -0.10497478f, -0.19024792f, -0.07456220f, 0.14767498f, -0.16280796f, -0.50780481f, -0.36914626f, 
    -0.36104554f, -0.33682168f, -0.40856758f, 0.07585116f, 0.39728501f, 0.26232255f, 0.03106982f, -0.19778048f, 
    -0.06649838f, -0.00597353f, 0.06717679f, -0.11993458f, 0.00843303f, 0.07446247f, -0.36197671f, 0.28867090f, 
    0.04290742f, -0.07834607f, 0.39493170f, -0.04603193f, -0.65118247f, -0.20585090f, -0.05154122f, -0.03777144f, 
    -0.59880692f, 0.21068856f, -0.01344109f, 0.46632192f, -0.35911238f, -0.57427841f, -0.23880038f, 0.22628354f, 
    0.22371316f, 0.15824126f, 0.48263660f, 0.14543734f, 0.33988798f, 0.15642312f, -0.25046235f, 0.11603482f, 
    0.34991825f, -0.03175772f, 0.41516364f, -0.00881164f, -0.00304287f, 0.01061377f, -0.04882898f, -0.11658057f, 
    0.02326061f, -0.11479151f, -0.07253785f, 0.25183371f, -0.50071955f, -0.07878437f, -0.22594367f, -0.91562456f, 
    -0.26511148f, 0.10413633f, -0.23125899f, -0.05969408f, -0.38648599f, -0.23975432f, 0.26161686f, 0.22419047f, 
    -0.13900764f, 0.02560305f, -0.35142207f, -0.09856192f, 0.16143955f, -0.45443046f, -0.45601088f, -0.30926996f, 
    -0.65415394f, 0.08985471f, 0.22470072f, -0.38215724f, -0.32434633f, -0.06453627f, -0.29612494f, -0.02649379f, 
    0.24510956f, -0.05206974f, -0.01961760f, 0.04110284f, 0.30267358f, 0.16073689f, -0.22700101f, 0.16716474f, 
    -0.43869039f, 0.12087979f, -0.04707112f, 0.42748764f, -0.28168651f, 0.14856569f, -0.10848477f, -0.16073337f, 
    -0.49732929f, -0.10493246f, -0.36564663f, -0.14315446f, -0.28504348f, 0.55462795f, -0.58772451f, -0.09958681f, 
    0.12888485f, 0.07863431f, -0.18195118f, -0.03064052f, -0.01313503f, 0.07155982f, 0.36970887f, -0.06752247f, 
    0.07127769f, 0.00422444f, -0.07913963f, 0.07478975f, -0.54238534f, 0.07882366f, 0.03933987f, 0.44887561f, 
    -0.47625113f, -0.03911856f, -0.01309426f, -0.22914083f, 0.19684976f, -0.14465682f, 0.22704072f, 0.29067469f, 
    0.13668256f, 0.23896924f, 0.02057398f, 0.07275138f, 0.01061908f, 0.14932413f, -0.05515465f, 0.20733765f, 
    -0.27113086f, 0.01181543f, -0.59880787f, -0.43877721f, -0.11537036f, -0.10733513f, 0.16858821f, 0.03813411f, 
    -0.27650318f, -0.04116424f, 0.03688710f, 0.11892082f, -0.12438900f, -0.29668155f, 0.71763688f, -0.22603956f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19578387f, 0.09599977f, 0.07351187f, -0.10041207f, -0.16931681f, -0.06424091f, -0.01245471f, -0.06105589f, 
    -0.01799378f, 0.00850194f, 0.07179369f, -0.17419846f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
