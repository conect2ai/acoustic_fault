#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.18399180f, 0.00733222f, -0.04483391f, 0.22809914f, 0.18113589f, 0.48271838f, -0.16716523f, -0.01362681f, 
    -0.22287405f, -0.37718165f, 0.06639101f, -0.20154221f, 0.25179735f, 0.14760622f, 0.00687229f, -0.17633408f, 
    -0.21446678f, 0.25078222f, -0.04160796f, -0.24512191f, -0.19487314f, 0.20453650f, -0.07605091f, 0.13149434f, 
    0.10349702f, 0.08082607f, 0.26563630f, -0.35199320f, -0.28666058f, 0.38898981f, -0.03294864f, -0.01099380f, 
    0.30313399f, -0.16923974f, -0.31643298f, 0.01288699f, -0.15871923f, 0.23025848f, 0.10032413f, -0.19628888f, 
    -0.25671625f, 0.40639672f, -0.09106029f, -0.10861178f, 0.18790764f, 0.02524049f, -0.45285064f, 0.26802933f, 
    0.25889134f, -0.00204570f, -0.38826603f, -0.56307769f, -0.48432100f, -0.35506225f, -0.31124476f, -0.38921890f, 
    -0.43395650f, -0.43405256f, -0.60112011f, -0.41082984f, 0.32201627f, -0.03600499f, 0.01334680f, 0.34380171f, 
    0.11237679f, 0.09896775f, 0.16120715f, 0.07847582f, -0.02220559f, 0.05416140f, -0.00579079f, 0.13518196f, 
    0.25857511f, -0.18530519f, -0.13279773f, -0.27575296f, -0.06070952f, -0.21759063f, -0.32131585f, -0.31032497f, 
    0.27890682f, 0.30977187f, 0.19911310f, -0.18783545f, -0.25359929f, 0.31200704f, 0.37962362f, 0.14130396f, 
    0.13011929f, -0.23424581f, -0.15893959f, -0.01922284f, -0.13033429f, 0.06986834f, -0.17782988f, -0.04468322f, 
    -0.04780382f, -0.05086532f, 0.25077048f, 0.20851448f, -0.63100374f, 0.01499138f, -0.37809539f, -0.03694430f, 
    -0.57927334f, -0.54241037f, -0.36402321f, -0.44460705f, -0.15290436f, 0.12992752f, 0.19038388f, -0.04676484f, 
    0.43266493f, -0.31155723f, 0.07500602f, -0.28630647f, -0.13247326f, 0.00609632f, -0.00767061f, -0.21179609f, 
    -0.10900664f, 0.28786898f, -0.38835070f, -0.14792824f, 0.43307674f, -0.12863436f, -0.74869657f, -0.22645319f, 
    -0.45077828f, 0.01690524f, -0.04221378f, -0.40445742f, -0.11132277f, 0.11142811f, 0.18735822f, -0.42560965f, 
    -0.14749455f, -0.29836208f, -0.38467383f, 0.46486950f, -0.19738930f, -0.18767212f, -0.38250956f, -0.03926274f, 
    -0.30038202f, -0.14317319f, -0.31770101f, -0.36750090f, -0.10237305f, -0.16340062f, -0.08008654f, 0.36119491f, 
    0.47295785f, 0.28484485f, 0.24924655f, -0.49409038f, -0.57257301f, -0.16647358f, -0.11684766f, -0.32798144f, 
    -0.08845546f, 0.14832747f, -0.07266372f, 0.35540557f, 0.05615137f, 0.22146298f, 0.09010679f, 0.21066061f, 
    -0.30792314f, 0.08282924f, -0.26546645f, 0.01653483f, -0.06410014f, -0.19950484f, -0.09690148f, -0.40382621f, 
    0.35049951f, 0.29539466f, -0.21542591f, -0.03299727f, -0.04585502f, 0.32917660f, -0.25331518f, -0.29969859f, 
    0.16587085f, -0.10946301f, 0.43598789f, -0.09359320f, -0.25098366f, -0.00239440f, 0.26671189f, -0.23615171f, 
    -0.21810502f, 0.17459059f, -0.07230760f, -0.03604190f, -0.05298722f, 0.17297250f, -0.36286071f, 0.16657642f, 
    0.02141353f, 0.17962226f, -0.69522560f, -0.49997121f, 0.29670504f, -0.27237299f, -0.05589024f, 0.48735011f, 
    0.42949244f, -0.36836761f, 0.15174337f, -0.35323876f, 0.37211296f, -0.27581856f, -0.24440295f, 0.04343698f, 
    -0.26608655f, -0.09891085f, 0.05461315f, 0.27759403f, -0.15629973f, -0.08662961f, -0.10216124f, -0.05226600f, 
    0.34634840f, -0.15034840f, 0.14981237f, -0.53674626f, -0.93754309f, -0.74251854f, 0.51962119f, 0.00998545f, 
    0.51148683f, -0.07894306f, 0.04816482f, 0.10844327f, 0.20753632f, 0.14588517f, 0.07834318f, 0.16482790f, 
    0.10583834f, -0.08752172f, 0.18363346f, -0.19561578f, 0.00023861f, 0.03918567f, -0.15949887f, -0.18093076f, 
    0.20941117f, -0.08069698f, 0.39888486f, 0.40391329f, -0.13818477f, 0.50958765f, -0.17087525f, 0.36137542f, 
    -0.14441440f, -0.39897886f, -0.62654245f, -0.49484494f, -0.02163390f, -0.11057672f, -0.02530602f, -0.04267563f, 
    -0.13383314f, -0.09224865f, 0.04869724f, 0.24631749f, -0.15254974f, 0.23056670f, -0.11199283f, 0.11979737f, 
    0.03351761f, -0.09477451f, -0.17969210f, -0.21716078f, 0.08867479f, 0.30516887f, 0.35197419f, 0.34821138f, 
    0.44081742f, 0.13481447f, 0.20559642f, 0.25295880f, 0.16615799f, -0.05253759f, -0.19085139f, -0.07214436f, 
    -0.17929354f, -0.21677564f, -0.14978078f, -0.06724198f, -0.26644784f, -0.03979316f, -0.05433679f, -0.04986008f, 
    0.05542050f, -0.13312210f, -0.17553121f, -0.04325739f, 0.45121732f, -1.09627116f, 0.14334923f, 0.75195771f, 
    0.32471827f, -0.60326201f, 0.05358473f, -0.36015084f, 0.04852615f, 0.08888912f, -0.02769479f, -0.20435764f, 
    0.06357086f, 0.09478398f, 0.29461792f, -0.06547818f, 0.15960439f, -0.07377748f, 0.03652527f, -0.08415557f, 
    0.06683414f, -0.04514857f, -0.08217227f, 0.01640506f, -0.00856936f, -0.79199213f, -0.57513469f, -0.50251907f, 
    -0.44492871f, 0.14487192f, -0.04815203f, 0.15301871f, -0.30956548f, 0.36147958f, 0.50983405f, 0.03420162f, 
    -0.47194549f, -0.43443474f, -0.30588189f, -0.38895306f, 0.20440847f, -0.04477004f, 0.02353743f, 0.33008790f, 
    -0.03647824f, -0.28707170f, -0.38083225f, -0.31731379f, -0.32618964f, -0.35768262f, -0.04321790f, -0.86509860f, 
    0.03594825f, 0.43966925f, -0.14879249f, 0.44709688f, 0.52957094f, -0.48696846f, -0.66598457f, 0.13837492f, 
    -0.05552438f, -0.09084501f, -0.18684378f, 0.16588119f, -0.20080210f, 0.11364526f, 0.08019453f, -0.18670328f, 
    0.52619559f, -0.11582169f, -0.29413593f, -0.37937853f, -0.45549905f, 0.16418564f, 0.06657851f, -0.50483817f, 
    -0.09203809f, 0.05151764f, -0.27604032f, -0.27371639f, -0.41124237f, -0.55927414f, -0.62273484f, -0.56806296f, 
    -0.34260061f, -0.15480773f, -0.41471547f, 0.24383208f, -0.25137773f, -0.06744645f, -0.11411758f, -0.60211575f, 
    -0.13209897f, -0.19103283f, -0.24615334f, 0.15415442f, -0.02287425f, -0.12080713f, -0.05665223f, 0.14088771f, 
    0.16951026f, -0.32301968f, -0.32412687f, -0.24280745f, 0.35955435f, -0.38230243f, -0.06117230f, 0.32401589f, 
    -0.43189386f, 0.36857152f, -0.36204943f, -0.22953646f, 0.53782910f, -0.03338292f, -0.26434049f, 0.22491103f, 
    -0.01532237f, -0.06450129f, -0.28488681f, -0.20491350f, 0.15687086f, -0.08431697f, -0.20758450f, 0.00729110f, 
    0.30006817f, -0.36710840f, -0.21318650f, -0.09558126f, -0.15617025f, 0.57633793f, -0.15611337f, -0.24583153f, 
    -0.31741136f, 0.54282987f, -0.20522635f, 0.15797836f, -0.31565383f, 0.29330319f, -0.03689787f, 0.15077303f, 
    0.15140052f, -0.17048287f, 0.01323211f, -0.11322204f, -0.13945119f, -0.19071166f, 0.00268424f, 0.37612525f, 
    -0.07769443f, 0.25544655f, 0.44637594f, 0.74405783f, 0.64068413f, -0.25929752f, -0.81286991f, -0.23762460f, 
    -0.34065029f, -0.12301414f, -0.27272755f, -0.46312070f, 0.38861278f, -0.25648940f, -0.15770306f, 0.37051147f, 
    -0.25246868f, 0.17531559f, -0.08971371f, 0.32553515f, -0.01624078f, 0.09855112f, -0.12380564f, -0.16307791f, 
    -0.25103819f, -0.22289145f, 0.12367129f, -0.02862569f, -0.80987287f, -0.43967462f, -0.62103891f, -0.50330907f, 
    -0.28288817f, -0.36357260f, -0.37635559f, -0.66018462f, -0.33113596f, -0.14497408f, 0.06796420f, 0.02814113f, 
    -0.12707235f, -0.45287442f, 0.04071098f, -0.21689253f, -0.04250253f, -0.00066403f, -0.27446553f, -0.13546039f, 
    0.24587543f, 0.18169998f, -0.05202042f, -0.14595875f, 1.09794652f, -1.04507613f, -0.75608140f, -0.23432206f, 
    0.06955597f, 0.27655816f, 0.68295503f, 0.29968297f, -0.03247559f, -0.18412820f, -0.26370412f, 0.25119087f, 
    -0.04870696f, -0.34029704f, 0.15143086f, 0.13816777f, -0.12696122f, 0.10995159f, 0.15756914f, -0.13474011f, 
    -0.10270096f, -0.07266340f, 0.04833638f, 0.16169058f, 0.03016574f, -1.07561481f, -0.39332435f, -0.56641322f, 
    -0.02381721f, 0.33557302f, 0.25775555f, 0.37064782f, -0.04719707f, 0.48338693f, 0.34026760f, 0.14598417f, 
    -0.02244742f, 0.14950316f, -0.23266876f, -0.43387154f, -0.27205899f, 0.07784835f, 0.14097397f, 0.19757004f, 
    0.03756602f, 0.04286106f, -0.04057615f, -0.27573889f, -0.07322576f, 0.17506349f, 0.44542292f, 0.33378392f, 
    -0.32108867f, -0.13130911f, 0.04924644f, -0.03314501f, -0.00045793f, 0.07563177f, -0.08550534f, -0.20708106f, 
    -0.23606732f, 0.20016286f, 0.21052094f, -0.09787775f, -0.04330694f, -0.20975141f, 0.10661895f, -0.06239315f, 
    0.02640052f, 0.10498087f, 0.15106711f, -0.09108505f, -0.09058230f, 0.23848096f, -0.25860775f, -0.11195611f, 
    -0.51832217f, -0.25553599f, -0.12678729f, 0.01132763f, -0.94040430f, -0.81699502f, -0.23831795f, -0.35478845f, 
    -0.15947855f, 0.84100515f, -0.04850771f, 0.38969547f, 0.15205047f, 0.14771917f, -0.18680227f, -0.09323619f, 
    -0.23285700f, -0.04331517f, -0.37126213f, -0.06423592f, 0.05502832f, 0.11741098f, -0.31761658f, 0.27474424f, 
    0.79112458f, 0.18560371f, 0.19350880f, -0.35824761f, -0.79883844f, 0.22866295f, 0.61400157f, -0.24542113f, 
    -0.43855748f, 0.17962225f, -0.17753163f, -0.26773739f, -0.08481178f, -0.15537076f, -0.04992888f, -0.08041023f, 
    -0.31500909f, -0.18966714f, 0.21693628f, 0.05469496f, -0.39802399f, 0.02294750f, -0.24384893f, -0.03006173f, 
    0.03187547f, -0.55154198f, -0.92936605f, -0.45426616f, 0.09995397f, -0.19291893f, -0.10176692f, 0.47021765f, 
    0.07171223f, 0.19276990f, -0.21751948f, 0.31741011f, 0.22372566f, -0.04044907f, -0.02405141f, -0.08003367f, 
    -0.30477503f, -0.01056903f, -0.09931403f, 0.06637090f, 0.14361294f, -0.33574948f, -0.16285394f, -0.00711717f, 
    0.19828984f, -0.37566137f, 0.64549583f, 0.58205521f, -0.21168579f, 0.06576834f, -0.09190216f, -0.45471206f, 
    0.02352538f, 0.23392449f, 0.11973681f, 0.18226562f, -0.28002319f, 0.17284556f, 0.03110429f, -0.10951968f, 
    -0.45825121f, 0.02204763f, 0.11343468f, 0.04741571f, -0.22179724f, -0.28298303f, -0.26258269f, 0.07663128f, 
    0.17022234f, 0.00108312f, -0.26158920f, -1.14354205f, -0.23269767f, -0.37404355f, -1.08480549f, -0.97679228f, 
    0.31820089f, 0.29505816f, 0.06687451f, 0.11220001f, 0.03849542f, -0.11676317f, -0.19314814f, -0.11238358f, 
    -0.47407919f, -0.27916327f, 0.07945522f, 0.05644753f, -0.11075538f, 0.12467638f, 0.02709566f, -0.03724547f, 
    0.12564832f, 0.03248533f, -0.20654808f, -0.10056404f, -0.40209976f, -0.23108718f, 0.26325521f, 0.20432952f, 
    -0.19210650f, -0.03132943f, -0.48501277f, 0.45899770f, 0.26664439f, -0.19052643f, -0.48873565f, -0.35125595f, 
    -0.20404454f, 0.20961311f, -0.00984829f, -0.10539417f, -0.21815443f, -0.22910927f, 0.17758715f, 0.05829488f, 
    0.23653190f, -0.13510375f, -0.26827544f, 0.09519329f, 0.07343115f, -1.34958243f, -0.94028711f, 0.31126559f, 
    0.54896647f, 0.00293469f, 0.65487772f, 0.38288867f, -0.06991725f, -0.14544801f, 0.13827738f, -0.20138803f, 
    -0.16738179f, -0.22189948f, 0.56957197f, -0.11655986f, 0.13042027f, 0.05354352f, -0.35628650f, -0.08149692f, 
    0.24966064f, 0.03823543f, -0.04396585f, 0.04277868f, 0.21328197f, -0.11363167f, -0.02001160f, 0.07370827f, 
    0.13797097f, -0.05402618f, 0.05293982f, -0.15786369f, -0.58112121f, -0.29367000f, 0.22482602f, -0.54451752f, 
    -0.12120244f, 0.22882697f, 0.27943128f, 0.41950095f, -0.34523082f, -0.18542700f, 0.06578577f, 0.14177702f, 
    0.06467812f, -0.21993259f, 0.08632377f, 0.10019203f, -0.06229364f, 0.06708381f, 0.08325997f, -0.46697196f, 
    -0.34216124f, -0.42804691f, -0.11375655f, 0.22724858f, 0.46038496f, 0.30112401f, 0.02599164f, 0.38768864f, 
    0.30505911f, -0.00662380f, 0.09499908f, -0.02893331f, 0.12050218f, -0.26395831f, 0.02280310f, -0.02930250f, 
    -0.20051944f, -0.26528597f, -0.18809862f, 0.28874367f, 0.06247923f, -0.03819840f, 0.32490557f, 0.19414859f, 
    -0.12782234f, 0.68698782f, 0.19652310f, -0.66145623f, -0.06001183f, -0.17112540f, 0.61519367f, 0.31618121f, 
    -0.13709150f, -0.38782308f, -0.26096958f, 0.11572838f, -0.04380185f, -0.01898027f, -0.36841792f, 0.40788284f, 
    -0.20679933f, -0.36333302f, 0.11585116f, -0.06078159f, -0.04710741f, 0.11518766f, 0.21471198f, 0.17476383f, 
    -0.02069370f, 0.40234765f, -0.04364414f, -0.40441468f, -0.61868143f, -0.43935663f, 0.14599745f, -0.14566895f, 
    -0.35983384f, -0.31660482f, -0.33349019f, 0.43261588f, 0.18664724f, 0.51739323f, 0.01928013f, 0.33255255f, 
    -0.00059187f, -0.16023278f, -0.03817114f, -0.02410552f, -0.32271910f, -0.04499879f, -0.13147105f, 0.21597151f, 
    -0.09164010f, -0.13550773f, 0.22177666f, 0.01967224f, 0.06816620f, -0.05639157f, 0.20983227f, 0.08662604f, 
    0.30939603f, -0.16169722f, -0.27013284f, -0.17204851f, 0.13821496f, -0.16082689f, -0.01910654f, -0.24830393f, 
    0.12411525f, 0.15738475f, 0.09005952f, 0.10467861f, 0.18364617f, -0.13482895f, 0.25555602f, -0.12507229f, 
    -0.11593959f, 0.04229126f, -0.15010723f, 0.22450133f, -0.37152749f, -0.27990893f, 0.09144691f, -0.20882182f, 
    -0.06516626f, -0.39352289f, -0.14843386f, 0.10593549f, 0.08366027f, -0.09807122f, 0.08144494f, -0.11853554f, 
    -0.19424351f, 0.46472943f, -0.30170527f, -0.08139181f, -0.13516216f, -0.25201815f, -0.48235473f, 0.15147734f, 
    -0.03101214f, -0.11451466f, 0.26379532f, 0.36391944f, 0.50877595f, 0.32021752f, 0.20199874f, 0.03980972f, 
    -0.13329013f, 0.09479582f, -0.24482860f, 0.01592289f, 0.28290513f, -0.16582635f, 0.20235661f, 0.25298852f, 
    -0.14162053f, -0.39928061f, -0.13121325f, 0.07306697f, -0.02517627f, 0.08441029f, -0.27942032f, 0.00743941f, 
    0.08930123f, -0.02283469f, -0.10024206f, 0.05317495f, -0.02824163f, -0.12030377f, -0.41306400f, -0.79331768f, 
    -0.70609659f, -0.68088865f, 0.72029805f, -0.10837974f, -0.01537602f, 0.29213741f, 0.78123337f, 0.14339601f, 
    -0.42552766f, -0.33715719f, -0.05961546f, -0.07296008f, 0.11210332f, -0.15243050f, 0.14876711f, -0.11791915f, 
    -0.52205205f, -0.23119240f, -0.05093214f, 0.31092784f, -0.12885296f, 0.27979866f, -0.05083771f, -0.83943307f, 
    -0.00124490f, 0.56984270f, 0.20122820f, -0.15817061f, -0.21938919f, -0.68080217f, -0.18651815f, 0.52909422f, 
    -0.12744872f, 0.56664246f, -0.18369839f, 0.05542590f, -0.17062081f, -0.30785203f, 0.05521796f, 0.03762698f, 
    -0.17586787f, -0.02695666f, 0.11766335f, -0.03589839f, -0.05546859f, -0.04303290f, 0.12916006f, 0.53794432f, 
    0.27951568f, -0.33527318f, 0.01455597f, -0.38075504f, -0.34013411f, -0.20494355f, 0.13276456f, 0.31379190f, 
    0.27828401f, -0.10435303f, -0.09893695f, 0.05338253f, -0.35279924f, 0.12741296f, -0.00365651f, -0.05267607f, 
    0.03286844f, -0.23036435f, -0.23555493f, -0.45377374f, -0.42030808f, -0.23779981f, -0.27808297f, -0.49582031f, 
    0.60295922f, -0.30263677f, -0.36173394f, 0.01970784f, -0.07244267f, -0.11708105f, -0.29503363f, -0.42984977f, 
    -0.13744220f, -0.49877658f, -0.18626840f, 0.66828340f, -0.48889312f, 0.02052750f, 0.22799544f, -0.15141718f, 
    0.00152526f, -0.20036849f, 0.22563760f, 0.13748458f, -0.03579244f, -0.30014545f, 0.06713337f, -0.02674722f, 
    -0.03999285f, 0.34155709f, -0.34347209f, -0.12289622f, -0.19113342f, 0.75068617f, -0.02868200f, -0.14956981f, 
    -0.28418124f, -0.36393240f, -0.31959340f, 0.12126730f, 0.17445193f, 0.04274656f, -0.23896858f, -0.04873228f, 
    -0.03871964f, 0.26889667f, -0.09171256f, 0.13595444f, 0.28923970f, -0.13125959f, -0.20882037f, -0.06318437f, 
    -0.05698697f, -0.27425423f, -0.06376832f, 0.04006623f, 0.13305019f, 0.28109589f, -0.15543593f, 0.12736695f, 
    -0.13220710f, -0.53876048f, -0.25660127f, 0.28671521f, 0.47145739f, -0.14993888f, -0.21474560f, 0.00818203f, 
    -0.38519147f, -0.23609442f, -0.18371403f, -0.07952480f, -0.05677513f, -0.11254611f, -0.28324568f, 0.32492316f, 
    0.06497064f, -0.31166449f, -0.39106509f, 0.23673153f, 0.10422458f, -0.39784873f, -0.01914298f, 0.13013999f, 
    -0.00829099f, 0.56309289f, -0.17465957f, -0.38585827f, -0.21378514f, -0.26368850f, -0.15275709f, 0.27030447f, 
    0.09514446f, 0.30665943f, -0.23991294f, -0.08192506f, 0.10584750f, -0.33923709f, -0.22795239f, 0.05493509f, 
    0.19290277f, 0.28028095f, 0.07836355f, -0.14146300f, -0.21925712f, 0.35143191f, 0.18201150f, 0.38023731f, 
    -0.22419417f, -0.18116617f, -0.29133964f, 0.02265554f, -0.00564282f, 0.14792973f, -0.10440346f, 0.11543339f, 
    0.07472654f, -0.23051570f, -0.07432137f, -0.30338368f, 0.07139202f, 0.16533609f, -0.04083534f, -0.24846272f, 
    -0.40622303f, -0.55792421f, -0.54071015f, -0.65900987f, -0.34208506f, -0.68129253f, 0.03065693f, 0.30244809f, 
    -0.06998748f, 0.19697349f, -0.33770734f, 0.21377805f, 0.22030091f, 0.34626165f, 0.30766043f, -0.06241390f, 
    0.19242176f, -0.18820576f, -0.14793719f, -0.20700715f, 0.41247916f, 0.12742452f, -0.28371802f, -0.30172768f, 
    -0.01711134f, -0.20601618f, 0.23103392f, 0.19917446f, -0.05115182f, -0.16060093f, -0.84396905f, -0.31617126f, 
    -0.15430239f, -0.33886117f, -0.46193933f, 0.58984345f, 0.37648901f, 0.02892292f, 0.21886733f, 0.49670541f, 
    0.18662447f, 0.14117472f, -0.16464543f, -0.11696289f, 0.12661888f, -0.26907113f, 0.18763915f, -0.28637776f, 
    -0.26088977f, -0.17953837f, -0.21933296f, -0.07634816f, -0.19068755f, -0.07218425f, -0.21358034f, 0.19353199f, 
    -0.33303830f, -0.42432731f, -0.80006105f, -0.65908313f, -0.24801986f, -0.24071971f, 0.21917053f, 0.26524264f, 
    0.12091302f, 0.18732761f, 0.31159824f, 0.00429710f, 0.00754480f, 0.40231532f, -0.05226429f, 0.02997883f, 
    0.07036376f, 0.09916874f, -0.12500885f, -0.16313696f, 0.16180119f, -0.16845430f, 0.04703800f, -0.16940559f, 
    -0.42704597f, -0.10179634f, 0.16742359f, 0.52201593f, 0.15615913f, 0.62455696f, -0.12706369f, -0.38535753f, 
    -0.21467912f, -0.43353847f, -0.07281892f, 0.05201948f, -0.07131593f, 0.22657827f, 0.03655076f, -0.03148286f, 
    -0.07102312f, 0.25595519f, -0.05359442f, -0.07736138f, 0.19149567f, -0.24958079f, 0.10253223f, 0.03744875f, 
    0.01940703f, 0.31919765f, 0.14118415f, -0.56385583f, 0.09448993f, 0.46986437f, -0.01310811f, 0.27772629f, 
    -0.23697376f, -0.31053510f, -0.23799077f, 0.07832713f, -0.24047050f, -0.30804566f, 0.17267445f, 0.04480514f, 
    0.31365213f, 0.14400256f, -0.19110066f, -0.08399895f, -0.07954907f, -0.17843099f, -0.18297958f, 0.18879649f, 
    0.14316842f, -0.04858269f, 0.04432127f, 0.10088134f, 0.08887497f, -0.23341078f, 0.06663287f, -0.15563296f, 
    0.13220093f, 0.21651489f, -0.17138855f, -0.32759795f, -0.10247841f, 0.56921303f, -0.28848001f, 0.15895499f, 
    -0.04857123f, 0.16348770f, 0.19664162f, -0.09989848f, -0.02648332f, -0.31602904f, 0.05698695f, -0.06016114f, 
    -0.21026824f, 0.03091408f, 0.35290372f, 0.80982286f, 0.24608223f, -0.64062762f, -0.22906487f, -0.95444304f, 
    -0.31475708f, -0.01230318f, 0.27047521f, 0.47651613f, 0.42209497f, 0.25243849f, -0.11069123f, 0.14661762f, 
    0.08056289f, -0.05861668f, -0.31005549f, -0.16124587f, 0.02369253f, 0.22567424f, -0.37817675f, 0.14657848f, 
    0.12766024f, 0.19108464f, -0.12185252f, 0.22875644f, 0.51497197f, 0.40115184f, 0.36570415f, -0.40361953f, 
    -0.68415344f, -0.01549564f, 0.07364468f, -0.02100116f, 0.04666331f, -0.29464912f, 0.41293758f, -0.22722100f, 
    -0.10083498f, -0.06528544f, -0.06334399f, -0.22950408f, 0.10735191f, -0.05134325f, 0.25153190f, -0.30932510f, 
    -0.09529987f, 0.34119236f, -0.17841232f, -0.18143919f, -0.32003939f, -0.41973114f, 0.00567392f, 0.00449971f, 
    0.29493874f, -0.07961537f, 0.14892247f, 0.09029993f, 0.22272380f, 0.00691874f, 0.36211786f, 0.14292587f, 
    0.11217666f, 0.17049421f, -0.30331331f, -0.30080512f, -0.24616554f, -0.19124517f, -0.08981373f, -0.01036954f, 
    0.26702216f, -0.17206316f, -0.21667153f, 0.14349711f, 0.21936586f, 0.20437212f, 0.46017796f, -0.38903609f, 
    -0.11567781f, -0.03723123f, 0.23433611f, -0.31410581f, 0.12460181f, 0.13811310f, -0.37645662f, -0.21761730f, 
    -0.06774289f, -0.09719976f, -0.07465557f, 0.08379637f, -0.40670604f, 0.26079786f, -0.11232119f, 0.16259933f, 
    -0.08474459f, -0.10812224f, -0.00268279f, 0.05995834f, 0.11035811f, -0.08781301f, 0.19115582f, -0.69033283f, 
    -0.46472579f, 0.26168069f, 0.05231372f, 0.45002231f, -0.32134151f, -0.06901073f, -0.41764075f, -0.11622272f, 
    -0.14801489f, -0.14301457f, 0.10620463f, -0.26844704f, -0.26996693f, -0.25843781f, 0.22257236f, -0.40789405f, 
    -0.23524787f, 0.15696202f, -0.18278851f, -0.17705579f, -0.24523644f, 0.04847068f, 0.09970224f, 0.22649008f, 
    0.17227650f, -0.49031916f, -0.78746212f, -0.65037489f, -0.40355876f, 0.38373253f, 0.15084088f, -0.10036215f, 
    -0.10586692f, -0.31390741f, 0.38475680f, -0.33692855f, -0.05038236f, 0.27479810f, -0.01165199f, -0.48052970f, 
    -0.23518491f, -0.24885494f, -0.07720032f, -0.45458367f, -0.24859113f, -0.17586473f, 0.37178653f, 0.15413855f, 
    0.11227059f, -0.38493773f, 0.12299604f, 0.06723297f, 0.19691598f, -0.22023790f, -0.27631360f, 0.09578133f, 
    0.27477244f, 0.19405781f, 0.25735673f, -0.04109031f, 0.07526511f, 0.27155200f, -0.39736316f, 0.04760708f, 
    -0.19738156f, -0.19696371f, -0.26207316f, 0.11852251f, 0.30915138f, 0.26068896f, 0.29446843f, -0.17658043f, 
    0.06838568f, -0.21308897f, 0.24150953f, 0.00548423f, 0.27988917f, -0.58409250f, -0.36404133f, -0.44436455f, 
    0.02082475f, -0.04069265f, 0.23159458f, -0.14378035f, -0.19181143f, -0.27226406f, 0.37753117f, 0.33385810f, 
    -0.25020775f, -0.07316919f, -0.03949862f, -0.15599784f, -0.37562570f, -0.41132736f, -0.02834000f, -0.30361632f, 
    -0.35618860f, -0.26629382f, -0.43642271f, -0.73718852f, 0.09665831f, 0.03388197f, 0.19726843f, 0.23824066f, 
    0.13010345f, 0.17627364f, -0.07999828f, -0.15123723f, 0.13841231f, -0.07858668f, -0.17850940f, -0.07970842f, 
    0.24893121f, 0.11464304f, -0.13425498f, -0.20447311f, -0.27522177f, 0.04519654f, -0.37728998f, 0.12149984f, 
    0.16078256f, 0.27359840f, 0.27871048f, 0.18146151f, 0.21460423f, -0.10822430f, 0.01310380f, 0.16878034f, 
    -0.16184172f, -0.39093679f, -0.17515896f, 0.25930509f, 0.01705350f, 0.00616249f, 0.44927064f, -0.31753740f, 
    0.26240695f, 0.26972228f, -0.44757220f, 0.11772627f, 0.24819063f, -0.26301283f, 0.09884720f, -0.31545767f, 
    0.06135468f, 0.11821239f, -0.28080791f, 0.05998863f, 0.30143973f, 0.83187264f, -0.45309874f, -0.23651811f, 
    0.38479683f, -0.59153855f, 0.40526462f, 0.34053895f, 0.13338776f, -0.59153050f, -0.53718424f, -0.19799781f, 
    0.04588488f, 0.12844039f, 0.06576026f, -0.04425701f, -0.20746253f, 0.33629355f, 0.24787968f, -0.14263305f, 
    -0.05703719f, 0.24842599f, -0.43245479f, -0.00318080f, -0.00600570f, -0.23656783f, -0.94263905f, -0.31169969f, 
    0.48295492f, -0.05142790f, -0.15090440f, -0.07701325f, -0.51649302f, 0.70493299f, 0.32142478f, -0.15118067f, 
    -0.10241152f, 0.05356709f, 0.14786275f, 0.12978728f, -0.02860366f, -0.15295643f, -0.27945557f, -0.07782184f, 
    -0.26451856f, 0.29000291f, 0.11301132f, -0.25514522f, 0.00814789f, 0.04119168f, 0.31222776f, -0.66708970f, 
    -0.57756436f, -0.33017316f, 0.44202569f, 0.49817580f, -0.14840326f, 0.37410203f, -0.31864661f, -0.10990416f, 
    -0.40151522f, 0.17089202f, 0.35119814f, -0.13473946f, 0.08088345f, 0.05567176f, -0.44375816f, 0.14350151f, 
    0.13105585f, -0.28283933f, 0.05769999f, 0.32408392f, -0.11836979f, -0.30505756f, 0.11194251f, 0.10763961f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02447883f, 0.08153327f, -0.07965606f, 0.19422580f, -0.24636231f, 0.13516156f, 0.01322552f, 0.10897136f, 
    0.28441066f, 0.09592999f, 0.01400301f, -0.28739303f, 0.29337776f, -0.35076109f, 0.34521627f, -0.25940502f, 
    0.23460570f, 0.03944043f, 0.06046113f, -0.33932731f, 0.17583400f, 0.07813534f, 0.15238547f, 0.07674094f, 
    -0.03925867f, -0.00684478f, 0.40500781f, -0.30184913f, 0.01506041f, 0.22050506f, 0.01906569f, 0.00474483f, 
    0.19061427f, 0.25380805f, 0.05581956f, 0.00731415f, 0.08507815f, -0.04504446f, 0.18154316f, -0.11786446f, 
    -0.18653286f, 0.00716233f, -0.06310382f, 0.00328261f, -0.23403281f, 0.42270026f, -0.04855518f, 0.23818941f, 
    0.09632894f, -0.04218148f, 0.02608297f, 0.36407170f, 0.28553399f, 0.27967766f, -0.04913441f, 0.18252574f, 
    -0.24213473f, 0.13555838f, -0.01110763f, 0.20106396f, 0.19543812f, 0.27946848f, 0.30921233f, 0.05536943f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.27130514f, -0.23913842f, -0.13338320f, -0.05297282f, 0.03640788f, 0.03756941f, -0.07053504f, 0.00737888f, 
    0.02282220f, 0.01488068f, -0.03752766f, 0.04878195f, -0.00978023f, -0.10543388f, -0.06568519f, 0.05330090f, 
    0.09865218f, -0.04978909f, -0.05603854f, 0.00232758f, -0.14666308f, 0.01129111f, 0.02068391f, -0.10078388f, 
    0.25215271f, 0.20885164f, -0.15829554f, -0.16771163f, 0.08388758f, 0.05376665f, 0.01465487f, 0.01401406f, 
    0.01996652f, 0.06267630f, 0.00853106f, 0.02071836f, 0.03945465f, -0.00553829f, -0.10379361f, 0.01026782f, 
    0.04384132f, 0.03378145f, -0.00732549f, -0.03408147f, -0.13925028f, -0.11753997f, -0.09414337f, -0.07703561f, 
    0.24827306f, 0.13232628f, 0.04640631f, -0.25323611f, 0.09447147f, 0.07846528f, 0.21109773f, -0.00609955f, 
    0.02661313f, -0.05089583f, -0.04051872f, 0.02506901f, 0.17667681f, 0.15318094f, 0.10432823f, -0.09256130f, 
    -0.08067233f, -0.01896323f, -0.05388695f, -0.21102399f, -0.22949252f, -0.12491864f, -0.00767556f, 0.01236582f, 
    -0.01877568f, 0.04037727f, 0.10064007f, -0.05226591f, -0.03678235f, -0.09167121f, -0.05710176f, -0.07180298f, 
    0.03964998f, 0.05093086f, -0.00138715f, -0.00744870f, -0.16621651f, 0.03849601f, -0.15606339f, 0.03711566f, 
    -0.07468979f, 0.00245700f, -0.02505353f, 0.00411635f, -0.08992404f, -0.00973329f, -0.01525074f, -0.15551007f, 
    -0.12979376f, -0.07257555f, -0.12502676f, -0.08915271f, 0.05574245f, -0.01639544f, 0.01184259f, 0.01513365f, 
    -0.06784979f, -0.19323234f, 0.02369409f, -0.04522907f, 0.18379320f, -0.14582053f, -0.04839893f, 0.05367853f, 
    0.10350839f, 0.16669822f, -0.10157558f, -0.21877040f, 0.01170556f, -0.10310095f, 0.04356458f, 0.05292937f, 
    0.00141122f, -0.16018322f, -0.21223997f, 0.10496985f, -0.11792720f, -0.10468869f, -0.01619446f, 0.04218741f, 
    -0.05068385f, 0.06956860f, 0.04307321f, 0.00536140f, -0.02354682f, -0.16706572f, -0.02632155f, -0.11874629f, 
    0.01369635f, -0.01180756f, 0.05389473f, 0.05329845f, 0.10174309f, 0.12618250f, -0.01363951f, 0.05613313f, 
    -0.27544343f, -0.10756588f, 0.29512629f, -0.70091224f, -0.22426958f, -0.07695480f, -0.00714901f, -0.09803376f, 
    0.04118433f, -0.00641718f, -0.05753292f, 0.01062768f, 0.35279375f, 0.24515872f, 0.10990288f, -0.04545592f, 
    0.03573500f, 0.20319633f, 0.13036832f, 0.12184288f, 0.03114998f, -0.02326004f, 0.11560533f, 0.13097058f, 
    0.26831034f, -0.08197526f, -0.40664828f, -0.15381998f, -0.09239890f, -0.05795387f, -0.02827022f, 0.01419271f, 
    -0.14701334f, -0.05388154f, -0.01770058f, 0.05120664f, 0.26031703f, 0.29207414f, -0.09663158f, -0.22418196f, 
    0.07854373f, 0.03301181f, 0.08327115f, 0.02218396f, -0.00532175f, -0.04788805f, -0.01936820f, -0.11882713f, 
    -0.02418687f, 0.21307829f, -0.09563113f, 0.04321049f, 0.02809264f, 0.01009001f, 0.00747077f, -0.05440067f, 
    -0.06497459f, -0.10052911f, -0.03662498f, -0.06234789f, 0.12158598f, 0.24756360f, 0.05039609f, -0.08840526f, 
    -0.06301156f, 0.16159005f, -0.02332709f, -0.18860443f, 0.04403226f, -0.10270844f, 0.00142106f, 0.00145123f, 
    0.02135846f, -0.01116136f, -0.14210114f, -0.14080504f, -0.04434505f, 0.05340052f, -0.02900643f, -0.00953948f, 
    -0.01977123f, 0.07377856f, 0.06127173f, -0.00959812f, 0.28456917f, 0.15873885f, -0.08823676f, -0.12720591f, 
    0.19246180f, 0.10620729f, 0.07128623f, 0.04108776f, -0.06150499f, -0.01700131f, 0.00623363f, 0.03523451f, 
    0.00390898f, -0.14028560f, -0.34286726f, 0.13022017f, 0.06868427f, -0.12382521f, 0.12031979f, -0.14790867f, 
    0.02172110f, -0.05628404f, -0.15842915f, -0.01836401f, 0.36441615f, 0.31522733f, 0.03504023f, -0.05597396f, 
    0.03848520f, 0.07773466f, 0.10530964f, 0.02636299f, 0.07258385f, 0.00270476f, 0.07896395f, -0.10322533f, 
    -0.28452873f, -0.08863086f, -0.29848698f, 0.13029730f, 0.00096872f, 0.02206798f, -0.01829657f, -0.09155795f, 
    -0.01252104f, 0.03159969f, -0.06447512f, -0.06035640f, 0.21022482f, 0.32418174f, -0.00326839f, -0.31828469f, 
    0.05664570f, 0.04065147f, 0.02273270f, 0.03420577f, 0.04190855f, -0.01741483f, -0.00688402f, -0.06653290f, 
    -0.30782568f, -0.24704202f, -0.05367346f, 0.09855208f, 0.02098522f, 0.00242549f, -0.06313606f, -0.06153941f, 
    -0.01673256f, -0.05682684f, 0.00203887f, 0.07032921f, 0.26540002f, 0.05128960f, -0.07958170f, 0.00317762f, 
    0.17648907f, 0.06234617f, 0.05217272f, -0.14725409f, -0.06507441f, -0.07987423f, 0.02765563f, 0.14513272f, 
    -0.72871774f, -0.33227411f, -0.23116395f, 0.11323611f, -0.00209519f, 0.00113693f, -0.01254245f, 0.01565067f, 
    0.00519157f, 0.04874720f, -0.01731750f, 0.04763194f, 0.18158370f, 0.14954090f, -0.04997992f, -0.12184207f, 
    0.14745466f, 0.34399080f, 0.08618756f, 0.23797294f, 0.00667742f, 0.00833564f, 0.02265123f, 0.05462470f, 
    0.16759640f, 0.12094913f, 0.24265097f, 0.01315853f, 0.05059076f, -0.00813479f, 0.06002291f, 0.02549548f, 
    -0.06048399f, 0.01577984f, -0.08389598f, -0.04833413f, 0.52590287f, -0.15814590f, -0.02710582f, -0.32416159f, 
    0.00812254f, -0.01396099f, 0.08145787f, 0.04696766f, -0.08400813f, -0.00179877f, -0.09344187f, -0.02911080f, 
    0.13584365f, 0.16463695f, -0.02664750f, -0.02138344f, -0.02079310f, -0.06771564f, -0.10329152f, 0.13681106f, 
    0.05501113f, -0.01574581f, 0.01409034f, -0.07361126f, -0.06179452f, 0.05606946f, -0.19626890f, -0.04600069f, 
    0.02024725f, 0.06714670f, 0.04453717f, 0.00532512f, -0.04488192f, -0.00799565f, -0.13540040f, -0.18613932f, 
    -0.31203797f, -0.11244656f, -0.06063156f, 0.18953414f, -0.10198236f, 0.01184480f, 0.01101168f, 0.03699310f, 
    -0.01433187f, -0.01274341f, 0.04023938f, -0.06211423f, 0.27910239f, 0.08155376f, -0.57252771f, -0.02116875f, 
    0.05448567f, 0.00497023f, 0.00183970f, -0.00254468f, -0.00824769f, -0.02913877f, 0.00525752f, -0.00054607f, 
    -0.04555654f, -0.05222469f, 0.00264681f, 0.01389885f, -0.07006618f, -0.14803274f, -0.08717906f, -0.10943466f, 
    -0.07176535f, -0.01782436f, -0.00965852f, 0.00570108f, -0.01357466f, -0.02740332f, -0.08856956f, -0.12307177f, 
    0.06870341f, 0.00751765f, -0.10578189f, -0.17523605f, -0.02783455f, -0.10607687f, -0.05264009f, -0.23943408f, 
    -0.18718013f, -0.06334643f, -0.21762082f, -0.02824624f, -0.00129353f, 0.01296550f, -0.01855478f, 0.02784426f, 
    -0.04358656f, 0.03333419f, 0.03866272f, 0.02043898f, 0.09199803f, 0.03913536f, -0.01637270f, -0.01930800f, 
    0.04658289f, 0.12730187f, -0.24352430f, -0.26117018f, -0.02515117f, -0.00009012f, -0.00653721f, -0.06274664f, 
    0.16318427f, 0.25199208f, 0.12474613f, -0.31887382f, 0.04432471f, -0.00519619f, 0.10453863f, -0.07358529f, 
    0.04369548f, -0.02680067f, 0.01048376f, -0.05069190f, -0.60459888f, -0.13644350f, 0.10649782f, 0.10227083f, 
    0.05056585f, 0.05218376f, -0.00157104f, 0.04336794f, -0.08921832f, -0.12559906f, 0.10175388f, 0.25819856f, 
    0.19766884f, 0.11418202f, -0.05268053f, -0.11944029f, -0.03014833f, -0.29970905f, 0.03310576f, 0.25445250f, 
    -0.00497735f, 0.09595510f, 0.01262623f, -0.04102833f, 0.17472757f, 0.00377397f, -0.33795494f, 0.03918042f, 
    0.02041678f, -0.13070694f, -0.04630001f, -0.01577159f, -0.07934120f, 0.03185361f, 0.04022815f, -0.03097622f, 
    0.11625597f, 0.18580581f, 0.03644475f, -0.22987650f, 0.00639950f, -0.04485135f, -0.04505220f, 0.04594482f, 
    0.00313981f, 0.00447441f, -0.00606391f, 0.05469991f, -0.04333271f, -0.11894589f, -0.10492930f, 0.11836478f, 
    0.02602229f, -0.06199277f, 0.00756925f, -0.02458483f, 0.03553761f, -0.01795421f, -0.02017266f, -0.02320443f, 
    -0.20928778f, 0.01336991f, 0.04286904f, 0.05074563f, -0.00041571f, 0.01141589f, 0.02854739f, 0.08410193f, 
    -0.06556404f, -0.02622616f, -0.06481344f, 0.18708380f, -0.51249677f, -0.21640207f, 0.18529242f, -0.16722187f, 
    -0.01472324f, -0.05846931f, 0.10521442f, 0.04990495f, -0.15293157f, -0.10468909f, -0.07398370f, 0.01277254f, 
    0.01249520f, -0.08954325f, -0.04617951f, 0.02391895f, 0.06354255f, 0.06575767f, 0.02192967f, 0.01219349f, 
    0.05150403f, 0.05921456f, -0.03600965f, -0.04636662f, 0.22575714f, 0.03689045f, 0.04538495f, 0.05384497f, 
    0.06978896f, 0.06407781f, -0.16944695f, -0.22033909f, -0.02941559f, -0.02492595f, 0.04680462f, 0.07791497f, 
    0.12933426f, -0.02392819f, -0.10976838f, -0.01921000f, -0.03501768f, -0.17312008f, -0.07788698f, -0.08859484f, 
    -0.05914376f, -0.10033549f, 0.02673115f, -0.08114637f, -0.22469291f, -0.14281127f, 0.09212356f, 0.09063014f, 
    -0.04170980f, -0.02111569f, 0.02609496f, -0.02552278f, -0.00139927f, 0.01251539f, 0.00472671f, -0.00950414f, 
    -0.03610804f, 0.00021648f, 0.02767655f, 0.03422091f, -0.12469576f, -0.21517418f, -0.06999856f, -0.07416628f, 
    -0.04388320f, 0.00070412f, -0.03962005f, -0.08606711f, -0.27332312f, -0.48983786f, -0.09484868f, 0.09871872f, 
    0.04627956f, -0.06937114f, -0.08923513f, -0.04210635f, -0.10796618f, -0.25361884f, -0.18715933f, -0.04956821f, 
    -0.27231631f, -0.60086125f, -0.16280198f, 0.00395263f, -0.03388584f, 0.05880534f, -0.06781178f, 0.02714936f, 
    -0.07566110f, -0.18056257f, 0.02089730f, 0.11110783f, -0.16958934f, -0.37969819f, -0.00862832f, -0.07597338f, 
    -0.02678411f, 0.00320851f, 0.08576638f, 0.04811322f, 0.01987193f, -0.04152868f, 0.03863620f, -0.09824347f, 
    0.10834941f, 0.00066311f, -0.17640907f, -0.15768225f, 0.05089247f, 0.01485459f, 0.00193468f, -0.03348648f, 
    -0.03003717f, 0.03177997f, 0.01273744f, -0.01869516f, 0.35515761f, 0.27161342f, -0.05409383f, -0.13933247f, 
    0.02048770f, 0.00917507f, 0.06429379f, 0.02796513f, -0.02938411f, -0.09005515f, -0.07815759f, -0.14026253f, 
    0.23327884f, 0.03320175f, -0.31918749f, 0.00058047f, 0.09099485f, 0.10579528f, -0.22847782f, -0.14996508f, 
    -0.09027220f, -0.16765790f, -0.15366027f, -0.08614160f, -0.16536312f, -0.09368524f, 0.10489792f, -0.00541231f, 
    -0.00433493f, -0.10698174f, 0.02542953f, -0.01085752f, -0.07126197f, -0.07439474f, -0.00951691f, -0.18228163f, 
    0.01451584f, -0.01414004f, 0.11553045f, -0.00674142f, -0.01688993f, -0.08509950f, -0.16519004f, 0.01706331f, 
    0.04985394f, -0.07948306f, 0.10361804f, 0.16424286f, -0.06700213f, 0.03486544f, 0.04779536f, -0.10722481f, 
    0.01688744f, -0.04715497f, 0.05291134f, -0.01365526f, -0.03432919f, -0.00934228f, -0.06720969f, -0.12731870f, 
    -0.21729086f, -0.04546551f, 0.02699707f, -0.10669085f, -0.16225037f, -0.05875405f, -0.01470943f, 0.07540709f, 
    -0.10241795f, -0.10559295f, -0.03941695f, -0.05362583f, 0.06893510f, -0.36975959f, -0.01560093f, -0.12596747f, 
    -0.02984304f, -0.10637517f, -0.16803023f, -0.06875993f, -0.11517733f, 0.01602043f, -0.00623357f, 0.05927641f, 
    0.01208829f, -0.06957808f, 0.31859660f, -0.16477495f, -0.04803521f, -0.06050956f, 0.14581746f, -0.01091771f, 
    -0.04149851f, -0.13045181f, 0.02697446f, -0.11039855f, 0.15341850f, 0.23537463f, -0.03202674f, -0.18273699f, 
    0.00299239f, 0.02468760f, 0.06870306f, -0.15413344f, -0.06401888f, -0.04768584f, -0.03370062f, -0.05062569f, 
    -0.08735811f, -0.08019538f, 0.02701039f, 0.14021099f, -0.00854367f, -0.06376566f, -0.01946034f, -0.04488932f, 
    -0.02870029f, 0.09059022f, -0.01601365f, 0.02937882f, -0.07484679f, 0.02821983f, -0.09059635f, 0.14725775f, 
    -0.04852778f, -0.05101249f, 0.27616903f, -0.16193627f, -0.06017599f, 0.07023840f, 0.07982703f, 0.04074186f, 
    -0.12346031f, 0.11672353f, 0.16407084f, 0.14080329f, -0.03157032f, -0.12441394f, 0.09470589f, -0.18218252f, 
    -0.10194649f, -0.01629225f, -0.00346153f, -0.02140398f, -0.04689979f, -0.23468705f, -0.11357225f, -0.02972248f, 
    0.02878435f, 0.03337266f, 0.02705902f, 0.00314710f, 0.08303037f, 0.08078664f, -0.01329163f, 0.08421009f, 
    -0.04227594f, 0.12240476f, 0.08648390f, 0.05877227f, 0.05906673f, 0.15784739f, -0.34811574f, -0.15758705f, 
    -0.00128646f, 0.00009253f, -0.00751343f, -0.02773993f, -0.00555455f, 0.19602664f, -0.11568341f, -0.01475198f, 
    0.09746546f, 0.09520251f, -0.04595247f, -0.03454596f, 0.00215684f, 0.07427122f, 0.08104073f, -0.15198998f, 
    -0.09529858f, 0.05756198f, -0.07227187f, -0.06014960f, 0.14758144f, -0.07970384f, -0.05231157f, 0.13439745f, 
    -0.02810863f, 0.07506825f, -0.02280275f, 0.03278607f, 0.11110412f, 0.02493908f, 0.14730740f, -0.04301126f, 
    -0.03664026f, 0.09628990f, -0.05894883f, -0.03540917f, -0.04951689f, 0.01530633f, -0.04206637f, -0.01725537f, 
    -0.27842104f, -0.13842970f, -0.17546947f, 0.08971827f, -0.02204344f, 0.04873440f, 0.17222756f, -0.09312599f, 
    0.06945585f, 0.08478776f, -0.08727220f, -0.01563094f, -0.03825848f, -0.22434294f, -0.04287507f, -0.16952761f, 
    -0.01501004f, 0.10046525f, 0.05734710f, -0.15930587f, 0.02167760f, 0.05506377f, 0.02750420f, -0.06275391f, 
    0.06786468f, 0.10524005f, -0.12605102f, -0.15354079f, -0.11164013f, -0.20356582f, -0.08801815f, -0.11556200f, 
    0.02255370f, 0.02153950f, 0.01833200f, 0.06635965f, 0.37484682f, 0.32433030f, 0.22879198f, 0.23069720f, 
    -0.03887679f, -0.03703896f, -0.04931821f, 0.02240831f, 0.09550600f, 0.09252835f, 0.19978824f, 0.09651651f, 
    -0.31987739f, 0.28734016f, -0.04070656f, -0.02269987f, -0.08965268f, 0.14275540f, 0.01681042f, -0.02864249f, 
    -0.05221351f, -0.06972126f, 0.04105701f, -0.00646645f, 0.11624695f, 0.26054004f, -0.02901240f, 0.09132506f, 
    0.01853008f, -0.15637714f, -0.23196031f, -0.25010246f, 0.00647615f, -0.09007128f, -0.24713859f, -0.20925719f, 
    0.17023458f, -0.14669546f, -0.12419328f, 0.07597097f, 0.09439705f, -0.04857884f, 0.04790530f, -0.04300848f, 
    0.21621078f, -0.24963620f, 0.13241878f, 0.10564388f, 0.01795991f, -0.00432692f, -0.04452346f, 0.12482668f, 
    -0.10387122f, 0.11776235f, -0.03566978f, -0.02963303f, -0.03576966f, -0.00364166f, -0.01885049f, 0.05246604f, 
    -0.01739871f, -0.34451443f, -0.04795166f, 0.17864124f, -0.07921779f, 0.09644669f, 0.11912321f, -0.00914843f, 
    0.11054302f, -0.08944188f, 0.07379517f, -0.06503125f, -0.18829931f, 0.06924092f, -0.05073088f, -0.01853698f, 
    0.19344364f, -0.01872269f, 0.04882975f, 0.05408794f, -0.05820364f, 0.06314809f, 0.08365605f, -0.08168525f, 
    0.10691486f, -0.09888756f, -0.02329382f, -0.42009866f, -0.09434501f, -0.15224777f, -0.02415231f, 0.05608218f, 
    0.04694683f, -0.04254116f, -0.01613412f, 0.01113665f, 0.15554877f, 0.21723971f, 0.18398297f, 0.33882535f, 
    -0.10306960f, 0.09260856f, -0.24837255f, -0.12159069f, -0.02726457f, -0.00255928f, -0.01120698f, 0.02883301f, 
    0.83360112f, -0.04007594f, -0.24495463f, 0.02018333f, -0.02268003f, -0.07254361f, 0.09805676f, -0.12280014f, 
    0.11439029f, -0.06046114f, -0.04741697f, -0.12051114f, 0.11028419f, -0.06244596f, -0.32341960f, -0.06727912f, 
    -0.11048637f, -0.00663710f, 0.03845825f, -0.09478684f, 0.04080930f, -0.11473769f, -0.25513938f, 0.07856853f, 
    0.09275626f, 0.03530342f, 0.02705447f, 0.08820195f, 0.06056947f, -0.08355188f, 0.00168722f, 0.03439886f, 
    -0.04756734f, 0.02086093f, 0.06638262f, 0.07488885f, -0.30158085f, -0.03399586f, -0.13217521f, -0.07698100f, 
    0.05169534f, 0.18934083f, 0.05670871f, 0.03128465f, -0.00795124f, 0.00028620f, -0.01437351f, 0.04880482f, 
    0.62491399f, -0.09314608f, 0.18605624f, -0.07071270f, -0.06819633f, -0.04069875f, 0.00287985f, 0.11239272f, 
    -0.20037815f, -0.08840185f, 0.12319230f, -0.13964495f, 0.02186715f, -0.09081815f, -0.14003319f, -0.10092674f, 
    -0.04576229f, 0.02978306f, 0.08040733f, 0.00100075f, 0.05499018f, 0.02959646f, 0.10340884f, -0.01585297f, 
    0.19736479f, 0.23437394f, 0.43304285f, 0.13701439f, 0.01164604f, 0.00963738f, 0.01786155f, -0.00720377f, 
    0.00596484f, 0.04629591f, 0.00031122f, 0.09492026f, 0.26601559f, 0.34413448f, 0.09238022f, -0.01861570f, 
    -0.01044565f, 0.01442115f, -0.17402136f, -0.18736327f, -0.11513476f, 0.02573968f, -0.09896574f, 0.01636373f, 
    -0.46543476f, -0.04610028f, -0.09511209f, -0.17977968f, 0.00673153f, -0.03925899f, 0.01926802f, -0.04245109f, 
    0.11739109f, 0.06874114f, 0.09815473f, -0.24389745f, 0.18001388f, -0.24005498f, 0.20033026f, -0.11122773f, 
    0.05541691f, 0.02417533f, 0.09357496f, 0.01126711f, 0.08106534f, -0.13265517f, 0.14693157f, -0.16104861f, 
    -0.04372625f, -0.06822353f, -0.25984302f, 0.02064848f, -0.03389598f, -0.18341322f, 0.04984163f, 0.08829185f, 
    -0.08595917f, -0.07653850f, 0.07072008f, 0.14160845f, -0.02528816f, 0.08237667f, -0.02370080f, -0.02195184f, 
    -0.05699654f, -0.03288269f, 0.04826481f, 0.00482894f, -0.05239571f, -0.07552460f, 0.09317220f, 0.00901187f, 
    0.24283375f, -0.35169283f, 0.22933529f, 0.03692855f, -0.21494585f, -0.19008279f, 0.12800664f, -0.03898620f, 
    -0.05592175f, -0.04903385f, 0.01777349f, 0.04325899f, -0.13372320f, -0.26167440f, 0.01619182f, -0.13782908f, 
    0.04739510f, 0.13740860f, 0.11913501f, 0.06280275f, 0.09777006f, 0.13694711f, 0.08683350f, 0.05025352f, 
    0.04956589f, 0.00687747f, -0.01658562f, 0.01556369f, 0.03578078f, 0.00679427f, 0.06156570f, -0.09300045f, 
    -0.02149191f, -0.10481148f, -0.02815036f, 0.04015834f, -0.05774552f, 0.08856800f, 0.02238906f, -0.20895238f, 
    -0.08787217f, 0.11214267f, 0.03865633f, 0.07287434f, -0.01594581f, -0.03596346f, 0.03080509f, -0.03252881f, 
    0.12945485f, 0.11810824f, 0.13183850f, 0.14027099f, 0.03907827f, -0.02705653f, 0.01811752f, 0.00632083f, 
    -0.01317911f, -0.04842164f, -0.05156253f, 0.10537835f, 0.07738066f, 0.38454926f, 0.00939292f, -0.32081693f, 
    0.10113533f, -0.00125801f, 0.03568747f, -0.03391564f, 0.04038985f, 0.05487350f, 0.02108859f, -0.00571359f, 
    -0.31141806f, 0.06494946f, -0.20511758f, -0.10740761f, -0.01643110f, 0.02686533f, -0.09475617f, 0.04123368f, 
    -0.02442231f, -0.03893020f, -0.10705166f, 0.11552700f, -0.02057729f, -0.05554774f, 0.17035815f, -0.02571624f, 
    0.01773286f, 0.04534753f, -0.05940399f, -0.00177463f, 0.06135354f, -0.11696762f, -0.16907494f, -0.22000600f, 
    0.24605620f, 0.02253202f, -0.38930717f, -0.25289059f, -0.15353386f, 0.10274557f, -0.13151792f, -0.08514522f, 
    -0.00987650f, 0.02686031f, -0.06463569f, -0.01401634f, -0.03189978f, 0.02719872f, -0.36191893f, 0.17761247f, 
    -0.14034006f, -0.11529120f, 0.06952307f, 0.05338944f, 0.06548961f, 0.02389867f, -0.06044393f, 0.00740336f, 
    0.15548320f, 0.12502734f, -0.12906837f, -0.08147957f, -0.03601225f, -0.05240485f, -0.03238707f, 0.06500445f, 
    0.02522619f, 0.02607636f, -0.10256166f, -0.23641858f, 0.20356388f, -0.20130116f, 0.28995630f, -0.05256332f, 
    -0.07970037f, 0.02290966f, 0.05607000f, 0.02615216f, -0.07730656f, -0.03109943f, 0.12737347f, -0.07521825f, 
    -0.10583352f, 0.07993887f, 0.09112880f, -0.07267661f, -0.04731053f, 0.02917141f, -0.11832409f, 0.04184679f, 
    -0.39514029f, -0.54727495f, -0.14944898f, -0.11150977f, 0.00398361f, -0.01357588f, 0.20414135f, 0.07690027f, 
    0.05154736f, 0.04701744f, -0.04822556f, 0.04882582f, -0.08565943f, -0.01291072f, -0.15215074f, 0.12157643f, 
    0.14438401f, -0.10146013f, -0.26932958f, -0.22466223f, -0.00055775f, -0.03285372f, -0.06620181f, -0.01362942f, 
    -0.22131820f, -0.26067504f, -0.17000148f, -0.30418983f, -0.18615678f, -0.12624574f, 0.01487712f, -0.08169445f, 
    0.05890802f, 0.19292083f, -0.12759618f, -0.16639236f, -0.04084961f, 0.09816908f, -0.03990615f, 0.00641282f, 
    -0.05373701f, -0.05750671f, -0.03456590f, -0.00863065f, 0.14447728f, -0.01251327f, -0.01697462f, 0.12096470f, 
    0.07182934f, -0.01068647f, 0.08267861f, 0.03138304f, 0.11794352f, 0.06318407f, 0.11038042f, 0.13555512f, 
    -0.08657078f, -0.05306097f, 0.03075575f, -0.03830586f, -0.03435223f, 0.07674635f, 0.04279760f, -0.01573823f, 
    0.08680049f, -0.03314654f, -0.00789667f, -0.00784998f, -0.08984318f, 0.08825224f, 0.05882598f, -0.06287774f, 
    0.07485035f, -0.02588479f, -0.06667180f, 0.07760453f, 0.05443267f, -0.01943574f, 0.12567531f, -0.30881774f, 
    -0.00564695f, 0.08264890f, 0.00123070f, 0.08664983f, 0.09152390f, 0.11116118f, 0.01158756f, -0.08931071f, 
    0.22625342f, -0.16243222f, 0.09605019f, -0.18254426f, -0.00000001f, -0.04024073f, 0.02141797f, 0.05115941f, 
    -0.02702851f, -0.03790111f, 0.00025289f, -0.08453110f, 0.05995875f, 0.19399035f, 0.06444899f, 0.06573910f, 
    -0.01481088f, 0.02387495f, -0.00227485f, -0.01366100f, 0.04852530f, 0.07838721f, -0.06361088f, 0.17768402f, 
    0.17061858f, 0.06975597f, -0.08097343f, -0.19746637f, -0.16286278f, 0.12184028f, 0.01298213f, -0.18202481f, 
    -0.08302719f, -0.02118124f, -0.02912373f, 0.03334380f, -0.06612127f, -0.08362801f, -0.16361475f, -0.05947391f, 
    -0.10241014f, -0.02859403f, 0.10842291f, 0.03610914f, 0.07484902f, 0.04513851f, -0.07277083f, -0.04675993f, 
    0.11661984f, 0.03389781f, 0.20283651f, -0.10189481f, 0.07834279f, 0.10774368f, 0.23293449f, 0.22407669f, 
    0.13482128f, -0.03586187f, -0.06299040f, -0.06928589f, 0.01508519f, 0.05960244f, 0.01784850f, 0.02075871f, 
    0.06956102f, 0.00228421f, -0.01387439f, -0.02573232f, -0.00787214f, 0.09078306f, -0.10632505f, 0.09794004f, 
    0.04073864f, -0.27331281f, -0.04533291f, -0.03406218f, -0.00443324f, 0.01736636f, 0.00332287f, 0.03397311f, 
    -0.13720199f, -0.05406257f, -0.03015765f, -0.21248066f, -0.14633806f, -0.14678617f, 0.08580223f, 0.14143163f, 
    0.02494195f, -0.08603413f, 0.11369933f, -0.00497750f, -0.02177870f, -0.05521676f, 0.10969500f, -0.04344079f, 
    -0.18403131f, 0.10971180f, 0.09537920f, -0.10405091f, 0.09264850f, 0.14397641f, 0.10623605f, 0.03025508f, 
    -0.00918632f, -0.13273853f, -0.05136362f, 0.05893496f, 0.43193924f, 0.00355066f, 0.21321183f, -0.31019440f, 
    -0.02241650f, 0.03125599f, -0.04197092f, -0.08527152f, 0.11733711f, -0.23902881f, 0.17241932f, 0.19277990f, 
    -0.81781632f, -0.17215449f, -0.23519936f, -0.25357136f, -0.02179751f, 0.10824382f, 0.14151672f, 0.00340891f, 
    0.16756432f, 0.02813360f, 0.08185855f, 0.12356063f, -0.24505834f, -0.13817862f, -0.07062760f, -0.03582355f, 
    0.01326664f, -0.09620731f, 0.06996058f, -0.03316464f, 0.16984099f, -0.05508523f, 0.00382068f, -0.04808323f, 
    -0.20316544f, 0.21629938f, -0.17801897f, -0.11300043f, 0.02268052f, -0.05987382f, -0.03268524f, 0.07319305f, 
    -0.04292370f, -0.02937371f, 0.12170380f, -0.25141001f, 0.03986389f, -0.07561729f, -0.01729226f, -0.05779401f, 
    -0.06905373f, -0.24106137f, 0.24091694f, -0.01738873f, 0.05591331f, 0.00996823f, -0.01497170f, 0.00133372f, 
    -0.36867192f, -0.32715949f, 0.04755825f, -0.14825590f, -0.01300616f, -0.03956260f, 0.05628092f, -0.04640614f, 
    0.07808872f, 0.03857234f, 0.03591768f, 0.00451956f, 0.07056397f, -0.00908669f, 0.03425104f, 0.00574806f, 
    -0.01168735f, -0.03250250f, 0.00251730f, -0.00037217f, -0.17705403f, -0.23013638f, 0.02720575f, 0.02103945f, 
    -0.10827693f, -0.36293849f, -0.28835592f, 0.07864571f, -0.01333871f, 0.10667669f, -0.13679771f, -0.02665415f, 
    -0.03372738f, -0.00316513f, 0.03865298f, -0.02866516f, -0.08680531f, 0.13808696f, 0.13492221f, 0.20542428f, 
    -0.01284170f, 0.03291023f, 0.00011901f, -0.05001572f, -0.14989462f, 0.05331754f, -0.17729726f, 0.04661246f, 
    -0.09451008f, -0.03214731f, -0.01973658f, -0.04101615f, -0.10830389f, -0.10798579f, -0.11575191f, 0.04702322f, 
    0.03340527f, -0.00182371f, -0.01514654f, 0.00887268f, 0.26381546f, -0.14524063f, 0.08290120f, -0.08287145f, 
    0.13610800f, 0.10970819f, -0.08215957f, 0.00901643f, -0.05288421f, 0.05124880f, 0.06326852f, 0.02444688f, 
    0.13744535f, 0.35416073f, -0.03222533f, 0.07741503f, -0.01739915f, -0.04315311f, 0.07584146f, -0.04959239f, 
    0.02995829f, -0.02003917f, 0.09223491f, -0.16568215f, 0.10327365f, 0.17812081f, 0.13950498f, 0.10262854f, 
    -0.01084599f, -0.02961862f, 0.12392329f, -0.08276842f, -0.00544968f, 0.05134460f, -0.05082712f, 0.09670022f, 
    -0.26659745f, 0.12119249f, 0.04322836f, -0.53174978f, 0.10216544f, -0.33824825f, -0.21328512f, -0.03121153f, 
    -0.05689091f, 0.00285338f, -0.01710794f, 0.04319964f, -0.43316859f, -0.21416169f, -0.54285854f, -0.04944992f, 
    -0.01788299f, -0.00943788f, -0.03079545f, 0.01921281f, -0.01329988f, -0.05443053f, -0.00735682f, -0.05178680f, 
    -0.04463271f, 0.21930560f, -0.26666307f, 0.44683281f, -0.01429603f, 0.02606197f, -0.12509939f, 0.02150192f, 
    -0.00047907f, 0.03795082f, -0.03434561f, 0.01271011f, -0.31246433f, 0.04234986f, 0.07584361f, 0.10563172f, 
    0.01274372f, -0.02936252f, -0.06145558f, 0.05510036f, 0.03319569f, -0.01856784f, 0.00337363f, 0.03011118f, 
    -0.00955676f, -0.02011505f, 0.23604864f, -0.18061318f, -0.03669211f, 0.02380268f, -0.02043146f, -0.07976874f, 
    0.06544470f, -0.01943372f, 0.20904399f, 0.04461777f, -0.48619536f, -0.56682473f, -0.18085144f, -0.38412866f, 
    0.21541385f, -0.00516759f, -0.10272909f, -0.03731458f, -0.01925309f, -0.05528677f, 0.02260959f, -0.06259517f, 
    0.31754240f, -0.15469122f, -0.03764610f, 0.13374560f, -0.10311499f, 0.06366897f, 0.01056799f, -0.03541306f, 
    -0.04684286f, 0.01524923f, 0.08230121f, -0.11547979f, -0.06723094f, -0.09161042f, -0.10756774f, 0.08576848f, 
    -0.05554277f, 0.07433935f, 0.02656703f, -0.12922910f, -0.08831038f, 0.03407803f, -0.01157464f, -0.00417110f, 
    -0.19524930f, -0.10386965f, 0.24338840f, -0.59834009f, 0.06843381f, -0.06045159f, -0.30625454f, -0.14111444f, 
    0.00540430f, -0.00550303f, 0.00042137f, 0.04236236f, -0.53260499f, -0.34199613f, -0.14633135f, -0.29570121f, 
    -0.12330677f, 0.03381225f, 0.11820339f, -0.09614258f, 0.03221015f, -0.04996138f, 0.02816771f, -0.02940076f, 
    -0.13709317f, 0.25083217f, 0.43255940f, -0.03109083f, -0.09117967f, 0.09087126f, -0.08772942f, -0.03685372f, 
    0.05835842f, 0.07687189f, 0.04436399f, 0.01341142f, -0.07739314f, 0.20202553f, -0.02507497f, 0.28303972f, 
    0.04886330f, 0.03811671f, -0.06515834f, 0.17688870f, 0.18116039f, -0.00672017f, 0.14712904f, -0.09002511f, 
    -0.12351661f, -0.00422636f, 0.11146957f, -0.01778076f, -0.00484182f, -0.09990383f, 0.04018695f, 0.07122178f, 
    -0.03531504f, -0.01362785f, 0.00990931f, 0.02256461f, -0.63928056f, -0.34266484f, -0.51485735f, -0.12518989f, 
    0.06020405f, 0.08823930f, 0.02921675f, -0.10525419f, -0.05206108f, -0.00957919f, -0.01429180f, -0.01846481f, 
    -0.05364770f, 0.05752848f, 0.17266349f, -0.37493929f, 0.01714663f, -0.03023437f, -0.08281391f, 0.08895923f, 
    -0.02179203f, 0.07731255f, 0.00926211f, -0.07920252f, 0.06958287f, 0.07070585f, 0.12824652f, 0.05580257f, 
    -0.06842157f, -0.10415228f, 0.07679036f, 0.03402792f, -0.21564695f, 0.09456360f, 0.01302988f, -0.01678314f, 
    -0.13531858f, -0.30468565f, 0.32330531f, -0.11483511f, 0.02158922f, -0.02369930f, 0.02689522f, -0.01596700f, 
    0.05595274f, -0.05732021f, -0.00742024f, 0.04065618f, -0.23277430f, 0.54733491f, 0.35031080f, 0.51274753f, 
    -0.29277328f, -0.04515012f, 0.05863132f, -0.00623888f, 0.02388607f, 0.00763133f, -0.04233745f, 0.03545395f, 
    -0.13961785f, 0.03595810f, -0.22762734f, 0.13949127f, -0.07745646f, 0.01857276f, 0.00691946f, 0.05040593f, 
    -0.05847122f, 0.01800173f, 0.03449176f, -0.15551710f, 0.23680189f, -0.12461958f, 0.48588338f, 0.30636790f, 
    0.01001329f, -0.01383093f, 0.05709298f, 0.01859904f, 0.08190660f, -0.05986814f, 0.04944738f, -0.02982733f, 
    -0.36838174f, -0.31583780f, -0.05396364f, -0.07197057f, 0.00675680f, -0.05570067f, -0.08804686f, 0.04593363f, 
    0.02565042f, -0.05127135f, 0.01243880f, -0.03526468f, -0.04131228f, -0.31799206f, 0.01425269f, 0.11355424f, 
    0.03011646f, 0.03536732f, 0.03803022f, -0.00323047f, 0.02922896f, -0.28843391f, -0.17622447f, -0.08330237f, 
    0.33837113f, -0.36967203f, 0.04254752f, -0.39956364f, -0.01859020f, -0.05527667f, 0.02742446f, -0.00777303f, 
    -0.00700364f, -0.05166367f, -0.04330423f, 0.04295094f, -0.18557499f, 0.00507820f, 0.15560973f, -0.09044836f, 
    -0.13258268f, -0.09318669f, 0.01601208f, -0.27249685f, 0.07851125f, 0.04886401f, 0.03526763f, 0.01558354f, 
    -0.05425370f, -0.00984425f, 0.01805824f, -0.04263624f, 0.04216203f, -0.00098473f, -0.02328567f, 0.09236504f, 
    0.00354486f, -0.04325104f, -0.02287193f, -0.02303065f, -0.16267508f, 0.00786020f, -0.01939874f, -0.00018292f, 
    -0.02412087f, 0.08626031f, -0.03231701f, -0.07991434f, 0.00360461f, 0.02002881f, -0.06436023f, -0.03465828f, 
    -0.25585207f, -0.03253896f, 0.02861917f, -0.19693696f, -0.02638861f, -0.00624665f, -0.03108842f, 0.05872254f, 
    0.03087391f, 0.00595111f, -0.06749804f, 0.01200202f, -0.18258557f, 0.44428441f, 0.47423446f, 0.18308182f, 
    0.07190930f, 0.09278405f, -0.07315955f, -0.05775428f, -0.03976288f, -0.00762377f, -0.00902465f, 0.03493226f, 
    0.20850903f, 0.07314613f, 0.00876241f, -0.03300291f, 0.00898762f, -0.04752526f, -0.07243728f, 0.08780020f, 
    0.01264400f, -0.00468281f, 0.01660473f, -0.03103207f, -0.18245280f, 0.03125507f, -0.01720702f, 0.07212789f, 
    -0.02415382f, -0.03366575f, 0.02171002f, -0.12588930f, 0.11282517f, 0.20298490f, 0.09354473f, 0.20423648f, 
    -0.61748505f, -0.00571894f, -0.11848676f, 0.00759253f, 0.10516410f, 0.02306730f, -0.00047292f, -0.10691900f, 
    0.01400801f, 0.02014822f, -0.14273575f, 0.00455017f, -0.09424530f, -0.00155056f, -0.10308249f, 0.04239815f, 
    -0.10987000f, -0.04909727f, 0.02552544f, -0.00321156f, 0.03157704f, 0.04281517f, -0.09381445f, 0.01314154f, 
    -0.19187227f, 0.16151860f, 0.03693232f, -0.25289056f, 0.03924713f, 0.01444655f, -0.08785128f, -0.03903840f, 
    -0.01692014f, -0.05554210f, 0.01060263f, -0.02049492f, 0.09467955f, -0.12962188f, -0.02577681f, -0.05584297f, 
    0.04826835f, -0.00534747f, -0.01700810f, -0.10544708f, -0.04571308f, 0.00729072f, -0.04360284f, -0.19418080f, 
    0.04133333f, 0.03945043f, -0.04543073f, -0.10881982f, 0.01090232f, -0.02372204f, -0.07035223f, -0.06391258f, 
    0.14166054f, 0.03559155f, 0.19857012f, 0.07721157f, 0.17387255f, -0.11002972f, -0.12206230f, 0.09799895f, 
    -0.01947076f, 0.07174271f, 0.04181714f, 0.01657214f, 0.05420573f, -0.00162380f, -0.22116075f, 0.22214539f, 
    0.19841985f, 0.07922021f, 0.37071311f, 0.18697934f, 0.01976132f, 0.00965423f, 0.00294462f, -0.02773635f, 
    0.03194101f, -0.00533095f, -0.10259189f, 0.11797071f, -0.08156486f, 0.21125837f, 0.11749434f, 0.08420862f, 
    -0.08991553f, 0.00442746f, 0.06651427f, 0.00320103f, 0.11264636f, 0.09666729f, -0.03681721f, 0.04392951f, 
    -0.07595678f, 0.16381171f, -0.05355895f, -0.00464637f, -0.04896333f, -0.17939386f, -0.09901454f, 0.23855425f, 
    0.00480892f, 0.02044895f, 0.01460255f, -0.01969960f, -0.01049021f, -0.16890475f, -0.09391496f, 0.03008718f, 
    0.00228072f, -0.07215609f, 0.06279977f, -0.06139696f, -0.00450665f, -0.00130127f, -0.04019311f, 0.07831001f, 
    -0.00835171f, -0.05506735f, -0.03281859f, 0.08018330f, -0.23650737f, -0.06690333f, -0.06780332f, 0.06547254f, 
    0.04855891f, -0.02957661f, -0.10979597f, 0.03313952f, -0.37970427f, 0.36725897f, -0.03998931f, 0.05439857f, 
    0.02780844f, 0.11816096f, -0.07938738f, 0.02056219f, -0.00572413f, -0.08510038f, 0.01430155f, 0.07460702f, 
    -0.10314791f, 0.08760504f, 0.11009238f, -0.17957829f, 0.03855467f, -0.06575458f, -0.11568145f, 0.01079283f, 
    0.14580624f, 0.00705107f, -0.12469105f, 0.27382663f, -0.10954385f, 0.00425014f, -0.06135085f, 0.02305903f, 
    -0.03273613f, -0.04373637f, -0.03929327f, 0.05521927f, -0.01591931f, -0.03920131f, 0.04283337f, -0.19015038f, 
    -0.07286924f, -0.19572923f, -0.04819590f, 0.19390641f, -0.17751054f, 0.00390805f, 0.04114774f, 0.00596012f, 
    0.02261281f, -0.04597990f, 0.03437078f, -0.02312586f, 0.09518488f, 0.14129397f, -0.16064441f, 0.03544123f, 
    0.00522740f, 0.06714652f, 0.04710606f, 0.10463296f, -0.02514926f, -0.07384700f, 0.07444531f, 0.03908126f, 
    -0.38406056f, 0.19198625f, 0.42693910f, -0.22664623f, -0.05850423f, -0.12097079f, 0.15231088f, -0.11935190f, 
    -0.08934177f, -0.11815773f, 0.06894080f, -0.13461292f, 0.05704083f, -0.06204435f, -0.09224195f, 0.08108409f, 
    0.02203651f, 0.02196133f, 0.06896430f, 0.03847630f, 0.03136568f, -0.09434662f, 0.01225732f, -0.07343857f, 
    -0.07460652f, -0.04390809f, -0.08947564f, 0.02016309f, -0.11029696f, -0.01288562f, 0.10136738f, -0.08215494f, 
    0.04435505f, 0.08507417f, 0.11142427f, 0.11498573f, 0.00203803f, -0.13357298f, -0.06009837f, 0.13732947f, 
    0.06179564f, 0.03348402f, 0.01336449f, 0.01562529f, -0.07085061f, -0.00826294f, -0.01403954f, -0.11198235f, 
    -0.11451343f, -0.11802927f, -0.13855697f, 0.02791194f, -0.10718139f, 0.11877911f, 0.01483834f, 0.07179548f, 
    0.09962824f, -0.03345329f, 0.09465244f, 0.01993657f, -0.01262712f, 0.02687198f, 0.10519781f, -0.20922732f, 
    0.00506613f, -0.09475705f, -0.01635974f, -0.15511386f, 0.20621729f, 0.06338087f, -0.00198834f, -0.04630241f, 
    0.48255575f, 0.21288769f, -0.44260135f, 0.08297100f, 0.01286500f, 0.07055865f, 0.05491548f, -0.02228378f, 
    -0.13883202f, 0.07957195f, -0.01132693f, 0.00303376f, 0.09244154f, -0.07092340f, -0.06561892f, 0.01812478f, 
    0.08654646f, -0.12137705f, -0.04428641f, 0.23200281f, 0.03672697f, 0.08796117f, -0.05689486f, 0.00855760f, 
    -0.07916042f, -0.02924298f, 0.04474780f, -0.19578390f, 0.03626736f, -0.04843667f, -0.07430942f, 0.10018425f, 
    -0.05771679f, -0.10459298f, 0.09604137f, -0.03649056f, 0.11097717f, -0.21246205f, -0.01648834f, 0.24477991f, 
    0.16708818f, -0.12222713f, 0.15549347f, -0.28516728f, 0.12617728f, -0.24259798f, -0.14835352f, -0.01641186f, 
    -0.04223828f, -0.19089507f, -0.12561692f, 0.13606691f, 0.07036260f, 0.09487533f, -0.00349480f, -0.00727580f, 
    0.05178660f, -0.02695272f, 0.02787411f, -0.03906685f, -0.16991740f, -0.23086974f, -0.07312833f, 0.16564082f, 
    0.05531004f, -0.15495352f, 0.04087252f, 0.00923891f, 0.10084349f, 0.06304291f, -0.06089936f, -0.11457085f, 
    0.11415435f, -0.05283368f, -0.06239279f, 0.15862527f, 0.07185892f, -0.01782681f, -0.08463760f, 0.07273341f, 
    -0.02645627f, 0.07951835f, -0.08743388f, 0.05076490f, -0.11509454f, -0.07503501f, -0.09214249f, 0.10766783f, 
    0.02416947f, -0.00312424f, 0.01213983f, -0.04677879f, -0.08490690f, 0.09946983f, -0.03339984f, 0.09464867f, 
    0.34636053f, 0.02224548f, 0.25722605f, -0.09033735f, -0.09533215f, 0.03446168f, 0.00710211f, 0.14071353f, 
    0.07377739f, 0.00570957f, 0.08251335f, 0.10034565f, 0.21405892f, 0.16435982f, -0.31735468f, -0.19168425f, 
    -0.07244954f, 0.17735463f, -0.27654448f, -0.39733392f, -0.06309131f, -0.22709322f, 0.07237619f, -0.03833828f, 
    0.38251185f, -0.20191509f, -0.24848758f, 0.18986334f, 0.05165166f, -0.11362889f, -0.15681991f, 0.00151772f, 
    0.06997317f, 0.03424134f, 0.02616615f, -0.18676142f, -0.03631158f, -0.12614004f, -0.07623941f, 0.39040560f, 
    0.15427940f, -0.14415723f, 0.05122655f, -0.00236383f, -0.08382383f, -0.00301344f, 0.00369641f, 0.00898059f, 
    -0.18481895f, 0.11198946f, 0.14212032f, 0.42737982f, -0.05576582f, 0.05472885f, -0.16302676f, 0.00361812f, 
    0.03815063f, 0.01431337f, -0.11586711f, 0.09569396f, -0.16959538f, -0.09442599f, -0.05466403f, -0.39622891f, 
    0.00836637f, 0.13066374f, 0.06796501f, 0.11404206f, -0.13561043f, -0.06590935f, 0.11383464f, -0.14301483f, 
    -0.33613238f, 0.51137179f, -0.57559717f, 0.22770816f, -0.09445430f, -0.28180838f, -0.03153024f, -0.09440041f, 
    -0.02799886f, 0.04630459f, 0.11130299f, -0.03664411f, 0.19159937f, -0.04872683f, -0.13532947f, -0.00973396f, 
    0.06263954f, -0.02105197f, 0.09746174f, -0.05341920f, -0.04864955f, 0.09316194f, 0.11486506f, 0.05893512f, 
    -0.46677899f, 0.30185965f, -0.10306334f, 0.18167868f, -0.03827417f, -0.10780665f, 0.10102710f, -0.07605136f, 
    -0.15230201f, -0.06808925f, -0.10487798f, 0.00384008f, 0.09631509f, -0.04606450f, 0.01869728f, 0.12337054f, 
    0.03526265f, 0.07695305f, 0.03132345f, 0.03588793f, -0.07787336f, -0.00904061f, -0.05960554f, -0.12160038f, 
    -0.02804857f, 0.13980879f, -0.29158163f, 0.04534728f, -0.04713677f, -0.04628207f, 0.00862969f, -0.09841560f, 
    -0.00168291f, -0.07051402f, -0.06666923f, -0.13339429f, 0.21517295f, -0.12481956f, -0.45795465f, -0.22114789f, 
    -0.04032623f, -0.07284857f, -0.06409470f, -0.15193462f, 0.08625706f, 0.18884021f, -0.08617409f, -0.19547249f, 
    -0.05770643f, -0.09092371f, 0.36685944f, 0.10154097f, 0.00575985f, 0.14185654f, 0.05047804f, 0.07480046f, 
    0.07281914f, -0.00979848f, 0.04183741f, -0.03217408f, -0.15465684f, -0.08414854f, -0.06860641f, 0.26711097f, 
    -0.05218636f, -0.03093261f, 0.00352617f, 0.00550325f, 0.02329390f, 0.01943820f, -0.06545653f, -0.02021508f, 
    -0.33950230f, 0.50149983f, -0.12972493f, 0.08832281f, 0.07484526f, -0.09534166f, 0.13510460f, -0.24788272f, 
    0.00712650f, -0.01297578f, 0.11710824f, -0.01610000f, 0.12137696f, -0.13189168f, -0.10117287f, -0.08755059f, 
    0.26734576f, 0.02832334f, 0.00320039f, -0.00189741f, -0.13850313f, -0.00619838f, 0.03726935f, -0.11673461f, 
    -0.03114664f, 0.07784138f, 0.19386892f, 0.10676402f, 0.03803260f, -0.09324404f, -0.08503365f, -0.20670427f, 
    0.08876815f, 0.04939261f, -0.12866899f, 0.09727446f, 0.07088569f, 0.00094048f, -0.05285290f, 0.06037143f, 
    0.04920945f, 0.11370379f, -0.03024833f, 0.06068439f, -0.01913161f, -0.03071933f, 0.06717803f, -0.11107734f, 
    -0.51946390f, -0.01027766f, 0.11486697f, 0.27109328f, -0.06739271f, -0.07371075f, -0.01646890f, 0.01518793f, 
    0.07247861f, -0.18364507f, 0.14354861f, 0.00345808f, -0.33016953f, 0.05633429f, 0.00261021f, 0.01311436f, 
    0.15617414f, 0.01753908f, -0.00725458f, -0.03561444f, -0.12645373f, -0.01987030f, 0.00559107f, -0.04363670f, 
    -0.32275486f, -0.01310630f, 0.17439616f, -0.20109996f, -0.24049881f, -0.05192424f, -0.28306845f, -0.06482100f, 
    -0.05602257f, -0.01354906f, -0.10310454f, 0.09802788f, 0.37920398f, -0.21839780f, 0.13012724f, 0.21917209f, 
    0.09832631f, -0.05311869f, -0.00461269f, 0.02680313f, 0.07845467f, 0.06666983f, 0.11038192f, 0.18572815f, 
    0.03060529f, 0.10232814f, -0.03496938f, -0.25278309f, 0.05279712f, -0.05848086f, 0.00368889f, 0.09050820f, 
    -0.15298620f, -0.06021704f, 0.13482209f, 0.05336040f, -0.50189203f, 0.71323282f, -0.09124675f, -0.33522224f, 
    0.06712159f, 0.05935251f, -0.12542118f, -0.04796709f, -0.42021942f, -0.04436855f, 0.03315390f, -0.08344898f, 
    0.13586019f, -0.27478412f, 0.11312754f, -0.03538461f, 0.05668088f, -0.02447655f, 0.08312705f, 0.02717451f, 
    -0.05921718f, -0.01683513f, -0.11468222f, -0.05811286f, 0.14337884f, 0.04286427f, -0.13866821f, -0.14230780f, 
    0.30663213f, 0.17147937f, 0.04785670f, 0.01351236f, -0.14473203f, 0.05511255f, -0.05235156f, 0.02773747f, 
    0.55091751f, 0.07782630f, 0.13070071f, 0.23328933f, -0.08144371f, -0.02909588f, -0.25474715f, 0.00218932f, 
    -0.15162855f, -0.03385573f, 0.19005354f, 0.23445633f, -0.17853642f, -0.08139113f, -0.02008545f, 0.20095737f, 
    0.04170579f, 0.12377513f, 0.07427079f, 0.06737497f, 0.03531392f, 0.02363215f, 0.06982341f, -0.03674102f, 
    -0.04457382f, 0.38911876f, 0.06458579f, 0.19971874f, -0.15093102f, -0.06957041f, -0.06443480f, -0.16257919f, 
    -0.02744122f, 0.16275308f, 0.04217016f, -0.06177766f, 0.00253573f, 0.06022909f, 0.20729695f, 0.11479277f, 
    -0.04375022f, -0.18454051f, 0.10831018f, 0.04448393f, 0.06886052f, 0.19286622f, -0.09293215f, -0.00808060f, 
    -0.48865280f, -0.42767149f, -0.00811087f, -0.29825830f, -0.09892255f, -0.01244624f, -0.06040889f, -0.15929744f, 
    -0.02756554f, 0.14616691f, -0.15702197f, -0.02935609f, 0.05434619f, -0.22491872f, -0.08298925f, 0.08679416f, 
    0.11954568f, 0.03174609f, 0.03476798f, -0.16622102f, 0.04291995f, 0.06343744f, 0.07348142f, 0.05126725f, 
    -0.02059910f, 0.03803584f, -0.17262866f, 0.01233055f, -0.03640663f, -0.02232648f, -0.02232684f, -0.08842435f, 
    -0.03210480f, 0.15431926f, -0.03915629f, 0.03762598f, -0.21208519f, -0.16816449f, -0.14104469f, -0.10460871f, 
    -0.10650558f, 0.03019575f, -0.12116124f, 0.03142941f, 0.01845998f, 0.21784353f, -0.10704500f, 0.00678830f, 
    -0.19648802f, -0.09643918f, -0.12014153f, 0.17711590f, -0.00918164f, 0.03749441f, 0.16064318f, 0.00412067f, 
    0.11256199f, -0.13194418f, 0.06686915f, 0.11225698f, -0.12816291f, 0.17359996f, 0.10557314f, 0.26960388f, 
    0.03945196f, -0.02348521f, 0.14909619f, -0.07079697f, 0.09408870f, -0.00740694f, -0.01650167f, 0.08383559f, 
    -0.19202350f, 0.05116399f, 0.14084829f, 0.10628767f, -0.00945184f, -0.01560049f, -0.07073199f, 0.03804410f, 
    -0.05986902f, -0.04540828f, -0.04196817f, 0.09480275f, -0.13898544f, 0.15028355f, -0.25430384f, 0.21921822f, 
    0.02709024f, -0.15169628f, -0.03535882f, 0.13550746f, 0.01469115f, -0.33051631f, -0.12129398f, 0.06479569f, 
    0.05106375f, 0.06994502f, 0.02427300f, 0.05104798f, -0.14664483f, 0.06579568f, -0.07598551f, -0.01930507f, 
    0.04878792f, 0.08038694f, -0.15927491f, -0.05503260f, 0.61776018f, 0.12196514f, -0.13007447f, -0.30790326f, 
    -0.01248400f, 0.05990937f, -0.04219761f, 0.01739139f, -0.13352254f, -0.00959334f, -0.14446652f, -0.00825811f, 
    0.16328181f, -0.11269460f, 0.13781662f, 0.11602253f, 0.19268055f, 0.07958595f, -0.01512702f, -0.01202154f, 
    -0.09989918f, -0.02063657f, -0.04705795f, -0.00757517f, -0.07785824f, -0.07177302f, -0.06140278f, 0.23413442f, 
    0.02398483f, -0.03861336f, 0.00793718f, -0.00194485f, -0.00532467f, -0.03873926f, 0.05991588f, 0.00391264f, 
    -0.14366497f, 0.51197499f, -0.06647136f, 0.15764643f, 0.09472193f, 0.16406883f, 0.15115464f, -0.06735395f, 
    -0.26917389f, -0.04930715f, -0.01777592f, 0.15095310f, 0.11418738f, -0.00334328f, -0.59778011f, 0.50899702f, 
    -0.02079983f, -0.14763875f, -0.11532674f, -0.01315339f, -0.12225870f, -0.03441540f, 0.09435836f, -0.04474873f, 
    0.00935234f, -0.00241667f, 0.03359965f, -0.07692201f, -0.02241988f, -0.03676939f, 0.00974744f, -0.07679080f, 
    0.02812960f, -0.02294856f, -0.17225179f, -0.14210254f, -0.13622151f, 0.06821011f, 0.00101553f, 0.30405369f, 
    -0.16092671f, 0.03139761f, -0.19845492f, -0.10650091f, -0.03426451f, 0.01504061f, 0.05891004f, -0.06344882f, 
    -0.22999717f, -0.06133077f, 0.24032623f, 0.10422602f, -0.15867527f, -0.05331069f, -0.16718203f, -0.02842346f, 
    -0.01918114f, 0.03383081f, -0.06634756f, -0.01489150f, -0.35666957f, 0.02148638f, 0.08868160f, -0.41263545f, 
    0.07978014f, -0.04233933f, -0.07245375f, 0.00218184f, -0.07474551f, -0.06145358f, -0.12800172f, -0.02441159f, 
    -0.06015402f, 0.18834153f, -0.14303398f, 0.34519681f, 0.07704106f, -0.05558845f, -0.08449186f, -0.02861885f, 
    -0.08995074f, 0.02978900f, 0.12076629f, -0.10395750f, -0.03605994f, 0.05791597f, -0.16535857f, -0.00661648f, 
    -0.02867551f, 0.05999508f, -0.06768571f, -0.05570834f, -0.08603325f, -0.08047444f, -0.05912652f, 0.03461260f, 
    -0.13776706f, -0.04896686f, 0.03305589f, 0.31984025f, 0.07771451f, 0.10078382f, 0.08407689f, 0.00526262f, 
    0.07709477f, 0.02778295f, 0.04213526f, 0.09734257f, 0.12763813f, -0.17170008f, -0.10083038f, -0.15345427f, 
    0.16486621f, -0.02761322f, -0.03823661f, -0.00323364f, -0.00814294f, 0.05133843f, -0.05899299f, -0.02561417f, 
    0.09036323f, -0.17744289f, 0.08549681f, 0.10708942f, -0.02243932f, 0.02242590f, 0.08973643f, 0.11534743f, 
    0.07505947f, 0.02797953f, -0.00213525f, 0.01132372f, 0.25723794f, 0.14850709f, -0.04223308f, -0.05670854f, 
    -0.00448173f, -0.07111537f, -0.02552154f, -0.06368428f, -0.04487641f, -0.12767257f, 0.13149983f, 0.02934685f, 
    -0.11765590f, -0.16883691f, -0.03085576f, -0.06921152f, -0.08980509f, -0.08105582f, 0.03533592f, -0.10675451f, 
    0.14365980f, 0.08663134f, 0.01383890f, -0.12843956f, -0.28580350f, 0.15327127f, -0.07543914f, 0.46861845f, 
    0.03751714f, 0.02540255f, 0.31367084f, -0.05828050f, -0.03812267f, 0.03018774f, -0.10823997f, 0.02705915f, 
    0.03793477f, 0.12713523f, -0.13449639f, -0.32485661f, 0.03694643f, -0.03861622f, -0.15924233f, 0.05688730f, 
    0.05964226f, 0.10856302f, -0.22898176f, -0.06683264f, -0.00365833f, 0.26914304f, -0.30120194f, -0.16371663f, 
    0.00233151f, 0.02452001f, 0.00230871f, 0.05797273f, -0.12261394f, 0.02450524f, -0.08403458f, 0.10480706f, 
    0.17630202f, -0.08553359f, -0.08028749f, 0.10861095f, 0.06955758f, -0.08915575f, 0.03916421f, 0.02217612f, 
    -0.01171818f, 0.03578453f, 0.01661160f, -0.16133218f, -0.06218546f, 0.10362551f, 0.11433399f, -0.08484118f, 
    -0.25205919f, 0.06798220f, -0.32963273f, 0.14034317f, -0.01866897f, -0.02118231f, 0.03835871f, -0.12456098f, 
    0.15607527f, 0.21105526f, 0.22397353f, 0.11975101f, -0.18380542f, -0.15193121f, -0.02616875f, 0.09553009f, 
    0.10029481f, -0.02267970f, 0.01514798f, 0.04768119f, 0.15147266f, 0.07958137f, -0.02646578f, -0.02287933f, 
    0.06671847f, 0.02534230f, -0.02920650f, -0.00323957f, -0.02939958f, -0.19043995f, 0.05607219f, -0.02874957f, 
    -0.00546265f, 0.14678645f, 0.15363030f, 0.13051781f, -0.11286588f, -0.03458446f, 0.06716623f, -0.01530355f, 
    0.05499442f, 0.05075203f, -0.01122598f, 0.01698644f, -0.05747396f, -0.01807647f, -0.11208583f, 0.08557335f, 
    -0.09502134f, 0.02046713f, -0.05947448f, 0.06355855f, -0.00441144f, 0.02942410f, -0.00589135f, 0.02407677f, 
    0.05093169f, 0.07690401f, 0.11163703f, 0.18541141f, 0.00097563f, 0.13551287f, -0.07268059f, -0.09973426f, 
    0.06739521f, -0.03999652f, 0.01348042f, 0.01275969f, 0.04190485f, -0.04930207f, -0.12850724f, 0.13669790f, 
    0.03763435f, -0.16390410f, 0.14707462f, -0.03651107f, -0.01819681f, 0.04329708f, -0.00806006f, -0.05879031f, 
    -0.31758702f, -0.00529694f, 0.10305020f, -0.21824165f, -0.14734176f, 0.01350869f, -0.43491030f, 0.04881020f, 
    -0.03095750f, -0.10397571f, -0.11103742f, -0.19581157f, 0.00270616f, 0.10577057f, 0.15804727f, 0.07580149f, 
    0.03085250f, -0.04286866f, -0.10786443f, -0.00961655f, -0.16162416f, -0.00892047f, 0.05968297f, 0.03767607f, 
    0.23775925f, 0.04047900f, 0.14885660f, 0.20884319f, 0.09279832f, 0.12225542f, 0.02543141f, -0.00204041f, 
    0.02375501f, -0.03871887f, 0.02228497f, -0.04113558f, -0.03745842f, -0.48259357f, -0.04646875f, -0.13000664f, 
    0.07052631f, 0.01520237f, 0.06646605f, 0.07237790f, 0.05988475f, 0.01753501f, -0.03010886f, 0.07886970f, 
    0.25217068f, -0.29786211f, 0.22607236f, -0.11393076f, -0.03748003f, -0.03105141f, -0.05483308f, -0.02984000f, 
    0.00414473f, -0.07288666f, -0.03728976f, 0.08696028f, -0.23988631f, -0.05441066f, -0.02149073f, 0.10380311f, 
    -0.09425195f, 0.07319862f, -0.05374514f, 0.04853712f, -0.03632144f, 0.04044671f, 0.01792225f, 0.02619850f, 
    -0.09238116f, -0.13971911f, 0.00524731f, -0.02614881f, -0.08587258f, 0.06154456f, -0.07645473f, 0.04185204f, 
    -0.27217838f, 0.06389955f, -0.18453427f, -0.03050970f, -0.01563583f, 0.14681426f, 0.12466165f, 0.18573491f, 
    -0.00836935f, 0.04028361f, 0.10338408f, 0.05208553f, 0.00326691f, -0.01514712f, 0.00465837f, 0.08799965f, 
    -0.05863677f, -0.14035843f, 0.09703384f, -0.19385961f, -0.18148375f, 0.01999770f, -0.19246119f, -0.11088196f, 
    -0.03326188f, -0.17043523f, -0.03504115f, -0.06046760f, -0.02709704f, -0.03694908f, 0.20124321f, 0.05209910f, 
    0.02447785f, -0.00188617f, -0.27591112f, 0.15630321f, 0.04199516f, -0.16522281f, 0.00937444f, 0.00176321f, 
    0.17843100f, 0.22487921f, -0.09555151f, 0.16984472f, 0.06956530f, 0.09148402f, -0.21735981f, 0.07822796f, 
    0.09934060f, -0.01407150f, -0.13116953f, -0.03090603f, -0.02768946f, 0.02549560f, 0.15115570f, 0.07903123f, 
    -0.07909337f, -0.08929422f, 0.03454064f, -0.01358001f, 0.04331280f, -0.04348785f, 0.08132746f, 0.02714433f, 
    -0.24354999f, -0.19953190f, -0.08952905f, -0.07152839f, -0.06348204f, 0.01522338f, -0.17696932f, 0.09455934f, 
    -0.10344584f, -0.03613152f, -0.02473578f, 0.11890105f, -0.06326027f, -0.08604269f, -0.06223933f, 0.09840877f, 
    -0.34208840f, -0.00936134f, -0.05916933f, 0.05037334f, -0.07293289f, -0.00763885f, -0.18279821f, -0.19133136f, 
    0.02313231f, 0.01659707f, -0.11936177f, -0.08578709f, 0.05383529f, 0.01498915f, -0.01781527f, 0.04129767f, 
    0.00164700f, 0.04882235f, 0.03633881f, -0.11972529f, 0.08392563f, 0.11959013f, 0.24726820f, 0.18722808f, 
    -0.15642731f, -0.02143476f, -0.00840993f, 0.16024388f, 0.08316123f, 0.00871850f, 0.01195477f, -0.03149936f, 
    0.04503903f, 0.18923414f, -0.28850564f, -0.10058688f, 0.04837836f, -0.03014606f, 0.03193773f, -0.03886547f, 
    -0.18578199f, 0.18612412f, 0.01682647f, 0.01711627f, 0.06393307f, 0.00217432f, 0.10047574f, 0.03042192f, 
    -0.07480901f, -0.07815042f, 0.00247546f, -0.06386533f, 0.00195489f, 0.13210270f, -0.06037577f, 0.01004821f, 
    -0.22984488f, -0.48750311f, -0.67332405f, -0.12773636f, 0.05452541f, 0.03241049f, 0.06287704f, -0.00624677f, 
    0.04552921f, -0.04273899f, 0.06414060f, -0.05036623f, -0.13516968f, -0.08726012f, 0.06290182f, 0.13249503f, 
    -0.09071325f, -0.17324395f, -0.09776413f, -0.10933332f, 0.03092904f, 0.02042517f, 0.02845197f, 0.02472199f, 
    -0.05638476f, -0.13365951f, -0.10672501f, -0.01319186f, -0.16105410f, -0.05613807f, -0.01693328f, 0.02136732f, 
    -0.03285555f, 0.01045186f, -0.15024288f, 0.04981138f, 0.18245192f, -0.47865719f, -0.02670601f, 0.00562976f, 
    -0.35166496f, -0.04947012f, 0.09763966f, -0.11725549f, -0.03770797f, 0.06050055f, -0.14557210f, 0.01411784f, 
    -0.05847500f, 0.01871721f, 0.10874871f, 0.02427394f, -0.08055156f, 0.03647352f, 0.08355991f, 0.06923486f, 
    -0.03660357f, -0.04967152f, -0.00492564f, -0.02276931f, 0.21879771f, 0.07202560f, -0.03486846f, 0.06050043f, 
    -0.09226165f, 0.00772062f, -0.00906727f, 0.08869343f, 0.03803538f, -0.21274740f, -0.02619424f, -0.06456824f, 
    0.04875247f, 0.00833082f, -0.26975691f, -0.08024506f, 0.30743709f, 0.09653271f, -0.07208493f, 0.03898575f, 
    0.03920579f, -0.07588286f, -0.09312517f, -0.14823245f, 0.07313687f, 0.09911003f, 0.32914850f, 0.04336155f, 
    0.03170034f, -0.18884915f, -0.05941695f, -0.04452181f, 0.10239998f, 0.01848398f, 0.00188242f, -0.02898077f, 
    0.11759382f, 0.02173264f, 0.03928549f, 0.07829207f, 0.10124078f, 0.13308699f, -0.02682042f, 0.01380996f, 
    0.03571817f, -0.00516306f, -0.03081402f, 0.01756987f, 0.03010371f, -0.05332841f, 0.09409009f, 0.19799268f, 
    0.06765730f, -0.06131617f, -0.05141394f, 0.04732148f, -0.09821536f, -0.13638788f, -0.07858808f, -0.11163050f, 
    0.13044281f, 0.06915720f, -0.02227013f, -0.01542492f, -0.00533466f, -0.01344271f, 0.08137999f, 0.07232674f, 
    0.06162224f, 0.00393190f, 0.04061905f, -0.05243496f, -0.07746030f, 0.14786135f, -0.00633740f, 0.22196014f, 
    -0.09196029f, -0.11566019f, -0.06041345f, 0.08388012f, -0.11018737f, -0.16125202f, -0.11663852f, 0.02569582f, 
    0.03249155f, 0.06943208f, 0.08922946f, 0.02460030f, 0.09316551f, -0.02850111f, -0.11056297f, -0.15500510f, 
    -0.14349225f, -0.02130799f, 0.00920464f, -0.02323599f, 0.02745380f, 0.06627094f, -0.04176835f, -0.02043043f, 
    -0.01222278f, -0.04380341f, 0.02263288f, -0.03123770f, 0.02408244f, 0.03570256f, 0.18363397f, 0.33201662f, 
    0.14870037f, 0.12601800f, 0.19373098f, 0.08139472f, 0.10003351f, 0.28547838f, 0.09300385f, -0.04209186f, 
    0.04719046f, -0.05966767f, -0.01216337f, -0.02219465f, 0.11532933f, 0.03733158f, 0.13061108f, 0.05383234f, 
    0.03750961f, -0.07025741f, -0.01073422f, 0.04327973f, -0.06813703f, 0.03966659f, 0.09025420f, -0.05373738f, 
    0.30577585f, -0.13611203f, -0.28742519f, 0.09451944f, 0.06118660f, 0.00744006f, 0.07662417f, -0.22501567f, 
    0.03470072f, -0.06183200f, 0.05356587f, -0.01852050f, 0.04590065f, -0.30569375f, -0.06378453f, 0.07315399f, 
    0.10164069f, -0.04210748f, 0.04427402f, 0.03476561f, 0.05266511f, -0.01326776f, 0.05546775f, -0.23263678f, 
    0.16931297f, -0.06051114f, -0.06467133f, 0.11386435f, 0.03962345f, -0.09015721f, 0.03681986f, -0.04243103f, 
    0.06063699f, 0.16865130f, 0.31066218f, 0.32574928f, 0.00482234f, -0.17301215f, -0.27201796f, -0.14673673f, 
    0.04363571f, -0.02090777f, 0.16257927f, 0.01864611f, 0.04456624f, 0.02196929f, 0.11325789f, -0.22417484f, 
    0.12685749f, 0.15867372f, 0.02464936f, 0.06703386f, -0.00988087f, -0.07899623f, 0.04346692f, -0.01037234f, 
    0.11480213f, -0.01216748f, 0.09365976f, 0.11174418f, 0.00061848f, 0.04517458f, 0.06818248f, 0.05536995f, 
    -0.07643519f, -0.05517071f, 0.07492669f, 0.00586299f, 0.03029595f, -0.07093202f, 0.00586633f, 0.00995288f, 
    0.10521500f, -0.27303505f, 0.17646086f, 0.06663472f, 0.10924053f, 0.01464222f, -0.04363949f, 0.07280496f, 
    0.03396210f, -0.00262719f, -0.11797486f, -0.01547046f, -0.13844225f, 0.12539582f, 0.20017672f, -0.27242514f, 
    -0.02128186f, 0.03593366f, -0.01648056f, 0.11682165f, -0.03159279f, -0.01861290f, -0.08080237f, 0.02511828f, 
    0.07859386f, 0.04624267f, 0.01651654f, 0.02601127f, -0.02210806f, -0.05315590f, 0.00060057f, 0.09224160f, 
    -0.02607514f, -0.02584606f, 0.01562832f, -0.16133347f, -0.30031008f, 0.01927828f, -0.00098699f, -0.02301676f, 
    0.01170277f, 0.04346403f, -0.01301510f, 0.04595224f, -0.09418277f, -0.10831422f, -0.11981703f, 0.05364109f, 
    0.04581321f, 0.14784491f, -0.19196171f, 0.02644350f, 0.10775404f, 0.00311207f, -0.02291046f, -0.26302868f, 
    0.05993715f, 0.02498610f, -0.00832106f, -0.06757458f, 0.18619028f, 0.05945564f, -0.34779239f, -0.08600838f, 
    0.03515036f, 0.04476907f, 0.05832775f, 0.02825746f, -0.21876661f, -0.09600256f, -0.11157673f, -0.07823556f, 
    -0.08164738f, -0.05733679f, 0.22335279f, -0.20422824f, -0.04178626f, -0.02700515f, 0.00610183f, 0.05970864f, 
    0.05984372f, -0.07703181f, -0.01154770f, -0.03738878f, -0.12005199f, -0.07978626f, 0.11756085f, 0.08359399f, 
    -0.08271643f, 0.01862092f, -0.08078779f, -0.06501791f, -0.09007569f, 0.04895487f, 0.01648903f, -0.00832481f, 
    0.12397069f, 0.11270597f, 0.22772610f, 0.12328564f, -0.07297871f, -0.10489763f, -0.18892449f, 0.01867009f, 
    -0.01320584f, -0.01509843f, 0.05669793f, -0.02166830f, 0.11385088f, 0.11638354f, -0.05219524f, -0.06050348f, 
    -0.00975824f, -0.01191498f, 0.04450347f, 0.06147602f, 0.00145659f, 0.03213251f, -0.18407422f, -0.08769248f, 
    -0.02471652f, 0.14516075f, 0.04496901f, 0.06541384f, -0.04432887f, 0.01350645f, 0.03578483f, -0.10635378f, 
    0.00050905f, 0.05377460f, 0.02832250f, 0.32151815f, 0.12225335f, -0.07054620f, -0.07442939f, 0.08898242f, 
    0.01526073f, 0.05551480f, 0.00652870f, -0.01588636f, -0.00201985f, -0.12511432f, -0.15265998f, -0.13521285f, 
    0.13641581f, -0.08178214f, 0.11965988f, -0.06491656f, -0.00538068f, 0.03373760f, -0.19955143f, 0.05139336f, 
    -0.02440759f, -0.03039365f, -0.12524679f, -0.15672058f, 0.00208607f, 0.03876372f, 0.02953606f, -0.21097833f, 
    0.08500754f, -0.23125437f, -0.10534135f, -0.03987927f, 0.01003688f, -0.06272771f, 0.03932250f, -0.12962347f, 
    0.07219485f, -0.04670950f, -0.02663474f, 0.08189864f, -0.14300227f, -0.10717459f, 0.00925505f, 0.04843195f, 
    -0.13270041f, -0.10295984f, 0.02313797f, -0.05027303f, 0.13559759f, -0.27361274f, 0.14242364f, 0.07650723f, 
    0.07580628f, -0.05463276f, -0.10206227f, -0.06565370f, -0.06583486f, 0.06326135f, -0.06813447f, -0.07634906f, 
    0.22697723f, 0.03913523f, -0.03737357f, -0.09906275f, -0.13435182f, 0.04640241f, -0.03635464f, 0.00077955f, 
    0.04727730f, -0.15006709f, -0.14534676f, 0.13584918f, 0.12320104f, 0.08814033f, -0.12776463f, -0.18412933f, 
    0.04666090f, 0.17485335f, -0.19004402f, 0.09601641f, 0.01359941f, -0.11341751f, -0.07653280f, 0.15460870f, 
    0.08524729f, 0.08137625f, 0.04173810f, -0.11202038f, 0.18953878f, 0.16699722f, 0.10095976f, 0.05599845f, 
    0.00330630f, -0.03039420f, 0.04701845f, 0.00380557f, -0.10508534f, 0.18420643f, -0.07839993f, -0.04022984f, 
    -0.04033769f, 0.08380789f, -0.07389781f, -0.01043708f, 0.06634035f, 0.01562462f, -0.03042386f, -0.03701141f, 
    -0.03261399f, -0.04194378f, 0.04539765f, 0.06226530f, 0.06191927f, 0.06645555f, 0.06808050f, 0.16755453f, 
    -0.01666565f, 0.01522605f, 0.02843568f, 0.03399739f, 0.11578793f, -0.08944955f, 0.29841173f, -0.02571837f, 
    -0.02834201f, -0.05901804f, -0.05789769f, 0.05171968f, 0.14736336f, -0.09542766f, -0.10890874f, -0.06456562f, 
    -0.12424527f, -0.16325602f, 0.11320916f, 0.15764095f, -0.06895721f, -0.12385982f, 0.09761844f, -0.12070504f, 
    0.00147073f, 0.02880775f, 0.07918829f, -0.09436167f, -0.36534381f, 0.13504919f, -0.18372752f, 0.13900548f, 
    0.11708844f, -0.29820514f, 0.01051110f, 0.35111967f, 0.18224020f, -0.07787245f, 0.06686017f, 0.26617521f, 
    0.21776561f, 0.00172585f, -0.02684169f, 0.00495643f, -0.04136344f, 0.11757844f, 0.03092756f, -0.12955821f, 
    -0.01775612f, -0.03510574f, 0.13428722f, 0.33234063f, -0.16785139f, 0.08458550f, -0.35055801f, -0.20349583f, 
    -0.03678683f, -0.01111032f, -0.03096370f, 0.15790085f, 0.08674461f, -0.19776413f, -0.07804913f, -0.03958517f, 
    0.10597594f, -0.01352918f, -0.25470108f, -0.05093577f, -0.05034426f, 0.09589004f, 0.26946631f, 0.31268340f, 
    0.02058657f, -0.01405663f, -0.04002912f, -0.09144720f, -0.29825029f, -0.19911510f, 0.05207300f, 0.07160209f, 
    0.02315880f, 0.03132768f, 0.04759989f, 0.03487522f, -0.04408269f, -0.10188098f, -0.14445464f, -0.15090726f, 
    0.25338215f, -0.51577955f, 0.31671518f, 0.17205851f, 0.11568129f, -0.02480131f, 0.02681261f, 0.09099949f, 
    0.12443550f, 0.06851890f, -0.02358720f, -0.05425325f, -0.18689276f, -0.15198378f, 0.11571298f, -0.18451589f, 
    -0.14406176f, -0.11284591f, 0.07569049f, 0.06526794f, -0.13119949f, -0.10471620f, -0.30280688f, 0.00638418f, 
    0.03253647f, 0.19987491f, 0.13365334f, -0.29407805f, -0.09700830f, -0.17281300f, -0.10200345f, -0.04885823f, 
    -0.09914906f, 0.14839885f, -0.13209337f, 0.00299098f, 0.00962657f, 0.11098429f, 0.23845465f, -0.04799890f, 
    0.10050477f, -0.09373505f, -0.08322057f, 0.10760475f, 0.05157541f, 0.00311788f, 0.04540118f, 0.09217766f, 
    0.11260728f, 0.14377549f, 0.22116259f, -0.05508991f, 0.19337735f, -0.09103248f, -0.06437517f, 0.08029801f, 
    0.03038499f, 0.07794412f, -0.10260031f, 0.26820308f, 0.04473281f, -0.07223608f, 0.03783468f, 0.04026611f, 
    -0.21577343f, 0.12276809f, 0.27158341f, -0.09252714f, 0.09544972f, -0.11397152f, -0.08752672f, 0.17833114f, 
    -0.06854606f, 0.06669927f, -0.34436885f, 0.28157887f, 0.03957862f, 0.02533207f, 0.06413463f, -0.04423323f, 
    -0.13297260f, -0.02974566f, 0.01748364f, 0.03426483f, 0.14755546f, 0.08663741f, 0.13477921f, -0.20346043f, 
    0.29260904f, 0.05369284f, 0.11438868f, 0.01880377f, 0.05312936f, 0.03762935f, 0.04846633f, 0.01438409f, 
    -0.01209745f, -0.15543263f, 0.08330236f, -0.21891829f, 0.04681155f, 0.10397064f, -0.06881574f, -0.00238789f, 
    0.01074348f, -0.06048972f, 0.00719606f, -0.02850593f, -0.65565318f, -0.17009673f, 0.02815884f, -0.14157118f, 
    -0.08518717f, -0.02088855f, 0.08587056f, -0.02677145f, -0.14384784f, -0.14193709f, 0.19924986f, 0.27715245f, 
    0.13671373f, -0.11467835f, -0.22157079f, -0.01199000f, -0.06012555f, 0.21297137f, 0.03783734f, -0.08661303f, 
    0.01369089f, -0.12783806f, 0.00734005f, -0.08195147f, 0.19746703f, -0.01350744f, 0.21427204f, 0.04187353f, 
    0.06079527f, -0.04822194f, -0.03633136f, -0.12791643f, -0.01992313f, 0.04270676f, -0.03503742f, 0.03566649f, 
    -0.00267484f, -0.23092905f, -0.62818789f, -0.14650264f, -0.00414698f, 0.02628296f, 0.00988622f, -0.01159844f, 
    0.27398938f, -0.12911756f, -0.30656096f, -0.10967522f, 0.04847978f, -0.01624507f, -0.17707501f, -0.03129844f, 
    0.05579763f, 0.10580643f, -0.06605282f, 0.07924956f, 0.02632947f, -0.10402834f, -0.05507025f, -0.08349524f, 
    0.51686949f, -0.13190025f, -0.27054185f, 0.27821028f, 0.06008463f, 0.02644248f, 0.01171609f, 0.05363141f, 
    0.06920175f, -0.02641599f, 0.08532143f, -0.07763475f, -0.30985194f, 0.03351240f, -0.19916917f, -0.26450604f, 
    0.00786851f, 0.05134249f, 0.14403155f, 0.09034673f, 0.01948748f, -0.01345398f, 0.04281837f, -0.05760925f, 
    0.21544060f, -0.05090375f, 0.15193814f, 0.01975447f, 0.06270962f, 0.05275686f, -0.01356602f, -0.05760244f, 
    -0.09352598f, 0.00464350f, -0.10363650f, 0.16628450f, -0.45663735f, -0.12353916f, -0.04568353f, 0.17273895f, 
    0.01675409f, -0.03304509f, -0.12245771f, 0.01563371f, 0.12614621f, 0.11217632f, -0.18773350f, -0.05823329f, 
    0.22634295f, 0.15942076f, -0.07811870f, -0.11042907f, 0.07228464f, 0.17692974f, 0.05514986f, -0.14019781f, 
    0.03835489f, 0.09956241f, 0.01869640f, -0.00225992f, -0.17457433f, -0.06879891f, 0.09146554f, 0.04010025f, 
    -0.01799964f, -0.07027857f, -0.06498972f, -0.07556976f, 0.17626777f, 0.01679512f, 0.07769993f, 0.16541113f, 
    -0.32327920f, 0.47559887f, -0.52378792f, 0.04950359f, 0.14653786f, 0.02554413f, -0.09929887f, -0.05219582f, 
    0.10583329f, 0.05408904f, -0.02991379f, 0.04990458f, 0.02883771f, 0.11800110f, -0.10940667f, -0.16446556f, 
    0.08186596f, 0.06122614f, -0.01637524f, -0.09276493f, -0.09062029f, -0.14262846f, -0.05944825f, -0.05006022f, 
    -0.09336376f, -0.01656813f, -0.10117798f, -0.07826875f, -0.07757998f, -0.10357659f, -0.02635260f, 0.20718502f, 
    -0.03129074f, 0.09541103f, -0.02700917f, -0.04721707f, 0.06845757f, -0.14734837f, -0.03684139f, 0.05612630f, 
    -0.10890301f, 0.01779309f, 0.03028205f, -0.00422439f, 0.09957828f, 0.06740232f, 0.03396738f, 0.21819586f, 
    0.00405132f, -0.08506432f, -0.21691632f, 0.04584207f, 0.02277564f, 0.02035457f, -0.11274134f, -0.01447196f, 
    0.05925548f, -0.04450698f, 0.08885040f, 0.04984993f, -0.01254776f, -0.44456199f, -0.07064743f, -0.31866407f, 
    -0.10561053f, 0.03394972f, 0.00806202f, 0.13326684f, 0.00068252f, -0.08365317f, -0.02013991f, 0.01996136f, 
    0.23202878f, -0.08524903f, 0.25927246f, 0.02382640f, -0.12431253f, 0.06347396f, 0.13044056f, 0.16940819f, 
    0.10563176f, -0.03545871f, 0.08174823f, -0.07221714f, 0.28911045f, -0.15775275f, -0.07560726f, 0.01565789f, 
    0.06060408f, 0.04948789f, 0.02029883f, 0.03790809f, -0.05857094f, -0.27605003f, -0.29207844f, -0.49981421f, 
    0.04604373f, 0.06619339f, 0.09390625f, 0.02721891f, 0.01912886f, -0.22083977f, -0.08164818f, -0.19129333f, 
    -0.01388075f, 0.07522029f, 0.10619639f, 0.02677801f, 0.01722779f, 0.02352919f, 0.28343987f, -0.37206185f, 
    0.13660128f, 0.06858164f, -0.12908098f, 0.01632051f, -0.09648363f, -0.05382890f, -0.03911363f, -0.00866383f, 
    -0.17801134f, 0.04267601f, 0.19692247f, 0.03746905f, 0.07099667f, -0.01688613f, -0.01055187f, 0.10332724f, 
    -0.00840031f, -0.05695203f, -0.04377572f, 0.12553652f, -0.03926495f, 0.18901367f, -0.33240199f, -0.00505402f, 
    0.08865888f, 0.05197479f, -0.01460478f, 0.07675251f, -0.02430663f, 0.06717161f, -0.05530029f, 0.03337849f, 
    0.06308118f, -0.16847581f, -0.06630027f, 0.10099363f, 0.02664947f, 0.03627266f, 0.06421663f, 0.03542409f, 
    0.00333738f, -0.25435546f, -0.13484521f, -0.54137689f, -0.34343821f, -0.06698835f, -0.11782873f, 0.21911940f, 
    -0.00368680f, -0.06136392f, -0.04121280f, -0.04202979f, 0.17913865f, -0.14894879f, 0.01994096f, 0.03504628f, 
    -0.55598152f, -0.11253709f, -0.30904609f, -0.25255075f, 0.02656710f, 0.00073588f, 0.02860333f, 0.07178937f, 
    0.17068696f, 0.07803985f, 0.01324458f, 0.02051000f, 0.18297675f, -0.04260732f, -0.15586895f, -0.04693295f, 
    -0.00189390f, -0.07096143f, -0.02442127f, 0.12861805f, -0.01267106f, -0.04800749f, 0.06274652f, -0.08616908f, 
    0.17380303f, 0.08468205f, -0.06971567f, -0.06604359f, -0.29077566f, -0.07173388f, -0.00347708f, -0.17544772f, 
    0.04126457f, -0.01567923f, -0.01837423f, -0.00030369f, -0.06538726f, 0.13880193f, -0.04293644f, -0.43125427f, 
    0.01888714f, 0.10076760f, -0.07170241f, 0.00034255f, 0.07119747f, -0.09410469f, 0.03021762f, 0.03578798f, 
    -0.07621379f, 0.04491829f, -0.08460759f, -0.05064416f, 0.27885801f, 0.16931729f, -0.19091861f, 0.02688186f, 
    -0.07521480f, 0.03962321f, 0.14851141f, 0.24311624f, 0.42917684f, -0.22126174f, -0.05827701f, 0.11691458f, 
    -0.08809602f, -0.06611645f, 0.00001658f, -0.05764686f, 0.18960455f, 0.12578963f, 0.04164840f, -0.04666111f, 
    -0.00185410f, 0.12375495f, -0.43443024f, 0.03026055f, 0.11848430f, 0.04244000f, 0.04196676f, 0.03288588f, 
    0.04227119f, -0.17345604f, -0.04570233f, -0.14667743f, -0.08679219f, -0.33046788f, -0.08285101f, 0.31117937f, 
    0.01378227f, -0.05314988f, -0.04061693f, 0.03622779f, 0.01715141f, 0.01702733f, 0.13732666f, -0.02691546f, 
    0.09265258f, 0.06722850f, -0.01011218f, 0.18522426f, 0.11536566f, 0.00336483f, -0.01159040f, 0.04964801f, 
    0.04331184f, 0.06879243f, -0.02072285f, 0.07347892f, 0.01666378f, 0.11549965f, 0.33389467f, -0.03986319f, 
    0.06999150f, -0.01931163f, -0.05439811f, 0.02860354f, 0.06170920f, -0.00101724f, -0.07742687f, 0.09813013f, 
    -0.05948491f, 0.08630893f, -0.22383924f, -0.35152814f, 0.02845326f, 0.02809047f, -0.00172644f, -0.18439613f, 
    0.10458608f, 0.02689190f, -0.07269588f, -0.14671019f, -0.21195884f, -0.18411510f, -0.02078887f, 0.20283863f, 
    -0.14009058f, -0.05943489f, 0.00221135f, 0.04867867f, 0.00686461f, -0.11090744f, 0.25869715f, 0.01172821f, 
    0.08813965f, 0.12546653f, -0.02448704f, 0.02053306f, 0.02905862f, 0.07667857f, -0.02714689f, -0.04282748f, 
    0.00334511f, -0.13115434f, -0.01899844f, -0.39711419f, -0.22717206f, 0.07451947f, 0.19370507f, -0.06045157f, 
    -0.08460899f, -0.06898396f, -0.07876921f, -0.00749933f, 0.05824717f, 0.13207106f, -0.10774069f, 0.05992923f, 
    0.23534586f, -0.01183364f, -0.16488025f, 0.09672936f, 0.03380376f, -0.13079131f, -0.11383227f, -0.08766218f, 
    -0.07721817f, 0.14203580f, 0.18989515f, 0.19414802f, -0.10193330f, -0.02449657f, -0.39187950f, 0.03677588f, 
    -0.02058351f, 0.16524968f, -0.06726743f, 0.08358428f, -0.16835652f, 0.17584650f, -0.07403903f, -0.30201387f, 
    0.15674323f, -0.11403572f, 0.03062707f, 0.26959714f, 0.06989197f, 0.04707934f, -0.09341422f, -0.03310841f, 
    -0.00710656f, 0.02929528f, -0.19260165f, -0.03785079f, 0.32704684f, 0.05361861f, 0.06419109f, -0.06953999f, 
    -0.10576521f, 0.16962725f, 0.01698425f, 0.22372936f, -0.00451005f, -0.00837470f, 0.09632249f, 0.09904122f, 
    -0.35623527f, -0.12399121f, 0.08602116f, 0.07732369f, 0.06575064f, -0.00752241f, -0.01235445f, -0.03362925f, 
    -0.04214935f, 0.07884411f, -0.13619721f, 0.09488750f, -0.17259200f, -0.02454008f, 0.15636761f, -0.07758199f, 
    0.14174904f, -0.02731103f, -0.12528779f, 0.23852675f, 0.05580128f, 0.00829922f, -0.08949091f, 0.03740922f, 
    -0.70132804f, -0.55645108f, -0.20419329f, -0.32770088f, -0.25964960f, -0.01497025f, -0.15457696f, -0.35299700f, 
    0.01415357f, 0.01384518f, 0.03211519f, 0.01198980f, -0.16271265f, 0.15014659f, 0.35019207f, -0.00110851f, 
    -0.09387469f, -0.14167356f, -0.06322657f, -0.12847878f, -0.14939722f, -0.02925797f, -0.09518149f, 0.00092483f, 
    -0.78039926f, -0.52352428f, 0.04823019f, -0.48383924f, -0.27457470f, -0.29675680f, 0.09646595f, -0.18477017f, 
    -0.02511978f, 0.02574496f, -0.08195564f, 0.00375020f, -0.31062108f, -0.32982701f, -0.41277769f, -0.07784801f, 
    -0.09853258f, -0.06264002f, 0.11197345f, 0.12606521f, 0.03547854f, -0.12491584f, 0.19612412f, 0.03439514f, 
    -0.09754711f, -0.20363738f, -0.28453168f, -0.06341627f, -0.07029475f, 0.18081629f, 0.13607778f, 0.03916270f, 
    0.00143198f, -0.04731473f, -0.03182306f, 0.05635851f, -0.00003894f, -0.14227274f, -0.00947364f, 0.06343587f, 
    0.09981988f, -0.03992702f, 0.10711392f, -0.09551042f, 0.03469105f, -0.06390788f, -0.04900458f, -0.07059003f, 
    0.08784914f, 0.13855493f, 0.02944673f, 0.27242836f, -0.01010939f, -0.21046345f, 0.00923645f, 0.16051824f, 
    0.04687860f, 0.01832932f, 0.02958628f, -0.12125450f, 0.21973094f, 0.26633465f, -0.01404704f, -0.01248867f, 
    -0.00289437f, -0.10542669f, -0.09644622f, 0.18192087f, 0.01737211f, 0.05890018f, 0.00446039f, 0.03654953f, 
    -0.17654303f, -0.47295457f, 0.05568149f, 0.13016003f, 0.06646846f, 0.18869346f, 0.20757180f, -0.12919725f, 
    0.03363962f, -0.02965768f, -0.02200193f, 0.03696046f, 0.01610334f, 0.00646926f, 0.02504562f, -0.09155034f, 
    -0.01271056f, 0.02033766f, -0.02559597f, -0.04122673f, -0.06861968f, -0.13240099f, -0.02692467f, 0.05127413f, 
    -0.17914905f, -0.15122235f, -0.43093762f, 0.18688121f, 0.05679078f, 0.14351442f, 0.08142914f, 0.08156294f, 
    0.04085479f, -0.01627943f, 0.02869727f, 0.07433826f, -0.08949603f, -0.43001455f, -0.05540733f, 0.06907918f, 
    -0.13337001f, 0.00581610f, 0.05247402f, 0.19919601f, 0.00541187f, 0.12102184f, 0.12201905f, -0.04729456f, 
    -0.05312182f, -0.00635947f, 0.08581518f, 0.09084090f, 0.13307625f, -0.00653821f, 0.12469684f, -0.10148883f, 
    0.00559776f, 0.10574978f, 0.06223550f, -0.07126003f, -0.47235268f, -0.54400247f, -0.57744020f, -0.30661610f, 
    -0.06019077f, -0.24783212f, -0.03130076f, -0.30335990f, 0.03040264f, 0.03021372f, -0.07885919f, 0.02641552f, 
    -0.02211430f, 0.06184070f, -0.11030009f, -0.31594294f, -0.07824416f, -0.14523028f, 0.16639978f, 0.19408466f, 
    0.04858917f, 0.11532415f, -0.02289345f, 0.09167083f, -0.02434031f, -0.09513339f, -0.00061417f, 0.12108529f, 
    -0.12176111f, -0.38171396f, -0.21006207f, 0.27596587f, -0.12610906f, -0.02465759f, -0.07120974f, -0.02393059f, 
    0.09373009f, -0.31554538f, -0.18277115f, -0.29225999f, 0.01551216f, 0.08776236f, 0.16434717f, -0.08654319f, 
    0.00688975f, 0.01797289f, 0.00702191f, 0.08781637f, -0.59419483f, -0.70323139f, -0.39687154f, -0.28172049f, 
    -0.07788175f, -0.11842100f, -0.12515488f, -0.26625738f, -0.03054638f, 0.04734587f, -0.02099592f, -0.03555601f, 
    -0.22931540f, 0.33765015f, -0.07761608f, 0.14809640f, -0.09361354f, 0.10658320f, 0.05362595f, 0.22648157f, 
    0.05392316f, 0.04637753f, 0.09835430f, -0.11909882f, -0.24166976f, 0.20118625f, 0.39802995f, 0.10329714f, 
    -0.04927542f, -0.12915808f, 0.09428129f, 0.02499910f, -0.14557315f, 0.24487354f, -0.05637657f, 0.07275236f, 
    -0.03789088f, -0.01519227f, 0.09035366f, -0.07820570f, 0.06145724f, -0.01547774f, 0.05613133f, -0.05182534f, 
    -0.03029624f, -0.04855516f, -0.00762928f, 0.06362326f, -0.55132067f, -0.50226265f, -0.18381700f, -0.34321710f, 
    -0.22062041f, -0.25621006f, -0.23476002f, -0.15831569f, 0.01440783f, -0.02062749f, -0.05108355f, -0.04259150f, 
    0.26858500f, -0.00354988f, 0.02546664f, -0.09883241f, 0.00264140f, -0.01762219f, 0.08715735f, -0.12465233f, 
    0.05473024f, -0.02778926f, 0.03861770f, 0.16218346f, -0.46839166f, 0.22090089f, 0.31465277f, -0.01443466f, 
    -0.14509681f, 0.06541940f, -0.04778024f, -0.21881159f, 0.02192720f, 0.01355461f, 0.00160667f, 0.00435923f, 
    0.03418143f, 0.00269063f, -0.24671690f, -0.36436960f, -0.08373368f, -0.02179362f, 0.00431089f, 0.04142273f, 
    -0.03867551f, 0.07763334f, -0.07542115f, -0.10500129f, -0.73661947f, -0.77406150f, 0.06330272f, 0.27401924f, 
    0.00625330f, -0.06691682f, -0.07363976f, -0.19350563f, -0.01008041f, 0.04832905f, 0.02021112f, -0.05899511f, 
    0.01940757f, 0.07429826f, -0.10728683f, -0.13731402f, 0.01078153f, -0.00884789f, 0.04301879f, -0.07189026f, 
    -0.10038973f, 0.00071786f, 0.04710995f, 0.10436030f, -0.28659979f, -0.21289405f, 0.29004797f, -0.05366533f, 
    -0.01214330f, 0.05126462f, -0.05457024f, 0.00847231f, -0.03166883f, 0.09000637f, 0.10061887f, 0.06101228f, 
    -0.27515399f, -0.02718924f, -0.09058286f, -0.23775186f, 0.09506586f, 0.10206214f, -0.18895917f, -0.17495179f, 
    -0.00633719f, -0.02562948f, -0.07258292f, -0.00253529f, -0.15977091f, -0.01489651f, 0.21313418f, -0.04345802f, 
    0.00295339f, -0.10748942f, -0.02155773f, 0.00968757f, 0.07399281f, 0.11634615f, -0.00652657f, -0.04440977f, 
    -0.28317869f, -0.25085527f, 0.30351171f, -0.18090811f, 0.07549106f, -0.00320881f, -0.08075631f, 0.01308632f, 
    0.02712114f, 0.02195763f, 0.03145392f, -0.12532999f, 0.19285545f, 0.20153187f, -0.05429454f, -0.10780222f, 
    -0.02341770f, -0.23719209f, -0.03843071f, -0.03141744f, -0.01253098f, -0.01650562f, -0.04064516f, 0.02977819f, 
    0.02009599f, -0.13954756f, -0.03480354f, 0.11108479f, 0.05034129f, -0.00622290f, -0.06333519f, -0.14797507f, 
    0.00107276f, -0.01179573f, -0.02991723f, 0.01140313f, 0.11645468f, -0.02643199f, -0.27857435f, -0.18172219f, 
    0.03339532f, -0.16111538f, 0.11468364f, 0.11088977f, 0.05086799f, 0.03778075f, 0.09489896f, -0.09285197f, 
    0.11836396f, -0.10313731f, -0.07817963f, -0.29947010f, 0.00944005f, 0.04836144f, 0.06218312f, -0.07187939f, 
    -0.02043448f, 0.02517512f, -0.04904587f, -0.11400588f, -0.23772494f, -0.05080635f, -0.00383897f, 0.34942967f, 
    0.10784423f, -0.04604157f, 0.11531723f, 0.19893341f, 0.05339707f, 0.09293566f, 0.14206384f, -0.03806971f, 
    -0.33003259f, -0.58902162f, -0.26766053f, 0.44592959f, -0.02233157f, 0.14271498f, 0.08398303f, 0.01628947f, 
    0.06324871f, 0.03792761f, -0.02927862f, -0.04125104f, 0.23434611f, 0.05621339f, -0.13722262f, 0.01867213f, 
    -0.04579074f, 0.01869662f, 0.05425158f, 0.10244140f, 0.08127348f, 0.15036604f, 0.19206093f, 0.05106293f, 
    -0.13590722f, -0.30751550f, -0.26624054f, 0.13979688f, 0.14580441f, 0.27819684f, 0.10681535f, -0.25615847f, 
    0.07426016f, -0.14671896f, 0.02555024f, 0.04029205f, -0.21989675f, -0.18749976f, 0.10775038f, 0.21210402f, 
    0.12517202f, 0.03410390f, 0.06312577f, -0.04021744f, 0.02211139f, -0.02674677f, 0.11606544f, 0.07872685f, 
    -0.01815795f, -0.28436503f, -0.22225893f, -0.14677836f, 0.03258817f, 0.08865213f, 0.03466533f, -0.01274278f, 
    0.05732803f, 0.05960736f, 0.08143569f, -0.09055131f, -0.14386925f, -0.05592543f, -0.05888509f, -0.00361658f, 
    0.03335923f, 0.10749123f, -0.02614671f, 0.01805340f, 0.02767911f, 0.07640694f, 0.03549161f, 0.14326179f, 
    0.03106255f, -0.01350733f, -0.03991633f, -0.01622419f, 0.00477531f, -0.00183947f, 0.08870307f, 0.09016860f, 
    0.12808044f, 0.23767713f, 0.04245358f, 0.23689522f, 0.17785022f, -0.15089057f, 0.04757505f, 0.03446653f, 
    -0.08471479f, -0.00864337f, -0.11176746f, 0.07924902f, 0.02771131f, 0.15103322f, 0.20335652f, -0.09540205f, 
    -0.32410786f, 0.05993339f, 0.19417104f, 0.10993715f, -0.00937443f, -0.00433770f, 0.03044242f, 0.01630463f, 
    -0.03972451f, 0.00447096f, 0.14287540f, 0.11223312f, 0.27146122f, 0.19824378f, -0.14245060f, -0.01649052f, 
    -0.10845070f, -0.00954863f, 0.01254693f, 0.12656012f, 0.13030721f, -0.00075172f, 0.03918821f, -0.04400587f, 
    -0.23989542f, -0.28911906f, 0.00580985f, 0.16762510f, 0.07909653f, 0.20857470f, 0.10036528f, -0.11014278f, 
    0.06910519f, -0.03210819f, -0.06026546f, 0.08907629f, -0.20539419f, -0.29926661f, -0.10797777f, 0.09113526f, 
    0.12138525f, 0.04210881f, -0.03754563f, 0.06718015f, -0.01604070f, 0.01010885f, 0.02435502f, -0.03760597f, 
    0.08341686f, -0.06236080f, 0.06653227f, -0.06741060f, -0.06476852f, -0.04157626f, 0.03804180f, -0.17490745f, 
    -0.02212700f, -0.06005192f, -0.00523636f, -0.08213033f, 0.44714218f, 0.23449278f, -0.34450543f, 0.19179422f, 
    -0.03511599f, -0.05126381f, 0.09550545f, 0.04449403f, 0.11414233f, 0.02175567f, -0.01857933f, 0.01155112f, 
    0.32905611f, 0.01825954f, 0.05497295f, -0.14969879f, 0.01277824f, -0.00411158f, 0.05778685f, 0.00146554f, 
    0.06942256f, 0.12971351f, 0.12367450f, -0.04466337f, 0.04629815f, -0.06073477f, 0.15107471f, 0.13470328f, 
    -0.00792332f, -0.04799647f, -0.01348259f, 0.05192997f, -0.06217434f, -0.01637587f, -0.04715047f, 0.08200004f, 
    -0.35435390f, -0.26051614f, -0.10335132f, -0.25117671f, -0.01338182f, -0.04687972f, 0.03361689f, 0.04955786f, 
    0.03384655f, 0.02690962f, 0.01915194f, 0.01284499f, 0.02225096f, -0.64503872f, -0.33163139f, 0.06034562f, 
    -0.00511151f, -0.16613249f, 0.00056632f, -0.01937632f, -0.07344813f, 0.02450941f, 0.10658149f, 0.02337286f, 
    -0.55825180f, 0.35269645f, 0.18219160f, 0.03757373f, 0.05842798f, -0.09235863f, -0.15092388f, -0.05463509f, 
    -0.05546959f, 0.00267915f, 0.03694640f, 0.02531921f, 0.02178691f, -0.05846506f, -0.09720746f, 0.05693790f, 
    -0.02541486f, 0.02596295f, -0.04417727f, -0.07699424f, -0.12229402f, 0.01994612f, 0.06518593f, 0.01421856f, 
    0.19853005f, 0.05663059f, -0.07096687f, -0.27371952f, 0.01351590f, 0.01186062f, -0.01319869f, 0.09526784f, 
    0.00350661f, 0.05065083f, 0.03205642f, 0.08644149f, -0.22115470f, -0.06606389f, -0.02154175f, -0.01613940f, 
    -0.05173739f, -0.09272736f, -0.01874236f, 0.01121208f, 0.02013053f, 0.06117206f, 0.03011959f, 0.05927074f, 
    0.20629989f, 0.03548896f, -0.04580637f, -0.21297197f, -0.01789060f, -0.06181156f, 0.17034331f, 0.03776853f, 
    0.02105600f, 0.10373437f, -0.05609891f, -0.14844579f, -0.02574456f, 0.03039621f, 0.15435421f, -0.03536613f, 
    0.07759214f, -0.01808936f, 0.15150920f, -0.12126429f, -0.05219042f, 0.05891994f, -0.07293642f, 0.14005139f, 
    -0.10625488f, 0.11229845f, 0.04098407f, 0.23242402f, -0.12156766f, 0.03769606f, -0.07323483f, 0.02044933f, 
    -0.13404033f, -0.01981694f, 0.09251884f, 0.14743415f, -0.37792721f, -0.11823519f, 0.26452106f, 0.22571056f, 
    -0.11052442f, 0.04418387f, 0.00724982f, -0.13461785f, -0.06805398f, 0.00009177f, -0.05775774f, -0.03229141f, 
    0.05257307f, 0.09853724f, 0.07774251f, -0.11891936f, -0.03706756f, 0.09155296f, 0.04753422f, 0.01976191f, 
    0.04763195f, -0.00157908f, 0.03171152f, -0.13989015f, -0.04546488f, 0.09147613f, -0.02454180f, 0.02163106f, 
    -0.09120524f, -0.10169748f, 0.06225039f, -0.12631588f, 0.04797370f, 0.01718192f, 0.03914691f, -0.06890295f, 
    -0.22127542f, -0.20180663f, -0.14493927f, -0.07261360f, 0.08952870f, -0.01793449f, 0.04654773f, 0.04316103f, 
    0.04190143f, 0.04501908f, -0.02841103f, -0.04722876f, 0.05322590f, 0.08851338f, -0.04518374f, -0.04131102f, 
    0.05696375f, -0.03693324f, 0.02843629f, 0.01818320f, 0.01185633f, -0.06377700f, 0.00261976f, 0.03991446f, 
    -0.07631620f, -0.27471247f, -0.17378955f, 0.26098260f, -0.02052016f, -0.08840741f, 0.01890065f, 0.09370973f, 
    0.02197549f, 0.00357779f, -0.04785432f, -0.00311113f, -0.26671457f, -0.49413648f, 0.04522929f, -0.37628841f, 
    0.01454295f, -0.03248183f, -0.00992972f, -0.04324247f, 0.10328167f, 0.03720359f, 0.00608724f, 0.00389158f, 
    0.01710387f, 0.00666240f, -0.11274413f, 0.01456806f, -0.11111694f, -0.09883304f, 0.07130464f, 0.01058337f, 
    -0.00353088f, 0.04858122f, 0.04870732f, -0.00659563f, -0.00698301f, 0.10794427f, 0.04374779f, 0.00370815f, 
    0.02172959f, 0.01607718f, 0.02271341f, -0.00115020f, -0.14197835f, 0.00976604f, 0.01707703f, 0.03588571f, 
    -0.22594276f, 0.05001558f, -0.17170246f, -0.06910194f, -0.00736477f, -0.02225389f, 0.08326963f, -0.04935107f, 
    -0.04422682f, 0.02508627f, -0.03086594f, 0.00748599f, -0.07826665f, -0.01715349f, -0.07540364f, 0.01131899f, 
    0.00369943f, 0.01598942f, 0.03588885f, 0.03502360f, 0.15778734f, -0.05521103f, 0.04441039f, 0.06526941f, 
    0.03287510f, 0.12246843f, 0.07519133f, -0.18440686f, -0.02736101f, -0.01839897f, -0.08406862f, -0.01778452f, 
    -0.00183739f, -0.00198491f, 0.08784685f, 0.01933017f, 0.03885608f, -0.00561102f, 0.02997412f, -0.17641437f, 
    0.02934545f, 0.02027749f, 0.00201342f, -0.04362593f, -0.01736646f, 0.07454985f, -0.08163963f, -0.12208281f, 
    0.18662058f, -0.53708059f, 0.09796210f, -0.16373624f, 0.00837493f, -0.06046616f, -0.00759371f, -0.12587075f, 
    0.05370198f, 0.03416499f, -0.01446384f, 0.00127642f, 0.28220871f, -0.62707090f, -0.16837753f, -0.12744258f, 
    -0.04747128f, -0.02115094f, 0.07147282f, 0.23042883f, 0.01457079f, -0.13414305f, 0.04075877f, -0.02648401f, 
    -0.00815250f, -0.22024791f, 0.15629159f, -0.09014056f, -0.08569098f, -0.00546630f, 0.04125295f, 0.11546960f, 
    -0.19770031f, 0.09692594f, -0.09603292f, -0.09831655f, -0.47986403f, -0.29244107f, 0.42873931f, 0.55270034f, 
    0.09246460f, 0.05115941f, -0.09036244f, 0.11354388f, 0.00321394f, -0.09291185f, -0.05681702f, -0.00907544f, 
    -0.45595941f, -0.09386914f, -0.31950906f, -0.01467317f, 0.19403823f, -0.09080441f, -0.04226132f, -0.00635853f, 
    -0.03591729f, -0.03364030f, -0.01608704f, -0.00184173f, 0.14594182f, 0.02595434f, -0.02809890f, 0.03076219f, 
    -0.29854277f, 0.05348155f, -0.02964877f, -0.11105959f, -0.02230443f, 0.10094015f, 0.04973894f, -0.02365085f, 
    -0.23008543f, 0.29777655f, -0.14417112f, 0.04949470f, -0.14314499f, 0.02150173f, 0.08106706f, 0.06633929f, 
    0.01963293f, -0.01853880f, 0.10496666f, 0.05027108f, -0.27691892f, -0.35063145f, -0.17657511f, 0.10138648f, 
    0.02240716f, 0.02882193f, 0.13099225f, 0.05175874f, 0.00516818f, -0.01899809f, -0.04049732f, -0.02931052f, 
    -0.38911560f, -0.11921869f, 0.03624469f, 0.03171897f, 0.01754427f, 0.00019448f, 0.14933683f, 0.00610875f, 
    -0.06640081f, 0.09110997f, 0.06173102f, -0.02480716f, 0.50115162f, -0.01925734f, -0.04073626f, -0.44969955f, 
    0.07061769f, 0.07909320f, -0.18578961f, 0.11873684f, -0.01947091f, 0.01965157f, -0.08708010f, -0.17013876f, 
    -0.08208402f, 0.06651060f, -0.03784183f, 0.00562188f, -0.02817925f, -0.03572221f, -0.01399333f, -0.01945237f, 
    0.06737585f, 0.02699828f, 0.01100496f, -0.01161579f, -0.59539086f, -0.34521928f, -0.24136993f, 0.49445987f, 
    -0.00136556f, 0.01581443f, 0.00699882f, 0.06008690f, -0.00291844f, 0.00757847f, 0.01766643f, 0.05261587f, 
    -0.02350266f, 0.21757399f, 0.05966806f, 0.32154548f, 0.05756021f, 0.05366322f, -0.03987647f, -0.02486963f, 
    0.02148187f, 0.13412903f, 0.00211202f, 0.00188354f, 0.28752115f, -0.25309500f, -0.15520820f, -0.12930740f, 
    0.05524049f, -0.11288989f, 0.02687002f, 0.13596062f, 0.05270150f, 0.08726464f, -0.00043211f, 0.00341764f, 
    -0.13464563f, -0.06284808f, -0.08447842f, -0.06374557f, -0.00526911f, -0.07410919f, 0.01380487f, -0.02973059f, 
    0.06023120f, -0.04603777f, 0.00214414f, -0.02644921f, -0.19145545f, -0.39101613f, -0.31463608f, -0.35704932f, 
    0.02950555f, 0.00890149f, -0.02897275f, 0.15029337f, 0.05316358f, -0.02591131f, -0.02342582f, 0.01087596f, 
    -0.23097454f, 0.18507826f, -0.12685023f, 0.15983342f, 0.04843656f, 0.02273587f, -0.21965678f, -0.06024687f, 
    -0.04743895f, 0.02205454f, -0.09853054f, 0.13276862f, 0.53700775f, 0.17796427f, -0.44909373f, -0.62897623f, 
    -0.02969422f, 0.00218744f, -0.27620733f, 0.01286605f, -0.07485592f, 0.20684598f, -0.01746232f, 0.04186455f, 
    -0.38248423f, -0.09812807f, 0.29338062f, 0.13901107f, -0.06166539f, -0.04550127f, -0.14109075f, -0.04934159f, 
    -0.00057522f, 0.04115296f, 0.06454044f, 0.00103882f, 0.19351807f, -0.01349303f, -0.08614711f, -0.17399524f, 
    0.02468793f, 0.09533390f, 0.03792063f, 0.04604564f, -0.03679145f, 0.02012565f, -0.11550688f, -0.03034295f, 
    -0.52113503f, 0.37669218f, -0.34563029f, 0.46916991f, 0.01104368f, 0.19885941f, 0.12627684f, -0.00824217f, 
    -0.03618348f, -0.02403195f, -0.10463186f, -0.03628511f, -0.28729421f, -0.02402861f, 0.02825987f, 0.08984354f, 
    0.04266972f, 0.05034367f, 0.02560351f, 0.00412972f, -0.08148371f, -0.04831031f, 0.02019850f, 0.05233296f, 
    -0.01893127f, 0.08152854f, 0.02131364f, -0.10008594f, -0.08167523f, -0.11098068f, -0.16774985f, -0.04787907f, 
    0.00225738f, -0.02967971f, 0.09131931f, 0.05945880f, -0.05618655f, -0.18357415f, 0.37963015f, 0.02382955f, 
    -0.04879871f, -0.01940751f, -0.11756235f, -0.08274934f, 0.00363299f, 0.00516104f, -0.04744849f, -0.07216579f, 
    -0.00248763f, -0.01309724f, 0.07580468f, -0.04905324f, 0.05128091f, 0.03219191f, -0.02625022f, -0.01533014f, 
    0.01154142f, -0.03618024f, 0.04194655f, 0.03037474f, -0.09696577f, -0.47913530f, -0.37171024f, -0.24357063f, 
    0.00503222f, 0.14166486f, -0.01506034f, 0.02306169f, 0.08885115f, 0.03632043f, 0.02571518f, 0.02063329f, 
    -0.24704970f, -0.54915535f, 0.30965146f, -0.11332455f, -0.00383479f, -0.11121309f, 0.03023443f, 0.00034790f, 
    0.00399516f, -0.02439912f, 0.01858946f, -0.04679983f, -0.04362423f, -0.04735853f, 0.03295014f, -0.01746048f, 
    -0.01276488f, 0.00221565f, -0.06858492f, -0.01409232f, 0.11655796f, -0.07773028f, -0.02677711f, 0.06028915f, 
    -0.44966400f, -0.09030549f, 0.28841567f, -0.25786459f, 0.01047151f, 0.04939244f, 0.08633088f, 0.02690981f, 
    -0.07163936f, -0.04493128f, -0.00991193f, -0.06504789f, -0.05244299f, 0.02275128f, 0.04437643f, -0.12057766f, 
    0.02121783f, -0.06949367f, -0.03721831f, 0.05606806f, 0.01288746f, 0.04214555f, 0.05022412f, -0.00008610f, 
    0.10391488f, -0.13198656f, 0.14555027f, -0.02289964f, -0.01423904f, -0.04301500f, -0.10235322f, 0.00135218f, 
    0.10902205f, -0.04128175f, 0.05712844f, -0.03378918f, 0.00425327f, 0.14627767f, 0.23297924f, 0.08252785f, 
    -0.06665828f, 0.00466468f, 0.04492393f, -0.01612397f, 0.07104831f, -0.09036711f, 0.03529912f, -0.01247465f, 
    0.16780813f, 0.09388006f, 0.02223637f, -0.02036312f, 0.00643740f, -0.03776433f, 0.00610856f, -0.01684864f, 
    0.02158264f, 0.04958392f, 0.00157999f, 0.08145673f, 0.10514133f, -0.01808161f, -0.00481114f, -0.07355575f, 
    -0.03451622f, -0.01774669f, -0.01293161f, 0.01767309f, -0.08567723f, -0.18132645f, -0.00231814f, -0.33801875f, 
    0.36727998f, -0.32938370f, -0.02369197f, -0.23730545f, 0.01477143f, 0.01133287f, -0.07486735f, 0.04028727f, 
    0.21115571f, 0.06633087f, 0.01086516f, -0.02433700f, -0.26604003f, -0.09170852f, -0.16171731f, -0.09382176f, 
    -0.01512162f, -0.06163647f, 0.04741871f, -0.15375131f, -0.04463096f, -0.01041972f, 0.07601316f, 0.03924700f, 
    0.00805256f, -0.01578197f, 0.09959508f, -0.08705879f, -0.17279638f, -0.00234330f, 0.04960371f, 0.03450018f, 
    -0.06955305f, 0.02255316f, 0.05648047f, -0.06579897f, -0.02662180f, 0.05446839f, 0.10857939f, -0.06072516f, 
    -0.05310496f, 0.00645666f, -0.00686739f, 0.01336975f, 0.05528329f, -0.01022349f, -0.04239386f, -0.02674459f, 
    -0.01208196f, 0.10101500f, -0.02501981f, -0.00904944f, 0.04958513f, -0.11285929f, 0.06906419f, -0.06082195f, 
    0.00216190f, 0.02655419f, 0.03434103f, -0.03117820f, -0.02061176f, -0.19515356f, 0.00189349f, 0.06816857f, 
    0.01756314f, -0.03382135f, -0.06230468f, -0.02690792f, -0.15605663f, 0.01589330f, -0.05766428f, 0.04067859f, 
    -0.13553759f, 0.12069406f, 0.06711976f, 0.03951316f, -0.04107131f, 0.04385161f, 0.00512685f, 0.00784811f, 
    0.08767208f, 0.12060478f, 0.07920376f, 0.02924752f, 0.10487400f, 0.11548710f, -0.00487842f, -0.10200427f, 
    0.01215493f, 0.05145552f, 0.02793724f, -0.04589099f, -0.08713546f, 0.04424337f, -0.05090673f, -0.34965327f, 
    -0.15831789f, 0.26356694f, 0.15314965f, 0.02898872f, 0.18753819f, -0.27708173f, 0.09925943f, -0.09358954f, 
    -0.01893562f, -0.01481255f, -0.01292911f, 0.05054025f, -0.13070555f, -0.22259589f, 0.22516923f, 0.27340963f, 
    0.02216915f, -0.07712862f, -0.11310268f, 0.17618626f, -0.04621302f, -0.01093704f, -0.11467257f, -0.10034060f, 
    -0.22679143f, -0.11866951f, 0.05267254f, -0.07892648f, -0.05547700f, -0.16894706f, 0.03558090f, -0.02481990f, 
    0.04211401f, 0.18238258f, 0.04715751f, 0.06100450f, 0.15645167f, 0.01835491f, -0.08087464f, -0.04857664f, 
    0.02185643f, -0.03469330f, -0.03414707f, -0.01883410f, -0.20112827f, 0.11195210f, -0.04346210f, -0.01231077f, 
    -0.32674450f, 0.04514779f, -0.25832689f, 0.21182473f, -0.09709746f, 0.00706990f, 0.01563351f, -0.01513482f, 
    0.05402301f, 0.02943995f, -0.02811631f, -0.05557293f, 0.19907954f, 0.03971452f, 0.02009377f, -0.08487784f, 
    -0.14409558f, 0.03125340f, 0.05342492f, 0.00553362f, 0.01294073f, 0.03556265f, -0.01468749f, 0.01490061f, 
    -0.01637246f, -0.07728702f, 0.00685091f, 0.04717883f, 0.03656550f, -0.00383065f, -0.04002032f, -0.11415171f, 
    -0.11572734f, -0.08608295f, -0.15859446f, 0.06825966f, -0.07276288f, 0.11268899f, 0.26259914f, -0.02829999f, 
    -0.13877517f, -0.04620492f, 0.04792024f, 0.07573900f, -0.15484573f, -0.00628514f, 0.02423226f, -0.02858405f, 
    0.34835732f, 0.30176488f, -0.21558508f, -0.12805800f, -0.01974742f, 0.03555850f, -0.14831148f, -0.08293457f, 
    -0.04189048f, 0.06105465f, 0.05332521f, -0.03535905f, 0.07477918f, 0.02463022f, 0.09224703f, -0.03249985f, 
    0.08068713f, 0.11453936f, -0.00701816f, -0.06799756f, -0.03977673f, 0.07967052f, 0.06490205f, 0.02652922f, 
    -0.04632962f, 0.10353225f, 0.00579476f, -0.25046250f, -0.00862176f, -0.08798544f, -0.03778543f, 0.02706640f, 
    0.13694738f, 0.14332180f, -0.05844606f, 0.14550200f, -0.10270212f, 0.06825536f, 0.02023106f, 0.09934475f, 
    0.06272823f, -0.04380434f, 0.11118171f, -0.10034851f, 0.17470121f, 0.03736972f, 0.06053235f, 0.07832883f, 
    -0.05398574f, -0.25738850f, -0.26098526f, -0.05727609f, -0.02274411f, 0.04978776f, 0.05709337f, 0.19653094f, 
    -0.11369997f, -0.04532360f, -0.04774806f, 0.01952027f, -0.15964240f, -0.12397553f, -0.02308189f, 0.03094003f, 
    -0.02945972f, 0.00965389f, 0.07511339f, 0.04397205f, 0.11023829f, -0.01023252f, -0.04112015f, -0.02250635f, 
    -0.24159850f, -0.46528283f, -0.50114954f, -0.19424541f, 0.22363642f, -0.18415338f, 0.01532744f, 0.04785005f, 
    0.00127893f, 0.00172480f, 0.02405262f, 0.00095042f, 0.24133371f, -0.31720847f, -0.19706155f, -0.33663523f, 
    0.20130752f, 0.10863372f, 0.11561877f, 0.12311933f, -0.01488426f, -0.13861647f, -0.12795208f, -0.32315636f, 
    0.07280261f, 0.07236357f, 0.08402800f, -0.06973859f, 0.00479498f, -0.06722929f, -0.01361990f, -0.00063664f, 
    -0.03767890f, -0.03100700f, -0.05034768f, -0.01322316f, 0.03672051f, -0.06601477f, 0.14429301f, 0.00843943f, 
    0.07831499f, -0.02241615f, 0.02600424f, 0.01114158f, -0.00482322f, 0.10952780f, -0.00199408f, -0.09636021f, 
    0.26464993f, 0.03154797f, -0.00375186f, 0.00268930f, -0.15469636f, -0.04472405f, 0.19497451f, -0.08323958f, 
    -0.00887932f, 0.03228793f, 0.07060523f, 0.21689877f, -0.22747609f, -0.30689806f, -0.05986788f, 0.07647338f, 
    0.03031620f, 0.04043986f, 0.02812082f, 0.10021224f, 0.02070348f, -0.03054522f, -0.15758102f, -0.15747726f, 
    -0.45141387f, 0.18565711f, 0.07791996f, 0.06700327f, -0.07222991f, -0.03884441f, -0.14374529f, -0.24106269f, 
    -0.01650777f, 0.00464401f, -0.07462426f, -0.01384234f, -0.01820133f, 0.06991050f, -0.17521648f, -0.30220059f, 
    -0.05100301f, -0.04011979f, -0.02156188f, -0.09144351f, -0.10164395f, -0.00149401f, -0.13630809f, 0.01041813f, 
    0.65640998f, 0.19395539f, -0.00326300f, -0.17499226f, 0.06096955f, 0.12697083f, 0.01663715f, -0.25892580f, 
    0.00570267f, 0.01407287f, -0.02220710f, -0.03566087f, 0.07194918f, -0.26427665f, -0.24500205f, -0.02548571f, 
    0.06320860f, -0.01899029f, 0.08408193f, -0.01312502f, -0.11114131f, -0.07789902f, -0.13141881f, -0.37219143f, 
    0.19995086f, 0.01600229f, 0.07649169f, 0.11319548f, 0.07843666f, 0.10203218f, 0.08712135f, 0.10989448f, 
    0.07596343f, -0.09630396f, 0.00172233f, -0.08555587f, -0.13577583f, -0.39298519f, -0.36646891f, -0.33392066f, 
    -0.15057002f, -0.26156524f, -0.12085635f, -0.05157954f, 0.06106515f, 0.10172087f, 0.07803558f, 0.03332413f, 
    0.31118378f, -0.24561308f, -0.02955410f, 0.10651489f, 0.07809119f, 0.09570701f, 0.08432750f, -0.02850949f, 
    0.12461502f, 0.18413340f, 0.07070272f, 0.11086545f, 0.12244990f, -0.08430397f, -0.06383070f, -0.09581172f, 
    0.14763288f, -0.14176296f, -0.05289361f, 0.06898784f, 0.09461658f, 0.10412633f, -0.02869587f, 0.12936760f, 
    -0.46988958f, 0.13077013f, 0.10085138f, 0.12763643f, 0.22627142f, -0.01847023f, -0.15133390f, -0.06401796f, 
    -0.20473401f, -0.01660931f, 0.01558833f, -0.07924668f, -0.13220266f, -0.46117234f, -0.37189853f, -0.12803344f, 
    -0.10796120f, -0.04953410f, -0.11210670f, -0.12088659f, 0.01573435f, 0.06712820f, -0.02437096f, 0.05064425f, 
    0.02807971f, -0.26163459f, 0.10475368f, -0.01366935f, -0.12468711f, 0.08949318f, 0.02605300f, -0.08595697f, 
    0.05677650f, -0.01684531f, 0.02844515f, 0.13078149f, 0.02093478f, -0.15186809f, -0.38853565f, -0.12956764f, 
    0.02371477f, -0.11142672f, 0.14641847f, -0.03584355f, 0.11287495f, 0.06143987f, 0.22160396f, -0.10347997f, 
    -0.24361865f, 0.02396612f, 0.06752235f, 0.05025095f, -0.02542283f, -0.06470320f, 0.08166440f, -0.03258930f, 
    -0.05139967f, 0.00351590f, -0.02504422f, 0.00556615f, 0.31411719f, -0.28199032f, -0.24860321f, -0.06628387f, 
    0.04384934f, -0.02551293f, 0.02637981f, 0.15414776f, -0.01552500f, 0.16317075f, 0.12065309f, 0.01050878f, 
    -0.69148678f, -0.24755545f, 0.23920999f, 0.33209437f, -0.07805339f, 0.00711267f, -0.19473830f, 0.07113539f, 
    -0.00191354f, 0.06248391f, 0.06506220f, -0.05415286f, -0.04064081f, -0.09643156f, -0.17042847f, -0.01830627f, 
    -0.08020161f, 0.07843071f, 0.10323802f, 0.08178674f, 0.09340133f, -0.43391493f, 0.03555481f, -0.09542224f, 
    -0.42804408f, 0.31012005f, 0.07291425f, -0.01187146f, 0.03109731f, 0.00028759f, -0.06542884f, -0.08235361f, 
    -0.04549510f, 0.03639404f, -0.13966386f, 0.08577786f, -0.15110329f, -0.51744926f, -0.41703832f, 0.02607115f, 
    0.06283756f, 0.11528672f, 0.10128077f, 0.02996447f, -0.12220265f, -0.00798528f, -0.03143359f, -0.05021142f, 
    0.25310129f, 0.10547426f, 0.01135006f, 0.11236919f, -0.00269755f, 0.01337977f, 0.05511143f, 0.13362418f, 
    0.10700309f, -0.02223792f, 0.12840737f, -0.11300264f, 0.13433224f, -0.21505409f, -0.47761187f, -0.48322409f, 
    -0.13717413f, 0.08269986f, 0.14184308f, 0.16344972f, 0.13216132f, -0.12971850f, 0.05491249f, 0.02743731f, 
    0.08283401f, 0.00626885f, 0.15658751f, -0.00037727f, -0.01137755f, -0.01896798f, 0.00275588f, -0.07075161f, 
    0.01815934f, 0.13005033f, 0.04009936f, 0.06549688f, -0.25643942f, -0.24055344f, -0.15528873f, -0.13466117f, 
    -0.07984018f, 0.03482191f, 0.04169028f, -0.02500507f, 0.10611974f, 0.12432332f, 0.09489095f, 0.12561667f, 
    -0.44630700f, 0.00961900f, 0.01315518f, 0.06496979f, -0.29479444f, 0.08359514f, -0.16206229f, -0.00452449f, 
    -0.01756983f, 0.05752361f, 0.18310249f, 0.02369277f, -0.16206515f, -0.24442184f, -0.07937175f, 0.10740889f, 
    -0.07420631f, 0.00619368f, -0.12820216f, 0.08530036f, -0.09433695f, 0.02073888f, -0.06419989f, -0.04801447f, 
    -0.10346919f, 0.03691398f, 0.05179757f, 0.01323789f, -0.00869591f, 0.04617581f, 0.02520301f, 0.02719105f, 
    -0.03021642f, 0.05686206f, -0.05419094f, 0.00878605f, 0.18287499f, -0.11945857f, -0.02898646f, -0.10363098f, 
    0.27777234f, 0.08223528f, -0.04996740f, 0.08321653f, 0.08414740f, 0.05624974f, 0.15369739f, 0.18766700f, 
    -0.19043031f, 0.10591005f, 0.10049066f, 0.03824524f, 0.02412590f, -0.05974891f, -0.05815918f, -0.02070382f, 
    -0.06726139f, 0.04071101f, 0.01876481f, 0.02511196f, -0.50418854f, -0.63175976f, 0.01389364f, 0.21992640f, 
    0.18214469f, 0.13574545f, 0.08491198f, 0.01984898f, -0.00291906f, 0.08738171f, -0.04757953f, -0.06283982f, 
    0.48189047f, -0.10513362f, -0.08495235f, 0.12669861f, 0.08095139f, 0.03060176f, -0.00901848f, -0.14607574f, 
    -0.03495642f, 0.12912484f, 0.11644185f, 0.04002675f, -0.26424679f, 0.02902627f, 0.02188040f, -0.01702356f, 
    0.06743793f, -0.08323725f, -0.02749866f, -0.05957191f, -0.23302199f, -0.22909552f, -0.22153376f, -0.25499171f, 
    0.02171683f, -0.01779195f, 0.09856266f, -0.09247380f, -0.02469804f, 0.06558368f, 0.00019059f, -0.01596335f, 
    -0.05751525f, -0.07455539f, 0.04001175f, -0.02138555f, 0.08984704f, 0.02215727f, -0.07091604f, -0.00884842f, 
    -0.01360019f, 0.03833070f, 0.06568173f, -0.22585517f, 0.02843217f, -0.02925111f, 0.00039355f, -0.09677832f, 
    0.07464602f, 0.13977039f, -0.13080780f, -0.20018812f, -0.03156164f, -0.01469773f, 0.08130822f, 0.05268834f, 
    -0.03290900f, 0.03551218f, 0.00268838f, -0.16348030f, -0.43090791f, -0.07704242f, 0.07546780f, -0.22778316f, 
    -0.08262584f, 0.12325133f, -0.06515943f, 0.04619104f, 0.06616113f, 0.16271669f, -0.03338881f, 0.17704256f, 
    -0.03596731f, 0.03319589f, -0.08398091f, 0.01540180f, 0.01079651f, -0.04808334f, 0.02414648f, -0.02663924f, 
    -0.26965609f, 0.03240148f, -0.29855871f, -0.12020709f, 0.02348367f, 0.13975891f, -0.16637090f, -0.17479263f, 
    -0.01986177f, -0.03226017f, -0.06808329f, -0.05820666f, 0.13239609f, 0.14374988f, 0.03848639f, 0.18920796f, 
    -0.50725806f, -0.24242625f, 0.04874512f, 0.07923984f, -0.04862517f, 0.06963953f, 0.04848913f, 0.00626759f, 
    -0.07022564f, 0.05704858f, 0.03390320f, -0.15664734f, -0.12538064f, -0.27184013f, -0.08672045f, 0.11122086f, 
    0.10328197f, 0.09740530f, -0.01944355f, 0.25287932f, -0.16678315f, -0.11643059f, -0.08266533f, -0.02455123f, 
    0.15787402f, 0.16528960f, -0.00225545f, -0.13422643f, -0.12476654f, -0.14248402f, -0.05964531f, -0.12150570f, 
    0.10488122f, 0.08464321f, -0.03767734f, 0.11024987f, -0.24431600f, 0.13672404f, 0.15047340f, -0.18014486f, 
    0.02324741f, -0.09112610f, 0.05598326f, -0.13647944f, -0.00986827f, -0.00089345f, 0.02107588f, -0.01070987f, 
    -0.14951330f, 0.06790065f, 0.03543024f, 0.04659390f, 0.02157992f, -0.02601459f, 0.03387106f, 0.06710964f, 
    0.09481364f, 0.05145351f, 0.02488535f, 0.07762643f, -0.38999316f, 0.17563692f, -0.04840234f, 0.04226400f, 
    0.11420265f, 0.06837224f, -0.00149913f, 0.01424717f, -0.05333571f, 0.09277462f, 0.02666690f, 0.20151709f, 
    -0.30603635f, 0.10227141f, 0.04584296f, 0.19742282f, 0.03085190f, -0.00254124f, -0.25353736f, 0.12127469f, 
    -0.09821009f, 0.02689106f, -0.14426599f, -0.09194765f, 0.15012382f, -0.07073083f, -0.02735083f, -0.09478117f, 
    -0.13610907f, -0.06853679f, -0.01061466f, -0.10382549f, 0.19283812f, 0.00591727f, 0.17276329f, 0.09132925f, 
    0.12337346f, -0.02499564f, 0.22289340f, 0.04261768f, 0.01346628f, -0.07577247f, -0.04115518f, -0.09469188f, 
    0.03375296f, 0.03392768f, -0.00436987f, 0.08440199f, 0.34825221f, 0.06096994f, -0.14641450f, -0.21033612f, 
    0.02363223f, 0.00573236f, 0.01500847f, -0.04032528f, 0.08559306f, 0.08954605f, 0.17272623f, 0.14361489f, 
    -0.25428799f, -0.60963821f, -0.16305223f, -0.12798718f, 0.07413901f, 0.25726855f, 0.03648339f, -0.06386602f, 
    -0.01617240f, -0.01355170f, 0.08480531f, -0.02529154f, 0.01030456f, 0.02655379f, 0.03216009f, -0.02227210f, 
    -0.02748488f, 0.03770458f, 0.01279613f, 0.01183995f, -0.00549599f, 0.03160692f, 0.07228480f, 0.05386616f, 
    0.00009461f, -0.06888708f, -0.08347672f, -0.04025197f, 0.02864612f, 0.03612156f, -0.07310160f, 0.15445432f, 
    -0.08626827f, -0.04740748f, -0.16554475f, -0.44774032f, 0.11204040f, -0.10303891f, -0.19366261f, -0.23571266f, 
    -0.07124694f, 0.08808176f, -0.10506862f, -0.01274311f, 0.03841639f, 0.14644155f, 0.15540476f, 0.17265366f, 
    0.05521063f, 0.12359669f, -0.04868394f, 0.08690000f, 0.08453924f, -0.04349639f, -0.07141267f, 0.03403409f, 
    0.08460645f, 0.01706422f, 0.08305147f, -0.04169398f, -0.39815828f, -0.06799714f, -0.08729481f, 0.28285208f, 
    -0.02082247f, 0.10416623f, -0.09703887f, -0.04531207f, 0.11138269f, -0.10576376f, -0.16772908f, 0.08269902f, 
    0.21767625f, -0.02352216f, -0.22016798f, 0.00733777f, -0.01140678f, -0.00616835f, 0.14863411f, 0.08413966f, 
    0.06020460f, -0.07181942f, 0.08383205f, -0.03472816f, 0.07522283f, 0.12779419f, -0.17398326f, -0.20458339f, 
    -0.14786503f, -0.00518570f, 0.13047926f, -0.10598108f, -0.03864140f, -0.03222471f, 0.02211949f, 0.10784932f, 
    0.10280427f, -0.28062290f, 0.24377467f, -0.05571100f, 0.05163963f, 0.19917874f, -0.09616540f, -0.10358897f, 
    -0.00791001f, -0.11873902f, 0.05292442f, -0.11092884f, 0.01372877f, 0.00207631f, -0.09985138f, -0.07097392f, 
    0.10378206f, -0.05371303f, -0.00712810f, -0.10827882f, -0.13273653f, -0.03306087f, -0.07457981f, -0.06235109f, 
    -0.11999463f, 0.06961883f, -0.03238381f, -0.04042186f, 0.02678667f, 0.00973393f, 0.04894669f, 0.17229861f, 
    0.00887270f, -0.00346200f, 0.03035526f, 0.02613124f, 0.16202487f, 0.22105439f, 0.14573903f, -0.06771787f, 
    0.09350473f, -0.01764198f, -0.11288107f, 0.09062289f, 0.02486601f, 0.08551455f, 0.12210135f, 0.08301980f, 
    -0.09923764f, 0.16284481f, -0.09247070f, -0.11910617f, -0.09270727f, -0.16833936f, 0.13953234f, 0.08466563f, 
    0.02193134f, -0.00695647f, 0.02834944f, 0.03904907f, 0.13648283f, -0.14499651f, 0.24912409f, 0.05593615f, 
    0.11073954f, -0.02725017f, 0.01089914f, -0.07115831f, -0.07148381f, 0.10056794f, 0.07009029f, 0.09268303f, 
    0.08536591f, 0.10645244f, -0.50160992f, 0.09862769f, 0.19015847f, 0.12899520f, 0.15701070f, 0.02067661f, 
    0.05407888f, -0.01781190f, -0.11310862f, -0.06297752f, -0.31530473f, -0.25460175f, -0.00171424f, -0.21445678f, 
    -0.13871890f, 0.19877447f, -0.15106027f, -0.05949262f, 0.18843162f, -0.11596894f, -0.15855469f, -0.09599613f, 
    -0.20670570f, -0.03565033f, 0.16542615f, -0.32931185f, 0.07034613f, -0.23440982f, 0.16857594f, -0.01951924f, 
    -0.26625359f, 0.09559029f, -0.05943611f, 0.02044589f, -0.00851029f, 0.28581828f, 0.24621530f, -0.37262014f, 
    -0.09207247f, -0.15176220f, -0.04692734f, -0.13748412f, 0.02376093f, 0.10920519f, 0.13838251f, 0.09121893f, 
    0.31166789f, -0.29548138f, 0.04451122f, -0.12486966f, 0.10130451f, 0.21144658f, -0.11659253f, 0.13749622f, 
    -0.00246196f, -0.12488701f, -0.06065200f, -0.00952141f, -0.10501454f, -0.10300630f, 0.06930059f, 0.24305423f, 
    0.00728198f, 0.08432384f, 0.06338235f, -0.05177692f, -0.05511642f, 0.02999106f, -0.09111091f, 0.04560282f, 
    0.04696043f, -0.47294241f, 0.01430094f, -0.15851276f, 0.07203235f, -0.09276038f, -0.04411953f, -0.16982567f, 
    0.01085677f, -0.06143534f, 0.02259736f, -0.05382270f, -0.16034141f, -0.09646004f, 0.30913070f, 0.11777461f, 
    0.04312677f, -0.01466891f, -0.14456658f, -0.11618399f, 0.13378727f, 0.03029341f, 0.05325824f, 0.13780837f, 
    0.05889188f, -0.39258707f, -0.15221219f, 0.09453930f, -0.06370866f, 0.15195659f, -0.13366336f, 0.24647628f, 
    0.25831345f, 0.00351538f, -0.09860399f, -0.11387812f, -0.19347477f, -0.02315857f, -0.22793840f, -0.06308318f, 
    -0.25642261f, 0.09329272f, 0.15014160f, 0.15680969f, 0.11528791f, 0.10349632f, 0.01994310f, -0.05562382f, 
    -0.07966837f, 0.00018355f, -0.22610995f, -0.03102577f, 0.04059368f, -0.04075148f, 0.01111047f, -0.09196866f, 
    0.05347932f, -0.00841492f, -0.00169524f, -0.10698248f, -0.29539576f, 0.13825659f, 0.02250184f, 0.05046855f, 
    0.11744014f, -0.21042021f, 0.03401878f, -0.09798246f, 0.03822604f, -0.10828634f, -0.10909852f, -0.13612062f, 
    -0.06705705f, 0.33881846f, -0.53114384f, 0.15093805f, -0.15011945f, -0.05015844f, 0.24407808f, 0.12516987f, 
    0.01107788f, -0.01933261f, -0.11632456f, -0.07666750f, -0.17061689f, 0.15317684f, 0.28982717f, -0.25173786f, 
    -0.15326895f, 0.03822962f, 0.03998338f, 0.30027977f, 0.02745326f, 0.05499390f, 0.04403521f, 0.00909316f, 
    0.04236631f, -0.43041801f, 0.30912498f, -0.45085356f, 0.21893091f, -0.21637183f, 0.00754023f, -0.04563649f, 
    -0.13211003f, 0.08276831f, 0.02705397f, 0.13063914f, 0.10005965f, -0.11865766f, 0.34391227f, 0.18760008f, 
    0.10493217f, -0.08186544f, -0.11286154f, -0.10655785f, 0.11884747f, -0.06670350f, -0.16414709f, 0.15122880f, 
    -0.08493203f, -0.01381995f, -0.09526247f, -0.22424874f, 0.10552371f, 0.00952042f, -0.00164692f, 0.11191066f, 
    0.15372166f, -0.00887461f, -0.07548957f, -0.03646818f, 0.09099983f, 0.10908825f, 0.04932078f, -0.00440254f, 
    0.06058532f, -0.31768733f, 0.06874938f, 0.08450773f, 0.07219678f, 0.03783957f, -0.04240453f, 0.03443832f, 
    -0.20288177f, -0.29000506f, -0.08211596f, -0.43317002f, -0.03052929f, 0.04997725f, 0.01292560f, 0.13393234f, 
    -0.03910466f, 0.02941239f, -0.01935122f, 0.15269850f, 0.05399802f, 0.02645841f, 0.20181917f, 0.18661700f, 
    0.14196198f, -0.18985839f, -0.32349816f, 0.05465162f, 0.07995678f, -0.03695758f, 0.05754192f, 0.11285978f, 
    -0.25099629f, -0.05271407f, -0.21338741f, 0.06104268f, 0.13498364f, 0.01306908f, 0.08963007f, -0.07469798f, 
    0.13942458f, 0.01409716f, -0.02148826f, 0.02304023f, -0.39910996f, -0.09865314f, -0.13756233f, -0.58253062f, 
    -0.04441740f, -0.08655512f, 0.05819489f, 0.07745173f, 0.10821763f, -0.02207810f, 0.07292535f, 0.03963339f, 
    -0.15035407f, 0.03506282f, -0.39040861f, 0.19393392f, 0.02147223f, -0.03215336f, 0.03684493f, 0.06715617f, 
    0.09853843f, 0.04932576f, 0.05569133f, 0.02179558f, -0.29808262f, 0.09244039f, -0.40236714f, 0.52748638f, 
    -0.20510802f, 0.13685599f, -0.09172774f, 0.04048949f, 0.13345669f, -0.09169743f, 0.07397979f, 0.10198051f, 
    -0.10622244f, 0.21880376f, -0.42701519f, 0.28708798f, 0.02867583f, -0.05763239f, 0.15764560f, 0.05727458f, 
    0.07908756f, 0.04254303f, -0.08214472f, -0.05115797f, 0.27117774f, 0.19795363f, 0.30821693f, 0.26441911f, 
    0.10105354f, -0.06332110f, -0.11008957f, -0.06810790f, -0.17176600f, 0.04975317f, -0.05134360f, -0.03099164f, 
    -0.76035339f, 0.24822251f, 0.07162361f, -0.26610023f, -0.02503775f, -0.15321504f, 0.09308466f, -0.01189045f, 
    -0.07894155f, 0.05815293f, 0.01195528f, -0.06446505f, 0.20151989f, 0.25229454f, 0.18864343f, -0.54415476f, 
    -0.13261275f, -0.08225529f, 0.05906141f, -0.00071167f, -0.04641312f, 0.09113210f, -0.01070394f, 0.01363389f, 
    0.05948066f, -0.19285774f, 0.02235941f, -0.27349478f, -0.00709548f, 0.11345804f, 0.12208568f, 0.07643221f, 
    0.20136236f, 0.04622960f, -0.09195500f, 0.00626263f, 0.21314986f, -0.19975366f, -0.00278392f, -0.07179710f, 
    -0.06945173f, -0.09736186f, -0.01175117f, -0.00598220f, 0.03684448f, -0.05095499f, -0.07513845f, -0.07554299f, 
    -0.12503169f, -0.20663193f, -0.43342504f, 0.24220948f, 0.01098399f, 0.14737132f, 0.22808497f, 0.05666875f, 
    0.02991391f, -0.00412021f, -0.05761068f, -0.06745598f, 0.43385363f, -0.25463906f, 0.25246647f, -0.36923072f, 
    -0.17252836f, -0.15634935f, -0.01193125f, -0.03570455f, 0.03518692f, -0.01234313f, 0.02106421f, -0.08133311f, 
    -0.19235370f, -0.48019508f, 0.18419088f, -0.18275046f, -0.06032500f, -0.01483704f, -0.09223761f, -0.10674888f, 
    -0.02504616f, -0.00752361f, 0.01404687f, 0.07782931f, 0.00326304f, -0.01525154f, -0.01694880f, -0.05556993f, 
    0.05748725f, 0.01339743f, 0.06684967f, -0.08504965f, 0.08494561f, -0.00443724f, 0.13620259f, 0.04034736f, 
    0.08729757f, -0.36475289f, -0.07463239f, -0.70977175f, -0.16301528f, -0.29800037f, -0.09278409f, 0.22594929f, 
    -0.01701726f, 0.02306171f, -0.06547554f, -0.06777230f, 0.09957518f, -0.28079602f, -0.05752053f, -0.35431579f, 
    0.03476680f, 0.01579663f, 0.01475966f, 0.14626895f, 0.01540300f, 0.03522424f, -0.01812435f, -0.02391466f, 
    0.03519137f, -0.52045840f, 0.08619206f, 0.10114437f, -0.04884075f, 0.12900738f, 0.00266098f, -0.09286556f, 
    0.00117332f, 0.03918434f, -0.08651683f, 0.03524573f, -0.03764280f, -0.19538935f, 0.14808322f, -0.25496152f, 
    0.04220768f, -0.17794128f, -0.00992638f, -0.06193580f, 0.11125614f, -0.07835912f, -0.06587611f, 0.05759653f, 
    0.03021899f, -0.13778128f, 0.00706207f, 0.15297818f, 0.07311936f, 0.04581136f, 0.06643350f, -0.03162253f, 
    0.10388299f, 0.11760292f, 0.09575182f, 0.06111238f, -0.25361472f, 0.28882754f, 0.05401376f, 0.27529311f, 
    0.03654340f, 0.04294351f, 0.00680647f, -0.14757961f, 0.13888757f, 0.06634648f, 0.00933775f, -0.20419939f, 
    0.20153743f, 0.22822376f, 0.17037593f, 0.17824923f, -0.04996366f, -0.03658099f, -0.12138437f, -0.12177627f, 
    -0.01065920f, 0.08058435f, 0.08764638f, 0.01826979f, 0.07423028f, 0.07043725f, 0.43544373f, -0.25407141f, 
    0.08343829f, -0.25855172f, -0.00292306f, -0.05688849f, -0.00049257f, 0.05666429f, 0.05053006f, 0.02925442f, 
    0.23063150f, -0.34627941f, 0.03984749f, -0.07337051f, 0.04540956f, 0.15085988f, -0.05348281f, 0.04537255f, 
    -0.13468513f, -0.02903329f, -0.02517124f, -0.08217167f, 0.06224978f, -0.28653517f, -0.06886304f, -0.21641363f, 
    0.09862934f, 0.03565495f, 0.01499725f, 0.04729875f, -0.04534480f, -0.03300651f, -0.02275213f, -0.13528998f, 
    -0.17763111f, 0.02763941f, -0.06993783f, -0.01321183f, 0.10993537f, 0.01789094f, 0.03229013f, 0.11161558f, 
    0.05354523f, -0.05469592f, -0.18015450f, -0.13045286f, -0.00966882f, 0.17597091f, 0.22926979f, -0.43660104f, 
    0.10243962f, -0.22004491f, 0.07343768f, -0.21090274f, -0.04310788f, 0.07381277f, 0.02006109f, -0.00304454f, 
    -0.07967981f, 0.07636181f, -0.24247180f, -0.13158524f, -0.03819617f, 0.07100492f, 0.20267411f, 0.02524093f, 
    0.05765369f, 0.00656365f, -0.03757639f, 0.11347161f, -0.11840817f, -0.17461471f, 0.01779197f, 0.11116987f, 
    -0.00244724f, 0.10598066f, 0.01148295f, -0.03487851f, -0.10373893f, 0.04079405f, 0.09011516f, 0.00279846f, 
    -0.18812792f, -0.41637471f, -0.11810775f, -0.17979178f, 0.15617633f, -0.02588435f, 0.03956345f, 0.08013318f, 
    -0.03319241f, -0.00746065f, -0.01845255f, -0.15365858f, -0.70322955f, -0.14813437f, 0.02494339f, 0.00863058f, 
    0.02300772f, 0.12212348f, 0.03783462f, -0.00818713f, 0.08205302f, 0.00726092f, 0.05443583f, -0.09474239f, 
    0.27005899f, -0.22069322f, 0.07428256f, -0.51057702f, -0.14621407f, -0.13384205f, -0.03417074f, 0.08615135f, 
    -0.14287642f, -0.02663681f, 0.03578665f, -0.02178953f, -0.14414816f, 0.10733131f, 0.10852338f, 0.05491550f, 
    0.03266612f, 0.11871945f, -0.04643329f, 0.10893258f, 0.14374790f, -0.02013115f, -0.11546127f, 0.01103281f, 
    -0.16940431f, 0.18099269f, -0.09316280f, -0.04608328f, 0.01265017f, -0.08683699f, -0.01757534f, 0.01934147f, 
    0.07590072f, 0.10388327f, -0.00672007f, 0.11913575f, 0.00486905f, -0.08580162f, 0.05437170f, 0.12919930f, 
    0.02957391f, 0.15685813f, -0.03417291f, -0.02096058f, -0.04960775f, -0.19316697f, 0.01078772f, -0.09149587f, 
    -0.16920669f, 0.02943466f, -0.18067306f, 0.14729366f, 0.03806797f, 0.00286688f, -0.00390770f, 0.05340681f, 
    0.05646095f, -0.00131394f, -0.22852460f, -0.11506496f, -0.04860628f, -0.05886659f, 0.00158105f, -0.20029044f, 
    0.02630642f, 0.06301348f, -0.14122398f, 0.06532513f, 0.12223541f, 0.03553908f, -0.11929800f, 0.06868651f, 
    -0.33553919f, 0.16470265f, -0.16962956f, 0.08613641f, -0.08340922f, -0.20362556f, -0.09652179f, 0.01847169f, 
    -0.01113452f, -0.04306401f, 0.01753410f, 0.04769219f, -0.09485076f, -0.20878567f, 0.07209948f, 0.04793146f, 
    0.11728300f, -0.10635456f, -0.17638923f, -0.09370033f, -0.10371676f, -0.14476721f, -0.03160931f, 0.00700649f, 
    -0.01082193f, 0.01327606f, -0.30901915f, 0.32319921f, -0.09011997f, 0.05881935f, 0.10539693f, -0.01822642f, 
    0.09656489f, 0.04102625f, 0.07330191f, 0.12706566f, 0.00065918f, -0.24074820f, -0.03808044f, 0.12933891f, 
    -0.18869650f, 0.12442807f, -0.13332886f, -0.05293298f, -0.03597020f, 0.01357645f, 0.03478851f, 0.14064011f, 
    -0.23158108f, -0.09178738f, -0.28720725f, 0.10687767f, 0.05852004f, -0.18337721f, -0.07710478f, 0.05567611f, 
    -0.08737381f, 0.06997462f, -0.01156730f, 0.03128090f, 0.20357704f, -0.12553038f, 0.12217478f, -0.04668554f, 
    -0.05757995f, -0.01359430f, -0.07800862f, -0.04108874f, -0.04274694f, 0.00757270f, 0.12906745f, -0.02475047f, 
    -0.17871957f, -0.18804345f, 0.19640993f, 0.01477915f, -0.15164009f, 0.06579694f, 0.07409999f, 0.07701009f, 
    0.03455164f, 0.04722114f, 0.15747225f, 0.06517585f, -0.17141674f, 0.22336023f, -0.18717849f, 0.01492471f, 
    -0.05275585f, 0.12757167f, 0.13927102f, 0.01514287f, 0.11989867f, 0.03060652f, -0.14306815f, -0.26945460f, 
    -0.30953792f, -0.06316130f, -0.12522681f, -0.13466837f, -0.10623533f, -0.00764649f, -0.01899149f, -0.14612506f, 
    -0.17446867f, 0.05438315f, -0.03496695f, -0.04969195f, 0.28488010f, -0.06369670f, 0.19495992f, -0.09343436f, 
    0.01506871f, -0.05625406f, 0.19551739f, 0.10126017f, -0.00397047f, -0.04495496f, 0.09299240f, 0.12513162f, 
    0.05217234f, 0.10435465f, 0.15669784f, 0.17406213f, -0.11276731f, 0.14009421f, -0.03351789f, 0.01511524f, 
    0.10095317f, -0.02237585f, 0.06286278f, 0.13013160f, 0.19193362f, -0.29419285f, 0.12853044f, 0.37185919f, 
    0.01881421f, -0.02212047f, -0.02875755f, 0.04012208f, -0.05842690f, 0.05453270f, 0.03966245f, -0.15527114f, 
    -0.00761650f, -0.13681392f, -0.10455379f, 0.26675200f, -0.15370551f, 0.09852969f, 0.10882891f, -0.24423802f, 
    0.06219537f, -0.08135264f, -0.06562489f, -0.01513778f, -0.24044612f, -0.23740563f, -0.10362022f, -0.28313002f, 
    -0.03281146f, -0.03403225f, -0.00707015f, -0.09750060f, 0.05442704f, -0.04371181f, -0.12328473f, -0.11605737f, 
    -0.73144585f, 0.28187066f, 0.05729477f, 0.13032909f, 0.00015933f, 0.06583338f, -0.05407120f, 0.18081191f, 
    -0.14320074f, -0.01707669f, 0.15247451f, -0.09823588f, -0.25380671f, -0.00146422f, -0.16169691f, -0.12297317f, 
    0.14966817f, 0.09043790f, -0.02685057f, -0.04516330f, -0.11065099f, -0.02838627f, -0.22979443f, -0.34608984f, 
    -0.12867053f, 0.07792640f, 0.11437742f, 0.07283470f, 0.14055124f, 0.05986044f, -0.05337824f, -0.11516505f, 
    0.00241476f, -0.09060608f, 0.06758976f, -0.19055931f, -0.10395441f, -0.40376472f, 0.06937120f, -0.03689839f, 
    -0.10092220f, 0.06481158f, 0.01249827f, -0.08835138f, 0.09990738f, 0.05953269f, 0.06910293f, 0.05825694f, 
    -0.14699467f, 0.10381892f, 0.18954225f, 0.09539192f, -0.10949437f, 0.17971727f, -0.03629930f, 0.07556786f, 
    0.04686579f, -0.13125443f, 0.08573085f, 0.11789619f, -0.04533041f, 0.20820737f, 0.11172143f, -0.00087215f, 
    -0.05790959f, 0.16126201f, 0.15274048f, 0.15252359f, -0.08555173f, 0.04023738f, 0.06605126f, 0.20612583f, 
    0.00139177f, -0.03429504f, -0.10414153f, 0.04957230f, -0.07630000f, -0.08631521f, 0.03771675f, -0.28986511f, 
    0.01959000f, 0.02887647f, -0.09167985f, -0.06619899f, -0.22245851f, -0.29373857f, -0.30585089f, 0.07452540f, 
    -0.00291234f, -0.27906784f, -0.08825692f, 0.14778477f, 0.10423136f, 0.01549995f, -0.03415001f, 0.04427056f, 
    -0.27652776f, 0.23843434f, 0.10401283f, 0.06410490f, -0.01597144f, 0.05795329f, -0.04531142f, 0.13119780f, 
    0.03373910f, 0.02359203f, -0.04019202f, 0.17244686f, -0.07377402f, 0.04561471f, 0.11191320f, -0.02672987f, 
    0.04841867f, 0.01413822f, -0.04234968f, -0.14911090f, -0.02609235f, -0.10024770f, 0.02903154f, -0.15057746f, 
    -0.10603510f, -0.14531194f, 0.04774043f, -0.00811463f, -0.07073942f, 0.04053656f, -0.05414113f, 0.03002200f, 
    -0.03421128f, -0.03505737f, 0.09051536f, -0.05539927f, -0.23847248f, -0.14295779f, -0.21963945f, 0.16601616f, 
    -0.01530985f, 0.12616314f, 0.04801631f, -0.00607671f, -0.01509295f, 0.12230065f, 0.07367080f, 0.14999139f, 
    -0.07130767f, 0.10668959f, 0.13802333f, 0.08272869f, -0.00399066f, 0.00424623f, -0.08679830f, -0.03131800f, 
    0.05589424f, -0.15025836f, -0.30205503f, -0.14137307f, -0.36960787f, 0.17315328f, 0.09208301f, 0.02033090f, 
    -0.01667782f, 0.18596901f, -0.12492855f, 0.08083475f, -0.13306038f, 0.02707920f, -0.04753767f, -0.32188454f, 
    -0.10380380f, 0.09839214f, -0.15589112f, 0.02324733f, -0.21258475f, -0.06128486f, -0.00153256f, -0.05041515f, 
    -0.18594982f, 0.01309298f, 0.04302717f, 0.02644627f, 0.20088038f, -0.35804379f, 0.10694289f, -0.04816787f, 
    -0.05667303f, -0.04362602f, -0.07602335f, 0.06730060f, -0.03247189f, 0.04265941f, -0.08620056f, -0.23128092f, 
    -0.09931424f, 0.01337003f, 0.19171309f, 0.19668360f, -0.18389660f, 0.00074905f, -0.14672175f, 0.02098142f, 
    0.10092296f, 0.01353693f, -0.00672554f, -0.06123261f, -0.09177870f, 0.46752256f, -0.13408241f, -0.03501582f, 
    0.19931352f, 0.01200229f, -0.10157925f, 0.08515967f, -0.18037222f, 0.03330250f, -0.07843626f, -0.02964175f, 
    -0.33846623f, 0.27326483f, 0.07774902f, 0.05790020f, -0.01191469f, 0.09477361f, 0.01437467f, -0.09771743f, 
    0.07752565f, 0.21131088f, 0.04148252f, -0.01339682f, -0.04725451f, 0.16808514f, 0.04990057f, -0.17912367f, 
    -0.01418794f, 0.00369462f, -0.04618441f, -0.08775114f, -0.00004021f, 0.00448649f, 0.19419053f, -0.03134100f, 
    0.38694915f, -0.33783957f, 0.41761100f, -0.13864781f, -0.10358051f, 0.08581373f, 0.12040519f, 0.08441398f, 
    0.05419935f, -0.02815636f, -0.11363138f, 0.17367995f, -0.16581535f, -0.02095867f, 0.02285276f, 0.32166207f, 
    0.08567370f, -0.03414013f, 0.00301896f, 0.09766322f, -0.11233308f, -0.14808734f, -0.01972576f, 0.05914874f, 
    -0.08306519f, -0.04653967f, 0.10330786f, 0.10671372f, -0.06736755f, 0.01290961f, -0.09087227f, 0.01227885f, 
    -0.13984017f, -0.11222178f, 0.00860395f, 0.00229570f, -0.13823603f, 0.25736400f, -0.13535990f, 0.00442212f, 
    -0.00543006f, 0.09066310f, -0.05497077f, -0.06642775f, 0.04999704f, 0.06179811f, 0.07934081f, 0.11415480f, 
    -0.08508151f, 0.01382935f, -0.14511551f, -0.20170365f, -0.19387807f, -0.18629558f, -0.11894780f, -0.03741367f, 
    -0.06656677f, -0.02304782f, 0.14801626f, 0.08711237f, -0.07939166f, 0.14615540f, -0.34900293f, 0.24574463f, 
    -0.02622315f, -0.04802724f, 0.04562626f, -0.04060256f, 0.03679561f, 0.02277200f, -0.20409144f, -0.03834778f, 
    -0.34935185f, 0.08145805f, -0.00214589f, 0.25311384f, -0.12626126f, 0.01027121f, -0.04028149f, -0.08670661f, 
    -0.07407683f, 0.01675259f, 0.08473571f, 0.05634686f, -0.25362146f, 0.21689355f, -0.07719773f, -0.07513179f, 
    -0.00647768f, -0.06466075f, -0.02194876f, 0.03981221f, -0.14764678f, -0.24660036f, -0.08615410f, -0.10741270f, 
    -0.35664991f, 0.16290078f, 0.36926445f, 0.02886396f, 0.08910805f, -0.18688059f, -0.25605431f, 0.01143744f, 
    -0.12230463f, 0.02792208f, 0.13914835f, -0.19023734f, -0.18901156f, 0.11304662f, -0.04064442f, -0.02127439f, 
    0.00563664f, 0.15906805f, -0.04517431f, 0.09178820f, -0.04429403f, -0.03294749f, -0.05333056f, -0.20939298f, 
    -0.08701302f, 0.13677424f, -0.18966311f, 0.12115539f, -0.09489878f, 0.01033361f, 0.01634332f, -0.04231725f, 
    -0.02173512f, 0.05815798f, -0.11894234f, -0.05423629f, 0.03448304f, 0.27846837f, 0.03472547f, 0.07639254f, 
    0.06955696f, 0.04236063f, 0.00803074f, 0.00108086f, -0.10366394f, 0.03798738f, 0.04190111f, 0.20746936f, 
    -0.10293825f, 0.09913838f, 0.09447689f, -0.14090580f, -0.04629498f, 0.03366050f, -0.00311441f, 0.05794462f, 
    0.07936486f, -0.11169874f, -0.12519224f, -0.45895347f, 0.08815277f, 0.13917345f, 0.16130890f, -0.20182155f, 
    -0.09561592f, -0.10048376f, 0.06233067f, -0.07184836f, -0.08502365f, -0.05503567f, -0.00618161f, 0.05218993f, 
    0.14065039f, 0.02910648f, -0.23546340f, -0.19115892f, 0.07129138f, -0.06931613f, -0.06647868f, -0.00118059f, 
    -0.22817813f, 0.00920505f, -0.16603446f, -0.29695877f, -0.23223241f, -0.03971684f, -0.07197835f, 0.04057439f, 
    -0.08537694f, -0.02400205f, 0.06836636f, 0.11728087f, 0.00685117f, -0.02214465f, 0.03554690f, -0.06443578f, 
    -0.24801676f, 0.08854888f, -0.13985907f, -0.02760194f, 0.04576236f, 0.12545037f, -0.02411446f, -0.02421201f, 
    0.02185233f, 0.04410333f, 0.04977522f, 0.05678173f, -0.00571969f, -0.17705631f, 0.03811365f, 0.20782731f, 
    -0.10806360f, 0.01938248f, -0.08206236f, -0.09268188f, 0.03782054f, 0.02711905f, -0.12971200f, 0.12225427f, 
    -0.01591937f, -0.10242655f, 0.27007312f, 0.00437539f, -0.05180953f, 0.00958147f, 0.05351132f, 0.08772543f, 
    -0.06362059f, 0.13075821f, 0.17326219f, 0.01807037f, -0.00301166f, 0.10136127f, 0.06105133f, -0.00689865f, 
    -0.18676323f, -0.02990845f, 0.16767420f, -0.06198858f, -0.04119495f, -0.05310860f, 0.07294448f, 0.04756915f, 
    0.15577847f, -0.10379734f, 0.03582704f, 0.11066180f, -0.11897054f, -0.12758687f, 0.10330819f, 0.06094343f, 
    -0.22262752f, -0.02996786f, -0.16418083f, -0.13905858f, -0.21899909f, -0.02235456f, 0.15841614f, -0.10223530f, 
    -0.08112302f, -0.02474419f, -0.11604155f, -0.08839215f, 0.20633912f, -0.12559927f, -0.00223631f, 0.08997607f, 
    -0.27941066f, -0.09760189f, -0.11297967f, 0.20158836f, -0.14524420f, 0.23941080f, 0.00167647f, 0.14585891f, 
    0.01041588f, 0.08833291f, 0.05255436f, 0.06933010f, -0.09310183f, -0.13978542f, 0.04020685f, 0.04674023f, 
    -0.00633359f, 0.02051071f, 0.12649025f, 0.04390390f, -0.06493916f, 0.04677069f, 0.03585543f, -0.00791348f, 
    0.00236326f, -0.05601640f, -0.42629638f, 0.29356420f, -0.05871472f, 0.00091198f, -0.00690446f, 0.16186774f, 
    0.04254895f, 0.06416965f, -0.13698494f, 0.13626301f, -0.18777087f, -0.04619727f, 0.25909671f, -0.30805486f, 
    -0.17589048f, 0.00880669f, 0.04158071f, 0.02115213f, 0.06479436f, -0.04419355f, 0.11262137f, -0.02258747f, 
    0.00537803f, 0.10678315f, 0.06920787f, 0.08074502f, -0.05528712f, -0.13732748f, 0.02218488f, 0.08660945f, 
    -0.16923364f, -0.11969578f, -0.32627380f, -0.29263252f, 0.12347157f, 0.17737141f, 0.00244087f, -0.11531124f, 
    -0.04665913f, 0.07190563f, 0.01252607f, 0.07199025f, 0.11347967f, 0.10948095f, 0.06877170f, 0.19558223f, 
    -0.01720040f, -0.06636930f, -0.05052701f, 0.11148117f, -0.18326557f, 0.01979789f, 0.04569264f, -0.10937359f, 
    0.00261317f, 0.12033667f, 0.05231797f, 0.07907942f, -0.18976267f, -0.02421149f, -0.01776022f, 0.15506752f, 
    -0.02980625f, 0.23756446f, -0.20224264f, 0.22978607f, -0.15535530f, -0.17482655f, 0.07784089f, -0.05502248f, 
    0.21585695f, 0.15316951f, 0.24291766f, 0.01231414f, -0.09960453f, 0.02900040f, -0.04872244f, 0.06786133f, 
    0.04559159f, -0.04952765f, 0.05751271f, 0.04734230f, -0.18883513f, 0.12748644f, 0.09083959f, 0.23930708f, 
    -0.15471652f, 0.12578444f, -0.17189951f, 0.04855878f, -0.02832729f, 0.02427628f, 0.17124289f, -0.01701363f, 
    0.12201881f, 0.15304522f, -0.10316700f, -0.04496531f, 0.05157904f, 0.04071932f, 0.02516548f, 0.04930763f, 
    0.06110519f, 0.02141868f, 0.08822618f, -0.07166158f, 0.30906323f, 0.08121253f, 0.21277297f, -0.18735926f, 
    -0.05238898f, 0.18550704f, -0.19148089f, 0.25733647f, -0.18914430f, 0.09118300f, -0.09895480f, -0.05175357f, 
    0.03607607f, -0.07518919f, 0.06559856f, 0.06476002f, -0.14821096f, -0.02521494f, -0.16850109f, -0.23270862f, 
    -0.00901676f, -0.03760788f, -0.03726724f, -0.08918298f, -0.14718832f, -0.06471094f, -0.06922064f, 0.06289742f, 
    0.00018490f, -0.01337573f, 0.04298809f, 0.07888667f, -0.08294756f, 0.09577206f, -0.07285675f, -0.10062372f, 
    -0.04928309f, -0.18108436f, -0.26197428f, -0.15420705f, -0.05290719f, -0.26629794f, -0.17099823f, -0.07980834f, 
    0.03244377f, 0.04501719f, 0.02571536f, -0.07170126f, -0.24641125f, -0.21761221f, 0.04968133f, -0.23299642f, 
    -0.03851737f, -0.10634996f, -0.06163733f, -0.03156387f, -0.06872826f, 0.10726697f, 0.09782944f, 0.08898669f, 
    0.50064510f, 0.06746364f, 0.23554096f, -0.18437687f, 0.10977358f, 0.02098715f, -0.08981427f, 0.07202167f, 
    -0.01349105f, 0.02229727f, 0.03636995f, -0.04531691f, -0.01555391f, 0.19133091f, -0.07062280f, -0.04585628f, 
    -0.13214213f, 0.13281131f, -0.01831070f, -0.11168709f, -0.04001855f, 0.14884667f, 0.01836013f, 0.07892191f, 
    0.18342711f, -0.10726037f, 0.30271935f, -0.38174757f, 0.07223038f, 0.16334768f, -0.35932600f, 0.15626842f, 
    0.05742104f, 0.08288687f, -0.03245889f, -0.13933653f, -0.19917536f, 0.03364009f, 0.24934450f, -0.08574995f, 
    -0.12570980f, -0.07130106f, 0.10098053f, 0.07517423f, -0.14397036f, 0.01767632f, -0.11092191f, -0.14212590f, 
    0.15942974f, 0.27746189f, 0.15163663f, -0.14957552f, -0.06619558f, -0.05903267f, 0.04448758f, -0.05090264f, 
    -0.00573440f, 0.04562126f, 0.02415022f, -0.10777006f, -0.18605834f, -0.08611386f, -0.12007225f, -0.08955438f, 
    0.01350869f, -0.01828866f, -0.03604392f, -0.08885776f, 0.12300029f, 0.10607947f, 0.06687430f, 0.01105425f, 
    -0.02090595f, 0.21298952f, -0.39196792f, 0.06607940f, 0.12217150f, -0.06384961f, 0.05146938f, 0.26108238f, 
    -0.00720531f, 0.11893437f, 0.04822763f, 0.02504250f, 0.08683757f, 0.15674147f, -0.27311823f, -0.05707255f, 
    0.11841539f, 0.05382557f, 0.06829926f, -0.12284894f, 0.00024387f, 0.14765453f, 0.25826678f, 0.17386228f, 
    -0.38557684f, 0.35968333f, -0.20877643f, 0.15180770f, 0.01970790f, -0.14102258f, 0.22681117f, 0.05301971f, 
    -0.05208769f, -0.05705248f, 0.06735531f, 0.16899128f, -0.13470714f, -0.32838044f, -0.05623915f, 0.05692646f, 
    -0.21556176f, -0.31242985f, -0.02496909f, -0.23754805f, -0.03715659f, 0.07161362f, 0.01066906f, -0.06756578f, 
    -0.04536997f, 0.21626057f, 0.31908059f, -0.08133825f, -0.04727551f, -0.11485041f, -0.01024874f, 0.05998003f, 
    -0.15259066f, 0.05210947f, 0.11112530f, -0.16161135f, 0.12215826f, -0.23109542f, 0.13300134f, -0.08038694f, 
    0.07326147f, 0.08829214f, -0.08787646f, 0.07930718f, -0.03519253f, -0.14818966f, 0.05538522f, -0.22157328f, 
    0.21600907f, -0.19446354f, 0.63992935f, 0.04572169f, -0.06337422f, -0.04239924f, -0.12917320f, -0.02488836f, 
    0.07763652f, -0.03591375f, 0.12532935f, 0.04568640f, -0.13819019f, -0.10760564f, -0.16465130f, -0.10535692f, 
    -0.13011932f, -0.20026076f, -0.08492274f, 0.00083863f, 0.02985535f, 0.06749132f, -0.07998592f, -0.12303254f, 
    -0.56371176f, -0.04080268f, -0.23219058f, 0.40090746f, 0.06265300f, -0.03348576f, -0.09671688f, 0.28536513f, 
    -0.27118552f, 0.01470972f, -0.01642461f, -0.02755414f, -0.20821638f, -0.13962814f, -0.17817222f, -0.06606174f, 
    0.16510187f, 0.04473617f, -0.05617109f, 0.12188694f, -0.06338876f, 0.12509342f, 0.13656266f, -0.02665068f, 
    0.24270713f, -0.01809018f, 0.17675537f, 0.07816377f, -0.07486764f, 0.12676565f, -0.05528866f, 0.08283982f, 
    -0.07852277f, 0.14694813f, -0.05920144f, 0.00803543f, -0.09723348f, -0.33341247f, -0.12940544f, 0.02499000f, 
    -0.15743189f, -0.21633020f, -0.03095680f, -0.11021701f, 0.02292318f, -0.06920108f, 0.01972468f, -0.03550115f, 
    -0.25540128f, 0.32750225f, 0.05905278f, 0.03104518f, 0.04293879f, 0.08005250f, 0.05366057f, -0.01960313f, 
    0.03881662f, 0.11161462f, 0.23094878f, 0.03188275f, 0.04019400f, -0.21331887f, -0.15596932f, 0.07452982f, 
    -0.10102089f, 0.07210493f, -0.01595408f, 0.01487592f, 0.05992886f, 0.11307408f, -0.04554302f, 0.09830971f, 
    0.46008441f, 0.10439537f, 0.25307211f, 0.07050196f, 0.01723818f, 0.03337349f, -0.08799654f, 0.12817146f, 
    -0.17047082f, 0.01086647f, 0.12685969f, -0.13053946f, -0.02001700f, 0.06450625f, 0.07854663f, -0.47471410f, 
    -0.04976270f, 0.12948740f, 0.19031464f, -0.07676528f, 0.07887918f, 0.05570713f, 0.04536534f, -0.06367090f, 
    0.33810979f, -0.41249642f, 0.39224604f, 0.18829115f, 0.15025063f, 0.02626294f, 0.07437822f, -0.06088921f, 
    -0.02656481f, -0.03393586f, 0.07853169f, 0.14610367f, -0.63713050f, -0.24556327f, -0.24165790f, 0.32826981f, 
    0.26847574f, -0.03541183f, 0.13071758f, -0.15584935f, -0.03945810f, -0.14459622f, -0.03161594f, 0.17099707f, 
    0.34667233f, -0.10469701f, 0.31682709f, 0.14789295f, 0.07385493f, -0.04832756f, -0.02894722f, 0.10426487f, 
    -0.06232231f, 0.00946060f, -0.04705381f, 0.00745906f, -0.33775684f, -0.05149198f, -0.22035894f, 0.03533196f, 
    0.10196317f, -0.04808043f, -0.04481566f, 0.08385400f, -0.06732586f, -0.00775866f, -0.15588063f, -0.07158943f, 
    0.33774912f, -0.13863456f, -0.08778228f, -0.27462417f, -0.01627352f, 0.13363943f, -0.22365364f, 0.13167262f, 
    -0.06573419f, 0.04802986f, -0.01305547f, -0.01288033f, -0.39684758f, -0.29023105f, 0.15184592f, 0.00741748f, 
    -0.16553304f, 0.04724284f, -0.02420624f, -0.02912383f, -0.01915122f, 0.07626416f, -0.05686907f, -0.04348744f, 
    -0.01463447f, 0.15030600f, -0.04615201f, -0.00238196f, 0.03214058f, 0.03809451f, 0.02314735f, 0.09367230f, 
    -0.05074667f, -0.01776247f, 0.06052845f, -0.05959415f, -0.24426225f, 0.01334807f, -0.27960560f, -0.01708060f, 
    0.05115631f, -0.10269310f, 0.07211351f, 0.03483676f, -0.09825908f, -0.04891047f, -0.10825455f, -0.02790128f, 
    0.20957765f, 0.06980831f, 0.10821585f, 0.22878481f, -0.09589053f, 0.00569213f, -0.05354146f, 0.03049060f, 
    -0.15062673f, 0.08296018f, 0.01631126f, -0.10085142f, -0.07458632f, 0.50821143f, -0.20803842f, -0.21600606f, 
    -0.10945501f, -0.00222678f, -0.10258938f, -0.07836284f, -0.08116618f, -0.05527344f, 0.01967186f, -0.02481477f, 
    -0.19409710f, 0.02945920f, -0.46802008f, 0.20729116f, 0.00407764f, -0.27225369f, 0.14862272f, 0.00318366f, 
    0.02994301f, 0.03363647f, -0.01854450f, -0.03225664f, 0.17428313f, -0.03553827f, -0.00048012f, 0.02131486f, 
    0.06936921f, 0.00574910f, 0.01757588f, 0.10233665f, 0.00694893f, 0.14832239f, 0.00828921f, 0.00967906f, 
    -0.13881716f, -0.34581226f, -0.18835562f, 0.58102673f, -0.08842187f, -0.02780271f, 0.01473504f, 0.11615279f, 
    0.06125034f, 0.02529801f, -0.01886290f, 0.09611305f, 0.05787694f, 0.04844195f, 0.08737140f, -0.04888368f, 
    -0.23091353f, 0.19952892f, -0.12017406f, -0.15115251f, -0.03378838f, 0.02969859f, -0.10189211f, 0.04675609f, 
    -0.45262694f, 0.10310148f, 0.03397854f, 0.14111315f, -0.06064627f, 0.01511416f, 0.04670944f, -0.09832911f, 
    0.01692572f, -0.07010438f, 0.18346943f, 0.09895903f, -0.00028791f, 0.16521868f, -0.33229652f, 0.10752258f, 
    -0.03372963f, 0.04443309f, 0.05370001f, -0.13643172f, -0.03147070f, 0.02548507f, 0.00092785f, -0.03861044f, 
    0.07259545f, 0.05396496f, -0.03682163f, -0.15136641f, 0.02941923f, -0.03156267f, -0.00642223f, 0.01191447f, 
    0.11532924f, 0.21006769f, 0.00455196f, 0.04076471f, -0.18295026f, -0.03289771f, -0.19159380f, -0.11615488f, 
    0.05701132f, 0.05868913f, 0.01868039f, -0.07405937f, 0.03306162f, 0.09837669f, 0.21364410f, -0.06178291f, 
    -0.49439681f, 0.03045596f, -0.47033009f, -0.17230295f, 0.04474625f, -0.09052751f, 0.03744169f, -0.08730366f, 
    -0.00010694f, 0.03932145f, -0.05282906f, 0.02557240f, 0.13054012f, -0.09912734f, 0.06200205f, -0.06012741f, 
    0.02428360f, -0.00177940f, -0.02781215f, -0.03714811f, -0.00284708f, 0.00801510f, -0.17164910f, -0.10638297f, 
    -0.11930525f, 0.08774083f, 0.11712934f, 0.00221517f, 0.14471865f, -0.00256867f, 0.09990954f, -0.16207899f, 
    -0.06528605f, 0.10209906f, 0.08918443f, 0.02612820f, 0.22749874f, 0.14956765f, -0.13464236f, 0.00680491f, 
    -0.02453757f, 0.08758334f, -0.04018556f, 0.03477482f, -0.01462001f, 0.00220379f, -0.07454307f, -0.08022574f, 
    0.12504999f, 0.01227299f, 0.04986288f, -0.03809109f, 0.02920556f, 0.06870908f, 0.04897536f, 0.05102864f, 
    0.05363848f, 0.01062492f, 0.05446528f, -0.04845687f, 0.07343662f, -0.30283308f, 0.16221264f, 0.10604595f, 
    0.08993310f, 0.05863751f, 0.17549896f, 0.06551505f, -0.09933507f, -0.13346620f, 0.01429756f, -0.04730510f, 
    -0.02723544f, 0.02836774f, 0.18351947f, 0.18938021f, -0.07077263f, 0.01497372f, -0.03319801f, 0.07068311f, 
    -0.09594682f, -0.00558435f, 0.21240519f, 0.09270966f, -0.20530500f, 0.02893432f, -0.07185419f, -0.29799518f, 
    0.06658621f, -0.01911108f, 0.03432695f, -0.01004461f, 0.06818818f, 0.15445185f, -0.11210612f, 0.00517196f, 
    0.13409892f, 0.20366983f, 0.18325262f, 0.07778066f, -0.20893322f, 0.00452420f, -0.15659729f, 0.08321796f, 
    0.01062252f, -0.10034946f, -0.03216188f, -0.10897034f, 0.05677011f, -0.38920644f, 0.01247779f, 0.10570218f, 
    0.02846592f, -0.02112263f, -0.00507696f, -0.16101328f, -0.01023444f, 0.04656225f, 0.00528093f, -0.00769491f, 
    -0.32456031f, -0.35447562f, -0.05512616f, 0.06438565f, -0.12588990f, -0.05644789f, -0.13045642f, 0.14359929f, 
    -0.09086388f, -0.03273363f, 0.00805532f, 0.16040732f, 0.02920859f, 0.07345914f, 0.04140508f, -0.12116641f, 
    0.03695359f, 0.04347662f, -0.03330729f, 0.00903692f, 0.09312910f, 0.01681258f, -0.01962540f, -0.04722124f, 
    -0.09122854f, -0.24708460f, 0.04556616f, -0.26829803f, 0.11399098f, -0.01514496f, 0.11428466f, -0.07266424f, 
    0.02699308f, 0.07554241f, 0.08675037f, 0.11305240f, -0.24251886f, 0.04021588f, -0.34440264f, -0.15132380f, 
    0.11371346f, -0.07240434f, -0.03588057f, -0.04853358f, -0.04699450f, -0.03807641f, -0.17113161f, -0.07330929f, 
    0.19883001f, -0.07984542f, 0.22465676f, 0.22318809f, 0.04796604f, -0.16554500f, 0.05277615f, 0.06107154f, 
    0.03903544f, -0.10671826f, 0.13346627f, 0.00080287f, -0.24677485f, 0.19661778f, -0.01338375f, 0.16842635f, 
    -0.09068906f, -0.10288566f, 0.19980496f, 0.16280428f, -0.07642464f, -0.00083240f, 0.05726051f, 0.05113359f, 
    0.01823287f, -0.47192919f, 0.34022206f, -0.10016685f, 0.30142257f, -0.00904245f, 0.15653002f, -0.05408018f, 
    0.02035079f, -0.03830190f, 0.14424020f, -0.02429798f, -0.35993752f, -0.03459640f, -0.23507567f, 0.14656676f, 
    0.10400828f, -0.02187433f, -0.02457110f, -0.02744133f, 0.17189650f, -0.01638227f, -0.05355457f, -0.15153563f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18820007f, 0.08190892f, 0.09318021f, -0.06378373f, -0.04107968f, 0.05692638f, 0.03870942f, -0.11769248f, 
    0.01980530f, 0.05686178f, 0.03161226f, -0.03928258f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
