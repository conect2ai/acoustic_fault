#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.38854790f, -0.47057524f, 0.50045103f, 0.53619891f, 0.43222216f, 0.14992212f, 0.03113881f, 0.93145216f, 
    0.36636338f, 0.42179164f, -0.12709856f, -0.36917984f, -0.43740138f, -0.11253360f, -0.27891827f, 0.42390090f, 
    0.14028393f, -0.08835733f, 0.25957993f, -0.48892722f, -0.07891057f, -0.26820531f, 0.19837803f, 0.24236889f, 
    -0.19862430f, 1.08235228f, 0.51522213f, 0.12289052f, 0.69920450f, 0.49320939f, 0.06559717f, 0.28003305f, 
    0.07610913f, -0.14270283f, -0.44223660f, 0.16769588f, 0.05871380f, -0.27017081f, -0.11112221f, -0.01834289f, 
    0.31105411f, 0.09706530f, -0.04884855f, -0.20372528f, -0.03602249f, -0.28041628f, -0.03325083f, -0.11497980f, 
    0.29519415f, 0.19947053f, 0.70595300f, 0.14843717f, 0.11707155f, 0.86188322f, 1.09731650f, 0.08852683f, 
    -0.47625840f, -0.09582207f, 0.02765116f, 0.43008739f, -0.31942537f, -0.08678138f, 0.05502063f, 0.10291427f, 
    0.23831442f, 0.05597338f, -0.06038277f, 0.20373906f, 0.10660994f, 0.14359920f, 0.47540408f, 0.14978704f, 
    0.10366728f, -0.17594026f, -0.07159424f, 0.97926033f, 0.61266804f, -0.29233372f, 0.19186819f, -0.68393153f, 
    -0.12228959f, 0.49096131f, 0.09889508f, 0.19390818f, 0.40843013f, 0.42352763f, 0.31250826f, 0.34881443f, 
    0.19124511f, 0.20147593f, 0.11376017f, -0.26641944f, 0.15978685f, -0.33458447f, 0.06946105f, -0.32421401f, 
    0.12897244f, -0.08118305f, 0.21039781f, -0.37462464f, 0.97908306f, -0.67774945f, -1.01892638f, -0.83709025f, 
    0.77887112f, 0.04234235f, -0.81105435f, 0.72059393f, -0.06664368f, 0.04969092f, -0.48667124f, -0.12875992f, 
    -0.09255525f, -0.16214406f, -0.08153686f, 0.06537754f, -0.12775226f, 0.01843254f, 0.02326627f, -0.07474099f, 
    0.03516584f, -0.02767666f, 0.15423788f, 0.14396000f, -0.15262051f, -0.59884721f, -1.13231301f, -0.88268292f, 
    0.11577690f, 0.14222306f, -0.86963654f, 0.26959559f, 0.42185953f, -0.73271108f, 0.54498291f, 0.41844150f, 
    0.19958159f, 0.29473817f, 0.12302918f, 0.51427209f, 0.17023872f, 0.27155039f, 0.27948859f, 0.06566591f, 
    0.06726369f, 0.00725207f, -0.26307857f, -0.25912797f, 0.18564546f, -0.02034241f, 0.54763591f, 0.38647920f, 
    0.25037643f, 0.61390871f, 0.55549872f, 0.88450706f, 0.58994716f, 0.77454668f, 0.18607105f, -0.27702823f, 
    -0.57135308f, -0.07542117f, 0.06796245f, 0.03792838f, -0.14324039f, -0.03359995f, -0.04916124f, 0.20831798f, 
    -0.18302396f, -0.02339059f, -0.10612938f, 0.04463746f, -0.08189264f, -0.10427146f, 0.27218479f, 1.16136861f, 
    0.04222610f, -0.93001014f, 1.14206934f, 0.21578966f, -0.13648953f, 0.07855973f, -0.27894154f, 0.36472797f, 
    0.05405807f, -0.07452723f, -0.22729456f, 0.27655780f, 0.05902640f, -0.14564550f, -0.29844803f, -0.20430762f, 
    0.01947059f, -0.19014513f, -0.13820410f, 0.13918132f, 0.02834960f, 0.00900309f, 0.03360999f, 0.11151038f, 
    -0.74771065f, -1.24614859f, -0.09129925f, 0.16670845f, -0.58314127f, 0.51610571f, 1.09048676f, 0.77260911f, 
    -0.05530366f, 0.36780286f, -0.35329568f, -0.34461984f, -0.13801603f, -0.09384690f, -0.32010743f, -0.01161109f, 
    0.05488278f, 0.04069594f, -0.26619896f, -0.08131366f, -0.10748406f, -0.03563163f, 0.01130659f, -0.11915983f, 
    0.10876776f, 0.28015739f, 0.77984405f, -0.31859130f, -0.59423995f, 0.12190147f, 0.32128462f, -0.62016422f, 
    -0.62728810f, -0.62430990f, -0.56247216f, 0.16793913f, 0.77965742f, 0.60154468f, 0.32654402f, 0.01507176f, 
    0.26818904f, 0.11714487f, 0.33185723f, 0.21448477f, 0.00557986f, 0.15144286f, -0.14503689f, -0.02661897f, 
    -0.02459031f, 0.26878604f, -0.34161526f, -0.04368461f, 0.28348735f, 0.52645576f, 0.19473664f, 0.60958022f, 
    -0.43040603f, 0.10630450f, 0.00672298f, 0.24102160f, 0.28388125f, -0.42491767f, 0.15144394f, 0.13117823f, 
    -0.07603740f, 0.04184523f, 0.35250801f, 0.12392325f, 0.48409957f, 0.63760298f, 0.20871763f, 0.27299687f, 
    0.70852941f, -0.05805524f, -0.42867702f, -0.45976105f, -0.27070162f, 0.03454684f, 0.08093753f, -0.63277453f, 
    -0.66612834f, 0.46320549f, -0.37610364f, -0.12170336f, -0.52058429f, -0.30176252f, 0.16270274f, -0.41765571f, 
    -0.47474432f, -0.47471759f, -0.30531323f, 0.20840980f, -0.12484258f, 0.16769518f, -0.54581732f, 0.32907420f, 
    0.21138391f, -0.44211921f, -0.23992388f, -0.14639285f, 0.87604368f, -0.16447155f, 0.08019497f, -0.45763102f, 
    -0.19840132f, -0.46144104f, 0.58874696f, -0.12169531f, -0.20899749f, -0.75897902f, -0.56375808f, -0.41054523f, 
    -0.72801918f, 0.19516018f, -0.11454099f, 0.10383496f, -0.32408977f, -0.27054894f, 0.14364493f, 0.11335719f, 
    -0.15519699f, -0.19659667f, -0.28145185f, -0.48830709f, -0.53777945f, 0.96904194f, 0.10842899f, 1.02014446f, 
    0.37890705f, -0.45491999f, 0.58031034f, -1.10583377f, -0.42453057f, 0.10693107f, 0.09214529f, -0.10792200f, 
    -0.19638947f, -0.01032644f, -0.08879242f, -0.13557482f, -0.27908736f, 0.03998471f, -0.32863355f, -0.34233558f, 
    0.13087665f, 0.12427416f, 0.10104948f, 0.00843159f, 0.07775086f, 0.13445908f, -0.69315261f, 0.93256700f, 
    -0.39937484f, -0.67499632f, -0.69660783f, 0.93899733f, -0.31619304f, -0.06703620f, 0.12805919f, -0.00860879f, 
    0.14226143f, -0.16559176f, 0.20713395f, 0.22590889f, -0.21714821f, -0.23150574f, 0.11238325f, 0.39995578f, 
    0.14818859f, 0.15935358f, 0.18486586f, -0.09713725f, -0.09014834f, -0.15050174f, 0.04350649f, 0.86885041f, 
    0.16429964f, -0.94088686f, -0.13862062f, -0.92036963f, 0.57125497f, 0.56056905f, 0.53167421f, 0.25117996f, 
    0.19701764f, 0.16967501f, 0.25090042f, -0.34429720f, -0.19186004f, 0.05442376f, -0.14514807f, -0.35159284f, 
    0.13402830f, 0.24909529f, 0.23970221f, 0.31433114f, -0.19129120f, 0.18544653f, -0.01634490f, -0.12823011f, 
    0.22299154f, 0.32796824f, 0.90424430f, 0.92092043f, 0.14180684f, -1.23777151f, 0.11675489f, -0.53281331f, 
    -0.14081162f, -0.13293327f, 0.62778074f, -0.13821821f, -0.09509999f, 0.20068741f, -0.35472852f, 0.18163712f, 
    -0.03777877f, 0.16551135f, 0.09939387f, -0.05603420f, 0.02115154f, -0.03372211f, 0.25750011f, -0.03756046f, 
    -0.19861038f, -0.83706743f, -0.91860896f, -0.90509874f, 0.51059645f, -0.31716207f, 0.43683067f, 0.88694930f, 
    -0.32183635f, 0.73565352f, 0.53425997f, 0.10043386f, -0.07905649f, -0.08742610f, 0.10561212f, 0.28244483f, 
    -0.12732206f, 0.15867825f, 0.00309296f, -0.02522819f, 0.01290066f, 0.07313034f, 0.03945073f, 0.04307057f, 
    0.13431157f, 0.06156206f, -0.78886849f, 0.84132928f, -0.00447377f, -0.94154048f, -0.75937766f, 0.64002305f, 
    0.04224217f, -0.64404041f, 0.26055506f, -0.05601044f, 0.01113181f, -0.05837873f, -0.07301375f, 0.10809241f, 
    0.06815076f, -0.02793575f, 0.00547918f, -0.04811374f, -0.15253738f, -0.12695546f, -0.33145580f, -0.14740475f, 
    0.27066720f, 0.51085901f, 0.04624262f, -0.87801248f, 0.75932676f, 0.78280157f, -0.53478605f, 0.19270082f, 
    -1.00046873f, 0.49356413f, -0.21030247f, -0.60421121f, -0.28605109f, -0.40517449f, 0.46675065f, -0.06884252f, 
    0.06434065f, -0.02181569f, -0.06237111f, -0.21239933f, 0.11061579f, -0.21996769f, -0.52253008f, -0.12835154f, 
    -0.00561869f, -0.19112150f, 0.12714650f, 0.05069951f, -0.21283236f, 0.24903151f, -0.34147501f, -0.55462325f, 
    0.42545187f, -0.60390747f, -0.86643428f, -0.23876688f, -0.88340914f, -0.56710762f, -0.08764615f, 0.03283659f, 
    0.22590555f, 0.24015051f, 0.07554451f, 0.22814219f, 0.22119839f, -0.38674170f, 0.08665731f, 0.35593358f, 
    0.17036128f, 0.25475767f, 0.54319805f, -0.24881038f, -0.03755405f, -0.29264262f, -0.89101291f, -0.66264892f, 
    -0.70514423f, -0.47363633f, 0.17987040f, -0.30358464f, -0.53001589f, 0.51417029f, 0.08487938f, 0.21946108f, 
    -0.25462392f, 0.13737218f, -0.11350186f, -0.45135453f, 0.05269820f, 0.05693647f, 0.08099575f, 0.20462194f, 
    0.19246994f, 0.02118191f, -0.09274419f, -0.20569700f, 0.15077753f, 0.39750209f, -0.46978763f, -0.55970478f, 
    -0.53672612f, 0.04797200f, -0.18909237f, 0.51563984f, 0.41992658f, 0.20147373f, 0.00561174f, 0.07464185f, 
    0.14262886f, 0.56557530f, 0.33273903f, -0.10228442f, -0.23826751f, -0.06467252f, -0.29576442f, 0.33535627f, 
    -0.60211128f, 0.29955098f, 0.18540430f, -0.06279023f, -0.05860824f, 0.36321217f, -0.06434410f, 0.30945781f, 
    0.81195104f, -0.68268239f, 0.00896477f, -0.20386316f, -0.21628714f, -0.92728615f, -0.02827734f, -0.38433087f, 
    0.21582308f, -0.29340845f, 0.22129691f, -0.04729985f, 0.10945177f, 0.23692863f, 0.28493291f, -0.56208235f, 
    -0.03255767f, -0.05329964f, 0.29981676f, 0.08972281f, -0.21837823f, -0.31036037f, -0.59765911f, -0.48813781f, 
    1.03505254f, 0.45225525f, 0.71816856f, 0.13742821f, 0.70210969f, 0.11684868f, -0.38718805f, 0.17006548f, 
    0.01087987f, -0.24880753f, 0.10976330f, 0.47261396f, -0.13588041f, 0.23225656f, 0.18221526f, 0.29423067f, 
    -0.15146014f, -0.09333491f, 0.08371133f, -0.03716379f, 0.38028136f, 0.50366598f, -0.01211934f, -0.17101654f, 
    0.35611671f, 0.95100957f, 0.52045619f, -0.33678284f, 0.49254873f, -0.16158132f, 0.19594860f, 0.15551785f, 
    0.03257573f, 0.61882645f, 0.33993623f, 0.26553887f, -0.02242623f, -0.20643522f, -0.41468653f, -0.04366296f, 
    -0.24815558f, -0.34562710f, -0.00826478f, 0.00375833f, 0.31089374f, -0.32423484f, 0.17859302f, 0.03354554f, 
    -0.32880479f, 0.03234165f, -0.13909528f, -0.14118402f, -0.06456573f, -0.52161849f, -0.35070580f, 0.62052345f, 
    0.01271919f, -0.07590136f, 0.39914837f, 0.37357238f, 0.72360849f, 0.25458291f, -0.30794179f, -0.11787041f, 
    0.41640893f, 0.24769732f, 0.24795435f, -0.53173465f, 0.33451241f, 0.64350921f, -0.26463479f, -0.17048310f, 
    -0.20476453f, -0.01678054f, 0.38048846f, 0.38455284f, 0.74626076f, 0.10778051f, 0.42844844f, 0.98522437f, 
    -0.06861155f, -0.33972636f, -0.13288182f, -0.27476171f, -0.28348827f, -0.44529709f, -0.15539195f, 0.00314080f, 
    0.68961960f, 0.15215527f, 0.20223448f, -0.06943855f, -0.15625346f, 0.27439967f, -0.02038773f, -0.29134274f, 
    -0.33514377f, -0.37361842f, 0.07143022f, -0.07725437f, 0.84274346f, 0.33623430f, -0.80253738f, -0.41190881f, 
    -0.22843692f, -0.16674225f, 0.25891408f, -0.69209194f, 0.18230319f, 0.49019000f, 0.12512119f, -0.01685827f, 
    0.25921696f, -0.06539370f, 0.00088066f, 0.19403166f, 0.08207066f, -0.03089151f, 0.42366076f, -0.15731214f, 
    -0.23871420f, 0.27667075f, 0.36834276f, -0.27112946f, 0.32117909f, 0.40176347f, 0.85499138f, 0.79661262f, 
    0.83993840f, 0.27041361f, 0.13660105f, 0.14001690f, -0.43374297f, 0.11418246f, -0.17600456f, 0.34219080f, 
    -0.03836296f, -0.33980921f, -0.16613635f, -0.17553639f, -0.11504784f, -0.31152984f, 0.05023491f, -0.20556511f, 
    -0.05614073f, -0.07357540f, 0.39945894f, 0.18372817f, 0.15356968f, 0.28985903f, 0.68904722f, 0.99419087f, 
    0.81722981f, -0.03619727f, -0.21641910f, -0.49429974f, -0.32563576f, -0.58381945f, 0.21933456f, 0.14691997f, 
    0.32398635f, 0.00527813f, -0.10666235f, -0.11672807f, -0.11935845f, 0.08367478f, 0.33766094f, 0.16102418f, 
    0.20600742f, 0.27798778f, -0.45552453f, -0.18035693f, -0.11843317f, -0.33564955f, 0.22207220f, 0.90395594f, 
    0.75423670f, 0.45771110f, -0.09525685f, -0.27799132f, 0.47776839f, 0.47574890f, -0.36714876f, -0.49303803f, 
    0.39818650f, 0.05769378f, 0.55009210f, 0.01969305f, -0.07079947f, -0.36324561f, -0.18646696f, -0.13734384f, 
    0.25650036f, -0.00640714f, -0.58489096f, -0.12866433f, 0.07737825f, 0.01799705f, 0.03844807f, -0.08846175f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06536924f, 0.30075294f, 0.14425884f, 0.34968621f, 0.35796914f, 0.28701290f, 0.06003347f, 0.30929562f, 
    0.25121370f, 0.19980107f, 0.02522573f, 0.07968050f, -0.10201934f, 0.35362035f, -0.00278744f, 0.18939957f, 
    0.30811468f, 0.25483957f, 0.05888749f, 0.21824718f, 0.36625701f, -0.05598204f, 0.21740289f, 0.16166116f, 
    0.17622009f, 0.04161974f, 0.15352774f, 0.09072956f, 0.17013568f, 0.18890913f, -0.03511870f, 0.28894225f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01835243f, -0.03880289f, 0.00396384f, 0.02888487f, 0.01547040f, 0.04235185f, 0.04743486f, 0.00504542f, 
    0.00813014f, 0.01071238f, -0.00719189f, 0.00671707f, 0.01895132f, 0.00393784f, -0.02917954f, 0.04488406f, 
    -0.04719906f, 0.02479235f, -0.02511689f, 0.01750533f, 0.01868724f, 0.01271223f, -0.00168851f, -0.00583443f, 
    0.04114809f, -0.00192137f, 0.02989333f, 0.04298145f, -0.03787832f, 0.01575650f, 0.01401071f, -0.02811332f, 
    -0.01899039f, -0.02829777f, -0.01589213f, 0.04901284f, 0.00922410f, 0.01268220f, 0.04778869f, -0.03323339f, 
    -0.01645913f, -0.00430478f, -0.03418004f, 0.04923439f, 0.00558260f, 0.00682134f, 0.01879489f, 0.01447219f, 
    0.01790224f, -0.01359085f, 0.02432228f, -0.00200453f, -0.03114016f, -0.00161819f, -0.04481483f, 0.01276163f, 
    -0.04850211f, -0.02864613f, -0.01225573f, 0.00268400f, 0.00287807f, -0.05010441f, -0.01021914f, -0.04037591f, 
    -0.00319116f, -0.04695408f, -0.01022827f, 0.02933073f, 0.04010111f, 0.03955246f, -0.01470233f, -0.02683450f, 
    -0.02982934f, 0.02935774f, -0.03826554f, 0.01980186f, -0.00888755f, -0.01530630f, -0.03267040f, 0.01807063f, 
    -0.02565531f, -0.03912470f, 0.01961596f, -0.00203075f, -0.03600565f, -0.00491243f, -0.03344909f, -0.03725989f, 
    0.03197132f, 0.01597410f, -0.02035409f, -0.03525939f, -0.03600220f, 0.01116695f, 0.02584466f, 0.03682318f, 
    -0.01683081f, 0.01588956f, 0.03115175f, -0.03432911f, -0.01965726f, 0.04586377f, 0.01993832f, -0.02509988f, 
    -0.04051994f, -0.00776677f, 0.02457847f, -0.03222055f, -0.04700961f, 0.02849145f, -0.04987412f, -0.04396918f, 
    -0.02327094f, -0.00858524f, 0.02373323f, -0.04479713f, -0.02193783f, 0.01134198f, -0.00456902f, -0.02425622f, 
    -0.03663268f, -0.00515666f, -0.01866559f, 0.02435652f, -0.01807499f, -0.04676434f, -0.03765320f, 0.04367156f, 
    0.00711585f, 0.04177331f, -0.02773275f, -0.00923005f, -0.04096510f, -0.02758954f, 0.03284376f, 0.00512328f, 
    -0.02002479f, -0.03500886f, -0.04549708f, 0.02447991f, -0.01643636f, 0.00524309f, -0.04972466f, -0.00548154f, 
    -0.02825243f, 0.01553513f, -0.02084477f, -0.02811987f, -0.03479819f, -0.04446108f, -0.01608353f, -0.02149315f, 
    0.00859953f, 0.03312600f, 0.01894314f, 0.02009871f, 0.03094873f, -0.02875454f, -0.02704498f, 0.02667494f, 
    0.03626171f, 0.00520278f, 0.04877554f, -0.03461053f, -0.01877372f, 0.00463110f, 0.04662225f, -0.02612058f, 
    -0.01319666f, 0.02792303f, 0.02668553f, 0.00991615f, 0.01639962f, 0.02155946f, 0.03811729f, -0.00355383f, 
    -0.03111758f, -0.04135824f, 0.04975916f, -0.00871701f, -0.01840123f, -0.00292339f, -0.00385309f, 0.01375338f, 
    0.04398724f, 0.03732589f, 0.03220839f, 0.04665815f, 0.03931705f, 0.00774272f, -0.04428850f, 0.02042805f, 
    0.01128640f, 0.00347095f, -0.01813462f, -0.03064011f, 0.03357368f, -0.04236757f, -0.03186708f, -0.03309647f, 
    0.02542516f, -0.04301636f, -0.00262115f, -0.02514183f, -0.02891959f, 0.01747595f, 0.01061021f, -0.02745187f, 
    0.04547942f, -0.03202180f, -0.04857205f, -0.02423345f, -0.01331151f, -0.05073454f, -0.02606507f, 0.03985225f, 
    0.02794446f, 0.04993828f, -0.01315994f, -0.03670070f, -0.00173113f, 0.02518362f, -0.01280652f, -0.01139517f, 
    0.01887566f, -0.04988339f, -0.01460198f, 0.04453310f, -0.04860535f, 0.03387265f, -0.02406920f, -0.01190521f, 
    -0.05007876f, 0.01416048f, 0.00954925f, 0.01323273f, -0.04616833f, -0.02183541f, -0.04600676f, -0.03778065f, 
    -0.02576427f, 0.03391993f, -0.01166076f, -0.04101697f, 0.01549477f, -0.00770245f, -0.04820322f, 0.03309345f, 
    -0.03114540f, 0.04652826f, 0.01270582f, -0.01847723f, 0.05101512f, -0.03913481f, 0.01872619f, -0.04962125f, 
    0.02116477f, 0.04056614f, 0.03692401f, 0.00355784f, -0.01008806f, 0.03595641f, 0.00067754f, 0.03301267f, 
    0.03195674f, -0.04929625f, 0.01966297f, 0.01703877f, -0.02591845f, -0.00337488f, 0.00257944f, -0.04126823f, 
    -0.04214185f, -0.04034714f, -0.03730825f, -0.03062080f, -0.01099043f, -0.02082242f, -0.02486911f, 0.04559314f, 
    -0.00966518f, 0.02036277f, 0.01312470f, 0.00096822f, 0.00215093f, -0.04825687f, -0.03112511f, -0.02453925f, 
    -0.01997506f, 0.03085619f, 0.01312656f, -0.01848415f, -0.03586550f, -0.02638265f, 0.01645480f, -0.03852763f, 
    -0.01858672f, 0.01666773f, -0.04245706f, -0.03179449f, -0.03218760f, -0.03701972f, 0.00822529f, -0.03760296f, 
    -0.01143498f, -0.04651741f, 0.04473230f, 0.02768424f, -0.03405853f, 0.03820251f, -0.02964128f, -0.02370087f, 
    -0.01458956f, -0.01222061f, -0.02760012f, -0.03451176f, -0.00845386f, -0.04641490f, 0.02356240f, 0.03248787f, 
    -0.04707625f, 0.03964239f, 0.02596923f, -0.03916909f, 0.01778455f, -0.03471759f, -0.02167276f, -0.04909432f, 
    0.01873383f, 0.03386012f, -0.03928476f, -0.03356989f, -0.01300525f, 0.04059691f, -0.02861517f, 0.04243513f, 
    0.03230098f, 0.04023244f, 0.03953210f, -0.00335792f, -0.01931892f, -0.04634031f, -0.04410064f, 0.01353254f, 
    0.02747687f, 0.01080265f, -0.01218806f, 0.04397558f, -0.04854532f, -0.02689244f, 0.05085763f, 0.02573778f, 
    -0.00204577f, -0.04851985f, 0.00973378f, -0.03601513f, 0.01551425f, 0.02746069f, 0.04931370f, -0.03658543f, 
    -0.00361346f, -0.01721008f, 0.01989851f, 0.02608534f, 0.01221851f, -0.04925576f, -0.04054173f, 0.05006802f, 
    0.00566753f, 0.01281029f, 0.02589378f, 0.00849009f, 0.02803206f, -0.04247627f, 0.04803059f, 0.01360408f, 
    0.04784499f, -0.02482733f, 0.02858925f, 0.02430947f, 0.01859793f, 0.04063431f, 0.00811627f, -0.00366694f, 
    0.04281949f, 0.01898968f, 0.02662157f, -0.00691524f, 0.04577203f, -0.03029542f, 0.00350080f, -0.00789295f, 
    -0.02180570f, -0.00186977f, 0.02496074f, -0.04853519f, -0.05841459f, 0.00300411f, -0.04918056f, 0.03715733f, 
    0.02851332f, 0.02110014f, 0.01500646f, -0.00803445f, 0.01249126f, -0.05553658f, 0.03531370f, 0.02945108f, 
    -0.02241625f, 0.02279009f, -0.02111343f, 0.03755711f, 0.02033344f, -0.03866531f, -0.01363205f, -0.00713300f, 
    -0.03950675f, -0.02886635f, -0.00237253f, 0.04138063f, -0.02935553f, 0.03396830f, 0.02623814f, 0.03029884f, 
    -0.00595720f, -0.03925750f, -0.00664903f, 0.03587772f, -0.05055909f, -0.03593032f, -0.00697527f, -0.03306663f, 
    0.03312316f, -0.03809058f, 0.00206034f, 0.00227305f, -0.03029086f, -0.04396857f, -0.04044583f, 0.02396194f, 
    0.01028101f, -0.01182903f, -0.03530307f, -0.01724327f, -0.01269359f, 0.01004522f, -0.04372434f, -0.03918066f, 
    0.00755555f, 0.02913615f, -0.03811763f, -0.05278516f, -0.04909682f, -0.00509312f, 0.01069755f, -0.00481362f, 
    0.04471217f, -0.00593141f, -0.03839078f, 0.02285261f, 0.03778284f, 0.02508108f, 0.02433926f, 0.03722719f, 
    -0.00311317f, -0.04476981f, 0.03382499f, 0.00758089f, -0.00910350f, 0.04045179f, 0.01040704f, 0.01747017f, 
    0.00402506f, -0.04006803f, -0.03396366f, -0.03254719f, 0.04166551f, -0.05771790f, 0.02204772f, 0.03871140f, 
    -0.01014823f, -0.04845275f, -0.05013448f, -0.01380076f, -0.02734180f, -0.05623469f, -0.04356316f, -0.00073196f, 
    0.01682504f, -0.01561907f, 0.02003128f, 0.02400707f, 0.01447070f, 0.00472415f, 0.02430464f, -0.04544779f, 
    -0.02891243f, -0.05600453f, -0.04288204f, -0.05044132f, -0.03668836f, -0.03515153f, 0.01689952f, 0.02554509f, 
    0.04006222f, -0.00487697f, -0.04164420f, 0.01779997f, 0.03412023f, 0.00222182f, 0.01014500f, -0.05025496f, 
    -0.03124631f, -0.01826516f, -0.04393415f, -0.01690551f, -0.02744467f, -0.05976933f, 0.00595493f, -0.01774134f, 
    -0.01895346f, -0.01195599f, -0.05103956f, 0.03689441f, -0.02928353f, 0.03854889f, 0.00215905f, -0.00458208f, 
    -0.05160140f, -0.05306844f, -0.05860277f, -0.03201148f, -0.02846211f, 0.00526575f, 0.01494008f, 0.03712722f, 
    0.02003520f, -0.01337719f, -0.02322079f, -0.04704589f, -0.00605883f, 0.00360766f, -0.00628054f, -0.03095026f, 
    -0.03585271f, -0.02341939f, 0.03286937f, -0.01774903f, 0.03587712f, 0.03555684f, 0.00514364f, -0.00176813f, 
    -0.03460968f, 0.00260893f, 0.01130348f, -0.04001596f, 0.01723440f, -0.02480063f, -0.00066743f, -0.00534320f, 
    0.04377407f, -0.00097809f, 0.02673245f, -0.00923649f, 0.03293986f, -0.03914168f, -0.00242568f, 0.00874824f, 
    -0.02085723f, 0.03948488f, 0.02203446f, -0.00604608f, -0.00464090f, -0.05200563f, -0.03932418f, -0.02566126f, 
    -0.02908267f, 0.02807055f, -0.02481009f, 0.04588658f, 0.00836061f, 0.02441160f, -0.02821292f, -0.02844251f, 
    0.00590608f, -0.03803566f, -0.01687977f, 0.00172772f, 0.01452095f, -0.01729037f, 0.03928349f, -0.01677156f, 
    -0.01804146f, 0.02550792f, 0.03371785f, -0.03859381f, 0.02123917f, 0.03164973f, 0.00445047f, -0.03321457f, 
    -0.01884904f, -0.01218636f, 0.01816170f, -0.03392841f, 0.00270663f, 0.04587333f, -0.04012493f, 0.00943311f, 
    0.03717058f, 0.04252155f, 0.01510458f, -0.04417209f, -0.02105795f, 0.03873526f, 0.03783166f, -0.04414549f, 
    0.01728738f, 0.02334774f, -0.02061332f, -0.04972055f, -0.01166446f, -0.02292438f, -0.02656669f, -0.00353840f, 
    0.01981165f, -0.03098213f, 0.00943149f, 0.02656263f, -0.02580179f, -0.03438380f, -0.05084549f, 0.04082054f, 
    -0.03567539f, -0.00532026f, -0.05734180f, -0.01317057f, 0.05717281f, 0.04961824f, 0.00599278f, -0.00186943f, 
    -0.01655731f, 0.00795031f, -0.04445589f, 0.02736769f, 0.00788083f, -0.01097187f, 0.00798286f, 0.01799427f, 
    -0.02786939f, 0.03432396f, -0.03011774f, -0.03584723f, -0.01881060f, -0.01239350f, -0.02614556f, 0.01194605f, 
    -0.05117950f, -0.00093038f, 0.03261536f, -0.04762331f, 0.01291911f, -0.00106708f, -0.04347558f, -0.02298003f, 
    0.01417757f, -0.01422520f, 0.01842542f, -0.05222952f, -0.03368910f, -0.01454863f, 0.03331566f, 0.01663766f, 
    -0.06181320f, -0.04851554f, -0.04224880f, -0.04777910f, -0.00853777f, 0.00539502f, -0.00806581f, -0.00012398f, 
    -0.00722754f, -0.03542987f, -0.04580316f, 0.02378850f, -0.01061665f, 0.01930723f, 0.01019309f, 0.02512363f, 
    -0.04042122f, 0.04494448f, -0.03599011f, 0.01294201f, -0.04436673f, 0.02212847f, -0.00019975f, -0.00198736f, 
    0.05171990f, 0.01082135f, -0.04688515f, -0.05008793f, -0.02084380f, -0.05842257f, -0.01815995f, -0.04702073f, 
    -0.00568237f, -0.05708027f, 0.01434619f, 0.01202786f, -0.01770739f, 0.01895834f, 0.01326843f, -0.00409819f, 
    0.03874787f, 0.01360646f, 0.02513407f, 0.03646554f, 0.01165413f, -0.01888579f, -0.00703438f, 0.02557790f, 
    0.02715519f, 0.00223290f, -0.03036148f, 0.04139568f, -0.00907994f, 0.01917776f, 0.00684813f, 0.01921979f, 
    -0.00045213f, 0.02931917f, -0.01777408f, -0.04645535f, 0.02679650f, 0.01579642f, 0.01489684f, -0.00439043f, 
    0.03879439f, -0.02700920f, 0.04243736f, 0.04124808f, -0.05081765f, 0.02924171f, 0.00903593f, 0.01985811f, 
    -0.03610183f, 0.01063629f, -0.01074824f, -0.02662058f, 0.04153354f, 0.02352312f, 0.01471244f, 0.01830359f, 
    0.03647429f, -0.03934955f, -0.00695079f, 0.03640309f, 0.02223907f, 0.00052705f, 0.01357154f, 0.01193709f, 
    0.02201757f, -0.04876387f, 0.03524197f, -0.00988557f, 0.03395592f, -0.00930297f, -0.02836948f, -0.01019688f, 
    0.34266460f, 0.04859327f, 0.06636520f, 0.34487107f, 0.24281937f, -0.03847925f, 0.02626730f, -0.04977994f, 
    0.23480752f, -0.01034575f, 0.01016900f, -0.05247581f, 0.04301722f, 0.08181098f, 0.03793228f, 0.09284179f, 
    0.01465796f, 0.09167050f, 0.02221827f, 0.00155564f, 0.11084761f, -0.00814923f, -0.00543556f, 0.18581046f, 
    -0.00262083f, -0.18543218f, -0.15137100f, 0.44984466f, -0.03231633f, -0.07361870f, 0.12664515f, 0.05601844f, 
    0.10897863f, 0.04335006f, -0.04909432f, 0.07389429f, 0.36216730f, -0.06419417f, 0.16219100f, -0.04985974f, 
    0.11095031f, 0.03906856f, 0.04443919f, -0.07886493f, 0.14130320f, 0.00606705f, -0.09264029f, 0.18906261f, 
    0.08489670f, -0.14548521f, -0.17119478f, -0.15519936f, -0.10846228f, 0.14185402f, -0.01914511f, 0.01043288f, 
    0.05996667f, 0.08880625f, 0.05248824f, 0.09235989f, -0.13939776f, -0.05383246f, -0.22173774f, 0.07919984f, 
    0.09176509f, 0.01808413f, -0.00061485f, 0.13340585f, -0.02760278f, 0.04048448f, 0.11170826f, 0.10833418f, 
    0.38519567f, 0.34540862f, -0.27069527f, 0.20526305f, 0.21989730f, 0.11350153f, -0.05323033f, 0.04379441f, 
    0.03388721f, 0.11420724f, -0.02008822f, 0.13061632f, -0.04670659f, -0.22046952f, 0.09950472f, 0.16807283f, 
    -0.10704006f, -0.01916155f, -0.07675535f, -0.00337231f, 0.11253262f, -0.00173713f, -0.02331089f, 0.15944175f, 
    -0.16446783f, 0.18818471f, -0.18506286f, 0.03092143f, 0.11499678f, -0.08779471f, -0.04430642f, -0.03045155f, 
    0.03769267f, 0.10097925f, -0.04452366f, 0.15167849f, -0.01565884f, 0.13219523f, 0.19770241f, -0.36690933f, 
    -0.11151909f, 0.08974084f, -0.12880926f, -0.05431105f, 0.14491571f, 0.05994671f, 0.09750219f, -0.01323888f, 
    -0.12492584f, 0.24244981f, 0.00861793f, -0.01969365f, 0.06840988f, 0.06375330f, -0.05176213f, -0.11077864f, 
    0.06895100f, 0.10399937f, -0.03048245f, 0.19120987f, -0.07757428f, -0.20851472f, -0.06960035f, 0.07659703f, 
    0.02367275f, 0.00692284f, -0.08706526f, 0.15001409f, 0.07545641f, 0.05747786f, 0.00010680f, 0.00188393f, 
    0.24426463f, 0.17975420f, 0.16624324f, 0.07323218f, 0.01884719f, -0.10345478f, -0.10260437f, 0.01940414f, 
    0.04958262f, 0.07757617f, -0.10680661f, 0.09502686f, 0.03398370f, 0.12294605f, 0.36369011f, -0.15916872f, 
    -0.08827176f, 0.12024618f, 0.03876195f, -0.05686954f, 0.05981626f, 0.00911415f, 0.13210762f, 0.08355569f, 
    -0.41002774f, -0.49434853f, 0.28625157f, -0.43042129f, 0.04334638f, 0.12730268f, 0.06482345f, 0.06456272f, 
    -0.02313447f, 0.06166482f, 0.01307243f, -0.14432694f, -0.04656494f, -0.03208563f, 0.13425545f, -0.07034590f, 
    0.02207594f, 0.19499750f, 0.02196943f, 0.05993420f, -0.00450116f, -0.02523132f, -0.01164853f, 0.20460320f, 
    -0.40422547f, -0.00683351f, 0.13373955f, 0.25989321f, -0.05057201f, -0.09911900f, -0.07825988f, 0.06176450f, 
    0.18828575f, -0.02025048f, 0.00548880f, 0.06780268f, -0.35078716f, -0.16562040f, -0.40990785f, 0.04344128f, 
    0.15079279f, 0.02381362f, -0.00211769f, 0.01231138f, 0.11160528f, 0.06214920f, 0.05076202f, 0.13663559f, 
    -0.69942892f, -0.30286068f, 0.38522810f, -0.42855334f, 0.20227447f, -0.07586534f, -0.02357811f, -0.04417916f, 
    0.24534699f, -0.19394635f, -0.00317936f, 0.07191718f, -0.32230589f, 0.05441052f, 0.11383484f, -0.27702975f, 
    -0.13407852f, 0.14375484f, -0.00552818f, 0.06941555f, -0.03260195f, 0.04120255f, 0.05901822f, 0.15619951f, 
    0.04355239f, -0.03311699f, 0.15364681f, -0.04332808f, 0.09698939f, 0.13255802f, 0.17035213f, 0.01816376f, 
    0.10777388f, 0.17753470f, 0.05373236f, 0.19896245f, -0.07390176f, -0.22223260f, 0.13914263f, 0.00393009f, 
    0.21992415f, 0.08577973f, 0.14568746f, 0.38236135f, -0.01681543f, 0.06560409f, 0.12148448f, 0.17688853f, 
    -0.20664844f, 0.04627902f, -0.21988463f, 0.09601316f, 0.18710615f, 0.12517673f, -0.05781989f, 0.12545837f, 
    -0.07866888f, -0.06548725f, 0.01310598f, 0.02839928f, -0.11753599f, -0.48246205f, 0.13426927f, -0.14710800f, 
    -0.06186060f, 0.03317077f, 0.11232632f, -0.15898947f, -0.11919373f, -0.00769562f, -0.06251673f, 0.18447432f, 
    0.12497097f, -0.10711233f, 0.30660552f, -0.09125493f, -0.00457777f, -0.10405695f, 0.06899092f, -0.09591758f, 
    0.05764253f, 0.00136101f, -0.07417841f, 0.09272271f, 0.10244351f, 0.05539583f, 0.17910735f, 0.30017436f, 
    -0.01024321f, 0.01506873f, 0.00191656f, -0.16573256f, 0.00675497f, 0.00530376f, -0.19342400f, 0.08742897f, 
    0.07816159f, -0.13777316f, 0.07368786f, -0.06143525f, 0.23359630f, -0.04464793f, 0.08562730f, 0.10558017f, 
    -0.14807560f, 0.12152928f, 0.08774689f, 0.24114060f, 0.14303547f, -0.01596143f, -0.19241227f, -0.01603639f, 
    -0.04797050f, 0.06133633f, -0.07682227f, 0.06595656f, 0.03589597f, 0.00474337f, -0.07250401f, 0.05265782f, 
    0.09980696f, -0.25753179f, 0.08341648f, -0.17096271f, -0.09164043f, -0.11450380f, 0.04230991f, 0.17249697f, 
    -0.11108019f, -0.00664151f, 0.05165614f, -0.07012741f, -0.27355552f, 0.11647949f, 0.32240379f, 0.01327234f, 
    -0.02035054f, 0.16177782f, 0.09686700f, 0.01538006f, 0.01478697f, -0.01999692f, -0.02624233f, -0.00412615f, 
    0.08752464f, -0.23318951f, 0.24053091f, -0.24764097f, 0.18193531f, 0.02890858f, -0.13418347f, -0.04990539f, 
    -0.03144124f, 0.13177481f, 0.14414848f, 0.07778995f, -0.06782296f, 0.29448867f, 0.09346789f, -0.09289511f, 
    0.06655133f, 0.04571007f, -0.07901549f, 0.00084341f, 0.15880494f, -0.03822176f, 0.12799619f, 0.02615411f, 
    -0.02515209f, 0.01925025f, 0.04264182f, 0.03866070f, -0.00414348f, 0.03332133f, -0.04030624f, -0.05271451f, 
    -0.00289512f, 0.03154311f, 0.00278802f, 0.00136890f, -0.04115241f, 0.00428332f, 0.01593490f, 0.00405030f, 
    0.01992364f, -0.01864586f, -0.03720439f, 0.03724301f, -0.03392180f, 0.03703431f, -0.01110587f, 0.01845058f, 
    0.02492616f, -0.02158955f, -0.05374924f, -0.05197814f, -0.03736642f, 0.04431899f, -0.02459175f, -0.01416522f, 
    -0.03582123f, -0.00245373f, 0.03202472f, -0.04899300f, 0.00464531f, -0.02106922f, 0.04392874f, -0.03638419f, 
    -0.00366642f, -0.04148509f, -0.00868131f, -0.01511177f, 0.01942187f, 0.02831285f, -0.05619354f, -0.00109367f, 
    -0.04204706f, -0.00268447f, -0.04843434f, 0.03210150f, 0.00375619f, 0.00637994f, -0.04761913f, 0.02444075f, 
    0.02074137f, 0.00468401f, -0.04896153f, 0.01045077f, -0.04227046f, 0.04322669f, -0.02507456f, -0.03497456f, 
    -0.04215581f, -0.05150460f, 0.00373341f, 0.01628700f, -0.02778744f, 0.01406285f, -0.03107708f, 0.03258447f, 
    -0.02177531f, -0.05043506f, 0.04031894f, 0.04225073f, 0.02525581f, -0.02081565f, -0.01205505f, -0.02085345f, 
    -0.03280104f, 0.02468208f, -0.02214978f, -0.05250519f, 0.03894923f, 0.01282155f, -0.00457412f, -0.00008774f, 
    -0.03696496f, -0.02575601f, -0.03528548f, 0.02261806f, 0.00364206f, 0.03587951f, -0.01820618f, -0.01137898f, 
    0.00251638f, 0.03897377f, 0.02249258f, -0.03679002f, 0.03182197f, -0.00495055f, 0.00579125f, -0.05078833f, 
    -0.00766993f, 0.03270377f, 0.02637311f, -0.01784706f, -0.03490601f, -0.04816265f, -0.00423277f, -0.04756586f, 
    0.02471964f, -0.00924513f, 0.03250881f, -0.04924837f, -0.04101310f, 0.01176553f, 0.03008503f, 0.01516265f, 
    -0.01546173f, 0.01315390f, -0.04753908f, 0.03439489f, -0.00504066f, -0.04709049f, 0.03187966f, -0.03079507f, 
    0.03084097f, -0.02918329f, -0.02399595f, 0.01675618f, 0.01415713f, 0.02129378f, 0.02878020f, 0.02490531f, 
    -0.01358701f, -0.05609761f, -0.02089039f, 0.01738057f, 0.01660548f, -0.02475012f, -0.04577894f, -0.01584448f, 
    0.00763014f, -0.00297974f, -0.00940167f, 0.02318630f, 0.01899023f, 0.04208017f, 0.01947313f, 0.02624458f, 
    0.02626602f, -0.00180320f, 0.02012221f, 0.02691064f, -0.04683415f, -0.03939576f, -0.00545357f, -0.03550782f, 
    -0.02333706f, -0.04940353f, -0.05603281f, 0.00951789f, 0.00752793f, 0.00285150f, -0.03372715f, 0.01804710f, 
    0.02153015f, 0.03702179f, -0.05603834f, 0.03661885f, -0.00343509f, -0.05247580f, 0.02347121f, 0.02143754f, 
    -0.04695889f, -0.01583267f, -0.00627210f, 0.01508644f, -0.04304262f, -0.00744927f, -0.05119868f, -0.01637365f, 
    -0.04376124f, 0.03312828f, 0.03310340f, -0.04361438f, 0.01104799f, -0.03788523f, -0.03896264f, 0.01294843f, 
    0.01448583f, -0.02639501f, -0.04199947f, 0.03739648f, 0.02242980f, -0.01796388f, -0.03494695f, -0.05269370f, 
    0.03109519f, -0.03952005f, 0.03527615f, -0.01891318f, 0.01728021f, -0.04144524f, -0.05152661f, -0.00709542f, 
    -0.00667414f, -0.00194273f, -0.04021577f, -0.05565957f, -0.02891798f, 0.03692343f, -0.03259927f, 0.01538377f, 
    0.00340677f, 0.04396509f, -0.02909786f, 0.02600593f, -0.03412846f, 0.02980707f, -0.04982652f, -0.04286759f, 
    -0.05145270f, 0.02624729f, -0.02213123f, -0.04168565f, -0.04251006f, 0.03147678f, -0.05458419f, -0.05643384f, 
    -0.01453357f, 0.03754819f, -0.05393742f, -0.05382535f, -0.05067657f, 0.03830177f, -0.01630952f, -0.00190623f, 
    0.00031811f, -0.03044942f, -0.05144670f, -0.01696620f, -0.00047520f, 0.00675347f, 0.03928870f, -0.03097367f, 
    0.02077549f, -0.00793277f, -0.05469123f, -0.02067232f, -0.04278618f, 0.00419011f, -0.02449346f, 0.02392487f, 
    0.02496037f, -0.03269586f, -0.03266672f, 0.02753770f, 0.03160556f, -0.00263215f, 0.02065302f, 0.02436983f, 
    -0.02368478f, 0.00328907f, -0.02232859f, -0.03104493f, 0.01255964f, 0.00505859f, -0.02316242f, 0.03515107f, 
    0.04495043f, -0.04992557f, -0.02757463f, -0.03203203f, -0.04487054f, -0.05024014f, -0.00765668f, -0.05464156f, 
    0.00528861f, 0.03286739f, -0.01093917f, 0.03359814f, 0.03127318f, 0.04396629f, -0.04963590f, -0.00232689f, 
    -0.05227533f, -0.01419135f, -0.03956462f, -0.04835367f, 0.01225335f, 0.04032813f, -0.03142960f, -0.02442283f, 
    0.00180324f, 0.02165392f, 0.02179582f, -0.04197459f, -0.00540909f, -0.02271732f, 0.04316926f, -0.03147497f, 
    -0.03587981f, 0.03677839f, 0.02644327f, 0.02575903f, -0.02330119f, 0.03096275f, -0.03534723f, -0.01874520f, 
    0.00106089f, -0.05147421f, -0.05022260f, -0.04584702f, 0.03328961f, -0.00637794f, 0.03044146f, -0.04058490f, 
    0.02047338f, -0.00393585f, -0.01320860f, 0.00208829f, 0.03733132f, 0.01822472f, -0.00908335f, -0.05631877f, 
    0.00488141f, -0.05359105f, -0.03363731f, 0.02549605f, -0.01082283f, -0.01259989f, 0.02526728f, 0.01757053f, 
    -0.04398071f, -0.00210386f, 0.03053288f, -0.02576612f, 0.03143417f, 0.04346088f, -0.02327628f, -0.01312758f, 
    -0.04113688f, -0.02278975f, -0.05646070f, 0.03873938f, 0.00699105f, -0.04713206f, 0.00271717f, -0.00226927f, 
    -0.02118729f, -0.05469445f, -0.04804366f, 0.01189375f, -0.02516104f, 0.02703015f, -0.05686449f, 0.01132959f, 
    0.03675200f, -0.03748641f, -0.03389344f, -0.02977934f, -0.02866160f, 0.04253610f, 0.03047216f, -0.03073071f, 
    0.01445082f, 0.03878732f, -0.00810963f, -0.03740146f, -0.01629817f, -0.04079675f, -0.05452473f, -0.02299710f, 
    0.03590481f, 0.02355358f, -0.04434348f, 0.02198717f, -0.00443870f, 0.03511775f, 0.03320885f, 0.00963982f, 
    -0.00392505f, 0.02373176f, 0.04114673f, 0.03559185f, 0.01189560f, -0.04017371f, 0.02783197f, -0.01563651f, 
    -0.00608076f, -0.02658894f, 0.02012635f, -0.00316713f, -0.03657087f, 0.01952232f, 0.02372795f, -0.02601632f, 
    -0.01213773f, -0.02180565f, 0.00002743f, -0.00207927f, -0.04627400f, -0.00451156f, 0.00938010f, 0.01251682f, 
    0.03510752f, 0.00266291f, -0.05416161f, -0.01204701f, 0.01204649f, 0.04034974f, -0.03113398f, -0.05438472f, 
    -0.00363749f, 0.01525981f, -0.05000061f, -0.00235833f, 0.04403229f, -0.01263340f, -0.04557987f, -0.02497597f, 
    0.04004603f, -0.01053965f, 0.01629332f, 0.04029328f, -0.00680223f, 0.01698086f, -0.05061208f, -0.02838946f, 
    -0.01132187f, 0.01760906f, -0.04594165f, -0.01488342f, 0.00495434f, -0.00607335f, -0.00187277f, 0.04469939f, 
    0.04015563f, -0.03414650f, -0.01576221f, -0.02851279f, 0.04065746f, -0.01465822f, 0.03500542f, 0.00763486f, 
    -0.02353083f, -0.03010553f, 0.02750036f, -0.00772104f, -0.05037514f, -0.00413477f, -0.00575409f, 0.01960810f, 
    -0.04747892f, 0.00118367f, 0.02043928f, -0.02891917f, 0.00255934f, 0.02647746f, 0.01573670f, -0.00187123f, 
    0.00793144f, -0.04488842f, -0.04934916f, 0.04154009f, -0.03295476f, -0.04327353f, 0.02735922f, -0.02500047f, 
    -0.05181216f, -0.00843300f, 0.03395153f, -0.01449949f, 0.01949497f, -0.05276784f, -0.02344352f, -0.05140871f, 
    -0.00173699f, -0.03207142f, 0.01186644f, -0.03859773f, 0.00260843f, 0.00139590f, 0.01935117f, 0.01671900f, 
    -0.03620207f, -0.02110027f, 0.02576838f, -0.04361225f, 0.00582449f, -0.02651830f, -0.03572157f, 0.00023670f, 
    -0.03177169f, -0.01614802f, -0.00583237f, 0.03567187f, 0.00968327f, -0.02495560f, 0.02330003f, -0.01471678f, 
    -0.02556731f, -0.03928709f, 0.03868011f, -0.01832019f, 0.01860026f, -0.00633054f, 0.03824357f, 0.02277614f, 
    0.00049165f, 0.01537637f, -0.02761534f, 0.01900469f, 0.02188401f, -0.00920896f, 0.02306788f, -0.04105350f, 
    -0.02414500f, 0.00673577f, 0.00911571f, -0.04631464f, -0.04886515f, -0.02594039f, 0.01312422f, -0.00469189f, 
    0.02331466f, -0.02758089f, -0.05601216f, -0.05189579f, 0.03636255f, -0.05411309f, -0.01701388f, -0.03790413f, 
    -0.00836531f, -0.03994983f, -0.05115344f, -0.02471020f, -0.02747667f, 0.03914744f, -0.00937853f, -0.04390054f, 
    0.02965216f, -0.00332304f, -0.00565063f, -0.04738999f, -0.00855297f, -0.01441410f, -0.01539188f, 0.04404237f, 
    -0.04168708f, -0.03087080f, -0.01414139f, 0.00177779f, -0.02839466f, 0.00115915f, -0.00686389f, -0.00162032f, 
    0.02249537f, 0.00472514f, 0.00009799f, 0.00444701f, -0.04251941f, -0.03316302f, 0.01179563f, 0.03872389f, 
    0.03350798f, 0.04043752f, 0.00539232f, -0.00579478f, -0.01945082f, -0.05453833f, -0.03893096f, -0.03049686f, 
    0.03054173f, -0.05397398f, 0.00839509f, 0.00022715f, 0.04126316f, 0.02526408f, 0.04023495f, -0.00711026f, 
    -0.00688301f, -0.05377474f, -0.03211540f, -0.01257811f, 0.01252184f, 0.01259230f, 0.01690587f, -0.03594269f, 
    0.03073333f, -0.04664487f, 0.00585556f, -0.03727670f, -0.01713701f, 0.04284671f, -0.02616348f, 0.04331728f, 
    0.04661535f, 0.03645204f, -0.02833188f, 0.02549207f, 0.03016604f, -0.01892708f, 0.01993960f, -0.03553533f, 
    -0.01171741f, -0.00773181f, 0.01296363f, -0.00571047f, 0.03083347f, 0.01849973f, 0.03956633f, -0.04507167f, 
    -0.00401722f, -0.04130737f, 0.00919555f, -0.05345278f, -0.01870843f, 0.03725077f, -0.00265962f, -0.03807296f, 
    0.00878283f, 0.01534157f, -0.00515400f, 0.04182389f, 0.00799824f, -0.01674682f, -0.05502120f, 0.01883058f, 
    -0.04776902f, -0.02801815f, 0.02269784f, -0.02574571f, -0.00597701f, 0.04114148f, 0.05049700f, -0.04512003f, 
    0.02231489f, -0.02611327f, -0.05073155f, -0.03834951f, -0.01641492f, -0.05096655f, 0.02937434f, 0.03876572f, 
    -0.00031788f, -0.02717058f, 0.03386787f, -0.04593441f, 0.00416021f, 0.00822751f, 0.00647696f, 0.00063240f, 
    -0.01837041f, -0.00922062f, -0.05094284f, -0.03427476f, 0.03677574f, -0.03075892f, 0.00332441f, 0.00898381f, 
    0.01210493f, -0.05102610f, 0.00138011f, 0.01093446f, 0.02594585f, -0.04665113f, -0.02104212f, -0.04490811f, 
    -0.05562560f, 0.03710703f, -0.01175156f, -0.02389604f, -0.01350099f, -0.00754308f, -0.03392172f, -0.04808683f, 
    0.01719908f, 0.01469263f, -0.00637050f, -0.02101659f, -0.02570119f, -0.01016029f, 0.02491488f, -0.00525547f, 
    -0.01703953f, -0.02105550f, -0.03258224f, -0.05088932f, -0.04370707f, 0.03242958f, 0.03321179f, -0.03690991f, 
    0.01493924f, -0.00681186f, -0.03457315f, 0.00539411f, -0.04010375f, 0.04186847f, -0.01631864f, -0.04879658f, 
    -0.05082101f, -0.00585967f, -0.00962267f, -0.01889892f, -0.05503934f, -0.04929209f, 0.02646826f, 0.00770346f, 
    -0.01732325f, 0.02561989f, -0.05276052f, -0.01076666f, 0.01123073f, 0.02881520f, 0.03788180f, 0.01775252f, 
    0.02212136f, -0.05296131f, 0.04412184f, 0.00967213f, -0.01099860f, -0.03317989f, 0.03105258f, -0.00212254f, 
    0.01552088f, -0.02602903f, -0.00945476f, -0.02154552f, -0.02767755f, -0.02346735f, -0.03313468f, 0.00093549f, 
    -0.00151070f, -0.05496085f, 0.03704092f, 0.00640495f, -0.05171191f, 0.00330423f, 0.00783423f, 0.02960946f, 
    0.02552061f, -0.04969903f, -0.00199343f, 0.03569923f, 0.00815301f, -0.05129618f, -0.04051552f, -0.01839838f, 
    -0.05552954f, -0.01236887f, -0.03415401f, -0.02254996f, -0.01734793f, -0.02667363f, 0.02989681f, 0.00360306f, 
    0.00235875f, -0.00617611f, -0.03817414f, -0.02355178f, -0.00988283f, -0.02746488f, 0.01598427f, -0.01273991f, 
    -0.01056532f, 0.04695375f, 0.13911144f, -0.41982445f, 0.18415129f, 0.02254691f, 0.04576177f, 0.09882938f, 
    -0.10811070f, -0.00109931f, -0.04424184f, 0.14039956f, 0.00742624f, 0.09423387f, 0.01625692f, -0.08924314f, 
    0.05807335f, 0.06341366f, 0.12752467f, 0.10430906f, -0.04240202f, 0.05855541f, 0.02915312f, -0.13406409f, 
    -0.13174967f, 0.23337187f, 0.00101764f, -0.34433246f, 0.10494217f, 0.16931029f, 0.08828592f, -0.04546843f, 
    0.08960079f, -0.11091114f, 0.07053325f, 0.01732857f, 0.00574277f, -0.06202909f, -0.04448471f, 0.14251034f, 
    0.10919241f, 0.09599386f, -0.06909673f, 0.06210109f, -0.05951643f, 0.11601719f, 0.09919968f, -0.13953665f, 
    -0.05867022f, 0.21205263f, -0.28470281f, 0.26113608f, 0.10561074f, -0.14347845f, 0.01268111f, -0.02390217f, 
    0.07557516f, 0.09279188f, 0.16040082f, 0.00825027f, -0.43482119f, -0.01551840f, -0.12966290f, -0.08974023f, 
    0.15893404f, -0.02486133f, 0.14583960f, 0.04701358f, 0.24091308f, -0.06132968f, -0.02015129f, -0.11319593f, 
    -0.40819594f, -0.09751911f, 0.12703963f, -0.10890777f, 0.15119158f, -0.10563023f, 0.13993816f, 0.09703746f, 
    -0.09134888f, -0.03431300f, 0.01032689f, 0.22871849f, -0.04597968f, 0.26020852f, 0.00649323f, -0.31458619f, 
    0.18439198f, 0.01220762f, 0.16977035f, -0.19981752f, 0.08919577f, -0.04764839f, 0.08298602f, 0.10653815f, 
    -0.39774802f, -0.49363938f, -0.22063202f, -0.15539695f, 0.13769776f, 0.13959318f, 0.00079244f, 0.05744836f, 
    -0.08594801f, 0.01450145f, 0.10476228f, 0.06279978f, 0.09237203f, -0.21795854f, 0.03028645f, 0.53292286f, 
    0.06334073f, 0.10374124f, 0.11743292f, 0.14861570f, -0.17458393f, -0.16880068f, -0.10412534f, -0.00645607f, 
    0.25239456f, -0.05292663f, 0.01619238f, -0.16755368f, 0.08492763f, 0.02337114f, 0.09944917f, 0.28421563f, 
    0.01842352f, -0.12978463f, -0.07528204f, -0.01918422f, 0.06760019f, 0.09006834f, 0.06745161f, -0.17025486f, 
    -0.13735431f, 0.27464035f, 0.19846742f, 0.08789337f, -0.02029538f, 0.17676292f, 0.22229926f, 0.17756282f, 
    -0.15580916f, 0.15574047f, -0.08395407f, 0.00240648f, 0.02102012f, 0.16197048f, 0.00831437f, 0.01523077f, 
    0.13228589f, -0.01480605f, 0.32320437f, 0.22728220f, 0.27770948f, 0.00841354f, -0.12127800f, -0.05391582f, 
    0.01882874f, 0.08466152f, -0.06839349f, 0.09285914f, 0.10186116f, -0.15217711f, 0.08985543f, 0.02812465f, 
    0.02114259f, -0.07708243f, -0.02328135f, 0.34170440f, -0.15413783f, 0.14311662f, -0.12861829f, -0.01129309f, 
    -0.02241057f, 0.00658037f, -0.02808466f, 0.29131883f, -0.12319152f, 0.13417448f, 0.02791042f, 0.24275154f, 
    0.22481179f, 0.06683293f, -0.10292175f, -0.08327515f, 0.04268030f, -0.05334145f, 0.18428090f, -0.11202252f, 
    -0.16921844f, 0.20693877f, 0.31316417f, -0.19456890f, 0.13303381f, 0.03055922f, 0.10992607f, 0.04361790f, 
    -0.05397174f, 0.12425058f, -0.07794319f, -0.05877606f, -0.51653141f, -0.23783623f, -0.07099554f, -0.08301473f, 
    0.05452305f, 0.01281250f, -0.00715956f, -0.10734177f, -0.05870976f, -0.13482009f, 0.03576475f, -0.09430995f, 
    0.26264307f, -0.15705867f, 0.03547805f, 0.26208520f, -0.19278654f, 0.04094720f, 0.03336405f, 0.15158184f, 
    -0.02680463f, 0.06091915f, 0.04648472f, 0.01189031f, 0.24146715f, 0.08010768f, 0.17712073f, 0.16473119f, 
    -0.09646585f, -0.20190363f, -0.07043219f, 0.05844746f, 0.03323997f, -0.02229449f, 0.03895314f, 0.16415039f, 
    -0.00780026f, -0.18946062f, 0.05792799f, 0.27346775f, -0.18622826f, -0.03786756f, -0.05084722f, 0.09449546f, 
    0.03009322f, -0.17535949f, 0.12636442f, 0.04241371f, 0.05454192f, -0.14872369f, -0.29318792f, 0.08156955f, 
    -0.16599406f, -0.18120149f, -0.20674284f, -0.29659790f, -0.06913178f, -0.03153714f, -0.07581758f, -0.05142690f, 
    -0.23891850f, 0.00537793f, -0.02606283f, -0.07247089f, 0.12519328f, 0.09699543f, 0.04110426f, 0.01511765f, 
    0.05534710f, 0.09715592f, -0.02530386f, 0.12765485f, 0.21213117f, 0.23753138f, 0.05725207f, 0.42398095f, 
    -0.06844722f, 0.08830950f, 0.19107546f, 0.11697132f, 0.09742738f, -0.01444604f, 0.21043631f, -0.04699626f, 
    -0.01870036f, 0.18366949f, -0.03123390f, 0.18334776f, -0.07981171f, 0.10378120f, -0.00076128f, 0.04976406f, 
    -0.03954455f, -0.12333282f, 0.07705770f, -0.10117920f, -0.17756212f, 0.20511474f, 0.00024005f, -0.39752260f, 
    0.03403942f, 0.17836021f, 0.00235564f, 0.06075859f, 0.04416553f, -0.01597837f, 0.20058545f, -0.02188540f, 
    0.04429691f, 0.13364606f, -0.09316884f, 0.05494581f, 0.14906017f, 0.07611261f, 0.00938802f, 0.07636024f, 
    -0.02267465f, -0.11314866f, 0.07416277f, -0.34622359f, 0.00114857f, 0.11041953f, 0.17276628f, -0.00621478f, 
    -0.03876727f, -0.08338565f, 0.05285211f, 0.00567855f, -0.11286002f, 0.04709876f, 0.17893049f, 0.00318663f, 
    0.08142328f, 0.05548974f, -0.04611380f, 0.16882683f, -0.15390593f, 0.25474903f, 0.01406558f, -0.02118461f, 
    0.00189773f, 0.03652120f, -0.19593613f, -0.02135317f, 0.13921687f, -0.08977772f, -0.04788121f, -0.07622372f, 
    0.06499135f, -0.09101123f, -0.12629133f, 0.03479042f, 0.14197908f, 0.03041644f, 0.07988212f, -0.15320401f, 
    0.07241441f, 0.12697949f, 0.08948785f, 0.28964207f, -0.04015751f, 0.19362299f, 0.13777126f, 0.08178096f, 
    0.08429570f, -0.04682536f, 0.01451018f, -0.11520770f, 0.09274055f, -0.19468673f, 0.05969942f, 0.21581414f, 
    0.14470915f, 0.04597578f, -0.06169610f, 0.13112456f, 0.06784108f, 0.01788151f, -0.02001731f, 0.03866056f, 
    -0.04074034f, -0.01898874f, -0.02752586f, 0.04550317f, -0.02946277f, -0.00488569f, -0.03194786f, -0.03243920f, 
    0.04359032f, -0.04986940f, -0.03459733f, -0.03630362f, -0.04076493f, 0.00067723f, -0.03611038f, -0.02752192f, 
    -0.02900439f, -0.00226048f, 0.04111216f, 0.01162584f, 0.00838687f, -0.04999908f, -0.04271213f, -0.00034362f, 
    0.00494934f, 0.03425268f, -0.03166547f, -0.01437923f, -0.03511000f, -0.00000694f, 0.02392789f, 0.02086608f, 
    -0.02188649f, -0.04468378f, -0.03303150f, 0.02197123f, 0.02457685f, 0.01518912f, -0.03748386f, 0.01131277f, 
    -0.04450465f, -0.03755883f, -0.05345487f, 0.01886005f, 0.02367025f, -0.01896112f, -0.04462233f, 0.02024008f, 
    0.02768202f, 0.02119661f, 0.00439972f, -0.04966920f, 0.00106035f, -0.04044065f, -0.04928585f, -0.05312885f, 
    -0.00869919f, 0.01395737f, -0.01959519f, 0.00593521f, 0.03009382f, 0.01599322f, -0.02918119f, -0.02772582f, 
    -0.02832823f, 0.03404229f, -0.03840670f, 0.02554592f, -0.03662994f, -0.05546784f, -0.03696783f, 0.00883731f, 
    -0.00025789f, -0.02611552f, 0.04217760f, 0.00531091f, -0.03245879f, 0.02505201f, -0.03348509f, -0.00246212f, 
    -0.04814447f, 0.00220090f, -0.01060539f, -0.03093998f, -0.01257320f, -0.02080327f, 0.03405372f, -0.01166879f, 
    -0.03421281f, -0.03835398f, -0.04470147f, -0.03772661f, -0.02778865f, -0.03414200f, -0.02802883f, 0.01827611f, 
    -0.01297298f, -0.04780808f, -0.05156071f, -0.05057275f, 0.04477283f, 0.02712838f, 0.00774327f, 0.02369584f, 
    -0.02327173f, -0.04075252f, -0.04930994f, 0.00556141f, -0.03788306f, 0.01097993f, -0.03776075f, -0.04333644f, 
    -0.03663052f, -0.03755835f, -0.04020481f, -0.04591526f, -0.03301168f, 0.03382348f, -0.05189229f, -0.05235463f, 
    0.04051399f, 0.02137484f, 0.03380956f, -0.02658570f, -0.03178179f, -0.02525432f, 0.00034118f, -0.05432014f, 
    -0.04868412f, 0.03467054f, 0.02284203f, -0.01389177f, -0.05016682f, 0.04099766f, -0.03301613f, 0.01528112f, 
    -0.00004531f, 0.01069874f, -0.02754119f, -0.00461145f, -0.03933519f, -0.04326672f, 0.01186438f, -0.04174788f, 
    -0.00106692f, 0.03461263f, -0.02952322f, -0.05434890f, 0.02575542f, 0.03725354f, -0.03788145f, 0.02448169f, 
    -0.04126453f, -0.01773801f, 0.00898370f, 0.03892751f, 0.03730422f, 0.01385749f, 0.00644973f, 0.02573668f, 
    -0.00441766f, 0.03734066f, -0.05249461f, -0.03623256f, 0.04149142f, -0.02533366f, 0.00282162f, -0.01721085f, 
    0.02518536f, 0.01210443f, 0.01363753f, 0.00783947f, -0.01912869f, -0.04762018f, -0.02565363f, 0.04422821f, 
    0.04279379f, -0.03092526f, -0.03907607f, 0.02575959f, -0.02443766f, 0.00141124f, 0.01601357f, -0.00699435f, 
    0.03819854f, 0.01190819f, -0.05461558f, 0.00119636f, -0.02021127f, 0.03453289f, 0.02184082f, -0.03539466f, 
    -0.01220694f, -0.02016494f, 0.00749592f, 0.00069799f, 0.00916312f, -0.04395181f, -0.05045870f, -0.00575595f, 
    -0.04192641f, -0.04637116f, -0.02038746f, 0.02627056f, -0.00423447f, -0.04195750f, -0.04217287f, -0.03810607f, 
    0.03288705f, -0.02446103f, -0.02718625f, 0.02089191f, -0.04272459f, -0.03659997f, -0.05578823f, -0.01836684f, 
    -0.05076393f, -0.01953861f, -0.00704968f, 0.04259266f, 0.00099780f, -0.00733942f, -0.05272741f, 0.02080041f, 
    0.02273672f, -0.03356082f, -0.01963226f, 0.02780045f, -0.01809826f, -0.04412948f, 0.00477326f, 0.02482149f, 
    -0.03339743f, -0.02864972f, 0.04280797f, -0.00745678f, 0.00844172f, -0.03990946f, -0.02949122f, 0.01416226f, 
    0.03110706f, 0.03718219f, 0.01138826f, 0.01039015f, 0.03958183f, 0.02033684f, 0.01003752f, 0.01054220f, 
    -0.02395874f, -0.00494682f, 0.01615741f, 0.00072188f, 0.03661998f, 0.04465704f, 0.02014136f, -0.05129742f, 
    -0.00049201f, 0.01363623f, 0.01396902f, 0.02950714f, 0.04441713f, 0.04179691f, -0.01572869f, 0.00412809f, 
    -0.02605283f, -0.04579435f, -0.01856921f, -0.02719087f, 0.04057699f, -0.05416321f, -0.01267248f, -0.03514403f, 
    0.04038638f, 0.03426229f, 0.00610444f, 0.01845838f, 0.02179942f, 0.02243526f, -0.03383717f, -0.02739838f, 
    0.00524007f, 0.01033439f, -0.04743756f, -0.01363228f, 0.00813475f, -0.02845442f, 0.00637036f, 0.02434920f, 
    0.03750871f, -0.04994372f, -0.02253777f, -0.04813533f, 0.03237467f, -0.03880120f, -0.00702432f, 0.04063899f, 
    -0.01604467f, 0.01491191f, 0.04493763f, -0.05509547f, -0.05302990f, 0.02715782f, 0.00083373f, 0.03237630f, 
    0.00194219f, 0.02148563f, 0.01710414f, 0.00227213f, -0.04576574f, 0.01144237f, -0.04499401f, 0.00841997f, 
    -0.03377301f, -0.02464530f, -0.01957284f, 0.03630045f, -0.04869438f, -0.02361109f, -0.01842358f, -0.04388095f, 
    -0.02838129f, 0.04020106f, -0.04794189f, 0.03580087f, -0.03643565f, -0.04993633f, 0.00678808f, -0.00792858f, 
    0.00781510f, 0.03895851f, 0.04340215f, -0.02391038f, -0.05613813f, -0.05094350f, -0.01668654f, 0.02315561f, 
    0.00069129f, 0.01480464f, -0.04164332f, 0.01915119f, 0.01089111f, 0.01833647f, 0.02049018f, 0.04507185f, 
    -0.00309526f, 0.03777608f, -0.01430639f, 0.02112388f, 0.04272369f, -0.03324926f, -0.02794018f, -0.00577796f, 
    0.04067595f, 0.00750482f, -0.04513829f, -0.01434775f, 0.03665601f, -0.04610821f, 0.03269779f, 0.00209491f, 
    -0.02018023f, 0.03714612f, -0.02630109f, -0.01887221f, -0.00822177f, 0.02397915f, -0.04361711f, 0.01111021f, 
    0.03681159f, 0.00091723f, 0.02540660f, -0.04787103f, -0.02664532f, 0.00582251f, -0.02873412f, -0.03954693f, 
    -0.04561515f, -0.01159338f, 0.01180948f, -0.03569149f, -0.01787493f, -0.00387462f, -0.02052621f, -0.01115462f, 
    0.02142902f, 0.14895047f, -0.04271492f, -0.03279549f, 0.04962973f, 0.02628162f, 0.01221166f, -0.03110550f, 
    0.03291539f, -0.09759405f, -0.06160650f, 0.14855275f, -0.04764055f, 0.07516430f, 0.18105733f, 0.09602382f, 
    -0.00055959f, 0.05044141f, -0.03319833f, -0.15991461f, -0.01162778f, 0.02412661f, -0.08576472f, 0.11017360f, 
    0.38422835f, -0.00796810f, 0.07190334f, -0.11288140f, 0.02880480f, -0.12006687f, 0.15726714f, 0.11758635f, 
    0.03111249f, 0.25133798f, 0.20335196f, 0.08239505f, -0.14059690f, 0.00250150f, -0.26371250f, -0.04661917f, 
    0.14174590f, 0.04151419f, -0.00151161f, -0.05199688f, -0.13432737f, 0.04494943f, 0.13034549f, -0.06774867f, 
    -0.02749857f, -0.19876227f, 0.16590583f, -0.11103661f, -0.01686973f, -0.12286683f, -0.10156244f, -0.05768850f, 
    0.12591518f, 0.01293965f, 0.14999412f, -0.17240542f, -0.90202194f, 0.16411000f, -0.10756751f, -0.08410138f, 
    0.19681206f, -0.06264538f, -0.12756470f, 0.10287310f, 0.16899475f, 0.12588495f, 0.00056197f, 0.16310292f, 
    0.18025446f, 0.15501687f, 0.15892291f, -0.05624214f, 0.06942291f, 0.04877554f, 0.03795341f, -0.12009393f, 
    0.03245898f, -0.05467613f, -0.05785400f, -0.04499657f, 0.03398591f, -0.01384357f, 0.12715243f, 0.19056195f, 
    -0.09519495f, 0.01707802f, 0.01954354f, -0.06658452f, 0.07975258f, -0.07360362f, 0.14581533f, -0.01487356f, 
    -0.46686506f, 0.18504177f, 0.01067373f, -0.10928316f, 0.06323899f, 0.11013369f, 0.07833079f, 0.02104998f, 
    -0.11688623f, -0.20275368f, -0.12441649f, 0.00453832f, 0.10429697f, 0.00339974f, 0.05930079f, 0.23852754f, 
    -0.23561630f, -0.00213359f, -0.06057431f, -0.11239497f, 0.00249365f, -0.04287953f, 0.31310198f, 0.28869730f, 
    -0.19453903f, -0.22151244f, 0.06447531f, -0.02066767f, 0.19330893f, -0.07778100f, 0.20079282f, 0.11939354f, 
    0.28338793f, 0.37314361f, 0.13980287f, 0.06517442f, 0.07764558f, 0.03030777f, 0.16589096f, 0.10860296f, 
    0.13427231f, 0.18292622f, -0.01303837f, 0.21245487f, 0.17075998f, -0.13865176f, 0.06953160f, -0.13464913f, 
    0.14547642f, -0.01221865f, 0.24018545f, 0.24470818f, -0.07258595f, 0.15944652f, 0.05955052f, -0.14475422f, 
    0.04313491f, 0.05858275f, 0.21400532f, -0.20401773f, 0.06161709f, -0.15679683f, 0.15480928f, 0.37816748f, 
    0.09115448f, -0.14563605f, 0.04760940f, -0.04321829f, 0.01584487f, -0.06157880f, -0.15093265f, 0.13059680f, 
    0.23911929f, 0.00814631f, -0.31186986f, 0.10726537f, 0.11387163f, -0.07722343f, -0.08725633f, -0.04621808f, 
    0.02958516f, -0.02843412f, 0.19700763f, 0.00912941f, 0.00657687f, 0.24697596f, -0.32182023f, -0.23031002f, 
    -0.01189901f, -0.04436151f, -0.25666085f, -0.18559439f, 0.11892930f, 0.03563537f, -0.05318952f, -0.01645959f, 
    0.05511952f, -0.10285953f, -0.03290388f, -0.02359730f, 0.00659700f, -0.12129373f, 0.07172900f, 0.06248396f, 
    0.05326673f, 0.01535632f, 0.11216158f, 0.20612423f, -0.36386395f, 0.19883521f, 0.02771853f, -0.03180654f, 
    -0.09491643f, 0.17301607f, 0.19317038f, 0.13379410f, 0.05818907f, -0.10108637f, -0.03179861f, -0.09910492f, 
    0.30195090f, -0.00770721f, 0.01213344f, 0.25338793f, -0.05467623f, -0.01520791f, 0.23309764f, -0.02287783f, 
    -0.01700387f, 0.05547856f, -0.09126464f, 0.00940729f, -0.20916025f, 0.00280357f, 0.04548812f, 0.33004174f, 
    -0.02804746f, -0.00086542f, -0.15491921f, 0.03678592f, 0.12249447f, -0.00165409f, 0.08478306f, 0.08117297f, 
    -0.01279625f, -0.03421415f, 0.08943401f, 0.40648222f, -0.00961205f, -0.16054916f, -0.06004421f, -0.07553696f, 
    -0.02121406f, 0.07940429f, 0.03551073f, 0.17618090f, 0.12022854f, -0.02235949f, -0.12702142f, 0.18799268f, 
    0.22691795f, 0.29028562f, 0.01292035f, -0.22659798f, 0.06123831f, -0.17288168f, 0.02695506f, -0.02945721f, 
    -0.24010533f, 0.06585853f, -0.10387048f, -0.10670520f, -0.04017234f, -0.02428031f, 0.32488337f, 0.04505013f, 
    -0.09821840f, 0.01327464f, 0.07982588f, 0.02400358f, 0.05745278f, 0.22579828f, -0.03536791f, 0.30632645f, 
    0.15830433f, -0.06382211f, -0.01353706f, 0.01152092f, -0.14814305f, 0.02187271f, -0.00881546f, -0.08666855f, 
    0.10369195f, -0.00061830f, 0.20132405f, 0.08236722f, -0.01641400f, -0.00548812f, -0.07041965f, 0.04754725f, 
    0.05573102f, 0.08315220f, 0.02265612f, 0.22372197f, -0.06521757f, -0.04597534f, -0.13825177f, -0.05530176f, 
    0.07601293f, 0.00059983f, -0.07563823f, -0.11490343f, -0.13847870f, 0.06560405f, 0.11990704f, -0.04576721f, 
    0.04648493f, 0.15708701f, -0.18852884f, 0.05497233f, 0.09847025f, 0.17512387f, 0.08462631f, -0.17105089f, 
    0.09464820f, 0.09753562f, -0.08618877f, 0.24787228f, 0.07636496f, 0.07123400f, 0.15397164f, 0.08309561f, 
    -0.03114426f, 0.00700932f, -0.08613752f, -0.02451505f, -0.12196365f, 0.09887152f, 0.26517624f, 0.04965898f, 
    -0.31525278f, -0.01990705f, -0.14379226f, 0.19894306f, -0.02968982f, 0.14054917f, 0.04434029f, -0.03034907f, 
    0.28116357f, 0.00545442f, -0.02773086f, 0.17592816f, -0.23900269f, 0.02982230f, 0.06613582f, 0.10351992f, 
    0.06600558f, 0.02100663f, -0.11582638f, 0.05997617f, 0.16309033f, 0.08478970f, -0.11980029f, 0.05032554f, 
    -0.22902739f, 0.03920970f, -0.01080086f, -0.12711117f, 0.07551532f, 0.10121251f, -0.04209074f, 0.00280907f, 
    0.03016489f, 0.07940703f, 0.17737697f, 0.27329522f, -0.14125209f, -0.31734836f, -0.02506646f, 0.16243391f, 
    0.18298592f, 0.00637706f, -0.00258729f, 0.01054091f, 0.08473700f, -0.16690259f, -0.02928554f, 0.05853068f, 
    0.02527596f, 0.01289216f, -0.03401109f, 0.00184531f, -0.02494341f, 0.01883346f, 0.02338029f, -0.04526754f, 
    0.00077301f, -0.00785595f, -0.04972412f, -0.01161013f, 0.01070635f, 0.00679971f, -0.02442051f, 0.03213436f, 
    -0.01542838f, -0.04037470f, -0.03734446f, -0.02061395f, -0.03956748f, 0.00796133f, -0.01522180f, -0.00481566f, 
    0.04092435f, -0.03811039f, 0.01710635f, 0.01773923f, 0.01886360f, 0.01193301f, -0.00226842f, 0.03472986f, 
    -0.04788944f, 0.03076411f, -0.00841238f, -0.01729450f, -0.01669577f, 0.03368466f, -0.03869259f, -0.05449760f, 
    -0.02414312f, 0.00379706f, 0.03107880f, -0.03460934f, 0.00633537f, 0.04063942f, -0.04092447f, -0.04105351f, 
    -0.01468161f, -0.00571546f, -0.04812890f, -0.04820900f, 0.02557501f, 0.01192940f, 0.03619293f, 0.01075392f, 
    0.02507726f, 0.00694313f, -0.03588810f, -0.05109370f, -0.02998945f, -0.02070932f, 0.00286888f, 0.03250511f, 
    0.02894422f, -0.05465977f, -0.04782798f, -0.01315083f, -0.02192036f, -0.05476353f, -0.02015363f, 0.03863481f, 
    -0.02889563f, -0.01122253f, -0.05155656f, 0.04065372f, -0.01707970f, -0.01229637f, -0.04982663f, -0.02046667f, 
    0.01070950f, 0.00107254f, 0.01007886f, 0.01218690f, -0.02704984f, -0.02087361f, 0.01120231f, 0.04942197f, 
    -0.01720477f, -0.00450698f, -0.00926816f, -0.02520264f, 0.02581613f, 0.04076447f, -0.00366520f, -0.06036347f, 
    -0.00274007f, -0.01622970f, -0.04690982f, 0.00545496f, -0.05362659f, 0.00757502f, 0.03593636f, 0.03729187f, 
    -0.01496107f, -0.05305281f, 0.01978893f, -0.00639508f, 0.05016832f, 0.00840534f, -0.03354190f, 0.04868210f, 
    -0.02971321f, 0.03125676f, 0.03650223f, 0.04558214f, 0.02343903f, -0.02989882f, 0.03063741f, -0.03231469f, 
    0.00559059f, 0.01536000f, 0.00342749f, 0.01750925f, -0.03852451f, 0.01993017f, -0.02594571f, 0.04170414f, 
    -0.00589246f, -0.03319487f, 0.00180160f, 0.00725020f, -0.03788747f, -0.02638510f, 0.01393463f, 0.03410091f, 
    0.03075471f, 0.01893785f, 0.01457756f, -0.05142617f, 0.00268529f, 0.00965160f, -0.02410198f, 0.03758397f, 
    -0.02803122f, 0.00517789f, -0.02851609f, -0.01997070f, 0.00449685f, 0.01618281f, 0.04694151f, 0.01804068f, 
    -0.04049688f, -0.01266095f, -0.03346942f, -0.00026767f, 0.02403236f, -0.03218665f, 0.04506829f, 0.03478976f, 
    0.00314033f, -0.01794617f, 0.00870938f, 0.00479981f, -0.04697920f, 0.01437338f, -0.02570615f, -0.02177643f, 
    0.03991706f, 0.01172026f, 0.00671485f, 0.00165296f, 0.02181329f, 0.03265946f, -0.05251833f, 0.02348216f, 
    0.00771848f, 0.01506591f, -0.02407038f, 0.02294510f, -0.04364821f, -0.03104637f, 0.02911267f, 0.00178586f, 
    0.02968007f, 0.02946658f, 0.03404244f, -0.00908619f, 0.00542064f, 0.00346940f, -0.01635945f, 0.01539629f, 
    0.00985530f, -0.01283811f, -0.01679933f, 0.01978827f, -0.02939571f, -0.02436151f, 0.00840871f, -0.02509353f, 
    -0.01148863f, -0.01220073f, -0.05226807f, -0.00996828f, -0.04662057f, -0.02604956f, -0.03859806f, 0.02101419f, 
    -0.02931963f, 0.02878948f, -0.04159850f, 0.00108575f, -0.03444983f, -0.03009238f, -0.01657973f, -0.03537511f, 
    -0.00820786f, 0.01831922f, -0.02889850f, 0.02900586f, 0.03295917f, -0.05096218f, -0.03749446f, -0.03626953f, 
    -0.00493802f, 0.01408496f, -0.05698540f, 0.01510019f, 0.00578368f, 0.01856985f, -0.04875317f, 0.03725171f, 
    -0.01031340f, -0.05171942f, 0.03810123f, -0.02710647f, 0.00831198f, 0.01930654f, -0.05098206f, -0.00887254f, 
    -0.02149117f, 0.01270639f, -0.02271623f, 0.04054425f, -0.01659313f, -0.05512317f, 0.01134570f, 0.03165057f, 
    -0.03210632f, 0.02784601f, -0.00075754f, 0.01066494f, 0.01708442f, -0.04300450f, 0.03072357f, -0.01292286f, 
    0.00081990f, -0.04942019f, 0.01970281f, -0.02808737f, -0.05129084f, 0.00051427f, 0.03569698f, -0.00591416f, 
    -0.05151788f, -0.00239562f, -0.03763316f, -0.00589695f, 0.00760639f, -0.05322886f, -0.02912870f, 0.01951557f, 
    -0.02005689f, -0.03912110f, 0.01598006f, 0.00825970f, 0.03694878f, -0.02776811f, 0.02680930f, -0.03342015f, 
    0.01619779f, -0.04099884f, 0.00858250f, -0.04177935f, 0.03842997f, 0.02057777f, -0.03829593f, 0.00516469f, 
    0.04478583f, 0.00105761f, -0.05515628f, 0.03303566f, -0.02216906f, -0.00128921f, 0.00605261f, 0.03728518f, 
    0.01892362f, -0.01105592f, -0.00272348f, -0.05196251f, -0.01874897f, -0.04374703f, 0.00928016f, 0.00005148f, 
    -0.04138148f, 0.03061660f, 0.02260332f, 0.03823848f, -0.00763195f, -0.03573613f, -0.05453436f, 0.00103624f, 
    0.03749245f, 0.03421221f, 0.00197319f, 0.03921391f, 0.02619291f, -0.04995626f, -0.04185254f, 0.03982067f, 
    0.02661527f, -0.05465445f, 0.02713297f, -0.00140037f, -0.00568315f, -0.04758035f, -0.03715816f, -0.02108578f, 
    -0.00481191f, -0.02887799f, 0.01260447f, -0.05185625f, -0.05669693f, -0.04495430f, -0.03948068f, -0.03525518f, 
    0.04128804f, 0.01436285f, -0.02370091f, 0.04046800f, -0.04176534f, 0.04098414f, -0.01939365f, -0.02828459f, 
    -0.02450476f, -0.02647957f, -0.03960535f, 0.02477212f, -0.02086940f, 0.02442236f, 0.00447603f, 0.01191888f, 
    -0.01038640f, -0.04412507f, -0.02111719f, -0.01258462f, -0.02790600f, -0.04328745f, -0.05818311f, -0.00847097f, 
    -0.03227121f, 0.00854287f, -0.03629994f, -0.03235192f, 0.01232779f, -0.02224444f, -0.04190192f, 0.03035909f, 
    0.04032286f, -0.02899257f, 0.02732584f, 0.03476166f, 0.03432956f, -0.01918198f, 0.02129508f, 0.01180768f, 
    -0.01202528f, 0.01266943f, -0.02464819f, -0.01098399f, 0.02321484f, 0.02356644f, 0.03379267f, -0.03797879f, 
    -0.08691938f, -0.17154689f, -0.04960759f, -0.11285769f, 0.11864651f, -0.12607460f, 0.03134921f, -0.01953623f, 
    -0.07592590f, -0.02723796f, 0.08061285f, 0.01721492f, -0.07306074f, -0.15825799f, -0.03054010f, -0.09228865f, 
    -0.00629278f, -0.01238177f, 0.03757620f, -0.04718243f, -0.06418577f, -0.04229115f, -0.05029605f, 0.10475712f, 
    -0.26126617f, 0.01093178f, -0.28312188f, 0.14399353f, 0.04695221f, -0.03592729f, 0.10887284f, -0.01184925f, 
    0.07479468f, -0.03953250f, -0.00844554f, -0.10595614f, -0.01051052f, -0.31649670f, -0.04473942f, 0.02942358f, 
    0.13768589f, 0.14198641f, -0.01503112f, -0.08318853f, 0.19655183f, -0.01081915f, 0.01583731f, 0.07388512f, 
    0.05062805f, 0.43756530f, -0.26526082f, 0.32484049f, -0.11638923f, -0.06391636f, -0.03775626f, 0.11039912f, 
    0.03214421f, 0.08385020f, 0.02738146f, 0.02178522f, 0.04803495f, 0.23478170f, 0.20647970f, 0.12113920f, 
    -0.04655017f, 0.03318187f, 0.18920398f, -0.15681475f, -0.01496241f, 0.09873071f, 0.07016986f, -0.14091370f, 
    0.26028886f, -0.25932479f, -0.24884766f, -0.16143061f, 0.09394758f, 0.11695750f, -0.01566981f, 0.03599475f, 
    -0.06564765f, 0.09826805f, 0.03770554f, -0.06039211f, -0.03161046f, 0.10826077f, -0.01529420f, 0.02112365f, 
    0.21099512f, 0.00421490f, 0.07722524f, -0.08408259f, 0.13702846f, -0.09843735f, 0.02649689f, -0.08050002f, 
    -0.21081260f, 0.12250955f, 0.23091076f, 0.27319485f, -0.03410928f, -0.02650143f, 0.04947092f, 0.05425435f, 
    0.04180604f, 0.06765140f, 0.00208577f, -0.08302796f, 0.15602486f, 0.15033020f, -0.34068474f, 0.14798360f, 
    -0.00487562f, 0.03398317f, -0.20775542f, 0.09989002f, 0.03282256f, 0.03474649f, 0.03728206f, -0.11286378f, 
    0.05703074f, 0.00851560f, -0.06645246f, 0.05772634f, 0.03374283f, -0.17188127f, 0.02214462f, 0.04706586f, 
    0.02872153f, -0.06850975f, -0.08193775f, -0.01830086f, 0.16694321f, 0.06278257f, 0.30654934f, -0.05473000f, 
    0.02312988f, -0.02470300f, -0.08350006f, 0.03882177f, -0.10064724f, -0.03936704f, 0.06344941f, -0.03597039f, 
    0.03428312f, -0.12254085f, 0.23383912f, 0.01597991f, -0.05874830f, -0.05398963f, 0.14764713f, 0.04362331f, 
    0.13275182f, -0.17625819f, 0.02551212f, 0.10157936f, 0.14347799f, 0.05065099f, 0.07322119f, -0.21356416f, 
    0.08566464f, 0.06793884f, -0.08996202f, 0.02083955f, 0.21627423f, 0.01691964f, 0.10211289f, 0.10363322f, 
    -0.06082773f, 0.27271804f, 0.14202258f, 0.17634994f, 0.00159833f, 0.04896973f, 0.02340250f, 0.09040423f, 
    0.04689604f, 0.15912989f, -0.06746308f, 0.09354597f, -0.23389700f, 0.15253340f, 0.03327619f, 0.24350907f, 
    0.01868162f, 0.19278468f, -0.11906035f, 0.00555549f, 0.02427142f, 0.05143134f, 0.03944813f, 0.01977818f, 
    -0.22032940f, -0.30292043f, 0.07883722f, -0.18057713f, 0.08358509f, 0.04254334f, 0.01716280f, 0.09185518f, 
    -0.08015338f, -0.05379320f, -0.01155979f, -0.03063193f, -0.03053174f, 0.21906783f, 0.32183784f, 0.26820281f, 
    0.00794358f, -0.08713298f, 0.00466928f, -0.04373861f, 0.01097825f, -0.00320652f, 0.06359700f, -0.01353795f, 
    0.11896160f, 0.22809692f, -0.08467631f, 0.06168472f, 0.20048322f, -0.10909238f, -0.08483294f, 0.13022488f, 
    0.17924088f, -0.00807737f, -0.03426445f, 0.08490445f, 0.20483783f, 0.02308022f, 0.26573032f, -0.00889699f, 
    -0.15361460f, -0.04465157f, -0.01113691f, 0.09245718f, 0.04246514f, -0.00457155f, 0.20005274f, 0.15686908f, 
    0.17254111f, 0.10407756f, 0.03165301f, 0.24196856f, -0.08257335f, 0.04401575f, 0.03303421f, 0.12003601f, 
    0.20673601f, -0.03610677f, -0.04367290f, 0.03277811f, 0.35352990f, 0.35752127f, 0.30567056f, 0.20047805f, 
    0.05298099f, 0.08236697f, 0.18712038f, 0.15545678f, 0.11146484f, -0.05771359f, 0.04944789f, -0.13602567f, 
    0.10313848f, 0.21177308f, -0.02772555f, 0.26223883f, 0.13904426f, 0.01453309f, 0.09675758f, -0.09751535f, 
    -0.03458381f, 0.11346311f, -0.01791541f, 0.21548980f, 0.04025831f, -0.04661997f, -0.32913569f, 0.11919005f, 
    0.06767353f, 0.08962798f, -0.11238535f, -0.07506007f, 0.09614007f, 0.04324950f, 0.10955673f, -0.05913825f, 
    -0.14446840f, -0.35006157f, -0.25120929f, 0.07326957f, -0.09062736f, -0.00195590f, -0.00381769f, -0.10646349f, 
    0.00354833f, -0.02843785f, -0.07682641f, -0.04004705f, -0.32127905f, -0.05906511f, 0.02455661f, -0.03035566f, 
    0.11946365f, 0.15331022f, 0.01720666f, -0.07877980f, -0.02640373f, -0.05882500f, -0.10860619f, 0.06635815f, 
    0.21055976f, 0.24439585f, 0.19270892f, 0.19145498f, 0.07435028f, 0.04326806f, -0.02294721f, 0.10326572f, 
    0.04387803f, -0.08621100f, -0.18328246f, -0.03786450f, -0.24928251f, -0.17033094f, -0.08854496f, 0.27730885f, 
    0.01835914f, 0.07128110f, -0.10654010f, 0.15455674f, -0.00910701f, -0.02339001f, -0.05175766f, -0.07160312f, 
    -0.00064652f, 0.42726710f, -0.18134858f, 0.20421785f, 0.00746825f, 0.00785431f, -0.14944856f, 0.12236966f, 
    -0.00929349f, 0.13124974f, 0.11095545f, -0.11609221f, -0.11674995f, -0.20933551f, -0.16335863f, -0.20476861f, 
    0.07483210f, 0.03503148f, -0.02577323f, 0.00498234f, 0.03075018f, -0.11649487f, -0.01541118f, -0.06214331f, 
    0.08270980f, -0.54838187f, -0.09748819f, -0.07929672f, 0.16518159f, -0.04713810f, -0.19553407f, 0.03616075f, 
    -0.12561107f, 0.10651892f, -0.10085824f, 0.18148437f, 0.12446306f, -0.31195486f, -0.32068574f, 0.02356124f, 
    0.02241888f, -0.00189809f, -0.10959757f, -0.04629166f, 0.05819478f, -0.06852154f, 0.03577829f, 0.03449944f, 
    0.04802198f, -0.01280658f, -0.13342321f, -0.22057784f, 0.21366531f, 0.02685432f, 0.02508432f, 0.02538283f, 
    -0.02671887f, -0.03738144f, 0.16676231f, 0.07170743f, -0.13906252f, 0.12736259f, -0.09481519f, -0.24983713f, 
    0.07487648f, 0.04232774f, 0.07771979f, -0.08531551f, 0.05493144f, -0.03003392f, 0.04664600f, -0.03513846f, 
    -0.27730393f, 0.16939113f, -0.17009678f, -0.36845440f, 0.17496695f, -0.09186811f, 0.10324091f, 0.01103220f, 
    -0.06354325f, -0.05645484f, -0.00218416f, 0.05453373f, -0.15244582f, 0.09235273f, 0.31835151f, -0.12241583f, 
    0.04134038f, 0.10044987f, 0.17837048f, -0.09352964f, 0.15291703f, -0.07695084f, 0.03900121f, -0.01455314f, 
    0.18299380f, 0.05411980f, -0.33806416f, 0.44124150f, 0.12410529f, -0.03690118f, -0.05177596f, 0.12731652f, 
    0.03500151f, -0.02171761f, 0.13446051f, 0.02708890f, 0.29845375f, 0.02783598f, -0.01304173f, 0.05561531f, 
    0.10258678f, 0.07432840f, -0.03754751f, -0.00750824f, -0.01273534f, -0.03902297f, -0.05545365f, -0.07543311f, 
    -0.09916810f, 0.15417366f, -0.07979526f, -0.27773198f, 0.09458656f, 0.06696707f, 0.06004686f, 0.01004327f, 
    -0.04141060f, 0.17103162f, 0.01162225f, 0.08858488f, -0.52342027f, 0.10963801f, 0.04456330f, -0.32675278f, 
    0.20140412f, 0.00141317f, 0.09310464f, -0.06326518f, -0.00766561f, -0.02693268f, 0.05441954f, 0.10957542f, 
    0.02231716f, 0.36416614f, -0.16977036f, 0.15085900f, 0.07397480f, 0.04278766f, -0.00551144f, 0.13800514f, 
    0.08087482f, 0.15498796f, 0.02871039f, 0.05138297f, -0.18629014f, -0.04357521f, 0.00078136f, 0.02231134f, 
    0.10049923f, -0.03798130f, 0.01034551f, -0.03370085f, -0.15411082f, 0.06792161f, 0.07660457f, -0.18975388f, 
    -0.04668937f, 0.02467548f, 0.00654117f, -0.07771118f, 0.09894356f, 0.00189344f, -0.15018591f, -0.01357080f, 
    -0.01202162f, -0.00575376f, -0.01627145f, 0.01118321f, 0.12806311f, -0.16915204f, 0.07379210f, 0.06657621f, 
    0.02179617f, 0.06114873f, 0.05539180f, -0.10528425f, 0.06173431f, -0.00721105f, 0.15104423f, -0.06576042f, 
    0.14424406f, -0.15780634f, 0.03587691f, -0.00456144f, -0.15362908f, 0.02830850f, -0.01899406f, -0.06311078f, 
    0.11475335f, 0.00254532f, -0.14769316f, 0.17133875f, 0.15213673f, 0.25651121f, 0.24310178f, -0.30791938f, 
    -0.03557080f, 0.06736574f, -0.11651853f, -0.06977544f, -0.00590597f, 0.02023450f, 0.15212905f, 0.05956470f, 
    -0.31788319f, -0.17527422f, 0.09472292f, 0.23511277f, 0.02341981f, 0.08636986f, 0.07283018f, -0.08756107f, 
    -0.08274673f, 0.18313751f, 0.02293690f, 0.06430644f, -0.31613231f, 0.18484974f, 0.26366434f, 0.10283089f, 
    0.07709546f, 0.18265890f, 0.05986028f, -0.05173840f, 0.00048379f, 0.05371744f, 0.10013916f, -0.08884989f, 
    0.08766621f, 0.09601537f, 0.28191614f, -0.28038624f, -0.13127069f, 0.04268155f, -0.02856404f, 0.09182326f, 
    -0.00934145f, 0.01560899f, -0.01509299f, 0.06665961f, -0.30488867f, -0.07164616f, 0.16252866f, 0.14689250f, 
    0.02752826f, 0.00130560f, 0.04236900f, 0.04719640f, -0.00740067f, 0.02677949f, -0.04749002f, 0.09409429f, 
    -0.22117998f, -0.09410598f, 0.05782288f, 0.33076167f, 0.08529251f, -0.03981647f, 0.02626134f, 0.04863345f, 
    0.15620945f, -0.00834186f, 0.05605518f, 0.01897419f, 0.53091240f, -0.36358634f, 0.06304874f, 0.13126919f, 
    -0.14552429f, -0.03867904f, -0.07245390f, 0.01496091f, 0.06827563f, -0.00157681f, 0.04708621f, 0.04078563f, 
    0.04759336f, -0.20239849f, -0.02459551f, 0.39216650f, -0.02283214f, 0.02762491f, 0.14839625f, 0.04003961f, 
    -0.02164488f, -0.08687300f, -0.00996191f, 0.11184356f, 0.23403057f, 0.05968717f, -0.05020186f, 0.34649009f, 
    0.24179633f, -0.00726797f, 0.05756021f, 0.07553172f, 0.03408959f, 0.16115414f, 0.04783372f, -0.13978815f, 
    -0.07884112f, 0.13577457f, 0.12602237f, 0.20963220f, 0.09483308f, 0.02276175f, 0.02789517f, 0.10939860f, 
    0.01536590f, 0.15712871f, -0.10099019f, 0.11208951f, -0.16484696f, -0.20922267f, 0.19941185f, 0.05309864f, 
    0.09125812f, 0.02336726f, 0.20122257f, -0.06582241f, -0.11220142f, -0.08903812f, 0.04782705f, -0.00032425f, 
    -0.02725107f, 0.02720147f, -0.03733047f, -0.15525787f, 0.08361259f, -0.04634386f, 0.08122651f, -0.10646036f, 
    -0.09081445f, -0.05621003f, 0.02883869f, 0.06863485f, -0.25705564f, 0.12487198f, 0.23651046f, -0.22944032f, 
    -0.01216228f, 0.06163977f, 0.13036878f, -0.17049885f, 0.00793075f, -0.03802476f, 0.02728467f, 0.03742540f, 
    0.36264971f, 0.01180097f, 0.19351178f, 0.15801010f, 0.18368687f, 0.02041427f, 0.05246254f, -0.01129332f, 
    0.11050177f, 0.01448112f, -0.06178654f, -0.10567351f, -0.25296304f, 0.03576962f, -0.07957192f, -0.07159704f, 
    0.15272291f, -0.06832674f, -0.02551298f, 0.08113681f, -0.11214871f, 0.15167350f, -0.07586484f, 0.02345851f, 
    -0.18890531f, -0.02112413f, 0.12661518f, 0.12751381f, 0.03472778f, -0.07641889f, -0.04149700f, 0.07130610f, 
    -0.08630450f, 0.13772172f, -0.03232872f, -0.06348070f, -0.21175493f, 0.13995326f, 0.06507522f, -0.44591659f, 
    0.08022038f, 0.10825571f, 0.02243254f, -0.05650655f, 0.02537179f, -0.00612254f, -0.02481466f, 0.03691490f, 
    -0.05419048f, -0.17209078f, 0.44711247f, -0.17322487f, 0.03370599f, 0.10129457f, -0.06286964f, -0.04901446f, 
    -0.08677737f, 0.03852540f, -0.08460041f, -0.02125504f, -0.25462249f, -0.17962548f, 0.06625715f, -0.16095832f, 
    0.11564975f, 0.02813456f, 0.04686157f, 0.02050372f, 0.13849618f, 0.05144833f, 0.07377248f, -0.09311727f, 
    -0.00354832f, 0.00413146f, 0.00174979f, -0.03769846f, -0.03089655f, -0.01179035f, -0.05149520f, -0.02890209f, 
    0.02114720f, 0.03513433f, -0.00811975f, -0.05536175f, -0.05258783f, 0.01952371f, -0.05410726f, -0.00762340f, 
    -0.01031330f, -0.04138661f, 0.02465869f, -0.02088014f, -0.05265267f, 0.00397046f, 0.00344253f, 0.00277862f, 
    -0.04071862f, -0.00342648f, -0.04954073f, -0.03355049f, 0.03170145f, 0.04144593f, 0.01020269f, -0.02729611f, 
    -0.04885684f, 0.03943363f, 0.01617296f, 0.02938340f, -0.04908071f, -0.04648925f, -0.03517295f, -0.00364618f, 
    -0.01719927f, -0.04734565f, -0.04989573f, -0.05739905f, 0.01253697f, 0.04257741f, -0.02763599f, -0.03787381f, 
    -0.03787592f, -0.00285882f, -0.04071130f, -0.02982660f, -0.00559248f, -0.05313767f, 0.00164089f, -0.04581685f, 
    -0.03258771f, 0.01783370f, -0.02869135f, 0.02330626f, -0.01884567f, -0.03276699f, -0.03845113f, -0.03116859f, 
    0.02806107f, 0.01065669f, 0.03378174f, 0.01737778f, -0.01798666f, -0.00622299f, 0.00453786f, -0.02343711f, 
    -0.00376628f, -0.02099479f, 0.01661404f, -0.01252695f, -0.02714322f, -0.02976710f, -0.04251248f, -0.05745310f, 
    -0.02252471f, -0.01432600f, 0.00756595f, 0.00519464f, 0.01154734f, 0.03574239f, -0.01226813f, 0.01511805f, 
    0.02431637f, -0.03228508f, 0.00257196f, -0.03326374f, 0.01179266f, -0.02857529f, 0.02343399f, 0.02222499f, 
    0.03007136f, -0.03443521f, 0.03787876f, -0.05312057f, 0.02654186f, -0.05789040f, 0.02019234f, -0.02017627f, 
    0.03015821f, 0.03828384f, -0.04219785f, 0.00855002f, -0.03248208f, 0.02038797f, -0.04966408f, -0.03071512f, 
    -0.00388657f, -0.02375120f, 0.02387499f, -0.02431098f, -0.03800798f, -0.04829792f, 0.00389622f, 0.01828052f, 
    -0.00230507f, 0.03476347f, -0.02895298f, -0.05463391f, -0.03649956f, 0.00648230f, -0.02900394f, 0.03305514f, 
    -0.00371477f, -0.04409681f, -0.04260392f, -0.02142802f, -0.04787999f, -0.05171662f, 0.01746464f, 0.01363006f, 
    0.02427384f, 0.02017599f, 0.03264286f, -0.05308513f, 0.00862034f, -0.05713299f, -0.01160066f, 0.03066148f, 
    0.01403231f, -0.05771118f, -0.04817828f, 0.01161893f, -0.02888926f, 0.00582869f, 0.02537402f, 0.01648840f, 
    -0.02141343f, -0.03680461f, -0.04835758f, 0.03564139f, 0.02083708f, -0.02439405f, -0.04022717f, 0.03038965f, 
    -0.03235723f, -0.00441534f, 0.03677266f, 0.03949564f, 0.00780639f, -0.00523194f, -0.04260112f, 0.02311698f, 
    -0.00145793f, -0.00818872f, -0.05758735f, -0.05572305f, 0.01559119f, 0.02027108f, -0.01650310f, -0.00603151f, 
    0.01742244f, -0.05868621f, 0.02655025f, -0.04704355f, -0.03514583f, 0.03031810f, 0.02827809f, 0.02792260f, 
    -0.01909474f, -0.04120238f, -0.01454296f, -0.00041292f, 0.03387333f, -0.01528991f, -0.00708665f, 0.00908610f, 
    -0.05289235f, 0.00866758f, -0.01095983f, -0.01050392f, -0.03755910f, -0.01372273f, 0.00567295f, -0.05550667f, 
    -0.01138900f, -0.00035584f, -0.01353712f, -0.02879801f, -0.01728182f, 0.00984171f, -0.04854012f, 0.02969521f, 
    -0.00815443f, -0.03111957f, 0.03036099f, 0.02050283f, -0.04634898f, 0.02639862f, 0.01002687f, 0.03667494f, 
    -0.03081740f, -0.04912408f, 0.00633044f, -0.04535966f, 0.03654678f, -0.04210221f, -0.04712968f, 0.03963407f, 
    0.00571501f, 0.01058259f, -0.05837743f, -0.01804825f, 0.01282926f, -0.03374748f, -0.03852643f, 0.00780464f, 
    -0.01979029f, 0.03475302f, -0.00383284f, 0.02479548f, -0.00555317f, -0.01195298f, 0.01734099f, -0.02268388f, 
    -0.05476675f, -0.03180262f, 0.01499874f, 0.02593544f, 0.03965741f, -0.04428720f, -0.03006025f, -0.03908039f, 
    0.01991103f, 0.02663821f, 0.02522666f, 0.03884958f, -0.00597786f, -0.00274980f, 0.01552778f, -0.04136214f, 
    0.03564383f, -0.03091959f, -0.02138905f, -0.02802559f, -0.04452520f, -0.04401408f, 0.00077746f, -0.01309053f, 
    -0.04998294f, -0.02418150f, 0.03586091f, -0.02612931f, -0.04615763f, -0.01023109f, -0.05058407f, 0.01303269f, 
    0.03846381f, 0.02289937f, -0.00847223f, 0.00171846f, -0.02695269f, 0.03980298f, -0.02669607f, -0.04293582f, 
    -0.00669740f, 0.01747555f, -0.03662634f, 0.01424084f, -0.04091840f, -0.00151004f, 0.03619205f, 0.00686353f, 
    0.02920298f, -0.03439958f, -0.01849815f, -0.02643247f, 0.01555893f, -0.04148045f, -0.04732707f, 0.00596498f, 
    0.03934960f, -0.01020442f, 0.02316934f, 0.02418235f, -0.03199835f, 0.04005488f, -0.04639069f, 0.00024878f, 
    0.02961839f, 0.03279589f, 0.02553517f, 0.00482882f, 0.00789889f, -0.04603851f, 0.00706067f, -0.05371390f, 
    -0.03236522f, -0.02260755f, 0.01753147f, 0.00922282f, -0.02822094f, 0.01597594f, 0.01009353f, -0.03293750f, 
    0.00211957f, -0.03858719f, -0.00868320f, 0.03293010f, -0.03777212f, 0.02604759f, -0.03267575f, 0.03316658f, 
    -0.05561006f, -0.03613776f, -0.01001550f, -0.02356097f, -0.01241609f, 0.02938718f, 0.04072667f, 0.00520585f, 
    0.03254551f, -0.00642815f, -0.03580825f, 0.01693761f, 0.01152575f, 0.04146108f, -0.02855467f, -0.02686500f, 
    -0.02284163f, 0.01779199f, -0.00794261f, 0.03462889f, -0.03385325f, -0.00232967f, 0.02174106f, -0.02159323f, 
    -0.05171717f, -0.01653815f, -0.04291201f, 0.02135501f, -0.05518338f, -0.00970663f, 0.01251212f, -0.05536775f, 
    -0.00015937f, -0.03107748f, -0.05733234f, -0.02212729f, 0.01120454f, -0.05519114f, 0.00716747f, 0.01287136f, 
    -0.01025904f, -0.02749196f, -0.05816543f, 0.01106499f, 0.01014211f, -0.05889999f, -0.02628797f, 0.00064430f, 
    0.03401271f, 0.00343121f, 0.01059934f, -0.05114616f, 0.03911296f, 0.03020017f, -0.01119724f, -0.03055095f, 
    -0.18600705f, 0.23389697f, 0.05009815f, 0.21778768f, -0.12237595f, 0.08262918f, -0.05201942f, -0.01579341f, 
    0.21313372f, 0.05337838f, -0.20224077f, -0.04457185f, 0.23714907f, -0.15749359f, 0.14354306f, 0.28498465f, 
    0.04052591f, 0.05506839f, 0.09784774f, -0.01165306f, -0.05452221f, 0.04549148f, -0.00510279f, 0.07833773f, 
    0.15134457f, -0.25509819f, -0.08899633f, 0.50355273f, 0.04791665f, -0.01783315f, -0.02302602f, -0.02019213f, 
    0.19194683f, 0.11501551f, 0.03676788f, 0.12370922f, 0.41766712f, -0.11896292f, -0.04134027f, -0.11666241f, 
    -0.08338337f, -0.09600391f, 0.09258695f, 0.11239021f, 0.01182705f, 0.05448261f, 0.00425628f, 0.02854239f, 
    -0.16488850f, -0.18883471f, -0.04420877f, -0.22411320f, 0.04215006f, 0.07434895f, 0.04809422f, -0.02212969f, 
    0.05024522f, 0.03280919f, -0.01183360f, -0.00893976f, 0.60991633f, -0.09649514f, 0.06222071f, 0.07194895f, 
    -0.00259695f, -0.11809323f, 0.00341037f, 0.08574709f, -0.11480058f, 0.08375182f, 0.05996754f, 0.11593322f, 
    0.25867084f, 0.14444080f, 0.17346813f, 0.07197673f, 0.04214625f, -0.06862102f, 0.04920696f, 0.09462150f, 
    0.07683697f, -0.02405992f, 0.08086729f, 0.00502026f, 0.73736238f, -0.26747510f, -0.09793106f, -0.10493120f, 
    -0.10525163f, -0.07538218f, -0.01385270f, -0.07422565f, 0.04599915f, 0.00034957f, -0.06739996f, -0.13652633f, 
    -0.10441296f, 0.11963211f, 0.07978656f, 0.18359162f, -0.08224427f, -0.10096421f, -0.06033161f, 0.11657048f, 
    0.08749556f, 0.07781983f, -0.09531603f, -0.12118290f, -0.10678326f, 0.05751627f, 0.16898203f, -0.14643271f, 
    -0.01285244f, -0.02785027f, 0.20809773f, 0.06463611f, 0.08783507f, 0.02720953f, 0.11572518f, 0.03409670f, 
    -0.18364647f, 0.19624816f, 0.09309652f, 0.20158421f, -0.01659758f, 0.09576545f, 0.06500645f, -0.14961676f, 
    0.13600002f, 0.08793906f, 0.29846713f, 0.16431125f, -0.27380455f, 0.10052130f, -0.16798213f, -0.11067097f, 
    0.02388957f, -0.03315220f, -0.04936715f, 0.20134728f, 0.02751189f, 0.21649075f, 0.01145420f, -0.08066935f, 
    0.01940959f, 0.31745350f, 0.33097416f, 0.03654560f, 0.10426145f, -0.13828047f, 0.01591582f, 0.13495149f, 
    -0.22867285f, 0.22448531f, -0.09208146f, -0.20626922f, -0.35943443f, -0.10992787f, -0.00445000f, 0.24869186f, 
    0.04479782f, 0.12401403f, 0.07070491f, -0.03115909f, 0.10563892f, 0.11388940f, -0.06534994f, -0.06001573f, 
    0.12544060f, 0.39870158f, 0.02015482f, -0.24400938f, 0.18513830f, -0.00699970f, -0.03804230f, 0.17419441f, 
    0.01337809f, -0.01919975f, 0.00526349f, -0.03129116f, 0.35299265f, -0.22620839f, 0.07032949f, -0.07044639f, 
    -0.19340581f, -0.16112089f, -0.05558053f, -0.06864071f, -0.03727521f, -0.01317639f, -0.05019700f, 0.06634757f, 
    -0.29496479f, -0.02633499f, -0.22417870f, 0.49807033f, 0.13021651f, 0.11612054f, 0.08003082f, 0.03063115f, 
    -0.09935296f, -0.01816487f, -0.01278660f, 0.03182736f, 0.18256240f, 0.18034148f, -0.12015583f, 0.14566739f, 
    0.12001031f, -0.07706723f, -0.06652186f, 0.16810586f, 0.00945891f, -0.01742871f, 0.09168956f, 0.00388077f, 
    -0.12393720f, 0.07070549f, -0.00377286f, -0.42102787f, 0.12984434f, -0.10104607f, 0.10757319f, 0.10014648f, 
    -0.07368764f, -0.02676153f, -0.07345627f, -0.10195644f, 0.09758248f, 0.52110946f, -0.09611572f, -0.07482419f, 
    0.01793152f, 0.01421248f, 0.02743806f, -0.07175595f, -0.04462415f, -0.00501478f, 0.02775227f, -0.02416686f, 
    0.01093432f, 0.06535593f, 0.13658968f, -0.10962012f, 0.19600204f, -0.04739218f, 0.03635617f, -0.10562642f, 
    0.14201759f, 0.09828976f, 0.12980083f, 0.04577024f, -0.15387446f, -0.05276852f, 0.26219973f, 0.38960019f, 
    0.05499559f, 0.07650178f, -0.03481669f, 0.13298640f, 0.03905335f, -0.08493059f, 0.18096077f, 0.10895753f, 
    0.02009668f, 0.00856893f, 0.06472205f, 0.04437954f, 0.02100245f, -0.11759491f, -0.06983086f, 0.04243183f, 
    -0.11146471f, -0.10446397f, 0.18305618f, -0.02606781f, -0.08635443f, -0.21650353f, -0.21306585f, -0.05340265f, 
    -0.00994967f, -0.00241428f, 0.05493820f, -0.15287915f, 0.06275722f, 0.18825120f, -0.02571142f, -0.02103748f, 
    -0.14622608f, -0.11404144f, 0.11499257f, 0.34796381f, 0.10097043f, -0.00526349f, 0.07054310f, -0.07654621f, 
    0.28927153f, 0.02983247f, 0.02176498f, 0.11922820f, 0.50400764f, -0.13251038f, 0.02430981f, 0.05720651f, 
    0.01657613f, -0.05452820f, 0.08172873f, 0.05299554f, -0.05635889f, -0.03567241f, 0.00773776f, 0.02593068f, 
    0.00427207f, 0.04173380f, 0.16594076f, -0.16537270f, 0.02312782f, 0.03560012f, -0.21138684f, -0.04547146f, 
    -0.13565668f, 0.16757162f, 0.07053705f, 0.10064880f, 0.22168434f, -0.10509039f, 0.04751272f, 0.47362971f, 
    0.12377751f, 0.22307259f, 0.13433984f, -0.12897061f, -0.08745731f, -0.08693260f, -0.01743037f, 0.07506087f, 
    0.28314415f, -0.21784520f, 0.09679957f, -0.25955600f, -0.20008761f, -0.15446964f, 0.23417704f, -0.03087821f, 
    0.00031580f, -0.07662864f, 0.09871841f, 0.06826182f, 0.04708711f, -0.01201026f, 0.04333309f, 0.37762541f, 
    -0.02896717f, 0.08580219f, 0.16332018f, 0.02460012f, -0.00815117f, 0.06349739f, 0.03797707f, 0.07225085f, 
    -0.13148886f, -0.12728916f, -0.33255213f, 0.10435031f, 0.00990482f, 0.07837918f, 0.19972952f, -0.00606205f, 
    -0.05277260f, 0.07691390f, 0.14273566f, 0.02884392f, -0.26617557f, -0.04695208f, 0.11477233f, -0.09922206f, 
    0.02766048f, 0.08513115f, -0.05727048f, -0.00537879f, 0.04907060f, -0.21204980f, -0.04308942f, -0.03138326f, 
    0.28719917f, 0.07643314f, -0.09615710f, -0.00822401f, -0.01122854f, -0.01502436f, 0.02189138f, -0.16994281f, 
    -0.02264856f, -0.09377175f, 0.11722033f, 0.04140923f, -0.26342925f, 0.10078538f, -0.16911329f, -0.09914696f, 
    0.15397143f, -0.00995176f, 0.04408383f, 0.00675919f, -0.02214526f, -0.12595253f, -0.01134427f, 0.00442600f, 
    -0.34958532f, 0.13983008f, -0.06819654f, -0.19475318f, 0.09414590f, -0.03258921f, 0.02238525f, -0.05508818f, 
    -0.11874769f, 0.04906575f, 0.01413234f, -0.16695498f, -0.20406273f, 0.27292585f, -0.00754346f, 0.04115085f, 
    0.12946931f, 0.02775874f, 0.14122398f, -0.08753654f, -0.01802880f, -0.05541789f, 0.13539043f, -0.11458787f, 
    -0.10146379f, 0.41715792f, -0.15484068f, 0.29994267f, -0.19358350f, -0.01180890f, -0.10894110f, 0.03955230f, 
    0.04077043f, -0.03394056f, -0.03501476f, -0.00253416f, -0.11408911f, -0.07399508f, 0.08399525f, -0.02104476f, 
    -0.05446189f, -0.04068284f, -0.01420141f, -0.12483121f, 0.03839394f, 0.12600404f, -0.11750708f, 0.01287457f, 
    0.05678638f, 0.19031042f, 0.04032288f, -0.03008165f, 0.18650702f, 0.02270471f, -0.00598792f, -0.10115095f, 
    0.01655494f, 0.03603806f, -0.02440083f, -0.07280266f, -0.37142804f, 0.29698798f, 0.12607838f, 0.03339200f, 
    0.06038836f, -0.08975192f, 0.05849251f, 0.04402814f, -0.09366727f, -0.03011063f, 0.14125945f, -0.05372895f, 
    0.52685905f, 0.13596562f, 0.17682463f, 0.06897130f, 0.02981814f, -0.04368883f, 0.11023074f, -0.02020662f, 
    -0.02074465f, -0.05103968f, 0.00491602f, -0.02916368f, -0.05297111f, 0.40512389f, -0.12314532f, -0.20352137f, 
    0.06251670f, -0.04345205f, -0.12112174f, -0.05253969f, -0.03959594f, 0.02269391f, 0.05852504f, 0.03551116f, 
    0.08803142f, 0.01721757f, -0.06863928f, -0.11909658f, -0.01365230f, -0.07797214f, -0.18017898f, 0.12132018f, 
    0.10227222f, 0.18228233f, 0.03475197f, -0.00008922f, 0.17065486f, -0.09878395f, 0.01851752f, 0.07245543f, 
    0.03491489f, 0.01769537f, -0.03256663f, -0.13222258f, 0.04686526f, -0.05834642f, -0.13056603f, 0.04642161f, 
    -0.10118359f, -0.08053910f, -0.26358378f, 0.03158173f, -0.08976352f, 0.06402998f, -0.08968589f, -0.07225500f, 
    0.16307765f, 0.00363738f, 0.25013387f, -0.00224260f, 0.13243693f, 0.08272511f, 0.01283677f, 0.02761817f, 
    -0.00985034f, 0.00170965f, -0.08903863f, 0.00058002f, -0.12999132f, -0.00707912f, -0.04520207f, -0.02703286f, 
    0.04235471f, 0.30061787f, 0.18095806f, -0.04264091f, 0.00160443f, -0.12455060f, -0.07551016f, -0.11059949f, 
    0.04550549f, -0.12346535f, 0.15619984f, 0.04654377f, -0.20985916f, 0.47731334f, 0.09457113f, 0.03431272f, 
    0.02997186f, 0.06785886f, -0.04817814f, 0.06041398f, 0.04705604f, -0.00573345f, 0.20479308f, 0.05579466f, 
    0.00329033f, -0.04741763f, 0.10581001f, -0.03574549f, -0.14694186f, -0.05540205f, 0.04863199f, 0.10105662f, 
    0.07458278f, 0.07794608f, 0.10508553f, 0.05314929f, -0.27945650f, -0.02594546f, 0.47436738f, 0.16508240f, 
    -0.18543531f, -0.05450400f, -0.01391126f, -0.01071336f, 0.09054102f, 0.01781758f, -0.01158764f, -0.04372187f, 
    0.21271415f, 0.18116656f, 0.03234581f, 0.10151377f, 0.09101974f, -0.01891358f, 0.00387308f, 0.02422389f, 
    0.09895755f, -0.18100439f, 0.11427211f, 0.07663621f, 0.38960612f, -0.56642187f, 0.05069790f, 0.22854184f, 
    0.04659524f, -0.05723264f, -0.07611065f, 0.01636808f, -0.03571106f, 0.06250241f, 0.02533115f, 0.00701726f, 
    0.00171335f, -0.11848419f, -0.15247177f, 0.05716399f, -0.09681281f, 0.06729979f, 0.01287949f, 0.02048974f, 
    0.03327361f, -0.07435013f, -0.15962575f, 0.02346361f, -0.17887987f, 0.11562256f, 0.08661446f, 0.12072851f, 
    0.11301786f, 0.05215016f, 0.03859557f, -0.07801976f, -0.11600167f, 0.09308628f, 0.09608205f, -0.03880526f, 
    -0.03951734f, 0.12921901f, 0.17699809f, 0.08134341f, -0.03764379f, 0.04491790f, 0.09389234f, 0.16884787f, 
    0.05384777f, 0.08072083f, -0.06894678f, 0.01596575f, -0.27240837f, 0.04053348f, 0.10188741f, -0.19767912f, 
    0.15211518f, 0.08359693f, 0.07324334f, -0.02420059f, -0.11151931f, 0.02758252f, 0.11056263f, -0.13885875f, 
    0.03859248f, 0.18098551f, -0.12857527f, -0.24499957f, 0.18760702f, 0.20743228f, 0.03286888f, 0.05665486f, 
    -0.14064300f, 0.00477770f, 0.07686806f, -0.11658077f, -0.09480000f, 0.21016034f, 0.00874181f, -0.01394665f, 
    0.11520475f, 0.00272112f, -0.04719624f, -0.00615363f, 0.06201145f, 0.18221815f, -0.04903316f, -0.11498269f, 
    0.30513811f, 0.13441578f, 0.10409433f, 0.06683494f, 0.03510001f, 0.05757656f, 0.30431291f, 0.00156319f, 
    0.18945065f, -0.08186926f, 0.03171317f, 0.10436654f, -0.26522717f, -0.05294762f, -0.05850562f, -0.01870979f, 
    -0.01247777f, 0.02013249f, -0.08031502f, -0.01910010f, -0.18099760f, 0.18226996f, 0.16779831f, 0.02881589f, 
    -0.40258628f, 0.28598735f, 0.11276045f, 0.11640532f, 0.04835255f, 0.11721487f, -0.08516132f, 0.08739835f, 
    0.08543713f, 0.03581793f, 0.01503650f, 0.08967780f, -0.24320422f, 0.06837185f, -0.02112250f, -0.00939594f, 
    0.22952385f, 0.11040869f, -0.15619496f, 0.04914235f, -0.07529086f, 0.00429660f, -0.17997317f, -0.08666071f, 
    -0.18357746f, -0.08513352f, 0.26952472f, -0.11283782f, 0.07192978f, 0.13978627f, -0.13767645f, 0.11810140f, 
    -0.04503791f, -0.02864022f, 0.00751954f, 0.12038624f, 0.06121410f, -0.04726421f, -0.07172169f, 0.00957571f, 
    0.04222918f, 0.08878307f, 0.16738607f, 0.04802787f, -0.05080018f, 0.20555359f, 0.05882013f, 0.00256981f, 
    -0.02911420f, -0.03519399f, -0.02248971f, 0.00865844f, -0.02754772f, 0.01564552f, -0.03454563f, 0.04032459f, 
    -0.05315177f, 0.02653159f, 0.00286014f, -0.05092888f, 0.03550107f, -0.05446867f, -0.04837997f, 0.03535963f, 
    -0.05546973f, -0.02503718f, 0.04119381f, 0.01719561f, -0.02685135f, 0.02227338f, 0.03479611f, 0.03943415f, 
    -0.04286251f, -0.04207399f, -0.05148960f, 0.00029325f, -0.01405096f, -0.01279258f, -0.02249439f, 0.03552212f, 
    0.01869790f, -0.01913693f, 0.00601921f, 0.05416197f, -0.01939954f, -0.03930397f, -0.01599558f, -0.05318705f, 
    -0.04166295f, -0.01524141f, -0.04492696f, -0.03930998f, 0.02312944f, 0.03404096f, 0.01763242f, -0.00599053f, 
    -0.02225004f, -0.05363395f, 0.03798749f, -0.04832127f, -0.01410800f, -0.02390105f, 0.01153139f, -0.03086082f, 
    -0.01393643f, 0.03207508f, -0.02775954f, -0.01391198f, 0.03788385f, -0.04187809f, -0.02029196f, 0.02744167f, 
    -0.01387222f, -0.00513308f, 0.00933680f, -0.01616642f, 0.01661591f, -0.01882189f, -0.04729274f, 0.02599714f, 
    0.03282650f, 0.04317307f, -0.05579953f, -0.04810553f, 0.03492874f, 0.02547239f, -0.04879724f, -0.01376246f, 
    -0.04712623f, 0.04118801f, -0.03127459f, 0.03671514f, -0.04711704f, 0.03424542f, 0.02851226f, -0.05793351f, 
    -0.00080115f, -0.03134482f, 0.00927779f, 0.01840539f, -0.02514641f, -0.03329334f, -0.02513576f, -0.00220761f, 
    -0.04353251f, -0.02332752f, -0.03229960f, 0.00543298f, -0.04247705f, 0.00885625f, 0.00885728f, 0.02194184f, 
    0.00015871f, -0.04007740f, 0.03332178f, -0.03731433f, -0.05104539f, 0.01734998f, -0.05265626f, -0.04473493f, 
    -0.05085323f, 0.01655538f, -0.00967182f, -0.00880546f, 0.00026531f, -0.01563004f, 0.01084397f, 0.00182248f, 
    -0.02407642f, -0.02572050f, 0.04458843f, -0.01216236f, -0.04402390f, -0.01284333f, 0.03176119f, 0.03924946f, 
    -0.05413597f, -0.04450535f, -0.00654163f, 0.02536184f, 0.01307430f, -0.01297662f, -0.01596016f, 0.04221127f, 
    -0.01092372f, 0.02946156f, 0.03273662f, -0.04654924f, 0.01972322f, -0.01233347f, -0.02958968f, 0.03067645f, 
    -0.01199235f, 0.01482465f, -0.02805935f, 0.02617367f, 0.00912594f, -0.05675086f, 0.04288554f, -0.02468432f, 
    -0.04328643f, 0.03602533f, 0.01582678f, -0.03262359f, 0.03400772f, 0.01730212f, -0.04744705f, -0.02923189f, 
    -0.03252733f, -0.04985887f, -0.05586915f, -0.00054458f, -0.05486558f, -0.03947288f, 0.02324702f, -0.00321020f, 
    0.01275189f, 0.00604527f, -0.02233294f, -0.01664860f, -0.04423653f, 0.02261322f, -0.03016494f, -0.03367505f, 
    -0.05084706f, 0.00997958f, 0.03151258f, 0.01076668f, -0.01696198f, -0.05654107f, -0.04690849f, 0.03845057f, 
    0.02082578f, 0.03818615f, 0.00527105f, 0.03025694f, -0.04602167f, -0.04952382f, -0.03454791f, 0.00365943f, 
    -0.04206509f, 0.01809402f, -0.02566724f, 0.03526962f, 0.02270084f, -0.01380706f, -0.03230028f, -0.05258472f, 
    -0.04039335f, -0.01945607f, -0.02252162f, 0.03114156f, 0.00744669f, -0.00289802f, 0.01194142f, -0.02436551f, 
    0.01381715f, 0.04648666f, -0.05140475f, -0.04223055f, -0.03343710f, 0.01404380f, -0.01941231f, -0.01592252f, 
    -0.00851177f, -0.00128883f, 0.00149705f, -0.03731984f, 0.00312737f, -0.05642251f, 0.00950008f, -0.04562239f, 
    -0.04465689f, 0.00630498f, 0.01417005f, -0.00196056f, -0.00525240f, 0.02177959f, 0.04023644f, -0.02265649f, 
    0.03485859f, -0.01214510f, 0.01317120f, 0.04871242f, 0.04040607f, -0.02744449f, -0.05761597f, -0.04421383f, 
    0.01070899f, -0.05404248f, -0.02692932f, -0.01508189f, -0.05129854f, -0.04830847f, 0.00919145f, -0.05441980f, 
    -0.04167864f, 0.00851829f, 0.00278549f, -0.03170980f, 0.03284163f, 0.02676628f, -0.00586873f, -0.05531017f, 
    -0.02064080f, 0.01188772f, -0.00700367f, -0.03277436f, -0.00161711f, -0.04657839f, -0.00107754f, 0.00692695f, 
    -0.05173869f, 0.02195011f, -0.00437396f, -0.02605995f, -0.00308276f, 0.01068644f, -0.03712493f, -0.05174316f, 
    -0.02265363f, -0.03338757f, 0.01249224f, 0.03576351f, 0.01665787f, -0.02549230f, 0.03926561f, 0.01268963f, 
    -0.01383332f, -0.04202680f, -0.02497130f, -0.05478921f, 0.02312026f, -0.00620712f, 0.02204391f, -0.04800809f, 
    -0.05189827f, 0.03758624f, -0.05302646f, 0.02892818f, 0.01044209f, -0.00064536f, -0.02391267f, 0.00418772f, 
    -0.04798514f, 0.03016742f, 0.03652958f, 0.03559157f, 0.02774852f, -0.00590950f, 0.01930803f, 0.01127008f, 
    0.03479912f, 0.03791429f, 0.01299355f, -0.04357092f, -0.02255443f, -0.05326423f, 0.00844522f, 0.02297234f, 
    -0.03890166f, 0.01050648f, 0.00401166f, 0.03133131f, 0.01869231f, -0.04484340f, 0.00210866f, 0.00550929f, 
    -0.04515836f, -0.02943326f, -0.02878930f, 0.01670709f, 0.00335710f, -0.03443576f, 0.02132335f, 0.03566794f, 
    -0.05018818f, 0.04419651f, -0.03509819f, -0.02338284f, -0.01439927f, -0.05766460f, 0.01511222f, 0.00135079f, 
    0.00948614f, 0.03602291f, -0.03396837f, -0.03072756f, -0.02758599f, -0.02263294f, 0.01348618f, 0.02238447f, 
    0.00868957f, -0.05218341f, -0.05931937f, 0.01038038f, 0.02664460f, -0.04687817f, -0.03458919f, -0.04869409f, 
    -0.04473648f, -0.03366913f, 0.03352348f, 0.00119514f, -0.05739006f, -0.03783301f, -0.00865183f, -0.00437456f, 
    -0.00585277f, 0.00605775f, -0.03182089f, 0.01780248f, 0.00151937f, 0.02572831f, 0.03724701f, -0.00079143f, 
    -0.00194656f, -0.00010919f, -0.02442908f, 0.02415630f, 0.02249889f, -0.04251802f, 0.01435848f, 0.00565072f, 
    0.02754198f, -0.05726695f, 0.03480680f, -0.04690095f, 0.02387498f, 0.00987452f, 0.02609104f, -0.03402381f, 
    0.00165891f, -0.00806675f, 0.02646649f, -0.06072231f, -0.05230163f, -0.03629585f, -0.00818273f, 0.01004836f, 
    -0.06505413f, 0.00259683f, 0.00707327f, -0.02162260f, 0.04801223f, -0.04831521f, -0.01719406f, 0.04990705f, 
    0.02732838f, -0.05208176f, -0.02639581f, -0.00398047f, -0.00414087f, -0.06821895f, -0.02313627f, -0.00362638f, 
    0.01628024f, 0.02694623f, -0.03015401f, 0.03625606f, -0.04460719f, -0.02006258f, 0.02895342f, 0.03349682f, 
    -0.00374942f, 0.02950668f, -0.06786332f, 0.01271033f, 0.02521783f, -0.08471113f, -0.06913162f, -0.01971506f, 
    0.02244586f, -0.07744360f, -0.00211873f, -0.02207815f, -0.06435908f, 0.04646053f, -0.00262375f, 0.00044919f, 
    0.01288363f, 0.01610640f, 0.02646269f, 0.03604281f, -0.04098547f, 0.02188548f, -0.05842728f, -0.02083100f, 
    -0.02761743f, 0.05412254f, -0.02268631f, 0.04246212f, -0.00652596f, 0.02100217f, -0.04792207f, 0.02944222f, 
    0.01046330f, -0.00711937f, 0.01790586f, 0.04573332f, 0.02385483f, 0.00068676f, 0.01065933f, 0.05361531f, 
    -0.01533252f, -0.00883763f, 0.01377419f, 0.01314055f, -0.04944697f, -0.05537931f, 0.01449554f, 0.01418431f, 
    -0.07598605f, -0.06122110f, -0.03017909f, 0.05159598f, -0.01621540f, 0.02800132f, 0.01323392f, 0.02272678f, 
    0.02664897f, -0.00292493f, -0.05425688f, 0.00243343f, 0.00350441f, -0.04461619f, -0.06188175f, -0.03726357f, 
    -0.08230591f, -0.07941101f, -0.06562179f, -0.02259617f, -0.04349293f, -0.00987084f, 0.05734010f, -0.04485293f, 
    0.00127288f, -0.03292815f, -0.04282677f, 0.03388814f, -0.02631527f, -0.01149053f, -0.02052535f, 0.06546631f, 
    -0.03630854f, -0.08475348f, 0.02656621f, 0.02038589f, 0.01985686f, -0.04614951f, 0.00829703f, 0.00310543f, 
    -0.07957187f, -0.06539913f, -0.00423819f, -0.05718872f, -0.06129274f, -0.04240178f, -0.03134245f, 0.05129316f, 
    0.01961125f, 0.02327088f, 0.02179724f, 0.03298935f, -0.01776293f, -0.00454620f, -0.02228551f, -0.07518169f, 
    -0.05596165f, -0.01294233f, -0.02277193f, 0.00485352f, 0.00585085f, 0.01122363f, 0.00925897f, -0.03580939f, 
    0.02880087f, -0.01899672f, -0.01545440f, -0.01841500f, -0.02204053f, -0.02726904f, -0.00911172f, -0.01307077f, 
    0.02243650f, 0.02120571f, 0.01458647f, -0.02085035f, -0.00392124f, -0.03445997f, -0.01772055f, -0.00613164f, 
    0.02787801f, 0.00341513f, -0.02744465f, 0.02322211f, -0.04445976f, -0.05363580f, -0.00018276f, -0.05058181f, 
    -0.05716904f, -0.03690431f, -0.02042872f, -0.04475906f, 0.02778608f, 0.00249714f, -0.00196165f, -0.04943727f, 
    -0.02647962f, -0.01967576f, 0.02303233f, -0.04324361f, -0.04052630f, -0.06691790f, -0.02276587f, -0.02701823f, 
    0.02012386f, -0.00113042f, -0.02215298f, 0.00146007f, -0.04728640f, -0.00757123f, 0.04582082f, -0.04286427f, 
    -0.04450995f, 0.03690400f, -0.03572104f, -0.04250852f, -0.04748526f, 0.00882918f, -0.04598724f, -0.01387928f, 
    -0.02158975f, 0.00270471f, 0.03151314f, -0.07131251f, 0.01016463f, -0.02710552f, -0.00816135f, -0.06190005f, 
    0.01411570f, 0.02210928f, -0.04063354f, -0.04523637f, -0.00411423f, -0.04358530f, 0.03054699f, -0.04281847f, 
    -0.01317968f, 0.02697964f, -0.00202425f, 0.00087272f, 0.02096045f, 0.01870104f, -0.03441231f, -0.03112152f, 
    0.03491348f, -0.00998925f, -0.03622741f, 0.04654625f, -0.01785331f, -0.04550451f, -0.01556271f, 0.01856186f, 
    -0.04390506f, -0.01861819f, -0.03300305f, -0.03381767f, 0.03469961f, 0.02875060f, 0.02512737f, -0.02426334f, 
    -0.01866635f, -0.05240912f, -0.01710111f, 0.02232365f, 0.02289986f, -0.02112702f, -0.03353633f, -0.03097455f, 
    0.03196242f, 0.03862751f, -0.04753226f, -0.06739929f, -0.01435525f, -0.01894543f, -0.01100892f, -0.03160609f, 
    0.01029369f, -0.00795470f, -0.02125775f, -0.06784569f, 0.06352007f, 0.01670972f, -0.04561768f, 0.01608235f, 
    -0.04866781f, -0.04951697f, -0.05386302f, 0.03548731f, -0.00596711f, -0.01986882f, -0.04942766f, -0.04507358f, 
    -0.04484292f, 0.01159580f, 0.02397557f, -0.00872482f, 0.00495541f, -0.01781709f, 0.00431729f, 0.03530663f, 
    -0.01930662f, 0.05054786f, -0.02071585f, 0.02354950f, -0.02662486f, 0.03545013f, -0.00346634f, 0.00013522f, 
    0.00038314f, -0.02927321f, -0.04938017f, 0.01511511f, 0.02125231f, -0.04742888f, -0.02175800f, -0.01384764f, 
    -0.02861611f, -0.01981610f, 0.03408522f, 0.01273014f, -0.04961674f, -0.05179043f, -0.02804968f, -0.04664985f, 
    -0.03483834f, -0.03332072f, 0.00925896f, 0.01267134f, -0.05932578f, 0.00019994f, 0.03114562f, -0.02703370f, 
    -0.01145126f, -0.01030387f, -0.04057994f, -0.02168562f, 0.00858737f, -0.03288148f, 0.00476834f, 0.01834706f, 
    0.01904334f, 0.01209152f, -0.03162403f, 0.00170454f, 0.03983195f, -0.05598479f, -0.00962413f, 0.02507903f, 
    -0.00313344f, -0.03879180f, -0.02203668f, -0.01436345f, -0.04569428f, -0.01807668f, 0.02062114f, 0.01524050f, 
    0.02999611f, 0.02613024f, -0.02972375f, 0.01740869f, -0.03499573f, -0.01358123f, 0.04749137f, 0.01537244f, 
    0.01227127f, 0.05991807f, -0.02641146f, 0.02657599f, -0.00292087f, 0.02341127f, 0.02495918f, -0.01631641f, 
    -0.00684035f, -0.01120321f, 0.00201013f, 0.02232594f, -0.00800665f, -0.05549555f, -0.03056066f, -0.05593169f, 
    0.00362384f, 0.01721818f, -0.02871325f, -0.02322106f, 0.02606739f, -0.02461334f, 0.01595418f, 0.06556617f, 
    -0.04174062f, 0.00607495f, 0.06113918f, -0.00789633f, 0.00259908f, -0.01088845f, -0.07102022f, -0.03954882f, 
    0.01947639f, -0.04510729f, -0.05475860f, -0.00591481f, -0.05507815f, -0.01595367f, -0.04809934f, 0.05233492f, 
    0.02897008f, 0.01255460f, 0.00066519f, 0.03929604f, 0.00227079f, -0.04299775f, -0.00585926f, -0.01784853f, 
    0.01630471f, 0.04079035f, -0.01444130f, -0.05933976f, 0.02928038f, -0.02465716f, 0.01433190f, 0.04829646f, 
    0.01243388f, 0.00618520f, -0.01585575f, -0.03655625f, -0.04407470f, 0.00194818f, 0.00562771f, -0.00010838f, 
    0.02087764f, 0.03327077f, 0.02279416f, 0.01850755f, -0.01126472f, 0.04313287f, -0.00607881f, -0.01846759f, 
    0.02519209f, 0.00322090f, 0.04487129f, 0.03961549f, -0.03570100f, 0.02749485f, -0.00851042f, -0.04444602f, 
    0.02003896f, 0.01693843f, -0.04194163f, 0.03052631f, 0.04203947f, -0.04415267f, 0.04034215f, -0.00185974f, 
    -0.05770202f, 0.02806622f, -0.03643862f, -0.01745823f, -0.03491517f, -0.05569249f, 0.03535656f, -0.02837178f, 
    -0.01908850f, -0.03669535f, -0.03674513f, -0.02379304f, -0.04516360f, 0.04172599f, 0.02169372f, 0.01783467f, 
    0.00858104f, -0.05199260f, -0.00977296f, -0.01657846f, -0.03048558f, -0.03390465f, 0.01562183f, -0.05256425f, 
    -0.01470107f, -0.02308507f, -0.01574502f, -0.00234941f, 0.03412811f, -0.05892076f, -0.04983296f, -0.03331354f, 
    -0.03497441f, -0.00654448f, -0.00084615f, 0.00961941f, 0.02618379f, 0.02709989f, 0.04512791f, -0.04784139f, 
    -0.00465551f, 0.04215120f, -0.04178518f, 0.03533628f, -0.04442802f, -0.04453164f, 0.00675729f, 0.02667753f, 
    0.01298047f, -0.03488528f, -0.03848481f, 0.04015140f, 0.01805292f, -0.02829624f, -0.03421354f, 0.00437847f, 
    -0.02255329f, 0.03801848f, 0.02041576f, 0.04387881f, -0.01647376f, -0.05875083f, 0.00925779f, 0.03941891f, 
    -0.01758876f, -0.02892365f, 0.01544196f, -0.01773908f, -0.03566937f, -0.03105763f, -0.01427210f, 0.02413779f, 
    -0.04149153f, 0.00757938f, -0.00597644f, 0.00257492f, 0.00265346f, -0.03439767f, -0.00726241f, -0.02326826f, 
    0.00970786f, -0.02772378f, 0.01428437f, 0.01248653f, 0.01595219f, -0.05698337f, 0.03266521f, -0.00038910f, 
    -0.04496513f, 0.01840020f, -0.02084188f, -0.02676723f, -0.02764165f, -0.03194926f, 0.02601416f, -0.05231684f, 
    -0.05111220f, 0.01504520f, -0.01617825f, 0.04716323f, 0.01431277f, -0.01194413f, 0.00863579f, 0.02420792f, 
    -0.00197175f, -0.02603015f, 0.00831275f, -0.04546514f, -0.00400317f, -0.00262540f, 0.03525416f, -0.03169749f, 
    0.02785291f, -0.05044506f, -0.02622214f, -0.03483987f, 0.03600593f, -0.04249437f, 0.01524160f, -0.04565318f, 
    0.02083648f, 0.02761930f, -0.03876099f, -0.00114938f, 0.01083309f, 0.00536551f, -0.04536123f, -0.03469449f, 
    -0.04313689f, 0.00794557f, -0.03270709f, -0.04283613f, 0.02906245f, 0.02295373f, -0.03672808f, -0.01976536f, 
    -0.00509440f, -0.01620551f, 0.00514040f, -0.02888254f, -0.00867161f, -0.00705938f, 0.00824131f, -0.00323117f, 
    -0.03306251f, -0.03377970f, -0.03245578f, 0.00038103f, -0.04280938f, 0.04253095f, -0.01761238f, 0.00331965f, 
    -0.02490154f, -0.00414607f, -0.04519482f, 0.02942137f, 0.03462331f, -0.03542886f, -0.00986993f, -0.05897951f, 
    0.03403215f, -0.01592605f, 0.01283434f, 0.03049448f, -0.04846552f, -0.03983953f, 0.00319563f, 0.04864455f, 
    -0.01543727f, -0.02339735f, 0.04976596f, 0.02990772f, -0.04294942f, -0.01576699f, 0.00117840f, -0.04483266f, 
    -0.02631555f, 0.01309449f, -0.05211062f, -0.00383759f, 0.03749733f, 0.03250703f, -0.02268308f, -0.04476357f, 
    -0.03137825f, -0.01876766f, -0.04974384f, -0.00735023f, -0.01012929f, -0.02429993f, 0.04808870f, -0.02794252f, 
    -0.03445042f, 0.01233097f, 0.01079609f, 0.00334342f, -0.05821953f, -0.02205289f, -0.03685755f, 0.01388757f, 
    0.00192701f, -0.00938467f, -0.04885861f, 0.04026012f, -0.03340391f, 0.03085825f, 0.04294832f, -0.02972143f, 
    0.04126444f, 0.04043289f, 0.00268077f, 0.00906435f, -0.02259341f, -0.01186267f, 0.03122641f, -0.00102614f, 
    0.03590805f, -0.00633221f, -0.05134806f, 0.01126912f, -0.05753581f, 0.01120195f, -0.04804398f, 0.00488036f, 
    -0.05127086f, 0.03058040f, 0.03364405f, -0.05281296f, -0.05455716f, 0.00979440f, -0.04201924f, 0.02724454f, 
    -0.01945199f, 0.00588702f, 0.04216623f, -0.00945421f, -0.02066254f, 0.00718240f, -0.05154811f, -0.04158591f, 
    0.03459265f, -0.01368613f, -0.01270345f, 0.04431212f, 0.03271313f, 0.03599876f, -0.05626843f, -0.04380699f, 
    -0.03615763f, -0.03017148f, -0.02871844f, -0.01278197f, -0.04276618f, -0.03020424f, -0.03854094f, 0.03265311f, 
    -0.02634902f, -0.00406396f, 0.00332685f, 0.02142560f, 0.03990440f, -0.03469394f, 0.00739639f, 0.01736065f, 
    0.02479390f, -0.02627051f, -0.01266912f, 0.01259434f, -0.05313757f, 0.02140482f, 0.00945560f, -0.02579604f, 
    0.03166371f, -0.00842912f, -0.01795865f, -0.00837510f, -0.02795633f, -0.00925095f, 0.01972380f, 0.02173289f, 
    0.01451788f, 0.00298363f, 0.00271374f, 0.00574809f, -0.04005086f, 0.00255151f, -0.00798053f, -0.00114374f, 
    -0.03285978f, 0.01435847f, 0.02738585f, 0.00903357f, 0.01983807f, 0.01302832f, -0.00015785f, -0.01764795f, 
    -0.05496570f, 0.00970575f, 0.04497110f, -0.05313936f, -0.00402079f, 0.03083637f, 0.03428523f, -0.03284266f, 
    0.01543426f, -0.04852516f, -0.00575353f, 0.03981268f, -0.03092073f, 0.03304497f, -0.02974652f, -0.03087625f, 
    0.02678349f, 0.01548906f, -0.04513394f, -0.04778860f, 0.02995540f, 0.02572028f, -0.01410331f, 0.00900465f, 
    0.03810781f, -0.02291150f, 0.01694002f, -0.04552596f, -0.04461484f, -0.05533818f, 0.01437471f, -0.02479725f, 
    0.00465834f, -0.01551517f, 0.04272408f, -0.03852597f, -0.04875504f, -0.03124651f, -0.01141432f, -0.05520739f, 
    -0.14999034f, -0.11670295f, 0.11130118f, -0.04019922f, -0.00558093f, 0.10092410f, 0.10099843f, 0.15994614f, 
    -0.02290001f, 0.06602653f, 0.12252188f, -0.05276678f, 0.14703737f, 0.05995198f, 0.02253215f, -0.10228083f, 
    -0.03755668f, 0.09402077f, -0.03007194f, 0.13523196f, -0.02067145f, 0.06449310f, 0.02004592f, -0.19487423f, 
    0.32870275f, 0.05623905f, 0.06518456f, -0.02616121f, -0.09039418f, 0.18428735f, 0.06006687f, 0.06072624f, 
    0.01108658f, -0.12134323f, -0.02690053f, 0.09933817f, -0.02262904f, -0.03134048f, 0.11804778f, 0.02224034f, 
    -0.09076267f, 0.01986846f, -0.20340550f, 0.14844894f, -0.03716066f, 0.07095455f, -0.04052700f, 0.12318695f, 
    0.46082053f, -0.06192874f, 0.29298112f, 0.01180311f, 0.08655275f, 0.07586380f, 0.16442150f, -0.01885182f, 
    -0.11279989f, 0.03681823f, 0.04698306f, -0.00170276f, -0.42191300f, 0.08845327f, -0.09730322f, 0.08458589f, 
    0.06157129f, 0.03890787f, 0.02716503f, 0.04263468f, 0.10336503f, -0.14941175f, -0.05870702f, -0.01656172f, 
    -0.29937997f, -0.27567363f, -0.12475536f, 0.08098181f, -0.12748608f, -0.00308466f, 0.08277301f, 0.13305987f, 
    0.01438018f, 0.02556368f, -0.09294967f, 0.09782792f, -0.00538783f, 0.08870256f, -0.04413390f, 0.12327636f, 
    0.04997299f, 0.19801037f, 0.03210428f, 0.08245642f, -0.06476374f, 0.12929216f, -0.02247418f, 0.09255712f, 
    -0.14816743f, -0.05439992f, -0.02746242f, -0.11203150f, 0.02304815f, 0.18787150f, -0.06911013f, 0.08975990f, 
    0.01626022f, 0.03969744f, 0.14136276f, 0.18403836f, 0.20592071f, -0.35095224f, 0.29375398f, 0.24793020f, 
    -0.02377865f, 0.04569244f, 0.19250044f, 0.10930964f, 0.12494216f, -0.01405232f, -0.19040178f, 0.05476295f, 
    0.23774993f, -0.06203382f, -0.00567223f, 0.02592636f, 0.12686327f, 0.10968387f, 0.06963675f, 0.07803966f, 
    -0.16503736f, -0.18059601f, -0.06204436f, -0.00496172f, -0.14071143f, 0.25975332f, 0.06370724f, 0.22059716f, 
    0.03128583f, 0.00038684f, 0.02924698f, -0.04796227f, -0.06670687f, 0.03094265f, -0.11613922f, 0.12130859f, 
    -0.05094294f, -0.02730234f, -0.06649745f, -0.10560042f, 0.04410383f, 0.02606913f, 0.01842971f, 0.00747889f, 
    0.10428791f, -0.16513872f, 0.00592968f, 0.08676778f, 0.37897795f, -0.13664709f, -0.29929444f, -0.04480623f, 
    0.04954780f, -0.09592438f, 0.06926247f, 0.13838840f, -0.04347125f, -0.03544757f, 0.01510793f, 0.07514179f, 
    0.09084851f, -0.32148126f, -0.07821899f, 0.15523405f, -0.07989779f, 0.14745697f, 0.06592043f, -0.03842136f, 
    0.03812846f, -0.00459507f, -0.19216450f, 0.07918534f, 0.01798336f, -0.19803794f, -0.10287173f, -0.08843241f, 
    0.16895381f, 0.01275096f, 0.12026878f, 0.01051810f, -0.12281523f, 0.06180793f, -0.02673890f, 0.03434576f, 
    0.22023961f, 0.06199522f, -0.05423309f, -0.02107269f, 0.02775360f, 0.02729833f, -0.02543844f, -0.07105035f, 
    0.10343849f, -0.01520034f, -0.01571262f, -0.09776855f, 0.15840383f, 0.09485999f, -0.29007521f, -0.20625351f, 
    0.07539567f, 0.09381964f, 0.04761003f, -0.01778542f, -0.03501460f, 0.00109081f, 0.00558389f, -0.01352955f, 
    0.17893343f, -0.19816196f, 0.06229104f, 0.20130238f, -0.16889203f, 0.15964293f, -0.07701872f, 0.00141073f, 
    -0.05477773f, 0.14719802f, -0.01651372f, -0.03086944f, -0.53540105f, 0.10003034f, 0.21912672f, 0.14023136f, 
    0.01105148f, -0.00794654f, 0.10391335f, 0.11650523f, 0.06893702f, -0.00662986f, -0.02739802f, 0.03679291f, 
    0.02175778f, -0.00667560f, 0.08433215f, 0.08391050f, -0.02036290f, 0.01626131f, -0.01090130f, 0.12060521f, 
    0.01415609f, -0.11744963f, 0.02881794f, -0.07629738f, 0.29508835f, -0.00916718f, -0.26438543f, -0.48691565f, 
    -0.20043744f, -0.17417441f, -0.02627149f, -0.07864443f, 0.06971554f, -0.00239419f, -0.21794315f, -0.00660378f, 
    0.17167410f, -0.10316559f, -0.14428787f, -0.08614042f, 0.04072066f, 0.12890895f, 0.03906206f, -0.11491846f, 
    0.06714746f, 0.06162615f, 0.03642241f, -0.04518312f, 0.41559520f, 0.27339241f, 0.12526073f, 0.17129675f, 
    -0.10013536f, -0.03527324f, 0.03368526f, 0.14643618f, 0.26364654f, -0.12906082f, 0.05411173f, 0.14822941f, 
    0.27010152f, -0.08347371f, -0.04565618f, -0.02068580f, -0.15842952f, -0.00933022f, -0.03209170f, 0.12758452f, 
    -0.00370235f, -0.02363159f, -0.00984120f, -0.10235503f, -0.21155055f, -0.11373155f, -0.03106000f, -0.04662760f, 
    -0.03773198f, 0.07523637f, -0.00061275f, 0.18119727f, 0.09372414f, -0.09931976f, 0.04853893f, 0.14449401f, 
    -0.22406468f, -0.11870181f, -0.07005818f, -0.06383798f, -0.12079772f, 0.06702324f, -0.03853685f, -0.08148824f, 
    0.02656320f, 0.01696631f, 0.05065117f, -0.25511360f, 0.18747674f, 0.26457113f, 0.18038836f, -0.23120837f, 
    -0.05815748f, -0.09107866f, 0.08587249f, 0.11398425f, 0.24023585f, -0.12566228f, -0.01957577f, -0.01003774f, 
    0.23981176f, -0.13939722f, 0.04664199f, 0.01240014f, 0.09391920f, 0.07027312f, 0.06307025f, -0.03648120f, 
    0.00815249f, -0.00535972f, -0.04686175f, -0.06014211f, 0.33323628f, 0.08001786f, -0.04171766f, -0.07895241f, 
    -0.10962003f, -0.16486338f, 0.13611764f, 0.10274580f, -0.02663767f, 0.01537663f, 0.10947076f, 0.00922113f, 
    0.33311164f, 0.17633580f, -0.11902586f, 0.10628777f, -0.05100796f, -0.02886277f, 0.16617775f, 0.06963006f, 
    0.24635658f, 0.02676286f, 0.02786934f, -0.04129227f, 0.26555344f, 0.17155313f, 0.10466042f, 0.09158596f, 
    -0.04155274f, -0.12847292f, -0.01038569f, 0.04664863f, -0.00674753f, 0.09519961f, -0.12427010f, 0.12631086f, 
    0.02095371f, -0.03972149f, -0.03779651f, 0.00765531f, -0.04263233f, -0.02454397f, -0.05077526f, 0.02641611f, 
    -0.01676777f, 0.02061272f, -0.00764489f, 0.02819478f, -0.01057473f, 0.04832821f, 0.02817071f, 0.02048338f, 
    -0.02935326f, -0.03962794f, 0.02277425f, 0.02507213f, -0.02836860f, 0.01929965f, -0.05158057f, 0.00120305f, 
    -0.05475044f, -0.01762740f, 0.00770443f, -0.02775835f, 0.01420733f, 0.00085751f, -0.00260161f, -0.01617803f, 
    -0.02814686f, 0.04621252f, -0.02665500f, 0.03798071f, 0.03733417f, -0.02932675f, 0.02154420f, -0.05321419f, 
    -0.03976805f, 0.02901957f, 0.02054665f, -0.04231957f, -0.03486181f, -0.02652916f, -0.03793708f, 0.04777681f, 
    -0.02027026f, -0.00305538f, -0.03420398f, 0.04961457f, 0.00991034f, -0.01350992f, -0.05000281f, 0.01034306f, 
    0.01993327f, -0.02164245f, -0.05161041f, 0.04213914f, 0.03531860f, 0.03725627f, -0.01202693f, 0.04789221f, 
    -0.05330772f, -0.04409770f, 0.00019215f, -0.00824542f, 0.02527935f, 0.04060831f, 0.01733617f, 0.00192364f, 
    -0.01236054f, -0.01759452f, -0.01021525f, -0.02996251f, 0.00146146f, 0.03230360f, -0.03411015f, -0.00867362f, 
    -0.05129759f, -0.04182940f, -0.04134595f, -0.04524999f, 0.03867804f, -0.02537782f, 0.00630092f, 0.03041307f, 
    0.00467466f, -0.00253300f, -0.03509823f, -0.03484445f, -0.00016127f, 0.01507137f, -0.02866610f, -0.02523134f, 
    -0.02223456f, 0.02720305f, -0.03865989f, -0.02703661f, 0.01361656f, 0.04324142f, 0.01056667f, 0.00774859f, 
    -0.03426452f, 0.02912036f, -0.04141343f, 0.00231122f, 0.02574571f, 0.03522668f, -0.01077283f, 0.02106713f, 
    -0.04438981f, -0.00930779f, -0.03679468f, -0.02222984f, 0.03859146f, 0.02685273f, -0.00266932f, -0.03238868f, 
    0.02792332f, 0.04407113f, -0.01715805f, 0.01635084f, 0.03543343f, 0.00844758f, 0.00378393f, -0.00287121f, 
    -0.01570876f, 0.01461135f, 0.00241229f, -0.01596996f, -0.04335341f, -0.02538420f, 0.00236122f, -0.02915303f, 
    0.01155573f, -0.02873865f, -0.01895174f, -0.04950823f, 0.00984565f, -0.01345742f, -0.02753088f, -0.00981827f, 
    0.00317756f, 0.04181127f, 0.03244061f, 0.01817120f, -0.02568543f, 0.04356750f, 0.01873141f, -0.00661525f, 
    -0.01463640f, -0.04696399f, -0.03357796f, -0.01634488f, 0.01110804f, -0.01145362f, -0.04096553f, -0.02970726f, 
    0.00089873f, 0.02537934f, 0.04113328f, 0.04517948f, 0.02197743f, -0.00759454f, -0.00948742f, -0.00828656f, 
    -0.00071434f, -0.02435839f, 0.01615842f, 0.02862637f, -0.00288924f, -0.02622853f, 0.02580246f, 0.01497234f, 
    0.02405357f, -0.00271753f, -0.00392531f, -0.01034255f, -0.00927790f, -0.02514477f, 0.00072673f, -0.05264868f, 
    0.03760667f, 0.01972797f, 0.03828729f, 0.03235183f, 0.00014311f, -0.03592904f, 0.00702783f, 0.01987378f, 
    -0.00837894f, -0.03374822f, 0.03764440f, -0.04166952f, 0.03957864f, 0.03255159f, -0.01688142f, 0.04182789f, 
    -0.03571955f, 0.04379997f, -0.02273540f, 0.01100882f, -0.04222300f, -0.03366260f, -0.00274955f, -0.02965488f, 
    -0.03929456f, -0.02514213f, 0.02401888f, -0.01096053f, -0.03087028f, -0.05264943f, -0.03537733f, -0.04125639f, 
    -0.01409861f, -0.01376342f, -0.02632299f, 0.00813946f, 0.02171337f, 0.04350689f, -0.04820752f, 0.03823255f, 
    0.00030641f, -0.02476504f, 0.01952706f, 0.00149851f, 0.04855913f, 0.02963799f, 0.01781879f, 0.00240622f, 
    -0.01827220f, -0.00661302f, 0.03261262f, 0.01841536f, 0.01976998f, 0.01177314f, 0.01912334f, 0.02646547f, 
    0.02388088f, -0.01420220f, 0.02515339f, 0.04450558f, -0.00701231f, -0.01226481f, 0.03663626f, -0.02500198f, 
    -0.03253372f, -0.04654640f, -0.00735377f, 0.01884108f, 0.02102388f, -0.02749251f, 0.00613406f, -0.01725319f, 
    -0.01206382f, -0.02071345f, -0.04056957f, -0.05017016f, 0.02394416f, -0.04263987f, 0.02156796f, 0.02898354f, 
    0.00911208f, -0.04429786f, 0.00709267f, 0.04574526f, -0.02474396f, -0.02538958f, -0.02698652f, 0.01496072f, 
    0.00941366f, 0.01347347f, -0.05246961f, -0.04590766f, 0.01916331f, -0.02560298f, 0.03518022f, -0.03686480f, 
    -0.02307712f, 0.04499835f, -0.03715715f, 0.01208511f, 0.01330858f, 0.04254723f, 0.01049314f, -0.03835422f, 
    -0.01958608f, -0.04067226f, 0.03427681f, -0.04946587f, 0.03123483f, -0.02184568f, 0.01722275f, -0.02542228f, 
    0.03355960f, -0.04964231f, -0.01497281f, 0.03264678f, 0.04626491f, -0.02473351f, -0.03924495f, 0.02783764f, 
    0.03208337f, 0.00499680f, -0.00099123f, -0.00452133f, 0.04215381f, 0.04439796f, -0.04030825f, -0.04622842f, 
    -0.02564647f, -0.01106982f, -0.01344987f, 0.00723255f, -0.02657011f, 0.03160824f, 0.00944167f, -0.02947546f, 
    -0.04343626f, 0.02946207f, -0.00230878f, 0.04183772f, -0.03545279f, -0.03720453f, 0.00006560f, -0.04584005f, 
    0.02973575f, 0.01633429f, -0.01004276f, -0.04032915f, 0.03504968f, 0.01612529f, -0.03200653f, 0.01170232f, 
    0.00063421f, -0.01822190f, 0.01742168f, -0.04842382f, 0.00285661f, -0.01085993f, -0.04109030f, 0.01842885f, 
    -0.00999366f, 0.03340117f, -0.05277748f, -0.01469379f, -0.00426011f, -0.02051207f, -0.05042562f, 0.02675540f, 
    0.02624104f, 0.03289817f, -0.00392105f, -0.05103199f, -0.03352626f, -0.02302857f, -0.01703451f, -0.04159906f, 
    -0.03192223f, -0.01414078f, -0.01397101f, 0.00135942f, -0.04050263f, 0.02073693f, 0.00806661f, 0.03261071f, 
    0.02890378f, -0.05413377f, -0.02732588f, 0.02404565f, 0.03935783f, -0.02776201f, -0.01115333f, -0.00421530f, 
    -0.03721292f, -0.02025637f, -0.03185596f, -0.02413247f, -0.03561585f, -0.00017274f, -0.01587356f, 0.00989026f, 
    -0.01102589f, -0.00786449f, 0.00016670f, 0.02467436f, -0.05289621f, -0.01651317f, -0.05155668f, 0.04993919f, 
    -0.03606676f, 0.00711234f, 0.00906348f, -0.01229006f, -0.03570019f, 0.03596106f, 0.02097193f, 0.02229474f, 
    0.00380672f, -0.02370382f, 0.00182055f, 0.00928867f, 0.02071659f, 0.00524244f, 0.00072141f, -0.00394162f, 
    0.04012828f, 0.03721911f, -0.04772977f, -0.04267346f, 0.00974180f, -0.00991499f, -0.00667617f, 0.02424873f, 
    0.01893014f, 0.00403528f, -0.01202159f, 0.04180273f, 0.01134625f, -0.00919473f, 0.02033539f, -0.00216241f, 
    0.02090440f, 0.01441503f, -0.02598274f, -0.04967737f, -0.04005098f, -0.04575609f, -0.02752786f, 0.03654343f, 
    0.01577165f, -0.04655046f, -0.01479012f, -0.04827391f, 0.01880927f, 0.02078823f, 0.02682956f, -0.01538065f, 
    -0.00952118f, -0.02713112f, 0.04062212f, 0.04052592f, -0.04913737f, 0.00291214f, -0.03996603f, 0.02623284f, 
    -0.05204107f, -0.02949323f, -0.04269324f, -0.03749351f, 0.02491912f, 0.01371920f, -0.01073117f, 0.03452883f, 
    0.02825804f, -0.00544629f, -0.00249689f, 0.00108019f, 0.02832187f, -0.01656215f, -0.02145618f, 0.03673620f, 
    0.01452967f, 0.04308013f, 0.01738128f, -0.04567794f, -0.05027476f, 0.03278647f, -0.02296502f, -0.03940187f, 
    -0.04118098f, -0.04359112f, 0.04212484f, 0.00216133f, 0.02003357f, 0.02473515f, -0.01500916f, 0.02403955f, 
    0.03190656f, -0.04184939f, 0.02389962f, -0.03190844f, 0.02575951f, 0.03274696f, 0.01800542f, 0.00026399f, 
    -0.02273870f, -0.01310635f, 0.04014779f, -0.04012419f, -0.04194997f, 0.03412124f, -0.03474785f, -0.04881482f, 
    0.04383404f, -0.01671620f, -0.00101595f, 0.01610433f, 0.03020211f, -0.00424896f, -0.03537652f, 0.04185155f, 
    -0.00823535f, 0.01147771f, -0.00854648f, 0.00342500f, -0.04893882f, -0.05167935f, -0.03270571f, 0.02421566f, 
    0.02193136f, 0.00832758f, -0.03391156f, 0.00376882f, 0.03353482f, -0.01795765f, -0.00303710f, -0.05402102f, 
    -0.04521080f, -0.02246799f, 0.02502539f, -0.04345462f, -0.02534047f, 0.02872730f, -0.01389942f, -0.05371234f, 
    -0.01452368f, -0.04613863f, 0.02042779f, -0.01257463f, -0.01685380f, -0.01511171f, -0.05592035f, -0.00131425f, 
    -0.05048377f, -0.02107472f, -0.01902784f, -0.00264703f, 0.04547054f, -0.04153002f, 0.00164059f, -0.03206516f, 
    0.01738631f, -0.03790678f, -0.01725979f, 0.03680233f, -0.02500117f, -0.00352865f, -0.04386058f, -0.03385107f, 
    0.01487090f, 0.04446568f, 0.01689803f, -0.01358057f, 0.00557417f, -0.05160230f, -0.02187788f, -0.01729017f, 
    -0.05099803f, -0.01528568f, -0.02101636f, 0.02980853f, -0.02323551f, 0.01818752f, -0.00398778f, 0.02982207f, 
    -0.00439595f, 0.00586735f, 0.00767657f, 0.00590851f, 0.01969537f, 0.01254577f, -0.04033243f, -0.00836735f, 
    0.00629391f, -0.02582077f, 0.00427947f, 0.03012024f, 0.01151464f, -0.03586303f, -0.05720249f, 0.03698254f, 
    -0.05485284f, -0.02179285f, 0.01416693f, -0.05130915f, -0.00064777f, -0.04764147f, 0.04169630f, -0.00850529f, 
    0.01554433f, -0.04432271f, 0.02755338f, -0.02444465f, -0.02491047f, 0.03980618f, 0.03183306f, -0.05101910f, 
    0.03275352f, 0.01882081f, 0.04053143f, 0.01229715f, -0.04041560f, -0.03338414f, -0.01136913f, -0.00032606f, 
    -0.02125350f, -0.03397113f, 0.00800553f, -0.02520318f, 0.03487520f, 0.02574085f, -0.04762976f, -0.02382271f, 
    0.03385839f, -0.02310092f, 0.03104095f, -0.01161058f, 0.03128555f, -0.01780095f, 0.03663754f, 0.03362947f, 
    -0.03547376f, 0.00821783f, -0.03477310f, -0.01815934f, -0.02425241f, 0.03259336f, -0.01015978f, -0.04192702f, 
    0.03291634f, -0.01101465f, 0.01901029f, -0.03266061f, -0.01443900f, -0.01210095f, -0.01953922f, 0.02358876f, 
    -0.05690138f, -0.02279472f, 0.00177991f, 0.03742753f, 0.04301508f, 0.04788913f, -0.03712317f, 0.00987078f, 
    -0.00180896f, 0.03505508f, -0.03224760f, 0.00015453f, 0.02925496f, 0.02147159f, -0.01785896f, -0.04443884f, 
    -0.00517567f, 0.00208491f, -0.00443532f, -0.05769350f, -0.04231144f, 0.01753584f, 0.00843961f, -0.01976158f, 
    -0.05126320f, -0.02916708f, 0.04085335f, 0.02723347f, -0.03930735f, 0.00318912f, 0.04179370f, -0.00299226f, 
    -0.01421484f, 0.02003784f, 0.03097640f, -0.04080873f, 0.00129611f, -0.02893446f, -0.05290878f, 0.01618072f, 
    0.02950310f, 0.02538503f, 0.05547933f, 0.03805930f, 0.01552780f, 0.02074944f, 0.04740261f, 0.01259101f, 
    -0.05789893f, 0.01267569f, 0.03513414f, -0.01842846f, -0.05815607f, -0.01967337f, -0.04804139f, 0.00136753f, 
    -0.02090760f, 0.01446678f, -0.00073309f, -0.04676826f, 0.02935894f, 0.04265002f, 0.03628504f, 0.00321489f, 
    -0.01573980f, 0.01734578f, -0.02587091f, 0.01540508f, -0.05575395f, 0.00506959f, 0.04083546f, 0.01605634f, 
    -0.02468771f, 0.02101305f, 0.03315778f, 0.03141793f, -0.04269742f, -0.03978155f, 0.01003596f, -0.02536223f, 
    -0.03306990f, 0.00931705f, -0.03308947f, -0.05400306f, -0.04270858f, -0.03207181f, 0.04949041f, -0.02315331f, 
    0.01181710f, 0.00967242f, -0.00089889f, -0.04345467f, 0.01665770f, -0.04340544f, 0.04758491f, -0.05573498f, 
    -0.03021320f, -0.02699086f, -0.01535147f, -0.03365202f, -0.03557118f, -0.03598936f, -0.03813196f, 0.03061526f, 
    -0.00136910f, 0.01172428f, -0.03502204f, -0.02423171f, -0.00547994f, -0.00398491f, -0.00217595f, 0.00806891f, 
    -0.03801301f, -0.00509085f, -0.02296133f, -0.00737439f, -0.05272296f, 0.02743579f, -0.00641153f, -0.05057139f, 
    -0.05668565f, -0.02479865f, -0.04375051f, 0.03553902f, 0.04360849f, -0.03884895f, 0.03801919f, -0.00854166f, 
    -0.01728510f, 0.12053998f, -0.08266634f, -0.00404539f, -0.16818365f, 0.09848634f, -0.17627048f, -0.24923949f, 
    0.13609910f, -0.01932066f, 0.01894455f, -0.08365921f, -0.15670800f, -0.16105638f, -0.00498496f, 0.00343354f, 
    -0.26723242f, -0.00292957f, 0.05533099f, 0.00024934f, 0.06569340f, -0.04939826f, -0.08591620f, -0.04163582f, 
    0.15455627f, 0.02343548f, -0.12614726f, 0.18674561f, -0.03805136f, 0.00623152f, -0.07110224f, -0.06924884f, 
    -0.02607443f, 0.07224640f, 0.06441072f, 0.14185022f, -0.18963794f, -0.23228414f, -0.09745002f, -0.18792382f, 
    -0.13220112f, -0.01359237f, -0.03023532f, 0.02969658f, 0.00458628f, 0.01398237f, -0.07760621f, -0.06351428f, 
    0.46051639f, -0.00258034f, 0.32632563f, 0.12095088f, -0.00625636f, 0.08334537f, -0.02221119f, -0.01613838f, 
    -0.25359336f, 0.05025273f, 0.17966907f, -0.10803675f, -0.18512328f, 0.10252035f, 0.11127263f, -0.01959553f, 
    0.12577456f, -0.02239457f, -0.14370528f, 0.03936096f, -0.00614788f, 0.09720067f, 0.04055822f, 0.21168768f, 
    -0.11355387f, 0.13798785f, 0.13903631f, -0.12849844f, -0.08547480f, -0.01538070f, -0.02276688f, -0.09159712f, 
    0.11730267f, 0.05239502f, -0.09629504f, -0.05094362f, 0.11756194f, -0.03849673f, -0.11174568f, -0.06201295f, 
    -0.18941505f, 0.01839335f, -0.07008091f, 0.04327650f, -0.00326004f, -0.00570038f, -0.02076361f, -0.05366862f, 
    0.13967654f, 0.60215855f, -0.06978206f, -0.06856164f, 0.18602702f, 0.04363929f, 0.11101042f, -0.05770480f, 
    -0.08114586f, -0.07932644f, 0.00808615f, -0.13981031f, 0.02012598f, 0.06321246f, 0.29990846f, 0.01424623f, 
    -0.19335657f, -0.17045145f, 0.01796622f, 0.02030188f, -0.01655257f, 0.03985126f, 0.01309733f, 0.07467567f, 
    -0.37153447f, 0.01557469f, -0.17592260f, 0.18938607f, 0.12024054f, -0.04100374f, -0.05104700f, -0.09090324f, 
    0.18850873f, 0.15209951f, 0.19746520f, 0.05123746f, -0.05682699f, 0.42502120f, 0.24224110f, 0.26862958f, 
    0.11616348f, 0.09674647f, 0.09093213f, 0.25017980f, 0.06513993f, 0.04248792f, -0.01551800f, -0.04705045f, 
    0.22167629f, 0.12641683f, 0.34092855f, 0.36453351f, -0.19168934f, -0.02073377f, 0.10701586f, -0.00312474f, 
    -0.14834601f, 0.00159443f, -0.04505189f, -0.05202391f, 0.23440745f, -0.26087281f, -0.12455888f, 0.35669106f, 
    -0.04865684f, -0.14018404f, 0.05405413f, -0.02177697f, -0.04849683f, -0.02721792f, -0.16264968f, 0.10212601f, 
    0.18119316f, 0.18063857f, -0.00306287f, -0.11976989f, 0.23919874f, -0.06399082f, 0.14898489f, 0.09741323f, 
    0.01398689f, -0.03760972f, 0.01699053f, -0.00378122f, 0.29946914f, -0.12708510f, -0.17784411f, -0.20171770f, 
    -0.09941150f, -0.07007235f, -0.01893382f, -0.04996825f, -0.02453637f, 0.15884766f, -0.00304127f, 0.07862802f, 
    -0.05113519f, 0.03210516f, -0.13647677f, 0.21940330f, -0.25047064f, -0.05691480f, -0.09080033f, 0.03358540f, 
    -0.00019540f, -0.10114358f, 0.01042727f, -0.02928517f, -0.10957595f, 0.47990143f, -0.15200013f, -0.08281395f, 
    0.04426245f, -0.00324175f, 0.12941411f, 0.12562732f, 0.07963718f, -0.02809153f, 0.05918578f, -0.08601490f, 
    -0.00058230f, 0.15099804f, 0.22421791f, 0.07947380f, 0.19132335f, -0.09109218f, 0.05580001f, -0.00946423f, 
    0.03987023f, 0.01305900f, 0.06722103f, -0.13340877f, -0.10942039f, 0.16028559f, 0.31908038f, 0.23248710f, 
    0.12664095f, 0.03898882f, 0.02075158f, 0.07353847f, -0.09864793f, 0.07521838f, -0.04359587f, -0.02496929f, 
    0.37206873f, 0.08342569f, 0.25218281f, 0.33213127f, 0.08620381f, 0.03238818f, -0.01582101f, -0.00607248f, 
    -0.06252687f, 0.02043991f, -0.02802514f, -0.02108110f, 0.27776745f, 0.19844656f, 0.04899414f, 0.16944046f, 
    0.29446340f, 0.17724210f, 0.08301374f, -0.01063623f, 0.12762873f, -0.09177894f, 0.07431546f, -0.04225032f, 
    0.21219218f, 0.07576559f, -0.05267322f, 0.05086342f, -0.13174514f, -0.01247238f, 0.11579236f, 0.14717168f, 
    -0.05546422f, 0.06477011f, -0.01633984f, -0.10958099f, 0.21268888f, 0.03999764f, 0.15095322f, 0.21959850f, 
    -0.04344909f, -0.02490659f, 0.01323132f, -0.00382484f, -0.10889541f, 0.02622517f, -0.01361443f, 0.02171867f, 
    0.06657293f, -0.23079634f, -0.07868166f, -0.07992390f, -0.13194068f, -0.04679411f, -0.07664569f, 0.02629432f, 
    -0.05053969f, -0.04368138f, -0.02025399f, 0.11054957f, -0.05444646f, -0.09779713f, -0.28931653f, -0.11647976f, 
    -0.00805823f, -0.05479095f, -0.12738502f, -0.10361208f, -0.01789667f, -0.07314329f, 0.11825988f, -0.09374098f, 
    -0.02251824f, 0.12840892f, -0.05999992f, -0.21859866f, 0.19167314f, 0.09136002f, 0.15590200f, -0.29550728f, 
    0.11105659f, 0.14176443f, 0.08146548f, 0.17018794f, 0.21189439f, -0.11759591f, 0.12904987f, 0.07755062f, 
    -0.14637810f, 0.06808498f, 0.01559100f, -0.09317011f, -0.12143254f, -0.15189932f, 0.07464152f, 0.13170585f, 
    -0.16403835f, -0.23167208f, 0.02145369f, -0.17172112f, 0.02737509f, -0.09569851f, 0.09227391f, -0.10841254f, 
    0.10838996f, -0.13186042f, 0.07342044f, 0.02819036f, -0.39476010f, -0.12808299f, -0.05717643f, 0.08868086f, 
    -0.12684460f, -0.05632340f, 0.00656572f, 0.04356013f, -0.01520690f, 0.06162130f, -0.14357826f, -0.05333475f, 
    -0.21136849f, -0.14789747f, -0.13707994f, -0.01653382f, -0.04735279f, 0.09219019f, -0.00632196f, 0.07313678f, 
    -0.06116701f, -0.00223833f, 0.18393762f, 0.15319754f, -0.45733589f, -0.29462007f, 0.01166310f, 0.15338902f, 
    -0.06428525f, -0.02686409f, -0.05906229f, 0.01796860f, 0.02904550f, -0.06698109f, -0.12414759f, -0.06761243f, 
    -0.00824136f, -0.01824897f, 0.00405601f, 0.01375596f, 0.03588428f, -0.03540211f, -0.00255939f, 0.02647713f, 
    -0.02007232f, 0.04033187f, -0.04196627f, 0.02449751f, -0.05605935f, -0.03649038f, 0.01946679f, -0.00357796f, 
    0.02203181f, 0.00378771f, -0.05552797f, -0.02715863f, -0.01077826f, -0.00310425f, -0.05932115f, -0.03469797f, 
    0.02016379f, 0.01164463f, -0.03584134f, 0.01011025f, -0.00911036f, -0.04307089f, -0.05148561f, 0.00346198f, 
    -0.00821849f, -0.01644905f, -0.02278080f, -0.04054146f, -0.01655970f, -0.03879303f, -0.03185606f, -0.05554989f, 
    -0.05017970f, 0.01340904f, -0.05015663f, -0.01440886f, -0.05763470f, 0.02216892f, 0.01930690f, 0.00316052f, 
    -0.04822391f, -0.04294146f, 0.00523336f, -0.04143618f, -0.03501365f, -0.00679918f, -0.00119442f, -0.05841546f, 
    -0.05260915f, -0.03079385f, 0.02637203f, -0.04515939f, -0.05309537f, -0.04096815f, 0.03445174f, 0.03038225f, 
    0.00863565f, 0.04209582f, 0.00466501f, 0.01191644f, 0.03665559f, 0.00080517f, -0.01830675f, 0.00119500f, 
    0.01871500f, 0.00590385f, -0.02087697f, 0.01479379f, 0.02175683f, -0.01927422f, -0.01112989f, -0.05847595f, 
    -0.03426009f, 0.03297005f, -0.01959351f, 0.03184025f, 0.03392116f, 0.00780075f, -0.00639272f, -0.00510273f, 
    -0.03898674f, 0.02024061f, -0.00512763f, 0.03146840f, 0.00000592f, 0.01274039f, -0.02351644f, -0.01541834f, 
    -0.05747971f, 0.03814766f, 0.02078390f, -0.03962538f, 0.01831310f, -0.03912414f, 0.01159729f, 0.03643975f, 
    0.02516685f, 0.03525138f, 0.01796989f, 0.02664553f, -0.03593415f, 0.02866231f, -0.05235108f, -0.03787738f, 
    0.02388980f, -0.00984787f, 0.00993175f, 0.01720193f, 0.04424237f, -0.02708295f, -0.00464966f, 0.02551596f, 
    0.02269598f, 0.02467112f, -0.05433435f, -0.02124031f, -0.00876989f, 0.02616531f, -0.02135002f, 0.01904153f, 
    -0.04459844f, 0.03591879f, 0.03066026f, 0.01692516f, -0.02349350f, -0.00307455f, -0.05786198f, 0.01866332f, 
    -0.00503461f, 0.02040646f, -0.04769182f, -0.02987031f, -0.03262218f, -0.03017268f, -0.00442395f, -0.05403739f, 
    0.02314111f, -0.00776888f, 0.00744546f, -0.04390283f, 0.02146170f, -0.05950715f, -0.05157615f, -0.05403412f, 
    0.02908594f, 0.01471995f, -0.04113671f, 0.01587151f, -0.00440530f, 0.02948196f, 0.01178909f, -0.00365634f, 
    0.02230754f, -0.03384085f, -0.01761059f, -0.01491740f, -0.01777834f, -0.04946256f, 0.00259837f, -0.03770635f, 
    0.00338108f, 0.03227106f, 0.02372031f, -0.04463485f, 0.02325710f, -0.00321909f, -0.00174698f, 0.00069321f, 
    -0.01485777f, -0.03070407f, 0.01442584f, 0.02501182f, -0.04844965f, 0.00251617f, -0.01940121f, 0.02872271f, 
    -0.05415484f, -0.02470007f, -0.01191410f, -0.04428043f, -0.05676206f, -0.02634675f, 0.02944156f, -0.00585009f, 
    -0.05479813f, -0.01431059f, -0.06055971f, -0.01703592f, -0.00805695f, -0.04859512f, 0.03265276f, -0.00787645f, 
    0.01073344f, 0.01395554f, -0.02423870f, -0.01233647f, 0.03940837f, -0.02988524f, 0.02654757f, -0.01811794f, 
    0.03665642f, -0.01394562f, -0.04100307f, -0.04696653f, 0.01592942f, 0.00055640f, 0.03860753f, -0.02652055f, 
    -0.05381197f, -0.01825085f, 0.03552442f, -0.04038269f, 0.03810620f, 0.02258461f, 0.03950984f, 0.03604781f, 
    -0.03336742f, 0.00708094f, -0.01077631f, 0.00087259f, -0.04842845f, -0.05202334f, 0.01148640f, -0.02318063f, 
    0.02302579f, 0.02099373f, 0.03890443f, 0.00743951f, -0.01370008f, -0.03074813f, 0.04240778f, -0.01450247f, 
    0.02628287f, -0.04475137f, -0.01228436f, 0.03523678f, 0.00048363f, -0.00665957f, -0.01420770f, -0.03976190f, 
    -0.04992848f, 0.01039313f, -0.02352916f, 0.02852508f, -0.01215152f, -0.02866020f, 0.02700068f, -0.01237984f, 
    0.03138159f, 0.01807508f, -0.04414564f, -0.00248145f, -0.01739326f, 0.02343659f, 0.03758533f, 0.03298575f, 
    0.02073259f, 0.02449051f, 0.00039851f, -0.03795999f, -0.01459403f, -0.02640497f, 0.01901535f, -0.05466489f, 
    0.03145683f, -0.04044774f, -0.03489152f, -0.01223365f, 0.01839334f, 0.03564430f, 0.02653850f, -0.04853403f, 
    -0.04151795f, -0.03174268f, 0.01716410f, 0.00349681f, 0.02546171f, -0.04500184f, 0.00285046f, -0.02346462f, 
    0.01661764f, -0.00824201f, 0.03143763f, -0.02732943f, -0.01184663f, 0.02626207f, 0.00102645f, -0.02833986f, 
    -0.03222984f, -0.01659748f, -0.00391572f, -0.02711788f, -0.00648383f, 0.00263346f, -0.05423667f, -0.01766394f, 
    0.00159599f, -0.03136230f, 0.03947786f, -0.02306903f, -0.03934665f, -0.03521338f, -0.04112810f, 0.02404342f, 
    -0.05832735f, -0.02356913f, -0.00125562f, 0.01937022f, -0.02674196f, -0.04932859f, 0.00060437f, -0.04500108f, 
    -0.04827426f, -0.01551389f, -0.02419162f, -0.02299793f, 0.02324419f, -0.04742585f, -0.03481192f, -0.04621539f, 
    -0.03634347f, -0.05124917f, 0.04080252f, -0.05425270f, 0.03647422f, 0.02110172f, -0.04580432f, 0.03301568f, 
    0.03349116f, -0.05093313f, 0.02692301f, 0.00171294f, 0.02229888f, 0.02756641f, 0.00173760f, -0.00768773f, 
    -0.05370976f, 0.00485595f, 0.02116155f, 0.03928458f, 0.00267333f, 0.02175340f, -0.03658209f, -0.02836254f, 
    -0.00840667f, 0.04884935f, 0.01114275f, -0.04059722f, -0.01946487f, -0.05778773f, 0.03651213f, -0.02700428f, 
    -0.02127792f, -0.05365878f, 0.00287737f, -0.03541447f, -0.01111201f, -0.01962052f, -0.00171498f, 0.02569220f, 
    -0.02162301f, 0.03940031f, 0.00602944f, 0.03688477f, -0.03233200f, -0.03457512f, -0.01105669f, -0.00817726f, 
    -0.01466299f, 0.01359247f, -0.03809630f, 0.03089946f, 0.01186927f, -0.04039273f, -0.03483229f, -0.03940299f, 
    -0.08196323f, -0.24471605f, 0.02866330f, 0.10072993f, -0.11802230f, 0.02118463f, 0.04994624f, 0.10698148f, 
    -0.05064749f, 0.04765183f, 0.07747356f, 0.01924848f, -0.17763560f, -0.03953058f, -0.16307028f, -0.20583458f, 
    -0.10646224f, -0.12860177f, -0.00592324f, 0.22405745f, 0.08457803f, -0.00140917f, 0.23118873f, -0.24951749f, 
    -0.07536333f, 0.01781817f, 0.19594003f, 0.08553633f, 0.08573679f, 0.06006195f, -0.05866794f, -0.09947371f, 
    -0.04760346f, -0.04619562f, 0.01161830f, 0.00559832f, -0.72240663f, -0.02674314f, -0.02281578f, 0.11905540f, 
    -0.10535638f, 0.02984623f, -0.05638782f, 0.17300528f, 0.00099554f, -0.09614215f, 0.05276906f, 0.03816978f, 
    0.10480033f, -0.07744703f, 0.18975523f, 0.35089463f, 0.03327176f, 0.18596447f, 0.15354063f, 0.05430892f, 
    -0.05783677f, -0.05356576f, -0.08697638f, 0.00855858f, 0.11637743f, -0.23271994f, -0.16558403f, 0.00429463f, 
    -0.15798195f, 0.00245362f, 0.02796355f, 0.12077041f, -0.01111535f, -0.09594382f, -0.12303261f, -0.02031842f, 
    -0.41456056f, -0.12171748f, -0.22011273f, -0.11025460f, -0.10361138f, -0.06023419f, -0.04841781f, 0.08635560f, 
    -0.02336654f, -0.06502109f, 0.04207901f, 0.04224325f, -0.12560847f, -0.07216582f, 0.08047251f, 0.25988343f, 
    0.08171722f, 0.08197467f, 0.10706324f, 0.11881949f, -0.04246781f, 0.11458239f, 0.07091940f, 0.11257371f, 
    0.58386964f, -0.11942516f, 0.13756669f, -0.14291196f, -0.06915314f, -0.01748751f, 0.11352254f, -0.00501331f, 
    -0.05086237f, 0.01066251f, 0.15839604f, 0.17355007f, 0.25424495f, -0.13096911f, 0.07500178f, -0.16037259f, 
    0.09248983f, 0.03588417f, 0.01441872f, 0.08893371f, 0.00935837f, -0.03197562f, -0.23508750f, -0.09121876f, 
    0.07363763f, -0.01809161f, -0.25272882f, 0.04500727f, -0.04829194f, 0.09091718f, -0.00342198f, 0.02339786f, 
    -0.05288979f, -0.00813735f, -0.02031758f, 0.05361107f, 0.09978587f, 0.07653380f, 0.13391441f, 0.07330213f, 
    0.01141470f, 0.07890995f, 0.01786060f, -0.21488926f, -0.10914642f, 0.06670075f, -0.12565552f, 0.15807253f, 
    -0.26550558f, 0.18307312f, 0.08479230f, -0.13110279f, 0.01939677f, 0.07040749f, -0.01496102f, 0.03064224f, 
    0.02779296f, -0.17823295f, 0.16558467f, 0.08450732f, -0.25159499f, -0.02262227f, -0.03718116f, 0.08641664f, 
    0.13878514f, 0.10009395f, 0.08113715f, 0.01873458f, -0.05455796f, -0.00614565f, -0.10000101f, 0.10637452f, 
    0.45032138f, 0.22672121f, -0.12909520f, -0.03837692f, -0.16444111f, -0.15471104f, 0.21555035f, 0.01703270f, 
    -0.00125022f, 0.04076994f, -0.09035529f, 0.11067247f, -0.24429896f, 0.10611077f, 0.04662848f, 0.06588578f, 
    -0.02556051f, 0.10869347f, 0.19900416f, 0.14998923f, 0.00411364f, -0.04777486f, 0.18149912f, 0.07242032f, 
    -0.14157714f, 0.30865347f, 0.25329980f, -0.01326563f, 0.06169624f, 0.14563903f, 0.02389371f, -0.01135983f, 
    0.00322768f, 0.02257481f, -0.04705804f, -0.13528508f, 0.49788851f, -0.11001581f, 0.05853569f, -0.01630737f, 
    -0.15913478f, -0.04140201f, -0.02629636f, 0.07347034f, 0.00905753f, 0.07487939f, 0.01645392f, 0.09730726f, 
    0.43509439f, 0.11344588f, 0.03551969f, 0.00310234f, -0.03354558f, 0.12023368f, -0.08576978f, 0.10296164f, 
    -0.04758661f, 0.03838411f, 0.04388691f, 0.04431411f, -0.06214321f, 0.14842029f, 0.00795289f, -0.12465288f, 
    0.09843642f, 0.02492864f, 0.14594948f, 0.02852801f, 0.05301120f, 0.03801404f, -0.08803999f, 0.03444435f, 
    0.24327844f, 0.22687444f, -0.04388451f, -0.24777435f, 0.12466493f, 0.18720740f, 0.06360503f, 0.06881706f, 
    -0.03654692f, -0.06590318f, -0.04951286f, -0.04367800f, -0.21116540f, -0.20204093f, -0.16607502f, -0.34468505f, 
    -0.11337903f, -0.15102947f, -0.03949005f, 0.00157485f, -0.01281927f, 0.07684116f, -0.01642013f, -0.00120745f, 
    0.32723373f, 0.01683255f, -0.07953530f, 0.00245098f, -0.16196364f, 0.02633479f, -0.14495520f, -0.02630920f, 
    0.05426471f, 0.04854919f, 0.05764347f, 0.00931865f, 0.20223150f, 0.06204989f, 0.30145952f, 0.04440240f, 
    -0.01725288f, 0.23606248f, 0.05539898f, 0.15738234f, 0.11613035f, -0.04239786f, 0.14309487f, 0.05607384f, 
    -0.28427631f, 0.01518877f, -0.08259875f, -0.35347655f, 0.08782633f, 0.10679158f, 0.01813592f, 0.01299360f, 
    0.01219129f, 0.09854318f, 0.07456644f, -0.07973149f, -0.39832968f, -0.12811951f, -0.11213958f, -0.05091194f, 
    -0.06765383f, 0.08868443f, 0.14434074f, 0.04338126f, 0.23338880f, 0.10369287f, -0.03583589f, 0.05422489f, 
    0.06962307f, -0.07316171f, 0.10965230f, 0.01323292f, -0.08629634f, 0.04952202f, 0.18231301f, 0.12602992f, 
    0.30210492f, -0.11134090f, 0.19221881f, 0.03853695f, 0.06550328f, 0.11190139f, 0.04627153f, -0.33342203f, 
    0.00453907f, -0.08543912f, 0.05369158f, 0.11970073f, 0.21577619f, 0.08254816f, 0.02419258f, -0.17926472f, 
    -0.29988232f, -0.10178147f, 0.20959808f, 0.09742259f, 0.13669470f, 0.19693796f, 0.03315142f, -0.02115391f, 
    0.02666972f, 0.07723778f, 0.04328580f, -0.03935976f, -0.27776062f, 0.23859493f, -0.14356548f, -0.24872541f, 
    0.07967798f, -0.00064793f, -0.03911710f, 0.08789843f, -0.04212542f, 0.02461472f, 0.09198435f, 0.05118221f, 
    -0.40367794f, 0.29769775f, 0.19953392f, 0.11157694f, -0.02716663f, -0.10930450f, 0.02354904f, 0.04433452f, 
    0.08063909f, 0.00735118f, -0.16380554f, -0.13121261f, -0.41516259f, 0.12809123f, 0.08142925f, 0.01084631f, 
    -0.12402496f, 0.01387502f, -0.00091961f, 0.12274977f, 0.00034354f, 0.26380211f, 0.01298194f, 0.01877024f, 
    -0.02112756f, -0.01279145f, 0.03392877f, -0.02724161f, -0.01716042f, -0.05147433f, 0.01622217f, -0.01174718f, 
    0.02598669f, 0.00325949f, 0.04294593f, -0.05066860f, 0.01624320f, -0.04603525f, 0.00825714f, 0.01134983f, 
    -0.01278197f, 0.02677842f, 0.00858373f, 0.02601655f, 0.00737732f, 0.02610347f, -0.05238368f, -0.05494203f, 
    -0.01040314f, 0.03613007f, -0.03584949f, -0.00033449f, 0.03395776f, -0.04127386f, -0.04840118f, -0.02798653f, 
    -0.01777834f, -0.02210385f, 0.00292416f, -0.00282707f, 0.02917193f, 0.00209930f, -0.01183947f, 0.04036265f, 
    0.00199303f, 0.02057666f, -0.02025209f, -0.01280444f, -0.01718564f, 0.01652281f, 0.03281472f, 0.03856071f, 
    0.02389593f, -0.05175257f, -0.01023586f, -0.03696688f, 0.02131169f, -0.02482461f, 0.04375763f, -0.04888956f, 
    -0.03763746f, -0.05169487f, -0.03341306f, 0.00358854f, 0.02103884f, -0.04989027f, -0.04494658f, -0.00974125f, 
    -0.04940868f, 0.03786711f, -0.02094761f, -0.05031005f, 0.00863685f, -0.02217274f, 0.02737161f, -0.02189199f, 
    0.02116180f, 0.02970569f, -0.05508959f, -0.04418896f, -0.04186942f, 0.01421960f, -0.01080982f, 0.01413387f, 
    -0.04555513f, 0.03376137f, -0.05281395f, -0.01645367f, -0.02613322f, 0.02930995f, 0.00142867f, 0.03780102f, 
    -0.04589063f, -0.00488920f, 0.01044046f, 0.01293049f, -0.03590580f, -0.01605030f, -0.00944707f, -0.00113823f, 
    -0.00480365f, -0.02793230f, -0.00778905f, -0.03730437f, -0.02067854f, -0.01438639f, 0.00532480f, 0.02955137f, 
    -0.04080983f, 0.03659457f, -0.02513654f, -0.03005180f, 0.01060354f, -0.01837784f, -0.00142036f, 0.01475858f, 
    0.02905637f, -0.04255650f, 0.03294642f, 0.03647092f, -0.05221196f, -0.01102451f, 0.01101104f, -0.02726753f, 
    0.00154981f, 0.01205038f, 0.01540266f, -0.00133782f, 0.02198381f, -0.05153537f, -0.02442001f, 0.03125871f, 
    -0.02543928f, -0.00575728f, 0.01191909f, 0.02405443f, 0.03165291f, -0.04433900f, -0.03320735f, -0.00615773f, 
    0.00601173f, -0.00790234f, 0.02844601f, -0.01256579f, 0.00097018f, 0.01856087f, 0.02768229f, -0.03259159f, 
    0.01213219f, 0.02368056f, 0.02477760f, -0.04485328f, 0.03098320f, -0.01238976f, -0.04875888f, -0.00238842f, 
    -0.00225616f, 0.00527322f, -0.02219795f, 0.03258004f, -0.00609919f, 0.00152910f, 0.03220636f, -0.04894918f, 
    -0.00809839f, -0.01201418f, -0.00769949f, -0.03479364f, -0.01900524f, 0.04432625f, 0.01729828f, -0.03965050f, 
    -0.00379144f, -0.00343984f, -0.02792092f, 0.02130698f, 0.01368232f, -0.04920240f, -0.00298384f, -0.03791126f, 
    0.00671316f, 0.00669893f, 0.02214799f, 0.03687670f, 0.01019386f, 0.00022344f, -0.03036214f, 0.02746704f, 
    0.00317299f, -0.05162791f, 0.01945209f, 0.02080238f, -0.00007157f, -0.01651413f, -0.02520343f, 0.03690333f, 
    0.01294788f, 0.02636457f, 0.03521746f, -0.05350853f, 0.00229629f, -0.02244570f, -0.02779340f, -0.03821668f, 
    0.01969712f, -0.00333749f, 0.01406193f, -0.05539136f, -0.03515475f, 0.04201737f, -0.02259932f, 0.03448609f, 
    0.01514893f, 0.01832016f, -0.00447075f, 0.01495495f, -0.01098739f, 0.01084082f, -0.00808671f, -0.03134153f, 
    0.03460192f, -0.02276713f, 0.01875699f, 0.01865605f, 0.03238524f, 0.01580317f, 0.00885728f, 0.03659898f, 
    -0.02826681f, 0.01808238f, -0.05058444f, -0.02772770f, 0.02003584f, -0.03228676f, -0.00928046f, 0.02004877f, 
    -0.05584131f, -0.03963529f, 0.04626970f, 0.03466363f, -0.04232511f, 0.00464783f, -0.00831116f, 0.04601220f, 
    0.02218636f, -0.05802071f, -0.04890882f, 0.01017132f, -0.05414465f, -0.04875279f, 0.03099224f, -0.01488078f, 
    -0.01907181f, -0.02970134f, 0.03507008f, -0.00633211f, 0.01978407f, -0.03530494f, 0.02722670f, 0.03144422f, 
    -0.04306592f, -0.04727671f, -0.05814027f, 0.01707460f, 0.04265293f, 0.00003398f, 0.01767048f, 0.03175786f, 
    0.03881195f, 0.00299594f, 0.04312700f, 0.01318607f, 0.03358399f, -0.00862309f, -0.01312410f, -0.00121460f, 
    -0.00299362f, -0.04691627f, 0.03454243f, 0.03069548f, 0.04567033f, -0.01765970f, 0.02531223f, -0.01342578f, 
    0.00797327f, 0.00244466f, -0.03287917f, -0.02877954f, -0.05214125f, -0.03572246f, 0.03465526f, -0.04171204f, 
    -0.03912760f, 0.00071282f, -0.02280415f, 0.00913254f, -0.05459150f, -0.02064480f, -0.03901953f, -0.05236360f, 
    -0.05321287f, 0.01823837f, 0.03460765f, -0.03896960f, -0.00786124f, 0.01192605f, 0.00377870f, -0.02120341f, 
    -0.00632659f, -0.01372608f, 0.01849378f, 0.02527203f, 0.03868011f, -0.00301494f, -0.01809146f, -0.01607386f, 
    -0.00420901f, -0.05059300f, -0.03251769f, 0.03102032f, -0.01048544f, 0.03192420f, -0.04999042f, 0.00040314f, 
    0.02218010f, -0.03210026f, 0.02839001f, -0.05609336f, -0.02938062f, -0.00645804f, -0.03073092f, -0.01210406f, 
    0.02385958f, 0.02502432f, -0.03348775f, 0.04317337f, -0.03042660f, -0.00936790f, -0.02018973f, 0.02185436f, 
    -0.00174456f, -0.00758162f, 0.02865944f, 0.03526010f, -0.01161447f, -0.03580924f, -0.00493984f, 0.02498589f, 
    -0.04010249f, -0.04139472f, -0.03655299f, 0.00196835f, -0.03025457f, -0.02740870f, -0.05005294f, 0.01819968f, 
    -0.02445409f, 0.01125085f, 0.03225334f, -0.01456457f, 0.01780399f, -0.01934140f, -0.02502575f, 0.00278561f, 
    -0.03153759f, -0.05338950f, -0.04951051f, -0.05024908f, -0.03542506f, 0.04109638f, -0.05283821f, 0.03403514f, 
    0.01331829f, -0.03634819f, -0.04268676f, 0.01948171f, 0.02544833f, 0.00063409f, -0.03208407f, -0.05284745f, 
    0.00395780f, -0.02528202f, -0.02222173f, 0.02816300f, -0.01794707f, -0.04511129f, 0.01683481f, -0.00976609f, 
    0.03132785f, 0.02244172f, 0.01380207f, 0.04396769f, 0.00035210f, -0.02492821f, -0.03537852f, 0.01312404f, 
    -0.01049032f, -0.02965005f, -0.00427382f, -0.05642949f, 0.00032526f, -0.03660174f, -0.03125665f, -0.00569959f, 
    0.04114321f, -0.02255647f, 0.00525928f, 0.04415429f, 0.01605914f, -0.02327952f, 0.00981987f, -0.03525442f, 
    0.01063337f, 0.02349554f, -0.00289505f, -0.00189027f, -0.00297202f, 0.02163653f, -0.04548773f, -0.04456395f, 
    0.02001562f, -0.03714209f, -0.05405461f, -0.01216357f, -0.03107308f, -0.01189846f, 0.01527560f, 0.00450044f, 
    -0.03895739f, -0.02728671f, -0.00337687f, 0.00865108f, 0.01333697f, 0.03249388f, -0.00539692f, -0.00191261f, 
    -0.04572595f, -0.01588735f, 0.00983654f, 0.04259360f, 0.03701839f, -0.04808414f, -0.04546251f, -0.00030905f, 
    -0.02450460f, -0.00094581f, -0.05044566f, 0.01654484f, -0.04647117f, -0.01134205f, -0.03572435f, -0.02463852f, 
    0.03577558f, -0.03961336f, -0.01238974f, -0.01877924f, -0.01860414f, -0.04290259f, -0.04445016f, -0.01492352f, 
    -0.00549618f, -0.05160850f, -0.01366101f, -0.03856640f, -0.02665245f, 0.00817471f, -0.02583555f, 0.00899437f, 
    0.00606937f, -0.00352316f, -0.01198754f, 0.00048594f, 0.00536959f, 0.02771022f, 0.00979688f, 0.00442643f, 
    -0.02643220f, -0.03272340f, -0.00725192f, 0.00779624f, -0.01689016f, -0.00605385f, 0.03438696f, 0.02924457f, 
    -0.03043085f, 0.04357189f, 0.02946033f, -0.02994704f, -0.02905425f, -0.05576930f, 0.00909745f, -0.02589744f, 
    0.04151949f, -0.04696228f, -0.02596790f, 0.03027712f, -0.02749331f, -0.00997019f, -0.03167437f, 0.00380634f, 
    0.03785852f, -0.02552513f, 0.01170049f, 0.04182462f, -0.02394398f, 0.03614976f, 0.00302457f, 0.02224444f, 
    -0.00340652f, -0.05663229f, 0.02359149f, 0.00645411f, -0.03855593f, 0.00239459f, -0.03461685f, -0.05334144f, 
    0.01965367f, -0.03304709f, 0.04205415f, -0.00586799f, 0.01184088f, 0.01169493f, -0.01419663f, 0.03787690f, 
    -0.04717751f, 0.02753844f, 0.03500030f, 0.01412351f, 0.02940498f, -0.01972784f, -0.00511848f, -0.02174984f, 
    -0.01056095f, -0.02270707f, 0.02430612f, 0.02338278f, -0.02872462f, -0.02226138f, -0.02449493f, -0.03879448f, 
    0.02757319f, -0.00209115f, -0.03998123f, -0.00130886f, -0.05702748f, 0.00987513f, 0.01940293f, -0.04053303f, 
    -0.03429314f, 0.02937990f, 0.03692006f, -0.03826464f, -0.05673416f, 0.03548793f, -0.03771050f, 0.02796833f, 
    -0.04392436f, 0.03856342f, 0.04293642f, -0.01992627f, 0.02323574f, -0.05517267f, -0.04512556f, -0.03941474f, 
    -0.04919363f, 0.02602611f, 0.01878386f, 0.00895135f, 0.00681313f, 0.03863282f, 0.03355629f, 0.00930338f, 
    0.04183668f, -0.03876272f, -0.02005741f, -0.01075120f, -0.02887549f, -0.01199605f, -0.00276417f, -0.05225834f, 
    -0.02246103f, -0.03253718f, -0.01126722f, -0.05389230f, -0.05341615f, 0.03135866f, -0.03006175f, -0.04181146f, 
    0.03105178f, -0.00462267f, -0.03007781f, -0.05555139f, -0.03949479f, -0.03094271f, -0.02485514f, 0.01904299f, 
    -0.05684763f, 0.00535422f, -0.01223456f, 0.01675306f, -0.05042204f, 0.03606262f, 0.00728165f, -0.03559157f, 
    -0.02473379f, -0.03832249f, 0.03984762f, 0.00091558f, -0.05293170f, 0.02166521f, -0.04332100f, 0.02220482f, 
    -0.00197281f, -0.04626015f, -0.00070899f, -0.00806901f, -0.05322294f, 0.01176485f, 0.02891442f, -0.02863396f, 
    0.01533122f, -0.01655021f, 0.03534358f, 0.02939961f, -0.01802324f, 0.01088449f, 0.00837696f, 0.01611566f, 
    0.02423445f, -0.04624629f, -0.04255569f, 0.02561378f, -0.01157872f, -0.03495838f, 0.03959044f, 0.02539386f, 
    -0.05311348f, -0.02093785f, 0.01671630f, -0.03144000f, 0.02825564f, -0.00677816f, -0.03494174f, -0.02947007f, 
    0.03454977f, -0.04324508f, 0.03879442f, -0.04452112f, -0.03327763f, -0.04233825f, 0.04039582f, 0.01164740f, 
    -0.00517069f, 0.02895410f, 0.04277727f, -0.04126517f, 0.01389818f, -0.02664800f, -0.02061125f, 0.01733712f, 
    -0.01797066f, -0.00886459f, -0.03489142f, -0.00523940f, 0.04451632f, 0.04055602f, 0.00504971f, 0.03743957f, 
    0.02675686f, 0.01027106f, 0.00490969f, 0.01641438f, 0.01195024f, -0.03323349f, 0.01863030f, 0.00339439f, 
    -0.03996033f, 0.04201514f, -0.04431330f, -0.00438523f, -0.03143312f, 0.00402191f, -0.00381472f, 0.01552654f, 
    -0.04389046f, -0.02227822f, -0.03461770f, -0.01872402f, 0.02812594f, -0.01936858f, 0.01838197f, -0.01540650f, 
    -0.03865694f, -0.00126166f, -0.03095417f, -0.01196434f, 0.03634001f, -0.00163199f, -0.03161597f, -0.03160820f, 
    0.01569563f, -0.00510922f, -0.03882199f, 0.00260579f, 0.04214828f, -0.04321706f, 0.00492668f, 0.02508120f, 
    -0.04661235f, -0.02619313f, -0.04504209f, 0.03899998f, -0.03580049f, -0.04941034f, 0.01994077f, 0.00031294f, 
    0.04132548f, 0.01202025f, 0.03334910f, -0.01546810f, -0.03407795f, -0.05029719f, -0.00981197f, -0.02957999f, 
    -0.04303456f, 0.01049240f, -0.01497330f, -0.04837736f, 0.00730730f, 0.03022262f, -0.02854581f, 0.01324271f, 
    -0.04385126f, 0.02126385f, -0.00328245f, 0.04083752f, 0.02566089f, -0.03784979f, -0.01170091f, 0.01082529f, 
    -0.03195997f, 0.02865933f, -0.05076068f, 0.02373425f, 0.02361065f, -0.05106949f, 0.03422628f, -0.02534632f, 
    0.03057834f, -0.00630462f, -0.00072719f, -0.01194223f, -0.02754150f, -0.01886913f, -0.04671759f, -0.01675518f, 
    -0.02739933f, -0.00822747f, -0.01784230f, -0.03139463f, -0.03204393f, -0.02246547f, -0.04721603f, -0.02609904f, 
    -0.00906707f, -0.05281346f, 0.02212321f, -0.02940539f, 0.01483967f, 0.04011955f, -0.01565994f, 0.02272500f, 
    -0.01862286f, -0.00343986f, -0.07721594f, -0.02502135f, -0.02807138f, -0.02152367f, -0.04893698f, 0.02436536f, 
    0.00723749f, -0.01121571f, 0.04193821f, -0.00529086f, -0.02650604f, -0.03603175f, -0.01280230f, -0.00165244f, 
    -0.00367615f, -0.01350577f, -0.03009644f, -0.03785179f, -0.04189688f, 0.01714585f, -0.06082081f, -0.04419697f, 
    -0.03435907f, 0.00766404f, 0.02954809f, 0.01801993f, -0.00049371f, -0.00289465f, -0.07253782f, -0.02448049f, 
    -0.00687092f, -0.05926094f, 0.03065417f, -0.01013335f, -0.07535548f, -0.02199855f, -0.05069628f, -0.00960103f, 
    -0.02918450f, -0.01015227f, -0.00617047f, -0.00960540f, -0.01133152f, 0.00487858f, -0.05986968f, -0.04801534f, 
    -0.02675142f, 0.02166303f, -0.03770600f, 0.02499256f, -0.00100020f, 0.04529365f, -0.03084197f, 0.00811343f, 
    -0.04921560f, -0.06527743f, -0.00435708f, 0.01356675f, -0.00661635f, -0.00208037f, 0.02779175f, -0.01748315f, 
    -0.03002197f, -0.01959120f, -0.02387659f, -0.01506860f, -0.02949478f, -0.02630735f, 0.02644507f, 0.02667125f, 
    -0.04088435f, 0.01367456f, 0.02248239f, -0.03281325f, 0.04476046f, -0.02379996f, 0.00935781f, 0.02719524f, 
    0.00448206f, -0.05420073f, -0.03428135f, -0.03659391f, 0.04470903f, 0.01190553f, -0.05867620f, 0.01665914f, 
    0.04812353f, 0.02461275f, -0.03560640f, 0.01608698f, -0.04277926f, -0.04665653f, -0.05225615f, -0.00284105f, 
    -0.04158396f, 0.02161968f, 0.01669203f, 0.00266212f, 0.01844951f, -0.06005848f, -0.00398910f, -0.00029830f, 
    0.03386683f, 0.00190703f, -0.02112957f, 0.01448276f, 0.00289044f, -0.00207385f, -0.00042516f, 0.00852819f, 
    -0.00223661f, 0.00991655f, -0.00114581f, 0.01879965f, -0.02823685f, -0.06739778f, -0.02820134f, -0.06313343f, 
    -0.01291254f, 0.01481732f, 0.02651214f, 0.02723719f, -0.03583189f, 0.02511159f, -0.05598243f, -0.04846649f, 
    0.00327870f, 0.01203647f, -0.06844440f, -0.01175381f, -0.06653068f, 0.03239198f, 0.03912224f, 0.02007220f, 
    -0.02377638f, -0.03082770f, 0.04236776f, -0.04523866f, -0.04349224f, 0.02150303f, 0.00398773f, 0.04194630f, 
    -0.03964973f, 0.00257555f, -0.05217347f, -0.01570243f, -0.01894522f, -0.01336309f, 0.03841408f, -0.02482463f, 
    -0.03402331f, -0.06771263f, -0.06609183f, -0.04164292f, 0.01046099f, -0.03218005f, -0.05922545f, -0.00635950f, 
    -0.06396835f, -0.00823321f, 0.02335060f, -0.04691374f, 0.01483593f, 0.01518806f, -0.03432600f, 0.04180666f, 
    -0.03278677f, 0.05042194f, 0.02291880f, -0.04654193f, 0.01482580f, -0.01849975f, 0.02141918f, -0.04151063f, 
    -0.02056535f, -0.01332546f, -0.05331682f, 0.03785832f, -0.07157234f, -0.00300610f, -0.01215941f, 0.00057797f, 
    0.00724948f, -0.00429777f, -0.00675870f, -0.02399744f, -0.00263798f, -0.05789885f, 0.00278267f, -0.01971124f, 
    -0.05649761f, 0.01267218f, 0.00772386f, 0.05493128f, -0.02563103f, -0.04179163f, -0.00113283f, -0.00812168f, 
    -0.01590343f, 0.00943160f, -0.01551534f, 0.03083869f, -0.00091527f, -0.03488328f, 0.02755386f, 0.04085008f, 
    0.01518961f, 0.04048616f, -0.01702978f, 0.03708721f, -0.00716319f, 0.01309518f, -0.01257083f, 0.00655596f, 
    0.00728713f, -0.06272599f, 0.04179274f, -0.06736220f, -0.02457887f, 0.02210409f, 0.00739851f, 0.03132084f, 
    0.01503455f, -0.06517493f, 0.00913537f, -0.03449557f, -0.01308550f, -0.00197439f, 0.00265229f, -0.03135349f, 
    -0.04619854f, -0.04359720f, 0.01392196f, -0.00591992f, 0.01841907f, -0.06138010f, -0.02095637f, 0.03788374f, 
    0.01931009f, 0.00312000f, 0.00381415f, 0.02670272f, 0.02775935f, 0.03952854f, 0.02462183f, 0.02090717f, 
    -0.01102587f, 0.01093221f, 0.02374776f, -0.00654535f, 0.02795620f, -0.07013660f, 0.02699313f, 0.04550873f, 
    0.03464109f, -0.04024651f, -0.04622197f, 0.05344473f, -0.04120989f, 0.02042881f, 0.02653868f, 0.00512292f, 
    -0.06075057f, -0.04034037f, -0.01657848f, 0.00524505f, 0.01425806f, 0.01448985f, 0.01252549f, 0.04442044f, 
    -0.02891134f, 0.00068323f, 0.02615007f, -0.01852510f, 0.00106665f, -0.06659032f, -0.02900119f, 0.03438953f, 
    -0.01493389f, 0.00102495f, 0.02324831f, 0.01677507f, 0.00191505f, -0.04095535f, -0.01516995f, 0.01805983f, 
    0.02480241f, 0.03345198f, -0.04789659f, -0.02748377f, -0.05884583f, -0.00788420f, -0.00067604f, -0.06452856f, 
    -0.06726700f, 0.02219428f, -0.04917097f, -0.04565112f, 0.03605625f, -0.00142444f, 0.02520756f, 0.02041673f, 
    0.01091356f, -0.00194488f, -0.06340879f, -0.01432560f, 0.01034454f, -0.00818543f, 0.01921911f, 0.00965606f, 
    -0.04203036f, -0.01639017f, -0.05528418f, 0.00961168f, 0.01271366f, -0.03872057f, -0.02012559f, 0.00769370f, 
    -0.01414082f, 0.01363484f, 0.02375928f, 0.01770067f, -0.01145196f, -0.01504776f, -0.05210348f, -0.02877850f, 
    -0.04198309f, -0.02568184f, 0.02357442f, -0.04273460f, -0.00058391f, -0.05024019f, -0.04778751f, -0.03747105f, 
    -0.04014039f, -0.03831137f, 0.00695261f, -0.01143132f, -0.05595013f, -0.04241090f, 0.02136859f, 0.04011384f, 
    -0.00614892f, 0.01756361f, -0.03329401f, -0.03897116f, -0.07130177f, -0.04324708f, -0.05328469f, 0.00954676f, 
    -0.03975922f, -0.06310578f, 0.00622970f, 0.02495095f, 0.01274634f, -0.01289312f, 0.01174990f, -0.01265415f, 
    0.00078043f, -0.05128236f, 0.02476525f, -0.04705921f, -0.04080727f, -0.02850251f, -0.06424778f, -0.05669768f, 
    -0.01704317f, 0.04023594f, -0.03050198f, 0.00000331f, -0.03246699f, -0.01406355f, -0.00282543f, 0.00761586f, 
    0.01201782f, -0.04448829f, -0.06113151f, -0.05788145f, 0.00035800f, 0.03714512f, 0.00260457f, -0.02278788f, 
    -0.28665972f, -0.09326685f, 0.09702692f, 0.12236131f, -0.11828675f, -0.03403318f, -0.03831392f, 0.18557429f, 
    -0.00742929f, -0.00504324f, -0.07031574f, 0.03612307f, 0.30685407f, 0.08590589f, 0.13735105f, 0.18305384f, 
    0.04960177f, 0.02824577f, -0.04201588f, -0.12092787f, 0.06439311f, 0.15774001f, 0.06448485f, 0.10763168f, 
    0.41161117f, -0.09779424f, 0.33526856f, -0.10869796f, -0.01917719f, -0.04948747f, -0.07330135f, 0.17568035f, 
    0.10397580f, 0.05068209f, 0.04865253f, -0.01187217f, 0.17489535f, 0.13472265f, 0.10908355f, 0.14760673f, 
    0.12418278f, -0.02586637f, 0.05388789f, -0.10034131f, -0.01368189f, 0.02821858f, 0.00643376f, 0.07154433f, 
    -0.16744098f, -0.23354843f, 0.31561932f, -0.44061553f, 0.28107792f, -0.04778653f, 0.19747937f, 0.07540539f, 
    0.13178396f, 0.07646500f, 0.01646713f, 0.17491141f, 0.31767407f, 0.29979968f, -0.04472649f, 0.02186711f, 
    0.03289060f, 0.13614918f, 0.10471476f, 0.15009323f, -0.01650992f, -0.10673124f, 0.16250761f, 0.07097579f, 
    0.05885513f, -0.20441912f, 0.12146807f, 0.05433811f, -0.14809348f, 0.04922459f, -0.09614289f, 0.00731875f, 
    0.00614157f, -0.03621707f, 0.16539750f, -0.04190534f, 0.15174833f, -0.37724367f, 0.16264947f, 0.29997256f, 
    0.06808919f, 0.10796396f, -0.12142226f, 0.30890381f, 0.06762965f, 0.24580035f, -0.05826911f, 0.08466339f, 
    0.04184747f, 0.03781633f, -0.04210832f, -0.03981141f, -0.24054992f, 0.11202317f, -0.00239708f, -0.00964076f, 
    0.16775799f, 0.00318233f, 0.02066529f, 0.11725652f, 0.24255943f, -0.33917084f, -0.21159372f, 0.00758329f, 
    0.23185526f, 0.06929468f, 0.18643290f, -0.04546763f, 0.22225747f, 0.05244575f, 0.06974942f, 0.10246161f, 
    -0.01545341f, 0.04405426f, 0.25308004f, 0.07139581f, -0.08885062f, -0.07347602f, 0.15278311f, -0.08206517f, 
    -0.05159049f, -0.02438476f, -0.09165651f, -0.03330657f, -0.09038793f, -0.02484381f, -0.23921657f, -0.13168558f, 
    0.00576285f, 0.00856232f, 0.08923922f, 0.00320731f, 0.01910572f, -0.13656329f, 0.01404976f, -0.02002145f, 
    -0.02498274f, -0.19997951f, -0.15526728f, -0.17561704f, 0.19997860f, -0.02054050f, 0.01363725f, -0.09155922f, 
    -0.11287599f, 0.04709231f, -0.15121298f, -0.06801245f, -0.13467160f, 0.12302583f, 0.31662232f, 0.04681869f, 
    0.04913355f, 0.00157076f, 0.03949662f, 0.06246406f, 0.02452068f, 0.08089495f, 0.10048506f, -0.06205820f, 
    -0.01666510f, -0.22995314f, -0.20951836f, -0.00554850f, -0.04744017f, 0.18272768f, -0.08318859f, -0.07867390f, 
    0.15673029f, 0.02287827f, -0.02422868f, -0.11518903f, 0.22775659f, -0.36472526f, -0.00681382f, -0.11997817f, 
    0.03332040f, -0.11588733f, 0.17757683f, 0.02395381f, 0.05011869f, 0.00995047f, -0.12846176f, 0.09036455f, 
    0.67181993f, 0.26671278f, -0.13039944f, -0.03881866f, 0.22752890f, 0.01471835f, 0.02124677f, -0.04675094f, 
    -0.05940561f, 0.04815747f, -0.00684900f, 0.18724115f, 0.87815815f, -0.04592846f, -0.03765596f, -0.01552310f, 
    0.11819887f, 0.11150370f, 0.08740071f, 0.11943726f, 0.01421205f, 0.10541656f, -0.09902819f, 0.18194398f, 
    -0.14941290f, -0.17299551f, -0.31578213f, 0.10139880f, -0.09293810f, 0.15858443f, 0.05083812f, -0.16820337f, 
    -0.11859503f, 0.23994952f, -0.03816916f, 0.07842127f, -0.16048512f, 0.24002084f, -0.47834939f, -0.18734615f, 
    0.00702443f, 0.20978153f, 0.19493723f, 0.06556100f, 0.15277030f, -0.01750519f, 0.05309340f, 0.00915802f, 
    -0.15928295f, 0.28863749f, -0.12537141f, -0.39067739f, 0.21118219f, -0.02016585f, 0.11389057f, 0.10466342f, 
    -0.08603540f, 0.19392282f, 0.04605640f, 0.03703913f, 0.08120161f, -0.16024502f, -0.09110374f, -0.32583314f, 
    -0.10224349f, -0.01980980f, 0.00010920f, 0.04301668f, 0.08793865f, 0.04115988f, -0.06987585f, 0.06019909f, 
    0.23444483f, -0.08907799f, 0.07279874f, -0.03375779f, -0.02409253f, 0.03313935f, 0.14540866f, -0.09135901f, 
    0.10250415f, -0.15011752f, 0.06574845f, 0.11460761f, -0.01042472f, 0.20359556f, -0.00566574f, -0.04660309f, 
    0.12167376f, -0.09493297f, -0.14448237f, -0.00140556f, 0.18071988f, 0.03272522f, -0.11989365f, 0.07020589f, 
    0.13189168f, 0.21691619f, 0.21316774f, -0.02042082f, 0.08791170f, -0.09637896f, -0.05209863f, 0.11430469f, 
    0.11635807f, 0.09621621f, -0.00756217f, 0.22229351f, 0.21776994f, -0.24819137f, 0.17221372f, 0.22909033f, 
    0.02708118f, -0.11143603f, 0.10654187f, 0.11752315f, 0.05572087f, 0.01301971f, 0.03376963f, 0.15785411f, 
    -0.09702145f, -0.18383646f, 0.02248606f, 0.07319183f, -0.10510649f, -0.01915386f, -0.10156911f, 0.06495907f, 
    0.01106302f, 0.07333194f, -0.05103434f, 0.05364660f, 0.14760360f, 0.14117749f, 0.06034649f, -0.01221863f, 
    0.12959336f, -0.04592708f, -0.02401410f, 0.06223994f, 0.27349749f, -0.05100411f, -0.26767424f, -0.06318276f, 
    0.52058250f, -0.16303881f, -0.04497993f, 0.20750895f, 0.28168827f, -0.08697867f, 0.02073123f, 0.06358772f, 
    0.08246471f, 0.08816417f, 0.15407537f, 0.02738846f, 0.66602606f, 0.18467288f, 0.13971432f, 0.04655800f, 
    -0.05066525f, 0.01013463f, 0.15724286f, -0.05211983f, 0.03668610f, 0.07745740f, 0.18453953f, 0.22274584f, 
    0.50725460f, 0.50364590f, 0.02937324f, 0.09951465f, 0.04683605f, -0.20045958f, 0.00162365f, -0.19577716f, 
    0.07355458f, 0.02816826f, -0.03140753f, 0.05117850f, 0.52703083f, 0.24029656f, 0.09523237f, -0.01116982f, 
    -0.04330649f, 0.01671619f, 0.09885675f, -0.15096849f, -0.00281447f, -0.00695242f, 0.13692963f, 0.09663860f, 
    -0.10659766f, -0.20480105f, -0.31170431f, -0.18286633f, 0.04042693f, 0.00783489f, 0.00602269f, 0.11796984f, 
    -0.05314286f, 0.09567481f, 0.19587894f, -0.04307874f, 0.33787027f, -0.01456688f, 0.06788701f, -0.05816373f, 
    -0.04150976f, -0.15717943f, -0.04795666f, 0.10095913f, -0.01408945f, -0.03159074f, 0.08833482f, -0.12513646f, 
    0.09090445f, 0.03337093f, -0.11156084f, 0.50382483f, 0.12114506f, 0.19290102f, -0.09396777f, -0.21323431f, 
    -0.04553319f, -0.08997215f, -0.05769291f, 0.03750359f, -0.24678038f, -0.24868399f, -0.16702534f, -0.12740095f, 
    -0.12963840f, -0.06620464f, -0.10358209f, 0.09039355f, 0.04190423f, -0.04001637f, -0.01940995f, -0.03666157f, 
    0.22252744f, 0.44500414f, -0.55190754f, 0.36124545f, 0.05448272f, 0.01998592f, 0.13645640f, -0.02317444f, 
    -0.19139582f, 0.10998645f, 0.10116573f, 0.06421470f, 0.24074209f, -0.00306427f, -0.10437831f, 0.11100861f, 
    -0.05060482f, -0.13100836f, 0.07987693f, -0.10813488f, -0.01276227f, -0.06914318f, -0.19662347f, -0.26684636f, 
    -0.23930885f, -0.22438008f, -0.26195109f, -0.37191972f, 0.11048593f, -0.15874642f, -0.00883028f, 0.05884843f, 
    -0.07476825f, 0.05687288f, -0.01320151f, 0.06812193f, 0.24703024f, 0.19516587f, -0.13735071f, 0.15363263f, 
    0.15297790f, -0.06903817f, 0.07508367f, -0.18304045f, -0.02449482f, 0.02676349f, -0.06467032f, 0.04443641f, 
    -0.10393468f, -0.03423842f, 0.25962207f, -0.03469044f, 0.01138361f, 0.07100713f, 0.13536887f, 0.27162370f, 
    0.00583008f, 0.04231223f, 0.05932238f, 0.01414312f, -0.12791221f, 0.04324803f, 0.06175319f, 0.11779483f, 
    0.04703797f, 0.05370799f, 0.10104374f, -0.00659573f, 0.01719181f, -0.08834960f, -0.26805663f, -0.19618084f, 
    0.24050947f, 0.05075174f, -0.18556339f, -0.12092247f, 0.01886028f, 0.12293296f, -0.16405120f, 0.04123727f, 
    -0.11223143f, -0.39655879f, -0.24093983f, -0.19321619f, -0.04753070f, 0.21949619f, 0.14898789f, -0.00592700f, 
    -0.10805807f, 0.01255584f, -0.03819170f, -0.08563920f, -0.12460949f, 0.23727675f, 0.04417237f, 0.20897365f, 
    -0.30635926f, 0.24314281f, 0.14626314f, -0.10380200f, -0.04079860f, 0.05985842f, 0.17504920f, 0.01049171f, 
    0.29790288f, -0.21736851f, 0.34428388f, 0.19172101f, 0.34264958f, -0.11791757f, -0.12560007f, -0.09839743f, 
    0.07561759f, 0.11619592f, -0.07751887f, -0.00789510f, -0.01405998f, 0.08432341f, 0.10410856f, 0.28427887f, 
    0.36567348f, 0.19168276f, 0.11704811f, -0.08104965f, -0.00466965f, 0.07700898f, 0.05883531f, -0.10101699f, 
    -0.05224771f, -0.05091440f, -0.10883924f, 0.18736678f, -0.41549277f, 0.09363832f, -0.02731426f, 0.11033632f, 
    0.06496492f, 0.04422344f, 0.15424214f, -0.12284420f, -0.18478802f, -0.03177847f, 0.18673357f, 0.06739712f, 
    -0.04945244f, 0.02672705f, -0.11169160f, 0.21073696f, 0.03569339f, 0.08862982f, -0.13089556f, -0.12831162f, 
    -0.01274650f, 0.10171112f, 0.00655565f, -0.23947608f, 0.17753987f, -0.09407147f, 0.08689287f, 0.04648668f, 
    0.08118926f, -0.00689397f, -0.05892449f, 0.13095109f, -0.14231361f, -0.12524046f, -0.03573667f, 0.11365311f, 
    0.61140454f, 0.01208594f, 0.00107162f, -0.14749739f, 0.04812277f, 0.02823676f, 0.03824577f, 0.17550452f, 
    0.13636440f, 0.07390027f, 0.05838172f, 0.18178236f, 0.09425543f, 0.13493694f, 0.26648304f, 0.19665840f, 
    -0.10730403f, -0.08657391f, 0.01273476f, 0.05766690f, -0.05314614f, 0.04429013f, -0.03091682f, 0.09164914f, 
    0.00599614f, 0.04269931f, -0.11375523f, 0.16592830f, 0.00414651f, -0.06342647f, -0.07664370f, 0.05025726f, 
    0.14048694f, -0.21394874f, -0.02941228f, -0.23819104f, 0.14378773f, -0.13617833f, 0.07275160f, 0.16544135f, 
    -0.10552864f, -0.20014577f, 0.09138449f, 0.09416556f, -0.02995173f, 0.05297884f, 0.06212130f, 0.02716902f, 
    -0.09810245f, 0.13139322f, -0.05721630f, -0.04209792f, 0.11376685f, 0.08114200f, -0.05183822f, 0.03832619f, 
    0.10419091f, 0.03147286f, -0.00290834f, -0.16268018f, 0.22158669f, 0.10833722f, -0.07832414f, -0.01064036f, 
    -0.09740788f, 0.26017895f, -0.01470546f, 0.01593227f, 0.22737281f, -0.04913298f, 0.19058688f, -0.02465840f, 
    0.21672708f, -0.17580111f, -0.19327007f, 0.01845178f, -0.06761058f, 0.01052548f, -0.11425366f, -0.28690052f, 
    0.08304286f, -0.08417714f, -0.07554890f, -0.19032963f, -0.01629088f, -0.05599501f, -0.03328159f, -0.17868479f, 
    -0.09610077f, 0.24742654f, -0.00324241f, 0.12937093f, 0.19125009f, 0.09076422f, 0.11993205f, 0.08726947f, 
    0.22910871f, 0.03045949f, 0.25699067f, -0.00109712f, -0.00253120f, 0.08185217f, 0.03449620f, 0.22695045f, 
    0.07071427f, -0.18171580f, -0.02462935f, -0.34211710f, 0.14625992f, -0.03874324f, 0.09713447f, 0.19617568f, 
    -0.00692115f, 0.03176995f, -0.10085916f, 0.04705761f, 0.05313634f, -0.07569917f, 0.15531993f, 0.07346901f, 
    0.12250767f, 0.13866363f, 0.13158399f, -0.08534288f, -0.10255057f, 0.02362985f, -0.04652077f, -0.09065863f, 
    -0.07505661f, 0.05260921f, 0.01420421f, -0.19551520f, 0.27248853f, -0.01022602f, -0.12731245f, -0.04196865f, 
    -0.03595790f, -0.01989124f, -0.19944867f, -0.09056942f, -0.08184280f, -0.01816410f, 0.03832360f, 0.00482237f, 
    0.18033907f, -0.05760812f, -0.09279114f, 0.16855437f, -0.02957287f, 0.11896525f, 0.06469569f, 0.18218040f, 
    0.13104993f, 0.08058462f, -0.08280188f, 0.00970448f, 0.11907059f, 0.01401587f, -0.00107699f, -0.17160505f, 
    0.00514566f, -0.07778467f, 0.02062466f, 0.03484748f, 0.09639484f, 0.23554789f, -0.05121889f, 0.07120018f, 
    0.06871650f, 0.05587820f, -0.05382915f, -0.22602057f, 0.04484224f, -0.03241633f, -0.10392043f, -0.18310285f, 
    -0.04432213f, 0.02667763f, -0.01142931f, 0.06716754f, -0.49252650f, -0.08310162f, -0.15214944f, -0.03440425f, 
    0.22487827f, 0.07990263f, 0.00328369f, -0.18887846f, 0.11835419f, -0.02379618f, 0.04294064f, 0.13135585f, 
    -0.41024619f, 0.18813317f, -0.05743755f, -0.49977523f, 0.03270753f, -0.11175143f, -0.07947653f, -0.03840814f, 
    -0.03598236f, 0.00255448f, 0.16649763f, 0.01308743f, 0.11734380f, 0.19737789f, 0.17276876f, 0.08050604f, 
    -0.03679762f, 0.02332312f, 0.19770996f, -0.13030556f, 0.04471911f, 0.00098016f, 0.01405273f, -0.07028888f, 
    -0.13540266f, 0.12687942f, 0.26286760f, 0.15024859f, -0.05339165f, -0.01065059f, 0.01973562f, 0.03007650f, 
    0.24318363f, 0.08676098f, 0.09437408f, 0.09410749f, 0.48038736f, -0.11254726f, 0.03600745f, -0.24306920f, 
    0.04958337f, 0.07345051f, 0.09603321f, -0.02857687f, -0.20168081f, 0.01617333f, 0.13048770f, 0.10769961f, 
    -0.26437294f, -0.02408298f, 0.34193999f, -0.09423089f, -0.07985891f, 0.08216783f, -0.13567944f, -0.11766975f, 
    0.09235121f, -0.05741083f, -0.00115852f, -0.05724471f, -0.30216277f, -0.13409936f, 0.10881503f, -0.29803815f, 
    0.20232372f, -0.14056244f, 0.00916766f, 0.00802770f, 0.12070546f, 0.10698936f, 0.01848111f, 0.06487101f, 
    0.56764168f, -0.09500368f, -0.18834399f, -0.15382430f, 0.02460072f, -0.10490705f, 0.04769690f, -0.10079018f, 
    0.04887360f, -0.05355990f, 0.11688405f, -0.09317865f, 0.28288719f, -0.08759039f, -0.14057903f, 0.02377722f, 
    0.24740420f, -0.06507029f, -0.00526798f, 0.04245388f, -0.09629442f, 0.02262357f, -0.01749559f, -0.02429798f, 
    -0.15298398f, 0.06575702f, 0.07182413f, 0.08457380f, 0.00662916f, -0.25008386f, 0.03059912f, 0.04973574f, 
    0.04136362f, 0.14233387f, 0.07231153f, 0.13145843f, 0.08842181f, 0.09847359f, -0.10853632f, 0.19780436f, 
    0.00202578f, -0.00301944f, 0.19560041f, 0.05746686f, 0.19900270f, -0.03332198f, 0.02455532f, 0.02671986f, 
    0.01205876f, -0.17896241f, -0.31423968f, 0.18344353f, 0.01558700f, 0.07305892f, -0.07954495f, -0.01368447f, 
    -0.08516081f, 0.13224390f, -0.07537825f, 0.11882873f, 0.14554781f, 0.00557343f, -0.08136163f, 0.12819414f, 
    0.08786473f, 0.06054679f, 0.05250470f, 0.06593769f, 0.03819913f, 0.05202643f, 0.08414293f, -0.18294483f, 
    -0.37468871f, -0.06863850f, 0.08337408f, -0.04875791f, -0.06983907f, 0.04606321f, -0.13966273f, -0.00998667f, 
    0.02904801f, -0.06428409f, -0.03071725f, -0.03543114f, 0.38742939f, -0.09899363f, 0.17224577f, 0.08349141f, 
    0.08574678f, -0.06415725f, 0.11760528f, 0.29998291f, 0.26388898f, -0.01989839f, -0.14316542f, 0.06335793f, 
    0.22711641f, 0.22416914f, 0.03886672f, -0.23403145f, 0.16949403f, -0.04615874f, 0.06266252f, 0.07857474f, 
    -0.04196302f, -0.03213437f, 0.15734288f, 0.23752813f, 0.08675159f, -0.08446463f, 0.00247940f, -0.13438973f, 
    0.03477653f, -0.06630960f, 0.06276377f, -0.02811347f, 0.06371807f, 0.12385089f, 0.04306302f, -0.06069368f, 
    -0.47418150f, 0.12587523f, 0.11964878f, 0.20046285f, 0.00240222f, -0.01184926f, -0.00997302f, 0.02425807f, 
    0.00938556f, -0.03995802f, 0.02614822f, -0.03832512f, 0.54789954f, -0.04429634f, -0.16011624f, -0.01011325f, 
    0.27229941f, 0.11178066f, 0.05080260f, 0.02640122f, -0.01585691f, 0.10322476f, 0.08193587f, 0.05382305f, 
    0.21513528f, 0.11583567f, 0.05409482f, -0.06338532f, 0.01335876f, 0.14138943f, -0.00717970f, -0.05106888f, 
    -0.00194909f, 0.30176571f, -0.00498106f, 0.11616024f, -0.07295301f, -0.00669002f, -0.11674050f, -0.09686583f, 
    0.04580618f, -0.00856510f, -0.14056973f, -0.17963755f, -0.00939217f, 0.08133426f, 0.02455932f, -0.09431109f, 
    0.19739725f, -0.07135645f, 0.26196507f, -0.00973691f, -0.04528521f, -0.14250617f, 0.12793583f, 0.09301346f, 
    0.23455161f, 0.02507485f, -0.00030246f, 0.04617168f, -0.12125678f, 0.06946725f, 0.10419085f, 0.13741325f, 
    0.14466855f, 0.10359899f, -0.00458765f, 0.12062091f, -0.07899715f, 0.14435355f, 0.00793120f, 0.02418019f, 
    -0.17439570f, 0.21866393f, -0.03272285f, 0.01083240f, 0.13182873f, 0.07715777f, 0.13592471f, 0.04444260f, 
    -0.20116407f, 0.03642703f, 0.05909586f, 0.08187002f, 0.13721356f, 0.03504943f, -0.11128701f, -0.22844659f, 
    0.11159585f, -0.11788286f, -0.00731749f, -0.08368520f, 0.02078650f, 0.01241464f, 0.04335107f, 0.05929440f, 
    -0.18792416f, 0.02117700f, -0.06706439f, -0.12739019f, 0.13394947f, -0.06239390f, 0.15500322f, -0.12231575f, 
    0.05328704f, -0.02768516f, -0.01589714f, 0.11605282f, -0.23880528f, -0.17264897f, 0.08406933f, -0.04266839f, 
    0.00096315f, 0.07688544f, 0.03800377f, -0.18771942f, -0.10804677f, 0.00534868f, 0.01160403f, 0.22595650f, 
    0.04307819f, 0.04964871f, -0.05543369f, 0.08299458f, 0.16838202f, 0.09075475f, -0.18010782f, 0.03235810f, 
    -0.01167801f, 0.00578633f, 0.05606085f, 0.20708726f, -0.17703253f, -0.17223147f, -0.09343575f, -0.06760757f, 
    0.17320354f, 0.06523471f, 0.02915635f, -0.04810847f, -0.01969873f, 0.00585158f, 0.10245078f, 0.02349599f, 
    0.15143611f, 0.20400450f, -0.00359488f, 0.13374001f, 0.19422621f, 0.12810843f, 0.01435987f, -0.11626870f, 
    -0.11760372f, -0.08301300f, 0.09697357f, 0.13028759f, 0.00565667f, -0.10887316f, -0.04476636f, 0.27717504f, 
    0.01179588f, 0.11773993f, -0.01437863f, -0.14131887f, -0.01514146f, -0.05371270f, 0.13807513f, -0.02920199f, 
    0.05150900f, 0.04298374f, 0.01896888f, -0.03959650f, 0.04867434f, 0.04135627f, -0.04837498f, -0.03240112f, 
    0.02858369f, 0.00833740f, -0.05624640f, -0.02944140f, 0.03712643f, -0.03226016f, -0.01898577f, -0.04102620f, 
    0.00596453f, -0.06298041f, 0.01846989f, -0.00242361f, -0.05642994f, -0.03519229f, 0.01675423f, -0.01156167f, 
    -0.01594336f, -0.01852175f, 0.00077309f, 0.02429540f, 0.04046459f, -0.00011685f, -0.00561297f, -0.01127707f, 
    0.02537380f, 0.04263605f, -0.03613114f, 0.00022076f, -0.01933838f, -0.01129004f, 0.02996590f, -0.05267282f, 
    -0.02031478f, -0.05032443f, 0.01849086f, 0.00199247f, 0.02858204f, -0.04101592f, 0.00206899f, -0.00077476f, 
    -0.04777346f, -0.03423459f, -0.03014931f, 0.00864839f, -0.01840088f, -0.00048787f, -0.05370789f, -0.05138017f, 
    0.02070085f, 0.00230151f, 0.03988123f, -0.03941161f, -0.04662239f, 0.04094383f, -0.05776067f, -0.04645023f, 
    -0.03526197f, 0.01663802f, 0.02480054f, -0.02320811f, 0.01653061f, 0.00201236f, -0.02277026f, 0.03143980f, 
    -0.02405629f, 0.00142835f, -0.02816149f, 0.01412482f, 0.03030002f, -0.01821349f, -0.00976081f, -0.00163926f, 
    0.03776791f, 0.03772775f, -0.03782231f, -0.04907466f, 0.04284929f, 0.04879027f, 0.02982960f, -0.02585104f, 
    -0.02428124f, 0.03280098f, -0.04209125f, -0.04972305f, -0.03328118f, -0.04531446f, -0.02505589f, 0.00496826f, 
    -0.01814988f, 0.04370419f, -0.02955455f, -0.00674059f, 0.01866766f, 0.04230880f, -0.01097930f, -0.02572596f, 
    0.03413562f, -0.04504908f, 0.00578475f, 0.00123773f, -0.00743043f, 0.04592978f, -0.03940327f, -0.00435993f, 
    -0.01067190f, -0.00426509f, -0.04483190f, 0.03335305f, 0.00137885f, -0.01746493f, -0.01035974f, -0.01097019f, 
    -0.00325019f, 0.01551928f, -0.02946675f, -0.01027903f, -0.02802978f, 0.02406728f, 0.03036053f, 0.01179963f, 
    -0.04280147f, -0.01246899f, 0.01651338f, -0.04590430f, -0.01721535f, 0.03109990f, -0.04560875f, -0.02111680f, 
    -0.03612832f, -0.03207044f, 0.03615942f, 0.00865815f, -0.04429112f, -0.02065588f, 0.04411793f, -0.03977308f, 
    0.01364834f, -0.03088027f, -0.04624696f, 0.01716525f, -0.01846713f, -0.02345009f, -0.02478408f, 0.04288425f, 
    0.00295817f, -0.04676795f, 0.04355861f, -0.00302006f, 0.01155822f, 0.01405661f, -0.04783687f, -0.04236324f, 
    -0.03941273f, 0.00315949f, -0.03833128f, 0.03859138f, -0.04588566f, -0.00321412f, -0.01018728f, 0.04714124f, 
    0.01965206f, -0.02860005f, -0.02717805f, -0.04740383f, 0.02964664f, -0.00295833f, -0.02525759f, 0.04731749f, 
    0.02267219f, -0.00228399f, 0.00405404f, -0.02163122f, -0.00907782f, -0.00598800f, -0.01546962f, -0.01919537f, 
    -0.03232586f, 0.02383124f, -0.00187592f, 0.04202774f, 0.00747139f, 0.03197027f, -0.03072647f, -0.04439984f, 
    -0.05261596f, -0.03713510f, -0.05091462f, 0.00673032f, -0.00320962f, 0.01506407f, -0.00414380f, -0.04636449f, 
    -0.04045440f, 0.02965271f, -0.02440560f, 0.01398387f, -0.04785327f, -0.05079520f, 0.01150738f, -0.04723062f, 
    -0.02439768f, -0.00742148f, 0.02867364f, 0.03784981f, -0.04032758f, 0.02414125f, 0.04089821f, -0.02122915f, 
    0.00034044f, 0.03699886f, -0.03481386f, -0.02333646f, -0.02879763f, -0.05573192f, -0.04707598f, 0.03483607f, 
    -0.01599892f, -0.02009244f, 0.02004009f, 0.00546797f, 0.03541927f, 0.00329136f, -0.04665418f, 0.01374538f, 
    -0.02163840f, 0.01072006f, -0.03870288f, -0.02932407f, 0.02202236f, -0.01427723f, 0.04003081f, -0.01145687f, 
    -0.04587019f, 0.03952469f, 0.02104544f, 0.00637541f, 0.01184789f, 0.00546689f, 0.00511738f, -0.04255124f, 
    -0.02766440f, 0.00764355f, -0.03945234f, -0.02233925f, -0.06176318f, -0.02503336f, 0.01744198f, 0.03698669f, 
    0.04940704f, -0.01077673f, -0.03211307f, 0.01324571f, -0.03428785f, -0.05102121f, 0.01170340f, 0.00317651f, 
    -0.00185656f, -0.04348477f, -0.05509916f, 0.03261166f, 0.00636102f, 0.03071054f, 0.03432083f, -0.05393851f, 
    0.02861050f, -0.01177794f, -0.01252912f, 0.03865791f, 0.00468188f, -0.01565844f, -0.02440994f, 0.03059332f, 
    0.03865276f, 0.02176209f, 0.04054468f, 0.04073945f, 0.04136217f, 0.03552165f, -0.04697153f, -0.02119455f, 
    0.01043544f, 0.01491995f, 0.03245519f, 0.03040565f, 0.00298515f, -0.00238448f, 0.03204915f, 0.00711165f, 
    -0.03700741f, 0.02638057f, 0.03110495f, 0.01925880f, 0.03296356f, 0.04242656f, -0.03243191f, 0.03948747f, 
    0.04386021f, 0.00642577f, -0.01273620f, -0.00429689f, -0.04648849f, 0.04567287f, -0.01107097f, -0.02304207f, 
    0.02203909f, -0.00592050f, 0.02952906f, -0.02195768f, -0.05343465f, 0.03706609f, -0.02924112f, 0.04068345f, 
    -0.05606809f, -0.04970234f, -0.00961157f, 0.01865031f, -0.02954319f, -0.04615605f, -0.03178596f, 0.03549488f, 
    0.02772977f, -0.00654311f, 0.00569471f, -0.01303549f, -0.04834343f, 0.01306423f, 0.02941859f, -0.03087221f, 
    -0.03697000f, 0.02427941f, 0.03788001f, -0.02967000f, -0.00312901f, -0.00329696f, -0.04124865f, 0.03205557f, 
    0.01196267f, 0.01627547f, 0.03132673f, 0.00781582f, 0.02899950f, 0.03242216f, -0.01229324f, -0.00962225f, 
    -0.04522093f, -0.03080964f, -0.04746014f, 0.02640942f, 0.00573908f, 0.04918090f, 0.03370192f, 0.04590224f, 
    0.00777007f, -0.01610221f, 0.00259083f, -0.01770838f, 0.01562478f, 0.03101202f, -0.00172807f, 0.00858587f, 
    -0.04698577f, -0.03508575f, -0.01678825f, 0.01491573f, -0.03212145f, 0.03030837f, 0.00509427f, -0.02586408f, 
    -0.02533766f, 0.01018378f, 0.03174361f, -0.03816694f, 0.00825300f, 0.03760384f, 0.03555693f, -0.03755331f, 
    0.54476142f, 0.08350869f, 0.05306514f, 0.30763724f, 0.01596045f, 0.04350560f, 0.07072994f, -0.05358009f, 
    0.13149464f, 0.04243791f, 0.20108558f, -0.06263618f, 0.22271703f, 0.30678824f, 0.05531935f, 0.17408262f, 
    0.07104065f, -0.01477414f, -0.03094098f, 0.11521725f, 0.12006347f, -0.13110252f, -0.03891796f, -0.05648058f, 
    0.05217457f, 0.17851007f, 0.14838864f, 0.08964457f, -0.07972682f, 0.13435264f, -0.11329795f, 0.00455059f, 
    -0.17167959f, -0.02266454f, -0.08440084f, 0.00958027f, 0.43146008f, 0.38524061f, 0.17473951f, -0.03799281f, 
    -0.07940458f, -0.03265921f, -0.04247432f, 0.06626776f, -0.02890744f, 0.04191406f, 0.00554794f, -0.02275661f, 
    0.34432328f, 0.04182373f, -0.00401076f, -0.23236144f, -0.14138167f, 0.05647872f, 0.01051211f, -0.04193364f, 
    -0.09920810f, 0.01498488f, 0.08999766f, 0.10889802f, -0.07298242f, -0.25226167f, -0.04646546f, 0.06125212f, 
    0.07799014f, -0.01810013f, -0.10873432f, 0.01932484f, 0.16628121f, 0.08455896f, 0.01983485f, 0.03629104f, 
    0.24804671f, 0.37788463f, -0.10343483f, 0.37091765f, 0.06974973f, 0.06105567f, 0.00071814f, 0.03269522f, 
    0.01257344f, 0.05899702f, -0.03446774f, 0.07434600f, -0.04391199f, 0.40576079f, 0.04446785f, 0.06476353f, 
    -0.12161396f, 0.00612252f, -0.01654605f, -0.03237695f, -0.15170409f, 0.01644813f, -0.00556669f, 0.02439648f, 
    0.26887661f, 0.15630354f, 0.06012020f, 0.02263770f, 0.26542398f, 0.10237087f, -0.01791701f, -0.05549124f, 
    -0.07726145f, 0.05593645f, -0.00173225f, 0.16603152f, -0.23138013f, 0.39309004f, 0.27816260f, -0.38538662f, 
    -0.02984452f, -0.05284868f, -0.02740662f, -0.13508579f, 0.05862152f, 0.01661788f, 0.00391418f, 0.01650618f, 
    0.12998703f, 0.13630717f, 0.09045672f, -0.08280740f, -0.02020858f, 0.21436498f, -0.22061737f, -0.03603794f, 
    -0.19710667f, -0.03638499f, -0.12449247f, -0.10204497f, 0.09651572f, -0.12280566f, -0.16138051f, 0.23802316f, 
    0.05107602f, -0.06497966f, 0.04289819f, -0.11367638f, 0.00968125f, 0.11570630f, -0.16644599f, 0.10605171f, 
    0.24352533f, 0.04145216f, -0.31066445f, 0.12236755f, -0.06347391f, 0.03443956f, -0.11783885f, 0.04253906f, 
    0.10839950f, 0.15536170f, 0.03818411f, 0.14630683f, 0.27080926f, 0.25814667f, -0.11338777f, -0.05837838f, 
    -0.17353876f, -0.04184340f, 0.00500297f, -0.05210847f, -0.14562911f, -0.04599136f, 0.15457927f, -0.06047278f, 
    -0.00184657f, -0.15703335f, 0.36685684f, -0.18513395f, 0.14411005f, -0.04448972f, 0.14967406f, -0.05051824f, 
    0.07088243f, -0.12293372f, 0.09158566f, -0.13070710f, 0.21419320f, 0.17854890f, 0.06546228f, -0.14244807f, 
    0.08174382f, 0.05209865f, 0.04539056f, -0.02065537f, -0.11189169f, 0.02457875f, 0.10804873f, 0.04425287f, 
    0.09466528f, -0.12397844f, -0.02292015f, 0.20035020f, -0.15792412f, -0.24228972f, -0.08304561f, -0.13352896f, 
    0.26768667f, 0.02182128f, -0.01864035f, 0.04204005f, -0.29414913f, -0.05201657f, -0.02240955f, -0.10946767f, 
    0.10206241f, 0.08779924f, -0.00560780f, -0.06266558f, 0.13175178f, 0.08145802f, 0.00729388f, 0.08530951f, 
    -0.12225821f, -0.00821138f, 0.21942095f, -0.12811059f, 0.13493656f, 0.07184107f, 0.10847640f, -0.08229669f, 
    0.00658437f, -0.12978904f, 0.13076551f, 0.12944286f, -0.05603601f, -0.47765237f, 0.06322720f, 0.07679963f, 
    0.06407650f, 0.01527641f, -0.08634647f, -0.06501176f, -0.21840133f, 0.09327429f, -0.06451515f, -0.01970385f, 
    -0.29543841f, -0.15420930f, 0.01045378f, 0.00380868f, -0.07382783f, 0.03541005f, 0.03371227f, -0.06036932f, 
    -0.01055564f, -0.09155340f, 0.02225000f, -0.07650189f, -0.20998605f, -0.03010353f, 0.08788858f, -0.01552082f, 
    0.11298341f, 0.08575952f, 0.15969481f, 0.13911234f, -0.07435942f, 0.16302882f, 0.00326836f, 0.13635823f, 
    -0.16960800f, 0.02208841f, 0.05723723f, -0.12568501f, -0.00676228f, 0.23228517f, -0.11527968f, 0.21194066f, 
    0.01592476f, 0.05052176f, -0.16033494f, -0.26389873f, -0.14173990f, -0.03748273f, 0.22346112f, -0.37738231f, 
    -0.09048746f, -0.09064414f, 0.04255079f, 0.03764179f, -0.06060325f, -0.00469157f, 0.00251256f, 0.10010599f, 
    0.38016918f, 0.34556836f, 0.18396765f, -0.15708873f, 0.07071044f, 0.08474649f, 0.07490075f, 0.00440284f, 
    -0.13158943f, -0.12968478f, -0.01561952f, -0.14681813f, 0.40856072f, 0.33249700f, 0.14280909f, 0.29248583f, 
    -0.07497486f, -0.09554482f, -0.07196576f, 0.06299095f, -0.04586182f, 0.12212728f, 0.00089978f, -0.05522503f, 
    0.03420121f, -0.07980610f, -0.13876002f, -0.02768973f, 0.00275505f, -0.03941476f, 0.12001991f, 0.07547333f, 
    -0.10276656f, 0.00937751f, 0.13835366f, 0.06616224f, 0.22660564f, 0.27553314f, 0.03758566f, -0.11273067f, 
    -0.03097360f, 0.01560846f, 0.09179378f, 0.05774878f, 0.05006669f, 0.05318113f, 0.00682811f, 0.13464639f, 
    0.00316793f, 0.00398820f, 0.12997010f, -0.23165756f, 0.03157894f, -0.14258796f, 0.03857835f, 0.01266859f, 
    -0.06418919f, -0.12181478f, -0.05564640f, -0.05804829f, 0.03895995f, 0.16435792f, 0.17003329f, 0.20835710f, 
    -0.00516740f, 0.03460139f, 0.00425443f, -0.06416521f, -0.18577410f, 0.00857431f, -0.17117086f, -0.05388108f, 
    0.19151543f, 0.20375910f, 0.22453348f, -0.06486242f, -0.00741041f, 0.08794298f, -0.02181836f, 0.18808015f, 
    0.00980557f, -0.05497447f, -0.01154214f, -0.18990466f, 0.47441599f, 0.45676640f, 0.15961280f, -0.07458279f, 
    -0.07579262f, 0.08703157f, 0.12533481f, 0.09055985f, -0.04938566f, 0.22935447f, -0.04046844f, 0.03484800f, 
    0.01617340f, 0.02901183f, 0.25377476f, -0.15375158f, 0.07425658f, 0.01094860f, 0.03630043f, 0.08694665f, 
    -0.03487089f, 0.11853809f, -0.11721273f, 0.18853033f, 0.18948598f, 0.23697555f, 0.20062621f, 0.01226960f, 
    0.01838032f, -0.06011621f, 0.01117095f, 0.09492358f, 0.11912072f, 0.14819361f, 0.13082977f, -0.17650467f, 
    0.24563493f, 0.04253998f, 0.18782143f, -0.19579366f, -0.06796610f, 0.12940590f, 0.04787643f, -0.03172063f, 
    0.05526253f, -0.12400568f, -0.07670666f, 0.06484833f, -0.03029845f, -0.05840219f, -0.05184750f, 0.07528037f, 
    0.03501744f, 0.13234305f, -0.06616135f, 0.09923065f, -0.13730903f, 0.03025829f, 0.00922764f, -0.03958341f, 
    0.14926705f, -0.34816974f, -0.18396212f, -0.09016901f, 0.06442442f, 0.02486221f, -0.01027107f, -0.06792857f, 
    -0.09208354f, -0.05452126f, -0.02219120f, -0.03613511f, 0.00677348f, -0.12365378f, 0.07501048f, -0.08597980f, 
    0.00477309f, 0.08407269f, 0.10637464f, 0.15648547f, 0.23425302f, 0.02208341f, -0.06704216f, -0.10360602f, 
    0.16216445f, 0.20350930f, 0.01860941f, 0.08870576f, -0.02249424f, -0.18491881f, 0.05280206f, 0.07422113f, 
    -0.05850290f, 0.00309313f, 0.01792661f, 0.16881056f, 0.45114908f, 0.22006510f, -0.00037880f, -0.13705164f, 
    -0.07093450f, 0.07711574f, 0.02273773f, -0.09602749f, -0.15097018f, -0.10153738f, 0.02359900f, 0.00362398f, 
    -0.26034784f, -0.48159879f, -0.03322453f, 0.12952486f, 0.05167198f, 0.11963052f, -0.04316784f, 0.05712762f, 
    -0.11183185f, 0.11624232f, 0.16660056f, 0.31593069f, -0.10672725f, -0.04933871f, 0.02544477f, 0.13482007f, 
    -0.07902851f, 0.10367940f, -0.15597810f, 0.11706242f, -0.08956070f, -0.10521174f, -0.05636045f, -0.14615293f, 
    0.15376398f, 0.02357421f, 0.01045574f, -0.21379666f, -0.07603008f, 0.14355142f, 0.10306234f, -0.09762331f, 
    0.00131267f, -0.10043117f, -0.04560736f, -0.12358797f, 0.36753142f, -0.21607187f, 0.23410966f, -0.29795119f, 
    0.12056569f, 0.19893174f, 0.17940910f, 0.08550797f, -0.12864152f, 0.11863457f, 0.27799526f, 0.10452656f, 
    0.26913869f, 0.07004800f, 0.30388582f, -0.00978723f, 0.08263031f, 0.01528279f, 0.19815432f, 0.00899207f, 
    -0.01943535f, 0.08627934f, 0.11744163f, 0.17010739f, -0.49277630f, 0.17969960f, 0.04321211f, -0.05040943f, 
    -0.12260249f, 0.09169228f, 0.04483144f, -0.05404344f, 0.09236364f, 0.01627779f, 0.06725127f, 0.01244320f, 
    0.31242257f, 0.31671831f, -0.22072347f, 0.53511363f, 0.09369799f, -0.12879008f, 0.09047768f, 0.05026322f, 
    -0.07568465f, 0.15824997f, 0.07033297f, 0.11562508f, -0.02404131f, 0.08381519f, -0.07446820f, 0.04504891f, 
    -0.08744857f, 0.11293441f, -0.01140250f, -0.11915097f, 0.09796517f, -0.00144127f, 0.09858102f, -0.16288173f, 
    -0.27540508f, -0.18687542f, 0.29420382f, -0.08599073f, -0.05668129f, 0.05202942f, 0.11566360f, -0.05562247f, 
    -0.13833186f, 0.05111972f, -0.07855251f, -0.11635469f, -0.35393775f, -0.04430932f, 0.04269280f, 0.07150554f, 
    -0.01882908f, 0.12936637f, -0.00332013f, -0.07169548f, -0.12413477f, -0.06920851f, 0.07716923f, -0.00812755f, 
    0.26829529f, 0.29154098f, -0.10082352f, 0.26594374f, -0.01007893f, -0.04832143f, 0.06728628f, 0.09155387f, 
    -0.04223242f, 0.19492893f, -0.09048850f, -0.01753285f, 0.18783678f, -0.06284004f, 0.24571092f, -0.05077122f, 
    0.16152027f, -0.14182962f, -0.06515796f, -0.18922278f, 0.06318876f, -0.00282016f, -0.11568777f, 0.09177687f, 
    -0.03163797f, 0.02965158f, 0.08277034f, 0.13485818f, -0.13320874f, -0.04263368f, -0.13968439f, -0.06042616f, 
    -0.05823005f, -0.15434696f, 0.18181822f, 0.01699659f, -0.09041802f, 0.19223335f, 0.07092941f, 0.24612875f, 
    -0.00583765f, 0.09374518f, 0.03553711f, 0.07396489f, -0.04896328f, 0.01529213f, -0.00340795f, 0.05310309f, 
    -0.07761489f, 0.00787083f, -0.05990553f, -0.13163325f, -0.06158060f, 0.06249757f, 0.00428173f, -0.04971564f, 
    -0.08962510f, 0.12750602f, -0.04588696f, -0.05447149f, 0.00776619f, 0.02023838f, -0.13814242f, 0.41327807f, 
    -0.12300708f, -0.05761766f, 0.17757405f, 0.10634241f, 0.03583432f, -0.03379753f, 0.11042320f, -0.00714382f, 
    -0.29359633f, 0.05189818f, 0.07038303f, 0.18008988f, -0.04376329f, -0.03605180f, -0.07960449f, -0.13401036f, 
    0.06167579f, -0.08639815f, 0.10161083f, -0.07152327f, -0.21066219f, 0.21102621f, 0.07045865f, 0.04116025f, 
    -0.08431272f, 0.09385260f, 0.00275488f, -0.11177132f, -0.07787360f, -0.09826457f, 0.14631721f, -0.03145616f, 
    -0.10046775f, 0.26088086f, -0.24615762f, 0.23458096f, -0.00298330f, -0.00925060f, -0.09185346f, 0.10522132f, 
    -0.06739985f, -0.10884540f, -0.02109817f, -0.23555158f, 0.01560809f, 0.30786642f, 0.07542925f, 0.04541538f, 
    0.01007679f, -0.05340943f, 0.07851982f, 0.04017370f, -0.04387761f, -0.00250953f, 0.03857986f, -0.09132174f, 
    -0.20137352f, -0.08717058f, -0.21396579f, 0.09319164f, -0.09997938f, 0.10355974f, 0.11631680f, 0.03074935f, 
    0.14345945f, -0.02915161f, -0.05641403f, -0.12570550f, -0.27055451f, 0.19720291f, 0.21380450f, 0.02666996f, 
    -0.00014712f, -0.10525455f, 0.02966100f, 0.01750086f, 0.13094330f, 0.05785321f, 0.17594011f, -0.05644695f, 
    -0.36366093f, -0.04376477f, 0.08573707f, 0.01710260f, -0.13518092f, -0.03490495f, 0.07750144f, -0.02250542f, 
    -0.01736103f, 0.00822456f, -0.13100371f, -0.22762839f, -0.42468017f, -0.00163505f, 0.10332453f, 0.03883598f, 
    0.13242309f, 0.06010776f, -0.14980134f, 0.13334915f, 0.10855182f, -0.10691129f, -0.12018938f, -0.00319321f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02928588f, -0.04421614f, 0.06122710f, -0.05636289f, -0.00375256f, 0.04461531f, 0.04106883f, 0.04713731f, 
    0.01482097f, 0.02412800f, 0.07964321f, -0.03879508f, -0.01473304f, -0.05364164f, -0.05192357f, -0.04122010f, 
    -0.01586033f, -0.02290922f, 0.03301101f, -0.00104866f, 0.01178343f, -0.01552395f, -0.00206522f, -0.03038266f, 
    0.04023176f, -0.04263638f, 0.10894138f, 0.00299442f, 0.09854868f, 0.02731674f, -0.09872462f, -0.02672529f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00744720f, 0.05584107f, 0.07884973f, 0.15091391f, -0.10253814f, -0.36377415f, -0.15832736f, 0.19155028f, 
    0.13161427f, -0.49888787f, -0.56696242f, 0.01001776f, -0.07045715f, -0.03966703f, -0.09569839f, -0.05091907f, 
    0.17458194f, 0.33932576f, -0.01031060f, 0.10115007f, 0.18220590f, -0.16333690f, 0.37053034f, -0.14599235f, 
    0.00146074f, -0.04556133f, 0.09265666f, 0.30331448f, -0.65163392f, 0.10672356f, 0.30884001f, -0.34166431f, 
    0.11650775f, -0.04143454f, 0.42266145f, 0.14415056f, -0.04583516f, -0.39298525f, 0.06102022f, -0.29667968f, 
    -0.17113389f, -0.13384262f, -0.34768525f, 0.12063901f, 0.33649847f, -0.57047939f, 0.12045110f, 0.01205667f, 
    -0.07250369f, 0.07705379f, 0.07093658f, 0.01216662f, -0.12937680f, 0.07172024f, -0.53457081f, -0.01135942f, 
    -0.06863660f, 0.03192258f, 0.29503137f, -0.72225010f, 0.07597856f, -0.08508354f, 0.16358165f, -0.10145908f, 
    -0.05747220f, 0.01102655f, -0.28997526f, -0.00162034f, 0.01157906f, -0.14365351f, 0.16378909f, -0.70786303f, 
    -0.15751168f, -0.35193011f, 0.13555783f, 0.09552895f, 0.43027613f, 0.08362791f, 0.17432645f, -0.17192879f, 
    0.13784529f, -0.39876562f, 0.16548780f, 0.01389782f, -0.56812721f, -0.02886625f, 0.25457066f, 0.13011795f, 
    0.10165220f, 0.04553568f, 0.15454626f, 0.28722116f, 0.24008900f, -0.04085132f, 0.00587780f, -0.22074075f, 
    -0.10521520f, -0.06149253f, -0.36928976f, -0.05149008f, 0.09783716f, 0.29801479f, -0.08122659f, -0.10761477f, 
    -0.08997231f, 0.08143364f, -0.62873077f, 0.08661930f, 0.38778508f, -0.18316573f, -0.14445005f, 0.15718059f, 
    0.00623322f, 0.17257805f, 0.04487317f, -0.15482225f, 0.32826689f, -0.01368907f, 0.36597335f, 0.10598993f, 
    -0.08283449f, -0.07514141f, -0.32785270f, 0.39769360f, 0.22562774f, -0.04100790f, -0.52086300f, -0.00911239f, 
    -0.06994706f, -0.11805771f, 0.21491072f, -0.00027328f, 0.16774501f, 0.23700427f, 0.00760489f, 0.15424530f, 
    -0.03186909f, 0.15695149f, 0.15548243f, 0.00575027f, 0.16181244f, -0.17098859f, -0.00582867f, 0.06172948f, 
    0.09063052f, -0.06950597f, -0.06290475f, -0.01266201f, -0.15892127f, 0.08812791f, -0.21304525f, 0.16467395f, 
    0.01680083f, 0.02031348f, -0.20359172f, 0.29374656f, -0.75852180f, -0.04297921f, -0.09346838f, 0.58364338f, 
    -0.00967144f, -0.07426795f, 0.03245259f, 0.15820439f, 0.03516685f, 0.24375047f, -0.05911286f, 0.50153071f, 
    -0.11168925f, -0.46414256f, 0.01515408f, 0.01205499f, -0.01576921f, -0.00584987f, 0.07645907f, 0.03012307f, 
    0.05623175f, -0.04183467f, -0.11653734f, 0.00488933f, 0.40322062f, 0.03857468f, -0.67996752f, -0.15766212f, 
    0.06305841f, -0.09885071f, -0.06272552f, -0.75783879f, 0.28746560f, 0.15169129f, 0.07019275f, -0.02955194f, 
    -0.10569380f, -0.01656960f, -0.29430684f, -0.09729052f, -0.13930801f, 0.33787626f, -0.17309314f, -0.06497900f, 
    -0.03852802f, -0.29929072f, -0.13793607f, -0.07564352f, -0.59863162f, -0.08237107f, 0.04410979f, -0.03176355f, 
    0.11333520f, 0.27390432f, -0.01544823f, 0.02645129f, -0.64751220f, -0.02875474f, 0.46305493f, -0.09178180f, 
    -0.13347155f, -0.15441908f, 0.20700300f, -0.18597713f, 0.09885798f, 0.02785947f, 0.01468208f, 0.43995687f, 
    -0.00706352f, 0.16289134f, -0.70658457f, -0.02042473f, -0.04696371f, -0.36438537f, 0.02301883f, 0.03830930f, 
    0.00700568f, 0.32032976f, 0.44354886f, -0.17140439f, -0.16263893f, 0.31102017f, 0.11324096f, -0.19081090f, 
    -0.05557480f, -0.15091726f, -0.11055052f, -0.07235846f, 0.32952559f, -0.11262565f, -0.30665568f, 0.00172944f, 
    0.16826946f, -0.05706371f, -0.33488423f, 0.00916367f, 0.11514863f, -0.13510197f, 0.06527668f, 0.40564603f, 
    -0.15124904f, -0.01308514f, 0.02769005f, -0.04785937f, -0.06911005f, -0.31432962f, -0.16803138f, 0.30300719f, 
    0.14079452f, 0.30810046f, -0.73090845f, 0.13766240f, 0.16492702f, 0.38999909f, -0.01718156f, -0.07956686f, 
    0.07881637f, -0.62350023f, -0.11693006f, 0.08043628f, -0.50849313f, 0.12397777f, -0.69228214f, -0.10075891f, 
    -0.11813135f, -0.04586475f, 0.18324675f, -0.21996526f, 0.09940325f, -0.12792742f, 0.06754638f, -0.26466629f, 
    -0.04613849f, 0.09170563f, 0.38378760f, -0.01074242f, -0.03392580f, 0.11598834f, 0.12214839f, -0.42205182f, 
    0.12182777f, 0.01912148f, 0.47827443f, -0.00148538f, -0.68444008f, 0.44169366f, 0.02576865f, 0.10457978f, 
    -0.07941645f, -0.11648666f, 0.11377384f, -0.09703764f, -0.22861870f, 0.11579623f, 0.09259797f, -0.04067220f, 
    -0.02744310f, 0.01017351f, -0.32447898f, 0.05559796f, 0.22058411f, 0.05199742f, 0.34713981f, -0.31626078f, 
    -0.06978454f, 0.17184146f, 0.02795714f, 0.04193440f, 0.14847022f, -0.47005409f, -0.00170914f, 0.22832048f, 
    -0.04338531f, 0.17992707f, 0.32352638f, -0.16399434f, -0.16596638f, -0.00167600f, 0.01855670f, -0.15245944f, 
    -0.16066615f, -0.22290596f, 0.04181078f, -0.16903418f, 0.18806176f, -0.06229281f, 0.59572941f, -0.10130430f, 
    -0.06771776f, -0.04649644f, 0.16231172f, -0.42740536f, 0.30793348f, 0.00342033f, -0.98162138f, -0.38846484f, 
    -0.05045797f, -0.07622930f, -0.37114343f, -0.04367941f, 0.06582396f, 0.31744871f, -0.17769203f, -0.09576571f, 
    -0.02571430f, 0.32928127f, 0.17330939f, 0.13725626f, -0.37099344f, -0.22307567f, -0.13734634f, 0.12955678f, 
    -0.11434661f, 0.43547982f, 0.02254264f, 0.16869220f, -0.34274256f, -0.10394634f, -0.45616746f, 0.08838309f, 
    -0.02924238f, -0.08132115f, 0.32056579f, 0.49945170f, -0.00502292f, -0.12505434f, -0.34622440f, -0.67801607f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.10695925f, -0.09750916f, 0.05778928f, 0.05037245f, -0.17386085f, -0.00446908f, 0.16242225f, 0.06446930f, 
    0.17663063f, 0.08121298f, -0.10036352f, -0.01386038f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
