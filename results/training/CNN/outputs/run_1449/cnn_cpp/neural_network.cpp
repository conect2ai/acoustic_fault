#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.60446703f, 0.40666032f, 0.32027718f, 0.77298647f, 0.21511884f, 0.68377346f, -0.08806027f, -0.19077197f, 
    -0.03611653f, 0.11985139f, 1.29232168f, -1.01522779f, -0.37143773f, 0.34330788f, -0.10410110f, -0.01960854f, 
    -0.21746118f, 0.16807999f, -0.52110767f, -0.54789299f, 0.05665780f, -0.16586959f, -0.11085352f, -0.04313739f, 
    0.02408916f, -0.27518684f, -0.45485240f, -0.72804815f, -0.43066880f, 0.51078993f, -0.23128617f, -0.29040119f, 
    0.05793901f, 0.22857831f, 0.46516749f, 0.44165659f, -0.25884187f, -0.99030757f, -0.59825760f, 0.94855791f, 
    1.02337348f, -0.19300874f, -0.30300173f, -0.45050851f, -0.11324593f, 0.56845546f, -0.31545919f, -0.08016630f, 
    0.06761858f, 0.11086279f, 0.00687931f, 0.01713242f, -0.35076025f, 0.40507141f, 0.09248476f, 0.53984576f, 
    0.61074609f, -0.85706818f, -0.43694738f, 0.17443517f, 0.02076582f, 0.50883025f, 0.37628883f, -0.22308971f, 
    0.31085634f, 0.35934329f, -0.29395247f, -0.64763081f, -0.80588299f, 0.67541003f, 0.51763678f, -0.23157005f, 
    -0.28245378f, 0.29050642f, 0.49933553f, -0.39628106f, 0.48715970f, -0.44303268f, -0.36661023f, -0.08120290f, 
    0.55424833f, 0.47087565f, 0.32674941f, 0.18208016f, 0.18923976f, 0.59514242f, -0.49732453f, 0.00875720f, 
    0.02576093f, -0.19014074f, -1.09921098f, -0.30552575f, 0.72838944f, 0.03128492f, -0.50461203f, 0.76454628f, 
    0.23536813f, 0.11421514f, -0.24749731f, 0.18502983f, 0.22962727f, -0.09419705f, -0.49461892f, -0.73739600f, 
    -0.30675223f, -0.29442003f, -0.23791851f, -0.22474958f, 0.84811455f, -0.87193137f, -1.02610540f, 0.44830376f, 
    -0.00074659f, 0.18812859f, 0.12763983f, 0.36208564f, 0.16765973f, 0.41144276f, 0.25518310f, 0.54564148f, 
    -0.58857584f, 0.28128153f, 0.14813899f, 0.20101605f, -0.20571740f, -0.04714598f, 0.04558533f, -0.26055136f, 
    0.00674324f, -0.78828579f, -0.56962448f, -0.03860805f, -0.08814248f, 0.51232404f, -0.13557878f, 0.18673153f, 
    -0.08221065f, 0.40528053f, 0.62255472f, -0.62014598f, -0.34594697f, 0.12844591f, -0.11928701f, -0.12306643f, 
    -0.97098213f, 0.89944106f, -0.59552062f, -0.22804514f, 0.74116451f, 0.15158866f, 0.20009330f, -0.06831581f, 
    0.11890114f, -0.25484809f, -0.46999985f, -0.45258448f, -0.12083081f, -0.34493613f, 0.44087332f, -0.17574994f, 
    -0.16126028f, -0.63258183f, -0.75792742f, -0.20248657f, -0.31971183f, 0.29821306f, 0.03328508f, -0.79534674f, 
    -0.11461414f, 0.06004347f, -0.30593655f, 0.53274810f, 0.25097173f, -0.44794419f, 0.10070602f, -0.03940417f, 
    0.42188749f, 0.00845907f, -0.44881472f, 0.46237311f, 0.10154872f, -0.13733874f, -0.01090523f, 0.08542757f, 
    0.72821593f, -0.81366676f, 0.17309882f, -0.16337566f, -0.04749058f, 0.37376574f, 0.11918882f, 0.33055869f, 
    0.16975565f, -0.04547911f, 0.02318287f, 0.13943304f, 0.40084070f, 0.07013346f, -0.63760817f, 0.65510929f, 
    -0.20334743f, 0.20598283f, 0.20850566f, -0.13568933f, 0.35836148f, 0.23180589f, 0.18113835f, -0.81573629f, 
    -0.49668610f, 0.02284700f, 0.32518449f, -0.53630883f, -0.33984324f, -0.22322007f, 0.46493754f, -0.05379253f, 
    -0.12025118f, 0.13252810f, -0.31264514f, -0.48536453f, -0.08718988f, -0.56242770f, 0.30340326f, -0.11216151f, 
    0.66744947f, -0.07198551f, 0.21457969f, -0.70927984f, -0.57685316f, -0.21171077f, -0.41505992f, 0.30033743f, 
    -0.32655728f, 0.37134588f, 0.63849235f, 0.42673603f, 0.45500046f, 0.18792272f, -0.63035846f, -0.31756613f, 
    0.03777911f, -0.04869814f, 0.10283803f, 0.76930314f, -1.24022579f, 0.48757061f, -0.34906462f, 0.02952765f, 
    -0.46590468f, -0.57123637f, 0.00274240f, -0.36971349f, -0.38206539f, -0.59332496f, 0.85011798f, 0.59116244f, 
    -0.38212559f, -0.44552720f, 0.24150413f, -0.29425073f, 0.50351155f, 0.32516754f, 0.34229693f, -0.28688771f, 
    0.41577423f, 0.07844313f, -0.42473817f, -0.11489574f, -0.18443207f, 0.19421117f, 0.01458254f, 0.46450222f, 
    0.40261611f, -0.12308649f, 0.01006912f, 0.35042557f, -0.31596836f, -0.50904936f, -0.36992675f, 0.41557211f, 
    0.45691961f, -0.73304701f, -0.25487214f, -0.18662269f, 0.35297024f, 0.19509421f, -0.23909988f, -0.23581021f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08539665f, -0.07360765f, -0.09343894f, -0.28400981f, 0.25063401f, 0.40854460f, -0.20560777f, 0.10036730f, 
    0.28724933f, -0.28510666f, -0.15032478f, 0.00727873f, 0.12017989f, 0.28015012f, 0.17890656f, 0.17835416f, 
    0.04164275f, 0.23859657f, -0.20444848f, -0.05748007f, 0.33430803f, 0.00937623f, -0.13804518f, -0.17984082f, 
    0.00823383f, -0.28250897f, 0.13626054f, -0.24742460f, -0.16889217f, 0.08875842f, 0.26211932f, 0.13867797f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.07666024f, 0.00410158f, -0.07678648f, 0.21352538f, 0.24434927f, 0.12601447f, 0.04106658f, 0.08126988f, 
    0.00040151f, -0.18824244f, 0.43608943f, 0.24713823f, -0.01457901f, 0.02059326f, -0.13313185f, 0.09385722f, 
    0.31065702f, -0.08852023f, 0.08178692f, -0.05947790f, -0.30584380f, 0.01488464f, 0.02211828f, 0.03794741f, 
    0.04329750f, -0.07297961f, 0.11055287f, -0.10301748f, -0.09412533f, 0.01098533f, -0.08113420f, 0.08039820f, 
    0.05039341f, 0.01731461f, -0.09692144f, -0.34865883f, 0.09657737f, -0.31731924f, -0.16478091f, 0.09849794f, 
    0.16744266f, 0.15378200f, 0.11162476f, 0.11759667f, 0.23904745f, -0.07977921f, -0.00759006f, 0.16349256f, 
    -0.04459123f, -0.06537639f, 0.03873011f, 0.03019424f, -0.08691098f, 0.04944582f, 0.21766028f, 0.05461134f, 
    0.10306725f, -0.24164388f, -0.06181989f, -0.01860172f, -0.10296623f, -0.09843089f, -0.13085805f, 0.13367726f, 
    -0.14706616f, -0.14092198f, 0.12650944f, -0.05205281f, 0.13979796f, -0.09488909f, -0.20485128f, -0.13237518f, 
    -0.01461935f, 0.30414915f, -0.15166655f, -0.06124146f, 0.01209101f, -0.00314966f, 0.02755583f, -0.02320079f, 
    -0.02215941f, 0.00233226f, 0.02597641f, -0.02129192f, 0.03146976f, -0.01228520f, 0.03407274f, 0.06448340f, 
    -0.02490087f, -0.00033340f, -0.00411109f, 0.10723896f, -0.34655151f, -0.19080785f, 0.17075676f, -0.01707038f, 
    0.04273156f, 0.03958856f, 0.12089492f, 0.05545770f, 0.00900069f, 0.00086081f, 0.13807833f, 0.10061618f, 
    0.01114541f, 0.04614567f, -0.04531679f, 0.03937189f, -0.06111652f, -0.20326269f, 0.12332044f, 0.12471537f, 
    -0.14874679f, 0.14043325f, -0.08682124f, 0.06902427f, 0.02120325f, 0.13129647f, 0.20652975f, -0.00758779f, 
    0.09378296f, -0.01345202f, 0.03959865f, 0.08130743f, -0.00138452f, 0.04734638f, 0.03239322f, 0.00073358f, 
    -0.02408218f, -0.04694001f, 0.03085365f, 0.05755100f, -0.11087940f, -0.08272336f, -0.12583207f, 0.33806288f, 
    0.17268479f, 0.04330105f, 0.06037875f, -0.13079751f, 0.07957856f, -0.17143470f, -0.12516202f, -0.00495978f, 
    -0.21333480f, 0.21711090f, -0.05337510f, 0.01305453f, 0.15829627f, -0.08103462f, -0.08305701f, 0.12659071f, 
    -0.10259503f, 0.13822697f, -0.11651008f, -0.06100690f, -0.01496611f, -0.06923074f, -0.02510308f, 0.00384883f, 
    0.02242161f, 0.13390853f, -0.00781716f, -0.26913312f, -0.30693489f, 0.07556653f, 0.10790807f, -0.05952030f, 
    0.11730246f, -0.05451188f, 0.09925801f, -0.09047867f, -0.11426494f, -0.02964504f, 0.00302657f, -0.07315329f, 
    -0.05982454f, 0.20297293f, 0.15670492f, 0.01967514f, 0.14962831f, -0.12039367f, -0.07145288f, -0.01909503f, 
    0.07961351f, 0.08681479f, 0.14981875f, -0.08587879f, -0.00428798f, 0.06497093f, -0.10574482f, -0.05375332f, 
    0.00525998f, -0.17007518f, -0.05276826f, -0.05476673f, -0.02971040f, -0.13889264f, -0.13849227f, -0.01007012f, 
    -0.05261625f, -0.03314025f, -0.04550575f, 0.04547303f, -0.09077924f, -0.14845672f, -0.24602152f, -0.02722272f, 
    -0.07761243f, -0.28202415f, 0.12248483f, 0.01817968f, 0.08138986f, 0.06582164f, -0.04445000f, 0.09593740f, 
    -0.13656861f, -0.07850458f, -0.03141673f, 0.00584793f, 0.11158895f, -0.01493682f, -0.03557707f, -0.06745059f, 
    -0.42976958f, -0.22298646f, -0.36158398f, -0.18427378f, 0.11604194f, 0.05392203f, -0.08048882f, -0.18013018f, 
    -0.12903501f, -0.25755525f, 0.29590762f, 0.29596016f, 0.11515494f, 0.09747394f, -0.11204904f, -0.00414029f, 
    -0.15507282f, -0.09167773f, 0.03659643f, 0.08611746f, -0.03600730f, 0.13435154f, 0.15998365f, 0.21063854f, 
    -0.09052021f, -0.11850222f, 0.04397448f, 0.07215212f, 0.07450467f, 0.30783877f, -0.17607553f, -0.07894414f, 
    0.21993238f, 0.28907338f, -0.00909163f, 0.03202884f, -0.09517326f, 0.04125791f, 0.10916913f, 0.10600717f, 
    0.21446189f, -0.04166968f, -0.10075244f, -0.00463695f, -0.02649503f, 0.04667874f, 0.02865908f, 0.14484139f, 
    0.01816930f, 0.01721134f, 0.05486786f, 0.07431852f, 0.12423107f, 0.10907794f, 0.01212979f, -0.14879286f, 
    0.17491046f, 0.22455218f, -0.00125426f, 0.04942004f, 0.06583493f, 0.15393206f, 0.13509734f, 0.02582547f, 
    0.00827964f, -0.00123081f, -0.28206161f, 0.02246167f, 0.09265099f, -0.09172984f, -0.05802495f, -0.02387815f, 
    0.10108469f, 0.48961797f, -0.50887609f, -0.10434076f, -0.01562960f, -0.23806436f, 0.00933479f, 0.10921214f, 
    0.06176414f, -0.04336841f, 0.22740583f, 0.14934225f, -0.10212895f, -0.02166503f, -0.00314208f, 0.04087470f, 
    -0.17203951f, 0.04418051f, -0.02404799f, 0.09446537f, -0.11121562f, -0.21221435f, -0.13440779f, 0.01149780f, 
    -0.10698594f, 0.00180163f, 0.07613583f, 0.01124926f, -0.08263394f, 0.05128290f, 0.50374383f, -0.00186337f, 
    0.11592275f, 0.06361043f, -0.04778112f, -0.00424550f, 0.18969952f, 0.07898588f, -0.01236698f, 0.08306679f, 
    0.00481780f, 0.01723857f, 0.03664716f, 0.09702514f, 0.11535902f, 0.12991080f, 0.06784935f, -0.37537464f, 
    -0.49230081f, -0.15381284f, 0.06764945f, -0.01846716f, -0.03822764f, 0.02192456f, 0.01120028f, -0.22919758f, 
    -0.38146341f, -0.10363854f, 0.15179817f, 0.10983633f, -0.18413222f, 0.10017330f, 0.06675746f, -0.07620565f, 
    0.21331015f, -0.22302853f, 0.14351958f, 0.06584509f, -0.02724108f, 0.03755929f, 0.04995365f, 0.14179096f, 
    0.07948006f, -0.12553304f, -0.25172240f, 0.11328242f, 0.07123607f, 0.04531765f, -0.15357532f, -0.24959794f, 
    -0.04063488f, 0.01278155f, 0.62192744f, -0.26222309f, -0.33609650f, -0.03302381f, -0.07702997f, -0.00702119f, 
    -0.11345334f, -0.10455930f, -0.00364822f, -0.52323914f, -0.10695140f, 0.10393032f, -0.01781513f, 0.06625338f, 
    -0.09997146f, 0.08240788f, -0.05635196f, 0.01256023f, -0.36917028f, 0.41984737f, 0.14880857f, -0.00712931f, 
    -0.01135636f, 0.01276311f, 0.02120194f, -0.09625950f, 0.02579254f, 0.12955774f, -0.07294670f, -0.00989462f, 
    -0.03455359f, -0.05190563f, 0.01086907f, -0.03425180f, -0.03209507f, 0.04787863f, -0.15153961f, -0.23267309f, 
    -0.37486961f, -0.07628310f, 0.03892374f, -0.01482712f, 0.00370575f, 0.00895804f, 0.04862563f, -0.11064809f, 
    -0.02900137f, 0.12559308f, 0.05081775f, 0.13529883f, 0.15907158f, 0.09636914f, -0.04646445f, 0.03801255f, 
    0.40880203f, -0.15170024f, -0.16125365f, -0.26529494f, 0.08270670f, -0.08544851f, 0.06873634f, -0.05769288f, 
    0.18993846f, 0.18166196f, -0.00172981f, 0.19252656f, 0.08193170f, 0.01543220f, 0.11385929f, -0.05004909f, 
    0.02225919f, 0.09457663f, 0.37616825f, -0.10345034f, 0.29858947f, 0.02929045f, 0.01440511f, -0.21085759f, 
    -0.27298331f, -0.00632235f, -0.05568628f, -0.04295334f, 0.03470759f, -0.01777093f, 0.08655264f, 0.01663790f, 
    -0.09497124f, -0.02836437f, 0.05775990f, 0.16812354f, -0.11955252f, -0.22707000f, 0.11323234f, 0.18404032f, 
    0.06643092f, 0.05362516f, 0.04962137f, 0.11346212f, 0.21618111f, 0.18059155f, 0.13200927f, -0.18160112f, 
    -0.16861945f, -0.18746963f, -0.07638716f, -0.02162112f, -0.07408140f, 0.03654616f, 0.22785193f, -0.31815928f, 
    -0.31641707f, 0.06373820f, -0.14764665f, -0.04954236f, 0.06039996f, -0.08615246f, -0.03567453f, 0.52946955f, 
    -0.20737852f, 0.05973843f, 0.07872881f, -0.04884266f, -0.25307366f, -0.02644900f, -0.15312999f, -0.02729637f, 
    -0.06803419f, -0.39218229f, 0.16674797f, 0.15074322f, -0.09359378f, -0.27802354f, 0.09797508f, 0.01734695f, 
    -0.00286317f, -0.31257272f, -0.40552384f, -0.32427838f, 0.00766917f, -0.01505351f, -0.24219933f, -0.18189038f, 
    -0.06989091f, 0.06902932f, -0.03454500f, 0.08193286f, 0.20414639f, 0.12841801f, 0.01751171f, -0.02175722f, 
    0.02771074f, 0.01225550f, 0.01929272f, -0.37455288f, -0.10870839f, -0.28742915f, -0.22854635f, -0.18499394f, 
    0.00321954f, 0.04978989f, -0.04740037f, -0.02826836f, -0.00108596f, -0.25357342f, 0.29071051f, 0.15567750f, 
    -0.13062714f, -0.03705527f, 0.20708728f, 0.07823848f, -0.08101875f, 0.17484847f, -0.11178538f, 0.04472457f, 
    0.02950366f, -0.07814915f, 0.07860292f, 0.15843911f, 0.11279276f, 0.02347887f, -0.12594284f, 0.01053371f, 
    0.04708031f, 0.03156821f, -0.07835449f, -0.03619826f, -0.06754728f, -0.08060082f, 0.16960934f, 0.16455483f, 
    0.22044002f, 0.05164718f, 0.07538436f, 0.07146554f, -0.01628381f, 0.07485444f, 0.17659399f, 0.07687929f, 
    -0.12013963f, -0.10604736f, -0.13209601f, -0.01232592f, -0.04869511f, -0.20494661f, 0.00594124f, -0.19506526f, 
    0.11713967f, 0.31296322f, -0.24008581f, 0.03337194f, -0.08374383f, 0.00635393f, -0.10997982f, -0.05392747f, 
    0.11355751f, -0.15124913f, 0.23938316f, -0.32850230f, -0.33945528f, -0.18874528f, -0.10488429f, 0.19835478f, 
    0.03926750f, -0.00798651f, -0.04386777f, -0.28901199f, -0.29504430f, -0.22756079f, -0.01453575f, 0.05812696f, 
    0.15314703f, 0.12264138f, 0.06426200f, 0.06664141f, -0.23925944f, -0.18457048f, -0.37970781f, 0.01553996f, 
    0.11362050f, -0.03236034f, 0.02309740f, -0.16728024f, 0.01754916f, 0.08174384f, 0.17567432f, 0.20175426f, 
    -0.01064865f, 0.03140682f, 0.00173666f, -0.08411319f, 0.05854587f, 0.14789368f, 0.19314887f, -0.07735536f, 
    0.09044226f, -0.19268614f, -0.06493271f, 0.01346011f, -0.00343505f, 0.09283797f, 0.05942848f, -0.16975304f, 
    0.13616368f, 0.23832406f, -0.23536988f, -0.08932106f, -0.11024605f, 0.22444110f, 0.12515530f, 0.12088974f, 
    0.09415036f, -0.00268189f, 0.19829029f, 0.11144122f, -0.02404630f, -0.01325141f, 0.11998470f, 0.19358878f, 
    -0.06206155f, 0.03107250f, -0.00462027f, 0.01222487f, -0.19485326f, -0.08030555f, -0.14701331f, -0.03588890f, 
    -0.02451928f, -0.04905275f, 0.08212262f, -0.59018743f, 0.17027226f, 0.08011556f, -0.11184874f, 0.10282208f, 
    -0.05063713f, 0.03318601f, 0.18079247f, 0.04210066f, 0.08692829f, 0.02593263f, -0.18477863f, -0.17285629f, 
    -0.12919882f, -0.02990868f, 0.03020147f, 0.07561196f, -0.47728404f, -0.36321729f, -0.31463164f, 0.01075355f, 
    0.21203245f, 0.05767300f, 0.07980689f, 0.05716538f, -0.06555924f, 0.28925410f, 0.08663554f, 0.09955575f, 
    -0.21580589f, -0.01045545f, -0.02651881f, -0.06996200f, 0.09858955f, 0.08501957f, -0.09516998f, -0.28084868f, 
    -0.06911957f, -0.06466395f, -0.03974598f, 0.04888025f, 0.13109323f, 0.10776005f, 0.07155779f, 0.10265832f, 
    0.21519190f, 0.05914174f, -0.01001704f, -0.06535325f, -0.01097962f, 0.11151733f, 0.09801986f, 0.04840588f, 
    -0.15984529f, -0.21945618f, -0.31705579f, -0.01218700f, 0.14791133f, -0.13028118f, -0.04837631f, 0.07014299f, 
    0.09886035f, 0.13601036f, -0.24216217f, 0.08638272f, -0.05810983f, -0.04455380f, -0.00875721f, 0.03808529f, 
    -0.09851336f, -0.02719738f, 0.15167071f, -0.06057718f, -0.45978037f, -0.24052966f, -0.04797176f, 0.06599452f, 
    0.08197140f, -0.04473587f, 0.07009331f, 0.10284011f, -0.08734332f, 0.23318179f, -0.12026250f, 0.03476146f, 
    -0.08229013f, -0.07013837f, 0.05829321f, 0.09221357f, -0.12938005f, 0.11445431f, 0.08521054f, 0.17941473f, 
    0.22854792f, 0.05645766f, 0.25879386f, 0.04297922f, 0.13059725f, 0.05937243f, 0.11679861f, -0.04457576f, 
    -0.13402803f, -0.02950702f, 0.03190435f, 0.14990088f, -0.05133040f, -0.03689064f, -0.24258782f, -0.17736988f, 
    -0.10700594f, -0.06738082f, 0.13675582f, 0.01553354f, 0.10702230f, 0.17411463f, 0.07739052f, 0.13751850f, 
    0.02963056f, -0.23612437f, -0.09847739f, -0.19469245f, 0.02466963f, -0.01558144f, 0.01031513f, 0.04069363f, 
    -0.37370136f, -0.17319611f, 0.30378902f, 0.05408694f, -0.08089201f, 0.07323056f, 0.06521332f, -0.02372926f, 
    0.07387795f, -0.22708821f, 0.02693033f, -0.05991473f, -0.20353940f, -0.09395926f, -0.03182235f, -0.01406876f, 
    -0.07732738f, 0.06391034f, 0.36355621f, 0.11062060f, 0.16500852f, -0.08583213f, -0.24553879f, -0.04853019f, 
    0.03704064f, 0.08415242f, 0.14250241f, -0.32506958f, 0.05488308f, -0.43743405f, 0.13262677f, -0.17093937f, 
    0.17887095f, -0.04277224f, -0.11395366f, -0.20183666f, -0.48055527f, -0.33908257f, -0.31717455f, -0.08266553f, 
    -0.21149974f, 0.18129627f, 0.16004366f, 0.11798412f, -0.02795410f, 0.05925211f, 0.01444799f, 0.15212382f, 
    -0.13886599f, 0.10289817f, 0.04492612f, 0.11824275f, 0.12406851f, 0.01347628f, 0.14928985f, 0.11236360f, 
    0.26978391f, -0.04268424f, -0.03169135f, -0.06172849f, -0.02494803f, 0.00150711f, 0.08189400f, 0.15560123f, 
    -0.22982730f, -0.07358950f, 0.02301928f, -0.09515850f, 0.06322322f, -0.10916951f, 0.05071418f, -0.00136527f, 
    0.17869417f, 0.09480558f, -0.13828000f, 0.07563026f, 0.05113059f, 0.12833577f, 0.08066296f, 0.11312303f, 
    -0.17359942f, -0.23172054f, 0.15862928f, 0.01176187f, 0.05293243f, 0.10539254f, -0.02559192f, 0.01481485f, 
    0.18929401f, 0.13486172f, 0.05459644f, 0.12858109f, -0.05194411f, -0.07145578f, -0.19670622f, 0.15966138f, 
    0.00293292f, 0.02501502f, 0.20465493f, -0.16710739f, 0.02629394f, 0.10217394f, 0.07353181f, -0.05170243f, 
    -0.24386261f, -0.04317039f, -0.09098820f, -0.44193259f, 0.00297311f, 0.14021392f, 0.21286392f, -0.08820863f, 
    -0.08449382f, 0.00304730f, -0.02865513f, 0.09126569f, 0.13215382f, -0.05029059f, 0.02556272f, -0.08644091f, 
    0.04484815f, 0.14106718f, 0.09045340f, -0.01655691f, -0.11965881f, -0.09734248f, -0.17981850f, 0.11828446f, 
    -0.08628190f, -0.14892721f, 0.03863427f, 0.14137843f, -0.22889155f, -0.14099219f, -0.34168193f, -0.08722351f, 
    -0.00152943f, 0.12196087f, 0.00782922f, -0.03138230f, 0.08055586f, -0.19209491f, -0.08375683f, -0.17576741f, 
    -0.06711837f, 0.19681902f, -0.28954867f, -0.18086651f, -0.00323676f, -0.12704511f, 0.04120989f, -0.10160284f, 
    -0.06474020f, 0.03701116f, -0.08307330f, -0.10142295f, -0.02511212f, -0.06760149f, 0.17520705f, 0.07983594f, 
    0.11324145f, -0.15404423f, 0.38619015f, 0.44547278f, -0.16996890f, -0.03458516f, -0.03087997f, 0.12782082f, 
    0.02206250f, -0.00803245f, 0.13069068f, 0.04727765f, 0.09829132f, 0.23490830f, 0.00038150f, -0.08230047f, 
    0.02182032f, -0.01312334f, -0.01632201f, 0.13421969f, -0.12403846f, 0.16240023f, 0.37303475f, -0.03072685f, 
    0.05947626f, -0.05922635f, -0.12222750f, -0.15814131f, -0.10251345f, 0.02682613f, -0.03029670f, -0.16735773f, 
    0.05627463f, 0.00453856f, -0.03864735f, -0.02640854f, -0.00876139f, -0.05177883f, -0.21768540f, 0.06364261f, 
    0.21178393f, -0.07388611f, 0.02574827f, 0.12239573f, 0.01993010f, -0.03801020f, -0.04128914f, 0.01400242f, 
    0.06157631f, 0.21443087f, -0.12847865f, -0.02979610f, 0.02009650f, -0.12797154f, 0.05457005f, -0.07739338f, 
    0.06992924f, -0.03632051f, 0.14266750f, -0.15885217f, 0.08813796f, 0.14140978f, -0.22669682f, -0.26580644f, 
    -0.05850967f, 0.03501605f, 0.09937622f, 0.07149013f, -0.17088921f, -0.10042175f, 0.05297824f, -0.04856608f, 
    0.09867756f, 0.28824633f, 0.12551264f, 0.02711858f, -0.01727060f, -0.20513836f, -0.00769203f, 0.05047411f, 
    0.01779677f, 0.03177908f, 0.18374066f, -0.07788092f, -0.10084223f, -0.29150563f, -0.02222569f, 0.15175870f, 
    0.05170462f, 0.07052629f, 0.04572256f, -0.03158431f, -0.02062824f, 0.13496172f, 0.04116319f, 0.00643577f, 
    0.05894231f, -0.13183239f, 0.05575173f, 0.10373681f, 0.09881789f, 0.02374882f, 0.00772226f, -0.14678715f, 
    -0.04610777f, -0.18540122f, -0.12975250f, -0.14858319f, -0.21326376f, -0.35356554f, -0.11555912f, -0.18957558f, 
    0.01351319f, -0.01870738f, 0.01395839f, 0.02308403f, -0.11554837f, -0.36904642f, -0.42922118f, 0.06191600f, 
    0.02465695f, 0.13642967f, -0.03279109f, -0.09136277f, 0.13918118f, -0.07682312f, -0.02754741f, -0.00668727f, 
    -0.06518759f, 0.09704082f, -0.03511631f, 0.24967416f, 0.09534226f, -0.08240248f, -0.08836438f, -0.14905177f, 
    -0.23334010f, 0.00609544f, 0.07234122f, 0.17858402f, 0.10582174f, 0.14924975f, -0.14333184f, -0.12126772f, 
    0.02513966f, -0.03141776f, 0.03751127f, 0.16475943f, -0.09776354f, -0.04935014f, -0.03905402f, -0.02331998f, 
    -0.00357767f, 0.00172047f, -0.09212861f, -0.20120959f, 0.25142208f, 0.26494059f, 0.15098201f, 0.02089774f, 
    -0.04150397f, -0.00658328f, 0.20586929f, 0.36623797f, 0.18270266f, -0.06209892f, 0.03355700f, -0.00753221f, 
    0.17763343f, -0.09021267f, 0.05980035f, 0.08059411f, -0.27622557f, -0.15419942f, -0.07523148f, 0.16525231f, 
    0.01711188f, 0.10152228f, -0.04699518f, 0.16254699f, 0.02604006f, 0.03562974f, -0.08442075f, 0.00946273f, 
    -0.00750192f, -0.02141758f, 0.04052298f, -0.01203378f, 0.14773318f, 0.12650010f, 0.00550805f, -0.07558856f, 
    -0.01344699f, 0.06874303f, -0.10520498f, 0.07135101f, 0.01805165f, 0.18613741f, 0.14717054f, 0.14140895f, 
    0.12398541f, -0.06748064f, 0.15417333f, -0.17173702f, 0.06123653f, -0.09757547f, 0.21545735f, 0.04923832f, 
    -0.11691280f, -0.65708423f, -0.20022804f, -0.19016671f, -0.18970932f, -0.02147729f, -0.05741681f, -0.10001805f, 
    -0.27706510f, 0.07526068f, 0.31507576f, 0.05732616f, -0.09950507f, 0.00341354f, -0.02411097f, 0.07203618f, 
    -0.04738789f, 0.09813169f, -0.15685420f, 0.20079820f, -0.33344764f, -0.18508965f, -0.26789424f, -0.12347790f, 
    0.07346950f, -0.07482973f, -0.07331729f, -0.17591408f, 0.24452671f, -0.12213929f, 0.08216011f, -0.06981753f, 
    -0.03562986f, -0.11986112f, 0.11582821f, -0.20981003f, 0.04011926f, 0.11156353f, 0.17832367f, 0.05307565f, 
    0.13808739f, 0.10739462f, -0.03773021f, 0.14362928f, 0.06024702f, 0.18051718f, -0.03487324f, 0.12190805f, 
    -0.14999397f, -0.03843809f, -0.20644549f, -0.09724870f, 0.10717671f, 0.05966603f, 0.06047107f, 0.04772139f, 
    -0.02316643f, 0.19413497f, -0.02548586f, -0.21574740f, 0.14656782f, -0.12941417f, -0.02743136f, 0.08993603f, 
    0.03996751f, 0.07310998f, -0.10746152f, 0.18640101f, 0.08985677f, 0.18610549f, 0.10267629f, 0.08094530f, 
    0.08988759f, -0.34766787f, 0.08134727f, 0.27679536f, -0.13082324f, 0.07231922f, 0.06990855f, -0.02791133f, 
    0.03234677f, -0.00726208f, 0.42208651f, -0.26852632f, -0.88006067f, -0.10081313f, 0.14465392f, -0.03401843f, 
    -0.01044895f, 0.07863210f, -0.35228586f, -0.08318092f, -0.01082182f, -0.05000663f, 0.05429275f, -0.19476104f, 
    0.10966748f, 0.01572718f, 0.17929256f, -0.00203988f, 0.16063854f, -0.54844797f, -0.47030240f, 0.12823389f, 
    0.04755731f, -0.01298272f, 0.01987931f, 0.15061606f, 0.00588044f, -0.11811315f, 0.15023415f, 0.12740119f, 
    0.03724470f, 0.03420570f, 0.03921843f, 0.01744914f, 0.02031730f, 0.11771595f, 0.30448258f, -0.17971417f, 
    -0.15498060f, -0.01192557f, -0.03217441f, -0.02176927f, -0.00260360f, -0.02607464f, 0.05137899f, -0.17056812f, 
    0.06343326f, -0.07238545f, -0.16388883f, 0.03610212f, 0.24609099f, 0.00899928f, 0.12349165f, 0.00433093f, 
    0.24078067f, -0.21397147f, -0.52961546f, -0.01182446f, 0.16049628f, -0.25036821f, 0.08749815f, -0.11842588f, 
    0.04585944f, 0.25819033f, 0.04265920f, -0.09723344f, 0.10538775f, -0.02418191f, 0.23027077f, 0.05614642f, 
    0.16294226f, -0.14527102f, 0.32356560f, -0.00279783f, -0.07483116f, 0.04638091f, -0.10267916f, 0.13370971f, 
    0.08599370f, -0.01358094f, -0.00380841f, -0.20701538f, 0.15354313f, 0.15371113f, -0.00062090f, 0.13903248f, 
    0.05847078f, 0.07310694f, -0.11668276f, -0.01177191f, -0.00991348f, -0.03526919f, -0.02804667f, -0.12067095f, 
    0.20637918f, 0.08836937f, 0.09525350f, 0.22108676f, 0.01423146f, 0.01177537f, 0.09611262f, 0.12621866f, 
    0.08378612f, -0.04462439f, 0.02741429f, 0.07291737f, 0.02533945f, 0.08461723f, 0.20835651f, -0.16082893f, 
    -0.24983788f, -0.04366393f, 0.00732548f, -0.01103965f, 0.21281584f, -0.11273142f, -0.09898498f, 0.26775348f, 
    0.00659957f, -0.16338883f, 0.02590580f, -0.11224542f, 0.08677405f, 0.11680345f, -0.02875617f, -0.08838460f, 
    0.16441566f, -0.11744277f, -0.16051567f, -0.09459339f, 0.08697239f, 0.09871049f, 0.10349081f, 0.13313302f, 
    0.01303139f, -0.02383095f, -0.19475104f, -0.14235646f, -0.13365699f, 0.06832353f, -0.05594962f, -0.01929754f, 
    0.05220571f, -0.12141568f, -0.38154912f, 0.06533346f, -0.03265887f, -0.06790325f, -0.15145436f, 0.19669120f, 
    0.14462903f, 0.05702526f, 0.06487004f, 0.50871634f, -0.22583883f, -0.26853144f, -0.06780946f, -0.00546889f, 
    0.05310486f, -0.05794941f, 0.25345209f, -0.14889206f, 0.21868367f, -0.07804083f, -0.33234164f, -0.22647050f, 
    0.16840078f, -0.05200631f, 0.03030322f, 0.18955700f, -0.09905076f, -0.42230994f, -0.06992579f, 0.00486368f, 
    -0.04871718f, -0.10302302f, 0.13937131f, 0.22552459f, -0.10071421f, 0.12649527f, -0.09527982f, 0.14759454f, 
    0.22088258f, -0.16392373f, -0.09460530f, -0.06403530f, -0.07653537f, -0.02528463f, 0.01000421f, -0.08221758f, 
    0.13225603f, 0.17925934f, -0.07756926f, 0.10964775f, -0.11267508f, 0.00792863f, -0.20878802f, -0.11927313f, 
    0.26172283f, -0.02980785f, -0.00200472f, -0.16029106f, -0.14835209f, -0.03548699f, 0.03156907f, 0.09770704f, 
    0.03906259f, 0.17987974f, 0.30562976f, -0.57450008f, -0.06080678f, 0.14148255f, 0.17513831f, 0.01926774f, 
    0.08249920f, -0.13395880f, 0.14547907f, -0.04215148f, 0.14959440f, -0.02335391f, 0.01329137f, -0.01304981f, 
    -0.05083426f, -0.00489832f, 0.12845024f, 0.20740122f, 0.34371045f, 0.31910807f, 0.10878903f, -0.13372199f, 
    -0.10401176f, 0.07103678f, -0.01529239f, -0.09574444f, 0.17056994f, -0.32641092f, -0.49061030f, -0.19270726f, 
    -0.12645134f, 0.01535655f, 0.00394193f, 0.07628180f, 0.11365290f, -0.28033397f, -0.24731511f, -0.00275689f, 
    -0.06468169f, 0.02038351f, -0.09267224f, 0.03158584f, -0.02333210f, 0.16852002f, -0.10615441f, -0.11702693f, 
    0.06810356f, -0.01490435f, 0.16191448f, -0.17013915f, -0.11630732f, 0.24973726f, 0.03225693f, 0.04679430f, 
    0.22848986f, -0.02666847f, -0.06996385f, 0.12541230f, -0.09706891f, 0.01387837f, 0.08221644f, 0.00118521f, 
    -0.22420654f, -0.26659131f, 0.13718675f, 0.04550744f, -0.04012829f, 0.04826802f, 0.00555397f, 0.06786098f, 
    0.00203329f, -0.27871656f, 0.07044650f, 0.02901910f, 0.01577181f, 0.06128793f, -0.06159795f, 0.17405421f, 
    -0.09473453f, -0.05481546f, 0.27664933f, 0.12043526f, 0.54374224f, -0.04455800f, -0.02763366f, 0.02177795f, 
    0.05739955f, -0.16570391f, 0.11349649f, -0.01110759f, 0.25812179f, 0.37696972f, -0.00342715f, 0.20132631f, 
    -0.03844809f, -0.03434710f, 0.00341520f, -0.06333915f, -0.12755205f, 0.05801903f, -0.43639231f, 0.01461778f, 
    -0.07863726f, -0.00250476f, 0.06938215f, -0.02417588f, -0.06734516f, -0.21894374f, -0.11429706f, 0.00233149f, 
    -0.00247662f, -0.04658942f, -0.04959611f, 0.06540201f, -0.04314603f, -0.05504995f, 0.05953873f, 0.14226854f, 
    0.22259808f, 0.03443707f, 0.08367132f, -0.08667988f, 0.12891836f, -0.02684774f, 0.08709182f, -0.15470743f, 
    -0.12767456f, -0.18930560f, 0.00726099f, 0.14187856f, -0.09945629f, -0.07786731f, 0.05772205f, 0.09241642f, 
    -0.02410930f, 0.00165504f, 0.10715486f, -0.26152495f, -0.22514267f, 0.20950073f, -0.02700284f, 0.03226363f, 
    -0.05069340f, 0.00926687f, -0.23918730f, 0.23162593f, -0.07973872f, -0.00726957f, 0.04473560f, -0.16396841f, 
    0.12223713f, 0.12338616f, 0.07180962f, 0.10277886f, -0.06043580f, 0.00924474f, -0.02569920f, -0.08865935f, 
    0.05352212f, -0.10701028f, 0.18055832f, -0.10492867f, -0.06188455f, -0.15000339f, 0.06452500f, -0.00162772f, 
    -0.00138506f, 0.09608153f, -0.07078424f, 0.12360346f, -0.14886190f, -0.09918018f, 0.12488488f, 0.03464641f, 
    -0.05177941f, -0.13330166f, 0.05920918f, 0.00878500f, -0.07762834f, -0.03108837f, 0.07590083f, 0.05038095f, 
    0.05388551f, -0.01935946f, -0.02268246f, 0.11903366f, 0.05221745f, 0.18276221f, -0.12213758f, -0.00424930f, 
    0.01955814f, -0.04615613f, -0.22314250f, 0.06838720f, 0.16490318f, 0.04649634f, -0.15841465f, 0.35410315f, 
    0.29811552f, 0.09570530f, 0.05844736f, 0.10347809f, -0.12539124f, -0.03075940f, -0.26609120f, 0.25748983f, 
    0.21585196f, 0.21277153f, 0.19255029f, -0.17719345f, -0.05981323f, -0.16697697f, 0.02123425f, -0.11867745f, 
    -0.08780934f, 0.24682605f, 0.31582344f, 0.35537869f, -0.09151129f, -0.03555668f, -0.10252438f, -0.15086927f, 
    -0.04985582f, -0.02239237f, -0.14338759f, -0.16244902f, 0.06596635f, -0.02391319f, 0.09577286f, -0.06039401f, 
    0.10691790f, -0.07736234f, -0.20356390f, 0.16308054f, 0.04957310f, 0.35797226f, 0.02971238f, -0.02397967f, 
    0.23695762f, 0.11870106f, -0.11979486f, -0.08506613f, 0.12664840f, -0.02712532f, -0.20559719f, 0.14224888f, 
    -0.05745355f, 0.10873003f, 0.04608463f, 0.01757057f, -0.05642310f, -0.20671694f, -0.10670526f, -0.14378721f, 
    0.12495154f, 0.01668148f, -0.06888004f, 0.04025890f, -0.12080617f, -0.00755468f, -0.09771874f, 0.09071527f, 
    0.05259910f, 0.04214276f, -0.10673419f, -0.17507948f, -0.02478447f, 0.02676391f, -0.05008829f, -0.03793267f, 
    -0.02820509f, -0.10110958f, -0.06288058f, -0.06304238f, 0.01712640f, 0.25477269f, 0.13264059f, 0.02437786f, 
    0.00160627f, 0.17549336f, -0.00938500f, -0.25993586f, -0.13803433f, -0.10316714f, 0.09833041f, -0.02811727f, 
    0.00029254f, -0.24727812f, 0.02947618f, -0.15534244f, 0.12635967f, 0.07348957f, 0.16303465f, 0.11402882f, 
    -0.04051021f, 0.00771359f, -0.18153824f, -0.08888040f, 0.08474696f, -0.04668713f, -0.05279025f, -0.19373268f, 
    0.01951639f, 0.05287262f, -0.06032133f, -0.15392180f, 0.18677585f, 0.01025500f, -0.13189645f, -0.01991945f, 
    0.04757859f, 0.02012788f, 0.00648935f, 0.01474594f, -0.12346626f, -0.06325518f, -0.01831153f, -0.11118937f, 
    -0.01828873f, -0.22014090f, -0.02801158f, 0.00510193f, 0.09463728f, 0.27333757f, 0.16312668f, 0.24623938f, 
    0.04255993f, 0.14286107f, 0.09650762f, -0.04022843f, 0.04120748f, -0.01247996f, 0.27977055f, -0.38718811f, 
    -0.02686009f, -0.10876362f, 0.02232838f, 0.05467310f, 0.06603138f, -0.19986349f, 0.09216811f, -0.20745523f, 
    -0.33963418f, -0.07093993f, 0.05580910f, 0.02238741f, 0.14681622f, 0.03428578f, -0.11178956f, 0.10303298f, 
    0.04367903f, 0.11017472f, 0.23043364f, 0.10490268f, 0.19218089f, -0.12743019f, 0.20139520f, 0.18967238f, 
    -0.02086064f, -0.07778094f, -0.02078000f, 0.04406482f, -0.04857969f, -0.17410630f, -0.18228398f, 0.04237813f, 
    -0.05352212f, 0.12444548f, -0.14737287f, -0.04138082f, 0.16033246f, 0.01852423f, -0.07663013f, 0.08498918f, 
    0.14047541f, 0.05278289f, -0.16717584f, -0.06540807f, -0.28735343f, -0.51151645f, -0.05022683f, 0.02863567f, 
    0.05372186f, 0.12635742f, -0.01127208f, -0.09137315f, 0.20548894f, 0.25732854f, -0.16234204f, -0.06188117f, 
    0.11954102f, 0.12418786f, 0.02959242f, 0.01546131f, -0.04541886f, 0.17406903f, 0.02562449f, 0.01604757f, 
    -0.06278633f, 0.04880421f, -0.00639476f, 0.00195230f, -0.02236670f, 0.13716765f, -0.03149698f, -0.24604437f, 
    -0.37602544f, -0.01219360f, -0.06334704f, -0.01232999f, 0.09368847f, -0.00344411f, 0.00274643f, -0.09604312f, 
    -0.06193187f, 0.04808802f, 0.03469840f, 0.12320299f, 0.04710317f, 0.08920919f, 0.07503925f, 0.13185759f, 
    -0.10488893f, 0.02268879f, -0.05193537f, -0.21151593f, -0.05659406f, 0.05091707f, 0.07219755f, -0.16604818f, 
    0.02023274f, -0.09892822f, -0.14139952f, -0.17776389f, -0.01772984f, 0.04808420f, -0.26431307f, 0.09706591f, 
    -0.02787564f, -0.07349540f, -0.13034837f, 0.07291691f, 0.01883669f, 0.04619166f, -0.15281668f, 0.00129112f, 
    0.08770795f, -0.17067391f, -0.09321848f, -0.05228778f, 0.17627299f, 0.17504658f, -0.02170725f, -0.10156133f, 
    0.15642187f, -0.19666810f, -0.12020978f, 0.02685863f, 0.07890725f, 0.14825027f, 0.02750007f, 0.14486735f, 
    0.34828088f, 0.03227091f, 0.22321896f, 0.28141770f, 0.19357041f, 0.08571436f, -0.02628412f, 0.04381204f, 
    0.06024765f, -0.19204482f, -0.09320988f, -0.13316986f, 0.03470683f, 0.08791698f, -0.25903395f, -0.14056979f, 
    0.03851953f, -0.02443894f, -0.14298043f, 0.21069556f, -0.04069012f, -0.11487186f, 0.05124341f, -0.00430840f, 
    -0.04504411f, 0.33475652f, -0.01544826f, -0.04826938f, 0.04052253f, 0.11454133f, -0.06068053f, -0.36595923f, 
    -0.07883486f, 0.01930572f, -0.38179460f, 0.02559139f, 0.13415411f, 0.01678973f, 0.10667796f, 0.00664116f, 
    -0.12186536f, -0.20175980f, 0.15988404f, -0.51764339f, -0.00326878f, 0.07912546f, -0.22490589f, 0.07646458f, 
    -0.02530868f, -0.46743137f, 0.10786436f, -0.09868395f, 0.07462603f, -0.01261180f, 0.07630627f, 0.02577302f, 
    -0.02203184f, -0.04962755f, 0.17525120f, -0.14277376f, -0.10968359f, -0.13534217f, 0.03871547f, -0.08203724f, 
    0.05063952f, -0.07785270f, -0.10616355f, -0.16630927f, -0.37539491f, 0.38966188f, 0.08286475f, 0.06836732f, 
    0.13691425f, -0.00936287f, 0.02458032f, 0.07549332f, -0.02812217f, -0.00376960f, 0.05407800f, 0.08587978f, 
    -0.02048243f, 0.08765875f, 0.10650900f, 0.08538912f, 0.10642576f, -0.02373887f, -0.07545340f, 0.03833505f, 
    -0.10779092f, -0.05708965f, 0.04698781f, 0.03173724f, 0.00599607f, -0.06904043f, 0.16586517f, 0.06380963f, 
    0.23771337f, -0.20416845f, 0.15838012f, 0.15277836f, 0.06005421f, 0.16056971f, 0.10334607f, -0.03987006f, 
    0.02438634f, 0.03438517f, -0.06057061f, -0.01116857f, -0.04241631f, 0.00497047f, -0.03603816f, 0.01334071f, 
    -0.02033004f, 0.02548935f, 0.02418073f, -0.01890621f, -0.02476299f, 0.02072160f, -0.02123602f, -0.02823407f, 
    0.02235057f, 0.01501355f, 0.01737115f, 0.00307480f, 0.01833790f, -0.03100080f, 0.00909269f, -0.01851897f, 
    -0.04390452f, 0.01618345f, 0.02798566f, 0.00131512f, -0.02859257f, 0.05207790f, 0.03175549f, -0.00669205f, 
    0.00948499f, -0.02878570f, -0.03146636f, -0.04288401f, -0.05970890f, -0.02031847f, -0.06285702f, 0.00190287f, 
    -0.03269170f, 0.01420606f, -0.05157344f, -0.06448210f, -0.04108953f, -0.06352561f, 0.02136107f, -0.05222385f, 
    -0.04105501f, -0.01035641f, -0.02266966f, 0.04692694f, 0.04286632f, -0.03800757f, 0.02100908f, -0.05045022f, 
    0.02709485f, 0.00230420f, 0.04796205f, -0.02094450f, -0.02554927f, -0.05122340f, 0.04754872f, 0.01781235f, 
    -0.05093423f, -0.01916574f, -0.00280190f, -0.01365208f, 0.01818084f, -0.06389076f, 0.01273024f, -0.03504625f, 
    -0.01467092f, 0.04516696f, 0.02102077f, -0.05489142f, -0.03213474f, 0.02966143f, 0.04380542f, 0.00266956f, 
    -0.04461212f, 0.03398594f, 0.04848053f, 0.04756752f, -0.02727137f, -0.00171660f, -0.04429974f, 0.03652459f, 
    0.01553962f, -0.03035186f, -0.03063427f, 0.04206095f, -0.02650397f, -0.06089260f, -0.05107052f, 0.00938816f, 
    -0.00130914f, -0.03158741f, -0.05660817f, 0.04258601f, -0.05356932f, -0.02381869f, -0.02441706f, -0.02923375f, 
    0.01448287f, -0.05553348f, 0.01192249f, -0.01529557f, 0.02706642f, -0.03972435f, -0.04453076f, 0.00835356f, 
    -0.00111220f, 0.00195624f, 0.00429437f, 0.01155632f, 0.02676119f, -0.05150121f, 0.02792516f, -0.05426611f, 
    -0.01216867f, -0.02194897f, -0.00658087f, -0.00188040f, -0.00283548f, 0.01062384f, 0.00525798f, -0.00575241f, 
    0.01815660f, -0.02945634f, -0.00343995f, 0.02262248f, -0.05297213f, 0.03982861f, 0.03017851f, 0.03392293f, 
    -0.00408420f, -0.04077892f, 0.01842791f, 0.00262706f, 0.03474311f, -0.05336070f, -0.01631822f, 0.01824588f, 
    0.04314842f, 0.04176413f, -0.01611925f, 0.03456042f, 0.02227547f, -0.04288596f, 0.00120741f, 0.03666186f, 
    0.01071776f, -0.05964109f, 0.00118844f, -0.02223301f, -0.01674132f, 0.00303071f, -0.05736425f, 0.03134291f, 
    0.00732164f, -0.01763117f, -0.04780674f, 0.04757095f, -0.04152980f, -0.01197956f, -0.01663131f, 0.04837126f, 
    -0.04539407f, 0.02169332f, -0.04014868f, -0.02695087f, -0.06285919f, -0.00628076f, 0.02520715f, -0.04432645f, 
    -0.00432573f, 0.02773529f, 0.00185535f, -0.03210957f, -0.00943421f, 0.05267103f, 0.01981222f, 0.02434878f, 
    0.03118469f, 0.02115353f, -0.00231052f, 0.04722346f, -0.01264071f, 0.02109827f, 0.04395228f, 0.00586019f, 
    0.02008053f, -0.05397622f, 0.04708995f, -0.05700578f, -0.06066592f, 0.04417707f, 0.03866436f, -0.03765400f, 
    -0.00488416f, 0.02338311f, 0.01048329f, -0.03579137f, 0.02523081f, -0.04550991f, -0.05893849f, 0.00829136f, 
    -0.05009988f, -0.02879646f, -0.00666160f, -0.04786367f, -0.03047256f, 0.02137307f, -0.06231189f, -0.00784779f, 
    -0.05274042f, -0.04641710f, -0.01394352f, 0.00336314f, -0.03410608f, -0.06069567f, 0.03794296f, -0.01044990f, 
    0.05096594f, -0.00469272f, 0.05146792f, 0.03304609f, 0.04201718f, -0.04043045f, -0.01911701f, -0.01570583f, 
    -0.01518286f, 0.03034109f, 0.01209882f, -0.05429370f, -0.05239629f, -0.03998217f, 0.04663121f, -0.06408385f, 
    -0.04270834f, 0.00911375f, 0.05027755f, -0.00619310f, 0.02609246f, -0.00132791f, 0.02169746f, -0.04116205f, 
    -0.01308636f, 0.00615785f, -0.05207984f, 0.03678524f, 0.00579765f, 0.05606931f, 0.02333728f, 0.01724227f, 
    0.03782710f, -0.02159142f, -0.02375179f, -0.04920799f, -0.03756374f, 0.01765692f, 0.01254899f, -0.01622873f, 
    -0.01989173f, 0.01065111f, -0.03612619f, -0.00043800f, -0.05944017f, 0.00489117f, -0.05188903f, 0.01900831f, 
    0.01133849f, -0.03228180f, -0.01453372f, 0.02120686f, 0.01735396f, 0.04435333f, -0.05642118f, 0.02615681f, 
    0.00672243f, 0.03082023f, 0.03856197f, -0.02657956f, -0.03626271f, -0.00532149f, -0.01154278f, -0.00262513f, 
    0.17761543f, -0.00330831f, -0.13876268f, -0.01056888f, 0.02086500f, 0.08659498f, -0.20533165f, -0.04343774f, 
    -0.03599690f, -0.33783835f, 0.21747877f, -0.16964492f, -0.02833933f, 0.05224450f, 0.04814828f, -0.03433436f, 
    -0.10840932f, 0.12013502f, 0.30400184f, -0.00564558f, 0.03676487f, 0.20382188f, 0.08179667f, -0.28524169f, 
    -0.04522609f, -0.03531086f, -0.08362918f, 0.19410895f, -0.04638572f, -0.09022109f, 0.07738320f, 0.19884455f, 
    -0.06851698f, 0.15555814f, -0.14728181f, -0.04154623f, -0.03222882f, -0.07895291f, -0.03623209f, 0.13045670f, 
    -0.00115711f, 0.11765566f, 0.01022717f, 0.20720947f, 0.11279053f, -0.14604625f, -0.08460210f, -0.05290315f, 
    -0.04264065f, 0.04775694f, -0.10694785f, -0.07417578f, -0.26227218f, 0.00038143f, -0.03496532f, 0.07481562f, 
    -0.18201080f, -0.09536899f, 0.03988106f, 0.18750368f, 0.02430226f, 0.10848574f, 0.02534008f, 0.05756035f, 
    -0.08878597f, -0.17252640f, 0.01078993f, -0.09862077f, 0.20343803f, 0.04812157f, 0.04316142f, -0.07914307f, 
    -0.05951127f, -0.00246973f, -0.09842125f, -0.09569019f, 0.01865324f, -0.01302604f, 0.04375577f, 0.01227004f, 
    0.12505637f, 0.09332822f, -0.03849990f, -0.00693367f, 0.11187164f, 0.04696483f, 0.01322216f, 0.00162748f, 
    -0.05486007f, 0.14064243f, 0.28415734f, 0.15389174f, 0.04339188f, 0.08558385f, 0.24981616f, -0.27125579f, 
    0.12066307f, 0.19247656f, -0.09004321f, 0.01167179f, 0.11322217f, 0.02784978f, 0.03575357f, -0.29086891f, 
    -0.19720683f, -0.08704370f, 0.08748030f, 0.04598964f, -0.03676020f, -0.04189353f, 0.11868986f, -0.07666717f, 
    -0.12592779f, 0.02103133f, -0.12690130f, 0.07806309f, 0.14162298f, -0.13643755f, -0.13986729f, -0.24250343f, 
    0.11902811f, -0.01219605f, -0.04129355f, 0.09603299f, 0.09708214f, -0.07908660f, 0.06935247f, 0.02329748f, 
    -0.16637619f, 0.08208086f, -0.03413122f, -0.02172892f, -0.04446065f, -0.14368017f, -0.03438998f, 0.09866425f, 
    -0.16855253f, -0.00122836f, -0.21900859f, 0.13257702f, 0.19697185f, -0.13952048f, 0.06995016f, -0.06774160f, 
    0.15207078f, -0.04204270f, 0.15042539f, -0.05592330f, 0.03896030f, 0.06267421f, -0.09628840f, -0.24976148f, 
    0.10221955f, 0.10676038f, -0.08851319f, 0.04191245f, 0.08311743f, 0.13347308f, -0.16744784f, -0.00113184f, 
    0.09187524f, -0.04138026f, 0.14781691f, -0.13636602f, -0.01831448f, 0.22722043f, 0.04529452f, -0.07127471f, 
    -0.01998737f, 0.01847538f, -0.07457583f, -0.00091689f, -0.00926265f, -0.14108223f, 0.02886936f, 0.07636345f, 
    0.02613432f, -0.19287562f, -0.05862824f, 0.07689228f, -0.08264801f, -0.18599890f, -0.08626074f, -0.12334654f, 
    -0.09352212f, 0.02677368f, -0.13520451f, -0.04936236f, 0.11124854f, 0.10329214f, 0.03012681f, 0.03495839f, 
    -0.04742652f, 0.00121124f, 0.11902491f, -0.08384634f, -0.12366120f, -0.00638301f, 0.13741866f, -0.08101121f, 
    0.02210569f, 0.09678236f, 0.09181935f, 0.06706756f, -0.13339016f, -0.36676484f, -0.22591291f, 0.07091045f, 
    -0.09404638f, -0.10100103f, 0.14849861f, 0.06984027f, 0.04565557f, -0.02001094f, -0.05192372f, -0.06377683f, 
    0.11431357f, 0.00476356f, -0.15188065f, 0.13205345f, -0.01956357f, -0.01343210f, 0.00511826f, -0.26888630f, 
    -0.04443837f, 0.16087514f, 0.25428167f, -0.07014795f, 0.32491943f, -0.09740400f, 0.06515212f, -0.02996627f, 
    -0.10001530f, -0.02562564f, -0.01918115f, -0.13290505f, -0.07130312f, -0.06229894f, 0.03096535f, 0.02215596f, 
    0.05512371f, 0.13202979f, 0.09996469f, 0.02531438f, 0.25233930f, -0.17156091f, -0.08152100f, -0.29110515f, 
    -0.00113681f, 0.05450676f, 0.03770513f, 0.09504455f, 0.45405802f, -0.21636628f, -0.16050640f, -0.18678482f, 
    0.22155289f, -0.04134207f, -0.07048637f, -0.03892762f, -0.17648552f, -0.01458299f, 0.04690144f, -0.05928192f, 
    0.11535761f, 0.03101326f, -0.01642456f, -0.05365566f, 0.02632621f, 0.14966922f, 0.14749543f, -0.04573018f, 
    -0.27345791f, 0.03419608f, 0.08139929f, 0.07907293f, 0.07701918f, 0.04168305f, -0.04802028f, -0.04737341f, 
    0.05174730f, -0.06540211f, -0.05326021f, -0.02000177f, -0.00396565f, -0.10155431f, 0.00030936f, -0.01504618f, 
    0.05528944f, 0.32654804f, 0.17109935f, -0.24269734f, 0.05604915f, -0.02580928f, 0.00496896f, -0.12157239f, 
    -0.16595687f, 0.16706119f, -0.07728265f, 0.20948833f, 0.01241923f, 0.08935307f, 0.26784530f, 0.09317699f, 
    -0.13821559f, 0.13834813f, 0.18504649f, 0.03419554f, -0.09779202f, 0.08355469f, -0.00084292f, 0.02971468f, 
    0.02661170f, -0.01922027f, 0.09494030f, 0.29546034f, -0.00396607f, 0.12120568f, 0.08569305f, 0.03935809f, 
    -0.02038611f, -0.06550127f, -0.04910663f, -0.09688437f, 0.09471137f, -0.14220044f, -0.03127539f, 0.03027389f, 
    -0.17035970f, 0.00893313f, 0.14687082f, 0.09621714f, -0.00763355f, -0.00685295f, 0.04368189f, 0.14126162f, 
    -0.06588997f, -0.02218371f, 0.04339516f, -0.12653179f, -0.06672855f, -0.11829398f, 0.13245749f, 0.16375543f, 
    -0.00761146f, 0.20359026f, 0.07390827f, 0.00297427f, 0.13022435f, -0.00492869f, -0.19739270f, -0.07223745f, 
    -0.17218016f, -0.01733024f, -0.01594919f, -0.03562644f, 0.14870726f, -0.09632577f, -0.19029669f, 0.06813740f, 
    0.02179766f, 0.07032400f, -0.03463153f, 0.13543883f, 0.07155500f, -0.09857969f, -0.01391992f, 0.01312636f, 
    -0.23018052f, 0.23052172f, 0.09573276f, 0.11053065f, 0.04933370f, 0.00257049f, 0.07501552f, 0.24781813f, 
    -0.02619438f, 0.01898038f, 0.19161765f, 0.14210029f, 0.24197039f, 0.08312855f, 0.11956266f, -0.08271638f, 
    0.16421990f, -0.14366326f, -0.04835363f, -0.03626570f, -0.22260264f, -0.06058328f, -0.05556339f, 0.02233873f, 
    0.05381706f, 0.12149593f, 0.04788749f, 0.00323690f, 0.10613903f, -0.14100413f, 0.12187677f, -0.06956991f, 
    -0.12238562f, -0.08671524f, 0.12250690f, -0.13533771f, -0.08795166f, 0.06980414f, 0.06553135f, 0.11123586f, 
    0.01704772f, 0.09074149f, -0.04988819f, 0.26354060f, -0.10328798f, -0.11151313f, -0.25138384f, -0.06482845f, 
    -0.07711297f, -0.00065806f, 0.08331376f, 0.01229028f, -0.02441670f, 0.04734461f, 0.07604887f, 0.14676403f, 
    0.04208511f, -0.04827110f, 0.00201768f, -0.00161687f, -0.10070755f, 0.06496592f, -0.07855255f, 0.02806793f, 
    0.14212677f, 0.11943588f, -0.09352899f, -0.01468061f, -0.07550404f, -0.09665678f, 0.01101960f, -0.13795342f, 
    -0.11806610f, -0.07740473f, -0.12571423f, -0.21385355f, 0.06683666f, -0.10681661f, -0.03054326f, 0.13416821f, 
    -0.00876488f, 0.05617762f, -0.05575905f, -0.02926150f, -0.23034276f, 0.01747995f, -0.01499059f, 0.01428542f, 
    0.03191299f, -0.02843418f, 0.11795240f, 0.10193530f, 0.08339712f, 0.23092903f, -0.03163525f, -0.12522817f, 
    0.07695913f, 0.02804902f, 0.02255774f, -0.08862644f, -0.02828247f, -0.00990890f, -0.05303749f, -0.03293791f, 
    0.06921895f, 0.13795155f, 0.02990231f, -0.00558206f, -0.00650341f, 0.07788085f, 0.09436394f, 0.06456763f, 
    0.16633290f, -0.02897649f, -0.10114402f, -0.04065352f, -0.05174256f, -0.10451445f, 0.16124249f, 0.10344733f, 
    -0.01655796f, 0.13005915f, 0.02714371f, -0.00658978f, -0.02955147f, -0.07093833f, -0.14683400f, -0.24264407f, 
    -0.00876647f, 0.18824378f, -0.10626159f, 0.01892660f, -0.03030828f, 0.07058041f, -0.09513508f, -0.03151043f, 
    -0.21463089f, -0.21020396f, -0.25139731f, 0.15878002f, 0.08555312f, -0.01004096f, -0.05585453f, -0.19047828f, 
    -0.08869912f, -0.08816157f, -0.18903106f, -0.31008369f, 0.00704864f, 0.02069127f, -0.10963783f, -0.00048142f, 
    -0.07579150f, -0.13927537f, 0.28170407f, 0.13194561f, -0.15709075f, 0.13894548f, -0.02261162f, -0.09127762f, 
    0.06896741f, -0.07197494f, 0.05924919f, -0.18842824f, -0.11561985f, 0.10253792f, 0.03845514f, 0.12081059f, 
    0.04187790f, -0.12924162f, 0.08214606f, 0.17448922f, -0.23946898f, -0.01788227f, 0.05941901f, 0.12800369f, 
    0.13044092f, 0.11664483f, -0.25939119f, 0.06763879f, 0.10540494f, 0.26678887f, -0.00243822f, 0.22860312f, 
    0.09002464f, 0.11262375f, 0.12639105f, 0.13381062f, 0.06649026f, 0.03432681f, 0.11846001f, 0.10132318f, 
    0.02613795f, 0.13145001f, -0.00546452f, -0.03710182f, 0.09379179f, 0.02845466f, 0.13561893f, 0.00094037f, 
    -0.18935746f, 0.19965887f, -0.09692631f, 0.07286263f, 0.00948733f, -0.00661940f, 0.03526049f, 0.09822429f, 
    -0.05572076f, 0.00840236f, 0.00458584f, 0.11735295f, 0.15129229f, 0.07099757f, -0.11781682f, 0.08495417f, 
    0.05126020f, 0.61392832f, 0.02086228f, -0.45293704f, -0.05820546f, 0.23845632f, 0.13809742f, 0.09613328f, 
    0.10007348f, -0.03044413f, -0.09197795f, -0.09428906f, -0.08502519f, -0.06700879f, -0.21358030f, -0.11711282f, 
    0.03785225f, -0.00631529f, -0.03523038f, 0.23909101f, 0.04118738f, -0.06178105f, 0.12875007f, 0.07274088f, 
    -0.19729617f, 0.09840862f, 0.08545168f, -0.19522654f, -0.22544321f, 0.01330960f, -0.34780699f, 0.07440899f, 
    0.06441458f, 0.02950508f, -0.14613856f, 0.04356383f, 0.01301874f, -0.09301142f, -0.17264561f, -0.17192578f, 
    0.03942026f, 0.11322808f, -0.03932711f, 0.01907517f, -0.00419115f, 0.03098766f, -0.12827131f, -0.00227877f, 
    -0.03810384f, -0.11784765f, -0.08771668f, 0.02926935f, 0.04492211f, 0.18043056f, -0.20247450f, 0.04911382f, 
    0.03954195f, 0.09985583f, 0.02049011f, 0.29404980f, 0.07135079f, -0.05464411f, 0.06185269f, -0.02870292f, 
    -0.08962014f, -0.11308934f, -0.10783913f, -0.08396115f, 0.08545101f, -0.22277036f, 0.07826611f, -0.04130720f, 
    -0.06015089f, -0.16330254f, -0.20038080f, -0.05285430f, 0.00896412f, 0.14624777f, -0.06186420f, 0.05953846f, 
    -0.07979432f, 0.08709329f, -0.24555123f, -0.07796919f, -0.39452013f, 0.27092636f, -0.21211110f, -0.13168237f, 
    0.20121004f, 0.19735795f, -0.00860566f, 0.26055279f, 0.03809281f, 0.29956293f, 0.08426995f, -0.12676950f, 
    0.04625195f, -0.00932421f, 0.12531984f, 0.01901058f, -0.21778803f, -0.02506393f, -0.13053928f, 0.03317455f, 
    0.01419177f, -0.07976189f, 0.02939450f, -0.03335578f, -0.07591181f, -0.09408133f, -0.19749807f, -0.08447140f, 
    0.08839390f, 0.04623463f, -0.03843234f, -0.01931761f, 0.14162153f, 0.11776214f, 0.02133098f, 0.10382008f, 
    0.08098131f, 0.13166955f, -0.06493171f, -0.01758085f, -0.05980762f, 0.06589054f, -0.06285825f, -0.09054380f, 
    -0.41892317f, -0.07943326f, 0.03198491f, 0.17653494f, 0.04468472f, 0.14091484f, -0.00902206f, -0.00267418f, 
    -0.16953886f, -0.00318310f, -0.05428212f, 0.06524429f, 0.08897745f, 0.06428691f, -0.22275679f, 0.29768199f, 
    0.00753350f, -0.01729980f, 0.01095026f, -0.08429049f, -0.03876139f, 0.02122577f, -0.01917364f, -0.04294120f, 
    0.08904291f, -0.01757556f, -0.11811925f, -0.02907132f, 0.14584792f, -0.03033396f, -0.13937274f, -0.07882600f, 
    0.01278047f, -0.01624257f, 0.17415693f, 0.15808040f, -0.15699284f, -0.17912495f, 0.05147970f, 0.05029009f, 
    -0.04136434f, 0.03819339f, 0.05620304f, -0.03836218f, -0.09042101f, 0.08160128f, 0.19973910f, -0.25144348f, 
    -0.13651697f, -0.11459269f, 0.02057629f, -0.06053450f, 0.09540084f, -0.05107549f, 0.04900086f, 0.03510604f, 
    -0.02065486f, 0.15360118f, -0.04298712f, 0.01489023f, 0.02409114f, -0.00411468f, -0.00881199f, 0.00067599f, 
    0.01380740f, 0.12085973f, 0.15274604f, 0.14345323f, 0.01298187f, -0.01929933f, -0.13504073f, -0.09728945f, 
    -0.08053745f, -0.03196707f, 0.18313159f, -0.00118239f, -0.06253025f, 0.09071440f, 0.03021636f, 0.02887628f, 
    0.11219843f, 0.06422842f, 0.13084702f, -0.02590036f, 0.29766759f, 0.04023531f, -0.01493018f, 0.08031747f, 
    -0.11626963f, 0.07047015f, 0.26722232f, 0.10274369f, 0.02933669f, 0.21706575f, 0.33088475f, 0.04055363f, 
    -0.05729195f, -0.03089846f, -0.20134197f, -0.35704920f, -0.04321990f, 0.13290231f, 0.19781506f, 0.10492067f, 
    0.02276932f, 0.04038325f, -0.06635707f, 0.36220717f, 0.29761514f, 0.07607412f, 0.08310090f, -0.17046519f, 
    -0.01457852f, -0.05280603f, 0.03066469f, -0.01591972f, 0.37167996f, -0.24101704f, 0.07220218f, -0.04083766f, 
    0.24530974f, -0.16395456f, 0.06258954f, -0.00519711f, -0.21442768f, 0.10464248f, -0.32988653f, -0.15670152f, 
    0.01844142f, 0.00535615f, -0.02526503f, 0.10013320f, -0.01496834f, 0.06793233f, 0.15273578f, -0.17934503f, 
    0.13012932f, 0.11420190f, -0.04725431f, 0.01126263f, 0.12879963f, 0.09373634f, 0.01232454f, 0.41211060f, 
    0.13146655f, -0.26406178f, 0.03759626f, 0.06000102f, 0.03593852f, 0.05368210f, -0.08433314f, -0.10877921f, 
    -0.22077650f, -0.05346438f, 0.00713536f, 0.02209257f, 0.05199568f, -0.05562421f, -0.33110023f, -0.20867725f, 
    -0.10956556f, -0.26384640f, -0.00206726f, 0.03105890f, -0.05377582f, 0.01311931f, 0.14100990f, -0.00263748f, 
    0.00884978f, 0.04457869f, 0.23690684f, 0.09466546f, 0.03367129f, 0.04320625f, 0.01088290f, 0.10786933f, 
    0.01782918f, -0.04021517f, -0.13878773f, 0.10887095f, 0.09564944f, 0.25627571f, 0.05637060f, 0.09758978f, 
    -0.05074773f, 0.13334978f, 0.14546271f, 0.18159576f, 0.30863082f, -0.00977049f, -0.35279179f, 0.03289164f, 
    -0.00328174f, -0.02559259f, -0.04969549f, -0.07761922f, 0.01650735f, -0.05630858f, 0.03786923f, -0.03640240f, 
    0.09169242f, 0.06931642f, -0.07647429f, -0.05079775f, -0.01350123f, 0.10099466f, -0.09964093f, -0.08618011f, 
    0.08440522f, -0.11097684f, 0.10163108f, -0.16557969f, -0.05807192f, -0.00628222f, 0.12045271f, 0.10580576f, 
    0.16959812f, 0.16356860f, -0.01699281f, 0.06749488f, 0.09519656f, -0.08110060f, 0.08763283f, 0.09806053f, 
    -0.15477036f, 0.09229371f, 0.13753365f, 0.01599952f, 0.03561582f, 0.07001089f, 0.19209735f, -0.03211880f, 
    0.16487528f, -0.40951076f, -0.31296498f, -0.04495799f, 0.02561477f, -0.04311436f, 0.00213828f, -0.04946309f, 
    0.04936500f, -0.21950053f, 0.07745685f, 0.03583289f, 0.56231993f, 0.00386272f, 0.03243718f, -0.09746692f, 
    0.03791974f, -0.03154275f, -0.02362628f, -0.15496282f, 0.06573175f, -0.07036149f, 0.12717897f, 0.10063501f, 
    0.00687914f, 0.00980277f, -0.12104107f, -0.02049930f, 0.24825208f, -0.15788850f, -0.32393277f, 0.05160987f, 
    0.15968822f, 0.03975461f, -0.01192634f, 0.00422548f, 0.08032879f, -0.26561669f, -0.21327278f, 0.04528336f, 
    -0.00931950f, -0.03071394f, 0.02808091f, -0.18785587f, 0.03196614f, -0.00015503f, 0.07958074f, 0.05625968f, 
    -0.00662168f, 0.01148185f, 0.08340050f, 0.06210602f, 0.13083288f, -0.01313841f, -0.07998389f, -0.04155479f, 
    -0.31733865f, -0.04218630f, -0.08915605f, 0.00288477f, -0.00410173f, 0.03267740f, -0.00044555f, -0.10241651f, 
    -0.04243464f, 0.06841879f, 0.02655205f, -0.05811125f, -0.06351775f, 0.09833983f, -0.05583574f, 0.06120687f, 
    -0.01505400f, 0.12795958f, 0.06867749f, 0.19674869f, -0.02708106f, 0.02206388f, -0.02352667f, 0.02361867f, 
    -0.08075098f, -0.04915542f, 0.14382337f, 0.32886013f, -0.10321175f, -0.06446172f, 0.06906667f, 0.13186100f, 
    -0.07074746f, -0.01784249f, -0.06151893f, -0.19395958f, -0.07256000f, -0.06007667f, 0.19682407f, -0.03980229f, 
    -0.03878044f, 0.00588510f, -0.16065386f, -0.09063734f, 0.16230789f, 0.20858756f, 0.17319782f, -0.00347929f, 
    0.09063973f, 0.18935068f, 0.06053280f, 0.07912699f, -0.01635723f, -0.13873972f, -0.12440934f, -0.04835409f, 
    0.04054525f, 0.02909978f, -0.02578914f, -0.02075283f, -0.05810887f, 0.05074256f, -0.02913596f, 0.07734065f, 
    -0.01356192f, 0.02618810f, -0.10909210f, 0.06528797f, -0.05421356f, 0.16108650f, -0.03024556f, 0.18341073f, 
    0.19954939f, 0.16709580f, -0.01604105f, 0.09384500f, 0.07195061f, -0.05786752f, 0.08544285f, -0.00702311f, 
    0.10681555f, 0.22043148f, 0.17764516f, -0.14351115f, -0.01684453f, 0.09543675f, 0.04020128f, 0.06755169f, 
    0.11576580f, 0.02239089f, 0.19972028f, 0.06688090f, -0.04530290f, 0.16005623f, 0.05719317f, -0.03283959f, 
    -0.04942983f, 0.02395953f, -0.26450840f, -0.35752854f, 0.01013401f, -0.07761440f, -0.01537404f, -0.05263076f, 
    0.00437716f, 0.01293694f, 0.01179301f, 0.16127597f, -0.01812076f, 0.07785276f, 0.10571750f, 0.03129780f, 
    0.22269793f, 0.09827039f, -0.19059721f, -0.33619368f, 0.14437614f, 0.13135090f, 0.12424230f, 0.03909177f, 
    0.04930745f, -0.03226121f, -0.02352844f, 0.07162254f, -0.01430277f, -0.06008442f, -0.23007677f, -0.21741821f, 
    0.12346333f, 0.02153985f, -0.05450586f, 0.00668506f, -0.07014832f, -0.10372821f, -0.29820317f, -0.09729529f, 
    0.02258695f, -0.06251613f, -0.07048352f, 0.03887944f, -0.04728870f, -0.01046364f, -0.12546808f, -0.10173243f, 
    0.04185789f, 0.06696204f, 0.17613962f, 0.04422303f, 0.02446045f, 0.08926172f, -0.13368970f, 0.00312180f, 
    0.05515070f, 0.01669036f, -0.04946265f, 0.04426751f, -0.00749469f, -0.03959456f, -0.04455249f, -0.02590988f, 
    -0.04514628f, 0.01297568f, 0.00550542f, 0.05657063f, 0.01189440f, 0.01532963f, -0.01865441f, -0.06097086f, 
    0.00664248f, -0.03272395f, 0.02525301f, -0.05062127f, -0.01741348f, -0.06255718f, 0.04374517f, 0.03397885f, 
    0.03048590f, 0.04691625f, 0.02610754f, 0.00822761f, 0.01100021f, -0.03407429f, -0.04066392f, -0.00380830f, 
    -0.04531223f, 0.00905547f, 0.03772178f, 0.05054156f, -0.01193729f, -0.00716088f, -0.01437035f, -0.03566589f, 
    -0.04717367f, 0.00412369f, -0.04477403f, 0.03404886f, -0.06106425f, 0.00183314f, 0.05094127f, -0.05069924f, 
    0.05124958f, -0.00696326f, -0.02786554f, -0.01528406f, -0.05978654f, 0.02945478f, 0.00129395f, 0.00658117f, 
    0.00875092f, -0.02838911f, 0.02523418f, 0.01990514f, 0.00211265f, 0.03757501f, -0.06126885f, -0.04644446f, 
    -0.01107347f, 0.03946943f, 0.05412718f, 0.03578603f, -0.00792331f, 0.05040156f, 0.03891344f, -0.05538283f, 
    0.04597089f, 0.04985273f, 0.04599383f, 0.00464309f, -0.04676270f, 0.01193534f, -0.00987801f, -0.05769749f, 
    -0.03375880f, 0.02029730f, 0.03764318f, 0.04462104f, 0.00265625f, -0.03379008f, -0.01837818f, -0.01579983f, 
    0.01812302f, -0.02334748f, 0.02459394f, 0.03702521f, -0.06367565f, 0.02971218f, 0.04112774f, 0.02748664f, 
    0.02047510f, -0.04819337f, 0.01365700f, 0.02641327f, 0.04165369f, 0.00546494f, -0.03417205f, -0.03902251f, 
    -0.02584939f, -0.00608904f, 0.02225155f, -0.00788910f, 0.00717968f, -0.00763633f, 0.00343106f, 0.00694160f, 
    0.00444754f, -0.03273212f, 0.05134349f, -0.01352290f, -0.05718276f, 0.02541686f, -0.06135652f, -0.04456317f, 
    -0.05569964f, -0.04872919f, -0.01256766f, 0.04037340f, -0.05985738f, -0.00522609f, -0.03013869f, -0.00696487f, 
    0.00024755f, -0.01701679f, -0.02988897f, 0.01049715f, 0.02974789f, 0.05521797f, -0.04633841f, -0.05313892f, 
    0.00053259f, 0.01845781f, 0.04062998f, 0.04337179f, 0.04397355f, 0.04862085f, -0.02485729f, 0.01957488f, 
    0.05132442f, 0.02444985f, -0.01924243f, -0.01209828f, 0.01345625f, -0.05590883f, -0.03179589f, -0.04572880f, 
    0.01280607f, -0.06653631f, -0.06102922f, 0.03471747f, 0.04041358f, -0.01148033f, -0.05405733f, -0.00559970f, 
    0.03844587f, -0.04285720f, -0.03369274f, -0.03886868f, 0.03579746f, 0.00780306f, -0.02649862f, 0.01417484f, 
    0.00218880f, -0.00005596f, -0.00511681f, -0.04863135f, -0.02905356f, 0.05437838f, -0.02910307f, 0.04942831f, 
    0.02381023f, -0.05136950f, -0.05118774f, -0.02087763f, -0.05551352f, -0.02372908f, 0.02800491f, 0.00577745f, 
    0.01026583f, -0.06140881f, 0.00615259f, 0.03420389f, 0.01893235f, -0.05222992f, -0.01746175f, 0.04030992f, 
    0.04606448f, 0.03366100f, -0.06286796f, 0.00030823f, -0.03084256f, 0.00637421f, -0.03643135f, 0.02402552f, 
    -0.03983953f, 0.00505212f, -0.03482845f, -0.02694324f, -0.01882927f, 0.03376961f, 0.03139089f, -0.03481506f, 
    -0.06385977f, 0.02962001f, -0.00614009f, 0.01490458f, -0.04238892f, -0.06256459f, 0.03461741f, 0.01415022f, 
    -0.04432467f, -0.04274053f, 0.03129579f, -0.02461847f, -0.04031519f, 0.01720206f, -0.04813522f, -0.02742943f, 
    -0.03453786f, 0.00300435f, -0.00854962f, 0.03934343f, -0.05842712f, -0.03967034f, 0.03992144f, 0.05367074f, 
    -0.06240237f, 0.04059421f, -0.05721804f, -0.03116552f, 0.04409600f, -0.00790148f, -0.06339631f, 0.05034496f, 
    0.02958350f, 0.00779950f, 0.00812341f, -0.05836824f, -0.00366689f, 0.01811929f, -0.03581589f, -0.03079175f, 
    0.01441752f, -0.04347378f, -0.02759415f, 0.00761983f, 0.02323934f, 0.03945449f, 0.03190315f, -0.02919392f, 
    0.02824264f, -0.00342623f, -0.06398493f, -0.02433413f, 0.02316824f, -0.03923305f, 0.00150324f, 0.00019279f, 
    0.02196929f, -0.00353059f, -0.02199115f, -0.02303973f, -0.00812344f, 0.04140469f, -0.04902474f, -0.00338684f, 
    -0.06045884f, 0.02409509f, 0.02062533f, -0.01291561f, -0.02309961f, -0.05204426f, -0.04785101f, 0.01626146f, 
    -0.04641793f, 0.04188960f, 0.03715584f, -0.01604228f, -0.05568734f, -0.04854761f, 0.01330581f, -0.06417056f, 
    0.03309862f, -0.00076220f, 0.03057156f, -0.04431872f, -0.05230786f, -0.00180140f, -0.02249786f, -0.00578920f, 
    0.02925328f, 0.01986267f, -0.03278094f, -0.04309249f, -0.05726168f, 0.02182838f, -0.01728889f, -0.01326154f, 
    -0.04206327f, 0.02456421f, -0.01892886f, -0.00347728f, 0.00465204f, -0.04756264f, -0.02403680f, -0.04486784f, 
    0.01278645f, 0.02823108f, -0.00331562f, 0.00175034f, -0.02293043f, -0.04191031f, -0.01869599f, 0.01842074f, 
    -0.02666506f, -0.05382853f, 0.00443078f, -0.02642885f, -0.00579445f, -0.04249639f, -0.03367328f, -0.00531521f, 
    0.02473975f, -0.03585091f, -0.04421445f, -0.06861131f, -0.05429601f, -0.07128782f, 0.01230230f, -0.00113973f, 
    -0.04760518f, -0.04688161f, -0.02012608f, -0.02851274f, -0.07198830f, 0.01730140f, 0.02580879f, -0.03200821f, 
    0.02962581f, -0.04746411f, 0.01291288f, 0.02398858f, -0.07461195f, -0.02663896f, 0.01390396f, -0.02128748f, 
    -0.03260987f, -0.01436663f, -0.01430733f, 0.01008773f, 0.00357597f, -0.06806850f, 0.03943419f, -0.02375804f, 
    -0.01467438f, -0.07077050f, -0.00512793f, 0.00252481f, 0.02621591f, 0.03181714f, 0.01370821f, -0.04706516f, 
    -0.01518242f, 0.02363868f, 0.02402601f, 0.02316532f, 0.02278536f, 0.03221187f, -0.00605078f, 0.00020927f, 
    -0.00820216f, -0.04403353f, -0.00777604f, 0.00939833f, -0.04710990f, 0.03765281f, 0.00056935f, -0.00049817f, 
    -0.06715754f, -0.02732805f, 0.04483213f, -0.07016777f, 0.01730955f, 0.02830558f, -0.01809347f, 0.00938644f, 
    0.02329246f, -0.01911678f, -0.05036729f, -0.03379604f, 0.01650655f, -0.03215716f, -0.05174344f, -0.05938307f, 
    0.00464508f, 0.02117243f, 0.03313782f, -0.04283386f, -0.06453371f, 0.03419727f, -0.02563522f, -0.03997435f, 
    -0.06807732f, -0.03430175f, 0.02459748f, 0.00328715f, -0.03673399f, -0.03616991f, 0.02938876f, 0.01442762f, 
    -0.04970748f, 0.03974352f, -0.02505264f, -0.02974294f, -0.03058659f, -0.04011302f, -0.01426883f, -0.02542364f, 
    0.01565404f, -0.01483090f, 0.01763294f, -0.03975542f, -0.03562531f, -0.00601707f, 0.01825125f, -0.07007744f, 
    -0.03111375f, 0.03516676f, 0.03851008f, 0.04992792f, 0.04504346f, -0.01778187f, -0.05296981f, 0.03203463f, 
    -0.02931906f, 0.03630574f, -0.05803128f, -0.00136101f, -0.04744031f, -0.04770339f, -0.01824563f, 0.03470956f, 
    -0.07010277f, -0.06818982f, -0.04710779f, 0.01166611f, 0.04459254f, 0.04527293f, 0.00658821f, 0.01569463f, 
    0.02183611f, -0.03224716f, 0.01731520f, 0.01100235f, 0.00509935f, 0.01626059f, -0.01771781f, -0.06610690f, 
    -0.03512295f, 0.03003045f, 0.00601397f, -0.06073365f, -0.03022752f, -0.02566828f, 0.00539306f, 0.00725281f, 
    -0.07248168f, -0.04664124f, -0.00553751f, -0.00969645f, -0.05144113f, 0.02878040f, -0.04434624f, -0.04730000f, 
    -0.01696742f, -0.06593136f, 0.00230290f, 0.02462374f, -0.04512465f, 0.00252614f, -0.06363282f, -0.03943378f, 
    0.02513516f, 0.02670434f, 0.03452237f, 0.04101367f, 0.00126147f, -0.02822250f, -0.06255522f, 0.03425393f, 
    -0.05072632f, 0.01127678f, 0.04587886f, -0.04093079f, -0.02524159f, -0.04514225f, 0.03590300f, 0.03275684f, 
    0.01045006f, 0.00835808f, 0.02108619f, 0.01280623f, -0.02309740f, -0.01292221f, -0.05632679f, 0.01392942f, 
    -0.06699931f, -0.02710842f, 0.03376910f, 0.01846428f, 0.02696234f, -0.00856412f, 0.01123607f, 0.02890823f, 
    0.03623905f, 0.03114829f, 0.04672344f, -0.04645928f, -0.04056140f, -0.05051645f, -0.05121694f, -0.01556904f, 
    -0.00193565f, -0.00991617f, -0.05395834f, -0.05738076f, -0.03953274f, 0.02819881f, -0.00156608f, 0.00129194f, 
    0.02584145f, -0.03294312f, 0.00452622f, -0.00602857f, -0.03707984f, -0.03745218f, -0.02825014f, 0.02584218f, 
    0.03581972f, -0.07479192f, -0.07278559f, 0.00355497f, 0.00265451f, 0.02098476f, 0.01889724f, 0.01659208f, 
    0.02877079f, -0.06547689f, -0.04907811f, -0.04826296f, 0.04241188f, -0.02986027f, -0.03646538f, 0.02576468f, 
    0.00976631f, -0.04836244f, -0.02753768f, -0.04535347f, 0.05189459f, 0.00624366f, -0.04012089f, -0.06487279f, 
    0.00416718f, -0.04964303f, -0.02390297f, 0.00315791f, 0.04047912f, 0.01939707f, -0.03068839f, 0.01035254f, 
    -0.23840441f, -0.04275762f, -0.18541254f, -0.06416167f, 0.01100903f, -0.10098930f, -0.09684262f, -0.08315880f, 
    0.20332050f, 0.55647039f, -0.32322788f, -0.54576099f, -0.05001700f, -0.25800526f, 0.14310105f, -0.00832337f, 
    0.03104658f, -0.05832257f, -0.02138961f, -0.06303593f, 0.36155573f, 0.07769486f, -0.08269943f, 0.13974801f, 
    -0.04525832f, 0.08177190f, -0.04417305f, 0.06254002f, -0.23178634f, -0.10442930f, -0.06234877f, -0.15806596f, 
    0.11728285f, -0.15302621f, -0.21679033f, -0.12419570f, -0.22485799f, -0.11489092f, -0.21128787f, -0.07707036f, 
    -0.03928911f, 0.01501587f, 0.10919587f, 0.10826428f, 0.09106977f, 0.14424492f, 0.02064187f, 0.03401504f, 
    0.11285685f, 0.03015897f, 0.19695196f, 0.03329709f, -0.04033329f, 0.00245146f, 0.00486887f, -0.10023343f, 
    -0.20431527f, 0.04301554f, -0.00573264f, -0.04899302f, -0.03842596f, -0.17418894f, 0.10895532f, -0.05844067f, 
    -0.14660463f, 0.19248113f, -0.06260679f, 0.08244755f, -0.06737407f, 0.05771023f, -0.02126203f, 0.02826971f, 
    -0.08832963f, -0.11298160f, 0.06341595f, 0.01594691f, -0.02558151f, 0.22204424f, -0.07866836f, 0.02725809f, 
    0.05949090f, 0.09050322f, 0.06007434f, 0.02833915f, 0.08724044f, -0.00130309f, 0.00720105f, 0.14673294f, 
    -0.15708999f, -0.01130410f, -0.32373780f, -0.69472575f, -0.05043543f, 0.05808071f, -0.12509038f, 0.01301588f, 
    -0.03785835f, -0.15427923f, 0.17566232f, 0.30767447f, -0.02983839f, 0.13023080f, 0.20770852f, 0.19668691f, 
    -0.02006348f, -0.03403418f, 0.08731946f, -0.05656024f, -0.05555338f, -0.12276347f, -0.05749793f, -0.12877616f, 
    -0.08031066f, 0.15591094f, -0.00651593f, 0.01557026f, -0.00738232f, 0.22965023f, -0.10856707f, -0.04474019f, 
    0.15673178f, -0.06885470f, 0.00355006f, -0.00120124f, 0.02515703f, 0.19735572f, 0.25888011f, -0.01556613f, 
    0.14660947f, 0.10771752f, 0.08039256f, -0.07266749f, 0.01246715f, -0.20742849f, -0.00764245f, 0.03428752f, 
    0.04471236f, -0.04263841f, 0.04077242f, -0.05777127f, 0.07944024f, 0.05111176f, 0.13795614f, 0.14164764f, 
    -0.19810922f, 0.11416173f, -0.42808583f, -0.05804077f, -0.31501761f, -0.04943018f, -0.04812535f, -0.11687424f, 
    0.01507382f, -0.08882681f, 0.05360671f, 0.13592443f, 0.05925900f, 0.10033435f, -0.02552122f, 0.03036920f, 
    0.07083078f, 0.08826444f, -0.15819933f, -0.17264181f, 0.36832771f, 0.10376954f, -0.25126326f, -0.06439300f, 
    0.09212753f, 0.12056156f, -0.11581048f, 0.22635570f, -0.05248573f, -0.12843314f, 0.05876942f, 0.01486709f, 
    0.12502214f, 0.08548177f, 0.01362808f, -0.15942441f, 0.03761086f, -0.12373486f, 0.04309659f, 0.21824969f, 
    0.00325706f, 0.24459991f, 0.20410107f, -0.08698042f, 0.04142072f, 0.04213843f, 0.03414564f, -0.10344040f, 
    0.06880451f, 0.18692032f, -0.02768139f, 0.10397413f, -0.06807731f, 0.09906501f, 0.01250926f, 0.03543805f, 
    -0.22258551f, 0.14681897f, -0.17645450f, -0.01035793f, 0.11975153f, -0.05710055f, -0.18045057f, -0.00625108f, 
    -0.21796580f, 0.39279109f, 0.06007598f, -0.05628769f, -0.03859668f, 0.05365025f, 0.03161192f, -0.06543785f, 
    0.00235115f, -0.12038448f, 0.00618158f, -0.11254201f, -0.19514035f, 0.11521438f, -0.04681329f, -0.06587105f, 
    -0.00778844f, -0.00468102f, 0.08984558f, 0.21704656f, 0.00202548f, -0.22526574f, 0.13695468f, 0.02358853f, 
    -0.21384671f, -0.08291059f, 0.23126197f, -0.00153258f, -0.14746533f, 0.06516573f, 0.10751254f, -0.09738463f, 
    -0.02583839f, 0.13441482f, 0.09364126f, 0.45129272f, -0.25270593f, 0.04257334f, 0.17476431f, -0.00572459f, 
    -0.09794950f, 0.01669965f, -0.07225192f, -0.00922351f, 0.09504971f, -0.22155803f, 0.14648360f, -0.01106663f, 
    0.02551584f, 0.24419460f, 0.10071363f, 0.00588827f, 0.14542717f, 0.37701166f, 0.07620143f, -0.21938160f, 
    0.02768618f, -0.14365079f, 0.18158378f, 0.02903967f, -0.04702472f, -0.10266620f, 0.14976962f, -0.07041486f, 
    0.07687420f, 0.11859054f, -0.00120987f, -0.11514828f, -0.12858179f, 0.13582015f, 0.14256062f, 0.47842291f, 
    0.03569522f, -0.16110604f, 0.11453786f, -0.04912011f, 0.07802172f, 0.27205744f, 0.07681257f, 0.01348884f, 
    -0.20264906f, 0.16929118f, 0.06138081f, 0.03303301f, 0.04967107f, -0.08341511f, 0.12319985f, -0.00682466f, 
    -0.17538035f, 0.07362460f, 0.23674303f, 0.28389934f, 0.08547972f, -0.24959181f, 0.04911758f, 0.20136993f, 
    -0.00795987f, 0.01846462f, -0.07898751f, -0.08989893f, -0.04963830f, -0.00611983f, 0.08436164f, 0.19488649f, 
    -0.02507207f, -0.01714834f, 0.25105557f, -0.33330363f, -0.20423107f, -0.02211111f, -0.21031322f, -0.09184836f, 
    -0.20397931f, -0.07886510f, 0.07996731f, -0.32474136f, 0.12532003f, 0.05232027f, 0.03002095f, -0.31450054f, 
    0.04817259f, 0.08452761f, 0.06260964f, 0.01227026f, 0.22130816f, 0.06424051f, 0.05983945f, 0.09882108f, 
    0.03958120f, -0.02908973f, 0.04616878f, 0.15664943f, 0.02892719f, 0.02390104f, 0.07788013f, 0.02666923f, 
    -0.09621689f, -0.01816835f, 0.11141624f, -0.16974379f, -0.12610273f, -0.15819503f, -0.16826738f, 0.04730877f, 
    -0.23972532f, -0.16895257f, -0.29978561f, -0.21936619f, -0.02828863f, 0.06311754f, 0.06015064f, 0.18090563f, 
    0.07159904f, 0.09571346f, 0.04939612f, -0.15112124f, -0.16442616f, -0.01487811f, 0.25684988f, -0.05091978f, 
    -0.10827670f, 0.23202814f, 0.14049236f, 0.07344314f, 0.06377810f, -0.04324864f, -0.02015262f, 0.04795794f, 
    0.19783841f, -0.11257146f, -0.35657382f, 0.40994018f, -0.03612959f, -0.04005477f, 0.03137763f, -0.09615870f, 
    -0.03254710f, -0.16417609f, 0.01115804f, 0.23334312f, -0.00825236f, -0.01605076f, 0.00187049f, -0.18478605f, 
    0.01348242f, 0.05084104f, 0.00411363f, 0.13259313f, 0.07483549f, -0.15691282f, 0.22312741f, -0.07068767f, 
    -0.07334863f, 0.25281873f, -0.13710400f, -0.19497250f, -0.23170508f, 0.24677651f, 0.28660539f, -0.03384362f, 
    0.01854211f, -0.07641714f, -0.07272323f, 0.00562832f, -0.02770304f, -0.11080368f, -0.20079096f, -0.11027901f, 
    0.22507608f, -0.13183674f, -0.03928150f, 0.09547298f, 0.03873712f, -0.06066298f, 0.20639278f, 0.34452671f, 
    0.06389128f, 0.17155237f, -0.11344520f, 0.04579750f, -0.05768461f, -0.00414317f, 0.19194193f, 0.04191934f, 
    -0.07110391f, -0.11022010f, 0.15840828f, -0.03270219f, -0.11857048f, 0.19850393f, -0.02707517f, -0.10907789f, 
    0.01752548f, 0.05895632f, -0.08850455f, 0.11319326f, 0.07639889f, -0.09624872f, 0.14232670f, 0.05204562f, 
    0.04865804f, 0.25038159f, -0.10537530f, -0.21284068f, -0.14080384f, -0.19255547f, 0.13877344f, 0.06777889f, 
    0.00322809f, 0.02073641f, 0.28717577f, 0.05878707f, 0.14830773f, 0.09943625f, 0.07578747f, -0.02520675f, 
    -0.08873617f, 0.10813548f, 0.02055268f, -0.01027338f, 0.12641151f, -0.20238701f, 0.05095208f, -0.03756522f, 
    -0.02806392f, 0.21737340f, 0.23668945f, 0.14621308f, 0.17283797f, 0.16780289f, 0.04752123f, 0.01134615f, 
    0.16010351f, 0.11623486f, 0.02596008f, 0.06813528f, 0.06103372f, -0.16039716f, -0.06917770f, -0.04207199f, 
    -0.06361003f, 0.01903462f, -0.03771337f, 0.03428551f, 0.10316955f, 0.06445971f, -0.19785510f, -0.22182328f, 
    -0.04968398f, -0.10655607f, -0.16192797f, -0.07811469f, -0.19964312f, 0.03213859f, 0.03453915f, 0.19098292f, 
    -0.29456696f, -0.00531876f, -0.06885539f, -0.16811876f, -0.17661463f, -0.08283404f, -0.08887061f, -0.12365264f, 
    -0.06454926f, -0.15069124f, -0.04064910f, 0.08641967f, -0.16054019f, -0.16136935f, -0.08864500f, -0.04234291f, 
    0.04070295f, -0.03376392f, 0.41830936f, 0.16741380f, -0.06765566f, -0.08585409f, -0.07964079f, -0.05121851f, 
    -0.09193862f, 0.08374701f, 0.10229377f, 0.10307621f, -0.04528884f, 0.27387455f, 0.13772839f, 0.06541511f, 
    0.14028481f, 0.02201988f, -0.07509761f, 0.12529746f, -0.12037570f, -0.08116329f, 0.04869881f, -0.09236509f, 
    -0.18068725f, -0.02480410f, 0.02992300f, 0.07550806f, -0.04949882f, 0.14486688f, 0.16417426f, 0.17260312f, 
    0.05197408f, 0.03701074f, 0.06807750f, 0.08725934f, 0.11205094f, -0.04872154f, 0.12075888f, 0.12848143f, 
    -0.01313153f, -0.09346079f, -0.11364577f, 0.02922383f, 0.04173640f, 0.05688252f, -0.04602432f, -0.10292538f, 
    -0.06869855f, 0.16633387f, -0.06043893f, -0.23917823f, 0.06983900f, 0.08093407f, 0.24108347f, 0.13574742f, 
    0.21764657f, 0.16207553f, 0.16138697f, -0.19757684f, -0.04662948f, -0.25250307f, -0.04847161f, -0.13473055f, 
    -0.03590529f, 0.03100704f, 0.25605863f, -0.03869014f, 0.01966926f, 0.08179857f, 0.09421574f, 0.05513797f, 
    -0.30779460f, 0.26905048f, 0.21549633f, -0.35117692f, -0.37165242f, -0.02019308f, -0.08503921f, -0.02838990f, 
    0.06390583f, 0.10479062f, -0.10349402f, 0.21990310f, 0.08614413f, 0.07429110f, -0.04527630f, -0.15721869f, 
    0.00859586f, 0.08082001f, 0.05842355f, 0.06288511f, 0.34875512f, -0.11022537f, -0.27337980f, -0.17219226f, 
    -0.01783895f, 0.00783480f, -0.11027771f, -0.04848019f, -0.17626874f, 0.10592069f, 0.06477535f, -0.01109058f, 
    0.10125643f, -0.04257895f, -0.04575823f, -0.13475154f, 0.13319518f, -0.16533914f, -0.24813308f, 0.11009169f, 
    0.28421596f, 0.06041227f, 0.18349276f, 0.12620661f, 0.13140288f, 0.19113903f, 0.09304032f, -0.04200061f, 
    0.05764655f, 0.25508350f, -0.01616434f, 0.01642222f, 0.11943634f, 0.09224941f, 0.06135814f, 0.07080217f, 
    -0.29777539f, -0.03596824f, -0.33235061f, 0.05814707f, 0.16802408f, 0.06120469f, -0.05388833f, -0.07263036f, 
    -0.02141936f, 0.16884013f, 0.00351860f, 0.00878382f, 0.09234394f, 0.04535230f, 0.15067910f, -0.06227780f, 
    -0.18370974f, -0.21321620f, 0.31429076f, 0.02887724f, -0.10680837f, 0.02754682f, -0.12712795f, -0.18283632f, 
    0.13359402f, -0.16347876f, 0.07786833f, -0.12628081f, -0.03750983f, 0.10646053f, -0.01027409f, -0.01133057f, 
    -0.04083527f, -0.05482185f, 0.05388469f, 0.00924553f, 0.31136137f, -0.08983502f, -0.09305822f, -0.23856577f, 
    -0.16520500f, 0.15256797f, 0.11984431f, 0.14598422f, -0.10599381f, 0.11870877f, -0.04250883f, -0.01025296f, 
    0.10961244f, 0.08332267f, 0.06544988f, -0.17230156f, 0.09604261f, -0.03994200f, -0.27052721f, -0.08503145f, 
    -0.26149321f, 0.11923609f, -0.14070101f, 0.12967907f, -0.07148587f, 0.05248721f, -0.08478791f, 0.09961455f, 
    -0.03591907f, 0.04205568f, 0.02248753f, -0.02078120f, 0.04565455f, 0.04394657f, -0.09267467f, 0.10506130f, 
    0.38936329f, 0.00443371f, -0.16060829f, -0.16511315f, -0.11339857f, -0.31860751f, 0.08219591f, -0.02116901f, 
    0.09585815f, -0.07504710f, -0.41543418f, -0.59732634f, 0.01838840f, -0.10460137f, -0.05358310f, 0.09856218f, 
    0.02394351f, 0.07354945f, 0.25766000f, -0.09136812f, -0.46629152f, -0.11576287f, -0.04652074f, -0.08073328f, 
    0.05406147f, 0.00698631f, -0.18639427f, 0.14071432f, 0.16045627f, -0.01818948f, 0.18801628f, -0.15238431f, 
    -0.05578163f, -0.11995447f, 0.02260516f, -0.10172579f, -0.08690244f, -0.14044665f, -0.06585202f, 0.00377824f, 
    0.00724595f, 0.03509708f, -0.08668832f, -0.23742910f, -0.10679933f, 0.02241489f, 0.06922429f, 0.14336331f, 
    0.05448368f, 0.00347433f, 0.05246391f, 0.25667110f, 0.08580264f, -0.00715397f, 0.26963833f, 0.13024332f, 
    0.04302054f, -0.20504434f, -0.06358761f, -0.12527570f, 0.13258825f, 0.11947744f, 0.19091070f, 0.00546082f, 
    0.04243971f, -0.06993073f, -0.07837840f, -0.02667386f, 0.04089275f, 0.08068601f, 0.02481990f, -0.08970901f, 
    -0.03947230f, -0.10288457f, -0.13998272f, 0.11737085f, -0.04985627f, 0.02716743f, 0.02862791f, 0.04908927f, 
    -0.02882437f, -0.02137150f, -0.17186424f, 0.01122522f, -0.05289447f, 0.00514435f, 0.02482553f, 0.00869822f, 
    0.03823796f, 0.03776061f, 0.07883028f, -0.10256545f, -0.04728416f, -0.00834184f, 0.07471364f, 0.11478181f, 
    0.05245470f, 0.15270028f, 0.01967680f, -0.01595922f, -0.17572656f, -0.12456279f, 0.06953450f, -0.05605092f, 
    -0.01337238f, -0.13304487f, -0.08151180f, -0.14817518f, 0.20640744f, 0.06862880f, -0.08426730f, -0.22876547f, 
    0.06401599f, 0.02404088f, 0.09007676f, 0.01497911f, 0.19640255f, 0.20765351f, 0.01387550f, -0.08697895f, 
    0.11751910f, 0.04314386f, 0.22908567f, -0.15896228f, -0.13639097f, -0.02400097f, 0.07095353f, 0.01466294f, 
    0.10915513f, 0.01122069f, 0.05800552f, 0.01998548f, -0.08474102f, 0.02522456f, -0.01477948f, -0.26034442f, 
    0.15076888f, -0.26662564f, 0.12882932f, -0.15693131f, 0.02140129f, -0.19331867f, -0.03590665f, 0.16309297f, 
    0.19917847f, -0.07688887f, -0.31124258f, 0.06849287f, 0.00479637f, 0.16725008f, 0.26383930f, 0.03886064f, 
    -0.17348848f, -0.04777457f, -0.05702773f, 0.09439171f, -0.16017473f, -0.01161765f, -0.00783965f, 0.14057302f, 
    -0.01561553f, -0.08976994f, 0.16401362f, 0.16348313f, 0.16733976f, 0.10835628f, 0.08649867f, 0.07838831f, 
    -0.03392772f, 0.00922268f, 0.15905727f, 0.13051505f, -0.05333576f, -0.04776702f, -0.01669040f, -0.09490401f, 
    0.03647032f, 0.11934283f, -0.07970233f, -0.30766162f, 0.06551769f, 0.00253707f, -0.15446530f, 0.08117827f, 
    0.15543792f, 0.30468529f, 0.14406236f, 0.15288076f, 0.07930331f, -0.22946100f, -0.06796630f, -0.13093401f, 
    0.10039801f, 0.12841190f, -0.08090475f, 0.07379083f, -0.07592288f, -0.02980587f, 0.03721994f, -0.13543624f, 
    -0.07135821f, -0.18853380f, -0.09018309f, -0.08307184f, -0.01685182f, 0.07364894f, 0.07497348f, 0.22831497f, 
    -0.04485863f, -0.07721836f, -0.06575911f, 0.03508083f, 0.01860632f, 0.05313478f, -0.01173098f, 0.03321336f, 
    0.23050778f, 0.02794761f, -0.05713201f, 0.00981428f, -0.25514734f, 0.17663991f, -0.19670206f, 0.16102466f, 
    0.11156485f, -0.04583283f, 0.03195909f, -0.20884340f, 0.00732123f, -0.04909185f, -0.00479725f, 0.01898350f, 
    0.03330849f, 0.06775009f, 0.42195582f, 0.01004148f, 0.02240376f, 0.31176338f, -0.00073255f, 0.14919221f, 
    0.25622931f, 0.14687750f, 0.01578409f, 0.16312923f, 0.00933622f, 0.29444668f, -0.03566776f, -0.09694028f, 
    -0.10506248f, -0.01668037f, 0.07683976f, 0.04878746f, -0.20693445f, 0.13684523f, 0.11183110f, 0.02962415f, 
    -0.09938306f, -0.04687047f, -0.17134368f, 0.33041307f, -0.07479686f, -0.05021499f, -0.20119669f, -0.14483783f, 
    0.06723589f, 0.05135740f, -0.21861495f, -0.09071933f, -0.14132684f, 0.09784599f, 0.18657470f, -0.03700285f, 
    0.01789537f, 0.00202412f, -0.04993426f, -0.07721820f, -0.01720804f, -0.00544641f, -0.08878153f, -0.11944350f, 
    0.28799379f, 0.12781188f, -0.11535413f, -0.07606430f, -0.00807785f, 0.09594564f, 0.11411778f, -0.07333155f, 
    0.27804190f, -0.26517603f, -0.11800280f, 0.19606699f, 0.09357505f, 0.03761295f, -0.03623155f, -0.20222539f, 
    0.12215982f, 0.19201000f, -0.10483491f, 0.15311827f, 0.05026332f, 0.17893481f, 0.13627645f, -0.02898049f, 
    0.16853748f, 0.19493002f, 0.14785622f, 0.01197985f, -0.01016477f, 0.08259661f, 0.02562672f, 0.12507576f, 
    -0.01837538f, 0.08048000f, 0.11535399f, 0.01876946f, -0.13583778f, -0.13878939f, -0.02665554f, 0.16524342f, 
    -0.02198332f, 0.02602840f, 0.07202896f, 0.03115375f, -0.00909196f, 0.12031642f, -0.19832645f, -0.02293620f, 
    0.06525444f, -0.04067691f, 0.02390383f, 0.11267820f, 0.20456792f, 0.00517156f, 0.01574153f, -0.09775995f, 
    -0.09333263f, -0.00693436f, -0.01067996f, -0.11552376f, -0.07118671f, -0.01413525f, 0.00819604f, -0.00198775f, 
    -0.15635255f, 0.00104323f, -0.07216830f, -0.00153417f, 0.05317676f, -0.23618719f, -0.18298127f, 0.06550467f, 
    -0.01939242f, -0.09075783f, 0.37086162f, 0.00447068f, 0.13761373f, -0.06985429f, 0.06024649f, 0.08335973f, 
    0.17367330f, 0.04231110f, -0.11585924f, 0.09059217f, 0.10707901f, 0.14024141f, 0.03204656f, 0.06410605f, 
    0.00114017f, 0.22642331f, 0.07202139f, -0.09140334f, 0.10475618f, 0.01349966f, 0.17246385f, 0.02731159f, 
    -0.00434603f, 0.09711990f, -0.22801517f, -0.05191404f, 0.09827111f, -0.01709377f, -0.07629848f, -0.07835742f, 
    0.09328426f, 0.13923709f, 0.06351679f, -0.27014855f, 0.42617258f, 0.14131349f, -0.04274171f, -0.16055220f, 
    0.10758324f, -0.03622009f, 0.15600868f, 0.02162542f, 0.17022797f, 0.06922468f, -0.08696049f, 0.02716033f, 
    -0.12697503f, 0.25211906f, 0.16652218f, 0.27057931f, -0.18488608f, 0.00749942f, -0.15619923f, -0.04559872f, 
    0.06786615f, 0.00153439f, -0.09489726f, 0.00831614f, 0.01885207f, -0.06082545f, 0.09410429f, 0.07450498f, 
    0.12477769f, -0.02941373f, 0.12213361f, 0.05762144f, -0.04935072f, -0.07067514f, -0.11770115f, 0.32462719f, 
    -0.11181977f, 0.17627642f, -0.26922387f, 0.08571456f, 0.00565903f, 0.15737201f, 0.12713210f, 0.10521535f, 
    0.30639571f, -0.18570675f, 0.04195520f, -0.19402087f, -0.17406796f, 0.00385449f, 0.06136053f, -0.03347689f, 
    0.08989931f, -0.43468496f, -0.96773440f, -0.01365860f, 0.14374773f, -0.14311220f, 0.41973653f, -0.03033833f, 
    0.00265299f, -0.18996829f, 0.10558086f, 0.04660353f, 0.06404695f, -0.03849901f, -0.00906212f, -0.00265807f, 
    -0.03055964f, 0.12812513f, -0.04699392f, 0.01582741f, 0.23391220f, 0.01818167f, 0.12310874f, 0.20320986f, 
    -0.08719686f, -0.08657273f, -0.09133711f, 0.02870653f, -0.05343616f, -0.04373660f, 0.58948928f, 0.12470032f, 
    0.01102758f, 0.14268436f, 0.11480965f, 0.17019330f, 0.07889749f, 0.10693027f, 0.06292334f, 0.00741112f, 
    0.02781671f, 0.05342616f, -0.13831313f, 0.15258203f, 0.06631153f, 0.21209447f, -0.48599216f, -0.53786749f, 
    0.00112732f, 0.06798067f, -0.09010227f, 0.02516963f, -0.01562514f, 0.13814081f, -0.00140945f, -0.15087342f, 
    -0.06853436f, 0.20869939f, 0.01791710f, -0.10421101f, 0.09739564f, -0.06698894f, 0.00397616f, 0.13024834f, 
    0.11909114f, -0.14610450f, 0.15764202f, 0.10667929f, 0.27479878f, -0.07086307f, -0.00701370f, -0.05764746f, 
    0.05691226f, 0.02858593f, -0.19130391f, 0.32224551f, -0.02573223f, -0.02819608f, -0.30754051f, -0.00567058f, 
    -0.10379848f, -0.16708894f, -0.03496442f, -0.10312252f, 0.04653180f, -0.41298753f, -0.04219894f, -0.06305298f, 
    0.00300654f, 0.00755465f, 0.00921554f, 0.04869141f, 0.10898025f, -0.12657580f, -0.03657485f, 0.01985818f, 
    -0.12399380f, -0.11819413f, -0.01581153f, 0.02602454f, 0.51056015f, -0.09936680f, -0.25017664f, -0.03736955f, 
    -0.03333374f, -0.13329661f, 0.11930932f, -0.03727065f, 0.16401125f, 0.18864435f, -0.03987894f, 0.23409265f, 
    -0.15839876f, -0.06797351f, -0.05522918f, 0.03690150f, 0.05034902f, 0.02588546f, -0.26345098f, 0.08632877f, 
    0.21263224f, 0.06197416f, -0.06289530f, 0.07159168f, 0.00439601f, 0.03968678f, 0.13469616f, -0.10679685f, 
    -0.20564222f, -0.48022744f, 0.07560718f, -0.11473153f, 0.07562713f, 0.03298671f, 0.01947961f, -0.22072047f, 
    -0.19056550f, -0.77141678f, 0.02834510f, -0.02617207f, -0.01391931f, 0.24511261f, -0.08370970f, 0.07092557f, 
    -0.00851207f, -0.09267132f, 0.16829740f, 0.08099381f, -0.06615942f, 0.06064508f, -0.01575290f, 0.17345719f, 
    0.14404300f, 0.01837348f, 0.14378145f, 0.09986061f, 0.41803572f, 0.08234417f, 0.04298653f, -0.07473408f, 
    -0.01693709f, 0.01344355f, -0.10057571f, 0.06066102f, -0.13067299f, -0.07524201f, 0.08563495f, -0.13592589f, 
    -0.04192505f, 0.09848647f, 0.01024061f, 0.04935867f, 0.11068177f, -0.13000430f, 0.42167553f, 0.10438769f, 
    0.05363561f, 0.06141599f, 0.04446919f, -0.01144318f, -0.13436867f, -0.30355301f, -0.17885323f, -0.09958640f, 
    -0.07484423f, -0.05302548f, -0.02699824f, 0.02259794f, 0.08574836f, 0.01960554f, 0.15431406f, -0.03938905f, 
    0.03751516f, -0.02143069f, -0.04552021f, 0.15053496f, -0.02975194f, -0.11533991f, -0.12461279f, 0.14993419f, 
    0.14652593f, 0.40485644f, -0.11767304f, 0.08811143f, 0.02120146f, -0.03776314f, 0.01160203f, 0.04193800f, 
    -0.06482963f, -0.06391169f, 0.12405140f, 0.09602185f, 0.06064623f, 0.05749400f, 0.03441119f, -0.13033670f, 
    0.09841834f, -0.02199660f, -0.10348363f, 0.13903128f, -0.02830782f, -0.08532943f, 0.03761322f, 0.06997123f, 
    -0.11873113f, -0.07684318f, -0.13638772f, -0.33749461f, -0.15216088f, -0.00844391f, -0.15832704f, 0.01846144f, 
    -0.10502741f, -0.00440184f, -0.10418040f, -0.00290436f, 0.10808662f, -0.20530351f, -0.00748415f, -0.03699920f, 
    -0.10615297f, -0.11069729f, 0.07910223f, 0.01066127f, -0.09989834f, -0.17659692f, -0.13766213f, 0.02232400f, 
    0.02341220f, 0.05691973f, -0.03991978f, -0.14430217f, -0.03883056f, 0.10708079f, 0.00386261f, -0.14077584f, 
    0.16668163f, -0.10501496f, -0.09529044f, 0.02613080f, 0.18096505f, -0.00500657f, 0.05732636f, -0.09499721f, 
    -0.14799401f, 0.12554441f, -0.00964452f, -0.10247649f, 0.18073906f, 0.10326947f, -0.14828938f, -0.17883617f, 
    0.15504433f, 0.00872477f, 0.14297119f, 0.14578700f, 0.25132871f, 0.10248882f, 0.01744196f, -0.14082175f, 
    -0.14579946f, -0.08596073f, -0.18908957f, 0.12365908f, 0.13864933f, 0.12688267f, 0.11828060f, -0.04522407f, 
    -0.13049644f, 0.04767149f, -0.13588810f, -0.05951268f, 0.02826416f, -0.06693700f, 0.12751444f, 0.12719059f, 
    0.09326123f, 0.05268187f, -0.14395438f, -0.17801368f, 0.10779158f, 0.00728692f, 0.03063162f, 0.01646568f, 
    -0.16506235f, -0.09631404f, -0.16115002f, -0.27637440f, -0.09137997f, -0.07672741f, 0.00177238f, 0.02520766f, 
    -0.14442241f, 0.18218704f, 0.15299170f, 0.16680723f, -0.06660192f, -0.06620736f, -0.02961429f, -0.01889089f, 
    -0.18318997f, -0.03680145f, -0.07122444f, -0.22000732f, -0.13499339f, 0.08177318f, 0.02692720f, 0.07566666f, 
    0.05375201f, -0.22037867f, 0.14346085f, 0.17286691f, 0.18370569f, 0.08000690f, -0.02238954f, -0.26457050f, 
    -0.12891929f, 0.01009266f, -0.12442574f, -0.04308404f, 0.20675676f, 0.07237841f, 0.06194722f, -0.25063553f, 
    -0.07742700f, -0.27117676f, 0.17625262f, -0.01933554f, 0.00021706f, 0.26833755f, 0.12742126f, 0.21745038f, 
    -0.13329475f, -0.16850807f, 0.18756288f, 0.08373008f, -0.07754727f, 0.16912650f, 0.26811376f, 0.07451643f, 
    0.04078553f, -0.16986476f, -0.16876963f, -0.09488887f, -0.04180070f, -0.01447451f, -0.17452900f, -0.03487391f, 
    0.15715365f, -0.25483692f, -0.25368747f, -0.12519771f, 0.18006091f, 0.08474335f, 0.24750058f, -0.08827473f, 
    -0.10266387f, -0.22066301f, 0.04174574f, -0.21969694f, -0.15836979f, -0.05737103f, 0.12629969f, 0.18628339f, 
    0.14532401f, 0.07803311f, 0.10417180f, 0.06110295f, 0.20917743f, 0.09388279f, -0.10380331f, 0.16668129f, 
    0.15556638f, -0.13270660f, -0.07385018f, 0.18837826f, 0.07354096f, 0.01126903f, -0.15245613f, -0.10097113f, 
    -0.09547386f, 0.07798377f, 0.04113112f, 0.06474188f, 0.14302935f, -0.04594581f, 0.04942236f, -0.12705845f, 
    -0.27456740f, 0.05702048f, 0.20988511f, 0.12290633f, 0.17576785f, 0.10665741f, 0.12066068f, -0.00886262f, 
    -0.02399051f, 0.03878919f, 0.07363667f, 0.10023639f, 0.00130892f, 0.13185036f, 0.09229546f, 0.02525313f, 
    -0.11578505f, 0.07550306f, 0.10727483f, 0.24379593f, 0.14021356f, -0.01926612f, 0.00920853f, -0.00066291f, 
    0.08494721f, 0.04471601f, -0.04890522f, 0.07029347f, -0.22742155f, -0.10552651f, 0.04029651f, -0.12646434f, 
    -0.19328663f, -0.04645378f, -0.05236249f, -0.12881175f, -0.04413632f, -0.08512610f, 0.05341408f, 0.08576430f, 
    0.01188865f, 0.00077263f, -0.08439517f, 0.00755865f, -0.21909106f, 0.02659091f, 0.06049272f, -0.10035785f, 
    0.21303393f, 0.12456382f, -0.02814229f, -0.19732064f, 0.22599095f, -0.02961667f, 0.02703218f, 0.07014455f, 
    0.11784663f, -0.06520904f, 0.01504881f, 0.12107236f, 0.02288284f, 0.03682386f, -0.12824103f, -0.12748854f, 
    0.00321628f, -0.07612083f, -0.03289988f, -0.11177778f, 0.10110520f, 0.16188031f, -0.26222515f, -0.04083353f, 
    0.01876983f, 0.07791211f, 0.05128695f, -0.06607887f, -0.00597660f, 0.19502325f, 0.23696718f, -0.14372845f, 
    -0.24400920f, -0.10370722f, -0.04137250f, 0.09613848f, 0.05618420f, 0.15163527f, 0.09713191f, 0.02444717f, 
    -0.02114416f, 0.00848115f, -0.15693760f, -0.08077750f, -0.02078979f, 0.03070324f, 0.28083882f, 0.21944724f, 
    0.11569390f, -0.15775412f, 0.19271253f, -0.41812494f, -0.04122984f, 0.03504942f, 0.09409138f, 0.10928667f, 
    0.14520843f, 0.08612157f, -0.02458200f, -0.10565378f, -0.06378535f, 0.10337477f, -0.01935518f, -0.00009743f, 
    0.07090755f, 0.02512033f, 0.03142382f, -0.06382776f, -0.48599428f, 0.14303860f, 0.23836167f, 0.06555846f, 
    0.18612702f, -0.18007179f, -0.14967079f, -0.30857795f, -0.10416894f, -0.26538324f, 0.27872521f, -0.11870159f, 
    -0.22460088f, 0.03290458f, 0.29468590f, 0.07440861f, 0.13116258f, -0.13840929f, -0.13576473f, 0.08627559f, 
    0.02393661f, 0.05460539f, -0.08352417f, -0.08559851f, 0.12136938f, -0.17727464f, -0.22825043f, -0.16327021f, 
    -0.12905724f, -0.18825746f, -0.04193699f, -0.02002916f, -0.12730482f, -0.34671536f, 0.00607529f, 0.18205729f, 
    -0.15911047f, -0.04109976f, 0.00686576f, 0.09322309f, 0.08976683f, 0.16334951f, 0.02528346f, 0.06762843f, 
    0.05867445f, 0.03703507f, -0.09721081f, -0.04244648f, 0.01111033f, -0.04019189f, 0.05534185f, 0.02798547f, 
    0.01864992f, 0.27922958f, -0.07225160f, 0.09766480f, 0.03374996f, -0.12846060f, 0.31083694f, 0.14720149f, 
    0.02013062f, -0.05018748f, 0.06709637f, 0.01342127f, -0.81813043f, -0.10589711f, -0.04545860f, -0.08798936f, 
    -0.01348771f, 0.04820978f, 0.03630156f, -0.20585309f, 0.04795923f, 0.00064210f, -0.12447056f, 0.08392543f, 
    -0.04593326f, -0.00864478f, -0.00392337f, -0.06494521f, -0.25609881f, -0.18442591f, 0.13478278f, 0.10815267f, 
    0.07967766f, 0.06574775f, 0.03760598f, 0.11358856f, 0.16869128f, 0.08097356f, 0.16992521f, 0.12682272f, 
    0.11623564f, -0.02580711f, 0.01971037f, 0.12036483f, -0.06465739f, -0.01120195f, 0.30472219f, -0.26005194f, 
    -0.36111879f, -0.19894503f, 0.03280266f, 0.00126509f, -0.13416322f, 0.04771385f, 0.01534979f, -0.03431540f, 
    -0.66107196f, -0.03397272f, 0.09602696f, 0.12642366f, -0.14377794f, -0.03182549f, -0.05046113f, 0.04785949f, 
    0.08682420f, -0.23285444f, 0.13994524f, 0.00037143f, 0.08466759f, -0.04542535f, 0.14205457f, -0.00004876f, 
    -0.11539356f, 0.01885587f, -0.04208093f, 0.10745814f, -0.14945973f, -0.04840633f, 0.03197406f, -0.09358677f, 
    -0.09535573f, 0.05907043f, 0.04668676f, -0.18088792f, -0.25885502f, 0.09243233f, 0.07667799f, 0.15556943f, 
    -0.07273959f, -0.02201166f, -0.09525605f, -0.45157057f, 0.06439284f, -0.35825160f, -0.04858628f, 0.16361763f, 
    -0.01946762f, 0.07978205f, -0.03980705f, 0.11309646f, -0.24427295f, 0.11416072f, -0.25320223f, -0.04889140f, 
    0.07685519f, -0.11376145f, 0.00442106f, -0.08796677f, -0.04162902f, 0.16917072f, 0.00523509f, -0.06794331f, 
    -0.05215827f, -0.11832926f, 0.03167288f, -0.02334209f, -0.03362898f, 0.02365566f, -0.23241156f, -0.55060929f, 
    -0.44205108f, -0.05482821f, 0.05053540f, -0.04531328f, -0.00903586f, 0.01644446f, -0.03169701f, -0.03749143f, 
    -0.12720531f, 0.04782210f, 0.01523363f, 0.14228006f, -0.09172583f, 0.17163198f, -0.11185335f, 0.11228529f, 
    -0.00379503f, -0.21927904f, -0.17213769f, -0.17247328f, 0.11223507f, 0.19035603f, 0.19271901f, -0.06940919f, 
    -0.07126840f, -0.05046935f, -0.35294703f, -0.50972241f, -0.07097935f, 0.11973874f, -0.12690385f, 0.03668464f, 
    -0.01720297f, -0.00348929f, 0.01398876f, -0.44420505f, -0.15980153f, 0.00137412f, -0.09331552f, -0.05973798f, 
    -0.13308255f, -0.01235641f, 0.21732549f, 0.04684028f, 0.15751545f, 0.02600689f, -0.04019466f, -0.16677395f, 
    -0.03101069f, 0.14997938f, 0.01457733f, 0.09673311f, -0.13411076f, -0.09847566f, 0.30308390f, 0.18413989f, 
    0.05598456f, -0.01106253f, 0.12791440f, -0.02751057f, 0.14937353f, 0.10297453f, 0.00304182f, -0.05834781f, 
    -0.03835300f, -0.11757002f, 0.10865550f, 0.00223681f, -0.04657193f, 0.05074101f, -0.10776973f, -0.09593979f, 
    0.04703850f, -0.10877875f, -0.03923434f, 0.13428046f, 0.08805164f, 0.03488649f, -0.06648381f, -0.10946236f, 
    -0.52394682f, 0.18525974f, 0.16240001f, -0.05635692f, -0.21812013f, -0.07825334f, 0.09897459f, 0.02178419f, 
    -0.41902974f, -0.13820417f, -0.04650144f, 0.11026490f, 0.03149240f, -0.02661927f, 0.06348669f, -0.08402009f, 
    -0.08754246f, -0.91443694f, -0.84352064f, -0.34055486f, -0.01607465f, 0.09826123f, -0.01572128f, -0.01640484f, 
    -0.15847901f, -0.07184961f, 0.18016325f, -0.06591053f, -0.00811927f, 0.00270577f, 0.05171321f, 0.00664400f, 
    0.00673984f, -0.04528080f, 0.01648724f, -0.09363292f, -0.02570201f, -0.14224499f, -0.10861108f, 0.06386592f, 
    0.01231825f, 0.19054189f, 0.00588575f, -0.03622581f, -0.49917197f, -0.15359335f, 0.43928915f, 0.13452050f, 
    0.00938929f, -0.03819911f, 0.22924314f, 0.02308791f, 0.16372865f, 0.05491712f, 0.04878511f, 0.07041470f, 
    -0.13523513f, 0.05005873f, -0.00196249f, 0.05103505f, -0.03686422f, 0.04818131f, -0.00937888f, 0.13988234f, 
    -0.02533575f, -0.04473673f, -0.07556078f, 0.01609647f, -0.04893050f, 0.03367110f, 0.17427766f, 0.17133567f, 
    0.30776587f, -0.15685181f, 0.09848002f, -0.00107543f, 0.00594679f, 0.18214341f, 0.05196184f, 0.18858707f, 
    0.10876896f, -0.07333173f, -0.07781301f, -0.11650230f, -0.04489851f, -0.04799866f, -0.03670229f, -0.17067158f, 
    0.11306555f, -0.02119885f, -0.37195909f, -0.12584557f, 0.12095746f, 0.04239839f, 0.03604452f, -0.03365096f, 
    0.05397238f, -0.17136559f, -0.18120633f, -0.08843569f, -0.05579746f, -0.15554495f, -0.06895072f, 0.00252636f, 
    0.06527761f, -0.06170961f, 0.00385068f, 0.03799862f, -0.06339799f, -0.24986817f, -0.08064047f, 0.05599733f, 
    0.02056760f, 0.05804903f, 0.06029556f, 0.12967983f, -0.28119099f, 0.20373137f, 0.36770988f, -0.03677510f, 
    0.02262805f, -0.14574529f, 0.04122740f, -0.02873400f, -0.11151212f, 0.18828598f, 0.18713333f, 0.13466538f, 
    0.07407906f, 0.09243080f, 0.04392339f, 0.07000498f, 0.08092203f, 0.05895699f, -0.10676343f, -0.48248705f, 
    -0.11683138f, -0.26956889f, -0.26530132f, 0.05384263f, -0.00953087f, -0.16677643f, -0.11322469f, -0.31368881f, 
    0.05693217f, -0.24309449f, -0.02216876f, -0.06513964f, -0.17310540f, -0.00146314f, 0.06704260f, 0.08361299f, 
    -0.04839499f, -0.04951498f, 0.29329348f, 0.07225473f, -0.13943100f, -0.00092878f, -0.01242768f, -0.07232212f, 
    0.19871047f, -0.29120737f, 0.13076931f, 0.07994808f, -0.07574684f, -0.08841708f, -0.20318870f, -0.24185415f, 
    0.12840913f, 0.00108636f, 0.05463235f, -0.48928446f, -0.34511673f, -0.22617902f, 0.07765684f, 0.00777299f, 
    -0.17091045f, -0.01297336f, 0.05163991f, -0.30435494f, 0.20389488f, 0.04965526f, 0.11320147f, -0.00866427f, 
    -0.04949395f, 0.08000391f, 0.06768838f, 0.15910980f, 0.17005354f, 0.00944581f, -0.26546344f, 0.08370907f, 
    0.14685228f, 0.00061614f, 0.05262639f, 0.02189247f, 0.11042655f, 0.05887662f, 0.13112405f, 0.03675469f, 
    -0.02926153f, -0.12491747f, -0.09402058f, -0.03738026f, 0.15177572f, 0.06957629f, -0.19482337f, -0.26312333f, 
    -0.13562106f, 0.11651997f, -0.01483770f, -0.07745970f, 0.11443711f, 0.00214961f, 0.08703426f, -0.04815372f, 
    0.05766362f, -0.34770459f, 0.05133398f, -0.02872112f, -0.01414562f, 0.11604110f, 0.15222718f, 0.08620383f, 
    -0.04469359f, -0.11595716f, -0.10939890f, 0.07642464f, 0.06932417f, 0.23543654f, 0.10838962f, -0.03588815f, 
    0.01189298f, -0.10328916f, -0.00447681f, 0.14216776f, 0.00054377f, 0.00620339f, 0.09989151f, 0.01638169f, 
    -0.04783953f, 0.06484287f, -0.08243512f, 0.04907063f, 0.18684815f, -0.17686172f, -0.11180715f, -0.08248118f, 
    0.04756350f, -0.04216793f, 0.02522098f, -0.06621619f, 0.19615044f, 0.13292792f, -0.02493482f, -0.01894313f, 
    0.00089169f, 0.04810236f, 0.00229624f, -0.03905554f, -0.17244765f, 0.07417149f, 0.28800574f, 0.06157803f, 
    0.14492024f, -0.08535876f, 0.00142844f, 0.16054945f, 0.10652188f, 0.00491309f, -0.00803067f, -0.20283134f, 
    -0.20636493f, -0.22031733f, -0.01528023f, 0.03913828f, -0.07927056f, 0.00775199f, -0.00797144f, -0.28899682f, 
    -0.21923599f, -0.11919843f, -0.00491768f, 0.09454025f, 0.00793445f, -0.06998013f, -0.01675656f, -0.19685034f, 
    0.10003112f, 0.06196458f, -0.09072289f, -0.14932412f, -0.09563382f, 0.10964185f, -0.08474515f, 0.04134966f, 
    -0.23115428f, -0.11734782f, 0.08111229f, 0.14032961f, 0.01669227f, -0.05718663f, 0.06170578f, -0.02495468f, 
    0.18002358f, -0.56826627f, -0.54662895f, -0.32976505f, 0.10876685f, 0.01173529f, -0.09208565f, -0.03546207f, 
    -0.04846356f, 0.04328601f, -0.03656355f, 0.13370062f, -0.14726050f, -0.02832229f, -0.18157454f, -0.06047412f, 
    0.06115480f, 0.08506741f, 0.18516551f, 0.04459131f, -0.04366785f, -0.20628427f, -0.00947287f, -0.05859964f, 
    -0.16991065f, 0.02567980f, -0.00131049f, 0.13272464f, -0.04378584f, -0.15316945f, 0.01384124f, -0.18659404f, 
    -0.05763898f, -0.21740152f, 0.03659935f, 0.11981781f, 0.11215811f, 0.13799804f, 0.05411785f, 0.18423750f, 
    -0.14124364f, 0.16973305f, 0.07067784f, 0.09464118f, 0.00742054f, 0.12785359f, -0.00180066f, 0.16636662f, 
    0.06899033f, 0.07223024f, 0.01006754f, -0.08213282f, 0.06870359f, 0.09239026f, 0.30186418f, 0.32870898f, 
    0.04325421f, 0.03521072f, 0.09940212f, 0.01870397f, 0.08099197f, 0.01165459f, 0.05076160f, -0.09424742f, 
    0.11935440f, 0.15861158f, 0.11762971f, -0.19328828f, -0.12877733f, -0.07842647f, -0.01557217f, 0.15338384f, 
    0.02303573f, 0.05753691f, -0.34054452f, -0.69464993f, -0.19198073f, 0.11965939f, 0.04524888f, 0.11766913f, 
    -0.16697000f, 0.01449586f, 0.06389567f, 0.18053284f, 0.47673991f, -0.18936752f, -0.07606000f, 0.12095323f, 
    0.02359782f, -0.03726201f, 0.10395113f, -0.28625709f, 0.13858534f, -0.07723776f, -0.22312094f, -0.03903779f, 
    -0.16998762f, -0.14158736f, -0.16340552f, -0.06677222f, -0.06180013f, 0.27794495f, 0.16944352f, -0.07237183f, 
    0.02284802f, 0.11663890f, 0.04544574f, 0.12408306f, 0.27433497f, 0.17970841f, 0.17051569f, -0.03640904f, 
    0.02819735f, 0.09523282f, 0.07788007f, 0.12714295f, 0.22904243f, 0.18016820f, 0.05843712f, -0.51977122f, 
    -0.29059607f, -0.08522513f, 0.14391001f, 0.15227462f, -0.10376645f, -0.10726880f, -0.30635068f, 0.05849860f, 
    -0.57615274f, -0.08876912f, -0.06484991f, 0.01681302f, -0.09846146f, 0.08602402f, -0.02485034f, -0.04679380f, 
    -0.14859115f, -0.24299206f, 0.00534958f, 0.05305706f, 0.12578088f, 0.14392826f, -0.01952172f, 0.02827697f, 
    0.17872760f, -0.14551385f, -0.03801997f, -0.05316247f, 0.09029628f, 0.01532644f, -0.16615310f, -0.09867070f, 
    -0.01363333f, 0.01182564f, -0.36212268f, -0.01031241f, 0.36713403f, -0.34293085f, -0.08778915f, -0.08582269f, 
    0.05501653f, 0.02930077f, 0.09634823f, 0.01114647f, -0.45292750f, 0.10456483f, 0.00543167f, 0.12148558f, 
    -0.13264279f, 0.00366133f, -0.07909079f, 0.07055043f, 0.34426555f, 0.48371843f, -0.25417477f, 0.01770351f, 
    -0.13661796f, -0.05345289f, -0.01500042f, -0.02259669f, 0.02641423f, -0.02003167f, -0.20904949f, -0.22266284f, 
    0.12698013f, 0.11194345f, -0.04692505f, 0.07894237f, 0.12731555f, 0.01471130f, 0.02724429f, -0.08804114f, 
    -0.28632984f, -0.13051315f, -0.05119547f, -0.15904976f, -0.05985210f, -0.04456808f, 0.00384189f, 0.00001528f, 
    0.01786004f, 0.22702022f, 0.04611611f, 0.07458245f, 0.09973912f, 0.15264028f, 0.04323870f, 0.06294125f, 
    -0.22485636f, 0.02084879f, 0.15850838f, -0.08123706f, -0.03889187f, 0.03227350f, -0.03676847f, 0.04876512f, 
    0.09831941f, 0.20133938f, -0.07232288f, 0.31144792f, -0.26127544f, 0.06780425f, 0.17398269f, 0.09486048f, 
    0.12017466f, 0.15755889f, -0.65234709f, -0.20179118f, -0.12794442f, -0.10779648f, -0.12526554f, -0.03542688f, 
    -0.03945124f, 0.06171540f, 0.04205310f, 0.14014949f, -0.02663957f, -0.13003315f, -0.02664426f, -0.07507839f, 
    0.03552065f, -0.05984478f, 0.18511251f, 0.04468020f, -0.29924589f, -0.02685788f, 0.13599484f, 0.24877281f, 
    0.15136026f, 0.12654230f, 0.11865278f, 0.15325652f, 0.12767135f, 0.02863167f, -0.22672902f, -0.18284863f, 
    0.11134213f, 0.06508016f, 0.08489587f, 0.08378548f, 0.04631798f, -0.08732099f, -0.23422268f, -0.14368606f, 
    0.00260990f, -0.03220015f, -0.05424653f, -0.11308857f, 0.15955736f, -0.11030551f, 0.02297511f, -0.57534331f, 
    -0.32321122f, -0.09813965f, -0.12147292f, -0.09001508f, -0.19118722f, -0.05831107f, 0.10437891f, -0.03199457f, 
    0.28030646f, -0.04539196f, -0.17850643f, -0.09463511f, 0.06197783f, -0.11745689f, 0.05623832f, -0.08908725f, 
    -0.11016583f, -0.00555434f, -0.06051966f, -0.51215959f, -0.07657861f, -0.15644966f, -0.33489501f, -0.00415316f, 
    -0.03129629f, -0.12819335f, 0.25868478f, -0.13717750f, 0.04001359f, 0.14083526f, 0.13955094f, 0.07654052f, 
    0.10034364f, -0.05800812f, -0.06632677f, -0.48877853f, -0.77419508f, -0.32257235f, -0.03423852f, 0.14079164f, 
    0.06820949f, -0.09662922f, -0.10732718f, -0.05926808f, -0.58845484f, 0.00517564f, -0.08684533f, 0.07970259f, 
    -0.04403048f, 0.08334622f, 0.23411134f, -0.09966183f, 0.02359599f, -0.14266379f, 0.02944368f, -0.08726758f, 
    0.02740062f, 0.15288641f, 0.03710487f, 0.09521082f, 0.14354852f, 0.15296131f, -0.06622458f, -0.07413086f, 
    -0.01934601f, 0.15002942f, 0.07061549f, -0.09991717f, -0.01279431f, 0.12961774f, 0.27155215f, 0.13018546f, 
    -0.10649442f, -0.27657336f, -0.07393373f, 0.26505148f, 0.00657417f, 0.16647856f, 0.10308326f, 0.04769538f, 
    -0.03941676f, -0.02053102f, -0.35651073f, -0.25740409f, -0.12052940f, -0.02896459f, 0.01768004f, 0.07082449f, 
    0.13106538f, -0.56708765f, -0.63047802f, -0.97185165f, 0.21106492f, -0.42692813f, -0.10527276f, 0.05981325f, 
    0.00689518f, 0.13957393f, 0.29496920f, 0.12405741f, 0.26509586f, -0.00143690f, 0.01831140f, 0.12113656f, 
    0.05819692f, -0.00265578f, -0.12156601f, -0.09019759f, 0.16267556f, 0.29623160f, -0.00265758f, 0.02805112f, 
    0.11083630f, 0.02362363f, 0.16686483f, 0.03300476f, 0.30882019f, -0.21550485f, 0.03981536f, 0.00551672f, 
    -0.07694807f, 0.18228760f, 0.10651902f, 0.01124068f, 0.06079973f, 0.11844694f, -0.04700905f, 0.08998070f, 
    -0.15198556f, -0.01749246f, -0.11933468f, -0.08807071f, 0.17106397f, 0.05170223f, 0.23958069f, -0.50351393f, 
    -0.28636655f, 0.01820817f, -0.05692742f, -0.07797816f, -0.03815052f, 0.07477759f, 0.09228862f, 0.03289336f, 
    0.09690535f, 0.14701787f, -0.16231315f, 0.05042091f, -0.27438593f, -0.06111089f, -0.04498913f, 0.14415999f, 
    -0.04655075f, -0.20918730f, -0.19232173f, 0.18486036f, 0.02650767f, 0.08251444f, 0.14055239f, 0.15226728f, 
    -0.06138466f, 0.04363149f, -0.18359306f, -0.69160622f, 0.00899997f, 0.15854155f, -0.02697241f, 0.01700710f, 
    0.09357279f, -0.10508236f, -0.50622910f, -0.25937539f, 0.24906705f, -0.12280186f, -0.02056575f, 0.02040779f, 
    -0.07569967f, 0.12816066f, 0.13774447f, -0.11432926f, 0.13241984f, 0.13229772f, -0.04925710f, 0.06831221f, 
    -0.18511836f, -0.08454752f, 0.01236992f, -0.04339179f, 0.65831095f, -0.21373002f, -0.85687375f, 0.07997058f, 
    0.08445881f, 0.08357108f, 0.06107761f, 0.10337352f, 0.00795791f, 0.17748946f, -0.46747422f, -0.03662769f, 
    0.00118926f, 0.02376982f, -0.11124603f, -0.02002468f, 0.02388511f, -0.03504862f, 0.04219802f, 0.08484986f, 
    0.03331465f, -0.10203464f, 0.01645433f, -0.06149178f, -0.00016690f, -0.00310243f, 0.04612634f, -0.01271609f, 
    -0.23389734f, -0.59005177f, -0.01938392f, 0.04249964f, -0.16389115f, 0.07086456f, 0.02110233f, 0.00554629f, 
    -0.95164305f, -0.57523310f, -0.41134891f, 0.05228135f, 0.00763539f, -0.14124982f, 0.10819706f, 0.02127169f, 
    0.10529419f, 0.09969390f, 0.15953040f, 0.22900644f, -0.07676423f, 0.05760480f, 0.16606915f, 0.05085632f, 
    -0.03927331f, -0.02298011f, 0.19548750f, 0.22134307f, 0.21538834f, 0.07768572f, 0.04853746f, 0.24537468f, 
    0.06084446f, -0.03731893f, -0.02905972f, -0.14088941f, 0.01547412f, 0.17833452f, -0.04125487f, -0.01048547f, 
    0.32852381f, -0.01922550f, -0.09906805f, -0.00837803f, -0.02296420f, -0.31754467f, -0.07186288f, -0.04802348f, 
    -0.11284459f, 0.06190008f, 0.01869123f, 0.10131909f, 0.10571169f, 0.00816673f, -0.02335656f, -0.33806005f, 
    -0.01689833f, -0.02554318f, 0.13511547f, 0.21218359f, 0.00127673f, 0.01681277f, 0.07037319f, -0.06756870f, 
    -0.13660072f, 0.04861570f, -0.03804567f, 0.07664865f, 0.00894578f, 0.12924923f, -0.07690181f, 0.20755965f, 
    0.24618831f, 0.21396631f, -0.04098693f, 0.10129989f, 0.19053783f, 0.00608906f, -0.02560023f, -0.01604806f, 
    0.15413283f, 0.23687030f, 0.05857998f, -0.03060501f, -0.19789593f, -0.09529413f, 0.09635995f, 0.06963672f, 
    0.00930690f, -0.00080762f, 0.34095395f, 0.12275102f, 0.00069636f, -0.15040420f, 0.09344209f, 0.13173132f, 
    0.08968370f, -0.03206606f, 0.20944063f, -0.39392146f, -0.35283843f, -0.14282574f, 0.00572188f, -0.02751596f, 
    -0.05617897f, 0.02048175f, 0.04425679f, 0.38527173f, -0.12793820f, -0.11904825f, -0.17357995f, -0.07477137f, 
    0.01815563f, 0.03261506f, 0.03386543f, -0.20175260f, 0.02503777f, 0.05095669f, -0.46420977f, 0.00716177f, 
    -0.01453447f, 0.16077246f, -0.00226516f, 0.10005797f, -0.11471864f, 0.18456578f, -0.19650128f, -0.36712691f, 
    0.06781528f, -0.00981494f, -0.23253264f, -0.07160435f, 0.09740836f, 0.12876144f, -0.31644216f, 0.07467959f, 
    0.03572875f, 0.08562057f, -0.01414548f, -0.12425466f, 0.26310974f, 0.02099968f, 0.07686329f, -0.22885798f, 
    0.28850698f, 0.04520241f, -0.01925869f, -0.00861070f, -0.00093244f, 0.02431088f, 0.01050801f, -0.07111790f, 
    -0.03624988f, -0.15274017f, 0.08680441f, 0.11180528f, 0.02357168f, 0.00146658f, -0.04807916f, 0.06795126f, 
    -0.08814628f, 0.50223696f, -0.49505213f, -0.22124073f, -0.04445782f, -0.03594726f, 0.20542552f, -0.01392095f, 
    0.08203450f, -0.16219977f, -0.31123725f, -0.01676353f, 0.01968328f, -0.04383805f, 0.01398569f, 0.07873801f, 
    0.03870984f, 0.01857418f, 0.03144561f, -0.01558114f, 0.01908328f, -0.04586928f, 0.04706822f, -0.02454231f, 
    -0.27196306f, 0.05644173f, 0.04683323f, 0.06264367f, -0.25576010f, 0.30801153f, 0.44175726f, -0.04165349f, 
    -0.05503738f, -0.08296165f, 0.02165458f, -0.02974050f, 0.00167659f, 0.01596969f, -0.05931048f, -0.18925780f, 
    0.05974387f, 0.13796195f, 0.18226705f, 0.00183678f, -0.05934620f, 0.20367092f, -0.05387913f, -0.21832088f, 
    -0.15421127f, 0.00317980f, -0.10666186f, -0.23406200f, -0.01405998f, 0.12076062f, -0.12345653f, -0.03160156f, 
    0.02832112f, 0.39052975f, -0.00241164f, -0.04565137f, 0.08315543f, 0.06940886f, 0.07742999f, 0.05480541f, 
    0.02614869f, -0.15965863f, 0.04090895f, 0.05931291f, 0.07631993f, -0.14457200f, 0.00844990f, 0.02696207f, 
    0.05126813f, -0.20958383f, -0.26688641f, -0.10985048f, -0.08965842f, 0.03032696f, -0.06571944f, 0.08947031f, 
    -0.05465000f, -0.19888999f, -0.18378374f, -0.38147661f, -0.14857660f, -0.19775110f, -0.23977108f, 0.00468728f, 
    0.07340658f, 0.08438711f, 0.06342421f, 0.25610727f, -0.16130546f, 0.01979869f, 0.04461296f, 0.16998255f, 
    0.05192325f, 0.06986404f, 0.11024764f, -0.03756496f, -0.15353903f, 0.04115942f, 0.13109550f, -0.11243349f, 
    -0.11561555f, 0.03973072f, 0.02946702f, -0.09189188f, 0.20805684f, -0.00685304f, -0.26391339f, -0.09036363f, 
    0.00083538f, 0.06866466f, 0.04267290f, 0.03209058f, -0.00220504f, 0.02229925f, 0.06140082f, 0.34791151f, 
    0.48310944f, 0.04179989f, -0.03177916f, 0.03614153f, 0.00687786f, -0.04047902f, -0.04259755f, -0.18757491f, 
    -0.26661333f, -0.02954171f, -0.01800186f, -0.16242689f, 0.04787422f, -0.03235348f, 0.19183503f, -0.10129996f, 
    0.06299240f, 0.02116153f, 0.11985268f, 0.01775856f, 0.04057352f, 0.06985790f, 0.17090149f, 0.16150151f, 
    0.06542160f, -0.15710902f, 0.18723606f, 0.14381543f, -0.00434651f, -0.02616885f, 0.11332795f, -0.01449169f, 
    0.02646087f, 0.10227360f, -0.24325997f, 0.02075788f, 0.42290482f, -0.05021631f, -0.03065085f, 0.03472628f, 
    0.11905245f, 0.04070000f, -0.05732609f, -0.04038558f, -0.20505844f, -0.08531915f, 0.02544614f, 0.04863463f, 
    0.01884415f, 0.04367558f, -0.00158984f, 0.01113421f, -0.00779133f, 0.19943911f, 0.27997762f, 0.07034677f, 
    0.05855552f, 0.09393937f, 0.04355116f, 0.01587416f, 0.03137959f, -0.18752877f, -0.04311964f, -0.06571363f, 
    -0.02080169f, 0.08801481f, 0.02208433f, 0.08521500f, 0.29409087f, 0.08833646f, -0.09042365f, -0.05877807f, 
    -0.00910419f, 0.04314315f, 0.16442479f, -0.15356745f, 0.15121752f, 0.28999734f, 0.06388955f, -0.13334446f, 
    0.09546183f, 0.28193691f, -0.02756099f, -0.14139679f, 0.02470343f, 0.07815124f, 0.01429631f, 0.07251758f, 
    -0.08834190f, 0.20145901f, 0.36884451f, 0.05296130f, -0.08174659f, 0.17076376f, 0.04642760f, 0.09103496f, 
    0.05397022f, -0.11426367f, 0.11702625f, 0.37054902f, -0.16693130f, -0.17094205f, 0.13882244f, 0.00244348f, 
    0.03393161f, 0.10436230f, -0.08908770f, -0.24157403f, -0.18169065f, -0.08062766f, -0.06426176f, 0.04905852f, 
    -0.02812143f, 0.07728446f, -0.10076133f, 0.28706935f, 0.00283041f, -0.08138971f, 0.11433385f, 0.06811064f, 
    0.04212983f, -0.10847591f, -0.00284766f, -0.10875999f, -0.27979377f, -0.13951445f, 0.32386208f, -0.22974889f, 
    -0.19184320f, 0.05346674f, 0.00262528f, 0.05548184f, -0.01969869f, 0.04461594f, -0.23725510f, -0.07526341f, 
    -0.01127921f, 0.08166082f, 0.22215179f, -0.00551163f, 0.00321769f, -0.13792141f, -0.09139217f, -0.30171680f, 
    -0.13911752f, 0.00496215f, 0.04976393f, -0.02569881f, -0.12262566f, -0.12434111f, -0.09460860f, 0.27016139f, 
    -0.19921719f, 0.02774772f, 0.02981692f, -0.11056442f, 0.10745759f, -0.09482089f, -0.12675458f, 0.17380880f, 
    -0.04138085f, -0.06052858f, -0.12331155f, 0.03142228f, 0.01622513f, 0.17523789f, 0.02184802f, 0.07841603f, 
    -0.12124299f, -0.00042767f, -0.02371459f, 0.15498906f, -0.11619982f, 0.42953143f, -0.24096957f, 0.09874564f, 
    0.20977210f, -0.12041858f, 0.34989697f, -0.11184641f, -0.24772500f, -0.08838513f, 0.00526854f, 0.20533700f, 
    0.11131767f, 0.00168307f, 0.18379048f, 0.07309470f, -0.38033119f, -0.04981274f, -0.00285595f, -0.02029386f, 
    -0.15571359f, 0.09808934f, -0.04511673f, -0.06402820f, -0.29346749f, -0.26358539f, -0.53867799f, -0.11475575f, 
    0.10254461f, 0.18624778f, -0.15453048f, 0.06737713f, 0.05422576f, -0.15695852f, -0.06011112f, 0.02536081f, 
    0.00308275f, 0.07961033f, 0.03944113f, 0.06122672f, -0.09643461f, -0.08669227f, 0.31838214f, -0.01613186f, 
    0.20336163f, 0.05275391f, 0.09803046f, 0.13798703f, -0.02868111f, 0.17298366f, -0.11177725f, -0.05702869f, 
    0.23150420f, 0.35573089f, 0.05283188f, 0.08917834f, 0.07027520f, -0.03421038f, 0.04996279f, -0.25053048f, 
    0.26776448f, -0.05742358f, 0.06160596f, 0.13084301f, -0.17123702f, -0.09291304f, -0.09825290f, 0.01934311f, 
    -0.13364281f, -0.08647139f, 0.34269470f, 0.10345008f, -0.11767115f, -0.02176998f, -0.11896437f, 0.00068824f, 
    0.06247815f, 0.00853911f, 0.51334673f, -0.17347494f, 0.09363149f, 0.22955075f, 0.05824232f, 0.11463286f, 
    0.14820191f, -0.19445646f, 0.00025786f, 0.05316618f, 0.08287697f, 0.17389163f, -0.05929425f, -0.01682314f, 
    0.06029457f, -0.05106413f, -0.05356504f, 0.11333688f, -0.54271460f, -0.07535756f, -0.10512481f, -0.13641991f, 
    0.31490701f, -0.05437630f, -0.13636041f, 0.08956701f, -0.02664711f, 0.09212679f, 0.22719195f, 0.12753315f, 
    0.01277005f, -0.00814647f, -0.12515983f, 0.01357917f, 0.00564692f, -0.06684668f, 0.22065134f, -0.20942476f, 
    0.25149539f, 0.08276822f, 0.14295235f, -0.02296822f, 0.13364552f, -0.03117625f, 0.15352353f, -0.11302656f, 
    0.39542833f, -0.12913664f, -0.04950366f, -0.21881828f, -0.01945069f, 0.05836482f, -0.12395447f, -0.13055812f, 
    0.22053999f, -0.25507325f, -0.37375191f, 0.02652071f, 0.20531105f, -0.15034594f, -0.02473726f, 0.08342903f, 
    -0.09385596f, -0.01347844f, -0.32011473f, -0.11943958f, -0.03149004f, -0.00931395f, 0.12047611f, 0.12115458f, 
    -0.03708046f, 0.13213040f, 0.18282774f, -0.01160708f, -0.53813213f, 0.08428702f, -0.14590254f, 0.07230657f, 
    -0.01060017f, 0.05001342f, 0.00415728f, -0.15102832f, -0.00334758f, 0.15858641f, -0.06810425f, 0.19567285f, 
    0.00559889f, -0.01089847f, -0.04522919f, 0.08758891f, -0.23510590f, 0.34728137f, -0.06616833f, 0.05863452f, 
    0.00037814f, 0.04408497f, 0.02149420f, -0.05977001f, 0.05975185f, 0.05341406f, 0.21197380f, -0.06442760f, 
    -0.08262537f, 0.05750446f, -0.06444316f, -0.01268937f, -0.02876581f, -0.07372425f, -0.01694825f, -0.19025747f, 
    -0.29609811f, 0.09592095f, 0.16374695f, -0.16855279f, -0.01321573f, 0.16442697f, -0.01099381f, -0.01338997f, 
    0.30397376f, -0.50849169f, 0.03696986f, -0.14030424f, -0.02798649f, 0.15398864f, -0.09479225f, -0.00237948f, 
    -0.02246585f, -0.15086152f, 0.01928161f, 0.03500626f, -0.09879915f, -0.13456419f, 0.07309448f, 0.12725180f, 
    -0.07458748f, 0.19724910f, -0.33538038f, -0.13758367f, 0.09099791f, -0.18134966f, 0.07116227f, -0.00519957f, 
    0.06297120f, -0.02912740f, 0.13090660f, 0.30084673f, 0.09859205f, 0.03473242f, -0.18702506f, -0.15856388f, 
    0.05286687f, -0.03878429f, -0.00297620f, 0.10950825f, 0.27912164f, -0.06185870f, -0.02400103f, 0.08479839f, 
    -0.13336484f, 0.04341219f, 0.05108930f, -0.01227340f, -0.27688155f, 0.19233656f, -0.30151030f, -0.02244938f, 
    0.03160512f, -0.15928489f, 0.33400935f, -0.23047057f, 0.02798534f, -0.19329984f, 0.13889618f, 0.10074013f, 
    -0.05556260f, 0.10817978f, 0.00119582f, -0.02531558f, -0.11490484f, 0.12479660f, 0.07538093f, 0.13363414f, 
    0.13263467f, 0.11124457f, -0.05786284f, -0.12387508f, -0.05180418f, 0.10747650f, 0.12439676f, -0.01316424f, 
    0.02355526f, -0.05054527f, -0.05989675f, 0.21747342f, -0.05663946f, 0.03541011f, -0.00451657f, 0.00240602f, 
    0.07548927f, 0.06860698f, -0.14333029f, 0.08537230f, -0.12776673f, 0.03492384f, -0.01527661f, -0.20139010f, 
    -0.13666034f, 0.24477491f, 0.17255580f, -0.10688537f, 0.14019102f, 0.05026987f, 0.36313975f, 0.00296038f, 
    0.38014191f, -0.13770895f, -0.40313509f, -0.08810287f, -0.22036770f, -0.09495126f, -0.08354886f, -0.02810020f, 
    -0.00228316f, 0.11152253f, -0.04402158f, 0.09865558f, 0.12453200f, -0.16209777f, -0.02597302f, -0.08302723f, 
    -0.05292688f, 0.13004526f, 0.06191340f, 0.15357564f, -0.07474829f, 0.00456550f, 0.05544371f, -0.03785500f, 
    0.09616666f, -0.04074589f, 0.07435124f, -0.05996869f, -0.00031727f, 0.05826168f, -0.02815849f, 0.16276565f, 
    0.08179028f, 0.08805712f, 0.19711755f, 0.10431989f, -0.11468745f, 0.20245875f, -0.17197856f, -0.15533492f, 
    -0.11477046f, -0.20798227f, 0.03124442f, -0.12244553f, 0.00041302f, 0.04030817f, 0.04089784f, -0.24488492f, 
    -0.16554567f, 0.09626850f, -0.01592400f, 0.11493890f, 0.02050117f, 0.00541659f, 0.07165113f, -0.00881507f, 
    -0.06887686f, -0.02724328f, 0.23784421f, 0.06387628f, 0.01482965f, -0.01126631f, 0.22301026f, -0.01732355f, 
    0.12040434f, -0.10692082f, 0.00782312f, 0.06014039f, 0.03255048f, -0.25675857f, -0.30474976f, 0.06380017f, 
    0.08370896f, -0.17158191f, 0.17423648f, 0.11969028f, -0.30270886f, 0.03476777f, 0.07487008f, -0.01659889f, 
    -0.28498954f, 0.09056676f, -0.06912567f, -0.36413369f, -0.19170001f, -0.01677141f, 0.00772992f, 0.03268962f, 
    0.06718457f, 0.04717630f, 0.01900840f, -0.14261197f, 0.17641971f, -0.30636811f, -0.23842205f, 0.08790833f, 
    0.15297851f, -0.05781828f, -0.02297516f, -0.07844823f, 0.17381735f, 0.09631410f, -0.01081653f, 0.07643112f, 
    -0.07947788f, -0.10612112f, -0.06839818f, 0.01665912f, -0.03522537f, -0.21603765f, -0.14551750f, -0.40212962f, 
    -0.24428442f, -0.00329458f, 0.15504296f, -0.07827180f, 0.14749946f, 0.01419261f, 0.03910657f, -0.15509968f, 
    0.09738363f, 0.10105102f, 0.07047572f, -0.01556301f, -0.05229270f, 0.02110760f, 0.05018148f, 0.08451997f, 
    0.29569638f, 0.13844511f, -0.00329355f, -0.00574428f, -0.22174722f, 0.11880662f, 0.20956503f, 0.07563565f, 
    -0.04970801f, -0.15030171f, -0.01898068f, -0.18173926f, -0.02031735f, -0.04120369f, -0.00939310f, 0.00035668f, 
    0.00418557f, -0.04092667f, -0.21572313f, 0.02891769f, 0.01248053f, -0.12520050f, -0.04889896f, 0.06295442f, 
    0.08072076f, -0.02664717f, -0.11518013f, -0.09746858f, 0.01599151f, -0.01953586f, 0.03830240f, 0.04409377f, 
    0.15496691f, -0.10618836f, -0.07352876f, -0.06493657f, 0.11789020f, 0.11778741f, 0.33704999f, 0.12256802f, 
    0.02913783f, 0.00818047f, -0.06442664f, 0.13916764f, 0.05108024f, -0.02139074f, 0.04231058f, -0.00284610f, 
    -0.10462399f, -0.07033570f, -0.07691332f, -0.12708004f, 0.02794923f, 0.12509431f, 0.13777854f, 0.11965463f, 
    -0.11818862f, -0.09162445f, -0.11391037f, -0.08999956f, 0.15287018f, 0.04527011f, 0.00281811f, -0.30163002f, 
    -0.00037648f, 0.00724913f, -0.10563723f, 0.06065695f, -0.13729388f, 0.05040073f, -0.03265885f, 0.01033696f, 
    -0.18620838f, -0.17013295f, -0.15893513f, -0.05850058f, -0.02517321f, -0.04638210f, 0.05185538f, -0.07447883f, 
    0.01208824f, -0.20686445f, 0.11815252f, -0.38449106f, -0.02177935f, 0.02563104f, 0.13134952f, 0.01570565f, 
    -0.10017069f, -0.06659333f, -0.21925426f, 0.04953019f, 0.20830676f, 0.04308708f, 0.03729957f, -0.04794864f, 
    -0.04462769f, -0.02587523f, -0.00721528f, 0.00810463f, -0.13584888f, 0.17556827f, 0.09926338f, 0.07069941f, 
    -0.02422717f, 0.04141463f, -0.13505581f, -0.09461537f, 0.13469748f, 0.28843006f, 0.13012859f, 0.02013630f, 
    -0.04620431f, 0.06665845f, 0.18459436f, 0.01031996f, 0.12420923f, -0.08295599f, 0.13260829f, 0.06023046f, 
    0.14696673f, 0.09246549f, 0.03142273f, -0.03098700f, 0.10982297f, -0.00333939f, -0.11520853f, -0.02086559f, 
    -0.02275463f, -0.01006492f, -0.10918788f, -0.04623541f, -0.08603890f, -0.07888749f, -0.23440166f, 0.24301685f, 
    0.21264587f, -0.12916261f, 0.17391598f, 0.04050228f, 0.27080286f, 0.04167898f, 0.09311264f, -0.19456570f, 
    0.05309877f, 0.01320961f, 0.00933507f, -0.01100989f, -0.02892186f, -0.02872196f, 0.02058684f, 0.01618797f, 
    -0.01718737f, -0.02484089f, 0.04631760f, -0.01678656f, 0.03859375f, 0.01093201f, -0.03594624f, -0.03029895f, 
    -0.02062456f, -0.02501873f, -0.05273968f, 0.01064112f, 0.02226343f, -0.05067555f, 0.01817771f, -0.03220193f, 
    0.01534263f, 0.02739647f, -0.06169660f, 0.00847959f, 0.01070711f, -0.01288211f, -0.02676022f, 0.03830485f, 
    -0.04549232f, 0.02916905f, -0.05444792f, 0.02128222f, 0.02826907f, -0.01333144f, 0.04705727f, -0.04310578f, 
    -0.06351937f, 0.03408558f, -0.04026105f, 0.04683997f, 0.01722324f, -0.06720188f, 0.00801942f, 0.01593288f, 
    0.00299781f, -0.03085508f, -0.01594761f, -0.01521861f, -0.05122845f, -0.02923696f, 0.04449598f, -0.02714056f, 
    -0.03059204f, -0.03107408f, -0.00972211f, -0.00215852f, -0.01547372f, 0.00862109f, -0.05549008f, 0.04323985f, 
    -0.02737106f, -0.01330877f, 0.03137807f, -0.04381559f, 0.03788493f, 0.01402720f, -0.00497372f, 0.04300577f, 
    -0.01085256f, 0.02529758f, -0.01440901f, -0.04245473f, -0.02942630f, 0.04423273f, -0.00688132f, -0.04601986f, 
    -0.02676798f, 0.04338661f, 0.01110717f, 0.04829484f, -0.05003205f, 0.03067851f, -0.03799663f, 0.05842325f, 
    0.05017589f, 0.00419262f, -0.03654404f, -0.00752357f, 0.03240019f, 0.03623372f, 0.02950935f, 0.02851607f, 
    0.00636215f, 0.02062692f, -0.05908471f, 0.01359251f, 0.03126651f, 0.03331289f, -0.05454474f, 0.04739162f, 
    -0.01551209f, -0.03133394f, 0.01006196f, -0.01484409f, -0.07237623f, 0.03077125f, -0.05565948f, 0.02329707f, 
    0.03676836f, -0.03042412f, -0.04678259f, -0.02896864f, -0.04464344f, -0.03660242f, -0.03050741f, -0.02233507f, 
    -0.00603320f, -0.01966788f, 0.02625029f, 0.02514574f, 0.01470624f, -0.01337421f, -0.02931233f, -0.03423129f, 
    0.00900260f, -0.00429366f, -0.01355460f, -0.01740102f, 0.01177032f, 0.03982946f, -0.02928773f, -0.06411496f, 
    -0.04114614f, 0.01231794f, -0.06202546f, -0.02315199f, -0.05019691f, -0.06122142f, 0.00042398f, -0.06296583f, 
    0.01762891f, -0.06604280f, -0.00334629f, -0.05337924f, -0.04118092f, -0.04585817f, 0.02392212f, -0.05736068f, 
    0.04274084f, -0.02757425f, -0.04663171f, 0.02733594f, -0.02129453f, -0.02739233f, 0.01745582f, 0.02245088f, 
    -0.05049888f, 0.04443112f, -0.04318121f, -0.01634754f, -0.03031190f, 0.04799539f, -0.03288130f, -0.02855663f, 
    0.04801614f, 0.03000014f, -0.04307438f, -0.01012643f, -0.06047211f, -0.04162238f, -0.00127029f, -0.02700046f, 
    -0.01282240f, 0.01557505f, 0.00089252f, -0.02143224f, 0.04223096f, -0.04344100f, -0.04854343f, -0.00382723f, 
    0.02865291f, 0.04787528f, 0.00720359f, -0.05063893f, 0.05097459f, -0.06275747f, -0.03874589f, 0.00409898f, 
    -0.06004319f, -0.01347456f, 0.00102129f, -0.00983648f, 0.01482735f, 0.03898591f, 0.02619497f, 0.02289237f, 
    0.03304246f, -0.03298178f, -0.05059273f, 0.02359535f, 0.01899634f, 0.01572292f, 0.03574364f, -0.03841202f, 
    0.02242079f, -0.03951598f, 0.03042099f, 0.00370627f, 0.03901477f, 0.03105888f, 0.01424104f, -0.00620134f, 
    -0.02433096f, -0.00308764f, 0.00043215f, -0.05205138f, -0.02706905f, -0.04638789f, 0.02816449f, 0.02907660f, 
    0.02485314f, -0.01861044f, 0.01679568f, -0.05670126f, -0.00357141f, -0.00487216f, 0.00315751f, -0.06371073f, 
    -0.03849079f, -0.01162830f, -0.02574683f, 0.04805641f, 0.00423575f, -0.02626451f, -0.04117233f, 0.01042155f, 
    0.04248278f, -0.00174118f, -0.00877361f, -0.02748084f, 0.04602407f, 0.04879458f, -0.04663916f, -0.03649701f, 
    0.03147246f, -0.01998021f, -0.02470666f, 0.01645966f, -0.01094411f, -0.00364151f, -0.05923898f, -0.05321763f, 
    0.01124310f, -0.01860062f, -0.03626045f, -0.01438014f, -0.04031640f, 0.00952798f, -0.04536060f, -0.02884113f, 
    0.03224622f, 0.04288637f, -0.05663712f, -0.02247245f, -0.01196011f, 0.05095377f, -0.03517210f, 0.03194317f, 
    -0.03580396f, -0.00160144f, -0.01519205f, -0.02321539f, -0.04487720f, -0.03250943f, 0.01883877f, -0.04810157f, 
    -0.04751597f, 0.04796297f, 0.02523170f, 0.01851864f, -0.04663856f, 0.02302004f, 0.01643276f, -0.00692109f, 
    -0.14749677f, 0.04280818f, -0.13253549f, 0.14805579f, 0.08749835f, 0.00319750f, 0.00152069f, -0.00362752f, 
    -0.18903492f, -0.09701355f, 0.17805612f, 0.15279368f, 0.08602956f, -0.03954501f, 0.13997737f, -0.26251340f, 
    0.11465417f, -0.10637755f, -0.21346201f, -0.15815842f, -0.04841295f, 0.06333628f, 0.02553453f, -0.04083153f, 
    -0.04712280f, 0.02036716f, -0.04517569f, -0.05703101f, -0.12789012f, -0.27549106f, -0.02170191f, -0.07706070f, 
    -0.19692026f, 0.01516436f, -0.08414400f, -0.01700924f, 0.08787051f, -0.01529210f, -0.15240580f, -0.04331804f, 
    -0.03114289f, -0.00207509f, -0.12718961f, -0.16553682f, -0.10615776f, 0.10780809f, 0.30473176f, 0.20901771f, 
    -0.17303070f, 0.08893763f, 0.19735688f, -0.04568456f, 0.14620984f, 0.07788886f, 0.30215639f, 0.07586799f, 
    -0.11040939f, 0.18703257f, -0.04360761f, -0.06731939f, -0.13111630f, -0.13094302f, 0.03389825f, -0.21609843f, 
    0.01999254f, -0.06598749f, 0.02270840f, -0.04912405f, -0.09509254f, 0.04081059f, 0.11883878f, 0.08317458f, 
    0.15866970f, 0.12374371f, 0.37620938f, 0.16780718f, 0.09610742f, 0.02944257f, 0.11911460f, 0.19876574f, 
    0.08578680f, -0.14063761f, -0.14733893f, 0.07423276f, -0.00303551f, -0.05958646f, -0.04014535f, 0.00205239f, 
    0.06765882f, -0.09355859f, -0.07625052f, 0.07436852f, -0.04012332f, 0.05455313f, 0.14565276f, 0.00316387f, 
    0.00852455f, 0.02950357f, 0.02577152f, -0.17635335f, -0.35172731f, -0.11360909f, 0.03659691f, 0.09508061f, 
    0.03760057f, 0.00444063f, 0.12545110f, -0.22041316f, -0.06693398f, 0.00990973f, 0.35125411f, -0.13333416f, 
    0.14034434f, 0.04935792f, -0.16621502f, -0.00844458f, 0.02053425f, -0.05760789f, 0.06177590f, 0.19986206f, 
    0.00918283f, 0.13886176f, -0.05231557f, 0.01109472f, 0.01235273f, 0.01999571f, 0.09285610f, -0.08668807f, 
    0.02212336f, -0.02906922f, 0.06366915f, 0.05270946f, 0.11782622f, 0.00512839f, 0.15653332f, -0.14044032f, 
    -0.00190241f, 0.22435218f, -0.09138062f, 0.13513272f, 0.02929517f, 0.09256086f, 0.08642419f, -0.04926709f, 
    -0.02014672f, 0.04040518f, 0.12859818f, 0.08054174f, 0.11401079f, -0.00966883f, -0.09173533f, 0.00490490f, 
    0.21553339f, -0.10314843f, 0.09630541f, -0.04655452f, 0.01543932f, -0.08760015f, -0.04588914f, -0.04205821f, 
    0.02052598f, 0.04503245f, -0.21375279f, -0.10614112f, 0.14303067f, 0.11794354f, -0.09767126f, -0.16218959f, 
    -0.01033565f, -0.07097577f, -0.04061735f, -0.08371054f, 0.15541060f, 0.09043896f, -0.01874617f, 0.16265525f, 
    0.02667367f, -0.10664998f, -0.05736136f, 0.04010546f, 0.20339116f, 0.13249990f, 0.27719191f, 0.13468838f, 
    0.18869610f, 0.08969615f, 0.13205068f, 0.19035272f, 0.17521794f, 0.12169931f, 0.08050636f, 0.03297366f, 
    -0.04321932f, 0.10822946f, -0.03469448f, -0.08732500f, -0.04253680f, 0.11483505f, -0.08645919f, 0.09059119f, 
    -0.00079774f, 0.06401669f, -0.00968886f, 0.00795824f, -0.18995893f, -0.08314903f, 0.05511009f, -0.10869304f, 
    -0.02526620f, 0.03013702f, -0.09107666f, -0.04592713f, -0.12328854f, 0.07305686f, -0.02034368f, -0.00686636f, 
    -0.02308825f, 0.21430704f, -0.07788568f, -0.08873284f, 0.12662968f, 0.07688692f, 0.08295085f, 0.21424697f, 
    0.01272228f, -0.09894659f, 0.18180776f, 0.12934941f, -0.01894809f, -0.05967156f, 0.04674219f, -0.00354659f, 
    0.08105282f, -0.11538544f, -0.07499424f, -0.04909744f, 0.15755568f, 0.03823172f, 0.08995038f, 0.04326871f, 
    0.09667357f, 0.10123578f, 0.02522911f, -0.28278190f, -0.16786712f, 0.03442109f, 0.13989772f, 0.16443180f, 
    0.12722853f, -0.09777231f, -0.16557296f, -0.13021259f, -0.02784966f, 0.06482686f, -0.03893179f, -0.14960532f, 
    0.13018191f, 0.00089234f, -0.09875952f, -0.01342666f, 0.03536686f, -0.17308630f, 0.10547008f, 0.07838470f, 
    -0.03773810f, 0.09486845f, 0.07381670f, -0.02059646f, 0.01070605f, -0.08423579f, -0.15087235f, -0.11121716f, 
    -0.12474139f, -0.03269408f, 0.02411761f, -0.04507430f, -0.06485575f, -0.19541262f, -0.23257664f, -0.13148311f, 
    0.11189372f, 0.05392227f, 0.03356475f, 0.08176805f, 0.16080815f, -0.12039790f, 0.02968377f, 0.00828912f, 
    -0.07950135f, -0.15788846f, -0.04092563f, 0.18583661f, -0.04815280f, -0.01663492f, -0.08476326f, 0.11147709f, 
    0.12181604f, 0.18857181f, -0.37819758f, -0.47263736f, -0.00183216f, -0.24371685f, 0.04981691f, 0.13352281f, 
    -0.11589603f, -0.02270103f, -0.11763389f, -0.00912510f, 0.11103953f, -0.00667933f, -0.00109167f, -0.13079320f, 
    0.20941181f, 0.02359616f, -0.21568105f, 0.16102873f, -0.22615536f, -0.08217788f, 0.07316209f, -0.01260572f, 
    0.03524480f, -0.13912599f, 0.12749520f, -0.10374399f, -0.25771585f, 0.27678022f, 0.16115038f, 0.17202838f, 
    -0.05243078f, 0.04566118f, 0.10347378f, -0.06127189f, 0.15426348f, -0.13091716f, 0.04031497f, -0.17833680f, 
    0.04167154f, 0.31433097f, -0.04286002f, 0.17973377f, 0.05356283f, 0.25223619f, -0.13278279f, -0.45334315f, 
    -0.02198671f, -0.21803601f, -0.13625960f, -0.10895984f, -0.03114866f, -0.01743020f, -0.19464299f, 0.10414884f, 
    -0.11674242f, 0.19397351f, 0.08221659f, 0.03820823f, 0.10828539f, -0.11485443f, -0.22324091f, -0.02518311f, 
    0.23155528f, 0.02149664f, -0.15536104f, -0.12495390f, 0.06424482f, 0.07464871f, -0.06642970f, 0.09871414f, 
    0.04836949f, -0.18090619f, -0.17840442f, 0.02406366f, 0.12967685f, -0.02903279f, -0.06644227f, -0.05213041f, 
    -0.22882764f, 0.15049537f, 0.26922542f, -0.29828098f, -0.65978503f, 0.14574359f, -0.09730938f, -0.04217489f, 
    0.01776786f, 0.21110086f, -0.27220368f, 0.16184014f, -0.10721291f, 0.30912209f, -0.02967425f, 0.01455275f, 
    0.02747273f, 0.02607905f, -0.15606086f, -0.01918050f, -0.37356699f, 0.23364899f, 0.31639263f, -0.13698922f, 
    0.06425937f, -0.11255432f, 0.07813632f, 0.06956264f, 0.16202697f, -0.12314124f, -0.09839757f, -0.23109706f, 
    0.17746396f, -0.09582727f, 0.00647118f, 0.09890515f, 0.07961084f, 0.18629099f, 0.35687494f, 0.07059533f, 
    0.30654284f, -0.03299355f, 0.04027125f, 0.14522578f, 0.04965143f, -0.09056124f, -0.24319634f, -0.03512941f, 
    0.06267877f, 0.14628164f, -0.12004817f, 0.28102493f, 0.05341756f, 0.22258835f, -0.09555358f, 0.16076978f, 
    0.27642861f, -0.15481111f, -0.15367036f, -0.03800917f, -0.03798867f, 0.30696926f, -0.17641488f, 0.17303345f, 
    0.24837875f, 0.14189433f, 0.11640189f, 0.17818190f, 0.07629085f, 0.11988337f, -0.01091348f, 0.10302984f, 
    0.01556994f, -0.23451909f, -0.23704198f, -0.07839224f, 0.22663634f, 0.11096592f, -0.11718449f, 0.03280344f, 
    0.21820296f, -0.06097123f, 0.02125096f, 0.01165080f, -0.12071638f, -0.26725012f, 0.08558761f, -0.06068388f, 
    -0.06182214f, 0.07836796f, 0.21160667f, 0.15444922f, -0.09726635f, 0.13157611f, 0.02637677f, 0.16823676f, 
    0.02646986f, 0.09373352f, 0.14421755f, -0.10801069f, 0.22866461f, -0.05755613f, -0.27166191f, -0.07527854f, 
    0.17269626f, 0.02339445f, -0.04183854f, 0.19333659f, 0.19990985f, 0.09066471f, 0.03662913f, -0.29063234f, 
    -0.18347813f, 0.10408716f, -0.12518856f, 0.04864643f, -0.05199391f, 0.02757953f, 0.15358922f, -0.22538947f, 
    -0.05731792f, 0.03619282f, 0.17145041f, -0.17153357f, 0.04979023f, 0.01190790f, -0.04613279f, 0.06105968f, 
    0.15414053f, -0.04965845f, 0.08135550f, 0.14744720f, 0.28470838f, 0.05194121f, -0.00264651f, 0.01379984f, 
    -0.01404337f, 0.12634358f, -0.11830514f, 0.25104833f, 0.11555496f, 0.20585380f, 0.03136101f, 0.15122990f, 
    -0.12066106f, -0.17138447f, -0.15305746f, -0.12205479f, 0.04180583f, -0.09896431f, 0.01479356f, 0.09487960f, 
    0.18965988f, -0.02427303f, -0.05605271f, -0.02062311f, -0.00010019f, 0.08569350f, -0.09358337f, 0.12499501f, 
    -0.08245903f, 0.08067354f, -0.00035174f, -0.05334492f, -0.04976104f, 0.06108977f, 0.04055636f, -0.20899121f, 
    -0.08792780f, -0.03095220f, 0.20394666f, 0.11878362f, -0.14021203f, 0.14132915f, -0.00175250f, -0.03004164f, 
    0.08001091f, 0.20841016f, -0.04229437f, 0.17901559f, -0.15873545f, 0.06675313f, 0.06439685f, -0.02793407f, 
    0.02728212f, 0.08370490f, 0.01560446f, -0.01730588f, 0.05270651f, -0.02102172f, 0.14802012f, 0.19115050f, 
    -0.03909228f, 0.03879783f, -0.06615085f, -0.10687493f, 0.12432295f, 0.10909677f, -0.06060865f, 0.15883355f, 
    -0.26149285f, -0.14856730f, -0.08607178f, 0.06481360f, 0.03799610f, -0.09208564f, -0.09873451f, -0.07250346f, 
    0.12655415f, 0.30867442f, 0.18865252f, 0.01197769f, 0.02136326f, -0.21318683f, 0.13152741f, -0.06024620f, 
    0.27324116f, -0.13561413f, 0.06160616f, 0.08418933f, 0.11588222f, -0.00531739f, -0.11795992f, -0.15622024f, 
    -0.08504212f, 0.02499070f, -0.05077853f, -0.06391922f, -0.08446781f, -0.17485753f, -0.01729847f, -0.12520979f, 
    -0.10636141f, -0.09004439f, 0.08165876f, 0.07762184f, -0.00611329f, -0.04977773f, -0.29557797f, 0.07728364f, 
    0.04668065f, -0.00009747f, -0.02123944f, -0.16329886f, -0.09165966f, -0.00058189f, 0.14446574f, 0.31082934f, 
    -0.04718973f, 0.05726529f, 0.09218387f, 0.01806760f, -0.17030266f, 0.27955902f, 0.51845711f, 0.13490435f, 
    0.14729568f, 0.01014343f, 0.03921080f, 0.06835125f, -0.00260611f, 0.12729736f, -0.00128828f, -0.17843875f, 
    0.01865616f, -0.04159291f, -0.11582453f, 0.20742030f, -0.03899187f, 0.04976133f, 0.16651490f, 0.05269263f, 
    0.12472776f, 0.08442283f, 0.30577129f, 0.14824061f, 0.05626409f, 0.23590700f, 0.16799542f, 0.05579710f, 
    0.19528174f, 0.01910107f, -0.04790588f, -0.02154214f, 0.06281269f, -0.05202970f, -0.16561712f, -0.11791058f, 
    -0.00735543f, -0.14340155f, -0.23767392f, -0.13833898f, 0.32379505f, 0.02310679f, -0.17558098f, -0.04373156f, 
    -0.12428766f, 0.12068497f, 0.14522560f, 0.22382037f, 0.02021492f, -0.11716846f, -0.01233524f, -0.18740125f, 
    0.06459556f, 0.00292381f, -0.00130549f, -0.03183170f, -0.28277144f, -0.11589961f, -0.00203446f, -0.16051325f, 
    -0.06292947f, 0.08995409f, -0.03313970f, -0.09161893f, 0.01908524f, 0.15026064f, 0.09843989f, 0.30649024f, 
    -0.07068881f, -0.05900247f, 0.03865300f, -0.09440977f, 0.03668081f, 0.07849526f, 0.03537364f, -0.27067435f, 
    -0.04534081f, -0.05340395f, 0.06179717f, -0.26049513f, 0.03553009f, 0.01266536f, 0.14059320f, -0.01584442f, 
    0.09747151f, 0.12971382f, 0.08329962f, 0.10617734f, 0.00413493f, 0.05247391f, 0.01805422f, 0.20387042f, 
    -0.30337098f, 0.25760165f, 0.02790881f, -0.03505179f, 0.02504134f, -0.14275593f, -0.03235552f, 0.09068023f, 
    0.07435041f, 0.25331810f, 0.04906325f, 0.10970142f, 0.02481689f, -0.14254187f, -0.13064203f, -0.09412334f, 
    -0.11195049f, 0.02084227f, -0.07482581f, 0.17101143f, 0.00023631f, -0.13117778f, -0.16166256f, -0.29171064f, 
    0.00758108f, 0.00242998f, -0.00882558f, 0.14819372f, -0.02263617f, 0.23029514f, -0.02778212f, 0.05256198f, 
    0.05184114f, -0.11037952f, 0.06068943f, 0.05291862f, -0.20346190f, -0.03656054f, -0.05267381f, 0.11955436f, 
    0.10233311f, 0.09652287f, 0.11692534f, 0.16153906f, 0.13620344f, 0.18425268f, 0.16857331f, 0.04639351f, 
    -0.02790129f, 0.05800734f, 0.07380748f, -0.01709655f, 0.06432899f, -0.03414201f, -0.11863664f, 0.09664205f, 
    0.02882415f, -0.11162694f, -0.09029613f, -0.03813214f, -0.11266405f, 0.26863384f, -0.05465879f, -0.02614310f, 
    0.03858864f, 0.06905208f, -0.06318922f, 0.08111863f, -0.25893655f, -0.04946439f, -0.13299404f, 0.02722715f, 
    -0.11105742f, -0.05011718f, -0.12389312f, 0.03001683f, -0.10359500f, -0.16183278f, 0.18233173f, 0.00932040f, 
    0.04369092f, 0.02740908f, 0.17916377f, -0.09547441f, -0.26101080f, -0.21928428f, -0.23079295f, 0.04939736f, 
    0.08979562f, 0.03085289f, 0.24907266f, 0.18031882f, 0.31322488f, 0.06536024f, 0.09958465f, 0.03967283f, 
    -0.02233519f, -0.07264103f, 0.04453461f, 0.05109643f, 0.07169925f, 0.06831129f, -0.07128108f, -0.10938359f, 
    0.12640719f, -0.17220660f, -0.42121997f, -0.19672970f, -0.20307893f, 0.01202039f, -0.08938945f, 0.11054752f, 
    -0.07483945f, 0.33786699f, -0.17927834f, -0.06176883f, 0.16568615f, 0.07633567f, 0.15426636f, 0.09628213f, 
    -0.11498498f, 0.04869187f, 0.00180506f, 0.02184244f, 0.13225870f, -0.07883182f, 0.13413368f, -0.10125285f, 
    0.03375096f, -0.00012754f, -0.10053194f, -0.03570023f, -0.14358853f, -0.11735914f, 0.05332323f, 0.11875439f, 
    -0.03095435f, -0.01621549f, -0.05419094f, -0.11381552f, 0.14959741f, -0.17781255f, -0.05514658f, 0.00283715f, 
    0.31706050f, 0.08535158f, 0.13716249f, -0.21989021f, -0.35259432f, -0.33664107f, -0.09008777f, 0.00535419f, 
    -0.08344163f, 0.11920782f, -0.05773689f, -0.20251825f, -0.03838499f, 0.22612067f, -0.14925055f, -0.03092811f, 
    0.03241789f, -0.11577508f, -0.15432175f, -0.07510548f, 0.16465011f, -0.19833313f, -0.08752445f, -0.04333310f, 
    0.04562503f, -0.06415772f, -0.00489969f, 0.12848273f, -0.30411026f, 0.03878962f, -0.12691560f, 0.11308831f, 
    0.06016047f, -0.05045925f, -0.02574004f, 0.05283164f, 0.06472582f, 0.19763106f, -0.25683308f, -0.13115753f, 
    -0.09572615f, 0.19388899f, 0.09213544f, -0.07102515f, -0.03132358f, 0.07435437f, 0.14955190f, -0.15052553f, 
    0.02282762f, 0.14917077f, 0.12492086f, 0.25187576f, 0.04177492f, 0.04146104f, -0.15782021f, 0.01233535f, 
    0.16058418f, -0.09247188f, -0.07615808f, -0.15164630f, 0.04608552f, -0.05176103f, 0.09329954f, -0.07742247f, 
    0.05214477f, 0.32314852f, 0.10893402f, -0.17891815f, 0.00615608f, -0.01423769f, -0.17889488f, 0.20246957f, 
    -0.09129107f, 0.06781376f, 0.03332951f, -0.05790608f, -0.08584238f, 0.02891308f, -0.24918351f, 0.24609955f, 
    0.19650592f, 0.13562945f, 0.06123995f, 0.02294460f, -0.08640661f, -0.14285633f, -0.04059201f, 0.12984245f, 
    -0.11147656f, -0.04566142f, 0.20019060f, -0.00075009f, -0.01556215f, -0.22136408f, -0.01058754f, -0.08814798f, 
    -0.03006794f, -0.06662221f, -0.06330775f, -0.19736475f, 0.29773977f, 0.21444538f, -0.06235243f, -0.06557624f, 
    0.07209112f, 0.17456989f, -0.12111925f, 0.11762429f, -0.02105122f, 0.17623737f, -0.33340240f, -0.12097950f, 
    0.24453747f, 0.04524935f, 0.20743836f, 0.10948112f, -0.01345444f, -0.12871268f, -0.00276422f, 0.14845249f, 
    0.10261029f, -0.03542137f, -0.05450515f, 0.18906395f, 0.01428262f, 0.06863458f, -0.14615686f, 0.15653224f, 
    0.30545464f, -0.04102666f, 0.17702562f, -0.16488224f, 0.03740038f, -0.09783891f, 0.03813866f, 0.01153175f, 
    0.06544475f, -0.12623481f, -0.02248068f, -0.05380686f, 0.01343357f, 0.10582052f, 0.06137434f, 0.08828649f, 
    0.13157357f, -0.06311147f, -0.12413506f, -0.45612943f, -0.06495073f, -0.15222523f, 0.00405751f, 0.14674142f, 
    0.04588420f, -0.13164245f, 0.12019256f, -0.15605226f, -0.10841797f, -0.05458213f, -0.03223481f, -0.02256469f, 
    0.04918671f, -0.05019064f, -0.43320081f, 0.17220347f, -0.23662418f, -0.12591526f, -0.11769045f, 0.02574672f, 
    0.01138828f, -0.07566495f, -0.11742505f, 0.12247287f, 0.00241340f, 0.02563199f, -0.14852001f, -0.05103181f, 
    -0.12054928f, 0.01852795f, 0.01894806f, -0.00571203f, -0.02040213f, 0.51750720f, -0.23077781f, 0.04683425f, 
    -0.00790122f, 0.15136917f, 0.11768758f, -0.23077014f, -0.09426986f, 0.13300842f, 0.09130364f, 0.05770910f, 
    -0.05893411f, -0.10035207f, -0.18021113f, 0.05996793f, 0.04255178f, 0.07133660f, 0.19632547f, -0.25216013f, 
    -0.12069089f, -0.03515869f, -0.03610839f, -0.05036272f, 0.04341591f, 0.13096200f, 0.11964126f, -0.46888784f, 
    0.51985103f, -0.30718142f, -0.18518983f, -0.04962591f, 0.01958911f, -0.00047659f, -0.11017719f, 0.12529328f, 
    -0.09596751f, 0.11372702f, -0.33940396f, 0.02238899f, 0.01811619f, 0.06453677f, -0.09842365f, -0.00879793f, 
    0.05040688f, 0.10406712f, 0.03993148f, 0.05714117f, -0.07388322f, -0.05739054f, 0.02896384f, -0.04893684f, 
    0.01090839f, -0.02671884f, -0.05440433f, -0.01567800f, -0.06895596f, 0.08470675f, -0.06147193f, -0.01306380f, 
    0.06323559f, -0.13993390f, -0.03987021f, -0.47451785f, 0.10643481f, -0.52452725f, -0.02785304f, 0.12047736f, 
    -0.06596191f, 0.04795723f, 0.02313484f, -0.04619199f, 0.16105272f, 0.09462139f, -0.17432506f, 0.05464919f, 
    0.09668856f, 0.06051405f, 0.12414505f, 0.18463172f, 0.01272630f, 0.13379698f, 0.06589763f, -0.09705201f, 
    0.05770607f, -0.04706533f, 0.08942313f, 0.16217771f, 0.02200620f, -0.08862122f, -0.00318024f, 0.07041746f, 
    0.23352249f, 0.04784572f, -0.02661262f, -0.06113743f, 0.12095568f, 0.05354465f, 0.08224822f, 0.02746021f, 
    0.06480463f, -0.04790667f, 0.07863595f, 0.20488089f, -0.02372736f, 0.29629609f, 0.03403501f, -0.10748272f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00394345f, 0.09393229f, 0.09612680f, -0.11530333f, 0.14423080f, -0.05009519f, 0.19345960f, -0.03635490f, 
    -0.15026045f, -0.06195210f, -0.02191455f, 0.03765944f, -0.05761033f, -0.03754385f, 0.21469779f, 0.15041853f, 
    -0.07662400f, -0.09700561f, 0.13937835f, 0.10176270f, 0.09387284f, 0.23832114f, 0.26653838f, 0.00679172f, 
    0.25621650f, -0.04811998f, 0.07272751f, 0.02761158f, 0.23789257f, 0.21323170f, 0.08334592f, 0.14944789f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06521230f, -0.09139193f, -0.03353734f, 0.04142310f, -0.19661053f, -0.05919261f, -0.22508363f, -0.08727890f, 
    -0.11699103f, 0.06780492f, -0.02113762f, 0.05977985f, 0.08531544f, -0.11877251f, 0.29683027f, 0.10339630f, 
    0.12752116f, -0.17388529f, 0.06544499f, -0.08488692f, -0.17246069f, -0.01896024f, -0.34528539f, 0.07525964f, 
    0.27281466f, -0.07806203f, -0.05961905f, -0.08883926f, -0.17904449f, -0.07650603f, 0.05626690f, 0.04073447f, 
    0.02922782f, 0.08964709f, -0.55253232f, -0.25618097f, 0.04880040f, 0.01466371f, 0.16315550f, 0.14795201f, 
    0.05772656f, -0.15107420f, 0.29986891f, 0.26520801f, -0.16002348f, 0.03668789f, -0.13691826f, -0.06231226f, 
    0.10418182f, 0.18345872f, 0.63987231f, -0.09875395f, 0.27869600f, 0.17416087f, 0.31300911f, 0.23139717f, 
    0.08414641f, -0.49493140f, 0.04894880f, -0.12575522f, -0.00219402f, 0.01793307f, -0.26297158f, 0.08347145f, 
    0.18800765f, -0.59522140f, -0.01154769f, 0.10651783f, -0.10250192f, -0.00073735f, -0.15377352f, -0.05978463f, 
    0.12793832f, 0.04892534f, 0.00038036f, -0.02784042f, -0.02552330f, -0.12404487f, -0.04078292f, 0.19635236f, 
    -0.18517493f, 0.33549184f, 0.08419410f, 0.11300831f, -0.41736344f, -0.52869427f, 0.29386878f, -0.09128597f, 
    0.00331538f, -0.08580817f, -0.30231163f, -0.16915348f, 0.09625087f, 0.11541013f, -0.06511493f, -0.01540964f, 
    -0.11355959f, 0.24410391f, 0.26354462f, 0.17843375f, -0.37872338f, 0.18610397f, -0.12294954f, 0.05170038f, 
    0.19031705f, 0.17155246f, 0.34213433f, -0.01879969f, 0.13717495f, 0.07619298f, 0.19092275f, 0.12815319f, 
    0.06444943f, 0.30010757f, -0.09203479f, -0.24573959f, -0.03634522f, -0.06816383f, -0.60168833f, -0.43953142f, 
    -0.05947613f, -0.27047309f, 0.04831043f, 0.06139832f, -0.09891251f, 0.27193555f, 0.07028835f, -0.26251933f, 
    -0.15467085f, 0.06053533f, 0.01840935f, -0.06022470f, -0.04942734f, 0.06245599f, 0.16824645f, 0.13180457f, 
    0.14205620f, -0.17058116f, -0.15305565f, -0.05315877f, 0.10439935f, -0.05622674f, -0.18086457f, -0.12119929f, 
    -0.04243258f, -0.12367399f, -0.14231572f, -0.16536607f, -0.17299612f, 0.14513373f, -0.00688283f, -0.11102233f, 
    -0.07632024f, -0.04486472f, 0.01774920f, -0.03126360f, 0.09523009f, 0.14340055f, -0.14781925f, -0.14404559f, 
    -0.06061135f, 0.27159363f, 0.22298050f, -0.34236133f, -0.02529571f, -0.27126929f, -0.00987022f, 0.08506519f, 
    -0.09948870f, -0.17672093f, 0.19805703f, 0.19229545f, 0.02557459f, 0.15348811f, -0.02026024f, -0.02257554f, 
    -0.21906933f, -0.19569862f, 0.29697707f, 0.35522854f, 0.37868881f, 0.58621138f, -0.20475332f, -0.20166957f, 
    0.40951917f, 0.13320298f, 0.32129061f, 0.15386219f, 0.30866644f, -0.08676636f, 0.32481369f, -0.33924830f, 
    -0.00507358f, 0.07680165f, -0.27668691f, 0.10456152f, -0.16196516f, 0.19412929f, -0.07690063f, -0.05963608f, 
    0.00573833f, -0.21069698f, -0.07550935f, -0.10307915f, 0.11978456f, -0.02161963f, 0.34728536f, 0.16562381f, 
    0.05928446f, 0.05229852f, -0.42849749f, 0.13583769f, 0.16459195f, 0.25324816f, -0.11930275f, -0.17636341f, 
    0.12557904f, 0.52734035f, 0.13386819f, -0.05987994f, 0.03308976f, 0.13078183f, -0.00162303f, 0.08056554f, 
    -0.17128147f, 0.20000768f, 0.27077964f, 0.13385965f, 0.78364021f, 0.34651893f, -0.18787815f, 0.00613239f, 
    0.13478450f, 0.07001127f, 0.16174045f, 0.39675269f, -0.07952578f, 0.16125573f, -0.23757643f, -0.12911217f, 
    0.06190325f, -0.00484952f, -0.24496469f, -0.07967851f, 0.15906525f, 0.14895415f, -0.45631859f, 0.12897098f, 
    0.07823581f, 0.54809660f, 0.08096493f, 0.09626684f, 0.02487745f, 0.03521095f, -0.18981852f, -0.05393858f, 
    0.06718265f, 0.81366688f, -0.51016068f, 0.20503187f, -0.14332412f, -0.32838690f, 0.12150840f, -0.13710840f, 
    0.15263276f, -0.53852135f, 0.25547653f, -0.13043931f, -0.09948623f, 0.03247515f, 0.31779787f, -0.03307730f, 
    -0.33407211f, -0.05748022f, -0.25811881f, 0.30579662f, 0.29132766f, 0.64071274f, 0.60123295f, 0.04305470f, 
    0.17448004f, -0.29945511f, 0.24783725f, 0.16469184f, -0.03724804f, -0.05913944f, 0.10007594f, -0.22311625f, 
    0.19673781f, -0.14200340f, 0.17810951f, 0.35985544f, 0.11493964f, -0.19750695f, 0.12415831f, -0.14032763f, 
    -0.21419320f, -0.02511657f, -0.13354665f, -0.04269208f, -0.10132629f, 0.07265387f, 0.06116869f, 0.09439751f, 
    -0.02910445f, 0.06260308f, -0.15974897f, -0.28869265f, 0.03467907f, -0.32011110f, -0.19890516f, -0.12362359f, 
    0.27995157f, 0.10539310f, -0.27219930f, -0.06304584f, 0.03761894f, 0.03315312f, -0.07991502f, -0.33828250f, 
    0.04251654f, 0.07082761f, -0.05928974f, -0.27005169f, 0.08564249f, -0.06272620f, -0.12080088f, 0.07954016f, 
    -0.24963619f, 0.18605874f, -0.14843901f, -0.24836297f, -0.13566083f, 0.03508544f, -0.16481663f, 0.11751737f, 
    0.06132022f, -0.44226176f, -0.09462345f, -0.20049764f, -0.05677177f, -0.13729016f, 0.18503086f, -0.06232465f, 
    -0.31599164f, 0.04834355f, 0.03871499f, -0.06627677f, 0.12209068f, -0.40335321f, 0.19504976f, -0.05353592f, 
    -0.17826459f, 0.11764837f, -0.01146178f, 0.03310195f, 0.12999181f, 0.00647138f, -0.17621060f, 0.05745703f, 
    -0.12814257f, -0.18383372f, -0.04682873f, -0.08539490f, 0.15512608f, 0.04454703f, 0.09779679f, -0.14955133f, 
    -0.02175452f, 0.02951412f, -0.01670386f, 0.03284504f, -0.03364203f, -0.05166516f, 0.13907330f, -0.00761709f, 
    -0.14320375f, 0.09142148f, -0.16373466f, -0.17622577f, -0.00078875f, -0.02222987f, -0.14378291f, -0.04575022f, 
    0.01924451f, 0.77984583f, 0.00249755f, 0.49734053f, 0.32487565f, -0.13540623f, -0.05625289f, -0.01346336f, 
    0.33778903f, -0.11295708f, 0.13929528f, -0.07782616f, 0.15022098f, 0.09646119f, -0.12340262f, -0.08097006f, 
    -0.28013536f, 0.12672572f, -0.08481549f, -0.28206459f, 0.41472900f, 0.17251681f, 0.00662334f, -0.43746608f, 
    -0.14295350f, 0.27733991f, 0.03324410f, -0.16836025f, -0.12845947f, 0.12322026f, -0.38603592f, 0.17664677f, 
    0.13404989f, 0.72990113f, -0.39338017f, 0.17128697f, -0.04608002f, -0.08843833f, 0.10929321f, 0.02441164f, 
    -0.06530624f, -0.16120304f, 0.18197918f, -0.20413767f, -0.13832872f, -0.13386488f, 0.02089509f, 0.15885040f, 
    -0.11978680f, 0.20347793f, -0.20155588f, 0.08671424f, 0.23998024f, 0.36344057f, 0.13480130f, -0.41114759f, 
    0.19700415f, -0.31553707f, -0.06479190f, 0.12952331f, 0.15289102f, 0.15985997f, 0.29482642f, -0.14862841f, 
    0.18801828f, -0.43942040f, 0.41953805f, -0.04288159f, -0.00380243f, 0.32686135f, -0.10083047f, -0.14897920f, 
    -0.08070029f, 0.02406952f, 0.04367403f, 0.16876249f, 0.03313525f, -0.12991391f, 0.33808786f, 0.19460505f, 
    0.01519151f, -0.23401351f, 0.07513323f, -0.12912604f, -0.16211212f, -0.40488774f, -0.05902536f, 0.23109536f, 
    0.26963964f, 0.15226431f, -0.08216285f, -0.09059357f, -0.08778263f, 0.10759249f, -0.07133168f, 0.37083837f, 
    -0.04572637f, -0.17094687f, 0.40803242f, -0.33201483f, -0.06274592f, -0.05488830f, -0.01746667f, -0.05932039f, 
    -0.23421095f, -0.30487555f, -0.11485831f, 0.33121297f, -0.01783461f, 0.16547868f, 0.05558730f, -0.18064198f, 
    -0.48572168f, -0.13632157f, 0.17064826f, 0.32232428f, -0.10240628f, 0.41826910f, -0.41807291f, -0.11227663f, 
    0.11440223f, -0.04903515f, 0.29909870f, -0.16877548f, 0.28833264f, 0.02890587f, 0.67286092f, 0.21444459f, 
    0.04163518f, -0.13357988f, -0.00917829f, 0.09549412f, 0.07782112f, -0.02636658f, -0.03931607f, -0.04263050f, 
    -0.04102306f, -0.04060359f, 0.14256968f, -0.08512444f, -0.14374535f, 0.08701582f, 0.05021734f, 0.16032645f, 
    -0.12924699f, -0.15337127f, -0.03334608f, -0.16848630f, -0.17262378f, -0.01683314f, -0.09788465f, -0.01533659f, 
    0.03749264f, -0.09887811f, -0.07463064f, -0.11033259f, -0.15066600f, -0.15875439f, -0.01062828f, 0.08095827f, 
    0.23031141f, -0.45690033f, 0.10509110f, -0.21272916f, -0.12074609f, -0.10928103f, -0.35277882f, 0.14837916f, 
    -0.04704168f, 0.21360941f, 0.00961448f, -0.08002435f, 0.16733897f, 0.05587398f, 0.05607070f, -0.23093970f, 
    -0.13170604f, -0.14817470f, 0.06066279f, -0.24540105f, 0.05544278f, -0.35322165f, 0.02975772f, 0.03599994f, 
    -0.03906160f, 0.35705808f, -0.23140875f, 0.13340083f, 0.05671423f, 0.15841934f, 0.07161482f, -0.09461367f, 
    0.08516508f, -0.25676757f, 0.06157669f, -0.13256995f, -0.20102067f, 0.41855207f, -0.22769935f, 0.01432896f, 
    -0.16471562f, -0.13206777f, 0.04949113f, 0.05201155f, 0.06795795f, -0.02625785f, 0.28348750f, 0.20525984f, 
    -0.16466746f, 0.15159990f, -0.29285675f, 0.04774489f, -0.36471432f, -0.32961413f, 0.26507914f, -0.23198980f, 
    -0.00920763f, -0.06569134f, 0.08017189f, 0.00693284f, 0.16624406f, 0.02346649f, 0.41048542f, -0.17976315f, 
    0.05765960f, -0.44591251f, -0.45220259f, 0.16469187f, -0.16432615f, -0.27530560f, 0.11531120f, -0.07874686f, 
    0.11151426f, 0.00359176f, 0.14542320f, 0.13593005f, -0.08012903f, -0.14985032f, -0.24185438f, -0.10622039f, 
    0.13511059f, -0.11573537f, 0.05951635f, 0.08411773f, 0.15131736f, -0.24205638f, -0.40020570f, 0.08411223f, 
    0.00288090f, -0.14729458f, -0.07459817f, 0.01701968f, 0.10539975f, -0.11738624f, 0.15242949f, 0.11554665f, 
    -0.11494769f, -0.06362315f, 0.16247411f, -0.07679036f, 0.02292397f, 0.07883386f, 0.08266122f, 0.02409620f, 
    -0.08414198f, 0.05879039f, 0.02099834f, -0.08708597f, -0.16387999f, 0.12917975f, -0.14864832f, 0.08415979f, 
    -0.14985156f, -0.13784999f, -0.09676318f, 0.10396759f, -0.16917098f, -0.05217912f, -0.05636871f, -0.05793645f, 
    -0.08020218f, -0.10944635f, -0.13542044f, -0.15893357f, -0.14656362f, -0.14758822f, 0.06242089f, -0.13165724f, 
    -0.07048614f, -0.11599861f, 0.58918417f, -0.25454536f, -0.08674981f, -0.02783353f, 0.29992062f, -0.02500930f, 
    -0.23615444f, 0.20014422f, -0.17120306f, 0.10993918f, 0.00797366f, -0.05741043f, -0.03016696f, 0.22722377f, 
    -0.27507883f, 0.02299391f, 0.60351413f, -0.28799784f, 0.36529273f, 0.30636299f, 0.07978367f, 0.36625266f, 
    0.04757480f, -0.31787539f, 0.09872685f, 0.07500018f, 0.11156300f, -0.22621898f, 0.16810587f, -0.18335058f, 
    0.12514859f, -0.38380787f, -0.32406300f, -0.23768707f, 0.10715096f, 0.14420079f, -0.05526181f, -0.05645601f, 
    -0.18606220f, 0.08130185f, 0.01649819f, 0.11022713f, -0.08134040f, -0.02134948f, 0.11204226f, 0.15820147f, 
    0.05951624f, -0.02226095f, -0.15849809f, 0.24148975f, -0.35482785f, 0.02668840f, 0.35900727f, 0.29836136f, 
    0.07048471f, 0.06960336f, -0.12530883f, 0.12043605f, -0.21788704f, 0.01170406f, -0.06541666f, 0.05538116f, 
    -0.06498962f, -0.84995306f, 0.14348105f, 0.05027537f, -0.15585329f, 0.04104302f, -0.12507811f, 0.06948154f, 
    -0.13468696f, 0.17765844f, 0.03305842f, -0.11149871f, 0.13488087f, 0.15461324f, -0.09583358f, 0.20689182f, 
    -0.02473569f, 0.12456559f, 0.10094885f, 0.25437373f, 0.18235464f, 0.08280537f, -0.59597069f, 0.06599253f, 
    -0.13946295f, 0.21053675f, 0.22175480f, -0.03500351f, -0.10326760f, -0.44335839f, -0.37630907f, -0.16783546f, 
    -0.06437725f, -0.13098948f, -0.07313673f, 0.06062611f, -0.09439341f, 0.05662726f, -0.03742659f, 0.01744641f, 
    0.03598199f, -0.05371557f, -0.16919906f, -0.11419046f, 0.03515721f, 0.07536773f, -0.15028502f, -0.07321618f, 
    -0.03519017f, -0.01999912f, -0.01495271f, 0.05521231f, 0.16800275f, -0.14804257f, -0.15945025f, -0.03268808f, 
    0.10275657f, -0.07989555f, 0.12685765f, 0.08276401f, 0.03172290f, -0.09219446f, -0.16687205f, 0.05278872f, 
    -0.08452047f, 0.42592436f, 0.01358960f, -0.20120333f, 0.28869766f, -0.16388565f, 0.16195238f, -0.11615100f, 
    -0.10917858f, 0.13481532f, -0.08061988f, -0.14376275f, 0.16521746f, 0.14489131f, 0.11647815f, 0.05833004f, 
    -0.03280428f, -0.07741045f, -0.06673446f, -0.08568245f, 0.23531513f, 0.37260947f, 0.16462725f, -0.02892031f, 
    0.01804787f, 0.22668086f, 0.15778194f, 0.09669291f, -0.26800552f, -0.03259055f, -0.08702983f, 0.28825065f, 
    0.16664542f, 0.49351481f, 0.02429222f, 0.35601267f, -0.18901068f, -0.01144194f, -0.34526804f, 0.02696539f, 
    0.26903456f, 0.13067177f, 0.31902790f, -0.25985971f, -0.12071070f, 0.16373625f, 0.16573100f, -0.15688045f, 
    -0.20029627f, 0.18476349f, 0.01244382f, -0.42787486f, -0.70273966f, -0.09068162f, 0.08658256f, 0.16872057f, 
    0.16385233f, 0.12240204f, -0.32657462f, -0.10076359f, -0.08111109f, 0.27752477f, -0.41965574f, 0.68953484f, 
    -0.05023936f, -0.08190928f, -0.21369009f, -0.08269256f, -0.11783429f, -0.06772054f, -0.01930506f, 0.13294601f, 
    -0.11665193f, -0.15911415f, -0.17858954f, -0.00803924f, -0.03403923f, 0.11368944f, -0.09646845f, -0.08133731f, 
    0.05501001f, -0.10020812f, 0.02740246f, 0.08130773f, 0.01229601f, -0.01007651f, -0.08193912f, -0.08847553f, 
    0.12836623f, -0.12196555f, -0.02491482f, 0.10033055f, -0.09262213f, 0.00333781f, 0.10870926f, 0.17858893f, 
    0.12111960f, -0.17004593f, 0.19336890f, -0.09698894f, -0.37159723f, -0.12487787f, 0.11706565f, -0.05389977f, 
    -0.07392414f, 0.13182615f, -0.16475821f, -0.07638697f, 0.06305528f, 0.06111742f, -0.10417795f, 0.32103229f, 
    -0.10114724f, -0.07725003f, 0.63378644f, 0.04619187f, 0.50005692f, -0.00497432f, 0.37695944f, 0.07108366f, 
    0.12005955f, 0.02105466f, 0.23776706f, -0.02968273f, 0.12534791f, 0.00691566f, 0.31319410f, -0.36621717f, 
    0.00245974f, -0.31145197f, -0.28524867f, -0.22306974f, 0.01687918f, 0.06018242f, -0.10734282f, -0.05253710f, 
    -0.11506681f, 0.06381301f, 0.28671455f, 0.14175628f, -0.07938251f, 0.05670847f, 0.26468509f, -0.09201889f, 
    0.09436784f, 0.03070419f, 0.30895233f, 0.19160967f, -0.26889268f, 0.07544055f, 0.05832837f, 0.36639321f, 
    0.12920110f, -0.13555034f, -0.00629411f, 0.00765740f, -0.06174628f, 0.28403524f, -0.10024378f, 0.13730541f, 
    0.01855185f, -0.49088454f, 0.65876317f, 0.12393314f, 0.16561949f, 0.31122851f, -0.15766928f, -0.10435732f, 
    -0.23638237f, -0.08743881f, -0.03341430f, 0.35615736f, -0.06269398f, 0.18005870f, 0.02196835f, 0.07997919f, 
    0.08964776f, -0.02421827f, 0.25488719f, -0.16191089f, -0.15388630f, -0.23446772f, -0.36851057f, -0.36037898f, 
    0.18342549f, 0.24621902f, -0.11383394f, 0.03689510f, 0.20187363f, 0.20623726f, 0.12734237f, -0.10435887f, 
    0.16498674f, 0.38702330f, -0.03854904f, 0.25549248f, -0.04466942f, 0.37001178f, -0.23656157f, -0.01187915f, 
    -0.02800424f, -0.34078178f, -0.09424555f, -0.02159677f, 0.04928649f, 0.11511029f, 0.15676498f, 0.08390911f, 
    -0.28229401f, 0.28029037f, -0.55141276f, 0.20857483f, -0.25516438f, -0.28669623f, 0.36199856f, -0.24921796f, 
    -0.12817672f, 0.28747347f, -0.21544279f, -0.12004869f, 0.11693231f, 0.14063863f, 0.04499870f, 0.18782975f, 
    0.01044584f, -0.09738554f, 0.00496608f, -0.14905614f, 0.02458870f, 0.06439395f, 0.01394102f, 0.04719222f, 
    0.08284160f, 0.12095834f, -0.19942126f, -0.04355674f, 0.05599013f, -0.01003410f, 0.07908943f, -0.18480964f, 
    -0.14899996f, 0.02499928f, -0.00933807f, 0.08732509f, -0.12469441f, 0.11447342f, 0.07516151f, -0.10758891f, 
    0.02706072f, -0.16625123f, 0.04615857f, 0.04849418f, -0.22194417f, -0.06266267f, -0.07408826f, -0.10447275f, 
    -0.07869580f, 0.12633628f, 0.12924719f, -0.07156967f, 0.18348883f, -0.08712239f, -0.09877240f, -0.13541837f, 
    -0.10462497f, -0.05256832f, -0.15601628f, 0.04974449f, 0.01402426f, 0.11228175f, 0.00876803f, -0.04624896f, 
    -0.07194584f, -0.06373326f, -0.02249263f, 0.02705490f, 0.13955431f, -0.10756806f, -0.10135230f, -0.15543951f, 
    -0.16281673f, -0.02993582f, -0.09557999f, 0.04021454f, 0.11000566f, 0.06098171f, -0.07163160f, 0.16555671f, 
    -0.24200217f, -0.27887818f, 0.62693632f, 0.06538403f, 0.59344363f, -0.22259218f, 0.04583739f, 0.08338553f, 
    -0.13236885f, 0.09377667f, -0.06949978f, 0.04053863f, 0.05053605f, -0.12834170f, -0.04383444f, -0.12273694f, 
    -0.02118584f, 0.11764361f, -0.21691950f, 0.12417423f, 0.12356031f, -0.00702001f, -0.39581883f, 0.67565501f, 
    0.12671165f, 0.47775203f, 0.03579737f, 0.16062048f, 0.21726649f, 0.11805867f, -0.19842106f, -0.29531407f, 
    0.01746799f, -0.11307673f, -0.14381240f, -0.03923910f, -0.19953541f, 0.55722439f, -0.06990604f, 0.10623328f, 
    0.11919034f, -0.14998940f, 0.32252607f, 0.26926062f, -0.04889555f, -0.14018299f, 0.09087645f, -0.16404487f, 
    0.22476451f, 0.17263199f, 0.16013126f, -0.13948210f, 0.02348690f, 0.22005799f, 0.18568869f, 0.20399117f, 
    -0.13290738f, -0.23835801f, 0.25370973f, -0.12723723f, -0.15142116f, -0.09116669f, 0.14119108f, 0.48739019f, 
    0.29202867f, 0.02430094f, -0.09468108f, 0.49037498f, -0.06158833f, 0.56401294f, -0.39339650f, -0.16474676f, 
    0.08081439f, 0.11428879f, 0.02706232f, 0.20893571f, 0.00454187f, -0.00826750f, 0.21235816f, 0.25515875f, 
    -0.25351682f, 0.17234185f, -0.20624369f, -0.44976330f, -0.45838645f, -0.46918842f, 0.51812416f, 0.23166253f, 
    -0.09016921f, 0.32733047f, -0.51279533f, 0.06343463f, -0.29539537f, -0.02265380f, -0.25404942f, 0.28596351f, 
    -0.09285254f, -0.51108760f, -0.15743650f, 0.01365909f, -0.18527579f, -0.14233893f, 0.30281809f, -0.10863749f, 
    -0.11415544f, -0.02460992f, -0.10041071f, -0.15976635f, 0.02534617f, 0.05153324f, 0.51053977f, 0.25988683f, 
    -0.09685612f, -0.16740865f, 0.25699699f, 0.12273367f, -0.21078598f, -0.30167007f, 0.73060042f, 0.53740782f, 
    0.05626275f, -0.10378858f, -0.16235733f, -0.07268476f, -0.00861995f, 0.18302999f, -0.01436722f, 0.39505813f, 
    -0.19823912f, 0.24747629f, 0.18409808f, -0.26851591f, 0.51480103f, -0.17359567f, 0.08169194f, -0.03462853f, 
    -0.03783787f, -0.16002133f, -0.12700433f, 0.30198112f, -0.02563310f, -0.02180874f, 0.05032518f, -0.22896288f, 
    -0.22097825f, 0.09510326f, 0.29046980f, 0.04862387f, 0.12040571f, 0.53817779f, -0.51848495f, 0.42514598f, 
    -0.28030500f, -0.10885049f, 0.25346187f, -0.17371543f, 0.25485757f, 0.05190010f, 0.23822820f, 0.22752017f, 
    -0.11422484f, 0.48084933f, -0.29054075f, -0.20948319f, 0.18015939f, -0.42198202f, -0.05772343f, 0.01250068f, 
    -0.02935290f, -0.02950414f, -0.16485618f, -0.15586172f, 0.16757062f, -0.05710761f, 0.44282952f, 0.09462608f, 
    -0.19225335f, 0.11715111f, -0.17733490f, 0.29847065f, 0.00404065f, 0.50903291f, 0.09458461f, 0.11514667f, 
    -0.11838079f, 0.09571754f, -0.14855973f, 0.10597701f, 0.03454771f, 0.21907701f, 0.05768937f, 0.25860733f, 
    0.19470303f, -0.07450768f, -0.15647696f, 0.29614514f, -0.31271338f, 0.21815662f, -0.10321198f, 0.03739144f, 
    0.24522723f, 0.15681796f, -0.03703389f, 0.07916566f, 0.09525403f, -0.04551274f, 0.15973194f, 0.30274993f, 
    -0.01848731f, -0.16680723f, 0.06777670f, -0.23097382f, 0.12681741f, -0.28500333f, 0.45713127f, 0.41028079f, 
    -0.02159281f, 0.24554498f, 0.16762863f, -0.01984332f, -0.25579414f, 0.12506625f, -0.24849989f, 0.19085677f, 
    -0.18096922f, 0.03900265f, 0.35984775f, 0.19624937f, -0.06213550f, 0.45817217f, 0.00664254f, -0.06462082f, 
    -0.01563043f, 0.11006746f, -0.00955679f, -0.15686472f, 0.10403152f, -0.07341214f, 0.30873984f, 0.21622823f, 
    0.08882875f, -0.12166641f, 0.10662884f, -0.02492393f, 0.28329492f, -0.07693297f, 0.14277750f, 0.01758367f, 
    -0.13301241f, 0.55927402f, 0.13375135f, -0.16239417f, -0.13362594f, -0.17023458f, -0.03881330f, 0.21516888f, 
    -0.08398612f, 0.08577424f, -0.53716570f, -0.10270774f, 0.55515236f, -0.26910093f, 0.19784164f, 0.01778641f, 
    0.08991536f, -0.30249387f, -0.08200622f, 0.03993725f, 0.04054834f, 0.10000993f, -0.14552025f, -0.14186180f, 
    -0.20047189f, 0.30267692f, -0.18472460f, 0.45529747f, -0.02474111f, 0.25555328f, 0.19667558f, -0.12539953f, 
    0.14251220f, 0.11305898f, -0.18804467f, -0.16204667f, 0.23985377f, 0.07602217f, -0.27172887f, 0.06885187f, 
    0.27339044f, 0.14144795f, -0.04094607f, -0.06573285f, -0.34614897f, -0.18131441f, 0.16360475f, 0.14879744f, 
    0.05285928f, 0.03220747f, 0.18359432f, -0.03916928f, -0.10894927f, 0.04087704f, -0.11643954f, 0.29319450f, 
    -0.18423425f, -0.08055320f, 0.59994256f, 0.12400511f, 0.13755620f, 0.39684924f, 0.30447221f, -0.24138214f, 
    0.16579309f, -0.52420139f, 0.21171278f, 0.03986574f, 0.20480913f, -0.06162011f, 0.15699309f, -0.38349193f, 
    -0.20146798f, -0.00731261f, -0.02002268f, 0.00972939f, 0.10157020f, -0.12054823f, -0.09925585f, 0.12098676f, 
    -0.10262311f, 0.07513218f, -0.12401852f, 0.07864352f, 0.03879786f, 0.01146390f, 0.04862286f, -0.06120240f, 
    0.00309042f, 0.09420463f, -0.14796983f, -0.11856331f, -0.16973746f, 0.16590206f, -0.06421606f, 0.13299739f, 
    -0.06225572f, -0.08590040f, -0.14635830f, 0.14166646f, -0.11278165f, -0.13748641f, -0.00074791f, -0.04655844f, 
    -0.24835978f, 0.57820302f, 0.27932179f, 0.18905890f, 0.65793920f, -0.32918108f, 0.20400257f, -0.15580504f, 
    0.07577826f, -0.15208681f, -0.21820112f, 0.06684311f, 0.07121909f, 0.11672283f, -0.03477734f, -0.07779783f, 
    -0.12753932f, 0.11201343f, 0.05538689f, -0.04370825f, -0.28238273f, 0.45783040f, -0.31936833f, -0.14629668f, 
    -0.14570695f, 0.11392961f, -0.11472584f, 0.00084230f, 0.29255280f, 0.31814304f, -0.26746646f, -0.01232062f, 
    0.22512700f, -0.14201963f, 0.34937081f, 0.33241668f, -0.30587137f, 0.18009754f, 0.13020518f, 0.06509341f, 
    -0.05695218f, 0.08445580f, -0.29891858f, -0.23723054f, 0.15952897f, -0.16148792f, 0.16024344f, 0.30085412f, 
    -0.30949304f, 0.04565672f, -0.24354415f, -0.05898994f, 0.31687832f, -0.38981548f, 0.88645667f, 0.27571571f, 
    -0.16694824f, 0.17532207f, -0.15645835f, 0.11277959f, 0.11921510f, -0.12104712f, 0.17192566f, -0.23448096f, 
    0.18823820f, -0.09329595f, 0.16729437f, -0.09089864f, 0.34097451f, 0.23541316f, 0.06895235f, -0.02094325f, 
    -0.21906458f, 0.13585047f, -0.01147599f, -0.20312352f, -0.12254057f, -0.06144686f, 0.12669171f, -0.04415292f, 
    0.06049661f, -0.11215115f, -0.34964702f, -0.13780217f, -0.08822422f, 0.35535005f, 0.11340644f, -0.00182363f, 
    -0.17928749f, 0.51837498f, 0.11317368f, 0.15685810f, -0.00168333f, 0.04832936f, -0.11874294f, 0.19326185f, 
    0.13728446f, 0.01595783f, -0.16421635f, -0.17836896f, 0.08124834f, -0.26165542f, -0.04892033f, -0.05135787f, 
    -0.11932148f, -0.19835523f, 0.28727669f, 0.07596245f, -0.12287937f, 0.01400010f, 0.30000553f, 0.17779750f, 
    -0.23499623f, -0.13406290f, -0.15638229f, 0.34763059f, -0.23168151f, 0.09499554f, 0.09443447f, -0.23379387f, 
    0.27513793f, -0.25712657f, 0.13114801f, -0.15002574f, 0.19223437f, 0.27519664f, 0.03693167f, -0.05970569f, 
    0.10178095f, -0.01045162f, -0.02578717f, -0.02903884f, 0.15255022f, 0.07923889f, -0.21648818f, 0.08811313f, 
    -0.17874762f, 0.02670399f, 0.17800245f, 0.12276579f, 0.17321336f, -0.11576730f, -0.01138593f, -0.03129074f, 
    -0.11457708f, 0.18565449f, 0.25482211f, -0.29894105f, -0.77519274f, -0.09138665f, -0.00433700f, 0.20541304f, 
    0.14574865f, -0.25610811f, -0.20449685f, 0.05970522f, -0.09123584f, 0.42925817f, 0.00579564f, 0.34568775f, 
    -0.17701821f, -0.45985731f, 0.13724524f, -0.37598929f, 0.25612646f, 0.33358729f, -0.14873697f, 0.08057392f, 
    -0.18101600f, -0.39649448f, 0.11072876f, 0.49637729f, -0.15763544f, -0.00664695f, 0.20743704f, 0.04615261f, 
    -0.15623908f, 0.05563610f, 0.07311600f, 0.31784689f, 0.12696669f, -0.15384975f, 0.12032106f, 0.57219267f, 
    0.13253373f, -0.29851249f, 0.11331845f, 0.05595826f, 0.17773762f, -0.10109726f, 0.32556486f, 0.17001177f, 
    -0.19510093f, 0.25797018f, 0.13334684f, -0.09958715f, 0.44347844f, 0.07646130f, 0.07247247f, 0.11020713f, 
    0.16435692f, -0.01187734f, 0.03319767f, -0.07076971f, 0.01339227f, -0.17061614f, 0.29481742f, -0.16144703f, 
    -0.06751211f, 0.10323033f, -0.44476154f, 0.05446480f, -0.21448711f, 0.07453193f, 0.02674823f, 0.18823279f, 
    -0.12184796f, 0.44420931f, -0.11077708f, 0.01342573f, 0.02929285f, 0.05672514f, -0.09858547f, 0.12505296f, 
    0.12187719f, 0.09786625f, -0.18213362f, 0.19138178f, 0.36253986f, 0.07129062f, 0.35151914f, 0.03369814f, 
    0.10754432f, 0.05288749f, -0.22061853f, 0.00667079f, -0.07145260f, 0.03369364f, 0.02110570f, -0.13604839f, 
    0.19552369f, 0.13993587f, 0.20652565f, -0.20204753f, 0.19970275f, -0.21588910f, 0.53205061f, 0.33490524f, 
    -0.16421504f, -0.28434262f, -0.13623604f, -0.07123859f, -0.17526959f, 0.18413009f, -0.27118945f, 0.15919158f, 
    -0.17649433f, 0.19637793f, 0.17030434f, -0.09338894f, -0.11767098f, 0.34509176f, -0.33643320f, -0.11140212f, 
    -0.16715728f, -0.62927252f, 0.34448144f, 0.11756653f, 0.05265279f, 0.00607880f, 0.36058050f, -0.03113637f, 
    -0.40756357f, -0.22234312f, -0.09985379f, 0.41967604f, 0.02267476f, 0.05822796f, 0.08522899f, -0.33676952f, 
    0.17691225f, 0.24773963f, 0.36326933f, -0.01166552f, 0.11890372f, 0.11826529f, 0.22259884f, 0.14217682f, 
    0.14891988f, 0.24695037f, -0.15144755f, 0.15577292f, 0.36943376f, 0.43188694f, -0.11978273f, 0.16635917f, 
    0.04579959f, 0.09826731f, 0.17456163f, 0.28463402f, -0.13837302f, -0.14156049f, -0.12670216f, -0.27585819f, 
    0.10125674f, -0.06548776f, 0.05284982f, -0.31874618f, 0.04293221f, 0.26927420f, -0.39240229f, -0.28594857f, 
    0.13681352f, 0.16344430f, 0.02872394f, -0.07251274f, -0.10682602f, 0.09192241f, -0.09584699f, 0.26128569f, 
    0.03991114f, 0.27067760f, 0.41689345f, 0.01359666f, 0.33641455f, -0.36134470f, 0.12056926f, -0.05663211f, 
    -0.16994677f, 0.05048072f, -0.04689302f, 0.04015088f, -0.06978481f, 0.05675034f, 0.00972095f, 0.03035434f, 
    -0.11774416f, 0.08174874f, -0.16500610f, 0.03758156f, -0.02397395f, 0.31250092f, -0.61657614f, -0.26784205f, 
    0.19731376f, -0.24827497f, -0.00439545f, -0.02776843f, 0.22212476f, 0.14383300f, 0.10212713f, -0.51601267f, 
    0.30230680f, 0.29451644f, -0.59796321f, -0.04296877f, -0.01500375f, -0.24347538f, 0.00167105f, 0.17610686f, 
    0.03455499f, -0.11431114f, -0.05253804f, -0.20613804f, 0.07411702f, 0.04182078f, -0.16308975f, 0.04831870f, 
    -0.06842849f, 0.31361243f, 0.19261511f, 0.22899622f, 0.05495186f, 0.04714891f, 0.59581822f, -0.45268521f, 
    0.20652632f, -0.27587608f, 0.07865272f, -0.07467373f, -0.05727671f, 0.28816256f, -0.21620695f, -0.20705189f, 
    -0.04326691f, 0.37895223f, 0.35345247f, -0.07548746f, -0.00891762f, 0.30171633f, 0.08407899f, 0.03240200f, 
    0.08241317f, -0.02874798f, 0.13287762f, 0.15681469f, -0.05477352f, 0.07891862f, -0.10868847f, -0.13866562f, 
    -0.02212557f, 0.01893509f, -0.03387662f, -0.03879360f, 0.45312899f, 0.15519403f, -0.11603268f, 0.24368075f, 
    -0.26224288f, 0.10531595f, 0.28028473f, 0.04574298f, -0.10774869f, -0.18695961f, 0.10981914f, -0.06605374f, 
    -0.05864513f, -0.38774601f, 0.80152458f, 0.00307108f, -0.28854004f, -0.13071823f, 0.10032903f, 0.10721646f, 
    -0.28821188f, 0.08965242f, -0.00965926f, -0.21446066f, -0.14815216f, -0.12026136f, 0.27548826f, 0.21145763f, 
    -0.37851903f, 0.00288918f, -0.01364356f, 0.02333007f, 0.27065179f, -0.30188391f, -0.27487001f, -0.04050547f, 
    0.36947507f, 0.30096951f, -0.03120775f, 0.14583695f, 0.21691911f, 0.22876684f, 0.21584408f, -0.29489037f, 
    0.35278675f, 0.81327164f, -0.01579694f, 0.55571663f, -0.28839731f, 0.45376587f, 0.10355093f, 0.04470178f, 
    0.10917475f, -0.18438731f, -0.17847136f, -0.25391778f, 0.02055697f, -0.14883344f, -0.38757038f, 0.22111629f, 
    -0.45879123f, 0.20138234f, 0.15623558f, -0.36428726f, 0.17565489f, -0.02814943f, 0.46264061f, -0.30271372f, 
    0.10879532f, 0.37588629f, -0.08705793f, -0.06934284f, -0.03727528f, -0.06358016f, 0.02306757f, -0.45055291f, 
    0.00941274f, -0.08896418f, 0.24863689f, 0.06670242f, -0.46285185f, -0.00544261f, 0.06699774f, -0.11908119f, 
    0.00520296f, -0.00858917f, -0.03149397f, -0.03994315f, 0.07066305f, -0.16079110f, 0.41597286f, 0.19964224f, 
    -0.12753563f, 0.00381787f, 0.27533349f, -0.18717319f, -0.35950452f, -0.12282385f, -0.25919211f, 0.07327418f, 
    0.16385740f, -0.56592119f, -0.03558894f, 0.04625034f, 0.22618502f, 0.31697962f, 0.28671497f, 0.01020229f, 
    -0.21244361f, -0.40511900f, 0.06272531f, -0.13027632f, -0.06229452f, -0.11598758f, -0.11564206f, 0.13493322f, 
    -0.20147128f, 0.17472263f, -0.04070152f, -0.03256597f, -0.00105388f, 0.16043425f, -0.06642624f, -0.23434614f, 
    0.10451730f, -0.10038242f, -0.15151145f, -0.03084175f, -0.11047900f, -0.20702490f, 0.01084328f, 0.14426588f, 
    -0.01554380f, 0.03920271f, -0.32444710f, 0.02214121f, -0.02174278f, -0.21474181f, 0.23638745f, 0.02449762f, 
    0.06058938f, 0.16052799f, 0.43515372f, 0.14704336f, -0.11499771f, -0.17022036f, -0.12690185f, 0.17862473f, 
    0.00479332f, -0.19151616f, 0.22460234f, -0.13273294f, 0.12435167f, 0.08203678f, 0.39910397f, 0.05046319f, 
    0.14461857f, -0.08885258f, 0.12656866f, -0.35748562f, -0.18213990f, -0.06165818f, -0.64148533f, -0.06324788f, 
    0.01194421f, -0.13746235f, -0.00089166f, 0.04209184f, 0.13664426f, 0.26192209f, 0.15636840f, 0.21683760f, 
    -0.13666944f, -0.00812069f, 0.21537128f, -0.16464707f, 0.36696729f, 0.07817673f, 0.12009607f, 0.14212532f, 
    0.15522508f, 0.12223239f, -0.06249993f, 0.12933809f, 0.03196384f, -0.17455079f, 0.07279520f, -0.16969015f, 
    0.09669287f, 0.14177620f, 0.10672572f, -0.05121729f, 0.05439182f, 0.14724518f, 0.36430311f, 0.47387287f, 
    -0.24064669f, -0.14123631f, 0.17453258f, 0.10694354f, -0.15330416f, -0.17278728f, -0.20152172f, 0.23387387f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10850050f, 0.19845313f, 0.14172758f, -0.13591793f, -0.06399630f, 0.23424406f, 0.05259985f, -0.10795110f, 
    0.27461088f, 0.24149659f, 0.29079336f, 0.04048599f, -0.08538511f, -0.05172300f, 0.01222244f, 0.26074791f, 
    0.03517820f, -0.20317942f, -0.11083844f, 0.00064885f, -0.04796299f, -0.10918199f, 0.22576824f, -0.23432098f, 
    -0.06117706f, -0.12226400f, 0.19669388f, 0.03438550f, -0.01496042f, 0.19707452f, 0.34039077f, -0.09263261f, 
    -0.04906315f, 0.07335973f, -0.01588138f, -0.14593406f, -0.01903972f, 0.15589736f, 0.10772621f, 0.06457859f, 
    -0.28466192f, -0.02251075f, 0.02457651f, 0.33229163f, -0.20466948f, 0.33738610f, 0.17271267f, 0.12978026f, 
    0.31742600f, 0.25815469f, 0.09043232f, 0.17264542f, 0.03811165f, -0.11253323f, -0.02046351f, 0.31254777f, 
    0.27413014f, -0.31962892f, 0.07437206f, 0.14475042f, 0.43919495f, 0.08266473f, 0.16299422f, -0.20900431f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.19389924f, 0.09093819f, 0.04688070f, -0.11279987f, 0.10337081f, -0.61796761f, -0.20706464f, 0.23853360f, 
    -0.75351107f, -0.36123085f, -0.38734326f, -0.05467373f, -0.43480533f, -0.42227256f, 0.02283924f, -0.04906382f, 
    0.04428766f, -0.40454367f, 0.02675437f, -0.10064735f, -0.01367459f, 0.25701675f, 0.01390930f, -0.08405811f, 
    0.05253677f, -0.04819969f, -0.01415306f, 0.06608955f, -0.30166373f, 0.08777951f, -0.06524043f, -0.12481918f, 
    -0.10693327f, -0.02752100f, 0.05477159f, 0.19981024f, 0.34924728f, -0.09527496f, 0.29768598f, -0.09890055f, 
    0.16322713f, -0.05295299f, -0.42832729f, -0.36923549f, -0.09436655f, -0.31188422f, 0.15448102f, -0.16036363f, 
    -0.60453373f, 0.07764301f, 0.22097611f, 0.01740564f, 0.14307438f, -0.52656358f, 0.04143056f, -0.30137244f, 
    -0.64166808f, 0.23433678f, -0.68862754f, 0.02869253f, -0.04413889f, -0.10260668f, -0.25908643f, 0.31871495f, 
    -0.04600376f, 0.19345523f, 0.01178206f, -0.17052689f, -0.05890372f, 0.03048016f, -0.11316229f, -0.07916670f, 
    -0.29992476f, 0.01025502f, 0.28588575f, -0.07046926f, -0.22093226f, -0.14743988f, 0.01779443f, 0.01428250f, 
    0.03050081f, 0.02237034f, -0.23125702f, -0.08073438f, 0.10938403f, 0.51388973f, 0.02648066f, 0.07154141f, 
    -0.07038084f, 0.05236262f, -0.16639526f, 0.08889376f, 0.09886675f, 0.14197810f, -0.01938233f, -0.58384281f, 
    -0.05475565f, -0.02610562f, 0.23133150f, 0.00762782f, -0.60379684f, 0.34806389f, 0.39779338f, 0.14576261f, 
    -0.12637496f, 0.02535253f, -0.01326732f, 0.00466281f, -0.08827386f, 0.20662622f, 0.15151839f, 0.08929276f, 
    -0.01327529f, -0.00174544f, 0.19427511f, 0.01834795f, 0.09312680f, -0.45644447f, -0.21867108f, -0.01620514f, 
    -0.11087690f, 0.01218533f, 0.09083850f, -0.73566961f, 0.10834292f, -0.05537934f, 0.00291817f, 0.09859880f, 
    -0.17901282f, 0.06531727f, -0.21995974f, 0.04747190f, 0.10246063f, 0.11194897f, -0.03417617f, -0.32137695f, 
    0.55839545f, -0.09452906f, 0.06965749f, -0.04044360f, 0.28897592f, 0.17634827f, -0.30380344f, -0.13166966f, 
    -0.04473696f, -0.13052131f, -0.37351617f, 0.26958838f, 0.10487074f, -0.13282387f, -0.09859645f, 0.14142931f, 
    -0.08638753f, 0.04997868f, 0.31530365f, 0.02598666f, -0.13996565f, 0.06528717f, -0.42863914f, -0.15904289f, 
    0.01901156f, 0.10561206f, -0.35478735f, 0.00557834f, -0.20632178f, -0.04254406f, -0.02806406f, 0.24649505f, 
    0.02734528f, -0.21840452f, 0.13671309f, 0.07953094f, -0.05005463f, 0.42183420f, -0.41717035f, -0.07251101f, 
    0.24425094f, -0.01606069f, -1.15754759f, 0.01644930f, 0.03577917f, -0.03720995f, 0.03494420f, 0.00044240f, 
    0.25347185f, -0.10035293f, -0.46235469f, 0.23102386f, 0.02871590f, 0.07563316f, 0.13692746f, -0.10660563f, 
    -0.25489730f, 0.04121759f, 0.22152200f, 0.38387635f, 0.08014736f, -0.41825113f, -0.02554423f, 0.22106272f, 
    -0.57179660f, 0.19787699f, -0.12321714f, -0.01448630f, 0.32563642f, 0.11792353f, -0.08299472f, -0.38817629f, 
    0.04895450f, -0.24619383f, -0.04127046f, -0.29498586f, -0.10811459f, -0.50984776f, -0.11065707f, -0.24847288f, 
    0.00994445f, -0.42046058f, 0.25160587f, 0.08941265f, -0.68579495f, 0.00942710f, 0.13943283f, 0.22482029f, 
    -0.00641444f, -0.02759333f, -0.03535607f, 0.07008533f, 0.19052655f, -0.49666581f, -0.14043388f, -0.05460119f, 
    -0.16113475f, -0.57483202f, 0.17918091f, -0.36760518f, 0.07428918f, 0.30504692f, -0.71948284f, -0.71592349f, 
    -0.03526153f, 0.18444830f, -0.18174045f, 0.06258111f, 0.12222287f, -0.35994649f, 0.12977237f, 0.11992995f, 
    0.23889059f, -0.12087722f, -0.19770040f, 0.08652309f, 0.02924809f, 0.00740476f, 0.03380207f, -0.04986595f, 
    0.10837807f, 0.02332910f, 0.13138895f, -0.02116443f, 0.08665576f, -0.22217166f, 0.02611944f, -0.08730030f, 
    -0.39262334f, 0.09161895f, 0.05309305f, 0.05583649f, -0.75558060f, -0.12332229f, 0.29971507f, -0.31690577f, 
    0.08704501f, -0.00101792f, -0.07266565f, 0.00089157f, 0.05360562f, 0.03621661f, 0.09854960f, 0.15859267f, 
    -0.11390431f, -0.09892901f, 0.27505213f, 0.03950046f, 0.11956473f, 0.16342500f, 0.13197128f, -0.31889337f, 
    0.06131476f, -0.07699716f, -0.17717713f, 0.04723616f, 0.27145857f, 0.29654670f, -0.47344807f, -0.31317723f, 
    0.32906836f, -0.08728352f, -0.69393474f, -0.06471246f, 0.04444519f, -0.67864287f, -0.28643957f, -0.21708579f, 
    0.05180570f, 0.13555670f, -0.10212634f, -0.20185867f, 0.00147071f, -0.08700637f, 0.02448574f, -0.19593462f, 
    -0.05372547f, -0.13656281f, 0.06446292f, 0.05632345f, 0.09671792f, -0.01015575f, 0.09029533f, -0.15010558f, 
    0.11220012f, -0.08927996f, -0.02181413f, 0.13297839f, -0.09927270f, 0.05118106f, 0.12356720f, 0.00789996f, 
    0.21551444f, -0.17290954f, -0.32929739f, 0.06064641f, -0.46421963f, 0.00052311f, 0.15660009f, 0.25006664f, 
    -0.02602832f, 0.29373777f, 0.25628954f, -0.10259519f, -0.12247363f, -0.36324051f, 0.10561582f, 0.23489453f, 
    -0.04365994f, 0.01071430f, 0.06917641f, -0.19759589f, -0.25295687f, 0.11792752f, 0.06773037f, 0.27458671f, 
    -0.11123801f, -0.07224044f, -0.05130453f, 0.11377228f, -0.18626074f, 0.09887938f, 0.00105050f, 0.14109482f, 
    0.00417294f, 0.02005501f, -0.17141569f, -0.20282207f, -0.10501097f, -0.28936359f, -0.23848397f, 0.06488135f, 
    0.22463350f, -0.02458326f, 0.25695041f, 0.09951240f, -0.35032925f, 0.57118523f, -0.05583358f, -0.10268806f, 
    -0.26817131f, 0.04665086f, 0.02566280f, -0.59816217f, 0.07374731f, -0.22588678f, 0.12936890f, -0.08645412f, 
    -0.18982784f, 0.01274837f, -0.21736713f, -0.08008099f, 0.07262868f, 0.01584007f, 0.10140930f, -0.40565187f, 
    0.57930273f, 0.02581160f, -0.08877575f, 0.04391313f, 0.27365890f, 0.27145314f, -0.47711596f, -0.71976739f, 
    0.03601136f, 0.31005836f, -0.05582935f, -0.04076701f, -0.10493536f, 0.06851105f, -0.04246163f, 0.04026838f, 
    0.00214446f, 0.13667808f, -0.34617871f, 0.02235245f, 0.21706755f, -0.33559600f, -0.60467660f, 0.16365761f, 
    0.02339726f, -0.10932626f, -0.39265454f, 0.01774718f, -0.27783236f, 0.10915828f, -0.64146829f, 0.17544901f, 
    0.11029508f, 0.02297808f, 0.01284337f, 0.25303179f, 0.09544823f, -0.23740533f, 0.22581433f, -0.16894719f, 
    0.00734719f, -1.20617044f, -0.57862383f, -0.00770716f, 0.11508629f, -0.00393102f, -0.30835059f, -0.02002593f, 
    0.26626804f, 0.17852202f, -0.07935137f, 0.34457889f, -0.63461989f, -0.54083955f, -0.25430924f, 0.11912312f, 
    0.00243804f, -0.45349780f, -0.64507431f, -0.12717776f, -0.01433696f, 0.11659949f, 0.10829456f, 0.28158340f, 
    -0.29940718f, 0.02027113f, -0.17208180f, -0.18037455f, 0.49287757f, -0.14388016f, 0.07844755f, -0.31121397f, 
    -0.05597033f, -0.30624416f, -0.45448950f, -0.05120231f, 0.05609362f, -0.10660925f, -0.25673661f, -0.35207078f, 
    -0.01249273f, 0.14594173f, 0.25062662f, -0.02895545f, -0.01054043f, -0.25116220f, 0.08537802f, -0.04068484f, 
    -0.04404068f, -0.07316833f, 0.25680676f, 0.06669986f, 0.02828361f, -0.03086712f, 0.24441952f, 0.02852728f, 
    0.12642708f, 0.19604555f, 0.02591446f, -0.42976767f, 0.01754176f, 0.19699474f, -0.31677309f, -0.06266347f, 
    -0.44042072f, -0.58446813f, -0.79896742f, 0.12787400f, 0.04931606f, 0.18503453f, 0.08887342f, -0.01001186f, 
    -0.63009280f, 0.18257408f, -0.06900109f, -0.00623139f, -0.54673493f, 0.07778867f, 0.19720823f, 0.11137371f, 
    -0.10271381f, -0.14557344f, -0.41053715f, -0.39505160f, 0.06689440f, 0.34065020f, 0.08356164f, 0.39180955f, 
    -0.02873091f, 0.11630923f, 0.13856241f, -0.13004269f, -0.05235355f, 0.10301606f, -0.06095090f, 0.32055053f, 
    0.05005965f, 0.21320800f, -0.16026066f, -0.11498742f, 0.00689098f, -0.07584362f, 0.01504241f, -0.14492698f, 
    0.04352707f, 0.05500964f, -0.66483545f, -0.07342413f, -0.04681825f, -0.08520309f, 0.10423625f, -0.01673705f, 
    0.07962022f, 0.07445616f, 0.33408305f, -0.54837930f, -0.61703026f, -0.95446807f, 0.21493132f, 0.12582484f, 
    -0.41877481f, -0.14662161f, 0.35896686f, -0.03027434f, -0.01812625f, 0.31058261f, -0.18435612f, 0.15172100f, 
    0.21446778f, -0.37576354f, 0.09055470f, 0.08044568f, -0.40047896f, 0.27742785f, 0.02295646f, 0.23561087f, 
    -0.04649369f, 0.01581026f, 0.08779449f, -0.21271032f, -0.51351887f, 0.22690375f, -0.09296788f, -0.29022652f, 
    -0.17748956f, -0.19232823f, 0.36865070f, -0.54021865f, 0.02304907f, -0.41034195f, 0.03504446f, -0.40084726f, 
    -0.11849984f, 0.15445547f, -0.33252394f, -0.15532809f, -0.14520350f, 0.02953699f, 0.06833696f, -0.30906382f, 
    0.01497357f, -0.01343241f, 0.19682768f, -0.13769832f, 0.00899957f, -0.24088423f, 0.28039911f, -0.25082165f, 
    0.01912881f, -0.01728821f, 0.06563580f, -0.06006634f, -0.04390475f, -0.04739911f, -0.17813492f, 0.28903735f, 
    -0.07336073f, -0.05350972f, -0.21291149f, -0.21819435f, 0.41976255f, 0.59433478f, -0.62601703f, 0.18527907f, 
    0.12462804f, -0.02876551f, 0.22404404f, -0.12022179f, -0.02731489f, 0.00776810f, 0.33364815f, -0.01279062f, 
    0.10308056f, -0.12411857f, -0.30936483f, 0.10424869f, 0.18124563f, -0.04576186f, -0.36387467f, -0.13591258f, 
    0.24452682f, -0.37119094f, -0.02998675f, 0.11237478f, -0.16823433f, -0.67765898f, -0.27927670f, -0.07412157f, 
    -0.30268598f, 0.21713762f, 0.08291060f, 0.01132265f, 0.11891850f, 0.37904128f, -0.16236643f, -0.19886610f, 
    -0.24306673f, -0.14220257f, -0.07958494f, -0.10382418f, -0.17985648f, 0.11091900f, -0.08485892f, 0.41821826f, 
    -0.10542130f, -0.02705716f, 0.21413043f, 0.06330122f, 0.12316814f, 0.32051376f, -0.15831731f, -0.14453973f, 
    -0.00973135f, -0.21051306f, -0.50837409f, -0.02792829f, 0.38653389f, 0.02552108f, 0.32087684f, -0.23077361f, 
    -0.08429457f, 0.08024898f, -0.66821223f, 0.15983845f, -0.84347391f, -0.64285278f, 0.08664937f, -0.30441344f, 
    -0.32155687f, -0.34269735f, -0.13763347f, 0.44407445f, -0.11129712f, -0.28624216f, -0.28700903f, -0.79407370f, 
    0.14695339f, -0.08023573f, -0.12923159f, -0.65481335f, -0.32055327f, 0.21157283f, 0.07955235f, -0.01811888f, 
    0.27583438f, 0.02432820f, -0.08895770f, 0.20213333f, 0.05293105f, -0.30727801f, -0.11191306f, -0.32547399f, 
    0.04900435f, -0.81903744f, 0.15456156f, 0.36271891f, 0.05198013f, 0.04653835f, -0.07940997f, -0.26104397f, 
    -0.16947295f, 0.22122118f, -0.21409827f, -0.17660083f, -0.14238101f, 0.11258982f, -0.11498229f, 0.19069369f, 
    0.07255582f, -0.30934438f, 0.22925864f, -0.21744297f, 0.08918840f, 0.29164565f, -0.38845336f, 0.04726400f, 
    -0.01619492f, -0.25330925f, -0.08980244f, -0.11044946f, 0.18545018f, -0.39588624f, 0.06983213f, 0.08844507f, 
    0.10298182f, -0.14889744f, 0.12133578f, -0.53689182f, -0.14751837f, -0.22575866f, -0.18372262f, -0.01097939f, 
    -0.22015017f, -0.05946633f, -0.15610021f, 0.14494339f, -0.07555549f, 0.08161838f, 0.29899913f, -0.35188809f, 
    0.05701391f, -0.11894552f, -0.37514606f, -0.02292177f, -0.33556470f, 0.00409292f, -0.40159425f, 0.23439486f, 
    -0.17730594f, -0.02904597f, 0.39263430f, 0.27857986f, 0.40531802f, -0.40533081f, 0.10571267f, -0.37540135f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.31189120f, 0.11527446f, -0.08417619f, 0.16254866f, 0.04841815f, -0.08254776f, -0.12613179f, -0.13231665f, 
    -0.04663613f, 0.14841907f, 0.14923608f, -0.08584854f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
