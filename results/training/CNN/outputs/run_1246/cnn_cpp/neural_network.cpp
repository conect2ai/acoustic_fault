#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.14485645f, -0.59552419f, -0.64968961f, -0.98994094f, 0.53841174f, -0.06846222f, -0.28304145f, 0.54837883f, 
    0.47287944f, 0.33354667f, -0.38801375f, -0.49506456f, -0.00381615f, -0.53930134f, -0.16748965f, 0.29891011f, 
    -0.24895988f, -0.16022354f, 0.63664931f, 0.22998220f, -0.22294915f, -0.34840426f, -0.04993344f, -0.20663762f, 
    0.12159685f, 0.32720724f, 0.62357461f, 0.53426611f, 0.34059706f, 0.40664387f, 0.05613065f, -0.04661206f, 
    0.16654274f, 0.04001416f, -0.10420983f, -0.09842057f, 0.05358720f, 0.43769455f, -0.27498442f, -0.24198465f, 
    0.02965701f, -0.20306145f, 0.06852449f, 0.06469225f, 0.08852777f, -0.14426222f, -0.00588507f, -0.09960105f, 
    0.18060032f, 0.13380820f, 0.60008764f, 0.54919600f, 0.00163047f, -0.01673778f, -0.69074178f, 0.23768967f, 
    -0.27530241f, 0.11654104f, 0.04204107f, -0.34437102f, 0.06090431f, -0.33919087f, -0.19807929f, -0.04731810f, 
    -0.29738447f, 0.09792488f, 0.32821494f, 0.16130343f, 0.22055581f, -0.04052520f, -0.11552526f, -0.11790463f, 
    -0.09786963f, -0.16032600f, 0.01649486f, -0.01629781f, -0.86115110f, -0.68297064f, -0.10552606f, -0.03987968f, 
    -0.38347137f, -0.53808153f, -0.47204790f, 0.01944322f, -0.16483366f, -0.22772124f, -0.03501415f, -0.13542977f, 
    -0.03014638f, 0.87871432f, -0.25140288f, 0.00861615f, -0.33331668f, -0.37133899f, -0.53583848f, -0.39076743f, 
    -0.19229250f, -0.21244153f, -0.31051850f, -0.35118923f, 0.81084228f, -1.31029475f, -0.57358766f, -0.26010340f, 
    -0.11165451f, 0.18156844f, 0.00592362f, 0.57838905f, 0.10996980f, -0.28108025f, 0.30779132f, -0.00196880f, 
    0.24938487f, -0.23813041f, 0.19902775f, 0.24461459f, -0.02372793f, -0.14220540f, 0.19127265f, 0.10820994f, 
    0.33285022f, 0.41917217f, -0.20362453f, -0.22422716f, -0.44016516f, -0.75180608f, -0.62507939f, -0.74590904f, 
    -0.61799556f, -0.43588614f, 0.71941203f, 0.41386577f, 0.14995761f, 0.04189768f, 0.58247501f, 0.21205166f, 
    0.31714070f, 0.08485532f, -0.08377943f, 0.15589581f, -0.01648980f, -0.17107540f, -0.35714608f, -0.28053433f, 
    -0.24011366f, -0.04863450f, -0.15307108f, -0.16591294f, -0.25173658f, -0.30867106f, -0.61360669f, 0.33878782f, 
    0.40899789f, 0.18975440f, -0.00741204f, 0.05438174f, 0.13272335f, -0.30327696f, -0.06083026f, 0.48053879f, 
    -0.24399424f, -0.15643361f, -0.47239730f, -0.22366245f, 0.27656233f, -0.15994759f, -0.22817597f, -0.02021100f, 
    0.17023964f, 0.02602115f, -0.55147833f, -0.25492573f, -0.55764759f, -0.52859735f, -0.88577241f, -0.45244732f, 
    0.45850515f, 0.50787526f, -0.56702131f, -1.01485920f, -0.64891875f, -0.17237684f, 0.38495123f, -0.20005231f, 
    0.21786132f, 0.04275092f, 0.19763094f, 0.07778819f, 0.04461061f, -0.01701890f, -0.12707813f, -0.40508088f, 
    -0.12616181f, -0.55037540f, -0.79898787f, 0.13556829f, -0.41863275f, -0.25534052f, -0.05748372f, -0.85764652f, 
    0.72547615f, 0.05330025f, -0.10342526f, -0.33093470f, -0.26663786f, 0.61026824f, 0.57386333f, -0.32874867f, 
    -0.34122983f, 0.40065941f, 0.05945538f, -0.05720353f, -0.11130156f, -0.59596139f, -0.20216548f, -0.29712227f, 
    -0.01979162f, 0.20746170f, -0.18435578f, -0.00249638f, 0.18935402f, -0.37301129f, -0.11091755f, 0.21957599f, 
    0.24136005f, -0.06135835f, -0.05310862f, -0.06255531f, 0.24496211f, 0.40096098f, -0.79938090f, -0.16417339f, 
    0.51849878f, 0.43744889f, 0.34006724f, 0.02058658f, 0.37930298f, -0.37251964f, -0.32794222f, 0.11269370f, 
    -0.22320451f, 0.39007780f, -0.21927220f, -0.36498782f, -0.22527628f, -0.26100323f, 0.33122957f, -0.08113770f, 
    -0.01735380f, -0.07948054f, 0.23632622f, -0.41616309f, 0.19160640f, -0.30741462f, 0.27344480f, -0.21070500f, 
    0.15155667f, -0.37915462f, -0.10834933f, -0.11939988f, 0.05958892f, -0.16692998f, 0.34282592f, -0.28077120f, 
    -0.02060671f, -0.22249566f, 0.02673284f, 0.21845421f, 0.21167196f, -0.25996402f, -0.20402382f, -0.04658594f, 
    0.23425221f, 0.31672317f, 0.38957745f, -0.46933177f, 0.55042559f, 0.88443977f, -0.74366093f, -0.14134096f, 
    -0.72968590f, -0.35157746f, 0.23526977f, 0.40270925f, 0.17341426f, -0.54246670f, -0.25656655f, -0.23854582f, 
    0.18214539f, 0.20682080f, 0.15001510f, 0.30181983f, -0.14207126f, 0.09994353f, -0.14048776f, -0.31070179f, 
    -0.15355191f, -0.20009665f, -0.04537582f, 0.25945103f, 0.56956738f, 0.78206331f, 0.27407706f, -0.17237970f, 
    -0.89408147f, -0.20838828f, -0.13081287f, -0.20941262f, 0.08735223f, -0.50570464f, 0.08320076f, 0.29822761f, 
    0.07993667f, 0.67390501f, -0.19955097f, 0.01988187f, -0.09169778f, -0.01061223f, -0.04262110f, -0.16371103f, 
    0.25102806f, -0.11339629f, -0.02340552f, -0.25832295f, -0.11392279f, -0.46608189f, -0.05398870f, 0.26980355f, 
    -0.36760303f, 0.74925631f, -0.06746002f, -0.14203411f, 0.22479156f, 0.34122568f, -0.06778952f, -0.41910532f, 
    -0.44062984f, 0.49438500f, -0.25635889f, 0.16354777f, 0.05677042f, 0.36386889f, 0.21798356f, -0.27789527f, 
    -0.25046620f, -0.00066719f, -0.33259964f, -0.31128651f, 0.34381375f, -0.00276438f, -0.00157205f, -0.68408060f, 
    0.59092623f, 0.79831928f, 0.45556694f, -0.20561568f, -0.92691439f, -0.86540103f, -0.45312494f, -0.32913753f, 
    0.00979653f, -0.54275090f, -0.22543511f, -0.34802452f, -0.41675681f, -0.50073248f, -0.41103923f, -0.17205761f, 
    -0.24437800f, -0.41021663f, 0.00325639f, -0.18992864f, -0.12107238f, -0.12756862f, 0.08802263f, -1.04138863f, 
    -0.64762855f, -0.41588026f, 0.38031960f, 0.13041833f, 0.36934927f, -0.09782030f, -0.56384397f, -0.08025243f, 
    0.77315831f, 0.61409724f, 0.20573510f, 0.20228854f, 0.35001302f, 0.15730512f, 0.02826538f, -0.06013921f, 
    -0.12332899f, -0.09011931f, -0.17159586f, -0.07777906f, 0.31391352f, -0.08635043f, 0.18969309f, -0.19083612f, 
    0.14031404f, 0.18351839f, -0.20830192f, 0.09837395f, -0.47758085f, 0.23771726f, -0.01142329f, -0.02504452f, 
    -0.24735232f, 0.31148627f, 0.19222632f, -0.21299258f, -0.42090845f, 0.44428572f, 0.58781892f, -0.16303821f, 
    -0.23080644f, -0.59651357f, -0.16151026f, -0.40101221f, 0.29400960f, 0.01467104f, 0.15279648f, 0.31906480f, 
    0.32747301f, -0.11684695f, -0.42764762f, -0.38428715f, -0.29951778f, -0.46432179f, -0.74380529f, -0.64316416f, 
    -0.86697263f, -0.57199901f, -1.09353030f, 0.23009966f, 0.28539330f, -0.01393764f, 0.38062054f, -0.05231985f, 
    0.21836089f, 0.14780140f, 0.26407319f, 0.05074286f, 0.12908845f, -0.25351030f, 0.01211849f, -0.29103813f, 
    0.06889714f, 0.31810370f, -0.09623881f, -0.38473353f, 0.30120561f, 0.65771890f, -0.42323053f, 0.51158798f, 
    -0.48357308f, 0.55101985f, -0.71875125f, 0.46319953f, -0.28746733f, 0.29772544f, -0.30570051f, 0.12485026f, 
    -0.00468808f, -0.45767850f, 0.18639746f, -0.31643832f, -0.17400141f, 0.66123098f, 0.23011298f, -0.13174698f, 
    0.00577669f, 0.19879545f, -0.16794668f, -0.33136326f, 0.48668787f, 0.01475372f, 0.22221829f, 0.34637675f, 
    -0.64790726f, -0.58996385f, -0.07025059f, 0.40398544f, -0.13876817f, -0.12012174f, -0.36512196f, -0.15829442f, 
    0.17848609f, -0.16855443f, -0.00542700f, 0.16036212f, 0.09381142f, -0.03074446f, 0.09188059f, -0.25747102f, 
    0.07845072f, 0.16025805f, 0.34567013f, 0.20423795f, -1.41638112f, -1.15016162f, 0.45651481f, 0.64735800f, 
    0.23727210f, 1.09030592f, 0.51698792f, -0.59230381f, -0.05922830f, 0.41392252f, 0.02553678f, -0.19061205f, 
    -0.15699029f, 0.13506535f, -0.68239719f, 0.06223931f, 0.22379769f, -0.13854347f, -0.03811255f, -0.12140186f, 
    -0.02707910f, -0.16401675f, -0.08945783f, 0.23574068f, 0.08763874f, -0.75994444f, -0.53843665f, -0.42540228f, 
    -0.77989668f, -0.50123644f, -0.71007419f, -0.63748962f, -0.82175142f, -0.69961971f, -0.13647495f, 0.25196925f, 
    0.41456905f, -0.02150213f, -0.29465267f, -0.43240154f, -0.36145690f, -0.21832943f, -0.33485192f, -0.52534503f, 
    -0.06607762f, -0.16829495f, 0.04751144f, 0.13407657f, 0.24974777f, 0.45300129f, 0.92656994f, -0.07050040f, 
    -0.07232076f, 0.06387804f, -0.15880182f, -0.39402428f, 0.28673288f, 0.45125467f, -0.47244743f, -0.15536511f, 
    -0.22861798f, 0.46570083f, 0.18011755f, -0.37536681f, -0.33895764f, -0.30990988f, -0.03761214f, 0.04571120f, 
    0.16878608f, -0.10960840f, 0.20741977f, -0.35759979f, -0.07625879f, 0.29694831f, -0.31244338f, 0.56530279f, 
    0.62687439f, 0.04536445f, 0.28653553f, 0.05285336f, 0.23477285f, 0.23805431f, -0.37595350f, -0.38063315f, 
    -0.37083194f, 0.20784612f, -0.04943575f, 0.09163697f, -0.10668451f, -0.05656624f, -0.25933081f, -0.09929927f, 
    -0.06028052f, 0.25111791f, 0.14785135f, -0.13990676f, 0.03787477f, -0.20448209f, -0.30512634f, -0.48321828f, 
    -1.03246796f, -0.32497528f, -0.54922861f, -0.99017173f, -0.81777656f, 0.39634305f, 0.13220714f, -0.02759934f, 
    -0.00116711f, 0.03748615f, 0.16767666f, -0.02478291f, -0.18710399f, -0.36864468f, -0.03490183f, 0.04031511f, 
    0.11393725f, 0.07966595f, 0.31823033f, -0.06867979f, 0.09417529f, 0.53218222f, 0.25620419f, 0.00748462f, 
    0.13355725f, 1.21484089f, 0.44643369f, 0.19552639f, -0.52862149f, -0.66779900f, 0.31848752f, 0.43190795f, 
    0.17540874f, -0.66462874f, -0.34858721f, -0.43518773f, -0.12336249f, -0.33287874f, -0.11802462f, 0.32976934f, 
    0.33367002f, -0.05116335f, 0.19262080f, -0.25564897f, -0.35158318f, -0.05634345f, 0.10302164f, -0.22237670f, 
    0.08444208f, 0.06518902f, -1.21926749f, -0.70391041f, 0.13884982f, 0.37712640f, 0.48820660f, -0.21349157f, 
    -0.31958112f, 0.60217679f, 0.17074594f, -0.25145689f, 0.04587200f, -0.14073300f, 0.01776411f, 0.39280164f, 
    -0.24391104f, 0.05563293f, -0.12941115f, -0.06837437f, 0.05404956f, 0.33247164f, -0.10426868f, 0.01131755f, 
    -0.17048888f, -0.22843871f, -0.12226989f, -0.46143395f, 0.33314708f, 0.17481327f, 0.28499377f, 0.21228792f, 
    -0.31085691f, -0.26446071f, 0.21591456f, 0.49870005f, 0.39209947f, 0.41457763f, -0.06063316f, 0.30759859f, 
    -0.41141665f, 0.19717669f, 0.28402358f, 0.06590494f, 0.05476379f, -0.07918965f, -0.07037615f, 0.14939255f, 
    0.07732023f, -0.22739193f, 0.15379871f, -0.02480814f, -0.97457910f, -0.66080904f, -0.26681212f, -0.58745509f, 
    -0.95779991f, 0.79223835f, 0.12287378f, -0.36016133f, -0.22555178f, -0.07292874f, -0.58244538f, -0.52405035f, 
    -0.47081813f, -0.17778958f, 0.01548786f, 0.17574620f, -0.04604074f, -0.18166751f, -0.11969063f, -0.26396212f, 
    -0.15851720f, 0.01655129f, 0.07234446f, -0.06350102f, -0.07801422f, 0.02668588f, -0.09006976f, -0.51953816f, 
    -0.34145871f, 0.40512893f, -0.56585032f, 0.28543788f, 0.66216564f, -0.44824144f, 0.15808752f, 0.25672400f, 
    0.15080187f, 0.49877793f, -0.14388114f, -0.24493708f, 0.02562692f, -0.03823800f, 0.07155313f, -0.68275231f, 
    -0.05194519f, 0.09552971f, -0.02078478f, -0.36442256f, 0.17268831f, 0.55234843f, 1.72664976f, -0.80637550f, 
    -1.04229832f, -0.34103790f, -1.11576378f, 0.62941349f, 0.21201926f, 0.52589816f, 0.64609706f, -0.29510292f, 
    0.18638335f, -0.16837880f, 0.06110003f, -0.08904304f, 0.01949261f, 0.09967122f, -0.08106129f, -0.01185711f, 
    -0.06101673f, -0.00752155f, 0.01329358f, -0.13901329f, 0.12974709f, 0.11270422f, 0.05164267f, -0.44832024f, 
    -0.81046706f, 0.17570549f, 0.29415467f, 0.45398158f, 0.27175158f, 0.30654520f, 0.44898516f, 0.09944913f, 
    0.08602656f, -0.02103439f, -0.22628148f, -0.28318128f, 0.43058783f, -0.18382014f, -0.04674646f, -0.00318914f, 
    -0.29043046f, -0.00585604f, -0.32837009f, -0.17041722f, -0.15589438f, 0.18228415f, 0.01043698f, -0.32348642f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18336564f, -0.23887478f, 0.21795824f, 0.19341739f, 0.12796621f, -0.03939642f, 0.08990736f, 0.04868313f, 
    0.19636248f, 0.60671633f, 0.48915133f, 0.36482820f, 0.31716663f, 0.36216292f, 0.01065546f, 0.32897049f, 
    0.22321561f, 0.33032078f, 0.29769668f, 0.35871336f, 0.41717285f, -0.45458972f, 0.37424460f, -0.00797138f, 
    -0.06803127f, 0.43568882f, 0.06037717f, 0.29418701f, -0.35788184f, 0.04400481f, 0.36459371f, 0.39163020f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22402552f, 0.28521901f, 0.08182205f, -0.27323911f, 0.14647354f, 0.30241019f, 0.08864406f, -0.07071463f, 
    0.06925492f, 0.01462519f, 0.11377487f, -0.08959853f, -0.07584931f, -0.09220593f, -0.19915079f, 0.07438233f, 
    0.05958745f, 0.02219381f, 0.07536647f, 0.05432463f, -0.00371010f, 0.04105309f, 0.03313125f, 0.04306369f, 
    -0.28247532f, -0.38360298f, -0.58769006f, -0.06519210f, 0.05282947f, 0.12116477f, -0.15302490f, -0.06370701f, 
    0.04210293f, 0.10722000f, -0.10232591f, 0.07844295f, 0.32130030f, 0.14677995f, 0.00880152f, -0.06933770f, 
    -0.00560259f, -0.11074916f, -0.07506160f, -0.21724233f, -0.07197630f, -0.15433753f, -0.07632494f, 0.04797435f, 
    0.25578061f, -0.00562452f, -0.20438710f, 0.02382628f, 0.02080988f, -0.04755829f, 0.07322539f, 0.04338954f, 
    -0.14536704f, 0.10921621f, -0.08785822f, 0.07943638f, 0.12425992f, 0.00375861f, -0.20808898f, 0.09990899f, 
    0.12210359f, 0.11864742f, 0.08721285f, -0.00634377f, -0.07386781f, 0.07762714f, -0.01051550f, 0.10986000f, 
    -0.37536576f, 0.15394424f, -0.03431581f, -0.11564018f, -0.02278015f, -0.02178999f, 0.07079584f, 0.05608077f, 
    0.09843798f, 0.03720431f, 0.05019218f, 0.18662091f, 0.00274338f, -0.03950937f, 0.14845122f, 0.04386174f, 
    -0.09841122f, -0.08339374f, -0.11340544f, 0.05112904f, -0.06218654f, 0.03994707f, 0.02001011f, 0.18334278f, 
    0.03227528f, -0.13962300f, -0.60125160f, 0.11562437f, -0.01406392f, 0.09803547f, 0.01515793f, -0.01008866f, 
    -0.02879861f, -0.16930297f, -0.17794301f, -0.06882605f, -0.77486181f, 0.08292809f, 0.14614874f, -0.21896029f, 
    -0.04352580f, 0.03040305f, -0.01370824f, -0.00356282f, -0.06787284f, -0.12829179f, -0.06319615f, -0.07811687f, 
    0.11525668f, -0.00391588f, -0.10180608f, -0.08199354f, 0.04990179f, -0.27137303f, -0.17340523f, -0.27798107f, 
    -0.04157041f, -0.01099306f, -0.05462155f, -0.07027238f, -0.61691600f, 0.17463005f, 0.32298312f, -0.20722272f, 
    -0.08189946f, 0.07108350f, -0.22244643f, 0.09580582f, -0.01043598f, -0.00297747f, -0.02223375f, -0.15759307f, 
    0.06517153f, -0.43638167f, -0.12886779f, -0.03725550f, -0.15463549f, -0.07863626f, -0.28272155f, 0.09780312f, 
    -0.01336624f, 0.09263381f, -0.18420009f, -0.15850607f, -0.67119557f, 0.00990190f, 0.08233485f, -0.01402705f, 
    -0.17000987f, 0.08602616f, -0.06646033f, 0.15229115f, 0.03212384f, -0.07037713f, -0.02049382f, -0.05521080f, 
    0.31337881f, 0.20743594f, 0.07252035f, -0.37726572f, -0.20149919f, -0.16539928f, -0.11679798f, -0.13818511f, 
    -0.05078224f, -0.04299767f, 0.00478572f, -0.00626917f, 0.25122398f, 0.30459467f, 0.13835332f, -0.16248557f, 
    -0.02192675f, 0.00500496f, 0.01115399f, 0.01013687f, 0.03331681f, -0.13795099f, -0.13253154f, 0.01459966f, 
    -0.23251331f, -0.26102778f, -0.14472759f, -0.06369394f, 0.08423706f, 0.02782078f, -0.14395282f, -0.19298416f, 
    -0.08979291f, -0.02906562f, -0.05158801f, -0.09931030f, 0.48768702f, 0.23248315f, -0.18444617f, -0.29883894f, 
    0.06610937f, -0.17737332f, 0.03763190f, 0.07506315f, 0.08096646f, 0.01080057f, 0.05484070f, 0.03996697f, 
    -0.19585542f, -0.56970322f, 0.27477658f, -0.45882976f, -0.04805826f, 0.05807870f, 0.06685996f, -0.07746773f, 
    0.04053305f, -0.07952539f, -0.15257233f, -0.19788422f, -0.14362143f, 0.20935099f, 0.20559464f, -0.21190783f, 
    -0.13992743f, -0.10726368f, -0.00402148f, 0.00788505f, 0.00466274f, -0.00092337f, -0.06954522f, -0.02558614f, 
    0.72942102f, -0.07619423f, 0.10135427f, -0.41656908f, -0.10042938f, -0.15892036f, 0.15830150f, 0.03574715f, 
    -0.08705547f, -0.00416105f, -0.13650675f, -0.27886224f, 0.41757914f, 0.28090799f, -0.09216360f, -0.36128256f, 
    0.21812010f, 0.12628624f, 0.12781316f, 0.10588962f, -0.03126470f, -0.06931628f, 0.07005357f, -0.07343091f, 
    -0.55706692f, -0.27433461f, -0.45490238f, -0.01609789f, -0.00647594f, -0.00213082f, -0.00528384f, -0.18054071f, 
    0.05509889f, -0.01294922f, -0.09928030f, 0.01895844f, -0.18448684f, -0.09694744f, -0.22544158f, 0.11615489f, 
    0.02513930f, -0.05824564f, 0.03515509f, -0.00698391f, -0.12997445f, 0.07113512f, 0.05582705f, 0.19191198f, 
    0.33688080f, 0.17707686f, -0.08081179f, -0.11603303f, 0.06734334f, 0.33346823f, -0.15195951f, 0.05605038f, 
    0.05916455f, -0.02455286f, 0.01886444f, 0.03511772f, -0.23829649f, -0.58056438f, -0.12756513f, 0.21395682f, 
    -0.03961275f, 0.04492520f, -0.09973948f, -0.01410265f, -0.08875758f, -0.03220001f, -0.02736316f, 0.00819778f, 
    0.58871943f, 0.06529880f, 0.23331809f, -0.26493993f, -0.02784798f, 0.05060608f, 0.10597745f, -0.08639876f, 
    0.09242996f, -0.28112265f, -0.12100224f, 0.00117739f, 0.00122674f, 0.03595626f, 0.11289422f, 0.01772268f, 
    -0.08363816f, 0.02506649f, -0.03131392f, 0.04044577f, -0.18026522f, -0.30483276f, -0.20371491f, -0.03530610f, 
    0.34701434f, 0.28669298f, 0.00475113f, -0.13539781f, 0.16566943f, 0.31345022f, 0.02627501f, 0.09466173f, 
    -0.09794246f, 0.00486642f, 0.04482082f, 0.03564743f, 0.08735109f, 0.24635842f, -0.11469496f, 0.03916212f, 
    0.07969163f, -0.00203728f, 0.04619863f, -0.19729443f, -0.24923913f, -0.22835672f, -0.04874061f, -0.09697339f, 
    -0.15377404f, -0.62024659f, -0.58887219f, 0.09642890f, 0.09163756f, 0.00682136f, -0.17335208f, -0.02005153f, 
    -0.12182572f, -0.13097841f, -0.15118882f, 0.07258812f, 0.07868646f, -0.58118135f, -0.09298591f, 0.05103143f, 
    0.03292582f, 0.05497174f, 0.00378566f, -0.02700031f, 0.00435214f, -0.04903683f, -0.13622133f, 0.12617847f, 
    -0.21822123f, 0.08412915f, -0.24201901f, 0.15718275f, -0.23234537f, -0.05284638f, 0.03769819f, -0.45834103f, 
    0.02731043f, 0.03617904f, -0.08859280f, -0.15339193f, 0.23187257f, 0.12368499f, 0.19742584f, 0.22100855f, 
    -0.05566958f, -0.03792297f, -0.05385216f, -0.06678859f, -0.04764261f, 0.03336557f, 0.04509216f, 0.03972469f, 
    0.24757491f, -0.04640367f, 0.25675166f, -0.42523888f, -0.08821270f, -0.26010385f, -0.15578543f, -0.06332757f, 
    0.04283874f, -0.14897633f, -0.04489776f, -0.02517930f, -0.03542564f, 0.10574313f, 0.03072052f, -0.19238916f, 
    0.18043774f, 0.13332748f, 0.02148158f, -0.04140039f, -0.03766100f, 0.07219370f, 0.06231201f, -0.07036948f, 
    0.09708225f, -0.03676976f, -0.15353861f, 0.04976905f, -0.15981546f, 0.06071211f, -0.13618806f, -0.18076307f, 
    0.01700927f, -0.11326920f, -0.05636825f, -0.02634522f, -0.02678847f, -0.21407403f, -0.25642100f, -0.17507951f, 
    -0.04621731f, -0.00341106f, -0.03740710f, 0.01548888f, -0.11392884f, -0.07333968f, 0.10288130f, -0.06111630f, 
    0.16337511f, 0.07823770f, -0.00894115f, 0.08980756f, -0.06152640f, -0.01109757f, -0.00904872f, -0.03414120f, 
    -0.40392390f, -0.20778756f, 0.13423957f, -0.30665004f, -0.31595582f, -0.55106425f, 0.23526676f, -0.47274908f, 
    0.08398548f, 0.07832368f, -0.08426912f, 0.13966620f, -0.03074853f, -0.26102388f, -0.06565617f, -0.15664859f, 
    0.67397475f, -0.05427261f, 0.08653937f, 0.05126198f, -0.15134302f, -0.02856586f, -0.05101349f, 0.02216255f, 
    0.09704672f, -0.09295696f, 0.00373091f, 0.20445900f, -0.35453421f, 0.25539881f, 0.21516235f, 0.00510207f, 
    0.04962917f, 0.02288795f, -0.03363922f, 0.04277285f, -0.00702946f, 0.14925668f, -0.19494745f, 0.27712992f, 
    -0.04005731f, 0.06844346f, -0.06806227f, -0.02322447f, -0.07442480f, 0.09542728f, 0.19469897f, 0.15585105f, 
    -0.03299012f, 0.05402929f, 0.04536935f, -0.02890158f, 0.13969956f, -0.03278828f, 0.04707301f, -0.18421789f, 
    0.39560634f, -0.03916473f, 0.00625875f, 0.07233565f, 0.14421020f, 0.09906223f, -0.01880818f, -0.10285178f, 
    0.03891945f, -0.12705147f, -0.05281789f, -0.37341684f, -0.08498891f, -0.10849492f, -0.12989415f, 0.11937197f, 
    0.12350518f, -0.14671256f, 0.11481878f, 0.18078765f, -0.33166939f, -0.00089477f, 0.16218744f, 0.06856754f, 
    0.10636966f, 0.02442090f, 0.08619323f, -0.16971710f, 0.16914436f, 0.28765950f, -0.18121696f, -0.30888766f, 
    -0.62244964f, -0.26510736f, -0.86358070f, -0.42906949f, -0.01168234f, -0.03985674f, -0.04753394f, -0.13964099f, 
    0.00653543f, 0.00014030f, 0.02281362f, -0.01880777f, -0.36594707f, -0.04463185f, -0.28463170f, -0.03496397f, 
    -0.00494324f, -0.01748907f, 0.10003265f, 0.09649295f, -0.21044695f, -0.04780397f, 0.09210461f, 0.00998251f, 
    -0.02831789f, -0.31525746f, 0.12924828f, 0.02179251f, -0.12411898f, 0.05701334f, 0.04221522f, 0.14605537f, 
    0.05757935f, -0.12398300f, 0.23238564f, -0.21205346f, -0.04997067f, -0.05969850f, -0.03013713f, -0.08273547f, 
    -0.09996084f, 0.00243735f, 0.06725610f, -0.11826558f, -0.02237765f, -0.05991737f, 0.02171633f, 0.07765862f, 
    0.11298742f, 0.29332402f, -0.16282873f, -0.29211989f, -0.04352682f, -0.09780622f, 0.00529957f, 0.01485542f, 
    -0.01672406f, 0.03430797f, 0.00995138f, 0.01224008f, -0.10643227f, 0.00300833f, -0.03594113f, -0.10288657f, 
    0.03896846f, -0.04749704f, -0.02587949f, -0.12298532f, -0.08411390f, 0.06931532f, -0.00592623f, 0.02143313f, 
    0.57217544f, -0.20278434f, -0.18192013f, 0.05407031f, -0.10032940f, -0.06591345f, 0.06680114f, 0.05038721f, 
    0.24527535f, -0.16372493f, 0.06941462f, 0.05891476f, 0.13099198f, 0.07774842f, 0.02969741f, 0.33318922f, 
    -0.00098321f, 0.38402334f, -0.08263098f, 0.04711981f, -0.01851271f, 0.04478949f, -0.04830717f, 0.09418671f, 
    0.67058086f, 0.07645565f, 0.11329257f, 0.02477165f, -0.02431610f, -0.09998675f, -0.02458962f, 0.00581868f, 
    -0.12632425f, -0.09221029f, 0.13259411f, 0.22934085f, 0.06899551f, 0.18315573f, 0.07027664f, 0.18419319f, 
    -0.05801365f, -0.09109924f, -0.16237886f, -0.02810523f, -0.08909993f, 0.04331464f, 0.10951615f, 0.03768454f, 
    0.12707995f, 0.29179928f, 0.12479319f, -0.17185648f, 0.01770513f, 0.12582743f, -0.04878374f, 0.05511438f, 
    -0.15418573f, 0.03346817f, -0.09312218f, 0.02027244f, 1.04135764f, -0.13326496f, 0.25488803f, 0.23716310f, 
    -0.03541806f, -0.11608227f, 0.00675892f, -0.11201575f, -0.07868948f, 0.09254839f, -0.12324619f, -0.06823577f, 
    -0.58450240f, -0.13064861f, -0.13532418f, -0.04235413f, 0.02307819f, -0.14056052f, 0.13771769f, -0.04080053f, 
    -0.07646026f, -0.08803909f, 0.00644796f, -0.15113467f, 0.00421215f, 0.07278978f, 0.14854118f, 0.07546321f, 
    0.06597967f, -0.05814996f, -0.05512974f, 0.02361329f, 0.00610783f, -0.00093076f, 0.01255654f, 0.08305445f, 
    0.41329971f, 0.38131818f, 0.42682412f, 0.17194186f, 0.12602252f, 0.04564823f, 0.18820520f, 0.14219074f, 
    0.00991468f, 0.01848383f, 0.01330822f, -0.21041074f, -0.18711413f, -0.19354299f, -0.05144165f, -0.21717307f, 
    -0.09656395f, 0.13836096f, 0.06055755f, -0.14658035f, 0.40444055f, -0.08571318f, 0.03438748f, 0.04347897f, 
    0.96023792f, -0.29441407f, -0.10326525f, -0.03397003f, -0.11410234f, 0.00229596f, 0.04765433f, -0.28662646f, 
    0.20492715f, 0.02985125f, 0.02153043f, -0.04980277f, 0.16871694f, -0.26387143f, 0.15123998f, 0.21435829f, 
    -0.05234330f, 0.02573594f, 0.02749027f, -0.03111249f, -0.18335728f, -0.11820852f, -0.22509332f, -0.09677268f, 
    -0.06105776f, 0.56752694f, -0.06989912f, 0.37075898f, 0.16549920f, -0.13326232f, -0.04386956f, 0.18710534f, 
    -0.02481063f, 0.03972478f, 0.02970266f, -0.06531572f, -0.24451126f, -0.19384755f, -0.11348294f, -0.19701920f, 
    -0.04182495f, -0.02258692f, -0.00110653f, 0.03996925f, -0.05847879f, -0.07444085f, 0.06910176f, -0.14364524f, 
    -0.39804640f, 0.16310951f, 0.22303852f, -0.71956140f, 0.07974657f, -0.02417211f, -0.10859959f, -0.06713229f, 
    -0.02377874f, 0.02748871f, -0.03700164f, 0.03766721f, -0.41610515f, -0.10952727f, 0.19734472f, 0.03598189f, 
    0.03033549f, 0.04868007f, -0.04477655f, -0.09245394f, -0.13225670f, 0.10330712f, -0.07557277f, -0.08038720f, 
    -0.06959003f, 0.10409961f, 0.10149869f, 0.12865728f, 0.05815237f, -0.13758883f, -0.10292356f, 0.11519548f, 
    0.13549361f, 0.10890140f, 0.03859752f, 0.09111299f, 0.17988519f, 0.02322960f, 0.45168030f, 0.29444438f, 
    -0.04113312f, -0.05269975f, 0.06202204f, 0.06332259f, -0.00568695f, 0.00163051f, -0.14590524f, 0.05300336f, 
    0.14086109f, -0.05354351f, 0.04049847f, -0.00062049f, -0.01773006f, -0.02155460f, -0.03014027f, 0.07046010f, 
    0.03470147f, 0.29969063f, -0.08788772f, -0.01236859f, 0.34750894f, 0.04275278f, 0.01204726f, -0.06955054f, 
    -0.05175177f, -0.03590928f, 0.06720413f, -0.10547508f, -0.10029911f, 0.00872112f, 0.09823557f, 0.05303774f, 
    -0.21133754f, -0.05727931f, 0.21429472f, -0.48495492f, 0.04209763f, -0.04967190f, -0.00088515f, 0.06770734f, 
    -0.03591765f, 0.00523890f, 0.08209085f, -0.11943406f, -0.00233743f, -0.29319984f, -0.04981900f, 0.14730144f, 
    0.02419897f, 0.01763041f, 0.04329981f, 0.04266551f, 0.09487711f, 0.06701896f, -0.23669378f, 0.33825094f, 
    -0.03096197f, 0.00409496f, 0.03325493f, -0.00951060f, -0.07110269f, 0.02674840f, -0.16860628f, -0.01983885f, 
    -0.03364109f, -0.05287189f, 0.15611926f, -0.10494290f, 0.17924832f, -0.08425440f, -0.06661819f, -0.03763220f, 
    -0.05554001f, 0.09484419f, -0.02469769f, -0.11547498f, -0.17773631f, -0.01974656f, 0.00633003f, -0.01311476f, 
    -0.22568303f, -0.03371768f, 0.10050012f, -0.16496597f, -0.03561661f, -0.17539850f, -0.31513438f, -0.14577319f, 
    0.11261730f, -0.09391005f, -0.10104436f, 0.11668687f, 0.24163352f, -0.13084117f, -0.23869868f, 0.22248045f, 
    0.02407173f, 0.02173755f, 0.05782417f, 0.11778827f, 0.12302309f, 0.17135400f, 0.11031479f, 0.00241806f, 
    -0.52065986f, 0.77610630f, -0.37600216f, -0.19840997f, -0.06364875f, -0.01122929f, -0.05572441f, 0.06704835f, 
    -0.00731113f, -0.05573555f, 0.00437444f, -0.07348377f, 0.32862812f, -0.12679060f, 0.22213106f, 0.25645244f, 
    0.01690474f, -0.05342579f, -0.00382311f, 0.09647234f, -0.05929545f, -0.21476378f, 0.00503058f, 0.12428139f, 
    -0.35337928f, -0.28627029f, -0.24950853f, 0.19915229f, 0.05826822f, 0.08313443f, -0.03048767f, -0.05811921f, 
    -0.02644302f, 0.02468812f, -0.16018306f, 0.12090775f, -0.64869916f, -0.58582091f, -0.35858020f, -0.43598381f, 
    0.07695831f, -0.03054965f, -0.06179765f, -0.04874879f, 0.03503741f, 0.00127328f, 0.04753936f, 0.02443304f, 
    0.41361356f, 0.32861859f, -0.57170314f, -0.14430204f, 0.01075920f, -0.19904326f, 0.04525707f, 0.08590011f, 
    0.02672410f, 0.08866833f, -0.08491966f, 0.04656879f, -0.04486194f, -0.02588092f, 0.05481247f, 0.03549840f, 
    -0.10817590f, 0.08725420f, 0.06759708f, 0.06191278f, -0.10488604f, 0.01760569f, 0.00295709f, 0.03055480f, 
    -0.03732425f, -0.20032801f, 0.45112300f, 0.29893181f, 0.09378368f, 0.06682630f, -0.11528593f, 0.12281477f, 
    0.09303903f, -0.09003513f, -0.02661677f, -0.04243496f, -0.28498125f, -0.43692145f, -0.51568407f, -0.28157943f, 
    -0.14708599f, 0.17585972f, -0.07166178f, -0.01785923f, -0.05359350f, -0.06270358f, -0.05604061f, 0.00560087f, 
    -0.24669655f, -0.15638086f, 0.02531439f, -0.15877965f, -0.04235882f, -0.06748287f, 0.02785554f, 0.05667985f, 
    0.06125889f, -0.05790080f, 0.00011602f, 0.03345123f, -0.11622546f, 0.00924370f, 0.05367756f, -0.24560152f, 
    -0.02163960f, -0.09603713f, -0.11949465f, 0.07486795f, 0.06790169f, -0.07174225f, 0.03164872f, -0.00614366f, 
    -0.32800651f, 0.25088778f, 0.39909014f, 0.30666956f, -0.09297302f, 0.01347508f, -0.04596221f, 0.16693278f, 
    0.04449889f, -0.04086325f, -0.07264510f, -0.04880166f, -0.35815209f, -0.39976206f, 0.07958870f, -0.54746062f, 
    0.04032946f, -0.00608254f, -0.10454327f, -0.00533185f, 0.06882349f, 0.03208601f, -0.02663126f, -0.01159791f, 
    -0.01479179f, 0.05654360f, -0.33934388f, 0.12867118f, -0.05605730f, 0.09190273f, -0.02716189f, 0.04281801f, 
    0.03284566f, 0.01700554f, 0.09353908f, -0.09648258f, -0.04139369f, -0.08434135f, -0.07154705f, 0.09267882f, 
    0.02002783f, 0.03452177f, 0.01891793f, 0.06779514f, -0.15190083f, -0.04194499f, 0.01101346f, 0.05321646f, 
    -0.50924659f, -0.11873721f, 0.79713356f, 0.47718838f, -0.07979035f, 0.01896194f, -0.01828399f, -0.06889279f, 
    -0.00849626f, 0.00098838f, -0.02284679f, -0.06093441f, 0.19636233f, -0.08241194f, 0.02589256f, 0.05665319f, 
    -0.07236373f, 0.13023488f, -0.03101114f, 0.00795499f, -0.13461363f, 0.12885186f, 0.04217377f, -0.11109675f, 
    -0.79394156f, 0.88042724f, 0.17815118f, 0.01914068f, -0.19646274f, 0.01485679f, 0.03549913f, -0.17667142f, 
    0.03305168f, 0.08908216f, -0.02408730f, 0.18828627f, -0.09061405f, -0.01352222f, 0.15513377f, 0.05526378f, 
    0.01025472f, 0.00480021f, 0.03828468f, 0.05520920f, 0.01990640f, 0.05571443f, 0.14831638f, -0.00967251f, 
    0.54838270f, -0.02714935f, -0.25896347f, -0.01337139f, 0.11588501f, -0.02314508f, 0.03127191f, -0.09434120f, 
    -0.09677577f, -0.10922339f, 0.11349376f, 0.11607387f, -0.13958673f, -0.47363740f, -0.09360866f, -0.14511843f, 
    -0.09072781f, -0.13294721f, -0.24929871f, 0.14621368f, 0.10798717f, -0.01501504f, 0.07914890f, -0.06067595f, 
    -0.12800233f, -0.27699664f, 0.39876601f, 0.04545952f, -0.26455814f, 0.03515432f, -0.04214662f, 0.04427244f, 
    0.19283219f, 0.28619498f, -0.22764182f, -0.00931555f, -0.11267707f, -0.03855959f, -0.24951813f, 0.07694661f, 
    -0.02372065f, -0.07235874f, -0.04668895f, 0.14397317f, 0.06226119f, 0.13789080f, 0.03517425f, 0.03656657f, 
    -0.62165219f, 0.50732416f, 0.05475414f, -0.02007821f, 0.02764817f, 0.25570667f, -0.08675531f, -0.05042032f, 
    -0.20226060f, -0.11522786f, -0.07727530f, 0.03558044f, -0.04318846f, -0.16138631f, -0.01026482f, 0.25118455f, 
    0.22032712f, 0.06666265f, 0.01524260f, -0.19363914f, -0.11361203f, 0.15853205f, -0.05980843f, 0.06809313f, 
    0.29104003f, 0.22482476f, -0.17797308f, 0.03961020f, 0.00897411f, 0.06466002f, 0.04679861f, -0.02677935f, 
    -0.00152553f, -0.13260281f, 0.02583716f, -0.05014635f, 0.22743297f, 0.19092624f, 0.02974234f, 0.13587666f, 
    0.06138920f, -0.17224337f, 0.01513672f, 0.08293412f, -0.00478729f, 0.09636060f, 0.01738664f, 0.06820232f, 
    -0.33977410f, 0.19577613f, -0.44499665f, 0.12034902f, 0.27625886f, -0.07030077f, 0.17892224f, -0.08192519f, 
    0.01126168f, 0.02389869f, 0.06280678f, -0.08475850f, 0.05867538f, -0.34266368f, -0.19122812f, -0.37372020f, 
    -0.18832065f, -0.22830521f, -0.06740766f, 0.11205715f, -0.12936719f, 0.18624762f, -0.18381111f, -0.10497376f, 
    -0.17537770f, 0.17203307f, -0.11834218f, 0.25815302f, -0.00724661f, 0.08709779f, -0.04053338f, -0.31671026f, 
    0.02923307f, -0.05306320f, -0.04667301f, -0.12795202f, 0.90856433f, -0.05239905f, 0.16611679f, -0.31759304f, 
    -0.57965100f, 0.05259904f, -0.06479998f, -0.17137913f, 0.00948137f, -0.12125057f, 0.16674250f, 0.02167044f, 
    -0.10163642f, -0.08789773f, 0.30821687f, 0.14858480f, -0.01803310f, 0.03009400f, -0.01192963f, 0.15776515f, 
    0.07583904f, -0.02271450f, 0.07669378f, -0.08316439f, 0.34357709f, 0.04804462f, -0.38141796f, -0.38158056f, 
    0.01295015f, -0.07756051f, -0.11440279f, -0.11503477f, -0.30804786f, 0.12706290f, -0.22091676f, 0.01839309f, 
    -0.37210363f, 0.19978726f, 0.05873077f, 0.40049797f, -0.02757807f, -0.10897900f, 0.09723826f, -0.09834998f, 
    -0.05480875f, -0.01616023f, -0.03032729f, 0.11396809f, -0.08273706f, -0.25682762f, -0.09615009f, -0.25231406f, 
    0.22828397f, 0.14614590f, 0.03194983f, -0.02021359f, -0.03576424f, 0.05620368f, 0.05356116f, -0.03494962f, 
    -0.05357822f, -0.03180493f, 0.08872200f, 0.35889590f, 0.00553990f, -0.22560567f, 0.22596112f, 0.13998416f, 
    0.10227370f, 0.06487367f, 0.04380863f, 0.13534698f, -0.03731754f, -0.37720379f, -0.01555109f, 0.29661742f, 
    0.07589993f, 0.11167159f, 0.06157491f, -0.04394770f, -0.04569575f, -0.02012935f, -0.05618197f, -0.12076562f, 
    -0.44059759f, 0.44771463f, -0.13415478f, -0.49724707f, 0.09463637f, -0.34145859f, -0.14309525f, -0.25723282f, 
    -0.27872056f, -0.04719083f, -0.21966371f, 0.00496862f, 0.35323182f, -0.17971337f, 0.21934158f, -0.08500223f, 
    -0.29355568f, -0.06981394f, -0.21049200f, -0.11471898f, -0.02526838f, 0.00740878f, 0.12398931f, -0.16208529f, 
    -0.87127638f, 0.88991797f, -0.28081521f, -0.66072768f, 0.35774451f, 0.24609210f, -0.03925785f, -0.00373933f, 
    -0.49500644f, 0.06382257f, -0.01692966f, -0.04042803f, 0.03743687f, -0.13205013f, -0.10577310f, 0.16423249f, 
    0.10594506f, 0.07003420f, -0.01901550f, -0.07199154f, -0.09781185f, 0.13913667f, -0.19246368f, -0.02204138f, 
    -0.37693945f, 0.37647295f, 0.06711353f, 0.14821233f, -0.03409828f, -0.14244115f, 0.28261968f, -0.05402130f, 
    0.08720489f, 0.01943591f, -0.04991572f, 0.14967334f, -0.54041821f, -0.00966382f, 0.18298848f, 0.31040069f, 
    -0.07484980f, 0.04514723f, -0.25441042f, 0.11325013f, 0.29607406f, 0.03509928f, -0.02634994f, 0.08798943f, 
    0.35056272f, -0.26422733f, 0.09570091f, 0.27174771f, 0.04020010f, -0.04986203f, -0.02129247f, -0.18528889f, 
    0.06186969f, 0.03012172f, 0.08479397f, 0.20990464f, -0.50412023f, -0.17806675f, 0.11268061f, 0.36763147f, 
    0.03879752f, -0.06582516f, -0.01518227f, 0.02781421f, -0.18593222f, 0.04324437f, -0.07109501f, -0.10304228f, 
    -0.01568157f, 0.43001324f, -0.27099285f, -0.51787955f, 0.15854263f, 0.11181217f, -0.04825919f, 0.19149370f, 
    -0.12494820f, 0.05108023f, -0.04095349f, -0.18408206f, 0.23404954f, -0.50421053f, 0.30314252f, -0.16996825f, 
    -0.33959758f, -0.02816414f, 0.09158836f, -0.01160864f, 0.08602171f, 0.17044653f, -0.19347809f, -0.29224682f, 
    0.12355606f, -0.11105380f, 0.13107581f, 0.27543390f, -0.05900028f, -0.10460641f, -0.04992570f, 0.04799205f, 
    -0.04243124f, 0.06567757f, -0.02473487f, 0.05878578f, 0.00449566f, 0.06359997f, -0.28782281f, 0.08890194f, 
    0.02876098f, -0.16657618f, 0.22200704f, -0.02598585f, 0.15857676f, 0.16527995f, -0.03504735f, -0.09359048f, 
    -0.74937397f, 0.09810935f, 0.20307501f, 0.37279770f, 0.05777167f, 0.06041016f, 0.12891962f, -0.19974796f, 
    -0.07783339f, -0.00810620f, 0.08615144f, 0.12903687f, -0.25755787f, 0.40838751f, -0.10303064f, -0.55487424f, 
    0.12714326f, 0.33971375f, 0.01857331f, 0.00283314f, -0.27083138f, -0.19902650f, 0.06418448f, -0.06705989f, 
    -0.50962061f, -0.16821252f, -0.01375722f, 0.21713088f, -0.22828560f, 0.03824525f, -0.10807505f, 0.18354359f, 
    -0.07865866f, 0.02888277f, -0.12711480f, -0.25773725f, 0.03375757f, 0.01887503f, 0.06292631f, 0.08761051f, 
    0.04960709f, 0.01524833f, 0.07711052f, 0.09985776f, 0.09709609f, 0.01639861f, 0.00765703f, -0.03221416f, 
    0.10939631f, 0.28133067f, -0.29694226f, 0.36878452f, 0.14652213f, 0.05979669f, -0.08442079f, 0.04346493f, 
    0.09694243f, -0.08275703f, 0.02721617f, -0.02173898f, 0.15161207f, 0.10474312f, 0.18833247f, 0.01832816f, 
    -0.07886413f, 0.02953561f, -0.02120151f, -0.08330142f, 0.04508720f, -0.14296469f, 0.07947376f, 0.24668460f, 
    0.00503264f, -0.09571299f, 0.24922056f, -0.01817918f, -0.07405987f, -0.09971238f, -0.06020149f, -0.03348644f, 
    0.23726499f, -0.13144030f, -0.13930295f, 0.12517110f, 0.29914337f, 0.17391817f, 0.11613365f, 0.12878610f, 
    -0.02002651f, -0.08093303f, 0.04991654f, 0.08846182f, 0.23174812f, -0.26597986f, -0.00815404f, 0.13449872f, 
    0.08015583f, -0.15937272f, -0.18916234f, 0.04442347f, 0.05036991f, -0.07517625f, 0.01761423f, -0.08419803f, 
    0.10000674f, 0.21479380f, 0.02426458f, 0.40791562f, 0.07257125f, 0.15065071f, 0.01135504f, 0.27384010f, 
    -0.08038502f, -0.19698560f, 0.00215990f, -0.10043917f, 0.10242225f, -0.00084020f, 0.14562617f, 0.22612396f, 
    -0.01410871f, -0.34923220f, -0.22423916f, 0.05618553f, 0.06273950f, 0.06940561f, -0.01241575f, 0.03477752f, 
    -0.27711239f, 0.04438433f, 0.01425117f, -0.09123695f, -0.14628820f, -0.42224333f, -0.33474752f, -0.15812308f, 
    -0.05573219f, -0.07252543f, 0.08603180f, 0.04677692f, -0.08889898f, -0.26050702f, 0.11376030f, -0.14571312f, 
    -0.07176598f, 0.05804463f, 0.11053118f, 0.04838140f, -0.04953123f, 0.17896265f, -0.19771273f, 0.12722576f, 
    -0.07312657f, -0.04104989f, -0.13452944f, -0.13983528f, -0.24620122f, -0.13342953f, -0.55063033f, 0.26752177f, 
    -0.05743489f, -0.06151891f, -0.09801379f, -0.45037523f, -0.02574627f, -0.17743887f, -0.01746195f, -0.03996501f, 
    -0.01979545f, 0.12662965f, -0.05038118f, 0.36411658f, 0.23328105f, 0.17399290f, -0.17007156f, -0.10401903f, 
    0.05486909f, 0.15142870f, -0.10319103f, -0.19476466f, -0.24324064f, -0.20334038f, -0.00453028f, -0.15685646f, 
    -0.04037007f, 0.02097013f, 0.01971036f, -0.13129197f, -0.11098800f, -0.07465959f, 0.00070848f, -0.08782383f, 
    0.19297494f, 0.02133917f, 0.35671213f, 0.27692553f, 0.23994672f, 0.10898191f, -0.05831543f, 0.10141717f, 
    -0.01207451f, -0.00427190f, -0.02843642f, 0.04793423f, 0.07720200f, 0.31495753f, -0.09223637f, 0.08620501f, 
    0.01448162f, -0.05897685f, -0.01888257f, -0.04097738f, 0.16173466f, 0.02333944f, -0.20388936f, 0.00014762f, 
    0.05419436f, 0.00381990f, -0.06290030f, 0.17657639f, -0.14064685f, -0.02261141f, -0.02088305f, 0.02809055f, 
    -0.07610732f, -0.14325286f, -0.38005078f, -0.27828097f, 0.16946724f, 0.40114805f, 0.32312310f, 0.25694755f, 
    -0.08325408f, -0.01484760f, -0.02704260f, 0.14103673f, 0.04887950f, -0.01422049f, -0.01302566f, -0.04887429f, 
    0.02715458f, -0.32385772f, 0.17383352f, -0.09078250f, -0.04153043f, 0.28117681f, -0.13836622f, -0.06870458f, 
    -0.16663003f, 0.01718199f, -0.08133166f, 0.05438865f, -0.03528638f, -0.16460584f, -0.06322955f, 0.17213242f, 
    -0.06107098f, -0.04317761f, 0.05870936f, 0.15464264f, -0.05540312f, -0.08036064f, -0.03997612f, -0.10660401f, 
    0.25992924f, -0.58920962f, -0.06759367f, 0.06353895f, -0.06369478f, 0.16431265f, 0.11124012f, -0.12431369f, 
    -0.25511134f, 0.12029374f, -0.06387500f, -0.09959222f, 0.05810991f, 0.26117724f, 0.19565648f, 0.19821563f, 
    -0.04948349f, -0.17849772f, -0.04696178f, -0.05864624f, 0.07362700f, -0.00495172f, 0.09552023f, -0.03595313f, 
    -0.03173434f, -0.15836746f, -0.42122832f, -0.54504794f, 0.15215750f, -0.16916499f, 0.00601051f, -0.01833563f, 
    0.06224925f, 0.04343047f, -0.12796253f, -0.29759923f, 0.10766511f, -0.06864312f, -0.00426550f, 0.11632765f, 
    0.13889594f, 0.01584715f, 0.15935767f, -0.04487437f, 0.03252637f, 0.04916315f, 0.15178175f, 0.10641679f, 
    0.07589623f, 0.02673703f, 0.03825071f, 0.18699598f, -0.11991895f, -0.11214983f, -0.05774381f, -0.18370016f, 
    0.11129736f, 0.04512723f, 0.04720528f, 0.05162162f, -0.15957211f, 0.39080039f, -0.85020512f, -0.04512311f, 
    0.07739545f, 0.12140149f, 0.02635084f, 0.00924475f, 0.05557536f, 0.02396749f, 0.03432495f, -0.04109040f, 
    -0.16556019f, -0.41732985f, 0.09969375f, 0.02511427f, -0.39077643f, -0.08030937f, -0.09127312f, 0.03851731f, 
    -0.14925334f, 0.02250183f, -0.00261060f, 0.29467902f, 0.02403123f, 0.04162527f, -0.06782867f, -0.02358156f, 
    0.08321497f, 0.02346277f, 0.02056844f, -0.02502779f, -0.03662078f, 0.01654920f, -0.00526025f, 0.03797273f, 
    -0.27677777f, -0.20807002f, -0.26618138f, 0.11896387f, -0.01406043f, -0.10622062f, 0.00320807f, -0.11932760f, 
    -0.03072312f, -0.00267089f, 0.05325065f, 0.05617746f, 0.24361186f, 0.15473695f, 0.20907275f, -0.00325452f, 
    0.05706094f, 0.05231874f, -0.19601136f, -0.04519273f, -0.20422919f, -0.31902239f, -0.17543218f, -0.22449821f, 
    -0.17387474f, -0.27033955f, 0.23950066f, -0.05926177f, -0.04972215f, -0.09193853f, -0.10581432f, -0.03522149f, 
    -0.07893851f, -0.04629990f, -0.05438028f, 0.19073614f, -0.14672001f, -0.27618918f, -0.01448260f, -0.22986272f, 
    -0.07209813f, -0.09961883f, 0.09918916f, 0.03470083f, -0.03141770f, 0.03309475f, -0.00309864f, 0.07305923f, 
    -0.17937024f, 0.00702864f, 0.33147380f, -0.19489445f, 0.12132504f, -0.04675030f, -0.03844306f, 0.00743586f, 
    -0.04966446f, -0.04505646f, -0.10159326f, 0.23887773f, -0.24118610f, -0.09643945f, -0.13563551f, 0.01818959f, 
    0.00130263f, -0.02926879f, -0.12290760f, -0.03382680f, -0.03243599f, -0.09786457f, -0.03230201f, 0.01100892f, 
    0.36242154f, 0.05547036f, -0.55118239f, -0.15264404f, 0.12180246f, 0.12928827f, -0.03683303f, 0.06808177f, 
    -0.15815507f, -0.06511919f, 0.01187573f, -0.03879858f, 0.14341341f, -0.06929220f, 0.15664175f, 0.18200430f, 
    -0.09557624f, -0.10275409f, -0.00155152f, -0.05752741f, 0.11068416f, -0.08005450f, -0.15226918f, -0.07787102f, 
    0.33863753f, -0.21151374f, -0.28447783f, -0.25757545f, 0.25786644f, 0.07526588f, 0.10388974f, -0.00535434f, 
    -0.14079626f, 0.16303639f, 0.23812646f, -0.03812752f, -0.41174385f, -0.21777444f, -0.46730459f, -0.36237368f, 
    -0.01407401f, 0.02787595f, -0.06078748f, 0.05077907f, 0.14344494f, 0.01930310f, -0.06313333f, -0.06190727f, 
    -0.39432403f, -0.12892559f, 0.16425958f, -0.03206456f, 0.04336177f, -0.00516484f, -0.02946802f, 0.14243415f, 
    -0.21584676f, -0.18745480f, -0.46961549f, -0.44614124f, -0.16351178f, 0.14157613f, -0.14938401f, 0.17159393f, 
    0.12491153f, 0.05599334f, -0.00981951f, -0.08533828f, -0.05298984f, -0.16490810f, -0.08544443f, -0.55550474f, 
    -0.33638409f, 0.13865775f, -0.31711683f, -0.25923350f, -0.02554855f, -0.08728547f, -0.04973845f, -0.01272055f, 
    0.25051215f, 0.02091386f, -0.08554989f, -0.00576035f, 0.33129352f, -0.24020042f, 0.06010352f, 0.34761211f, 
    0.15074502f, -0.03430306f, 0.04443895f, 0.09501668f, 0.06187479f, -0.08006811f, 0.36838108f, 0.02268112f, 
    0.16943172f, -0.09218769f, 0.06100302f, -0.10634684f, 0.13952537f, 0.08197544f, 0.04019212f, -0.21083806f, 
    0.06460430f, 0.09795515f, 0.00332910f, 0.10562694f, -0.50995684f, -0.11431589f, 0.06237198f, 0.36270007f, 
    0.09526752f, -0.10640693f, -0.18092209f, 0.12067621f, -0.06443759f, -0.02222645f, -0.12957342f, 0.12394375f, 
    0.07573898f, 0.03976586f, -0.49267292f, 0.37710339f, 0.03332827f, 0.26766309f, 0.20443951f, -0.10027682f, 
    -0.31807196f, 0.12092271f, 0.06152721f, -0.13477762f, 0.15913339f, -0.22158673f, 0.37691820f, 0.05692035f, 
    -0.12870941f, 0.02324017f, -0.25693747f, 0.17984991f, -0.01500962f, -0.43932807f, 0.24319242f, 0.22875039f, 
    0.35989442f, 0.12889351f, 0.40778112f, -0.24254940f, 0.04400785f, 0.09229873f, 0.13252282f, 0.07757931f, 
    0.07315089f, -0.04829080f, -0.02698785f, 0.08400705f, -0.00268753f, -0.24746118f, 0.24439262f, -0.15008676f, 
    -0.00971203f, 0.01801558f, -0.02552952f, 0.04548476f, 0.16712561f, 0.04776984f, -0.04991690f, -0.17020366f, 
    0.07231882f, 0.08677121f, -0.01969025f, -0.22065669f, -0.04795755f, -0.06374723f, -0.21787000f, -0.00685530f, 
    0.07088065f, 0.32572508f, -0.10251654f, 0.09633043f, 0.18210094f, 0.27540708f, 0.18167964f, -0.07585815f, 
    0.15425323f, 0.14344162f, -0.04611685f, -0.10526799f, -0.05025189f, -0.01357931f, 0.07990001f, 0.12330326f, 
    -0.23901148f, -0.33804658f, -0.25867745f, 0.86096585f, 0.00389178f, -0.06419729f, -0.00926322f, 0.12122203f, 
    0.05753890f, 0.06128496f, 0.13712861f, -0.06470101f, -0.01992938f, -0.05474351f, 0.19589734f, 0.08126342f, 
    0.15639521f, 0.09965171f, -0.02929184f, -0.02752016f, 0.11881892f, 0.07385465f, 0.08469484f, 0.00164386f, 
    -0.82077849f, -0.18783334f, 0.30063942f, 0.12756066f, -0.03823374f, -0.10850198f, -0.09767538f, 0.01100846f, 
    0.21487401f, -0.15401310f, -0.12621921f, 0.20756209f, -0.00960919f, 0.00708147f, 0.17923558f, -0.04111364f, 
    0.06534558f, 0.05322522f, 0.05566834f, -0.01349815f, 0.09741584f, 0.02157125f, 0.00486996f, -0.01131889f, 
    0.10143121f, -0.28017589f, -0.22535172f, 0.16942026f, 0.13234209f, 0.26309529f, -0.13788316f, 0.12504840f, 
    0.11698899f, 0.12624356f, 0.05755426f, -0.11118597f, -0.02357786f, -0.11460356f, -0.18430993f, -0.17201057f, 
    0.11007113f, 0.02703727f, 0.01686792f, -0.01122829f, 0.12078011f, -0.09452804f, -0.17762078f, -0.28307101f, 
    -0.33787522f, 0.01939278f, -0.13877259f, -0.15470691f, 0.03925007f, -0.00956490f, 0.21771929f, 0.11881188f, 
    0.07945474f, -0.02881690f, 0.03314287f, -0.03793921f, -0.32763937f, 0.17249969f, -0.41215602f, -0.33059144f, 
    0.01273479f, 0.08598109f, 0.02245747f, 0.13483861f, 0.16109563f, -0.21845824f, 0.10159902f, 0.04344882f, 
    0.19326872f, -0.13566254f, -0.05102842f, 0.05462050f, 0.20348467f, -0.15520246f, 0.06995369f, -0.05963136f, 
    0.16886999f, 0.11351107f, -0.07476776f, -0.08860220f, -0.17947006f, -0.08728602f, -0.09519511f, 0.13756274f, 
    -0.01336795f, -0.11515691f, -0.07204664f, 0.06228723f, 0.04545255f, -0.06191578f, 0.19461232f, 0.07679951f, 
    -0.08178793f, 0.12219762f, -0.07079566f, -0.37006253f, 0.09570110f, -0.04364848f, -0.02710721f, -0.04746883f, 
    -0.04762622f, 0.00245788f, -0.08706471f, 0.10654148f, -0.04192127f, -0.07156436f, -0.01200289f, 0.20931022f, 
    0.06788278f, -0.15058455f, -0.00637045f, 0.20737863f, -0.20743567f, 0.20276485f, -0.14093752f, 0.35653737f, 
    0.11468879f, -0.17086579f, -0.51389962f, -0.39915794f, -0.00569971f, 0.07749200f, -0.22321153f, 0.20750666f, 
    0.08421931f, -0.00932414f, 0.02874162f, -0.18448853f, 0.06130611f, 0.09043184f, -0.12632591f, -0.04222595f, 
    0.03731677f, -0.11517723f, -0.06092234f, -0.02734795f, 0.09263989f, 0.00802551f, -0.06353348f, -0.19333553f, 
    -0.08382974f, -0.35235825f, 0.18955334f, 0.60370165f, -0.24098611f, -0.09799246f, 0.11828726f, 0.47556829f, 
    0.00363468f, 0.08290028f, -0.02320915f, -0.06299809f, -0.13236770f, -0.15068646f, -0.16665795f, -0.12886871f, 
    -0.00122241f, 0.02396324f, 0.02339535f, -0.05662848f, -0.11646866f, -0.01990230f, -0.17617737f, 0.04225584f, 
    0.10506285f, -0.13529450f, 0.19816943f, -0.55035645f, 0.06607402f, -0.08322739f, 0.13921267f, -0.12865563f, 
    0.11450718f, 0.15624599f, 0.06788812f, 0.10337476f, -0.56621969f, -0.29605490f, -0.70869976f, -0.23896757f, 
    -0.20879750f, -0.01633557f, 0.03256378f, 0.02457854f, 0.01508809f, -0.04330603f, 0.19458699f, -0.00649454f, 
    -0.08108777f, 0.52800477f, 0.11532465f, -0.14492629f, -0.11732025f, 0.12821758f, -0.19502936f, 0.00931471f, 
    0.07173324f, -0.01807659f, 0.04346707f, -0.06446287f, -0.23923290f, 0.44124982f, 0.44129014f, 0.10322484f, 
    0.00515488f, 0.02359532f, 0.02934553f, 0.06870468f, -0.01017146f, 0.06320485f, 0.20534579f, 0.01252132f, 
    -0.03591608f, -0.02468337f, -0.12821551f, 0.04722820f, -0.00394204f, 0.09253306f, 0.13508722f, 0.09256919f, 
    0.26270938f, 0.02153224f, 0.29509610f, 0.13213459f, 0.49256134f, -0.07905543f, -0.03340169f, -0.30819836f, 
    -0.05992117f, -0.01306084f, -0.01590981f, 0.03747520f, 0.09210987f, 0.17844455f, 0.19618054f, 0.03796675f, 
    -0.16684510f, -0.16751139f, 0.09591610f, 0.08619654f, 0.20171642f, -0.13442694f, 0.00825458f, -0.00455543f, 
    -0.05853062f, 0.12228463f, -0.10092167f, 0.04756014f, 0.22121042f, 0.19045930f, -0.30157223f, -0.06208285f, 
    -0.01899522f, -0.06558001f, 0.02943059f, 0.14029941f, 0.01550359f, 0.06615661f, 0.00458007f, -0.04622531f, 
    -0.14881857f, -0.15013872f, -0.17010359f, 0.05455574f, -0.00981075f, -0.18852229f, 0.06711244f, 0.22749159f, 
    -0.07246546f, -0.08733556f, -0.16018859f, -0.03069249f, 0.12303380f, -0.08851560f, -0.43428281f, -0.02325748f, 
    -0.28920144f, 0.15618244f, 0.20620129f, 0.33786786f, -0.00238307f, -0.05371026f, 0.03260791f, 0.04071823f, 
    0.39283448f, 0.03564258f, 0.03140729f, -0.37729371f, 0.11442919f, -0.04925813f, 0.13797702f, 0.03669968f, 
    0.00563129f, 0.03872291f, -0.06042079f, -0.06687748f, 0.19672050f, 0.08848359f, -0.15218076f, -0.24298370f, 
    -0.08617239f, -0.10831515f, 0.04785004f, 0.28512961f, -0.01381902f, 0.04240323f, -0.00033817f, 0.22239412f, 
    -0.65668452f, -1.10266340f, -0.64272887f, 0.06963340f, 0.17750622f, 0.20252322f, -0.07956213f, -0.00564769f, 
    0.01202423f, 0.05238104f, 0.04143196f, 0.06087147f, -0.55976862f, 0.07166883f, 0.33965787f, -0.05704780f, 
    -0.09748151f, -0.00163803f, -0.04402281f, 0.07503794f, 0.02260530f, 0.06959478f, 0.19986573f, -0.00823454f, 
    0.35836664f, 0.10248054f, -0.06552952f, -0.13476931f, 0.10402028f, -0.11880561f, -0.01829418f, 0.01407976f, 
    0.06097827f, -0.04312925f, 0.23920487f, 0.01422936f, -0.94785267f, -0.90642756f, -0.75149095f, 0.09263609f, 
    -0.15747459f, -0.04866527f, -0.09576928f, -0.44067374f, 0.06396353f, -0.05713348f, 0.00934515f, -0.01953633f, 
    -0.33121383f, -0.05454320f, 0.01918009f, 0.65153068f, 0.06608432f, 0.12924147f, -0.09490999f, -0.21876183f, 
    0.01880518f, -0.12495361f, 0.06137898f, 0.14171381f, -0.27156785f, -0.08528279f, -0.36944142f, -0.21208502f, 
    -0.19235711f, 0.07889260f, 0.04607834f, 0.17689686f, 0.00428658f, -0.01619710f, 0.02390311f, 0.03283029f, 
    -0.15418792f, -0.26364371f, 0.31535879f, 0.01733228f, -0.03953202f, -0.11606452f, -0.05467598f, -0.02199577f, 
    -0.10599911f, 0.14725704f, 0.02365947f, -0.02300247f, -1.09659684f, -1.00485110f, -0.18939272f, -0.53482747f, 
    -0.20916688f, -0.36329880f, -0.18352194f, -0.32790735f, -0.07697055f, -0.09877941f, -0.05585978f, -0.09520762f, 
    0.02400729f, 0.07528986f, -0.02076676f, -0.27361780f, 0.00594378f, 0.04276699f, 0.05415947f, -0.14993612f, 
    -0.07116167f, 0.10123086f, -0.09074049f, 0.03326281f, 0.00618895f, -0.15170836f, -0.03370962f, 0.09840149f, 
    0.03577175f, 0.02360247f, 0.14624229f, -0.06330396f, -0.09596984f, -0.13175905f, 0.00244445f, 0.03625146f, 
    -0.83300596f, -0.50845003f, 0.22101814f, -0.01318681f, -0.18078165f, -0.08886634f, -0.15400440f, -0.28078255f, 
    -0.00701919f, -0.05806186f, -0.05214764f, -0.07192984f, 0.33812481f, -0.19931731f, 0.20735204f, -0.47930601f, 
    -0.02674271f, -0.00905250f, 0.11195014f, -0.11002337f, 0.02271279f, -0.03113605f, 0.07608678f, 0.04338523f, 
    -0.24745052f, -0.13511221f, 0.03845153f, -0.08805457f, -0.23265891f, 0.09775526f, 0.04253411f, -0.13016067f, 
    -0.03491780f, 0.09957778f, 0.15955788f, 0.00927977f, 0.06397016f, -0.08882710f, -0.01685512f, 0.07943907f, 
    -0.06201908f, -0.01408151f, 0.03441299f, 0.02130790f, -0.12388258f, -0.03453458f, -0.25591737f, -0.34547716f, 
    -0.59865004f, -1.01519942f, -0.39278904f, -0.31234002f, 0.06954732f, -0.33579519f, 0.01128010f, -0.33050233f, 
    -0.05038584f, -0.02115181f, 0.05243720f, -0.03036836f, -0.02169740f, 0.31316167f, 0.03383907f, -0.15792042f, 
    -0.09774466f, -0.28081670f, -0.03116581f, 0.19112672f, 0.00469901f, 0.02330100f, -0.04249654f, -0.14917715f, 
    0.18495800f, 0.75285894f, -0.28940919f, 0.31079194f, 0.01918772f, 0.04055982f, -0.03948591f, 0.06947895f, 
    0.20895651f, 0.00886361f, 0.10123943f, 0.00357923f, -0.01482895f, 0.08393854f, 0.22111113f, -0.10284651f, 
    0.02416207f, -0.00023751f, -0.06084687f, 0.19627339f, 0.00311311f, 0.08674832f, 0.21804237f, 0.14385474f, 
    0.33256406f, -0.45324939f, -0.67269260f, -0.34883702f, 0.03959735f, 0.13791266f, 0.01308707f, 0.23618358f, 
    0.07482215f, -0.02563130f, -0.07973728f, 0.09688374f, 0.01924182f, 0.12910309f, -0.13580440f, -0.03346976f, 
    0.07764692f, -0.00338136f, 0.03606730f, -0.04011428f, 0.07314478f, 0.08232524f, 0.04660381f, -0.03054991f, 
    -0.11504555f, 0.30024081f, 0.06568804f, 0.09528230f, 0.04750682f, 0.01908960f, 0.17019115f, 0.06136611f, 
    -0.09574170f, 0.06037553f, 0.14417729f, 0.16844127f, -0.40514427f, -0.58627486f, 0.10795566f, 0.02592242f, 
    0.00421362f, 0.04308593f, 0.08695998f, -0.01033259f, -0.01174307f, 0.10727912f, -0.00893626f, -0.16443889f, 
    -0.07353302f, -0.05445298f, -0.02232420f, -0.02380573f, 0.03318427f, -0.22398081f, 0.12742205f, -0.16383523f, 
    -0.10613042f, -0.08233223f, 0.11826769f, 0.08496271f, 0.46839294f, -0.71553296f, -0.14296503f, -0.23919293f, 
    -0.03463241f, -0.08714131f, -0.01967564f, -0.03409151f, 0.18449396f, 0.07792801f, 0.01867577f, -0.02270995f, 
    0.19017550f, -0.17226979f, 0.06410511f, -0.07983805f, -0.01746313f, -0.02142942f, -0.03505801f, -0.03491465f, 
    -0.07590206f, -0.10482103f, -0.08196538f, 0.11336440f, -0.19785103f, -0.19244528f, -0.62293977f, 0.53324032f, 
    -0.06649354f, 0.03046607f, -0.05636933f, 0.02124905f, 0.24292746f, 0.15264206f, 0.00718897f, -0.07839616f, 
    0.05878551f, 0.08517996f, 0.25307888f, -0.06495076f, 0.01218263f, 0.09948094f, 0.00798660f, 0.00250629f, 
    -0.07172610f, 0.00890350f, -0.02435080f, -0.08767787f, 0.15522094f, -0.30249184f, 0.04683008f, -0.14968012f, 
    0.00205081f, -0.02031534f, 0.01672264f, -0.13202108f, 0.02363682f, -0.07827440f, -0.10932392f, -0.40055859f, 
    -0.11085593f, -0.02980495f, 0.15150738f, -0.00864673f, -0.17965615f, -0.16883537f, 0.08026680f, 0.02309296f, 
    0.05232906f, -0.00776377f, 0.07036487f, 0.01886484f, -0.40217790f, 0.38205692f, -0.01567884f, 0.00602328f, 
    -0.12130007f, 0.35664594f, -0.12163997f, -0.25993451f, -0.24870422f, 0.05952159f, -0.13600270f, 0.12012971f, 
    -0.16335182f, 0.20399882f, -0.23725583f, 0.11594843f, -0.03240966f, -0.11826175f, 0.10241257f, 0.04637455f, 
    -0.00707251f, -0.06736103f, 0.08797295f, 0.00183140f, -0.12572829f, -0.05486143f, -0.19959253f, -0.08355431f, 
    -0.01409079f, 0.01441340f, -0.03235332f, -0.14026494f, -0.03044379f, -0.11425567f, -0.05518502f, -0.03206298f, 
    0.18199071f, -0.60623008f, 0.40330470f, 0.21187238f, -0.08643490f, -0.13700934f, -0.05533676f, 0.02828190f, 
    0.05993840f, 0.02245202f, -0.02378960f, -0.06665251f, 0.62912101f, -0.65153491f, -0.01726649f, -0.44831443f, 
    0.02567899f, 0.01913777f, -0.00151344f, -0.04381222f, 0.02041106f, 0.14767237f, 0.08693002f, 0.02016486f, 
    -0.00766076f, 0.23100606f, 0.17361328f, -0.06040744f, -0.03028573f, 0.01911689f, 0.06478436f, -0.05073357f, 
    -0.03591986f, 0.03038605f, -0.01582428f, 0.02921603f, -0.62911254f, -0.38902226f, -0.21356909f, 0.28579390f, 
    0.07921123f, -0.07230935f, 0.01735451f, 0.09092875f, 0.04101759f, 0.02342287f, 0.00988599f, -0.05296048f, 
    0.16574468f, -0.08341447f, -0.06524997f, -0.12864952f, 0.00408435f, -0.10690975f, -0.04637195f, 0.00281172f, 
    -0.10235577f, 0.13124022f, 0.00787418f, -0.16754439f, -0.05777791f, -0.08475928f, 0.00207339f, 0.00180478f, 
    -0.15761267f, -0.11488264f, 0.05498944f, -0.00201763f, 0.03238798f, 0.02912330f, 0.01563943f, -0.04576802f, 
    0.55800182f, 0.13856743f, -0.02336309f, -0.82712531f, -0.02911099f, 0.04798599f, -0.08934133f, 0.13960490f, 
    -0.05957784f, 0.12789364f, 0.00447585f, -0.08472199f, -0.41288227f, -0.52691233f, -0.23575307f, 0.64067864f, 
    -0.10046999f, -0.09424379f, -0.04805051f, 0.17343487f, -0.03760741f, -0.03701585f, -0.01164286f, -0.02698127f, 
    -0.43134546f, 0.20995370f, -0.15698196f, 0.05886589f, -0.05669998f, -0.07048561f, 0.00077432f, -0.01610005f, 
    0.00582767f, 0.14480872f, 0.00801104f, 0.00920098f, 0.07119741f, 0.13280390f, -0.00491322f, -0.09820694f, 
    -0.05147387f, -0.00057546f, 0.04614277f, 0.03904044f, -0.03325166f, 0.00075489f, 0.08192001f, 0.03521168f, 
    -0.34053895f, -0.45545495f, -0.52518302f, -0.48270482f, -0.00956583f, -0.18131240f, 0.00395624f, 0.02644739f, 
    0.08483072f, 0.06433758f, 0.03614172f, 0.03570541f, -0.15246002f, 0.33918536f, -0.08990349f, 0.07142822f, 
    0.00529587f, -0.01603560f, 0.00150828f, -0.02945159f, -0.01563813f, -0.11541782f, 0.08078232f, -0.00339044f, 
    0.57926655f, 0.36956474f, -0.20694321f, -0.00285653f, 0.16121081f, 0.03430497f, -0.19001247f, -0.03364944f, 
    -0.09004121f, -0.13072048f, -0.21996145f, 0.09547342f, 0.21653546f, -0.07052388f, 0.02223850f, -0.10680924f, 
    0.02652648f, -0.01771765f, 0.01065267f, -0.05472158f, -0.29647410f, -0.11326566f, -0.18102401f, 0.07887042f, 
    -0.38650942f, -0.38249847f, -0.27070901f, -0.64050078f, 0.01850115f, -0.00036872f, -0.01218162f, 0.35813236f, 
    0.03293897f, -0.09174504f, -0.01238467f, -0.09282283f, -0.12122701f, 0.08983018f, -0.12586696f, 0.10458338f, 
    0.06025890f, -0.11773223f, 0.13697751f, -0.13600124f, -0.23188370f, 0.16680881f, 0.07821380f, 0.14983974f, 
    -0.17212747f, -0.20452090f, -0.11869380f, -0.10382164f, -0.00276457f, -0.12967721f, 0.20137426f, -0.02770767f, 
    -0.22442162f, 0.09975768f, 0.04420950f, -0.03540855f, 0.14554623f, -0.06114461f, -0.10221601f, -0.19580604f, 
    -0.02402072f, -0.01860198f, -0.01257947f, -0.04249199f, 0.14517400f, 0.09314511f, 0.02759705f, -0.07141899f, 
    0.27789542f, -0.20182808f, -0.56975353f, -0.11997052f, 0.20954551f, 0.05488262f, 0.27331829f, 0.14480597f, 
    0.03256748f, -0.05661812f, 0.04750228f, -0.01063448f, -0.04707935f, -0.00594795f, -0.01438977f, -0.05337155f, 
    -0.17242977f, -0.09565213f, -0.03791741f, -0.07871857f, -0.07140984f, -0.11465909f, -0.06832232f, -0.00268942f, 
    -0.87496501f, 0.09595136f, 0.14469722f, 0.21443893f, -0.04853918f, -0.00004445f, -0.12740667f, -0.00499409f, 
    0.02727971f, -0.10452898f, -0.06578860f, -0.22523534f, 0.24156685f, -0.33283105f, -0.13372359f, -0.54035652f, 
    0.20476873f, 0.20941746f, 0.13761552f, 0.14603724f, -0.03663526f, -0.24793757f, -0.09674963f, -0.05823717f, 
    0.08069327f, -0.25268939f, -0.10881637f, 0.04163573f, 0.00779370f, 0.08004972f, 0.09686438f, 0.15742019f, 
    0.06033976f, -0.06105776f, -0.19662052f, -0.09623019f, -0.48304424f, -0.26762325f, -0.03493913f, 0.09302063f, 
    0.01240709f, 0.12170956f, 0.08139089f, 0.01299686f, -0.30315804f, -0.11067967f, -0.09355874f, -0.38482633f, 
    0.02610789f, 0.05185048f, 0.06142263f, -0.11330137f, 0.03162641f, -0.07072740f, 0.02090953f, 0.00767047f, 
    -0.12056511f, 0.07694118f, -0.18686917f, -0.43019071f, -0.06233129f, -0.20379761f, -0.26122767f, 0.03311053f, 
    0.13299166f, 0.11251178f, 0.08923038f, 0.11572833f, -0.08768360f, 0.01201855f, -0.29820910f, -0.38123444f, 
    -0.29725569f, -0.07924201f, 0.23101893f, 0.18232670f, -0.20379348f, -0.04416932f, -0.02969171f, 0.03696786f, 
    0.05090675f, -0.10786296f, 0.20981823f, 0.08542127f, 0.16309763f, 0.39061442f, 0.04701740f, -0.22980802f, 
    0.00056199f, -0.01891075f, -0.00608447f, -0.06785481f, 0.07042897f, 0.04504108f, 0.03317097f, 0.11834452f, 
    0.16219628f, -0.00987376f, -0.02973437f, 0.07467280f, 0.05126929f, -0.13738461f, -0.14753959f, 0.11950687f, 
    0.16854802f, 0.14581488f, 0.18429251f, 0.17694545f, 0.01296974f, -0.01398575f, 0.19745184f, 0.06156654f, 
    0.22011527f, -0.15218389f, 0.03743015f, 0.23513073f, 0.03637844f, -0.02168080f, 0.29936570f, -0.00088963f, 
    -0.41799504f, 0.08101696f, 0.13310507f, 0.08466260f, 0.13299640f, -0.04502000f, -0.32876340f, 0.01478304f, 
    -0.19603547f, -0.04186433f, 0.02862656f, -0.04819540f, 0.20940599f, 0.05150610f, -0.10611805f, 0.02181540f, 
    0.05942713f, -0.09631366f, 0.03995037f, -0.04484837f, 0.17459956f, 0.26921922f, 0.09160497f, -0.14260007f, 
    0.59611368f, -0.19369222f, -0.22471628f, -0.73741758f, -0.04385791f, -0.12308604f, -0.02850353f, 0.01377549f, 
    -0.01543017f, 0.02366400f, -0.01648027f, -0.04532199f, -0.13903487f, -0.41988206f, -0.21648806f, -0.26159534f, 
    -0.05356373f, 0.08589499f, 0.13946120f, 0.03916589f, -0.05520514f, 0.07892696f, -0.00488986f, -0.04863134f, 
    -0.38543227f, -0.27006650f, -0.04096555f, -0.28433630f, 0.19079609f, 0.09793538f, 0.05560168f, -0.03795712f, 
    -0.00276038f, 0.09053681f, 0.23352861f, 0.15476137f, -0.15235195f, -0.11422389f, -0.03272076f, 0.05787288f, 
    -0.04877907f, -0.07102773f, -0.01473704f, 0.17266411f, 0.00668514f, -0.01614190f, 0.03435840f, 0.05955872f, 
    0.06338553f, 0.12359669f, -0.12455832f, -0.03799317f, -0.09137028f, 0.02907199f, 0.20227244f, -0.07436200f, 
    -0.01616857f, -0.12376323f, 0.07229563f, -0.04707200f, 0.35718802f, 0.23764594f, 0.11664478f, 0.03300624f, 
    0.13377845f, -0.27925330f, 0.01380495f, -0.06731817f, 0.17057626f, 0.07469690f, 0.14161880f, 0.08830748f, 
    0.12724458f, -0.05159501f, -0.29941550f, -0.22990416f, -0.08342700f, -0.12829667f, -0.05650816f, 0.08714279f, 
    0.19867374f, 0.13088204f, 0.17673990f, 0.09192167f, -0.33894047f, -0.73276037f, -0.69025028f, -0.26318741f, 
    -0.04649412f, -0.24735361f, -0.10077108f, -0.02841101f, -0.00434334f, -0.03130453f, 0.02530595f, 0.06246478f, 
    -0.13317469f, 0.07238141f, 0.19713369f, 0.31814548f, -0.23835164f, 0.08211214f, 0.07061786f, -0.04222876f, 
    -0.01388395f, -0.09559179f, 0.01099718f, 0.09080459f, -0.28355825f, -0.10081030f, -0.03273373f, 0.05010527f, 
    -0.10301090f, -0.00095269f, -0.16966222f, -0.13669243f, -0.31480697f, -0.03260600f, -0.30325443f, -0.23532313f, 
    -0.30902389f, -0.77061051f, -0.43618348f, 0.31252673f, 0.07397885f, 0.12068051f, 0.12825722f, 0.18429357f, 
    -0.04549693f, 0.05115398f, 0.06187517f, 0.05795263f, -1.21368396f, -0.18325035f, 0.34157288f, 0.37748256f, 
    -0.07733801f, -0.10575470f, -0.18548077f, 0.01880346f, -0.00506616f, -0.02412238f, 0.08734076f, -0.06032927f, 
    0.33682284f, -0.09947238f, -0.24533454f, -0.15163885f, 0.09393992f, 0.18312095f, 0.13601187f, 0.10971329f, 
    0.01656459f, -0.11305317f, 0.07550251f, 0.13536330f, 0.16582763f, -0.02367219f, -0.06625866f, -0.06237322f, 
    0.09674469f, -0.00823900f, -0.02688495f, -0.03096822f, 0.06551319f, 0.11150087f, 0.16311091f, 0.12570760f, 
    -0.10560329f, -0.52428496f, -0.64217138f, -0.08358897f, -0.19282763f, 0.00449848f, 0.25270981f, 0.13920546f, 
    0.00159700f, 0.02181632f, 0.02521595f, 0.05583277f, -0.02467781f, -0.21001928f, -0.16796923f, -0.07924050f, 
    -0.02024186f, 0.03736382f, 0.09335998f, 0.00635569f, 0.26111028f, 0.13015389f, 0.00828783f, 0.20333475f, 
    -0.48514935f, -0.06930520f, 0.29614177f, -0.02230395f, 0.29007548f, 0.15012065f, 0.10397025f, -0.01858555f, 
    0.08731336f, 0.10869957f, 0.02270198f, 0.19659699f, -0.03088715f, 0.04571853f, -0.20883903f, -0.36220744f, 
    -0.01166200f, 0.01177544f, -0.01740697f, 0.06807084f, 0.00756343f, -0.15921555f, 0.10373744f, -0.17475194f, 
    -0.22082511f, -0.02632217f, 0.24299429f, 0.00567026f, 0.05826532f, -0.29296345f, -0.09628963f, -0.19582331f, 
    0.06739632f, -0.00934983f, 0.09678372f, 0.14379622f, -0.31198323f, -0.32232273f, -0.11254885f, 0.15809287f, 
    0.19944045f, 0.21318585f, 0.14625292f, 0.08851461f, -0.02891064f, 0.12686874f, 0.15351321f, 0.10926229f, 
    -0.13710646f, -0.07833677f, -0.50470912f, 0.03393196f, -0.08199105f, -0.07683485f, 0.28002965f, 0.13540189f, 
    0.03015928f, 0.08954355f, 0.05871890f, -0.01950538f, 0.10644649f, -0.29274973f, 0.27344751f, 0.13143539f, 
    0.09687906f, -0.06170126f, 0.02594970f, 0.03095418f, -0.06914592f, -0.00871645f, 0.06381735f, 0.12995383f, 
    -0.15293625f, -0.23560549f, 0.40205383f, -0.23852742f, 0.06400744f, -0.15832439f, -0.12688173f, 0.07005924f, 
    0.13816921f, 0.04240935f, -0.00416408f, -0.01645237f, 0.29429871f, 0.14704537f, 0.24264756f, -0.08396383f, 
    -0.06037419f, -0.04159665f, -0.21639974f, -0.28003192f, 0.04047298f, 0.05469234f, 0.03680304f, 0.05897850f, 
    -0.00809856f, -0.24615526f, 0.22170754f, 0.12144623f, -0.11013577f, 0.07705330f, -0.00971733f, -0.01391971f, 
    0.07040985f, 0.09336138f, 0.31761327f, 0.21861658f, -0.16100760f, 0.42232898f, -0.41692176f, -0.12436195f, 
    -0.12280247f, -0.16532247f, 0.02761929f, -0.12313084f, 0.17487435f, 0.16198029f, 0.02592874f, 0.20390226f, 
    0.32194456f, -0.39084893f, 0.02544469f, -0.40963694f, -0.19288552f, 0.15301165f, 0.02907758f, -0.04768852f, 
    -0.02749231f, 0.20666352f, -0.06766830f, 0.07610299f, -0.24034981f, -0.08212983f, 0.01638160f, 0.07611159f, 
    0.11288685f, 0.07147979f, 0.00613978f, -0.06831088f, 0.13758549f, 0.08964036f, -0.04491042f, -0.21019283f, 
    0.12792407f, -0.22923861f, -0.04283991f, -0.09753889f, 0.11005082f, -0.04731691f, 0.01177481f, 0.02375107f, 
    -0.01328482f, -0.18615548f, -0.21791112f, -0.02142510f, -0.39535716f, 0.50071752f, -0.65807188f, -0.02459384f, 
    0.01053041f, -0.27284995f, -0.01146355f, -0.16126120f, 0.02618280f, -0.03678221f, 0.18575159f, 0.00566211f, 
    -0.02335628f, 0.58512241f, -0.62356085f, -0.08021935f, 0.08033291f, -0.00337480f, 0.38014135f, 0.12107804f, 
    0.21818146f, -0.02537205f, -0.10686196f, 0.08181859f, 0.04319334f, 0.19281004f, -0.27757722f, 0.47412348f, 
    0.01687303f, -0.16745837f, 0.01996764f, -0.37261039f, 0.01966350f, 0.09878922f, -0.24589881f, -0.07879455f, 
    0.07394948f, -1.27842569f, -0.03036839f, 0.13820340f, -0.00816174f, 0.19845201f, 0.16959211f, 0.06499943f, 
    0.04211803f, 0.13343558f, 0.12145432f, -0.11057685f, 0.41437003f, -0.24573956f, 0.33603951f, 0.29494554f, 
    -0.18611625f, -0.02728603f, -0.25667039f, -0.19520760f, -0.02827699f, 0.02101831f, -0.08142298f, 0.01284244f, 
    0.18681392f, 0.07289518f, -0.06323338f, -0.14019822f, -0.10654783f, 0.02940592f, -0.01227921f, -0.12198013f, 
    -0.07647920f, -0.08784556f, -0.10918520f, -0.21975990f, -0.11137959f, 0.30761972f, 0.07018853f, -0.14613988f, 
    -0.09991526f, -0.15656288f, 0.20479394f, 0.20129102f, -0.06751092f, 0.03794043f, -0.06548361f, -0.12922314f, 
    0.05382271f, -0.37748301f, -0.19621149f, -0.51501220f, 0.13592096f, 0.18631272f, 0.03643448f, 0.05711830f, 
    0.00155652f, -0.23955511f, -0.04451610f, 0.04333722f, -0.34815899f, -0.19333239f, -0.41279957f, 0.16947500f, 
    0.21066886f, -0.14487952f, 0.19317017f, -0.05027700f, -0.00229254f, -0.11745462f, -0.06609212f, -0.05240259f, 
    -0.11549009f, -0.14799492f, -0.12838660f, 0.46781257f, -0.09278689f, 0.25848839f, -0.35046574f, -0.03865755f, 
    0.19484589f, -0.00871578f, -0.05788344f, -0.16422559f, -0.72858447f, 0.10736326f, 0.41712627f, -0.44330996f, 
    -0.26359421f, -0.35537884f, -0.05324946f, 0.25406143f, 0.05796576f, -0.02922634f, 0.03592024f, -0.05770338f, 
    -0.08282099f, -0.02686246f, 0.12420015f, -0.27100062f, 0.09327301f, 0.06137665f, -0.01427006f, 0.02488674f, 
    0.07952005f, -0.14011420f, 0.00927861f, -0.06674388f, 0.14681004f, -0.11902349f, 0.12036840f, -0.22630055f, 
    0.02551991f, 0.29242575f, 0.13913564f, 0.07609330f, 0.16503453f, 0.12151080f, -0.00051092f, 0.19714153f, 
    0.14687200f, -0.08796250f, -0.09105724f, -0.43149766f, 0.14246406f, 0.00804706f, -0.13226290f, -0.04807010f, 
    0.10300476f, -0.07726423f, -0.00817892f, -0.02893350f, -0.10504726f, -0.32776383f, -0.18057860f, -0.31992343f, 
    -0.00709645f, 0.04696911f, 0.17003661f, 0.11884638f, 0.10110441f, -0.03083658f, -0.07375784f, 0.02424654f, 
    -0.82712293f, 0.18201604f, 0.08021496f, 0.64422685f, 0.04285818f, -0.33725753f, -0.10364266f, -0.03922981f, 
    0.09964473f, -0.04360126f, -0.01895785f, 0.21330009f, -0.25660187f, -0.01793206f, -0.13949209f, 0.19290474f, 
    0.08566888f, 0.27788749f, 0.07797327f, -0.23099190f, 0.38834104f, 0.11277676f, -0.09104540f, -0.05879322f, 
    -0.10692880f, 0.02441831f, -0.43983805f, -0.13823949f, -0.36252445f, 0.05079716f, -0.10180333f, 0.11436293f, 
    0.18202315f, -0.01805363f, 0.14187391f, -0.08741540f, -0.15196982f, 0.23975636f, 0.02086707f, -0.02734326f, 
    0.06258647f, -0.29181740f, -0.17580163f, -0.12010095f, -0.15155633f, -0.03274842f, 0.00096615f, -0.09328795f, 
    0.14664531f, -0.28951356f, 0.58343601f, -0.88151354f, 0.14147550f, -0.30604923f, -0.15200672f, -0.14159648f, 
    -0.26845899f, 0.05288259f, 0.13598998f, -0.15911201f, 0.11658121f, 0.21573168f, -0.04998644f, 0.55843866f, 
    0.11222840f, -0.04023032f, -0.14752541f, -0.13133284f, -0.00236904f, -0.02313610f, 0.12311471f, -0.06674360f, 
    -0.22699602f, -0.17730588f, 0.27224657f, -0.06510855f, -0.00927370f, 0.11465815f, -0.02775048f, -0.24357469f, 
    -0.10498090f, 0.05234368f, -0.05562767f, -0.22048627f, -0.26457122f, -0.50142151f, -0.30840290f, -0.49232140f, 
    -0.29098749f, -0.31837478f, -0.14783989f, -0.18108188f, 0.25893596f, -0.05835404f, 0.15337555f, 0.06747469f, 
    0.13716155f, -0.14050059f, -0.29475588f, 0.40588742f, -0.03395012f, 0.03844387f, 0.15719135f, -0.34101608f, 
    -0.11302274f, -0.02632064f, -0.14744884f, -0.00679320f, -0.57074916f, 0.48389387f, -0.34463999f, 0.08148377f, 
    0.11508470f, 0.01739571f, -0.02982305f, 0.06280793f, -0.05639896f, 0.06771464f, -0.20566429f, -0.20980734f, 
    -0.52883208f, 0.06032798f, 0.04502571f, 0.34172761f, -0.14108658f, 0.00020544f, 0.10551978f, 0.25319421f, 
    -0.12842368f, -0.02008666f, 0.00838109f, -0.20708320f, 0.05132126f, 0.11149888f, -0.10407005f, -0.19669989f, 
    0.09670889f, -0.12612231f, -0.18264729f, 0.03508508f, -0.24712254f, -0.03912595f, -0.24818416f, -0.49485037f, 
    0.01413171f, 0.03260338f, 0.25605607f, -0.19160183f, -0.18388234f, 0.00966066f, 0.06183893f, -0.00996583f, 
    0.06107151f, -0.10488138f, -0.20420961f, -0.21025541f, 0.10792904f, -0.10166164f, 0.17915452f, -0.24671206f, 
    -0.05147906f, 0.05882866f, -0.03675227f, 0.00856796f, -0.21087655f, -0.42966136f, -0.27908739f, -0.15141164f, 
    -0.06774756f, 0.30900863f, 0.02695856f, 0.32418820f, -0.04038272f, -0.17947471f, -0.00883912f, 0.02376087f, 
    -0.03938233f, -0.07649433f, 0.00146505f, 0.15021048f, -0.43545312f, 0.08138398f, 0.16524778f, -0.21846534f, 
    -0.14131995f, 0.00932082f, -0.00442104f, -0.01963094f, -0.02723681f, -0.06620141f, 0.15479584f, -0.09907208f, 
    -0.01859802f, 0.06692317f, 0.19452199f, 0.22956325f, -0.05399221f, -0.01783630f, 0.22381301f, 0.29369318f, 
    0.03805243f, 0.17936678f, 0.17554024f, 0.44890723f, 0.23503187f, -0.05283079f, 0.00580385f, 0.13646199f, 
    -0.19850275f, 0.17772207f, 0.28824648f, 0.17331788f, 0.04189144f, 0.14342394f, -0.10668296f, -0.05908009f, 
    0.07306562f, -0.05564044f, 0.15083745f, -0.16332535f, -0.09782511f, -0.12539627f, 0.12941957f, -0.05242983f, 
    -0.21452303f, 0.04981944f, -0.08463271f, -0.02024331f, -0.13718964f, 0.14090106f, 0.07394606f, 0.18302922f, 
    -0.19191954f, 0.20749567f, 0.18727824f, 0.08080334f, 0.08490893f, -0.29008809f, -0.02172926f, -0.00983212f, 
    -0.59258276f, 0.00284594f, -0.64215887f, 0.19323425f, -0.14074481f, -0.07589533f, -0.00299106f, 0.13575067f, 
    -0.01710197f, 0.03223470f, -0.16790724f, -0.08431709f, -0.52836120f, 0.25134346f, -0.43875039f, -0.26132551f, 
    0.05910076f, 0.14793719f, -0.01814737f, -0.01937216f, -0.17646073f, 0.20099092f, 0.05030184f, 0.01916622f, 
    0.20746553f, 0.36463884f, -0.03182859f, -0.07868767f, 0.03060291f, 0.12957732f, 0.25675359f, 0.03996727f, 
    0.17044494f, 0.10975038f, 0.05845582f, 0.03061199f, -0.29890701f, -0.00426835f, 0.01575675f, 0.12751415f, 
    0.00987467f, 0.00461935f, -0.12344962f, -0.12405507f, -0.06167357f, 0.10579268f, 0.03859653f, 0.00459422f, 
    -0.32877186f, 0.01045574f, 0.79367846f, 0.40841642f, 0.01575867f, 0.29595360f, -0.19570497f, 0.14974704f, 
    0.10421158f, 0.27199131f, 0.42622507f, -0.23873794f, -0.12707648f, 0.19309092f, -0.51052022f, -0.14449087f, 
    -0.02611201f, 0.19581074f, 0.16123034f, -0.03148139f, 0.00861440f, 0.18080001f, 0.02200260f, 0.08201461f, 
    -0.25911018f, 0.42476070f, -0.08054900f, -0.04659705f, 0.20947942f, -0.10085429f, 0.01873586f, -0.18280056f, 
    -0.10656779f, -0.02960258f, 0.02445312f, 0.00939278f, -0.18686812f, -0.34409526f, 0.03841899f, -0.12494572f, 
    -0.16311751f, -0.17952180f, 0.17633328f, 0.06953992f, -0.00173823f, 0.16532893f, 0.16696490f, 0.11872762f, 
    -0.28831261f, -0.14268897f, 0.30944386f, 0.06382615f, -0.02980702f, 0.07495603f, -0.59397757f, 0.17520712f, 
    -0.08935442f, -0.09693970f, 0.09967065f, -0.11108059f, 0.16529743f, -0.22434670f, 0.03648982f, 0.07450921f, 
    -0.22191167f, -0.02062610f, 0.07776208f, -0.07986124f, -0.09771806f, -0.07828107f, -0.24361065f, -0.23410396f, 
    0.19772108f, -0.10184129f, 0.12509656f, 0.16815884f, -0.20622043f, -0.18458089f, 0.13551554f, 0.16715582f, 
    -0.06737925f, 0.12884745f, 0.14874233f, 0.04396703f, 0.03040162f, -0.05836524f, 0.15691316f, 0.29797673f, 
    -0.08026560f, 0.10900271f, 0.04318636f, -0.00280462f, -0.31290919f, -0.12371794f, -0.09010085f, 0.12440305f, 
    -0.22010466f, 0.49843317f, 0.33023944f, -0.21449520f, -0.14737889f, 0.08230291f, -0.07454220f, 0.18811238f, 
    -0.24854724f, 0.10547161f, -0.37885454f, -0.13378601f, -0.35030374f, -0.10589773f, 0.02125422f, -0.28399009f, 
    -0.14887916f, 0.10369211f, -0.06780007f, -0.03931032f, 0.02403693f, -0.05248183f, 0.14768486f, 0.11027750f, 
    0.15526453f, -0.18078077f, -0.23897029f, 0.07456281f, -0.04304725f, 0.18758515f, 0.14198752f, -0.00956423f, 
    0.00847149f, 0.12158996f, -0.01926312f, -0.14900598f, -0.11636919f, -0.28421104f, 0.31724304f, 0.11943443f, 
    -0.14546922f, 0.23992005f, -0.16107163f, 0.09231040f, 0.22387935f, -0.26305827f, 0.20407459f, 0.12658291f, 
    -0.28524047f, 0.44715762f, -0.26102605f, 0.41015705f, -0.19815305f, 0.01720228f, -0.10193295f, 0.23694296f, 
    0.06558718f, 0.04844135f, -0.08276576f, -0.18338831f, -0.22336304f, 0.41732520f, 0.15411238f, -0.24065173f, 
    -0.10543543f, -0.08731243f, 0.03766205f, 0.12657499f, 0.08636600f, 0.12477892f, -0.32915583f, -0.09769548f, 
    0.16093902f, 0.13788064f, 0.24778463f, -0.80627930f, 0.17214404f, -0.07843930f, -0.10742511f, -0.05774322f, 
    -0.05122249f, 0.13195415f, 0.20702313f, 0.14118184f, 0.47933501f, 0.14889266f, 0.22235835f, -0.29950970f, 
    -0.03114332f, 0.04461433f, -0.08643197f, 0.05523194f, -0.14651620f, 0.12182072f, -0.23173381f, -0.17769553f, 
    0.18409000f, -0.21728639f, 0.34490609f, 0.27283618f, -0.18326315f, -0.14773847f, -0.01603472f, 0.09839550f, 
    -0.10863067f, -0.05213935f, 0.06886734f, 0.05509936f, -0.32134417f, -0.12732902f, -0.06037315f, -0.11297112f, 
    -0.13823184f, -0.22132578f, -0.17921251f, 0.01484314f, 0.10622677f, 0.12502307f, 0.02972470f, 0.08514966f, 
    -0.27316996f, -0.13715667f, 0.21487314f, 0.23688999f, -0.14475349f, 0.03535496f, 0.13931243f, 0.03612158f, 
    0.01641094f, 0.06011439f, 0.06074954f, -0.10117351f, -0.37708414f, 0.18251874f, -0.45876202f, -0.17467259f, 
    -0.00175177f, -0.13136855f, 0.06578897f, -0.06177869f, -0.01298360f, -0.07548921f, -0.03775177f, -0.02466248f, 
    -0.07087077f, 0.14854713f, -0.32975903f, 0.00865908f, -0.05188727f, 0.05032374f, 0.14346753f, 0.06665746f, 
    0.31455362f, 0.05857696f, 0.03170652f, 0.07405820f, -0.35728511f, -0.25714442f, -0.03834935f, -0.61888021f, 
    0.07323568f, 0.02580605f, 0.13983057f, 0.07111026f, -0.09806279f, 0.11925151f, 0.09458963f, 0.11225992f, 
    -0.57993960f, 0.30113095f, -0.12223542f, 0.02104341f, 0.06687692f, 0.00494418f, -0.00584090f, -0.08089310f, 
    -0.47439751f, 0.07086919f, 0.02381392f, -0.15856957f, 0.21603422f, 0.14565402f, -0.19492204f, 0.15365010f, 
    -0.00562709f, 0.27068335f, -0.09729902f, 0.15936314f, -0.14105000f, -0.04312297f, 0.04970333f, -0.10342903f, 
    -0.01185919f, 0.20900202f, -0.00407496f, -0.04098656f, -0.07997426f, -0.03198506f, -0.01155931f, -0.12968291f, 
    -0.24335912f, -0.06529413f, -0.28916943f, -0.31799001f, 0.70555025f, -0.48148656f, 0.38520652f, -0.36372921f, 
    0.07653422f, -0.06179291f, 0.20422539f, 0.09681045f, -0.07367720f, 0.07058997f, 0.03474133f, -0.02948844f, 
    0.32324496f, -0.38863668f, 0.76802427f, -0.04601412f, 0.13374372f, 0.23346345f, -0.02077544f, -0.18778192f, 
    -0.02729212f, -0.03434167f, 0.12420246f, 0.19470640f, -0.03870155f, -0.05859116f, 0.15896931f, -0.28553909f, 
    0.05621992f, 0.06839546f, -0.04491895f, 0.04993492f, -0.09289715f, 0.10658637f, 0.18594714f, 0.00659360f, 
    -0.08307748f, 0.25014329f, 0.11941539f, 0.07909068f, 0.00547055f, -0.11535106f, 0.08031953f, -0.06076930f, 
    0.06085443f, 0.07699266f, 0.13620366f, 0.07658568f, -0.57691908f, 0.15534478f, -0.59833932f, 0.55339748f, 
    -0.01848700f, -0.27897835f, 0.13727304f, -0.20300657f, 0.09434488f, -0.07307232f, -0.06569065f, -0.02949834f, 
    -0.27498755f, 0.18665609f, -0.02416279f, 0.01417107f, 0.07265871f, -0.13170975f, 0.15485600f, 0.02452391f, 
    -0.02738942f, -0.24308434f, -0.18028989f, 0.21672560f, -0.09442875f, -0.10352776f, 0.08450449f, 0.03147575f, 
    -0.14363484f, -0.33651301f, -0.22075766f, -0.18504123f, -0.06632619f, -0.10006652f, -0.06566550f, -0.07025176f, 
    -0.15797828f, 0.23888962f, 0.24706009f, -0.07693207f, 0.03239690f, -0.19185403f, 0.07567495f, 0.06240972f, 
    0.06926913f, -0.15875545f, -0.25470856f, 0.19252838f, 0.68739367f, -0.15874755f, 0.12366230f, 0.01301457f, 
    0.00261279f, -0.06038759f, -0.43923184f, 0.27414545f, -0.30176610f, -0.04802697f, -0.08970627f, -0.16097747f, 
    -0.93228698f, 0.03339466f, -0.58313739f, 0.51155156f, 0.24818695f, -0.18804279f, 0.23445536f, -0.11473241f, 
    -0.19431365f, -0.04015645f, 0.23236607f, 0.04896887f, -0.29153273f, -0.39476058f, -0.47410345f, -0.06119797f, 
    -0.17267159f, -0.36970574f, 0.04604808f, -0.33422825f, 0.00701081f, 0.19808023f, -0.15515074f, -0.10049176f, 
    0.43028003f, 0.12633130f, 0.15368021f, 0.26404518f, -0.12967832f, 0.12450584f, 0.12737793f, 0.27795020f, 
    -0.15669930f, 0.12597668f, 0.05718055f, 0.05716931f, 0.13985837f, 0.23074611f, 0.06089075f, -0.19559060f, 
    -0.21844602f, 0.10462968f, -0.08828750f, 0.06844711f, -0.08231089f, 0.03468477f, 0.10114218f, 0.14000438f, 
    -0.02327020f, 0.23668802f, 0.07564089f, -0.32907298f, -0.14959799f, -0.00970924f, 0.02360305f, -0.05117986f, 
    -0.00402648f, -0.02627865f, -0.02145324f, -0.19982599f, 0.27705961f, 0.21155706f, -0.02651981f, -0.00963801f, 
    -0.12519971f, 0.01054844f, -0.01159996f, -0.13602901f, 0.04014776f, 0.13331622f, 0.10071629f, -0.08493371f, 
    0.13032746f, -0.36779264f, 0.28698617f, 0.11632021f, 0.25614253f, 0.15630321f, -0.10633389f, -0.07530785f, 
    0.00009100f, 0.07139853f, 0.27122825f, 0.19929241f, -0.10559475f, 0.04518943f, -0.05349065f, -0.17949273f, 
    0.00056973f, -0.06364708f, 0.00431350f, 0.16626605f, 0.06596153f, 0.02335117f, -0.00555147f, -0.26753116f, 
    -0.16763140f, -0.30606109f, 0.25944901f, -0.21291423f, -0.29347977f, 0.13108595f, -0.02294824f, -0.07478559f, 
    -0.09627129f, 0.02568305f, 0.05224467f, 0.07139800f, -0.05183084f, 0.01029163f, 0.21109846f, 0.00542172f, 
    0.20579188f, 0.01120808f, -0.12286998f, 0.21510883f, -0.10328312f, 0.16281016f, 0.06079228f, -0.37500343f, 
    -0.30200571f, -0.70844567f, 0.35929260f, 0.30441532f, 0.11982138f, 0.14923975f, 0.16921170f, 0.30515996f, 
    -0.23414309f, 0.01114501f, -0.08407111f, 0.04431673f, -0.25470257f, -0.27971190f, -0.21127267f, 0.18868996f, 
    0.07546216f, -0.03749594f, 0.00515165f, -0.00906036f, -0.09168779f, 0.03153043f, 0.12086352f, 0.34927678f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25493127f, 0.06117001f, 0.13443623f, -0.05860581f, -0.12252750f, 0.17885092f, 0.01952740f, -0.17380920f, 
    0.10738548f, 0.05979847f, -0.01178409f, -0.07829789f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
