#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.54950571f, 0.04377940f, 0.03905407f, 0.36905757f, -0.48041698f, -0.51891917f, -0.50979060f, -0.26640257f, 
    -0.02973426f, -0.57043517f, -0.03794698f, 0.18160938f, 0.16912998f, 0.31688255f, -0.11119201f, 0.22984634f, 
    -0.04941047f, 0.25030932f, 0.01832866f, -0.13037309f, -0.19086961f, 0.05322178f, -0.00723803f, -0.17238627f, 
    -0.07182597f, 0.24098384f, 0.36483994f, -0.83720291f, -0.56379050f, -0.48061177f, 0.57352322f, -0.09886484f, 
    -0.37993947f, -0.47765446f, 0.38194692f, -0.01244282f, 0.04642806f, 0.35936472f, 0.48055288f, 0.38541111f, 
    -0.06326680f, -0.33903587f, -0.23639785f, -0.27697706f, -0.34567183f, -0.12555212f, 0.44000244f, 0.03607608f, 
    -0.00222584f, 0.19086036f, -0.07272608f, -0.18010046f, -0.57243854f, -0.50467616f, -0.17598519f, 0.62218660f, 
    0.49918461f, 0.21942508f, -0.58492273f, 0.15709628f, 0.17739803f, -0.11785854f, 0.12810738f, 0.10390837f, 
    -0.14454423f, -0.42275992f, 0.02068053f, 0.31914589f, -0.15778433f, 0.23098260f, -0.09853411f, -0.18105075f, 
    0.06403595f, -0.03053893f, 0.04903278f, 0.15264237f, 0.15725538f, -0.51718628f, 0.09682238f, -0.11796144f, 
    0.33498567f, 0.21418317f, -0.08458763f, -0.36500734f, 0.36238596f, -0.21243411f, 0.04956559f, -0.26676729f, 
    -0.21278784f, -0.15743451f, 0.53964943f, 0.14084975f, -0.17576487f, -0.05273477f, -0.34356207f, -0.12061545f, 
    0.12312341f, -0.08289379f, 0.00888491f, 0.17094459f, -0.76695204f, -0.65574312f, -0.33093116f, 0.17736724f, 
    0.05328601f, 0.41420433f, 0.19251519f, -0.18436882f, 0.49916786f, 0.39124921f, 0.26193392f, 0.05513126f, 
    -0.30400902f, -0.21251331f, -0.04569148f, -0.25499317f, -0.17076914f, -0.01237735f, -0.11190715f, 0.03659726f, 
    -0.05246549f, 0.24922849f, -0.05302547f, 0.10619177f, 0.36477762f, 0.77553672f, -0.54365945f, -0.52108622f, 
    0.12745546f, -0.08641632f, 0.44196862f, 0.01340889f, -0.07914409f, -0.09446090f, 0.22644834f, -0.06389326f, 
    0.39673832f, -0.37368500f, -0.37272540f, 0.27050045f, -0.17218748f, -0.08191442f, 0.09553457f, 0.08831161f, 
    -0.04153540f, 0.31394160f, -0.00124160f, -0.21528299f, 0.00206162f, -0.11335903f, -0.11294641f, 0.10713308f, 
    0.17170815f, -0.08654118f, -0.11190280f, -0.07711699f, -0.16439810f, 0.01744107f, 0.10215218f, -0.20567667f, 
    0.08146022f, -0.12082838f, -0.12468584f, 0.26279891f, -0.14693606f, -0.08916522f, 0.14163084f, -0.00116359f, 
    0.07589646f, -0.34146720f, 0.14073932f, 0.03501939f, -0.11694522f, 0.35127601f, 0.10803968f, -0.01560207f, 
    0.06680530f, 0.00364319f, -0.39597833f, -0.33828896f, -0.41194442f, -0.07073087f, 0.01310759f, -0.02234384f, 
    0.39431998f, 0.03641869f, -0.04950364f, -0.42047963f, -0.20775312f, -0.03188686f, 0.10912458f, 0.12392269f, 
    0.23222673f, -0.10256848f, 0.25357649f, 0.02850069f, -0.14948975f, 0.08816182f, -0.16614805f, 0.22648975f, 
    0.85714120f, 0.13161525f, -0.44335005f, -0.62496293f, -0.79238272f, -0.10069094f, 0.14994244f, 0.38649321f, 
    0.39172095f, 0.06193493f, 0.06088080f, 0.27379754f, -0.21213865f, 0.05308719f, -0.20258024f, 0.07468466f, 
    -0.11779260f, 0.27018148f, -0.05931074f, -0.13587208f, 0.13290399f, 0.09077514f, -0.02322541f, -0.12245053f, 
    0.17927465f, -0.46652779f, 0.32128754f, 0.02416658f, 0.41206181f, -0.29078597f, -0.01025928f, -0.29771739f, 
    -0.07708634f, 0.03696052f, 0.15554784f, -0.12167308f, -0.25552699f, -0.16020453f, 0.36750168f, -0.41252351f, 
    0.04301127f, 0.05907062f, 0.30404842f, -0.19377932f, -0.10484637f, -0.01372409f, -0.13457930f, 0.13779175f, 
    -0.13659611f, 0.17503230f, -0.80480283f, -0.59679693f, -0.24842417f, -0.36118469f, 0.07559286f, 0.17520146f, 
    -0.29920435f, -0.66062677f, -0.70570499f, -0.45396861f, -0.20524888f, -0.18163007f, -0.20226370f, -0.27138317f, 
    -0.52100968f, -0.08969326f, -0.19626297f, -0.10683926f, -0.03993819f, -0.05612320f, -0.17101274f, -0.25835633f, 
    -0.10502558f, -0.20755187f, -0.11491504f, 0.21440850f, -0.46886709f, -0.64122242f, -0.24495520f, -0.19300209f, 
    -0.20004541f, -0.11596184f, -0.01402728f, 0.10751599f, -0.15578517f, 0.12230650f, 0.26423016f, 0.33997977f, 
    0.12996489f, 0.23406479f, 0.25926948f, 0.00220714f, -0.09576877f, 0.06645291f, -0.08061138f, 0.21606590f, 
    -0.35807768f, -0.08791880f, 0.00979182f, -0.36345199f, 0.27469403f, 0.52088678f, 0.22597551f, 0.30585453f, 
    -0.25965279f, -0.64841431f, -0.73194951f, -0.19288775f, 0.19368848f, 0.39616066f, 0.04718693f, -0.10372373f, 
    -0.04198799f, -0.17729196f, 0.10145533f, 0.16189449f, 0.38760975f, -0.17358118f, 0.04005970f, -0.26995042f, 
    0.06512145f, -0.07847697f, -0.05699446f, 0.14761843f, -0.16854590f, -0.14663552f, -0.37378919f, -0.39088577f, 
    -0.13642415f, -0.15424955f, -0.25809097f, -0.21285239f, -0.24719435f, -0.35122806f, -0.15977538f, -0.07723021f, 
    0.17366309f, -0.23412147f, -0.19495627f, 0.03283924f, -0.28986022f, -0.13556033f, 0.09965270f, -0.08655834f, 
    -0.07788812f, 0.34186575f, 0.23999417f, 0.27716398f, 0.30218902f, 0.33416307f, -0.92553037f, 0.12542729f, 
    -0.42187160f, -0.25544742f, -0.25196582f, 0.33952561f, -0.06887961f, -0.58940864f, -0.47787610f, -0.02719401f, 
    -0.14244176f, -0.14700119f, -0.05328223f, -0.41776824f, -0.05165172f, -0.09004183f, 0.09607252f, -0.18385814f, 
    -0.14468215f, -0.19362924f, 0.01353427f, 0.03194720f, -0.14673738f, -0.19994089f, 0.04474858f, -0.91007543f, 
    -0.63387853f, -0.27446729f, -0.38818309f, -0.37918800f, 0.30755427f, 0.11028937f, -0.63494742f, -0.54162675f, 
    0.13545673f, -0.32544643f, -0.17305556f, 0.16097540f, -0.21225300f, -0.16054325f, -0.05524411f, -0.18079345f, 
    -0.15076102f, -0.01866486f, 0.09394754f, 0.02080811f, 0.14303949f, -0.16168061f, 0.09438208f, -0.14834699f, 
    0.31362778f, 0.38241351f, 0.22634695f, -0.25327674f, -0.21042310f, -0.38273740f, -0.05897729f, 0.22678348f, 
    -0.13317710f, -0.03258507f, -0.16532306f, -0.28891480f, 0.45119768f, -0.48294762f, 0.21584843f, 0.06881161f, 
    -0.13786361f, -0.27705729f, 0.12265785f, 0.27605611f, 0.06675947f, -0.01151341f, -0.09517705f, -0.10027313f, 
    0.31692487f, 0.38564798f, -0.45956346f, 0.01109994f, 0.28136492f, 0.09172635f, -0.18237491f, 0.25365716f, 
    -0.20057496f, -0.43087557f, 0.11446271f, 0.19349605f, -0.10541248f, -0.22168657f, 0.25140196f, -0.02470972f, 
    -0.00729499f, 0.11141472f, 0.01214191f, 0.05920955f, -0.12676230f, -0.24371973f, -0.15109383f, 0.37160587f, 
    0.31417727f, -0.09434354f, -0.94443858f, -0.48391291f, -0.63429034f, -0.48237208f, -0.22854109f, 0.42653856f, 
    0.17369175f, 0.25523967f, 0.37143332f, 0.43411571f, -0.04558577f, -0.03336827f, 0.25628212f, 0.17494360f, 
    -0.17221607f, 0.05676934f, 0.20445865f, 0.16955109f, 0.01242435f, 0.13704313f, -0.04217643f, 0.16995026f, 
    -0.00179911f, -0.18739864f, -0.16119176f, 0.48687875f, 0.28619412f, 0.12406352f, -0.26660305f, -0.14403568f, 
    0.20721290f, 0.23934402f, 0.36351338f, -0.21989994f, -0.13177422f, -0.36495349f, 0.32968527f, -0.09355677f, 
    -0.38415506f, -0.29271361f, 0.15768564f, 0.18074235f, 0.11653641f, -0.22668427f, 0.01267617f, -0.01557658f, 
    0.00977292f, -0.36254042f, -0.09876119f, 0.07553396f, -0.74720228f, -0.36583564f, -0.16131818f, -0.51250482f, 
    -0.56150997f, 0.61748648f, -0.20450750f, -0.31271061f, 0.20369805f, 0.63144815f, 0.02811799f, -0.08627295f, 
    -0.13074148f, -0.01110198f, 0.14561403f, 0.13149987f, 0.23889166f, 0.10050648f, -0.20515178f, -0.15228127f, 
    0.04648561f, 0.07399561f, 0.15062825f, 0.22904876f, 0.05152702f, -0.03841988f, -0.18967944f, 0.10986408f, 
    0.34888962f, -0.37669149f, -0.04920097f, -0.34161204f, 0.21627408f, 0.02790154f, -0.04224361f, 0.48118234f, 
    -0.35806322f, 0.00136782f, -0.28196213f, 0.11952434f, 0.11870085f, 0.18882373f, -0.21745715f, -0.31080344f, 
    0.30352429f, -0.11036758f, -0.29121977f, 0.17362249f, -0.11553124f, 0.31220844f, -0.22216423f, -0.26666272f, 
    0.16494542f, 0.19729151f, 0.23124979f, -0.17410189f, -0.12494351f, -0.11016852f, 0.31528300f, -0.01771565f, 
    -0.05150075f, -0.25122714f, -0.20132945f, 0.35246605f, 0.26088777f, -0.28017220f, 0.10994973f, 0.34379187f, 
    -0.15453517f, -0.23293312f, -0.07181958f, 0.00285319f, -0.03438544f, 0.01240470f, 0.32420623f, 0.38879147f, 
    0.30189255f, 0.25996375f, -0.03434768f, -0.42017820f, -0.25080225f, -0.13967760f, 0.25918376f, 0.17541203f, 
    -0.50032169f, -0.00363943f, -0.01744645f, -0.13623115f, -0.11063571f, -0.23489860f, 0.40088946f, 0.15977307f, 
    0.16343005f, -0.25060004f, 0.01163054f, -0.01657623f, -0.25174603f, -0.12941557f, 0.21559677f, -0.20759465f, 
    0.40170610f, 0.41363075f, 0.72012019f, -0.72859627f, -0.56637055f, -0.12640005f, 0.17766085f, -0.37518686f, 
    -0.23887116f, -0.29668838f, 0.09000015f, -0.46248567f, -0.09825965f, 0.40945637f, -0.10870625f, 0.06501309f, 
    -0.38230374f, -0.26895288f, 0.33859405f, 0.13066979f, -0.46583995f, 0.03832589f, -0.09769078f, 0.05810959f, 
    0.31419960f, -0.30252394f, 0.08244877f, 0.10019207f, 0.13372786f, -0.00350750f, -0.62340581f, -0.58331698f, 
    0.68887472f, 0.35932848f, -0.02897048f, -0.05384546f, 0.19750381f, 0.02686067f, -0.03367534f, -0.10376650f, 
    -0.31525525f, -0.00088570f, 0.14242902f, 0.21885134f, -0.11610533f, 0.08340222f, -0.17806309f, -0.33310136f, 
    0.14007182f, 0.32480222f, -1.28890073f, 0.78605062f, -0.02002281f, -0.53288150f, 0.56617433f, -0.57549614f, 
    -0.02989230f, 0.81255943f, 0.19267660f, 0.03546309f, -0.08646405f, -0.27551180f, -0.02345171f, -0.32242849f, 
    0.06493673f, 0.28989792f, -0.29045019f, -0.29752621f, -0.05197008f, -0.14809653f, -0.05149454f, -0.19361043f, 
    0.35867640f, 0.13192245f, -0.22921064f, -0.59511006f, -0.96381521f, 0.03063736f, 1.08455074f, 0.42606083f, 
    -0.00371594f, 0.76415145f, -0.60585845f, -0.77434200f, -0.47736341f, -0.36413780f, 0.06832580f, 0.17556004f, 
    -0.32238761f, -0.25928897f, -0.11572555f, -0.10628125f, 0.13797472f, 0.28062451f, 0.04489855f, 0.15930112f, 
    -0.21318813f, -0.05354709f, -0.04966229f, -0.10048747f, 0.06616112f, -0.19011930f, 0.18911090f, 0.09558749f, 
    -0.09070732f, 0.45486093f, -0.11972539f, -0.21214880f, -0.05298723f, -0.06461463f, 0.30064246f, 0.11286522f, 
    0.04917184f, -0.19540010f, -0.26697606f, -0.31363603f, -0.13803372f, 0.22961092f, 0.01655664f, 0.13787176f, 
    -0.21859145f, 0.15264398f, 0.14420016f, -0.01936966f, 0.08774073f, -0.80770057f, -0.50161105f, -0.62335497f, 
    -0.54463798f, -0.24029191f, 0.16802707f, -0.03036619f, -0.15667604f, 0.35348532f, 0.57886368f, 0.18072920f, 
    0.02423222f, -0.14942314f, -0.10702597f, -0.31315175f, -0.24089496f, 0.04965497f, -0.31561780f, -0.11329730f, 
    -0.14610820f, -0.51540613f, -0.04956549f, -0.33880559f, -0.31030020f, -0.16924779f, 0.88965940f, 0.78265762f, 
    -0.18811613f, -0.48427954f, -0.55805910f, 0.29536200f, -0.39942747f, 0.09524994f, 0.02535272f, -0.70047086f, 
    -0.11701107f, -0.07219747f, 0.11127178f, -0.11919397f, 0.22449552f, 0.13699526f, -0.01566718f, 0.21806829f, 
    0.03706800f, -0.01520330f, -0.21592289f, -0.22758415f, -0.29271653f, 0.15387531f, -0.11413492f, 0.28257516f, 
    0.12950598f, 0.26492816f, 0.24260440f, -0.64271951f, -0.61299837f, -0.18490170f, 0.14248316f, -0.01072826f, 
    -0.24394363f, 0.25771013f, -0.14712989f, -0.31149006f, -0.10509545f, 0.13251595f, -0.39307222f, -0.22007968f, 
    -0.09330696f, 0.04430605f, -0.39536139f, -0.17515363f, -0.04521276f, -0.30176878f, -0.35839245f, -0.14038593f, 
    1.24762022f, -0.67092109f, -0.80401754f, -0.23984079f, -0.64398468f, 0.90346456f, 0.65089577f, 0.10888185f, 
    -0.16551383f, 0.09537306f, -0.18308726f, 0.29289201f, -0.29186076f, -0.02220277f, -0.12739268f, 0.08644991f, 
    0.00411012f, 0.00616280f, 0.06489494f, -0.11255609f, 0.06816915f, 0.00470796f, 0.04421728f, -0.08087739f, 
    -0.03411448f, -0.14775626f, 0.28005525f, 0.32660595f, -0.34966844f, -0.05600244f, 0.24649037f, 0.19274177f, 
    -0.38838872f, -0.60099983f, -0.12903930f, -0.02178948f, -0.09080034f, 0.09312575f, -0.19767196f, -0.34253693f, 
    0.00006795f, 0.11750025f, -0.00248982f, -0.33620495f, -0.46993056f, 0.08488387f, -0.28154489f, 0.03087138f, 
    -0.12897585f, -0.20596616f, 0.48636267f, 0.06026728f, 0.03346007f, -0.04015778f, -0.02652046f, -0.10395914f, 
    -0.00610018f, 0.03317986f, 0.22012648f, 0.19236234f, -0.04625225f, 0.22401184f, 0.07160718f, -0.01270948f, 
    0.13718139f, 0.07747340f, 0.17723922f, 0.08175457f, 0.07337263f, 0.21582703f, 0.10973459f, -0.00720334f, 
    0.09293669f, 0.06759317f, -0.12976104f, -0.05077992f, 0.02106736f, 0.22493844f, -0.16203906f, 0.22966342f, 
    0.16471355f, 0.21739197f, 0.03888290f, -0.07344034f, -0.22085564f, 0.08020479f, -0.03452490f, 0.30639017f, 
    -0.12066586f, -0.23011883f, 0.02219439f, -0.15751645f, -0.12179147f, -0.10266037f, -0.18228306f, -0.05926888f, 
    -0.16461086f, -0.30111465f, -0.22412254f, -0.10744702f, -0.10192656f, -0.30963743f, -0.25715211f, -0.30921188f, 
    0.07965633f, 0.36529988f, 0.17097522f, -0.19769707f, -0.26046360f, 0.50943881f, 0.09648450f, 0.00663968f, 
    0.18850958f, -0.18120998f, -0.13021414f, -0.41544178f, -0.37529618f, 0.18047805f, 0.19105181f, -0.15121175f, 
    -0.08181913f, 0.28512326f, -0.00088691f, 0.28237179f, 0.13781604f, 0.23968498f, -0.15749881f, 0.28412372f, 
    0.07611463f, 0.11794630f, 0.33904603f, 0.24160928f, -0.19018862f, 0.25895169f, 0.22462462f, 0.13223524f, 
    0.05720096f, 0.11336143f, -0.29714444f, 0.04156219f, -0.18314017f, 0.01872063f, 0.04139475f, 0.02657057f, 
    -0.09043257f, 0.18895909f, 0.25839341f, 0.13740794f, -0.17328164f, -0.19752298f, 0.22975130f, 0.22103731f, 
    -0.09862918f, 0.15064828f, -0.57125062f, 0.16522835f, 0.05315214f, -0.22184524f, -0.06491708f, 0.08277880f, 
    0.16052136f, -0.25379547f, -0.18293472f, -0.32765946f, 0.16862975f, 0.14897865f, -0.24675703f, 0.10685410f, 
    0.15175484f, -0.34899378f, -0.12391301f, -0.08062178f, -0.16988505f, -0.37204632f, -0.44698817f, 0.25176844f, 
    0.01980998f, -0.78958607f, -0.75695705f, -0.70225966f, 0.48625886f, 0.18390937f, 0.37982166f, -0.14265049f, 
    -0.08063489f, 0.35475099f, 0.29301813f, 0.33234507f, 0.32457712f, -0.13976836f, -0.03458359f, -0.09308539f, 
    -0.32932690f, 0.13080661f, -0.25714785f, 0.08534068f, -0.25786987f, -0.08329684f, 0.02045090f, 0.31762019f, 
    0.90097207f, -0.18800330f, -0.25372583f, 0.29206085f, -0.48769513f, 0.31042027f, 0.23766764f, 0.30553260f, 
    -0.49607265f, -0.01711477f, -0.30936956f, 0.32799855f, -0.02392396f, -0.24039921f, -0.19887947f, -0.21477167f, 
    0.04856336f, 0.17177923f, -0.24254702f, 0.20743933f, 0.07576222f, -0.26883477f, -0.15160552f, 0.27668104f, 
    0.10621849f, -0.45840558f, -0.43430537f, -0.30992374f, -0.41049519f, -0.00898032f, 0.22896066f, -0.32051501f, 
    -0.62787020f, -0.54007614f, 0.06906947f, -0.12099235f, -0.10197222f, 0.03122122f, -0.02219151f, -0.09130900f, 
    0.10164417f, -0.14825642f, -0.30747932f, -0.18354777f, -0.37775564f, -0.04228793f, -0.29599553f, -0.11107897f, 
    -0.25819060f, 0.05709511f, 0.48122999f, -0.05926523f, -0.15307815f, 0.05221690f, -0.45543268f, 0.04010575f, 
    0.18321985f, 0.05164998f, -0.08203396f, -0.17785023f, -0.12577252f, 0.00380600f, 0.14643753f, -0.25632000f, 
    -0.15450649f, -0.07908089f, -0.06432776f, 0.00023551f, -0.39326060f, -0.37900850f, -0.51138759f, -0.16444121f, 
    0.07724871f, -0.08339909f, -0.38836381f, -0.80474579f, 0.57110763f, 0.46952769f, -0.51989502f, 0.00891773f, 
    0.22082205f, 0.14983197f, -0.14704821f, -0.16715632f, 0.08180533f, 0.28611609f, -0.39079630f, -0.17590423f, 
    -0.03848129f, -0.31473783f, -0.00178949f, 0.09998182f, -0.28289557f, -0.01587519f, -0.10924210f, -0.06267106f, 
    -0.20158175f, -0.25149018f, -0.21796808f, -0.67495966f, 0.56583184f, -0.68731511f, -0.06914203f, 0.43683451f, 
    0.43094581f, 0.16066229f, -0.53794825f, -0.52402878f, 0.33091417f, 0.05648050f, -0.16124803f, 0.12716676f, 
    0.18223296f, 0.14313403f, -0.33232009f, 0.01312701f, -0.20967314f, 0.01140010f, 0.02307075f, -0.07182197f, 
    -0.20397034f, 0.15654287f, -0.10356393f, -0.06827841f, 0.02211682f, -0.47254020f, -0.22605848f, -0.57567716f, 
    0.28404325f, 0.09331255f, -0.21884003f, -0.39187905f, -0.34418640f, 0.31312501f, -0.26486701f, 0.16147637f, 
    0.43644226f, 0.33750448f, -0.02497215f, -0.07586375f, 0.23571640f, -0.11047982f, -0.08294243f, -0.42119765f, 
    0.07308736f, -0.10903404f, -0.23495686f, 0.16259244f, -0.03997221f, 0.04606490f, -0.28070182f, -0.77783686f, 
    0.21992552f, 0.35909122f, 0.01818292f, -0.59336168f, -0.98936594f, -0.88503861f, -0.75388235f, -0.18064807f, 
    0.58187109f, -0.08861722f, 0.57098734f, 0.05348437f, 0.35617259f, -0.24445049f, -0.10611888f, -0.02560302f, 
    -0.35004321f, -0.26094130f, 0.11336574f, -0.19678803f, -0.11916375f, -0.00716465f, 0.12064499f, 0.13874876f, 
    0.30202225f, 0.12351844f, -0.04588392f, -0.41823351f, -0.12442717f, 0.21461859f, -0.07147546f, 0.00962260f, 
    -0.12157124f, 0.07830626f, -0.08550439f, 0.39569667f, -0.34179547f, -0.25402600f, 0.21074739f, -0.02931532f, 
    -0.26148874f, 0.01133077f, 0.13512896f, 0.12256172f, 0.03721537f, -0.04850176f, -0.33982250f, 0.33346337f, 
    0.00286199f, -0.36514610f, -0.51682895f, -0.49390596f, -0.40664241f, -0.44188958f, -0.64366066f, -0.47777551f, 
    -0.57962412f, -0.72675818f, 0.10891856f, -0.14405760f, 0.17748556f, 0.17765749f, 0.26725852f, 0.07709923f, 
    -0.00919025f, 0.04150174f, 0.17479168f, 0.18339837f, -0.08957666f, 0.12465522f, 0.23341204f, -0.02215604f, 
    -0.25119847f, 0.40115997f, 0.00893745f, -0.49475986f, -0.53824747f, -0.38972703f, 0.24306034f, 0.00291193f, 
    0.13360232f, -0.13115114f, -0.03385982f, 0.22699015f, 0.27523211f, 0.16735132f, -0.14027621f, -0.06955220f, 
    -0.58588225f, -0.12268000f, -0.01767266f, -0.22796836f, -0.30492824f, 0.12213895f, 0.19756252f, -0.04870724f, 
    0.30916485f, 0.43551454f, 0.27203038f, 0.28640217f, 0.28545293f, 0.11945982f, -0.28292999f, -0.22020957f, 
    -0.09253519f, 0.01952051f, -0.45108071f, -0.41086254f, -0.15519506f, 0.33160007f, 0.15864924f, -0.03785232f, 
    0.15826283f, -0.14150883f, 0.05086114f, 0.01246054f, 0.24541061f, -0.09314235f, 0.22022793f, 0.02267040f, 
    -0.07321712f, -0.19653945f, 0.30551031f, -0.45250100f, -0.93010640f, -0.46478200f, 0.37960976f, 0.56618571f, 
    0.41992557f, 0.27397531f, -0.03499590f, -0.19713080f, 0.20556211f, 0.36208186f, -0.39957526f, -0.27665609f, 
    -0.04028066f, 0.26432398f, 0.06205465f, -0.14591715f, 0.15213242f, 0.23934913f, -0.27154008f, -0.00541059f, 
    -0.13459383f, 0.05660161f, -0.13215843f, 0.19128017f, 0.07549320f, 0.42030546f, 0.41395336f, 0.14539452f, 
    0.17289053f, -0.40867841f, -0.26704246f, -0.19279951f, -0.03177790f, -0.23957779f, 0.01685923f, -0.09662396f, 
    -0.36203131f, -0.00173983f, 0.44268060f, 0.00866137f, 0.63158798f, 0.10207700f, -0.09641293f, -0.02943643f, 
    -0.24864642f, -0.04831534f, -0.24030741f, -0.45864406f, -0.31880474f, -0.57189006f, 0.33256960f, 0.05886251f, 
    0.10199907f, 0.18272536f, 0.09077466f, 0.17007898f, -0.38807622f, -0.11352386f, 0.45097500f, 0.12994581f, 
    0.36546835f, -0.28885496f, -0.14922875f, -0.43101189f, 0.05299091f, -0.03970295f, 0.06284393f, 0.27359346f, 
    -0.09769929f, -0.16184440f, 0.27778488f, -0.08356307f, -0.05533508f, -0.24853794f, 0.01563424f, -0.83391446f, 
    -0.39807647f, -0.33264041f, -0.22226119f, -0.06311054f, 0.14313541f, 0.44253045f, 0.27177852f, 0.24595411f, 
    0.01893846f, 0.23298907f, 0.07923272f, -0.11510719f, -0.18107980f, -0.06733283f, -0.01679455f, 0.03233313f, 
    -0.14186625f, 0.13975878f, 0.01412363f, 0.07156035f, 0.10637902f, -0.02450176f, -0.10131725f, -0.92767268f, 
    0.40063271f, -0.45036849f, -0.68139720f, -0.04529114f, 0.25078166f, -0.13801421f, -0.17271018f, -0.14723039f, 
    -0.01018862f, 0.09455200f, 0.35659924f, 0.25749773f, -0.18244344f, 0.07310495f, 0.03719999f, -0.03737330f, 
    -0.33165634f, -0.28060004f, -0.23537435f, 0.37377846f, 0.29502934f, 0.19866721f, 0.06390794f, -0.16408105f, 
    -0.69943434f, -0.15216336f, -0.04991993f, 0.30709592f, 0.39770037f, -0.34667426f, 0.19188172f, -0.42845365f, 
    0.37446430f, 0.57764006f, -0.02998561f, 0.03540155f, -0.07070604f, -0.08952695f, 0.18298221f, -0.17977980f, 
    -0.17460401f, 0.06865908f, 0.11960043f, -0.01433944f, 0.10278461f, -0.32900035f, 0.14156154f, 0.18724249f, 
    -0.17673293f, 0.08450212f, 0.62380505f, 0.18335985f, -0.16597162f, -0.04458154f, -0.06269363f, -0.07745858f, 
    -0.02044888f, 0.22612524f, -0.19394761f, -0.07150810f, -0.18696865f, -0.21419626f, 0.13403116f, -0.19357762f, 
    0.26471543f, 0.21432582f, -0.06741703f, -0.33356157f, 0.15876487f, 0.07604731f, 0.05789288f, -0.16144851f, 
    -0.37666738f, -0.26226029f, -1.11643457f, 0.28100005f, 0.40063044f, 0.20288064f, 0.17065173f, -0.03935219f, 
    -0.06826030f, 0.19598012f, 0.05152614f, -0.34476259f, -0.34858835f, -0.24742156f, 0.19759199f, 0.12839156f, 
    -0.20281200f, 0.19986311f, -0.28979042f, -0.18325421f, 0.04353059f, 0.17113549f, -0.31996408f, -0.20274483f, 
    0.03586901f, -0.25301880f, -0.55155647f, -0.56056774f, 0.10594092f, -0.12997431f, 0.40945941f, 0.17368130f, 
    0.29962468f, -0.58349442f, -0.15401483f, 0.30758047f, 0.11947268f, -0.33358464f, 0.03263812f, -0.25586888f, 
    -0.21663159f, 0.37263155f, -0.09138826f, 0.04703043f, 0.40381256f, -0.03394292f, 0.18019955f, -0.37969127f, 
    0.28278306f, 0.21814610f, -0.04889444f, -0.26289600f, 0.63058680f, -0.32645613f, -0.32055366f, -0.40053585f, 
    -0.21089737f, -0.16906664f, -0.03061030f, -0.24343610f, -0.01866928f, 0.12565446f, 0.09991948f, -0.05029269f, 
    0.19455667f, 0.25406066f, 0.02951272f, 0.38250208f, 0.22188830f, -0.06012711f, -0.32183650f, -0.14578256f, 
    -0.23732613f, -0.21808083f, -0.09731635f, 0.05851986f, 0.33260071f, -0.11094477f, 0.32876948f, 0.17303450f, 
    -0.30251437f, -0.14426771f, 0.00684987f, 0.12957473f, 0.13435484f, 0.17458634f, 0.02123727f, -0.03972825f, 
    0.16931485f, 0.26430410f, -0.25596055f, -0.44729623f, 0.17450210f, -0.24379648f, -0.03206904f, 0.18174294f, 
    -0.15422185f, -0.16098829f, 0.39430487f, 0.19374289f, 0.14453067f, -0.39535737f, -1.18562734f, 0.41346672f, 
    -0.03078208f, -1.35893071f, -1.03274632f, 0.38548729f, -0.00818899f, 0.48375535f, 0.47536379f, 0.44164753f, 
    -0.30505648f, -0.45187581f, 0.09945548f, -0.45465338f, -0.16997150f, 0.09520487f, -0.12942141f, 0.01686240f, 
    0.04406144f, -0.06930526f, -0.08484381f, 0.17329316f, 0.09357892f, 0.00004869f, 0.10671191f, -0.51388329f, 
    -0.35883954f, 0.35726911f, 0.68548638f, 0.03740395f, -0.15476251f, -0.50222760f, 0.09468344f, -0.44590607f, 
    -0.39185739f, -0.01376358f, 0.17738746f, 0.00058561f, -0.19752169f, -0.29153186f, 0.19387552f, -0.02685684f, 
    0.16197009f, -0.18607198f, 0.15122537f, 0.00934451f, -0.10477532f, 0.13074328f, 0.19909523f, -0.13435370f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00387499f, 0.13898264f, 0.14584394f, 0.07099596f, 0.28317121f, 0.26742488f, 0.05446365f, 0.19563998f, 
    0.22428347f, -0.03720544f, -0.55691463f, 0.10540990f, 0.16748452f, -0.12752338f, -0.00351738f, -0.55971014f, 
    0.17043480f, 0.04747738f, -0.03271577f, 0.18385673f, -0.06220248f, 0.26291946f, 0.05394831f, 0.13313837f, 
    0.06343235f, 0.33101612f, 0.20604865f, -0.01657141f, 0.21786512f, -0.09973016f, 0.09181102f, 0.01215668f, 
    0.23252477f, 0.09976796f, -0.02995548f, -0.08106264f, -0.00958035f, -0.03968039f, 0.04856227f, 0.44551080f, 
    0.17963973f, -0.03142884f, -0.15676777f, 0.03681241f, 0.36348164f, 0.40940347f, 0.29628757f, 0.21170013f, 
    -0.00502629f, 0.29352540f, 0.05841096f, 0.23537180f, 0.06996601f, 0.19759731f, 0.15488178f, -0.10801315f, 
    0.41228026f, 0.05930369f, -0.04044751f, -0.03288286f, 0.28160283f, 0.30603689f, -0.12658778f, 0.03884736f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14561187f, -0.00809005f, 0.04494553f, -0.20758866f, -0.16821405f, 0.00870567f, 0.01103638f, 0.05513233f, 
    -0.00557778f, 0.06240942f, -0.00100062f, -0.02723024f, 0.30212060f, -0.06310546f, -0.34941289f, -0.00383358f, 
    0.04034398f, 0.02666171f, 0.04580653f, -0.23934405f, -0.12575969f, -0.15792868f, -0.00620867f, 0.00681670f, 
    0.13088211f, -0.10274395f, -0.48486689f, 0.06872284f, 0.10846072f, 0.04692460f, -0.17052138f, 0.00168766f, 
    0.03871508f, -0.06341406f, -0.07784135f, -0.04568378f, -0.45047608f, 0.18120590f, -0.40951085f, 0.12438346f, 
    -0.02033127f, 0.00034281f, 0.07691439f, 0.05210137f, -0.06727688f, 0.11005543f, 0.16885434f, -0.07302485f, 
    0.14909065f, 0.13465111f, -0.00627517f, -0.12015265f, 0.02396367f, 0.06052998f, 0.06290423f, -0.04400077f, 
    -0.03836469f, -0.04415768f, -0.09443402f, -0.09360282f, -0.13841401f, -0.05316907f, -0.07698377f, 0.07687373f, 
    -0.00613389f, -0.02557445f, 0.01684368f, -0.02208199f, -0.15267837f, 0.05236175f, -0.05992467f, -0.09587214f, 
    0.04608444f, 0.05793695f, 0.10875090f, -0.02956208f, 0.00013430f, -0.00453926f, -0.12776041f, -0.02282731f, 
    0.02441294f, -0.06398779f, 0.01608447f, -0.00586076f, 0.08619982f, 0.17473796f, 0.07026579f, -0.12354148f, 
    0.06112093f, 0.08633741f, -0.05264136f, -0.00277871f, 0.04264038f, -0.01878447f, 0.03848058f, -0.01580224f, 
    -0.15429342f, -0.66385555f, -0.18286128f, 0.10427918f, 0.05825210f, -0.01198016f, -0.08737457f, -0.20585631f, 
    -0.08920703f, -0.03083573f, -0.13451666f, -0.08888704f, 0.04173138f, 0.16644153f, -0.08858672f, -0.37128004f, 
    -0.03239677f, -0.07285210f, -0.02097069f, 0.06566939f, 0.00418432f, 0.02655555f, 0.00249066f, -0.02688120f, 
    0.37705654f, 0.24294285f, -0.12838867f, -0.04561152f, 0.16001166f, 0.20048985f, 0.18260266f, 0.11199199f, 
    -0.05213314f, -0.08257424f, -0.04437550f, -0.03727750f, 0.13672909f, 0.07267866f, 0.01865165f, 0.03243992f, 
    0.03977492f, 0.07021596f, -0.00942514f, -0.06322405f, -0.02071845f, -0.01142781f, -0.03440621f, 0.06501699f, 
    -0.40816951f, 0.21786091f, 0.17040855f, -0.37092197f, 0.00824814f, -0.05777360f, -0.04401487f, -0.02579731f, 
    -0.05326324f, -0.11368052f, -0.00046014f, 0.06682479f, 0.20717065f, 0.18917009f, -0.03764348f, -0.05410114f, 
    0.09888436f, 0.11441141f, -0.00157135f, -0.16336335f, -0.02474884f, -0.05902741f, -0.04874250f, -0.05611027f, 
    0.29963005f, 0.29050922f, -0.18125099f, -0.05781391f, 0.03606500f, 0.09139089f, 0.00879414f, -0.02859513f, 
    -0.05114230f, -0.07801271f, -0.03121002f, -0.05640205f, 0.39787179f, 0.23638968f, -0.11704583f, -0.10237753f, 
    0.19197433f, 0.19377474f, 0.15202641f, 0.02042973f, -0.02295926f, -0.04373727f, 0.00275150f, -0.00585050f, 
    -0.11332236f, 0.04720840f, -0.00322824f, 0.00173888f, 0.09913972f, -0.13962859f, -0.11392811f, -0.04356994f, 
    -0.03172410f, 0.01327250f, -0.03279180f, -0.04238639f, 0.01340728f, 0.02495966f, 0.01256435f, 0.00136806f, 
    -0.12003899f, -0.16515179f, -0.10889900f, -0.27653474f, -0.01862927f, 0.04936806f, 0.02443705f, 0.05891751f, 
    0.26370457f, 0.15058474f, 0.02406685f, 0.03089686f, 0.13820691f, 0.21793525f, 0.12250632f, -0.08726092f, 
    -0.05763445f, 0.15580915f, 0.07651842f, -0.01009441f, -0.35199401f, -0.24809138f, -0.48554903f, 0.06069030f, 
    0.01199385f, -0.00140285f, 0.00243227f, 0.05022999f, 0.01590327f, 0.00138988f, 0.08060062f, -0.04894582f, 
    0.24740084f, 0.11925433f, 0.09007721f, -0.13470566f, 0.05271224f, 0.18418615f, -0.17244850f, -0.04681456f, 
    0.02278229f, 0.04628078f, 0.05877201f, 0.07716623f, -0.05456252f, -0.10932072f, 0.07003064f, -0.17160468f, 
    -0.11413921f, -0.10160480f, -0.01246769f, 0.05121540f, -0.16340390f, 0.00874158f, -0.15083292f, -0.16226353f, 
    -0.16670907f, 0.02045715f, 0.09894306f, -0.14628981f, -0.01819210f, -0.04032532f, 0.02718654f, 0.02810566f, 
    0.05818859f, -0.07339139f, 0.03552146f, -0.02681906f, -0.17101526f, -0.17431450f, 0.03705218f, 0.02232237f, 
    -0.02209280f, 0.00948549f, -0.03308458f, 0.07682969f, -0.06039345f, 0.00897862f, -0.03813333f, 0.09383945f, 
    -0.02710696f, -0.10930606f, -0.23800059f, -0.11903680f, -0.03531124f, -0.11915059f, -0.11206733f, -0.08666048f, 
    -0.07723645f, 0.01054202f, 0.00004909f, 0.02193162f, -0.24008228f, -0.04608924f, 0.24790041f, -0.07950065f, 
    -0.12496256f, 0.01013445f, -0.06564862f, -0.01921100f, 0.01375538f, 0.04867161f, 0.00045662f, -0.04240714f, 
    -0.70641011f, -0.08801799f, 0.15611444f, -0.03613548f, -0.07251387f, 0.06923466f, 0.09139254f, 0.04499253f, 
    -0.03530635f, -0.15962929f, -0.01567346f, -0.01574776f, 0.54027694f, 0.19079724f, 0.07484999f, -0.25644055f, 
    0.15056704f, -0.19873530f, 0.08588412f, -0.07992904f, -0.04777882f, -0.06210903f, -0.00070907f, 0.05002365f, 
    -0.07541949f, -0.06885605f, -0.01723980f, -0.05600978f, -0.02475933f, 0.02342121f, 0.04828324f, 0.04428879f, 
    -0.02857668f, -0.00755613f, -0.02147315f, 0.01314157f, 0.23079182f, 0.13283864f, -0.06139237f, -0.06837369f, 
    0.06227280f, 0.12297329f, 0.00206841f, -0.18168445f, 0.05905797f, 0.20139073f, 0.06872812f, -0.03556729f, 
    0.00243330f, -0.14103761f, -0.32320860f, 0.12955183f, -0.03785081f, -0.11857661f, -0.12134387f, -0.06649707f, 
    -0.01288572f, 0.07234393f, -0.01378382f, 0.07247548f, -0.01719865f, -0.11081586f, 0.16990745f, -0.21383449f, 
    -0.06322748f, -0.03667659f, -0.12771547f, -0.05936732f, -0.02397047f, -0.06490635f, -0.00554669f, 0.15883432f, 
    0.00497428f, -0.32174346f, -0.59229487f, 0.11902449f, 0.07519023f, -0.04104519f, 0.00984050f, -0.09028502f, 
    0.00935952f, -0.08385620f, -0.18158749f, -0.14681259f, 0.08085369f, 0.17157574f, -0.36847690f, 0.07210385f, 
    -0.12998073f, -0.11574193f, -0.07158814f, 0.08420594f, -0.08160297f, -0.07961679f, 0.02833008f, 0.07707646f, 
    0.04587655f, 0.01417991f, 0.04011592f, 0.06841260f, -0.12168494f, -0.03055948f, 0.02638542f, 0.00799315f, 
    -0.24303994f, -0.20994401f, -0.04907290f, 0.00189850f, -0.36879224f, -0.18648595f, -0.45347854f, 0.07008288f, 
    0.00595626f, 0.01312806f, 0.03897072f, 0.05289740f, -0.00682275f, -0.02717796f, 0.01431391f, 0.07566320f, 
    0.09875551f, 0.04550434f, -0.09610462f, 0.06047440f, 0.02885489f, 0.06233841f, -0.03039226f, -0.05155715f, 
    0.06352706f, -0.18761945f, -0.14666508f, -0.01472004f, -0.02001733f, -0.02904728f, -0.00885839f, 0.00719803f, 
    0.03640942f, 0.01957890f, 0.06169757f, 0.03055998f, -0.05115833f, 0.00131194f, 0.07609906f, -0.04314366f, 
    -0.28978187f, -0.08740344f, -0.04256902f, 0.02372115f, 0.02353968f, 0.00097601f, 0.02075331f, 0.01488061f, 
    -0.21058507f, -0.08460353f, -0.01696405f, 0.14690460f, 0.10196991f, -0.07492746f, -0.30673987f, 0.01651553f, 
    0.12368884f, 0.01341702f, -0.13385604f, -0.09394790f, -0.12791322f, -0.03900629f, -0.07191030f, -0.07663199f, 
    -0.35413644f, -0.26574618f, -0.33999804f, 0.04342337f, 0.04220971f, 0.09641160f, -0.02334568f, -0.01061493f, 
    0.03244785f, -0.02679493f, -0.02573152f, 0.01261806f, 0.26253739f, 0.20625831f, -0.16473703f, -0.06126970f, 
    0.06995998f, 0.05799324f, 0.06303232f, -0.04994707f, -0.07460770f, -0.11954972f, -0.07115207f, -0.09044247f, 
    0.00352602f, -0.12613140f, -0.04116606f, 0.00854538f, -0.01561951f, -0.06081367f, 0.03544067f, 0.00652910f, 
    -0.02060232f, 0.03307125f, -0.08383210f, 0.20980626f, -0.20163207f, -0.16003788f, -0.29146963f, -0.00006086f, 
    -0.01633745f, 0.05163353f, -0.04283815f, 0.06273005f, -0.00991096f, 0.12219863f, 0.02296427f, 0.08672547f, 
    -0.67827481f, 0.14063103f, -0.05922172f, -0.02153387f, -0.02209835f, -0.00806718f, -0.00711283f, -0.04542177f, 
    -0.00266726f, -0.00840132f, -0.00944563f, -0.02373292f, 0.25078729f, 0.18554515f, -0.04953493f, -0.21769197f, 
    -0.14565021f, -0.12737936f, -0.00879640f, 0.01320423f, -0.03574158f, -0.05584749f, -0.01709211f, -0.05226292f, 
    0.18090770f, 0.19906689f, -0.00876290f, -0.35522014f, -0.01945720f, 0.11395832f, -0.03270273f, 0.08175907f, 
    0.00007383f, -0.01122883f, 0.00515628f, -0.06574901f, -0.12424065f, -0.13623184f, -0.13061962f, 0.03413300f, 
    0.01704143f, -0.07822043f, -0.00389732f, 0.00592864f, -0.04132434f, -0.00329375f, -0.07360871f, -0.03488048f, 
    0.33421865f, 0.06580106f, -0.11038703f, -0.13044986f, 0.09220177f, 0.07870618f, -0.02179195f, 0.09796996f, 
    -0.02774354f, 0.03877829f, 0.03900588f, 0.00661265f, 0.04841720f, -0.20274656f, -0.36079416f, 0.01785576f, 
    0.07722708f, 0.01883344f, -0.15014440f, -0.19265607f, -0.13404496f, -0.14578538f, -0.07448994f, -0.10344690f, 
    -0.00482209f, -0.03958004f, 0.04780138f, -0.00287831f, -0.01120481f, -0.05682973f, 0.06893928f, -0.10213032f, 
    -0.01328034f, 0.04533896f, 0.01318013f, -0.01894195f, 0.28470278f, -0.02137356f, -0.14467068f, -0.07051845f, 
    0.02072088f, 0.03244010f, 0.07417472f, -0.08645005f, -0.04852445f, -0.05985969f, -0.15565528f, 0.10044833f, 
    -0.17366111f, 0.04471477f, 0.15237054f, -0.06688273f, 0.02291325f, 0.04065052f, 0.00605368f, -0.03636636f, 
    0.02825551f, 0.03200407f, 0.05571282f, 0.09085812f, -0.10771824f, 0.10268001f, 0.03179145f, -0.06260997f, 
    -0.03445651f, -0.00176016f, 0.10113924f, -0.01626189f, -0.07509148f, -0.00134037f, -0.07411693f, -0.10250188f, 
    0.10832269f, -0.02293158f, 0.00605028f, 0.07383028f, 0.02789204f, -0.00431129f, 0.06981222f, 0.01486586f, 
    -0.12849534f, 0.03980369f, 0.02221303f, 0.07533343f, 0.18196876f, 0.11562400f, -0.09976722f, -0.09849727f, 
    0.00751200f, 0.21477048f, 0.02374470f, -0.04035377f, -0.05381694f, -0.07241602f, 0.00600173f, 0.00474941f, 
    -0.05471040f, 0.22306758f, 0.17134935f, -0.09763337f, -0.05582446f, 0.00785403f, 0.03399188f, -0.02492983f, 
    -0.02569224f, -0.11055941f, -0.08976982f, -0.10498224f, -0.22982244f, -0.10797633f, -0.06519312f, 0.14382435f, 
    0.04895904f, 0.03499624f, -0.04070554f, 0.00674760f, -0.06135344f, 0.02389857f, -0.11769743f, -0.02137029f, 
    0.05701217f, -0.09615571f, 0.07944030f, 0.04502816f, 0.01342859f, -0.01886576f, -0.01488839f, 0.03284606f, 
    0.02141379f, 0.00234973f, 0.11870255f, 0.01857454f, -0.23045565f, 0.25913453f, 0.13839906f, -0.23714843f, 
    -0.08312504f, -0.07550002f, 0.12013638f, 0.00765789f, -0.01369240f, 0.05849119f, -0.03605165f, -0.00513330f, 
    0.07462194f, 0.03076142f, -0.03245544f, -0.06405812f, 0.01141891f, -0.04916619f, 0.09160777f, -0.00504017f, 
    -0.24854000f, -0.00545541f, 0.02499742f, 0.03257907f, -0.57413465f, -0.33081019f, -0.23456757f, -0.12940839f, 
    0.00386940f, -0.09108362f, 0.01370212f, -0.02059845f, -0.05413328f, 0.02449426f, -0.04279628f, 0.20384903f, 
    -0.15639447f, -0.03531989f, 0.13569371f, -0.03356622f, -0.01216919f, 0.29546759f, 0.01345291f, 0.12246324f, 
    -0.00082840f, 0.03158766f, 0.00213883f, 0.02566363f, 0.23003747f, 0.06892380f, 0.09135532f, -0.30356237f, 
    -0.00403461f, -0.07770573f, -0.10060678f, 0.01783645f, -0.02329361f, -0.04266259f, 0.01148674f, 0.03646597f, 
    -0.06177476f, 0.01474421f, -0.13473575f, -0.24537554f, -0.07207231f, 0.07279912f, -0.14306922f, -0.01654085f, 
    -0.07367674f, -0.03012405f, 0.01506190f, 0.13126352f, -0.32084644f, -0.55878401f, 0.08902625f, 0.02302488f, 
    0.02355616f, 0.07770199f, 0.00976535f, 0.02028646f, 0.02168228f, 0.04858703f, 0.10565747f, -0.07626478f, 
    0.25897419f, -0.32051146f, -0.10270281f, -0.11921506f, -0.00831191f, 0.04688524f, 0.08138538f, -0.05581821f, 
    0.15235528f, 0.06438370f, 0.05935199f, -0.07466896f, 0.14906186f, -0.03918621f, 0.09446784f, 0.39877626f, 
    0.05746377f, -0.03194583f, 0.03358251f, 0.00248525f, -0.06050457f, 0.00563716f, -0.13579395f, 0.24519646f, 
    -0.02535671f, 0.31637749f, -0.22419593f, -0.11215630f, -0.04713678f, 0.04835635f, 0.01173336f, 0.08435839f, 
    -0.00370183f, 0.04601979f, -0.11875856f, 0.00144103f, 0.36065242f, 0.06845111f, -0.00127408f, 0.05445887f, 
    -0.06206913f, 0.02552177f, -0.05933791f, 0.02788129f, 0.07322495f, -0.00602224f, -0.06398155f, 0.11600994f, 
    -0.11524975f, -0.00612936f, 0.00825999f, -0.05018130f, -0.08468401f, -0.07427406f, -0.00592273f, 0.01876444f, 
    -0.01159891f, -0.03857200f, 0.04092659f, 0.00751579f, -0.02876480f, 0.02001124f, 0.01517907f, -0.17040229f, 
    0.02337574f, -0.00606279f, -0.11095424f, -0.05123747f, -0.01085604f, -0.01896497f, -0.06816508f, 0.01189129f, 
    0.35422310f, -0.06045161f, 0.13602945f, -0.19481842f, -0.01845984f, 0.04078853f, -0.09716193f, -0.00301643f, 
    -0.05034437f, 0.10402565f, -0.12274391f, -0.02361897f, -0.26004893f, 0.07526233f, -0.21165676f, -0.33109325f, 
    0.08843365f, -0.03325076f, 0.00654659f, -0.07136822f, -0.00803675f, 0.02714201f, -0.00330852f, -0.02841188f, 
    0.16983031f, 0.03627067f, 0.10161620f, 0.18516123f, 0.00831304f, -0.13455345f, -0.02897945f, -0.18553254f, 
    0.04282746f, 0.03269173f, -0.02685374f, 0.03331391f, -0.08985357f, -0.13347450f, -0.02962920f, 0.00620134f, 
    0.02488514f, 0.14726281f, 0.11684982f, -0.07383047f, 0.24147472f, -0.08935262f, 0.06480004f, -0.02850874f, 
    -0.32236758f, 0.10814817f, 0.26527157f, -0.13210215f, 0.09292591f, -0.04638037f, -0.02394417f, -0.03064306f, 
    -0.03357285f, -0.04168151f, 0.00106095f, 0.04373133f, 0.02079442f, 0.18660599f, 0.14939822f, 0.14657629f, 
    0.02117532f, -0.02619301f, 0.06519520f, 0.10899901f, -0.09819745f, 0.04363707f, -0.02276206f, 0.02886584f, 
    0.13520248f, 0.02339070f, 0.10148060f, 0.12933509f, 0.21505211f, 0.07980982f, -0.25256974f, -0.00228218f, 
    -0.00628896f, 0.03086378f, -0.01795371f, 0.01370066f, 0.30999425f, 0.16068587f, 0.18416432f, 0.26977056f, 
    -0.12663262f, 0.01752547f, -0.15380800f, 0.01308185f, 0.00569955f, -0.04944440f, 0.00639674f, 0.03942483f, 
    0.34171057f, -0.01708613f, -0.15169476f, 0.02637076f, -0.20062877f, 0.00320163f, 0.16973858f, -0.20173843f, 
    -0.07062328f, 0.00509239f, -0.00299963f, -0.04341984f, 0.00909203f, 0.11671766f, -0.04842532f, 0.02704899f, 
    -0.16424572f, 0.13244039f, 0.11036602f, -0.02432539f, -0.14152823f, 0.01360291f, 0.01992328f, 0.01485737f, 
    -0.16802989f, -0.05011940f, -0.11505073f, 0.00474798f, -0.02632110f, 0.02538678f, -0.01786725f, -0.14354941f, 
    -0.08468217f, -0.18425535f, -0.04085972f, -0.04811674f, 0.51784396f, 0.13111785f, 0.22648317f, -0.01458181f, 
    -0.00834342f, -0.01857422f, -0.03180851f, 0.01043756f, 0.01716832f, -0.01029390f, -0.09155691f, 0.09489520f, 
    0.14770195f, 0.12998216f, 0.05162808f, -0.24259941f, 0.00852540f, -0.07006675f, -0.10101649f, 0.06919830f, 
    -0.06107739f, -0.01499251f, 0.00723459f, -0.09208900f, -0.05711265f, 0.10358515f, 0.01374352f, 0.00648929f, 
    0.06333286f, 0.05498220f, 0.14386147f, -0.15326780f, 0.10800460f, -0.03681974f, -0.09985493f, 0.04604536f, 
    -0.13594979f, 0.06711743f, -0.02094910f, -0.02207104f, -0.04457654f, 0.00362344f, 0.03811156f, 0.02794238f, 
    0.01645870f, 0.01415739f, -0.05715450f, 0.05047764f, 0.17247573f, -0.09465568f, 0.26353568f, -0.01215828f, 
    0.04317997f, -0.01929705f, 0.05058098f, -0.21508873f, 0.00614094f, -0.04971584f, -0.05185639f, 0.10507001f, 
    0.58140951f, -0.36062172f, 0.16903466f, -0.07079358f, -0.11729423f, -0.02492945f, -0.03420963f, 0.17751493f, 
    -0.00554684f, -0.04964771f, 0.00369233f, -0.14034189f, -0.34504122f, 0.20102106f, 0.14070162f, -0.12771621f, 
    0.06329690f, 0.06640377f, 0.10503485f, -0.09804726f, 0.08465809f, -0.06229426f, 0.05891848f, 0.09045072f, 
    -0.78853881f, -0.41029575f, -0.00526933f, -0.06337731f, 0.09221884f, -0.04018768f, 0.07244851f, -0.06441730f, 
    0.15553577f, 0.25922090f, -0.13049901f, -0.12089965f, -0.06506018f, -0.17626071f, -0.09101330f, -0.25127304f, 
    -0.07997990f, 0.00173516f, 0.07418708f, 0.01436775f, 0.11835013f, -0.00750839f, 0.02853961f, 0.04063710f, 
    0.10180645f, 0.08855404f, -0.01962996f, 0.00446529f, 0.01714425f, -0.00003773f, -0.07168887f, 0.04075242f, 
    -0.02327848f, 0.06854089f, -0.01968112f, 0.04875518f, 0.02855923f, 0.02236293f, -0.13078825f, 0.06445491f, 
    0.01434874f, 0.09553773f, -0.07650993f, -0.10651574f, -0.19478831f, -0.22830646f, -0.25404271f, -0.17701082f, 
    0.26040697f, -0.11553910f, 0.12768391f, -0.20950720f, -0.00276625f, -0.02986129f, 0.10265516f, -0.24836919f, 
    -0.02585586f, 0.11342923f, -0.09740593f, 0.03132840f, -0.01369457f, -0.04731507f, 0.03795195f, -0.65795106f, 
    -0.00842670f, -0.00661872f, 0.00834220f, 0.09991006f, 0.00356586f, -0.01143326f, 0.01472280f, -0.19475479f, 
    0.97642767f, -0.11693016f, -0.36522612f, -0.04214960f, -0.05744329f, -0.05281416f, -0.02886318f, -0.01994210f, 
    0.03262968f, 0.00516083f, 0.02606317f, 0.02998707f, 0.10429732f, -0.43523085f, -0.12601863f, -0.09948419f, 
    0.03988750f, 0.02599729f, -0.07445861f, 0.02934799f, 0.01540790f, -0.00043194f, -0.17883725f, 0.10230387f, 
    0.05235115f, 0.05739471f, 0.06596910f, 0.00515331f, 0.02994527f, 0.00400646f, 0.05894883f, 0.00073283f, 
    0.03303788f, 0.01438144f, -0.05007290f, -0.01320590f, 0.16601965f, 0.00802534f, 0.10196382f, 0.10847663f, 
    0.01650312f, -0.01888698f, -0.02208971f, -0.02382521f, -0.12125708f, -0.12252568f, -0.22263858f, -0.03601857f, 
    0.06670901f, 0.05530823f, -0.01215308f, -0.07481543f, -0.00416868f, 0.00605986f, 0.02499760f, 0.06659306f, 
    -0.03064609f, 0.01183570f, -0.01579175f, -0.01596936f, 0.14994477f, 0.08166546f, 0.08151055f, 0.14039743f, 
    -0.00977193f, -0.02943428f, 0.00784791f, 0.04415651f, -0.06792009f, 0.04340965f, -0.06042221f, 0.01870370f, 
    0.03048966f, 0.07238585f, 0.10083348f, -0.01995323f, -0.00453658f, 0.05237951f, -0.03392648f, 0.00045206f, 
    -0.17107274f, -0.15301983f, 0.10971496f, -0.16604725f, 0.01260766f, -0.40362358f, -0.20924269f, -0.31366792f, 
    0.05144707f, 0.09825315f, 0.04817187f, -0.04409591f, 0.07533922f, 0.08192097f, 0.03285519f, 0.06521288f, 
    0.88114947f, 0.07619756f, 0.02279856f, -0.04730766f, -0.06269967f, -0.03906747f, 0.04031003f, -0.02995127f, 
    0.04021550f, -0.09571256f, -0.04340752f, 0.14979206f, 0.09900215f, -0.03872255f, 0.01783885f, 0.21983512f, 
    0.09821767f, 0.00877196f, 0.05083276f, 0.03918871f, 0.05204241f, -0.00900448f, 0.00968210f, -0.04694689f, 
    0.29996988f, -0.17590567f, 0.10690627f, -0.24034093f, -0.04249103f, 0.04160868f, 0.01116622f, 0.03995734f, 
    -0.10188898f, -0.07823742f, -0.25604877f, -0.13435623f, 0.16830741f, -0.07085253f, -0.03536876f, -0.03675443f, 
    0.02872878f, -0.00735101f, -0.12155920f, 0.04437422f, -0.36288640f, -0.09892188f, -0.19275448f, -0.26315472f, 
    0.10884786f, 0.21997806f, -0.11464416f, 0.15927140f, 0.06449111f, -0.03214994f, -0.00708645f, -0.02518789f, 
    -0.01890663f, 0.07373480f, -0.02202595f, 0.09417593f, -0.34045887f, -0.00835638f, -0.28283015f, 0.06353914f, 
    0.19653031f, 0.00496426f, 0.04278846f, 0.03226897f, 0.07637080f, -0.00171337f, 0.02995074f, 0.02767485f, 
    -0.54492128f, -0.00309554f, -0.30944157f, -0.11512543f, -0.08010524f, -0.04502073f, 0.11871924f, 0.13784340f, 
    -0.01230009f, -0.11513233f, 0.06220141f, 0.04319464f, 0.13172109f, 0.09827600f, 0.07289392f, -0.07045653f, 
    -0.09246884f, 0.04783422f, -0.00585097f, -0.03132586f, -0.08456779f, -0.05545153f, -0.00432502f, -0.00454682f, 
    -0.02740992f, 0.05182353f, 0.21989559f, 0.01381547f, -0.14635116f, -0.06588569f, -0.10947936f, -0.21522486f, 
    -0.06192012f, -0.01669996f, -0.00429127f, -0.01473367f, 0.04302925f, -0.18807881f, -0.12382501f, -0.16244695f, 
    0.06480755f, 0.12414654f, 0.10384624f, 0.13365023f, 0.08026468f, 0.16742973f, -0.05002159f, 0.05891977f, 
    0.08325741f, 0.06082094f, -0.03399225f, -0.05281280f, -0.09391392f, 0.01998889f, -0.01741692f, -0.21040453f, 
    -0.05401045f, -0.05985036f, -0.01602416f, 0.03778187f, 0.11795278f, -0.04090108f, 0.08458848f, 0.01863363f, 
    -0.02826114f, 0.01443511f, -0.02199092f, -0.02120785f, 0.15914224f, -0.10722037f, 0.00448241f, -0.04691625f, 
    -0.06230080f, 0.04822645f, 0.10326570f, -0.03950562f, 0.06586516f, -0.04017455f, 0.02269602f, 0.08803983f, 
    0.13698457f, 0.13819906f, -0.15842743f, 0.08239184f, 0.10154320f, 0.06561359f, 0.07238343f, 0.09100984f, 
    -0.12253382f, 0.13444430f, -0.02825360f, 0.02753100f, -0.05615266f, -0.25875393f, -0.06157360f, 0.15682241f, 
    0.07139488f, -0.02906517f, -0.05127758f, -0.05038309f, -0.05374453f, -0.00304193f, 0.00464253f, -0.05213744f, 
    0.00041742f, -0.04246886f, -0.09132227f, 0.03780127f, -0.22282949f, -0.01057628f, 0.12789458f, 0.18537056f, 
    0.03347708f, 0.16040030f, -0.17707567f, 0.05327451f, -0.12423591f, -0.02763341f, -0.00845402f, 0.01173797f, 
    -0.03695221f, 0.10792414f, 0.12480243f, 0.05770295f, -0.07228007f, 0.04111149f, 0.03509393f, 0.02149660f, 
    -0.03470455f, 0.03881893f, 0.05741720f, 0.04170846f, -0.00491579f, 0.09223130f, 0.06435938f, -0.01412075f, 
    0.00400851f, -0.05270759f, -0.09484342f, 0.21985368f, 0.03275223f, 0.04168534f, -0.08806053f, -0.02435256f, 
    -0.02630338f, -0.02171401f, -0.02798683f, 0.04588722f, 0.01392460f, -0.02400236f, -0.03131982f, 0.03629206f, 
    -0.32462397f, 0.08190178f, -0.03498136f, -0.30363792f, -0.57035965f, 0.11940543f, 0.00601835f, -0.10603458f, 
    0.05414921f, 0.04347334f, -0.06917901f, 0.08194177f, -0.01821881f, -0.05408881f, 0.01486887f, -0.04333966f, 
    0.01399331f, -0.12428911f, -0.14915329f, -0.07971545f, 0.12083767f, 0.22677624f, 0.19697461f, -0.20949295f, 
    0.40572390f, -0.04551867f, -0.01838318f, -0.00271766f, 0.19455345f, -0.02578229f, 0.18565133f, 0.10275196f, 
    -0.04509171f, -0.09055188f, 0.05391277f, 0.06682625f, -0.05068097f, -0.02036346f, -0.13518350f, 0.03304013f, 
    -0.07965483f, 0.36715841f, -0.10423973f, -0.21021149f, -0.12375926f, 0.12617950f, -0.04504476f, -0.16611755f, 
    -0.01389811f, 0.06026095f, -0.07346375f, -0.16681305f, -0.19867249f, -0.08135950f, -0.28081593f, -0.29791272f, 
    0.00320179f, 0.10764418f, 0.11438111f, 0.18387911f, 0.01721213f, 0.07978151f, -0.02561418f, 0.01076153f, 
    -0.37402797f, -0.10445790f, 0.09487490f, 0.08051615f, -0.05376044f, 0.03776970f, -0.08075915f, -0.35063571f, 
    0.08638995f, -0.05960210f, 0.10884259f, -0.01018674f, -0.03270645f, -0.37943631f, 0.08009519f, 0.13336633f, 
    0.01007451f, 0.01352589f, -0.13243549f, -0.22879753f, -0.16508418f, -0.21248433f, -0.03895855f, -0.03748970f, 
    -0.09689682f, -0.14384989f, 0.40020591f, 0.01987845f, 0.00163735f, -0.08904122f, 0.08535060f, -0.07896626f, 
    0.11075249f, 0.09914058f, 0.11163738f, -0.23153031f, -0.01824166f, -0.54101950f, 0.14616811f, -0.15437528f, 
    0.08390249f, 0.01665636f, -0.02459279f, 0.03261339f, 0.04257145f, -0.02570072f, -0.02063845f, 0.12088010f, 
    -0.10532115f, -0.10492654f, 0.07358198f, 0.21068932f, 0.10176830f, 0.07805922f, 0.00203785f, 0.04085792f, 
    -0.09681626f, 0.03264838f, -0.12876147f, 0.04728394f, -0.11096995f, 0.02342007f, 0.08674385f, 0.01255982f, 
    -0.04234189f, 0.06409609f, -0.01163429f, 0.05820365f, 0.00343487f, 0.09655631f, -0.11755762f, 0.10442070f, 
    -0.02748956f, -0.00299992f, -0.02876475f, 0.06546329f, -0.00828099f, 0.04608835f, 0.09897458f, 0.04869570f, 
    -0.01736169f, -0.06085653f, 0.06781490f, -0.01568787f, 0.06619542f, 0.13192932f, 0.12449204f, -0.12250903f, 
    0.14009021f, 0.08487385f, -0.08194762f, 0.09668603f, -0.00297418f, 0.05499470f, 0.01765955f, 0.03954843f, 
    -0.29285595f, 0.49473262f, 0.02105813f, 0.01425152f, -0.02326546f, 0.10263702f, -0.03536098f, 0.03069102f, 
    0.05086617f, 0.01424510f, -0.06561406f, 0.09679100f, -0.25861740f, -0.03687264f, -0.04363313f, -0.03723747f, 
    0.00139947f, 0.02824347f, 0.00844600f, 0.02500658f, -0.02911184f, -0.04698657f, 0.09353855f, -0.00724155f, 
    -0.74863076f, -0.32309502f, -0.07846868f, -0.22060660f, -0.10650668f, -0.09802628f, -0.01053828f, 0.03456358f, 
    -0.04040252f, -0.03808601f, 0.04677726f, -0.07532308f, 0.01359133f, 0.00592918f, 0.13492244f, 0.08311161f, 
    -0.04505594f, -0.05216440f, 0.00151518f, -0.09583353f, -0.03708269f, 0.12576786f, 0.07809374f, 0.09238947f, 
    -0.44892168f, -0.29182300f, 0.26147357f, 0.03581221f, -0.00812532f, 0.07224880f, 0.07280611f, -0.00184161f, 
    -0.01559561f, -0.03492023f, -0.04565277f, 0.09087906f, -0.20971327f, -0.24235889f, -0.09557281f, -0.18375976f, 
    -0.00597415f, 0.05920347f, 0.03635373f, -0.07776905f, -0.02070458f, -0.04507411f, -0.06011461f, -0.06726424f, 
    -0.00012998f, -0.36628896f, 0.09224932f, 0.23344967f, 0.05617376f, 0.07353049f, -0.08778633f, 0.06011653f, 
    -0.01395924f, -0.01291068f, -0.01209656f, 0.03323127f, -0.37498438f, -0.62962651f, 0.19276212f, 0.34457555f, 
    -0.13982153f, -0.12108988f, 0.04733222f, 0.13748470f, 0.00526470f, 0.00599557f, -0.06357523f, -0.01425851f, 
    -0.03976402f, -0.01207103f, 0.01597295f, -0.08890813f, 0.00572519f, 0.02470273f, -0.02406773f, 0.15864947f, 
    -0.01251285f, 0.01775272f, -0.00325756f, -0.04877391f, -0.10898309f, -0.01374317f, -0.00163975f, 0.07274071f, 
    -0.19346935f, -0.33858383f, 0.05219303f, 0.00550652f, -0.08783662f, -0.06366979f, 0.07559159f, 0.05614109f, 
    -0.05796940f, 0.21386309f, 0.23186463f, 0.32730755f, 0.01286721f, -0.07155882f, 0.10159989f, 0.04944336f, 
    0.14218955f, 0.01050985f, 0.12724505f, 0.02641349f, 0.04632565f, -0.12539379f, -0.07401623f, -0.23201653f, 
    0.04142996f, -0.01394269f, -0.02382032f, 0.07731386f, 0.06318495f, -0.01452329f, -0.02986377f, 0.00344184f, 
    0.02553247f, 0.03265760f, 0.30295905f, 0.45519066f, -0.01157893f, 0.07781889f, -0.01093083f, 0.06499451f, 
    -0.00210742f, -0.04003450f, -0.04131726f, 0.08421558f, -0.01108690f, 0.07940379f, -0.18742029f, -0.09001444f, 
    -0.08733972f, 0.11201077f, 0.00489218f, -0.08449205f, -0.08894812f, 0.09539626f, -0.12217100f, 0.16056423f, 
    -0.22709920f, 0.13660568f, -0.10147093f, 0.15231672f, 0.02521925f, 0.10310864f, -0.01398210f, 0.04027946f, 
    -0.00853295f, -0.04085059f, 0.07706156f, -0.05157967f, -0.11376107f, -0.08358039f, -0.14417796f, -0.14285272f, 
    -0.01878215f, -0.03893606f, 0.11705726f, 0.04947439f, -0.05038551f, 0.03979509f, -0.03226509f, 0.05761902f, 
    -0.37345502f, -0.10336595f, 0.18939731f, -0.44070971f, 0.02468257f, -0.06071991f, -0.05524183f, 0.13765176f, 
    -0.04717693f, -0.00628612f, 0.05677490f, -0.10497941f, 0.03480772f, 0.16204908f, -0.12280120f, 0.00756863f, 
    -0.11486596f, 0.05701338f, 0.07788604f, 0.00205661f, 0.03083025f, -0.07559627f, 0.06954125f, -0.02216356f, 
    0.22624990f, -0.01921208f, -0.08833934f, 0.11039891f, 0.05194898f, 0.00354508f, 0.06851516f, -0.15909502f, 
    -0.14076152f, 0.01541566f, -0.10169408f, 0.08552997f, 0.05752057f, 0.27252126f, -0.43263692f, -0.20281969f, 
    -0.09153530f, -0.02224409f, 0.02477885f, 0.15538530f, -0.01628248f, 0.01367060f, 0.03348302f, -0.05374330f, 
    -0.09844297f, 0.16296083f, -0.11039577f, -0.28998652f, 0.00370935f, -0.01158075f, 0.02636673f, 0.11200758f, 
    0.03716255f, -0.06680959f, 0.00220219f, -0.08535857f, 0.04870620f, 0.33034390f, 0.14879310f, 0.29910734f, 
    -0.03101111f, -0.02879944f, 0.01143937f, 0.07437851f, 0.00651248f, -0.02636699f, -0.03274883f, 0.16016537f, 
    -0.33461744f, -0.00715135f, 0.19137552f, -0.43592808f, -0.02934093f, -0.11817323f, -0.21211338f, -0.37331083f, 
    -0.06871393f, 0.05460634f, 0.04380050f, -0.03328077f, -0.34505227f, 0.07048656f, -0.02577131f, -0.00163808f, 
    0.00500513f, 0.00117032f, -0.08418887f, -0.04554799f, 0.07168134f, -0.04815516f, -0.06555351f, 0.13929881f, 
    -0.28537816f, 0.41091028f, 0.26794893f, -0.17666231f, 0.04803086f, -0.01594579f, -0.07516413f, 0.03225164f, 
    0.08720846f, 0.00378374f, -0.02300207f, 0.08975385f, 0.26376313f, 0.00181885f, 0.19641078f, -0.33822083f, 
    0.07789946f, -0.01421741f, 0.03492709f, -0.05659562f, -0.02905807f, 0.09881974f, 0.03827790f, -0.13560666f, 
    -0.14008862f, 0.01272163f, -0.00873991f, 0.03320718f, -0.00481723f, -0.02841362f, -0.02438764f, -0.04655656f, 
    -0.11189402f, 0.03054813f, -0.04322516f, 0.01515965f, 0.01267520f, -0.07825369f, -0.12029140f, -0.03193638f, 
    0.03218871f, -0.04289122f, 0.00615957f, 0.06083716f, -0.04590574f, 0.01672199f, 0.12707905f, -0.08761749f, 
    -0.17529655f, -0.07878493f, 0.07915754f, 0.01259623f, 0.13176057f, -0.02349635f, -0.14769574f, 0.02857039f, 
    -0.00245041f, 0.04255440f, 0.09447645f, -0.15242507f, -0.12109403f, -0.10807731f, -0.04256628f, -0.01627460f, 
    0.01263735f, -0.01680927f, 0.04830088f, 0.03169736f, -0.02291831f, -0.05333171f, 0.03880916f, 0.03169062f, 
    -0.04150216f, -0.02172028f, 0.05008882f, -0.05544239f, -0.02471893f, 0.03071625f, -0.02794210f, -0.05844850f, 
    0.11992534f, 0.15128599f, 0.10396572f, 0.05593884f, 0.07000137f, 0.31786406f, 0.19269565f, -0.08691628f, 
    -0.05405337f, 0.00907902f, 0.11117812f, -0.08663197f, 0.04526636f, -0.10911942f, 0.01013110f, -0.07049050f, 
    -0.38139012f, 0.16008377f, -0.04231588f, -0.28818360f, 0.00307072f, 0.00524688f, 0.00648750f, 0.05027354f, 
    -0.01484373f, -0.00247651f, -0.03872074f, 0.02243601f, 0.01638110f, -0.22565304f, 0.24205671f, 0.16728733f, 
    -0.04633600f, 0.01565471f, -0.00520811f, 0.04710266f, 0.02872711f, -0.00814690f, 0.02020035f, -0.04935357f, 
    -0.20500493f, -0.00689564f, -0.03964492f, -0.19251688f, -0.02154899f, -0.02450043f, 0.02318198f, -0.07188033f, 
    -0.06837793f, -0.01171414f, 0.08533308f, -0.00884595f, 0.18524438f, -0.11497637f, 0.04295847f, -0.07150079f, 
    0.04190825f, -0.12842409f, 0.04914462f, -0.06038588f, 0.10790952f, 0.18592006f, -0.01462466f, 0.25398713f, 
    -0.28400242f, 0.38207853f, -0.15379901f, 0.00321266f, -0.00043965f, 0.02040208f, 0.01939333f, 0.07907458f, 
    0.01207001f, -0.04359890f, 0.12512191f, -0.08476846f, 0.11303161f, -0.02037656f, -0.08692717f, 0.16154568f, 
    -0.03634322f, 0.00424373f, 0.00151977f, -0.00892604f, -0.02523239f, 0.13284194f, 0.04923410f, 0.04360007f, 
    -0.37970543f, -0.48665088f, -0.24562737f, -0.30645192f, 0.07907662f, -0.02331613f, -0.11283146f, -0.11086234f, 
    0.00806278f, 0.04267828f, -0.00669081f, -0.02959178f, 0.02729639f, 0.06864805f, 0.04498942f, -0.21578750f, 
    0.01197796f, 0.01039025f, -0.11165702f, 0.17258404f, 0.01179100f, -0.00622997f, 0.03329221f, 0.03375661f, 
    -0.68944240f, -0.36157319f, -0.05876277f, -0.21863396f, -0.09334124f, -0.04633718f, 0.11189305f, -0.07302819f, 
    0.02737718f, 0.00668946f, -0.00030661f, -0.07089633f, -0.09069853f, 0.13807017f, -0.04036116f, -0.21392469f, 
    0.01556276f, 0.08867161f, -0.22300403f, 0.00000590f, 0.04299311f, -0.03880991f, -0.27724287f, -0.02973827f, 
    -0.10156083f, 0.04264482f, 0.00360340f, -0.00398815f, -0.11073317f, -0.19870056f, -0.31635171f, 0.09343924f, 
    0.02503728f, -0.05409531f, 0.01635932f, -0.03709018f, -0.07370057f, -0.13731305f, 0.23613380f, 0.00084588f, 
    0.06295170f, 0.05137150f, 0.03311622f, 0.16957837f, -0.03740710f, 0.05898514f, 0.02055987f, 0.00358257f, 
    -0.00126606f, -0.06078486f, -0.01063341f, -0.09987532f, 0.04173766f, -0.00617055f, -0.18216269f, -0.01520461f, 
    0.03199567f, -0.01081047f, -0.12088709f, 0.11166068f, 0.15815459f, -0.13617574f, -0.02731180f, 0.08767585f, 
    0.07796926f, 0.02630573f, -0.07651379f, 0.01887440f, 0.03127981f, -0.04086878f, 0.06332236f, 0.00641949f, 
    0.03576262f, 0.24093510f, 0.06387854f, 0.13460727f, 0.00844074f, 0.01367590f, 0.08577218f, -0.10723086f, 
    -0.06945743f, -0.09330835f, -0.00313983f, 0.03041957f, 0.14534459f, -0.28180027f, 0.00623857f, 0.17063072f, 
    0.06930476f, -0.20161530f, 0.16066462f, 0.00692640f, 0.06589327f, -0.03580347f, -0.07676582f, 0.05171169f, 
    0.03036090f, -0.06388265f, 0.02965204f, 0.09714432f, 0.07668456f, 0.00780843f, 0.03698780f, 0.05503720f, 
    -0.05070751f, 0.08118694f, 0.01538801f, -0.00886206f, 0.02798547f, -0.01983612f, -0.11103139f, -0.06293575f, 
    -0.00790792f, 0.05094285f, -0.03660790f, 0.07293218f, -0.06817441f, 0.04055520f, -0.01990698f, 0.09895598f, 
    0.07699273f, 0.01613132f, -0.25448856f, 0.03906197f, -0.03098637f, -0.04659439f, 0.06448846f, -0.04255109f, 
    -0.11183418f, 0.15386726f, 0.10759418f, -0.04661163f, -0.30343735f, 0.04122768f, -0.13526149f, -0.00864525f, 
    0.04443537f, -0.10570770f, -0.02383315f, -0.01584143f, -0.04889474f, 0.04080574f, -0.06934526f, 0.06014723f, 
    0.00976527f, 0.05093310f, 0.04079157f, 0.03524463f, -0.02722068f, 0.03989888f, 0.00033568f, -0.09216770f, 
    -0.02346367f, 0.07380414f, 0.01589360f, 0.12048297f, 0.07197834f, -0.06100271f, 0.02704346f, 0.10231186f, 
    0.03733645f, -0.00789735f, 0.00419742f, 0.00500706f, 0.06224201f, -0.15595987f, 0.19192065f, 0.00417579f, 
    0.13288377f, 0.68442202f, 0.22273403f, 0.46198374f, -0.04482213f, -0.01262508f, 0.00594760f, -0.01462913f, 
    -0.02013160f, -0.03218480f, -0.02589471f, -0.00482335f, 0.02021410f, 0.07705542f, -0.38532001f, -0.10814926f, 
    -0.03545161f, -0.11948180f, 0.12383686f, 0.08304642f, -0.03517206f, -0.00537673f, 0.01532080f, 0.00738242f, 
    0.09543300f, -0.17474391f, 0.12116173f, 0.25694823f, 0.01426738f, 0.01890189f, 0.13160278f, 0.01291504f, 
    0.05933286f, 0.04981014f, 0.06351344f, -0.01225320f, -0.23109344f, -0.16883592f, 0.07710721f, 0.29017073f, 
    0.01029174f, 0.05630749f, -0.07124533f, 0.01924024f, 0.02338905f, -0.12872437f, 0.03546691f, -0.14453045f, 
    0.00501368f, -0.12022801f, -0.30274796f, 0.08750609f, 0.24035521f, -0.02732652f, 0.03986197f, -0.22492163f, 
    0.03218165f, -0.15986651f, -0.12062955f, -0.11112788f, 0.10073534f, 0.08006181f, -0.21943875f, 0.03064946f, 
    0.01397246f, 0.07901537f, 0.00361519f, -0.05174009f, -0.30615121f, -0.01412440f, -0.03060703f, -0.02290068f, 
    -0.02718586f, 0.10311712f, -0.08281339f, -0.15080258f, 0.22175322f, 0.05345824f, -0.03897777f, 0.11808718f, 
    -0.17163530f, 0.04905194f, 0.04374406f, -0.11187334f, -0.42914411f, 0.19021571f, -0.13606168f, 0.05649889f, 
    -0.08145034f, 0.03614718f, -0.06420421f, -0.12478373f, -0.02047143f, 0.02587126f, 0.05177851f, -0.04793818f, 
    0.13559060f, -0.11283746f, 0.07684562f, -0.06466457f, -0.23648566f, -0.12046412f, -0.01044529f, -0.07652764f, 
    0.01254884f, 0.06214028f, 0.06314804f, 0.12889139f, 0.20993827f, -0.08349627f, -0.01573905f, 0.05636594f, 
    -0.11279844f, -0.00771293f, -0.01539875f, -0.01589771f, -0.04192575f, -0.02630473f, -0.13059524f, -0.02513984f, 
    0.07949337f, 0.14723961f, -0.01943780f, 0.33636394f, 0.03667369f, 0.00434552f, -0.02973838f, -0.02672424f, 
    -0.08552314f, -0.00131202f, 0.19362777f, 0.03946921f, 0.09228169f, 0.19940075f, 0.04807900f, -0.01549017f, 
    -0.21854304f, -0.08980390f, -0.03142228f, -0.12903523f, -0.22383673f, 0.20331807f, 0.08006131f, 0.01452207f, 
    -0.16184212f, -0.02768906f, -0.06098394f, 0.14731283f, 0.06491271f, 0.03572105f, 0.01903688f, 0.04023829f, 
    -0.06655627f, 0.01269791f, -0.05028540f, -0.00143193f, -0.08915749f, 0.03527034f, -0.09056954f, 0.15629771f, 
    0.05992121f, 0.04685212f, 0.13692975f, 0.00524876f, -0.06440648f, -0.09088561f, 0.07364213f, 0.02161581f, 
    0.10463814f, -0.04867209f, 0.13177496f, -0.03500827f, -0.21735920f, -0.01020726f, -0.09653029f, 0.02965155f, 
    -0.00173557f, 0.23747684f, -0.11114547f, 0.04929451f, 0.05511577f, 0.05202622f, 0.02179430f, 0.10154828f, 
    -0.09558239f, -0.00800844f, 0.07637557f, 0.01731426f, 0.00694880f, 0.11613759f, -0.01088695f, -0.02115588f, 
    0.06183466f, -0.17774098f, -0.07424837f, 0.08511262f, 0.05612995f, -0.04248130f, -0.11579926f, -0.00176760f, 
    -0.04180784f, 0.07047707f, -0.10380274f, 0.05191299f, -0.06725866f, -0.05238773f, -0.02313509f, 0.13361982f, 
    0.03117963f, -0.02405259f, 0.01170011f, -0.03179785f, -0.00845521f, 0.08066733f, -0.03881256f, 0.09784596f, 
    -0.08924237f, -0.01714433f, 0.03632229f, 0.03424485f, -0.08579102f, 0.00690384f, -0.28020117f, 0.06025366f, 
    -0.01768097f, -0.03292942f, 0.05797040f, -0.04085540f, -0.10561407f, -0.18458638f, -0.29551843f, 0.37980989f, 
    0.00865963f, -0.15987435f, 0.02767538f, -0.25943741f, 0.01515846f, 0.00711973f, -0.02827946f, 0.13346066f, 
    0.36925074f, -0.21761702f, -0.03159211f, 0.04518352f, 0.19699135f, 0.11026133f, 0.00188326f, -0.01677125f, 
    -0.10120734f, 0.01231800f, -0.06134799f, 0.00630617f, 0.13474180f, -0.15286581f, 0.26785916f, -0.24086833f, 
    -0.06159418f, 0.07372244f, 0.04260613f, 0.13916583f, 0.08769446f, 0.12497144f, -0.06416205f, -0.05914569f, 
    0.20624965f, -0.19900987f, 0.07509073f, 0.06181698f, 0.02387419f, -0.03429662f, 0.00665956f, -0.08175529f, 
    -0.01499944f, 0.08270604f, -0.09223546f, 0.14449188f, 0.12665270f, -0.23091908f, 0.08672485f, -0.35505578f, 
    0.01384471f, -0.14977190f, -0.16576757f, -0.15173616f, -0.11254796f, 0.13033870f, -0.08494880f, -0.16119371f, 
    0.12396930f, 0.09758630f, -0.14186974f, -0.16296747f, -0.23346558f, -0.11913511f, -0.06320048f, -0.01757452f, 
    -0.10635341f, 0.00625397f, -0.01379744f, 0.00814437f, 0.16596861f, -0.23034339f, 0.36558622f, -0.07364637f, 
    -0.08805832f, -0.19430159f, 0.09212609f, -0.00811563f, -0.04755471f, 0.18313944f, 0.12216600f, -0.00652134f, 
    -0.13051762f, -0.17113233f, 0.24960649f, 0.06998741f, -0.09587160f, 0.19266368f, -0.13344739f, -0.09727036f, 
    -0.06893362f, -0.29817295f, 0.12727578f, -0.20930205f, 0.22723517f, -0.08238812f, -0.11206149f, -0.35696298f, 
    -0.18098110f, -0.21096516f, -0.06889124f, -0.03218738f, -0.04271827f, 0.02028803f, -0.25710785f, -0.13783921f, 
    1.07150483f, 0.08836865f, -0.20404235f, -0.26389739f, 0.01622942f, -0.20253341f, -0.08171617f, -0.13866450f, 
    -0.13008061f, -0.02611961f, 0.14736415f, 0.00194381f, -0.34712571f, 0.59098804f, -0.35755062f, 0.34497923f, 
    0.09416158f, 0.01955142f, 0.03840669f, -0.03353257f, -0.08481962f, 0.00229855f, 0.00492387f, 0.17722160f, 
    -0.49058279f, -0.01742673f, 0.13601372f, -0.11593165f, -0.03735565f, -0.07672674f, -0.12050962f, 0.02856707f, 
    -0.10993712f, 0.01687208f, -0.00610115f, -0.10602488f, -0.00498473f, -0.15361303f, -0.00438247f, 0.15550171f, 
    0.15686242f, 0.04777600f, 0.04549706f, 0.01865578f, 0.01361953f, 0.02163962f, -0.06369437f, 0.09941427f, 
    -0.29406247f, -0.29267678f, 0.39308381f, 0.35152221f, -0.11844677f, -0.04608797f, 0.02709145f, 0.05037069f, 
    0.13778646f, 0.08288919f, -0.03809188f, -0.10790455f, -0.07217664f, -0.12330902f, 0.13788559f, 0.14542712f, 
    -0.08804064f, -0.00833335f, -0.17392035f, -0.02743181f, -0.06240563f, 0.04077760f, -0.02446843f, -0.01778049f, 
    -0.42148185f, 0.16573498f, -0.10213495f, 0.20661566f, -0.00308556f, 0.10347110f, 0.05383552f, -0.12410727f, 
    -0.04361538f, -0.12918253f, 0.13711159f, 0.09780709f, 0.01704391f, -0.01741643f, 0.11051932f, 0.02993188f, 
    -0.04607429f, 0.07715589f, -0.02559318f, -0.04526556f, -0.01016851f, 0.03257363f, 0.02748877f, 0.06658868f, 
    0.10412160f, 0.00363120f, -0.03019894f, 0.02620972f, -0.13731803f, -0.04397388f, -0.11311629f, -0.19541131f, 
    0.06628674f, -0.11062461f, -0.27803150f, -0.00447686f, -0.12140049f, 0.05132451f, 0.05396250f, -0.17340995f, 
    0.04100212f, 0.05643036f, -0.12264055f, -0.02020840f, 0.10956873f, -0.07364247f, 0.17327279f, -0.09402102f, 
    -0.16057898f, -0.08809566f, -0.16932471f, 0.00202185f, 0.18931442f, -0.09704825f, -0.02839505f, -0.04816362f, 
    0.10536654f, -0.14484642f, 0.07591365f, -0.04546094f, -0.42565137f, -0.52842826f, -0.23380050f, -0.27300698f, 
    0.09767765f, 0.21141243f, -0.02134441f, -0.07325429f, -0.04989453f, 0.02675479f, -0.05459400f, -0.13015802f, 
    -0.15723382f, -0.12155502f, 0.15541442f, 0.04779695f, -0.11374756f, 0.14060557f, -0.16481787f, 0.00562162f, 
    0.13861087f, 0.15978162f, 0.15309665f, -0.10946264f, -0.10884979f, -0.01469125f, 0.00407107f, 0.27591372f, 
    0.08424561f, 0.03957765f, 0.02188651f, -0.09146600f, -0.03836238f, -0.04650110f, 0.07860782f, 0.01678152f, 
    -0.48035637f, 0.12580384f, 0.16574396f, 0.06917641f, -0.03371409f, -0.19134346f, 0.18799040f, -0.09712089f, 
    0.00285758f, 0.03390695f, -0.15641244f, 0.03120956f, -0.13007991f, -0.08738041f, -0.10370297f, 0.15193346f, 
    0.07428084f, -0.00092520f, 0.05053770f, -0.05922573f, -0.02044533f, 0.12558642f, -0.01568946f, 0.04515128f, 
    -0.22390440f, 0.11574566f, 0.01240330f, 0.12550798f, -0.09859020f, 0.02058831f, -0.02243011f, -0.02608771f, 
    0.05981996f, 0.03822580f, -0.04670733f, 0.00196202f, 0.38417646f, 0.11334894f, 0.23006354f, -0.10284586f, 
    0.01251711f, 0.05516710f, 0.02424988f, -0.21556373f, -0.00562620f, -0.01862217f, 0.07559553f, -0.10469221f, 
    -0.53994834f, -0.03909693f, -0.22588919f, 0.05273724f, -0.03967930f, -0.35369581f, -0.19398440f, -0.12275326f, 
    -0.20360528f, 0.10235376f, -0.04998776f, -0.03746234f, -0.07463644f, -0.04628231f, -0.28929365f, -0.07594023f, 
    0.03668483f, -0.02234980f, 0.04225171f, 0.11688171f, 0.06194863f, 0.03471521f, -0.12002884f, -0.09335674f, 
    0.11339165f, -0.07253394f, -0.17176545f, 0.14355822f, 0.13469607f, -0.05264984f, 0.00218524f, 0.16250601f, 
    -0.05806116f, -0.07308511f, -0.00196533f, -0.01756676f, -0.15189318f, -0.12817143f, -0.00246541f, -0.05092804f, 
    -0.01751338f, 0.01001223f, -0.25644177f, -0.03842349f, -0.07409124f, -0.04378700f, 0.12306638f, -0.14100036f, 
    -0.06772168f, -0.23711245f, -0.07689846f, 0.12743020f, 0.05767487f, -0.04279872f, 0.10514174f, -0.07846019f, 
    0.05929099f, -0.04995033f, 0.08170502f, -0.04623304f, -0.16666964f, 0.07189238f, 0.01122661f, 0.29684132f, 
    0.00023533f, -0.11105137f, 0.05276353f, -0.06454264f, 0.00951859f, 0.07009433f, 0.03853910f, 0.06669547f, 
    -0.01928807f, -0.21299945f, 0.18308592f, 0.31805110f, 0.06627577f, 0.07243148f, -0.05846413f, 0.00054726f, 
    0.04636259f, -0.08508287f, -0.01138632f, 0.09794528f, -0.20656887f, 0.58759123f, -0.22511284f, -0.50574213f, 
    0.20095418f, -0.01247174f, -0.09972541f, -0.07088613f, -0.28318569f, 0.01397476f, 0.01090159f, -0.12248594f, 
    0.21883990f, -0.08321650f, 0.25886256f, 0.05900800f, -0.20127219f, 0.13441770f, -0.09252159f, -0.03956658f, 
    0.14842814f, 0.10562049f, -0.06610486f, 0.02639106f, -0.07056452f, 0.17683117f, -0.54410541f, -0.24641089f, 
    0.05560676f, 0.11489695f, 0.08232615f, 0.02748001f, -0.14528739f, -0.18186742f, 0.03607806f, -0.13136433f, 
    -0.35101300f, -0.01509695f, -0.09887829f, 0.02966318f, 0.05988872f, 0.13524419f, 0.10938749f, 0.03544710f, 
    -0.00194438f, 0.00632076f, -0.14399061f, -0.00035819f, 0.18317612f, -0.05865539f, -0.12904337f, 0.17600125f, 
    0.06824943f, -0.04834956f, 0.04550681f, 0.00830067f, -0.13101166f, 0.11531194f, -0.08621727f, 0.10628975f, 
    0.08441472f, 0.07625262f, -0.19845234f, -0.64564389f, 0.10001627f, 0.06097927f, -0.04370842f, -0.24199969f, 
    -0.02364027f, -0.04957356f, -0.20003656f, -0.03272465f, 0.12858292f, -0.08615007f, 0.20079538f, -0.12643771f, 
    -0.13618910f, 0.07352442f, 0.08041443f, -0.00117465f, 0.08088878f, 0.04450490f, 0.07383714f, -0.08331493f, 
    0.29500362f, 0.43685052f, -0.00791284f, -0.22992830f, -0.05864194f, 0.04499289f, 0.03502586f, -0.02885052f, 
    -0.10850172f, -0.11628621f, 0.14389886f, -0.04742558f, 0.18241100f, 0.11065578f, 0.10124499f, -0.27295032f, 
    -0.02559785f, 0.01913746f, -0.14856268f, 0.18358682f, 0.00145567f, 0.16631722f, 0.04309287f, -0.21982221f, 
    -0.17500198f, -0.12713081f, -0.11477450f, 0.19635344f, -0.07252425f, -0.04793988f, 0.08852572f, 0.07161395f, 
    -0.04644006f, -0.00054375f, -0.10993794f, -0.04499154f, 0.14695972f, -0.09110191f, -0.07384180f, 0.10984188f, 
    -0.11441323f, 0.13338707f, -0.06920162f, 0.05827467f, 0.03597087f, -0.11603662f, 0.09337082f, 0.02418869f, 
    0.79180080f, -0.08884148f, -0.03130580f, 0.26865885f, 0.16116087f, -0.12567037f, -0.05617663f, -0.08679822f, 
    0.00753162f, 0.07224652f, 0.10967127f, 0.23456500f, -0.10477382f, 0.21309836f, -0.04238222f, 0.24435169f, 
    0.06401237f, -0.00737112f, -0.01138169f, 0.10057572f, -0.12768458f, 0.01298651f, -0.11881210f, 0.06510203f, 
    0.08889896f, 0.14828993f, 0.24495780f, 0.00788456f, 0.02399776f, 0.10638302f, 0.04942865f, 0.13162352f, 
    0.03549967f, 0.07705849f, -0.02634414f, -0.05068168f, 0.19977140f, 0.21686134f, -0.01144164f, 0.09142186f, 
    0.03071384f, -0.00671377f, -0.03628248f, 0.15872189f, 0.05886919f, -0.06903121f, 0.09127691f, 0.02412750f, 
    -0.11387565f, 0.17744398f, 0.18163104f, -0.00765008f, -0.11474629f, -0.17801514f, -0.10837182f, -0.02167996f, 
    -0.17023413f, -0.10717580f, -0.00484749f, -0.02916241f, -0.17179748f, -0.33868477f, -0.26658612f, -0.27293128f, 
    0.01860945f, 0.08973701f, 0.05557752f, 0.13799055f, 0.02977593f, 0.02489564f, 0.15486334f, -0.05479235f, 
    0.26150870f, -0.00103832f, -0.00851196f, 0.04566330f, -0.11224192f, -0.03231039f, -0.05097027f, -0.00955632f, 
    0.02988888f, -0.14387605f, -0.07962715f, -0.06498852f, 0.06157832f, -0.09692357f, 0.00557953f, -0.07621944f, 
    0.04480825f, -0.02021485f, 0.07027605f, 0.05069011f, -0.01594368f, -0.22266507f, -0.25443181f, -0.01762512f, 
    0.00530331f, -0.00724265f, 0.01940738f, 0.15195264f, 0.13651434f, 0.03618662f, -0.07565466f, 0.01378832f, 
    -0.04207700f, -0.00539919f, -0.08840977f, -0.10268049f, -0.24621768f, -0.06935964f, -0.03451432f, 0.02231872f, 
    -0.01352175f, -0.02989758f, -0.06612594f, 0.00279363f, 0.03975067f, 0.00923167f, -0.00023984f, -0.04337219f, 
    -0.31495002f, -0.10973976f, -0.00539245f, -0.08556292f, 0.02623335f, -0.03845170f, -0.06329819f, 0.06738327f, 
    -0.02181703f, -0.06674493f, -0.06629133f, -0.03404878f, 0.16404487f, -0.38084945f, 0.13699706f, 0.14858648f, 
    0.00998611f, -0.06140010f, 0.10131681f, 0.05458549f, 0.12749375f, -0.05977098f, -0.08379088f, -0.02582734f, 
    -0.13825569f, -0.03408804f, 0.05169631f, 0.06725160f, -0.04801767f, -0.07327367f, -0.00907416f, 0.05700611f, 
    -0.06555767f, -0.02942226f, 0.02422739f, 0.08904289f, 0.12925620f, 0.05882941f, 0.08839577f, 0.06903794f, 
    -0.03756469f, -0.05303137f, -0.06414884f, -0.03833406f, 0.05821105f, 0.06113753f, 0.01241724f, 0.12615827f, 
    0.06973447f, -0.17594190f, -0.20033106f, 0.23436762f, -0.16854906f, -0.02556893f, -0.00002193f, 0.01480289f, 
    0.08281026f, -0.02057714f, 0.04539713f, -0.01425461f, 0.01093654f, 0.08408073f, 0.11281303f, 0.10199728f, 
    0.01152749f, 0.03923330f, 0.01543621f, -0.03283624f, 0.04841225f, 0.00990359f, 0.01055701f, 0.00210493f, 
    -0.06253409f, -0.14339785f, -0.01838670f, -0.02029249f, -0.11223300f, -0.05716743f, 0.05752629f, 0.00531663f, 
    0.01792210f, -0.04610142f, 0.08445483f, -0.06049760f, -0.11937280f, 0.02475335f, -0.02939757f, 0.10124301f, 
    -0.06995598f, -0.04798463f, 0.10550266f, -0.03001499f, 0.03071417f, -0.01729676f, 0.02837273f, 0.03490923f, 
    -0.08158898f, 0.16881667f, 0.01442128f, 0.02925343f, -0.19850710f, -0.07823068f, -0.03728905f, -0.01752984f, 
    0.09817749f, -0.00893834f, -0.07177158f, -0.04817535f, 0.08381040f, 0.01862627f, 0.07132504f, 0.06708780f, 
    -0.05905411f, 0.01489508f, -0.02166408f, 0.14033951f, -0.08498287f, -0.02775943f, -0.12071945f, -0.05679988f, 
    -0.04646221f, 0.06089334f, 0.16938002f, 0.06891835f, -0.20903380f, -0.03858997f, -0.03094504f, 0.11684679f, 
    0.07042331f, -0.01002358f, -0.01087617f, 0.04583317f, 0.11011218f, 0.02044159f, -0.55131364f, -0.28004587f, 
    0.10207962f, 0.02144775f, 0.08936810f, -0.00912365f, 0.01007804f, -0.00466604f, 0.06098784f, -0.06748196f, 
    -0.04099455f, 0.10884200f, -0.06863169f, 0.15558778f, -0.08107538f, -0.09875806f, 0.05830242f, -0.14530875f, 
    0.03251446f, 0.05574746f, 0.04144907f, 0.01954591f, -0.04312664f, -0.01027278f, -0.02474722f, 0.02636094f, 
    -0.14705464f, -0.09212187f, 0.01758400f, 0.12855127f, -0.20635942f, -0.12175270f, -0.03736624f, -0.17634222f, 
    0.00685001f, -0.18355994f, 0.01786836f, 0.04241107f, 0.06435344f, 0.03229236f, 0.00347189f, -0.00970563f, 
    -0.06231800f, -0.03039160f, -0.11492345f, -0.11057515f, 0.10633602f, 0.27136344f, -0.22919807f, -0.02903936f, 
    -0.00620543f, -0.05262618f, -0.08184193f, 0.09164719f, 0.09618529f, 0.03279394f, 0.01711735f, -0.10223191f, 
    -0.10069468f, 0.39019600f, -0.29152435f, 0.33228466f, -0.05395791f, 0.10575294f, -0.13775019f, 0.01089408f, 
    -0.04151833f, 0.05552972f, -0.13531151f, -0.03399551f, -0.18597485f, -0.00795186f, -0.06658784f, -0.14418048f, 
    -0.21513160f, -0.06889190f, -0.03229335f, 0.15016261f, -0.04253316f, -0.05238187f, -0.00610965f, -0.12870082f, 
    -0.30378455f, -0.34819275f, -0.09827897f, -0.15336651f, 0.14942320f, 0.02514281f, -0.01958312f, 0.14897887f, 
    0.02527662f, -0.23226978f, -0.11015286f, 0.02344885f, 0.01603892f, -0.43166468f, 0.35918194f, 0.06528781f, 
    -0.03122869f, 0.04901477f, -0.08716136f, -0.01247783f, -0.08830661f, -0.00840442f, -0.06903292f, -0.07015451f, 
    0.17352869f, -0.04804620f, -0.11667795f, -0.01391790f, 0.14436352f, 0.02866588f, 0.12687992f, -0.04600869f, 
    -0.10079034f, -0.04680846f, -0.06249248f, -0.07957035f, 0.03533194f, 0.11929404f, 0.05087820f, 0.12103957f, 
    -0.08941582f, -0.00400293f, 0.04369057f, 0.04609553f, 0.11361565f, 0.01310814f, 0.07768477f, 0.10418717f, 
    0.02890420f, 0.29815492f, 0.02456896f, 0.00410387f, 0.02957268f, 0.12366547f, -0.06824870f, -0.11575465f, 
    -0.02656780f, -0.04193147f, -0.02565134f, -0.00003022f, 0.01956456f, 0.27500671f, -0.04880391f, 0.08973022f, 
    -0.00222057f, -0.02487582f, 0.07489482f, -0.12292507f, 0.03820337f, -0.00402842f, 0.09542211f, 0.08509534f, 
    -0.20491059f, -0.01889531f, -0.06228866f, -0.04693946f, 0.00365716f, -0.05606607f, -0.11337142f, 0.07334065f, 
    0.02036760f, -0.13712473f, -0.07821424f, 0.14023918f, 0.08678351f, -0.03661081f, -0.11109179f, 0.08545554f, 
    0.03335091f, -0.05035100f, 0.02302655f, -0.11126358f, 0.01978452f, -0.01501521f, 0.01242040f, -0.05454350f, 
    0.06685378f, 0.08166675f, 0.05004263f, 0.06422990f, 0.15787987f, 0.12136976f, 0.06044281f, 0.03205824f, 
    0.05550345f, 0.08518966f, -0.03189860f, 0.00068356f, -0.18501611f, -0.23934701f, -0.05718309f, -0.02386820f, 
    0.00676870f, -0.05331694f, 0.04556418f, 0.03896606f, 0.04122944f, 0.00241416f, -0.02004983f, 0.20293374f, 
    0.11066516f, 0.22065313f, -0.17404567f, -0.02472326f, -0.16020633f, -0.02868205f, -0.00356002f, 0.01581731f, 
    -0.07491644f, -0.11682129f, -0.01395995f, -0.07392503f, 0.11981523f, 0.03466585f, -0.02304443f, -0.04805281f, 
    0.13266668f, 0.06094782f, 0.04966291f, 0.04263604f, 0.09430471f, -0.02840388f, -0.07766437f, -0.05255877f, 
    0.08963863f, 0.01074424f, -0.13705000f, 0.05279014f, 0.07179832f, -0.10290439f, 0.11275543f, -0.06660463f, 
    0.03742903f, 0.02695593f, 0.03380666f, 0.21629068f, 0.16759218f, 0.06047583f, 0.06070697f, 0.13725950f, 
    -0.01030208f, -0.03450860f, -0.11860645f, -0.04966225f, -0.04224707f, -0.12604402f, 0.00580102f, 0.00513395f, 
    -0.20129746f, -0.12190128f, -0.24398725f, -0.66566342f, 0.12338050f, -0.00198625f, 0.03085116f, 0.01490420f, 
    -0.05919283f, 0.04160649f, -0.00047862f, -0.11572745f, 0.07714252f, 0.08510079f, 0.11366932f, 0.10548924f, 
    -0.05391578f, -0.02780177f, -0.08045872f, -0.02594533f, 0.01101036f, -0.02475614f, 0.06814195f, 0.13109887f, 
    -0.03057350f, -0.06390496f, -0.02254707f, 0.03145145f, 0.00065046f, -0.01624820f, -0.01964046f, -0.03362211f, 
    0.01224557f, -0.11982191f, 0.13758653f, 0.19343695f, 0.12589809f, -0.22203618f, -0.27343068f, 0.11121749f, 
    0.02876787f, -0.13059181f, 0.03098555f, -0.12403549f, 0.19599868f, 0.11828672f, 0.00934183f, 0.27694711f, 
    0.38046256f, -0.49521670f, 0.30721024f, -0.30425483f, 0.03583410f, 0.01322369f, -0.01869605f, 0.03371781f, 
    -0.01156238f, -0.02900771f, 0.05040881f, 0.06772888f, 0.07298204f, 0.01681958f, 0.13683948f, 0.10605025f, 
    -0.02043776f, -0.03208337f, -0.18537393f, -0.08941822f, -0.10437077f, 0.02398688f, -0.01066842f, 0.01878487f, 
    0.10144939f, 0.19280188f, 0.31923383f, 0.25594896f, -0.09780914f, -0.08747819f, -0.03319019f, 0.04230780f, 
    -0.14827849f, 0.04657161f, -0.09591573f, -0.00745479f, 0.10186069f, 0.01221925f, -0.07656772f, -0.04350631f, 
    -0.08975272f, -0.05348299f, 0.02109951f, 0.00726562f, 0.08155086f, -0.09329018f, -0.09333926f, -0.07651994f, 
    0.10666723f, 0.24746925f, 0.22778977f, 0.15831676f, -0.18902594f, -0.00255456f, -0.04930568f, 0.15859301f, 
    0.08517487f, -0.02116260f, 0.03176183f, 0.04636938f, -0.03656897f, 0.06434155f, 0.11656737f, 0.03020626f, 
    -0.01643106f, -0.04596431f, 0.03446697f, -0.07866077f, -0.28591633f, -0.23202652f, 0.00960341f, -0.16036211f, 
    0.08995531f, 0.03335742f, 0.04761007f, 0.05909221f, -0.08821855f, -0.02346335f, 0.15411554f, 0.11001796f, 
    0.13026781f, -0.00473391f, -0.01791694f, -0.08672542f, -0.03455433f, -0.40158206f, -0.20188086f, 0.05209015f, 
    -0.15214521f, -0.05607779f, -0.09105389f, -0.06130392f, -0.04524903f, 0.10385033f, -0.22415099f, -0.15161923f, 
    0.22390552f, 0.16220418f, -0.13766839f, 0.24089888f, -0.11250285f, -0.11712211f, -0.00140145f, -0.09226122f, 
    0.09115585f, -0.19656008f, 0.11907037f, 0.06373478f, 0.26404747f, -0.05516990f, -0.16835575f, 0.12039787f, 
    0.00713875f, -0.18047734f, 0.07829934f, -0.09939256f, 0.01660152f, 0.02370453f, -0.04817745f, 0.03721728f, 
    0.01484890f, 0.02021228f, 0.04889878f, -0.07177285f, -0.01277591f, -0.04518586f, -0.05054793f, 0.14921059f, 
    0.02704500f, -0.05554540f, -0.11707176f, -0.01661441f, 0.18425789f, 0.12742935f, 0.06195123f, 0.06985390f, 
    0.00409622f, -0.08512063f, -0.12756528f, 0.00899061f, 0.18985815f, 0.00871931f, 0.03841363f, 0.00303458f, 
    -0.21910110f, -0.08988728f, -0.29355320f, -0.03960882f, -0.00648147f, -0.04669589f, -0.00088151f, -0.04277943f, 
    -0.18259148f, -0.01479673f, -0.14957124f, 0.05020772f, 0.16853847f, 0.12902445f, -0.10490575f, 0.03661080f, 
    0.05944765f, -0.00998451f, -0.14275162f, -0.08270476f, 0.14776464f, -0.09974774f, -0.01334386f, 0.01401834f, 
    -0.09427845f, -0.20423833f, 0.11525980f, 0.07299267f, 0.00809990f, -0.06853271f, 0.00145126f, -0.04758444f, 
    0.01115637f, 0.24183914f, -0.04429778f, 0.44106671f, 0.07156508f, -0.29672876f, -0.20156832f, 0.19561832f, 
    0.01630693f, -0.01871383f, 0.06734187f, -0.26358482f, -0.11153156f, -0.12174085f, -0.01645690f, 0.10843752f, 
    0.11985420f, 0.09022468f, 0.00371682f, 0.06286704f, 0.12696338f, -0.00007954f, -0.13856959f, -0.11099638f, 
    -0.18615672f, 0.03786240f, 0.00699033f, -0.07104742f, 0.25865901f, 0.02520576f, -0.28817865f, -0.26702994f, 
    0.03471899f, -0.05988449f, 0.01952753f, -0.07366922f, -0.06523708f, -0.16689713f, -0.04073806f, -0.27252328f, 
    -0.09444924f, -0.12653901f, -0.00946809f, 0.15167287f, -0.06566691f, -0.11244531f, -0.16974455f, -0.00940835f, 
    -0.00615819f, -0.05243565f, 0.07108299f, -0.08033842f, -0.02866989f, 0.03537082f, 0.28911331f, 0.20027742f, 
    -0.09915526f, 0.04203191f, 0.10484917f, 0.15210213f, -0.03813877f, -0.05299778f, -0.05901039f, 0.00148446f, 
    0.08433842f, 0.06115688f, -0.17259507f, 0.17000550f, -0.05847431f, -0.14821973f, -0.03446237f, -0.07064743f, 
    -0.04084551f, -0.04022314f, 0.02790060f, -0.07462601f, -0.03097247f, 0.16099618f, -0.09685658f, -0.33485296f, 
    -0.09278720f, 0.00206586f, 0.08405261f, 0.02707449f, 0.10467137f, 0.17058420f, -0.15554772f, -0.07704768f, 
    -0.13185096f, 0.24152651f, -0.33912137f, -0.20735858f, -0.00996199f, 0.16225153f, -0.03709294f, 0.01746913f, 
    0.01005024f, 0.01381851f, -0.01446862f, 0.16325864f, 0.23932184f, 0.07319034f, -0.07199465f, -0.42929235f, 
    -0.01347636f, -0.04134777f, -0.11994833f, -0.02926859f, 0.20456766f, -0.29910302f, -0.23251361f, -0.01677557f, 
    -0.28681499f, -0.42405453f, 0.14430480f, 0.01681245f, -0.18043795f, -0.01908587f, 0.02641229f, -0.06769537f, 
    0.19344129f, 0.01739001f, 0.04090576f, 0.22754316f, -0.23093784f, -0.07284153f, -0.05009707f, -0.05105462f, 
    0.08843523f, 0.00897295f, -0.00401601f, 0.03533908f, 0.05666611f, 0.12236319f, 0.21459830f, -0.14443375f, 
    0.10314902f, 0.00713751f, -0.06227423f, -0.11412218f, -0.04747777f, 0.17063490f, -0.05365800f, -0.10718593f, 
    0.03172453f, 0.09764388f, 0.06053915f, 0.06116430f, 0.09836858f, 0.04763568f, -0.07010386f, 0.17550731f, 
    -0.01787583f, -0.04763769f, 0.04950549f, 0.05791225f, -0.01128386f, 0.03413570f, 0.08858646f, 0.13572963f, 
    0.12712471f, -0.22586882f, -0.40773651f, -0.01570593f, 0.00444627f, 0.01100185f, 0.00096462f, 0.09647688f, 
    0.12756284f, -0.15697522f, 0.03652104f, 0.02316578f, 0.01423779f, -0.06008865f, 0.16461608f, 0.23622622f, 
    0.06481528f, 0.04811181f, -0.12856825f, 0.03504506f, -0.04755316f, 0.00939793f, 0.05413310f, -0.02416862f, 
    -0.00781555f, 0.18773450f, 0.21495080f, -0.13492745f, 0.06555333f, -0.03621193f, -0.02455120f, -0.08002958f, 
    0.01259708f, -0.00321836f, 0.06915624f, 0.03679933f, 0.07665854f, 0.00042914f, 0.00215518f, -0.10747835f, 
    0.05592058f, -0.08837481f, 0.05528186f, 0.04387483f, -0.23589885f, -0.00524124f, -0.02684581f, -0.08597842f, 
    0.13498481f, -0.02531252f, -0.10115004f, 0.05369643f, 0.11425008f, -0.01195592f, -0.14236411f, 0.07018808f, 
    0.05616374f, 0.07781813f, 0.08843369f, -0.06663894f, 0.04568784f, -0.02644909f, 0.01559614f, -0.03352947f, 
    0.01800182f, 0.11554705f, 0.09828629f, 0.07458371f, 0.09708697f, 0.05007759f, 0.07556852f, 0.00853879f, 
    -0.24206965f, 0.27634662f, 0.18408929f, -0.16443734f, -0.00870603f, -0.08021545f, 0.06852061f, 0.13978961f, 
    0.02472537f, -0.02161953f, 0.05223410f, 0.03015180f, -0.19934288f, 0.09721456f, 0.14230607f, -0.20251477f, 
    0.16548711f, -0.10301036f, -0.07543547f, -0.04743182f, 0.06564768f, 0.02328098f, -0.02513064f, 0.00733055f, 
    -0.18171424f, -0.01804198f, -0.03500068f, 0.18290611f, 0.13990209f, 0.02157090f, -0.16702545f, 0.08574708f, 
    0.10716645f, 0.02041499f, 0.02627428f, 0.15200709f, -0.01846626f, -0.18091002f, 0.00318773f, -0.10518584f, 
    0.32124513f, 0.03638357f, 0.00423460f, -0.00224002f, 0.22243641f, -0.03640885f, 0.03769535f, 0.00580986f, 
    -0.35467106f, -0.24080701f, -0.12311453f, -0.24259548f, 0.06466253f, -0.06800514f, -0.04153333f, 0.05959379f, 
    -0.01835274f, 0.00787079f, 0.01207897f, -0.02854069f, -0.27754191f, -0.10725253f, -0.39903161f, 0.17386934f, 
    0.04814350f, -0.03556840f, -0.01450942f, -0.03177605f, 0.03781840f, -0.15171143f, 0.06707492f, 0.06042329f, 
    -0.29379347f, -0.14260618f, -0.10041834f, -0.04880029f, 0.06111062f, 0.07623563f, 0.05114068f, 0.00645059f, 
    0.04811183f, -0.00981503f, 0.04020191f, 0.00696055f, 0.10221470f, -0.06632475f, -0.09339517f, 0.17079030f, 
    0.17202799f, 0.04753979f, -0.09455097f, 0.03101557f, 0.04013374f, 0.00287582f, 0.12655258f, 0.17554863f, 
    0.17898740f, -0.34619665f, 0.14633006f, 0.17360505f, 0.00093297f, -0.07052792f, -0.07093354f, -0.00826798f, 
    0.00678452f, 0.04938688f, 0.02047040f, -0.00048516f, 0.05957451f, 0.03038619f, -0.47671694f, 0.07369792f, 
    0.01339875f, 0.10288687f, -0.16000214f, -0.05691739f, 0.00492264f, -0.17071186f, 0.09674092f, -0.04167901f, 
    -0.06307687f, 0.05775757f, -0.46188486f, 0.06541718f, 0.17614505f, -0.16210811f, 0.01938554f, -0.10175300f, 
    0.12225106f, 0.08977635f, -0.00567861f, 0.18265370f, -0.04083237f, -0.39845836f, 0.05872751f, 0.32421127f, 
    0.03717343f, 0.03539353f, -0.09849907f, 0.01965430f, -0.05841849f, 0.09558091f, -0.06246362f, 0.08639010f, 
    -0.44759032f, 0.55083019f, 0.17271855f, 0.14430329f, -0.06451091f, -0.06185639f, 0.01174091f, -0.01223299f, 
    0.08867266f, 0.04372183f, -0.11591940f, -0.03712910f, 0.04667028f, 0.13518259f, -0.00385069f, -0.10473301f, 
    -0.04741189f, -0.08564555f, -0.05056463f, 0.07172766f, -0.00837568f, 0.05298625f, 0.02447869f, -0.01870048f, 
    0.03851510f, -0.14689897f, -0.08588308f, 0.24035658f, -0.00159298f, -0.04267958f, 0.03549442f, -0.05589242f, 
    0.10347668f, -0.08334743f, 0.06516977f, 0.05551350f, -0.25058335f, -0.26889515f, 0.05162027f, -0.23870480f, 
    -0.00820387f, -0.05873600f, 0.06986236f, 0.05796192f, -0.01417842f, -0.13082412f, -0.07402578f, -0.01230798f, 
    0.14864275f, 0.08065268f, -0.53716189f, -0.17738149f, -0.06359007f, 0.18803042f, -0.05178075f, 0.14551844f, 
    -0.02248389f, -0.14815776f, 0.14577432f, -0.02446291f, 0.19190250f, -0.17308138f, -0.03087675f, 0.42743444f, 
    0.10962220f, 0.06435113f, -0.00981834f, 0.05420922f, -0.03513619f, -0.00926456f, -0.10642518f, -0.24478418f, 
    -0.11377592f, -0.03380927f, -0.05328573f, -0.33086196f, -0.03945952f, 0.08099598f, -0.07329655f, 0.08245547f, 
    -0.00753532f, 0.04767086f, -0.01158340f, -0.24532680f, -0.20610242f, 0.34216756f, 0.13480498f, -0.05526811f, 
    0.02305337f, 0.08144626f, -0.01754395f, 0.14019786f, 0.03399927f, -0.16793492f, 0.14410737f, -0.17154385f, 
    -0.07871178f, -0.07815264f, -0.05160309f, -0.02293303f, -0.01718940f, -0.05242204f, -0.09746489f, -0.00521252f, 
    0.12740639f, -0.00872144f, 0.04423637f, -0.01419381f, 0.02640594f, -0.02460735f, -0.15664037f, -0.03756305f, 
    0.05297616f, 0.04784395f, 0.00316995f, -0.03513232f, 0.10926304f, 0.01772087f, -0.02545504f, -0.06223105f, 
    -0.10592213f, -0.15257035f, 0.01158095f, -0.00873603f, -0.03825370f, 0.13526835f, -0.04289182f, -0.08119349f, 
    0.12233210f, 0.19013745f, 0.02732656f, 0.12412524f, -0.11486522f, -0.13117480f, -0.06098699f, -0.00369143f, 
    -0.03641615f, -0.04911662f, -0.09067012f, -0.04413285f, 0.09593427f, 0.01535847f, 0.15209769f, -0.00105606f, 
    0.11203565f, -0.02512779f, -0.17903477f, -0.09253287f, 0.00694217f, 0.01356328f, -0.00362860f, 0.07482442f, 
    -0.05144016f, -0.15823147f, -0.38988021f, -0.16033792f, -0.11523764f, 0.08220630f, -0.15958822f, -0.09260318f, 
    -0.04366878f, 0.07220472f, -0.02338100f, -0.00190759f, 0.09193454f, 0.06591718f, -0.08618300f, -0.03525025f, 
    -0.26054817f, -0.19435368f, -0.43779150f, 0.15057175f, 0.03241089f, 0.02220758f, -0.01246928f, -0.01105847f, 
    0.11329365f, -0.01357347f, 0.01964201f, -0.08377772f, -0.10025723f, 0.11971515f, 0.21124868f, -0.15052807f, 
    0.04320747f, 0.13641189f, -0.02275225f, 0.00537860f, 0.04064501f, -0.07063450f, -0.05728731f, 0.03224095f, 
    0.23809870f, 0.00449055f, -0.14282550f, 0.10264208f, 0.01337599f, 0.03555410f, 0.03234218f, -0.01403672f, 
    0.10513353f, -0.08083320f, -0.08901233f, -0.37840447f, -0.67826867f, 0.15524551f, 0.14836715f, 0.01492026f, 
    0.06048054f, 0.02163842f, 0.07278577f, 0.08711916f, 0.05631265f, -0.43212312f, -0.26829669f, -0.36021900f, 
    0.14493723f, -0.14522026f, 0.25712258f, -0.03551278f, -0.10171651f, 0.04965572f, 0.05682453f, -0.01277983f, 
    0.08144796f, -0.11636532f, 0.01139970f, -0.05029760f, 0.16237199f, -0.00135172f, 0.29784468f, 0.01803030f, 
    -0.00498538f, 0.02138286f, 0.12137978f, -0.07734501f, -0.01047811f, -0.07627552f, -0.05599117f, -0.02901402f, 
    0.37452543f, 0.09567644f, 0.26838452f, -0.10980573f, 0.04389511f, 0.09718546f, -0.14006995f, -0.16311494f, 
    0.03551352f, -0.02381194f, -0.02466335f, -0.00928274f, 0.00767200f, -0.10265116f, -0.25739670f, 0.33451831f, 
    0.17176419f, -0.02757255f, 0.08063940f, -0.02170888f, 0.13845088f, 0.03471578f, -0.00946965f, 0.23006216f, 
    0.10023190f, 0.16212380f, -0.03285933f, 0.01052851f, 0.31406885f, 0.13715322f, 0.13084626f, 0.01323508f, 
    -0.01411362f, 0.01533480f, -0.01982275f, 0.02072521f, -0.00882853f, -0.05058997f, -0.01940097f, -0.10309912f, 
    -0.18263888f, 0.04387848f, -0.12955154f, -0.04616818f, 0.13626567f, -0.08356148f, 0.19239852f, -0.01823004f, 
    -0.00206048f, -0.14432833f, -0.24819462f, 0.14292774f, 0.15345827f, 0.10433381f, 0.06702954f, 0.16916311f, 
    -0.08314776f, 0.03186113f, 0.06903390f, 0.02722084f, -0.08831080f, 0.13842775f, 0.20051919f, -0.17777207f, 
    -0.04727717f, -0.08708300f, 0.09893250f, 0.11220841f, 0.03566941f, -0.06992543f, -0.14979503f, 0.10706970f, 
    -0.13585429f, -0.18620944f, 0.01430182f, 0.08897459f, 0.01507209f, -0.06884587f, -0.14024681f, 0.06103825f, 
    -0.11594639f, 0.01644912f, 0.17736158f, -0.20716186f, -0.48504010f, -0.02063165f, 0.14408371f, -0.11137589f, 
    0.10149424f, -0.13180713f, -0.08470016f, 0.19095530f, 0.00996924f, 0.25350782f, 0.13439006f, -0.03624556f, 
    0.14330900f, -0.29718244f, -0.14477639f, 0.01673738f, 0.02699644f, -0.01195020f, -0.03406227f, 0.06180110f, 
    0.01895086f, -0.00038968f, 0.22066969f, -0.06843694f, -0.19870917f, 0.14757308f, 0.08062109f, -0.17204250f, 
    0.00053955f, -0.03116530f, 0.13563223f, -0.00828552f, 0.09230919f, 0.04881839f, 0.06666064f, -0.06068564f, 
    -0.22225094f, -0.28899235f, 0.14708897f, 0.25458628f, -0.11681455f, -0.11078578f, 0.04229353f, 0.12214518f, 
    0.09951250f, -0.01099645f, 0.18079129f, -0.04851324f, -0.03596275f, -0.05088948f, -0.06433738f, 0.05308529f, 
    0.01475323f, 0.09679206f, 0.11780556f, -0.18351333f, -0.03761375f, -0.06966776f, 0.03650668f, -0.07240099f, 
    -0.24283081f, 0.05321675f, -0.03335426f, 0.03271404f, 0.00862382f, -0.03511930f, -0.00451303f, -0.03604919f, 
    0.15585451f, -0.27782655f, -0.16535999f, -0.46555722f, 0.29475558f, -0.12287050f, 0.21942700f, 0.04359909f, 
    -0.12173181f, 0.05849437f, 0.00603094f, 0.14707054f, 0.13702786f, -0.00518220f, 0.02729074f, -0.05962142f, 
    -0.04373941f, -0.02846183f, 0.08613596f, -0.09772990f, -0.00577932f, 0.01199207f, -0.20007688f, 0.14115930f, 
    0.00117385f, -0.13004959f, -0.01116163f, 0.09497727f, -0.19707921f, 0.02447830f, -0.34728739f, -0.10918631f, 
    0.01328850f, 0.02710450f, -0.02926425f, -0.06568670f, 0.12322883f, 0.13337238f, 0.17754330f, -0.04284066f, 
    -0.32886314f, -0.10851707f, -0.12905209f, -0.15539591f, 0.10964271f, -0.07188443f, 0.07980280f, 0.08502761f, 
    0.02802054f, -0.04457720f, -0.06471173f, -0.00856371f, 0.29497799f, -0.03338834f, 0.05417456f, -0.02068539f, 
    0.08330362f, 0.03381275f, 0.11317913f, -0.22383069f, 0.08112834f, -0.03823057f, 0.09076590f, -0.02560081f, 
    0.03155206f, -0.11856323f, -0.44149682f, -0.39962375f, -0.08159367f, 0.04056273f, 0.20245460f, -0.22754890f, 
    0.09706978f, -0.02782883f, -0.06692573f, 0.07063571f, 0.45102048f, 0.48413447f, 0.13005745f, -0.06782965f, 
    0.06459688f, -0.11924174f, 0.05152989f, -0.00795075f, -0.03430601f, -0.03854486f, 0.08023993f, 0.09879886f, 
    -0.56864721f, 0.01866908f, 0.36352965f, 0.03590337f, 0.01232270f, -0.07115354f, -0.08491916f, 0.07454330f, 
    -0.03867475f, -0.00558243f, -0.10282799f, 0.19932136f, 0.03691041f, -0.27146766f, -0.01196975f, -0.22144410f, 
    -0.02580094f, 0.01421940f, 0.02382142f, 0.06420257f, -0.09357747f, 0.09102242f, 0.23761135f, -0.16869275f, 
    -0.28054580f, -0.00721174f, 0.08243997f, 0.10057390f, -0.04822003f, -0.12276453f, -0.01215282f, 0.08268660f, 
    -0.09672882f, -0.00460124f, 0.15778498f, -0.04131114f, 0.02953618f, 0.07081759f, -0.05384889f, 0.12085743f, 
    0.09686803f, 0.00204338f, 0.04701205f, -0.11895830f, 0.00688769f, -0.12061441f, 0.12683763f, 0.03533313f, 
    -0.02082186f, 0.00822078f, -0.12901615f, -0.24490456f, 0.06371255f, -0.00754355f, 0.05270794f, -0.05124269f, 
    -0.03029346f, 0.02972461f, -0.04990257f, 0.07893641f, -0.13557453f, -0.36973256f, -0.34232524f, 0.53046876f, 
    -0.07851207f, -0.05741984f, 0.15079239f, 0.05415137f, 0.10151205f, -0.06389274f, -0.03214843f, -0.06871485f, 
    0.36323732f, 0.21020080f, -0.03529334f, 0.19624251f, 0.02457749f, -0.03582553f, 0.04061812f, -0.02737048f, 
    0.28017011f, 0.19304557f, -0.06637447f, -0.14040995f, -0.25531691f, -0.00642527f, -0.30577287f, -0.14049558f, 
    -0.11111373f, 0.04621948f, 0.03022253f, 0.00215859f, -0.07397605f, 0.03436895f, -0.13676287f, 0.08881206f, 
    -0.26083785f, -0.55865937f, -0.47761148f, -0.03545744f, -0.14597552f, -0.14879330f, -0.02789577f, -0.14694302f, 
    -0.03278987f, 0.08164666f, 0.01030439f, 0.00148549f, 0.05412192f, 0.24176419f, -0.13113821f, -0.09582243f, 
    -0.14379914f, 0.04250869f, -0.14586663f, -0.02365007f, 0.12501264f, 0.01519499f, 0.04865421f, 0.02261680f, 
    0.29208693f, -0.29332259f, -0.58039039f, -0.24964146f, -0.17412493f, 0.17831662f, 0.20198044f, 0.05595069f, 
    -0.07815683f, 0.07767553f, -0.02094139f, -0.07142192f, -0.44680431f, -0.42974189f, -0.40673646f, -0.10459361f, 
    -0.18967018f, -0.30614486f, -0.20306154f, -0.15002720f, -0.05745813f, -0.06704236f, -0.09116474f, -0.05851080f, 
    -0.60362059f, -0.50675857f, -0.06401651f, -0.13046634f, -0.03116006f, -0.19601165f, 0.01533166f, -0.19715010f, 
    -0.03145964f, 0.07535082f, 0.06817327f, 0.01707361f, -0.52364242f, -0.58548278f, -0.40378866f, -0.29192778f, 
    0.07697894f, 0.01043400f, -0.11791798f, -0.37648696f, -0.04328289f, 0.00920725f, -0.03267946f, 0.02014662f, 
    0.19591342f, -0.12469357f, -0.08094560f, 0.01184846f, -0.00689604f, 0.04445883f, 0.21818043f, 0.09492502f, 
    -0.01580250f, -0.01691032f, -0.01561116f, 0.00335363f, -0.06544739f, -0.07538779f, -0.08226036f, -0.00002963f, 
    -0.08955001f, -0.00195736f, -0.05093714f, 0.04484003f, 0.07318214f, 0.01959291f, -0.14018461f, -0.01218510f, 
    -0.26096162f, 0.22092766f, 0.17237788f, 0.00022675f, -0.08617415f, -0.02691445f, -0.02439352f, -0.00015436f, 
    -0.02319787f, 0.14106153f, -0.02795892f, 0.12932621f, -0.09309712f, -0.03695106f, 0.10615755f, -0.17869757f, 
    -0.00299517f, -0.04171773f, 0.04373987f, -0.09338906f, -0.06687399f, 0.01802900f, -0.02193468f, 0.00587877f, 
    -0.49764436f, -0.18320504f, 0.01022507f, 0.02465649f, -0.03381117f, -0.28052008f, 0.05649533f, 0.06895321f, 
    0.00894415f, 0.01219764f, -0.00915992f, -0.09805793f, 0.04981775f, 0.00250405f, -0.01491407f, 0.21503624f, 
    -0.03548547f, -0.00241807f, 0.03394732f, 0.03936484f, 0.07705703f, -0.03669645f, 0.09486061f, -0.15615125f, 
    -0.20694298f, 0.03604736f, 0.00419815f, 0.07564729f, 0.02133102f, 0.01512419f, -0.03267321f, -0.00902803f, 
    -0.06985582f, -0.02170769f, 0.01190796f, 0.15841576f, -0.07330167f, -0.04952278f, 0.14658883f, -0.47618881f, 
    -0.00147022f, 0.09457165f, 0.09638236f, -0.04360617f, 0.01691121f, 0.09965092f, 0.04047363f, -0.02212107f, 
    0.10489244f, -0.22200750f, -0.04187227f, -0.17056186f, 0.03342786f, 0.09488837f, 0.12181756f, -0.19561699f, 
    -0.01048009f, -0.07743985f, -0.00217106f, 0.07329266f, -0.00294674f, 0.05117400f, -0.30678764f, -0.06943615f, 
    0.05574331f, 0.00315896f, 0.08607584f, -0.04719506f, -0.11700583f, 0.00856948f, -0.03930732f, 0.08228520f, 
    0.26891813f, -0.03500133f, -0.22183697f, 0.10525204f, -0.02686439f, -0.05352098f, -0.06896934f, 0.12669769f, 
    -0.02869996f, 0.00264885f, 0.29610389f, -0.02224735f, -0.42437556f, -0.38412219f, -0.27042669f, 0.52564859f, 
    0.09878350f, -0.01849642f, -0.03166208f, -0.39802402f, -0.01459652f, 0.03953767f, 0.02738544f, 0.06754693f, 
    -0.06052487f, -0.11788929f, 0.09061517f, 0.06320965f, 0.06543849f, 0.02784069f, -0.02350406f, -0.03350548f, 
    0.00304730f, -0.01605819f, -0.03845737f, 0.04310066f, -0.33462200f, 0.08880626f, 0.17382744f, -0.00717371f, 
    -0.03481171f, -0.05482552f, -0.02208286f, 0.08843549f, -0.06653443f, 0.08556022f, 0.06341907f, 0.09305353f, 
    0.35951364f, -0.03180684f, 0.10930113f, -0.48168930f, -0.00118655f, -0.03334448f, 0.14465353f, -0.04967831f, 
    0.18171060f, -0.07655856f, 0.05372968f, 0.12564719f, 0.20108555f, -0.06495983f, -0.16170050f, -0.29229197f, 
    0.03933278f, -0.02845139f, 0.14104870f, 0.03068589f, 0.00119667f, 0.07455428f, 0.07904578f, 0.02972386f, 
    0.09267518f, 0.25083846f, -0.00297134f, 0.15238295f, 0.06765566f, 0.07866741f, 0.02918487f, -0.03891116f, 
    0.17063580f, 0.06719219f, 0.25167832f, -0.03397892f, -0.03560049f, -0.23993045f, -0.04391607f, -0.17880844f, 
    0.02786021f, 0.10271288f, 0.02676756f, -0.04809443f, 0.03738265f, 0.07911024f, -0.02423533f, 0.03402472f, 
    0.08577941f, -0.02277099f, -0.15284552f, -0.07971330f, -0.01728531f, -0.09400616f, -0.00953988f, -0.00262188f, 
    -0.11660665f, -0.22803877f, -0.07285357f, -0.06557384f, 0.07384212f, 0.09373590f, 0.12142565f, -0.14099859f, 
    0.03984940f, 0.00922666f, 0.01463637f, 0.04828122f, -0.02414737f, 0.09939000f, 0.05008460f, 0.05892665f, 
    -0.20702037f, -0.06535488f, 0.21887912f, 0.12364616f, -0.03890221f, -0.12958334f, 0.01665854f, 0.12064262f, 
    -0.10581067f, 0.00658605f, -0.19273145f, 0.02107782f, -0.00852228f, -0.05857933f, 0.00589178f, -0.01896457f, 
    0.00863228f, 0.03409467f, -0.00726585f, 0.00220747f, -0.01843347f, -0.18756834f, -0.06517995f, -0.05412743f, 
    0.15049522f, 0.00385878f, -0.02496778f, 0.04033358f, -0.02405837f, -0.00627120f, 0.06295230f, -0.00767985f, 
    0.15495765f, 0.14145114f, 0.08535426f, -0.04000463f, 0.17771669f, 0.35902372f, 0.32590440f, 0.00130056f, 
    0.05599403f, -0.11642867f, -0.05728036f, -0.06284427f, 0.01215218f, 0.05613708f, 0.03280469f, 0.02438439f, 
    -0.07804210f, -0.01928560f, 0.23375550f, -0.06631479f, -0.00426532f, -0.02577839f, 0.10628069f, -0.08800004f, 
    0.00964316f, 0.04702793f, -0.15509066f, 0.04304317f, -0.47566009f, -0.33961827f, -0.06273727f, -0.18696102f, 
    -0.09280490f, -0.20071751f, 0.01091802f, -0.11458108f, -0.03390924f, 0.08034526f, 0.00297725f, 0.02230742f, 
    -0.08400209f, 0.06145398f, -0.02648612f, -0.17815734f, -0.02486325f, 0.03964712f, -0.03753803f, 0.00460841f, 
    -0.01602252f, 0.13548586f, 0.12790212f, 0.15234806f, 0.04756258f, -0.07360327f, 0.16780668f, -0.10615820f, 
    0.05855588f, 0.05135554f, 0.04216573f, 0.00760455f, 0.10594228f, 0.22094874f, 0.18009868f, 0.03859009f, 
    -0.15432180f, -0.05314374f, -0.08892153f, 0.09537599f, 0.03549756f, 0.03817290f, -0.03326689f, -0.01006275f, 
    -0.00361098f, -0.00926076f, -0.06959009f, 0.01672576f, -0.56178701f, 0.22415608f, 0.06570885f, 0.00121590f, 
    -0.16542482f, -0.13329533f, -0.09975202f, 0.06313653f, -0.10787110f, -0.04759727f, 0.01669388f, 0.01619312f, 
    -0.88703984f, -0.95116776f, -0.27299291f, 0.15875325f, -0.15584412f, -0.01527883f, -0.23279975f, -0.09885816f, 
    0.05268718f, 0.04563675f, -0.01284471f, 0.03253804f, 0.06366610f, -0.10338191f, -0.03156663f, 0.01714043f, 
    -0.00517833f, -0.03744963f, 0.19102401f, -0.08156598f, 0.02585794f, 0.00402893f, 0.04252649f, -0.05488261f, 
    -0.57641524f, -0.49392667f, -0.52091897f, -0.15308474f, -0.04875346f, -0.00125381f, -0.29544517f, -0.32669798f, 
    0.04761236f, -0.04253597f, -0.00008524f, -0.00055930f, 0.13158202f, 0.20853226f, 0.09200785f, -0.04075775f, 
    0.02224719f, -0.21345682f, 0.09147798f, 0.00281085f, 0.04073196f, 0.10817702f, -0.13158806f, -0.10049061f, 
    0.08557938f, -0.26126629f, -0.05800063f, -0.06284735f, -0.02313809f, 0.01587678f, 0.11465877f, -0.26005316f, 
    0.02224185f, -0.09530751f, -0.04983913f, 0.07647427f, -0.29507044f, 0.07001816f, 0.09050407f, -0.00248481f, 
    0.03102235f, -0.10309450f, -0.01046660f, 0.09440340f, -0.05552287f, -0.02953386f, 0.10318364f, -0.07144611f, 
    0.09738699f, -0.15958570f, -0.15531081f, 0.06987718f, 0.03451062f, 0.09243827f, 0.14062785f, 0.00619784f, 
    -0.09400619f, -0.08947107f, 0.06879400f, 0.01145410f, 0.05986787f, -0.12319633f, 0.05857434f, 0.10343213f, 
    0.04841249f, 0.07249282f, -0.06297388f, 0.15996607f, -0.02277046f, 0.07814658f, 0.01576813f, -0.05836843f, 
    -0.10491554f, 0.31147501f, 0.12035808f, 0.03620072f, -0.08053418f, 0.04295365f, -0.10914134f, -0.02786665f, 
    0.06472825f, 0.02981388f, 0.00744206f, 0.10793470f, -0.66108352f, -0.06931539f, 0.01891885f, -0.45865172f, 
    -0.11095542f, -0.22307381f, -0.19716606f, -0.08514947f, -0.02106047f, 0.00768545f, 0.04690161f, -0.01113430f, 
    0.00177193f, -0.06948007f, -0.00016341f, 0.09101754f, -0.01717339f, 0.02822451f, -0.00772876f, 0.08559841f, 
    0.09013797f, 0.04823544f, -0.00788008f, 0.15344168f, 0.05143896f, -0.00877816f, 0.07486560f, -0.01664997f, 
    -0.04544617f, 0.06227610f, 0.09025624f, 0.01450430f, -0.01803808f, 0.09009244f, 0.10626215f, -0.11809690f, 
    -0.14162779f, -0.02373251f, -0.00568063f, -0.14047815f, 0.00639557f, 0.07738503f, 0.06746081f, -0.01361121f, 
    0.14063796f, 0.06380579f, 0.17639829f, 0.12945579f, 0.07479396f, -0.08063449f, -0.10297667f, 0.44106629f, 
    -0.00370104f, 0.23140471f, -0.17207824f, 0.09573451f, -0.03623063f, -0.07444213f, 0.08482762f, 0.03810756f, 
    0.21542342f, 0.22211379f, -0.21025366f, -0.14379255f, -0.00249729f, -0.13003005f, 0.08947945f, 0.00759834f, 
    0.12022903f, 0.01509490f, 0.09272548f, -0.05672407f, 0.13522072f, -0.01509625f, 0.00173988f, -0.08187321f, 
    -0.00206568f, 0.00341947f, -0.05880964f, 0.01832447f, -0.03802049f, 0.08837287f, -0.02446858f, -0.14985757f, 
    -0.57839388f, -0.22934221f, 0.05187267f, 0.32261008f, 0.04421027f, -0.04435928f, -0.00079595f, 0.05748024f, 
    -0.00737706f, 0.04393124f, -0.03362565f, 0.07725154f, -0.22484922f, -0.51719540f, -0.39488584f, 0.24933504f, 
    -0.07045233f, 0.09866627f, -0.20133476f, -0.31287146f, -0.01508090f, -0.00497391f, -0.01198101f, 0.01740738f, 
    -0.30075559f, -0.04812566f, 0.00638351f, 0.15256287f, 0.02337751f, -0.01952421f, 0.03257906f, 0.03103541f, 
    -0.08551422f, -0.09909479f, -0.02924391f, -0.00399662f, -0.35919735f, -0.03523779f, 0.45109957f, -0.16955376f, 
    0.00694761f, 0.02488171f, 0.03770153f, -0.06921324f, -0.07692987f, 0.05473116f, 0.03366532f, 0.08813341f, 
    0.06710276f, 0.15974773f, 0.08273450f, 0.01163427f, -0.13129133f, -0.08169129f, 0.05415956f, 0.02906005f, 
    0.00293306f, -0.08336939f, -0.09186887f, 0.08311255f, 0.11855575f, 0.09536992f, 0.09383052f, 0.00330898f, 
    0.04111522f, 0.01388627f, 0.01913059f, 0.01120363f, 0.08103492f, -0.01565705f, 0.19937849f, 0.04688445f, 
    0.43927240f, -0.31868136f, -0.15806946f, -0.60010713f, 0.06853615f, 0.04316779f, 0.01412494f, 0.06512105f, 
    -0.02329536f, 0.11830891f, -0.05701778f, -0.13234538f, -0.03611397f, -0.11146161f, 0.13159545f, -0.09586947f, 
    0.06492559f, -0.00341272f, 0.00644234f, -0.04617370f, -0.13263838f, -0.11934292f, -0.03608394f, -0.16005303f, 
    0.10205545f, 0.08083525f, 0.01952750f, 0.12308952f, -0.08992618f, 0.07057057f, -0.03969198f, 0.05354712f, 
    -0.03394546f, 0.01737107f, -0.02840686f, -0.00008997f, -0.35180914f, -0.32322961f, -0.23542829f, 0.07937716f, 
    0.03741125f, 0.02532885f, -0.02544659f, -0.06513765f, 0.00978506f, 0.07193497f, -0.00845423f, -0.04215597f, 
    -0.27187550f, -0.15988931f, -0.18097140f, -0.01393737f, -0.06453031f, -0.07479168f, 0.08978687f, -0.07010728f, 
    -0.14816472f, 0.05499476f, 0.07375380f, 0.00828528f, 0.14912722f, -0.05806648f, 0.05373888f, -0.06688613f, 
    -0.00198059f, 0.05682569f, -0.07049196f, -0.01847092f, -0.01505012f, 0.06014656f, 0.01614327f, 0.06935298f, 
    -0.21976086f, -0.37054536f, 0.25866610f, -0.23559833f, 0.00993259f, -0.06041300f, -0.12715232f, 0.33531436f, 
    -0.00818441f, -0.09434681f, -0.07337819f, -0.04083399f, -0.06817261f, -0.10948022f, -0.07816787f, -0.05170383f, 
    0.11768451f, 0.03914134f, 0.00440825f, 0.08262345f, -0.10836639f, -0.00174680f, 0.00368030f, 0.07667390f, 
    -0.06379940f, -0.10789195f, -0.01821141f, 0.02589921f, -0.00291007f, 0.03559007f, -0.12781720f, -0.01228390f, 
    0.04249836f, 0.02425122f, 0.04060375f, 0.00399864f, -0.18917687f, -0.28687802f, -0.12988898f, -0.03347837f, 
    -0.00154541f, -0.13372143f, -0.09480022f, 0.04409583f, 0.03099705f, -0.00407956f, 0.01265056f, 0.02119011f, 
    -0.11726902f, -0.38736129f, 0.37841114f, -0.19730619f, -0.05167526f, -0.05753773f, 0.03276764f, 0.08416091f, 
    0.02722468f, -0.05065896f, -0.05725508f, -0.05458825f, -0.09929664f, -0.29303643f, 0.01278525f, -0.24335493f, 
    0.13514698f, -0.02038248f, -0.05012630f, 0.22449286f, 0.03158487f, 0.03179298f, 0.00794243f, -0.00549776f, 
    -0.39112493f, 0.19491972f, -0.21477325f, -0.04573362f, 0.11134826f, -0.04283143f, -0.09320504f, -0.11458507f, 
    0.02864626f, 0.11714659f, -0.02150137f, 0.00279904f, -0.00199293f, -0.00741630f, 0.06421144f, -0.05021571f, 
    -0.11388696f, -0.01058599f, 0.02898366f, -0.02157374f, 0.08689296f, -0.01492266f, 0.04096902f, 0.00918553f, 
    0.56964850f, -0.11321741f, -0.07595938f, -0.16606688f, -0.17851175f, -0.20116931f, -0.18747580f, 0.07571688f, 
    0.03749209f, -0.04427743f, 0.01591159f, 0.03507278f, -0.00909778f, 0.08900368f, 0.05422041f, 0.11950365f, 
    0.11258507f, 0.04516876f, 0.04447277f, -0.04678063f, 0.00231609f, -0.02106834f, 0.08098855f, -0.00713638f, 
    0.27367610f, -0.20249842f, -0.12636271f, -0.20007068f, -0.18278350f, 0.13041875f, -0.22436653f, 0.08305671f, 
    0.11639924f, 0.04153489f, 0.03168412f, 0.04338845f, 0.07442345f, -0.07262398f, 0.03926259f, -0.05963996f, 
    -0.06576991f, 0.05594432f, -0.02955946f, -0.07925433f, -0.14532115f, 0.05606733f, -0.10461246f, -0.03477629f, 
    0.09119146f, -0.08314223f, 0.02428042f, -0.08778650f, -0.00980449f, 0.05095854f, 0.01356190f, 0.00851979f, 
    0.01324038f, 0.10075581f, -0.02798466f, -0.07519172f, -0.10658211f, 0.16284864f, -0.02659938f, 0.17269166f, 
    0.05597213f, 0.10524715f, -0.07219718f, -0.00284083f, -0.04091511f, -0.03420794f, 0.00401637f, 0.06855049f, 
    -0.50785649f, 0.60921776f, -0.07417487f, 0.08496970f, -0.05367142f, 0.11873949f, -0.06687296f, -0.02815338f, 
    -0.05883418f, 0.03155364f, -0.00758803f, 0.01244226f, 0.17902035f, 0.01228010f, -0.09363690f, -0.09012125f, 
    -0.08030120f, 0.04222558f, -0.08771048f, -0.07282471f, -0.03743418f, 0.07541107f, -0.00924885f, 0.00222698f, 
    0.40870026f, 0.21274202f, -0.49430230f, 0.10933563f, -0.09059331f, 0.04819294f, 0.03565210f, -0.02379346f, 
    -0.06707303f, -0.05097256f, -0.07932381f, -0.08930460f, -0.02377555f, -0.16891888f, 0.12115256f, -0.32778513f, 
    0.08967584f, -0.17409739f, 0.09483636f, 0.18427506f, -0.05006627f, 0.04100414f, 0.04222025f, 0.01601241f, 
    -0.00143836f, 0.04278404f, 0.07417447f, -0.12380248f, 0.00467040f, 0.04280969f, 0.00126476f, 0.03465967f, 
    0.03184577f, -0.01029466f, 0.05657611f, -0.10378422f, 0.50894219f, -0.69541097f, -0.44575867f, -0.21715811f, 
    -0.09484993f, -0.16474009f, -0.11868801f, 0.04376636f, 0.25384954f, 0.01154096f, 0.00416825f, -0.05870807f, 
    -0.20443724f, 0.38898411f, -0.26678941f, 0.08561089f, 0.12217395f, -0.05774277f, 0.06972640f, 0.16700655f, 
    -0.08102413f, -0.06686082f, 0.07566074f, -0.01874564f, 0.00060999f, 0.06641089f, 0.00940042f, 0.08792790f, 
    -0.05638334f, -0.03847856f, -0.02739160f, -0.05475943f, 0.08014818f, -0.03673030f, -0.05164409f, 0.00871817f, 
    -0.38179511f, -0.11459398f, 0.25144160f, 0.09817683f, 0.02873317f, -0.07730693f, 0.22301102f, -0.03780861f, 
    -0.05494304f, -0.03890475f, 0.01597375f, 0.04234566f, 0.12584102f, 0.09007022f, 0.02697395f, 0.13645843f, 
    -0.15368050f, -0.08190652f, -0.16878311f, -0.06242922f, -0.04359094f, -0.07846239f, 0.01348974f, -0.03999188f, 
    0.02533287f, -0.04592765f, 0.01673231f, -0.05590034f, 0.02330198f, -0.05760725f, 0.00546700f, -0.02793125f, 
    -0.09874655f, 0.00663146f, 0.08890703f, 0.06563662f, 0.03685154f, 0.13227828f, -0.09238555f, 0.01213364f, 
    0.00822195f, -0.02575745f, 0.03145884f, 0.01962677f, 0.07475040f, 0.01859215f, 0.02355168f, -0.19724025f, 
    0.19089508f, -0.08634935f, 0.22745802f, -0.15521806f, 0.05054064f, 0.11190332f, 0.14121197f, 0.03782158f, 
    0.02237832f, -0.08944359f, 0.02895020f, -0.06852160f, 0.02459468f, -0.01580247f, 0.03835567f, -0.09727082f, 
    0.00838968f, 0.04604996f, -0.00279091f, 0.00120249f, 0.06793351f, -0.01943767f, 0.01497557f, -0.08942461f, 
    0.02033752f, -0.02413692f, 0.10427940f, -0.02344316f, 0.02147087f, 0.02454262f, 0.00570530f, -0.04194410f, 
    0.12584516f, -0.05365357f, -0.01865919f, 0.09537277f, -0.47037405f, -0.08269502f, -0.45284066f, -0.08521359f, 
    0.00890627f, -0.05614800f, 0.08175395f, 0.02710942f, -0.03892434f, 0.06039535f, -0.06221934f, 0.08450207f, 
    0.08132935f, 0.05593016f, 0.04374982f, 0.10305915f, 0.01712707f, 0.09458452f, 0.00741518f, 0.00495378f, 
    -0.04104420f, 0.06145288f, 0.01761580f, -0.02803992f, -0.19833122f, -0.46784446f, 0.39827025f, -0.12264406f, 
    -0.03926914f, -0.00192314f, -0.05642486f, 0.13918519f, -0.02800569f, -0.03819202f, -0.05480991f, -0.03145403f, 
    0.10879748f, 0.17675833f, 0.01096673f, 0.20180219f, -0.00073227f, -0.05122138f, -0.02140088f, -0.04045039f, 
    0.07308684f, 0.02207011f, 0.08561507f, -0.09094246f, 0.10427835f, 0.03970129f, -0.09003911f, 0.05876148f, 
    -0.04593199f, 0.03468642f, -0.06504829f, 0.04676890f, -0.00758987f, 0.06094950f, 0.03524548f, 0.08576912f, 
    -0.07724870f, -0.24393503f, 0.14585574f, -0.25447151f, 0.03763528f, -0.04956026f, 0.04538627f, -0.00535996f, 
    0.04672045f, 0.00943125f, -0.03056021f, -0.05339595f, 0.25984031f, -0.51304811f, 0.15919404f, -0.03532033f, 
    -0.10842223f, 0.14379475f, -0.03732052f, 0.04454586f, -0.13670507f, -0.08506251f, -0.00155106f, -0.04835226f, 
    -0.74557424f, -0.79011142f, 0.47200865f, 0.46496853f, 0.19415210f, 0.03937845f, 0.04796407f, 0.04874848f, 
    0.02497271f, -0.03118129f, -0.06074869f, -0.00365645f, -0.06246804f, 0.06962845f, 0.05555009f, -0.03406036f, 
    0.06309800f, 0.02597619f, -0.05119203f, -0.03957865f, 0.02810847f, 0.00890016f, -0.00653512f, 0.02089028f, 
    -0.26122320f, -0.21338022f, -0.12455562f, -0.01669408f, 0.12239002f, 0.06088577f, 0.03031909f, 0.10293280f, 
    0.02171537f, -0.02833183f, -0.02065192f, 0.02449496f, -0.13221328f, 0.06399611f, -0.06214490f, -0.02130764f, 
    -0.07358090f, -0.00438793f, 0.02419406f, -0.05417309f, -0.06982875f, -0.10616592f, 0.03652766f, 0.03915578f, 
    -0.09951095f, 0.16326450f, 0.01550640f, -0.03348574f, -0.07264841f, -0.25236878f, -0.10124802f, 0.17443921f, 
    0.00834201f, 0.09033098f, -0.01413530f, 0.00646906f, 0.27252406f, -0.30052894f, -0.09042805f, -0.23281054f, 
    0.10634374f, 0.01150965f, -0.00968538f, -0.04745702f, 0.06355350f, 0.15736306f, 0.03199413f, -0.13239850f, 
    0.08851670f, 0.00916295f, 0.03105429f, -0.05574635f, -0.03606025f, -0.02949962f, 0.03264061f, -0.02974161f, 
    0.00333074f, -0.07040359f, 0.10618291f, 0.02031020f, 0.16885914f, 0.01398620f, 0.08055907f, -0.13901082f, 
    0.02799594f, -0.04516648f, -0.07846259f, -0.02544868f, -0.05084562f, -0.02907825f, -0.03412528f, -0.04037928f, 
    0.07040539f, -0.13662119f, -0.07140806f, -0.05441678f, -0.07716011f, -0.04301440f, 0.04670462f, -0.03966673f, 
    -0.10321198f, -0.10372328f, 0.00685205f, -0.03127659f, 0.22926457f, -0.32940087f, -0.31720924f, -0.08565698f, 
    0.09113361f, 0.03743226f, 0.15139715f, -0.09415541f, 0.01944862f, -0.06634860f, 0.06508218f, 0.04721082f, 
    0.34835988f, -0.09082182f, -0.10743736f, -0.38041860f, 0.01234815f, 0.02528092f, -0.05655425f, -0.08695020f, 
    -0.13061045f, -0.03637903f, -0.05954367f, -0.34730220f, -0.00771396f, 0.01788288f, 0.00714596f, 0.04284368f, 
    0.03397920f, 0.01446531f, -0.08024532f, -0.08265907f, 0.03885834f, -0.01503950f, 0.02681045f, 0.06138313f, 
    0.28415018f, 0.10398746f, -0.33970416f, 0.06299273f, 0.04829204f, -0.10605944f, -0.03555814f, -0.04825671f, 
    -0.00383442f, 0.12877132f, 0.00102233f, 0.03473629f, 0.35086560f, -0.19105023f, 0.15141946f, -0.16454576f, 
    0.04870616f, -0.20968492f, -0.05832436f, 0.04522968f, -0.02283037f, -0.04295676f, 0.11390956f, -0.08448742f, 
    -0.25099236f, -0.21298237f, 0.15496245f, -0.03835300f, -0.08390705f, 0.06048424f, 0.03263519f, 0.02053395f, 
    -0.12753883f, 0.10848096f, -0.00164800f, 0.00138527f, -0.08318372f, 0.02405170f, 0.05524607f, 0.00681928f, 
    0.02602647f, 0.04699253f, -0.01200264f, 0.02733721f, -0.00039794f, -0.03206674f, -0.07091018f, -0.24839531f, 
    -0.23215933f, -0.49864832f, -0.31729868f, -0.61264795f, 0.02634324f, 0.28284809f, 0.05362437f, 0.10466155f, 
    0.07918159f, -0.11235420f, 0.01499356f, 0.07885925f, -0.21097547f, -0.13766421f, 0.08157796f, 0.17441674f, 
    0.06717356f, -0.10552464f, -0.06687315f, 0.04196740f, -0.00316095f, 0.05986120f, 0.03184315f, -0.01841698f, 
    -0.13493207f, -0.15545629f, 0.03046379f, -0.00279973f, 0.21776645f, 0.06858309f, -0.20175555f, -0.12832066f, 
    0.02074350f, -0.02349873f, 0.01865906f, 0.00365799f, -0.42951167f, -0.59829968f, -0.16592664f, -0.14189090f, 
    0.06562888f, 0.10155635f, -0.04130031f, 0.10187234f, -0.05136742f, 0.15249574f, 0.02824332f, 0.00157590f, 
    0.09551535f, -0.35076985f, 0.27750263f, 0.13047256f, -0.03127070f, 0.07119364f, 0.09935393f, 0.25823858f, 
    0.03413187f, 0.01743082f, 0.09429723f, 0.07365298f, -0.58345312f, -0.04943803f, 0.33672294f, -0.15836842f, 
    -0.06701501f, -0.09379583f, -0.06003086f, -0.06255870f, -0.01783334f, 0.15258075f, -0.12691180f, -0.11772788f, 
    -0.05963311f, -0.04027416f, -0.19622654f, 0.10043110f, -0.01815169f, -0.00437001f, 0.12138917f, -0.02568955f, 
    0.18596445f, 0.14315864f, 0.06404831f, 0.01040209f, -0.14021489f, -0.08783752f, 0.06186910f, -0.09741295f, 
    -0.01532547f, -0.01092005f, 0.07821997f, -0.03680386f, 0.04749719f, -0.02315877f, 0.05921594f, 0.09740339f, 
    -0.07553349f, 0.05773918f, 0.01454487f, 0.04292561f, 0.02455196f, -0.14360794f, -0.13317479f, 0.05742520f, 
    0.09918747f, 0.03476919f, 0.10580672f, 0.06993440f, -0.04378019f, -0.11334732f, -0.12907405f, 0.16596159f, 
    0.01352885f, 0.05536767f, 0.09163483f, -0.05489130f, 0.00942865f, -0.00937556f, 0.02706701f, 0.02187836f, 
    -0.47193453f, 0.20049916f, 0.01723482f, 0.15531336f, 0.04220017f, 0.09014989f, 0.04554474f, 0.07610290f, 
    -0.08002355f, 0.04015752f, -0.10408127f, 0.16521831f, 0.19398811f, 0.13785326f, -0.00010205f, 0.12557454f, 
    0.04576831f, -0.12000403f, -0.10059469f, -0.03524324f, 0.06235503f, -0.03211315f, -0.09410856f, 0.03677487f, 
    0.13224594f, -0.05937521f, -0.36896810f, -0.50588804f, -0.23277879f, -0.21905522f, 0.01329897f, -0.18998879f, 
    0.03620554f, 0.01382293f, -0.03681658f, 0.02819515f, 0.00365437f, -0.14535606f, -0.16177823f, -0.02386892f, 
    -0.04227621f, 0.11326368f, -0.01711628f, 0.01276486f, -0.12943211f, -0.18710966f, -0.09468969f, -0.14091741f, 
    -0.04380224f, 0.06178702f, 0.14846775f, 0.13423635f, 0.14201060f, -0.13572219f, 0.02812804f, -0.08843025f, 
    -0.01075025f, 0.02710950f, 0.00814848f, -0.04488850f, -0.10441356f, -0.28180841f, -0.23336127f, -0.04462320f, 
    0.17034315f, 0.02928839f, -0.01510767f, -0.04319062f, -0.02073408f, 0.04548360f, 0.07619945f, 0.10856448f, 
    0.08906545f, -0.25164980f, -0.33629072f, -0.27571979f, 0.05364313f, -0.11657634f, 0.03524266f, -0.14649485f, 
    0.01490245f, 0.05554992f, -0.00256928f, 0.01381945f, -0.12027062f, -0.25829446f, -0.44013742f, -0.15831992f, 
    0.06721994f, -0.04359044f, 0.09208289f, -0.11005065f, 0.03897205f, -0.05773125f, 0.05739954f, 0.04654385f, 
    -0.08916761f, -0.08476015f, -0.00888565f, 0.17846642f, 0.05044363f, -0.02080469f, 0.01145104f, -0.08313967f, 
    0.02202532f, -0.01781183f, 0.10306905f, -0.00309825f, 0.10055504f, 0.08088226f, 0.07467425f, -0.04554224f, 
    -0.08187700f, -0.10224385f, 0.05322167f, 0.04534666f, 0.12378921f, 0.08103438f, 0.03737075f, 0.02958878f, 
    -0.21143258f, -0.22433901f, -0.34962261f, -0.12619257f, -0.00074418f, 0.04844633f, 0.15472735f, 0.12917604f, 
    0.07406674f, -0.01620783f, -0.16021241f, -0.05794396f, -0.41457587f, 0.00066799f, 0.10307096f, 0.13243282f, 
    -0.15532778f, 0.02977546f, -0.06035012f, -0.02142548f, -0.11201144f, -0.11840238f, -0.14679989f, -0.03710794f, 
    -0.32742062f, -0.25908101f, -0.26081693f, 0.06374227f, 0.19778733f, 0.05159750f, 0.15641478f, 0.10337212f, 
    0.04932122f, -0.02868777f, -0.02490305f, 0.00799988f, -0.00119729f, 0.13294995f, -0.03118881f, -0.07534450f, 
    0.01814318f, 0.03976228f, 0.00639575f, 0.07924588f, 0.07908652f, -0.02936822f, 0.09708349f, 0.09318587f, 
    0.08692711f, 0.08875480f, -0.01799863f, -0.18487079f, 0.15473399f, -0.07880802f, -0.07658350f, 0.00929973f, 
    0.12539467f, 0.06875992f, 0.07317892f, 0.11417014f, -0.60854012f, 0.04486561f, 0.12433241f, 0.23883629f, 
    0.00539307f, -0.12774940f, -0.09279438f, 0.00121458f, -0.02510042f, -0.07603461f, -0.23001280f, -0.04345179f, 
    -0.30660102f, -0.06805301f, 0.13506049f, 0.20594282f, 0.12244559f, -0.02089008f, -0.03076129f, 0.06305347f, 
    -0.00414396f, 0.00984528f, 0.04455912f, -0.01646160f, 0.41632238f, 0.07071137f, 0.03882261f, 0.05262107f, 
    0.01077004f, -0.06926492f, 0.05163424f, 0.05853846f, 0.17667045f, -0.06028386f, 0.12436677f, 0.07661741f, 
    0.38031337f, -0.04124837f, -0.28176129f, -0.08500081f, -0.00896718f, 0.09195916f, 0.00729408f, -0.00714749f, 
    0.14121178f, 0.09500924f, 0.07016842f, 0.04134493f, 0.49317312f, 0.29277879f, 0.09116244f, -0.10081835f, 
    -0.12705258f, -0.04639087f, -0.15893672f, -0.17433818f, 0.05474737f, 0.04573678f, 0.03360560f, 0.05801713f, 
    -0.02179963f, 0.04758345f, 0.00352619f, 0.01899283f, -0.09646092f, -0.05165732f, 0.03042226f, 0.00090565f, 
    0.01136421f, 0.07290618f, 0.10322433f, 0.01567745f, -0.35460696f, -0.29438484f, -0.07342114f, -0.03810088f, 
    0.08064802f, 0.10891919f, 0.19057575f, 0.03588890f, -0.18402801f, -0.01346897f, -0.18461268f, -0.39694935f, 
    -0.51745218f, -0.20288460f, 0.27043226f, 0.31853831f, 0.15882307f, 0.07653429f, -0.12563142f, 0.10224008f, 
    0.07385480f, -0.22704217f, 0.01940659f, -0.06578990f, -0.17355798f, 0.13458142f, -0.08376573f, -0.00489530f, 
    0.05372825f, 0.04439108f, 0.00398391f, 0.11687963f, 0.00033738f, 0.07398591f, -0.01795958f, -0.07695577f, 
    -0.37898508f, -0.25167823f, 0.28366500f, 0.17132093f, -0.06450848f, 0.04160007f, -0.07778997f, -0.09495389f, 
    -0.00510930f, 0.10461747f, -0.08761159f, 0.12999585f, -0.09334952f, 0.02119703f, 0.01780607f, -0.01869203f, 
    -0.07128836f, 0.09964001f, 0.02544763f, 0.14789484f, 0.02417580f, -0.00280093f, -0.05530647f, 0.02674064f, 
    -0.14259370f, -0.02085325f, -0.06482734f, -0.04149922f, 0.02023302f, 0.03277950f, 0.00073777f, 0.01197988f, 
    0.03850562f, 0.01984466f, 0.07438600f, 0.02403281f, -0.13451803f, -0.11152489f, -0.06302529f, -0.02035884f, 
    -0.07071645f, -0.04468500f, 0.01233203f, -0.00940226f, -0.16152197f, -0.00489365f, -0.15930709f, -0.22242390f, 
    0.09314089f, -0.13512523f, -0.14989428f, 0.08243286f, -0.12134860f, -0.06708778f, 0.13145125f, 0.04681547f, 
    0.06253689f, 0.03855733f, 0.09917360f, 0.17529364f, -0.16213301f, -0.01791403f, 0.01256421f, -0.05602907f, 
    -0.09007333f, -0.00539712f, 0.02807872f, -0.06574638f, 0.04702936f, 0.08542630f, 0.02741629f, 0.12743793f, 
    -0.22485656f, -0.11992960f, 0.03157930f, 0.07952151f, -0.01083834f, -0.06894241f, -0.02009097f, -0.01306650f, 
    -0.13694914f, 0.05170138f, -0.25379986f, -0.38553905f, -0.34801379f, -0.27809948f, -0.08078023f, 0.18895394f, 
    0.04913891f, 0.11306165f, 0.09392592f, 0.06730532f, -0.08844005f, -0.03289728f, 0.04494824f, -0.01047895f, 
    -0.39939931f, -0.01064274f, 0.14909397f, 0.15925431f, -0.10139644f, 0.01989706f, -0.07222977f, -0.11402135f, 
    0.01089274f, -0.03424402f, 0.11083003f, 0.10558522f, -0.01726853f, -0.40291813f, -0.36060381f, -0.46511936f, 
    -0.03209720f, -0.02486451f, 0.06794317f, -0.12848246f, -0.00836735f, -0.05799418f, 0.05323962f, -0.04049899f, 
    -0.24877477f, 0.01319487f, 0.03998204f, 0.10285352f, 0.04207031f, -0.01434723f, -0.03409529f, 0.03109114f, 
    0.04955820f, -0.02611267f, -0.12359345f, -0.16122125f, -0.04682070f, 0.07513506f, -0.00621573f, -0.00524800f, 
    -0.04301164f, -0.03715541f, -0.04016870f, 0.04938440f, -0.15557337f, 0.02124030f, -0.16564564f, -0.31624624f, 
    0.36108017f, -0.06653846f, 0.02574511f, -0.18800795f, 0.06866854f, -0.03461973f, -0.04231856f, -0.14511864f, 
    0.00564311f, 0.09144522f, 0.00513693f, 0.08848289f, 0.27371356f, -0.12856516f, -0.15473652f, -0.10517225f, 
    0.01001840f, 0.06035381f, 0.03931233f, -0.06536066f, 0.15977184f, -0.01905254f, 0.01582502f, -0.01322075f, 
    0.66266900f, -0.05217536f, -0.42123544f, -0.35088930f, 0.08531215f, -0.03141091f, 0.04327886f, -0.05541893f, 
    0.05484772f, 0.12758361f, 0.07609981f, 0.03158023f, -0.13141793f, 0.06944138f, 0.01112279f, 0.10871290f, 
    -0.01992323f, -0.02571539f, -0.04234685f, 0.00780094f, -0.08331060f, 0.07181232f, 0.01317391f, -0.00087172f, 
    -0.16281371f, -0.21148027f, -0.13257162f, -0.00084218f, 0.01176450f, 0.03406701f, 0.07790882f, 0.09046957f, 
    -0.00445873f, -0.00040259f, 0.01029789f, 0.03594948f, -0.21822633f, -0.13945211f, -0.10542893f, 0.09360490f, 
    0.11269360f, 0.09439220f, 0.22139022f, 0.02157995f, 0.03954323f, 0.04420952f, 0.03537784f, 0.12665528f, 
    -0.12475813f, 0.02485529f, 0.06367341f, 0.00020902f, -0.08919452f, -0.00325903f, -0.08149536f, -0.07363507f, 
    0.08518212f, 0.06755707f, 0.04077331f, 0.05361528f, 0.14973396f, -0.08640599f, -0.13145499f, -0.23878999f, 
    -0.10914396f, -0.00620492f, 0.03090865f, 0.11560241f, 0.03522111f, 0.04691224f, 0.06399628f, 0.03008861f, 
    -0.25499132f, 0.04671360f, -0.04027633f, -0.12630294f, 0.08673657f, 0.01028281f, -0.02002858f, -0.15638362f, 
    -0.33749613f, -0.23908521f, -0.25021717f, -0.07883316f, 0.00921907f, 0.05118358f, 0.01706226f, -0.08502066f, 
    0.00218733f, 0.01208664f, -0.02965154f, 0.04401204f, -0.00181515f, 0.09862052f, -0.03137498f, -0.06363968f, 
    -0.12541306f, -0.08982743f, -0.06802449f, 0.01567503f, -0.00369904f, 0.05262343f, 0.10884337f, 0.01803890f, 
    0.12806626f, 0.01493881f, -0.02551259f, -0.02896738f, -0.14393833f, -0.49217036f, -0.29991588f, 0.05869545f, 
    -0.08973254f, 0.18294838f, 0.06984037f, -0.02138903f, -0.08656506f, 0.07767630f, -0.03870834f, 0.02589612f, 
    0.29250804f, 0.06035007f, -0.11170428f, -0.25160637f, 0.03286644f, -0.00723060f, -0.00050927f, -0.05529312f, 
    0.17520742f, 0.07818772f, 0.16795491f, 0.15068373f, -0.19689728f, -0.00133936f, 0.05547145f, 0.07289211f, 
    0.01968575f, -0.02858279f, -0.15254635f, 0.01079987f, -0.25951245f, -0.18027748f, -0.17678238f, -0.11409077f, 
    0.25042939f, -0.09203812f, -0.07140494f, -0.02291504f, -0.00890833f, 0.09643123f, -0.01377779f, 0.11162716f, 
    -0.05548330f, -0.03483542f, -0.14167823f, -0.10019949f, 0.14812948f, 0.22640255f, -0.03117333f, -0.30626249f, 
    0.12389586f, -0.13334095f, 0.04895623f, -0.02537364f, 0.12073243f, 0.13973856f, -0.14504729f, 0.12951215f, 
    0.09529386f, -0.14438814f, 0.04475840f, 0.08148685f, -0.03319257f, -0.14385068f, 0.01728509f, 0.05041309f, 
    -0.04076807f, -0.04119946f, 0.04665016f, -0.04430528f, -0.00056415f, 0.09105100f, 0.00848417f, 0.13913916f, 
    -0.16585836f, -0.01753556f, -0.01262490f, 0.05499526f, -0.01621110f, 0.08651066f, -0.07707155f, 0.11213342f, 
    -0.48739547f, -0.50932634f, -0.28349388f, 0.30200240f, 0.03698718f, -0.01864746f, -0.02811563f, 0.10194639f, 
    -0.06126239f, 0.08562657f, -0.00810100f, -0.01504344f, 0.17796817f, 0.13606718f, -0.05083297f, -0.01589922f, 
    -0.09223024f, -0.14591074f, -0.25536454f, -0.28769824f, 0.10097279f, 0.10194656f, -0.03710599f, 0.06992854f, 
    0.27985260f, 0.21192782f, -0.44936520f, 0.11239314f, 0.06707525f, -0.10552976f, 0.00892485f, 0.17106599f, 
    0.02032268f, 0.08873411f, 0.00243667f, -0.11426036f, 0.18754421f, 0.21151225f, 0.26120225f, -0.68335491f, 
    -0.17826723f, -0.20290749f, -0.04508895f, -0.02996844f, 0.14298651f, 0.03897540f, 0.02416442f, -0.00969918f, 
    0.39784101f, -0.03031656f, -0.05084485f, -0.27140385f, 0.08490966f, -0.08169630f, -0.09497363f, -0.03485211f, 
    -0.04085326f, -0.14836726f, -0.02045094f, 0.11977044f, -0.13516477f, -0.16032846f, 0.04892676f, 0.02752504f, 
    0.05433528f, -0.02101639f, 0.03946816f, -0.04249144f, 0.08161301f, 0.23042692f, 0.01386914f, -0.27183810f, 
    0.20282704f, 0.17971343f, 0.36625195f, 0.28779173f, 0.08721180f, -0.04039842f, -0.16103531f, -0.06412330f, 
    0.00535688f, -0.02587491f, 0.03557082f, 0.03281894f, 0.19797125f, -0.27147052f, 0.27677533f, -0.30453819f, 
    -0.06607080f, -0.02796655f, -0.03325798f, 0.06409316f, -0.02282724f, 0.02076418f, 0.00541442f, 0.01338895f, 
    -0.08961517f, -0.01712979f, -0.30963102f, 0.13934469f, -0.03576284f, 0.02002477f, 0.23231649f, 0.06299868f, 
    0.05469663f, -0.05844929f, -0.12148132f, -0.05906003f, -0.05695520f, 0.03747996f, 0.25746906f, -0.34778655f, 
    -0.06215235f, -0.10421287f, -0.01815133f, -0.16029713f, -0.04579289f, 0.03255547f, 0.07711315f, 0.11892987f, 
    -0.09976771f, 0.16570000f, 0.50680757f, -0.33920157f, 0.10297737f, -0.18197413f, 0.07706983f, -0.14830337f, 
    -0.17312962f, 0.00698319f, 0.04811574f, -0.12279303f, -0.09550011f, -0.09206597f, -0.22121562f, 0.13780217f, 
    0.20587012f, 0.07946076f, 0.12860309f, -0.02556792f, 0.03924624f, -0.03690349f, -0.03965744f, -0.03135162f, 
    -0.28458145f, -0.00334562f, 0.28528970f, 0.08418997f, -0.07844944f, 0.04192501f, -0.08328644f, 0.10458051f, 
    0.12286369f, 0.08321298f, 0.08137882f, -0.03537560f, -0.07683152f, 0.06292615f, 0.26201579f, 0.02428714f, 
    -0.04950616f, -0.23063977f, -0.22541477f, -0.10822145f, -0.00985739f, 0.22891703f, 0.10793324f, 0.04562603f, 
    -0.08127616f, -0.05621551f, -0.68876284f, 0.20993921f, 0.09793905f, 0.05728338f, 0.13919063f, 0.03302085f, 
    0.09612503f, -0.11012711f, 0.10683706f, 0.03182071f, 0.02420496f, -0.18018721f, 0.05274916f, -0.27321061f, 
    0.01810145f, -0.13696380f, -0.11819579f, 0.07513411f, -0.00184417f, -0.04876302f, -0.01967000f, 0.00654054f, 
    -0.08113012f, 0.18084030f, -0.08960067f, -0.11034386f, -0.12857938f, -0.02131929f, 0.07617407f, -0.00828988f, 
    0.10487506f, 0.06060289f, 0.00074928f, -0.05366885f, -0.32643247f, -0.10195815f, -0.14845173f, -0.18922989f, 
    -0.48231289f, 0.07014187f, -0.06758704f, 0.19540325f, 0.08036755f, -0.03179595f, 0.01388891f, -0.02973055f, 
    -0.30004504f, 0.08692928f, -0.52253085f, -0.29907146f, 0.01572135f, 0.05198801f, 0.15514894f, 0.08980287f, 
    0.00036052f, -0.05823341f, -0.03543130f, 0.03614968f, 0.16427210f, -0.63621265f, 0.00729598f, -0.06817970f, 
    0.31722248f, 0.17024608f, -0.17787042f, 0.07247919f, -0.13381818f, -0.04449407f, -0.12520409f, -0.09691366f, 
    0.16607042f, 0.04908017f, 0.07080200f, 0.13550816f, -0.06231137f, -0.05551735f, -0.25859541f, -0.17066489f, 
    0.22741148f, -0.04341328f, 0.04212603f, 0.18356976f, -0.10793145f, -0.02752232f, -0.02769617f, -0.07526668f, 
    0.12317173f, 0.06918075f, 0.14417857f, 0.16727385f, 0.01812130f, 0.09369998f, -0.08806673f, -0.03929328f, 
    0.09557894f, -0.15029840f, -0.14210229f, -0.33927679f, -0.09631082f, 0.13926241f, 0.03071077f, -0.06607503f, 
    0.11037646f, -0.01371226f, 0.01933416f, 0.03712195f, -0.06599587f, 0.07063294f, -0.05581138f, -0.17610176f, 
    0.05492342f, 0.06512360f, -0.03518467f, 0.18681595f, 0.01657544f, -0.02998158f, 0.05733918f, -0.19295256f, 
    -0.00434341f, -0.21915463f, -0.09093380f, 0.05410590f, 0.00332452f, -0.01474025f, -0.02557712f, 0.01393828f, 
    -0.14515211f, -0.06491525f, -0.01089161f, -0.09099120f, -0.32816833f, 0.09646230f, -0.48316503f, 0.19281293f, 
    0.11344485f, -0.07331794f, 0.06314845f, 0.11619401f, 0.00181818f, -0.06623682f, -0.05869157f, -0.02255001f, 
    -0.25440469f, -0.01586699f, -0.24120691f, -0.25960031f, -0.08856019f, 0.05330644f, 0.11833526f, 0.17623834f, 
    -0.01781735f, -0.01019489f, -0.04130566f, -0.02359173f, -0.17066686f, -0.06973977f, -0.36088508f, 0.26680416f, 
    0.06597934f, 0.02946230f, 0.14096889f, -0.02336400f, -0.00486138f, 0.04477972f, -0.06170977f, -0.09247434f, 
    -0.92535073f, 0.25399208f, -0.09181668f, 0.31975913f, -0.01743900f, -0.05770951f, -0.20143509f, -0.23933029f, 
    -0.02139713f, -0.09139304f, 0.04916041f, -0.10256965f, -0.68516678f, -0.89993125f, 0.30581293f, -0.51800776f, 
    -0.02103529f, 0.10374288f, -0.32409889f, 0.23650122f, 0.06480979f, -0.03391607f, -0.00117893f, 0.01940684f, 
    0.00412162f, -0.43711013f, 0.08144664f, 0.06304031f, 0.04235035f, 0.20221633f, -0.03069449f, 0.06020856f, 
    -0.09696751f, 0.03815655f, -0.09170834f, -0.03966078f, 0.08913116f, -0.11931347f, 0.38336733f, 0.09498017f, 
    -0.00120578f, -0.07357124f, -0.04373299f, -0.25664130f, 0.05271262f, 0.03104940f, 0.07752546f, 0.00168828f, 
    -0.18261430f, 0.09867341f, -0.38286757f, 0.10803404f, 0.02203690f, -0.20218569f, 0.07880970f, 0.11047745f, 
    -0.06652806f, -0.09066959f, -0.12552492f, -0.05690752f, -0.04067705f, -0.00443084f, -0.28429607f, 0.06413541f, 
    -0.05320153f, 0.07648836f, 0.07117916f, 0.07283907f, 0.07984953f, -0.01196625f, 0.12505047f, 0.03627383f, 
    0.08670053f, -0.34166989f, 0.27274868f, -0.44369683f, -0.00950021f, -0.10519440f, -0.09449649f, 0.00666925f, 
    -0.07867207f, 0.05853784f, -0.11134243f, 0.01724575f, -0.40927562f, -0.13777162f, 0.05223206f, 0.18459263f, 
    0.06721248f, 0.02998440f, 0.06687164f, -0.03974795f, 0.06840635f, 0.12283952f, -0.03173826f, -0.11924277f, 
    -0.04579873f, 0.02258774f, 0.07377623f, -0.05401006f, 0.06851230f, 0.19118200f, 0.03124579f, 0.05016893f, 
    0.11953901f, 0.06418757f, 0.08312524f, 0.09629335f, -0.08832096f, -0.01692017f, 0.08531966f, 0.19144434f, 
    0.06126030f, 0.02591814f, -0.01904658f, -0.00160944f, 0.04790508f, 0.16395442f, 0.06278674f, 0.11690370f, 
    0.22329454f, -0.26153952f, 0.12519369f, -0.26635084f, 0.05558842f, 0.02231485f, 0.03664965f, -0.13062039f, 
    -0.11585553f, -0.06087940f, -0.14295644f, 0.17393161f, 0.06177863f, -0.10996567f, 0.03690939f, 0.08357195f, 
    0.12593968f, 0.17331383f, 0.03727473f, -0.05740926f, 0.08446717f, 0.09264260f, -0.02791148f, 0.01434936f, 
    0.13422365f, -0.05867058f, 0.03279044f, -0.02546768f, -0.03679984f, -0.03432785f, 0.02283855f, 0.03831503f, 
    0.10039347f, 0.06137531f, 0.08819911f, 0.21410914f, 0.15575841f, 0.21487798f, 0.23995683f, -0.66534609f, 
    0.02892004f, -0.24288736f, -0.02975098f, 0.00647359f, -0.08058872f, 0.12193666f, 0.09007714f, 0.06564741f, 
    -0.13895862f, -0.22117129f, -0.11800596f, -0.23954839f, 0.09353408f, 0.05932040f, 0.04534518f, 0.08787812f, 
    -0.03854326f, -0.05531576f, 0.01558804f, -0.03607354f, -0.17823854f, 0.05697909f, 0.09250240f, -0.18835780f, 
    -0.12815177f, 0.01664395f, 0.06685507f, 0.08593969f, 0.12835807f, 0.13754401f, 0.05031289f, 0.03612770f, 
    -0.09081929f, -0.05077153f, 0.06746350f, 0.03398100f, 0.04811849f, 0.01822997f, 0.03373340f, 0.01683586f, 
    0.04101130f, 0.08228067f, 0.16936302f, 0.13705902f, -0.21726122f, -0.02981031f, -0.14128780f, 0.17457277f, 
    -0.04238911f, 0.05920674f, -0.04602413f, -0.07451481f, 0.00017667f, -0.05667381f, 0.16394310f, 0.15797229f, 
    0.06065916f, -0.53631186f, 0.07352006f, 0.02423669f, 0.20457411f, -0.02550873f, 0.08487537f, 0.00431041f, 
    0.08253922f, 0.06611752f, -0.06877930f, -0.08152401f, 0.08023384f, -0.01505483f, 0.09048611f, 0.07166108f, 
    -0.09483478f, -0.07870960f, -0.11390048f, 0.04305805f, 0.02979687f, 0.02317625f, 0.06397917f, 0.03280639f, 
    0.28879517f, -0.36957973f, -0.16237831f, -0.04154840f, -0.06080467f, 0.00768532f, 0.08026309f, 0.12309258f, 
    0.03459990f, 0.04616939f, -0.07234976f, -0.05568675f, -0.19814464f, 0.05815762f, -0.26620293f, -0.16403580f, 
    0.16064587f, 0.09461431f, 0.03393925f, 0.13826688f, 0.03645699f, 0.00798276f, -0.18454443f, -0.09880688f, 
    0.05086548f, 0.11701094f, 0.18103267f, -0.10274424f, -0.09834238f, 0.03732516f, 0.03901427f, 0.25234419f, 
    -0.01402155f, 0.00659148f, 0.00598484f, -0.02411771f, 0.14045861f, 0.19148050f, 0.21107192f, -0.47715512f, 
    0.13106935f, -0.15113901f, 0.05927794f, 0.02419544f, -0.05964421f, 0.06597444f, 0.00749140f, 0.01072458f, 
    -0.16411012f, 0.22359084f, -0.13307710f, -0.06674628f, 0.10231087f, 0.03949367f, 0.08068623f, 0.09195726f, 
    0.11261824f, -0.04739654f, -0.08443020f, -0.07878975f, 0.22454624f, -0.39828601f, 0.30248863f, 0.52699608f, 
    0.16060808f, -0.01553449f, -0.17309174f, -0.08261135f, -0.01234221f, 0.01752552f, -0.11095458f, -0.03604796f, 
    0.03655419f, 0.03424262f, -0.23128249f, 0.00126077f, 0.04851737f, 0.12514243f, 0.13590236f, 0.13503844f, 
    -0.05731206f, 0.11172466f, -0.02197991f, 0.04565677f, -0.23290543f, -0.28332165f, -0.01411503f, 0.01673408f, 
    -0.13694981f, 0.11565745f, 0.00856288f, -0.39410502f, 0.15838398f, 0.01180946f, -0.07446463f, -0.01467552f, 
    0.10418526f, 0.15427068f, 0.35532987f, 0.10488254f, 0.14733529f, -0.12753969f, -0.06291871f, -0.17949016f, 
    0.05024073f, 0.09082250f, 0.04792062f, 0.11286239f, -0.30187261f, 0.15015036f, 0.03671758f, -0.14962515f, 
    -0.19210988f, 0.06221150f, -0.09487796f, -0.10254291f, 0.07603911f, 0.01419764f, -0.00757789f, -0.04532793f, 
    -0.13286275f, -0.09891665f, 0.24711485f, 0.23518376f, 0.09391582f, 0.01217161f, -0.13641831f, -0.17577867f, 
    -0.04920019f, -0.17332929f, -0.04638551f, -0.00027924f, -0.18910545f, 0.03675486f, -0.22683375f, 0.02501754f, 
    0.10340481f, 0.02515870f, 0.16155559f, 0.00042916f, 0.02281219f, 0.08078817f, 0.00824264f, 0.13849889f, 
    -0.32261565f, 0.03371605f, -0.00899501f, 0.23770428f, -0.00137131f, 0.00376683f, -0.11393607f, 0.05823100f, 
    0.03986477f, -0.04180262f, 0.00004499f, 0.21615158f, -0.05819852f, -0.44064885f, -0.07439405f, -0.24117132f, 
    0.00991377f, 0.05558304f, 0.02776655f, -0.08150784f, 0.11595970f, -0.11613832f, -0.02551338f, 0.12600945f, 
    -0.00550531f, 0.11649603f, 0.24186209f, -0.05049526f, -0.12964983f, -0.25819421f, -0.07374480f, 0.13017206f, 
    -0.15077697f, 0.12447932f, 0.07314304f, -0.03202802f, -0.23465782f, 0.09343790f, 0.02542984f, 0.15844773f, 
    -0.00068202f, 0.11021140f, -0.01949877f, -0.10256754f, 0.12026724f, -0.02799840f, -0.16386189f, 0.05448300f, 
    -0.14808024f, -0.13025180f, -0.31741872f, -0.40088826f, -0.19017181f, -0.15576600f, 0.06007257f, -0.16904710f, 
    0.04797058f, 0.08111317f, 0.08803889f, -0.06721099f, -0.11608768f, -0.40777278f, -0.25944299f, -0.13140966f, 
    0.05184690f, -0.05095411f, -0.11127477f, 0.12964027f, -0.08554693f, -0.15615705f, 0.01501962f, -0.10033122f, 
    -0.24146970f, 0.05491642f, -0.06739948f, -0.07622681f, 0.02256193f, 0.02429395f, -0.10676250f, -0.04029712f, 
    -0.09054002f, 0.08260563f, -0.11569284f, 0.01730950f, 0.13323966f, 0.15643831f, -0.21855448f, 0.23200931f, 
    0.09848321f, -0.06538996f, 0.15887472f, -0.27160236f, -0.13656855f, 0.13714246f, -0.02395320f, 0.09162696f, 
    0.12356256f, -0.04810268f, 0.11756598f, 0.39242235f, 0.12471226f, -0.05733423f, 0.06931823f, 0.01186441f, 
    -0.03776022f, 0.09670329f, -0.07007800f, -0.05493811f, 0.11818996f, 0.23374808f, -0.03247266f, 0.27072164f, 
    -0.11408106f, 0.04593157f, 0.02316401f, -0.08345151f, -0.07910302f, -0.15259115f, -0.02886977f, -0.00808228f, 
    -0.01422944f, 0.17734830f, 0.04160280f, -0.08484901f, -0.03646907f, -0.03458149f, 0.09065917f, -0.11802012f, 
    -0.01261980f, 0.04299938f, 0.11861563f, -0.05800006f, -0.23816960f, 0.29432145f, -0.10084099f, 0.14058055f, 
    0.01659584f, 0.05576893f, -0.10581530f, 0.01820707f, -0.11852784f, -0.07063420f, 0.07636755f, 0.03027569f, 
    0.09285688f, 0.07224367f, 0.02713381f, 0.00585052f, -0.09716348f, 0.04659267f, 0.09266587f, -0.02988389f, 
    0.13906297f, 0.20202199f, -0.02636160f, 0.05351843f, -0.00058364f, 0.01458799f, 0.11784977f, 0.12188489f, 
    0.03397846f, 0.06338840f, 0.08025751f, -0.01196113f, -0.00745148f, -0.04471087f, 0.02057113f, -0.01611543f, 
    0.01622824f, 0.04816692f, 0.11336250f, 0.06448867f, -0.08595357f, -0.10370126f, 0.01936298f, 0.01065907f, 
    0.01140338f, -0.08393599f, 0.06506315f, -0.01322902f, 0.05250429f, 0.41301045f, -0.17044003f, 0.11301778f, 
    -0.13255309f, 0.22049141f, 0.19940533f, 0.01585962f, 0.04107166f, 0.06274271f, -0.03955791f, 0.10709137f, 
    0.00256591f, -0.38717204f, -0.49995756f, -0.01412952f, -0.00743012f, 0.01907394f, -0.08455516f, -0.09078285f, 
    0.04281775f, 0.03267328f, -0.01699834f, -0.04525498f, -0.24783710f, 0.14436777f, -0.21211541f, -0.01539426f, 
    0.03190693f, 0.11458298f, -0.22815420f, 0.10802504f, -0.03112604f, -0.04818727f, -0.22544986f, -0.06667423f, 
    -0.07699743f, 0.00284542f, -0.26445103f, -0.15509272f, -0.14478199f, 0.10978731f, -0.00715820f, -0.20676295f, 
    -0.09398707f, -0.01268047f, -0.08355880f, -0.01981911f, -0.08920047f, 0.10477524f, 0.07269609f, 0.05851725f, 
    -0.11105220f, -0.02625217f, -0.01020777f, 0.09857225f, 0.09527820f, 0.05199113f, 0.14807358f, 0.14581378f, 
    0.11243352f, -0.30451950f, -0.13979018f, 0.02995016f, -0.12317847f, 0.08735912f, 0.10429047f, 0.14701927f, 
    0.04220585f, 0.08163411f, 0.08139579f, 0.02410277f, -0.04504966f, -0.29418516f, -0.07819996f, -0.16068769f, 
    -0.09270119f, -0.13188170f, -0.11630355f, 0.12208366f, 0.01015717f, 0.07959377f, 0.12941602f, -0.02592015f, 
    -0.03861966f, -0.19538411f, 0.42015615f, 0.05874768f, -0.07095332f, -0.00466035f, 0.09194648f, 0.03583234f, 
    0.02766859f, 0.00588367f, 0.23843731f, 0.03445396f, -0.28236353f, 0.04080540f, 0.15277785f, -0.00369280f, 
    -0.03806723f, 0.07987271f, -0.09320337f, 0.18983002f, -0.01710444f, 0.12852512f, 0.06516340f, 0.06602126f, 
    0.01497832f, -0.03513115f, -0.06107508f, -0.02926900f, -0.05639188f, -0.27428675f, -0.11357622f, -0.03210678f, 
    -0.13241421f, 0.17297411f, -0.01444419f, -0.36225137f, -0.02470446f, -0.10397834f, 0.21582380f, 0.15689415f, 
    -0.05189680f, -0.03832129f, -0.09468477f, -0.03552799f, -0.11627275f, -0.15973653f, -0.07237107f, 0.08930965f, 
    0.00851650f, 0.10010557f, -0.13990913f, 0.10485741f, -0.00975854f, -0.09787664f, -0.01495083f, -0.08817040f, 
    -0.12059131f, 0.05891822f, -0.00548749f, -0.02965420f, -0.07223523f, -0.10528983f, 0.16249973f, 0.08087961f, 
    -0.11148509f, 0.13886537f, -0.00499464f, 0.08959874f, -0.05004834f, 0.06634573f, 0.15215001f, 0.16213821f, 
    -0.25161627f, 0.19952643f, -0.22220288f, -0.09184884f, -0.02919171f, 0.01417657f, 0.18677302f, 0.06281736f, 
    0.00426290f, 0.01646981f, 0.06831749f, 0.00374274f, 0.11647682f, 0.13281557f, -0.05860798f, -0.12956119f, 
    -0.11481421f, 0.05489619f, -0.36669132f, -0.05040121f, -0.09617887f, -0.10399837f, -0.07666916f, -0.04183824f, 
    0.07817344f, -0.16330434f, 0.29371297f, -0.25346071f, -0.15489073f, -0.11240243f, 0.09970050f, 0.00190988f, 
    0.12476786f, 0.06938914f, -0.15716279f, 0.02288399f, -0.20795541f, 0.05255809f, 0.12934364f, -0.02269556f, 
    -0.00898686f, -0.04669913f, -0.09045137f, 0.03314695f, 0.13832735f, 0.08847766f, 0.10960484f, 0.02480753f, 
    0.37791723f, -0.19587345f, 0.21593849f, -0.24520537f, -0.20167141f, 0.11058418f, 0.09834684f, 0.11345880f, 
    0.02797529f, -0.14830847f, -0.28726941f, 0.21907638f, -0.60062510f, -0.38553441f, 0.12410068f, 0.17630635f, 
    -0.14685591f, 0.24043056f, -0.31143153f, 0.08093566f, -0.07744391f, -0.11277979f, 0.06636234f, -0.03916297f, 
    -0.08896586f, -0.07874691f, -0.15997624f, 0.13326283f, -0.06396758f, 0.06217109f, 0.03860965f, 0.10097224f, 
    -0.00861331f, 0.07626764f, -0.05628619f, 0.09448995f, -0.17102626f, 0.05744811f, -0.24397781f, -0.19343314f, 
    -0.02771406f, -0.07237322f, 0.03354915f, 0.14971521f, -0.11056685f, -0.03534004f, -0.30231851f, -0.46968615f, 
    -0.08680009f, -0.06908572f, -0.23752747f, 0.18310373f, 0.17355604f, -0.08810916f, 0.00795415f, -0.06148490f, 
    0.01454641f, 0.01856680f, -0.06162039f, -0.16157325f, -0.05962016f, -0.13725878f, -0.02481309f, -0.02101320f, 
    0.01632087f, 0.01562881f, 0.00984597f, 0.00675468f, -0.08744466f, -0.12330582f, -0.12612592f, -0.13611585f, 
    -0.04524065f, 0.01530129f, 0.11814253f, 0.15110210f, 0.07768323f, -0.07869582f, -0.00622736f, 0.02207554f, 
    -0.09371869f, 0.10360895f, -0.19698085f, -0.01389715f, 0.15283725f, -0.13235894f, -0.00331016f, 0.16054370f, 
    -0.04338481f, -0.08115486f, 0.09489018f, 0.00722455f, 0.07933721f, -0.16525990f, -0.12620395f, 0.09972649f, 
    -0.07955316f, -0.02311045f, -0.22826183f, -0.20554955f, -0.05227703f, -0.06148443f, -0.11025944f, 0.03231886f, 
    -0.08117189f, 0.11546112f, 0.10443472f, -0.03340017f, 0.10266925f, -0.07982790f, 0.05544948f, -0.14099672f, 
    0.01920412f, -0.02490961f, 0.01626782f, 0.03824136f, 0.03713199f, -0.39219955f, -0.30048069f, -0.05797427f, 
    0.07713678f, 0.24164382f, 0.08398265f, 0.16344492f, -0.00282007f, 0.07868601f, 0.12137257f, 0.01804509f, 
    -0.00126994f, 0.11129119f, 0.01204530f, 0.14161707f, -0.32065073f, -0.12447353f, -0.07626949f, -0.21464457f, 
    -0.09877080f, -0.15302089f, 0.02871893f, 0.02352795f, -0.13354196f, 0.03457920f, 0.08639880f, 0.02167086f, 
    -0.00570150f, -0.02780399f, -0.04155068f, 0.07537074f, -0.07616721f, -0.04820976f, 0.00574026f, 0.00539480f, 
    -0.02219894f, -0.20165522f, -0.21472383f, -0.04372690f, 0.27190813f, -0.13307679f, 0.03926574f, 0.19629978f, 
    0.00621205f, -0.08533546f, 0.04736965f, -0.03257401f, 0.02776919f, 0.06060050f, -0.01693407f, 0.06061716f, 
    -0.16276523f, 0.00244430f, 0.22903617f, 0.28566608f, 0.03013480f, 0.16202782f, -0.25309378f, 0.06284504f, 
    0.03171129f, -0.07276220f, 0.19765821f, 0.11959830f, -0.09236486f, -0.03419654f, -0.26457965f, -0.03010438f, 
    0.03739128f, 0.00698467f, 0.04065457f, -0.04697149f, 0.05663567f, 0.05652011f, 0.01094590f, -0.06509566f, 
    -0.16108458f, 0.11047665f, -0.04629113f, 0.06422208f, 0.07719782f, 0.05820787f, -0.07654408f, 0.15683475f, 
    -0.08347636f, -0.19024523f, -0.20233126f, -0.16250479f, 0.35788330f, 0.11036427f, 0.13949028f, -0.02009991f, 
    -0.10096166f, 0.01720543f, 0.02117320f, 0.06050264f, -0.04676033f, 0.05418437f, -0.02016836f, -0.21187703f, 
    -0.50237244f, 0.22858503f, -0.47856036f, 0.08687203f, -0.11568365f, 0.08332463f, 0.05324926f, 0.14186981f, 
    -0.05983797f, 0.02192201f, 0.00422407f, -0.00248783f, -0.17952940f, 0.14549281f, 0.05196695f, -0.02604408f, 
    0.10324331f, 0.14680220f, 0.14225061f, 0.10720637f, -0.14188512f, -0.00802916f, -0.02682544f, -0.01069050f, 
    -0.52910614f, 0.07068747f, 0.15765567f, 0.17591810f, -0.09748293f, 0.08742099f, 0.00336960f, -0.11155860f, 
    -0.03856181f, 0.15361214f, 0.06278299f, 0.08893858f, 0.06049674f, -0.15220924f, 0.35053128f, 0.04521061f, 
    -0.22087340f, 0.06306565f, 0.11333551f, 0.11116799f, -0.03487489f, -0.16251530f, 0.14594597f, 0.12993155f, 
    -0.16303109f, -0.12460837f, -0.16420665f, 0.13876010f, -0.01852899f, -0.09546247f, -0.15828624f, -0.00415748f, 
    0.02032731f, 0.07742532f, 0.00439914f, 0.08367378f, 0.20253518f, 0.00904492f, 0.07458621f, 0.14652549f, 
    -0.02016447f, 0.03864191f, 0.08548416f, -0.00912470f, -0.00035642f, -0.12472236f, 0.19927883f, 0.14027859f, 
    -0.22370893f, -0.49367866f, 0.04917219f, -0.18509687f, -0.06311366f, 0.01364331f, -0.09791276f, -0.06586546f, 
    0.02641756f, 0.09485690f, 0.13862415f, -0.07444163f, -0.31575277f, 0.27057588f, -0.10452787f, 0.32792330f, 
    0.04887519f, 0.07093964f, 0.06548523f, -0.11900180f, 0.08503158f, 0.07016953f, -0.06555448f, 0.00180597f, 
    -0.03627011f, -0.10973282f, -0.15234375f, -0.21854925f, -0.18003945f, -0.10236422f, -0.07824634f, -0.07574962f, 
    -0.27490860f, -0.02068865f, -0.06063297f, -0.24558339f, -0.17756249f, 0.22500995f, 0.23415343f, -0.04504421f, 
    0.00762222f, -0.06445817f, 0.09972323f, 0.05438256f, -0.00163540f, -0.00157352f, 0.02890875f, 0.06703877f, 
    -0.29278436f, -0.01444745f, 0.07609519f, -0.14672285f, 0.02436950f, -0.14154814f, -0.12126494f, 0.03038005f, 
    0.05353167f, 0.03374670f, -0.01365453f, -0.10245807f, 0.12416940f, -0.21617484f, 0.12217027f, -0.10014714f, 
    0.00645863f, -0.12203881f, 0.02838613f, 0.15329598f, -0.09345612f, 0.09419294f, 0.01525781f, 0.03597326f, 
    -0.48528591f, 0.20939808f, 0.21478058f, -0.27295017f, 0.02847276f, 0.11488377f, -0.07319118f, 0.01810381f, 
    0.01761936f, 0.05128342f, 0.04389755f, -0.02604699f, 0.12358512f, 0.06128854f, -0.03160850f, -0.07685393f, 
    -0.12607470f, -0.24284185f, 0.02054221f, -0.06169528f, -0.14145058f, -0.03030545f, -0.18218420f, -0.07501931f, 
    0.13224246f, 0.07339537f, 0.16344638f, -0.31989565f, -0.14182830f, 0.07310205f, -0.01877652f, 0.03175079f, 
    -0.04874559f, -0.10974788f, -0.52352661f, -0.29972786f, -0.23032402f, -0.04319621f, -0.37565291f, 0.15686108f, 
    -0.09510067f, 0.22732992f, 0.08326741f, -0.06129157f, -0.11234560f, -0.07646468f, 0.05985604f, 0.02020831f, 
    -0.19681914f, 0.06529561f, -0.20946088f, 0.14852983f, 0.11636246f, -0.02331700f, -0.03099103f, 0.16030858f, 
    -0.08141427f, 0.05213820f, -0.06180849f, -0.00379131f, 0.18537661f, 0.05144362f, 0.14414360f, -0.11767486f, 
    -0.08281033f, 0.03796056f, 0.02919096f, -0.04671948f, -0.00334582f, 0.02320909f, -0.14669146f, 0.08659703f, 
    0.49432719f, -0.43817347f, 0.26642585f, 0.11415933f, -0.02393966f, 0.07825545f, 0.05209085f, -0.01754630f, 
    0.05778354f, 0.02480243f, -0.12277084f, -0.10027674f, -0.10530144f, -0.13010664f, 0.15166944f, 0.15353876f, 
    -0.12037411f, 0.09726998f, -0.11500945f, 0.04731794f, -0.04069851f, -0.07138348f, 0.10653038f, 0.11098049f, 
    0.29294974f, -0.13459572f, 0.24020718f, 0.06053217f, 0.10418806f, -0.12356059f, -0.10305979f, 0.14922613f, 
    -0.12490098f, 0.00550495f, 0.05895735f, 0.08611640f, -0.54630983f, -0.01349564f, 0.01191852f, 0.05516787f, 
    -0.11852817f, 0.00653349f, -0.07554404f, 0.15077932f, 0.02916788f, 0.01290955f, -0.13247578f, 0.06201016f, 
    -0.64355028f, 0.42779371f, -0.17300168f, 0.10029218f, -0.10246141f, -0.03000455f, -0.01669963f, 0.00331481f, 
    -0.21744375f, 0.13586803f, 0.03906785f, -0.03284461f, -0.22112811f, 0.49755025f, -0.25848147f, 0.08439383f, 
    -0.14918019f, -0.11915689f, -0.06365165f, 0.02270452f, -0.06887352f, -0.08081083f, 0.14912756f, -0.05687188f, 
    -0.38835147f, -0.22424401f, -0.08150657f, 0.23419766f, 0.19146615f, 0.04892749f, -0.10862111f, -0.01953499f, 
    -0.16942191f, -0.17500305f, 0.06457056f, -0.08982352f, -0.24735148f, 0.04939739f, -0.31572127f, 0.35197505f, 
    -0.04505813f, 0.03656856f, 0.13066086f, 0.14560571f, -0.03737529f, 0.04646041f, -0.02789317f, 0.00794885f, 
    0.13207787f, -0.03323176f, 0.18183114f, 0.16692029f, 0.13443588f, -0.02443980f, -0.06024599f, 0.07999670f, 
    -0.10738195f, 0.05046177f, -0.08580936f, -0.16152473f, 0.22345448f, 0.12941504f, 0.15531492f, -0.24283114f, 
    -0.03460542f, -0.11653794f, 0.01814541f, -0.01450800f, -0.09542080f, 0.02403870f, -0.01351495f, -0.07423054f, 
    -0.02902162f, -0.40135729f, 0.24727926f, 0.11609688f, 0.02869043f, 0.11284720f, 0.03000180f, 0.06115765f, 
    -0.17075551f, -0.06240024f, 0.21793312f, -0.04582599f, -0.00165565f, -0.38520771f, 0.29337242f, 0.11408177f, 
    0.03089607f, -0.15202473f, -0.02527069f, -0.07909054f, -0.06113083f, 0.05785874f, 0.08485930f, -0.11878217f, 
    -0.18891324f, -0.37764144f, -0.03649336f, 0.13599160f, -0.16361965f, 0.07739545f, -0.00055791f, -0.23065259f, 
    -0.03846303f, 0.01865375f, 0.03461934f, 0.01595793f, -0.06130886f, -0.19737625f, 0.06138328f, -0.04675313f, 
    -0.06397425f, -0.17432146f, 0.04334662f, 0.03689679f, 0.16265148f, 0.02139799f, -0.01841841f, -0.07706144f, 
    0.58597589f, 0.21258669f, 0.21706729f, -0.03099809f, 0.10910336f, -0.02649057f, -0.01905054f, 0.01550296f, 
    -0.15732351f, 0.01688570f, -0.02486051f, -0.05011452f, 0.00466091f, 0.02290080f, -0.10571697f, -0.07864022f, 
    -0.06046767f, -0.19439830f, -0.21086651f, -0.04290335f, -0.04846104f, 0.01977474f, -0.08957049f, -0.20364878f, 
    -0.40167800f, -0.00107416f, -0.13665639f, 0.13186616f, -0.16087867f, 0.00733799f, 0.04283132f, -0.15101278f, 
    0.05831110f, 0.06185323f, -0.03548944f, -0.08050743f, -0.05135254f, -0.02680685f, -0.38284999f, -0.08281633f, 
    -0.11381263f, -0.07361437f, 0.15573788f, -0.08090756f, -0.00905560f, 0.08026161f, -0.07669041f, -0.07773490f, 
    0.35075277f, -0.03984137f, 0.52859497f, -0.23158455f, 0.05465488f, 0.04107254f, -0.12012015f, -0.03038875f, 
    0.00178910f, -0.03358627f, -0.13910909f, 0.01152757f, -0.01150659f, 0.18578690f, -0.10648739f, 0.14641573f, 
    0.11094616f, 0.01493136f, 0.01132443f, 0.22161694f, 0.01015226f, -0.01275986f, -0.04801490f, -0.07937976f, 
    -0.17759052f, 0.07286676f, -0.13997076f, -0.06392854f, -0.03931138f, 0.03620783f, 0.14495265f, 0.01008600f, 
    -0.03718745f, 0.04313828f, 0.03834398f, -0.12097508f, -0.05782711f, -0.02595123f, 0.01934918f, -0.06138262f, 
    -0.13770527f, -0.00905870f, -0.07713208f, 0.09237634f, -0.09452083f, 0.13749216f, 0.13894846f, -0.01414278f, 
    -0.33919978f, 0.35833776f, 0.00919388f, -0.05264517f, 0.03622767f, 0.00153751f, 0.00434807f, 0.00308072f, 
    -0.09906426f, 0.01040300f, -0.04813219f, -0.09870970f, 0.03935639f, -0.07714368f, 0.02989990f, 0.15395011f, 
    0.00973358f, -0.09826934f, 0.10678935f, 0.01828251f, 0.14260894f, 0.03069573f, -0.02931275f, -0.14987206f, 
    0.14565249f, 0.00696422f, -0.08419491f, 0.12072504f, 0.11494579f, 0.01506583f, 0.09651214f, 0.02977470f, 
    0.10135870f, 0.12241641f, 0.01721312f, -0.09418513f, 0.36060223f, -0.19276701f, 0.21830870f, 0.06497537f, 
    -0.06634527f, -0.19748762f, 0.06266108f, 0.06358382f, -0.01394990f, 0.09804497f, 0.08168226f, -0.03703756f, 
    0.11524738f, -0.15354103f, 0.45202526f, 0.04340795f, 0.00991405f, 0.09022968f, 0.18255381f, -0.07643099f, 
    0.09305242f, 0.08800451f, 0.06700853f, 0.14569236f, 0.29168820f, -0.09910118f, 0.14682245f, 0.13181299f, 
    0.12126964f, -0.01652166f, -0.07494455f, 0.08100344f, -0.19539064f, 0.03414854f, -0.08834471f, -0.06246082f, 
    -0.00101023f, -0.33624798f, 0.27750656f, -0.42695749f, 0.10161833f, 0.16756523f, -0.10704811f, 0.03099674f, 
    -0.09469473f, 0.02642215f, 0.01643902f, 0.07652103f, -0.45224938f, 0.18646578f, -0.37017852f, 0.27761346f, 
    0.01978208f, 0.01716406f, 0.17153189f, -0.06489479f, -0.00480876f, -0.01116471f, -0.14525589f, 0.04559191f, 
    -0.09853690f, 0.23113959f, 0.00468108f, 0.02525677f, -0.05819311f, 0.04310727f, 0.11232653f, -0.07977144f, 
    -0.02437071f, -0.02008650f, -0.02862637f, -0.05156457f, 0.04128277f, 0.11497010f, -0.39558706f, -0.28155845f, 
    0.08411425f, -0.15404785f, -0.09605372f, 0.01294538f, 0.04780517f, 0.11553113f, 0.14783163f, 0.04153564f, 
    0.21056837f, -0.23653722f, 0.38677472f, -0.03776301f, 0.00135293f, 0.03797413f, -0.21803406f, 0.09130038f, 
    -0.02043605f, 0.12732249f, -0.04016302f, 0.11799874f, 0.12822311f, 0.10469233f, 0.11842715f, -0.00315880f, 
    0.05284443f, -0.01295305f, 0.01311525f, -0.00573198f, -0.01657091f, 0.01563595f, 0.04939904f, 0.07953244f, 
    -0.67233610f, 0.11482154f, -0.33732864f, 0.21020041f, -0.00610810f, 0.20438015f, 0.03270484f, 0.29309595f, 
    -0.15483995f, -0.01690568f, 0.13072965f, 0.07276709f, -0.41018733f, 0.23438868f, 0.04234941f, -0.09547839f, 
    0.01791164f, 0.03460087f, 0.01783429f, -0.10070004f, 0.06634598f, 0.11495350f, 0.06921561f, 0.02659506f, 
    0.11953878f, -0.03590516f, -0.02157452f, 0.13135652f, -0.01433922f, 0.05609608f, -0.05571939f, -0.00587415f, 
    -0.01280908f, 0.05979727f, -0.05643520f, -0.05452538f, 0.04079719f, 0.04305026f, 0.07767680f, -0.15984768f, 
    -0.00562114f, 0.05042012f, -0.00711536f, -0.04141897f, 0.00317047f, 0.12419976f, 0.15226518f, -0.04311781f, 
    -0.40120000f, 0.36023977f, -0.13794789f, 0.11167558f, 0.10947277f, 0.01719885f, 0.03940761f, -0.00381500f, 
    -0.12604478f, -0.07205594f, -0.10379642f, -0.19103369f, -0.17836438f, 0.08511900f, -0.09801417f, -0.01795447f, 
    -0.08379750f, 0.02902054f, 0.06759330f, -0.04846737f, -0.02350400f, -0.02740670f, -0.04222065f, -0.10338665f, 
    -0.00634709f, 0.10718046f, -0.07770727f, 0.04508182f, -0.00432402f, -0.00376552f, 0.06185186f, 0.11239719f, 
    0.06743091f, 0.06833751f, 0.16845886f, 0.10200601f, -0.39623833f, -0.29022565f, 0.13197982f, -0.26077002f, 
    -0.07360849f, 0.00188635f, -0.02266468f, 0.19176954f, -0.06002307f, -0.05170427f, -0.04690855f, -0.00659216f, 
    0.02668951f, 0.13764875f, -0.07795829f, 0.16342372f, -0.06317955f, -0.10114204f, 0.06802209f, 0.22393069f, 
    -0.24230921f, 0.17906867f, 0.03691690f, -0.08211271f, -0.45172545f, -0.18624562f, -0.15766203f, -0.01484089f, 
    -0.14292951f, -0.10424585f, -0.00361192f, -0.14984106f, -0.00339128f, 0.02402750f, 0.04652184f, 0.04392169f, 
    -0.20600827f, -0.03536424f, -0.09733140f, -0.06981369f, 0.04726249f, -0.04872083f, 0.03884254f, 0.06498671f, 
    0.03402395f, 0.06479852f, 0.08637965f, 0.03140643f, -0.08910673f, 0.15211849f, 0.01745062f, 0.04399155f, 
    -0.07277749f, 0.05519326f, 0.02274774f, -0.02441622f, 0.01449869f, 0.03732116f, 0.14983004f, 0.14139417f, 
    0.14245114f, 0.22675969f, -0.01456738f, 0.23919243f, -0.02172204f, 0.06967419f, -0.07632581f, 0.29644808f, 
    -0.10019977f, -0.01009340f, -0.03130238f, -0.09567802f, -0.18033484f, -0.40188953f, 0.17351317f, 0.23480098f, 
    0.09692844f, 0.01178438f, -0.01127546f, 0.00351895f, 0.10028230f, 0.09270295f, 0.13731173f, -0.04020456f, 
    -0.39168906f, -0.06498526f, -0.20548896f, -0.01896988f, -0.01418595f, -0.19181047f, 0.05645847f, -0.30433005f, 
    0.06102254f, 0.08318343f, 0.05623540f, 0.04875502f, 0.01424628f, -0.05420456f, 0.27840281f, -0.10015501f, 
    0.02028628f, 0.01069639f, -0.08565215f, -0.05692222f, -0.05299549f, -0.00148866f, 0.01525141f, -0.11377718f, 
    -0.01205128f, -0.16254731f, 0.02033354f, -0.27272373f, -0.17606728f, -0.15708640f, -0.19277737f, -0.19387953f, 
    0.03380821f, -0.04313637f, -0.08734334f, -0.08274420f, -0.12252317f, -0.11566237f, 0.02480026f, -0.07270299f, 
    -0.16243879f, -0.02602064f, -0.05910876f, 0.12242503f, -0.22012405f, 0.00734411f, -0.14588644f, -0.06737304f, 
    0.17895798f, 0.18497527f, 0.20955092f, -0.11611201f, 0.03376026f, -0.01272460f, -0.07679319f, -0.02362592f, 
    -0.06030547f, 0.00240152f, -0.05532049f, 0.02094479f, -0.55406862f, 0.10372241f, -0.40999284f, 0.25111941f, 
    0.10041768f, 0.03069717f, 0.11795788f, -0.06834838f, -0.02843392f, 0.05237019f, 0.28881380f, 0.13269421f, 
    0.17018293f, 0.18747360f, 0.02170904f, -0.13413106f, 0.01419105f, 0.00127505f, -0.06567027f, 0.03457332f, 
    0.08734545f, 0.01109065f, -0.05489165f, -0.02177630f, -0.12436121f, 0.13643238f, -0.18938521f, 0.06211942f, 
    -0.00384393f, 0.01501559f, 0.05640199f, -0.14503978f, 0.01961059f, -0.03333225f, 0.03556355f, 0.03589740f, 
    -0.13770151f, -0.14924608f, -0.18778014f, -0.06253349f, 0.10740530f, 0.08636038f, -0.01053786f, -0.01984382f, 
    -0.09758824f, 0.10765103f, 0.05206597f, -0.08948091f, -0.42622209f, 0.05385847f, 0.01530530f, -0.19873062f, 
    -0.09220905f, -0.04458449f, -0.05242328f, -0.04564010f, 0.14075537f, 0.04203112f, -0.09988254f, -0.15555847f, 
    -0.20583135f, -0.06883544f, -0.38608697f, 0.26398584f, 0.11273606f, 0.01578051f, 0.04986328f, -0.05585740f, 
    -0.01369916f, 0.13116866f, 0.03131853f, 0.02756744f, 0.13059644f, -0.08260415f, 0.12340410f, -0.09898511f, 
    -0.04292623f, -0.00586940f, 0.02966202f, 0.00284132f, 0.06096396f, 0.09272818f, 0.10637673f, 0.04740052f, 
    0.04811021f, -0.13501735f, 0.10415365f, -0.16543216f, 0.07225032f, 0.10017315f, -0.00716394f, 0.04691738f, 
    0.08894213f, 0.02453054f, 0.10872971f, 0.20634495f, 0.07934012f, 0.02066916f, -0.04076080f, 0.23143734f, 
    -0.01548346f, 0.03185739f, 0.08332040f, -0.00647842f, 0.04819917f, 0.12090550f, -0.02875911f, -0.05217211f, 
    -0.18915682f, 0.01282975f, 0.24536775f, 0.08552742f, 0.05918360f, -0.07376166f, -0.01048432f, 0.02867400f, 
    0.01080949f, -0.04827828f, 0.02387306f, 0.02675226f, 0.01951699f, 0.03737114f, 0.14698313f, -0.11529242f, 
    -0.01938864f, 0.06507408f, -0.04950308f, -0.10836043f, -0.11475638f, 0.11653066f, 0.17464881f, 0.02430884f, 
    -0.07580119f, 0.10511082f, 0.16905530f, -0.91117340f, 0.06933911f, -0.10904444f, 0.02734629f, -0.07332304f, 
    0.02940276f, 0.03006315f, 0.02481584f, -0.01027536f, -0.10265087f, 0.24213012f, 0.28178528f, -0.10934199f, 
    0.06259694f, -0.32155576f, -0.08847068f, -0.07021364f, -0.09407209f, -0.02913026f, 0.02453302f, -0.00700575f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14684659f, 0.11879554f, 0.05903054f, -0.09202285f, -0.07522964f, 0.05768066f, -0.00113152f, -0.15420498f, 
    0.06400885f, 0.00777803f, 0.03101294f, -0.00315446f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
