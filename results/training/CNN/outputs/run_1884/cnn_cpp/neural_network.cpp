#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.63388950f, -0.60808891f, -0.03846591f, -0.43661144f, 0.07800553f, -0.55359954f, -0.35102755f, -0.21961385f, 
    0.02174566f, 0.51451439f, 0.00909766f, -0.12164684f, 0.27819747f, -0.63298911f, 0.34100562f, 0.11173368f, 
    -0.03090472f, -0.12480675f, -0.24885345f, -0.19217582f, -0.36685178f, -0.23057461f, -0.16487929f, -0.45089510f, 
    0.24040146f, 0.59160262f, 0.60230762f, 0.60684997f, 0.15524267f, 0.42378765f, -0.21467790f, 0.04001080f, 
    0.20360640f, 0.65464753f, -0.25851369f, -0.60984898f, -0.14080061f, 0.38464540f, 0.71712559f, -0.39250308f, 
    -0.55167818f, -0.40331653f, 0.26852664f, 0.17066301f, -0.33726883f, 0.87755430f, -0.76031506f, 0.62296450f, 
    0.21945558f, 0.00147464f, -0.08487923f, 0.29101560f, 0.31676781f, 0.05332083f, 0.28235748f, 1.24075115f, 
    -1.00979519f, 0.05956011f, -0.25194296f, -0.24904998f, -0.03976428f, 0.34959862f, 0.10042841f, -0.03159296f, 
    -0.14421423f, -0.50994790f, -0.35084611f, -0.56104410f, -0.35653985f, -0.36913833f, -0.35275930f, -0.17545654f, 
    -0.22651549f, -0.49425617f, 0.74443138f, -0.79736227f, -0.74871391f, 0.85344923f, -0.07611790f, 0.05251204f, 
    0.11967538f, -0.87482649f, 0.06995790f, 0.24888560f, -0.23168664f, 0.91785306f, -1.00592101f, -0.24805272f, 
    0.07460651f, 0.07127693f, -0.01086049f, -0.43504518f, -0.03799792f, 0.37754270f, 0.40110332f, 0.28580037f, 
    0.43861905f, -0.47675875f, -0.36616513f, 0.12815906f, 0.17750478f, 0.22945406f, 0.36142421f, -0.53785837f, 
    -0.56813061f, -0.12504978f, -0.24471697f, 0.03246878f, -0.68209589f, -0.32276252f, 0.12179842f, 1.00786030f, 
    -0.18800801f, -0.16281988f, -0.24538688f, -0.16361606f, -0.19950187f, 0.03540678f, 0.47422582f, -0.66041219f, 
    0.93691403f, -0.82682061f, 0.01059012f, -0.17455098f, 0.11736646f, 0.02135402f, 0.30022708f, 0.17872940f, 
    -0.08244993f, 0.11112683f, 0.39329740f, 0.55218548f, -0.32757249f, 0.12067630f, 0.51202148f, -0.59677404f, 
    -0.64746982f, -0.05706367f, 0.14441343f, 0.48154011f, -0.52049273f, 0.38505229f, -0.19382375f, 0.16053058f, 
    0.08582992f, 0.32845366f, 0.25401917f, 0.47523668f, 0.50119925f, -0.22319825f, 0.30674219f, 0.12296163f, 
    -0.50246036f, -0.62009752f, 0.27980140f, -0.83409661f, -0.00303105f, 0.69888836f, 0.22335492f, 0.37393942f, 
    0.36515686f, 0.13450821f, -0.67287320f, -0.32305950f, -0.58834082f, -0.23994145f, 0.00776935f, 0.90213060f, 
    0.03575007f, -0.07279073f, -0.25062776f, 0.53042108f, 0.38968128f, 0.45353240f, 0.15907839f, 0.17678253f, 
    0.27930871f, -0.08675373f, 0.13331507f, -0.13058825f, -0.21209231f, 1.07120752f, -0.35868430f, -0.49524149f, 
    -0.04816349f, 0.60414410f, -0.11339838f, -0.24927285f, 0.17387986f, 0.16397756f, 0.56453550f, -0.38666207f, 
    -0.40595132f, 0.92964792f, -0.28019029f, -0.32148317f, -0.35160029f, -0.20783985f, 0.51293319f, 0.15902235f, 
    -0.23107269f, 0.57500380f, 0.21473826f, 0.57405376f, -0.07859492f, 0.41651475f, -0.46613204f, -0.07788133f, 
    -0.73001647f, -0.33216414f, 0.40910837f, 0.30254290f, -0.09760658f, -0.25297838f, -0.39855602f, -0.35316408f, 
    0.46400031f, 0.08383162f, 0.38699755f, 0.21726452f, -0.10946895f, -0.79896033f, -0.30445892f, 0.35522160f, 
    0.77509099f, -0.62345648f, -0.49692336f, 0.87094212f, -0.80648637f, -0.62333798f, 0.15853307f, 0.69688284f, 
    -0.34571463f, 0.01153623f, 0.01891232f, 0.45012763f, -0.11020110f, 0.35294533f, 0.62906921f, -0.37760559f, 
    0.33765641f, 0.38449496f, 0.24424697f, 0.22259839f, 0.07433056f, -0.46467853f, 0.35469195f, -0.13580954f, 
    -0.34742159f, -0.05513551f, -0.44842887f, -0.27059549f, -0.19419895f, 0.39245373f, -0.26441571f, -0.06107724f, 
    -0.42458349f, -0.56611449f, 0.59674835f, 0.29413730f, 0.54980075f, -0.70842159f, -0.51378131f, 0.31732282f, 
    0.36405301f, -0.29896319f, -0.55253005f, -0.34310293f, -0.37426257f, -0.35068184f, -0.47511184f, -0.46887782f, 
    -0.35288414f, -0.64561164f, 0.42840871f, -0.48119056f, 0.46629140f, -0.21055883f, -0.30178592f, 0.67471129f, 
    -0.75200927f, -0.58578217f, 0.40971524f, -0.32048687f, 0.09445539f, 0.40776643f, 0.06177583f, -0.21882294f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03684571f, 0.28773281f, 0.29977986f, -0.06353468f, 0.13190971f, 0.21578349f, 0.22690536f, -0.45500165f, 
    -0.00089088f, 0.28960186f, 0.33994815f, 0.32356384f, 0.00909143f, -0.07486811f, 0.19443260f, -0.05140982f, 
    -0.02930740f, 0.14217368f, -0.13462144f, 0.10691851f, 0.01734780f, -0.05617425f, 0.27948749f, 0.08710275f, 
    -0.03699195f, 0.03777160f, -0.13515984f, 0.23135482f, -0.12566103f, -0.44687858f, -0.22805442f, 0.32399577f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06845535f, -0.24826650f, -0.63435102f, 0.20293015f, 0.15766934f, -0.13260639f, -0.04398304f, -0.15182421f, 
    0.14988849f, 0.02325098f, 0.22051564f, 0.17950800f, 0.01676755f, 0.12687591f, -0.11637496f, 0.04825490f, 
    0.05759992f, -0.10720013f, -0.12388177f, 0.06524856f, -0.08589080f, -0.04200376f, 0.18114486f, -0.12103769f, 
    0.15411407f, 0.13200606f, 0.15503593f, -0.01537575f, 0.04346170f, -0.00364110f, 0.09517464f, 0.03901636f, 
    0.01771767f, 0.24686438f, -0.07059552f, 0.11868547f, -0.23931159f, -0.22686359f, -0.31052914f, 0.07014890f, 
    0.06250989f, 0.03933981f, 0.29435593f, 0.14227854f, 0.08233633f, 0.22080179f, -0.02407776f, -0.22786206f, 
    0.05372330f, 0.04035622f, 0.13940409f, 0.21025671f, -0.04103635f, 0.12969396f, 0.12056172f, -0.35103825f, 
    -0.25497749f, 0.13172716f, 0.00764947f, 0.00729023f, 0.15174051f, -0.04099906f, 0.08985781f, -0.03460171f, 
    -0.04547780f, 0.20065905f, -0.07318000f, -0.03706126f, -0.14354320f, 0.02347361f, -0.12849337f, -0.00788713f, 
    0.40213281f, -0.60094386f, -0.49338329f, -0.11158013f, 0.12766413f, 0.06404317f, 0.08496287f, -0.17367625f, 
    0.11211785f, -0.02570588f, -0.23118423f, -0.02090855f, 0.15125518f, 0.00361082f, -0.06039692f, 0.01475917f, 
    -0.02702421f, -0.01896822f, 0.08505340f, 0.09830723f, 0.19691692f, 0.00190416f, 0.15391183f, -0.00551430f, 
    0.10253069f, 0.00818676f, -0.07978569f, -0.50716180f, -0.12166625f, -0.14840962f, 0.21220876f, 0.11685837f, 
    -0.05111803f, 0.08416488f, -0.06309312f, 0.17863041f, -0.02738327f, -0.06566814f, -0.00585114f, -0.06043630f, 
    -0.14022265f, -0.02033568f, 0.11566678f, -0.04037154f, -0.00839423f, -0.12265427f, -0.37283167f, -0.34699941f, 
    0.15686965f, -0.37330094f, -0.07071274f, 0.03543890f, -0.17075567f, -0.25150415f, 0.06539275f, 0.09461646f, 
    0.07113207f, 0.08895452f, 0.08781633f, 0.21448386f, 0.07923901f, 0.02201300f, 0.16860083f, -0.41193223f, 
    -0.09073610f, 0.45918089f, 0.00287965f, 0.05279423f, -0.11910931f, 0.03726217f, 0.00153307f, 0.06076398f, 
    -0.02332423f, -0.12221344f, 0.13180603f, 0.12530293f, -0.04063671f, 0.00053847f, -0.03275906f, -0.04405473f, 
    0.16204359f, -0.07972736f, 0.32744610f, 0.31647745f, 0.02625692f, 0.00734547f, 0.01412611f, 0.04221198f, 
    0.10843679f, 0.01827832f, -0.36727193f, 0.14381808f, 0.03563480f, -0.14374812f, 0.09554970f, 0.29111615f, 
    -0.03145991f, -0.01749526f, 0.05017441f, 0.00553214f, -0.05877361f, 0.08704931f, 0.08193250f, 0.00552875f, 
    -0.02034989f, -0.00578473f, -0.05155931f, 0.01790996f, 0.02094542f, -0.27531874f, -0.13686994f, 0.04554610f, 
    -0.24921636f, -0.01872426f, 0.02947834f, -0.09950459f, 0.07000829f, -0.14320128f, -0.54867446f, 0.00622200f, 
    -0.00202273f, -0.17863527f, 0.10675638f, -0.25272632f, -0.07559713f, -0.07537749f, 0.09186704f, 0.00833709f, 
    0.02573875f, 0.00750851f, 0.21990660f, 0.12960444f, 0.08710197f, 0.07997587f, -0.00679949f, 0.00913566f, 
    0.02182817f, 0.31996912f, -0.08141902f, 0.02562972f, -0.01394027f, -0.02366151f, -0.12617290f, 0.10792547f, 
    0.10444541f, -0.65772229f, 0.13329494f, 0.24292736f, 0.14215159f, 0.04750966f, 0.10656855f, 0.14869305f, 
    -0.01676860f, 0.23847120f, -0.16747625f, -0.65519810f, 0.08333997f, -0.03897774f, 0.07288916f, 0.18708272f, 
    0.06225752f, -0.17304882f, 0.01060524f, -0.10888769f, 0.04406737f, 0.07061992f, 0.04240952f, -0.12064499f, 
    0.03405766f, 0.07156248f, 0.15975520f, -0.16931328f, 0.05915092f, -0.22264777f, -0.01764192f, -0.07299003f, 
    -0.03776121f, -0.02974012f, -0.07481791f, 0.15164201f, -0.06757660f, -0.18734211f, -0.15241203f, -0.06846178f, 
    0.00943148f, -0.07818924f, 0.17322144f, 0.21377759f, -0.02131975f, 0.33239377f, 0.05515837f, 0.21701528f, 
    -0.14265817f, -0.14655526f, -0.11954102f, -0.11248690f, -0.17788896f, 0.01553938f, -0.03220566f, 0.20526762f, 
    0.05377570f, -0.01652532f, 0.10530428f, 0.00912698f, -0.02729743f, -0.01850920f, -0.05759639f, 0.15423794f, 
    0.41306508f, -0.35732356f, -0.04022001f, 0.13649705f, -0.14445877f, -0.01557568f, 0.12984827f, -0.07110734f, 
    0.06268680f, -0.01645905f, 0.04817914f, -0.02156832f, 0.00684862f, 0.05082805f, -0.06167272f, -0.01707891f, 
    0.01304524f, -0.00521176f, -0.05223452f, 0.05453914f, 0.01012710f, 0.01444288f, 0.02789724f, -0.02493415f, 
    0.01422833f, -0.03545223f, -0.04984293f, 0.01929487f, 0.04805988f, -0.04957133f, -0.05260184f, 0.00416136f, 
    0.03993633f, 0.01994955f, -0.03568346f, 0.04562783f, -0.00853143f, -0.04572405f, 0.03168219f, -0.01840288f, 
    -0.05769189f, -0.02508049f, 0.02224573f, -0.00546777f, -0.02790813f, -0.03181442f, -0.00274363f, -0.04196853f, 
    -0.02695006f, 0.02642110f, -0.03022798f, 0.05062241f, -0.03419015f, 0.04298439f, -0.00801214f, 0.01970942f, 
    -0.00305148f, 0.00709503f, 0.01814771f, -0.01375172f, 0.03656353f, 0.04077255f, 0.00724743f, 0.01864859f, 
    0.02097308f, -0.01188566f, 0.00028501f, 0.05098114f, 0.04460268f, -0.00129243f, 0.02023244f, -0.02357706f, 
    0.00972409f, -0.00665554f, -0.01249620f, -0.05546805f, 0.03306843f, 0.00969160f, 0.03121557f, -0.01197313f, 
    0.02520290f, -0.02058239f, 0.01455439f, 0.06590671f, 0.01987460f, -0.04366009f, -0.04160909f, -0.03287545f, 
    -0.02041272f, 0.01288259f, 0.03447858f, -0.03421546f, 0.03729290f, 0.00081520f, -0.00454902f, -0.03768869f, 
    -0.02193687f, 0.01261367f, -0.03708204f, 0.03350626f, 0.02507698f, 0.04803851f, -0.01456365f, -0.02609920f, 
    0.01542299f, 0.04507804f, -0.01076401f, -0.03142252f, -0.02628721f, -0.03378789f, -0.01525114f, -0.00186761f, 
    -0.01183192f, -0.05421035f, 0.04641738f, 0.01516860f, -0.01848705f, 0.05134308f, -0.03730915f, 0.04819589f, 
    0.04220082f, 0.02634249f, -0.04890769f, -0.05790065f, -0.01834717f, -0.05687597f, 0.01581019f, -0.04664481f, 
    -0.05582239f, 0.00181976f, -0.01259819f, -0.03636281f, 0.01361357f, -0.03617165f, -0.03571871f, -0.02791257f, 
    -0.04872755f, -0.01751967f, 0.02144884f, -0.03294437f, 0.01474431f, -0.02024042f, 0.04629932f, 0.01592456f, 
    -0.00706370f, -0.06212007f, -0.02801486f, -0.00702483f, -0.01205742f, -0.04089803f, 0.00836709f, -0.01397785f, 
    0.02302663f, -0.04484843f, -0.01688124f, -0.06280544f, -0.00100459f, -0.05062500f, 0.00356649f, 0.02974736f, 
    -0.03299352f, -0.01528492f, -0.03537255f, 0.00546829f, 0.01498438f, -0.03387432f, -0.02849510f, -0.05489580f, 
    -0.01357212f, 0.03420496f, 0.00552771f, 0.01230400f, -0.04493349f, -0.02972900f, -0.04040883f, -0.01461198f, 
    -0.02187038f, 0.00952436f, 0.02844046f, -0.00321634f, 0.00308479f, -0.03327739f, -0.06105642f, -0.02628327f, 
    0.02049191f, 0.03243490f, -0.00193553f, -0.04103828f, 0.01658900f, -0.05069823f, -0.01684876f, -0.00455672f, 
    -0.04272654f, 0.04379575f, -0.02978898f, -0.03380752f, -0.04591541f, -0.05868110f, -0.06300543f, -0.02909153f, 
    -0.03270609f, 0.00425743f, 0.00172787f, -0.03246859f, -0.03657070f, -0.02066747f, 0.03873291f, 0.02054980f, 
    0.04403770f, 0.02350713f, 0.05497072f, -0.03399926f, -0.02016660f, 0.00671896f, 0.04879129f, 0.01600591f, 
    0.03966939f, -0.02171657f, 0.01284497f, -0.01331248f, 0.03944892f, -0.01026409f, 0.02482110f, -0.06333494f, 
    -0.06163616f, -0.01307978f, 0.03800184f, 0.01514960f, -0.04163644f, 0.03747563f, -0.04084380f, -0.04899276f, 
    -0.00038428f, -0.00108107f, -0.00930349f, -0.04727543f, 0.02852202f, 0.03292711f, -0.00492711f, 0.03083720f, 
    0.01781152f, -0.04202057f, 0.04689974f, -0.03355785f, 0.01224061f, 0.02946464f, 0.04197413f, -0.04278951f, 
    0.00806481f, -0.01671251f, -0.04655817f, -0.02012026f, -0.03603750f, -0.04315044f, 0.02452003f, -0.05141600f, 
    -0.01332429f, -0.06040133f, -0.01025129f, 0.03363083f, -0.05824488f, -0.02473342f, -0.03812976f, 0.03805229f, 
    -0.02446133f, 0.06133599f, 0.03535718f, -0.01567850f, -0.00547556f, 0.06230688f, -0.03620586f, 0.00346646f, 
    0.00146865f, -0.05299870f, 0.02679483f, 0.00823367f, -0.00934823f, 0.03061226f, -0.04505868f, 0.00936546f, 
    -0.06393142f, 0.01204296f, -0.00116333f, 0.02890817f, 0.02495322f, -0.03000199f, 0.02036249f, -0.01744088f, 
    -0.03111818f, -0.00108092f, -0.01628693f, -0.06099438f, 0.01498788f, -0.05427737f, 0.00776420f, -0.01175410f, 
    0.25867671f, 0.08573779f, 0.09618717f, -0.02050256f, -0.05665549f, 0.01593046f, 0.04397090f, -0.01095206f, 
    0.02441282f, 0.37605256f, 0.05314955f, 0.06300992f, 0.04952278f, 0.15161419f, 0.09737989f, 0.07090952f, 
    0.19796401f, 0.17493699f, 0.12763192f, 0.14592773f, 0.30349049f, 0.00847123f, 0.01455033f, -0.05828954f, 
    -0.02380727f, -0.04317336f, 0.10850468f, 0.03431323f, -0.53683126f, -0.05513437f, 0.13177730f, 0.21299060f, 
    0.04234013f, -0.16641772f, -0.15820290f, 0.10637689f, -0.09426033f, -0.13611421f, -0.04622674f, 0.00886986f, 
    -0.05626323f, -0.13583449f, -0.10422163f, -0.01818855f, 0.05895301f, -0.23914495f, -0.25002429f, -0.27047625f, 
    -0.00573234f, 0.09973940f, 0.12092190f, -0.01670559f, -0.00388393f, 0.16987348f, 0.32039040f, -0.38332757f, 
    -0.79979503f, 0.10089823f, 0.08556388f, -0.09814093f, 0.12639789f, 0.08379760f, 0.05223109f, 0.02692176f, 
    0.27267256f, 0.15478840f, 0.10784315f, 0.03950553f, 0.04811157f, 0.11358111f, -0.01375257f, 0.02806140f, 
    -0.55451548f, -0.21205831f, 0.15756397f, -0.04048954f, 0.14625695f, -0.12087039f, 0.16203840f, 0.15990511f, 
    0.04908304f, -0.31868830f, -0.12091276f, 0.36036456f, -0.20845087f, -0.01604714f, 0.19678693f, 0.08625907f, 
    0.03302219f, 0.06803019f, 0.07095123f, -0.39735246f, -0.05413322f, -0.10179680f, -0.03313031f, 0.01584027f, 
    0.22935943f, -0.09668297f, 0.04451773f, -0.00386422f, -0.18764517f, -0.21834870f, 0.00984191f, 0.05482920f, 
    -0.10653510f, 0.00662572f, 0.06387914f, -0.06215807f, -0.40917480f, -0.06389625f, 0.17234719f, -0.19662446f, 
    0.05948725f, 0.03179228f, 0.21478842f, -0.08724473f, -0.07899755f, -0.07091170f, 0.33481973f, -0.18030678f, 
    -0.25015697f, 0.03090589f, -0.18939020f, 0.02899746f, 0.18099698f, 0.10156088f, -0.08163562f, -0.30112076f, 
    -0.18149924f, -0.23976479f, 0.13584775f, 0.11529926f, -0.04155464f, 0.15238842f, 0.12675902f, 0.29931143f, 
    -0.07849594f, 0.11578590f, -0.07518876f, -0.06872994f, 0.25586444f, 0.06823643f, 0.05623252f, -0.01681277f, 
    0.00109859f, -0.22147374f, -0.33466649f, -0.19703375f, -0.07405335f, -0.06244057f, -0.03271486f, -0.17430706f, 
    -0.09546058f, -0.50465012f, -0.46813601f, -0.46567225f, -0.11806419f, 0.04758183f, 0.24707709f, 0.05950772f, 
    0.05005778f, 0.00552857f, -0.19640851f, -0.04193796f, 0.02818541f, -0.04367302f, -0.11103950f, -0.03850364f, 
    0.17001908f, -0.09020358f, 0.00654349f, 0.26463389f, -0.33429882f, -0.46729490f, -0.03481382f, 0.17316642f, 
    0.02233410f, 0.03243731f, -0.07199286f, 0.04157333f, -0.16898730f, -0.43469456f, -0.55345702f, -0.27192599f, 
    -0.14262375f, 0.03593561f, 0.20901722f, -0.01941133f, -0.08665462f, -0.08713466f, 0.10419451f, -0.08162505f, 
    0.17553896f, -0.12162722f, -0.12174734f, 0.10089608f, 0.04170121f, -0.20794250f, 0.44024363f, -0.10418158f, 
    -0.17513455f, 0.00507244f, -0.08516487f, -0.10172199f, 0.05771785f, -0.00427534f, -0.04204210f, 0.10692389f, 
    -0.10753064f, 0.07929854f, -0.03290537f, -0.11974029f, -0.00213770f, 0.26309180f, 0.01335541f, -0.05451295f, 
    -0.17988883f, -0.22592010f, 0.19058223f, -0.02801367f, 0.02466543f, -0.15508933f, -0.03764177f, -0.03250924f, 
    0.13327254f, -0.09891883f, 0.00994295f, 0.08827347f, 0.03945571f, -0.03491899f, 0.01010086f, -0.08252254f, 
    0.11353724f, -0.09321848f, -0.26936010f, -0.09390867f, -0.26619264f, 0.00728664f, -0.09758766f, 0.09491697f, 
    0.11586254f, 0.11201635f, 0.15736011f, 0.05749720f, 0.22698605f, 0.07579601f, 0.06532568f, 0.01657329f, 
    0.14771928f, 0.24958795f, -0.02672310f, -0.03132835f, 0.02515201f, 0.04382442f, 0.10035043f, -0.02032948f, 
    -0.16956751f, 0.02946882f, -0.08546258f, 0.08619335f, 0.11652417f, -0.05444092f, -0.00300979f, -0.01119391f, 
    -0.18591109f, -0.01325057f, 0.02360748f, 0.14631835f, 0.03285436f, 0.00417637f, 0.00656589f, 0.00774339f, 
    0.14706405f, -0.16478731f, -0.05784664f, 0.11283080f, 0.17402287f, -0.07092239f, -0.14895278f, 0.23235369f, 
    -0.03750401f, -0.09116094f, 0.04679247f, 0.10950254f, -0.03152218f, 0.05363138f, -0.13653409f, -0.02948900f, 
    0.06578753f, -0.18502359f, -0.23627424f, -0.13139701f, -0.07555087f, -0.08393950f, -0.00747177f, -0.05546908f, 
    -0.11695756f, 0.02929364f, 0.03262068f, -0.08516874f, -0.14279521f, -0.07156285f, 0.04805562f, -0.13765562f, 
    0.01173954f, 0.04810788f, 0.11499470f, 0.15238923f, -0.07942426f, 0.03396764f, -0.19695839f, -0.02708627f, 
    0.08598129f, 0.07831836f, 0.11291811f, -0.68844312f, -0.02618234f, 0.05748639f, 0.12124754f, 0.03896737f, 
    -0.00510277f, 0.05077475f, -0.03191021f, 0.04162695f, -0.10804896f, 0.19765833f, 0.03548839f, -0.05662477f, 
    0.07978293f, -0.13047798f, -0.08068048f, -0.04417158f, 0.08744475f, -0.08789302f, 0.04147255f, -0.08352335f, 
    0.09692640f, 0.13500541f, 0.02842762f, 0.05960427f, -0.00879307f, 0.12702048f, -0.21647188f, -0.19888312f, 
    -0.40830067f, -0.05330229f, -0.17958491f, -0.02881201f, 0.03017386f, -0.00391951f, -0.05159836f, 0.15907127f, 
    0.05148586f, -0.08259645f, 0.07559857f, -0.07487317f, -0.05243030f, -0.09769388f, -0.07253729f, 0.09945402f, 
    -0.07375520f, -0.04736574f, 0.18152675f, 0.11976771f, 0.16110292f, 0.03883504f, 0.21863776f, -0.13426670f, 
    -0.13619523f, 0.21361443f, 0.06423231f, 0.00799622f, -0.06048383f, 0.01503193f, 0.03261055f, -0.01932078f, 
    -0.10868641f, -0.14556800f, 0.16386099f, -0.22172923f, -0.08710101f, 0.16189399f, -0.10873753f, 0.04201223f, 
    0.00460272f, 0.06258436f, 0.04740954f, -0.09796175f, -0.17138553f, -0.09943143f, -0.15950105f, -0.04294290f, 
    -0.05940803f, 0.08252599f, -0.12943524f, 0.13060832f, 0.28186888f, 0.37341097f, -0.00955355f, -0.00723394f, 
    -0.03163467f, 0.15812641f, -0.08422104f, 0.09681614f, 0.04525278f, 0.08314937f, -0.20617490f, -0.37366897f, 
    -0.28758004f, 0.06743018f, 0.24753289f, -0.00949876f, -0.07894296f, 0.26133162f, -0.01571119f, -0.07716828f, 
    -0.13072376f, -0.11084783f, 0.06793731f, -0.06353096f, 0.11588981f, -0.03880061f, -0.07223951f, 0.30188668f, 
    0.07561021f, -0.14111465f, -0.06271140f, -0.05450146f, 0.10729187f, -0.05903997f, 0.18232453f, 0.01543555f, 
    -0.15258133f, -0.06252773f, -0.54940152f, 0.05860108f, -0.00366549f, -0.03189315f, 0.00671657f, -0.00372284f, 
    0.13395916f, -0.32385150f, -0.33655497f, -0.66616315f, 0.04246482f, 0.02913247f, 0.07548055f, 0.15880477f, 
    -0.05656460f, -0.02715019f, 0.27187634f, 0.02043118f, 0.07918269f, 0.14748959f, 0.06937897f, 0.09718917f, 
    -0.03980224f, 0.12123493f, 0.04901091f, -0.12620176f, -0.12504543f, -0.46504900f, 0.01348076f, 0.07228895f, 
    0.04440919f, 0.01043895f, -0.02008230f, -0.06496038f, -0.68281680f, -0.36665720f, -0.03703532f, 0.00536408f, 
    -0.20609419f, -0.13779841f, 0.05821687f, -0.00449539f, -0.00706940f, 0.00448216f, -0.47536510f, 0.02035131f, 
    0.11141772f, 0.05467221f, -0.15043005f, 0.14766185f, -0.05744140f, -0.09528206f, 0.12933044f, -0.01889802f, 
    -0.18883197f, 0.00815359f, 0.04637853f, 0.03392450f, -0.09069984f, -0.02289746f, 0.03511502f, 0.26202491f, 
    0.12325893f, -0.03242555f, -0.02874402f, -0.02361742f, 0.14859131f, 0.06544214f, 0.08630449f, 0.02368648f, 
    0.10810135f, 0.04321689f, 0.13432850f, 0.16742091f, -0.02195339f, -0.04666441f, -0.06758103f, 0.04964811f, 
    -0.11155447f, 0.07054230f, 0.02603277f, 0.19493033f, -0.09965764f, 0.06897870f, -0.18415445f, -0.07921804f, 
    -0.00007025f, -0.10795976f, 0.10561664f, 0.12248095f, -0.19793843f, 0.13126999f, -0.04575996f, 0.08725755f, 
    -0.10420043f, 0.03454689f, 0.08633910f, 0.16733831f, -0.08878549f, 0.03966122f, -0.12995948f, -0.08018183f, 
    0.12769280f, -0.04275568f, -0.10423506f, 0.04426654f, 0.12641370f, 0.13268851f, 0.07592844f, -0.05813827f, 
    -0.11776592f, -0.18892555f, -0.07012203f, 0.18719068f, 0.12495588f, 0.37399903f, 0.14903286f, -0.15190797f, 
    -0.10142236f, -0.00539302f, 0.00703659f, -0.09704535f, -0.04947270f, 0.07611781f, 0.30507255f, 0.07009924f, 
    -0.14299150f, 0.02953117f, -0.01495142f, -0.01276173f, 0.03692224f, -0.08898842f, 0.11360338f, 0.31847554f, 
    -0.09014484f, -0.04257774f, -0.14795908f, -0.08880156f, 0.03891816f, 0.07970465f, -0.06562548f, 0.13368000f, 
    -0.00301777f, 0.02464145f, -0.02016651f, -0.04729498f, -0.05186237f, -0.01891280f, -0.03790386f, 0.05579493f, 
    -0.05871793f, -0.03607270f, -0.03865701f, -0.02246594f, -0.05764046f, 0.01772990f, -0.00207209f, -0.01761951f, 
    -0.01338319f, 0.01035201f, 0.00677638f, -0.06002429f, -0.00446710f, -0.01987543f, -0.00867975f, 0.02128969f, 
    0.03812717f, -0.04691545f, 0.04782079f, 0.00759117f, -0.02206138f, -0.02167745f, -0.03819312f, 0.04165715f, 
    -0.06540209f, 0.04984519f, -0.00896413f, 0.00330588f, 0.00729102f, -0.04447926f, -0.01037654f, -0.04396887f, 
    -0.04900783f, -0.06791186f, -0.01908740f, -0.02412762f, 0.02246870f, 0.01487051f, -0.01492943f, 0.00972955f, 
    -0.00362996f, -0.06659449f, -0.04114250f, -0.02884567f, -0.04900014f, 0.04540610f, 0.01798662f, -0.00492931f, 
    0.01097861f, 0.00738572f, -0.00875250f, -0.04690357f, 0.01997310f, -0.01827390f, -0.03020497f, 0.02378384f, 
    -0.03612031f, -0.01271815f, 0.02082852f, -0.01836684f, -0.04110975f, 0.03456462f, 0.03743700f, 0.00945432f, 
    -0.01042151f, 0.01258203f, 0.01912325f, -0.03956338f, -0.03363700f, -0.00068937f, -0.03219083f, 0.02943824f, 
    -0.00618010f, 0.00385753f, 0.00458019f, 0.05000737f, 0.03135036f, 0.03090359f, 0.01787342f, 0.03051024f, 
    -0.01151741f, -0.02368986f, 0.02278486f, -0.02934140f, -0.07006280f, 0.02811126f, -0.01331547f, 0.01041104f, 
    -0.05364798f, -0.05856036f, -0.04281789f, -0.02314524f, -0.04104856f, -0.04869947f, -0.04599326f, -0.02436489f, 
    0.03559574f, 0.00466564f, -0.01156121f, -0.04046648f, -0.03221685f, 0.03091666f, -0.05294632f, -0.01696931f, 
    0.01027874f, -0.02083706f, -0.03550128f, -0.02013488f, -0.06545438f, 0.00922886f, -0.02108192f, 0.04366135f, 
    0.03207631f, -0.00420701f, -0.02830602f, -0.00239761f, -0.01197195f, 0.03996495f, -0.05625517f, -0.03227970f, 
    -0.04432147f, -0.01739813f, 0.01505260f, -0.06183961f, -0.06238559f, -0.05453259f, -0.05294045f, 0.00077057f, 
    0.01873791f, -0.05985208f, 0.01963239f, -0.02194177f, -0.05366760f, 0.04506342f, 0.01330280f, -0.03846995f, 
    0.01006975f, 0.02226979f, -0.00879784f, 0.01898317f, -0.03158296f, 0.00948622f, 0.03308555f, -0.05327004f, 
    0.00379347f, 0.03745014f, 0.00895367f, -0.02713862f, -0.05401136f, 0.02948832f, 0.03155738f, -0.05955340f, 
    -0.07442746f, 0.05028271f, 0.03135633f, -0.03996148f, 0.02616334f, 0.03416529f, -0.00641364f, -0.01655716f, 
    -0.00599785f, 0.04567483f, -0.00938339f, 0.00939827f, 0.03488135f, -0.01282225f, -0.03126442f, -0.02456130f, 
    -0.05262752f, -0.03774976f, -0.01972722f, -0.01041648f, 0.00016088f, -0.04816800f, -0.00344142f, 0.00830373f, 
    -0.05747626f, 0.04099812f, 0.04079740f, 0.02578133f, 0.04350884f, -0.01356362f, -0.03004109f, 0.04993381f, 
    0.04663748f, 0.01576260f, -0.05785328f, -0.00489457f, 0.02750105f, 0.03302435f, 0.02498520f, 0.02364375f, 
    0.02563631f, -0.03649920f, 0.02227118f, 0.02031559f, 0.01091331f, -0.06242867f, 0.02887629f, -0.03192725f, 
    0.00246035f, 0.03263066f, -0.04458184f, -0.02579810f, -0.00806396f, 0.01072253f, 0.03183281f, -0.02176822f, 
    -0.06748754f, -0.04287918f, -0.02302417f, 0.01886806f, 0.01755940f, -0.00368097f, 0.03222293f, -0.00955773f, 
    0.03563467f, -0.02557594f, -0.04190317f, 0.02370648f, 0.03332148f, 0.03758720f, 0.00942405f, -0.03681269f, 
    -0.05807107f, 0.04041088f, 0.03283614f, 0.00812603f, -0.00945440f, -0.03999632f, -0.04002900f, -0.04101660f, 
    0.03196532f, 0.00092356f, -0.02639057f, 0.00449684f, -0.00288931f, 0.01505566f, -0.03156784f, -0.02906948f, 
    -0.05708546f, 0.02296562f, -0.05767058f, -0.03359042f, 0.00309701f, -0.03394955f, -0.00436637f, -0.04206342f, 
    -0.02031854f, 0.01957975f, -0.05294175f, -0.06430903f, -0.05503197f, 0.02035371f, 0.00099480f, -0.04939906f, 
    0.01245189f, -0.04736408f, 0.02249331f, -0.03619372f, 0.00083016f, -0.05471767f, -0.04164564f, -0.04569514f, 
    0.01680673f, -0.03311518f, -0.02452036f, -0.02294990f, 0.02628920f, 0.04868345f, -0.02947081f, 0.05226346f, 
    0.00441484f, 0.02844334f, 0.02048110f, 0.03161350f, -0.01887998f, -0.02821155f, 0.02108872f, 0.02571131f, 
    -0.00940943f, -0.04891673f, -0.04623707f, -0.00187844f, -0.00723498f, -0.01507580f, 0.04084210f, -0.02811533f, 
    -0.01811138f, 0.03096440f, 0.00102166f, 0.04703471f, 0.04984980f, 0.04903544f, -0.05604807f, 0.04344730f, 
    0.05039015f, -0.01098592f, -0.02510382f, 0.00421656f, -0.05713832f, -0.03577007f, 0.03787114f, -0.03123783f, 
    -0.00388006f, -0.05591917f, 0.01182009f, 0.05035397f, 0.05059410f, -0.01665740f, -0.01622104f, -0.02618138f, 
    0.04002282f, -0.01574844f, 0.01860444f, 0.02432798f, 0.00183717f, -0.06056299f, -0.02352136f, 0.02504998f, 
    -0.06041474f, -0.02475869f, -0.06542946f, -0.05978938f, -0.00748967f, -0.00791134f, -0.01233471f, -0.04506754f, 
    -0.04820733f, 0.04457972f, -0.01081931f, -0.02854672f, 0.00086692f, 0.04532000f, -0.01227569f, -0.00513373f, 
    -0.06201946f, -0.00705899f, -0.03546697f, 0.02080240f, -0.06497812f, 0.03446826f, -0.01616012f, 0.02116528f, 
    0.05027166f, -0.03482727f, -0.02151439f, 0.05443523f, 0.05440481f, 0.03266726f, 0.04011550f, -0.01352878f, 
    0.02760261f, -0.00269931f, 0.04279521f, 0.04969288f, -0.05588699f, 0.03564239f, -0.03596203f, -0.00701349f, 
    0.03219415f, 0.02475621f, 0.00785622f, -0.03491650f, 0.01474984f, -0.03443056f, 0.01401593f, -0.05474196f, 
    0.02194042f, 0.01260710f, 0.00790144f, 0.01895928f, 0.02691782f, 0.00570706f, -0.04915749f, -0.00692382f, 
    -0.01497301f, 0.01540964f, -0.02002392f, -0.02175110f, -0.02823312f, -0.01684699f, -0.01540831f, -0.01211235f, 
    0.04036785f, -0.01074685f, 0.02385427f, -0.04287767f, -0.04183348f, -0.02670460f, -0.01678315f, 0.04389970f, 
    0.03383837f, 0.03132470f, 0.04238583f, 0.03685005f, -0.01292970f, -0.03752334f, 0.02455291f, 0.04152578f, 
    -0.03588125f, -0.02478366f, 0.00029019f, -0.00103558f, -0.05589868f, 0.03491902f, -0.05273869f, 0.01501555f, 
    -0.00401579f, 0.02027539f, -0.05205366f, -0.01189114f, -0.02801487f, -0.02166124f, -0.00025934f, 0.03680896f, 
    0.02256451f, 0.00692524f, -0.04239112f, -0.05151590f, -0.05173475f, -0.00033480f, -0.06078321f, -0.02178494f, 
    -0.04211484f, -0.01960997f, 0.04364265f, 0.03774819f, -0.03113657f, -0.00950481f, -0.01459128f, 0.03748649f, 
    0.01756461f, 0.01721653f, -0.03291292f, -0.07070224f, 0.02155511f, -0.05356090f, -0.06148981f, -0.05173214f, 
    -0.03736782f, -0.00477236f, -0.02632252f, 0.02355443f, 0.03544861f, -0.03025625f, -0.02580131f, 0.03721563f, 
    -0.03304791f, 0.00811212f, -0.01443918f, -0.04585175f, 0.03212347f, -0.06603589f, -0.03260517f, -0.06197897f, 
    -0.01876063f, -0.05355187f, 0.05287896f, 0.00291383f, 0.01374133f, -0.03203347f, -0.01820112f, 0.03036780f, 
    0.03885703f, 0.04353284f, 0.02882361f, 0.02496395f, 0.04019564f, 0.04230227f, 0.03826210f, 0.01887050f, 
    -0.05962657f, -0.02555098f, 0.03903694f, 0.02663567f, -0.03961549f, 0.04226859f, -0.02105132f, -0.05445341f, 
    0.00840514f, -0.03389450f, -0.01045959f, 0.01623327f, 0.00771947f, 0.03816042f, -0.03658605f, 0.01642296f, 
    0.01727660f, -0.04628878f, 0.00172487f, -0.03544893f, -0.04593163f, 0.04541513f, 0.00722759f, 0.01169360f, 
    -0.01072729f, -0.06517380f, 0.03950061f, -0.01141545f, 0.03375343f, -0.03155729f, 0.04780289f, 0.01457567f, 
    -0.04865151f, 0.01251496f, 0.01370374f, -0.05052756f, -0.01937184f, -0.05279766f, 0.04702055f, -0.01119529f, 
    -0.01906366f, 0.00539708f, -0.02767075f, 0.00108892f, -0.03031286f, 0.03364000f, -0.00865429f, 0.02271696f, 
    -0.01637589f, 0.02183757f, 0.00232500f, 0.01492304f, -0.01366027f, 0.04683474f, 0.05098077f, -0.03256877f, 
    -0.02548087f, -0.00465195f, 0.00938378f, -0.05022528f, -0.03888967f, -0.01858076f, -0.03877376f, -0.02746793f, 
    -0.02645040f, -0.01382721f, -0.05555123f, 0.01464887f, -0.00966828f, -0.04255009f, 0.00836753f, -0.00191675f, 
    -0.03088438f, -0.03270826f, 0.02776955f, -0.03790487f, 0.05434950f, -0.04821132f, 0.01306574f, 0.00111936f, 
    -0.04427759f, 0.02932003f, 0.03286568f, 0.05407975f, -0.03563913f, 0.04809237f, 0.01084392f, 0.03835272f, 
    -0.01389726f, -0.05067970f, 0.02230037f, -0.05257279f, 0.05144421f, -0.02836630f, 0.03673919f, -0.03496595f, 
    0.10924982f, 0.08215537f, -0.11457404f, 0.07644793f, 0.06713785f, 0.12289972f, -0.08856153f, 0.07508052f, 
    -0.04657267f, 0.04356621f, 0.14081229f, -0.08698373f, 0.21546736f, -0.02844785f, 0.01588912f, -0.05792278f, 
    0.11036026f, -0.04245399f, -0.04658416f, -0.02473263f, 0.07813045f, -0.09477098f, -0.11900602f, 0.10162962f, 
    0.09577868f, 0.17840862f, 0.14375465f, 0.01493199f, -0.23032995f, -0.05433378f, -0.05362343f, 0.06674266f, 
    0.16858366f, -0.20022471f, 0.00155657f, -0.09608020f, -0.01461074f, -0.13209520f, 0.01162459f, 0.01776359f, 
    0.01872015f, 0.20125815f, 0.07743716f, 0.04674317f, 0.18953893f, -0.04910301f, 0.00416107f, -0.03023460f, 
    -0.01488356f, 0.11881652f, -0.08251158f, 0.02562966f, 0.15363434f, 0.14261566f, -0.05319937f, 0.13188300f, 
    -0.06656838f, 0.06750549f, -0.08942435f, 0.18757084f, 0.16425516f, 0.21914078f, 0.03573313f, 0.00477222f, 
    -0.10492665f, -0.35108560f, 0.01316391f, 0.20274881f, 0.01423510f, -0.20876954f, 0.04906113f, -0.06463044f, 
    0.32739928f, 0.00174973f, 0.20659272f, 0.17565149f, 0.17327593f, 0.09082918f, 0.27384141f, -0.01728016f, 
    0.18174355f, 0.04996262f, 0.16406998f, 0.20133515f, 0.02577378f, 0.11651497f, 0.10542621f, 0.11626723f, 
    0.15169278f, -0.06291521f, -0.14594528f, 0.01212968f, -0.08882833f, 0.12269371f, 0.09567605f, 0.11124222f, 
    0.11600279f, -0.12071581f, -0.26600838f, 0.08962276f, -0.12007954f, -0.11853410f, 0.11067415f, 0.09286506f, 
    0.07313071f, 0.02617486f, 0.01640475f, -0.05270085f, 0.05981458f, 0.19249402f, 0.07720204f, 0.18112417f, 
    0.07362460f, 0.22854200f, -0.07779033f, -0.26480529f, -0.16153850f, 0.27685502f, 0.44151405f, -0.09143795f, 
    0.19626662f, 0.02249805f, 0.17170478f, -0.03835043f, 0.13183972f, 0.06268252f, -0.05304062f, -0.02610002f, 
    -0.07190563f, 0.12031723f, 0.05368555f, 0.09495921f, -0.08906763f, 0.04147652f, 0.10436700f, -0.07039125f, 
    0.17164437f, 0.03018760f, 0.03456442f, 0.18186818f, -0.09187094f, -0.10154516f, -0.03697614f, 0.03271088f, 
    -0.28523439f, -0.45542428f, -0.17092578f, 0.18152185f, 0.21480528f, 0.06172550f, -0.12093482f, -0.01416196f, 
    -0.02819412f, 0.15052111f, 0.21136793f, 0.10584845f, 0.23671983f, 0.11283771f, 0.11134423f, -0.15428145f, 
    0.03022246f, -0.08296412f, 0.06484034f, 0.27587041f, 0.08715916f, 0.09883446f, -0.00537832f, -0.23339339f, 
    -0.05901977f, 0.07929140f, -0.01315468f, -0.29124165f, -0.27333766f, -0.42357755f, -0.06323701f, 0.01793863f, 
    -0.00770579f, 0.02837705f, -0.00162890f, -0.20075466f, 0.08315316f, 0.28072324f, -0.04622534f, -0.06072389f, 
    0.02188659f, 0.17159392f, -0.01588857f, -0.16289331f, -0.11458734f, -0.00463198f, 0.21717757f, 0.00115888f, 
    -0.05640936f, 0.00032962f, -0.11281803f, -0.09666459f, -0.19450508f, -0.12344209f, -0.26690763f, -0.07553287f, 
    -0.23775138f, 0.19423135f, 0.31319699f, 0.00943434f, -0.05738832f, -0.07963926f, -0.09166938f, -0.10871863f, 
    0.01547317f, -0.14133792f, 0.16233358f, -0.05068767f, -0.05347450f, -0.05580672f, -0.26995781f, -0.29383162f, 
    0.03150976f, -0.10120526f, -0.20948069f, 0.04296689f, 0.10104845f, 0.03411383f, 0.11870822f, 0.18199027f, 
    0.13362932f, 0.05900030f, 0.09723679f, -0.04011967f, 0.03454092f, 0.17393056f, 0.15023673f, 0.04400789f, 
    0.04517226f, 0.17705084f, -0.23167196f, 0.04883050f, 0.03678661f, 0.03457274f, 0.08323260f, -0.00780122f, 
    -0.22119921f, 0.07708141f, 0.15607685f, 0.15088905f, 0.16151133f, -0.11960409f, 0.14127478f, 0.06706765f, 
    -0.07205696f, -0.13569421f, 0.00839425f, -0.17104813f, -0.17074509f, 0.05227882f, -0.03208433f, -0.09826476f, 
    -0.13821758f, 0.01267638f, 0.04242550f, 0.35137543f, 0.06434841f, -0.16596733f, -0.23099622f, -0.05055042f, 
    0.07945823f, 0.15180089f, -0.14403406f, -0.26459727f, -0.28415510f, -0.31263635f, 0.07136636f, 0.20203310f, 
    -0.01722503f, -0.18131137f, -0.03600573f, -0.00696296f, -0.15607965f, 0.24247089f, -0.08448710f, 0.04873874f, 
    0.20382747f, 0.14898437f, -0.16344263f, -0.08526464f, -0.03306391f, 0.01991803f, 0.07697338f, -0.10743774f, 
    -0.33144403f, -0.04738069f, -0.23207848f, -0.00591625f, 0.00455158f, -0.12890258f, 0.07624722f, 0.13504316f, 
    -0.04727453f, 0.07594624f, 0.16903378f, 0.23102507f, 0.01606784f, -0.03740847f, -0.09627066f, -0.05514893f, 
    0.12302700f, 0.10770699f, -0.27303356f, 0.09500682f, -0.09676310f, 0.06973040f, 0.07851893f, -0.07952719f, 
    0.13408811f, -0.21677710f, 0.12002259f, 0.22331759f, 0.18020542f, 0.07074433f, 0.12723249f, 0.00412242f, 
    -0.08742946f, -0.02453723f, 0.01786213f, 0.13007312f, -0.01649427f, -0.12779000f, 0.06696654f, 0.02827577f, 
    -0.03532853f, -0.04673335f, 0.07545558f, -0.05322756f, 0.06353471f, 0.26576126f, 0.18048693f, -0.03349073f, 
    -0.00423700f, -0.05335300f, 0.15917991f, 0.09426469f, 0.15602523f, 0.13755499f, 0.05532528f, -0.16631004f, 
    0.03770984f, 0.07136112f, 0.12921597f, 0.06179954f, 0.00404233f, 0.00398628f, 0.26285106f, -0.19199447f, 
    0.05737033f, -0.40872633f, -0.16850039f, 0.00213474f, -0.09901524f, 0.24130876f, 0.11228494f, 0.14265348f, 
    0.06559617f, 0.16837505f, -0.17115675f, -0.15444344f, 0.00260068f, 0.18842290f, 0.04683586f, 0.09585333f, 
    0.19721691f, 0.10741260f, -0.10912613f, 0.01401912f, 0.15457231f, 0.07934063f, -0.04082699f, 0.13325228f, 
    0.15774664f, -0.06474661f, -0.10412335f, 0.05905552f, 0.01371224f, 0.12016830f, 0.09395485f, 0.01083894f, 
    -0.07523552f, -0.08900309f, 0.04460823f, -0.11285447f, -0.02863088f, -0.01479812f, -0.05358531f, 0.05722347f, 
    -0.02753023f, 0.16898695f, 0.08875250f, 0.15657416f, 0.11750881f, -0.27928194f, -0.06255269f, 0.04730924f, 
    -0.03832950f, 0.09181003f, -0.12264487f, -0.05603731f, -0.15581958f, -0.65877151f, -0.04982230f, 0.13123333f, 
    -0.09873437f, 0.11495493f, -0.06452069f, 0.12361553f, -0.13023175f, 0.01352971f, 0.06611916f, 0.21200633f, 
    -0.01988349f, 0.01759149f, -0.13655394f, 0.16167219f, -0.00068883f, -0.07151645f, 0.02196498f, -0.10599719f, 
    -0.13039906f, 0.01007229f, 0.04485384f, 0.23257808f, -0.13306351f, -0.22186460f, 0.10634243f, -0.10341444f, 
    0.15656790f, 0.08640904f, 0.21710844f, 0.04525705f, -0.04521451f, -0.04428199f, -0.04906483f, 0.00472889f, 
    0.00430692f, -0.42353567f, -0.18295613f, -0.14602393f, 0.10792461f, 0.17658089f, 0.01716252f, 0.01527685f, 
    -0.05462777f, 0.13571882f, -0.54387289f, 0.03040601f, -0.17021726f, -0.10658348f, -0.05677637f, -0.11033139f, 
    -0.05288489f, -0.10246706f, 0.03056028f, 0.31580660f, 0.22222964f, 0.13156380f, -0.18215710f, 0.01330867f, 
    -0.04244345f, 0.02412279f, 0.01893214f, 0.06919172f, 0.21841554f, 0.23525175f, -0.20886886f, 0.03347664f, 
    -0.11567006f, 0.12379411f, 0.02751746f, 0.12257014f, -0.11280712f, -0.16991156f, 0.07582213f, 0.13635716f, 
    0.00362703f, -0.13489369f, 0.05913819f, -0.19426697f, -0.11644750f, -0.14064099f, 0.07364518f, 0.21852809f, 
    0.11764885f, -0.00101830f, 0.05624596f, 0.00866387f, -0.07074540f, 0.08553372f, 0.13048735f, 0.08118955f, 
    -0.16480751f, -0.27224338f, 0.01222506f, -0.01144512f, 0.08239606f, -0.14753816f, -0.09111527f, -0.04464830f, 
    -0.03680897f, 0.02713352f, 0.07467351f, -0.04432798f, -0.10898779f, 0.04216903f, 0.16461213f, 0.08149121f, 
    0.07230303f, -0.27485013f, -0.08487057f, -0.00356319f, -0.06868321f, 0.09002130f, -0.01645869f, 0.01243413f, 
    0.11647230f, -0.04464717f, -0.16676460f, -0.13102369f, -0.04707129f, -0.11263105f, 0.07903266f, -0.05832677f, 
    0.01505704f, -0.04116755f, 0.09899255f, 0.06510171f, -0.04820662f, 0.10553584f, -0.10548663f, -0.04870874f, 
    0.02282215f, 0.13009979f, -0.04490722f, 0.14345920f, -0.32115421f, -0.03487470f, -0.11209211f, -0.20594651f, 
    -0.02689941f, -0.08506096f, 0.02337689f, -0.17939714f, 0.01555764f, -0.17032886f, -0.07591760f, -0.48429587f, 
    -0.18615592f, -0.17224424f, 0.03590010f, 0.08092830f, 0.13036832f, 0.05795247f, -0.13167658f, 0.04216083f, 
    -0.36710915f, -0.08559845f, 0.30922243f, -0.14956449f, 0.02213045f, 0.07082359f, -0.04374912f, -0.18658729f, 
    0.03172758f, -0.30985600f, -0.04684728f, 0.17974921f, 0.04296280f, 0.10511492f, 0.10216637f, 0.09306408f, 
    -0.03079304f, 0.18308371f, 0.25165212f, 0.28501868f, 0.01221571f, 0.01024689f, -0.07933354f, 0.11005763f, 
    0.00485212f, 0.04589251f, 0.03203948f, -0.23024271f, 0.05394011f, 0.03273629f, -0.00469534f, 0.02309788f, 
    0.03127638f, 0.12263107f, 0.11818835f, -0.11720252f, 0.08588003f, 0.11562327f, 0.16348639f, -0.19788690f, 
    -0.00676754f, -0.43799388f, -0.35637283f, 0.08010373f, 0.26196003f, -0.11529144f, -0.00833897f, -0.11503211f, 
    -0.09494514f, 0.08337960f, -0.03144663f, 0.05119304f, 0.19976121f, 0.25645503f, -0.11166424f, 0.10327193f, 
    0.04504178f, 0.11442619f, 0.04466860f, 0.07830231f, 0.16027811f, 0.13632007f, 0.06724203f, 0.02451933f, 
    0.08140388f, -0.05896961f, 0.10821492f, 0.01740035f, -0.07925525f, -0.22758493f, 0.06747194f, 0.05753668f, 
    -0.12791586f, -0.01339921f, 0.05433112f, -0.01222803f, -0.10098252f, 0.04557914f, -0.14230321f, 0.08040980f, 
    -0.09707177f, 0.15924227f, 0.17407709f, 0.13323157f, 0.03269786f, -0.03270238f, 0.05098167f, 0.01313433f, 
    0.48084185f, -0.09902614f, -0.05238932f, 0.02800654f, 0.17603181f, -0.05132376f, 0.11904208f, 0.03980861f, 
    -0.12608668f, -0.07033172f, 0.19285867f, -0.28469816f, 0.04769241f, -0.06802844f, -0.05238567f, 0.05449175f, 
    0.09490469f, 0.15862811f, 0.05234231f, -0.10139652f, -0.04723020f, -0.04133778f, 0.21560994f, 0.11039288f, 
    0.01264166f, -0.07510478f, 0.01555494f, 0.25275460f, 0.24871896f, 0.07498766f, 0.03047034f, -0.05897921f, 
    0.06420030f, 0.03199639f, 0.12467475f, -0.09907977f, -0.03050186f, -0.11458298f, -0.07018072f, 0.01700945f, 
    -0.04393281f, 0.12646025f, 0.07604597f, 0.03313666f, 0.28800973f, 0.06663653f, -0.02849648f, 0.08758431f, 
    0.11458267f, -0.05243028f, -0.02114098f, -0.02444120f, 0.33054757f, 0.03750152f, -0.17775466f, -0.08539006f, 
    -0.08563855f, 0.09525579f, 0.07612039f, 0.11266756f, -0.16066135f, -0.17237802f, -0.23423935f, 0.01031276f, 
    -0.13514802f, -0.15499865f, -0.02217762f, -0.06420170f, 0.12689494f, -0.00653151f, 0.00299907f, 0.03673356f, 
    0.13322799f, 0.12850119f, -0.05025868f, -0.01424338f, 0.16236597f, 0.06919144f, 0.08393583f, -0.02072110f, 
    -0.08293433f, -0.01060560f, 0.02829812f, 0.20441553f, 0.17094569f, 0.17153384f, -0.04307897f, -0.23148914f, 
    -0.23979078f, 0.00470540f, 0.03762555f, -0.17524783f, -0.26655725f, 0.17800148f, 0.29829797f, 0.25817433f, 
    -0.01524047f, 0.01736810f, 0.29809558f, 0.12590198f, 0.15982951f, -0.00982162f, -0.04453506f, -0.05924335f, 
    0.15149973f, 0.11765793f, 0.01271392f, -0.02216407f, -0.12461615f, 0.20316024f, -0.12486612f, 0.04837646f, 
    0.13457228f, -0.12628625f, 0.02627372f, 0.26344270f, -0.10272049f, 0.13988096f, 0.24551187f, 0.11802753f, 
    -0.01815279f, 0.25620419f, 0.07350024f, 0.19865935f, 0.25857317f, 0.29124382f, -0.14532098f, 0.05687113f, 
    -0.11047044f, -0.04870610f, 0.08049826f, 0.18076354f, 0.09171429f, -0.06980509f, -0.08891611f, -0.05429997f, 
    -0.00560265f, -0.08708238f, -0.12338476f, 0.10444235f, 0.09053320f, -0.03315334f, 0.20540769f, 0.27815658f, 
    0.19150633f, 0.07519232f, -0.02384810f, -0.08107483f, -0.06060987f, 0.11893073f, -0.11558308f, -0.09759326f, 
    -0.40404779f, 0.29537091f, -0.12628120f, 0.06383207f, 0.12887941f, 0.16994536f, 0.04411492f, 0.11017717f, 
    -0.01753510f, 0.02931854f, 0.00522805f, 0.01996953f, -0.00149555f, -0.01510470f, 0.09148095f, 0.21462983f, 
    -0.16426827f, -0.06427433f, -0.28224817f, 0.01551703f, -0.06361764f, 0.11973443f, -0.17641439f, 0.03332833f, 
    0.03922635f, 0.01974168f, 0.12345355f, 0.17563801f, 0.01061864f, -0.02395258f, -0.10647503f, 0.29673681f, 
    0.12862058f, -0.03896149f, -0.23911837f, -0.38811645f, -0.60712826f, 0.16911654f, 0.12489952f, 0.03159655f, 
    -0.09116413f, -0.06220444f, 0.04566000f, 0.01092379f, 0.01279118f, 0.21641210f, 0.14981705f, -0.07343749f, 
    -0.17391522f, 0.22462508f, 0.12212262f, 0.13484837f, 0.02124404f, 0.04302292f, 0.18691330f, -0.18932557f, 
    0.05808743f, -0.00415205f, 0.11235423f, 0.08109721f, -0.07711260f, -0.12223057f, 0.04728976f, 0.09116589f, 
    -0.15623310f, 0.06428362f, -0.00314849f, -0.04210455f, 0.04641187f, -0.01308743f, -0.14188553f, 0.18087316f, 
    0.14874820f, 0.10864208f, 0.12399107f, 0.01752833f, -0.03500359f, -0.06348769f, 0.27899039f, 0.17693315f, 
    0.35847768f, 0.31713748f, -0.08109419f, 0.19925804f, 0.07455002f, 0.11864192f, 0.11966479f, 0.07977568f, 
    0.02380874f, -0.18802844f, -0.13648458f, -0.08832143f, -0.14677349f, 0.05575643f, -0.11466783f, 0.05559618f, 
    0.13445348f, 0.09039009f, -0.06758656f, 0.08473390f, -0.11380128f, -0.03490147f, 0.36268330f, -0.15086704f, 
    0.13399044f, 0.19816895f, -0.13688935f, -0.07873072f, -0.00063072f, -0.08993391f, 0.03097638f, 0.16729301f, 
    -0.19483194f, 0.09395247f, 0.17245440f, -0.00388229f, 0.15999834f, 0.21729913f, 0.20445643f, 0.17564699f, 
    0.10378192f, -0.01764843f, -0.07404483f, 0.03739400f, -0.06271318f, 0.01685095f, 0.04327006f, -0.01463498f, 
    -0.05791424f, -0.06959943f, -0.01518361f, 0.17135248f, -0.15928853f, -0.08448811f, -0.15582046f, -0.29083315f, 
    -0.16475154f, 0.34807375f, 0.02602341f, 0.05067155f, 0.08073010f, 0.03462905f, 0.02326232f, 0.36216131f, 
    -0.19674280f, 0.39835721f, 0.08669806f, 0.10715653f, 0.00785254f, 0.20244250f, 0.10889891f, 0.01358073f, 
    -0.03562506f, 0.20208022f, 0.04419555f, 0.14116578f, 0.19039713f, 0.02906116f, 0.16936512f, 0.06717427f, 
    0.16141470f, 0.15806796f, 0.06220629f, 0.01167823f, 0.11440808f, 0.18344501f, 0.03382865f, 0.20374332f, 
    0.14711739f, -0.07528862f, 0.29709747f, 0.06239311f, -0.02233632f, -0.03899457f, 0.02450431f, 0.06352801f, 
    0.19138883f, -0.26210031f, -0.00111165f, 0.32003525f, 0.22091742f, 0.19662102f, 0.21068457f, 0.12243026f, 
    0.13460413f, -0.00220487f, 0.06496055f, -0.10697985f, 0.26893258f, 0.07322013f, -0.09422742f, 0.16522072f, 
    0.03723751f, 0.04115589f, -0.09088761f, 0.17993096f, 0.06797322f, 0.02069611f, 0.00413288f, -0.15666944f, 
    -0.22917670f, 0.06250663f, -0.20910448f, -0.02949715f, -0.03063370f, -0.00857357f, 0.25972971f, -0.20062496f, 
    -0.02765718f, -0.03363331f, 0.15286249f, 0.09217007f, 0.24238634f, 0.07840923f, -0.06911439f, -0.01593560f, 
    0.05827524f, -0.18749870f, -0.01421487f, 0.01210674f, -0.15069027f, -0.05093355f, 0.23178518f, -0.00082385f, 
    -0.26116168f, 0.26517808f, -0.06989929f, -0.04913040f, -0.13218854f, -0.04513947f, -0.02599151f, -0.16430065f, 
    0.17977585f, 0.19435836f, -0.13513365f, -0.02185924f, -0.03854872f, 0.15592325f, -0.00229046f, 0.05168435f, 
    0.15141973f, 0.07968155f, -0.06568509f, 0.02262497f, -0.18138622f, -0.13085443f, 0.04515716f, -0.06644961f, 
    0.09853102f, -0.13507523f, -0.14557773f, 0.07819911f, 0.40398109f, -0.14507346f, -0.05333990f, 0.13863002f, 
    -0.07456250f, -0.06170586f, -0.01599927f, 0.06755615f, -0.20355177f, 0.32763809f, -0.00860879f, 0.07748074f, 
    0.01958382f, -0.05070147f, 0.09003004f, 0.22578599f, 0.10816395f, 0.00680182f, 0.05965365f, -0.05908912f, 
    0.03397670f, -0.04450222f, -0.12638161f, 0.09521434f, -0.31049779f, 0.07859462f, 0.19696978f, 0.10052101f, 
    -0.01710279f, -0.02974963f, -0.05581589f, -0.07756817f, -0.06255934f, 0.08834906f, -0.35883003f, 0.00848473f, 
    0.14275587f, -0.14444622f, 0.28720123f, 0.25037959f, -0.06332818f, 0.08835522f, 0.12188023f, 0.19450358f, 
    0.24697053f, -0.16504064f, -0.19898853f, -0.12980965f, -0.06597973f, -0.01212487f, -0.06556904f, 0.14415033f, 
    -0.17304097f, -0.13055745f, 0.10713866f, -0.00402900f, 0.11029888f, 0.07723100f, 0.03789894f, 0.09219691f, 
    -0.06971449f, 0.02464465f, 0.22782089f, 0.15661983f, -0.07641838f, -0.04207933f, -0.01171044f, -0.16418481f, 
    -0.06160142f, 0.08513211f, -0.16790804f, -0.29267299f, -0.22075407f, 0.03425830f, -0.01294350f, -0.07398707f, 
    -0.02365959f, 0.21179625f, -0.30919838f, -0.05220059f, -0.07375618f, -0.26689366f, -0.03088790f, 0.06540196f, 
    0.02390469f, 0.05998937f, -0.06816161f, -0.10674546f, 0.09743202f, -0.13058187f, -0.24335046f, 0.05402162f, 
    0.09782175f, 0.14648829f, -0.04331614f, 0.10349777f, 0.09150366f, 0.14628214f, 0.25310862f, 0.02290173f, 
    0.11054984f, 0.10351245f, -0.23737493f, 0.05902368f, 0.19880681f, -0.04346886f, 0.03812202f, -0.02262013f, 
    -0.04686414f, 0.03372367f, -0.12343377f, 0.00842711f, 0.08706126f, 0.02610686f, 0.05653642f, 0.08346235f, 
    0.07094278f, -0.05838434f, 0.14821012f, 0.47905156f, -0.04259017f, 0.01109797f, 0.12636471f, -0.09025010f, 
    -0.08035468f, 0.08245071f, -0.05594257f, -0.10368845f, 0.02500870f, -0.00817871f, 0.18424115f, -0.03851316f, 
    -0.11337054f, 0.03768680f, 0.10469305f, -0.03974244f, -0.02851888f, -0.45184797f, 0.37355605f, 0.06350239f, 
    -0.15958309f, -0.07687351f, 0.07017297f, -0.05594090f, 0.01730508f, -0.20760696f, -0.15013653f, -0.26961204f, 
    -0.05076407f, -0.01299265f, 0.07400376f, -0.01129743f, -0.16803229f, -0.03352056f, 0.56580406f, -0.25477916f, 
    -0.76534009f, -0.01992095f, 0.21638663f, 0.14293790f, -0.06357744f, -0.03031737f, -0.03878292f, 0.24137267f, 
    0.16881023f, 0.10848750f, -0.10813570f, -0.07647162f, 0.01773554f, 0.15866086f, -0.04527206f, 0.03551199f, 
    -0.09725933f, -0.20707580f, 0.46643156f, 0.05593708f, 0.07519003f, -0.20079087f, 0.13341674f, -0.20029303f, 
    -0.05762754f, -0.70817345f, 0.04501422f, 0.06355886f, -0.03477838f, -0.03387301f, 0.07517675f, -0.08228011f, 
    0.02853549f, 0.05837272f, 0.14785449f, 0.10911428f, 0.12072292f, 0.00651297f, 0.04140863f, -0.01059157f, 
    0.03415117f, 0.17414990f, -0.01390030f, 0.09360757f, 0.21254876f, 0.19784492f, 0.05438174f, -0.09274177f, 
    -0.10074275f, 0.17418692f, 0.03825755f, -0.04251413f, -0.52258438f, -0.17308694f, -0.16375065f, -0.07231049f, 
    -0.11790736f, -0.05817023f, 0.07799292f, 0.11584053f, -0.11230379f, -0.18278268f, 0.15575400f, -0.12825410f, 
    -0.16988187f, 0.09277366f, -0.23315373f, 0.06649750f, -0.05979397f, -0.05075308f, 0.07990770f, 0.03896857f, 
    0.12583385f, -0.25436750f, -0.07373125f, -0.04769645f, 0.11647157f, 0.14513315f, 0.10587087f, -0.16752143f, 
    -0.04997004f, 0.14020224f, 0.13807584f, -0.12145061f, -0.01725458f, -0.22185740f, -0.02233889f, -0.06375974f, 
    -0.02923136f, 0.32275072f, -0.04535268f, 0.14160874f, -0.27740967f, -0.30124310f, 0.02665792f, 0.18981883f, 
    0.01401012f, 0.01996471f, 0.19208297f, -0.24546981f, -0.08780145f, -0.19773427f, 0.05154308f, 0.08576641f, 
    0.10072184f, 0.14563359f, -0.02736581f, 0.10171729f, 0.19950384f, -0.01831727f, -0.18758076f, 0.00002280f, 
    -0.11209750f, -0.11566889f, -0.04126329f, -0.14446890f, 0.03165952f, 0.11375696f, -0.07783770f, -0.10275364f, 
    -0.08821085f, 0.06114514f, 0.04516944f, 0.16347556f, 0.27107805f, -0.36792994f, -0.32110086f, -0.29350910f, 
    0.12118626f, -0.10341270f, 0.11703657f, -0.01541325f, 0.08646804f, -0.15507872f, 0.35008630f, -0.05944677f, 
    -0.02551236f, 0.08192550f, -0.12219601f, 0.03552627f, -0.16570275f, 0.41318274f, -0.09355666f, 0.11199240f, 
    -0.21382050f, -0.05052956f, -0.23023389f, 0.00714715f, 0.07598682f, 0.10552269f, -0.03787542f, 0.03404456f, 
    -0.24217278f, -0.21139541f, 0.02750007f, 0.06335514f, 0.26456627f, 0.01219196f, -0.02075425f, -0.02348384f, 
    -0.21921422f, 0.06759980f, -0.00162757f, -0.11796574f, -0.02309234f, -0.04654808f, 0.02267332f, 0.00882068f, 
    0.03504863f, -0.23928232f, 0.13615403f, 0.61704230f, 0.09585097f, 0.00306220f, -0.00251750f, 0.12666233f, 
    -0.12314544f, 0.11928400f, -0.07424225f, 0.30050004f, -0.06873482f, -0.11806041f, -0.16106792f, 0.00071960f, 
    0.13343416f, -0.05017974f, 0.12879279f, -0.10038850f, 0.09552594f, -0.13962530f, 0.13815270f, 0.07854087f, 
    0.03678462f, 0.12045018f, 0.00394675f, -0.07966546f, 0.05405895f, 0.17743957f, -0.17044261f, -0.06520721f, 
    -0.10316265f, 0.01516931f, 0.00656036f, 0.08793502f, -0.07985885f, -0.14980081f, -0.27234361f, -0.16672441f, 
    -0.11071173f, -0.09607686f, 0.05285636f, 0.24327701f, -0.05780499f, 0.00311535f, -0.07039593f, 0.09102244f, 
    0.19965248f, -0.29653987f, -0.14196266f, -0.09678414f, -0.06740015f, -0.07087429f, 0.02949383f, -0.26913875f, 
    0.25393754f, -0.21426804f, 0.16915451f, 0.10710318f, -0.05188661f, 0.00544332f, 0.04313433f, 0.02517634f, 
    0.01388599f, -0.05103474f, 0.04987143f, 0.02828680f, -0.02510986f, 0.03493465f, -0.05197386f, -0.04192058f, 
    -0.04785805f, -0.04053812f, 0.00500123f, 0.00776392f, -0.01567773f, 0.03661764f, 0.01048600f, -0.04769052f, 
    -0.02507361f, -0.04561737f, -0.01543856f, 0.02357318f, 0.02451023f, 0.01462164f, 0.01219782f, 0.04329361f, 
    -0.05248782f, 0.02071036f, -0.02775951f, 0.03068913f, 0.01470200f, 0.01820407f, -0.06361171f, -0.03443079f, 
    0.03812019f, 0.00197999f, -0.04819957f, 0.05245188f, 0.04388371f, -0.01951724f, -0.03391963f, 0.02242725f, 
    -0.04479532f, 0.01880326f, -0.07384690f, -0.05890940f, -0.01843978f, -0.05170086f, -0.06274783f, -0.03868261f, 
    -0.06579656f, 0.02049850f, -0.01160560f, -0.00086382f, -0.02209910f, 0.02292859f, -0.00596575f, 0.01731143f, 
    -0.02857979f, 0.01851784f, -0.00048108f, -0.04973254f, -0.03741430f, -0.04563145f, -0.04848365f, -0.02230350f, 
    0.07199600f, 0.02727156f, 0.03156289f, -0.03407992f, 0.05103898f, 0.01937801f, 0.00986534f, 0.03604975f, 
    0.00008954f, 0.01864831f, 0.03222122f, 0.00672282f, 0.02293379f, -0.02866194f, -0.00080164f, 0.00401572f, 
    -0.02631982f, -0.02635145f, 0.01353247f, -0.03702055f, -0.04925723f, -0.05054136f, 0.03423561f, -0.01416762f, 
    0.00278006f, 0.00911797f, 0.02457598f, -0.02615896f, 0.01822576f, -0.00531634f, -0.06515688f, 0.02077173f, 
    -0.04396473f, -0.00970129f, 0.04037023f, 0.05161504f, 0.01211260f, 0.01422457f, -0.04689956f, 0.00995441f, 
    -0.03547050f, -0.02309546f, -0.07051900f, -0.00666826f, -0.00460091f, 0.00923491f, -0.06178457f, 0.02911649f, 
    0.01744043f, 0.00333446f, 0.01213138f, -0.01332255f, -0.03408186f, 0.01010162f, -0.05200967f, 0.01114657f, 
    -0.02405926f, -0.02181001f, 0.00500286f, -0.04367191f, 0.00575598f, -0.00894809f, 0.04794282f, 0.01849163f, 
    -0.02807012f, 0.03587954f, -0.04817335f, -0.01121997f, 0.03006150f, -0.01889597f, 0.03449531f, -0.03865677f, 
    0.05266125f, -0.05541561f, -0.00622126f, -0.04749694f, -0.03396491f, -0.04605804f, 0.00741063f, 0.01718615f, 
    0.00904782f, -0.05342641f, 0.02102018f, -0.04106518f, -0.02694248f, -0.05060638f, 0.01400772f, 0.03103502f, 
    0.04496921f, 0.01560375f, 0.01479088f, -0.02703260f, -0.06569728f, 0.01771378f, 0.00702819f, 0.00661091f, 
    -0.01301507f, 0.00552902f, 0.00429588f, -0.03379806f, 0.05637426f, -0.02531390f, 0.00006907f, -0.00062663f, 
    -0.02021869f, -0.06288961f, -0.00167767f, 0.03786363f, -0.04028132f, 0.01431055f, -0.06706651f, 0.03823953f, 
    0.04723993f, 0.00172568f, -0.00424218f, 0.03552701f, -0.02145799f, 0.01656913f, -0.01795212f, -0.01556238f, 
    0.01563692f, -0.00608972f, -0.05929265f, 0.00621569f, -0.05385331f, 0.00638390f, 0.01974576f, -0.05210593f, 
    -0.01622336f, 0.02902480f, 0.00865678f, 0.03800305f, 0.01203790f, -0.04814776f, -0.00008302f, -0.04396941f, 
    -0.00128421f, -0.01710079f, -0.00234753f, -0.04466688f, -0.01977642f, -0.03040767f, -0.05651943f, -0.03964239f, 
    0.00026844f, -0.02806961f, -0.01967294f, -0.02660608f, 0.04123716f, -0.02503701f, 0.01623060f, 0.03122355f, 
    0.04034634f, -0.04393500f, 0.01738817f, -0.01902966f, 0.00860751f, -0.01047978f, 0.02873998f, -0.05338039f, 
    0.03666286f, -0.06076256f, 0.06129447f, -0.04802951f, -0.05827361f, -0.03777409f, -0.05713471f, -0.03368131f, 
    0.02535609f, 0.00513014f, 0.00691775f, -0.05857267f, 0.03248920f, 0.02001700f, 0.01885055f, -0.04816390f, 
    -0.06322448f, 0.05063927f, -0.00593658f, 0.00973667f, -0.05491992f, 0.02317633f, -0.01447328f, 0.03835474f, 
    -0.02392557f, 0.01361816f, -0.01348939f, -0.00519411f, -0.02144888f, 0.01183951f, 0.04837554f, -0.03846983f, 
    0.00373567f, 0.02697801f, -0.01248559f, -0.01869480f, -0.04068091f, 0.02177678f, -0.03342608f, -0.05295058f, 
    0.02107227f, 0.05459043f, -0.02489576f, -0.00931280f, 0.00428787f, 0.00011445f, 0.07548411f, 0.06141700f, 
    -0.00375664f, 0.03747317f, -0.01018304f, 0.01252899f, -0.01671001f, -0.05190971f, -0.05717629f, 0.00087998f, 
    0.04753280f, -0.06488660f, -0.04320169f, -0.00455406f, -0.04552152f, 0.01675879f, 0.02551842f, -0.02625022f, 
    0.28861836f, 0.00812301f, 0.05726119f, 0.03485364f, -0.06097029f, 0.08882521f, 0.09307522f, -0.12929356f, 
    -0.10024326f, -0.25221029f, -0.25525764f, 0.14554867f, -0.03798009f, -0.01473531f, -0.01780781f, -0.06266692f, 
    0.04981691f, -0.09418713f, -0.09036512f, -0.03037597f, 0.21526174f, 0.12504981f, 0.04136254f, -0.06277621f, 
    0.06183428f, -0.01468768f, 0.01104072f, -0.00547205f, 0.18888074f, 0.41855460f, -0.00840860f, -0.29727325f, 
    0.00209196f, -0.07277113f, 0.23600011f, -0.05183433f, 0.02716191f, 0.23787473f, 0.15589271f, 0.00541184f, 
    0.01875580f, -0.14813758f, -0.05021167f, 0.11242592f, -0.11891413f, 0.14625593f, -0.16752386f, 0.02994602f, 
    -0.02946684f, 0.19336298f, 0.10271531f, 0.05371667f, 0.05700294f, -0.25986212f, -0.16114299f, -0.11065353f, 
    0.10274772f, 0.12976508f, 0.01661327f, 0.23890407f, 0.03016492f, 0.04157075f, -0.04992112f, 0.27575159f, 
    0.12493495f, 0.11753744f, 0.00872123f, -0.11773413f, 0.03229770f, 0.16614819f, -0.05105295f, 0.04729559f, 
    -0.89257383f, 0.48000777f, -0.17866869f, -0.06619661f, 0.05420372f, -0.01420198f, 0.01533614f, 0.00255771f, 
    0.08507790f, -0.31407472f, 0.08699947f, 0.47876370f, 0.04903261f, -0.04388581f, -0.37613052f, 0.03729215f, 
    0.02928485f, -0.00231896f, -0.17869537f, -0.16236937f, 0.16129328f, -0.06274050f, -0.11136836f, 0.04430193f, 
    -0.04270180f, -0.02297777f, 0.11900641f, 0.07161175f, 0.40088663f, 0.15409558f, -0.07835494f, -0.13697338f, 
    -0.14229655f, 0.09245683f, -0.02218346f, 0.06048587f, -0.51889390f, -0.45498925f, 0.37791339f, -0.04963091f, 
    0.12802668f, -0.24360828f, -0.07244942f, -0.16044198f, 0.01993252f, -0.63906097f, -0.37381107f, 0.45664316f, 
    -0.21237037f, -0.13988328f, 0.00555864f, 0.10064367f, -0.07708885f, -0.26984891f, 0.04077217f, -0.14059409f, 
    -0.25401148f, 0.00545930f, -0.08303782f, 0.02231919f, -0.04286306f, -0.06497008f, -0.01497077f, 0.22813106f, 
    0.03273730f, 0.36448511f, -0.12285580f, -0.04214994f, -0.27923957f, 0.11328800f, 0.12426665f, 0.07317458f, 
    0.06285761f, 0.19259940f, -0.14134224f, 0.00703274f, -0.03200237f, -0.18803979f, 0.09970638f, 0.04200061f, 
    -0.16206560f, -0.19697005f, -0.26502258f, -0.06604990f, 0.07108488f, 0.11409715f, 0.19056225f, 0.04596009f, 
    0.03734259f, -0.02886982f, -0.16981000f, 0.42636794f, -0.44350681f, -0.06769764f, -0.22076160f, -0.37160006f, 
    -0.01420077f, -0.09750853f, -0.09158102f, 0.18116355f, 0.12418462f, 0.12564313f, -0.08723798f, -0.08523880f, 
    -0.05581692f, 0.02872328f, 0.14171226f, 0.03230859f, -0.35500658f, -0.24130353f, -0.14485833f, 0.12091926f, 
    -0.18074287f, 0.33553386f, -0.02047871f, -0.31650651f, 0.11390036f, 0.01553745f, -0.17471619f, 0.20195666f, 
    0.09322505f, -0.02492918f, -0.10211889f, 0.18122089f, -0.22879232f, 0.12634984f, -0.06173842f, -0.25500777f, 
    0.19376539f, 0.03001599f, -0.05186985f, 0.03410878f, -0.09495398f, 0.12597845f, 0.03472522f, -0.02842308f, 
    -0.27207553f, -0.25327125f, 0.06899148f, 0.02602172f, 0.10536639f, -0.02922916f, -0.02825865f, 0.11412979f, 
    0.25099969f, 0.21348044f, -0.08190262f, -0.14318891f, -0.00270464f, -0.08582962f, 0.13351898f, 0.19527359f, 
    -0.03488608f, -0.28851858f, -0.07745391f, 0.38511714f, -0.06843816f, -0.00214795f, -0.22763805f, 0.04616306f, 
    0.06829080f, 0.06268702f, 0.00776561f, 0.01717207f, -0.16438642f, 0.06243469f, -0.01984094f, 0.08478598f, 
    0.11690982f, -0.04335789f, 0.18070605f, 0.18037331f, 0.00602807f, 0.04574896f, 0.07320502f, -0.00891177f, 
    0.06609893f, 0.01120531f, -0.06807207f, 0.02082341f, -0.25725114f, -0.04513894f, 0.18608096f, 0.02214630f, 
    0.17031382f, -0.02893336f, -0.00002732f, 0.12019908f, 0.00925106f, -0.25713795f, -0.07615435f, 0.15418723f, 
    -0.07685114f, 0.15381981f, -0.16841951f, 0.05212809f, 0.02147714f, 0.09503002f, 0.06289791f, 0.15129110f, 
    0.31977874f, -0.18940985f, -0.20115821f, -0.15943629f, 0.10809510f, 0.11926495f, -0.03802473f, -0.07692352f, 
    -0.21216281f, 0.03838638f, 0.03370028f, -0.08397703f, 0.22608569f, 0.10203573f, -0.12107967f, 0.05580727f, 
    -0.03657947f, -0.03680149f, -0.09234575f, 0.00124928f, -0.00554709f, 0.09923352f, -0.05124038f, -0.10169423f, 
    0.07584304f, 0.17359523f, 0.24281560f, 0.07067370f, 0.10802069f, 0.18173529f, 0.02375174f, 0.18830647f, 
    -0.19090180f, 0.10912498f, -0.16286683f, -0.17259111f, -0.09256995f, -0.09949268f, -0.00140517f, -0.03698797f, 
    -0.11171649f, -0.11866604f, -0.20504369f, -0.04751340f, 0.15247986f, 0.14999181f, 0.04020516f, -0.00759937f, 
    -0.05450920f, -0.00359589f, -0.05742967f, -0.03176472f, 0.12733118f, 0.08604329f, 0.22492616f, -0.06218563f, 
    -0.06015452f, 0.05499031f, 0.03572841f, -0.04049413f, 0.12610847f, -0.19404279f, 0.16968080f, 0.14264719f, 
    0.08416171f, 0.10764953f, 0.03697718f, 0.03058367f, -0.14637427f, -0.20067807f, 0.40161157f, 0.20162758f, 
    0.10147516f, -0.04773825f, 0.10987515f, 0.08048642f, -0.13347150f, 0.09441160f, -0.02362524f, 0.11720880f, 
    -0.15805723f, -0.04393844f, 0.03428765f, 0.07496466f, 0.00352815f, -0.33264253f, -0.24924073f, 0.07842094f, 
    -0.18930279f, 0.38847312f, 0.02281286f, -0.00617839f, 0.12344377f, -0.10153188f, 0.02901880f, 0.04972158f, 
    -0.23186849f, -0.26644954f, -0.07059038f, -0.23041970f, -0.10066982f, 0.05817334f, -0.02428223f, -0.07387218f, 
    0.05052980f, -0.03898187f, -0.00213582f, 0.07184948f, 0.13715608f, -0.13928951f, 0.15436585f, -0.02533995f, 
    0.08645067f, 0.02564449f, 0.16821183f, 0.37159339f, 0.11825730f, 0.04863222f, 0.07687982f, -0.07476647f, 
    -0.00850560f, -0.10342114f, 0.05557904f, 0.15053231f, -0.23425893f, 0.24647431f, -0.14160334f, 0.06930770f, 
    -0.09223395f, -0.02747383f, 0.02269743f, 0.21574059f, -0.02141356f, 0.36965922f, 0.37133503f, 0.22230335f, 
    0.13259108f, 0.10412346f, 0.10941667f, 0.39649996f, -0.02500428f, 0.08003077f, 0.17343868f, 0.04679983f, 
    0.12757567f, -0.03098590f, -0.05584288f, -0.09705296f, -0.03241325f, -0.10548955f, -0.26230860f, -0.08508298f, 
    -0.05417818f, 0.00679221f, 0.09344131f, -0.07412945f, -0.10125355f, 0.04121526f, 0.00286152f, -0.16806874f, 
    0.12232788f, 0.15453270f, 0.13716756f, 0.08633340f, -0.01650175f, -0.05902447f, -0.02307535f, 0.09740172f, 
    -0.17874046f, 0.19075935f, -0.11007267f, -0.09611298f, -0.05873059f, -0.09905002f, -0.07481732f, -0.16678981f, 
    0.04834017f, -0.22137161f, 0.06184673f, 0.18988612f, -0.07829051f, 0.03081166f, -0.16493222f, 0.06764887f, 
    -0.04649695f, 0.00925119f, -0.05572697f, 0.19791852f, 0.07416032f, 0.10605503f, 0.02513018f, 0.02457633f, 
    0.05707292f, 0.09286629f, -0.05372773f, -0.04738083f, 0.11745276f, 0.00123999f, 0.18342486f, -0.11821261f, 
    -0.02720362f, -0.09890407f, 0.02760099f, 0.04292923f, -0.12564553f, 0.07698051f, -0.10392638f, 0.01019867f, 
    -0.05972325f, 0.03006376f, -0.11666346f, -0.00347383f, 0.30587891f, 0.10174850f, 0.15946668f, 0.18352523f, 
    0.07180995f, 0.00640377f, 0.10990888f, -0.08232338f, 0.09386271f, -0.07657498f, -0.10499752f, -0.10564340f, 
    -0.11114504f, -0.01565336f, 0.06821299f, 0.02737452f, 0.10764153f, 0.05012417f, -0.02670779f, 0.11992353f, 
    0.33668429f, 0.18840736f, 0.08050212f, -0.10060710f, 0.06665209f, 0.06375014f, 0.02217232f, -0.12130672f, 
    0.12431890f, -0.17182948f, 0.10973560f, 0.11270281f, 0.12263115f, 0.03341267f, -0.08772622f, -0.10430297f, 
    -0.17729215f, -0.03816181f, 0.17912883f, 0.10972027f, 0.00826508f, 0.17465945f, 0.14284639f, 0.05343654f, 
    0.04641126f, 0.02599536f, -0.42130691f, 0.03715147f, -0.00607220f, -0.10988052f, 0.10751019f, -0.07847267f, 
    0.06161901f, -0.14200149f, -0.08542096f, 0.11506662f, -0.20884164f, -0.16436511f, 0.11698415f, 0.00202199f, 
    -0.09639522f, 0.07050233f, -0.21215330f, -0.17172539f, 0.06026960f, 0.18964183f, 0.13034846f, -0.10188412f, 
    0.06403861f, 0.17853370f, 0.12603864f, -0.01690026f, 0.08035292f, -0.00199584f, -0.06558893f, -0.42828077f, 
    -0.15394865f, 0.08223061f, -0.08562900f, 0.06980366f, 0.09029804f, -0.10631410f, -0.07746886f, 0.04138305f, 
    0.22455086f, 0.02524517f, 0.03532158f, 0.07401453f, -0.07098701f, -0.00405043f, -0.03587476f, -0.05046401f, 
    -0.12470831f, -0.30034989f, -0.84796798f, 0.03397774f, -0.09043352f, -0.11219201f, 0.04322157f, -0.05924560f, 
    0.18673967f, -0.12800701f, -0.02459025f, 0.14958549f, 0.18430743f, 0.02713246f, 0.01775844f, -0.13139650f, 
    0.06240098f, 0.02573717f, 0.27256614f, 0.21221717f, -0.10440118f, -0.18584794f, -0.09765191f, -0.33261546f, 
    0.16358975f, 0.05303801f, 0.04230558f, 0.04761445f, -0.04445216f, 0.19677787f, 0.21401869f, 0.09215038f, 
    -0.00181492f, -0.04278644f, -0.01982381f, 0.05060397f, 0.05082845f, 0.36880460f, 0.14449073f, 0.27263102f, 
    -0.02966124f, -0.25820440f, -0.07297394f, -0.00298356f, 0.00781051f, 0.05866439f, 0.13200471f, 0.15032537f, 
    -0.01658794f, -0.06354341f, 0.09687123f, -0.17240602f, -0.13570316f, -0.02397757f, -0.14618483f, 0.03541974f, 
    0.01423844f, 0.08283013f, -0.16955283f, -0.13329865f, -0.10140276f, 0.02083463f, -0.12629117f, -0.04755484f, 
    0.25661102f, -0.52189815f, -0.25125280f, -0.19173105f, -0.03217175f, 0.06370082f, 0.12305713f, 0.14089401f, 
    -0.04905469f, 0.05826729f, 0.81949180f, -0.12107345f, -0.19702926f, 0.28152189f, -0.00726581f, 0.01101894f, 
    -0.02491871f, -0.46515822f, 0.02058071f, -0.21919942f, -0.02901932f, 0.02612948f, 0.03822887f, -0.12731723f, 
    0.16316968f, 0.09995317f, 0.16899341f, 0.06441997f, 0.14763333f, 0.08628674f, -0.02570133f, -0.21684307f, 
    -0.20981473f, -0.08324520f, -0.14053552f, -0.54264456f, -0.14927745f, 0.12488249f, 0.24687609f, 0.14205311f, 
    0.04284583f, -0.08197545f, 0.01672347f, -0.10249039f, 0.08497370f, 0.04416983f, -0.24503207f, -0.38437298f, 
    -0.11707032f, -0.07215463f, -0.04739584f, -0.09246515f, -0.16287735f, -0.11429195f, -0.48462301f, 0.30975908f, 
    -0.02483769f, -0.16260824f, 0.05960752f, -0.15213275f, -0.00020979f, -0.05395599f, 0.14454061f, 0.15915452f, 
    0.27248704f, 0.07365738f, 0.06579756f, 0.04421604f, 0.02066692f, 0.08381023f, 0.08206029f, -0.35106617f, 
    0.05264232f, -0.10011522f, 0.39552796f, 0.16429478f, -0.03881133f, -0.02408186f, 0.15801893f, -0.00019298f, 
    -0.03217594f, 0.00609775f, 0.10652427f, 0.06823145f, 0.04902319f, 0.07006566f, 0.05757004f, 0.01761360f, 
    -0.04285135f, 0.05915296f, 0.20180203f, 0.30595168f, 0.06146690f, 0.06348037f, 0.00078883f, 0.01922034f, 
    -0.14707193f, -0.17451884f, -0.42572045f, -0.10891795f, -0.06397733f, -0.00123755f, 0.10710141f, -0.02650155f, 
    -0.07051024f, 0.17363346f, -0.07642090f, 0.04995978f, 0.02811993f, 0.19779684f, 0.10717183f, 0.15096250f, 
    0.02882662f, -0.01289079f, 0.02052393f, -0.00454443f, 0.05462266f, 0.03246978f, 0.38443175f, 0.19178054f, 
    0.19383396f, 0.03996783f, -0.13812479f, 0.04996106f, -0.12675309f, 0.41590157f, 0.15705171f, -0.10582475f, 
    -0.06720509f, 0.13627972f, -0.04534817f, -0.11488833f, -0.02403544f, 0.02430619f, 0.05215478f, 0.05297926f, 
    0.18905163f, -0.04296396f, 0.06914722f, 0.00705902f, 0.07301614f, 0.10359576f, 0.12088769f, 0.19502172f, 
    0.31575897f, -0.29920015f, -0.35951608f, -0.01313261f, -0.44002536f, 0.00766012f, -0.01076072f, -0.31121731f, 
    0.17500298f, 0.04318199f, 0.11019833f, -0.16475482f, 0.02025785f, -0.05622720f, -0.12222145f, -0.15183739f, 
    -0.07941645f, 0.34541878f, 0.14766552f, 0.00200093f, -0.30220416f, -0.22260857f, 0.28568953f, -0.01166079f, 
    0.09605490f, -0.02671378f, 0.08450627f, -0.03003856f, 0.13142017f, -0.02074911f, -0.02962584f, -0.04854590f, 
    0.02624002f, 0.14304203f, -0.01774789f, 0.18416212f, -0.04077336f, -0.30634859f, -0.24625205f, -0.13977885f, 
    -0.05542924f, -0.12503856f, 0.07960486f, -0.07481263f, 0.35870478f, 0.21810327f, -0.15581574f, -0.20799394f, 
    -0.20370360f, -0.19107111f, -0.04456446f, -0.05507799f, 0.07370920f, -0.37169296f, -0.05420328f, 0.02690858f, 
    -0.41610822f, 0.05341363f, -0.01921472f, 0.08431537f, 0.05392222f, -0.01701547f, 0.08390078f, 0.11031568f, 
    -0.25862056f, 0.25382093f, 0.03466632f, -0.01758919f, 0.07943755f, 0.14370455f, 0.02584142f, -0.06144498f, 
    -0.25646308f, -0.34610912f, 0.13837509f, -0.26502931f, 0.02491809f, 0.11195144f, 0.01937559f, -0.15556870f, 
    -0.06309363f, 0.29346484f, 0.52754408f, -0.08717135f, 0.06528401f, -0.02220314f, 0.01256321f, -0.41512734f, 
    -0.15005761f, -0.31593192f, 0.05893983f, -0.23249833f, 0.08878503f, 0.06218071f, -0.17295925f, 0.07894034f, 
    0.08210766f, -0.00502812f, 0.22930399f, 0.00154109f, 0.11902356f, -0.02449879f, -0.17534611f, 0.08570684f, 
    0.08333964f, 0.07954426f, 0.08848837f, -0.24427706f, 0.03775726f, -0.18845366f, 0.20010500f, -0.19551492f, 
    -0.30995938f, 0.04249136f, -0.02760003f, 0.25131580f, 0.19831057f, 0.18579227f, 0.24309625f, 0.08002389f, 
    0.03311935f, 0.09777305f, -0.12572508f, -0.21259241f, 0.03340219f, -0.12484122f, -0.05316219f, -0.20404936f, 
    0.14929862f, 0.07633489f, -0.03440868f, 0.18126619f, 0.07603938f, 0.06717923f, -0.03243082f, 0.27213335f, 
    0.13573933f, 0.03430745f, 0.26691473f, -0.03766027f, 0.00039437f, -0.00761807f, -0.01330156f, 0.17222172f, 
    -0.02471355f, 0.48299420f, -0.03598811f, -0.04426410f, 0.02642843f, 0.05471124f, -0.21636121f, -0.44396198f, 
    0.10840385f, 0.02963583f, -0.28387794f, 0.18753237f, -0.32559702f, -0.13035142f, 0.12257063f, 0.00480443f, 
    -0.15254109f, 0.34348819f, 0.10441576f, -0.03315492f, 0.03984392f, -0.01508695f, 0.03689788f, 0.02667014f, 
    0.09026504f, 0.09597912f, -0.19696835f, 0.07238512f, -0.11783103f, 0.11635723f, 0.12025128f, 0.07879744f, 
    0.03467854f, 0.11013054f, 0.19799529f, 0.18234584f, 0.18642272f, 0.29422086f, -0.08243724f, -0.02697274f, 
    -0.06620825f, -0.04101890f, -0.15208068f, -0.16993281f, -0.04171589f, -0.03634618f, -0.04164629f, 0.10129607f, 
    0.00912834f, 0.07000602f, 0.01953112f, -0.13788474f, 0.04502781f, -0.29782036f, 0.04163198f, 0.08927987f, 
    0.06291412f, 0.16477087f, -0.11130307f, 0.04429391f, -0.01099792f, -0.06696717f, 0.13327508f, 0.05737185f, 
    -0.06532580f, 0.09371648f, -0.15567954f, -0.05865053f, 0.15505752f, 0.10139949f, -0.07908526f, -0.19749068f, 
    -0.06722835f, 0.06975048f, 0.17722276f, -0.13844658f, -0.15156172f, 0.02913783f, 0.02233084f, 0.10065422f, 
    -0.13820167f, 0.04206401f, -0.00886405f, 0.01530421f, -0.08749471f, -0.20016462f, 0.02599328f, -0.06546992f, 
    0.13285668f, 0.10817591f, -0.08000230f, 0.08999258f, -0.00619138f, -0.15539131f, -0.11961786f, 0.00585296f, 
    0.26692173f, 0.19081013f, -0.02476685f, -0.16153231f, 0.17196445f, -0.11326224f, 0.08712003f, 0.05766661f, 
    0.01102581f, -0.03228443f, -0.24342304f, -0.00600889f, 0.00600379f, -0.04887893f, 0.11546282f, -0.23872262f, 
    -0.06948994f, -0.03962845f, -0.06153763f, 0.05867133f, 0.43759891f, -0.13357683f, -0.59085387f, 0.01348782f, 
    0.20332657f, -0.23815186f, 0.11114080f, -0.08549510f, -0.19736294f, 0.13387644f, -0.16582243f, -0.19220795f, 
    0.02441177f, 0.03922396f, 0.07634214f, 0.18825512f, -0.11043529f, -0.00134677f, -0.10419063f, 0.01290181f, 
    0.05182889f, 0.00438287f, -0.23600338f, -0.00626887f, -0.03302974f, 0.15609534f, 0.16718008f, -0.12448595f, 
    0.17013918f, 0.04161443f, -0.14652134f, 0.04120830f, 0.23377556f, 0.20519924f, -0.13083909f, -0.02811918f, 
    -0.27930236f, 0.12895158f, -0.10208577f, -0.03664611f, 0.12077041f, 0.07022187f, 0.06130755f, -0.15943891f, 
    -0.23792392f, 0.45808113f, 0.07067109f, -0.08558740f, 0.07916304f, -0.03772892f, 0.04747355f, 0.07518152f, 
    -0.09371804f, 0.11323468f, 0.13916698f, 0.06755562f, -0.12431464f, -0.18722647f, -0.18272218f, 0.00790568f, 
    0.18131244f, 0.07164717f, 0.05742617f, 0.01625289f, 0.16806096f, 0.22589682f, -0.09964018f, 0.15407267f, 
    -0.00575955f, 0.18096003f, -0.25804231f, -0.04946516f, 0.25862107f, 0.04569345f, 0.07280325f, 0.01789160f, 
    -0.11675839f, 0.07390655f, 0.09077708f, 0.11740825f, 0.11692050f, 0.05572155f, 0.12402580f, 0.15312551f, 
    -0.06150312f, -0.04618427f, 0.01506489f, 0.31675383f, -0.08294667f, -0.08280128f, -0.05573599f, -0.04074091f, 
    0.35015890f, 0.12763914f, -0.05934709f, -0.03598089f, -0.14513233f, -0.06027606f, -0.04820980f, -0.10626167f, 
    0.12014640f, 0.23815472f, -0.14123528f, 0.08827060f, -0.00705008f, 0.06789039f, -0.14298353f, 0.12189130f, 
    -0.06422422f, 0.11861344f, -0.28129700f, 0.05109997f, -0.07339421f, -0.15363000f, 0.02538722f, -0.09425618f, 
    0.00454875f, 0.09932345f, 0.02758106f, 0.08043376f, 0.10394491f, 0.03876897f, 0.00946773f, 0.16679688f, 
    0.05801304f, 0.19950368f, -0.14354455f, 0.24981408f, -0.04880297f, -0.05937805f, 0.09839146f, 0.02413444f, 
    0.08370040f, 0.06308922f, -0.09700824f, 0.06392972f, -0.00251577f, -0.06376030f, 0.15687038f, 0.08297897f, 
    0.03782818f, -0.16191591f, 0.12389185f, -0.05258971f, -0.20760353f, -0.28975618f, 0.12443307f, 0.11709662f, 
    -0.00405894f, 0.07443183f, -0.01939695f, 0.01313119f, 0.03138702f, -0.08083090f, 0.08754624f, 0.14277005f, 
    -0.13804366f, -0.08498708f, -0.03062318f, 0.01089062f, -0.05732968f, 0.09667908f, 0.29054204f, 0.20175099f, 
    -0.22145258f, -0.16176984f, -0.02059080f, 0.13884573f, -0.00943596f, 0.09753447f, -0.07682899f, 0.24586682f, 
    -0.58076954f, -0.27987748f, 0.03639681f, 0.10976630f, -0.11032725f, -0.10960899f, -0.03225604f, 0.01131377f, 
    -0.63727409f, -0.16745433f, -0.04669609f, 0.03236457f, 0.12767148f, -0.21030928f, 0.11087964f, 0.05941069f, 
    -0.03367052f, -0.60734957f, -0.21012980f, -0.45763701f, 0.07887159f, 0.02113210f, -0.01722682f, 0.00970726f, 
    -0.11932612f, -0.23123589f, 0.14656930f, 0.05957181f, -0.01688130f, -0.16327132f, 0.14733639f, -0.10151691f, 
    0.10296261f, 0.04873542f, -0.00857365f, 0.18737243f, 0.01760332f, 0.07821363f, 0.11335661f, 0.05065989f, 
    0.08424440f, -0.12883973f, -0.07093238f, 0.12833956f, -0.30343398f, 0.06674907f, -0.35802895f, 0.18590967f, 
    -0.00748328f, -0.00061309f, -0.00853550f, -0.06764243f, -0.00825687f, 0.40587056f, 0.32143468f, -0.29416150f, 
    0.06378383f, 0.22366521f, 0.12216088f, -0.05118739f, -0.03131636f, 0.15466362f, 0.17548212f, -0.02171398f, 
    0.18939975f, -0.08871280f, -0.06245866f, -0.23656288f, -0.08911572f, 0.16027555f, -0.04039609f, -0.01770184f, 
    -0.00122303f, -0.26444727f, 0.01083024f, 0.00993272f, 0.25236711f, 0.17959541f, -0.06594412f, -0.24607623f, 
    0.07947110f, 0.11320460f, -0.02530091f, -0.07402360f, -0.01452220f, -0.18658844f, 0.00092065f, 0.11863284f, 
    0.05656619f, 0.14622687f, -0.03885223f, -0.01410802f, -0.14575030f, -0.05373491f, 0.08236901f, -0.03284932f, 
    0.07930870f, -0.02759209f, 0.03155859f, 0.05099694f, -0.28232071f, 0.02447220f, -0.01904950f, -0.02870708f, 
    -0.13496679f, 0.20686468f, -0.14692186f, 0.02275956f, 0.02296072f, 0.13627574f, -0.10865511f, -0.05286940f, 
    0.00360093f, 0.03644139f, 0.14535822f, 0.11872289f, -0.29738522f, 0.14609292f, 0.04493105f, -0.11379875f, 
    0.19421642f, -0.09703564f, 0.12780844f, 0.12639804f, 0.00992713f, 0.02896999f, 0.11237676f, 0.10095530f, 
    -0.08855099f, 0.15678331f, -0.15533176f, -0.19324078f, 0.20550217f, 0.35607108f, 0.16621593f, 0.12558019f, 
    0.03199627f, -0.14059745f, -0.19305047f, -0.15383056f, 0.04402001f, 0.08649168f, -0.13469951f, -0.27365750f, 
    -0.30396089f, -0.46279487f, 0.14949660f, 0.09808051f, 0.09228382f, 0.09053934f, -0.06458921f, -0.13723321f, 
    0.21679096f, 0.04155618f, -0.07264346f, -0.18006945f, -0.07695457f, 0.14664161f, 0.06458945f, 0.06127704f, 
    -0.05032534f, -0.84737813f, -0.06251880f, 0.11688745f, 0.08863126f, -0.01904388f, 0.05360909f, -0.09408286f, 
    -0.10192413f, 0.03178777f, 0.24210078f, 0.06372903f, -0.00973291f, -0.13937409f, 0.07936759f, -0.01174245f, 
    0.06104203f, 0.00799321f, -0.03118851f, 0.09906457f, -0.12557782f, -0.23165648f, 0.19741870f, 0.01239138f, 
    -0.01400253f, -0.16611227f, 0.05312763f, -0.01211387f, -0.12098014f, 0.25799274f, 0.09363469f, -0.00733513f, 
    -0.04744178f, -0.00793693f, 0.02939114f, -0.08800882f, 0.15480313f, -0.02836310f, -0.25022927f, -0.33806464f, 
    0.10205745f, 0.04317487f, 0.13217393f, 0.18862136f, 0.10773797f, 0.09365955f, -0.04082768f, -0.22948003f, 
    -0.33791324f, -0.01280568f, 0.01334434f, 0.08648248f, 0.04068668f, -0.13832213f, -0.32420066f, -0.13784689f, 
    -0.09807719f, -0.00322056f, 0.25895530f, 0.24416500f, -0.08493086f, 0.10910095f, 0.02060328f, 0.08740280f, 
    0.03104552f, 0.18758227f, 0.09077606f, 0.01995675f, 0.08296688f, -0.06825144f, -0.11078011f, 0.05476156f, 
    -0.02645981f, -0.01754671f, -0.31763974f, 0.03177814f, 0.03169580f, -0.06634352f, -0.06644868f, -0.00703692f, 
    0.04394576f, 0.08526981f, 0.15018773f, 0.06878612f, 0.16443154f, -0.00267539f, 0.04170229f, -0.05129997f, 
    0.01838970f, -0.03847039f, 0.14963053f, 0.00739611f, -0.16206154f, -0.05592199f, -0.06300002f, -0.05058778f, 
    0.11841770f, -0.12334799f, 0.00643455f, 0.05441805f, -0.03866315f, -0.03787864f, -0.21029457f, -0.02510212f, 
    -0.11954430f, -0.05900330f, -0.01237531f, 0.11883277f, -0.00342272f, -0.37991080f, -0.01760473f, -0.24176681f, 
    -0.12495271f, -0.00875769f, 0.08529101f, 0.01213521f, 0.12227043f, -0.01265252f, 0.04631504f, -0.45322508f, 
    -0.27714619f, 0.14702857f, 0.14095081f, 0.12670888f, -0.26392299f, 0.14926191f, 0.03843240f, 0.11091007f, 
    0.23644130f, 0.20162489f, -0.02239473f, 0.15719993f, 0.02218389f, -0.05653318f, 0.06749699f, 0.03720115f, 
    -0.94438714f, -0.27529511f, 0.19997424f, -0.18000200f, -0.23974587f, 0.14299241f, -0.05510626f, -0.14722377f, 
    0.24998049f, -0.00786896f, -0.04750902f, 0.43452683f, -0.13096151f, 0.04493507f, 0.06357124f, -0.06180030f, 
    0.08618282f, 0.03253313f, 0.10171564f, -0.26745826f, 0.09837344f, -0.04978507f, -0.07998001f, 0.05455420f, 
    -0.02756492f, -0.05155373f, 0.04736944f, 0.08819011f, -0.27923721f, -0.08395807f, 0.04307582f, -0.10234002f, 
    -0.04169165f, -0.02014772f, 0.02965319f, -0.02391976f, 0.06750439f, -0.04772693f, -0.09218711f, -0.11871593f, 
    0.03509723f, 0.02832620f, 0.09768644f, -0.02921807f, -0.07094288f, -0.03913026f, 0.06137827f, 0.03079166f, 
    -0.00209222f, -0.17484142f, -0.03260522f, -0.15577079f, 0.07484265f, 0.09380847f, -0.09061824f, -0.13735577f, 
    -0.18540931f, -0.25829691f, 0.02123787f, -0.20057894f, 0.05870018f, -0.00560818f, 0.09817845f, 0.46105430f, 
    -0.04098062f, 0.11040984f, -0.21201293f, -0.00657209f, -0.08161649f, -0.15909414f, 0.17759013f, 0.05991356f, 
    0.01272978f, -0.16529092f, 0.25125796f, -0.07638048f, 0.04569692f, -0.06117567f, -0.05648071f, -0.03668154f, 
    0.04752507f, 0.12646675f, -0.72583139f, 0.17036353f, -0.19041696f, 0.11410821f, 0.03875872f, 0.02212198f, 
    0.11966106f, -0.02604159f, -0.25893599f, 0.03389002f, 0.31394589f, -0.19340308f, 0.06534030f, -0.08578943f, 
    0.12887894f, 0.10725664f, -0.05799018f, -0.08325780f, -0.36633763f, -0.04674755f, 0.03453271f, 0.08617084f, 
    -0.04403669f, 0.02950711f, -0.02432736f, -0.02501039f, -0.33558115f, -0.47339991f, 0.11172927f, -0.03342536f, 
    0.04586880f, 0.20331411f, -0.10452123f, -0.15270220f, 0.20624478f, -0.11852379f, 0.06438667f, 0.50995564f, 
    0.01292916f, -0.00940481f, 0.01091337f, 0.02582509f, 0.13022751f, -0.14017823f, 0.17265907f, 0.06917449f, 
    0.03097893f, -0.13626082f, 0.05820958f, -0.27245876f, -0.07854158f, -0.05241457f, 0.17441139f, 0.09058169f, 
    -0.07307523f, 0.04972499f, 0.03523589f, 0.06707198f, -0.05766311f, 0.07702414f, 0.01757500f, -0.07411610f, 
    -0.08945111f, -0.06605676f, -0.18542655f, 0.04084979f, -0.06310574f, 0.07718015f, 0.17791322f, 0.15645193f, 
    0.03977037f, -0.39543685f, 0.10581600f, -0.08072860f, -0.25588968f, -0.07222868f, -0.04223850f, 0.03497578f, 
    0.02205658f, -0.07386926f, 0.04913323f, -0.20606974f, 0.08220153f, -0.00217707f, 0.05903869f, 0.01031158f, 
    0.01373137f, -0.04643222f, 0.01132839f, 0.06499600f, 0.18788925f, -0.00406578f, 0.10358566f, 0.10652425f, 
    0.04239171f, 0.00364883f, -0.06955124f, -0.18305950f, 0.14573529f, 0.01215752f, 0.26826096f, 0.03740822f, 
    -0.00646807f, 0.09878979f, -0.03047882f, -0.03589238f, 0.22926132f, 0.14649761f, -0.13177401f, -0.04832901f, 
    -0.01200266f, 0.08926667f, 0.07451241f, 0.05095683f, -0.05658427f, -0.04169628f, 0.02662142f, 0.02792406f, 
    0.03739942f, -0.02234404f, -0.10528184f, -0.03884357f, -0.01015688f, 0.14468659f, -0.03038272f, 0.21915238f, 
    0.04288417f, -0.11002661f, 0.08179595f, -0.01689644f, -0.09586503f, 0.02224173f, -0.13833369f, -0.08488615f, 
    -0.26154605f, -0.15557757f, -0.41899008f, 0.01734052f, -0.01121739f, -0.04995764f, -0.01967976f, -0.08845245f, 
    -0.01174989f, 0.11053016f, 0.19854830f, 0.37218171f, 0.06976892f, 0.11770174f, 0.06127170f, -0.03111854f, 
    -0.02716803f, 0.03722562f, -0.09793349f, 0.12278870f, -0.06934165f, 0.07811723f, 0.04699713f, -0.25473368f, 
    -0.14813368f, -0.04673027f, -0.12818652f, 0.17662142f, 0.04562891f, -0.01343221f, 0.03162389f, -0.02812411f, 
    -0.11144920f, -0.08181775f, 0.03221205f, 0.09887467f, 0.06209792f, -0.27859944f, -0.11178444f, -0.00326549f, 
    0.10909081f, -0.31511992f, 0.02459956f, 0.08337670f, -0.02773198f, 0.28462222f, 0.06243449f, -0.13941327f, 
    -0.08361230f, 0.07353619f, 0.22697753f, 0.09963550f, -0.08970904f, -0.05189791f, 0.40628228f, -0.12000085f, 
    -0.18340556f, 0.17313592f, -0.15987588f, 0.06450251f, 0.13117307f, 0.09802341f, -0.17700706f, -0.26198032f, 
    -0.19779462f, -0.15794934f, -0.28821701f, -0.08294137f, -0.06575417f, 0.02157021f, 0.05244477f, 0.02127653f, 
    0.27007282f, -0.11378327f, -0.61530244f, -0.40009350f, 0.18409312f, 0.21766053f, -0.06043913f, 0.22369954f, 
    0.03331435f, -0.16026087f, -0.48779407f, 0.00101042f, -0.07437094f, 0.29856819f, -0.01351690f, 0.03571352f, 
    0.04325976f, 0.02992270f, 0.03594925f, 0.06952493f, 0.20862544f, 0.06013179f, -0.05621651f, -0.01142891f, 
    0.02635573f, 0.04924491f, 0.20993066f, 0.01294685f, -0.03970864f, 0.13772678f, 0.04830132f, 0.25095189f, 
    -0.06927659f, 0.16486140f, 0.06105439f, 0.07749239f, -0.16801174f, -0.11025099f, 0.15412439f, -0.18222366f, 
    0.00123883f, -0.08013295f, -0.04323295f, 0.21323027f, 0.02992305f, -0.11587244f, -0.07032467f, 0.43404561f, 
    -0.29215240f, -0.30268630f, 0.08212081f, 0.02840303f, -0.03229374f, -0.15214986f, 0.02947446f, 0.11566097f, 
    -0.03584712f, 0.01427195f, 0.02796117f, 0.08127272f, 0.08607095f, 0.07009745f, 0.05131434f, -0.45579895f, 
    -0.38160992f, 0.40289453f, -0.03811800f, 0.20019566f, -0.26633683f, -0.09384832f, -0.00828319f, -0.08137742f, 
    0.05012274f, -0.00066217f, 0.05490770f, 0.04694582f, 0.05014595f, -0.12132014f, -0.25412995f, 0.09963274f, 
    0.04092004f, -0.20289731f, 0.18552862f, 0.32756186f, -0.07644375f, 0.04606409f, 0.08265743f, -0.16195728f, 
    0.08941860f, -0.05300514f, -0.34474653f, -0.15504710f, 0.20475906f, 0.07151087f, -0.00713918f, 0.15394105f, 
    0.04056520f, 0.11547445f, 0.05275159f, 0.07811879f, 0.07526264f, 0.01273051f, -0.01508157f, 0.12847903f, 
    -0.11625919f, -0.12752160f, -0.01279659f, 0.09731909f, 0.11780810f, -0.01387396f, -0.39177474f, -0.07712669f, 
    -0.20858036f, 0.14599262f, 0.00198428f, 0.02643117f, 0.12392777f, -0.26027235f, -0.31271511f, 0.10335372f, 
    -0.04557658f, 0.03160511f, 0.10796412f, -0.03125376f, -0.06694435f, 0.29728705f, 0.04560198f, 0.06466764f, 
    0.00227619f, -0.09431963f, 0.03744831f, 0.05654255f, -0.04083423f, 0.27674031f, 0.20430189f, 0.06305407f, 
    -0.11230807f, 0.20920715f, 0.02396160f, 0.19067940f, -0.03168659f, 0.13172522f, 0.00043555f, 0.13854840f, 
    0.11048710f, -0.19659197f, -0.18110462f, -0.05536547f, -0.16765966f, -0.06500866f, -0.01850099f, -0.20374224f, 
    -0.03759398f, -0.25813565f, -0.25876719f, -0.03635284f, -0.08072512f, 0.15465254f, 0.03422482f, -0.05394138f, 
    0.17621121f, -0.03671042f, -0.07864344f, -0.17415856f, 0.07150311f, -0.19141558f, -0.10738703f, -0.00373888f, 
    -0.05587865f, 0.17497346f, 0.02586765f, -0.23181154f, 0.00285253f, 0.10032541f, 0.08288413f, 0.12137464f, 
    -0.08236092f, 0.06565927f, -0.05914050f, 0.14054853f, 0.00362178f, -0.07758766f, -0.31021604f, -0.14097725f, 
    -0.26221660f, -0.21546488f, -0.01852011f, -0.27255961f, -0.15578403f, 0.29446635f, 0.02558861f, -0.13605052f, 
    -0.27157280f, 0.02355685f, -0.26792052f, -0.03309769f, 0.09887712f, 0.03931742f, -0.06314818f, -0.43577600f, 
    -0.10440424f, 0.12576701f, 0.40541881f, -0.05627146f, -0.00684778f, -0.07945200f, 0.08182750f, -0.25929964f, 
    0.36092597f, 0.12197877f, 0.18327399f, 0.04807816f, 0.11062606f, 0.07473084f, -0.04364087f, 0.11245181f, 
    -0.08669096f, 0.20449300f, -0.02253544f, 0.08900471f, -0.07824615f, 0.04742951f, 0.08369230f, 0.02502540f, 
    0.12131120f, -0.23822460f, -0.35857698f, -0.35426009f, -0.03683718f, 0.00020963f, 0.02043640f, 0.08879229f, 
    0.05798412f, 0.05243219f, 0.35298210f, 0.36566308f, 0.28901589f, 0.09848593f, -0.18588001f, -0.05663558f, 
    0.11875668f, 0.03217447f, -0.09375112f, -0.23170628f, -0.11774588f, -0.11298817f, 0.00595559f, 0.07333158f, 
    -0.01876370f, -0.10631843f, -0.04796508f, -0.05887467f, 0.20993820f, 0.14571023f, -0.11810720f, 0.00667223f, 
    0.14027953f, -0.08996399f, -0.06852363f, 0.04252444f, 0.08926723f, -0.14300922f, -0.13628215f, 0.06832895f, 
    -0.00357470f, 0.03799293f, 0.07003219f, 0.18903928f, 0.08236732f, -0.02541383f, -0.06758062f, 0.11197666f, 
    -0.28875968f, -0.04756072f, 0.10876375f, 0.12373147f, -0.06428213f, 0.14861752f, -0.01304344f, 0.09081113f, 
    0.25515541f, 0.18321371f, -0.07381527f, 0.02481005f, 0.01057364f, 0.00851910f, -0.01109834f, -0.02683260f, 
    -0.41946980f, -0.18328762f, -0.16888463f, -0.07397513f, -0.01109594f, 0.13221999f, 0.02622130f, -0.05847375f, 
    -0.04665000f, -0.10700818f, -0.11937124f, 0.08723585f, -0.04757566f, 0.00217644f, -0.21285239f, 0.05572225f, 
    -0.16760142f, -0.02967969f, 0.18104081f, 0.11635284f, 0.10259102f, -0.14681101f, -0.23184451f, -0.08652134f, 
    -0.03004382f, 0.10645828f, 0.05426313f, 0.07613484f, -0.20022194f, 0.07311428f, 0.04167673f, 0.04736346f, 
    -0.02186037f, 0.06665929f, -0.04062732f, -0.08114261f, 0.14472207f, -0.04622792f, -0.23221546f, -0.35675791f, 
    -0.07400548f, -0.18329403f, 0.07265940f, -0.05072492f, 0.14279242f, -0.82154053f, -0.45541435f, -0.27494735f, 
    -0.16601722f, -0.04768138f, 0.19974536f, 0.16264904f, 0.05541246f, 0.06875504f, 0.06257843f, 0.19830814f, 
    -0.03405223f, 0.02462695f, -0.20556793f, -0.28065377f, 0.12353866f, 0.00273477f, 0.03994641f, 0.58586687f, 
    -0.09680150f, 0.06459281f, 0.01181313f, -0.10570610f, -0.26233697f, 0.04505667f, 0.00047687f, -0.13907582f, 
    0.01977092f, -0.02153329f, 0.12193279f, -0.25837016f, -0.14014430f, 0.06848728f, 0.06601744f, -0.04660425f, 
    0.07827847f, 0.24275312f, -0.15689442f, 0.04393784f, -0.08399555f, -0.06055594f, -0.07975428f, 0.04549817f, 
    0.09246632f, -0.01196729f, 0.48140967f, -0.05055072f, 0.13361955f, -0.06431010f, 0.00115521f, -0.18062249f, 
    -0.06067577f, -0.05747860f, 0.05671822f, -0.12453727f, -0.02985336f, 0.06544733f, 0.10077775f, 0.05712378f, 
    0.00478365f, 0.05717428f, 0.04668871f, 0.13045669f, -0.37674552f, -0.07205257f, -0.37074184f, 0.00141084f, 
    0.02763010f, 0.06197364f, -0.02398413f, -0.11699206f, 0.21227038f, -0.13441697f, -0.04546368f, -0.03037844f, 
    0.01135004f, -0.16763575f, -0.12801781f, 0.09387380f, 0.19005716f, 0.18468870f, 0.10156783f, 0.24128249f, 
    0.11123163f, -0.02133832f, -0.45716149f, -0.10704831f, -0.01448011f, 0.08499569f, 0.13804585f, 0.17776871f, 
    -0.06436383f, -0.09685783f, -0.10766111f, -0.00799377f, -0.06801903f, 0.07008976f, 0.05648520f, 0.05326289f, 
    -0.16627595f, -0.01656366f, -0.14028437f, -0.02732478f, 0.09841275f, 0.06087142f, 0.14208528f, -0.11563114f, 
    -0.13116264f, 0.21369433f, 0.14986505f, 0.05982615f, -0.03530939f, -0.03500995f, -0.18521494f, 0.03154714f, 
    0.04473939f, 0.06630171f, 0.07231767f, 0.17894088f, 0.21352024f, -0.26729536f, -0.12521742f, -0.10392331f, 
    0.11851040f, 0.10026850f, 0.14629750f, -0.09390325f, 0.02485457f, -0.07959373f, 0.03283460f, 0.02637964f, 
    0.09243199f, -0.00922540f, -0.02436395f, -0.00285485f, 0.28963685f, 0.24098779f, 0.02653735f, 0.00012653f, 
    -0.09015676f, -0.11917318f, 0.08388231f, 0.13955551f, -0.06390236f, 0.06680346f, -0.05356872f, -0.17228355f, 
    -0.02825708f, 0.11229464f, -0.11304670f, 0.16951026f, 0.00301570f, 0.26660040f, 0.14325063f, -0.09249688f, 
    0.32359663f, 0.08198141f, -0.05698825f, -0.09713992f, -0.04439186f, -0.02861084f, -0.01948693f, 0.05560884f, 
    -0.10842384f, 0.17319874f, 0.03854435f, 0.01733583f, 0.04836629f, -0.01675801f, -0.08143599f, 0.05833527f, 
    -0.01852414f, -0.20002030f, 0.15851587f, -0.05612879f, -0.20878075f, 0.19133411f, 0.00153269f, 0.08414569f, 
    -0.13346070f, 0.24767302f, 0.08654445f, 0.20289776f, -0.01665015f, -0.07090827f, 0.05931379f, 0.02403860f, 
    0.13926259f, 0.04758097f, -0.16504005f, 0.13879457f, -0.00663490f, -0.09871501f, -0.09511255f, -0.16477783f, 
    0.07330999f, 0.06604762f, -0.07625159f, 0.11602575f, 0.08164141f, 0.22814740f, -0.09075975f, -0.11967686f, 
    -0.13574035f, -0.11570249f, 0.20388611f, -0.15168479f, -0.04583162f, 0.09365715f, 0.16889803f, 0.07900286f, 
    -0.05802130f, -0.04647475f, 0.10096878f, -0.05056167f, 0.14440601f, 0.40529102f, -0.00465995f, -0.00467003f, 
    -0.23605675f, 0.01304126f, -0.02034979f, -0.03214407f, -0.01743477f, -0.02580499f, 0.28140485f, 0.14260396f, 
    0.08765790f, -0.01289325f, 0.05744601f, 0.22136699f, 0.04686665f, 0.07003196f, -0.00298907f, -0.21220438f, 
    -0.01807464f, -0.21011928f, -0.00283779f, -0.19129135f, 0.14068185f, 0.10389372f, 0.02789358f, -0.20981249f, 
    -0.09753214f, -0.03251165f, 0.06192648f, 0.07101106f, 0.09326988f, 0.09088417f, 0.11369343f, -0.10277472f, 
    0.12681685f, -0.15230899f, -0.15829949f, 0.20797415f, 0.06120166f, -0.01685842f, -0.21671955f, 0.19559523f, 
    0.07566379f, 0.31272769f, 0.05039622f, 0.06653814f, 0.22163574f, 0.12867363f, 0.07952137f, -0.04110969f, 
    -0.15829583f, -0.00885544f, 0.06256232f, 0.13148253f, 0.14715768f, 0.10090029f, -0.01576212f, 0.09256537f, 
    0.06480201f, 0.11217954f, -0.02934491f, 0.05509574f, -0.18950793f, 0.00577735f, 0.04796547f, -0.07384931f, 
    -0.02330874f, -0.01560735f, -0.22823320f, -0.03983759f, 0.21187997f, 0.04952505f, 0.03067632f, 0.08661027f, 
    -0.11964583f, -0.40884796f, 0.10774707f, 0.19150890f, 0.19588998f, -0.20297825f, 0.14074512f, 0.01613850f, 
    -0.07866959f, 0.07040353f, 0.07654971f, -0.04580602f, 0.05546882f, 0.08605012f, 0.13983729f, -0.10873365f, 
    -0.07279944f, 0.13798894f, 0.10443097f, -0.05606299f, -0.12830222f, -0.29193816f, -0.02154147f, 0.02367435f, 
    -0.08281604f, 0.10354695f, 0.00836336f, -0.03099360f, 0.08975832f, -0.14673690f, -0.04488130f, 0.02040219f, 
    -0.10240041f, -0.12228492f, 0.08747251f, -0.09782006f, -0.03326613f, 0.06856159f, 0.13226311f, -0.32849896f, 
    0.25692573f, 0.09606767f, -0.05413219f, -0.08913621f, 0.00528521f, 0.05750562f, -0.12613933f, 0.16175000f, 
    -0.12739751f, -0.00622597f, -0.13052461f, 0.05951374f, -0.03507731f, -0.01297405f, -0.02550886f, 0.14042085f, 
    -0.14174154f, 0.02996862f, 0.10327073f, -0.02930792f, 0.00114199f, 0.03348256f, -0.14288974f, -0.24984024f, 
    -0.19500199f, 0.07982097f, 0.06195026f, 0.13404697f, -0.01449190f, 0.06264570f, -0.11452246f, 0.09777652f, 
    -0.32770899f, 0.14303042f, -0.07235689f, 0.18046026f, 0.00958185f, 0.01091871f, 0.03939931f, -0.14007464f, 
    0.03553360f, 0.00285638f, 0.17326723f, -0.00443755f, 0.08826883f, 0.10569408f, 0.11768756f, 0.05744039f, 
    -0.08539959f, 0.22330046f, 0.05435775f, 0.12229622f, 0.09141788f, -0.22306186f, -0.11168043f, 0.06519326f, 
    0.17138201f, -0.00016845f, 0.08783357f, -0.05546969f, -0.27310476f, 0.04130436f, 0.09459320f, 0.07850401f, 
    0.08592540f, -0.31022072f, -0.11564988f, 0.13454381f, 0.04200318f, 0.03362212f, -0.02891648f, -0.01721832f, 
    -0.19094604f, 0.11569479f, -0.15491980f, -0.04834756f, 0.07512525f, -0.05971055f, 0.11442783f, -0.03343830f, 
    -0.18205860f, 0.19445975f, 0.09699723f, 0.11437715f, 0.05149511f, 0.06162665f, -0.00794564f, 0.06993453f, 
    -0.10898042f, -0.01788252f, 0.07117260f, -0.07950646f, -0.16393967f, 0.00546983f, 0.02085795f, -0.06904338f, 
    -0.14187297f, -0.29177615f, 0.03025103f, 0.05193119f, -0.13372689f, -0.21603441f, -0.11370666f, 0.08637100f, 
    -0.15140717f, -0.06601742f, -0.11771382f, -0.02452249f, -0.14231360f, 0.11206081f, -0.04453819f, -0.16576147f, 
    -0.01028942f, 0.12058695f, -0.05781695f, -0.00655212f, -0.13369019f, 0.13095869f, -0.00613328f, 0.00697739f, 
    0.03080946f, 0.20839730f, -0.07934313f, -0.04129948f, 0.16732839f, -0.04771528f, 0.09738676f, 0.12165236f, 
    0.02523866f, -0.05251510f, 0.04026874f, -0.02698011f, -0.05498260f, 0.02031418f, -0.00198563f, 0.04031198f, 
    0.05744955f, 0.00878675f, -0.06265337f, -0.02866069f, -0.04959716f, 0.04400123f, 0.00865059f, -0.00054554f, 
    0.01978948f, 0.04278940f, -0.03833169f, -0.03756256f, 0.05206846f, -0.02139243f, -0.04444018f, 0.03836995f, 
    0.04794317f, -0.03822894f, 0.04959833f, 0.00418236f, -0.06109782f, -0.05255191f, -0.02544924f, 0.03950145f, 
    -0.06251206f, -0.05535591f, 0.02211821f, -0.00606647f, -0.03130052f, -0.02313088f, -0.05879603f, -0.02653697f, 
    0.05126821f, -0.01682560f, 0.05338039f, -0.02219578f, 0.04404809f, -0.02837803f, -0.06371158f, 0.03697130f, 
    -0.01591130f, 0.04816310f, 0.00752148f, 0.02195407f, -0.03671204f, 0.04996920f, -0.01620122f, -0.04025917f, 
    -0.03936057f, 0.01964922f, -0.03435811f, -0.05158415f, 0.03063144f, -0.00763428f, -0.05011162f, -0.03614825f, 
    -0.04946417f, -0.01485376f, -0.04303768f, -0.06399123f, 0.01769108f, 0.02131341f, 0.03565895f, -0.03138087f, 
    0.00474632f, -0.03313541f, 0.00708711f, 0.05461369f, -0.02131826f, -0.01789648f, -0.00052969f, -0.03416601f, 
    0.02319536f, 0.02001929f, 0.02642999f, -0.00355599f, -0.00732432f, -0.04172453f, 0.00806543f, 0.00538952f, 
    0.03494126f, 0.04696492f, 0.02643700f, -0.01030590f, -0.03254708f, -0.03335434f, 0.03626310f, -0.05797463f, 
    0.04817263f, 0.03870871f, 0.02634723f, 0.00796736f, -0.01309131f, -0.04477402f, 0.01071278f, 0.04167798f, 
    -0.05172530f, -0.02250655f, -0.04161926f, 0.02348427f, -0.03254027f, -0.04871040f, -0.01343405f, -0.05182696f, 
    0.01048941f, -0.04199410f, -0.02236543f, 0.01654118f, -0.05344258f, 0.02991563f, 0.04401254f, 0.00944470f, 
    0.03926635f, 0.03944677f, -0.04627360f, -0.00293021f, -0.03288865f, -0.03543994f, -0.02359901f, -0.04053248f, 
    -0.05878923f, 0.01802929f, 0.02577343f, -0.03382768f, 0.01947159f, 0.01504696f, -0.00633072f, -0.04904254f, 
    0.03981157f, -0.05470011f, 0.02539842f, -0.06019406f, -0.04493345f, 0.00480986f, 0.00046117f, 0.01451833f, 
    -0.01452456f, -0.01895195f, -0.06233274f, -0.06074330f, -0.04974426f, 0.04957604f, -0.02003038f, 0.01526773f, 
    0.00789314f, 0.00998605f, -0.03130313f, 0.02753097f, -0.03120871f, -0.04356297f, -0.02037702f, -0.03043413f, 
    0.01238471f, 0.01758954f, 0.01421977f, 0.02537457f, 0.00790714f, -0.03006488f, -0.04696343f, -0.03256048f, 
    0.05118309f, 0.04299117f, -0.05176359f, -0.00693422f, -0.06169394f, -0.02017723f, -0.04510785f, 0.04790126f, 
    -0.02358637f, -0.00375833f, 0.00105557f, -0.02996186f, 0.02739917f, -0.05422568f, 0.03671397f, 0.01110166f, 
    0.03091688f, -0.02783332f, -0.04689132f, -0.00811356f, -0.02876635f, 0.03621756f, 0.02947950f, -0.04927754f, 
    -0.03611305f, 0.01986550f, -0.00290468f, -0.02277776f, -0.00982438f, 0.02974434f, -0.02124683f, 0.03261620f, 
    0.03715611f, -0.05197059f, 0.01686203f, -0.02019405f, -0.04161580f, 0.00274744f, -0.04209368f, 0.01141432f, 
    0.04590726f, -0.01429773f, -0.05848773f, -0.04411374f, -0.00333592f, -0.01546763f, -0.00628315f, -0.03644006f, 
    -0.05830961f, -0.01370362f, -0.03953220f, 0.05010441f, -0.00370198f, -0.04927737f, -0.04926457f, -0.04692445f, 
    -0.04379752f, -0.03502514f, -0.06706077f, 0.03079830f, -0.04059691f, 0.05220895f, 0.00858122f, 0.03374591f, 
    -0.00454724f, 0.02619128f, 0.04640218f, -0.01707775f, 0.03565800f, 0.05434569f, 0.03972847f, 0.05097451f, 
    -0.01931989f, 0.03655646f, -0.04325468f, -0.00175103f, -0.00051989f, -0.00197114f, -0.03773081f, -0.00302876f, 
    0.05175781f, -0.01710449f, -0.03448458f, 0.00303528f, -0.01832511f, -0.01405374f, 0.03022300f, -0.01142365f, 
    -0.05828971f, 0.00216157f, 0.04130328f, 0.03012065f, -0.00706199f, 0.04081735f, -0.00971678f, -0.03444831f, 
    -0.06312528f, 0.03470301f, -0.00705212f, -0.05260375f, 0.04223904f, -0.01580518f, 0.05247721f, -0.02023716f, 
    -0.05976624f, -0.04942675f, -0.00704984f, -0.03396107f, -0.05817797f, 0.02828237f, 0.03019378f, -0.05258143f, 
    -0.04327763f, 0.02250561f, 0.01363340f, -0.00416967f, 0.00593470f, 0.01315981f, -0.05548677f, 0.00000715f, 
    0.22427157f, -0.10405047f, -0.02241153f, 0.17115118f, 0.06445225f, 0.04932774f, -0.01615205f, 0.03409791f, 
    0.03872616f, 0.35301644f, 0.02820579f, -0.02724502f, 0.10896479f, 0.04133493f, 0.12699367f, 0.08053604f, 
    -0.11184039f, 0.05879557f, 0.03842894f, -0.02217482f, 0.10186075f, -0.10359280f, -0.14351448f, -0.03860200f, 
    -0.00256101f, 0.12544957f, 0.04985604f, -0.03508603f, -0.03875945f, -0.09739594f, -0.06212825f, -0.09826124f, 
    0.05394191f, -0.00720188f, 0.18807198f, 0.04460101f, -0.12700081f, -0.03058421f, 0.11529783f, 0.07473914f, 
    -0.09695335f, 0.02503971f, 0.03665020f, 0.20947611f, 0.03371191f, 0.20045203f, 0.01828664f, -0.13380286f, 
    0.02318896f, 0.12769233f, 0.03697738f, 0.09853165f, 0.15782607f, 0.23174916f, 0.43968710f, 0.03126162f, 
    -0.18369284f, 0.03712641f, 0.11659586f, 0.21969189f, 0.21085136f, 0.27192059f, 0.14645438f, -0.06800577f, 
    -0.08585210f, -0.09197167f, -0.06627894f, -0.02493954f, 0.14550701f, -0.07619707f, 0.14584187f, -0.12754381f, 
    0.31110606f, -0.22753999f, -0.01479411f, 0.15652694f, -0.02615364f, 0.11762317f, 0.23474659f, 0.03015450f, 
    0.06405983f, -0.28730777f, -0.11793894f, 0.36206716f, 0.05207038f, -0.07204896f, -0.02225213f, 0.03654740f, 
    0.04934676f, 0.19374363f, 0.08799746f, -0.03921879f, -0.12829767f, 0.00185659f, -0.09163420f, -0.08592841f, 
    -0.01912854f, 0.06469570f, -0.10757594f, 0.17332055f, -0.01811659f, 0.12878813f, 0.19493508f, 0.07172154f, 
    0.01598439f, 0.16289531f, 0.04484088f, 0.02105048f, -0.20064513f, 0.00317338f, 0.17148635f, -0.06908695f, 
    -0.10657535f, 0.03727870f, 0.00759681f, -0.14292677f, 0.00346852f, 0.72734284f, 0.15555723f, -0.09945723f, 
    0.06138856f, 0.03452899f, 0.17490926f, 0.19516386f, 0.08712669f, 0.16613729f, -0.03047259f, 0.01804736f, 
    -0.28476736f, -0.05486873f, 0.04559102f, -0.06434649f, 0.10015301f, 0.00826905f, 0.07975473f, 0.08063398f, 
    -0.09128326f, 0.16946147f, -0.03950770f, -0.19481504f, 0.00123981f, 0.03567712f, 0.01630799f, -0.08697923f, 
    -0.18739145f, 0.00201787f, -0.17480837f, 0.05696658f, -0.04752241f, -0.19397327f, 0.09321947f, 0.01799433f, 
    -0.07034913f, -0.16555430f, 0.24283767f, -0.16427003f, 0.09784044f, -0.08961792f, 0.03573501f, 0.16689599f, 
    0.14436330f, 0.07591320f, -0.22930235f, 0.01397040f, -0.12665313f, -0.02989878f, -0.21149038f, -0.23106337f, 
    -0.01441691f, 0.00418017f, 0.06302737f, -0.08513147f, -0.14356856f, -0.19260968f, -0.01557629f, -0.14158510f, 
    -0.39420533f, 0.06728669f, 0.11191260f, 0.02182966f, 0.08956123f, -0.13088109f, -0.38145050f, -0.22115023f, 
    -0.14676552f, 0.01972676f, -0.30710179f, 0.05892706f, -0.16231094f, 0.06134894f, 0.10919920f, -0.42612064f, 
    -0.18612732f, 0.05201848f, 0.06279990f, -0.33628994f, -0.07095742f, -0.23428036f, -0.11646052f, -0.09760986f, 
    -0.33254933f, 0.07384489f, 0.10309145f, -0.08987799f, -0.02264902f, 0.12065370f, -0.00842507f, 0.05249939f, 
    -0.01435978f, -0.03987722f, -0.00155858f, -0.06803369f, -0.06316562f, -0.21122292f, -0.03472514f, -0.13710693f, 
    0.07938621f, -0.19619869f, 0.02484045f, -0.02333472f, 0.13669305f, -0.18730526f, 0.20355733f, -0.04931825f, 
    0.18465689f, 0.03828751f, 0.08912137f, -0.10099795f, 0.11333000f, -0.08418455f, 0.08611408f, 0.02218060f, 
    0.13860519f, -0.03970786f, -0.23003198f, 0.00654715f, -0.29723272f, -0.14639129f, 0.16741464f, -0.09219980f, 
    0.18313456f, 0.41273171f, 0.01078792f, 0.21665280f, 0.10310145f, -0.04087820f, 0.01604398f, 0.13364312f, 
    0.23633164f, 0.11404888f, 0.12499332f, -0.22847275f, -0.26953220f, 0.10227676f, -0.16777653f, -0.17434803f, 
    -0.05656743f, -0.06852584f, 0.03701203f, 0.22740169f, -0.10984584f, -0.25412419f, -0.14202537f, 0.25111029f, 
    -0.12668777f, -0.09714552f, 0.00693523f, -0.01189504f, 0.01199382f, -0.31728846f, -0.18769169f, -0.11171112f, 
    0.07719323f, -0.01804190f, -0.20123562f, 0.01569419f, -0.07529421f, -0.06115237f, -0.12529059f, 0.22627367f, 
    0.01262574f, 0.00115360f, 0.03535996f, -0.09907215f, 0.03304442f, 0.02509541f, 0.15789343f, -0.00365734f, 
    0.05632251f, -0.03962454f, -0.00060523f, -0.00151834f, -0.00349517f, 0.02636459f, 0.04927587f, 0.02030187f, 
    -0.03482582f, -0.03475143f, -0.01077637f, 0.01026457f, -0.04440269f, -0.05892627f, 0.05304652f, -0.05217410f, 
    -0.05343939f, -0.06184120f, 0.05159136f, 0.01822612f, -0.02510788f, 0.00196039f, 0.02820724f, -0.06200966f, 
    -0.04362807f, 0.01487491f, -0.03302584f, -0.06130260f, 0.02660443f, -0.00156354f, 0.00661162f, -0.01184989f, 
    0.04623694f, 0.00221140f, -0.03142829f, 0.03571840f, -0.03785520f, -0.02486427f, 0.04196503f, -0.06125006f, 
    -0.04179652f, -0.00828835f, -0.00035830f, -0.04020097f, -0.01603630f, -0.01977234f, 0.03757105f, -0.05733195f, 
    0.04156741f, -0.06305787f, -0.03958475f, 0.04728376f, 0.03073467f, -0.06158340f, -0.05611363f, -0.04162513f, 
    -0.00341038f, -0.00351894f, -0.03730896f, -0.05101022f, 0.00162360f, 0.04001902f, 0.04416262f, -0.03341394f, 
    0.05311069f, -0.01392857f, 0.03367128f, -0.00203500f, -0.04231211f, 0.05625749f, 0.05666085f, -0.02922143f, 
    0.02476680f, 0.01396475f, -0.04613680f, -0.05179924f, -0.02192882f, 0.05028876f, -0.01929889f, 0.05515315f, 
    0.00345404f, -0.03246446f, -0.03230556f, 0.00411463f, -0.02732268f, -0.01447822f, -0.05567996f, 0.05515711f, 
    0.03125275f, -0.01210309f, 0.01742859f, -0.01336881f, -0.02808017f, 0.04362225f, 0.01680186f, -0.04144723f, 
    -0.00630730f, -0.00124391f, -0.04162337f, 0.01503692f, 0.00649648f, -0.01542917f, -0.04219894f, -0.02273095f, 
    0.05252779f, 0.02023944f, 0.00845382f, 0.01325976f, -0.03835487f, -0.04943451f, -0.01838060f, 0.04172818f, 
    -0.02334504f, 0.04787689f, 0.03212790f, -0.02341443f, -0.03154268f, 0.04248331f, 0.02678226f, 0.00826653f, 
    -0.03502163f, -0.03993154f, -0.00303550f, 0.03783996f, 0.00826181f, 0.02045466f, -0.01038030f, -0.05745452f, 
    -0.02091357f, 0.00978869f, -0.02361054f, -0.04404164f, -0.02048332f, -0.03855672f, -0.01852827f, -0.02903344f, 
    0.04192929f, -0.04602595f, 0.05304614f, 0.03786907f, 0.04240635f, -0.00071737f, -0.02955365f, -0.03238089f, 
    0.02473186f, 0.05097191f, -0.00036607f, 0.04766836f, -0.05745718f, 0.00332220f, 0.03827607f, 0.03358058f, 
    -0.04380522f, 0.03109654f, 0.04143677f, 0.02791067f, 0.02037022f, -0.04784917f, 0.04957600f, -0.05119368f, 
    -0.05381746f, 0.04150411f, -0.04153658f, -0.04972050f, 0.02326312f, 0.00964411f, 0.04086436f, 0.02455816f, 
    0.00679122f, -0.03216670f, -0.02774046f, -0.02920439f, 0.03920933f, 0.00749348f, -0.03063226f, -0.05561277f, 
    0.01976515f, -0.04743238f, -0.00257085f, -0.04111098f, -0.06223987f, -0.00743377f, -0.02259721f, 0.01503208f, 
    -0.02596566f, -0.03062396f, -0.03541226f, 0.03542934f, -0.02800196f, -0.01906842f, -0.02344828f, 0.02982452f, 
    0.05410700f, -0.00473320f, 0.04551006f, -0.00040366f, 0.04796864f, 0.01010405f, 0.04082775f, -0.02235263f, 
    0.00769431f, 0.04858473f, 0.01827117f, -0.03134047f, 0.01948954f, -0.00968022f, 0.03368035f, -0.03351965f, 
    0.02398590f, -0.06522077f, 0.00457712f, -0.03622746f, -0.00058984f, -0.04378910f, -0.04880561f, -0.05039902f, 
    0.03972756f, -0.03979364f, 0.03755219f, 0.04412252f, 0.04686566f, -0.04973703f, -0.00910961f, 0.02968122f, 
    -0.02265075f, 0.02002094f, -0.01713291f, 0.00042524f, 0.00557607f, 0.02320486f, -0.04677993f, -0.02344560f, 
    -0.05964293f, -0.03480623f, 0.02065037f, -0.00497773f, -0.04090880f, -0.02362386f, -0.03961132f, -0.00950227f, 
    0.01335700f, -0.03997387f, -0.04817655f, 0.04534428f, 0.00663025f, -0.02323428f, 0.04451242f, 0.01258313f, 
    -0.03225071f, 0.03055300f, -0.02749497f, -0.02936902f, -0.00130674f, -0.02804735f, -0.00368934f, 0.02417109f, 
    -0.05537101f, -0.01566061f, -0.02076145f, 0.01135692f, 0.00408696f, 0.02073605f, 0.01095029f, 0.03462793f, 
    -0.04620949f, -0.00471837f, -0.02918449f, 0.05474868f, -0.04083631f, 0.03599324f, 0.02741416f, 0.04931940f, 
    -0.03212599f, -0.04480036f, -0.05387047f, -0.05577439f, -0.02566499f, -0.02775041f, -0.05294379f, -0.00895268f, 
    0.00683979f, 0.01241492f, -0.04364846f, -0.03130476f, -0.05035407f, -0.02883458f, 0.02580700f, -0.04232566f, 
    0.14906934f, 0.14230622f, 0.20301895f, 0.01224098f, 0.11302175f, -0.08549963f, -0.10720071f, 0.04476901f, 
    -0.07085167f, -0.01589938f, 0.20472899f, -0.08383876f, -0.09504307f, -0.03907173f, 0.11182544f, -0.16690385f, 
    0.15524779f, -0.01340367f, 0.17177549f, 0.07972380f, 0.11946474f, -0.03105849f, -0.01449283f, 0.10509209f, 
    0.02789911f, -0.03938158f, -0.09232274f, 0.06733609f, -0.00639679f, -0.01333061f, 0.11055678f, 0.04274803f, 
    0.16845779f, -0.17266114f, -0.05792385f, -0.03041374f, 0.02741649f, -0.05970293f, 0.10363329f, -0.00218066f, 
    0.01066490f, 0.01084924f, -0.03352431f, 0.03786598f, -0.02648868f, -0.12267595f, -0.11198308f, -0.09874010f, 
    -0.13694671f, 0.16373603f, 0.01761924f, -0.02403204f, -0.14624959f, 0.06326078f, 0.04055858f, -0.03085446f, 
    -0.71026939f, 0.07323979f, -0.04106300f, -0.00811458f, -0.00741592f, 0.10397839f, -0.10339344f, 0.21677266f, 
    0.15523890f, 0.20815724f, 0.14447100f, 0.12310191f, 0.05788961f, -0.05667664f, -0.13862932f, -0.10580474f, 
    -0.02530938f, -0.02884541f, 0.10340974f, 0.21596245f, 0.11427637f, -0.02664017f, -0.06373637f, 0.00008913f, 
    0.12398238f, 0.02738619f, 0.05726025f, 0.13992426f, -0.01952662f, -0.10361177f, 0.21395791f, -0.04512633f, 
    -0.01528714f, -0.00642307f, 0.02361900f, -0.35194016f, -0.18312611f, 0.07658306f, -0.16580813f, -0.14919963f, 
    0.05301476f, 0.14942802f, 0.09286592f, 0.06334832f, 0.13140789f, -0.10147066f, -0.02717131f, -0.05936743f, 
    -0.05981773f, 0.05903777f, 0.07736080f, -0.00580746f, 0.00927697f, 0.06662553f, 0.01319463f, -0.01141569f, 
    0.10396215f, -0.02032714f, -0.04112643f, -0.01028564f, -0.07978962f, -0.10796115f, 0.41523391f, -0.23415178f, 
    -0.04900049f, 0.20420842f, 0.12985928f, -0.03369378f, -0.03466801f, 0.00917454f, -0.07700419f, -0.11625925f, 
    -0.22897184f, 0.03072280f, -0.02614963f, 0.08507063f, 0.03711410f, -0.03856670f, -0.00984272f, 0.40384576f, 
    0.06443971f, 0.06797650f, 0.24555497f, -0.00479290f, 0.07828818f, 0.05993645f, 0.01368696f, 0.02719957f, 
    -0.03725733f, 0.00044711f, -0.06180537f, 0.14460635f, -0.07562441f, 0.02876416f, -0.05189153f, -0.08275413f, 
    -0.05713470f, -0.06799824f, -0.20522550f, -0.45384315f, -0.20184673f, -0.01553413f, 0.28625351f, 0.01289353f, 
    0.03591512f, 0.05183715f, 0.07218772f, -0.18719047f, -0.01165552f, 0.08910499f, 0.03513391f, 0.04313838f, 
    -0.01444134f, 0.01068306f, 0.09795666f, 0.16096249f, 0.06718674f, -0.03137688f, 0.27246767f, 0.00567369f, 
    0.04207386f, -0.04770726f, -0.14406215f, 0.00659662f, -0.20255253f, 0.09220377f, -0.37425229f, -0.00885505f, 
    -0.12080596f, 0.18987124f, 0.27269730f, 0.01220963f, 0.08376309f, -0.11722250f, -0.05441007f, 0.06013445f, 
    0.21143031f, -0.14384782f, 0.04314618f, 0.07147108f, 0.14682852f, 0.01571338f, 0.01694447f, 0.10145676f, 
    -0.21968509f, 0.03401448f, -0.16612187f, -0.12965684f, 0.00018530f, 0.01030692f, -0.03020510f, 0.15137506f, 
    -0.16696106f, 0.07667905f, 0.16454956f, -0.02838072f, -0.00169851f, 0.05346845f, -0.03906086f, 0.01476059f, 
    -0.05941341f, -0.12736121f, 0.09042405f, -0.08055560f, 0.03213296f, -0.02813395f, -0.14431147f, -0.05464286f, 
    -0.16038515f, 0.13195647f, 0.03419834f, 0.09819730f, 0.08887493f, 0.03585260f, -0.07059181f, 0.01551015f, 
    0.01690460f, 0.12450177f, -0.00072772f, 0.01326150f, -0.12512209f, 0.00608756f, -0.00171098f, 0.15960167f, 
    0.04005555f, -0.08595449f, -0.07346093f, 0.13354068f, 0.12961039f, 0.09449927f, 0.04388168f, 0.12763278f, 
    0.06768329f, 0.00263096f, -0.06405646f, 0.07938380f, 0.24749021f, 0.06728619f, -0.02851389f, -0.15938766f, 
    -0.22296444f, 0.00293314f, -0.05462487f, 0.06472763f, -0.14241819f, 0.35656965f, 0.08432155f, -0.00985616f, 
    0.13249435f, 0.04019574f, 0.10328085f, 0.06995682f, -0.00692300f, -0.11096781f, 0.13139734f, -0.04320343f, 
    0.09707906f, 0.08683155f, -0.10101611f, 0.08962174f, -0.06367528f, -0.02707412f, -0.08451956f, 0.13555513f, 
    0.00209460f, -0.13702706f, -0.00861464f, 0.18272822f, -0.05452166f, 0.02855884f, -0.07257903f, -0.05518779f, 
    -0.05502197f, 0.03266307f, -0.02900579f, -0.03942601f, -0.05786498f, 0.00540944f, -0.04538095f, 0.03342260f, 
    0.04238909f, 0.03410517f, 0.02817889f, -0.05174696f, 0.01354486f, -0.03102593f, -0.05835288f, -0.04197560f, 
    -0.01609348f, -0.00478154f, 0.04928470f, 0.02456499f, -0.01965458f, 0.04476083f, -0.03912605f, 0.04884164f, 
    -0.04861306f, -0.01515421f, 0.01355541f, -0.02855401f, 0.04627091f, 0.01013102f, 0.02587407f, -0.01387479f, 
    0.02805626f, 0.00026095f, 0.01858241f, 0.01966974f, -0.04891591f, 0.01281189f, -0.06028296f, -0.04341723f, 
    -0.00363543f, 0.00431140f, -0.05421936f, 0.01251334f, 0.03319249f, -0.03797044f, 0.04569534f, -0.00473116f, 
    -0.05434591f, 0.02646064f, -0.02505838f, -0.04329174f, -0.02782178f, 0.02115892f, -0.05661686f, 0.03555399f, 
    -0.04782199f, -0.05435192f, -0.05947155f, 0.01022592f, -0.00595725f, 0.00247356f, -0.06407619f, -0.03480105f, 
    0.05722526f, -0.00272093f, 0.04291658f, 0.05232390f, -0.01416706f, -0.01644429f, -0.02318683f, 0.02247557f, 
    0.02953251f, 0.03677518f, -0.03146542f, 0.04352869f, 0.01047302f, 0.04999239f, -0.02460188f, -0.03778270f, 
    -0.01281161f, -0.05345014f, 0.02087454f, 0.00554970f, -0.06413890f, -0.03408318f, -0.03667637f, 0.00003127f, 
    0.02048454f, -0.05998683f, -0.05156920f, -0.02351750f, -0.04302259f, 0.04376341f, 0.00045336f, -0.04279836f, 
    -0.06397361f, -0.02703906f, -0.03468769f, 0.02898504f, -0.05262757f, -0.01648636f, 0.02032482f, -0.03050332f, 
    -0.01355705f, -0.03929424f, -0.00706273f, -0.05769422f, -0.05982973f, 0.01853003f, 0.01655896f, -0.05104027f, 
    -0.04798131f, -0.02686284f, -0.04519359f, -0.05979696f, -0.04768049f, -0.04301625f, -0.02011169f, 0.01542710f, 
    -0.01076517f, 0.01137774f, 0.04749281f, -0.00105056f, 0.00447741f, 0.02881881f, 0.00282671f, -0.06365073f, 
    -0.00527210f, 0.01514823f, 0.04842910f, -0.01889380f, -0.01985781f, 0.01294667f, 0.00528132f, 0.02530469f, 
    0.04258409f, -0.01999650f, 0.05079887f, -0.00989229f, -0.06082871f, -0.02264992f, 0.04053609f, -0.04392401f, 
    0.00812692f, 0.00228586f, 0.01625661f, 0.00271666f, -0.05499068f, -0.01707094f, -0.04267573f, -0.03183638f, 
    0.04348680f, 0.03938397f, -0.03578563f, 0.03288220f, -0.04654448f, -0.02167687f, -0.04700955f, -0.02988346f, 
    -0.00938543f, 0.02447880f, -0.04648429f, -0.03831140f, 0.04590670f, 0.05136229f, -0.00187458f, 0.02099729f, 
    -0.04808842f, 0.03751065f, -0.05399577f, -0.00524162f, 0.00173372f, 0.00555477f, 0.00804984f, 0.00294671f, 
    -0.00733350f, -0.04286402f, -0.00809898f, -0.00649021f, -0.05815940f, -0.03211308f, -0.05267439f, 0.00478098f, 
    -0.04699202f, -0.02555289f, -0.03778754f, 0.03047369f, 0.03438682f, 0.00100030f, -0.05582954f, -0.01284309f, 
    0.00404495f, 0.01023609f, -0.04413858f, 0.01971453f, -0.02544454f, 0.00974217f, 0.00575072f, -0.06026140f, 
    0.00772669f, -0.03617103f, 0.03223125f, 0.01606875f, -0.00227805f, 0.01229780f, -0.02181735f, 0.04938929f, 
    -0.00053926f, -0.01652060f, -0.04780200f, 0.02423977f, -0.04044437f, 0.01631496f, -0.00022307f, -0.01633833f, 
    0.01019145f, 0.02552543f, -0.00611306f, -0.06154465f, -0.01244539f, -0.04849586f, 0.03072578f, 0.02805847f, 
    -0.00070820f, -0.01758423f, 0.03549255f, 0.05062714f, -0.00228490f, -0.02537006f, -0.02533964f, -0.03639670f, 
    -0.01491807f, -0.04108479f, -0.00666043f, 0.00446788f, -0.04515933f, 0.00480613f, 0.02540517f, 0.02913779f, 
    0.05022167f, -0.00368712f, -0.06491767f, -0.05306825f, -0.03578718f, 0.01857174f, 0.00434248f, -0.01432640f, 
    0.02003116f, 0.01471477f, -0.05778497f, 0.03418493f, 0.01437307f, -0.04276463f, -0.00513831f, -0.01647525f, 
    -0.01757352f, 0.00976738f, -0.03916514f, 0.01427113f, 0.02269922f, -0.03896906f, -0.00151378f, -0.06394976f, 
    -0.02893349f, -0.05865954f, -0.05839125f, -0.05541775f, 0.02618363f, 0.00009327f, 0.04243537f, 0.03289239f, 
    -0.00980255f, -0.00245042f, 0.01691971f, 0.04414277f, 0.03026577f, -0.00906943f, -0.02437860f, 0.05237028f, 
    -0.06479269f, -0.05170709f, 0.05820980f, -0.00670274f, -0.04602631f, -0.02839159f, 0.02279981f, -0.00070671f, 
    -0.04943989f, -0.00546491f, -0.06877751f, -0.04956024f, -0.05991957f, -0.06333674f, -0.06154086f, 0.00234426f, 
    -0.05274811f, -0.06337339f, -0.05290531f, 0.02211015f, -0.07414738f, -0.00075025f, -0.01393305f, -0.09245399f, 
    -0.03767372f, -0.07782122f, -0.01083343f, -0.00654576f, -0.00755239f, -0.00145207f, 0.00949922f, 0.00805342f, 
    -0.02945729f, -0.08497678f, 0.00575069f, -0.05466688f, -0.06219440f, 0.00473053f, -0.03373466f, -0.00028795f, 
    0.02084487f, 0.00260643f, 0.01969307f, -0.08017930f, -0.09342019f, -0.05384316f, -0.08944061f, 0.00919589f, 
    0.01141437f, -0.02907113f, -0.03153969f, -0.00837844f, -0.04199754f, -0.02470273f, 0.00020007f, -0.06318939f, 
    -0.04723494f, -0.04156664f, -0.09435356f, -0.06735362f, -0.07678715f, -0.05888593f, -0.04552709f, -0.05045749f, 
    0.01898974f, -0.02333527f, -0.07550776f, -0.08004993f, -0.08809331f, 0.02035692f, 0.02104467f, -0.01311280f, 
    -0.05951014f, 0.01643461f, 0.01341815f, -0.08677312f, -0.01445556f, 0.00292000f, -0.01347182f, -0.04320602f, 
    -0.02868423f, -0.03141772f, -0.09224515f, -0.03314545f, 0.00815585f, -0.00826027f, -0.01211620f, -0.03281000f, 
    -0.09282134f, -0.03195681f, -0.09037951f, -0.00802450f, 0.01866324f, -0.00938800f, -0.08861323f, -0.04296888f, 
    -0.01099342f, 0.01432589f, -0.06653351f, -0.08853675f, -0.05167170f, -0.03086308f, -0.04125706f, -0.00921780f, 
    -0.07177974f, -0.09285957f, 0.01728513f, -0.08894406f, -0.04199702f, -0.06961713f, 0.02129295f, -0.01875303f, 
    -0.06785373f, -0.08063515f, 0.01778419f, -0.08197039f, -0.01705294f, -0.04801967f, -0.08925621f, -0.08499772f, 
    -0.05213624f, 0.00812914f, -0.09265994f, -0.03237566f, 0.00279156f, -0.07529061f, -0.02404274f, 0.01270434f, 
    -0.03390703f, -0.06948770f, 0.01683339f, -0.03867519f, 0.02252478f, -0.01683810f, -0.02376490f, -0.05004116f, 
    -0.07102992f, -0.06024820f, -0.04342787f, -0.04330024f, -0.08857620f, 0.01026193f, -0.00276156f, -0.02015731f, 
    -0.08777846f, -0.03342357f, -0.00447205f, -0.07071891f, -0.06371817f, -0.01694999f, -0.07320254f, -0.03312450f, 
    -0.04835359f, 0.02260455f, -0.01669602f, -0.04107311f, -0.03005327f, 0.00688054f, -0.06497022f, -0.07366411f, 
    0.01457197f, -0.00829788f, -0.08561951f, -0.08969311f, -0.00722637f, -0.00272551f, -0.03465432f, 0.01871928f, 
    -0.04277384f, -0.01921319f, -0.09272848f, -0.03840084f, -0.01731024f, -0.00293270f, -0.05907928f, -0.09613698f, 
    -0.07493268f, -0.06678680f, 0.00689136f, 0.01251472f, 0.02930257f, -0.05675484f, -0.05396896f, -0.04625345f, 
    -0.01300963f, -0.08788604f, -0.04811649f, 0.00911089f, -0.06715609f, -0.08504623f, -0.02532308f, -0.02679924f, 
    0.01747714f, 0.01092568f, -0.08391954f, -0.00092725f, -0.00111335f, -0.09141983f, 0.02035728f, -0.06256896f, 
    0.00938066f, 0.00455907f, 0.01565332f, -0.07763036f, -0.00564207f, 0.00028774f, -0.01762969f, -0.05929336f, 
    -0.05931670f, -0.05272398f, -0.02430541f, 0.01737580f, -0.01081745f, -0.08205284f, -0.03023746f, -0.03609558f, 
    0.00881798f, 0.01137608f, -0.02999929f, 0.01369739f, -0.08999810f, -0.07916755f, -0.02619609f, -0.04168557f, 
    0.01430901f, -0.04008426f, -0.03002125f, -0.03417547f, -0.07018637f, -0.08015661f, -0.02370063f, 0.01679845f, 
    -0.00066205f, 0.01739700f, -0.03399849f, -0.09304009f, -0.03574805f, -0.07470948f, -0.03087182f, -0.04912385f, 
    -0.04897742f, -0.04274837f, 0.03417762f, -0.08308019f, -0.04912632f, -0.05181433f, -0.08212347f, 0.02297960f, 
    -0.08211876f, -0.08392378f, -0.06839402f, 0.01717459f, -0.03630595f, -0.08619604f, -0.00978998f, -0.01237476f, 
    -0.02832531f, -0.03932243f, -0.00828955f, -0.01770659f, -0.05879040f, -0.01928065f, 0.02328806f, -0.08876576f, 
    -0.00206638f, -0.02193225f, -0.02042032f, 0.00348557f, -0.02106433f, -0.04555321f, -0.08107080f, -0.07235664f, 
    -0.09181920f, 0.00702600f, -0.03009868f, -0.04564767f, 0.02397287f, -0.03600292f, -0.07089081f, -0.08587559f, 
    0.04327273f, 0.02109758f, -0.05653451f, -0.08989390f, -0.06822392f, -0.05078969f, 0.01024243f, -0.03822044f, 
    0.00397995f, -0.04189166f, -0.05862805f, -0.00904919f, -0.03753702f, -0.02603137f, -0.07398491f, 0.04222099f, 
    -0.15007187f, -0.08381109f, -0.02420912f, -0.16474125f, -0.03632101f, -0.00838551f, -0.02720815f, -0.01880971f, 
    -0.17594327f, -0.08095010f, -0.03573693f, -0.04597856f, -0.10786052f, 0.19800738f, -0.04118518f, 0.11672863f, 
    0.11963447f, 0.21027733f, 0.22512496f, 0.03785186f, 0.13678925f, 0.13670105f, -0.01847664f, 0.06404207f, 
    0.11416439f, 0.01649351f, -0.01901770f, -0.35265037f, -0.32900110f, 0.07561493f, 0.07671145f, 0.04927110f, 
    -0.05968371f, 0.12280049f, 0.01014884f, 0.12283977f, -0.12170056f, 0.03780510f, 0.27085277f, -0.13546222f, 
    -0.04218803f, -0.05180841f, -0.01597595f, -0.14692713f, 0.18521215f, -0.20058165f, -0.08812902f, -0.12578671f, 
    -0.06543073f, 0.15284736f, 0.00025583f, 0.10067581f, 0.09879014f, 0.16135976f, -0.22705862f, -0.19368593f, 
    0.05410017f, 0.03251532f, -0.01856710f, -0.02485921f, -0.13956180f, 0.08628287f, 0.02751014f, -0.14831135f, 
    -0.05967757f, 0.08230755f, 0.09671962f, 0.09847271f, 0.06207281f, -0.02034492f, -0.03696035f, -0.08586079f, 
    -0.27289763f, -0.02436665f, -0.19110180f, 0.16059956f, 0.11591199f, -0.37419471f, 0.18750207f, 0.07840277f, 
    -0.23240216f, 0.28915656f, 0.05165177f, 0.05810311f, -0.19178160f, 0.04020412f, -0.10651123f, -0.08442803f, 
    0.08692600f, 0.00078888f, 0.03953067f, -0.05246402f, 0.08583388f, 0.07161076f, -0.02285259f, 0.09715981f, 
    0.04350113f, 0.09536381f, 0.12068616f, -0.18349306f, -0.17726474f, 0.12827444f, -0.00170762f, 0.10404425f, 
    -0.06880248f, -0.00277247f, 0.04154636f, 0.03962150f, 0.11404119f, 0.41433492f, 0.04923149f, -0.16080868f, 
    -0.09480648f, 0.03869731f, -0.00693725f, 0.09971274f, -0.09786633f, -0.05811951f, 0.17465305f, -0.07084773f, 
    -0.15770110f, 0.16162528f, -0.05209825f, -0.05657041f, -0.00298540f, 0.14066520f, -0.07512865f, -0.14731802f, 
    -0.17544298f, 0.05662322f, -0.04630741f, -0.02611897f, 0.16320468f, 0.03224013f, -0.01728284f, 0.33031070f, 
    -0.00584221f, 0.17864765f, -0.12732901f, 0.05597292f, 0.05449952f, -0.00388833f, 0.12545758f, -0.11921374f, 
    -0.22629045f, -0.35185486f, -0.02595848f, 0.03210364f, 0.02884244f, 0.01146059f, -0.03210544f, -0.09559043f, 
    0.06317169f, 0.00199647f, -0.20386666f, -0.04595996f, -0.00879894f, 0.04473285f, 0.14329918f, -0.08507796f, 
    0.03991829f, -0.07917657f, 0.20258847f, -0.06427628f, 0.13373217f, -0.12492863f, 0.01059733f, 0.00831826f, 
    0.07526215f, 0.04015625f, -0.14293338f, -0.24606898f, -0.32349983f, -0.00849860f, 0.10204297f, 0.09004642f, 
    0.03282027f, 0.10213359f, -0.07648475f, -0.05908406f, -0.40574768f, -0.14886294f, -0.04966122f, 0.27725971f, 
    -0.28238827f, -0.07375949f, -0.16897237f, -0.07130568f, 0.20005104f, -0.25013176f, -0.37124950f, 0.06142001f, 
    0.16119750f, -0.07394971f, -0.27639106f, 0.04866585f, 0.06084372f, 0.01758152f, 0.00687350f, -0.02582300f, 
    -0.08106105f, 0.00304995f, 0.07966695f, 0.03016774f, 0.04312105f, 0.03559699f, 0.14446723f, 0.09234622f, 
    0.12660445f, 0.35026428f, -0.01602536f, -0.03765444f, 0.07476476f, 0.07621744f, -0.04707109f, -0.09611679f, 
    -0.11720023f, -0.18981566f, -0.16090222f, 0.18791799f, 0.02193304f, -0.05815532f, -0.09329015f, 0.20455344f, 
    -0.08520634f, -0.03425480f, 0.09039059f, -0.07925241f, 0.03756434f, 0.04904805f, -0.15358348f, 0.07325158f, 
    -0.00493612f, 0.03484662f, -0.00055282f, -0.06721539f, 0.01736631f, -0.03718259f, -0.05899757f, -0.04106862f, 
    0.00987301f, 0.11560430f, -0.02071138f, 0.09977932f, 0.07756281f, 0.16236562f, 0.19051681f, 0.03345330f, 
    0.09971715f, 0.11825647f, 0.07144015f, 0.02117508f, 0.29889610f, 0.10921950f, 0.12978069f, 0.08897323f, 
    -0.12586640f, -0.08338773f, -0.13323471f, -0.00000889f, 0.09595244f, 0.27570125f, 0.18525149f, -0.02563013f, 
    -0.22221157f, -0.15801106f, 0.02033853f, 0.02974984f, 0.02254419f, -0.06132422f, 0.05564485f, -0.12829724f, 
    -0.01952289f, -0.16711380f, 0.04623923f, 0.02123436f, 0.07583243f, 0.02776108f, -0.07757030f, 0.27771902f, 
    0.14032954f, 0.12542059f, -0.02513353f, 0.18631651f, 0.15324005f, 0.13406986f, -0.08299737f, -0.03049226f, 
    0.05240868f, 0.21723332f, 0.24426308f, -0.01786122f, 0.13343638f, 0.03622103f, -0.00207447f, 0.05995410f, 
    0.20668966f, 0.10298637f, 0.03408036f, -0.14635102f, 0.00144568f, 0.00870947f, -0.04738029f, 0.08176208f, 
    -0.12756962f, 0.12377706f, -0.15809922f, -0.00069524f, 0.13391410f, -0.12632893f, -0.13434255f, -0.13321812f, 
    0.06861588f, 0.04601985f, -0.04483538f, -0.05854950f, -0.14483145f, -0.24637087f, 0.09038172f, -0.23788735f, 
    0.14072539f, 0.06495048f, -0.14934155f, 0.10699093f, 0.11610256f, -0.14092994f, 0.24914242f, 0.12119046f, 
    -0.02346866f, 0.04357214f, -0.00264599f, 0.05448353f, 0.07652886f, 0.03854671f, -0.04989112f, -0.04410962f, 
    0.05162645f, -0.24010511f, 0.03736562f, -0.02588386f, -0.11202101f, 0.13533881f, 0.34576398f, 0.17867213f, 
    0.39737937f, 0.17237283f, -0.03053902f, -0.06924831f, 0.14386395f, -0.13279802f, 0.31493556f, -0.08382224f, 
    -0.02178179f, 0.17155087f, -0.00695245f, 0.02211373f, -0.07899763f, -0.07212179f, 0.14815889f, 0.10106916f, 
    0.32998079f, -0.34770989f, -0.07067050f, 0.15080744f, -0.11629876f, -0.03295121f, -0.05675574f, 0.21629812f, 
    -0.07122975f, 0.21762443f, 0.16978529f, 0.12605536f, 0.04265912f, -0.05297218f, -0.06701348f, 0.14409351f, 
    0.08048163f, 0.22025637f, -0.06765209f, 0.21424896f, -0.14598623f, 0.14504074f, 0.14920618f, 0.05092767f, 
    0.20439619f, 0.09391065f, 0.20010877f, 0.14749004f, 0.31313252f, 0.30472764f, 0.13398798f, 0.10849448f, 
    0.12641282f, 0.18369861f, 0.18407534f, 0.02311886f, -0.08544236f, 0.12342978f, 0.04083083f, 0.10494520f, 
    0.00828637f, 0.00135850f, 0.21815343f, 0.10708829f, 0.03529134f, 0.60926491f, 0.01571362f, 0.24104834f, 
    0.08833606f, -0.10314963f, -0.02208971f, 0.31596765f, 0.07732350f, 0.20773555f, 0.04031069f, 0.02761780f, 
    -0.14179868f, 0.03690391f, 0.10409627f, -0.02823158f, -0.00012439f, 0.04461325f, 0.04583327f, -0.25818247f, 
    -0.05069111f, 0.27054411f, -0.12093834f, -0.01480281f, -0.08063060f, 0.24626927f, -0.05065993f, -0.03265759f, 
    0.04367612f, -0.18835558f, -0.17604646f, -0.03232634f, -0.11437002f, 0.07993315f, 0.18813282f, 0.10626876f, 
    0.00599529f, -0.07665371f, -0.00375369f, 0.19300167f, -0.14929192f, 0.12564728f, -0.05601830f, 0.18707331f, 
    0.03390197f, 0.08539725f, -0.16668896f, 0.08420339f, 0.18627453f, 0.04353453f, 0.03201520f, -0.01032641f, 
    -0.09044793f, -0.01381517f, -0.06313048f, 0.00077226f, -0.12392574f, -0.15512408f, -0.19226412f, -0.11805072f, 
    -0.04234061f, -0.00301998f, 0.04549664f, -0.06138128f, 0.33665147f, -0.42364180f, -0.14898196f, -0.14548652f, 
    0.09251563f, -0.15124844f, -0.22911870f, -0.03505392f, -0.14208856f, 0.28816953f, -0.18200427f, -0.29400679f, 
    -0.00496107f, 0.09140955f, 0.07831997f, -0.07731585f, -0.27298820f, 0.05963878f, -0.15701254f, -0.11577901f, 
    -0.14333145f, 0.01237752f, 0.07151914f, 0.07063711f, 0.16311890f, 0.07065041f, 0.14296776f, 0.02276716f, 
    0.35215607f, 0.02891947f, 0.13055588f, 0.08135895f, 0.04271014f, -0.06814373f, 0.15541244f, 0.12626931f, 
    -0.13395303f, -0.14106737f, -0.29677281f, -0.01095907f, -0.05963282f, -0.14966203f, 0.00694586f, -0.02045455f, 
    0.05412496f, 0.24620582f, -0.15366961f, 0.03143887f, 0.13576479f, 0.05750632f, 0.00465139f, 0.06829499f, 
    0.20763665f, 0.08314581f, -0.01323522f, -0.15702155f, -0.16906771f, -0.29140937f, -0.09232912f, -0.04404590f, 
    0.07656780f, 0.02797330f, 0.12199932f, 0.21729136f, 0.14327531f, 0.12939361f, 0.06790161f, -0.00571562f, 
    0.05308497f, 0.24814580f, 0.15906467f, 0.04750771f, -0.20207207f, -0.03523200f, 0.04763728f, -0.09494849f, 
    -0.05305129f, -0.14162137f, 0.16457959f, -0.01893039f, -0.06201563f, -0.26558706f, 0.12762192f, 0.28009081f, 
    0.05923555f, 0.00725363f, -0.11402161f, 0.11800313f, 0.12377361f, -0.05597967f, -0.03317949f, 0.17635773f, 
    0.30237266f, -0.09250094f, 0.00681129f, -0.11341166f, -0.00662134f, 0.05507352f, 0.00602812f, -0.04918473f, 
    0.25786647f, 0.25496912f, 0.07636650f, -0.06600791f, 0.00827424f, 0.05967598f, 0.05698621f, 0.28291377f, 
    0.17316015f, 0.05392464f, 0.09179156f, 0.02017814f, 0.05525263f, -0.03214419f, -0.16345417f, -0.24133682f, 
    -0.12078360f, 0.05975688f, -0.13943142f, 0.11141165f, -0.05185568f, 0.03242506f, -0.08543383f, -0.01173856f, 
    -0.13447183f, -0.09336016f, 0.10885888f, -0.17942770f, -0.06813002f, -0.08425608f, -0.06399117f, -0.11903459f, 
    0.14150740f, -0.03576199f, 0.15286662f, 0.11659738f, 0.19434001f, 0.20369084f, -0.18788940f, 0.07623326f, 
    0.02039232f, 0.01487922f, 0.04290049f, -0.13823391f, -0.06932569f, 0.13271198f, -0.03171712f, 0.07722946f, 
    0.15916945f, 0.04781646f, -0.07057972f, 0.17331116f, 0.04323834f, 0.10993693f, 0.15546846f, 0.32636535f, 
    0.05854473f, -0.05703729f, -0.12375526f, -0.00463553f, 0.02648650f, 0.13025929f, 0.06276631f, 0.38460985f, 
    -0.02459632f, -0.10340346f, 0.15303166f, 0.05370744f, -0.04695097f, 0.18685849f, 0.04898114f, -0.13502517f, 
    -0.00755391f, -0.08462830f, 0.02038801f, 0.05519909f, 0.07388477f, 0.05820910f, -0.04033235f, 0.02049724f, 
    0.20650040f, 0.21214764f, 0.36682078f, 0.05929397f, -0.01382713f, 0.14302514f, 0.10626749f, 0.13604321f, 
    -0.06811586f, 0.16013470f, -0.07287122f, -0.05170274f, 0.05178512f, -0.04541497f, 0.01264384f, 0.04910824f, 
    0.02082480f, 0.02123043f, 0.04149934f, -0.00907210f, -0.05643246f, -0.11207960f, 0.07477365f, 0.03181230f, 
    -0.26699021f, 0.01010177f, -0.11434713f, -0.07087244f, 0.02975442f, -0.00770692f, -0.06309380f, 0.05050019f, 
    -0.03713990f, 0.06977891f, -0.08126286f, 0.00652675f, 0.25627404f, -0.07578261f, -0.16562040f, 0.13625254f, 
    -0.15991999f, 0.00483728f, -0.17195828f, -0.30504268f, -0.08380537f, 0.08038135f, 0.27404720f, -0.02001582f, 
    -0.02749059f, 0.29036766f, 0.02442214f, 0.23550864f, 0.15945916f, 0.16143942f, -0.00600058f, 0.12487465f, 
    0.13369216f, 0.01434513f, 0.04488129f, 0.17035197f, -0.00943898f, -0.06802232f, 0.12962756f, 0.37985897f, 
    -0.10100347f, -0.09737214f, 0.03577144f, 0.02918633f, 0.09909939f, -0.05229808f, 0.07184809f, -0.12013950f, 
    -0.06150381f, 0.12721331f, 0.09462232f, 0.05440197f, -0.02451989f, -0.02732071f, -0.10863388f, 0.08021204f, 
    -0.14112735f, 0.23210907f, 0.14068164f, 0.06953342f, 0.05054420f, -0.07665616f, -0.10077451f, 0.10882401f, 
    0.13841061f, 0.09326025f, 0.15117915f, -0.24390890f, 0.02499643f, -0.04825553f, -0.18470414f, -0.14174251f, 
    -0.09088784f, 0.03161340f, -0.10926708f, -0.07163993f, 0.12526725f, 0.22898938f, 0.02035203f, -0.04143879f, 
    -0.10806991f, 0.00017164f, -0.07965120f, -0.02321503f, 0.29386005f, 0.40690693f, 0.10305464f, -0.00888713f, 
    0.15901111f, 0.09775771f, -0.07979741f, 0.09337799f, -0.28862554f, -0.00560779f, 0.19108333f, -0.24637972f, 
    0.13907447f, -0.05043419f, 0.01060450f, -0.21985470f, 0.12876941f, -0.40140089f, -0.09605664f, -0.07933734f, 
    0.09110546f, 0.05713408f, 0.09008031f, 0.17648216f, -0.11750340f, -0.03553372f, -0.10944778f, 0.06628027f, 
    -0.20368686f, -0.16654126f, 0.00653457f, -0.06099325f, -0.03714143f, -0.19309188f, -0.35187781f, -0.08964884f, 
    0.06532903f, 0.08533483f, 0.20352127f, 0.03542475f, 0.20963430f, -0.01420739f, 0.01972688f, 0.14849629f, 
    0.15936814f, -0.06794211f, 0.18216288f, 0.05829188f, 0.11795704f, -0.15065767f, 0.20177430f, -0.17793915f, 
    0.12038956f, -0.13806732f, 0.03284397f, 0.27899423f, 0.03539540f, 0.00746917f, 0.02229157f, 0.17576776f, 
    0.06080697f, 0.12445295f, -0.11261260f, 0.02598272f, 0.04547180f, -0.19025737f, -0.02622792f, -0.06299250f, 
    -0.03638501f, -0.05913914f, -0.34474134f, -0.13582222f, 0.05213575f, 0.18991025f, -0.03146230f, -0.03696337f, 
    0.11022783f, 0.04347896f, 0.21860424f, 0.31688794f, 0.20199348f, -0.12035389f, 0.01202582f, 0.08781035f, 
    0.00872344f, -0.05215999f, 0.05313646f, -0.02350291f, -0.12791489f, -0.05630746f, -0.22142904f, -0.09278014f, 
    -0.02187517f, 0.00147687f, 0.00584371f, 0.00073982f, -0.08251062f, 0.12394261f, 0.00738467f, -0.24345264f, 
    -0.22730494f, 0.03187785f, -0.11230208f, -0.06202342f, -0.06434904f, -0.09354950f, -0.17927343f, -0.05656288f, 
    -0.58585018f, 0.03276420f, -0.03076225f, 0.19485849f, 0.15347388f, -0.03959346f, -0.00966451f, -0.03584805f, 
    -0.10974014f, 0.23400323f, 0.03382145f, 0.09282198f, -0.10497990f, 0.14662084f, -0.09032366f, 0.14829214f, 
    0.07825232f, 0.01180407f, -0.12408593f, 0.34068301f, 0.13200964f, 0.09200168f, -0.01003541f, 0.02993320f, 
    0.07211892f, -0.11671014f, -0.08956918f, 0.04583599f, 0.02541525f, -0.06226528f, 0.16506326f, 0.02732319f, 
    -0.07418920f, -0.11637843f, 0.14117584f, 0.02680780f, -0.32836211f, -0.30414948f, 0.14026000f, 0.09264813f, 
    -0.06064466f, -0.01354504f, 0.01307971f, 0.11631524f, -0.00766986f, 0.25471359f, 0.05058709f, -0.13073103f, 
    -0.04378223f, -0.02504317f, -0.00114850f, 0.00039501f, 0.07288293f, -0.04524850f, 0.11556930f, 0.03049727f, 
    -0.23919003f, 0.02829427f, 0.10062203f, 0.17952600f, 0.02372404f, 0.01853383f, -0.02836486f, -0.36267367f, 
    -0.52349144f, 0.01883473f, -0.05690370f, -0.00771415f, 0.03526189f, -0.21564846f, -0.20507847f, 0.26996484f, 
    -0.37284580f, -0.22528349f, 0.03864982f, -0.13937542f, 0.06692113f, -0.10994548f, 0.08912154f, -0.03447624f, 
    -0.06586666f, -0.18727349f, -0.04590994f, -0.07763564f, -0.02105463f, 0.05477206f, 0.01892303f, 0.19627799f, 
    -0.03637639f, 0.03946688f, 0.03789668f, 0.13148332f, -0.06001735f, -0.15677093f, -0.13179746f, -0.04938587f, 
    0.07901828f, -0.04488330f, 0.03012192f, -0.08467756f, 0.17559245f, -0.12732935f, 0.15925618f, -0.00328936f, 
    0.09559736f, 0.04365001f, 0.11438008f, 0.07223412f, -0.07932929f, -0.02181670f, -0.52213657f, -0.19298971f, 
    0.00761384f, -0.01608727f, 0.18105279f, -0.04801458f, -0.07289433f, 0.17635617f, 0.32181656f, -0.30371827f, 
    0.14626950f, 0.24205318f, 0.13156219f, 0.15719679f, 0.20455314f, 0.04300943f, 0.13444506f, -0.02357899f, 
    0.16423625f, -0.21296868f, -0.21107171f, -0.20254757f, -0.03959501f, -0.00118736f, 0.00938981f, 0.21453530f, 
    -0.18164195f, -0.22481346f, -0.06827706f, 0.06788392f, 0.07363160f, 0.21719663f, -0.13187040f, -0.11044833f, 
    0.13512751f, 0.23775978f, 0.09801253f, 0.01875307f, -0.15799257f, -0.06632343f, -0.14660233f, -0.14851117f, 
    0.00528763f, -0.02141442f, -0.26570818f, -0.27192390f, -0.17733768f, -0.07302920f, 0.05294448f, -0.03025245f, 
    -0.01138456f, -0.01720402f, -0.36282626f, -0.57413650f, -0.70584190f, -0.20877261f, -0.17771608f, -0.06239204f, 
    -0.16898179f, -0.05877388f, -0.11518501f, 0.11489270f, 0.12560190f, 0.16702093f, -0.09944309f, -0.09293655f, 
    -0.06700356f, 0.09807089f, 0.00939750f, -0.07779329f, 0.04689823f, 0.00394903f, 0.01731130f, -0.24714726f, 
    0.22332327f, 0.01818888f, 0.22979778f, 0.22334844f, -0.17634398f, -0.00196347f, 0.00951071f, 0.24185285f, 
    -0.03579075f, 0.11822479f, 0.06674604f, 0.15188812f, 0.01426481f, 0.03934914f, 0.28093126f, 0.23683980f, 
    0.04769948f, -0.10662425f, -0.18247207f, -0.04132972f, -0.07154019f, -0.02016238f, -0.14722036f, -0.18343692f, 
    -0.50564462f, -0.58127058f, -0.09565777f, -0.06791074f, 0.10199961f, 0.09272800f, -0.02655065f, -0.06488177f, 
    0.10528458f, -0.06067725f, -0.06301960f, -0.09119904f, -0.12747948f, 0.06880103f, 0.08964077f, 0.15267715f, 
    0.11844980f, -0.59843445f, 0.07698870f, 0.10742943f, 0.18369626f, 0.15922189f, -0.00864805f, -0.01204107f, 
    0.02015496f, 0.07450400f, 0.14664119f, -0.05166401f, -0.07778215f, -0.11588059f, -0.13648723f, 0.02704078f, 
    0.13253535f, -0.10672366f, -0.08757649f, -0.06179001f, 0.05248815f, -0.07691936f, 0.13182786f, 0.01473219f, 
    -0.00747214f, 0.03618056f, 0.13175347f, 0.05477446f, -0.19011104f, 0.36950359f, -0.04491289f, 0.08440565f, 
    0.02491076f, -0.03001117f, -0.00386596f, -0.11429008f, -0.08834633f, -0.10369822f, 0.12638001f, -0.68664318f, 
    -0.21885137f, -0.08194551f, 0.02020101f, 0.25080553f, 0.04810040f, 0.00651041f, -0.02927912f, -0.74952793f, 
    -0.33011287f, -0.17477071f, 0.04347094f, 0.05298235f, 0.12594132f, -0.11740251f, 0.06935629f, 0.33447638f, 
    -0.08663267f, -0.17681386f, 0.09584976f, 0.31258038f, -0.03584702f, 0.16860026f, 0.13923682f, 0.10283372f, 
    0.01351059f, 0.07870334f, -0.32695612f, 0.13884914f, 0.18774354f, -0.05220834f, -0.03053299f, 0.03700366f, 
    -0.28252748f, -0.12510143f, 0.03872569f, 0.17922373f, 0.01266096f, 0.03587111f, 0.02264386f, 0.09842592f, 
    -0.27594745f, -0.08872014f, 0.03386401f, 0.11239962f, -0.07405274f, -0.08100935f, -0.14914648f, 0.22940326f, 
    0.27638370f, 0.00285183f, 0.05798631f, 0.06706902f, 0.15597779f, 0.09835017f, -0.02253962f, 0.07269935f, 
    -0.09678556f, -0.18410043f, 0.07656903f, 0.14059898f, -0.03497497f, 0.20402445f, 0.07079279f, 0.06099826f, 
    -0.04791658f, 0.12061828f, 0.07038007f, 0.12238146f, 0.08298361f, -0.14590083f, 0.03523481f, 0.02936464f, 
    -0.16534744f, -0.02005985f, 0.22868529f, 0.15908954f, 0.05600238f, 0.29926181f, -0.39101991f, -0.12656859f, 
    0.20312577f, -0.26372969f, -0.00916331f, 0.23819120f, 0.03349493f, -0.17127439f, 0.05864359f, 0.18195125f, 
    0.15165862f, -0.12601078f, 0.09340468f, 0.07914391f, -0.02659700f, 0.12102240f, 0.25806770f, 0.16576163f, 
    -0.07342274f, 0.37776282f, 0.28097197f, 0.00412077f, 0.03598275f, -0.06420773f, 0.09331390f, 0.02820798f, 
    -0.00123063f, 0.16275157f, 0.29175028f, 0.20177363f, 0.15219413f, -0.05741556f, 0.00536313f, 0.12942815f, 
    -0.09925774f, 0.06314136f, 0.03705467f, -0.09789716f, 0.03143784f, -0.08228786f, 0.13004996f, -0.17773293f, 
    -0.11552926f, -0.19248651f, -0.04239861f, -0.13485689f, -0.30881214f, -0.20361032f, 0.06914525f, 0.04859745f, 
    0.13479011f, -0.10773133f, -0.12302331f, -0.03020691f, 0.17773120f, 0.02762445f, -0.10346964f, 0.06006891f, 
    0.16712135f, 0.01377761f, -0.07036109f, -0.14344245f, -0.24785118f, 0.11892147f, -0.18293682f, -0.12500843f, 
    0.29604161f, 0.23766899f, 0.20742846f, -0.11474395f, 0.10889547f, 0.00574052f, 0.04911505f, 0.10805085f, 
    0.09536593f, -0.01417077f, -0.21401975f, -0.11231832f, -0.04213021f, 0.00071344f, 0.07392239f, 0.25117519f, 
    0.12982784f, -0.20470291f, 0.13486417f, -0.06456781f, -0.07258370f, -0.08733965f, 0.05251671f, 0.20919122f, 
    0.08860452f, -0.09796568f, 0.12223116f, 0.14012045f, -0.02413476f, -0.03928339f, -0.07221305f, -0.17162026f, 
    -0.02122925f, -0.01944180f, -0.06903138f, -0.02699243f, 0.04784561f, -0.17964621f, -0.15510517f, -0.07317770f, 
    0.02896273f, 0.01637700f, -0.02226402f, 0.06604372f, -0.06738196f, 0.09172331f, -0.14968552f, -0.23733166f, 
    -0.13731016f, 0.12620887f, -0.04550156f, 0.04060722f, -0.00977572f, 0.03787532f, -0.04855692f, -0.03246476f, 
    -0.00544581f, -0.21811715f, -0.15563218f, -0.06435104f, -0.16269886f, -0.09192660f, 0.23665118f, 0.14570940f, 
    0.01005822f, -0.01486166f, 0.05831565f, -0.30362329f, 0.06786396f, -0.12945068f, -0.04107717f, 0.27106190f, 
    0.10076702f, 0.07211337f, 0.08897340f, -0.21103302f, -0.49317595f, -0.15130506f, 0.16705656f, 0.08577320f, 
    0.19141629f, 0.04821473f, -0.09529733f, -0.01118123f, -0.08000071f, -0.04455685f, -0.11510904f, -0.04656722f, 
    -0.12257070f, -0.16413617f, -0.14947872f, 0.01896093f, -0.04592877f, -0.06700357f, -0.20707680f, 0.01309150f, 
    0.10397705f, 0.02968461f, 0.11603444f, -0.06362741f, 0.05606633f, 0.12236413f, 0.21708030f, 0.02961887f, 
    0.17858985f, -0.05250709f, 0.41304535f, 0.18415719f, 0.11589621f, -0.00558817f, -0.02065570f, 0.07764426f, 
    0.13435639f, -0.16681746f, 0.10453702f, 0.06372099f, 0.18842061f, -0.28995484f, -0.07383870f, -0.10997229f, 
    0.13180715f, 0.13747928f, 0.06877042f, 0.10240161f, -0.16531156f, -0.13105163f, 0.07415716f, 0.16468692f, 
    -0.02934966f, 0.16896695f, 0.06686015f, -0.33883345f, -0.11494733f, 0.14985159f, 0.13675772f, -0.29833880f, 
    0.00715601f, 0.37394416f, 0.16697732f, -0.06460142f, 0.27918586f, 0.17317854f, -0.05957498f, -0.27996385f, 
    -0.00572088f, -0.02442474f, 0.05509159f, 0.02490783f, -0.14516707f, -0.02399298f, 0.04035415f, 0.20412117f, 
    -0.15399532f, -0.02601200f, -0.02127372f, -0.00969185f, -0.12982391f, 0.09187719f, -0.03153802f, 0.07145221f, 
    -0.23764955f, -0.27291536f, 0.04734857f, -0.03868840f, 0.03576669f, 0.04012243f, -0.02134576f, -0.03519336f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.11674034f, 0.04883087f, 0.09061594f, -0.09282415f, -0.02545667f, -0.05245314f, 0.03832006f, 0.09980147f, 
    -0.06503471f, 0.16891997f, 0.09129123f, 0.04344321f, 0.05539698f, 0.02500648f, -0.10554927f, 0.09809003f, 
    -0.00133878f, 0.06862424f, 0.20472293f, 0.01002202f, 0.22276580f, 0.02384980f, 0.21275260f, -0.01509896f, 
    0.01661254f, 0.05132778f, -0.00007250f, 0.12428466f, 0.19244219f, -0.07594471f, 0.18619467f, -0.06890293f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.29283708f, -0.09947197f, 0.43329653f, 0.39359620f, -0.13307221f, 0.12191077f, 0.30945611f, -0.24636263f, 
    -0.14547993f, 0.08017557f, 0.01578843f, 0.16331245f, 0.12992491f, 0.04892083f, 0.08165839f, 0.33845782f, 
    -0.31008685f, 0.34273824f, -0.50364757f, -0.17505825f, 0.01395098f, 0.04452811f, 0.10359024f, 0.03583401f, 
    0.38983950f, 0.11446257f, -0.17185482f, 0.36862683f, 0.01328469f, 0.15919171f, -0.13459811f, 0.28166953f, 
    -0.24225490f, -0.11235461f, 0.14327927f, 0.33671919f, -0.16313332f, 0.15326011f, -0.03159828f, -0.68260670f, 
    -0.06373549f, -0.20755301f, 0.25790444f, 0.17060007f, 0.29030439f, 0.21415910f, -0.15587120f, 0.14317670f, 
    -0.32849231f, 0.29576921f, -0.00414456f, 0.21800759f, -0.27034208f, -0.15564103f, 0.19031386f, -0.16919671f, 
    0.29743364f, 0.07534072f, -0.00039137f, 0.00502566f, -0.05715802f, -0.16853897f, 0.14492030f, -0.00815941f, 
    0.08410983f, -0.01833075f, 0.54070312f, 0.37375343f, -0.11915725f, 0.02419155f, -0.19337852f, -0.32291624f, 
    -0.21798898f, 0.30284485f, 0.23720860f, -0.06752016f, -0.19380723f, 0.25333408f, 0.17463881f, 0.10035248f, 
    -0.00104787f, -0.10610925f, -0.12968823f, -0.26252121f, 0.04326175f, 0.16412628f, 0.12092929f, -0.04865025f, 
    0.34547296f, -0.12723739f, -0.02840384f, 0.16106898f, 0.18971586f, -0.07036248f, -0.21219875f, 0.03149525f, 
    -0.15500951f, -0.01227167f, 0.34990406f, 0.38447610f, 0.07388992f, -0.09366873f, 0.02053441f, -0.07093751f, 
    0.17184083f, -0.13401471f, 0.45756519f, 0.00681429f, -0.14663933f, 0.25476021f, -0.11630734f, 0.06517576f, 
    0.21910225f, -0.20317104f, -0.16979495f, 0.32019457f, -0.05252034f, 0.02224264f, 0.11212774f, -0.11720167f, 
    0.38308781f, 0.00846934f, -0.00236010f, 0.07498412f, -0.18627211f, 0.16871259f, 0.27128765f, 0.14884683f, 
    0.16776112f, 0.16150805f, -0.22145092f, -0.25070179f, 0.14689475f, -0.00541906f, 0.28998223f, 0.21110208f, 
    0.04824040f, -0.02375815f, -0.04136497f, 0.14271352f, -0.12584759f, -0.06620875f, 0.13397095f, 0.13831910f, 
    -0.28250751f, 0.05862156f, 0.35195282f, 0.02443280f, 0.26080063f, 0.10260104f, 0.06966394f, 0.14869986f, 
    -0.17557983f, -0.06785282f, 0.07082169f, -0.12474909f, 0.08744606f, -0.03738531f, -0.12892482f, -0.15273559f, 
    -0.30849966f, -0.00101822f, -0.22792386f, -0.65419650f, 0.09256209f, 0.06316580f, -0.14388433f, 0.10058054f, 
    0.13079186f, 0.03503385f, 0.11636722f, 0.10790312f, 0.67394578f, 0.11047919f, -0.01768784f, 0.02498314f, 
    -0.03127870f, 0.22777586f, 0.14040729f, 0.40374291f, 0.21286257f, 0.04829883f, 0.04849823f, 0.03281720f, 
    -0.20261636f, -0.15494272f, -0.08864533f, 0.12124442f, 0.18415530f, 0.28538007f, -0.31021395f, -0.25341031f, 
    -0.09151959f, -0.11520293f, 0.07811674f, 0.09294962f, 0.10794016f, -0.15072949f, -0.10486545f, 0.14707260f, 
    -0.14531557f, -0.11950751f, -0.16552407f, -0.05623534f, 0.08272013f, -0.07018918f, -0.06004535f, -0.11927879f, 
    0.09814123f, -0.09125693f, -0.07472153f, 0.14761791f, -0.02542933f, 0.11065963f, -0.06868123f, -0.02294238f, 
    0.09653649f, 0.04129312f, -0.14998139f, 0.06990547f, 0.01972957f, -0.06712389f, -0.16076018f, 0.13445728f, 
    -0.57235128f, -0.06000628f, -0.30395728f, -0.25502211f, 0.00034518f, 0.01649269f, -0.30674696f, -0.37105951f, 
    0.22402897f, 0.18116029f, -0.04310833f, 0.04310359f, 0.63964111f, 0.51267767f, -0.25659344f, 0.26365373f, 
    0.20221360f, 0.28597346f, 0.02202991f, 0.56231254f, 0.11491491f, -0.00790914f, -0.07908993f, -0.11060397f, 
    -0.06110199f, -0.14747018f, -0.18033548f, 0.06916799f, 0.10074562f, -0.17064373f, -0.30617443f, -0.40485922f, 
    0.26861104f, -0.15957406f, 0.09788613f, -0.11588427f, 0.01967254f, 0.02799377f, -0.14198095f, 0.10887207f, 
    0.13230224f, 0.08973347f, 0.93639278f, -0.04444930f, -0.38351163f, 0.10168640f, -0.31803638f, -0.12036288f, 
    0.28909263f, -0.18127961f, 0.39825636f, 0.07333998f, 0.26862422f, 0.14363493f, 0.32965541f, -0.07980155f, 
    0.15324016f, -0.05851831f, 0.00791710f, -0.40539756f, 0.11034709f, -0.10333633f, 0.37642643f, -0.15713868f, 
    -0.05402102f, -0.06015525f, 0.18261759f, 0.54881877f, 0.09922623f, 0.04116005f, 0.15291865f, 0.09520803f, 
    -0.09940889f, 0.15001145f, -0.09386646f, 0.04350085f, -0.04749031f, 0.04175120f, 0.11870071f, -0.21928848f, 
    0.24765719f, -0.08848890f, -0.33871526f, 0.04581129f, 0.00840129f, -0.04465791f, -0.12581173f, 0.17757766f, 
    0.21556424f, -0.12014984f, -0.07803454f, 0.09882667f, -0.23552653f, 0.08884018f, 0.24566612f, 0.10166303f, 
    -0.13342208f, -0.06515874f, 0.41932723f, -0.08473842f, -0.10789024f, 0.12621093f, 0.15497693f, 0.12779921f, 
    -0.27977356f, 0.11794097f, -0.03092484f, -0.02638836f, 0.13576487f, -0.31557453f, -0.06878088f, 0.01542618f, 
    -0.22779596f, 0.21214411f, -0.15005736f, -0.72461438f, 0.34278348f, 0.06573910f, 0.39728838f, -0.12819895f, 
    -0.00839764f, 0.00970278f, 0.14605105f, -0.06157384f, 0.09741151f, 0.17608295f, 0.38734877f, -0.05347793f, 
    0.10044235f, -0.18396972f, 0.50520116f, 0.44921392f, 0.08962584f, 0.16930617f, -0.03104467f, -0.22062370f, 
    0.00935317f, -0.02525855f, 0.46031430f, 0.03825588f, -0.12188885f, 0.36292887f, -0.13835895f, 0.27710015f, 
    0.21186146f, 0.06625220f, -0.26290265f, 0.32778814f, -0.10004370f, -0.02540608f, 0.06868248f, 0.05166044f, 
    0.42226654f, 0.13731281f, 0.20376128f, 0.37942263f, 0.05644247f, -0.05354306f, -0.04230051f, -0.15531990f, 
    -0.06711045f, -0.13487053f, -0.09463004f, 0.01824655f, -0.08416633f, -0.12282479f, -0.14035864f, 0.07698434f, 
    0.11797020f, 0.04659205f, -0.20285399f, -0.15860185f, -0.16840678f, -0.03882620f, -0.14940262f, 0.03136136f, 
    -0.00383528f, -0.16217078f, -0.00760459f, 0.01697066f, -0.14669707f, 0.05925000f, 0.10236128f, 0.17004393f, 
    0.16600439f, -0.11051045f, -0.15266249f, 0.10118841f, -0.05315350f, 0.13206439f, -0.02028551f, -0.07749935f, 
    0.06428824f, 0.13809735f, -0.05284777f, -0.43025678f, -0.07450391f, 0.03100516f, -0.09966380f, -0.20797251f, 
    0.33403176f, -0.19712028f, 0.64996153f, 0.14016008f, 0.27504614f, -0.21399635f, 0.03908947f, 0.04232464f, 
    -0.16179128f, -0.31289193f, 0.58208555f, 0.10891203f, 0.28417641f, -0.15196705f, 0.27145481f, 0.01194680f, 
    0.07642900f, -0.14786634f, -0.13156466f, -0.42228901f, 0.23299877f, -0.01733216f, -0.05288167f, -0.03459528f, 
    0.15471938f, 0.06824190f, 0.25095606f, 0.39366508f, 0.12003359f, -0.01334203f, -0.27452147f, -0.41066557f, 
    0.21717480f, 0.19296409f, 0.09058843f, 0.06341273f, -0.22250766f, 0.20140228f, 0.19720535f, 0.09483329f, 
    -0.22288139f, -0.34081852f, 0.35304570f, 0.33683419f, -0.13090405f, -0.16449367f, -0.03659970f, -0.12456434f, 
    0.11939587f, 0.11425395f, -0.00217755f, 0.11062524f, 0.18594828f, -0.37118354f, -0.25558454f, -0.16097581f, 
    -0.01267070f, 0.01656651f, -0.26277870f, -0.24857591f, 0.02666803f, -0.12206271f, 0.34750924f, 0.43466705f, 
    -0.12122671f, -0.01036554f, -0.66809309f, -0.20164107f, 0.12388644f, -0.08399078f, -0.07753590f, 0.16235121f, 
    -0.47173646f, -0.05749392f, -0.03899289f, -0.42316449f, 0.12233012f, -0.06272548f, 0.23313911f, -0.07356030f, 
    -0.17458160f, 0.00430298f, 0.07862349f, 0.05220619f, 0.26368338f, -0.20621333f, 0.01261532f, 0.06044425f, 
    0.07559193f, 0.06868383f, 0.00549226f, -0.40251487f, 0.01109151f, 0.15860723f, 0.10818615f, 0.18069087f, 
    -0.18707326f, 0.07535112f, 0.13993913f, -0.16942461f, -0.17549890f, -0.23974332f, 0.10423846f, -0.34744024f, 
    0.11627897f, -0.16717607f, -0.30084893f, -0.04647724f, -0.12120379f, 0.04225198f, -0.46456695f, -0.15075167f, 
    -0.38643861f, 0.12474717f, -0.16609003f, -0.03304975f, -0.14658697f, 0.00253902f, 0.10491324f, -0.18676977f, 
    0.31243393f, -0.07245936f, 0.37848726f, -0.47076187f, -0.03363590f, -0.12921172f, 0.20582849f, 0.08195372f, 
    -0.11694523f, 0.09892726f, -0.01004786f, -0.09350446f, -0.15213557f, 0.05250997f, -0.21626718f, -0.14327827f, 
    -0.10189150f, -0.01113559f, 0.34999052f, -0.33453575f, 0.30685246f, -0.10938041f, 0.38523805f, -0.12794554f, 
    0.03130304f, -0.01302234f, 0.07817233f, 0.03740796f, 0.19863446f, -0.26818985f, 0.14065717f, -0.26842880f, 
    -0.06551755f, -0.01427191f, -0.11739336f, 0.30339050f, -0.08271268f, -0.14248064f, 0.29314286f, 0.14616548f, 
    -0.04877159f, -0.08879381f, 0.30967993f, 0.00424805f, -0.08300440f, -0.17426938f, -0.35467285f, -0.05286411f, 
    -0.20017004f, 0.39508662f, -0.32492307f, 0.16893184f, -0.09695052f, 0.00335915f, 0.07294619f, 0.10277461f, 
    -0.01522783f, 0.05016377f, 0.08468886f, 0.09144264f, -0.00787968f, 0.28016287f, 0.47091207f, 0.29567766f, 
    0.23159526f, 0.15361401f, -0.30322516f, 0.30536669f, 0.14374071f, -0.07988356f, 0.05123797f, -0.07138690f, 
    0.19312340f, 0.27292672f, -0.26340866f, -0.06396343f, -0.36804700f, -0.30846092f, 0.10356405f, 0.08585498f, 
    -0.29815087f, -0.35017401f, 0.24873452f, -0.23877123f, -0.23993252f, -0.10936376f, 0.03665290f, 0.02209722f, 
    0.06862505f, 0.07090896f, -0.16704082f, 0.23804379f, 0.17685166f, -0.28171325f, -0.27102244f, 0.15220748f, 
    -0.39263660f, -0.11337628f, 0.36181214f, -0.18578981f, -0.09096167f, -0.11542343f, -0.08122090f, 0.19701943f, 
    -0.16319734f, 0.07166159f, -0.12584786f, -0.12592895f, 0.39932179f, 0.36872137f, 0.05714124f, -0.07065780f, 
    0.27404425f, 0.55603516f, -0.20682278f, -0.08454978f, 0.02300185f, 0.07626399f, 0.09333880f, 0.02989800f, 
    0.01975749f, -0.09793553f, 0.06393798f, 0.22935607f, -0.04103583f, 0.22825471f, 0.32865173f, -0.18720560f, 
    0.26305395f, 0.03875300f, -0.02844206f, -0.03610623f, -0.00544908f, 0.04841345f, -0.11159138f, 0.20479862f, 
    0.09223862f, -0.13528562f, -0.13099377f, -0.15893407f, 0.40742218f, 0.07257548f, 0.39650670f, -0.12364772f, 
    0.16734956f, 0.28080255f, 0.15614498f, -0.16056003f, 0.01591352f, 0.11063600f, -0.26308718f, 0.05131971f, 
    -0.09254916f, 0.15500784f, 0.10626483f, 0.08377090f, -0.07558054f, 0.19080994f, 0.02094865f, -0.08425048f, 
    -0.23598424f, -0.03297055f, 0.31096837f, -0.18102275f, -0.10505892f, -0.01364885f, 0.11734679f, -0.08368156f, 
    -0.06624411f, -0.22512515f, 0.80426711f, -0.10754796f, -0.24559444f, 0.10298191f, -0.25103831f, 0.27787003f, 
    -0.13219625f, 0.04091376f, -0.21713367f, 0.29411522f, 0.20633389f, 0.16395715f, 0.33511522f, -0.15997913f, 
    0.19389437f, -0.08135512f, -0.03721483f, -0.12379894f, 0.19878194f, 0.44318980f, -0.04202653f, 0.05406814f, 
    -0.21769379f, -0.03197305f, -0.46607691f, -0.47476831f, 0.13451561f, 0.02116961f, -0.06014956f, 0.24703154f, 
    0.01817082f, -0.02572358f, 0.24121045f, -0.10198501f, 0.31296059f, 0.29049587f, -0.36663115f, -0.07087360f, 
    0.17299442f, -0.62030244f, 0.32713407f, 0.26223665f, 0.31192720f, -0.06842618f, 0.21302591f, 0.06608640f, 
    -0.01530160f, -0.08905590f, 0.12213009f, -0.19030035f, -0.01890248f, 0.01003108f, 0.47113568f, -0.38582680f, 
    0.14122292f, -0.07615666f, 0.52095228f, 0.03119524f, 0.02783633f, 0.02992237f, -0.05829862f, 0.27975705f, 
    -0.29464665f, 0.09569070f, -0.11285204f, 0.01838616f, 0.30718195f, 0.05545179f, -0.30237913f, -0.10499465f, 
    0.19201817f, 0.42138427f, -0.03291802f, 0.04906163f, 0.12855960f, 0.01246888f, 0.18946071f, -0.14546739f, 
    0.21491073f, -0.01812854f, -0.11787225f, -0.01218188f, -0.01039753f, -0.09239843f, 0.43779811f, 0.14912654f, 
    -0.21834303f, 0.05423455f, 0.01256087f, -0.11082669f, 0.04130144f, 0.03692942f, -0.00219323f, -0.00174116f, 
    -0.17544167f, -0.17709602f, -0.17026187f, -0.02960262f, -0.08842942f, -0.09661619f, 0.05893930f, -0.13440624f, 
    0.12942135f, 0.09516408f, 0.11297337f, 0.08071338f, 0.04672578f, 0.09772079f, -0.15549015f, -0.10023991f, 
    -0.16845539f, -0.08823746f, 0.14574970f, -0.00443308f, -0.17079222f, 0.06603072f, -0.22239785f, 0.07356676f, 
    0.06339015f, 0.09151779f, -0.18702756f, 0.25177565f, 0.12660797f, 0.15322767f, 0.18892588f, 0.06287130f, 
    -0.11846486f, 0.11907156f, -0.52064437f, -0.14613110f, -0.47519523f, -0.48446044f, -0.02779080f, 0.26426557f, 
    -0.31528059f, -0.02171349f, 0.01840075f, -0.14163385f, -0.21282327f, -0.07523145f, 0.12991102f, 0.15743738f, 
    -0.16263604f, 0.12075625f, -0.12429537f, 0.18660505f, 0.24762163f, -0.03650857f, -0.36980358f, 0.06565303f, 
    -0.09506068f, 0.07129801f, -0.30864987f, -0.37785265f, 0.15059578f, -0.15083134f, 0.22877148f, 0.36844486f, 
    -0.01448290f, 0.19531932f, -0.35231796f, -0.02775793f, 0.47656474f, -0.12993227f, 0.04781260f, 0.10667863f, 
    -0.28394493f, -0.05842287f, 0.43679926f, -0.32862303f, 0.15790014f, 0.07252684f, 0.18255584f, 0.04378716f, 
    -0.26927239f, -0.02875155f, 0.17835139f, -0.12773797f, 0.24874674f, 0.18077701f, -0.10739370f, -0.15990530f, 
    0.01080106f, -0.03246551f, 0.12328162f, -0.17573322f, -0.11867119f, 0.05688023f, 0.02781488f, 0.04511964f, 
    -0.12875423f, -0.18453325f, 0.12080197f, -0.06544153f, -0.08910053f, -0.00878799f, -0.09609036f, -0.06632143f, 
    -0.14787923f, 0.04275742f, -0.07972828f, -0.18011558f, -0.10575965f, -0.15229543f, -0.05121346f, 0.04425548f, 
    0.03890343f, -0.15230353f, 0.10774633f, 0.00554093f, 0.01799928f, -0.16039647f, -0.01010692f, 0.06737091f, 
    -0.41158631f, -0.00686519f, 0.26586887f, -0.09169404f, 0.15177689f, 0.15443721f, 0.05002483f, -0.12839626f, 
    0.10001402f, 0.21603580f, 0.20652698f, 0.07625085f, 0.25863433f, 0.20324101f, -0.16451314f, 0.28961480f, 
    0.02236135f, 0.53968328f, -0.33977702f, 0.57459080f, 0.09362679f, 0.09828129f, -0.07750646f, -0.01447971f, 
    0.14476296f, -0.07937687f, -0.05778074f, 0.33879265f, 0.06431312f, 0.06050717f, -0.13887653f, 0.14506139f, 
    0.28318387f, 0.14308472f, -0.10686389f, -0.41161782f, -0.13423127f, 0.01347971f, -0.07203466f, -0.02753908f, 
    0.27684191f, 0.19623156f, 0.37095311f, -0.12884749f, -0.21641852f, -0.01398066f, 0.03277289f, 0.37112474f, 
    -0.42287779f, -0.37001148f, 0.51298815f, 0.13089423f, 0.27935597f, -0.02528168f, -0.00194130f, 0.07801199f, 
    -0.06760555f, 0.14251044f, -0.03649237f, -0.10280053f, 0.14722426f, -0.20991969f, -0.54905665f, -0.53779501f, 
    0.12598103f, -0.15094550f, 0.00230186f, -0.15373363f, -0.13011077f, 0.16862211f, -0.11578666f, -0.21707158f, 
    0.03789694f, -0.15493459f, -0.16005544f, 0.03730706f, -0.04773090f, -0.05213438f, -0.06954570f, -0.14348204f, 
    -0.03941499f, 0.13939756f, -0.12039489f, -0.09084255f, -0.17973433f, -0.02509782f, 0.10903466f, -0.01030061f, 
    0.11324795f, 0.08177308f, -0.14793941f, 0.14437838f, -0.10303710f, -0.01052066f, -0.03151548f, 0.11623637f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14497972f, -0.08019977f, 0.09742060f, -0.10816301f, 0.25303894f, -0.00418345f, -0.15386197f, -0.04776746f, 
    0.05261434f, -0.01556011f, 0.05004228f, -0.03367657f, -0.05111611f, -0.17539425f, 0.27286667f, 0.21352357f, 
    -0.46956226f, 0.44970793f, -0.06595139f, -0.02714458f, 0.02859706f, 0.08120506f, 0.03374449f, 0.09328821f, 
    0.03079041f, -0.05093522f, 0.10375701f, 0.15702087f, -0.11529747f, 0.21531574f, 0.27841306f, -0.03896287f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.29257625f, 0.54605520f, 0.02800933f, 0.27578270f, -0.24545239f, 0.19054420f, 0.01411523f, 0.45557785f, 
    0.11867190f, 0.09973063f, 0.03409548f, 0.35584426f, -0.01179115f, 0.03492718f, -0.05612031f, -0.49346960f, 
    -0.27188849f, -0.13483232f, 0.06738025f, -0.20544189f, 0.17503613f, -0.11214738f, 0.37241662f, -0.08652852f, 
    -0.04922912f, -0.04807196f, -0.22277282f, -0.20383507f, 0.15849991f, 0.30053198f, 0.05511802f, 0.01056114f, 
    0.07485781f, 0.03067105f, 0.38907695f, 0.13390394f, 0.12785737f, -0.34009439f, 0.13881490f, -0.57126200f, 
    0.21592933f, 0.18977010f, 0.16256732f, -0.12511022f, 0.12601298f, -0.06318384f, 0.43018726f, -0.16291873f, 
    0.01678344f, 0.41538513f, -0.03880652f, 0.31985733f, -0.05306472f, -0.09108312f, -0.00933950f, 0.25011268f, 
    -0.00030574f, 0.14049645f, 0.21159354f, -0.20196463f, -0.09078575f, -0.07626920f, 0.12122396f, -0.16802675f, 
    0.08013070f, 0.02502843f, -0.08862308f, -0.08778419f, 0.24798232f, 0.05322168f, 0.07719205f, -0.03634223f, 
    -0.10648284f, -0.00743222f, -0.26962894f, -0.07628824f, 0.20126784f, -0.04244329f, -0.13347834f, 0.48011246f, 
    -0.20877682f, -0.11609809f, 0.33203164f, 0.35955372f, -0.30682662f, -0.24290054f, -0.03937019f, 0.34552348f, 
    -0.33284584f, -0.07050683f, 0.17560308f, 0.35897425f, -0.20287380f, -0.07344253f, 0.06045543f, -0.03541052f, 
    0.25705761f, 0.08379335f, -0.45293659f, -0.04622975f, 0.16928662f, -0.20880713f, -0.06883259f, 0.09543550f, 
    0.11770353f, -0.04102313f, -0.07290582f, 0.38818285f, 0.06293867f, 0.04531351f, 0.22837801f, 0.12810279f, 
    0.15678938f, -0.33909693f, 0.18459280f, -0.15463200f, 0.00460140f, 0.19444539f, 0.16754271f, -0.15554534f, 
    0.13943014f, -0.11545235f, -0.02442175f, -0.17213118f, 0.09493303f, -0.22256127f, -0.10568511f, -0.17386264f, 
    -0.19397138f, -0.07737244f, 0.10125124f, -0.22776304f, 0.23081145f, 0.28005430f, 0.16928431f, 0.69447094f, 
    -0.01989047f, -0.54176313f, -0.28418267f, 0.15141174f, -0.03290267f, 0.35793895f, 0.46811995f, -0.11840363f, 
    0.01643424f, 0.28319612f, -0.80313271f, 0.12984659f, -0.40338996f, -0.03829231f, -0.08194993f, 0.06498681f, 
    -0.43879083f, -0.07767756f, -0.01705664f, 0.20418426f, -0.15488893f, 0.16725893f, 0.48736221f, -0.15489465f, 
    0.54523087f, 0.18436627f, 0.51453614f, -0.07292219f, -0.01231890f, -0.01565490f, -0.02241577f, -0.03235504f, 
    -0.19000667f, -0.32068247f, 0.14303613f, 0.24778400f, 0.09093338f, -0.15133007f, -0.07465204f, -0.06196626f, 
    0.01617884f, 0.08281528f, 0.29969263f, -0.09442169f, -0.12439398f, -0.17827065f, 0.42646646f, -0.41958624f, 
    0.21752772f, 0.00356588f, 0.06668925f, -0.04993731f, 0.00361612f, 0.31500927f, 0.09399182f, -0.01577360f, 
    0.31029293f, -0.45347744f, 0.38523179f, -0.05437801f, -0.21200345f, -0.13490121f, 0.02021227f, 0.01393790f, 
    -0.55253196f, 0.15276253f, 0.14015263f, 0.22625147f, 0.10521748f, -0.61798972f, 0.08342072f, 0.06685410f, 
    0.01324592f, -0.13724609f, 0.01834098f, 0.35709217f, -0.00448704f, -0.30400220f, 0.08490375f, 0.01278299f, 
    -0.19777741f, 0.06776536f, 0.31299525f, -0.16108795f, -0.18447351f, 0.12506571f, 0.01815843f, 0.14900762f, 
    0.29160762f, 0.13608098f, 0.01005072f, 0.32299685f, -0.15278883f, -0.16625705f, 0.01536990f, 0.06114933f, 
    -0.38965249f, -0.10305329f, -0.15195644f, 0.32503912f, 0.16297296f, 0.00255126f, 0.29440287f, 0.14890583f, 
    -0.15903977f, -0.10881419f, 0.31990585f, 0.03273664f, -0.41216439f, -0.41029194f, 0.14738016f, 0.25222898f, 
    -0.29126325f, -0.05589290f, 0.07782471f, -0.34324750f, -0.07684600f, 0.13286217f, -0.10490531f, 0.16695727f, 
    0.06470218f, 0.29843712f, -0.01881367f, 0.28627586f, 0.00356330f, 0.10886818f, -0.15027647f, 0.42639980f, 
    0.11024706f, 0.17891590f, -0.55230469f, 0.38187015f, 0.00219232f, -0.28293040f, 0.07356796f, -0.22260006f, 
    0.09335005f, -0.20374633f, 0.40520543f, -0.00790726f, 0.23804502f, -0.28931835f, -0.04593439f, 0.27360407f, 
    0.17422555f, 0.09691865f, -0.10564175f, -0.28124553f, -0.06715675f, 0.27421361f, 0.00602224f, 0.04864806f, 
    0.20184076f, -0.28237411f, 0.02312389f, -0.03685113f, 0.08238942f, -0.11875492f, 0.04719470f, -0.51842892f, 
    0.05055883f, -0.13586044f, 0.71661001f, 0.14464709f, 0.24011305f, -0.09691279f, -0.30497178f, 0.42723450f, 
    0.02254190f, 0.39113277f, 0.41559669f, -0.25837377f, 0.14977138f, -0.55307025f, 0.25514898f, 0.08457581f, 
    0.48095518f, 0.06692079f, 0.11492383f, 0.11269908f, 0.01846408f, 0.07410058f, -0.11388610f, 0.07111748f, 
    0.06484958f, -0.13967605f, 0.07261778f, -0.16886809f, 0.08916766f, 0.05916253f, -0.02463593f, -0.12451088f, 
    0.07448276f, -0.13143051f, 0.09847455f, -0.12016641f, -0.01245752f, -0.15664943f, -0.11918578f, -0.10264252f, 
    -0.00879325f, 0.01024535f, 0.00430236f, -0.20819421f, 0.07146710f, -0.04124407f, 0.06839971f, 0.07066553f, 
    -0.07234966f, 0.11432108f, -0.05321985f, -0.11544666f, -0.09815244f, -0.12121384f, -0.06361330f, 0.16221970f, 
    0.11409853f, -0.50005519f, 0.13866891f, -0.13617709f, 0.04730577f, 0.10892221f, -0.03055442f, -0.24968675f, 
    -0.04269345f, 0.06065106f, 0.27070680f, 0.08238224f, 0.05717700f, -0.42239493f, -0.24151607f, 0.26656616f, 
    -0.02536919f, 0.34119540f, -0.06659608f, -0.19823748f, 0.23720953f, -0.17756186f, -0.15011676f, 0.40361953f, 
    0.25590587f, 0.13229999f, 0.07093909f, 0.17339763f, 0.08038063f, 0.01059092f, 0.02443530f, -0.06576123f, 
    -0.10440061f, 0.16700862f, -0.00897429f, -0.15987152f, -0.03978019f, -0.11488845f, -0.01335141f, 0.11753632f, 
    0.09439462f, 0.07239655f, -0.13611546f, -0.07888879f, -0.17282069f, 0.08802558f, -0.09413546f, -0.06574054f, 
    -0.14592154f, -0.12074523f, -0.15004407f, -0.12637517f, 0.00875078f, -0.08684415f, -0.09668635f, -0.19164605f, 
    0.05518738f, -0.08697230f, 0.07362080f, -0.01582251f, -0.15385629f, -0.00570277f, -0.02911510f, 0.02764882f, 
    -0.06220741f, 0.19731332f, -0.14539459f, 0.28836727f, -0.05806735f, 0.07099235f, 0.08246909f, -0.23883373f, 
    0.42162475f, -0.31998318f, 0.47458759f, 0.02927220f, 0.10857362f, 0.35464111f, -0.24191497f, -0.18633860f, 
    -0.28506562f, 0.37577415f, 0.22286311f, -0.32420439f, 0.16393310f, -0.18786334f, 0.36112782f, 0.42379621f, 
    0.27464265f, -0.04178454f, -0.10878161f, 0.00779604f, 0.04220724f, 0.04681970f, -0.05251538f, 0.13118525f, 
    0.04246286f, 0.00327426f, 0.03009803f, -0.18158795f, -0.07210400f, -0.15578789f, -0.02994976f, 0.09550751f, 
    -0.22626011f, 0.06275690f, -0.11619407f, -0.17950614f, -0.06677890f, -0.08313279f, -0.17835909f, -0.10365762f, 
    0.18635046f, -0.19189397f, -0.05007049f, 0.12113845f, -0.22498198f, 0.14209893f, 0.03465090f, -0.08850055f, 
    -0.14048430f, 0.10928252f, -0.06819171f, 0.06650566f, 0.04427309f, -0.01988719f, -0.22245891f, -0.01469172f, 
    -0.18058050f, 0.15948023f, -0.20790385f, 0.16053344f, -0.11714715f, 0.17191017f, 0.04661649f, 0.26454660f, 
    0.21088250f, -0.01564919f, -0.26313367f, 0.18468396f, -0.10882059f, 0.06545264f, 0.05932524f, -0.13495165f, 
    -0.12689395f, 0.07967935f, -0.00589639f, -0.33184385f, 0.13488744f, -0.30991098f, 0.16416427f, 0.46839651f, 
    0.35807705f, 0.15192382f, -0.41268009f, -0.13614652f, 0.14943086f, 0.03834460f, 0.11913792f, 0.03397387f, 
    0.05368027f, -0.21737529f, 0.12208137f, -0.31188315f, 0.04626472f, -0.10826462f, 0.02463916f, 0.24916619f, 
    -0.09462821f, -0.30118814f, -0.11290395f, 0.17440061f, -0.03030824f, -0.21150064f, 0.34463516f, 0.22253141f, 
    -0.04695739f, 0.22801457f, -0.69978565f, 0.37204280f, -0.11275329f, -0.29259157f, -0.04575380f, -0.52828330f, 
    -0.15846731f, 0.16506191f, 0.27558163f, -0.07690432f, -0.12075140f, 0.08936808f, 0.19547679f, -0.21767631f, 
    -0.15926260f, -0.16843261f, 0.06548437f, -0.18678662f, -0.11141186f, -0.01848850f, -0.15000838f, -0.07962724f, 
    -0.17102601f, -0.21706979f, 0.07700817f, -0.02620977f, -0.05205734f, -0.10275647f, -0.17196710f, 0.13983592f, 
    -0.05150751f, -0.19034077f, -0.00053973f, 0.03533779f, 0.09073396f, 0.05781641f, -0.19891495f, -0.00589832f, 
    -0.21594094f, -0.12954430f, -0.10150126f, 0.10749584f, -0.07186238f, -0.10937434f, 0.13308349f, 0.06738994f, 
    -0.11043131f, -0.07016487f, -0.04090335f, -0.20306309f, -0.20147739f, -0.12422794f, 0.09042168f, -0.01461016f, 
    0.05880799f, -0.13494605f, -0.17557760f, -0.04773518f, 0.09061714f, -0.11340749f, -0.04823937f, 0.05883245f, 
    0.09140067f, 0.06447848f, -0.11054835f, 0.00271143f, -0.00567509f, 0.07940151f, 0.01302382f, 0.04503117f, 
    -0.04092679f, -0.03402599f, 0.01103265f, -0.15998548f, -0.04726250f, -0.00219016f, -0.07853431f, 0.11768215f, 
    -0.05873282f, -0.27365229f, 0.07513238f, -0.06205580f, 0.29401854f, 0.08737779f, 0.11111627f, -0.32123116f, 
    -0.04316332f, 0.07857700f, -0.01143061f, -0.25044003f, -0.17496507f, -0.20506844f, 0.20138533f, 0.45858285f, 
    -0.08427744f, 0.25349909f, -0.06220843f, 0.46894011f, 0.00912078f, 0.22768463f, -0.28237894f, 0.00099842f, 
    0.10822245f, -0.01515690f, 0.44874385f, 0.24912143f, -0.05903191f, -0.04286450f, 0.23788372f, -0.06162718f, 
    0.13375650f, -0.04744281f, -0.12806053f, -0.05837068f, 0.07342254f, -0.14750597f, 0.05459825f, -0.14519286f, 
    -0.00295970f, -0.06493093f, 0.01024332f, -0.08863639f, 0.00103974f, 0.13649115f, -0.17450601f, 0.07321353f, 
    -0.01955515f, -0.14381099f, -0.18343835f, -0.06558926f, 0.07420207f, -0.10336129f, -0.06006300f, -0.17439485f, 
    0.13800345f, 0.16109495f, -0.20347540f, 0.01588898f, -0.06808273f, -0.05422165f, 0.00533837f, 0.04453476f, 
    0.08387129f, 0.16569304f, 0.38884485f, 0.21868056f, -0.11852617f, 0.26073641f, -0.14991193f, 0.45759717f, 
    0.21395768f, 0.15220544f, -0.10137493f, 0.16562493f, -0.11568418f, 0.32689047f, 0.37551361f, -0.38770062f, 
    -0.20231405f, -0.12824430f, -0.13320147f, -0.06302954f, 0.14141943f, -0.09898574f, 0.14748010f, -0.20460588f, 
    -0.04913223f, -0.08443021f, -0.22065157f, -0.16004547f, 0.00431940f, 0.22672923f, 0.17252953f, -0.09777076f, 
    0.08617435f, -0.15267716f, -0.09225585f, -0.00745310f, 0.40704861f, 0.27305612f, -0.05960122f, -0.22956990f, 
    0.03833187f, -0.13773111f, 0.35384867f, 0.05885040f, -0.09024937f, 0.51656991f, -0.26720557f, 0.52598417f, 
    -0.19524296f, 0.12430770f, -0.07213110f, 0.01659295f, 0.09574210f, 0.13639615f, 0.22614303f, -0.16049665f, 
    -0.11309997f, 0.13639812f, 0.19770706f, 0.46500227f, -0.03240276f, -0.08091660f, 0.31783766f, 0.02096096f, 
    0.36783075f, -0.17467219f, 0.18555927f, 0.17306750f, -0.33654991f, -0.20139012f, -0.09598306f, 0.10156631f, 
    -0.43946591f, 0.15502712f, -0.14173040f, 0.36123636f, 0.09549213f, -0.47109666f, 0.12171441f, -0.03799798f, 
    -0.10607479f, -0.07301991f, 0.23446144f, 0.14102513f, -0.11818542f, 0.01005306f, -0.06179208f, -0.65337896f, 
    -0.05431669f, 0.10514645f, 0.20922193f, -0.22981296f, 0.16713975f, 0.34171963f, -0.03501612f, 0.00124857f, 
    -0.09923313f, -0.05661188f, 0.02286800f, -0.01405492f, 0.06583202f, 0.35695863f, -0.12283397f, 0.15996902f, 
    -0.13398474f, -0.02457272f, 0.25135797f, 0.11006331f, 0.01731607f, 0.30563158f, 0.13927603f, 0.03069702f, 
    -0.23944040f, 0.15696080f, -0.74045008f, -0.20372109f, 0.01826678f, -0.09285603f, 0.09050044f, 0.12608698f, 
    -0.28099498f, -0.03168418f, -0.11067516f, 0.07057752f, 0.06263656f, 0.09421872f, 0.34059423f, 0.12019082f, 
    0.00991048f, 0.07715594f, -0.13730705f, 0.15969335f, 0.11237032f, 0.11132853f, -0.01863426f, -0.01785249f, 
    -0.15809944f, 0.04495774f, -0.03559542f, 0.05995350f, -0.02937309f, -0.15543789f, 0.21353510f, -0.22126247f, 
    0.04572075f, -0.07872178f, -0.03270607f, 0.04179789f, 0.13210921f, 0.31267214f, -0.34200203f, 0.04152447f, 
    -0.10186347f, 0.01246085f, -0.42314294f, -0.09538107f, 0.05319510f, -0.14743756f, -0.20916045f, -0.05355250f, 
    -0.05829392f, 0.62364048f, 0.59922141f, 0.17209844f, -0.15908080f, -0.15775464f, -0.06192575f, 0.04328992f, 
    0.25464970f, 0.03461754f, -0.15693687f, 0.38539737f, 0.05837350f, 0.21035387f, 0.80006778f, 0.00175708f, 
    0.07059132f, 0.05598439f, -0.37184441f, 0.34315217f, -0.30998835f, 0.21358438f, 0.11133344f, -0.28685823f, 
    -0.06371213f, 0.01941554f, 0.02459192f, -0.01677916f, -0.00932690f, -0.08877747f, 0.28290012f, -0.07434529f, 
    0.33675534f, -0.04658383f, -0.04386009f, -0.07899559f, 0.25357333f, 0.29661924f, 0.09558468f, 0.38499025f, 
    -0.37893772f, -0.04184193f, -0.06647097f, -0.17036875f, -0.13920169f, 0.00515168f, -0.13475505f, 0.41206625f, 
    0.17558859f, -0.25036925f, 0.35173580f, 0.24967445f, -0.11250106f, 0.16522826f, 0.28499341f, -0.39528608f, 
    -0.48920041f, -0.07499523f, 0.39976770f, 0.04612715f, -0.05536200f, 0.12068374f, 0.14010289f, -0.11357082f, 
    -0.11930113f, -0.10881551f, -0.26563588f, -0.21336904f, 0.34432614f, 0.40224725f, -0.16512981f, 0.46492067f, 
    -0.04545520f, -0.70200652f, -0.17845398f, -0.04218543f, -0.05250175f, 0.43681651f, 0.11355131f, 0.28112754f, 
    -0.21125388f, 0.21154483f, -0.11455088f, 0.00999852f, -0.23156895f, -0.28723460f, 0.23557405f, 0.14021389f, 
    -0.30948284f, -0.00337426f, 0.22143276f, 0.30513081f, 0.15575743f, 0.11145642f, 0.38288981f, -0.09615060f, 
    0.26819175f, -0.49592918f, 0.10101067f, 0.04220806f, -0.16803266f, 0.24770589f, -0.06537912f, 0.55709434f, 
    -0.31139204f, 0.03488196f, 0.40669209f, -0.13363196f, 0.22770081f, -0.33776277f, -0.14150956f, 0.23339249f, 
    -0.31878275f, 0.14528915f, -0.18480721f, -0.06938175f, 0.46161100f, 0.00654403f, -0.27027380f, 0.39655107f, 
    0.27072343f, -0.15057339f, -0.13196786f, 0.20702448f, 0.09953731f, 0.23737501f, -0.22110334f, 0.17370367f, 
    -0.27242661f, -0.47278610f, -0.16177273f, 0.02611310f, 0.16486698f, 0.09012877f, 0.14994168f, -0.33278504f, 
    0.36891326f, 0.03550342f, 0.01431519f, -0.18680099f, -0.06624765f, 0.04562463f, 0.02671701f, 0.25208044f, 
    0.16869837f, 0.14095403f, 0.08369475f, 0.38451725f, -0.43051749f, 0.06072508f, -0.15954174f, 0.34106985f, 
    -0.04270537f, 0.12720817f, 0.21905264f, 0.14182922f, 0.04142985f, 0.06833316f, 0.41028512f, 0.16856107f, 
    -0.26700503f, -0.16930714f, 0.01357064f, -0.16426112f, -0.18006584f, -0.08980627f, -0.03443214f, -0.12326756f, 
    0.06086423f, -0.05040329f, -0.16638905f, -0.16353531f, -0.02779765f, 0.03765382f, 0.09151888f, 0.17744425f, 
    0.04039038f, 0.13598500f, -0.23409115f, -0.10204349f, -0.01119328f, 0.10303830f, -0.27059254f, -0.17368561f, 
    -0.07230137f, -0.06557411f, -0.08599081f, -0.11623517f, 0.05601858f, -0.29827937f, 0.11892755f, 0.13953045f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15404968f, 0.06286114f, -0.09187745f, -0.23010816f, 0.09826048f, 0.15216748f, 0.21079780f, -0.07980663f, 
    0.05506627f, 0.02279977f, -0.06228900f, 0.21644025f, -0.14174254f, 0.26525539f, 0.03820755f, -0.14765526f, 
    0.15136740f, -0.04212634f, -0.18890530f, 0.26999557f, -0.07432178f, -0.12213732f, 0.15110131f, -0.04161221f, 
    0.03369525f, 0.06005590f, 0.31954345f, 0.06953069f, 0.01058288f, -0.12151389f, 0.10434986f, -0.03193687f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.17011411f, 0.06187861f, -0.26607040f, -0.03184438f, -0.37983474f, 0.08547184f, 0.16965429f, 0.29609728f, 
    0.33602762f, -0.32141656f, 0.02521496f, -0.18418355f, -0.04093134f, -0.21496080f, 0.02953890f, 0.17809746f, 
    -0.11113600f, 0.01485429f, 0.13324682f, -0.25031522f, -0.08751368f, -0.01504330f, -0.80060804f, 0.17853856f, 
    -0.49998453f, -0.19069208f, 0.16936688f, -0.00971987f, -0.76621914f, 0.03531179f, -0.13716184f, 0.03095793f, 
    -0.15544248f, 0.20129853f, -0.28587672f, -0.11002702f, -0.82254571f, 0.12064328f, 0.41976660f, -0.00965794f, 
    -0.06153311f, 0.37063020f, -0.10633780f, 0.35381031f, -0.11070731f, 0.08199085f, -0.07300744f, 0.15427680f, 
    -0.01636609f, -0.13086036f, -0.09111137f, 0.25240326f, -0.11812595f, -0.30019623f, -0.08585922f, 0.25846401f, 
    -0.29373354f, -0.04865682f, -0.01990945f, -0.22002378f, -0.54383439f, 0.31580687f, 0.07678333f, -0.08161333f, 
    -0.33779556f, 0.40843704f, -0.07825837f, 0.06424812f, 0.37758616f, 0.04308356f, -0.22582231f, -0.90068066f, 
    -0.11836169f, -0.22811021f, 0.13853119f, 0.01952602f, -0.00503084f, -0.40222368f, -0.09888570f, -0.59780926f, 
    0.59206688f, 0.03991635f, 0.11179377f, 0.24371274f, 0.13103056f, -0.21695998f, -0.05495162f, -0.48336774f, 
    0.05850033f, 0.06143482f, 0.26928237f, -0.03838915f, 0.08930812f, -0.27620581f, 0.09597266f, -0.27272001f, 
    0.00371048f, -0.22044179f, 0.26807627f, -0.23153549f, 0.19751444f, -0.10389718f, 0.22735299f, 0.11610981f, 
    0.06041645f, -0.48050302f, 0.16065595f, -0.48218143f, -0.02836203f, -0.73189539f, -0.09320891f, -0.46514559f, 
    0.27567452f, -0.11451780f, 0.10648943f, 0.15800326f, -0.17035154f, -0.08017373f, -0.17177829f, 0.09612399f, 
    -0.07411470f, -0.75717288f, 0.14888102f, 0.35255435f, 0.15338430f, 0.06759321f, 0.01519502f, -0.28931618f, 
    0.11600245f, -0.28915143f, -0.76244193f, 0.00483939f, 0.05873472f, 0.09429239f, -0.00338074f, -0.03190856f, 
    0.22901513f, -0.23133606f, -0.02474483f, -0.14076732f, 0.09854902f, -0.12469633f, -0.06235581f, 0.31904149f, 
    0.04283540f, 0.00121772f, -0.11555249f, -0.18664531f, 0.04962079f, 0.13271323f, -0.06119622f, -0.03747164f, 
    0.01400969f, -0.05669283f, 0.12472612f, -0.01053996f, 0.04180530f, 0.17866310f, -0.42032513f, -0.08526388f, 
    0.12451868f, 0.18668838f, -0.30818230f, -0.18173869f, -0.36080706f, 0.20730996f, 0.00733145f, -0.06131731f, 
    -0.33554631f, 0.27611634f, 0.10185546f, -0.10071137f, -0.04541663f, 0.21572918f, 0.09878817f, -0.37685823f, 
    -0.11099016f, -0.11384815f, -0.02449046f, -0.11305252f, -0.14089061f, 0.03697976f, 0.17203222f, -0.17623615f, 
    0.07220701f, 0.17866617f, 0.25655988f, -0.00263503f, -0.11163943f, -0.21341977f, -0.14144833f, -0.27128696f, 
    -0.44673261f, 0.12408052f, -0.00017378f, 0.20430380f, 0.38335192f, -1.22651696f, -0.45163056f, -1.15726745f, 
    -0.59291011f, -0.34120703f, -0.05217174f, -0.18745637f, -0.17947237f, 0.18130955f, -0.11954632f, 0.04072759f, 
    -0.57395262f, -0.09015699f, -0.11918375f, 0.20493361f, -0.11502754f, -0.14926851f, 0.06378594f, -0.50740653f, 
    0.03338687f, 0.05319385f, 0.10919110f, -0.69804043f, 0.42491856f, -0.54299003f, 0.37088662f, 0.06358066f, 
    0.38339436f, -0.23871398f, -0.20050782f, -0.02322146f, 0.06553923f, -0.12977348f, -0.43297055f, -0.13327841f, 
    0.34108591f, 0.21171793f, -0.01020625f, 0.03975864f, -0.08479845f, 0.22994629f, -0.20417990f, 0.42625213f, 
    -0.57207477f, 0.04521330f, 0.06877761f, -0.53472006f, -0.00570178f, 0.01546099f, -0.25724000f, -0.45956090f, 
    0.09876084f, -0.14228293f, -0.45435351f, -0.32391438f, 0.22013639f, 0.03442746f, -0.15379094f, -0.09467745f, 
    -0.51706904f, -0.03492124f, 0.41746879f, -0.02884426f, -0.30771804f, -0.03082879f, -0.34719923f, -0.03505103f, 
    -0.31231239f, 0.27432215f, -0.09603853f, -0.02623589f, 0.05269429f, 0.06547577f, 0.01704047f, -0.30082551f, 
    -0.32003614f, 0.01870257f, 0.02708367f, 0.27564290f, -0.08291139f, -0.81359905f, 0.23206754f, -0.47545272f, 
    -0.11375037f, -0.00416313f, -0.46190411f, 0.24611156f, 0.24751329f, -0.32371676f, 0.33806807f, 0.01558424f, 
    0.24643020f, 0.15554987f, -0.67172670f, -0.41802296f, 0.30885360f, -0.02384457f, -0.60081524f, -0.33855140f, 
    0.21967648f, -0.61259598f, 0.11443458f, -0.01190190f, -0.18365923f, 0.09821998f, -0.11694720f, 0.08487736f, 
    -0.16527805f, 0.01208573f, 0.16623436f, -0.09957707f, 0.15816833f, 0.24828070f, -0.08784506f, -0.91029841f, 
    0.13860714f, -0.39970502f, 0.23294251f, -0.04021375f, 0.04613269f, -0.56311852f, 0.17937449f, -0.08666533f, 
    0.12935200f, -0.70370710f, -0.15837215f, -0.20215155f, -0.12987073f, 0.37271938f, -0.03875612f, -0.82448661f, 
    -0.11748147f, 0.27904636f, -0.10804459f, 0.07591776f, 0.05054497f, 0.06555819f, -0.14222109f, -0.44078654f, 
    -0.69173098f, -0.13850288f, -0.11288340f, -0.13513465f, -0.02438004f, -0.07660636f, 0.06562883f, -0.22968702f, 
    -0.20804462f, -1.20046818f, -0.73365188f, 0.37037843f, 0.13506906f, 0.32664075f, -0.30294335f, -0.32906663f, 
    -0.15401261f, -0.66854334f, -0.11667529f, -0.48736018f, 0.30992737f, -0.44163242f, -0.15712415f, -0.57798707f, 
    -0.64190906f, -0.09508736f, 0.04620704f, 0.21414092f, -0.09566177f, -0.11891408f, -0.08230122f, -0.07828876f, 
    -0.01898566f, 0.08148050f, 0.07682843f, -0.03207633f, -0.11129669f, -0.13943844f, 0.26538166f, -0.64651656f, 
    0.43426785f, -0.55922985f, -0.29487386f, -0.07052451f, 0.25997657f, 0.63806027f, -0.04438562f, -0.09293984f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15687808f, 0.34264722f, 0.11395967f, 0.06302638f, 0.10321645f, 0.08667682f, -0.19926839f, -0.05851956f, 
    -0.00753416f, 0.10418259f, -0.05934788f, -0.22665831f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
