#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34008440f, 0.05649183f, 0.44995296f, -0.37757099f, 0.15481299f, -0.16517967f, 0.11001291f, 0.18566297f, 
    0.38283512f, -0.18339379f, -0.16544755f, -0.32876155f, -0.18808366f, -0.21567643f, 0.65420008f, 0.16740239f, 
    0.09427876f, -0.07223324f, -0.27719152f, 0.03647085f, -0.36779693f, -0.40828189f, -0.08811438f, 0.11244771f, 
    -0.25505504f, -1.17363214f, 0.65105003f, 0.46160486f, -1.14103425f, 0.60969549f, 0.16071267f, -0.28801471f, 
    -0.21503229f, 0.55927873f, -0.12720248f, -0.49418318f, -0.09379403f, -0.00674159f, -0.46283513f, 0.09353528f, 
    0.35396555f, 0.03044425f, -0.34929439f, -0.24593081f, 0.43692136f, -0.05836633f, 0.36915198f, -0.12807520f, 
    -0.11003090f, -0.20150958f, 0.44128796f, -0.55768126f, -0.95866621f, -1.04913735f, -0.22234221f, -0.11744040f, 
    -0.54710782f, -0.54788995f, -0.12422878f, -0.28423858f, 0.44154581f, 0.61555350f, 0.64541417f, -0.27754840f, 
    -0.13326147f, -0.12764804f, 0.10747062f, -0.29782632f, -0.19263761f, 0.05535079f, -0.25211778f, -0.01543897f, 
    -0.14065355f, -0.17413531f, -0.43824938f, 0.47604382f, 0.39622676f, -0.54036129f, -0.22107831f, -1.01290941f, 
    0.51539415f, -0.33545774f, -0.11456796f, 0.46160272f, 0.20721717f, -0.27174094f, -0.56064719f, -0.24072218f, 
    0.03839010f, -0.03080918f, 0.09267730f, 0.15905571f, -0.27400452f, 0.00185005f, -0.35588017f, -0.38378161f, 
    -0.06183561f, -0.49461570f, -0.39215371f, -0.30781147f, 0.82690603f, -0.03417178f, 0.25290361f, 0.46140024f, 
    0.61583275f, -0.77258617f, -0.08510618f, 0.09610090f, -0.52713919f, -0.66752309f, -0.27252564f, 0.21127294f, 
    0.25922948f, -0.02710794f, 0.11457995f, 0.07014592f, 0.10027732f, 0.25001353f, 0.13667148f, -0.26112843f, 
    0.00439090f, -0.30011502f, 0.00555411f, 0.49021742f, -0.06882360f, 1.20487690f, -1.31927657f, -0.97495693f, 
    0.20247640f, -0.81457442f, 0.99934328f, 0.43087730f, 0.34633970f, -0.09720553f, 0.26342571f, 0.33003932f, 
    0.24249381f, -0.30625033f, -0.43365160f, 0.35110205f, -0.05295224f, -0.09807676f, 0.18048024f, -0.12996094f, 
    -0.15396245f, -0.03138025f, -0.08455640f, -0.10064615f, 0.14827946f, 0.06227944f, -1.21386409f, -0.41826209f, 
    0.64292747f, 0.16241553f, 0.42250189f, 0.39143378f, 0.92757791f, 0.55939078f, 0.07113531f, 0.13567081f, 
    0.28339946f, 0.05845202f, 0.03207399f, 0.16882297f, -0.12414075f, -0.29506880f, 0.33899736f, -0.19180767f, 
    -0.33243904f, 0.20901541f, 0.07000936f, -0.18066974f, 0.24251203f, -0.06960402f, -0.02228848f, 0.59019047f, 
    0.80475366f, 0.16223085f, -0.07788677f, -0.05135431f, 0.03839584f, -0.10197312f, 0.28245443f, 0.40240926f, 
    -0.30962798f, -0.00349528f, 0.70466757f, -0.17179763f, -0.49986583f, -0.26593956f, -0.24707940f, -0.00961280f, 
    0.14606740f, -0.22907509f, 0.03781021f, -0.26737282f, 0.09139437f, 0.10632537f, -0.03296311f, -0.06626352f, 
    -0.48169366f, -0.17210840f, 0.41818479f, 0.44138759f, 0.04933415f, -0.35642374f, -0.26839674f, 0.22062539f, 
    -0.17393836f, -0.03614795f, -0.03436023f, 0.41639346f, -0.36820003f, 0.21118887f, 0.06187579f, -0.14610229f, 
    -0.06530044f, 0.12947257f, -0.28201523f, 0.12933727f, 0.02529474f, 0.49875563f, 0.37297273f, 0.49299586f, 
    0.19783473f, 0.33660418f, -0.41487879f, -0.25197816f, 0.08458330f, -0.04377591f, 0.49077019f, 0.26153588f, 
    0.51208735f, -0.17517276f, -0.79304373f, -0.22749589f, -0.14760473f, 0.23689105f, -0.21736348f, 0.02488333f, 
    -0.41587275f, -0.16487151f, -0.00790265f, 0.02191633f, 0.26033321f, 0.21194828f, 0.33524817f, -0.10965799f, 
    -0.37153926f, 0.42473534f, -0.79588503f, 0.54378325f, -0.53491235f, -0.14832291f, 0.89962387f, -0.25311080f, 
    0.72806716f, -0.25606513f, -0.20855999f, 0.00206357f, 0.39785799f, 0.56996787f, -0.43055362f, -0.05321765f, 
    -0.35020548f, 0.26238918f, -0.04902979f, -0.29038233f, -0.14675042f, -0.43667200f, 0.03215956f, 0.15894566f, 
    0.16476843f, 0.04819523f, -0.16804279f, -0.49037889f, -0.45305124f, -0.17553577f, 0.46351755f, 0.10402545f, 
    -0.83744222f, -1.01294565f, -0.31816667f, -0.11088654f, -0.61069626f, 0.26328331f, 0.05801395f, -0.25146958f, 
    -0.02144616f, -0.41992715f, -0.01181119f, -0.08876669f, 0.13939795f, -0.27586088f, -0.44704834f, -0.22640835f, 
    0.21020858f, 0.18245722f, -0.25894010f, 0.37131456f, -0.85429025f, -0.32421505f, -0.89490801f, -0.85088116f, 
    -0.18760815f, 0.13546591f, -0.18388210f, -0.36950570f, -0.45805803f, -0.11550117f, -0.26869702f, -0.32956478f, 
    -0.14742367f, -0.43541998f, -0.36582834f, 0.31598750f, 0.07562347f, 0.03097792f, 0.35867301f, 0.08935770f, 
    0.02548855f, -0.08921753f, -0.20501207f, -0.20404458f, -0.08684184f, -0.66955966f, -0.51120263f, -0.09965862f, 
    -0.01676830f, 0.40743405f, -0.57926559f, -0.57585043f, 1.03215945f, -0.69622386f, -0.80173111f, 0.26810220f, 
    0.65447885f, -0.14376846f, 0.59619302f, -0.31899774f, 0.30100861f, -0.29909298f, -0.29895240f, -0.26801097f, 
    -0.11331160f, 0.01681849f, -0.03860908f, -0.08759359f, 0.23795737f, -0.38505518f, -1.13006890f, -0.57433498f, 
    -0.12933975f, 0.00083535f, -0.30389625f, 0.44689548f, -0.07606093f, -0.46002001f, 0.26234877f, 0.59472799f, 
    0.16430180f, 0.02815853f, 0.05630670f, 0.59015137f, -0.11649487f, -0.22217847f, -0.24673977f, -0.40231273f, 
    -0.00680830f, -0.13108276f, 0.47792950f, 0.23844507f, 0.20824665f, 0.35253829f, 0.31874621f, -0.78115386f, 
    -0.49174696f, -0.19649425f, 0.13255531f, -0.83684897f, -0.37979367f, -0.16540487f, -0.77946645f, -0.87293541f, 
    -0.44604298f, -0.23478930f, -0.01491692f, -0.41520485f, -0.49598804f, -0.41476336f, -0.24528770f, 0.15742633f, 
    -0.41210696f, -0.32535776f, -0.32764000f, 0.10385452f, 0.04636864f, 0.02609355f, -0.03117477f, 0.22024305f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30164370f, 0.50728536f, 0.57644528f, 0.13430159f, 0.16350542f, 0.31812155f, 0.03606577f, 0.42854384f, 
    0.40508255f, 0.34200343f, 0.32075855f, 0.33940020f, -0.04356247f, 0.45919791f, 0.23600779f, -0.38819906f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.31189391f, -0.15036574f, -0.00796137f, -0.10659848f, -0.07210644f, -0.04437284f, -0.17270407f, 0.08527691f, 
    -0.17315128f, -0.08804257f, -0.00171567f, -0.04735696f, -0.24119738f, 0.11186782f, 0.44649640f, -0.17789854f, 
    0.19358481f, 0.09519098f, 0.25050771f, 0.10764659f, 0.04711985f, 0.05998297f, 0.06124728f, 0.08211569f, 
    0.44124186f, 0.00845165f, 0.04495602f, -0.07613002f, 0.17910179f, 0.10236803f, -0.13868408f, -0.00735393f, 
    -0.04621278f, -0.18030927f, 0.05277933f, -0.12836906f, -0.09679738f, -0.35411480f, -0.27833566f, -0.20755459f, 
    -0.01368041f, 0.11639822f, 0.08621433f, 0.07187515f, 0.07654180f, -0.10185379f, -0.05565356f, -0.20270416f, 
    0.13209386f, -0.13827230f, 0.07398798f, 0.04925982f, 0.20642695f, 0.27626508f, -0.21321721f, 0.05940312f, 
    0.02380515f, -0.02197122f, 0.07363136f, 0.04875989f, 0.01705847f, -0.25458163f, -0.95575345f, 0.19430326f, 
    0.08494782f, 0.13322295f, -0.04625919f, 0.02044804f, 0.27467224f, 0.02301381f, -0.20080647f, -0.10500041f, 
    -0.21817473f, -0.18488944f, -0.12253270f, -0.08949966f, -0.10474892f, -0.15179406f, 0.04983836f, -0.03923551f, 
    0.26270738f, 0.10435151f, 0.18320681f, 0.17365636f, 0.11589129f, 0.11244334f, -0.24901171f, 0.20341718f, 
    0.00000222f, -0.04097536f, -0.04094492f, 0.06116728f, -0.02926535f, -0.07058879f, 0.15596034f, -0.01581800f, 
    0.08957264f, 0.04794024f, 0.15170383f, 0.02966706f, 0.09879394f, 0.33963025f, -0.03251605f, -0.01949447f, 
    0.03739651f, 0.03383662f, 0.03994970f, 0.11180765f, -0.05294169f, -0.45592141f, 0.09762637f, 0.14267036f, 
    -0.20578656f, -0.02442066f, 0.10797174f, -0.08404157f, -0.06655346f, 0.03475329f, 0.10279393f, 0.14604668f, 
    -0.48588261f, 0.59586078f, 0.14185728f, 0.07144305f, -0.07824318f, 0.02124910f, -0.05975916f, 0.05530604f, 
    0.00336083f, 0.07683247f, -0.00544446f, 0.33076429f, 0.44949359f, 0.31036034f, 0.40014458f, -0.06418195f, 
    -0.02274567f, 0.13971071f, 0.17248432f, -0.00740827f, 0.01124536f, 0.09382618f, 0.03024671f, 0.09398258f, 
    0.19095035f, 0.28079873f, 0.04492468f, -0.12920183f, 0.16448703f, 0.20324072f, 0.04586139f, 0.09197293f, 
    -0.08395812f, -0.01295191f, 0.11423554f, 0.02471559f, 0.64222234f, 0.14197557f, 0.53221536f, 0.07165767f, 
    0.03532950f, -0.03416310f, -0.12875201f, -0.13037570f, 0.17928387f, 0.10085951f, 0.03258622f, 0.12255201f, 
    -0.17903590f, 0.08185435f, -0.24210550f, -0.37677002f, 0.03325884f, 0.07063820f, 0.18047735f, -0.20897497f, 
    0.02534744f, 0.07207169f, -0.01730725f, -0.12715191f, 0.31237832f, 0.18229234f, 0.07734793f, -0.05163741f, 
    0.22642292f, 0.39387336f, 0.26932487f, 0.17647842f, 0.04094053f, 0.01085825f, 0.24900398f, 0.25685745f, 
    -0.21929555f, 0.23820530f, -0.45175335f, -0.30371547f, -0.07126145f, 0.02691670f, 0.15114273f, 0.16201110f, 
    0.05325817f, 0.05015077f, 0.16910505f, 0.21361305f, -0.44491065f, -0.13570409f, 0.18321168f, -0.11533315f, 
    0.18635693f, 0.13780093f, 0.27236995f, 0.10239045f, 0.11200598f, -0.21155445f, 0.08960287f, 0.06790985f, 
    0.05613325f, 0.11453454f, 0.39919487f, -0.20970213f, -0.00397410f, 0.05890003f, -0.14012870f, -0.06554116f, 
    0.06294962f, -0.00177481f, 0.04598563f, -0.05286637f, 0.11151855f, 0.11297434f, -0.49253309f, -0.05162929f, 
    -0.14875901f, -0.10441108f, 0.11746462f, 0.11055501f, 0.00576844f, 0.02691177f, 0.02509358f, -0.03379726f, 
    0.35356972f, -0.36630762f, -0.02321699f, -0.25372487f, 0.46343049f, 0.13313699f, -0.05121958f, 0.20739843f, 
    -0.13504578f, -0.04242386f, 0.03956791f, -0.06107200f, -0.11650827f, 0.05923491f, -0.08963347f, 0.10220581f, 
    0.01570854f, 0.00553710f, -0.09313183f, 0.27891409f, -0.12950972f, -0.06947017f, -0.02624408f, -0.08174974f, 
    -0.38907757f, -0.06562871f, 0.19569454f, 0.40338853f, -0.06532765f, -0.07234900f, -0.05635561f, 0.01562149f, 
    0.08185180f, 0.17619017f, 0.16157724f, 0.03999036f, 0.26500493f, -0.04466722f, -0.37761745f, 0.15937854f, 
    -0.03117475f, 0.20188126f, -0.07721087f, -0.10759295f, 0.11507867f, -0.10753644f, 0.32296377f, -0.06714973f, 
    -0.06500497f, -0.05953086f, 0.17845938f, 0.10960109f, -0.08066773f, 0.15036027f, 0.09842856f, 0.09471218f, 
    -0.02488578f, -0.01527344f, -0.08251633f, 0.00285052f, -0.33049729f, -0.18053868f, 0.38095978f, -0.00498621f, 
    0.00106481f, 0.04486943f, -0.23503834f, -0.12714720f, -0.02495278f, 0.02379342f, 0.18523428f, 0.08600385f, 
    -0.38050452f, 0.39872661f, 0.32787579f, 0.29999229f, 0.07105340f, 0.17077383f, -0.07178754f, 0.13914742f, 
    0.03557947f, 0.07313839f, 0.13387230f, 0.06491075f, -0.08685099f, -0.04069818f, 0.26710001f, 0.14830868f, 
    -0.13415845f, 0.14206752f, 0.15456954f, -0.08936221f, -0.06170006f, -0.00991639f, -0.08254208f, -0.05598312f, 
    -0.32865691f, -0.13329664f, 0.20971641f, -0.21358994f, -0.02228802f, -0.00419135f, -0.00426435f, 0.00941125f, 
    -0.16890843f, -0.06344637f, -0.08417694f, -0.07274351f, -0.08900870f, 0.12648951f, 0.61524898f, 0.09108789f, 
    0.02674987f, 0.04536704f, -0.13970606f, -0.07305434f, 0.12553191f, -0.02220767f, 0.03243022f, 0.11186925f, 
    0.04505210f, 0.22905794f, -0.06166613f, 0.08388539f, 0.02176555f, -0.01956585f, 0.11068023f, -0.16656087f, 
    0.02568925f, 0.06108593f, -0.25995165f, -0.15889363f, -0.13586128f, -0.10821372f, 0.09913342f, 0.21064924f, 
    -0.06773283f, 0.20327614f, 0.09806260f, 0.02730384f, 0.04274170f, 0.00093412f, 0.11416093f, 0.02589091f, 
    -0.10942508f, 0.09403691f, 0.18542880f, 0.08331979f, 0.05496151f, 0.02990904f, 0.05708497f, -0.09926309f, 
    -0.09620333f, 0.23965771f, 0.23742597f, -0.05674105f, -0.34629017f, 0.06743097f, -0.41863546f, 0.25914046f, 
    -0.22399217f, -0.21655443f, 0.07261149f, 0.00297134f, -0.04344955f, -0.05611248f, 0.02868290f, -0.07185483f, 
    0.42531070f, 0.27294484f, 0.02926508f, 0.25840706f, 0.06890514f, 0.15699646f, -0.17297077f, 0.16074257f, 
    -0.00396161f, -0.10523527f, -0.03844301f, 0.07574977f, -0.10330306f, 0.33817190f, -0.13516174f, 0.07147520f, 
    0.13468993f, 0.03922666f, -0.12440272f, -0.00667542f, -0.12351510f, -0.29237750f, -0.26282787f, 0.03556907f, 
    -0.12842308f, -0.02008587f, -0.02518628f, -0.07104892f, -0.05473413f, -0.00687623f, -0.20938936f, -0.37243843f, 
    0.08447892f, 0.02349267f, 0.16200924f, -0.00854824f, 1.22981858f, -0.00076891f, -0.48004937f, -0.08336879f, 
    -0.04399937f, 0.01020886f, -0.05720520f, -0.28516346f, 0.03448562f, 0.09716521f, -0.11563565f, -0.06695719f, 
    0.29974812f, -0.04421188f, 0.22875407f, 0.08797439f, -0.01153083f, -0.10349746f, 0.05060803f, 0.10576627f, 
    0.06814872f, 0.14726481f, 0.12280654f, -0.03921186f, 0.14423358f, -0.12940234f, 0.08683442f, -0.12858540f, 
    0.05089241f, -0.09604313f, 0.12537985f, -0.05310535f, 0.07699237f, 0.03270816f, 0.04031552f, 0.07794853f, 
    -0.04071221f, 0.03209904f, 0.16649817f, 0.10008712f, 0.11064678f, 0.13236535f, 0.06970519f, 0.09407862f, 
    -0.09815425f, -0.08631327f, 0.11574320f, 0.21352443f, 0.34254363f, 0.18178423f, 0.12091262f, 0.35794663f, 
    -0.01932444f, -0.09567327f, -0.06662390f, 0.05042979f, 0.06133532f, 0.16901347f, 0.00769068f, 0.01361109f, 
    -0.00725355f, -0.40213752f, 0.54731798f, 0.08727480f, -0.21226266f, -0.00623530f, 0.09240897f, -0.03334035f, 
    0.00245379f, 0.05035880f, -0.20123528f, 0.07023145f, -0.12081641f, 0.29018599f, -0.14629242f, -0.14361107f, 
    0.06463622f, 0.21619584f, 0.18046397f, -0.03579015f, -0.07128068f, -0.01181372f, -0.10626815f, 0.07478189f, 
    0.15841548f, 0.14933011f, -0.07434270f, 0.10874034f, 0.03915458f, 0.14708644f, -0.20070823f, -0.03960316f, 
    -0.06206416f, -0.05793983f, -0.01125415f, 0.04652636f, 0.03047861f, 0.24412702f, 0.03888804f, 0.10518032f, 
    -0.28928721f, 0.15929635f, 0.14014746f, -0.02201018f, -0.00127589f, 0.02445024f, -0.02172475f, 0.07304571f, 
    0.13407934f, 0.56618595f, -0.08194991f, -0.11275649f, -0.12909280f, 0.11196533f, 0.14595821f, 0.30981785f, 
    -0.06312326f, -0.11424500f, 0.13149448f, 0.02931207f, 0.40695995f, 0.19732951f, 0.19520395f, 0.00118631f, 
    0.05194431f, 0.11337493f, 0.08227737f, 0.34972835f, 0.02077153f, -0.03560618f, -0.07673536f, 0.07192435f, 
    -0.13055342f, -0.10326818f, 0.18591283f, -0.03812840f, 0.11687690f, -0.20388135f, -0.11592203f, -0.20819452f, 
    0.08373673f, -0.03539724f, 0.22189900f, 0.04258579f, -0.04082572f, 0.18282841f, -0.06803228f, 0.53170699f, 
    0.13161761f, 0.00019831f, 0.14320131f, 0.10931135f, -0.04875227f, 0.22420876f, 0.01636279f, 0.06483419f, 
    0.12588932f, 0.16971323f, -0.22889116f, 0.19886658f, 0.01935973f, 0.22291435f, -0.03944986f, 0.09362462f, 
    -0.02942450f, -0.09416082f, -0.03280545f, 0.09234285f, 0.03183486f, 0.59800005f, 0.15767354f, 0.22863001f, 
    0.09239285f, -0.07495105f, 0.02930633f, -0.15026101f, 0.17892006f, -0.04155000f, -0.11965030f, 0.01255729f, 
    -0.50087106f, 0.03648143f, -0.31092516f, 0.04174108f, -0.38318074f, 0.07701154f, -0.27621058f, -0.22475587f, 
    0.10429236f, -0.20489122f, 0.20196384f, -0.04840286f, 0.51509762f, 0.69788671f, 0.34968033f, 0.39660540f, 
    -0.20661606f, -0.03727774f, -0.06414220f, 0.04159006f, 0.22087857f, -0.17214282f, -0.03448879f, 0.05257744f, 
    0.05007783f, -0.62141657f, 0.29545853f, -0.38141710f, -0.23673390f, -0.14297320f, -0.05418703f, -0.09998403f, 
    0.22758459f, 0.05806633f, 0.02208262f, 0.24394338f, -0.03209497f, 0.04253647f, 0.25113672f, -0.34995303f, 
    -0.12661394f, -0.16540368f, -0.00275462f, -0.26634470f, -0.00317903f, -0.06633846f, -0.06794222f, 0.01984976f, 
    -0.14805153f, -0.05990752f, -0.28624728f, 0.08115118f, 0.01329777f, 0.00777376f, 0.02117044f, 0.02493737f, 
    0.03066716f, 0.18516891f, 0.32084492f, 0.28182596f, 0.05090677f, -0.03638372f, 0.02381815f, 0.16190614f, 
    -0.18887611f, 0.10064319f, 0.17025472f, 0.06427212f, 0.29956514f, 0.07973899f, -0.03073156f, 0.22508273f, 
    0.18275021f, -0.59634072f, 0.15590355f, -0.12304077f, -0.09646555f, -0.17054176f, 0.12571520f, 0.17212741f, 
    0.07572765f, 0.13088471f, 0.10874462f, 0.16855806f, -0.28324944f, 0.18673117f, -0.57696575f, -0.29448372f, 
    0.18047562f, 0.02988853f, 0.03414173f, -0.00491662f, 0.03603053f, 0.05215779f, 0.01887327f, 0.14176397f, 
    -0.01629417f, -0.07986087f, -0.08998746f, 0.14329983f, -0.08831390f, 0.02618250f, 0.08663995f, -0.11577995f, 
    -0.06617673f, -0.23382565f, -0.10768981f, -0.18463761f, -0.11335573f, -0.20673984f, -0.05292833f, 0.01955637f, 
    -0.12360792f, 0.09289212f, 0.19238606f, 0.05970649f, 0.10848688f, 0.16375576f, -0.02630812f, 0.02409377f, 
    -0.15619710f, 0.09281258f, -0.02956168f, 0.02581982f, 0.07078215f, -0.02910467f, 0.20915903f, 0.30024084f, 
    -0.21936838f, -0.22613189f, 0.00798457f, -0.13385980f, 0.03048527f, -0.00777276f, 0.05606303f, -0.38422695f, 
    -0.08206291f, -0.14514376f, -0.06606922f, -0.12405724f, -0.05266304f, 0.04245050f, 0.09677097f, 0.07650861f, 
    0.01326390f, -0.24597640f, 0.00476079f, -0.06138261f, -0.12114459f, -0.17629890f, -0.18133578f, 0.22272860f, 
    0.15566893f, -0.06031767f, -0.19119407f, -0.01936192f, 0.18062046f, 0.12633047f, 0.48231164f, -0.05219144f, 
    0.24648347f, 0.28557619f, -0.00125750f, 0.30082503f, -0.04587959f, 0.09401135f, -0.10239460f, 0.18916915f, 
    0.14273436f, -0.05854135f, -0.41585922f, -0.05615961f, 0.10136578f, 0.04134799f, 0.04168079f, 0.03271182f, 
    -0.10459070f, 0.06851558f, -0.01101530f, -0.01452841f, -0.20398957f, -0.33132556f, 0.24005964f, -0.03528063f, 
    -0.09328894f, -0.01734296f, -0.00622388f, 0.12599130f, 0.13052170f, 0.04177647f, 0.15013419f, -0.02350395f, 
    0.08819819f, 0.04543340f, 0.06853574f, 0.19034663f, 0.04692687f, 0.00008083f, -0.01179149f, 0.09373190f, 
    -0.06024049f, 0.03232590f, -0.09404108f, 0.01770182f, -0.66804814f, -0.22849290f, -0.61711639f, 0.15347320f, 
    0.10761374f, -0.16687249f, 0.21392889f, 0.09364456f, 0.27026352f, 0.02404686f, -0.08967400f, 0.07085788f, 
    -0.27773097f, -0.02555922f, -0.38424599f, 0.03083123f, -0.14501673f, 0.04605210f, 0.05130910f, -0.00342358f, 
    0.07806506f, 0.02181315f, 0.04088164f, 0.14918484f, 0.29930484f, 0.27271780f, -0.09573311f, 0.36145967f, 
    -0.09455736f, 0.00691801f, -0.22118765f, 0.08300077f, -0.08283190f, -0.01352760f, 0.02575242f, 0.29365322f, 
    0.05351557f, -0.04197827f, 0.02744162f, -0.20348269f, -0.05829617f, 0.04967718f, 0.01954546f, 0.09893675f, 
    0.01867967f, 0.09552901f, -0.08408947f, -0.07964581f, -0.12390451f, -0.16542479f, -0.25018671f, -0.09065566f, 
    -0.05371024f, 0.10927413f, 0.09368555f, -0.09899197f, -0.20590897f, 0.19370049f, 0.06460833f, -0.00425161f, 
    -0.04279108f, 0.69387758f, -0.38516253f, -0.09294447f, 0.10579632f, 0.14476240f, -0.02776760f, 0.25107634f, 
    -0.03649582f, 0.01108367f, 0.16533104f, 0.23283717f, 0.45086363f, 0.13209338f, 0.24862140f, -0.06631403f, 
    0.16830069f, 0.01814683f, -0.00240996f, 0.01878193f, 0.04474574f, 0.00498465f, 0.03211741f, 0.00615830f, 
    0.19059411f, 0.34580457f, -0.01064430f, -0.06853943f, 0.18197943f, 0.15804482f, 0.07524559f, 0.03779280f, 
    -0.02653586f, -0.04758728f, -0.02872240f, 0.00730524f, 0.49623275f, -0.19918419f, -0.03008948f, -0.16261764f, 
    0.25697076f, 0.05759167f, 0.04372593f, -0.08027762f, 0.13835636f, 0.07809182f, 0.05183772f, 0.08383657f, 
    -0.30056790f, -0.44924495f, -0.04984076f, -0.16034870f, 0.30736968f, -0.00635493f, 0.17828919f, -0.00258744f, 
    0.09344405f, 0.12240449f, -0.12080567f, -0.17792977f, 0.19887751f, 0.23150316f, -0.15340436f, -0.28761607f, 
    0.20049548f, 0.07711110f, 0.17350465f, -0.09339112f, 0.05084866f, -0.07440379f, -0.22393897f, -0.10383178f, 
    -0.13753946f, -0.06741769f, -0.02140421f, 0.03492569f, 0.01368114f, 0.03568927f, -0.01420779f, 0.01320330f, 
    0.07682497f, -0.16502976f, 0.04186390f, -0.09262770f, 0.24665742f, 0.29419148f, 0.14269279f, 0.18727759f, 
    -0.10496401f, -0.01142143f, -0.11722324f, -0.04090880f, -0.01329110f, 0.09646059f, -0.03450499f, -0.05542730f, 
    0.09040537f, -0.01924651f, -0.17733373f, -0.02091582f, 0.18287544f, 0.25411740f, 0.12409078f, -0.22114083f, 
    -0.08692907f, -0.25698465f, 0.05713477f, 0.00249742f, -0.18104649f, -0.30050874f, -0.20706135f, -0.00687269f, 
    -0.02136589f, 0.13456838f, 0.02765307f, 0.07906569f, 0.15654695f, 0.09337272f, 0.41339320f, 0.22971798f, 
    0.04624607f, 0.00715078f, 0.12756833f, 0.13425367f, -0.18384856f, 0.11390100f, 0.00418455f, 0.15105744f, 
    0.11039831f, 0.02059174f, 0.00553793f, 0.02675923f, -0.32371330f, -0.68771529f, -0.08236901f, -0.04590355f, 
    0.09146902f, 0.06732689f, 0.11021842f, 0.11175553f, 0.41937801f, -0.24529569f, -0.08911651f, 0.26544109f, 
    0.12216128f, 0.17968541f, -0.10227000f, -0.09996515f, 0.05044582f, 0.02116580f, 0.01585912f, 0.07677181f, 
    0.10394307f, 0.02226897f, -0.18441691f, -0.03752087f, -0.05804934f, 0.18659006f, -0.22703804f, -0.09337845f, 
    0.04130670f, 0.00466983f, 0.13136718f, -0.00627511f, 0.12497713f, 0.01933015f, 0.04650886f, -0.12563442f, 
    0.18066174f, 0.08064326f, 0.02777834f, 0.01648407f, 0.02467118f, 0.01328280f, 0.18149139f, -0.10516710f, 
    0.15063143f, 0.14469607f, 0.02351043f, 0.04050741f, 0.19562793f, 0.06572936f, 0.01207270f, -0.10035208f, 
    -0.05717881f, 0.25250456f, 0.13283688f, -0.05337300f, -0.08554869f, -0.02094066f, -0.02972723f, -0.10678248f, 
    0.29884508f, 0.24641933f, -0.31160650f, 0.01737419f, -0.02742634f, 0.00588582f, 0.17239265f, -0.02017234f, 
    0.01694380f, -0.20516993f, -0.13613629f, 0.10825016f, 0.20678154f, 0.03661844f, 0.30230996f, -0.05050394f, 
    -0.13743985f, -0.24917628f, -0.19766861f, 0.02421308f, 0.10349897f, -0.11969369f, 0.00467763f, -0.02474130f, 
    -0.18231989f, -0.06812596f, -0.29273900f, -0.18599038f, 0.22544608f, 0.20614393f, 0.14823663f, 0.08241162f, 
    -0.05135066f, -0.19105452f, -0.06985584f, -0.00538155f, 0.72981364f, 0.12121755f, -0.23634818f, 0.12448863f, 
    0.19672039f, -0.09874341f, -0.01248007f, -0.02197960f, 0.16205716f, -0.03446194f, 0.00125342f, -0.02516631f, 
    0.46922615f, -0.21242033f, -0.08051134f, -0.15305991f, -0.00708566f, 0.06494657f, 0.09345096f, -0.10583419f, 
    0.21745402f, 0.15398562f, 0.12039138f, 0.12298784f, -0.17355751f, -0.07043757f, -0.17102401f, -0.25415313f, 
    -0.13136455f, -0.39862606f, -0.06377766f, -0.02318537f, -0.09373878f, -0.04613886f, 0.03576913f, 0.10823416f, 
    0.25998998f, 0.06014073f, 0.18843652f, -0.15596263f, 0.00542131f, -0.06031574f, 0.00148680f, -0.04923355f, 
    0.00120402f, -0.03376984f, 0.06008603f, -0.03755245f, 0.37910026f, -0.00042123f, 0.17306294f, -0.25178647f, 
    -0.07739164f, 0.08447625f, -0.11848975f, 0.07982270f, -0.04870845f, -0.01368381f, 0.18103488f, 0.05810787f, 
    -0.10156641f, -0.19663492f, -0.17532864f, 0.13713199f, 0.06798523f, 0.02754996f, 0.12187419f, 0.37793344f, 
    0.01335144f, 0.12959358f, -0.03860881f, 0.02848043f, 0.03803328f, -0.25708354f, 0.23029482f, 0.11954198f, 
    0.09445862f, -0.06463378f, -0.04768532f, 0.12316823f, -0.02431982f, 0.24305727f, 0.02692852f, 0.01362301f, 
    0.66882300f, 0.37635383f, 0.10293987f, -0.00801214f, 0.11672945f, 0.16559374f, 0.15724427f, -0.01941440f, 
    -0.04158931f, -0.03060316f, -0.10634924f, 0.02140886f, 0.17337157f, -0.15174961f, -0.52708292f, 0.55679959f, 
    -0.00026127f, -0.04001781f, 0.14067683f, 0.21525300f, 0.02899725f, 0.07449108f, 0.39123246f, 0.15496033f, 
    -0.34640121f, 0.27678546f, -0.11142799f, -0.32702863f, -0.09736302f, -0.01968180f, 0.01766008f, -0.13994977f, 
    -0.18806000f, -0.06870272f, 0.09762153f, -0.00897386f, -0.02397833f, 0.26648340f, 0.53181130f, 0.23575585f, 
    -0.11546645f, -0.01322761f, -0.03160788f, 0.00429079f, -0.18256994f, 0.17006880f, -0.13237418f, -0.18544681f, 
    0.00200885f, 0.09345075f, -0.10542659f, -0.14636293f, 0.13272209f, -0.01553788f, -0.23763284f, -0.11193091f, 
    -0.04020844f, -0.01478975f, 0.04480020f, 0.01799842f, 0.06872066f, 0.06328803f, 0.15099543f, 0.16508856f, 
    0.22738338f, -0.14750111f, -0.05741709f, -0.00502189f, 0.02685423f, -0.20736337f, 0.19562025f, 0.03313523f, 
    -0.05467980f, 0.02417243f, -0.08829409f, 0.26604736f, -0.20140958f, 0.17618257f, -0.16434051f, -0.01050162f, 
    0.12920985f, 0.28362533f, 0.16608779f, 0.03686216f, 0.12805904f, -0.15412669f, -0.10116106f, -0.02921179f, 
    0.02212226f, -0.10044602f, -0.22026701f, 0.08583366f, -0.02085149f, 0.08250763f, 0.00586594f, 0.01374256f, 
    0.41355771f, 0.00457830f, -0.21735020f, 0.21924978f, -0.08108031f, 0.05925577f, -0.02861950f, 0.03275791f, 
    0.01488481f, 0.03491091f, -0.13408066f, -0.10845870f, -0.12642998f, -0.13457645f, 0.11852574f, -0.10734195f, 
    0.14949790f, 0.16572866f, 0.01376571f, 0.23975894f, 0.08503931f, 0.06953731f, 0.11905974f, 0.05056790f, 
    -0.17485315f, 0.19182099f, -0.25615919f, -0.12285141f, -0.01018265f, -0.24009848f, 0.00815560f, -0.12713403f, 
    -0.27817944f, -0.08036778f, -0.04028629f, -0.00129425f, 0.18210468f, -0.08109703f, -0.16152553f, 0.25518599f, 
    0.09549122f, -0.16692562f, -0.10319693f, 0.00602790f, -0.00171955f, 0.13166407f, -0.00954866f, -0.00065285f, 
    0.02777859f, 0.02257101f, -0.27590966f, -0.04387349f, -0.06492114f, -0.05488614f, -0.14156076f, 0.16143414f, 
    -0.10805530f, 0.19810234f, -0.02844570f, 0.39733374f, 0.04293705f, -0.27289549f, 0.34338552f, 0.04254586f, 
    0.24016690f, 0.10822752f, 0.13778062f, 0.19358075f, 0.02433222f, -0.08400263f, -0.07250161f, 0.00525451f, 
    0.12631007f, 0.51849359f, 0.30443040f, 0.00452553f, 0.17433503f, 0.22319727f, -0.07316297f, -0.26556715f, 
    0.03121016f, 0.00637299f, 0.00402612f, 0.06322277f, 0.31444588f, 0.05507160f, -0.36597335f, -0.21515143f, 
    -0.05100973f, -0.02926584f, 0.05394327f, 0.22664843f, 0.26054719f, -0.03731874f, 0.10870431f, 0.22298928f, 
    -0.12034462f, -0.58092773f, 0.02392942f, 0.04010200f, 0.18554424f, 0.03802085f, 0.10166676f, 0.10684188f, 
    -0.04576441f, -0.03997256f, -0.02763843f, 0.08404469f, -0.37627223f, 0.67544210f, -0.24426292f, -0.19440681f, 
    0.19959746f, 0.08750902f, -0.16517237f, 0.08164126f, 0.13614619f, 0.17775892f, -0.02733849f, -0.09074095f, 
    -0.13684927f, -0.37435994f, 0.15250601f, 0.36711419f, 0.13925928f, -0.25333783f, -0.00840239f, 0.01953008f, 
    -0.04062767f, 0.10511249f, 0.02825561f, 0.21185882f, 0.28402403f, -0.18750998f, -0.39073399f, -0.04080883f, 
    0.04017742f, 0.00616436f, -0.05385712f, 0.00747220f, 0.18894373f, -0.07042652f, 0.23335081f, 0.04431454f, 
    -0.23421204f, -0.21760885f, 0.20191316f, 0.09934770f, 0.05936279f, 0.01388911f, 0.04261739f, 0.04681633f, 
    -0.10186874f, -0.25365418f, -0.24538852f, -0.14599004f, 0.03349908f, 0.18537056f, -0.02912850f, 0.00923281f, 
    0.02247342f, 0.10022258f, -0.06705859f, -0.17273265f, -0.08181871f, 0.04626817f, -0.06825701f, -0.00495940f, 
    -0.33766168f, 0.24600251f, 0.09311313f, -0.06007136f, 0.24955116f, -0.29005787f, -0.07103954f, 0.22163481f, 
    0.02480832f, -0.10389479f, 0.05381688f, 0.16033590f, 0.08265421f, 0.04827203f, 0.44389373f, 0.13294986f, 
    -0.21389309f, 0.12964596f, 0.16620627f, -0.14484724f, 0.01402800f, -0.08023465f, -0.01457986f, 0.04555393f, 
    -0.15566364f, 0.04826739f, 0.12148599f, -0.02936534f, 0.06023129f, 0.12017221f, -0.06109877f, -0.03482024f, 
    -0.12389019f, -0.03123261f, 0.03358353f, 0.12737267f, 0.05788929f, 0.08883612f, 0.74392480f, 0.01389157f, 
    0.12663721f, -0.05000112f, -0.02777054f, -0.23808044f, 0.01629502f, 0.06108016f, 0.22659756f, 0.10938779f, 
    -0.39571482f, -0.02914791f, 0.37454048f, 0.14230843f, 0.10009127f, -0.07158353f, 0.01915515f, -0.07715015f, 
    -0.02142830f, 0.05987238f, -0.20524168f, -0.11139864f, -0.10481513f, 0.08089907f, 0.23538329f, 0.24978273f, 
    0.07556433f, 0.20921034f, 0.14454639f, -0.00311861f, 0.03525180f, 0.00482804f, 0.04288190f, 0.08988374f, 
    0.37425187f, -0.04029274f, 0.06009573f, -0.01257210f, -0.00349443f, -0.00017747f, 0.07236450f, -0.02732482f, 
    0.08844357f, 0.09017633f, 0.03797970f, -0.17114829f, 0.17797939f, -0.01092364f, 0.15506169f, 0.05265607f, 
    0.31330267f, -0.17664979f, -0.12312269f, 0.06763683f, -0.04231530f, 0.03979595f, -0.12104429f, 0.05262832f, 
    -0.16225933f, -0.18065289f, -0.02268659f, 0.30125284f, -0.02398090f, 0.08188960f, 0.08164389f, 0.01592709f, 
    0.14434397f, 0.18365878f, -0.03774359f, 0.02193298f, 0.16780858f, -0.07270269f, 0.25221780f, 0.13042754f, 
    0.01825047f, -0.11379614f, -0.11538526f, 0.07928496f, -0.03706712f, -0.04237696f, -0.05166908f, 0.06675760f, 
    0.43235001f, 0.37393159f, -0.08839878f, 0.03363944f, 0.06202593f, 0.09850530f, 0.22947198f, -0.10713045f, 
    -0.00014078f, -0.00947866f, -0.09063827f, 0.11898423f, 0.13565581f, 0.00992347f, 0.03199922f, -0.02178523f, 
    -0.17920637f, -0.03020566f, 0.12291080f, 0.05333703f, -0.01453295f, 0.11460385f, 0.04759919f, 0.09186756f, 
    -0.14489071f, -0.04681658f, -0.09170409f, -0.06289002f, -0.00717513f, 0.04869033f, -0.05808493f, -0.13475543f, 
    0.20812973f, 0.07556947f, 0.13717440f, 0.27495104f, 0.33185682f, 0.26668197f, 0.52718794f, 0.13127238f, 
    0.01398748f, -0.01655653f, -0.09814373f, 0.00682143f, 0.03441004f, 0.10694356f, -0.04942833f, 0.17033309f, 
    0.04858473f, -0.00292903f, -0.16878781f, -0.02585280f, 0.22186220f, 0.06556010f, -0.05912111f, 0.18638523f, 
    -0.06794254f, 0.06552795f, 0.06015668f, 0.02017068f, 0.08726412f, 0.12392108f, 0.02676185f, -0.11382390f, 
    0.21272516f, -0.01989652f, 0.01053340f, -0.03153664f, 0.16893816f, 0.01509147f, 0.03874633f, 0.15260728f, 
    0.18940312f, -0.54671204f, -0.43881360f, -0.06186624f, -0.09926891f, 0.04304785f, -0.12576839f, 0.11324466f, 
    -0.01417520f, 0.21877973f, 0.05734460f, 0.07981475f, -0.16442913f, -0.15214659f, 0.02610329f, 0.19192918f, 
    0.03724492f, -0.10316499f, -0.01033637f, 0.04092508f, -0.01199679f, 0.03680867f, -0.05624244f, 0.00662598f, 
    -0.05739457f, -0.08813189f, 0.22012192f, 0.18685424f, -0.16763484f, -0.08730600f, -0.10856160f, -0.09416259f, 
    -0.06780963f, -0.09415545f, -0.16162200f, -0.04447196f, -0.17882228f, -0.51007694f, -0.00645570f, -0.10063794f, 
    0.12952381f, 0.11634144f, 0.15037932f, 0.06038429f, 0.07127888f, -0.02391032f, 0.14784363f, 0.07247812f, 
    -0.11321445f, -0.07886469f, -0.03241374f, 0.23361047f, 0.05741648f, -0.16151747f, 0.07600506f, 0.22725876f, 
    -0.10401534f, -0.15779577f, 0.06800096f, -0.07156860f, -0.25323108f, 0.00428272f, 0.21905713f, 0.16995786f, 
    -0.08102830f, -0.17567313f, -0.12521689f, -0.13569559f, -0.00455608f, 0.14147872f, -0.02864678f, 0.00264334f, 
    0.03254120f, 0.10805538f, -0.06466958f, -0.18341620f, -0.06035969f, 0.18206029f, 0.36749721f, -0.17192335f, 
    0.01794120f, 0.25420383f, 0.17041834f, 0.38956362f, 0.18004608f, -0.09367085f, -0.39882982f, 0.08357136f, 
    0.08337568f, 0.11310698f, -0.12610960f, -0.09321498f, 0.03152530f, -0.14207190f, 0.01695377f, -0.16341253f, 
    0.08818625f, 0.28534016f, 0.19584392f, 0.19213270f, -0.08136833f, 0.11551650f, 0.10727686f, 0.05254818f, 
    0.32590845f, 0.24226736f, 0.14918312f, 0.02308642f, -0.03831501f, 0.09658520f, 0.07269213f, 0.06700036f, 
    -0.01178529f, 0.23975313f, 0.10502250f, -0.05259737f, 0.28102693f, 0.50102741f, 0.41509637f, 0.66515356f, 
    0.09498584f, 0.27278364f, 0.32292473f, -0.07130706f, 0.12424752f, -0.23488842f, 0.36707520f, -0.22431135f, 
    -0.19775632f, -0.24163167f, -0.27161425f, -0.21233492f, 0.22726691f, 0.07776640f, 0.66967654f, -0.19180456f, 
    -0.33026311f, -0.16889735f, 0.05657707f, -0.16783720f, 0.12588730f, 0.10185683f, 0.16092928f, 0.30370137f, 
    0.29931784f, 0.40415356f, -0.03269494f, -0.02545333f, -0.09825142f, -0.02708341f, -0.10560510f, -0.01216007f, 
    0.12263776f, 0.12287633f, 0.01434828f, 0.05219407f, -0.08259762f, -0.24504645f, -0.11619420f, -0.18973923f, 
    0.11415683f, -0.30551714f, 0.15360612f, -0.06872728f, -0.04397100f, 0.12259229f, -0.27507731f, -0.06694344f, 
    -0.33431593f, -0.01876463f, -0.19350782f, 0.16217652f, 0.07073899f, -0.00971395f, 0.04580022f, -0.15173563f, 
    -0.52092409f, -0.60903341f, -0.47837836f, -0.49283114f, -0.12115316f, 0.11219361f, 0.03593487f, -0.10356002f, 
    0.24732913f, -0.07023919f, -0.10515812f, -0.01144396f, 0.04920287f, -0.13627730f, -0.18527575f, -0.20809489f, 
    0.49289075f, -0.08020384f, -0.21325666f, 0.25723505f, -0.19734001f, -0.22530365f, -0.11051962f, -0.05177993f, 
    -0.00156057f, 0.07576558f, 0.02165336f, -0.10216860f, -0.13041629f, -0.13593988f, 0.01638957f, 0.12872688f, 
    0.03076705f, 0.00189612f, 0.06725265f, 0.12529571f, -0.03997469f, -0.09181631f, 0.08161525f, -0.16716777f, 
    -0.05451835f, -0.10502593f, 0.10939575f, 0.07106729f, 0.05398724f, -0.04362395f, 0.05923045f, 0.03965740f, 
    0.07568598f, 0.05769659f, 0.06294692f, 0.17653942f, 0.03099471f, 0.06412716f, -0.13503180f, 0.05553551f, 
    -0.04830860f, -0.15166861f, 0.24231492f, 0.24178189f, 0.17888135f, 0.11933865f, 0.09698182f, 0.02522095f, 
    0.43145928f, 0.19117641f, 0.22831698f, 0.46116510f, -0.23195721f, -0.04556467f, 0.04016490f, -0.08933210f, 
    -0.05880177f, -0.31413579f, -0.08702657f, -0.33898497f, -0.08162704f, -0.03842848f, 0.14650424f, 0.08015388f, 
    0.10820270f, -0.09214636f, 0.10890566f, 0.02788789f, -0.22243844f, -0.03452351f, -0.02771686f, 0.10168482f, 
    -0.18208070f, 0.09342213f, -0.22798321f, -0.13606066f, -0.04573601f, 0.07497501f, 0.26903281f, -0.08243721f, 
    0.00497875f, 0.22807145f, 0.12060672f, 0.24403045f, 0.02639945f, -0.30962199f, -0.50994778f, -0.00821103f, 
    -0.03308349f, -0.07220073f, 0.03931316f, -0.13693248f, 0.13641526f, -0.02505216f, 0.02406300f, 0.03649596f, 
    0.23738895f, 0.38223523f, 0.31434345f, 0.04631425f, -0.07908748f, -0.08259001f, 0.14164312f, 0.06372973f, 
    0.14296612f, 0.17691141f, 0.06958631f, -0.05362923f, -0.16251005f, 0.17684369f, -0.16773534f, -0.13043536f, 
    -0.05351559f, 0.01992984f, -0.06320202f, -0.08530378f, 0.25648651f, 0.29998940f, 0.09775098f, 0.50197673f, 
    0.03750275f, -0.02944525f, 0.53098297f, 0.29050583f, 0.14341879f, -0.08357254f, 0.27815247f, -0.01433771f, 
    -0.18240607f, -0.12211126f, -0.11507460f, -0.24250056f, 0.12946333f, 0.12544847f, 0.77678257f, 0.13265319f, 
    0.06211171f, -0.22997481f, -0.16914035f, -0.07394192f, -0.02651945f, 0.21625724f, -0.07183301f, 0.28594333f, 
    -0.05322037f, 0.03236473f, 0.17703298f, 0.74131870f, 0.07715858f, -0.13017459f, -0.16422357f, -0.18338734f, 
    -0.11331979f, 0.07113054f, 0.02187856f, 0.04413551f, -0.30497527f, -0.33792713f, -0.45439744f, 0.07128073f, 
    -0.06897341f, 0.13279760f, 0.10786579f, 0.11837632f, -0.02095162f, -0.20594352f, -0.20815289f, -0.03431744f, 
    0.10723306f, 0.01925013f, 0.03230724f, -0.08937111f, 0.32529479f, 0.01428012f, 0.17600943f, 0.04777172f, 
    -0.14103729f, -0.19452952f, -0.33195058f, -0.44127828f, 0.02780464f, -0.25808269f, 0.06827351f, -0.15358527f, 
    0.08830225f, 0.00581774f, -0.07631614f, 0.06052915f, 0.21323398f, -0.10562508f, -0.23625498f, -0.32105443f, 
    -0.19661796f, -0.01317888f, -0.30263391f, 0.02597593f, 0.11401901f, -0.20128819f, -0.13950360f, -0.28748450f, 
    -0.16680416f, 0.08678196f, -0.06891787f, 0.23074073f, 0.03751524f, -0.04255292f, 0.15563577f, -0.03234028f, 
    -0.01961505f, 0.07124304f, 0.21156776f, 0.18603480f, 0.02139531f, 0.05476482f, 0.07445922f, -0.23846957f, 
    -0.06838267f, -0.06789614f, 0.05867782f, 0.03155795f, -0.10999507f, 0.01076677f, 0.00582877f, 0.04776979f, 
    0.14366142f, 0.17771162f, 0.23768061f, 0.00302999f, 0.31872404f, -0.16003206f, -0.05819952f, 0.02464359f, 
    -0.20187400f, -0.34424281f, -0.00205029f, 0.03873309f, 0.07129220f, 0.08238532f, 0.12113232f, 0.09694071f, 
    0.19747025f, 0.42075554f, -0.00503330f, 0.34871438f, -0.25218537f, 0.10894831f, -0.07301802f, -0.26937410f, 
    -0.09397715f, -0.33689612f, 0.01955015f, -0.32135040f, 0.04215734f, -0.06063081f, 0.06555754f, 0.04778683f, 
    0.05150428f, 0.05457366f, 0.26465195f, 0.19999294f, -0.17010464f, -0.06735344f, 0.02419027f, 0.04321627f, 
    0.26410377f, 0.05558985f, -0.19004239f, 0.17109466f, -0.03447521f, 0.09910567f, 0.03445748f, 0.02845474f, 
    -0.13856673f, 0.05652750f, -0.20080312f, 0.12628894f, 0.07281166f, -0.14265850f, 0.18951593f, 0.13512017f, 
    0.20474756f, -0.01960173f, 0.03987340f, 0.03250009f, 0.01187227f, -0.06715053f, -0.03317080f, 0.03855512f, 
    -0.27612785f, -0.07881786f, 0.42997095f, 0.04654229f, 0.01804105f, 0.16179204f, 0.08873375f, -0.20544699f, 
    0.09540588f, 0.10177170f, 0.05917758f, -0.08669408f, 0.24045035f, 0.02621319f, 0.07027809f, 0.03046976f, 
    -0.09889103f, 0.05081652f, 0.14317589f, -0.06438061f, 0.11292186f, -0.04146830f, 0.18272895f, 0.12584820f, 
    0.16989411f, -0.03802108f, 0.07584281f, -0.00341671f, -0.03348386f, -0.12606269f, -0.06221640f, 0.27886748f, 
    -0.08552572f, 0.04485983f, -0.02130883f, -0.05945754f, -0.56973404f, 0.29400501f, 0.50344193f, -0.29947475f, 
    -0.03668740f, 0.08594636f, 0.06911585f, 0.11597535f, -0.11025222f, 0.02736779f, -0.00483911f, 0.02004120f, 
    0.11071262f, 0.08510940f, -0.12983610f, 0.02986506f, 0.18595894f, 0.02135670f, -0.03239378f, -0.01774465f, 
    -0.05107611f, 0.12333752f, -0.12639110f, 0.08157036f, 0.31502628f, 0.05436414f, -0.11674678f, 0.06521171f, 
    0.13683853f, -0.01444164f, -0.11541532f, -0.05458698f, 0.05712565f, -0.05317322f, 0.10304353f, -0.02756162f, 
    -0.03192152f, 0.07628120f, 0.02035412f, 0.12534241f, -0.10975505f, -0.11715686f, 0.16606559f, -0.09669695f, 
    -0.04399890f, -0.11829394f, -0.11048147f, -0.12609200f, -0.02529555f, 0.18966833f, -0.09479520f, -0.20686464f, 
    0.03718668f, 0.14014119f, 0.12417845f, 0.06425733f, 0.01829360f, -0.13919356f, -0.08242349f, -0.05311143f, 
    0.27521914f, 0.21597995f, -0.39735195f, -0.02714083f, 0.02952913f, -0.07409567f, 0.00747189f, 0.03679492f, 
    0.00187663f, -0.21359256f, 0.06759724f, -0.06122566f, -0.11567117f, -0.21240978f, 0.46706939f, 0.47295138f, 
    -0.15691750f, 0.00412603f, 0.08771878f, -0.04022866f, 0.00130992f, -0.06461986f, 0.00433779f, -0.06436918f, 
    -0.45596600f, -0.10727556f, 0.30027634f, -0.06741024f, 0.02440051f, -0.10403677f, 0.08704503f, 0.05292718f, 
    0.01033728f, 0.04703405f, 0.03689802f, 0.11044939f, 0.02044141f, -0.01991197f, 0.27847779f, 0.15293491f, 
    0.16752958f, -0.01304959f, 0.13926552f, -0.05463700f, -0.06766955f, 0.15977752f, 0.13840395f, -0.07138432f, 
    0.20771827f, -0.22651640f, 0.00072762f, 0.26134521f, 0.04850047f, -0.05937831f, -0.23292848f, -0.06839874f, 
    0.19056255f, 0.20777774f, -0.06979842f, 0.05772522f, -0.38359773f, -0.12583753f, 0.27430195f, 0.32092839f, 
    -0.05199856f, -0.08366802f, -0.04679862f, -0.08977134f, 0.01849630f, 0.02814979f, 0.09844179f, -0.03112257f, 
    -0.03371599f, 0.01109917f, 0.05735410f, 0.03968503f, 0.05469665f, -0.04382287f, -0.04359068f, -0.05138015f, 
    -0.07350303f, -0.03779953f, -0.05619391f, -0.06754484f, -0.01418918f, -0.04041110f, 0.04076615f, 0.04044304f, 
    0.04506858f, 0.01403005f, -0.03657700f, -0.06340961f, 0.05904981f, -0.02323966f, -0.07037439f, -0.01406054f, 
    -0.03934463f, -0.06268283f, -0.03911494f, 0.00292807f, -0.06991165f, -0.00994399f, 0.05075919f, -0.06059010f, 
    0.04894280f, 0.04827886f, -0.01166759f, 0.00703837f, -0.06000935f, -0.02968436f, 0.05810481f, 0.00173160f, 
    0.00613287f, 0.00550463f, -0.07151708f, 0.03934402f, -0.03330665f, -0.00299921f, 0.00842665f, 0.00242381f, 
    -0.06502321f, 0.04535699f, 0.05774012f, 0.05177491f, -0.02088904f, 0.02780554f, -0.06400741f, 0.03370351f, 
    -0.02255704f, -0.00295429f, 0.02706678f, 0.01755011f, -0.00767519f, -0.03081200f, -0.00971961f, 0.02556298f, 
    -0.07629196f, -0.01202892f, -0.01427416f, 0.05392347f, -0.04549453f, -0.03875624f, 0.02295390f, -0.01223157f, 
    -0.02859794f, -0.02953094f, 0.01650223f, 0.06119209f, 0.02667321f, -0.05808884f, 0.05539137f, -0.07694969f, 
    -0.01822268f, -0.05378536f, 0.03700542f, -0.00821932f, -0.08207999f, -0.05387761f, 0.05962866f, -0.00089187f, 
    0.04139452f, -0.01940272f, -0.03757771f, -0.06051756f, 0.03107101f, -0.04001858f, -0.07943530f, 0.01140732f, 
    -0.05408196f, -0.02199306f, 0.05501267f, 0.02007899f, -0.02023752f, 0.01207787f, -0.01202930f, -0.02129018f, 
    -0.06550549f, -0.05497537f, 0.01405129f, -0.05957186f, -0.01740530f, -0.07224975f, 0.05444421f, 0.03918545f, 
    -0.07394469f, 0.00108827f, 0.02462173f, 0.01252542f, -0.04771428f, -0.07719686f, -0.02200850f, 0.03941423f, 
    0.05951486f, 0.01179337f, 0.01736368f, -0.05240108f, -0.07002721f, -0.00083293f, -0.04317915f, 0.05185108f, 
    -0.02937151f, -0.02561008f, -0.01822344f, 0.04377891f, -0.01931166f, 0.02668454f, 0.03382065f, -0.05664615f, 
    -0.06860403f, -0.06597017f, 0.04828046f, -0.00018148f, -0.04314985f, -0.01543477f, 0.02053039f, -0.02879496f, 
    -0.04833714f, -0.00143457f, 0.04758213f, -0.01381642f, 0.05483836f, 0.04641118f, 0.04369250f, 0.06554744f, 
    0.01828890f, 0.01846035f, 0.02586929f, 0.01385656f, 0.01969534f, 0.03238051f, -0.04969002f, -0.05668509f, 
    -0.07161167f, -0.02107741f, -0.04722763f, -0.07381836f, -0.03515682f, -0.03392695f, 0.04500787f, 0.01560905f, 
    0.04415317f, 0.02202975f, 0.02868262f, 0.00876506f, 0.00989267f, -0.02916555f, 0.05847967f, -0.07475016f, 
    -0.07451590f, 0.05714373f, -0.00748007f, -0.07245754f, 0.01848721f, 0.01111421f, -0.01396773f, 0.05487764f, 
    0.02051930f, -0.07007299f, 0.00466504f, -0.05166723f, 0.03406141f, -0.01682853f, 0.02573945f, 0.01632435f, 
    0.06600379f, -0.06584954f, 0.13215804f, 0.11885511f, -0.02698217f, -0.02090769f, -0.18547198f, -0.10143290f, 
    -0.06294344f, 0.15055473f, -0.18455546f, -0.19274828f, 0.24669531f, 0.42742109f, 0.11379656f, 0.31958842f, 
    0.06400765f, -0.11573064f, 0.01118956f, 0.24932142f, -0.21456572f, -0.01247254f, -0.21945949f, 0.07706454f, 
    -0.16077796f, -0.17296912f, 0.06922629f, 0.20865683f, 0.13143033f, 0.13453855f, 0.19772458f, 0.08442102f, 
    -0.00709620f, -0.19076495f, -0.14011852f, -0.07264395f, 0.15085688f, -0.28289318f, 0.01838692f, -0.11409122f, 
    0.07239074f, 0.04314931f, -0.16840599f, -0.11500877f, -0.09267357f, -0.28497452f, -0.32729179f, -0.40301120f, 
    -0.42500114f, -0.06235915f, -0.11885991f, 0.05724320f, 0.02164160f, -0.08190247f, 0.00665928f, 0.03944808f, 
    -0.03074360f, -0.01107427f, 0.16361900f, 0.00361222f, 0.19656280f, -0.00231412f, 0.14558072f, -0.44394577f, 
    0.01902476f, 0.09705247f, -0.01768264f, 0.04269222f, 0.16595946f, 0.05513666f, -0.21472220f, -0.04216266f, 
    0.29128227f, -0.01381843f, -0.15971261f, -0.17436999f, -0.00060040f, -0.05399644f, -0.06637245f, 0.03686260f, 
    0.03383967f, 0.02162196f, 0.09139662f, 0.01634176f, 0.07113068f, 0.16680719f, 0.11929084f, -0.23269737f, 
    -0.02730228f, -0.13687181f, -0.08686721f, -0.11898094f, 0.14477481f, -0.04053217f, 0.18422373f, 0.15332268f, 
    -0.00016948f, -0.02036595f, 0.01926615f, -0.01299710f, 0.01315667f, 0.06090830f, -0.00272811f, 0.05755886f, 
    0.09832026f, 0.12729803f, 0.14947289f, 0.12265088f, 0.52353197f, 0.16340265f, -0.18170476f, 0.18057606f, 
    -0.12782185f, -0.07066335f, 0.36147031f, 0.00218089f, -0.05984310f, 0.18135731f, 0.07839740f, 0.15214358f, 
    0.47328639f, 0.04193583f, 0.24941857f, -0.25494081f, 0.00388275f, -0.35752851f, 0.09375890f, -0.02315435f, 
    0.13367447f, -0.09328765f, -0.17891240f, 0.30443901f, -0.23943987f, 0.24706618f, 0.29311806f, 0.41119754f, 
    0.13298218f, 0.16539229f, 0.16619812f, 0.14776143f, 0.01705276f, 0.09387503f, -0.00637693f, 0.00887751f, 
    -0.07487232f, 0.02692188f, 0.12915625f, -0.02857459f, 0.17420688f, 0.05778653f, 0.03156135f, 0.14793038f, 
    -0.02178064f, -0.12855582f, -0.10749241f, 0.06649561f, 0.13894501f, 0.36528739f, -0.48241335f, 0.38423583f, 
    0.38988733f, 0.01256383f, 0.21448736f, 0.08282655f, -0.09513339f, 0.11885931f, -0.08973029f, 0.01027264f, 
    0.29930529f, -0.11684635f, 0.11642522f, -0.13273817f, -0.06815925f, 0.18389133f, -0.13276246f, 0.05022013f, 
    0.11311133f, 0.26077563f, 0.24723305f, 0.18412574f, -0.15193370f, 0.18974076f, 0.41238633f, 0.31952679f, 
    0.10529860f, 0.09801539f, -0.00458891f, 0.43972975f, 0.07858974f, 0.05991330f, 0.01739402f, 0.14560163f, 
    0.05014281f, 0.00179758f, -0.06556531f, 0.00822746f, -0.01865854f, -0.05372835f, -0.06099740f, 0.00055256f, 
    0.03790698f, -0.06766149f, -0.04108395f, 0.02192243f, -0.04289620f, -0.07634889f, -0.03159026f, -0.00067209f, 
    0.01453970f, 0.02193057f, -0.07208247f, 0.04668143f, -0.04187440f, 0.00894532f, -0.03428497f, -0.01256177f, 
    -0.00492649f, 0.03596852f, -0.04609524f, 0.02535800f, 0.07072081f, -0.00605161f, -0.00292753f, 0.00131000f, 
    -0.03062844f, -0.07771104f, -0.04468750f, -0.05644520f, -0.04729668f, 0.01267257f, -0.00937351f, 0.04850351f, 
    -0.01208410f, -0.05057973f, 0.04827031f, 0.06258669f, -0.05595620f, 0.02758370f, -0.04326317f, -0.02799229f, 
    -0.04203096f, 0.05824863f, -0.01220326f, 0.04845750f, 0.06132789f, 0.06380466f, -0.06878395f, -0.01457566f, 
    0.03734710f, -0.05198135f, 0.00939795f, -0.06006261f, -0.03101566f, 0.03689668f, 0.04528312f, 0.04871646f, 
    -0.04385366f, -0.06352645f, 0.00891357f, -0.04437015f, -0.05713395f, -0.04551349f, 0.07022011f, 0.01954337f, 
    -0.02082776f, 0.04682595f, -0.06020821f, -0.03675124f, -0.07224746f, -0.02471358f, -0.03539724f, -0.04438543f, 
    -0.07156461f, -0.03676602f, -0.06414583f, 0.02466695f, -0.01496869f, -0.07535467f, -0.03012330f, 0.01445367f, 
    0.03917315f, 0.02326864f, -0.03049023f, -0.01136362f, -0.01171004f, -0.05441342f, -0.04994794f, 0.01051052f, 
    0.00327763f, 0.04841572f, -0.02631187f, 0.04405641f, 0.01934966f, 0.00837455f, -0.03921574f, -0.03360526f, 
    0.06244953f, -0.04305413f, -0.07206805f, -0.00242043f, 0.04639222f, 0.04055502f, 0.06465901f, 0.01805112f, 
    0.02496699f, -0.01923128f, -0.04323968f, 0.05382502f, -0.00630296f, -0.05300506f, 0.02171260f, -0.02833982f, 
    0.02289083f, -0.03507117f, 0.06441576f, -0.07300413f, 0.05639703f, -0.06154878f, -0.03231154f, 0.05366233f, 
    -0.04006073f, -0.00876376f, -0.06667089f, -0.06445017f, -0.05446422f, -0.01475412f, 0.03294151f, -0.05107117f, 
    0.03447596f, -0.00605415f, -0.05174221f, -0.04595503f, 0.03424622f, -0.02433386f, -0.06677950f, -0.03719547f, 
    -0.02073484f, 0.06021912f, -0.01412919f, -0.01548428f, -0.05588632f, 0.00089679f, -0.02763907f, -0.01895754f, 
    -0.05480274f, 0.02908758f, 0.02065598f, 0.05619135f, 0.05516023f, -0.04858024f, 0.02557735f, -0.06021878f, 
    0.04796492f, 0.00744516f, 0.05612659f, -0.06442016f, 0.02684849f, 0.00661146f, -0.07388145f, 0.05270281f, 
    -0.03390728f, -0.03983669f, 0.05173409f, -0.03642351f, -0.02547358f, 0.06232286f, -0.07378737f, -0.05785965f, 
    -0.00383511f, 0.03963727f, 0.00083622f, 0.03213689f, -0.03950396f, 0.03070077f, 0.06338655f, -0.02991023f, 
    0.06270229f, -0.05543246f, -0.04529883f, -0.04308067f, 0.06737797f, 0.06847955f, 0.06426761f, -0.01257697f, 
    -0.05182229f, -0.21513371f, -0.23491977f, -0.17160411f, -0.12386588f, -0.15033886f, -0.08150613f, 0.32887933f, 
    -0.05922498f, -0.00034865f, 0.06907273f, 0.16580242f, 0.67792404f, 0.17871332f, 0.20703933f, -0.00839490f, 
    -0.01891676f, 0.20950158f, 0.00188855f, 0.24498446f, -0.00822082f, 0.06922638f, 0.05305568f, 0.13121380f, 
    -0.25888997f, -0.03868677f, -0.24655692f, -0.07708758f, -0.06649011f, 0.02394502f, 0.26409209f, 0.11346574f, 
    -0.25924605f, -0.06121468f, 0.05631004f, -0.00832677f, 0.09979057f, -0.38294169f, 0.05794674f, -0.07880889f, 
    -0.19493651f, 0.03256399f, 0.15452705f, 0.36963922f, 0.09200779f, 0.18313174f, 0.31183752f, -0.08287441f, 
    -0.61598909f, -0.25391823f, 0.11167075f, 0.27889112f, 0.13163166f, -0.00083511f, 0.15930104f, -0.07867303f, 
    0.07972319f, -0.01136616f, -0.20778018f, -0.02117659f, -0.80849695f, 0.29179674f, 0.42375851f, 0.29055989f, 
    -0.10989343f, -0.06552864f, 0.04849184f, -0.05757305f, 0.03389642f, -0.04865906f, 0.30346218f, -0.02440917f, 
    -0.07314350f, 0.31391358f, -0.14295436f, -0.14723547f, -0.11588410f, -0.02472438f, -0.16401730f, 0.15829834f, 
    0.21954013f, 0.04756792f, 0.20661651f, 0.06239464f, -0.33188677f, 0.01303750f, 0.02950229f, -0.19999957f, 
    -0.02937159f, 0.00179603f, -0.06463888f, 0.02667778f, 0.04626513f, 0.02620993f, 0.10231149f, 0.13111447f, 
    0.12391164f, 0.03229669f, -0.15275800f, 0.05510648f, 0.14211898f, -0.04982375f, -0.05248853f, 0.07615677f, 
    0.13611792f, 0.05035511f, 0.06051812f, 0.09976448f, -0.28671488f, 0.26316440f, 0.28437638f, 0.09363905f, 
    -0.03467824f, -0.07053312f, -0.01607410f, -0.00914816f, -0.21658272f, 0.15989409f, 0.15675116f, 0.26951918f, 
    0.39327911f, 0.29894975f, 0.11150940f, -0.06196002f, 0.03987421f, -0.23855200f, 0.01121477f, -0.19615756f, 
    -0.19144234f, 0.19141231f, 0.11447599f, 0.08000147f, 0.29993775f, -0.15610874f, -0.21917017f, 0.00280902f, 
    0.03475541f, -0.07284581f, 0.09140217f, 0.19530499f, 0.09512417f, 0.06729031f, 0.20027511f, 0.12071152f, 
    0.13463356f, -0.13975817f, -0.42087823f, -0.05408007f, 0.13761133f, 0.05985976f, 0.13823894f, 0.05391625f, 
    -0.13832475f, -0.02773452f, 0.05267305f, 0.06773885f, 0.22312512f, 0.40926385f, -0.57531428f, 0.12212733f, 
    0.37985373f, -0.09102897f, -0.11609599f, 0.01131757f, 0.19772159f, 0.00606170f, 0.07141963f, -0.16948283f, 
    0.04613708f, -0.16765387f, 0.15576653f, -0.25849366f, -0.07118750f, -0.03770152f, -0.12188496f, -0.10581228f, 
    0.06975846f, 0.15002793f, 0.16517401f, -0.02498153f, -0.04044995f, -0.24040705f, -0.38453951f, -0.06448729f, 
    0.12972234f, -0.08060063f, 0.05900340f, 0.04638840f, -0.03454754f, 0.05968866f, -0.13073891f, -0.02514610f, 
    0.13523054f, -0.20472823f, -0.01391295f, 0.26213241f, 0.05869126f, 0.05972091f, -0.14203797f, 0.11132424f, 
    0.30481052f, -0.03855536f, 0.18459520f, 0.08388186f, -0.75096846f, 0.43116704f, 0.01338367f, 0.01533123f, 
    0.17418899f, 0.09232555f, -0.04328468f, 0.14600867f, 0.06667095f, -0.01709213f, 0.12246253f, -0.00311574f, 
    -0.03928105f, 0.32554156f, 0.10413448f, -0.46330565f, -0.06323691f, -0.10793956f, -0.11266322f, 0.04891692f, 
    -0.05445718f, -0.12516810f, 0.06693898f, 0.06396591f, 0.30822575f, -0.07992719f, -0.04447763f, -0.36562485f, 
    -0.01248403f, 0.06893004f, 0.11768696f, 0.10198490f, 0.05891204f, 0.09797646f, 0.34755388f, 0.09073646f, 
    -0.15286100f, -0.30771762f, -0.21316350f, -0.08510768f, 0.37181515f, 0.10060693f, 0.15155216f, 0.14006682f, 
    0.02050754f, 0.08288454f, -0.12022413f, 0.01283830f, 0.04791981f, -0.57076907f, 0.26184320f, -0.26831380f, 
    0.10447549f, -0.04080695f, -0.11062986f, 0.07751840f, 0.23188636f, 0.02715954f, 0.28731009f, 0.08197532f, 
    -0.32981738f, 0.21132728f, 0.03431132f, 0.50626379f, 0.03084951f, 0.13442676f, -0.30060109f, -0.01132349f, 
    0.15110680f, -0.04615596f, 0.17982636f, 0.08927360f, -0.12311678f, 0.05874292f, -0.26415655f, 0.11618786f, 
    0.19192159f, 0.10603770f, 0.09262147f, 0.11145773f, 0.00015245f, -0.09474386f, -0.08084340f, -0.03335693f, 
    0.10475404f, -0.13526200f, -0.14587867f, 0.08057551f, -0.07859197f, 0.06576575f, -0.14717326f, 0.16610651f, 
    0.05551235f, -0.05420355f, -0.08644052f, -0.02376996f, -0.09697362f, -0.13562858f, -0.02176463f, -0.18980142f, 
    0.03171113f, -0.17351279f, 0.17748207f, -0.01704778f, 0.10682785f, 0.05079299f, 0.06938136f, 0.30095243f, 
    -0.44093838f, 0.14960608f, 0.50880438f, 0.17868657f, 0.30404937f, -0.05024238f, 0.02996609f, -0.05042170f, 
    0.02193099f, 0.04767698f, 0.16937321f, -0.03419736f, 0.15239029f, -0.00532457f, 0.08977757f, -0.09812696f, 
    0.08179078f, 0.10229447f, 0.04318563f, 0.01877598f, 0.02920092f, 0.09832866f, 0.03876650f, 0.06043042f, 
    -0.12532598f, 0.17845336f, 0.00528689f, -0.19033490f, 0.11196188f, -0.03482568f, 0.14875896f, 0.11949255f, 
    0.08046956f, 0.03939093f, 0.04218872f, 0.11243588f, -0.23538141f, 0.11961588f, -0.25953323f, 0.10134622f, 
    0.25951988f, -0.24897975f, 0.01723980f, -0.12072038f, -0.07290277f, -0.08480042f, 0.01421878f, 0.01458172f, 
    -0.18626991f, -0.42236018f, 0.49021915f, -0.15231504f, 0.11263150f, 0.05757733f, -0.12980866f, -0.26703274f, 
    -0.03382085f, 0.04998512f, 0.00515389f, -0.00149602f, 0.15599087f, 0.17895387f, -0.06875074f, -0.30360478f, 
    0.14557464f, -0.06018376f, 0.05767784f, -0.05555261f, -0.01621810f, 0.01690138f, 0.01517673f, -0.22063392f, 
    -0.02442800f, 0.04179709f, 0.07053864f, -0.01143184f, -0.06439520f, 0.05758046f, -0.03440614f, -0.04334480f, 
    0.03690381f, -0.05606721f, 0.00545414f, -0.02828425f, 0.04485325f, 0.04189636f, -0.03645287f, 0.07138808f, 
    0.00466992f, -0.02157052f, 0.01538479f, 0.02721339f, -0.01166886f, -0.06612428f, -0.02897585f, -0.05173906f, 
    0.01849940f, 0.01525658f, -0.06214945f, 0.02373255f, -0.02880207f, -0.04636553f, -0.01572444f, -0.01069562f, 
    0.01245547f, 0.02648323f, -0.00390068f, -0.03877022f, -0.06118475f, -0.04324272f, 0.02207348f, -0.01350897f, 
    0.04613865f, 0.01437992f, 0.03661846f, -0.05844875f, 0.04517228f, 0.04075406f, -0.04112017f, -0.02208862f, 
    -0.00813845f, -0.02997368f, 0.04023568f, -0.05269962f, -0.03431137f, 0.03826153f, -0.00860071f, -0.02851609f, 
    -0.07488462f, 0.02538757f, 0.01148244f, -0.04703365f, -0.06829555f, -0.03880770f, 0.06294001f, -0.03875895f, 
    0.01196117f, 0.00264456f, -0.02325203f, -0.03747383f, -0.01696535f, -0.04649982f, -0.04623376f, 0.06537354f, 
    0.03929025f, -0.00631046f, 0.05623387f, -0.04002867f, -0.01608003f, -0.03064345f, -0.03211402f, -0.04515970f, 
    0.04972867f, -0.01181282f, -0.03681245f, -0.02952939f, 0.02967829f, 0.07076506f, -0.05489490f, -0.02151287f, 
    -0.05073812f, -0.07110308f, -0.03749136f, -0.06025273f, -0.02469288f, -0.06957739f, -0.06782266f, -0.05465000f, 
    0.00191323f, -0.03962895f, -0.02476829f, 0.05584543f, -0.02231675f, 0.01366845f, 0.02196894f, -0.01786706f, 
    -0.05944763f, 0.05107147f, -0.04704967f, 0.00104764f, 0.04793315f, -0.06241786f, 0.02231717f, -0.01391336f, 
    0.05233791f, 0.02953247f, 0.00470769f, 0.04419110f, -0.06378233f, 0.00230463f, -0.00204172f, -0.02866707f, 
    0.05588302f, -0.00874909f, -0.03838262f, -0.01784941f, -0.07021338f, 0.01898179f, -0.06157868f, -0.05120927f, 
    -0.00451462f, -0.01176871f, 0.00417424f, 0.00102805f, -0.00194281f, -0.01873885f, -0.00026239f, 0.01613455f, 
    0.05667553f, -0.00450083f, -0.06699417f, 0.06433203f, -0.04717917f, -0.02836963f, 0.05087661f, 0.03193448f, 
    -0.04224510f, 0.02895373f, 0.03090286f, 0.00334109f, -0.06739994f, 0.04723296f, 0.01048101f, 0.01548312f, 
    0.06892837f, 0.01317809f, -0.02278219f, -0.05250281f, 0.05072187f, 0.06329013f, 0.02372368f, -0.06667557f, 
    0.06165950f, -0.01210505f, 0.03546539f, -0.06479491f, -0.06452287f, -0.05240179f, 0.00017352f, -0.05335490f, 
    0.03819938f, -0.00214599f, -0.04717492f, 0.01377716f, -0.00874192f, 0.04584602f, 0.02206811f, 0.01140507f, 
    -0.01116381f, -0.04408450f, -0.07654109f, -0.05062157f, -0.07908349f, 0.02004387f, 0.00572685f, -0.03234920f, 
    -0.00241090f, 0.06415043f, 0.02323354f, 0.03047924f, 0.00182910f, -0.07563433f, -0.06272788f, 0.04321738f, 
    0.10508911f, -0.04917905f, 0.13567512f, 0.16116981f, 0.01007134f, -0.14884371f, -0.15510252f, -0.31160900f, 
    0.18214343f, 0.24526721f, -0.36122200f, -0.21149531f, 0.31519371f, 0.27481225f, 0.10005793f, 0.36095834f, 
    0.21811175f, 0.07589933f, -0.11535703f, 0.04405750f, -0.06652312f, 0.20592916f, -0.14389603f, 0.33657604f, 
    -0.24665105f, -0.25453189f, -0.18145001f, 0.27792963f, -0.08644366f, 0.09625159f, 0.31282625f, 0.05276509f, 
    -0.03335120f, 0.04053526f, 0.09945378f, 0.11385184f, -0.04422674f, 0.17677659f, 0.58708066f, 0.39097723f, 
    -0.00183333f, 0.10151373f, 0.02790049f, -0.17480361f, 0.11054239f, -0.08047241f, -0.20721947f, -0.12539853f, 
    0.10036314f, 0.50001079f, 0.03115320f, -0.08912218f, -0.38864192f, -0.08024843f, -0.09040773f, 0.18058980f, 
    -0.06361852f, -0.05856976f, 0.03780107f, -0.13196446f, 0.04188704f, 0.43404013f, 0.43515489f, 0.05443311f, 
    -0.13096169f, -0.04316333f, -0.04680340f, -0.10542233f, -0.06967959f, 0.07881095f, -0.10552320f, 0.05954240f, 
    -0.05325122f, -0.11935699f, -0.20856065f, -0.27134833f, -0.15032083f, -0.16621213f, -0.10638004f, -0.06362735f, 
    0.01560235f, 0.03580896f, 0.05807773f, 0.14207374f, 0.15474397f, 0.15153214f, 0.51816434f, 0.22850929f, 
    -0.10435919f, -0.08518597f, -0.26226217f, -0.01137445f, -0.13543317f, 0.21096192f, -0.18403155f, 0.08912124f, 
    0.07246828f, 0.24486901f, -0.40533620f, -0.19809256f, -0.02494911f, -0.08458680f, 0.21959405f, 0.11763114f, 
    0.03611372f, 0.25725311f, 0.23630896f, 0.04975418f, 0.10466051f, 0.34824058f, -0.03627709f, -0.16116183f, 
    0.07628514f, 0.06745310f, 0.13732471f, 0.25790912f, 0.08771448f, 0.14580511f, 0.00276808f, 0.13597344f, 
    0.35729852f, -0.13535365f, -0.40245432f, 0.08263449f, -0.13071518f, 0.31329590f, 0.03570499f, 0.06718094f, 
    0.02314856f, -0.15522957f, -0.01239225f, 0.35717148f, -0.22483191f, 0.02605395f, -0.16967541f, 0.22637650f, 
    0.24558727f, -0.06970246f, -0.01538618f, 0.05893778f, 0.02118757f, -0.14978318f, -0.00288857f, 0.09800624f, 
    0.03661048f, 0.05486955f, 0.02005630f, -0.12207777f, 0.02856756f, -0.13346168f, 0.01586982f, -0.02152700f, 
    -0.02740325f, -0.09534624f, -0.16715717f, -0.03051168f, -0.09036288f, -0.21604432f, -0.16664971f, -0.03054537f, 
    0.29964498f, 0.12422671f, 0.30349076f, 0.20602944f, 0.02439892f, -0.06754423f, -0.00758063f, 0.08863281f, 
    -0.05959808f, -0.35914281f, -0.17943847f, 0.17126159f, 0.15161416f, -0.00338933f, 0.00204948f, 0.07673964f, 
    -0.08720630f, 0.04717443f, 0.06082721f, -0.15339166f, -0.34980857f, -0.13742208f, -0.07527647f, -0.07703566f, 
    -0.12629791f, -0.05039556f, -0.25057334f, -0.07897575f, 0.07117920f, -0.02132741f, -0.04244225f, -0.11027656f, 
    -0.16617954f, -0.34933579f, -0.10462756f, -0.00579234f, 0.07932246f, -0.04258892f, 0.05070360f, -0.06116421f, 
    0.13255529f, 0.26691222f, -0.10604658f, 0.04064575f, -0.39557260f, 0.37018016f, -0.13227786f, 0.09969299f, 
    0.18328315f, -0.00302832f, -0.18630758f, 0.08899794f, -0.09773157f, 0.04906943f, -0.03757393f, 0.22439775f, 
    0.49454883f, 0.16587093f, 0.12947512f, -0.03969658f, -0.06287027f, -0.09232954f, 0.28511336f, 0.15109685f, 
    0.10551934f, 0.24617068f, -0.01403216f, -0.08498298f, -0.14833747f, -0.09684621f, 0.16843854f, -0.09554703f, 
    0.11633177f, -0.00489584f, -0.07585936f, 0.04908625f, -0.04110235f, 0.03195400f, 0.05278095f, 0.12456805f, 
    0.33573174f, 0.16062024f, 0.01822509f, 0.01478832f, 0.00482980f, -0.16235214f, 0.25838485f, -0.08035774f, 
    0.06252783f, -0.02923679f, 0.05229257f, 0.04289209f, 0.56166720f, -0.60810769f, 0.07326465f, -0.23211944f, 
    0.02757917f, -0.07997263f, 0.06195204f, -0.01948117f, 0.06160903f, 0.09483617f, -0.09807328f, 0.12548888f, 
    -0.22433613f, -0.12770845f, -0.30490127f, 0.27444559f, -0.05438985f, 0.09773066f, 0.05788712f, 0.03617689f, 
    0.03400863f, 0.01834209f, -0.03095822f, -0.00834135f, -0.07287580f, -0.35470861f, -0.31885412f, 0.07507796f, 
    -0.05574433f, 0.04832377f, 0.00137172f, 0.07265204f, -0.00484323f, 0.12198958f, -0.11275573f, 0.23386331f, 
    0.23567361f, 0.12911329f, -0.05666899f, 0.04746615f, 0.07604367f, 0.14133856f, 0.10254403f, 0.05603105f, 
    -0.01404104f, 0.04181556f, -0.18016896f, -0.06352716f, 0.24628235f, -0.08640470f, -0.26109084f, 0.01907761f, 
    0.22502092f, 0.09083597f, -0.15147227f, -0.02042780f, -0.07980480f, 0.13181143f, 0.02046581f, -0.17108954f, 
    -0.44022879f, -0.06279593f, -0.25508243f, -0.03053349f, -0.05743464f, 0.10780615f, -0.01760077f, -0.14795613f, 
    -0.05251800f, 0.20609289f, -0.10508414f, 0.30033728f, 0.27733418f, 0.32449245f, 0.18363574f, 0.04287616f, 
    0.09568675f, 0.09619924f, 0.10270841f, 0.17510824f, 0.01844129f, -0.04331662f, 0.05202217f, -0.00643649f, 
    0.30258995f, 0.65830094f, 0.24590077f, -0.06825464f, 0.03500654f, -0.05623088f, 0.00423100f, 0.16101855f, 
    -0.03414304f, -0.03958093f, -0.00256772f, 0.05645507f, 0.58730704f, -0.15545489f, -0.39265132f, -0.00871187f, 
    0.06181032f, -0.10694280f, 0.13097054f, 0.17036486f, 0.08176094f, -0.05244730f, -0.03321371f, -0.03816375f, 
    0.06760374f, -0.00701842f, -0.01730884f, 0.19231559f, 0.20777607f, 0.12372264f, 0.20629552f, 0.12541008f, 
    0.09804292f, -0.27998421f, 0.00865262f, -0.03450699f, 0.31056869f, 0.35354409f, 0.28029266f, -0.23738651f, 
    -0.00118306f, -0.00172007f, -0.00797945f, 0.28903589f, 0.01424934f, -0.02469685f, -0.11595166f, -0.02012637f, 
    0.02706854f, -0.09354483f, 0.01778276f, 0.06952208f, 0.14333647f, -0.05673799f, -0.16242178f, 0.01229491f, 
    0.26741117f, -0.14211708f, 0.27919397f, -0.01897793f, -0.57649171f, 0.29115719f, -0.14715950f, 0.32598203f, 
    0.30849206f, -0.07544968f, 0.11808454f, 0.08651985f, 0.00156498f, 0.19070001f, 0.04353227f, 0.11041813f, 
    0.00764413f, 0.23144570f, 0.21620402f, -0.07763827f, -0.07998637f, 0.16131476f, -0.04971716f, 0.07634404f, 
    0.06654652f, -0.12621002f, 0.04188850f, -0.02640983f, 0.06410760f, 0.27840841f, -0.01561361f, -0.09744616f, 
    -0.01645890f, -0.09381329f, 0.04353182f, -0.15192831f, -0.08093351f, -0.15714587f, 0.00936188f, -0.02253479f, 
    -0.21969749f, -0.12579909f, -0.33556196f, -0.02748420f, 0.13207698f, 0.21377981f, 0.21494761f, -0.11589532f, 
    0.00093968f, -0.22111280f, 0.01200720f, 0.09485445f, 0.66252786f, -0.17945106f, 0.53359437f, -0.23672783f, 
    -0.20506424f, -0.02452877f, -0.09893996f, -0.08694143f, 0.19398203f, 0.01183585f, 0.12883726f, 0.03739586f, 
    0.01236302f, -0.22982217f, 0.04802690f, 0.20457093f, -0.17812254f, -0.07327098f, -0.19589502f, -0.08084139f, 
    0.28782797f, 0.06942186f, 0.27595642f, 0.10948414f, 0.18150924f, 0.16906475f, -0.11955068f, -0.05785800f, 
    0.03243670f, -0.04246066f, 0.08819392f, -0.09389748f, 0.13606733f, -0.05939173f, 0.02546022f, 0.19812144f, 
    0.00234380f, -0.14583758f, -0.16437697f, 0.13839541f, 0.11296590f, 0.12698181f, 0.04731861f, 0.06310911f, 
    0.14025158f, 0.07834160f, 0.12302760f, 0.19108284f, 0.01850858f, -0.23319151f, 0.06185922f, -0.01618227f, 
    -0.11799757f, -0.09880001f, 0.03249310f, -0.05458749f, 0.19156758f, 0.31785375f, 0.19689269f, 0.29503801f, 
    -0.12893131f, -0.45942724f, 0.29397377f, -0.22050671f, 0.01654744f, -0.13212804f, 0.03299113f, 0.05619621f, 
    0.03293407f, 0.39858541f, 0.04021370f, 0.13065477f, -0.20088588f, 0.12952460f, -0.19811237f, -0.01807329f, 
    0.14821321f, 0.14465673f, 0.14940257f, -0.15413314f, 0.10498264f, 0.09151979f, 0.02618691f, 0.15406641f, 
    -0.31299594f, 0.04748842f, 0.28736064f, -0.04475524f, -0.06586069f, -0.04538519f, -0.03885797f, -0.14577699f, 
    0.02134591f, 0.05279774f, -0.03733417f, -0.02590761f, -0.04490274f, -0.25508466f, -0.28791484f, 0.26199228f, 
    -0.10250182f, -0.12548336f, 0.17843665f, 0.01440826f, 0.04985468f, -0.11308203f, 0.05164275f, -0.01572968f, 
    -0.21732101f, -0.25716102f, -0.00719819f, 0.03355296f, -0.03888622f, -0.06137379f, 0.10244967f, 0.04092889f, 
    -0.05528241f, -0.23328611f, 0.16624682f, -0.04651876f, -0.15620486f, 0.09026949f, 0.23611894f, -0.34083605f, 
    -0.09504246f, 0.04264084f, -0.00651697f, 0.01386832f, 0.03993936f, 0.05381822f, 0.09912023f, 0.01812989f, 
    -0.03764380f, 0.00067113f, -0.06943058f, 0.03587776f, -0.04155621f, -0.03552142f, 0.03809179f, 0.06548486f, 
    0.00341213f, -0.05845181f, 0.02119778f, 0.06416233f, 0.02667687f, -0.05965329f, -0.03148250f, 0.05130116f, 
    0.05624764f, -0.04896672f, 0.04292859f, -0.06101558f, 0.02195615f, 0.00364807f, 0.00761752f, 0.04395800f, 
    -0.03525911f, -0.05007523f, 0.01116215f, -0.00833231f, -0.03429371f, 0.01100016f, -0.05359173f, 0.03996731f, 
    0.06278388f, -0.05330838f, -0.03412555f, 0.02944367f, -0.04279662f, 0.03413269f, -0.06031421f, 0.03795754f, 
    -0.02386533f, 0.03731938f, 0.03546910f, 0.02154562f, 0.00965352f, 0.02271156f, -0.06397405f, -0.04270596f, 
    0.03564716f, 0.05658428f, 0.06790612f, -0.01474701f, 0.03527107f, -0.00906271f, 0.05576618f, -0.02369550f, 
    -0.06357631f, -0.01595173f, 0.04734430f, -0.05741268f, -0.05871247f, -0.06538307f, 0.01636390f, -0.02239489f, 
    -0.01252646f, -0.04625675f, 0.02524044f, -0.02899653f, -0.03369641f, -0.04288632f, -0.00180894f, -0.01190638f, 
    0.06297033f, -0.00612069f, -0.03741803f, -0.00071349f, -0.06031827f, -0.01162310f, -0.06452260f, -0.01334377f, 
    -0.00971987f, 0.02641882f, 0.04441182f, -0.01149493f, -0.07968012f, -0.05418661f, -0.04616781f, -0.03786784f, 
    0.00203949f, -0.08078178f, -0.00502354f, -0.02778406f, -0.07489029f, -0.05766923f, 0.06029075f, -0.06395880f, 
    -0.05239289f, 0.05891835f, 0.04004866f, -0.02248260f, -0.04579590f, 0.05570972f, -0.06288075f, 0.03340773f, 
    0.02596412f, 0.04006785f, -0.03630839f, 0.03680495f, 0.02250794f, -0.06341032f, -0.07602770f, -0.03670828f, 
    -0.05173771f, 0.01827774f, -0.01451367f, -0.00020900f, 0.00059309f, -0.03160241f, 0.04558594f, -0.06114023f, 
    0.04054001f, -0.06956550f, 0.03942498f, 0.03799868f, 0.02921141f, -0.05733604f, -0.00860124f, 0.00312035f, 
    -0.05000374f, -0.04505765f, -0.04028838f, -0.04241178f, -0.04578593f, 0.02672780f, -0.02121098f, 0.04123598f, 
    0.05517860f, -0.04405426f, 0.01636081f, -0.03259351f, -0.06436802f, -0.03203930f, -0.03819530f, -0.07977126f, 
    -0.00701057f, -0.06770024f, 0.05013197f, -0.05603172f, 0.01665869f, -0.01218123f, -0.06010127f, 0.04532066f, 
    -0.02157407f, -0.00844413f, -0.07369006f, 0.01688850f, 0.05496991f, 0.03626781f, 0.02212882f, -0.06291666f, 
    0.01123135f, -0.02432236f, 0.06162990f, -0.00954545f, -0.02540536f, 0.06506836f, 0.04657936f, -0.03637013f, 
    -0.06440089f, 0.00979882f, 0.02953739f, -0.02973711f, -0.03732557f, -0.01120442f, -0.03774723f, -0.05654168f, 
    0.04853084f, 0.01240674f, 0.03085036f, 0.02271053f, -0.03746807f, -0.07173907f, 0.00415075f, 0.05677504f, 
    0.00929411f, -0.01352343f, 0.05532934f, -0.05667802f, -0.03002939f, 0.03092672f, 0.06140803f, -0.02196355f, 
    -0.15710181f, 0.06215307f, -0.33045924f, -0.28310201f, -0.02790622f, -0.08963889f, 0.10230076f, 0.16544817f, 
    -0.05865698f, 0.07271944f, 0.32484072f, 0.45998895f, 0.49967387f, -0.20916380f, 0.00534054f, 0.12579437f, 
    0.06222528f, -0.13799022f, 0.19104977f, 0.07085448f, 0.14676496f, -0.00336584f, 0.08533397f, 0.07544707f, 
    -0.13028756f, 0.24336798f, 0.37100035f, 0.04506863f, 0.07489055f, 0.05807679f, 0.23738448f, -0.08741164f, 
    0.10163815f, 0.14346330f, -0.03288532f, -0.02416513f, 0.20076483f, 0.15456571f, -0.21347578f, 0.23717083f, 
    -0.00443848f, -0.02733711f, 0.27001575f, 0.09714626f, 0.16727860f, 0.20789987f, 0.19858018f, 0.21368887f, 
    -0.26905960f, -0.35324520f, 0.05768552f, 0.20885617f, 0.04552670f, -0.05384181f, 0.25097689f, 0.10458560f, 
    -0.06513994f, -0.06685022f, -0.12981068f, -0.02563895f, -0.52725494f, 0.52016163f, 1.15931737f, 0.09629427f, 
    -0.04115938f, 0.04451195f, -0.13039190f, 0.11924354f, 0.04992034f, 0.05235058f, 0.15029748f, 0.08631252f, 
    -0.17553180f, 0.04673146f, 0.07333811f, -0.02475745f, 0.10293559f, -0.00817576f, -0.16099410f, 0.01024702f, 
    0.05854993f, 0.06009454f, 0.19198471f, 0.02094895f, -0.37088260f, -0.23197296f, -0.14153124f, -0.47350851f, 
    -0.07709137f, -0.08128626f, 0.02967020f, -0.06174856f, 0.06916163f, 0.01263386f, -0.06022795f, -0.12574251f, 
    0.13034503f, 0.00754330f, -0.20580380f, 0.11494358f, 0.10397597f, -0.05912186f, 0.01173546f, 0.06128228f, 
    0.04508320f, -0.11602329f, 0.06850571f, -0.03617520f, -0.39940429f, 0.18715319f, 0.45082507f, -0.14653687f, 
    0.13968734f, -0.00220258f, -0.18219861f, -0.02146329f, -0.00027473f, 0.06669183f, 0.09147971f, 0.18581693f, 
    0.38501799f, -0.15849999f, -0.10008815f, -0.10197692f, 0.07484392f, -0.06961378f, -0.10312693f, -0.11338907f, 
    -0.05301458f, 0.16434760f, 0.07851800f, -0.14852522f, -0.13427871f, -0.26236036f, 0.04664122f, 0.15055777f, 
    -0.05311478f, -0.05710612f, 0.02414048f, 0.05959547f, 0.06752263f, 0.04525650f, 0.11435183f, -0.03189495f, 
    -0.37192231f, -0.41631901f, 0.15058167f, -0.01810320f, -0.15029241f, -0.15330350f, 0.02251784f, -0.01078875f, 
    0.06227076f, 0.04224363f, 0.06407795f, -0.04273289f, -0.16669320f, 0.07644688f, -0.03121257f, 0.07988026f, 
    0.25217566f, -0.04984726f, 0.02940951f, 0.09090883f, 0.17670606f, -0.00214906f, 0.07239001f, -0.12319899f, 
    0.16580588f, -0.00154856f, 0.00314366f, 0.35050464f, -0.12224306f, -0.06807491f, -0.10895085f, -0.06259909f, 
    0.00467896f, -0.07025228f, 0.08546316f, 0.06936840f, -0.43119347f, -0.22112428f, -0.07205108f, 0.20609646f, 
    -0.06379476f, 0.00449569f, 0.03816779f, -0.29014999f, -0.05432661f, 0.10897846f, -0.01395004f, -0.04130982f, 
    -0.06675114f, -0.06722581f, 0.00525039f, -0.02465230f, 0.04086385f, 0.06111147f, -0.06833708f, -0.00044520f, 
    -0.06548157f, 0.02801655f, 0.05306598f, 0.03876196f, -0.01688723f, -0.06271248f, -0.07914103f, -0.01134774f, 
    -0.01193654f, 0.01369229f, -0.00997031f, 0.01233489f, -0.06078923f, -0.06837773f, 0.03047202f, -0.07652672f, 
    -0.01089165f, -0.04737581f, -0.02160082f, -0.05465985f, -0.02318109f, -0.02586021f, -0.02900207f, -0.07813661f, 
    -0.05556851f, -0.00415554f, -0.05021309f, 0.03957297f, -0.00912608f, 0.01050679f, -0.03845029f, -0.02424297f, 
    -0.07252052f, 0.02497594f, 0.01782062f, 0.04413639f, 0.02411975f, -0.07397866f, -0.00847690f, -0.04580162f, 
    -0.01446386f, -0.06480540f, -0.03719078f, -0.04640550f, -0.04334452f, -0.00719312f, -0.01503783f, -0.03716703f, 
    0.01720926f, -0.01112381f, 0.04510895f, 0.04607407f, -0.03844970f, 0.00831723f, 0.04516569f, 0.01497885f, 
    -0.01384979f, -0.00368417f, -0.02632824f, -0.01539002f, 0.03308213f, 0.04446794f, -0.03524831f, -0.02560411f, 
    0.04975262f, 0.00976458f, 0.05300366f, -0.01696631f, 0.03415407f, 0.05073638f, -0.05198184f, -0.02026200f, 
    0.01717138f, 0.01644320f, -0.05257066f, 0.02755043f, 0.05605193f, -0.06655475f, 0.03483021f, 0.01887397f, 
    -0.07619356f, 0.00428395f, -0.04449980f, -0.04110224f, 0.05182043f, -0.02370381f, 0.03765338f, -0.01487082f, 
    -0.04063541f, -0.04630034f, 0.06030656f, -0.04181379f, -0.04793248f, -0.01092378f, -0.00851067f, 0.03514220f, 
    -0.04917697f, -0.06834628f, 0.00144336f, -0.06034442f, -0.03523666f, 0.00483914f, -0.04152594f, -0.00570023f, 
    -0.00943418f, 0.00943375f, 0.05496609f, 0.00602779f, 0.01731724f, -0.05048768f, 0.02821587f, -0.01967769f, 
    0.00370058f, 0.05152690f, -0.05802925f, 0.04549168f, 0.01065738f, -0.03315727f, 0.00293313f, 0.02614696f, 
    -0.00046531f, 0.05087798f, 0.02253991f, 0.00937019f, 0.04601371f, 0.06123787f, -0.01023059f, -0.03065969f, 
    0.04092499f, -0.01709697f, -0.02995564f, -0.03581313f, 0.04269777f, 0.04553936f, -0.01168543f, -0.01115604f, 
    0.00979933f, 0.04435182f, -0.01710891f, 0.03328929f, 0.06214042f, 0.04771149f, -0.06473186f, 0.00047447f, 
    -0.07253017f, -0.07354747f, -0.05173328f, 0.01995651f, -0.07660167f, 0.05710765f, 0.00562817f, 0.03014628f, 
    0.04285033f, -0.01329586f, 0.04400593f, 0.00057057f, -0.05277002f, -0.06478876f, 0.06463731f, -0.02534061f, 
    0.04323428f, 0.02921041f, -0.05587254f, -0.03036365f, -0.03139464f, -0.04220951f, 0.01930080f, -0.04523147f, 
    -0.00108705f, -0.02597358f, 0.00124050f, 0.04865772f, 0.06146714f, -0.06560966f, -0.01539046f, -0.00895183f, 
    0.05488159f, -0.04267060f, 0.03971410f, -0.01811867f, -0.02674352f, -0.05064865f, -0.01978446f, -0.02204382f, 
    0.08345288f, 0.22367774f, -0.18197466f, -0.10682368f, 0.00404504f, 0.09598894f, -0.09430495f, 0.00638154f, 
    0.05176123f, -0.06076161f, -0.09463178f, 0.10526605f, -0.08435472f, 0.09553719f, 0.25050110f, 0.05169181f, 
    0.19656932f, 0.03979198f, 0.23139948f, 0.07168961f, 0.09761795f, -0.11293418f, 0.05065900f, 0.16109014f, 
    -0.11711555f, -0.21062791f, 0.40639362f, -0.13614054f, 0.00982982f, 0.08334937f, 0.05531934f, -0.02162961f, 
    -0.01142777f, -0.00075141f, 0.09588809f, -0.08422650f, 0.16705760f, 0.04666353f, -0.07545724f, 0.11058540f, 
    -0.14216396f, -0.07935879f, 0.19754168f, -0.08703023f, 0.02485072f, 0.19591644f, 0.02615916f, -0.12453454f, 
    -0.04392669f, -0.02637080f, 0.02479466f, -0.07512072f, 0.12635782f, 0.20849299f, 0.06606539f, 0.60329574f, 
    0.07004198f, -0.07701693f, 0.06757001f, -0.15648787f, -0.31547183f, -0.17760095f, 0.52187270f, -0.01151012f, 
    -0.03753943f, -0.06469182f, 0.03087573f, 0.24036367f, -0.02661061f, -0.19053456f, -0.08917516f, 0.08395261f, 
    0.01309630f, 0.13268411f, -0.07179716f, -0.02061637f, 0.02846309f, -0.08121453f, -0.06446803f, -0.06132391f, 
    0.26248720f, 0.06546548f, 0.05101732f, 0.01950123f, 0.08059075f, 0.25493890f, -0.09996930f, 0.34465277f, 
    -0.01731430f, 0.06473726f, 0.01305108f, 0.00169345f, 0.13480037f, -0.04052322f, 0.17227057f, -0.13087372f, 
    0.08313832f, -0.00703395f, -0.07266066f, 0.06606805f, -0.12597024f, 0.05278295f, 0.16062406f, 0.01762684f, 
    0.09880942f, 0.04045761f, 0.08558419f, -0.04773987f, -0.14563057f, -0.29201105f, 0.09917623f, -0.25578073f, 
    0.00480732f, 0.09338797f, 0.08388205f, -0.03987576f, 0.00076932f, -0.04728379f, 0.08019600f, 0.14049618f, 
    0.18269071f, 0.28319895f, -0.21737590f, 0.17100526f, 0.05406659f, 0.00765422f, 0.05175400f, -0.10123585f, 
    0.09796320f, -0.10789246f, -0.15010218f, 0.12823202f, -0.05184500f, -0.11211988f, 0.19393668f, 0.29806268f, 
    0.06528678f, 0.08642753f, 0.02579897f, 0.18146187f, 0.05864548f, -0.06927398f, 0.01763004f, -0.05831385f, 
    -0.41307452f, -0.22872011f, 0.05336332f, -0.30278394f, 0.03115096f, 0.04415344f, 0.16072062f, 0.15135545f, 
    0.09469108f, 0.00496972f, 0.05562035f, 0.00333901f, 0.05390029f, 0.09285469f, 0.34711072f, 0.28855664f, 
    0.13113886f, -0.06871831f, -0.13447504f, 0.07705265f, 0.17570972f, 0.10766838f, 0.02890197f, 0.06160801f, 
    0.32133180f, -0.30767176f, -0.21005197f, -0.06762534f, -0.00680752f, 0.02431020f, -0.01718262f, -0.28289956f, 
    0.11114652f, 0.03912807f, -0.06256678f, 0.07227283f, -0.43865198f, -0.24628395f, -0.08405761f, 0.08419524f, 
    -0.18058826f, 0.18130329f, -0.09915488f, 0.05303483f, 0.04676916f, -0.02640182f, 0.18841192f, 0.04011040f, 
    -0.26467785f, 0.17894447f, -0.07474944f, -0.07115689f, -0.13588308f, 0.14918451f, 0.04278243f, -0.41149268f, 
    -0.09334775f, 0.59402770f, -0.15073244f, 0.06212207f, 0.45740947f, -0.03567216f, -0.37036538f, -0.08864597f, 
    -0.18402393f, 0.03183051f, 0.00585811f, -0.00975817f, -0.26013058f, 0.06762476f, -0.21203758f, 0.04794631f, 
    0.22318083f, 0.35311306f, 0.10485817f, 0.41120863f, 0.10617435f, -0.18273814f, 0.23577443f, 0.23179504f, 
    0.06067574f, 0.08192346f, 0.10525053f, 0.08878953f, -0.24205776f, 0.04466703f, 0.11998064f, 0.21213862f, 
    0.16986126f, 0.00076252f, -0.08864330f, -0.21299253f, 0.00062901f, 0.11735468f, -0.14399391f, 0.05211538f, 
    -0.41231743f, 0.11093066f, 0.23150398f, -0.05675742f, -0.17523874f, -0.07728378f, 0.04634019f, 0.17212640f, 
    -0.18774296f, 0.07280343f, 0.08892222f, -0.18621819f, 0.15807797f, 0.28451508f, 0.26701924f, -0.17011760f, 
    -0.00147764f, -0.14087296f, -0.36545983f, -0.20730221f, -0.17663100f, 0.27469701f, -0.06570567f, 0.04318656f, 
    0.30835792f, -0.00632937f, 0.14759447f, 0.10015357f, 0.02130347f, -0.00312735f, 0.01536019f, -0.21323065f, 
    -0.04585952f, 0.25221488f, -0.05443181f, -0.00670295f, -0.43260688f, -0.48339191f, 0.06612930f, -0.00833784f, 
    -0.17470810f, -0.10987269f, -0.16145658f, -0.14475495f, -0.09091130f, 0.06432273f, -0.11278212f, -0.05525210f, 
    0.00057077f, 0.13885549f, 0.34415519f, -0.30319864f, 0.13499205f, 0.02685439f, 0.17756614f, 0.12035650f, 
    -0.01567084f, 0.05716519f, -0.16687040f, -0.16657418f, 0.22918509f, 0.27809006f, -0.16910931f, 0.15302889f, 
    0.11173193f, 0.02568324f, -0.01185138f, 0.45045462f, 0.19471031f, -0.12244758f, -0.18616179f, -0.28177267f, 
    -0.10313722f, -0.17701535f, -0.00542376f, 0.13312750f, -0.07071252f, -0.00077541f, 0.05760153f, -0.46779647f, 
    0.00857602f, -0.31512555f, -0.19633490f, 0.29656374f, 0.16525076f, 0.30087370f, 0.13382509f, 0.08682082f, 
    0.12588644f, 0.15982433f, 0.09649611f, 0.20950440f, -0.06054207f, -0.04454906f, -0.09030562f, -0.00502188f, 
    0.54548621f, 0.17183419f, 0.14216693f, 0.16773556f, 0.17266428f, -0.06178841f, -0.15601194f, 0.19945554f, 
    0.05063488f, 0.09608857f, 0.07536408f, -0.06469134f, 0.21500334f, 0.31383190f, -0.07059388f, 0.32124925f, 
    0.05257684f, -0.01037138f, 0.16789640f, 0.27594686f, -0.17597660f, 0.07214244f, -0.06237962f, 0.00003375f, 
    0.27878767f, 0.60851651f, 0.17828272f, -0.04850464f, -0.09003045f, 0.25453228f, -0.04208488f, -0.04436207f, 
    -0.02690626f, -0.15934373f, 0.02579470f, 0.15316597f, 0.32049033f, 0.17936029f, 0.06032773f, 0.27387616f, 
    -0.04974692f, 0.21126226f, 0.03436675f, 0.35114777f, -0.02810203f, -0.02125372f, -0.10575039f, -0.02020159f, 
    -0.02170012f, 0.01377292f, 0.04188020f, -0.05713008f, 0.05714989f, -0.04736574f, 0.00724791f, -0.01683654f, 
    0.03657902f, -0.07273062f, -0.03844144f, 0.02686144f, 0.03274726f, -0.06329850f, 0.06148447f, -0.01482313f, 
    -0.05308007f, -0.05780143f, 0.05717244f, 0.01873134f, -0.07816897f, 0.04830084f, -0.06203888f, -0.02488065f, 
    -0.05490888f, -0.00418135f, -0.03678733f, -0.02866270f, -0.07301722f, -0.07422246f, 0.04412303f, -0.05280608f, 
    -0.00963362f, -0.04448130f, 0.01757632f, -0.01652472f, 0.04136071f, 0.03862885f, -0.02603268f, -0.06611770f, 
    -0.01004034f, -0.06102030f, 0.02805807f, -0.02615792f, -0.06843075f, -0.00378612f, -0.02209492f, 0.04880207f, 
    -0.06836238f, -0.07631985f, 0.05843103f, -0.02412216f, -0.01878980f, -0.05722708f, 0.00901261f, -0.06652651f, 
    0.03178946f, -0.00360237f, -0.05223488f, -0.02781974f, 0.05370286f, -0.05922312f, -0.00884149f, -0.00625835f, 
    -0.06693333f, -0.06280666f, 0.03882731f, 0.02592889f, 0.02708553f, 0.02597339f, -0.02331768f, -0.04727311f, 
    -0.02291479f, -0.00749160f, 0.04763644f, -0.04549636f, -0.06535996f, -0.00139827f, 0.03510230f, -0.07230290f, 
    -0.04437926f, -0.00195765f, 0.02166237f, 0.02340475f, -0.05020430f, 0.00789636f, 0.01223499f, -0.01353713f, 
    0.04164397f, -0.07673521f, 0.05384041f, -0.02451061f, 0.00054292f, 0.05100466f, 0.05367565f, -0.00961154f, 
    0.02528753f, 0.02588436f, 0.01927765f, 0.01833853f, 0.02411667f, -0.00236102f, -0.04747841f, -0.07470250f, 
    -0.05683408f, -0.03029065f, -0.05714878f, -0.07115942f, 0.04705418f, 0.03284268f, -0.02946677f, 0.05256335f, 
    0.02852540f, 0.02688670f, -0.00949592f, -0.07230317f, -0.01395870f, 0.04386355f, 0.00945520f, 0.01987868f, 
    -0.04649818f, -0.06781118f, -0.06184348f, -0.04313409f, -0.05456670f, 0.00729165f, -0.08006085f, -0.07767408f, 
    0.02430106f, 0.03655020f, -0.06805546f, -0.06989138f, -0.07115567f, 0.03232156f, 0.03001387f, 0.05032864f, 
    0.01394418f, 0.01114031f, 0.01154393f, 0.01331090f, -0.05167457f, 0.04935430f, 0.04872208f, -0.04062968f, 
    0.02858221f, -0.07676848f, -0.01076843f, 0.06011233f, -0.06631832f, -0.01642085f, -0.04406330f, -0.02030502f, 
    -0.06507245f, 0.05729916f, -0.05637097f, -0.01473550f, -0.07811188f, -0.02411326f, 0.05223014f, -0.02051269f, 
    0.05486653f, 0.03916061f, -0.04041747f, -0.00023173f, -0.05681042f, -0.07191265f, 0.05740582f, -0.01548335f, 
    -0.00940909f, 0.01469955f, -0.01192834f, -0.08040282f, 0.04025529f, 0.02256803f, 0.05671996f, -0.01390835f, 
    0.01599640f, 0.03581868f, -0.05191326f, 0.02909517f, -0.00793303f, -0.04172529f, -0.05533019f, 0.02512451f, 
    -0.00335140f, 0.01932192f, 0.02748457f, -0.03406058f, 0.02832306f, -0.05055670f, -0.03060041f, -0.06586134f, 
    -0.03506736f, 0.15035743f, -0.09304192f, 0.02655178f, 0.02073877f, 0.09427315f, 0.09271140f, 0.07703903f, 
    0.28779197f, 0.12932454f, 0.29360279f, 0.23918681f, -1.09207666f, 0.05141481f, -0.21855497f, -0.12520202f, 
    0.03493497f, 0.25691134f, 0.02720032f, -0.10007101f, 0.21757825f, -0.05256708f, 0.16713169f, -0.03714081f, 
    0.10550795f, 0.28025311f, 0.41588420f, -0.51253206f, 0.03373091f, -0.15462810f, -0.03400842f, 0.15898287f, 
    -0.00119569f, 0.02868096f, -0.00815281f, 0.02687560f, 0.17184642f, 0.33023417f, -0.01443355f, -0.16788480f, 
    0.07143267f, -0.01635476f, 0.16616648f, 0.02082284f, 0.07802372f, 0.08439370f, 0.22685924f, 0.10734778f, 
    0.28540030f, -0.11696542f, -0.14781864f, -0.30897498f, 0.19858088f, 0.05162717f, 0.00652346f, -0.00639655f, 
    -0.05038183f, 0.12868333f, -0.12293632f, 0.06076623f, 0.44028276f, -0.28682724f, 0.30056688f, -0.00260512f, 
    0.02211050f, -0.14708641f, -0.12277739f, 0.06201484f, -0.12569124f, -0.00164766f, 0.18998984f, 0.03032972f, 
    -0.45115212f, -0.00624757f, 0.25456882f, 0.46494469f, 0.01546253f, 0.04345049f, -0.06655013f, 0.00343070f, 
    0.02869593f, 0.06940290f, 0.08791248f, -0.05052532f, 0.08372180f, -0.13007036f, -0.34932253f, 0.13119319f, 
    0.15528452f, 0.24184220f, 0.06403415f, 0.04618718f, 0.01445877f, 0.04435517f, -0.02533160f, -0.01418886f, 
    -0.09083467f, -0.13101107f, 0.07429459f, 0.11542840f, -0.04990252f, 0.25465971f, 0.08180673f, 0.10487907f, 
    0.03809244f, -0.18085222f, -0.10114240f, -0.08393314f, -0.34253198f, -0.02796536f, 0.26019922f, -0.07225402f, 
    0.22593288f, -0.05963451f, -0.16300665f, 0.13206437f, 0.17683437f, 0.00327405f, -0.01701968f, 0.19933863f, 
    -0.60281253f, -0.07999055f, 0.44983354f, 0.37423843f, 0.27242759f, 0.29493913f, 0.00888797f, 0.10531086f, 
    0.03969171f, 0.10746550f, 0.20377520f, -0.19370857f, -0.08054629f, -0.08665849f, -0.06960078f, -0.07838302f, 
    -0.01998445f, 0.05447946f, 0.04093131f, -0.10603317f, -0.06581482f, -0.09944724f, -0.03928079f, -0.07467128f, 
    -0.16623898f, 0.16297348f, 0.23012611f, -0.21361428f, -0.04550994f, 0.03068338f, 0.10004138f, 0.09796437f, 
    -0.00521867f, 0.03939833f, 0.10768967f, -0.01255464f, -0.59018701f, 0.10469244f, 0.41950169f, 0.05140867f, 
    -0.01174025f, 0.01934377f, -0.11791453f, -0.09356088f, 0.00766854f, -0.08455110f, 0.03047898f, -0.06077498f, 
    -0.29917106f, 0.22722775f, 0.32409212f, 0.04211901f, 0.03855488f, -0.05181551f, 0.13441953f, 0.06096915f, 
    -0.03071078f, -0.10409088f, -0.07255132f, -0.05031510f, 0.12719247f, 0.07868843f, -0.06300373f, -0.28651175f, 
    -0.01195098f, 0.12492885f, -0.00092379f, -0.02197511f, 0.03830450f, -0.12645186f, 0.02210168f, -0.18384843f, 
    -0.02363189f, -0.00447642f, 0.03638028f, -0.05214596f, 0.02651979f, -0.07673772f, -0.07350320f, 0.05490841f, 
    -0.03721517f, -0.07560757f, -0.09147669f, 0.02550882f, -0.01214910f, 0.03837973f, -0.02757372f, -0.00420026f, 
    -0.05404640f, -0.06682729f, -0.01578748f, 0.00833309f, 0.06099715f, -0.06815096f, 0.01319888f, -0.03686850f, 
    -0.02547466f, -0.00171833f, 0.04471581f, -0.06181197f, -0.08702972f, -0.01942119f, -0.07512912f, -0.09493516f, 
    -0.05548309f, -0.06990148f, -0.05457576f, 0.01838290f, -0.05440601f, 0.03626595f, 0.05126549f, 0.03672864f, 
    -0.07089651f, 0.05931465f, -0.06643999f, -0.02362900f, 0.03015055f, -0.04457969f, 0.02090989f, 0.04567366f, 
    -0.03940754f, 0.01400117f, 0.04216925f, -0.05259993f, 0.01284066f, 0.05965059f, -0.08689796f, 0.06517692f, 
    0.02650767f, -0.06208628f, -0.00127116f, 0.02251155f, -0.00387164f, 0.08749377f, 0.04761645f, -0.01359838f, 
    -0.03270436f, -0.04174121f, -0.03895758f, -0.07486786f, 0.00680873f, 0.05561869f, 0.05480908f, 0.00886362f, 
    0.06553334f, -0.05318015f, 0.03055054f, -0.05792810f, 0.02376648f, -0.08104939f, 0.00315235f, -0.05817769f, 
    -0.07428867f, 0.03263082f, -0.04349274f, 0.08664263f, -0.00611114f, -0.00783321f, -0.04471320f, 0.06578146f, 
    -0.03127946f, 0.03560983f, 0.03538750f, -0.07117022f, -0.04100787f, 0.02913168f, -0.01975814f, 0.00983903f, 
    -0.02813535f, -0.02866896f, -0.10503450f, -0.00304509f, -0.01374532f, -0.09101944f, -0.00714193f, 0.00287255f, 
    0.03228708f, -0.05083497f, -0.07131219f, -0.06006883f, 0.02962726f, 0.00869340f, -0.07438423f, 0.00811163f, 
    -0.05975861f, -0.08574063f, -0.06652074f, 0.03309699f, 0.00271855f, -0.00049597f, -0.03633718f, 0.04696457f, 
    0.08799493f, -0.00985433f, -0.04232430f, 0.03709116f, -0.03225161f, 0.06405731f, 0.02831825f, 0.05546959f, 
    -0.03853578f, -0.01509530f, -0.06866975f, 0.01893638f, -0.05753247f, -0.07613102f, 0.00948797f, -0.04107840f, 
    -0.02339673f, 0.05623436f, 0.00563898f, -0.06301781f, 0.03376192f, -0.06416404f, 0.01950935f, 0.04968718f, 
    -0.00636452f, -0.08416916f, 0.00387188f, 0.00216525f, -0.08568268f, -0.02663684f, 0.00495382f, -0.00661114f, 
    -0.03371263f, 0.01871825f, -0.05165906f, -0.01513344f, -0.00145852f, 0.04641590f, 0.02079819f, -0.07037816f, 
    0.01443390f, -0.01863487f, 0.04017836f, -0.00542469f, -0.00951165f, -0.03952855f, 0.02190657f, 0.04338735f, 
    0.02118605f, -0.02473979f, -0.03933211f, -0.06505813f, 0.00331720f, -0.07570456f, 0.05395254f, 0.01318316f, 
    0.01303886f, -0.10297209f, -0.00557593f, 0.02253673f, -0.02888946f, -0.04309101f, -0.06460757f, -0.01109835f, 
    -0.07491549f, 0.01305192f, 0.02038360f, 0.02898048f, -0.08516657f, -0.01478345f, 0.01170527f, 0.03596619f, 
    0.12695177f, 0.06778479f, 0.06233933f, 0.02416228f, -0.02327846f, -0.03474491f, -0.00021857f, 0.02710312f, 
    0.05810953f, 0.15245765f, 0.18429579f, 0.11111827f, -0.00656754f, -0.23341896f, 0.30806375f, -0.04958314f, 
    0.11739630f, -0.03816285f, 0.13899498f, 0.03175634f, -0.01789172f, 0.04344515f, 0.14568445f, 0.04351182f, 
    -0.20935941f, -0.10349845f, -0.05511707f, 0.11923812f, 0.00767574f, 0.00038042f, -0.09079851f, 0.05353333f, 
    -0.00435562f, 0.05582674f, -0.13236645f, 0.08093505f, 0.14043526f, 0.15684828f, 0.05876053f, 0.17744493f, 
    0.06332406f, -0.05997854f, 0.04404014f, 0.01202892f, -0.04726566f, -0.10192414f, -0.07253254f, -0.26731154f, 
    0.28493622f, 0.07480975f, -0.11035804f, -0.14947505f, -0.03210735f, 0.21084435f, -0.11665044f, -0.16826043f, 
    -0.07017072f, -0.03148540f, 0.07921758f, -0.00081701f, 0.34515023f, 0.70169562f, -0.56713194f, 0.32460707f, 
    -0.11649046f, 0.07015569f, -0.08430563f, 0.02599105f, -0.04089607f, 0.06685499f, 0.20272353f, -0.16344707f, 
    -0.25285149f, -0.13373606f, 0.19200993f, -0.02174990f, -0.03928837f, -0.10464792f, 0.00806982f, -0.00855717f, 
    0.01611895f, 0.05835593f, 0.21191539f, 0.23019333f, 0.27411750f, 0.15875942f, 0.41354010f, 0.06223243f, 
    -0.09736481f, -0.01840115f, -0.11300125f, -0.03538667f, -0.09497105f, 0.11084086f, 0.01108586f, 0.13736576f, 
    -0.11687998f, 0.06286263f, 0.10752121f, -0.11183258f, 0.11059967f, 0.04470142f, -0.13399078f, 0.06646541f, 
    -0.16585597f, 0.06336246f, 0.18137035f, 0.10209934f, -0.07734498f, 0.07794705f, 0.32151946f, 0.22208014f, 
    0.09997196f, -0.13466743f, 0.02041299f, -0.00118669f, 0.11044994f, 0.01294468f, 0.16146670f, 0.27279556f, 
    -0.26645371f, -0.37547290f, 0.25244424f, 0.08782675f, -0.07540921f, 0.14111449f, -0.08952280f, 0.19891468f, 
    0.06188633f, 0.21602446f, 0.23814759f, 0.10875384f, -0.22067821f, -0.05302056f, -0.34959841f, -0.04194640f, 
    -0.01786385f, 0.06333692f, -0.03879275f, -0.14837751f, -0.02937019f, 0.08543263f, -0.03855051f, 0.10450137f, 
    0.18016271f, -0.09754955f, 0.02588259f, 0.13495694f, -0.19106586f, 0.01485529f, -0.02894766f, -0.21281576f, 
    -0.07623353f, 0.09517284f, -0.00968410f, -0.16940010f, -0.64494407f, -0.19653715f, 0.55411589f, -0.16861187f, 
    -0.15483215f, 0.29264304f, 0.02333318f, 0.04958360f, -0.03665043f, 0.01254659f, 0.04857681f, 0.03453497f, 
    -0.45895433f, 0.36611867f, -0.07277175f, 0.06137790f, 0.01775703f, -0.23135257f, 0.04928280f, 0.18557915f, 
    -0.14349882f, -0.06269316f, -0.00309345f, -0.14165169f, -0.07323153f, -0.01529295f, 0.05548069f, 0.08864974f, 
    -0.15705039f, 0.09263603f, 0.00401973f, -0.08218732f, 0.08743928f, 0.04234137f, 0.05808652f, -0.00757846f, 
    0.28428629f, 0.15202612f, 0.14968371f, 0.07017890f, -0.16169073f, 0.09004497f, 0.07073117f, -0.05719066f, 
    0.26098087f, 0.25195667f, 0.17415659f, 0.26011351f, 0.18195419f, -0.20512584f, -0.17631908f, -0.11759650f, 
    0.04233267f, 0.21882431f, 0.06333489f, 0.04200166f, -0.03009555f, -0.02477251f, 0.08937341f, -0.05726310f, 
    -0.23678090f, -0.04934474f, -0.16539398f, 0.18746161f, 0.15301849f, 0.15190800f, 0.13539675f, 0.12184822f, 
    0.17986628f, 0.08012713f, 0.10806859f, 0.10767137f, 0.18503052f, 0.09424753f, 0.10788961f, 0.27142105f, 
    -0.06457562f, 0.01973829f, 0.15752140f, 0.01454029f, 0.17591248f, 0.06509795f, 0.14177983f, 0.23953916f, 
    0.03391070f, -0.01871008f, -0.02664645f, -0.03502633f, 0.04783736f, -0.28944468f, 0.01621957f, -0.10192484f, 
    -0.01753231f, -0.03024361f, -0.15539575f, -0.14630051f, 0.03002061f, 0.16385989f, -0.16171455f, -0.04108990f, 
    -0.05143813f, -0.08760218f, -0.00000594f, 0.03631817f, 0.13764086f, 0.16620269f, 0.12565084f, 0.00174871f, 
    0.48217317f, 0.10997094f, 0.19714443f, -0.05779859f, 0.06321204f, -0.04470569f, 0.04067603f, 0.01568941f, 
    0.10614447f, -0.01525566f, -0.08018878f, 0.26260075f, 0.29642555f, 0.32349131f, 0.47774991f, -0.02523254f, 
    0.13192329f, -0.02204097f, -0.05261783f, 0.09290349f, 0.11351296f, 0.13612816f, -0.11315308f, -0.05074492f, 
    -0.18214059f, -0.06218669f, -0.10022616f, 0.04326066f, -0.00703996f, -0.18059757f, -0.10453606f, -0.09345329f, 
    -0.27261421f, -0.28221956f, -0.26290107f, -0.25609848f, 0.03460561f, 0.10122277f, 0.13802326f, 0.10982621f, 
    0.13769335f, -0.20281380f, -0.08230218f, -0.08719321f, 0.06726027f, -0.13700347f, -0.08781591f, 0.02235412f, 
    0.25583723f, -0.09142326f, 0.14941050f, 0.32562298f, 0.08116043f, -0.07686757f, -0.12687367f, 0.04782613f, 
    0.02332709f, -0.02646505f, 0.24593808f, -0.22440405f, -0.28980523f, -0.34938964f, -0.41180825f, -0.11018149f, 
    0.09332476f, 0.16240171f, 0.06654693f, -0.02538028f, -0.13035156f, 0.05765790f, 0.05546110f, -0.02208066f, 
    -0.00000047f, -0.16343328f, 0.04200394f, 0.26448229f, -0.07913574f, -0.21074541f, -0.12424595f, 0.00883903f, 
    -0.08607272f, 0.05543659f, 0.09477270f, 0.02595662f, -0.64580971f, -0.13000226f, -0.08434314f, -0.23857601f, 
    0.26109862f, 0.03557841f, 0.06006888f, -0.02615259f, -0.23516625f, 0.20111200f, -0.11109883f, 0.09438466f, 
    -0.05770845f, -0.07734822f, 0.07873816f, 0.18197100f, -0.17345522f, -0.17612207f, -0.07774622f, 0.02135322f, 
    -0.10176481f, -0.01785355f, -0.10323472f, -0.23334828f, -0.17552558f, -0.17479202f, -0.18693718f, -0.01507469f, 
    0.14137006f, 0.07535679f, 0.00254748f, 0.10003418f, -0.12544289f, 0.03560252f, 0.06918643f, 0.12298760f, 
    -0.06406923f, 0.03932891f, -0.16630314f, -0.23288162f, 0.03585903f, -0.11401897f, 0.04673001f, 0.03788471f, 
    -0.08615194f, 0.04989051f, -0.01876548f, 0.13524735f, 1.17572105f, -0.46981862f, 0.28079373f, 0.17406742f, 
    -0.12829107f, 0.11574651f, 0.10014901f, -0.08854710f, 0.04673937f, 0.07271203f, 0.03890593f, 0.05776852f, 
    -0.02425061f, -0.01161787f, -0.17773053f, 0.50589669f, -0.10732975f, 0.04484762f, 0.18089975f, -0.10471209f, 
    0.04546791f, 0.13107191f, -0.04173413f, 0.07768087f, -0.11155250f, 0.22255999f, 0.11818998f, 0.44960472f, 
    -0.05130257f, 0.01387038f, 0.06023032f, 0.10878073f, 0.10003310f, 0.17599501f, 0.03248035f, 0.32442316f, 
    -0.08256916f, 0.13722157f, 0.31011441f, 0.29939359f, -0.28771412f, -0.02737268f, 0.19758469f, -0.05638619f, 
    0.09623422f, 0.07857499f, -0.06783157f, 0.05384000f, -0.66249955f, 1.12417352f, 0.26589987f, 0.56453270f, 
    0.03468894f, 0.02375738f, 0.17445669f, -0.04638493f, 0.01292871f, 0.12117632f, 0.14113057f, 0.02079197f, 
    0.02853637f, -0.26566213f, 0.12460021f, -0.35243484f, 0.05610365f, 0.13186583f, 0.20697758f, 0.02920378f, 
    -0.15247038f, 0.08815358f, -0.05690838f, 0.21503480f, -0.34575972f, -0.21923235f, 0.28444847f, -0.43693775f, 
    -0.16530572f, -0.18625697f, 0.02592549f, -0.04675468f, -0.14713679f, 0.05615615f, -0.20525895f, 0.08382709f, 
    -0.05058325f, 0.11541251f, -0.05744893f, -0.10595251f, 0.07168224f, -0.21054061f, 0.00354110f, 0.05467563f, 
    0.00714107f, 0.15982942f, 0.12154096f, 0.05578637f, -0.24633698f, 0.26380563f, 0.00094636f, 0.07751269f, 
    0.08967606f, 0.11521892f, -0.09814373f, 0.11375317f, 0.15920928f, -0.10912631f, -0.01325613f, -0.13618506f, 
    0.37690091f, -0.25786254f, -0.44495961f, -0.30368164f, -0.09884431f, 0.03913558f, 0.05646819f, 0.17212853f, 
    0.01322078f, 0.13660981f, 0.13374653f, 0.10359059f, 0.06316311f, -0.10892162f, -0.23230550f, -0.14165568f, 
    -0.01339151f, -0.07871773f, -0.10900667f, -0.04784300f, -0.07059304f, 0.01137726f, 0.11235781f, -0.07577724f, 
    0.24907742f, -0.21835990f, -0.13612448f, 0.34726131f, -0.20388602f, -0.01363076f, -0.00165674f, -0.28096145f, 
    -0.03167817f, 0.00294888f, 0.01110369f, -0.01727283f, 0.07440385f, -0.19864804f, 0.19136913f, -0.18017800f, 
    -0.12795404f, 0.13676567f, 0.10591757f, 0.06429143f, -0.08496284f, 0.08026138f, 0.08304442f, -0.06634355f, 
    -0.17852738f, 0.11399248f, 0.01991512f, 0.49097618f, 0.31361160f, -0.07484634f, 0.14355600f, 0.15778914f, 
    -0.03894536f, -0.01559773f, 0.04443976f, -0.05254484f, -0.05827846f, -0.24851237f, -0.20637694f, 0.18377371f, 
    -0.17351827f, -0.08315250f, 0.00504460f, -0.38476542f, -0.04177151f, 0.04010986f, -0.06187666f, -0.04801401f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13932364f, 0.07477405f, -0.01511053f, 0.31415778f, 0.03230336f, -0.11527111f, 0.03373602f, 0.04562180f, 
    0.23303621f, -0.12350856f, -0.03888123f, -0.00535800f, -0.00369634f, 0.11494600f, -0.07709950f, -0.00100062f, 
    0.14836837f, 0.01729554f, 0.14847226f, 0.08707339f, 0.50517666f, -0.06667718f, 0.14944702f, 0.04685519f, 
    0.09319709f, -0.18709745f, 0.02887120f, 0.11883234f, -0.00169526f, 0.23410942f, 0.13291603f, 0.03317131f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.29342484f, -0.24245614f, 0.22897394f, -0.23708390f, 0.31742814f, 0.09467421f, 0.07698911f, -0.02170037f, 
    -0.69956046f, 0.09714847f, 0.11999933f, -0.71418911f, -0.18247259f, -0.29505092f, 0.12555183f, 0.04508943f, 
    0.09542373f, -0.09859010f, -0.76007932f, 0.28131914f, -0.48993710f, 0.12526281f, -1.10424042f, 0.00871271f, 
    -0.48306566f, 0.24128483f, 0.07350316f, 0.08289246f, -0.03990781f, -0.17131351f, 0.07017092f, -0.20404120f, 
    0.06211902f, -0.27087677f, 0.36074048f, 0.49152532f, -0.24670739f, -0.19576184f, 0.18981853f, -0.15519372f, 
    0.23310749f, -0.27173629f, -0.48574013f, -0.19851622f, -0.11846738f, 0.12213624f, -0.08155601f, -1.10534871f, 
    -0.09085775f, -0.13718338f, 0.22837235f, 0.23574319f, 0.28830615f, -0.16151753f, -0.73393643f, -0.09223618f, 
    -0.32162067f, 0.00177124f, -0.16179998f, -0.10359330f, 0.04796002f, 0.26553914f, 0.57255644f, -0.12728111f, 
    -0.49255896f, -0.41965830f, -0.13943283f, 0.63246924f, -0.19363128f, -0.11916886f, -0.81078309f, -0.19834255f, 
    -0.11664100f, 0.24209599f, 0.09390958f, 0.11876076f, 0.03113575f, -0.05355950f, 0.07090374f, -0.05779595f, 
    -0.05046242f, 0.13657030f, 0.49640316f, 0.11929505f, 0.28960359f, -0.09164206f, 0.18086149f, 0.00706744f, 
    0.05665347f, 0.16626967f, 0.15597387f, -0.11448297f, -0.06992184f, -0.23308882f, -0.02215614f, 0.36378071f, 
    -0.06998253f, -0.49666709f, -0.21890870f, -0.58778143f, 0.07708675f, -0.02766975f, 0.21665579f, 0.16192910f, 
    -0.04326057f, 0.17435320f, 0.15880801f, 0.07662593f, -0.12604848f, 0.11235534f, -0.09836598f, 0.57206225f, 
    -0.40522400f, -0.05081785f, -0.13002774f, 0.04788322f, -0.88733917f, -0.06835698f, 0.13782342f, -0.16625974f, 
    -0.40000576f, 0.28184304f, 0.00354135f, -0.88967663f, 0.12103171f, -0.13531697f, -0.15061936f, 0.62333715f, 
    0.18426841f, 0.35160273f, 0.11526630f, -0.40495858f, -0.24239555f, 0.19094165f, -0.22688979f, 0.18262462f, 
    -0.13260624f, 0.43787572f, 0.40142670f, 0.25897336f, 0.08567108f, -0.10364961f, -0.00479431f, -0.68557549f, 
    -0.36796558f, -0.14523104f, -0.77175981f, -0.03543401f, -0.21913934f, 0.12598616f, 0.15851235f, -0.05857962f, 
    0.20529529f, 0.02687448f, 0.15470849f, -0.23420109f, 0.14103486f, -0.27535722f, -0.95003742f, -0.09119689f, 
    0.30939844f, 0.34505945f, -0.14750017f, -0.35945073f, 0.30579978f, -0.04875105f, -0.45297056f, 0.36719933f, 
    -0.18567134f, -0.51332283f, -0.36470795f, 0.26147950f, -0.09844492f, 0.28235188f, 0.07327624f, 0.03363513f, 
    0.32991618f, -0.12819925f, -0.16353382f, 0.09345087f, 0.17355555f, -0.14537993f, -0.40831777f, 0.13797413f, 
    0.15650618f, -0.18765716f, 0.00645718f, -0.09019368f, 0.06717350f, -0.15173429f, -0.23536554f, -0.64989269f, 
    -0.40001044f, 0.21848802f, -0.23087282f, 0.42228180f, -0.38793489f, -0.21193324f, -0.01817343f, 0.28715986f, 
    0.00513919f, 0.19171983f, -0.30187982f, -0.05108547f, 0.15921184f, -0.42322794f, 0.10325640f, 0.28392696f, 
    0.32718244f, -0.06739438f, -0.37701243f, -0.93339109f, 0.17754060f, 0.12846939f, 0.36755729f, 0.10022228f, 
    -0.18460818f, -1.07297587f, 0.14780965f, 0.21787106f, 0.15064898f, 0.31984693f, 0.34714326f, 0.30192253f, 
    -0.58702093f, -0.54792506f, -0.13785438f, -0.47763309f, -0.23358893f, 0.17511779f, 0.06504961f, -0.60214794f, 
    -0.01547583f, 0.66453588f, -0.89037687f, 0.30991048f, -0.10075561f, 0.29934967f, 0.05759060f, 0.27968779f, 
    0.00879863f, -0.05267492f, 0.33441585f, -0.29618683f, -0.39838114f, -0.18419722f, -0.02746814f, -0.16435887f, 
    0.30048195f, 0.03497915f, -0.17213503f, -0.30030677f, 0.10066653f, -0.41783357f, 0.30851316f, -0.15970787f, 
    0.27414158f, -0.43777242f, -0.27813551f, 0.23993517f, 0.33293384f, 0.04528819f, 0.29093122f, -1.16199601f, 
    0.20412977f, -0.67679566f, -0.40605742f, -0.35344061f, -0.12291942f, -0.04210409f, 0.10939697f, 0.58391970f, 
    0.02480983f, -0.15331510f, 0.19731572f, 0.10188468f, 0.34039009f, 0.05183802f, 0.06509435f, 0.05467360f, 
    0.26305407f, -0.67370218f, -0.14453191f, -0.64140987f, -0.10183860f, -0.05374007f, -0.42605060f, 0.12447427f, 
    -0.34873357f, 0.23971151f, -0.15796398f, -0.63345659f, -0.76718259f, -0.26425281f, -0.10866016f, -0.26888651f, 
    -0.14478226f, 0.23229875f, 0.39290646f, -0.11890984f, 0.13860422f, -0.21098386f, 0.00305440f, 0.14057353f, 
    0.53755593f, -0.09520312f, -0.28885227f, 0.24074803f, 0.36095598f, 0.12769878f, 0.29199114f, 0.14054045f, 
    0.20432408f, 0.05763332f, -0.08332288f, 0.47605571f, -0.13710269f, -0.13571844f, -0.15393123f, -0.84077162f, 
    0.24041939f, 0.43332893f, 0.26590249f, 0.33405969f, -0.38410482f, -0.44607076f, 0.04770804f, 0.11142106f, 
    -0.42784801f, -0.83638126f, -0.65356010f, -0.18802088f, -0.16315852f, 0.17952980f, 0.04443479f, 0.22875299f, 
    -0.79431397f, 0.10315622f, 0.00616999f, -0.72331595f, -0.36229345f, -0.05109186f, 0.11757503f, -0.14632764f, 
    0.22823513f, 0.28918529f, -0.12489548f, -0.32244021f, -0.02590595f, 0.48809874f, -0.10179027f, 0.28982842f, 
    0.01153736f, 0.45429924f, -0.89107215f, -0.73643386f, 0.46347904f, -0.33471012f, 0.47316635f, 0.00586175f, 
    0.33410802f, -0.10046081f, -0.40512308f, 0.35933396f, -0.12001731f, -0.55989301f, 0.12673895f, -0.36601681f, 
    -0.19488874f, -0.14150575f, 0.36989236f, 0.13175057f, -0.52521950f, 0.11138289f, -0.09220451f, -0.02886299f, 
    0.27032319f, -0.28676510f, -0.05705756f, 0.12717484f, 0.01899938f, 0.39584529f, -0.01145945f, 0.24081104f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07581829f, 0.07797486f, -0.07615119f, -0.27704248f, 0.10872065f, 0.22164182f, 0.11455556f, 0.00229590f, 
    0.27413905f, 0.03078280f, 0.14049780f, -0.00366027f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
