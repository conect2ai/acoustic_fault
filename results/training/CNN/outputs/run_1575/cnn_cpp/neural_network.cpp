#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.16183814f, -0.59347260f, -0.36923605f, 0.33034894f, 0.26495832f, 0.63657951f, 0.68300420f, 0.24171755f, 
    -0.55939215f, -0.38999605f, -0.14059126f, -0.04371747f, 0.03033544f, -0.14519043f, 0.05764561f, 0.15296040f, 
    0.03714212f, -0.27713856f, -0.22868505f, -0.21031797f, 0.26830825f, -0.07376751f, 0.04992196f, 0.34712607f, 
    -0.06713521f, -0.42651182f, -0.39079645f, -0.49909019f, -0.27865931f, -0.38396651f, 0.24547386f, -0.32537672f, 
    -0.52678365f, -0.47552595f, -0.65156627f, 0.51588225f, -0.10432290f, 0.05881665f, -0.02243989f, 0.15784338f, 
    -0.07817770f, 0.18531384f, -0.10465246f, 0.06119333f, -0.15292732f, -0.29378241f, 0.27236757f, 0.49930245f, 
    0.23313551f, 0.24184507f, 0.84964484f, -0.13502540f, -0.23887186f, -0.08792214f, -0.11073359f, 0.38119659f, 
    0.52915835f, -0.23421408f, -0.41207004f, 0.13229322f, -0.29027861f, 0.27474445f, 0.01387368f, -0.07763902f, 
    -0.01919749f, -0.06831279f, 0.07144124f, 0.28189898f, -0.25153950f, -0.03503703f, -0.08134468f, -0.07440592f, 
    0.18694773f, -0.10957316f, -0.06782525f, -0.96408230f, -0.89536351f, -0.51204592f, 0.27935281f, 0.74529332f, 
    0.14486152f, -0.40181476f, 0.06844196f, 0.68582040f, 0.69517356f, 0.03591833f, -0.10791380f, -0.35405219f, 
    -0.15541619f, 0.09297012f, -0.04757017f, 0.22734423f, 0.15459947f, 0.06441436f, -0.16936232f, -0.12430070f, 
    0.10883934f, -0.02123385f, -0.00424037f, 0.03543912f, -0.34463966f, -0.19624905f, 0.03675735f, -0.52801567f, 
    -0.47120669f, -0.00929438f, 0.23041067f, -0.46874437f, -0.08682889f, 0.13199636f, -0.22582513f, -0.23357895f, 
    -0.05778634f, -0.29799303f, -0.15142803f, 0.16361412f, 0.15647456f, 0.17840348f, 0.27165490f, -0.31966317f, 
    -0.16298312f, 0.22445227f, 0.03325735f, -0.30907676f, 0.32436526f, 0.13286377f, -0.86851245f, -0.19061682f, 
    0.63522655f, 0.47863540f, 0.04784779f, -0.07394355f, 0.69105226f, -0.52735239f, -0.41734946f, -0.30496702f, 
    -0.31652251f, 0.32955983f, -0.00537020f, 0.13438943f, -0.18281583f, -0.21754622f, 0.10165923f, 0.16089702f, 
    0.30390719f, -0.05146198f, -0.03405695f, -0.00267087f, -0.05547951f, 0.05021352f, -0.32542193f, 0.05595696f, 
    0.16420130f, -0.01558102f, 0.06096421f, 0.00481154f, 0.08889589f, 0.20144580f, 0.19093417f, -0.22233522f, 
    0.38729814f, -0.06855907f, -0.33300856f, -0.20552327f, -0.15974773f, -0.19323665f, 0.05595843f, -0.03164097f, 
    0.03952417f, -0.07119878f, -0.00387715f, -0.07092000f, -0.24643002f, -0.19872494f, -0.58934826f, -0.94013733f, 
    -0.41213855f, 0.16905625f, 0.41234556f, 0.47163963f, 0.25258419f, 0.42270681f, 0.20690198f, 0.04906806f, 
    -0.00214191f, -0.05764844f, -0.19384408f, 0.02514735f, 0.28835273f, -0.02928849f, 0.07040720f, -0.02297798f, 
    -0.29177389f, -0.30431983f, 0.08740871f, -0.08355857f, 0.04280967f, 0.18003333f, 0.09168264f, -0.16090652f, 
    0.33595920f, 0.52707702f, 0.12140951f, -0.05644813f, -0.36278003f, -0.27210769f, -0.37453374f, -0.08751942f, 
    -0.22608030f, -0.38036674f, 0.25180456f, -0.18555132f, -0.06941102f, 0.52780628f, -0.11981832f, -0.21214855f, 
    -0.15216774f, 0.18397689f, 0.07342546f, -0.16799425f, 0.22632852f, -0.07073297f, -0.34903398f, -0.58314461f, 
    -0.37291294f, -0.59943128f, 0.08835243f, 0.59159148f, 0.04484858f, 0.36306489f, -0.48578668f, -0.37051374f, 
    -0.21861473f, 0.15820503f, 0.32549527f, -0.29125544f, -0.05952749f, -0.16056354f, 0.10063003f, 0.09588186f, 
    0.07275198f, 0.07830971f, 0.25723678f, 0.15326589f, 0.45120865f, -0.15149371f, -0.18012278f, -0.28172064f, 
    -0.35594115f, -0.16411266f, 0.05487059f, -0.07773717f, 0.16219838f, 0.14699309f, 0.13151482f, -0.32559949f, 
    -0.26573387f, 0.09127458f, -0.10332146f, -0.02321644f, 0.48003483f, -0.38403013f, 0.44631541f, -0.14587118f, 
    -0.14194159f, 0.17975128f, -0.04191601f, 0.08244707f, -0.17342357f, -0.43233061f, -0.01212065f, 0.16058673f, 
    0.19426979f, 0.02473529f, 0.38023791f, -0.38468364f, -0.77882689f, -0.51433343f, 0.07714671f, -0.01916098f, 
    0.21605837f, 0.28774282f, 0.54755646f, -0.26416665f, -0.04753073f, 0.05370238f, -0.16564457f, -0.24733688f, 
    0.26061040f, 0.00030257f, 0.22492822f, 0.11309049f, 0.05209370f, 0.22919530f, 0.03687592f, -0.32635465f, 
    -0.13313727f, -0.14939594f, -0.34955433f, -0.27573705f, 0.67891729f, 1.00333476f, 0.38593867f, -0.28126127f, 
    -0.23629345f, -0.53084826f, -0.37064120f, 0.07817140f, -0.35300785f, -0.63095218f, -0.11357577f, -0.03677905f, 
    -0.00481152f, 0.11344418f, -0.33241954f, 0.29569346f, -0.26553932f, 0.18644398f, 0.30509433f, -0.16238450f, 
    -0.06863955f, 0.11896314f, -0.01626255f, -0.00542454f, 0.27804336f, 0.11031149f, -0.32413617f, 0.23534290f, 
    0.21515431f, 0.34669957f, -0.29712763f, 0.00064480f, 0.17475623f, 0.16870193f, 0.12644224f, 0.19949764f, 
    0.06919595f, -0.20099214f, -0.01929937f, -0.10677605f, 0.19069043f, -0.17428403f, -0.09600585f, -0.18981558f, 
    0.04981537f, -0.27306473f, 0.29213485f, -0.04347439f, -0.14924823f, -0.22909464f, 0.91839606f, 0.35863593f, 
    -0.44311804f, -0.65446675f, -1.02314818f, -0.22613545f, -0.13634439f, 0.30264306f, 0.31194532f, 0.29524440f, 
    0.35155368f, 0.27368334f, -0.23679949f, -0.21828541f, -0.00453395f, -0.01653394f, 0.16200806f, -0.18407930f, 
    0.04993899f, -0.15971619f, -0.17331314f, 0.16350701f, -0.26143643f, -0.07425925f, -0.06214791f, 0.11889758f, 
    -0.01251805f, 0.05911629f, 0.33792993f, 0.20825465f, 0.30273747f, 0.11431380f, -0.00127969f, 0.01122365f, 
    -0.04482557f, -0.07996346f, 0.23278862f, 0.03244671f, -0.39984933f, -0.31438828f, 0.22278544f, 0.11038702f, 
    -0.07509663f, -0.02106088f, 0.00697544f, -0.10642633f, -0.13187626f, 0.04704991f, -0.30668139f, -0.30355114f, 
    -0.40806359f, -0.18743885f, -0.31510001f, -0.53296018f, -0.28608745f, 0.10198212f, 0.27967808f, 0.26530722f, 
    0.01731069f, -0.31741634f, -0.15400404f, 0.00189807f, 0.44628292f, -0.41344631f, -0.27796271f, -0.30654624f, 
    -0.31330916f, -0.11199908f, -0.23190607f, 0.00403286f, -0.03615059f, 0.27786356f, 0.14651813f, 0.11917783f, 
    0.34591216f, -0.14414048f, -0.72314239f, 0.10875318f, 0.42249709f, -0.48909399f, -0.44069928f, -0.22744817f, 
    -0.35796788f, -0.47399718f, -0.51859182f, -0.12237223f, 0.01281060f, -0.12614745f, 0.22280927f, -0.37117913f, 
    -0.03740790f, -0.28503501f, -0.11145639f, 0.20235282f, 0.00882962f, -0.02540728f, -0.06691104f, -0.20614371f, 
    -0.00246131f, -0.02346589f, -0.25343028f, -0.27129069f, 0.51147002f, -0.22168367f, -0.37939331f, 0.12214126f, 
    -0.11588032f, -0.18233359f, 0.18369608f, 0.34707734f, -0.08084621f, -0.16190329f, 0.29061407f, 0.16490129f, 
    0.24239485f, 0.11509737f, 0.06327712f, 0.25314572f, -0.06543706f, 0.21182716f, 0.35120553f, 0.28650227f, 
    0.03607390f, -0.24336131f, 0.01279072f, 0.50888181f, -0.01613732f, -0.13715160f, -0.44618997f, -0.36774018f, 
    0.48165125f, 0.18685938f, 0.20685150f, 0.19747207f, 0.03263082f, 0.16149810f, -0.14523666f, -0.03783149f, 
    -0.36399257f, -0.11701731f, -0.35998127f, -0.06763045f, 0.25611758f, -0.16159931f, 0.04867586f, 0.27459666f, 
    -0.04389869f, -0.33404988f, 0.14494991f, 0.47192061f, 0.52073431f, 0.58169168f, 0.30088297f, -0.20925587f, 
    -0.55035478f, -0.55865407f, -0.12877226f, -0.05157718f, 0.14557578f, 0.38849980f, 0.20995817f, -0.13221896f, 
    0.02965808f, 0.15385523f, -0.23282000f, -0.13346854f, 0.10274564f, 0.21540359f, -0.25600466f, -0.20098898f, 
    -0.10482518f, 0.31810099f, 0.02647655f, 0.20057707f, -0.19683509f, -0.92573196f, 0.49204981f, -0.09538537f, 
    -0.82792735f, -0.72639197f, 0.33203039f, 0.09015768f, 0.14359015f, 0.61156845f, 0.20799549f, -0.08608549f, 
    -0.31194785f, -0.19559917f, -0.37436256f, 0.18500222f, -0.03158445f, 0.30944970f, -0.08729050f, 0.01653429f, 
    0.06310624f, -0.05514733f, 0.09758612f, 0.20620400f, -0.18034053f, -0.41434240f, 0.66349721f, -0.12235267f, 
    -0.46896982f, 0.11428836f, 0.20877767f, 0.23162788f, 0.12995778f, 0.04070926f, -0.02484911f, -0.34589136f, 
    -0.23539907f, -0.12505877f, 0.16454375f, -0.20429637f, -0.10661910f, 0.19097018f, -0.16379532f, -0.01378282f, 
    -0.01895234f, -0.10973704f, 0.02952593f, 0.26762801f, -0.05842953f, -0.11025362f, -0.48251468f, 0.39719850f, 
    -0.47682378f, 0.34272298f, 0.34436616f, -0.38656843f, -0.15425907f, -0.31615022f, -0.17534511f, 0.36635652f, 
    0.28592360f, 0.29872030f, -0.42980334f, -0.24195173f, 0.72759211f, -0.25386190f, -0.22069752f, 0.14013599f, 
    -0.21525720f, 0.14659433f, -0.26900241f, 0.16473046f, 0.10039003f, -0.17262904f, 0.03023999f, 0.02914304f, 
    -0.81689036f, -0.47840762f, -0.35994688f, -0.09283305f, 0.25097224f, 0.38819206f, 0.28821063f, -0.26249599f, 
    -0.50876623f, -0.24881627f, -0.29427403f, -0.26812667f, -0.25959855f, -0.41351601f, -0.17838842f, -0.10980903f, 
    -0.28809708f, -0.28363743f, 0.14033312f, -0.02130158f, 0.02359451f, 0.02701948f, -0.23577210f, -0.12273608f, 
    -0.05189383f, 0.41777128f, -0.03853286f, 0.02067429f, 0.22922088f, -0.11945315f, -0.02014570f, -0.02973846f, 
    -0.22965802f, 0.31941810f, -0.06013275f, -0.26988372f, 0.44564471f, 0.09001581f, -0.51331443f, 0.30395734f, 
    -0.23898624f, 0.23531158f, -0.33581483f, 0.12156212f, -0.03939068f, 0.19187135f, 0.13896532f, -0.10748132f, 
    -0.08857856f, 0.15379331f, -0.22683834f, -0.43833092f, -0.25734428f, -0.32785007f, -0.16453618f, -0.52703500f, 
    -0.29641786f, -0.42548373f, -0.13473144f, -0.43119559f, 0.34383017f, 0.58946019f, 0.36938888f, -0.00277136f, 
    -0.02487065f, 0.17792225f, 0.20077758f, -0.21458212f, -0.30712262f, -0.25870979f, 0.03189709f, -0.24829321f, 
    0.00625911f, -0.09357741f, -0.22729288f, -0.29863930f, -0.64913619f, -0.12396487f, 0.18287139f, 0.16878812f, 
    -0.53932649f, -0.47127897f, 0.00261254f, 0.55275095f, -0.52558565f, -0.08122711f, 0.50787133f, -0.12491447f, 
    0.32501888f, -0.06887415f, -0.17416216f, -0.24191441f, -0.11404128f, -0.04833288f, 0.19623399f, 0.13463156f, 
    0.27218422f, 0.21120794f, 0.02651455f, 0.36591461f, -1.06913543f, -0.57875597f, -0.01824165f, -0.44188318f, 
    -0.85244614f, 0.45410600f, 0.41303453f, 0.28531864f, -0.06086346f, 0.26011261f, -0.15327443f, 0.05731144f, 
    0.02404528f, 0.49713308f, -0.31390065f, -0.23969637f, -0.03471005f, -0.40020958f, 0.13994542f, 0.18879598f, 
    0.02294882f, -0.10829802f, 0.24395202f, -0.10460217f, -0.22784047f, 0.36775792f, 0.33075526f, 0.04661242f, 
    0.25544742f, 0.23898079f, -0.25615340f, -0.13084783f, -0.35174355f, -0.31957486f, 0.04611219f, 0.28868604f, 
    0.35835925f, -0.16061796f, -0.36385080f, 0.30965880f, 0.09996877f, 0.29771799f, -0.00150314f, -0.00302970f, 
    0.15865943f, -0.01583583f, -0.08399055f, -0.00233142f, -0.26172593f, -0.38971111f, -0.57261181f, 0.43844050f, 
    0.70426184f, 0.47912946f, 0.52025592f, -0.00328535f, -0.36151823f, -0.20477405f, 0.04209420f, 0.09047793f, 
    -0.31219414f, -0.29706761f, -0.03032192f, 0.35841483f, 0.18821777f, 0.00759449f, -0.01134530f, -0.20570724f, 
    -0.08957002f, -0.14691222f, 0.01011134f, 0.05149152f, -0.20904145f, 0.29057315f, -0.11368330f, -0.57536089f, 
    -0.11681823f, 0.16642544f, 0.22103542f, -0.27728614f, -0.41143027f, -0.37805203f, -0.42535028f, 0.26107910f, 
    -0.08598074f, 0.02351381f, -0.43778837f, 0.26620892f, -0.02255747f, -0.08432946f, -0.16432442f, -0.32908654f, 
    -0.39327389f, -0.28928244f, -0.14100921f, -0.35103133f, -0.36191434f, -0.20532940f, -0.12233249f, -0.48798367f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.33312190f, -0.07855036f, 0.14561459f, 0.27723461f, 0.23562787f, 0.10009679f, 0.02074021f, 0.38835713f, 
    0.01796199f, -0.17740546f, 0.20563357f, -0.19500583f, 0.15011549f, 0.18826251f, 0.25330511f, -0.01647653f, 
    0.19836110f, -0.02941366f, -0.04907095f, 0.22121193f, 0.32912937f, 0.18221986f, 0.13549457f, 0.06814181f, 
    -0.17913161f, 0.25937206f, 0.04507038f, 0.02121376f, 0.25102925f, -0.05668614f, 0.11618564f, -0.13369085f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.14730576f, 0.37068751f, -0.14721729f, -0.18737507f, 0.04787037f, -0.08091660f, -0.00046313f, 0.05724082f, 
    -0.10112006f, 0.13296752f, -0.03856647f, 0.00453473f, -0.13235387f, -0.11921280f, -0.02874489f, -0.14131437f, 
    -0.00255722f, 0.05439831f, 0.06683759f, -0.00182228f, 0.06069035f, -0.05216058f, -0.08033756f, 0.04507260f, 
    -0.45423120f, -0.21056943f, -0.10147131f, -0.16079320f, -0.03516291f, 0.08473615f, 0.09857160f, -0.00378445f, 
    0.19429767f, -0.01736440f, -0.01979345f, 0.03760257f, -0.13664657f, -0.14950106f, 0.29991823f, 0.08758918f, 
    0.05836247f, -0.02490236f, -0.01999192f, 0.16693325f, 0.02654804f, -0.06094471f, 0.05822097f, 0.10786930f, 
    0.03820293f, -0.00354793f, 0.00743029f, -0.04981191f, 0.11293698f, -0.10268415f, 0.07562511f, 0.14673223f, 
    -0.05597099f, -0.12776430f, 0.08476339f, 0.10180240f, 0.20687050f, 0.26729879f, -0.42170471f, 0.19560312f, 
    0.08005755f, -0.07552200f, 0.04365298f, 0.08155853f, -0.06555066f, 0.09833930f, -0.04975608f, -0.01225219f, 
    -0.17082892f, 0.07041947f, -0.04014942f, -0.00355835f, -0.03071118f, 0.08787855f, -0.01583511f, 0.00825628f, 
    0.10217159f, 0.04607839f, -0.05331930f, -0.01183301f, -0.05931447f, 0.15064248f, 0.05781268f, 0.13756284f, 
    -0.00539866f, -0.04597572f, -0.07325458f, 0.06405608f, 0.08315761f, -0.00098260f, 0.07284345f, 0.07045481f, 
    -0.06153993f, -0.05314022f, -0.00354630f, -0.01182155f, -0.03588991f, 0.19917040f, -0.00281307f, -0.01136263f, 
    0.02106040f, 0.04920413f, -0.02076077f, 0.02095942f, -0.15467030f, -0.22360197f, 0.01108819f, 0.05053768f, 
    -0.19403446f, -0.02215990f, -0.07191175f, 0.09120725f, 0.07759405f, 0.17033271f, -0.11846054f, -0.10806972f, 
    0.18794096f, -0.03998061f, -0.08597508f, 0.00141673f, 0.00807902f, -0.03536682f, -0.04191833f, 0.04091270f, 
    0.14185579f, -0.04430375f, 0.05687905f, 0.10933431f, -0.00323951f, 0.01191027f, -0.04492387f, -0.06602223f, 
    0.02713412f, -0.06949753f, -0.05247638f, 0.01194243f, -0.14245106f, -0.10565528f, 0.10890143f, -0.08997633f, 
    -0.21762404f, -0.19693324f, -0.13704258f, -0.10830949f, 0.09163384f, 0.01670080f, 0.01322405f, -0.01133694f, 
    0.03725898f, -0.00926794f, 0.11706198f, -0.02174753f, -0.00814542f, -0.04875877f, -0.16762546f, 0.18618739f, 
    0.14542450f, -0.06390920f, -0.03644064f, -0.05388806f, 0.08347065f, 0.04325055f, 0.02606022f, 0.04226688f, 
    0.22453849f, 0.33480120f, -0.24132112f, 0.15988295f, -0.01378904f, 0.00418883f, -0.07361303f, 0.06692001f, 
    0.05326280f, 0.10037961f, -0.05470176f, 0.05074622f, -0.05886654f, -0.14692600f, -0.20078638f, -0.11407905f, 
    -0.05983583f, 0.07087057f, -0.07008965f, 0.02037145f, 0.04926538f, 0.02294349f, 0.08508601f, -0.07104921f, 
    -0.02310181f, 0.10326204f, -0.06449407f, 0.00545834f, 0.06636036f, 0.05744791f, 0.04206624f, -0.02607307f, 
    -0.01435448f, 0.03111177f, 0.14778392f, 0.17016682f, -0.08146258f, 0.00338556f, -0.04735309f, 0.04439497f, 
    0.18980213f, 0.07636923f, 0.01236696f, -0.17447437f, -0.02142983f, -0.02012445f, 0.06152063f, 0.06673268f, 
    0.25367367f, -0.14779913f, -0.24000457f, -0.03937930f, 0.13413657f, -0.04060120f, 0.10646038f, 0.05200497f, 
    -0.05536092f, 0.00931271f, -0.14717272f, 0.00293429f, -0.32386866f, 0.02306461f, -0.06611551f, 0.18530610f, 
    0.05972571f, -0.14530870f, -0.03412759f, -0.02837799f, 0.20403987f, -0.04444722f, 0.03783946f, 0.19463836f, 
    -0.00738777f, 0.20634463f, -0.26431200f, -0.00285615f, 0.07612228f, -0.01888275f, -0.02391607f, 0.03608764f, 
    0.11940073f, 0.01977009f, -0.01782937f, 0.03269094f, 0.00561662f, 0.08895566f, -0.06970062f, 0.24909659f, 
    0.06578458f, -0.03639921f, 0.11159322f, 0.07565630f, 0.00197001f, 0.01731445f, 0.08753276f, 0.07368650f, 
    0.03551296f, 0.29958829f, 0.00507807f, -0.02817927f, 0.06483790f, 0.03263166f, 0.09669435f, -0.02057515f, 
    -0.01187662f, 0.18188164f, 0.00776549f, -0.14174291f, 0.27640274f, 0.10577268f, 0.02012599f, -0.07264800f, 
    0.00764805f, -0.08076195f, -0.15641950f, 0.09626010f, -0.01226124f, 0.04132371f, 0.15598090f, -0.00836498f, 
    -0.10256339f, 0.22448716f, -0.00780620f, -0.11369515f, 0.02879161f, -0.06109813f, 0.03301465f, 0.13214123f, 
    0.01084935f, 0.01812011f, -0.02992466f, 0.06362855f, -0.23786175f, -0.19859570f, -0.02366441f, 0.16818051f, 
    -0.07571074f, -0.04248101f, -0.11689169f, -0.06898310f, 0.11122327f, -0.00065560f, 0.11028501f, 0.25017911f, 
    0.03761525f, -0.04627648f, -0.02980652f, -0.16633420f, 0.08333068f, 0.04812883f, 0.02554026f, -0.01732347f, 
    -0.12182876f, -0.00349900f, 0.02948629f, -0.02212287f, 0.04863325f, -0.08333845f, -0.10971997f, -0.00820621f, 
    0.02331992f, 0.02652077f, 0.06116866f, -0.13923176f, -0.03856855f, -0.01712704f, -0.09426416f, -0.06621750f, 
    -0.15056433f, -0.10301650f, -0.02495021f, 0.17637500f, 0.06503751f, 0.03458062f, -0.10503892f, 0.03172113f, 
    0.05680326f, 0.13055494f, 0.14820381f, -0.02741128f, -0.33415833f, -0.36597151f, -0.18343498f, -0.09864659f, 
    0.10006980f, 0.11122555f, -0.14555426f, 0.04476836f, 0.06371789f, -0.00156829f, -0.02663640f, 0.01329888f, 
    -0.27064863f, 0.12721641f, 0.21188721f, 0.10560356f, -0.07466798f, -0.01594193f, -0.17244862f, 0.11984177f, 
    -0.06921258f, -0.13072373f, 0.02813240f, 0.08119329f, 0.05278001f, 0.00617902f, 0.00470152f, 0.07455549f, 
    0.05019883f, 0.04141615f, -0.00119980f, -0.03495101f, 0.08366630f, -0.07154702f, 0.09327625f, -0.06839090f, 
    -0.01847232f, -0.05152208f, 0.02197883f, -0.02589468f, 0.00006398f, -0.02015828f, -0.02187562f, -0.02112705f, 
    0.04424125f, -0.02485342f, -0.02409292f, 0.00581870f, -0.04088048f, 0.04595361f, -0.01935307f, 0.02987373f, 
    0.04435141f, -0.00325688f, 0.02624298f, -0.03603446f, 0.00807095f, -0.04272323f, -0.03556561f, 0.01357223f, 
    -0.02630660f, 0.02369785f, 0.01702510f, 0.01884070f, -0.02513976f, -0.04867424f, -0.03778141f, 0.01598514f, 
    0.03450980f, -0.00401285f, 0.01600397f, 0.04399858f, 0.04754741f, -0.03060205f, -0.00575852f, -0.03415834f, 
    -0.04116092f, 0.04020208f, 0.00703960f, -0.02674606f, 0.03352899f, 0.02384646f, 0.04321488f, -0.03434127f, 
    -0.00568696f, -0.00188361f, -0.05103346f, -0.01243339f, -0.01663143f, -0.01109415f, -0.03810067f, -0.04648925f, 
    -0.00143046f, -0.04150578f, -0.04242959f, 0.00927662f, 0.00111519f, 0.00509221f, 0.02467862f, -0.03571603f, 
    -0.03252907f, -0.00349068f, -0.04454774f, 0.02718516f, -0.02739252f, -0.02419894f, 0.01425262f, 0.01187680f, 
    -0.03345453f, -0.05309930f, -0.01297119f, 0.02101434f, -0.05176558f, -0.04060262f, -0.02287809f, 0.01522683f, 
    -0.00234486f, -0.03813851f, -0.04422092f, 0.00328526f, 0.00290018f, 0.02020704f, 0.00158212f, 0.01150856f, 
    -0.02266336f, 0.00234356f, -0.02854028f, 0.02807093f, -0.01564954f, 0.00029872f, 0.02994026f, -0.04818936f, 
    0.00656445f, -0.05573728f, -0.01756074f, 0.02260112f, -0.01297628f, 0.04195789f, -0.03622083f, -0.00725131f, 
    -0.04459353f, 0.01003955f, 0.03662055f, -0.01730599f, -0.01076272f, 0.04943764f, 0.00968172f, 0.00518382f, 
    0.00526847f, -0.00894425f, 0.02932375f, -0.01950555f, 0.01869162f, -0.03414021f, -0.00752581f, -0.01270503f, 
    0.01252575f, -0.05644964f, 0.03105412f, -0.01403729f, 0.03454963f, -0.00688239f, -0.05506259f, 0.02377833f, 
    -0.04596360f, 0.01732635f, -0.05380340f, 0.00199890f, 0.02660138f, 0.01915945f, 0.01441463f, -0.04082966f, 
    0.01668645f, 0.00126596f, 0.02382819f, 0.01437854f, -0.04963569f, -0.05128087f, 0.00791217f, -0.03104495f, 
    -0.00297221f, -0.03841652f, 0.01845507f, 0.00140521f, 0.05038657f, -0.02674334f, -0.02863055f, -0.01260251f, 
    0.01978065f, 0.03977373f, -0.02644948f, 0.00821852f, -0.01139518f, 0.00006136f, -0.01477298f, -0.00280150f, 
    0.02676205f, -0.05492622f, -0.00452327f, 0.02167421f, 0.01076648f, -0.01438512f, -0.03682857f, -0.04886496f, 
    0.04311181f, 0.02209575f, 0.03183434f, -0.04980033f, -0.05334348f, 0.01262042f, -0.01392856f, -0.00155338f, 
    -0.02210306f, -0.00129978f, 0.01691135f, 0.04546593f, 0.00425790f, 0.00456835f, -0.01151466f, -0.00398879f, 
    -0.04485865f, -0.04848478f, -0.02033780f, -0.02176785f, -0.01755821f, -0.01000189f, -0.00243597f, 0.00206420f, 
    -0.04303071f, -0.02132876f, 0.04113430f, 0.03163881f, -0.05346389f, -0.03671017f, -0.03946335f, 0.02728816f, 
    0.00686066f, -0.04636129f, -0.03400431f, -0.01508954f, -0.01844680f, -0.02452780f, 0.01664919f, 0.03959095f, 
    -0.02859725f, 0.00019406f, 0.04203641f, -0.03577927f, 0.04372527f, -0.04926458f, 0.00023191f, -0.02212768f, 
    -0.04683507f, -0.03146513f, -0.01034382f, 0.01150762f, 0.01593407f, -0.03568874f, -0.04060842f, 0.02120728f, 
    0.00405484f, -0.02704741f, 0.04276174f, 0.02214006f, 0.00699496f, -0.01849645f, -0.02968640f, 0.04006423f, 
    0.00083472f, -0.02101883f, -0.02178161f, -0.01328495f, -0.03446117f, 0.02148566f, -0.03551594f, -0.03694609f, 
    0.01518227f, 0.03937631f, -0.01396944f, 0.02555644f, 0.02122452f, -0.01512637f, 0.02657459f, 0.04354209f, 
    -0.02603474f, -0.01329758f, -0.00538774f, -0.04804680f, 0.02976755f, -0.04185465f, -0.01034420f, 0.00037560f, 
    0.02550219f, -0.00794845f, 0.03079981f, -0.01315289f, -0.04807419f, -0.03431590f, 0.01996372f, 0.01370872f, 
    -0.03295029f, -0.00092566f, 0.03409607f, -0.00493579f, 0.00534289f, -0.03654228f, -0.05082313f, 0.05329753f, 
    -0.05152951f, -0.03725708f, 0.03579840f, -0.01911729f, -0.01928132f, 0.00370027f, 0.03857620f, 0.03233439f, 
    0.01448827f, -0.04324584f, 0.00984617f, -0.04505290f, 0.01456196f, -0.05086847f, -0.05051655f, -0.01418889f, 
    0.00995565f, -0.00328201f, 0.04361569f, 0.00851281f, 0.00440759f, 0.04622930f, -0.01262867f, 0.02928717f, 
    -0.04855187f, 0.03798148f, -0.03616036f, 0.00246896f, 0.03126214f, -0.01734055f, -0.04530921f, 0.03470919f, 
    -0.02951607f, 0.04127406f, 0.00881408f, 0.03041534f, 0.03082992f, -0.02851382f, -0.00361521f, 0.02251643f, 
    -0.05085220f, 0.01338017f, 0.00320458f, 0.05007933f, -0.01925479f, -0.03893439f, 0.02253072f, -0.04569513f, 
    -0.03558271f, -0.04239078f, 0.02010870f, 0.00587192f, 0.03647722f, -0.04394353f, -0.04393222f, -0.03524736f, 
    -0.04590334f, -0.01551517f, 0.00410998f, -0.00654288f, 0.01094875f, -0.02282487f, 0.03761616f, -0.02368172f, 
    0.01941301f, 0.04419015f, -0.01474322f, 0.03219247f, -0.01547511f, 0.01389071f, -0.03262318f, -0.02717703f, 
    -0.01849863f, -0.02866399f, -0.04189549f, -0.02107196f, 0.01719273f, -0.04985277f, -0.04172207f, -0.00225642f, 
    -0.01294657f, -0.01419210f, -0.03321122f, -0.00436268f, -0.02368356f, -0.05090830f, 0.00781324f, -0.02259170f, 
    -0.01465129f, 0.03844739f, -0.00726878f, -0.03134615f, 0.00730042f, -0.02342318f, 0.01214444f, 0.03451730f, 
    0.00759830f, 0.01952583f, 0.04560938f, 0.03571640f, 0.01754764f, -0.00371246f, 0.03202678f, -0.01618570f, 
    0.04295017f, 0.03360655f, 0.03409937f, 0.03833139f, -0.04118451f, 0.01828266f, 0.03468066f, -0.03627104f, 
    -0.21914722f, -0.16080475f, -0.02640520f, -0.12073220f, -0.02347460f, -0.00860321f, -0.14687288f, -0.07198960f, 
    -0.04401597f, 0.09573072f, 0.12859662f, 0.17008020f, 0.27390751f, 0.02119283f, -0.15414824f, -0.20186333f, 
    -0.02900067f, -0.01722253f, -0.10995620f, -0.12873243f, -0.07152981f, -0.09095860f, -0.08194041f, -0.11009725f, 
    0.03083218f, -0.01782792f, -0.04950910f, 0.22100526f, 0.05611194f, 0.03382855f, 0.02087838f, 0.00310319f, 
    -0.08068809f, 0.11204398f, -0.12197152f, 0.07649481f, 0.21824862f, 0.17846094f, 0.12004287f, 0.10592075f, 
    0.02357298f, 0.02528337f, 0.08863963f, 0.08192552f, 0.12038586f, 0.13060534f, 0.12111391f, -0.01478370f, 
    0.08466544f, 0.07772695f, -0.15207127f, -0.18097186f, 0.09785811f, 0.07765079f, 0.16388512f, 0.08346366f, 
    -0.11950476f, -0.02220852f, -0.12244192f, 0.09941202f, -0.14746070f, -0.33368826f, 0.32499760f, -0.09196620f, 
    0.13360293f, -0.01922088f, 0.01713941f, 0.09363278f, -0.00063610f, -0.09015238f, -0.10876358f, 0.16922742f, 
    -0.26438838f, -0.05795555f, 0.11904329f, 0.11771130f, -0.00350763f, 0.03561643f, -0.01052419f, -0.03906375f, 
    -0.08668528f, 0.12188909f, 0.31599036f, 0.09647394f, -0.09637497f, -0.18012245f, -0.00676833f, -0.05053966f, 
    0.11742856f, 0.00133323f, -0.04094659f, -0.05858903f, 0.01316935f, 0.05789823f, 0.14285915f, 0.08714806f, 
    0.13601528f, -0.09581436f, -0.17770386f, -0.02949273f, -0.00595941f, 0.10532699f, 0.16373245f, 0.03608525f, 
    0.13680935f, 0.05674087f, 0.03763432f, 0.16368538f, -0.21348119f, -0.05222766f, -0.07191212f, -0.03298846f, 
    0.17182648f, 0.19059403f, 0.18731622f, 0.07572327f, 0.17489199f, -0.04977481f, 0.21666192f, 0.00061557f, 
    -0.08178579f, -0.12694283f, 0.14254223f, -0.12670386f, 0.15068308f, 0.08587020f, -0.09151447f, 0.11097644f, 
    -0.13710216f, 0.15108471f, -0.22168463f, -0.12815501f, 0.09400546f, -0.04970670f, -0.00165640f, 0.02064967f, 
    -0.04600229f, 0.10556799f, 0.06154753f, 0.14114244f, -0.00213393f, -0.04739895f, 0.12018779f, 0.02387097f, 
    0.06361648f, 0.02361964f, -0.38229248f, -0.10826961f, 0.11900053f, 0.08410781f, 0.16045251f, -0.06685645f, 
    -0.02808085f, 0.06912642f, -0.13976085f, 0.02894608f, -0.02094933f, 0.04018067f, -0.05059054f, -0.04184682f, 
    0.06694789f, 0.10547500f, -0.03083633f, -0.00640437f, -0.04859333f, 0.00315187f, 0.00264598f, -0.06607671f, 
    0.23830914f, -0.13584721f, -0.03407135f, 0.00180597f, 0.05643148f, 0.00355522f, 0.07168788f, 0.08412752f, 
    0.06182106f, 0.14200056f, 0.20714404f, -0.07790800f, -0.12398180f, -0.03813142f, 0.02898849f, 0.01058382f, 
    -0.00808316f, -0.02345553f, -0.10503974f, -0.14212339f, -0.02529656f, 0.20610587f, 0.07953981f, 0.00592720f, 
    -0.10906924f, -0.06011423f, 0.01786521f, -0.17940393f, 0.07147412f, -0.04292706f, -0.07836563f, 0.06370471f, 
    -0.08483478f, 0.00797603f, -0.02784234f, 0.10048876f, 0.33326334f, 0.01093843f, 0.04440759f, -0.20544815f, 
    0.13984983f, 0.00919935f, 0.09341112f, -0.03082620f, -0.02759886f, -0.09196348f, 0.02789001f, 0.02582400f, 
    -0.00618511f, 0.00700433f, 0.03385541f, -0.14336540f, 0.04728331f, 0.04102662f, 0.02189722f, -0.05004299f, 
    -0.01392668f, -0.31211844f, -0.16075100f, -0.04813744f, -0.01721813f, -0.14638665f, -0.12028964f, 0.06894195f, 
    0.03715998f, -0.09989403f, 0.11237336f, 0.00516617f, 0.11534826f, 0.10247143f, 0.06195692f, 0.02494255f, 
    0.24843149f, -0.00767475f, -0.31793293f, 0.01638284f, -0.07539762f, 0.05886741f, 0.23018052f, 0.04054360f, 
    -0.07391670f, 0.07755321f, 0.00639448f, 0.00881915f, -0.29713339f, -0.10915753f, -0.06183640f, -0.09856423f, 
    -0.06542895f, 0.22341958f, 0.09399305f, 0.09637133f, 0.00242372f, 0.02781428f, -0.06331720f, -0.10879871f, 
    -0.08200040f, -0.21602122f, 0.02331011f, 0.09519485f, -0.02140769f, -0.08105814f, 0.19084327f, -0.01244254f, 
    -0.01572486f, 0.17605363f, 0.00737637f, 0.04371777f, 0.23905225f, 0.04554351f, 0.06273979f, 0.21300064f, 
    0.17610505f, 0.00118789f, 0.27453938f, -0.01262330f, 0.02412014f, -0.07475530f, -0.10653240f, -0.02713343f, 
    0.31242725f, 0.01235131f, -0.13025564f, -0.10313457f, 0.04845895f, 0.11764109f, 0.02711042f, -0.10626087f, 
    -0.07927414f, -0.03701326f, 0.09337482f, 0.11211018f, 0.08905729f, -0.04375156f, -0.09014278f, 0.07745599f, 
    0.12647812f, 0.08649869f, 0.14225350f, -0.09181362f, -0.07502192f, -0.11460045f, 0.12299002f, -0.03843747f, 
    0.09762178f, 0.23643731f, 0.08084495f, -0.19550937f, -0.09186890f, -0.07703563f, -0.08474103f, 0.09930620f, 
    0.00466020f, 0.09290394f, 0.03720555f, -0.13424894f, -0.05525200f, 0.18148488f, 0.16613027f, -0.22388673f, 
    0.05868087f, -0.15940897f, -0.12937097f, -0.05579374f, -0.02256330f, -0.11413420f, 0.04887335f, -0.09937503f, 
    -0.07788254f, -0.08616155f, -0.09895093f, -0.18861581f, 0.07331859f, 0.11380533f, 0.01794194f, -0.01113474f, 
    0.01394174f, 0.01147562f, -0.06734433f, 0.08986686f, 0.04133419f, -0.29942027f, -0.24912076f, -0.00642091f, 
    0.02862111f, 0.12632890f, 0.01685091f, 0.03976995f, -0.04137997f, 0.09696881f, 0.02346441f, -0.08368521f, 
    -0.02297105f, -0.24399504f, -0.04777896f, -0.06639320f, 0.11712445f, 0.17725587f, 0.08864801f, -0.07347585f, 
    0.04636800f, -0.06874948f, 0.11403603f, -0.01896745f, 0.03591307f, -0.01578055f, 0.08818321f, -0.20560887f, 
    0.01700827f, 0.01265372f, -0.01754506f, 0.09663036f, 0.05231490f, 0.01510223f, 0.11576003f, 0.20299760f, 
    0.29523495f, 0.23534788f, 0.32808995f, 0.22349668f, -0.04467985f, -0.03438906f, -0.00611646f, -0.01132977f, 
    0.10291389f, 0.00946786f, 0.07292548f, 0.02294387f, -0.07755408f, 0.08092326f, 0.08082425f, 0.03597816f, 
    0.05401834f, 0.07312249f, 0.24189804f, 0.18305382f, -0.10651600f, -0.01757971f, 0.01022236f, 0.03086091f, 
    0.20908387f, -0.02694116f, 0.07662352f, -0.12863298f, -0.02457267f, -0.11665668f, -0.05671233f, -0.01787335f, 
    0.10012317f, 0.00709865f, -0.01073411f, 0.05589337f, 0.00792325f, 0.10591053f, 0.11366370f, 0.04655419f, 
    -0.05286456f, -0.06437454f, 0.04189407f, 0.09317981f, -0.01860621f, -0.08026323f, 0.01511644f, 0.13975604f, 
    0.16095892f, 0.05877320f, 0.16547310f, 0.03051449f, 0.05718545f, 0.12293334f, -0.01786525f, 0.19182369f, 
    0.04061862f, -0.07451795f, -0.04667816f, -0.00960765f, 0.19273613f, 0.18253316f, -0.20278151f, 0.03543491f, 
    0.06656229f, 0.08096441f, -0.08748034f, 0.02228274f, 0.02806625f, 0.25723800f, 0.08666178f, -0.00565206f, 
    0.17604673f, -0.00433410f, 0.12534848f, -0.03428486f, -0.09553683f, -0.03022603f, -0.06050941f, -0.00554367f, 
    -0.07300627f, -0.15052581f, -0.19377895f, -0.14580898f, 0.18987960f, 0.37148082f, 0.18018015f, 0.27273306f, 
    -0.07449767f, -0.12975177f, -0.08222404f, -0.04723498f, 0.04483489f, 0.10692736f, 0.13103421f, 0.06408259f, 
    -0.05239123f, 0.03389245f, -0.13473120f, -0.13424885f, -0.05779525f, 0.01512970f, 0.03527000f, -0.03711155f, 
    -0.14116728f, -0.05659905f, -0.13612032f, -0.18328954f, -0.18702893f, -0.03786959f, -0.06988939f, -0.21803451f, 
    0.06995273f, -0.05572029f, -0.11117093f, 0.03318901f, -0.05355106f, 0.10148874f, -0.08943493f, -0.15552951f, 
    -0.01895083f, -0.00672305f, -0.08880739f, 0.04464838f, -0.02250329f, 0.08812921f, 0.08726581f, -0.08124854f, 
    0.01317364f, -0.00924311f, 0.03378297f, 0.25789636f, 0.01018979f, -0.07824832f, -0.14971471f, -0.00908511f, 
    0.03406870f, -0.10294329f, -0.12101615f, -0.07140163f, 0.14670272f, 0.03355491f, -0.09608594f, 0.01539089f, 
    -0.04847887f, -0.04383538f, -0.11347415f, -0.02069526f, -0.08175328f, -0.02376316f, 0.10196081f, 0.04128939f, 
    -0.02030779f, 0.01813863f, -0.01195456f, 0.09964224f, -0.02531279f, 0.03539396f, 0.10151623f, 0.06613057f, 
    -0.07108688f, -0.10962604f, -0.06365188f, -0.01898977f, -0.10197101f, -0.03440800f, -0.03063812f, -0.03604895f, 
    -0.08529104f, -0.02490877f, 0.20026916f, -0.16111331f, 0.00993089f, -0.02888074f, 0.12527697f, -0.04940823f, 
    0.05577143f, -0.00262850f, -0.10817918f, 0.06593432f, 0.07842732f, 0.12232247f, 0.12842551f, 0.03907400f, 
    -0.06042578f, -0.01832128f, -0.09517742f, -0.06232115f, -0.10094360f, -0.18679403f, -0.09863357f, -0.10014530f, 
    0.09839212f, 0.11006508f, 0.09227306f, -0.02242449f, 0.01469155f, 0.18919742f, 0.06952203f, 0.16764370f, 
    0.04708118f, 0.00870287f, -0.04674787f, 0.06622107f, -0.21120934f, 0.06604335f, 0.00060628f, 0.04888698f, 
    0.02587186f, 0.09680551f, -0.02692623f, 0.12997645f, 0.00772576f, 0.07143950f, -0.06867210f, -0.08807842f, 
    -0.06796427f, -0.04579182f, -0.03406835f, -0.13169292f, 0.06456611f, 0.07864723f, 0.04340560f, 0.15119007f, 
    -0.01809860f, 0.07848264f, 0.13145858f, 0.10640077f, 0.42997691f, 0.04810359f, -0.05629399f, -0.20817861f, 
    -0.07985713f, 0.05723805f, -0.02768447f, 0.00109009f, 0.26249492f, 0.12484434f, 0.15463449f, 0.02019514f, 
    0.08688412f, 0.02788534f, 0.17952523f, -0.13237160f, -0.04340794f, -0.02427181f, -0.13382341f, 0.00424497f, 
    0.12614802f, -0.02665850f, -0.04278804f, 0.04184461f, 0.03809164f, 0.14457276f, 0.04488675f, -0.18980099f, 
    0.03047504f, 0.01032030f, 0.00780681f, 0.06159985f, -0.05175606f, 0.02622644f, -0.06276178f, 0.04676985f, 
    0.27248484f, 0.31344387f, -0.17445873f, 0.19577019f, 0.01798241f, -0.14391908f, -0.12239919f, 0.06887373f, 
    -0.13797596f, 0.00168655f, 0.04669679f, -0.11999732f, -0.10404013f, 0.00874360f, -0.09280156f, -0.14522082f, 
    -0.20529333f, -0.09800996f, -0.10733736f, 0.01882892f, -0.01469925f, 0.02541017f, 0.12095770f, 0.04708869f, 
    0.07069423f, 0.22390305f, 0.18975356f, 0.05430105f, 0.12384062f, -0.00634415f, 0.06460435f, 0.16872339f, 
    0.11012466f, 0.02490231f, -0.13296846f, -0.15529282f, 0.06264971f, -0.00513746f, -0.07682882f, -0.01003874f, 
    -0.07102233f, -0.10016046f, -0.15210804f, -0.08216263f, 0.11266916f, 0.09565475f, 0.08941888f, 0.06373958f, 
    -0.20925426f, -0.09917188f, -0.14177962f, 0.09309467f, 0.17307959f, 0.00505853f, 0.01106153f, 0.12100421f, 
    -0.04893250f, -0.07307672f, -0.06789024f, 0.00143065f, -0.23116955f, 0.21202537f, -0.18469639f, 0.17005847f, 
    0.09108362f, 0.11940926f, 0.23316877f, 0.04895453f, -0.06537571f, 0.10069648f, 0.03041755f, 0.09676854f, 
    0.13821569f, 0.09679291f, -0.11393447f, -0.04011962f, -0.00713071f, -0.09420924f, -0.04512836f, 0.05741458f, 
    0.01349106f, 0.03728361f, 0.04372001f, -0.05490639f, -0.03213831f, -0.07094865f, 0.03155604f, -0.18322523f, 
    0.00582011f, -0.11705998f, -0.04170542f, -0.07039473f, -0.06092283f, -0.07365260f, -0.04725552f, -0.01712465f, 
    -0.12320635f, 0.08265394f, 0.05005826f, 0.10157526f, -0.20706347f, -0.15790400f, -0.00519209f, -0.01100399f, 
    -0.06689180f, -0.02518085f, -0.05185971f, -0.03204479f, 0.05839339f, 0.13396972f, 0.07161687f, 0.11682852f, 
    0.08101714f, 0.15123080f, -0.00442842f, -0.04984871f, -0.14802837f, 0.00884874f, -0.06133591f, -0.36690846f, 
    -0.05794670f, 0.20538995f, 0.02266084f, 0.05755377f, 0.08529516f, 0.11181872f, -0.04495811f, -0.04553960f, 
    -0.05706684f, -0.03232815f, 0.00251186f, 0.09166697f, 0.17131545f, 0.10511769f, 0.22279714f, 0.30768356f, 
    -0.00671954f, 0.00295817f, 0.01600580f, 0.11892684f, 0.04761042f, -0.02413946f, 0.06226449f, -0.01443964f, 
    -0.06243219f, -0.17898233f, -0.17777188f, -0.18197219f, -0.00607894f, 0.03566036f, -0.01457879f, -0.10755010f, 
    0.21205343f, 0.07843116f, 0.07906125f, 0.10992214f, 0.14120741f, -0.08453593f, -0.00798297f, 0.04929972f, 
    0.11748946f, -0.05306530f, 0.10252785f, -0.03886971f, -0.09277420f, -0.04546698f, -0.07873661f, 0.03297102f, 
    0.04003998f, 0.02280348f, 0.07616857f, 0.08893599f, -0.12471171f, -0.12750316f, -0.06806042f, -0.11726410f, 
    -0.01399518f, -0.03698503f, -0.06220362f, 0.05883557f, -0.10524832f, 0.05801974f, -0.05701268f, -0.07011129f, 
    0.06054196f, 0.07011143f, -0.11532313f, -0.11050452f, -0.05811688f, -0.16219948f, -0.00824071f, 0.01352087f, 
    -0.02914919f, -0.11307918f, 0.01734770f, 0.07117223f, -0.02244700f, 0.06630038f, -0.02662746f, 0.02015764f, 
    -0.01851131f, 0.02562573f, 0.02167600f, -0.05416225f, -0.18046679f, 0.09048270f, -0.04733578f, -0.00662970f, 
    -0.04022751f, 0.02852646f, -0.05260488f, -0.06646550f, -0.03513671f, -0.04886268f, 0.02149332f, -0.05514184f, 
    0.01281354f, 0.12759657f, 0.11599065f, 0.18447621f, 0.02067717f, 0.04685149f, 0.09095051f, 0.06506319f, 
    -0.05547134f, -0.01214993f, 0.02192811f, 0.10277734f, 0.08821633f, 0.04043877f, -0.02326114f, 0.00767068f, 
    -0.02331846f, -0.06625890f, -0.00407919f, -0.11341802f, -0.02287779f, -0.09718144f, -0.03512149f, 0.00732771f, 
    0.11338554f, 0.12243072f, 0.02408679f, 0.00561533f, 0.08823689f, -0.09851278f, -0.06165130f, -0.00839704f, 
    -0.02855053f, 0.08504842f, 0.01815843f, -0.11161333f, -0.05855013f, -0.00432072f, -0.02330837f, 0.10063625f, 
    0.01601309f, -0.03645783f, -0.12885135f, 0.03694608f, -0.00906344f, -0.03823787f, 0.00190887f, 0.03136814f, 
    0.18630631f, 0.13961124f, 0.04367823f, 0.18167588f, 0.07271988f, -0.02626510f, 0.02170314f, 0.07019250f, 
    0.01496793f, -0.07132139f, -0.04112344f, -0.12217213f, -0.13778850f, -0.20101698f, -0.09352812f, -0.12613833f, 
    -0.06934073f, 0.03847913f, -0.02014552f, -0.06092174f, 0.07651129f, 0.08630519f, 0.09129383f, -0.00742902f, 
    -0.18580776f, -0.09243243f, 0.18232164f, -0.05833368f, 0.03980990f, -0.00325307f, -0.03390716f, 0.12335198f, 
    -0.00757104f, 0.07323983f, 0.02030345f, 0.03175568f, -0.11537679f, -0.16573018f, -0.03510691f, -0.09949059f, 
    0.01964990f, 0.02947621f, 0.01450338f, 0.04901898f, 0.05279410f, 0.04684161f, 0.03161652f, 0.14340416f, 
    0.17657840f, 0.10795089f, -0.03212134f, 0.13962582f, 0.04664323f, -0.00345088f, -0.04107164f, 0.09708926f, 
    -0.04342888f, 0.02332076f, 0.05760296f, 0.03369283f, -0.12791528f, -0.01096826f, 0.16284291f, 0.22911051f, 
    -0.18230452f, -0.07124146f, -0.11271645f, 0.00023225f, -0.03715729f, 0.05565653f, 0.04192727f, 0.00811114f, 
    -0.03142153f, 0.00548766f, 0.00962827f, -0.06060009f, 0.15959007f, 0.13047935f, 0.06210672f, 0.05434574f, 
    0.13196854f, 0.10024386f, -0.03641826f, -0.07937783f, 0.05507636f, -0.00115699f, 0.11058189f, 0.04041306f, 
    0.04931685f, -0.07331537f, -0.00486117f, 0.02838074f, -0.00473543f, 0.06495905f, 0.01239850f, 0.08000971f, 
    -0.06856038f, 0.18433020f, 0.04459083f, 0.02589498f, -0.04865586f, -0.00532596f, -0.04133027f, -0.06929679f, 
    0.00088684f, 0.09103528f, -0.05133911f, -0.01839204f, 0.30123287f, -0.10933555f, 0.06384344f, -0.05906963f, 
    0.11957355f, -0.04612173f, -0.03096426f, 0.05744417f, -0.11061288f, -0.04547289f, 0.01748727f, 0.10738495f, 
    -0.02253134f, -0.08144470f, 0.13183007f, -0.15103394f, -0.03710922f, 0.10701805f, -0.02916755f, -0.06171511f, 
    -0.04910653f, -0.04139962f, -0.02276812f, 0.10935648f, -0.04894786f, -0.19348730f, 0.05609442f, 0.05541968f, 
    -0.07677552f, -0.14925873f, -0.01940174f, -0.16106033f, 0.02767869f, 0.03146336f, 0.00536593f, 0.05266234f, 
    -0.11636744f, -0.03867452f, -0.05296628f, 0.07129425f, -0.01698481f, 0.00727872f, -0.01056723f, 0.06964868f, 
    0.03644728f, -0.00326379f, 0.16291276f, 0.15446711f, 0.01053607f, -0.06497125f, -0.10795669f, -0.18340640f, 
    -0.03040967f, -0.03676848f, -0.02514370f, -0.03079997f, 0.06732461f, 0.02323295f, -0.11934304f, -0.06640898f, 
    0.06647850f, 0.04298289f, 0.19820762f, 0.26127630f, 0.08199094f, -0.06247374f, 0.03150212f, 0.06701022f, 
    -0.03051192f, 0.01726269f, -0.00631216f, -0.00242179f, 0.18386964f, -0.05530163f, 0.11139723f, 0.08341752f, 
    0.18645714f, -0.08208751f, 0.03456985f, 0.22676308f, 0.03951837f, -0.02953918f, -0.06065087f, -0.01025176f, 
    -0.06057886f, -0.00506026f, -0.05111339f, 0.09325478f, 0.02703279f, 0.01850882f, 0.07488129f, -0.02885010f, 
    -0.03772210f, -0.06390272f, -0.02235580f, -0.05314054f, 0.10341600f, 0.06586242f, -0.08240382f, -0.01120987f, 
    -0.10988721f, 0.15323456f, 0.12414386f, 0.00514190f, 0.10515567f, 0.12349229f, -0.01698392f, 0.06602399f, 
    -0.02964234f, -0.07423203f, -0.12429672f, -0.10822893f, -0.01535345f, 0.00589345f, 0.03587361f, -0.07091420f, 
    0.02372079f, -0.05096182f, -0.02018470f, -0.02076048f, -0.00414716f, -0.04040198f, -0.02656199f, 0.12843095f, 
    -0.05589195f, 0.03212845f, 0.06993506f, 0.06745663f, 0.04493625f, 0.03069150f, 0.01793346f, 0.02436976f, 
    0.03320982f, 0.08013327f, -0.20078491f, 0.07079592f, -0.00380574f, 0.05815890f, -0.10897278f, 0.01035676f, 
    -0.00968868f, 0.00399144f, -0.00052529f, 0.11534782f, 0.29451799f, 0.30364001f, -0.06119503f, 0.13354352f, 
    0.06947294f, 0.05883162f, 0.10513823f, -0.00445265f, 0.00077581f, -0.02341338f, 0.01537550f, -0.06865612f, 
    -0.06182599f, -0.09105872f, -0.25053179f, 0.06870659f, -0.01915868f, -0.12028858f, 0.09009535f, 0.00560134f, 
    -0.08524139f, -0.01207093f, 0.08932742f, 0.02873682f, -0.00144805f, 0.04170263f, 0.18494037f, 0.03251491f, 
    -0.01742031f, 0.09834523f, 0.14367189f, -0.10866915f, 0.06247222f, -0.06017613f, 0.07273748f, -0.11479610f, 
    0.05498604f, 0.10207698f, 0.02847110f, -0.01031397f, 0.07677476f, -0.05337543f, 0.12016023f, 0.04076811f, 
    -0.02857575f, -0.00934924f, 0.05081373f, 0.04893311f, -0.23331727f, -0.32873067f, 0.46404350f, -0.17662317f, 
    0.07071993f, 0.09696026f, -0.10327249f, 0.14306962f, -0.04259146f, 0.01420775f, -0.13840854f, -0.03941752f, 
    -0.17904608f, -0.07916471f, -0.12733379f, 0.07455580f, 0.02165539f, -0.00223001f, 0.00538672f, 0.02763290f, 
    0.08782278f, -0.05726723f, 0.11982115f, 0.13776729f, -0.02383035f, -0.13356499f, 0.14239627f, -0.05471450f, 
    0.03756744f, 0.06037304f, -0.04165863f, -0.11517622f, 0.09194498f, 0.02050463f, -0.06206621f, 0.09706781f, 
    0.14619316f, -0.02434926f, -0.10808305f, 0.26271874f, -0.09451823f, 0.01836536f, 0.14194931f, -0.05488723f, 
    0.06211721f, 0.07143438f, -0.02177689f, 0.07794420f, -0.15038331f, -0.12925571f, 0.02470398f, 0.01871655f, 
    0.06646696f, 0.02691360f, 0.09636965f, 0.01270526f, -0.01399115f, 0.02711071f, 0.04208426f, 0.00509777f, 
    -0.02755533f, -0.06300239f, 0.25758308f, 0.20788807f, -0.01044098f, 0.15925643f, 0.09031001f, 0.06503528f, 
    -0.10865939f, -0.11825673f, -0.05667061f, 0.08541755f, 0.09847701f, -0.02158565f, 0.03733196f, -0.06446844f, 
    0.08565097f, 0.06058061f, -0.18006453f, 0.12794270f, -0.08273862f, 0.08944567f, 0.04700818f, 0.12473810f, 
    0.24821633f, 0.10189173f, -0.22636238f, 0.25642475f, 0.10299027f, 0.08260746f, 0.09555488f, 0.15286241f, 
    0.01802572f, 0.11407668f, -0.12647006f, -0.12472202f, -0.21158193f, -0.20633596f, 0.01486260f, 0.00468155f, 
    -0.01577225f, -0.04247190f, -0.02389481f, 0.00319441f, 0.00149508f, -0.03204707f, -0.04673404f, 0.11455785f, 
    0.14971210f, -0.31262705f, -0.05439472f, -0.06474068f, 0.03536124f, -0.03595342f, -0.00820601f, 0.15665951f, 
    -0.08885431f, -0.03329642f, 0.18926084f, -0.08115327f, -0.17394760f, -0.17412882f, -0.08462571f, 0.02279162f, 
    -0.06284717f, 0.01334385f, -0.09358305f, -0.05123224f, -0.02271449f, 0.03257091f, 0.10645314f, 0.15999268f, 
    0.15398541f, 0.09047549f, 0.13694769f, -0.04429621f, 0.02867462f, -0.03531548f, -0.06164471f, -0.02001227f, 
    -0.00639628f, -0.09335994f, -0.01420829f, 0.02639204f, 0.30661327f, 0.25409955f, 0.19952838f, 0.01992399f, 
    0.22030494f, 0.13413678f, 0.13647316f, 0.20498395f, -0.03271997f, 0.02785077f, -0.06811649f, 0.02094606f, 
    0.01100280f, 0.08622796f, 0.11042186f, -0.13223183f, 0.02392348f, -0.13681135f, 0.00395712f, 0.08965748f, 
    0.05096133f, -0.06441186f, 0.08526554f, -0.01310025f, -0.07638458f, -0.28561839f, -0.24505208f, 0.09124201f, 
    -0.04277175f, -0.01513335f, -0.07418264f, -0.09500265f, 0.13041919f, -0.02405255f, -0.00793091f, 0.13507551f, 
    0.18329202f, -0.11266323f, -0.25680828f, 0.18266778f, -0.12423716f, 0.07809129f, 0.08824976f, -0.02471443f, 
    -0.09509178f, -0.06415409f, -0.00577381f, -0.03481710f, -0.06721177f, -0.04342851f, -0.06679600f, -0.11839795f, 
    0.02629183f, 0.02179165f, 0.09868754f, 0.19309388f, -0.07369768f, 0.05433122f, 0.05456218f, -0.02815925f, 
    0.01793227f, -0.16751809f, -0.07472228f, -0.00631232f, -0.06191839f, 0.05849217f, 0.08648635f, 0.03654963f, 
    0.15120423f, -0.10845133f, -0.10435257f, 0.01336597f, -0.05394657f, 0.01489900f, 0.11867460f, 0.10339778f, 
    -0.08071752f, -0.11630190f, 0.05088585f, 0.02850717f, -0.08521710f, 0.05120093f, -0.10510349f, -0.05352674f, 
    0.09076929f, 0.07300457f, -0.00349595f, -0.03582165f, 0.10167439f, 0.11745311f, 0.03565937f, -0.00836316f, 
    -0.00528127f, -0.04668853f, -0.02652010f, 0.17661613f, -0.01720055f, -0.06222849f, 0.02802092f, 0.09384735f, 
    -0.04642877f, 0.00752278f, 0.10988081f, -0.01519814f, -0.07431141f, -0.11276706f, 0.17984986f, -0.02943608f, 
    0.27500939f, 0.28073868f, 0.27382043f, 0.09054143f, 0.14806491f, 0.01673977f, 0.03885686f, 0.06221239f, 
    -0.00723890f, -0.05461643f, 0.02326047f, 0.03055411f, 0.07980607f, 0.32649982f, 0.44456881f, 0.00376116f, 
    0.02977210f, 0.05986890f, 0.03008571f, 0.02809035f, 0.09688906f, -0.00141064f, -0.01335233f, -0.17196779f, 
    0.05316876f, 0.12611450f, -0.09194577f, -0.12222581f, 0.15693203f, 0.03795339f, -0.01486759f, 0.09222729f, 
    0.04588767f, 0.11783259f, -0.22141302f, -0.04678522f, 0.01662105f, -0.04436048f, -0.11400266f, -0.10264747f, 
    0.05543091f, -0.05973478f, 0.04849797f, 0.03089176f, -0.09801284f, 0.11998501f, 0.10886974f, -0.09299169f, 
    -0.36487207f, -0.35811427f, 0.21768802f, 0.06543451f, 0.00586689f, 0.10514142f, -0.01811525f, -0.12284154f, 
    0.01495768f, -0.04332171f, -0.10467901f, -0.07594299f, 0.01647465f, 0.15005629f, 0.24976644f, -0.00013117f, 
    -0.06279608f, 0.00256670f, -0.01084104f, 0.01571453f, 0.00038649f, -0.04290280f, -0.04388734f, 0.14987919f, 
    0.02946332f, -0.00733485f, -0.00235126f, 0.01653092f, 0.00584866f, -0.05703009f, -0.03058237f, 0.02587291f, 
    0.04056737f, -0.05618257f, 0.02084342f, -0.00531976f, 0.04505302f, -0.03798613f, 0.00157620f, -0.01787697f, 
    0.04037435f, 0.01548783f, -0.04286025f, 0.00853687f, -0.00617426f, 0.03757666f, -0.02246851f, -0.01659545f, 
    0.03468141f, -0.02933851f, -0.01463620f, -0.02685846f, -0.04469218f, 0.04044617f, -0.04642028f, 0.03833841f, 
    -0.05510288f, -0.01771341f, -0.03409883f, -0.05599864f, 0.02027604f, -0.04724647f, 0.01814734f, -0.01358395f, 
    -0.04057889f, -0.03519215f, 0.01619500f, -0.04988547f, -0.03572316f, -0.00820723f, -0.04785571f, -0.04351279f, 
    -0.00034345f, -0.01993165f, 0.02263834f, -0.04838124f, -0.04052876f, 0.00369825f, -0.03456123f, -0.01011238f, 
    -0.03245339f, 0.02585593f, 0.02273219f, -0.04816855f, 0.03392585f, -0.02209270f, 0.01934669f, -0.02260607f, 
    0.01164764f, 0.02885438f, -0.00079542f, 0.00342697f, -0.01818967f, 0.02277058f, 0.02914871f, -0.00412722f, 
    -0.01035577f, -0.02930333f, 0.01780679f, -0.03929871f, -0.00383557f, 0.02436465f, -0.03338365f, -0.00318472f, 
    -0.00590834f, 0.02725783f, 0.02098494f, 0.00203591f, 0.01843132f, -0.01287287f, 0.03712946f, 0.01331271f, 
    -0.00956644f, -0.01603477f, -0.03870182f, 0.01039743f, 0.02383810f, -0.03519613f, -0.02978635f, -0.03743668f, 
    0.04542334f, 0.03846952f, 0.01074458f, -0.05141770f, 0.01209919f, 0.00972398f, 0.01191416f, -0.03667274f, 
    0.00536625f, -0.00712773f, -0.03371975f, -0.02015787f, -0.05659512f, -0.00193025f, 0.01279770f, 0.01149930f, 
    -0.02860742f, 0.03361259f, 0.01834944f, -0.02719070f, -0.03425618f, 0.01370430f, -0.04257964f, 0.02756404f, 
    0.03189038f, 0.01463238f, -0.03765114f, 0.01756667f, 0.00753814f, -0.01445202f, -0.04986858f, 0.01922760f, 
    0.03605357f, 0.02960309f, -0.04450835f, -0.00019834f, 0.04488768f, 0.02615741f, -0.01038506f, -0.01086894f, 
    -0.01550614f, -0.00003171f, 0.04068810f, -0.03219760f, -0.04911702f, -0.01021415f, -0.04321623f, -0.02230333f, 
    0.04165369f, 0.00268055f, 0.04955718f, 0.01435614f, -0.00301992f, 0.03167059f, 0.04306441f, 0.03186570f, 
    0.02626916f, -0.04568946f, -0.04616782f, 0.00290697f, 0.01258349f, -0.01432550f, -0.00051647f, -0.01255120f, 
    0.02219264f, -0.03323558f, 0.01819139f, -0.02432061f, -0.05024380f, -0.00466627f, -0.02486597f, -0.03655120f, 
    -0.02918347f, -0.01036006f, 0.04199005f, -0.03372663f, -0.03105851f, -0.04048373f, -0.04811811f, -0.04314747f, 
    -0.01483437f, -0.05629300f, 0.03908863f, 0.02953681f, 0.01330558f, -0.01689023f, 0.02965889f, 0.02371734f, 
    0.00098658f, -0.04744707f, 0.02793480f, -0.01143402f, -0.04592529f, -0.02353452f, 0.00024382f, 0.02159918f, 
    0.01540705f, 0.04833593f, 0.01768349f, 0.02522720f, -0.02248873f, -0.01768243f, -0.00393229f, -0.03748202f, 
    -0.05352002f, -0.04776717f, -0.01631647f, -0.01331324f, -0.03047419f, -0.02370690f, -0.02914637f, -0.02349395f, 
    -0.01266914f, -0.02386673f, -0.02086437f, -0.01550149f, -0.01177678f, -0.00819813f, -0.02878425f, -0.02050568f, 
    0.03462369f, 0.00402163f, 0.01923513f, -0.01646410f, 0.04649327f, 0.02579696f, 0.03945434f, 0.02677540f, 
    0.02065977f, -0.04809456f, -0.02900481f, -0.04205411f, -0.02618217f, -0.03818088f, 0.00596191f, -0.01472216f, 
    -0.04825748f, 0.00565389f, -0.01430158f, -0.04031840f, -0.05381156f, -0.00623007f, 0.01101725f, -0.02862332f, 
    0.00192774f, -0.03178991f, -0.02730885f, -0.04814292f, 0.04184297f, -0.02053952f, -0.02162191f, 0.00334088f, 
    0.00844823f, 0.01903603f, 0.03621050f, 0.03051683f, -0.03049471f, -0.02711742f, -0.02927270f, 0.02136141f, 
    -0.00872469f, -0.04151208f, 0.00241449f, -0.01271891f, -0.03738496f, 0.04172627f, -0.01195778f, 0.00153976f, 
    -0.03175979f, -0.01389642f, 0.04869876f, 0.01326537f, 0.01198213f, 0.04167841f, -0.00786262f, -0.02476377f, 
    -0.00195793f, -0.02582984f, -0.05371875f, 0.01948117f, -0.02063579f, 0.01696426f, 0.01679913f, 0.02317612f, 
    -0.02900660f, -0.00259702f, -0.00212254f, -0.05530107f, -0.01083838f, -0.05170767f, -0.04329909f, -0.02384071f, 
    0.04112013f, 0.00367426f, 0.03994405f, -0.00043525f, 0.02348538f, -0.00047737f, 0.01244422f, -0.00162768f, 
    0.02160172f, -0.03163452f, -0.00071247f, 0.03702135f, -0.04240308f, 0.00048397f, -0.03473656f, 0.01637328f, 
    0.03482950f, -0.00316967f, -0.04568924f, -0.03378624f, -0.00633557f, 0.04485288f, 0.03358038f, -0.01570900f, 
    -0.01091180f, 0.03779636f, 0.00841921f, -0.01405160f, 0.04625641f, -0.04878849f, 0.04964003f, 0.00469052f, 
    0.03100656f, -0.04491200f, -0.04757515f, -0.03756695f, -0.02041485f, -0.02062309f, -0.03984686f, -0.00774459f, 
    0.01271432f, 0.02790286f, -0.00751371f, -0.00718083f, -0.04138557f, 0.03049257f, 0.03702946f, -0.04534116f, 
    -0.05031675f, -0.04477419f, -0.01851427f, -0.04941455f, -0.04278211f, 0.01991339f, -0.03535186f, 0.03361280f, 
    -0.00805256f, 0.02185757f, 0.04569285f, -0.03780501f, -0.02476244f, 0.02479270f, 0.01279541f, 0.03249880f, 
    0.02064664f, 0.00526510f, -0.05100466f, -0.02637256f, 0.03394584f, -0.02020388f, -0.03524890f, 0.00167757f, 
    -0.05089301f, -0.02647487f, -0.02736939f, -0.04317933f, -0.01383689f, -0.02873278f, 0.00928754f, 0.01871016f, 
    -0.05069210f, -0.05517191f, -0.05442057f, -0.04368234f, 0.02869982f, 0.03849869f, 0.02171701f, -0.02184248f, 
    0.02498148f, -0.03805369f, -0.04054881f, 0.00455083f, 0.02517040f, -0.03456855f, -0.04842027f, 0.03771655f, 
    0.04230064f, -0.02945064f, -0.01334322f, -0.03877611f, -0.03151615f, 0.02896473f, 0.01520244f, -0.03968275f, 
    -0.04087404f, 0.03117450f, -0.00908913f, 0.03413708f, 0.00870476f, 0.00931810f, 0.05110600f, -0.05585279f, 
    0.02334534f, 0.02703784f, -0.01339139f, -0.03832113f, -0.04630428f, 0.03762408f, -0.02731932f, -0.05266524f, 
    -0.04843476f, 0.04380406f, -0.03636750f, 0.00745086f, 0.02974889f, 0.03082269f, -0.04090272f, 0.01353269f, 
    0.01727473f, 0.00981973f, 0.00052869f, -0.03952026f, 0.04341163f, -0.00526758f, 0.02079165f, 0.04486519f, 
    0.03572068f, -0.04402715f, 0.04220863f, -0.02250304f, -0.04273909f, -0.01939278f, 0.01514042f, -0.02922838f, 
    -0.02044580f, 0.01829551f, -0.03517641f, 0.03414679f, -0.01725142f, -0.04609079f, 0.03475356f, 0.03607108f, 
    0.00867367f, -0.01228606f, -0.02928766f, -0.03995371f, 0.00083961f, 0.01854089f, -0.02227554f, -0.00605428f, 
    -0.01996147f, 0.04356689f, 0.02908715f, 0.01345087f, 0.03390761f, 0.02285488f, 0.03021779f, -0.01756519f, 
    -0.01692527f, -0.00595474f, 0.03210261f, -0.04208142f, 0.04195474f, 0.02628705f, -0.02251864f, -0.05588071f, 
    0.02125963f, -0.02539819f, 0.01206152f, 0.04097020f, 0.00937131f, -0.04457070f, -0.04026663f, -0.04060801f, 
    0.03133726f, -0.05282900f, 0.03315843f, 0.02905491f, 0.04829069f, 0.04270951f, 0.00865352f, -0.03987230f, 
    -0.03774587f, -0.00492386f, -0.01948288f, -0.02110515f, -0.00201044f, 0.04114402f, 0.03171777f, 0.01116329f, 
    -0.03915733f, 0.01203124f, -0.04190039f, 0.04201351f, -0.05504049f, 0.00137334f, -0.01936780f, 0.02776224f, 
    -0.04905107f, 0.02885945f, -0.03207039f, 0.03180757f, -0.02171378f, 0.03581003f, -0.01570115f, 0.00481098f, 
    0.02659093f, 0.01038128f, 0.03305013f, 0.02736304f, 0.00555748f, 0.02306518f, 0.00714487f, 0.05183648f, 
    -0.05653020f, 0.03940060f, -0.04975241f, -0.05467281f, 0.03472345f, 0.00568548f, -0.02145616f, 0.01862703f, 
    -0.02614127f, 0.01221122f, -0.02520664f, 0.03285853f, -0.03303083f, -0.03290915f, 0.04563728f, 0.01472839f, 
    -0.04267335f, -0.00533033f, -0.00821314f, 0.03258927f, -0.02354094f, -0.03980886f, -0.00489628f, 0.02702506f, 
    0.00705436f, -0.00842899f, -0.04148322f, -0.04710215f, -0.02918695f, 0.01180055f, -0.00635169f, 0.01485178f, 
    0.01295387f, -0.03557483f, -0.03456871f, -0.02668268f, 0.03607613f, -0.03761150f, 0.00958651f, 0.04319351f, 
    -0.03589447f, 0.00947518f, 0.01639595f, 0.02061860f, 0.01020642f, -0.05049352f, 0.01806372f, 0.05376915f, 
    -0.04412326f, -0.04323153f, -0.01553333f, -0.02696213f, -0.00138466f, -0.03035597f, 0.04559953f, -0.01616494f, 
    -0.00657109f, 0.03205562f, -0.04522487f, -0.03983717f, 0.04107626f, -0.04353195f, 0.03835479f, 0.03145934f, 
    -0.01367822f, -0.01069972f, -0.04981312f, -0.03776962f, 0.03903424f, -0.01976752f, -0.02049528f, -0.00864611f, 
    -0.02136571f, 0.02604429f, 0.03599829f, -0.01344602f, 0.01590985f, 0.04298960f, -0.02819138f, -0.04050362f, 
    -0.02042950f, -0.00807943f, 0.02707159f, 0.01860408f, 0.00106904f, -0.05513506f, 0.02833008f, -0.00565227f, 
    -0.02835439f, 0.01839004f, 0.03028893f, -0.01000829f, -0.04507518f, 0.01945156f, -0.04912641f, 0.05045794f, 
    -0.02134285f, -0.03008118f, -0.03225810f, 0.03005828f, 0.01278686f, -0.03158394f, -0.04489308f, -0.05078772f, 
    0.01806354f, -0.02421313f, -0.05197633f, 0.03495343f, -0.00529216f, -0.03986422f, -0.00472125f, -0.01218087f, 
    0.04121709f, -0.00683570f, 0.02734652f, -0.03968537f, -0.01198181f, 0.01662288f, -0.01411148f, -0.04344771f, 
    0.00939851f, -0.01912476f, -0.05816985f, 0.00025965f, -0.04589191f, 0.02283318f, 0.03229239f, -0.03074022f, 
    0.04136324f, -0.00688407f, 0.03282187f, 0.03117802f, 0.04368930f, -0.04173618f, 0.02615264f, 0.03634915f, 
    0.03276285f, -0.03189919f, 0.04920973f, -0.00674382f, 0.01096650f, 0.01601729f, 0.00698728f, 0.02788256f, 
    0.03476237f, 0.01918907f, 0.02178269f, -0.05187162f, -0.00957732f, -0.04378710f, -0.02094812f, -0.04886340f, 
    0.02464954f, -0.04725460f, 0.02966599f, -0.05462392f, -0.02433071f, 0.03198934f, -0.04242858f, -0.05347068f, 
    -0.00593779f, -0.05167771f, -0.03896919f, -0.01228482f, 0.00546576f, 0.03743277f, 0.02330864f, 0.02447972f, 
    -0.00618463f, -0.01008180f, -0.00497339f, -0.04696377f, -0.03236599f, -0.04422908f, 0.00981039f, -0.01131445f, 
    -0.02034251f, 0.03134963f, -0.03557747f, -0.04307753f, -0.04736450f, -0.04893077f, 0.03323574f, 0.00803953f, 
    0.04640874f, -0.04108919f, 0.00517859f, -0.05383004f, 0.03093017f, -0.01693716f, -0.03773638f, 0.04175480f, 
    0.04566988f, -0.00699598f, -0.02281239f, -0.05000464f, -0.04639942f, -0.04519577f, -0.01492061f, -0.02269197f, 
    -0.03377445f, 0.03150843f, 0.02552734f, 0.04649369f, 0.00252369f, 0.00330733f, 0.03296754f, 0.03277517f, 
    0.01263150f, -0.02423647f, -0.05679743f, -0.05058957f, 0.03477297f, -0.01848307f, 0.03941449f, -0.05884623f, 
    -0.01929929f, -0.02925120f, -0.00255810f, -0.02290627f, -0.01988079f, -0.05939123f, -0.00222880f, -0.05371220f, 
    0.03738672f, -0.00586578f, -0.01717790f, -0.01192326f, 0.03378756f, 0.02062101f, -0.04081053f, -0.03879753f, 
    0.02578674f, 0.03977057f, 0.01465594f, 0.01758697f, -0.05234568f, -0.02880176f, -0.03641856f, 0.01283053f, 
    -0.00317305f, 0.03025483f, 0.01722479f, -0.03836104f, -0.01006573f, 0.01025587f, -0.01603811f, 0.02451417f, 
    -0.04308530f, -0.02967989f, 0.02178251f, -0.02145429f, -0.03268782f, 0.03043778f, 0.01143688f, -0.00757813f, 
    0.18783012f, -0.16986625f, 0.03636229f, -0.01011266f, -0.01232121f, 0.07781981f, -0.22935422f, -0.02940056f, 
    -0.03893266f, -0.01540764f, -0.01266062f, -0.06307287f, 0.25281376f, 0.27177095f, 0.21579500f, 0.00288046f, 
    0.07867531f, 0.04455890f, 0.12930588f, 0.21847163f, 0.02879025f, -0.06366561f, 0.01631436f, -0.07641511f, 
    0.03743254f, -0.32742143f, -0.10392536f, -0.33197618f, 0.07951752f, 0.01583241f, -0.03173194f, -0.08527820f, 
    0.17409368f, -0.13186045f, -0.05934728f, -0.08002188f, 0.47136763f, -0.01691688f, 0.27720329f, 0.19454548f, 
    -0.01194968f, 0.06747989f, 0.14772375f, -0.03991511f, 0.14479044f, -0.08215979f, -0.04340438f, 0.12448724f, 
    0.06391807f, 0.11221927f, 0.02257971f, -0.02272854f, -0.04046703f, -0.04556448f, -0.11399138f, 0.00375810f, 
    0.05968385f, -0.07532211f, 0.04870220f, -0.02548654f, 0.02677617f, -0.35027871f, 0.02602560f, -0.18098475f, 
    0.00598298f, 0.02300336f, 0.00085085f, 0.00323676f, -0.04182510f, -0.04651171f, -0.05973912f, 0.04195209f, 
    -0.12956265f, -0.11248694f, 0.01633644f, -0.00208131f, -0.03963244f, -0.03579640f, -0.07366121f, 0.02169544f, 
    0.01610248f, 0.00891684f, 0.05672253f, 0.06211687f, -0.02912550f, 0.02249197f, 0.06510431f, 0.27669957f, 
    0.01308361f, -0.07517000f, -0.10049684f, -0.03899856f, 0.01730917f, 0.03816390f, 0.11262700f, 0.00637139f, 
    -0.09193502f, 0.16549389f, -0.08960266f, 0.12121937f, 0.09812938f, 0.01771151f, 0.09748696f, -0.03762465f, 
    0.09439988f, 0.11350968f, -0.04634117f, 0.03651623f, -0.09960759f, -0.14781155f, -0.00634109f, 0.13927928f, 
    0.09471743f, -0.12537624f, -0.06602760f, 0.03028012f, 0.00434427f, -0.04630824f, -0.07152826f, 0.06791875f, 
    -0.07284196f, 0.02738036f, -0.09364719f, 0.00753740f, 0.07138595f, 0.04284128f, -0.03048739f, 0.13223012f, 
    -0.03859980f, -0.15324138f, -0.07190631f, -0.13054819f, 0.06686427f, -0.06994873f, -0.00109328f, 0.10976395f, 
    0.00864348f, 0.02162986f, -0.17272332f, 0.04556473f, 0.09623062f, -0.05479235f, -0.05640436f, 0.16720290f, 
    -0.13242796f, 0.33284658f, -0.49448165f, 0.26566151f, 0.17086262f, 0.00341450f, 0.11187620f, 0.16936922f, 
    0.06789103f, -0.01814174f, -0.05382875f, -0.07764597f, -0.17730619f, -0.28163555f, -0.04117920f, -0.05749230f, 
    0.01812517f, 0.00549175f, -0.08402286f, -0.06615562f, 0.15797432f, 0.00694022f, -0.00817267f, 0.03189250f, 
    0.06439167f, 0.11526056f, 0.20426153f, -0.24386868f, 0.07975782f, 0.00615087f, 0.00590481f, 0.12368746f, 
    -0.05999555f, -0.07549235f, 0.07351063f, -0.01279999f, -0.02450733f, -0.26564890f, 0.01743571f, -0.10073067f, 
    0.04812196f, -0.03601468f, -0.06893270f, 0.03139430f, -0.02600324f, 0.02198607f, 0.06399427f, 0.07782748f, 
    0.09037948f, 0.11266728f, -0.03650551f, -0.06763729f, 0.09612916f, 0.06568033f, 0.05624495f, 0.02131757f, 
    0.00402434f, 0.00368706f, 0.00122754f, -0.02108066f, 0.22336499f, 0.24954654f, 0.17207773f, 0.08337975f, 
    0.11756405f, 0.07827996f, 0.06579530f, 0.05009884f, 0.02853911f, 0.06499699f, 0.01804436f, -0.00431485f, 
    0.01361986f, 0.03092764f, -0.13699561f, -0.15602539f, -0.01530667f, 0.08374454f, -0.04655818f, 0.00752951f, 
    0.14673904f, 0.09970400f, -0.02142102f, -0.01075418f, 0.13314956f, -0.28060752f, -0.05672417f, -0.20711289f, 
    -0.04078858f, -0.06434462f, -0.10310570f, -0.12959035f, -0.04947566f, 0.03137790f, -0.00684676f, 0.17464830f, 
    -0.23398140f, 0.17934808f, -0.27970958f, 0.14319941f, 0.08485048f, 0.04686110f, -0.05862699f, -0.04784298f, 
    0.10983450f, -0.20847024f, -0.08828443f, 0.03662764f, -0.11866146f, 0.09735356f, 0.01118535f, -0.09370176f, 
    0.04657656f, -0.07770409f, 0.01859174f, -0.01895311f, 0.06880951f, -0.08970217f, 0.09803238f, 0.08520394f, 
    0.02825500f, -0.19310646f, 0.10719887f, -0.27759486f, 0.00177190f, 0.00141343f, -0.03222519f, 0.00944491f, 
    0.12225609f, -0.09205548f, -0.04889341f, -0.04833604f, -0.00562467f, -0.19568256f, -0.04470725f, -0.07319094f, 
    -0.15191424f, -0.05601906f, 0.01363234f, 0.04189859f, -0.07495881f, -0.08435562f, -0.16276887f, 0.15887205f, 
    -0.06552593f, 0.15182273f, 0.18316962f, 0.03456428f, 0.04591028f, 0.05441086f, -0.00949739f, 0.05639611f, 
    0.15107298f, 0.00717575f, 0.07323101f, 0.13578250f, -0.00212333f, -0.29501683f, -0.04187997f, -0.12409320f, 
    0.04929959f, -0.01333534f, 0.03723750f, -0.03660228f, 0.01304055f, -0.07959533f, -0.06691632f, -0.00850697f, 
    0.33504874f, 0.38183954f, 0.37958196f, 0.23867632f, 0.05660550f, -0.08455107f, -0.03448992f, 0.04917395f, 
    0.06176275f, 0.02219350f, 0.09247743f, 0.03319145f, 0.13569458f, 0.00395086f, 0.20990060f, 0.06280669f, 
    0.05706102f, -0.12191194f, 0.13138044f, 0.04860724f, 0.19607009f, -0.07896737f, -0.10046129f, -0.04498140f, 
    -0.08981612f, 0.09158227f, -0.17450516f, 0.10582217f, 0.05129977f, -0.01478738f, -0.01403626f, 0.02413462f, 
    0.04680045f, -0.08537746f, 0.00785693f, -0.01373865f, 0.04090230f, -0.16059063f, -0.15866770f, -0.25671780f, 
    0.17524606f, 0.16235361f, -0.02078936f, -0.00062346f, 0.07415505f, -0.02170858f, 0.04326547f, -0.06796445f, 
    -0.48474157f, -0.41766486f, 0.13424239f, 0.01989088f, 0.14368378f, -0.02350875f, -0.02921691f, 0.03370098f, 
    -0.00710795f, -0.11360446f, -0.06491311f, 0.00054754f, -0.01720036f, 0.10099049f, -0.01678601f, 0.16810358f, 
    -0.00550920f, 0.03832105f, 0.02912114f, 0.03808957f, 0.18292467f, 0.03961832f, 0.04539556f, 0.10290432f, 
    0.18573205f, -0.16312921f, 0.05977351f, -0.07245178f, 0.02266553f, 0.17902924f, -0.02743570f, -0.07545087f, 
    0.07150932f, 0.03149994f, 0.03997208f, -0.11557475f, 0.22070459f, 0.07919053f, 0.19940673f, 0.14371622f, 
    0.09040774f, 0.06303448f, -0.11335455f, 0.10746568f, 0.05063151f, -0.06032877f, -0.00011037f, -0.03052517f, 
    0.02890257f, -0.19895214f, -0.04431437f, -0.11539876f, 0.09084792f, 0.11818948f, 0.02175980f, -0.05988261f, 
    -0.00603620f, 0.05458508f, 0.05301316f, -0.04103218f, 0.44691885f, 0.07673868f, -0.19540790f, -0.22636488f, 
    -0.15257359f, -0.01936681f, 0.05091784f, -0.08714852f, 0.02386213f, 0.08659310f, -0.35305974f, 0.11780730f, 
    0.08077577f, 0.07128687f, 0.02067048f, 0.03787316f, -0.07177864f, -0.06509552f, -0.21800296f, -0.09073674f, 
    0.07129657f, -0.02647343f, 0.01331249f, -0.02475521f, 0.10342519f, -0.23103996f, 0.03628048f, 0.06095445f, 
    -0.03620298f, -0.02740945f, -0.11147499f, -0.16214664f, -0.09601503f, -0.11547375f, 0.05724762f, -0.09667895f, 
    0.02501077f, -0.09629466f, -0.02154574f, -0.03528821f, 0.01181635f, -0.02959004f, 0.03404500f, 0.00022761f, 
    -0.05219423f, 0.10587337f, 0.00781124f, 0.14649320f, 0.36521193f, -0.05383719f, -0.15392466f, -0.19050050f, 
    -0.06027903f, 0.00320529f, 0.07500242f, 0.02528915f, -0.09914885f, 0.03890337f, -0.01593984f, -0.02252692f, 
    -0.19630058f, -0.06710040f, 0.12144312f, 0.15580429f, 0.03313936f, 0.04487554f, -0.01108168f, 0.00674387f, 
    -0.10531437f, -0.01047489f, 0.17819485f, 0.01093826f, 0.11235507f, 0.11207704f, 0.05405058f, 0.12102781f, 
    0.13571768f, -0.01830574f, -0.08518154f, -0.29312658f, 0.03615119f, -0.08856425f, -0.05299414f, 0.18833499f, 
    0.08117580f, 0.20126496f, -0.07314936f, -0.06459235f, 0.09753758f, -0.22012404f, 0.00632912f, -0.03819225f, 
    0.05561385f, -0.00572211f, -0.01442801f, -0.11333256f, 0.07991967f, 0.00615118f, 0.07543449f, 0.09468608f, 
    0.12042566f, 0.04476316f, 0.08570564f, 0.03504657f, -0.05566623f, 0.06420874f, -0.03388933f, 0.24485666f, 
    -0.06028337f, 0.21656951f, 0.17185639f, 0.30212206f, 0.05747913f, -0.20502453f, -0.16282913f, -0.09624650f, 
    0.11004455f, 0.00226193f, 0.02583529f, -0.08213950f, -0.11287953f, -0.05314659f, 0.02850994f, -0.12050575f, 
    0.01076531f, -0.03546995f, -0.01728087f, 0.01019145f, 0.18957059f, 0.05652198f, 0.02868910f, -0.03903385f, 
    -0.27006775f, 0.13694189f, 0.00106771f, -0.02533296f, -0.08352838f, -0.02759406f, -0.00290719f, 0.03518621f, 
    -0.10674474f, 0.01632853f, -0.07543560f, 0.06411645f, -0.01344248f, -0.04683583f, 0.05355043f, -0.06631524f, 
    -0.00852184f, 0.05745117f, 0.15402021f, 0.03604330f, 0.02089977f, 0.21675520f, 0.04085854f, 0.06634698f, 
    0.05028879f, 0.14368156f, -0.24083444f, 0.11975653f, 0.03829056f, -0.00511542f, -0.06941458f, -0.24270214f, 
    0.00149263f, -0.06029766f, 0.05013834f, 0.07371112f, 0.12178535f, -0.10855635f, 0.06373778f, -0.06851513f, 
    0.00453631f, -0.08102987f, 0.06805611f, 0.03306911f, -0.05634223f, -0.10950106f, 0.02181053f, -0.03794942f, 
    0.08463685f, 0.05221321f, -0.07382926f, 0.05664024f, -0.13697797f, 0.14164864f, -0.01378017f, 0.00407221f, 
    0.10178038f, 0.05808445f, -0.05575417f, -0.04210342f, -0.01560211f, -0.02684278f, 0.22427471f, -0.05777604f, 
    0.01854444f, 0.09233280f, -0.01186044f, 0.01956328f, -0.06267972f, 0.01754078f, -0.10333835f, -0.12301560f, 
    -0.34239405f, 0.21961485f, 0.10985457f, 0.11255515f, 0.03398154f, -0.24893835f, -0.04598690f, -0.00624388f, 
    0.07111836f, 0.10274669f, 0.02768420f, 0.00799366f, 0.27592379f, 0.00261764f, 0.12200121f, 0.01700172f, 
    0.09029768f, 0.01653513f, -0.08527046f, 0.04476605f, 0.02432364f, 0.01508101f, 0.04163088f, 0.17741454f, 
    -0.13692038f, -0.19618674f, 0.12122992f, -0.04178394f, 0.10361735f, 0.01984336f, -0.06747273f, 0.04018753f, 
    -0.03687320f, 0.08224325f, 0.17151129f, 0.04717936f, -0.26395473f, -0.13508199f, -0.28036019f, -0.13016354f, 
    0.05778987f, -0.04204742f, -0.01434986f, 0.00506150f, 0.10504190f, -0.25492883f, 0.02308686f, 0.08576912f, 
    0.15752079f, -0.01802075f, 0.00997256f, 0.00639140f, 0.10607983f, 0.19932128f, -0.02066249f, 0.06049146f, 
    -0.00153791f, -0.03719904f, 0.07740203f, 0.13572764f, -0.05657368f, -0.03476390f, -0.00817180f, -0.15921861f, 
    -0.01868898f, 0.00083471f, -0.07223979f, -0.01004773f, -0.00152130f, 0.00757210f, -0.10809021f, -0.05138139f, 
    0.30801731f, 0.15131670f, -0.00615710f, 0.08748162f, 0.08402362f, 0.10784884f, 0.12986685f, 0.02702870f, 
    -0.07505635f, -0.13391086f, 0.06968658f, 0.03403246f, 0.32307738f, -0.06109539f, -0.02606622f, -0.13265201f, 
    -0.03966899f, -0.03323104f, 0.05680092f, -0.07657409f, 0.01924524f, -0.11995436f, -0.02411099f, 0.02485752f, 
    0.17783326f, -0.00644929f, 0.16924766f, 0.17351805f, -0.02545317f, 0.05496471f, 0.04175685f, -0.01870419f, 
    -0.10787257f, -0.12737638f, 0.15740179f, 0.03705302f, -0.00724337f, 0.04096820f, 0.06146259f, 0.16063088f, 
    -0.12994519f, 0.08982177f, 0.03815516f, -0.05232004f, 0.25262332f, 0.08873341f, 0.01392813f, 0.16358618f, 
    0.23720212f, 0.10446527f, -0.17031418f, 0.03877425f, 0.06204162f, -0.05900087f, 0.02229094f, -0.03426739f, 
    0.04350854f, -0.00332728f, 0.04671486f, 0.10153528f, 0.18417506f, 0.17246154f, -0.02347110f, 0.02216243f, 
    -0.02582188f, -0.10809595f, 0.09638464f, 0.02500319f, -0.21050727f, 0.01302002f, -0.11342094f, 0.09484017f, 
    0.02890875f, -0.04066206f, -0.05646268f, -0.03013222f, -0.03940883f, 0.02139395f, -0.04168019f, 0.01916842f, 
    -0.00239810f, 0.03561372f, -0.03330769f, -0.03573487f, -0.01828123f, -0.02071559f, 0.02803813f, -0.05912044f, 
    -0.02730345f, 0.01224348f, 0.03479844f, 0.03842766f, -0.04429059f, 0.02150286f, 0.01999690f, 0.02122071f, 
    -0.04093516f, -0.04329732f, -0.01932624f, 0.01664146f, -0.04093389f, -0.03782664f, -0.05957560f, -0.01032563f, 
    -0.02764963f, 0.00585142f, 0.01014493f, -0.01205563f, 0.02780123f, -0.06126818f, 0.01951813f, -0.02060558f, 
    -0.05682782f, -0.01076322f, -0.01423225f, 0.01065916f, -0.00341832f, -0.04318877f, 0.01855712f, -0.05826743f, 
    -0.03098125f, 0.01817459f, -0.04561072f, -0.00356665f, -0.02993549f, -0.04623363f, -0.01130222f, 0.03849160f, 
    -0.04118275f, -0.02780810f, 0.00489430f, -0.00846189f, -0.04241044f, -0.04134690f, 0.03331735f, -0.01223436f, 
    -0.00064423f, -0.01913808f, -0.01313009f, 0.00934485f, -0.02807284f, -0.02415696f, -0.05034551f, -0.02222823f, 
    -0.03942657f, -0.03523104f, -0.00933003f, -0.00517794f, -0.00425816f, 0.04623773f, 0.01348067f, -0.01878758f, 
    0.00973195f, -0.04302017f, 0.00882222f, 0.01026550f, -0.01727185f, -0.03508380f, -0.04723785f, 0.02087580f, 
    -0.05976225f, -0.01008924f, 0.00846989f, -0.03108898f, -0.00199985f, 0.03223247f, -0.04442612f, -0.03423869f, 
    -0.04803633f, -0.01567491f, -0.03525419f, -0.02209571f, 0.01653414f, 0.04239742f, 0.00056905f, 0.01887164f, 
    -0.03056514f, -0.00376360f, -0.05048775f, -0.05853363f, -0.00702563f, 0.02767128f, -0.04036445f, 0.04577856f, 
    -0.01993641f, -0.02456342f, 0.01140748f, 0.02220319f, 0.00716207f, -0.00917477f, -0.01302366f, -0.04895836f, 
    0.00851843f, -0.03847774f, -0.04289975f, 0.01270896f, -0.02873392f, -0.01959728f, -0.03531518f, -0.02511616f, 
    -0.02390833f, 0.00341179f, 0.01547499f, 0.02273980f, 0.03257719f, -0.00405204f, -0.04954733f, 0.02662041f, 
    -0.04994124f, 0.03518617f, -0.01426857f, 0.02744990f, -0.03412630f, 0.02673570f, -0.05876653f, 0.00976185f, 
    -0.05519723f, 0.00438436f, -0.02376956f, 0.03738797f, -0.03316443f, -0.03950053f, -0.01736211f, -0.02456859f, 
    -0.05212697f, -0.02065072f, 0.04878763f, -0.05382402f, 0.01514422f, -0.04313842f, 0.00546833f, 0.03768377f, 
    0.01117904f, 0.00191671f, 0.00834348f, -0.03925789f, -0.03323521f, 0.01112189f, -0.02282660f, 0.01984821f, 
    0.03142512f, -0.01660685f, -0.00791929f, -0.06242119f, -0.01955403f, -0.03420546f, 0.00279474f, -0.05014570f, 
    -0.04797384f, 0.00151601f, -0.02444939f, 0.01910005f, -0.01865547f, -0.04052104f, -0.05188809f, 0.00077974f, 
    0.02042240f, -0.01085905f, -0.00760210f, 0.00496050f, -0.01561494f, -0.05555989f, -0.00640035f, -0.01167411f, 
    -0.05956099f, 0.03511624f, -0.04778942f, 0.03234300f, 0.01508920f, 0.02681723f, -0.00555468f, 0.01529444f, 
    -0.00121085f, -0.03892439f, 0.03859876f, -0.02396196f, 0.00258804f, 0.00676008f, -0.04426056f, -0.03333597f, 
    -0.02756214f, -0.01098127f, 0.02462293f, 0.00771243f, -0.05808116f, 0.02795626f, 0.03921931f, 0.03392281f, 
    -0.02741193f, -0.00858862f, -0.04596392f, -0.04136886f, 0.02073834f, -0.00318566f, -0.05492372f, 0.02654878f, 
    -0.03292007f, 0.01318332f, -0.04613746f, 0.02653570f, 0.02211327f, -0.02789298f, -0.00197101f, -0.00330291f, 
    -0.04040148f, -0.05831614f, -0.05770052f, -0.03057185f, -0.01829432f, 0.03057550f, -0.04007027f, -0.05844352f, 
    0.02045688f, -0.00045330f, -0.05451978f, 0.02889130f, -0.01901605f, -0.02798805f, 0.01994262f, 0.00009903f, 
    -0.03142885f, -0.05449460f, 0.01449768f, -0.03444364f, 0.00241806f, 0.01152173f, -0.02708945f, -0.04104283f, 
    -0.05534542f, 0.01747637f, -0.02773419f, -0.05877978f, -0.01133224f, 0.00723881f, -0.05331460f, -0.02914860f, 
    -0.05072034f, -0.01035412f, -0.05204329f, 0.00632767f, -0.02652700f, -0.02003623f, -0.05960536f, 0.00111250f, 
    0.04998282f, 0.01321879f, -0.05867728f, -0.00024529f, 0.02908739f, 0.00647157f, -0.02402877f, 0.01886670f, 
    0.02870538f, -0.05227514f, 0.01588926f, -0.04981550f, -0.05701130f, 0.00267024f, -0.01720774f, 0.02848336f, 
    -0.03699545f, 0.03382863f, 0.03926221f, -0.01295836f, -0.02269599f, 0.00931483f, -0.04839239f, 0.05087933f, 
    -0.04753724f, -0.01179751f, -0.01153787f, 0.04840114f, 0.00543345f, -0.02243777f, 0.02858151f, 0.00309116f, 
    -0.03423024f, -0.05810971f, -0.05514961f, 0.03800997f, -0.05075970f, -0.01543088f, -0.01877322f, -0.03222743f, 
    -0.03775588f, -0.01635459f, 0.03877174f, -0.01320686f, 0.04996352f, -0.06019845f, -0.05484335f, -0.03873296f, 
    -0.02471489f, 0.04416276f, 0.02919775f, 0.05098670f, 0.00765351f, -0.06191619f, -0.01441362f, 0.02136843f, 
    -0.03804810f, -0.03726915f, 0.02780052f, 0.02583745f, -0.04945064f, 0.02352127f, -0.03698529f, -0.00121388f, 
    -0.03789524f, 0.00152063f, -0.03743643f, -0.00534595f, -0.04759992f, -0.04237587f, -0.03633287f, 0.02682129f, 
    0.00305048f, -0.01743039f, -0.04891576f, -0.04341944f, 0.03906170f, 0.02712669f, -0.03944367f, -0.05653850f, 
    0.00255337f, -0.02997668f, 0.02379683f, 0.02440703f, 0.01285007f, -0.06048218f, 0.02999839f, -0.01875840f, 
    0.03726841f, -0.04050298f, 0.00411564f, 0.00007849f, -0.01600615f, 0.02611135f, -0.02272775f, -0.02356136f, 
    0.03583322f, 0.01981045f, -0.04650564f, -0.03474582f, -0.05481302f, -0.02752575f, -0.02734285f, 0.00026060f, 
    -0.00558257f, -0.02116182f, 0.01728864f, -0.01945425f, -0.03725687f, 0.02677795f, -0.04451992f, -0.01943193f, 
    0.00340208f, -0.21673125f, -0.00472200f, -0.11250895f, 0.07126713f, -0.04036491f, 0.00579462f, -0.04557562f, 
    0.01572356f, 0.14337483f, 0.12843557f, 0.00961188f, 0.07265954f, -0.01522837f, -0.01448189f, 0.04191114f, 
    0.15887126f, 0.04965371f, 0.09867109f, 0.08118033f, 0.01224621f, 0.07042319f, 0.03017595f, 0.01915303f, 
    -0.02619334f, -0.20993322f, -0.09548419f, -0.15484606f, 0.05339631f, -0.09106293f, 0.03322703f, -0.02924185f, 
    0.07628979f, 0.06806193f, -0.05708896f, -0.06298565f, -0.14190111f, 0.59749693f, 0.05386356f, 0.33709988f, 
    -0.05070126f, 0.19635049f, 0.16237310f, 0.00601497f, -0.02864839f, -0.01084464f, -0.13979182f, 0.07541800f, 
    0.22487819f, 0.01246604f, 0.06734115f, 0.07785501f, 0.14853950f, 0.02274753f, 0.00650676f, 0.11545524f, 
    0.05384343f, -0.03605043f, 0.02215265f, -0.00262839f, -0.05069427f, 0.12461890f, -0.04605493f, 0.17971507f, 
    0.10502934f, -0.13178307f, -0.05870116f, 0.09985369f, 0.09699459f, 0.13168758f, -0.03252567f, 0.03490694f, 
    0.03740594f, -0.03599040f, -0.17175476f, -0.03032481f, 0.03042878f, -0.01411362f, 0.02983700f, 0.04148761f, 
    0.03421124f, 0.12766825f, 0.01168473f, 0.07802229f, -0.21054883f, 0.01722983f, 0.10669108f, 0.02494974f, 
    -0.01272912f, 0.07376646f, 0.03828974f, 0.12606867f, -0.14080843f, 0.01504809f, -0.12223524f, 0.05976928f, 
    0.05379076f, -0.05624950f, -0.01891308f, -0.08006928f, -0.11625250f, -0.08409292f, -0.01456186f, -0.02554467f, 
    -0.07848065f, -0.04325940f, -0.26940152f, 0.01103826f, -0.14278917f, 0.16490950f, 0.03022849f, -0.01250924f, 
    -0.02410783f, 0.26210421f, -0.17261930f, 0.14154452f, 0.21789861f, 0.17099397f, -0.11275550f, -0.12579203f, 
    -0.07062581f, -0.09575073f, -0.10946394f, -0.02272384f, 0.09078591f, 0.28486979f, 0.09609111f, 0.02698449f, 
    -0.00353504f, 0.10285527f, 0.00455637f, 0.11275232f, 0.04898457f, 0.09140058f, 0.02708813f, 0.09766350f, 
    0.16175653f, 0.17768505f, 0.10105634f, -0.16199195f, 0.01268927f, 0.09184935f, 0.14205544f, -0.00565375f, 
    -0.02582634f, -0.27783674f, 0.00277370f, -0.19069935f, 0.08357726f, 0.20015132f, 0.04352135f, 0.01542469f, 
    0.02285112f, -0.01735551f, 0.02699647f, -0.00638403f, -0.28449798f, -0.10743363f, -0.18019415f, 0.00799617f, 
    0.03311133f, 0.01646090f, 0.03265785f, 0.07095696f, -0.09322487f, 0.01904273f, 0.08148763f, 0.15262978f, 
    0.09853730f, 0.03287768f, 0.12914814f, 0.00936106f, 0.09707430f, 0.08956043f, -0.20105529f, -0.15387855f, 
    0.06319734f, 0.00514721f, -0.08298899f, 0.12977995f, -0.18187428f, -0.15089779f, -0.22791690f, 0.00669262f, 
    0.04704221f, 0.02054664f, 0.02810678f, 0.08876684f, 0.04495743f, -0.06408631f, 0.08246247f, -0.02034576f, 
    0.13258789f, 0.19231203f, 0.07622816f, 0.12257221f, 0.06386565f, 0.01443384f, -0.00105743f, 0.09171773f, 
    0.04148071f, 0.02664092f, -0.01517700f, -0.03666620f, -0.02206657f, 0.02880969f, -0.21129224f, -0.11838495f, 
    0.19317260f, 0.11934666f, 0.06247240f, 0.06289443f, -0.06077161f, -0.05361080f, -0.00989537f, 0.02022279f, 
    0.02803616f, -0.03968959f, 0.05610239f, 0.13340312f, 0.03884246f, 0.10960819f, 0.05546246f, 0.13507643f, 
    0.09218275f, 0.07259946f, 0.04007021f, 0.03874122f, 0.05906668f, 0.19094326f, -0.17456296f, -0.17893302f, 
    0.10411547f, -0.08694709f, 0.01085228f, -0.03030393f, 0.14228839f, 0.21576901f, 0.12813671f, -0.08025119f, 
    -0.08690830f, -0.02892846f, -0.13935041f, -0.16733441f, 0.13125069f, -0.03974400f, -0.07146590f, 0.06516605f, 
    0.01553479f, 0.02452308f, 0.05492298f, 0.06605101f, 0.17334768f, 0.10165247f, -0.04075059f, 0.22996376f, 
    0.11565337f, 0.06061146f, -0.06050886f, 0.05829608f, -0.06899714f, 0.05746398f, 0.09138232f, 0.13675223f, 
    0.08324737f, 0.09042155f, -0.02521466f, 0.13167247f, 0.00693007f, 0.05853881f, 0.02918244f, 0.03166553f, 
    -0.11036450f, -0.05082421f, 0.01365156f, 0.05028599f, -0.18172315f, 0.21123961f, -0.28800961f, -0.27781031f, 
    -0.07663953f, -0.00281892f, -0.10935693f, 0.08188515f, -0.06119019f, -0.00012826f, 0.06222373f, -0.01293832f, 
    0.13796687f, 0.26287606f, 0.00049819f, 0.02241304f, -0.00400787f, 0.00840229f, 0.20220992f, 0.10668790f, 
    0.01204025f, -0.04607574f, -0.11415146f, 0.02943306f, -0.21776724f, -0.09779795f, -0.18246037f, -0.08666780f, 
    0.02320596f, -0.01000333f, 0.06744751f, 0.01898356f, 0.01971024f, -0.08655685f, -0.01525754f, 0.07986303f, 
    0.27646211f, 0.19348115f, -0.19106819f, -0.14495233f, -0.11259729f, 0.14142406f, 0.11044899f, 0.22864370f, 
    -0.08478579f, -0.03976564f, -0.11485812f, 0.01585018f, 0.06173687f, 0.51196426f, 0.08395737f, 0.09517156f, 
    -0.05208824f, 0.12122879f, 0.07918786f, 0.01987758f, -0.03360561f, 0.08455882f, -0.04980456f, -0.01128924f, 
    0.16970809f, 0.18324557f, 0.14859778f, 0.26391315f, 0.14640257f, 0.18550217f, 0.18449260f, -0.15773907f, 
    0.11787803f, -0.04201157f, -0.02848154f, -0.07096159f, -0.09931356f, -0.14825703f, -0.09082365f, 0.01391598f, 
    0.03936832f, -0.12196287f, -0.10249496f, 0.04954584f, 0.01584041f, -0.02190223f, -0.03099171f, 0.03954868f, 
    -0.52900714f, -0.03283374f, -0.25881550f, -0.09461730f, -0.02957238f, 0.05685513f, 0.00991874f, 0.06371542f, 
    0.00498315f, 0.01441294f, 0.07776655f, 0.08509199f, 0.25156301f, 0.33452502f, 0.07729211f, -0.02664058f, 
    -0.03622530f, -0.00073453f, -0.05191042f, 0.00403683f, -0.29168376f, -0.16857572f, 0.03321370f, 0.03504657f, 
    0.04037937f, -0.24741812f, 0.08126710f, 0.17496446f, 0.08141903f, 0.09402636f, 0.04225252f, -0.05739322f, 
    -0.01551411f, -0.00284393f, 0.02343364f, 0.00619847f, 0.16514878f, 0.17736645f, 0.22934414f, 0.23346554f, 
    -0.00243604f, -0.04806494f, -0.00940982f, -0.06058840f, -0.05441055f, -0.01747496f, -0.01494031f, -0.02061808f, 
    0.11156054f, -0.08508376f, -0.19734332f, -0.14922737f, 0.00243727f, -0.00161093f, 0.02501625f, -0.14171490f, 
    -0.05990343f, 0.06411038f, 0.10943297f, 0.06895848f, 0.18103871f, 0.14511122f, -0.16086558f, -0.00368322f, 
    0.11164412f, 0.10955181f, -0.01526483f, -0.03484339f, -0.10309959f, 0.06287222f, -0.01505653f, -0.04193131f, 
    0.11293364f, 0.14648849f, 0.17377859f, 0.19449124f, -0.13793965f, 0.04021091f, -0.12373985f, -0.16278996f, 
    -0.02087011f, 0.04477508f, -0.12225522f, -0.09601042f, -0.02450605f, -0.06682529f, 0.08727087f, -0.01967457f, 
    -0.15555148f, -0.00914561f, 0.01857724f, -0.18790816f, 0.04030777f, -0.09862696f, 0.08532301f, -0.03906588f, 
    0.11484975f, -0.06373351f, 0.02642422f, -0.03886921f, -0.00153889f, -0.02993533f, -0.00575434f, 0.03124114f, 
    0.02259740f, 0.10425882f, -0.01027431f, 0.08781394f, -0.09164443f, -0.26910579f, -0.03096241f, -0.19861466f, 
    -0.00177277f, 0.05546419f, 0.04457794f, -0.02868778f, -0.02561872f, 0.09439677f, 0.06431007f, -0.04899303f, 
    0.02691309f, 0.02881259f, 0.19587713f, 0.13732982f, 0.08982055f, -0.09688166f, -0.05200214f, -0.01311226f, 
    0.00758663f, -0.04269762f, 0.20767412f, 0.20316890f, 0.11831962f, 0.08008868f, -0.05707695f, 0.00742208f, 
    0.11118297f, -0.03852712f, 0.02082289f, -0.11304288f, 0.05217749f, -0.06317020f, 0.11986466f, 0.07657871f, 
    -0.05640496f, 0.17415781f, 0.11289087f, -0.03553722f, 0.00369853f, -0.01714254f, -0.03953451f, 0.02425094f, 
    -0.16922672f, 0.04671244f, -0.02171423f, -0.20773008f, -0.04163370f, 0.01736313f, 0.14428522f, 0.14106025f, 
    0.05501436f, 0.04236429f, 0.05807136f, -0.01455858f, 0.01753033f, 0.14498733f, 0.01949749f, 0.22859159f, 
    0.15927653f, 0.12751490f, 0.33604729f, 0.01995102f, -0.15669428f, 0.08125443f, -0.08373970f, 0.03572028f, 
    0.00560690f, -0.08851455f, 0.01487449f, -0.09379228f, -0.17525104f, -0.10123595f, -0.05243606f, -0.18375476f, 
    -0.18479720f, -0.02365686f, -0.10456835f, -0.00749327f, -0.10035442f, -0.01148442f, 0.06581304f, 0.10106526f, 
    -0.18680537f, 0.01452065f, 0.11541650f, -0.08911829f, 0.07991752f, -0.01112679f, 0.01298154f, 0.02019583f, 
    0.02152528f, 0.06346498f, -0.03577046f, 0.22596833f, -0.11981515f, -0.08157090f, -0.15157579f, -0.10351969f, 
    -0.09230631f, -0.02890529f, 0.13707925f, 0.00989824f, 0.03147037f, 0.04266452f, 0.01334654f, 0.13574901f, 
    0.14261487f, 0.14778903f, 0.03505672f, 0.13904047f, 0.00782181f, 0.01823391f, -0.02108257f, 0.02656149f, 
    -0.00809318f, -0.04595312f, -0.07700126f, -0.08300991f, -0.05712897f, -0.05632504f, 0.09550274f, -0.02668069f, 
    -0.09538380f, -0.17086108f, -0.02293926f, 0.08832098f, -0.00785370f, -0.03615057f, -0.02017621f, -0.02873200f, 
    -0.06929091f, 0.04323217f, -0.01423020f, 0.00769513f, -0.06666276f, 0.06442963f, 0.03890490f, 0.05770395f, 
    0.10098335f, 0.03051532f, -0.03265545f, -0.13704383f, 0.06042285f, 0.12266996f, 0.12925535f, -0.03964129f, 
    0.00540094f, 0.14139688f, -0.07020782f, 0.07725567f, -0.16686088f, 0.11108568f, -0.04438781f, -0.18278167f, 
    -0.16245052f, -0.19195649f, 0.34525859f, 0.02101432f, -0.05139980f, -0.07057863f, -0.13079752f, -0.07346351f, 
    -0.07901089f, 0.01272926f, 0.04480473f, -0.08578710f, 0.37687019f, 0.03023139f, 0.20628443f, 0.10363568f, 
    0.09326969f, 0.06792369f, -0.05781642f, 0.03079495f, 0.00015480f, 0.00595595f, -0.03908708f, 0.13474798f, 
    -0.08861065f, -0.19682154f, -0.03823682f, -0.04300028f, -0.00262574f, 0.06262967f, -0.12053289f, -0.04417570f, 
    -0.00485505f, -0.06621701f, 0.00302155f, 0.21996066f, -0.54734105f, -0.10350066f, -0.08589970f, 0.14562514f, 
    -0.11545355f, 0.03315380f, 0.03054446f, -0.09832428f, 0.00257097f, -0.03316593f, -0.05860246f, 0.04393106f, 
    0.02511918f, -0.13519402f, 0.03814026f, 0.12729347f, 0.04255976f, 0.02217951f, -0.01799357f, -0.04472693f, 
    0.02959733f, -0.01505970f, 0.03691584f, 0.04908425f, -0.02929493f, 0.05588320f, -0.09773818f, -0.22718909f, 
    -0.06161936f, -0.04529878f, 0.02402529f, -0.01645488f, -0.10354070f, 0.01624921f, -0.22311342f, -0.25795522f, 
    0.12656999f, 0.07266866f, 0.14364120f, 0.27260616f, -0.02196066f, 0.09852420f, 0.08750222f, 0.03675316f, 
    0.14091231f, 0.14405780f, -0.01432906f, 0.05884497f, 0.23628689f, 0.05688276f, 0.12830752f, 0.07428661f, 
    -0.07821748f, 0.03660281f, 0.02632845f, 0.15895975f, -0.03179318f, -0.09632474f, -0.07405646f, -0.09013258f, 
    0.30040821f, 0.18787149f, 0.22465755f, 0.06861501f, 0.01274415f, -0.03135123f, 0.11883815f, -0.00110230f, 
    -0.00925696f, -0.14005598f, 0.05980512f, 0.01570026f, 0.03995229f, 0.15844236f, 0.03958840f, 0.21329461f, 
    -0.13459013f, -0.06767980f, 0.06232794f, -0.03886343f, 0.03474896f, 0.01393389f, -0.04437159f, 0.13779436f, 
    0.09085111f, 0.03380270f, -0.43654466f, -0.09936825f, 0.01201058f, -0.14706448f, -0.04083035f, -0.12295648f, 
    0.06013994f, 0.03540695f, -0.02754647f, -0.12390538f, 0.07693627f, 0.12711990f, -0.04207077f, -0.00155988f, 
    0.00401334f, -0.02100280f, 0.12094796f, 0.01333446f, -0.04202732f, 0.03384283f, 0.00770876f, 0.12699245f, 
    0.13499928f, -0.18918270f, -0.02928412f, -0.01304000f, -0.00462902f, -0.10686740f, -0.20769286f, -0.03923317f, 
    -0.01914744f, 0.06420220f, -0.00268733f, -0.01903596f, 0.13447756f, 0.11348806f, -0.03439149f, -0.24357153f, 
    -0.01759366f, 0.00214699f, -0.06987657f, 0.02420407f, 0.01592463f, -0.08561925f, -0.03335766f, -0.01709507f, 
    -0.01162499f, -0.28230745f, -0.03164194f, -0.33608562f, 0.05390472f, 0.00263835f, -0.01772076f, -0.06687833f, 
    0.11809433f, 0.01518932f, 0.07833304f, 0.03421101f, 0.19745810f, 0.00103314f, 0.40137348f, 0.40237552f, 
    -0.08541986f, 0.06069649f, -0.01718230f, -0.12328330f, 0.13471487f, -0.04593568f, 0.13233082f, 0.03759294f, 
    -0.07603074f, 0.04272079f, -0.07875768f, -0.09850109f, 0.05768073f, -0.04987573f, 0.01148228f, 0.11138852f, 
    -0.05760338f, -0.02795690f, 0.08581944f, 0.11410708f, -0.16769777f, -0.37934124f, 0.17001535f, -0.12779430f, 
    -0.02210543f, -0.00935229f, -0.02162246f, 0.04261354f, 0.03748655f, 0.04714962f, -0.19706236f, -0.08920293f, 
    -0.06041620f, -0.02528041f, -0.03169828f, 0.14595282f, 0.03218927f, 0.01195947f, -0.00958246f, 0.03072578f, 
    0.26573384f, 0.12285905f, 0.09776570f, 0.22919446f, 0.15445857f, -0.04419317f, 0.23025939f, 0.31480819f, 
    0.05265534f, -0.03690239f, -0.12232213f, 0.00381421f, 0.05841808f, 0.00566863f, 0.10337170f, 0.02451094f, 
    0.04623382f, 0.15523347f, -0.09377903f, 0.07123695f, 0.13156839f, 0.04546352f, 0.15839578f, -0.01159279f, 
    0.24245410f, 0.16966879f, 0.01192572f, 0.09401765f, -0.25296611f, -0.23319542f, -0.03115469f, 0.30250046f, 
    0.06508091f, 0.11386550f, -0.08288164f, 0.00053829f, 0.10522874f, 0.07734831f, 0.05905882f, 0.12407555f, 
    -0.17977980f, -0.16925758f, 0.00869479f, 0.03074708f, 0.08727968f, 0.16664408f, 0.06388430f, 0.03709625f, 
    -0.24595255f, -0.22744736f, -0.21181887f, -0.24325490f, 0.05699919f, -0.15377085f, 0.12524951f, -0.06209774f, 
    -0.06108584f, -0.03510170f, -0.03169948f, 0.05619588f, 0.12092002f, 0.08670260f, 0.26566193f, 0.13501969f, 
    -0.24358162f, 0.05106271f, -0.45045817f, 0.02881803f, 0.23791105f, -0.00941323f, 0.08735587f, 0.08461778f, 
    0.05204103f, -0.13181970f, -0.12277403f, -0.22846279f, 0.04468786f, -0.14507836f, -0.11246001f, 0.20989430f, 
    0.11383805f, 0.10865946f, -0.06625558f, -0.05760781f, 0.14921270f, 0.05788780f, 0.14036830f, 0.20149675f, 
    0.15918493f, 0.32142201f, -0.14005443f, -0.15792908f, 0.00880552f, 0.03688118f, 0.00945641f, 0.12064134f, 
    0.16161531f, 0.19215700f, 0.07669747f, 0.05248562f, 0.08065084f, -0.25467348f, 0.01921974f, 0.06701625f, 
    0.05118370f, -0.09685182f, -0.13095690f, 0.00439827f, 0.21159402f, 0.11423346f, 0.23328730f, 0.17987654f, 
    -0.03961430f, 0.13551146f, -0.03488126f, -0.02755474f, 0.08172363f, -0.09929308f, -0.16624318f, -0.01799048f, 
    -0.07521880f, -0.17563920f, 0.00018356f, -0.06278802f, 0.14633824f, 0.06108145f, -0.00720626f, -0.17789461f, 
    0.12380391f, 0.11441255f, 0.09361065f, 0.00231327f, 0.04461785f, 0.01568414f, -0.00082664f, 0.03398715f, 
    0.30793300f, 0.03755885f, -0.14946663f, 0.03785445f, -0.03439777f, 0.04514419f, 0.00709853f, 0.02509424f, 
    0.03167640f, -0.14458100f, -0.19180273f, -0.06975136f, -0.09747105f, -0.00406486f, -0.14050932f, -0.08096775f, 
    0.01508532f, -0.15893859f, -0.08526128f, -0.06389125f, 0.01120016f, -0.04337670f, -0.11585677f, 0.05429802f, 
    -0.03386028f, 0.06330512f, -0.37414944f, 0.12362228f, 0.01073630f, 0.09151757f, 0.13851148f, -0.00994756f, 
    0.00067204f, -0.16072384f, -0.01733148f, 0.01217721f, -0.36345470f, 0.03445200f, -0.07460579f, 0.06232707f, 
    -0.10947064f, -0.00171540f, -0.03866405f, 0.06227060f, 0.13342275f, -0.00667535f, 0.05078851f, 0.16742867f, 
    0.00887483f, -0.18848513f, 0.14652894f, -0.13873176f, 0.02791769f, 0.03825787f, 0.12468918f, 0.06171215f, 
    0.26292503f, 0.05527912f, 0.07217360f, 0.04828630f, 0.14734767f, 0.09713820f, -0.28073579f, 0.01193160f, 
    0.05019780f, 0.06296457f, -0.04801507f, -0.04606704f, -0.08294503f, -0.13094769f, -0.05271650f, 0.00543135f, 
    -0.05444976f, 0.02635670f, 0.04910363f, -0.03573727f, 0.07370443f, 0.02185399f, -0.07797345f, -0.02168904f, 
    0.12751062f, 0.00671178f, 0.02296583f, 0.08454595f, 0.00638144f, -0.22021417f, -0.10896880f, 0.06237315f, 
    -0.01219953f, 0.09091752f, 0.09002369f, 0.04730452f, -0.09609403f, -0.22999297f, 0.07145955f, 0.04343569f, 
    0.15498024f, 0.19769056f, 0.17827801f, -0.05784803f, -0.00362316f, -0.08372732f, -0.01005397f, -0.06881320f, 
    0.04236684f, 0.01014943f, 0.00195745f, 0.03988282f, 0.03992333f, 0.09043590f, 0.11585156f, -0.09539161f, 
    0.02062150f, -0.03019162f, 0.05209247f, -0.17364509f, 0.07011615f, -0.20892213f, -0.22947496f, -0.28858498f, 
    -0.08879799f, 0.15342864f, 0.08162382f, 0.06257178f, -0.03760938f, -0.06039822f, -0.04363162f, 0.04109273f, 
    0.14433962f, -0.01809741f, 0.00991817f, 0.09573588f, -0.14286530f, -0.40229991f, -0.19872029f, 0.01841159f, 
    0.31649512f, 0.21504205f, -0.02723441f, 0.10707777f, 0.12307903f, 0.10722318f, 0.06472532f, 0.03956375f, 
    -0.28744245f, -0.19205803f, 0.12543385f, 0.38476786f, 0.19385096f, 0.19476697f, -0.07305535f, -0.08739333f, 
    -0.11843118f, -0.22077672f, 0.00422342f, 0.00205663f, -0.06519149f, 0.10912233f, -0.04644923f, 0.05220986f, 
    0.04847454f, 0.13733949f, 0.02930881f, -0.02083209f, 0.14273684f, 0.10192396f, 0.06455494f, 0.23181230f, 
    0.00935354f, 0.03932976f, 0.04124329f, -0.01753387f, -0.04024847f, -0.03976764f, -0.04328655f, -0.04911832f, 
    -0.03087911f, -0.00514063f, 0.03148181f, -0.01760569f, -0.04543091f, -0.01896347f, -0.05093176f, -0.01941914f, 
    0.02184013f, 0.02782907f, 0.03468634f, -0.01228655f, 0.01104020f, -0.02512414f, -0.04348739f, -0.02062433f, 
    0.01253221f, 0.01836564f, -0.04159226f, -0.01226942f, -0.03423164f, -0.02639365f, -0.00405995f, 0.03271963f, 
    -0.03160173f, 0.00504706f, 0.02692100f, -0.02336206f, -0.03155837f, 0.00656195f, 0.01047372f, -0.05522377f, 
    0.02565351f, -0.00859274f, -0.00316611f, 0.00480022f, -0.01095213f, 0.03803328f, 0.01114586f, -0.03727439f, 
    -0.02351402f, -0.02814705f, -0.04897877f, 0.01643116f, 0.03743771f, -0.03798612f, -0.01394885f, -0.03088200f, 
    -0.00066621f, 0.02579305f, -0.01536332f, 0.03784447f, -0.04102536f, 0.01811268f, -0.01111987f, -0.02903927f, 
    0.03647754f, -0.02951282f, 0.02820837f, -0.03966114f, -0.02304100f, 0.03802864f, 0.03360789f, 0.00641044f, 
    -0.01527724f, 0.00005104f, 0.01002289f, 0.02254352f, -0.02701346f, -0.00109866f, 0.01313706f, 0.00759101f, 
    0.00166929f, -0.04095239f, -0.04215455f, 0.00987361f, -0.00856926f, 0.00141296f, 0.03495356f, -0.05160837f, 
    -0.03687682f, -0.03169402f, -0.04748887f, -0.01634111f, -0.02924371f, 0.01928425f, 0.02492176f, -0.05568202f, 
    -0.02509250f, -0.04676234f, 0.03454046f, -0.04175147f, 0.01072860f, -0.04097829f, -0.05813950f, -0.05853140f, 
    0.01599709f, 0.00553631f, 0.03771088f, -0.04202306f, -0.00193034f, -0.03236690f, -0.03312768f, 0.00707037f, 
    -0.01693757f, -0.04958574f, -0.01615844f, 0.02539914f, 0.02016210f, -0.05740213f, 0.03835085f, 0.04050259f, 
    -0.01543059f, 0.01171576f, -0.02305721f, -0.00985088f, 0.01751580f, -0.00764469f, 0.01208869f, 0.01825408f, 
    -0.00286354f, -0.00504910f, -0.04172715f, 0.01075851f, -0.03340108f, 0.03405005f, 0.01275398f, -0.04870002f, 
    -0.03016380f, 0.03466822f, -0.01354443f, -0.03010574f, -0.01331557f, -0.02588957f, 0.02684645f, 0.01614182f, 
    0.00778967f, -0.00635850f, -0.04465355f, 0.02221164f, -0.02259493f, -0.03689744f, 0.03578339f, 0.00600782f, 
    0.00267206f, -0.02850745f, 0.01799812f, -0.02541083f, -0.02703545f, -0.03107823f, 0.00673369f, 0.02893794f, 
    -0.03295769f, -0.04791805f, -0.05979317f, 0.02477252f, -0.02630806f, 0.03073770f, -0.00962009f, -0.00959691f, 
    0.01916971f, -0.04477003f, 0.03550404f, 0.00154467f, -0.03369086f, 0.02283449f, 0.03617273f, -0.01686823f, 
    -0.00747428f, -0.04764156f, -0.03460850f, 0.00486856f, -0.02060964f, 0.02671142f, 0.02671280f, -0.05557921f, 
    0.01132915f, -0.02992516f, 0.01477452f, 0.01205600f, -0.02854528f, -0.04944557f, -0.02404503f, -0.03717742f, 
    -0.01915860f, -0.01043596f, -0.02587629f, 0.03964045f, -0.00887911f, -0.04040933f, 0.03635985f, 0.01315860f, 
    -0.00051642f, -0.01174075f, -0.00213100f, -0.05453708f, 0.03859177f, -0.04363617f, -0.05252852f, -0.05906424f, 
    -0.01015945f, -0.03118610f, 0.01704541f, -0.01146447f, -0.03231265f, 0.03080381f, 0.02634489f, 0.00300461f, 
    -0.00235619f, -0.03165025f, -0.01856516f, 0.04216806f, -0.00240486f, -0.04857757f, -0.02838928f, -0.00191475f, 
    -0.04022273f, 0.02852841f, -0.00089714f, -0.04328546f, -0.01617367f, -0.01829920f, -0.03076245f, -0.01867647f, 
    0.01852159f, 0.02468535f, -0.05113380f, 0.01323931f, 0.00958672f, -0.00443748f, -0.04750916f, 0.01836052f, 
    0.00086581f, 0.01363754f, -0.02125635f, -0.01679632f, -0.03791855f, -0.01389788f, -0.02923487f, -0.01024029f, 
    -0.03229842f, -0.03127150f, 0.00527003f, 0.02333181f, -0.05622400f, 0.02532465f, -0.01302534f, 0.02374603f, 
    -0.00293391f, -0.03581445f, -0.00973642f, 0.02195922f, 0.01817878f, -0.00068477f, 0.00015199f, -0.05617143f, 
    -0.04627478f, -0.01144239f, -0.02909053f, -0.03159976f, -0.04809521f, 0.01769508f, -0.02285678f, -0.01322661f, 
    -0.00783440f, -0.03229713f, -0.00445024f, 0.00364382f, -0.05440247f, -0.05000417f, 0.01629420f, -0.02368805f, 
    0.04005976f, 0.01941931f, 0.01936725f, 0.02946475f, -0.03754491f, -0.00650567f, -0.00837090f, -0.03904760f, 
    -0.00591412f, -0.00512473f, -0.01881271f, -0.02710390f, -0.01210989f, 0.00894022f, 0.00849628f, 0.04035056f, 
    -0.04358363f, 0.02073729f, -0.04658499f, -0.02254107f, -0.05269086f, 0.03946863f, 0.02736051f, -0.04009434f, 
    -0.01727785f, 0.04176269f, 0.03727188f, 0.01496754f, -0.02124969f, 0.01888817f, -0.02551568f, -0.04465465f, 
    0.02427658f, -0.02665391f, -0.01029878f, 0.02319934f, 0.04154608f, 0.00158094f, 0.00661387f, -0.02263029f, 
    0.04217751f, 0.00822757f, -0.02228630f, 0.03406932f, 0.01118809f, -0.01970647f, -0.00338607f, -0.00196968f, 
    0.03176211f, -0.04007137f, -0.00136394f, -0.03656454f, 0.02008712f, -0.03471775f, -0.02821412f, 0.01580297f, 
    -0.01230892f, -0.04166926f, 0.02553199f, -0.03600259f, -0.03135871f, -0.01042877f, 0.02249248f, 0.00014115f, 
    0.01025443f, -0.01961610f, -0.00118486f, -0.05044656f, -0.04463710f, -0.05727027f, 0.02884778f, -0.00269848f, 
    0.02031292f, 0.03637805f, 0.01959442f, 0.03246705f, 0.00123856f, -0.05833257f, -0.03278855f, 0.03119794f, 
    -0.02791519f, -0.02528851f, -0.03089198f, 0.01592732f, 0.00422748f, -0.01532299f, -0.04612613f, -0.02507322f, 
    -0.04625435f, -0.04231283f, 0.03066163f, 0.02517507f, -0.04095422f, 0.01406418f, -0.04638387f, 0.01130805f, 
    0.01519910f, 0.04696328f, -0.01754224f, -0.00387299f, 0.02930188f, -0.02291238f, 0.04301808f, 0.03648042f, 
    -0.23323075f, 0.58829129f, -0.06855950f, -0.12229670f, 0.09612808f, -0.08528722f, -0.00182544f, 0.08266255f, 
    -0.27714145f, -0.00079444f, 0.00560970f, -0.01243508f, -0.16733812f, -0.25426763f, 0.00830212f, 0.02405510f, 
    -0.00844179f, -0.00419493f, -0.05915467f, -0.00294832f, -0.04108578f, -0.10821903f, -0.12480661f, -0.04814546f, 
    -0.28332031f, 0.13320868f, -0.09702529f, -0.10035691f, -0.10433858f, -0.02022598f, 0.17258903f, 0.06046515f, 
    0.07747514f, 0.12939413f, 0.08396063f, -0.01308040f, 0.02626599f, -0.16974726f, 0.20034330f, 0.07024731f, 
    0.17893955f, -0.06977361f, -0.01242628f, 0.17794895f, -0.02150043f, 0.02830166f, 0.07713374f, 0.12054101f, 
    -0.08090129f, -0.09626408f, -0.06845660f, -0.03529112f, -0.08776179f, -0.02101950f, 0.07372486f, 0.05274966f, 
    -0.00756127f, -0.11903738f, 0.07419729f, 0.00115634f, -0.18840359f, 0.43244570f, -0.31907448f, 0.27560544f, 
    0.27033296f, 0.08546896f, -0.11950665f, 0.04832831f, -0.00437995f, 0.04492873f, -0.01629639f, -0.07328168f, 
    -0.02101373f, 0.09997424f, 0.00105428f, 0.06857147f, -0.05210096f, 0.16597269f, 0.01705109f, -0.09669767f, 
    0.17750873f, 0.07760248f, 0.01971544f, 0.11923022f, -0.17099129f, 0.35664722f, -0.27360821f, 0.10733160f, 
    0.11037158f, 0.05367939f, -0.09228992f, 0.05638373f, -0.04071268f, -0.08553017f, 0.06729288f, 0.05082250f, 
    -0.06782609f, -0.06051970f, 0.05570322f, -0.02878810f, 0.01346302f, 0.21370973f, -0.00779938f, 0.03080137f, 
    0.14116989f, 0.06279337f, 0.02860045f, 0.13642021f, 0.06192780f, -0.10872580f, -0.07743159f, -0.02327798f, 
    -0.13141419f, 0.08890555f, 0.06374640f, -0.00401540f, 0.18374892f, 0.28146964f, -0.03195331f, 0.04112799f, 
    0.16312519f, -0.08539498f, -0.09479247f, 0.04189540f, 0.05338818f, 0.06394033f, -0.11294567f, 0.04500100f, 
    0.06439642f, -0.11396636f, 0.05752784f, -0.17300054f, -0.16071729f, 0.19895770f, -0.02935968f, 0.04233764f, 
    0.04984833f, -0.03499148f, 0.04477557f, 0.07109389f, 0.01445307f, 0.01264557f, 0.09408221f, 0.03701478f, 
    -0.16330993f, -0.12867244f, 0.21118012f, -0.11988852f, 0.05253606f, 0.07618484f, 0.06079002f, -0.00607015f, 
    -0.03157864f, -0.07082061f, 0.09508809f, -0.03578580f, -0.01854237f, -0.10061946f, -0.13213046f, 0.08272394f, 
    -0.04301990f, 0.10777675f, 0.04178348f, -0.09713838f, 0.17145441f, 0.05407153f, 0.03295613f, -0.03597240f, 
    0.01300794f, 0.25318867f, -0.06334405f, 0.19364728f, -0.10712505f, -0.03211143f, 0.10211382f, 0.00315816f, 
    0.10320402f, 0.22913074f, 0.04597842f, 0.10978793f, -0.11116828f, 0.06870497f, -0.13913703f, -0.11236351f, 
    0.02542844f, 0.14861634f, 0.04286053f, 0.12816794f, 0.06935577f, 0.13337989f, 0.08379416f, 0.09741148f, 
    -0.06730501f, -0.00104451f, 0.03593589f, 0.01784112f, 0.07870371f, -0.04640234f, -0.14184847f, -0.01270432f, 
    -0.00286304f, 0.01283321f, 0.09287693f, 0.00813445f, -0.26898128f, -0.14704736f, -0.08796121f, 0.15512122f, 
    -0.03862681f, -0.00855939f, 0.05031427f, -0.02459289f, -0.01561039f, -0.05580295f, -0.01945731f, 0.00246798f, 
    0.08507056f, -0.02512295f, -0.08410155f, -0.01357078f, 0.10696380f, 0.14652656f, 0.01761749f, -0.08445754f, 
    0.06433409f, 0.02504353f, -0.26215097f, -0.12239888f, -0.13213548f, 0.06615792f, 0.08215836f, 0.08122310f, 
    0.06431247f, -0.06468222f, -0.02586746f, 0.04277994f, 0.03092773f, 0.02265542f, 0.02046876f, 0.07150598f, 
    0.02460659f, 0.08988408f, -0.02490886f, -0.06330719f, -0.06111351f, -0.02268811f, 0.06838617f, -0.11652418f, 
    0.12168446f, 0.01787629f, -0.15000790f, -0.05037292f, 0.34945282f, -0.01661842f, 0.06017308f, 0.17424312f, 
    0.05487498f, -0.01054952f, 0.11373275f, 0.06420995f, 0.02800802f, -0.04166038f, -0.02505395f, 0.16749704f, 
    -0.01569391f, 0.25420809f, 0.08282535f, 0.07459625f, 0.05252212f, 0.04805562f, 0.03362719f, 0.07223852f, 
    -0.01030604f, 0.17670342f, 0.17911628f, -0.00495091f, 0.03636684f, -0.09692521f, 0.20030619f, 0.13444187f, 
    -0.05777729f, -0.11664132f, -0.06889539f, -0.02036527f, 0.09092695f, 0.09548940f, 0.03439401f, 0.10659322f, 
    -0.23086935f, -0.01996652f, -0.02271849f, -0.00345261f, 0.04075673f, -0.01223089f, -0.09323122f, 0.01104725f, 
    0.06387836f, 0.02759519f, 0.06256691f, 0.08957368f, -0.16182654f, -0.08471311f, -0.09998573f, -0.10762618f, 
    -0.12043813f, 0.01821526f, -0.08867759f, -0.02044139f, 0.13593112f, -0.02899298f, -0.04472657f, 0.10791801f, 
    -0.15326668f, -0.21219382f, -0.03509711f, 0.03587809f, 0.07057744f, -0.00086451f, 0.11115936f, 0.00141934f, 
    -0.03687567f, 0.02022195f, 0.05130944f, -0.03678914f, -0.03088874f, -0.14975533f, -0.10530895f, -0.02753000f, 
    0.14998837f, -0.04399714f, 0.01171943f, 0.07931508f, -0.03909471f, -0.11949834f, -0.09479249f, -0.24959747f, 
    -0.13939136f, 0.03152168f, 0.07455344f, 0.19324979f, -0.00998780f, 0.02159218f, -0.05613148f, 0.02435840f, 
    0.05810230f, -0.00617199f, 0.13688166f, 0.11394376f, -0.03441000f, -0.13242397f, -0.19608277f, -0.10943999f, 
    0.01216121f, 0.20356682f, -0.03239889f, 0.00268006f, 0.18933822f, 0.04351784f, -0.08000758f, 0.13967972f, 
    0.09051214f, 0.22863190f, -0.10621159f, -0.05968753f, -0.06875113f, 0.07831293f, 0.03035918f, -0.06351987f, 
    -0.06217191f, -0.05150732f, 0.00246126f, 0.03899994f, -0.04974224f, -0.13998057f, -0.06087843f, 0.07099340f, 
    0.00538859f, 0.03414243f, -0.03974657f, 0.02209689f, 0.20260164f, 0.00070366f, 0.08236319f, 0.08119863f, 
    0.03162945f, -0.03636206f, -0.05448018f, 0.01494611f, -0.04959484f, -0.02163863f, -0.02111764f, 0.00067201f, 
    -0.02091846f, 0.01157740f, 0.00381739f, -0.03000854f, 0.00083369f, 0.02151005f, 0.00119128f, -0.03334196f, 
    -0.03870279f, 0.04712981f, -0.03747163f, 0.02653730f, 0.02171480f, 0.03412475f, -0.01117567f, -0.02985426f, 
    -0.04051463f, 0.04267840f, -0.00525712f, -0.04409719f, -0.01295280f, 0.03869271f, -0.05196035f, 0.01867055f, 
    0.02941427f, 0.00729631f, -0.01210251f, 0.01578168f, -0.04838205f, -0.03264070f, 0.01034477f, 0.03250229f, 
    0.01661271f, -0.04978224f, 0.03869457f, -0.00888542f, 0.01098351f, 0.00543161f, 0.01883542f, 0.00804069f, 
    -0.01130316f, 0.00083694f, 0.04073369f, -0.03728677f, -0.03313045f, 0.03364437f, 0.04132722f, -0.04491976f, 
    -0.02957427f, -0.01812889f, -0.05713312f, 0.02552416f, -0.01746020f, -0.01067943f, 0.00629221f, -0.02184461f, 
    -0.03819380f, 0.00130978f, -0.02379179f, 0.01431341f, -0.04500107f, 0.01810856f, -0.02190412f, 0.03474348f, 
    0.00547138f, -0.03969738f, -0.00527508f, -0.02831810f, -0.04084222f, 0.00440147f, 0.01369886f, 0.01939061f, 
    0.00724084f, 0.00027988f, 0.00105044f, -0.04148391f, -0.02206227f, 0.04358800f, 0.02473813f, 0.00049234f, 
    0.02619553f, -0.04803833f, -0.03577891f, 0.01283472f, 0.03551992f, 0.00356993f, -0.00078283f, -0.04436222f, 
    -0.01308433f, 0.03396749f, 0.01359926f, 0.03396009f, -0.00653998f, -0.02635099f, 0.00009742f, -0.03054613f, 
    -0.00333225f, -0.03802111f, 0.01864891f, -0.03264048f, -0.04970510f, 0.00333755f, -0.02454556f, -0.04608624f, 
    -0.02166449f, -0.03787462f, 0.04820569f, -0.02589758f, -0.01878448f, 0.00248371f, 0.01838864f, -0.02238161f, 
    -0.05424487f, 0.00327674f, 0.03010592f, -0.02662425f, 0.03854051f, -0.01453386f, 0.00751172f, 0.03982702f, 
    0.02415920f, -0.02288703f, -0.05527513f, 0.01446028f, -0.01420227f, -0.03074787f, -0.01302644f, 0.00565956f, 
    0.03671325f, -0.05292092f, -0.03950867f, -0.02605700f, 0.00057555f, -0.02134725f, -0.03833719f, 0.00943556f, 
    0.01595854f, 0.02971396f, -0.02160094f, -0.03094784f, 0.03345394f, -0.01356182f, 0.03812914f, -0.02438152f, 
    -0.04808337f, -0.00295799f, 0.01855964f, 0.01429600f, 0.03661535f, -0.03457116f, 0.01185689f, -0.02900570f, 
    -0.01450092f, 0.02757295f, 0.03168286f, -0.04475389f, 0.00616019f, 0.00887474f, 0.00236543f, 0.01551163f, 
    -0.05294911f, 0.03722157f, -0.00160006f, 0.03165863f, 0.03426002f, 0.01498431f, -0.00978608f, -0.02076468f, 
    -0.05261012f, 0.00186207f, -0.04311925f, 0.01681110f, -0.04015679f, -0.02410630f, 0.01830199f, 0.03543822f, 
    0.00394382f, -0.02467080f, -0.05165851f, 0.03210296f, -0.02321364f, 0.03804792f, 0.00285523f, 0.02235471f, 
    -0.04998377f, -0.05502846f, -0.00360433f, 0.02381026f, -0.00110590f, 0.03663101f, 0.03757655f, 0.02003916f, 
    -0.03307332f, 0.02077521f, 0.00209733f, -0.00677193f, -0.00583515f, -0.04346717f, -0.03018347f, -0.03848051f, 
    -0.01019479f, -0.02248439f, -0.01204090f, -0.03808950f, -0.05832366f, -0.04362109f, -0.06060244f, 0.01536050f, 
    -0.04559435f, 0.00774257f, -0.03447611f, -0.05011864f, -0.03255467f, -0.02507846f, -0.04667007f, 0.00924147f, 
    0.01351497f, -0.00150523f, 0.01066499f, -0.04937039f, -0.01576984f, 0.01342728f, -0.04650654f, 0.02603230f, 
    0.00807511f, -0.00280921f, -0.00939707f, 0.02920252f, -0.05056503f, -0.04474076f, 0.00030530f, 0.01395853f, 
    0.02503643f, -0.01781278f, -0.01684282f, -0.03052801f, 0.03288710f, 0.03380314f, -0.00582309f, -0.02606469f, 
    0.03056334f, 0.03265455f, 0.01388120f, -0.03245701f, 0.02016217f, -0.01393533f, -0.02659264f, -0.01172023f, 
    0.00330634f, 0.02609875f, 0.04040556f, -0.05081055f, -0.05409273f, 0.01889374f, -0.00910435f, 0.02373167f, 
    0.00563325f, -0.04945886f, -0.04769113f, -0.01632405f, 0.00094209f, 0.00869389f, 0.03277099f, 0.02414174f, 
    -0.02086383f, 0.01444075f, 0.00572213f, -0.02154700f, 0.01476078f, -0.02287020f, -0.00717651f, -0.01152915f, 
    -0.01710401f, -0.05106251f, -0.03774647f, -0.04401507f, -0.02890703f, 0.02011102f, 0.02756418f, -0.05721446f, 
    -0.03889350f, -0.02505967f, -0.00005439f, -0.02025228f, -0.01457347f, -0.05063036f, 0.01018371f, -0.04263134f, 
    -0.01603726f, 0.01887176f, 0.02618438f, -0.04635044f, -0.00005914f, -0.05280517f, 0.03028935f, -0.03869474f, 
    -0.02926791f, -0.04936412f, -0.03393801f, -0.05346523f, -0.04525898f, -0.05808234f, -0.03573573f, -0.02344264f, 
    -0.01801660f, -0.03405981f, -0.00992270f, -0.00870679f, 0.02075997f, -0.05911697f, -0.01768213f, -0.02109127f, 
    0.00622726f, -0.04322932f, 0.01807740f, 0.02647243f, -0.00395944f, 0.02973717f, -0.05505900f, -0.03208309f, 
    0.03602700f, -0.04144068f, -0.00783473f, -0.03473131f, -0.03171201f, -0.00336383f, -0.05463765f, 0.00772903f, 
    -0.03472134f, -0.00222933f, -0.00892300f, -0.03699698f, -0.03746665f, 0.03298047f, -0.05114581f, 0.01889807f, 
    0.01453425f, 0.01816394f, 0.03324350f, -0.01345465f, -0.05022370f, 0.03077992f, 0.01698505f, -0.05860928f, 
    -0.04798425f, 0.02896948f, 0.02010782f, -0.01724919f, -0.04232351f, -0.02823510f, -0.04232981f, -0.01890516f, 
    0.04173815f, 0.04031151f, -0.04187824f, 0.03148444f, -0.04695930f, 0.00296329f, 0.03106185f, 0.02120805f, 
    -0.02947022f, -0.00109071f, -0.05151100f, -0.05615655f, -0.05166577f, -0.02959137f, -0.00220269f, -0.00378482f, 
    0.01100666f, -0.01336570f, -0.01695993f, 0.02423123f, 0.02135114f, 0.02224232f, -0.04780742f, 0.02905229f, 
    -0.20922770f, 0.31268629f, -0.23831891f, -0.23100157f, -0.00283955f, -0.14207377f, -0.07574774f, 0.05139614f, 
    -0.15505259f, 0.10603963f, -0.04589727f, 0.05035375f, -0.10836801f, -0.00361975f, 0.12178224f, 0.10814238f, 
    -0.04645691f, 0.02544071f, -0.01207824f, 0.06246077f, 0.12276127f, -0.12361629f, -0.03474988f, -0.03976137f, 
    -0.48461938f, -0.07820735f, -0.18090568f, -0.16502829f, -0.06490188f, -0.08187019f, 0.11231063f, -0.05373023f, 
    0.08674084f, -0.08066191f, 0.03611315f, -0.05405591f, 0.19541161f, -0.43042374f, 0.26641896f, 0.17686155f, 
    0.02559485f, 0.02086391f, 0.04961110f, 0.10474095f, 0.09463643f, -0.04142704f, 0.17106418f, 0.07300069f, 
    -0.14944279f, -0.10254889f, -0.09010518f, -0.01239660f, 0.00427764f, -0.09290911f, 0.12002464f, 0.07347710f, 
    -0.14688827f, -0.09799366f, 0.12837857f, 0.19055238f, -0.15916479f, 0.05077492f, -0.07706771f, -0.01021387f, 
    0.19060864f, 0.04860051f, -0.07170280f, 0.15741472f, -0.05362067f, 0.04744133f, -0.13373730f, 0.04259265f, 
    -0.10550677f, 0.08242951f, -0.10423808f, 0.07488771f, 0.02394564f, 0.22542678f, 0.09407122f, -0.02832851f, 
    0.22018841f, 0.02514419f, 0.10932922f, 0.00638883f, -0.13816355f, 0.07871858f, -0.23878562f, 0.07852878f, 
    0.01793136f, 0.05084792f, -0.13043891f, -0.00330499f, 0.13216408f, 0.00112812f, 0.09176899f, 0.05485413f, 
    -0.00629971f, 0.16825378f, 0.00296483f, 0.26130098f, 0.08377818f, 0.13860066f, 0.12501432f, -0.04318386f, 
    0.09355254f, 0.09522093f, 0.04910331f, 0.03452150f, 0.10718774f, -0.39160186f, -0.01661953f, 0.28830838f, 
    -0.05533266f, -0.00366752f, 0.03875961f, 0.02214408f, 0.16642411f, 0.09102245f, -0.04015206f, 0.13481034f, 
    0.20230767f, -0.17350923f, -0.01819314f, 0.22359109f, 0.03932716f, -0.05722646f, -0.15581901f, 0.03467340f, 
    -0.04986561f, -0.17707010f, -0.05893951f, -0.12957695f, -0.03412407f, 0.09767973f, -0.08616643f, -0.09824355f, 
    -0.08184320f, -0.02505990f, -0.10784791f, 0.17109083f, 0.03373219f, -0.06881755f, 0.10664794f, 0.03457344f, 
    -0.05972122f, 0.37483719f, -0.44259280f, 0.32313976f, 0.35775948f, 0.05091435f, 0.13372923f, 0.14081112f, 
    -0.01452226f, -0.02133854f, -0.02130464f, -0.11498552f, 0.07011411f, -0.18571131f, -0.10869914f, -0.02571838f, 
    0.05880691f, 0.09433907f, 0.05087521f, -0.09964665f, 0.28914627f, -0.00914605f, 0.00369101f, -0.04654754f, 
    0.01633007f, 0.14534372f, -0.01849345f, 0.05193011f, -0.03538565f, 0.03509104f, 0.03399587f, 0.12724294f, 
    0.00654785f, 0.08986462f, 0.20390397f, -0.07426028f, -0.13508913f, -0.05177329f, -0.10033418f, -0.12233155f, 
    0.00243722f, 0.07917513f, -0.04632027f, 0.04319257f, 0.09285086f, 0.09829587f, 0.08512449f, 0.12427064f, 
    -0.02209190f, 0.01778732f, 0.00292452f, 0.00236633f, 0.08550297f, -0.08927372f, -0.14977548f, -0.12420706f, 
    -0.01539669f, 0.01610526f, 0.16623071f, 0.06711267f, -0.04504832f, 0.08806580f, 0.15284131f, 0.25877154f, 
    0.08548062f, 0.06662893f, -0.00583210f, 0.04581898f, 0.03010107f, 0.02363929f, -0.03737075f, 0.05711363f, 
    0.14098006f, 0.01258419f, 0.04446084f, 0.05420553f, 0.20839879f, 0.06094357f, -0.02323827f, -0.09946837f, 
    0.15006658f, -0.04194802f, -0.26997837f, -0.00590312f, -0.33616415f, -0.10536600f, -0.03808416f, 0.04471156f, 
    -0.06688362f, -0.14115377f, -0.05172098f, -0.07163673f, -0.01410305f, -0.00563743f, 0.05466614f, 0.27577555f, 
    -0.01186099f, 0.09658244f, -0.33469597f, 0.25310504f, -0.03633814f, 0.16201957f, 0.08478894f, -0.06825715f, 
    -0.01176706f, -0.05248737f, 0.03700600f, -0.04258618f, 0.03768321f, -0.13655357f, -0.17423479f, 0.06218978f, 
    -0.10320472f, -0.10174044f, 0.15654998f, 0.10583351f, 0.07342124f, -0.12774847f, 0.04222822f, 0.11483277f, 
    -0.05807295f, 0.05833626f, 0.24908912f, -0.23649313f, 0.09309907f, 0.16484508f, 0.16704029f, 0.02361171f, 
    0.08043511f, 0.01130611f, 0.03435181f, -0.15320303f, 0.42233300f, -0.25294930f, 0.09584832f, 0.13589202f, 
    -0.04594598f, -0.07002626f, -0.17037348f, -0.02632808f, -0.18131961f, 0.11895537f, -0.06793609f, 0.07285632f, 
    -0.33735672f, -0.05555129f, 0.06181655f, -0.05167878f, -0.08701504f, 0.01456319f, -0.13719925f, 0.08788453f, 
    0.02930243f, -0.05127181f, 0.11651961f, 0.15451486f, -0.05010226f, -0.10606695f, -0.03013976f, -0.04260746f, 
    0.03507822f, -0.00402971f, 0.06230852f, -0.01169210f, 0.09288638f, -0.12575121f, 0.07222848f, 0.16551886f, 
    0.01018593f, 0.09695779f, 0.26853687f, 0.20828813f, 0.09619814f, -0.04993883f, 0.08555724f, -0.21434923f, 
    -0.01966836f, -0.07442091f, -0.02850221f, -0.09875774f, 0.09568151f, -0.22493079f, 0.23099981f, 0.23401727f, 
    0.15801044f, -0.04633863f, -0.03645807f, -0.10935136f, 0.03209234f, -0.06760830f, -0.10115735f, -0.20665008f, 
    -0.25096244f, -0.03216871f, -0.21367359f, 0.08635788f, 0.07088551f, -0.03506670f, -0.09679870f, 0.08573353f, 
    0.17111710f, 0.01227861f, -0.02593444f, 0.09973243f, -0.00876086f, -0.14911026f, -0.18024699f, -0.16957486f, 
    0.08217511f, 0.21076694f, -0.01308391f, 0.09342665f, 0.03426537f, 0.07243036f, 0.04442767f, 0.02054801f, 
    -0.03826270f, -0.27724516f, 0.16993025f, -0.09141386f, 0.06859671f, 0.20006481f, -0.03469359f, -0.05232889f, 
    -0.13302276f, -0.10344404f, -0.11557569f, 0.05932717f, -0.11222064f, -0.20229003f, 0.04272452f, 0.29212663f, 
    0.07466374f, 0.01661655f, -0.00106446f, 0.01918361f, 0.29020023f, 0.02408474f, 0.08795913f, 0.16057913f, 
    -0.15031859f, 0.23519641f, -0.16342914f, -0.24647507f, -0.15126963f, -0.03482945f, -0.03979719f, 0.10070832f, 
    0.01500041f, 0.18433660f, 0.07880450f, 0.12293304f, -0.13920750f, -0.02337239f, -0.15128875f, 0.00553019f, 
    0.03803653f, 0.07992746f, 0.18668047f, 0.05132767f, -0.01221301f, 0.01084503f, -0.04136248f, 0.08716153f, 
    -0.31459877f, -0.01530896f, 0.10434660f, 0.02316324f, -0.04735149f, -0.03482316f, -0.01463911f, 0.05594471f, 
    0.03961831f, -0.05686452f, 0.03494982f, -0.00623918f, -0.10673104f, -0.20528208f, 0.08080076f, -0.06702553f, 
    -0.00298121f, 0.06380347f, 0.08895551f, 0.10957724f, 0.03870557f, -0.10745344f, 0.12938692f, 0.01340863f, 
    -0.01245397f, 0.01392086f, 0.05659708f, 0.02461548f, 0.19322714f, -0.00371975f, 0.16356225f, 0.08622036f, 
    -0.08568572f, -0.06112629f, 0.05887736f, 0.09728827f, 0.20667572f, 0.12665306f, -0.11060321f, -0.07344555f, 
    0.06673463f, 0.01014460f, 0.09605498f, 0.03655925f, 0.03405703f, 0.14685458f, -0.04949535f, -0.02634625f, 
    -0.11586437f, 0.04840511f, -0.13065958f, -0.08624278f, 0.03418973f, 0.02130354f, -0.03640941f, -0.05425328f, 
    0.06604462f, -0.15886052f, -0.05719577f, -0.12944134f, 0.00221346f, 0.03371903f, -0.12525292f, -0.09009694f, 
    -0.07600798f, -0.03580377f, -0.04047568f, -0.01976653f, 0.26426396f, 0.04702409f, 0.11110998f, 0.11221601f, 
    -0.01077854f, 0.00706413f, -0.15250997f, 0.10273444f, -0.09247418f, 0.04947917f, 0.09391467f, 0.03587195f, 
    -0.04528378f, -0.01759051f, -0.09122910f, -0.14869751f, -0.08626971f, -0.11417417f, -0.07702094f, -0.11158204f, 
    -0.00772244f, -0.06181589f, 0.03302316f, 0.12098242f, -0.12571594f, 0.05013952f, -0.13395131f, -0.16004515f, 
    0.11261294f, -0.06155754f, 0.03941653f, 0.15750130f, 0.01674997f, -0.03439895f, -0.03092721f, -0.06433578f, 
    0.10771677f, -0.00207118f, 0.09259273f, 0.20532586f, 0.09185424f, -0.03869424f, -0.15085711f, -0.24044740f, 
    -0.01007209f, 0.07152780f, -0.05086563f, 0.14538066f, -0.11010263f, -0.08985745f, -0.12239695f, -0.25429335f, 
    -0.19755983f, 0.04928472f, -0.24338965f, 0.24372269f, 0.24192442f, 0.08393552f, 0.04910247f, 0.02353476f, 
    -0.06312195f, 0.03181894f, -0.00972823f, 0.04221494f, 0.04666758f, -0.00437385f, 0.01138831f, -0.04302911f, 
    -0.01413114f, -0.03189111f, 0.02302965f, -0.14109285f, 0.03223123f, -0.02802119f, -0.08833592f, -0.07041352f, 
    0.15543406f, -0.11629449f, -0.17354459f, 0.21142332f, -0.06770499f, -0.00421770f, 0.03389902f, 0.12371428f, 
    -0.07236058f, -0.05610128f, 0.07137846f, -0.03807953f, 0.01207467f, -0.05930696f, -0.09236799f, -0.08761384f, 
    0.00659891f, -0.11367915f, -0.06690403f, -0.08503439f, -0.15794325f, -0.15875933f, 0.00480288f, -0.05714187f, 
    0.01845740f, -0.15107487f, 0.05584668f, -0.09915956f, 0.05769294f, 0.11586807f, 0.05621359f, 0.00447630f, 
    0.02308053f, 0.04061422f, 0.10815141f, 0.08951264f, 0.18334776f, 0.18031329f, 0.01974329f, 0.07020673f, 
    0.17956784f, 0.14328134f, 0.00792504f, -0.04342306f, -0.02038107f, 0.04907544f, -0.00182651f, 0.05122928f, 
    0.01972888f, -0.10846025f, -0.02807736f, -0.07101586f, 0.14895509f, -0.00321136f, 0.12527163f, 0.03465895f, 
    0.00071716f, -0.01132045f, 0.01405693f, 0.08975337f, -0.27212062f, -0.17708200f, -0.16734764f, 0.18345486f, 
    -0.05692115f, -0.07139089f, -0.10311964f, -0.10062291f, 0.21610847f, -0.00246677f, 0.21361314f, 0.21243614f, 
    0.09800940f, 0.23605014f, -0.22038817f, 0.31040111f, 0.04385651f, 0.05928843f, 0.00409875f, 0.03270182f, 
    0.06530242f, 0.03227480f, 0.01500572f, 0.06441657f, -0.08300105f, 0.04316797f, -0.13470797f, 0.08563559f, 
    0.03182530f, 0.02273681f, 0.21687791f, 0.13911441f, 0.04737571f, 0.02651933f, -0.00867360f, -0.01799435f, 
    0.06982330f, 0.16301300f, -0.00922068f, 0.07757606f, -0.09249040f, -0.03674280f, 0.08483361f, -0.02289370f, 
    0.00525957f, 0.01813666f, -0.11143406f, -0.11136757f, 0.54608095f, 0.11027709f, 0.15718228f, -0.00524758f, 
    0.03255048f, -0.00677635f, 0.00464248f, 0.03665734f, -0.05610353f, 0.13045919f, 0.13026722f, -0.03140442f, 
    -0.03527129f, 0.10714357f, -0.06293954f, -0.17027062f, -0.04331938f, -0.04379167f, 0.00483692f, 0.17325130f, 
    -0.08254052f, 0.03450103f, -0.04913063f, -0.02483570f, -0.03789381f, -0.05359679f, 0.16755237f, 0.09203018f, 
    -0.03331301f, 0.06395994f, -0.04167717f, 0.05347510f, 0.08768947f, 0.02768200f, 0.18053934f, 0.15864432f, 
    0.06547470f, 0.06099935f, 0.02805278f, -0.07455224f, 0.16594812f, -0.01021255f, -0.05151198f, 0.02464686f, 
    -0.13522176f, -0.17481636f, -0.04954337f, -0.13293105f, -0.02779439f, -0.03541025f, 0.10378993f, 0.14748485f, 
    0.00947803f, 0.04390612f, 0.07114042f, -0.07786716f, 0.01199609f, 0.02791707f, 0.02018604f, 0.03724917f, 
    -0.18740460f, -0.16018306f, -0.26317805f, -0.00205300f, 0.02179992f, 0.05429566f, -0.05391139f, 0.14187752f, 
    0.13570723f, 0.19128677f, -0.02163138f, -0.07849487f, -0.17540850f, -0.05123520f, -0.04498391f, -0.09751968f, 
    0.03901733f, -0.01209643f, -0.02377196f, 0.04110121f, -0.12083826f, -0.01022941f, 0.06036637f, -0.16604236f, 
    0.07450003f, -0.15584953f, 0.33346581f, -0.09557598f, -0.09472100f, 0.04299169f, -0.00133799f, 0.01784055f, 
    -0.02234667f, -0.02457049f, -0.02677876f, 0.00645946f, -0.00637947f, -0.05818166f, 0.18193339f, 0.01789163f, 
    0.00385972f, 0.02973486f, -0.02283625f, 0.03117536f, 0.05194622f, -0.13178360f, -0.01607277f, -0.27727294f, 
    0.06088419f, 0.19130595f, 0.28653470f, 0.18283495f, 0.02731845f, 0.04046945f, 0.03454287f, -0.00283592f, 
    -0.04273881f, -0.03586430f, 0.09421517f, 0.10092319f, 0.07194079f, -0.08123355f, -0.07867575f, 0.23786148f, 
    0.03916838f, -0.07178103f, -0.07892393f, -0.02929763f, -0.05634252f, 0.03897505f, 0.02634665f, -0.00358962f, 
    0.14760152f, 0.10142016f, -0.01295179f, 0.15525946f, -0.07356491f, -0.08485445f, -0.08270180f, 0.02727073f, 
    -0.09732343f, 0.12323777f, -0.03253536f, 0.12594400f, 0.02651211f, 0.26290500f, -0.35046566f, -0.34973821f, 
    0.18202794f, 0.04596178f, -0.04699935f, -0.01919366f, -0.03041518f, 0.09204850f, -0.04999847f, -0.05207842f, 
    0.13985012f, -0.06772486f, 0.02067214f, 0.17813312f, -0.00519843f, 0.17467506f, -0.01762927f, -0.04552319f, 
    0.01037407f, -0.01928866f, -0.13130708f, -0.07742903f, -0.07364969f, 0.26011801f, -0.05662251f, 0.14381483f, 
    0.03275480f, 0.14386943f, -0.07104713f, -0.04734110f, 0.04017004f, 0.01215001f, 0.08986058f, 0.03169044f, 
    0.19474569f, 0.04445006f, 0.16215424f, -0.10906849f, -0.00876251f, -0.00689146f, 0.00947372f, -0.05809398f, 
    -0.18262617f, 0.07226203f, 0.00586029f, -0.04194609f, 0.07472353f, 0.27187988f, 0.01255075f, -0.33825356f, 
    -0.02177595f, 0.08333615f, 0.05895489f, -0.05326089f, -0.07301444f, 0.02463708f, 0.01253025f, -0.02036051f, 
    0.05147237f, -0.12844066f, 0.02486119f, -0.08036179f, 0.01568658f, -0.04074900f, -0.02074336f, 0.13281475f, 
    0.00180340f, 0.01853474f, 0.13936067f, 0.15669198f, 0.07749721f, 0.17328541f, -0.10505981f, -0.19749756f, 
    0.13191648f, 0.11439766f, 0.21240503f, -0.01275678f, 0.15402330f, -0.00535501f, 0.12344721f, -0.04733318f, 
    -0.00992222f, 0.03270409f, -0.00131591f, -0.03297814f, 0.01026566f, -0.03119887f, -0.06004589f, -0.05306570f, 
    -0.10363846f, 0.11609539f, 0.01145938f, -0.04088137f, -0.03830743f, 0.03561620f, -0.03726882f, 0.09578677f, 
    -0.00037765f, 0.01733309f, 0.03294894f, -0.01004640f, 0.01472280f, 0.11293265f, -0.07626625f, -0.01907013f, 
    0.10129267f, -0.22548932f, 0.42140624f, -0.15391007f, -0.19482325f, 0.03628172f, -0.00445899f, -0.06644743f, 
    -0.01753554f, -0.03351626f, 0.01746345f, 0.04428121f, -0.05061851f, 0.10737301f, 0.02340896f, -0.15617947f, 
    -0.08612175f, 0.03384533f, -0.09031295f, 0.03018631f, -0.10762446f, 0.01674453f, -0.02513672f, -0.06116822f, 
    -0.17504133f, -0.23784849f, 0.17648123f, 0.12913950f, -0.01202342f, -0.00982362f, 0.18748955f, 0.03209399f, 
    0.05631874f, 0.04190120f, -0.00552117f, 0.16868377f, -0.08268314f, 0.17324170f, 0.06175653f, 0.00137971f, 
    -0.01826737f, -0.01341858f, 0.06556682f, -0.04850984f, 0.01430707f, 0.14862147f, -0.02969717f, 0.12321098f, 
    0.10228558f, -0.07355843f, 0.09168681f, 0.12353144f, 0.00885186f, 0.02397842f, 0.03663123f, 0.16301543f, 
    -0.03918850f, 0.06803568f, -0.00606484f, 0.08620068f, -0.17782682f, -0.09344686f, -0.08290900f, 0.09365210f, 
    -0.10543422f, -0.08111835f, -0.01582588f, 0.07106137f, -0.03357978f, -0.08753352f, 0.02098691f, -0.04421328f, 
    -0.18665421f, -0.06719533f, -0.00160954f, -0.03544335f, -0.02752525f, 0.13110608f, 0.02348784f, -0.01684750f, 
    -0.09198092f, -0.04626512f, 0.00596731f, -0.01190898f, 0.32234204f, 0.18497790f, 0.26572418f, 0.18615350f, 
    -0.01802481f, -0.02506024f, 0.01969103f, 0.03308813f, 0.06661092f, 0.08282222f, 0.13212642f, -0.11962259f, 
    0.10821352f, -0.08841853f, 0.39024061f, -0.13224556f, -0.15393780f, -0.11179458f, -0.06196226f, -0.00089051f, 
    -0.12310883f, 0.04945787f, -0.00784870f, -0.02883272f, 0.46221441f, -0.05680974f, 0.14956401f, 0.07458503f, 
    0.09963749f, 0.06993409f, -0.00277524f, -0.04053960f, -0.14400819f, 0.04099959f, -0.06778909f, -0.00372824f, 
    0.02029573f, 0.16365430f, -0.13210435f, 0.31323120f, -0.06070023f, -0.09219503f, -0.09699692f, 0.05354584f, 
    -0.08883526f, 0.06539778f, -0.06176220f, 0.16465704f, -0.20111649f, 0.14857951f, 0.10258785f, -0.01773085f, 
    -0.04082350f, -0.02530249f, 0.00069533f, -0.10153132f, 0.03582437f, -0.00045733f, 0.02173350f, -0.06422192f, 
    0.21702214f, -0.00439228f, -0.14425179f, 0.06122298f, 0.10792139f, 0.07795358f, 0.11821218f, 0.01577727f, 
    -0.08510695f, 0.03143813f, 0.02527213f, 0.02911252f, -0.04023214f, 0.13662010f, -0.07276410f, -0.09298224f, 
    -0.03997209f, -0.03186834f, -0.01604231f, -0.03899876f, -0.09735614f, 0.06281866f, -0.08610485f, -0.07214750f, 
    -0.11563684f, -0.16102180f, -0.19441421f, 0.05811448f, 0.04159212f, 0.13760492f, 0.01982168f, 0.15156962f, 
    0.00544166f, 0.08310624f, 0.00461893f, 0.09314585f, -0.03655483f, 0.12044652f, -0.06331067f, -0.11253962f, 
    0.05343773f, -0.00572854f, -0.01973078f, 0.23485702f, -0.08285028f, -0.01475188f, 0.05269980f, 0.00000441f, 
    0.21915343f, 0.08325004f, 0.14006564f, -0.10947660f, 0.06028861f, 0.02341326f, 0.03843571f, 0.02330993f, 
    -0.08975013f, 0.02251253f, 0.08642717f, 0.01977197f, 0.06835059f, 0.02965579f, -0.03803384f, 0.07697868f, 
    -0.25732192f, -0.12849954f, 0.11864327f, -0.08317935f, -0.00508113f, 0.03950228f, -0.00570347f, 0.05435872f, 
    0.36733451f, 0.35007671f, -0.37438661f, -0.09192605f, -0.13463968f, -0.09840868f, -0.04000325f, -0.09491491f, 
    -0.00860576f, 0.07184823f, 0.02716329f, -0.08046785f, 0.17143774f, 0.09026968f, 0.08287577f, -0.10660177f, 
    0.02371962f, 0.04463293f, 0.00283745f, 0.05845081f, -0.04335550f, 0.15713283f, -0.01479161f, 0.01879413f, 
    0.16134046f, -0.16069415f, 0.23201393f, 0.30678794f, 0.00353643f, 0.01708957f, 0.01808679f, 0.05723921f, 
    0.08704591f, 0.04071494f, 0.11257076f, 0.17345013f, -0.10023953f, 0.19063373f, 0.07041981f, 0.02386141f, 
    -0.11755935f, -0.11379743f, 0.07503287f, -0.08835751f, -0.05458495f, -0.02973229f, -0.00083100f, -0.00383543f, 
    0.36269411f, 0.11336186f, -0.03504639f, -0.00658712f, -0.03420103f, -0.01342411f, -0.02737263f, 0.04856328f, 
    -0.18588959f, 0.05655704f, 0.08664594f, 0.09491659f, -0.28228495f, 0.04352335f, -0.14983965f, 0.20510434f, 
    -0.15831833f, -0.00445902f, -0.03913040f, 0.11533094f, -0.05091105f, -0.02953532f, 0.10251348f, 0.00030558f, 
    -0.09929899f, 0.02901363f, 0.07708737f, 0.03749161f, 0.03245671f, 0.06812390f, 0.13830984f, -0.03096906f, 
    -0.04627392f, -0.01081712f, 0.01102408f, -0.07249475f, -0.19142003f, -0.02298700f, 0.24427946f, -0.00792342f, 
    -0.01942018f, 0.05115458f, -0.13447025f, 0.08897650f, 0.01405853f, 0.02810960f, 0.06235924f, -0.06903165f, 
    0.06222068f, 0.06932171f, -0.00677648f, 0.02088849f, 0.05074333f, -0.00795373f, -0.06518022f, -0.04282029f, 
    0.02813072f, -0.07696450f, 0.05043411f, -0.09417078f, -0.07609638f, -0.14947984f, 0.30483380f, 0.16190553f, 
    0.08720455f, -0.01764844f, -0.03709134f, -0.02356873f, 0.06377929f, 0.09188252f, 0.09996291f, 0.08549426f, 
    0.17031617f, -0.14528953f, -0.05794368f, -0.06886465f, 0.02279026f, -0.05481218f, 0.09518215f, 0.00566177f, 
    -0.03587846f, 0.02576954f, 0.03336815f, -0.00721009f, -0.16352421f, -0.19472499f, -0.07432072f, 0.03308974f, 
    -0.06470911f, 0.00566856f, 0.05295808f, 0.06362511f, 0.02589936f, 0.03947201f, 0.01320031f, -0.10239762f, 
    -0.09810983f, -0.02924748f, 0.06847209f, -0.02336493f, -0.04634427f, 0.16602585f, 0.14234926f, -0.02857878f, 
    -0.11370243f, -0.05637732f, 0.01945255f, 0.02083523f, -0.27561998f, 0.01902130f, 0.10521903f, -0.16219950f, 
    -0.17240563f, -0.09204358f, -0.08486760f, -0.10057625f, 0.02921916f, 0.11184992f, -0.04351672f, -0.07874075f, 
    0.53218096f, -0.13060603f, -0.07964216f, -0.28567848f, -0.18609795f, 0.05751348f, 0.04510726f, -0.02295729f, 
    -0.01301691f, 0.04663346f, -0.09920048f, 0.03471801f, 0.04060880f, 0.00701522f, 0.04741744f, 0.09496628f, 
    0.02291401f, -0.11589082f, -0.01856014f, 0.09839591f, -0.11370292f, 0.06630258f, -0.00102405f, 0.06268289f, 
    0.34746552f, -0.03970151f, -0.01694788f, -0.14542927f, 0.07549146f, 0.01924486f, 0.17552708f, 0.09377023f, 
    0.16790594f, -0.11789151f, 0.02990226f, -0.04018365f, 0.10966190f, 0.00937852f, 0.03881266f, 0.05697257f, 
    -0.06493210f, -0.03434299f, -0.11078857f, -0.06356695f, -0.00912261f, -0.00332805f, 0.15832315f, 0.01222093f, 
    -0.03735316f, 0.12103924f, 0.21251704f, 0.02846846f, -0.07841079f, 0.00678627f, 0.06503376f, -0.00993468f, 
    -0.03854447f, 0.06688194f, -0.08291070f, -0.08672464f, -0.04954153f, 0.02321130f, 0.14485106f, -0.10229599f, 
    -0.03740283f, 0.03459980f, -0.03278938f, -0.00725529f, 0.02631820f, 0.05068742f, -0.01224740f, 0.07488210f, 
    -0.10537865f, -0.05710675f, -0.00960493f, 0.02082329f, 0.01496774f, -0.00923148f, 0.06486817f, 0.10086148f, 
    -0.07282863f, -0.07301217f, 0.05124015f, -0.05768851f, 0.30209374f, 0.11980849f, 0.09403248f, -0.04953062f, 
    -0.02722268f, -0.03890549f, 0.00765877f, 0.00914299f, -0.03428680f, 0.10388441f, 0.12151855f, -0.00480604f, 
    0.57207882f, -0.04686130f, 0.10306200f, -0.18435459f, 0.01030529f, 0.00984030f, 0.10001230f, 0.07911223f, 
    -0.02727626f, 0.05911161f, -0.04961399f, -0.16008979f, -0.27025983f, 0.16592436f, -0.00113622f, -0.02739171f, 
    -0.08160982f, 0.03256392f, -0.04141735f, 0.05436414f, -0.02507692f, 0.05904769f, 0.08420371f, -0.14543901f, 
    0.09684613f, -0.02006619f, -0.07306781f, -0.04961065f, -0.14640658f, -0.01951235f, -0.02302149f, -0.02270254f, 
    -0.04407427f, -0.16583492f, 0.03221697f, 0.04190597f, -0.00076498f, 0.20316671f, -0.01684600f, 0.16512224f, 
    0.10060480f, 0.04688958f, 0.09345094f, -0.02088523f, 0.01255512f, 0.11740918f, 0.03972077f, 0.05613894f, 
    -0.13253140f, -0.11427531f, 0.19687997f, 0.16311106f, 0.04347120f, 0.02920334f, 0.04005463f, -0.04492960f, 
    -0.00858521f, 0.04235779f, 0.03750149f, 0.04828710f, 0.21218827f, 0.06338730f, 0.03875211f, 0.10436505f, 
    0.07523511f, 0.02209614f, 0.10280053f, 0.05957585f, -0.02723204f, -0.01804663f, 0.00217226f, -0.02418760f, 
    -0.19938938f, 0.00458528f, 0.09340225f, 0.04684157f, -0.08053672f, -0.04562842f, 0.01310052f, -0.08539439f, 
    -0.00790573f, 0.06169859f, 0.04863831f, 0.08651610f, -0.30367404f, 0.18294808f, 0.08863477f, 0.13559946f, 
    0.01779805f, 0.07858375f, -0.06921937f, 0.04406332f, -0.00581157f, -0.04294685f, -0.09282010f, 0.05317055f, 
    -0.01376944f, 0.17986469f, 0.18589592f, -0.06981576f, -0.00744889f, -0.06168576f, 0.05442059f, -0.07290935f, 
    0.07555255f, 0.13916236f, -0.07400293f, 0.00715847f, 0.00065392f, 0.00641814f, -0.05982204f, 0.06817470f, 
    0.08951080f, -0.06198205f, 0.04995491f, -0.08857582f, -0.04180678f, -0.04712913f, -0.03840182f, -0.04865973f, 
    -0.00115523f, -0.07059810f, -0.05608160f, 0.15285146f, -0.04630047f, 0.01917524f, -0.07897528f, -0.02141088f, 
    0.04820257f, 0.01092351f, -0.03067409f, -0.07293692f, -0.06197112f, 0.06395757f, 0.02929405f, -0.02989344f, 
    0.05853723f, 0.05698179f, 0.06959955f, 0.01150984f, -0.05847503f, 0.05068348f, 0.00713724f, 0.05555655f, 
    0.02029277f, -0.00279035f, -0.01067803f, -0.03457704f, -0.02426157f, 0.01269481f, 0.01087817f, 0.01092986f, 
    -0.00841685f, 0.01640239f, 0.03156288f, -0.04918594f, 0.01375624f, 0.02443125f, -0.02995424f, -0.04023406f, 
    0.01713647f, 0.02292150f, 0.01299935f, -0.04208675f, -0.00649215f, -0.00023558f, -0.00508252f, 0.03704954f, 
    0.02869755f, 0.02700100f, 0.02457189f, -0.03164797f, 0.00937254f, -0.02171210f, -0.05154718f, 0.00459350f, 
    0.04473111f, -0.00874595f, -0.01675507f, 0.01787732f, 0.00739271f, 0.01075773f, -0.03112303f, 0.01196604f, 
    0.00027384f, -0.02841719f, -0.00639436f, -0.03350941f, -0.01698782f, -0.02121214f, 0.04360601f, 0.02767554f, 
    0.02731466f, -0.01918452f, -0.03828240f, -0.05594440f, -0.04693687f, -0.03130261f, 0.00669570f, -0.02000591f, 
    -0.01413634f, -0.03794762f, -0.02747452f, -0.04714823f, 0.03081649f, -0.01876779f, -0.02152645f, 0.00690395f, 
    0.00187234f, -0.04909467f, -0.03748073f, 0.01496700f, 0.01862714f, -0.02095336f, -0.05134230f, -0.04295213f, 
    -0.00083229f, 0.04066584f, -0.04667556f, -0.01178476f, -0.03705169f, -0.04551327f, 0.03691893f, -0.01387467f, 
    -0.03061085f, -0.01069347f, -0.01477169f, 0.01349873f, -0.05766940f, -0.00719238f, -0.05898946f, -0.05546823f, 
    -0.02701594f, 0.02356767f, 0.01769256f, -0.00406916f, 0.00479767f, 0.03992924f, 0.00097619f, 0.02463512f, 
    0.01652413f, -0.04598553f, -0.05653342f, 0.03117636f, 0.00249958f, -0.03567404f, -0.00715920f, -0.04724743f, 
    -0.03967518f, -0.02371123f, 0.01670076f, 0.00894327f, 0.01521098f, 0.03724736f, -0.05235044f, 0.02339911f, 
    -0.00549930f, 0.01503770f, -0.01889980f, -0.02800968f, 0.02617531f, -0.02601665f, 0.02418780f, -0.05447188f, 
    0.04627416f, 0.03472782f, -0.05249532f, -0.02370626f, -0.03300228f, -0.04865305f, -0.00565741f, -0.01016345f, 
    -0.03609179f, 0.00403233f, -0.05554998f, -0.05019282f, -0.05050661f, 0.02444278f, -0.00369426f, -0.00353961f, 
    0.00085734f, 0.03303607f, -0.04461285f, 0.04349529f, -0.04988099f, 0.01452185f, -0.05289506f, -0.02468695f, 
    0.04721992f, 0.01705974f, 0.04402227f, -0.03078519f, -0.03500504f, -0.00159073f, 0.02889029f, -0.00459242f, 
    0.04433242f, 0.04408911f, 0.00391722f, 0.01769104f, -0.04613834f, -0.00357861f, -0.02406756f, 0.03198180f, 
    -0.02920057f, -0.04080186f, -0.05812596f, 0.01557716f, 0.03301690f, 0.03644144f, 0.01719764f, 0.00876751f, 
    -0.04272077f, 0.01515721f, -0.01384906f, -0.01249550f, 0.04408562f, 0.02323336f, -0.02251382f, -0.04270354f, 
    0.02141391f, -0.00347054f, -0.01071700f, 0.02946946f, -0.04764619f, -0.04468647f, -0.02290993f, 0.03322950f, 
    0.03874053f, -0.00550108f, 0.01815769f, -0.01638856f, -0.02656174f, 0.01813939f, 0.01394278f, 0.03389379f, 
    -0.00604025f, -0.04363851f, -0.01008609f, -0.03803834f, -0.04124044f, 0.00398751f, 0.02872490f, -0.02075887f, 
    0.02324150f, -0.02893109f, 0.02077497f, -0.03915971f, 0.00055494f, -0.03964181f, -0.00632033f, -0.05433681f, 
    0.02956387f, -0.03949834f, -0.01451082f, -0.05207685f, -0.05161462f, -0.03824192f, 0.02918023f, -0.05222455f, 
    0.03885490f, -0.04339761f, -0.04900312f, -0.04371611f, 0.02739851f, -0.03265316f, -0.03608571f, 0.01119571f, 
    -0.03257606f, 0.01872543f, -0.00856797f, 0.01728874f, 0.01801374f, -0.05547809f, -0.03937356f, 0.01355730f, 
    -0.03024269f, -0.04751050f, 0.02677001f, 0.02532190f, -0.03874262f, -0.04425386f, 0.00800545f, 0.04259857f, 
    0.01663240f, -0.04083601f, 0.04468675f, 0.00894559f, 0.01352097f, -0.00181506f, -0.04796661f, -0.00612972f, 
    0.01505695f, -0.00114708f, 0.04264548f, 0.04522456f, 0.02209393f, -0.05029171f, 0.00798255f, -0.02176902f, 
    -0.04325004f, -0.03505496f, -0.02625546f, -0.03853637f, 0.02832843f, 0.03238964f, 0.01512604f, 0.02577826f, 
    -0.00473525f, 0.01313469f, -0.02089699f, -0.02701886f, -0.01074148f, -0.04948119f, 0.02602779f, 0.03463065f, 
    -0.03573854f, 0.00777335f, -0.03425430f, -0.04938005f, -0.04345437f, -0.03383930f, 0.01563502f, 0.00687153f, 
    0.00927371f, -0.01483565f, -0.02744796f, 0.03472542f, 0.02491328f, -0.04129661f, 0.00221261f, -0.02719276f, 
    0.01679825f, -0.02163300f, -0.05209986f, -0.05345821f, 0.03401145f, 0.04137671f, -0.00090489f, -0.01918812f, 
    -0.00936395f, 0.04480465f, 0.00558908f, 0.03459188f, 0.01290325f, -0.02243820f, -0.01828885f, 0.04633103f, 
    -0.01762931f, -0.02626949f, 0.04634041f, 0.04107846f, 0.04345994f, 0.01901772f, 0.00123672f, 0.03057300f, 
    0.00420077f, -0.02771400f, -0.05710744f, -0.03598301f, -0.00091902f, -0.04543030f, -0.04258856f, -0.04199479f, 
    -0.04129281f, -0.04079005f, 0.03013712f, -0.01894261f, 0.02676104f, -0.03840441f, -0.00556044f, -0.04689481f, 
    -0.02508315f, 0.01225795f, 0.04710647f, 0.02561053f, 0.01343535f, 0.04646425f, 0.00193187f, -0.01778203f, 
    -0.01647284f, -0.03216718f, -0.01080036f, 0.01631506f, 0.00844003f, -0.01170748f, 0.03350901f, -0.03607267f, 
    -0.05251748f, -0.03009269f, -0.03948602f, 0.00559381f, -0.05267132f, 0.03130151f, 0.02793123f, -0.01921489f, 
    -0.05739526f, -0.03582307f, -0.02402674f, -0.00740425f, -0.05328037f, -0.02604205f, 0.02982242f, -0.02487189f, 
    -0.01874068f, 0.04110888f, -0.03721854f, 0.03748933f, 0.00540221f, -0.04938128f, 0.01424965f, -0.03897844f, 
    -0.00292584f, -0.01660967f, 0.00852124f, 0.03712452f, 0.00494270f, 0.02132920f, -0.01231946f, 0.02720738f, 
    0.02546482f, 0.03997246f, 0.01770506f, 0.01091092f, -0.00883137f, 0.00813476f, -0.01949444f, -0.05862284f, 
    0.00250194f, 0.20794587f, -0.00022957f, 0.11160104f, 0.01100986f, -0.11766137f, 0.09159978f, 0.00846751f, 
    -0.12501316f, 0.04216998f, 0.07019210f, 0.03045356f, -0.08955792f, -0.02656914f, 0.12575138f, 0.06642531f, 
    0.07027522f, 0.05796239f, 0.10952044f, -0.07008953f, 0.07956283f, 0.06088365f, -0.01778745f, 0.00205722f, 
    0.08970637f, -0.04362466f, -0.08602801f, 0.05386917f, -0.03715947f, -0.02885405f, 0.05679465f, 0.04387548f, 
    0.19177243f, -0.01285566f, 0.00732025f, -0.01048922f, -0.22105159f, -0.10502413f, -0.02630395f, -0.19442822f, 
    -0.02195747f, -0.00323860f, -0.00400564f, 0.13733752f, -0.03277256f, -0.01414516f, 0.10451405f, 0.13148975f, 
    0.04083018f, 0.00327646f, 0.01117755f, 0.08370189f, 0.02517737f, -0.02785132f, 0.00736917f, 0.00119380f, 
    -0.02807832f, -0.03863912f, -0.03639159f, 0.03801839f, 0.15985470f, 0.30233255f, -0.24754997f, 0.21344592f, 
    0.03772413f, -0.05929212f, 0.06239560f, -0.01949206f, 0.11757990f, -0.00835269f, -0.06550333f, 0.02518636f, 
    0.07170675f, 0.02512884f, -0.08761153f, -0.03894053f, 0.02937684f, 0.02910456f, -0.02056602f, -0.05113440f, 
    -0.17663001f, -0.06167626f, -0.04377322f, -0.16924934f, -0.16591722f, 0.03214093f, 0.07324380f, -0.05112357f, 
    0.03301879f, 0.02904817f, -0.03899876f, 0.06141263f, -0.08021985f, -0.01139276f, 0.01219583f, 0.06061007f, 
    0.11564273f, -0.16394368f, 0.06246900f, -0.07433391f, 0.04148126f, 0.17317843f, 0.00052638f, 0.17519529f, 
    -0.03134026f, -0.01870573f, -0.00243058f, -0.03490330f, -0.03342994f, 0.02464957f, 0.03755593f, 0.05300828f, 
    -0.12275078f, -0.07805269f, -0.14287570f, 0.23568359f, 0.14755684f, 0.07840516f, 0.03468492f, -0.03823210f, 
    0.03751823f, 0.09457985f, 0.04529329f, -0.01424724f, 0.01577289f, 0.03667936f, -0.04614595f, -0.01373517f, 
    -0.04592956f, 0.05940159f, -0.01738672f, 0.03453479f, -0.14576888f, 0.11623620f, -0.18455252f, -0.11794847f, 
    -0.01725601f, -0.00401965f, 0.11194382f, -0.03837131f, -0.02522355f, -0.11959773f, -0.11330321f, -0.16539547f, 
    0.28485817f, -0.08682500f, 0.18542223f, -0.15052165f, -0.02029146f, 0.09974951f, -0.04479907f, -0.06311511f, 
    0.00418979f, -0.06876969f, 0.07802280f, 0.01634305f, 0.01672585f, -0.09323933f, -0.06518580f, 0.10454638f, 
    0.03729572f, -0.09993716f, -0.00429611f, -0.00376849f, -0.01017920f, 0.11032148f, 0.04398111f, -0.04901053f, 
    0.28511700f, -0.01378731f, -0.18389112f, 0.11596572f, 0.04405589f, -0.02716336f, -0.12026054f, 0.04499280f, 
    0.07315373f, -0.07993892f, 0.02244054f, 0.00474215f, 0.06662653f, -0.06085314f, -0.02754413f, -0.02206555f, 
    -0.06788898f, -0.02263357f, -0.04362820f, 0.07245672f, -0.08555403f, -0.05503702f, 0.04301663f, -0.03527061f, 
    -0.05114173f, 0.05036313f, -0.06274926f, 0.07378986f, 0.04766364f, 0.03889267f, 0.07935934f, 0.01562281f, 
    0.07844635f, 0.22664021f, 0.02232073f, 0.07355610f, -0.14522974f, -0.01213153f, 0.08156308f, 0.22445787f, 
    0.04239887f, 0.00538056f, -0.00861640f, -0.15246195f, -0.03195442f, -0.03115184f, 0.00483755f, 0.07800312f, 
    -0.01186773f, -0.13331045f, -0.03825822f, -0.07931899f, 0.06571352f, 0.02216569f, 0.01177333f, 0.17788875f, 
    -0.16710544f, -0.03766156f, -0.09337198f, -0.08531163f, 0.00034783f, 0.08420208f, -0.04629519f, 0.04192188f, 
    0.06083564f, -0.06602313f, 0.08068817f, -0.07135311f, 0.12051090f, 0.09004351f, 0.07746496f, 0.14988607f, 
    0.28642365f, -0.04636656f, 0.11958472f, -0.02999778f, 0.06478567f, -0.04561700f, -0.05216836f, 0.05509279f, 
    -0.02514923f, 0.05900731f, -0.01279082f, -0.04759968f, 0.17300077f, 0.00444256f, -0.01128271f, 0.11788539f, 
    0.06275770f, 0.04279013f, -0.02072779f, 0.07036242f, -0.00773299f, -0.11399856f, 0.01927891f, 0.03999994f, 
    0.07894751f, 0.26494616f, -0.08612783f, 0.04373541f, -0.10114370f, 0.13326032f, -0.08793126f, -0.05534364f, 
    -0.09363146f, 0.02938870f, -0.00029877f, -0.03835878f, 0.07480299f, -0.06090559f, 0.18415135f, -0.03640081f, 
    0.06020203f, -0.01591045f, -0.07636110f, -0.01992849f, 0.03366718f, 0.01848354f, 0.10278679f, 0.02662487f, 
    -0.13839161f, 0.18019690f, 0.06229139f, 0.05022074f, -0.10791638f, -0.12060491f, 0.07105540f, 0.01764777f, 
    0.03483067f, 0.05821846f, 0.04199106f, 0.05881359f, 0.04312347f, -0.02007270f, -0.12512262f, 0.10898580f, 
    -0.00585363f, -0.10619198f, 0.00874680f, -0.04160200f, 0.02265275f, 0.03790568f, -0.01576432f, 0.11904888f, 
    -0.01110497f, -0.06681810f, 0.02909814f, -0.05802437f, -0.05282695f, 0.05319916f, 0.06309196f, 0.06203356f, 
    0.03321576f, 0.04504855f, 0.02337317f, -0.01250136f, -0.01053439f, -0.19287038f, -0.05592459f, 0.02821155f, 
    0.01323118f, 0.20528077f, 0.02533138f, -0.06945541f, 0.04200137f, 0.02236218f, 0.04482460f, -0.00752213f, 
    -0.25526515f, -0.13188328f, 0.07994406f, 0.01206680f, 0.01590514f, 0.12951188f, 0.07998125f, -0.07971515f, 
    0.03614185f, 0.10559282f, 0.02192352f, 0.02488775f, -0.04545096f, 0.01010747f, -0.03410265f, 0.07894746f, 
    0.02896237f, -0.08950082f, -0.05646214f, 0.00777917f, 0.04223919f, -0.04511908f, 0.01370231f, 0.02312081f, 
    -0.01093153f, 0.12422476f, 0.18253668f, 0.09293202f, -0.02743540f, 0.03070257f, -0.07670537f, -0.02062467f, 
    -0.07389082f, 0.00188974f, 0.04598596f, 0.07213470f, 0.02826494f, 0.00837506f, 0.04252424f, -0.00155925f, 
    -0.01220435f, -0.04884029f, 0.00236872f, 0.06726106f, 0.09329177f, 0.01973114f, -0.00018671f, -0.09983940f, 
    0.23080999f, 0.29024944f, 0.07918218f, 0.02504768f, -0.07225392f, 0.06443295f, 0.04723218f, -0.00468336f, 
    0.06926893f, 0.12326436f, 0.08905239f, 0.09750517f, 0.02843508f, -0.02508849f, -0.02267434f, 0.01659486f, 
    0.17926212f, 0.15370664f, 0.14251149f, 0.22300470f, -0.00811565f, 0.00027448f, -0.02179458f, 0.06476155f, 
    -0.12428464f, -0.07981565f, 0.18660423f, -0.02655097f, -0.12346459f, -0.08209103f, -0.02484576f, -0.03911276f, 
    0.26189643f, -0.13896544f, 0.01431821f, -0.07022746f, 0.35931760f, -0.12867312f, 0.11557364f, -0.43191269f, 
    0.15610901f, 0.02044893f, 0.12534755f, 0.09548471f, 0.01461786f, -0.12973267f, -0.04480852f, 0.06979710f, 
    0.06393762f, 0.00878070f, 0.02050671f, 0.00134575f, 0.22142434f, -0.01629546f, 0.01810322f, 0.20831412f, 
    -0.03882552f, -0.05122500f, 0.03671499f, 0.10050821f, 0.44020861f, 0.16846575f, -0.37252426f, -0.13051458f, 
    0.05404488f, -0.06341642f, 0.02153971f, 0.01319136f, 0.01666447f, 0.12678283f, 0.03486389f, 0.06968333f, 
    0.07050013f, -0.01870244f, 0.07355350f, -0.06264825f, 0.01815048f, 0.01130799f, -0.00116206f, -0.00767078f, 
    -0.06223337f, -0.08568225f, -0.12123451f, -0.15277374f, 0.28252703f, 0.22156194f, -0.08748695f, -0.03913466f, 
    -0.03087025f, -0.06838826f, -0.04497056f, -0.10492848f, 0.16890173f, 0.11593901f, 0.05117740f, 0.06729931f, 
    -0.09521081f, 0.03488408f, -0.09972224f, 0.14273615f, -0.09846389f, 0.12712881f, 0.14668101f, 0.04871473f, 
    0.00916126f, 0.05241284f, 0.04532880f, -0.13480477f, 0.02871304f, 0.06160311f, 0.05487274f, -0.10971071f, 
    0.14432207f, -0.06154905f, 0.01432695f, 0.05474959f, -0.07814166f, 0.03654965f, -0.05588359f, -0.16824327f, 
    -0.00807912f, 0.07832471f, -0.05228338f, 0.11042704f, 0.05214673f, -0.01663705f, -0.15973748f, -0.15119345f, 
    0.09240197f, 0.00061195f, 0.11133182f, 0.22914658f, 0.18949318f, -0.10070552f, -0.36456412f, -0.10659523f, 
    0.04718529f, 0.01229227f, -0.01147263f, 0.22567642f, -0.04070445f, -0.09969138f, -0.19052657f, -0.06660095f, 
    -0.36801383f, 0.21328427f, -0.34938636f, 0.31554145f, 0.15178327f, -0.01147831f, 0.00698836f, 0.05631758f, 
    -0.03502377f, 0.01324709f, 0.00112997f, 0.08411416f, 0.02730626f, 0.00966128f, 0.07497972f, -0.03072756f, 
    -0.01469204f, -0.04412979f, 0.00347622f, -0.16080283f, 0.10227771f, 0.07605468f, -0.06516255f, 0.02607402f, 
    -0.17639893f, -0.22471756f, -0.07994285f, 0.05707448f, -0.04467641f, 0.01819007f, 0.08374302f, 0.08576251f, 
    -0.14785756f, -0.07884800f, -0.04251892f, 0.01324499f, 0.07652370f, 0.10897642f, 0.08561631f, -0.03841376f, 
    0.00785918f, -0.04555510f, -0.06288978f, -0.07122155f, -0.04416580f, -0.09473323f, -0.06705322f, -0.05740234f, 
    0.05361525f, -0.11253610f, -0.14987715f, 0.02022211f, 0.11542394f, 0.23248062f, 0.24644841f, 0.07504022f, 
    0.04589267f, 0.10480420f, 0.09978653f, 0.22146726f, 0.16471995f, 0.26925054f, -0.03191147f, 0.19738077f, 
    0.20001374f, 0.13175280f, -0.00916733f, 0.06521131f, 0.00435288f, -0.00154942f, -0.01921697f, 0.06741529f, 
    -0.05835317f, -0.06934232f, -0.02815881f, -0.10626037f, 0.10793728f, 0.03441507f, -0.07144401f, 0.15905870f, 
    -0.03530521f, 0.02030202f, 0.04073229f, 0.10050035f, 0.16913438f, -0.11166304f, -0.05095968f, 0.10475308f, 
    -0.06792741f, 0.08138087f, -0.04364871f, -0.03014508f, 0.29845074f, 0.11024922f, 0.21613261f, 0.17561281f, 
    -0.15377869f, 0.13495770f, 0.01948092f, 0.29313824f, 0.00566506f, 0.04745414f, -0.09205637f, -0.02198760f, 
    0.11450435f, -0.10585558f, 0.07050627f, 0.15518811f, 0.07691339f, 0.02972357f, -0.23050992f, -0.19229257f, 
    0.08792833f, 0.00922956f, 0.08620279f, 0.08762954f, -0.04362023f, -0.00862306f, -0.08712922f, 0.03098857f, 
    0.12990087f, 0.26315823f, -0.06657575f, 0.13617921f, -0.03274129f, -0.18637294f, 0.12287762f, -0.02494931f, 
    -0.08300593f, -0.00555757f, -0.00809573f, 0.04583489f, 0.19531626f, -0.10754482f, 0.08221117f, -0.20064929f, 
    -0.13850851f, 0.07374476f, -0.11530292f, -0.08396965f, -0.01665309f, 0.02966771f, 0.05313068f, 0.08308830f, 
    0.21255440f, 0.38619250f, -0.05487186f, -0.17159317f, 0.10700967f, 0.00493150f, 0.08727193f, 0.26708424f, 
    -0.03511874f, 0.06005892f, 0.00410966f, 0.09228025f, -0.06924266f, -0.03106144f, 0.09750679f, -0.07108764f, 
    -0.04475585f, -0.08581125f, -0.21073934f, -0.10249349f, -0.01233157f, 0.07975156f, 0.17553878f, 0.10156215f, 
    0.17781758f, 0.06107291f, -0.07449621f, -0.00426353f, 0.24027254f, 0.11531936f, 0.04837856f, 0.15973696f, 
    -0.01558563f, -0.06423668f, 0.00944434f, -0.09360939f, 0.25870940f, 0.11249188f, -0.02510096f, 0.09518765f, 
    -0.01535867f, 0.12806779f, 0.22138998f, -0.15583141f, 0.02497139f, 0.15398456f, 0.13349202f, 0.10171964f, 
    -0.01190827f, -0.23306862f, -0.42256886f, -0.18084553f, 0.06131784f, 0.05161193f, -0.07700130f, 0.16398588f, 
    -0.01616223f, 0.10522009f, -0.02388800f, -0.07935855f, -0.11268196f, 0.03037506f, 0.16700439f, -0.13550949f, 
    0.14672320f, 0.08597068f, -0.01329191f, -0.04889985f, -0.05197712f, 0.10682247f, 0.02506869f, -0.05283715f, 
    0.12907277f, -0.02070277f, 0.28691107f, -0.04090365f, -0.12457593f, -0.09108218f, -0.06431337f, -0.06878296f, 
    -0.09541441f, 0.01513354f, -0.00629424f, 0.04568167f, 0.13735114f, 0.15670235f, 0.19967964f, 0.07485141f, 
    0.10277538f, 0.06509836f, -0.01258159f, 0.04016831f, 0.05232218f, 0.01387829f, -0.01457936f, -0.28565228f, 
    0.41646308f, -0.51513535f, 0.28102762f, 0.20240474f, -0.01229481f, 0.11700626f, -0.08795261f, 0.09210856f, 
    0.08760224f, 0.09043894f, 0.06279843f, -0.00900973f, 0.17814335f, 0.16760184f, 0.13915738f, -0.12496704f, 
    -0.08165218f, -0.07669052f, 0.00389186f, 0.11538664f, -0.03529890f, -0.04151050f, 0.06190239f, 0.00251625f, 
    0.25140265f, -0.03051002f, 0.05582216f, -0.12313363f, 0.15976839f, -0.01604577f, -0.08797468f, -0.04634944f, 
    -0.09595016f, 0.10222154f, 0.03063667f, 0.07687108f, 0.07228822f, 0.19657755f, 0.14651754f, 0.39392114f, 
    -0.15301944f, 0.03481642f, -0.09741163f, -0.21928158f, 0.04963294f, -0.10978195f, -0.09255733f, 0.05089139f, 
    0.01076128f, 0.06296984f, 0.02306359f, -0.06008468f, -0.03150279f, 0.08948603f, -0.07470487f, 0.02373268f, 
    0.01498789f, 0.02278404f, -0.01442549f, -0.00734603f, -0.31572101f, -0.25076881f, 0.30183694f, -0.09784138f, 
    0.00071204f, -0.01741323f, 0.00977190f, 0.01131477f, -0.01350463f, 0.00863085f, 0.07503346f, -0.03633151f, 
    0.01899817f, -0.03286527f, 0.17487337f, 0.10175033f, -0.02989322f, -0.01388076f, -0.05711613f, 0.03427082f, 
    0.06378416f, 0.05134919f, 0.07516414f, 0.01317379f, 0.13816330f, -0.06295115f, 0.39394000f, 0.28557581f, 
    -0.02954563f, -0.01389241f, 0.00739118f, -0.03591194f, -0.02030392f, 0.05775025f, 0.07992078f, 0.00811621f, 
    -0.01298851f, 0.11680828f, -0.18757690f, 0.01249029f, 0.09265054f, -0.09200668f, 0.07378363f, -0.07551815f, 
    0.03282575f, 0.04480766f, -0.06389604f, -0.02136621f, -0.15347721f, -0.02521001f, -0.00733874f, 0.04970334f, 
    0.02909613f, 0.02537913f, -0.07376916f, -0.05388587f, -0.08461256f, -0.09586224f, 0.14781418f, 0.09163621f, 
    -0.13091964f, -0.12481646f, 0.11742474f, 0.04296499f, 0.06023536f, 0.11448474f, 0.22668591f, 0.09134982f, 
    -0.06837169f, -0.07399209f, -0.13213742f, -0.00602863f, -0.01757377f, 0.04551255f, 0.21655102f, 0.06470035f, 
    -0.11292847f, -0.11139031f, -0.15659170f, -0.11352892f, 0.23330958f, 0.17856868f, 0.08088554f, 0.14871602f, 
    0.02588484f, 0.16657186f, -0.38074353f, -0.14230080f, 0.00978281f, 0.00810339f, 0.22782160f, -0.00129339f, 
    0.02661312f, -0.00816548f, -0.02731053f, 0.00370161f, 0.00734609f, -0.05481912f, 0.10704613f, 0.06051294f, 
    -0.03485278f, 0.01041176f, -0.00046709f, 0.03844136f, 0.03881435f, -0.00445571f, 0.03294194f, 0.01612831f, 
    0.18795153f, 0.18954624f, 0.17335916f, -0.29450554f, -0.00608486f, 0.05191424f, -0.03745090f, 0.00599351f, 
    0.11664172f, -0.02812067f, 0.01350288f, -0.03815069f, 0.12035825f, -0.08433962f, 0.15032877f, 0.10024226f, 
    0.02005898f, -0.00613509f, -0.14010540f, 0.02899916f, 0.10646933f, 0.00181550f, 0.15538247f, 0.01307831f, 
    0.05648739f, 0.14179711f, 0.09783373f, -0.03276066f, 0.00258977f, -0.00511679f, 0.04931372f, 0.02521300f, 
    -0.02065427f, -0.07549511f, -0.01592423f, -0.04459148f, 0.09783478f, 0.07788013f, -0.01464117f, -0.15577626f, 
    0.03499510f, 0.02416523f, -0.03254485f, 0.08984274f, 0.03483012f, 0.02171519f, 0.04589288f, -0.07521509f, 
    0.07964941f, 0.14091954f, 0.03587020f, -0.01015314f, -0.12970829f, -0.00389825f, 0.02380551f, 0.04440164f, 
    0.04935713f, -0.00823800f, 0.08963456f, 0.02758580f, 0.27067107f, 0.10802902f, 0.00208467f, -0.27102277f, 
    0.05696765f, 0.05894360f, -0.02944385f, 0.02002838f, -0.03766857f, 0.05836269f, -0.04326891f, -0.15041301f, 
    0.02828502f, 0.15845278f, -0.13816805f, -0.15237896f, 0.01700168f, -0.02497091f, 0.18246330f, 0.05048393f, 
    0.08915823f, -0.08411247f, -0.06021660f, -0.03722073f, -0.19190711f, 0.17985913f, 0.04586098f, -0.10776221f, 
    0.00898573f, -0.13303506f, -0.08420961f, -0.05538424f, 0.02639501f, 0.05421919f, 0.04276098f, 0.00691563f, 
    0.03102775f, -0.21736656f, 0.06101830f, -0.13388184f, 0.07822476f, -0.05824801f, 0.05837892f, 0.08045851f, 
    0.11731613f, -0.10545287f, -0.06766921f, -0.03589805f, -0.12232098f, 0.31559175f, -0.38901612f, -0.18509838f, 
    -0.15511370f, 0.10023642f, 0.13298245f, 0.04287730f, 0.00802752f, -0.05309206f, -0.05154903f, -0.03448434f, 
    -0.03840132f, -0.04508429f, 0.18968944f, 0.04098039f, 0.03009260f, 0.13295512f, -0.06395743f, -0.08096689f, 
    0.05908026f, 0.00139295f, -0.09933854f, -0.01324142f, 0.11413577f, 0.04563563f, -0.09320973f, 0.00345213f, 
    0.03823285f, 0.04348773f, 0.08593129f, 0.10387459f, 0.01036459f, -0.02447415f, -0.04488378f, -0.08465783f, 
    0.07379135f, 0.18786052f, 0.13471864f, 0.09399965f, -0.06473958f, -0.01986791f, -0.09524129f, 0.02191949f, 
    0.08587074f, -0.05916706f, 0.09412801f, 0.04211729f, -0.16115046f, 0.25553033f, 0.07054268f, 0.01116392f, 
    -0.05936875f, -0.05683370f, 0.04655654f, -0.03333089f, 0.03457678f, -0.00294946f, -0.00335499f, 0.00692450f, 
    0.06381980f, 0.24885321f, 0.23009901f, -0.03336749f, -0.12399320f, -0.19625349f, -0.10496493f, -0.13690899f, 
    0.11309588f, -0.01676587f, -0.01438051f, 0.01828939f, 0.01889954f, -0.15286179f, -0.02126716f, 0.01591127f, 
    0.07135504f, 0.05148532f, 0.07584710f, -0.04455910f, -0.04392303f, -0.02868885f, 0.04263511f, 0.05809150f, 
    -0.24645315f, -0.05944461f, -0.08318337f, 0.27505660f, 0.01292350f, 0.02636473f, 0.04753275f, 0.01416402f, 
    0.05499858f, -0.03610887f, 0.00958623f, -0.02729549f, -0.02896895f, 0.12384683f, -0.03681033f, 0.03937369f, 
    -0.01935461f, 0.14640906f, 0.01233737f, -0.01908209f, -0.10711744f, 0.03177190f, -0.00565400f, 0.05453242f, 
    0.17967822f, 0.16113855f, -0.17820682f, -0.05674342f, -0.01982417f, -0.17071339f, 0.15134409f, -0.02670260f, 
    -0.08474026f, 0.13027567f, 0.03153047f, -0.02768111f, -0.17821448f, -0.01774025f, 0.14942840f, 0.03902674f, 
    -0.02595608f, 0.04582731f, 0.00824506f, -0.06127257f, 0.10333767f, -0.10015059f, -0.11735261f, -0.04377760f, 
    -0.24576494f, 0.02516727f, -0.18156828f, -0.12307943f, -0.08023398f, -0.02013399f, 0.14400512f, 0.03501794f, 
    0.04999769f, 0.07048585f, 0.18361616f, 0.01200177f, -0.06079369f, -0.15435337f, 0.07722653f, -0.03055250f, 
    0.03741435f, 0.10040400f, -0.09390718f, 0.13426800f, 0.02729366f, 0.04639205f, 0.06097523f, -0.00622842f, 
    -0.21523878f, -0.07468991f, 0.01395316f, 0.08639261f, -0.07162470f, -0.17591441f, 0.02195950f, 0.09026419f, 
    -0.05144767f, -0.15410015f, 0.11843550f, 0.03049612f, -0.11802951f, 0.32914659f, -0.04831669f, 0.21410693f, 
    0.02166119f, -0.03601446f, 0.03600974f, -0.06341531f, 0.08074287f, 0.09229044f, -0.00706436f, -0.24578027f, 
    -0.03183934f, 0.11943734f, -0.14518666f, 0.02797139f, 0.00617818f, 0.03354923f, 0.06617560f, -0.04277954f, 
    0.14235878f, 0.04574027f, 0.06343416f, 0.11467021f, 0.10869852f, -0.05061704f, 0.00015579f, -0.06927351f, 
    -0.00880800f, -0.01850732f, 0.02230603f, 0.00427649f, 0.04850408f, 0.06023416f, 0.00737052f, 0.08256405f, 
    -0.00342523f, -0.14824747f, 0.08524098f, 0.13354938f, 0.21568947f, 0.08622248f, -0.01718251f, 0.01320643f, 
    0.24385926f, -0.03353865f, 0.10659733f, 0.19958913f, 0.01208595f, -0.39226916f, -0.01865902f, 0.31263554f, 
    -0.01240823f, 0.05122099f, -0.06321128f, -0.04151799f, 0.15976605f, 0.20925787f, -0.01445862f, 0.18868324f, 
    -0.02669495f, -0.07969089f, 0.10448465f, 0.03163988f, -0.05326669f, 0.00106443f, -0.01021159f, -0.00113960f, 
    -0.13638413f, -0.25972646f, -0.05040797f, -0.16579677f, -0.15804808f, 0.12789999f, 0.11471911f, -0.35136667f, 
    -0.07191300f, 0.00520444f, 0.14855468f, 0.08789008f, 0.02778768f, -0.11326037f, 0.09024768f, 0.04147869f, 
    -0.00196359f, 0.05289450f, 0.00177101f, -0.11103453f, 0.12824596f, 0.01338610f, -0.03863518f, 0.05416172f, 
    0.01253012f, -0.08306043f, 0.03999755f, -0.20964211f, 0.06758179f, -0.17548253f, -0.12899016f, 0.00907392f, 
    -0.03856137f, -0.02090579f, -0.06259380f, -0.09993704f, 0.14922626f, 0.09664224f, 0.08155809f, 0.08747327f, 
    0.35316131f, 0.24871486f, -0.43992954f, 0.32666934f, -0.06498571f, -0.01161017f, 0.03182540f, 0.08571079f, 
    0.05710100f, 0.14470126f, 0.06353221f, 0.14601427f, 0.07689869f, -0.08187269f, -0.12251163f, 0.05000625f, 
    -0.15340419f, -0.00865989f, 0.05489571f, 0.00542210f, 0.13838580f, 0.08380247f, 0.21350120f, 0.10632215f, 
    -0.02874803f, 0.19968045f, 0.08454967f, 0.11599331f, 0.03136251f, -0.10065535f, -0.04605030f, -0.12466650f, 
    -0.00472068f, -0.06114589f, 0.02320323f, -0.08489481f, -0.05586030f, -0.06057126f, 0.06462260f, 0.19953537f, 
    0.12774815f, 0.08702292f, 0.12783217f, -0.05080738f, 0.07597850f, -0.09922305f, -0.07851442f, 0.04392053f, 
    0.29170278f, -0.23775347f, -0.11469885f, 0.03805446f, -0.02470083f, -0.03292472f, -0.08191235f, -0.00510930f, 
    0.03328466f, -0.04572814f, -0.23285587f, -0.14594404f, -0.22810040f, 0.02480135f, 0.00125497f, 0.05210393f, 
    0.06242344f, -0.04321457f, -0.04146288f, 0.07847875f, -0.00519049f, -0.05164734f, 0.00077098f, 0.09332462f, 
    0.16636755f, -0.13233893f, -0.07459285f, 0.01438135f, -0.09800002f, 0.06311561f, -0.03803612f, -0.05040873f, 
    -0.06095550f, -0.06572412f, -0.12031144f, -0.07044317f, 0.07144983f, 0.05614583f, -0.01894958f, 0.31010190f, 
    0.05210876f, 0.00328786f, 0.05482892f, 0.18540065f, 0.09018558f, -0.11759963f, 0.13765775f, 0.19657603f, 
    0.03511488f, 0.10465702f, 0.12209237f, -0.05764361f, -0.02657192f, 0.13396236f, 0.03705283f, 0.01894158f, 
    0.13295543f, -0.00038300f, 0.16062053f, -0.11119421f, 0.01523106f, -0.00436795f, 0.09313253f, 0.00225997f, 
    0.06495874f, -0.02973261f, -0.13248146f, 0.00231894f, 0.08382391f, -0.03635316f, 0.11447589f, 0.04346113f, 
    -0.37743774f, -0.08213531f, 0.11609641f, 0.00936987f, -0.04602625f, -0.04584131f, -0.09830962f, 0.03892194f, 
    -0.00857906f, 0.06376397f, 0.03782665f, 0.07245038f, -0.08820614f, -0.09040616f, 0.00389290f, -0.01994186f, 
    -0.05398025f, 0.02341488f, 0.01977677f, 0.01461670f, 0.02694323f, -0.17305762f, -0.05894682f, 0.11122964f, 
    0.01871632f, -0.01403615f, 0.07784982f, 0.14812510f, 0.12304248f, 0.07958063f, 0.09209616f, -0.17281722f, 
    0.04950486f, -0.04082552f, -0.01000521f, 0.03627387f, 0.04767503f, -0.25884804f, 0.10256348f, 0.00454966f, 
    0.05628578f, 0.22996484f, 0.01381126f, -0.16521226f, 0.01818182f, -0.12889914f, -0.21353938f, -0.22834419f, 
    -0.04517338f, 0.07285435f, 0.30915210f, 0.27028725f, 0.03839089f, -0.04138701f, -0.02767940f, 0.04858111f, 
    0.12996151f, 0.06185933f, -0.06784596f, 0.02092244f, -0.15245767f, -0.25097135f, -0.17507507f, 0.15746176f, 
    0.12754449f, -0.03670288f, -0.12418932f, 0.06875721f, 0.19670817f, 0.00023750f, 0.03388345f, 0.18379258f, 
    -0.06846690f, 0.11599825f, 0.08993741f, 0.19726911f, -0.11115208f, 0.03133055f, -0.20944470f, -0.01653289f, 
    -0.05112337f, -0.06220830f, -0.03038201f, 0.02809967f, -0.09583893f, -0.13455886f, -0.04539565f, 0.13911003f, 
    0.08253528f, -0.01618491f, -0.05145494f, -0.02935084f, 0.14759713f, -0.03854433f, -0.03659385f, 0.18643078f, 
    0.05212525f, -0.08828483f, -0.14732757f, 0.04801967f, -0.02383551f, -0.01532413f, 0.11578254f, -0.03531546f, 
    0.08720583f, 0.05116958f, 0.03838831f, 0.14774756f, -0.31849107f, -0.47653294f, -0.16083260f, -0.14600833f, 
    -0.08880030f, -0.14387250f, -0.21751374f, -0.12807126f, -0.12101334f, -0.10832068f, -0.13596831f, -0.12356343f, 
    0.02737550f, 0.16934298f, 0.12295434f, 0.23193245f, -0.03383895f, 0.02045257f, -0.01228213f, 0.15982194f, 
    0.08290458f, 0.19980063f, 0.14457527f, 0.09154588f, -0.02551639f, -0.06719074f, -0.31937966f, -0.38449234f, 
    0.18042926f, 0.19516379f, -0.03091718f, 0.25678191f, -0.14176498f, 0.01695868f, 0.12698361f, 0.08136483f, 
    -0.19965918f, -0.20934495f, -0.26663387f, -0.12459192f, 0.08716240f, 0.01316533f, 0.05301683f, -0.10740667f, 
    -0.09382804f, -0.06786245f, -0.04509435f, -0.06600642f, 0.39501521f, 0.25458980f, 0.03777511f, 0.02004660f, 
    0.04676291f, 0.07146595f, 0.10011747f, 0.03241908f, 0.07168148f, 0.11765502f, 0.01539886f, -0.01375232f, 
    0.11084333f, 0.03906875f, 0.03403524f, -0.08959151f, -0.06910660f, -0.03697440f, 0.01904722f, 0.01117221f, 
    0.09692473f, 0.02363788f, 0.13798510f, 0.00479174f, 0.08665846f, -0.07196490f, -0.21831745f, -0.14034148f, 
    0.06360330f, 0.11173274f, 0.07725596f, -0.05728898f, -0.00109244f, -0.07832322f, 0.06459309f, 0.03385748f, 
    0.07938618f, -0.09805875f, 0.27864972f, -0.01612389f, 0.19411990f, 0.11738928f, -0.06636482f, 0.06651536f, 
    0.07708100f, -0.03498363f, 0.14202042f, 0.08324262f, 0.01456546f, -0.11369429f, 0.03296342f, -0.04810262f, 
    -0.08662137f, 0.04871032f, 0.29908201f, 0.00228214f, 0.11541753f, 0.03424535f, -0.00032724f, -0.07618343f, 
    0.12745911f, -0.01715994f, 0.04868320f, -0.07398830f, 0.09137069f, 0.02422073f, -0.13319445f, 0.02875005f, 
    -0.10115320f, 0.04194397f, -0.04682988f, -0.06561112f, -0.05487641f, -0.07272875f, -0.24066488f, -0.31712875f, 
    -0.10880922f, -0.13591895f, 0.20934069f, 0.01531900f, -0.05518653f, -0.10885317f, 0.01596467f, 0.04573436f, 
    0.48436970f, 0.22484306f, 0.29698861f, -0.05280360f, 0.02744149f, -0.02712735f, -0.05957595f, 0.05104709f, 
    -0.08425359f, -0.01183491f, -0.04243175f, -0.00188598f, 0.18244375f, 0.18583722f, -0.01167434f, -0.00343998f, 
    -0.00290024f, 0.04795148f, 0.01793195f, 0.02212481f, 0.04811649f, -0.02852441f, 0.08054490f, 0.07237034f, 
    0.08222201f, -0.18171506f, -0.26962599f, 0.24169682f, 0.07917153f, 0.16246939f, 0.11944510f, 0.14851928f, 
    0.04111546f, 0.04401090f, 0.06427486f, 0.11920653f, 0.03967280f, 0.09874650f, 0.01671074f, 0.03469981f, 
    -0.02062308f, -0.02646527f, 0.09066338f, -0.02312157f, 0.16650672f, 0.07460257f, 0.15406045f, 0.10462164f, 
    -0.41437691f, -0.57273966f, -0.26877275f, -0.11352167f, -0.07168241f, 0.03730592f, 0.16439599f, 0.02106540f, 
    -0.08382495f, 0.06766800f, 0.00275836f, -0.02690791f, 0.02709667f, -0.41902795f, -0.17215918f, -0.09868714f, 
    0.00003883f, -0.05612673f, -0.04436754f, -0.12375648f, 0.06466077f, 0.02183082f, 0.00876087f, 0.03014317f, 
    -0.09942085f, -0.15635240f, -0.01104410f, 0.00100040f, 0.08058913f, 0.02616274f, 0.10313428f, 0.09968712f, 
    -0.16479608f, -0.14585331f, -0.13284695f, -0.15144624f, -0.10264503f, 0.02422663f, 0.11747183f, 0.19844082f, 
    0.00630767f, -0.00574315f, 0.02233414f, -0.01175933f, -0.01039066f, 0.14311790f, 0.05783736f, 0.09323296f, 
    0.38889605f, 0.10516285f, 0.41331553f, 0.21623559f, 0.10267746f, 0.03808167f, 0.01777911f, -0.00077078f, 
    -0.10667053f, -0.04942470f, 0.06755555f, -0.11824913f, -0.35313147f, -0.22665523f, -0.02829200f, -0.00283790f, 
    0.04290837f, -0.01177951f, 0.10913020f, -0.01905474f, 0.00691254f, -0.07706736f, -0.06186194f, -0.00787640f, 
    0.17532291f, 0.14875950f, 0.18956251f, 0.16369621f, -0.01143017f, 0.06482332f, 0.04324419f, -0.02543632f, 
    0.03089224f, 0.07151463f, 0.18053102f, 0.07490433f, 0.27118772f, 0.16582946f, 0.31361020f, 0.27937439f, 
    0.18432115f, 0.12535223f, 0.16920194f, -0.03545170f, 0.05044615f, 0.06967528f, 0.02293976f, -0.00312383f, 
    -0.01712194f, -0.53597468f, -0.27562594f, -0.11047735f, -0.02252461f, -0.12880327f, 0.02594131f, -0.00959249f, 
    0.00245987f, 0.05078402f, 0.12182219f, 0.10809523f, 0.15539904f, 0.16739690f, 0.08059523f, 0.12216029f, 
    0.04095239f, -0.01134878f, 0.01851718f, 0.01401064f, 0.05796142f, -0.01194538f, -0.07823397f, 0.01593721f, 
    -0.31730810f, -0.23923779f, -0.10277113f, -0.11040986f, -0.02056611f, -0.03222492f, -0.07753686f, -0.06685241f, 
    0.12040344f, 0.06065373f, 0.11046630f, 0.01464501f, 0.07868043f, -0.37747768f, -0.11867737f, -0.05002092f, 
    0.08733694f, -0.06877361f, -0.05627350f, -0.00392443f, -0.11057635f, -0.03833845f, -0.04674628f, -0.04707593f, 
    -0.26085800f, -0.48467565f, -0.06809269f, -0.21059176f, -0.11305783f, -0.01438753f, 0.09947717f, 0.02417699f, 
    -0.05045900f, 0.13386330f, -0.01692587f, 0.10430411f, 0.03427260f, 0.11414357f, 0.03146192f, 0.11095978f, 
    -0.10946502f, 0.02575698f, 0.02836737f, -0.00981558f, 0.09026885f, -0.03909435f, -0.01933312f, 0.00042277f, 
    0.44235507f, 0.23404218f, 0.09039659f, -0.09964012f, 0.00053199f, -0.07867645f, 0.11471622f, -0.01574282f, 
    -0.14026996f, 0.04618940f, 0.08954592f, 0.02522995f, 0.07548001f, -0.33192217f, -0.03424233f, -0.15186061f, 
    0.11799286f, -0.08326259f, -0.02344131f, 0.07014180f, 0.05030642f, 0.06708986f, 0.12013852f, 0.12458213f, 
    0.07957140f, 0.06814948f, 0.27821058f, 0.08702900f, -0.03167311f, 0.05973360f, 0.06695811f, -0.05542328f, 
    0.02657589f, -0.03660039f, 0.18178082f, 0.03043895f, 0.05763172f, -0.04019619f, -0.03874264f, -0.01551448f, 
    0.07767842f, -0.00315653f, 0.01016991f, 0.07732406f, -0.09783024f, 0.01465606f, -0.03372082f, -0.08531015f, 
    0.12744932f, 0.04755249f, 0.16334453f, 0.05736771f, -0.03825375f, 0.02287284f, -0.08818683f, 0.05261144f, 
    0.10399633f, 0.14634345f, -0.06711348f, 0.05201425f, 0.24067357f, 0.21204281f, -0.00911057f, -0.30767125f, 
    0.14728580f, -0.04719028f, 0.01642397f, -0.00766874f, 0.04552326f, 0.02183865f, 0.02278073f, 0.13110709f, 
    0.19994989f, 0.06462064f, -0.01088225f, 0.02113150f, 0.07818422f, 0.22052880f, -0.03703376f, 0.11375194f, 
    -0.01220265f, -0.05848992f, -0.11175241f, 0.01802120f, 0.27096879f, 0.09592159f, -0.29591992f, 0.01153870f, 
    0.14082521f, -0.02105086f, 0.13541603f, -0.06886399f, 0.08787953f, 0.03111923f, 0.05916614f, 0.09509547f, 
    0.12051622f, 0.01110718f, 0.20796882f, -0.04476669f, -0.12837394f, -0.06895736f, -0.07876331f, -0.01375653f, 
    -0.15840022f, 0.03910132f, -0.11896036f, -0.14280730f, 0.11798357f, 0.13851747f, -0.07385895f, -0.13308874f, 
    -0.02274349f, -0.03510371f, 0.00120471f, -0.08534601f, 0.07415836f, 0.02147176f, 0.09604300f, -0.00622877f, 
    -0.08731721f, 0.00270308f, 0.08544394f, -0.15531842f, -0.09327929f, 0.00828520f, -0.02054880f, 0.13436228f, 
    -0.14409633f, 0.04601092f, 0.02134645f, 0.00639915f, 0.00506815f, 0.15936752f, -0.14919600f, -0.31218189f, 
    0.20933154f, 0.06147337f, 0.05399239f, 0.03566876f, 0.06310664f, -0.06162422f, -0.02398453f, -0.17428775f, 
    0.00713038f, 0.06776025f, -0.13074853f, -0.06604560f, 0.15274177f, -0.02772954f, -0.07030019f, -0.16917816f, 
    0.06964676f, 0.14009173f, 0.01110614f, -0.03065825f, 0.08831596f, -0.09595970f, -0.25610673f, 0.03232538f, 
    0.06233850f, 0.00659308f, 0.11573166f, 0.02775851f, 0.12100451f, -0.07460751f, -0.10794352f, -0.09712453f, 
    -0.05777415f, 0.06261651f, 0.24336416f, -0.02173139f, -0.01510713f, -0.10504287f, 0.02208651f, 0.00256964f, 
    -0.10007161f, 0.01905882f, -0.01631056f, 0.02848303f, -0.01005707f, 0.13070172f, 0.03345136f, -0.06715886f, 
    -0.10305235f, -0.07909062f, -0.02006698f, -0.05383989f, -0.14374463f, -0.10093459f, -0.05370517f, -0.07763969f, 
    -0.16564645f, -0.21183717f, 0.22682694f, 0.02081362f, 0.00236357f, 0.04467543f, 0.12508285f, -0.02774901f, 
    -0.05658337f, 0.04521005f, -0.05630204f, 0.15792379f, -0.03293781f, 0.10829221f, 0.02162484f, -0.00626585f, 
    -0.03423332f, -0.04044738f, -0.00162427f, -0.03906312f, -0.14639907f, 0.00246745f, -0.16873455f, -0.13223419f, 
    -0.04951079f, -0.12341095f, -0.14848202f, 0.05615722f, 0.05630137f, 0.26941377f, 0.22064838f, 0.15320805f, 
    -0.00271572f, 0.03494834f, -0.01574707f, 0.10840340f, 0.07444797f, -0.02381238f, 0.00308592f, 0.05126745f, 
    -0.02090041f, -0.10807641f, -0.03513331f, 0.10061329f, -0.02498593f, -0.08211870f, 0.00046212f, -0.00984816f, 
    -0.18869226f, -0.02929865f, -0.13281171f, -0.12251169f, 0.09217469f, 0.21915559f, 0.11148026f, 0.13071513f, 
    -0.06333406f, -0.00266379f, 0.02907033f, -0.03485858f, 0.26087737f, 0.04696396f, 0.03758694f, 0.04972504f, 
    -0.04945591f, 0.02340302f, 0.00625578f, -0.01837616f, 0.11199261f, 0.19946441f, 0.09116736f, -0.00638785f, 
    -0.09331682f, 0.12460274f, 0.38537246f, -0.03924086f, 0.06636310f, -0.07239751f, -0.14395495f, 0.05294348f, 
    0.02412094f, 0.09585983f, -0.00689204f, 0.07001617f, 0.22002690f, 0.04704988f, 0.13350089f, -0.14860749f, 
    0.09910061f, 0.09131658f, 0.00024273f, 0.00613331f, -0.03014014f, 0.03096225f, -0.02971507f, -0.00598537f, 
    0.18918671f, 0.24438843f, -0.10968166f, 0.36018932f, -0.01775417f, -0.21295001f, -0.07911991f, 0.02764723f, 
    -0.25266442f, 0.02301760f, -0.01528218f, 0.09964442f, 0.03633260f, 0.03499971f, 0.20498532f, -0.05445593f, 
    0.01314370f, 0.00959397f, 0.04389125f, -0.04326539f, 0.09513941f, -0.05442919f, 0.00236952f, 0.02299709f, 
    0.41875511f, 0.14099002f, -0.10514612f, -0.02069766f, 0.07093205f, -0.02201198f, 0.20734571f, 0.18536276f, 
    0.01612283f, -0.05460209f, 0.00012388f, 0.04226096f, 0.00979430f, 0.06931043f, -0.04881608f, -0.07597297f, 
    0.06558824f, -0.05561979f, -0.18030380f, -0.09218024f, -0.06685811f, 0.09357014f, -0.04196814f, -0.03779266f, 
    -0.08261438f, -0.05296208f, -0.23650888f, -0.01815026f, 0.03781053f, 0.20294948f, -0.00251735f, 0.28700608f, 
    0.05676270f, 0.01746674f, -0.03406895f, -0.08576863f, 0.02191426f, -0.06053598f, -0.27631909f, -0.07167326f, 
    0.04899606f, 0.04579339f, 0.12604281f, 0.11770691f, -0.11231426f, 0.02922811f, 0.04174335f, 0.06882265f, 
    0.16069122f, -0.09522037f, -0.17056611f, -0.07918053f, -0.03027130f, 0.15294892f, 0.05144511f, 0.12101003f, 
    -0.03609455f, 0.00787658f, 0.12243092f, 0.01515784f, -0.02461231f, -0.02803790f, -0.00681853f, -0.06921627f, 
    -0.20560916f, -0.00029284f, -0.06263272f, -0.09888016f, 0.00125763f, -0.02124666f, -0.12424456f, -0.10727178f, 
    0.38295263f, 0.28941137f, -0.01285987f, -0.11987385f, -0.06820764f, -0.16002440f, 0.01380009f, -0.08360396f, 
    -0.02220790f, -0.04711181f, 0.01609280f, -0.00584609f, 0.17361027f, 0.05487238f, 0.07277793f, -0.04361788f, 
    0.04673865f, -0.04532745f, 0.08130976f, 0.12082541f, 0.00345331f, 0.10461316f, -0.02536451f, -0.16879055f, 
    0.13275525f, 0.23476388f, -0.20055307f, -0.10602078f, 0.11547302f, -0.10586496f, 0.08353006f, -0.11234673f, 
    -0.14425603f, 0.04613755f, -0.07827231f, 0.03576621f, 0.17869361f, 0.04017086f, 0.07665715f, 0.17255540f, 
    0.10581490f, 0.16515465f, -0.00258061f, 0.06949162f, 0.13864878f, -0.04838694f, -0.05711581f, -0.02167208f, 
    -0.25897542f, -0.01298335f, -0.01586673f, 0.08711599f, 0.12697057f, -0.28536135f, 0.12158564f, -0.19323976f, 
    0.07979567f, -0.07470555f, 0.10492255f, 0.10907472f, 0.16914539f, -0.12761436f, 0.10799088f, -0.29881486f, 
    0.00292358f, 0.05892264f, -0.20587809f, -0.02000333f, 0.14655015f, 0.14318903f, 0.00329297f, -0.04939009f, 
    0.05841116f, -0.07402766f, -0.04648941f, 0.10409549f, 0.07498338f, -0.04685880f, 0.07043155f, 0.05850552f, 
    -0.02009226f, -0.10783590f, 0.00667585f, -0.04432330f, 0.08840830f, 0.25257403f, -0.23310497f, -0.04410119f, 
    0.09955104f, 0.01871788f, 0.07499384f, -0.11262817f, -0.08393640f, 0.05209278f, -0.09357896f, -0.08517133f, 
    0.19536927f, -0.00003529f, -0.01169544f, -0.00464598f, -0.11058252f, 0.11282395f, 0.02267029f, 0.05069480f, 
    0.04923538f, 0.07884549f, 0.05749313f, 0.11852978f, 0.19000033f, 0.11619550f, -0.26814127f, -0.29933512f, 
    -0.22396578f, -0.01719386f, 0.00288629f, -0.07106179f, 0.03836443f, 0.10241352f, -0.04627780f, -0.00584293f, 
    0.08682480f, 0.11784985f, 0.09570702f, 0.32904065f, 0.02242419f, 0.06044548f, 0.01838863f, 0.02049892f, 
    0.24722169f, -0.08503175f, 0.01063424f, 0.11995956f, 0.16334027f, 0.06193677f, 0.10329336f, 0.12576500f, 
    -0.00945769f, 0.23548625f, 0.24513237f, -0.04030113f, 0.12307578f, 0.03380941f, -0.05943210f, 0.19896148f, 
    -0.13144335f, -0.08010298f, 0.02502875f, 0.05076861f, 0.04207344f, -0.09819403f, -0.25295207f, -0.15463667f, 
    -0.28249952f, -0.25142360f, -0.08539879f, -0.36451572f, 0.29955637f, 0.06328828f, -0.25444290f, -0.15055774f, 
    0.02013540f, 0.13135217f, 0.15411584f, 0.10373835f, 0.10487067f, 0.05087494f, 0.21656190f, 0.16481553f, 
    -0.26445863f, 0.38919026f, -0.10191204f, 0.33749270f, 0.26794383f, 0.10684579f, 0.10271543f, 0.10420514f, 
    -0.02122906f, -0.11606442f, 0.01266939f, -0.21829963f, 0.11626114f, -0.17700401f, 0.08516291f, -0.14657539f, 
    -0.24789444f, -0.15009370f, -0.11839382f, -0.14871915f, 0.14437303f, 0.00260376f, 0.00124908f, 0.02738269f, 
    0.04345379f, -0.21775857f, -0.14608622f, 0.34258035f, -0.09835718f, -0.08946326f, 0.06240075f, -0.06376464f, 
    0.02235336f, 0.16235605f, 0.12104243f, 0.16995132f, 0.09689251f, 0.11902234f, 0.03251604f, -0.08206388f, 
    0.05773993f, -0.02646785f, 0.11118553f, 0.02666895f, 0.03773411f, 0.12537275f, 0.12367904f, 0.10046673f, 
    0.02216731f, 0.05348525f, -0.02868718f, 0.10099030f, 0.14368108f, -0.12390226f, 0.12173638f, 0.01460046f, 
    0.05341927f, -0.14762567f, -0.12164424f, -0.15903039f, 0.19352634f, 0.09389281f, 0.16576430f, 0.26994202f, 
    0.18925597f, -0.02454053f, 0.18117067f, 0.21144615f, 0.01933273f, -0.11177566f, -0.07662494f, -0.05406463f, 
    0.09429336f, -0.36457890f, -0.04409720f, -0.24759294f, -0.00826420f, 0.18972020f, -0.15195398f, -0.20890702f, 
    0.16705914f, -0.08421185f, -0.24716818f, -0.23017734f, -0.14864978f, 0.03344273f, -0.09316191f, 0.16752875f, 
    -0.06607677f, -0.11033887f, -0.08144128f, 0.03554482f, -0.04509465f, -0.04204983f, -0.01421051f, -0.00725987f, 
    -0.17249811f, -0.12507628f, -0.02478774f, 0.27189496f, -0.24387072f, 0.05761481f, -0.08722740f, -0.13927925f, 
    -0.11471675f, -0.23510528f, -0.06444986f, -0.10536139f, 0.35480291f, -0.17807573f, -0.04922309f, 0.14303517f, 
    0.00050948f, 0.02012827f, -0.07867680f, -0.04028480f, 0.16050015f, -0.12124603f, 0.10056105f, 0.21684554f, 
    -0.08932306f, -0.00436023f, 0.11682121f, 0.18399870f, 0.24852303f, 0.06955118f, 0.06517111f, -0.07234748f, 
    0.01836894f, -0.04631071f, 0.04004205f, 0.05739880f, -0.03901480f, -0.26025131f, 0.21434462f, -0.08410834f, 
    -0.22204271f, 0.12470256f, -0.25920552f, -0.20244029f, -0.04102043f, -0.07785685f, -0.14044225f, -0.06958473f, 
    0.13921383f, 0.23643979f, -0.07737955f, -0.04284773f, 0.11544592f, 0.10322695f, -0.00041167f, 0.12229446f, 
    -0.00092793f, 0.05844706f, 0.13437177f, 0.08838663f, -0.17690028f, -0.12320644f, -0.08290004f, -0.35059491f, 
    0.01841945f, -0.06095703f, -0.07162575f, -0.20897382f, -0.09503398f, -0.15656830f, -0.14763896f, -0.22972679f, 
    0.32242161f, 0.15272696f, 0.12970872f, 0.18009542f, 0.08263434f, 0.03076077f, 0.09048706f, 0.05889424f, 
    0.10905463f, 0.04624750f, 0.02478725f, 0.01708454f, 0.22191574f, -0.08923850f, 0.25264180f, -0.10507458f, 
    -0.02816459f, 0.05368403f, 0.02314465f, -0.06539112f, -0.18546270f, -0.10834216f, -0.18473721f, -0.27853334f, 
    0.14871074f, -0.13498081f, -0.01647844f, 0.11045967f, 0.08225004f, -0.06030688f, -0.10617195f, 0.04908783f, 
    0.13891818f, 0.01337131f, 0.01172427f, 0.07095320f, -0.04105691f, -0.09610875f, 0.08366249f, 0.04603634f, 
    0.09928583f, -0.03595617f, -0.01375458f, 0.07048138f, 0.13158998f, -0.06341009f, -0.07274341f, 0.08733927f, 
    0.06217351f, 0.06293248f, 0.15272145f, -0.00574309f, -0.19836822f, -0.10158759f, -0.18802531f, -0.08479977f, 
    -0.24355671f, -0.05139389f, -0.02320792f, -0.04839988f, 0.22382316f, 0.08990064f, 0.19353238f, 0.08826598f, 
    0.02524744f, 0.00358703f, -0.00388672f, -0.02450745f, 0.05047702f, 0.03635798f, 0.02659439f, 0.14359091f, 
    -0.13629085f, 0.06043570f, 0.07954121f, 0.07180247f, -0.03557429f, -0.02494373f, -0.07679748f, 0.08576281f, 
    0.02848176f, -0.07787750f, 0.06149909f, 0.06866577f, -0.18077724f, -0.14922673f, -0.04836142f, -0.20808987f, 
    -0.10824150f, -0.03216420f, -0.10655208f, -0.05169290f, -0.09951898f, -0.01237546f, -0.01400063f, -0.08969376f, 
    -0.01783647f, 0.06119532f, 0.18164781f, -0.01973389f, 0.02338225f, 0.02119305f, -0.06168734f, 0.03431512f, 
    -0.05538733f, 0.09648700f, 0.03555525f, 0.14711531f, -0.07160188f, 0.07121101f, 0.29015094f, 0.47984010f, 
    0.04393208f, -0.12316152f, 0.08628625f, -0.01809999f, 0.01587082f, -0.06177540f, 0.09417515f, 0.12136458f, 
    -0.02405566f, 0.07462262f, 0.04580871f, 0.00948477f, -0.06511947f, 0.21885899f, 0.15952906f, 0.19217321f, 
    -0.01564522f, 0.00559686f, -0.08360829f, 0.02735085f, -0.20168397f, -0.00703771f, 0.04031650f, -0.15023044f, 
    0.10730655f, 0.08763693f, 0.08794706f, 0.14033660f, -0.04328603f, 0.11087885f, 0.03412379f, 0.03561869f, 
    -0.00913003f, 0.09104563f, 0.02973239f, 0.09703199f, -0.08638347f, -0.03368236f, 0.03823603f, -0.00534526f, 
    0.17049637f, 0.07393096f, -0.00084225f, 0.12815438f, -0.07711634f, 0.16155855f, -0.07577807f, 0.25667748f, 
    -0.01101040f, -0.04497810f, -0.07456280f, -0.05432982f, 0.10616594f, 0.02482102f, 0.13749750f, 0.03317457f, 
    -0.11156823f, 0.10664231f, -0.02150556f, -0.11562657f, -0.00473519f, -0.04199279f, -0.01796481f, -0.11228599f, 
    0.06106439f, 0.05558435f, -0.02073379f, 0.14687087f, -0.02201723f, -0.06609875f, -0.15492658f, -0.21497232f, 
    0.02088725f, -0.01283807f, 0.14254241f, 0.08004028f, 0.02366526f, -0.02952021f, -0.01198919f, -0.12353385f, 
    0.03791913f, -0.07356176f, -0.06778191f, 0.01218786f, 0.06668087f, 0.01679259f, 0.01913996f, -0.01869634f, 
    0.03091430f, 0.01782754f, 0.14122772f, -0.04092486f, -0.05004662f, -0.07416927f, 0.26070705f, 0.10528253f, 
    0.02533767f, -0.11511619f, -0.07340676f, 0.06808062f, -0.01312802f, 0.00195326f, 0.10938364f, 0.01214233f, 
    -0.06093927f, -0.02318739f, 0.18456078f, -0.01028031f, -0.03011598f, -0.15093940f, -0.10171353f, 0.01316137f, 
    -0.07718266f, -0.04878284f, -0.08932339f, -0.01368655f, -0.04600196f, 0.16176030f, -0.04473905f, 0.14765291f, 
    -0.00226766f, 0.16889480f, 0.06027105f, -0.00730665f, 0.02627413f, -0.11424829f, -0.07970249f, 0.01963371f, 
    -0.16098371f, 0.41521573f, 0.25285915f, -0.16783465f, -0.05011445f, 0.00922413f, 0.15339516f, -0.04451780f, 
    0.09912989f, 0.11111597f, 0.00832097f, 0.05981605f, -0.05415317f, 0.07151943f, -0.02055993f, 0.02981394f, 
    -0.04411126f, -0.06420377f, -0.03528343f, 0.00612043f, 0.11720699f, 0.04298825f, 0.02047740f, 0.05041039f, 
    -0.14157844f, -0.00256855f, 0.24203993f, -0.11620294f, 0.02058459f, 0.10597315f, -0.00328878f, 0.15173388f, 
    -0.02489288f, -0.03931166f, 0.00451607f, -0.01795574f, -0.14368600f, -0.07032012f, -0.22046696f, -0.14440672f, 
    -0.14236246f, -0.14510587f, -0.00282312f, 0.12560289f, 0.02484169f, 0.06102770f, 0.02201851f, -0.06106903f, 
    -0.01913430f, 0.07501568f, 0.02943052f, -0.01483695f, 0.05489936f, 0.09975870f, 0.08557472f, -0.07151360f, 
    0.13757469f, 0.05077408f, 0.09342258f, -0.01387320f, 0.12154897f, 0.09496866f, 0.03282090f, -0.16962142f, 
    -0.03522324f, 0.03966407f, -0.01406802f, -0.05359071f, 0.06271245f, -0.00689949f, -0.03398408f, 0.00164096f, 
    -0.05005440f, 0.26980612f, 0.07622499f, -0.03780111f, 0.05130149f, 0.00781044f, 0.01186207f, 0.00678649f, 
    0.04192866f, -0.05641518f, -0.00881527f, 0.07750205f, -0.06324688f, 0.19971648f, 0.15575342f, -0.04188702f, 
    -0.15397416f, 0.05577110f, 0.18923908f, -0.07461030f, 0.01021945f, 0.01684720f, -0.06385475f, 0.02931015f, 
    0.06007510f, 0.11519312f, 0.06277559f, 0.08555143f, -0.03077549f, -0.19259514f, 0.12570761f, 0.05498825f, 
    -0.05863201f, 0.02873976f, 0.01653784f, 0.15837911f, -0.00067829f, 0.10547391f, 0.08968005f, 0.18204328f, 
    0.05457412f, 0.01097513f, 0.15745367f, 0.04427384f, -0.01659375f, -0.02080473f, -0.06288345f, 0.09218223f, 
    -0.06684959f, -0.16398430f, 0.09183636f, 0.02576047f, -0.06404268f, -0.01041642f, 0.02102172f, 0.05307812f, 
    0.04112337f, -0.07580157f, -0.00469943f, 0.03105512f, 0.02648559f, 0.08918718f, 0.07718484f, 0.03484686f, 
    0.04055068f, 0.11311906f, -0.06173813f, 0.03957513f, 0.00260402f, -0.07542508f, 0.05247873f, 0.04746160f, 
    -0.23384361f, -0.21565984f, -0.11328489f, -0.15692496f, 0.03418876f, -0.05203742f, -0.00355807f, 0.02480116f, 
    -0.04018395f, 0.09559298f, 0.01289115f, -0.02179747f, -0.17492610f, 0.10925470f, -0.20996682f, 0.04389972f, 
    0.17478952f, -0.26827425f, 0.03283230f, 0.07857141f, -0.09601274f, 0.01245799f, -0.00744825f, -0.04537090f, 
    0.13440599f, 0.19412267f, 0.09652282f, 0.06421322f, -0.11889633f, -0.14029521f, -0.01650307f, 0.16338505f, 
    -0.05681004f, -0.06558090f, 0.09233499f, 0.09593908f, -0.01987813f, -0.06151630f, -0.08702221f, -0.15759523f, 
    -0.06811728f, 0.07488216f, -0.02505350f, 0.00288982f, 0.05714027f, 0.08618874f, -0.07399879f, -0.07305360f, 
    0.13562265f, 0.05095004f, -0.08244663f, 0.04695611f, -0.00374450f, -0.04700952f, 0.05084860f, -0.00763621f, 
    -0.04220807f, 0.00011732f, -0.00431268f, -0.14402086f, -0.05864780f, -0.12951270f, -0.04519665f, 0.09461751f, 
    0.02792305f, 0.08220427f, 0.02107959f, 0.07177621f, 0.02095537f, -0.03955470f, 0.18093412f, 0.09286931f, 
    -0.21158500f, 0.05434587f, 0.17999703f, 0.12968053f, -0.04970277f, -0.00223065f, 0.02248514f, 0.08219364f, 
    0.01522516f, 0.07189988f, 0.14162749f, 0.13855042f, -0.21711564f, -0.01868891f, 0.10368351f, 0.09024212f, 
    -0.03765311f, -0.11299475f, 0.08261954f, -0.03912126f, -0.01849486f, -0.07649852f, -0.08559839f, -0.04295855f, 
    0.08641651f, 0.06897227f, -0.10344204f, 0.00940127f, -0.08139164f, 0.09610189f, 0.01651298f, 0.07527446f, 
    -0.02387547f, 0.12623596f, 0.15471724f, 0.17242774f, -0.26372635f, -0.09590030f, -0.25077507f, 0.06435003f, 
    0.03741071f, -0.04250475f, 0.00509367f, 0.01656923f, 0.01214383f, -0.00618947f, 0.08686469f, 0.13413048f, 
    -0.07362124f, -0.02329151f, 0.10626471f, 0.08572702f, 0.04187968f, 0.06313235f, 0.04769769f, -0.06867216f, 
    -0.07608731f, -0.02783652f, -0.02674807f, -0.02323815f, -0.05018293f, 0.15847108f, -0.02561687f, -0.00497350f, 
    0.04941501f, 0.08621366f, -0.03296873f, -0.03176324f, 0.15106055f, -0.05252071f, -0.00688698f, 0.04812350f, 
    0.03078998f, 0.09536996f, 0.02248807f, -0.00426084f, -0.02082176f, -0.08998765f, -0.02274423f, -0.06336322f, 
    0.02182632f, 0.04321772f, -0.01647669f, -0.22837695f, -0.22204289f, -0.09488600f, 0.04849636f, 0.02167641f, 
    -0.03116649f, 0.01133411f, 0.04714436f, -0.00389506f, 0.21686579f, 0.06158466f, 0.12050327f, 0.15108405f, 
    0.16263838f, -0.05621290f, 0.12081916f, -0.06258973f, 0.17964168f, 0.02956368f, -0.03799780f, 0.09312843f, 
    -0.23740567f, -0.03471841f, 0.04381671f, 0.04430975f, -0.14534655f, -0.24463086f, -0.16428958f, -0.09733450f, 
    -0.05852948f, -0.07859820f, -0.02213486f, 0.10004887f, -0.08917356f, 0.01719259f, -0.17461137f, -0.26953450f, 
    0.18650711f, 0.03233634f, -0.08014162f, -0.02446469f, 0.10182774f, 0.05677823f, 0.09228045f, 0.00294046f, 
    0.05366924f, 0.09138093f, 0.10206860f, 0.01747605f, -0.27520329f, 0.11303849f, -0.06730935f, -0.14876711f, 
    -0.04541750f, -0.11929043f, -0.01187667f, -0.10838947f, 0.01588207f, -0.04188279f, -0.09572067f, -0.23837845f, 
    0.31649044f, -0.16374353f, 0.27537462f, -0.06015633f, 0.10215494f, 0.05779568f, 0.06672877f, 0.12692696f, 
    -0.12932397f, -0.06660027f, -0.00846651f, 0.03606486f, 0.07527683f, 0.14736494f, -0.09679920f, -0.01951769f, 
    0.03301457f, -0.08194368f, 0.03466434f, 0.06239408f, 0.12287046f, -0.06843525f, -0.03233252f, 0.00411332f, 
    0.26336908f, 0.07455313f, -0.04526334f, 0.13256240f, 0.03019210f, 0.09608049f, 0.00510051f, 0.22019410f, 
    0.07361218f, -0.04952787f, 0.08010378f, -0.01788897f, -0.10183118f, -0.03199277f, -0.12331054f, -0.14281011f, 
    -0.11203333f, -0.03012522f, 0.01616282f, -0.04506110f, 0.05293779f, -0.01656975f, -0.04356492f, -0.04588296f, 
    -0.06604286f, -0.00324167f, 0.06095010f, 0.05295634f, 0.00978019f, 0.16539928f, 0.10732792f, 0.04677245f, 
    -0.03037466f, 0.14616936f, 0.04344647f, 0.00668509f, -0.17089638f, -0.02675344f, 0.17454739f, 0.20258777f, 
    -0.11344568f, 0.02091465f, -0.07392155f, -0.13611247f, -0.01666706f, -0.01468221f, 0.00707048f, 0.04222870f, 
    -0.05555908f, -0.04123142f, -0.09100612f, -0.01808086f, 0.32480353f, 0.11739501f, 0.26565835f, 0.14750895f, 
    -0.10251838f, 0.00784992f, -0.00381575f, -0.05098555f, -0.16044576f, 0.05689844f, 0.16844368f, 0.08430466f, 
    0.01287439f, -0.08892685f, 0.00225189f, -0.10072536f, 0.03954067f, 0.08167597f, 0.15842423f, 0.18875024f, 
    0.39855063f, 0.15383287f, 0.18598193f, 0.06253697f, 0.22507778f, -0.04550385f, 0.01808696f, 0.03023846f, 
    -0.00066768f, 0.19518965f, -0.00222247f, 0.00145896f, -0.07523135f, 0.07616156f, 0.03922080f, 0.16540407f, 
    0.09702656f, -0.07881675f, 0.07140422f, 0.01828058f, -0.05093403f, 0.00974998f, 0.04244510f, -0.04870688f, 
    0.07926233f, 0.14085905f, 0.08806437f, -0.03645559f, -0.12930271f, 0.01709121f, -0.08020502f, 0.01654978f, 
    -0.01982464f, -0.04964356f, 0.01862813f, 0.01540612f, 0.40488169f, 0.09672233f, 0.10086898f, 0.25222856f, 
    0.20579068f, -0.08059059f, 0.12586755f, -0.08942911f, 0.08395179f, 0.17320818f, 0.11391203f, 0.08957603f, 
    -0.21154942f, -0.11192564f, 0.08138685f, 0.09073009f, -0.10960821f, 0.02611035f, 0.06230441f, 0.00978643f, 
    0.04000480f, -0.06041099f, 0.08892564f, 0.05729372f, 0.20100358f, 0.01556742f, 0.06232157f, 0.19470526f, 
    0.09645097f, 0.00828771f, 0.06605266f, 0.00227035f, 0.03292602f, 0.12978250f, -0.02685998f, 0.13259986f, 
    -0.13465133f, -0.12127402f, 0.06023131f, 0.02606851f, -0.04448247f, 0.02898065f, 0.03739734f, -0.10630026f, 
    -0.01381590f, 0.04455505f, 0.09668262f, -0.05963610f, -0.11400672f, -0.20117261f, -0.05483318f, 0.09880521f, 
    0.08494610f, 0.03995825f, -0.03187293f, 0.15178636f, -0.15148146f, -0.04125070f, -0.07216337f, -0.02629310f, 
    -0.22713344f, -0.08727553f, 0.17181514f, 0.06979521f, 0.00539803f, 0.06851691f, 0.06391021f, 0.03931528f, 
    0.09360967f, 0.06047082f, 0.09536330f, -0.00005377f, -0.05670143f, 0.07347141f, -0.01732335f, -0.00950843f, 
    0.00425387f, 0.11806206f, 0.03728870f, -0.07203642f, 0.05062258f, -0.02507631f, -0.00974282f, -0.04479994f, 
    0.27509665f, 0.05545113f, 0.03949710f, -0.02668581f, -0.00274884f, 0.02686135f, 0.01574843f, -0.01273971f, 
    -0.03805723f, -0.03098040f, -0.04729270f, 0.04434245f, -0.02074657f, -0.16788201f, -0.02645709f, 0.08917291f, 
    0.13526523f, 0.03442538f, 0.11644538f, 0.03937830f, 0.10510413f, 0.05476623f, 0.04845427f, 0.00725316f, 
    0.11266349f, -0.09353399f, 0.12055607f, -0.12968192f, -0.12017692f, 0.07788912f, -0.07808340f, -0.02427315f, 
    0.18977764f, 0.12127624f, 0.00921502f, 0.10070650f, -0.02384100f, 0.03252251f, -0.26031563f, -0.01556835f, 
    0.01596606f, -0.01674765f, 0.03653418f, 0.13942857f, 0.01387355f, 0.03184017f, 0.04221921f, 0.03708188f, 
    -0.15093166f, 0.00416200f, 0.15225899f, 0.00317727f, 0.00966816f, 0.01115824f, 0.02064805f, 0.01786730f, 
    0.03056196f, -0.03135397f, -0.00031275f, 0.09406240f, 0.02561261f, -0.08588433f, -0.12206376f, -0.09341839f, 
    -0.20076974f, -0.00736186f, 0.05451120f, 0.05538596f, 0.08588675f, -0.06257594f, -0.04549735f, -0.09547906f, 
    -0.10378063f, -0.14969757f, 0.09324415f, 0.06035952f, 0.12900028f, 0.00600516f, -0.02102507f, 0.14822257f, 
    -0.03380223f, -0.08569685f, 0.07450394f, 0.02764693f, 0.07798050f, -0.18421410f, 0.05966848f, 0.00419977f, 
    -0.16381060f, -0.13650426f, 0.15965576f, 0.08747316f, -0.09186868f, -0.04683007f, -0.00144428f, 0.01011306f, 
    0.02507725f, -0.00406349f, -0.04308549f, -0.13735647f, 0.03548680f, -0.04703226f, -0.03470974f, -0.01004765f, 
    0.08539092f, -0.02093733f, -0.06350586f, -0.11208244f, 0.36448029f, -0.01194791f, 0.17884691f, -0.19223662f, 
    -0.15837139f, -0.00283156f, -0.02522392f, 0.05449261f, 0.16312954f, 0.14799756f, -0.00212400f, 0.01190684f, 
    -0.02673948f, 0.06783259f, -0.21421693f, 0.18911086f, -0.12755093f, -0.03566248f, 0.12507342f, -0.10353947f, 
    -0.02786272f, 0.02297343f, -0.04131889f, -0.13769382f, -0.01697273f, -0.07183950f, -0.05491741f, 0.00359154f, 
    0.04754798f, 0.08151583f, 0.09545620f, 0.07311580f, -0.13928387f, -0.16031729f, -0.14265008f, -0.01311361f, 
    -0.05409369f, -0.01902295f, -0.01002535f, 0.19078436f, -0.03434382f, -0.08309934f, 0.04325181f, -0.12480178f, 
    0.00389045f, 0.03795611f, 0.05611179f, 0.20642135f, 0.04584436f, -0.15932171f, 0.00786878f, -0.25986198f, 
    -0.04266236f, 0.03952848f, -0.11948872f, 0.11817563f, -0.06917813f, 0.07824018f, -0.14003175f, -0.15258627f, 
    -0.35189369f, 0.10266544f, -0.25486752f, 0.13038197f, 0.06357379f, 0.09236979f, 0.13023129f, 0.02223002f, 
    0.05359527f, 0.09400780f, -0.04789999f, -0.01035950f, -0.00477270f, 0.01046262f, -0.00536469f, -0.08975415f, 
    0.03029633f, -0.15942810f, 0.04355965f, -0.12221923f, -0.00402537f, -0.01555956f, -0.04520686f, 0.11433656f, 
    -0.02955631f, 0.02652058f, -0.22554219f, 0.14643003f, -0.02724567f, 0.00821047f, 0.10700940f, -0.01801848f, 
    0.03991283f, -0.05339339f, -0.03800513f, 0.04312459f, 0.05919608f, -0.04545083f, 0.06288039f, -0.05165392f, 
    -0.01872059f, -0.13447228f, -0.01010236f, -0.21929225f, 0.06264248f, -0.13243806f, -0.01646154f, -0.03557989f, 
    0.08539252f, -0.04607725f, 0.17938745f, 0.10318798f, -0.08975111f, 0.04128718f, 0.16753668f, 0.03688436f, 
    0.01454125f, -0.11608308f, 0.09199990f, 0.15097186f, 0.14023116f, 0.19683775f, -0.06033677f, -0.13087323f, 
    0.14451389f, 0.18820228f, -0.07065926f, 0.02524411f, 0.01307678f, 0.07156897f, 0.00638051f, 0.07503497f, 
    0.02772641f, 0.01973352f, 0.00079730f, -0.03644100f, -0.01553147f, -0.15936245f, 0.06939003f, 0.08080133f, 
    -0.04026276f, 0.01744004f, 0.08596874f, 0.11140262f, -0.20178227f, 0.07817373f, 0.03682849f, 0.16429466f, 
    0.01379718f, -0.02679148f, -0.02446144f, -0.00766325f, 0.16148150f, -0.00603301f, 0.10034538f, 0.05522715f, 
    -0.13391168f, 0.30608454f, -0.19496581f, 0.19042434f, -0.05521606f, 0.08101882f, -0.07604892f, -0.00372169f, 
    0.06390543f, 0.05302526f, 0.00975205f, 0.12448914f, -0.10422894f, 0.08890973f, -0.11389733f, 0.14753756f, 
    0.02045353f, 0.03927818f, 0.05344095f, 0.18453030f, -0.08026840f, 0.05349483f, 0.04351222f, 0.08350674f, 
    -0.13811471f, -0.00727704f, -0.00149927f, -0.04794218f, -0.08025048f, -0.07164012f, 0.17089440f, -0.13284346f, 
    0.14261390f, -0.07789002f, -0.01889182f, -0.00227173f, 0.22492233f, 0.43280956f, -0.21420260f, -0.30153301f, 
    -0.12665331f, 0.13923331f, -0.05258239f, 0.01202638f, -0.04258464f, 0.01293512f, 0.04315101f, 0.00927546f, 
    0.11088061f, -0.08213752f, -0.10814476f, -0.11009859f, -0.08222164f, -0.02085986f, 0.02787053f, 0.08803999f, 
    -0.04589640f, 0.03380210f, -0.03325550f, -0.04308252f, -0.12249328f, 0.10102121f, 0.24334522f, 0.03418382f, 
    0.06178630f, 0.04812362f, -0.03878246f, 0.03415909f, -0.02305803f, 0.00145906f, 0.21375299f, 0.02727157f, 
    0.13267154f, 0.11833467f, 0.09084892f, 0.09076399f, 0.05646090f, 0.11134841f, -0.02187280f, 0.05354899f, 
    0.03327906f, -0.01699800f, -0.11597261f, -0.07454401f, -0.09191538f, 0.11545677f, -0.12278388f, -0.01997606f, 
    -0.18946803f, 0.04823646f, -0.00640226f, -0.22158025f, 0.03892221f, -0.07618924f, -0.05286751f, 0.08763136f, 
    0.15601753f, 0.07855850f, 0.17768572f, 0.01303756f, -0.02889877f, 0.01353520f, 0.05348177f, 0.26860726f, 
    0.04581142f, 0.05515149f, -0.03612796f, -0.13262482f, -0.20793977f, -0.04852142f, 0.09673212f, -0.04109583f, 
    0.14421690f, 0.00034310f, 0.04592488f, -0.03472718f, -0.01372704f, 0.02585982f, 0.12690544f, -0.07497131f, 
    -0.05730389f, -0.09892075f, 0.11338833f, 0.14161287f, -0.07065875f, -0.02478170f, -0.00722738f, 0.03187440f, 
    -0.01242292f, 0.04886528f, -0.01519294f, 0.11520346f, 0.06624138f, 0.18136963f, 0.10016007f, -0.01691072f, 
    -0.00919003f, 0.11079438f, 0.05329288f, 0.02574216f, 0.01732155f, 0.04505054f, -0.05934893f, -0.03405010f, 
    -0.02593156f, -0.01264435f, 0.04572543f, -0.04548112f, 0.02729772f, 0.04151970f, 0.01282497f, -0.02160604f, 
    -0.00693615f, -0.03475606f, -0.03428285f, -0.04013051f, -0.00104978f, -0.00377216f, -0.05099813f, -0.00989565f, 
    0.03037671f, -0.05825033f, 0.02922325f, -0.02742972f, -0.01230375f, -0.03794781f, 0.02113048f, -0.03619426f, 
    -0.02948280f, 0.02855059f, -0.04595561f, 0.02471992f, -0.01930814f, 0.02207201f, 0.02960074f, -0.02844812f, 
    0.03475674f, -0.04571586f, 0.05351601f, -0.04578437f, -0.01422384f, -0.03217333f, 0.03328064f, -0.01981381f, 
    -0.03069894f, 0.02414980f, 0.02537563f, -0.04986483f, -0.02702357f, -0.02596422f, 0.00515218f, -0.02977781f, 
    -0.06055323f, 0.01628978f, 0.02312623f, 0.00288446f, -0.03161934f, -0.05409077f, 0.03461934f, -0.03803624f, 
    0.04395752f, -0.04810843f, -0.03965345f, 0.00021662f, 0.03317950f, -0.04168982f, -0.04193036f, 0.04297857f, 
    -0.02730315f, 0.04003667f, 0.03328726f, -0.02418241f, -0.02018162f, 0.02912891f, -0.01918953f, -0.04975743f, 
    0.02729858f, -0.05835219f, -0.04158202f, -0.04092333f, -0.00463861f, -0.01777571f, 0.04132540f, -0.00020235f, 
    -0.03088770f, 0.01569290f, -0.04743759f, -0.03773731f, -0.02038257f, 0.04304409f, 0.02101480f, -0.03223627f, 
    -0.02488347f, -0.03385581f, -0.05466292f, -0.02139626f, 0.01803601f, 0.01850574f, -0.02413343f, -0.01641045f, 
    -0.01546416f, -0.02632853f, -0.01234776f, -0.01402492f, -0.02433941f, 0.02281226f, 0.02328884f, 0.02434191f, 
    0.02597255f, -0.03221363f, -0.00844817f, -0.01209647f, 0.03641769f, -0.02541620f, 0.02931357f, -0.04028007f, 
    -0.05903011f, -0.04995731f, -0.03685410f, -0.02896239f, 0.03134207f, 0.01166960f, 0.00631019f, 0.04036740f, 
    0.00978217f, 0.03959329f, 0.01840185f, -0.02064639f, 0.01516336f, -0.00991629f, -0.04039471f, 0.04561701f, 
    0.01296185f, -0.04425571f, -0.05410760f, -0.00601352f, 0.00896013f, -0.00572286f, 0.02277964f, 0.02770794f, 
    -0.04674728f, -0.03366459f, 0.01931436f, -0.03743227f, 0.02334108f, -0.03241419f, -0.00166856f, -0.00578558f, 
    -0.03478616f, -0.02631934f, -0.00374494f, 0.04121647f, 0.00200370f, 0.03015985f, -0.01667164f, -0.05190776f, 
    0.00661781f, 0.01763975f, 0.02790512f, 0.02664040f, 0.00117932f, -0.05148323f, 0.01920080f, -0.04697651f, 
    0.00630710f, -0.03813997f, 0.02546105f, -0.04284746f, 0.00249376f, 0.00436165f, 0.00761157f, -0.00610988f, 
    -0.00235673f, -0.02772194f, -0.02533326f, -0.01129242f, 0.01385602f, -0.05002984f, -0.01926840f, -0.01336523f, 
    -0.00427548f, -0.05684095f, -0.00005427f, -0.02376558f, -0.04420766f, -0.01782602f, -0.02546176f, -0.02839665f, 
    -0.00553797f, -0.00797066f, -0.02926532f, 0.02584029f, 0.03712580f, 0.00443316f, 0.02759544f, 0.03984695f, 
    -0.05435798f, -0.02279778f, 0.01840925f, -0.04917733f, 0.00258219f, 0.00995908f, 0.00816021f, 0.04381498f, 
    0.01431060f, -0.02874922f, 0.04011063f, 0.02396881f, 0.00645839f, -0.05615246f, -0.05058182f, -0.02939899f, 
    -0.04131541f, -0.02374324f, -0.04053704f, 0.04407267f, 0.03439682f, -0.04870263f, 0.02765025f, -0.01332275f, 
    -0.00960766f, -0.01330988f, -0.04220112f, -0.03720331f, 0.03408679f, -0.02188408f, -0.00438833f, -0.00126696f, 
    0.01890015f, -0.02322461f, -0.01207747f, -0.03871146f, 0.04405106f, -0.04752956f, -0.03105393f, -0.01473181f, 
    0.03436466f, 0.00986254f, 0.01969370f, -0.04000073f, -0.04787451f, -0.05961065f, -0.00831696f, -0.02912023f, 
    0.01728753f, -0.02033566f, 0.01537670f, 0.01091405f, -0.01472418f, 0.03237458f, -0.01824414f, 0.03833800f, 
    -0.03106983f, 0.04294910f, 0.00248884f, -0.01707141f, -0.06116740f, 0.03082828f, 0.00981849f, -0.02920731f, 
    0.03521886f, -0.05371182f, -0.04382744f, -0.00441154f, 0.01347581f, -0.01092094f, 0.00081667f, -0.01946577f, 
    -0.01148735f, -0.04869436f, 0.04512800f, -0.04490231f, 0.00302241f, -0.03005592f, 0.02795584f, -0.05170735f, 
    -0.04243798f, -0.05220965f, 0.01467755f, -0.02376958f, 0.00913848f, -0.03919486f, -0.03489240f, -0.04892860f, 
    0.04398137f, -0.01462473f, -0.03817185f, 0.02579542f, -0.01465259f, 0.01042654f, -0.00031384f, -0.05623617f, 
    0.00006932f, -0.00859636f, 0.03470602f, -0.00691651f, 0.01455104f, -0.01713835f, 0.00826355f, -0.05533770f, 
    0.04547272f, -0.01939224f, 0.01753414f, -0.00348184f, -0.00105065f, 0.04795608f, -0.01964224f, -0.01583940f, 
    0.01296784f, -0.00188990f, -0.03600697f, -0.03211301f, -0.03938329f, -0.01031795f, -0.04752713f, -0.03632570f, 
    -0.00074735f, -0.02459819f, -0.03640185f, -0.01205489f, 0.03121045f, -0.02973372f, -0.03613227f, -0.04236319f, 
    0.01394298f, 0.01239111f, 0.03909701f, -0.02339640f, -0.05417475f, 0.03282355f, 0.02254754f, -0.00919273f, 
    -0.03049710f, -0.02445834f, -0.05093980f, -0.05583776f, -0.00929663f, -0.02269415f, -0.03433793f, -0.01373196f, 
    0.04057961f, -0.01644442f, 0.02899262f, -0.00564942f, 0.03276870f, 0.02442212f, -0.00392822f, -0.03367557f, 
    0.04224978f, 0.04017432f, -0.05101738f, 0.02621582f, 0.03094963f, -0.01891204f, 0.04426252f, -0.04914028f, 
    0.03879966f, 0.00574604f, 0.00078266f, -0.04524041f, -0.00690267f, -0.00814196f, 0.00269653f, 0.02959418f, 
    0.00819501f, -0.04903990f, 0.01430696f, 0.00711317f, 0.02323441f, -0.05464189f, -0.03026402f, 0.02025439f, 
    -0.00356244f, -0.00955632f, -0.01659199f, -0.01946675f, 0.03852981f, -0.00731730f, 0.00388976f, 0.00160356f, 
    -0.03513268f, -0.02336881f, -0.02391274f, -0.02587426f, -0.03405391f, 0.03030508f, -0.01917790f, -0.04590274f, 
    -0.40664908f, 0.50798798f, -0.10909969f, -0.07544299f, 0.11043237f, 0.04717209f, -0.16648607f, -0.00697220f, 
    -0.24417403f, -0.06660997f, -0.04695299f, 0.11428063f, 0.03666903f, -0.16282418f, -0.16036943f, 0.06321131f, 
    0.06467269f, 0.09045625f, -0.03547953f, -0.00154328f, -0.02411498f, -0.02856260f, -0.00770163f, 0.00306090f, 
    -0.18342203f, 0.12622665f, -0.08107561f, 0.14847574f, 0.01586688f, -0.05427352f, 0.01324708f, 0.07788786f, 
    0.03743641f, 0.16584720f, -0.13062519f, 0.04989946f, -0.02914284f, 0.11740315f, -0.01014599f, -0.10688528f, 
    0.20780472f, -0.03813466f, 0.08309883f, -0.03680791f, -0.15348415f, -0.01083919f, 0.11881359f, 0.07071723f, 
    0.17652072f, -0.03626520f, -0.05301388f, 0.00168889f, 0.05215066f, -0.03842910f, 0.01495213f, -0.01947622f, 
    -0.10658584f, 0.02730004f, -0.04431996f, 0.04533363f, -0.10384803f, 0.15163888f, -0.00519463f, 0.02170094f, 
    0.23305084f, 0.07993373f, -0.11477447f, 0.12332539f, 0.10787646f, -0.15295713f, -0.02012851f, 0.18866196f, 
    -0.09216686f, 0.06579819f, 0.01373823f, 0.11583082f, -0.05537941f, 0.10183849f, 0.02712591f, -0.01614851f, 
    -0.03377049f, 0.06458350f, -0.05834458f, 0.01317661f, -0.25289014f, 0.33639193f, -0.11172188f, -0.04547136f, 
    0.06717385f, 0.04680445f, -0.10229385f, -0.02125713f, 0.05032562f, -0.10763567f, 0.06287171f, 0.07785240f, 
    -0.06835475f, -0.02648030f, 0.03408803f, -0.00042994f, -0.09542224f, 0.11538441f, 0.10175393f, 0.06217219f, 
    0.03437858f, 0.01214105f, 0.03583488f, 0.03475135f, 0.05543293f, 0.10718430f, -0.12222086f, -0.16904050f, 
    -0.03311097f, 0.07378713f, 0.05283105f, 0.08309662f, 0.04791705f, 0.06080196f, 0.01238511f, -0.05662284f, 
    0.14554387f, 0.04087360f, 0.01776819f, 0.05076721f, 0.15382172f, 0.09277467f, -0.08456124f, -0.01718692f, 
    0.06763715f, 0.09972311f, 0.13609114f, 0.03951141f, 0.10925951f, 0.00305336f, -0.04497560f, 0.08445470f, 
    0.18097068f, -0.01539439f, -0.13975023f, 0.09473784f, -0.13522963f, 0.00795846f, 0.05947784f, -0.06705099f, 
    0.05151021f, -0.34032786f, 0.31502366f, 0.13670766f, -0.00286382f, 0.04155795f, -0.02532118f, 0.04771037f, 
    -0.00501283f, 0.02222285f, -0.04776555f, -0.03015026f, -0.08213895f, 0.10185812f, -0.09771678f, 0.01111324f, 
    -0.01736467f, 0.14381120f, -0.00254283f, -0.09443656f, -0.04730413f, -0.03098691f, 0.02338101f, -0.00307059f, 
    -0.22408867f, -0.02774529f, 0.08829658f, 0.02499195f, -0.10919668f, -0.07573310f, -0.03728796f, 0.11174188f, 
    -0.02699048f, 0.01179960f, -0.00829139f, 0.03571405f, -0.12081455f, -0.00623080f, -0.14119561f, 0.00103755f, 
    0.03045855f, 0.03307454f, -0.05183450f, -0.08382133f, -0.10455808f, 0.07991772f, -0.10383222f, 0.04314295f, 
    0.11556908f, -0.09155525f, 0.02119058f, 0.02749763f, 0.05232231f, 0.00161810f, -0.11869910f, 0.11350725f, 
    0.01129205f, 0.04949842f, 0.13423777f, 0.10795643f, -0.02608435f, -0.00572523f, -0.05296987f, 0.02067092f, 
    0.01756022f, -0.06667227f, 0.01477245f, 0.02638991f, -0.06235290f, 0.04815258f, 0.02049314f, -0.11166764f, 
    -0.04620664f, 0.00493265f, -0.03557025f, -0.14513823f, 0.15785618f, 0.13084163f, 0.08601073f, -0.05686904f, 
    0.12484410f, -0.04369598f, -0.03740684f, -0.02800479f, -0.13028716f, -0.02617548f, 0.07507986f, 0.28760991f, 
    0.05901291f, -0.05992100f, -0.01926183f, 0.00134623f, 0.15340926f, 0.09706525f, 0.10201679f, 0.05894811f, 
    0.03317502f, 0.18437201f, -0.07233975f, 0.01960351f, -0.02596018f, -0.03218514f, 0.06223455f, -0.11761735f, 
    -0.13266581f, 0.09865271f, -0.04862150f, 0.09329101f, 0.34914461f, -0.12906387f, 0.03834113f, -0.00224698f, 
    0.00568098f, 0.04035407f, 0.09426615f, 0.06427465f, -0.04957500f, 0.06259593f, -0.09635422f, -0.00795771f, 
    -0.00089459f, 0.11122652f, -0.01334362f, 0.06066556f, -0.03860101f, 0.03455283f, 0.03561058f, 0.03599219f, 
    -0.13043863f, 0.08948102f, -0.11004609f, -0.00629026f, 0.05868652f, -0.03602327f, 0.21432450f, 0.31236750f, 
    0.10994236f, -0.15983957f, 0.01868040f, -0.02820878f, 0.01003299f, 0.13849564f, 0.10222089f, 0.03532584f, 
    0.15226091f, 0.15259036f, -0.19918820f, -0.07827759f, 0.02870978f, 0.11282468f, 0.12317826f, -0.07931937f, 
    -0.05368395f, 0.03407444f, 0.07439414f, 0.05232885f, -0.09273355f, 0.05767287f, -0.00303359f, 0.13911863f, 
    0.00540105f, 0.07999204f, -0.02488143f, -0.03442071f, -0.04185270f, -0.03078279f, 0.02699810f, 0.10484289f, 
    -0.00782326f, -0.12658241f, -0.00805160f, -0.14756230f, 0.13857786f, 0.00148758f, 0.09784512f, 0.09405566f, 
    -0.05741898f, 0.07982714f, -0.04227466f, -0.02159790f, 0.06729617f, 0.09096973f, -0.02172415f, -0.19295877f, 
    0.08163025f, -0.07033878f, 0.03462984f, 0.19184063f, -0.07207157f, -0.00377697f, 0.07210584f, -0.16719586f, 
    -0.08149421f, -0.05645660f, -0.09119812f, 0.03637308f, 0.02245814f, -0.03126067f, -0.02370558f, -0.02146518f, 
    -0.04756748f, 0.00785575f, 0.01691060f, -0.00548288f, -0.06952072f, -0.04835931f, -0.08407423f, 0.05529504f, 
    -0.10840642f, 0.16957670f, 0.02409662f, 0.02704472f, 0.07697996f, 0.15774678f, -0.08567671f, -0.00254402f, 
    0.14078569f, 0.26321834f, 0.06443626f, -0.06815325f, -0.04685985f, 0.08709668f, 0.04400140f, -0.02955403f, 
    -0.04083550f, -0.01119992f, 0.05404587f, -0.01837220f, 0.02668362f, -0.01309619f, 0.10831197f, -0.13801146f, 
    -0.01017781f, 0.03701733f, 0.04419848f, -0.03314159f, 0.00056139f, 0.01859754f, 0.03869882f, -0.02476376f, 
    -0.06456425f, -0.27600515f, 0.19693401f, 0.01266467f, -0.07981968f, -0.05320709f, 0.02570188f, 0.01013315f, 
    0.17013380f, 0.18817431f, 0.12136758f, 0.10708994f, -0.26932147f, -0.00816796f, 0.11226980f, -0.14092577f, 
    -0.10133302f, -0.10983998f, 0.17243297f, 0.05685793f, -0.02955500f, 0.00294076f, 0.02549708f, 0.03743478f, 
    -0.05871607f, -0.18649645f, -0.00880850f, -0.11416362f, -0.14167981f, 0.11778772f, -0.09534208f, -0.06030825f, 
    0.05035555f, -0.03954796f, 0.04379283f, 0.18135697f, -0.10089448f, -0.03352171f, -0.25546312f, 0.11543872f, 
    -0.10035803f, 0.06856156f, -0.07473173f, 0.12054177f, -0.00417006f, 0.04791661f, 0.01190823f, 0.14573684f, 
    -0.10220075f, -0.02683456f, 0.07859887f, 0.11457672f, 0.12147830f, 0.02757248f, -0.04233821f, 0.03445883f, 
    0.03904591f, 0.03897285f, -0.00963939f, 0.05229633f, 0.11399167f, -0.05260887f, -0.19578722f, 0.03070817f, 
    -0.16842756f, -0.14995986f, 0.04464254f, -0.08772124f, 0.06491154f, 0.02459423f, -0.06769130f, 0.05180878f, 
    -0.01146213f, 0.00066858f, -0.01271781f, -0.04625878f, 0.02567200f, -0.06688982f, -0.03684716f, -0.05298103f, 
    0.04342996f, 0.06954741f, 0.01498641f, -0.17839599f, 0.04034279f, -0.16119704f, 0.14922072f, -0.05017847f, 
    -0.08371124f, -0.03488528f, -0.01784905f, 0.03633260f, 0.14278953f, 0.15483345f, 0.13278389f, 0.12371434f, 
    0.07059640f, -0.05571557f, 0.02487241f, -0.11583426f, -0.00884846f, 0.05313428f, 0.07926222f, 0.12331872f, 
    -0.11561101f, -0.00608947f, 0.00248827f, 0.01803984f, -0.07338434f, -0.13342571f, -0.11720745f, 0.00695675f, 
    -0.04784871f, 0.05929436f, -0.04646905f, 0.19009611f, -0.04417938f, -0.01699111f, -0.09614561f, -0.15351765f, 
    -0.01329822f, 0.03338007f, -0.11182354f, -0.04210907f, 0.05101985f, -0.15765515f, 0.12735756f, 0.06279264f, 
    0.04771022f, 0.13740352f, -0.01629112f, 0.12336560f, -0.20605487f, -0.03388108f, -0.03279332f, -0.10175120f, 
    -0.13780494f, -0.03690349f, 0.09498046f, 0.03665198f, 0.04293144f, -0.05429266f, -0.13813375f, -0.22572981f, 
    0.03697839f, -0.15518485f, 0.02269476f, -0.27794632f, -0.01620504f, 0.01420410f, 0.03694909f, 0.01965841f, 
    -0.04411700f, -0.04226735f, -0.00825629f, 0.08335947f, 0.01327013f, 0.03008622f, -0.14564027f, -0.06467338f, 
    0.06077965f, -0.13185994f, -0.08480508f, 0.01278725f, 0.01490681f, 0.05800254f, 0.02338989f, 0.01105784f, 
    0.39326641f, 0.17857713f, -0.21817791f, 0.14294301f, 0.05006385f, 0.03759912f, 0.05993227f, 0.13467491f, 
    0.20918988f, -0.05662998f, -0.09837493f, -0.00377065f, -0.08843128f, -0.13742219f, -0.04964742f, -0.10932915f, 
    -0.09317779f, -0.06982803f, -0.03203483f, -0.07759855f, -0.02668742f, -0.02175159f, 0.07703913f, -0.05938378f, 
    -0.02682701f, 0.13914809f, 0.03004895f, 0.16245131f, 0.00277960f, 0.10079242f, 0.23222098f, 0.07948191f, 
    -0.00394218f, 0.11668008f, -0.01176001f, 0.14182265f, -0.06369834f, -0.08878586f, 0.05642346f, -0.07392085f, 
    0.02377951f, 0.11876906f, -0.20111755f, -0.32482570f, 0.00311458f, -0.02130433f, 0.06333445f, 0.16082437f, 
    -0.03811923f, -0.22469744f, -0.16504082f, -0.02400212f, 0.10402450f, -0.13587193f, 0.22175603f, 0.25379145f, 
    -0.23989515f, 0.02695870f, -0.00300795f, 0.02343801f, -0.03796193f, 0.10790519f, 0.10730362f, 0.16012624f, 
    0.00909344f, -0.08180756f, 0.00276073f, -0.02275284f, 0.17221065f, 0.04376965f, 0.16949321f, 0.10412449f, 
    0.33614492f, 0.24276434f, -0.02883736f, -0.15819822f, 0.14343654f, -0.06380293f, -0.01639841f, 0.13698342f, 
    0.01142008f, 0.13295385f, 0.06412397f, -0.05897972f, -0.36124569f, 0.22045821f, 0.03595477f, 0.29740363f, 
    0.04918236f, -0.01922812f, 0.05257300f, 0.10425119f, 0.04195946f, 0.01341042f, 0.15952641f, -0.01621633f, 
    0.08090872f, 0.07281084f, 0.04650306f, -0.00356502f, -0.05414743f, -0.06583526f, -0.08615772f, -0.08004393f, 
    0.02034257f, -0.01907105f, 0.09825638f, 0.06747138f, 0.38794693f, 0.39109525f, -0.20216015f, -0.20675401f, 
    0.05464410f, -0.03457963f, -0.05055231f, -0.03818257f, 0.06844550f, -0.00043831f, 0.12023898f, 0.07840656f, 
    -0.09576238f, -0.10878792f, 0.15336743f, 0.08005525f, -0.06960217f, -0.12048366f, 0.07579100f, 0.05071033f, 
    -0.05129529f, 0.05323295f, -0.03887842f, 0.04785361f, 0.07586931f, -0.09836830f, -0.06153425f, 0.16811648f, 
    0.01604604f, -0.05524600f, 0.00144791f, -0.02955452f, 0.04291885f, 0.05634493f, 0.01326497f, 0.12534529f, 
    -0.09843281f, -0.03069455f, -0.07614923f, 0.00989598f, -0.06454969f, 0.13107650f, -0.03302459f, 0.03099994f, 
    -0.00175773f, -0.08454936f, 0.02918022f, -0.03999938f, -0.06094433f, -0.17833699f, -0.22519240f, -0.01030958f, 
    -0.05888564f, 0.14367087f, 0.03420966f, -0.14418559f, -0.05739607f, -0.05776674f, 0.00776055f, 0.16908696f, 
    -0.11881254f, 0.00414914f, 0.30806139f, 0.19686210f, -0.05040382f, 0.24324197f, 0.11774776f, 0.01149601f, 
    0.09658208f, 0.07551340f, 0.06978728f, -0.00901866f, -0.23207925f, -0.19251290f, -0.06341196f, -0.01519202f, 
    0.03045054f, -0.11663622f, -0.06150621f, -0.13161118f, -0.02914901f, -0.14165942f, 0.02435740f, -0.05490539f, 
    -0.02702205f, 0.03649928f, -0.11612245f, -0.07725800f, -0.11972020f, -0.08402912f, -0.14412118f, -0.09877709f, 
    -0.02065544f, -0.03637225f, -0.01860617f, 0.14825432f, 0.03412651f, -0.06003048f, -0.01408113f, 0.03009737f, 
    0.11721161f, 0.10576516f, 0.11564160f, 0.10326140f, -0.00985521f, 0.03840783f, -0.02356485f, -0.03765582f, 
    -0.24856377f, 0.16071166f, -0.14498147f, -0.06926421f, 0.04034359f, 0.03795552f, 0.06418141f, -0.02931716f, 
    0.03050219f, -0.06014492f, -0.13658087f, 0.13564014f, -0.37335333f, -0.36941281f, -0.29033464f, -0.14649743f, 
    -0.09894437f, 0.02680032f, -0.04258371f, 0.00766101f, 0.01450596f, -0.05059123f, -0.07174370f, -0.00015019f, 
    -0.16920505f, 0.02895887f, 0.05858574f, 0.07846264f, 0.02107893f, -0.05227267f, 0.02925117f, 0.06385066f, 
    0.06712582f, -0.15960647f, 0.18242259f, 0.15292309f, 0.21992725f, -0.22059028f, 0.01197060f, 0.05075692f, 
    0.20490874f, -0.00787543f, 0.10127361f, 0.21851894f, 0.02679904f, 0.15830156f, 0.10650156f, 0.07118988f, 
    -0.23038715f, -0.19103187f, -0.02666595f, 0.12791218f, 0.07383986f, 0.04258109f, 0.18403833f, 0.10700158f, 
    0.00334880f, -0.00949549f, -0.04958943f, 0.04103829f, 0.06342629f, -0.06100070f, -0.11104073f, -0.15436332f, 
    0.08883956f, 0.29688472f, 0.05325436f, 0.04713535f, 0.05026131f, 0.06612348f, 0.05846580f, -0.01034967f, 
    0.01334395f, 0.04739394f, -0.04034793f, -0.00320540f, -0.01124765f, -0.04917568f, -0.03548663f, -0.01189017f, 
    0.19796251f, 0.09372514f, -0.08585316f, 0.09086080f, 0.08582828f, 0.10554453f, -0.20279863f, -0.00288592f, 
    0.03158299f, 0.01517260f, 0.07533202f, 0.03258359f, 0.22697544f, 0.16702536f, -0.01372473f, -0.04855618f, 
    -0.10648140f, 0.06102440f, 0.00101544f, 0.10151283f, 0.00096834f, -0.07613272f, -0.03843047f, -0.08909483f, 
    0.02360484f, 0.00568056f, 0.02568007f, 0.12402424f, 0.12831374f, -0.09019468f, -0.06382604f, -0.09574193f, 
    0.13031927f, 0.25199091f, 0.20676050f, -0.24209957f, -0.06964657f, 0.19244587f, -0.00418422f, -0.00807024f, 
    -0.05014457f, -0.09444737f, -0.16250278f, 0.11878560f, 0.03135677f, 0.05176802f, -0.03489796f, -0.03792927f, 
    0.07700179f, 0.04070279f, 0.04737349f, 0.04947671f, 0.04494024f, -0.09170162f, 0.10869016f, -0.10644604f, 
    0.04451382f, 0.04408536f, 0.05395027f, 0.23120598f, 0.04210404f, 0.06733210f, 0.14285812f, -0.13778190f, 
    -0.32544190f, 0.02297980f, 0.05478236f, 0.10290544f, 0.17024881f, 0.32306990f, 0.17033279f, 0.44108176f, 
    -0.01997271f, 0.02096810f, -0.00237956f, 0.02079713f, 0.07282856f, 0.07588562f, 0.02121186f, 0.00954505f, 
    -0.00067042f, 0.03871851f, 0.05355239f, -0.05098008f, -0.02410284f, -0.04453903f, -0.17124002f, 0.09211548f, 
    -0.40881115f, 0.15591200f, 0.09684514f, 0.19062750f, 0.02683906f, 0.00913196f, 0.14237578f, -0.00864346f, 
    -0.04605575f, 0.08817505f, 0.01646226f, 0.17589821f, -0.04786695f, 0.07794528f, -0.06403412f, -0.03498146f, 
    -0.01923985f, -0.01074570f, 0.04061045f, -0.03831125f, 0.04740058f, -0.09045243f, -0.09356300f, 0.05886499f, 
    -0.11600211f, -0.27408904f, 0.04537246f, -0.07343301f, -0.07672432f, 0.09971195f, 0.06083869f, 0.09220978f, 
    -0.02414147f, -0.11137792f, 0.05300990f, 0.04104433f, -0.04053214f, -0.12195233f, -0.24008536f, -0.01881285f, 
    -0.06357869f, -0.07858990f, 0.03307956f, 0.10555612f, 0.01034212f, 0.00281278f, -0.02402271f, -0.03184677f, 
    0.02440488f, 0.03831894f, 0.04899238f, 0.03751734f, 0.08023296f, 0.05319738f, -0.01977976f, 0.00988443f, 
    0.08775722f, 0.04354619f, -0.01016784f, 0.04099602f, -0.19001171f, -0.03321077f, -0.05847735f, 0.36269152f, 
    -0.02835380f, 0.06431741f, 0.01701179f, 0.03081816f, 0.01602888f, -0.10176459f, 0.17501812f, 0.04732647f, 
    -0.28214023f, -0.01786346f, 0.18130524f, 0.20974021f, 0.11724655f, 0.16361734f, -0.04733352f, -0.04261434f, 
    0.04840374f, -0.04629616f, 0.07603782f, 0.07806560f, -0.09795444f, 0.06186432f, -0.04214796f, 0.11770064f, 
    0.11252332f, -0.00292111f, 0.11529440f, 0.05285916f, 0.01160605f, 0.10084975f, -0.04767764f, -0.03884199f, 
    -0.16947648f, 0.03326139f, -0.04624793f, 0.10014940f, 0.04405514f, -0.09098363f, 0.14960369f, -0.03553260f, 
    -0.01177503f, -0.07746232f, 0.03465708f, 0.13356176f, 0.07128516f, -0.12744628f, 0.06513505f, 0.23863684f, 
    0.13527355f, 0.04190957f, -0.04274791f, -0.00446285f, -0.02415290f, 0.09084581f, -0.06139277f, 0.14211799f, 
    -0.02070227f, -0.29034612f, -0.10960763f, -0.08640961f, 0.03623534f, 0.22788404f, -0.07039093f, 0.09779784f, 
    -0.02414807f, -0.03247766f, 0.05208384f, 0.01755895f, -0.07869739f, 0.00474148f, 0.10019431f, -0.13928999f, 
    0.08575649f, -0.01249771f, -0.02802921f, 0.02946895f, -0.01136679f, -0.02175941f, 0.07003856f, -0.00789289f, 
    -0.09818120f, -0.26518106f, -0.19417778f, -0.05899826f, 0.10458367f, 0.05089214f, 0.01358728f, -0.13936903f, 
    -0.13622704f, -0.04144661f, -0.04023201f, -0.05587298f, 0.30096403f, -0.15216525f, -0.05550976f, 0.03926519f, 
    0.02712991f, 0.02446882f, 0.08725797f, -0.01802487f, -0.04794679f, -0.01139025f, -0.05703098f, -0.01778790f, 
    0.15131137f, -0.08546899f, -0.22775178f, 0.05737679f, 0.06541375f, -0.06494593f, 0.08067178f, 0.26684865f, 
    0.16063963f, 0.00277786f, 0.11401527f, 0.02424575f, -0.04836058f, 0.01496748f, 0.04484478f, -0.06905916f, 
    0.16559221f, -0.00048078f, -0.01659624f, -0.03901356f, 0.01280440f, -0.00519965f, -0.00855107f, 0.00708135f, 
    0.22883514f, -0.00850181f, -0.14388706f, -0.19203784f, 0.05482195f, -0.02658011f, 0.05676642f, 0.04471392f, 
    -0.03118241f, 0.03741276f, -0.01664607f, -0.07836594f, -0.15733920f, -0.34060186f, -0.02317483f, -0.04325647f, 
    0.05282629f, 0.01862333f, -0.03375359f, 0.03934233f, -0.05267028f, -0.09799776f, 0.03168689f, 0.07652677f, 
    0.09699621f, -0.01223193f, 0.14090659f, -0.07198063f, -0.09413581f, 0.03812169f, 0.02593571f, -0.00235712f, 
    0.15372938f, 0.16197523f, 0.03365595f, 0.06601968f, -0.16156818f, -0.07754207f, 0.01697613f, 0.24178177f, 
    0.03506961f, -0.06513241f, 0.11393647f, 0.03809934f, -0.03553297f, 0.08402196f, 0.02556261f, 0.14506142f, 
    -0.11705229f, -0.00955452f, 0.07353576f, 0.07382444f, -0.02132271f, -0.07215700f, -0.06989729f, 0.01250191f, 
    -0.03561695f, 0.02821510f, 0.05453714f, 0.15037861f, -0.12552798f, -0.07058315f, -0.42936799f, -0.15317255f, 
    -0.09553804f, -0.02576727f, 0.05081456f, 0.03387024f, -0.00489493f, -0.04219964f, 0.01988599f, 0.07900988f, 
    -0.09532303f, -0.11820987f, 0.19195868f, 0.19116309f, 0.13972521f, 0.05050146f, 0.04786146f, 0.10269399f, 
    0.00738588f, 0.03098597f, 0.01708892f, -0.04162389f, 0.06424410f, 0.06465802f, -0.02887780f, 0.08845324f, 
    -0.06811845f, -0.05844513f, 0.08837663f, -0.03281775f, 0.04256475f, 0.01743411f, 0.06421493f, 0.12994450f, 
    0.18274564f, 0.10294010f, -0.00391804f, -0.11707680f, -0.04145769f, -0.13325670f, -0.03628686f, -0.02962903f, 
    0.05415525f, -0.03124023f, -0.16965653f, -0.24055386f, 0.17681718f, 0.04523492f, 0.13201870f, -0.26523885f, 
    -0.14381810f, -0.03223394f, 0.00435975f, 0.02202274f, 0.18130440f, 0.14211406f, -0.05702350f, 0.12049843f, 
    0.01667669f, -0.01372286f, -0.04673462f, 0.04586280f, 0.03575315f, -0.00480461f, 0.01607496f, 0.01023232f, 
    -0.07863155f, 0.01018414f, -0.10820790f, -0.12705062f, -0.06979007f, -0.07199184f, -0.12769748f, -0.14104533f, 
    0.06234531f, 0.12602080f, 0.07924592f, 0.04097408f, -0.04790888f, -0.03659651f, -0.15006962f, -0.16913037f, 
    0.04098840f, -0.04173513f, -0.03873745f, 0.11701439f, -0.03077492f, -0.07139716f, -0.01890020f, -0.05090650f, 
    0.06182335f, 0.06339766f, 0.10603924f, 0.26141873f, -0.11463534f, -0.00777654f, -0.14899586f, -0.28688633f, 
    -0.04031913f, -0.04635077f, -0.14835954f, -0.05216063f, -0.03869487f, 0.06612351f, -0.17272407f, -0.17270589f, 
    -0.28071487f, -0.14914919f, 0.12166555f, 0.07225760f, 0.05463357f, 0.08396927f, 0.03863537f, 0.03217648f, 
    0.00342088f, 0.04720722f, 0.01979458f, -0.00429231f, 0.03356843f, 0.05906824f, 0.00011414f, -0.19233848f, 
    -0.09178138f, -0.14144081f, 0.04861300f, -0.11210084f, 0.01246850f, -0.01156374f, -0.05590851f, 0.01292994f, 
    0.02966193f, 0.03071783f, -0.19321552f, 0.28442612f, 0.04824207f, 0.06014887f, 0.01732347f, 0.02511531f, 
    0.05120055f, -0.10933940f, -0.01237880f, 0.00966934f, 0.04641509f, 0.01442806f, -0.00751601f, -0.12413125f, 
    -0.09367342f, -0.07484145f, -0.05490095f, -0.15815052f, 0.00617640f, -0.19757116f, -0.04381512f, -0.09763245f, 
    0.04151962f, -0.06532115f, 0.16504730f, 0.19903436f, -0.08577086f, 0.08169835f, 0.21944296f, 0.03619819f, 
    0.02689214f, 0.01327666f, 0.08155201f, 0.13234599f, -0.11447207f, 0.07885578f, 0.01800404f, 0.22168575f, 
    0.04289005f, 0.13625559f, -0.10897841f, -0.07143451f, 0.03074333f, 0.02874892f, 0.07877024f, 0.08786191f, 
    -0.09521020f, -0.14316499f, -0.07129180f, 0.03638755f, 0.11394185f, -0.09280905f, 0.17284928f, 0.18602908f, 
    -0.09854309f, 0.02943986f, 0.02750494f, 0.06554212f, -0.08882532f, 0.13025063f, 0.09538482f, 0.17292945f, 
    -0.00899056f, -0.13625838f, 0.01083521f, -0.04280986f, 0.17893466f, 0.05589929f, 0.17371051f, 0.09855058f, 
    0.00997833f, 0.16916050f, -0.11507997f, 0.06270060f, 0.02740259f, -0.04778791f, -0.11848761f, 0.05098047f, 
    0.01654435f, 0.05249615f, 0.03339151f, 0.10636454f, 0.07345921f, 0.07885215f, -0.05591769f, 0.21121730f, 
    0.11789186f, -0.01301587f, 0.00643888f, 0.11942183f, -0.09444938f, 0.05817961f, -0.00766088f, 0.02011260f, 
    -0.07328439f, 0.22202009f, -0.01609870f, 0.09140794f, -0.07823157f, -0.06468616f, -0.03507729f, -0.10717940f, 
    0.04389048f, -0.04493012f, -0.04880735f, -0.00114600f, 0.26795071f, 0.29345798f, -0.19997531f, -0.18804948f, 
    -0.00786807f, 0.09963429f, -0.05566912f, -0.06463218f, -0.04535424f, 0.08943512f, 0.08634001f, 0.07196285f, 
    -0.10171197f, -0.09558535f, 0.01011044f, 0.02742092f, -0.09149852f, -0.11143721f, 0.03402275f, 0.08552073f, 
    0.03495897f, 0.02907240f, -0.00456239f, -0.07581222f, -0.06031991f, 0.08666497f, 0.12173320f, 0.06833405f, 
    0.08698265f, -0.07530197f, -0.00950252f, 0.00569896f, 0.00040444f, 0.09357809f, 0.05027508f, 0.08038064f, 
    -0.08603317f, -0.10428949f, -0.10167227f, 0.12960631f, 0.05267466f, 0.17014529f, 0.04064218f, 0.06369272f, 
    0.07019985f, -0.05091010f, -0.07294424f, -0.02888395f, -0.07725018f, -0.00060891f, -0.08636074f, 0.06664408f, 
    -0.11781289f, 0.13766718f, -0.00252802f, -0.03482785f, -0.07106256f, -0.00663246f, 0.04044551f, 0.09926630f, 
    0.11096597f, 0.14397180f, 0.32023770f, 0.10032805f, -0.08283708f, -0.04783019f, 0.10981449f, 0.14682385f, 
    0.08686216f, 0.12425312f, -0.00462766f, -0.09216094f, -0.21528673f, -0.05112842f, 0.04654255f, -0.03660363f, 
    -0.00248511f, -0.09183943f, 0.00729753f, -0.10302231f, -0.05072619f, -0.03507563f, -0.00782046f, -0.05016791f, 
    -0.04532869f, 0.08962806f, 0.03166767f, -0.00494659f, -0.24082592f, -0.03955132f, -0.05721745f, 0.04834808f, 
    0.02848506f, 0.04735844f, -0.08183060f, 0.06796125f, -0.00704089f, 0.12196285f, 0.13157849f, 0.00258941f, 
    0.15067229f, 0.09288451f, 0.15987405f, 0.09520269f, -0.00081891f, 0.08665726f, -0.09358484f, -0.10976367f, 
    -0.01501496f, -0.01701151f, -0.00418832f, 0.01499670f, -0.05357832f, 0.01742242f, -0.02826069f, -0.01838943f, 
    0.03914489f, -0.02138859f, 0.03328904f, 0.01835029f, 0.00596795f, -0.03441406f, 0.03755188f, -0.01258988f, 
    0.02443138f, -0.01523434f, -0.00164168f, 0.01052328f, 0.02307635f, 0.04017949f, -0.01081948f, 0.01021571f, 
    -0.03412835f, 0.00143059f, 0.01327235f, -0.01045056f, -0.02358922f, -0.02771085f, -0.00300311f, -0.03724175f, 
    0.00277381f, -0.02334412f, 0.02463663f, -0.05552850f, -0.02219309f, -0.01539973f, -0.01571413f, 0.03977731f, 
    -0.01426386f, 0.04168108f, 0.00656186f, -0.01354016f, -0.02717073f, -0.03554397f, 0.00004583f, -0.03945294f, 
    0.03722930f, -0.03969497f, -0.01893201f, -0.02343706f, 0.04011885f, -0.03186250f, -0.03194903f, 0.02887611f, 
    0.02107273f, -0.01343634f, 0.04439512f, 0.01617030f, -0.04979296f, -0.01638173f, -0.02963353f, -0.05196724f, 
    -0.02902233f, -0.03098254f, -0.01718923f, -0.03523817f, 0.03636010f, -0.01309214f, 0.03168705f, 0.04387526f, 
    0.03935803f, -0.00303345f, 0.03554719f, -0.01937924f, 0.04375008f, -0.05167017f, 0.00777359f, 0.00268611f, 
    0.04297938f, 0.05678373f, 0.01384678f, 0.01724582f, -0.03601547f, -0.02414212f, -0.01263267f, 0.00287512f, 
    0.00965184f, 0.02185487f, -0.04159352f, 0.03229530f, -0.03368798f, -0.04104303f, 0.00991037f, 0.01936626f, 
    -0.03962518f, -0.01913554f, -0.01176729f, -0.00856018f, -0.05268313f, -0.02467413f, 0.00887975f, -0.03930779f, 
    0.00784840f, -0.03318388f, -0.01316833f, -0.03000454f, -0.00742781f, 0.03807117f, 0.00204672f, 0.01161013f, 
    -0.02919405f, -0.04393566f, 0.04454693f, 0.04246438f, 0.00616799f, 0.03036253f, 0.02306806f, -0.03728930f, 
    0.04394813f, 0.00465108f, -0.00251577f, -0.04747165f, -0.02927572f, -0.04967527f, -0.01162472f, 0.02241150f, 
    -0.03196551f, 0.00241122f, -0.00462886f, -0.00158358f, -0.02657145f, -0.02716868f, -0.03890024f, -0.03761958f, 
    0.03656603f, 0.04406572f, 0.00635051f, -0.00151998f, -0.02629670f, -0.05286096f, -0.04001677f, 0.02979286f, 
    0.04412350f, -0.02320826f, -0.01399446f, 0.01497994f, 0.00042724f, -0.00161424f, 0.02162718f, -0.01747604f, 
    -0.01572643f, -0.04508051f, 0.03333564f, 0.01952251f, 0.03201755f, 0.02743291f, -0.04741820f, 0.00220847f, 
    0.02548283f, -0.00537679f, 0.02002701f, 0.04326743f, -0.03900386f, -0.01326591f, -0.04764983f, 0.02996808f, 
    -0.00245221f, 0.02899818f, -0.04379506f, -0.03319155f, -0.00102633f, 0.02119515f, 0.02092792f, 0.03570602f, 
    0.04845009f, -0.03060290f, -0.02857032f, -0.03143879f, -0.01361300f, 0.02605798f, -0.03238505f, 0.00465841f, 
    -0.02276758f, -0.01947099f, -0.03863681f, 0.00054911f, -0.04321757f, -0.02745327f, -0.05249356f, -0.00940933f, 
    -0.00567246f, -0.00378946f, -0.00533905f, -0.02189689f, 0.04821817f, 0.01775702f, -0.00276228f, 0.03591045f, 
    -0.02997552f, -0.02974836f, -0.02759298f, -0.02491409f, -0.03998655f, -0.02512971f, -0.02892114f, -0.01284444f, 
    -0.04317603f, -0.01636219f, -0.02537966f, -0.04105938f, -0.00896026f, 0.01841829f, -0.01045018f, -0.04045932f, 
    0.03581795f, 0.01889477f, -0.04177525f, 0.00671043f, -0.00658406f, 0.04480154f, -0.00413759f, -0.00758368f, 
    0.00625821f, 0.03208769f, -0.01869999f, 0.02971995f, 0.00169906f, 0.02738308f, 0.00760893f, -0.02860535f, 
    0.02474357f, -0.01597777f, 0.01275940f, -0.05256860f, -0.03026230f, -0.02340667f, -0.04403958f, -0.03021653f, 
    -0.01303882f, 0.00357352f, -0.01335770f, 0.01038889f, 0.01853375f, -0.03370443f, 0.03774972f, -0.00516275f, 
    0.04047913f, 0.03425717f, 0.00990596f, -0.03920160f, 0.01768306f, 0.01550028f, 0.00393492f, 0.03629733f, 
    0.02094098f, -0.02587849f, 0.03155787f, -0.03119923f, -0.04049335f, -0.04040817f, -0.01017848f, -0.01351225f, 
    0.03668604f, 0.04241350f, 0.03469355f, -0.03601217f, -0.03359731f, 0.01712673f, -0.01938116f, -0.05336918f, 
    0.01233755f, 0.00471773f, 0.02405777f, 0.02852364f, -0.05032247f, -0.01809415f, -0.00628883f, -0.01212974f, 
    0.03203376f, -0.00685257f, -0.02243708f, -0.02380437f, 0.00930496f, -0.02960726f, -0.01907034f, -0.04801515f, 
    0.04125303f, -0.03715105f, 0.00949093f, 0.01392509f, -0.02860201f, -0.00626565f, -0.02589035f, -0.01814813f, 
    -0.00673098f, 0.04226535f, -0.01245702f, -0.01560433f, -0.03671244f, -0.02041095f, -0.02805789f, 0.01499481f, 
    -0.01545215f, 0.03464789f, -0.05069742f, 0.01707460f, -0.02922208f, 0.00998044f, -0.02242428f, 0.03463907f, 
    0.01061271f, -0.00949994f, -0.04232150f, 0.01181458f, -0.02871917f, 0.00589372f, 0.04680521f, 0.00276759f, 
    0.00100817f, -0.03496378f, 0.00175617f, 0.02182531f, 0.04233015f, -0.02430421f, 0.01080992f, 0.02323593f, 
    -0.02987129f, 0.01192572f, -0.02628668f, -0.00828402f, 0.00182616f, 0.02167860f, -0.01018232f, 0.02583245f, 
    -0.03311113f, -0.03455401f, -0.02168105f, 0.00570420f, -0.01972898f, -0.01096764f, 0.04351715f, -0.00453800f, 
    -0.03364222f, -0.03716967f, -0.00252811f, -0.00656178f, -0.01849878f, 0.01058828f, 0.01777464f, 0.01850179f, 
    -0.02678164f, 0.00730066f, 0.04031804f, -0.01537542f, -0.03062052f, -0.01648814f, 0.02705941f, -0.03286601f, 
    0.02177488f, -0.04123712f, -0.03222251f, -0.04085672f, 0.00349081f, 0.02349988f, -0.03913485f, -0.05112400f, 
    -0.00479737f, -0.01834987f, 0.03635883f, -0.01793690f, -0.03470874f, 0.04271274f, -0.02358465f, 0.04202344f, 
    -0.03845915f, 0.00757582f, 0.00274338f, -0.04387714f, -0.05037425f, 0.05549116f, 0.00669840f, -0.02787084f, 
    0.13439424f, 0.06854901f, 0.16537203f, 0.28265521f, -0.00220607f, 0.00406014f, -0.13978259f, -0.05551223f, 
    -0.00741964f, -0.00596775f, 0.01121233f, -0.04584191f, 0.00061724f, -0.03532958f, -0.07227600f, -0.19955017f, 
    0.09915508f, -0.00494595f, -0.13081434f, 0.16195111f, -0.02697979f, -0.09415963f, -0.05590772f, -0.07420702f, 
    0.26178804f, -0.00055383f, 0.14337197f, -0.01786057f, 0.04872826f, 0.08242916f, 0.01574546f, -0.05421412f, 
    0.11540926f, 0.04686388f, 0.05095778f, 0.06898415f, 0.33342525f, -0.06779179f, 0.30186778f, 0.12433867f, 
    -0.04900151f, -0.06157087f, 0.02582451f, -0.04223810f, 0.03067652f, -0.07561766f, 0.01737409f, -0.00211973f, 
    -0.02315018f, -0.14642076f, -0.24542451f, -0.27118552f, -0.06588589f, 0.00275094f, 0.00602649f, -0.00165531f, 
    0.06241300f, 0.01825990f, -0.05768460f, 0.10810696f, 0.01118219f, -0.08121327f, 0.02776011f, -0.14445059f, 
    0.15426196f, 0.04719712f, -0.21123676f, 0.02055493f, -0.02660966f, 0.02184376f, -0.03012032f, -0.07158785f, 
    0.03479324f, -0.00000269f, 0.21555044f, 0.09238640f, -0.01202584f, 0.02179627f, 0.00392354f, 0.05088016f, 
    -0.02560687f, 0.01266250f, 0.08561920f, 0.00798102f, 0.08085319f, 0.20959738f, 0.08067142f, 0.31262496f, 
    -0.02879140f, -0.03603694f, -0.09146197f, -0.07173382f, -0.02681487f, 0.01132175f, 0.15147308f, -0.09172776f, 
    0.08561487f, 0.12241253f, 0.01229525f, 0.07847531f, -0.07033668f, 0.04317703f, 0.11348484f, 0.06196482f, 
    0.02856653f, 0.10590960f, 0.05145715f, 0.09368160f, -0.08569600f, -0.09252635f, -0.01582070f, -0.08869471f, 
    -0.00477228f, -0.02129790f, 0.18563806f, -0.09322115f, 0.11775971f, 0.02253748f, -0.08212506f, -0.13051844f, 
    0.01871576f, 0.09558848f, -0.04022910f, 0.05072134f, 0.12804775f, 0.02777440f, -0.06114021f, -0.12109493f, 
    -0.08907437f, -0.04451944f, -0.04613159f, -0.12484093f, 0.05838469f, -0.11821524f, -0.08942109f, 0.16299817f, 
    -0.11714710f, -0.15707424f, -0.08846090f, 0.01651115f, 0.07339940f, 0.05650684f, 0.02013869f, 0.04682277f, 
    0.32931188f, 0.35591638f, -0.34964687f, 0.09687114f, 0.08879631f, -0.05245879f, 0.13574210f, 0.06308650f, 
    -0.13876472f, 0.01396813f, -0.09272413f, -0.05346629f, 0.01296181f, 0.05169807f, 0.07185491f, 0.15724595f, 
    0.09118451f, 0.04424484f, -0.01535978f, -0.00212918f, 0.09462237f, 0.01991592f, 0.11319521f, -0.02151727f, 
    -0.19724184f, -0.08568452f, 0.32284713f, -0.36748502f, 0.04083421f, 0.04767667f, 0.07598381f, 0.09895729f, 
    0.00918400f, 0.07880447f, 0.02729465f, 0.00926950f, 0.09236859f, 0.02462387f, 0.16744329f, 0.15954822f, 
    0.01958013f, 0.07637660f, -0.03191731f, 0.05973582f, 0.06351586f, 0.07556115f, 0.09953102f, 0.13274895f, 
    -0.21436879f, -0.15586765f, -0.12641658f, -0.23437393f, 0.04176796f, -0.08053806f, -0.06212002f, 0.14472608f, 
    -0.00282866f, 0.01915925f, 0.00139877f, -0.01147863f, 0.00499496f, 0.03631402f, -0.09368791f, 0.08022634f, 
    0.13187447f, -0.01084694f, 0.07710160f, 0.13143313f, -0.04306377f, 0.03889481f, 0.05978840f, 0.02234921f, 
    -0.08039533f, 0.07644024f, -0.04515630f, -0.11815998f, 0.01680978f, 0.10225641f, -0.04065553f, -0.05734815f, 
    0.00953270f, -0.05987742f, -0.12249590f, -0.10616206f, 0.32193714f, -0.04328341f, 0.09308845f, -0.00128008f, 
    -0.07070814f, -0.04652989f, -0.03042433f, -0.06093769f, 0.07861530f, 0.04577868f, -0.04210138f, -0.00270487f, 
    0.20308889f, 0.21986288f, 0.05709945f, 0.06002431f, 0.13104771f, 0.02186866f, 0.05199389f, -0.02541224f, 
    -0.03883598f, -0.06204911f, -0.02583515f, -0.00968145f, -0.31046665f, -0.06038782f, -0.10320142f, -0.36652312f, 
    -0.13932778f, -0.14858386f, -0.02039463f, -0.09807017f, -0.01353121f, -0.09647441f, 0.02401658f, -0.01296538f, 
    0.17352375f, -0.04042994f, 0.12234513f, 0.04046169f, 0.09611244f, 0.00723274f, -0.02143556f, 0.11206994f, 
    -0.13147216f, 0.00919404f, 0.12015112f, 0.07064966f, 0.08055212f, -0.07899184f, 0.13585889f, 0.18754421f, 
    -0.12439182f, 0.03972432f, 0.01489558f, -0.09011437f, 0.02034729f, -0.00286542f, -0.12443010f, -0.02730838f, 
    -0.12576893f, -0.12363306f, 0.03010594f, -0.04528275f, 0.06028296f, 0.00909579f, -0.09823190f, 0.06596222f, 
    0.10555969f, -0.01568683f, 0.14682439f, 0.17893703f, 0.10247012f, 0.07397943f, -0.11357539f, -0.04710441f, 
    0.01482585f, 0.05628565f, -0.07675784f, -0.02108743f, 0.01610690f, -0.02174095f, -0.05254156f, -0.04917131f, 
    -0.13841362f, 0.10896841f, 0.17130485f, 0.02733329f, 0.03926648f, -0.17971860f, 0.04242847f, 0.17690553f, 
    -0.01846378f, -0.03022751f, 0.03822678f, -0.00167360f, -0.35313341f, 0.02023060f, -0.05687205f, -0.03385472f, 
    0.11821491f, -0.31346527f, 0.11555842f, -0.05494620f, -0.01701091f, -0.06019377f, -0.11793974f, -0.06413072f, 
    -0.08438596f, -0.02485012f, -0.52090734f, -0.23538034f, 0.01776369f, -0.04833351f, -0.08525053f, -0.03168426f, 
    0.09305173f, -0.03075887f, 0.06276121f, 0.03528773f, 0.18486057f, 0.05972844f, 0.00300436f, -0.08470384f, 
    -0.01315246f, 0.12627442f, 0.03447363f, 0.04678018f, 0.07301358f, 0.08633934f, -0.11018131f, -0.00144847f, 
    0.18285616f, 0.05918251f, 0.10798698f, 0.13510975f, 0.03192572f, 0.06441148f, 0.09274960f, -0.09216211f, 
    -0.10690373f, 0.02752043f, 0.00745466f, 0.00631729f, 0.06094885f, -0.03679054f, -0.07374858f, 0.00092124f, 
    -0.04654296f, 0.03995013f, 0.01063813f, 0.09166086f, 0.00626864f, 0.09458795f, 0.14754108f, 0.01386705f, 
    0.38051599f, 0.01293789f, 0.20068340f, 0.12354027f, 0.07542501f, 0.08080335f, -0.05514312f, 0.05529779f, 
    0.15587257f, 0.01800205f, 0.00178902f, 0.00704549f, 0.04755219f, -0.12807387f, -0.05877681f, -0.14167623f, 
    0.01081469f, -0.12785934f, -0.17630067f, 0.13931695f, -0.12033811f, -0.00806259f, 0.05684195f, 0.00008684f, 
    0.10228732f, 0.01398660f, 0.16855976f, -0.09262693f, 0.07936241f, -0.00427649f, -0.01686952f, -0.02368694f, 
    0.13360280f, 0.08392961f, 0.07088225f, 0.04701595f, 0.53693908f, -0.06502216f, 0.20300198f, 0.02203540f, 
    0.10253263f, -0.06250517f, -0.16657980f, 0.02691077f, -0.11675135f, -0.16024573f, -0.01983329f, -0.02956265f, 
    -0.15421034f, -0.20358285f, -0.24304849f, -0.16881551f, -0.02894489f, -0.02440918f, -0.02598475f, 0.03540053f, 
    -0.01901100f, 0.01558690f, -0.05973082f, -0.00255468f, -0.05955827f, -0.09214313f, -0.05620150f, 0.00303241f, 
    0.01871684f, 0.11182675f, -0.05871696f, 0.13752618f, -0.02971485f, -0.02871851f, -0.02447062f, 0.04798624f, 
    0.02036829f, -0.04420173f, 0.17973721f, -0.04671954f, -0.01103856f, -0.02107812f, -0.01845573f, 0.05778908f, 
    -0.00857429f, 0.06927121f, 0.12051886f, 0.08526787f, 0.34612212f, 0.29585573f, 0.07857738f, 0.08174112f, 
    0.06610139f, 0.07497401f, -0.08305430f, -0.09886289f, -0.05243391f, 0.02267531f, 0.08571681f, 0.04236397f, 
    -0.20437583f, 0.07728615f, -0.23845923f, -0.04368839f, -0.04660180f, -0.03968225f, 0.10578083f, 0.03281378f, 
    0.03225508f, 0.15103748f, 0.11970191f, -0.02684692f, -0.00976780f, -0.03789447f, -0.01896767f, 0.05153579f, 
    -0.03377803f, 0.04859163f, 0.08233898f, -0.01938478f, 0.00345814f, -0.13824618f, 0.04128762f, 0.01471924f, 
    0.05802225f, 0.02452803f, 0.08368522f, 0.03108723f, 0.03229126f, -0.06904849f, 0.01106548f, -0.03999886f, 
    -0.02460229f, -0.08634973f, -0.17236532f, -0.01985468f, -0.02906443f, -0.00011533f, -0.06126108f, 0.06285532f, 
    -0.20323390f, -0.13221358f, -0.13386817f, 0.07084096f, -0.03440366f, -0.17142528f, -0.04083980f, 0.04347634f, 
    0.05548571f, 0.28537863f, -0.39513588f, 0.01011511f, -0.05559087f, -0.14413397f, 0.22114462f, -0.14689143f, 
    -0.02586939f, 0.05317060f, 0.00154437f, -0.00927290f, 0.03308203f, -0.02215436f, 0.10093747f, 0.09099232f, 
    0.09896833f, 0.02923097f, -0.02871081f, -0.04535404f, 0.13630812f, 0.14398248f, 0.05667374f, -0.06601868f, 
    -0.20624654f, -0.02120576f, 0.11907236f, -0.30530128f, 0.02221903f, 0.03183954f, 0.26235729f, 0.14596769f, 
    0.07404898f, 0.11719710f, 0.11119157f, -0.05033404f, 0.11524101f, 0.08961295f, 0.28971919f, 0.05193533f, 
    0.08480585f, 0.01410825f, -0.07334260f, 0.00624333f, 0.34432569f, 0.07869747f, 0.14709336f, 0.21501847f, 
    -0.18024448f, -0.08883287f, -0.10506861f, -0.16448992f, 0.07373995f, 0.00141189f, -0.01615462f, 0.11807552f, 
    -0.05336142f, 0.06373034f, -0.02189940f, 0.04368778f, -0.30263427f, 0.02830185f, -0.01356720f, 0.09570495f, 
    0.05514237f, 0.01096067f, 0.08579990f, 0.09515146f, -0.05209617f, -0.04650700f, 0.00517661f, -0.10842866f, 
    0.01541786f, 0.11453616f, -0.05847666f, -0.08091649f, 0.03888336f, -0.00150893f, -0.22791290f, -0.06529178f, 
    0.00754619f, -0.02200564f, -0.01433155f, -0.04650756f, 0.33933923f, 0.09263011f, -0.00044854f, -0.05865351f, 
    0.00166751f, 0.05368163f, 0.04983193f, 0.01804386f, 0.20476928f, 0.16885956f, 0.03930349f, 0.01068776f, 
    0.10833755f, 0.24912037f, -0.06319423f, 0.00641578f, -0.04823035f, 0.06640490f, 0.05212622f, -0.06269624f, 
    0.03747702f, -0.07356496f, 0.06954952f, 0.01500505f, -0.11722441f, -0.04517215f, -0.02268473f, -0.26967275f, 
    -0.16622952f, -0.03040580f, 0.06408215f, -0.04680992f, -0.03993705f, -0.09406425f, -0.10169787f, -0.12006214f, 
    0.05984055f, 0.02509034f, 0.19429418f, -0.01206367f, 0.04226765f, -0.11784322f, 0.07198396f, 0.13363078f, 
    0.01504679f, 0.02592186f, 0.06151164f, 0.14893509f, 0.02178964f, 0.04060524f, 0.05916283f, 0.00397343f, 
    -0.12287766f, 0.00944627f, -0.04655552f, -0.04749409f, 0.03137525f, -0.06678934f, -0.07325298f, -0.04784841f, 
    -0.12765205f, -0.08948408f, 0.05087451f, -0.07629404f, 0.17463180f, 0.03131571f, 0.02983353f, 0.12755620f, 
    -0.05619385f, -0.13720238f, -0.07761446f, 0.12637453f, 0.18607251f, 0.10211761f, -0.05539986f, -0.00755852f, 
    -0.08982538f, -0.03435539f, -0.05714519f, 0.01536423f, 0.06208685f, 0.01414968f, 0.01956682f, -0.04464058f, 
    -0.44581768f, 0.20327698f, 0.24464713f, 0.15134935f, 0.12802671f, 0.00529704f, 0.04450764f, 0.09131692f, 
    -0.14308231f, -0.26042005f, 0.07012441f, -0.01314781f, -0.07307807f, 0.22103658f, -0.00506985f, -0.01559993f, 
    0.06326921f, -0.23730430f, -0.09534041f, -0.01305337f, -0.00677161f, -0.02303427f, 0.05399523f, 0.02684451f, 
    0.04108785f, 0.01015124f, -0.38325003f, -0.32526383f, -0.06286006f, -0.21270952f, -0.27467519f, -0.04210779f, 
    -0.10922506f, -0.08534437f, 0.08246480f, -0.04204394f, 0.08949778f, 0.00076038f, -0.00259226f, -0.05842706f, 
    0.04256438f, 0.16914360f, 0.11129326f, 0.06849730f, 0.07702632f, 0.02736200f, 0.08972597f, 0.05937312f, 
    0.21054243f, 0.06251479f, 0.00018743f, 0.14842010f, -0.06883626f, 0.06821124f, -0.00566885f, -0.01486536f, 
    0.04948206f, 0.08231600f, 0.04614885f, -0.01920845f, 0.02646458f, -0.00302850f, -0.14387313f, 0.11392006f, 
    -0.10667699f, 0.07182321f, -0.12033813f, -0.04389428f, -0.03601457f, 0.16246405f, 0.04947687f, 0.10301003f, 
    -0.07537927f, 0.15438905f, -0.06063690f, 0.04001041f, 0.07584675f, 0.13209933f, -0.07376707f, 0.03740517f, 
    -0.04263741f, -0.02829808f, 0.02014103f, 0.17731898f, 0.45682904f, 0.32791948f, 0.03562796f, 0.33500710f, 
    0.10317049f, 0.01116550f, 0.08922913f, 0.07814315f, -0.00163072f, -0.00179353f, 0.01745255f, 0.02698598f, 
    -0.18680827f, -0.12971525f, -0.13245359f, 0.01951846f, -0.03059664f, -0.03752688f, -0.06389095f, -0.00927529f, 
    -0.01862438f, 0.02364056f, 0.02765710f, 0.03256232f, 0.04447384f, 0.18232387f, -0.05758740f, -0.11373597f, 
    0.00608263f, 0.08016831f, 0.11651418f, -0.03838257f, -0.01863645f, -0.10786745f, 0.02470249f, -0.09684732f, 
    0.25423628f, 0.15003529f, 0.16408026f, 0.13168265f, 0.06829449f, -0.06992143f, 0.02290469f, -0.02415940f, 
    -0.09494580f, 0.02471658f, 0.01283148f, 0.01565271f, -0.08874849f, -0.00816925f, 0.18277778f, -0.11311306f, 
    -0.01771777f, 0.08865006f, -0.09549022f, 0.00798761f, -0.03198553f, -0.06506582f, -0.01121111f, 0.07678448f, 
    -0.08181068f, -0.11240107f, -0.10592076f, 0.01703655f, -0.01848839f, 0.03800782f, -0.01890113f, -0.05376259f, 
    -0.05302289f, -0.16035059f, -0.00432316f, -0.04937989f, -0.18826082f, 0.00180967f, -0.09234803f, -0.13413733f, 
    -0.06001324f, 0.02712940f, -0.10362480f, -0.04379880f, 0.07150727f, -0.01848411f, 0.07684579f, 0.01431204f, 
    0.09131407f, 0.11351278f, 0.08283629f, 0.16498370f, -0.11246887f, -0.00294122f, 0.11144517f, 0.00133075f, 
    0.04196199f, 0.05483209f, 0.05074172f, 0.05409951f, -0.04497194f, 0.03141858f, 0.00507720f, -0.05203627f, 
    -0.03128266f, -0.12482315f, 0.02966055f, -0.05637225f, -0.09901921f, -0.04033163f, -0.02609493f, -0.05928352f, 
    0.10856882f, 0.06779078f, 0.16981786f, 0.05640412f, -0.07044464f, 0.05017592f, -0.00008283f, -0.02297727f, 
    -0.00254587f, -0.06277581f, 0.02386906f, 0.02593147f, 0.03096596f, 0.02182980f, -0.06316589f, 0.04603541f, 
    0.09912845f, -0.00551604f, -0.14765997f, 0.02423356f, -0.12950075f, 0.00372542f, -0.13337864f, 0.02032073f, 
    0.29965031f, 0.08662847f, -0.02430657f, 0.22245105f, 0.03883964f, -0.05985321f, -0.05652166f, 0.04293789f, 
    0.02185443f, 0.06270148f, -0.02876649f, -0.09338056f, -0.22949260f, -0.11046331f, 0.00277587f, -0.12711021f, 
    -0.10399105f, -0.04082250f, 0.02809033f, -0.05961496f, -0.03324970f, -0.00068147f, -0.00995557f, 0.07314961f, 
    -0.09655703f, -0.20802411f, 0.11424085f, 0.02387907f, 0.02652850f, -0.01072333f, -0.02375360f, 0.14042123f, 
    0.01262274f, -0.01175080f, 0.13652258f, 0.09477627f, -0.21456251f, -0.16573340f, -0.13965394f, -0.08349248f, 
    -0.00692651f, -0.01952503f, -0.04628593f, -0.07122833f, -0.00561152f, -0.06466408f, -0.06498028f, 0.00320502f, 
    0.37623268f, 0.04386838f, 0.15176387f, 0.12195625f, -0.06077082f, 0.03519867f, -0.03028068f, 0.08594795f, 
    0.08336539f, 0.02309849f, 0.06773003f, 0.00420843f, 0.11045405f, 0.28469950f, 0.19122104f, 0.18460198f, 
    -0.07255843f, 0.09588749f, -0.04634488f, 0.07577136f, -0.03512110f, 0.05860606f, 0.05197588f, 0.01142458f, 
    -0.11682812f, 0.01781370f, -0.02302915f, -0.12595722f, 0.14400735f, -0.00749785f, -0.01799639f, -0.00962344f, 
    0.02321768f, 0.02370385f, -0.00817713f, -0.00525786f, 0.00196896f, -0.22004727f, -0.07171255f, 0.05240159f, 
    -0.00709852f, -0.04455030f, -0.09294160f, 0.02199513f, 0.14449903f, -0.01571382f, 0.09406213f, 0.10181651f, 
    0.05788131f, 0.05229890f, -0.10793622f, 0.14388801f, -0.16334476f, -0.00926180f, -0.05017101f, -0.10394151f, 
    -0.07182300f, -0.04100664f, -0.05308642f, 0.08419601f, 0.40397346f, -0.05419854f, 0.10978844f, -0.11022638f, 
    0.10485352f, -0.00533467f, 0.16964342f, 0.07812057f, -0.08445467f, -0.00573564f, -0.01601804f, 0.00756003f, 
    -0.01800113f, -0.11079727f, -0.08749711f, -0.11038009f, -0.13023096f, 0.03556093f, 0.02537587f, 0.03518140f, 
    0.00335187f, -0.06717937f, -0.03100857f, 0.03741750f, -0.20078844f, -0.01844262f, -0.00205353f, 0.05305652f, 
    -0.20268106f, -0.13750285f, 0.00535098f, -0.00591634f, -0.05964848f, 0.12731421f, 0.01392638f, -0.03176497f, 
    0.06294046f, 0.12618980f, -0.12328476f, 0.02141755f, 0.09290631f, 0.13724227f, 0.04579924f, 0.03692821f, 
    -0.00714533f, 0.04154073f, 0.08949477f, 0.18599199f, -0.04400503f, 0.00674162f, -0.01688830f, -0.03272067f, 
    0.00311759f, -0.03725800f, -0.00810313f, -0.04268765f, -0.06543110f, -0.04956880f, 0.09686702f, -0.08140527f, 
    0.24500738f, 0.20687874f, 0.38623214f, 0.27391881f, 0.18492466f, 0.03348732f, 0.02480362f, 0.13699238f, 
    -0.01553116f, 0.00778446f, -0.02860105f, 0.08361965f, 0.21713826f, 0.26816434f, 0.42891288f, 0.01087284f, 
    -0.00190962f, 0.15384707f, 0.01575558f, 0.24097131f, 0.02030586f, -0.02329149f, -0.04242277f, -0.10833881f, 
    0.11041401f, 0.06707665f, -0.07601134f, -0.02696905f, 0.10485730f, -0.03205555f, 0.06742591f, 0.04812221f, 
    -0.07714199f, 0.11608240f, -0.05845143f, -0.07189415f, -0.00609788f, 0.00448119f, -0.09161992f, -0.11274365f, 
    -0.02365636f, -0.03427108f, 0.06707507f, 0.02312510f, -0.01893832f, 0.08545912f, 0.05778890f, -0.00365880f, 
    -0.19662249f, -0.26018202f, -0.04416897f, -0.18107989f, -0.10447998f, -0.04737082f, -0.01534261f, -0.08401970f, 
    0.06161220f, 0.01398569f, -0.03156462f, 0.01791033f, 0.03708251f, 0.25233722f, 0.29109165f, 0.06268071f, 
    -0.00066902f, 0.09091956f, 0.11534838f, -0.06403070f, 0.04056584f, 0.07933959f, -0.00804611f, -0.00980744f, 
    -0.07799558f, -0.22623886f, 0.08716150f, 0.00937115f, -0.01595761f, 0.07557078f, -0.07290207f, -0.06021804f, 
    0.02303995f, -0.01278831f, 0.02860288f, 0.03499550f, -0.12562801f, -0.00935884f, 0.07407644f, 0.06204856f, 
    -0.04291579f, -0.12158366f, -0.10845446f, -0.10212938f, -0.04821816f, -0.04486904f, -0.05520359f, -0.10625751f, 
    0.01284727f, 0.09808072f, -0.10984865f, -0.07196252f, -0.00074880f, 0.10375638f, 0.01897924f, -0.01899390f, 
    -0.00045163f, 0.07446851f, 0.19638017f, 0.18226863f, -0.07178094f, -0.07553708f, -0.13630629f, 0.18804435f, 
    0.05564584f, 0.11019953f, 0.00506091f, 0.09758237f, 0.04833083f, 0.13669930f, 0.08588346f, 0.08220249f, 
    -0.18431622f, -0.00329824f, 0.01416377f, 0.14125103f, -0.09192825f, 0.00502822f, -0.04115885f, -0.08792565f, 
    -0.05077903f, 0.01918434f, 0.06179207f, -0.13230723f, -0.21056202f, -0.07667008f, 0.19988932f, 0.00886656f, 
    -0.03934397f, 0.05626468f, 0.02952554f, 0.03733807f, 0.05686891f, -0.09530575f, -0.05707296f, 0.04628178f, 
    0.03051125f, 0.07929247f, -0.04391137f, -0.05161954f, -0.01921409f, -0.11607008f, -0.07482623f, -0.04230067f, 
    0.26123679f, 0.15453024f, 0.13382514f, 0.10197110f, -0.05515713f, -0.18566042f, -0.02825793f, -0.00232695f, 
    -0.06358559f, -0.02917839f, 0.05916372f, 0.03646483f, 0.08244164f, 0.07867645f, 0.03653332f, 0.08886463f, 
    -0.01309735f, -0.02889168f, 0.16840111f, 0.00269176f, 0.28203779f, -0.02535032f, -0.08580900f, -0.07206327f, 
    0.09473009f, 0.06725247f, 0.08439612f, 0.12687968f, 0.08397888f, -0.22475764f, -0.17839316f, 0.08081660f, 
    -0.03550520f, 0.05737052f, 0.02998857f, 0.01129664f, 0.01344884f, 0.00633315f, 0.04288409f, 0.06946284f, 
    -0.01346539f, 0.02072968f, 0.04711963f, -0.03562051f, 0.14460365f, -0.03255074f, 0.02733003f, 0.21438274f, 
    -0.09399296f, -0.00943228f, 0.00470296f, -0.21262847f, -0.30807099f, 0.00215225f, 0.26080391f, -0.06337596f, 
    -0.09190048f, 0.00815195f, -0.01950202f, -0.02520505f, 0.02898834f, 0.03040769f, 0.08918748f, 0.07050432f, 
    0.09352595f, -0.03209475f, 0.41407710f, 0.03154289f, 0.03577036f, 0.10134297f, -0.08095282f, 0.04938445f, 
    -0.07747418f, -0.15475966f, -0.01225217f, -0.20640641f, 0.14417839f, 0.05149592f, -0.16968025f, -0.14757103f, 
    -0.01267576f, -0.04354378f, -0.12418018f, 0.03439801f, 0.11625804f, 0.00281038f, 0.07853915f, 0.10783082f, 
    0.05700143f, 0.28937373f, -0.05602241f, -0.02747743f, 0.08376309f, 0.04676310f, 0.06774273f, 0.08342564f, 
    0.10415769f, 0.05587603f, 0.12821764f, -0.02485700f, -0.12350493f, -0.08391732f, -0.10375819f, -0.12941684f, 
    -0.05090804f, -0.01243144f, 0.09778250f, 0.01139024f, 0.15358604f, 0.11428792f, 0.02754871f, 0.09110783f, 
    -0.04302939f, 0.10906321f, 0.03145495f, 0.06055576f, -0.00434581f, -0.08072685f, -0.05933167f, -0.09522899f, 
    -0.10293000f, -0.02118416f, -0.08604540f, -0.09585250f, -0.11904103f, -0.12214996f, 0.06607976f, 0.02118262f, 
    -0.16902871f, 0.00451294f, -0.05864034f, -0.05301927f, 0.05505348f, 0.00734102f, -0.01680648f, -0.01341546f, 
    0.08365778f, -0.01372831f, 0.00632816f, 0.15342142f, 0.03988113f, 0.03799433f, 0.16426940f, 0.06628910f, 
    0.01576563f, 0.00548067f, -0.08286306f, -0.00891437f, -0.21466102f, 0.30741882f, 0.26616859f, 0.02961962f, 
    0.00546259f, -0.01337980f, -0.00338376f, 0.02860326f, -0.20175155f, -0.00095737f, -0.04914792f, 0.06118283f, 
    0.07049100f, 0.02454597f, 0.13285221f, 0.00514618f, 0.14080605f, 0.00088615f, 0.08188226f, -0.01228145f, 
    -0.06595832f, 0.03992730f, 0.09821416f, -0.10922753f, -0.05617230f, 0.07027353f, 0.18613920f, 0.21111059f, 
    0.02153101f, 0.03203162f, -0.05290456f, 0.00175076f, -0.00733050f, 0.01827068f, 0.07503096f, 0.00797540f, 
    -0.12453546f, -0.14855583f, 0.26460150f, -0.21382336f, -0.12700620f, 0.02744014f, 0.00888500f, -0.02228610f, 
    0.15971421f, -0.11650695f, 0.06882758f, 0.12546408f, 0.13656716f, 0.17769477f, -0.01909473f, 0.23723063f, 
    0.18808430f, 0.09263628f, 0.01978909f, 0.02254030f, -0.03819019f, 0.01490147f, 0.06716304f, 0.04152996f, 
    -0.18360820f, -0.28653613f, 0.04415153f, 0.11765958f, -0.11064990f, -0.00328690f, -0.12825924f, -0.17852472f, 
    -0.00606288f, -0.00297455f, 0.01434090f, 0.01410756f, 0.11091508f, 0.07303180f, 0.06184420f, 0.04323125f, 
    0.10116092f, 0.07737702f, 0.14701593f, 0.11831743f, -0.07930817f, 0.01961434f, -0.19388171f, -0.02706093f, 
    -0.05398208f, -0.02538123f, 0.00137402f, 0.09964874f, -0.11589160f, 0.00492277f, 0.00006238f, -0.18411398f, 
    0.02816996f, 0.06558321f, 0.04840049f, -0.02963259f, 0.06897739f, -0.23352365f, -0.00483242f, 0.03241534f, 
    0.06267773f, -0.03193232f, -0.09328555f, 0.13088140f, 0.01950054f, -0.11638878f, -0.06542986f, -0.06700370f, 
    0.03545160f, 0.16400240f, 0.36572328f, 0.21297085f, -0.12318686f, -0.04417667f, 0.14900927f, 0.08164774f, 
    0.02456231f, -0.06880005f, 0.07340021f, 0.08864554f, 0.01607399f, 0.05616300f, -0.11956865f, 0.26393649f, 
    -0.05158977f, 0.08735026f, 0.06717988f, -0.08896246f, 0.13534229f, -0.02176223f, 0.00856973f, 0.05304536f, 
    0.22898947f, 0.14315324f, -0.12547180f, 0.12047100f, 0.12183164f, 0.01801364f, -0.11365888f, 0.00079322f, 
    -0.02395838f, -0.03417933f, -0.06569096f, -0.09445125f, -0.09937066f, -0.18775870f, -0.14894944f, 0.05184490f, 
    -0.00347543f, 0.02112649f, 0.02471810f, -0.00103330f, 0.06758372f, 0.12429925f, 0.07895499f, 0.29325232f, 
    0.01182671f, -0.14540669f, -0.04024534f, 0.09557106f, 0.03760341f, -0.05358251f, 0.06027362f, 0.00395225f, 
    -0.00398007f, 0.04260422f, -0.08500424f, -0.08819472f, -0.00861174f, 0.14056745f, 0.22836939f, -0.08643973f, 
    -0.00088929f, 0.14859469f, 0.12205864f, -0.00356252f, -0.02067901f, -0.09555240f, -0.07368816f, -0.01519273f, 
    -0.11458856f, 0.00768908f, -0.19589573f, -0.12049129f, -0.04175705f, 0.05982368f, -0.01544236f, -0.01269887f, 
    0.07958330f, -0.04503963f, 0.10949761f, -0.13018946f, -0.20059693f, -0.06150293f, -0.02305490f, 0.01830923f, 
    0.05807172f, 0.04448019f, -0.08653052f, 0.05719447f, -0.09437557f, -0.01198520f, 0.09867551f, 0.12822968f, 
    -0.02371785f, 0.20675613f, 0.11686665f, 0.02569077f, -0.03636878f, -0.00340130f, -0.04743800f, 0.01610607f, 
    -0.00325620f, -0.02802035f, 0.03927086f, 0.03954282f, 0.25131738f, 0.04743453f, -0.09406549f, -0.07112330f, 
    -0.02279021f, -0.00894896f, 0.04387096f, -0.04928735f, 0.07089023f, -0.02896880f, -0.04301038f, -0.17002565f, 
    0.02529754f, -0.03109133f, -0.12467653f, 0.01891476f, -0.00782545f, 0.00189428f, 0.00493770f, -0.01229668f, 
    0.17451949f, 0.08606869f, 0.00535846f, 0.21454938f, 0.00123847f, -0.27172405f, -0.04858327f, 0.15479384f, 
    0.01052564f, -0.04024726f, 0.00126028f, -0.00938539f, 0.04583655f, -0.05017278f, -0.08162173f, -0.01489163f, 
    -0.11238322f, -0.06522963f, 0.27406469f, 0.02336478f, 0.13767764f, 0.01441110f, -0.16481243f, -0.05287497f, 
    0.03961837f, 0.01756866f, 0.08785692f, 0.10732759f, 0.00293325f, -0.09976935f, 0.01767037f, 0.09339475f, 
    0.03425421f, -0.13717578f, -0.18546730f, 0.01651234f, 0.01026335f, 0.05833418f, -0.05298414f, 0.01430799f, 
    0.03764252f, 0.15254387f, 0.00477437f, -0.03531593f, 0.11601418f, 0.02599740f, 0.04702726f, -0.03059234f, 
    0.03769591f, -0.08664799f, 0.04902404f, -0.07838080f, -0.07736571f, -0.06009126f, -0.01449567f, -0.03410731f, 
    0.00683016f, -0.06498981f, 0.06863993f, -0.01434779f, -0.02183406f, 0.07028753f, 0.08337729f, 0.09978784f, 
    0.20199955f, -0.01537513f, 0.50559330f, 0.10602985f, 0.06779097f, -0.08732684f, -0.22446345f, 0.00249036f, 
    0.02586463f, -0.13470148f, -0.01579855f, -0.10228112f, 0.10710070f, -0.05095235f, -0.14428592f, 0.11302137f, 
    0.00431696f, -0.06866965f, -0.05545693f, -0.00804764f, 0.00558123f, -0.07183412f, 0.04804453f, 0.18813929f, 
    -0.01179594f, 0.08984989f, -0.04373218f, -0.04385590f, 0.06262238f, 0.12826048f, -0.12328642f, -0.00058848f, 
    0.04299359f, 0.01447745f, -0.01922766f, 0.21938287f, -0.02449341f, -0.10525607f, -0.15721734f, -0.02107757f, 
    -0.01002403f, -0.04338726f, 0.09675402f, 0.09312540f, 0.02744293f, -0.02811395f, 0.06281038f, 0.07797772f, 
    0.06078249f, 0.17119579f, -0.21881314f, 0.09538455f, 0.00902575f, 0.05547875f, 0.10386037f, -0.00767263f, 
    -0.02876478f, -0.03178670f, -0.00460657f, -0.15097065f, 0.07771769f, -0.09819393f, 0.18638895f, -0.12546848f, 
    -0.06899828f, 0.03882387f, 0.05405734f, -0.05588150f, 0.02939631f, -0.00786093f, 0.00309007f, 0.01706359f, 
    0.04780913f, -0.07524443f, -0.08716518f, 0.06019179f, 0.04748073f, 0.05241174f, 0.12590875f, 0.04135543f, 
    -0.02401026f, -0.01759067f, -0.06917930f, -0.09046933f, -0.19861566f, 0.06838612f, 0.07436252f, -0.09446938f, 
    0.03369368f, 0.04834530f, -0.10198362f, 0.02534224f, -0.13799056f, -0.04310994f, -0.09687420f, -0.03582426f, 
    -0.07665364f, -0.05640121f, 0.46713653f, 0.12227074f, 0.14820755f, -0.04091368f, -0.06888096f, -0.01671013f, 
    -0.02613237f, -0.07679853f, 0.03992965f, 0.00009821f, 0.03607348f, 0.15416978f, 0.16402937f, 0.08546413f, 
    0.02071473f, -0.10914310f, -0.04504091f, -0.01870527f, 0.03604726f, 0.02567703f, -0.00136652f, 0.14866123f, 
    0.10917392f, -0.01538962f, 0.10715970f, -0.04043758f, -0.04773166f, 0.05622902f, -0.09496356f, 0.02220331f, 
    0.03086298f, -0.05079546f, 0.05627902f, -0.00744590f, -0.18066809f, -0.14687799f, 0.14247201f, 0.26289889f, 
    0.05620136f, -0.02616604f, -0.09257588f, 0.06891480f, 0.05603062f, -0.03439715f, 0.21731035f, 0.04305848f, 
    -0.21782914f, -0.04822352f, 0.17532024f, 0.04240511f, -0.04060213f, 0.04986259f, -0.07262426f, 0.00562546f, 
    -0.01175943f, 0.07463459f, 0.00000457f, 0.06423397f, 0.10914195f, 0.01788239f, 0.08569775f, 0.04298855f, 
    -0.02432700f, 0.01203600f, -0.02613965f, 0.12372070f, 0.05645068f, -0.05993526f, -0.12079962f, 0.07313506f, 
    0.25946501f, -0.09565567f, 0.04015160f, -0.01468806f, 0.06528132f, 0.05190708f, 0.06901352f, -0.19381697f, 
    0.00379413f, 0.01043453f, 0.10640709f, -0.00632145f, 0.30514443f, -0.29241690f, -0.10463880f, 0.01836267f, 
    0.07655644f, 0.17873052f, 0.12439456f, 0.04112098f, 0.01197301f, -0.01633445f, -0.09120529f, -0.06733155f, 
    0.02830661f, -0.09018300f, 0.03449369f, 0.22668667f, -0.10348722f, -0.04309002f, 0.20273225f, 0.02789420f, 
    0.05189808f, 0.00586636f, -0.01265633f, 0.02705615f, -0.02018392f, 0.06186138f, -0.02276823f, 0.13596399f, 
    -0.01943432f, -0.08838429f, -0.13165045f, -0.03465698f, 0.09761415f, 0.02750473f, -0.04673137f, 0.06892716f, 
    0.10554853f, 0.17821747f, 0.11683952f, 0.12260377f, 0.09717544f, -0.04689227f, -0.03507645f, 0.01031863f, 
    -0.06027570f, -0.07703552f, 0.04291591f, -0.06868753f, -0.06551497f, -0.05667533f, -0.07105453f, 0.02990174f, 
    0.03135918f, -0.02096977f, 0.03022756f, -0.04219875f, 0.03590391f, -0.01685287f, 0.15790367f, 0.05920603f, 
    0.05278829f, -0.36396125f, 0.36292827f, 0.25395611f, -0.06890276f, -0.09709160f, 0.00490990f, 0.10294994f, 
    0.07718711f, 0.13366170f, 0.15271857f, 0.20145579f, -0.22653633f, -0.00739083f, 0.05016380f, -0.02908303f, 
    -0.08259718f, -0.06768580f, 0.07099269f, 0.00449211f, -0.03038223f, 0.04823822f, 0.01163887f, 0.04269021f, 
    0.06105533f, 0.00387806f, 0.08111554f, -0.01937624f, -0.09766330f, 0.01235774f, -0.03965630f, 0.05870648f, 
    -0.18470457f, 0.03584568f, -0.01393691f, 0.23312564f, -0.23517437f, 0.20799249f, -0.03352509f, 0.23697302f, 
    -0.05110011f, 0.02719666f, 0.00261280f, -0.13541703f, 0.16674350f, 0.01690160f, 0.12304627f, 0.06736504f, 
    -0.02626277f, 0.08640544f, 0.04072871f, -0.01337814f, 0.08007603f, 0.21013872f, 0.04312969f, 0.13330562f, 
    0.04112041f, 0.07371612f, -0.04858821f, -0.02525728f, -0.03171691f, -0.01693160f, 0.02580848f, -0.16381916f, 
    0.11791854f, -0.01338855f, 0.14385520f, 0.06929075f, 0.23330688f, 0.20854551f, 0.09906800f, 0.12267160f, 
    0.04110637f, 0.13638820f, 0.18861313f, 0.00051203f, 0.04469750f, 0.02017550f, -0.03462098f, 0.03829037f, 
    -0.01685383f, -0.10243804f, -0.10240759f, -0.27916723f, -0.00897734f, -0.05500194f, 0.27806976f, 0.17262648f, 
    -0.02028927f, -0.02352999f, 0.02355574f, -0.05427638f, 0.22502370f, 0.05546438f, 0.22157416f, 0.08035917f, 
    0.10623886f, 0.04636946f, -0.03829186f, -0.19777663f, 0.23233762f, 0.01685319f, -0.00269856f, 0.18003628f, 
    -0.20602490f, -0.01159074f, -0.22103822f, -0.11219659f, -0.12944271f, -0.10064387f, -0.11445688f, -0.16071860f, 
    0.26713529f, 0.29763091f, -0.02019284f, 0.25549746f, 0.13558027f, 0.15449333f, -0.00616887f, -0.21057104f, 
    -0.10938383f, -0.02312415f, -0.01721376f, 0.03533648f, 0.06095915f, 0.12476686f, 0.11952537f, 0.06407752f, 
    0.01249978f, 0.03198568f, 0.07195551f, 0.18085566f, -0.08879959f, -0.04425835f, -0.01189246f, -0.01544682f, 
    -0.11092768f, -0.00422104f, -0.01960647f, -0.05454199f, 0.30858999f, -0.10494850f, -0.00840458f, -0.24546805f, 
    0.04872637f, -0.19618392f, -0.15021576f, -0.28240582f, -0.09276071f, -0.00262293f, 0.08189795f, -0.03985013f, 
    -0.09068940f, -0.02975632f, -0.06068819f, 0.07480522f, 0.00748699f, 0.14044636f, -0.03959339f, 0.14089392f, 
    -0.00159104f, 0.05922835f, 0.05981899f, -0.00116459f, -0.06034458f, 0.06283551f, -0.06027186f, 0.06826560f, 
    0.16129862f, 0.03167260f, 0.17963614f, -0.12924610f, 0.07186282f, 0.10236600f, 0.02460107f, 0.12700872f, 
    -0.02181312f, -0.10340188f, -0.17591855f, 0.02654744f, 0.01606007f, 0.00906751f, -0.00148207f, 0.00626013f, 
    -0.11414544f, -0.02915954f, -0.13638398f, -0.00540660f, -0.06895673f, -0.20815273f, -0.05993634f, 0.13176429f, 
    -0.04713358f, 0.01301328f, 0.17557546f, -0.00455672f, -0.03172420f, 0.08242273f, 0.20659448f, 0.25537261f, 
    -0.04170799f, 0.07916510f, -0.03222707f, 0.08542437f, -0.11544481f, 0.04426419f, -0.05934478f, -0.05382815f, 
    -0.10965673f, -0.01036673f, -0.10096083f, -0.01447750f, 0.10844713f, 0.05611881f, 0.01461835f, 0.04467090f, 
    -0.15394057f, -0.02464969f, 0.00611677f, 0.00115474f, 0.17664896f, 0.02961679f, 0.18218489f, 0.17616636f, 
    -0.12534235f, -0.06836411f, 0.11356698f, 0.06954050f, 0.16856721f, 0.15846372f, 0.01289835f, -0.06780439f, 
    -0.10252961f, -0.03267642f, 0.02971810f, -0.06132698f, 0.00655637f, 0.26227257f, 0.22430751f, -0.00798666f, 
    0.20799856f, 0.21143377f, 0.13489200f, -0.14640442f, 0.08614617f, -0.03831664f, 0.08613309f, 0.16149509f, 
    -0.01788445f, 0.04322761f, 0.01007286f, 0.13504145f, -0.30720294f, 0.25718921f, 0.10438369f, -0.01167894f, 
    -0.02445237f, -0.01128269f, 0.05589838f, 0.02672028f, -0.03741541f, 0.05287378f, -0.05535264f, -0.17716990f, 
    0.14743525f, 0.08227292f, -0.00989388f, 0.09852833f, -0.05432002f, -0.01802314f, -0.07406800f, 0.04303590f, 
    -0.02219685f, -0.00751440f, -0.20139489f, 0.11097381f, 0.20083743f, 0.34139365f, 0.03817316f, -0.05261002f, 
    0.04800319f, 0.05349382f, -0.00036078f, 0.06121599f, -0.03595778f, -0.00899319f, 0.01661101f, -0.12691340f, 
    -0.02002086f, -0.10484172f, 0.12515427f, 0.12309402f, -0.12430301f, -0.14932173f, 0.07246590f, 0.01313376f, 
    0.13498785f, 0.10392295f, -0.08830228f, -0.07274221f, 0.09108274f, 0.08649115f, -0.08630197f, 0.06332260f, 
    0.03397406f, 0.11295477f, 0.00534835f, 0.04650207f, 0.01495789f, 0.05180165f, 0.08465040f, 0.01619215f, 
    -0.21574451f, -0.01607379f, -0.03870646f, -0.04317721f, -0.25142801f, -0.02846702f, -0.01327566f, 0.10923988f, 
    0.10263696f, 0.00775801f, -0.03997001f, 0.04167782f, -0.24639724f, 0.05985357f, -0.10700307f, 0.17913629f, 
    0.05756854f, -0.06790534f, 0.07174402f, 0.13148110f, -0.08559829f, 0.05104478f, 0.10266510f, 0.05348949f, 
    0.01102838f, 0.13513157f, 0.06979447f, -0.04829568f, -0.05726767f, -0.03334421f, 0.03526531f, 0.07415822f, 
    0.15915704f, -0.16590349f, 0.10580073f, -0.03800670f, -0.09627105f, -0.02391552f, -0.08136630f, -0.03446880f, 
    -0.00099762f, 0.00471542f, 0.00427114f, 0.06750382f, -0.15486142f, -0.10398721f, -0.11107212f, -0.07553931f, 
    0.01411425f, 0.10067513f, -0.09083353f, 0.00495336f, 0.02396802f, -0.08238050f, 0.05338427f, -0.04803795f, 
    -0.08612879f, -0.00347967f, -0.01201120f, -0.09422936f, -0.06692658f, -0.02856479f, -0.04809496f, -0.05863780f, 
    0.30679011f, 0.22792017f, 0.16299638f, 0.18009578f, 0.11067885f, 0.15220571f, -0.04648480f, -0.17966196f, 
    0.16803931f, -0.15900436f, 0.10168213f, 0.20256001f, -0.02859947f, 0.01208819f, -0.08413003f, 0.01821583f, 
    0.00627644f, -0.01778308f, 0.09759015f, 0.04088745f, -0.13800624f, -0.07076227f, -0.02389921f, -0.14515434f, 
    -0.05137777f, -0.00135384f, 0.05516252f, -0.04214213f, -0.01048668f, -0.01100113f, 0.03865625f, -0.04950537f, 
    0.21406853f, 0.11022437f, -0.02000988f, 0.08937967f, -0.02610593f, 0.00802595f, 0.02461730f, 0.01428491f, 
    -0.02738743f, 0.09318589f, -0.12012999f, -0.12919095f, -0.27198532f, 0.06098781f, 0.03550075f, -0.03709824f, 
    -0.07014648f, -0.05045659f, -0.09276552f, -0.14632870f, 0.04529765f, -0.11429079f, 0.02132478f, 0.03968478f, 
    -0.11254919f, -0.05150689f, -0.28563544f, -0.14883788f, -0.09078829f, -0.04140138f, 0.05454122f, -0.02860002f, 
    -0.05522256f, 0.01471168f, 0.06132344f, 0.03779744f, -0.05800259f, 0.01371748f, 0.12532994f, 0.10703607f, 
    0.04079662f, -0.03639845f, -0.05029470f, -0.08220235f, 0.02982372f, -0.03215624f, 0.01510526f, 0.00946542f, 
    0.06113075f, 0.07694836f, 0.07550117f, 0.09692536f, 0.06763539f, -0.00478592f, 0.01194620f, -0.00846713f, 
    0.04471597f, -0.04121766f, 0.04077171f, 0.06883661f, 0.05080891f, 0.04459119f, 0.21516621f, 0.08917283f, 
    -0.00445553f, 0.00970963f, -0.04074131f, -0.00021843f, -0.00134965f, -0.07147475f, 0.06962866f, 0.06724031f, 
    0.03681812f, -0.07896236f, 0.03032627f, -0.13446374f, 0.12395559f, 0.07950538f, 0.01869033f, 0.08632059f, 
    0.08338727f, 0.07216001f, 0.00508419f, 0.01012706f, -0.09966145f, -0.05653811f, 0.00873446f, 0.08483341f, 
    -0.08671670f, -0.13325605f, -0.03641194f, 0.15221177f, 0.13074879f, -0.02522976f, 0.07349690f, -0.02821998f, 
    0.04100892f, 0.12258835f, 0.16156803f, -0.00417364f, 0.07352690f, 0.08717627f, 0.04105503f, 0.01978676f, 
    -0.02818269f, -0.02116667f, -0.00851921f, 0.01816056f, -0.10133387f, 0.02104067f, -0.07717147f, 0.04057128f, 
    -0.04674154f, -0.07838529f, 0.03498396f, -0.10279553f, -0.04141043f, -0.06929822f, -0.08600852f, 0.20685191f, 
    0.41215751f, -0.10387049f, 0.13340977f, -0.06838644f, 0.02282030f, -0.06756529f, -0.04551475f, -0.15993793f, 
    -0.03935606f, -0.01666498f, -0.05342849f, 0.03588022f, 0.11723856f, 0.02198571f, 0.08953801f, 0.10274500f, 
    0.01352770f, 0.00567234f, 0.01259235f, 0.00450408f, 0.03589851f, 0.05945526f, 0.15611258f, -0.08574073f, 
    0.24386507f, -0.16100484f, 0.02985742f, -0.07417837f, 0.00018034f, 0.09591764f, -0.09674343f, 0.11998759f, 
    0.06369095f, 0.07681313f, 0.09015649f, 0.00783224f, 0.12739494f, 0.04084677f, 0.07293941f, 0.06813211f, 
    0.02652371f, 0.01073523f, -0.01632169f, 0.07319173f, 0.06308232f, 0.08308495f, 0.15806711f, 0.07965930f, 
    -0.22890826f, -0.28070420f, -0.15754680f, -0.14027797f, 0.02350855f, -0.05250338f, -0.11754807f, -0.09535363f, 
    0.04567911f, 0.13217969f, 0.00117890f, -0.04481354f, -0.03579369f, -0.18634851f, -0.09317823f, -0.07208728f, 
    0.10969345f, 0.03359532f, 0.00529810f, -0.02337524f, -0.01594522f, 0.06734928f, -0.00781080f, -0.01650453f, 
    -0.01992927f, -0.05044296f, 0.00248605f, 0.00020946f, -0.01560639f, 0.00370968f, 0.02767893f, 0.07651492f, 
    -0.10731469f, -0.06780954f, -0.01251126f, -0.08106817f, 0.10788855f, 0.03356888f, 0.12573180f, -0.08436114f, 
    -0.02355619f, -0.06507493f, 0.00623437f, 0.04591665f, -0.01353629f, 0.09066793f, -0.03468159f, 0.02632822f, 
    0.47541583f, 0.17775631f, 0.06861880f, -0.02333990f, 0.02791326f, -0.07788775f, 0.03789756f, 0.04288449f, 
    -0.06790794f, -0.02735133f, -0.07603810f, 0.03000828f, -0.39173418f, -0.12214329f, -0.10196716f, -0.12056414f, 
    -0.17560822f, -0.17360374f, 0.01327593f, -0.03332913f, -0.01257609f, -0.04548587f, 0.03247970f, 0.04454781f, 
    0.18665817f, 0.05311348f, 0.13997775f, 0.08906921f, 0.00569212f, 0.03025726f, -0.01679140f, 0.04492622f, 
    -0.03791206f, 0.00338522f, -0.00329506f, -0.07751542f, 0.09884401f, 0.11994933f, 0.21593072f, 0.11136541f, 
    0.02430584f, -0.08027045f, 0.13178812f, 0.06506467f, 0.11600303f, 0.10054513f, -0.01499389f, -0.02170417f, 
    -0.15587336f, -0.25273803f, -0.11775579f, 0.08198605f, 0.07268736f, -0.17685027f, -0.13391761f, -0.15426493f, 
    0.10300047f, 0.05799600f, 0.09423278f, 0.02832838f, 0.10942112f, 0.15235615f, -0.01561657f, 0.20476951f, 
    -0.00608541f, -0.02237282f, 0.07892861f, 0.00777460f, 0.00495421f, 0.00121830f, -0.01144043f, 0.03483498f, 
    -0.21242158f, 0.07703557f, 0.02502827f, -0.14015700f, -0.15116474f, -0.27436844f, -0.02576888f, -0.00779826f, 
    0.09160250f, 0.01536615f, 0.04903929f, 0.02773281f, -0.33815917f, -0.06177812f, 0.03249532f, -0.09060637f, 
    0.15492362f, -0.05566600f, -0.02039621f, 0.05371736f, 0.11172577f, -0.04571857f, 0.04126189f, 0.01915039f, 
    -0.36060327f, -0.23169301f, -0.01308400f, -0.20243733f, -0.09594325f, -0.03359810f, -0.08761610f, -0.12874033f, 
    0.06138849f, -0.00564259f, -0.07567083f, 0.06917772f, 0.01671563f, -0.00793543f, 0.00117695f, 0.09760648f, 
    -0.08899843f, -0.03911260f, -0.03643008f, 0.06311923f, -0.09263150f, -0.00587690f, -0.05123293f, 0.01785697f, 
    0.17866907f, 0.32472935f, 0.16065699f, 0.24466869f, 0.03935134f, 0.02023323f, 0.04258389f, 0.01548720f, 
    -0.06035472f, -0.04355009f, 0.09487537f, 0.05441898f, 0.00617466f, -0.08926822f, -0.15651083f, -0.23143530f, 
    0.08049329f, -0.01425059f, 0.08037394f, -0.00815385f, 0.12792607f, 0.10487111f, 0.08770274f, 0.07231341f, 
    0.24065147f, -0.09057046f, -0.06831624f, -0.03689088f, -0.09076153f, -0.10308430f, 0.04277488f, -0.15554047f, 
    0.01153975f, 0.03459228f, 0.02281925f, 0.02541245f, 0.04688706f, 0.01910814f, -0.10335238f, -0.16300686f, 
    0.01653801f, -0.02298005f, -0.14742137f, -0.02635942f, -0.09304248f, -0.06270831f, -0.11777329f, -0.14001137f, 
    -0.04229611f, -0.06203144f, 0.18610406f, 0.02848969f, 0.10029185f, 0.00764893f, 0.10282889f, -0.09235338f, 
    0.04682951f, 0.10120300f, 0.10485810f, 0.13137707f, 0.28309247f, 0.20074064f, 0.25356919f, 0.08168025f, 
    -0.04989219f, 0.07433394f, -0.06623913f, 0.00151305f, 0.03402460f, 0.12332083f, 0.04051744f, 0.05582725f, 
    -0.00236824f, 0.04083221f, 0.02594519f, -0.02088289f, -0.03432119f, 0.00399338f, 0.02056959f, 0.14104219f, 
    -0.02537939f, -0.06161226f, 0.01849150f, -0.04598481f, -0.10517351f, -0.03319219f, -0.01469927f, 0.14298023f, 
    0.04818331f, -0.03245962f, 0.20239951f, -0.03089961f, -0.04093922f, -0.03920708f, -0.07765573f, -0.04999034f, 
    0.10632303f, 0.07829850f, -0.00291274f, 0.07462569f, -0.12360636f, -0.01640437f, 0.09257394f, 0.02612575f, 
    0.18815944f, 0.21984905f, 0.13779366f, 0.29812357f, 0.21323334f, 0.04306836f, 0.00322378f, -0.14200532f, 
    -0.11068156f, -0.16799113f, -0.01186210f, -0.05734277f, 0.05494988f, 0.05078955f, -0.01800473f, 0.05760074f, 
    -0.06405322f, 0.06484663f, -0.00169840f, 0.05315658f, 0.11237154f, 0.12843376f, 0.13344958f, 0.01151783f, 
    0.25759026f, 0.13710879f, 0.07660326f, 0.18253928f, 0.05493498f, 0.04910795f, -0.09428310f, 0.04423113f, 
    0.14844753f, 0.14482187f, 0.14094798f, 0.00502445f, 0.24844509f, 0.06106013f, 0.12365788f, 0.25286803f, 
    -0.28885248f, -0.09657521f, 0.01840253f, -0.08562580f, 0.00407213f, -0.01117060f, -0.04231879f, -0.04440023f, 
    -0.34859312f, -0.11753552f, -0.33057925f, -0.40336934f, 0.15097439f, -0.10969122f, 0.17587018f, -0.04652328f, 
    0.00459630f, 0.10644070f, 0.21692911f, 0.15621527f, 0.09953271f, 0.08213319f, 0.20421197f, 0.23223606f, 
    -0.26070777f, 0.11890169f, 0.01417794f, -0.09948726f, 0.13088237f, 0.03595715f, 0.10927399f, -0.11678338f, 
    0.01505559f, -0.11569808f, -0.10257563f, -0.20294379f, 0.01702300f, 0.02275006f, -0.06410063f, -0.06060189f, 
    -0.15753517f, -0.03206796f, -0.08250414f, -0.09205076f, 0.04985796f, 0.05917670f, 0.03509229f, 0.07153820f, 
    -0.01527400f, 0.23724978f, -0.16800833f, 0.15985787f, 0.01910845f, 0.07117967f, 0.18227001f, -0.07932729f, 
    0.10959691f, 0.18886921f, 0.11489615f, 0.20484151f, 0.04112289f, 0.04364849f, 0.06440613f, -0.00456720f, 
    -0.02894064f, -0.06755857f, 0.04670224f, -0.09749448f, 0.19542426f, 0.14759347f, 0.18362156f, 0.04856867f, 
    0.00334846f, 0.06983319f, 0.02240548f, 0.04880515f, -0.00269967f, -0.06907152f, -0.02209717f, -0.02615993f, 
    -0.05087737f, -0.13521978f, -0.14521465f, -0.06869259f, 0.10933540f, -0.06634253f, -0.14008704f, -0.18022512f, 
    0.06727479f, 0.00835615f, 0.18778096f, 0.06976052f, 0.03463974f, -0.11639868f, -0.06352020f, -0.10713004f, 
    0.13019243f, -0.20798039f, -0.18722157f, -0.08716816f, -0.23958799f, -0.06178593f, -0.14978063f, -0.07372693f, 
    -0.08733702f, -0.30173340f, -0.29470852f, -0.12038838f, -0.03528032f, 0.10747635f, 0.00537957f, 0.11999846f, 
    -0.03293175f, -0.00523131f, 0.13924403f, 0.01400273f, -0.10666478f, -0.06167877f, -0.16779946f, -0.17484958f, 
    -0.16555576f, -0.15113336f, 0.04704713f, -0.00148530f, -0.10326847f, 0.13291223f, -0.01446381f, -0.10192090f, 
    -0.12454823f, -0.08116520f, -0.02187627f, -0.00005114f, 0.05424147f, 0.02440458f, 0.18246265f, 0.21345215f, 
    -0.06301566f, 0.24040456f, -0.04345922f, 0.09393717f, 0.08620202f, -0.04156646f, 0.03006788f, 0.18647891f, 
    -0.06490499f, -0.02922184f, 0.09981776f, 0.20650969f, 0.12118762f, -0.06021236f, 0.08924145f, -0.02034287f, 
    0.08917563f, 0.07482325f, 0.14145103f, 0.10351928f, -0.18072611f, 0.10793658f, 0.02624865f, -0.23608023f, 
    -0.04231056f, 0.13577589f, -0.06421103f, -0.11913190f, -0.04622575f, -0.22561927f, -0.04818168f, 0.03939192f, 
    0.19319437f, -0.09137655f, -0.07572232f, -0.05378081f, 0.04833914f, 0.07755572f, 0.06520429f, 0.13730468f, 
    -0.03250698f, -0.01344782f, 0.02023465f, 0.06141135f, -0.12832049f, -0.00380115f, -0.10217480f, -0.17841263f, 
    -0.00339016f, -0.01782802f, 0.05325495f, -0.09736010f, -0.18142566f, -0.24269724f, -0.14029257f, -0.20539789f, 
    0.08593258f, 0.08464011f, -0.10137463f, -0.10824637f, -0.02007941f, 0.06062786f, 0.02037802f, 0.07215055f, 
    0.16038309f, 0.04937247f, 0.00461066f, 0.07042821f, -0.07330856f, -0.00063807f, -0.08230987f, -0.27159694f, 
    -0.05305941f, -0.05500295f, -0.00616353f, -0.15851805f, -0.12471753f, -0.17213908f, -0.14211075f, -0.23176737f, 
    0.26882085f, 0.14718971f, 0.30958283f, 0.18208131f, 0.02629647f, 0.03642523f, -0.07060641f, 0.19529232f, 
    0.05531585f, 0.00268456f, 0.06812601f, 0.19996035f, -0.10934808f, -0.26846656f, -0.01844673f, 0.07517113f, 
    -0.00454884f, 0.03101386f, 0.04601501f, -0.00163407f, 0.14602678f, -0.07101598f, -0.03839168f, -0.07943679f, 
    0.01581445f, 0.11169729f, -0.07952068f, 0.08386921f, -0.07698196f, -0.09012012f, -0.12911060f, -0.13503943f, 
    -0.13711448f, -0.06138977f, 0.11377295f, -0.01398679f, 0.06615230f, 0.12236255f, 0.00478470f, 0.03011530f, 
    -0.01357810f, -0.00819085f, -0.06035051f, 0.03223563f, 0.07418853f, 0.17227782f, 0.06492141f, 0.34199154f, 
    0.13036084f, 0.15700696f, 0.05922943f, 0.10321078f, 0.09336101f, 0.07276303f, 0.03366309f, -0.02180582f, 
    -0.00828871f, 0.00254204f, 0.08520863f, 0.15681252f, -0.17403981f, -0.04407779f, 0.00752305f, 0.17514871f, 
    -0.00756523f, -0.03145844f, 0.14314294f, -0.07916359f, 0.00977741f, 0.05187104f, 0.06237504f, 0.01101061f, 
    0.12849550f, 0.08471526f, -0.15198249f, -0.10321480f, -0.09655428f, 0.00204019f, 0.02941598f, -0.01162765f, 
    0.03856626f, 0.10296991f, 0.12122662f, 0.15944308f, -0.34606874f, 0.09692489f, -0.24971265f, 0.08409353f, 
    -0.09141091f, 0.07144177f, -0.05736864f, 0.09859340f, -0.15494128f, -0.04140567f, 0.00938928f, 0.00560704f, 
    -0.01734711f, -0.04976160f, 0.12360579f, 0.13911676f, 0.04171838f, -0.04951480f, 0.00985404f, -0.03467362f, 
    -0.04437995f, 0.00995969f, 0.02645338f, -0.05771882f, -0.13437612f, 0.17888661f, 0.00327970f, 0.21883325f, 
    -0.01590719f, -0.08852202f, -0.17498802f, 0.09225316f, 0.03751225f, -0.03574466f, -0.02519336f, -0.07471348f, 
    0.12363944f, 0.02710452f, -0.01071961f, -0.04823777f, 0.01832510f, -0.06746660f, -0.06463926f, -0.04430493f, 
    0.00215221f, -0.01818749f, -0.06282660f, -0.09224264f, -0.03171153f, 0.07007173f, 0.29428542f, -0.12108928f, 
    0.00511611f, -0.02785276f, 0.00601196f, 0.05739054f, -0.05872663f, 0.03726541f, -0.01502605f, 0.04026695f, 
    0.19298309f, -0.13526873f, -0.00297919f, -0.00988201f, -0.05172221f, 0.11992086f, 0.06962899f, 0.06278609f, 
    0.04506593f, -0.00843442f, 0.04339558f, 0.03570707f, -0.04026392f, -0.08137791f, -0.10857656f, -0.00573280f, 
    -0.22752917f, -0.03996817f, -0.10478781f, 0.10669857f, 0.05579584f, 0.14504296f, 0.00066895f, -0.03223881f, 
    -0.04456017f, -0.01995089f, 0.00725693f, -0.00822125f, -0.09551997f, 0.13375792f, 0.18467307f, -0.08204488f, 
    -0.02359675f, 0.01474856f, 0.04590534f, 0.14428067f, -0.20505312f, 0.18211830f, 0.01462198f, -0.14134708f, 
    -0.01703327f, -0.05314863f, -0.06072115f, -0.02377380f, -0.06940455f, 0.11031317f, -0.03993815f, -0.12320949f, 
    0.37578529f, -0.50542426f, 0.16699572f, -0.25993231f, -0.10317989f, 0.22582963f, 0.03750444f, -0.02196211f, 
    0.00720577f, 0.05043601f, -0.02671360f, -0.07332290f, -0.12058074f, -0.06360534f, -0.02766036f, 0.04405428f, 
    -0.03375415f, -0.15817720f, -0.07319077f, 0.05422771f, -0.17544886f, 0.07956970f, 0.07396910f, 0.10137800f, 
    0.31793043f, 0.05564991f, -0.17180933f, 0.04561321f, -0.03961859f, -0.07068328f, 0.05720901f, 0.09388224f, 
    0.11611021f, -0.11111328f, -0.06656092f, 0.03889745f, -0.00888120f, -0.03271564f, -0.02585929f, -0.02179899f, 
    -0.05203305f, -0.04787824f, -0.09842432f, -0.09975352f, 0.03850147f, -0.12159210f, 0.07948069f, -0.03869824f, 
    0.12923059f, 0.17423408f, 0.24810050f, 0.20169652f, -0.07216444f, -0.00739944f, 0.04495784f, -0.01480593f, 
    -0.00360601f, 0.06624083f, 0.02293654f, -0.01234477f, -0.33589599f, 0.02312494f, -0.07840662f, 0.09823861f, 
    0.08386073f, 0.09111016f, -0.03275834f, -0.15468220f, -0.00316401f, -0.00622562f, 0.04251882f, 0.12605092f, 
    0.02229476f, -0.18414293f, -0.04449175f, -0.01121346f, -0.02239325f, 0.00491880f, 0.06484754f, 0.14087079f, 
    -0.03568963f, 0.01422155f, -0.00096915f, -0.11121220f, 0.11368863f, 0.16633052f, 0.06658572f, 0.16863808f, 
    0.16740057f, -0.02552881f, -0.01433921f, 0.00248204f, 0.11469933f, -0.00120642f, 0.10968951f, 0.02971367f, 
    0.37225941f, -0.03405800f, -0.06530107f, -0.18658796f, -0.06682997f, -0.03417172f, 0.02826487f, 0.04086047f, 
    -0.07508025f, 0.12576422f, -0.11566825f, -0.06489583f, 0.31130895f, -0.05103102f, -0.01795178f, 0.23332641f, 
    0.08187706f, 0.05189385f, 0.00608312f, 0.07191424f, -0.02233637f, 0.03616843f, 0.07547978f, 0.03533731f, 
    0.06059697f, 0.19687045f, -0.11456752f, -0.02236075f, -0.07105301f, 0.11110051f, -0.02171895f, -0.00138354f, 
    -0.05729339f, -0.02068901f, 0.08448636f, 0.02878342f, -0.09836014f, 0.24627562f, -0.14783500f, -0.07775539f, 
    -0.01750091f, -0.10718685f, -0.07698246f, -0.00785436f, 0.03163178f, 0.06526121f, 0.19388309f, 0.04878176f, 
    -0.24565181f, -0.03617294f, -0.06003904f, 0.18176551f, 0.10680701f, -0.00131937f, 0.03563638f, -0.00938943f, 
    -0.00064351f, 0.09257504f, -0.02270331f, 0.09317722f, 0.01735303f, 0.05780486f, -0.03531903f, 0.15634136f, 
    0.02220125f, -0.02113881f, 0.00097577f, -0.00635021f, -0.12839086f, -0.01460296f, 0.04133283f, 0.03338862f, 
    -0.21134834f, -0.03023220f, -0.00633791f, 0.04923709f, 0.00772752f, 0.07975181f, 0.01737916f, 0.02291354f, 
    0.01889489f, 0.04781675f, -0.01071227f, 0.08246212f, -0.21311113f, 0.18148224f, -0.00073978f, -0.05638560f, 
    -0.12575936f, 0.15687786f, -0.04004471f, 0.11180583f, 0.05823005f, 0.01032958f, -0.06617200f, -0.02556290f, 
    0.03973499f, 0.23270458f, 0.38811159f, 0.08842228f, 0.00715256f, -0.00045378f, 0.06999426f, 0.01583259f, 
    0.03729685f, 0.12140123f, 0.04113194f, -0.05692119f, -0.03431217f, -0.08283738f, -0.04590796f, 0.11820072f, 
    -0.01689650f, -0.12638533f, -0.03676709f, -0.05737546f, 0.05970215f, 0.01314187f, 0.06216679f, -0.00307996f, 
    -0.12779061f, 0.12698184f, -0.01635174f, 0.21716291f, -0.11703053f, 0.00850526f, -0.07614999f, -0.03506137f, 
    -0.00418990f, -0.08846780f, -0.11824268f, 0.01817678f, -0.01129568f, 0.21607368f, 0.05008981f, 0.00787980f, 
    -0.02161147f, 0.10108585f, 0.08293670f, 0.09659514f, -0.00620870f, 0.08642346f, 0.02537221f, 0.01835729f, 
    -0.03451378f, -0.02669523f, 0.02584443f, -0.01242618f, 0.02324244f, -0.00994121f, 0.03647250f, -0.06045900f, 
    -0.00788008f, -0.00834789f, 0.01258175f, 0.03386548f, -0.04993472f, -0.04858667f, -0.01814261f, 0.03774890f, 
    -0.01292402f, -0.01388950f, -0.04212726f, 0.00863583f, 0.01956006f, -0.02849604f, 0.00744898f, -0.00198518f, 
    0.01339519f, 0.03854431f, 0.02818799f, -0.04019047f, 0.02091932f, -0.00615715f, -0.04884598f, -0.05572209f, 
    0.00405877f, 0.00503397f, 0.01753520f, -0.06129407f, 0.01556046f, -0.00536096f, 0.00837368f, -0.04286714f, 
    -0.02570468f, 0.01264315f, -0.00086029f, 0.01310405f, 0.01544627f, 0.00040859f, -0.02194413f, -0.00606773f, 
    0.01774669f, 0.00012671f, 0.01926226f, 0.00972501f, 0.03929428f, 0.03544914f, -0.05365057f, 0.03100776f, 
    0.02295038f, 0.01208702f, 0.00675452f, 0.01101493f, -0.04734569f, -0.00761560f, -0.03530160f, -0.01898176f, 
    -0.05556162f, 0.01141197f, -0.03753471f, -0.05293001f, 0.02781973f, -0.01291979f, -0.05552245f, -0.03709313f, 
    -0.00555875f, 0.02181234f, 0.03790796f, -0.03340047f, 0.03256739f, 0.03211696f, 0.02188157f, -0.05956793f, 
    0.00958193f, -0.01835984f, -0.02464390f, -0.02437555f, 0.00385171f, 0.00757830f, 0.01127175f, -0.05744550f, 
    -0.02062694f, -0.01033590f, 0.02655138f, -0.02509794f, 0.02275872f, -0.02592939f, -0.00237467f, -0.01237861f, 
    0.02581749f, 0.02287551f, -0.00724777f, 0.03415526f, -0.02856633f, -0.02280031f, -0.03969470f, -0.02816689f, 
    -0.01955674f, 0.03631159f, -0.02734584f, -0.00048339f, 0.03076520f, 0.01439099f, 0.00010581f, 0.00509082f, 
    0.02186832f, -0.00231747f, -0.00331230f, -0.02891107f, -0.00182880f, 0.00206184f, 0.04680602f, -0.04529472f, 
    -0.00060320f, -0.04496415f, -0.00073590f, -0.02144040f, 0.01483514f, -0.02704929f, -0.00583481f, -0.04756579f, 
    0.00011304f, 0.02590695f, 0.04006686f, -0.01076278f, -0.05113554f, -0.00766816f, 0.01129570f, 0.01220173f, 
    0.01615644f, -0.04373959f, -0.04795100f, 0.00190667f, -0.01478284f, -0.00810824f, -0.03623528f, -0.00439139f, 
    0.03211795f, 0.01087667f, -0.01113557f, -0.00182464f, 0.00102702f, -0.00190155f, -0.04480219f, -0.02613134f, 
    0.01620275f, -0.04469538f, -0.03547155f, 0.00830964f, -0.00225125f, -0.02511006f, -0.03848638f, 0.01917685f, 
    -0.01206468f, 0.02829566f, -0.01323990f, 0.01452126f, -0.03669269f, -0.02026939f, 0.03120752f, 0.03768590f, 
    -0.06073034f, -0.00078400f, -0.01207924f, -0.00196675f, 0.01974538f, -0.01384468f, -0.03401406f, -0.01410386f, 
    -0.03013373f, -0.04584568f, -0.01391410f, -0.05742240f, 0.03700348f, -0.04854500f, 0.00426225f, -0.04783352f, 
    0.03450100f, 0.01683002f, -0.05779350f, -0.05868632f, 0.01279550f, -0.04590766f, -0.05418511f, -0.04874380f, 
    -0.04361462f, -0.00504426f, -0.01375349f, -0.05991339f, -0.00856297f, -0.02610620f, 0.03956063f, 0.04183338f, 
    0.03531142f, -0.05710582f, 0.01518957f, -0.04030649f, -0.05020968f, 0.00344591f, -0.04564711f, -0.02431542f, 
    -0.02815678f, 0.03421478f, 0.01449861f, -0.01628315f, 0.03411091f, -0.03753876f, 0.01692438f, -0.00358418f, 
    -0.04022986f, -0.03767302f, 0.02199032f, -0.01729605f, -0.02129385f, -0.02882769f, 0.04135172f, 0.03635477f, 
    0.01936151f, -0.04307908f, 0.00850472f, 0.01284211f, -0.01119698f, -0.01636034f, 0.01311050f, -0.03446217f, 
    -0.00932947f, -0.04458879f, -0.04394101f, -0.00370322f, -0.05410579f, -0.03781677f, 0.02163900f, -0.02602017f, 
    0.02954140f, -0.01029943f, 0.02588088f, 0.03456524f, -0.03658117f, -0.04292833f, -0.03162450f, -0.03717035f, 
    -0.03555013f, -0.04546910f, -0.04001627f, -0.04545008f, -0.02620367f, -0.02346104f, 0.04054854f, -0.00581637f, 
    -0.03355825f, 0.03308463f, -0.05892713f, -0.02117902f, 0.02496523f, -0.00398915f, 0.01100966f, -0.00162560f, 
    0.03755482f, -0.01890326f, 0.01293810f, -0.04184471f, -0.04914216f, -0.04547444f, 0.04222150f, -0.02865081f, 
    -0.05397201f, -0.05354735f, -0.00629252f, 0.00597297f, -0.01930908f, 0.03913145f, -0.04607016f, -0.00291559f, 
    0.03271572f, 0.01828740f, 0.01816445f, 0.02484844f, -0.01461161f, 0.03886456f, 0.00263546f, 0.02302967f, 
    0.03498977f, 0.00136751f, 0.00826384f, -0.01284458f, -0.05050547f, 0.02555586f, -0.00255893f, 0.02103102f, 
    0.02627997f, 0.00363556f, -0.00579068f, -0.03356059f, 0.01759967f, -0.01466578f, 0.01397950f, 0.02121357f, 
    -0.01122906f, 0.02816915f, 0.03818046f, -0.01476616f, -0.03670347f, 0.03767007f, 0.02410518f, 0.02590119f, 
    0.01430256f, -0.02745728f, 0.00980445f, -0.03957657f, -0.04308695f, -0.02395342f, 0.04023248f, 0.02846389f, 
    -0.01086909f, -0.00909987f, -0.02269278f, -0.00695733f, -0.01407277f, -0.03189294f, -0.00374594f, 0.00369314f, 
    0.04083425f, 0.02524342f, -0.04063923f, -0.04332668f, -0.03854613f, -0.01282107f, -0.04372288f, -0.03882989f, 
    0.02646103f, 0.03350205f, 0.04059768f, -0.03305256f, -0.00687236f, 0.00636455f, -0.02878770f, 0.01842531f, 
    -0.01845938f, -0.02390124f, 0.03864450f, -0.05600040f, -0.05866823f, -0.02362463f, 0.00698850f, 0.03025135f, 
    -0.04823763f, -0.03054881f, 0.00891691f, 0.02601836f, -0.04781269f, 0.02873237f, -0.02862318f, -0.06050249f, 
    -0.00860546f, -0.03072900f, -0.02789073f, 0.03722974f, -0.04183153f, -0.01102025f, 0.01983558f, 0.00557267f, 
    0.03023156f, -0.02470805f, -0.04760649f, 0.01132113f, 0.02521924f, -0.04263756f, -0.01688838f, -0.01374280f, 
    -0.02196750f, -0.05646314f, 0.03523728f, -0.04143592f, 0.01438241f, -0.01460690f, -0.03358591f, -0.03807095f, 
    -0.01180014f, 0.22922006f, -0.21000220f, 0.09331107f, 0.07594891f, -0.05789543f, -0.09118013f, 0.00852588f, 
    -0.06165259f, -0.07325488f, -0.16535585f, 0.04551278f, -0.00440515f, 0.18608035f, 0.13969631f, 0.19535920f, 
    -0.01440813f, 0.11122131f, 0.19514866f, -0.04159495f, 0.07474533f, 0.02941286f, -0.04912659f, 0.01372587f, 
    -0.23024721f, 0.09289424f, -0.23457530f, -0.00423992f, -0.04336412f, -0.05721846f, 0.02172481f, 0.04131078f, 
    0.05296652f, -0.01396129f, 0.08642227f, -0.02350951f, -0.28479645f, -0.17691320f, -0.00559394f, 0.25487018f, 
    0.02799038f, 0.03892437f, 0.04706811f, -0.01352314f, -0.07889420f, -0.25024027f, 0.11273079f, 0.04739997f, 
    -0.08717377f, 0.07759023f, 0.15283230f, 0.09133972f, 0.00470442f, -0.07793833f, 0.11304466f, 0.00663874f, 
    -0.04509469f, -0.03939007f, 0.07813445f, 0.03994824f, -0.08025874f, 0.00914508f, 0.19974801f, -0.12089563f, 
    -0.02714265f, 0.09699167f, -0.05377378f, 0.09662267f, 0.06614379f, 0.02228446f, -0.02441483f, -0.18474874f, 
    0.04064112f, 0.07263785f, -0.23392017f, 0.08995101f, -0.00892157f, 0.00822038f, 0.01122763f, -0.04392717f, 
    0.09316648f, -0.10372592f, -0.04775352f, 0.19872126f, -0.10739419f, -0.03880504f, -0.03395258f, 0.20962749f, 
    0.06192084f, 0.00887719f, 0.00174353f, -0.04499613f, 0.06506148f, -0.06751157f, -0.12856849f, 0.08707839f, 
    0.05252095f, 0.05214311f, 0.13341436f, 0.21087937f, 0.02712649f, 0.02279764f, -0.08667654f, -0.04413420f, 
    0.11157504f, 0.04379802f, -0.03882397f, -0.00942442f, -0.00879533f, -0.25490344f, -0.00039379f, 0.10550167f, 
    -0.15357393f, -0.16390187f, -0.08405060f, 0.05750598f, -0.20142053f, 0.09537569f, -0.07622970f, -0.07425023f, 
    0.04167387f, -0.03746864f, 0.13604210f, 0.22996339f, 0.05569179f, 0.11657639f, 0.03610872f, 0.07118575f, 
    -0.04145530f, -0.17413872f, 0.10298897f, 0.04637517f, -0.14482696f, 0.04058960f, 0.13610148f, -0.07670735f, 
    0.11302489f, -0.04694276f, -0.14071020f, 0.02442349f, -0.19705115f, -0.00175766f, 0.03562473f, 0.06965157f, 
    0.29313132f, -0.04339804f, 0.28339291f, 0.31431839f, 0.06601682f, 0.08613302f, -0.04770086f, 0.18666200f, 
    0.03958394f, -0.05941686f, -0.05294196f, -0.15758619f, 0.01651712f, -0.05308964f, -0.08653481f, 0.08503606f, 
    0.01497706f, 0.05826999f, 0.07360315f, 0.03498204f, 0.03415148f, -0.03704103f, -0.01772975f, 0.17202047f, 
    -0.07704271f, -0.01338699f, 0.06530947f, -0.10055495f, 0.03710385f, 0.04888451f, -0.05392153f, 0.02532524f, 
    0.02050166f, -0.09146986f, 0.11386545f, -0.01600638f, -0.08733796f, -0.14715752f, -0.21040253f, -0.00646090f, 
    -0.07556840f, -0.00352503f, -0.06396767f, 0.00077321f, 0.09119681f, -0.10935694f, -0.00165938f, 0.04146434f, 
    0.11686705f, 0.07530006f, 0.11372896f, -0.04230591f, 0.00307480f, 0.03853197f, -0.07275502f, -0.00643718f, 
    0.06769232f, -0.05056889f, 0.07388925f, -0.14487514f, -0.01263005f, 0.17059125f, 0.13973695f, 0.13420671f, 
    0.02934997f, 0.12777586f, -0.00104261f, 0.14443855f, 0.01781017f, 0.02404108f, -0.04742875f, 0.05232174f, 
    -0.01416075f, 0.02411964f, 0.03411068f, 0.04418812f, 0.05868948f, -0.07146175f, 0.06575273f, -0.02139794f, 
    0.04282707f, 0.04363645f, -0.00552453f, -0.04109452f, -0.10872887f, -0.09875114f, -0.01653058f, -0.05366356f, 
    0.03380042f, 0.00786469f, -0.16691786f, -0.01835410f, -0.01191483f, -0.16971222f, -0.03200516f, 0.09547748f, 
    0.10656858f, -0.01959183f, 0.07993652f, 0.11973234f, 0.07307313f, 0.05799133f, 0.08179677f, -0.09268104f, 
    -0.00870274f, -0.09745891f, -0.07909834f, 0.01796127f, 0.10893882f, -0.01919697f, -0.02730618f, 0.02851604f, 
    0.03977838f, -0.09633062f, 0.17640889f, 0.01284316f, -0.04682809f, -0.01676952f, -0.03288715f, 0.01307796f, 
    0.06950771f, 0.02220113f, 0.04835315f, -0.16746083f, -0.05526517f, 0.20766442f, 0.00047550f, 0.13692370f, 
    0.14594892f, -0.16556479f, -0.05488107f, -0.07027601f, -0.08411252f, 0.02655021f, 0.15293828f, 0.40140256f, 
    -0.03818948f, -0.13828443f, 0.03818796f, 0.14371479f, -0.06203496f, 0.09367783f, 0.01819220f, 0.07039522f, 
    -0.29415429f, -0.08750381f, 0.00417160f, 0.09119526f, -0.04196865f, 0.08406830f, -0.11553177f, -0.02606346f, 
    0.00174461f, 0.09531526f, 0.02748686f, 0.01010910f, 0.06680506f, 0.02855722f, 0.26622337f, 0.13503167f, 
    -0.00936116f, 0.06739908f, 0.04529319f, 0.08073534f, -0.00234160f, -0.08038315f, 0.03075252f, 0.02798693f, 
    0.23895510f, 0.07067006f, 0.31594798f, 0.11711064f, 0.22038037f, -0.07677937f, 0.07660186f, -0.12067784f, 
    0.00852594f, 0.06914008f, 0.00084243f, 0.04490240f, 0.10386547f, -0.01503245f, 0.29001224f, 0.22152042f, 
    0.11439923f, 0.18255177f, 0.00086491f, 0.18799172f, 0.10088604f, 0.02095624f, -0.05102082f, -0.13754411f, 
    -0.00063532f, 0.14033538f, -0.01349039f, 0.13785034f, 0.11739419f, -0.15938385f, 0.11163802f, 0.10675532f, 
    0.04926713f, 0.14770332f, -0.18923864f, -0.09479356f, -0.02522667f, 0.16059074f, -0.10665257f, 0.01261123f, 
    0.09016164f, -0.02027312f, -0.07100988f, 0.02929311f, -0.02641031f, 0.02589599f, -0.01074323f, -0.02258890f, 
    -0.11103629f, 0.06187361f, 0.28642651f, 0.09493010f, 0.02272366f, 0.00345509f, 0.01802014f, -0.03557995f, 
    0.03225829f, -0.07110464f, -0.17264347f, -0.08099435f, -0.16588487f, -0.02611474f, 0.05938908f, 0.14868720f, 
    0.04896823f, 0.13600940f, 0.06272534f, -0.01478228f, 0.09483106f, -0.02244962f, 0.11576881f, 0.01203843f, 
    0.28684893f, -0.05335648f, 0.17575048f, 0.17918767f, 0.03075011f, 0.02267740f, -0.05491186f, -0.13930160f, 
    -0.05978001f, 0.08692433f, 0.05789807f, 0.18524587f, -0.11652604f, -0.27000821f, -0.41412178f, -0.28555545f, 
    0.14453135f, -0.08177041f, -0.04917456f, 0.09404738f, -0.17279376f, -0.08380880f, -0.02152334f, -0.10080405f, 
    0.13794006f, -0.02901584f, 0.06484089f, 0.00822028f, -0.00908020f, -0.03287532f, -0.01175252f, 0.02263859f, 
    0.14034837f, 0.11645010f, -0.04706237f, 0.06122868f, -0.09294393f, 0.36018437f, 0.20213205f, -0.03524317f, 
    -0.05972863f, 0.17050517f, 0.00594496f, -0.08100270f, -0.09030652f, -0.16389212f, 0.02660806f, 0.19911841f, 
    -0.23856612f, -0.52085948f, -0.48183692f, -0.40649006f, 0.10260560f, -0.13677289f, -0.20425332f, -0.13792181f, 
    -0.12126113f, -0.11270913f, -0.05815440f, 0.03987845f, 0.08940225f, 0.08639240f, 0.03930725f, 0.08566243f, 
    0.19194700f, 0.02865070f, -0.03706784f, 0.07274812f, 0.19207144f, 0.01750074f, -0.02555776f, -0.08242062f, 
    0.09014203f, 0.05307526f, 0.23272659f, 0.09682739f, -0.05657269f, 0.05555445f, -0.05546619f, -0.04217113f, 
    0.05008903f, -0.02580144f, -0.03605911f, -0.07000742f, 0.10573756f, 0.20341077f, 0.26729864f, 0.18362112f, 
    -0.04247056f, 0.09626159f, 0.01188320f, -0.00636745f, -0.02599021f, -0.03579455f, 0.05291517f, 0.07992891f, 
    -0.00508381f, -0.01780580f, -0.02758166f, -0.02740994f, 0.07975782f, 0.13411738f, 0.18259814f, 0.06503067f, 
    0.03168177f, 0.06396037f, 0.02905070f, -0.16210967f, -0.16008946f, -0.00569960f, 0.02431421f, 0.03553470f, 
    -0.02424912f, 0.26967007f, -0.04471153f, 0.16568561f, 0.21106315f, 0.10337534f, -0.05116362f, 0.07502306f, 
    0.00860035f, 0.02312152f, 0.03288147f, 0.00347288f, 0.06438933f, 0.20891500f, 0.01740805f, 0.00044169f, 
    -0.07409827f, -0.00344283f, -0.05270400f, -0.04032695f, -0.09002215f, 0.04201298f, -0.20249279f, -0.03284218f, 
    -0.10750186f, -0.11030756f, -0.02976299f, -0.16998115f, 0.09087464f, 0.06815989f, -0.01761836f, -0.00907167f, 
    0.35672101f, -0.02900844f, -0.28783789f, -0.01933170f, -0.03463572f, 0.21137244f, 0.34828642f, -0.07851488f, 
    -0.04520309f, -0.08309688f, -0.01692881f, -0.01833571f, 0.04996301f, 0.09174426f, 0.05443246f, 0.15616304f, 
    0.08206145f, 0.05276988f, 0.01831783f, 0.01349812f, 0.07196398f, 0.05688467f, 0.14062659f, 0.18977322f, 
    0.08630280f, -0.13603568f, 0.03509049f, -0.25164387f, 0.05240891f, 0.02688247f, -0.05378846f, 0.13334571f, 
    0.05728443f, 0.17648862f, 0.06026629f, -0.14461493f, 0.11442792f, 0.00217967f, 0.14800963f, 0.11466789f, 
    -0.06686859f, 0.09876193f, -0.01553577f, -0.02594010f, 0.19524381f, 0.04414588f, 0.08821411f, 0.19107778f, 
    -0.26943025f, -0.16155215f, -0.24401276f, -0.15539706f, -0.01821749f, -0.16504155f, -0.07537668f, 0.05311156f, 
    -0.05361712f, 0.02779698f, -0.07533532f, 0.03946801f, -0.30839998f, -0.28843734f, -0.40555710f, -0.20988125f, 
    0.12415966f, 0.23523545f, -0.04748833f, -0.07039248f, -0.04839449f, 0.03847156f, -0.03390691f, -0.03678257f, 
    0.04022168f, -0.00300772f, -0.06003401f, -0.01618572f, 0.05207449f, -0.02124524f, -0.02529432f, 0.14886098f, 
    -0.09222078f, -0.09319750f, -0.14286320f, -0.07169408f, 0.18327643f, 0.10822030f, 0.03322127f, 0.11120383f, 
    0.04325505f, -0.06137452f, 0.05284961f, -0.01160203f, 0.11115699f, 0.18285450f, 0.03841582f, -0.03809728f, 
    0.41653714f, 0.18625519f, -0.08883340f, 0.06303898f, 0.15359172f, 0.06062787f, 0.01811310f, 0.07849336f, 
    -0.07435566f, -0.06212992f, -0.06577200f, 0.02625200f, -0.43327972f, -0.21244763f, -0.32478130f, -0.15905590f, 
    -0.02401602f, -0.19384271f, -0.16526730f, -0.07149310f, -0.16132258f, -0.03272701f, 0.02628434f, -0.00542530f, 
    0.18533024f, 0.07867519f, 0.13090661f, 0.07169852f, -0.02868296f, 0.14989525f, -0.04527252f, -0.00638079f, 
    -0.05509067f, 0.00841776f, 0.12076016f, 0.01198485f, 0.17011765f, 0.36668658f, 0.02443280f, -0.03493943f, 
    -0.01191728f, 0.05430024f, 0.04208472f, 0.05122510f, -0.01435758f, -0.03616650f, -0.08081287f, 0.03850910f, 
    -0.32480845f, 0.01403360f, -0.35256553f, -0.26914415f, 0.17315461f, -0.02284562f, 0.01472175f, -0.09353489f, 
    0.03473622f, 0.04163817f, 0.05203224f, -0.01102917f, 0.13410136f, 0.07966899f, -0.05468972f, 0.06861585f, 
    0.01777193f, 0.03387198f, 0.01590456f, 0.03603540f, -0.01007967f, 0.01715737f, -0.07464770f, 0.00692789f, 
    -0.15831083f, 0.32109207f, 0.16851790f, -0.41787198f, 0.02105412f, -0.02371555f, -0.04051504f, 0.03610368f, 
    0.11725930f, -0.00484903f, -0.01506526f, -0.04337665f, -0.30384994f, 0.15373854f, 0.08609085f, -0.12732624f, 
    -0.06788114f, 0.05536097f, 0.05891043f, -0.11105716f, -0.04323856f, -0.04140780f, -0.13021539f, -0.04252732f, 
    -0.39452869f, -0.01593436f, -0.11872876f, -0.25570613f, -0.06691152f, -0.09282637f, -0.06476577f, -0.12030545f, 
    0.07281958f, -0.01404759f, -0.05297963f, -0.05786392f, 0.03467437f, -0.02264375f, 0.02336279f, 0.08821495f, 
    0.13822201f, 0.03807386f, -0.00420763f, -0.08212924f, 0.04737616f, 0.05398767f, 0.02416438f, 0.08118169f, 
    0.06702770f, 0.28028902f, 0.20178355f, 0.21207899f, -0.05105696f, 0.04282371f, 0.01107335f, -0.04308147f, 
    -0.04104700f, 0.01354184f, 0.06808314f, 0.10016063f, -0.06571358f, 0.20531778f, -0.19802311f, -0.25772572f, 
    -0.03739317f, 0.19146019f, 0.01303895f, 0.04207835f, -0.02857545f, 0.05914859f, -0.12364873f, -0.11395350f, 
    0.02643312f, -0.02230049f, -0.04520832f, -0.02532827f, 0.02623682f, 0.00451602f, -0.00196463f, -0.02559974f, 
    0.00613900f, 0.02726277f, 0.00312474f, -0.02209748f, -0.01413479f, -0.03420376f, -0.03838338f, -0.05930771f, 
    0.01209512f, 0.01740884f, -0.02341975f, -0.02500052f, -0.03627735f, 0.00297618f, -0.02042811f, -0.02557722f, 
    -0.02355015f, 0.00219638f, 0.03520994f, 0.02939937f, -0.02537096f, -0.05266661f, 0.02111220f, -0.04702165f, 
    -0.04583852f, -0.00438568f, -0.01670925f, 0.04038005f, -0.05034369f, -0.02569164f, -0.00870543f, 0.03657943f, 
    -0.05339196f, 0.00947424f, 0.00352372f, 0.01341797f, -0.00333632f, -0.00109751f, 0.03448882f, 0.01712102f, 
    -0.02513591f, 0.00264933f, 0.02480698f, -0.04848925f, 0.02514057f, 0.00659970f, -0.01781873f, 0.00220747f, 
    0.02324688f, 0.02762561f, -0.03631660f, -0.05106434f, 0.04242023f, -0.00923948f, 0.00800892f, -0.01125838f, 
    -0.05209307f, -0.03800611f, -0.02041585f, -0.00552659f, -0.01285286f, 0.00571763f, -0.01979937f, -0.02897054f, 
    -0.04551314f, 0.03615562f, -0.04077243f, -0.00635240f, 0.00227708f, -0.01370806f, 0.03831868f, -0.05110635f, 
    0.00733609f, 0.02482940f, -0.03493614f, 0.03826594f, -0.00923137f, 0.02182996f, -0.04300370f, -0.03641134f, 
    0.02068938f, -0.05500218f, -0.04172807f, -0.01703550f, 0.03135698f, 0.03488986f, -0.00337978f, -0.04842984f, 
    0.01685750f, 0.01809496f, -0.00924423f, -0.04320702f, -0.03285970f, -0.02740397f, 0.02502330f, 0.03030513f, 
    -0.02123992f, -0.05368216f, 0.01931100f, -0.02575722f, -0.02636801f, 0.02871525f, 0.02966758f, -0.03174650f, 
    0.03715343f, 0.03656734f, 0.00885116f, -0.00517244f, 0.02086374f, 0.00944336f, -0.01897359f, -0.00012265f, 
    0.02937762f, 0.04236650f, 0.00749918f, -0.00120657f, -0.04155181f, -0.05364106f, -0.04957173f, 0.02115824f, 
    -0.01864719f, -0.01651286f, -0.05430156f, -0.01978781f, -0.03009748f, -0.04334789f, -0.00951867f, -0.00049720f, 
    -0.01526439f, 0.02893813f, -0.02610332f, 0.01364154f, -0.01559805f, -0.05231187f, 0.00742151f, -0.00431759f, 
    0.04635475f, 0.03132269f, -0.01444390f, 0.04544016f, -0.03956282f, -0.02490683f, -0.05541468f, 0.03988801f, 
    -0.00567738f, -0.03379108f, -0.01263201f, -0.03134695f, -0.04131666f, -0.00969675f, 0.03801941f, -0.05051550f, 
    0.02400717f, -0.05420072f, 0.01319202f, -0.02883021f, 0.02978608f, -0.04853866f, -0.03611170f, 0.01074385f, 
    -0.04137101f, -0.05667185f, 0.00449871f, -0.02883790f, 0.01790222f, -0.01888997f, -0.04166387f, 0.02846981f, 
    -0.03253456f, -0.04199526f, 0.03807928f, -0.05059924f, 0.03134349f, -0.02253611f, -0.02975507f, 0.00822435f, 
    0.02010931f, 0.03777294f, -0.00144139f, -0.00736804f, -0.01239849f, 0.04010431f, 0.01571345f, 0.02383325f, 
    -0.01105268f, 0.02577650f, -0.01015948f, 0.03871162f, -0.05066560f, -0.04034930f, 0.03626730f, -0.05257521f, 
    -0.02732916f, -0.02749318f, 0.02428476f, -0.02198506f, 0.03744014f, 0.01453903f, 0.02177076f, 0.02478714f, 
    -0.02332368f, 0.01142853f, 0.01193925f, -0.03954749f, -0.06055064f, -0.04865803f, -0.00031588f, -0.03489853f, 
    0.01836327f, 0.00554737f, 0.03838612f, 0.05297633f, 0.00189776f, -0.02003214f, -0.01726243f, 0.00441771f, 
    -0.02977850f, -0.01489924f, -0.05112295f, 0.03952023f, 0.03399723f, 0.00642255f, 0.03471187f, 0.00919603f, 
    0.04384760f, -0.02915126f, -0.01722786f, -0.05470963f, 0.02789011f, -0.02487475f, 0.03021380f, 0.02541639f, 
    0.03677806f, -0.03328374f, 0.02342668f, -0.05686021f, 0.03983616f, 0.02507146f, 0.01046044f, 0.01517804f, 
    -0.02400297f, -0.02776903f, -0.02631359f, -0.00582359f, -0.04637599f, 0.01439182f, 0.03075134f, -0.01196362f, 
    -0.04877625f, -0.04969319f, -0.02554654f, 0.00153309f, 0.00218442f, 0.02913212f, -0.02355007f, 0.01589036f, 
    0.02739279f, -0.05510025f, -0.05281890f, -0.01509501f, -0.00804584f, -0.04768929f, -0.00296544f, 0.03644400f, 
    -0.03345950f, -0.03992901f, -0.00562984f, 0.03512917f, -0.03352290f, -0.01850811f, 0.02929411f, 0.03231287f, 
    -0.03430316f, -0.03553639f, 0.02320318f, -0.06103824f, -0.01960815f, 0.03009423f, -0.00705539f, 0.03482695f, 
    0.04130186f, 0.01301918f, -0.03615366f, 0.03419206f, -0.00989345f, -0.00187998f, 0.02416416f, 0.01667265f, 
    -0.03259794f, 0.01284964f, 0.00190992f, -0.00914186f, -0.02723562f, -0.05617207f, 0.03949174f, -0.02989756f, 
    -0.04927629f, -0.04684023f, -0.03202971f, -0.01754865f, 0.02558319f, 0.00670438f, -0.01418082f, 0.01077201f, 
    -0.01915272f, -0.04172703f, 0.00767935f, -0.01521204f, 0.03442359f, -0.04177759f, 0.00805785f, -0.04488026f, 
    -0.01324647f, 0.02306397f, -0.00888840f, 0.04228710f, -0.04818526f, -0.03439346f, 0.01178968f, -0.04569104f, 
    -0.00108083f, 0.01536714f, -0.05308333f, 0.03342463f, 0.02611487f, -0.05713602f, 0.02540446f, -0.03575708f, 
    0.00195538f, -0.03751631f, -0.03991551f, -0.02503859f, -0.04138999f, 0.02022060f, 0.01895306f, 0.01481041f, 
    0.00393962f, -0.01287994f, -0.00546005f, 0.02036391f, -0.03596136f, -0.02505879f, 0.04059547f, 0.01828988f, 
    -0.00856938f, 0.00394166f, 0.01912817f, 0.02368396f, -0.05261680f, -0.00810465f, -0.02156231f, 0.03498413f, 
    -0.04099109f, 0.03696414f, 0.03319232f, 0.03088661f, -0.02452081f, 0.00716466f, -0.04947392f, 0.02347440f, 
    0.02943106f, -0.01225335f, 0.04393308f, 0.03680826f, -0.04119579f, -0.02474911f, -0.00750572f, -0.01384746f, 
    0.00371818f, -0.04418968f, 0.03245536f, -0.02653866f, 0.00974641f, -0.04209313f, -0.05677633f, 0.03620542f, 
    0.10400867f, -0.22150423f, -0.10805929f, 0.14667825f, -0.04240552f, -0.17455664f, 0.18058969f, -0.08534756f, 
    0.07436349f, -0.00043864f, 0.01537954f, -0.10289983f, 0.29017448f, 0.29656991f, 0.17933027f, -0.05605844f, 
    0.06653434f, 0.18209697f, 0.12559631f, 0.03478776f, 0.01896491f, -0.15578499f, -0.04494517f, -0.07946426f, 
    0.12883756f, 0.10190757f, -0.22168124f, 0.07749752f, 0.01959207f, -0.01983267f, 0.02303684f, 0.00632762f, 
    0.00123861f, -0.04601407f, 0.07312729f, -0.14756621f, 0.13681266f, 0.07418262f, 0.26814920f, 0.05354415f, 
    0.00321959f, 0.05117609f, 0.09049588f, -0.06893135f, 0.10337596f, -0.04004974f, 0.18564120f, 0.06854195f, 
    0.11778381f, 0.26156172f, 0.06204112f, -0.09920464f, 0.01688819f, 0.07988882f, 0.13814750f, 0.03590301f, 
    0.00666174f, 0.04169925f, 0.03130304f, 0.02615881f, 0.26651353f, -0.31633696f, 0.21379679f, -0.39966440f, 
    0.09475558f, 0.02052156f, 0.06691459f, -0.02970431f, -0.03648252f, 0.07749811f, -0.18561321f, -0.15109223f, 
    -0.11274661f, -0.05752198f, -0.05867388f, 0.18702380f, 0.00928716f, 0.02708115f, 0.02179854f, 0.07091748f, 
    0.10337840f, 0.00857678f, 0.08764373f, 0.28829280f, -0.05229967f, -0.29150438f, -0.14890777f, 0.33153391f, 
    0.10634778f, -0.07928744f, -0.01074062f, -0.13553047f, 0.03621089f, 0.07738310f, -0.03316821f, 0.02118382f, 
    -0.00843859f, 0.01007063f, 0.16443132f, 0.00790653f, 0.15479685f, -0.06586894f, -0.12968659f, 0.02026099f, 
    0.09525723f, 0.05234689f, 0.02492276f, 0.08020638f, -0.12086748f, -0.13650644f, 0.12507939f, -0.09482590f, 
    0.18222557f, -0.09000150f, 0.07892830f, 0.01827029f, 0.02047461f, 0.00095909f, -0.09065043f, 0.10322252f, 
    -0.10132736f, 0.14984603f, 0.10159930f, -0.11803742f, 0.06035380f, 0.07328737f, 0.00641462f, -0.04195506f, 
    -0.09666026f, -0.18175830f, -0.13285761f, -0.18708885f, 0.22096048f, -0.17994814f, -0.03563934f, 0.07602018f, 
    -0.01629998f, -0.00443810f, 0.10893545f, -0.01303774f, 0.11962536f, 0.11638127f, 0.06349554f, 0.21103980f, 
    0.23940165f, 0.31152201f, -0.02389414f, 0.14119855f, 0.03071082f, -0.12679270f, -0.22164550f, 0.09290309f, 
    -0.07117612f, -0.03719783f, -0.07662985f, -0.09630283f, 0.02769994f, -0.08831179f, 0.05824596f, 0.24235712f, 
    -0.06923342f, 0.07045697f, -0.03563565f, -0.01108843f, 0.01586583f, -0.00448842f, 0.09047643f, 0.03245631f, 
    -0.04255277f, -0.20117202f, 0.17657349f, -0.29114991f, 0.06721336f, 0.02515089f, -0.00684687f, 0.01891726f, 
    -0.00246239f, 0.05367936f, 0.14334236f, 0.03321176f, -0.05750506f, -0.10345431f, -0.01937860f, 0.15799101f, 
    -0.01746560f, 0.03091713f, 0.09264220f, 0.06598275f, -0.07042871f, 0.04030282f, 0.03145543f, 0.05236071f, 
    0.08105057f, 0.05825555f, -0.13776825f, -0.15015963f, 0.13743524f, 0.17265329f, 0.06962430f, 0.10520016f, 
    0.02761569f, -0.06112541f, -0.03695421f, -0.21229932f, 0.39125142f, 0.11843935f, 0.19117089f, -0.18343151f, 
    0.02664133f, -0.02497542f, 0.18609630f, 0.22694041f, -0.03715456f, -0.02457973f, -0.06308059f, -0.00963102f, 
    -0.17884168f, 0.01447284f, 0.01837418f, -0.13483895f, -0.05645248f, 0.05079364f, -0.03237650f, -0.07180563f, 
    0.02689867f, -0.13772470f, -0.02834025f, -0.20733014f, 0.01967878f, -0.19812450f, -0.18701893f, -0.27145675f, 
    -0.19932592f, 0.13334325f, -0.13019170f, -0.03822936f, -0.05326150f, 0.02959502f, -0.09385387f, -0.07323143f, 
    -0.00660383f, -0.12079609f, 0.41811007f, 0.22927701f, 0.08694717f, 0.07586095f, -0.07062893f, 0.01345998f, 
    -0.03366683f, -0.09713500f, 0.02071366f, 0.00684047f, -0.19907521f, 0.19815758f, 0.06051148f, -0.23038684f, 
    -0.01020818f, 0.06759031f, 0.13093722f, -0.02588486f, 0.06944420f, -0.03818781f, -0.01925801f, -0.04574715f, 
    0.13969889f, -0.12853700f, 0.09264715f, -0.00082573f, 0.02548898f, 0.02033393f, -0.02646613f, 0.00730880f, 
    0.02227806f, -0.10307043f, 0.12017553f, 0.04400947f, -0.28111276f, -0.37963194f, 0.37895048f, 0.40251452f, 
    0.07201967f, -0.03015817f, 0.05894104f, 0.06257517f, 0.03202817f, -0.02932149f, -0.00493785f, 0.01625212f, 
    0.12679377f, 0.15148114f, 0.12739898f, 0.03959266f, 0.01723451f, 0.12076864f, 0.05900760f, 0.01289050f, 
    -0.01333800f, -0.00818294f, 0.04831374f, 0.09052026f, 0.14670864f, -0.03489179f, -0.00881318f, 0.05797716f, 
    0.06045067f, -0.06289796f, 0.02965652f, 0.05182936f, -0.02925394f, -0.09825663f, -0.03448151f, -0.15153272f, 
    0.26498923f, 0.18958521f, 0.18186980f, -0.06288584f, 0.08114054f, -0.00872914f, 0.09375139f, -0.05217729f, 
    0.02378127f, 0.00206418f, 0.16024230f, 0.03851956f, 0.19348736f, 0.07910150f, 0.15769631f, -0.02595604f, 
    0.10744164f, 0.07871659f, 0.15176949f, 0.10720065f, -0.03321577f, -0.03851537f, -0.16918984f, -0.12794518f, 
    0.14044385f, -0.02628442f, -0.32903492f, -0.14790033f, 0.02395094f, -0.05633811f, 0.06630265f, 0.01751376f, 
    0.08764803f, -0.04388032f, -0.11813968f, 0.07019965f, 0.15146397f, 0.28541800f, -0.08946800f, -0.06645992f, 
    0.05958261f, -0.08803060f, 0.01102419f, 0.15352075f, 0.02535635f, 0.00229769f, 0.02793320f, -0.10785250f, 
    0.05957228f, -0.11218587f, 0.20598418f, -0.02902328f, 0.22682548f, -0.15414321f, -0.05004663f, -0.04169485f, 
    -0.03444314f, 0.01439612f, -0.01969595f, -0.12522541f, 0.06701638f, -0.00404703f, 0.00287496f, 0.03782203f, 
    -0.01882771f, -0.09151305f, 0.06203209f, 0.08940672f, 0.01174757f, -0.11813284f, 0.05303084f, 0.04988850f, 
    0.00394896f, -0.06590007f, 0.02444021f, 0.00846059f, -0.06898618f, -0.04941663f, -0.03099389f, -0.02562841f, 
    -0.06416541f, 0.00632121f, -0.04020942f, -0.05833108f, -0.03299256f, -0.03559285f, -0.00222356f, 0.01890973f, 
    0.01492656f, -0.07056763f, 0.01578565f, -0.04337067f, -0.02956579f, -0.01584965f, -0.01631774f, -0.05077269f, 
    -0.04362724f, -0.06828467f, -0.05577084f, 0.01518731f, -0.01904404f, -0.06680540f, 0.01811096f, -0.00003740f, 
    -0.02163677f, -0.05139827f, -0.05529789f, -0.02631233f, -0.00280967f, -0.04220841f, -0.05522737f, -0.02701307f, 
    -0.00981078f, -0.02422201f, -0.03773814f, -0.04106094f, -0.05712508f, 0.01364149f, -0.04826809f, 0.00633053f, 
    -0.04884392f, -0.04672543f, -0.03382745f, -0.02288940f, -0.00447912f, -0.04726766f, 0.00865327f, 0.01909112f, 
    -0.04481328f, -0.00259419f, -0.03958213f, -0.02942667f, -0.02543015f, 0.01882611f, 0.02495772f, -0.02217405f, 
    0.03050502f, -0.03903315f, 0.02642964f, -0.06257077f, -0.07135636f, -0.05371379f, -0.03640212f, -0.04119039f, 
    -0.03194389f, -0.04127658f, 0.00338170f, -0.05088740f, 0.04237163f, 0.02154786f, -0.02054537f, -0.04484309f, 
    -0.02650412f, -0.02365427f, 0.02834370f, -0.01413613f, -0.02540418f, -0.00281512f, 0.01081448f, -0.03675433f, 
    0.00448836f, -0.03662149f, 0.02047613f, -0.02374367f, -0.06674583f, -0.03540434f, -0.01694390f, -0.03117524f, 
    -0.06405541f, -0.04891097f, 0.02165451f, 0.04440539f, 0.00975037f, -0.05839665f, 0.01964777f, -0.00460311f, 
    -0.01843500f, 0.00636723f, -0.03465637f, -0.00911415f, -0.04966227f, -0.04653665f, -0.00723745f, -0.01394160f, 
    -0.04744928f, -0.00987338f, -0.06539719f, -0.06684145f, -0.02139644f, 0.00121648f, -0.02020733f, 0.02347316f, 
    -0.04550564f, -0.00442159f, 0.02687952f, -0.03496300f, 0.01498328f, 0.02584072f, -0.03433380f, 0.01016524f, 
    -0.01166181f, 0.00701686f, 0.02915892f, -0.06269208f, -0.02285677f, -0.04056607f, 0.01264579f, -0.03000283f, 
    0.02865032f, -0.02124687f, 0.00027993f, -0.02527027f, -0.02815360f, 0.02603505f, 0.00637356f, -0.03885957f, 
    0.02682685f, -0.05940258f, -0.04142327f, -0.04876433f, -0.03864712f, 0.00670189f, -0.04234733f, -0.06877363f, 
    0.01113915f, -0.01744114f, 0.01486267f, -0.05813172f, 0.01874060f, -0.03333702f, -0.02715607f, -0.02065463f, 
    -0.03200107f, -0.02731371f, -0.04073248f, -0.04407473f, 0.02352994f, -0.06891178f, -0.00934985f, -0.01503596f, 
    -0.04749159f, -0.03850135f, -0.04512867f, 0.01620918f, -0.06816704f, -0.00847610f, -0.00675913f, -0.02182328f, 
    -0.06538339f, -0.00168460f, -0.05757813f, -0.02863965f, 0.00451180f, -0.06272509f, -0.01868547f, -0.05721899f, 
    -0.00967870f, -0.06127579f, -0.03683795f, -0.01070576f, -0.05609198f, -0.04174974f, -0.04945683f, 0.01803755f, 
    -0.02465344f, 0.01839425f, 0.03876447f, -0.04244833f, -0.03250487f, -0.06678604f, -0.01261351f, 0.02875342f, 
    -0.03323665f, -0.00978364f, -0.00144295f, -0.02258799f, -0.01641506f, -0.02609763f, -0.04808630f, -0.00255794f, 
    0.02075488f, -0.06156427f, -0.03884151f, -0.05124382f, -0.00754400f, -0.03578086f, 0.02927160f, -0.06065654f, 
    -0.06362477f, -0.03319496f, -0.04758826f, -0.02536437f, -0.00805343f, -0.01038880f, -0.04048841f, 0.01258250f, 
    -0.05067417f, -0.04783911f, -0.05129623f, -0.06528464f, -0.02903652f, -0.04681190f, -0.01157039f, -0.06313768f, 
    -0.04594856f, -0.00895288f, -0.06129748f, 0.02494359f, -0.04873449f, 0.01071558f, 0.00260101f, -0.00056145f, 
    -0.04853074f, -0.02752445f, -0.06762245f, 0.02712974f, -0.05899660f, -0.02172587f, -0.05155944f, -0.02295035f, 
    -0.03394467f, 0.00893683f, -0.01354147f, 0.00999707f, -0.04761498f, -0.03436190f, -0.04556201f, 0.03047258f, 
    0.02070050f, -0.02659295f, -0.04299362f, 0.01040949f, -0.03459186f, 0.02798033f, -0.03054945f, -0.00686781f, 
    -0.00429588f, -0.04999720f, -0.00308156f, -0.06428776f, -0.05091448f, -0.04866821f, -0.03579575f, -0.07183702f, 
    0.00076306f, -0.03651270f, -0.00854184f, -0.04322580f, -0.06777533f, -0.03036293f, 0.02053205f, 0.00833013f, 
    -0.03034052f, -0.03595975f, -0.02364068f, 0.00470097f, 0.02288713f, -0.02900682f, -0.02866539f, -0.02686801f, 
    -0.03683658f, 0.00098933f, -0.04064035f, 0.03048538f, 0.03470299f, -0.03944889f, 0.01994850f, -0.05530514f, 
    0.03969296f, -0.06768863f, 0.02125080f, -0.04853698f, 0.02234362f, -0.04030623f, -0.07118758f, 0.00763180f, 
    -0.04778484f, -0.06401864f, 0.01929715f, -0.06571237f, -0.00844072f, -0.01609262f, -0.00509709f, -0.00572719f, 
    0.00644055f, 0.03062279f, 0.01228074f, -0.02377325f, -0.05436742f, -0.04359991f, -0.02170179f, 0.01614530f, 
    -0.06554892f, -0.00070043f, 0.02004118f, 0.01969920f, -0.04507456f, 0.02142665f, -0.01629277f, -0.00537271f, 
    0.01202125f, -0.06340933f, -0.05871166f, -0.04517969f, -0.03445796f, -0.07109477f, 0.01194574f, -0.01925008f, 
    0.02411139f, -0.03335204f, -0.06216321f, -0.01545812f, -0.01858456f, -0.05782112f, -0.01787324f, -0.03839028f, 
    0.02571716f, -0.00395679f, -0.02968810f, -0.06646524f, 0.01483173f, -0.06376665f, -0.06223668f, -0.04579773f, 
    -0.00603012f, -0.04703383f, -0.06965923f, -0.02743875f, -0.07038596f, -0.02267037f, 0.02552813f, -0.03473555f, 
    -0.04993942f, 0.00763120f, -0.01179542f, -0.04074807f, -0.04957672f, -0.06993601f, 0.01215108f, 0.01674115f, 
    0.01267666f, -0.04948024f, -0.02114039f, -0.06905854f, 0.00770894f, 0.05012265f, 0.00878154f, -0.02230942f, 
    -0.03578736f, 0.00246603f, 0.02297299f, 0.00036453f, 0.00437207f, -0.05226108f, -0.02110168f, -0.04593852f, 
    -0.07828321f, 0.20442769f, -0.16485830f, -0.07856806f, 0.10302068f, 0.02779681f, 0.09633279f, -0.04486417f, 
    -0.00238877f, -0.00070787f, -0.06556221f, 0.07008025f, 0.03696644f, -0.20863225f, -0.10559620f, 0.16681047f, 
    -0.01082019f, -0.01905345f, -0.19780295f, -0.05391645f, -0.04069012f, 0.01538409f, -0.07041758f, -0.08579812f, 
    -0.27674940f, 0.16518372f, -0.07073468f, 0.26115286f, 0.07952571f, -0.02153435f, 0.02618788f, -0.01095197f, 
    0.02820896f, 0.10661882f, 0.02046432f, 0.03338059f, 0.06811775f, 0.15295953f, -0.16750024f, -0.21350545f, 
    0.21551949f, 0.00430424f, 0.03816833f, 0.10052824f, -0.03445433f, 0.16528378f, 0.02573586f, 0.11726640f, 
    0.09988664f, -0.05619355f, 0.01552751f, 0.21129793f, -0.02652095f, 0.09561416f, -0.01127088f, -0.04748046f, 
    -0.13629454f, 0.00767040f, -0.05243897f, -0.04591464f, 0.09882744f, 0.23980391f, -0.02902342f, 0.23094456f, 
    0.07959765f, 0.06429061f, 0.15553193f, -0.02557375f, 0.12815164f, -0.10825018f, 0.07175653f, 0.11134573f, 
    0.17283477f, 0.06675114f, -0.04798802f, -0.01197457f, -0.11416063f, -0.09400269f, 0.02141484f, -0.00319963f, 
    0.12840037f, 0.11320787f, -0.04074341f, 0.19108693f, -0.02529361f, 0.11454624f, -0.27493331f, -0.34854573f, 
    -0.05392055f, 0.03864736f, 0.07306889f, -0.00879161f, -0.02540537f, -0.08078406f, -0.05501845f, 0.04480732f, 
    -0.14238521f, -0.06007383f, 0.22463298f, -0.03949709f, 0.10824811f, 0.08648221f, -0.09920964f, 0.00897989f, 
    0.16955744f, 0.05804512f, 0.11796054f, 0.13867585f, 0.29175350f, 0.25500831f, -0.03594293f, -0.00239005f, 
    0.11055793f, 0.12502353f, 0.07404558f, 0.11043081f, 0.10824103f, 0.04219172f, 0.08301199f, 0.18257338f, 
    0.06861841f, 0.07925797f, 0.04080776f, -0.05560512f, 0.04691420f, -0.01777885f, -0.08504727f, 0.02443506f, 
    -0.03086833f, 0.02555368f, 0.03800875f, -0.26574954f, 0.03964366f, -0.01963755f, 0.12937579f, 0.09227786f, 
    0.12264837f, 0.06910726f, 0.10502599f, 0.02184527f, -0.08353911f, -0.05871814f, 0.05514953f, 0.16690151f, 
    -0.10201593f, -0.15024829f, 0.69101548f, 0.14458174f, 0.01152148f, 0.08321176f, -0.22636937f, 0.04413008f, 
    -0.04141432f, -0.05330288f, 0.05017955f, -0.02741299f, 0.04322478f, 0.19886507f, -0.08653626f, -0.14936283f, 
    -0.25427479f, 0.08651679f, -0.09247717f, -0.00340646f, 0.04736383f, -0.05299500f, -0.01432780f, 0.06146936f, 
    -0.34634611f, 0.10539568f, -0.02351011f, 0.23538806f, 0.03294785f, -0.01201824f, -0.00273417f, 0.03263164f, 
    0.00662833f, 0.17398337f, 0.09688781f, 0.15468621f, -0.17713766f, 0.08599815f, -0.15981157f, -0.01718235f, 
    -0.02557253f, -0.02390118f, 0.17525665f, -0.00341698f, 0.14789955f, 0.11012352f, -0.00020901f, 0.10918164f, 
    0.09379943f, -0.01983369f, 0.02869512f, 0.09447022f, -0.00975297f, -0.01323806f, 0.00321515f, -0.01021927f, 
    0.02088184f, 0.04705099f, -0.04706388f, -0.03204383f, -0.06754951f, -0.26822796f, -0.12188098f, 0.00456596f, 
    -0.09643457f, -0.07351530f, 0.10139980f, 0.03418405f, -0.10110594f, -0.14787075f, 0.00788088f, -0.17435975f, 
    -0.10965840f, -0.16175048f, -0.03006099f, 0.09085502f, -0.10547532f, 0.03314091f, -0.06768028f, -0.24569818f, 
    -0.10394730f, -0.05288640f, -0.16770464f, -0.09266012f, -0.28829676f, 0.08397675f, 0.14365424f, 0.19945171f, 
    0.05024974f, 0.02973674f, 0.00730963f, 0.02223545f, -0.07660404f, 0.02297108f, 0.01455174f, -0.18746677f, 
    -0.17049725f, -0.06350189f, 0.40081328f, 0.12895148f, -0.00747708f, -0.04813377f, -0.14295623f, -0.10246713f, 
    -0.11754368f, 0.01877165f, 0.01378281f, 0.04858987f, 0.54092026f, -0.06405829f, 0.21375115f, 0.25490639f, 
    0.13995849f, 0.18447794f, 0.04917773f, 0.05885467f, -0.08222755f, 0.03229921f, -0.04969226f, 0.14933874f, 
    -0.08586986f, 0.11066556f, 0.15643121f, 0.23030229f, 0.00477655f, -0.00701822f, -0.03381813f, 0.02708999f, 
    -0.04579141f, 0.14408703f, 0.03233527f, 0.04968102f, -0.18496126f, 0.01588558f, 0.36625931f, 0.22078608f, 
    0.13392116f, 0.03062503f, 0.05415905f, 0.03379013f, 0.05376538f, -0.02877199f, 0.01328039f, 0.07355453f, 
    0.19933398f, -0.10077235f, -0.21464321f, 0.02587978f, -0.03453185f, 0.05900523f, 0.13669282f, 0.03063859f, 
    -0.17678769f, 0.04594967f, -0.01581976f, -0.05982760f, -0.09525195f, 0.21474569f, 0.11992613f, 0.01059349f, 
    0.01455180f, -0.02003690f, -0.08980564f, -0.05019259f, -0.08839021f, -0.07756452f, -0.22401038f, -0.10919636f, 
    0.00912666f, -0.24591008f, -0.21063007f, -0.01596662f, 0.06791216f, 0.08879926f, 0.14040308f, 0.05375753f, 
    -0.01212761f, 0.11276489f, -0.09205252f, -0.07716063f, 0.28372699f, -0.13035718f, -0.15439324f, -0.14541993f, 
    0.06735741f, 0.02229953f, 0.00491105f, 0.18918729f, -0.01590802f, -0.02418766f, 0.06140121f, -0.12718585f, 
    0.29446661f, -0.06204170f, 0.19102259f, 0.21051827f, -0.05715000f, 0.05819597f, 0.10223267f, 0.13701002f, 
    -0.16203630f, -0.02145071f, -0.00599117f, 0.08290052f, -0.03378103f, 0.12439854f, -0.02983407f, 0.13313144f, 
    -0.20408076f, -0.01410013f, -0.04193505f, -0.05812294f, 0.11326145f, -0.01170517f, -0.10204568f, 0.06945214f, 
    0.47761813f, 0.40534854f, -0.13213159f, -0.09663472f, -0.00115352f, -0.20593588f, -0.05869704f, -0.03144167f, 
    -0.06917988f, 0.03870357f, 0.01926667f, -0.06405976f, 0.12150066f, -0.08550952f, -0.04625811f, -0.07437225f, 
    0.04615283f, -0.07021932f, 0.04903262f, -0.05172631f, -0.02444184f, 0.01118042f, -0.01005843f, 0.13120082f, 
    0.07808848f, -0.05082999f, 0.33679268f, 0.16584919f, 0.02649244f, -0.05545748f, 0.07128035f, 0.00179005f, 
    0.00586164f, -0.08446877f, 0.12262356f, 0.07532045f, -0.15586905f, -0.15398775f, 0.10125122f, -0.03915534f, 
    -0.07222428f, -0.10670306f, -0.04174107f, 0.02824714f, -0.10939222f, -0.03797425f, -0.05813665f, -0.09841897f, 
    0.12350555f, -0.04072016f, 0.10507351f, -0.07909181f, -0.04928990f, -0.03521566f, -0.04373804f, -0.00624266f, 
    0.12142731f, 0.10282409f, 0.10282464f, 0.16164891f, 0.16155130f, 0.11110071f, -0.01798441f, 0.02606050f, 
    0.19599362f, -0.02068385f, -0.04742753f, 0.10799997f, -0.09338925f, 0.04448500f, -0.02720815f, 0.07344826f, 
    0.01940930f, -0.01473713f, 0.01680783f, 0.12916256f, -0.07266465f, 0.23263764f, -0.04574211f, 0.10067544f, 
    0.03517791f, -0.00715845f, -0.07517982f, -0.07731606f, 0.07015716f, 0.26438615f, -0.27937573f, 0.00300640f, 
    0.08027106f, 0.02318539f, 0.07370758f, -0.15052556f, 0.14349067f, 0.10369039f, 0.08732798f, -0.02041844f, 
    0.18198438f, 0.01079265f, 0.21664663f, -0.04019417f, -0.04519852f, 0.01070296f, -0.01100796f, 0.00413759f, 
    -0.01997992f, 0.06561658f, -0.01280876f, 0.01472031f, 0.05334686f, 0.22487375f, -0.03983391f, 0.05320355f, 
    -0.08307163f, -0.00954849f, -0.03540294f, 0.00780142f, -0.08897868f, -0.00330139f, 0.17024007f, -0.00916238f, 
    -0.08772531f, -0.01415132f, 0.04999772f, -0.20948267f, 0.11545645f, -0.00014706f, -0.05321112f, 0.07021266f, 
    0.00781699f, 0.04044438f, 0.10664417f, 0.08396171f, -0.00826831f, 0.00115926f, -0.08360595f, -0.16237395f, 
    0.04596978f, 0.18065093f, -0.07177373f, 0.00951949f, 0.20866838f, 0.10987549f, 0.13907197f, -0.03352581f, 
    -0.11159589f, 0.00774109f, -0.19293639f, -0.06324597f, 0.00870373f, 0.00336685f, 0.00710761f, 0.00695772f, 
    0.01471560f, 0.07461591f, 0.00758200f, -0.11783957f, -0.01552053f, 0.02470685f, 0.01938290f, 0.11143336f, 
    -0.03829351f, -0.08865006f, 0.10929795f, -0.07388267f, 0.20423201f, 0.02435290f, 0.07709034f, 0.00459868f, 
    -0.13367428f, -0.09112042f, 0.22386424f, -0.28207994f, -0.20259921f, 0.00916445f, 0.06322094f, -0.06359448f, 
    -0.10022999f, -0.10741567f, 0.04790827f, -0.03617176f, -0.01991058f, 0.04097102f, -0.05437449f, 0.02961287f, 
    -0.02849772f, 0.01097385f, -0.05903379f, -0.00958446f, 0.03545287f, 0.08563817f, 0.06232844f, 0.08205699f, 
    -0.20695671f, 0.17146929f, 0.19726612f, -0.05821163f, -0.04628400f, 0.02568183f, 0.11528167f, -0.00223170f, 
    0.14571680f, 0.12643436f, -0.17026597f, 0.18707693f, -0.00193055f, 0.02177489f, 0.00301619f, 0.01706207f, 
    -0.02158455f, 0.00856138f, 0.02051547f, -0.02185214f, 0.17368504f, 0.06450988f, 0.01195643f, 0.09447120f, 
    -0.07384968f, 0.06603245f, -0.02676285f, 0.12987588f, 0.04045643f, 0.10998158f, 0.07404491f, 0.17065233f, 
    -0.04045551f, 0.07423026f, -0.06997543f, 0.00412961f, -0.25770754f, -0.14994781f, -0.04564630f, 0.10055916f, 
    -0.15895912f, -0.13717826f, -0.01120310f, -0.04208966f, -0.02933275f, -0.08576140f, -0.00564580f, -0.12178975f, 
    -0.09226237f, 0.02509956f, -0.04469298f, 0.03045286f, -0.00742313f, 0.22254965f, 0.04309987f, 0.09727620f, 
    -0.04577360f, 0.01893261f, -0.03925959f, -0.05050961f, 0.23877053f, 0.27749658f, 0.22053772f, 0.01146769f, 
    -0.00190539f, 0.00111998f, 0.05524865f, 0.04359371f, -0.06487099f, 0.22684547f, 0.01770940f, -0.10943294f, 
    -0.02203165f, -0.03655344f, 0.37510878f, -0.23232131f, -0.04922011f, -0.04553013f, -0.01773132f, 0.03309023f, 
    0.03117889f, -0.00936493f, -0.01897459f, 0.00250792f, 0.29565161f, 0.10013282f, 0.19410169f, 0.05551973f, 
    0.09217028f, 0.10457944f, -0.05351043f, -0.09928742f, 0.01497987f, -0.04846732f, -0.05766258f, 0.03952301f, 
    0.08606283f, 0.21562891f, -0.05495615f, 0.20847620f, 0.08375567f, -0.07603989f, -0.15778333f, -0.05206910f, 
    -0.12071545f, 0.04050801f, 0.05796310f, 0.13217248f, -0.26195207f, -0.06224058f, 0.03785933f, -0.10243147f, 
    -0.06054779f, 0.06483672f, 0.01318542f, -0.02617508f, 0.05377323f, -0.12423133f, 0.00338692f, -0.00522086f, 
    0.00060199f, -0.01489852f, 0.03597078f, 0.14453042f, 0.07267937f, -0.05298649f, 0.00170527f, 0.06339642f, 
    0.04798011f, -0.02359838f, 0.04346247f, -0.06260235f, -0.01923592f, -0.04183963f, -0.13190340f, -0.10267911f, 
    0.00473173f, 0.03355105f, -0.00512113f, -0.03282448f, 0.04140919f, -0.00309401f, -0.14332312f, -0.05109077f, 
    -0.30077043f, -0.21603844f, -0.22586064f, 0.06964698f, -0.01581297f, 0.11039511f, 0.08497883f, 0.08554086f, 
    0.11113209f, 0.10580011f, -0.01004945f, 0.05157174f, -0.06027524f, -0.14216979f, -0.28164485f, 0.09067996f, 
    0.07089449f, -0.14718795f, 0.04785348f, 0.16000785f, -0.11228848f, -0.01833725f, -0.05073453f, 0.00889585f, 
    0.16303580f, 0.07183361f, 0.16358353f, 0.13279893f, -0.05776952f, 0.06104381f, 0.05461026f, 0.01680953f, 
    -0.02764186f, -0.13838807f, 0.15768540f, 0.14515856f, -0.03955811f, -0.03256254f, 0.00652801f, -0.09270256f, 
    -0.09998738f, 0.09727641f, 0.03285738f, -0.05302863f, 0.10153932f, -0.08883816f, -0.13249007f, 0.08897879f, 
    0.20519061f, 0.33417854f, -0.45243186f, -0.19903827f, -0.04120159f, -0.06335403f, -0.01738000f, -0.02607596f, 
    -0.00508585f, 0.02602633f, 0.07274681f, -0.11834364f, 0.04558133f, -0.02309063f, -0.19310638f, -0.00488499f, 
    0.07523175f, 0.05431008f, 0.02319206f, 0.08281463f, -0.01757448f, 0.07806987f, 0.06498466f, -0.02710475f, 
    -0.31878743f, 0.36620006f, -0.01658627f, -0.07824216f, 0.09785475f, 0.08571186f, -0.13276926f, 0.04139867f, 
    -0.11857912f, -0.07144966f, -0.10595550f, 0.03249725f, -0.10551658f, -0.19506629f, -0.05283357f, 0.24426846f, 
    -0.08802091f, -0.19366059f, -0.17415504f, -0.08542474f, -0.08769728f, 0.01909485f, 0.00943786f, -0.03607782f, 
    -0.08706737f, 0.15829703f, -0.05978207f, -0.04075466f, 0.04847330f, -0.09236806f, 0.12339100f, 0.01484034f, 
    -0.07207688f, 0.20679407f, 0.12367941f, 0.16948414f, -0.24679279f, -0.01573437f, -0.21339549f, 0.30218837f, 
    0.22193870f, 0.08758681f, -0.07609179f, 0.08793993f, -0.17975004f, 0.02198198f, 0.13264200f, -0.02572256f, 
    -0.18410699f, -0.22895817f, 0.10213447f, 0.17288038f, -0.13764358f, -0.02654495f, 0.07501543f, -0.06570592f, 
    0.04350547f, -0.01826914f, 0.03000277f, -0.10126128f, -0.69475991f, 0.12568778f, 0.27887371f, 0.22334313f, 
    0.08427411f, 0.23946534f, -0.17913605f, 0.20194647f, -0.02860777f, -0.11889225f, 0.02728393f, 0.10308239f, 
    0.12708497f, 0.12208578f, -0.03750550f, 0.05168928f, 0.00221517f, -0.00316783f, 0.06064770f, -0.05444936f, 
    0.24630615f, 0.08391791f, 0.11562940f, 0.10387576f, -0.18207689f, 0.21586213f, 0.01213553f, -0.15331186f, 
    0.06558556f, 0.20536268f, -0.09686223f, -0.00496899f, -0.01739301f, 0.07391378f, -0.04398055f, 0.01755112f, 
    0.12068591f, 0.04264201f, 0.13497582f, 0.15407147f, 0.03474829f, 0.07470851f, 0.10210031f, -0.08682114f, 
    0.16874586f, -0.02579993f, 0.02034820f, 0.20652919f, 0.05385406f, -0.17568205f, -0.24673727f, 0.13962066f, 
    -0.18461193f, 0.20392190f, 0.26719186f, -0.04914823f, -0.07318635f, 0.10008683f, 0.13892625f, 0.06064047f, 
    -0.00650989f, -0.29733750f, 0.01735444f, 0.20598607f, -0.01191236f, 0.09881420f, 0.04207762f, 0.05541301f, 
    -0.03583137f, -0.13760309f, 0.04522187f, -0.15137210f, -0.26522419f, 0.17751865f, 0.33246735f, -0.00310892f, 
    -0.09721005f, -0.00646407f, -0.19024849f, 0.04472153f, -0.13063614f, 0.23171271f, 0.24817748f, 0.08534185f, 
    0.13529405f, -0.34768417f, 0.31200206f, -0.11537041f, -0.01931385f, 0.20645864f, 0.17736688f, 0.15392578f, 
    0.02264341f, -0.03381377f, -0.05261445f, -0.11778288f, 0.02060264f, 0.06272260f, -0.14473914f, -0.06888939f, 
    -0.08475789f, 0.11507386f, -0.01924713f, 0.14456253f, -0.04004677f, -0.04259180f, 0.02576849f, 0.02679507f, 
    -0.04105701f, 0.23990652f, 0.05085169f, 0.12115835f, -0.04625817f, -0.00030468f, 0.19231977f, -0.02879775f, 
    0.16199353f, 0.10197658f, 0.17486626f, 0.06334463f, -0.14473197f, -0.02147930f, -0.13569701f, -0.09398587f, 
    0.06957861f, 0.08773167f, 0.02150183f, 0.00588568f, 0.10333303f, 0.12445959f, 0.05349218f, 0.05375239f, 
    0.00930715f, -0.01397454f, 0.36447787f, 0.07361508f, -0.14441669f, -0.16475615f, -0.18113381f, 0.02295086f, 
    -0.03789056f, -0.05295844f, 0.01399443f, -0.13620380f, -0.38697928f, -0.14957772f, -0.10561731f, 0.16909602f, 
    -0.14767516f, -0.05741574f, -0.00878823f, 0.01078016f, 0.03893569f, 0.05427637f, -0.00386968f, -0.03669206f, 
    0.00901032f, 0.03228397f, 0.11143598f, 0.08085950f, 0.10422712f, -0.00048466f, 0.10211758f, -0.10828838f, 
    0.09927258f, -0.09717195f, -0.11122429f, -0.05729856f, -0.02631269f, 0.32426965f, 0.16977188f, 0.21543927f, 
    0.07465340f, -0.13408379f, -0.00158756f, 0.06916496f, -0.07653582f, -0.03332814f, 0.00074274f, 0.01164221f, 
    0.24825525f, -0.07585610f, -0.12819853f, -0.07890876f, -0.13534991f, 0.13471721f, 0.20427379f, -0.12948766f, 
    -0.09238288f, 0.03019430f, 0.00042730f, -0.13957280f, 0.43953061f, -0.11028816f, 0.08341867f, 0.33952278f, 
    -0.03422879f, -0.04787960f, 0.03653676f, -0.00118776f, 0.07500433f, 0.04117724f, 0.01526690f, 0.13962759f, 
    -0.14490256f, 0.03191596f, 0.10322601f, -0.14667721f, -0.02281888f, 0.12201249f, 0.10822599f, -0.01788519f, 
    0.09166162f, 0.01038062f, 0.02443171f, 0.18627301f, -0.01151537f, 0.08754214f, -0.12015640f, 0.40420839f, 
    0.02711474f, -0.08769076f, 0.10116370f, -0.05063697f, -0.02192828f, 0.15888639f, -0.00059298f, -0.03273105f, 
    -0.30137870f, -0.33558887f, -0.07941247f, 0.16344614f, 0.14036462f, 0.19512117f, -0.14169642f, -0.15793520f, 
    -0.02292655f, 0.09318461f, 0.14933059f, 0.00869490f, -0.07616990f, 0.07376271f, 0.06264430f, -0.18917200f, 
    0.01066570f, 0.03725008f, 0.21993344f, 0.09001095f, -0.06169378f, -0.02524494f, -0.05005009f, -0.10201814f, 
    -0.24462979f, -0.16320048f, 0.15629755f, 0.21455656f, 0.08955345f, -0.09944429f, 0.04605732f, -0.11167527f, 
    -0.02141099f, 0.19280539f, -0.04286095f, 0.01935088f, -0.16453893f, -0.03315606f, 0.12066200f, 0.03448621f, 
    0.03293031f, -0.07610436f, -0.20843311f, 0.24483407f, -0.11889505f, -0.05900265f, -0.07183753f, -0.14820935f, 
    0.02610598f, 0.34345892f, 0.47343072f, 0.23874345f, -0.04623931f, -0.19589670f, 0.02427893f, -0.05960186f, 
    0.01681127f, 0.13333370f, -0.00497191f, 0.02019701f, 0.09038630f, -0.00325589f, -0.13760379f, 0.12018449f, 
    -0.03203944f, 0.16243689f, 0.11838844f, -0.06149321f, 0.03459034f, -0.06039108f, -0.01898555f, -0.03246003f, 
    0.04071531f, 0.13664436f, -0.34833303f, 0.02374582f, -0.00155695f, 0.19259575f, 0.06104390f, -0.00528858f, 
    -0.02880755f, -0.09746803f, -0.13453902f, -0.06250438f, -0.16605042f, -0.16398107f, -0.02481486f, 0.09334595f, 
    0.03294440f, 0.10551695f, 0.05028181f, -0.06093917f, 0.07078478f, 0.16425438f, 0.10361786f, 0.29309550f, 
    0.17881814f, -0.57204479f, 0.24567851f, 0.14762995f, -0.01736110f, -0.02078391f, 0.03863496f, 0.06668037f, 
    -0.02544025f, 0.11364085f, 0.14719763f, 0.02913665f, -0.08525481f, 0.16624402f, 0.26721814f, -0.20847778f, 
    -0.05233028f, -0.06837749f, 0.02226462f, -0.01165477f, 0.05629554f, -0.04786091f, -0.00710225f, -0.11471326f, 
    0.25424829f, 0.03171306f, 0.08794457f, -0.06266836f, 0.07841810f, 0.04872331f, -0.04340734f, 0.01964552f, 
    0.04514776f, 0.02181745f, 0.07425907f, 0.01276995f, -0.09334467f, -0.28312573f, 0.10632881f, 0.38357732f, 
    -0.09325276f, -0.08204275f, -0.17247881f, -0.07624013f, 0.09411965f, -0.03691531f, 0.15589298f, 0.04802012f, 
    -0.16524999f, 0.11096407f, 0.02454563f, -0.03551415f, -0.00659200f, 0.09083992f, 0.07078765f, 0.00709778f, 
    -0.00719378f, 0.01001404f, 0.04864719f, 0.00150480f, -0.15713362f, -0.19270645f, 0.04912626f, -0.13806058f, 
    -0.00326515f, -0.03828503f, 0.19722761f, -0.02125703f, 0.04637863f, 0.04953649f, -0.03372047f, 0.00778305f, 
    -0.01280688f, 0.07908349f, 0.11312632f, 0.05784017f, 0.00293507f, -0.03241464f, -0.00700785f, -0.05059060f, 
    0.07561381f, 0.02843294f, 0.10185056f, -0.02256725f, 0.05170721f, -0.46055508f, 0.23551083f, 0.35570177f, 
    0.01499910f, -0.06155451f, -0.04133573f, 0.01001443f, 0.08511335f, 0.10069571f, 0.14034855f, 0.04857820f, 
    0.04382237f, 0.14745210f, -0.05961131f, -0.02773857f, 0.20042603f, 0.03208860f, 0.06576020f, 0.00200683f, 
    0.09807716f, 0.08087260f, 0.06838282f, 0.08617927f, -0.09830462f, -0.16256589f, -0.10423284f, 0.15003625f, 
    -0.11671428f, -0.10718556f, -0.05298930f, 0.12727204f, -0.07896756f, -0.15900733f, 0.12830178f, 0.02193086f, 
    -0.00387535f, -0.03105083f, 0.09860300f, -0.01318891f, -0.00698523f, 0.07795336f, 0.12028585f, 0.04530684f, 
    -0.00279761f, -0.02681315f, -0.06168253f, -0.03072615f, -0.13682529f, 0.01891698f, 0.04405540f, -0.02700166f, 
    -0.23841649f, -0.10434967f, -0.03492787f, -0.05790313f, 0.20242900f, -0.01142616f, -0.04011957f, 0.01417626f, 
    0.13469259f, 0.28369159f, -0.25034243f, -0.13376336f, 0.06659301f, -0.06412230f, 0.18777953f, 0.02938514f, 
    -0.04467677f, -0.06683547f, -0.04849263f, 0.03411081f, 0.36049724f, -0.05785654f, -0.01913672f, 0.12650365f, 
    -0.00727965f, 0.03128708f, -0.08955617f, 0.03465201f, 0.04086632f, -0.01621823f, 0.11015860f, -0.01949965f, 
    0.31798965f, 0.04056523f, 0.05164485f, -0.21268645f, -0.00156443f, 0.15421045f, 0.04339902f, 0.02095829f, 
    0.07648238f, 0.05067902f, 0.06467626f, -0.03153253f, 0.22228649f, -0.01310536f, 0.10984052f, 0.08720756f, 
    -0.03086176f, 0.02758703f, -0.00190398f, 0.08431491f, 0.07717143f, 0.02813303f, 0.12045183f, 0.01210207f, 
    -0.02485292f, 0.18668512f, 0.04318096f, -0.06515684f, -0.01337982f, -0.02861726f, 0.01916083f, 0.03901887f, 
    0.06159215f, 0.07456867f, -0.09975751f, -0.09715512f, -0.00815324f, 0.05648335f, 0.16159661f, 0.00472048f, 
    -0.10505753f, 0.00341428f, -0.03842659f, -0.10937893f, 0.00971536f, -0.00501125f, -0.04259994f, 0.03163175f, 
    -0.03249205f, -0.00398994f, -0.02336835f, -0.03109366f, 0.07768207f, 0.05671010f, 0.20293652f, 0.10419901f, 
    0.09374379f, 0.04846993f, 0.04133486f, 0.00730992f, 0.03948520f, 0.16342029f, 0.09109344f, -0.20549606f, 
    -0.00425008f, -0.10259897f, -0.01144771f, -0.05396263f, -0.15939294f, 0.07231952f, -0.05167308f, 0.15449256f, 
    0.26384699f, 0.14614575f, -0.06247628f, -0.03124981f, 0.03003804f, 0.13916662f, 0.08307463f, 0.02482511f, 
    0.02148716f, 0.03099174f, 0.04094449f, -0.01547052f, -0.44292182f, 0.16834831f, -0.04219639f, -0.07547824f, 
    -0.03203812f, 0.00705794f, -0.01512810f, -0.05315813f, 0.09155714f, -0.01794317f, -0.00019967f, -0.02197197f, 
    0.05901800f, -0.23386428f, 0.19836782f, -0.32144916f, 0.03094081f, 0.05153313f, -0.04359249f, -0.02961283f, 
    0.02240824f, -0.05723997f, 0.09683780f, 0.00061835f, 0.05964798f, -0.13510348f, -0.00845637f, 0.24099749f, 
    0.00405965f, 0.11559294f, 0.06863220f, -0.06094770f, -0.06088714f, -0.04207255f, 0.08715039f, 0.08713066f, 
    -0.17064275f, -0.09297184f, 0.23489258f, 0.09644175f, -0.03201831f, -0.07127545f, -0.08274238f, -0.12447623f, 
    0.06126506f, 0.03990636f, 0.06587923f, 0.06089329f, 0.36482641f, 0.04048625f, 0.08358734f, 0.16976771f, 
    -0.00169465f, 0.01700439f, 0.13856590f, 0.04731070f, 0.01458135f, 0.00302878f, -0.06127073f, 0.02222456f, 
    -0.08408284f, 0.03938613f, 0.20028831f, 0.12878615f, -0.03538012f, -0.00078612f, -0.03941151f, -0.10971355f, 
    0.10762752f, 0.01726255f, 0.04426512f, -0.02024933f, -0.15166433f, -0.23055072f, -0.05649791f, 0.11413527f, 
    0.14575258f, -0.05020591f, 0.03554463f, -0.06298758f, 0.12346946f, -0.01633346f, 0.02350856f, 0.08123676f, 
    -0.14370075f, 0.03029671f, 0.12661751f, -0.06098340f, -0.15092984f, -0.11941431f, 0.01504239f, 0.00816164f, 
    0.17560241f, -0.01690080f, 0.02151076f, 0.03042455f, 0.11060669f, -0.00735874f, -0.05039226f, 0.04607082f, 
    0.00891829f, 0.15505897f, 0.02145705f, 0.06120937f, 0.03848848f, -0.00309255f, 0.02347447f, -0.04424877f, 
    0.06148575f, -0.30115706f, 0.18829621f, 0.35580939f, 0.12409449f, 0.08279757f, 0.01725711f, -0.01629548f, 
    -0.03180151f, -0.10823662f, 0.04120044f, 0.02149181f, -0.12429958f, -0.10760496f, -0.04196625f, 0.08517433f, 
    0.10636833f, 0.12836674f, 0.12586488f, 0.06198707f, 0.19648029f, 0.07945655f, 0.08029027f, 0.10782716f, 
    0.05033420f, 0.01438882f, -0.14593115f, 0.16085963f, 0.00519614f, 0.02063905f, 0.10400396f, 0.03814077f, 
    0.02695818f, -0.00858173f, -0.00346149f, 0.04336482f, 0.24836832f, 0.15094477f, -0.03616264f, 0.30854109f, 
    0.11487423f, 0.06946656f, 0.09372025f, -0.01250407f, -0.05354255f, 0.03116875f, -0.03101693f, 0.03238575f, 
    -0.03098728f, 0.16941778f, -0.10211045f, 0.22187236f, -0.02399428f, -0.03811453f, 0.01267263f, 0.09553297f, 
    -0.21516262f, 0.06614622f, 0.11736704f, -0.06802665f, -0.21896909f, 0.19419375f, -0.24710689f, -0.27439743f, 
    -0.04830903f, 0.18324023f, 0.08804598f, 0.02764428f, 0.00133594f, -0.09033319f, 0.03324153f, -0.03805554f, 
    0.14334927f, 0.15534942f, 0.16282783f, 0.11463799f, 0.14141512f, 0.08266474f, 0.13609423f, -0.02660494f, 
    -0.02927237f, -0.03509169f, 0.00937475f, 0.04445183f, 0.13879985f, 0.11735255f, 0.26773772f, 0.00070727f, 
    -0.08655602f, 0.18661542f, -0.04824995f, 0.05185598f, 0.08327429f, 0.11707075f, 0.03370069f, -0.10948922f, 
    0.03345042f, -0.01315222f, -0.21286799f, -0.02757128f, 0.01721041f, -0.00367326f, 0.05523976f, -0.00814706f, 
    -0.01586874f, -0.06380735f, -0.06110290f, 0.16076879f, 0.05397472f, -0.08661984f, -0.18417580f, -0.25945219f, 
    -0.02912267f, 0.02369773f, 0.12069291f, 0.04179688f, -0.02472990f, 0.07410220f, -0.06895103f, 0.02413377f, 
    0.01995207f, -0.08901024f, 0.21103731f, 0.05356030f, -0.00600122f, -0.07168986f, -0.17893530f, -0.00939008f, 
    0.08717435f, 0.01866267f, 0.12308709f, 0.04034714f, 0.03005829f, 0.12775648f, 0.08761112f, -0.13815281f, 
    0.17404515f, -0.09999421f, 0.11053000f, 0.02038888f, -0.06147389f, -0.03249222f, -0.06355037f, -0.07518946f, 
    0.03759281f, 0.14538586f, 0.21179226f, 0.08309903f, 0.04849659f, 0.00331420f, -0.08140746f, -0.09324071f, 
    -0.08063447f, -0.10979278f, 0.16003338f, 0.05462484f, 0.03343543f, -0.09351471f, 0.05030384f, -0.08237754f, 
    0.17157020f, 0.08448663f, 0.02089186f, 0.00759964f, -0.20216736f, 0.10170380f, -0.10640229f, 0.18257654f, 
    0.19103342f, -0.12831491f, 0.51452363f, 0.14334165f, 0.00477108f, -0.16637135f, -0.40151227f, -0.16215266f, 
    -0.02729994f, 0.06451865f, -0.00195491f, -0.02854992f, -0.03176489f, 0.08734190f, 0.05096357f, -0.04863627f, 
    -0.01758683f, -0.04127850f, 0.04889904f, 0.06034875f, 0.03119168f, 0.04695308f, 0.01218738f, 0.11389683f, 
    -0.13324195f, -0.33709198f, -0.06474221f, 0.12908651f, 0.00171721f, 0.09012181f, 0.10285366f, -0.01902425f, 
    -0.08215038f, -0.04586766f, 0.08807456f, 0.21000837f, -0.04966445f, 0.11708455f, -0.13174364f, 0.00532732f, 
    -0.02674318f, 0.02074987f, 0.01777693f, -0.03202666f, -0.04696225f, -0.07613096f, -0.02345379f, 0.12682171f, 
    0.20683657f, -0.11721434f, 0.03888389f, 0.01701220f, -0.08513708f, 0.08616582f, 0.00196451f, -0.13386554f, 
    0.04897306f, -0.07119957f, 0.06002434f, -0.07729717f, 0.23756407f, 0.07353144f, 0.02446847f, -0.09401882f, 
    0.03763823f, -0.05421486f, 0.06471340f, 0.26556790f, 0.03390626f, -0.06876040f, 0.02415130f, 0.02722178f, 
    -0.09693477f, 0.05125453f, 0.05863487f, -0.01133771f, -0.13031694f, -0.11270622f, 0.07568552f, -0.06951105f, 
    -0.12148798f, -0.06737220f, -0.00138009f, -0.06589402f, -0.05263712f, -0.04834026f, 0.08756411f, 0.03642770f, 
    -0.08167807f, 0.17355660f, -0.11037188f, 0.04084747f, -0.06043573f, -0.07647834f, 0.05716808f, -0.20259990f, 
    0.04205918f, -0.21584770f, 0.48841169f, 0.10672902f, 0.07194202f, -0.03568943f, -0.07115820f, -0.06121861f, 
    -0.07988480f, -0.01048644f, 0.08590478f, -0.01151782f, 0.27934822f, 0.02836030f, 0.16486900f, -0.06207916f, 
    0.06673642f, -0.02820880f, 0.14060940f, 0.03579668f, -0.09997030f, 0.09152338f, -0.08531500f, -0.04799194f, 
    0.05941042f, 0.04883357f, -0.12221463f, 0.20639880f, -0.08954099f, 0.03763822f, -0.03164551f, 0.03752945f, 
    0.03530648f, 0.01298581f, -0.00948218f, 0.04712806f, -0.26151106f, 0.02186303f, 0.24871281f, 0.26272091f, 
    0.02927004f, -0.01420114f, 0.06453803f, 0.14148165f, 0.08050446f, 0.04266567f, 0.01778173f, 0.05959217f, 
    0.22402415f, 0.06133686f, -0.15821929f, 0.07016645f, 0.03414730f, 0.03400873f, 0.11714794f, -0.01086217f, 
    -0.01710533f, -0.02679607f, -0.05580857f, -0.00195231f, -0.07722227f, 0.18717146f, 0.17015335f, 0.08468445f, 
    -0.04868133f, 0.07506289f, -0.08315931f, 0.10149934f, -0.10806820f, 0.03605621f, 0.07092441f, -0.05344587f, 
    0.17128146f, -0.05122789f, -0.06756582f, 0.05995627f, 0.03559451f, 0.08364050f, 0.03531543f, 0.01286513f, 
    -0.01660432f, 0.02136848f, -0.00175451f, 0.04772486f, 0.22572142f, 0.27029938f, 0.17894854f, 0.04711751f, 
    0.01222452f, 0.31380224f, 0.04442682f, 0.21828221f, -0.00351043f, 0.04419155f, 0.04688847f, -0.10199632f, 
    0.38793504f, 0.04802763f, -0.08110100f, -0.11321565f, 0.05733747f, -0.03629465f, 0.16155468f, 0.17296031f, 
    -0.07432658f, 0.09579072f, -0.12121364f, -0.09446131f, -0.04239699f, 0.24268979f, 0.10500602f, 0.12619796f, 
    -0.09907846f, -0.20128764f, 0.00126606f, -0.02688112f, -0.01385667f, 0.01998606f, 0.04379591f, -0.01731685f, 
    0.20459211f, 0.16006240f, 0.05758942f, -0.09899626f, -0.05316190f, -0.04532731f, 0.02051304f, 0.02178989f, 
    0.09061082f, 0.13647096f, -0.03805863f, 0.01611865f, 0.02599463f, 0.13631752f, 0.12775208f, -0.08643466f, 
    0.04928591f, -0.15730327f, 0.01293203f, -0.14200746f, -0.04847442f, -0.00139868f, 0.05148017f, 0.01923786f, 
    0.11906826f, -0.02194447f, 0.21596313f, 0.07835179f, -0.02096546f, -0.03170722f, -0.01854273f, -0.03381704f, 
    0.05940019f, -0.08693524f, 0.00848223f, -0.00797332f, -0.06742769f, -0.07250820f, 0.19308397f, 0.11737315f, 
    -0.08918585f, -0.03770247f, -0.03072215f, 0.20074472f, -0.03571306f, -0.02741651f, -0.02783888f, -0.06634516f, 
    0.11224081f, -0.15105996f, 0.15091932f, -0.16797729f, 0.02070732f, -0.16206540f, -0.15117599f, -0.07482552f, 
    -0.00950382f, 0.03040680f, 0.11080437f, 0.03021100f, 0.18884999f, -0.07518158f, -0.05368353f, 0.12581815f, 
    0.02446155f, 0.04484152f, -0.12972546f, 0.04981286f, 0.04671422f, 0.02576292f, 0.09175315f, 0.02303838f, 
    -0.17563711f, -0.18063067f, -0.03810794f, 0.07901885f, -0.04850557f, 0.05922759f, 0.00745891f, 0.10118872f, 
    0.01067167f, -0.03525495f, 0.00718999f, -0.06650215f, -0.34652185f, 0.09150353f, -0.13428468f, -0.12246648f, 
    0.07826794f, 0.12509309f, 0.02200313f, -0.00047171f, -0.10295110f, -0.04004973f, -0.03875415f, 0.08111592f, 
    0.17335725f, 0.07051383f, 0.19201162f, 0.03441129f, -0.00855192f, -0.01779306f, -0.05360934f, 0.00946488f, 
    0.08627921f, 0.07495998f, 0.09602237f, 0.07320356f, 0.02445403f, 0.26621714f, -0.02368540f, 0.08843309f, 
    -0.16641267f, -0.01790790f, -0.10794494f, -0.13033599f, -0.00277326f, 0.01350266f, 0.03877730f, -0.00946931f, 
    -0.11346152f, 0.09565371f, 0.18166362f, 0.14140467f, 0.14616026f, -0.02027677f, 0.06541454f, 0.02100123f, 
    0.06710222f, 0.09247149f, 0.05738753f, 0.06431216f, 0.07867328f, -0.00630684f, -0.17924947f, 0.08029985f, 
    0.08328251f, 0.31540361f, 0.12529506f, -0.07902831f, 0.10076144f, -0.06113134f, 0.06463540f, 0.08272634f, 
    0.01301202f, -0.02944187f, -0.04056793f, 0.05732213f, 0.03376598f, 0.02066537f, -0.14898863f, -0.05689791f, 
    -0.17408463f, -0.16822785f, -0.15552814f, -0.36242980f, -0.20107099f, -0.04650189f, 0.07168303f, 0.15405585f, 
    0.01285476f, 0.02340300f, -0.00484486f, -0.09153716f, 0.13680519f, 0.16138293f, 0.13130020f, 0.15166970f, 
    0.09546578f, 0.28762335f, 0.16622055f, 0.16104518f, 0.08475555f, 0.04841994f, 0.19134150f, 0.15400663f, 
    -0.02892219f, -0.05789932f, -0.16577476f, -0.08074828f, 0.03647949f, -0.03231420f, -0.03801709f, -0.07231554f, 
    -0.11568896f, 0.14583053f, 0.01082619f, 0.01253263f, 0.18324782f, 0.00291256f, 0.12997279f, 0.04294224f, 
    -0.20588392f, 0.11368538f, 0.20365739f, -0.06204598f, 0.06185812f, 0.01241486f, 0.20602959f, 0.04313274f, 
    0.10079423f, 0.06477618f, 0.02729055f, 0.16143082f, 0.07771948f, 0.12111688f, 0.15943527f, 0.00333329f, 
    -0.09410605f, 0.02401257f, -0.03569980f, 0.17048860f, 0.14390622f, 0.03964650f, 0.04721024f, 0.14773905f, 
    -0.09507290f, -0.02795194f, 0.07849553f, 0.05756064f, -0.08951075f, -0.16781127f, -0.10874241f, 0.04676789f, 
    -0.05607380f, 0.00978218f, -0.11410163f, -0.05706628f, -0.27300206f, -0.05043120f, 0.07918413f, 0.25089526f, 
    0.00356649f, -0.03032685f, 0.09682979f, 0.13067952f, 0.01322408f, 0.11139603f, -0.00647021f, -0.04510256f, 
    -0.16402461f, 0.15753947f, -0.05650282f, -0.07598024f, -0.13609314f, -0.00612501f, -0.15707168f, -0.21634695f, 
    0.02419651f, -0.01661729f, -0.18034877f, -0.08123288f, 0.17960647f, 0.21052751f, 0.26542422f, 0.02505531f, 
    -0.20432179f, -0.09999469f, -0.04556255f, 0.06303560f, -0.15712485f, 0.04424962f, -0.13915791f, -0.10588763f, 
    0.02967406f, 0.09576255f, 0.00188709f, -0.00471265f, -0.05635031f, 0.15724111f, 0.08472471f, -0.13928699f, 
    -0.04534641f, -0.08998214f, -0.02261646f, -0.06232018f, 0.21201664f, -0.13439310f, 0.04789880f, 0.09541240f, 
    0.09355196f, -0.02979815f, -0.05392945f, -0.07406211f, 0.02164760f, -0.08905193f, -0.01269081f, 0.24383366f, 
    0.00245970f, 0.08088875f, 0.19636390f, -0.02637513f, 0.07247724f, -0.02607988f, -0.13642932f, 0.04345238f, 
    0.19334026f, -0.00273077f, 0.16989318f, 0.20705579f, -0.02801969f, -0.05291611f, -0.13633277f, -0.08196220f, 
    -0.08862704f, 0.10911877f, -0.17016172f, -0.34115136f, -0.15227848f, 0.01975982f, -0.11600202f, 0.08411146f, 
    -0.20374775f, -0.17163968f, -0.03265875f, 0.16205595f, 0.08066280f, -0.01726142f, -0.06312896f, 0.11123770f, 
    0.07776082f, -0.03958403f, 0.10315486f, 0.11365683f, 0.07290040f, 0.04217544f, -0.06554940f, -0.42049801f, 
    0.11264285f, -0.08118723f, 0.04482675f, -0.09793272f, -0.07329251f, -0.10611970f, -0.23166578f, -0.20618437f, 
    -0.08681311f, -0.12362084f, 0.03015191f, 0.22591214f, -0.02925498f, -0.05376478f, 0.15172884f, 0.08376058f, 
    0.06204974f, 0.10486988f, 0.01452976f, 0.05620854f, 0.02804100f, -0.11948671f, 0.02088360f, 0.11614921f, 
    -0.07681333f, -0.20046428f, -0.10494390f, 0.08317589f, -0.09587748f, -0.13004090f, -0.15064983f, -0.01177878f, 
    0.04051645f, 0.21686418f, 0.12833448f, 0.10624015f, -0.07452766f, -0.18061511f, -0.09982646f, -0.08753832f, 
    -0.00665532f, -0.00517919f, 0.03487203f, 0.25761884f, 0.07549106f, -0.07667823f, -0.04692505f, 0.00469353f, 
    0.01911163f, 0.16885214f, 0.20576322f, -0.02352336f, 0.09516013f, -0.10841525f, -0.07390491f, -0.01950414f, 
    0.19580291f, 0.13495977f, -0.21142548f, -0.07701115f, -0.06574506f, -0.01693420f, -0.02990834f, -0.15989858f, 
    -0.12707636f, -0.06833155f, 0.10038522f, -0.00503499f, -0.03037040f, -0.01013097f, -0.09058285f, 0.24860351f, 
    0.04425677f, 0.19175939f, -0.01334572f, -0.05109937f, 0.11514718f, 0.18775094f, 0.03098017f, 0.22545321f, 
    0.20942439f, -0.03603232f, -0.03870573f, 0.14263940f, 0.00946848f, -0.08681147f, 0.09414870f, 0.04542141f, 
    0.02184068f, 0.13717176f, 0.03344110f, 0.08867328f, -0.13012742f, -0.04830670f, 0.16783391f, 0.01593820f, 
    -0.00841626f, -0.12439520f, 0.07310621f, -0.18588258f, 0.01733780f, 0.00538213f, 0.02150072f, -0.03753098f, 
    0.16596457f, 0.13293082f, -0.05980740f, 0.09682695f, -0.04463349f, 0.04854908f, 0.06560098f, 0.06352405f, 
    -0.05522051f, 0.06980944f, -0.01017123f, -0.13589373f, -0.22386302f, -0.08048300f, -0.09678753f, -0.14609499f, 
    -0.04070650f, 0.13402608f, -0.19559823f, 0.07694753f, -0.14324312f, -0.17758299f, 0.15259442f, -0.21716024f, 
    0.08509998f, 0.23305534f, -0.14278997f, -0.18355371f, -0.02911368f, -0.01556731f, 0.13453704f, -0.03970983f, 
    -0.03189044f, 0.04599489f, 0.03993917f, -0.04330209f, 0.12569822f, 0.21721184f, 0.05490991f, 0.09745133f, 
    -0.02512796f, -0.04660625f, 0.05591022f, 0.02335222f, 0.05294337f, 0.05525317f, -0.06697691f, 0.01986799f, 
    0.00641998f, 0.00015135f, -0.07345176f, -0.10638296f, 0.00103306f, -0.00217483f, 0.05597302f, -0.00516707f, 
    -0.03865393f, -0.03068193f, 0.07053278f, 0.10198206f, 0.09468210f, -0.07837023f, 0.04612721f, -0.01648183f, 
    0.07634564f, 0.04617715f, 0.06979465f, 0.04738926f, -0.15292318f, -0.05868091f, -0.02261930f, 0.07088151f, 
    0.06520911f, -0.17470305f, 0.06706319f, -0.24331450f, 0.03914195f, 0.04972522f, -0.09171915f, 0.14857741f, 
    0.05419089f, 0.04092811f, 0.06395582f, 0.05230317f, -0.06767288f, 0.06250438f, 0.09195054f, 0.10369552f, 
    -0.20657043f, -0.11234047f, 0.03787607f, 0.14740250f, 0.04168778f, -0.02519398f, 0.07626963f, -0.08363535f, 
    0.00198180f, 0.12255166f, 0.18636075f, -0.05482635f, -0.13083021f, -0.09726325f, -0.03774283f, -0.00708176f, 
    -0.05313554f, 0.00992859f, -0.02721536f, -0.01643201f, -0.13001972f, 0.06647610f, -0.08487043f, -0.08194137f, 
    0.02366646f, 0.06106222f, 0.11888297f, -0.15190654f, -0.27586097f, -0.13914935f, 0.02025012f, 0.13716249f, 
    0.61106551f, -0.04722893f, 0.27648941f, -0.17844859f, -0.12523189f, -0.16228685f, -0.16274175f, -0.26094773f, 
    0.01478221f, -0.02426142f, -0.02697348f, 0.02178976f, 0.07967345f, 0.00173437f, 0.01809386f, 0.15141250f, 
    0.03999612f, -0.00245668f, 0.04438031f, 0.02612639f, 0.00841193f, 0.11517834f, 0.00484217f, 0.00829997f, 
    0.29662299f, -0.18849689f, -0.09942948f, 0.05262079f, 0.00246459f, 0.18301588f, 0.03016352f, -0.13878581f, 
    0.10572702f, 0.11587097f, 0.14568059f, 0.08275995f, 0.09488101f, 0.07632740f, 0.00144633f, 0.02892462f, 
    -0.01420834f, 0.10775225f, 0.01383651f, 0.03328028f, 0.06756121f, -0.08068199f, 0.11406569f, 0.06701969f, 
    -0.25313202f, -0.20069112f, -0.21004625f, -0.09571268f, -0.03532627f, 0.00424264f, -0.00780163f, -0.04709188f, 
    0.01306515f, 0.11554962f, -0.10992184f, -0.03681342f, -0.06491052f, -0.17758760f, 0.03004813f, 0.03909389f, 
    0.13981490f, 0.06581675f, 0.07149656f, -0.02847570f, 0.00414249f, -0.08544341f, -0.00226953f, 0.05822292f, 
    -0.02122075f, -0.11090053f, 0.07599165f, 0.01351444f, -0.06517042f, -0.03255967f, -0.13596337f, 0.03560735f, 
    -0.11655755f, -0.09733616f, 0.03700917f, 0.02184478f, 0.13252378f, 0.14904112f, -0.08552127f, -0.16930273f, 
    0.01842664f, 0.07782412f, 0.06613249f, 0.08244434f, 0.07752347f, 0.07688604f, 0.02090154f, -0.10781904f, 
    0.59286088f, -0.18484077f, 0.35153779f, -0.17041172f, -0.06109166f, 0.04517052f, 0.03489162f, 0.00936916f, 
    -0.03437753f, -0.06691745f, 0.06998093f, -0.08645970f, -0.21041642f, -0.09607282f, 0.02839892f, 0.06537279f, 
    -0.19850735f, 0.01313794f, -0.00288568f, -0.00710151f, -0.04076206f, -0.00467194f, -0.00150690f, 0.01799823f, 
    0.28803882f, 0.22971761f, 0.10376655f, 0.15863381f, -0.04347280f, 0.06454106f, -0.02525178f, -0.01210872f, 
    -0.05245550f, 0.04540478f, 0.05456419f, 0.01649203f, -0.02355050f, 0.03224401f, 0.24826883f, 0.09592640f, 
    0.00894846f, -0.02136619f, -0.00949108f, 0.06562749f, 0.09288582f, 0.10519920f, 0.08503808f, -0.13103500f, 
    -0.17499515f, -0.11613052f, 0.02533745f, 0.14396061f, -0.15268512f, -0.30629870f, 0.01625814f, 0.00904384f, 
    -0.02929415f, 0.00095506f, -0.06568576f, 0.04510646f, 0.16221841f, 0.12871963f, -0.02258981f, 0.17468250f, 
    -0.13959765f, -0.01371999f, -0.02512943f, -0.01084516f, 0.02606998f, 0.03731149f, 0.02376499f, -0.01795988f, 
    -0.13737437f, 0.10401642f, 0.04330219f, -0.03809591f, -0.00878230f, 0.06542077f, -0.12007013f, -0.06868487f, 
    0.03761651f, 0.02365746f, -0.03342009f, -0.00836296f, -0.23702167f, 0.03326593f, 0.12899230f, 0.05037730f, 
    0.04364256f, 0.16491035f, -0.04940418f, -0.07144506f, 0.01968816f, 0.01654902f, 0.01247572f, -0.03097763f, 
    -0.20232464f, -0.38134933f, 0.01880226f, -0.02801620f, 0.01387304f, 0.11500867f, -0.00772114f, -0.18950652f, 
    -0.09885313f, -0.04746843f, -0.08579123f, 0.10434669f, 0.10713501f, 0.08416053f, 0.07750960f, 0.14344347f, 
    -0.10514465f, -0.18845709f, 0.06744698f, 0.08639159f, -0.04490205f, 0.00812955f, 0.03709617f, 0.05220352f, 
    0.11286816f, 0.13663021f, 0.14926021f, 0.13697818f, -0.07107919f, 0.03500852f, 0.02218661f, 0.04501844f, 
    0.04723012f, 0.00693397f, 0.11563841f, 0.00536160f, 0.12924089f, 0.08374798f, 0.17694618f, 0.02231991f, 
    -0.03475931f, -0.10114921f, -0.01331974f, -0.07797799f, 0.00134839f, -0.03298261f, 0.08199831f, 0.12785453f, 
    -0.14265203f, 0.16655621f, -0.01463656f, 0.09129252f, -0.04522402f, -0.11180943f, 0.10070856f, -0.03743199f, 
    -0.12103904f, -0.04573403f, 0.01301326f, 0.02376741f, 0.12692998f, 0.09193417f, 0.13977709f, -0.04296385f, 
    0.03854913f, 0.08529514f, 0.10739708f, 0.01445742f, 0.00221688f, -0.03271950f, 0.00366284f, -0.05944021f, 
    0.03360552f, -0.00532403f, -0.13472843f, -0.00546797f, -0.14231461f, 0.06567331f, -0.04228650f, 0.01501503f, 
    0.11699279f, -0.09052622f, -0.13085592f, -0.11654042f, 0.03567502f, 0.12507442f, 0.19398075f, -0.07354212f, 
    0.06342708f, -0.02341030f, 0.17771411f, 0.01888373f, 0.18518792f, 0.00306451f, 0.05616236f, 0.23573415f, 
    0.30190063f, 0.21930079f, -0.02796595f, -0.07667756f, 0.05899904f, 0.07299034f, 0.00867160f, 0.03956292f, 
    0.02524260f, 0.03563333f, 0.03810235f, 0.04938876f, 0.38400459f, 0.11819084f, -0.16622630f, -0.01594024f, 
    0.09318369f, -0.04759066f, 0.08673345f, -0.06814231f, 0.13483979f, 0.01972460f, -0.05540668f, 0.05383381f, 
    -0.07992753f, -0.01625689f, -0.09901366f, 0.01855977f, -0.01025976f, 0.09421817f, -0.00807728f, 0.05307358f, 
    -0.02989822f, -0.07066226f, 0.02610431f, -0.09493067f, -0.23288688f, -0.01556231f, -0.08989640f, 0.09719193f, 
    0.08542112f, -0.10462690f, 0.05058289f, 0.00778040f, 0.06694239f, -0.06000718f, 0.00632587f, -0.04335058f, 
    -0.00689917f, -0.11796161f, 0.15581883f, -0.13819613f, 0.02901839f, 0.11205559f, 0.00381281f, 0.07081071f, 
    -0.13645566f, -0.00985781f, -0.04781982f, -0.05493639f, -0.07021489f, 0.07723679f, 0.07212345f, -0.07373074f, 
    0.19664054f, -0.08830371f, -0.10856417f, 0.20044570f, 0.17623517f, 0.07858743f, -0.11783314f, -0.11430091f, 
    0.08270772f, 0.22371852f, -0.03804795f, -0.09555478f, 0.13986295f, -0.06197378f, -0.10323747f, -0.09249263f, 
    0.03441129f, 0.10523681f, 0.03771241f, 0.02851362f, 0.04134555f, -0.08371822f, -0.19243701f, 0.07933549f, 
    0.16262512f, 0.11268589f, 0.13644643f, -0.01979132f, 0.04692743f, -0.20859481f, -0.11088168f, -0.05613597f, 
    0.17322329f, -0.00664291f, 0.18790436f, 0.03031229f, 0.06008002f, -0.19611207f, -0.36117545f, -0.18830507f, 
    -0.10277970f, -0.05986750f, 0.08471467f, 0.02954243f, 0.00426502f, -0.01753636f, -0.06041376f, 0.11481827f, 
    0.03488404f, 0.01825107f, -0.05432703f, -0.04991336f, 0.14320004f, 0.11180568f, -0.00024072f, -0.02173871f, 
    0.06041900f, 0.03174367f, -0.00951801f, 0.03831711f, 0.05183881f, -0.01278302f, -0.05513301f, 0.06325750f, 
    -0.10223930f, -0.04033821f, -0.06696135f, 0.02046182f, -0.06999640f, -0.05375337f, -0.04129992f, 0.07507730f, 
    -0.06870750f, 0.04210466f, 0.06224034f, 0.00514706f, -0.10175924f, 0.01588100f, -0.14644028f, 0.09628548f, 
    -0.05340372f, 0.02000873f, -0.22196876f, -0.05511611f, 0.15971594f, 0.16682664f, 0.02094186f, -0.13261047f, 
    0.06869802f, 0.12863560f, -0.01957139f, 0.03925027f, 0.17912008f, 0.05150548f, 0.16203518f, -0.04016768f, 
    0.02436665f, -0.09390339f, 0.00073355f, -0.04109454f, 0.03190227f, 0.07568949f, 0.12784621f, 0.07154019f, 
    -0.08617632f, -0.11352511f, -0.12709272f, -0.06448092f, 0.09968226f, 0.03349823f, 0.03876999f, 0.03647211f, 
    -0.18165712f, -0.09066851f, -0.10820558f, -0.00894653f, 0.09017584f, -0.11413942f, -0.01632760f, -0.03737884f, 
    -0.03314065f, -0.02430238f, -0.00836309f, -0.01827427f, 0.03457052f, 0.08133822f, -0.02729513f, 0.09346388f, 
    -0.07311426f, 0.10762967f, 0.21331014f, 0.05018242f, 0.19961658f, -0.06977042f, -0.09838695f, 0.15719070f, 
    -0.01714087f, 0.00253795f, 0.01897618f, 0.10258622f, -0.07718305f, 0.12119582f, 0.07709435f, -0.09486988f, 
    0.10191824f, 0.07509357f, -0.02692643f, -0.05118141f, -0.00413334f, -0.08801302f, -0.04025064f, -0.02371514f, 
    0.19699147f, 0.11506031f, -0.05164009f, 0.03863846f, -0.06725816f, 0.00217564f, -0.12488948f, 0.02569173f, 
    -0.09609795f, 0.15517716f, -0.07553595f, 0.04365943f, 0.14703967f, -0.23268111f, 0.39998791f, 0.10726638f, 
    0.16055724f, -0.06817704f, 0.03075791f, 0.01414595f, 0.07148166f, -0.11274487f, 0.09522888f, 0.06444628f, 
    0.22232582f, 0.33769599f, 0.07188571f, -0.05133319f, -0.03799088f, -0.17625633f, 0.17713648f, 0.03701336f, 
    0.05663338f, 0.06490164f, 0.08076458f, 0.01127921f, 0.01730986f, -0.02274155f, -0.06728582f, 0.18054765f, 
    0.04133419f, -0.02800333f, -0.06593681f, -0.03953481f, 0.01161318f, 0.01746980f, -0.00850928f, 0.07588725f, 
    0.11003807f, 0.09607694f, -0.02727927f, -0.20606311f, -0.06178125f, 0.04412597f, 0.00106637f, 0.07781477f, 
    0.08225392f, 0.05956428f, -0.01570405f, -0.01730212f, 0.16211823f, -0.15814476f, 0.01392825f, 0.00652028f, 
    0.08813889f, 0.03137927f, 0.16122769f, -0.00581844f, 0.08052966f, -0.01096664f, 0.00041866f, 0.04969823f, 
    -0.13131833f, -0.27820989f, -0.30955535f, 0.00245909f, 0.03406836f, 0.23079807f, 0.03458809f, 0.03820634f, 
    -0.07569570f, -0.02137305f, 0.01893615f, -0.03589243f, -0.03056514f, 0.08569723f, -0.03747163f, 0.05398339f, 
    -0.02385536f, 0.01253487f, -0.10249029f, 0.02279911f, 0.00431442f, -0.07118222f, -0.10964066f, 0.00484219f, 
    0.13872078f, 0.06883475f, 0.13570201f, -0.00526885f, 0.09147731f, -0.12363734f, -0.03957980f, 0.02388802f, 
    -0.05763394f, -0.03291972f, 0.09478708f, 0.07312552f, 0.07729281f, -0.05901239f, 0.05165011f, -0.08231114f, 
    0.17018744f, -0.14507605f, -0.02536658f, 0.05584817f, 0.18838583f, 0.01883807f, 0.02948848f, -0.25139058f, 
    -0.38142979f, 0.60282630f, -0.09525525f, -0.17851113f, -0.02596316f, 0.08177236f, -0.01326556f, 0.02538866f, 
    0.00697356f, -0.06474494f, 0.04093653f, 0.07086899f, -0.15372725f, -0.20575063f, -0.24983318f, -0.09292113f, 
    0.00722812f, 0.08054268f, 0.02410884f, -0.03558361f, 0.06799563f, 0.01617305f, 0.04106452f, 0.05129613f, 
    -0.15965980f, 0.05964308f, 0.13115068f, 0.04284371f, -0.05863428f, 0.10040277f, 0.00386079f, -0.04771465f, 
    0.24868219f, -0.09668174f, -0.03735683f, -0.02939435f, 0.04853294f, -0.40240353f, 0.12933950f, -0.14173605f, 
    0.10660236f, -0.18520488f, 0.11565667f, 0.20073542f, 0.13193601f, 0.12281110f, 0.23061313f, 0.00400927f, 
    -0.10467264f, -0.19343095f, -0.05647374f, 0.04267323f, 0.07090995f, -0.09601931f, 0.07967424f, 0.00878534f, 
    -0.03540481f, 0.00745642f, 0.07927831f, 0.09748966f, 0.08094288f, -0.00788008f, -0.15453801f, 0.09968565f, 
    0.06355184f, 0.02850734f, 0.09883124f, 0.20368050f, -0.08097848f, -0.07788815f, -0.10928843f, 0.06541470f, 
    0.00559055f, 0.10229490f, 0.11253925f, 0.13283625f, 0.01377226f, 0.06082290f, 0.03434230f, -0.07187787f, 
    0.05481302f, 0.05649068f, 0.02631793f, -0.07435233f, -0.09435788f, 0.27839792f, -0.06316604f, -0.01873429f, 
    0.05386757f, -0.05960606f, -0.06151932f, -0.02074167f, 0.16025442f, -0.06460108f, 0.00321437f, 0.03926231f, 
    0.07223306f, 0.02269493f, -0.06480353f, 0.17836741f, -0.11472578f, 0.15687448f, 0.20444170f, 0.06171622f, 
    0.04254724f, 0.04369980f, 0.03433190f, 0.11681323f, 0.11637928f, -0.14679024f, -0.03585174f, 0.02619631f, 
    -0.11794421f, -0.11398258f, 0.20988208f, 0.13049246f, -0.12772429f, 0.02326022f, -0.08944678f, 0.07279417f, 
    0.04566161f, -0.01911755f, -0.10571828f, 0.05779659f, 0.02602692f, -0.10228903f, -0.12093215f, 0.00664888f, 
    0.04358693f, 0.02933695f, 0.00344517f, -0.01480743f, 0.02843710f, 0.03574391f, -0.04728193f, -0.12847291f, 
    -0.01986330f, 0.02138246f, -0.09331375f, 0.19087310f, -0.04743051f, 0.03702554f, -0.05055318f, -0.21090098f, 
    -0.21625946f, -0.04506045f, -0.13695545f, 0.23965116f, 0.20961703f, 0.24338898f, 0.34411812f, 0.25487113f, 
    -0.00749820f, 0.11789698f, -0.02355247f, 0.00443615f, 0.11836740f, 0.03516461f, 0.03979469f, -0.04097151f, 
    0.03642042f, -0.01202803f, 0.03946684f, -0.07368398f, -0.02994800f, -0.10718931f, 0.11149121f, -0.08939748f, 
    0.06303249f, 0.17644683f, -0.22310774f, 0.18407826f, -0.04507488f, -0.00082556f, 0.05388983f, 0.09646846f, 
    0.08397497f, 0.01409563f, 0.17847866f, -0.15551542f, 0.05823755f, 0.05949154f, 0.10702580f, -0.02542869f, 
    0.07633170f, -0.02665084f, 0.00355095f, -0.02647999f, -0.05578329f, -0.05687927f, -0.05825214f, -0.19988933f, 
    -0.06404793f, -0.07335284f, 0.01312298f, 0.00830941f, 0.10063935f, -0.02386826f, 0.05176244f, 0.09471612f, 
    0.06394987f, 0.07940515f, 0.14672543f, 0.15578803f, -0.03337382f, 0.04417004f, -0.03894570f, 0.19358610f, 
    0.15121476f, 0.02286228f, 0.05458299f, -0.10967216f, -0.05662325f, 0.08587003f, -0.03980331f, 0.06561333f, 
    0.08340769f, -0.03498261f, -0.05837089f, -0.07531641f, 0.06880151f, -0.09833530f, -0.01469318f, -0.02388214f, 
    0.10392486f, 0.06189759f, -0.08010518f, -0.02157773f, -0.23502277f, -0.14897349f, -0.01246242f, 0.38153732f, 
    0.04400850f, -0.12484645f, 0.02970610f, -0.05011398f, 0.11144219f, -0.14423971f, 0.11048497f, 0.26833314f, 
    0.00936440f, 0.10862429f, -0.35024014f, 0.29217532f, 0.01691402f, 0.15580615f, -0.02111687f, -0.02111858f, 
    -0.04372944f, 0.12569091f, -0.00453366f, 0.06029610f, 0.01147727f, -0.14715122f, -0.13342693f, 0.10389245f, 
    0.06720605f, 0.11661563f, 0.13211928f, 0.17788348f, 0.15216006f, -0.03023314f, 0.11723652f, 0.02168698f, 
    -0.01970076f, 0.13672154f, 0.08452111f, -0.00052665f, 0.00123389f, 0.10018410f, 0.13821010f, -0.08810771f, 
    0.02168694f, -0.01229448f, 0.14228283f, -0.09115238f, 0.47701162f, -0.14227366f, 0.18209846f, 0.10225788f, 
    0.00244351f, 0.04780037f, -0.00516101f, -0.12172438f, -0.06421947f, 0.14207473f, 0.01261810f, 0.12992813f, 
    -0.16261521f, 0.04586683f, -0.12641636f, -0.11211173f, 0.03115114f, 0.00631991f, 0.01550044f, 0.06579309f, 
    -0.02727997f, 0.02293531f, 0.16072559f, 0.11177688f, 0.01005869f, -0.08185957f, 0.21751425f, 0.01853908f, 
    0.08130364f, -0.01552156f, 0.02292679f, -0.09089956f, 0.03715955f, 0.03669889f, 0.12291338f, 0.02775666f, 
    -0.18058737f, -0.11267083f, 0.02040349f, -0.02377101f, 0.20093322f, 0.01596296f, 0.04175112f, -0.08480109f, 
    -0.07102690f, 0.15553954f, 0.03730946f, -0.06051510f, -0.04236981f, -0.31588879f, -0.15974627f, -0.14610702f, 
    0.09926894f, 0.04746458f, -0.05128830f, -0.12240822f, 0.09846264f, 0.06161352f, 0.03994247f, 0.04631407f, 
    -0.19629909f, -0.18013546f, -0.20220719f, -0.04982561f, 0.01423958f, 0.08771360f, -0.01448813f, 0.15908635f, 
    0.06299161f, 0.27233818f, -0.01453141f, 0.12931955f, -0.01811915f, -0.07861934f, 0.02069602f, -0.12185829f, 
    0.08564859f, 0.08527442f, 0.04761613f, 0.03769634f, 0.07291494f, 0.05791514f, 0.04000739f, -0.16560410f, 
    0.11213218f, -0.09056086f, 0.28868794f, -0.02727763f, -0.04140110f, 0.07746248f, -0.03279372f, 0.00771671f, 
    -0.03095319f, -0.04213234f, -0.04349704f, 0.03615244f, -0.01481998f, -0.14191638f, 0.08255229f, 0.03498265f, 
    -0.04391114f, 0.11062279f, 0.00109773f, 0.09530561f, 0.22493790f, 0.07204650f, 0.02203997f, -0.04313164f, 
    0.07561699f, -0.15690562f, 0.12315527f, 0.06682991f, -0.03404994f, -0.14060555f, 0.16880383f, 0.03448187f, 
    0.13378133f, -0.00450102f, 0.14747699f, -0.09041893f, 0.11552866f, 0.22064164f, 0.21452008f, -0.23989530f, 
    -0.04269257f, 0.09095541f, 0.07600745f, 0.07959605f, -0.07018363f, -0.00131930f, -0.04485102f, -0.13363606f, 
    0.28939936f, -0.23162904f, -0.11244036f, -0.44340447f, -0.07930943f, -0.00325686f, -0.08927117f, -0.05139291f, 
    0.15491918f, -0.02898058f, 0.03589059f, -0.08083137f, 0.17070957f, 0.25910905f, 0.34815589f, 0.13747233f, 
    0.04756829f, -0.01234500f, 0.04852777f, 0.06274738f, 0.09010407f, 0.00882228f, 0.03164130f, 0.16757904f, 
    0.28079602f, 0.30067056f, 0.18419550f, 0.00849050f, 0.06141250f, 0.16675006f, 0.04206400f, 0.15340115f, 
    0.09783009f, -0.00054766f, 0.04208216f, 0.05296548f, 0.43315169f, 0.09845223f, -0.32047576f, -0.21147037f, 
    0.08868842f, -0.14358020f, 0.13123216f, 0.00295378f, 0.04752873f, 0.12032961f, -0.00783397f, -0.07407080f, 
    -0.04821629f, -0.11616975f, -0.05632167f, -0.05811397f, -0.07904229f, -0.05368099f, 0.03386572f, 0.02621467f, 
    -0.06466701f, -0.03608128f, -0.02615700f, 0.03517849f, -0.10758246f, -0.08376228f, 0.06261093f, 0.42661867f, 
    0.00440217f, -0.21613851f, 0.03121327f, 0.09124991f, 0.01195336f, 0.10883540f, 0.08897758f, 0.00607840f, 
    -0.03670206f, -0.00386053f, 0.02171926f, -0.15513529f, -0.01307159f, -0.01426093f, -0.00963992f, 0.04504607f, 
    -0.10972262f, -0.00740580f, 0.00561663f, 0.01836131f, -0.35263941f, -0.01173922f, 0.01823268f, -0.32067069f, 
    0.06030757f, -0.02838936f, -0.18915503f, 0.12220586f, -0.06292152f, 0.02617980f, -0.07532246f, -0.07289162f, 
    -0.22677754f, 0.08945742f, -0.21799438f, -0.27714363f, 0.02668911f, 0.04563120f, 0.08685316f, -0.06251226f, 
    0.09611008f, 0.01636425f, -0.04850344f, -0.00807782f, 0.19357727f, -0.13819711f, -0.07271480f, 0.20524859f, 
    0.11598180f, -0.00370241f, 0.11861789f, -0.05670139f, 0.11024803f, 0.04249898f, 0.03615222f, 0.15740745f, 
    -0.02446427f, -0.02112245f, -0.05394946f, -0.18816595f, -0.05628132f, -0.08216015f, -0.10652120f, -0.05567170f, 
    -0.09495537f, -0.04254101f, 0.02176574f, 0.07285810f, -0.25908437f, -0.12969078f, -0.08277731f, 0.30699626f, 
    -0.01665937f, -0.09717749f, -0.11786185f, -0.03848265f, -0.01045125f, -0.01972995f, -0.01421592f, -0.03415258f, 
    0.12303280f, 0.18767412f, 0.21028675f, -0.24688950f, 0.03499736f, 0.02891830f, -0.01217315f, -0.07105920f, 
    0.10030416f, 0.06084777f, -0.09368557f, 0.25614694f, -0.13210168f, -0.22015646f, -0.05659946f, 0.02641200f, 
    -0.07906611f, -0.04402172f, 0.09189966f, 0.12030023f, -0.02974920f, -0.05683846f, 0.07534735f, -0.08525665f, 
    0.09248286f, 0.17448676f, -0.07699797f, -0.01899097f, 0.07254526f, 0.15975328f, 0.19371444f, 0.16566774f, 
    0.07241447f, 0.08450818f, -0.02861691f, 0.05326668f, 0.22657719f, 0.19194520f, 0.05618147f, -0.16761707f, 
    0.05886772f, -0.01157640f, 0.08214440f, 0.08642352f, 0.04351826f, 0.00872872f, 0.06978368f, -0.00689817f, 
    -0.11722542f, -0.10459471f, -0.22184078f, -0.16415031f, -0.09118316f, 0.11298808f, 0.00984446f, 0.11699735f, 
    0.00093588f, 0.01404558f, 0.01739223f, -0.02433706f, 0.24114890f, -0.16214682f, -0.22830766f, -0.34998569f, 
    -0.00324229f, 0.12088549f, -0.00375777f, -0.13710476f, 0.11530696f, 0.18460043f, -0.00616587f, 0.00208230f, 
    -0.09393301f, -0.05323977f, 0.37553793f, -0.08869807f, 0.18298993f, -0.06139200f, -0.24472885f, 0.01714903f, 
    0.15250580f, -0.11765605f, -0.00999420f, 0.12681980f, -0.02126122f, 0.29818937f, 0.25444356f, -0.08670213f, 
    0.12538645f, 0.11524452f, 0.11265355f, -0.07636072f, -0.02525021f, 0.00653388f, 0.05154980f, 0.05857195f, 
    0.29230836f, 0.07881794f, -0.16930401f, 0.03647622f, 0.04426849f, -0.16389444f, -0.05464928f, -0.04871682f, 
    -0.07335384f, -0.00351125f, 0.12501076f, -0.02195891f, -0.50307947f, -0.25638744f, 0.05961693f, -0.10285917f, 
    0.00211209f, -0.00586730f, -0.01461402f, 0.03606500f, 0.10271835f, -0.25261611f, 0.12099540f, 0.13366365f, 
    0.26806870f, 0.39382020f, 0.26112986f, 0.01703695f, 0.11615516f, 0.06387095f, 0.19400010f, 0.15712267f, 
    0.04320839f, -0.04073578f, -0.02083296f, 0.00402544f, -0.08215239f, -0.36594698f, -0.23457350f, -0.04129734f, 
    -0.02664053f, 0.02447271f, -0.15862867f, -0.00700305f, 0.07991637f, -0.00160412f, -0.05010239f, -0.00626293f, 
    0.22035192f, 0.15582673f, -0.10470621f, 0.02160078f, -0.04273662f, 0.10770484f, 0.01582279f, 0.05520160f, 
    0.08007105f, -0.00625669f, 0.11325619f, 0.02239729f, 0.01798746f, 0.16639568f, -0.18535489f, 0.07175376f, 
    -0.10817608f, 0.03150637f, 0.07110137f, -0.11978897f, -0.05184513f, -0.05334220f, -0.09837431f, 0.05535425f, 
    0.17666633f, 0.06217262f, -0.08746815f, 0.08585440f, 0.00237986f, 0.13926286f, 0.11333597f, -0.03987200f, 
    0.00613270f, -0.02468272f, 0.13289718f, 0.06756768f, -0.21377619f, -0.16013464f, -0.04368495f, -0.32824129f, 
    -0.06321561f, -0.11843407f, -0.08430077f, 0.06788579f, -0.03944739f, -0.09240536f, -0.09445107f, -0.10023453f, 
    -0.60098225f, -0.17388488f, -0.04667309f, 0.00680835f, 0.11535458f, -0.21444365f, 0.00601997f, 0.14187601f, 
    -0.10550300f, -0.11866807f, -0.03801854f, -0.12292247f, 0.13815612f, 0.25259477f, 0.04487181f, 0.07075361f, 
    0.08678105f, 0.00518926f, -0.01939324f, 0.03482330f, -0.05956892f, -0.11020884f, 0.01516363f, -0.18662690f, 
    -0.04333624f, 0.01562505f, 0.01717635f, 0.03300395f, 0.01830305f, -0.00720012f, -0.05349846f, 0.02513448f, 
    -0.04823121f, -0.04054273f, -0.00048289f, -0.00898638f, -0.02416634f, -0.01327833f, -0.04252528f, 0.03725253f, 
    0.01629645f, 0.00364830f, 0.04850845f, -0.04447381f, 0.02975083f, -0.00560646f, 0.00203608f, -0.04375438f, 
    0.01176175f, -0.03506633f, 0.03437346f, 0.02080910f, 0.02548348f, 0.02662786f, -0.01304634f, -0.05656675f, 
    0.04122290f, 0.00246053f, -0.03321275f, 0.03197386f, -0.02308284f, -0.01928521f, -0.05011082f, -0.03456865f, 
    0.02282012f, -0.05349046f, 0.03141074f, -0.01928915f, -0.04096634f, -0.03551287f, 0.04373853f, -0.00203388f, 
    -0.03694258f, -0.05665449f, 0.01223279f, -0.05045990f, 0.01320216f, 0.04381049f, -0.02569435f, -0.03941281f, 
    -0.03732261f, -0.01600604f, -0.02304201f, -0.05306751f, -0.06019446f, -0.05320118f, -0.02571067f, 0.03662500f, 
    0.01527784f, -0.04223041f, -0.03470980f, -0.05833326f, 0.01062165f, -0.01566089f, -0.02334551f, -0.04050964f, 
    0.02207081f, 0.04644232f, 0.04107830f, 0.00217449f, 0.03745252f, -0.00871787f, -0.03411635f, -0.01371130f, 
    -0.00239554f, -0.04376334f, 0.00737284f, 0.02878964f, 0.00908786f, 0.00918765f, -0.04069056f, -0.02137122f, 
    0.01799109f, 0.00252703f, 0.01895716f, -0.05198961f, 0.00512417f, 0.03562732f, -0.03458397f, -0.01577124f, 
    -0.00995202f, -0.00418538f, -0.03266534f, -0.00269396f, 0.01421624f, 0.02580533f, 0.01672964f, -0.03807266f, 
    -0.03933884f, -0.03943036f, 0.00937908f, 0.00240866f, -0.00315065f, 0.01762975f, -0.04078440f, -0.04870512f, 
    -0.02500836f, 0.01901253f, -0.00989191f, -0.03147472f, 0.02565906f, 0.02413976f, -0.01510764f, 0.01968043f, 
    0.01721298f, -0.04550489f, -0.03452426f, -0.05773935f, 0.02012286f, -0.02540479f, 0.03385872f, 0.04254847f, 
    -0.00708879f, -0.03162300f, -0.03716856f, 0.00376778f, -0.04393797f, -0.02650365f, 0.03088975f, -0.02391541f, 
    -0.02710359f, -0.02726589f, -0.00152046f, 0.01900410f, -0.00223263f, -0.02052084f, 0.01084859f, -0.03605029f, 
    0.02158099f, -0.02128058f, -0.00964507f, -0.04261917f, 0.04119602f, 0.03037224f, -0.03742395f, 0.03561603f, 
    -0.04906114f, -0.03151350f, -0.03724493f, -0.04563869f, -0.04378378f, 0.02099298f, -0.00781268f, -0.03384230f, 
    -0.05570512f, -0.02017988f, 0.00466947f, -0.00107097f, -0.05456145f, -0.01263886f, 0.01449987f, 0.01961475f, 
    -0.02678516f, 0.04399986f, -0.00578453f, 0.04028327f, 0.01786507f, -0.02420103f, 0.02650780f, -0.00246289f, 
    -0.00791044f, -0.02604011f, 0.01592732f, -0.01971962f, -0.04984046f, -0.05759385f, -0.05939872f, 0.02722099f, 
    0.03983963f, -0.00168402f, -0.05471252f, 0.00136291f, -0.04722863f, 0.00763954f, -0.05697259f, -0.04827692f, 
    -0.04460355f, -0.05010193f, 0.02641510f, 0.02242584f, 0.01840238f, -0.04320805f, -0.01282874f, 0.01447079f, 
    0.02488807f, -0.02812279f, -0.02604314f, -0.01361718f, 0.04141224f, 0.03022311f, -0.03208486f, 0.03354144f, 
    -0.03547107f, -0.00157001f, 0.02388025f, 0.03590959f, 0.00912427f, 0.01577600f, -0.00973082f, -0.00897145f, 
    -0.03278097f, 0.04166164f, -0.03459427f, -0.00324460f, 0.00982571f, -0.01598497f, -0.01216521f, -0.02698247f, 
    -0.03749580f, -0.00993592f, 0.01019104f, -0.01340699f, -0.00609062f, 0.02374974f, -0.02689938f, 0.03556992f, 
    -0.04598403f, 0.04197123f, -0.02144158f, 0.03365335f, -0.03452932f, 0.01384472f, -0.04965218f, -0.04705524f, 
    -0.00808573f, -0.04042001f, -0.03229290f, 0.00461573f, 0.03663936f, -0.04338275f, -0.03305255f, 0.00298038f, 
    -0.05243519f, 0.00950621f, 0.01123231f, -0.04901206f, -0.00329106f, 0.01019841f, -0.03502549f, -0.04821387f, 
    0.03347879f, -0.02036550f, -0.04017654f, 0.01627041f, 0.02986073f, -0.02584019f, -0.04023725f, -0.04155533f, 
    -0.03984173f, 0.01678212f, -0.03866620f, 0.02685133f, 0.04324267f, -0.03926328f, 0.00840100f, -0.04664323f, 
    -0.01876480f, 0.03037895f, 0.00249119f, 0.03635733f, 0.04401279f, -0.01324737f, 0.03377631f, -0.04826298f, 
    -0.05617159f, -0.04527339f, -0.03574502f, -0.04109429f, 0.03796923f, -0.02896154f, -0.01832417f, -0.02144678f, 
    0.03664799f, 0.03846830f, -0.05049391f, -0.04465241f, -0.01742309f, 0.00307387f, 0.03594885f, -0.01562445f, 
    0.02468362f, 0.01582693f, -0.01789649f, -0.02415833f, 0.02276870f, -0.03568920f, 0.03069195f, -0.03155034f, 
    -0.03118094f, -0.03891011f, -0.05623863f, 0.00875666f, -0.02296156f, 0.01119876f, -0.00693700f, -0.03264399f, 
    -0.00422917f, -0.02015970f, 0.01128862f, 0.00487979f, -0.01622126f, -0.03025383f, -0.01150453f, 0.02437030f, 
    -0.04051929f, 0.00212618f, 0.03072567f, 0.02213671f, -0.01814835f, -0.04971271f, 0.02234580f, -0.03128288f, 
    -0.01090009f, -0.00559113f, -0.03306015f, -0.02245574f, -0.05766232f, 0.03030960f, -0.00500920f, 0.02987139f, 
    -0.03258948f, 0.00462326f, -0.05642030f, 0.00161770f, -0.03371739f, -0.05423958f, 0.00765415f, 0.04606959f, 
    -0.02009902f, 0.02855012f, -0.02558247f, 0.04119845f, -0.00973125f, 0.00454749f, 0.03002358f, 0.03847963f, 
    -0.02001596f, 0.00756845f, 0.03873754f, -0.04661528f, 0.02941148f, 0.03421075f, -0.00085119f, 0.02469431f, 
    0.03937129f, -0.02941080f, 0.04079608f, -0.05360527f, -0.01062944f, 0.02427703f, -0.05543430f, 0.00153648f, 
    -0.01318169f, 0.02134973f, 0.02475995f, -0.02435192f, 0.02610503f, -0.01321058f, -0.00252504f, -0.02600990f, 
    0.01402531f, 0.04069424f, -0.04425700f, 0.03174430f, 0.03297399f, -0.04927247f, -0.02263504f, -0.00532947f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10236607f, -0.05273071f, -0.04306741f, 0.15007284f, 0.01523407f, 0.04161370f, -0.01437554f, -0.00794406f, 
    0.03030319f, -0.11276608f, 0.01950183f, 0.02315530f, -0.02620724f, 0.04988301f, 0.02898737f, -0.02726310f, 
    -0.02634899f, -0.00528067f, 0.04822994f, -0.02101894f, 0.09390420f, -0.05678838f, 0.06342007f, -0.00792759f, 
    0.06303128f, -0.01698702f, 0.07651419f, 0.08158767f, -0.10368300f, 0.06352337f, 0.14360344f, 0.08171559f, 
    0.03963999f, -0.06336630f, 0.20056586f, -0.02321642f, 0.11071394f, 0.03871758f, 0.00300664f, 0.00451151f, 
    -0.02349615f, 0.08675133f, 0.03829883f, 0.20230015f, 0.03540928f, -0.04529579f, 0.05774977f, -0.05329354f, 
    0.03599028f, 0.10725679f, 0.02486638f, -0.02853492f, -0.05015603f, -0.03964850f, 0.04511780f, 0.08294900f, 
    0.15311293f, 0.00733712f, -0.00008366f, 0.03468025f, 0.04401174f, 0.01493559f, 0.12054928f, 0.03606151f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.17119545f, 0.02860373f, 0.44817591f, -0.15488981f, -0.13541877f, 0.24482480f, 0.05337673f, -0.00521434f, 
    0.03431487f, 0.15495427f, -0.02573160f, 0.18196866f, 0.00064478f, 0.19981134f, 0.06110658f, -0.46084568f, 
    0.06966233f, -0.42683238f, -0.15677464f, 0.00966992f, -0.14111739f, -0.00571006f, -0.14968835f, 0.10253189f, 
    0.05953551f, -0.10124144f, -0.08921719f, 0.06821941f, 0.18180905f, 0.08975512f, -0.40605775f, 0.00852760f, 
    -0.03539008f, 0.10051123f, -0.39709833f, -0.04447850f, -0.26727331f, -0.10246160f, -0.07991539f, -0.23316818f, 
    0.07407969f, -0.38362262f, -0.01042994f, -0.30668664f, -0.05014101f, 0.33632556f, -0.13223939f, -0.06742620f, 
    -0.12565589f, -0.06959589f, 0.07609683f, 0.29543886f, 0.02758630f, 0.13854986f, -0.26078784f, -0.45610100f, 
    -0.29138526f, 0.20818342f, -0.53378731f, 0.04586207f, 0.11852398f, -0.27859828f, 0.23823135f, -0.04864329f, 
    -0.38749772f, 0.00767915f, -0.11101804f, 0.31085858f, 0.01629604f, -0.06205473f, -0.09291498f, -0.04732524f, 
    0.06065829f, -0.02339672f, 0.08605028f, 0.10589072f, 0.10563394f, -0.24232620f, -0.03084125f, -0.35168770f, 
    0.02867410f, -0.69632798f, -0.25482133f, 0.11987574f, 0.25633129f, -0.02204502f, 0.07824674f, 0.10649459f, 
    0.08159472f, -0.28527790f, 0.30541489f, 0.21203451f, -0.48223260f, -0.10737450f, 0.07874319f, -0.06718281f, 
    0.08082841f, -0.17295150f, 0.17306563f, -0.19586323f, 0.06273662f, -0.07529847f, 0.25869077f, 0.10216642f, 
    0.00978571f, -0.12711598f, 0.02842699f, 0.13101143f, 0.12048063f, -0.30523479f, 0.11448057f, -0.07728802f, 
    -0.16691439f, 0.42898136f, 0.08090957f, 0.07547428f, -0.04194925f, -0.31523743f, 0.18586767f, -0.28808200f, 
    0.06649698f, 0.08895382f, 0.08998694f, 0.15167719f, 0.17727961f, -0.32880729f, 0.37793270f, -0.04402554f, 
    0.29752120f, -0.07574888f, -0.54383045f, 0.13659692f, -0.27420086f, -0.44312704f, -0.10202583f, -0.04603187f, 
    -0.18180832f, 0.00593875f, 0.00109832f, 0.16592579f, -0.03414471f, 0.15052643f, 0.04761046f, 0.15117712f, 
    -0.03917846f, -0.20703723f, -0.20853841f, -0.09423963f, -0.00337420f, -0.06324492f, -0.05279754f, -0.21802048f, 
    0.11159209f, 0.30149743f, -0.18939048f, -0.14779009f, -0.26795989f, 0.22528848f, -0.03036720f, 0.02497741f, 
    0.09023861f, -0.17964207f, 0.15505527f, 0.13036643f, 0.07992271f, -0.06461192f, -0.44548801f, -0.18544951f, 
    -0.34874284f, 0.26792973f, 0.24998340f, 0.09812262f, -0.10884203f, 0.26328450f, 0.11041335f, -0.03751944f, 
    -0.01974175f, -0.55524361f, -0.07113437f, -0.22152813f, -0.04854677f, 0.27529642f, 0.16232911f, 0.03211894f, 
    0.04352992f, 0.00788220f, 0.04690129f, -0.04063268f, -0.05413036f, -0.14211662f, 0.17419362f, -0.11437500f, 
    0.13987984f, 0.08970661f, -0.37222543f, -0.04020841f, 0.21255545f, -0.08072611f, -0.09229992f, 0.04305909f, 
    -0.08364112f, 0.13799030f, -0.10540678f, 0.08719707f, 0.08615550f, -0.24127504f, 0.10391791f, 0.33052528f, 
    0.09364863f, 0.03417315f, -0.23362592f, 0.26601350f, -0.29429775f, 0.06987347f, 0.24141486f, 0.10003194f, 
    -0.33917388f, 0.14725684f, -0.22263433f, 0.06018131f, 0.20914322f, -0.29165095f, -0.05235442f, -0.22818932f, 
    -0.07014384f, 0.27662021f, -0.23994176f, -0.13539837f, 0.01507873f, 0.11129190f, -0.18203595f, -0.11587136f, 
    0.10767452f, -0.11445777f, 0.01591086f, -0.37764728f, -0.40565026f, -0.06650361f, 0.15061368f, 0.04192146f, 
    -0.03464685f, -0.01623865f, 0.07532787f, -0.19686840f, -0.10228413f, 0.32103428f, 0.18682064f, 0.17522655f, 
    -0.56617516f, 0.05844977f, 0.22356761f, -0.27201903f, 0.09429117f, 0.16746908f, -0.07056653f, -0.09135196f, 
    -0.29039946f, -0.00091104f, -0.13206851f, -0.24737568f, 0.15428816f, 0.17288043f, -0.08087350f, -0.09159057f, 
    0.21529900f, 0.13816252f, -0.11388835f, -0.07917460f, 0.19756892f, 0.17533670f, 0.00001465f, -0.29354265f, 
    0.00619102f, 0.12507014f, -0.21571468f, -0.11110663f, 0.05384332f, -0.11364302f, -0.08845026f, -0.11791106f, 
    0.12235390f, 0.16979887f, -0.07561239f, -0.39074868f, 0.11812424f, -0.39116320f, -0.05343409f, 0.06868389f, 
    -0.11648678f, -0.17396864f, -0.11913896f, -0.21424808f, 0.00551894f, -0.01197575f, -0.54349905f, 0.05892887f, 
    0.12416990f, 0.23396526f, 0.11753539f, -0.21606547f, 0.15789291f, -0.00377624f, 0.00769761f, 0.01844623f, 
    0.17556007f, -0.00670070f, 0.10773462f, 0.09803282f, 0.06079471f, -0.07876800f, -0.21977946f, 0.07646137f, 
    0.14300178f, 0.07989892f, 0.21114199f, 0.10320897f, -0.10938210f, -0.06272480f, -0.14150263f, 0.07690128f, 
    0.41223294f, -0.06966989f, -0.04245366f, 0.12751286f, -0.02069334f, 0.14796111f, -0.08535425f, 0.01550902f, 
    0.15878420f, -0.09497947f, 0.09994492f, 0.01644500f, -0.32729098f, 0.06354772f, 0.00554684f, -0.07118388f, 
    -0.09057614f, 0.28497049f, 0.36882052f, -0.30757838f, 0.05569151f, 0.09272281f, 0.13277890f, 0.23949708f, 
    -0.08006352f, 0.09059821f, -0.16364719f, -0.16961652f, -0.10282853f, -0.18473774f, 0.05138754f, 0.06249965f, 
    -0.01141295f, -0.00305880f, 0.09072670f, -0.06866854f, 0.07890178f, 0.10885110f, 0.02082111f, -0.24681850f, 
    0.08511448f, -0.29340994f, 0.04398412f, -0.02441016f, 0.05729380f, -0.50203735f, 0.04896878f, -0.00717644f, 
    0.14947480f, -0.01431714f, 0.05668216f, 0.04747349f, 0.00272280f, -0.47664541f, -0.37897569f, -0.33253807f, 
    0.08207861f, 0.01358231f, -0.52793962f, 0.02841477f, 0.20096458f, 0.22750400f, 0.12583216f, 0.09296542f, 
    0.18922384f, 0.00883660f, 0.37073582f, -0.47966796f, -0.30369487f, -0.11977822f, 0.11130310f, -0.12337600f, 
    -0.40793741f, -0.21295831f, -0.08848029f, 0.03291593f, -0.38263595f, 0.19140647f, -0.08035967f, 0.13832273f, 
    -0.09857711f, 0.06181009f, -0.15121776f, 0.00533130f, 0.27762285f, 0.09077582f, 0.12994434f, -0.44205347f, 
    0.10773563f, 0.32952985f, 0.02471774f, -0.30192339f, -0.15488033f, -0.03522880f, 0.13165317f, -0.07368457f, 
    -0.06965503f, -0.02388530f, 0.35417822f, -0.10506734f, 0.02476902f, -0.06014867f, -0.17552598f, -0.02824949f, 
    -0.51487124f, 0.29080293f, -0.32277620f, 0.06650692f, 0.09780748f, 0.20550516f, 0.26884979f, 0.06615847f, 
    -0.36248928f, 0.03774172f, -0.00723791f, -0.68825155f, 0.09123545f, -0.09299897f, 0.05508004f, 0.22335169f, 
    0.18023187f, -0.35390067f, -0.00448259f, 0.04800283f, -0.15171069f, 0.16109160f, -0.76110935f, 0.07711029f, 
    -0.23262563f, -0.06668115f, -0.03154150f, 0.14525229f, -0.21299639f, -0.14398363f, -0.11447225f, 0.07539297f, 
    -0.07438253f, 0.07121643f, 0.03699144f, -0.43458956f, -0.21883525f, -0.22073683f, 0.11958154f, 0.06887296f, 
    0.06679495f, 0.26217425f, 0.06566175f, 0.03598297f, -0.12655991f, 0.00039625f, -0.17244194f, 0.32498869f, 
    -0.04765107f, 0.14715022f, 0.08973894f, 0.13421667f, 0.44308963f, 0.04080553f, -0.13626012f, 0.07800117f, 
    0.09041787f, -0.33210394f, -0.32256731f, 0.25479323f, 0.01862211f, 0.11797932f, 0.09953988f, 0.29212141f, 
    -0.27317265f, -0.33166477f, -0.31083292f, -0.15873708f, -0.13251512f, 0.25569713f, -0.44534907f, 0.08814447f, 
    -0.36366150f, -0.21252689f, 0.07855206f, 0.06841389f, 0.07889657f, -0.02159739f, 0.11602475f, -0.21883368f, 
    -0.00696360f, 0.07514881f, 0.20014070f, 0.01841660f, -0.16460532f, 0.14269628f, -0.30496261f, 0.06466173f, 
    0.13478248f, 0.10298252f, 0.04025454f, -0.18499872f, -0.00975885f, -0.60678911f, -0.01417754f, -0.09086286f, 
    -0.20537288f, 0.06992992f, -0.04463657f, -0.01304461f, -0.19960493f, -0.53148431f, -0.04074460f, -0.20446940f, 
    -0.03734247f, -0.10009562f, 0.25560910f, 0.08770555f, -0.25142655f, -0.05493861f, -0.06801324f, 0.22366092f, 
    -0.21129435f, -0.47609779f, 0.23201387f, 0.30039296f, -0.20935640f, 0.02433206f, 0.20957430f, 0.27861741f, 
    0.09976919f, 0.11505676f, 0.34001297f, 0.18149787f, 0.35189077f, 0.02741992f, -0.23047334f, -0.21435718f, 
    -0.04933206f, 0.08197195f, -0.05054100f, 0.16722408f, -0.13524948f, -0.20016688f, -0.34484231f, -0.07357646f, 
    -0.39219493f, -0.06964295f, 0.06532731f, -0.39593595f, 0.07444347f, 0.24833478f, 0.11180545f, -0.29208833f, 
    -0.07003164f, 0.03226398f, -0.20278218f, -0.31380635f, 0.21680608f, 0.17092210f, -0.32179415f, 0.10843835f, 
    -0.03215012f, 0.06930328f, 0.17717238f, 0.04736365f, 0.18489039f, -0.03512853f, 0.02145439f, 0.06747244f, 
    0.37530619f, 0.00909723f, 0.03351910f, 0.00806161f, -0.17275096f, 0.28941554f, -0.02919022f, 0.11770625f, 
    -0.00083630f, 0.21979992f, -0.28549004f, -0.11423127f, -0.05120699f, -0.08527195f, -0.39984664f, -0.07908963f, 
    0.35911453f, -0.17651048f, -0.32758892f, -0.05305422f, -0.25292888f, 0.26645988f, -0.08460135f, -0.21512973f, 
    -0.08877434f, 0.13804838f, -0.22113532f, -0.06926613f, -0.42442837f, 0.02457054f, 0.34801033f, 0.36631066f, 
    0.00581113f, -0.03351957f, -0.24959309f, 0.10392296f, 0.07061289f, 0.00934878f, -0.28646111f, -0.08260107f, 
    -0.18380061f, 0.08566352f, -0.00434242f, -0.03882040f, -0.06880945f, -0.26132241f, 0.15700014f, 0.04469290f, 
    0.16451645f, -0.44976324f, 0.27781555f, -0.44842526f, -0.00232752f, -0.00973524f, 0.09630678f, 0.06092930f, 
    -0.21577179f, 0.11080837f, -0.05894748f, 0.25730294f, -0.04131177f, 0.22475883f, 0.09903182f, -0.12588243f, 
    -0.34346807f, -0.42812017f, 0.03302730f, 0.02201862f, -0.11412497f, -0.31588387f, 0.10929874f, -0.16118547f, 
    -0.03151844f, -0.24035698f, 0.15884271f, 0.26956448f, 0.28071180f, 0.02990040f, -0.11993483f, 0.08371423f, 
    0.04458618f, -0.22798003f, -0.42148909f, -0.06952734f, -0.44186410f, 0.02938052f, 0.02750780f, 0.33106479f, 
    -0.09750997f, 0.15271553f, -0.03602006f, -0.01156088f, 0.34518817f, -0.03406103f, -0.26937285f, -0.06352701f, 
    0.21802877f, -0.17714077f, -0.36870337f, 0.18683945f, -0.32087895f, -0.38007975f, 0.32564723f, 0.03637988f, 
    0.15969765f, -0.20801605f, -0.04159669f, -0.47969085f, -0.07583936f, -0.10521993f, -0.15225311f, 0.31970289f, 
    -0.28102168f, 0.26308629f, -0.15515178f, -0.21469466f, -0.33989048f, 0.01488639f, -0.34427607f, -0.11805066f, 
    -0.38884744f, 0.06734657f, 0.08552632f, -0.31720263f, 0.06814962f, 0.00355526f, -0.11479118f, -0.11788121f, 
    -0.49944410f, -0.23377006f, 0.09316940f, -0.32237160f, 0.14284687f, -0.33598760f, -0.07720531f, 0.10571996f, 
    -0.05029450f, 0.02519266f, -0.15012321f, 0.12457103f, 0.17412911f, 0.09835250f, -0.05615651f, -0.32672322f, 
    -0.25681591f, -0.02042894f, 0.27737924f, -0.00847718f, -0.22270176f, 0.14985508f, 0.19903353f, -0.59420812f, 
    -0.05180904f, 0.19248602f, -0.26640385f, 0.08161080f, -0.31149158f, -0.07330936f, 0.01025587f, -0.16128482f, 
    0.05252231f, 0.27004814f, 0.18263307f, 0.00161011f, 0.13435657f, -0.33085996f, -0.09942460f, -0.09870558f, 
    0.21986485f, -0.23859555f, -0.08894140f, 0.31564441f, -0.02205259f, 0.32024929f, 0.06866644f, 0.25160533f, 
    0.10511880f, 0.26669183f, -0.04045229f, 0.07170984f, 0.13491033f, -0.03459780f, -0.22197467f, -0.11037292f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03425516f, 0.10870618f, 0.17402598f, -0.17501178f, 0.00958286f, 0.12467572f, -0.05584883f, -0.02875517f, 
    0.17350958f, -0.02970684f, 0.12261403f, -0.04382678f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
