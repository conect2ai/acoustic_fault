#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.31698436f, -0.28072321f, -0.98833758f, -0.45026234f, 0.06045118f, -0.79006344f, 0.45462811f, 0.70345181f, 
    -0.19521108f, 0.44777745f, 0.30992097f, -0.40456837f, 0.07932675f, -0.38007548f, 0.31363305f, 0.18008392f, 
    0.30670273f, 0.04228271f, -0.06160475f, -0.28857532f, 0.02025014f, 0.28156406f, -0.14308290f, 0.06211721f, 
    0.03479334f, -0.31949151f, -0.56366193f, -0.59033084f, -0.53893864f, -0.25705314f, 0.18717033f, 0.59180033f, 
    0.54010874f, 0.53269148f, 0.47101387f, -0.09449279f, 0.10367623f, -0.13956182f, -0.38279486f, -0.04594342f, 
    -0.11135496f, 0.03522394f, 0.08604176f, 0.14877829f, -0.17232667f, -0.07341097f, -0.26008198f, 0.28690496f, 
    -0.31052911f, 0.06551751f, -0.31252071f, -0.35263023f, -0.82513285f, -0.23506260f, 0.16479099f, -0.64315802f, 
    -0.11391565f, 0.65390438f, -0.08669865f, 0.11997838f, 0.55346960f, 0.26598170f, 0.40537575f, -0.28439504f, 
    0.05774627f, -0.33935285f, -0.16883896f, 0.07503218f, -0.29069889f, -0.27203503f, -0.13487087f, -0.15088347f, 
    -0.14057940f, -0.29878432f, 0.19344595f, -0.57399416f, -0.93281806f, 0.09949660f, 0.11775485f, 0.03694171f, 
    0.28738853f, -0.44833338f, 0.47761962f, 0.13189711f, -0.58843219f, -0.01618054f, 0.02651322f, 0.03589686f, 
    0.21765493f, -0.40017357f, -0.22700475f, 0.17283469f, -0.23280188f, 0.00422934f, 0.18940485f, -0.17016020f, 
    0.14926004f, 0.31166106f, -0.25572613f, 0.10642184f, 0.29820782f, -0.17662795f, -0.55734330f, -0.73198950f, 
    -0.43931559f, -0.27989504f, -0.04903964f, -0.34172741f, -0.03810665f, 0.26300770f, 0.37926090f, -0.23383167f, 
    -0.06025373f, -0.23922589f, -0.06066858f, -0.03355889f, 0.17334440f, 0.25834793f, 0.07801272f, 0.07999936f, 
    0.11783049f, 0.15359890f, 0.10430056f, 0.15276714f, 0.48328966f, -0.11109778f, 0.12982138f, 0.15892062f, 
    -0.27592126f, -0.09879775f, -0.24424553f, -0.44626543f, -0.55258077f, -0.55735999f, -0.66076958f, -0.12410349f, 
    -0.09474780f, -0.19554378f, -0.34169653f, 0.02177124f, -0.20384282f, -0.05110017f, -0.37310240f, 0.03744593f, 
    -0.12820539f, -0.18621589f, -0.06807309f, 0.36002317f, 0.19817869f, 0.41400969f, 1.09940612f, 0.51544833f, 
    0.14328103f, 0.74827474f, 0.40999681f, 0.24094671f, 0.30941740f, -0.12513161f, 0.44210929f, -0.26325697f, 
    -0.28769857f, -0.14897832f, -0.24014163f, 0.07329454f, -0.35970059f, 0.21126240f, 0.09365454f, -0.21514042f, 
    0.09977528f, 0.25501809f, 0.18027227f, 0.05203519f, 0.40533498f, 0.00680817f, 0.38963661f, -0.50139505f, 
    -0.56227130f, -0.78520131f, -0.26008677f, -0.29924032f, 0.45791587f, 0.23749615f, -0.02872866f, 0.25798646f, 
    0.58023489f, -0.47980124f, -0.24240378f, 0.09537764f, -0.19223920f, -0.30443636f, -0.47662270f, -0.13262391f, 
    0.38223529f, -0.24808146f, -0.19259804f, 0.03307709f, 0.27167749f, 0.11020374f, 0.21379825f, -0.02704415f, 
    0.33995983f, -0.31382141f, -0.00644476f, 0.98413092f, 0.19864479f, -0.07411387f, -0.78601515f, -0.09205845f, 
    0.10357928f, -0.06602173f, 0.35571644f, 0.22822395f, 0.23157373f, 0.11479516f, 0.01777841f, -0.43252769f, 
    -0.02726883f, -0.08052205f, -0.36734152f, 0.30831900f, 0.25794199f, -0.21481588f, -0.03651983f, -0.00927299f, 
    -0.21571641f, -0.66296196f, -0.72769141f, 0.00222396f, 0.48696122f, 0.47792217f, -0.03979061f, 0.73841292f, 
    -0.06220780f, 0.40703750f, -0.01564962f, -0.24402581f, -0.42048323f, -0.34863615f, -0.21881135f, -0.13141641f, 
    -0.30978474f, -0.30390903f, 0.07896178f, -0.22667320f, -0.36388516f, -0.00307459f, 0.08960707f, -0.04437768f, 
    -0.23094708f, -0.32243985f, -0.26702216f, 0.72553509f, 0.59649730f, -0.75001532f, 0.33095738f, 0.44527382f, 
    0.28272545f, -0.67917019f, -0.39057580f, -0.56059879f, 0.26431546f, 0.42907450f, 0.06448949f, 0.32343906f, 
    -0.13732523f, -0.19571434f, 0.22500175f, -0.30275097f, 0.00633232f, 0.12721801f, -0.09019191f, 0.13478407f, 
    -0.04480841f, 0.12190995f, -0.01147946f, 0.77279520f, 0.50456041f, -0.53052366f, 0.32348868f, 0.63696510f, 
    0.52055472f, -0.33833364f, 0.05405794f, 0.42178690f, 0.27817336f, 0.12505962f, 0.22901505f, -0.01556278f, 
    0.02276391f, 0.08361503f, 0.03248915f, -0.03716191f, -0.44395798f, -0.16715814f, -0.39404124f, -0.21481256f, 
    0.19794099f, -0.02927857f, 0.08368302f, -0.06895223f, 0.37563312f, -0.16027005f, 0.28271630f, -0.18528756f, 
    0.53135461f, -0.21828644f, -0.65921825f, -0.74198872f, -0.48935840f, 0.04305633f, 0.12520114f, 0.54569000f, 
    0.29007697f, 0.09903233f, 0.03416740f, -0.35594061f, 0.09683201f, -0.08205359f, 0.22246790f, 0.15584716f, 
    0.25127941f, 0.21285263f, 0.15639047f, -0.20834823f, -0.19705448f, 0.27829480f, 0.40558392f, 0.55581385f, 
    0.51319849f, -0.13055895f, -0.86778545f, -0.58940476f, 0.09746342f, -0.41800043f, 0.11228514f, 0.36863494f, 
    -0.00044997f, -0.36407229f, 0.18257867f, 0.24107297f, -0.20000224f, 0.04037002f, 0.36348078f, -0.31782135f, 
    0.37361401f, 0.38746735f, 0.16874123f, 0.21015707f, -0.08835318f, 0.24859431f, 0.39752969f, 0.08114231f, 
    -0.48925707f, -0.36710310f, -0.44777304f, -0.66430032f, -0.34065959f, 0.52974290f, 0.06530652f, -0.68401444f, 
    -0.44591978f, -0.26064125f, -0.13544102f, -0.13726279f, -0.59689492f, -0.44717887f, 0.30837801f, -0.02169592f, 
    -0.18991739f, -0.02591352f, -0.27036557f, -0.19473076f, 0.24238667f, -0.16758716f, -0.13823600f, 0.53936708f, 
    0.24237861f, 0.74600035f, 0.83862060f, 0.74795771f, 0.80683452f, -0.09129068f, -0.31283098f, 0.03802490f, 
    0.30229264f, 0.08619398f, 0.22501560f, 0.29592329f, 0.28221858f, -0.23066743f, -0.06599250f, -0.06004819f, 
    0.20190082f, -0.20996250f, -0.05760342f, -0.14175673f, -0.14424410f, 0.09861045f, 0.02151924f, -0.21284157f, 
    0.33705097f, 0.19171664f, 0.14684840f, -0.13152516f, 0.20387238f, 0.10472432f, -0.82963413f, -0.39498729f, 
    -0.37173828f, -0.31274486f, -0.04847029f, 0.17555194f, 0.35977545f, 0.21995771f, -0.33588353f, 0.12757887f, 
    -0.42625001f, 0.48189780f, -0.15524991f, 0.23416625f, -0.51879799f, -0.16576935f, 0.01840629f, -0.18857940f, 
    -0.19323447f, 0.68427426f, 0.71034533f, -0.41214833f, 0.02274879f, 0.85875535f, -0.33818030f, 0.18071327f, 
    0.18852495f, 0.28679818f, 0.39096197f, -0.25634816f, -0.27082005f, 0.13702735f, -0.33632898f, 0.26620954f, 
    0.22581470f, 0.19414400f, 0.25074795f, 0.13359812f, 0.15850632f, -0.12859927f, -0.03931408f, -0.02789480f, 
    0.14986406f, -0.04644373f, 0.86186105f, -0.97267348f, 0.35690349f, 0.86143136f, 0.52704734f, 0.63343394f, 
    0.40699828f, -0.10673985f, 0.14823416f, -0.21033819f, -0.20899352f, -0.14839448f, -0.20230170f, -0.00196980f, 
    -0.19346669f, -0.03568036f, 0.17340511f, 0.18419652f, 0.26770860f, 0.10832830f, -0.11780848f, -0.13281831f, 
    -0.18554826f, -0.17024931f, -0.03946076f, -0.80794054f, -0.15036193f, -0.68616486f, -0.66257161f, 0.03075764f, 
    -0.38721830f, -0.39903000f, 0.45611814f, 0.32882172f, 0.16556002f, 0.32694906f, -0.02624491f, 0.27957961f, 
    -0.08358727f, -0.21153103f, 0.30833274f, 0.05421844f, -0.21222800f, 0.06567489f, 0.24661124f, -0.18702351f, 
    -0.04793955f, 0.18521698f, 0.05308084f, -0.22342092f, 0.42299947f, 0.00875905f, -0.58815503f, -0.68443370f, 
    -0.13811703f, 0.12735620f, 0.05448816f, 0.11954444f, -0.45413697f, -0.66052800f, 0.45125785f, 0.35351604f, 
    0.25081038f, 0.10713968f, -0.05116423f, 0.17428912f, -0.25615907f, -0.38684401f, -0.51145828f, 0.22773494f, 
    -0.08177032f, -0.06091269f, 0.29050830f, 0.09051651f, -0.14032781f, 0.51496005f, 0.66802591f, 0.62908226f, 
    -0.20193093f, 0.41700172f, 0.48332089f, 0.15032810f, 0.07679328f, -0.43618077f, -0.38681117f, 0.27490056f, 
    0.33789349f, -0.07998070f, 0.38742909f, -0.24427892f, 0.18330786f, 0.04883353f, 0.08841299f, 0.01593402f, 
    -0.01897127f, -0.12833659f, 0.16159311f, -0.03482198f, -0.20467480f, 0.37393531f, 1.09533870f, -0.11950976f, 
    -0.63305610f, -0.74613637f, 0.20968190f, -0.27300283f, -0.24095924f, -0.01390791f, 0.13797526f, 0.08901174f, 
    -0.38027635f, -0.17285967f, 0.60051936f, 0.00713533f, -0.24744080f, 0.03400436f, -0.13675217f, -0.22040808f, 
    0.37513784f, 0.33950403f, 0.20179011f, 0.24806951f, 0.10189760f, -0.32824323f, -0.17261454f, -0.20255676f, 
    -0.31645441f, -0.88953412f, -0.04465446f, -0.52346736f, 0.53731149f, -0.68534702f, -0.14766581f, -0.36666811f, 
    -0.16967928f, 0.39064926f, -0.42245808f, -0.08959399f, 0.25601795f, 0.38125265f, -0.12211802f, 0.34151709f, 
    -0.01194521f, -0.02270780f, 0.17129785f, 0.17438215f, -0.06939194f, 0.07797927f, 0.07660268f, -0.41326877f, 
    -1.33175778f, 1.26250017f, 0.71125615f, -0.83982891f, 0.19402345f, -0.29954880f, 0.46500757f, 0.24043573f, 
    0.23412915f, -0.26273012f, -0.05487709f, -0.05799584f, -0.34520155f, -0.09662103f, -0.22121000f, -0.23169535f, 
    -0.16858403f, -0.19744131f, -0.21084325f, -0.05284220f, 0.00963239f, 0.04221519f, 0.07610747f, 0.37772912f, 
    0.01730574f, 0.66950727f, 0.15758097f, 0.04248805f, 0.66580129f, 0.70673192f, 0.46550253f, 0.60280561f, 
    0.37802327f, 0.51909477f, 0.41350514f, -0.14610165f, -0.29263705f, -0.04674555f, -0.13914333f, 0.00844350f, 
    -0.13279532f, -0.04627539f, 0.08771607f, -0.29291764f, 0.09133011f, 0.04998448f, -0.02256327f, 0.17646891f, 
    -0.12055466f, 0.22064742f, 0.65841872f, -1.06878936f, -0.42148226f, 0.90356439f, 0.25580597f, -0.68353999f, 
    0.45431378f, 0.35311821f, -0.61081535f, 0.11200658f, 0.14654975f, 0.21058647f, -0.34628195f, -0.11391784f, 
    0.27954966f, 0.11432575f, -0.07526027f, -0.26388183f, 0.10166626f, -0.23443714f, -0.05138594f, -0.19127586f, 
    -0.10844073f, 0.29230383f, 0.03759602f, 0.62546027f, 0.62316948f, -0.62280512f, -0.73160493f, 0.08416946f, 
    0.69065976f, -0.12509188f, 0.42407423f, 0.60880584f, 0.51766169f, -0.27572480f, -0.44033000f, -0.35628873f, 
    -0.26881671f, 0.26076213f, 0.17696223f, 0.03160462f, -0.27109495f, 0.02383822f, 0.52147722f, -0.02718240f, 
    0.04718523f, -0.24553809f, -0.03227473f, -0.29522789f, -0.16891347f, -0.19462772f, -0.17840435f, -0.01468257f, 
    -0.05291430f, 0.08893001f, -0.67923832f, -0.53241992f, -0.19351412f, 0.26431039f, 0.42514580f, 0.20415075f, 
    0.59277481f, 0.00471162f, -0.05678825f, 0.16431414f, 0.17781933f, -0.16786289f, 0.08552827f, 0.23491211f, 
    -0.51495796f, 0.09257310f, 0.43310535f, 0.18116798f, -0.00815708f, 0.49581933f, 0.87378764f, -0.60850418f, 
    -0.75207382f, -0.60743922f, -0.34618405f, -0.31822497f, 0.27027711f, 0.33149481f, 0.07029635f, -0.12316515f, 
    0.10666673f, -0.03936313f, -0.04850024f, 0.05778430f, 0.40456697f, -0.10440135f, 0.15703817f, -0.12483212f, 
    -0.14786668f, 0.12576911f, 0.34255558f, -0.15774781f, 0.10270714f, 0.19365168f, -0.91258508f, 0.05452396f, 
    -0.26514840f, -0.16245419f, -0.45814016f, 0.08805915f, -0.24383354f, -0.34738845f, -0.25378695f, -0.16069378f, 
    0.06810396f, 0.46300229f, -0.20472863f, 0.20265506f, -0.15679845f, -0.17674887f, 0.01323846f, -0.10228489f, 
    -0.44763309f, 0.01132977f, 0.08098148f, 0.34011328f, 0.45985186f, 0.27956492f, 0.24395791f, -0.10559829f, 
    -0.97151721f, 0.36239457f, 0.61022204f, -0.79124469f, -0.85932040f, 0.39267635f, 0.55725592f, -0.42880842f, 
    0.25327879f, 0.17391106f, 0.25869933f, -0.32959071f, -0.17915261f, 0.09607809f, -0.18290006f, -0.29894406f, 
    -0.03829710f, 0.19341840f, -0.24794802f, 0.16318387f, 0.10192642f, 0.00435682f, 0.17492317f, -0.11566547f, 
    -0.04614943f, -0.43209818f, -0.39631891f, -0.55761600f, -0.03884247f, 0.04706091f, -0.57075024f, -0.29055306f, 
    -0.30676916f, -0.49367476f, 0.08218392f, -0.40994063f, 0.15863293f, -0.13831262f, -0.18568560f, 0.20226111f, 
    0.18559042f, -0.30874509f, 0.32929105f, 0.55218524f, 0.09082466f, -0.02516135f, 0.15482625f, -0.18174152f, 
    -0.28325716f, -0.31094456f, 0.33976379f, 0.22502461f, 0.06287757f, 0.08001099f, -0.66572571f, 0.42263862f, 
    0.43474114f, -0.02841529f, 0.38564295f, -0.38242626f, 0.16661492f, -0.09374023f, -0.47311512f, -0.59630877f, 
    -0.19313432f, -0.41488737f, -0.02408084f, -0.26035282f, 0.01020938f, -0.22991972f, 0.07076497f, -0.25031596f, 
    0.08131111f, -0.32738560f, -0.68610638f, -0.76661229f, 0.03885406f, 0.26936698f, 0.12271379f, 0.23383260f, 
    0.68493700f, 0.49262583f, -0.69023365f, 0.55593795f, -0.62232119f, -0.10770810f, 0.24407771f, -0.09647513f, 
    -0.22491576f, -0.27099192f, -0.03579255f, 0.09986005f, -0.16986489f, -0.46229565f, 0.18546249f, -0.45317757f, 
    -0.24025665f, -0.23764808f, 0.06909204f, -0.22908066f, -0.79943740f, -0.40496689f, -0.13586724f, -0.48560569f, 
    0.29842165f, 1.00279760f, 0.51848984f, -0.24167766f, 0.17505048f, -0.23030110f, -0.31060097f, -0.61590099f, 
    -0.42133060f, -0.08174928f, -0.12890728f, 0.33278391f, -0.04589986f, -0.02610053f, 0.12868680f, -0.06459311f, 
    0.00674495f, 0.04882234f, -0.00977082f, 0.00113772f, -0.77069390f, -0.28244847f, 0.32439721f, -0.32663071f, 
    0.58146375f, -0.66868103f, -0.06296842f, 0.07109482f, -0.53601414f, -0.28822386f, -0.10012787f, 0.46736795f, 
    0.32136175f, -0.27191743f, -0.07624809f, -0.18498468f, -0.22571613f, 0.12474646f, 0.42017552f, 0.17141414f, 
    0.16344182f, -0.32320741f, -0.02553503f, -0.22098829f, -0.07632311f, -0.44361678f, -1.22050929f, -0.36870185f, 
    -0.18267515f, 0.36091712f, -0.03962872f, 1.00592804f, -0.00536453f, -0.29990166f, 0.01703763f, -0.23172322f, 
    0.36431348f, -0.05905189f, 0.39412543f, 0.19452368f, -0.06677747f, -0.25800595f, -0.51602477f, -0.24944259f, 
    -0.27144176f, 0.07279807f, 0.02997893f, 0.24837369f, 0.26881930f, -0.25062352f, 0.54679561f, 0.61444974f, 
    -0.16475704f, -0.36834556f, 0.25804141f, -0.43754804f, -0.67073780f, -0.06779936f, -0.16455008f, 0.37337676f, 
    0.38729328f, 0.12783259f, -0.07295679f, 0.21678488f, -0.27320531f, 0.36740267f, 0.11967026f, -0.31980032f, 
    0.13786098f, 0.47118345f, -0.24251223f, 0.22556481f, 0.10660154f, -0.20217080f, -0.20947024f, 0.04197317f, 
    0.73397899f, 0.30475277f, 0.41211417f, 0.24812940f, -0.46812835f, 0.10914357f, -0.18653634f, -0.67902005f, 
    -0.50424516f, 0.12925948f, -0.28041095f, 0.21925640f, -0.05274318f, 0.33951956f, 0.12802707f, 0.38318369f, 
    -0.11822744f, -0.09152074f, 0.17475802f, -0.29337662f, -0.17271425f, -0.29425767f, 0.14573961f, -0.13812964f, 
    -0.50983173f, -0.17281726f, -0.06549251f, 0.29458028f, 0.01006209f, -0.27028960f, -0.63551718f, -0.60856885f, 
    -0.16556701f, -0.09215806f, 0.07067293f, 0.02148858f, 0.28826797f, 0.65998799f, -0.21289371f, 0.33571538f, 
    0.20390722f, 0.37472242f, -0.14002310f, 0.08705600f, -0.04514054f, -0.00293667f, 0.12491912f, -0.13649777f, 
    0.07998201f, 0.75822902f, -1.13973689f, -0.08605939f, 0.25454900f, 0.18349943f, 0.03467296f, 0.52475297f, 
    -0.11497242f, -0.25959888f, 0.08835482f, 0.55448723f, 0.22268337f, -0.34439278f, 0.36072153f, -0.01440651f, 
    -0.07729504f, -0.33205813f, 0.14437288f, 0.19309425f, -0.28728110f, -0.07147977f, -0.05400169f, 0.31182879f, 
    -0.17153896f, 0.05695178f, -0.20093252f, -0.25699410f, 0.36864701f, 0.94688153f, 0.32980093f, -0.04046491f, 
    0.00626220f, -0.69503236f, 0.14211735f, -0.11835174f, 0.45911801f, -0.04782524f, -0.17922238f, -0.25837636f, 
    -0.44364625f, -0.38469666f, 0.16068691f, -0.09258183f, -0.24524578f, 0.57593364f, 0.24213511f, -0.02057344f, 
    -0.19833253f, 0.30402383f, 0.11107611f, 0.32457969f, -0.30599895f, 0.57419747f, 0.59619439f, 0.83986640f, 
    -0.43621194f, 0.54200304f, 0.48290202f, -0.40782210f, 0.33201855f, 0.07110137f, -0.27115503f, 0.22197659f, 
    -0.01615386f, 0.04695832f, 0.02067791f, -0.10278659f, 0.00599096f, 0.02465523f, -0.04906430f, 0.17828891f, 
    0.04179274f, 0.08100059f, 0.12409185f, 0.03448278f, 1.10778332f, 0.63819879f, 0.72185373f, -0.19517665f, 
    0.00378444f, -0.29835185f, 0.18542624f, -0.23168087f, 0.42468798f, 0.46403402f, -0.14820512f, 0.20249367f, 
    -0.27052373f, 0.01227800f, -0.25688404f, -0.25239399f, 0.07748214f, -0.01514525f, -0.45068413f, -0.01941721f, 
    0.06964671f, 0.11157394f, 0.04117245f, -0.02519407f, -0.09425543f, 0.74871278f, 0.09650849f, 0.56447756f, 
    0.70203853f, 0.75062191f, 0.33451375f, -0.47656536f, -0.34665930f, -0.19594294f, -0.24531250f, 0.26306117f, 
    -0.21583167f, -0.39631829f, 0.05182511f, 0.15124239f, 0.43678999f, 0.08194520f, 0.10254166f, 0.06118946f, 
    0.21861115f, 0.34941399f, 0.24163491f, 0.39717674f, 0.19332986f, 0.40845704f, 0.88845617f, -0.19748881f, 
    0.15800527f, -0.09133030f, -0.33152515f, 0.24389087f, -0.50719631f, 0.40353194f, 0.75333595f, 0.26236111f, 
    -0.38423023f, -0.31342003f, -0.16269499f, -0.34525758f, -0.28956714f, -0.19278967f, -0.10596233f, 0.09809276f, 
    -0.03573595f, -0.09998094f, 0.02297911f, -0.06324574f, -0.19070256f, 0.28026363f, -0.05650213f, 0.51531810f, 
    -0.23553792f, -0.85524780f, -0.58115989f, -0.52817953f, -0.09783122f, 0.75177217f, 0.75000525f, -0.21412621f, 
    0.45779335f, -0.05400215f, 0.17392957f, 0.39979982f, -0.09162116f, 0.06343193f, -0.45488870f, -0.24067226f, 
    -0.04575816f, 0.21701694f, -0.12007441f, 0.34216133f, -0.11081179f, 0.21512838f, -0.03106622f, 0.14111033f, 
    -0.08215193f, -0.57297343f, -0.67358416f, -0.40795350f, -0.13701531f, 0.47170436f, -0.67321956f, -0.15079919f, 
    0.33458379f, 0.10394713f, -0.51482505f, -0.45035565f, 0.26413900f, 0.12939066f, -0.37006158f, 0.04735568f, 
    0.03105191f, 0.24133898f, 0.05622189f, 0.03325168f, 0.23967426f, 0.02694563f, -0.11186843f, 0.37179539f, 
    0.09826533f, 0.42918894f, 1.10320938f, -0.13115369f, -0.10900727f, -0.55999184f, 0.56307524f, -0.19331008f, 
    -0.70137662f, -0.00227878f, -0.16846308f, 0.47935504f, 0.15881063f, -0.01027945f, 0.37198260f, -0.19892648f, 
    -0.06450426f, 0.02262729f, 0.44888353f, 0.15831390f, -0.20661327f, -0.18115564f, -0.10654119f, -0.12861782f, 
    -0.29771781f, 0.12475361f, 0.75199682f, -0.87067533f, -0.00422127f, -0.62954420f, 0.22731990f, 0.78285325f, 
    -0.25923508f, 0.29994109f, 0.20962535f, -0.23791806f, -0.14201175f, 0.06795301f, 0.03255257f, 0.08326202f, 
    -0.01329692f, -0.15951742f, -0.22491838f, -0.28564239f, -0.09496989f, -0.44760439f, 0.24909391f, 0.38512790f, 
    0.16234015f, 0.17713407f, 0.33931574f, -0.47132277f, 0.75567269f, 0.29115734f, -0.55252987f, 0.84128982f, 
    0.92770630f, -0.25209519f, -0.86169606f, 0.33473197f, -0.33079568f, -0.40510467f, 0.14801738f, -0.46519014f, 
    0.25091881f, -0.43941352f, -0.29720375f, -0.05474528f, -0.08517123f, 0.08925895f, -0.10717487f, 0.19441205f, 
    0.02281412f, -0.09128807f, -0.07393813f, 0.02512916f, 0.70551252f, 0.17932798f, -0.59631819f, -0.72668952f, 
    -0.03591403f, 0.50843167f, 0.00969836f, -0.51698935f, -0.07774577f, -0.12905420f, -0.40836459f, 0.17036092f, 
    -0.13652354f, 0.20873454f, 0.04316382f, -0.40390161f, 0.00117629f, -0.42634949f, -0.13301246f, 0.08072022f, 
    -0.05827336f, 0.13831648f, -0.13401051f, -0.10513476f, -0.16455981f, -0.36391848f, 0.64220685f, 0.19823471f, 
    -0.00937788f, -0.66180313f, 0.32888967f, -0.38153595f, 0.16627748f, 0.55831617f, -0.78708744f, -0.47410321f, 
    -0.26436400f, -0.38120586f, 0.14662176f, -0.12693129f, -0.11440904f, -0.03418897f, 0.37072858f, 0.02718794f, 
    0.00215546f, 0.17147736f, 0.09318757f, 0.11000022f, 0.37001917f, 0.05212641f, -1.08572054f, 0.18211049f, 
    -0.25499681f, -0.60488117f, -0.84026575f, 0.68755782f, 0.69476801f, -0.66733420f, 0.37297645f, 0.40434572f, 
    -0.11203298f, -0.13162479f, 0.37465602f, -0.20113412f, -0.11347715f, 0.19887954f, 0.31998801f, 0.27380562f, 
    0.01494891f, -0.00139486f, -0.11109666f, -0.32777125f, -0.05197562f, 0.03872459f, 0.15204108f, 0.69998813f, 
    -0.18867350f, 0.52891535f, 0.68647552f, 0.53517789f, -0.08247163f, -0.42938992f, 0.32899809f, 0.07944802f, 
    -0.12846123f, 0.09672971f, 0.03665607f, -0.10569735f, 0.08512273f, -0.13740373f, 0.16136643f, 0.14476149f, 
    0.27862313f, 0.17511009f, 0.26234838f, -0.42186618f, 0.16135381f, 0.21153915f, -0.26093051f, -0.24138676f, 
    -0.66553122f, -0.16976832f, -0.48290646f, 1.01136196f, 0.81206989f, 0.52068049f, 0.19372331f, 0.31737402f, 
    0.04738431f, 0.02930188f, -0.26043269f, -0.20415677f, -0.40519279f, -0.01298803f, 0.24795109f, -0.01894315f, 
    -0.37536070f, -0.01002861f, -0.22242296f, -0.09197892f, 0.04222589f, 0.09827980f, -0.36077413f, 0.37124011f, 
    -0.34135693f, 0.04451391f, 0.89263380f, -0.61803615f, -0.55726641f, -0.14936253f, -0.14517833f, -0.63121063f, 
    -0.58477563f, -0.72566664f, -0.26462096f, 0.17501113f, -0.12389780f, -0.10457934f, -0.00094993f, -0.36057061f, 
    0.02839196f, -0.22262675f, -0.43985885f, 0.16799425f, -0.06378581f, 0.20245497f, -0.07439555f, -0.00692157f, 
    0.25051337f, 0.39721739f, 0.76184434f, 0.16049258f, -0.42069912f, 0.73378593f, -0.69012308f, -0.18035761f, 
    0.34484619f, -0.56545490f, 0.59453511f, 0.07607239f, -0.12402260f, -0.08885466f, -0.07130426f, 0.28284100f, 
    -0.36458263f, -0.05477108f, 0.06999093f, -0.25841609f, -0.13630858f, -0.22689958f, -0.19936171f, 0.21320194f, 
    -0.10872719f, 0.11126719f, -0.01435809f, 0.53459835f, 1.10733819f, 0.66967243f, 0.54120243f, -0.05842634f, 
    -0.81387091f, 0.72164309f, -0.41625869f, -0.27384493f, 0.38455844f, 0.20530915f, 0.06781612f, -0.24181938f, 
    0.19068871f, -0.10124148f, -0.19628648f, -0.18240324f, -0.08853557f, 0.13374612f, -0.19447628f, -0.06026722f, 
    0.30766612f, 0.06148207f, -0.13269858f, 0.05027607f, 0.48720688f, 0.65237319f, -0.57516068f, 0.62595719f, 
    0.34852073f, 0.26258960f, -0.08254218f, -0.68058479f, -0.02406511f, 0.21347386f, 0.11292527f, 0.41620842f, 
    -0.01155239f, 0.13789015f, 0.03852811f, -0.10134280f, -0.23161788f, 0.43509600f, -0.14713933f, -0.19552563f, 
    0.02625067f, 0.25676069f, 0.00705550f, 0.16640532f, 0.36795405f, -0.33623579f, -0.19961701f, -0.51257491f, 
    0.54794639f, 0.04557095f, 0.19499388f, -0.03380930f, -0.15485089f, 0.42980039f, -0.39345723f, -0.24959674f, 
    -0.34419680f, -0.03525291f, -0.29164243f, 0.03671859f, 0.37187317f, 0.27626619f, 0.05498355f, -0.46142101f, 
    0.06365495f, 0.09351851f, 0.11418340f, 0.26509777f, -0.13404357f, 0.66508299f, 0.04396449f, 0.11582603f, 
    0.48714221f, 0.37465167f, 0.55747288f, -0.47575316f, -0.00039434f, -0.26267007f, -0.25288522f, 0.46577942f, 
    0.20278259f, 0.30429339f, -0.33990666f, 0.54950225f, 0.03357038f, 0.15745457f, -0.44750077f, -0.44742006f, 
    -0.28231266f, -0.34281129f, -0.03406857f, -0.25588268f, 0.04777351f, 0.15976760f, -0.17988366f, -0.40256912f, 
    -0.01717401f, 0.84753186f, -0.36035994f, 0.45045808f, -0.01337975f, -0.00445084f, 0.29450843f, 0.27882972f, 
    0.35963088f, -0.31769210f, -0.36325070f, -0.15564410f, 0.26393306f, -0.20701015f, 0.09628869f, 0.02673889f, 
    0.10024424f, -0.15762413f, -0.21096168f, -0.37087128f, -0.05096629f, 0.28451008f, 0.14710672f, -0.19288519f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18056916f, 0.11621476f, 0.14148372f, 0.13898101f, 0.15010215f, 0.23005481f, 0.30309471f, 0.00997374f, 
    -0.03206660f, -0.02418966f, 0.04643849f, 0.22960714f, 0.24323191f, 0.07264543f, -0.11573894f, 0.18346664f, 
    0.08951504f, 0.16915636f, -0.00448549f, 0.22332641f, 0.21480019f, 0.02958522f, 0.07073043f, 0.25325981f, 
    0.18838841f, 0.03251049f, -0.07788289f, 0.08686697f, 0.25692773f, 0.08108746f, 0.26205382f, 0.09239379f, 
    0.23211536f, -0.09346150f, 0.00257447f, 0.16136064f, 0.23221830f, 0.19106354f, 0.22049706f, -0.04063204f, 
    0.25463682f, 0.22148189f, 0.25533006f, 0.27278164f, 0.08182785f, 0.13196482f, 0.10966506f, 0.07397941f, 
    0.32630643f, 0.10528768f, -0.00583648f, -0.09148178f, 0.02368509f, -0.01194021f, 0.07686643f, 0.12895350f, 
    0.07273803f, 0.11723009f, 0.19778419f, 0.15709998f, 0.19366530f, -0.08453669f, 0.09785543f, 0.02631128f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.36479244f, 0.23631096f, 0.00299642f, -0.22849149f, 0.10323545f, -0.06303171f, 0.04662572f, -0.13964708f, 
    -0.01820638f, -0.03943681f, 0.02412530f, 0.08131941f, 0.08418074f, 0.15721460f, -0.03367405f, -0.32319766f, 
    0.10506511f, -0.00980619f, 0.08615153f, -0.05946047f, 0.05598275f, -0.01418790f, -0.03145188f, 0.03829563f, 
    -0.31725529f, -0.08222803f, -0.17785966f, -0.04876054f, -0.03162004f, -0.13792402f, -0.05739896f, -0.00944030f, 
    0.01668947f, -0.01734604f, -0.12205557f, 0.08393449f, -0.11337716f, 0.08021045f, 0.02475992f, -0.03749400f, 
    0.07286545f, 0.01895513f, 0.00380992f, -0.00513266f, -0.03948626f, -0.01701195f, 0.00797843f, -0.18024582f, 
    -0.23355156f, -0.16437149f, 0.01415965f, -0.25987419f, 0.06110214f, -0.02638103f, 0.06417879f, 0.06311247f, 
    0.06711737f, -0.08866792f, 0.05779553f, -0.09540039f, -0.18090868f, 0.00032518f, 0.05241746f, 0.07180581f, 
    0.09899916f, -0.02050694f, -0.05161761f, -0.03940205f, -0.07860482f, -0.10271552f, -0.03769860f, -0.01545150f, 
    0.11687887f, -0.00207974f, -0.08645770f, 0.17183682f, -0.06794577f, -0.10408344f, -0.09087307f, 0.07826122f, 
    -0.00472314f, -0.02590809f, 0.00322637f, -0.10625215f, 0.25910565f, 0.10148449f, -0.08668052f, -0.09018070f, 
    0.14101525f, 0.02458747f, 0.08402400f, -0.00018239f, -0.03783394f, -0.01395880f, -0.02758937f, 0.03362348f, 
    0.17356756f, -0.07602972f, -0.11179518f, 0.21726699f, 0.06777260f, 0.06175106f, -0.04752277f, -0.07556578f, 
    0.06884760f, -0.01545669f, -0.13236794f, -0.05318050f, -0.17221411f, 0.17101401f, 0.07807057f, 0.09712922f, 
    0.02821123f, -0.01340157f, 0.12434117f, 0.00232485f, -0.08554839f, -0.01892171f, -0.01132269f, 0.07125454f, 
    -0.44240960f, 0.09000154f, 0.10595736f, -0.15949753f, -0.13077238f, 0.08682077f, 0.03303003f, -0.02285491f, 
    0.01273358f, 0.01148595f, 0.09124208f, 0.04769749f, 0.26584601f, -0.14532481f, 0.14069964f, -0.02117869f, 
    -0.18437725f, 0.00970762f, 0.01332343f, 0.07566203f, -0.02094181f, 0.06038885f, 0.11268932f, -0.01660248f, 
    0.10085869f, -0.08989108f, 0.07620629f, -0.12457035f, 0.02848371f, 0.00396017f, 0.01564251f, -0.12280324f, 
    -0.03674560f, -0.04231053f, -0.01340283f, 0.01610055f, 0.15439124f, 0.00846640f, -0.04292643f, 0.07900794f, 
    -0.09776840f, -0.02676230f, 0.03982013f, -0.11676348f, -0.03012273f, -0.06791137f, -0.06174270f, 0.05895879f, 
    -0.10744604f, 0.19528626f, 0.04665184f, 0.00965920f, -0.01519256f, 0.03134158f, 0.01907257f, -0.09030592f, 
    -0.07305846f, 0.05864562f, -0.02203319f, -0.12203351f, 0.11632685f, -0.12319903f, -0.09740049f, 0.18046735f, 
    -0.16308029f, -0.04202936f, 0.01924305f, 0.07267769f, 0.01414819f, 0.08117536f, -0.08398515f, 0.00546586f, 
    0.09648557f, 0.06584937f, 0.22881931f, -0.09305607f, -0.09392705f, -0.03664136f, -0.10289089f, 0.08708438f, 
    0.12979095f, 0.00652484f, -0.16323715f, 0.06999427f, 0.12442753f, -0.01547792f, 0.12075328f, -0.02906230f, 
    -0.19689104f, 0.01108941f, 0.07381926f, 0.10184184f, 0.02485042f, 0.04127276f, 0.09288720f, 0.04139455f, 
    0.13306893f, -0.06651042f, -0.01242643f, 0.28950456f, -0.06452868f, -0.02438076f, 0.12941188f, 0.06493248f, 
    -0.00107360f, -0.03936904f, -0.08934285f, 0.04954396f, 0.03110306f, -0.05145653f, -0.12386247f, -0.07544891f, 
    -0.10474327f, -0.00623349f, -0.00700386f, -0.00777080f, -0.02181553f, -0.01971083f, -0.01596607f, -0.15005860f, 
    -0.28391883f, -0.05266309f, 0.13469204f, -0.08677522f, -0.06475671f, 0.00740550f, -0.07665861f, -0.02527037f, 
    0.02572505f, -0.02943105f, 0.02029080f, -0.05128273f, -0.03143858f, 0.05660932f, 0.03239980f, -0.33197084f, 
    -0.21534839f, -0.03203579f, -0.00771049f, 0.11865421f, 0.00239104f, 0.05131456f, 0.01327540f, 0.04844391f, 
    -0.07246345f, -0.21253185f, 0.15093736f, -0.37412009f, -0.01740435f, 0.05746992f, 0.09351356f, 0.03184224f, 
    -0.13554771f, -0.04965669f, 0.08463524f, 0.06582386f, -0.01557508f, -0.36235848f, -0.03326442f, 0.06699171f, 
    0.00968914f, 0.07855607f, -0.13058169f, 0.04898516f, -0.15572917f, -0.07688611f, 0.03401798f, 0.01801381f, 
    -0.08057650f, -0.00153690f, 0.17268358f, -0.02728815f, -0.04904832f, -0.04160936f, 0.04992633f, -0.04420049f, 
    -0.00388453f, -0.00977311f, 0.01806075f, 0.02081487f, 0.03525450f, 0.04163477f, 0.08332927f, 0.19679737f, 
    -0.12813196f, 0.03214911f, -0.05650765f, 0.04462311f, -0.06303889f, 0.03681830f, -0.01652373f, -0.08412306f, 
    0.15285820f, -0.14952576f, 0.04279222f, 0.29014248f, -0.05911086f, -0.01007925f, -0.01982726f, 0.00060921f, 
    0.00958941f, 0.02684664f, 0.02908496f, -0.06653535f, 0.22408691f, -0.15766987f, 0.08251202f, -0.22366606f, 
    -0.11771857f, 0.02780718f, 0.15997373f, 0.03241373f, -0.03869628f, -0.04611469f, 0.09393294f, 0.15921132f, 
    -0.08227963f, -0.19008817f, 0.04092645f, 0.03163149f, -0.00733141f, -0.02199288f, -0.02128958f, 0.06210301f, 
    -0.04395206f, -0.00469613f, -0.00872977f, -0.05986020f, -0.06757899f, -0.07840025f, 0.01450681f, -0.40669522f, 
    -0.00164379f, -0.05644216f, 0.01378501f, -0.14226398f, 0.00793950f, 0.02866920f, -0.00436935f, -0.00978748f, 
    -0.09297456f, -0.10257965f, 0.00893421f, -0.02946993f, 0.04246963f, 0.05634117f, -0.02832085f, 0.07021539f, 
    -0.01457691f, -0.01347631f, -0.06751128f, -0.07103759f, -0.17240016f, -0.12075479f, -0.10795510f, 0.19062009f, 
    -0.03662887f, -0.00252395f, 0.07283889f, -0.14160712f, 0.16234669f, -0.00958414f, -0.04648570f, -0.04950227f, 
    -0.20632809f, -0.20437171f, 0.08741719f, -0.02453385f, -0.03875040f, 0.01376726f, -0.02163531f, 0.04786837f, 
    -0.02874617f, -0.05653603f, 0.10702220f, -0.03091853f, -0.14182837f, 0.03742435f, 0.01460835f, 0.02899699f, 
    -0.20682745f, 0.08048647f, -0.01507424f, -0.06689756f, 0.14105786f, 0.13867863f, 0.07674833f, 0.08794365f, 
    -0.14155620f, 0.21424045f, 0.03345506f, 0.07513009f, 0.02937886f, 0.03310980f, 0.02807451f, 0.07562985f, 
    0.02944104f, -0.04149933f, -0.14981294f, -0.02990268f, 0.02033749f, 0.17391260f, 0.16273259f, -0.22330751f, 
    -0.03969277f, 0.01254648f, -0.05895955f, 0.03604395f, 0.02884595f, -0.04893151f, 0.11142194f, 0.07391017f, 
    -0.57157516f, -0.13559361f, -0.08344053f, -0.02572688f, -0.03308735f, 0.13490580f, 0.03554167f, 0.03205355f, 
    0.04879420f, 0.01145352f, -0.00524024f, 0.02479655f, -0.32119745f, -0.00820678f, 0.04300722f, -0.15514909f, 
    0.05929643f, 0.02637015f, -0.06130259f, 0.01937923f, -0.00845465f, 0.06736709f, 0.05432122f, -0.06945551f, 
    0.12150535f, -0.01849536f, 0.03243069f, -0.12422982f, -0.04743042f, 0.05861268f, 0.05453230f, 0.04291888f, 
    -0.00231248f, -0.11230161f, 0.10013467f, -0.05270529f, 0.05285098f, 0.22503562f, 0.02856617f, -0.00555955f, 
    -0.06652522f, -0.09787206f, 0.11564787f, 0.03618923f, -0.03235267f, 0.04384609f, 0.05550124f, -0.16591090f, 
    -0.14731091f, 0.05634871f, 0.06112994f, 0.07296988f, 0.00230346f, -0.01958779f, -0.00549478f, 0.05342424f, 
    0.05578195f, 0.07264822f, -0.13126451f, -0.02668761f, -0.01896578f, 0.03837491f, 0.06085124f, 0.16148308f, 
    -0.28433526f, -0.05735320f, 0.00185907f, 0.00837205f, 0.01413077f, 0.12173688f, -0.13029581f, -0.04044020f, 
    -0.00712096f, 0.02391730f, -0.04755969f, 0.19131635f, -0.07137366f, -0.06591707f, 0.01777986f, 0.01466280f, 
    -0.00254275f, 0.10522559f, -0.10719925f, -0.00045863f, 0.07312536f, 0.05607972f, -0.11899638f, 0.13599285f, 
    -0.20405154f, 0.06171134f, -0.02634048f, -0.01123699f, -0.03081737f, -0.02538249f, -0.01255199f, -0.10852766f, 
    0.13974074f, -0.04005508f, -0.04043305f, -0.05345431f, -0.11434463f, -0.08664575f, 0.03534555f, 0.02419393f, 
    -0.07033318f, 0.09627490f, 0.01399528f, -0.05562112f, 0.22445947f, -0.06692927f, -0.00982530f, 0.09363085f, 
    -0.06438953f, -0.03068832f, -0.03016378f, 0.05339929f, 0.06546731f, -0.04225266f, -0.01388176f, -0.06113650f, 
    0.25348786f, -0.01212576f, -0.06056897f, 0.12316220f, 0.09844967f, 0.07020691f, -0.08647477f, -0.07934585f, 
    -0.05994542f, -0.03110361f, 0.02300341f, 0.03836673f, -0.29344320f, -0.04821737f, -0.13659754f, -0.37860078f, 
    0.02721304f, -0.11794668f, 0.08867844f, -0.01391461f, 0.04790184f, 0.03752463f, -0.03147209f, 0.04670992f, 
    0.15435936f, -0.09231947f, 0.03136946f, -0.14165983f, 0.08435275f, 0.05049058f, -0.00437792f, 0.00951909f, 
    -0.01042765f, 0.02910548f, -0.03238839f, 0.10156071f, -0.14712405f, 0.14052202f, 0.03502753f, -0.17839086f, 
    -0.12129291f, 0.03980489f, -0.00421894f, 0.02163642f, 0.06614060f, 0.10498520f, -0.08277705f, 0.08415163f, 
    0.31660903f, -0.08540244f, 0.06768937f, -0.19444714f, 0.11308949f, -0.02849235f, 0.06672163f, -0.08057605f, 
    -0.06136071f, 0.07786652f, 0.07605348f, -0.08330366f, -0.22053784f, -0.14268243f, 0.29480299f, -0.19351815f, 
    0.07018515f, -0.05274983f, 0.06790674f, -0.16704433f, 0.01374577f, 0.03107704f, -0.01631861f, 0.04958899f, 
    0.05750049f, -0.11192338f, 0.16155477f, -0.39028448f, -0.08879208f, -0.14877881f, 0.05928609f, -0.01959979f, 
    -0.01259948f, -0.07454875f, 0.04036911f, 0.05933367f, -0.02383402f, 0.11817554f, 0.02317726f, 0.18444327f, 
    -0.09424139f, -0.02537466f, -0.01366051f, -0.13997154f, -0.05869721f, -0.02040893f, 0.00808433f, 0.03249559f, 
    0.63887507f, 0.09955137f, 0.07822076f, -0.23957275f, -0.01576806f, 0.03809119f, -0.09862933f, -0.04491856f, 
    0.04407085f, 0.01494075f, -0.11155853f, 0.05933144f, 0.21988821f, -0.11580019f, -0.09485801f, 0.16202809f, 
    -0.12127796f, 0.03677772f, -0.00632568f, 0.03803943f, 0.03972973f, -0.02268853f, -0.06519546f, -0.09733614f, 
    -0.04042459f, 0.11615025f, 0.19085637f, 0.13837597f, -0.00867356f, 0.00818321f, 0.06729998f, -0.16032584f, 
    0.03923245f, -0.13557771f, 0.03822276f, -0.12414271f, -0.15268423f, -0.05394217f, 0.28535157f, -0.12665370f, 
    -0.08725179f, -0.01644466f, 0.03934307f, 0.05884663f, 0.06706482f, -0.09107562f, -0.00947068f, -0.02629976f, 
    -0.01087463f, -0.04535019f, -0.18736644f, 0.26339689f, -0.07740834f, -0.06559191f, -0.11956001f, 0.00978576f, 
    -0.06502660f, -0.01894075f, 0.06496768f, 0.04448711f, 0.13985401f, 0.09443810f, -0.00074587f, 0.02316252f, 
    -0.11316690f, -0.03998457f, 0.00093733f, -0.04635717f, -0.15708160f, 0.02156116f, -0.17395848f, 0.02306969f, 
    0.11434314f, -0.00239228f, 0.15169100f, 0.04007136f, -0.18632120f, -0.08261476f, -0.01499618f, -0.02180642f, 
    -0.06620633f, 0.07672980f, -0.03728217f, -0.00145349f, 0.09817939f, 0.04724962f, -0.12845281f, 0.15700547f, 
    0.05878834f, 0.06484836f, -0.05937605f, 0.02716123f, 0.03153820f, 0.06739055f, -0.03756289f, -0.04043550f, 
    0.06007851f, -0.10874439f, -0.08422965f, 0.06657910f, -0.07139485f, -0.12456144f, -0.00196142f, -0.04409390f, 
    0.00443101f, 0.03036605f, 0.09697790f, -0.12131539f, -0.10664824f, -0.08245055f, -0.05951419f, -0.01459763f, 
    -0.05408369f, -0.00180516f, -0.03565742f, 0.05319304f, 0.10199580f, -0.06387446f, -0.01227809f, -0.02539220f, 
    0.43321505f, -0.03004077f, -0.11116537f, -0.04396598f, -0.05386410f, 0.04624763f, -0.11565714f, 0.06390493f, 
    0.13732092f, -0.01289336f, 0.08366840f, -0.01267073f, 0.14104353f, -0.13966085f, -0.01252723f, -0.13577347f, 
    0.03932238f, -0.00947959f, -0.06600723f, 0.06447823f, 0.09269110f, -0.02719088f, 0.01745896f, -0.02458925f, 
    0.27029979f, -0.04982231f, 0.02804908f, 0.00711694f, 0.00900480f, 0.00072475f, -0.04445549f, 0.05599384f, 
    0.01569097f, -0.18888195f, 0.03015015f, -0.19626810f, 0.07378371f, 0.07265316f, -0.09419138f, 0.03263154f, 
    -0.14116415f, -0.00788315f, 0.02398050f, 0.10840898f, -0.04278642f, 0.04173857f, 0.06103889f, 0.12212281f, 
    0.19274075f, -0.06667494f, -0.11887889f, -0.18832301f, -0.09938513f, 0.03721967f, 0.00615499f, 0.08406848f, 
    -0.03400798f, -0.08325790f, 0.08434628f, 0.05058321f, -0.03075955f, 0.04293468f, -0.24440575f, -0.16810265f, 
    0.01394503f, 0.05465959f, -0.00540594f, 0.10587560f, -0.00950081f, 0.01750267f, -0.05852090f, -0.05706789f, 
    0.30868661f, -0.06638807f, 0.15347354f, 0.25598466f, -0.12250420f, 0.03700452f, 0.01182863f, 0.05839578f, 
    -0.03295381f, 0.10003817f, -0.02883889f, 0.08021210f, 0.03631753f, -0.10371853f, -0.03566684f, -0.05931590f, 
    -0.00545801f, -0.06903032f, -0.04422176f, 0.00115615f, 0.07106125f, -0.07404966f, -0.00351920f, -0.05912296f, 
    -0.24071757f, 0.09989939f, 0.14048193f, 0.12791909f, 0.04672700f, -0.01047513f, -0.06613595f, 0.06224879f, 
    0.01521436f, 0.02454349f, 0.01211096f, 0.05503047f, 0.16114484f, -0.09632803f, -0.14683916f, 0.03603929f, 
    0.01061088f, 0.06526395f, -0.05754139f, 0.10185457f, -0.03990984f, 0.07360116f, -0.14113486f, -0.20763123f, 
    -0.04861614f, 0.03020002f, 0.01728967f, -0.13418664f, -0.12439515f, 0.00387657f, 0.08592080f, -0.15363058f, 
    0.02426770f, 0.05424581f, -0.00071456f, -0.09749811f, 0.06086878f, -0.09843115f, 0.06501745f, 0.13083938f, 
    0.08127161f, -0.09715956f, -0.04887615f, -0.03521273f, -0.00174837f, 0.02687367f, -0.09327322f, 0.07572956f, 
    -0.11290001f, -0.09426647f, 0.12320504f, 0.00715873f, -0.05235942f, -0.09087666f, -0.02263260f, 0.11368903f, 
    0.03439637f, 0.05476236f, 0.11172090f, -0.04340902f, -0.25092456f, 0.01803717f, -0.09443510f, 0.17218362f, 
    0.01824369f, 0.05558936f, -0.02341793f, 0.04107251f, 0.02066308f, 0.01172230f, 0.06069456f, 0.17748533f, 
    0.09639473f, -0.25028405f, -0.19372584f, -0.31953403f, -0.12483832f, -0.14993870f, -0.10076849f, 0.09747405f, 
    -0.03088148f, -0.16374119f, 0.02383253f, -0.07073016f, 0.10668715f, 0.08821847f, 0.18896370f, -0.00199960f, 
    -0.08608230f, -0.01137112f, -0.01821988f, -0.00671732f, -0.02679866f, -0.02914195f, 0.08668547f, 0.01229852f, 
    0.03348857f, -0.15542173f, -0.09916140f, -0.10511126f, 0.09646963f, -0.01223552f, 0.01286961f, -0.10773525f, 
    0.15923901f, -0.04162943f, 0.01477168f, 0.06213689f, 0.22935908f, 0.01723456f, 0.00931523f, -0.07612158f, 
    -0.07390174f, 0.02642892f, -0.10901268f, 0.05299478f, 0.02630217f, -0.07237121f, -0.08280587f, -0.01402905f, 
    0.34752765f, -0.25016034f, 0.01561854f, 0.09990790f, 0.02314167f, 0.07298939f, -0.05470607f, -0.05998059f, 
    0.06770517f, 0.04170686f, 0.07948248f, -0.03482507f, 0.07147137f, -0.01975498f, 0.02841303f, -0.22891225f, 
    0.07546308f, -0.09040861f, 0.08543374f, 0.16475810f, 0.02178052f, -0.01369620f, 0.02805601f, 0.03862885f, 
    0.15149269f, -0.12109612f, 0.03337813f, -0.05310226f, -0.04282385f, -0.04309138f, 0.15758957f, 0.05907318f, 
    -0.09116293f, -0.00413396f, -0.06632667f, -0.01636081f, 0.21700230f, 0.07086947f, 0.12904033f, 0.02651345f, 
    -0.17336096f, -0.08448149f, -0.00649559f, -0.05052461f, -0.08522491f, -0.05074250f, -0.04368138f, 0.02562634f, 
    0.17351155f, -0.29088539f, 0.06597959f, -0.25917125f, 0.01670960f, -0.14009929f, 0.09543058f, 0.01312488f, 
    -0.14649568f, 0.00138818f, -0.05974489f, 0.01890835f, -0.11015557f, 0.11946455f, -0.10818641f, 0.05458736f, 
    0.05464027f, -0.01858320f, 0.17032331f, -0.09024495f, 0.07556828f, 0.09435777f, -0.07716032f, 0.02203967f, 
    -0.49405766f, 0.24761771f, -0.22349988f, -0.20549071f, -0.09275420f, 0.07859576f, 0.08522494f, -0.01581858f, 
    -0.00752072f, -0.03765967f, 0.03188157f, -0.07223172f, 0.25856006f, -0.00821138f, 0.05146657f, 0.11977707f, 
    0.03300296f, 0.03348918f, 0.03211074f, -0.05965611f, -0.01999770f, 0.09468458f, 0.09260129f, 0.04456372f, 
    -0.02701946f, -0.30688724f, 0.13886653f, 0.09672359f, -0.20555389f, 0.06241067f, -0.03050537f, 0.06613705f, 
    -0.02347139f, 0.01572777f, -0.15180647f, 0.13591512f, 0.03053243f, -0.12542191f, 0.09219784f, -0.13809700f, 
    0.06605165f, -0.14090692f, -0.09493447f, -0.03137764f, 0.10337626f, 0.02870352f, -0.00909778f, -0.04031543f, 
    -0.23797490f, -0.09634638f, 0.06382395f, -0.04646143f, 0.10701591f, -0.14269343f, 0.09378001f, -0.09020418f, 
    -0.06472646f, -0.03238738f, 0.04130962f, 0.00466300f, 0.11107016f, -0.10174423f, -0.04845756f, -0.30949891f, 
    -0.06562397f, -0.00781510f, -0.01610147f, 0.18645161f, -0.00964608f, -0.05326747f, -0.05448378f, 0.12243352f, 
    -0.27502397f, -0.06539075f, -0.23314793f, -0.04698643f, 0.06831840f, 0.03845420f, 0.04040843f, 0.07681178f, 
    0.11032394f, 0.01790660f, 0.00576614f, 0.00498883f, -0.42253989f, -0.06526776f, -0.17933311f, 0.21752013f, 
    -0.04782298f, 0.01160680f, -0.05808979f, -0.07554474f, -0.08626750f, -0.07811606f, -0.11252999f, 0.24570425f, 
    -0.03175927f, -0.01960195f, 0.04781866f, -0.06219551f, 0.02726911f, 0.05461115f, 0.11660170f, -0.04836393f, 
    -0.02733460f, 0.05799338f, -0.05986020f, 0.09557936f, 0.06177527f, 0.12239539f, 0.02761651f, -0.02711042f, 
    0.11740299f, 0.02238489f, 0.03343188f, -0.00533447f, -0.02793232f, -0.17652766f, -0.13662516f, -0.14267474f, 
    0.04759262f, 0.08667169f, -0.11851750f, 0.13617344f, 0.00566011f, -0.02698236f, -0.10394265f, -0.05536685f, 
    -0.09488862f, 0.05257301f, 0.12275948f, -0.14187993f, 0.10640586f, -0.19099203f, -0.18872832f, 0.01242495f, 
    0.06197985f, -0.01191775f, -0.01173179f, -0.06359491f, 0.16599567f, -0.01122790f, -0.15360259f, 0.01327339f, 
    0.10202404f, -0.07706343f, -0.04687726f, -0.11596413f, 0.02892420f, -0.14546147f, -0.01194395f, -0.00500381f, 
    -0.01787865f, 0.03686137f, 0.10831905f, 0.00634979f, 0.26160523f, -0.07713739f, -0.03530246f, -0.02848210f, 
    -0.08952006f, 0.07804799f, 0.02078124f, 0.00783115f, -0.03142120f, -0.08114330f, -0.12431253f, -0.07873793f, 
    -0.03711699f, -0.01504342f, 0.00469194f, -0.14367470f, 0.06481477f, -0.09197182f, 0.11627264f, -0.01050429f, 
    -0.06177859f, 0.02501390f, 0.02897202f, 0.10168330f, 0.08697689f, -0.00075076f, -0.13892463f, 0.01796153f, 
    -0.01953101f, 0.12731135f, -0.05240115f, -0.10452230f, 0.04778007f, -0.10336041f, 0.04497948f, 0.13159133f, 
    -0.10980411f, -0.02283658f, 0.02743498f, -0.05699334f, 0.07877890f, 0.02767602f, 0.07287042f, 0.12275019f, 
    -0.00221059f, -0.05546779f, 0.11521893f, 0.05952629f, 0.25218287f, -0.30575389f, -0.02133217f, -0.00178609f, 
    -0.00233885f, 0.03206178f, -0.03897624f, 0.04827052f, 0.00689942f, -0.06779879f, -0.06035075f, -0.03919810f, 
    -0.13826345f, -0.06100826f, -0.04531978f, 0.02535421f, 0.00272681f, 0.08635354f, 0.00212254f, -0.04150994f, 
    -0.09133296f, -0.16337390f, 0.10079227f, -0.18870738f, -0.04583922f, 0.13647182f, 0.10556102f, 0.12127990f, 
    -0.04842935f, 0.06271009f, -0.02359083f, 0.05822206f, 0.10599222f, 0.18222480f, -0.03746321f, 0.05970275f, 
    0.29394838f, 0.13699386f, 0.07194030f, 0.16263172f, -0.09566495f, -0.02663480f, 0.06705774f, -0.01377248f, 
    -0.00989134f, -0.16763015f, -0.03137405f, -0.06260408f, -0.00254755f, -0.04729544f, 0.18066539f, 0.07714157f, 
    -0.12941675f, -0.00071198f, 0.08999461f, 0.03329530f, -0.00401245f, 0.07978870f, 0.02049715f, 0.12954177f, 
    -0.00363664f, -0.01724077f, 0.09049840f, 0.00494094f, 0.02319842f, 0.01499192f, 0.01812865f, -0.05699425f, 
    0.18167181f, -0.04088560f, 0.02949364f, -0.06381395f, 0.35274521f, -0.18533747f, 0.07260439f, -0.25389358f, 
    0.05114184f, 0.11936128f, -0.06855754f, 0.02947289f, -0.01302085f, -0.07477201f, -0.01216474f, -0.07561209f, 
    -0.14885868f, -0.02067681f, 0.03004188f, -0.16288106f, -0.04700062f, 0.00387165f, 0.08517707f, 0.06253769f, 
    0.13611984f, 0.00342792f, 0.06005565f, -0.07015273f, 0.04670745f, -0.17158765f, 0.08380533f, -0.05618829f, 
    0.01346911f, -0.07879400f, -0.01328217f, 0.01780832f, -0.02648552f, -0.02256708f, 0.08955336f, -0.03327428f, 
    0.03818171f, -0.32628572f, 0.09243239f, -0.12975091f, -0.00736484f, 0.06466650f, -0.07906794f, 0.03443299f, 
    -0.05994508f, -0.06415042f, -0.02948481f, -0.01953230f, 0.06467289f, -0.09638804f, -0.10845901f, -0.04709949f, 
    -0.00619885f, -0.00915517f, -0.03309571f, 0.05290571f, -0.04876734f, 0.00083710f, -0.01353808f, -0.19636969f, 
    0.11329888f, -0.23100582f, 0.05635263f, -0.25368819f, 0.04182165f, -0.07894907f, 0.12679790f, -0.05489504f, 
    -0.31957212f, 0.05713554f, 0.04843554f, -0.14981477f, -0.31856209f, 0.03741109f, -0.19901030f, 0.05871854f, 
    -0.02738532f, -0.11382801f, 0.07038113f, 0.06848890f, 0.05735659f, 0.07268438f, -0.04781020f, -0.00698672f, 
    -0.48183757f, -0.20695361f, 0.08749867f, -0.06371247f, 0.11213644f, 0.01903685f, 0.07016045f, 0.05262914f, 
    0.00258428f, -0.00190562f, 0.04176887f, -0.00703862f, -0.00503139f, 0.04803464f, 0.06141963f, 0.04234391f, 
    0.05480374f, -0.12976703f, 0.01349840f, 0.02240990f, 0.01477907f, -0.07423826f, 0.09691840f, 0.04519554f, 
    0.19658837f, 0.07010840f, -0.29074201f, 0.08142481f, 0.12012509f, 0.04978564f, -0.13922653f, 0.04978931f, 
    -0.03761141f, 0.08467369f, -0.05205105f, 0.14551643f, -0.13139817f, -0.02809503f, -0.17511971f, -0.42902064f, 
    -0.07100331f, 0.08749393f, 0.04038464f, 0.01727034f, -0.08202907f, 0.14305393f, 0.02827146f, -0.00119961f, 
    0.30070323f, -0.15813312f, -0.21553732f, -0.09388467f, 0.04236856f, -0.04599898f, 0.01697156f, 0.03752709f, 
    -0.00539956f, -0.09667604f, -0.00733123f, -0.04658402f, 0.25823465f, 0.03643668f, 0.01764395f, 0.02589494f, 
    -0.12409471f, -0.07075796f, 0.07710171f, 0.01315765f, 0.16507998f, 0.00208284f, -0.01804034f, -0.00401521f, 
    0.06760509f, -0.20045640f, -0.01397075f, 0.03227482f, 0.06530116f, -0.03574096f, 0.01887401f, 0.02393053f, 
    0.05345592f, 0.00467326f, -0.00456067f, -0.06853411f, -0.15858388f, -0.02702853f, -0.14080270f, 0.05793105f, 
    0.03684727f, 0.02027084f, -0.02588550f, 0.09112579f, 0.09036899f, 0.08674288f, 0.10026792f, -0.03541011f, 
    -0.07132611f, 0.01892659f, 0.10725856f, 0.00764770f, 0.03486795f, 0.08001081f, -0.03914387f, -0.00013153f, 
    0.01343804f, -0.09625068f, -0.27104521f, 0.03809051f, -0.12215805f, 0.07524902f, -0.02128966f, -0.03664697f, 
    0.05598084f, -0.04163693f, -0.05010277f, -0.04749227f, -0.07993050f, 0.07983834f, -0.09013620f, 0.00006810f, 
    0.27461481f, 0.02966672f, -0.07350589f, 0.26577422f, -0.10583290f, -0.13287055f, 0.03815365f, 0.00750737f, 
    -0.03766291f, -0.01266350f, -0.07462907f, 0.04998941f, 0.18299785f, 0.17242837f, 0.10060704f, 0.26164475f, 
    -0.10868692f, -0.00993019f, 0.00126043f, 0.08650460f, -0.01856178f, -0.04880534f, -0.08629967f, 0.00052401f, 
    0.27462605f, -0.01460019f, 0.07250462f, 0.10999055f, -0.07058949f, -0.07122346f, 0.06740676f, -0.06005286f, 
    -0.07729653f, 0.05481339f, -0.03338239f, -0.16953683f, -0.23323035f, -0.01311851f, -0.13114236f, -0.00156387f, 
    -0.01696735f, -0.01413843f, -0.04151881f, -0.06060344f, 0.05098729f, -0.02388245f, -0.01660943f, -0.08076712f, 
    -0.23372184f, -0.22440691f, 0.12112515f, 0.01500373f, -0.04172865f, -0.05692420f, -0.00466437f, -0.08200785f, 
    -0.00987358f, -0.01130787f, 0.00983351f, 0.01275605f, -0.19042239f, -0.08424587f, -0.19953987f, -0.19965592f, 
    0.04038160f, -0.05798072f, -0.03529662f, -0.00401403f, 0.01228529f, 0.09550681f, 0.04394749f, -0.03078645f, 
    0.06973897f, -0.00442780f, -0.03376381f, -0.02636634f, 0.08988529f, -0.04230206f, 0.01420807f, 0.03684263f, 
    -0.00099345f, 0.06404983f, 0.00402809f, -0.02107734f, 0.23941833f, -0.00620311f, 0.09288089f, 0.26568758f, 
    -0.11266683f, -0.00859501f, -0.08455414f, 0.00161908f, 0.03493903f, 0.02724153f, -0.02411944f, 0.08081426f, 
    -0.03896086f, -0.00739744f, -0.24266186f, 0.02962981f, -0.04902122f, 0.08888823f, -0.11691680f, -0.06994756f, 
    0.00178771f, 0.09156683f, -0.05997537f, 0.01557633f, 0.07227258f, -0.13473123f, -0.08679908f, -0.07087879f, 
    -0.12218954f, 0.05891991f, -0.00226015f, -0.02420443f, 0.04385406f, -0.00400517f, 0.04247333f, 0.11902328f, 
    0.14431717f, -0.00928475f, -0.06886517f, -0.01524738f, 0.06264880f, -0.02614111f, 0.02964622f, -0.06596810f, 
    0.02242203f, -0.07374641f, -0.04147281f, -0.06131262f, 0.05214488f, -0.10242826f, 0.04431687f, -0.10121955f, 
    0.12360194f, -0.01513597f, 0.04495671f, -0.00281775f, 0.02643706f, 0.03019467f, -0.00847575f, -0.09441635f, 
    -0.10908254f, 0.03127239f, 0.06960113f, -0.12621126f, 0.03171280f, 0.05031344f, 0.02224364f, 0.00214384f, 
    -0.01482022f, -0.04654955f, 0.02850308f, -0.07902240f, -0.00605305f, 0.08166052f, -0.00922102f, 0.02602568f, 
    -0.06101921f, 0.06679522f, 0.06932168f, -0.07861769f, -0.02878857f, 0.01935174f, -0.06005145f, 0.07074661f, 
    -0.21317174f, -0.00974303f, -0.25644210f, -0.02465667f, 0.05798605f, -0.07031562f, 0.07698535f, 0.05129988f, 
    0.01865590f, 0.11526156f, -0.02814862f, 0.01954435f, 0.09534702f, -0.01886251f, 0.02337660f, 0.08409369f, 
    0.05326506f, 0.07765637f, -0.05329831f, -0.02368302f, -0.05071490f, 0.03676040f, -0.10339787f, 0.03153428f, 
    -0.30516815f, 0.08327155f, -0.10329603f, -0.07987110f, 0.08894449f, 0.04797553f, 0.03723041f, -0.09575351f, 
    -0.13344730f, 0.06312136f, -0.09124122f, -0.08878316f, 0.04066081f, -0.12888344f, 0.02753508f, -0.04499805f, 
    0.04623915f, 0.05082759f, 0.02908123f, 0.02427742f, -0.02021070f, -0.05026508f, 0.01183538f, 0.00393192f, 
    -0.42258170f, -0.07654805f, 0.06373198f, -0.14192669f, 0.10812653f, -0.04374202f, -0.00144651f, 0.05108169f, 
    -0.00648589f, -0.13422473f, -0.09522445f, -0.03835489f, -0.01655274f, 0.02158970f, 0.05474188f, 0.15125148f, 
    -0.04323563f, 0.06637701f, -0.09180225f, -0.07345423f, 0.00603037f, 0.09734344f, -0.08933334f, -0.04204240f, 
    -0.13522275f, 0.01013166f, -0.00566568f, -0.15656486f, 0.00129005f, -0.07078244f, 0.08482573f, 0.00545572f, 
    -0.00290818f, 0.03686240f, -0.01657960f, -0.08030385f, -0.08713906f, 0.00770716f, -0.00476600f, -0.04388568f, 
    0.15971355f, -0.05074876f, 0.08779571f, -0.02573999f, -0.02242331f, 0.08034096f, -0.05374354f, 0.04896126f, 
    -0.39942703f, 0.09152590f, 0.00736453f, -0.15214589f, -0.03059845f, -0.00413215f, 0.04187391f, 0.00203204f, 
    -0.02978243f, 0.01752268f, -0.00582808f, 0.07116178f, -0.11737618f, -0.01135271f, 0.03973576f, -0.10560672f, 
    -0.10932580f, 0.05086124f, -0.09186890f, 0.03576432f, -0.00807098f, -0.15800643f, -0.01899773f, 0.06914961f, 
    0.35312009f, 0.02304620f, -0.33394557f, 0.02785517f, -0.01996692f, 0.09030826f, 0.01293410f, -0.07930668f, 
    -0.03297517f, 0.08071807f, 0.05164688f, -0.01131781f, 0.03662875f, 0.03505502f, 0.05328915f, -0.08064000f, 
    0.12086614f, 0.02806728f, -0.00616162f, 0.04687312f, 0.03468909f, -0.00833173f, 0.00767304f, 0.02471522f, 
    0.53064817f, -0.10239971f, -0.06998844f, -0.27738884f, 0.09151146f, -0.00779099f, -0.02205262f, 0.07192227f, 
    -0.01814590f, 0.01269163f, 0.08599897f, -0.11691692f, 0.01858471f, 0.03731015f, 0.04910110f, 0.14995565f, 
    0.06108224f, 0.00081658f, 0.12407450f, 0.07842112f, -0.08366353f, -0.13064186f, -0.03127081f, -0.01803678f, 
    -0.02755298f, 0.05709032f, 0.06478891f, -0.12029684f, -0.01195990f, 0.07499751f, -0.03429005f, 0.06040429f, 
    -0.13221711f, 0.02734091f, 0.01988640f, -0.12516704f, -0.18866247f, -0.11944022f, -0.02958304f, 0.05903715f, 
    -0.09947406f, -0.03428730f, 0.04869743f, 0.01989819f, 0.02193301f, -0.04287203f, -0.02355900f, 0.01086652f, 
    0.07586472f, -0.03546844f, -0.03540280f, -0.29533306f, -0.06613533f, -0.03649328f, -0.15516250f, -0.06400996f, 
    -0.01371723f, -0.04265522f, 0.03099009f, -0.00115907f, 0.42605126f, -0.10148597f, -0.02978428f, -0.10404190f, 
    -0.10426509f, -0.00778297f, 0.04846508f, -0.05991511f, 0.05534987f, 0.01180084f, 0.07880829f, -0.11428043f, 
    -0.32655355f, -0.12071560f, 0.02485047f, -0.10461436f, -0.04433155f, 0.00694908f, -0.05053558f, -0.04601869f, 
    -0.02429571f, -0.06696649f, 0.02473875f, 0.01506862f, 0.18679750f, 0.05620734f, -0.14399564f, 0.03753372f, 
    0.05932724f, 0.07544670f, 0.00312707f, 0.00950009f, -0.06577979f, 0.13464949f, 0.08541278f, -0.02841306f, 
    0.27559504f, -0.04198474f, 0.03721253f, 0.07902318f, -0.10816219f, -0.06512790f, 0.08008981f, 0.05286615f, 
    0.09838974f, 0.04457943f, -0.09062779f, 0.00977789f, 0.18988436f, 0.02282044f, 0.09816404f, 0.09339137f, 
    -0.10067367f, -0.13737410f, -0.03141417f, 0.06685425f, 0.02275649f, 0.05910344f, -0.00094477f, -0.00226442f, 
    0.23523171f, -0.02032763f, -0.05650601f, 0.06700063f, 0.01529666f, 0.04023409f, 0.01922624f, -0.05439094f, 
    -0.02048843f, -0.02392891f, -0.12046921f, -0.01895893f, 0.32188296f, -0.06462763f, 0.01245694f, -0.06170517f, 
    -0.15923989f, -0.01195556f, -0.08350567f, -0.03005975f, 0.02575476f, -0.05295724f, -0.02154179f, -0.06486534f, 
    -0.10737381f, 0.11136899f, 0.05201042f, -0.05562180f, 0.02539732f, 0.01525940f, 0.07970657f, -0.00700303f, 
    -0.01486419f, -0.05444999f, 0.01851383f, -0.10000479f, 0.08977405f, 0.06768104f, -0.24952346f, 0.01155304f, 
    0.04476760f, 0.06458875f, -0.01609240f, -0.03781617f, -0.01832173f, -0.01650785f, -0.07677713f, -0.06500257f, 
    0.05693925f, 0.10348161f, -0.14785710f, -0.04712719f, 0.01384650f, 0.02951289f, -0.06235944f, -0.01227717f, 
    -0.03652007f, 0.01716636f, -0.14693874f, -0.07277095f, 0.08986677f, -0.08542093f, -0.00708105f, -0.07391750f, 
    0.00787758f, 0.04677965f, -0.03904867f, 0.03612695f, -0.06703064f, -0.08733111f, 0.06126792f, -0.05324557f, 
    0.01010658f, -0.08657458f, -0.10628390f, 0.13284129f, -0.05066347f, 0.03959561f, -0.10237274f, 0.02119487f, 
    -0.00287729f, 0.01725401f, 0.09688303f, 0.02599188f, 0.14181662f, -0.03032296f, -0.09566799f, 0.01724833f, 
    0.11447879f, 0.01849183f, -0.03542984f, -0.08748938f, 0.01905557f, -0.00253815f, 0.01072557f, 0.02329344f, 
    -0.03354637f, 0.06241129f, 0.03019570f, -0.18699862f, 0.09374561f, -0.01548160f, 0.04421346f, 0.00241267f, 
    0.00559477f, 0.07096500f, -0.00724335f, -0.04177806f, -0.01170515f, 0.00881353f, -0.10709064f, 0.00685247f, 
    0.07340219f, 0.00475058f, -0.02879952f, -0.02763803f, 0.02409806f, -0.05677589f, 0.00772679f, -0.06882155f, 
    -0.14470364f, 0.14177896f, 0.06575510f, 0.00998532f, 0.06236148f, -0.05738568f, 0.01323029f, 0.10505150f, 
    -0.00978960f, -0.00942918f, 0.02829772f, 0.03782998f, 0.23168664f, 0.14559776f, 0.03082586f, 0.22652972f, 
    -0.01261257f, -0.13945715f, 0.01312385f, -0.05182903f, -0.05928184f, -0.10237491f, -0.00341376f, 0.07099842f, 
    -0.33038479f, 0.07256985f, -0.00448022f, 0.03588007f, -0.03062526f, -0.05153416f, -0.06211013f, -0.01629626f, 
    0.01455274f, -0.00196761f, -0.05574457f, -0.01543809f, 0.04493260f, -0.05245439f, -0.01653032f, -0.18416259f, 
    0.09434416f, -0.00133103f, 0.14889681f, -0.06870151f, -0.02331373f, -0.04741727f, -0.06917320f, -0.03143220f, 
    -0.37569356f, 0.09866743f, -0.01840748f, 0.10043677f, 0.01810313f, -0.00191508f, 0.02773133f, -0.10249274f, 
    -0.11874443f, 0.05372799f, -0.09021667f, 0.04935226f, 0.13693425f, -0.16831386f, -0.00076346f, 0.19692053f, 
    0.00347307f, 0.02261867f, 0.07169658f, -0.01997745f, -0.01709834f, 0.16219814f, -0.05990627f, 0.09851037f, 
    -0.18773033f, -0.15299028f, 0.00215203f, -0.30237737f, 0.00091963f, -0.03321660f, 0.05189798f, -0.05350563f, 
    -0.11486779f, -0.04019191f, -0.00037807f, -0.00765190f, -0.22073051f, -0.02576767f, -0.21750161f, -0.10326450f, 
    0.00303767f, 0.05599663f, -0.02111015f, 0.03089023f, -0.08785270f, -0.07203758f, 0.02082972f, 0.00665823f, 
    0.32489336f, 0.08388150f, 0.08706599f, -0.07798494f, 0.03326359f, -0.05462995f, 0.00247496f, 0.01279894f, 
    -0.05111014f, 0.00072334f, -0.02507157f, -0.03890499f, -0.19497952f, 0.11937661f, -0.04007116f, 0.01844179f, 
    0.02367850f, 0.12586276f, -0.04808789f, 0.01881759f, -0.01320223f, -0.00835046f, -0.08555405f, -0.07457419f, 
    -0.06424633f, -0.17713901f, 0.07146047f, 0.05365641f, -0.05950668f, -0.02318719f, -0.03871264f, -0.06862976f, 
    0.14432062f, -0.01323171f, 0.01431805f, -0.01488809f, -0.39893267f, -0.20871010f, -0.19890058f, -0.35136586f, 
    0.06506585f, 0.02788399f, -0.03916705f, -0.06476212f, 0.03737896f, 0.12275410f, 0.01256633f, 0.01936644f, 
    -0.11355801f, -0.05740924f, -0.06595829f, -0.09819169f, -0.01865409f, -0.03644739f, -0.02751202f, 0.02121384f, 
    -0.05558380f, 0.12012541f, -0.02132759f, -0.07234910f, 0.02029367f, 0.13909195f, -0.02543368f, -0.12723228f, 
    0.09119266f, 0.06885315f, 0.02506673f, -0.04779097f, -0.05639979f, 0.01233390f, -0.03946266f, -0.00114667f, 
    0.12234718f, -0.09856724f, 0.01317368f, -0.20066477f, 0.07618988f, -0.03569064f, -0.00351311f, -0.04121755f, 
    -0.02915180f, 0.02950018f, 0.01408379f, 0.04288319f, -0.10436544f, -0.20192422f, -0.16399726f, 0.09152007f, 
    -0.04484263f, -0.06399626f, -0.15975976f, -0.04152019f, 0.03477418f, -0.01985693f, -0.00877166f, 0.02717233f, 
    0.22690456f, -0.13678026f, -0.14395227f, -0.00621045f, 0.01992535f, 0.01214558f, -0.03726875f, -0.08916427f, 
    0.00352667f, 0.08454768f, 0.10152146f, -0.07806472f, 0.09438248f, -0.03090849f, -0.27161393f, 0.11249791f, 
    -0.04267510f, 0.01764525f, 0.02189923f, -0.02532360f, -0.06880267f, 0.07579724f, -0.04462761f, -0.02760439f, 
    0.01143448f, -0.14592300f, -0.05927052f, -0.10827255f, -0.03221183f, -0.06561276f, -0.00616207f, -0.00980343f, 
    -0.10392498f, 0.06061993f, -0.09754060f, -0.03650572f, -0.06944130f, -0.02252962f, -0.05854320f, -0.18997636f, 
    -0.10758497f, -0.01693966f, -0.03087642f, 0.01455271f, -0.08888092f, -0.10146699f, -0.06614095f, -0.01582607f, 
    0.08839105f, 0.03743299f, 0.04422187f, -0.04359641f, -0.04967779f, 0.00011764f, 0.03339256f, -0.09759863f, 
    -0.04463901f, -0.01700562f, -0.04428115f, 0.10827692f, 0.14003271f, -0.00930147f, 0.03090708f, 0.10190023f, 
    -0.04126394f, -0.03441042f, -0.07346807f, -0.01700699f, 0.00616871f, -0.03229079f, 0.07978114f, -0.01223713f, 
    0.06407984f, -0.02685773f, -0.04879884f, 0.00809041f, -0.09040700f, -0.03542473f, -0.02858371f, -0.05453477f, 
    -0.00640254f, -0.02548450f, -0.19417284f, 0.08495248f, 0.08033843f, 0.03594407f, 0.05818499f, -0.02531904f, 
    0.02318970f, -0.05192800f, -0.01481048f, 0.06046426f, 0.08378699f, -0.02519397f, -0.07417790f, -0.02069509f, 
    -0.09421754f, -0.34826854f, -0.24779290f, -0.07846654f, -0.09578928f, -0.18273146f, -0.04797903f, -0.00590768f, 
    -0.02655706f, -0.11458767f, 0.02987480f, 0.02154730f, 0.03594264f, 0.08989392f, 0.04791409f, -0.16916497f, 
    -0.09072676f, -0.06164195f, 0.10718380f, 0.04377875f, -0.05610941f, -0.01548740f, -0.05316321f, -0.00440696f, 
    0.26657680f, -0.05369821f, -0.10822926f, 0.15862451f, 0.02364744f, 0.10405028f, 0.12733020f, -0.12642799f, 
    -0.01477548f, 0.05932431f, 0.09832099f, -0.08616241f, -0.06706072f, 0.06548754f, -0.00055588f, 0.12292544f, 
    -0.11988341f, -0.04630787f, 0.00581140f, 0.09186827f, -0.01063147f, 0.09338200f, 0.04819185f, 0.02968480f, 
    0.35182428f, -0.04937962f, 0.26843756f, 0.04246108f, 0.02761727f, -0.00323689f, -0.06587533f, 0.14761864f, 
    -0.00869125f, -0.04507480f, -0.08347239f, -0.08036075f, 0.02448747f, -0.01532611f, -0.26749551f, 0.02752611f, 
    -0.11764673f, -0.04618285f, -0.03548806f, -0.04311763f, 0.05648500f, -0.02182681f, -0.03612899f, -0.02429161f, 
    -0.00958995f, 0.06801857f, 0.11942939f, 0.19639082f, 0.05727998f, 0.11157687f, -0.05278459f, -0.04939013f, 
    -0.02008707f, 0.01114116f, -0.04307872f, -0.08874022f, -0.12737733f, -0.13760599f, -0.02169616f, 0.19959585f, 
    0.07088718f, 0.07451918f, -0.03138282f, 0.00141856f, -0.05059677f, -0.00796273f, 0.00296558f, -0.06295467f, 
    0.08577210f, -0.10437454f, 0.05526372f, 0.02122400f, -0.03391686f, -0.01264727f, -0.02259378f, 0.08990466f, 
    0.00515926f, 0.12349396f, -0.07602254f, 0.16697435f, -0.11497530f, -0.15087022f, -0.13069241f, 0.09906247f, 
    0.05129974f, 0.05921625f, 0.00544225f, -0.02512586f, 0.07794048f, -0.00642621f, -0.15415584f, 0.07948255f, 
    0.06584560f, -0.01407246f, 0.11502221f, 0.15367047f, 0.08362938f, 0.11654194f, 0.00714720f, 0.08075122f, 
    0.05958781f, -0.01105171f, -0.07185877f, 0.04904161f, -0.14659342f, -0.15051098f, -0.12982154f, -0.08324821f, 
    -0.15910082f, 0.04180292f, 0.03508540f, -0.05148453f, 0.03531717f, -0.08523770f, -0.03190247f, 0.04928925f, 
    -0.31974515f, -0.23268537f, 0.03911640f, 0.12925200f, -0.05879266f, -0.03988585f, -0.00925878f, 0.00527039f, 
    0.06239064f, 0.05978894f, 0.05256148f, 0.12157502f, -0.01270764f, 0.06065384f, -0.08149979f, -0.02856068f, 
    -0.11906402f, -0.02735583f, 0.04356620f, 0.02094693f, -0.03336899f, -0.04482108f, 0.01325454f, -0.00505545f, 
    0.06211923f, 0.02216938f, -0.02912026f, 0.04566733f, -0.07280315f, -0.08125871f, -0.01160835f, 0.13018151f, 
    0.02760581f, 0.00429633f, 0.02926677f, -0.07099844f, -0.08736998f, -0.38682157f, 0.00075477f, 0.12606364f, 
    -0.13731091f, -0.16747354f, -0.02851517f, 0.09951062f, -0.00058859f, -0.02408284f, -0.07994450f, -0.10904426f, 
    0.03549198f, 0.10049551f, -0.00195012f, -0.08152334f, -0.01400031f, -0.07891435f, -0.01036517f, 0.03437443f, 
    0.08936749f, -0.05194097f, 0.00631832f, 0.10186819f, 0.20026949f, 0.08939350f, -0.18303794f, -0.02869346f, 
    -0.03856077f, 0.04131533f, 0.04858314f, -0.02787100f, 0.00402548f, 0.01289019f, 0.02188296f, -0.09360892f, 
    -0.08632126f, 0.35441551f, 0.10737457f, -0.09897489f, 0.03613961f, 0.07904471f, 0.03819269f, 0.08483076f, 
    -0.01295406f, 0.02684775f, -0.00048633f, 0.02219091f, -0.37804288f, -0.19195150f, -0.23538886f, -0.29588383f, 
    -0.05802483f, 0.05804193f, -0.07981073f, -0.02693412f, 0.02362476f, -0.01835787f, 0.00524479f, -0.00881939f, 
    -0.04086931f, -0.14110383f, 0.33725595f, 0.03648201f, 0.06648315f, 0.03380615f, 0.05803303f, -0.08811781f, 
    -0.01206579f, 0.00346784f, 0.01510880f, -0.02369834f, -0.33681259f, 0.14432755f, -0.15582018f, -0.10519906f, 
    -0.08669571f, 0.08392643f, 0.00664976f, -0.00069884f, -0.00278607f, -0.05558464f, -0.04198066f, -0.03555701f, 
    0.13654318f, 0.10795710f, 0.02514915f, 0.05498514f, 0.03236555f, -0.00816271f, -0.08568804f, 0.10877375f, 
    0.07314406f, -0.07625660f, 0.04196190f, -0.05582483f, 0.04967044f, -0.18049502f, 0.04173584f, -0.11654136f, 
    -0.13628873f, 0.05358913f, -0.02359518f, 0.06536788f, -0.00862439f, 0.08503517f, -0.08566046f, -0.02198971f, 
    0.12265324f, 0.18993072f, 0.03967961f, -0.02393366f, 0.00281543f, -0.04609572f, -0.05120203f, 0.07483655f, 
    -0.05306616f, 0.04278419f, 0.00692593f, -0.00864312f, 0.01733859f, 0.20454852f, 0.15791349f, -0.19605696f, 
    0.00365854f, 0.00239216f, -0.17442957f, -0.01025819f, -0.02976853f, -0.06720114f, -0.02274723f, -0.00690448f, 
    0.11866750f, -0.01383882f, 0.03158101f, 0.04141071f, -0.01678957f, 0.02247905f, 0.01173504f, -0.00814739f, 
    0.02182390f, -0.03471943f, 0.00331775f, 0.00299307f, -0.26169530f, 0.22144800f, 0.10871179f, 0.06808700f, 
    0.04505694f, 0.06369825f, -0.07091264f, 0.08885721f, -0.07382260f, 0.05245430f, 0.02959569f, 0.09144706f, 
    0.01405674f, -0.14756984f, 0.15674384f, -0.07269032f, 0.07159441f, 0.07312115f, 0.08503068f, 0.00228897f, 
    -0.03756542f, 0.06113569f, -0.09248255f, -0.03916745f, -0.03148000f, -0.20342061f, 0.01756375f, -0.06750561f, 
    -0.04654259f, -0.02615484f, 0.05650073f, 0.04282409f, -0.01394952f, -0.03310544f, 0.06195947f, -0.05268354f, 
    -0.07275706f, 0.19856104f, 0.17364050f, 0.14865910f, 0.06246725f, -0.00399787f, 0.07710962f, -0.03499231f, 
    0.04882910f, -0.02306359f, -0.10037359f, 0.09601319f, 0.12039395f, 0.16697650f, -0.05846673f, 0.21143579f, 
    -0.02149889f, -0.07758250f, -0.05282784f, -0.02528094f, -0.03444307f, 0.06886093f, -0.00875691f, 0.04316645f, 
    0.02836709f, 0.03420152f, -0.15318501f, 0.08343107f, 0.04603697f, 0.11382893f, -0.06094168f, 0.07475335f, 
    0.02496316f, -0.05421644f, -0.01082950f, -0.14120202f, -0.16954644f, -0.18222791f, 0.13072406f, 0.06827930f, 
    0.02959890f, -0.01241259f, 0.07948805f, 0.02786866f, -0.01784453f, -0.07339654f, 0.07318667f, -0.06034005f, 
    0.09716425f, 0.08093727f, 0.11790139f, 0.05533870f, 0.06828294f, 0.00441009f, 0.07181839f, -0.09816811f, 
    0.02896108f, 0.04065307f, 0.00618380f, -0.06483810f, -0.12349335f, -0.06387643f, 0.13072608f, 0.00401770f, 
    -0.02989248f, 0.07967295f, -0.01756245f, 0.04622062f, -0.00692101f, -0.00158138f, -0.01120641f, -0.00563994f, 
    -0.22231732f, -0.11241545f, 0.00696817f, 0.18437476f, 0.10696919f, -0.03573183f, 0.01404587f, 0.01127062f, 
    -0.09709175f, 0.11326642f, -0.01242327f, -0.09607100f, -0.58167779f, -0.13193741f, 0.24352401f, 0.07396185f, 
    -0.01300844f, 0.07834321f, 0.01512301f, -0.08999003f, -0.06333600f, 0.03536588f, -0.06804803f, -0.09170815f, 
    -0.31366071f, -0.18742329f, -0.38755187f, -0.15038158f, -0.12586433f, 0.04601002f, 0.01560627f, 0.02127800f, 
    -0.05748965f, 0.09370186f, -0.03347519f, 0.07117720f, -0.15788221f, -0.26048553f, -0.10705629f, 0.13791490f, 
    -0.05545670f, 0.05452221f, -0.02958103f, -0.06038028f, -0.09086283f, -0.10049336f, -0.04270684f, -0.08297457f, 
    -0.02852034f, -0.11812337f, 0.01674192f, -0.12577766f, -0.04039259f, 0.09799634f, -0.01732750f, 0.04540641f, 
    -0.02555393f, 0.04792806f, -0.02463218f, -0.01179966f, 0.00558313f, -0.30071324f, -0.13101493f, 0.02304397f, 
    0.02052093f, 0.08700123f, 0.07224115f, -0.05745316f, -0.07078880f, 0.01767202f, -0.00374078f, 0.06960858f, 
    0.00054827f, 0.02379177f, -0.10078754f, -0.03093777f, 0.00662080f, -0.03836580f, 0.01851989f, 0.00883420f, 
    -0.00498282f, -0.00508258f, -0.10766176f, -0.00900318f, 0.33355135f, 0.10465986f, -0.16954686f, 0.22460186f, 
    -0.10348282f, -0.00860105f, -0.06657301f, 0.03273261f, -0.03347396f, -0.02653877f, -0.10010484f, 0.04698651f, 
    0.09027310f, 0.05733854f, -0.09268276f, 0.20060425f, -0.00861455f, 0.11456329f, 0.02228604f, -0.11159639f, 
    -0.07228427f, 0.03974935f, 0.02324483f, 0.02306398f, 0.67092216f, 0.01423301f, -0.04643847f, 0.07757532f, 
    -0.02160602f, -0.10143106f, -0.07328029f, -0.06454260f, -0.06734771f, -0.07878579f, -0.03845554f, 0.05740775f, 
    0.14139771f, 0.08931150f, 0.11025716f, 0.09640194f, -0.06548560f, -0.03834626f, 0.02696334f, 0.06109866f, 
    -0.07702831f, -0.06051507f, 0.06079519f, -0.03827666f, -0.05603718f, 0.03630468f, -0.12872417f, -0.08578519f, 
    -0.04732980f, 0.01704400f, -0.03034565f, 0.08190658f, -0.10573315f, -0.01035637f, 0.04667624f, -0.03105920f, 
    -0.15814640f, 0.08842952f, -0.06735876f, -0.12142378f, -0.10011005f, 0.01116565f, -0.02967729f, 0.02913248f, 
    -0.00090327f, -0.11510935f, -0.07287643f, 0.05621035f, 0.05025563f, -0.14115557f, 0.06808306f, 0.10953148f, 
    -0.01575267f, 0.10438709f, 0.05063620f, -0.06239097f, -0.02254347f, -0.03324235f, -0.04662988f, -0.03071388f, 
    -0.22428431f, 0.09232534f, -0.07578932f, 0.07935310f, -0.06957223f, -0.13114816f, 0.10004451f, -0.08981507f, 
    -0.01932511f, -0.01249530f, 0.08953110f, -0.03500715f, 0.23808677f, 0.13756777f, 0.08178888f, -0.00868289f, 
    -0.06338121f, 0.07702875f, 0.00657701f, 0.04360582f, 0.02377996f, 0.09547796f, 0.01383893f, -0.02177761f, 
    0.11632505f, -0.11266335f, -0.08806972f, -0.02329907f, 0.02529699f, 0.05350659f, -0.00309349f, -0.07197057f, 
    0.13879554f, -0.00501508f, 0.11886993f, 0.05725165f, -0.78411049f, -0.12001017f, -0.23515539f, 0.04906601f, 
    -0.13285545f, 0.03471009f, 0.00015845f, -0.05045649f, -0.11779243f, -0.01994661f, 0.13549064f, 0.00565778f, 
    0.17543648f, 0.00178107f, -0.21367264f, 0.13956274f, 0.03556100f, -0.08904465f, 0.05300352f, 0.00185081f, 
    -0.00655419f, -0.03109243f, -0.01666816f, 0.04184336f, 0.30847710f, 0.06580444f, -0.12149818f, -0.04909715f, 
    -0.04264073f, -0.11089911f, 0.01161705f, 0.03248450f, -0.13984965f, 0.04700294f, -0.06447756f, -0.00856874f, 
    -0.13930602f, 0.04101432f, 0.10140791f, 0.09848917f, -0.00634883f, 0.06657872f, -0.00877677f, -0.06744041f, 
    0.01507882f, 0.04388772f, 0.09563536f, 0.06396534f, 0.00528971f, -0.10846167f, 0.06509162f, -0.11484920f, 
    -0.03223082f, -0.03815473f, -0.04866844f, 0.01175767f, -0.00772707f, 0.00572231f, -0.04865340f, -0.03198800f, 
    -0.06475763f, 0.00028833f, 0.01705517f, 0.05942009f, -0.05578500f, -0.05114816f, 0.10223454f, 0.03866311f, 
    0.00322491f, -0.03793111f, 0.03205617f, -0.00325177f, -0.29336134f, 0.05165675f, 0.12490177f, 0.19558446f, 
    -0.01494875f, 0.06403142f, 0.06951457f, 0.01023719f, -0.08583768f, 0.00875202f, 0.06733375f, 0.05274750f, 
    0.04981128f, 0.02382563f, -0.14217623f, 0.03884482f, 0.15812288f, 0.03274247f, 0.12538090f, 0.02764619f, 
    -0.03520493f, 0.00584099f, 0.02060345f, 0.04750961f, -0.08970080f, 0.05984837f, -0.15765612f, -0.17858459f, 
    -0.00919685f, 0.08434665f, -0.04543594f, -0.04145941f, 0.07896136f, -0.02163529f, -0.08539344f, -0.04829845f, 
    -0.04842593f, -0.00395764f, 0.05327147f, 0.12354060f, 0.03742225f, 0.07518952f, 0.13115266f, 0.05961544f, 
    -0.01064725f, 0.01286366f, 0.06869096f, -0.04366967f, 0.02777209f, -0.01341262f, 0.16228797f, 0.08431761f, 
    -0.00386105f, -0.00593689f, -0.05034187f, 0.01950727f, 0.09667133f, -0.02409818f, 0.08639622f, 0.09619670f, 
    0.21951106f, 0.19331343f, 0.01071817f, 0.00392494f, 0.00284692f, -0.05650540f, 0.07866950f, -0.01935521f, 
    -0.00412671f, -0.03565037f, 0.01331989f, 0.03349535f, -0.31146482f, -0.05031092f, -0.06655729f, 0.17975888f, 
    0.02003603f, 0.03854807f, -0.02281071f, 0.09379601f, -0.03727624f, 0.02666275f, -0.02671910f, -0.06081396f, 
    -0.23596711f, -0.03047366f, 0.06105079f, 0.07820361f, -0.00597594f, -0.02589711f, 0.04457259f, -0.16770294f, 
    -0.05969581f, -0.12811553f, -0.03336821f, 0.01108197f, -0.17301711f, 0.11892345f, -0.11775560f, -0.17837837f, 
    0.00265204f, 0.18247126f, 0.05558225f, -0.07224911f, -0.01746463f, 0.04602979f, 0.02742201f, 0.17457435f, 
    -0.09354135f, 0.12991804f, -0.02526039f, -0.26596475f, 0.13468538f, -0.10016494f, -0.05180985f, -0.05731116f, 
    -0.00120123f, 0.07428187f, -0.06125293f, -0.05262275f, 0.04697580f, -0.21413720f, -0.10758576f, 0.05619448f, 
    -0.11192612f, 0.06095459f, -0.06021938f, 0.04894463f, -0.01159662f, 0.00190235f, -0.12428338f, 0.05830471f, 
    -0.22809358f, -0.18897334f, 0.06620169f, 0.08918042f, 0.06728813f, 0.02195262f, -0.11461625f, -0.03580640f, 
    0.05009712f, -0.10700697f, -0.07483467f, 0.12522936f, -0.18418416f, -0.36198670f, 0.13582279f, 0.14639410f, 
    -0.02729820f, -0.01174311f, -0.00867228f, -0.11892965f, 0.09821643f, -0.01762905f, -0.10967202f, -0.15390141f, 
    0.04232373f, -0.01459945f, 0.03991720f, -0.03314088f, 0.04361857f, 0.00412035f, 0.04216022f, -0.11355355f, 
    -0.04501958f, -0.07056531f, 0.10565237f, 0.10896414f, -0.19109462f, 0.01248618f, -0.10078646f, 0.00861468f, 
    -0.01562004f, 0.02410348f, -0.01940596f, 0.09756640f, -0.06387761f, -0.02526148f, -0.03260402f, 0.10214519f, 
    -0.10299539f, -0.02100096f, 0.01141456f, 0.08805539f, -0.03146749f, 0.02146184f, -0.03992897f, 0.09946764f, 
    -0.09810009f, -0.02212470f, 0.10411800f, -0.00570034f, 0.23773679f, -0.14672668f, -0.08854438f, 0.04346354f, 
    -0.15822783f, -0.09780685f, 0.04704834f, -0.03189641f, 0.07354314f, 0.06569779f, -0.03073993f, -0.08759537f, 
    0.10659617f, 0.32436827f, -0.23990045f, -0.16664004f, 0.01816563f, 0.01035108f, 0.00185810f, 0.04755343f, 
    -0.08501348f, -0.06136284f, -0.06240785f, -0.06006511f, 0.28308001f, 0.00762862f, -0.14853266f, 0.23307455f, 
    0.05772931f, 0.07907398f, -0.02881121f, -0.00236057f, 0.07089850f, 0.03203426f, 0.01041803f, -0.02207139f, 
    -0.00322278f, 0.10815880f, -0.09770828f, 0.00087510f, 0.00360205f, -0.00536534f, 0.00887318f, -0.01269080f, 
    -0.10478399f, 0.13046956f, 0.12393122f, 0.01582829f, -0.20532067f, 0.10957839f, 0.00804908f, -0.05467419f, 
    0.00404897f, -0.09439675f, -0.05559271f, 0.05528521f, 0.03453510f, -0.04164777f, 0.10496834f, -0.05421272f, 
    0.20822833f, -0.19988342f, -0.11509361f, 0.15531085f, -0.06157602f, 0.04581458f, 0.08295671f, -0.02248025f, 
    0.01297209f, 0.00100133f, -0.03081824f, -0.12748085f, 0.03582748f, 0.13882446f, 0.02010932f, 0.06736341f, 
    -0.00692929f, 0.04392098f, 0.05545170f, -0.01816007f, -0.04652392f, -0.10622827f, 0.10068628f, 0.00341770f, 
    0.42169207f, 0.34145287f, -0.07628413f, -0.10244445f, -0.09456747f, -0.03451764f, 0.05763926f, -0.12880725f, 
    0.02976466f, -0.05949906f, -0.03548239f, 0.04227050f, 0.11485936f, -0.11490997f, -0.10229786f, 0.04535407f, 
    -0.04938335f, -0.02509576f, 0.06228663f, 0.02359752f, -0.08829333f, -0.06642497f, 0.03400026f, 0.06257458f, 
    -0.37751970f, 0.16957703f, -0.15713899f, 0.00254602f, 0.07811242f, -0.09331751f, -0.01135408f, -0.05474655f, 
    0.04035625f, -0.02390304f, -0.09124345f, -0.08974893f, 0.01767590f, -0.29011950f, -0.03073355f, 0.23273395f, 
    0.00529802f, -0.00274185f, -0.02941996f, -0.01418217f, 0.11120711f, -0.03521869f, 0.05778379f, 0.01999949f, 
    0.01182146f, -0.10505287f, 0.03826401f, 0.12468901f, 0.02913478f, 0.02589656f, -0.07737067f, 0.00522515f, 
    0.08581913f, 0.06262602f, -0.09120914f, 0.01341715f, 0.06087935f, -0.20868635f, -0.11154310f, -0.02137777f, 
    -0.06226742f, -0.14076878f, 0.18902795f, -0.10731193f, -0.08314092f, 0.02454030f, -0.06328002f, -0.04497560f, 
    0.15055576f, -0.06114461f, 0.10174390f, -0.29708615f, 0.06315219f, 0.00445402f, -0.05391363f, 0.06102363f, 
    -0.04835223f, 0.05813470f, -0.07863472f, -0.04336705f, -0.42561376f, -0.12233154f, 0.04444816f, -0.22829366f, 
    0.02978095f, 0.11011070f, -0.01777225f, 0.12983295f, -0.05090839f, 0.05075701f, 0.06425490f, -0.14955765f, 
    0.10174938f, 0.11975409f, 0.02261443f, 0.16187640f, 0.08110052f, -0.00672563f, 0.07416843f, 0.09575773f, 
    0.11647369f, -0.08813132f, 0.06740331f, 0.03092718f, -0.10878295f, 0.04903748f, 0.12967685f, 0.06565840f, 
    0.00131787f, -0.02380608f, -0.00639898f, 0.10937862f, -0.03588724f, 0.03527250f, 0.08237925f, -0.03901571f, 
    -0.37901351f, 0.14658242f, 0.03680282f, -0.09164067f, 0.03864380f, -0.11818300f, -0.01751558f, 0.03592095f, 
    -0.03877291f, -0.00997370f, 0.02020143f, 0.17571457f, -0.73504126f, 0.02920485f, 0.15292507f, 0.18371154f, 
    0.06010739f, -0.02429276f, 0.00640607f, -0.04533869f, -0.08102578f, 0.00465004f, 0.12625603f, 0.14673859f, 
    -0.12236808f, -0.00234531f, -0.00560475f, 0.00022941f, -0.02603141f, 0.03045800f, -0.01958578f, 0.04847254f, 
    0.07927676f, -0.04407589f, 0.02309543f, -0.01774920f, -0.52587408f, 0.14453927f, -0.05190942f, -0.04526146f, 
    0.15524037f, -0.10480665f, 0.05976277f, 0.02078016f, 0.04178292f, 0.00912089f, -0.01447467f, 0.06295574f, 
    -0.09353106f, -0.24520178f, -0.10755371f, 0.04595497f, -0.18623346f, -0.07467715f, -0.05626879f, -0.15281057f, 
    -0.05216742f, 0.07392134f, -0.02571118f, -0.11579930f, -0.22518028f, 0.00263593f, 0.10561525f, 0.01276036f, 
    0.06996954f, 0.03189917f, 0.02022588f, -0.03171853f, -0.04082024f, 0.09497732f, 0.01521130f, -0.01714507f, 
    -0.03089336f, 0.00108707f, 0.13448222f, 0.04349419f, 0.01999024f, 0.07393789f, -0.05759397f, -0.06672978f, 
    0.07761623f, -0.02425767f, -0.06734445f, 0.02407577f, -0.43135491f, 0.22897673f, 0.04558330f, -0.18627322f, 
    0.07312103f, 0.03458055f, 0.01021328f, -0.04590396f, 0.00659749f, 0.01051530f, -0.00556732f, 0.01490647f, 
    -0.03374009f, 0.13833052f, 0.07922285f, -0.01092138f, 0.09078763f, 0.00214009f, -0.04912289f, -0.00020623f, 
    -0.00549148f, -0.08202815f, -0.04202341f, -0.12539555f, -0.05238850f, 0.06592079f, -0.09919107f, 0.02968713f, 
    0.02895157f, -0.09098697f, 0.02243266f, 0.02493638f, -0.03216984f, -0.11770684f, 0.00196633f, 0.03480240f, 
    -0.07835317f, -0.02182431f, 0.15657364f, -0.00391381f, -0.07230013f, -0.03045168f, 0.00137116f, 0.05101231f, 
    0.02491081f, 0.08355191f, -0.04855992f, 0.07582004f, 0.05545378f, 0.08342154f, 0.23373549f, 0.13178629f, 
    -0.02896548f, -0.02081945f, -0.01957767f, -0.01216525f, 0.04443264f, -0.05989731f, 0.01488439f, -0.11858696f, 
    -0.21618418f, -0.06989603f, 0.05809874f, 0.08615196f, 0.02772028f, -0.01586309f, 0.04690440f, -0.05010388f, 
    -0.02193308f, 0.06662834f, 0.01506553f, 0.11487260f, -0.11829755f, 0.00685012f, 0.10536447f, 0.09013300f, 
    -0.06595102f, 0.07673915f, -0.05492269f, -0.07882079f, -0.05213397f, -0.06592985f, -0.02810747f, -0.01638584f, 
    -0.08938307f, -0.07636726f, -0.04001809f, 0.22519520f, 0.02649587f, -0.07108616f, -0.03831593f, -0.01114628f, 
    -0.12305707f, -0.00775223f, 0.00893759f, -0.01955945f, -0.12702604f, 0.01177983f, 0.04794789f, -0.07191370f, 
    -0.11311729f, 0.08495153f, 0.03406427f, 0.04098104f, 0.05258223f, -0.03798263f, 0.02454282f, 0.00071933f, 
    -0.26396000f, -0.09317514f, -0.19422461f, -0.19999067f, -0.03968326f, 0.02719967f, 0.08014779f, -0.11465125f, 
    -0.09126417f, -0.10133781f, -0.04578368f, -0.11434417f, 0.38172773f, 0.26289192f, -0.34105480f, -0.07691947f, 
    -0.01960774f, -0.09369041f, -0.03118038f, 0.17584960f, -0.01829544f, -0.01639617f, -0.04401261f, 0.10017731f, 
    -0.11886860f, -0.11723603f, 0.00120459f, 0.14197791f, 0.04480130f, 0.02912920f, 0.02484777f, 0.07592017f, 
    -0.04104897f, 0.02050767f, -0.00771121f, 0.04630603f, 0.27210292f, 0.16657028f, -0.02960819f, -0.36019239f, 
    0.07174863f, -0.10727356f, 0.04193381f, -0.01992955f, 0.06937514f, -0.13808948f, 0.00888529f, 0.08222745f, 
    -0.10830899f, 0.02281551f, 0.10469577f, 0.18208842f, 0.01259389f, -0.05810698f, 0.06633731f, 0.09559371f, 
    -0.06225950f, 0.07310676f, -0.01473111f, 0.01035922f, -0.06403187f, -0.01482545f, -0.05871321f, 0.00064902f, 
    0.03373532f, 0.04238810f, -0.01641789f, 0.00943553f, 0.15870579f, -0.12301602f, -0.04762622f, -0.05624146f, 
    0.08167005f, -0.13539658f, -0.30058080f, -0.09744666f, -0.00353261f, 0.08609806f, 0.12350862f, 0.00010968f, 
    0.05761261f, -0.05010789f, 0.05894432f, -0.03099662f, -0.08525519f, -0.03895696f, -0.05577291f, 0.05480086f, 
    0.00959187f, -0.03570856f, 0.07122391f, 0.01338450f, 0.00474578f, 0.02320180f, 0.00891689f, -0.06121669f, 
    -0.00590263f, 0.11134524f, -0.08042666f, 0.01288306f, -0.06274676f, 0.01585860f, 0.00143970f, -0.00485582f, 
    -0.05749372f, -0.01185146f, 0.01012938f, 0.11202449f, -0.58012420f, 0.05251554f, 0.15857244f, 0.13549350f, 
    -0.01699894f, 0.05946109f, 0.01735516f, 0.02846026f, 0.15155311f, 0.03464328f, 0.01354610f, -0.09629443f, 
    -0.14430383f, -0.04159216f, 0.07784425f, -0.01965674f, -0.15828344f, 0.02350728f, -0.03876213f, -0.05058963f, 
    0.03419923f, -0.15403475f, -0.08514148f, 0.04378612f, 0.02675605f, 0.00501189f, -0.08657783f, -0.16728681f, 
    0.03412455f, -0.06127068f, -0.18466569f, 0.05765057f, 0.01993340f, -0.05034283f, 0.01018068f, 0.03739739f, 
    -0.21219155f, 0.09197288f, 0.05301309f, 0.14771497f, -0.01968976f, -0.01709187f, 0.02831755f, 0.05348732f, 
    -0.02203618f, 0.18750152f, 0.00497238f, 0.03399177f, 0.23609103f, 0.14746761f, -0.09522697f, 0.02480889f, 
    0.04292778f, 0.05897857f, -0.08135812f, 0.17594221f, -0.06501143f, -0.03375842f, -0.04701061f, 0.01359792f, 
    -0.51597792f, -0.16106644f, -0.07375792f, -0.11690143f, 0.18892290f, 0.04953856f, -0.05831753f, 0.08789527f, 
    0.05052840f, 0.08496699f, -0.13359235f, 0.07429560f, -0.07417310f, -0.04334069f, -0.22487831f, -0.11165953f, 
    0.13114329f, 0.02335536f, -0.03071684f, -0.15683000f, 0.01251617f, -0.03317863f, -0.02591265f, 0.05727217f, 
    -0.23876485f, -0.15529197f, -0.04518436f, -0.01637590f, -0.03001610f, 0.08055604f, -0.09624734f, -0.06289801f, 
    -0.01685436f, -0.04952955f, -0.00282392f, 0.13272361f, -0.31481460f, -0.27483958f, -0.07275199f, -0.05634272f, 
    0.04613639f, -0.00954610f, 0.13317487f, -0.16747729f, -0.09081702f, -0.00340571f, -0.03892839f, 0.11613407f, 
    -0.15432878f, -0.22936654f, -0.07843854f, 0.10682546f, 0.09412230f, 0.07044739f, -0.07659923f, 0.00979034f, 
    -0.01905221f, -0.05579161f, -0.03948508f, 0.01451534f, 0.03783719f, 0.07865406f, 0.07515582f, 0.14702091f, 
    -0.06032299f, -0.05520175f, 0.10063237f, 0.03783729f, -0.07526934f, -0.00855889f, -0.00515903f, -0.09890193f, 
    -0.07180791f, 0.04225650f, 0.01610758f, -0.06100805f, 0.01342752f, -0.00199098f, -0.01533778f, -0.10063353f, 
    0.13125043f, -0.00423296f, -0.05993197f, 0.05049255f, -0.05726366f, 0.02639662f, -0.30702007f, -0.07281984f, 
    0.11657496f, 0.13266702f, 0.11966527f, 0.09108834f, -0.07307292f, -0.11819465f, 0.14154693f, -0.22880818f, 
    0.08000771f, -0.14143650f, 0.03255158f, -0.22400820f, 0.04161303f, -0.06336613f, 0.03534795f, 0.12150031f, 
    -0.23319107f, 0.00436960f, 0.14963332f, 0.05490785f, -0.13401961f, 0.22296406f, 0.09410457f, -0.14085288f, 
    -0.04953499f, -0.04681744f, -0.06177862f, -0.07028030f, 0.04351778f, -0.09860162f, -0.05505463f, -0.26988357f, 
    -0.13123915f, -0.07283970f, 0.19249238f, 0.27269319f, 0.01654571f, 0.02922139f, 0.01481029f, 0.06472033f, 
    -0.07736519f, 0.04020954f, -0.06468873f, 0.09800027f, -0.01825293f, 0.03837534f, -0.02480042f, -0.11217956f, 
    0.06425947f, -0.05393686f, 0.03991790f, -0.14316326f, -0.06100876f, -0.02669674f, -0.11019050f, 0.00736193f, 
    0.07102996f, 0.04329146f, 0.01165282f, 0.07249925f, -0.01186831f, -0.12399803f, 0.12161448f, 0.14492394f, 
    -0.00576593f, -0.01826828f, 0.02476687f, 0.03056734f, 0.12912114f, 0.07256941f, -0.08561014f, -0.03277681f, 
    -0.10513775f, -0.03674759f, -0.04643387f, 0.06734919f, 0.00689839f, 0.00641921f, 0.05464733f, -0.01188156f, 
    0.07745864f, -0.04325045f, -0.07532848f, 0.16611755f, 0.07140324f, 0.06595798f, 0.05006618f, 0.10304692f, 
    0.01082642f, -0.08125103f, -0.01805601f, -0.00522395f, 0.07356800f, -0.01533553f, 0.15905671f, 0.05349871f, 
    0.08299065f, 0.05212815f, 0.01675540f, -0.06379880f, -0.01248028f, 0.05011832f, 0.06565197f, 0.01295939f, 
    0.04655799f, -0.08997614f, 0.00866216f, 0.15200685f, -0.21744730f, -0.04704881f, 0.05252002f, -0.10723270f, 
    -0.20069908f, -0.16764326f, 0.14541218f, 0.08819168f, 0.01062087f, -0.03031138f, 0.16116729f, -0.19199170f, 
    0.01007419f, -0.04996549f, -0.05509128f, -0.07541174f, -0.04266774f, 0.00084005f, 0.13803965f, 0.06838475f, 
    -0.38704753f, 0.17336881f, 0.05035014f, 0.01153763f, -0.01161723f, -0.02821149f, -0.14239495f, -0.02387602f, 
    0.10519010f, 0.09694078f, 0.12537441f, 0.03250204f, -0.19037572f, -0.31267881f, 0.00085244f, -0.00616777f, 
    0.08796135f, 0.03949644f, -0.02091835f, -0.23807928f, -0.04256757f, 0.01846057f, -0.14588571f, 0.12523223f, 
    -0.15436691f, -0.13278027f, 0.13866688f, 0.16002256f, 0.02677379f, -0.02540144f, 0.04600361f, 0.06283478f, 
    0.16499804f, 0.09145005f, -0.12798120f, 0.16754560f, 0.02020672f, 0.09738442f, 0.21108967f, 0.29861072f, 
    -0.10882948f, 0.13420665f, 0.14494534f, -0.02711099f, -0.03208917f, 0.01927694f, -0.02827914f, 0.15015115f, 
    0.13426065f, -0.07892589f, 0.02665533f, -0.08315513f, 0.03922019f, -0.06196450f, -0.09221921f, -0.02447285f, 
    0.06806245f, 0.00063592f, 0.05125568f, -0.02621059f, -0.19147961f, -0.14028600f, 0.05697908f, -0.04383184f, 
    0.15621412f, -0.05937306f, -0.09859776f, 0.09155953f, 0.11649509f, 0.23097835f, 0.03517133f, -0.03987182f, 
    -0.06429531f, -0.25298855f, 0.06135483f, 0.40005624f, -0.09256943f, -0.14325979f, -0.03083132f, 0.07913474f, 
    0.10553508f, 0.14306448f, -0.11257668f, -0.06465531f, 0.05014678f, 0.08095120f, 0.09250745f, -0.20833318f, 
    -0.08119401f, 0.03531735f, -0.06406385f, 0.04624218f, 0.06558971f, -0.04566862f, -0.04000250f, 0.05245181f, 
    -0.26627260f, 0.22412103f, 0.05721360f, -0.19467229f, 0.04240434f, 0.10909281f, -0.12769157f, 0.01778450f, 
    -0.02467796f, -0.05511758f, -0.12815675f, -0.07310655f, 0.36315036f, 0.13487604f, 0.02309329f, -0.15574020f, 
    0.04186456f, -0.11327310f, -0.14743972f, -0.16580358f, -0.06068663f, 0.12668796f, -0.07235634f, -0.04655646f, 
    -0.00963971f, 0.02169592f, 0.04879062f, 0.04011854f, -0.18029074f, -0.02175804f, 0.00492418f, 0.00697910f, 
    0.12937905f, -0.05621774f, 0.11131837f, 0.12020551f, -0.05291374f, 0.08921464f, -0.05245071f, -0.00370528f, 
    0.19390030f, 0.15898488f, -0.00430641f, -0.04954419f, 0.08578031f, -0.04037782f, 0.10177120f, -0.00924076f, 
    -0.21832509f, 0.00920827f, 0.08846054f, 0.28638408f, -0.00281481f, -0.03871782f, 0.10110015f, 0.01211399f, 
    -0.01906406f, 0.00469597f, -0.03704441f, 0.04934816f, -0.06958786f, 0.13549048f, -0.11819512f, -0.03620370f, 
    0.03996757f, -0.17306666f, 0.00011905f, 0.13879970f, 0.04793750f, -0.07364091f, 0.02289399f, -0.20445389f, 
    -0.04431336f, -0.08017799f, -0.09697352f, 0.09564492f, 0.11143485f, -0.10626502f, -0.09369723f, -0.00851118f, 
    0.05874363f, 0.17047401f, -0.00372111f, -0.04026954f, 0.09449028f, 0.00109577f, -0.15623482f, -0.00811150f, 
    -0.00488101f, -0.10806128f, -0.03761370f, 0.00145917f, 0.07646921f, -0.03745703f, -0.02814640f, -0.10131799f, 
    -0.17897213f, 0.10069960f, -0.04831678f, -0.13290726f, 0.05240374f, 0.05188147f, -0.09562758f, -0.07247685f, 
    -0.06477343f, -0.23366915f, 0.02844397f, -0.29806471f, 0.01197152f, 0.28333417f, -0.27148604f, -0.11479722f, 
    0.08717582f, 0.10387419f, -0.05484473f, 0.06230421f, 0.06556683f, 0.02894131f, -0.06614842f, -0.09510395f, 
    0.07662187f, -0.07116356f, -0.11140401f, -0.14086524f, 0.09457125f, -0.01627805f, -0.02302874f, -0.02948859f, 
    -0.03148670f, 0.09480362f, 0.06854013f, 0.08099547f, -0.39458641f, -0.02750982f, 0.00489455f, -0.20088336f, 
    -0.00632315f, 0.01168315f, 0.02499841f, 0.08779220f, -0.11228950f, 0.02238831f, 0.02943715f, 0.00964095f, 
    0.01696810f, 0.09049194f, 0.17128934f, 0.08758086f, -0.10576607f, -0.13960658f, -0.03734684f, -0.00302845f, 
    0.02950376f, -0.07435814f, -0.05850420f, 0.11114016f, 0.05934371f, -0.06035114f, 0.20257606f, 0.15159705f, 
    -0.03190072f, -0.04666300f, 0.05939037f, 0.03503221f, -0.00497099f, 0.04618640f, 0.05389138f, 0.18424696f, 
    0.07008397f, -0.04543935f, -0.05521087f, 0.04605265f, -0.00358726f, -0.04180511f, -0.01422105f, -0.14299539f, 
    0.03015725f, 0.02585718f, 0.18518591f, 0.17356046f, -0.31333336f, 0.04249340f, 0.02211998f, 0.07046782f, 
    -0.00603896f, 0.02639285f, -0.07574427f, -0.05608109f, 0.05101390f, -0.22588424f, 0.03943856f, 0.04244960f, 
    0.05870048f, -0.05130260f, 0.12335585f, -0.14050195f, -0.17405021f, -0.00182102f, 0.08743349f, 0.03684685f, 
    -0.00678455f, 0.16585526f, 0.04904970f, 0.16019455f, -0.04690015f, 0.08029992f, 0.16598497f, -0.25876734f, 
    -0.00857083f, -0.03887619f, 0.04282000f, -0.01124217f, -0.00147399f, -0.01187532f, 0.04284844f, 0.03005042f, 
    0.01308813f, -0.04407226f, 0.01503746f, 0.04349462f, 0.05593434f, -0.09657805f, -0.09117272f, -0.04591018f, 
    -0.02148912f, -0.08495784f, 0.06871889f, -0.16934618f, 0.01835570f, 0.05129260f, -0.13353842f, 0.09847850f, 
    0.01774820f, 0.05369971f, 0.03011001f, -0.00862812f, 0.10904031f, 0.10126789f, -0.01914821f, 0.16108656f, 
    0.22735406f, -0.14743942f, 0.03543255f, 0.00377360f, -0.00613448f, 0.00807981f, -0.08269487f, -0.07327849f, 
    -0.03306327f, -0.05496031f, 0.04947562f, -0.08518151f, -0.08519077f, 0.00109401f, -0.16264264f, -0.02262607f, 
    -0.05695968f, -0.02761403f, 0.05685593f, 0.06821502f, 0.09879284f, 0.10308578f, 0.16814719f, -0.11232635f, 
    -0.06176697f, -0.23537262f, -0.13066347f, 0.01486849f, 0.05781524f, 0.14624634f, -0.08813383f, 0.01985216f, 
    0.08526310f, -0.00546179f, 0.14080581f, -0.13570595f, -0.06215198f, 0.11754206f, -0.11618601f, 0.05294920f, 
    0.00914554f, 0.08193582f, -0.06028579f, -0.11845692f, -0.08047599f, -0.14045803f, 0.02353760f, 0.04405094f, 
    -0.15284248f, -0.01697325f, 0.01931240f, 0.13760506f, -0.13809592f, -0.05691780f, -0.01403912f, 0.20275235f, 
    0.27894676f, -0.01155006f, -0.04679430f, 0.00783286f, -0.10255495f, -0.30637547f, 0.15155812f, 0.00930376f, 
    0.10067953f, 0.03800302f, 0.06008357f, -0.03622251f, -0.02497785f, -0.08181591f, -0.01085671f, -0.04235034f, 
    0.01820467f, -0.17459755f, 0.06851546f, -0.01544837f, -0.01132527f, -0.03171463f, -0.09113616f, -0.01106948f, 
    0.13305184f, -0.03711336f, -0.00193180f, -0.03330754f, 0.03622517f, -0.17122532f, 0.19103843f, 0.09969707f, 
    0.04778719f, 0.04686855f, -0.07987821f, 0.07931729f, 0.06683791f, 0.10898605f, 0.03160108f, -0.07400645f, 
    -0.31837645f, -0.01199711f, -0.11459646f, -0.07957333f, 0.04065978f, 0.00988527f, -0.11431952f, -0.26184362f, 
    0.09604140f, -0.12963980f, 0.07990365f, 0.00585133f, -0.05610000f, 0.07534395f, 0.04159546f, 0.06737313f, 
    -0.02665928f, -0.02387304f, 0.00261467f, -0.11009329f, 0.03840512f, 0.04839792f, 0.12926763f, 0.11515454f, 
    -0.21215241f, 0.20971648f, 0.27357668f, -0.45492753f, -0.02563505f, 0.02253179f, 0.10586096f, 0.01594754f, 
    -0.06287318f, 0.13683645f, -0.14167628f, -0.09789570f, -0.03784290f, 0.02490714f, 0.11939255f, 0.31537303f, 
    0.00796520f, 0.00365031f, 0.01772242f, -0.00141539f, -0.07948980f, -0.17393565f, -0.03217212f, -0.01916397f, 
    -0.04228201f, 0.04575390f, -0.03628737f, 0.03055594f, 0.01718651f, -0.01348892f, -0.03302166f, -0.01961370f, 
    -0.05826850f, -0.10410726f, -0.02451518f, 0.01588437f, -0.05178895f, -0.09326685f, 0.05931582f, 0.04273273f, 
    -0.08319716f, -0.00249313f, -0.06344753f, -0.03243171f, -0.01760814f, -0.05589466f, 0.07434025f, -0.01897296f, 
    -0.04033214f, 0.00330496f, 0.11328089f, -0.01693701f, -0.07333858f, 0.06310056f, -0.00549031f, 0.07945776f, 
    -0.02707997f, -0.11256529f, 0.02911544f, -0.02613608f, 0.06081228f, 0.16002148f, 0.13577084f, -0.11045791f, 
    -0.00412770f, 0.16958694f, 0.07973375f, -0.07620802f, 0.14064668f, -0.02072350f, -0.22610462f, 0.04281106f, 
    0.14506000f, -0.01009378f, 0.03350537f, -0.06654903f, -0.09612299f, -0.03369664f, 0.03518284f, -0.00830850f, 
    -0.09610138f, -0.16596465f, -0.02491735f, -0.00144513f, 0.07787660f, 0.12616272f, 0.02637281f, 0.09405145f, 
    0.04811435f, 0.07400355f, 0.09221338f, -0.18556064f, 0.02602327f, -0.14941780f, 0.07346030f, -0.06976857f, 
    -0.46700692f, -0.13240020f, 0.07494963f, -0.01801299f, 0.06278834f, -0.01097143f, 0.12185860f, -0.04791924f, 
    0.06626917f, -0.15578984f, 0.06441725f, 0.01339458f, -0.23382236f, -0.18679519f, -0.15907107f, -0.15665700f, 
    0.03697157f, 0.01870152f, 0.00052436f, 0.03727311f, 0.03872754f, 0.02450629f, -0.00157958f, 0.02144236f, 
    -0.18797266f, -0.02762335f, 0.16312739f, -0.06516293f, 0.00054009f, 0.00583026f, -0.01569165f, 0.01511372f, 
    0.04856655f, 0.06305411f, 0.03558330f, 0.10040296f, -0.10339228f, -0.23592511f, 0.10908915f, 0.01131258f, 
    0.04107232f, -0.06024664f, 0.08834561f, 0.01519236f, -0.02296896f, 0.05668729f, -0.06149712f, 0.04232931f, 
    -0.16002566f, -0.07223595f, -0.29794514f, 0.08830713f, -0.02100170f, -0.09391757f, -0.11507364f, -0.15589832f, 
    -0.03284268f, 0.04112160f, 0.00433959f, -0.23238358f, -0.04376620f, -0.09366622f, -0.08631522f, -0.13009541f, 
    -0.07333747f, -0.02946867f, 0.00073995f, -0.02243627f, 0.02060594f, 0.03277994f, -0.03714890f, 0.02479169f, 
    -0.22248533f, 0.13828857f, 0.10113772f, -0.20498395f, 0.02536166f, -0.00357630f, 0.03875056f, 0.01912992f, 
    -0.03960332f, 0.06717476f, 0.05732408f, -0.02299553f, 0.00667315f, 0.04602866f, 0.05351397f, -0.38901407f, 
    -0.19854359f, 0.01699912f, -0.05634357f, -0.12804624f, -0.13688329f, 0.13255271f, -0.02848798f, 0.22863466f, 
    0.12319113f, 0.12936190f, 0.06592724f, -0.23607607f, -0.08310408f, 0.11098056f, 0.02314363f, -0.16230097f, 
    0.11151218f, -0.17511426f, -0.12410782f, 0.01786604f, 0.21611026f, -0.33006197f, 0.03864033f, 0.02573637f, 
    0.03769197f, -0.01529500f, -0.09323991f, -0.01019995f, -0.02583527f, 0.00595019f, 0.08999003f, 0.10409757f, 
    0.07050776f, -0.06876172f, -0.11518479f, 0.02881064f, -0.06748649f, -0.08236800f, -0.03839688f, 0.04676677f, 
    -0.02637280f, -0.05188818f, -0.01013295f, 0.00413860f, -0.15032479f, 0.09280514f, 0.05172496f, -0.02870031f, 
    -0.15697414f, 0.01150492f, -0.04310245f, 0.08233690f, 0.05486588f, 0.02575789f, 0.11705132f, -0.02506923f, 
    0.07487315f, 0.06468412f, -0.00865536f, -0.10570922f, 0.02312157f, 0.02932478f, -0.03088014f, -0.01940020f, 
    -0.00295125f, -0.07399826f, -0.05858039f, 0.00756028f, -0.01840642f, 0.08496594f, 0.04469436f, -0.13723595f, 
    0.08427776f, 0.09344351f, 0.00355148f, 0.03891724f, 0.00617611f, -0.08805607f, -0.08045117f, 0.02315577f, 
    -0.13163544f, -0.16412820f, 0.02796174f, 0.01836641f, 0.08381115f, -0.06842393f, 0.11844866f, -0.08235843f, 
    0.06930476f, 0.03276045f, -0.05358818f, 0.17369439f, 0.13483714f, 0.01123703f, 0.11544687f, -0.14255315f, 
    -0.27519789f, -0.05219126f, 0.11457372f, 0.02524469f, 0.08339863f, 0.04598811f, -0.00142014f, 0.00863940f, 
    0.17717111f, 0.15423109f, -0.01063969f, 0.09106736f, 0.02165417f, -0.01860931f, 0.06633580f, 0.01170907f, 
    -0.02433804f, 0.01163326f, -0.23814501f, 0.06808729f, -0.33948189f, 0.22648868f, 0.09094806f, 0.04808357f, 
    -0.01011663f, 0.01345301f, 0.04829016f, 0.04537215f, -0.02360681f, -0.08458977f, -0.07888189f, 0.02511769f, 
    0.31744927f, -0.06292526f, -0.02957128f, -0.28944862f, -0.11902370f, 0.02323066f, 0.05581496f, 0.03862630f, 
    0.00815512f, -0.09793324f, -0.06813024f, -0.11454835f, -0.38510749f, -0.01949191f, -0.08881258f, -0.25429845f, 
    0.00782236f, 0.07615054f, -0.01255491f, 0.04576176f, 0.06266788f, 0.01394269f, 0.08868540f, 0.03756785f, 
    -0.00575062f, 0.02119464f, -0.33510783f, 0.05839678f, -0.02498158f, 0.06017995f, -0.09441953f, -0.05126494f, 
    0.01747841f, -0.00802317f, 0.02418832f, -0.02086159f, -0.12231342f, -0.06441899f, -0.13995302f, 0.10611856f, 
    0.06302151f, -0.10387677f, -0.04659470f, 0.06466089f, 0.01642586f, 0.00212325f, -0.00724196f, -0.14055060f, 
    -0.13215782f, -0.12782229f, -0.03422161f, 0.03596300f, -0.03745389f, 0.09364274f, 0.03330423f, 0.01678041f, 
    0.03840523f, -0.15176794f, 0.07701678f, 0.02701233f, 0.08088914f, -0.00819886f, -0.11069047f, 0.10150547f, 
    -0.01303395f, 0.01298149f, 0.04930394f, 0.04699171f, 0.05130496f, -0.07614977f, -0.00413185f, 0.01181233f, 
    0.01241665f, -0.17015351f, -0.02699107f, 0.09755458f, -0.03115013f, 0.01575902f, -0.01592135f, -0.03284619f, 
    -0.04308359f, -0.04871494f, -0.04805801f, 0.07238313f, -0.13125688f, 0.07495947f, 0.14096451f, -0.06806607f, 
    -0.05501387f, -0.12052624f, 0.04270255f, 0.10207249f, 0.01567465f, -0.10509662f, 0.08645417f, 0.06531470f, 
    0.58843607f, -0.05715881f, 0.18571156f, -0.21399423f, -0.07238060f, 0.03872738f, 0.00363935f, 0.08260075f, 
    0.07714733f, 0.05487389f, 0.12470885f, -0.07316390f, -0.60128874f, 0.01064195f, -0.18386278f, 0.10407253f, 
    -0.01943619f, 0.08844811f, 0.03991691f, 0.19272910f, -0.03362322f, -0.07407133f, 0.03895708f, -0.12354111f, 
    -0.02217451f, 0.00244181f, -0.12600367f, -0.04870025f, 0.02287050f, 0.08102721f, 0.00777516f, -0.09805883f, 
    -0.05587767f, 0.02548794f, -0.19896698f, -0.10015777f, -0.15678844f, -0.00435927f, -0.24546367f, 0.44072157f, 
    -0.02612488f, -0.11426797f, -0.00997839f, 0.09925135f, 0.06958736f, -0.07851230f, -0.02420617f, -0.12479318f, 
    0.20820062f, -0.00561274f, -0.18207993f, -0.02162780f, -0.09426107f, 0.00908835f, -0.04219699f, -0.20806596f, 
    -0.03223136f, -0.02385408f, -0.05518709f, -0.09569201f, 0.34031805f, -0.06030022f, 0.03721163f, -0.15532376f, 
    -0.02404469f, -0.00182900f, 0.01070660f, -0.11812434f, -0.06836200f, 0.04742390f, 0.00432024f, -0.04666006f, 
    -0.09036599f, -0.03738200f, -0.09473843f, -0.20197889f, -0.07163695f, -0.04436403f, -0.01086915f, -0.00302543f, 
    -0.13415593f, -0.13042592f, -0.00148005f, 0.09035758f, -0.09561027f, -0.07243396f, 0.13088991f, -0.04983674f, 
    -0.00631055f, -0.02116478f, 0.02663582f, -0.02478760f, -0.04874036f, -0.00768061f, 0.14701483f, 0.13131218f, 
    0.00434423f, -0.38682178f, 0.00410471f, 0.03262359f, -0.01974549f, 0.07487509f, 0.04195825f, 0.02205775f, 
    0.08348072f, 0.09928516f, 0.08562202f, 0.33532894f, 0.10613445f, -0.35769385f, -0.01165789f, -0.07533697f, 
    0.03210907f, 0.02324662f, -0.04096498f, -0.02155968f, -0.09057887f, -0.02352344f, 0.05483249f, 0.10958093f, 
    0.03516892f, -0.05259270f, -0.01889029f, 0.02596336f, -0.01447102f, 0.11033876f, -0.07453211f, -0.08059118f, 
    0.09314047f, -0.14880167f, -0.13991189f, 0.03153177f, 0.30814055f, -0.22449252f, 0.03477319f, -0.03518298f, 
    0.05996179f, 0.08740377f, -0.04894276f, -0.10537109f, 0.15656230f, -0.05273839f, 0.01584585f, 0.04895394f, 
    -0.14559311f, 0.18055801f, -0.00838135f, -0.07745624f, 0.01489194f, 0.10497507f, 0.00021594f, 0.11938302f, 
    -0.02502526f, -0.07532219f, 0.00331189f, -0.17310798f, 0.10671592f, 0.15615626f, 0.14936146f, -0.07634437f, 
    -0.10169514f, -0.11623911f, 0.06576950f, 0.16546154f, 0.06667725f, -0.05763306f, -0.05254773f, -0.21136609f, 
    0.04184632f, -0.00110595f, -0.05769862f, -0.06628246f, -0.02292442f, 0.05351389f, -0.06782414f, 0.10899743f, 
    -0.09968612f, 0.07699048f, -0.06831284f, -0.06624094f, 0.41587031f, -0.02427061f, -0.03376412f, -0.16952369f, 
    -0.06341156f, -0.07008758f, 0.07706971f, 0.01738744f, 0.00058361f, 0.13018377f, 0.00342021f, -0.06419361f, 
    0.31245920f, 0.00378490f, -0.01495348f, -0.16736709f, 0.03553231f, 0.04386009f, -0.07105713f, -0.09711839f, 
    0.04104934f, -0.18296427f, 0.04062723f, -0.05470761f, 0.35002410f, -0.16234079f, 0.19767952f, -0.02178469f, 
    0.00880660f, -0.02284851f, 0.10349495f, 0.09296739f, -0.02908030f, 0.03442707f, 0.01484810f, -0.00998656f, 
    -0.46567333f, 0.22743151f, 0.14567298f, 0.26216444f, -0.08164278f, -0.04094662f, -0.05484090f, -0.00978882f, 
    -0.02050325f, 0.02053647f, 0.05463771f, 0.12997402f, 0.01430881f, 0.14955680f, 0.03490315f, -0.31605908f, 
    -0.01678901f, 0.00285843f, -0.04757424f, 0.02177241f, -0.07182045f, -0.07878258f, 0.05136333f, -0.05227946f, 
    -0.31986466f, 0.04680894f, -0.01405598f, -0.01189598f, -0.03516923f, -0.05010761f, 0.13247186f, 0.02610890f, 
    0.02492361f, 0.06291072f, -0.03377669f, 0.06664570f, -0.23683576f, -0.06078523f, -0.04379535f, -0.02955746f, 
    0.02890733f, 0.00005647f, -0.01472102f, -0.15672860f, 0.09523301f, -0.09246217f, 0.04629188f, 0.04625609f, 
    -0.13871448f, 0.03127373f, 0.00454291f, -0.14752512f, -0.17772906f, -0.00754388f, 0.00728269f, -0.16266561f, 
    -0.05721964f, 0.02856203f, -0.11054459f, 0.05610358f, 0.10779086f, 0.01647878f, 0.03127207f, 0.28034204f, 
    -0.04119859f, -0.00062644f, 0.05183578f, 0.02540316f, 0.09099030f, 0.14416459f, -0.16946915f, 0.04133540f, 
    0.14899227f, 0.10167184f, -0.06094722f, 0.02302795f, -0.04006691f, -0.02829328f, -0.06932782f, -0.17253703f, 
    -0.26753557f, 0.01330731f, 0.07841176f, -0.03575149f, -0.10162136f, -0.18510157f, -0.10565238f, 0.06538374f, 
    -0.01018672f, 0.04242379f, 0.03990955f, 0.07114073f, 0.10605852f, 0.06945904f, 0.00805624f, 0.13427919f, 
    0.13671032f, -0.09589041f, -0.24698779f, 0.09033892f, -0.09775149f, 0.03323553f, -0.06827927f, 0.08735278f, 
    0.11097409f, -0.04210041f, 0.04534692f, 0.14115945f, 0.03015455f, 0.06660113f, 0.10038221f, 0.18480060f, 
    -0.07236977f, -0.06869654f, 0.06727360f, -0.09084272f, 0.06415562f, -0.11891432f, -0.05286182f, 0.01163574f, 
    0.09637751f, -0.16522752f, -0.19164076f, 0.09483248f, -0.12641619f, 0.11067279f, 0.00186957f, 0.03129357f, 
    -0.05222073f, 0.09788037f, -0.10063657f, 0.05775543f, 0.11294563f, 0.06316449f, 0.14634265f, -0.23274913f, 
    0.02223991f, 0.09550095f, 0.01261243f, 0.02232359f, -0.13123901f, -0.02317772f, -0.08037055f, -0.11071599f, 
    0.09494610f, -0.26172513f, -0.01299076f, 0.01577966f, -0.01204851f, 0.03821092f, -0.03585267f, 0.05568875f, 
    0.04543728f, -0.05381144f, 0.03634666f, -0.02382200f, -0.04754829f, -0.21172039f, -0.25389755f, 0.14033227f, 
    0.04283091f, 0.05954459f, -0.06891067f, -0.03217417f, -0.08443354f, 0.00191673f, 0.06990184f, -0.01557050f, 
    -0.02106165f, 0.11446239f, 0.31940046f, 0.14483349f, 0.01998295f, 0.11471000f, 0.04759505f, -0.01025119f, 
    -0.04944471f, 0.10704011f, 0.12523927f, 0.00210734f, -0.06967698f, 0.19414723f, 0.14955582f, -0.15599868f, 
    0.05839133f, 0.04791424f, 0.08021182f, 0.09593557f, -0.06604173f, 0.11141430f, 0.01864040f, 0.10620160f, 
    -0.05596251f, 0.07104915f, -0.06498189f, -0.03127179f, -0.00656557f, 0.03777058f, 0.00875605f, 0.00782232f, 
    0.09828476f, 0.07214241f, -0.10063506f, -0.05200844f, -0.02593209f, 0.00233178f, -0.05084639f, 0.01341676f, 
    -0.20120446f, 0.00219960f, 0.05173774f, 0.00802762f, -0.07036097f, -0.07537136f, 0.04587133f, -0.19766480f, 
    0.05602695f, 0.07109609f, 0.01559489f, -0.07623720f, -0.04752252f, -0.01273798f, 0.05416924f, 0.02243900f, 
    0.05857008f, 0.09614531f, 0.06347637f, 0.03130171f, -0.00602596f, -0.07682256f, 0.11714993f, 0.11791062f, 
    -0.07780007f, -0.04842587f, 0.08336329f, 0.08360057f, -0.01446286f, 0.10221907f, -0.02976602f, 0.09558608f, 
    0.11044230f, 0.07053386f, 0.19209543f, 0.04565920f, 0.05132156f, 0.01760057f, 0.01165270f, -0.00677076f, 
    -0.03475513f, -0.02353205f, 0.06696502f, 0.02333805f, 0.06320006f, 0.08907832f, 0.09274375f, 0.08772582f, 
    0.05615266f, 0.00609750f, 0.05106816f, -0.08824656f, -0.00468441f, 0.05352629f, 0.04957550f, -0.03515407f, 
    0.12079839f, -0.04869493f, 0.09692341f, 0.01043010f, -0.05778106f, -0.07112657f, -0.04355976f, -0.06534969f, 
    -0.04801892f, 0.10685518f, 0.06409668f, 0.04776958f, 0.03775404f, -0.00074092f, 0.12511136f, 0.11801819f, 
    0.06497711f, -0.00944563f, -0.00181375f, -0.01628641f, -0.07672088f, 0.02875238f, -0.05729615f, -0.01581108f, 
    0.03726214f, 0.18948774f, 0.09426004f, 0.15802099f, 0.07022288f, -0.05393528f, 0.02677687f, 0.00432023f, 
    0.01046157f, -0.00943059f, 0.01137394f, -0.07391033f, 0.03867222f, 0.02513889f, 0.06448904f, 0.17666019f, 
    -0.02894840f, -0.03554212f, -0.03573574f, -0.07964109f, -0.05772709f, -0.01341563f, 0.01801542f, 0.01548278f, 
    -0.14751628f, 0.06296308f, -0.00687104f, -0.11313798f, -0.01429135f, 0.02592854f, -0.03924507f, -0.07520173f, 
    -0.01329014f, -0.03387935f, -0.00599884f, -0.06039177f, -0.07054428f, 0.12311620f, 0.09557118f, 0.13145800f, 
    0.05974955f, 0.05309638f, 0.02215272f, -0.01633896f, -0.05745387f, 0.07318105f, -0.01198318f, -0.01015034f, 
    -0.00360978f, 0.13742910f, -0.18855985f, 0.00064701f, -0.06838975f, 0.02131691f, -0.06270254f, -0.05949232f, 
    -0.05186689f, -0.05395479f, 0.04215201f, -0.03803391f, -0.01315297f, 0.05923546f, 0.17823721f, -0.12847444f, 
    0.02186411f, 0.00822904f, -0.05933943f, -0.04587623f, -0.02590481f, 0.01907588f, 0.05057028f, 0.01848441f, 
    -0.01891407f, -0.05766229f, 0.04718028f, 0.17577416f, 0.06639627f, -0.02333833f, 0.00911706f, 0.00370029f, 
    -0.02496597f, -0.05633773f, -0.06634332f, -0.00708071f, -0.15031238f, 0.13938323f, -0.08967864f, -0.04556091f, 
    0.05083504f, 0.04841357f, -0.02659884f, -0.02784358f, -0.04527635f, -0.01472188f, 0.02543346f, -0.08087571f, 
    -0.05161257f, -0.05356924f, -0.21963868f, 0.05706653f, -0.10270365f, -0.04300969f, -0.07769967f, -0.09952610f, 
    -0.06908344f, -0.04078760f, 0.01585929f, -0.04735112f, 0.12269714f, -0.04266609f, -0.09695573f, -0.12946241f, 
    0.01215826f, -0.11337222f, -0.02840748f, -0.07957254f, -0.06996703f, -0.04807413f, 0.04615991f, -0.00514648f, 
    0.12585232f, 0.13291997f, 0.01845874f, 0.11116786f, -0.02484451f, 0.09741746f, -0.03216173f, -0.01445464f, 
    -0.07159832f, 0.01461204f, -0.01070880f, -0.09475999f, -0.26266813f, 0.07356093f, -0.14558157f, -0.16573291f, 
    0.02527233f, -0.02127766f, -0.02940958f, -0.08338661f, -0.08238927f, 0.00484242f, -0.04013586f, -0.06098650f, 
    -0.07804011f, -0.04919210f, -0.01052409f, 0.11269973f, -0.04762862f, -0.03907391f, -0.07295348f, 0.00650904f, 
    -0.10884298f, 0.01097294f, 0.04540163f, -0.10693360f, -0.12273005f, 0.08757366f, 0.07122099f, 0.05516147f, 
    0.08949525f, 0.01181785f, -0.04545802f, -0.01410151f, -0.04606811f, -0.00326215f, -0.08888397f, -0.05050201f, 
    -0.14626969f, 0.07788123f, 0.02916784f, -0.01336129f, -0.04796479f, 0.02274055f, 0.03243129f, -0.05783188f, 
    -0.06012883f, 0.03948285f, -0.09868172f, -0.11772792f, 0.03221428f, 0.12808064f, 0.12119506f, 0.12963684f, 
    0.10439325f, -0.03272894f, 0.03444332f, 0.02122559f, -0.03885941f, 0.03785168f, -0.01042213f, -0.10647766f, 
    -0.04554236f, 0.02088548f, -0.03596673f, 0.02758443f, -0.08492800f, 0.02383651f, -0.12358538f, -0.02636848f, 
    0.00372104f, -0.05175986f, -0.00467996f, 0.00837628f, -0.20388487f, -0.07605203f, -0.01502702f, -0.04431160f, 
    0.05991198f, -0.06451377f, 0.03163627f, -0.04262869f, -0.00716154f, 0.04246952f, -0.08765857f, 0.03769267f, 
    0.06325644f, 0.12609021f, -0.08638079f, 0.16417003f, -0.02193286f, 0.02832469f, -0.12790035f, -0.00348241f, 
    -0.04798383f, -0.01024242f, 0.00213512f, -0.10582522f, -0.14877746f, 0.09869830f, 0.01663215f, 0.06624722f, 
    -0.13066979f, -0.00595032f, -0.11299828f, -0.01843106f, 0.01972425f, -0.08332225f, -0.01332173f, -0.09342671f, 
    0.11549035f, -0.27695218f, 0.18822385f, 0.00716582f, 0.11104631f, -0.00828114f, -0.03702874f, -0.11560993f, 
    -0.01042559f, -0.08743660f, -0.08616068f, -0.04297750f, -0.13520369f, 0.04467190f, -0.03511952f, -0.04668324f, 
    -0.05476467f, 0.02385309f, -0.03566862f, -0.13434142f, 0.00751142f, 0.02412114f, -0.08654544f, -0.08188158f, 
    0.19635147f, 0.09184676f, 0.00346679f, -0.14052449f, -0.15051320f, 0.03590874f, -0.01019569f, 0.02756466f, 
    -0.04183786f, 0.03354048f, -0.03506064f, -0.03630442f, 0.04374413f, 0.06462452f, -0.13209671f, -0.07410764f, 
    0.00008880f, 0.03883556f, -0.01627449f, -0.05261356f, -0.00800909f, 0.02462210f, -0.00025567f, 0.04764887f, 
    -0.09437646f, 0.03134106f, -0.00949961f, 0.01137437f, -0.01586512f, 0.03009380f, -0.05362386f, -0.07552413f, 
    -0.00319975f, 0.04522993f, -0.01765858f, 0.00081127f, 0.07482308f, 0.10155115f, -0.07284363f, 0.21154656f, 
    0.12362476f, -0.03321008f, -0.06757019f, -0.05522433f, 0.07152702f, -0.03181518f, 0.05517561f, -0.03731370f, 
    0.15101072f, 0.04203486f, 0.10408666f, 0.17159210f, 0.04310408f, -0.02822800f, -0.00313789f, -0.05844623f, 
    -0.03839246f, 0.01548117f, -0.07329696f, -0.05455177f, 0.31691396f, -0.03005412f, 0.09706426f, 0.01980183f, 
    0.04903727f, -0.03748999f, -0.01821955f, -0.01269126f, 0.05374968f, 0.00463335f, -0.00900224f, -0.00537611f, 
    0.05820116f, 0.13691436f, 0.05670693f, 0.09574621f, 0.05511340f, 0.02663628f, -0.09437391f, 0.00198433f, 
    0.03014412f, -0.01653933f, -0.02104115f, -0.08437525f, 0.20317933f, -0.20681787f, -0.00261502f, -0.10766964f, 
    0.05706397f, -0.05019719f, -0.07691593f, -0.07756934f, -0.04364007f, 0.06615832f, 0.03454697f, -0.06100751f, 
    0.13617541f, -0.11867005f, 0.06261452f, 0.03482228f, -0.01574376f, 0.02375644f, -0.01090670f, 0.00360049f, 
    -0.04141541f, 0.06192461f, -0.02894951f, -0.09757908f, 0.13587721f, 0.13607395f, 0.18160342f, 0.03895966f, 
    -0.00083812f, 0.01364875f, 0.03121278f, 0.05908687f, -0.11339669f, 0.07301724f, -0.00492499f, -0.01757364f, 
    0.09234640f, -0.21201591f, 0.08010391f, 0.13117330f, 0.02685779f, -0.03514139f, 0.00508306f, -0.05318090f, 
    -0.04186445f, 0.01547360f, -0.12568386f, -0.07466130f, 0.00416502f, -0.09061591f, 0.14868078f, 0.00231525f, 
    -0.00883538f, 0.02991104f, 0.04299444f, 0.03022976f, 0.02131290f, -0.00281174f, -0.00020030f, 0.11770386f, 
    -0.25050032f, -0.04762870f, -0.12748477f, 0.05772199f, -0.02165087f, -0.04158873f, -0.17741136f, -0.03171466f, 
    -0.03981240f, -0.00291138f, 0.03849481f, -0.07400187f, -0.12673286f, -0.13312683f, 0.09736079f, 0.10802819f, 
    -0.06256380f, -0.06405839f, 0.02726259f, -0.02228999f, 0.03984100f, 0.01776491f, -0.01719073f, -0.06381670f, 
    -0.02742876f, -0.04631041f, -0.00610927f, 0.05143599f, -0.03068219f, -0.03984407f, -0.07673034f, -0.07123148f, 
    -0.02097528f, 0.01811823f, -0.04037591f, -0.02921219f, 0.01858947f, 0.04266118f, -0.05641183f, -0.02716113f, 
    -0.14653999f, -0.02070594f, -0.04480330f, -0.02995173f, -0.05231008f, 0.02891766f, -0.11807911f, -0.01748758f, 
    -0.13251415f, -0.12274004f, -0.00838337f, -0.09327421f, -0.03190358f, -0.06668705f, 0.01051275f, -0.07564263f, 
    -0.03919665f, -0.01306648f, 0.00517379f, 0.03209842f, 0.14129210f, -0.13789676f, -0.10936056f, -0.05874308f, 
    -0.06826127f, 0.00299323f, -0.01169393f, -0.07690693f, -0.02402249f, -0.07756962f, 0.00479229f, 0.00878042f, 
    -0.21485595f, -0.17014669f, -0.12466860f, -0.15856968f, 0.07539323f, 0.01013316f, 0.01470930f, -0.07215130f, 
    0.00461414f, -0.04382635f, 0.00166225f, -0.08568759f, -0.17541637f, -0.00119121f, -0.20064306f, -0.12412180f, 
    -0.04311804f, -0.03662181f, -0.01917164f, -0.10100165f, -0.05536868f, -0.03642378f, 0.00696308f, 0.00006091f, 
    0.09779598f, 0.02857638f, -0.17388214f, -0.13616566f, -0.06845083f, -0.00560394f, -0.05118985f, -0.06233195f, 
    -0.07947674f, 0.00515497f, 0.02226082f, -0.06129290f, 0.03488540f, 0.06876967f, 0.13033383f, 0.03237189f, 
    -0.13609043f, 0.02728930f, -0.00496398f, -0.06781008f, 0.05810136f, 0.12247809f, -0.04976870f, -0.00768536f, 
    0.22648212f, 0.18453753f, -0.01217058f, 0.15347259f, 0.06385403f, 0.03711197f, -0.00012553f, -0.00753492f, 
    -0.09562609f, -0.00844880f, -0.01697099f, -0.05072113f, -0.30826086f, 0.02026838f, -0.02102519f, 0.09233491f, 
    -0.00537911f, -0.05026919f, 0.05463751f, 0.03545315f, -0.00034261f, 0.12729023f, -0.03108177f, -0.00478359f, 
    0.02493379f, 0.07372015f, -0.11831808f, 0.04587421f, 0.01351518f, -0.00408524f, -0.04107603f, -0.00995464f, 
    -0.02736715f, -0.03947847f, 0.05627572f, -0.03351709f, -0.09564780f, 0.23720121f, -0.14484103f, 0.05580642f, 
    0.02514427f, -0.03765890f, 0.08086891f, -0.09172291f, 0.06230208f, -0.00141865f, 0.09408981f, 0.04867456f, 
    -0.00675869f, 0.09816618f, -0.22371735f, 0.14458199f, -0.06797965f, -0.03166949f, -0.03291196f, 0.00656999f, 
    0.05105214f, -0.01487826f, -0.05463225f, -0.01313096f, 0.14292145f, 0.11080460f, 0.03180565f, 0.10405037f, 
    -0.00509574f, -0.00383988f, 0.02002233f, -0.12110536f, -0.03772778f, -0.00470075f, 0.05739947f, -0.02392144f, 
    -0.03161907f, 0.14829542f, -0.00591357f, 0.16034931f, 0.14032274f, -0.03407619f, -0.00249526f, 0.05538814f, 
    0.00515156f, 0.04244195f, 0.01321227f, -0.03748569f, 0.00180269f, -0.03542909f, -0.14041650f, -0.05954120f, 
    -0.02198025f, 0.02835326f, -0.02083588f, -0.03116629f, -0.07946029f, -0.01195977f, 0.02665277f, -0.08631705f, 
    -0.12597345f, -0.07603574f, 0.07827289f, -0.16212521f, -0.00198863f, -0.01890914f, -0.02363176f, -0.00493308f, 
    0.03826477f, 0.03010567f, 0.04180104f, -0.08980351f, 0.01952922f, 0.04929869f, 0.04194986f, 0.15884967f, 
    -0.00336612f, -0.10148050f, -0.12587628f, 0.00158294f, -0.01836891f, -0.05362301f, -0.01363756f, 0.00567932f, 
    -0.00553361f, 0.09767178f, -0.07704821f, -0.05747773f, -0.08486243f, 0.00656399f, -0.00207628f, -0.04016782f, 
    -0.06895431f, 0.02010806f, -0.00631991f, -0.04820704f, 0.06708985f, -0.26611656f, -0.04392903f, -0.16214311f, 
    0.06286721f, -0.00999022f, -0.01396863f, 0.02804843f, -0.03481135f, -0.09082308f, -0.00232674f, -0.01846813f, 
    -0.36175355f, 0.11656353f, -0.08328549f, -0.05955112f, 0.01430455f, -0.08111478f, -0.06780513f, -0.03940716f, 
    -0.03533171f, 0.07090639f, -0.00793123f, -0.06731316f, -0.07006241f, 0.10738988f, 0.17913136f, -0.06291278f, 
    0.10565018f, 0.00439186f, 0.08717006f, -0.02492733f, -0.07884232f, 0.05620201f, 0.05916052f, 0.04206619f, 
    -0.15794995f, -0.25417802f, -0.12422159f, -0.07103819f, -0.03273131f, -0.05136450f, 0.00803676f, -0.01835130f, 
    0.00454644f, 0.04065516f, -0.02023247f, -0.07831477f, 0.00244730f, -0.07846772f, -0.00683987f, -0.04980199f, 
    -0.05661337f, 0.02820674f, -0.05700732f, -0.08880426f, -0.00139485f, 0.03859895f, 0.02090330f, 0.03170657f, 
    -0.10840277f, 0.16982262f, 0.03947109f, -0.04017474f, -0.05002194f, 0.00277456f, -0.07269522f, -0.05132852f, 
    -0.02520934f, 0.05766146f, -0.13788086f, -0.06082429f, -0.03704919f, 0.06662183f, 0.10069294f, 0.17196329f, 
    -0.16178568f, -0.08979223f, -0.01008087f, -0.03949614f, 0.00844499f, -0.01413819f, -0.05899511f, -0.01296373f, 
    -0.07965161f, 0.16476552f, 0.00241552f, -0.10481455f, 0.01735011f, 0.02249884f, -0.01680318f, 0.02821218f, 
    -0.04939640f, -0.05946281f, 0.13081011f, 0.07680938f, -0.28119054f, 0.00058713f, 0.14992583f, -0.11469194f, 
    -0.02827867f, -0.03596559f, 0.00731505f, -0.01660767f, -0.04447823f, -0.06621308f, 0.02744284f, 0.08596471f, 
    -0.05236015f, 0.23106802f, -0.09516694f, -0.11142083f, 0.08819953f, 0.07038735f, -0.06290284f, -0.01840132f, 
    0.06808811f, -0.00088954f, 0.00016273f, 0.04414902f, -0.08597688f, -0.09384977f, -0.07076917f, -0.23490326f, 
    -0.01645251f, 0.06842221f, 0.05962654f, -0.09473657f, 0.11086380f, 0.01259257f, -0.10151707f, 0.01930064f, 
    0.17870834f, -0.04760331f, 0.07078045f, 0.14872977f, 0.03915863f, 0.02671786f, -0.02050973f, -0.08567827f, 
    -0.01010244f, -0.00018281f, 0.06954556f, 0.04761473f, -0.11879227f, -0.05735383f, 0.24625848f, 0.05913218f, 
    0.02899126f, -0.02282759f, 0.06943868f, 0.02417064f, 0.07282624f, -0.04421189f, -0.05282101f, -0.20772383f, 
    0.03647304f, -0.25879559f, 0.08242683f, 0.09091328f, 0.06276856f, -0.00795571f, 0.03140605f, 0.01971311f, 
    -0.06748050f, 0.12727046f, 0.03124434f, -0.09633150f, -0.00506753f, -0.18285404f, 0.08044766f, 0.02072565f, 
    -0.04390788f, -0.05548338f, -0.04693232f, -0.05646926f, 0.11268799f, -0.00909799f, -0.08289890f, -0.09082961f, 
    0.19416302f, 0.04015413f, -0.28595519f, -0.02910556f, 0.07922228f, -0.11609035f, -0.02552865f, 0.01921219f, 
    0.01215069f, -0.02113624f, 0.04071961f, 0.08115345f, 0.00652919f, -0.02834091f, 0.00128793f, 0.02636592f, 
    0.04329518f, -0.02300314f, -0.02782148f, 0.04671609f, -0.02002949f, 0.00863098f, -0.10493832f, -0.00444457f, 
    -0.02668776f, 0.00273561f, -0.13460678f, -0.14475694f, -0.12321868f, -0.02018170f, 0.04729512f, -0.06568474f, 
    0.09416369f, 0.03820200f, 0.04911389f, -0.03358475f, -0.06797995f, -0.19381435f, -0.06403898f, -0.17866708f, 
    0.09511620f, -0.02167554f, 0.00835626f, 0.07975276f, 0.11245243f, 0.05525754f, 0.02990275f, -0.00641251f, 
    -0.18669674f, -0.14077610f, -0.08840426f, -0.29233685f, 0.07218671f, 0.01801393f, 0.00373395f, 0.04518910f, 
    0.11987828f, -0.02566925f, 0.02737379f, -0.09200318f, 0.02385087f, 0.05085555f, 0.04332737f, 0.11163974f, 
    0.06242916f, 0.03454540f, 0.00635799f, -0.03501140f, 0.10919006f, -0.04465819f, 0.08378924f, -0.11550300f, 
    -0.12103003f, -0.01876011f, -0.21670513f, -0.18133195f, 0.09370624f, 0.03758759f, -0.07480431f, -0.01174391f, 
    0.01455305f, 0.04679809f, 0.12565295f, -0.12165427f, -0.06809609f, 0.12916055f, -0.15939538f, 0.14349096f, 
    0.06037974f, -0.04922859f, -0.03262748f, -0.04531621f, -0.07518330f, 0.05662468f, 0.03485035f, -0.01599907f, 
    -0.04647537f, 0.02955507f, 0.23767108f, 0.14960891f, -0.07985298f, -0.12650968f, -0.01672624f, -0.18169774f, 
    0.05397657f, 0.02073115f, 0.14055043f, 0.04264398f, -0.20899385f, 0.16365686f, 0.18428849f, -0.00444185f, 
    -0.01960592f, -0.11933980f, 0.05574550f, 0.02969861f, 0.05016726f, -0.09277351f, 0.03345382f, 0.09565428f, 
    0.06156263f, 0.21308601f, -0.11598071f, -0.16564561f, 0.07956025f, 0.06297338f, 0.01098536f, -0.13641113f, 
    0.07501520f, 0.00179512f, 0.04632339f, 0.03278217f, 0.10830094f, 0.11084987f, -0.22207421f, 0.10224858f, 
    0.10678457f, 0.08480146f, -0.06992211f, -0.01245952f, 0.06741479f, -0.07673926f, 0.12087832f, 0.00601310f, 
    -0.21228641f, 0.17210692f, -0.13826026f, -0.07493594f, -0.14688523f, -0.00566227f, -0.14165212f, 0.01313622f, 
    0.06460854f, 0.06869038f, 0.02521532f, -0.20578595f, -0.16493583f, 0.07222853f, 0.09184484f, -0.21425992f, 
    -0.06187118f, -0.17970625f, -0.09994739f, -0.00882381f, 0.00697372f, 0.03675979f, -0.02800732f, 0.07241336f, 
    0.14674117f, -0.06349151f, 0.03616891f, -0.04907680f, 0.05988626f, -0.04628258f, -0.11172308f, -0.02578458f, 
    0.02076461f, -0.05409666f, -0.07062335f, -0.02835005f, 0.27752140f, 0.03973361f, 0.03808668f, 0.14449476f, 
    0.06431208f, -0.02073222f, -0.01545881f, -0.07895667f, 0.02556968f, -0.01389733f, -0.08866432f, -0.09448718f, 
    -0.16832209f, 0.17685890f, -0.11767276f, -0.02893487f, 0.02141245f, -0.09177361f, 0.11810211f, -0.07496791f, 
    0.01875653f, 0.01536471f, -0.02103455f, 0.04158848f, -0.00067230f, 0.19262953f, -0.11860437f, 0.05786064f, 
    -0.08042432f, -0.05825409f, -0.12493391f, -0.05379960f, 0.00058181f, 0.02549125f, -0.10067374f, -0.03873101f, 
    -0.04273809f, 0.09068485f, -0.06425060f, -0.15359779f, -0.12956975f, -0.04053272f, 0.03319467f, -0.03055146f, 
    0.03890930f, 0.05351932f, 0.01343590f, 0.11768375f, -0.08088993f, 0.33747271f, -0.16873693f, -0.08137450f, 
    0.05752776f, -0.03683786f, -0.22182229f, 0.10228410f, -0.00227004f, 0.02273709f, -0.05832912f, 0.06830495f, 
    -0.06341218f, -0.07937325f, 0.04564387f, -0.20824413f, -0.04276530f, 0.00290932f, 0.09838645f, -0.00634654f, 
    0.01795544f, -0.01233168f, 0.01154758f, 0.07543319f, 0.06301045f, -0.22003242f, 0.05881060f, -0.17994423f, 
    0.00341385f, -0.08632307f, -0.05235540f, 0.11145186f, 0.06514174f, 0.02621267f, 0.07332800f, 0.06886510f, 
    -0.24629988f, 0.05697278f, -0.13937414f, -0.24635549f, -0.09738503f, -0.10939861f, -0.09149729f, 0.05695368f, 
    0.05413180f, 0.05573375f, -0.01873636f, 0.01584746f, 0.09727217f, -0.06843776f, 0.03118995f, -0.05979354f, 
    0.00392250f, -0.09967860f, -0.01712619f, -0.13580148f, 0.00308723f, -0.12162086f, -0.14168392f, -0.00722711f, 
    0.13990252f, -0.16107407f, 0.13726488f, -0.01968017f, -0.07854937f, 0.02187040f, -0.04932629f, -0.04840047f, 
    0.04173111f, -0.08268889f, -0.06697354f, -0.09357925f, -0.04463599f, 0.04590911f, 0.01897932f, -0.05111129f, 
    -0.12273356f, -0.10281478f, 0.02012224f, 0.03416220f, -0.01291429f, 0.04484027f, -0.11230844f, -0.02574307f, 
    -0.10417696f, -0.10873837f, 0.13937365f, -0.16975944f, -0.05308053f, -0.02698132f, -0.08054643f, -0.11164933f, 
    0.00713734f, -0.00918919f, 0.07171853f, 0.00638864f, -0.14604458f, 0.04959860f, -0.00457612f, 0.03777596f, 
    0.01643693f, 0.04035437f, 0.06393120f, -0.15359701f, -0.02993171f, -0.09265094f, -0.02696471f, -0.01035996f, 
    -0.06042123f, 0.09627832f, -0.20189357f, -0.04126481f, 0.06463391f, 0.04725446f, -0.03264103f, 0.09450971f, 
    -0.04641474f, 0.05943715f, -0.06841894f, 0.14710690f, -0.04323706f, -0.25814062f, -0.01487138f, 0.02749019f, 
    0.05934246f, -0.07269323f, 0.00279596f, -0.04018316f, -0.00935076f, 0.07798871f, -0.01289440f, 0.07295601f, 
    -0.14037608f, -0.26421818f, -0.03714870f, -0.19340037f, -0.09491163f, -0.09053586f, -0.00369670f, -0.02217909f, 
    -0.04194127f, 0.03274238f, 0.09889860f, -0.04386799f, 0.01523660f, -0.02522446f, -0.03447168f, -0.05535389f, 
    0.06381484f, -0.06321645f, 0.00409728f, -0.07835665f, -0.04067325f, -0.08845836f, 0.08087724f, 0.04938630f, 
    -0.09691154f, -0.14768156f, 0.09591933f, 0.10296546f, 0.03326272f, -0.01787591f, -0.02012669f, -0.00674001f, 
    0.05591979f, 0.00336428f, -0.01922266f, 0.09079746f, 0.18455775f, -0.04066820f, 0.01860750f, 0.16316180f, 
    0.07240240f, -0.06820618f, -0.05980789f, -0.06525386f, 0.02669318f, -0.02518426f, 0.03657161f, -0.02535013f, 
    0.12083235f, -0.05391429f, -0.08004277f, 0.01891791f, 0.12387646f, 0.09305220f, 0.01425136f, -0.02444843f, 
    0.08663891f, -0.03249061f, -0.03238948f, -0.01185786f, -0.26159444f, -0.00642117f, 0.04425521f, 0.19843136f, 
    -0.00414377f, 0.09246481f, 0.01475050f, -0.04600882f, 0.05188937f, 0.08516607f, 0.01828762f, 0.09692687f, 
    0.05951088f, 0.04932853f, 0.04021898f, 0.00763133f, -0.05648311f, 0.05195589f, 0.00386150f, 0.07103449f, 
    0.04814151f, -0.00024269f, 0.00288168f, -0.03440641f, 0.05886591f, 0.23076943f, -0.09010029f, 0.14561598f, 
    -0.09081904f, 0.00539447f, 0.01564228f, 0.07080332f, -0.05376564f, 0.05808468f, 0.03013722f, 0.02038566f, 
    -0.25239173f, 0.00804942f, 0.18168353f, -0.10423169f, -0.11457451f, 0.07745940f, -0.03390890f, 0.06594122f, 
    -0.02396425f, -0.05502130f, 0.06235802f, -0.11943276f, 0.12134401f, 0.14313076f, -0.20390691f, -0.04966757f, 
    0.07510556f, -0.00805916f, -0.12077998f, -0.01622156f, 0.03019603f, -0.12082858f, 0.09897241f, 0.12723933f, 
    -0.13235788f, 0.17951852f, 0.12078031f, -0.04090902f, -0.03144877f, 0.04894600f, -0.01260304f, 0.03585732f, 
    0.06034801f, 0.02435820f, -0.04054141f, -0.08254128f, -0.18122804f, -0.12008698f, -0.04068612f, 0.00269950f, 
    -0.03062045f, 0.00121926f, -0.08403648f, -0.02804774f, 0.06531318f, -0.11401220f, 0.03323096f, -0.10133658f, 
    -0.05348688f, 0.20015839f, -0.22576326f, -0.16805397f, 0.00441614f, -0.03324102f, -0.03878034f, -0.08024575f, 
    -0.00401645f, 0.03316985f, -0.13493749f, -0.05043435f, 0.15685920f, -0.07461155f, -0.09130744f, -0.26259211f, 
    0.02109722f, 0.00902164f, -0.09914756f, 0.04776651f, 0.05325978f, 0.07856685f, 0.01353408f, -0.07090409f, 
    0.01870632f, -0.07346737f, 0.02016344f, -0.03805788f, -0.14700648f, -0.12718129f, -0.01920479f, -0.07377589f, 
    0.01001967f, -0.12615788f, 0.06915220f, 0.04088718f, 0.01320367f, -0.00345217f, 0.06721269f, 0.06498010f, 
    0.03788267f, -0.00544072f, 0.02363556f, -0.05802714f, 0.00745632f, 0.10950176f, 0.06797102f, 0.05842150f, 
    -0.02341706f, -0.01941035f, -0.00877242f, 0.19312806f, -0.04866024f, -0.13743187f, 0.01406023f, 0.02841472f, 
    0.03470265f, 0.03090400f, -0.15932612f, -0.03360163f, -0.03824004f, 0.17205994f, -0.35683528f, -0.29140580f, 
    -0.04670454f, -0.06134189f, -0.09371129f, -0.05448325f, 0.01079927f, -0.03283539f, 0.03448449f, -0.01711397f, 
    0.07769908f, -0.13849086f, 0.03193513f, -0.03412756f, -0.04702966f, -0.16190979f, -0.00344054f, 0.00718097f, 
    0.11116707f, -0.13516910f, -0.01511063f, -0.11558028f, 0.10965379f, -0.08830194f, -0.34755775f, 0.15776929f, 
    0.13176621f, 0.01116070f, -0.02998378f, -0.02500558f, 0.07196977f, 0.07474060f, 0.01645775f, -0.04945566f, 
    0.09065286f, 0.07914010f, -0.09641356f, 0.06381911f, 0.07845216f, 0.00985711f, -0.03274123f, 0.06593399f, 
    0.04647217f, -0.06823308f, 0.10465896f, 0.03054599f, -0.09650774f, -0.16521548f, 0.06778952f, -0.12588727f, 
    -0.02058523f, 0.05848042f, 0.04806690f, -0.05010545f, 0.05512018f, 0.09058727f, -0.07527164f, 0.06230886f, 
    -0.19181630f, -0.05274731f, -0.12228012f, 0.11587726f, 0.07282991f, -0.00276894f, 0.02406111f, 0.00101790f, 
    0.09347362f, -0.03093502f, 0.08293062f, 0.01078987f, 0.15022801f, -0.07375766f, 0.11185045f, 0.06053340f, 
    -0.06476007f, -0.13355388f, -0.09124073f, -0.11812844f, 0.00518762f, 0.01598311f, -0.01979468f, -0.06390244f, 
    0.14407583f, -0.30137816f, -0.19155981f, 0.00860168f, -0.12201581f, -0.00272383f, 0.01466532f, 0.16733234f, 
    -0.13652645f, 0.08743329f, 0.05471648f, 0.03519562f, -0.08397592f, -0.16377741f, -0.01181511f, 0.04115195f, 
    0.00967883f, -0.02991722f, -0.00933126f, 0.00336661f, 0.03697954f, -0.03228536f, 0.03433784f, -0.15409991f, 
    -0.02906569f, -0.27094772f, 0.01827415f, 0.09505150f, -0.11282300f, 0.04000326f, 0.00344936f, 0.09388970f, 
    0.05159701f, 0.04001249f, -0.01593358f, -0.05609269f, 0.44098964f, 0.01784238f, -0.18068175f, 0.12039395f, 
    0.02738193f, -0.09048668f, -0.05307109f, 0.09955175f, -0.01273251f, -0.00223884f, 0.11219058f, 0.12570816f, 
    0.02003654f, -0.11046503f, 0.07535106f, -0.03106223f, -0.06074709f, -0.08133308f, -0.05157768f, -0.00576052f, 
    -0.11959146f, 0.07811059f, -0.08173650f, 0.13900329f, -0.04917458f, -0.10611943f, -0.03545626f, -0.09370272f, 
    0.01087059f, 0.08305195f, -0.08486967f, -0.07995507f, -0.05990298f, -0.12849550f, 0.09818055f, 0.08878901f, 
    -0.34053418f, 0.08527884f, -0.04908030f, -0.05188866f, 0.11026676f, 0.11308357f, 0.03224918f, 0.01458837f, 
    -0.00283367f, -0.11866783f, -0.02056167f, -0.09550304f, -0.17259166f, -0.20883831f, 0.10645975f, -0.05005833f, 
    0.01208248f, -0.04490884f, -0.19419810f, -0.00885217f, 0.09900196f, 0.08332061f, -0.01630679f, 0.07349782f, 
    -0.19832411f, 0.14051749f, 0.00170347f, -0.10824151f, 0.00844570f, -0.09289683f, 0.05046324f, 0.10226042f, 
    0.08715078f, -0.01320096f, -0.03339327f, 0.03324134f, 0.07354674f, -0.09484684f, 0.08688933f, 0.18957700f, 
    -0.00100470f, -0.03972469f, -0.03620779f, -0.01184366f, 0.02353706f, -0.09184886f, 0.04743647f, 0.10395473f, 
    0.05737456f, -0.09013513f, -0.04737334f, -0.21955469f, 0.00031759f, -0.01753509f, -0.07342622f, 0.04762967f, 
    0.00806006f, 0.02696302f, 0.12517574f, 0.03874632f, -0.24593018f, 0.31076801f, -0.00956307f, -0.02677071f, 
    0.12352235f, 0.10680220f, 0.00370404f, -0.03855044f, 0.09929787f, -0.07816963f, 0.17299393f, 0.04087505f, 
    -0.06970966f, 0.08252059f, -0.08655508f, -0.19741221f, -0.03156321f, 0.07977645f, 0.04079651f, -0.03222024f, 
    -0.04713662f, 0.02755702f, -0.04848665f, 0.02269277f, 0.07877447f, -0.04904183f, 0.17447565f, -0.16279970f, 
    0.00215184f, -0.09860432f, 0.04258798f, -0.07835719f, -0.04066062f, 0.08059377f, 0.01016476f, -0.17681918f, 
    0.10515988f, -0.03260803f, -0.03613222f, 0.10198542f, -0.12259962f, 0.04390564f, -0.09691142f, -0.01292856f, 
    0.03242461f, 0.05342815f, 0.04742346f, 0.01736325f, -0.23758948f, 0.31357569f, -0.19895141f, -0.43515381f, 
    0.08340368f, 0.01608767f, -0.08341612f, 0.06659473f, 0.01539069f, 0.00315930f, -0.05430409f, -0.10182941f, 
    -0.03350192f, 0.03409446f, -0.01250255f, -0.27833790f, -0.02845744f, 0.04083400f, -0.03292444f, 0.06228146f, 
    0.16645218f, 0.15629035f, -0.05156266f, -0.02670731f, 0.06767754f, -0.02139460f, -0.08367848f, 0.01199209f, 
    0.08430274f, 0.04602876f, 0.02605189f, 0.03036241f, 0.00910503f, 0.01924627f, 0.12048524f, -0.05217789f, 
    0.23060270f, 0.21239151f, -0.13827658f, -0.17260049f, 0.19544654f, -0.06438206f, 0.08546183f, 0.02453586f, 
    -0.11839931f, 0.02054707f, -0.02547781f, 0.12246705f, -0.06812745f, -0.43121782f, -0.07268884f, 0.04987648f, 
    -0.05199541f, 0.00230006f, -0.07490197f, 0.16113174f, -0.10006283f, -0.06752946f, 0.02587273f, -0.02086737f, 
    -0.05809999f, 0.00842582f, 0.11919694f, 0.16877961f, -0.00396387f, 0.03623286f, -0.11326541f, -0.05389997f, 
    0.08842245f, -0.03951524f, 0.09387313f, 0.00446690f, 0.01588666f, 0.14999130f, -0.01544310f, -0.31080666f, 
    0.14019690f, 0.01260617f, 0.00269149f, 0.08512150f, -0.03647668f, 0.04905016f, -0.14959283f, -0.08349612f, 
    -0.36458641f, 0.21084976f, -0.00008537f, 0.24237531f, 0.02019510f, 0.17761025f, -0.11928815f, -0.05371388f, 
    -0.03913990f, 0.05469174f, -0.11582383f, 0.03745731f, -0.17070359f, -0.03930063f, 0.16809024f, -0.17301348f, 
    -0.02563940f, 0.00099968f, -0.01608936f, -0.01654404f, -0.05406770f, -0.16639583f, 0.03301314f, -0.05327124f, 
    0.18650247f, -0.58247256f, 0.08423966f, -0.09489046f, 0.02580083f, -0.03923355f, -0.02607931f, 0.10245053f, 
    -0.06935019f, 0.01060870f, 0.13901341f, 0.03228075f, -0.32858413f, 0.17366464f, -0.24537808f, -0.07146866f, 
    0.11825377f, 0.01932863f, -0.07393004f, -0.11671997f, 0.08548138f, -0.01049442f, -0.00850477f, -0.06405514f, 
    -0.39776814f, 0.07655101f, -0.29580814f, -0.01706507f, 0.06502463f, -0.09287801f, 0.06225072f, 0.01874992f, 
    0.02713523f, -0.00224564f, 0.18830170f, 0.08428377f, -0.04407689f, 0.31781211f, 0.12626013f, 0.00656959f, 
    -0.06733407f, 0.04465875f, 0.08915713f, 0.08767463f, -0.01064804f, -0.09470970f, 0.04102111f, 0.05205325f, 
    -0.09556217f, 0.05437096f, 0.00722811f, -0.03012801f, -0.00337518f, 0.00420937f, 0.03043798f, 0.07714872f, 
    -0.03855355f, -0.01974865f, -0.02276878f, -0.16284585f, 0.13796885f, -0.11377303f, 0.39121115f, -0.06811158f, 
    -0.05275616f, 0.04030155f, 0.04969198f, 0.10156798f, -0.01981298f, -0.00278121f, 0.03301581f, -0.07882141f, 
    -0.19486497f, -0.29389066f, -0.09993022f, 0.18150015f, -0.04751703f, -0.01694044f, -0.08149596f, -0.02676430f, 
    -0.02214406f, 0.01017650f, 0.06853563f, -0.02406744f, -0.00275521f, -0.16001810f, 0.01486380f, 0.07290458f, 
    -0.00840595f, 0.05594103f, -0.00413570f, 0.01477719f, -0.00770497f, 0.02340521f, 0.02067793f, 0.10425484f, 
    0.05254605f, -0.08410148f, -0.04253195f, 0.02863749f, -0.04794829f, 0.11201718f, -0.01840160f, 0.02009863f, 
    -0.06688281f, 0.05770261f, 0.00077809f, -0.03488971f, 0.18284218f, -0.32647961f, 0.06179050f, 0.06915223f, 
    -0.06060313f, 0.04425198f, 0.11959267f, 0.06361786f, -0.10859148f, -0.02020080f, -0.00323843f, 0.06705726f, 
    0.24155116f, -0.12461253f, -0.18228449f, -0.14728336f, 0.07865934f, -0.03967744f, 0.13531116f, -0.16925770f, 
    -0.07611863f, 0.13141079f, -0.02888116f, 0.02984355f, 0.05439761f, 0.02534194f, -0.13904448f, 0.08292967f, 
    0.08666524f, 0.03583344f, -0.04419348f, -0.01630570f, -0.05654199f, -0.04447860f, 0.00824254f, -0.01623006f, 
    0.03787863f, -0.09995424f, -0.01068557f, 0.01009190f, -0.01708291f, -0.01326205f, 0.03973597f, -0.04385542f, 
    -0.02822523f, -0.04186112f, -0.04821979f, -0.12238200f, 0.00191805f, -0.24956299f, -0.13135898f, 0.17899556f, 
    -0.02937074f, 0.02777160f, -0.16625933f, 0.03455047f, -0.03786487f, 0.03315594f, 0.02162552f, -0.09223582f, 
    0.02290183f, -0.12344608f, 0.20547654f, 0.01690613f, 0.03122791f, 0.07394001f, -0.00355915f, -0.13698679f, 
    0.06634877f, -0.03577606f, -0.06297044f, 0.00322208f, 0.10240591f, 0.01468407f, -0.14214073f, -0.22147259f, 
    -0.08038939f, 0.02065619f, -0.09660607f, 0.03042131f, 0.06384697f, -0.01762611f, 0.07145499f, -0.06582241f, 
    -0.09352707f, -0.02908301f, -0.01532228f, -0.03964804f, -0.09185518f, -0.04636699f, 0.01403658f, 0.09783246f, 
    -0.04835819f, 0.02328106f, -0.25921705f, -0.00385025f, 0.04388821f, 0.14892003f, -0.20246750f, -0.00878237f, 
    0.04565607f, -0.03451265f, 0.10503826f, -0.00637712f, -0.05168587f, 0.09337299f, 0.06525010f, 0.14116813f, 
    -0.22088461f, 0.12979804f, -0.00695601f, -0.00945488f, 0.01222321f, -0.06023156f, 0.05764769f, -0.00275464f, 
    0.03932963f, 0.13412589f, -0.08163971f, 0.04389731f, -0.03338813f, -0.02287305f, -0.18646036f, -0.12634109f, 
    0.08653658f, 0.00277064f, -0.01843858f, -0.07057434f, -0.00788573f, 0.01701292f, -0.06002711f, -0.03788984f, 
    0.13372335f, 0.03729805f, 0.09907727f, -0.13640222f, 0.07785547f, 0.18780591f, 0.05825748f, -0.10478971f, 
    -0.05367190f, -0.00009814f, -0.03248083f, 0.04918098f, -0.03109389f, 0.16659570f, -0.24061507f, -0.38840637f, 
    0.07607534f, -0.09348739f, -0.05031447f, -0.05822923f, -0.22268598f, -0.10095926f, -0.04812919f, -0.21123889f, 
    0.27727774f, 0.19194624f, 0.04012702f, 0.03373612f, -0.07624860f, -0.01105998f, 0.04063306f, 0.12346376f, 
    -0.00972278f, 0.03631694f, 0.02385296f, -0.01083882f, -0.27498171f, -0.03143446f, 0.16466311f, 0.15832303f, 
    0.11039035f, 0.02523545f, -0.03173590f, 0.06402024f, -0.09068393f, 0.18024518f, -0.06041526f, 0.05307006f, 
    -0.13033243f, -0.02527890f, 0.14186619f, -0.02815469f, 0.07571980f, -0.01263084f, -0.03536296f, 0.02835612f, 
    0.00568757f, -0.01268746f, -0.00595133f, 0.15558244f, -0.04832394f, 0.10778561f, 0.28096291f, -0.18208863f, 
    0.06827924f, 0.02273869f, -0.03996342f, 0.04251324f, -0.06777041f, 0.03112062f, -0.03131209f, -0.19416909f, 
    0.33049804f, 0.34972709f, 0.03848917f, 0.16530311f, 0.06468748f, -0.09400021f, -0.06398059f, -0.01343674f, 
    0.06381517f, 0.03349756f, 0.00875158f, 0.11335938f, -0.62310100f, 0.36449847f, -0.04490992f, -0.19125912f, 
    -0.04481481f, -0.08996663f, -0.03355569f, -0.03088944f, -0.10856206f, -0.04991143f, 0.02737245f, 0.01902688f, 
    -0.32610416f, 0.35414475f, 0.12329961f, 0.24988924f, 0.14273462f, 0.08291992f, -0.14890939f, -0.00992210f, 
    0.08288089f, 0.05636937f, 0.04245601f, 0.01404099f, -0.04988132f, -0.06291788f, 0.13991973f, 0.11021793f, 
    0.03123486f, 0.06557573f, -0.02624288f, -0.01929920f, -0.05121573f, -0.02485215f, -0.01384316f, 0.05849214f, 
    -0.10812784f, -0.29533616f, 0.09895918f, -0.12823649f, 0.05916264f, -0.02024063f, 0.06060516f, 0.10060071f, 
    0.04347054f, 0.01718037f, -0.02483814f, -0.01102119f, 0.10384609f, 0.02663951f, -0.05982559f, -0.12206878f, 
    -0.00365640f, 0.00705039f, 0.05958563f, 0.03738649f, 0.06860872f, 0.06403083f, -0.11020094f, 0.01247957f, 
    0.01332465f, 0.00408701f, -0.14535412f, 0.10889853f, 0.03550658f, 0.06873466f, 0.00841986f, 0.13437293f, 
    -0.09116460f, -0.08229760f, 0.04387990f, 0.07768010f, 0.05041412f, -0.11143524f, 0.14149654f, -0.27920836f, 
    -0.07344089f, -0.09583164f, -0.03302177f, -0.00087891f, -0.05813426f, -0.04542487f, -0.00679610f, 0.11081104f, 
    -0.49597073f, 0.15496576f, 0.08186250f, -0.13858350f, -0.00564042f, -0.00163857f, 0.06136956f, -0.04056588f, 
    0.16208304f, 0.02359936f, -0.02885072f, 0.00174044f, 0.01441247f, -0.18214455f, 0.11404169f, -0.11954775f, 
    -0.00432587f, -0.02714711f, -0.07569666f, -0.07527748f, 0.02775359f, -0.02589774f, -0.03505374f, -0.03289470f, 
    -0.36214074f, 0.30121654f, 0.09238464f, -0.17899054f, 0.05382577f, 0.04554961f, 0.00324620f, -0.08418992f, 
    -0.11829399f, 0.02475567f, 0.01850957f, -0.04184592f, -0.14559081f, -0.02390326f, 0.03302857f, 0.18195935f, 
    0.14548081f, -0.12048847f, 0.08810887f, -0.05717079f, -0.11335760f, -0.13129352f, 0.03576030f, 0.07098848f, 
    -0.03510188f, -0.01076330f, 0.08975168f, -0.23321676f, 0.06658046f, 0.09906065f, -0.08468644f, -0.02622871f, 
    -0.00662857f, -0.02838211f, 0.13109608f, -0.01902656f, 0.08691628f, -0.19944076f, 0.05510149f, -0.08905324f, 
    0.05768303f, 0.14243561f, -0.12681817f, -0.06303025f, 0.04477502f, 0.02160405f, 0.13884427f, 0.07168797f, 
    0.16221429f, 0.00023629f, 0.01140398f, -0.01167878f, -0.05309297f, 0.07237168f, -0.04507937f, 0.00699535f, 
    -0.04026337f, -0.00623125f, 0.03010610f, 0.00901603f, 0.15430355f, 0.02017763f, 0.05795470f, -0.09428025f, 
    -0.10173147f, -0.03348424f, 0.05211169f, 0.01676362f, 0.07284638f, 0.02616294f, -0.01127220f, -0.06586136f, 
    0.11201075f, 0.07443943f, 0.04695869f, -0.01386091f, 0.06046996f, 0.06226098f, -0.07462805f, 0.15531909f, 
    -0.05136174f, -0.13084663f, 0.04495957f, -0.16219077f, 0.17817312f, 0.09605585f, 0.11617120f, -0.21668240f, 
    0.04668429f, 0.03998520f, 0.06309812f, 0.06422862f, 0.06355752f, 0.11430807f, -0.08578783f, -0.08611828f, 
    -0.05726320f, -0.00582140f, 0.03887093f, -0.07527047f, 0.03972713f, 0.01764059f, -0.04160855f, 0.00192472f, 
    0.07615903f, 0.00970396f, 0.05148762f, -0.01816132f, 0.18256833f, 0.17099358f, 0.08253486f, 0.00335726f, 
    0.06347634f, 0.09455957f, 0.02776144f, -0.06354558f, 0.06690911f, 0.00578098f, -0.12044378f, -0.03363724f, 
    -0.32183576f, -0.36924845f, -0.04435852f, -0.13130987f, 0.04732794f, 0.09307919f, 0.07850742f, 0.00742239f, 
    0.10733546f, 0.13661693f, 0.05074581f, 0.07818501f, 0.15520783f, 0.08817460f, -0.09175032f, 0.08655526f, 
    -0.05276752f, -0.10361937f, 0.05116714f, -0.07853322f, 0.07930458f, 0.03296036f, 0.03478081f, -0.04229124f, 
    0.24541676f, -0.09540405f, 0.03187549f, -0.07615450f, 0.01049640f, -0.09473305f, -0.01836246f, 0.02570743f, 
    0.03645260f, 0.05038363f, -0.05391598f, 0.08076440f, 0.27149552f, 0.02442856f, -0.15105736f, 0.10470457f, 
    0.06429712f, -0.22775909f, -0.09407543f, -0.00802344f, -0.03353709f, -0.06412098f, -0.21043994f, -0.19453160f, 
    -0.23910274f, 0.07486357f, -0.22653356f, -0.09700181f, 0.09232913f, -0.01694797f, 0.00407655f, -0.06358021f, 
    0.14359167f, 0.07462460f, -0.03785918f, -0.01233780f, -0.10588632f, -0.26299968f, -0.00516020f, 0.01706620f, 
    0.09228639f, 0.00420985f, 0.04766374f, -0.04285512f, 0.00848658f, -0.06894436f, -0.00171094f, 0.10764503f, 
    0.18690491f, 0.05907143f, 0.03559189f, -0.09375966f, 0.06872004f, 0.03209498f, 0.00149193f, 0.08363120f, 
    0.04315545f, 0.08557671f, 0.11424533f, 0.04514908f, -0.21596542f, 0.31236643f, 0.12119899f, -0.01804460f, 
    0.10855688f, -0.01749959f, 0.12217898f, 0.03498513f, -0.03837794f, 0.12020808f, 0.10962934f, 0.11965775f, 
    -0.12015958f, -0.02771289f, 0.20431390f, -0.01372385f, 0.06253237f, 0.07860314f, 0.03960135f, -0.04504694f, 
    0.00331087f, -0.04440646f, -0.01979068f, -0.18016310f, -0.25328520f, -0.16722167f, -0.04875657f, -0.21403418f, 
    0.01797282f, -0.13239302f, 0.00519952f, -0.01737857f, -0.01429312f, -0.05164201f, 0.14829935f, 0.02528333f, 
    0.14965077f, -0.08036266f, 0.07645537f, -0.04281223f, -0.01745064f, -0.08591072f, 0.06500526f, -0.03984024f, 
    -0.09728205f, 0.01859124f, 0.14909138f, -0.07117223f, -0.42301971f, -0.38125306f, -0.11334876f, 0.10091643f, 
    0.05090341f, 0.08092207f, -0.06737411f, -0.02514420f, -0.02898608f, 0.11968763f, 0.06988700f, -0.01179122f, 
    -0.31531635f, -0.05031701f, -0.09781225f, -0.18907119f, -0.03571151f, -0.01175378f, -0.09593142f, 0.00490399f, 
    -0.01011376f, -0.05069043f, 0.09105355f, -0.10845122f, 0.11727588f, 0.05858504f, 0.13043740f, -0.21471033f, 
    -0.01408834f, 0.01278840f, -0.00476828f, 0.00174901f, -0.02270809f, -0.01256638f, 0.00963394f, 0.00664889f, 
    0.11956806f, -0.03136009f, 0.02853383f, -0.08940502f, 0.06939258f, 0.06082728f, 0.02199978f, -0.13182876f, 
    -0.01689547f, -0.01430375f, -0.03298315f, -0.01162435f, -0.35233918f, -0.22452405f, -0.11308188f, -0.25892276f, 
    0.05998964f, 0.05950585f, -0.05138764f, -0.05338693f, 0.01933367f, 0.02583649f, 0.07792553f, 0.08367068f, 
    -0.18560305f, -0.29369208f, 0.12434965f, 0.12189186f, 0.03396639f, 0.07176107f, -0.05731146f, 0.00206577f, 
    0.01526079f, -0.01080935f, 0.04005005f, -0.00815595f, 0.10204978f, -0.08052642f, 0.01289710f, 0.06827021f, 
    0.00011225f, -0.02353134f, 0.05370730f, 0.01509578f, -0.04543420f, 0.13576493f, -0.03938362f, 0.10732704f, 
    -0.49023351f, 0.16739382f, -0.20644815f, -0.14351740f, 0.15801516f, 0.05190687f, -0.09456132f, -0.04033763f, 
    0.07820057f, 0.05937890f, -0.10214616f, -0.11793318f, -0.13089381f, -0.09433673f, -0.10732162f, -0.06164922f, 
    0.00753311f, 0.04266039f, 0.02388541f, -0.00067104f, 0.02125568f, -0.02608870f, -0.02214319f, 0.01056393f, 
    -0.17517605f, -0.32240173f, -0.19493699f, 0.12187622f, -0.03443469f, -0.04139812f, -0.12524760f, -0.03337548f, 
    -0.03017704f, -0.07367042f, -0.16487439f, 0.01251309f, -0.11560325f, -0.38500449f, -0.06476416f, -0.05991206f, 
    -0.00046024f, 0.05043473f, -0.02452958f, -0.04504599f, 0.00433406f, 0.03642081f, -0.10378317f, -0.04955951f, 
    0.20344712f, 0.10258470f, -0.06607238f, -0.02625128f, 0.03851577f, -0.00256674f, 0.13872750f, -0.07123003f, 
    -0.03398671f, 0.05094360f, 0.09838571f, 0.08957618f, -0.13771267f, -0.01509684f, 0.16059908f, 0.08788826f, 
    -0.05837851f, 0.05856726f, -0.03477697f, 0.06360861f, -0.00503057f, -0.06390328f, -0.03028058f, 0.05912397f, 
    0.12888351f, 0.08592217f, -0.02746835f, 0.06346239f, -0.00751812f, 0.08704882f, 0.12764497f, 0.02336816f, 
    0.10718114f, 0.02597577f, 0.08251595f, 0.06437439f, 0.01175311f, 0.03281761f, 0.00457558f, 0.06576400f, 
    0.07912672f, 0.07987154f, 0.05391741f, -0.03632909f, -0.02383538f, 0.05024656f, 0.03010984f, 0.06669072f, 
    0.10756526f, 0.06959286f, 0.03472558f, -0.07571381f, 0.06781047f, -0.00647043f, 0.04126162f, 0.04082089f, 
    -0.02848226f, 0.07565712f, -0.02731994f, 0.05452295f, -0.09024735f, 0.02038363f, -0.17139767f, -0.03914789f, 
    0.07660940f, -0.00214719f, -0.05036272f, -0.07721683f, 0.05740733f, -0.10533690f, -0.11954023f, -0.11550321f, 
    0.11532438f, 0.15946472f, -0.02596816f, 0.06230267f, -0.14428957f, -0.12685062f, -0.19578862f, 0.05328488f, 
    -0.00795688f, -0.10356133f, -0.04768858f, -0.11414211f, 0.27065545f, -0.00453706f, -0.10982735f, -0.06911214f, 
    -0.08029420f, -0.03809054f, -0.01096619f, -0.01370962f, 0.04658657f, -0.01182776f, -0.14545375f, -0.15704517f, 
    0.21707086f, 0.21123081f, 0.03300642f, -0.20247744f, -0.05493617f, -0.04175345f, -0.05164700f, 0.09945504f, 
    -0.00192683f, 0.02946697f, 0.09189822f, 0.02520693f, 0.20326097f, -0.02293770f, 0.00666220f, 0.04086905f, 
    -0.13071908f, -0.12063438f, 0.10856047f, -0.01259953f, -0.01732762f, -0.11670697f, -0.07539491f, -0.14799273f, 
    0.00081634f, 0.02883008f, 0.03329688f, 0.01459202f, 0.15556790f, -0.05078314f, 0.05304388f, 0.03915583f, 
    0.07230162f, 0.06263363f, 0.02933097f, 0.12650846f, -0.35299948f, -0.01605580f, -0.06498782f, -0.07460500f, 
    0.02195944f, 0.04260042f, -0.16068979f, -0.03624731f, 0.01263703f, -0.01693754f, -0.04303408f, 0.11108811f, 
    0.23006606f, 0.12033219f, -0.06336380f, -0.05857805f, -0.01777855f, -0.01374971f, 0.07371905f, 0.02618850f, 
    -0.11777546f, -0.04994547f, 0.16342522f, 0.01523028f, 0.05733283f, -0.07973813f, 0.02811339f, 0.11824873f, 
    -0.02461352f, -0.00920161f, -0.05391628f, 0.06678309f, 0.02421965f, 0.02578243f, 0.06290114f, -0.05411592f, 
    0.21122774f, 0.17994179f, 0.04407186f, -0.09163650f, -0.09014690f, 0.00304538f, -0.02047933f, 0.11006475f, 
    0.03871174f, -0.10345840f, 0.08667873f, 0.19780131f, -0.06150737f, -0.07633045f, -0.23418844f, -0.05247618f, 
    -0.02846630f, 0.01278746f, -0.09427980f, 0.12848224f, 0.02252202f, 0.04313221f, 0.04703655f, 0.04594484f, 
    -0.60109258f, -0.42204699f, 0.03510236f, 0.02046514f, 0.06990851f, 0.05603479f, -0.01785658f, -0.13377769f, 
    0.02003480f, -0.02060251f, -0.06724656f, -0.01156187f, -0.20255637f, -0.02348232f, -0.03384514f, -0.23930955f, 
    0.04050994f, -0.09328812f, 0.10312887f, 0.10725392f, 0.10736783f, 0.07946426f, 0.06763612f, 0.16165584f, 
    -0.31928930f, -0.26217577f, 0.00440275f, 0.02370296f, -0.01140993f, 0.06784467f, 0.04337201f, -0.10855064f, 
    0.05610478f, -0.02552282f, -0.10272176f, -0.01739523f, 0.14892878f, -0.02051520f, -0.04189200f, -0.06317137f, 
    -0.14322487f, 0.04944746f, -0.00677041f, 0.08180679f, 0.08355106f, -0.02980786f, 0.01820355f, -0.06552416f, 
    0.04765068f, 0.04657339f, -0.02962743f, 0.06592415f, -0.04137067f, 0.01901954f, 0.01861078f, -0.00274628f, 
    0.04776422f, 0.02709061f, 0.09653085f, -0.03588700f, -0.44878092f, -0.23157279f, -0.09652452f, -0.03280765f, 
    0.08530559f, -0.09363759f, -0.03175349f, -0.04084090f, -0.00990990f, 0.04048143f, 0.11516204f, 0.01422632f, 
    -0.13670242f, -0.04090882f, 0.18234578f, 0.09131697f, -0.08457678f, -0.09802587f, 0.11412357f, 0.09941502f, 
    0.10655959f, 0.09490129f, 0.00474764f, 0.03576600f, -0.32168570f, 0.12658107f, -0.07878397f, -0.11179517f, 
    0.14317299f, 0.01472613f, 0.01778299f, 0.03280963f, -0.00082695f, -0.02691220f, -0.00586507f, -0.02141857f, 
    -0.18287128f, -0.09780090f, -0.05383765f, -0.02476642f, 0.02543133f, 0.03816812f, -0.06545606f, -0.01570291f, 
    0.09961805f, -0.02219815f, -0.12048922f, -0.16017725f, -0.13608986f, -0.12037468f, 0.10241057f, -0.03581656f, 
    -0.00051326f, -0.02900778f, -0.05705054f, 0.03240282f, 0.00442360f, 0.16762842f, -0.08921227f, -0.00652935f, 
    0.06301724f, 0.08378367f, -0.20019534f, 0.02070368f, -0.04174501f, -0.07993499f, 0.07299903f, -0.13346481f, 
    -0.06677039f, -0.00762812f, 0.10195588f, -0.01975680f, -0.38045099f, -0.13668218f, -0.05842213f, -0.18688421f, 
    -0.00717289f, -0.07557622f, -0.03471617f, -0.04183025f, -0.04667596f, 0.14696576f, 0.09965112f, 0.03268525f, 
    0.30002084f, 0.03259543f, -0.00142069f, 0.01923148f, -0.03307614f, -0.14896375f, -0.15260030f, 0.09716810f, 
    0.03879242f, -0.03304038f, -0.14669190f, 0.09483252f, 0.11565285f, -0.00872758f, 0.06823859f, 0.04481844f, 
    0.09667598f, 0.08589984f, 0.05936689f, -0.09479713f, 0.08859711f, -0.01042320f, -0.04304149f, 0.00901250f, 
    -0.31320351f, -0.16696216f, 0.26935029f, 0.05124306f, 0.13084817f, -0.01395805f, 0.03297250f, 0.06044722f, 
    0.07714356f, -0.08981751f, -0.12505141f, 0.06886649f, -0.42535314f, -0.08019625f, -0.09783886f, -0.08352835f, 
    0.06097277f, 0.04885441f, -0.05315774f, 0.01844835f, 0.04441576f, 0.05332927f, -0.12608987f, -0.02681117f, 
    -0.08314612f, -0.19250754f, -0.04147865f, -0.00207322f, 0.04640771f, 0.07001778f, -0.00390282f, 0.10245152f, 
    0.11772168f, 0.12640885f, 0.19025929f, 0.03159742f, 0.04208929f, -0.27561250f, 0.01100123f, 0.16536407f, 
    -0.02731263f, -0.03294188f, 0.02805106f, 0.03889235f, 0.13685839f, 0.00479602f, 0.04467913f, 0.09987999f, 
    0.00766603f, 0.05158804f, -0.02845967f, -0.04337345f, 0.10046041f, -0.02011792f, -0.04711965f, -0.02470348f, 
    0.02575947f, -0.10759621f, -0.09963122f, -0.03519375f, -0.27585745f, 0.06275639f, 0.06792589f, -0.01826011f, 
    0.02353551f, -0.07552725f, 0.02652822f, 0.00850772f, -0.01807074f, -0.03195886f, 0.03565253f, 0.04925516f, 
    -0.06644260f, 0.23928629f, 0.00519982f, 0.11708945f, -0.05030236f, 0.00562071f, 0.00077501f, -0.15221092f, 
    -0.09577052f, 0.07539607f, 0.03705395f, -0.16878974f, -0.16977279f, 0.04866804f, -0.04423932f, 0.03050946f, 
    -0.11150913f, -0.00284925f, -0.07244506f, 0.03547766f, -0.08349630f, 0.03704520f, 0.03816636f, -0.06994821f, 
    -0.29800445f, 0.17219473f, 0.01881929f, -0.04933676f, -0.01545618f, -0.02876540f, 0.07475857f, -0.13444048f, 
    0.05639244f, 0.11284275f, -0.05923375f, -0.11029661f, -0.02162341f, 0.04585442f, 0.04176859f, -0.03495974f, 
    -0.00573200f, 0.01616290f, -0.03809254f, -0.00254968f, 0.07836013f, -0.06717569f, 0.03037237f, -0.00504689f, 
    0.22156130f, 0.12195464f, -0.04267057f, -0.03104279f, -0.06619776f, -0.09244984f, -0.02664088f, -0.12780303f, 
    0.00206816f, 0.11235385f, -0.06868038f, 0.01321673f, 0.02482849f, -0.08894157f, -0.07785174f, 0.12213172f, 
    -0.00369650f, 0.00726570f, 0.05918530f, -0.01686889f, -0.05768259f, 0.03946680f, -0.01781344f, -0.00676310f, 
    0.01958400f, -0.07912780f, -0.01571018f, -0.13964108f, 0.03408593f, 0.04142213f, -0.00519183f, 0.01516845f, 
    -0.09481267f, -0.00823200f, -0.06903827f, -0.10148358f, 0.11866228f, -0.09655966f, 0.00504896f, -0.03452757f, 
    -0.01658707f, -0.01751825f, -0.04200990f, -0.01944442f, 0.06385899f, -0.00765366f, -0.04239924f, 0.03898546f, 
    -0.01594616f, -0.01054592f, 0.01165019f, -0.08559204f, 0.04753781f, 0.00259213f, 0.07632142f, 0.13764536f, 
    0.08527610f, 0.11537269f, 0.04933115f, -0.04187608f, -0.24255733f, -0.05676078f, -0.00606193f, -0.26465258f, 
    0.02506839f, -0.03245494f, 0.06768675f, 0.02566463f, 0.02132646f, 0.03792077f, 0.08575947f, 0.07483277f, 
    0.06109937f, -0.15412757f, -0.12688988f, 0.35209042f, -0.01074012f, 0.02532511f, -0.11205813f, -0.03551345f, 
    -0.02923723f, -0.06530982f, 0.07748907f, -0.04712601f, -0.02310521f, -0.00144222f, 0.00311391f, 0.04466601f, 
    0.05362894f, 0.02263723f, -0.00330815f, 0.05555046f, 0.03260729f, 0.02999085f, 0.07286504f, -0.01512810f, 
    0.20704836f, 0.00609031f, -0.24778026f, 0.21139550f, -0.00737667f, -0.02717676f, 0.00774874f, 0.06529729f, 
    -0.03454968f, 0.07244726f, -0.01824562f, -0.01011225f, 0.24195057f, 0.16279472f, -0.01785863f, -0.10628874f, 
    0.00980747f, 0.04215530f, -0.02796236f, 0.07162517f, 0.06208710f, -0.08397923f, -0.07726117f, -0.10337035f, 
    -0.16991389f, 0.34228894f, 0.02683167f, 0.00738666f, 0.01346054f, -0.03683048f, -0.11923659f, -0.16082570f, 
    0.02924418f, 0.07166379f, 0.03928342f, -0.08431341f, 0.15077204f, -0.33511242f, -0.07581656f, 0.01236347f, 
    0.00578216f, 0.03275332f, 0.02492510f, -0.00400053f, 0.00230037f, -0.00139443f, -0.07570701f, 0.10209236f, 
    -0.00082655f, 0.02414282f, -0.11635828f, 0.05478304f, 0.14506805f, -0.07590112f, -0.00762750f, -0.00224340f, 
    0.00145992f, -0.00873817f, 0.03988820f, -0.01740617f, -0.08150278f, 0.28316835f, -0.13891312f, 0.18369231f, 
    0.09378185f, 0.03182824f, 0.00634604f, 0.06539179f, 0.04681683f, 0.03135749f, -0.05200560f, -0.01333951f, 
    -0.12536643f, -0.48486573f, -0.00001483f, -0.12208769f, 0.11701072f, 0.07152540f, -0.05570301f, -0.01525536f, 
    -0.12049189f, 0.04741449f, -0.11776625f, 0.03635142f, -0.02521023f, 0.17268620f, -0.09636695f, -0.05957475f, 
    -0.06965546f, 0.01850822f, 0.06055840f, -0.12929092f, 0.05127582f, 0.14676826f, -0.03440698f, -0.06391735f, 
    -0.09967523f, -0.10736515f, 0.02442088f, -0.02620029f, 0.09574623f, -0.06788515f, 0.04392479f, 0.03095039f, 
    -0.03441546f, -0.01209676f, -0.04202309f, -0.01691255f, 0.23621601f, -0.38043195f, -0.18056688f, 0.12704617f, 
    0.06723223f, -0.01345564f, -0.00075052f, -0.02275575f, -0.01742541f, 0.00775397f, -0.02017579f, -0.11164788f, 
    0.05232610f, 0.34871677f, -0.20513736f, 0.19360864f, 0.05274065f, -0.24908608f, -0.08800000f, -0.12970759f, 
    0.01177765f, 0.12225205f, -0.07842129f, 0.07750682f, 0.22907096f, -0.11224708f, 0.03760172f, -0.06972961f, 
    -0.10527794f, -0.03156820f, -0.02570243f, -0.00669519f, 0.00804116f, -0.03470211f, 0.00838156f, -0.01797688f, 
    -0.26294574f, -0.03235270f, 0.02600867f, 0.09034925f, -0.07630824f, 0.07831498f, -0.18618590f, 0.13745539f, 
    0.01903477f, 0.00667765f, 0.08807931f, -0.00948752f, -0.25490367f, -0.34157500f, -0.11143465f, -0.17395735f, 
    0.05353127f, -0.01576397f, 0.13559106f, 0.05175402f, -0.07260259f, 0.03795461f, 0.00188060f, -0.01254344f, 
    -0.34773502f, 0.10606708f, -0.09119235f, 0.07305766f, 0.12337755f, -0.04462714f, 0.11725476f, -0.08538857f, 
    0.02676179f, 0.01846696f, 0.04565813f, 0.10298180f, -0.00938690f, -0.04058780f, 0.00567912f, 0.12354364f, 
    0.08582561f, 0.04666858f, 0.05106557f, 0.01819967f, -0.06490289f, -0.00262597f, -0.07867916f, 0.08810824f, 
    0.07448663f, -0.04918184f, -0.08835308f, 0.07193261f, 0.04212052f, 0.08285234f, -0.00173462f, 0.00816026f, 
    -0.02758594f, -0.03381484f, -0.10094881f, 0.07506513f, 0.12335028f, 0.27248225f, -0.01905328f, -0.02959484f, 
    -0.05866956f, 0.03499112f, -0.02436010f, -0.15450460f, 0.01018610f, 0.09407687f, 0.00374291f, 0.05723696f, 
    -0.01554512f, -0.03049973f, -0.01889471f, -0.02127593f, -0.16312477f, 0.03782287f, -0.04867648f, -0.10153080f, 
    -0.11395148f, 0.02993071f, 0.10394228f, -0.01366346f, -0.13925925f, 0.17219655f, 0.01285259f, 0.12422810f, 
    0.10617416f, 0.00159514f, 0.03822890f, -0.03043428f, 0.05755688f, 0.02256212f, -0.02650991f, -0.02008986f, 
    0.08352099f, 0.00538721f, 0.02988060f, 0.14391910f, -0.05404111f, -0.09564951f, -0.05643422f, -0.00471929f, 
    -0.04702453f, -0.15220188f, -0.06740926f, -0.05289460f, -0.26934040f, 0.15814847f, -0.11208840f, -0.22208689f, 
    -0.02311662f, 0.05343388f, 0.03261468f, 0.09377351f, 0.17167491f, 0.04044405f, -0.01116779f, -0.00320515f, 
    -0.19419214f, -0.02730077f, -0.18792957f, -0.11777978f, -0.12082641f, 0.01962745f, 0.09529889f, 0.04830471f, 
    0.06634689f, -0.07598788f, 0.03023962f, 0.06577113f, -0.22612430f, -0.22681499f, 0.04645427f, 0.06180956f, 
    -0.05663800f, -0.00421163f, 0.11174726f, -0.02962058f, -0.02090281f, 0.02019890f, -0.02393925f, -0.12771998f, 
    -0.28619984f, 0.12216084f, -0.05350747f, 0.12562859f, -0.10403892f, -0.08309089f, 0.09245732f, 0.17317340f, 
    0.04142585f, 0.02409659f, 0.02278867f, -0.06048956f, -0.06635386f, 0.02335982f, 0.00288431f, 0.04699757f, 
    0.05503822f, -0.02343122f, 0.15316503f, 0.00292068f, 0.02607086f, -0.02134131f, 0.12544003f, 0.02774608f, 
    0.22811379f, 0.06357492f, -0.07426104f, 0.10960059f, 0.09302688f, 0.02073976f, -0.10503908f, 0.05732182f, 
    0.03673286f, 0.04767487f, 0.06482806f, -0.04109206f, 0.09496681f, 0.00437146f, -0.07440023f, 0.00972844f, 
    -0.04293752f, -0.03059640f, -0.12603858f, -0.04114635f, -0.19278356f, -0.01486204f, -0.02842591f, -0.04165828f, 
    -0.03930698f, -0.00898167f, -0.04084599f, 0.01341463f, -0.08033498f, 0.01979902f, 0.13215522f, 0.05321374f, 
    0.03482413f, -0.10677984f, -0.09097392f, -0.03976241f, -0.17755210f, -0.03482778f, -0.12282684f, 0.05652226f, 
    0.14461060f, 0.00020222f, 0.01013963f, -0.05333658f, -0.05679283f, 0.03014296f, -0.05034136f, 0.00380786f, 
    0.18671884f, -0.09537503f, -0.07841484f, -0.15727532f, 0.11128162f, -0.03261551f, 0.01010458f, -0.00435504f, 
    0.01497107f, -0.02834521f, 0.01651833f, 0.05040835f, -0.30470118f, 0.08253888f, -0.27443823f, -0.14250754f, 
    0.03294575f, 0.01385279f, 0.03868135f, -0.00954670f, -0.04320489f, -0.00557203f, 0.03615489f, 0.11052676f, 
    0.39545438f, 0.10914387f, -0.19055587f, -0.13033552f, -0.02658981f, -0.06475782f, 0.01428434f, -0.01282095f, 
    0.13927709f, 0.02451882f, 0.06392109f, 0.03354301f, 0.16537775f, -0.14965175f, 0.00913658f, 0.05751060f, 
    0.02855870f, -0.13289551f, -0.06190631f, 0.02871921f, -0.01988317f, -0.06261124f, -0.04166484f, -0.10987613f, 
    -0.15901493f, 0.14234778f, -0.09647080f, -0.18651794f, 0.12678793f, -0.09456670f, -0.00115384f, 0.10401282f, 
    -0.10632922f, 0.00054417f, -0.01295563f, 0.00395567f, -0.27279845f, 0.14188448f, -0.11735393f, 0.06528388f, 
    0.20359285f, -0.10836034f, -0.04766072f, 0.07372098f, -0.04363180f, -0.01634694f, -0.06567828f, 0.05487806f, 
    0.29657221f, -0.00196458f, -0.12942183f, 0.01952585f, -0.01842640f, -0.12644413f, 0.02286392f, 0.01971896f, 
    0.01096059f, -0.05291761f, -0.07073562f, 0.00190959f, 0.25361386f, -0.31197274f, -0.06831438f, -0.01732760f, 
    0.05294467f, -0.13523573f, -0.05264121f, -0.14474364f, 0.10458475f, 0.04740747f, 0.01215117f, 0.03181270f, 
    -0.12603983f, -0.16478129f, 0.01616681f, -0.01352911f, 0.04350294f, -0.09870847f, -0.04225072f, -0.01313645f, 
    -0.10845399f, 0.01366693f, 0.02883546f, 0.02158683f, -0.17717035f, -0.04838844f, 0.09197414f, 0.32837722f, 
    -0.15259896f, 0.10081821f, 0.00623459f, 0.05632481f, 0.11843339f, 0.00670215f, -0.05110687f, 0.00280962f, 
    0.12314892f, -0.07428961f, -0.21511567f, 0.15043263f, -0.05030857f, 0.08265112f, 0.01474917f, -0.08725525f, 
    0.10463440f, -0.00842049f, 0.02780997f, 0.14845483f, -0.01599535f, -0.07067308f, -0.02661983f, -0.13288164f, 
    0.06510995f, 0.18798195f, -0.09888624f, 0.03075059f, -0.10256749f, 0.00023722f, -0.01324129f, -0.07942266f, 
    0.13894089f, -0.16474152f, -0.12967069f, -0.01379482f, -0.18904147f, 0.06301592f, -0.03405324f, -0.05464974f, 
    -0.09447706f, -0.03789710f, -0.12397567f, -0.14127931f, -0.12746258f, 0.05291023f, -0.13526464f, -0.07749129f, 
    0.01660027f, -0.08137929f, -0.03470861f, 0.04058752f, -0.02069830f, -0.05785340f, -0.04271983f, -0.02423533f, 
    -0.03637985f, -0.06574699f, 0.10304671f, -0.02526897f, 0.06984748f, -0.01080521f, 0.05863011f, -0.04396242f, 
    -0.09088176f, 0.01513678f, 0.04091550f, 0.12868209f, 0.19558820f, 0.01506924f, -0.11127397f, 0.06143989f, 
    0.01584200f, -0.08766560f, 0.02331940f, -0.01684562f, 0.10080922f, -0.01132762f, 0.01573529f, 0.06971362f, 
    0.12150797f, 0.08685381f, 0.12812285f, -0.22189704f, 0.06353040f, 0.01450019f, 0.00288644f, 0.01798452f, 
    -0.04348380f, 0.07892163f, -0.03226740f, -0.00573384f, 0.60614234f, 0.07050209f, -0.27228063f, -0.05237690f, 
    0.03386145f, -0.08312776f, 0.00458625f, 0.00366056f, -0.01080234f, 0.05628383f, 0.04694845f, 0.12319389f, 
    0.17820464f, -0.03840257f, -0.06845587f, 0.08797763f, 0.10354020f, -0.07268679f, 0.01438687f, -0.01230834f, 
    -0.01026761f, 0.05261685f, 0.00001146f, 0.02048362f, 0.01604171f, 0.06049186f, 0.17653312f, -0.18265648f, 
    -0.07427936f, -0.12414314f, 0.06806740f, 0.03935332f, -0.14458212f, -0.02924678f, 0.11263783f, -0.08757435f, 
    0.11713054f, 0.01822779f, -0.06132182f, -0.10153624f, -0.09872682f, -0.05963343f, 0.03456077f, 0.10044169f, 
    -0.07838321f, 0.06122420f, -0.01535007f, 0.04417545f, -0.47602928f, 0.00170335f, -0.01534568f, -0.17108922f, 
    -0.00207797f, -0.06239656f, 0.05503887f, 0.09651528f, -0.00099346f, -0.07220399f, -0.01503771f, -0.06254868f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06961909f, 0.02059972f, 0.00083205f, 0.01312552f, 0.04670683f, 0.00557105f, -0.02094998f, -0.04241619f, 
    -0.03196887f, 0.03918858f, 0.02216599f, 0.04022322f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
