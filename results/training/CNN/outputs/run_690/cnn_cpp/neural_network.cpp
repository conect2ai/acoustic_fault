#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.41993561f, -0.39765507f, 0.86326104f, -0.98800439f, 0.06433459f, 0.59735554f, 0.57031059f, -0.54361337f, 
    0.51031375f, 0.46396220f, -1.66067505f, 0.93219090f, 0.38005278f, 0.69568062f, 0.30586502f, -0.28087440f, 
    0.27077213f, -0.45404583f, 0.30740470f, 1.42069268f, 0.43818945f, -1.31949425f, 0.27214611f, -0.70614618f, 
    0.17648125f, -0.12759399f, -0.21406364f, 0.41835618f, -1.17820632f, -0.60196471f, -1.13213062f, -0.10863855f, 
    0.42984661f, -0.13955726f, 0.08335880f, 0.22721305f, 0.53406972f, 0.42969167f, 0.34717059f, -0.62479585f, 
    -1.00658739f, 0.43030480f, 0.75636858f, 0.37237570f, 0.38442883f, -1.03123581f, -0.88860345f, -0.76576477f, 
    -0.21775338f, -0.51410538f, 0.10060234f, 0.20011111f, 0.34483492f, -0.07759595f, -0.23233467f, -0.75226313f, 
    -0.51174009f, -0.74287444f, -0.97110415f, -0.91246843f, -0.50117052f, 0.19813678f, -0.53596634f, 0.33125371f, 
    -1.29497981f, 0.48344988f, 0.82793128f, -1.02178752f, 0.79521531f, 0.20647579f, -0.48595336f, 0.18114737f, 
    -1.23696792f, 1.17699170f, 0.81792015f, 0.24888971f, 0.98165840f, -0.12481581f, -0.19085471f, -0.04994780f, 
    0.29172114f, 0.56654584f, 0.83580261f, 1.06932104f, -0.76779789f, -0.46550041f, -0.05073191f, 0.33440423f, 
    -0.12736870f, -0.69025618f, -1.45519018f, 1.20248926f, 0.57691550f, 0.42212915f, -0.24497859f, -0.94855380f, 
    0.17967904f, -0.05614512f, 0.08706801f, 0.13804203f, 0.78212363f, 0.93431741f, -0.52794808f, 0.74243683f, 
    0.04302928f, 0.05565229f, 0.35826308f, 0.44008720f, -0.08799825f, -0.47772083f, -0.68499458f, 0.18907328f, 
    -1.20885086f, 0.40026289f, 0.70001471f, -0.11371642f, -0.51220286f, 1.08752322f, 0.18161809f, 0.83539397f, 
    0.70567781f, 0.21130081f, -0.33639988f, -0.24632320f, -0.11066715f, -0.13344020f, -0.03199200f, -0.81064981f, 
    -0.98871690f, 0.09574104f, -0.20907468f, 0.02367910f, -0.46870372f, 0.08276670f, 0.24721605f, -0.36073503f, 
    -0.44381580f, -0.91926384f, 0.89964902f, -0.28403869f, 0.09730266f, -0.90284997f, -0.00931436f, -0.04288032f, 
    -0.74650192f, -1.05916381f, -0.50598341f, -0.75571162f, 0.85935438f, 1.11234534f, 0.26542386f, -0.35053581f, 
    0.17141996f, 1.33156872f, -1.00855732f, -0.10676304f, 0.99131912f, -0.15341392f, -0.00184888f, -0.43373305f, 
    0.01879163f, -0.08219504f, -0.64708322f, -0.63372749f, 0.79405028f, 1.17527092f, 0.50222790f, -0.50841653f, 
    0.15260804f, -0.33687919f, 0.61921310f, 0.60330796f, 0.64032060f, 0.56741643f, -0.32739842f, -0.23584138f, 
    0.71512049f, -0.60028052f, -0.71894741f, 0.18773057f, 0.94299215f, 0.40000692f, 0.65033889f, -0.77859336f, 
    -0.93279022f, -0.71196777f, -0.00817439f, 0.89975578f, -0.31673503f, -0.83978015f, -0.82231772f, 0.35425970f, 
    -1.20333433f, -0.59748763f, 0.65156376f, 0.81194067f, 0.25077099f, -0.09594798f, 1.37289667f, 0.05494151f, 
    -0.82254499f, -0.42737374f, -0.57440799f, 0.06435531f, -0.43194669f, -0.17451251f, 0.30079612f, 0.57807338f, 
    0.74536687f, 0.71161294f, 0.60616988f, -0.44943139f, 0.63323778f, -0.23267554f, -0.24296524f, -0.05590248f, 
    -1.32193065f, 1.08589947f, 0.36740306f, -0.03932255f, 1.08551157f, 0.64912981f, -0.52973634f, -0.15526535f, 
    -0.31755108f, 0.84787017f, 0.41564649f, 0.39460036f, 0.64447433f, 0.42495006f, 0.08420491f, -0.06821963f, 
    0.67894185f, 0.29044583f, -1.23009992f, -0.46451202f, 1.07284713f, 0.35256076f, -0.32414687f, 0.09013940f, 
    -0.38219208f, 0.08386639f, -0.43219906f, -1.11630476f, -0.85518205f, -0.25172535f, 0.52971321f, 0.68756634f, 
    0.95421857f, -0.14261542f, 0.22330670f, 0.56535822f, -0.12951124f, -0.93534440f, -0.47382045f, -0.10261476f, 
    1.25536847f, -0.88232321f, 0.28636897f, 0.48519495f, -0.43465066f, -0.81582314f, -0.97916961f, -0.84183681f, 
    0.69030893f, 0.69702780f, 0.57855791f, 0.04596822f, -0.26599297f, -0.34678403f, 0.90205079f, 0.50164610f, 
    0.55702174f, -1.26991630f, 0.40318188f, 0.17788231f, 0.03396568f, 0.53703958f, -0.07582191f, 0.92644173f, 
    0.75899041f, -0.05246302f, 0.29569313f, 0.68078065f, 0.61576295f, -0.04299178f, 0.41882181f, -0.53102726f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26660052f, 0.34531447f, 0.14751843f, 0.30567572f, 0.08875417f, 0.06609438f, 0.23039800f, -0.06669105f, 
    0.39019397f, -0.00632328f, -0.05153228f, 0.52097821f, 0.17301352f, 0.10645075f, 0.26586983f, -0.23704119f, 
    0.30375797f, -0.05290118f, -0.13602301f, 0.27311215f, 0.13699819f, 0.15743759f, -0.06765988f, 0.45069525f, 
    0.06678104f, 0.38933396f, 0.13332413f, 0.33808419f, 0.34226131f, -0.00034786f, 0.09417041f, 0.26560086f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26036191f, -0.20583268f, -0.12742376f, 0.10964582f, -0.16693999f, -0.00049596f, -0.07854863f, -0.04788409f, 
    -0.01536889f, -0.03804896f, 0.05073208f, -0.04811732f, 0.02940143f, 0.10297044f, 0.05568487f, -0.02717604f, 
    -0.14126076f, -0.06976803f, -0.12839085f, -0.01485105f, -0.52259606f, 0.38694519f, 0.10985930f, -0.11161130f, 
    -0.20390946f, 0.13381280f, 0.00321091f, -0.07082260f, -0.06399857f, -0.05547578f, 0.05875904f, -0.04545013f, 
    0.07574359f, -0.01703581f, 0.01260652f, 0.04986460f, 0.00341746f, -0.13582370f, 0.10260362f, -0.08847105f, 
    -0.41267604f, -0.04014311f, 0.08054343f, 0.15632063f, 0.17815639f, -0.03720601f, 0.03957054f, 0.09021588f, 
    -0.19412972f, -0.03247068f, -0.02483109f, -0.16667157f, 0.09277223f, -0.13952586f, 0.04188462f, -0.11398205f, 
    0.06361572f, 0.01978326f, 0.09293819f, 0.09915375f, 0.21650298f, -0.05398187f, -0.27401966f, 0.23381518f, 
    -0.21920027f, 0.00442685f, 0.01693190f, -0.06885797f, 0.09415780f, 0.15296715f, 0.00201116f, -0.10545570f, 
    -0.11599315f, -0.04193388f, -0.01017675f, 0.01913507f, -0.10264699f, 0.16639750f, 0.05952286f, -0.11640941f, 
    0.00376994f, -0.20487064f, 0.02224057f, 0.38792562f, -0.03885400f, -0.25824335f, -0.03564828f, -0.04834899f, 
    -0.15767898f, 0.01988382f, -0.05023183f, -0.12748954f, -0.14095992f, 0.01429467f, 0.06489068f, -0.13632995f, 
    -0.06728670f, -0.02036098f, -0.19866119f, -0.01288942f, -0.22983114f, -0.14445329f, -0.04992523f, 0.06253608f, 
    0.19868295f, 0.13364080f, 0.12138993f, -0.04048947f, 0.17625690f, 0.19345312f, 0.09192578f, 0.11202648f, 
    0.00285056f, -0.04733294f, 0.02040282f, 0.00138760f, -0.05140583f, 0.10597717f, 0.10571877f, 0.12755975f, 
    -0.14221601f, -0.06361321f, 0.11718303f, 0.24292122f, -0.15593635f, 0.04878590f, 0.10441495f, 0.01558674f, 
    0.07441285f, -0.01673868f, 0.08927039f, 0.04185054f, 0.15934661f, 0.04825339f, 0.20188069f, -0.17640546f, 
    0.10809662f, 0.17674568f, 0.06894464f, 0.03699525f, -0.15316725f, 0.05927046f, -0.21542342f, -0.12397552f, 
    -0.08782844f, 0.07150019f, 0.14849399f, -0.07155413f, -0.07528988f, -0.02087183f, 0.04721041f, 0.07188526f, 
    -0.05841219f, 0.06796454f, 0.02502430f, 0.00796867f, -0.10437104f, 0.00522203f, -0.04840102f, 0.12366858f, 
    0.25610024f, 0.24458688f, 0.18084918f, 0.07216605f, -0.23739599f, 0.11619452f, -0.07805378f, 0.15800786f, 
    -0.01917128f, -0.08703434f, 0.02216762f, 0.06491294f, -0.12534957f, 0.00510864f, -0.03102396f, -0.02263023f, 
    0.08487540f, -0.09549946f, 0.04290398f, 0.00069403f, -0.40643817f, -0.21019755f, 0.05749437f, 0.34687105f, 
    0.28462389f, -0.18945713f, 0.10290543f, 0.03506088f, 0.02709424f, 0.08630018f, -0.03940795f, 0.00187312f, 
    0.02575964f, -0.08934225f, 0.00228201f, 0.12039365f, 0.10897914f, -0.00956391f, 0.09411982f, 0.09996572f, 
    0.32770836f, 0.26147476f, 0.25003624f, -0.11466354f, -0.34149730f, 0.02126885f, 0.20037889f, -0.04337883f, 
    -0.03034735f, -0.12266043f, -0.09082518f, 0.21700056f, -0.13781030f, -0.02808980f, 0.00765748f, -0.16260977f, 
    0.05741426f, -0.04542821f, -0.00592566f, 0.01616496f, -0.17343692f, 0.13866282f, 0.04372261f, 0.19625624f, 
    0.05780414f, -0.01123845f, 0.07551985f, 0.15415649f, 0.02462316f, -0.07823080f, -0.02634967f, -0.05679235f, 
    0.07379244f, -0.03909043f, -0.00062522f, -0.14706424f, -0.03809281f, -0.13989303f, 0.07301245f, -0.08011492f, 
    -0.08612801f, -0.14215428f, -0.10785285f, 0.32582584f, -0.04419374f, -0.08505569f, 0.09876220f, -0.06431315f, 
    0.03020561f, 0.11959536f, 0.02119549f, -0.03329681f, 0.15619595f, 0.02916469f, -0.05336864f, -0.10809787f, 
    0.06554558f, 0.03743659f, -0.23587251f, -0.08696605f, 0.41820529f, 0.24789153f, 0.35702026f, 0.09190473f, 
    0.46458200f, 0.13200496f, -0.01821901f, -0.00094722f, 0.23550184f, 0.00508728f, -0.01664886f, -0.02956352f, 
    -0.04629947f, 0.09076438f, 0.02046972f, 0.02390488f, 0.07749216f, 0.04859022f, 0.01638308f, 0.01138942f, 
    -0.01013486f, -0.06315906f, -0.26703596f, 0.21178620f, -0.10658190f, -0.04424359f, 0.05755980f, -0.13992326f, 
    0.10686494f, 0.15576746f, -0.02815637f, 0.08206423f, -0.00571780f, 0.00258352f, 0.02625525f, -0.00294785f, 
    -0.00116937f, 0.18148196f, 0.07941240f, 0.06675573f, -0.46245348f, -0.13255917f, -0.16358890f, 0.13691527f, 
    0.01178484f, 0.09609718f, 0.08640805f, 0.04868845f, 0.07591434f, 0.33684275f, 0.12407576f, 0.07190557f, 
    -0.00893951f, -0.04165121f, 0.00730254f, 0.08258008f, 0.09017169f, -0.03091490f, 0.26036519f, 0.12065591f, 
    -0.32066441f, -0.08889993f, -0.21478295f, 0.02316576f, 0.07075842f, 0.12417369f, 0.04403250f, 0.00654341f, 
    0.08282674f, 0.01001369f, 0.01793646f, -0.04194095f, -0.06640868f, 0.11397011f, 0.05580004f, 0.15165043f, 
    -0.04325283f, 0.06063494f, 0.13533376f, -0.06064654f, 0.02219818f, 0.26264095f, -0.08421851f, -0.09827890f, 
    -0.14284720f, -0.01427428f, -0.00580404f, -0.11764313f, 0.01003315f, -0.03512569f, 0.12254607f, -0.04856620f, 
    -0.00471394f, 0.09157153f, -0.00935985f, -0.01334002f, -0.02279196f, 0.00435271f, -0.04004293f, 0.02362061f, 
    -0.11928488f, 0.13983382f, 0.12942396f, -0.22761433f, -0.03987743f, 0.10297031f, -0.06902435f, -0.09876512f, 
    0.08422909f, -0.07511088f, 0.01047345f, 0.13078429f, -0.03146425f, 0.02700837f, -0.00492243f, 0.02878750f, 
    0.10951517f, 0.07437421f, -0.04471115f, 0.01918254f, 0.40646142f, -0.08597720f, 0.13372132f, 0.07705159f, 
    0.34547484f, -0.06565000f, -0.00683623f, 0.02911405f, -0.01013142f, 0.05964595f, -0.06001221f, 0.19356443f, 
    0.06726396f, -0.03265928f, -0.13527501f, -0.02005212f, 0.14627258f, 0.05082467f, 0.06877714f, -0.02200099f, 
    -0.11111859f, -0.01921528f, 0.22093213f, 0.19370855f, 0.14271337f, -0.17417811f, 0.02119104f, 0.14014371f, 
    -0.06051123f, -0.08040196f, -0.05168413f, -0.11694876f, 0.03463692f, -0.03585921f, 0.10450813f, -0.10319383f, 
    -0.10243392f, 0.05216976f, -0.01985212f, -0.13161530f, 0.16496068f, -0.48497915f, -0.03237911f, 0.17679901f, 
    -0.06126391f, -0.11009529f, -0.04994446f, -0.07103039f, 0.01637250f, -0.03973694f, 0.11072937f, 0.09290002f, 
    -0.18677984f, 0.07770379f, -0.06799974f, 0.07898824f, -0.03575783f, -0.06770580f, -0.02783594f, 0.03094385f, 
    0.62636340f, -0.04074951f, -0.05609242f, 0.03641536f, -0.40125549f, -0.09741229f, -0.06800365f, -0.02035003f, 
    0.03066355f, 0.10231803f, -0.11121687f, -0.09085587f, 0.04350409f, -0.04931607f, -0.04731854f, 0.00760515f, 
    -0.00635993f, 0.11191486f, 0.05666863f, 0.02206637f, 0.13063598f, 0.15205476f, 0.23129705f, 0.08693684f, 
    0.18922473f, -0.04292198f, -0.09220278f, -0.01027775f, 0.03641735f, -0.06258950f, -0.01804538f, 0.05848194f, 
    0.13233249f, 0.03155039f, -0.16442183f, 0.04655543f, -0.01691118f, -0.05627008f, -0.06980572f, 0.03804484f, 
    0.52376574f, 0.29993331f, 0.23081249f, 0.18644963f, 0.11653367f, 0.07003459f, -0.00556200f, 0.28085330f, 
    -0.01084368f, 0.05190909f, 0.12915154f, -0.12065378f, -0.00019319f, 0.05240972f, -0.11723715f, 0.04701142f, 
    0.01587049f, -0.13620853f, 0.19919366f, -0.04868418f, 0.27611622f, 0.02903490f, 0.20585573f, 0.02393890f, 
    0.12653583f, -0.01833797f, -0.04238513f, 0.02135063f, 0.11078285f, -0.04586436f, 0.04158690f, 0.00074079f, 
    -0.02863229f, 0.03340667f, 0.09665252f, 0.03281605f, 0.01211721f, -0.14116943f, -0.03086713f, 0.00132267f, 
    0.36814576f, -0.02014394f, -0.11853871f, -0.25972682f, -0.08594558f, 0.00397098f, -0.13357559f, 0.04239223f, 
    -0.00784106f, -0.12689389f, 0.07287593f, -0.16342705f, 0.03556371f, 0.02365408f, -0.08074578f, -0.09281963f, 
    0.10403238f, -0.03363406f, 0.08613290f, -0.11730938f, -0.22981155f, 0.10986722f, -0.07713532f, -0.09246527f, 
    0.18388493f, 0.02995407f, 0.06883601f, -0.06768271f, 0.01279652f, 0.09451774f, 0.11771762f, 0.08850498f, 
    -0.01002329f, 0.04450327f, -0.02512621f, 0.11084953f, -0.03406109f, -0.01394497f, 0.21465711f, -0.03468155f, 
    -0.30633557f, 0.03626386f, 0.37218809f, -0.07492537f, 0.21768925f, 0.04472711f, 0.02025260f, -0.02999848f, 
    0.08241552f, -0.10556308f, -0.11766350f, -0.03260112f, 0.00794469f, 0.09520244f, 0.07423000f, -0.05270178f, 
    -0.03403705f, 0.04578610f, -0.00911410f, 0.04378293f, -0.42629746f, 0.12216713f, -0.08081693f, 0.07408833f, 
    0.22961082f, 0.22340627f, 0.09349976f, 0.14275244f, 0.07033562f, 0.14631672f, 0.18224555f, -0.02263754f, 
    0.09240752f, -0.01281195f, 0.19783773f, 0.13247970f, 0.06281887f, 0.06219481f, 0.19317064f, 0.05731450f, 
    0.03721587f, 0.06809420f, 0.16714136f, -0.08186279f, 0.17620406f, -0.18396389f, -0.00888229f, 0.13533826f, 
    -0.02600376f, -0.02308209f, 0.09119751f, -0.11247505f, 0.01593618f, -0.10589660f, -0.06506184f, -0.14819169f, 
    -0.07570090f, -0.17369792f, 0.09241174f, 0.01019080f, 0.53158891f, -0.01070016f, 0.17513461f, -0.05993349f, 
    0.35291898f, -0.10061024f, 0.00015331f, -0.01138747f, 0.03741865f, 0.02186863f, 0.00933172f, 0.13548851f, 
    0.03252099f, -0.00795349f, 0.02755549f, 0.16271074f, -0.11151494f, -0.00761477f, -0.02339307f, 0.03520297f, 
    -0.04280858f, -0.03586305f, 0.00693744f, 0.02413212f, -0.03788813f, 0.01879580f, -0.04421150f, -0.03616437f, 
    0.00057335f, -0.02614029f, 0.01248089f, -0.00706269f, -0.02503922f, -0.00721837f, 0.02168990f, -0.03881372f, 
    -0.03227091f, -0.00561110f, 0.03776444f, -0.02251363f, 0.00693187f, -0.01249757f, 0.00291371f, -0.04773466f, 
    0.03261862f, 0.02982884f, -0.02582680f, -0.04442363f, -0.01388464f, -0.03467374f, 0.02778046f, 0.01129066f, 
    -0.00545108f, -0.00264951f, -0.03973329f, -0.01880642f, -0.01094016f, -0.03207854f, -0.01447199f, 0.03377618f, 
    -0.02837552f, -0.02684917f, -0.02775455f, -0.03080490f, -0.03945207f, -0.03003613f, 0.02408811f, 0.00842234f, 
    -0.04334804f, 0.02189736f, 0.02480269f, 0.01985886f, -0.01120309f, -0.02368033f, -0.02199583f, -0.04286611f, 
    -0.01517077f, -0.00953816f, -0.00160138f, 0.02688570f, -0.04269486f, -0.03052969f, 0.02405868f, -0.00920244f, 
    -0.00222097f, 0.03216714f, -0.00410397f, 0.02085574f, -0.03091059f, 0.03403722f, -0.02955543f, 0.02110064f, 
    0.01818042f, -0.03414533f, 0.00885877f, -0.02187797f, -0.04079910f, -0.00909056f, 0.03121203f, -0.04508636f, 
    -0.02140570f, 0.01113633f, 0.00738791f, 0.02630495f, -0.01709521f, -0.02118834f, -0.04279059f, 0.01256710f, 
    -0.03739870f, 0.01023918f, -0.00660506f, -0.02796408f, -0.03480799f, 0.00269232f, -0.03949442f, -0.02994994f, 
    0.02898277f, 0.02718783f, 0.02117609f, 0.03134338f, -0.01458394f, -0.03936779f, 0.00899948f, -0.01409334f, 
    0.00518140f, -0.03321092f, 0.01127748f, 0.00098285f, -0.01268497f, 0.02637795f, -0.02114656f, -0.00254796f, 
    0.03620055f, -0.02024699f, -0.02317455f, -0.02229111f, 0.02972947f, -0.03370651f, 0.01153785f, 0.03721842f, 
    0.01940960f, -0.03579056f, 0.00474602f, 0.02705389f, -0.01861477f, -0.03730148f, -0.02757593f, 0.00822655f, 
    -0.01953514f, 0.01000852f, -0.03962796f, -0.02751564f, -0.04209539f, 0.01372542f, 0.00387251f, -0.03169535f, 
    -0.03071893f, -0.02625953f, -0.01179727f, -0.02415600f, -0.03755517f, 0.01787655f, -0.01033080f, -0.01825324f, 
    -0.00051765f, -0.03359499f, -0.02429892f, -0.02758762f, 0.00451172f, -0.02695601f, 0.00796839f, -0.01961108f, 
    0.00563606f, -0.03536156f, 0.01496624f, 0.01917958f, -0.03656677f, 0.02872925f, -0.01716700f, 0.01715602f, 
    -0.01172181f, -0.03216719f, -0.03058534f, -0.04494218f, 0.01168185f, 0.01623256f, 0.00528028f, -0.04427183f, 
    -0.02455247f, -0.04001518f, -0.02120553f, 0.03190366f, 0.03011273f, 0.02054280f, 0.01162446f, -0.03892306f, 
    0.01265093f, -0.02266715f, 0.02402311f, 0.02682226f, 0.01333999f, -0.00448606f, 0.02823461f, 0.01737417f, 
    0.03697541f, -0.02344220f, 0.00430271f, 0.00831835f, -0.00548475f, -0.01652208f, -0.02258808f, -0.02283645f, 
    -0.02947262f, -0.01355786f, -0.02676238f, -0.00950709f, 0.02173931f, 0.01052406f, -0.04839720f, 0.00825872f, 
    -0.04735240f, -0.03266081f, 0.03220106f, -0.03494925f, 0.01362195f, -0.03422555f, -0.04350646f, -0.01004246f, 
    0.01223550f, -0.02341594f, -0.00741441f, -0.02058740f, 0.01244170f, 0.01942138f, -0.04480977f, -0.01117987f, 
    -0.01876873f, -0.03922831f, -0.00904261f, 0.02051386f, -0.02129464f, -0.04321443f, -0.01132973f, 0.01033645f, 
    0.01981672f, -0.00088635f, -0.02946369f, -0.03584026f, -0.00924614f, -0.03755835f, 0.01565232f, -0.04357878f, 
    0.00593540f, -0.01204680f, 0.00629648f, -0.03535274f, -0.04303733f, -0.02049604f, -0.01393877f, 0.00478304f, 
    0.01618892f, -0.03845723f, 0.01553450f, -0.00888991f, -0.02577799f, -0.01452238f, -0.01671858f, 0.02007258f, 
    -0.02592037f, -0.01267907f, -0.01882671f, -0.01771673f, -0.03052370f, -0.02996227f, 0.00483854f, 0.02135112f, 
    -0.00042389f, -0.00307695f, 0.03025563f, -0.01051226f, -0.02819810f, 0.01998673f, -0.00992117f, 0.01143102f, 
    -0.03520581f, -0.02580430f, -0.00104306f, 0.00216387f, 0.02346355f, -0.01472461f, -0.00036047f, 0.02327855f, 
    -0.01929401f, -0.02650051f, -0.04019682f, 0.01008243f, -0.02287393f, 0.03078637f, -0.00002892f, 0.02527661f, 
    0.00275407f, -0.02097481f, 0.01333744f, 0.01822222f, -0.02481267f, -0.02881651f, 0.02063136f, 0.02673288f, 
    -0.03643256f, -0.02520523f, -0.01350682f, -0.00978006f, -0.01273170f, 0.03449733f, 0.03297336f, -0.01482587f, 
    -0.04318857f, -0.02267118f, -0.03864706f, -0.00510750f, -0.00986977f, -0.00991401f, 0.01747462f, -0.00091327f, 
    0.00163710f, -0.01238509f, -0.01860684f, -0.04006099f, 0.03969848f, 0.00333545f, -0.00865860f, -0.02806585f, 
    -0.00333721f, -0.04482081f, -0.01272261f, -0.01343269f, 0.02278182f, -0.03340077f, 0.03426478f, -0.00799371f, 
    -0.02221954f, 0.01111897f, 0.00308659f, -0.02134093f, -0.00157417f, -0.00851300f, -0.01801005f, -0.03047897f, 
    0.01236428f, 0.02076729f, 0.01079976f, 0.02841260f, -0.00192356f, -0.03319341f, -0.02118644f, 0.02938621f, 
    0.04101191f, -0.03874343f, 0.02688762f, -0.01053634f, -0.03046604f, 0.00552702f, -0.02232116f, 0.01020461f, 
    0.02026205f, 0.02813455f, -0.02615135f, -0.02137016f, -0.00815771f, -0.02072864f, -0.01203309f, 0.02876615f, 
    -0.02897785f, 0.02752220f, -0.04275094f, -0.02095939f, -0.00573663f, 0.00187737f, -0.01278945f, 0.01630695f, 
    0.01925016f, -0.01887963f, -0.02844513f, 0.00116936f, -0.04112073f, -0.00740136f, -0.02555741f, 0.00320198f, 
    0.01235432f, 0.01703417f, 0.01310881f, -0.03422878f, -0.03734170f, -0.04622382f, 0.02000208f, 0.01433884f, 
    0.01707089f, 0.00634667f, 0.03490267f, -0.04171492f, 0.01163765f, -0.02718343f, 0.00319978f, -0.01921775f, 
    -0.04012106f, -0.00042602f, 0.02134219f, 0.00427003f, 0.00180033f, 0.03045987f, 0.02069256f, 0.00084924f, 
    -0.02354871f, -0.03638646f, -0.02032340f, -0.03577551f, -0.03592202f, 0.03102218f, 0.03196669f, -0.03820503f, 
    0.02116890f, -0.00447258f, 0.02128550f, -0.00377753f, 0.00436787f, -0.01821261f, -0.01863329f, 0.03015275f, 
    -0.00951849f, -0.01193155f, 0.02974980f, 0.00806752f, -0.03382516f, -0.01893164f, 0.00158267f, -0.01094415f, 
    -0.00737309f, 0.01847052f, 0.00965751f, 0.01447084f, -0.01434475f, -0.01130454f, -0.01564276f, 0.01001911f, 
    -0.01445052f, 0.01511366f, -0.00208327f, 0.01993852f, 0.02659280f, -0.02259594f, -0.03582846f, 0.00391209f, 
    0.01952684f, 0.01179813f, 0.01179847f, -0.01309678f, 0.04410806f, -0.03150750f, -0.03008212f, 0.01486366f, 
    -0.02469888f, 0.02887668f, -0.04293278f, 0.01164831f, -0.01067363f, -0.02122770f, -0.03020206f, 0.02997565f, 
    0.00982615f, -0.04579891f, 0.00146926f, -0.03289410f, 0.00047535f, 0.00550016f, -0.02976120f, -0.00064599f, 
    0.02260106f, 0.03658670f, 0.02208710f, -0.03803743f, -0.01201706f, 0.02781660f, 0.01536893f, 0.00521941f, 
    -0.00448648f, -0.03474741f, 0.00244660f, 0.02099905f, -0.04648706f, 0.03076324f, 0.00579230f, -0.01999752f, 
    -0.03183170f, 0.01100011f, -0.00554019f, -0.03734971f, -0.00682455f, -0.01322267f, -0.02495737f, -0.04178042f, 
    -0.03971248f, -0.04367736f, 0.01659335f, 0.01030639f, 0.03250428f, 0.00105837f, -0.02435976f, -0.03964759f, 
    0.00224601f, 0.03286362f, -0.00820354f, 0.01128871f, -0.01360457f, -0.03200136f, 0.00845981f, 0.01397838f, 
    0.02542168f, -0.03700470f, 0.00744649f, -0.02437688f, -0.03985263f, -0.02701830f, 0.00715851f, 0.02666990f, 
    0.01617576f, -0.00397747f, 0.02739275f, -0.01675929f, 0.00718383f, 0.02843313f, 0.03356348f, 0.02554928f, 
    -0.01127533f, 0.02072903f, 0.02414181f, -0.02627988f, 0.02764658f, -0.00196693f, -0.02727536f, 0.03012267f, 
    0.01968787f, -0.00067593f, -0.00026271f, 0.00122340f, -0.03838201f, -0.01689567f, 0.03006468f, 0.02131172f, 
    0.03579384f, 0.00157204f, -0.02939290f, 0.02706422f, 0.02578408f, 0.03292818f, -0.03572485f, -0.03955046f, 
    0.00432897f, -0.00768393f, -0.03180297f, 0.00633057f, -0.03595098f, -0.03162832f, 0.01986092f, -0.04167464f, 
    -0.04295578f, -0.01367073f, -0.04146851f, -0.00633990f, 0.00253849f, 0.03007110f, 0.02905643f, 0.02079798f, 
    0.03161412f, -0.02981678f, 0.02880213f, -0.03066127f, 0.00555710f, -0.03028951f, 0.00380943f, -0.01911015f, 
    -0.01228966f, 0.01839150f, -0.01512393f, 0.01628854f, 0.02881913f, 0.02979892f, -0.02581843f, -0.04030551f, 
    -0.00417883f, 0.02012726f, 0.02560266f, -0.02880025f, 0.01899520f, -0.03176404f, -0.01327670f, 0.01824870f, 
    -0.02364239f, 0.00939946f, 0.00170314f, -0.00197507f, -0.04586342f, -0.03678212f, -0.02147633f, -0.02274369f, 
    0.03024470f, -0.02448992f, -0.00990749f, -0.04518951f, 0.03166627f, 0.00217129f, 0.00412752f, 0.00045377f, 
    0.02271425f, -0.03570675f, 0.02534230f, 0.03825069f, -0.04084861f, 0.01370102f, 0.02073456f, -0.02907473f, 
    0.00478509f, 0.01510335f, -0.00185083f, -0.03888148f, -0.00311885f, 0.00209667f, -0.03472276f, 0.00965493f, 
    0.02564215f, -0.02282241f, 0.03073586f, 0.00042125f, 0.03541582f, 0.02260746f, -0.01976932f, -0.01691050f, 
    0.03172513f, -0.01243435f, 0.00381538f, 0.01586346f, 0.00052796f, -0.03117536f, -0.00884690f, 0.01636051f, 
    0.01962032f, 0.03359289f, -0.03320158f, 0.01376511f, -0.04998842f, -0.03929354f, -0.02563041f, -0.00062879f, 
    0.03024056f, -0.03507235f, 0.02776648f, -0.02371079f, 0.02702706f, 0.00668187f, 0.02566212f, 0.00464338f, 
    -0.03386351f, -0.01536688f, -0.03427927f, -0.03092852f, 0.01580669f, 0.01093884f, -0.01598690f, -0.01710336f, 
    -0.00780054f, -0.00112195f, -0.01991604f, -0.02553098f, -0.00297646f, -0.01592718f, -0.00878666f, -0.01238758f, 
    0.02980935f, 0.02070285f, 0.00725114f, -0.00950430f, 0.01681334f, -0.01746028f, -0.02369741f, -0.03378402f, 
    0.02938375f, 0.03377976f, -0.00856956f, -0.00084743f, 0.00814365f, -0.04204497f, 0.03272263f, 0.00532614f, 
    -0.02955889f, -0.00058284f, -0.04006372f, 0.00794828f, -0.01384235f, -0.02224839f, 0.02712636f, 0.01203144f, 
    -0.01754211f, -0.02124145f, -0.01496965f, 0.03023653f, 0.02867049f, -0.01175770f, -0.02808918f, -0.04013631f, 
    0.00316212f, -0.04108564f, 0.01767318f, -0.03334619f, 0.00900295f, -0.01438632f, 0.02984218f, -0.00813062f, 
    -0.04439206f, 0.00622010f, 0.01637942f, 0.02559816f, -0.03150522f, 0.00582758f, -0.02522374f, -0.00620743f, 
    0.01785389f, -0.03599617f, 0.02785561f, 0.00253184f, -0.00077566f, -0.02812416f, -0.01801101f, 0.00587803f, 
    0.03017100f, -0.01650633f, 0.00064845f, -0.01886103f, -0.00749726f, -0.04054898f, -0.00313389f, -0.00380567f, 
    0.02480111f, -0.03670790f, 0.03709900f, -0.04755726f, -0.03028416f, -0.03558147f, 0.01059365f, 0.00058915f, 
    0.01732425f, -0.01010590f, 0.02198769f, -0.00362002f, -0.01140902f, 0.02151532f, -0.00903616f, 0.01648805f, 
    0.01093631f, 0.03159928f, -0.03786618f, 0.00521490f, 0.00921553f, 0.01410209f, 0.00092071f, 0.00534531f, 
    -0.00064693f, -0.01832394f, -0.02239119f, -0.01132784f, -0.02434107f, -0.01556960f, -0.03598039f, -0.02961556f, 
    -0.04305674f, 0.00761881f, -0.01388840f, 0.02818235f, 0.01597034f, 0.02748382f, -0.01813014f, 0.02775522f, 
    0.01065114f, -0.02651531f, -0.00743223f, 0.02307284f, -0.03578588f, -0.03223032f, 0.02859202f, 0.01045465f, 
    0.00086415f, 0.02409818f, -0.00082385f, -0.03523957f, -0.02960785f, 0.02694976f, -0.00954122f, -0.02019343f, 
    0.02858258f, 0.02064293f, -0.02832412f, -0.03372004f, 0.02002081f, -0.03405066f, -0.03783503f, -0.00223137f, 
    0.01340914f, -0.00997246f, -0.00896593f, -0.01707595f, 0.00592877f, 0.00844452f, -0.03802966f, -0.04527887f, 
    0.00761179f, -0.00323802f, -0.00926477f, 0.03333938f, -0.02713841f, 0.00711742f, 0.03124734f, 0.00375272f, 
    0.02109593f, 0.02466268f, -0.02702576f, 0.02602081f, 0.01074980f, 0.00220336f, -0.03799921f, 0.03127654f, 
    -0.00223327f, -0.02164703f, -0.01781331f, -0.03525072f, 0.00789544f, 0.01414697f, -0.00955242f, -0.02618322f, 
    -0.02929629f, 0.01653685f, -0.02568899f, 0.00917363f, 0.00860269f, -0.00709572f, -0.01898097f, -0.03772457f, 
    -0.03133008f, -0.00289987f, -0.01797309f, -0.02281759f, -0.00530364f, 0.02681884f, 0.00129414f, 0.02417557f, 
    -0.02555651f, 0.03647835f, -0.03737067f, 0.01994788f, -0.02397117f, 0.00152354f, 0.02446618f, 0.00799196f, 
    0.02018879f, -0.03609006f, -0.00987326f, -0.01535359f, -0.00746531f, -0.00479462f, -0.02625101f, 0.01204937f, 
    -0.00564930f, -0.04170128f, -0.01104029f, -0.03616463f, -0.02897000f, -0.03323866f, 0.00911595f, -0.00258044f, 
    -0.00702135f, -0.03577619f, 0.00481481f, -0.00455409f, -0.01853614f, -0.03987147f, 0.02495447f, -0.03130852f, 
    0.02997694f, -0.00084965f, -0.03916474f, -0.02560924f, 0.00000541f, 0.01323662f, -0.01674643f, -0.03598911f, 
    0.03500764f, -0.03520966f, 0.02650354f, -0.04327559f, -0.02505557f, -0.01391974f, -0.00039194f, 0.01297718f, 
    -0.02833856f, 0.00264395f, 0.01569281f, 0.02063048f, -0.01225881f, -0.00749219f, 0.01084210f, -0.03959373f, 
    0.03293645f, 0.03262795f, -0.03671655f, 0.01441230f, -0.02637383f, 0.00307029f, 0.01819291f, -0.01887124f, 
    0.03155535f, -0.02638149f, -0.04114641f, -0.02008295f, -0.01388407f, 0.02536801f, 0.02615990f, -0.01298679f, 
    -0.00206400f, -0.03660017f, 0.00719323f, 0.02437392f, -0.04074303f, -0.00572897f, -0.02950133f, -0.03002266f, 
    -0.04539200f, -0.00248280f, -0.00136432f, -0.03241128f, 0.02784207f, -0.01403401f, -0.02426810f, -0.00412688f, 
    0.02683134f, 0.02154855f, -0.04226143f, 0.03071564f, -0.03863572f, -0.04217407f, 0.02793040f, -0.01119902f, 
    0.02353700f, 0.02557307f, -0.01588433f, -0.01262463f, -0.04123772f, -0.03209133f, -0.01656947f, -0.02913490f, 
    0.01943697f, -0.00000946f, -0.01582446f, 0.01870974f, -0.02047266f, -0.01656286f, 0.02096674f, -0.03627161f, 
    0.01710823f, 0.03133580f, -0.02320682f, 0.00019890f, -0.02168332f, -0.00929398f, 0.03242545f, -0.02609104f, 
    0.01136250f, 0.01457437f, 0.01008538f, -0.03616055f, 0.02329385f, -0.03026347f, -0.02414978f, 0.01576451f, 
    -0.02741249f, 0.01431001f, -0.00662246f, 0.00761382f, 0.02842898f, 0.02821057f, -0.00065698f, -0.00086196f, 
    -0.03358088f, -0.01413052f, 0.01865630f, -0.01131153f, -0.00916444f, 0.01020379f, 0.00652528f, -0.00122062f, 
    0.01947290f, -0.01347984f, 0.00419369f, -0.02341856f, -0.00116591f, 0.01078501f, 0.02724958f, 0.00393249f, 
    0.03188075f, 0.01259698f, 0.01885102f, 0.02147615f, -0.02903543f, -0.00652452f, 0.00050601f, -0.00169715f, 
    -0.01625101f, -0.02112142f, 0.02806641f, 0.01173545f, -0.00759391f, -0.03764290f, -0.01830195f, 0.02916246f, 
    -0.00973393f, -0.03790383f, -0.01101397f, 0.00475302f, 0.02714351f, -0.01491155f, 0.02916428f, -0.01465912f, 
    -0.03303749f, -0.01115928f, -0.01033788f, -0.02567002f, -0.01978777f, 0.03392204f, -0.00055279f, 0.01347893f, 
    0.00854660f, -0.01147810f, -0.03852786f, 0.00821356f, 0.02464784f, 0.03528174f, -0.01233402f, -0.03471933f, 
    -0.02154347f, -0.00598441f, -0.02248217f, 0.01618454f, -0.01820817f, 0.00342542f, 0.03426329f, -0.04088954f, 
    0.00183488f, -0.02306797f, -0.04098866f, 0.00934618f, -0.02634129f, -0.01735259f, -0.04346348f, 0.01423354f, 
    -0.04499619f, -0.01895699f, 0.01724585f, 0.01241620f, -0.03507313f, 0.00772063f, -0.02824822f, 0.02172964f, 
    0.03473010f, -0.01372461f, -0.00768692f, 0.03004999f, 0.01729247f, -0.02817243f, 0.03541727f, 0.00958605f, 
    -0.04443904f, -0.02188664f, -0.01266459f, -0.03784873f, 0.01163902f, -0.04789339f, -0.01914871f, 0.01232089f, 
    -0.00722683f, -0.02166526f, -0.01282869f, 0.02946530f, -0.00665517f, -0.02781443f, -0.02902873f, 0.01811382f, 
    0.01111020f, 0.02447183f, -0.03731700f, 0.01640171f, 0.01532495f, -0.03212957f, -0.00604021f, 0.00012063f, 
    -0.02013240f, -0.00133915f, -0.01812554f, 0.00097578f, -0.02662873f, 0.01788495f, -0.02146824f, -0.04251093f, 
    -0.02655220f, -0.00095380f, -0.04044975f, 0.02030748f, -0.02226632f, -0.01748316f, 0.00360719f, 0.00849469f, 
    -0.00143040f, -0.01913911f, -0.03904374f, -0.03651601f, -0.02793556f, 0.02403967f, -0.00403658f, -0.03950965f, 
    0.01620368f, 0.01245123f, 0.01906302f, -0.00723726f, -0.03506692f, -0.00417815f, -0.01473267f, 0.02277137f, 
    -0.01321745f, 0.00619315f, -0.02994883f, -0.01858811f, 0.00557137f, 0.01472531f, 0.00545768f, 0.01245527f, 
    -0.02876465f, 0.00145825f, 0.03501447f, -0.00058133f, -0.04350780f, 0.03256691f, -0.02820372f, -0.02310652f, 
    -0.04479156f, -0.03150804f, -0.02093720f, -0.01722990f, 0.01853807f, -0.00065529f, 0.01602350f, -0.00963760f, 
    -0.01973165f, -0.03059037f, -0.04013183f, 0.00859951f, -0.01250943f, -0.02108963f, -0.01260603f, 0.02935249f, 
    0.01137919f, -0.01992267f, -0.02519911f, 0.01994811f, -0.02143172f, -0.03268836f, 0.00029574f, -0.02770197f, 
    0.01576003f, 0.02438426f, -0.03847130f, -0.00324438f, 0.02080184f, 0.02432927f, 0.00171352f, -0.04094836f, 
    -0.02753255f, -0.04029945f, 0.02303654f, 0.02442876f, 0.01064065f, 0.00619646f, 0.00600828f, 0.00990574f, 
    -0.03268355f, -0.03577679f, 0.02010417f, 0.01681842f, 0.00333837f, -0.03155184f, -0.02286301f, 0.00217070f, 
    0.01788042f, 0.01834453f, -0.02630359f, 0.03789178f, -0.00322124f, -0.02483129f, 0.00235546f, 0.00575274f, 
    0.02933448f, 0.01458534f, -0.01943312f, -0.00293047f, 0.03012815f, -0.00980862f, 0.01653423f, 0.00998744f, 
    -0.03519731f, 0.03064075f, -0.00698983f, 0.02228723f, -0.01721764f, 0.02669606f, 0.02924949f, 0.02032571f, 
    -0.02192273f, -0.01289680f, 0.00628341f, 0.01092600f, 0.02224076f, 0.00763098f, 0.01343704f, -0.00518075f, 
    0.02132929f, -0.01755806f, -0.00740804f, -0.03637752f, -0.00692966f, 0.01882316f, -0.04486931f, 0.01436030f, 
    -0.01469543f, 0.02246088f, -0.02752144f, -0.00668650f, -0.02129583f, 0.00945791f, 0.01185663f, -0.02962361f, 
    -0.01799228f, -0.03639856f, 0.01837329f, -0.00586610f, -0.00585922f, -0.04263080f, 0.03266689f, 0.03106550f, 
    -0.02687463f, -0.00471318f, -0.02755284f, 0.02084957f, -0.01776434f, 0.03204788f, -0.00124861f, 0.01917188f, 
    -0.02714195f, -0.02951277f, -0.01935522f, -0.04198231f, -0.03241219f, -0.01547108f, -0.03450953f, 0.02819144f, 
    0.03034427f, 0.00069682f, 0.02396822f, -0.01081589f, -0.01411547f, 0.02429306f, 0.00662515f, 0.03787396f, 
    -0.03761569f, 0.00234862f, -0.04158958f, -0.02288733f, 0.00896783f, -0.02012132f, -0.03349620f, 0.02339778f, 
    0.02946076f, -0.02476158f, -0.02776640f, 0.01294772f, -0.00353505f, 0.01070725f, -0.04135027f, 0.01840379f, 
    -0.01425624f, -0.00772063f, 0.03451221f, -0.00837722f, -0.00344800f, 0.02067827f, 0.01864837f, -0.02861105f, 
    0.06860318f, -0.06883264f, 0.00734919f, -0.17628923f, 0.16273810f, -0.00177696f, 0.05973758f, 0.12131705f, 
    0.08196347f, 0.05675920f, 0.04064708f, 0.15759163f, 0.00204255f, -0.00122005f, -0.03018198f, 0.10119689f, 
    -0.00043539f, 0.04251195f, -0.11600422f, 0.16642296f, -0.59471095f, 0.35131800f, 0.04625970f, -0.01612175f, 
    0.28711680f, -0.04168937f, -0.01680609f, -0.08091877f, 0.10484839f, -0.01782094f, 0.08634043f, -0.05117107f, 
    0.03308284f, -0.08003820f, 0.10010842f, 0.07224780f, 0.05238773f, 0.00641812f, 0.11222757f, -0.07229043f, 
    0.06565510f, -0.19391271f, 0.15332492f, 0.31628454f, -0.09513109f, -0.03710578f, -0.01097509f, -0.04161466f, 
    -0.09939550f, -0.07041125f, 0.03300145f, -0.00264921f, 0.06778505f, 0.11272807f, 0.09566016f, 0.03905952f, 
    -0.08128552f, -0.13135204f, 0.01243177f, -0.00408265f, -0.02009187f, 0.13004205f, 0.02341707f, -0.11227654f, 
    -0.16924486f, 0.18330261f, 0.00568276f, -0.04135406f, 0.04593371f, -0.02143721f, 0.02923376f, -0.06406768f, 
    -0.00319377f, 0.02453925f, -0.06565375f, 0.04867902f, 0.14654364f, -0.01865377f, 0.04873666f, -0.01227558f, 
    -0.02974726f, 0.26041564f, -0.03578999f, -0.11402342f, 0.03266301f, 0.12085716f, -0.01012571f, -0.01092121f, 
    0.05032249f, -0.01383357f, 0.07947540f, -0.00852839f, -0.11393447f, 0.15183096f, 0.05558898f, 0.05457808f, 
    0.10564419f, 0.11944914f, -0.06999414f, 0.07242002f, -0.11234820f, 0.05638694f, 0.39160112f, 0.01225942f, 
    0.15203565f, 0.14285111f, 0.20605968f, 0.07533136f, -0.08387823f, 0.02447538f, 0.04084107f, 0.03223711f, 
    -0.13730496f, 0.07322401f, -0.08718897f, 0.00415382f, 0.05733151f, 0.01978313f, -0.13647619f, -0.01833997f, 
    0.10617232f, 0.10134152f, -0.18663225f, -0.12100842f, 0.04512329f, 0.11471011f, 0.01117477f, -0.11236233f, 
    0.14516507f, -0.13381523f, 0.06553966f, 0.22318567f, 0.18302032f, 0.00989908f, 0.10000054f, -0.08191032f, 
    -0.03442745f, -0.14405683f, -0.10632695f, -0.03161869f, -0.59562284f, 0.08029176f, -0.07375875f, 0.10809960f, 
    0.27663326f, -0.13333412f, -0.22748815f, -0.04286911f, 0.13905807f, -0.12925275f, 0.12444112f, -0.04815155f, 
    0.07669652f, -0.12154137f, -0.10517919f, -0.01742152f, -0.10338145f, -0.05712505f, -0.09571472f, 0.05377144f, 
    -0.30602291f, 0.15778929f, -0.39540479f, -0.00667121f, -0.05777228f, 0.12966946f, 0.07500146f, -0.11032958f, 
    0.06472915f, 0.09110946f, -0.06552433f, 0.12337627f, -0.01199595f, -0.05057403f, 0.05598105f, -0.06564608f, 
    0.06731511f, 0.01734042f, -0.00507239f, 0.09272610f, -0.07989950f, -0.25628352f, 0.05472934f, 0.05803408f, 
    -0.00416169f, 0.09640703f, 0.18081041f, -0.01343597f, -0.15739177f, -0.16176213f, -0.02797374f, 0.01123170f, 
    0.09459002f, 0.21803355f, 0.04817253f, -0.04709490f, 0.02858182f, 0.05386306f, -0.05639616f, -0.11357322f, 
    -0.15649520f, 0.02464183f, -0.28427052f, 0.12588668f, -0.19123393f, -0.05008783f, 0.11039602f, -0.15635127f, 
    0.00717348f, -0.06070187f, 0.00620805f, -0.07687152f, 0.10924717f, 0.01166559f, 0.06104473f, -0.02399160f, 
    0.15818760f, -0.08428235f, 0.04814144f, -0.00305561f, 0.17777301f, -0.17992611f, -0.19789775f, 0.09244768f, 
    0.00624673f, 0.02429431f, 0.10854147f, 0.00797709f, -0.05346078f, 0.07281015f, -0.02563187f, 0.06247860f, 
    0.03732934f, 0.03997818f, -0.03313709f, 0.17901392f, 0.01305246f, 0.06081381f, 0.21712585f, 0.10739541f, 
    -0.35086185f, 0.15021913f, 0.12486795f, -0.01172241f, -0.02497194f, 0.12925397f, -0.00825756f, -0.08292253f, 
    0.05407584f, 0.03100208f, -0.02375500f, 0.08534015f, -0.08594915f, 0.05902911f, -0.07054574f, 0.06273898f, 
    0.05485140f, -0.10266418f, -0.18208890f, 0.02842994f, -0.13647939f, 0.13417286f, 0.14855027f, -0.03218475f, 
    0.01151793f, 0.31417918f, 0.31731141f, 0.09461690f, -0.19118710f, -0.05768256f, 0.03718031f, -0.04142384f, 
    0.08633328f, -0.02131325f, -0.05034474f, -0.08534596f, -0.02705686f, -0.01670719f, 0.05723295f, -0.18657665f, 
    -0.02788250f, 0.24087425f, 0.11105988f, 0.14541745f, -0.10159244f, 0.07729865f, 0.08592092f, -0.12617296f, 
    0.05392054f, 0.01388970f, 0.06719029f, 0.10515641f, 0.02850481f, -0.10144593f, -0.03188743f, -0.01761361f, 
    -0.02380713f, 0.01728171f, 0.11209849f, -0.00238381f, -0.04213673f, 0.16167542f, 0.22169232f, 0.05789327f, 
    0.09133551f, 0.01280442f, 0.10317213f, 0.00173877f, 0.11341640f, 0.14969793f, -0.00969246f, 0.13595068f, 
    -0.07801791f, -0.17714085f, 0.02919163f, -0.17675981f, 0.04156917f, -0.03461238f, 0.19907637f, -0.08755364f, 
    -0.03938347f, -0.04821494f, 0.19507307f, 0.00721749f, 0.31504232f, -0.03159579f, 0.05629525f, 0.07585818f, 
    -0.04854884f, 0.06948003f, -0.00822142f, -0.01429276f, 0.03224110f, -0.06118414f, -0.06568954f, 0.00896561f, 
    0.06726577f, 0.02557233f, -0.02512700f, -0.02230189f, -0.66608006f, 0.18785021f, -0.00336969f, -0.11720920f, 
    -0.06478085f, -0.04634461f, -0.22632961f, 0.09357802f, -0.01955765f, 0.08011047f, 0.20181760f, 0.03264483f, 
    -0.04176369f, 0.03520339f, 0.01101086f, -0.11732110f, -0.02124595f, 0.04262039f, 0.16466628f, -0.09930692f, 
    0.24528074f, 0.31069240f, -0.10574818f, -0.17665185f, 0.19459186f, -0.07886999f, 0.04065654f, 0.11396873f, 
    0.03472948f, 0.04792896f, 0.04229702f, -0.02544468f, -0.04841047f, -0.01624447f, -0.03511605f, -0.02140152f, 
    -0.09042450f, 0.00991862f, 0.17370532f, 0.01856606f, -0.08809086f, 0.07279460f, 0.14999945f, -0.09337299f, 
    -0.13632420f, 0.04069459f, 0.17901835f, -0.13484323f, -0.00720331f, 0.00013072f, -0.07878916f, 0.02957284f, 
    0.02514656f, 0.00909424f, -0.03645651f, -0.24385250f, -0.07337668f, 0.11978259f, 0.03617678f, -0.07161754f, 
    -0.10085328f, -0.02402408f, -0.10467972f, -0.02189094f, 0.09559461f, -0.06414426f, -0.06658845f, -0.05904265f, 
    0.01818352f, -0.09918540f, 0.09714253f, 0.06281502f, 0.14716594f, 0.14831457f, 0.02237508f, 0.02377283f, 
    0.07129209f, 0.01270281f, -0.10680629f, 0.03199022f, 0.09347907f, -0.02917272f, -0.04456930f, -0.31085059f, 
    0.08506311f, 0.21635336f, -0.05360147f, 0.06095602f, 0.03159985f, 0.02973234f, 0.03797179f, 0.08223126f, 
    -0.04307511f, 0.12882097f, 0.04687374f, 0.08644444f, 0.05303158f, 0.05425210f, -0.18623431f, 0.06801807f, 
    -0.54499882f, 0.33123636f, -0.31103644f, 0.01100709f, -0.28284356f, -0.07478397f, -0.09513219f, 0.02404610f, 
    -0.11555680f, 0.01674615f, 0.08217650f, 0.09376311f, 0.07739304f, 0.01507285f, 0.15572795f, 0.05039991f, 
    0.06071803f, 0.08047916f, -0.15819715f, 0.13126554f, 0.03940127f, 0.20876347f, 0.02667597f, -0.22731274f, 
    -0.07093212f, 0.30299866f, 0.17746137f, -0.14179099f, -0.02044164f, -0.01986579f, 0.05838695f, 0.01228332f, 
    0.01152552f, -0.03455397f, -0.06841059f, -0.14271605f, 0.01292126f, 0.16879565f, 0.00813729f, -0.09640868f, 
    0.10258430f, 0.10137246f, -0.28792891f, 0.04251876f, 0.04213992f, 0.09302448f, -0.05713014f, -0.17205733f, 
    0.04921358f, 0.05468320f, -0.02491291f, 0.05365057f, -0.06979986f, 0.03856720f, -0.00709576f, -0.06287892f, 
    -0.02662624f, 0.04844867f, -0.08509781f, -0.00852599f, 0.02129873f, -0.03588314f, 0.03783733f, 0.01944528f, 
    -0.02088209f, 0.23588955f, 0.15822999f, 0.04170324f, -0.08129663f, 0.04304390f, 0.05134007f, -0.02759106f, 
    -0.04734699f, -0.00025592f, -0.07483582f, 0.11425018f, 0.11290657f, 0.06254803f, 0.20688117f, 0.17687510f, 
    0.41461802f, 0.09463155f, -0.05385774f, -0.15795651f, 0.34948146f, -0.07094345f, 0.08426321f, -0.09082966f, 
    -0.01037377f, -0.13695912f, -0.03207741f, -0.05036189f, 0.04596967f, 0.00276158f, 0.13882402f, 0.01711851f, 
    0.01218169f, -0.00411546f, 0.01485590f, 0.00952410f, -0.18853028f, 0.05536349f, 0.15024386f, 0.16757765f, 
    0.49971414f, -0.13071568f, 0.01389370f, 0.09104493f, 0.10165824f, 0.04494006f, 0.07981174f, -0.07105555f, 
    0.06689352f, -0.12257825f, -0.00316167f, -0.02902038f, -0.02703037f, -0.00951126f, 0.03879404f, 0.04614794f, 
    0.23099448f, 0.14106123f, 0.17825702f, -0.16021965f, -0.11565854f, 0.09946334f, 0.06695002f, 0.12546708f, 
    0.02477533f, -0.07350223f, 0.09317902f, -0.11932097f, 0.04590485f, 0.00590643f, 0.01228448f, -0.00972960f, 
    0.04926067f, -0.11530089f, 0.13267423f, -0.01354531f, -0.08798459f, 0.16728924f, 0.38911024f, 0.21755619f, 
    0.44689935f, -0.17587742f, -0.18197714f, 0.07965981f, -0.01962290f, 0.02163649f, 0.03940683f, -0.18959858f, 
    -0.16874091f, -0.04887997f, 0.02863464f, -0.08745717f, -0.02859068f, -0.02192356f, 0.00975728f, 0.06410827f, 
    -0.15545712f, -0.32787040f, -0.05656738f, -0.03905338f, 0.07946509f, 0.13546889f, 0.04141200f, 0.12031866f, 
    -0.08164120f, -0.01869024f, 0.06544823f, 0.00055165f, -0.10583341f, 0.01464787f, 0.04881669f, 0.06131442f, 
    0.01556526f, 0.04095838f, -0.01470376f, 0.06202131f, 0.16533534f, -0.01040250f, -0.06592257f, -0.11953941f, 
    -0.17920090f, 0.19940604f, 0.15400106f, 0.05301863f, -0.14321512f, 0.05231659f, 0.11876489f, -0.09135943f, 
    -0.12763567f, -0.06923082f, 0.01500309f, 0.08854473f, 0.08904935f, 0.09506185f, 0.07760690f, -0.00061200f, 
    -0.22962995f, 0.02034554f, 0.24146748f, -0.04176363f, 0.24167706f, 0.02418096f, 0.16908185f, 0.15854770f, 
    0.06258108f, -0.01861032f, 0.11064737f, -0.06875862f, -0.01971638f, -0.03024068f, 0.20538327f, -0.10800655f, 
    0.12712047f, 0.08826695f, -0.05220074f, -0.05467589f, -0.25039345f, 0.05208896f, -0.11964595f, 0.26024345f, 
    0.20565717f, 0.16757117f, 0.01081562f, -0.15884957f, 0.11667005f, -0.04389331f, -0.11171493f, 0.06003645f, 
    0.17972235f, 0.05234655f, 0.09519909f, 0.00779867f, -0.04101044f, 0.05321041f, -0.09652697f, -0.03833920f, 
    -0.01008529f, 0.44809461f, 0.25787380f, 0.31691915f, -0.28119844f, 0.09535896f, 0.07761130f, 0.16392875f, 
    0.06641658f, -0.06619164f, -0.00867272f, 0.12615916f, -0.02834321f, 0.18862100f, 0.03542967f, 0.10469609f, 
    0.01945678f, -0.05001156f, 0.05219748f, 0.06055823f, -0.37429127f, 0.20011349f, 0.00588649f, -0.22368090f, 
    0.25703564f, 0.15848489f, -0.13854539f, 0.01875173f, -0.02994596f, -0.00252684f, 0.05741327f, 0.01064293f, 
    0.13253298f, -0.03819298f, -0.04480936f, 0.02397395f, 0.06280967f, -0.09081826f, 0.08842895f, -0.06871644f, 
    0.02191382f, -0.15561646f, 0.09173167f, 0.24952047f, 0.20832208f, 0.10746625f, 0.17309207f, -0.07643982f, 
    0.07306690f, 0.00512362f, 0.08449464f, 0.03930055f, -0.06745416f, 0.07397614f, 0.17349648f, 0.12024894f, 
    -0.02836248f, -0.01751851f, -0.04162123f, -0.01442069f, -0.15175697f, 0.38917091f, -0.10680061f, -0.37964135f, 
    0.14191867f, 0.01537135f, -0.12763438f, 0.02365172f, 0.02800812f, -0.05484932f, 0.14751802f, 0.07691859f, 
    -0.10510784f, 0.05675476f, 0.10441925f, -0.02470115f, -0.05183295f, 0.06608653f, 0.03623795f, 0.08080411f, 
    -0.00403378f, 0.21170419f, -0.22189775f, 0.04441568f, 0.07716897f, 0.02899432f, -0.06581540f, 0.04822500f, 
    0.03958132f, 0.12317081f, -0.00729219f, 0.06800188f, 0.01663877f, -0.00696208f, 0.09919365f, 0.04718435f, 
    -0.10688850f, 0.19227959f, 0.15228283f, 0.14586829f, -0.43995398f, -0.41276848f, 0.04317482f, -0.04122008f, 
    0.13740210f, 0.04609999f, 0.06720834f, 0.19804342f, -0.04156896f, -0.05328788f, -0.04320018f, -0.05376458f, 
    -0.06384329f, 0.03677658f, 0.01503654f, -0.03377358f, -0.07785617f, 0.08555523f, -0.12597483f, -0.08562161f, 
    -0.21325713f, 0.32236224f, -0.23547471f, 0.14146793f, 0.00178163f, 0.04429869f, 0.04502117f, 0.09253690f, 
    0.11453895f, 0.15371330f, -0.05841480f, 0.07004640f, -0.12753536f, -0.00687093f, -0.04049583f, -0.01258630f, 
    0.06898159f, 0.07278416f, 0.00668785f, 0.02891294f, 0.10628805f, 0.31755891f, 0.07141138f, 0.20411852f, 
    -0.18257619f, 0.08704414f, 0.06040011f, 0.05268826f, 0.00090510f, 0.01084760f, 0.09964921f, 0.03947337f, 
    -0.09543478f, -0.00282586f, 0.02146227f, 0.12102760f, 0.00559880f, -0.05587122f, 0.12358604f, 0.00184977f, 
    0.18173601f, 0.15881984f, 0.34920162f, 0.06987285f, 0.21074890f, -0.08477694f, 0.09528826f, 0.00086295f, 
    0.21506053f, -0.05582357f, 0.12332814f, 0.04268690f, 0.01241993f, 0.06406177f, -0.19955438f, 0.01480227f, 
    0.11670151f, -0.08068039f, -0.01478605f, 0.11223943f, -0.18371567f, 0.28003323f, -0.03559000f, 0.10575987f, 
    0.00862355f, 0.03195598f, -0.05293443f, 0.00702018f, 0.06156493f, 0.14137335f, 0.09553827f, 0.05854587f, 
    0.06412589f, 0.01603414f, -0.00704127f, 0.10637385f, -0.12088751f, -0.00736815f, 0.01990685f, -0.11234228f, 
    0.11046999f, 0.03605923f, -0.23274533f, -0.20886868f, 0.17727537f, 0.13733733f, -0.05432857f, -0.05698957f, 
    -0.14642948f, -0.06458014f, -0.05468938f, -0.05934499f, -0.12168948f, -0.06121161f, 0.02689049f, 0.07650662f, 
    0.04104236f, -0.00145057f, 0.20088433f, 0.30899155f, -0.33297423f, 0.25229540f, 0.00131952f, 0.19659039f, 
    -0.05359844f, -0.06010199f, 0.06595813f, -0.01086697f, 0.00340798f, 0.19605522f, 0.11025570f, -0.09296612f, 
    0.12059252f, -0.01389562f, 0.09230895f, -0.06772231f, 0.10407886f, -0.03203527f, -0.05427612f, 0.02189932f, 
    0.04685028f, 0.13817394f, -0.21543460f, -0.19406581f, 0.05315879f, -0.06550310f, -0.12583786f, 0.04155343f, 
    0.08639306f, -0.07535262f, 0.18727921f, 0.09440717f, 0.12072781f, -0.05711956f, -0.01976321f, 0.08760671f, 
    -0.04626378f, 0.04230185f, 0.25503206f, 0.09137907f, -0.20985569f, -0.25585505f, -0.38118866f, -0.35861921f, 
    -0.08290542f, -0.16422012f, 0.01691772f, -0.02370217f, 0.03488613f, -0.22376479f, 0.04791118f, 0.07425950f, 
    0.11393242f, -0.14247638f, 0.10250980f, -0.02784706f, 0.09792744f, 0.03645968f, 0.11281910f, 0.04253260f, 
    -0.66498238f, -0.13289952f, -0.02904605f, -0.22182198f, 0.11577377f, 0.07879993f, 0.02308406f, 0.11347795f, 
    -0.06374105f, 0.04734342f, -0.01878422f, -0.16939494f, 0.15453272f, 0.12750436f, -0.04818175f, 0.04946031f, 
    0.11435918f, 0.03496260f, -0.10988931f, -0.10847493f, -0.10055212f, -0.03565740f, -0.07779840f, -0.17403334f, 
    0.48389065f, -0.03611670f, -0.05828305f, 0.02279568f, -0.08747391f, -0.06339508f, 0.20918621f, -0.09076556f, 
    0.09850000f, 0.06459454f, -0.00171298f, -0.01438338f, -0.00480429f, 0.23050624f, -0.00494561f, 0.00601199f, 
    0.04403668f, -0.12322875f, -0.34464061f, 0.05231415f, -0.05285990f, -0.08059171f, 0.08763270f, 0.10511269f, 
    0.08461779f, -0.05217362f, -0.05053143f, 0.00989971f, 0.02922484f, 0.03059471f, 0.01431747f, -0.08086257f, 
    0.06565129f, -0.09595928f, -0.09981153f, 0.09364554f, -0.18093279f, 0.41532761f, 0.23174661f, -0.03595568f, 
    -0.01289626f, 0.10102258f, 0.10577904f, -0.07443411f, 0.02312130f, 0.13155569f, 0.05119411f, 0.03403647f, 
    0.00521510f, 0.05611750f, 0.20797706f, 0.10070436f, -0.11269115f, 0.01769922f, 0.19047329f, -0.05134520f, 
    0.05077009f, 0.15815955f, 0.03678712f, 0.21899460f, -0.14722745f, 0.00940745f, 0.00838635f, -0.01126835f, 
    0.02675966f, 0.10868143f, 0.18827018f, -0.09396262f, -0.02858134f, 0.21896178f, -0.10877751f, 0.16586018f, 
    -0.11602625f, 0.25738361f, -0.05864258f, 0.18771091f, -0.30031651f, 0.39424083f, -0.02087734f, -0.19514997f, 
    0.12777500f, 0.11038516f, 0.04195474f, 0.15306945f, 0.10323662f, -0.04733582f, -0.00860423f, -0.10162041f, 
    -0.11750539f, 0.01949399f, 0.25745603f, -0.08061004f, -0.01006834f, 0.13380553f, -0.05170875f, 0.00320173f, 
    0.16488463f, 0.00230007f, -0.14115545f, 0.03904684f, -0.04024315f, 0.05327800f, -0.04317321f, -0.07721901f, 
    -0.03943761f, 0.05978213f, 0.08730400f, 0.09443410f, 0.08329052f, 0.07134717f, -0.05091308f, 0.00445882f, 
    0.14852463f, 0.07049686f, -0.07574301f, 0.09905315f, -0.16674808f, 0.20814565f, 0.03721732f, 0.15745378f, 
    -0.08870867f, 0.08164696f, 0.02578511f, 0.02159243f, 0.04121484f, 0.08138723f, 0.09970383f, 0.08317239f, 
    0.10233479f, -0.00425288f, 0.07421718f, -0.01031013f, 0.03152074f, 0.07420410f, 0.12511519f, -0.07292911f, 
    -0.23683582f, 0.13967872f, -0.09019415f, -0.02251427f, -0.12757656f, 0.04516995f, 0.09299555f, 0.11155551f, 
    0.07109190f, 0.01086605f, -0.14666796f, 0.06616055f, 0.03555046f, 0.11730456f, 0.09002325f, -0.03398912f, 
    -0.06747422f, 0.19697089f, -0.00457111f, -0.08011902f, -0.17811431f, -0.24229787f, -0.18984880f, 0.20238855f, 
    -0.03011527f, 0.03635067f, 0.12100542f, 0.03411586f, -0.02040441f, 0.13886246f, 0.04650181f, -0.09414160f, 
    -0.05257445f, -0.01431600f, -0.08336579f, 0.13619681f, 0.10957086f, 0.03437791f, -0.04114523f, -0.09191857f, 
    0.09634703f, -0.11445541f, -0.03347583f, -0.27909446f, 0.01641956f, -0.07684493f, 0.08156379f, -0.05023045f, 
    0.05487844f, -0.06648853f, 0.05528205f, 0.08260603f, -0.07396859f, 0.13811521f, 0.09176712f, 0.06793612f, 
    -0.04381196f, 0.02901260f, 0.00045045f, 0.08973294f, -0.38594741f, -0.28751940f, -0.16413234f, -0.14823577f, 
    0.04633708f, -0.09164075f, 0.15509669f, 0.12569195f, 0.03936484f, -0.01294152f, -0.05234901f, 0.00762868f, 
    0.02381029f, 0.12468664f, 0.04642944f, 0.10010711f, 0.04857875f, -0.01341973f, -0.05408115f, -0.07088482f, 
    0.11628373f, 0.28271368f, -0.15821709f, -0.04591969f, -0.10298149f, 0.17299476f, -0.00297610f, 0.16040914f, 
    0.01754942f, -0.23550384f, 0.01760594f, -0.10239255f, -0.04109076f, -0.14441624f, 0.08631607f, -0.07750557f, 
    0.06217451f, 0.01736670f, -0.08224396f, 0.18761842f, -0.34733829f, -0.25284374f, -0.31519309f, -0.27884263f, 
    -0.07684378f, -0.05638378f, -0.11851374f, -0.05093275f, 0.01094909f, -0.04457491f, -0.10014272f, 0.05741315f, 
    0.01155934f, 0.06290541f, -0.01085001f, -0.03133329f, 0.06074487f, -0.10688918f, -0.10860442f, 0.11672644f, 
    -0.14334466f, 0.17720968f, 0.23358309f, 0.23750298f, 0.11978135f, 0.00677272f, -0.01665388f, 0.03363438f, 
    0.05406059f, 0.09363934f, 0.08190490f, 0.08627115f, 0.02213468f, 0.04272483f, 0.02514074f, 0.13346823f, 
    -0.05943473f, 0.00395262f, -0.06432752f, -0.02573223f, -0.28072461f, -0.13808803f, -0.16938654f, 0.09481716f, 
    -0.16673762f, 0.08409461f, 0.09488887f, -0.00279016f, 0.08846333f, 0.19772020f, 0.05479074f, -0.10552765f, 
    0.01040624f, 0.00256134f, 0.03000720f, -0.04180745f, 0.09133447f, -0.01384088f, -0.05169557f, -0.06700322f, 
    0.00607007f, 0.00934488f, -0.01336769f, -0.02583851f, 0.00686629f, -0.00324692f, 0.03113415f, -0.04104920f, 
    -0.02631871f, 0.00368345f, 0.01335567f, 0.02311958f, -0.01457842f, 0.03026908f, -0.03186269f, 0.02717078f, 
    0.04002152f, 0.01622220f, 0.00991499f, -0.00921241f, -0.02442246f, 0.00919001f, 0.00077902f, -0.03546930f, 
    0.00803875f, 0.02022174f, 0.02975630f, 0.00931305f, 0.01629370f, -0.03423174f, 0.02402764f, -0.00133794f, 
    -0.03351918f, -0.02948267f, 0.03437604f, 0.03589807f, -0.01590229f, 0.00018633f, -0.01318219f, -0.03880394f, 
    -0.01081013f, -0.04428734f, 0.00338703f, -0.02550461f, -0.01930271f, 0.02091884f, 0.03110602f, -0.02248951f, 
    0.01146109f, 0.03030071f, -0.01107071f, -0.00139831f, -0.00373585f, 0.02678915f, 0.00812855f, 0.00809217f, 
    -0.01012350f, 0.02717000f, 0.00947539f, -0.00064902f, -0.00926807f, -0.02532502f, -0.01844227f, 0.03013780f, 
    -0.02943171f, 0.02131669f, -0.02527856f, 0.02045263f, 0.03733918f, -0.00049737f, -0.00909572f, -0.03517009f, 
    -0.03229332f, 0.00502327f, -0.00640011f, 0.02144233f, -0.02148825f, -0.00040889f, 0.02961263f, -0.00932918f, 
    0.03670202f, -0.03632399f, -0.04199827f, 0.01493405f, -0.03450721f, 0.02070098f, -0.03485841f, 0.00832954f, 
    -0.00972279f, -0.03963186f, -0.00264137f, 0.00593164f, 0.03367253f, -0.01976992f, 0.02073004f, -0.02967506f, 
    0.03958026f, 0.00034541f, -0.03831894f, -0.02435557f, 0.02134783f, 0.02281828f, -0.02001835f, -0.03203879f, 
    0.01574117f, 0.00713642f, -0.00484284f, -0.00387934f, -0.01814598f, -0.02555621f, 0.04271018f, 0.01889029f, 
    -0.03590186f, 0.02061525f, 0.03242644f, -0.01283486f, -0.02608531f, 0.02605641f, -0.00744816f, -0.03182801f, 
    0.00131108f, -0.03509676f, -0.02274333f, -0.03124378f, 0.02005664f, -0.02462115f, 0.01034350f, -0.02358557f, 
    0.01462786f, -0.03810457f, -0.00797496f, -0.00999533f, 0.00846959f, 0.02906417f, 0.02999760f, -0.03103038f, 
    -0.03413548f, -0.02973963f, 0.01178678f, -0.01466904f, -0.00330666f, 0.00493560f, 0.02368340f, -0.02274949f, 
    -0.04211661f, 0.03543554f, 0.03454269f, 0.01549981f, 0.01655879f, -0.03203999f, 0.02339174f, -0.00728586f, 
    0.02508092f, 0.04337046f, 0.02968762f, -0.04260636f, 0.01825783f, 0.00982303f, 0.01791645f, 0.01447720f, 
    0.02511885f, 0.02652700f, -0.00678576f, 0.01107596f, -0.04536654f, 0.02583127f, -0.02645747f, -0.00967900f, 
    0.01552590f, -0.01803143f, -0.04025894f, 0.00571892f, -0.01907593f, -0.02956101f, 0.00054622f, -0.01312026f, 
    0.01443039f, 0.00905952f, -0.03668653f, -0.00904372f, -0.00829823f, -0.02510339f, -0.01028659f, -0.04120456f, 
    0.04131521f, 0.02618458f, -0.04383957f, -0.03842966f, -0.02483281f, -0.01962659f, 0.03534976f, -0.01469174f, 
    -0.03384271f, -0.03650462f, 0.00668352f, 0.00347327f, 0.03048091f, -0.00409347f, 0.01684563f, 0.01542796f, 
    -0.02042248f, -0.03536718f, 0.02029265f, -0.03103923f, -0.00056718f, 0.00752745f, -0.01785892f, -0.04425127f, 
    -0.02222972f, -0.03149408f, 0.01917821f, 0.00064489f, 0.02703671f, 0.01644282f, 0.01606736f, 0.02736255f, 
    0.01463437f, 0.03771375f, -0.00536451f, -0.01909200f, -0.03029850f, -0.03707984f, -0.02065445f, 0.01325807f, 
    -0.03014909f, 0.02246010f, 0.01554299f, 0.01871547f, 0.00796896f, -0.01983415f, -0.02455918f, 0.01299901f, 
    0.01383033f, -0.00320343f, -0.04092319f, 0.01313213f, -0.03074781f, 0.01933771f, -0.01748033f, -0.03858078f, 
    0.00725967f, -0.01523388f, 0.00231364f, 0.01486155f, 0.03842040f, -0.03766452f, -0.02459444f, -0.01322720f, 
    -0.00203699f, -0.00970634f, -0.01431983f, -0.02595529f, -0.02195515f, -0.04126975f, 0.00141390f, 0.01061617f, 
    -0.00214521f, 0.01539014f, -0.01134328f, 0.01263506f, 0.00119927f, 0.01277075f, 0.02727936f, -0.00609681f, 
    0.01040073f, -0.00971527f, 0.01188794f, -0.02247143f, -0.00308008f, -0.02644100f, -0.04214536f, 0.02781310f, 
    -0.04529642f, 0.03270830f, 0.02852627f, 0.01707910f, 0.00530598f, 0.03149763f, 0.03205923f, 0.01959769f, 
    0.01267030f, 0.00255310f, 0.02241314f, -0.03256362f, 0.02160266f, 0.00348748f, 0.00796833f, 0.00548518f, 
    0.01165061f, 0.02535448f, 0.00664368f, 0.02996876f, -0.03872159f, 0.01389554f, 0.02927992f, 0.02075454f, 
    -0.01868574f, -0.04291226f, -0.02316366f, -0.02338321f, -0.00750689f, -0.02612668f, -0.00583791f, -0.01482097f, 
    -0.00190039f, 0.03312775f, -0.04396416f, 0.00555564f, -0.02516099f, -0.00285091f, -0.02201602f, -0.03927785f, 
    -0.01726356f, 0.02162184f, -0.01156703f, 0.03677827f, 0.00727424f, 0.00379269f, 0.00000116f, 0.03250261f, 
    0.01587649f, -0.01974733f, 0.02374928f, -0.02379603f, -0.02714442f, -0.00607256f, -0.03692992f, -0.01435233f, 
    -0.01214434f, -0.04531167f, -0.02166047f, 0.02429582f, 0.00238209f, 0.00936921f, -0.00786598f, -0.02345807f, 
    0.00641553f, -0.02516017f, -0.01901328f, -0.04250991f, -0.04321596f, -0.01804089f, 0.02375211f, 0.00476641f, 
    0.01168338f, 0.02118423f, -0.02302531f, -0.04068818f, -0.01165550f, -0.02901298f, -0.03900465f, -0.01594632f, 
    -0.03663967f, 0.01843036f, -0.01340753f, -0.01756685f, -0.02944036f, 0.03371511f, 0.01744104f, 0.00101751f, 
    0.02531178f, 0.02420278f, -0.00897149f, -0.03399012f, 0.02763227f, -0.01352870f, -0.03281325f, -0.02145797f, 
    0.01682911f, -0.03542804f, 0.02226041f, -0.02739028f, 0.01269070f, 0.01313369f, -0.02341976f, 0.00971347f, 
    0.00362538f, 0.02795256f, 0.03187395f, 0.02147643f, -0.03319931f, -0.03483664f, 0.02382693f, -0.03055980f, 
    0.01927234f, 0.04568749f, -0.02142324f, -0.02329829f, -0.01359621f, 0.02508554f, -0.01113658f, 0.02752321f, 
    -0.00010210f, -0.01007076f, 0.01295885f, -0.01053750f, -0.00691579f, -0.01107401f, 0.00350867f, -0.01266861f, 
    -0.01602948f, -0.03561756f, 0.03020581f, -0.01031661f, 0.01601045f, -0.02640378f, 0.00197953f, -0.03800860f, 
    -0.02570482f, 0.01593426f, 0.00571212f, -0.00491781f, 0.00372998f, 0.00406945f, 0.00975886f, 0.00943612f, 
    -0.03340890f, -0.03428517f, 0.01606168f, -0.04172124f, 0.00480505f, -0.02289845f, -0.03601874f, -0.01529130f, 
    -0.02422433f, -0.00120177f, 0.02980977f, -0.00822033f, -0.03257822f, -0.03614855f, 0.00059768f, -0.02945491f, 
    -0.01152435f, -0.04155417f, 0.02623811f, 0.03022025f, -0.03832403f, -0.01932140f, 0.02237446f, 0.00538316f, 
    -0.03883343f, -0.01350897f, -0.00113389f, 0.01965856f, 0.00691248f, 0.00381187f, 0.01821365f, 0.01432386f, 
    -0.02590769f, -0.00195960f, -0.02627297f, -0.02815726f, 0.02569180f, 0.02141024f, 0.02463767f, 0.03214679f, 
    -0.00923560f, -0.00902610f, 0.04411220f, 0.04705675f, -0.04277312f, 0.01336518f, -0.02508742f, 0.01969603f, 
    0.01487700f, 0.00286394f, -0.02208415f, 0.01590541f, 0.02859506f, -0.04688073f, -0.01492768f, 0.02437692f, 
    0.00710423f, 0.03917053f, -0.01200436f, 0.03387048f, -0.02723987f, -0.00256519f, -0.04130435f, -0.00523014f, 
    0.01147560f, 0.01089567f, -0.02677776f, -0.00462371f, 0.02130589f, 0.00313725f, 0.02896239f, -0.03143058f, 
    -0.03655381f, -0.02054702f, -0.02985064f, 0.01573342f, -0.00310494f, -0.00737674f, 0.02156430f, 0.00806296f, 
    -0.00576696f, -0.01189782f, -0.01922395f, -0.00636462f, 0.00473207f, 0.02722218f, 0.00160750f, -0.03845788f, 
    -0.03682628f, 0.02091356f, -0.03433252f, -0.02514273f, -0.03986435f, -0.02076790f, -0.00169893f, 0.00807161f, 
    -0.04186630f, -0.02459645f, -0.03918969f, 0.00344625f, -0.01288814f, 0.02059558f, -0.00207967f, -0.01586162f, 
    0.02613225f, -0.02653764f, -0.03779641f, -0.02089321f, 0.01420848f, 0.00065105f, -0.04371886f, 0.00175413f, 
    -0.02456784f, 0.01017996f, 0.00021630f, 0.00716274f, -0.03029557f, -0.02811303f, -0.02312332f, 0.00484692f, 
    -0.02059713f, 0.01173827f, -0.02417093f, -0.01136372f, 0.01280050f, -0.02789576f, -0.03433249f, -0.01509618f, 
    0.00136427f, 0.03431872f, -0.02221795f, 0.02105124f, 0.03689705f, 0.02852413f, -0.01760745f, -0.02033348f, 
    -0.02248522f, 0.02797019f, -0.01681140f, -0.00095207f, -0.01375424f, 0.02369516f, -0.00801091f, -0.03844344f, 
    0.04748891f, -0.03710366f, 0.03211508f, 0.00760314f, -0.01583877f, -0.00092049f, 0.02035366f, 0.00602708f, 
    0.00643339f, 0.02309912f, 0.01321915f, -0.03277520f, 0.03326143f, 0.03002263f, -0.02815407f, 0.03224677f, 
    -0.03013963f, 0.00863924f, -0.01277502f, -0.03191826f, -0.03924686f, -0.02730791f, 0.00021815f, -0.02566395f, 
    0.01299349f, -0.03564734f, 0.00991711f, -0.02446738f, -0.00506925f, 0.03139557f, 0.00952187f, 0.00011054f, 
    0.00326515f, -0.00158042f, -0.00658491f, -0.04156066f, 0.00723883f, 0.02849219f, -0.00696606f, 0.00055941f, 
    -0.01192030f, -0.03484019f, 0.02627621f, 0.02216777f, 0.03016059f, 0.03270634f, -0.02291470f, -0.01548879f, 
    -0.01168327f, -0.01303061f, 0.02689411f, 0.01271111f, -0.04050727f, -0.00610237f, -0.01894639f, -0.03497756f, 
    0.03108326f, -0.02680505f, 0.00756610f, 0.01279143f, 0.01456848f, -0.03153468f, -0.04087055f, -0.02358357f, 
    -0.02683712f, 0.02674912f, -0.02484102f, -0.03481918f, 0.00452928f, -0.01783563f, 0.02924637f, 0.03971002f, 
    0.01952027f, 0.00313037f, -0.00297417f, -0.00363220f, -0.00215183f, -0.00909802f, -0.02563519f, 0.02139379f, 
    -0.02414372f, -0.01675581f, -0.03586793f, 0.01171653f, -0.00778971f, -0.03891658f, -0.00680175f, 0.00110830f, 
    -0.03892274f, 0.01328327f, 0.00717032f, -0.03208344f, -0.03070709f, 0.02290032f, 0.03249510f, -0.02049198f, 
    -0.00364935f, -0.01995283f, 0.00568889f, -0.03625424f, 0.03636951f, -0.01162015f, -0.02829326f, -0.02913182f, 
    -0.02748684f, -0.01642541f, 0.03045093f, -0.03821979f, -0.02939094f, 0.00295042f, 0.02344380f, -0.02385318f, 
    -0.00816532f, 0.02017489f, -0.03902040f, -0.01985083f, -0.01435777f, 0.00013513f, 0.02940989f, 0.00452748f, 
    0.01372784f, -0.03460736f, -0.02785060f, 0.00376252f, -0.00218475f, -0.02643346f, -0.01836563f, 0.02794306f, 
    -0.01383723f, 0.00555033f, -0.01902319f, 0.00035769f, 0.00315197f, 0.02505328f, -0.01017204f, -0.00295310f, 
    0.00893154f, 0.00301249f, -0.03231777f, -0.00599256f, -0.03015575f, -0.00963652f, -0.00778100f, -0.03576198f, 
    0.00056660f, 0.03670083f, 0.01671882f, 0.01458907f, -0.02579115f, 0.01252736f, -0.01190172f, -0.00891070f, 
    -0.00697993f, -0.01956616f, -0.01701711f, 0.01316362f, 0.01656297f, -0.01717431f, 0.01809716f, -0.03366052f, 
    0.00295377f, -0.04371938f, 0.03245933f, -0.00722412f, -0.01780497f, -0.02930280f, 0.02166231f, -0.02833675f, 
    0.00744779f, -0.03198354f, 0.00450822f, -0.00738458f, -0.02939467f, -0.01312229f, 0.00884764f, -0.00962510f, 
    0.00078309f, 0.02767193f, 0.00486160f, 0.01520442f, 0.00442944f, 0.00374225f, -0.01820493f, -0.01626690f, 
    -0.02307164f, 0.03905020f, -0.02308680f, 0.02970530f, 0.00673323f, 0.00375518f, -0.00065200f, 0.01644280f, 
    0.00394324f, 0.03404155f, 0.01327009f, 0.02220581f, 0.00594108f, -0.03556422f, -0.02762270f, -0.01971077f, 
    0.01215928f, 0.02248857f, 0.02898774f, -0.00046212f, -0.03449426f, -0.00935888f, 0.00431106f, -0.02986723f, 
    0.02575291f, -0.03816336f, -0.03696141f, 0.00641403f, 0.01775718f, 0.02365551f, 0.01116721f, 0.01707051f, 
    0.00357903f, 0.01169552f, 0.01141286f, -0.01721681f, -0.02548685f, 0.01394507f, 0.01950673f, -0.01511918f, 
    0.03395715f, 0.02123533f, 0.03569671f, 0.02799202f, -0.02806843f, 0.02158360f, 0.02941137f, 0.03962851f, 
    -0.03192201f, 0.02740671f, -0.03057258f, -0.02983510f, 0.01967212f, -0.03218768f, -0.00589636f, -0.01881684f, 
    -0.01731445f, 0.02974271f, -0.01374774f, -0.02125474f, -0.02353482f, 0.02704255f, 0.00722694f, -0.00699133f, 
    0.01387408f, -0.02959507f, -0.02951059f, 0.00739656f, -0.01065388f, 0.02669417f, -0.03853456f, -0.02105923f, 
    0.00352727f, -0.00594925f, 0.00712035f, -0.03543996f, -0.01199329f, 0.00186510f, 0.02044791f, -0.04305984f, 
    -0.01134123f, 0.01533514f, -0.03431683f, -0.04137291f, 0.04194694f, -0.00224491f, 0.03654930f, -0.00589757f, 
    0.01039383f, -0.03243380f, 0.00068769f, 0.02669862f, 0.00218765f, 0.01719571f, -0.02023509f, 0.03713087f, 
    -0.04464449f, 0.03485018f, -0.00508748f, 0.00499044f, -0.03572394f, -0.02758593f, -0.01358792f, 0.02697279f, 
    -0.00040352f, 0.03184916f, 0.03406513f, -0.00240570f, -0.02582589f, -0.01704815f, 0.01529500f, -0.04651499f, 
    -0.03126201f, 0.03201706f, -0.02184347f, 0.02208961f, -0.01141522f, 0.00678237f, -0.04108803f, -0.01585216f, 
    0.01045796f, 0.02936865f, -0.03849513f, 0.01969114f, 0.03152587f, 0.00938214f, -0.04292161f, 0.01936958f, 
    0.01203914f, 0.02078393f, -0.04559892f, -0.01189771f, 0.01955340f, -0.00161212f, -0.01100662f, -0.02395142f, 
    -0.00447219f, -0.04414338f, 0.00247411f, 0.02341404f, 0.01444628f, -0.01555980f, -0.00794686f, 0.03057940f, 
    -0.02691715f, 0.02361025f, -0.00536422f, 0.00969827f, -0.01356053f, 0.00906716f, 0.01711548f, -0.00312208f, 
    -0.04616464f, 0.02823130f, -0.02669368f, 0.00288426f, -0.00404575f, 0.02144197f, 0.00952745f, -0.03153330f, 
    0.03184512f, -0.02249142f, -0.00831547f, -0.03799368f, -0.01223670f, -0.03236330f, -0.03406003f, -0.00373997f, 
    -0.00673194f, -0.03659226f, -0.04576261f, 0.01422465f, -0.02620176f, -0.03463154f, -0.03377949f, -0.00586869f, 
    -0.04008889f, -0.00678231f, -0.04426771f, -0.02620755f, 0.02648943f, 0.03741767f, -0.02112155f, -0.01896078f, 
    0.03978923f, -0.02162744f, -0.00838568f, 0.00518182f, -0.01372769f, 0.00711213f, 0.01030289f, -0.00775915f, 
    0.02812656f, 0.02030977f, 0.01235477f, 0.00664436f, -0.04265891f, 0.02762484f, 0.00934930f, -0.04375924f, 
    0.00828195f, -0.03178464f, -0.03820430f, -0.00550540f, 0.00129208f, -0.00893101f, 0.01799937f, -0.02868765f, 
    0.02968551f, 0.01920193f, 0.02529018f, -0.02138595f, 0.03326751f, -0.03274509f, -0.01899462f, 0.01386565f, 
    -0.00933857f, -0.02044520f, 0.02008556f, -0.01862100f, 0.01565999f, 0.00128695f, 0.03020349f, 0.01820556f, 
    -0.02570775f, 0.01475172f, -0.03953202f, -0.01146171f, 0.02763113f, 0.01148995f, -0.01021897f, 0.00529159f, 
    -0.00449493f, 0.00314789f, -0.03644458f, -0.03137758f, -0.01609248f, -0.00840797f, 0.01873355f, 0.00823804f, 
    -0.03139985f, 0.01206679f, 0.00557945f, -0.01170358f, -0.01724707f, 0.02425462f, 0.02306546f, -0.02675871f, 
    -0.03859312f, 0.00736124f, -0.04388379f, -0.02268606f, -0.00287594f, -0.04211070f, 0.00016386f, -0.02199678f, 
    -0.01998324f, -0.00561609f, -0.01156761f, -0.01407778f, -0.00247326f, -0.01865786f, -0.03863085f, -0.03511789f, 
    0.02434745f, 0.03096774f, -0.02363016f, 0.03006777f, 0.03368912f, -0.02048210f, -0.00504639f, -0.00363080f, 
    0.01228310f, -0.01654546f, 0.00559052f, -0.00167768f, -0.01893220f, 0.01548189f, -0.02170096f, -0.03069208f, 
    -0.04448581f, -0.01100902f, -0.01271461f, 0.03063397f, -0.00296176f, 0.00679041f, -0.02408789f, 0.02737612f, 
    0.00542272f, -0.00190764f, 0.01221876f, -0.03648866f, 0.01370076f, -0.00088067f, 0.01583367f, -0.04243729f, 
    -0.04330360f, -0.03047790f, -0.03966449f, 0.00556169f, 0.04297069f, 0.01082300f, -0.02039074f, 0.00082824f, 
    0.01020158f, -0.01169460f, 0.03246981f, -0.00896237f, 0.02879156f, 0.03103714f, -0.03833584f, -0.00137146f, 
    -0.01977237f, -0.02133561f, -0.03049788f, 0.02490721f, 0.00462352f, -0.00401038f, -0.01037622f, 0.00445000f, 
    0.01448812f, -0.00521335f, -0.03422354f, -0.01637568f, 0.03557850f, -0.03162961f, -0.00368717f, 0.01033051f, 
    -0.03873456f, -0.02917881f, -0.01087310f, -0.03453702f, 0.00755539f, 0.01035405f, -0.00441345f, 0.02410234f, 
    0.02220009f, 0.03618851f, -0.04237641f, 0.03377836f, -0.00473720f, 0.03652776f, -0.00769171f, -0.01809041f, 
    0.04206391f, -0.02575164f, -0.02992130f, -0.02550564f, -0.01263080f, 0.02487168f, 0.01680665f, 0.00856194f, 
    -0.01476067f, 0.01592057f, 0.02635399f, 0.01472244f, 0.00592085f, -0.02356919f, 0.03101163f, -0.00491077f, 
    0.01737994f, -0.02593214f, -0.01703948f, -0.03972868f, -0.01817736f, -0.02672303f, 0.02403983f, 0.03173222f, 
    -0.00637599f, -0.00073519f, -0.01897726f, -0.01909449f, 0.01452866f, 0.02453873f, -0.01429128f, -0.04268488f, 
    0.03860583f, 0.00280997f, -0.03442470f, 0.00114021f, 0.00534142f, -0.01067477f, -0.03390019f, -0.04382436f, 
    -0.00226995f, 0.00020948f, 0.00507596f, 0.02782512f, -0.01453294f, -0.04416372f, 0.01465953f, -0.00680544f, 
    0.03228780f, -0.00233190f, 0.03468962f, -0.02601777f, -0.02727854f, -0.00473936f, -0.02665315f, -0.01645780f, 
    0.00391392f, -0.02849085f, 0.03425751f, -0.01508729f, -0.03820409f, 0.00584224f, 0.01110898f, -0.01377177f, 
    0.03618662f, -0.00310341f, 0.03124383f, -0.03133599f, 0.03589557f, -0.01897593f, -0.01834056f, -0.02080179f, 
    -0.01016942f, -0.00733471f, -0.00347616f, -0.02071497f, 0.03058956f, -0.00337176f, 0.01856445f, -0.02548708f, 
    0.01491681f, 0.03116301f, -0.00211203f, 0.03916630f, -0.02897868f, -0.04403695f, -0.00338623f, -0.02920142f, 
    -0.02008617f, -0.01642806f, -0.03997349f, -0.00691475f, 0.00593144f, 0.00965560f, 0.02528520f, -0.03390724f, 
    0.02319506f, -0.00777916f, 0.00317403f, 0.01026426f, 0.00971128f, -0.00267136f, -0.03222127f, -0.03582028f, 
    -0.03243567f, -0.00916501f, 0.01004957f, 0.02396369f, 0.03190482f, -0.04354706f, -0.02185003f, -0.00622220f, 
    -0.00942590f, -0.02473301f, 0.01664542f, 0.02352481f, -0.03640335f, -0.03753866f, -0.02154790f, 0.03863522f, 
    0.03101240f, -0.02199143f, 0.00756790f, -0.03809465f, -0.03724705f, -0.03079320f, 0.02037125f, -0.00704534f, 
    -0.00269394f, -0.00519991f, -0.04203238f, -0.01555226f, 0.01672931f, 0.00671919f, -0.00008520f, 0.02410968f, 
    -0.03142831f, -0.01551967f, -0.04662261f, 0.02673346f, 0.00693284f, 0.03700729f, -0.03806125f, 0.02356535f, 
    -0.01702962f, -0.02823357f, -0.01548285f, 0.00587914f, 0.00312104f, 0.03107294f, -0.00626772f, -0.00695385f, 
    0.00915997f, 0.02002882f, -0.01225715f, -0.04193821f, -0.01882269f, 0.00457046f, -0.00198472f, -0.04600510f, 
    -0.03347587f, -0.00982042f, -0.02026217f, -0.01275084f, -0.01857996f, 0.02043162f, -0.00667341f, 0.03179892f, 
    0.02064078f, -0.00082452f, -0.03649968f, -0.01070303f, -0.01301754f, -0.01458433f, -0.03123133f, -0.01559928f, 
    0.00066932f, -0.01911437f, 0.02376444f, 0.01064360f, -0.04140775f, 0.00050904f, 0.02745558f, -0.04027350f, 
    0.03215214f, 0.00782087f, -0.02630262f, 0.03316600f, -0.02798694f, 0.01867415f, -0.02199434f, -0.02946236f, 
    0.01954761f, -0.03754229f, 0.01250528f, -0.03038790f, -0.00700900f, -0.03893700f, 0.00987186f, -0.01189799f, 
    0.03072466f, -0.03360470f, -0.00071842f, 0.02002048f, -0.00405406f, 0.02558101f, -0.02773350f, 0.02673802f, 
    0.03272568f, -0.01876442f, -0.01359336f, -0.03953794f, -0.03516600f, 0.00852400f, 0.01421620f, -0.00575587f, 
    -0.00004450f, 0.02605638f, -0.00620336f, 0.00697614f, -0.01981433f, 0.02010010f, 0.02454822f, 0.01857452f, 
    -0.01752619f, 0.01722706f, 0.02686230f, -0.03224118f, -0.00920785f, -0.02920895f, -0.04510533f, 0.01664300f, 
    0.02892017f, -0.03226285f, -0.01972021f, -0.04255749f, -0.01172267f, 0.01020503f, -0.01882072f, -0.03292597f, 
    0.00728982f, 0.01013939f, 0.00181594f, 0.02962718f, 0.01962280f, -0.01581103f, 0.02688899f, 0.03081889f, 
    -0.03839999f, 0.03215928f, -0.00086751f, 0.02086146f, -0.03112138f, -0.00065064f, 0.00102245f, 0.00595303f, 
    -0.03442509f, 0.02922242f, -0.03310600f, 0.01148176f, 0.03227598f, 0.00061439f, 0.00325255f, -0.01300041f, 
    0.02037702f, 0.03317292f, 0.00238212f, 0.02572136f, -0.02797547f, -0.01529038f, -0.03838799f, 0.03147899f, 
    -0.04298212f, -0.01160278f, 0.01382914f, 0.01704125f, -0.02011983f, -0.03617278f, -0.01720644f, 0.00859858f, 
    -0.01043723f, 0.01453313f, -0.03048379f, 0.02584380f, -0.00477268f, -0.02505449f, -0.03560943f, 0.01118628f, 
    -0.00823184f, 0.01901546f, -0.03870894f, 0.00263639f, 0.02060873f, 0.03257407f, -0.01803894f, -0.02933012f, 
    -0.01486194f, 0.01504306f, -0.01802562f, -0.00932180f, -0.02775712f, -0.03641950f, 0.03110409f, 0.00248523f, 
    0.01707591f, 0.02212684f, 0.00095714f, -0.01808279f, 0.03139244f, -0.04029387f, 0.02069066f, -0.00358472f, 
    0.00877081f, 0.00430193f, -0.03635644f, 0.01293332f, 0.02903230f, 0.03193880f, 0.02755264f, 0.00250422f, 
    -0.00522927f, -0.03706444f, -0.03861424f, -0.00362088f, 0.01150949f, -0.02011413f, 0.01192390f, -0.03191254f, 
    0.02048923f, -0.02595029f, 0.00253072f, -0.02320608f, 0.02025555f, -0.02180040f, -0.02854975f, 0.00287448f, 
    -0.03737210f, 0.01717647f, -0.02842677f, -0.03430950f, -0.02700358f, -0.04054339f, 0.02927117f, 0.03018128f, 
    -0.01869277f, -0.00758039f, 0.00108190f, 0.00543977f, -0.01096047f, -0.04436268f, 0.01400748f, -0.00767184f, 
    0.03017238f, -0.00250764f, -0.01399465f, -0.04109775f, -0.04487708f, -0.02927200f, -0.02473783f, 0.02362319f, 
    0.01649482f, 0.02700807f, -0.02654315f, 0.00916299f, -0.03512379f, -0.04044794f, 0.00442903f, -0.03253463f, 
    -0.01737290f, -0.03580555f, 0.00592316f, 0.02353485f, -0.01448524f, -0.03031598f, -0.01810943f, -0.02452577f, 
    -0.04329958f, -0.03093632f, -0.01856313f, -0.04513665f, 0.01657671f, 0.01529924f, 0.03197357f, -0.00748605f, 
    -0.02067941f, -0.03215112f, -0.01301712f, 0.00220814f, -0.01152462f, -0.04188809f, 0.01212945f, -0.00895104f, 
    -0.00751527f, -0.02041949f, -0.02391865f, -0.00044982f, -0.04268013f, -0.01447571f, -0.02298091f, -0.02676746f, 
    -0.00766666f, -0.01166061f, 0.01933254f, -0.04195285f, -0.00040461f, 0.01420293f, -0.03237032f, 0.02531461f, 
    -0.03334788f, -0.00016783f, 0.01008877f, 0.00852405f, -0.02400198f, 0.00214923f, 0.00510676f, 0.00344047f, 
    -0.01175506f, 0.00758376f, -0.02788068f, -0.01253131f, 0.00213804f, 0.01408820f, -0.00789545f, -0.01482024f, 
    0.00173283f, 0.02853368f, 0.01732776f, 0.01888173f, -0.02166851f, -0.00708887f, -0.01035776f, 0.03296642f, 
    0.01788964f, -0.01153350f, -0.01341659f, -0.01514028f, -0.02767477f, -0.02726357f, 0.01213006f, -0.00364952f, 
    0.01354543f, -0.01596627f, -0.03587817f, -0.00312599f, -0.03253993f, 0.00829161f, -0.00264224f, -0.02548363f, 
    -0.03175867f, 0.02699973f, -0.02778236f, -0.01967807f, -0.03485186f, 0.02516332f, 0.01134077f, -0.03135384f, 
    -0.00054242f, -0.03557486f, -0.04254202f, -0.03002959f, -0.01473338f, 0.02900716f, -0.00787726f, 0.03123956f, 
    -0.00174524f, -0.00902018f, -0.01402408f, -0.02626795f, 0.00878505f, -0.03965047f, 0.00147645f, -0.01270751f, 
    -0.03806623f, 0.02632047f, -0.01748584f, 0.01010258f, 0.02563472f, -0.01339148f, 0.03267919f, 0.01552406f, 
    -0.03305533f, 0.00582364f, 0.01014852f, 0.03278119f, -0.04282346f, 0.01086515f, -0.03681953f, -0.02619202f, 
    -0.04199759f, -0.02988014f, 0.01147023f, -0.04511238f, 0.02602808f, -0.02784837f, -0.01032286f, 0.02604776f, 
    -0.00814885f, 0.00879118f, -0.02012557f, 0.03100287f, -0.01791369f, -0.03001493f, 0.00659882f, -0.03904106f, 
    0.01252030f, -0.03456407f, 0.01751898f, 0.01732111f, 0.01911860f, 0.00854465f, 0.02315930f, 0.00081283f, 
    0.01522195f, -0.01384395f, -0.02922591f, 0.01594706f, -0.02884679f, 0.00964786f, -0.04325943f, 0.02540547f, 
    -0.02010079f, -0.04425916f, -0.02166943f, 0.00894427f, -0.02349711f, -0.03071116f, -0.02338789f, 0.00744101f, 
    -0.00746171f, -0.02617386f, 0.02160031f, -0.01275730f, 0.00241945f, -0.04302334f, 0.00781765f, -0.02359341f, 
    -0.00459976f, -0.02679513f, 0.00804387f, 0.00221126f, -0.04079509f, -0.03126957f, -0.03945792f, 0.00391812f, 
    0.01175599f, -0.03759538f, 0.03207511f, -0.04159623f, -0.01105763f, 0.01869073f, -0.00157871f, 0.01236754f, 
    -0.04448771f, -0.03999114f, 0.00924466f, 0.00070439f, 0.01437775f, -0.02322372f, -0.00712801f, 0.01160880f, 
    0.02261982f, -0.02772167f, 0.01307519f, -0.02784219f, -0.00182101f, -0.02190074f, 0.01464920f, -0.00252491f, 
    0.03027331f, -0.03647852f, -0.04011894f, -0.01239640f, 0.00978871f, -0.00031150f, -0.03379312f, 0.02333673f, 
    0.01947539f, -0.00056224f, 0.02776371f, 0.01629476f, -0.02876913f, -0.01714457f, -0.02030029f, -0.03491935f, 
    -0.01798598f, -0.03097894f, -0.02572096f, -0.03456032f, -0.03565777f, 0.02448233f, -0.04522204f, -0.02838190f, 
    -0.04409697f, 0.01703096f, -0.04413224f, -0.02455219f, -0.03482186f, 0.00428988f, -0.01478763f, -0.01735368f, 
    -0.03284241f, 0.01465791f, -0.01538607f, -0.04218898f, -0.03360828f, 0.00545099f, -0.03657694f, 0.01555150f, 
    0.02947121f, -0.03710739f, -0.02207146f, 0.01509691f, 0.02163294f, -0.02189223f, 0.02861495f, -0.02703437f, 
    0.01189616f, -0.04014669f, 0.00534691f, -0.00679227f, 0.02727322f, 0.01266125f, -0.01937322f, -0.03888909f, 
    -0.04221742f, 0.01516369f, -0.03152866f, 0.00318845f, 0.03099280f, 0.03303050f, -0.01158582f, -0.02869694f, 
    -0.03167269f, 0.02070850f, -0.01046019f, -0.02481671f, -0.01962389f, -0.01244274f, -0.01762277f, -0.02280675f, 
    -0.02392019f, -0.04041448f, -0.02939282f, -0.00836064f, -0.04085026f, -0.04540552f, -0.02030287f, -0.03644523f, 
    0.00905808f, -0.02748319f, -0.03762317f, -0.01302142f, 0.02323809f, 0.02040063f, 0.00039047f, 0.02235000f, 
    0.00540243f, -0.02108450f, -0.03898828f, 0.02911467f, 0.00967735f, -0.02851997f, 0.00519663f, -0.04367994f, 
    -0.03228968f, 0.00346788f, -0.02090413f, -0.00571191f, -0.02941995f, -0.00650906f, 0.00218271f, 0.03048685f, 
    0.01603807f, 0.02555114f, -0.03275459f, -0.00802968f, 0.01029977f, -0.03830685f, -0.00206550f, -0.00731506f, 
    0.01488205f, -0.00258760f, 0.02966626f, 0.01261591f, -0.02287867f, 0.03289476f, -0.00924110f, 0.00972538f, 
    0.02538804f, -0.03902193f, 0.02064322f, -0.03815511f, -0.02680245f, -0.03341375f, -0.01418645f, 0.02476043f, 
    -0.01948339f, 0.00656196f, -0.04464382f, 0.03011442f, -0.03504088f, -0.00057103f, -0.03977348f, -0.00111831f, 
    -0.03004222f, -0.02774567f, -0.02098508f, -0.02309182f, 0.02964849f, -0.03532053f, -0.04301683f, -0.04447366f, 
    -0.00105925f, -0.00258733f, -0.00637524f, -0.01372788f, -0.03334665f, -0.01019149f, -0.00526230f, -0.04491191f, 
    -0.00385853f, -0.03974674f, -0.02887342f, 0.01585473f, -0.00575747f, -0.03066089f, 0.00937329f, 0.01673893f, 
    -0.03500822f, -0.01092832f, 0.02880155f, -0.01811127f, -0.01087738f, 0.01647501f, 0.02575880f, 0.00704915f, 
    -0.03918995f, 0.02618767f, -0.02994160f, -0.01376541f, -0.02859193f, -0.03407262f, -0.01356006f, -0.02489931f, 
    0.02017317f, -0.04029339f, 0.03253309f, 0.01803683f, -0.03342092f, 0.00894491f, -0.01028693f, -0.00141090f, 
    -0.03721991f, 0.00220143f, -0.02474513f, -0.00218233f, 0.00189626f, 0.02112489f, -0.00713152f, 0.01948248f, 
    0.01513389f, -0.03321853f, 0.01527729f, -0.01988746f, -0.03795700f, 0.01408398f, -0.00534544f, 0.03107678f, 
    -0.03509298f, -0.00288278f, -0.01590431f, 0.02101209f, -0.00454247f, 0.00442347f, 0.02764786f, 0.03098607f, 
    -0.00756037f, 0.02613399f, 0.01972370f, 0.01955877f, 0.03768283f, 0.02578503f, -0.01835160f, -0.00746316f, 
    -0.01941676f, -0.03907780f, 0.02696470f, 0.01578007f, -0.00087011f, -0.00122535f, -0.00586071f, -0.03833592f, 
    -0.03299021f, -0.02931946f, 0.01210072f, 0.02805817f, -0.01774611f, 0.02419534f, 0.01363418f, -0.04123612f, 
    -0.02435853f, -0.00869657f, -0.01980253f, 0.00258304f, -0.03547118f, -0.04347112f, -0.02749710f, -0.02026892f, 
    0.00486835f, 0.03224430f, -0.02334596f, -0.04496792f, 0.01803184f, -0.01526638f, -0.01630917f, -0.02161060f, 
    0.02852391f, 0.01771368f, -0.03379200f, -0.00162858f, -0.03032858f, -0.03637914f, 0.00207926f, -0.03017401f, 
    0.02307457f, 0.00814683f, 0.01850154f, -0.02755824f, 0.03007024f, 0.01572350f, -0.04150786f, -0.03334339f, 
    -0.03558519f, -0.04437741f, 0.00254769f, -0.01682426f, 0.00341192f, -0.01322137f, -0.02402811f, -0.02897540f, 
    -0.03003203f, -0.02807245f, 0.02103420f, 0.02573238f, -0.01075029f, 0.02675238f, 0.00531439f, 0.00055320f, 
    0.00989090f, 0.02426760f, -0.02704777f, 0.02138720f, 0.00702042f, -0.01117594f, 0.01701735f, -0.03912334f, 
    -0.00636211f, 0.02865975f, 0.00933163f, -0.03724821f, -0.01458479f, -0.00089826f, 0.01971360f, 0.02161539f, 
    0.01301273f, -0.02618391f, 0.01576933f, 0.01798685f, -0.02627519f, -0.03435971f, -0.00218899f, -0.04335438f, 
    0.00674462f, 0.01545260f, -0.03598137f, 0.03025636f, -0.04300215f, -0.04057747f, -0.00207478f, 0.01948804f, 
    -0.00221287f, -0.00948908f, 0.00327310f, 0.01034196f, -0.03192480f, -0.02015674f, -0.03038631f, -0.03272668f, 
    0.01139014f, 0.00999953f, -0.02117643f, -0.00639762f, -0.03273470f, 0.02658308f, -0.03517125f, 0.02266545f, 
    -0.02498398f, -0.03464676f, 0.03152024f, -0.01211693f, -0.00346903f, 0.02458026f, -0.03814201f, 0.00046792f, 
    -0.02324093f, -0.02150378f, 0.00681987f, -0.02232072f, 0.02352856f, -0.00536124f, -0.02469455f, -0.03308666f, 
    -0.00546216f, 0.00886712f, 0.02448064f, 0.01296344f, -0.02676671f, -0.03477833f, -0.02722058f, 0.02543162f, 
    0.01186652f, 0.02580271f, -0.03360895f, 0.02944731f, -0.00570892f, -0.01112946f, 0.00113010f, 0.00406123f, 
    0.03273581f, -0.01749607f, -0.01497020f, -0.03774013f, 0.01320059f, -0.00809678f, -0.04005735f, 0.03211501f, 
    -0.00914502f, -0.03511023f, -0.00267830f, -0.01467738f, -0.03634429f, -0.04458482f, -0.03611284f, -0.04372510f, 
    -0.00705222f, -0.02539924f, -0.01614106f, -0.03652428f, -0.01797499f, -0.03924912f, -0.04084185f, -0.04401654f, 
    -0.03919692f, 0.02515177f, -0.04379176f, 0.02454872f, -0.02408715f, -0.02296643f, -0.03832237f, -0.01258679f, 
    0.03557588f, 0.02736300f, 0.00385895f, -0.03786511f, 0.01909092f, 0.01100571f, 0.02409364f, -0.04321824f, 
    0.02560849f, -0.00186568f, 0.00368356f, 0.02744472f, -0.02895034f, 0.02271727f, -0.04085202f, 0.00832361f, 
    0.01194190f, -0.03594190f, -0.00505884f, -0.00769383f, 0.00493799f, 0.00820308f, 0.01771257f, 0.00290528f, 
    -0.02952975f, -0.00338827f, 0.02203095f, 0.02284425f, -0.03298067f, 0.02975623f, -0.01940342f, -0.03542947f, 
    -0.03557611f, 0.00265711f, -0.01165083f, -0.03889592f, -0.01773418f, 0.02241662f, 0.02048648f, -0.03775498f, 
    -0.00106611f, -0.03388983f, -0.02502358f, -0.03398231f, -0.01118524f, 0.00886461f, 0.02380874f, 0.00058374f, 
    0.01335155f, -0.04217903f, 0.03091258f, 0.02618521f, 0.02482263f, -0.00637831f, -0.03694035f, -0.03825324f, 
    0.01575494f, 0.00385702f, 0.01936758f, 0.02451285f, 0.01853589f, -0.03682788f, -0.03918715f, 0.00102094f, 
    0.02460599f, -0.04305445f, 0.03167786f, -0.00217446f, -0.02241066f, 0.02659586f, -0.02058701f, 0.00926565f, 
    -0.01278363f, 0.02596892f, 0.01968362f, -0.01269594f, -0.00278064f, -0.00244992f, 0.01459513f, 0.01367895f, 
    0.00407015f, -0.00596635f, -0.04376866f, -0.00665397f, -0.03616374f, 0.00511832f, -0.00533077f, -0.00464599f, 
    0.02610333f, -0.02107392f, -0.03101520f, -0.01823825f, -0.00376470f, 0.00959195f, 0.02275004f, 0.00967809f, 
    -0.00712318f, -0.02421410f, -0.03799891f, 0.00878812f, -0.02916604f, 0.00645781f, 0.03043281f, 0.01416890f, 
    -0.01699565f, -0.01462553f, 0.03301384f, -0.01812765f, -0.03999186f, -0.00988200f, -0.01896526f, 0.01994938f, 
    -0.02350513f, 0.00239522f, -0.01067894f, -0.04373513f, -0.03503450f, -0.03098834f, -0.02422764f, -0.03346193f, 
    -0.03902727f, -0.01131066f, 0.00647270f, -0.04185326f, 0.01698638f, 0.02471842f, -0.00312292f, -0.02383927f, 
    -0.03222797f, 0.02039130f, -0.04544821f, 0.00377773f, -0.04504107f, -0.01047059f, -0.03564652f, -0.01613045f, 
    -0.01033504f, -0.01113594f, -0.03886196f, -0.02326573f, -0.02924245f, -0.01108510f, -0.01872312f, 0.02085762f, 
    0.02273556f, -0.00835432f, 0.01990898f, 0.00815503f, 0.01691055f, 0.03311860f, -0.01394954f, -0.01177678f, 
    0.00880107f, 0.02373717f, -0.03344264f, -0.03796695f, 0.00638685f, 0.00318775f, -0.02405978f, -0.03024428f, 
    -0.03222189f, -0.01741258f, 0.00618726f, -0.01370422f, 0.03135245f, 0.01128429f, -0.03325522f, 0.01595826f, 
    -0.04179502f, 0.02767038f, -0.03244805f, 0.02607403f, 0.00309649f, 0.01525916f, 0.00702072f, 0.02927073f, 
    -0.02971465f, -0.03951047f, 0.01509752f, -0.03407753f, -0.02559495f, -0.03522332f, 0.01915223f, 0.00736926f, 
    -0.04501549f, 0.01700964f, -0.01756970f, 0.01573294f, -0.01574859f, -0.01849842f, -0.04485437f, -0.00397602f, 
    -0.01224423f, -0.00282382f, -0.03763786f, 0.02069942f, 0.00267395f, -0.02180784f, -0.02668370f, -0.03979456f, 
    -0.03982482f, -0.02659396f, 0.01492677f, -0.03894372f, -0.01244828f, 0.00251413f, -0.03482809f, -0.03513770f, 
    0.00951600f, -0.04765970f, 0.02285172f, -0.02122608f, -0.03275187f, -0.01801292f, 0.01590643f, 0.02800333f, 
    -0.02114414f, 0.02845464f, -0.00936943f, 0.00515422f, -0.00700791f, -0.00765660f, -0.01812154f, 0.02387582f, 
    -0.02615584f, 0.01756922f, -0.01225558f, -0.04621853f, -0.04074574f, -0.00624118f, -0.00726390f, -0.03957205f, 
    0.00011467f, -0.02282761f, 0.01758762f, 0.00138082f, 0.03160372f, -0.03682188f, -0.04275920f, 0.00582212f, 
    0.01588679f, -0.04333068f, 0.02964908f, -0.00901049f, -0.03153606f, -0.00570219f, -0.03770478f, -0.03549461f, 
    0.00782299f, -0.02550943f, -0.04395304f, -0.03412022f, -0.02439387f, 0.02844521f, -0.02981427f, -0.01599492f, 
    -0.03762452f, -0.00923134f, 0.00058785f, 0.01608082f, -0.02598870f, -0.01072410f, -0.03557240f, 0.02394415f, 
    0.02445377f, -0.00210179f, 0.01447470f, -0.03705830f, -0.00867956f, -0.00393325f, -0.00825026f, 0.02283484f, 
    -0.00058469f, 0.01057664f, -0.00419362f, 0.02622465f, 0.02710848f, -0.03746299f, -0.02155448f, 0.00002568f, 
    -0.02275775f, -0.01215270f, -0.04799731f, -0.03107503f, 0.01027664f, 0.00779146f, -0.01703257f, 0.01698264f, 
    -0.00393351f, 0.01564153f, 0.00339416f, 0.03099056f, 0.00271657f, 0.00541850f, -0.00681714f, -0.01331514f, 
    0.00136170f, -0.00837857f, -0.00221016f, -0.02919434f, -0.01387444f, -0.01377206f, -0.00657596f, -0.02626575f, 
    -0.01218455f, 0.02957261f, 0.02215179f, 0.02133961f, 0.00469685f, -0.02193697f, 0.00935196f, -0.02578959f, 
    -0.02527283f, 0.02309905f, -0.00603941f, 0.02030797f, -0.00613756f, -0.00802651f, 0.03060608f, -0.03029503f, 
    -0.00464311f, 0.01440045f, 0.00448139f, 0.01824933f, -0.03266640f, 0.01504647f, 0.01095650f, 0.02162209f, 
    0.01439655f, -0.04251403f, -0.02878115f, 0.00289622f, -0.01319264f, 0.00778076f, -0.03320708f, -0.00450591f, 
    0.01124979f, -0.04216279f, 0.01562745f, -0.03680244f, -0.02024919f, -0.00252479f, 0.00527714f, -0.03561706f, 
    0.00681840f, -0.03037227f, 0.00606750f, -0.01832029f, -0.01827911f, 0.02875044f, 0.02046991f, -0.03107696f, 
    0.01388251f, -0.03990728f, 0.01262552f, 0.00094110f, 0.00122479f, 0.00044510f, -0.03464434f, -0.04448668f, 
    0.03195649f, -0.03775896f, 0.03091312f, -0.00732893f, 0.02731799f, -0.01211372f, 0.00597230f, -0.03492518f, 
    -0.02081161f, -0.01354615f, 0.00568846f, -0.01728254f, 0.02284161f, -0.00560644f, -0.01095135f, -0.01968453f, 
    0.01616949f, -0.03357323f, 0.02267544f, 0.00539587f, -0.00431876f, 0.01657079f, 0.00341974f, 0.01438061f, 
    -0.03118758f, 0.02982094f, -0.04747288f, -0.04036340f, 0.02386202f, 0.03582817f, -0.01930274f, 0.01603930f, 
    -0.04329989f, 0.02295007f, -0.04538418f, -0.00308356f, 0.02006214f, 0.01122630f, -0.01503982f, 0.02518837f, 
    -0.04100613f, -0.00356907f, -0.03422813f, -0.00320188f, -0.00465999f, 0.02324220f, -0.02453128f, 0.01097841f, 
    -0.01763195f, -0.03213286f, -0.04381827f, -0.02298019f, -0.04418598f, 0.00811187f, -0.01546512f, -0.01484956f, 
    -0.02727421f, 0.02916726f, 0.00104364f, -0.02642127f, 0.00357457f, -0.00781732f, -0.00214486f, 0.01363177f, 
    0.02896839f, 0.02465562f, -0.00872865f, 0.00491895f, 0.00854725f, -0.00259033f, 0.00400238f, -0.03567464f, 
    -0.04057270f, 0.02075028f, 0.01345919f, -0.02910450f, 0.01787138f, -0.04043753f, 0.02734785f, -0.00230712f, 
    -0.00552213f, -0.00340719f, -0.01953381f, 0.02192341f, -0.00468595f, -0.02604151f, -0.01604583f, -0.00680803f, 
    -0.02571452f, -0.01215288f, 0.02974330f, -0.01430277f, -0.02060273f, 0.00536241f, -0.02687432f, -0.01406821f, 
    -0.01655475f, -0.02932914f, 0.01037842f, -0.03102584f, 0.02877033f, -0.01058283f, -0.04388686f, -0.01749652f, 
    0.02919349f, -0.00789157f, -0.01208444f, 0.03282285f, -0.02549809f, 0.00764086f, 0.00945417f, -0.01269480f, 
    0.02063878f, -0.02397064f, 0.01469418f, -0.04521770f, 0.00810372f, 0.02126831f, 0.01843904f, 0.00223792f, 
    -0.03213703f, -0.02782643f, 0.00442713f, 0.01229842f, -0.00574891f, 0.02973127f, -0.02281802f, 0.01517382f, 
    -0.02543128f, -0.01209217f, -0.01165644f, -0.04377781f, -0.01576639f, 0.03089426f, 0.02709402f, 0.02231982f, 
    -0.02142461f, -0.04102036f, 0.00562138f, -0.04164487f, -0.02393933f, 0.02717489f, 0.02429310f, 0.02015039f, 
    0.02144998f, 0.00495012f, 0.00244174f, -0.01588310f, -0.01789242f, -0.01731794f, 0.00045885f, -0.01484886f, 
    -0.02519531f, 0.18793257f, -0.10619602f, 0.30932805f, -0.03033125f, 0.03370291f, 0.06441084f, 0.06120472f, 
    -0.00246580f, -0.04382822f, -0.03110978f, 0.10439869f, 0.03863404f, 0.05685432f, 0.11072882f, 0.02494285f, 
    0.00305823f, -0.13908710f, 0.15408780f, 0.04807743f, 0.18326253f, -0.15605085f, 0.13695607f, -0.10656267f, 
    -0.21041428f, 0.10345851f, 0.04487033f, -0.02846006f, -0.08630163f, 0.03249181f, 0.07783623f, -0.03367657f, 
    0.02501224f, -0.00090856f, -0.04970247f, 0.07172124f, 0.14390600f, -0.11389161f, -0.06418492f, 0.04162028f, 
    -0.46896362f, -0.03053866f, 0.33399561f, -0.08756354f, 0.07269873f, -0.05021642f, 0.06263893f, -0.12051560f, 
    -0.13363639f, 0.15709499f, 0.09894753f, 0.04963079f, -0.04209337f, -0.11250634f, 0.02496806f, 0.01124214f, 
    0.13113239f, 0.06538104f, -0.01285727f, 0.00454242f, 0.01355774f, 0.05104687f, -0.31019187f, 0.26047355f, 
    -0.26829553f, 0.00250776f, 0.10645521f, 0.00092930f, -0.06123799f, 0.15198085f, -0.12901960f, 0.04120139f, 
    0.09616613f, 0.05125898f, 0.08572260f, 0.02354582f, -0.11294737f, 0.06125622f, -0.10620867f, 0.08995813f, 
    -0.09482347f, -0.38413268f, 0.11117342f, 0.14505234f, 0.02519230f, -0.05998687f, -0.00325203f, 0.06999209f, 
    -0.22559416f, 0.00712115f, -0.10574183f, 0.12019619f, 0.07839694f, -0.15462895f, -0.06653775f, 0.00924612f, 
    -0.06015671f, 0.17904587f, 0.16511151f, -0.08714635f, 0.16659108f, -0.14534913f, -0.17037326f, -0.00348247f, 
    -0.11499480f, -0.00897035f, -0.07074228f, -0.13353355f, 0.25403696f, -0.03168611f, -0.01435830f, -0.18086915f, 
    0.05946926f, -0.07915521f, 0.02519649f, 0.00057844f, -0.02790014f, 0.02309469f, 0.20887412f, 0.06694638f, 
    0.19763325f, -0.06152076f, 0.27221578f, 0.23965950f, -0.34978428f, -0.18397431f, 0.20936172f, 0.06215130f, 
    0.09492046f, -0.00230654f, -0.05484838f, -0.07168508f, -0.07127505f, -0.00184010f, 0.05463522f, 0.18220308f, 
    -0.00613537f, -0.12251545f, 0.20544019f, 0.12960798f, 0.50324839f, 0.30769622f, 0.06070565f, 0.00826331f, 
    -0.05295618f, 0.00196259f, 0.02867193f, -0.09088459f, 0.04392523f, -0.00572227f, -0.24254970f, -0.02297062f, 
    -0.13120532f, -0.04306054f, 0.04102986f, -0.05683529f, 0.09686442f, -0.13172770f, 0.04950706f, 0.04491906f, 
    0.35741606f, 0.20966755f, -0.27718422f, -0.19160108f, 0.38594940f, 0.03319532f, 0.14014442f, 0.14137839f, 
    0.01212586f, -0.04639341f, 0.02302980f, 0.00555962f, 0.02288802f, -0.01993503f, 0.09577160f, 0.06043332f, 
    0.06849008f, -0.09105633f, -0.06914765f, -0.00958619f, -0.29990488f, 0.07037113f, 0.12522754f, -0.12549008f, 
    -0.04979946f, 0.06530746f, -0.13177645f, -0.02300086f, -0.18923649f, 0.11180088f, 0.02099584f, 0.15076962f, 
    -0.01770567f, -0.05516369f, -0.01039958f, 0.07931732f, -0.19367875f, 0.02164361f, 0.03514817f, 0.02093082f, 
    -0.06805586f, 0.43813983f, -0.11092488f, -0.47504020f, 0.23945579f, 0.01269973f, 0.00339344f, -0.02992163f, 
    -0.02295426f, 0.01889937f, -0.01077951f, -0.05471719f, 0.00933157f, 0.07967058f, -0.00009331f, -0.05821367f, 
    0.08241002f, -0.05978170f, -0.07761161f, -0.12213261f, -0.57668370f, -0.04487269f, 0.05384128f, -0.04013756f, 
    0.17134669f, 0.03727278f, 0.11133588f, 0.05445173f, 0.05760271f, -0.07457812f, -0.04606057f, 0.03390411f, 
    -0.03853966f, 0.09715192f, -0.00124870f, 0.00669678f, 0.01715033f, -0.04213616f, -0.05840157f, 0.15433040f, 
    0.28992391f, -0.26030681f, -0.01221263f, -0.14040676f, -0.03715927f, -0.01898349f, 0.04814734f, 0.24535872f, 
    0.17323996f, -0.05921270f, -0.01158657f, -0.12719393f, 0.10963024f, 0.01339347f, 0.05863072f, -0.01277848f, 
    0.04625323f, 0.23681775f, 0.04164515f, 0.03936154f, -0.25077546f, 0.08935481f, -0.18725586f, -0.47163460f, 
    -0.31623980f, 0.09706286f, 0.23081315f, -0.19931595f, 0.08987555f, -0.04757823f, 0.12004215f, 0.01097444f, 
    0.00847267f, 0.03104105f, -0.04377941f, 0.07829650f, 0.06792916f, 0.03741855f, -0.18319541f, -0.00189012f, 
    0.15439749f, 0.03061640f, -0.05361069f, 0.17987959f, -0.06362294f, -0.04137885f, -0.17051202f, -0.03946336f, 
    0.09660973f, -0.05225861f, -0.01518728f, -0.09207521f, -0.02781013f, -0.03619146f, 0.19113927f, 0.19265527f, 
    -0.05326552f, -0.00423772f, -0.04844666f, 0.10981113f, -0.20808358f, -0.19071250f, -0.16800998f, 0.19516107f, 
    -0.08823378f, 0.05412367f, -0.15283254f, 0.13474999f, 0.11464424f, -0.04608359f, -0.04620390f, -0.26947680f, 
    -0.05160662f, 0.15758370f, 0.10838341f, 0.17253241f, -0.22221540f, 0.00115306f, 0.00509990f, 0.22934645f, 
    0.18947579f, 0.12321802f, -0.07956665f, 0.19633231f, 0.08659253f, -0.09409116f, 0.09546233f, -0.05028320f, 
    0.09440724f, 0.09376432f, 0.04534172f, -0.00343035f, 0.03214376f, 0.05626660f, -0.04998520f, -0.04900134f, 
    0.22742446f, 0.04536010f, 0.08549289f, 0.00376703f, -0.23689044f, 0.30268055f, 0.01036221f, 0.27761713f, 
    -0.32956150f, 0.10218382f, 0.06012227f, 0.10728041f, -0.14338356f, -0.04691859f, -0.06895224f, -0.04981345f, 
    0.02483123f, -0.01697313f, 0.02498514f, -0.05215228f, 0.16575572f, -0.00210003f, -0.15032256f, 0.06823903f, 
    0.22708753f, 0.28897151f, -0.16480334f, -0.21878673f, -0.09488793f, 0.12013191f, -0.17634515f, 0.02586786f, 
    0.07806456f, 0.08171777f, 0.01348912f, -0.04981859f, -0.12968096f, 0.22332811f, 0.05221652f, -0.16116861f, 
    -0.18376435f, 0.05349880f, -0.04007691f, -0.12780596f, -0.07367394f, -0.13555147f, -0.12994093f, 0.17885824f, 
    -0.01825583f, 0.02403339f, 0.04698242f, 0.02609266f, -0.05260485f, -0.22943985f, 0.04465460f, 0.05017064f, 
    -0.00832494f, 0.03155427f, 0.06311058f, 0.03370696f, 0.21037905f, -0.02173567f, -0.19593565f, 0.04548957f, 
    -0.25668234f, -0.27527130f, 0.36159506f, 0.11496802f, -0.35030085f, -0.07946015f, 0.18608378f, -0.01069234f, 
    -0.15398212f, 0.07032418f, 0.13661298f, 0.23086888f, 0.08038083f, -0.02730967f, -0.05751680f, 0.00347200f, 
    -0.02742449f, 0.06419291f, 0.12837350f, -0.05943491f, 0.08835647f, 0.08020652f, -0.04481858f, 0.14645211f, 
    -0.11130036f, 0.04492911f, 0.10099401f, 0.00453178f, -0.12202600f, -0.01595970f, 0.03747231f, 0.18696117f, 
    0.09519265f, -0.14905402f, -0.05224343f, 0.03682585f, 0.12699881f, 0.03795232f, 0.21190529f, 0.10286973f, 
    -0.18362668f, -0.49660566f, 0.07455930f, 0.20303054f, -0.16790518f, -0.00365936f, 0.12696373f, 0.10691043f, 
    -0.20851304f, -0.15373379f, 0.01619146f, 0.12181723f, 0.07581332f, -0.04528462f, 0.05387143f, 0.00230139f, 
    0.29039246f, 0.01370171f, 0.05273986f, 0.01466987f, -0.12083986f, -0.14551295f, -0.05373983f, -0.12365457f, 
    0.22091287f, -0.03156623f, 0.00220231f, -0.04138299f, -0.00284395f, -0.02960074f, -0.08975358f, 0.04283587f, 
    -0.05211660f, 0.04504183f, 0.05563515f, 0.08910535f, 0.09889715f, -0.18222225f, -0.08964556f, 0.01827604f, 
    0.50616509f, 0.03634452f, -0.15284738f, 0.09259462f, 0.30637378f, -0.04858745f, 0.00276487f, 0.00649977f, 
    0.13187133f, 0.03008485f, -0.04577281f, 0.00886370f, -0.03834568f, 0.01059542f, 0.17712496f, 0.07655317f, 
    0.08317242f, -0.11734939f, 0.00391519f, 0.19910105f, -0.25353241f, 0.01332918f, -0.30770916f, -0.25808421f, 
    0.10306658f, -0.01727110f, -0.07836635f, -0.12910447f, 0.08883666f, -0.00894151f, 0.10984182f, -0.00153069f, 
    0.13667929f, 0.06750400f, 0.11665869f, 0.04888733f, 0.04142584f, -0.01127237f, -0.14426424f, 0.04230027f, 
    0.26550409f, 0.03594946f, -0.04597976f, -0.19192117f, 0.06934491f, -0.13295910f, -0.00552540f, -0.12689050f, 
    0.15939069f, 0.00403809f, 0.09629053f, 0.05831803f, 0.00322778f, 0.07905957f, -0.05644601f, 0.13402995f, 
    0.00974822f, -0.06085521f, -0.09171968f, 0.18973334f, 0.54640132f, 0.40475735f, 0.08967875f, 0.06117107f, 
    0.06446799f, -0.01237180f, 0.06804947f, -0.12100581f, 0.13455884f, 0.13352604f, -0.00809922f, -0.06183335f, 
    -0.11972229f, 0.09276630f, -0.00223262f, 0.11797328f, -0.02322805f, 0.00521242f, 0.06351367f, -0.04782363f, 
    -0.37108967f, 0.01621138f, -0.06586542f, 0.06736710f, -0.22237040f, 0.03282223f, 0.00265602f, 0.00870809f, 
    -0.01313818f, 0.05669880f, 0.01426563f, 0.18533911f, -0.03934801f, 0.01853293f, 0.07423444f, -0.07387397f, 
    0.00116847f, -0.10348110f, 0.05708965f, -0.01204222f, 0.17126016f, -0.10920361f, 0.01584889f, 0.19041520f, 
    0.02506050f, -0.11794046f, -0.08500148f, -0.04335699f, 0.15498735f, -0.00216039f, -0.05129414f, -0.09599654f, 
    0.03949861f, 0.14817341f, -0.01099751f, 0.00589594f, -0.01613935f, 0.06446107f, 0.06821556f, -0.13724880f, 
    -0.47183886f, -0.13963518f, 0.05598820f, 0.07149933f, -0.14993069f, 0.03830300f, 0.11340509f, -0.02906492f, 
    -0.16723022f, 0.09051799f, 0.05128056f, -0.04727365f, 0.05413382f, 0.04432346f, -0.00899558f, -0.09184921f, 
    0.09173010f, 0.03606845f, -0.05657721f, -0.04822922f, -0.09726194f, -0.11877917f, -0.08098815f, -0.09763157f, 
    0.17922726f, -0.10791244f, -0.06419767f, -0.07730804f, 0.01168656f, 0.05254179f, -0.04487138f, -0.08886345f, 
    0.06003095f, -0.02604785f, -0.02351658f, 0.10185345f, -0.01184770f, -0.16546208f, 0.04410233f, 0.03064150f, 
    -0.02291971f, -0.04060489f, 0.02145780f, -0.00522161f, -0.04478225f, 0.01707890f, 0.03041208f, 0.00724031f, 
    0.03275717f, -0.00353442f, 0.00839599f, -0.02357530f, 0.01729324f, 0.00555984f, -0.02286271f, -0.03388603f, 
    0.00186116f, -0.02077915f, -0.00158220f, -0.02276716f, -0.04326897f, 0.02973623f, -0.03754206f, -0.01213758f, 
    0.02064766f, 0.00333866f, -0.02000141f, 0.01200300f, 0.01922206f, 0.00171577f, -0.03948016f, 0.03315831f, 
    -0.01437771f, 0.00961192f, -0.00062356f, -0.03154727f, 0.02195006f, 0.02319705f, -0.03061918f, -0.01708480f, 
    -0.03723923f, -0.00059509f, -0.04311610f, -0.00249265f, -0.03195672f, -0.01351040f, -0.04092900f, -0.03124915f, 
    -0.00697240f, -0.01020016f, 0.00245312f, -0.03548998f, -0.02528455f, 0.00591499f, 0.00557895f, 0.02333983f, 
    0.01151598f, -0.03574486f, -0.03312067f, 0.02957496f, -0.01809911f, 0.01972724f, 0.02525608f, -0.04073764f, 
    0.00232897f, 0.01850055f, 0.00154114f, -0.00306054f, -0.03086202f, -0.02181643f, 0.03351987f, -0.02009867f, 
    0.02185236f, -0.00474624f, 0.00041955f, -0.03035957f, -0.00889490f, -0.00855099f, 0.02415434f, -0.04433532f, 
    -0.01330818f, -0.01623731f, 0.01584139f, 0.01345440f, -0.01008885f, 0.03013552f, 0.03234370f, 0.00900353f, 
    0.01092680f, 0.03140160f, 0.01221762f, -0.02481496f, -0.01205849f, -0.03065027f, -0.03428907f, -0.01044324f, 
    -0.00639796f, 0.01042016f, -0.00240214f, 0.00871951f, -0.01976003f, 0.02268867f, 0.01891835f, -0.00166633f, 
    0.03425454f, 0.00252519f, -0.02637574f, 0.01172053f, 0.02702714f, 0.01484503f, 0.02919927f, 0.02218279f, 
    -0.02053545f, 0.00533645f, -0.03794037f, 0.01903990f, 0.02401981f, -0.04216656f, -0.00226332f, 0.03292408f, 
    -0.01554042f, 0.02933469f, 0.00536500f, -0.01000713f, -0.00995250f, -0.01943763f, -0.03437009f, 0.00614971f, 
    -0.01443158f, -0.03579945f, -0.02665464f, -0.02613372f, -0.02241061f, -0.04045872f, -0.02421815f, -0.00871789f, 
    0.02556034f, -0.01554132f, -0.01977972f, -0.04373674f, 0.00977412f, -0.00824908f, -0.02628635f, -0.00030498f, 
    -0.02458237f, -0.02787481f, 0.00769244f, 0.00779791f, 0.02387899f, -0.04016152f, -0.02925722f, -0.01442957f, 
    -0.01346846f, -0.01410092f, 0.02210829f, -0.03327216f, -0.03050222f, 0.03165827f, -0.00204869f, -0.04541020f, 
    0.02425333f, -0.01679637f, -0.04348294f, -0.01136838f, -0.01530655f, 0.01321944f, -0.03380419f, 0.02744658f, 
    -0.02946055f, -0.00518548f, 0.01886054f, -0.04451810f, 0.01218895f, -0.00487744f, 0.00555669f, -0.00311175f, 
    0.01620605f, -0.01436306f, 0.01188746f, -0.01545445f, 0.01046783f, 0.02704415f, -0.00004034f, -0.03800236f, 
    -0.00340654f, -0.01636098f, -0.00750525f, -0.01875260f, 0.02690763f, -0.04492990f, -0.02295846f, 0.01918897f, 
    -0.00989061f, -0.01718667f, 0.00809859f, -0.02391938f, -0.00261781f, -0.04037312f, -0.02108111f, -0.01392045f, 
    0.01798716f, -0.02121529f, -0.03800097f, 0.02740439f, 0.00689628f, -0.00499747f, -0.03520897f, 0.01572828f, 
    -0.01889993f, 0.00163903f, -0.03193474f, -0.00204878f, -0.04543120f, 0.02733862f, 0.03145801f, -0.02828224f, 
    -0.01085307f, -0.00008086f, -0.01767316f, 0.00316636f, -0.00352470f, -0.01290332f, -0.03505608f, 0.02261014f, 
    0.01037105f, 0.01558850f, -0.01223326f, 0.02232560f, 0.02929537f, -0.01676210f, 0.03278847f, 0.01348874f, 
    0.02220209f, -0.00714367f, -0.03911678f, -0.01223835f, 0.00192425f, 0.00368737f, 0.01351743f, 0.02340665f, 
    -0.01154088f, -0.03171432f, -0.00605968f, 0.00205169f, -0.04135999f, -0.00906806f, 0.01367394f, 0.01084132f, 
    -0.02417534f, -0.04149982f, 0.03065797f, -0.02060677f, -0.04103599f, 0.01569180f, -0.02042239f, 0.02598291f, 
    -0.00601042f, -0.00699172f, -0.00829171f, -0.02168977f, 0.00366667f, -0.02645548f, 0.01530178f, 0.03821346f, 
    -0.03150807f, 0.01962532f, -0.02392934f, -0.01883701f, 0.01623587f, -0.03224612f, -0.00492122f, 0.01511354f, 
    -0.02278299f, 0.00710965f, -0.03434117f, -0.01052224f, -0.00589061f, -0.02534472f, 0.00492496f, 0.00862307f, 
    -0.03475184f, -0.04314208f, -0.03197332f, -0.02107751f, -0.02107920f, 0.03299521f, 0.01044039f, -0.00112325f, 
    -0.02273453f, -0.00760353f, -0.04325204f, 0.01923485f, 0.02414406f, -0.03220479f, 0.01887191f, 0.02910154f, 
    0.01552522f, 0.00742644f, 0.00303800f, 0.00531434f, 0.02716926f, 0.02917337f, 0.01887744f, 0.00588752f, 
    0.02392641f, -0.01426394f, -0.03413601f, 0.00184965f, 0.02550484f, -0.03688944f, -0.02206004f, 0.00181936f, 
    0.00051826f, -0.03392946f, -0.02769713f, -0.00355161f, -0.03577919f, 0.00896708f, 0.02025390f, -0.04282442f, 
    -0.01440327f, -0.01771916f, -0.02956294f, -0.00769194f, -0.01181346f, -0.00308028f, -0.01885184f, -0.02382623f, 
    0.00372746f, 0.01179386f, 0.01623981f, 0.01664561f, -0.01473953f, 0.01029386f, 0.02241695f, -0.02250450f, 
    -0.02885970f, 0.01163225f, 0.01385015f, -0.03350475f, -0.03623730f, -0.01299481f, 0.02601233f, -0.02104143f, 
    0.02590737f, -0.01095069f, 0.03273306f, -0.03008394f, -0.03952093f, 0.01911944f, 0.00943211f, 0.02104516f, 
    -0.01882107f, -0.00103290f, -0.03696792f, -0.03840148f, 0.02441474f, 0.02602646f, -0.03210481f, -0.03412672f, 
    0.03318648f, 0.00999407f, -0.04209186f, -0.01320592f, -0.02564989f, 0.00417079f, -0.03484761f, 0.03100005f, 
    0.03158467f, -0.01461550f, 0.01536265f, -0.01361351f, -0.01212413f, -0.01809165f, 0.02355956f, -0.03380743f, 
    -0.04511733f, 0.02264652f, -0.00378080f, -0.02891743f, 0.01341047f, 0.02666742f, -0.02358421f, -0.01816330f, 
    -0.02199433f, -0.02678118f, -0.04151437f, -0.04324768f, -0.01247725f, -0.02511843f, -0.02859336f, -0.01078683f, 
    -0.00036189f, -0.00466398f, 0.01892619f, 0.01142356f, 0.01507291f, -0.01264308f, -0.02715787f, 0.03178208f, 
    0.00583734f, 0.02751303f, 0.00933762f, 0.01156396f, -0.03799122f, -0.03767794f, -0.03457324f, -0.03139189f, 
    -0.01872085f, 0.03254536f, -0.00051796f, 0.01082111f, -0.01563367f, 0.01899898f, -0.02954974f, -0.03385067f, 
    -0.00641750f, -0.01800116f, -0.03158215f, 0.01797584f, -0.01638124f, -0.03234822f, 0.00244724f, -0.01465175f, 
    0.02342145f, 0.01856801f, -0.02186140f, 0.01427274f, -0.03876472f, -0.04495615f, -0.03697977f, 0.02226160f, 
    -0.03283810f, -0.00565791f, 0.02541090f, -0.04373159f, -0.03191654f, 0.01242569f, -0.00274254f, 0.00277577f, 
    0.03120147f, 0.03064105f, 0.00028354f, -0.01006563f, 0.03297868f, -0.03344698f, 0.02000889f, 0.01937202f, 
    -0.03700562f, -0.02470783f, -0.04156010f, 0.01723933f, -0.01663884f, -0.01396094f, -0.01158205f, 0.02170219f, 
    -0.03959393f, 0.01436059f, -0.04358984f, 0.01981344f, -0.01633291f, -0.00970489f, -0.03603948f, 0.01534516f, 
    0.02684117f, -0.02432789f, -0.03836570f, -0.02946096f, -0.01349520f, 0.00649272f, -0.01127845f, 0.01478815f, 
    -0.02654145f, 0.01908639f, -0.04542158f, 0.00068302f, 0.00118035f, -0.01565983f, -0.02428061f, -0.00416969f, 
    0.03051130f, 0.00811403f, 0.01065973f, 0.02981902f, 0.01048605f, -0.00835838f, 0.01336372f, 0.02984431f, 
    -0.04240092f, 0.01651170f, -0.03811856f, 0.01029813f, 0.01141433f, -0.02387874f, 0.00984331f, 0.02646473f, 
    -0.02756370f, 0.01735699f, -0.02739743f, 0.00072958f, -0.01403370f, -0.01931445f, -0.03740888f, -0.03855023f, 
    0.00288067f, -0.02639031f, -0.04175837f, -0.00132059f, -0.04472820f, 0.00880083f, -0.01084056f, -0.02122506f, 
    0.01226964f, -0.01150349f, -0.00144831f, -0.03707111f, 0.03134250f, -0.03245000f, 0.02458821f, -0.02067701f, 
    0.01062529f, -0.02137684f, -0.03654488f, 0.01245364f, -0.04010104f, -0.01407799f, -0.01397185f, -0.02827482f, 
    0.00150405f, 0.00358244f, -0.02426351f, -0.00557820f, -0.00130756f, 0.00684301f, 0.03126632f, 0.00276579f, 
    -0.04376512f, 0.01251569f, -0.02298261f, -0.00192714f, -0.04432479f, 0.01014347f, 0.00784409f, -0.03631793f, 
    0.01651532f, 0.00277759f, -0.02181365f, -0.03611735f, -0.01987551f, -0.02347139f, -0.04065157f, -0.03316297f, 
    -0.02642414f, 0.00690016f, -0.03225073f, -0.04134670f, -0.01905311f, -0.01790643f, -0.03412007f, 0.01375357f, 
    0.02348660f, 0.02149802f, -0.04060229f, -0.03427747f, -0.00470547f, -0.04311361f, -0.03491995f, -0.03794076f, 
    -0.03496465f, 0.01443892f, 0.03065373f, 0.00069471f, 0.01693477f, 0.03097295f, 0.01065094f, -0.02262494f, 
    0.01884746f, 0.00535212f, 0.00204578f, -0.02728222f, 0.00703905f, 0.01733026f, -0.04405804f, -0.04313239f, 
    -0.04364379f, -0.02215025f, -0.01533404f, 0.03152002f, -0.03831350f, -0.01728416f, -0.01750615f, -0.02713318f, 
    -0.02494979f, -0.01072488f, -0.02781220f, -0.00736123f, -0.00885254f, 0.01988063f, -0.03908773f, 0.00011061f, 
    0.01923465f, -0.03928962f, 0.03845075f, -0.01938977f, 0.01388576f, -0.03317431f, 0.02048498f, -0.03908159f, 
    -0.03924083f, -0.04225834f, -0.02812253f, 0.01098941f, -0.02879450f, 0.01831371f, -0.02184010f, -0.03045333f, 
    0.01652658f, 0.02018849f, 0.01796566f, 0.01324088f, -0.03913303f, 0.02857836f, -0.03922290f, 0.02703175f, 
    -0.01751898f, -0.03926285f, 0.00789414f, 0.01557355f, 0.02082320f, 0.01953190f, -0.01383323f, -0.04329825f, 
    -0.02235600f, 0.00827742f, 0.03165897f, -0.00318228f, -0.01379512f, -0.00833371f, 0.01725142f, -0.02255432f, 
    0.13598292f, 0.21389070f, 0.04622227f, 0.15270789f, 0.14989616f, 0.01864720f, 0.14697327f, 0.06064762f, 
    -0.02343001f, 0.07056280f, 0.05064694f, -0.01791548f, -0.12193342f, -0.02973250f, -0.05095292f, 0.07618813f, 
    0.06734004f, -0.05994314f, 0.28750217f, -0.14251521f, 0.70087695f, -0.55775577f, -0.07420027f, -0.08003697f, 
    0.36424109f, 0.04325530f, 0.05537261f, 0.04596320f, 0.07092445f, 0.10307201f, -0.01363743f, 0.00791354f, 
    0.04170226f, 0.13935395f, 0.03190900f, 0.02979536f, 0.01702840f, -0.03150322f, 0.01364755f, 0.07105075f, 
    0.11175290f, -0.08676302f, 0.00181278f, -0.20267530f, -0.10607442f, 0.16033921f, 0.13594298f, 0.10192155f, 
    0.08604715f, 0.00297301f, -0.01838388f, 0.05496908f, 0.04617712f, 0.01691034f, -0.16463386f, 0.08169884f, 
    0.05951149f, 0.03707241f, -0.00480690f, 0.12373292f, 0.35689917f, 0.22972281f, 0.18045993f, -0.08336521f, 
    0.25832915f, -0.03864709f, 0.00841436f, 0.01910213f, -0.12088159f, 0.11169489f, 0.01837094f, 0.09169324f, 
    0.03795097f, 0.02655161f, 0.04402704f, 0.13548878f, 0.06527854f, 0.10784363f, 0.02134340f, 0.11973181f, 
    0.07550644f, 0.13825074f, -0.10116042f, -0.11435205f, -0.04227639f, 0.11196350f, 0.02692340f, 0.17822212f, 
    0.06103724f, 0.13424416f, -0.00864624f, 0.05993145f, 0.08799000f, -0.17146227f, -0.09161078f, -0.00183424f, 
    -0.09069333f, -0.11883157f, 0.25240541f, -0.07938354f, 0.36743495f, 0.21704419f, 0.13344309f, 0.18040131f, 
    0.07890335f, -0.11060184f, -0.06669639f, -0.09323349f, -0.15379269f, -0.08906581f, -0.02065122f, -0.07235488f, 
    0.08307955f, 0.03259554f, 0.12624359f, -0.03638598f, -0.00315697f, 0.13050506f, 0.10385045f, 0.00038840f, 
    0.12938623f, 0.34475425f, 0.02965870f, -0.14939620f, 0.11292893f, -0.23711506f, 0.12483842f, -0.01144468f, 
    -0.09451335f, -0.07020818f, -0.00933750f, -0.02821450f, -0.06659491f, 0.01654834f, -0.11548658f, 0.18615060f, 
    -0.05449330f, 0.16325212f, 0.21815667f, 0.10643581f, 0.32247049f, 0.19510393f, -0.02451970f, 0.06058437f, 
    0.29578516f, -0.09979051f, -0.17826359f, -0.09302720f, 0.07443199f, 0.08124238f, 0.00046062f, -0.09087829f, 
    0.09998743f, 0.03651526f, 0.03773103f, -0.01148840f, 0.04432997f, -0.00436118f, 0.10877371f, 0.02473830f, 
    0.25428301f, -0.19017977f, -0.16252783f, -0.09779332f, 0.07491366f, 0.00938408f, 0.10205370f, -0.11018792f, 
    0.06353167f, 0.02019369f, 0.03673372f, 0.06286301f, 0.01470461f, 0.08577811f, -0.03972007f, 0.06611048f, 
    0.01706999f, -0.10217402f, -0.06876694f, -0.05017790f, 0.16180606f, -0.20019828f, -0.01117246f, -0.24345861f, 
    -0.11462743f, 0.16793284f, 0.14830491f, 0.16774538f, -0.02871509f, -0.11438898f, 0.03017528f, 0.03211330f, 
    0.04289304f, -0.05465198f, -0.11658696f, -0.03085662f, -0.07349566f, -0.06897132f, -0.00160521f, -0.00056195f, 
    0.28346616f, -0.26637718f, -0.18324089f, 0.15110120f, 0.22869372f, 0.05039207f, -0.00094769f, -0.02254821f, 
    0.19394307f, 0.11452483f, 0.03046565f, -0.19145016f, 0.03102305f, -0.03062617f, -0.06589376f, 0.20860155f, 
    -0.06299001f, -0.05189126f, 0.00170839f, 0.07416502f, 0.07476118f, -0.24274325f, 0.10555788f, -0.09615804f, 
    -0.10991115f, 0.15391040f, 0.10216329f, 0.05321323f, 0.04994605f, -0.05635558f, 0.12094716f, 0.00636243f, 
    -0.05049011f, 0.12471175f, 0.02811643f, 0.10720148f, 0.03164006f, -0.09180665f, -0.10140406f, 0.01073062f, 
    0.04454249f, 0.33889672f, 0.05805269f, -0.12990372f, 0.03043121f, 0.03273173f, -0.00457305f, 0.22710136f, 
    -0.04843213f, -0.03025558f, -0.02305226f, 0.08304729f, 0.06705691f, 0.00306626f, 0.10686096f, 0.00834819f, 
    0.07209637f, 0.16091582f, 0.21397305f, 0.03205183f, -0.46147308f, -0.02216512f, -0.31943384f, -0.11659367f, 
    -0.45792878f, 0.03482854f, 0.15538022f, 0.01016534f, -0.10582983f, -0.03632363f, 0.07234089f, -0.02913432f, 
    0.08299976f, -0.06379624f, -0.00578379f, 0.07265878f, -0.09704529f, -0.09853357f, -0.14159691f, -0.10703469f, 
    0.23696774f, 0.15258281f, 0.23260669f, 0.00819897f, 0.27940089f, 0.02994600f, -0.02857404f, -0.02303163f, 
    -0.06561328f, 0.06733123f, -0.01695550f, -0.12368171f, -0.06896844f, 0.19428173f, 0.14596380f, 0.13728802f, 
    0.00875125f, 0.10367634f, 0.02756579f, 0.03725443f, 0.10433083f, 0.21395250f, 0.13766502f, 0.17344570f, 
    0.23056033f, -0.08670960f, -0.05009988f, -0.15201737f, 0.02177206f, 0.07455114f, -0.15964885f, -0.04998713f, 
    -0.07497089f, 0.26513898f, 0.12487222f, -0.09584615f, -0.12423227f, 0.16314977f, -0.00766959f, 0.04323344f, 
    0.69674844f, -0.17040516f, 0.24925041f, 0.25538227f, 0.05955732f, -0.05982595f, -0.06421454f, -0.06390013f, 
    -0.01488154f, 0.22138724f, -0.05341895f, 0.14144610f, 0.01524186f, -0.14259669f, 0.02864107f, -0.01696007f, 
    0.11308774f, 0.03271210f, 0.07774831f, 0.04488561f, -0.11474860f, 0.09285495f, -0.22398128f, 0.08064326f, 
    0.09887375f, 0.05926871f, 0.22034894f, 0.02784378f, 0.05041900f, 0.26534447f, -0.03523131f, -0.01003816f, 
    -0.07938793f, -0.05052047f, -0.01809838f, 0.03467852f, -0.00808556f, 0.09525058f, -0.05293815f, 0.07359536f, 
    0.28328377f, 0.00792014f, -0.20582651f, 0.06050072f, 0.33210558f, 0.15453832f, -0.05706014f, -0.01460312f, 
    0.10595205f, 0.12155963f, 0.12278016f, -0.11111726f, -0.03808291f, 0.11484529f, -0.12768029f, 0.01203874f, 
    -0.15124987f, -0.03762337f, -0.02683285f, -0.11097524f, -0.14342457f, -0.13168563f, -0.12899192f, 0.01840311f, 
    -0.24099913f, 0.09580582f, 0.04258724f, 0.21323955f, 0.07612775f, -0.06192136f, 0.15610935f, -0.05597091f, 
    0.02059785f, 0.13451138f, 0.02990058f, 0.01484019f, -0.04386733f, -0.01470269f, -0.09347293f, -0.15186703f, 
    -0.07116038f, 0.02372402f, -0.16832411f, -0.04705028f, -0.10675950f, 0.11630081f, 0.19808732f, 0.13051917f, 
    -0.11421105f, 0.04987470f, 0.07245673f, 0.19253063f, 0.08344384f, -0.09762008f, -0.03040357f, 0.05616986f, 
    0.04035963f, -0.01743236f, 0.08506202f, 0.16075870f, 0.31768221f, 0.51205653f, 0.13135386f, 0.08603214f, 
    0.14848484f, -0.05372940f, 0.10509418f, -0.02192215f, -0.10307329f, -0.00841795f, 0.01598609f, -0.16638611f, 
    0.03727121f, -0.12748255f, -0.00475453f, -0.06533758f, 0.02966548f, -0.02397102f, 0.39625832f, -0.06495298f, 
    -0.26352555f, 0.33274254f, -0.05867866f, 0.02363466f, 0.16801985f, 0.07801042f, 0.17605965f, 0.10383029f, 
    -0.00952530f, 0.07631855f, 0.01567122f, 0.07007723f, -0.17159986f, 0.01075493f, -0.00811953f, -0.03173850f, 
    0.21335861f, 0.24626815f, 0.06461427f, 0.08709010f, -0.02173795f, -0.14959790f, -0.19674359f, -0.12757301f, 
    -0.08107532f, 0.05634165f, 0.18622035f, 0.03483178f, 0.01560641f, -0.05300865f, 0.05164021f, -0.09334243f, 
    -0.04397018f, 0.14053908f, 0.00823681f, 0.05653565f, -0.06786636f, -0.08635476f, -0.08650731f, -0.07133346f, 
    -0.16352107f, -0.33465403f, -0.29003909f, -0.11125264f, -0.16824359f, 0.06919960f, -0.07790233f, -0.04348859f, 
    0.05459686f, -0.00499282f, -0.05584721f, 0.15585525f, 0.15779361f, 0.12538347f, -0.03316846f, -0.05219335f, 
    0.02851161f, -0.02776649f, -0.21431491f, 0.06302814f, -0.24266262f, 0.03506423f, -0.20989670f, 0.01588443f, 
    -0.27824709f, 0.01254985f, -0.06165969f, 0.08124276f, -0.05271938f, -0.04351947f, -0.06565447f, 0.05709861f, 
    0.09891792f, -0.07783480f, 0.05918290f, -0.01943899f, -0.04383606f, -0.06054983f, -0.07790354f, -0.13535719f, 
    0.18367578f, -0.08655621f, -0.11312481f, 0.00910928f, 0.40907466f, 0.14908738f, 0.10245492f, -0.04576110f, 
    0.03021560f, 0.12320007f, -0.04824305f, 0.04926418f, -0.07989632f, 0.17786799f, 0.02487219f, 0.14230917f, 
    0.11597765f, -0.00086230f, 0.08272646f, -0.01695366f, 0.48289433f, -0.07634155f, 0.05479956f, 0.21371256f, 
    0.04726836f, 0.03567034f, -0.13005583f, 0.00936406f, -0.10711101f, 0.13283567f, -0.01960192f, 0.03330024f, 
    -0.03769600f, 0.03865983f, 0.11906676f, -0.08986202f, 0.04962050f, -0.03543287f, -0.00375827f, -0.03446959f, 
    0.40479887f, -0.00215510f, -0.07519884f, 0.04263759f, 0.14541961f, 0.02676558f, 0.12301435f, -0.08251847f, 
    -0.02928431f, 0.17177947f, -0.05124549f, 0.05331657f, 0.05132919f, -0.06160409f, -0.05134065f, 0.03050155f, 
    -0.05691291f, 0.05269582f, 0.12161210f, 0.01632708f, 0.32403880f, -0.14595596f, 0.10033641f, 0.25841597f, 
    0.22821538f, -0.07455163f, -0.12303538f, -0.13547194f, -0.01894083f, 0.24167822f, -0.06655598f, 0.06427079f, 
    0.10328170f, -0.04876554f, 0.07026103f, -0.21241866f, -0.17191206f, 0.06635736f, -0.04357975f, 0.06313227f, 
    -0.25323248f, -0.09672507f, -0.01729872f, 0.07698395f, -0.20132974f, 0.23550729f, 0.18800659f, 0.21594058f, 
    0.00454561f, -0.07311648f, -0.05348219f, 0.04717980f, -0.00044518f, 0.16062820f, 0.07168230f, 0.03990534f, 
    0.04004959f, -0.09572805f, -0.05223285f, -0.04152615f, -0.36756033f, -0.12924093f, -0.05559447f, 0.11854719f, 
    -0.32901153f, 0.17182498f, -0.16625091f, 0.15149228f, 0.00921218f, -0.11642281f, 0.06264135f, -0.00926033f, 
    0.08816041f, 0.05571185f, -0.03215075f, 0.01285956f, -0.04703299f, -0.07060274f, -0.07749050f, -0.06386817f, 
    0.01269639f, -0.02423997f, 0.01578606f, -0.03186939f, 0.00260421f, 0.00012146f, 0.02500008f, 0.03155203f, 
    0.02479252f, -0.02305076f, 0.02054151f, -0.01819840f, 0.00543790f, -0.02807794f, -0.00508520f, -0.04217388f, 
    -0.03437207f, -0.03817065f, -0.02237976f, -0.04526643f, -0.00685815f, 0.03017182f, 0.01601645f, -0.00474974f, 
    -0.01890606f, -0.02761999f, 0.03042342f, -0.03851996f, 0.03090941f, 0.02808476f, 0.02643935f, -0.00785899f, 
    0.01033806f, -0.02041205f, 0.00050109f, -0.02933144f, 0.02097852f, -0.01431430f, 0.00718934f, -0.02944246f, 
    -0.04373450f, -0.04097839f, 0.01333883f, -0.00232097f, -0.01928757f, 0.02153619f, 0.02932522f, -0.01651901f, 
    0.00383889f, 0.02295704f, -0.02133240f, 0.02180619f, 0.00555048f, 0.02661037f, 0.03290335f, -0.02530380f, 
    -0.03867038f, 0.01354241f, -0.01484134f, 0.02179041f, -0.02463750f, -0.02942518f, 0.00281370f, 0.00655014f, 
    -0.01246931f, -0.03043414f, -0.01305980f, -0.02292645f, 0.01095256f, 0.02755409f, 0.00390937f, 0.01900504f, 
    -0.04329002f, 0.00335615f, -0.04041294f, 0.03349407f, -0.01888631f, -0.02937601f, -0.01055953f, 0.01854268f, 
    0.00910249f, -0.00748849f, 0.00292270f, -0.01285568f, 0.01600948f, -0.01190725f, -0.02969051f, -0.04220922f, 
    -0.00925835f, 0.00722874f, 0.00734762f, 0.02749859f, 0.02206569f, -0.00868922f, -0.00171745f, 0.00610111f, 
    -0.00185462f, 0.01369593f, -0.01270804f, -0.01517125f, -0.03003267f, -0.04697019f, -0.01449330f, -0.00872696f, 
    -0.02075816f, -0.00477443f, -0.01162656f, 0.03125806f, 0.01765653f, -0.04500059f, -0.04077233f, -0.03214783f, 
    -0.02754393f, 0.00516267f, 0.03394550f, 0.03209199f, -0.04496681f, 0.02631389f, -0.03258318f, 0.02015469f, 
    0.01393052f, -0.02699947f, -0.04219575f, 0.03157074f, -0.03582468f, -0.02857036f, 0.01107699f, 0.01249867f, 
    -0.03905810f, 0.01696009f, -0.02009436f, 0.01767695f, -0.01377142f, 0.02876466f, 0.01908927f, 0.02299739f, 
    -0.00733587f, -0.01065839f, -0.04639798f, 0.02693396f, 0.00150736f, 0.01635532f, 0.02917782f, -0.03995797f, 
    0.03037239f, -0.02638036f, -0.03361391f, -0.02367241f, -0.01880557f, 0.01865648f, -0.01691908f, -0.01356705f, 
    0.00523846f, -0.02962498f, -0.02118953f, -0.02474693f, -0.00009135f, -0.03592477f, -0.03737126f, -0.01116855f, 
    0.02020065f, -0.03559045f, -0.02739241f, -0.02416934f, -0.03369702f, -0.01704322f, -0.02272416f, -0.04489588f, 
    -0.03069340f, -0.01342882f, -0.00370782f, 0.00944894f, 0.00583941f, -0.03684215f, 0.00538813f, -0.03419353f, 
    -0.00857775f, -0.03157161f, 0.00729507f, -0.04225542f, -0.02713606f, 0.00796151f, 0.01742818f, 0.00462687f, 
    -0.00631208f, 0.02278690f, 0.01248061f, 0.00272956f, 0.03153428f, -0.01309418f, -0.02620724f, -0.01397765f, 
    0.00344511f, -0.01876178f, -0.00454879f, 0.01938928f, 0.00037742f, -0.02180123f, 0.00617649f, -0.01740657f, 
    0.01213550f, -0.02790192f, -0.02136626f, -0.04513758f, 0.00764118f, -0.00652317f, -0.00125022f, -0.01232915f, 
    0.00262398f, 0.01932894f, -0.01356030f, -0.02804794f, 0.00947389f, -0.01774960f, -0.01966662f, 0.02802732f, 
    -0.03864285f, 0.00857981f, 0.00874198f, -0.00823238f, 0.00660085f, 0.00759918f, -0.00738024f, -0.03860424f, 
    -0.00514837f, 0.01819703f, 0.03775483f, 0.02229016f, -0.00735280f, -0.00082674f, 0.02439429f, 0.00666374f, 
    0.00231072f, -0.03026059f, 0.01123813f, -0.04258065f, 0.02300906f, -0.00885560f, -0.01960668f, -0.02216949f, 
    -0.02259755f, -0.03729888f, -0.01324838f, 0.03212206f, -0.01746352f, -0.01138423f, -0.03261828f, 0.02506807f, 
    0.02173003f, 0.00120491f, 0.00435585f, -0.02177389f, -0.02668459f, -0.01868555f, -0.04058985f, 0.02984045f, 
    -0.03506542f, -0.04501296f, -0.03207869f, -0.03873554f, 0.01477845f, 0.02100504f, -0.02475482f, -0.00725167f, 
    -0.04326743f, 0.01286001f, 0.00420020f, -0.02091928f, 0.01576895f, -0.02557205f, -0.02629091f, 0.02910276f, 
    -0.03376575f, 0.01317439f, 0.02120070f, -0.03837018f, 0.01564671f, -0.04268151f, 0.00794729f, 0.02995496f, 
    0.02872308f, 0.02283181f, 0.03254030f, -0.04019514f, 0.02082165f, -0.03806936f, -0.01704919f, 0.01207689f, 
    0.03277189f, -0.00973128f, -0.01108794f, 0.01509139f, -0.01066313f, -0.00689333f, 0.01715539f, 0.02679121f, 
    0.00827785f, 0.00151120f, -0.00931025f, -0.02459011f, -0.00694577f, 0.03213209f, 0.00761531f, -0.01428776f, 
    -0.02488988f, 0.02937507f, -0.01150993f, -0.02591971f, 0.02257141f, -0.03280189f, 0.00734990f, 0.02591423f, 
    0.03503377f, -0.01956390f, 0.00536292f, 0.00544823f, 0.02143241f, 0.04451512f, -0.01375011f, -0.01764974f, 
    0.01262804f, 0.03165638f, -0.02305993f, -0.00498170f, -0.02547584f, -0.01337630f, 0.00993115f, 0.01507717f, 
    -0.01083440f, -0.04525293f, 0.02544020f, -0.02455582f, -0.02874695f, -0.02335244f, 0.02421284f, 0.03100509f, 
    -0.00724096f, 0.01317377f, 0.01016500f, -0.01597962f, -0.03132850f, 0.00428550f, 0.03063983f, 0.03338303f, 
    -0.00887340f, 0.02948652f, -0.03504806f, -0.01953421f, -0.04373204f, -0.03115646f, -0.01422482f, 0.03123426f, 
    0.00293987f, 0.00519719f, -0.01674733f, -0.03111348f, -0.03884090f, 0.01546465f, -0.00052204f, -0.01539571f, 
    -0.02861926f, -0.03514946f, -0.01299414f, -0.03891480f, -0.00344755f, 0.01064855f, -0.04268598f, 0.02384305f, 
    0.02549195f, 0.00355158f, -0.01050105f, -0.01142354f, 0.02551670f, -0.02091837f, 0.02744632f, -0.01147092f, 
    0.03337640f, 0.02377696f, -0.04467328f, 0.03044817f, -0.03250606f, -0.03467224f, -0.01725258f, -0.03733103f, 
    0.00060250f, -0.01992895f, -0.03472048f, -0.00770955f, 0.00985297f, 0.03097468f, 0.03751526f, 0.01349767f, 
    0.00064735f, 0.02455923f, -0.01990218f, 0.03225127f, 0.00036611f, -0.03494462f, -0.01070910f, 0.02455545f, 
    -0.00275331f, 0.02237917f, 0.01318956f, 0.00949701f, 0.01784974f, 0.00337685f, -0.00717752f, -0.04254889f, 
    -0.02546573f, -0.03776015f, -0.02743965f, 0.01738179f, -0.00906932f, -0.02935595f, -0.01233173f, -0.00065476f, 
    0.03050539f, -0.00313173f, 0.01825851f, -0.04510910f, 0.02513113f, 0.00448526f, 0.00981933f, -0.02406442f, 
    -0.03877513f, -0.02128163f, -0.01334180f, -0.04561042f, -0.00754507f, 0.02576058f, 0.01470686f, -0.00915048f, 
    0.02794664f, 0.02560237f, -0.01067632f, -0.01157353f, -0.04097741f, 0.00404797f, -0.01734166f, 0.02728274f, 
    -0.04091072f, 0.02575309f, -0.01040430f, 0.01318734f, -0.03874735f, -0.02047661f, -0.03722943f, -0.01719080f, 
    -0.04201278f, -0.00087440f, -0.01690536f, -0.00565371f, 0.01350904f, 0.02450335f, 0.02296253f, 0.00949649f, 
    -0.03009389f, 0.00646895f, 0.02754148f, 0.00594285f, 0.00379625f, 0.02770455f, -0.01342714f, 0.02957176f, 
    0.03188578f, -0.01819565f, -0.04194144f, 0.02366234f, -0.00129279f, -0.01314562f, 0.01734122f, -0.02716117f, 
    -0.02972091f, 0.03003542f, 0.00938343f, -0.01436071f, -0.02119065f, 0.00170348f, -0.00640616f, -0.02544400f, 
    -0.04243534f, 0.02520516f, -0.03561806f, -0.02304739f, 0.01651228f, 0.01275448f, -0.00182400f, -0.02111691f, 
    -0.04198403f, -0.03929582f, 0.01947733f, -0.01252967f, 0.00142892f, -0.04049548f, 0.00861885f, 0.02759362f, 
    -0.04247645f, 0.00736598f, 0.02474156f, -0.00407405f, -0.01505660f, -0.03266031f, 0.01117137f, -0.03208500f, 
    0.03236244f, -0.02936353f, 0.01151255f, -0.00130593f, -0.04618002f, -0.04277131f, 0.02373246f, 0.03117753f, 
    0.01885472f, 0.03111652f, 0.01305477f, -0.02864642f, -0.01524537f, -0.04127304f, -0.00978480f, -0.02459717f, 
    -0.00531794f, -0.03155411f, -0.00264157f, 0.02900407f, -0.04400727f, 0.00693179f, -0.03712729f, 0.02087455f, 
    -0.02239527f, 0.01041576f, -0.00030775f, 0.03021428f, 0.01573847f, -0.02153524f, -0.00648050f, -0.02703566f, 
    0.02104669f, -0.00507623f, -0.02625279f, -0.00282199f, -0.03337051f, 0.02747027f, -0.02539490f, -0.02711160f, 
    0.01870961f, -0.00241455f, -0.03749117f, 0.01253690f, -0.03135162f, 0.00419806f, 0.00977562f, -0.03097379f, 
    0.00363503f, -0.00808187f, -0.02157777f, 0.01664791f, -0.03853758f, 0.01872748f, 0.01492961f, 0.00914774f, 
    -0.01317834f, -0.00763603f, -0.00197183f, -0.01441287f, -0.01517031f, -0.03986869f, 0.00642517f, -0.02779568f, 
    -0.02465017f, -0.02382149f, -0.02992281f, 0.03244818f, -0.00326536f, 0.02781406f, 0.02908847f, -0.02873120f, 
    -0.04509434f, 0.01726607f, -0.01884314f, -0.03303715f, -0.03428676f, -0.00890585f, -0.00583524f, -0.03811346f, 
    -0.00212870f, 0.02843809f, 0.02946318f, -0.01656633f, 0.00178205f, 0.02912317f, -0.00911473f, 0.00185786f, 
    -0.01283844f, -0.04016121f, -0.01730817f, -0.02290603f, -0.01358536f, -0.00669446f, 0.01622299f, -0.02880649f, 
    -0.02796480f, 0.01186746f, -0.01929315f, 0.02336718f, 0.02972566f, -0.03510468f, 0.03513436f, -0.02584016f, 
    0.02376214f, 0.01550962f, 0.00209420f, -0.01507859f, -0.00334914f, -0.04578206f, 0.01072532f, 0.00208905f, 
    -0.02030963f, 0.00209206f, -0.03688496f, 0.00123342f, -0.00857825f, 0.03213981f, -0.02023167f, 0.01892256f, 
    0.00273409f, -0.01860056f, -0.00638928f, -0.00463444f, 0.01578089f, -0.01598367f, -0.00951950f, -0.03072161f, 
    -0.00209000f, -0.03054170f, -0.03699238f, 0.02918291f, -0.01867368f, -0.04175328f, 0.01112065f, -0.00691742f, 
    -0.40424991f, 0.43714058f, -0.19981173f, -0.00825314f, 0.01358963f, 0.01392855f, 0.14050426f, -0.08378635f, 
    0.07848132f, 0.04405677f, -0.09986238f, 0.07238983f, 0.03367548f, 0.02772673f, -0.10181256f, 0.14116153f, 
    -0.02530328f, 0.06779166f, 0.09728478f, 0.08658379f, -0.18730953f, 0.27627906f, -0.01406473f, 0.06753255f, 
    -0.37458527f, 0.04359634f, 0.06594888f, 0.12231033f, 0.07661512f, 0.16694848f, -0.06431821f, -0.04921111f, 
    -0.03276078f, -0.02789876f, -0.10698616f, 0.04662405f, 0.05724642f, 0.07494346f, 0.03712042f, 0.09698267f, 
    0.57751548f, 0.11870825f, -0.26378107f, -0.04675858f, 0.19337612f, -0.23283160f, 0.02484202f, -0.02409838f, 
    -0.01453987f, 0.05111865f, 0.17391412f, -0.03701698f, 0.19116521f, 0.10532341f, 0.10383930f, -0.06082734f, 
    0.08935872f, -0.09019761f, -0.13428779f, 0.01843147f, -0.18838704f, -0.35219330f, -0.17391972f, 0.37910289f, 
    -0.04730877f, 0.04655414f, 0.02355949f, -0.03073286f, 0.09884401f, 0.02430608f, 0.01246886f, 0.16976507f, 
    0.05953182f, 0.03905170f, 0.05215090f, -0.02761845f, -0.05020992f, -0.07924481f, -0.14552699f, 0.05617021f, 
    0.11622688f, -0.02340097f, 0.15260814f, 0.02442242f, 0.16678040f, -0.08038892f, 0.05813477f, 0.07236932f, 
    0.10312941f, 0.03367962f, 0.01302807f, 0.08999077f, -0.04845253f, -0.01399127f, 0.06637862f, -0.00210087f, 
    -0.00292603f, 0.05280995f, 0.04525728f, 0.05592977f, 0.13067029f, 0.05233375f, -0.34211862f, 0.03155767f, 
    -0.20477082f, -0.06959450f, -0.13173734f, 0.03492054f, 0.06919254f, 0.05988154f, -0.04447407f, -0.06706127f, 
    0.04314485f, 0.08244202f, 0.00514314f, 0.08088071f, 0.10066164f, -0.02333438f, -0.05025986f, -0.07132133f, 
    -0.23737469f, -0.13704126f, 0.08355274f, 0.08187577f, 0.05186458f, -0.00038813f, -0.15737242f, 0.01321481f, 
    0.01712079f, 0.07859159f, 0.00232285f, -0.02306501f, 0.15978412f, 0.14848916f, 0.05982680f, -0.01141211f, 
    0.08728667f, -0.07696175f, -0.16286567f, -0.06907394f, 0.11231419f, 0.23504525f, -0.02497537f, 0.07608415f, 
    -0.36293942f, 0.01943613f, -0.04992551f, 0.01448183f, 0.08607163f, 0.14995822f, 0.04410719f, 0.00253620f, 
    0.07746325f, -0.10539000f, -0.03870720f, 0.12538311f, 0.02831441f, -0.17310755f, 0.05179969f, 0.01586627f, 
    -0.52421242f, 0.17119533f, 0.07182983f, -0.14211039f, 0.12310400f, -0.12845452f, 0.18871485f, -0.10260691f, 
    -0.06061152f, -0.06389660f, 0.02980819f, 0.04245787f, 0.23241745f, 0.03528243f, 0.05402744f, 0.12052817f, 
    -0.08490024f, -0.01853859f, 0.09905168f, 0.02798584f, 0.47228032f, 0.21405070f, -0.20459472f, 0.01353018f, 
    0.10958586f, -0.16512676f, 0.08244283f, -0.02347979f, 0.08221023f, 0.11268128f, 0.01829784f, -0.09153683f, 
    0.12898666f, 0.13750850f, 0.09112799f, -0.01986024f, 0.09108976f, 0.01765016f, -0.10960616f, -0.04686327f, 
    -0.32515159f, -0.12682308f, 0.12032107f, 0.03490077f, -0.02988497f, -0.10534517f, 0.14040743f, 0.00266444f, 
    -0.19658846f, -0.02732899f, -0.00582783f, 0.01752944f, 0.07284261f, 0.08518486f, 0.13749835f, 0.03145572f, 
    -0.06730983f, 0.01248282f, 0.10022040f, 0.06625494f, 0.17440696f, 0.27721557f, -0.07135471f, -0.00388769f, 
    0.18548219f, -0.14269796f, 0.06996521f, 0.01331049f, 0.05097929f, 0.05938337f, 0.10201870f, 0.03515195f, 
    -0.00168239f, -0.01950306f, 0.10740024f, 0.04411899f, 0.01774998f, 0.08696117f, -0.03251229f, 0.09793750f, 
    0.23491241f, -0.12534395f, -0.02020314f, 0.06178571f, -0.01085822f, -0.02776921f, -0.03725632f, -0.06103016f, 
    0.15427990f, 0.24029867f, 0.06576404f, 0.15770613f, -0.03652800f, 0.03714039f, -0.03902721f, -0.04970689f, 
    0.12541711f, -0.17421956f, -0.03238178f, 0.02485907f, 0.60110360f, -0.36149260f, 0.15219758f, -0.14988570f, 
    0.06938004f, -0.03502176f, -0.13614479f, 0.08941261f, -0.00363455f, 0.11571585f, 0.12578011f, -0.02502325f, 
    0.03135296f, 0.01076632f, -0.00286132f, -0.02592013f, 0.01199300f, 0.00972646f, 0.01108057f, 0.17538854f, 
    0.04897471f, -0.16962287f, -0.11188738f, 0.22127801f, -0.17272648f, 0.00968860f, -0.03456932f, -0.00141015f, 
    0.04743353f, 0.05257834f, 0.07292682f, 0.04486512f, 0.25131834f, 0.05646624f, 0.04661165f, -0.01247222f, 
    0.15757038f, -0.14053749f, -0.00435125f, -0.01107505f, 0.06655931f, -0.13288130f, -0.10944212f, -0.00379542f, 
    -0.18667100f, 0.14646001f, -0.08017856f, -0.01416816f, -0.08224092f, -0.01228560f, 0.16361660f, -0.02706068f, 
    0.27847770f, -0.16097127f, -0.17487581f, 0.05923025f, -0.02869473f, -0.16410564f, -0.09035932f, 0.02912744f, 
    -0.04482354f, 0.43611342f, -0.33052823f, 0.17747357f, -0.26981750f, -0.07308113f, -0.02032132f, -0.02132426f, 
    0.15243608f, -0.18782367f, -0.01275494f, 0.04248959f, -0.02042820f, -0.07449716f, 0.04132391f, 0.03356326f, 
    -0.03887786f, -0.02197457f, -0.06515867f, 0.02189099f, 0.28312039f, -0.35281664f, 0.07709248f, 0.00120659f, 
    -0.31723824f, 0.15655260f, 0.02524118f, 0.00945907f, -0.02476302f, 0.01180972f, 0.13371232f, -0.01975481f, 
    0.10793551f, -0.00196017f, 0.00806399f, 0.13651980f, -0.02823963f, -0.02134239f, 0.07162167f, -0.08475336f, 
    -0.48605141f, 0.18225019f, 0.07256580f, 0.29578483f, -0.16699994f, 0.10602629f, 0.05210800f, 0.07790271f, 
    -0.02838098f, -0.00707186f, -0.02371788f, -0.06095499f, -0.07050591f, -0.06551921f, -0.00382001f, 0.20057786f, 
    0.01723844f, 0.00555491f, 0.03693097f, -0.06010821f, 0.23878445f, 0.12879394f, -0.04670369f, 0.04225125f, 
    0.14230293f, -0.03708877f, -0.08672585f, -0.03905946f, -0.05706016f, 0.08707540f, -0.06675336f, -0.10261641f, 
    0.00168015f, 0.09985521f, -0.12861790f, -0.03608928f, -0.03447668f, 0.17320377f, -0.02094288f, 0.07891629f, 
    0.30628327f, 0.04195426f, 0.13141051f, 0.07417025f, 0.21630469f, 0.20560856f, -0.04259002f, -0.04031285f, 
    0.08148157f, 0.10615211f, -0.01300038f, -0.06119171f, -0.01582296f, 0.13261786f, 0.12271064f, -0.06198490f, 
    -0.04547025f, -0.17887288f, -0.08199172f, -0.02573722f, -0.30282810f, 0.30758047f, -0.21527468f, 0.01420243f, 
    -0.02499321f, 0.04012082f, 0.03281120f, -0.17846470f, 0.19195399f, 0.08214033f, -0.08773543f, 0.08446622f, 
    -0.00799170f, 0.02132125f, -0.01680394f, 0.10457597f, -0.04791280f, 0.01516396f, -0.08822992f, -0.02334450f, 
    0.05462036f, -0.21315689f, 0.16214740f, -0.00963207f, 0.13508929f, 0.19518077f, -0.25892454f, 0.04834642f, 
    -0.09210598f, -0.00884614f, 0.05512192f, 0.06637854f, -0.07662677f, 0.05396967f, 0.12238291f, -0.09651875f, 
    -0.10981799f, -0.05529409f, -0.18043046f, -0.15774681f, 0.28118742f, -0.34358343f, 0.14465639f, 0.00352574f, 
    0.20268255f, -0.01276809f, -0.01710067f, 0.10122717f, -0.08278069f, 0.12453272f, 0.02072056f, 0.02098303f, 
    0.03888789f, -0.00885770f, 0.03373893f, 0.06429533f, -0.02165231f, 0.11540486f, 0.03341892f, 0.11361442f, 
    -0.59355706f, 0.38587540f, -0.05506413f, -0.09038822f, 0.07506673f, -0.04267767f, 0.18052816f, -0.11635260f, 
    0.11447843f, -0.05907511f, 0.12112361f, 0.10173222f, 0.01057765f, -0.14531842f, 0.09219661f, -0.03370307f, 
    0.06131483f, 0.00558907f, 0.02655433f, -0.01306370f, 0.36020181f, 0.14495617f, 0.26706341f, -0.11226132f, 
    0.07579233f, 0.13473350f, 0.03708198f, 0.04943796f, -0.02577991f, 0.11107036f, 0.13158117f, 0.04037682f, 
    -0.11232481f, -0.01027265f, -0.00626294f, 0.00274607f, -0.00458306f, 0.06028854f, -0.00726341f, 0.15758556f, 
    -0.29852173f, 0.26780012f, -0.06261262f, 0.10353658f, -0.24345767f, -0.19236645f, 0.03065204f, -0.02641345f, 
    0.01212262f, 0.10823810f, -0.03585292f, 0.00836435f, 0.04154908f, 0.03232870f, -0.07255106f, -0.06732011f, 
    0.00884852f, -0.00485771f, 0.01849263f, 0.04751336f, -0.01789335f, 0.52922761f, -0.27107823f, -0.01910207f, 
    -0.26527783f, 0.05789980f, 0.05488519f, 0.03777940f, 0.09863788f, 0.02977820f, -0.01135798f, -0.01596089f, 
    0.02493764f, -0.02560815f, 0.02671449f, 0.07289323f, -0.01928539f, 0.01009971f, -0.00216849f, 0.09197750f, 
    0.03925158f, -0.34912914f, -0.32823282f, 0.14811148f, 0.05068794f, 0.08852629f, -0.17226909f, -0.00650998f, 
    0.15127319f, 0.19184215f, 0.07556694f, -0.04941537f, -0.03626542f, -0.05045749f, -0.04799036f, 0.20023856f, 
    0.18503931f, -0.08462536f, 0.00894135f, 0.01905124f, 0.34545654f, 0.16411470f, -0.30340001f, -0.02446271f, 
    -0.40732524f, 0.19814900f, 0.00932968f, 0.07826568f, -0.13425070f, -0.11645339f, 0.13985160f, -0.08770928f, 
    -0.13904552f, -0.08239327f, -0.07956278f, 0.10802262f, 0.04014162f, 0.02039419f, -0.02741324f, -0.02095597f, 
    0.25106469f, 0.25069165f, -0.12721322f, -0.03491597f, 0.22247563f, -0.05987752f, 0.07234212f, -0.03899192f, 
    0.06492201f, 0.00925998f, 0.11446586f, 0.13514748f, -0.07861055f, -0.05184406f, -0.02161958f, 0.13538732f, 
    -0.12510201f, 0.13083531f, -0.03798103f, 0.05236188f, 0.35162652f, 0.03318867f, 0.20654896f, -0.12103675f, 
    0.09386598f, 0.10503488f, 0.19199701f, -0.00724488f, -0.07124754f, 0.10199160f, -0.00842867f, 0.10003728f, 
    -0.07016706f, 0.06043803f, -0.00635079f, 0.01277607f, 0.02081627f, 0.08576807f, -0.00934706f, 0.10233754f, 
    0.13790698f, -0.07200126f, -0.10534636f, -0.03988392f, -0.03944580f, -0.02291616f, -0.13282838f, -0.00615229f, 
    0.09717728f, 0.04108196f, 0.00639243f, 0.08170626f, 0.10965983f, 0.03222233f, -0.00778435f, 0.04793889f, 
    -0.07608999f, 0.06830746f, -0.03533489f, 0.24623686f, 0.06524054f, 0.14626192f, -0.11738918f, 0.07853182f, 
    -0.03221625f, 0.00259146f, -0.02820375f, 0.20377479f, -0.08014999f, 0.07707229f, -0.01596477f, 0.08621871f, 
    -0.11579774f, 0.12846318f, -0.07732296f, -0.00871815f, 0.06920660f, 0.00157416f, -0.02523246f, -0.03878288f, 
    0.07062687f, -0.29446414f, 0.18380521f, 0.03193999f, -0.08335079f, -0.12314523f, -0.02605203f, -0.26214415f, 
    0.05271707f, 0.03893616f, 0.02989343f, 0.07398394f, 0.09545803f, -0.01906096f, 0.03290014f, -0.00810693f, 
    -0.09899597f, 0.05881807f, 0.05746429f, -0.05924252f, -0.34913918f, -0.02190847f, 0.01587570f, -0.03586768f, 
    0.06266347f, -0.03306400f, 0.10911026f, -0.09232239f, 0.04061133f, -0.02486416f, -0.07398342f, -0.07429051f, 
    0.03711540f, 0.04415693f, 0.05287330f, -0.05629283f, 0.06889964f, -0.05351656f, -0.02815473f, 0.03319712f, 
    0.09096124f, 0.31392235f, 0.13397714f, -0.29060712f, -0.28235307f, -0.05274231f, -0.10742608f, -0.06163738f, 
    0.14793834f, 0.10052618f, 0.13313581f, -0.24407309f, -0.01371840f, 0.09657079f, -0.02794965f, -0.05631389f, 
    0.12938885f, -0.06198390f, -0.02487887f, 0.09127074f, -0.29767612f, -0.15643303f, -0.13649684f, 0.31114665f, 
    0.02414257f, 0.01221893f, 0.16725278f, 0.12830052f, -0.15079868f, 0.04121097f, -0.00740779f, 0.14461799f, 
    -0.07325688f, -0.07273278f, 0.00364973f, 0.09470455f, -0.01146727f, 0.00261247f, -0.04867497f, 0.01956100f, 
    -0.21896306f, -0.21292394f, -0.05204529f, -0.05304625f, 0.06439577f, 0.00792983f, -0.16987029f, -0.01393490f, 
    -0.03658751f, 0.04892850f, 0.01382108f, 0.13170893f, -0.04512019f, 0.08134561f, 0.05532581f, -0.08235040f, 
    0.10235669f, -0.05858786f, -0.01210231f, 0.02054941f, 0.78045470f, -0.40415278f, -0.20136879f, -0.04387002f, 
    -0.03421174f, 0.07796598f, 0.01934673f, 0.08519773f, 0.10118952f, -0.15651333f, 0.06553319f, -0.01798868f, 
    0.09251941f, 0.06165454f, 0.03645834f, 0.13973251f, -0.05844032f, 0.03364065f, -0.03410522f, -0.04108530f, 
    0.16553721f, -0.43438989f, 0.43474773f, 0.09974501f, 0.02568068f, 0.15146829f, -0.08267207f, -0.04751167f, 
    0.04158387f, -0.02364292f, 0.03419248f, -0.07068107f, -0.01930792f, 0.07189400f, 0.06026910f, -0.01497223f, 
    -0.02545356f, -0.00153432f, -0.05590235f, 0.10587716f, 0.38107181f, -0.08713667f, 0.40978682f, -0.00473743f, 
    -0.14790474f, -0.13182673f, 0.00321277f, -0.21274334f, 0.06405541f, 0.08694246f, 0.09855649f, -0.01343054f, 
    0.20608272f, -0.08646474f, 0.09008701f, 0.05459657f, 0.08594358f, 0.09801997f, 0.08280604f, -0.00875286f, 
    -0.52710927f, -0.38871297f, 0.36588362f, 0.10606950f, 0.20390712f, -0.08608225f, -0.05985625f, 0.05638818f, 
    -0.10896318f, -0.01928922f, 0.03221210f, -0.02538375f, 0.06918373f, 0.02580423f, 0.16304298f, 0.09076137f, 
    -0.10093547f, 0.03959915f, 0.00449066f, -0.04849834f, 0.57822877f, -0.19469237f, 0.23886406f, -0.02748166f, 
    0.00883099f, 0.12954248f, 0.06262382f, -0.21179637f, 0.00035152f, 0.09034289f, -0.07260042f, -0.03119248f, 
    0.04722530f, -0.04736662f, -0.03452193f, -0.10916083f, -0.04102305f, 0.04205162f, 0.05522514f, -0.00845988f, 
    0.11308628f, -0.21395506f, 0.10029702f, -0.02231744f, -0.06930249f, -0.01899373f, 0.07639674f, 0.03968053f, 
    0.18255061f, 0.01560493f, -0.02937362f, 0.14555992f, 0.10394888f, -0.09711297f, -0.00018642f, 0.00083895f, 
    0.00085518f, 0.01140011f, 0.02638170f, -0.02628296f, 0.54185241f, 0.36871356f, 0.16715164f, 0.21621676f, 
    0.29913482f, -0.01947814f, -0.03032424f, -0.02788340f, -0.02268912f, -0.05626507f, -0.00379758f, 0.05005823f, 
    -0.07074789f, 0.06688253f, 0.01683475f, 0.09562688f, 0.06386775f, 0.02431557f, 0.04468248f, -0.06159349f, 
    -0.46274632f, -0.07724698f, 0.18226738f, -0.07381203f, 0.11973047f, 0.08277108f, 0.18011162f, 0.03188052f, 
    -0.06716742f, 0.12368844f, 0.01815904f, 0.03346793f, 0.04856649f, 0.00875984f, 0.10611222f, 0.01843566f, 
    0.03454144f, 0.00272814f, -0.07688231f, 0.14454804f, -0.00945807f, 0.01665991f, 0.35655892f, -0.13322692f, 
    -0.05603956f, 0.17965512f, 0.15287010f, 0.11521893f, -0.04269347f, 0.00363663f, 0.12054191f, 0.03133333f, 
    0.02719223f, 0.04204383f, -0.01348946f, 0.01212314f, 0.16518474f, 0.10630876f, -0.06820279f, -0.05310841f, 
    -0.35036004f, 0.24880439f, -0.19756967f, -0.01811404f, -0.14462526f, 0.20642687f, 0.04809777f, -0.00082650f, 
    0.08220279f, -0.16455737f, -0.07831699f, 0.03389387f, -0.08959099f, -0.02326286f, 0.04117477f, 0.04009271f, 
    -0.02905224f, -0.14010112f, -0.00138978f, 0.01944313f, 0.61020166f, 0.05668759f, -0.09008526f, 0.12570636f, 
    0.13686036f, -0.06427298f, -0.08450308f, 0.04530536f, 0.14464334f, 0.04630785f, -0.02010827f, 0.05342606f, 
    0.09923216f, -0.05080823f, 0.11576338f, 0.11810840f, 0.10693984f, 0.12900224f, -0.01791808f, -0.02960403f, 
    -0.19578299f, -0.01683918f, 0.09089419f, -0.03827789f, -0.00783717f, -0.04798512f, 0.16497560f, -0.09925155f, 
    -0.15399545f, 0.22048941f, 0.00179009f, 0.10193307f, 0.04490254f, -0.04521802f, -0.00289151f, 0.11809842f, 
    0.20248203f, -0.05988334f, 0.00012078f, -0.01146841f, 0.15668358f, 0.09419829f, 0.12405361f, 0.02711422f, 
    0.15934666f, -0.10918004f, 0.06887962f, -0.05528704f, -0.06440259f, 0.05382374f, 0.05258188f, 0.02809608f, 
    0.00810744f, -0.11454751f, -0.00347108f, 0.17937866f, 0.05984675f, -0.15023014f, 0.00412613f, -0.02781756f, 
    0.35155547f, 0.10366589f, 0.03490462f, -0.36454114f, -0.11878780f, -0.09296190f, -0.13333751f, -0.00208730f, 
    -0.00581108f, 0.03698995f, -0.18597911f, -0.05334471f, -0.04521447f, 0.11427290f, 0.11315691f, -0.17702612f, 
    0.02237445f, -0.02427481f, 0.13604972f, -0.03465074f, -0.02869284f, -0.27968013f, -0.25504136f, -0.00510329f, 
    0.15379977f, -0.02553178f, -0.13094391f, 0.09257390f, 0.10343263f, 0.10523055f, 0.09603789f, 0.06490707f, 
    0.06548149f, -0.02275297f, 0.13870856f, 0.07654249f, 0.03614563f, 0.01299439f, -0.06054241f, 0.21882746f, 
    -0.28151983f, 0.53461862f, -0.04463015f, 0.11870959f, 0.03824142f, -0.12839466f, 0.03678752f, -0.16323642f, 
    0.01997778f, -0.06924785f, -0.05913739f, -0.11747362f, 0.12483747f, 0.06496296f, 0.16169463f, 0.04882469f, 
    -0.16337040f, 0.05425739f, -0.02707936f, 0.03233079f, 0.29579654f, 0.11986652f, 0.17646690f, -0.05440789f, 
    -0.10151064f, 0.02772417f, 0.09297197f, -0.04229029f, 0.02881009f, -0.07898083f, 0.03902853f, 0.01690699f, 
    -0.11871172f, -0.09188826f, 0.11498315f, 0.05682201f, 0.01210462f, -0.03140451f, -0.03820918f, -0.06826906f, 
    0.33617532f, -0.47067410f, 0.31104130f, 0.18324010f, 0.15087163f, 0.10061015f, 0.07713834f, 0.04899683f, 
    -0.04393246f, -0.00153216f, 0.06200328f, 0.03674670f, 0.02640173f, 0.06830556f, 0.05983291f, 0.12807222f, 
    0.04338014f, -0.03815122f, 0.10248794f, 0.00600513f, 0.28613558f, 0.43494728f, 0.12134693f, 0.04735162f, 
    0.17172623f, 0.09942587f, 0.20716116f, 0.04600425f, -0.02631653f, -0.02560794f, -0.02096074f, 0.09047879f, 
    -0.04349769f, 0.01670535f, -0.04174051f, -0.06939961f, 0.06823076f, -0.01525357f, 0.04306057f, -0.00944528f, 
    -0.24788257f, 0.16277173f, 0.00773081f, 0.33321452f, 0.13294160f, 0.40105864f, 0.04982137f, 0.07315448f, 
    -0.13413006f, 0.12341756f, -0.11091182f, -0.03761154f, 0.13000906f, -0.03399019f, -0.02488840f, 0.02362148f, 
    -0.01217858f, -0.03012122f, 0.03901953f, -0.17160219f, -0.21987554f, -0.11811148f, -0.18139698f, -0.05232195f, 
    -0.12668295f, 0.26889712f, 0.18088758f, 0.13317305f, 0.03619044f, -0.08633341f, -0.00124529f, 0.09957340f, 
    0.05327802f, 0.00001159f, 0.00124732f, -0.00780896f, -0.05030469f, 0.02511127f, -0.04496553f, 0.06605067f, 
    -0.63426214f, -0.02145693f, -0.04988658f, 0.02457382f, 0.09408019f, 0.11878636f, 0.10902418f, -0.02779436f, 
    -0.02082527f, -0.07743431f, 0.08646325f, -0.05748481f, 0.02748293f, -0.06589825f, -0.02665955f, -0.02733200f, 
    -0.03973620f, 0.02648289f, 0.02941329f, 0.04936368f, -0.25269935f, 0.16180721f, -0.10402749f, -0.11505594f, 
    -0.20429149f, 0.26286769f, 0.33532062f, 0.16382180f, -0.02320152f, 0.00635074f, 0.00370808f, -0.03180729f, 
    -0.09288137f, 0.09933300f, 0.01900844f, 0.08897513f, -0.01855434f, 0.00328753f, 0.07084135f, 0.02562680f, 
    0.36729878f, -0.17571212f, 0.19677283f, -0.04601475f, -0.12985666f, 0.02823074f, -0.00056358f, -0.15475810f, 
    0.01928527f, 0.04920276f, -0.01737391f, -0.08358394f, 0.04387907f, -0.05081191f, 0.06861107f, -0.01962014f, 
    -0.02067854f, 0.13845067f, 0.04658271f, -0.01376778f, 0.10333101f, 0.46554840f, -0.00660631f, 0.22228186f, 
    0.05475406f, 0.08999945f, 0.22364023f, -0.04239652f, -0.06850081f, -0.09506473f, 0.11052577f, 0.02890944f, 
    -0.12142096f, -0.07951438f, 0.09087946f, 0.09839556f, 0.00440289f, 0.09907995f, 0.01573228f, 0.02663814f, 
    0.12978974f, -0.20524581f, -0.10875335f, -0.11124150f, -0.44503158f, 0.07151920f, 0.16517128f, -0.10606211f, 
    -0.08407412f, 0.00351034f, 0.02021056f, 0.00222010f, -0.07694478f, -0.03174918f, 0.02848164f, 0.05512466f, 
    -0.03188309f, 0.09842379f, 0.07097573f, 0.01963958f, 0.69271666f, -0.07793317f, 0.17218712f, 0.00605201f, 
    0.08409011f, -0.00447564f, 0.02968987f, 0.08408958f, 0.09493601f, 0.02824768f, 0.09359768f, -0.00961586f, 
    0.01501786f, -0.08430601f, -0.03860083f, -0.08018206f, 0.00526186f, 0.04576939f, -0.02754163f, 0.00954521f, 
    0.09196635f, 0.35322583f, -0.08643116f, -0.20676731f, -0.06414875f, 0.19118182f, -0.08886339f, 0.01551773f, 
    0.04782538f, -0.09848620f, -0.07300366f, -0.03925638f, -0.15591295f, 0.10054225f, -0.03139449f, 0.07934158f, 
    -0.04532348f, -0.06013000f, -0.06212554f, -0.15801148f, 0.37661478f, -0.38758630f, -0.03774056f, -0.04565528f, 
    -0.01464052f, -0.08842883f, 0.03181561f, 0.12771243f, 0.10195417f, 0.00469154f, 0.02475101f, -0.02340610f, 
    0.00286445f, 0.01099136f, -0.12547906f, 0.01445150f, -0.00276977f, -0.03311397f, 0.11346744f, 0.04033298f, 
    -0.22041754f, 0.42744374f, 0.18309917f, -0.22023483f, -0.06395134f, 0.16871192f, 0.03387118f, -0.00802477f, 
    0.12039874f, -0.05472616f, -0.03570687f, 0.11710731f, 0.20228523f, 0.07615319f, -0.06460006f, 0.15682290f, 
    -0.01897344f, -0.00651114f, 0.05886620f, -0.11600380f, -0.00812754f, -0.12591720f, 0.10309106f, -0.03677135f, 
    -0.20409517f, 0.11069471f, -0.07893945f, 0.00227911f, 0.06168519f, -0.04101254f, -0.06727203f, -0.02744993f, 
    -0.03572347f, 0.08135457f, -0.02441240f, -0.03221495f, 0.05279593f, -0.08372514f, 0.01627612f, 0.11542986f, 
    -0.10047527f, -0.29439807f, -0.28755099f, -0.27377227f, -0.26594472f, 0.08925147f, 0.00422644f, 0.01095481f, 
    -0.07302371f, -0.00140036f, -0.19690086f, -0.08025369f, 0.10641479f, 0.00340381f, -0.11824666f, -0.05643559f, 
    0.01973277f, -0.05667358f, -0.22830549f, -0.09043290f, -0.57156229f, 0.08427667f, 0.14435641f, 0.01858683f, 
    -0.06038796f, -0.01446480f, 0.19346009f, 0.01721799f, -0.12875639f, 0.22534548f, 0.00330781f, 0.05989656f, 
    0.02374933f, 0.01908856f, 0.24801090f, -0.10497645f, 0.18433344f, 0.03082756f, 0.12915690f, 0.12172055f, 
    0.23731026f, -0.04413406f, 0.11383982f, 0.02933518f, 0.24799667f, -0.20417412f, -0.02068428f, 0.00477993f, 
    -0.02924000f, 0.07916565f, 0.02938134f, 0.01745527f, 0.08555887f, 0.02866072f, 0.00120458f, 0.01894092f, 
    -0.04032567f, 0.16807172f, 0.01657603f, 0.02943130f, -0.16075759f, 0.57749403f, -0.02201953f, 0.05993497f, 
    -0.06212170f, 0.02061864f, -0.08301744f, -0.01355882f, 0.00004620f, -0.10052119f, -0.02211748f, 0.01131545f, 
    -0.03853098f, 0.07199059f, 0.00767651f, -0.00943731f, -0.02805937f, -0.15174517f, -0.19500685f, -0.01292902f, 
    -0.04014199f, -0.01590853f, -0.09550671f, -0.15744683f, 0.24349409f, 0.03439718f, -0.14776917f, 0.06474870f, 
    -0.15291882f, 0.10626125f, -0.01191201f, 0.11439592f, 0.11689370f, -0.09364018f, -0.08403562f, 0.07044095f, 
    -0.02957053f, 0.04488771f, 0.00133067f, -0.12413297f, 0.14521736f, 0.36216658f, 0.03061262f, -0.02250626f, 
    0.10480752f, 0.05052077f, -0.03468064f, 0.01159225f, -0.07706624f, 0.02213157f, 0.03827039f, -0.07313733f, 
    0.01820760f, 0.07276527f, 0.00513724f, -0.01169684f, 0.08488605f, 0.06044675f, -0.06264495f, -0.12512054f, 
    -0.43292695f, -0.15745360f, 0.26624736f, -0.07411239f, -0.19732651f, -0.00857242f, -0.00900461f, -0.08108601f, 
    -0.00937732f, -0.00650196f, 0.02352004f, -0.11186675f, 0.08783694f, 0.20339385f, -0.01734004f, 0.15074529f, 
    -0.14899698f, -0.04276127f, 0.10587681f, 0.05578353f, 0.12417106f, -0.03995179f, 0.46356684f, 0.17439252f, 
    0.19424304f, -0.05779799f, -0.12965234f, 0.04328886f, -0.00485632f, -0.03967975f, -0.05935673f, 0.08821859f, 
    0.13522722f, -0.02669222f, 0.15697515f, 0.01957810f, 0.00247933f, -0.03641285f, 0.01167558f, 0.04928501f, 
    -0.11116323f, -0.21955410f, 0.08663713f, -0.15693790f, 0.02294110f, 0.00247119f, -0.07367580f, 0.09794404f, 
    0.04313114f, -0.12550674f, -0.02360686f, -0.08004742f, -0.12968649f, 0.07626367f, -0.11512503f, -0.09199072f, 
    0.02085201f, -0.07088883f, 0.04030524f, -0.10003991f, -0.02706558f, -0.05563980f, 0.16715315f, -0.29448918f, 
    -0.09717175f, -0.08699175f, -0.20287898f, -0.05924134f, -0.13819653f, -0.13596888f, 0.01851087f, 0.01734781f, 
    -0.17378505f, -0.05113745f, 0.04878481f, -0.09760443f, 0.14257316f, -0.12332327f, -0.13555121f, -0.13639963f, 
    0.55180621f, -0.04271437f, 0.00202488f, 0.02988158f, -0.03379358f, -0.04506518f, 0.05131626f, 0.07358092f, 
    -0.04081381f, 0.01101461f, 0.02474180f, -0.02334103f, 0.03217273f, 0.09878684f, 0.07964719f, 0.07677807f, 
    -0.09803297f, -0.12075225f, 0.00259808f, 0.16441822f, 0.17569135f, -0.48467216f, 0.31839237f, -0.26280808f, 
    0.21246895f, 0.00677187f, 0.02828113f, -0.01400208f, 0.08850712f, 0.05090282f, -0.04340464f, 0.01223781f, 
    0.15553963f, -0.16706538f, 0.02575243f, -0.07474881f, -0.00858819f, -0.02961637f, 0.12034784f, 0.10268279f, 
    0.27533862f, -0.37296283f, 0.24922693f, -0.01399706f, -0.17421708f, -0.14331023f, 0.16302343f, 0.01542746f, 
    -0.13823478f, 0.13948785f, -0.11840057f, 0.07625136f, 0.16767181f, -0.11619779f, 0.15176837f, 0.02434045f, 
    0.06190205f, 0.06371715f, -0.02135449f, 0.21333672f, -0.37282938f, 0.30927065f, 0.05808273f, 0.11749539f, 
    0.03050104f, 0.08914147f, -0.03898496f, 0.01310151f, -0.00075695f, 0.04630674f, -0.07469685f, 0.04200545f, 
    0.02334876f, -0.02063264f, 0.07842259f, 0.09000751f, 0.05621314f, 0.02543480f, 0.01407785f, 0.02282489f, 
    -0.00388073f, 0.32469460f, -0.10616616f, -0.24285699f, -0.12677720f, 0.10959008f, 0.00224406f, 0.07267196f, 
    0.08033662f, -0.06713071f, -0.01054037f, -0.01323836f, 0.01112777f, 0.09313884f, -0.06764314f, 0.09559768f, 
    0.20810886f, -0.13427202f, -0.06332235f, -0.00707569f, 0.19474594f, -0.21129891f, -0.13194640f, 0.04153905f, 
    -0.43556985f, 0.11227880f, 0.09005275f, -0.04986654f, 0.25434616f, -0.09782256f, -0.04438701f, -0.09201268f, 
    0.04912285f, 0.04028828f, -0.09297515f, -0.02593567f, -0.07399078f, 0.13628940f, -0.02831032f, 0.06468584f, 
    0.03725896f, -0.72421294f, -0.08970255f, -0.24986623f, -0.12732185f, 0.10398125f, 0.02927138f, 0.10556135f, 
    0.19118132f, 0.07167704f, -0.08600119f, 0.00238937f, -0.03059162f, 0.09355817f, -0.20287688f, -0.03673634f, 
    -0.10799725f, 0.01577226f, 0.05782915f, -0.05442807f, -0.28764004f, 0.41575667f, 0.21594462f, 0.26556060f, 
    0.11580668f, -0.08157188f, 0.02875376f, 0.08029831f, -0.04566398f, 0.12839018f, -0.02882745f, 0.02937242f, 
    0.08351322f, 0.01928016f, 0.13091677f, -0.00190513f, -0.04165765f, -0.07524504f, -0.00440585f, -0.02371310f, 
    0.34806958f, 0.06726774f, -0.12277105f, -0.07057417f, 0.28327486f, -0.09662244f, 0.13031955f, -0.06507469f, 
    -0.06901238f, 0.05882214f, 0.04743445f, 0.01973063f, 0.05559935f, -0.17252262f, 0.16163918f, 0.13970874f, 
    -0.05364841f, 0.03884321f, -0.03563485f, 0.00917438f, 0.16256805f, 0.23968546f, 0.29884681f, 0.12091135f, 
    0.16921967f, -0.16182965f, -0.02772987f, 0.11268815f, -0.09863498f, 0.06014824f, -0.03364649f, 0.08332411f, 
    0.02160931f, -0.02261523f, -0.06852131f, -0.05947670f, -0.04839500f, 0.00922939f, -0.01668170f, -0.00349521f, 
    -0.02437110f, -0.10191276f, -0.08835948f, 0.21682099f, -0.55396724f, -0.09661132f, -0.03937942f, 0.05751861f, 
    -0.04410181f, 0.12859190f, 0.03542444f, 0.20416330f, -0.09148414f, -0.09613922f, 0.12263326f, 0.10124657f, 
    0.03869974f, 0.12318794f, 0.03877648f, 0.05853438f, 0.28798079f, -0.08934513f, 0.02135478f, 0.04658813f, 
    -0.14360482f, -0.04417918f, 0.03669693f, 0.04685539f, -0.00778115f, 0.00666706f, 0.05367453f, -0.01184781f, 
    -0.08178744f, 0.07187257f, 0.11312588f, 0.06449475f, 0.15139669f, -0.08491343f, 0.05886187f, 0.11411259f, 
    0.64438611f, -0.41581714f, -0.22322448f, -0.02750148f, -0.05372690f, -0.08736442f, 0.06224062f, -0.06106713f, 
    0.02078065f, 0.24144049f, 0.11282558f, -0.07616846f, -0.00222885f, -0.06016944f, -0.00561643f, 0.20973048f, 
    0.09433218f, 0.10211945f, -0.03767876f, 0.12959243f, 0.54220229f, 0.16161381f, 0.14820822f, -0.12437059f, 
    -0.07553567f, -0.00771884f, 0.04436386f, -0.18592034f, 0.14226562f, 0.04442908f, 0.07362841f, 0.12941283f, 
    -0.11272305f, 0.12119544f, 0.09583618f, 0.15092409f, 0.09875753f, -0.12771197f, -0.08167804f, 0.04251319f, 
    0.28336835f, 0.34359124f, 0.02282543f, 0.13478521f, 0.05415822f, 0.07213558f, -0.08917431f, -0.12445859f, 
    0.03920849f, -0.04597382f, -0.06460224f, 0.07501905f, 0.04010042f, 0.17180693f, -0.10685077f, 0.06513046f, 
    0.05670823f, 0.01045555f, -0.05588874f, -0.04891585f, 0.35701123f, 0.34128469f, 0.14017695f, 0.21209906f, 
    0.31512487f, 0.04677575f, -0.15750678f, 0.01614031f, 0.04104960f, 0.01474663f, -0.06991272f, -0.01344581f, 
    0.05388235f, 0.23202690f, -0.12417834f, -0.16969429f, 0.08204535f, 0.01511466f, 0.01493748f, -0.04381172f, 
    -0.04283889f, 0.02576495f, -0.01955141f, 0.02823983f, 0.02518258f, -0.04568416f, -0.03715065f, 0.00873867f, 
    -0.01018531f, -0.04540612f, 0.00813527f, 0.01980492f, -0.01850568f, -0.02888108f, -0.03029110f, 0.01788071f, 
    -0.04318311f, -0.04413753f, 0.02802507f, -0.04468617f, -0.03402929f, -0.01108315f, -0.04395653f, 0.02454796f, 
    -0.04445967f, -0.00478017f, -0.01261066f, 0.02578075f, -0.03199609f, 0.01902066f, -0.01531310f, -0.02442563f, 
    -0.01765121f, -0.00146892f, 0.02237223f, -0.03539673f, -0.03632323f, 0.01274343f, 0.00965792f, -0.00909300f, 
    -0.00265041f, -0.04596436f, 0.00814618f, -0.00515268f, -0.02177307f, 0.00071389f, -0.02691878f, -0.03125812f, 
    0.02722671f, 0.01947836f, 0.01194463f, 0.01622246f, 0.00978640f, 0.02396356f, -0.02877720f, 0.00920594f, 
    -0.02906089f, 0.01651779f, -0.01371418f, 0.00223758f, 0.02790153f, 0.00959869f, -0.03610339f, -0.01531829f, 
    -0.04102745f, -0.04317746f, 0.01233691f, -0.00283549f, -0.01144063f, 0.02203328f, -0.02974998f, -0.01801551f, 
    -0.00191041f, 0.00104578f, -0.02558288f, 0.00179812f, 0.02049312f, 0.00611921f, 0.02096018f, 0.00066652f, 
    0.01986006f, -0.02133423f, -0.02032449f, -0.04064258f, 0.01194489f, -0.02511132f, -0.00086487f, -0.02293525f, 
    -0.01636530f, 0.02976813f, -0.00818139f, 0.01570223f, 0.02188956f, -0.01588169f, 0.02894891f, 0.00910048f, 
    0.02923342f, -0.00625930f, -0.00419918f, -0.01325991f, 0.00660732f, -0.03459707f, -0.00542706f, 0.00632651f, 
    -0.00979324f, 0.02378158f, 0.03031156f, 0.03046732f, 0.02763487f, -0.02022674f, -0.00635551f, -0.01290264f, 
    0.00710809f, -0.03369531f, -0.03315461f, -0.04488691f, 0.01316766f, -0.02069769f, -0.03901533f, 0.01127908f, 
    0.01987422f, -0.03115102f, -0.00364202f, -0.01069228f, 0.00552206f, 0.01061735f, -0.00844806f, 0.01097541f, 
    -0.03803905f, 0.02552687f, -0.01577473f, -0.04167204f, 0.00056010f, 0.00632835f, 0.00788475f, -0.04026505f, 
    0.03022852f, 0.02573710f, -0.04148712f, 0.01712755f, -0.01612925f, -0.03181553f, -0.04003436f, 0.01381780f, 
    0.03080714f, -0.04447009f, -0.01189777f, -0.03017801f, -0.01077642f, -0.01571296f, -0.03082655f, 0.01141934f, 
    0.02428296f, -0.01480129f, 0.03168903f, -0.01203337f, -0.03437968f, -0.02371253f, 0.02953016f, 0.00659754f, 
    0.01449036f, -0.03032142f, -0.00249395f, -0.02828008f, 0.02763858f, 0.02155250f, 0.01340691f, 0.03227776f, 
    -0.02977453f, -0.02277221f, -0.02529196f, -0.00802674f, -0.03044195f, 0.02188905f, -0.02395989f, -0.02751222f, 
    0.00318170f, 0.00966397f, 0.02799490f, -0.03827351f, 0.02681980f, 0.01923983f, -0.00861766f, 0.04262036f, 
    0.02445109f, -0.00756855f, 0.01141006f, -0.02032420f, 0.01836342f, 0.03095526f, -0.01587399f, -0.02482584f, 
    -0.02360418f, -0.01143308f, 0.01976704f, -0.02297067f, 0.01918086f, 0.02019608f, -0.01905239f, 0.03131689f, 
    -0.02526271f, 0.03142452f, 0.01656739f, -0.01250493f, -0.01332734f, -0.04054899f, 0.01600999f, 0.02043154f, 
    0.00292763f, 0.02624825f, -0.00426440f, 0.03236332f, -0.02268080f, -0.00965518f, 0.00866120f, -0.01797350f, 
    0.02735342f, -0.01529932f, -0.01271451f, -0.04370390f, 0.01899011f, -0.01910818f, 0.03065897f, -0.03388657f, 
    0.01635993f, -0.00477959f, 0.01204177f, 0.02151395f, -0.02559093f, -0.04189548f, -0.01812778f, 0.00044715f, 
    0.00910055f, 0.04221775f, 0.00419438f, 0.01936033f, -0.01978965f, -0.01314514f, -0.04552447f, 0.02801519f, 
    -0.00881890f, 0.01725101f, -0.04461408f, -0.00975688f, -0.01172462f, -0.04230095f, -0.02312428f, -0.00346067f, 
    -0.01946122f, 0.02911926f, -0.03984476f, -0.02813077f, -0.02113226f, 0.02197268f, 0.00539401f, -0.02852403f, 
    0.01414652f, -0.04466284f, -0.04315412f, 0.03085508f, -0.00971609f, 0.00117616f, 0.01112317f, -0.04144005f, 
    -0.00204200f, -0.03554628f, 0.01211312f, 0.02175492f, -0.02068912f, -0.01199391f, -0.04194295f, 0.00785025f, 
    -0.04173707f, -0.03552006f, -0.03100977f, -0.00558009f, -0.01277997f, -0.04591509f, 0.00499111f, -0.02672538f, 
    -0.04594634f, -0.01693339f, 0.00039865f, -0.01440946f, 0.00591787f, -0.00438938f, 0.00330029f, -0.00072090f, 
    0.00207365f, 0.00924975f, -0.02852304f, -0.04327152f, 0.00838741f, 0.02784549f, -0.03567097f, -0.00702833f, 
    -0.02907613f, 0.00198794f, -0.03138904f, -0.01627099f, 0.01055298f, -0.00248085f, -0.00058858f, -0.03393948f, 
    0.00721977f, 0.02780574f, -0.01487361f, -0.01720738f, 0.02427111f, 0.00960978f, 0.02839609f, 0.02843491f, 
    0.03090512f, -0.04616183f, -0.02653140f, 0.01338774f, -0.01263228f, -0.02378568f, -0.01284257f, -0.04363654f, 
    -0.01093572f, -0.03890573f, -0.03456930f, -0.02793688f, -0.02432234f, 0.00018456f, -0.03503874f, -0.04406339f, 
    -0.00058872f, 0.02444459f, -0.04036489f, -0.03822452f, 0.01817365f, 0.00720466f, -0.04535731f, -0.01998219f, 
    -0.02870730f, -0.04021414f, 0.02104563f, 0.00608466f, -0.02988671f, -0.01713168f, 0.01434364f, 0.01211125f, 
    0.03224977f, 0.00820960f, -0.03057034f, 0.02552911f, 0.02065341f, -0.02944020f, -0.00988819f, -0.01650696f, 
    0.01178890f, 0.01548684f, 0.01916462f, -0.03969932f, 0.03023317f, -0.01572080f, -0.01378586f, -0.01468657f, 
    -0.04541285f, 0.00339466f, -0.02861071f, -0.00611670f, -0.04155162f, 0.02569856f, 0.00462975f, -0.04335973f, 
    -0.00821360f, 0.01016469f, -0.00478578f, -0.02354870f, 0.02780994f, -0.02077088f, -0.01386416f, 0.02750864f, 
    0.00567403f, 0.02980473f, 0.01903209f, -0.00867452f, 0.00281604f, -0.04346301f, 0.00999194f, -0.02640911f, 
    0.01014158f, -0.00908572f, -0.03119576f, -0.04624765f, 0.01279703f, -0.00371517f, 0.02638327f, 0.01090927f, 
    -0.04317728f, 0.03234351f, 0.02573764f, 0.02422745f, 0.02442379f, -0.00548328f, -0.03674841f, -0.02258543f, 
    0.00431726f, -0.00663548f, -0.03781055f, 0.00209659f, -0.02400895f, 0.01875876f, 0.02192481f, 0.02894506f, 
    -0.00631998f, -0.00784910f, 0.02451476f, -0.01481942f, 0.02859715f, -0.02589806f, -0.03409327f, -0.00236667f, 
    -0.00779288f, 0.02438332f, -0.01673595f, -0.02731990f, 0.00514852f, -0.01228320f, -0.04203350f, -0.03871075f, 
    -0.00573036f, -0.03236781f, 0.00111693f, 0.01967445f, 0.00502524f, -0.03959421f, 0.01525726f, 0.00595348f, 
    -0.00299442f, 0.01689363f, -0.03238457f, -0.01218005f, -0.00969588f, -0.02448840f, -0.03784248f, -0.00392415f, 
    -0.02963481f, -0.03502471f, 0.02614775f, -0.03486214f, -0.04418848f, -0.00608741f, 0.01971311f, 0.02082545f, 
    0.01606091f, 0.02334096f, -0.01619944f, -0.03550043f, 0.01713609f, -0.04323719f, -0.02669749f, -0.03439107f, 
    -0.01103747f, -0.02914366f, -0.01874743f, -0.03383010f, 0.00502194f, 0.00168166f, -0.00743976f, -0.01431767f, 
    -0.00467446f, -0.01524215f, 0.01281961f, -0.00219719f, 0.00762499f, 0.01224698f, -0.01705413f, -0.04161941f, 
    0.02250132f, -0.02548419f, 0.01206612f, 0.02642694f, 0.00755824f, -0.01686101f, 0.02802560f, 0.00003095f, 
    0.02861915f, -0.02322959f, -0.01956106f, 0.01686133f, -0.01705767f, -0.02795645f, -0.01403394f, -0.01855336f, 
    -0.00039739f, 0.00624035f, -0.01934755f, -0.00965195f, -0.02038107f, 0.01690779f, 0.00869632f, 0.00326507f, 
    -0.01206373f, -0.01980457f, -0.01020742f, -0.01712266f, 0.03117503f, -0.00537790f, 0.00975840f, -0.01655803f, 
    -0.01674659f, 0.02576694f, -0.03333347f, -0.02535916f, -0.04200786f, 0.01445790f, -0.02355324f, -0.01334288f, 
    -0.00322785f, -0.03605126f, -0.02249624f, -0.03908758f, -0.02984588f, 0.01492473f, -0.03123935f, 0.01454946f, 
    0.00966255f, -0.02431824f, 0.02873655f, -0.01812280f, -0.02054745f, -0.03710285f, -0.02463607f, -0.00255991f, 
    -0.00631745f, 0.02331721f, 0.01188794f, -0.04071931f, 0.00188199f, -0.02761783f, -0.02354355f, 0.03220067f, 
    0.00159905f, -0.00299269f, -0.01589677f, -0.03394242f, -0.02352019f, -0.01378361f, -0.04151096f, 0.02132696f, 
    0.02000341f, 0.01070855f, -0.00267940f, -0.02128691f, -0.03484681f, 0.00918258f, -0.00679690f, -0.01323228f, 
    0.01310775f, 0.01962481f, -0.01073577f, -0.04615834f, 0.01629038f, -0.02890047f, 0.00395127f, -0.01134538f, 
    0.03215360f, -0.03425661f, -0.01802021f, -0.04324219f, 0.01292576f, 0.02620037f, -0.03925650f, -0.02675575f, 
    0.00469428f, -0.02629668f, 0.01580893f, -0.00275686f, -0.01604908f, 0.01057904f, 0.03142611f, -0.02508411f, 
    0.02626356f, -0.03506958f, -0.02352800f, 0.01675470f, -0.02330748f, 0.01247671f, -0.02012582f, 0.02596794f, 
    -0.04382088f, -0.00947763f, -0.03161363f, 0.01264166f, 0.03541959f, -0.02102498f, -0.01220301f, -0.03354429f, 
    0.02308177f, 0.03008389f, -0.03138516f, 0.02337113f, 0.01026219f, 0.00325457f, 0.02338844f, -0.01494055f, 
    0.02842893f, -0.00276696f, -0.01610732f, 0.02888367f, -0.01071300f, -0.01431681f, 0.01827680f, -0.00408248f, 
    -0.02687705f, 0.01800270f, -0.04598214f, 0.00141646f, -0.04655741f, -0.02120481f, 0.00812295f, -0.01269936f, 
    -0.04244636f, -0.00721403f, 0.02336454f, 0.01888488f, 0.00658372f, 0.01601562f, -0.02167565f, 0.02630461f, 
    -0.00402169f, -0.01787624f, 0.03028989f, -0.00119989f, 0.00945726f, 0.00880893f, 0.02594253f, 0.02032785f, 
    -0.03573591f, -0.00662805f, -0.01136181f, 0.03564945f, -0.02629733f, 0.00922758f, 0.02268939f, -0.01777882f, 
    -0.00171834f, -0.02852350f, 0.02433580f, 0.01317291f, -0.00997759f, 0.01287331f, -0.03592815f, 0.01654871f, 
    0.03012306f, -0.03144067f, 0.01267480f, -0.02472660f, -0.02944769f, 0.02443691f, -0.03907661f, 0.00131969f, 
    0.02879566f, -0.02770050f, 0.02640013f, -0.00260869f, -0.01925811f, 0.02663504f, -0.04098354f, -0.02662919f, 
    0.00268165f, -0.04350076f, 0.00094809f, 0.00886366f, -0.01114114f, -0.04192883f, -0.04266171f, -0.02582690f, 
    -0.03378395f, -0.01665718f, -0.02289371f, -0.01197837f, -0.03648208f, -0.01473527f, 0.00322129f, -0.02634323f, 
    -0.03386125f, -0.03745004f, 0.02123078f, -0.02710759f, 0.02154097f, 0.02847876f, -0.00566849f, -0.01886505f, 
    0.00491964f, -0.03870683f, -0.01260087f, -0.03364496f, 0.03326539f, -0.01752467f, -0.01468399f, 0.00744794f, 
    -0.01436065f, -0.00515012f, 0.01636470f, -0.02091875f, -0.03788139f, 0.01432822f, -0.03639397f, -0.00167200f, 
    -0.01765914f, -0.02722709f, -0.00754415f, 0.01201812f, -0.04455969f, -0.02373638f, -0.01818016f, 0.00610529f, 
    0.00547838f, -0.00254481f, 0.01614349f, 0.00741653f, -0.02619764f, -0.00656871f, -0.03624707f, 0.01432311f, 
    0.02032472f, 0.02284320f, 0.02494232f, 0.00240171f, -0.00672691f, -0.01361931f, 0.01049085f, 0.01258163f, 
    0.02272802f, -0.01045859f, -0.01774434f, -0.02948673f, 0.02650190f, 0.00078442f, -0.02712969f, -0.04509403f, 
    0.01049951f, -0.01324949f, 0.03271351f, 0.01648042f, 0.01505175f, 0.02630391f, -0.02764580f, -0.02371033f, 
    0.02817361f, -0.01963365f, -0.03570865f, -0.02460135f, 0.00619195f, -0.02465365f, 0.03104182f, 0.01745849f, 
    0.00217015f, 0.01932739f, -0.02286397f, 0.00043715f, 0.01644603f, -0.03293373f, 0.01230671f, -0.03985370f, 
    -0.04671823f, 0.01745564f, 0.01350858f, 0.00425598f, 0.00845571f, -0.02545360f, -0.01306223f, 0.01610558f, 
    0.03045348f, 0.00688762f, -0.00795754f, 0.00197771f, 0.00517782f, 0.00937925f, -0.00057769f, 0.02324465f, 
    -0.02287493f, -0.00892753f, -0.00854749f, 0.00813362f, -0.02073155f, 0.02895303f, 0.02090739f, -0.02002916f, 
    -0.01220035f, -0.01354933f, -0.00582558f, 0.01246243f, 0.00547771f, 0.03760336f, 0.00299244f, -0.02052815f, 
    -0.01254999f, 0.00626801f, 0.01319058f, -0.00529474f, -0.03023532f, -0.03070857f, -0.02132406f, -0.01337523f, 
    0.00825007f, -0.04679726f, -0.04343949f, 0.02028158f, -0.03086049f, 0.02175894f, 0.01827973f, 0.02536434f, 
    -0.00605444f, -0.04123264f, -0.03979861f, -0.02711107f, 0.01655457f, -0.03494771f, 0.01943459f, -0.04749136f, 
    -0.01367481f, -0.04150470f, -0.01963609f, -0.00525516f, 0.00372824f, -0.03825111f, -0.02922083f, 0.02568865f, 
    0.03756426f, -0.02529784f, -0.04057603f, -0.02313690f, 0.01651058f, 0.02305639f, -0.03087227f, -0.00945450f, 
    -0.02986510f, -0.01776897f, -0.01280028f, -0.03046387f, 0.03808209f, -0.03680924f, -0.01309794f, -0.00131339f, 
    -0.03985711f, 0.00949395f, -0.00084717f, -0.03960811f, 0.00572291f, -0.02178996f, -0.01547050f, 0.02208313f, 
    0.00544967f, -0.00437461f, 0.03157584f, -0.01211496f, 0.03158026f, 0.02937496f, -0.01925300f, 0.02885545f, 
    -0.04201614f, -0.02583560f, 0.02265675f, -0.01217172f, 0.00925403f, -0.01698491f, -0.04481518f, -0.03312728f, 
    -0.04756425f, 0.00532035f, -0.04542570f, -0.03778151f, 0.02657257f, 0.02879243f, -0.04423128f, -0.00767277f, 
    0.01781511f, -0.01797099f, -0.03561684f, 0.00083686f, 0.02856315f, -0.02210766f, 0.00988811f, -0.04339961f, 
    0.01469156f, -0.02144981f, -0.00362282f, -0.02164808f, 0.02360647f, -0.02077545f, -0.02212515f, 0.00185444f, 
    -0.02515955f, -0.00398228f, -0.02013565f, -0.00608270f, 0.02832296f, 0.02488789f, 0.00009801f, -0.02622881f, 
    -0.01817470f, -0.02094504f, -0.03430407f, 0.00806938f, 0.02005136f, 0.01508216f, -0.00139591f, -0.01940554f, 
    0.01091275f, 0.00290034f, 0.01667290f, -0.04439777f, -0.01269723f, -0.00337711f, 0.00920258f, -0.03007969f, 
    -0.04150398f, -0.01864081f, -0.01335974f, -0.03570577f, -0.01425208f, -0.01898172f, -0.03606930f, -0.03771340f, 
    0.01318542f, -0.01040148f, 0.00081938f, -0.00992148f, 0.01146697f, -0.02958173f, 0.02800968f, -0.01049876f, 
    -0.04208263f, -0.00632730f, -0.01281315f, 0.02211147f, 0.00316975f, -0.04685533f, -0.04506032f, -0.02679170f, 
    -0.02343192f, 0.01667568f, -0.01878192f, -0.03902739f, -0.04144465f, -0.03343021f, 0.01043492f, -0.01713066f, 
    0.02458163f, -0.01682630f, -0.00693037f, -0.02701395f, -0.00975111f, -0.03662513f, -0.01588695f, -0.00785133f, 
    -0.00719045f, -0.03273982f, 0.00722050f, -0.00749498f, -0.00978454f, -0.00337022f, -0.02606626f, 0.00991860f, 
    0.02501808f, 0.00386382f, 0.02036864f, -0.04890111f, -0.03448278f, 0.01734067f, -0.01840331f, 0.01784042f, 
    -0.04468064f, -0.01965005f, 0.02940429f, -0.04002455f, 0.01340245f, 0.00021000f, -0.00389828f, -0.00137207f, 
    -0.04015845f, 0.00620351f, -0.04408703f, -0.00266227f, 0.02932801f, 0.00615764f, 0.00316155f, 0.02481446f, 
    -0.00350636f, -0.00090830f, -0.03603075f, 0.02622916f, 0.01209476f, -0.01077095f, -0.02832730f, -0.04375321f, 
    -0.04872658f, -0.04471853f, 0.00260315f, 0.00909514f, -0.02571699f, -0.01978020f, -0.00939166f, -0.04428230f, 
    -0.04933437f, -0.01480439f, -0.02315092f, -0.02373183f, 0.01947044f, -0.00831197f, -0.01475647f, 0.01427195f, 
    0.01311572f, -0.03461804f, -0.02153380f, -0.01182045f, -0.04145788f, -0.01174408f, 0.02564755f, 0.00613791f, 
    -0.01117121f, -0.00088027f, -0.01340908f, 0.01645396f, -0.03824035f, 0.00086818f, -0.02551385f, -0.01110991f, 
    0.00261105f, 0.00472757f, -0.01841372f, -0.00455736f, -0.01017298f, -0.02745136f, 0.02025937f, 0.01166245f, 
    0.02586620f, -0.02263444f, 0.01851753f, -0.01372230f, -0.03708544f, -0.00441640f, -0.02867348f, 0.02542408f, 
    0.02459823f, 0.01166888f, -0.01917809f, -0.01563408f, -0.00195034f, -0.04875223f, -0.04699002f, 0.02729594f, 
    0.01496508f, -0.03707939f, -0.01544001f, 0.00190068f, -0.03181547f, 0.01155337f, -0.01214595f, -0.00661879f, 
    0.01990123f, 0.02581640f, -0.03924510f, 0.01341537f, -0.00603008f, -0.04795068f, -0.02192313f, 0.02231105f, 
    -0.02603483f, 0.02485129f, 0.00540373f, -0.04819564f, -0.01543109f, -0.03410888f, 0.02178309f, -0.01369965f, 
    -0.02616050f, 0.01138746f, -0.02189734f, -0.01820521f, -0.00393599f, -0.04354341f, 0.01416190f, -0.04256866f, 
    0.02452306f, 0.03019961f, -0.01571179f, 0.01429305f, -0.01278415f, -0.04017716f, 0.01122346f, 0.02588111f, 
    0.01631684f, 0.01796618f, 0.00108187f, -0.04477872f, -0.00241215f, -0.01589349f, -0.01981346f, -0.04463338f, 
    0.00793850f, -0.02714700f, 0.01200979f, -0.03007638f, 0.00596639f, -0.03018935f, 0.02090932f, 0.00057362f, 
    0.03547942f, -0.03463418f, 0.00502711f, 0.01443159f, -0.01805936f, -0.03103226f, 0.02101888f, 0.01074147f, 
    -0.02081991f, 0.00307779f, 0.00449275f, -0.01753536f, -0.00998521f, 0.01420043f, 0.01621386f, -0.03736901f, 
    -0.02034216f, -0.01897189f, -0.04434350f, 0.01170933f, 0.03720167f, 0.02065881f, 0.02604789f, 0.02795845f, 
    -0.04526095f, 0.01285619f, -0.04749111f, 0.02943796f, -0.03482896f, -0.03814965f, -0.03355256f, -0.01640108f, 
    -0.00356910f, 0.02878869f, -0.02053107f, -0.00235676f, 0.01064078f, -0.00647070f, -0.02402910f, -0.01279983f, 
    0.02273482f, -0.01164517f, -0.00830038f, 0.01599993f, -0.02068988f, 0.00590597f, 0.02128052f, -0.02318431f, 
    -0.01456214f, 0.00604294f, -0.03684186f, -0.03181438f, 0.01296319f, -0.04773465f, -0.03458403f, 0.01239504f, 
    -0.00019760f, 0.00720043f, -0.02792086f, 0.00394326f, 0.02977320f, -0.04644770f, 0.01989653f, -0.03160717f, 
    -0.01320631f, -0.04104027f, 0.00086399f, -0.01790639f, -0.04805708f, -0.02538441f, 0.01005684f, 0.00299106f, 
    0.01768626f, 0.01067617f, 0.00508186f, -0.04522073f, 0.02335478f, -0.00450037f, 0.01834065f, -0.00513734f, 
    0.02672597f, -0.02833314f, -0.00162147f, -0.02721766f, -0.02881056f, 0.00532296f, 0.00158039f, -0.04506623f, 
    0.00473528f, -0.02711525f, 0.01460340f, -0.00818114f, 0.02275803f, 0.01579911f, -0.00019479f, -0.02759159f, 
    -0.03480003f, 0.00634536f, 0.00576521f, 0.01183045f, -0.01967383f, -0.03677038f, 0.01914853f, -0.00647457f, 
    -0.02720533f, -0.02818171f, 0.02089642f, 0.01665471f, -0.01008454f, -0.01326340f, -0.01692204f, 0.02351790f, 
    -0.00017494f, -0.03479942f, -0.04484292f, 0.02626990f, 0.01836952f, -0.02490689f, 0.01470901f, 0.00430378f, 
    -0.01157307f, -0.03426674f, -0.04922324f, 0.00476307f, -0.00133586f, -0.01138137f, -0.00808442f, 0.01693421f, 
    -0.01077914f, -0.00618300f, -0.03024442f, -0.03335356f, -0.00771185f, 0.02674974f, -0.04238920f, -0.00152754f, 
    0.02665554f, -0.04858817f, 0.01072862f, 0.01685796f, -0.00162353f, -0.01405976f, -0.00640057f, 0.00324794f, 
    0.01839761f, -0.04746122f, 0.02905800f, 0.00071479f, -0.04089200f, 0.00952289f, 0.02612508f, -0.03121472f, 
    -0.02995834f, 0.00314165f, -0.01382076f, 0.02051404f, 0.04319575f, 0.03562552f, -0.00333257f, 0.02765452f, 
    0.02921175f, 0.01277807f, -0.04386308f, -0.02197103f, -0.02802246f, 0.01993802f, -0.00552315f, -0.00179906f, 
    0.00214477f, -0.03086493f, -0.00030241f, -0.02171513f, 0.01115288f, 0.00975613f, 0.02360981f, -0.02408563f, 
    -0.21955889f, -0.07983740f, 0.22156182f, -0.21560219f, 0.10888887f, 0.20753682f, 0.08518751f, -0.20404693f, 
    0.04159073f, -0.14793603f, -0.13926043f, -0.01139982f, -0.04293215f, -0.01268206f, -0.09653212f, 0.01756912f, 
    0.01242836f, -0.02065687f, -0.09008589f, -0.02408798f, 0.42735419f, -0.04926666f, 0.01189278f, -0.00024671f, 
    -0.05361461f, -0.04453366f, 0.04636014f, -0.06156992f, -0.00381493f, 0.04158965f, 0.12597835f, -0.03291025f, 
    0.02098491f, -0.06578656f, -0.04710479f, 0.01851357f, 0.05096884f, 0.07324790f, 0.13882841f, 0.10269170f, 
    -0.11229215f, -0.00175082f, -0.37688026f, 0.15512003f, 0.41297185f, 0.09417140f, 0.03690781f, 0.03523607f, 
    0.01231113f, 0.03825749f, 0.15063228f, -0.06494907f, 0.22170153f, 0.19728023f, 0.07599906f, -0.00145070f, 
    0.09551435f, -0.11760897f, -0.03588443f, -0.07185017f, -0.16982327f, -0.10330040f, 0.21806240f, -0.14455007f, 
    0.13515098f, 0.01676643f, 0.04082477f, 0.09754365f, 0.21413158f, -0.04057466f, 0.00029502f, 0.09265317f, 
    -0.00493269f, 0.09537230f, 0.03859894f, 0.09568084f, -0.09909210f, -0.03733289f, -0.03294282f, -0.00281072f, 
    -0.01785911f, -0.24788088f, -0.02729024f, -0.14060368f, 0.07960891f, 0.05766031f, -0.06280912f, 0.06665233f, 
    -0.06614622f, -0.08785187f, -0.02934116f, 0.20930822f, 0.03186344f, 0.09255085f, -0.10411269f, 0.14121802f, 
    -0.02079138f, 0.08660036f, 0.03647901f, 0.01712816f, 0.07524272f, 0.17124957f, 0.28247517f, -0.00250477f, 
    -0.18584560f, 0.20953152f, -0.07256869f, 0.02917762f, 0.07214833f, 0.10778766f, -0.01075314f, -0.08586025f, 
    0.11369266f, 0.27779055f, -0.00225703f, 0.04584665f, 0.16723093f, -0.11023162f, -0.20339292f, -0.06792402f, 
    0.19281778f, 0.16478971f, 0.26183367f, -0.13643883f, -0.09674422f, 0.03843826f, 0.07504614f, 0.07652641f, 
    0.10336427f, 0.05848720f, -0.14358021f, -0.20696414f, 0.11822768f, 0.04462242f, 0.10081529f, -0.11267739f, 
    0.07184452f, -0.21895592f, -0.39931378f, 0.03548637f, -0.30076802f, 0.57838964f, 0.12324387f, -0.05792131f, 
    -0.05692852f, -0.11948072f, 0.05388265f, 0.08666696f, 0.02070660f, 0.08084974f, 0.17934139f, 0.04221422f, 
    -0.02467343f, -0.13193507f, -0.05484159f, -0.14241119f, 0.12389896f, 0.02641124f, 0.10693441f, -0.09108321f, 
    -0.37620360f, 0.29619044f, -0.16378479f, -0.10037621f, 0.35015875f, -0.12738174f, -0.02888355f, -0.04895181f, 
    -0.07353399f, 0.03013916f, -0.02150343f, 0.04324805f, 0.13898629f, -0.07580474f, -0.01330650f, 0.02416618f, 
    0.04467927f, 0.02674915f, 0.15828045f, 0.00130137f, -0.39849433f, 0.09806324f, -0.13634530f, 0.26091295f, 
    0.19086242f, 0.15452735f, -0.03272034f, -0.01159716f, -0.03466353f, -0.00443729f, -0.00170802f, 0.04136271f, 
    0.02777064f, 0.04406614f, -0.04132832f, -0.04802800f, -0.03976778f, 0.01230234f, -0.07074790f, -0.10685580f, 
    -0.19040634f, -0.08206708f, -0.26776251f, -0.22917634f, 0.12213170f, 0.12466133f, -0.08658560f, -0.06911510f, 
    0.00854639f, 0.12898612f, 0.12290087f, -0.01665623f, 0.05806535f, -0.11258957f, -0.02390247f, -0.03591400f, 
    0.04990415f, -0.05941005f, -0.00548516f, 0.08969827f, -0.30164164f, 0.09869829f, -0.09126952f, 0.08892144f, 
    0.27715212f, -0.02746994f, 0.01273720f, -0.00345572f, -0.02923296f, -0.03218654f, 0.08251521f, 0.05419192f, 
    0.04335232f, 0.13670559f, 0.04312140f, 0.19414160f, 0.09313745f, 0.07018842f, -0.01501512f, 0.08339465f, 
    -0.07092820f, 0.39743584f, 0.09026935f, -0.10941868f, 0.00728334f, 0.03880535f, -0.00476307f, -0.08516544f, 
    0.10045991f, 0.12904562f, 0.04443048f, -0.09674141f, -0.09885754f, 0.21208869f, 0.07515036f, -0.09663763f, 
    -0.00309315f, -0.12904054f, -0.03243265f, -0.02305088f, 0.27823082f, -0.11781845f, -0.04764375f, 0.09312550f, 
    0.04722600f, -0.16764532f, 0.06399430f, -0.16010514f, -0.06076277f, 0.00527096f, -0.01750345f, 0.00063875f, 
    0.08551904f, -0.06037791f, 0.06790772f, -0.08284270f, 0.05626813f, 0.01264130f, 0.06472673f, 0.05186052f, 
    -0.08472893f, 0.17881331f, 0.22329837f, -0.04554006f, -0.08192351f, 0.01153602f, 0.08734002f, 0.08064062f, 
    0.12803884f, -0.00749487f, -0.11347187f, -0.08502507f, 0.01045408f, -0.10011773f, -0.05014280f, 0.03296487f, 
    0.05665267f, -0.16052206f, 0.10734105f, -0.13983904f, -0.01610164f, 0.15623799f, -0.06791177f, -0.13747472f, 
    -0.08899178f, -0.02686680f, -0.10052555f, -0.04913396f, -0.11721405f, -0.07028461f, 0.06436501f, 0.03174456f, 
    0.00004891f, -0.25153935f, -0.09192476f, -0.03292346f, 0.00260243f, -0.16085324f, -0.06006871f, 0.03661723f, 
    0.38620225f, -0.19746086f, 0.29482439f, 0.06534290f, 0.13179629f, -0.20866849f, -0.03028491f, 0.09293446f, 
    0.00976818f, 0.06871215f, -0.00591420f, -0.07956596f, 0.00803529f, -0.00755012f, 0.09752314f, -0.00767804f, 
    0.07160629f, 0.11685796f, -0.17493054f, 0.11933520f, 0.25000250f, 0.14728168f, 0.25697893f, -0.07329974f, 
    -0.29821989f, -0.06319848f, 0.10160968f, -0.00708714f, -0.08810377f, -0.15325068f, 0.09376512f, 0.05885325f, 
    0.08459999f, -0.01023644f, -0.11666572f, -0.10726099f, -0.08274864f, -0.16710120f, 0.16219774f, -0.00951586f, 
    -0.27980053f, 0.07998108f, -0.11145872f, 0.09047000f, -0.15553586f, 0.13852313f, -0.12887211f, 0.01437904f, 
    -0.07812577f, -0.01507996f, -0.05243302f, -0.15116763f, -0.06549169f, -0.09052829f, 0.10830498f, -0.00294921f, 
    -0.15413234f, -0.09057476f, 0.09637191f, -0.00416457f, 0.19658002f, -0.04576318f, -0.03100927f, 0.15186369f, 
    0.26935095f, 0.06015158f, 0.03741598f, 0.02164421f, -0.01059313f, 0.00514244f, -0.05219300f, -0.01058006f, 
    -0.09613275f, 0.08453953f, 0.04372951f, -0.03062620f, 0.00368263f, 0.16619554f, 0.09258574f, -0.08928336f, 
    -0.09981829f, -0.31844226f, -0.18737572f, 0.15510775f, 0.02056617f, 0.14277719f, 0.01713423f, -0.01178187f, 
    0.06847291f, 0.02311149f, 0.12875579f, 0.00563890f, -0.07341161f, 0.14042275f, 0.02059486f, 0.06378569f, 
    -0.04609182f, -0.08297571f, -0.18401581f, 0.03878765f, -0.21585549f, 0.20521967f, 0.38847578f, -0.12487219f, 
    -0.07319336f, 0.25426152f, 0.03850390f, -0.11373226f, 0.15814978f, -0.14389297f, -0.11936165f, -0.05739836f, 
    0.03370421f, 0.14805104f, -0.17479593f, -0.05297367f, -0.04852229f, 0.08483545f, -0.33995485f, -0.06975416f, 
    0.17558047f, -0.72707891f, 0.19717222f, -0.24762723f, 0.02612090f, 0.00144657f, -0.02906960f, 0.08246064f, 
    -0.03983670f, -0.15730536f, 0.05879780f, -0.00676224f, -0.11787257f, 0.07365263f, -0.04196256f, -0.13422889f, 
    -0.07847466f, -0.20032233f, -0.07419870f, -0.10417800f, 0.15484002f, 0.02060031f, -0.08551559f, 0.18367644f, 
    0.40737697f, -0.08639231f, -0.02122456f, -0.03205585f, -0.08919433f, 0.02878793f, -0.01421422f, 0.07266684f, 
    0.07947174f, 0.07316891f, 0.00974352f, -0.00807797f, 0.04410171f, 0.19753143f, 0.14570947f, 0.02699862f, 
    -0.36052775f, 0.32021773f, -0.17828457f, -0.07058752f, 0.27350396f, 0.01573725f, 0.07032327f, -0.16629866f, 
    -0.03806123f, -0.02478285f, 0.00970326f, -0.01091524f, -0.02722804f, -0.17253694f, 0.09532177f, -0.08494014f, 
    0.06894787f, 0.15718096f, 0.05760863f, 0.01113779f, 0.19733284f, 0.13466199f, -0.01934863f, 0.00139422f, 
    0.13823542f, -0.10297155f, -0.09315179f, -0.10892262f, -0.10831179f, 0.00157996f, 0.04829759f, 0.01294105f, 
    -0.07898938f, -0.10088313f, -0.09432504f, -0.00463663f, 0.05855404f, 0.04621774f, 0.07234655f, 0.09057109f, 
    -0.01903689f, 0.08318931f, 0.09427339f, -0.09219299f, -0.45652390f, -0.11920489f, -0.12745227f, -0.03540575f, 
    -0.03476257f, 0.00358671f, -0.01523201f, 0.13792154f, -0.01075369f, 0.01079000f, 0.07634666f, 0.01025777f, 
    -0.02526628f, 0.06946420f, -0.07460111f, 0.22132510f, 0.19935383f, 0.18624564f, 0.17471588f, 0.16706987f, 
    -0.03324410f, -0.11174031f, -0.00731663f, 0.10042851f, -0.15261707f, 0.07665110f, -0.05754725f, -0.06602733f, 
    -0.00132813f, -0.01094967f, 0.07313489f, 0.13775381f, 0.09405459f, 0.02800191f, -0.04144960f, 0.13557738f, 
    0.29329237f, -0.03564111f, -0.44323716f, 0.17729312f, -0.08967826f, -0.04598400f, -0.09341466f, 0.03073436f, 
    0.04439880f, 0.29645297f, 0.03579042f, 0.13991086f, -0.07861896f, 0.08729400f, 0.07703656f, 0.16170965f, 
    0.05114493f, -0.22223383f, 0.04592557f, 0.11247443f, 0.23740192f, 0.07652204f, 0.04611735f, 0.10000315f, 
    -0.20289421f, -0.16969256f, -0.09030142f, -0.09858481f, -0.10857910f, 0.03309073f, 0.00950604f, 0.00454858f, 
    -0.11844210f, -0.09635524f, 0.05172762f, 0.00901324f, 0.16343834f, 0.08341082f, 0.00263175f, 0.02111758f, 
    -0.04250615f, -0.17796008f, -0.29090261f, 0.28495023f, 0.21160151f, 0.09793577f, -0.02906465f, -0.02454433f, 
    0.01487801f, -0.08667667f, 0.08495267f, 0.15184329f, -0.16113445f, 0.18227038f, -0.07729858f, 0.06524009f, 
    0.00965449f, 0.11155818f, -0.05879789f, -0.02337637f, 0.38210624f, 0.11277481f, 0.02463732f, 0.14840513f, 
    0.27353150f, -0.11367922f, -0.03763949f, -0.22707391f, -0.09814290f, -0.00132095f, -0.11302515f, 0.03320519f, 
    -0.13101876f, 0.10383122f, -0.05875107f, -0.09378527f, 0.18848087f, 0.04522105f, 0.01731748f, -0.01835318f, 
    0.01696889f, -0.03318791f, 0.03321034f, -0.02972888f, 0.02314878f, 0.02264389f, -0.03261974f, -0.04082378f, 
    0.01311856f, 0.02411147f, -0.03866654f, -0.04317981f, 0.01690903f, -0.04385128f, -0.00272629f, -0.03115363f, 
    -0.00656319f, -0.02457658f, -0.02224165f, 0.00367716f, -0.02667342f, -0.02110524f, -0.00592461f, -0.03309565f, 
    -0.01662429f, 0.01824526f, -0.03620676f, -0.02069639f, -0.02745303f, -0.03171291f, 0.02565749f, -0.03231921f, 
    0.02344960f, -0.04088004f, 0.02516878f, -0.03092342f, 0.01763447f, -0.02327207f, -0.03506571f, 0.00410561f, 
    0.03204061f, -0.00826300f, 0.01089772f, -0.02918387f, -0.00062645f, -0.02723101f, 0.00367773f, -0.00190150f, 
    -0.02385266f, 0.01757643f, -0.03896599f, -0.04131034f, 0.01624740f, -0.00904216f, -0.03887242f, -0.02828192f, 
    0.02624664f, -0.02446661f, -0.03269738f, -0.01799369f, -0.04331909f, -0.00824462f, -0.04156907f, -0.00713108f, 
    0.01069971f, 0.01960047f, -0.02872686f, 0.01547194f, -0.02449109f, -0.02168585f, 0.03323650f, 0.01880986f, 
    0.00109552f, -0.02383347f, -0.02389664f, 0.00284222f, -0.02592449f, -0.04439785f, -0.00439249f, 0.00337619f, 
    0.00363099f, -0.03549785f, 0.03267698f, -0.01863177f, -0.02254566f, 0.01073972f, -0.00773952f, -0.00902008f, 
    0.00106989f, 0.00917745f, -0.04336167f, 0.02122330f, 0.01598656f, 0.01606923f, -0.00489968f, 0.02155504f, 
    -0.02809734f, -0.04441049f, -0.00260276f, 0.01588200f, -0.03940925f, 0.03168277f, -0.00727456f, 0.00620337f, 
    -0.00381933f, 0.00842167f, 0.00310224f, -0.02462411f, -0.01235043f, -0.01749237f, -0.01024138f, -0.00925980f, 
    -0.00472528f, -0.01909209f, 0.02929242f, -0.02920318f, -0.03073776f, -0.03484214f, -0.00427343f, -0.03265232f, 
    0.03114585f, -0.04539746f, 0.02574562f, -0.03882090f, 0.02579038f, 0.00350524f, 0.00370534f, 0.00833298f, 
    -0.02484749f, -0.01445925f, -0.02695977f, -0.03017945f, -0.02623340f, -0.01799646f, -0.03379744f, 0.02309491f, 
    -0.00955238f, 0.00698377f, -0.01633555f, -0.01278651f, -0.03172219f, -0.00173907f, 0.00935976f, 0.01625752f, 
    0.01703979f, 0.03214881f, 0.00993189f, 0.01739472f, -0.04261928f, 0.02317202f, -0.02705953f, -0.00784321f, 
    -0.03395350f, -0.00370607f, 0.02118704f, -0.01772686f, 0.00083312f, 0.02906924f, -0.01074115f, -0.03216926f, 
    -0.01280409f, 0.00914785f, -0.00003398f, -0.03785513f, -0.01328999f, 0.01822134f, 0.01658936f, -0.03049975f, 
    -0.01456054f, -0.00022958f, -0.00110441f, 0.01271678f, 0.02750668f, -0.01510060f, -0.01464297f, -0.03895013f, 
    0.01845596f, -0.02800306f, 0.01254325f, 0.00730223f, -0.02755048f, -0.02308973f, 0.01240520f, 0.00274766f, 
    0.02030396f, 0.00513654f, -0.03516227f, 0.03020198f, 0.03113086f, 0.00047738f, 0.02807550f, -0.03031175f, 
    0.00638417f, -0.00603429f, -0.01847613f, -0.00669533f, 0.02309963f, 0.01072816f, -0.03919720f, 0.03235855f, 
    0.03235084f, 0.01020184f, -0.00014950f, 0.02470681f, -0.01359922f, -0.04355157f, -0.00663453f, -0.00651036f, 
    0.01631473f, -0.01775578f, -0.01571800f, -0.01829156f, -0.00921151f, 0.03557581f, -0.03252533f, 0.03764467f, 
    0.02622898f, -0.02833071f, -0.00657507f, -0.02855108f, -0.02494231f, 0.00614918f, -0.03749594f, 0.00764882f, 
    0.01438798f, 0.02709403f, -0.01668863f, 0.03044543f, -0.00177106f, -0.00977325f, -0.02160066f, -0.03551213f, 
    -0.04355929f, -0.03230114f, -0.02413850f, 0.01741645f, -0.04529173f, -0.04418330f, -0.01007164f, 0.00218782f, 
    -0.01108235f, -0.02162262f, -0.02863460f, 0.02440127f, -0.03959430f, 0.01733891f, 0.02750139f, 0.00656301f, 
    -0.02966756f, -0.03600088f, -0.03555685f, 0.00101379f, -0.03945971f, -0.00801118f, 0.00063309f, -0.04265508f, 
    0.02818868f, -0.01516154f, -0.01090150f, 0.03067447f, 0.03460629f, -0.02238152f, -0.04189319f, 0.03044830f, 
    -0.03939686f, -0.00040964f, 0.02053286f, 0.00553418f, -0.04341650f, -0.03560172f, 0.02820420f, -0.01862400f, 
    -0.04550461f, -0.00544560f, 0.02234776f, 0.00799502f, 0.00054664f, -0.00756127f, -0.02387931f, 0.00830667f, 
    -0.00474223f, 0.01756652f, -0.03951225f, 0.00351688f, -0.03970228f, -0.00132400f, 0.02916799f, 0.02895847f, 
    -0.04397646f, 0.00776258f, 0.00528010f, 0.01286469f, 0.02528950f, -0.04419768f, -0.00806677f, 0.02926785f, 
    0.03110551f, -0.03705439f, -0.00707961f, 0.00229173f, 0.03060647f, -0.01689688f, -0.03284263f, 0.02260258f, 
    0.02219978f, 0.00070421f, 0.02140000f, 0.02713323f, -0.04458261f, -0.02658871f, -0.03361816f, 0.01845770f, 
    0.03323747f, 0.03026565f, -0.01289683f, -0.00572033f, 0.01425401f, -0.03411805f, -0.02688649f, -0.02276817f, 
    0.02280983f, -0.01758429f, -0.00451521f, -0.01572258f, -0.04529043f, -0.03479734f, -0.02733241f, -0.01751701f, 
    -0.01528699f, 0.03089831f, -0.02430416f, -0.01947752f, -0.01666583f, 0.00619822f, 0.02912853f, -0.02902139f, 
    -0.04551133f, 0.01965702f, -0.04048214f, -0.02773868f, 0.00487058f, -0.02188713f, 0.01430511f, 0.03329441f, 
    0.02547085f, -0.01223665f, 0.00262262f, -0.01553812f, -0.01696691f, 0.00909911f, -0.02356642f, 0.03038496f, 
    -0.03734152f, -0.03855361f, 0.02984560f, -0.02497627f, -0.01688239f, -0.00953875f, -0.03439853f, -0.04364348f, 
    0.00153692f, -0.02199161f, 0.02225013f, -0.00662335f, 0.01940843f, -0.03191772f, 0.01864031f, -0.01375670f, 
    0.01982110f, -0.03167905f, 0.02253307f, 0.03211219f, 0.02905479f, 0.02528658f, 0.02323678f, 0.01647060f, 
    -0.04153426f, -0.03884115f, -0.00597098f, -0.02917213f, 0.00957242f, 0.01960518f, -0.00044983f, -0.03074365f, 
    -0.04031439f, 0.00405910f, -0.01499722f, -0.02713212f, 0.01683894f, 0.03008152f, 0.01641241f, -0.00877106f, 
    -0.00339922f, 0.03287602f, -0.00403310f, 0.01654441f, -0.03919182f, -0.01685882f, 0.01288783f, -0.03116179f, 
    -0.01284213f, -0.00675444f, -0.02335385f, 0.00282947f, -0.03426073f, 0.03045178f, 0.00778178f, 0.03085326f, 
    -0.02506669f, -0.02988140f, -0.01948300f, -0.02982396f, -0.04454874f, -0.01425445f, -0.02547370f, 0.01093446f, 
    -0.00265850f, -0.00122035f, -0.04168076f, 0.01273972f, -0.04425017f, -0.02805284f, 0.00718649f, 0.00370828f, 
    -0.01047528f, -0.02908030f, -0.01283940f, -0.03595559f, -0.00106201f, -0.04225077f, 0.03322458f, 0.01230985f, 
    0.00709496f, -0.03607181f, 0.01353905f, -0.00700522f, -0.00215502f, -0.00114226f, 0.01789483f, -0.01751218f, 
    0.00268238f, 0.01997032f, 0.01181455f, 0.00814409f, -0.01675576f, 0.01055275f, 0.01496896f, -0.00001527f, 
    -0.00985341f, -0.00254476f, -0.01485269f, -0.01170904f, -0.02569209f, 0.01780563f, 0.03481965f, 0.03316836f, 
    -0.04236843f, 0.02426231f, -0.02455419f, -0.02522692f, -0.03954739f, 0.01921548f, 0.00709180f, 0.01856242f, 
    0.00458877f, 0.01614727f, -0.02426151f, -0.03901602f, -0.01573268f, -0.04460962f, 0.02277902f, -0.02004947f, 
    -0.02745336f, 0.01768359f, -0.00581791f, -0.01142177f, -0.03022020f, 0.02940396f, -0.02269104f, -0.02933933f, 
    -0.01105061f, 0.02879943f, 0.01690967f, -0.01124016f, 0.01040239f, -0.01701145f, -0.03506979f, -0.02848927f, 
    0.01107430f, -0.01705443f, -0.01527322f, -0.03496462f, -0.03690058f, -0.00850122f, -0.01812716f, -0.00911044f, 
    -0.01945115f, -0.00356324f, -0.03685528f, -0.03330832f, -0.00213076f, -0.01539376f, 0.03192503f, -0.00153375f, 
    -0.04033362f, -0.02777658f, -0.00708085f, -0.03666593f, -0.00337826f, -0.03816197f, -0.01032227f, -0.01428978f, 
    -0.02337255f, -0.00183325f, 0.02427719f, -0.02023095f, 0.01615531f, -0.02692870f, -0.00682998f, -0.00635983f, 
    -0.02240973f, 0.00007933f, -0.03452421f, -0.01745933f, -0.03273473f, 0.00391134f, -0.04198588f, 0.00936323f, 
    0.01470684f, 0.01407469f, -0.01763058f, -0.02953780f, 0.02092564f, 0.00566533f, 0.01868383f, 0.03484356f, 
    -0.01147538f, 0.03022268f, 0.02319282f, -0.03289407f, -0.01476908f, -0.01215457f, 0.01542117f, -0.02625726f, 
    -0.01459303f, -0.04455785f, 0.01848233f, -0.02339644f, -0.02107033f, 0.02691592f, 0.02609364f, -0.01320030f, 
    0.01569249f, 0.02229090f, 0.00083488f, 0.02743658f, -0.03601658f, 0.01539105f, 0.03343689f, -0.03011309f, 
    0.00670426f, 0.01502578f, -0.03305468f, -0.02738472f, -0.00782984f, 0.00593342f, -0.02236805f, 0.00433893f, 
    0.01342093f, -0.03438891f, 0.01255894f, -0.04082779f, -0.03538076f, 0.01959109f, -0.03637787f, -0.02547828f, 
    -0.03950109f, 0.00383167f, -0.00412233f, 0.01119428f, 0.02805522f, 0.00641235f, 0.03193310f, 0.01153065f, 
    -0.04127862f, -0.00827671f, 0.01546731f, 0.02295022f, 0.01194474f, 0.01338161f, -0.01482896f, 0.01070291f, 
    -0.00234034f, 0.00152882f, -0.00875595f, -0.03708811f, -0.01672783f, -0.02460010f, -0.01412954f, -0.00594006f, 
    0.01166576f, 0.00681878f, -0.04068565f, -0.02997390f, -0.01668891f, 0.01497422f, 0.00167927f, 0.00587136f, 
    0.01873022f, -0.01243599f, 0.00394802f, -0.00717276f, 0.02983370f, -0.03070760f, 0.01624326f, 0.01480725f, 
    0.02424147f, -0.03744689f, -0.04413417f, 0.03161267f, 0.02353854f, -0.03935329f, -0.03719364f, 0.01071216f, 
    0.01625342f, -0.02227308f, 0.01355670f, 0.03055582f, 0.03145545f, -0.02982230f, -0.00584092f, -0.02267724f, 
    -0.01197448f, -0.02204333f, -0.00819719f, -0.01768122f, 0.01746584f, -0.02708053f, 0.01978427f, 0.02051401f, 
    -0.00619830f, -0.02762756f, 0.00647741f, -0.03450300f, -0.01205697f, 0.03166397f, -0.00737577f, -0.00805260f, 
    0.02601131f, 0.02416729f, -0.02868867f, -0.03092947f, -0.00224182f, -0.00957447f, -0.03764647f, 0.02256578f, 
    -0.03683167f, -0.00503467f, -0.01839179f, 0.02534698f, 0.01968628f, -0.00504052f, -0.04030624f, -0.01250922f, 
    -0.01456230f, -0.01989655f, 0.00222402f, 0.02895401f, -0.00190637f, -0.03221852f, -0.01324928f, 0.01806381f, 
    -0.01989896f, 0.00809595f, -0.01300692f, -0.04437499f, -0.02481821f, -0.00679188f, -0.02440429f, -0.04191392f, 
    -0.01489157f, 0.01652522f, 0.02216050f, -0.03527647f, -0.04133741f, -0.00673854f, -0.02185732f, -0.04328432f, 
    0.02806111f, 0.01835451f, 0.01987454f, 0.00064650f, -0.04602444f, 0.02462936f, -0.02158817f, -0.01878980f, 
    0.00222736f, -0.01130522f, -0.01990221f, -0.00424041f, 0.03115933f, 0.02490108f, 0.00917746f, -0.00402195f, 
    -0.03522096f, -0.04442088f, 0.03240329f, -0.01114875f, 0.02322790f, 0.01543127f, 0.02943091f, -0.02036621f, 
    -0.02267248f, 0.00324598f, -0.01216969f, -0.02490006f, 0.00188890f, 0.00058275f, -0.00044519f, 0.04295449f, 
    0.01862029f, -0.01574900f, -0.03084893f, 0.01095194f, -0.02759544f, -0.03007202f, -0.01403247f, 0.00358271f, 
    -0.03289966f, -0.01298301f, -0.03558842f, 0.02705059f, -0.03584997f, 0.02902290f, -0.01538478f, 0.00102917f, 
    0.03704818f, 0.00543796f, 0.00490386f, 0.03726964f, -0.03443043f, -0.01771875f, -0.00011276f, 0.03288865f, 
    0.00579706f, -0.03060856f, 0.04343500f, -0.03390929f, 0.00851087f, -0.01400779f, 0.00790178f, -0.02792320f, 
    -0.02059597f, 0.02323196f, 0.03452022f, -0.00772430f, -0.04026400f, -0.00583777f, 0.02321202f, -0.01664644f, 
    -0.00733564f, -0.01751706f, 0.02089889f, 0.01476190f, 0.03777931f, -0.03656814f, -0.03202893f, -0.01141198f, 
    -0.03411152f, -0.00540260f, -0.01335863f, 0.02148537f, -0.03378849f, 0.00215255f, -0.00618818f, -0.03024406f, 
    -0.03940741f, 0.02461558f, 0.01864825f, 0.02279177f, 0.02778818f, 0.01957499f, 0.02873728f, 0.00018955f, 
    -0.01516952f, -0.02735160f, 0.03091281f, 0.01865591f, 0.02572959f, -0.01093918f, -0.02553074f, -0.01513001f, 
    -0.01313984f, -0.02023108f, -0.03255840f, 0.03565053f, 0.04052062f, 0.01976675f, -0.01842555f, -0.02490982f, 
    -0.00043163f, 0.01685456f, 0.01261974f, -0.02848823f, 0.02852237f, -0.00713407f, -0.04107964f, 0.02924762f, 
    -0.03065496f, -0.01863505f, -0.01058416f, -0.01728630f, -0.04137350f, -0.00869112f, -0.01506065f, -0.02211512f, 
    -0.04536700f, -0.00077563f, -0.03490437f, 0.00605845f, -0.01269771f, 0.02957313f, -0.00584388f, 0.01989122f, 
    -0.04686359f, -0.03511061f, 0.01584663f, 0.02437205f, 0.01779838f, -0.02050240f, -0.00130335f, -0.02238469f, 
    -0.01674903f, 0.01857574f, 0.01608731f, -0.04466851f, -0.01660998f, 0.00665584f, 0.00180945f, 0.02369084f, 
    -0.00435748f, -0.00386965f, 0.02470840f, 0.02179761f, 0.00854924f, -0.02960130f, -0.02150317f, -0.00212502f, 
    -0.00255663f, -0.01445957f, -0.02162055f, -0.03971897f, 0.00616233f, 0.00082110f, -0.03039261f, -0.02152043f, 
    0.01991139f, 0.02584612f, -0.01947304f, 0.03154747f, -0.00413280f, -0.03927087f, 0.00835559f, 0.00288404f, 
    -0.00366061f, 0.00853029f, -0.03906759f, 0.00997192f, -0.02036313f, -0.00894061f, -0.01323997f, -0.02967017f, 
    0.00180706f, -0.03179799f, -0.03493359f, 0.00861128f, -0.02298940f, 0.01325448f, 0.00320366f, 0.02115894f, 
    0.00700776f, -0.03240946f, -0.00126535f, 0.03384116f, -0.01457337f, -0.03743344f, 0.01276325f, 0.01435212f, 
    -0.03277117f, -0.03328760f, -0.00612134f, -0.03847376f, -0.04722142f, 0.03710794f, 0.02952871f, -0.00899994f, 
    -0.00304875f, -0.00294979f, -0.02034540f, 0.02603810f, -0.02026735f, 0.01587142f, -0.01253085f, -0.00417480f, 
    0.01204959f, -0.00230697f, 0.00301890f, 0.01743162f, -0.00434154f, 0.01231008f, -0.02281587f, -0.00932337f, 
    0.01600061f, 0.01540664f, 0.00229086f, -0.02463903f, -0.03334127f, -0.01444206f, -0.02579494f, -0.04734743f, 
    -0.03808551f, -0.00887932f, 0.02269416f, 0.03108529f, 0.03884691f, -0.03914667f, 0.00717128f, 0.00753746f, 
    -0.02435116f, -0.00438337f, 0.02640362f, -0.02712040f, -0.02128433f, 0.01770509f, -0.04120352f, -0.03576534f, 
    0.02213503f, -0.02108867f, 0.03242021f, -0.01193090f, 0.01244299f, 0.00643231f, 0.00228179f, -0.01206645f, 
    0.03113104f, -0.04123102f, -0.00438023f, 0.01786962f, 0.02489539f, -0.03374889f, -0.02214938f, -0.04032761f, 
    -0.01227146f, -0.00692657f, -0.02831063f, -0.01714102f, -0.01577158f, -0.00748961f, -0.01333295f, 0.00212914f, 
    -0.03560017f, 0.00974429f, -0.01748253f, 0.02906752f, -0.01874002f, -0.02547941f, -0.01108079f, -0.01862750f, 
    -0.04493948f, 0.03414145f, 0.01105465f, -0.02219678f, -0.03577673f, -0.00184799f, 0.01313027f, -0.02954126f, 
    0.02946208f, -0.01081642f, -0.01936770f, -0.03875188f, 0.00705153f, -0.00816978f, -0.04270261f, 0.00940938f, 
    -0.01931018f, 0.02088995f, -0.03389468f, 0.02236536f, 0.00116806f, 0.02022907f, 0.00073853f, -0.00270763f, 
    0.04512502f, -0.00722343f, -0.00810923f, 0.02294859f, -0.01605787f, -0.02537543f, -0.01689998f, -0.00699601f, 
    0.00132200f, -0.00298652f, -0.02430652f, -0.04259859f, 0.01022884f, 0.03491992f, -0.00897531f, -0.02043387f, 
    -0.00249362f, -0.01619069f, 0.01665653f, -0.04205013f, 0.01900849f, -0.02946812f, 0.00042158f, 0.01433394f, 
    0.02785570f, 0.00303854f, 0.01409264f, -0.01832703f, -0.02002375f, -0.01025751f, -0.00784145f, 0.01395574f, 
    0.03926715f, -0.00331053f, 0.01307045f, -0.01238336f, -0.01114908f, 0.03156800f, -0.02179079f, 0.03798724f, 
    -0.03118231f, 0.00829915f, -0.01868677f, -0.01898869f, -0.00764099f, 0.01162311f, 0.01853853f, 0.02811134f, 
    -0.01379898f, 0.03631427f, -0.03841406f, -0.00281760f, -0.01053285f, 0.00438951f, -0.00186263f, -0.04101096f, 
    0.02454718f, -0.00852697f, 0.02690409f, 0.01851339f, 0.00356542f, -0.02530023f, -0.00073808f, -0.03435285f, 
    -0.00087529f, 0.02550059f, 0.02631284f, -0.02842328f, -0.01047728f, -0.00965523f, 0.02740377f, -0.04998868f, 
    -0.03625371f, 0.02784236f, 0.01417092f, -0.03214248f, -0.01016132f, -0.02764084f, -0.02607534f, -0.04094145f, 
    0.02754941f, -0.02411721f, 0.02784951f, 0.02586184f, 0.02902940f, -0.04215179f, 0.01773057f, -0.01511430f, 
    0.03638094f, 0.02553736f, 0.03377526f, -0.01136092f, 0.03336591f, 0.00435550f, -0.02938598f, 0.02221025f, 
    0.01684037f, -0.01752766f, -0.00579190f, 0.03176870f, -0.02884512f, -0.01400395f, -0.00352061f, -0.01841889f, 
    0.01141392f, 0.01521878f, 0.04108952f, 0.04021897f, 0.03862417f, -0.02009909f, 0.02084578f, -0.03368259f, 
    0.00339827f, 0.02834001f, -0.02788906f, -0.00999704f, 0.02246811f, 0.02833321f, 0.01320766f, 0.02407354f, 
    -0.00749902f, 0.01636788f, -0.00740337f, -0.02090821f, 0.03067653f, 0.03319073f, 0.02617074f, -0.00845342f, 
    0.01718942f, -0.04025369f, -0.02731999f, -0.02758327f, -0.02666176f, -0.03324763f, 0.03225842f, 0.02900694f, 
    -0.00194174f, 0.00641654f, -0.02879254f, -0.00268961f, 0.02209139f, 0.03319300f, 0.00069339f, 0.01347115f, 
    -0.00074002f, -0.00895949f, 0.00786261f, -0.02220176f, -0.02278741f, -0.00540639f, -0.00590385f, 0.03130897f, 
    0.01472759f, 0.00057225f, -0.00286196f, 0.00767503f, 0.03206170f, 0.02468891f, 0.03250868f, -0.01544098f, 
    -0.03095344f, 0.03481438f, 0.02300449f, -0.00701498f, -0.01048292f, -0.01549197f, -0.02830511f, -0.03247171f, 
    0.03651742f, 0.01685379f, 0.00892242f, -0.02377944f, -0.03718970f, -0.04341817f, 0.00632051f, -0.03294902f, 
    -0.03904202f, -0.00614745f, -0.01323821f, -0.00005243f, -0.04224288f, 0.03022724f, -0.01165957f, -0.00393356f, 
    0.03403911f, -0.03271462f, 0.00264429f, -0.01222781f, -0.01018194f, 0.00927225f, 0.04397338f, 0.00039969f, 
    -0.00226520f, -0.01334886f, -0.03367246f, 0.02242656f, -0.02451942f, -0.02139882f, 0.00356916f, 0.03523660f, 
    0.00452122f, -0.02893142f, -0.00709755f, -0.03276175f, 0.02385412f, -0.02841761f, 0.02040217f, -0.01826680f, 
    0.03996474f, -0.02856594f, -0.01919726f, -0.03529335f, -0.03651369f, -0.03604108f, 0.01786868f, -0.02806095f, 
    0.02708990f, -0.00230483f, 0.02289017f, -0.03485462f, 0.02731358f, -0.03785542f, -0.02202906f, 0.02024853f, 
    0.00025714f, -0.00710594f, -0.03169166f, -0.00705858f, -0.02616071f, -0.02145752f, -0.01258646f, 0.03452061f, 
    0.00600684f, -0.03349972f, -0.01561529f, 0.01183659f, -0.00063574f, 0.00863159f, -0.02177217f, -0.02278611f, 
    0.01147744f, 0.03729780f, -0.01175628f, -0.00581817f, 0.02981054f, 0.01216845f, 0.00193297f, 0.00779278f, 
    -0.03477397f, -0.00242364f, 0.00366164f, -0.01138679f, -0.01824737f, -0.03729674f, 0.00291084f, -0.04013988f, 
    -0.01658971f, -0.00943986f, -0.00181454f, 0.03080956f, -0.01479397f, -0.01517652f, 0.01294911f, -0.02305425f, 
    -0.02287384f, -0.01205357f, -0.02761847f, 0.00950435f, -0.01206790f, -0.02514808f, 0.02041094f, 0.00108754f, 
    0.01835947f, 0.00022558f, -0.01509117f, -0.02661907f, -0.02078428f, -0.01033777f, -0.01844645f, 0.01370256f, 
    -0.04163952f, 0.01174630f, -0.03484482f, -0.02622743f, -0.00966980f, -0.01154193f, -0.00529592f, 0.00938566f, 
    -0.01234686f, 0.01361161f, -0.03134058f, 0.00546113f, -0.00025326f, -0.03064941f, -0.00645483f, -0.00705298f, 
    0.01241928f, 0.00977959f, -0.02564305f, 0.02969733f, 0.00127930f, -0.00015437f, -0.03403289f, -0.00092285f, 
    0.00136546f, -0.01753953f, 0.03192953f, 0.01158648f, 0.00237405f, -0.02879657f, 0.01378751f, 0.02153288f, 
    -0.03774642f, -0.03804505f, 0.00777960f, -0.01660496f, -0.02994950f, -0.02679615f, 0.01294478f, -0.01147601f, 
    -0.01391272f, -0.02944936f, -0.00450524f, 0.00909224f, 0.01555072f, -0.00354156f, 0.01571989f, -0.04093372f, 
    -0.02407944f, 0.01491978f, 0.02200591f, -0.03250560f, -0.03490128f, 0.00404669f, 0.02851934f, -0.04495348f, 
    -0.04730005f, 0.02405267f, -0.01849125f, -0.00375930f, 0.01606515f, 0.01143283f, 0.01410852f, -0.04550288f, 
    0.01752631f, -0.02491705f, -0.02889926f, -0.00162701f, -0.00231964f, 0.00071824f, -0.03986345f, 0.00495116f, 
    -0.02011706f, 0.00129402f, 0.01677752f, 0.00881948f, 0.03105751f, -0.01456278f, 0.03147224f, -0.03064234f, 
    -0.02172749f, -0.04614540f, -0.04539111f, 0.00407949f, -0.01522593f, -0.02710759f, 0.02826163f, -0.04334543f, 
    -0.02372581f, -0.03291747f, 0.00041427f, -0.03297511f, 0.02291289f, -0.04318598f, -0.01799528f, 0.00216497f, 
    -0.00968961f, -0.01079213f, -0.01813331f, -0.00052758f, -0.00115961f, -0.04136738f, 0.02072047f, -0.02423950f, 
    0.03395786f, -0.01832028f, 0.03008704f, 0.02726895f, 0.01214872f, -0.00717479f, -0.02295950f, 0.02112133f, 
    0.00500742f, -0.04543088f, -0.01723285f, -0.03727815f, -0.03375887f, -0.01427609f, -0.04043527f, -0.03139315f, 
    0.01248141f, -0.01923817f, 0.01513758f, 0.02430966f, 0.00755415f, -0.03840200f, -0.01584412f, 0.03722442f, 
    -0.04025981f, -0.02996456f, 0.01779492f, -0.03244485f, 0.00247092f, 0.02291222f, -0.04308464f, 0.00630361f, 
    -0.00789668f, -0.02047521f, 0.02975862f, -0.00437806f, 0.02153683f, 0.02205613f, -0.01835714f, 0.01168592f, 
    0.02784277f, -0.03494908f, 0.02481860f, -0.00097583f, -0.00874999f, -0.04379614f, 0.01723735f, 0.02855276f, 
    -0.01846285f, -0.01323414f, -0.03322203f, -0.01569216f, -0.01595282f, 0.00592253f, 0.01337187f, -0.01189702f, 
    -0.03949394f, -0.04456472f, 0.02104250f, -0.01762849f, 0.02413312f, 0.00514289f, -0.03795074f, -0.02548082f, 
    0.02389621f, -0.04461014f, -0.04568956f, 0.00400075f, 0.00756543f, 0.00740886f, -0.04670072f, 0.00227165f, 
    0.02522541f, 0.02648453f, 0.01053379f, 0.01227333f, -0.01670647f, 0.02345690f, -0.04773037f, 0.01909165f, 
    -0.02454400f, 0.01298201f, 0.01766932f, 0.01219537f, -0.03607391f, 0.00446075f, 0.02352676f, 0.02037885f, 
    0.01975091f, -0.01925135f, -0.02148915f, 0.02454575f, 0.01877286f, -0.01259936f, 0.01685523f, 0.01609865f, 
    -0.03378480f, 0.00618141f, -0.03831398f, 0.01245496f, -0.02730468f, -0.02416643f, -0.03120599f, -0.01473804f, 
    0.02396993f, -0.02954139f, -0.04895350f, 0.01341826f, -0.04041946f, -0.02268147f, -0.02987262f, -0.03251531f, 
    -0.00851387f, 0.00856992f, 0.01483047f, 0.02599973f, -0.03131675f, 0.02993881f, -0.04149433f, -0.01270048f, 
    -0.01312289f, 0.01574393f, -0.04293464f, -0.04226032f, 0.02419276f, -0.02265534f, -0.00787314f, 0.00224282f, 
    0.01301812f, 0.02657631f, 0.02788161f, -0.01684801f, -0.00841362f, -0.02738520f, -0.00875180f, 0.03122148f, 
    0.03052679f, -0.00119206f, 0.03023512f, -0.03540554f, -0.02644827f, 0.00780090f, -0.02507723f, 0.01845523f, 
    0.01176844f, -0.02416905f, -0.02332827f, -0.01785944f, 0.01481641f, -0.01072753f, -0.04164055f, 0.03052499f, 
    0.02047936f, 0.01499519f, 0.02443572f, 0.00667297f, 0.02507160f, -0.03100189f, -0.00790611f, 0.00147629f, 
    0.02653974f, -0.04297472f, 0.01309611f, -0.03462771f, -0.03938896f, -0.03711929f, -0.00687109f, 0.02502375f, 
    -0.03341655f, 0.01350737f, 0.01951595f, -0.00444734f, -0.00285472f, -0.02813130f, 0.00901046f, -0.03416505f, 
    -0.03917013f, -0.03088344f, 0.02289838f, 0.00335207f, -0.02722824f, 0.02357235f, -0.04258702f, -0.03226199f, 
    -0.00017579f, -0.02853029f, 0.02564452f, -0.02511378f, -0.02253695f, 0.02897860f, 0.00416482f, -0.01869239f, 
    -0.01942052f, -0.00329259f, 0.01561216f, 0.02864313f, -0.02021380f, -0.03063694f, 0.03277992f, -0.00705180f, 
    0.01612795f, 0.01706894f, 0.02487892f, -0.01154128f, -0.02657044f, 0.01702482f, -0.01085563f, 0.01919406f, 
    -0.03128934f, -0.01917228f, -0.00848462f, -0.03516533f, -0.03721392f, 0.02639602f, -0.01450778f, -0.02595802f, 
    -0.03673870f, 0.01198443f, 0.00411316f, -0.00133826f, 0.01354440f, -0.04356780f, -0.00492281f, -0.01017319f, 
    -0.01303862f, -0.01767635f, 0.01640000f, -0.02599585f, -0.04341226f, -0.00367230f, -0.00617001f, 0.00058828f, 
    -0.04465071f, 0.00012575f, 0.02588514f, -0.03512485f, 0.01962063f, -0.04635542f, -0.00428335f, -0.04416143f, 
    -0.04323209f, -0.03785447f, 0.01808488f, 0.01704285f, 0.03277905f, -0.02699303f, 0.02198764f, 0.00494592f, 
    -0.00913177f, 0.02545389f, 0.01163935f, 0.01464106f, -0.01238967f, -0.02777970f, 0.02736102f, -0.00186469f, 
    0.01702224f, -0.03956962f, -0.00753216f, -0.00568059f, 0.01652427f, -0.00176363f, -0.00546630f, 0.02173470f, 
    -0.01789429f, 0.01274440f, 0.00085138f, -0.03238697f, 0.00809845f, -0.04067811f, -0.02111411f, -0.04569080f, 
    -0.04573643f, 0.00325399f, 0.01019655f, 0.00456557f, -0.00657291f, 0.00651986f, 0.01079648f, 0.01070063f, 
    0.03110206f, -0.02884836f, 0.01771010f, -0.02469740f, 0.02972155f, 0.02693682f, 0.01547389f, -0.00421294f, 
    -0.02584767f, 0.01138255f, 0.00117980f, 0.01968606f, 0.02808577f, 0.00999116f, 0.02202628f, -0.03343603f, 
    -0.02096680f, 0.00503035f, -0.03211287f, -0.03253435f, 0.03024689f, 0.02367343f, -0.00982440f, 0.00810099f, 
    0.00038582f, -0.03751971f, 0.01946908f, 0.00447577f, -0.02519297f, -0.01823360f, -0.00178794f, -0.01281360f, 
    0.01340919f, -0.01564628f, 0.01830228f, -0.01490213f, -0.01657328f, 0.02974006f, -0.03476518f, -0.01159736f, 
    -0.00495360f, -0.03611540f, -0.01674983f, -0.00208824f, -0.04412915f, -0.00412017f, -0.03589834f, 0.01872656f, 
    -0.01332646f, 0.02728222f, 0.01346421f, 0.02501209f, -0.01424467f, 0.02789702f, -0.03754820f, 0.01671445f, 
    -0.03665227f, -0.02992120f, 0.02329319f, -0.01822971f, 0.02009710f, 0.00284384f, -0.03321462f, -0.02526901f, 
    -0.02277161f, 0.02097574f, -0.02992820f, 0.00493361f, -0.01244948f, -0.00856211f, -0.02232115f, -0.03581293f, 
    -0.02547371f, 0.00104035f, 0.00921341f, 0.02244271f, -0.03654914f, -0.01067579f, 0.03003926f, 0.00240112f, 
    0.00500546f, 0.03212602f, -0.00773280f, -0.01356635f, -0.00223301f, -0.02378657f, -0.00798354f, -0.01383305f, 
    0.02100190f, 0.02331326f, -0.01368971f, 0.01037656f, 0.00023366f, -0.01524075f, 0.02735085f, -0.03039820f, 
    -0.02132182f, 0.00028332f, -0.01150310f, -0.01503952f, -0.04505799f, -0.00648170f, -0.01902943f, 0.02904437f, 
    -0.02994473f, -0.04351263f, 0.02059148f, 0.00882938f, -0.01422064f, -0.03532942f, 0.01579454f, -0.03024254f, 
    -0.02518242f, 0.02417221f, 0.01470519f, 0.02244905f, -0.03960943f, -0.00977136f, 0.01144346f, -0.00995411f, 
    0.01120047f, -0.03736676f, 0.02408024f, -0.03251458f, -0.00332543f, 0.01134650f, -0.02794405f, -0.00383199f, 
    -0.00073847f, 0.00064251f, -0.03614693f, 0.01822951f, 0.01802950f, -0.04240676f, 0.01267790f, -0.04258933f, 
    0.01167915f, 0.00141737f, -0.01565753f, -0.04113533f, 0.01660654f, 0.02543687f, 0.00671218f, -0.01499601f, 
    0.00575713f, -0.03170756f, -0.03738545f, -0.02716526f, -0.03156805f, -0.04549691f, -0.00791768f, -0.03850205f, 
    -0.02879892f, -0.01229507f, 0.00845653f, 0.02792329f, 0.00920907f, -0.03448690f, 0.00248431f, 0.01566862f, 
    -0.04293361f, -0.04514811f, -0.04800812f, -0.02928847f, 0.01430064f, 0.01991371f, -0.04595426f, 0.00556491f, 
    -0.03543076f, 0.00614627f, -0.01720199f, 0.02236290f, 0.00260521f, -0.03260242f, -0.02954329f, 0.02737355f, 
    -0.04353106f, 0.02117250f, 0.02752361f, -0.02758580f, 0.00862738f, -0.00886579f, -0.00652515f, 0.03042532f, 
    0.00834720f, -0.01991529f, -0.04684554f, -0.01191463f, 0.02394276f, -0.03046330f, -0.00313557f, -0.01724602f, 
    -0.00433925f, 0.02113671f, -0.02416254f, -0.01454617f, -0.04752107f, -0.00276913f, -0.00256118f, -0.02302348f, 
    -0.00786047f, -0.01306887f, -0.00346840f, -0.01229144f, -0.02099635f, -0.03552818f, 0.01043520f, -0.02137690f, 
    -0.04199848f, 0.00031777f, -0.02665956f, 0.00174873f, -0.00265536f, -0.00971881f, -0.00597995f, -0.00642203f, 
    0.01625926f, 0.02966349f, -0.03436405f, -0.03090220f, 0.02006626f, 0.02831086f, -0.03367913f, 0.02225258f, 
    0.02699420f, 0.02390947f, -0.01524735f, 0.00199556f, -0.03256673f, -0.02951205f, 0.01493988f, 0.00020824f, 
    -0.00131888f, 0.02262292f, -0.00476206f, -0.04377951f, 0.02971125f, -0.04664265f, -0.03201113f, -0.02716332f, 
    0.00073734f, 0.02052000f, -0.00420231f, -0.00660607f, 0.01927993f, 0.02655732f, -0.00126256f, 0.01292996f, 
    -0.01478108f, 0.02786302f, -0.02039372f, -0.01798822f, 0.00071278f, -0.04318766f, 0.01477594f, 0.00368489f, 
    0.00609784f, -0.02666706f, -0.03085616f, -0.00954944f, -0.00230232f, 0.00336425f, 0.02916863f, -0.00814730f, 
    0.00379434f, -0.04101887f, 0.02094456f, -0.02886853f, 0.00631104f, -0.02432624f, 0.02146159f, -0.01101829f, 
    -0.01885445f, 0.00406657f, 0.01925090f, -0.02899553f, 0.02377772f, 0.01372545f, -0.02626719f, -0.00940779f, 
    -0.03889363f, -0.01670942f, 0.02060013f, -0.01694312f, 0.00147156f, 0.00904870f, -0.01868360f, 0.02355668f, 
    -0.00956572f, 0.00994968f, 0.00049486f, -0.04268272f, -0.01264657f, -0.02700723f, 0.01519991f, -0.00045134f, 
    0.01397680f, -0.03276711f, -0.02948924f, -0.03482921f, 0.01799189f, -0.02736809f, 0.00681799f, -0.01969187f, 
    -0.03852720f, -0.01172395f, -0.02658960f, -0.01776905f, 0.00794178f, -0.01660196f, 0.03331865f, -0.03476971f, 
    0.02660601f, 0.02059207f, -0.00759264f, -0.03975650f, 0.01526167f, 0.02414562f, 0.02935750f, -0.03583639f, 
    -0.04242584f, -0.00878879f, -0.04485518f, 0.02901483f, -0.01107787f, -0.00660270f, -0.03972860f, 0.02401913f, 
    0.03322032f, -0.04250257f, -0.00453956f, -0.01113103f, 0.03314694f, -0.03648894f, 0.03366304f, -0.03226770f, 
    0.01088509f, -0.02015905f, 0.00024461f, 0.02239973f, 0.01507733f, -0.02475961f, -0.00978154f, 0.01409323f, 
    -0.03885517f, -0.03021093f, -0.01501370f, -0.00060684f, 0.03044510f, 0.00324211f, 0.02473715f, -0.01852477f, 
    -0.02225437f, -0.02923982f, 0.00454726f, -0.00784555f, -0.01679588f, 0.02171476f, -0.00028147f, 0.03077346f, 
    0.03374453f, 0.02599081f, -0.00087448f, -0.01786492f, 0.01059012f, -0.02909907f, 0.03526251f, -0.01120253f, 
    -0.02479294f, -0.03052655f, -0.00864320f, 0.01789881f, -0.00385835f, 0.02807170f, -0.02488702f, 0.01556599f, 
    -0.03357250f, -0.00013130f, 0.01625390f, -0.01107171f, -0.02182003f, 0.02224075f, -0.03439548f, 0.03056066f, 
    -0.01884483f, -0.04465340f, -0.00513034f, 0.01522883f, -0.03300150f, -0.01089806f, -0.00025791f, -0.04104041f, 
    -0.04010302f, 0.01533425f, -0.00540082f, 0.01752256f, 0.02207657f, 0.00596980f, -0.01591849f, 0.00612897f, 
    0.01649630f, -0.01787067f, -0.03997193f, 0.00544395f, 0.02014896f, -0.00344283f, -0.01601496f, 0.02408320f, 
    0.04189757f, -0.00452857f, -0.02226392f, -0.04340845f, -0.03529609f, -0.01848228f, 0.00098062f, -0.00552662f, 
    -0.01460706f, -0.01527207f, -0.01229247f, -0.03156307f, 0.00343773f, 0.01019351f, -0.01691445f, 0.03384037f, 
    -0.02921954f, -0.03948037f, 0.01402986f, -0.03766636f, 0.00907985f, -0.00563182f, -0.03529752f, 0.01997196f, 
    -0.00963951f, -0.02349176f, 0.01248947f, -0.03451813f, -0.00557742f, 0.02710052f, -0.00655431f, 0.00231044f, 
    -0.00555195f, 0.01678022f, -0.00887235f, -0.00773255f, 0.00097079f, 0.02268625f, 0.02458237f, -0.00741784f, 
    0.00265431f, 0.02467065f, -0.01433480f, 0.01261487f, -0.03783140f, -0.01752920f, -0.03449215f, -0.02348539f, 
    -0.01368618f, 0.02585594f, -0.01499527f, 0.02409102f, -0.01648380f, 0.02454032f, -0.04044675f, -0.00628849f, 
    0.02062399f, -0.01645835f, 0.03269159f, 0.02509596f, -0.03562107f, 0.01637190f, 0.00312358f, -0.00767968f, 
    0.00022558f, 0.00034686f, 0.03446686f, -0.03451029f, 0.00420087f, 0.01562852f, -0.02925302f, -0.01616231f, 
    0.01460209f, 0.01446832f, 0.00212904f, 0.01112198f, -0.01225482f, 0.01755278f, -0.03511108f, -0.00823579f, 
    0.02397530f, -0.00525699f, 0.02286225f, -0.02308563f, 0.03114429f, -0.00185533f, -0.04292238f, -0.03767493f, 
    -0.02771696f, -0.00661837f, 0.01395346f, -0.01258712f, 0.01524145f, -0.01069007f, 0.01385309f, -0.01226071f, 
    0.01749785f, 0.00476649f, -0.03517845f, 0.01183620f, -0.00750277f, 0.00807992f, -0.03810760f, -0.03713136f, 
    0.02530640f, 0.02215337f, -0.01507267f, -0.01767219f, -0.03080266f, 0.02670004f, -0.02814279f, 0.00164300f, 
    0.00654462f, 0.01375836f, 0.01670673f, 0.01261362f, -0.00227017f, -0.01212141f, -0.03080733f, -0.01610925f, 
    0.02567937f, 0.00496297f, 0.02812399f, -0.00921260f, -0.00521042f, 0.03273883f, -0.01684145f, 0.00498289f, 
    0.00081530f, 0.01984077f, -0.04653439f, -0.03266132f, 0.00984353f, 0.00657406f, -0.01106156f, -0.00162308f, 
    0.01911503f, -0.00744708f, 0.03823052f, -0.03173617f, -0.02062872f, 0.02528249f, -0.00575145f, -0.00152240f, 
    0.00802038f, 0.01385631f, 0.02367388f, 0.00143716f, -0.02195317f, -0.03946756f, 0.02210546f, 0.02210709f, 
    -0.01282134f, -0.04407706f, 0.00718988f, -0.01092106f, 0.00197147f, 0.01312679f, 0.00647957f, 0.00162638f, 
    -0.01741783f, -0.02202230f, 0.00176619f, -0.01451798f, 0.01286404f, 0.01175182f, 0.00040500f, -0.01886191f, 
    -0.00471316f, 0.01910512f, -0.00698774f, -0.04276384f, -0.04406501f, 0.00317813f, -0.00090609f, 0.00419971f, 
    -0.02193909f, 0.02117434f, 0.01440136f, -0.03951401f, 0.03518969f, -0.03003053f, -0.01932003f, -0.03770600f, 
    -0.02864339f, -0.02356608f, -0.03128740f, -0.03225073f, -0.01297930f, 0.03091370f, -0.00426262f, -0.03949631f, 
    -0.02056293f, 0.01066158f, -0.01216331f, -0.03842971f, -0.00188094f, -0.03312050f, -0.03542917f, 0.02775729f, 
    -0.02004630f, -0.02444934f, 0.01972169f, 0.02640489f, 0.00640280f, 0.02883619f, 0.03457911f, 0.01306916f, 
    -0.01318108f, -0.04219215f, 0.00627205f, 0.03093681f, 0.02267184f, -0.02754413f, -0.02486810f, -0.03385404f, 
    0.02370796f, -0.03258383f, 0.01409261f, 0.02531946f, 0.01444368f, -0.02676302f, 0.02363062f, -0.02056816f, 
    -0.02998456f, 0.01127850f, 0.00842117f, -0.01275112f, 0.01857958f, -0.01028631f, -0.03119655f, 0.00750558f, 
    0.02347030f, -0.03133560f, -0.00825515f, -0.02238565f, -0.01574568f, 0.02056681f, -0.00257053f, 0.02313933f, 
    -0.03780354f, -0.01886113f, 0.00415660f, -0.02768700f, -0.02260810f, -0.00832579f, 0.02856694f, -0.02467738f, 
    -0.00376467f, -0.02921050f, 0.03055076f, 0.00662291f, -0.04335961f, -0.00309791f, -0.04076207f, 0.00205354f, 
    -0.00903524f, -0.04403556f, -0.01968885f, 0.00369792f, -0.03507887f, 0.01797433f, -0.03762020f, -0.02530438f, 
    -0.00469460f, -0.03573822f, 0.03293707f, 0.03252418f, 0.02821230f, 0.03050806f, -0.01698140f, -0.00099730f, 
    -0.04286031f, 0.02472398f, -0.04160658f, -0.00557056f, 0.00117887f, -0.03172669f, 0.01683398f, -0.01721983f, 
    -0.03554827f, 0.00412496f, 0.03524374f, -0.03531672f, 0.00561077f, -0.02992362f, 0.02140054f, 0.02770234f, 
    -0.01745494f, -0.00063779f, -0.01780103f, -0.04276193f, -0.00190270f, -0.01296458f, 0.00180854f, -0.01251754f, 
    -0.01895746f, -0.00205368f, -0.00505126f, 0.00573010f, 0.00979414f, 0.01566163f, 0.00253805f, -0.03125111f, 
    0.01170528f, 0.03373181f, -0.00401655f, -0.04121189f, 0.01840726f, 0.00157286f, 0.00780246f, 0.01817589f, 
    -0.01920957f, -0.01442071f, 0.03141154f, 0.02050183f, 0.00966837f, 0.01090552f, 0.01472098f, -0.02682106f, 
    -0.01316588f, -0.00905173f, 0.00418617f, -0.02400676f, 0.00575706f, -0.00061847f, 0.01084493f, 0.01297507f, 
    0.02296676f, 0.01110662f, -0.01606596f, 0.00274464f, 0.02409257f, 0.03441521f, -0.02706479f, 0.02069444f, 
    0.00356498f, 0.00763896f, 0.02091661f, -0.01873942f, -0.00142255f, 0.00181366f, -0.01888954f, 0.00282985f, 
    0.01257205f, 0.03363942f, -0.03715255f, 0.03252701f, -0.02891567f, 0.01998179f, -0.00190639f, 0.01261948f, 
    -0.04138222f, -0.01175801f, 0.00324127f, -0.02036133f, 0.03966092f, 0.00159491f, -0.03131691f, -0.03715092f, 
    0.00341400f, -0.00090476f, 0.01967742f, -0.00113721f, 0.01049709f, -0.03317085f, -0.02761306f, -0.00006434f, 
    -0.00454651f, -0.04410196f, -0.00210814f, -0.01400049f, 0.03743228f, 0.01619407f, 0.02400963f, 0.02205200f, 
    -0.01697183f, -0.02717234f, -0.02169425f, -0.01720661f, -0.03783811f, 0.03369120f, -0.01323939f, 0.01703635f, 
    0.00647279f, 0.00099519f, -0.01834137f, 0.01369179f, 0.01060382f, -0.03692443f, -0.03375646f, 0.01150881f, 
    0.01031603f, 0.02129421f, -0.03332697f, -0.03644239f, -0.01411531f, -0.02216353f, -0.02503372f, 0.03059889f, 
    0.02086326f, 0.01470132f, -0.03328149f, -0.00707733f, 0.00139932f, -0.01929941f, -0.03945940f, 0.01542576f, 
    -0.01437449f, -0.03596438f, 0.02868694f, -0.01964153f, -0.03304179f, -0.01602841f, -0.03185688f, -0.03420492f, 
    -0.01505430f, 0.02496065f, -0.01958997f, -0.02330678f, -0.04093874f, -0.01385298f, -0.01786857f, -0.02539658f, 
    0.00843835f, 0.02761481f, -0.03807005f, -0.03510639f, -0.03035128f, 0.01527875f, 0.01567834f, -0.01211600f, 
    -0.00077322f, -0.02337554f, -0.01064996f, -0.04471128f, 0.00745602f, -0.03527473f, -0.02436212f, 0.00905863f, 
    -0.00562125f, 0.00365339f, -0.03099617f, 0.01774551f, -0.04420382f, -0.03923149f, -0.01301545f, 0.03242107f, 
    0.00199223f, -0.04448503f, -0.02066296f, -0.00315468f, 0.02687829f, -0.04149431f, 0.02916467f, 0.00430017f, 
    -0.00969996f, -0.01289123f, -0.00438219f, -0.02570805f, 0.00665389f, 0.00420400f, 0.01398468f, 0.00531711f, 
    0.02909917f, 0.00428912f, 0.01063449f, -0.01395587f, -0.02966571f, 0.00768016f, 0.03142712f, -0.04175615f, 
    -0.01918066f, 0.02460149f, 0.01636669f, -0.01765234f, -0.02290193f, -0.04240207f, -0.02544632f, 0.03689413f, 
    0.03500311f, 0.03243374f, -0.00873766f, 0.02839269f, -0.00695696f, -0.01235030f, -0.03828548f, -0.02010027f, 
    0.03434008f, -0.03681060f, -0.00300905f, 0.03680858f, 0.02249039f, -0.01767436f, -0.01784435f, 0.01318609f, 
    -0.01433771f, 0.02775879f, 0.03068868f, 0.02239763f, -0.03674010f, 0.02077437f, 0.02897262f, -0.02775492f, 
    0.02832113f, -0.00536994f, 0.00357466f, -0.00073002f, 0.01417207f, -0.01218208f, -0.01742799f, -0.01622970f, 
    0.00784977f, -0.01655257f, -0.02221083f, -0.04227494f, -0.03925974f, -0.03640024f, -0.02662114f, -0.03358516f, 
    0.01927202f, -0.02130007f, -0.01792697f, 0.02902736f, -0.01911280f, 0.00056893f, 0.00811637f, -0.01274241f, 
    -0.02806283f, 0.01930607f, 0.02548326f, -0.02446297f, -0.04278268f, -0.02889534f, -0.00799161f, -0.01168646f, 
    0.01378684f, -0.01027587f, 0.00977211f, -0.03836196f, 0.00729082f, -0.01375232f, 0.01235949f, 0.03067454f, 
    -0.03058200f, -0.03199453f, -0.00816517f, -0.02910061f, 0.02100675f, -0.02646925f, -0.01030938f, 0.00031510f, 
    0.00889422f, -0.00238600f, 0.02148265f, -0.02515400f, -0.02183799f, 0.01872598f, -0.00944515f, -0.03982786f, 
    0.00517608f, -0.02673264f, 0.02403530f, 0.00632202f, 0.01052964f, -0.00617583f, 0.02620772f, 0.00734914f, 
    -0.00908526f, -0.01474248f, -0.03875994f, -0.03903555f, -0.00646956f, -0.03888074f, -0.01104428f, 0.03200059f, 
    -0.04286742f, 0.03180021f, 0.02216652f, 0.02202860f, -0.02313213f, -0.01467840f, -0.01727646f, -0.02808972f, 
    0.02912070f, -0.04327146f, -0.00207024f, -0.04332099f, 0.03169543f, 0.00526537f, -0.00289115f, 0.01246579f, 
    0.01085043f, 0.00979026f, 0.02799808f, 0.02777248f, -0.00638853f, -0.04279728f, -0.01916577f, -0.00658976f, 
    -0.04466845f, 0.00341284f, -0.03891121f, -0.04056535f, -0.02024550f, 0.01040445f, -0.00701952f, 0.01825836f, 
    -0.01652876f, 0.02830846f, -0.00781123f, -0.03190640f, -0.00028888f, 0.02978110f, 0.01825913f, 0.02807649f, 
    0.02003125f, 0.00279626f, -0.03792378f, -0.01241212f, 0.03493490f, -0.02747786f, -0.04413484f, 0.02179274f, 
    -0.02609145f, 0.03287916f, -0.03896069f, 0.00877545f, 0.00118225f, -0.03767025f, -0.00315013f, -0.00985476f, 
    -0.01287905f, -0.00115816f, -0.04326451f, -0.04399611f, 0.02873283f, -0.04717694f, 0.02574421f, -0.00098291f, 
    -0.02101122f, -0.01741515f, 0.00308957f, 0.01239868f, -0.03620416f, -0.04547600f, 0.00892351f, -0.00589994f, 
    -0.00195330f, -0.03311317f, -0.01742171f, -0.03467695f, -0.03192213f, 0.01425512f, -0.01465520f, -0.00637661f, 
    0.01982349f, -0.02859558f, 0.02815689f, 0.01475116f, -0.02250911f, -0.01063687f, -0.02521723f, -0.03658612f, 
    0.00271882f, -0.01042269f, -0.01022714f, -0.01123811f, 0.02120827f, -0.03587433f, 0.02100688f, -0.01850737f, 
    -0.02011926f, -0.01349691f, 0.00794340f, -0.00757958f, 0.00226693f, -0.04422382f, -0.02148431f, -0.02289419f, 
    -0.01103684f, -0.03774125f, 0.00017079f, 0.00313886f, -0.03203615f, 0.03043670f, -0.03372227f, -0.02102380f, 
    0.02585967f, -0.02336558f, -0.00126029f, 0.03208085f, -0.03707747f, -0.00789198f, 0.01859890f, -0.01567734f, 
    -0.03257158f, -0.00283554f, -0.02869531f, -0.04045343f, 0.01915043f, 0.02767776f, -0.02661650f, 0.00971146f, 
    0.03262211f, 0.01325828f, 0.00351652f, -0.03312859f, -0.03644898f, -0.03652450f, 0.01945111f, -0.00695367f, 
    -0.03849420f, -0.00665611f, 0.03170747f, -0.02790610f, 0.00447009f, -0.03079327f, 0.01468389f, 0.00700135f, 
    -0.00183775f, -0.00371340f, 0.01007054f, 0.01339793f, 0.01805200f, 0.00604380f, -0.03773978f, -0.03702666f, 
    -0.04126795f, -0.03513668f, 0.02797086f, -0.03415398f, -0.00613792f, -0.02257647f, 0.00810674f, -0.03642755f, 
    -0.03097148f, 0.00810135f, -0.02946829f, -0.00130798f, -0.02127736f, -0.01597066f, -0.01890279f, 0.00422139f, 
    0.00429542f, -0.02406078f, -0.00151907f, -0.02328161f, 0.03080309f, 0.00511829f, -0.03483459f, 0.01190810f, 
    0.02274419f, -0.04126592f, -0.00689632f, 0.00304922f, -0.04313099f, -0.00230937f, -0.03410649f, 0.02767541f, 
    -0.02430023f, 0.00961599f, 0.02125788f, -0.00724906f, -0.00556869f, 0.02820227f, -0.01127738f, 0.01746040f, 
    0.01404656f, 0.00647565f, 0.00854274f, -0.02891837f, 0.00684796f, 0.00567206f, -0.03562535f, 0.01973468f, 
    0.01911536f, 0.01327003f, -0.02260273f, 0.00229755f, -0.04247900f, 0.00868995f, -0.03324789f, -0.01782412f, 
    0.02496583f, -0.04521266f, -0.01916491f, 0.00059873f, 0.01677574f, 0.01459251f, 0.02596146f, -0.04244145f, 
    -0.01387597f, 0.03019122f, -0.00990271f, 0.03135131f, 0.01347732f, -0.00451326f, -0.02586365f, 0.00661409f, 
    -0.04596644f, 0.00476635f, 0.01554235f, -0.02987908f, -0.03780666f, 0.01745418f, -0.01193608f, -0.01535532f, 
    0.01449379f, 0.00257588f, -0.01609903f, 0.02998738f, 0.01826355f, -0.01249423f, 0.02373366f, 0.02944902f, 
    0.00169799f, -0.04475080f, 0.02361494f, -0.02202383f, -0.04209499f, -0.04477435f, -0.02176421f, 0.00619817f, 
    -0.00488908f, -0.02580476f, 0.01550938f, -0.00805401f, 0.01678493f, -0.01064093f, -0.02195405f, -0.01155703f, 
    -0.00685992f, -0.02967894f, -0.03967321f, -0.00288961f, 0.01547578f, -0.01018574f, 0.00567472f, -0.02412498f, 
    0.01298584f, 0.01450691f, -0.01384590f, -0.00220601f, -0.03283588f, -0.03178892f, 0.03233230f, -0.01238947f, 
    0.00955698f, 0.02399055f, -0.02768239f, -0.00732944f, -0.02339635f, -0.00430404f, -0.01360680f, 0.00994312f, 
    -0.01005217f, -0.00883380f, -0.03449897f, 0.02605372f, 0.03162839f, 0.01639654f, -0.00304447f, -0.02798505f, 
    0.02757880f, -0.01138501f, 0.01405023f, 0.00946975f, 0.03237629f, -0.01700687f, -0.00149789f, -0.00340386f, 
    -0.02279267f, 0.01024161f, 0.03293784f, -0.04389820f, -0.01382376f, -0.01143424f, -0.02831728f, 0.01763688f, 
    -0.02654392f, -0.00418278f, -0.02025232f, -0.02256436f, -0.00651379f, 0.02003583f, 0.03052061f, -0.02536554f, 
    -0.00041976f, 0.03334721f, 0.02313291f, -0.01922336f, 0.00137370f, -0.03229124f, 0.00241188f, 0.01774300f, 
    -0.02523664f, 0.01080238f, -0.01211295f, -0.00546627f, -0.01476857f, -0.02230044f, 0.01903892f, -0.02258023f, 
    -0.04434532f, -0.03470667f, -0.03039804f, 0.02362797f, 0.02824249f, -0.01848087f, 0.02435779f, 0.00242231f, 
    -0.04264138f, -0.00838900f, -0.02745804f, -0.04022020f, -0.04272226f, 0.00867350f, 0.02913432f, 0.02621339f, 
    0.02317184f, -0.00987525f, 0.01727197f, -0.03768791f, -0.01783075f, -0.02436805f, 0.02431661f, 0.00612894f, 
    -0.00142813f, -0.01166653f, 0.00291660f, -0.02643213f, 0.04279682f, -0.03679343f, -0.00786920f, 0.02974250f, 
    -0.03295175f, -0.04233295f, -0.00677844f, -0.03738799f, 0.03074980f, -0.02923044f, -0.04298621f, -0.02772062f, 
    -0.01882776f, -0.03729522f, 0.01612643f, -0.00247887f, -0.04185951f, -0.04523252f, 0.01087207f, -0.01295224f, 
    -0.03533332f, -0.02964059f, -0.00453633f, -0.00990414f, 0.02363876f, -0.04471143f, -0.02800474f, 0.00446426f, 
    -0.02505181f, 0.02110541f, -0.03125405f, 0.02594758f, 0.02191667f, -0.03922842f, 0.00233094f, 0.00792583f, 
    -0.01820853f, -0.00035558f, -0.00573847f, -0.02249736f, -0.03525198f, -0.01814992f, -0.01537146f, -0.04460559f, 
    -0.03027983f, 0.00382763f, 0.00490426f, 0.02141332f, 0.03159224f, 0.00407813f, 0.02149551f, -0.01050477f, 
    0.01082067f, -0.00866749f, -0.00065022f, 0.02915346f, 0.01005616f, -0.02259767f, -0.04346024f, 0.00753063f, 
    -0.03887185f, -0.01042361f, 0.01022412f, 0.02058492f, -0.02564369f, 0.01362426f, 0.02827037f, 0.01449198f, 
    -0.02714148f, -0.03297628f, 0.02021798f, -0.01646038f, 0.00723746f, -0.02768847f, 0.01646218f, -0.01026995f, 
    -0.00085100f, 0.01402642f, -0.02962609f, -0.03823670f, 0.00451434f, -0.01614081f, -0.03145694f, -0.02165282f, 
    -0.04016719f, -0.01522721f, 0.03231898f, 0.00460063f, 0.01797537f, -0.02432165f, -0.00761433f, -0.03563610f, 
    0.01747696f, -0.00147909f, 0.00832951f, -0.03037987f, 0.00920595f, -0.01841263f, -0.02122857f, 0.00094613f, 
    0.00154591f, -0.00927329f, -0.01618463f, -0.01883432f, -0.04541801f, 0.03213821f, 0.02847005f, 0.02056928f, 
    -0.04584726f, 0.02880143f, 0.00313858f, 0.01230871f, -0.02070553f, 0.02319830f, 0.01226904f, 0.01353143f, 
    0.02710141f, -0.00316492f, -0.04276514f, -0.01079202f, 0.00250368f, -0.04496765f, -0.02518797f, -0.01977390f, 
    0.00225643f, 0.00419078f, 0.01692171f, -0.04184255f, -0.04550918f, -0.03044257f, -0.03156301f, 0.00622229f, 
    0.01586865f, 0.01249903f, -0.03734538f, -0.04172353f, -0.02270733f, 0.01101747f, -0.04301461f, 0.02334803f, 
    0.01520844f, -0.04029854f, 0.00911564f, -0.01994097f, 0.03160029f, 0.02231919f, -0.00520137f, 0.01858268f, 
    0.03195292f, -0.00340708f, 0.00679663f, -0.01154228f, 0.00952213f, -0.03442638f, -0.01948395f, -0.01493580f, 
    -0.02543196f, 0.01113470f, -0.03749974f, 0.00327601f, -0.03487181f, -0.01483124f, -0.01593119f, -0.02778094f, 
    -0.01851784f, -0.00127148f, 0.00875057f, 0.03168050f, -0.03510008f, 0.01052432f, 0.00853151f, -0.03973253f, 
    0.00851689f, 0.00649177f, 0.00436000f, 0.01396362f, -0.00898704f, -0.02859189f, -0.02435255f, -0.01556570f, 
    -0.03495188f, 0.02972840f, 0.00047972f, -0.01754273f, 0.00397307f, 0.00884984f, 0.00623000f, 0.02944249f, 
    -0.02313930f, -0.01473140f, -0.04579672f, -0.03132189f, 0.03122218f, -0.02144926f, 0.01876982f, 0.02613183f, 
    -0.03567063f, 0.03178314f, -0.04494945f, 0.00242892f, -0.02570146f, 0.02606800f, 0.03010017f, 0.02553585f, 
    -0.01627348f, -0.00514645f, -0.03672310f, 0.03278646f, -0.00644376f, -0.02742653f, 0.02411151f, 0.01711991f, 
    -0.03592182f, 0.01861401f, 0.01517685f, -0.00908050f, -0.03711817f, 0.01917885f, 0.02994737f, 0.00628874f, 
    -0.01864836f, -0.01062663f, 0.00003600f, -0.00949836f, -0.00655383f, -0.03591859f, -0.03608315f, 0.00716121f, 
    -0.03754977f, 0.02929637f, 0.02789254f, -0.01375342f, -0.03925292f, 0.02044293f, 0.02018533f, -0.01003979f, 
    0.01375537f, 0.03032049f, 0.00134631f, -0.01580044f, -0.00902090f, -0.01074419f, -0.03680947f, -0.04109551f, 
    -0.00299261f, 0.01420779f, 0.02958720f, 0.00292151f, -0.03423455f, 0.01715490f, -0.04225532f, -0.03864147f, 
    -0.02774342f, 0.02530119f, 0.01470457f, 0.00487752f, 0.02183754f, 0.02333663f, -0.01844274f, -0.00094814f, 
    -0.04358130f, -0.03987709f, 0.01056670f, -0.01932905f, -0.01865979f, 0.02087436f, -0.00912460f, 0.01463159f, 
    0.00109172f, -0.01937555f, -0.02655302f, 0.02782656f, -0.03617440f, 0.03326719f, -0.04306079f, -0.00124316f, 
    -0.04246705f, 0.01935015f, -0.03522695f, 0.01093896f, -0.01478575f, -0.03431492f, -0.00243337f, -0.00946951f, 
    -0.04317594f, -0.03420015f, -0.01827337f, -0.00169339f, -0.02931670f, -0.00080416f, -0.02257551f, 0.00939091f, 
    0.01035330f, -0.01524306f, -0.03207980f, -0.01621552f, -0.03134713f, -0.03324500f, 0.01491684f, 0.02407750f, 
    0.02811876f, -0.02681469f, -0.04009103f, 0.01073753f, -0.03127973f, 0.00335745f, -0.00976656f, 0.02648632f, 
    0.02062314f, -0.01639979f, 0.02079448f, 0.00183878f, 0.02770552f, -0.00598444f, 0.01718813f, -0.04129617f, 
    -0.01662012f, -0.04194242f, 0.01276243f, 0.01428184f, 0.03031947f, 0.01904301f, 0.03275107f, -0.04228887f, 
    -0.03371932f, -0.01459466f, 0.01376841f, -0.00620482f, -0.00133174f, -0.03173040f, -0.04283713f, -0.02740819f, 
    -0.03095616f, 0.02833610f, -0.03050265f, -0.01369441f, 0.02835399f, -0.02322192f, 0.02803561f, -0.01247278f, 
    0.00839823f, -0.02074170f, -0.03222210f, 0.00237624f, -0.03349784f, 0.01644678f, -0.01075860f, 0.02823995f, 
    -0.00487895f, 0.00278653f, -0.02999397f, -0.02177021f, -0.00448125f, -0.01934292f, -0.02119998f, 0.02915750f, 
    -0.02896329f, 0.01187794f, -0.03732224f, -0.02574850f, 0.01563305f, -0.00746382f, 0.02661019f, 0.02156416f, 
    0.00296898f, 0.03130684f, 0.02131831f, 0.03402361f, -0.01916994f, -0.04409624f, 0.03464251f, -0.02442258f, 
    0.01187373f, -0.01484061f, -0.02672228f, -0.03342070f, 0.00031126f, 0.01242701f, -0.01169114f, -0.02317440f, 
    0.03360081f, -0.01148091f, 0.02215122f, -0.03413338f, 0.00418501f, 0.00855318f, 0.00294442f, 0.00054655f, 
    0.02603271f, -0.02982732f, -0.01329408f, -0.01061404f, 0.01697392f, -0.00354350f, 0.02874247f, 0.00254761f, 
    -0.00983749f, -0.02149106f, -0.01621598f, 0.03380507f, 0.03119703f, 0.01721729f, -0.02712866f, -0.02527230f, 
    -0.01553860f, -0.03834066f, 0.01037043f, -0.01176264f, 0.02159242f, -0.04241426f, 0.00287758f, -0.02173034f, 
    -0.03374937f, -0.00332098f, -0.04086159f, -0.04483758f, -0.02269605f, 0.00184839f, -0.03549656f, 0.00265003f, 
    -0.04252532f, 0.02868604f, 0.03114901f, -0.03585871f, -0.00163472f, 0.00106054f, 0.01069037f, -0.01106331f, 
    -0.00539449f, -0.04496614f, -0.01979117f, 0.00911872f, -0.01246361f, 0.01881279f, -0.01277952f, 0.02984845f, 
    -0.03727137f, -0.02795867f, -0.01547822f, -0.01607456f, -0.03056750f, -0.01172570f, 0.03012936f, 0.01726335f, 
    -0.01582009f, 0.03112823f, 0.02516427f, 0.01747745f, 0.01542731f, -0.04044048f, -0.01188197f, 0.01719586f, 
    0.00130511f, 0.03228692f, 0.01152363f, -0.03732720f, 0.01369501f, -0.03232770f, -0.02047534f, -0.02874058f, 
    0.00831627f, -0.03381215f, -0.01593927f, 0.02916898f, 0.02950841f, -0.03327318f, -0.00296220f, -0.02067611f, 
    -0.00800851f, -0.03243931f, 0.03018994f, 0.03044007f, 0.01091326f, 0.03425501f, 0.02626325f, 0.01048174f, 
    -0.01677536f, 0.00451808f, -0.04362294f, 0.03341165f, -0.00502934f, -0.03543249f, -0.01847211f, 0.00603994f, 
    0.00526134f, 0.01028173f, 0.01079912f, 0.00780448f, 0.01970526f, -0.02945632f, 0.01912752f, 0.02636481f, 
    0.00318147f, 0.00279588f, -0.00352374f, 0.01467993f, 0.00464426f, 0.00062807f, 0.00945946f, -0.01438387f, 
    -0.00489997f, 0.03310225f, 0.02666953f, 0.02036806f, 0.01985752f, 0.00311377f, -0.03882875f, -0.00482144f, 
    0.00207367f, 0.02092469f, -0.01373309f, 0.01793414f, -0.00702632f, 0.00804674f, -0.02247323f, 0.01210473f, 
    0.01360379f, 0.02981709f, -0.01381350f, 0.00777162f, 0.02482884f, -0.01758963f, 0.00901924f, -0.02466421f, 
    -0.02097690f, 0.02926691f, -0.04332305f, -0.01411819f, -0.03695249f, -0.01729069f, -0.03473756f, -0.00634600f, 
    0.01394120f, -0.00980299f, 0.01739829f, 0.00016425f, -0.00023697f, -0.03543056f, -0.00420031f, 0.01920619f, 
    -0.00697272f, -0.00447709f, -0.02363954f, 0.01850836f, -0.03269760f, 0.02843688f, -0.02184657f, -0.00251698f, 
    -0.02155659f, 0.03351625f, 0.01115537f, 0.00447995f, -0.02582188f, 0.01648000f, -0.00149781f, 0.00616439f, 
    -0.02724691f, -0.01562256f, -0.01447941f, -0.03197220f, 0.00602443f, -0.00463356f, -0.02045977f, -0.02872671f, 
    -0.00924405f, -0.03687160f, 0.02985851f, -0.03719769f, 0.01847816f, 0.00887306f, 0.00644105f, -0.03498400f, 
    0.01576370f, 0.02363909f, -0.02582409f, 0.02112159f, -0.03527457f, 0.01264608f, 0.00037732f, 0.00648618f, 
    -0.02288070f, 0.02837409f, 0.02745016f, -0.00572274f, -0.02528132f, -0.00748969f, -0.00143523f, -0.02747970f, 
    -0.03456203f, -0.00903528f, 0.02206716f, -0.01821369f, 0.02838437f, 0.00688226f, -0.00785775f, -0.02121160f, 
    -0.01798065f, 0.03400616f, -0.02982985f, 0.02777077f, 0.00324444f, -0.01181455f, -0.00946533f, -0.01300433f, 
    0.00129656f, 0.00494953f, -0.01499955f, -0.04417111f, -0.00679506f, -0.03588225f, 0.02240290f, -0.00895302f, 
    -0.03183237f, 0.01301084f, 0.00598262f, -0.04434034f, 0.02811642f, 0.02869280f, -0.01208535f, 0.02418041f, 
    -0.04106246f, -0.01755091f, 0.03075370f, 0.02478206f, 0.02365454f, -0.02196591f, -0.00284917f, -0.00423738f, 
    -0.01576316f, -0.01153368f, 0.01877888f, -0.01538556f, -0.01960948f, -0.02714467f, -0.04398919f, 0.02239214f, 
    0.02579998f, 0.02351810f, -0.03708056f, 0.02523362f, 0.01080784f, -0.01381100f, -0.01124438f, 0.00843437f, 
    -0.02039255f, 0.00702741f, -0.00769343f, 0.01068119f, -0.03466365f, -0.01223330f, -0.01302037f, -0.03596041f, 
    0.00239328f, -0.03427666f, -0.00652314f, 0.00189860f, -0.02899414f, -0.03240487f, -0.01310306f, -0.01991806f, 
    -0.01167305f, 0.01800073f, -0.00367478f, -0.01828870f, 0.01806907f, -0.02868127f, 0.01407503f, 0.00734250f, 
    -0.01506049f, 0.01160159f, -0.00461737f, 0.02584595f, 0.00336268f, -0.02644495f, -0.03029319f, -0.04315802f, 
    0.01095490f, 0.02733750f, -0.01798299f, -0.00382466f, -0.03097408f, 0.01327969f, 0.01157108f, 0.02392658f, 
    0.03462132f, -0.02757279f, -0.04479786f, -0.03499599f, -0.01910068f, -0.01847582f, 0.00619446f, -0.00887991f, 
    -0.04504361f, 0.03008709f, -0.04148583f, 0.02063599f, -0.00516015f, 0.00459071f, -0.04093383f, 0.01568219f, 
    0.02042870f, -0.03427438f, -0.04354683f, 0.01305216f, 0.02449378f, 0.00660898f, 0.00128067f, 0.02202458f, 
    0.02243367f, 0.03300596f, -0.01292555f, -0.03976443f, 0.01305731f, 0.00098938f, 0.02720572f, 0.00035286f, 
    0.00892491f, -0.03966552f, -0.04107582f, 0.02569909f, 0.01336521f, 0.02184593f, 0.02102571f, -0.04396043f, 
    -0.01969047f, -0.02540523f, 0.02060547f, 0.02461364f, -0.02339973f, 0.02391839f, 0.00515662f, -0.00662735f, 
    0.02500310f, -0.02118237f, -0.01303837f, 0.03143138f, 0.02208533f, 0.03123315f, -0.04529650f, 0.01191165f, 
    -0.01669864f, -0.03959470f, -0.02604967f, 0.02191710f, -0.02028044f, 0.00600840f, 0.02854177f, 0.00143697f, 
    -0.02127511f, 0.00225464f, -0.02332191f, -0.02518781f, 0.01336654f, 0.01580075f, -0.00364082f, 0.02016191f, 
    -0.00762648f, -0.00457308f, -0.02361764f, -0.00495528f, 0.00639123f, -0.02566124f, -0.00201184f, -0.02947996f, 
    -0.02117045f, 0.02383159f, 0.01230691f, 0.01352837f, 0.00153602f, -0.03613291f, 0.00686910f, 0.02687512f, 
    -0.00339832f, 0.02243746f, 0.02929713f, -0.02830094f, -0.00529789f, 0.00113632f, -0.02052885f, -0.02249232f, 
    0.01992316f, 0.02040967f, 0.00578809f, 0.01394459f, -0.02330305f, 0.00734045f, -0.02493289f, -0.04255107f, 
    0.00287493f, -0.03220184f, -0.00859611f, -0.01864330f, 0.03423964f, 0.00714334f, -0.02420856f, 0.02989786f, 
    -0.04402434f, 0.02368699f, -0.02963321f, 0.01239030f, 0.03506678f, 0.01346323f, -0.03534453f, 0.00864824f, 
    -0.04250450f, 0.00897332f, -0.03717075f, -0.02678159f, -0.02129407f, -0.01536747f, 0.00362242f, -0.04249335f, 
    -0.04262809f, -0.02717348f, -0.02023928f, 0.01930903f, 0.00739136f, -0.00413270f, -0.00377427f, -0.00733434f, 
    -0.03892878f, -0.02491599f, -0.00103053f, 0.03432131f, 0.00886959f, 0.02318174f, -0.03691484f, 0.02066104f, 
    0.03183547f, 0.01922511f, 0.02720837f, -0.01424161f, -0.02315105f, -0.01139922f, -0.02605638f, -0.00499121f, 
    -0.01501237f, 0.00987213f, -0.03317741f, 0.02532998f, -0.03065576f, -0.03987947f, 0.03026143f, 0.01173681f, 
    -0.03725154f, -0.03927759f, 0.00969854f, -0.04077290f, -0.01006859f, -0.00026702f, 0.01412898f, -0.03881862f, 
    0.03088323f, -0.02167106f, -0.01327128f, -0.00295178f, -0.04150102f, 0.02132467f, -0.02526796f, -0.01526318f, 
    0.02449881f, 0.00571841f, -0.04156995f, -0.00587429f, -0.01798580f, 0.00108619f, 0.02695998f, 0.01713523f, 
    -0.02267308f, 0.00874255f, 0.01683391f, 0.02141155f, -0.02211901f, -0.00301513f, -0.00769287f, -0.03485871f, 
    0.01848747f, 0.00848261f, -0.00453127f, 0.02039580f, 0.01668494f, 0.00526624f, -0.01295284f, -0.03713883f, 
    -0.04246556f, -0.00172727f, 0.01196582f, -0.04470341f, 0.01396299f, 0.02737211f, -0.02566723f, 0.00642286f, 
    -0.02429813f, -0.03189280f, -0.01655744f, -0.02341757f, 0.01403386f, -0.00676968f, 0.01553923f, 0.01800102f, 
    -0.04327075f, 0.00563371f, -0.01834248f, 0.00302226f, -0.01635437f, -0.01150034f, -0.01628545f, -0.01713008f, 
    0.00495418f, 0.03069441f, 0.00523573f, 0.00360230f, -0.00986523f, 0.01375984f, -0.01035944f, -0.02345782f, 
    -0.03822411f, -0.02817117f, -0.01466813f, 0.02854767f, -0.02319499f, 0.01111308f, -0.01937716f, 0.02683538f, 
    -0.02042548f, 0.02450573f, 0.00401113f, -0.02122706f, 0.02445654f, 0.01762194f, 0.02563797f, -0.01602553f, 
    -0.01838504f, -0.01195057f, 0.01398581f, -0.03735993f, -0.04023136f, -0.01371583f, -0.01733467f, -0.02586295f, 
    0.00610762f, 0.00977360f, 0.01921152f, 0.01406129f, 0.00320278f, -0.03834289f, -0.00144985f, 0.01427966f, 
    0.00514938f, -0.01306974f, 0.02994197f, -0.02295989f, 0.01582130f, 0.01793678f, -0.01533215f, -0.01963860f, 
    -0.01858456f, 0.01402252f, 0.02186815f, -0.00239453f, 0.00762527f, 0.00217933f, 0.00565002f, 0.02157410f, 
    0.02459137f, 0.01290950f, 0.02980115f, -0.02813579f, -0.03736845f, -0.02734029f, 0.02721580f, -0.00753187f, 
    -0.04363376f, 0.03324920f, -0.00936887f, -0.02229958f, -0.01392450f, -0.03798480f, -0.00471906f, -0.02686932f, 
    -0.01819448f, -0.02168425f, -0.01776253f, 0.03064285f, 0.02769169f, 0.03111544f, -0.00885467f, 0.00300864f, 
    -0.00650214f, -0.00044397f, -0.03328047f, 0.02529234f, -0.01462489f, -0.04441467f, -0.04298209f, 0.00991598f, 
    0.01796232f, -0.00736142f, -0.01178243f, -0.02642318f, -0.00751395f, -0.04176553f, -0.03843249f, -0.03014996f, 
    -0.03254961f, -0.01761662f, -0.03301412f, 0.02913143f, -0.00918369f, -0.01215479f, 0.02378956f, 0.01071255f, 
    0.02180084f, -0.03437952f, -0.04072780f, 0.02999128f, -0.03871560f, -0.03578788f, 0.02886130f, 0.00486844f, 
    -0.02846349f, -0.01628052f, 0.00089002f, -0.03236113f, 0.00818755f, 0.02067169f, -0.03098705f, 0.00421524f, 
    0.02689296f, 0.02242560f, -0.03167025f, 0.02410020f, -0.00359970f, 0.00615160f, -0.04282568f, 0.01205986f, 
    0.00627409f, 0.00368769f, -0.03715359f, 0.00363012f, -0.01839495f, 0.01636698f, 0.02381190f, -0.03242149f, 
    -0.03516046f, -0.01931286f, 0.00063919f, 0.02764623f, -0.03741329f, 0.03136415f, -0.01334237f, -0.00348915f, 
    -0.01836127f, -0.01049070f, -0.00636961f, -0.03198785f, -0.04355095f, 0.01477871f, -0.02263366f, -0.03473755f, 
    -0.00230652f, -0.00677579f, -0.04456593f, -0.04527637f, -0.01661675f, -0.01034542f, 0.02231356f, -0.04394974f, 
    -0.03225578f, -0.02639077f, 0.02914220f, -0.00855090f, 0.01429233f, 0.00516794f, -0.00142127f, 0.02255910f, 
    0.01597853f, -0.01709331f, -0.02239367f, 0.01174062f, 0.01712870f, 0.02632666f, 0.00452951f, -0.03391953f, 
    0.00638500f, 0.01638373f, -0.02308446f, 0.00278098f, -0.01238419f, -0.00926600f, 0.01995879f, -0.04191416f, 
    0.02611438f, -0.03753366f, -0.03233436f, 0.01351193f, 0.03325316f, -0.01185963f, 0.00822725f, -0.01887215f, 
    -0.03557643f, -0.04404639f, -0.02203123f, 0.00794238f, 0.02276517f, -0.03916377f, -0.01174297f, -0.01300908f, 
    -0.00289452f, -0.02029354f, 0.01308412f, -0.01737364f, 0.01894326f, 0.01788265f, 0.01312385f, 0.00512950f, 
    0.00670445f, 0.00419188f, -0.01130194f, -0.02384302f, 0.00051648f, 0.00835939f, -0.03828807f, -0.04452163f, 
    -0.03585745f, -0.00515617f, -0.00241220f, -0.03142478f, -0.02635746f, -0.01411958f, 0.00736848f, 0.01923500f, 
    -0.00792238f, 0.02611016f, -0.04029154f, 0.02877316f, -0.02293748f, -0.03218874f, 0.01419516f, -0.01172925f, 
    -0.04150315f, 0.02084453f, -0.04526226f, 0.00674607f, 0.01088887f, -0.03447793f, 0.01315655f, -0.00022857f, 
    0.03006862f, 0.02323099f, 0.03298624f, 0.03127948f, -0.01807231f, 0.00332321f, 0.02066054f, 0.00712394f, 
    -0.04079336f, 0.01282143f, -0.02073821f, -0.04547350f, -0.01838413f, -0.01842017f, -0.04288276f, -0.00687114f, 
    -0.02538867f, -0.00691510f, -0.02405468f, -0.02433259f, -0.02420166f, 0.01674159f, 0.02680189f, 0.01967400f, 
    0.01659393f, -0.01618274f, 0.02700144f, -0.02625876f, 0.00442777f, -0.02827013f, -0.03953816f, 0.00000181f, 
    -0.03567272f, -0.02251664f, -0.02731456f, -0.01760067f, -0.04002475f, 0.02591601f, 0.00852408f, -0.03840008f, 
    0.01741076f, 0.02830289f, 0.02468798f, -0.00282599f, -0.03151671f, 0.00601430f, -0.03572104f, -0.01724584f, 
    -0.03802833f, 0.02646369f, 0.00992716f, 0.00748639f, -0.01083533f, -0.02575510f, -0.01199400f, -0.03067702f, 
    0.02135384f, -0.00349309f, 0.02203812f, 0.02864925f, -0.00082482f, -0.03169237f, -0.04463530f, -0.00579530f, 
    0.02645454f, -0.03193558f, -0.00156225f, 0.01367345f, -0.02142536f, -0.00505539f, -0.03028325f, -0.04420035f, 
    -0.03253362f, -0.03365555f, -0.01033980f, 0.01860059f, 0.01912747f, 0.02736543f, 0.01935467f, -0.01853649f, 
    -0.04005804f, 0.01895635f, 0.02444016f, -0.03082089f, -0.00383376f, 0.00410459f, 0.02584257f, -0.01333862f, 
    -0.02361860f, -0.03190936f, -0.02012988f, -0.02934485f, 0.02055557f, 0.03251878f, -0.02172649f, -0.02710374f, 
    0.02116021f, -0.00629013f, -0.01916079f, 0.00966733f, -0.00989743f, -0.00429199f, -0.00128264f, 0.00715007f, 
    -0.00972338f, -0.03492089f, -0.02476103f, 0.01940758f, 0.01834710f, 0.00677721f, -0.02722228f, -0.03793253f, 
    0.00748661f, 0.03067899f, -0.03666101f, -0.02360491f, 0.01021959f, -0.00195208f, -0.02391586f, -0.04175329f, 
    -0.03407305f, -0.00207628f, -0.01441304f, -0.02392136f, 0.02939989f, 0.01407888f, -0.00646390f, -0.03831387f, 
    -0.02262687f, -0.01171487f, 0.02536438f, 0.04241308f, -0.04520120f, 0.00033829f, -0.03034921f, -0.00331523f, 
    0.03243420f, -0.01822059f, -0.02197451f, 0.03044903f, -0.02076929f, 0.00303133f, 0.02020399f, -0.01872735f, 
    -0.03004847f, 0.01765123f, 0.03336199f, 0.00502086f, 0.02171710f, -0.01770720f, 0.02635457f, -0.01420141f, 
    -0.00513543f, 0.02615799f, -0.03843170f, -0.03168966f, 0.01222684f, 0.01058917f, -0.04408078f, 0.00821032f, 
    0.01344254f, 0.00847737f, 0.01637961f, 0.03185384f, -0.02710269f, -0.02811514f, -0.03905488f, -0.00296509f, 
    -0.03408654f, 0.02597514f, -0.00374393f, -0.02718697f, -0.02751008f, -0.03957650f, 0.00361635f, -0.02501405f, 
    -0.03062788f, -0.02207623f, 0.02191838f, -0.04183510f, -0.02039993f, -0.02727249f, 0.03320261f, -0.00951084f, 
    -0.02838910f, 0.01595551f, -0.02314567f, 0.01619502f, 0.01868491f, 0.01171836f, -0.01068102f, -0.02377693f, 
    0.00171400f, 0.02608199f, -0.03062250f, 0.00036478f, -0.01896403f, 0.00745757f, 0.02314138f, -0.01313473f, 
    -0.01937721f, -0.04346745f, -0.04076364f, 0.00933314f, 0.01498279f, 0.02595592f, 0.00643341f, -0.01307467f, 
    -0.00631092f, -0.02606763f, -0.01629329f, -0.00673844f, 0.01979071f, 0.02148692f, -0.00420153f, 0.01991857f, 
    -0.00629901f, -0.02786143f, -0.01574732f, 0.00035141f, 0.02961637f, 0.03298898f, -0.00691526f, 0.01528720f, 
    -0.02902799f, 0.00176912f, -0.02769363f, -0.02522131f, -0.01373816f, 0.01141728f, 0.00635001f, -0.01647343f, 
    -0.00828883f, 0.01760823f, 0.01344649f, 0.00914582f, -0.02704887f, 0.01615660f, 0.02077605f, -0.00697625f, 
    0.01657788f, 0.00439451f, -0.00419609f, -0.02663873f, -0.01668276f, -0.04422868f, 0.00324006f, 0.00895244f, 
    0.02317774f, 0.02242148f, -0.04446229f, -0.02626175f, 0.01242419f, 0.00487488f, -0.00547292f, -0.02522356f, 
    -0.02244818f, -0.03869908f, 0.03303876f, -0.02497789f, -0.02951647f, -0.03903208f, -0.00232859f, 0.01642873f, 
    0.01115781f, -0.01695037f, -0.03925684f, -0.03670748f, -0.01925497f, -0.00965553f, -0.03593118f, -0.02663025f, 
    -0.00329646f, -0.03891893f, 0.01535689f, -0.02957818f, 0.00061561f, -0.01101598f, -0.00897950f, 0.02780597f, 
    0.00257952f, 0.00588224f, -0.03914775f, 0.01340929f, -0.03329887f, -0.03931348f, -0.01134427f, -0.01964034f, 
    0.03120545f, 0.00139780f, -0.02684849f, 0.00839074f, 0.00933327f, -0.01611923f, -0.00889913f, 0.00764469f, 
    -0.00947226f, 0.01842009f, 0.00264592f, 0.02079652f, -0.01469538f, 0.01990028f, -0.03484690f, -0.00360225f, 
    -0.01420644f, 0.01345974f, -0.03828039f, -0.00913567f, -0.02809282f, 0.01911919f, 0.01202353f, -0.00072744f, 
    -0.00280622f, 0.01425413f, 0.01402845f, -0.04413726f, 0.03294269f, -0.02226867f, 0.00953267f, -0.02669520f, 
    0.00911325f, -0.03660146f, -0.03193083f, 0.01790932f, 0.02061034f, 0.00278917f, 0.03139433f, 0.03265566f, 
    -0.01116433f, 0.01833469f, -0.03880554f, -0.01370613f, -0.03803666f, 0.01813006f, -0.01763334f, 0.01163542f, 
    0.02962263f, -0.03756778f, 0.01838356f, 0.01682370f, 0.03413060f, -0.01356787f, -0.03284843f, 0.00315221f, 
    -0.00275908f, -0.04352663f, 0.02461351f, 0.00529678f, 0.02145072f, -0.04131313f, -0.02576515f, -0.03638109f, 
    0.03413002f, -0.02938370f, -0.04321796f, -0.04144156f, -0.02382719f, 0.01675398f, -0.00441603f, -0.00522621f, 
    0.01085306f, 0.01279565f, 0.01531366f, -0.02624124f, -0.01658013f, -0.02195943f, -0.00271439f, -0.03321022f, 
    -0.00660803f, -0.03035738f, 0.01139892f, -0.02612331f, 0.03337052f, 0.00205271f, 0.01402814f, -0.01645009f, 
    0.01466857f, 0.03069171f, 0.01809535f, -0.02076915f, 0.00081863f, 0.01144339f, 0.02644646f, -0.03781196f, 
    -0.03996343f, 0.03584166f, -0.02909269f, 0.02131960f, -0.02989573f, 0.02605567f, 0.02577169f, -0.04300798f, 
    0.02866639f, -0.02062191f, -0.01294092f, 0.00628829f, 0.01949746f, -0.02322706f, -0.02342023f, -0.04366294f, 
    -0.03126294f, 0.02860111f, -0.02799798f, 0.02428831f, 0.02521943f, 0.01987410f, 0.02165502f, 0.01463853f, 
    0.00946982f, -0.03339708f, -0.03787496f, -0.02700345f, -0.00151851f, -0.00296846f, 0.01036473f, -0.04350895f, 
    -0.03735830f, -0.01150750f, -0.00229971f, -0.01497647f, -0.00654621f, 0.02536633f, 0.00851397f, -0.02991425f, 
    -0.02804195f, 0.02085727f, -0.01490745f, -0.00583006f, 0.01272781f, -0.01940658f, 0.00017672f, -0.03425906f, 
    0.00055498f, 0.00662205f, -0.02737859f, -0.03450609f, 0.01278890f, 0.03878490f, 0.03228960f, -0.02930215f, 
    0.01701944f, 0.00633067f, -0.02965338f, 0.03893059f, 0.01373818f, -0.02704418f, 0.00802168f, 0.02335298f, 
    0.01814357f, 0.03112643f, 0.03060743f, -0.01800879f, 0.03285573f, 0.01217252f, -0.01381929f, 0.01319433f, 
    -0.02211695f, -0.01613661f, 0.02850761f, -0.01022733f, 0.00416380f, 0.03318874f, -0.00361444f, 0.02567201f, 
    -0.01130746f, -0.03882192f, -0.03847699f, -0.04378625f, -0.00503322f, 0.02961179f, -0.02745267f, 0.04056112f, 
    0.00264135f, 0.01558693f, 0.00956560f, 0.02005420f, -0.01861162f, -0.02828101f, 0.00471063f, -0.01738773f, 
    0.03421890f, -0.03017510f, 0.02697471f, 0.01792685f, -0.01585367f, -0.03944664f, 0.03665447f, -0.04144835f, 
    -0.02943050f, 0.01295680f, -0.01286673f, -0.00934643f, 0.01524309f, -0.03336003f, -0.04489177f, -0.00487520f, 
    0.00725652f, -0.04104538f, 0.03143828f, -0.00022651f, -0.04283395f, -0.00496525f, -0.01998478f, 0.00736318f, 
    -0.02511567f, 0.01520184f, -0.00828459f, 0.02541417f, 0.02981662f, 0.02138558f, -0.00500489f, -0.00446126f, 
    -0.00644643f, 0.00260678f, -0.01776106f, -0.00326180f, -0.02834467f, -0.03039305f, -0.01903110f, 0.01974014f, 
    -0.02883959f, 0.02440701f, -0.04491848f, 0.00691459f, -0.02126293f, 0.01887011f, 0.00674949f, 0.02976345f, 
    -0.00541119f, 0.00822054f, -0.03382020f, -0.00007535f, 0.02792251f, -0.00930182f, -0.04358513f, 0.02210530f, 
    -0.02319749f, -0.02372986f, 0.00042491f, -0.03197197f, -0.00201105f, -0.02495052f, -0.00051472f, 0.01485213f, 
    0.03556674f, 0.02027074f, -0.00054561f, -0.01073955f, -0.04039678f, -0.02997056f, -0.02488634f, 0.00941147f, 
    -0.03640245f, -0.02377656f, 0.00288914f, -0.03377496f, 0.00018227f, -0.00652391f, -0.00701269f, -0.03678359f, 
    -0.00578696f, -0.01141948f, -0.03975413f, 0.02645549f, 0.01298524f, -0.01788625f, 0.00629902f, -0.02063775f, 
    0.00295622f, 0.02454965f, -0.00350498f, -0.03705679f, 0.00331172f, -0.00296465f, 0.02366009f, 0.01874979f, 
    0.02411841f, 0.03289094f, -0.01081580f, 0.01108935f, 0.03721626f, 0.01322373f, 0.00367907f, -0.00131036f, 
    -0.02818081f, 0.02340429f, -0.02178309f, 0.00754140f, 0.00172460f, 0.02419391f, 0.01896301f, 0.01383804f, 
    -0.03446842f, -0.03143102f, -0.02106045f, 0.02271630f, -0.02510374f, -0.00871164f, 0.02227090f, 0.01669890f, 
    -0.04315056f, 0.01430454f, -0.02162086f, 0.03071832f, 0.02689615f, -0.03932568f, 0.03160186f, -0.00293525f, 
    -0.04221159f, -0.01850668f, 0.01284164f, 0.03047924f, 0.01014434f, 0.03330377f, -0.04387227f, -0.00676842f, 
    0.00041989f, 0.01142605f, 0.02860957f, 0.03161490f, -0.00519027f, 0.01375543f, 0.03005209f, 0.03467278f, 
    -0.03739837f, -0.04338273f, 0.00459472f, 0.00151495f, 0.00602363f, -0.03750929f, 0.03422885f, 0.03210936f, 
    -0.02780476f, -0.02263716f, 0.01416457f, -0.00153321f, -0.01599550f, 0.01755247f, -0.03435744f, -0.02901257f, 
    -0.02343621f, -0.02305486f, 0.00819442f, 0.01442254f, -0.00792526f, -0.04200872f, 0.00602745f, -0.04068996f, 
    0.01710019f, -0.01170279f, -0.03763638f, 0.00228639f, -0.01943579f, -0.03654764f, 0.02529795f, -0.03497654f, 
    -0.03897596f, -0.02131764f, -0.01995111f, 0.02002804f, -0.00974537f, 0.02066824f, 0.00012556f, 0.01263911f, 
    0.01040084f, -0.03342956f, -0.01809249f, -0.01235410f, 0.02678295f, -0.01822915f, -0.00521412f, -0.03751462f, 
    0.01930631f, 0.01381491f, -0.01856968f, 0.02269081f, 0.03924903f, 0.03349607f, 0.03936128f, 0.01645019f, 
    0.00391477f, 0.01022204f, -0.02108986f, -0.01789691f, 0.01922741f, -0.02760723f, 0.01045569f, -0.02235557f, 
    -0.04362238f, -0.02948288f, 0.01194675f, -0.04404930f, 0.00012382f, -0.00055795f, 0.01347351f, -0.02274527f, 
    0.03195106f, 0.00637690f, 0.01444228f, -0.00124119f, 0.00387684f, 0.00264024f, -0.02334957f, 0.02667200f, 
    -0.00717539f, 0.03213688f, -0.02827486f, -0.01957456f, -0.00511857f, -0.02897923f, 0.03185141f, -0.03784409f, 
    -0.01765587f, 0.02069240f, -0.01190583f, -0.03260148f, -0.02837153f, -0.03662590f, -0.02817170f, -0.00085509f, 
    -0.01989387f, 0.00208709f, -0.03303542f, 0.02894791f, 0.00549524f, -0.00086443f, 0.00762640f, -0.00182808f, 
    -0.01868821f, -0.04199817f, 0.00681275f, -0.01136112f, -0.00219158f, -0.01568401f, -0.00457380f, 0.00688674f, 
    0.00784031f, -0.02088166f, 0.03778280f, -0.00121988f, -0.01927415f, -0.02628209f, 0.00578027f, 0.02320372f, 
    -0.01783749f, -0.04472166f, -0.00756530f, -0.03551447f, -0.00962861f, -0.01246045f, -0.00080106f, 0.00753680f, 
    0.00224886f, -0.01091931f, -0.00514979f, -0.03813247f, -0.01926586f, 0.02216534f, -0.00163896f, -0.00282559f, 
    0.00798001f, -0.00156664f, 0.00602053f, -0.03955058f, 0.01876196f, -0.00935569f, 0.01603362f, -0.00093989f, 
    0.01648129f, 0.01101581f, -0.00419619f, 0.04316713f, -0.01736633f, 0.02725322f, -0.00461217f, 0.02669754f, 
    0.04110570f, -0.02951776f, -0.00991050f, -0.00805154f, -0.03478314f, -0.00156027f, -0.02702365f, -0.04274061f, 
    -0.01488751f, 0.01896659f, -0.00625813f, -0.00688915f, 0.03248790f, -0.04424319f, 0.02611449f, 0.02967703f, 
    -0.01623371f, -0.00788970f, -0.03897804f, 0.01055504f, 0.01781956f, 0.00236421f, 0.01043434f, -0.03228701f, 
    -0.02812093f, 0.02506776f, -0.01312380f, 0.01113704f, -0.03988621f, -0.04090665f, 0.02086528f, -0.02868359f, 
    0.02016845f, -0.03829198f, -0.02520056f, 0.00738843f, 0.00558576f, -0.00265168f, -0.01736418f, -0.00091446f, 
    -0.03570467f, 0.02538659f, 0.02119664f, -0.01870320f, 0.02674923f, -0.01420704f, -0.02627025f, 0.01098911f, 
    -0.03322516f, 0.00157153f, -0.02705330f, -0.03837952f, 0.01751856f, 0.01772245f, 0.03220730f, 0.03129050f, 
    -0.02936293f, -0.01753055f, 0.01491171f, -0.02741274f, 0.00005297f, -0.02829553f, 0.02247261f, 0.03156384f, 
    0.02778499f, -0.02291015f, 0.01374616f, 0.01145391f, 0.01503240f, -0.02142582f, -0.00488827f, -0.04315164f, 
    -0.00935872f, 0.00323261f, -0.03733984f, -0.00468431f, 0.01111384f, -0.01700142f, -0.01794257f, 0.02142803f, 
    -0.02624463f, 0.02951933f, -0.03447538f, 0.00802535f, 0.03660585f, -0.03876602f, -0.01668477f, -0.00008968f, 
    0.02484990f, -0.04246651f, -0.02629694f, -0.00009635f, -0.01699161f, -0.01443580f, 0.02695516f, -0.00838502f, 
    0.01737492f, -0.00062612f, -0.02107810f, -0.01520800f, -0.03418098f, 0.00280635f, -0.04054360f, 0.03463408f, 
    0.00035498f, -0.01947396f, 0.01923150f, 0.02942874f, 0.00324163f, -0.00610480f, -0.02024353f, 0.01698143f, 
    0.01635745f, 0.01478881f, 0.03093911f, -0.01427247f, -0.00213308f, 0.03328389f, -0.00818851f, 0.00774129f, 
    0.01704606f, 0.01369341f, -0.00978588f, -0.00738966f, -0.01602058f, -0.00573176f, 0.01514901f, 0.01643380f, 
    -0.02728724f, -0.02154622f, -0.01736991f, 0.01710651f, -0.02857573f, -0.03660469f, -0.03701066f, -0.01506192f, 
    -0.03009132f, 0.02240133f, -0.01170835f, -0.03314091f, 0.01912128f, -0.01463940f, -0.01679102f, 0.02816778f, 
    -0.03517937f, 0.00714583f, -0.01689278f, 0.01714690f, -0.01999433f, 0.00816176f, -0.02304426f, 0.01627306f, 
    0.00750141f, -0.02049004f, 0.02036729f, -0.01017158f, 0.00987335f, 0.02773078f, -0.01639762f, 0.00381265f, 
    -0.00979916f, -0.00052422f, 0.01307564f, 0.00378807f, -0.00866268f, -0.03275796f, 0.01166051f, 0.02356435f, 
    -0.03942151f, 0.02732562f, -0.00617300f, -0.01499003f, 0.01903970f, -0.00951008f, 0.01595607f, -0.02182845f, 
    -0.00996148f, 0.01729394f, 0.00353415f, -0.03251738f, 0.01192745f, -0.02938212f, -0.02920442f, -0.01650401f, 
    0.00018101f, -0.02818276f, -0.00184984f, 0.02351168f, -0.00984693f, 0.01761401f, -0.02799678f, 0.02185711f, 
    -0.04451187f, -0.04328202f, -0.01802210f, -0.04415702f, 0.02115859f, -0.01892965f, 0.00451514f, -0.01080299f, 
    -0.03792234f, 0.12546095f, 0.04115875f, 0.25404796f, 0.28818092f, -0.01999749f, -0.16918516f, -0.04036531f, 
    -0.01495030f, 0.05274915f, -0.02946497f, -0.04505773f, 0.10922274f, -0.07730462f, 0.07453352f, -0.10655933f, 
    0.18436578f, -0.03707150f, -0.02775010f, -0.07520662f, -0.40244922f, 0.19322105f, 0.01785267f, -0.02824178f, 
    -0.27058604f, -0.14247236f, 0.00482871f, -0.06932906f, 0.01647160f, 0.05999541f, 0.05936419f, 0.07557085f, 
    -0.06578749f, -0.03375014f, 0.07703891f, -0.05519052f, -0.08716724f, -0.03619923f, -0.05364667f, 0.00748605f, 
    0.03124673f, 0.08860157f, -0.20254990f, -0.07116942f, 0.33664209f, 0.05340914f, 0.05269121f, -0.00674791f, 
    -0.06152060f, -0.00228454f, -0.00686207f, 0.06492102f, -0.10538311f, -0.13708669f, 0.10071038f, -0.01004983f, 
    0.05994479f, 0.05498792f, 0.06232293f, 0.00991558f, 0.08724135f, 0.40972447f, 0.09149087f, 0.00518375f, 
    -0.09138194f, 0.04078031f, -0.15101260f, 0.05944716f, -0.13520031f, -0.04922122f, 0.06005174f, 0.03046174f, 
    -0.07644168f, -0.01029008f, 0.03386352f, -0.02088323f, 0.04856717f, -0.01646551f, 0.05913880f, -0.02015494f, 
    0.27788657f, -0.25743994f, -0.24539876f, 0.07277390f, 0.31946230f, -0.00415621f, 0.11651223f, -0.09976125f, 
    -0.06746517f, -0.02929219f, -0.06191864f, 0.04220317f, 0.00384480f, -0.16481338f, 0.06558848f, -0.11392438f, 
    -0.00084091f, 0.14365758f, -0.10197545f, 0.07514426f, 0.08839668f, -0.02637025f, 0.06553156f, -0.22825092f, 
    -0.02617609f, -0.04173704f, -0.13077295f, -0.03752696f, 0.02774603f, -0.08645846f, 0.01642000f, -0.06949408f, 
    0.03052845f, -0.16632994f, -0.00763029f, 0.01245037f, -0.05537594f, 0.13478388f, 0.10179719f, 0.02515432f, 
    0.08586057f, -0.00730572f, 0.12789114f, 0.24038522f, 0.17022653f, 0.06050428f, -0.16231368f, -0.08292077f, 
    -0.01586471f, 0.05533635f, 0.10087057f, 0.00135640f, -0.18475303f, -0.02566799f, 0.01409939f, 0.12850870f, 
    0.02435340f, 0.20152751f, 0.06093414f, -0.00965147f, 0.09862851f, 0.01554390f, 0.01147727f, -0.05468319f, 
    -0.16568559f, 0.08640363f, 0.18814589f, -0.08422966f, -0.01370203f, 0.05177584f, -0.13952234f, 0.17670302f, 
    -0.08824579f, 0.07461962f, 0.01795061f, 0.05472038f, 0.01685935f, 0.11263842f, -0.02824694f, -0.11004412f, 
    0.15942192f, 0.08643574f, 0.18880530f, 0.24328224f, -0.06252652f, 0.10354047f, 0.02605609f, -0.00120445f, 
    0.06092017f, -0.04704483f, 0.01265715f, -0.00201622f, 0.05736404f, 0.00336058f, 0.02259507f, 0.02094501f, 
    0.01541448f, -0.02462494f, 0.06558882f, 0.05293970f, 0.10498568f, -0.04455948f, -0.33391863f, -0.00782280f, 
    0.60814047f, 0.04186223f, -0.06963963f, -0.02155631f, 0.05334199f, 0.01902264f, 0.05248613f, 0.09843574f, 
    -0.10205554f, -0.04029940f, 0.15176532f, 0.07769385f, 0.07128266f, 0.02257173f, 0.07249328f, -0.00332218f, 
    0.58086246f, 0.34511447f, 0.07294345f, 0.23257181f, -0.16291775f, 0.15171918f, 0.03417656f, 0.02563692f, 
    0.06880786f, -0.06742596f, 0.06368116f, 0.15315655f, -0.04327634f, 0.04789666f, 0.00979161f, -0.05422700f, 
    0.01265728f, 0.00598664f, 0.10227819f, 0.02044564f, -0.09567480f, 0.01035115f, -0.21095857f, 0.07893571f, 
    0.12370377f, -0.05006526f, -0.06202486f, 0.03265638f, -0.00612713f, -0.04694457f, -0.01332492f, 0.06154765f, 
    -0.03224510f, -0.02354096f, 0.08457062f, -0.00084050f, 0.13070919f, 0.00921738f, -0.05792474f, 0.00990568f, 
    0.27695403f, -0.04281079f, -0.05818205f, 0.20774430f, 0.06993832f, -0.05996114f, 0.00212980f, -0.15531814f, 
    -0.07654741f, 0.03418434f, -0.09196569f, -0.00917861f, -0.10867533f, -0.06812490f, 0.05929363f, -0.02311419f, 
    -0.05247883f, 0.09582469f, 0.05857232f, -0.11105655f, 0.18152113f, -0.24081425f, -0.34406456f, -0.03582507f, 
    0.04288175f, -0.03402675f, -0.11501507f, 0.07063335f, 0.01963315f, 0.05116396f, -0.01339628f, 0.09625348f, 
    -0.03081612f, 0.17825718f, -0.02055683f, 0.02521217f, 0.06609370f, 0.02115040f, -0.06009675f, 0.02809490f, 
    0.38401088f, 0.12557948f, -0.02665483f, 0.01397159f, -0.15233997f, -0.06736012f, -0.12205307f, 0.13279979f, 
    0.00139021f, -0.13984849f, -0.03063229f, 0.03246462f, -0.03701891f, 0.08487208f, 0.01170919f, -0.09755434f, 
    0.07864253f, 0.15937273f, -0.02312541f, 0.06675908f, 0.50499296f, 0.06864922f, -0.07890487f, 0.09606427f, 
    -0.00334848f, 0.01082225f, -0.02785971f, 0.17972754f, 0.11816421f, -0.01851298f, -0.06582805f, -0.07782747f, 
    0.01507795f, 0.12686428f, -0.07740876f, 0.07326864f, 0.08256802f, 0.07732611f, -0.03124581f, 0.13361044f, 
    -0.31844589f, 0.26203731f, 0.28304416f, -0.18091501f, -0.09961741f, 0.03796165f, -0.04546401f, 0.00282424f, 
    -0.00376989f, -0.00935463f, 0.02434521f, -0.04714502f, -0.02459848f, 0.06421371f, 0.01050808f, -0.03731293f, 
    -0.03271215f, 0.02622004f, 0.14092755f, 0.03800454f, 0.01691171f, 0.19548404f, 0.13019605f, 0.07589998f, 
    -0.07392759f, 0.09179622f, 0.02571709f, 0.07770103f, -0.05610425f, -0.02056167f, -0.15741652f, 0.17205374f, 
    -0.13068987f, 0.14245860f, 0.00682387f, 0.02902494f, 0.12413722f, -0.02764095f, -0.16934921f, -0.00181671f, 
    0.09076232f, -0.06349649f, 0.26583776f, 0.12784672f, -0.00871992f, -0.01413247f, 0.03707475f, -0.04003948f, 
    0.20976822f, -0.27995282f, 0.03779364f, 0.11468995f, 0.11179383f, -0.02874198f, 0.00753679f, -0.01712498f, 
    0.11755639f, 0.05822210f, -0.06295522f, 0.05150929f, 0.09278651f, -0.11473610f, -0.24942113f, -0.08573354f, 
    0.11585033f, -0.05252051f, -0.11007697f, -0.16749825f, -0.09078349f, 0.00797238f, 0.04888709f, 0.06458092f, 
    0.10556617f, 0.00008700f, 0.09787679f, 0.09118261f, 0.13213617f, -0.10605954f, -0.02903692f, 0.08768290f, 
    0.07383189f, 0.00186889f, -0.16692406f, 0.29146725f, 0.44455323f, 0.08314936f, -0.02528085f, -0.03710528f, 
    0.03065294f, -0.09359102f, 0.08897662f, -0.06132284f, -0.04415867f, -0.09260777f, 0.01362002f, 0.08386154f, 
    -0.02960344f, 0.08365946f, 0.04976977f, -0.09698275f, -0.14039007f, 0.05151214f, 0.21798368f, 0.17993051f, 
    0.09018733f, -0.16452610f, 0.06229636f, -0.05987366f, -0.23076975f, 0.07348197f, -0.07659947f, 0.13043149f, 
    -0.03180786f, 0.00070281f, 0.05302322f, 0.03251199f, 0.11822641f, -0.12127849f, 0.09957310f, -0.03431363f, 
    0.25668326f, 0.45779851f, 0.23822904f, 0.08611673f, 0.39222705f, 0.03305208f, 0.11303741f, 0.04132078f, 
    0.03795026f, 0.01581781f, 0.09935701f, 0.07829167f, 0.06234687f, -0.06517683f, 0.04149529f, 0.09894677f, 
    0.08221707f, 0.00019589f, 0.11776619f, 0.03475487f, 0.08654010f, -0.27849871f, -0.20245919f, -0.05371678f, 
    -0.03181810f, 0.06696159f, -0.16190882f, -0.03294190f, -0.01736770f, 0.01298422f, -0.04134877f, 0.04219655f, 
    0.07996974f, -0.00438318f, 0.07823061f, 0.07548441f, 0.01975253f, -0.07912470f, -0.10469679f, 0.06431628f, 
    -0.08928621f, 0.37671310f, 0.30404562f, 0.11437784f, -0.06919857f, -0.01204675f, 0.01011605f, -0.00874135f, 
    0.01619132f, 0.06696340f, 0.02318022f, -0.09059530f, -0.08370971f, 0.10258060f, -0.11002012f, 0.10045728f, 
    0.09554453f, -0.16586046f, 0.11776636f, 0.01528280f, 0.03191206f, -0.28166249f, -0.16522305f, -0.13070862f, 
    -0.00274897f, 0.04025590f, 0.05407644f, -0.07475866f, 0.08620208f, 0.03575328f, 0.05513597f, -0.04077452f, 
    -0.00558164f, 0.04860932f, 0.06538907f, -0.03526627f, -0.03939041f, -0.01675214f, -0.15584160f, -0.08695695f, 
    -0.38032144f, -0.11496037f, 0.51788294f, 0.09893170f, 0.24131079f, -0.09126420f, 0.02824361f, -0.01966566f, 
    0.17109950f, -0.09460997f, 0.09191643f, -0.02338438f, 0.10440835f, -0.13258237f, -0.13582085f, -0.10722670f, 
    -0.06325001f, -0.00993646f, -0.01696828f, 0.07920010f, -0.05028255f, 0.12551476f, 0.36830032f, -0.18398130f, 
    -0.11492471f, 0.06217287f, 0.00662835f, -0.08167008f, 0.10818820f, -0.15144832f, -0.03344546f, -0.10888781f, 
    0.02179009f, -0.01329104f, -0.13974333f, -0.07780232f, -0.06713029f, 0.06273951f, 0.01509807f, -0.07415871f, 
    -0.12251689f, 0.39088947f, 0.43090680f, -0.02413109f, -0.07266007f, -0.19670492f, -0.08617690f, 0.09793046f, 
    0.00934977f, -0.11028443f, -0.03850131f, 0.04035134f, 0.01389755f, 0.10729017f, -0.03180333f, -0.10312287f, 
    0.04289773f, 0.04392907f, 0.00413376f, -0.20701759f, -0.02508634f, 0.05473784f, 0.25486821f, -0.14322415f, 
    -0.12671126f, -0.02391120f, -0.02142831f, 0.17049357f, 0.10618604f, -0.19225056f, -0.08112213f, -0.03135625f, 
    0.19131069f, -0.00430418f, -0.04841815f, 0.00302556f, 0.02307885f, 0.02241450f, 0.12690370f, -0.02211338f, 
    0.19650570f, 0.28353587f, -0.33780050f, -0.28225479f, 0.33650425f, -0.17080496f, 0.02499275f, -0.04281646f, 
    -0.02792376f, -0.01668377f, 0.06473338f, 0.01270041f, 0.05703092f, -0.13448176f, 0.10856730f, 0.06067112f, 
    0.03462148f, -0.15634412f, 0.05995207f, -0.03629760f, -0.08426173f, -0.36216253f, -0.18013309f, -0.35256678f, 
    0.05858021f, -0.13841425f, 0.11909620f, 0.01656163f, 0.03796343f, 0.06480934f, -0.03999418f, 0.12436883f, 
    0.13661005f, -0.07209378f, 0.11730231f, 0.01393118f, -0.06290492f, -0.04635532f, -0.04858024f, -0.03046638f, 
    0.01544318f, 0.00171951f, -0.00624776f, -0.03885841f, 0.03302721f, -0.02126232f, 0.02338766f, 0.01755458f, 
    0.02029906f, -0.02258985f, 0.01405923f, 0.01626226f, -0.02755411f, 0.02447448f, 0.00554855f, -0.02786322f, 
    -0.01047402f, -0.01314165f, -0.01041567f, 0.00819593f, 0.00431184f, 0.02492610f, -0.02050802f, -0.01583909f, 
    0.03250273f, 0.00943123f, -0.03404935f, -0.00375865f, -0.01929715f, -0.00211723f, -0.00308752f, -0.04036610f, 
    0.02897134f, -0.02519306f, -0.00365133f, -0.00700839f, 0.03111861f, 0.00911487f, 0.01269446f, 0.02422028f, 
    -0.03577422f, -0.02215306f, -0.01905785f, -0.03133215f, 0.00633833f, -0.00403005f, -0.02350767f, -0.01200558f, 
    -0.00849495f, -0.01665742f, -0.01501769f, 0.03299341f, 0.00015002f, -0.04267007f, -0.03929562f, 0.00691565f, 
    -0.00864575f, 0.00737428f, -0.02098372f, 0.00716589f, -0.02918932f, -0.00165274f, -0.02853530f, -0.02046638f, 
    -0.00338183f, -0.04013969f, -0.02592277f, -0.03376710f, -0.01586455f, 0.01483823f, -0.03838250f, 0.03627339f, 
    0.01209065f, 0.00017783f, -0.00416994f, 0.00977652f, -0.01064995f, -0.02865026f, -0.01900600f, 0.02578161f, 
    -0.04051014f, -0.04041287f, 0.01025280f, -0.02969781f, -0.00071162f, 0.01612666f, -0.03243003f, 0.00050973f, 
    -0.03762796f, -0.02396661f, -0.02399806f, -0.03100099f, -0.03168355f, -0.02302453f, 0.01668760f, -0.02474783f, 
    -0.03172789f, -0.01021234f, -0.03448783f, 0.00507805f, -0.00993273f, -0.02891861f, -0.02829562f, -0.01022337f, 
    -0.00707371f, 0.02762434f, 0.00510172f, -0.00282347f, -0.03129644f, 0.00272596f, -0.01689605f, 0.01523886f, 
    -0.00184479f, -0.03771238f, -0.02331598f, -0.02572815f, -0.01329803f, 0.02723293f, -0.00248786f, -0.00293518f, 
    0.03329315f, 0.00234431f, -0.03912377f, 0.00652701f, -0.01310776f, 0.01947224f, -0.00583567f, -0.00660477f, 
    -0.01606895f, -0.00989480f, -0.02823347f, -0.00443026f, 0.01973062f, 0.00590422f, 0.02658389f, -0.02538935f, 
    -0.04498103f, 0.03138626f, -0.02250309f, 0.02459466f, 0.00133745f, -0.02849520f, 0.01439004f, -0.03681668f, 
    0.03494911f, 0.01819906f, 0.01088216f, 0.02669855f, 0.01429134f, 0.01736046f, -0.03328462f, 0.01887909f, 
    -0.03972808f, 0.03472384f, -0.00129485f, 0.01911705f, -0.03659044f, -0.01154604f, 0.01554863f, 0.01643709f, 
    -0.01042358f, -0.03313197f, 0.03100868f, -0.03964821f, -0.01572176f, 0.01488503f, 0.02974910f, -0.00191942f, 
    -0.00543152f, 0.01830509f, -0.01956200f, -0.00568991f, -0.02557880f, -0.01060875f, 0.03399657f, 0.01362747f, 
    0.03065183f, 0.01106746f, 0.02654306f, 0.01938580f, 0.01860199f, 0.02184622f, 0.00319988f, -0.03657770f, 
    0.00409632f, 0.02220789f, 0.02558624f, 0.00111912f, -0.01095535f, -0.03805629f, 0.00663710f, -0.03639554f, 
    0.02717414f, -0.03815430f, 0.01675478f, 0.02208797f, 0.01526892f, -0.04326506f, 0.03280259f, -0.03058803f, 
    -0.03846576f, -0.03246026f, -0.02614317f, -0.00171199f, -0.03990379f, 0.02371204f, 0.01475486f, -0.00413341f, 
    -0.01319021f, 0.01939915f, -0.03065174f, -0.02401330f, 0.00648576f, 0.02422502f, -0.01478645f, -0.01221810f, 
    0.02538600f, -0.03878468f, 0.00859218f, 0.00394714f, 0.01183951f, 0.00456874f, 0.02653027f, -0.00645094f, 
    -0.03266465f, 0.01025630f, -0.03547974f, 0.01632138f, 0.01749923f, -0.02192023f, -0.00480016f, 0.01004531f, 
    -0.02995348f, -0.01864634f, 0.01583170f, -0.03497960f, -0.00480745f, 0.03280031f, -0.03370232f, 0.03046204f, 
    0.02773400f, -0.04090750f, -0.02381962f, 0.00169285f, 0.00419091f, -0.00888169f, 0.02493045f, -0.00591633f, 
    0.02803361f, 0.02578006f, -0.03302916f, 0.03354226f, -0.04080052f, 0.02249701f, 0.01491551f, -0.01678702f, 
    0.03496691f, -0.03018211f, -0.02529173f, -0.00665286f, -0.00332129f, 0.00975432f, -0.03334663f, 0.02712627f, 
    -0.00641804f, 0.03366147f, -0.01291689f, -0.00400177f, 0.01916815f, -0.00491810f, 0.02734699f, -0.01744764f, 
    0.03359478f, -0.01904945f, 0.02916867f, -0.03155745f, -0.03555354f, -0.03909345f, 0.01505317f, -0.02937520f, 
    0.03082405f, -0.03760117f, -0.03816522f, 0.01242731f, -0.03416490f, -0.02455144f, 0.03289436f, -0.03276167f, 
    0.02522441f, -0.02538788f, -0.00685683f, -0.04418863f, 0.00055580f, 0.00575134f, -0.00263230f, -0.03040498f, 
    -0.03407791f, 0.02491531f, -0.02029604f, -0.00916908f, 0.00133652f, 0.02000777f, 0.01974062f, 0.00528280f, 
    0.03178744f, 0.03026390f, -0.03283324f, 0.00396383f, 0.02275041f, -0.02871019f, -0.01017444f, 0.00871006f, 
    0.02266597f, -0.02179434f, 0.03079773f, 0.01836491f, 0.00196642f, 0.01276310f, 0.03095177f, 0.00104371f, 
    0.03787618f, 0.02831651f, 0.00628758f, -0.03857659f, 0.01711087f, -0.03491189f, -0.00329102f, -0.02907578f, 
    0.02890737f, 0.01722804f, 0.02663575f, 0.01251099f, 0.00244789f, -0.02073608f, -0.02070535f, -0.01654084f, 
    -0.01636304f, -0.03917002f, -0.03982035f, -0.01507846f, 0.00881766f, 0.02085335f, 0.00657930f, -0.00409138f, 
    -0.03411148f, 0.02111638f, 0.02601583f, 0.03171038f, -0.01108019f, -0.02961531f, 0.02544566f, 0.03564695f, 
    -0.02730108f, 0.02502347f, -0.01623697f, -0.00824322f, 0.02961295f, -0.02858035f, -0.01136636f, -0.03347081f, 
    0.01632884f, 0.02531115f, 0.00423238f, -0.03336567f, -0.03638255f, 0.01962631f, 0.02578716f, -0.02845857f, 
    -0.01402667f, -0.02039307f, -0.02493003f, -0.04071310f, -0.01517572f, 0.01327854f, -0.01594145f, 0.00517455f, 
    -0.02879217f, 0.01261016f, -0.00659205f, 0.01577947f, 0.01229108f, 0.00944905f, 0.02161926f, -0.03546114f, 
    0.00548402f, 0.02216313f, 0.00777955f, -0.04136441f, -0.02949257f, -0.00874867f, -0.00604133f, -0.02999906f, 
    -0.00081859f, -0.01780264f, -0.04052804f, 0.00670768f, -0.00058592f, -0.03753389f, 0.02988967f, 0.00995001f, 
    -0.04355917f, 0.02228783f, 0.01032363f, -0.02565020f, -0.03314181f, 0.01816460f, -0.00391207f, -0.03824446f, 
    0.02024829f, -0.01795533f, 0.01765388f, 0.01323186f, -0.03343506f, -0.03188696f, -0.00305813f, -0.02865297f, 
    0.02779451f, 0.03127292f, 0.02306898f, 0.01710511f, 0.00095921f, 0.00795919f, 0.02899033f, -0.00122017f, 
    0.03455131f, -0.04269801f, -0.02074069f, -0.02628729f, -0.02118231f, 0.00622284f, -0.02381119f, 0.01658179f, 
    -0.03313949f, -0.04138216f, 0.00633351f, 0.02234676f, -0.01660883f, -0.01826257f, -0.04017883f, -0.04126300f, 
    0.01406582f, -0.02190885f, -0.03193491f, 0.02226200f, -0.04245824f, -0.03622682f, -0.01461113f, -0.02222341f, 
    -0.03505907f, 0.00680348f, -0.01512563f, 0.02263856f, 0.01452185f, -0.01674128f, 0.01195321f, -0.03988481f, 
    -0.02573325f, 0.00794287f, 0.02949494f, -0.02870252f, -0.00673462f, 0.01136061f, -0.00110299f, -0.02511958f, 
    0.00977249f, 0.02493438f, -0.00299358f, 0.00509595f, 0.00643043f, -0.00529255f, 0.00531891f, 0.01425402f, 
    0.02529277f, -0.00356708f, 0.02792494f, 0.00423695f, -0.03373992f, -0.01943242f, 0.02459904f, 0.02381372f, 
    0.02430269f, 0.00587005f, -0.01596084f, -0.02395291f, -0.01157976f, -0.00776525f, -0.02420976f, -0.00343954f, 
    -0.00597907f, -0.01400718f, 0.01528150f, 0.02103306f, -0.02413338f, 0.01726980f, 0.00600821f, 0.01520492f, 
    0.00311384f, -0.04141576f, 0.02911097f, -0.01568854f, -0.02701584f, -0.04153386f, 0.00692631f, -0.01543769f, 
    -0.01355141f, 0.01157628f, 0.01908852f, 0.01521884f, -0.00474178f, 0.00331044f, -0.03028790f, 0.02885152f, 
    -0.03327313f, -0.02115555f, -0.01997852f, -0.03594664f, 0.00354280f, 0.02914617f, 0.00332951f, -0.00927891f, 
    0.01755594f, -0.02493738f, 0.02323964f, 0.00848882f, -0.02589539f, -0.02387645f, 0.02154192f, -0.03854477f, 
    0.01721686f, 0.01944443f, -0.02865767f, 0.01050616f, 0.02155312f, -0.01401305f, -0.02080560f, 0.02725589f, 
    0.03589130f, -0.03350511f, 0.01200383f, 0.02292398f, 0.00032541f, 0.02259205f, 0.00312426f, -0.02187138f, 
    0.01951259f, -0.01076354f, -0.02987404f, -0.00623037f, 0.03183671f, -0.02011972f, -0.01713471f, -0.03021286f, 
    -0.01328071f, -0.01479576f, -0.01222388f, 0.01322374f, -0.00269941f, -0.00833960f, -0.01452984f, 0.00205797f, 
    -0.02578985f, -0.00262551f, -0.01394806f, -0.00881137f, -0.00557869f, 0.03086846f, -0.01071000f, -0.04269036f, 
    0.02044121f, 0.02830387f, -0.03747419f, -0.03433537f, -0.03066678f, 0.03019817f, 0.02000059f, 0.02783676f, 
    -0.03551646f, 0.02933516f, -0.01012046f, 0.03305798f, -0.00486877f, -0.03668409f, -0.03469265f, -0.01627650f, 
    -0.00510459f, -0.03748045f, 0.01975040f, -0.02569520f, -0.04341185f, -0.00881173f, 0.01800959f, 0.02914685f, 
    -0.01918880f, 0.01797688f, -0.03641082f, -0.01564292f, -0.03840413f, 0.02472902f, 0.00861216f, 0.02985368f, 
    0.01055996f, 0.02186311f, 0.01194592f, 0.04479052f, -0.01117595f, -0.01693982f, -0.02950055f, -0.02352031f, 
    -0.01904470f, -0.00502007f, 0.02025530f, -0.02269678f, -0.01659849f, -0.03508010f, 0.01461988f, 0.01082730f, 
    0.02681162f, 0.00121189f, 0.01034714f, 0.01696883f, -0.01969691f, 0.03163811f, -0.00660516f, -0.00666050f, 
    0.02387440f, 0.03770622f, 0.03275242f, -0.03466826f, 0.02249887f, -0.02705510f, 0.01836269f, -0.01393533f, 
    -0.01155987f, -0.02455587f, -0.03950879f, 0.03382573f, 0.02877748f, 0.00841248f, -0.00098071f, -0.01541107f, 
    -0.02043000f, 0.03083616f, 0.00907298f, -0.00020644f, 0.02731464f, 0.00142509f, 0.00267583f, -0.03567939f, 
    0.01599669f, -0.01001936f, 0.00508433f, 0.00548145f, -0.02939206f, 0.00594911f, -0.03978101f, -0.04431491f, 
    -0.01929795f, -0.02694152f, 0.02224963f, -0.02035994f, 0.01805316f, -0.00048474f, -0.00315321f, -0.00026533f, 
    -0.01377540f, 0.00968703f, 0.00357183f, -0.03950005f, -0.02100112f, 0.01924799f, 0.00315930f, 0.00838990f, 
    -0.03627553f, -0.04421782f, 0.00164352f, 0.03262628f, -0.00207332f, 0.02915192f, 0.01321579f, -0.00428138f, 
    0.02788837f, 0.01319690f, 0.00406691f, 0.02846016f, 0.00488970f, 0.01978530f, 0.02686951f, -0.02281623f, 
    0.00483288f, 0.01027461f, -0.03683926f, -0.03818476f, 0.02094495f, 0.02258827f, 0.01245861f, -0.01847691f, 
    0.02925849f, -0.03201539f, 0.01454565f, 0.00767523f, 0.00684227f, -0.03896149f, -0.01601578f, -0.00360848f, 
    -0.02202576f, 0.02689074f, 0.02813077f, 0.00537207f, -0.01160222f, 0.01232455f, -0.01889885f, 0.02122606f, 
    -0.02642225f, -0.04051690f, 0.00668457f, -0.01532287f, -0.03770379f, -0.03148308f, -0.00395579f, -0.03644924f, 
    -0.00990815f, -0.01702522f, 0.03168282f, 0.02537140f, -0.00188940f, 0.01422470f, -0.01502260f, 0.02991436f, 
    0.01788665f, 0.01509887f, -0.02520460f, -0.02563722f, 0.02879480f, 0.01406968f, -0.01339928f, 0.02229821f, 
    -0.03436030f, 0.01866609f, -0.02221499f, -0.00099340f, -0.01790719f, 0.02366900f, -0.02962780f, -0.04233667f, 
    -0.01369957f, -0.04194627f, -0.03365233f, 0.02664110f, -0.02926031f, -0.01980865f, -0.03765131f, 0.01801189f, 
    -0.01796179f, 0.02962560f, 0.01168566f, -0.03159513f, -0.01447442f, 0.01171135f, -0.01661574f, 0.02006953f, 
    -0.05004102f, 0.02419651f, -0.04009468f, -0.03883601f, 0.01731190f, 0.01508609f, 0.00799567f, -0.03688115f, 
    -0.04005400f, -0.01216403f, -0.03538467f, -0.02298047f, -0.01552052f, -0.02467455f, -0.02694211f, -0.03550237f, 
    0.00937677f, -0.03002501f, 0.02336637f, 0.00482032f, 0.02624394f, -0.00801143f, 0.01042760f, 0.00866860f, 
    0.00266628f, 0.00680785f, 0.00974813f, -0.04132296f, -0.01366858f, -0.03676901f, 0.02797158f, 0.00513947f, 
    0.00128474f, -0.00078876f, -0.03214949f, 0.03385238f, -0.02772205f, 0.02690817f, 0.01105578f, 0.03268508f, 
    0.02524087f, -0.01217392f, 0.02893803f, -0.03113248f, 0.01116433f, 0.01290188f, -0.03347478f, -0.01461848f, 
    -0.04138476f, -0.01699843f, 0.02542741f, 0.02986031f, -0.03497247f, -0.00007384f, 0.02686046f, -0.01676103f, 
    -0.03399455f, -0.01100986f, 0.01758251f, -0.01778243f, -0.03202556f, 0.02871638f, -0.00644867f, -0.04667816f, 
    0.03096210f, -0.01674313f, -0.04418140f, -0.03455212f, 0.00097055f, 0.02505864f, -0.00344196f, 0.02750026f, 
    -0.01299770f, 0.03082316f, -0.02481751f, 0.01841705f, 0.00765450f, 0.02085031f, 0.02574401f, -0.00778656f, 
    -0.00241637f, -0.02347981f, -0.00709838f, -0.01196746f, 0.01157895f, 0.02134698f, -0.02387261f, -0.00977099f, 
    0.01817743f, 0.01603431f, 0.01854641f, 0.03276180f, -0.01305899f, -0.03224003f, 0.03223680f, -0.03679081f, 
    -0.00997417f, -0.04217409f, -0.04065234f, -0.01694279f, -0.02035206f, -0.00532835f, -0.02271625f, -0.02350860f, 
    -0.00780382f, -0.03660057f, 0.03409602f, 0.02835002f, 0.00487264f, -0.03323935f, -0.03015144f, 0.00804437f, 
    0.01126559f, 0.02904138f, -0.00854696f, -0.00746041f, -0.03778379f, 0.01546072f, 0.02853789f, -0.03945830f, 
    0.01872366f, -0.00468478f, 0.00692182f, 0.02627126f, -0.01280859f, 0.00136941f, -0.01007880f, -0.02493102f, 
    -0.03980288f, -0.01985146f, 0.01584289f, -0.00804830f, -0.01799617f, -0.01696342f, -0.03572479f, 0.00131335f, 
    -0.00694538f, -0.03571663f, -0.01920174f, -0.02562031f, 0.00517021f, 0.01077202f, -0.01590972f, 0.03285335f, 
    0.03617937f, -0.02761522f, -0.03765365f, -0.01878304f, -0.03055757f, -0.02074807f, -0.03402175f, 0.00205429f, 
    0.03246080f, -0.02931867f, 0.03027396f, 0.00418262f, -0.01459781f, 0.01754643f, -0.02339878f, -0.03218650f, 
    -0.00439241f, -0.01550321f, 0.01832480f, 0.01641845f, -0.01393108f, 0.02017067f, -0.02793180f, -0.01830374f, 
    0.02349151f, 0.01633492f, -0.02717039f, 0.01093235f, 0.00098565f, -0.03045041f, 0.00592058f, 0.01203791f, 
    -0.02296496f, 0.02370599f, -0.04099336f, 0.01218901f, -0.01890348f, 0.02005114f, 0.02996519f, -0.00884344f, 
    0.00011390f, 0.00269438f, -0.00664384f, -0.02158204f, -0.00817263f, -0.02165963f, 0.00643787f, -0.02542647f, 
    -0.02526034f, -0.01587757f, -0.00444985f, 0.00985456f, -0.02751771f, 0.01162419f, -0.01491598f, -0.01695380f, 
    0.02283516f, 0.02197010f, 0.00534601f, -0.03439989f, -0.02600393f, -0.01200389f, 0.02724073f, -0.02719223f, 
    -0.04413156f, -0.01132814f, -0.02789175f, 0.01225553f, 0.02969481f, 0.02600168f, 0.00508846f, -0.04121087f, 
    0.00930247f, -0.02034914f, 0.02885761f, -0.02697931f, 0.01144700f, -0.01733653f, -0.00417962f, 0.01442559f, 
    -0.03200714f, -0.02513610f, -0.01604571f, -0.03728333f, 0.01417180f, -0.04152530f, -0.00277243f, 0.02547597f, 
    -0.02629164f, -0.03332785f, -0.01613883f, 0.03013635f, 0.01135612f, -0.04078332f, 0.02591305f, 0.00781038f, 
    -0.02313368f, 0.03213648f, 0.00281279f, -0.00256181f, 0.03459159f, 0.02233454f, -0.00881964f, -0.00729810f, 
    0.00242494f, 0.03046610f, -0.03527815f, -0.00478594f, 0.02379319f, -0.01795899f, -0.01664505f, -0.02754249f, 
    -0.00689412f, 0.00908581f, 0.03524889f, 0.02591371f, -0.02465898f, 0.01919384f, 0.00518785f, 0.01782855f, 
    -0.03624400f, -0.02761137f, -0.04514594f, -0.01172175f, -0.00354578f, 0.00630479f, 0.02968081f, -0.04032538f, 
    0.02841256f, -0.01965944f, -0.02387594f, -0.00519141f, 0.00507357f, -0.04005791f, 0.00817716f, -0.02025036f, 
    -0.04208679f, -0.01020682f, 0.00569875f, -0.00591418f, -0.01559868f, -0.00810980f, -0.02559074f, -0.03760767f, 
    -0.00589242f, 0.03251700f, 0.02034307f, 0.02091582f, 0.01515814f, -0.00173352f, 0.01184801f, 0.03379696f, 
    0.02154310f, 0.03149352f, -0.02606286f, -0.03780829f, 0.01579972f, -0.02642125f, 0.00385461f, -0.02719911f, 
    -0.01785155f, 0.00107775f, -0.01287729f, 0.01635700f, -0.02895381f, -0.02612845f, 0.03705290f, -0.02908218f, 
    -0.03203819f, 0.01410681f, -0.01197840f, -0.01546644f, -0.01723562f, -0.01567876f, -0.03210726f, 0.01638702f, 
    0.02002775f, 0.00006784f, -0.04602493f, 0.01431661f, -0.01778944f, -0.03850285f, 0.01308581f, -0.04014838f, 
    -0.00512599f, 0.02963106f, 0.01992964f, -0.02183183f, 0.00735221f, -0.02474256f, 0.02509895f, 0.01924782f, 
    0.00113797f, 0.01928680f, -0.00036016f, 0.02397616f, 0.02675335f, 0.00804524f, 0.01888072f, 0.00249846f, 
    -0.00799934f, -0.01842016f, 0.01148265f, -0.03850709f, -0.01214475f, 0.00506144f, 0.02729966f, 0.00279244f, 
    -0.03311601f, -0.04541857f, -0.04500449f, -0.02648911f, -0.00201320f, -0.03663003f, -0.01022407f, -0.00043797f, 
    -0.01234599f, -0.00676451f, -0.02093814f, -0.03202833f, 0.02627655f, 0.00676790f, -0.02917230f, 0.01346327f, 
    0.02283956f, -0.00337800f, 0.02580859f, -0.03345203f, -0.02450051f, -0.02141469f, -0.04358123f, 0.01639328f, 
    0.00879182f, 0.03126274f, 0.02095827f, -0.00779203f, -0.00590787f, -0.00244487f, -0.02960840f, 0.01331221f, 
    -0.00335478f, 0.01827797f, -0.00710869f, 0.01629633f, -0.00317391f, -0.02815935f, -0.02800274f, -0.01783901f, 
    0.00549474f, -0.00926948f, -0.02852362f, -0.02890807f, -0.00411180f, -0.02834040f, 0.02325683f, -0.01112457f, 
    0.02818853f, 0.02478583f, -0.02633802f, -0.03848268f, 0.02613325f, -0.03896660f, -0.01798458f, -0.03308560f, 
    0.03102167f, -0.04144974f, -0.02341193f, -0.04064634f, 0.01403241f, -0.02676137f, -0.04265165f, -0.02947344f, 
    0.01616814f, -0.03061682f, 0.03365842f, 0.02424973f, -0.01764864f, -0.00826719f, 0.02527175f, -0.02867642f, 
    0.03396001f, -0.04256061f, -0.02096004f, 0.01661089f, -0.00532768f, -0.02385796f, -0.04475839f, -0.03024567f, 
    -0.00189725f, -0.03368502f, 0.01577919f, -0.00790543f, -0.02179614f, -0.00053547f, 0.00909879f, -0.02921228f, 
    -0.03260899f, -0.04164860f, 0.00779731f, -0.04412927f, -0.03176625f, -0.01653820f, -0.04106218f, -0.02460355f, 
    0.00420755f, -0.01190932f, -0.03278989f, 0.01449069f, -0.02428122f, -0.00329334f, -0.00266923f, 0.03396503f, 
    -0.01922498f, -0.03116030f, 0.03485637f, 0.01544556f, 0.00090818f, 0.03126329f, -0.00048200f, 0.00675438f, 
    -0.02166925f, -0.00418019f, 0.01636037f, -0.03473054f, -0.03946182f, -0.03704834f, -0.00628615f, -0.01897244f, 
    -0.01996792f, 0.02898495f, -0.02528907f, 0.02181793f, 0.02475071f, -0.00055377f, 0.01804406f, 0.00854993f, 
    -0.00020109f, -0.01473362f, -0.03890033f, 0.03269985f, 0.02625939f, -0.03662400f, 0.01714469f, 0.03159941f, 
    -0.03535744f, -0.01628027f, 0.01451697f, -0.00047447f, -0.01580063f, 0.00400685f, -0.00254087f, 0.02411767f, 
    -0.03842793f, 0.00380989f, 0.01077548f, -0.00037406f, 0.01670052f, 0.00549899f, -0.00835103f, -0.00563284f, 
    -0.01703696f, -0.00503840f, 0.00006247f, 0.01188557f, -0.01515562f, -0.00739223f, -0.01066878f, -0.01773281f, 
    0.02803412f, 0.01945120f, -0.00202397f, -0.00670477f, -0.01067198f, -0.02157732f, -0.03381853f, -0.00546943f, 
    -0.02141218f, 0.03031281f, 0.02437754f, -0.00250133f, -0.04205722f, -0.03198346f, 0.02683899f, 0.03139368f, 
    -0.03889896f, -0.02456143f, -0.03149891f, 0.01622528f, 0.01360330f, 0.01037253f, -0.03699244f, 0.01362907f, 
    0.02228477f, -0.02441111f, 0.01094518f, -0.01276256f, -0.03694823f, -0.00833892f, -0.02095265f, 0.01668283f, 
    0.00340765f, -0.04476994f, 0.01847749f, -0.04523278f, -0.04461604f, -0.02737267f, 0.00526831f, 0.00069073f, 
    -0.02639229f, 0.02221254f, 0.00088554f, 0.02111852f, -0.02489952f, -0.02371356f, -0.04402889f, -0.01877591f, 
    -0.03751463f, 0.03246471f, 0.02423178f, 0.01033311f, -0.00000715f, 0.02086477f, -0.01437141f, 0.00113831f, 
    0.00853423f, -0.01371940f, 0.01775603f, -0.03704056f, 0.01926265f, 0.01546452f, -0.01343473f, 0.03082461f, 
    -0.00658686f, -0.02072255f, -0.03183498f, -0.03445497f, 0.00155199f, 0.02052804f, 0.02890324f, 0.01323439f, 
    -0.00919883f, -0.01086145f, -0.00667224f, -0.03140481f, -0.03725482f, -0.04499633f, -0.00574978f, -0.01557947f, 
    0.01929839f, 0.00151569f, 0.00310426f, 0.02327449f, -0.04164590f, -0.03840921f, -0.02921625f, -0.03206415f, 
    0.04080563f, 0.01429642f, -0.02309893f, 0.01477724f, -0.00353271f, 0.02844915f, 0.02650486f, -0.03900397f, 
    -0.01997693f, -0.02461009f, 0.01635312f, -0.03980171f, 0.02602988f, -0.01152723f, -0.00816406f, -0.01272502f, 
    -0.00703617f, -0.00149064f, 0.02613345f, 0.00791083f, -0.03505282f, -0.03924428f, -0.00675345f, 0.03287121f, 
    -0.02286647f, -0.01480401f, 0.02977307f, 0.01037350f, -0.02953329f, -0.04206387f, -0.01386791f, 0.00906999f, 
    -0.00920661f, -0.02938435f, 0.02507544f, -0.01788864f, -0.02617879f, 0.02716048f, -0.03772154f, -0.04505274f, 
    0.03329227f, -0.01218974f, 0.00889920f, -0.00305022f, -0.01917063f, 0.00589167f, -0.04093555f, -0.04094778f, 
    -0.03184479f, -0.04217657f, 0.02539119f, -0.00322448f, -0.04239574f, 0.02210003f, 0.02424056f, 0.02244229f, 
    -0.00217863f, 0.01944762f, 0.00036346f, -0.03363285f, 0.01878903f, 0.01433855f, -0.04415864f, 0.02909832f, 
    0.00496810f, -0.03016436f, -0.04080360f, 0.00341107f, -0.01782026f, 0.01764260f, 0.04266996f, 0.00956008f, 
    -0.00178661f, -0.00335261f, -0.01342633f, -0.03734295f, 0.02631035f, -0.02135169f, -0.02878646f, -0.02732985f, 
    0.01287824f, -0.00729172f, -0.02848838f, -0.04064192f, -0.00074576f, -0.03090570f, 0.00033338f, -0.02367643f, 
    -0.03365882f, -0.01461163f, 0.00674079f, 0.02118930f, 0.01588294f, 0.02788359f, 0.01184911f, -0.02152072f, 
    -0.03062784f, 0.01499704f, -0.04187912f, 0.03271074f, 0.00528499f, 0.01373537f, 0.01307040f, -0.03533529f, 
    -0.03128553f, -0.02572405f, -0.01020689f, -0.03205520f, 0.02522945f, 0.01954593f, -0.02028717f, 0.03129790f, 
    0.00892833f, 0.01127495f, 0.03799950f, 0.03250665f, -0.02998108f, -0.01552579f, 0.00399944f, 0.00177446f, 
    -0.03226273f, -0.03498164f, -0.01277475f, 0.01803010f, 0.00089963f, -0.03991165f, -0.01699297f, -0.00041870f, 
    -0.00490574f, -0.01983025f, 0.02305676f, -0.02421607f, -0.00402519f, -0.02017767f, -0.02990345f, 0.03281065f, 
    0.01023110f, -0.00756868f, -0.00048428f, -0.04492917f, -0.00883021f, 0.02219998f, 0.00319884f, -0.00612958f, 
    -0.02666558f, 0.00034768f, 0.00510005f, -0.02232447f, -0.03836401f, -0.03618722f, -0.00555766f, -0.02786030f, 
    -0.00805926f, -0.01474968f, -0.00262737f, 0.02023426f, 0.01663986f, -0.00605964f, -0.03026949f, -0.01812894f, 
    0.01720194f, -0.02994126f, 0.00482882f, -0.01666993f, 0.02469880f, 0.01978195f, 0.02961410f, 0.02594217f, 
    -0.02104750f, 0.02266715f, -0.03885452f, 0.03072152f, -0.01256434f, -0.02486602f, 0.00532534f, -0.04431583f, 
    0.01887129f, -0.00594339f, -0.01806983f, 0.01141501f, -0.03987009f, 0.02623070f, -0.00461349f, -0.04011713f, 
    -0.02052645f, 0.00007183f, -0.02600764f, 0.01331118f, 0.03255102f, 0.01855664f, 0.04407593f, 0.01932889f, 
    -0.00904141f, 0.01837665f, -0.00352874f, 0.00003351f, -0.01132513f, -0.01902576f, 0.01277491f, -0.02078006f, 
    0.00988235f, -0.03826464f, 0.02766327f, 0.02257681f, 0.00838745f, -0.02064265f, 0.00877778f, 0.02610951f, 
    -0.02532977f, -0.04434099f, -0.04201016f, -0.04250198f, 0.01688253f, 0.01674259f, -0.02478980f, -0.03940614f, 
    0.00444220f, 0.02528950f, 0.00051409f, -0.02107210f, -0.02583267f, -0.00028560f, -0.00512843f, 0.04226289f, 
    -0.02697877f, -0.01209489f, -0.01453749f, -0.04435634f, 0.00429578f, -0.00447544f, 0.02067030f, -0.01180297f, 
    -0.00080946f, -0.00495948f, -0.04501688f, -0.00600411f, 0.02153115f, 0.00401037f, 0.00123784f, -0.02423907f, 
    0.01795346f, 0.00542751f, 0.01681533f, 0.03288055f, -0.02623679f, -0.02187992f, 0.02761844f, -0.00310385f, 
    0.00702415f, 0.00577333f, -0.02044350f, 0.00934409f, -0.02060070f, 0.01688231f, -0.00833033f, -0.01243117f, 
    0.00761717f, -0.02683083f, -0.03446252f, 0.00458215f, 0.01894876f, 0.04200536f, 0.03222715f, 0.01319610f, 
    -0.02380008f, 0.02276992f, 0.02272782f, -0.02051145f, 0.02396919f, -0.03186416f, 0.02408867f, 0.02500384f, 
    -0.03740631f, 0.03051089f, 0.00141275f, 0.01560726f, -0.00260727f, -0.00101954f, -0.04105219f, -0.02942920f, 
    -0.03588840f, 0.01586016f, 0.00202389f, 0.02254988f, 0.02878529f, -0.01594741f, 0.01712437f, -0.02252714f, 
    -0.00471466f, -0.00598061f, 0.02536917f, -0.00991167f, -0.01287237f, 0.00158103f, -0.02409056f, 0.02017045f, 
    0.00620973f, 0.01520395f, 0.02068700f, 0.00124916f, 0.02143299f, -0.02822899f, 0.03229146f, 0.00635300f, 
    0.01263712f, -0.04094378f, -0.02407491f, 0.02065445f, -0.00315635f, 0.03031257f, -0.01469701f, 0.02541198f, 
    0.01657648f, 0.02670125f, 0.00943823f, -0.02664595f, -0.01013015f, 0.01192000f, 0.02766825f, -0.03315341f, 
    0.00624833f, -0.04539045f, -0.01347465f, -0.01802781f, -0.00827560f, 0.02260607f, -0.01674525f, -0.00734950f, 
    -0.02964775f, -0.00359508f, 0.00235539f, -0.04535969f, 0.01534670f, -0.01055215f, 0.00429736f, 0.00251025f, 
    -0.04384414f, -0.00948599f, -0.03080378f, -0.00019883f, 0.00562001f, -0.01708477f, 0.02594808f, -0.01033017f, 
    -0.00978479f, -0.00768110f, -0.03067802f, -0.00016474f, -0.00139459f, -0.03349791f, 0.02901983f, 0.01332189f, 
    0.02464518f, 0.00706293f, 0.03181786f, -0.01580475f, -0.02858885f, -0.01583923f, -0.00675060f, -0.01905764f, 
    -0.02196909f, -0.02166195f, -0.01568406f, -0.00827997f, 0.01045688f, 0.01811291f, -0.00179475f, -0.03992089f, 
    -0.01711218f, 0.02851704f, 0.02057878f, 0.03239224f, 0.00615492f, 0.01772777f, 0.04255348f, 0.01473897f, 
    -0.03890059f, 0.01729751f, -0.01895314f, 0.04419820f, 0.00906159f, -0.02042485f, 0.03217558f, -0.03505598f, 
    -0.03056348f, -0.00322393f, 0.01684199f, -0.02873747f, 0.02740031f, -0.02210488f, -0.04192028f, -0.02404514f, 
    0.00573054f, -0.00385422f, 0.02199865f, -0.00049579f, -0.03699738f, -0.02444068f, 0.03198778f, -0.02420960f, 
    0.00172626f, -0.02358495f, 0.03546398f, 0.01894845f, -0.01679533f, 0.00961815f, -0.01671617f, -0.01983585f, 
    0.01253460f, -0.04520232f, -0.01884399f, -0.02586322f, 0.02701651f, -0.04257894f, 0.00152011f, -0.02869959f, 
    -0.02459637f, -0.03291049f, -0.03417179f, 0.02433096f, -0.01738452f, -0.04145155f, 0.03726817f, -0.00395194f, 
    -0.01700797f, -0.00128470f, 0.00275589f, -0.04219320f, -0.03248106f, -0.01253851f, -0.01177846f, 0.01901138f, 
    -0.03592916f, -0.01665201f, 0.02244393f, 0.01983538f, -0.03099112f, -0.02150615f, 0.02074821f, -0.00552958f, 
    0.02695846f, -0.04115982f, -0.03149676f, -0.03249027f, -0.00568983f, 0.02779869f, 0.04483890f, -0.02339304f, 
    -0.03973264f, -0.02293662f, -0.00635740f, -0.03816827f, 0.02386765f, -0.01242821f, 0.02696330f, 0.01237546f, 
    -0.03686694f, -0.03237154f, 0.00361871f, -0.00690305f, 0.02710861f, 0.02836704f, -0.00232887f, -0.04352670f, 
    -0.03990218f, 0.02328082f, 0.00908389f, -0.04097742f, 0.00540742f, 0.00178286f, 0.00546465f, 0.02486555f, 
    0.00756241f, 0.01952172f, 0.02381436f, -0.00723084f, 0.03919739f, 0.01547137f, 0.02755428f, -0.01559195f, 
    -0.01843163f, -0.03775750f, 0.01737667f, -0.04368874f, 0.01181266f, 0.01151964f, 0.00437778f, -0.03846892f, 
    -0.04192526f, 0.00428553f, -0.03702147f, -0.03907390f, 0.02913100f, 0.00641651f, -0.03082562f, -0.03699953f, 
    -0.00749370f, 0.02612109f, -0.02261502f, 0.01390097f, -0.00619783f, -0.04099495f, -0.01528459f, -0.01596326f, 
    -0.02119168f, -0.02561168f, 0.02756153f, 0.03058771f, -0.00824872f, 0.03157210f, -0.03177035f, 0.04011669f, 
    -0.02450839f, 0.02583815f, -0.00165585f, 0.02663706f, 0.00999075f, 0.01614111f, -0.00607329f, -0.03117551f, 
    0.02448331f, -0.01117771f, -0.00071249f, -0.03259930f, -0.03942133f, -0.01581829f, -0.04224422f, -0.03608303f, 
    0.01824394f, -0.00251705f, -0.02499388f, 0.01635419f, -0.03110988f, -0.01510152f, 0.03150871f, -0.02455075f, 
    0.02870720f, 0.00205631f, -0.02502036f, -0.02562878f, -0.01147467f, -0.00940501f, -0.02758286f, -0.02990422f, 
    -0.01462970f, -0.02213096f, 0.03152087f, -0.01231955f, -0.01123682f, 0.03116588f, -0.00397015f, 0.02389524f, 
    -0.02814099f, 0.02767788f, -0.02668722f, 0.04133380f, 0.00268185f, 0.00219776f, 0.03167930f, 0.00745837f, 
    -0.04268917f, -0.02914646f, 0.02711810f, -0.00917273f, 0.00703269f, 0.01661740f, -0.00224814f, -0.03844399f, 
    -0.02408193f, 0.02637710f, -0.04329673f, 0.01939503f, -0.02910402f, -0.00609537f, -0.04328779f, 0.02185908f, 
    -0.03798231f, -0.00972858f, -0.03775657f, 0.01719051f, 0.01696270f, 0.02937090f, -0.03096984f, 0.02893609f, 
    -0.00967733f, -0.01212368f, -0.00686781f, -0.01098447f, 0.03046290f, 0.00342870f, -0.02848426f, 0.02888648f, 
    -0.00678582f, -0.00020344f, -0.00536584f, -0.01104764f, -0.00836540f, -0.02502151f, -0.03053854f, -0.01131594f, 
    -0.03512307f, 0.01368477f, 0.00941999f, 0.01926758f, -0.03453643f, -0.02325352f, -0.03743199f, -0.02214806f, 
    -0.00513986f, 0.02375659f, 0.02979715f, 0.00906662f, 0.01013009f, -0.02014779f, -0.03036142f, -0.03099027f, 
    -0.03344437f, 0.00380573f, -0.01382483f, 0.01320132f, 0.00432650f, 0.00508668f, 0.03324449f, 0.01123090f, 
    -0.00804251f, -0.01079277f, -0.02103030f, -0.02424678f, 0.03101314f, -0.00032327f, -0.04511936f, -0.01829815f, 
    -0.03587850f, -0.04282876f, 0.02095890f, 0.01820546f, 0.00410349f, -0.01094444f, 0.02761010f, -0.04266327f, 
    0.02527609f, 0.02640417f, 0.00085757f, 0.00536384f, -0.04530423f, -0.01596025f, -0.03711654f, -0.04376673f, 
    0.03393432f, -0.00901619f, -0.00254524f, -0.02643490f, 0.00636278f, -0.01285805f, -0.04440301f, -0.00982521f, 
    -0.01081635f, -0.02551838f, 0.02246696f, 0.03179304f, 0.01758029f, 0.01986439f, -0.04444750f, 0.01914160f, 
    -0.01426542f, -0.00864741f, 0.01423484f, -0.02921610f, 0.01819598f, 0.02724180f, 0.01676516f, 0.02388644f, 
    0.02126488f, -0.03485195f, 0.02945128f, 0.00030830f, -0.01077652f, -0.03722968f, -0.00460273f, -0.02525982f, 
    0.00999036f, 0.00296558f, -0.02113286f, -0.02142227f, 0.01127298f, -0.02900532f, -0.00459530f, 0.01244781f, 
    0.00927524f, -0.00686822f, -0.01151853f, -0.04271191f, 0.03264104f, -0.02477861f, -0.03348425f, 0.02121252f, 
    -0.01270520f, -0.00400530f, 0.02447973f, -0.03538652f, 0.00403195f, 0.02837000f, -0.01782509f, 0.03335687f, 
    -0.00375990f, -0.02219441f, -0.04102147f, -0.01690382f, -0.03424357f, -0.01309462f, 0.01072064f, 0.00858081f, 
    -0.01294687f, -0.03858604f, 0.00752978f, -0.02591234f, -0.03525351f, -0.03363391f, 0.01188716f, -0.04105521f, 
    -0.02971354f, -0.03155389f, 0.00073891f, -0.03615524f, -0.04039654f, 0.00614991f, -0.02490158f, 0.00279238f, 
    -0.02435022f, -0.03174181f, 0.02689875f, -0.03634883f, -0.00251163f, 0.01743239f, -0.00457747f, -0.01928615f, 
    -0.04108874f, 0.02534114f, -0.00339455f, -0.00238981f, -0.00944539f, -0.04535041f, 0.02135572f, -0.02002610f, 
    0.00462892f, -0.03979539f, -0.03741037f, 0.00196343f, -0.03798686f, 0.01273016f, -0.03938781f, -0.02650325f, 
    -0.03921382f, -0.01184286f, 0.00895364f, -0.00439294f, -0.03245343f, -0.02959506f, 0.02524650f, 0.03001178f, 
    -0.01522053f, -0.02582444f, -0.00577283f, -0.03689196f, -0.03970037f, 0.00401973f, -0.00486575f, -0.03008042f, 
    0.01004350f, -0.02702280f, -0.01872203f, -0.00386696f, 0.00864235f, -0.04000868f, 0.02431327f, 0.02277626f, 
    0.01500841f, -0.00542802f, -0.02531561f, -0.00947139f, -0.01443248f, -0.03910346f, 0.02828567f, -0.00593698f, 
    0.01565010f, 0.03036851f, 0.01706914f, -0.01909064f, -0.04124635f, 0.00707547f, -0.01112774f, 0.00774848f, 
    -0.03544810f, 0.02289592f, 0.00150633f, 0.00141446f, 0.00173559f, -0.00407087f, -0.00587097f, -0.02127756f, 
    -0.03674378f, 0.00924970f, -0.02011485f, -0.00568608f, -0.02420693f, -0.01381639f, -0.00695457f, -0.00580715f, 
    0.00924715f, -0.03304566f, 0.02510943f, 0.00441457f, 0.00537815f, 0.02937732f, -0.01823783f, -0.01961346f, 
    -0.00040795f, 0.02907751f, -0.03424611f, 0.01649175f, 0.01780124f, 0.02182304f, -0.00256466f, -0.02921031f, 
    -0.03078771f, -0.00197655f, -0.02295241f, -0.00763965f, -0.00827400f, 0.01949188f, 0.02197766f, 0.00920329f, 
    -0.00865769f, -0.01465955f, -0.00430979f, -0.01115975f, 0.03157840f, -0.00721517f, -0.00750137f, -0.02003150f, 
    -0.03061171f, -0.02140513f, 0.00646823f, 0.01604551f, 0.00548993f, -0.00878868f, 0.02555839f, -0.00694811f, 
    0.01069287f, 0.02144560f, -0.00095411f, 0.02010420f, -0.02553270f, -0.01264059f, 0.02001973f, 0.03168588f, 
    -0.00699669f, 0.01653705f, -0.02299681f, 0.00795537f, -0.02590444f, -0.00524381f, 0.00087072f, 0.02641211f, 
    0.00625988f, -0.00267347f, 0.00269346f, -0.03804500f, 0.02850781f, 0.01511663f, -0.03498616f, 0.03074920f, 
    -0.02396021f, 0.03169548f, -0.01792113f, -0.02641230f, -0.03652364f, -0.00050870f, -0.02265276f, -0.03023546f, 
    -0.00902290f, -0.01793696f, -0.02432709f, 0.02158924f, -0.00568782f, 0.00380945f, -0.03794279f, -0.03380593f, 
    0.00540509f, -0.02551559f, 0.00296506f, -0.01359035f, 0.02416943f, -0.03938245f, 0.02224530f, 0.00545045f, 
    -0.04199512f, -0.02779252f, 0.02791588f, -0.02335044f, -0.01023903f, -0.00195472f, -0.02657142f, 0.02494690f, 
    -0.03401835f, -0.02404532f, -0.00596291f, 0.01850117f, -0.01602677f, -0.04452692f, 0.02094140f, -0.02459258f, 
    0.01100204f, -0.00937748f, -0.00427976f, 0.02836727f, 0.00554095f, -0.00537738f, 0.01472616f, -0.00417122f, 
    0.01011625f, -0.03789917f, -0.00491077f, -0.00678430f, -0.02601130f, 0.00734660f, -0.02600588f, -0.00591321f, 
    -0.00372211f, 0.01809622f, 0.00058541f, 0.02959597f, -0.00878174f, -0.01258128f, 0.01761312f, -0.02578333f, 
    0.02817988f, -0.04488919f, -0.04521962f, -0.00209296f, -0.01666030f, -0.01175927f, -0.02678726f, 0.03021892f, 
    -0.01923806f, -0.01370969f, 0.00591912f, 0.02458581f, -0.03199300f, 0.00581895f, -0.01673670f, 0.03188812f, 
    0.01655683f, 0.03107072f, -0.02507807f, -0.00039184f, -0.02396723f, 0.01336879f, 0.00229385f, 0.01748521f, 
    0.01986694f, -0.00431196f, 0.01036352f, -0.00905259f, -0.03725045f, -0.01368806f, -0.00987467f, -0.01943989f, 
    0.01449161f, -0.03516214f, 0.02479166f, -0.02560646f, -0.00221067f, 0.00551477f, 0.02720342f, 0.02785655f, 
    0.01322157f, 0.00446724f, 0.02678057f, 0.02806186f, 0.00160666f, -0.02966909f, -0.03176359f, 0.03686398f, 
    -0.04429395f, -0.01892672f, 0.00159928f, -0.02311986f, -0.03811384f, -0.00565008f, -0.03922438f, -0.00111027f, 
    -0.04021839f, 0.01361223f, -0.01463520f, 0.03317890f, 0.00044358f, -0.02424441f, -0.02981656f, -0.00473477f, 
    0.02470498f, 0.02588649f, 0.00976504f, -0.03743393f, 0.02565968f, -0.01294874f, -0.01556479f, -0.03897311f, 
    -0.02380350f, -0.02114862f, 0.00737198f, 0.01408089f, 0.02423322f, -0.03682141f, -0.02861757f, 0.03263689f, 
    -0.02910092f, 0.00169909f, -0.02529063f, -0.00894009f, 0.01244501f, -0.02768921f, -0.03358441f, 0.01855290f, 
    -0.02286126f, 0.02820308f, 0.00672693f, -0.02036357f, -0.01816250f, -0.00974302f, -0.01255821f, 0.02345617f, 
    -0.02521822f, 0.01442706f, 0.01831014f, -0.00998947f, -0.03683047f, -0.00567523f, -0.03804417f, -0.03667207f, 
    0.01572032f, -0.01019282f, 0.01773176f, -0.00107070f, -0.04342294f, 0.01953628f, -0.00752058f, 0.00585298f, 
    -0.02830949f, -0.03263656f, 0.01252734f, -0.02557730f, -0.03345172f, -0.01698418f, 0.02988473f, -0.03743340f, 
    -0.01969235f, -0.03690148f, -0.02872837f, 0.00363087f, -0.00023004f, -0.03855854f, -0.02749387f, 0.03207065f, 
    0.03049015f, 0.00282300f, -0.02985684f, -0.00629052f, -0.00478367f, 0.02021789f, 0.03003711f, 0.03094011f, 
    0.02413299f, -0.00402334f, -0.03729673f, 0.02099268f, -0.02503190f, 0.01357186f, -0.04545299f, -0.01889539f, 
    0.00131856f, -0.04155023f, -0.02296733f, -0.00330658f, -0.02354555f, 0.02421831f, -0.01330825f, -0.00208628f, 
    -0.03116702f, -0.02216990f, -0.02295028f, 0.02127950f, -0.03605676f, 0.01055040f, 0.01237154f, -0.01595729f, 
    -0.02138096f, -0.04537114f, -0.03145128f, 0.02518024f, -0.04363171f, -0.02457942f, -0.02793132f, -0.03169142f, 
    -0.03248208f, 0.01390012f, -0.03923609f, 0.00633996f, 0.00762119f, -0.00810391f, 0.00411984f, -0.03722157f, 
    -0.01377456f, -0.02095399f, -0.04526546f, -0.01043310f, 0.00482574f, -0.02164717f, 0.03133190f, 0.02337636f, 
    0.03342599f, -0.00496456f, -0.01739765f, 0.03345318f, -0.01256228f, 0.00435901f, 0.01025918f, -0.02523365f, 
    0.02809106f, -0.02409736f, -0.02442151f, -0.03050187f, 0.02057639f, -0.03303091f, -0.02518811f, 0.02517626f, 
    -0.03402403f, -0.03638267f, 0.00268076f, -0.00212451f, 0.01329302f, 0.02620077f, 0.02501502f, -0.02775281f, 
    0.01752725f, -0.03364108f, -0.01533615f, 0.01366375f, -0.02974771f, 0.02344363f, -0.01028866f, 0.02869690f, 
    -0.04506414f, 0.01883622f, -0.04313106f, -0.02838894f, -0.01405458f, -0.01933478f, -0.04099393f, -0.04155000f, 
    -0.00268101f, -0.03250365f, -0.02581387f, -0.00993540f, -0.04115679f, 0.00460941f, 0.01348382f, -0.02764810f, 
    -0.03094443f, -0.01080056f, 0.01921680f, 0.02969006f, -0.00265938f, 0.00218831f, 0.02532317f, -0.00984803f, 
    0.02639890f, -0.01454036f, -0.03716759f, 0.02030815f, -0.01985665f, 0.03464432f, -0.02729784f, 0.00635850f, 
    -0.01938011f, 0.00527637f, 0.02406179f, -0.01884226f, -0.01794083f, 0.03474586f, 0.01657815f, -0.03051946f, 
    -0.00118757f, 0.01834562f, -0.03566008f, -0.00749929f, -0.01398405f, -0.00640479f, -0.00268795f, 0.02147811f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07148004f, 0.02471400f, 0.01560482f, 0.06377631f, 0.14076091f, -0.00999712f, 0.01186106f, 0.02036869f, 
    -0.01069585f, 0.02707544f, 0.00382627f, 0.04361529f, -0.00053355f, 0.12236065f, 0.01976065f, -0.03812650f, 
    0.03053441f, -0.02098344f, 0.09329845f, 0.00076386f, 0.02739854f, -0.04161418f, -0.02563800f, 0.00046302f, 
    -0.02081090f, 0.00058388f, -0.00225083f, -0.04720936f, 0.01782482f, -0.00307363f, -0.03205030f, 0.01478460f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.11788314f, -0.04079107f, -0.13732815f, -0.95437592f, -0.27426034f, -0.08193348f, 0.08132987f, 0.05886189f, 
    -0.03292429f, 0.25031155f, 0.07637715f, -0.51753742f, -0.10505480f, 0.28384617f, 0.26602381f, 0.21965671f, 
    0.03382851f, 0.05687655f, -0.17406644f, -0.15538526f, 0.00776220f, 0.12632884f, -0.09667178f, 0.08454456f, 
    0.04727117f, -0.14657901f, 0.13378070f, 0.36915120f, -0.00354215f, -0.03748946f, 0.03974956f, 0.09897649f, 
    -0.06735753f, 0.13310724f, -0.01738699f, -0.37491304f, -0.12313240f, -0.17800486f, 0.07474671f, 0.09665608f, 
    -0.12693590f, -0.19843009f, -0.07220743f, -0.05678863f, 0.09909855f, 0.42112041f, -0.05814229f, 0.34288380f, 
    -0.06197277f, 0.14010449f, 0.42215979f, 0.11252964f, -0.17155454f, 0.10752267f, 0.09664991f, 0.13064383f, 
    -0.10413024f, 0.04762233f, -0.02932694f, -0.42276296f, 0.05781819f, -0.18145847f, 0.02682473f, 0.13170195f, 
    0.23233747f, 0.05533430f, -0.00635643f, 0.38218576f, -0.45841309f, -0.01338615f, -0.15283655f, 0.03510169f, 
    -0.10149832f, 0.13517506f, -0.03512257f, 0.09825259f, -0.06618811f, -0.04387956f, -0.52893758f, 0.52760208f, 
    -0.07453523f, -0.00659948f, -0.53308678f, 0.04888158f, -0.09917691f, -0.05347644f, 0.07275528f, -0.12265300f, 
    0.15679049f, 0.03301887f, -0.07500186f, -0.15596093f, 0.09871790f, 0.14592184f, -0.00072888f, 0.00537478f, 
    0.02390896f, 0.00808822f, -0.11992931f, -0.42195371f, 0.08556598f, -0.11836125f, -0.14287840f, 0.08535965f, 
    0.16122806f, 0.23993263f, -0.12462809f, 0.15795922f, -0.09036832f, -0.02179137f, -0.57179767f, -0.51124120f, 
    0.16547659f, -0.02036657f, 0.13624936f, 0.16373344f, 0.00983922f, -0.08263966f, -0.00380485f, -0.12641349f, 
    -0.16926280f, 0.02408843f, 0.11964007f, 0.46755603f, -0.13818476f, -0.15884295f, -0.11855075f, 0.13746628f, 
    0.49352983f, 0.11241901f, 0.11069345f, 0.29706329f, 0.22585721f, 0.12917350f, 0.17393914f, 0.01553048f, 
    -0.06790249f, 0.44243747f, 0.05677316f, -0.24602199f, -0.07731686f, -0.16522324f, -0.11434124f, -0.49937794f, 
    -0.09135881f, 0.14703238f, -0.22322163f, -0.08026376f, -0.16647626f, 0.03272300f, 0.08642986f, 0.12709413f, 
    -0.06658322f, -0.07561053f, -0.06732405f, -0.12471046f, 0.11859837f, -0.04831073f, 0.07941473f, -0.17019692f, 
    0.23515446f, 0.01618938f, 0.02516062f, 0.24285464f, 0.17789572f, -0.17394246f, -0.00582719f, -0.04130170f, 
    -0.10172695f, -0.82705361f, 0.07027336f, -0.45262948f, -0.14714627f, 0.23201253f, 0.37522066f, -0.09590544f, 
    -0.09600843f, 0.05965056f, -0.38926786f, -0.01159267f, 0.10058656f, -0.11313565f, 0.05906500f, -0.00710699f, 
    -0.01330653f, -0.08802932f, -0.10784302f, -0.16022135f, -0.05015750f, -0.08092843f, 0.10415930f, 0.07297380f, 
    -0.23524620f, 0.03664165f, -0.01143023f, -0.37332711f, 0.58942688f, -0.07169985f, -0.01162675f, 0.04341950f, 
    -0.11893075f, -0.11962938f, 0.12458704f, 0.19612114f, 0.15806243f, -0.62842840f, 0.07642382f, 0.44719493f, 
    -0.12529705f, -0.14849362f, -0.40863445f, 0.08278356f, -0.09595264f, -0.13316818f, -0.04665536f, -0.09782659f, 
    -0.02947206f, -0.05534832f, 0.05130893f, -0.27029711f, 0.11233194f, -0.04876461f, -0.15544912f, -0.06916030f, 
    -0.20935254f, 0.09057213f, 0.00361249f, 0.26027781f, -0.56748217f, -0.04882654f, -0.12822174f, -0.09488459f, 
    0.06509571f, -0.30849388f, -0.00067988f, 0.41573647f, -0.08959018f, -0.65931481f, 0.07117604f, -0.09675038f, 
    -0.03683742f, -0.01442895f, -0.29699606f, -0.00748442f, 0.17736225f, -0.11785708f, 0.15601534f, -0.04687023f, 
    0.07910387f, -0.09105053f, 0.16290799f, 0.33027631f, -0.11925647f, -0.01955542f, 0.13493718f, 0.08764269f, 
    -0.12082776f, 0.04655619f, 0.05004159f, 0.67467523f, -0.14540556f, -0.01633388f, 0.12953044f, 0.00301157f, 
    -0.14503974f, -0.30994329f, 0.15256669f, -0.27405208f, -0.00114273f, -0.39798856f, 0.07381375f, 0.20165747f, 
    -0.07544103f, 0.15330581f, 0.47271094f, -0.12917808f, 0.12831654f, -0.07237607f, 0.13095024f, -0.00560270f, 
    -0.13301307f, -0.06487545f, -0.17094998f, -0.09601780f, 0.03077002f, 0.04785645f, -0.05244588f, -0.09314734f, 
    -0.08492189f, -0.08186258f, -0.05610029f, -0.21755238f, -0.35213983f, 0.15539764f, 0.10704026f, -0.06236860f, 
    -0.02248334f, 0.47319973f, 0.02269747f, 0.33864009f, 0.12729402f, -0.07946888f, 0.53657192f, -0.14791985f, 
    0.13745056f, 0.02099328f, -0.55665404f, -0.06142610f, -0.06166865f, 0.11184724f, 0.06523831f, 0.08753217f, 
    -0.11230760f, 0.08568141f, -0.07671005f, -0.60059506f, -0.15726107f, -0.05473628f, -0.02747688f, -0.02801571f, 
    -0.88778514f, 0.04884247f, -0.04818354f, 0.37466326f, 0.12936035f, -0.03047156f, -0.15352345f, -0.11698319f, 
    -0.05621883f, 0.43464401f, 0.13566694f, 0.14338382f, -0.01976691f, 0.13177478f, -0.44890022f, -0.05173668f, 
    -0.12673831f, -0.05578355f, 0.26468137f, 0.16557981f, -0.16592090f, -0.14446878f, 0.04123507f, 0.01339179f, 
    -0.03990661f, 0.07554640f, -0.08192179f, -0.24051256f, -0.01451362f, -0.05669134f, -0.04357205f, 0.15349789f, 
    -0.65857083f, 0.02156319f, 0.01137912f, 0.08216244f, 0.23752868f, 0.02777346f, 0.10703083f, 0.09881849f, 
    0.04563443f, -0.42413762f, -0.07530138f, 0.09197468f, 0.11069223f, 0.48481426f, 0.09277655f, -0.44285274f, 
    -0.14627554f, -0.15308113f, -0.53473562f, 0.10890599f, -0.01364033f, 0.15189818f, 0.12560739f, 0.01330123f, 
    -0.02107703f, 0.03632759f, 0.15286967f, 0.24282816f, -0.08591621f, -0.05288634f, 0.17962067f, -0.08450130f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01705528f, -0.00753033f, 0.02860528f, -0.07602125f, 0.09552028f, 0.16116124f, 0.11879243f, 0.10568181f, 
    -0.22646886f, -0.04334007f, -0.02929519f, -0.04545561f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
