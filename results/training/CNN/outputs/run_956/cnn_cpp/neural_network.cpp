#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.01725185f, 0.72814465f, 0.00751798f, -0.82787770f, -0.61530346f, 0.74502140f, 0.13506003f, -0.39594370f, 
    0.67099130f, 0.26631731f, -0.17292595f, -0.25179678f, -0.06529983f, 0.25539261f, -0.10418233f, -0.00284618f, 
    0.03449072f, -0.07643870f, 0.04183172f, -0.10668761f, -0.05191695f, -0.12938850f, 0.10079531f, 0.13170336f, 
    0.05079559f, 0.40174147f, 0.55717611f, 0.80485731f, 0.65936506f, 0.45364454f, 0.75575972f, -0.12098659f, 
    -0.82368767f, -0.36939946f, 0.12377461f, -0.03881676f, 0.39690962f, 0.03263153f, 0.09446934f, -0.47417957f, 
    -0.00352457f, -0.25131339f, 0.13587812f, -0.30099282f, -0.22418386f, -0.12084232f, 0.20620529f, -0.09067886f, 
    0.15356748f, -0.06022115f, 0.73684484f, -0.54617566f, 0.17031157f, 0.28918019f, -0.45052281f, 0.05986045f, 
    -0.61999542f, -0.27718374f, -0.48539552f, -0.44534928f, -0.23766175f, -0.43727806f, -0.24568108f, -0.34400657f, 
    -0.37128574f, 0.07751218f, -0.14047515f, -0.19704726f, -0.04254374f, -0.23861000f, -0.00222093f, -0.35921904f, 
    0.30971774f, -0.04954822f, 0.10571576f, 0.04295428f, -0.38765895f, -0.19448176f, 0.94900560f, 0.76241481f, 
    0.30370355f, 0.26309007f, 0.13703677f, 0.15170233f, -0.58190745f, 0.33634946f, 0.58204317f, -0.17595349f, 
    0.06186770f, -0.41139328f, 0.16028850f, 0.06001113f, -0.09039485f, -0.00443040f, -0.13030471f, -0.01259364f, 
    0.06311661f, -0.09764505f, 0.31274846f, -0.13096358f, 0.80797887f, 0.59607071f, -0.62975538f, 0.61849219f, 
    0.11391263f, 0.70001543f, 0.12590671f, 0.05773940f, 0.42532179f, 0.54641068f, -0.00077142f, -0.08701827f, 
    -0.11789956f, -0.25124934f, -0.02831725f, -0.09595238f, 0.06283182f, -0.36073187f, -0.01637710f, 0.12092023f, 
    -0.34248742f, -0.29738405f, -0.06045312f, -0.02710100f, -0.00380889f, 0.63624662f, 0.25133905f, -0.61296600f, 
    -0.56625676f, 0.68962282f, -0.38204849f, -0.40450537f, 0.45862493f, 0.08101176f, -0.02748799f, -0.56783605f, 
    -0.34916028f, 0.15333578f, -0.48079282f, -0.62682557f, 0.23346652f, 0.04458352f, 0.03768372f, -0.14540711f, 
    -0.33872804f, -0.17129807f, 0.00428076f, 0.28700507f, 0.13911696f, -0.19635147f, -0.30009341f, -0.83372253f, 
    -0.31808019f, 0.16955388f, -0.35775468f, -0.28128120f, -0.02425082f, -0.50173420f, -0.45520136f, 0.50371277f, 
    0.13665035f, 0.38043466f, 0.24143092f, -0.15255424f, -0.01278706f, -0.10404690f, -0.07335213f, 0.31135079f, 
    -0.09181426f, 0.12741652f, -0.12067889f, -0.21977262f, -0.21044214f, 0.01554579f, 0.07308684f, 0.76258093f, 
    -0.51656383f, 0.63454431f, -0.06547248f, 0.65579003f, -0.09307262f, 0.08525866f, 0.30910307f, 0.32011539f, 
    0.29106373f, 0.01621465f, -0.01006889f, -0.16591421f, 0.51315230f, -0.07336972f, 0.26035461f, -0.22039425f, 
    -0.18812960f, -0.14700729f, -0.18293282f, 0.17936671f, -0.20682673f, 0.20577540f, 0.22918989f, -0.07852922f, 
    -0.68770683f, -0.55069101f, 0.57541972f, 0.12665655f, 0.08585328f, 0.65810150f, 0.41199660f, 0.83751154f, 
    -0.05301503f, 0.00580024f, -0.09349484f, -0.44844934f, -0.17630062f, -0.20258254f, -0.34512880f, 0.13905418f, 
    -0.11460425f, 0.04235895f, -0.26430431f, 0.00672769f, -0.42490521f, 0.08966639f, 0.05009422f, -0.01506986f, 
    -0.27287960f, -0.79033297f, 0.15810174f, 0.36343905f, 0.17049301f, 0.56930000f, 0.29046699f, 0.69565094f, 
    0.45353305f, 0.35169289f, 0.46302512f, -0.04868643f, -0.26944384f, 0.10768356f, -0.31979850f, -0.13027899f, 
    0.23361799f, 0.08199222f, -0.34020337f, 0.27994215f, -0.01485857f, 0.22052914f, -0.23141292f, -0.08577065f, 
    -0.00624392f, 0.05588558f, 0.13950446f, 0.34713402f, 0.44066742f, -0.24010411f, 0.44627407f, 0.29193234f, 
    -0.42247474f, 0.40313810f, 0.19583479f, 0.24991433f, 0.33083808f, -0.09333988f, 0.20954455f, 0.32286429f, 
    0.10927144f, -0.09396660f, -0.05501654f, -0.14171006f, 0.22051340f, -0.29812282f, 0.29992414f, 0.48615512f, 
    -0.08118099f, 0.15178053f, 0.22343589f, -1.04498196f, 0.48233369f, -0.13136439f, -0.41643512f, -0.74205983f, 
    0.38247210f, 0.62747931f, -0.04373210f, 0.44290227f, -0.08464353f, -0.01736264f, 0.06655349f, -0.42434481f, 
    0.22738272f, 0.24785993f, 0.07140834f, -0.10198457f, -0.09874871f, -0.06409308f, -0.15893930f, 0.38919014f, 
    0.26481020f, 0.30605084f, 0.24705207f, 0.37344190f, -0.88520741f, -0.03242996f, 0.41937220f, 0.00671814f, 
    0.33156815f, 0.21320157f, -0.31591094f, -0.48988673f, -0.54207265f, -0.53432536f, -0.17218177f, 0.09895287f, 
    0.42460352f, 0.55864137f, -0.23602724f, -0.34003425f, -0.14386740f, -0.07455494f, 0.27841905f, 0.17737849f, 
    -0.18073243f, -0.00986867f, -0.20601463f, 0.04784410f, -0.23469232f, 1.02524531f, 0.22719994f, 0.09270751f, 
    -0.28326061f, -0.69007659f, -0.25182787f, 0.20425527f, 0.29708278f, 0.01306376f, 0.62066793f, 0.31353328f, 
    -0.14779484f, 0.22697090f, -0.39472175f, -0.14777687f, -0.07051845f, -0.37545386f, 0.03501480f, -0.42922676f, 
    0.05571621f, -0.24921151f, -0.27404040f, -0.31327459f, -0.11115364f, -0.36209595f, -0.46872929f, 0.26030001f, 
    -0.24510716f, -0.52896357f, -0.19573130f, 0.47037771f, 0.48092774f, -0.36489251f, 0.27994180f, 0.90526527f, 
    0.09980703f, -0.05618545f, 0.30513233f, 0.00461022f, -0.22942141f, -0.14859885f, -0.21389310f, -0.05438044f, 
    0.18236226f, -0.10117797f, -0.48927057f, -0.02199573f, -0.22368629f, -0.24831815f, 0.28341407f, -0.15292621f, 
    0.91224468f, -0.43378529f, -0.57982337f, -0.43858519f, 0.83270240f, -0.27222154f, -0.57831866f, -0.00436644f, 
    -0.46493205f, 0.32550579f, 0.24584915f, 0.30816159f, 0.38991708f, -0.16923499f, -0.01316287f, -0.16497315f, 
    0.13587576f, -0.10378350f, 0.12585841f, 0.18845701f, -0.04827723f, -0.12407888f, -0.01308686f, 0.17194279f, 
    0.25461683f, 0.10083108f, 0.72442633f, 0.68950611f, 0.27702063f, -0.42456290f, -0.23844643f, 0.35737970f, 
    0.45305556f, 0.02377469f, -0.66075599f, -0.15160505f, -0.41621509f, 0.29503942f, -0.04879637f, 0.21015026f, 
    0.07340191f, -0.27887073f, -0.09263967f, -0.00477166f, -0.12965348f, -0.05645986f, 0.30650419f, -0.05009657f, 
    0.02664809f, -0.63043016f, 0.87966716f, 0.49359268f, -0.28377327f, 0.63304168f, 0.23846185f, 0.35292807f, 
    0.68223244f, -0.13521135f, -0.22949968f, -0.17086716f, -0.05324836f, -0.02742745f, -0.19538203f, -0.16275543f, 
    0.08817573f, 0.07230568f, -0.05128793f, -0.23732746f, -0.35172528f, -0.07279577f, 0.02052772f, 0.08717114f, 
    0.34496465f, 0.20682935f, 0.41480783f, 0.22810803f, 0.14671536f, 0.49841663f, 0.28600967f, -0.35611179f, 
    -0.80689460f, 0.02676412f, -0.40442795f, 0.35368147f, 0.31629580f, 0.39920333f, 0.20486733f, 0.18222833f, 
    -0.21989018f, -0.17437099f, 0.09876691f, 0.02730443f, -0.39795384f, 0.51059169f, 0.43158576f, -0.03388248f, 
    -0.00432227f, 0.00074407f, -0.00188011f, 0.71129876f, -0.15422410f, -0.16353442f, -0.60129112f, 0.72675920f, 
    0.55440295f, 0.22484468f, 0.23695868f, -0.31174687f, -0.48911089f, 0.04828665f, 0.07194362f, -0.18691550f, 
    0.08837824f, 0.06198272f, 0.11986820f, 0.24543135f, -0.02738872f, 0.01049821f, -0.17906936f, -0.11836822f, 
    0.44485161f, 0.29910740f, -0.16648044f, -0.25804090f, 0.80939364f, 0.25765419f, 0.88298041f, 0.17277142f, 
    -0.23471877f, 0.41695303f, -0.65486342f, 0.08778650f, 0.44540516f, 0.32776886f, -0.07420152f, -0.27615958f, 
    -0.08639297f, 0.19328465f, -0.57101566f, 0.17223057f, 0.14753263f, 0.19412783f, -0.28045064f, -0.07674330f, 
    -0.03397770f, -0.08136930f, 0.23882489f, 0.19477481f, 0.15361021f, -0.20400609f, -0.45185116f, 0.69253343f, 
    0.44758180f, -0.65143830f, -0.31774956f, 0.51818568f, -0.58191150f, -0.46127260f, -0.37358403f, 0.10771081f, 
    0.39495966f, -0.30879006f, -0.03489516f, 0.36330828f, -0.03552116f, -0.25644517f, -0.12509386f, -0.23687959f, 
    0.13059178f, -0.24128948f, -0.03563014f, 0.45651227f, 0.28215796f, -0.11768559f, -0.21434949f, 0.02637666f, 
    -0.51942199f, -0.16904335f, -0.44290814f, -0.26236662f, -0.13796893f, -0.34970984f, 0.55286193f, -0.00925192f, 
    0.21127227f, -0.17536600f, -0.49052691f, -0.12733062f, -0.14405744f, 0.16112225f, 0.56636840f, -0.30957192f, 
    0.21774480f, 0.08115309f, -0.32467771f, -0.11247486f, 0.44229650f, 0.13304673f, 0.50885129f, 0.16367112f, 
    -0.88354701f, -0.53798002f, -0.55583668f, -0.31066528f, 0.39683735f, 0.48520225f, 0.43579382f, 0.32494536f, 
    0.47999254f, -0.18040082f, -0.19446309f, -0.24595994f, -0.01042204f, -0.17663838f, -0.12831706f, 0.22384751f, 
    0.11456375f, -0.07745488f, 0.03090356f, 0.22937918f, -0.30559468f, -0.00380457f, -0.08165397f, 0.23823024f, 
    0.27956432f, -0.73356062f, -0.66737688f, -0.62129807f, -0.15832841f, -0.29839328f, 0.48173296f, 0.05972398f, 
    0.16704747f, 0.54117817f, -0.27835098f, -0.18371186f, -0.31379238f, -0.17314507f, -0.09308023f, 0.03134598f, 
    0.27850863f, 0.02644673f, 0.03915600f, -0.05466771f, -0.07567070f, -0.13877147f, -0.12586783f, -0.13866071f, 
    -0.04929861f, -1.01145411f, 0.44688752f, 0.15895307f, 0.60648358f, -0.76413363f, 0.46930295f, -0.00068956f, 
    0.20343210f, 0.39751247f, 0.15584414f, 0.05864311f, -0.37334889f, 0.08745751f, 0.27321506f, -0.07453960f, 
    0.05333667f, 0.21373118f, -0.29366291f, -0.41861689f, -0.19662315f, -0.07833388f, -0.02986591f, -0.11459930f, 
    0.00271755f, -0.15660213f, 0.55786878f, -0.11303543f, 0.09882333f, 0.72502393f, -0.12592319f, 0.15013704f, 
    -0.60561353f, 0.07749852f, 0.24226637f, 0.01094732f, 0.20487145f, 0.28825581f, 0.30898637f, -0.11364533f, 
    0.21480852f, -0.12109538f, 0.21332286f, -0.26062462f, -0.10773259f, -0.00673710f, -0.65642411f, 0.05079223f, 
    -0.20137706f, 0.17680568f, 0.40092540f, 0.17599455f, 0.85614181f, 0.48521692f, 0.61722398f, -0.32917267f, 
    -0.37259132f, 0.17207462f, -0.08244649f, 0.20712607f, -0.43536565f, -0.24844493f, -0.14794551f, -0.20630467f, 
    -0.06158683f, -0.06269614f, 0.02106053f, 0.05995522f, 0.10467562f, 0.13283901f, -0.28241959f, -0.22155774f, 
    -0.19433630f, -0.51849455f, -0.07274250f, -0.17744359f, 0.71635151f, -1.25130177f, 0.62805992f, 0.64160722f, 
    0.03461505f, 0.72962481f, 0.41319638f, 0.45263657f, -0.21601827f, -0.03360164f, -0.19895580f, 0.03089690f, 
    -0.08018975f, 0.29767194f, -0.08032571f, -0.15024959f, -0.16371129f, -0.03484808f, -0.10352729f, -0.14041044f, 
    -0.17854406f, 0.05165014f, -0.04074094f, -0.22470614f, -0.03330270f, -0.32447949f, -0.50376046f, 0.26163843f, 
    0.32138130f, 0.25825116f, 0.47041619f, 0.19284602f, -0.15666853f, 0.19362423f, -0.35166997f, -0.05022007f, 
    0.30959925f, -0.15217552f, 0.74835163f, 0.10746135f, 0.56093580f, 0.31662920f, -0.11206967f, -0.04350127f, 
    -0.43616375f, 0.28797686f, -0.12686759f, -0.14427203f, 0.16938356f, 0.43070233f, -0.70998043f, 0.56826949f, 
    0.17058696f, -0.21098611f, 0.77804297f, -0.04237596f, 0.81712657f, 0.25544024f, -0.43380788f, -0.08337567f, 
    -0.44704348f, 0.05532767f, 0.43209121f, -0.06588230f, 0.10527996f, 0.21348074f, 0.04380593f, -0.00614698f, 
    0.25443155f, 0.10977089f, 0.28406510f, 0.10415766f, 0.00961529f, -0.04629282f, -0.02385428f, -0.34361526f, 
    0.32064712f, 0.19571361f, 0.81244206f, -0.46846998f, -0.53612804f, -0.09699328f, -0.64152408f, -0.72324437f, 
    -0.16016012f, 0.41844752f, 0.24593121f, 0.33769909f, 0.21475156f, -0.21654502f, -0.30222565f, 0.17116694f, 
    -0.16958484f, 0.03155121f, -0.00127925f, 0.09501819f, -0.06295300f, -0.05208733f, 0.18708457f, 0.20263422f, 
    -0.69575596f, -0.77348626f, -0.36402056f, 0.72876579f, 0.28635475f, 0.63844752f, 0.44912434f, 0.38961819f, 
    0.35275376f, -0.43872184f, -0.08747618f, 0.21061143f, -0.24561037f, 0.27068064f, 0.28895545f, 0.02061861f, 
    0.13508968f, -0.19628282f, -0.01933943f, 0.07729653f, 0.02726997f, 0.19693531f, 0.00325438f, -0.09308725f, 
    -0.28489000f, 0.05071331f, -0.43830577f, -0.27500087f, 0.48390010f, -0.25707939f, -0.60913861f, -0.42572403f, 
    -0.89095330f, -0.20211740f, -0.10682956f, -0.25946862f, -0.07777549f, -0.11957134f, -0.32866865f, -0.33527368f, 
    -0.44801086f, -0.06912301f, -0.17367896f, -0.11162179f, -0.23964460f, -0.41557613f, 0.32338923f, 0.04625729f, 
    -0.33133742f, -0.01407438f, -0.45366669f, 0.40069944f, -0.36914045f, -0.76601613f, -0.35160965f, 0.79295200f, 
    0.40518704f, 0.20291683f, 0.53957373f, 0.05937977f, -0.08791773f, -0.29121891f, -0.01323028f, -0.31774381f, 
    -0.42530480f, 0.28254798f, -0.02285963f, 0.19784254f, -0.00836637f, 0.27748039f, -0.17454161f, -0.36492616f, 
    -0.15998957f, -0.44330096f, 0.12633336f, -0.00712904f, 0.76412392f, -0.47377807f, -0.70831871f, -0.10812035f, 
    0.48500890f, -0.72636551f, -0.37080559f, -0.71766251f, -0.38652456f, 0.25651506f, -0.29799944f, 0.35132229f, 
    0.37207359f, -0.16027993f, -0.14077210f, 0.11907358f, -0.08050714f, -0.00211533f, 0.24442697f, 0.19552332f, 
    -0.01911732f, 0.27699339f, -0.09919082f, 0.08689282f, 0.62260634f, 0.61806959f, -0.61607367f, -0.80815423f, 
    -0.24896096f, 0.08195601f, 0.34840414f, 0.27002195f, 0.44954330f, 0.10489550f, -0.12852591f, 0.29194829f, 
    0.16156244f, 0.08517642f, 0.17033626f, 0.29886094f, -0.04090635f, 0.24261791f, 0.32789135f, 0.07790180f, 
    -0.20793054f, 0.10689610f, 0.21046816f, -0.28203744f, -0.02922527f, 0.17429161f, 0.96114272f, 0.17848608f, 
    0.10263880f, 0.67326111f, 0.33174422f, -0.79569542f, -0.51962411f, -0.68715489f, -0.25434214f, 0.24994817f, 
    -0.27000549f, -0.09591915f, 0.06385174f, -0.22221403f, 0.40662286f, -0.17108020f, -0.23101926f, 0.04020314f, 
    -0.09993556f, -0.10925166f, 0.19093147f, 0.26986629f, -0.25717756f, 0.34528482f, 0.82069641f, -0.46241075f, 
    0.03425949f, -0.39125744f, -0.36935866f, 0.63479614f, -0.71930891f, 0.18209764f, 0.55667609f, 0.00719587f, 
    -0.15129898f, 0.11880751f, -0.40847984f, 0.10536559f, 0.15812568f, 0.08081890f, -0.00449290f, 0.03529340f, 
    0.12556072f, 0.34151089f, 0.28956017f, 0.13539293f, 0.21100788f, 0.19312982f, -0.27368912f, 0.96291691f, 
    0.71009147f, 0.24646014f, 0.20862889f, -0.09178100f, -0.67206746f, 0.34867108f, -0.36637071f, 0.16898018f, 
    0.26835409f, 0.18555169f, 0.25859845f, 0.06866726f, -0.01375529f, 0.17559302f, 0.08886320f, 0.14601606f, 
    0.01894342f, 0.04958747f, 0.33628282f, -0.28530714f, 0.11429854f, 0.24374045f, 0.21024550f, -0.15894507f, 
    0.19003648f, 0.30273327f, 0.53155136f, 0.52456236f, 0.38342521f, -0.20726785f, -0.60171974f, -0.13943970f, 
    0.09799827f, -0.06113166f, 0.45026374f, -0.28613433f, -0.03161772f, 0.19784619f, -0.31431565f, 0.15699010f, 
    0.34958643f, 0.31884325f, -0.07535561f, 0.50557464f, 0.26852867f, -0.01803007f, 0.19946373f, 0.15740983f, 
    0.15949889f, -0.69433004f, 0.32045305f, 1.13074863f, -0.84558105f, 0.24583726f, -0.53534847f, 0.60404694f, 
    0.06866518f, 0.02762472f, 0.16741575f, -0.14184606f, 0.62596309f, -0.13480163f, -0.09053697f, -0.31105828f, 
    -0.10989116f, -0.24187301f, -0.12963997f, -0.30133805f, 0.04591998f, 0.09658958f, 0.09639670f, 0.13395584f, 
    0.01826007f, -0.12211154f, -0.91105026f, -0.58144814f, -0.20289527f, -0.43569258f, -0.44334978f, 0.05982997f, 
    -0.62908745f, 0.12385218f, 0.41954824f, 0.02425296f, 0.04301565f, 0.07680808f, -0.21861450f, 0.13103792f, 
    -0.06631502f, 0.10296065f, 0.22555763f, 0.16262759f, 0.08571447f, -0.13555805f, -0.25079778f, 0.35290509f, 
    0.03775283f, -0.26174724f, 0.03010604f, 0.05880326f, 0.27170092f, 0.77952194f, -0.05123317f, -1.09978187f, 
    -0.66133708f, -0.39411217f, 0.12825319f, 0.01030410f, 0.30893487f, 0.41638502f, 0.31945416f, -0.13090563f, 
    0.04310665f, 0.15245432f, -0.34609956f, -0.00542319f, 0.20830232f, 0.03804252f, 0.12603004f, -0.15776797f, 
    0.20757861f, -0.16369836f, -0.20281959f, 0.19615518f, -0.55171525f, -0.60389471f, -0.61781341f, -0.55342883f, 
    -0.35539860f, -0.37854162f, 0.32981217f, 0.39212048f, -0.28094366f, -0.07135666f, 0.35891026f, 0.37286660f, 
    0.23200463f, 0.13399421f, 0.31469554f, -0.10856407f, -0.28248721f, -0.31003907f, -0.23928152f, -0.11435691f, 
    -0.14026862f, -0.17490798f, 0.51745713f, -0.26074570f, -0.18314961f, 0.94846970f, 0.64014524f, 0.54929763f, 
    0.82976955f, 0.23851022f, 0.54823422f, 0.03763241f, -0.42893729f, 0.31490004f, -0.22007746f, -0.14316201f, 
    -0.18378481f, -0.07380538f, 0.16670680f, 0.02785225f, 0.22922805f, -0.07821625f, -0.00449456f, 0.11799370f, 
    0.05974841f, 0.16264394f, -0.01805690f, 0.48276335f, -0.05397483f, 0.20442255f, 0.35545716f, 0.66327620f, 
    -0.54677993f, 0.75969410f, 0.69301921f, 0.32095578f, 0.02158360f, 0.55739874f, 0.55495483f, 0.10011748f, 
    -0.40363312f, -0.23240177f, -0.07070506f, -0.29880798f, 0.18341634f, -0.18077940f, -0.06263052f, 0.17609994f, 
    0.01491547f, -0.02964638f, 0.39498845f, -0.35665292f, -0.19406462f, -0.27407482f, -0.27725628f, 0.37918672f, 
    -0.78159958f, 0.21478650f, 0.77444768f, -0.15607640f, -0.81973338f, -0.39797664f, 0.38414299f, -0.31615639f, 
    -0.52588201f, 0.22153215f, 0.14124465f, 0.28037560f, -0.21300851f, 0.37315968f, -0.11810847f, 0.03974801f, 
    -0.10862017f, 0.01908310f, -0.01170481f, 0.01278680f, 0.12746635f, 0.23420480f, 0.08221401f, 0.02667874f, 
    -0.02737256f, -0.06052395f, -0.42046157f, -0.75873756f, -0.65012521f, 0.28153473f, 0.31384543f, -0.03182301f, 
    0.07791013f, 0.08437873f, 0.43433031f, 0.33762416f, 0.05665759f, -0.11368556f, -0.22629674f, 0.04921212f, 
    0.41107526f, 0.20846166f, -0.33193448f, 0.36077848f, -0.10171895f, -0.07395536f, -0.21467501f, 0.37987795f, 
    -0.27335730f, 0.89364415f, 0.44096488f, -0.74646372f, -0.68506396f, -0.79399741f, -0.10361706f, 0.44564152f, 
    -0.08533809f, -0.24496992f, 0.14106800f, 0.06503745f, 0.14823741f, -0.12142323f, -0.22114162f, -0.02410979f, 
    -0.14912193f, 0.00191002f, -0.07595345f, 0.01651931f, -0.17444763f, 0.12549607f, -0.01121373f, 0.25500706f, 
    -0.04583170f, 0.28209576f, -0.26340672f, -1.08395660f, -0.65706050f, 0.36928946f, 0.09619243f, -0.73371828f, 
    0.69773996f, 0.70984524f, -0.58344567f, 0.26814806f, 0.62101609f, 0.19717498f, -0.04649602f, -0.11592022f, 
    -0.09174000f, -0.35103774f, -0.04139071f, -0.07359289f, -0.16327801f, -0.22659287f, 0.00045176f, -0.08701921f, 
    0.24147202f, -0.07186319f, 0.26680928f, 0.24485497f, 0.63346678f, 0.73077887f, 0.47621298f, 0.37614349f, 
    0.14432319f, 0.32848185f, 0.02582556f, -0.30051535f, 0.34368676f, 0.21640691f, 0.26425168f, 0.11547565f, 
    0.17423993f, 0.27318776f, 0.25469053f, -0.09218576f, 0.13765547f, 0.26246545f, 0.25887561f, 0.10576607f, 
    0.09746726f, 0.44939592f, -0.18206303f, 0.26170644f, -0.73248959f, 0.90588748f, 0.05793905f, -0.74663365f, 
    -0.10527288f, -0.54923856f, 0.48612776f, 0.44991174f, 0.04079570f, -0.62386668f, 0.01339784f, 0.20158586f, 
    -0.00013646f, -0.33141097f, -0.40906593f, -0.12288998f, -0.04279531f, -0.13048787f, 0.03629174f, 0.04650539f, 
    0.18399048f, -0.09316476f, 0.04945742f, -0.04229796f, -0.27862504f, -0.58284414f, 0.80141735f, 0.63967460f, 
    0.33954924f, -0.05032057f, -0.82231331f, 0.19748624f, 0.31475338f, -0.73539346f, -0.13649665f, 0.31671971f, 
    0.30373192f, -0.11460905f, 0.38339815f, 0.23814817f, 0.32989311f, 0.26723623f, -0.01276230f, 0.21510930f, 
    0.14169854f, 0.22572319f, -0.07974149f, -0.08428691f, 0.25715309f, -0.12613237f, -0.48780066f, -0.19746484f, 
    -0.55281425f, 0.56550735f, -0.54536039f, 1.06114435f, 0.85956979f, -0.43565467f, 0.14455752f, 0.25555450f, 
    -0.30488876f, -0.34041768f, -0.01139546f, -0.36689365f, 0.31860739f, -0.14057721f, 0.14601415f, -0.14589129f, 
    -0.14882605f, -0.04892735f, 0.04153152f, -0.20299999f, 0.19630358f, 0.01145156f, -0.13463910f, -0.53947377f, 
    -0.67756128f, -0.36242756f, -0.57014936f, 0.04992087f, -0.27606022f, 0.55240095f, 0.45195800f, -0.28550908f, 
    0.51424563f, -0.07531734f, -0.23079295f, 0.41053978f, -0.35356209f, -0.06795890f, 0.05818222f, -0.23510243f, 
    0.06830367f, -0.20183621f, -0.22836639f, 0.16699949f, 0.14499424f, 0.13502759f, 0.09274394f, 0.15288897f, 
    -0.17116337f, -0.51512331f, -0.00823451f, -0.28643548f, -0.11103250f, -0.36832723f, -1.00785732f, -0.56455487f, 
    -0.12996671f, -0.63077557f, 0.19143097f, 0.26772240f, 0.13107096f, -0.22602601f, 0.28811079f, 0.12667096f, 
    -0.13355698f, -0.01496534f, 0.39204499f, 0.14364968f, 0.44526455f, 0.12543632f, 0.16217080f, -0.14389729f, 
    -0.12388393f, -0.40069139f, 0.00512933f, 0.68937951f, 0.55690914f, 0.26807001f, 0.41145885f, 0.57721394f, 
    0.07013457f, -0.17408684f, 0.10502669f, 0.04264922f, -0.17386259f, 0.42515129f, -0.30442530f, -0.39257407f, 
    -0.09248926f, -0.51742667f, 0.28387877f, -0.22519852f, -0.46566492f, 0.18362685f, 0.43290013f, -0.02266551f, 
    0.27773416f, -0.09448652f, -0.47125256f, -0.09698118f, 0.54736978f, -0.15875331f, -0.02571480f, 0.24904259f, 
    -0.02551924f, -0.30751404f, 0.46002099f, 0.51924413f, -0.26530343f, -0.27141351f, 0.12256008f, -0.16083214f, 
    -0.50984299f, -0.26480606f, -0.26594016f, -0.09976531f, -0.42147681f, -0.22736183f, 0.07036047f, 0.27265865f, 
    0.02120685f, 0.12324443f, 0.20320955f, 0.22940765f, 0.69875747f, 0.65518343f, 0.47703463f, -0.27690715f, 
    -0.84134978f, 0.08533889f, -0.55598480f, 0.17840163f, 0.23427410f, 0.39082843f, -0.29925603f, 0.22021270f, 
    -0.25026974f, -0.18071720f, -0.00674922f, -0.04556468f, 0.06362372f, 0.30911851f, 0.02180776f, 0.17493165f, 
    -0.11647933f, 0.05571355f, -0.35018381f, -0.16829596f, -0.16180806f, -0.05806353f, 0.01258205f, -0.26604792f, 
    -0.57546026f, 0.60104191f, -0.59665167f, -0.29676831f, -0.13155548f, 0.31022117f, 0.22829230f, -0.45177636f, 
    0.16690904f, -0.54387516f, 0.27686185f, -0.19458273f, -0.21344492f, 0.42794624f, 0.24989690f, -0.13238040f, 
    0.15207991f, 0.38685113f, -0.27328670f, 0.21885498f, -0.42371821f, -0.86993349f, -0.57329023f, -0.53757924f, 
    -0.04510800f, -0.19693372f, 0.25368136f, 0.76378971f, -0.01453008f, -0.05779763f, 0.30659521f, -0.11053994f, 
    -0.05786508f, 0.15630640f, -0.43864110f, 0.10452997f, -0.03595310f, 0.23721364f, 0.30253074f, 0.09834038f, 
    -0.17427170f, -0.11625870f, -0.34495860f, -0.33958986f, -0.32238862f, 0.00388939f, 1.03727436f, 0.84744674f, 
    0.41798273f, -0.63332742f, -0.81605303f, -0.28078461f, -0.60767514f, -0.41320780f, 0.12740335f, -0.07211664f, 
    0.29922619f, -0.02397190f, -0.06092750f, 0.12943773f, -0.09145671f, -0.06386486f, 0.07428741f, -0.17648217f, 
    -0.05396298f, -0.20120321f, 0.08092928f, 0.16254850f, 0.23225470f, 0.16049843f, -0.09014247f, -0.45527667f, 
    -0.48692107f, 0.41515082f, 0.54743713f, -0.37130594f, 0.19654945f, 0.08409791f, -0.69581944f, -0.13188834f, 
    0.37256381f, 0.33300519f, 0.09943506f, 0.04269523f, -0.23600031f, -0.24385594f, 0.41983899f, 0.28050417f, 
    0.10058531f, 0.20304492f, 0.55926734f, -0.25559878f, -0.22028081f, -0.12204271f, -0.06006426f, -0.13769941f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05987237f, -0.03980078f, -0.05971779f, 0.08269094f, 0.22233580f, -0.00655167f, 0.19391625f, 0.07574365f, 
    0.21502449f, 0.04902234f, 0.24142690f, -0.04301975f, 0.10245387f, -0.05207615f, 0.00697179f, 0.04479887f, 
    0.04371009f, 0.20194174f, 0.13859406f, -0.00283914f, 0.30168658f, 0.10644510f, 0.22795768f, 0.17987628f, 
    0.14977477f, 0.00898270f, 0.06248410f, 0.18729761f, 0.13470991f, 0.01364708f, -0.01251420f, 0.07806701f, 
    0.27369443f, 0.11932344f, 0.08908972f, 0.31658727f, 0.17588106f, 0.17193650f, 0.13800181f, 0.06918920f, 
    0.04084521f, 0.20485714f, 0.05949670f, 0.14469028f, 0.00869644f, 0.30975586f, 0.05554685f, 0.15026163f, 
    0.24385412f, 0.14675917f, 0.06196526f, 0.14294171f, 0.02941957f, -0.04636407f, 0.02006121f, 0.18638012f, 
    0.09472746f, 0.15582089f, -0.08810974f, 0.06622507f, 0.15845332f, 0.09329645f, 0.34076834f, 0.12646343f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.40599862f, 0.01347837f, -0.03675860f, -0.11634325f, -0.06990185f, -0.00929753f, 0.02858538f, 0.02153575f, 
    0.05394963f, -0.06183088f, -0.02233219f, 0.01861538f, 0.07175991f, 0.09653304f, 0.00018188f, 0.16073222f, 
    -0.17258583f, -0.08565196f, 0.02685244f, 0.04949022f, -0.13275497f, 0.15502645f, -0.06226693f, -0.06488372f, 
    -0.04213700f, -0.18809350f, 0.06160431f, 0.23118174f, -0.07331961f, -0.07574335f, -0.10493439f, 0.04711025f, 
    -0.16062929f, 0.05805765f, -0.07861861f, -0.00032978f, -0.12237407f, 0.05616816f, -0.18931361f, 0.12370024f, 
    0.13102503f, 0.05535113f, -0.06720317f, 0.00020124f, 0.08953407f, -0.03295570f, 0.11088330f, -0.13199218f, 
    0.11602236f, -0.10499072f, 0.03677563f, 0.09156638f, -0.10558788f, 0.01437945f, 0.06047171f, 0.08092176f, 
    0.02173080f, 0.05804303f, -0.01370552f, 0.01451051f, 0.00036563f, 0.05185914f, 0.17795485f, -0.07098015f, 
    -0.03185028f, 0.05385738f, -0.06079529f, 0.05029549f, -0.05993319f, 0.05153913f, 0.04891048f, -0.07285298f, 
    -0.18813668f, -0.29390046f, -0.09471633f, 0.06799086f, -0.05221454f, -0.09239106f, -0.06739564f, -0.01480835f, 
    0.04420476f, 0.00870653f, -0.07535992f, -0.03238859f, 0.20092587f, -0.05654476f, -0.17073026f, 0.00230872f, 
    -0.11879427f, -0.00503928f, -0.03025150f, 0.03563488f, 0.06294562f, 0.03652446f, 0.03092485f, -0.16533035f, 
    -0.23393539f, 0.13547875f, 0.19718996f, -0.00094643f, -0.07677788f, 0.02895194f, 0.06087963f, -0.01030198f, 
    -0.10598245f, -0.09502608f, 0.02340782f, -0.06797217f, 0.11786006f, 0.11204974f, 0.15191481f, 0.05888699f, 
    -0.01093742f, 0.03509725f, -0.03954459f, -0.02121576f, -0.00758775f, -0.02420664f, -0.06038473f, -0.01876567f, 
    0.01188653f, -0.10943464f, 0.06458103f, -0.19499877f, 0.02834313f, -0.06070513f, -0.04284102f, -0.19420750f, 
    -0.00457138f, 0.01149638f, 0.07050788f, 0.09342597f, 0.39984632f, 0.07282370f, 0.15400910f, -0.23696277f, 
    0.03019079f, 0.10144956f, -0.00099025f, 0.04386298f, 0.01205459f, 0.01545643f, -0.11104522f, 0.05624178f, 
    -0.49619865f, -0.02038969f, 0.01864105f, 0.11877354f, 0.03440091f, -0.04483341f, 0.01517721f, -0.00203470f, 
    0.11721157f, -0.12756924f, 0.00928776f, -0.03069840f, -0.29639378f, -0.04058550f, -0.04975151f, -0.26092863f, 
    0.02890137f, -0.06923334f, -0.09469215f, 0.07228579f, 0.06215407f, 0.03579285f, 0.04472665f, -0.00797715f, 
    0.30501953f, -0.05185738f, 0.03397489f, -0.14017284f, 0.04024286f, 0.09902746f, -0.01481564f, 0.04677121f, 
    0.07194436f, 0.06876615f, -0.01898667f, 0.01603413f, -0.11683606f, -0.07927461f, 0.04607800f, -0.10042532f, 
    -0.16277337f, 0.00794729f, 0.11139165f, -0.01128701f, 0.00524959f, -0.03974762f, -0.00028823f, 0.10099935f, 
    0.12557343f, -0.02584723f, -0.16083474f, 0.25262865f, -0.01307918f, -0.08579987f, 0.02882759f, 0.05313035f, 
    0.00398793f, -0.07605695f, 0.05516669f, -0.06076498f, -0.10664692f, 0.09041312f, 0.11204806f, -0.02314668f, 
    -0.01820357f, -0.09302734f, 0.03369174f, -0.07552776f, -0.01150352f, -0.02164819f, 0.02321966f, -0.05726178f, 
    0.10842752f, -0.01021752f, 0.09265881f, -0.06745297f, 0.00256657f, -0.06540737f, -0.01599924f, -0.00015018f, 
    -0.07877868f, -0.03992100f, -0.02470447f, -0.09645046f, 0.19184166f, 0.09544908f, 0.16525595f, -0.34695888f, 
    -0.11200829f, 0.07681056f, 0.00905859f, -0.12406782f, -0.02633986f, -0.02227624f, 0.06431651f, -0.24310923f, 
    0.13982870f, -0.02927583f, -0.08486192f, 0.07866565f, -0.00238236f, -0.12365260f, -0.00443023f, -0.02555823f, 
    -0.01121332f, 0.07367870f, -0.10966709f, -0.00235617f, -0.06714457f, -0.07161266f, -0.05410048f, 0.15426658f, 
    0.05524646f, 0.03401041f, 0.00789893f, -0.00169064f, 0.00639613f, 0.06445873f, 0.14998753f, -0.02696778f, 
    -0.03194794f, -0.06195255f, -0.00485581f, -0.19998845f, -0.00324437f, 0.00583868f, 0.02261163f, 0.00620967f, 
    0.03826770f, -0.06963776f, 0.03393018f, -0.13907771f, 0.10855209f, 0.06475918f, -0.07368536f, -0.28718460f, 
    0.09661417f, -0.02999702f, 0.03773930f, 0.08618980f, 0.02741568f, 0.00013487f, -0.05993283f, 0.09790235f, 
    0.00019471f, -0.08832494f, 0.05412921f, -0.29793724f, 0.04149703f, 0.03619107f, 0.02309395f, -0.07375251f, 
    -0.03500374f, 0.00666950f, 0.03904092f, 0.01662066f, 0.36792487f, -0.01052462f, -0.14624983f, 0.12153971f, 
    -0.06741448f, 0.03049017f, 0.05501043f, -0.01249456f, -0.00483603f, -0.03258817f, 0.01059002f, 0.02721151f, 
    0.09203836f, -0.27097833f, -0.09767541f, 0.17527086f, -0.05152290f, -0.11349932f, -0.02856170f, -0.05392210f, 
    0.01880930f, -0.00044525f, -0.01821346f, 0.07580458f, 0.01295801f, 0.09787917f, -0.08760121f, 0.14681298f, 
    -0.14036831f, -0.00205403f, -0.00598605f, -0.02354816f, -0.05855683f, -0.01230759f, 0.00954988f, -0.02759969f, 
    0.00225790f, 0.13340232f, -0.07984777f, 0.19485915f, -0.08853041f, 0.03270927f, 0.04178932f, -0.03073967f, 
    -0.06257547f, 0.03908632f, -0.06753550f, -0.05702043f, -0.23627590f, -0.00556416f, 0.04191339f, 0.17767489f, 
    0.16709681f, -0.02711315f, 0.03744137f, 0.13188411f, 0.08466101f, 0.11181895f, 0.04042633f, -0.09183484f, 
    -0.27979058f, -0.00798333f, 0.09495749f, -0.10828589f, -0.04021239f, 0.05440577f, 0.00149944f, 0.00602914f, 
    0.04226005f, -0.05633823f, 0.00548490f, 0.06283443f, -0.13206835f, 0.17442787f, 0.00575292f, 0.15836273f, 
    -0.03897821f, 0.06127827f, 0.00518569f, -0.09676897f, 0.01145230f, -0.01138709f, -0.05253916f, -0.00695878f, 
    -0.20250817f, 0.06967621f, 0.03836908f, 0.12375747f, 0.05820207f, 0.06302101f, -0.00797119f, 0.08216867f, 
    -0.00790952f, -0.10768997f, 0.09557505f, -0.08054135f, 0.03036509f, -0.20857638f, -0.04133930f, 0.21843025f, 
    -0.08454670f, 0.01163007f, -0.07945033f, -0.12521161f, -0.06158391f, 0.04128600f, -0.06454936f, -0.00004950f, 
    0.30603105f, 0.07014726f, 0.02631367f, -0.22290972f, 0.03361390f, 0.02696064f, 0.01725523f, 0.00675231f, 
    -0.03517402f, 0.02559634f, -0.09170449f, 0.05769799f, -0.18357302f, 0.02274562f, 0.12183426f, -0.24990118f, 
    -0.07987694f, 0.01218185f, 0.02561876f, 0.01411223f, 0.02301685f, -0.03168990f, -0.02386331f, -0.00431900f, 
    -0.04052946f, -0.11484835f, 0.00381517f, -0.39854994f, -0.07905318f, -0.04666043f, 0.01929629f, -0.01622917f, 
    -0.01692031f, -0.03712775f, -0.07211976f, 0.06073048f, 0.17014402f, 0.03196251f, 0.19976112f, -0.22162937f, 
    -0.11894980f, -0.08791149f, -0.05695787f, 0.09617512f, 0.00098053f, -0.06533092f, 0.03602019f, -0.12680505f, 
    0.20622469f, -0.25514466f, 0.01798943f, -0.08101191f, 0.13491105f, -0.06851967f, -0.00368789f, -0.07488647f, 
    -0.22189265f, -0.06401313f, 0.02418056f, 0.09404624f, 0.09243714f, -0.02739469f, -0.09791182f, 0.02790622f, 
    -0.12137406f, -0.19168285f, -0.03027296f, 0.16969252f, 0.07779689f, -0.00019557f, 0.04524640f, -0.07356786f, 
    0.00233332f, 0.08318872f, -0.08893712f, 0.03156964f, -0.09654673f, -0.03936492f, 0.01028572f, -0.02714579f, 
    0.01046862f, -0.01470537f, 0.01989302f, -0.04503022f, -0.30035964f, -0.06603812f, 0.12084278f, -0.08133594f, 
    -0.02980143f, 0.01231888f, -0.08841492f, 0.03135066f, 0.04801887f, -0.11497833f, 0.10466357f, 0.04273574f, 
    -0.11161243f, -0.08218239f, -0.14004213f, -0.10476488f, -0.03649690f, 0.01031660f, 0.04755412f, 0.04154306f, 
    0.00656347f, -0.00780349f, -0.07018644f, -0.02047117f, -0.27235222f, 0.07453991f, -0.16396016f, 0.22004420f, 
    0.00145735f, -0.02638764f, -0.04182251f, -0.09831930f, -0.00184121f, -0.05196157f, 0.00837596f, 0.07184394f, 
    -0.24776404f, -0.09402091f, -0.03928973f, -0.06926402f, 0.00617778f, -0.04362709f, 0.04565628f, 0.02129396f, 
    0.09986646f, 0.07942735f, 0.04263176f, 0.05952069f, 0.13760138f, 0.04619012f, -0.16616327f, 0.12869453f, 
    -0.12441445f, -0.06164352f, -0.03106059f, 0.04228536f, -0.03398039f, -0.10091746f, -0.08482879f, 0.01631298f, 
    0.01760881f, 0.06195929f, 0.13926725f, 0.12042061f, -0.09976842f, 0.13184085f, 0.11559281f, -0.04800059f, 
    -0.06915842f, 0.06460739f, -0.01021841f, -0.00088351f, 0.18250565f, -0.05654946f, -0.09961531f, 0.31586432f, 
    0.01695877f, 0.01683452f, -0.05217190f, -0.10526817f, 0.01159177f, -0.04421810f, -0.02856801f, -0.03610440f, 
    -0.04628679f, -0.09150474f, -0.04851794f, -0.16981256f, -0.07676252f, 0.09148066f, -0.07732970f, -0.02053492f, 
    -0.12586609f, -0.00108528f, -0.05622527f, -0.03475365f, -0.30295736f, 0.01326002f, 0.09649652f, -0.32524568f, 
    0.02491367f, -0.10693166f, 0.05603389f, -0.09583857f, -0.05006645f, 0.01901771f, 0.02467255f, 0.02033223f, 
    -0.42815715f, 0.23869787f, -0.11796906f, 0.13738297f, 0.01480826f, -0.00068256f, -0.10406375f, -0.02300300f, 
    0.01753821f, 0.06264284f, -0.14804998f, -0.01575684f, -0.08630490f, 0.05746436f, -0.05359773f, -0.02147862f, 
    -0.14912648f, -0.01010128f, 0.00594697f, -0.03465159f, 0.06367122f, -0.10058378f, -0.00180966f, 0.01447980f, 
    -0.02642248f, 0.16641207f, 0.06322568f, -0.15737566f, -0.03450534f, -0.00921397f, -0.09295078f, -0.01820535f, 
    0.03723668f, -0.05533866f, 0.02562678f, 0.00292703f, -0.28089741f, 0.21483470f, -0.13304885f, 0.09627896f, 
    -0.01437842f, 0.07665560f, 0.09270786f, -0.07955103f, -0.03726673f, -0.04698681f, 0.09456138f, -0.00433859f, 
    0.40019637f, 0.20427443f, 0.11045431f, 0.02406275f, -0.04222728f, 0.03404454f, -0.13906008f, -0.06156050f, 
    0.06008469f, 0.02289118f, -0.03651027f, 0.07145831f, -0.17748883f, 0.13586137f, 0.05757066f, -0.35100809f, 
    -0.00141594f, -0.03626005f, -0.06398407f, 0.05898702f, 0.02523186f, 0.01707050f, -0.05342443f, 0.08687691f, 
    -0.22129413f, -0.03644603f, 0.04765155f, 0.00786193f, -0.02898615f, -0.00313788f, 0.05663387f, 0.01960721f, 
    -0.04260506f, -0.09736259f, -0.04994095f, -0.09983527f, -0.18563926f, 0.07138374f, 0.02974167f, 0.07862705f, 
    -0.15241322f, 0.03525938f, -0.00005044f, 0.00966219f, -0.05967465f, -0.04289000f, 0.02925201f, -0.01184853f, 
    0.08473627f, -0.00213154f, 0.04236013f, 0.06314726f, 0.04491599f, 0.07459314f, 0.01644253f, -0.02382859f, 
    -0.04634321f, 0.04739466f, -0.01746574f, 0.04608921f, 0.07029433f, 0.20850645f, -0.14081419f, 0.07987965f, 
    -0.07166567f, -0.05626918f, -0.09509730f, -0.01403108f, 0.01220635f, 0.01526814f, 0.00688260f, -0.06538568f, 
    0.03788209f, -0.01518541f, 0.04310156f, -0.07520320f, -0.01341428f, 0.02224099f, 0.02759876f, -0.14693169f, 
    -0.05952311f, 0.04281997f, -0.01764095f, -0.07952692f, 0.29737788f, 0.13430752f, 0.06782066f, -0.16039391f, 
    0.10055887f, 0.03123003f, 0.04752182f, 0.06649003f, 0.05010065f, -0.03109231f, -0.10591540f, 0.07375783f, 
    -0.20527388f, 0.17522198f, -0.06480990f, -0.18186918f, -0.00150303f, -0.02253849f, -0.05228292f, -0.00337141f, 
    0.00770002f, -0.09605109f, 0.00951671f, 0.01135475f, 0.02101133f, 0.04740842f, -0.13185056f, 0.18900940f, 
    -0.02207387f, -0.00281735f, 0.06706633f, -0.02978255f, 0.07055715f, 0.02907638f, 0.03273694f, 0.02738001f, 
    -0.69267857f, -0.04398002f, 0.05140960f, -0.08912633f, 0.08134592f, -0.01966898f, -0.05411169f, 0.04592555f, 
    0.02662362f, 0.06808510f, -0.03180529f, -0.03063069f, 0.18717444f, -0.05208618f, 0.27412653f, -0.04290916f, 
    -0.00364186f, 0.06257323f, -0.04541943f, -0.04684651f, 0.03285659f, -0.11448694f, 0.02896282f, -0.05829366f, 
    0.04837435f, 0.07057283f, -0.31695476f, -0.15990762f, 0.00410554f, 0.06620000f, -0.00010187f, 0.02231462f, 
    0.03587531f, -0.04557465f, -0.09581235f, -0.15826248f, 0.02481994f, -0.06176173f, -0.02096074f, 0.20389295f, 
    0.01165962f, 0.06653620f, -0.07007906f, 0.10834754f, -0.06271916f, -0.03816767f, -0.14219047f, 0.07336666f, 
    0.13957073f, -0.10808235f, 0.07713288f, 0.11224149f, 0.01694445f, -0.05962327f, -0.06554050f, -0.08742578f, 
    -0.04760038f, 0.01093528f, -0.04473819f, 0.08492062f, 0.17244555f, -0.09295302f, 0.27908984f, -0.34615526f, 
    -0.00975583f, -0.01713442f, -0.06929427f, 0.08938345f, -0.01142726f, -0.22693104f, -0.13850939f, 0.15162367f, 
    0.00127536f, -0.01966063f, -0.01912843f, 0.07614876f, 0.01572248f, -0.03270828f, 0.03788837f, 0.05849518f, 
    0.00645011f, -0.07020104f, 0.11929546f, -0.01192976f, 0.21049245f, 0.05577745f, 0.22590990f, 0.04956018f, 
    0.07698062f, -0.00441901f, -0.01804004f, -0.02103111f, -0.03127478f, -0.01846286f, -0.11471070f, -0.00609123f, 
    -0.10785268f, 0.06027335f, -0.06220092f, 0.03364076f, 0.00449275f, 0.08810396f, -0.05013645f, -0.13057837f, 
    0.05251571f, 0.16273254f, -0.14428230f, 0.03411236f, -0.01969229f, 0.12759331f, -0.05716409f, 0.03568771f, 
    0.11645216f, -0.01297112f, -0.12979583f, -0.00057308f, 0.04702894f, 0.11265999f, -0.07836934f, 0.05416753f, 
    0.00641382f, 0.09749549f, 0.07395222f, 0.10646779f, -0.00612027f, -0.01573929f, 0.00990894f, 0.08709434f, 
    -0.09875705f, 0.08995977f, -0.08489295f, -0.04080009f, -0.41735229f, -0.10875334f, -0.25407314f, -0.10420290f, 
    -0.02025504f, -0.04020398f, 0.00193533f, 0.01278663f, 0.11043182f, 0.02781346f, -0.10946405f, 0.02557101f, 
    -0.03663160f, -0.01902867f, -0.04557705f, -0.14607160f, -0.05504728f, 0.00228579f, 0.01519456f, -0.16173825f, 
    -0.17640929f, 0.06705189f, 0.05076881f, -0.08877508f, 0.32956612f, -0.05628037f, 0.02881553f, 0.03533796f, 
    -0.12205657f, -0.01383464f, 0.01677828f, -0.04048572f, 0.07045054f, -0.12314796f, -0.12785687f, 0.02200868f, 
    -0.24241666f, -0.06332862f, 0.02571403f, -0.10552353f, -0.11505809f, -0.12301248f, 0.10862546f, 0.02514330f, 
    -0.10536842f, 0.02466263f, -0.04575919f, -0.01514312f, -0.17064570f, -0.34161842f, 0.04177792f, -0.08772989f, 
    -0.07152005f, 0.00452767f, 0.01757560f, 0.08134423f, -0.00160028f, 0.14550072f, -0.04205954f, -0.12421957f, 
    0.27046600f, 0.10660198f, 0.03029394f, 0.09692887f, -0.08374943f, -0.02684661f, -0.03138638f, 0.00733912f, 
    -0.04100456f, -0.09369957f, -0.04178274f, -0.00295508f, 0.02575306f, 0.17995268f, -0.05716855f, -0.00122499f, 
    0.00652416f, 0.05511976f, 0.01730837f, 0.03952703f, 0.05490804f, 0.03424417f, 0.11090935f, 0.12459375f, 
    -0.06892364f, 0.03020001f, 0.13608196f, 0.07194298f, 0.03223194f, -0.03893415f, -0.04618688f, 0.02682800f, 
    0.05818193f, -0.03547371f, 0.09592965f, -0.00005005f, 0.21544591f, -0.06067897f, 0.03476351f, -0.18615262f, 
    -0.11000348f, -0.02395971f, -0.04524595f, 0.00528962f, -0.00869719f, 0.02028172f, -0.00879542f, -0.02418619f, 
    0.12899567f, 0.08209808f, 0.07877908f, 0.07570795f, -0.08813334f, -0.06092209f, -0.00196292f, 0.02575823f, 
    0.09281545f, -0.11075103f, 0.12770897f, -0.05732661f, -0.39996427f, -0.16892646f, -0.31935948f, 0.00662042f, 
    -0.04311090f, 0.01668686f, -0.02903437f, -0.10777661f, 0.00085684f, -0.10935444f, 0.00168626f, 0.15342815f, 
    -0.05590225f, -0.09509711f, -0.19683100f, -0.07215076f, 0.03517288f, -0.00369954f, -0.00994744f, 0.03988745f, 
    0.04599001f, 0.08613165f, -0.01532005f, 0.06948679f, 0.19443202f, -0.23581579f, -0.00610414f, -0.14066242f, 
    0.08005382f, 0.09266695f, -0.06972424f, 0.04064875f, -0.00020413f, 0.01315771f, 0.08372880f, -0.02050724f, 
    0.24037848f, -0.11831205f, 0.05461114f, -0.11850381f, 0.04891283f, 0.00250120f, 0.00420873f, -0.04198510f, 
    0.05124237f, 0.01984243f, -0.07286518f, -0.05102669f, -0.39041787f, 0.15332846f, 0.03141353f, 0.06794917f, 
    0.11304121f, -0.09924050f, 0.06304679f, -0.08133753f, -0.05598102f, -0.06465277f, 0.05233910f, -0.05805606f, 
    -0.14112872f, 0.04699359f, 0.12438100f, 0.09156764f, 0.10282744f, 0.03841351f, -0.08836692f, -0.04747550f, 
    0.00991785f, -0.04391065f, 0.08205187f, -0.05569830f, 0.21862143f, 0.01106700f, -0.17478584f, 0.04500716f, 
    0.06531917f, 0.04246375f, -0.03236948f, 0.01642378f, 0.00874114f, -0.11806240f, -0.01698359f, 0.06353289f, 
    0.27914473f, -0.12489469f, 0.05238717f, 0.12247130f, -0.11174613f, 0.06037532f, -0.02943073f, 0.01168274f, 
    0.13129677f, -0.09530411f, 0.12794738f, -0.06625914f, 0.11478024f, 0.04997803f, -0.04092728f, 0.14535135f, 
    -0.15688181f, 0.08776812f, -0.04149192f, -0.00093082f, 0.02987866f, -0.06847419f, -0.15534504f, 0.11281101f, 
    0.04657989f, 0.19225708f, -0.23550633f, -0.09963252f, -0.04858666f, 0.03223170f, -0.05168501f, -0.08575779f, 
    0.07094283f, 0.14339298f, 0.05454505f, -0.04526606f, -0.29211414f, -0.21518669f, -0.23011364f, -0.00977350f, 
    0.01712890f, -0.00094254f, -0.03869375f, 0.06213259f, 0.06223251f, -0.02117485f, 0.01492705f, -0.08097249f, 
    0.27764526f, 0.11782651f, -0.17334269f, 0.07285064f, 0.05479730f, 0.03467885f, -0.04294733f, 0.02797752f, 
    -0.07849433f, 0.13235325f, -0.03164169f, 0.05934058f, -0.04292634f, -0.17362808f, -0.26532811f, -0.31357467f, 
    0.08140291f, -0.09387384f, 0.09528539f, 0.04910309f, -0.01770580f, -0.11917008f, -0.06686850f, -0.28413838f, 
    -0.23686382f, -0.02223411f, 0.05224172f, -0.09798815f, 0.06644243f, 0.07201860f, 0.02478876f, -0.00905449f, 
    0.07912569f, -0.01416792f, 0.00836090f, 0.01982829f, 0.00807235f, -0.09968746f, -0.04400789f, -0.25981092f, 
    0.02408711f, 0.01758872f, 0.11604084f, -0.00033274f, -0.02204894f, 0.06017785f, 0.05141249f, -0.07475463f, 
    0.20144176f, -0.11159264f, 0.11220517f, -0.23424998f, 0.02415576f, -0.07684661f, 0.00302200f, 0.09434617f, 
    -0.02599511f, 0.00795108f, 0.04698676f, -0.02396268f, 0.19491488f, -0.04481883f, 0.00983747f, -0.05173452f, 
    -0.00422342f, 0.03706769f, 0.01724493f, -0.04385037f, -0.00775018f, 0.03255824f, -0.06075238f, 0.12334456f, 
    0.13862355f, -0.05140489f, 0.14478177f, -0.16521002f, -0.06041403f, -0.07071753f, 0.01276017f, 0.00202941f, 
    0.08819164f, 0.04678645f, 0.05910737f, -0.03032093f, 0.33653238f, 0.00583059f, 0.01548738f, 0.03392320f, 
    -0.05002683f, -0.03276984f, 0.02667513f, -0.10631894f, 0.00614131f, 0.12351085f, -0.05471835f, 0.10018431f, 
    -0.03357469f, 0.02185132f, 0.08861685f, 0.17646381f, 0.02895992f, -0.05398992f, -0.02926165f, 0.00123138f, 
    -0.04851914f, -0.04113106f, 0.01490170f, 0.02006637f, -0.42883423f, 0.23725848f, -0.18339998f, -0.05251486f, 
    0.03452318f, 0.05598362f, -0.00885739f, 0.05809517f, 0.00786870f, -0.12860031f, -0.02461064f, -0.17485926f, 
    -0.04397124f, 0.15041883f, 0.08651255f, -0.01641376f, 0.07994286f, -0.05266278f, 0.03680696f, 0.09049913f, 
    0.06256493f, 0.04738183f, 0.00749060f, 0.07980376f, -0.20804825f, -0.09055897f, -0.17884170f, -0.04988851f, 
    -0.08888131f, 0.01390898f, -0.06319638f, 0.05479299f, 0.02950759f, -0.05436483f, -0.00342109f, 0.02422894f, 
    0.16644476f, 0.01382783f, -0.03892336f, 0.01216699f, -0.06268515f, 0.14042020f, -0.01618545f, 0.05417464f, 
    -0.15788503f, -0.06454005f, -0.08869448f, -0.12575930f, 0.24591808f, -0.04076333f, 0.15679628f, 0.15438476f, 
    -0.12124575f, -0.01950278f, 0.04838680f, 0.04290815f, 0.04468250f, 0.04258560f, 0.05968045f, 0.10423116f, 
    0.04514290f, -0.00156858f, -0.01936233f, 0.21215566f, 0.12615424f, -0.09746024f, -0.15143813f, 0.02151801f, 
    0.03393636f, 0.07934403f, -0.04689818f, 0.01934897f, -0.38658643f, -0.07703253f, -0.13646920f, 0.12608920f, 
    -0.04629036f, -0.03227810f, -0.03256658f, 0.01364206f, -0.02863597f, 0.14740019f, 0.04423881f, 0.02802433f, 
    0.00848925f, -0.16002116f, -0.01834398f, -0.16105549f, 0.03539165f, 0.04648908f, 0.06613351f, 0.05115018f, 
    -0.00006797f, -0.01134726f, 0.04749016f, 0.07472249f, 0.36634243f, -0.11086904f, -0.07003635f, -0.36690539f, 
    -0.02856021f, 0.02458940f, -0.04076451f, 0.06265190f, -0.10679847f, -0.09391028f, 0.05313668f, 0.00492757f, 
    0.35439536f, -0.16408102f, -0.09392320f, 0.07628914f, -0.07521847f, 0.04630749f, -0.11631017f, 0.07104036f, 
    -0.05459248f, -0.17492951f, 0.08964784f, 0.01822322f, 0.09092497f, 0.09324114f, 0.14904232f, 0.15660061f, 
    -0.13550946f, -0.06751228f, 0.01421727f, -0.03651010f, 0.04979379f, 0.06666865f, -0.00964213f, 0.05005657f, 
    -0.19615404f, 0.00655572f, -0.14229515f, -0.35042897f, -0.02555958f, 0.05504012f, -0.03882181f, -0.04527914f, 
    -0.04073295f, -0.12501957f, 0.02371109f, -0.03282940f, -0.27796644f, 0.04574899f, -0.16668028f, -0.09237662f, 
    0.00530710f, -0.02780365f, -0.09074114f, -0.16175190f, -0.02039562f, 0.12516509f, -0.01875070f, 0.05613858f, 
    -0.11079464f, -0.08325057f, -0.18882656f, 0.06406754f, 0.13633391f, -0.07590277f, 0.01652657f, -0.02483112f, 
    0.01147041f, 0.08844528f, 0.06809735f, 0.00257520f, 0.24527040f, -0.05223219f, -0.09143233f, -0.08183505f, 
    -0.01576780f, -0.00929786f, -0.06261434f, 0.07385695f, 0.09596621f, -0.02174213f, -0.04804896f, -0.02827721f, 
    -0.32785472f, -0.04084473f, 0.06359179f, -0.01077963f, 0.05470506f, 0.08308356f, 0.00076991f, -0.00281267f, 
    -0.01854772f, 0.14348452f, 0.13159914f, 0.11817393f, -0.06806210f, 0.18628563f, 0.01504530f, 0.17149685f, 
    -0.03435615f, 0.14959113f, 0.04259292f, -0.01573424f, -0.07914018f, -0.01829053f, 0.14761119f, 0.03053865f, 
    -0.14618830f, 0.02471053f, 0.02967278f, 0.03784470f, 0.01168923f, 0.07160249f, -0.00206364f, 0.05145922f, 
    -0.04680310f, -0.09573238f, 0.06268012f, -0.24756770f, 0.10668777f, -0.11362944f, -0.15682833f, 0.11832261f, 
    0.04973926f, -0.11849438f, 0.05069670f, -0.01201795f, -0.05633707f, -0.09977551f, -0.02403259f, 0.07731725f, 
    -0.22490536f, 0.07032818f, 0.03731977f, 0.08253914f, 0.00286914f, -0.20402716f, -0.01674227f, 0.01516107f, 
    0.15486060f, -0.01947751f, -0.03950649f, 0.17750274f, 0.14734256f, 0.00130372f, -0.13097720f, -0.04129130f, 
    0.11632659f, 0.02784599f, -0.09976155f, -0.07861482f, -0.03047210f, -0.01906526f, 0.00570320f, -0.09562203f, 
    -0.01282047f, -0.12135082f, -0.12370583f, -0.09918476f, -0.00499817f, -0.11140054f, 0.07424192f, 0.08431975f, 
    -0.06198527f, 0.03920441f, 0.10824776f, 0.08140356f, -0.22040693f, -0.07923840f, -0.11112320f, 0.01716634f, 
    0.07077190f, -0.07920399f, 0.11981997f, -0.20498914f, -0.02943556f, -0.05756241f, 0.02171931f, 0.04461651f, 
    0.31875151f, 0.19565482f, -0.08757211f, 0.08070104f, 0.01925936f, 0.00596543f, -0.02702252f, -0.01146374f, 
    -0.05725457f, 0.07535681f, -0.01447564f, -0.02867861f, 0.13228859f, -0.03320459f, -0.02306240f, 0.04979104f, 
    -0.01542680f, 0.00224584f, -0.01100440f, 0.02195337f, 0.04179778f, 0.18048631f, -0.05131926f, -0.01388940f, 
    -0.39816430f, -0.31041640f, -0.29720667f, -0.20882238f, 0.00622220f, -0.00895049f, -0.06111781f, 0.05084819f, 
    0.02183414f, 0.05903453f, -0.01396640f, -0.04495023f, 0.11681018f, -0.23276676f, -0.02227148f, -0.00979216f, 
    -0.03224089f, 0.06134229f, -0.02787318f, -0.08159646f, 0.00335733f, -0.11230465f, -0.03998018f, -0.09357272f, 
    0.24215993f, -0.12706061f, 0.02940036f, -0.01297043f, 0.05604213f, -0.04891231f, 0.02237936f, 0.07117111f, 
    -0.01422255f, 0.04433994f, 0.08540481f, -0.02836335f, -0.20444560f, -0.05210898f, -0.17077181f, -0.05984076f, 
    0.16764611f, 0.06962195f, 0.10651593f, -0.04203108f, -0.00795256f, 0.08358010f, -0.03947907f, -0.04628777f, 
    0.23690313f, -0.22187026f, 0.07503545f, -0.06679887f, -0.05497093f, -0.01339056f, -0.03167629f, 0.10146037f, 
    0.00998122f, 0.06920747f, -0.00011288f, -0.21270831f, -0.10268644f, 0.11323877f, -0.15989520f, -0.02630595f, 
    0.06809594f, 0.00271084f, -0.02734952f, -0.06561466f, -0.10863508f, 0.02039143f, 0.03930645f, -0.07142606f, 
    0.09876587f, -0.03381394f, 0.07730470f, 0.03201400f, -0.04884899f, -0.02136729f, -0.08438537f, 0.07507142f, 
    0.02806657f, 0.03682790f, -0.01543245f, -0.13624629f, 0.17032267f, 0.04153766f, -0.00125408f, 0.09440172f, 
    -0.04224110f, -0.07031617f, 0.08319080f, -0.06628820f, -0.01172500f, 0.04568071f, -0.00745848f, -0.06404018f, 
    0.01662544f, 0.13561703f, 0.04442589f, 0.01514824f, 0.02326715f, -0.01340075f, 0.03678026f, -0.11238286f, 
    -0.02038098f, -0.05015162f, -0.07629880f, 0.06864707f, 0.29863146f, 0.14948998f, 0.01796740f, 0.10904407f, 
    -0.06860203f, -0.05988305f, -0.03477419f, -0.04050269f, -0.09886161f, -0.11449785f, 0.08723892f, -0.04674136f, 
    0.22634469f, 0.05277672f, -0.06926025f, -0.01176328f, -0.05535334f, 0.03135150f, -0.04277867f, 0.03250187f, 
    -0.06456935f, 0.06462286f, 0.02018906f, 0.00098891f, -0.08288401f, 0.07471960f, 0.13012567f, -0.13349687f, 
    -0.15808289f, -0.09304175f, 0.07403783f, 0.15476328f, -0.07542100f, 0.03691985f, -0.00277923f, -0.10266345f, 
    0.23229486f, 0.13577668f, 0.13393505f, -0.00670586f, 0.03453138f, -0.07881437f, -0.05891183f, 0.06433085f, 
    -0.01659400f, 0.08147281f, 0.10720042f, -0.06943887f, -0.20884436f, 0.03620424f, 0.01080806f, -0.14934853f, 
    0.06157779f, -0.05409101f, 0.03132363f, -0.03527417f, -0.07083845f, 0.02163554f, -0.07470211f, -0.05021556f, 
    -0.07483270f, 0.01683869f, -0.18938793f, 0.03020350f, 0.00086706f, 0.02158914f, -0.05598501f, -0.01270526f, 
    0.02564073f, 0.06951524f, 0.04654004f, -0.07945693f, 0.16577581f, -0.08863955f, -0.08385293f, 0.01571553f, 
    0.03777760f, 0.00235602f, -0.00593228f, -0.04674525f, 0.01261729f, 0.01277044f, 0.01166698f, 0.05621054f, 
    -0.11593714f, 0.09251804f, -0.05527172f, 0.05451602f, -0.07037627f, -0.02243147f, 0.06165943f, -0.08591793f, 
    -0.06464090f, 0.04425373f, -0.02406006f, 0.00219250f, -0.43906930f, -0.07288130f, 0.02425581f, -0.09095776f, 
    0.15117979f, -0.00692704f, 0.01519562f, -0.03560520f, 0.01238209f, -0.10008582f, -0.02010108f, -0.02549672f, 
    -0.10961092f, 0.00289625f, 0.02131343f, 0.04498014f, 0.07578338f, -0.02147768f, 0.00076294f, 0.01291065f, 
    -0.10174413f, 0.06462239f, -0.02659992f, -0.05067885f, 0.22719358f, -0.06724682f, -0.19054480f, -0.22919892f, 
    -0.16123208f, 0.09104877f, -0.11258842f, 0.05094996f, 0.08723422f, -0.05213494f, -0.06840464f, -0.07085228f, 
    -0.08317780f, -0.19146189f, 0.03918967f, 0.06058573f, -0.07394014f, -0.06852169f, -0.06705199f, 0.02319731f, 
    -0.06667631f, -0.02358826f, 0.10848201f, 0.00074912f, 0.06475139f, 0.10587618f, 0.16420011f, 0.25107548f, 
    -0.09975272f, -0.13734177f, -0.00803482f, 0.01734682f, -0.02913012f, -0.04477838f, 0.00599037f, -0.05733027f, 
    0.12131075f, -0.12857524f, 0.05708189f, 0.13253087f, -0.04121523f, -0.03980507f, 0.08859564f, 0.03111613f, 
    -0.02543674f, -0.03325891f, -0.04662148f, 0.00045833f, 0.08349370f, 0.14500700f, -0.13772874f, -0.07236719f, 
    0.05053161f, 0.05177845f, -0.09010257f, -0.03528471f, 0.02742237f, 0.09123722f, -0.01771825f, 0.03020908f, 
    0.01163751f, -0.01755395f, -0.04955240f, -0.01428718f, 0.04227486f, 0.06044637f, -0.00743858f, 0.03885726f, 
    -0.07846683f, 0.05905768f, 0.01489087f, -0.13400155f, -0.14334416f, 0.04373498f, -0.22589806f, -0.13193388f, 
    0.00485484f, 0.07502671f, -0.00316341f, -0.00647192f, -0.13256481f, 0.00200662f, 0.01586870f, -0.07917892f, 
    -0.24649210f, -0.03507720f, 0.04647749f, -0.12644017f, 0.02931426f, 0.01658059f, -0.07941469f, 0.04777631f, 
    0.03035943f, 0.08603595f, -0.00239851f, -0.05608394f, 0.28341064f, -0.06112375f, -0.01935134f, -0.04851421f, 
    0.04168178f, 0.02251107f, -0.05613752f, 0.05985045f, -0.02136293f, -0.01695477f, -0.07109672f, -0.11290660f, 
    0.15050168f, -0.06035075f, -0.00192759f, -0.02601991f, -0.01764793f, 0.06185596f, -0.00696139f, -0.02875184f, 
    -0.00136331f, -0.00780611f, 0.02237107f, 0.07547341f, 0.03098387f, 0.15325253f, -0.29843056f, -0.12261357f, 
    -0.02367660f, 0.10314470f, -0.11026755f, 0.03253956f, 0.01143462f, 0.00185501f, -0.06893715f, -0.02289368f, 
    0.06747471f, -0.02634029f, 0.01204931f, 0.03650096f, -0.14804192f, -0.02083068f, -0.05824276f, -0.02234262f, 
    0.05804892f, -0.09528058f, -0.06120102f, -0.03406145f, -0.30774680f, -0.03892776f, -0.18013528f, -0.16806236f, 
    -0.05484143f, -0.03568273f, 0.00537975f, -0.09638923f, -0.02621427f, 0.16172029f, 0.00503894f, -0.01688726f, 
    0.14919381f, 0.08033582f, 0.01651667f, 0.12414592f, 0.02009439f, -0.05490713f, 0.00962205f, 0.04946978f, 
    0.00746404f, -0.00130864f, -0.00341460f, -0.02837220f, -0.30541229f, 0.01888123f, 0.01530803f, -0.21439128f, 
    0.08121725f, -0.03157356f, 0.09393701f, 0.01960298f, 0.00692475f, -0.00762222f, -0.03524014f, -0.03245371f, 
    -0.01179237f, 0.07792102f, -0.04289718f, 0.06831601f, -0.03619557f, -0.02499210f, 0.14832096f, 0.03688122f, 
    -0.00075198f, -0.04153464f, 0.01472275f, 0.01355328f, 0.03284130f, 0.02176510f, -0.05630405f, -0.04077522f, 
    0.06053388f, -0.00419576f, -0.01540109f, -0.06112474f, 0.02467576f, -0.01180817f, 0.01579184f, -0.10435744f, 
    -0.39015725f, -0.04815644f, 0.00646684f, 0.02646767f, 0.10694650f, 0.04442113f, 0.02753456f, -0.03130495f, 
    -0.04823008f, -0.13946855f, 0.00723732f, 0.01556816f, 0.14539212f, 0.10694827f, -0.00717711f, -0.12686917f, 
    -0.04663553f, 0.05123966f, 0.06931065f, 0.03220894f, 0.02291036f, -0.08283833f, -0.06464200f, -0.13427363f, 
    -0.03215995f, 0.03788428f, -0.11411746f, 0.15212220f, -0.06415886f, 0.05001560f, -0.00077133f, -0.04727083f, 
    -0.10509428f, -0.03381981f, 0.04553092f, 0.03759835f, 0.40091640f, -0.03637415f, -0.23985375f, -0.04396662f, 
    -0.03248171f, -0.03139878f, 0.04766692f, -0.00020506f, -0.00723874f, 0.04039612f, 0.01699400f, -0.00475467f, 
    -0.12740639f, -0.01760566f, -0.12561461f, 0.04100166f, -0.11456481f, -0.13075475f, -0.07232834f, -0.03019783f, 
    -0.01266639f, 0.03939302f, -0.01264544f, 0.02335490f, -0.14027864f, -0.02895043f, 0.13920110f, -0.06523249f, 
    -0.10381486f, 0.09426942f, 0.10043409f, -0.01465413f, 0.00876507f, -0.10148317f, -0.07368325f, 0.00436214f, 
    0.18715306f, 0.12126253f, 0.05614011f, 0.04529633f, -0.09511545f, -0.12250675f, -0.02308644f, 0.03910966f, 
    0.05225794f, -0.07367215f, -0.02653463f, -0.17605883f, 0.05206757f, -0.07798982f, -0.05451099f, -0.05203144f, 
    0.08910970f, 0.07058357f, 0.00336642f, 0.02803931f, -0.06575476f, 0.07283508f, 0.02047952f, -0.06523827f, 
    0.02265278f, -0.02540941f, -0.07971878f, -0.10142917f, 0.00979133f, -0.00530722f, 0.05683337f, -0.05414026f, 
    0.00810345f, -0.00026473f, -0.10034222f, 0.04694329f, 0.29606014f, -0.04122249f, -0.21848612f, -0.13291156f, 
    -0.02827471f, 0.09771722f, 0.01930747f, -0.01638595f, 0.06541264f, 0.03165278f, -0.01789182f, -0.10027917f, 
    0.03355362f, -0.03750571f, 0.22009060f, 0.01577130f, -0.12774828f, -0.01125277f, -0.03792038f, -0.01332401f, 
    -0.02946805f, -0.01671172f, -0.00870962f, -0.10137544f, -0.05778630f, 0.05763370f, 0.06491501f, -0.01426984f, 
    -0.03094528f, -0.11732232f, 0.10831295f, -0.05295189f, 0.03463856f, 0.00549624f, 0.02559601f, 0.00274109f, 
    0.47337753f, -0.14451210f, 0.06442222f, 0.17957661f, -0.07618693f, -0.00948739f, -0.00809971f, -0.13652553f, 
    -0.04929984f, 0.04149243f, 0.00930964f, 0.05078727f, 0.06187320f, -0.00989900f, -0.03720466f, -0.00748286f, 
    -0.04562984f, 0.14018819f, -0.02471972f, -0.03397667f, -0.05050425f, -0.04298270f, 0.02992423f, 0.03952368f, 
    0.08915390f, 0.09139252f, -0.37249625f, -0.19027266f, 0.06726236f, 0.00853314f, -0.06030019f, 0.00952627f, 
    -0.09756136f, 0.07305755f, 0.01753557f, 0.00896290f, 0.15847972f, 0.19016621f, -0.29587385f, 0.05717222f, 
    -0.03604333f, 0.04791161f, 0.01114413f, 0.03716828f, -0.11750153f, -0.10731060f, -0.05133617f, -0.05446167f, 
    0.19470434f, -0.04676593f, 0.06355686f, -0.07268060f, 0.08582625f, 0.01930446f, -0.09996961f, 0.03976965f, 
    -0.04026758f, 0.01507678f, -0.02819008f, 0.07483725f, 0.14549808f, -0.02561793f, -0.01645409f, 0.15775450f, 
    -0.09239060f, -0.15439662f, -0.05695890f, -0.04586764f, 0.01362167f, -0.02172028f, -0.00302886f, 0.04748722f, 
    -0.26004922f, -0.19679639f, -0.11772840f, -0.26223671f, -0.01600970f, 0.08266730f, -0.07451158f, -0.04615697f, 
    0.03857284f, -0.09793586f, 0.00635063f, -0.03676443f, 0.11313400f, -0.02579732f, 0.07859685f, -0.03054870f, 
    0.00675083f, -0.02215744f, -0.01145906f, -0.02802920f, 0.02721119f, 0.06900854f, -0.00781056f, -0.01797643f, 
    0.16968442f, -0.03933832f, -0.01139935f, 0.04774543f, -0.11881553f, -0.06157875f, 0.07414126f, -0.00460492f, 
    0.03412149f, 0.09303019f, 0.00117321f, 0.06515389f, -0.08940349f, 0.04540274f, -0.00522819f, 0.01143577f, 
    -0.05586099f, 0.01734984f, 0.05540260f, -0.06787558f, 0.05586752f, -0.07140695f, 0.01093935f, -0.05668996f, 
    -0.15926661f, -0.04327820f, 0.14231239f, -0.25676522f, -0.11832064f, 0.00678833f, -0.02421306f, -0.01192151f, 
    -0.07708964f, -0.05273253f, -0.03854953f, 0.04992457f, 0.17541912f, -0.07186621f, 0.04215391f, 0.08056848f, 
    0.01034190f, -0.05111269f, -0.01061256f, 0.15452471f, 0.00087491f, -0.05531502f, -0.07444222f, -0.05475198f, 
    -0.30740979f, 0.00670644f, 0.02370229f, -0.15777312f, -0.04890350f, 0.07584642f, 0.03370112f, -0.05040945f, 
    -0.01307542f, 0.01485321f, -0.00473562f, -0.05264301f, 0.20544764f, -0.25565073f, 0.06850937f, -0.03979117f, 
    -0.11285863f, 0.04536968f, 0.07782910f, 0.02154263f, -0.05831926f, -0.04127214f, -0.02016942f, -0.11730126f, 
    0.15630616f, 0.22116712f, 0.06975525f, -0.17327596f, -0.00864103f, 0.01486426f, -0.05830028f, 0.05708381f, 
    -0.06768896f, -0.08046804f, -0.02060116f, 0.01007907f, 0.17174399f, -0.32897583f, -0.27180246f, 0.32529303f, 
    0.02878819f, -0.02680906f, -0.07893236f, 0.00304500f, 0.01450389f, 0.04838951f, -0.08222204f, 0.07035001f, 
    0.26343083f, -0.13736701f, 0.10130376f, 0.00882929f, 0.08717500f, 0.05323087f, -0.08507793f, 0.01673773f, 
    0.07443303f, 0.02538447f, -0.05813387f, 0.04558649f, -0.12754998f, -0.03326135f, 0.17811237f, 0.11228359f, 
    -0.01139512f, -0.03707270f, 0.07877447f, -0.01573948f, 0.01961805f, 0.17324667f, -0.05226070f, -0.06835395f, 
    -0.10686141f, -0.02785544f, -0.30660045f, -0.06279862f, -0.07607126f, 0.02158566f, 0.00622891f, 0.01871898f, 
    0.03472083f, -0.05129615f, 0.01784727f, -0.06835738f, 0.01068875f, 0.03669058f, 0.02739769f, -0.01981765f, 
    -0.10004313f, -0.03280975f, -0.09525377f, -0.07001518f, 0.07769839f, 0.13220650f, -0.07673587f, -0.02800259f, 
    0.03180738f, 0.07851707f, 0.07480616f, -0.05193602f, 0.00169722f, -0.01996395f, -0.04429484f, 0.01955235f, 
    -0.01752373f, -0.02470793f, -0.03368168f, 0.04425488f, -0.32812971f, -0.18725045f, -0.10086402f, 0.06803021f, 
    0.00017406f, 0.06690042f, -0.04909522f, -0.03601012f, 0.00051560f, 0.08265748f, -0.00783718f, -0.01669442f, 
    -0.02371513f, -0.06944714f, 0.11109931f, -0.00525031f, -0.02233014f, -0.20336010f, -0.07606935f, -0.09025502f, 
    -0.00840701f, 0.00023898f, 0.04750295f, -0.04500920f, -0.38406864f, 0.14975585f, -0.08393993f, -0.09459560f, 
    -0.04799030f, -0.14788064f, -0.03952980f, 0.08934253f, -0.04232975f, 0.02045514f, 0.02127521f, -0.10673025f, 
    -0.20440583f, -0.04969058f, -0.03183244f, -0.04872782f, -0.07914951f, -0.01591622f, 0.00080287f, -0.12649944f, 
    -0.02731915f, -0.04499225f, 0.03575332f, 0.01936372f, -0.15313165f, 0.20228283f, 0.08009518f, -0.14659764f, 
    0.00249576f, 0.07371103f, 0.04875693f, -0.03618077f, -0.05224735f, -0.05619457f, -0.04361977f, 0.01372746f, 
    0.21936543f, -0.01571205f, 0.18284290f, 0.15850830f, 0.10528945f, 0.06444101f, -0.02537043f, 0.08759766f, 
    0.02867914f, -0.12188326f, -0.03475928f, 0.03043741f, -0.04832888f, 0.06046791f, -0.21840179f, 0.13834572f, 
    -0.00137051f, 0.07744865f, -0.10586188f, 0.06891330f, 0.07936842f, 0.10295134f, 0.05089572f, 0.00851241f, 
    -0.12388667f, 0.16212721f, -0.05998489f, -0.15244499f, 0.01888539f, 0.05485523f, -0.05430081f, -0.09595878f, 
    0.04991560f, -0.11485142f, -0.07711977f, 0.04383237f, 0.44199374f, 0.23013027f, 0.01196646f, 0.02677014f, 
    -0.07709294f, -0.04380064f, 0.02915075f, 0.03233624f, -0.05661902f, 0.00242930f, -0.05334108f, -0.02097874f, 
    -0.28904507f, -0.15845342f, 0.07072211f, 0.13443319f, -0.07298930f, -0.00662808f, -0.03052087f, -0.07614081f, 
    -0.06224504f, -0.02237418f, -0.05654793f, 0.07224990f, -0.23212568f, -0.06266927f, 0.08387638f, -0.07412764f, 
    -0.03228232f, -0.09327895f, -0.01243197f, 0.05512179f, 0.01223688f, -0.02080264f, -0.10991664f, -0.03207625f, 
    0.16470484f, -0.15894899f, -0.20417637f, 0.24948812f, 0.11226907f, 0.11809253f, -0.03259354f, -0.08321700f, 
    -0.00496550f, -0.04252266f, -0.07113454f, -0.04072263f, -0.06407043f, -0.00510379f, 0.06424527f, 0.18209884f, 
    -0.08237644f, 0.07610042f, -0.10112644f, 0.13231994f, -0.02783548f, -0.12387874f, -0.04193934f, -0.04410850f, 
    -0.16818632f, -0.29681256f, -0.41627017f, 0.01532039f, -0.13860434f, 0.02368639f, 0.00376771f, 0.08521498f, 
    -0.06486358f, 0.03348054f, -0.06067328f, 0.02783466f, -0.15963289f, 0.25468579f, 0.06041862f, -0.05473483f, 
    -0.02912690f, -0.00268501f, -0.12019049f, 0.04285510f, -0.05845100f, -0.07669165f, 0.02755878f, -0.02561451f, 
    0.09414757f, 0.03131036f, 0.05703257f, -0.07997428f, -0.10159548f, 0.03326190f, -0.03139078f, 0.06918491f, 
    0.10286003f, -0.04168108f, 0.03977636f, -0.05492720f, 0.03512753f, -0.03377407f, -0.15364750f, -0.06669517f, 
    -0.01898621f, 0.01484525f, 0.01252560f, -0.04487640f, -0.10138378f, 0.02977153f, -0.05144240f, -0.04408904f, 
    -0.04993236f, 0.03489488f, -0.03148275f, 0.01522799f, -0.06299390f, -0.02713590f, -0.00889247f, -0.02257825f, 
    -0.07300686f, 0.04502833f, 0.02676737f, 0.03280652f, -0.13635233f, 0.25935319f, -0.08652460f, -0.12049514f, 
    0.02321756f, 0.09768771f, 0.03243581f, 0.16195481f, -0.04219652f, 0.04770480f, -0.04604497f, 0.01467929f, 
    0.16374351f, -0.03134686f, -0.07164373f, 0.13756552f, -0.05486292f, -0.10502407f, 0.13016155f, 0.03029458f, 
    0.04228763f, -0.10872681f, 0.03832397f, -0.09454025f, -0.13715369f, -0.00633911f, -0.14766681f, 0.11950658f, 
    0.00274749f, 0.02044536f, 0.09119540f, 0.08504303f, -0.10208367f, 0.06596338f, 0.13150954f, 0.01255785f, 
    0.00699035f, -0.20832758f, -0.26262236f, 0.01737678f, 0.05939824f, 0.04070663f, -0.00883625f, 0.06465897f, 
    0.01848115f, -0.00224585f, -0.03183840f, 0.08631415f, 0.10466368f, 0.04835037f, -0.02836427f, -0.04094721f, 
    0.06261967f, -0.15464592f, 0.00464410f, -0.13205878f, -0.01400452f, 0.00436687f, -0.09609270f, -0.03452615f, 
    -0.20192403f, 0.14320616f, 0.22133127f, 0.05318606f, 0.09249245f, -0.04566087f, -0.01765056f, 0.04927935f, 
    0.07119378f, 0.02063852f, -0.11114410f, -0.01957970f, -0.22128722f, 0.02680799f, 0.06136726f, 0.09176788f, 
    0.07908169f, 0.03651934f, 0.08173416f, 0.03343704f, -0.05990290f, 0.00645360f, -0.03998185f, 0.02993205f, 
    0.07009485f, 0.07027077f, -0.07988632f, -0.02522457f, -0.01267391f, -0.09601817f, -0.00979322f, -0.06481196f, 
    -0.04147282f, -0.09013198f, 0.05764120f, -0.03415164f, 0.12091938f, 0.19761081f, 0.08826011f, 0.10792207f, 
    -0.04563428f, 0.22588895f, -0.00567959f, 0.09015581f, 0.08440134f, 0.04985535f, 0.04409551f, 0.03628208f, 
    -0.16929603f, 0.09196267f, -0.11110729f, -0.17875665f, -0.09402066f, 0.02580434f, -0.01413325f, 0.00862391f, 
    0.01893888f, -0.02836926f, 0.02336304f, -0.03313517f, 0.37360141f, 0.14458048f, 0.06222415f, -0.00192574f, 
    0.03114749f, 0.02147435f, -0.03544789f, 0.01563886f, 0.00730177f, -0.05109571f, -0.02076804f, -0.09582554f, 
    -0.05308161f, -0.14025222f, -0.00926631f, -0.03938086f, -0.14664556f, 0.04873786f, -0.09278311f, 0.05080292f, 
    0.01368298f, -0.04174876f, -0.10131414f, -0.00338563f, 0.30826584f, -0.02166020f, -0.12043992f, 0.15011103f, 
    -0.03327791f, 0.04176563f, -0.12211809f, 0.10019842f, 0.02493713f, -0.03854091f, -0.06059829f, -0.05019908f, 
    -0.02153607f, -0.04428219f, 0.01632342f, -0.02360830f, -0.06817349f, 0.14591086f, -0.04207228f, 0.09289254f, 
    0.02783194f, 0.06856684f, -0.02400445f, 0.04583785f, -0.33799797f, -0.23314537f, -0.29592147f, -0.05017662f, 
    -0.12054069f, -0.00326818f, 0.02724546f, 0.11765426f, -0.01970515f, -0.09515452f, -0.04553210f, -0.05447053f, 
    -0.07495690f, -0.09045582f, -0.18499045f, 0.14114265f, 0.03977912f, 0.04818963f, 0.01585806f, -0.13155578f, 
    -0.04271196f, 0.04298837f, 0.00194255f, -0.08492760f, -0.14070722f, 0.43985152f, 0.11097655f, -0.05434509f, 
    0.10723595f, 0.10523792f, 0.05964408f, -0.00498038f, 0.05572898f, 0.01342511f, -0.00053112f, 0.08896872f, 
    0.07817263f, -0.02798995f, 0.06610004f, -0.16088730f, -0.20763323f, 0.01216957f, -0.04719334f, 0.13338365f, 
    0.01069308f, -0.00912358f, 0.03368409f, 0.11301028f, -0.13270296f, 0.12324475f, -0.07283567f, 0.00436173f, 
    -0.01056029f, 0.02022050f, -0.02539401f, -0.00412337f, -0.02027744f, -0.01344866f, 0.00623579f, 0.06647947f, 
    0.11040401f, -0.00549838f, 0.01236508f, -0.04817762f, -0.09910610f, -0.07125554f, -0.02951511f, -0.00314968f, 
    -0.01226589f, -0.03087290f, 0.11587798f, 0.08109628f, -0.09824128f, -0.44767720f, -0.34131446f, 0.09883142f, 
    -0.03683300f, -0.07121459f, -0.03953873f, -0.03559310f, -0.01233924f, -0.13036115f, 0.01716690f, 0.03509899f, 
    -0.10266648f, -0.10235161f, -0.14135745f, -0.03619558f, 0.00417157f, -0.04884618f, 0.08963966f, -0.02724713f, 
    0.05569660f, -0.07937713f, 0.06156552f, -0.03477155f, 0.21397197f, -0.02965801f, 0.15936381f, 0.08400143f, 
    -0.10171743f, 0.04936961f, -0.03378524f, 0.03791548f, -0.04333724f, -0.04192335f, 0.08071782f, -0.08730742f, 
    -0.05473157f, -0.05363188f, -0.09536538f, -0.06157206f, -0.15184718f, 0.01729638f, 0.03549431f, -0.02625545f, 
    0.03390917f, -0.04856549f, -0.07487988f, -0.01290491f, 0.04748559f, -0.18167496f, 0.03664258f, 0.14062566f, 
    -0.00533421f, 0.08901810f, 0.01493293f, 0.02994198f, -0.07967848f, 0.05290373f, -0.00054301f, 0.02875086f, 
    0.06203969f, 0.03663395f, 0.12636769f, -0.00720301f, -0.01285069f, 0.01615505f, 0.07094786f, -0.03816105f, 
    -0.05167630f, 0.07210328f, -0.10034887f, 0.03294540f, -0.43575761f, -0.29128158f, 0.04653380f, 0.03223568f, 
    -0.03513103f, -0.05454503f, -0.04867834f, -0.02514679f, -0.08412902f, -0.07481879f, -0.09680345f, -0.02815128f, 
    -0.16286123f, 0.34593230f, 0.11093677f, -0.01826579f, 0.02821363f, 0.14372575f, 0.08007006f, 0.06870313f, 
    0.00717996f, 0.12936975f, -0.02696274f, 0.03689002f, -0.32766274f, 0.04440624f, 0.29122916f, 0.10405074f, 
    -0.01860177f, 0.04643963f, 0.04573521f, 0.05844564f, -0.01033987f, -0.03426431f, 0.00873944f, -0.02716243f, 
    -0.09781435f, -0.15621772f, -0.20774248f, 0.00077798f, 0.02808450f, -0.02183200f, 0.00977539f, 0.05514002f, 
    -0.02763893f, -0.08965872f, 0.09750018f, -0.01383571f, 0.14739774f, -0.04192206f, 0.03783667f, -0.02825454f, 
    0.03565206f, -0.03247886f, -0.03657397f, -0.01961996f, -0.04482923f, 0.00191457f, 0.01473270f, -0.00543316f, 
    0.16251512f, 0.07049266f, 0.10059042f, 0.15178832f, -0.04812930f, 0.07931843f, -0.06508180f, 0.01180426f, 
    0.00140266f, -0.09995069f, 0.02268764f, -0.03174332f, -0.47603187f, -0.10664447f, 0.06441398f, 0.01151622f, 
    0.02439415f, -0.02680240f, 0.07695115f, 0.06242197f, 0.07985744f, 0.02568597f, -0.04056859f, -0.00973630f, 
    0.05842024f, -0.04418209f, 0.00203563f, -0.05926561f, 0.00254883f, -0.05910834f, 0.06954397f, 0.01306565f, 
    0.03197590f, -0.11618524f, 0.07262696f, 0.02933190f, -0.27690852f, 0.05176836f, -0.22216181f, 0.25252452f, 
    -0.03460209f, 0.11239865f, 0.10148416f, -0.04317109f, -0.04787656f, 0.07166030f, -0.10363722f, -0.01366872f, 
    0.06037624f, 0.13123378f, 0.00769110f, -0.05056365f, 0.01721729f, 0.07295749f, -0.12841710f, 0.08527055f, 
    -0.04757381f, 0.02483296f, -0.06777000f, 0.11896230f, -0.19595557f, -0.01824453f, -0.05451651f, -0.10580507f, 
    -0.05689558f, -0.05916849f, 0.02475231f, 0.05997120f, 0.02914442f, -0.11765318f, -0.04092345f, -0.04701419f, 
    0.04405348f, -0.23941536f, -0.13511962f, -0.06421234f, -0.01682215f, 0.06714679f, -0.03519613f, 0.07191307f, 
    0.01606037f, 0.03688948f, 0.02268125f, -0.01998669f, -0.26415005f, 0.04015761f, 0.01371478f, -0.02284364f, 
    0.10059629f, -0.04481022f, 0.04068591f, 0.01026472f, -0.00540563f, -0.01149285f, -0.01368453f, -0.05924599f, 
    0.34071076f, 0.04968201f, 0.02241325f, 0.02691445f, 0.02078550f, -0.09898568f, 0.11389468f, 0.05211941f, 
    0.02823888f, 0.01908922f, -0.05807151f, 0.01148489f, -0.28382310f, 0.21416388f, 0.10158061f, 0.01998062f, 
    -0.05976185f, 0.00111993f, -0.07251611f, 0.11704419f, 0.01525926f, -0.16674381f, -0.04984323f, 0.18890999f, 
    -0.03683700f, 0.25622308f, 0.16032778f, 0.05591562f, -0.04873743f, 0.05035418f, 0.07293064f, -0.16494045f, 
    0.00147456f, -0.06239566f, 0.05746537f, 0.03213403f, 0.04838787f, 0.05992809f, 0.01889970f, -0.02057594f, 
    -0.05211866f, -0.07978171f, 0.01528522f, 0.02347773f, 0.02641596f, -0.02705138f, -0.02641463f, -0.07420352f, 
    0.00965017f, -0.08229857f, -0.04141279f, 0.19920994f, 0.05038945f, 0.06740750f, -0.00596961f, 0.05980158f, 
    -0.10901405f, -0.11783320f, 0.03366476f, -0.07270821f, 0.26320571f, -0.23803920f, -0.14331269f, 0.16752183f, 
    -0.12767422f, -0.05177665f, 0.02202946f, -0.05564774f, -0.08792870f, 0.06733665f, -0.01754767f, 0.01843981f, 
    -0.11693403f, -0.11539287f, 0.12830409f, 0.10771039f, -0.01146064f, -0.02822872f, -0.00183818f, 0.06657349f, 
    0.06422082f, 0.02117742f, -0.01576961f, 0.07330032f, -0.30794722f, -0.07211507f, -0.02013831f, 0.05201766f, 
    0.10268902f, -0.07398010f, 0.13512655f, 0.05829918f, 0.03539278f, 0.06494284f, -0.05111102f, 0.09131426f, 
    0.01181985f, 0.12832415f, -0.27706462f, -0.01652080f, -0.00671492f, 0.09233839f, -0.03181057f, 0.12462668f, 
    0.02512672f, 0.08543659f, 0.04969953f, -0.00763492f, -0.07205874f, 0.07677386f, -0.04083234f, 0.00792741f, 
    0.00708436f, -0.02485387f, 0.10565574f, 0.12600711f, -0.04582821f, 0.01818855f, 0.06980456f, -0.11811788f, 
    0.12513664f, -0.12861407f, -0.10588965f, 0.07762731f, 0.08783917f, -0.05044264f, -0.14901897f, -0.13799207f, 
    -0.03101011f, -0.07061876f, -0.08981151f, -0.04760177f, 0.22243020f, -0.10044073f, -0.02723785f, -0.13586923f, 
    0.04408323f, -0.06042081f, 0.08030375f, 0.05991052f, 0.03473002f, -0.07842506f, -0.08155685f, -0.07049455f, 
    -0.17426738f, 0.23108275f, 0.05262085f, -0.17485811f, -0.08119825f, -0.09546471f, -0.03866196f, 0.03243376f, 
    0.06731436f, -0.01445367f, 0.00694042f, 0.09142701f, -0.01367862f, -0.28032973f, 0.18317720f, -0.11085857f, 
    -0.02518777f, 0.17156491f, 0.07300325f, 0.02790681f, -0.11301546f, -0.04568069f, 0.12795122f, -0.00882939f, 
    -0.18096283f, 0.05538751f, -0.00448847f, 0.16797306f, 0.13146234f, -0.08328329f, 0.00382626f, 0.05476817f, 
    0.02096444f, 0.00881252f, 0.12086710f, -0.00785930f, -0.05317037f, 0.00935874f, -0.09456009f, -0.08651792f, 
    0.08607014f, 0.11492211f, 0.07028543f, 0.02176857f, 0.06888244f, -0.07862160f, 0.00532696f, -0.00361963f, 
    0.00999192f, 0.13251996f, 0.02134711f, 0.08064206f, 0.03309518f, 0.06399082f, -0.01527582f, 0.00990671f, 
    0.01421756f, -0.00156845f, -0.03298094f, 0.06921211f, 0.33247599f, 0.17366260f, -0.10830689f, 0.01621315f, 
    -0.01631929f, -0.01088394f, 0.12458674f, 0.05644304f, -0.07776930f, 0.01099476f, -0.00593061f, -0.01809775f, 
    -0.22268026f, -0.23763610f, 0.00947458f, 0.14207961f, -0.22173059f, 0.01831219f, -0.04050047f, -0.21111062f, 
    -0.02947303f, -0.00890637f, -0.11718772f, -0.09411076f, 0.03145986f, -0.06529681f, -0.11432166f, -0.17336212f, 
    0.04652146f, -0.01601651f, -0.07803934f, -0.05111072f, 0.01722631f, -0.01731654f, -0.01709127f, -0.02461559f, 
    -0.09889967f, 0.07929442f, 0.01615151f, -0.04184693f, -0.04220101f, 0.02856519f, -0.05125712f, 0.10463426f, 
    -0.01398760f, 0.08118762f, -0.04047120f, 0.09372291f, -0.28923965f, -0.03936037f, 0.08413511f, -0.25847182f, 
    -0.00364866f, -0.02729462f, -0.07422373f, 0.02749473f, -0.05506289f, -0.05029002f, -0.03735342f, 0.04920514f, 
    0.20614320f, 0.10912595f, -0.03236831f, 0.10817722f, -0.06214514f, -0.02270806f, -0.03177162f, 0.05249882f, 
    -0.12117229f, 0.08781146f, 0.09902589f, 0.00256385f, -0.56694317f, -0.01233693f, 0.11662389f, 0.28070122f, 
    0.07783099f, -0.09966833f, 0.02560213f, -0.06502265f, 0.07181066f, -0.04840913f, 0.03118967f, 0.01545832f, 
    -0.30941597f, 0.04643274f, 0.20485131f, 0.24363767f, 0.04887874f, -0.10594956f, -0.04283197f, 0.09061056f, 
    0.00492488f, 0.05324044f, 0.09740716f, 0.02498061f, 0.10472444f, -0.21432014f, 0.00686094f, -0.11944972f, 
    0.11770027f, 0.05548213f, 0.00528951f, 0.04169818f, -0.02325457f, -0.10290372f, -0.05480501f, 0.00439973f, 
    -0.04164665f, -0.01519958f, 0.02578121f, 0.18188058f, -0.10418081f, 0.10513107f, -0.02929670f, -0.03248861f, 
    0.06059742f, -0.04431637f, 0.01882372f, -0.00438459f, -0.00259560f, -0.01789133f, 0.11058204f, -0.09896713f, 
    0.07591203f, 0.01851212f, 0.17215717f, 0.11409431f, 0.09378439f, 0.03448274f, -0.00598379f, 0.00393585f, 
    -0.50700545f, 0.29991373f, -0.11947271f, -0.20854861f, 0.05089189f, -0.03623811f, 0.06899282f, 0.08997844f, 
    -0.00919036f, 0.07213929f, -0.02997299f, 0.04188157f, 0.08290330f, 0.06305926f, -0.00359915f, -0.26285928f, 
    -0.08445329f, -0.14749505f, 0.00259752f, -0.01279571f, 0.03963230f, 0.00307826f, 0.05842559f, -0.07201125f, 
    -0.15376885f, 0.16277021f, -0.06402602f, -0.00801781f, -0.07215691f, -0.05009922f, 0.03965996f, -0.04026419f, 
    0.02359852f, -0.13014303f, -0.00286897f, -0.00330363f, -0.25594956f, -0.26346573f, 0.08354035f, -0.03069463f, 
    0.06855635f, 0.07650077f, -0.02504592f, -0.01032172f, -0.00198408f, -0.00334909f, -0.09076854f, 0.03032437f, 
    -0.35842496f, 0.01898928f, -0.23210664f, -0.20639695f, 0.02861819f, 0.08445542f, 0.10728686f, -0.03509533f, 
    0.14993763f, -0.06522878f, -0.06442070f, 0.01873668f, 0.01659966f, -0.09705548f, -0.01481502f, 0.08199940f, 
    -0.06375301f, 0.04274843f, -0.09085833f, 0.01928622f, 0.08237550f, -0.02402185f, 0.11091311f, 0.11352742f, 
    -0.11029261f, 0.09251831f, -0.01393502f, 0.14020345f, 0.00431966f, -0.07576224f, 0.02431998f, 0.04337608f, 
    -0.04774962f, 0.08420247f, 0.15853168f, 0.03303026f, -0.01351185f, 0.03480041f, 0.00019704f, 0.08943749f, 
    -0.07987815f, 0.11130244f, 0.03102494f, -0.03562986f, -0.09327099f, -0.02200313f, 0.04069313f, -0.06655616f, 
    -0.00836703f, -0.07926094f, -0.01113615f, 0.05121175f, -0.15274876f, -0.00407618f, -0.03626393f, -0.14304121f, 
    0.09405196f, 0.02933148f, -0.05628480f, -0.00735376f, -0.09634818f, 0.11435492f, 0.12479246f, 0.14612398f, 
    -0.13601111f, 0.01414827f, -0.17424904f, 0.02039061f, 0.02260320f, -0.07895547f, 0.05664581f, -0.08782229f, 
    -0.11586099f, 0.08292099f, 0.00712354f, -0.06051095f, -0.06269648f, 0.11793961f, -0.00062022f, -0.18552594f, 
    0.05328205f, -0.07004270f, -0.00551753f, -0.06424081f, -0.19368991f, -0.11792449f, 0.13663965f, 0.01688165f, 
    -0.04487620f, -0.03841097f, -0.00070936f, -0.02273671f, 0.10238875f, 0.06521075f, -0.00451757f, -0.00957407f, 
    -0.06503659f, 0.01495979f, 0.04221461f, 0.05934961f, 0.03436074f, 0.01215616f, -0.08041670f, -0.00864199f, 
    0.01154688f, -0.00780017f, -0.11555537f, -0.19033141f, 0.02647154f, 0.18956794f, -0.01907682f, -0.16254860f, 
    -0.08777779f, -0.12315778f, -0.04164589f, -0.09597058f, -0.01232042f, 0.14902636f, -0.01351725f, -0.00466449f, 
    0.39635426f, 0.03219834f, -0.04069830f, 0.03248218f, 0.03959508f, 0.02621543f, -0.04685312f, 0.01111060f, 
    0.07764494f, -0.06172976f, 0.00720437f, -0.06081856f, 0.00535643f, -0.40995771f, 0.04332856f, -0.17125462f, 
    0.07558956f, 0.04396071f, -0.00338973f, -0.03875717f, 0.10616131f, -0.04309467f, 0.02198491f, -0.02552460f, 
    -0.10679512f, 0.08675058f, 0.04261293f, 0.05305944f, 0.07892356f, 0.00284748f, 0.04173148f, 0.11599670f, 
    -0.10292987f, -0.03465441f, -0.05030945f, 0.11223262f, 0.09070538f, 0.25063059f, 0.09049194f, 0.01231649f, 
    -0.05115364f, -0.04148490f, 0.00945409f, 0.05685815f, 0.00451778f, -0.05189538f, 0.09197778f, 0.01102741f, 
    0.28858227f, -0.21327053f, -0.04023950f, 0.04087717f, 0.00244342f, 0.05922545f, 0.16276304f, 0.02622367f, 
    0.02216756f, 0.02073520f, 0.00865042f, -0.01094070f, -0.24809724f, 0.00809998f, 0.02238722f, -0.00056453f, 
    -0.01844507f, -0.00293399f, -0.07560210f, -0.05401424f, -0.01615899f, 0.00476605f, -0.10794725f, -0.07075952f, 
    -0.05192952f, 0.02025464f, 0.13480160f, 0.19683586f, 0.14116697f, 0.02389245f, 0.03844548f, 0.08660524f, 
    0.01655112f, 0.01265339f, -0.00505432f, 0.04938195f, -0.25358841f, -0.19948870f, 0.04812027f, -0.02673865f, 
    0.00162206f, 0.03617110f, 0.04193965f, -0.08295043f, 0.03476649f, -0.00430964f, -0.10800708f, -0.03545745f, 
    -0.59356761f, 0.08280569f, -0.09229388f, -0.10192585f, 0.12956479f, 0.01405975f, 0.07659298f, 0.01245933f, 
    -0.09481116f, -0.03766639f, -0.02817981f, 0.01759364f, -0.23730321f, -0.02460731f, -0.10268603f, 0.04182092f, 
    -0.05591673f, -0.08672058f, 0.00567480f, 0.14915824f, -0.05363389f, -0.04393651f, 0.04435681f, -0.07473531f, 
    0.19744094f, 0.10927335f, 0.13951036f, -0.07779341f, -0.02276710f, 0.01308116f, 0.16641016f, -0.16462207f, 
    0.06930112f, -0.09568354f, -0.05803734f, 0.08531181f, -0.18386021f, -0.18138205f, 0.12620962f, 0.02222136f, 
    -0.14861390f, -0.04138650f, 0.08408111f, 0.06597987f, 0.00595391f, -0.00601550f, -0.08447570f, -0.11803097f, 
    -0.53202850f, -0.08474340f, -0.08626083f, 0.05949642f, 0.04190792f, -0.08096650f, 0.04111387f, -0.06835671f, 
    0.01432990f, -0.02400163f, -0.06070364f, 0.04901962f, -0.31973612f, 0.10124673f, -0.01522681f, 0.08606198f, 
    -0.02073086f, -0.02595792f, -0.03872249f, 0.04136161f, 0.00978954f, -0.05301988f, -0.06259792f, -0.04945596f, 
    0.06295440f, -0.03687587f, 0.04925519f, 0.13935067f, 0.09612001f, 0.02010594f, -0.02193495f, 0.08050888f, 
    0.04182164f, -0.14807332f, -0.00284844f, 0.03881669f, -0.12610266f, 0.27796757f, -0.07708186f, -0.07677288f, 
    0.05114447f, -0.04300003f, 0.06315915f, 0.09469579f, -0.09537655f, -0.02308488f, -0.09080830f, 0.01166376f, 
    0.05898871f, 0.13440755f, -0.18043919f, -0.01336938f, 0.13359118f, 0.03456827f, -0.16929603f, 0.08736258f, 
    0.07075952f, 0.02905745f, -0.07050641f, 0.06868811f, -0.40193403f, -0.15996765f, 0.11726922f, -0.03027294f, 
    0.02681849f, 0.03420306f, 0.05800956f, -0.07140692f, 0.03680459f, 0.07398952f, 0.07543240f, -0.08117282f, 
    0.06058384f, -0.05753800f, 0.07853656f, -0.04788405f, 0.00952387f, -0.02252948f, 0.06021513f, -0.04643584f, 
    -0.14643723f, -0.09455875f, -0.03417248f, 0.04830439f, -0.39505318f, 0.02484306f, 0.14417723f, 0.13480641f, 
    -0.04255951f, -0.10282652f, 0.09347836f, 0.00501062f, -0.00428565f, 0.14502665f, 0.09827816f, 0.12884672f, 
    0.00415016f, -0.18291287f, 0.06394036f, -0.00107079f, -0.17116232f, 0.06084359f, 0.14999558f, -0.10386219f, 
    0.07993554f, 0.10306599f, 0.04922212f, -0.02950229f, 0.06985157f, -0.10195386f, -0.02574145f, -0.11284780f, 
    -0.02076664f, -0.01127498f, -0.11749244f, 0.13952680f, -0.07212746f, 0.05598542f, -0.02825426f, 0.01378689f, 
    -0.07527579f, -0.30511063f, 0.00369804f, 0.00151988f, 0.02351966f, -0.04204292f, -0.00046313f, -0.18027328f, 
    -0.10615785f, -0.11175568f, 0.10875835f, -0.08811612f, -0.01504157f, -0.12640563f, 0.13541614f, 0.18129778f, 
    0.02446035f, 0.01214122f, 0.05607271f, 0.02377815f, -0.02301231f, 0.00706434f, 0.00302782f, 0.02534756f, 
    0.12445609f, 0.02513793f, 0.00659871f, 0.13381390f, 0.03120854f, -0.17896412f, -0.00993025f, 0.06376571f, 
    0.07984623f, -0.07769570f, -0.01241950f, -0.04204940f, -0.20185921f, 0.07452189f, 0.10638621f, -0.34478381f, 
    0.05399556f, -0.02262496f, 0.11441475f, -0.16052398f, 0.05626155f, -0.01964852f, 0.00608066f, 0.22437079f, 
    0.19412604f, 0.23603792f, 0.11234403f, -0.35915563f, -0.01361269f, -0.01229152f, -0.07113539f, -0.11487151f, 
    -0.09053483f, -0.04343576f, -0.09080990f, -0.06500018f, 0.04425990f, -0.01622904f, 0.12870285f, -0.15247992f, 
    0.11196457f, -0.01159566f, 0.03547089f, -0.10944329f, 0.14310248f, -0.20540991f, -0.00544620f, -0.09984697f, 
    -0.21597281f, -0.03769216f, -0.15221511f, 0.06247501f, 0.06366724f, 0.05156133f, 0.05983100f, 0.01022972f, 
    0.06259734f, -0.14065984f, 0.20204651f, 0.07129952f, -0.06428067f, 0.22549330f, 0.13826632f, -0.06074734f, 
    -0.04068971f, 0.03987214f, 0.06811128f, -0.02631399f, 0.07068499f, -0.15794744f, -0.00302579f, 0.01131796f, 
    -0.08134454f, 0.04304095f, 0.12767859f, -0.02312025f, 0.14835332f, -0.12326741f, 0.13587937f, -0.13560106f, 
    0.05008196f, -0.11231937f, -0.00124688f, -0.03730281f, -0.12332424f, 0.10160921f, 0.10833979f, -0.11847246f, 
    -0.00724422f, 0.13203563f, 0.00193299f, -0.06620987f, 0.04181804f, -0.03611555f, 0.00659687f, 0.06363581f, 
    -0.02880980f, 0.01005905f, 0.03823554f, 0.02270985f, -0.00053428f, -0.01537999f, 0.08402469f, 0.07842932f, 
    0.12106717f, -0.02236801f, -0.00254304f, -0.02755253f, -0.24817504f, -0.17413506f, -0.03217472f, -0.00069491f, 
    0.03749700f, 0.01818768f, 0.10576265f, -0.01869030f, 0.16437824f, 0.05752430f, 0.06843877f, 0.06918220f, 
    0.01213346f, -0.24210800f, -0.08084255f, 0.06945903f, -0.03803166f, 0.17795193f, 0.05188939f, -0.15774082f, 
    -0.20111687f, 0.09692823f, 0.17676705f, 0.11298192f, 0.24459773f, 0.02445475f, -0.09831876f, 0.03611073f, 
    0.10352281f, -0.14728804f, 0.01358983f, -0.16708596f, -0.05390013f, -0.04035911f, -0.02015282f, -0.18819903f, 
    0.00791194f, -0.24585930f, -0.17065062f, -0.05690432f, 0.02952530f, -0.00576341f, -0.04446716f, -0.18985219f, 
    -0.08929997f, -0.17746034f, 0.05031079f, -0.08604682f, -0.29505497f, -0.00021543f, -0.05424540f, 0.11810837f, 
    -0.07048286f, 0.06729073f, -0.11683349f, -0.05977079f, -0.07617808f, -0.07080621f, 0.12012500f, 0.04113627f, 
    -0.01665707f, 0.11508322f, 0.03299361f, -0.06877256f, 0.01213592f, 0.02054591f, 0.15768361f, 0.01250872f, 
    -0.02317470f, 0.08698800f, 0.01269497f, -0.09750675f, -0.12720852f, -0.01706433f, 0.20379616f, 0.29425541f, 
    -0.02120703f, 0.05965134f, 0.06723642f, 0.02588056f, 0.15299982f, -0.08772226f, -0.08547053f, -0.03446186f, 
    0.12985811f, 0.06817174f, -0.08672483f, 0.09706022f, -0.02191526f, -0.00968726f, -0.02341186f, 0.03212968f, 
    -0.08344971f, 0.00766010f, 0.05425439f, 0.19471477f, 0.04974406f, 0.06917913f, 0.18947129f, 0.16515806f, 
    -0.02780313f, -0.06231562f, 0.11182714f, 0.02851313f, 0.28082097f, 0.06627511f, -0.04695716f, 0.17257814f, 
    0.12930559f, -0.03718316f, 0.02258579f, 0.05590243f, -0.00193365f, 0.07494067f, 0.05334570f, -0.08872563f, 
    0.07956088f, -0.18447158f, 0.03519205f, -0.00566861f, -0.11764824f, 0.07933217f, -0.00847960f, 0.18102345f, 
    -0.01402582f, 0.09798408f, 0.18731387f, 0.08163225f, -0.01994446f, -0.01990667f, -0.16111442f, -0.06012214f, 
    -0.07501186f, -0.03955707f, 0.07014333f, -0.00745592f, 0.20206505f, 0.11252216f, 0.09452901f, -0.07662605f, 
    -0.10068494f, -0.01081639f, -0.18806890f, 0.11374227f, -0.07852785f, -0.02121069f, -0.29919019f, -0.06561171f, 
    0.01692740f, 0.03811125f, -0.02082941f, -0.10371985f, 0.13276154f, 0.01506225f, -0.01686785f, -0.01933046f, 
    -0.04347204f, -0.12999856f, -0.23491825f, -0.10429471f, -0.01880151f, 0.15198949f, -0.14981470f, -0.01942620f, 
    0.02623675f, -0.09064861f, -0.19245280f, -0.04271722f, -0.12842466f, -0.13844293f, 0.01466337f, -0.03657804f, 
    -0.07745443f, -0.01300606f, -0.06693712f, -0.05224141f, 0.05571078f, 0.02784052f, -0.23137845f, 0.02871897f, 
    0.10586605f, 0.03381332f, -0.06881833f, -0.08065096f, -0.17477727f, 0.08564214f, 0.16858399f, -0.03869894f, 
    -0.17966610f, -0.10156305f, -0.07057936f, 0.03501943f, 0.00544974f, -0.00256534f, 0.12645859f, 0.14124951f, 
    -0.05097748f, 0.05558426f, -0.14899878f, -0.05057033f, -0.07426348f, 0.08004521f, 0.09595419f, -0.09846526f, 
    -0.32106540f, 0.19905941f, 0.09701888f, 0.09879355f, 0.03029867f, -0.02251049f, -0.12159113f, -0.04263318f, 
    -0.01907587f, -0.10779555f, 0.01751584f, -0.03589914f, -0.31948841f, 0.07651961f, -0.05385865f, -0.03919969f, 
    0.10454315f, 0.03337603f, 0.03940111f, -0.03406230f, 0.06199567f, -0.00428956f, -0.01813943f, 0.10092942f, 
    -0.23623441f, 0.02171955f, 0.16539104f, -0.07387448f, 0.11580792f, -0.00930441f, -0.01555213f, 0.03279214f, 
    0.05288568f, 0.10802682f, 0.17383254f, 0.02307819f, 0.17881761f, 0.16864306f, 0.30753466f, 0.04957388f, 
    -0.17574482f, -0.07735391f, -0.00806594f, 0.02649156f, -0.12661567f, -0.10649970f, 0.12487985f, 0.14561297f, 
    -0.51121438f, 0.16262911f, 0.01408009f, -0.33157673f, 0.01216136f, 0.01291276f, 0.01256294f, -0.12624554f, 
    -0.00247925f, 0.09518463f, -0.04267161f, -0.07365526f, 0.00898987f, 0.09349910f, 0.22278897f, 0.13469006f, 
    -0.02543422f, -0.02520693f, 0.03528965f, 0.09869980f, 0.03767426f, -0.01548879f, 0.03465270f, -0.02374624f, 
    0.17431283f, 0.03568061f, 0.02222687f, -0.00989679f, 0.10014142f, -0.08165526f, -0.19179298f, -0.17155808f, 
    -0.03165551f, -0.02893258f, -0.04653693f, -0.09490186f, -0.28391865f, -0.07979777f, 0.09363981f, 0.25091076f, 
    0.04066403f, -0.12401049f, 0.02473236f, 0.01217792f, 0.06838045f, 0.03463052f, 0.00880834f, -0.00787856f, 
    0.09950743f, 0.05845135f, -0.05628892f, -0.04281963f, -0.04075368f, -0.07616731f, 0.06945198f, -0.18124896f, 
    -0.06431374f, 0.00389941f, -0.00384386f, 0.05447659f, -0.19882677f, -0.06174917f, 0.06254359f, 0.28863987f, 
    -0.10519131f, -0.03265448f, 0.17395885f, -0.06451514f, -0.02439742f, 0.05966743f, -0.02370199f, 0.23159143f, 
    -0.07722965f, -0.08116519f, -0.09248947f, 0.00504295f, -0.01705287f, -0.24190189f, -0.04044456f, -0.03927272f, 
    0.09972961f, 0.11453739f, -0.05055862f, 0.02377654f, 0.05488952f, -0.00573240f, -0.05703513f, -0.06408696f, 
    0.00037464f, 0.07833979f, 0.07874549f, -0.01097300f, -0.01876444f, -0.07359685f, 0.09428544f, 0.04282916f, 
    0.11452816f, -0.00969913f, -0.06068203f, -0.00961802f, -0.09865107f, 0.00894168f, 0.00807025f, 0.02437459f, 
    0.07512807f, 0.01879392f, 0.09771365f, 0.26166448f, 0.12530838f, -0.07507787f, -0.08885057f, 0.02014231f, 
    0.05630910f, -0.14505289f, -0.03600238f, 0.02490844f, -0.02426495f, 0.04171237f, -0.09745027f, 0.04110503f, 
    -0.22652461f, -0.11774408f, -0.09132541f, 0.14131697f, 0.13628586f, 0.08992799f, -0.01729577f, -0.04270925f, 
    0.00203287f, -0.08256879f, -0.04723810f, 0.07396771f, 0.02363539f, 0.10906833f, -0.06355651f, 0.05466839f, 
    -0.03003640f, -0.09171000f, 0.01543673f, 0.09100367f, -0.01149190f, -0.01181647f, 0.10044494f, -0.07897618f, 
    -0.54278821f, -0.45595214f, -0.09566643f, -0.01647571f, 0.12990609f, -0.04768664f, -0.00522242f, -0.04425688f, 
    0.09779138f, 0.11802136f, -0.01637368f, 0.21443065f, 0.04641198f, 0.04428042f, 0.05217955f, 0.07828087f, 
    0.00271200f, -0.02411558f, 0.03628081f, -0.08509550f, 0.06500051f, 0.08536585f, -0.01878573f, 0.06115727f, 
    0.03204059f, 0.15470107f, 0.25207654f, -0.38848406f, -0.07692494f, -0.06716689f, -0.15268512f, 0.00642887f, 
    0.00727418f, -0.06808677f, 0.04841544f, -0.09226040f, -0.03146652f, -0.08254350f, 0.05824774f, -0.04136333f, 
    -0.10552654f, 0.02037862f, -0.04247509f, 0.10862084f, -0.02246425f, -0.11081415f, 0.03589674f, 0.02596927f, 
    -0.07923473f, 0.03837128f, -0.16716166f, 0.09371662f, 0.07518956f, -0.12532820f, 0.01380239f, -0.07880278f, 
    0.04676935f, 0.02346193f, -0.00146933f, 0.09845006f, -0.02322228f, 0.01495604f, -0.07587869f, 0.07246321f, 
    0.00936318f, 0.04161728f, -0.06124405f, 0.07694175f, 0.03257613f, -0.03541146f, -0.03752219f, -0.07189658f, 
    -0.49456900f, -0.11841329f, 0.01431106f, -0.33199239f, 0.07043607f, -0.03918880f, -0.06021406f, -0.00879497f, 
    0.05899000f, -0.05386430f, -0.03717411f, -0.00427897f, 0.05051604f, 0.02221801f, 0.08237819f, 0.03101423f, 
    0.01067373f, 0.10518020f, 0.05340486f, 0.02784882f, -0.01222126f, 0.02420196f, 0.04566324f, 0.06603903f, 
    -0.07835322f, -0.22671212f, -0.01618244f, 0.34839347f, 0.06043459f, -0.12267838f, -0.13636206f, 0.13139240f, 
    0.08865330f, 0.19747163f, -0.05425263f, 0.05205092f, 0.14964983f, -0.11258265f, -0.01616568f, -0.03887558f, 
    -0.03941453f, -0.03367784f, -0.04443102f, 0.11149877f, 0.13413286f, 0.06559993f, 0.03034888f, 0.15462270f, 
    -0.14195287f, 0.28781149f, 0.11020928f, -0.24613041f, -0.05829284f, 0.14647487f, 0.05651484f, -0.02307677f, 
    -0.02505722f, -0.06590740f, 0.08561082f, -0.20621608f, -0.42533237f, -0.24547927f, -0.18559840f, -0.10007907f, 
    0.03511604f, 0.15339337f, 0.07444738f, -0.04498756f, -0.07023478f, -0.04361132f, 0.00584886f, -0.04358368f, 
    0.07411213f, -0.13331944f, -0.05532812f, 0.16724598f, 0.07434566f, -0.19784062f, -0.04560531f, 0.00050216f, 
    -0.06195640f, 0.10695899f, 0.02932451f, 0.18879327f, -0.22023416f, -0.06126771f, 0.10337196f, 0.02959195f, 
    0.00428646f, -0.16006626f, 0.02422959f, 0.10465180f, 0.10227719f, 0.00528861f, 0.03819972f, -0.17386383f, 
    -0.06035206f, -0.13091350f, -0.07716382f, 0.13703309f, 0.01914262f, -0.07059385f, 0.03108281f, -0.04441706f, 
    -0.05310903f, -0.12234044f, -0.16303553f, -0.17059711f, 0.05003009f, 0.11149425f, 0.11326968f, 0.00668802f, 
    -0.03333598f, -0.08054055f, 0.00231886f, 0.02439742f, 0.04965359f, -0.00493301f, 0.10460068f, 0.08138730f, 
    -0.01746956f, -0.33239597f, -0.06903280f, 0.13422620f, 0.11763430f, -0.00540692f, -0.04449371f, 0.13865918f, 
    0.08011759f, -0.05538835f, 0.05485767f, -0.24754880f, -0.42810667f, 0.13170056f, -0.22195767f, -0.13821214f, 
    0.11737464f, 0.14664616f, -0.13044399f, -0.12745044f, 0.06732304f, -0.14216596f, 0.08366555f, -0.18355945f, 
    0.01350638f, 0.17984255f, -0.03755021f, 0.05605369f, 0.00751477f, -0.07800752f, -0.01305106f, 0.09402385f, 
    -0.03601633f, -0.09792712f, -0.05208046f, -0.03105069f, -0.11354415f, 0.08649087f, -0.13692975f, -0.05317017f, 
    -0.03820545f, -0.01406855f, -0.02660319f, -0.05363313f, 0.08042771f, 0.12518857f, 0.18538316f, 0.03135341f, 
    0.12985107f, -0.05746846f, -0.15072374f, 0.23192216f, -0.13918181f, 0.08678150f, 0.05169245f, -0.00718213f, 
    -0.19756289f, 0.12568703f, -0.05433507f, 0.10368960f, 0.06501956f, 0.05511852f, -0.00136438f, -0.14625788f, 
    -0.11027774f, 0.02044481f, 0.17508951f, 0.03276063f, 0.08580560f, 0.04845760f, 0.02505194f, 0.00400034f, 
    -0.05640344f, -0.07762725f, -0.06291190f, -0.22843558f, 0.08141721f, 0.11012638f, -0.06372759f, 0.05761419f, 
    -0.02916198f, 0.05121978f, 0.06383175f, 0.12991647f, 0.34414339f, -0.07927479f, -0.12347195f, -0.10301485f, 
    -0.06318527f, 0.08038464f, 0.09691141f, 0.12563445f, 0.03553649f, -0.01567618f, 0.06018089f, -0.08535515f, 
    -0.20040232f, 0.08728494f, -0.06047467f, -0.01175466f, -0.03108362f, 0.06378564f, -0.01060867f, 0.10579716f, 
    0.09673183f, 0.01322511f, 0.03364775f, 0.01238169f, -0.25381422f, 0.02432915f, 0.04867084f, -0.09135599f, 
    -0.03014625f, 0.01087656f, -0.04312155f, 0.04044055f, -0.03559015f, 0.07949021f, -0.02299906f, 0.03882756f, 
    -0.08505783f, 0.01695316f, -0.16431771f, -0.04550883f, 0.00222127f, -0.03212992f, -0.10227622f, -0.10888470f, 
    -0.02513858f, 0.05715378f, -0.04490482f, -0.02261184f, 0.18289360f, 0.12204400f, 0.24089551f, 0.09545439f, 
    -0.14453819f, -0.12154277f, -0.00797255f, 0.03915306f, -0.09588391f, 0.08324213f, 0.09550516f, 0.10403147f, 
    0.06361371f, -0.56948900f, -0.12121827f, 0.06163399f, -0.04425497f, 0.16857068f, 0.03713323f, 0.07035918f, 
    -0.07720546f, -0.05397153f, 0.10108952f, 0.15222859f, 0.01978841f, -0.31459060f, -0.06370913f, 0.02827908f, 
    -0.07352735f, -0.02509268f, 0.03473160f, -0.00260136f, -0.05796402f, -0.04270679f, -0.02825929f, 0.04089380f, 
    -0.09032840f, 0.02709239f, 0.06546248f, 0.04148418f, -0.08672357f, 0.03049091f, -0.05327442f, 0.08450712f, 
    -0.06612193f, 0.00415034f, -0.00176460f, -0.10387313f, 0.04444214f, 0.00750736f, -0.03139697f, 0.16639522f, 
    -0.05985667f, -0.01829138f, -0.11603654f, -0.13586506f, -0.21698847f, -0.09802257f, 0.00794654f, -0.22053838f, 
    0.20134810f, -0.09241083f, 0.07210983f, -0.09743472f, -0.02133223f, 0.07389659f, -0.04324193f, 0.06631197f, 
    0.14280474f, -0.03758743f, -0.04921946f, -0.00194049f, -0.46944025f, 0.03043258f, 0.00704050f, 0.16971256f, 
    0.05504056f, -0.04627433f, -0.13109957f, 0.02769876f, -0.06894713f, 0.05327067f, 0.08530962f, 0.01172862f, 
    -0.20275821f, 0.00583149f, -0.17739888f, 0.11296161f, -0.10681237f, 0.06790750f, 0.11411196f, 0.01163307f, 
    -0.03159010f, 0.10119744f, -0.02862470f, 0.12467210f, 0.10662257f, -0.25508419f, -0.14153339f, 0.25594014f, 
    0.01756281f, 0.07284337f, -0.02691872f, 0.01832593f, -0.04350137f, -0.02991682f, -0.18855897f, 0.07818206f, 
    -0.07741069f, 0.12305471f, 0.10933947f, -0.28902254f, 0.06221227f, 0.08694690f, 0.13002014f, 0.05360428f, 
    -0.01796439f, 0.05918360f, -0.10274282f, -0.04912180f, -0.00752742f, 0.05506185f, -0.03815058f, -0.03046284f, 
    -0.09858979f, -0.11039043f, 0.04523300f, -0.07184914f, -0.04738298f, 0.01969158f, -0.12353957f, 0.06293961f, 
    0.08382323f, 0.11841246f, 0.04329538f, -0.25315699f, -0.01596165f, 0.09746823f, -0.07834743f, -0.00489928f, 
    0.01968052f, -0.08221892f, -0.08988848f, -0.01899606f, -0.03315584f, -0.15140167f, -0.07872351f, 0.05179339f, 
    0.01040973f, -0.03987235f, -0.13764489f, 0.06550919f, -0.13916452f, 0.10842994f, 0.06638162f, -0.00021367f, 
    -0.27097592f, 0.19505051f, 0.03066142f, 0.16844262f, -0.04937502f, 0.03665372f, 0.11533612f, 0.01360309f, 
    -0.04201818f, 0.06730746f, -0.07568868f, 0.03236770f, 0.20131233f, -0.06374661f, 0.03050614f, -0.18309438f, 
    0.01463681f, 0.00858440f, 0.02791915f, -0.06177558f, -0.08237526f, 0.11003920f, 0.15043618f, -0.18229592f, 
    -0.10727887f, 0.14281236f, -0.01238388f, 0.02494638f, -0.06942036f, -0.03270548f, -0.02116315f, -0.06226179f, 
    0.09011450f, -0.02509795f, 0.08591996f, -0.06197251f, -0.23815839f, -0.05687659f, -0.06710705f, -0.18380792f, 
    -0.01931317f, -0.01622429f, 0.00711478f, -0.03199618f, -0.06898516f, -0.02784550f, 0.02795103f, 0.06377387f, 
    -0.11044066f, -0.13391432f, -0.11363433f, -0.14600214f, 0.02786577f, -0.00554619f, 0.00108886f, -0.02051597f, 
    -0.03613738f, -0.03407250f, 0.07555325f, 0.06673601f, 0.43160880f, -0.18066956f, 0.23332672f, 0.04817194f, 
    -0.06949878f, 0.03810975f, -0.03360503f, 0.10358335f, -0.05757809f, 0.00616181f, 0.10277123f, 0.06583901f, 
    0.03658820f, 0.06041049f, 0.11447664f, -0.12313813f, -0.15069155f, -0.07470251f, -0.00615553f, 0.04781736f, 
    0.17422697f, 0.09777754f, -0.01523419f, -0.06811275f, 0.13575731f, 0.14384449f, 0.18672778f, -0.09820278f, 
    0.08133693f, -0.06720671f, 0.10599901f, 0.02931398f, 0.07496864f, 0.07372697f, -0.03993807f, 0.07630249f, 
    0.36182839f, -0.35130644f, 0.12005155f, 0.00312963f, 0.07236121f, -0.02766306f, 0.01506240f, -0.06244693f, 
    -0.01796615f, -0.04902086f, 0.00525952f, 0.05922921f, -0.02015094f, -0.13716729f, -0.11250658f, -0.22273703f, 
    0.03821019f, 0.01961339f, 0.02106360f, -0.10396472f, -0.12114176f, 0.02713704f, 0.13331988f, -0.39406899f, 
    -0.06843650f, -0.27812666f, -0.11985631f, 0.12048241f, 0.05006580f, 0.02444028f, -0.02874785f, 0.00896060f, 
    -0.08430548f, -0.06018852f, -0.17808865f, -0.03741019f, 0.08311138f, -0.02561540f, 0.09447400f, -0.02507444f, 
    0.05757540f, -0.02384402f, -0.05334207f, 0.01480601f, 0.11324579f, 0.01688674f, -0.01194759f, -0.01985733f, 
    0.11746832f, -0.33994693f, 0.14574440f, 0.00519878f, -0.02020903f, -0.01149657f, -0.02502353f, 0.00126263f, 
    -0.01367401f, -0.02098878f, -0.01898481f, -0.06450572f, -0.02465220f, -0.02297851f, -0.14782155f, -0.17591523f, 
    0.03341289f, 0.00901434f, 0.03398049f, -0.01071319f, -0.05951339f, 0.01008431f, -0.02974249f, 0.04699276f, 
    -0.06501301f, -0.23682085f, -0.26357362f, 0.10043463f, -0.09593720f, 0.01268437f, 0.08823497f, -0.02519840f, 
    0.08192272f, 0.00341405f, 0.01672842f, 0.08433819f, 0.06165546f, -0.10379725f, -0.09831782f, 0.16035062f, 
    0.07783597f, 0.03408041f, -0.11254724f, -0.00539303f, -0.07833309f, -0.08834879f, -0.02368675f, -0.05921867f, 
    -0.33522227f, -0.07996713f, -0.16484095f, 0.19597758f, 0.05359174f, 0.04319719f, 0.07522608f, 0.02623852f, 
    0.05278609f, -0.02511345f, 0.03402726f, -0.00365986f, -0.01135688f, 0.12054529f, -0.10892888f, -0.23977122f, 
    0.01529038f, 0.01095127f, 0.06208989f, 0.02658066f, -0.08364820f, 0.01315991f, -0.04557423f, -0.10287177f, 
    -0.27529138f, 0.01472249f, -0.08903369f, 0.12646341f, -0.00097790f, 0.06538120f, 0.11310844f, -0.00420218f, 
    0.00727707f, -0.02047229f, -0.01006144f, -0.08006810f, -0.27801827f, 0.24294162f, 0.13517797f, 0.08135444f, 
    0.09437073f, 0.03585600f, -0.00614320f, 0.01736167f, -0.04523794f, 0.03976804f, -0.01648783f, 0.01431175f, 
    0.04864417f, 0.09362976f, 0.12112542f, -0.35559046f, -0.02868214f, -0.00657042f, 0.09923032f, -0.06444954f, 
    0.03205059f, -0.07043063f, -0.07225616f, -0.13976681f, 0.05542305f, -0.25000954f, -0.08906881f, 0.28687030f, 
    -0.01269152f, 0.04795869f, -0.14724192f, -0.05463457f, -0.02875589f, -0.00605644f, 0.11176024f, 0.11866072f, 
    -0.29332682f, -0.11574278f, 0.02962970f, -0.20589441f, -0.03375147f, -0.09979695f, -0.06127095f, -0.10240199f, 
    -0.09946975f, 0.07527422f, 0.02510813f, 0.02718051f, -0.30637777f, -0.01196206f, 0.06948478f, 0.17020883f, 
    0.02818044f, -0.01250945f, 0.08990584f, 0.00929954f, -0.04296566f, -0.05498674f, -0.12939151f, -0.14801991f, 
    -0.00256948f, 0.04951364f, -0.14343788f, -0.16912019f, -0.07650479f, 0.01194522f, -0.00813499f, -0.08499102f, 
    0.10936971f, -0.11655550f, 0.10216017f, -0.02792423f, -0.19873570f, 0.18420394f, 0.13119359f, -0.08597514f, 
    -0.03380536f, 0.04096679f, -0.02524897f, 0.01627867f, 0.05563704f, 0.05825740f, -0.01770844f, -0.02155782f, 
    -0.18136066f, 0.15328152f, -0.01076117f, -0.04020009f, -0.12075227f, 0.06673783f, 0.18676645f, 0.00564963f, 
    -0.05416327f, -0.12467237f, -0.09825961f, 0.00370348f, 0.13469887f, -0.07434086f, 0.14544609f, -0.18195508f, 
    0.10837112f, -0.01367838f, 0.13583773f, -0.09976959f, 0.04861316f, 0.06183112f, -0.07486320f, -0.03274626f, 
    0.02647951f, -0.05820977f, -0.29430294f, 0.04643542f, -0.02181013f, 0.05561116f, -0.12988667f, 0.07342409f, 
    -0.02416786f, 0.05994593f, 0.04443916f, -0.13322356f, -0.10323304f, -0.06536580f, -0.13187321f, 0.23022014f, 
    0.10233225f, 0.03851610f, -0.03696129f, -0.01841597f, 0.10313421f, -0.03438419f, 0.02696864f, -0.00237082f, 
    0.27715272f, -0.08651020f, 0.01126310f, -0.17539567f, 0.02848994f, -0.02375615f, 0.12263368f, 0.02803181f, 
    0.08987342f, -0.03313790f, 0.08901636f, -0.02827138f, 0.03280945f, 0.15754801f, 0.05481995f, -0.10583647f, 
    -0.01959044f, -0.01348266f, -0.03674344f, 0.05409592f, 0.00302536f, 0.04499704f, -0.08920900f, -0.08531546f, 
    -0.03108668f, -0.31374985f, -0.13545397f, 0.13104834f, 0.15442842f, -0.01154782f, 0.12892854f, -0.07251247f, 
    -0.08005949f, -0.11631846f, 0.05754259f, 0.05206459f, 0.07793069f, 0.11298682f, 0.10127935f, -0.13443787f, 
    0.11739181f, 0.01282196f, 0.09450282f, -0.01890640f, -0.06497124f, 0.01223326f, 0.04172588f, -0.16042839f, 
    0.41534343f, -0.14147195f, 0.14361529f, 0.02845528f, -0.12422118f, 0.03259464f, -0.06799003f, 0.01038842f, 
    0.00333888f, -0.01696872f, 0.04690671f, 0.03020961f, -0.03022133f, -0.06020084f, 0.00157020f, -0.09412125f, 
    0.04088455f, 0.00582840f, -0.05453184f, -0.09084228f, 0.00436747f, -0.02724523f, 0.09896889f, 0.21594709f, 
    -0.12586266f, -0.10280308f, -0.12097259f, -0.16081905f, -0.03666731f, 0.08328874f, 0.04888997f, -0.00055697f, 
    -0.04949224f, -0.09969631f, 0.00117008f, 0.02815334f, 0.34148890f, -0.23144582f, -0.05511977f, -0.10368101f, 
    0.06650291f, -0.06869221f, 0.00130480f, 0.02119437f, 0.01801383f, 0.04452091f, 0.12363993f, 0.14463638f, 
    0.10705335f, -0.07358578f, -0.06315244f, 0.09797176f, -0.08504584f, -0.03559368f, -0.03468197f, -0.02638668f, 
    -0.10912313f, 0.07582077f, 0.09588529f, 0.16628100f, 0.04888447f, 0.14331561f, 0.13827112f, -0.13733646f, 
    0.02142701f, -0.00248791f, 0.09399888f, -0.05598619f, 0.06447565f, -0.02054444f, -0.11404656f, -0.02336032f, 
    0.11841355f, 0.04971094f, -0.12077539f, 0.16679421f, -0.00899081f, -0.01682412f, -0.00115509f, -0.05406698f, 
    -0.23801067f, 0.08890904f, 0.05885293f, -0.04412282f, -0.01872998f, -0.24985236f, -0.12986585f, -0.14165415f, 
    -0.02239379f, -0.00639234f, -0.01031602f, 0.12323048f, 0.07533897f, 0.08381264f, -0.03006433f, 0.19360471f, 
    -0.30719629f, 0.00239980f, -0.08622123f, 0.30035612f, 0.06636153f, 0.08996004f, -0.05699709f, -0.06008834f, 
    0.01220018f, 0.13725877f, 0.00309565f, -0.09572399f, 0.15015811f, 0.02486474f, -0.02275519f, -0.10356728f, 
    -0.03626956f, 0.02512528f, 0.04750524f, -0.00533709f, 0.07799764f, -0.05152801f, -0.15087847f, -0.16370879f, 
    -0.05181404f, 0.16379602f, -0.02902042f, 0.22939231f, 0.09796993f, -0.03577245f, 0.02319932f, 0.03742465f, 
    0.01706143f, 0.02707438f, -0.00572874f, -0.06361497f, -0.35177630f, -0.01617812f, -0.11205582f, -0.12031181f, 
    -0.05042804f, -0.05112971f, 0.01578238f, -0.09093127f, -0.08673401f, 0.09017653f, -0.02512405f, 0.00812688f, 
    0.03874734f, 0.08434852f, 0.01569090f, 0.16014321f, -0.09043938f, -0.03857173f, -0.02342668f, 0.00638384f, 
    -0.04313203f, 0.05191379f, -0.02673096f, -0.01334091f, -0.19720697f, -0.14924337f, 0.02037491f, -0.10339879f, 
    -0.00998735f, 0.04999936f, 0.01330256f, -0.07977372f, 0.01514660f, -0.09153031f, 0.09574915f, -0.07695603f, 
    -0.19709015f, 0.12717851f, -0.00871202f, -0.17172161f, -0.06968883f, -0.05304468f, -0.06234320f, -0.00159448f, 
    0.04200260f, 0.01374249f, -0.07270391f, -0.15143114f, 0.19064814f, -0.01658484f, -0.02325505f, 0.20626254f, 
    -0.01541846f, 0.00145269f, -0.13910495f, 0.00277522f, -0.08131614f, 0.03640831f, -0.00519968f, -0.06126795f, 
    0.19042510f, 0.03999677f, 0.10656912f, 0.01233199f, -0.02866481f, 0.02194425f, -0.03944567f, -0.00493225f, 
    -0.05438157f, 0.00312060f, -0.11871618f, -0.12652576f, -0.06324957f, -0.10568002f, -0.21097544f, -0.07660958f, 
    -0.05420446f, 0.04100838f, 0.01117209f, -0.09248789f, -0.05248333f, -0.03768245f, 0.02308065f, -0.01841328f, 
    0.02803095f, 0.03752633f, -0.03303538f, -0.01251987f, 0.03534786f, -0.03411527f, -0.01489790f, 0.00618848f, 
    -0.02800811f, -0.00571502f, 0.11563865f, -0.00486849f, -0.10036828f, -0.07399239f, -0.00083277f, -0.08844511f, 
    0.03067811f, -0.07013847f, 0.00449642f, -0.05509151f, -0.03973060f, -0.04422912f, 0.07008404f, 0.00360878f, 
    -0.08790185f, 0.02466445f, -0.10846958f, -0.10608698f, 0.03861265f, -0.03863377f, 0.01636623f, -0.02395246f, 
    -0.06480462f, -0.02124241f, 0.00336284f, -0.06302982f, 0.06899396f, 0.17945755f, 0.13345459f, 0.12258334f, 
    0.08316205f, 0.03227692f, 0.07159587f, -0.01700060f, -0.01272989f, -0.06945848f, 0.02369986f, 0.03744189f, 
    0.00168738f, -0.04683516f, 0.10132582f, 0.10851613f, 0.06507111f, -0.02498672f, -0.00721930f, -0.01920118f, 
    0.03748664f, 0.02520009f, -0.00382202f, -0.08010358f, -0.07788938f, -0.04077304f, -0.09472827f, -0.07108407f, 
    -0.08438934f, -0.04298493f, -0.02826166f, -0.01008605f, 0.00156352f, -0.02835055f, -0.07704790f, -0.05704088f, 
    0.00968141f, 0.12705909f, -0.01350531f, 0.01085562f, 0.01577653f, -0.00931796f, 0.00743814f, -0.01846565f, 
    0.09489832f, -0.03039096f, -0.09012153f, -0.00575354f, 0.01955403f, 0.15675290f, 0.01140764f, 0.16086541f, 
    0.03717677f, -0.08608454f, 0.00465985f, 0.04493200f, 0.01715522f, -0.00358166f, -0.04939229f, -0.02299889f, 
    0.11944344f, -0.16170537f, -0.05513046f, -0.16580190f, -0.08214309f, 0.03602699f, -0.02966165f, -0.06352839f, 
    -0.03187976f, 0.05308010f, 0.00664353f, -0.06971347f, -0.16834071f, -0.14065109f, 0.05255431f, 0.02653818f, 
    -0.02737476f, -0.06263050f, -0.06120224f, -0.08855759f, 0.02674148f, 0.00756957f, -0.01917004f, -0.01979286f, 
    -0.13611932f, 0.01066251f, -0.18587710f, -0.08365521f, -0.04468301f, -0.07619275f, -0.06801929f, -0.07468106f, 
    -0.07746582f, -0.03424156f, 0.01719549f, -0.00592281f, -0.15573622f, -0.09921195f, -0.07844514f, 0.01907422f, 
    0.05583194f, 0.07253873f, 0.03698210f, -0.03525335f, -0.01128680f, 0.01912441f, 0.03967797f, -0.05623563f, 
    -0.01586046f, -0.04987423f, -0.10334077f, -0.19926099f, -0.02974619f, -0.06548389f, -0.01187373f, -0.04955532f, 
    -0.05321201f, 0.06839685f, -0.03875824f, -0.07687496f, 0.27368209f, -0.08931648f, 0.17500323f, 0.11900585f, 
    -0.03682414f, -0.03306621f, -0.01684666f, 0.05204939f, 0.01152456f, 0.00941925f, 0.00004320f, -0.03301873f, 
    -0.05197087f, 0.16512612f, 0.03749351f, 0.08910266f, 0.05900587f, -0.01776352f, -0.02572667f, 0.01001858f, 
    -0.01060156f, 0.03467118f, 0.01695913f, -0.07764579f, -0.02584590f, 0.15861468f, 0.14953765f, 0.16777033f, 
    -0.00089293f, 0.06536954f, 0.01671466f, -0.03093052f, -0.05923159f, 0.08679899f, 0.00079424f, 0.00093515f, 
    0.01675520f, 0.11107747f, 0.11687102f, 0.04740761f, -0.00416112f, 0.04431043f, 0.04614446f, 0.02386255f, 
    -0.09752107f, -0.01333852f, -0.04095836f, 0.02337061f, 0.01038939f, -0.10890753f, 0.01805879f, 0.06107853f, 
    0.09070374f, -0.00274269f, 0.01829948f, -0.03189806f, -0.02040321f, 0.04502200f, 0.05793983f, -0.08404283f, 
    -0.00546637f, 0.18686906f, -0.20266731f, -0.06714147f, -0.04218217f, 0.05637208f, -0.02263431f, -0.02968532f, 
    -0.07056540f, 0.00724588f, -0.02109997f, -0.13790962f, -0.08387597f, -0.14649172f, 0.06519837f, -0.00512186f, 
    -0.03480311f, -0.09272379f, -0.01969277f, -0.06540198f, -0.06728351f, -0.00056276f, -0.02954469f, -0.00468501f, 
    0.03432541f, -0.06222063f, -0.07844993f, -0.12971236f, -0.05636233f, -0.01891709f, -0.02165719f, -0.02870683f, 
    -0.03448489f, 0.01057799f, -0.14849856f, -0.03426990f, -0.22496201f, -0.08893803f, 0.09304243f, -0.08267354f, 
    -0.02578913f, 0.00574488f, 0.00348929f, -0.06349853f, -0.05544683f, -0.04395427f, 0.02575375f, -0.06913125f, 
    0.10516934f, -0.13704443f, 0.10469729f, 0.10258977f, -0.04751083f, -0.06048060f, 0.01079537f, 0.01592673f, 
    -0.00693366f, 0.01153238f, -0.02206077f, 0.00340379f, 0.10995904f, -0.09765308f, 0.03326562f, 0.11227288f, 
    -0.07248177f, -0.13188608f, -0.05565735f, -0.05650505f, 0.02896559f, 0.05020621f, 0.04771162f, -0.05105772f, 
    -0.06168689f, -0.14172029f, 0.14517368f, -0.06383349f, -0.03400758f, -0.02546832f, 0.02316392f, 0.09856977f, 
    -0.00730271f, -0.02283985f, -0.04451348f, -0.09795985f, 0.14683308f, 0.01781648f, 0.04837931f, 0.13077615f, 
    -0.03976353f, -0.03776278f, -0.09575830f, -0.07553243f, -0.10238452f, 0.05281474f, -0.05317442f, -0.04003013f, 
    0.00115779f, 0.16989860f, 0.00854560f, 0.08059707f, 0.05842423f, -0.04438426f, 0.03916304f, 0.03643768f, 
    0.05798675f, -0.02459807f, 0.00246048f, -0.02948740f, -0.10978723f, 0.06263980f, -0.02856998f, 0.16660404f, 
    -0.01050597f, -0.09647965f, -0.11722665f, 0.01445916f, -0.01625813f, -0.00087689f, -0.03362828f, 0.01790368f, 
    -0.09161166f, 0.13401109f, -0.09301212f, 0.03638274f, 0.03798581f, 0.03244727f, -0.03678600f, -0.01160071f, 
    0.02829200f, 0.03641635f, 0.01558314f, -0.03942557f, -0.28794950f, -0.03555288f, -0.01333251f, 0.08973818f, 
    -0.05370000f, -0.13666886f, -0.07637024f, -0.01394724f, -0.02974540f, 0.05256034f, 0.06350437f, -0.01987164f, 
    0.06872843f, 0.12507519f, -0.15218171f, 0.10067043f, -0.10268236f, -0.03795746f, -0.09666290f, 0.01320954f, 
    -0.03602673f, -0.08309489f, -0.01423742f, -0.03963565f, -0.15704705f, -0.04003901f, -0.10083720f, -0.08633581f, 
    -0.02404722f, 0.02177182f, -0.06355049f, 0.00429228f, -0.06787357f, -0.02738605f, 0.05276086f, -0.06048615f, 
    -0.20613439f, -0.16070712f, -0.12425260f, -0.15247004f, -0.08144035f, 0.02388675f, -0.07051623f, -0.00814995f, 
    0.00807842f, 0.01933437f, -0.00478653f, -0.00251675f, 0.19925246f, -0.30774423f, 0.08850777f, 0.06989079f, 
    0.07742848f, 0.03545426f, 0.04184159f, -0.03553958f, -0.04879865f, -0.13332392f, 0.01048407f, -0.08693366f, 
    0.05182850f, 0.15142581f, 0.06418844f, 0.24830449f, 0.14114545f, 0.14459258f, 0.09019141f, -0.11516696f, 
    -0.00311203f, -0.01020353f, 0.04146672f, -0.08953077f, 0.23194805f, 0.00112219f, -0.03033640f, -0.02114161f, 
    0.02694622f, 0.00499389f, -0.05132697f, -0.09433087f, -0.09747642f, -0.03704517f, -0.01709174f, 0.00265930f, 
    0.21507028f, 0.08313098f, 0.15824561f, 0.09118606f, 0.01926182f, 0.04719654f, 0.01614038f, -0.02164568f, 
    -0.01802807f, 0.01247642f, 0.05166625f, 0.00766549f, -0.21516214f, 0.12702167f, -0.06249313f, -0.14194748f, 
    -0.02939608f, -0.08226380f, -0.00670242f, -0.10111912f, -0.05661626f, 0.00201762f, -0.04785011f, -0.03551646f, 
    -0.00258958f, 0.15739916f, 0.03862366f, -0.16432939f, -0.02620412f, 0.02422793f, -0.00346144f, -0.08747222f, 
    -0.09188060f, -0.03836800f, -0.08043090f, 0.03637604f, 0.30523738f, 0.16284356f, -0.01739060f, -0.03665013f, 
    -0.11505184f, -0.10667528f, 0.01989184f, -0.03911761f, -0.02454440f, -0.02510172f, -0.03201873f, -0.00166146f, 
    -0.01852070f, 0.17713557f, 0.01196646f, 0.09717152f, 0.06027705f, -0.06496488f, -0.05531729f, -0.05279629f, 
    0.00106698f, 0.01714122f, -0.04646590f, -0.07808448f, -0.04645005f, 0.09203015f, -0.01140452f, 0.02734823f, 
    -0.08062346f, -0.01347404f, -0.04266690f, -0.01471572f, 0.03423852f, -0.01472083f, -0.04592872f, -0.01966614f, 
    0.31220353f, -0.01276989f, 0.17839101f, -0.09790239f, -0.07898401f, 0.03084513f, -0.05213235f, -0.05411726f, 
    -0.03450606f, 0.10692620f, -0.02311235f, 0.02395932f, 0.06992790f, 0.01504142f, -0.06753628f, -0.13272075f, 
    -0.02342556f, 0.03449468f, 0.02538337f, -0.05945379f, -0.08287602f, -0.06088906f, 0.03783173f, -0.03100018f, 
    0.14675547f, -0.05335421f, 0.21494330f, 0.18230847f, 0.12765269f, 0.01279572f, 0.00489890f, -0.08837817f, 
    -0.05119243f, -0.02015126f, -0.00567037f, -0.07556931f, 0.21177161f, -0.31358647f, 0.03289210f, 0.00574088f, 
    0.03904131f, -0.03895411f, 0.00325693f, -0.04583811f, 0.00121485f, -0.04598281f, -0.03055578f, -0.08054157f, 
    -0.11490113f, 0.08837435f, 0.08277249f, 0.00868675f, -0.01096821f, -0.07695984f, 0.00663946f, -0.00755408f, 
    -0.05267369f, 0.03640526f, 0.05055024f, 0.03035341f, 0.04272131f, 0.07437701f, 0.13290969f, 0.14978722f, 
    0.02938250f, 0.05721311f, 0.05985453f, -0.04258620f, -0.06126824f, -0.02867335f, -0.06267840f, -0.07099368f, 
    0.11428586f, 0.11832051f, 0.01396620f, 0.15260160f, -0.02672420f, -0.08496145f, -0.05428783f, -0.06152615f, 
    -0.04105115f, -0.04446007f, -0.09147212f, -0.08819694f, 0.00267580f, -0.20030904f, -0.05038112f, -0.09044882f, 
    0.00667412f, 0.01338161f, -0.03804034f, -0.09004937f, -0.04611171f, -0.01527821f, -0.07087869f, -0.08179361f, 
    0.02886913f, 0.03153558f, -0.03352220f, -0.08518479f, 0.07286701f, 0.03725719f, -0.02525991f, -0.05152179f, 
    0.02074078f, 0.06806444f, -0.02721876f, -0.07951246f, 0.01565044f, -0.28864893f, -0.10926474f, -0.10309956f, 
    -0.03789349f, -0.04234370f, -0.07783178f, 0.02776141f, 0.00630457f, -0.00857729f, -0.04247661f, 0.00032503f, 
    0.04358095f, 0.08487215f, -0.20354937f, 0.10367931f, -0.00543630f, 0.04019477f, -0.01918043f, -0.02255914f, 
    -0.12490063f, -0.04761110f, -0.04144499f, -0.08404657f, 0.06145702f, 0.14866675f, 0.13568220f, 0.02472397f, 
    0.09980711f, 0.03935600f, 0.05062262f, 0.01035536f, -0.12379555f, 0.03541563f, -0.00375687f, -0.06945112f, 
    -0.11672222f, -0.03711738f, -0.13909209f, 0.07928650f, -0.00602020f, -0.02778527f, -0.04550589f, 0.03366515f, 
    -0.09186539f, 0.01091469f, 0.02419962f, 0.00142358f, 0.00748351f, 0.03440565f, 0.07009690f, 0.03926760f, 
    0.01598811f, 0.03621239f, 0.01856473f, -0.05194393f, -0.01533560f, 0.04218168f, -0.00148956f, -0.06193729f, 
    0.01455511f, 0.03359542f, 0.01215733f, 0.00457781f, -0.00677033f, -0.03012264f, 0.04497275f, -0.00689919f, 
    0.07844643f, -0.04543614f, 0.03960522f, -0.01995390f, -0.03129280f, -0.04421036f, 0.00036299f, 0.18481514f, 
    0.07089814f, 0.03056675f, -0.01864469f, -0.06601725f, 0.13369605f, -0.01086708f, 0.04629648f, -0.14083631f, 
    -0.18896683f, -0.17681533f, -0.03078862f, -0.09196065f, -0.10405935f, 0.04152303f, 0.05723063f, -0.02093947f, 
    0.10103888f, -0.08905245f, 0.00818047f, 0.04453637f, -0.14674734f, -0.26375455f, 0.08943716f, 0.06666984f, 
    -0.13652425f, -0.00272801f, 0.00879288f, -0.05893986f, 0.01996135f, -0.04551798f, -0.07089388f, 0.10311995f, 
    0.10302196f, 0.03597179f, 0.07236513f, 0.09431102f, -0.01733251f, -0.03436321f, -0.07414823f, -0.04026207f, 
    -0.11334844f, 0.06939092f, -0.09208710f, 0.02846290f, -0.17082380f, -0.01658715f, -0.13891989f, -0.12787469f, 
    -0.02509033f, -0.06101514f, 0.03112908f, -0.06195040f, 0.10199375f, 0.07298123f, 0.00568737f, 0.01082829f, 
    -0.03736390f, -0.03359844f, 0.06093731f, -0.16941404f, -0.03951447f, 0.01787561f, 0.09372672f, -0.12371200f, 
    -0.00201698f, 0.04984922f, 0.01486820f, 0.07761194f, -0.04545855f, -0.00763275f, 0.04658302f, 0.09411234f, 
    0.06933399f, 0.04116460f, -0.06206446f, -0.07206492f, 0.01903721f, 0.01313304f, 0.07438152f, -0.06221998f, 
    0.16318370f, 0.02507409f, 0.11763906f, 0.00035140f, -0.04264664f, -0.18866156f, -0.03500265f, -0.12493806f, 
    -0.02599268f, 0.05879198f, -0.06355272f, -0.05819246f, 0.13606329f, -0.01036405f, 0.06289144f, 0.09155881f, 
    -0.11137768f, -0.01830115f, -0.05634702f, -0.04706297f, 0.03684572f, -0.11016601f, -0.02465151f, -0.00123386f, 
    0.11220466f, -0.04304328f, -0.00612161f, 0.06595206f, -0.00899861f, -0.04873277f, -0.05870341f, 0.00041032f, 
    0.03893833f, 0.02207078f, 0.05417969f, 0.00598496f, 0.09629369f, 0.02586432f, -0.03360697f, 0.07165347f, 
    -0.03747698f, -0.03593497f, -0.00018481f, -0.03128978f, 0.00384538f, -0.00539847f, 0.00093495f, 0.06073791f, 
    -0.08212601f, -0.26864195f, -0.02952630f, -0.21852617f, 0.04125391f, -0.07160328f, 0.03763136f, -0.10798535f, 
    -0.04944596f, 0.02169003f, 0.07249714f, -0.21720776f, 0.03373385f, 0.10398473f, -0.21675205f, -0.12583189f, 
    0.07775614f, 0.02152112f, -0.05818442f, -0.12007611f, 0.02182405f, -0.04498268f, -0.06981230f, 0.03661810f, 
    -0.01458210f, 0.07822703f, -0.00912324f, 0.17272894f, 0.04489754f, 0.04629355f, -0.10541905f, 0.05417439f, 
    -0.06547141f, -0.07715808f, 0.09987969f, 0.02533875f, 0.10400854f, 0.24120764f, -0.23866624f, -0.15802526f, 
    0.05954029f, -0.08933255f, -0.20106143f, -0.00563897f, 0.00971651f, -0.01958968f, 0.14132884f, 0.06141065f, 
    -0.19240500f, -0.13756607f, 0.07534987f, 0.09495140f, 0.07582600f, -0.10564058f, -0.05482211f, -0.03775655f, 
    0.05467647f, -0.00194022f, -0.08448058f, 0.01180695f, 0.20821770f, 0.12394416f, 0.04502670f, 0.07882168f, 
    0.03146810f, -0.00850807f, -0.12284973f, -0.11574997f, -0.06981514f, -0.01548214f, -0.00707800f, -0.07818294f, 
    0.08285382f, -0.05006595f, -0.00054428f, -0.04575859f, -0.03402060f, -0.05161166f, 0.02410930f, 0.00642263f, 
    0.06340474f, 0.05978536f, 0.05199423f, -0.04861692f, -0.00725218f, 0.13708566f, -0.17619567f, -0.07675925f, 
    -0.05546118f, -0.03134578f, -0.01461824f, -0.04739233f, 0.09552392f, -0.08529636f, -0.00328997f, 0.10144888f, 
    0.00166390f, 0.07488357f, 0.11618889f, 0.03336986f, 0.01839148f, 0.03865935f, -0.05085798f, -0.04656573f, 
    0.01031005f, -0.06042824f, 0.07358117f, 0.00315620f, 0.11252485f, -0.26827270f, -0.23507521f, -0.21365514f, 
    -0.07469275f, -0.09627530f, 0.10848699f, -0.12911424f, -0.07379121f, 0.03693617f, -0.07650261f, 0.01898652f, 
    -0.07837336f, 0.00842991f, -0.06848112f, -0.04818035f, -0.01749092f, -0.01908558f, -0.06930701f, -0.05970663f, 
    0.01181510f, -0.09068310f, -0.05875227f, 0.09841365f, -0.07635742f, 0.08464243f, 0.13292439f, 0.08871006f, 
    -0.18137935f, 0.06384689f, -0.10005865f, 0.04493899f, 0.00827044f, 0.00893285f, -0.05217833f, -0.02173431f, 
    -0.22345407f, 0.23285319f, -0.01354645f, -0.02134766f, -0.06074304f, 0.03000723f, -0.14405873f, -0.07156634f, 
    0.07641373f, 0.04984510f, 0.02047813f, -0.02933841f, 0.05270581f, -0.14033546f, 0.08977361f, -0.05177447f, 
    -0.10173644f, -0.15932570f, -0.10593626f, -0.01923676f, 0.02097480f, -0.02646634f, -0.03290564f, 0.00719809f, 
    -0.01824583f, -0.11567000f, 0.11878701f, 0.00509348f, 0.00189534f, 0.02482068f, 0.02863077f, 0.04195757f, 
    -0.07058499f, -0.00713751f, 0.00877733f, 0.04781918f, 0.01074634f, -0.30424726f, -0.00304071f, 0.07234752f, 
    0.08054923f, -0.02141206f, -0.05567896f, -0.07755561f, -0.00161275f, 0.04126966f, 0.05556415f, -0.05140879f, 
    0.11880547f, 0.13213983f, 0.13536772f, 0.02554394f, 0.04271831f, -0.05267852f, -0.00159215f, -0.07457276f, 
    0.09271603f, -0.11428155f, 0.03337999f, -0.11806892f, 0.03384067f, -0.19837779f, 0.09166725f, -0.00231392f, 
    -0.05477326f, 0.04298761f, 0.00028452f, 0.05274717f, -0.01356672f, -0.04759068f, -0.02132062f, 0.12111847f, 
    0.08965465f, 0.07346167f, -0.03111559f, 0.04578789f, 0.01175987f, -0.08796689f, -0.09665595f, -0.15692063f, 
    -0.02292020f, 0.01130561f, 0.05013044f, -0.06070702f, 0.19017388f, -0.12687284f, -0.16749264f, -0.10162902f, 
    -0.01436209f, -0.03615445f, 0.03847996f, -0.05161415f, 0.03318401f, 0.01072629f, 0.10312660f, 0.05399977f, 
    -0.03197913f, -0.12167227f, 0.09602647f, 0.05127947f, -0.11272608f, -0.15260716f, -0.00211690f, 0.06330183f, 
    0.01077105f, 0.05890479f, -0.09809317f, -0.06003280f, -0.11762312f, -0.08068678f, -0.08439297f, -0.20534016f, 
    -0.02138477f, -0.12239400f, -0.07645751f, -0.06370507f, 0.02478804f, -0.10219835f, -0.07007653f, -0.15683480f, 
    -0.06523997f, 0.11034676f, -0.02998325f, 0.01318052f, 0.01224843f, -0.03832974f, -0.16386385f, -0.06524459f, 
    -0.04395624f, -0.02372943f, 0.08144286f, -0.05841811f, -0.03878028f, 0.21137047f, -0.18501209f, -0.18425173f, 
    -0.07448951f, -0.08603247f, -0.09853320f, -0.00992409f, 0.06279414f, 0.01873107f, 0.11162034f, -0.01445867f, 
    0.03378720f, 0.30196935f, -0.20377477f, 0.10653233f, 0.09882356f, -0.00784602f, -0.12227356f, -0.00536944f, 
    0.05961750f, 0.01633985f, -0.01021396f, 0.00728760f, -0.20318832f, 0.02769810f, -0.08499431f, 0.09404135f, 
    0.04473931f, 0.08146968f, -0.00099161f, 0.00896382f, 0.10905563f, -0.01846208f, 0.04600270f, -0.04584971f, 
    0.03892655f, 0.09372734f, 0.01707078f, -0.11983389f, -0.10155784f, 0.03868463f, 0.07502461f, 0.09526481f, 
    0.02102401f, 0.07652049f, 0.01690792f, 0.01041632f, 0.06306658f, -0.06486627f, -0.22782831f, 0.08200895f, 
    0.10077845f, 0.07291600f, 0.01529922f, -0.07205991f, -0.05914320f, 0.03651490f, -0.02289488f, 0.05750063f, 
    -0.04071934f, -0.15923560f, 0.04048683f, 0.10188409f, 0.06623932f, 0.01284140f, 0.02233966f, -0.01807196f, 
    0.01530266f, 0.11618719f, 0.08205160f, 0.08057091f, 0.12096768f, -0.07611678f, -0.01739451f, -0.00290251f, 
    -0.06524311f, 0.03767181f, -0.00469815f, 0.00366952f, 0.04677944f, -0.00936347f, -0.14903387f, 0.10083774f, 
    -0.20094904f, -0.17497140f, 0.16967689f, -0.07361062f, -0.04318433f, -0.02726989f, -0.05402132f, -0.08940699f, 
    0.06141615f, 0.01523206f, -0.01675613f, -0.08220829f, 0.16945504f, -0.10365031f, -0.05669887f, -0.10237038f, 
    0.05178725f, -0.00196517f, -0.05808418f, 0.03830814f, -0.04054359f, 0.04592032f, 0.04457048f, 0.07844280f, 
    -0.03620713f, 0.03594216f, 0.06942819f, -0.11194339f, 0.08827098f, 0.00713842f, 0.13543539f, -0.03438866f, 
    0.03514831f, 0.09302621f, 0.01854876f, 0.09933686f, 0.04224196f, -0.07101387f, 0.09600707f, 0.18470411f, 
    0.08027556f, 0.05804715f, -0.06074753f, -0.05053842f, 0.04216211f, 0.06405982f, 0.08164539f, -0.07481555f, 
    0.18395486f, -0.09123038f, 0.00841864f, 0.07120325f, 0.04798942f, -0.11269262f, -0.09926651f, 0.03316586f, 
    -0.02120707f, -0.01857378f, 0.04688543f, -0.22712904f, -0.12902808f, -0.22908184f, 0.02002372f, -0.24481447f, 
    -0.00557704f, -0.05554984f, 0.10424955f, 0.07332121f, 0.02004288f, 0.03434062f, 0.02498856f, 0.06284504f, 
    0.09404637f, 0.19814713f, -0.09211177f, 0.08857775f, -0.01127034f, -0.04314715f, 0.04261217f, -0.01578480f, 
    0.02699403f, -0.12592590f, 0.00063473f, 0.12114733f, 0.02342436f, 0.23366860f, -0.23098946f, -0.06409110f, 
    -0.00884040f, -0.00816107f, -0.08838291f, -0.01026403f, 0.02642793f, 0.04003406f, -0.09164273f, 0.06512813f, 
    -0.05718039f, 0.02153678f, 0.12464575f, -0.03942915f, -0.04475017f, -0.02305193f, -0.03597017f, 0.02191236f, 
    -0.03869376f, -0.01897932f, -0.07027477f, 0.02860975f, 0.13377921f, 0.04257607f, -0.08865904f, 0.13158731f, 
    0.13170439f, 0.00976758f, -0.00690393f, -0.03951950f, -0.00618918f, 0.07052648f, 0.04615971f, -0.00076172f, 
    0.02731433f, 0.11732055f, 0.04171130f, -0.26341996f, 0.00552835f, -0.14170986f, -0.09705921f, -0.00898197f, 
    0.03838943f, 0.02162543f, 0.03547184f, 0.02817632f, 0.08857086f, -0.07406321f, -0.02109123f, 0.00383043f, 
    0.05611139f, -0.09268113f, 0.00637736f, -0.07385660f, 0.08449601f, 0.06334527f, 0.04289009f, 0.10974287f, 
    0.16999972f, -0.08419480f, 0.04452918f, 0.01429684f, -0.04170119f, -0.16907489f, 0.01243465f, 0.01150421f, 
    0.01106654f, -0.02481266f, -0.13910125f, -0.01064957f, -0.05131841f, -0.00689764f, 0.14460838f, -0.00178938f, 
    -0.04273450f, 0.01223743f, 0.08149320f, -0.10934302f, 0.05124816f, -0.04009058f, 0.04285964f, -0.16032732f, 
    -0.14542401f, -0.10972480f, -0.07301950f, -0.32571435f, -0.12563121f, -0.03450393f, -0.01216321f, 0.09620603f, 
    0.09948311f, 0.06223646f, -0.06638486f, 0.00437923f, 0.16850962f, -0.09485559f, 0.02835702f, 0.07749628f, 
    0.05979221f, 0.00935556f, -0.01804136f, -0.00840758f, 0.10416419f, -0.12452054f, -0.03653095f, -0.05969228f, 
    0.01321165f, -0.20687689f, 0.14727265f, -0.01685517f, -0.03102580f, 0.11711759f, 0.01581888f, -0.00856373f, 
    0.09256324f, -0.10153449f, -0.02069201f, -0.07652326f, 0.04029776f, -0.11432353f, -0.18270189f, -0.03996993f, 
    0.06270915f, 0.00822183f, 0.00744386f, 0.01123074f, 0.05773737f, 0.08809299f, -0.02726336f, -0.04948647f, 
    -0.09562516f, 0.03819078f, -0.13113633f, -0.29372928f, 0.09670271f, -0.06689084f, 0.05763974f, 0.17018901f, 
    0.06452607f, 0.00473807f, 0.06055614f, -0.07219991f, -0.25381160f, -0.18109763f, 0.13236362f, 0.05433344f, 
    -0.08629822f, -0.06421656f, -0.03011158f, -0.18226659f, 0.04532572f, -0.03476166f, -0.06904203f, -0.07888936f, 
    0.16848546f, 0.02153676f, -0.24637103f, -0.23501609f, 0.04284619f, -0.08630620f, 0.03953129f, -0.01384081f, 
    0.07437719f, -0.01177847f, -0.06758126f, 0.03091618f, -0.08767880f, -0.16469333f, 0.02556678f, -0.09711995f, 
    -0.07009786f, -0.15145282f, 0.03480133f, -0.01537399f, -0.00769742f, 0.06895155f, -0.06557239f, 0.13376410f, 
    -0.40481186f, -0.23237447f, 0.15427998f, -0.12483922f, 0.01915559f, -0.00732123f, 0.00611396f, -0.01529939f, 
    0.08616336f, -0.04527277f, 0.07689558f, 0.06849404f, -0.18019396f, 0.25664252f, -0.22880347f, -0.48090881f, 
    0.08166548f, 0.00321318f, -0.16894247f, 0.04087494f, -0.05063382f, 0.08363447f, 0.05438057f, -0.13768159f, 
    0.04863798f, -0.09187955f, -0.13134243f, -0.04123813f, -0.00758617f, -0.10817654f, 0.00749334f, 0.00635475f, 
    -0.08181537f, -0.03074913f, 0.09909311f, 0.00146613f, -0.12539984f, 0.30649915f, -0.15990619f, 0.10027212f, 
    0.04059770f, -0.04579356f, -0.01625457f, 0.07873277f, 0.05187945f, 0.07892419f, 0.04467179f, -0.05100926f, 
    -0.30665803f, 0.17179547f, 0.02973711f, -0.06500394f, 0.05018641f, -0.04931047f, 0.02068559f, -0.08339660f, 
    0.10728743f, 0.09333014f, 0.09847619f, 0.01382260f, 0.01716179f, -0.05663941f, -0.33677101f, 0.18481140f, 
    -0.09179635f, 0.11599577f, -0.02263677f, 0.06477271f, -0.10006107f, 0.08478583f, 0.15000328f, 0.10382479f, 
    -0.24716757f, -0.09820765f, -0.02869367f, -0.14913173f, 0.02343082f, 0.00555371f, 0.06798176f, 0.02307528f, 
    0.01344428f, 0.12922771f, -0.06666639f, -0.07350328f, 0.22595832f, -0.02565319f, -0.15420176f, -0.06908001f, 
    0.04327373f, 0.07758518f, -0.14907579f, -0.13860069f, -0.01616942f, -0.01067675f, 0.09954204f, 0.08686778f, 
    0.24013577f, 0.10402807f, -0.10522381f, 0.10003746f, 0.00969887f, 0.00773096f, -0.00137217f, 0.06131088f, 
    0.02705302f, -0.03330707f, 0.01262539f, 0.06189703f, 0.14415623f, -0.19855200f, -0.01792366f, 0.02204941f, 
    0.06397320f, 0.02867272f, 0.03437744f, -0.15856899f, -0.05430099f, -0.02336943f, 0.10338820f, -0.01256978f, 
    -0.03452154f, 0.04595118f, 0.03529986f, -0.26049328f, 0.04006369f, 0.10995223f, 0.08275495f, -0.03536586f, 
    -0.04068804f, -0.01170629f, 0.03364592f, 0.07375830f, -0.28213018f, -0.13502252f, 0.20774937f, 0.12599601f, 
    0.10240395f, -0.00984954f, -0.02875416f, -0.05651331f, 0.00736280f, -0.03533172f, 0.07655114f, 0.04750007f, 
    0.07976618f, -0.05310200f, -0.32787785f, -0.11199638f, 0.03586952f, -0.00941282f, -0.04363786f, 0.12281892f, 
    0.02165052f, 0.00270150f, -0.16166379f, 0.06630888f, 0.13473086f, 0.18595931f, 0.08234394f, 0.13413902f, 
    -0.03748164f, 0.01401066f, 0.17486021f, 0.03481191f, 0.04266975f, 0.06453645f, -0.01439947f, 0.07010147f, 
    0.03275679f, -0.27757737f, 0.22649142f, -0.16432826f, -0.01599168f, -0.00228718f, -0.01315760f, 0.01778387f, 
    0.03674533f, 0.13879558f, -0.02578800f, -0.05365084f, -0.23758742f, 0.06250435f, 0.31288403f, -0.15271546f, 
    0.05844323f, -0.05227588f, -0.04518243f, -0.06170641f, 0.02600147f, 0.01443314f, 0.13248961f, -0.03936946f, 
    0.14769159f, -0.18153001f, 0.11932756f, -0.04895982f, 0.03082735f, 0.03175004f, -0.14133824f, -0.11724515f, 
    0.05731640f, 0.05040190f, 0.14753376f, 0.07764698f, 0.19674622f, -0.32635206f, -0.10827412f, -0.05090232f, 
    0.04118226f, 0.02691803f, -0.08645227f, 0.01529118f, -0.08943325f, 0.01953605f, 0.12187637f, 0.03010376f, 
    -0.14662150f, 0.05198000f, 0.04377395f, -0.22547753f, 0.15907864f, -0.04095269f, 0.15080829f, 0.04483955f, 
    0.05514466f, -0.07511766f, -0.03351973f, -0.00597154f, 0.00187936f, 0.27156723f, -0.25982964f, 0.23646832f, 
    0.08469106f, 0.08930871f, 0.00368595f, 0.02255451f, -0.12232566f, -0.05083446f, -0.02570489f, 0.01747404f, 
    0.28067076f, -0.06012269f, 0.11871078f, -0.20075563f, 0.00360134f, 0.06029768f, -0.08785611f, -0.07090830f, 
    0.00642164f, 0.01425731f, -0.03030922f, -0.14967398f, -0.05091420f, 0.04605582f, 0.02344860f, -0.04316929f, 
    -0.00559811f, 0.01412654f, -0.13775033f, 0.03502544f, 0.12310336f, -0.00115301f, -0.00110716f, 0.07005796f, 
    -0.21729164f, -0.22136863f, -0.04825794f, 0.02217407f, -0.00413846f, -0.00635086f, -0.04915559f, 0.04607543f, 
    0.01026429f, -0.08063528f, 0.08490811f, -0.14231101f, 0.12664160f, 0.01696704f, -0.10016617f, 0.00253299f, 
    0.14412703f, 0.04200960f, 0.06967212f, 0.06445938f, -0.02062199f, 0.01928826f, -0.01741395f, 0.00496686f, 
    -0.17221923f, -0.03308909f, -0.20746346f, 0.08763678f, -0.03757796f, -0.03203561f, 0.03364138f, 0.10007096f, 
    -0.02467354f, 0.00335903f, 0.04002115f, -0.01884228f, -0.16319010f, 0.14990354f, -0.10415650f, 0.20768076f, 
    -0.03427999f, -0.05931505f, 0.02691875f, -0.06094008f, 0.12404309f, -0.01217824f, 0.00450509f, -0.02005490f, 
    -0.04069613f, 0.14333829f, -0.04399261f, -0.14774993f, 0.08487865f, -0.12864776f, -0.05087687f, -0.03572954f, 
    -0.01042254f, -0.12875061f, 0.02530971f, 0.03871625f, -0.03649509f, -0.12971592f, 0.02830148f, 0.08276945f, 
    -0.06495342f, -0.05547665f, -0.02385886f, -0.03050397f, 0.05828707f, -0.00999852f, 0.04487590f, -0.08629676f, 
    0.39773619f, 0.04817820f, -0.19361576f, -0.20296302f, 0.11679909f, -0.02352132f, 0.07467777f, 0.02705484f, 
    -0.06454757f, 0.04536965f, -0.01459973f, 0.10264146f, 0.20287897f, 0.21527411f, -0.22996806f, 0.06016305f, 
    0.02851661f, -0.09446947f, -0.02323832f, -0.07129908f, 0.01124596f, -0.02733084f, -0.09294927f, 0.10049844f, 
    0.54401833f, -0.26721328f, -0.12185980f, -0.03586478f, 0.03902661f, 0.00420170f, 0.11688197f, 0.00014586f, 
    -0.04780255f, -0.01437727f, -0.10268332f, -0.07188306f, -0.07988070f, 0.15586463f, -0.08958653f, -0.13018021f, 
    -0.01151685f, -0.04613647f, -0.03447695f, 0.01069535f, -0.04639997f, 0.07848629f, -0.07088027f, -0.10904487f, 
    0.09764051f, -0.03192203f, -0.10907702f, 0.25749689f, 0.02428004f, 0.00797751f, -0.01281460f, -0.04990906f, 
    0.00750071f, -0.01463887f, 0.08477350f, 0.04668383f, -0.29944640f, 0.12379608f, 0.06396956f, -0.12636822f, 
    -0.08335482f, 0.07526278f, -0.02362015f, -0.00646082f, -0.08528278f, 0.07138815f, -0.03435950f, 0.09475816f, 
    -0.20112103f, -0.25843665f, 0.16764304f, 0.00036191f, 0.03143287f, 0.04490604f, 0.00367807f, 0.13308962f, 
    0.02949185f, -0.04079223f, 0.04587613f, -0.03438378f, -0.13543490f, -0.05951845f, 0.06553827f, -0.15499952f, 
    -0.05345463f, 0.00915353f, -0.07721332f, 0.00930734f, -0.02141561f, -0.04371175f, -0.04754542f, 0.03879360f, 
    -0.05856709f, 0.04091511f, 0.21019219f, 0.04116651f, 0.08401762f, -0.00157578f, -0.02354758f, 0.16002418f, 
    0.04843637f, 0.04906342f, -0.05267469f, -0.13357124f, -0.15760219f, -0.00503035f, -0.06879071f, -0.37204951f, 
    -0.02307749f, 0.02435225f, -0.06067896f, 0.04449135f, 0.01626785f, -0.02277981f, -0.07221555f, -0.05332098f, 
    0.30286622f, 0.15602033f, 0.03142977f, 0.04515301f, 0.03549415f, -0.03472859f, -0.03202455f, 0.18552938f, 
    -0.07491912f, -0.01238214f, -0.04453482f, -0.02455722f, -0.19017805f, 0.00031262f, 0.08025932f, -0.00464940f, 
    0.00609552f, 0.03908042f, -0.08504690f, -0.05798289f, -0.03535724f, -0.13724650f, -0.01150058f, -0.02644082f, 
    -0.01850910f, -0.01826633f, 0.10878910f, -0.12992802f, -0.04667955f, -0.04676224f, -0.00300957f, -0.00500194f, 
    -0.04125400f, -0.01380765f, -0.11217940f, -0.21938702f, 0.11209469f, -0.53453374f, 0.29410201f, -0.22881223f, 
    0.04620909f, 0.01633736f, 0.11625898f, -0.07160011f, -0.04963149f, -0.04577094f, 0.06619926f, 0.00064705f, 
    -0.02644477f, -0.18739298f, -0.11715592f, 0.12430156f, -0.00685413f, -0.02662715f, 0.01914650f, 0.01180602f, 
    -0.03453214f, -0.11705622f, 0.03124216f, -0.02255949f, 0.24890374f, 0.10288163f, 0.12511835f, -0.08267789f, 
    0.03443506f, 0.03171303f, 0.03072857f, -0.15075961f, -0.05207042f, 0.07809479f, 0.04821924f, 0.00417795f, 
    -0.22662577f, -0.15706451f, -0.03999859f, 0.20267139f, -0.09058065f, 0.03677116f, -0.10170508f, 0.01805489f, 
    0.06291138f, 0.03800088f, -0.01195130f, -0.15633212f, -0.24564472f, 0.09332782f, -0.04725061f, -0.30039743f, 
    0.07420036f, 0.04842656f, 0.00228926f, -0.01117637f, -0.18917227f, -0.11836082f, -0.04166323f, -0.07775857f, 
    -0.19397642f, 0.04185564f, -0.09236892f, 0.15175211f, 0.06521386f, -0.03129091f, -0.02641249f, 0.00233266f, 
    -0.00850539f, 0.04957595f, 0.04944553f, 0.10484910f, -0.01670431f, 0.12266210f, -0.17265077f, -0.12560362f, 
    -0.00788706f, 0.00051363f, -0.00990897f, 0.07600322f, -0.04441179f, -0.03785092f, -0.01498842f, 0.10076024f, 
    -0.16912684f, -0.12865721f, 0.09815100f, -0.09266025f, 0.04313172f, 0.02188318f, -0.05638232f, 0.04092280f, 
    -0.03920883f, -0.07698155f, 0.07582929f, 0.03798192f, -0.03905964f, 0.13547072f, 0.24585153f, 0.06625420f, 
    -0.00801336f, -0.05127763f, 0.00744662f, 0.08627820f, 0.00371341f, 0.01826376f, 0.05047953f, 0.11509533f, 
    -0.11903219f, -0.16223314f, -0.06202215f, 0.11403593f, -0.09525331f, -0.08530166f, -0.04380438f, 0.01581672f, 
    0.00226431f, 0.11129940f, 0.02000764f, -0.10934118f, -0.00181835f, 0.00271832f, 0.04019692f, -0.20985444f, 
    0.15510237f, -0.00439744f, -0.12896815f, -0.03399516f, -0.08451249f, 0.05907318f, -0.18335898f, -0.04394162f, 
    0.25660959f, -0.42701775f, 0.01702169f, 0.00816357f, -0.06811472f, -0.07576790f, 0.00228059f, 0.11868273f, 
    -0.06614386f, 0.10163048f, 0.08111005f, -0.16403997f, 0.21992950f, -0.24331260f, 0.09133317f, -0.15258421f, 
    -0.04347072f, 0.08953214f, -0.14731181f, 0.05206885f, 0.05416470f, -0.16237226f, -0.04656237f, -0.10557929f, 
    -0.40259287f, 0.03675822f, -0.01451516f, 0.02401691f, 0.05289956f, 0.02329607f, 0.04707827f, -0.10892978f, 
    0.01210860f, 0.01320773f, -0.07643447f, 0.05142446f, 0.05643431f, -0.14213146f, -0.01574406f, 0.05571684f, 
    -0.03785909f, 0.00800319f, 0.01512801f, 0.02954274f, -0.00534472f, 0.16890232f, -0.07186787f, -0.05432373f, 
    0.05726746f, -0.06085988f, -0.06554706f, -0.02936871f, -0.13464668f, -0.01380205f, 0.06861740f, -0.15904748f, 
    0.07368128f, 0.01350500f, -0.06271071f, -0.13561317f, 0.07113034f, 0.05442768f, -0.02071311f, -0.09683286f, 
    0.03082022f, 0.14258198f, -0.03992168f, -0.13496226f, 0.01694007f, 0.01258060f, -0.24903707f, 0.14493717f, 
    -0.01530782f, -0.03706426f, 0.10576070f, -0.28421545f, -0.05918454f, -0.16422491f, 0.05758467f, -0.12667929f, 
    0.09169469f, 0.09106204f, 0.07526033f, 0.12212937f, 0.02339303f, -0.05741536f, 0.11531959f, -0.01354744f, 
    -0.11969564f, 0.01719602f, -0.06090452f, 0.14844339f, -0.02805926f, -0.03610640f, -0.03600698f, -0.02450896f, 
    -0.13388555f, 0.00800090f, 0.20198047f, -0.22135213f, -0.03269267f, 0.05904850f, 0.09903064f, -0.02875632f, 
    0.04013040f, 0.03076371f, 0.08973482f, 0.05937841f, 0.15099879f, -0.30737141f, -0.01605446f, 0.04005594f, 
    -0.00528467f, 0.03335491f, 0.03379625f, -0.01981282f, -0.00910791f, 0.02769364f, -0.02776577f, 0.01997338f, 
    0.22752029f, 0.02774495f, 0.21485764f, -0.00799273f, 0.00854869f, 0.11453191f, -0.19583932f, -0.00712405f, 
    -0.12464567f, -0.13328896f, 0.02165247f, 0.03443999f, -0.02675757f, 0.11913881f, 0.02223975f, -0.09415162f, 
    0.01030389f, 0.10972621f, -0.03802970f, 0.14593369f, 0.04912698f, 0.05711964f, -0.08257383f, -0.01284155f, 
    -0.14310844f, -0.02583480f, -0.12366066f, -0.00145018f, -0.04679716f, -0.01610730f, -0.00147487f, -0.00884401f, 
    -0.06688710f, 0.00378332f, 0.06437214f, -0.11163080f, -0.27735716f, -0.28615376f, -0.02651428f, -0.33462107f, 
    0.03042084f, -0.07126140f, 0.02493277f, -0.08894099f, 0.05559494f, -0.13020685f, 0.09538643f, -0.06375349f, 
    -0.24791044f, 0.07321367f, 0.21363249f, -0.04195428f, 0.07359218f, 0.00091062f, 0.03054685f, -0.10848592f, 
    0.03617811f, 0.02117784f, -0.12354760f, -0.01815383f, 0.08909377f, 0.02164198f, -0.13269034f, -0.00235615f, 
    0.03523388f, -0.05658790f, -0.01762444f, 0.11973572f, -0.02305605f, -0.23886031f, -0.04891965f, 0.06730955f, 
    -0.30698600f, -0.24351849f, -0.18923986f, -0.07737191f, 0.07495868f, 0.01525012f, 0.07662857f, -0.04774603f, 
    0.06618150f, -0.04930462f, -0.07778421f, 0.10156174f, -0.28108558f, -0.21847415f, 0.12814805f, 0.02256896f, 
    -0.08824787f, 0.01117491f, 0.12065707f, 0.01202030f, 0.02126005f, -0.12568948f, 0.06051574f, 0.00214439f, 
    0.18124634f, 0.08622398f, -0.06077513f, 0.07798652f, 0.06601256f, -0.02671046f, -0.00689965f, -0.02722333f, 
    -0.05092243f, 0.00528771f, 0.04511624f, 0.09310565f, -0.23524763f, -0.14157593f, 0.00042386f, -0.00044494f, 
    0.02699706f, -0.00763752f, -0.01145826f, 0.01414496f, 0.02303361f, -0.03239719f, -0.01714302f, 0.05396989f, 
    0.00955778f, 0.19398601f, -0.01427433f, -0.10608826f, -0.06622967f, -0.07919669f, -0.01718388f, 0.10153719f, 
    -0.02652095f, -0.11366126f, -0.08592048f, 0.00066645f, 0.03103312f, 0.06276173f, -0.14960635f, -0.03551994f, 
    0.08528790f, -0.01915400f, -0.14160399f, -0.01727375f, 0.00226362f, -0.00664217f, -0.03851037f, 0.05686431f, 
    -0.12110371f, -0.02011818f, -0.00628705f, -0.00269324f, 0.08002359f, -0.00552382f, 0.00562338f, 0.06863005f, 
    0.10262598f, 0.16575105f, 0.09732061f, 0.06919055f, 0.05497824f, -0.05097524f, -0.09907486f, -0.04659190f, 
    -0.16747361f, 0.00223425f, -0.04640556f, 0.03904327f, 0.02866361f, 0.16093302f, -0.01830882f, -0.00284846f, 
    0.11381420f, 0.16535471f, -0.15635912f, 0.01440462f, -0.06338048f, -0.02837504f, 0.00701956f, -0.03443950f, 
    0.10802138f, 0.05820191f, 0.01904660f, -0.14130025f, -0.28811148f, -0.19147751f, 0.06235789f, 0.04807797f, 
    0.02296276f, 0.01060746f, 0.06149155f, -0.19984145f, 0.01632495f, -0.22848445f, -0.18534312f, 0.05592928f, 
    0.01638487f, 0.04744880f, -0.14273340f, 0.06390711f, -0.08338338f, -0.10962728f, -0.02969876f, -0.01579043f, 
    -0.05262694f, -0.05391317f, 0.00816924f, -0.11415780f, -0.11261557f, -0.15093368f, -0.20221631f, -0.11923818f, 
    0.03444559f, 0.02723013f, -0.05817379f, 0.09172954f, 0.04858422f, 0.05179728f, 0.00690500f, -0.06488312f, 
    -0.27179798f, -0.11134407f, -0.08349295f, -0.08471049f, 0.01903684f, -0.05648733f, -0.03242143f, 0.03605753f, 
    -0.06018235f, 0.00693482f, -0.00119511f, -0.02234006f, -0.32660258f, 0.07075103f, -0.18375331f, -0.23640360f, 
    0.03662683f, 0.12634757f, -0.05800233f, -0.00630297f, 0.08091197f, -0.00155329f, 0.03729770f, -0.04445828f, 
    0.07105970f, 0.06183192f, 0.10024196f, -0.12807968f, 0.05728170f, -0.01205746f, 0.05747637f, 0.12261667f, 
    0.08132124f, 0.08063652f, 0.12871313f, 0.14255667f, -0.06847171f, -0.04150399f, 0.14972031f, -0.01836372f, 
    -0.04174020f, -0.17669909f, 0.03133994f, 0.03543366f, -0.01268095f, 0.11313739f, 0.02151068f, 0.03219651f, 
    -0.49135053f, -0.26826000f, 0.06394676f, 0.02076718f, 0.11675946f, 0.00632983f, 0.03009345f, -0.10069995f, 
    0.09932193f, -0.05353598f, 0.05068214f, 0.07805705f, 0.00057091f, 0.17115550f, 0.05353618f, 0.18286614f, 
    0.12990315f, -0.08334290f, 0.13378470f, -0.04585806f, 0.15206398f, 0.05474731f, -0.03557055f, -0.03091037f, 
    0.02367389f, -0.02399515f, 0.19344544f, 0.00132075f, 0.02108733f, 0.02179337f, 0.11414367f, -0.11586657f, 
    0.09310257f, 0.05131591f, -0.05745212f, 0.10032684f, 0.25157428f, 0.03824124f, 0.00291724f, -0.07481962f, 
    -0.16624835f, 0.03627938f, 0.00987356f, -0.01236290f, 0.02644926f, -0.04537110f, -0.03440180f, -0.05974883f, 
    0.14817952f, -0.06012067f, -0.05706116f, -0.05943386f, 0.00313801f, 0.08545855f, 0.04358433f, -0.08108418f, 
    0.02808403f, -0.08980729f, -0.08962895f, -0.10002765f, -0.10286261f, -0.05318021f, 0.00330835f, -0.04942049f, 
    -0.02569712f, -0.01210983f, 0.00924367f, -0.14317818f, -0.00167696f, -0.09644169f, 0.01384839f, -0.02843019f, 
    -0.18944742f, -0.22224818f, 0.02009995f, -0.07122318f, 0.11263475f, 0.04597978f, -0.02534075f, -0.08757459f, 
    0.05546931f, -0.00485922f, -0.07909535f, 0.08814642f, -0.43786141f, -0.22961651f, 0.15030703f, -0.07732969f, 
    0.01661065f, -0.01534739f, -0.15116711f, -0.09412714f, 0.04334656f, -0.14148249f, -0.04511581f, -0.04595526f, 
    -0.16275978f, 0.00322207f, 0.08308250f, 0.11500744f, -0.05790582f, -0.02777820f, 0.03096447f, -0.07443268f, 
    0.03440607f, 0.00476995f, -0.03055909f, -0.18596426f, -0.13664490f, -0.08816706f, -0.11603043f, 0.17334403f, 
    0.02987110f, 0.06540336f, -0.03973019f, 0.16323955f, 0.08471995f, -0.04251042f, 0.09438772f, 0.02483371f, 
    -0.07010856f, 0.03732743f, -0.09793348f, -0.12162022f, -0.02448784f, -0.06900856f, 0.00144500f, -0.01358736f, 
    0.01299492f, 0.12096689f, 0.07663210f, 0.01412273f, 0.20974541f, 0.12867498f, 0.08638156f, 0.02429059f, 
    -0.02681192f, 0.11642197f, 0.08433533f, -0.03468860f, 0.02552814f, 0.00936096f, 0.04739568f, -0.01717143f, 
    0.31724921f, -0.02003819f, 0.01377569f, 0.06685870f, -0.08816400f, -0.17170271f, 0.07431499f, 0.09919234f, 
    -0.04419003f, 0.09479929f, -0.08987733f, 0.06423798f, 0.23498823f, 0.04271189f, 0.24052683f, 0.11643821f, 
    0.13203001f, -0.04416448f, 0.03142288f, -0.03493294f, -0.01698411f, -0.03852730f, -0.05907586f, -0.10906043f, 
    0.10126733f, -0.02245563f, 0.01114589f, -0.11420354f, -0.11960761f, -0.03816195f, -0.02989012f, -0.03421402f, 
    -0.05980785f, -0.09754399f, -0.08021393f, -0.07091317f, 0.00525786f, -0.02878729f, -0.14870350f, -0.00300815f, 
    0.15658994f, 0.10197981f, 0.03968932f, 0.06000511f, 0.06067992f, 0.11600413f, -0.02387947f, 0.05884966f, 
    -0.13877998f, -0.12043344f, 0.05879642f, 0.00870558f, -0.05413698f, -0.01494433f, -0.02140417f, -0.03534066f, 
    -0.01715349f, 0.00691580f, 0.09744153f, -0.00703484f, -0.04101977f, -0.01917912f, -0.04769433f, -0.20402388f, 
    0.18069309f, 0.04807360f, 0.12073877f, -0.06400501f, 0.07556212f, -0.00638611f, -0.01478984f, 0.02064875f, 
    -0.31427938f, -0.18289268f, 0.10888924f, 0.12971582f, 0.06869785f, -0.03172993f, 0.06603386f, -0.06315298f, 
    0.06932852f, 0.16139765f, 0.03915495f, 0.02879469f, -0.47769085f, -0.33443820f, -0.00804903f, 0.02935943f, 
    0.13816540f, 0.03441171f, 0.03402751f, -0.05651313f, 0.10386482f, 0.11648955f, 0.10029878f, 0.09194487f, 
    -0.16152337f, 0.02664550f, 0.07373902f, -0.19542356f, 0.03637055f, -0.05736572f, 0.06149190f, 0.16355169f, 
    0.03052245f, 0.10205057f, 0.06826280f, 0.11728870f, -0.22391844f, 0.10956085f, -0.08055541f, -0.12050945f, 
    0.03001697f, 0.06163058f, -0.02525725f, 0.08826179f, 0.08439718f, 0.06381849f, -0.07917608f, -0.04615942f, 
    0.14065242f, 0.13376373f, 0.00435483f, -0.08958022f, 0.04807662f, 0.01403321f, 0.10549394f, -0.20125793f, 
    -0.07696890f, 0.06078244f, 0.00433191f, -0.06124303f, -0.07079759f, 0.16115834f, 0.07102947f, 0.14095029f, 
    0.14365910f, -0.04492286f, -0.00710594f, 0.00177443f, -0.03066908f, 0.20124643f, -0.05192099f, -0.05451424f, 
    0.19336863f, -0.00677517f, -0.03566116f, -0.13538343f, -0.05976149f, 0.02888642f, 0.08575900f, -0.03701225f, 
    -0.04534441f, -0.03873520f, -0.13768794f, -0.01433801f, -0.59895080f, -0.37015232f, -0.07951279f, -0.20275801f, 
    0.07938752f, -0.01604478f, 0.03171498f, -0.01264715f, 0.11788504f, 0.09892143f, 0.02471823f, 0.02343853f, 
    -0.17852937f, -0.29264984f, -0.19181578f, -0.09943743f, 0.04461513f, -0.08720759f, -0.16293496f, 0.00894069f, 
    -0.08160032f, 0.04725073f, -0.04863865f, 0.01141650f, -0.13345577f, 0.08197425f, 0.02839661f, -0.01502502f, 
    0.08928509f, 0.10776561f, 0.07418248f, 0.03149292f, 0.01247315f, 0.06788415f, -0.02089618f, 0.16991723f, 
    0.03678453f, 0.05939703f, -0.09702150f, -0.08051881f, -0.04615482f, -0.13625817f, -0.03039778f, -0.02202437f, 
    0.08402141f, -0.01750803f, 0.13496023f, 0.08691183f, -0.23496807f, -0.03967639f, 0.05802625f, -0.03057802f, 
    -0.02552584f, -0.03787555f, -0.08636794f, 0.00927374f, 0.15076685f, -0.04248496f, 0.02621949f, -0.06080028f, 
    0.16023482f, 0.02647479f, -0.14255264f, 0.05517727f, -0.01024628f, 0.07377087f, -0.04531004f, 0.07960510f, 
    0.03705588f, -0.04764479f, -0.00485692f, -0.03400286f, -0.48112428f, -0.08473304f, -0.17532243f, -0.13051055f, 
    0.03977644f, -0.10463704f, -0.06197487f, -0.00490197f, 0.13094999f, 0.11221316f, 0.11612990f, 0.12057638f, 
    -0.07202582f, -0.12860119f, -0.02846975f, -0.17765599f, -0.00995625f, -0.07238556f, -0.03755848f, 0.05489465f, 
    -0.01009625f, -0.10370441f, -0.01634292f, 0.01190663f, -0.41133502f, 0.10837439f, -0.21800303f, -0.03480888f, 
    0.02640232f, -0.01479299f, -0.06057882f, -0.00707776f, -0.03161044f, 0.07171373f, 0.06747796f, 0.14459394f, 
    0.21201856f, 0.15897349f, -0.07902000f, 0.15276766f, -0.01655186f, -0.12302044f, 0.03813213f, -0.04734207f, 
    0.06936419f, -0.01780791f, -0.00444704f, -0.11543026f, 0.21778220f, 0.03826625f, 0.06168060f, 0.04953471f, 
    -0.20510392f, -0.00040960f, 0.10631854f, -0.02519928f, 0.04364397f, 0.08839390f, 0.02850448f, -0.05241812f, 
    0.27949315f, 0.25845426f, 0.03792287f, -0.08747385f, 0.12266781f, -0.01580853f, 0.05002987f, 0.04300373f, 
    -0.06120309f, 0.08237512f, 0.00401822f, 0.02168721f, 0.05836342f, 0.07419284f, -0.20288098f, -0.06459703f, 
    0.09251792f, 0.00947721f, -0.07986340f, 0.00037783f, -0.01578360f, -0.08693349f, 0.05744561f, -0.04500856f, 
    0.03595639f, 0.10866861f, -0.04323298f, 0.09966827f, -0.05627903f, 0.01681029f, -0.10715012f, -0.02645234f, 
    0.07125719f, -0.07129214f, -0.03365732f, -0.10723830f, -0.21124868f, -0.10350552f, 0.12104273f, -0.08443125f, 
    0.16820654f, -0.03539326f, -0.15098841f, 0.02005794f, -0.05708892f, 0.04651618f, 0.03295417f, 0.05953041f, 
    0.04615985f, 0.00859007f, -0.10977460f, 0.13781579f, 0.08373930f, -0.04128502f, 0.07297695f, -0.13650654f, 
    0.02912609f, 0.10177808f, -0.06853687f, 0.04677138f, 0.21580632f, 0.17668405f, -0.01359212f, 0.14201409f, 
    -0.08720935f, -0.06234168f, -0.07582249f, -0.06478538f, 0.00024823f, -0.02998317f, -0.06737958f, -0.03764070f, 
    -0.40520367f, -0.01226969f, 0.31692860f, 0.09181931f, 0.13654552f, -0.05373182f, 0.09112668f, 0.02072467f, 
    -0.02372191f, 0.01411100f, -0.04573651f, 0.12011974f, 0.17526887f, 0.14130563f, 0.09569646f, 0.13294058f, 
    -0.02804433f, -0.12670302f, -0.06258187f, -0.12568362f, -0.00424011f, 0.00771221f, 0.02193682f, 0.16626303f, 
    -0.11158843f, -0.13877884f, -0.08282025f, 0.08313657f, -0.04271923f, 0.13060227f, -0.13676733f, 0.04881950f, 
    0.11897657f, 0.01919546f, -0.03334844f, 0.10390387f, 0.31270999f, -0.20017372f, -0.23237705f, 0.03280608f, 
    0.10054015f, -0.03495545f, 0.04213756f, -0.03719592f, 0.07091197f, 0.00115354f, 0.00098252f, 0.06225085f, 
    -0.07525804f, 0.00128087f, -0.00429408f, 0.02380797f, 0.09699290f, -0.06148185f, 0.04948430f, 0.00558939f, 
    -0.05095773f, -0.03353512f, -0.02060167f, -0.00654592f, 0.02521481f, -0.11703081f, 0.09182961f, -0.18066944f, 
    -0.03396863f, 0.01918348f, -0.06038522f, -0.04396932f, -0.06744181f, 0.14495149f, 0.01323902f, -0.02572041f, 
    -0.04136830f, -0.24253717f, 0.04778063f, -0.08961134f, 0.07242273f, -0.03370656f, 0.09349704f, 0.09488724f, 
    0.07277668f, -0.00888504f, 0.04116464f, -0.00041659f, -0.20334271f, 0.45521203f, -0.23042336f, 0.17530285f, 
    0.12838973f, -0.21845168f, 0.00603651f, -0.09153908f, -0.01732220f, 0.06385138f, 0.12441294f, 0.00834203f, 
    0.07780160f, 0.18706045f, -0.07813372f, -0.01228492f, 0.03703146f, 0.04945419f, -0.00999671f, 0.01392097f, 
    0.02071619f, -0.07873240f, -0.07639703f, -0.03639777f, -0.14993174f, 0.03690238f, -0.13003370f, -0.19917858f, 
    -0.01118011f, -0.08470377f, 0.08776145f, 0.10920296f, -0.08118846f, 0.00983849f, 0.00635517f, -0.02705931f, 
    -0.43194196f, -0.06977486f, 0.03538850f, -0.14239258f, -0.05819253f, -0.02281019f, 0.04075285f, 0.05367119f, 
    -0.04307546f, 0.07219642f, 0.03137407f, -0.07558255f, -0.26761332f, -0.06565329f, -0.07596332f, -0.22739625f, 
    -0.09952401f, -0.04735057f, 0.08166061f, 0.07460801f, -0.02817271f, 0.01410369f, 0.02718999f, -0.06820977f, 
    0.11924502f, -0.16545667f, -0.08501790f, 0.04884147f, -0.03746912f, 0.02292175f, -0.00636363f, 0.11630866f, 
    0.04932716f, -0.00348400f, -0.05653075f, -0.04101697f, -0.14876352f, -0.06088920f, 0.04890435f, 0.06009370f, 
    -0.09213363f, 0.10082461f, -0.16541277f, -0.01808156f, -0.18196134f, 0.06757745f, 0.17826763f, -0.03920745f, 
    -0.29940510f, 0.07687707f, 0.07890990f, 0.15094282f, 0.01094593f, -0.02083250f, 0.06449838f, 0.09781045f, 
    0.01903008f, -0.14618790f, -0.07922457f, 0.04996827f, -0.06396163f, 0.09570268f, 0.07207177f, -0.09223518f, 
    0.06589331f, -0.09474817f, -0.10643594f, 0.05832116f, 0.09357881f, 0.12730467f, 0.05537423f, 0.12027545f, 
    0.00812773f, -0.13068487f, 0.06610988f, 0.10369820f, 0.02148378f, 0.09956863f, 0.00846851f, 0.06650499f, 
    0.08172654f, 0.02792623f, -0.14859490f, -0.02658753f, 0.11738817f, -0.26569700f, -0.14468877f, 0.16653426f, 
    0.13136129f, 0.05031874f, -0.03491021f, -0.12658954f, 0.09732766f, -0.05249521f, -0.07782336f, 0.03758902f, 
    -0.17251083f, 0.03490588f, -0.02030482f, -0.30066910f, -0.06124511f, -0.08747035f, 0.02165482f, 0.14510801f, 
    0.09061425f, -0.09607881f, 0.04467983f, 0.03965126f, -0.38983619f, -0.11306692f, 0.08733916f, -0.04105363f, 
    0.04838724f, -0.05237624f, -0.01223914f, 0.10400524f, -0.10085797f, -0.01677670f, 0.05956532f, -0.06728154f, 
    0.07514402f, 0.06029320f, -0.14126462f, -0.00286601f, 0.05347249f, 0.06607707f, 0.02417816f, 0.12526548f, 
    0.10908530f, 0.04099047f, -0.01151692f, -0.07344839f, -0.12932655f, -0.19545497f, 0.02520425f, 0.13363025f, 
    0.06619573f, 0.06127653f, 0.06993381f, 0.00774555f, -0.01040336f, -0.04274539f, 0.02179934f, -0.17836367f, 
    0.18366234f, 0.00796348f, -0.09136536f, -0.24036211f, 0.11774450f, 0.02429166f, -0.02657384f, 0.08641103f, 
    -0.07853477f, 0.02316173f, -0.01179969f, -0.08653951f, 0.32486033f, -0.04058197f, 0.02003257f, 0.21376355f, 
    0.02407511f, -0.01808030f, -0.11747314f, 0.02736782f, 0.03301917f, -0.03421759f, 0.08866436f, -0.05050796f, 
    0.15605880f, 0.15450820f, 0.02988132f, -0.09823737f, -0.06301318f, -0.10827828f, -0.02450655f, -0.01680154f, 
    -0.03229684f, 0.06567553f, -0.08082526f, -0.07851310f, -0.01109507f, -0.06725050f, -0.07820794f, -0.01706374f, 
    -0.06724553f, -0.05130312f, 0.02573972f, 0.00643886f, -0.09885100f, 0.04160926f, 0.03801946f, -0.05204448f, 
    0.08019802f, 0.09079772f, -0.04142992f, 0.06888179f, -0.02428505f, -0.16336171f, -0.00422075f, -0.01722118f, 
    -0.01843538f, 0.10104696f, 0.04570333f, 0.05902222f, -0.35379484f, -0.05840408f, 0.02455538f, -0.20337744f, 
    0.02609185f, -0.02970770f, -0.08846635f, 0.01764790f, -0.04104346f, 0.09877947f, 0.05201813f, 0.06383165f, 
    -0.07226849f, -0.08272383f, 0.06626657f, -0.19953290f, 0.23460379f, -0.04620058f, -0.09223133f, 0.15485792f, 
    0.05640799f, 0.09124652f, -0.08616650f, 0.15027349f, 0.15053277f, 0.07386157f, -0.04751981f, -0.23698182f, 
    -0.09209345f, 0.06349210f, -0.03085750f, -0.08278251f, 0.00590015f, -0.01668733f, -0.02437135f, 0.06996078f, 
    -0.39959738f, -0.39070165f, 0.06245586f, -0.09326611f, 0.06486554f, -0.03116292f, -0.00618475f, 0.00283080f, 
    0.03029565f, 0.05423497f, -0.03506380f, 0.11917867f, -0.04492441f, -0.14459011f, 0.13708226f, -0.06598872f, 
    -0.05269125f, 0.05703315f, 0.00266653f, 0.03120870f, 0.02692091f, -0.07822525f, 0.01829797f, 0.00743262f, 
    -0.18553586f, 0.04930969f, 0.12519318f, 0.11099228f, 0.03636139f, -0.07651768f, 0.05466468f, 0.03079464f, 
    -0.12907732f, -0.05600296f, 0.05732086f, 0.07158472f, 0.21395424f, -0.02091630f, -0.17693010f, -0.02330470f, 
    0.04509258f, -0.06749201f, -0.00172371f, 0.02503723f, 0.00511269f, 0.01533700f, 0.03097758f, 0.01392038f, 
    0.03371086f, -0.05783855f, 0.16408756f, -0.05642664f, 0.01887655f, -0.02882123f, 0.05190969f, -0.04523665f, 
    -0.03712957f, -0.05587289f, 0.09460664f, 0.08989266f, -0.15155481f, 0.06271637f, -0.19389148f, -0.10620973f, 
    0.16475928f, -0.11931705f, 0.06072386f, -0.06681280f, 0.15609828f, -0.06034729f, 0.04611422f, 0.11560080f, 
    0.02867875f, -0.23313990f, -0.01292609f, 0.09219708f, -0.02294819f, 0.00329337f, 0.07321217f, -0.01379389f, 
    -0.00975838f, -0.00839830f, -0.00133506f, -0.01732957f, 0.19065318f, -0.16401827f, -0.12917487f, 0.11229559f, 
    0.06330696f, 0.02968178f, -0.07685707f, -0.00020045f, 0.06924955f, 0.01956924f, -0.02514346f, 0.02907508f, 
    0.00657830f, 0.00085561f, -0.10925154f, 0.11508325f, 0.10519184f, 0.08953319f, -0.05612492f, -0.09411691f, 
    -0.02710698f, 0.01778999f, -0.10289203f, -0.08705758f, 0.21456930f, -0.20975576f, -0.15944789f, 0.09368491f, 
    0.07162536f, -0.01605327f, -0.00096283f, 0.04995034f, -0.00150124f, -0.01134580f, 0.04601886f, -0.03366622f, 
    0.09837207f, 0.02903446f, 0.05789344f, -0.12626933f, 0.06605104f, 0.04052193f, -0.07749379f, 0.08800498f, 
    -0.10024437f, -0.06889774f, -0.01764647f, -0.01777637f, 0.35743174f, 0.05321952f, 0.02385631f, -0.02133481f, 
    0.08589514f, -0.02431598f, -0.08225485f, -0.00606492f, -0.01729072f, -0.02589819f, -0.02252641f, -0.07823619f, 
    0.19437687f, -0.09711423f, -0.07681418f, 0.01079849f, 0.05931386f, 0.02942865f, -0.10600751f, 0.09391459f, 
    -0.07234447f, -0.13150245f, -0.01272375f, -0.02666366f, -0.16790946f, 0.08463874f, -0.10995901f, 0.11769397f, 
    -0.10372885f, 0.11938602f, -0.00541275f, 0.13582958f, -0.00575995f, 0.04058201f, 0.09803128f, -0.05769020f, 
    0.12501942f, 0.13361648f, -0.04324217f, -0.21398698f, -0.04964199f, -0.03016683f, -0.09898801f, -0.09657075f, 
    -0.06208136f, -0.03307989f, -0.01164446f, -0.03600617f, 0.23460886f, 0.00751775f, 0.09819770f, -0.01882775f, 
    0.05393341f, 0.11180179f, -0.08217712f, 0.11124533f, 0.04057314f, -0.02486489f, -0.05093897f, 0.01639529f, 
    -0.15185951f, 0.09177643f, 0.02615075f, -0.01445723f, 0.08536438f, 0.01547503f, -0.00812382f, -0.08896637f, 
    -0.07283124f, 0.00322078f, 0.05438992f, -0.12558535f, 0.29924718f, -0.17316587f, -0.11606277f, -0.16560820f, 
    -0.00086925f, -0.00825443f, -0.01354990f, 0.02313734f, -0.04684118f, -0.00289649f, -0.08582709f, -0.07025231f, 
    -0.33939102f, -0.05315446f, -0.11321387f, -0.07106813f, -0.01393526f, 0.02569010f, -0.00177561f, 0.03931596f, 
    0.02879334f, 0.01827508f, 0.07245494f, 0.07102941f, -0.38829592f, 0.16522267f, 0.03273331f, -0.01395094f, 
    0.20311281f, -0.11362239f, 0.05215900f, 0.02703621f, 0.04448726f, -0.03789615f, -0.00323705f, -0.08617856f, 
    0.15240078f, -0.15921189f, -0.02303642f, -0.02026860f, 0.00503723f, 0.06328809f, -0.01951308f, -0.13424070f, 
    -0.07268898f, 0.05606069f, -0.06329402f, -0.20863555f, 0.06659458f, 0.13145697f, -0.01471472f, 0.02345307f, 
    -0.00767079f, -0.02561986f, -0.02273854f, -0.06303655f, -0.01441116f, 0.04292876f, -0.01243182f, 0.01134871f, 
    -0.36547285f, 0.23580973f, -0.08756325f, 0.01508750f, 0.07716259f, -0.06464966f, 0.04723186f, -0.06322057f, 
    -0.00700266f, 0.02841624f, 0.03249256f, -0.12926121f, 0.28794089f, -0.09586006f, -0.14851107f, -0.06395959f, 
    0.02570182f, -0.03464799f, 0.02655569f, -0.01321078f, -0.01099311f, -0.08492505f, 0.01497271f, -0.03833701f, 
    -0.41560888f, 0.01974815f, 0.02121813f, 0.10215292f, -0.20361564f, 0.17075603f, 0.04078439f, -0.09038948f, 
    -0.01575076f, -0.01935763f, 0.03385657f, -0.08933404f, 0.16950729f, 0.02272340f, -0.02902131f, 0.01332895f, 
    -0.09493539f, -0.03261042f, -0.04945247f, 0.06108474f, 0.02101288f, -0.06771813f, -0.05539900f, -0.00106419f, 
    0.11534826f, -0.37475574f, 0.03539528f, 0.00655923f, -0.06784618f, 0.05969577f, 0.07213556f, 0.15025716f, 
    -0.02813181f, -0.01641892f, -0.02445883f, 0.04654085f, -0.10600462f, 0.16389182f, -0.03804530f, 0.06845204f, 
    0.02939158f, -0.05594841f, -0.00495843f, -0.04647652f, 0.01975179f, -0.01389550f, 0.09486637f, -0.03933054f, 
    0.01663734f, 0.02650798f, -0.06832800f, -0.05958416f, 0.02562165f, 0.00068726f, -0.02700507f, -0.00770331f, 
    0.02604492f, -0.18941063f, -0.11581110f, -0.12794845f, -0.02225486f, -0.10700145f, -0.07145024f, -0.00970201f, 
    -0.05177591f, -0.02011132f, 0.01185641f, -0.09717000f, 0.00319085f, 0.04917708f, 0.04334297f, 0.00861742f, 
    -0.07968055f, -0.05522841f, 0.04946413f, -0.13653781f, 0.09159855f, 0.08877028f, 0.06556705f, 0.07079256f, 
    -0.00592577f, -0.00064816f, 0.00301369f, 0.00510210f, 0.42892018f, 0.04294839f, -0.04858932f, -0.18933518f, 
    -0.01126087f, 0.07990785f, -0.04704160f, -0.02396349f, 0.01243099f, -0.03115016f, 0.08492929f, 0.08118343f, 
    0.10451521f, -0.17863426f, -0.01652487f, 0.02663208f, -0.16847955f, 0.05745736f, -0.10047294f, -0.00245244f, 
    0.13544898f, 0.03828239f, -0.06939066f, -0.05191757f, 0.17301260f, 0.00527554f, 0.02408222f, -0.00636796f, 
    -0.09473585f, -0.03443266f, 0.04231106f, 0.04297658f, -0.09757403f, -0.03249953f, 0.00594583f, -0.10564379f, 
    0.45176166f, 0.10949209f, -0.04809353f, -0.11152261f, -0.05816052f, -0.02666724f, -0.10997962f, -0.08861905f, 
    0.11611088f, 0.05466074f, -0.01641119f, 0.09366495f, 0.08040333f, 0.06523521f, 0.06594604f, 0.04792818f, 
    0.03230695f, 0.01343529f, -0.02504471f, -0.02078331f, -0.09075469f, -0.18188937f, -0.05899008f, -0.03284146f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07966331f, 0.03265161f, -0.00935895f, 0.01959719f, 0.03974251f, 0.01374355f, 0.02048273f, -0.04144857f, 
    -0.05145970f, 0.03673989f, 0.05476873f, 0.01327816f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
