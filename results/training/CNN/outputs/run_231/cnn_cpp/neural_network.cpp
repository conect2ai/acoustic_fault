#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.73195708f, 0.59129924f, 0.26169828f, 0.22596471f, -0.47474870f, 0.17589326f, -0.05542001f, 0.08868368f, 
    0.14096580f, -0.52297670f, -0.47535118f, -0.46789163f, 0.03819612f, -0.27196798f, 0.32946631f, -0.01787884f, 
    0.22149929f, -0.26924521f, -0.01591704f, 0.25649887f, 0.25959113f, -0.26523516f, -0.32556841f, -0.08011608f, 
    0.55675185f, -0.17817216f, 0.41226596f, 0.34333122f, 0.03081310f, -0.24129626f, -0.37678590f, -0.64650369f, 
    -0.52043551f, -0.17457032f, -0.16112494f, 0.04611387f, -0.32265717f, -0.87919891f, 0.25561503f, 0.70210475f, 
    0.13454698f, 0.81546330f, 0.08264852f, -0.10141715f, 0.06431212f, 0.52522862f, -0.09028947f, 0.12929048f, 
    -0.18191972f, -0.01984914f, 0.07905952f, 0.16726537f, 0.35590318f, -0.08114617f, -0.20789631f, -0.22529671f, 
    -0.11770076f, 0.19192775f, 0.36336702f, 0.42831400f, -0.28269774f, -0.47445461f, -0.54238713f, 0.08276959f, 
    0.47448686f, 0.48462689f, 0.26336101f, 0.42669052f, 0.46080384f, 0.25325876f, 0.44459057f, 0.22119834f, 
    -0.62628794f, 0.12275472f, 0.03685388f, 0.41742563f, 0.64886045f, -0.26353642f, 0.23086710f, 0.15626881f, 
    -0.25871873f, -0.40962830f, -0.53118581f, -0.75582570f, -0.07812294f, -0.10201769f, 0.23888196f, -0.07265014f, 
    0.02910083f, 0.25606167f, -0.35235292f, -0.42197740f, -0.19993268f, -0.09843399f, 0.78427148f, -0.38429666f, 
    -0.13236122f, -0.21511304f, -0.23711100f, -0.25639763f, 0.58218229f, -0.34911320f, -0.28180015f, 0.36889836f, 
    -0.59448254f, 0.09726202f, 0.25631988f, 0.26216802f, 0.24875088f, -0.09294902f, -0.37595448f, -0.30259779f, 
    -0.46590096f, 0.55588925f, -0.36882469f, -0.30985293f, 0.17948884f, -0.63776606f, 0.13103138f, 0.18661776f, 
    -0.40259063f, -0.39787734f, 0.14518692f, -0.05565530f, 0.29172578f, -0.21477431f, 0.64886355f, 0.61530012f, 
    0.70615053f, -0.25319895f, 0.16286987f, -0.43176308f, 0.16600488f, 0.19889013f, -0.10156563f, 0.35838214f, 
    0.45757800f, 0.42401791f, 0.09758997f, -0.02216478f, 0.33521679f, -0.25756362f, -0.08519800f, -0.05520874f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13668717f, -0.40088660f, -0.31399339f, 0.14437366f, 0.15034834f, 0.27572876f, -0.06602291f, 0.50744045f, 
    -0.13073815f, -0.01239960f, -0.12184258f, 0.06341746f, -0.23272203f, 0.42682749f, -0.24516305f, -0.04411029f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.58868808f, -0.20616090f, 0.02733486f, 0.16588810f, -0.01756919f, -0.05404001f, -0.04250630f, 0.10998060f, 
    0.12313106f, 0.28622329f, -0.01598503f, 0.15889305f, -0.17511688f, -0.02556465f, -0.22179487f, 0.15505914f, 
    -0.05052439f, -0.18041089f, -0.01056767f, 0.06800278f, -0.02444879f, 0.09031061f, -0.02264231f, 0.00711287f, 
    -0.25640282f, -0.12703547f, 0.15060893f, 0.18819590f, 0.16308850f, 0.29229346f, 0.05202023f, -0.15477110f, 
    0.14796053f, -0.06833898f, 0.11326040f, 0.05945226f, 0.16596489f, 0.12936531f, -0.02313064f, 0.08723252f, 
    0.14628547f, 0.00970737f, 0.00552867f, 0.12531163f, 0.03876374f, -0.09784333f, -0.06320840f, 0.00610228f, 
    -0.11765029f, 0.08160033f, -0.08418446f, 0.07057226f, 0.01222476f, -0.03984074f, 0.23213093f, -0.03593897f, 
    0.06855827f, -0.00970451f, 0.16792677f, -0.24881728f, 0.06060057f, -0.03238048f, -0.15669569f, -0.47369584f, 
    -0.01569009f, -0.13906321f, 0.19812688f, -0.03582596f, -0.09042412f, 0.16858916f, 0.07816482f, 0.14676565f, 
    -0.10497063f, 0.06078855f, -0.16430132f, 0.14809768f, 0.12196147f, -0.10302208f, 0.19265644f, 0.20309040f, 
    -0.00200643f, 0.15818068f, 0.17639813f, 0.04771374f, -0.06589841f, 0.04641524f, -0.14776166f, -0.07388764f, 
    0.17133778f, 0.16174607f, 0.07313210f, -0.13644049f, -0.16952276f, -0.02917428f, -0.12379248f, -0.03952502f, 
    0.00372884f, -0.05086653f, -0.11957081f, 0.05643402f, 0.00123070f, 0.00472274f, 0.03021930f, -0.19951153f, 
    0.01303082f, 0.04139534f, 0.00885777f, 0.15749900f, -0.06378485f, -0.44443846f, 0.04879199f, -0.25312045f, 
    0.10004780f, 0.20999143f, -0.01241978f, -0.19568621f, -0.05561849f, -0.02640442f, 0.09058525f, -0.22090302f, 
    -0.00382737f, -0.01431992f, -0.04803038f, 0.10499545f, 0.10341195f, 0.03956364f, -0.29113618f, -0.29711786f, 
    -0.18409486f, 0.13024664f, 0.04046891f, 0.07967989f, -0.20823926f, -0.03025322f, 0.13916396f, -0.23160045f, 
    -0.30110934f, 0.18554389f, -0.01952921f, -0.00951128f, -0.03438052f, -0.15072682f, -0.06670170f, -0.09675723f, 
    -0.02238254f, 0.20245041f, 0.39957607f, -0.09520788f, 0.17158756f, -0.01985776f, 0.02664492f, 0.03667959f, 
    0.03899275f, -0.41900045f, -0.00279941f, 0.04068256f, 0.19563562f, 0.06177995f, 0.00584967f, -0.09656858f, 
    0.03053932f, 0.02192529f, -0.06997740f, 0.14967296f, 0.00002154f, -0.22339307f, -0.06297803f, 0.07107382f, 
    0.09101508f, 0.05108804f, -0.01369423f, -0.00861488f, -0.09938217f, -0.23689733f, -0.10967602f, 0.24330127f, 
    -0.08709521f, -0.00908343f, 0.03136888f, 0.12213223f, -0.27663463f, -0.25504258f, -0.17054567f, -0.05239560f, 
    -0.01382668f, 0.02811044f, 0.05284905f, -0.10911196f, -0.06006283f, 0.09366912f, 0.17504810f, 0.16594668f, 
    -0.19621573f, 0.02564483f, 0.04535650f, 0.27369469f, 0.02078916f, 0.01301477f, 0.15869927f, -0.10050698f, 
    -0.11817229f, 0.08775946f, -0.12107318f, -0.03153458f, 0.04317939f, -0.03313415f, 0.04871744f, 0.15962078f, 
    -0.21386433f, 0.07902548f, -0.13092446f, -0.06555477f, -0.00081917f, -0.06641924f, 0.07418759f, 0.01295808f, 
    -0.47675437f, -0.32988206f, -0.48097089f, 0.14218746f, 0.15000317f, -0.07436977f, 0.03620347f, -0.02503120f, 
    0.01580721f, -0.20835541f, -0.09571127f, -0.06352640f, 0.12445531f, 0.15156902f, 0.01019707f, -0.04103659f, 
    0.15416399f, -0.11010896f, 0.02845114f, -0.13831061f, -0.18358503f, -0.06945330f, 0.07165915f, 0.29416680f, 
    -0.03106939f, 0.04446731f, -0.10461830f, 0.02441976f, -0.01978907f, -0.07758663f, 0.21890576f, 0.06479060f, 
    0.03385473f, -0.06672306f, -0.08829392f, 0.11435547f, -0.05015422f, -0.16756256f, 0.05773702f, 0.03909365f, 
    -0.14843418f, 0.06438655f, -0.04551271f, -0.05733259f, 0.10296587f, -0.13116792f, -0.19248626f, -0.12158193f, 
    0.04751870f, 0.12108789f, 0.03511102f, -0.00945827f, 0.09219507f, 0.08502004f, 0.08164531f, 0.33296162f, 
    0.35613388f, -0.14052145f, -0.10825495f, -0.10968553f, -0.14004481f, 0.01996545f, -0.02702144f, -0.00029282f, 
    0.21531394f, 0.35931221f, 0.26595107f, -0.05456784f, 0.02254292f, 0.11336337f, 0.04426965f, 0.08980281f, 
    0.06915617f, 0.05841859f, -0.08321378f, 0.05070092f, -0.01828494f, 0.02991421f, -0.02806306f, -0.07425240f, 
    -0.06472478f, -0.02841302f, 0.02943355f, -0.03661959f, -0.03911289f, 0.00850087f, -0.05704629f, -0.02903282f, 
    0.01354039f, 0.00262777f, -0.03826216f, -0.00537650f, -0.08073396f, 0.04076600f, -0.04600205f, -0.06531885f, 
    0.01724673f, 0.04769439f, -0.08640702f, 0.07450309f, 0.00291453f, 0.02253118f, -0.05915878f, -0.01367982f, 
    -0.07572814f, 0.00519489f, 0.01250034f, 0.03150307f, -0.03218984f, 0.02285674f, 0.01234285f, 0.00998418f, 
    0.05689431f, -0.04461832f, -0.05597143f, 0.03647751f, 0.04443040f, -0.05920951f, -0.06496063f, -0.07419124f, 
    -0.01574377f, 0.00451218f, -0.04870376f, 0.05183736f, 0.04676870f, -0.07573391f, 0.02009725f, -0.08780408f, 
    -0.03964918f, 0.06555028f, 0.05225226f, 0.06110025f, -0.07787146f, -0.01499596f, -0.05182942f, 0.01754239f, 
    0.03108637f, -0.08520220f, -0.00232220f, 0.00864530f, -0.03330919f, 0.03801291f, -0.00917600f, -0.08112043f, 
    0.03939703f, 0.02742758f, -0.00081820f, -0.09073193f, -0.03560744f, 0.06566183f, -0.00293840f, 0.02947612f, 
    0.05918258f, -0.05773842f, -0.00092497f, -0.03581978f, 0.00472631f, -0.01110727f, -0.05397750f, 0.00455156f, 
    0.03971043f, 0.07209951f, 0.06908907f, 0.04310310f, -0.08892441f, -0.08219149f, -0.07807808f, 0.07004388f, 
    -0.04433625f, 0.04832359f, -0.03812683f, -0.01204171f, 0.00963473f, 0.02499027f, -0.02868294f, -0.08514496f, 
    0.03488464f, -0.09380840f, -0.04137968f, -0.01465468f, -0.03939629f, -0.06379434f, -0.03097740f, -0.03452105f, 
    -0.06759232f, -0.08308250f, -0.02478261f, -0.02758644f, 0.00892396f, 0.02727884f, 0.04259387f, -0.03053884f, 
    -0.04723359f, -0.04662048f, -0.00943128f, 0.05609582f, -0.03427871f, -0.05779766f, -0.02500598f, 0.03225004f, 
    0.04205875f, -0.04094417f, 0.05647279f, 0.04729834f, 0.00442990f, -0.06311569f, 0.01937771f, -0.00873880f, 
    -0.09556461f, 0.00125857f, -0.02512758f, -0.00300438f, -0.05230078f, -0.03567040f, 0.05272034f, -0.05011997f, 
    0.00014581f, -0.05325811f, 0.10448498f, -0.02256572f, -0.08917709f, 0.01350570f, -0.04422626f, -0.05927287f, 
    -0.09902350f, 0.03467241f, -0.05216124f, -0.00597495f, -0.03681229f, 0.00496748f, 0.00266124f, 0.03242879f, 
    -0.05992882f, -0.11002994f, 0.04176620f, 0.03276514f, -0.02124584f, -0.01305635f, 0.02387143f, 0.01410068f, 
    -0.10763428f, -0.01222069f, 0.02007416f, -0.00288687f, -0.08625349f, -0.03135392f, -0.02514024f, -0.13573252f, 
    -0.15968002f, -0.07919641f, -0.05902327f, 0.03658456f, -0.02007373f, 0.00729451f, -0.12200091f, 0.08158326f, 
    0.02820211f, 0.00549240f, -0.11368059f, 0.00432345f, -0.12001802f, -0.08105513f, -0.08136263f, -0.03169822f, 
    0.05477120f, -0.09753123f, -0.06827672f, -0.09196134f, -0.03433618f, 0.02531850f, 0.05218903f, -0.05527130f, 
    -0.02147002f, -0.05602651f, -0.04031653f, -0.04350337f, -0.12909375f, 0.03112819f, 0.05621369f, 0.01211835f, 
    -0.07237538f, 0.00237845f, 0.01890969f, 0.03178342f, -0.04508512f, -0.05376860f, -0.06183470f, -0.07008510f, 
    -0.02224789f, -0.00054357f, -0.11303762f, -0.08774434f, 0.04247164f, -0.03849936f, -0.00408477f, -0.08652996f, 
    -0.07169238f, -0.06857706f, -0.09580287f, -0.12521750f, 0.00237947f, -0.00300503f, -0.06212822f, 0.03327611f, 
    -0.02818294f, -0.02145536f, 0.05734012f, 0.03526821f, -0.10481372f, -0.09160902f, -0.01486461f, 0.00984965f, 
    0.04479554f, 0.01166152f, 0.01381500f, -0.07264267f, -0.03533503f, 0.02446853f, 0.05189681f, 0.01276187f, 
    -0.05185793f, -0.03299123f, -0.13803986f, 0.01507656f, 0.02125412f, -0.07407431f, -0.14885274f, -0.01887019f, 
    -0.04988841f, -0.09388454f, -0.04298036f, -0.03974045f, -0.03681123f, -0.03808237f, -0.05732469f, -0.11414758f, 
    -0.02893231f, 0.02218511f, -0.07056302f, 0.02902611f, -0.07052772f, -0.09855250f, -0.14259240f, -0.02652220f, 
    0.09695815f, 0.00155687f, -0.03005586f, -0.10302155f, 0.04823963f, -0.01159996f, 0.04540853f, -0.09310727f, 
    0.00331854f, 0.12597388f, 0.02983992f, 0.04170976f, 0.11879607f, 0.04754183f, -0.10516106f, 0.03685894f, 
    0.02829987f, 0.05158753f, 0.01564131f, -0.03245312f, 0.06989429f, 0.01299744f, -0.05794074f, -0.06410501f, 
    -0.04811833f, -0.02900491f, -0.00682757f, 0.04852784f, 0.05199583f, -0.07922674f, -0.09214779f, -0.01812395f, 
    -0.06940945f, -0.01965180f, -0.01950478f, 0.02995255f, 0.01047426f, -0.01912184f, 0.02742402f, -0.11481643f, 
    -0.02219280f, 0.04277776f, 0.05357599f, -0.06357976f, -0.06437208f, -0.03351633f, -0.05819923f, 0.03167676f, 
    0.05757812f, -0.04287097f, 0.04239367f, -0.03978510f, 0.06328332f, -0.08341212f, -0.01935657f, -0.07104093f, 
    -0.02374817f, -0.06912299f, -0.07746316f, -0.06771000f, -0.06787620f, -0.01988103f, -0.02884764f, 0.06030724f, 
    -0.00590233f, 0.05823396f, -0.06829645f, -0.07826338f, -0.09724373f, 0.04104434f, -0.08309678f, 0.00303668f, 
    -0.00542340f, 0.00972343f, 0.00156746f, 0.06953726f, -0.04003207f, -0.06914431f, -0.07170623f, -0.03596710f, 
    -0.08192884f, -0.02375756f, 0.00470465f, -0.01464981f, -0.04332412f, 0.00377748f, 0.02619598f, 0.04587690f, 
    -0.02172226f, -0.08439980f, -0.00082533f, -0.03121154f, -0.05583609f, 0.06690877f, -0.09510529f, -0.04564877f, 
    0.03127270f, -0.06958316f, -0.00809444f, 0.03099982f, 0.05899078f, 0.04899335f, -0.07417946f, -0.02509326f, 
    -0.00342151f, 0.00440412f, -0.06192571f, 0.05930900f, 0.02313304f, -0.10423186f, -0.03697727f, -0.02178732f, 
    -0.00373702f, -0.04954313f, -0.03277987f, 0.08071713f, 0.02394829f, 0.03336642f, -0.02613845f, 0.06245949f, 
    -0.09633197f, -0.01958327f, 0.00619739f, -0.04225146f, 0.02349566f, 0.02254975f, 0.03086149f, -0.06396485f, 
    0.04665982f, -0.05261390f, 0.01104399f, -0.09878258f, -0.08733603f, 0.04417663f, 0.00402210f, -0.03159983f, 
    -0.04033295f, 0.06324807f, -0.03797645f, 0.01693359f, -0.06341759f, -0.08143363f, -0.02451671f, 0.02742690f, 
    -0.08940122f, -0.06490777f, 0.04767888f, -0.07421576f, -0.08383189f, -0.03191632f, 0.03777425f, -0.02994162f, 
    0.04256439f, 0.03491968f, -0.08721353f, 0.04947475f, -0.04882529f, -0.02754483f, 0.01902512f, -0.08706323f, 
    0.01051263f, -0.04488121f, -0.00674735f, -0.12289696f, -0.02925432f, 0.00005823f, -0.09562090f, -0.02399531f, 
    0.02788729f, -0.13364570f, -0.07267688f, 0.01836319f, 0.06180082f, -0.04875180f, -0.11964429f, -0.04301763f, 
    0.00370526f, -0.07999731f, -0.01048492f, -0.05310630f, -0.03686513f, -0.03306342f, 0.01314351f, 0.02669265f, 
    -0.05943444f, 0.00515364f, -0.04751172f, -0.05860454f, 0.01274167f, -0.00768240f, 0.01575460f, 0.00019923f, 
    0.05469547f, 0.02019644f, -0.00431714f, -0.01780556f, -0.08371756f, 0.03419181f, -0.03055658f, -0.02234012f, 
    -0.02323206f, -0.01405191f, 0.00988302f, -0.04536400f, -0.10678748f, -0.11770453f, -0.12493240f, 0.02619010f, 
    -0.09501113f, 0.02851217f, -0.05308106f, -0.04071663f, 0.00673606f, 0.04351065f, 0.00251125f, -0.10844564f, 
    -0.04272870f, -0.02290795f, 0.01632030f, 0.03292476f, 0.04853850f, -0.09813650f, -0.07480661f, -0.00425453f, 
    -0.08820140f, -0.07949402f, -0.10938942f, -0.09263728f, 0.03071142f, -0.07686825f, -0.04871282f, -0.05520364f, 
    -0.15494473f, -0.01853050f, 0.09039189f, -0.11058945f, -0.00524399f, 0.00514705f, 0.04949815f, -0.03471002f, 
    0.00206549f, -0.13453239f, -0.13947332f, -0.12411241f, -0.02985192f, -0.09475555f, -0.09903120f, -0.04093507f, 
    -0.05557434f, -0.06604215f, -0.04776020f, -0.01881080f, 0.00679332f, -0.06957823f, 0.01159817f, -0.03249025f, 
    -0.01097129f, -0.00639426f, 0.02537498f, -0.06149425f, 0.04249097f, 0.00135592f, -0.07595203f, -0.03060738f, 
    -0.10553718f, -0.11224896f, -0.07070304f, 0.02094815f, -0.07967687f, -0.02248958f, -0.10504413f, 0.00207131f, 
    -0.09902250f, -0.02482885f, 0.03398676f, 0.02833414f, -0.10769432f, -0.01466354f, -0.01570497f, -0.05294311f, 
    0.03171432f, -0.01517661f, -0.07895763f, 0.03742757f, 0.02119276f, -0.05942837f, 0.00488397f, 0.01442755f, 
    0.02312871f, 0.03011093f, 0.02415649f, -0.12131085f, -0.07479500f, -0.07384822f, -0.03659954f, 0.00044576f, 
    0.03370196f, -0.01456492f, -0.09706289f, -0.00592670f, -0.11753321f, -0.04585815f, -0.02274087f, 0.03919068f, 
    -0.02427249f, -0.18285079f, -0.17915703f, 0.01796588f, 0.02047285f, 0.12549418f, -0.16705534f, 0.09868013f, 
    -0.15043905f, -0.06555355f, -0.11823887f, -0.14199707f, -0.24239671f, -0.04695106f, 0.14986712f, -0.23128052f, 
    0.04001695f, 0.10773491f, 0.07165521f, 0.17978805f, 0.12130380f, -0.08574350f, 0.02603474f, -0.10297152f, 
    -0.15609130f, 0.02890297f, -0.00137992f, 0.19638705f, 0.19078462f, 0.02078693f, 0.17793228f, -0.07458214f, 
    -0.18386385f, 0.01884071f, 0.07488504f, 0.01006138f, 0.30264252f, 0.06735890f, -0.00216541f, -0.08527450f, 
    -0.10059133f, -0.00990038f, -0.05713953f, 0.09417672f, -0.08773553f, 0.15732767f, 0.23005253f, -0.19351627f, 
    -0.02098193f, 0.10539448f, 0.11271060f, 0.16479816f, 0.01301255f, 0.02665206f, -0.17861561f, -0.11201977f, 
    0.04771790f, -0.01286045f, 0.13552271f, 0.11754981f, 0.10277703f, -0.09766913f, 0.15689251f, -0.22759661f, 
    -0.15357792f, 0.01427645f, -0.11979487f, 0.26294160f, 0.18455860f, 0.02608233f, -0.11189514f, -0.11632875f, 
    0.49352604f, 0.13072398f, 0.08560250f, -0.18265849f, -0.21723461f, -0.10533144f, -0.10801155f, 0.05296171f, 
    -0.02569106f, -0.01788071f, -0.28149396f, 0.16434707f, 0.11675460f, -0.19553271f, -0.02429289f, 0.02631719f, 
    -0.01370923f, 0.02008029f, -0.41309097f, 0.02393348f, 0.11928835f, 0.02053465f, -0.03141529f, 0.01965642f, 
    -0.06041700f, 0.13944556f, 0.20075700f, 0.12719031f, 0.02377054f, -0.19757104f, 0.01558654f, 0.03110082f, 
    0.05552464f, -0.00802516f, -0.08307162f, 0.04256805f, 0.19720003f, 0.09984156f, -0.03175120f, -0.17398208f, 
    0.12903167f, 0.14109793f, 0.06104362f, 0.10129343f, -0.17738916f, -0.01980026f, 0.13806175f, 0.07236485f, 
    -0.03817799f, 0.09351347f, -0.02711165f, 0.06625378f, -0.13079269f, -0.04574172f, -0.11893762f, 0.11505571f, 
    0.35598469f, 0.05572655f, 0.05650165f, -0.15267582f, 0.11044641f, -0.06311891f, -0.17213662f, -0.31658903f, 
    0.00396831f, -0.22735463f, 0.04351712f, 0.16598293f, 0.14401335f, 0.06628177f, -0.15553521f, -0.04301123f, 
    0.17782572f, 0.23465011f, 0.07027707f, -0.17350632f, -0.05112170f, -0.04486655f, -0.09645507f, 0.14734279f, 
    -0.02114892f, 0.08897521f, 0.14543833f, -0.52044868f, 0.00547443f, 0.11040442f, 0.12687264f, 0.04812564f, 
    0.13910435f, 0.03165393f, 0.03234531f, -0.00637096f, -0.12237720f, 0.00237920f, -0.00563388f, 0.06736035f, 
    -0.18251935f, -0.12041920f, 0.18975523f, 0.13143533f, -0.06651099f, 0.03040604f, 0.01626978f, 0.11731261f, 
    0.11062906f, -0.03295505f, -0.00823506f, 0.17647940f, -0.22082379f, 0.21902470f, 0.06280372f, 0.07662404f, 
    0.02078179f, 0.15733166f, 0.06563445f, -0.09127767f, 0.09174892f, 0.17069925f, -0.19679166f, 0.03900414f, 
    -0.03441069f, 0.00689244f, 0.15959974f, 0.04557944f, 0.04033247f, 0.09081858f, 0.04228016f, 0.24167964f, 
    -0.30573940f, 0.14823475f, -0.20862539f, -0.20310557f, 0.11874946f, 0.15322040f, -0.17489846f, 0.18430768f, 
    0.30470532f, 0.08763672f, -0.08899911f, -0.08434811f, -0.09634361f, 0.15244749f, 0.02140112f, 0.09911525f, 
    -0.11185133f, -0.13103810f, -0.05537082f, -0.06373213f, 0.05236459f, -0.06709211f, -0.08371425f, -0.11390457f, 
    0.01858456f, -0.14373595f, 0.32918149f, -0.41144386f, 0.19132434f, 0.11555161f, 0.01196341f, -0.16660276f, 
    -0.12237960f, 0.02238576f, 0.05897632f, -0.05037796f, -0.41971883f, -0.00241450f, 0.09843004f, 0.18549019f, 
    -0.07634036f, -0.13877206f, -0.16161856f, 0.12388749f, -0.08518138f, -0.20771071f, -0.06366454f, -0.06187196f, 
    -0.10419022f, 0.07588733f, -0.05171432f, 0.14104068f, -0.32056180f, 0.08368234f, -0.06202715f, 0.03315410f, 
    -0.06996197f, 0.10023025f, 0.01398019f, 0.05260491f, -0.09414412f, -0.35712254f, -0.11653755f, -0.20949450f, 
    0.16797459f, -0.05704653f, 0.05251207f, -0.00638054f, 0.13676883f, -0.05725072f, 0.31344041f, 0.20385522f, 
    -0.13729300f, -0.02655691f, 0.02228975f, 0.10395363f, 0.05802209f, 0.10946871f, 0.07344514f, 0.10791228f, 
    0.02805450f, -0.12691525f, 0.00411236f, -0.14402868f, -0.13193138f, -0.12929150f, 0.07708274f, 0.10377167f, 
    0.17312481f, -0.13439867f, -0.05980623f, 0.03454726f, -0.16244040f, 0.07974689f, -0.13555254f, 0.03534550f, 
    -0.06038567f, 0.17073002f, 0.36778510f, 0.23895158f, 0.17455089f, 0.11436167f, 0.04977439f, 0.07840194f, 
    0.18600276f, 0.02978940f, -0.27894443f, -0.31216288f, -0.23787630f, -0.10688964f, -0.05106889f, -0.01752455f, 
    0.14302368f, -0.09727015f, 0.04271593f, 0.23575220f, -0.14181183f, 0.04462934f, -0.12020513f, -0.11232261f, 
    -0.10531940f, -0.10332857f, -0.11922660f, -0.02984976f, 0.09432922f, -0.03711020f, -0.23458497f, 0.05792161f, 
    0.04090359f, 0.01063685f, 0.11299887f, 0.04264605f, 0.09570210f, 0.07029086f, -0.17638205f, -0.18402278f, 
    -0.17671721f, -0.09604258f, -0.08506395f, 0.03443151f, -0.12924406f, -0.07083173f, -0.02087499f, -0.01929758f, 
    -0.03425266f, -0.00723033f, 0.14791539f, -0.05008474f, 0.07683156f, -0.03715286f, 0.06739948f, -0.07139196f, 
    -0.10563234f, 0.17640255f, 0.13991442f, 0.02291259f, 0.05903113f, 0.10714217f, 0.07208096f, -0.02211500f, 
    0.14946283f, 0.27855703f, 0.12595497f, 0.02134142f, 0.00947360f, -0.09547266f, 0.03202004f, 0.04165126f, 
    0.06460385f, 0.16069089f, 0.41909930f, 0.22196710f, 0.18236104f, -0.05580575f, -0.00294136f, -0.01679299f, 
    0.16623102f, -0.06353983f, 0.04347673f, 0.39657202f, 0.33421767f, -0.09852802f, -0.02874834f, 0.06665416f, 
    -0.17186457f, 0.02582024f, -0.16731222f, 0.00850482f, 0.02021105f, -0.03219643f, 0.01094370f, -0.03645838f, 
    -0.06629889f, 0.00669556f, -0.07788529f, 0.05621039f, 0.14680679f, -0.15807687f, -0.01625161f, -0.20478328f, 
    -0.09709241f, 0.08447617f, -0.05313554f, 0.10030304f, 0.07546546f, 0.08704178f, -0.22353305f, -0.13832444f, 
    -0.01070633f, -0.03274635f, 0.02155158f, -0.16698565f, 0.04363042f, -0.06709892f, -0.24826150f, -0.47031900f, 
    0.02169315f, 0.09192619f, 0.03523415f, 0.17872486f, -0.11318039f, -0.07351036f, 0.03969960f, 0.12285796f, 
    0.02551645f, 0.02306882f, 0.00561698f, -0.01065260f, 0.11679450f, 0.00500110f, 0.03153991f, -0.02280632f, 
    0.32623580f, 0.13356061f, -0.04834775f, 0.15290503f, 0.14362490f, 0.13659833f, 0.10910271f, 0.09805250f, 
    -0.11304249f, 0.18831772f, 0.17160435f, 0.05018390f, 0.01674392f, 0.12943533f, 0.08027408f, -0.09228624f, 
    -0.08301629f, 0.04557295f, 0.45468670f, -0.03137095f, -0.09072337f, 0.02135374f, -0.00417705f, -0.14600953f, 
    -0.01957386f, 0.00987493f, -0.10113481f, 0.22586447f, 0.28832790f, -0.42474964f, 0.10921374f, -0.26059085f, 
    -0.07524414f, -0.07479348f, 0.12315616f, 0.00989920f, -0.28494143f, -0.02577273f, 0.11181255f, -0.13511784f, 
    0.02570629f, 0.07250250f, -0.12938954f, -0.08538530f, 0.02777656f, 0.04213093f, 0.14973937f, -0.23456797f, 
    0.03360303f, 0.08269294f, 0.01674042f, 0.11849620f, 0.18431854f, -0.10855378f, -0.36563548f, -0.13371176f, 
    0.21035346f, -0.00996061f, 0.00464856f, 0.04638004f, -0.16204123f, -0.04593856f, 0.05682027f, 0.14887293f, 
    -0.08827031f, -0.00734412f, -0.01950079f, 0.04397185f, 0.04365325f, -0.00787717f, 0.08979063f, 0.04694169f, 
    -0.10763752f, -0.27333328f, -0.06174737f, -0.04687757f, -0.03206400f, -0.16851020f, -0.13732043f, 0.01189097f, 
    0.18670794f, -0.00256362f, 0.01986169f, 0.21998888f, -0.05596706f, -0.02931819f, -0.20081896f, 0.07406294f, 
    0.10269234f, -0.08242982f, -0.04084682f, -0.15207663f, 0.02278780f, 0.00408600f, -0.01734423f, -0.01217264f, 
    -0.02004965f, 0.07024587f, 0.02397569f, -0.18035918f, -0.01387256f, -0.43105206f, -0.04725945f, 0.04456214f, 
    0.12306733f, -0.03685457f, 0.03426756f, -0.10884648f, 0.22177809f, 0.12452856f, 0.16480750f, -0.10205877f, 
    0.13002223f, -0.05204392f, 0.00267729f, -0.05337571f, 0.04093960f, -0.24135597f, 0.05735059f, -0.29391164f, 
    -0.05552983f, 0.10369167f, 0.07060092f, 0.10611550f, -0.08831803f, -0.01971676f, 0.44632262f, 0.00380379f, 
    -0.30230510f, 0.01635729f, -0.11179297f, -0.07351769f, 0.10675815f, -0.04246915f, 0.01719087f, -0.05866779f, 
    0.21037295f, -0.02074094f, 0.02745751f, 0.18342458f, 0.05564252f, -0.11514035f, -0.08416722f, 0.11775149f, 
    -0.24272372f, 0.15457569f, 0.00289095f, -0.16408235f, -0.18049197f, 0.00785803f, -0.01469323f, 0.09971301f, 
    -0.01103636f, -0.36455008f, -0.16380347f, -0.15996890f, -0.00935693f, 0.01695145f, -0.02237613f, -0.07495297f, 
    -0.01566640f, -0.01591114f, -0.07862690f, 0.28505346f, -0.17385401f, -0.17529050f, 0.03525478f, -0.03368940f, 
    -0.01743497f, 0.09727757f, -0.01771965f, -0.08418420f, 0.03149977f, 0.08253770f, -0.00157886f, 0.19181912f, 
    0.04198985f, 0.03323824f, 0.01192899f, 0.12670493f, 0.71629798f, 0.03890108f, -0.35308897f, 0.13152957f, 
    0.06480090f, 0.08589784f, 0.02072637f, -0.01846837f, -0.01329434f, 0.12579206f, 0.25773638f, -0.09574578f, 
    -0.06385434f, 0.04362059f, 0.15619123f, 0.20135596f, 0.15300012f, -0.02413075f, 0.22741643f, 0.00189961f, 
    -0.21634984f, -0.01237310f, -0.14843796f, 0.02903382f, 0.07627469f, 0.03503390f, 0.03545466f, -0.06017463f, 
    0.06163556f, 0.19366497f, -0.02765707f, -0.00598501f, -0.05266808f, -0.06308391f, 0.07093965f, -0.06689062f, 
    -0.36631095f, -0.21071565f, -0.16890834f, 0.11011226f, 0.09389756f, -0.07680894f, 0.00796671f, -0.05854445f, 
    -0.11689053f, -0.18344662f, -0.11562043f, -0.02280382f, -0.08981648f, 0.05590967f, 0.12718935f, 0.02964108f, 
    0.02073491f, -0.06168082f, -0.18060535f, -0.31539598f, -0.19387780f, -0.03921462f, 0.07332391f, -0.10765375f, 
    -0.06803078f, -0.06538133f, -0.08861361f, 0.11425685f, -0.22771707f, -0.07283755f, 0.02885037f, -0.04116611f, 
    0.14720827f, -0.09711921f, -0.04780436f, 0.12608269f, -0.26811212f, 0.05406400f, -0.03440645f, -0.04836939f, 
    -0.05541802f, -0.02012165f, -0.06497397f, 0.10221370f, 0.10626207f, -0.05853730f, -0.21253435f, 0.09420320f, 
    0.02632830f, 0.06700553f, 0.12987314f, 0.12251661f, 0.07269476f, 0.08801600f, -0.03803508f, 0.04580862f, 
    0.16958763f, -0.14328119f, 0.06123344f, -0.03841787f, -0.16194029f, -0.10762983f, -0.05195105f, -0.06024608f, 
    -0.22713140f, 0.20949504f, -0.12243724f, 0.27034199f, 0.02963770f, 0.03440115f, 0.05614734f, -0.08335183f, 
    -0.02842696f, 0.00479652f, 0.01856936f, 0.00691532f, 0.04520874f, -0.05597390f, 0.05149850f, 0.04962176f, 
    -0.05447388f, -0.08280680f, -0.06143349f, -0.02271043f, 0.00298285f, 0.02594463f, -0.03346973f, 0.01315078f, 
    -0.01794584f, 0.02754128f, 0.02101133f, -0.08005073f, 0.04537250f, -0.05469422f, 0.01619150f, 0.07830264f, 
    -0.03688316f, 0.04642019f, 0.03488980f, -0.00859852f, -0.06100025f, -0.08145715f, 0.02467900f, -0.03037365f, 
    -0.05902821f, -0.02793799f, -0.06821972f, -0.06152989f, -0.00628090f, 0.01576728f, 0.04163031f, -0.01560701f, 
    0.05601982f, 0.00146500f, -0.00379493f, -0.08290742f, -0.04242697f, -0.03807268f, 0.07621380f, 0.06945854f, 
    0.02199477f, 0.04916398f, -0.03042607f, 0.01769318f, 0.07776227f, -0.02809638f, 0.05806553f, -0.04571136f, 
    0.05961394f, -0.06799638f, -0.07553880f, 0.02371661f, -0.03104593f, -0.01806757f, 0.06802752f, -0.03940380f, 
    -0.08079101f, 0.06792992f, -0.04529841f, -0.07159135f, -0.07335301f, 0.06420647f, 0.01539259f, -0.03931611f, 
    -0.07861316f, -0.07562968f, -0.05579282f, -0.00698865f, -0.02209446f, 0.02807884f, 0.05123956f, -0.05311238f, 
    -0.06505632f, -0.03527657f, -0.01693858f, -0.03729617f, -0.02404225f, 0.00972473f, -0.02821374f, 0.00571526f, 
    -0.04511749f, -0.06867545f, 0.03410707f, 0.02788012f, 0.04147335f, -0.06840505f, -0.08001998f, 0.00994955f, 
    -0.06057694f, -0.05299070f, -0.04210102f, 0.03812221f, 0.03804887f, -0.06811810f, 0.00644009f, 0.06107052f, 
    0.05215915f, -0.07344425f, -0.01683262f, -0.07944100f, -0.03234976f, 0.04624667f, -0.01622971f, 0.04594554f, 
    0.06078219f, -0.05639790f, -0.00360849f, 0.01132732f, -0.07520670f, -0.06602259f, 0.08093092f, -0.01810686f, 
    -0.06544458f, -0.04413037f, -0.07508083f, -0.03967134f, -0.02137909f, -0.06749504f, -0.00576106f, -0.03284601f, 
    -0.02068417f, 0.03427674f, -0.03755526f, -0.03737899f, -0.05338264f, 0.07003405f, -0.04728675f, -0.03463168f, 
    -0.03344113f, 0.05447022f, 0.08304767f, -0.06771521f, -0.00146508f, -0.06627168f, 0.01902629f, 0.01336662f, 
    -0.02914620f, -0.08955377f, -0.04084442f, -0.04205366f, -0.01159455f, -0.05348125f, 0.00629788f, -0.01502321f, 
    0.04889056f, 0.02000246f, 0.00695909f, -0.06785056f, -0.00038910f, -0.03982130f, -0.06713025f, 0.05076844f, 
    0.01417541f, 0.04589359f, -0.07645076f, -0.00699563f, 0.01955309f, -0.05630569f, 0.00350694f, -0.06408997f, 
    0.05338836f, 0.00436560f, 0.07046236f, 0.05748893f, 0.01047623f, -0.04252698f, -0.08779231f, 0.05144873f, 
    -0.06773168f, -0.03870585f, 0.06817118f, 0.02924849f, -0.03563629f, -0.01359694f, -0.00545036f, 0.01086498f, 
    -0.02728469f, 0.00776004f, 0.03186662f, 0.07408172f, -0.08512434f, 0.03752374f, -0.05297954f, 0.00373909f, 
    -0.06186227f, 0.07425800f, 0.03610718f, -0.07962179f, -0.01277183f, -0.06206981f, 0.02501650f, 0.04848682f, 
    -0.00892316f, -0.01010529f, 0.04072984f, 0.07047167f, 0.06465408f, -0.07601685f, -0.03802502f, -0.00448946f, 
    0.01841771f, -0.05143993f, -0.05833056f, 0.04716789f, -0.04033350f, -0.00822964f, -0.04901611f, -0.08539196f, 
    -0.04303957f, -0.08539885f, -0.07744299f, -0.01296515f, -0.01782314f, -0.04355396f, -0.02783549f, -0.00727336f, 
    -0.02086814f, 0.04145966f, 0.04846828f, -0.03597824f, -0.02501620f, -0.02066763f, 0.02154925f, -0.06926833f, 
    -0.06677159f, 0.07859383f, -0.04081742f, 0.02534934f, -0.03441929f, 0.02628312f, -0.07914261f, 0.03041427f, 
    -0.01839163f, 0.00501934f, -0.03514149f, -0.06245575f, -0.02127967f, -0.04550102f, 0.06083280f, 0.04688596f, 
    -0.06393397f, 0.02137582f, 0.02317507f, -0.03968771f, -0.02054058f, -0.00363112f, -0.03902752f, 0.02849986f, 
    0.00458633f, -0.00615286f, 0.04930000f, 0.00283375f, 0.03690512f, 0.03723884f, -0.07491937f, 0.06976971f, 
    -0.03461070f, -0.01894200f, -0.08582405f, 0.07235730f, -0.06159416f, -0.00375354f, -0.07352890f, 0.02306937f, 
    -0.01348591f, 0.02668566f, -0.08999622f, -0.01686594f, 0.04640747f, -0.02391627f, 0.01998264f, 0.06142640f, 
    0.01273399f, -0.06048264f, -0.05020510f, -0.00617390f, -0.07395928f, 0.00516054f, -0.05886985f, 0.00694772f, 
    -0.21530432f, 0.17181931f, 0.05340825f, 0.09957863f, 0.05776138f, 0.03135546f, 0.01153612f, 0.10728721f, 
    0.08774190f, -0.19520059f, 0.26130092f, 0.09654229f, 0.08565456f, -0.06250211f, -0.15399735f, 0.13830894f, 
    0.00865701f, -0.04963248f, 0.22411627f, -0.22701225f, 0.09907649f, 0.17282887f, -0.03625457f, 0.05762761f, 
    0.05491676f, 0.03486178f, 0.05997896f, -0.10206846f, -0.20139341f, -0.04221221f, 0.03296401f, 0.19002336f, 
    0.07746010f, 0.04652436f, -0.02181761f, 0.07198498f, 0.27429062f, 0.24814770f, 0.13903579f, -0.10249804f, 
    -0.08625457f, -0.03385544f, -0.04878667f, 0.05567415f, 0.06510031f, -0.02897104f, 0.00671264f, 0.02047372f, 
    0.18150352f, 0.02776633f, 0.17168403f, -0.06276238f, 0.02664512f, -0.00489487f, 0.20413534f, 0.05796680f, 
    0.08180486f, -0.17760797f, -0.03549529f, -0.24783787f, 0.10914245f, -0.02699353f, -0.09514549f, 0.34323981f, 
    0.00727908f, 0.00509502f, 0.06822520f, -0.07320686f, -0.02004653f, -0.12764074f, 0.06422594f, 0.09438135f, 
    -0.03419502f, -0.24946257f, -0.02305228f, -0.10732839f, 0.02593297f, -0.04411750f, 0.05959632f, -0.01693941f, 
    -0.10360073f, -0.37050784f, 0.16008481f, 0.24017219f, -0.05890961f, 0.01097029f, -0.01161935f, -0.05264155f, 
    0.05338563f, 0.00201268f, -0.33514982f, -0.23642224f, -0.29584694f, -0.07342301f, -0.01130640f, -0.01196348f, 
    -0.03215455f, -0.15641311f, 0.04580519f, 0.01414361f, 0.07034652f, -0.57833403f, 0.15307759f, 0.10436496f, 
    0.02318070f, 0.08878763f, 0.01715696f, 0.15679835f, -0.21128732f, -0.01432946f, -0.14443353f, -0.06705230f, 
    -0.05272394f, 0.13446411f, 0.10162091f, -0.03893778f, 0.11129788f, -0.14038049f, -0.47746885f, -0.07413480f, 
    0.05770041f, 0.01246400f, 0.06193608f, -0.02729788f, -0.02323645f, 0.15240268f, 0.09795313f, -0.19818802f, 
    -0.09106579f, -0.04746955f, 0.02913197f, 0.11624327f, -0.07270084f, -0.06653816f, -0.01379019f, 0.01471682f, 
    -0.45820752f, 0.14098229f, 0.16103804f, -0.16514327f, 0.10770002f, -0.08777314f, 0.14437790f, 0.03323076f, 
    -0.01452753f, 0.17044710f, -0.16496590f, 0.06641936f, -0.26349539f, 0.15710740f, -0.00892316f, -0.13711731f, 
    -0.01429452f, 0.08370813f, -0.07599308f, 0.06562653f, 0.15810546f, -0.13927826f, 0.08611252f, 0.10953962f, 
    -0.12868832f, 0.09327498f, -0.11807204f, 0.14944528f, -0.38102484f, -0.20131050f, -0.13649780f, -0.17983517f, 
    -0.09385409f, -0.17832568f, 0.05679644f, -0.10652795f, 0.08037036f, 0.14075898f, 0.06985246f, -0.13420209f, 
    -0.21696578f, 0.04773420f, 0.10783537f, 0.13113792f, 0.22610930f, -0.07834394f, 0.07037985f, 0.00992232f, 
    0.12428185f, 0.21698457f, -0.06182678f, -0.03256851f, 0.00919131f, -0.24574085f, -0.05713210f, 0.06313761f, 
    -0.03835893f, 0.17512061f, -0.11698896f, 0.02022740f, 0.07694348f, 0.06858712f, 0.19013408f, -0.12489630f, 
    0.00433171f, -0.08040813f, 0.05389396f, 0.06356489f, 0.05379713f, -0.10679602f, 0.02264015f, -0.01851993f, 
    -0.27495027f, -0.24870294f, 0.18779463f, 0.11753946f, 0.12959014f, 0.15701964f, 0.08872316f, 0.11291236f, 
    0.06508733f, 0.02307982f, 0.09294416f, -0.13943604f, 0.06852224f, -0.06152036f, 0.04119128f, -0.09337521f, 
    0.03632300f, 0.03262928f, -0.00241315f, -0.00231945f, 0.06551944f, 0.21790732f, 0.12044270f, 0.09978499f, 
    -0.09331616f, -0.04153493f, -0.35058126f, -0.03475791f, 0.01875477f, -0.07047894f, 0.02252139f, -0.08371676f, 
    0.00818913f, -0.11416999f, 0.07225100f, -0.02006136f, 0.01717516f, 0.18714018f, 0.15144576f, 0.15340559f, 
    -0.09129859f, 0.10074726f, -0.09020910f, -0.09364808f, 0.04756221f, -0.26060128f, -0.10646030f, -0.13743044f, 
    0.19030307f, 0.06301200f, 0.17292556f, 0.05682913f, 0.07294435f, -0.38250023f, 0.17412671f, -0.08844425f, 
    -0.15890852f, -0.01540378f, -0.21756984f, 0.07797544f, 0.10477184f, 0.21423975f, -0.03835264f, 0.31126106f, 
    -0.18083026f, 0.23380294f, -0.15157807f, -0.03869195f, 0.03689871f, 0.17022847f, 0.05245373f, -0.08043434f, 
    0.13810138f, 0.16348614f, 0.21323285f, -0.00341946f, -0.03537207f, 0.09931022f, -0.04484172f, -0.04389277f, 
    -0.02681621f, 0.01704654f, -0.02873693f, -0.05485282f, -0.06365839f, -0.06115182f, -0.07485214f, -0.02879256f, 
    -0.07662314f, 0.05979574f, 0.08112129f, -0.09507127f, -0.07579400f, -0.01991390f, 0.03669784f, -0.00896117f, 
    0.01426669f, -0.00098414f, 0.04568949f, 0.07201425f, 0.03142736f, 0.03695457f, -0.04570023f, -0.05793645f, 
    -0.01416726f, -0.01001867f, -0.07042491f, 0.01555610f, 0.01755490f, 0.03181669f, 0.01062437f, 0.02413482f, 
    -0.04781119f, 0.00606106f, -0.04097311f, -0.05434301f, 0.00906947f, 0.01726027f, -0.03046745f, -0.01340085f, 
    -0.03971591f, -0.10348778f, -0.08818354f, -0.06195159f, -0.06395666f, 0.03386722f, 0.01809979f, -0.04848766f, 
    -0.03626483f, 0.02367738f, -0.05109138f, -0.04113938f, -0.10745239f, 0.05065206f, -0.07534815f, -0.02301673f, 
    0.05222775f, 0.00303157f, 0.00577747f, -0.09998182f, -0.05205284f, -0.04311308f, -0.03125118f, -0.02188474f, 
    -0.07127111f, -0.06182311f, 0.05245351f, -0.07388608f, -0.03450799f, -0.00666470f, -0.01758961f, -0.01359040f, 
    0.02305804f, 0.00254957f, 0.06193937f, -0.12967712f, 0.01810099f, -0.02127373f, 0.00054922f, -0.11476359f, 
    0.05105122f, -0.01975160f, 0.07811921f, -0.07662570f, 0.01751615f, -0.05987366f, -0.03816874f, -0.03794969f, 
    0.05430700f, -0.03332754f, -0.05353328f, -0.06395674f, 0.05569226f, -0.00313657f, 0.01495808f, -0.04350477f, 
    0.08161687f, 0.00284711f, 0.01794257f, -0.05878275f, 0.03699347f, -0.06898139f, -0.09781869f, 0.07343645f, 
    0.00271104f, -0.05337565f, -0.06861701f, -0.10475639f, -0.06917087f, 0.02906268f, -0.09419682f, 0.03781399f, 
    -0.08321387f, -0.01442972f, -0.11536524f, -0.02071353f, -0.01473912f, -0.01496136f, 0.08058482f, -0.05193355f, 
    -0.02707052f, 0.03124856f, -0.08346393f, 0.09137982f, 0.01698615f, -0.08881657f, -0.06082050f, 0.03259448f, 
    -0.07384468f, -0.02992116f, 0.00691040f, 0.03263528f, -0.11131430f, -0.08370299f, -0.09690417f, -0.02921547f, 
    -0.06456258f, -0.02634914f, -0.05842321f, 0.02491121f, 0.03285972f, -0.12082137f, -0.08374129f, -0.01621631f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00669277f, 0.16022444f, 0.06550022f, -0.07721880f, 0.00944057f, 0.03115329f, 0.02104659f, 0.11735279f, 
    -0.09560677f, -0.06581064f, 0.26408541f, -0.00107912f, -0.05296514f, 0.12144125f, 0.20885536f, 0.02651971f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01202796f, -0.12980682f, 0.20496786f, 0.00096501f, -0.00686213f, 0.02288121f, -0.02041676f, -0.01677609f, 
    0.32837597f, -0.18076883f, -1.12391138f, 0.18345827f, -0.07935324f, -0.14134130f, -0.09886561f, 0.27420476f, 
    0.25837329f, 0.37145939f, 0.23437864f, 0.21114162f, 0.00356902f, 0.03888194f, 0.21860240f, 0.11517314f, 
    -0.41246462f, -0.12154276f, 0.03632108f, -0.11152640f, 0.06446642f, -0.37681428f, 0.26063502f, -0.22177595f, 
    -0.12816672f, -0.34163392f, 0.07877597f, -0.03762186f, 0.18904290f, -0.14498460f, 0.35480487f, -0.33960655f, 
    0.00883447f, 0.11794464f, 0.47331178f, 0.14056501f, 0.01663905f, -0.13440292f, 0.20674470f, -0.16855694f, 
    0.25923559f, 0.20409146f, 0.19436592f, -0.13944860f, -0.18939334f, -0.01917653f, 0.33899003f, 0.12207722f, 
    -0.28598133f, 0.25068980f, 0.59655005f, -0.05038920f, 0.04398176f, -0.34077120f, -0.03600630f, 0.17847270f, 
    -0.04104321f, 0.39886954f, -0.00927374f, 0.14133085f, 0.11383763f, -0.22048245f, -0.17457134f, 0.04172984f, 
    0.19615433f, -0.25934494f, 0.13808362f, -0.19166023f, 0.23253249f, -0.29123580f, 0.35690087f, -0.30951059f, 
    0.62201500f, -0.31296065f, 0.11714595f, -0.27953908f, 0.11111175f, 0.01419789f, 0.11253336f, -0.03473894f, 
    -0.26202318f, 0.17491202f, -0.25707129f, 0.11811325f, 0.10631327f, 0.04978002f, 0.21836020f, -0.01124473f, 
    0.05120411f, 0.05910151f, -0.01525158f, 0.20908797f, -0.15805964f, -0.15542597f, 0.31304032f, -0.16350988f, 
    0.19402312f, 0.42361224f, -0.21517937f, 0.04994485f, -0.20755622f, 0.32609499f, -0.18001638f, 0.04733703f, 
    -0.29222003f, 0.09112252f, -0.02040561f, 0.02117039f, 0.19489717f, 0.14457326f, -0.24552988f, 0.29943490f, 
    -0.26769406f, 0.14221457f, -0.13104254f, 0.06928638f, 0.21172710f, 0.56482381f, -0.15128158f, -0.08188605f, 
    0.07995031f, -0.33131248f, -0.07017481f, -0.22674754f, -0.22855532f, -0.03249395f, -0.03261865f, 0.27998996f, 
    -0.21654657f, 0.25760281f, 0.05118206f, -0.08047965f, -0.20880663f, 0.34919932f, 0.09292868f, 0.22768591f, 
    -0.26475263f, -0.00879822f, -0.15804508f, 0.17501083f, -0.13014174f, -0.02768278f, 0.08073376f, 0.05181267f, 
    -0.11033178f, -0.29870793f, -0.06006916f, -0.16330016f, -0.04385275f, -0.09025288f, -0.08851017f, 0.16440406f, 
    -0.00229393f, 0.55920613f, 0.08006006f, 0.18473741f, -0.09288948f, 0.10254996f, 0.06943502f, 0.00694805f, 
    -0.13018289f, -0.14507097f, -0.41487157f, 0.24945837f, 0.15388620f, 0.17157061f, -0.16355664f, -0.15195945f, 
    0.41699645f, -0.01185658f, 0.15854202f, 0.12515649f, -0.28098431f, 0.15582561f, -0.19163477f, -0.05396268f, 
    -0.29902244f, 0.37106591f, 0.52514446f, 0.10603827f, -0.22928078f, -0.34724391f, 0.06932712f, 0.17643808f, 
    -0.41351634f, -0.11409107f, 0.08394924f, 0.13947603f, 0.19222397f, 0.19622487f, 0.26649514f, 0.23550759f, 
    0.20789373f, -0.40120637f, -0.04628801f, 0.06527603f, -0.07398359f, -0.50428832f, 0.29578781f, 0.07434107f, 
    0.22629032f, 0.22276628f, -0.22829153f, -0.11222187f, 0.02585594f, 0.08396834f, 0.03825147f, -0.15907782f, 
    0.47541434f, 0.17490183f, 0.03420865f, -0.22202241f, 0.21735899f, -0.28464463f, -0.07920574f, -0.15214904f, 
    -0.40608051f, 0.11308890f, 0.01589403f, -0.16829668f, 0.13511832f, -0.20683952f, -0.11209638f, 0.37480876f, 
    -0.23876178f, -0.49630716f, 0.42347515f, -0.17886069f, -0.03977584f, -0.35752267f, 0.32195917f, 0.23147957f, 
    -0.09376422f, 0.16889322f, -0.13874894f, -0.05237185f, 0.11611871f, 0.09121957f, 0.17995077f, 0.33299780f, 
    -0.14025976f, 0.48132265f, -0.42451853f, 0.08624202f, 0.22089325f, -0.04637321f, -0.16152573f, 0.03625719f, 
    -0.45963025f, 0.26889631f, 0.12076544f, 0.09290944f, 0.00381271f, 0.22144504f, 0.26008216f, 0.05079821f, 
    0.00496969f, 0.32920489f, -0.05513251f, -0.24711245f, -0.25449055f, 0.38179785f, -0.32025698f, 0.06145843f, 
    0.13571683f, 0.08174447f, 0.17662184f, -0.19186912f, 0.17980908f, -0.00315682f, 0.24838945f, -0.50392681f, 
    0.29377860f, 0.27956709f, 0.31517330f, -0.14413947f, 0.01853871f, -0.21333006f, 0.20652393f, -0.20444931f, 
    0.03682950f, -0.07820492f, -0.02620229f, 0.13121831f, 0.03033708f, 0.20621647f, -0.22071032f, 0.28657541f, 
    0.43832135f, 0.21387121f, -0.17604131f, 0.15451977f, -0.10552797f, 0.05166394f, -0.18755741f, 0.09964344f, 
    0.07555090f, -0.09257281f, 0.13820741f, -0.23558572f, 0.16095236f, 0.08916186f, 0.29385921f, -0.45721677f, 
    0.39647701f, 0.15579054f, 0.33469662f, -0.11926705f, 0.20733620f, -0.25877932f, 0.08627973f, 0.08673305f, 
    -0.54904199f, 0.25563568f, 0.06707244f, -0.13570794f, 0.14149106f, 0.21364944f, -0.13198446f, 0.30694515f, 
    0.13892539f, 0.13768804f, 0.09979746f, -0.15198225f, -0.03349037f, 0.14356443f, -0.07368882f, 0.05423610f, 
    -0.14143389f, 0.25665164f, -0.03870513f, -0.00233189f, -0.05124446f, -0.23817840f, 0.34459630f, -0.27824366f, 
    -0.12184879f, 0.00772938f, 0.10825253f, 0.23148206f, 0.12601887f, -0.27705169f, 0.37796670f, 0.17213655f, 
    -0.57094795f, -0.35264096f, 0.13023104f, -0.02436255f, -0.03036412f, 0.23714127f, -0.04500077f, 0.10558025f, 
    -0.10427421f, 0.02401342f, 0.45562026f, -0.00724605f, -0.03376288f, 0.48046139f, 0.31430465f, -0.09634545f, 
    0.51352125f, -0.38837060f, -0.17820713f, -0.08723232f, 0.07982838f, -0.00721252f, -0.04822145f, -0.29777023f, 
    0.04118720f, -0.40118590f, 0.01331521f, -0.03908226f, 0.10164785f, 0.09842252f, 0.06797193f, -0.20190652f, 
    -0.24021623f, -0.57891518f, -0.00031017f, -0.03096330f, -0.03270442f, -0.21276671f, 0.37609434f, -0.15436524f, 
    0.12983154f, 0.30507517f, 0.39134482f, -0.21436015f, 0.19420010f, 0.10111286f, 0.26786083f, 0.16003658f, 
    -0.05225243f, 0.44681057f, -0.24969357f, 0.23369002f, -0.12175654f, 0.23357819f, 0.41444138f, -0.06215437f, 
    -0.33441079f, 0.42049539f, -0.22728840f, -0.02868500f, -0.17920536f, -0.27427527f, 0.06102454f, 0.04142821f, 
    0.15683779f, -0.03455658f, 0.06185275f, -0.21478878f, -0.02635284f, -0.29650235f, 0.40219259f, -0.27320969f, 
    -0.29303798f, 0.46248025f, 0.21317725f, 0.11226895f, 0.21566154f, 0.25745097f, 0.09410484f, -0.02072827f, 
    -0.18541963f, -0.19519007f, 0.00422368f, 0.09057766f, 0.23206076f, 0.01502367f, 0.22887813f, 0.22919077f, 
    0.13480048f, -0.00063763f, 0.27738911f, -0.24319848f, 0.04460847f, 0.15346435f, -0.24863738f, -0.00155267f, 
    0.16916715f, -0.18678488f, 0.12181011f, 0.04046489f, -0.14018524f, -0.13142525f, 0.41645318f, -0.10086361f, 
    0.19207948f, 0.37434468f, -0.16146137f, -0.10433552f, 0.21499003f, 0.22836927f, -0.11986459f, 0.04501380f, 
    0.54828960f, -0.21224658f, -0.05321562f, 0.13598128f, -0.09161032f, -0.01476781f, 0.24003594f, 0.26742035f, 
    0.26310757f, -0.09175631f, -0.23723559f, -0.01312894f, -0.23923475f, 0.18815865f, -0.21596996f, 0.10127407f, 
    0.45713538f, 0.00130433f, 0.01422334f, -0.16144677f, 0.18534897f, -0.09830587f, -0.11216909f, 0.16872947f, 
    0.02087179f, -0.23725735f, -0.14979595f, 0.15293434f, -0.10211304f, 0.43858817f, -0.06178686f, -0.06455904f, 
    0.22318153f, -0.84443349f, 0.16132903f, 0.18812740f, 0.18617637f, -0.11069057f, 0.29025516f, -0.43869811f, 
    0.30833918f, -0.25626305f, 0.19700566f, 0.24950334f, -0.12357557f, -0.23857680f, -0.08479782f, -0.10474820f, 
    0.69152105f, 0.07627184f, 0.14134395f, 0.07781079f, -0.04966606f, -0.15711467f, 0.37113562f, -0.15915471f, 
    -0.21805654f, -0.04463649f, -0.25568938f, 0.24911931f, 0.00852150f, -0.11744680f, 0.35070419f, 0.05264802f, 
    -0.20002331f, 0.30578393f, -0.23413055f, -0.02478064f, 0.23031996f, 0.18937269f, -0.16326110f, -0.49107823f, 
    0.37993851f, 0.14793769f, -0.03540875f, -0.04601929f, -0.06735165f, -0.00762538f, -0.33932671f, 0.05403520f, 
    -0.07657673f, 0.30994135f, -0.20965216f, 0.23424788f, 0.21776487f, 0.04197542f, -0.15927455f, -0.08917215f, 
    0.37409037f, -0.07353590f, 0.43032470f, 0.24386525f, -0.11785286f, -0.01952737f, 0.12953845f, -0.10204053f, 
    -0.21587560f, 0.25424418f, 0.19153920f, -0.20910843f, -0.00530152f, 0.10497949f, -0.05159563f, 0.22254793f, 
    -0.21140786f, -0.22897938f, 0.17607772f, 0.22667709f, 0.01300747f, -0.28346920f, 0.34581271f, 0.16520703f, 
    -0.24535047f, -0.32588807f, 0.07563610f, 0.08593787f, 0.15937589f, -0.11105290f, 0.32933980f, 0.24379988f, 
    0.00748222f, 0.16514376f, 0.36227274f, -0.20919687f, 0.17918096f, -0.37370843f, 0.17478038f, -0.11543650f, 
    0.16599211f, -0.04647045f, 0.14944725f, 0.22797748f, -0.19984379f, 0.08006471f, -0.15735863f, -0.10737779f, 
    -0.06383245f, 0.05569404f, -0.06918786f, 0.22324735f, 0.02423418f, -0.18476887f, -0.27296436f, -0.11516032f, 
    0.12536311f, -0.00153390f, 0.20080057f, 0.14664689f, 0.19698387f, 0.14183345f, -0.24438179f, -0.23348510f, 
    -0.14242509f, -0.06121618f, -0.17250237f, 0.12358996f, 0.06549868f, -0.22465768f, -0.24034113f, -0.03966388f, 
    -0.06898293f, -0.00046300f, -0.19762945f, -0.03623754f, -0.20009355f, -0.04383421f, -0.26963308f, 0.35961547f, 
    0.24454103f, 0.17846800f, 0.39713499f, -0.03461152f, -0.01791379f, -0.57215089f, 0.07444430f, -0.22181822f, 
    0.09079645f, -0.21892680f, -0.06203156f, 0.06314458f, 0.05491322f, -0.08432071f, -0.07596047f, -0.27672485f, 
    0.25999507f, 0.69714952f, -0.05240241f, 0.07524478f, -0.12529100f, -0.48885688f, 0.06539740f, 0.02420929f, 
    -0.49645752f, 0.01616165f, 0.08466316f, -0.19470559f, 0.13785516f, 0.06836696f, 0.18219131f, 0.05233103f, 
    -0.11011145f, 0.29119641f, 0.39434478f, 0.04464680f, -0.01474846f, 0.48830906f, -0.17064017f, 0.03009180f, 
    -0.09262100f, -0.68746144f, -0.07113409f, -0.02518114f, 0.14796206f, -0.14409645f, 0.43630099f, -0.06616462f, 
    0.30772102f, -0.05641571f, 0.31021622f, 0.19748050f, -0.24824235f, -0.33284846f, 0.15993589f, -0.23895815f, 
    -0.37473968f, -0.19745761f, -0.10216228f, 0.03799130f, 0.03352409f, 0.12234262f, 0.07899252f, 0.46164742f, 
    -0.38645735f, -0.07761807f, 0.50049937f, 0.20374244f, 0.07081679f, -0.37720498f, 0.26898989f, -0.15682009f, 
    0.46830437f, -0.49117717f, -0.11782999f, -0.09414809f, -0.11541712f, -0.02918718f, 0.17501222f, -0.15063883f, 
    0.23559992f, 0.36644840f, -0.12661254f, -0.10458067f, 0.10599254f, -0.15301625f, 0.26183543f, -0.03104405f, 
    0.02557127f, 0.35935867f, -0.15925725f, 0.28474733f, 0.18883137f, 0.22750710f, 0.09342720f, -0.17803407f, 
    0.15079534f, -0.24778038f, 0.23029925f, -0.00561172f, 0.07926346f, -0.22801107f, 0.00374699f, -0.05289753f, 
    0.16719279f, -0.02279858f, 0.04053865f, 0.07857107f, 0.24389333f, -0.08024981f, 0.11362081f, -0.11062386f, 
    -0.38516930f, 0.02885637f, 0.49938032f, -0.21784091f, -0.12669079f, 0.08269046f, 0.41422737f, 0.12467443f, 
    -0.04414032f, 0.18138745f, -0.22944333f, 0.23593186f, -0.04304330f, -0.03472063f, -0.22361419f, -0.34098130f, 
    0.15587611f, 0.17364036f, -0.49877152f, 0.00426394f, -0.10345359f, -0.07771136f, 0.39275265f, 0.06714206f, 
    -0.18167906f, 0.35513729f, -0.21450061f, -0.13879266f, 0.02194817f, 0.06515382f, -0.16671954f, 0.17936170f, 
    0.00487364f, -0.08709614f, 0.13728131f, 0.03444222f, -0.11643156f, 0.31802914f, -0.33323789f, 0.17848676f, 
    0.12208077f, -0.24752082f, 0.16768560f, -0.05087656f, -0.21230364f, 0.22119781f, -0.08354247f, -0.05392990f, 
    -0.24894303f, -0.22844952f, -0.24973588f, -0.03370193f, 0.07476559f, -0.11935630f, 0.06132303f, 0.22733018f, 
    0.13848236f, -0.22023889f, 0.00578621f, 0.16209239f, -0.17432666f, 0.03799310f, -0.07113218f, -0.15775478f, 
    -0.24965036f, -0.20156553f, -0.04732603f, -0.01897025f, 0.20663485f, 0.18242040f, -0.24844384f, -0.14756948f, 
    -0.25482771f, -0.24693000f, -0.22730400f, 0.13429111f, -0.08887322f, 0.07342972f, -0.29550087f, 0.31103730f, 
    0.44682050f, -0.52133977f, 0.20828328f, 0.13832715f, -0.12954590f, 0.39047277f, -0.02568900f, -0.05445454f, 
    -0.41302195f, 0.25208607f, -0.10081870f, -0.01040830f, -0.11814481f, -0.13278103f, 0.13151756f, 0.40455216f, 
    -0.25589061f, 0.51026613f, -0.23967499f, -0.04074794f, 0.13830979f, -0.14939629f, -0.36960849f, -0.02105918f, 
    -0.04629164f, -0.00726042f, -0.10866344f, 0.05524985f, 0.13371041f, 0.12120592f, 0.14293778f, 0.08683683f, 
    0.40989920f, 0.19091564f, -0.28683716f, 0.18904617f, -0.13083264f, -0.28833288f, -0.19127667f, -0.30408803f, 
    0.18332037f, 0.27304852f, -0.22585042f, 0.26279762f, -0.24162735f, 0.14537936f, -0.22471377f, -0.08328692f, 
    -0.08906128f, -0.32325542f, -0.16282894f, 0.02349976f, 0.10872666f, 0.47477025f, 0.28806299f, -0.18390112f, 
    -0.04163237f, -0.26369581f, -0.05874312f, -0.10096422f, -0.24670425f, -0.10638985f, 0.06910633f, -0.24069622f, 
    -0.03220465f, -0.20510688f, -0.23838335f, -0.21517330f, -0.09869093f, 0.19330882f, -0.28028584f, 0.14053553f, 
    0.52784437f, 0.03783818f, 0.19212827f, -0.00985773f, 0.19983244f, -0.16107437f, 0.02913487f, 0.14311884f, 
    0.08600050f, -0.16441934f, 0.55982763f, -0.20182201f, -0.18542102f, -0.21305510f, -0.37497902f, -0.13666214f, 
    0.20394312f, -0.71720624f, -0.11748327f, 0.06958101f, -0.15706660f, 0.14310299f, 0.19157544f, 0.04583516f, 
    0.14191468f, 0.13928989f, 0.13785170f, -0.07352728f, -0.18389910f, 0.20584500f, 0.02711402f, -0.04031511f, 
    0.09654548f, -0.18324544f, -0.21833289f, 0.20811467f, -0.21368422f, -0.05489953f, 0.19419935f, 0.09903489f, 
    0.36437228f, -0.08879518f, -0.14690922f, -0.13398027f, 0.05446665f, 0.18705933f, -0.18064155f, -0.09026001f, 
    -0.34744421f, 0.20206930f, 0.09092931f, -0.15354323f, -0.10719607f, -0.11067058f, 0.48370633f, -0.35683954f, 
    0.01666439f, -0.16264988f, -0.49212542f, -0.13864568f, -0.04933840f, 0.25497186f, -0.02138912f, 0.05002240f, 
    -0.13172634f, -0.09851583f, -0.06743334f, 0.05504310f, -0.13187021f, 0.04516732f, 0.03242221f, 0.00120593f, 
    0.02584523f, -0.02464359f, -0.10671453f, 0.21265981f, -0.13702589f, -0.22306100f, -0.19434936f, -0.08761042f, 
    -0.00672944f, 0.15140559f, 0.13478830f, 0.09156773f, -0.18365213f, 0.03382714f, 0.03926340f, -0.25936285f, 
    -0.22972395f, 0.07761336f, -0.27255005f, -0.04703745f, -0.03603163f, -0.10749152f, -0.08243185f, -0.14773059f, 
    0.26296204f, 0.24328430f, -0.13931222f, -0.06776221f, 0.17148240f, 0.04291631f, -0.08596479f, -0.00350396f, 
    0.09488754f, 0.16020611f, -0.15662202f, 0.06202045f, -0.21010870f, 0.52046436f, -0.33256897f, 0.03139684f, 
    0.51099008f, 0.08936619f, 0.23683119f, -0.13123780f, -0.03930737f, -0.07026923f, 0.33938029f, 0.17589475f, 
    0.04476016f, -0.14568146f, -0.06415903f, -0.06155232f, -0.15429164f, -0.26263005f, -0.21285900f, 0.04468508f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.31891209f, 0.49573466f, -0.10938614f, -0.10458919f, 0.01651196f, 0.42175591f, -0.36915976f, 0.50747347f, 
    0.07406145f, -0.26092583f, -0.53622758f, 0.24903639f, 0.59828198f, -0.03422372f, 0.30237851f, -0.05147120f, 
    0.27104315f, -0.20789331f, 0.04177333f, 0.36626920f, 0.00563121f, 0.21942000f, -0.14134938f, -0.07387535f, 
    -0.06628291f, 0.14677159f, 0.03491620f, -0.07898651f, 0.06479015f, 0.05234981f, -0.12683627f, -0.13229121f, 
    0.47375923f, -0.00893450f, 0.07617848f, 0.54472995f, 0.23551716f, -0.26940817f, -0.24410611f, -0.19971941f, 
    0.11698179f, 0.08210264f, 0.15983385f, -0.02155093f, -0.14461465f, 0.43708795f, 0.44740266f, 0.40614083f, 
    0.16305815f, -0.01367417f, -0.12711629f, 0.06301305f, 0.36409074f, -0.35930964f, 0.42152539f, -0.08869333f, 
    -0.13661797f, 0.14262348f, 0.16506113f, 0.34787950f, 0.00049685f, -0.25163788f, -0.37207466f, 0.29120511f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.38960597f, 0.10133523f, -1.00111425f, 0.17122100f, 0.12944904f, -0.31896549f, 0.09744292f, 0.17435549f, 
    -0.00877577f, -0.06476699f, -0.68884981f, 0.04885943f, -0.17057313f, -0.00293692f, 0.09005140f, 0.27318758f, 
    0.31946418f, -0.15415913f, 0.26430646f, -0.72607267f, 0.28189468f, -0.12045221f, -0.15145262f, -0.67915487f, 
    -0.23316135f, 0.23944880f, -0.01804077f, 0.11213536f, 0.07764858f, 0.15209611f, 0.23924464f, -0.25870761f, 
    0.04812578f, -0.39683431f, 0.22001600f, 0.06597184f, -0.13122268f, -0.01906212f, 0.07686329f, 0.09109940f, 
    -1.40940309f, 0.26487160f, -1.19306314f, -0.11893222f, -0.70301372f, 0.09283793f, -0.11009433f, -0.46599692f, 
    0.41048756f, -0.02069764f, 0.07796653f, 0.07722610f, 0.38690728f, -0.10335972f, 0.15587181f, -0.02338010f, 
    0.57394123f, -0.38720861f, -0.02050905f, 0.15661851f, 0.04746150f, -0.02647547f, 0.05628662f, 0.13555396f, 
    -0.39084542f, 0.02427761f, 0.19730367f, -0.05019770f, -0.49227834f, 0.28798273f, 0.37120542f, 0.32640508f, 
    0.33253735f, -0.00663362f, 0.25002024f, -0.39516306f, -0.02195468f, -0.02110248f, -0.25541830f, 0.62201637f, 
    0.20074147f, -0.07285208f, 0.27936524f, -0.16378483f, 0.03935771f, -0.15338565f, -0.06757958f, -0.25250596f, 
    0.01612917f, 0.15162872f, 0.22961737f, 0.07234705f, 0.32626256f, 0.28044581f, 0.20510738f, 0.80274171f, 
    0.03488761f, -0.61915034f, -0.35832638f, -0.17343327f, 0.12712100f, 0.06252319f, -0.09739242f, -0.20825881f, 
    0.38328230f, 0.00171199f, 1.17078626f, -0.24950939f, 0.19592057f, -0.31822798f, -0.16338320f, -0.38271585f, 
    0.33778572f, 0.06596304f, -0.00610977f, -0.11258544f, 0.27102685f, -0.26400828f, -0.25075939f, -0.03269481f, 
    -0.17127953f, 0.28303269f, 0.08664268f, -0.06849845f, -0.02067718f, 0.01429198f, 0.42909357f, 0.15522152f, 
    -0.04922615f, 0.09357368f, 0.11338376f, 0.05479646f, 0.27058992f, -0.40396038f, -0.28764299f, 0.07444645f, 
    -0.83240634f, 0.14671488f, 0.16503188f, -0.18404037f, 0.78180051f, -0.04605066f, 0.15744458f, 0.43257457f, 
    -0.03886733f, 0.02979152f, -0.00723307f, 0.07368763f, 0.13427344f, 0.24042454f, -0.50863457f, -0.15960532f, 
    -0.21923605f, 0.20313077f, -0.31502497f, 0.02042798f, -0.30972204f, 0.03147214f, -0.35817447f, 0.63503593f, 
    0.05941726f, -0.54837912f, -0.00858326f, 0.10775410f, 0.18180355f, -0.06098838f, 0.12254341f, -0.03714011f, 
    -0.23648126f, -0.48846644f, 0.69375533f, 0.33178025f, -0.08859105f, 0.15231074f, -0.30995783f, 0.04943270f, 
    0.12598269f, 0.02105869f, -0.02077480f, -0.06009118f, 0.45278609f, -0.00164671f, 0.16163582f, -0.05699729f, 
    -0.01663573f, -0.50766701f, 0.03153731f, 0.10971992f, 0.00339132f, 0.14641625f, -0.12931177f, 0.21368276f, 
    -0.01845700f, 0.13780430f, 0.24994257f, 0.17880768f, 0.03844298f, 0.03081902f, -0.48576516f, 0.30710718f, 
    0.11471730f, 0.06372780f, -0.28899693f, 0.35145333f, -0.13814257f, -0.17367832f, 0.19977564f, -0.21224724f, 
    0.21344931f, -0.07770608f, -0.33885950f, -0.26006091f, 0.11957637f, 0.07024273f, 0.32241273f, -0.16640896f, 
    0.19445074f, 0.15523629f, 0.26195151f, 0.10450783f, -0.17539433f, -0.30505726f, -0.38712800f, 0.10741639f, 
    -0.11141372f, 0.79216546f, 0.11944903f, 0.31012043f, 0.10028502f, 0.09360179f, 0.05701055f, 0.02271568f, 
    -0.60871834f, 0.30299294f, 0.04184993f, 0.01290514f, -0.11074056f, 0.02250060f, 0.31825802f, 0.08793711f, 
    0.21048492f, 0.04955544f, -0.06342994f, 0.01604152f, 0.07948422f, -0.35657296f, 0.05166340f, -0.07304467f, 
    0.22125790f, -0.08750203f, -0.41560200f, 0.16551040f, -0.12584861f, -0.09341805f, -0.55561209f, -0.20537256f, 
    -0.03382261f, -0.07722909f, 0.08844945f, 0.08400775f, -0.13958655f, -0.02601770f, -0.15569116f, -0.04716827f, 
    -0.10495315f, 0.08632603f, -0.05553990f, -0.15775150f, -0.04508735f, -0.04119437f, 0.08881938f, -0.00721959f, 
    0.04249245f, 0.05873275f, -0.06744049f, -0.13250390f, -0.12872331f, 0.06437835f, -0.11030533f, 0.07297695f, 
    -0.11501867f, -0.03960989f, -0.07564397f, -0.01159292f, -0.00660274f, -0.14159735f, 0.06829048f, 0.08223617f, 
    0.01695156f, -0.05094270f, -0.00827035f, -0.11001189f, -0.02164953f, 0.08849519f, 0.01172020f, -0.02044183f, 
    -0.11381422f, -0.06751899f, -0.05778007f, 0.10228527f, 0.03447499f, 0.00914615f, 0.08086503f, -0.11560994f, 
    0.04126121f, 0.06328984f, 0.12010685f, 0.02138299f, -0.09326098f, 0.06135760f, 0.02574562f, 0.00692704f, 
    -0.12366071f, -0.09743049f, 0.06176025f, -0.15017253f, 0.01990606f, -0.02109671f, 0.02851328f, -0.04231009f, 
    0.68387699f, -0.37350422f, -0.24568206f, -0.16226430f, -0.08711249f, -0.06443685f, 0.28327501f, -0.18676324f, 
    0.01298763f, 0.06591643f, -0.17782748f, -0.48128003f, 0.13279900f, 0.12503968f, -0.28040618f, 0.07152703f, 
    0.22457503f, 0.16273959f, 0.35656592f, 0.23056315f, 0.12864010f, -0.20118430f, -0.03660236f, 0.32762855f, 
    0.07049248f, 0.02343047f, -0.22267552f, 0.11596768f, 0.35883898f, 0.29043430f, 0.09785348f, 0.36812133f, 
    -0.05567716f, 0.98915488f, 0.11028228f, -0.15956596f, 0.16357356f, -0.05805429f, 0.10084125f, 0.07802977f, 
    0.31343457f, 0.39146054f, 0.03428325f, -0.42222777f, 0.27658904f, -0.06291794f, -0.51809818f, 0.02621287f, 
    -0.03640331f, -0.04352835f, 0.04321751f, 0.25393537f, 0.12926896f, 0.48131606f, -0.20419802f, -0.01293418f, 
    0.10153723f, 0.18446805f, 0.39602759f, -0.05579003f, -0.05446178f, -0.03837353f, -0.39353448f, 0.20186248f, 
    -0.23292482f, 0.12929337f, 0.12220974f, -0.00771760f, -0.37950364f, 0.61428607f, 0.31233975f, 0.11866541f, 
    0.05109412f, 0.11091851f, 0.80250955f, 0.00196336f, 0.03957991f, -0.04864479f, -0.23352996f, 0.04351193f, 
    0.14494425f, 0.07021966f, -0.17845786f, 0.21905363f, -0.29546440f, 0.05784265f, -0.29827785f, -0.06162520f, 
    0.09326813f, 0.34137145f, 0.13897699f, 0.00887912f, 0.33074141f, 0.31861958f, 0.29540998f, 0.45424375f, 
    0.25793716f, 0.23043722f, -0.24967138f, -0.26984233f, 0.03278719f, 0.12856843f, -0.07873735f, -0.43487573f, 
    0.61428547f, -0.23871878f, 0.53584462f, -0.29719219f, 0.18333142f, 0.00409785f, 0.03202886f, -0.03256179f, 
    0.29579571f, -0.14143109f, 0.05510552f, -0.10408298f, -0.00422788f, -0.07317205f, 0.25482094f, -0.07941296f, 
    0.07151446f, 0.24527374f, 0.26348853f, 0.44201344f, 0.00370641f, 0.03845702f, 0.42333603f, 0.28315026f, 
    -0.45156989f, -0.03912161f, 0.46916953f, 0.09088916f, -0.02113842f, 0.13639438f, 0.02943829f, -0.18693545f, 
    0.12422854f, -0.09527238f, -0.35729212f, 0.24792327f, 0.02924821f, 0.03175733f, 0.25628996f, -0.43473968f, 
    -0.44972864f, 0.08474611f, -0.11796461f, 0.14084569f, -0.18605459f, 0.05956515f, 0.30156094f, -0.74179816f, 
    0.04827072f, -0.59999442f, 0.24824090f, 0.20964111f, 0.01794408f, 0.11952529f, 0.04325230f, -0.51103002f, 
    0.19115326f, 0.43540901f, 0.09899144f, 0.10975450f, 0.18125694f, 0.00136202f, 0.05377665f, 0.16793738f, 
    -0.14510253f, 0.03633494f, -0.22721083f, 0.33819383f, 0.05986770f, 0.18481338f, 0.48073792f, 0.07225627f, 
    -0.61375499f, -0.08301824f, 0.03008910f, 0.45951992f, -0.83011746f, 0.07823370f, 0.13505745f, -0.10699937f, 
    0.25570643f, 0.00891785f, -0.02256491f, -0.28549287f, -0.08373559f, -0.04653145f, 0.03870711f, 0.14023751f, 
    -0.08761659f, 0.00967549f, -0.03904314f, 0.04674147f, -0.13665152f, -0.03366011f, -0.01125808f, -0.04125985f, 
    -0.05770944f, -0.04916707f, 0.11759695f, -0.10734173f, -0.03954202f, -0.09048080f, 0.10027203f, 0.03030505f, 
    0.04444926f, 0.02329400f, -0.07408907f, 0.00953884f, -0.12248263f, -0.05529132f, -0.07878765f, 0.05729327f, 
    -0.05092608f, 0.10938783f, 0.03049835f, -0.05737911f, -0.00261504f, -0.00342921f, -0.08227548f, 0.05547935f, 
    0.02304805f, 0.11492056f, -0.11170463f, -0.09443279f, 0.00243911f, -0.10601297f, 0.08465387f, 0.00915459f, 
    0.04363385f, 0.00604030f, -0.06615414f, 0.00247023f, 0.04304249f, -0.09797759f, -0.05867005f, -0.02623651f, 
    -0.00626186f, 0.05689913f, 0.11895590f, -0.09476094f, -0.07262417f, -0.01054074f, 0.07391793f, -0.03340444f, 
    -0.07539783f, -0.13277146f, 0.04530368f, -0.07917350f, 0.05873296f, -0.10791382f, -0.00539117f, 0.01290464f, 
    0.34058034f, -0.07180148f, 0.13466850f, 0.08658466f, 0.09761231f, -0.51905721f, 0.20607871f, 0.09001771f, 
    -0.05995647f, -0.00114605f, 0.16163917f, 0.14351058f, -0.42361632f, 0.06421618f, -0.07256947f, 0.12614232f, 
    0.27930614f, -0.01210786f, -0.05247514f, -0.16466969f, 0.19551966f, 0.06542895f, -0.00138461f, -0.08030894f, 
    0.16637892f, 0.46462616f, 0.19814131f, -0.08976343f, 0.13142900f, -0.55150831f, -0.46179447f, -0.11273491f, 
    -0.46603814f, 0.26343602f, 0.04351813f, -0.07961384f, -0.13322186f, -0.07257141f, 0.09014566f, 0.12514743f, 
    0.10235754f, 0.18468620f, -0.52024770f, -0.17206752f, 0.12580052f, -0.02075107f, -0.13647990f, 0.08116224f, 
    0.14679709f, 0.05758502f, 0.02718104f, -0.34479013f, 0.30910060f, 0.06017011f, -0.04143995f, 0.00484993f, 
    -0.22238997f, -0.25128794f, -0.38770592f, 0.02970498f, -0.08661467f, 0.08611323f, 0.19530825f, -0.44422638f, 
    0.52046341f, 0.15380318f, -0.73746139f, 0.04905888f, 0.01188331f, 0.19009475f, -0.37862623f, 0.10462022f, 
    0.03498807f, -0.17926966f, -0.40800515f, 0.51035792f, 0.02449731f, 0.01862720f, 0.12380591f, -0.27098227f, 
    -0.04223264f, -0.10983726f, -0.01420114f, -0.17679176f, -0.06849045f, -0.14544038f, -0.07771501f, 0.36310986f, 
    -0.27914110f, -0.23245235f, -0.11746067f, -0.14053571f, -0.17495202f, 0.03507359f, 0.17518538f, 0.23787896f, 
    0.11976839f, 0.01521498f, 0.22695488f, 0.15927632f, -0.09672898f, 0.04422704f, -0.07700421f, -0.03194343f, 
    0.27035224f, 0.02910275f, 0.02123341f, -0.06578680f, 0.14300548f, 0.06071081f, 0.08865208f, 0.04571206f, 
    0.32039341f, 0.07010605f, 0.07083407f, -0.01401590f, -0.06274459f, 0.11968306f, 0.25953415f, 0.01163296f, 
    0.13106947f, -0.21322882f, -0.01268957f, -0.07696638f, 0.07102156f, 0.04381326f, -0.45389128f, 0.08783326f, 
    0.07221082f, -0.12594818f, -0.04560176f, -0.01031646f, -0.12950224f, -0.10770876f, -0.06935767f, -0.07182080f, 
    0.07182267f, 0.11393233f, 0.03949164f, -0.04251235f, 0.03480760f, -0.14127047f, 0.04287791f, -0.11965290f, 
    0.03577428f, -0.05900690f, -0.15116870f, 0.04886727f, 0.02132054f, 0.08253324f, 0.07158732f, -0.01298830f, 
    -0.02823915f, -0.02358049f, -0.16036712f, -0.04837486f, -0.12232078f, -0.01774698f, 0.02697470f, 0.04333235f, 
    -0.15082344f, -0.07649903f, -0.15307191f, 0.04170486f, 0.03440341f, 0.10609615f, -0.09804432f, -0.15208896f, 
    -0.12193362f, -0.15216921f, -0.03107251f, -0.12050812f, 0.01860896f, -0.14198369f, -0.02967397f, -0.07028932f, 
    0.06709259f, 0.08453433f, -0.04604524f, -0.01396018f, -0.04783141f, -0.03304325f, -0.03717739f, 0.02188246f, 
    -0.01009017f, -0.04403131f, -0.14139573f, 0.11515873f, 0.06715105f, 0.04112424f, 0.11790761f, 0.03263468f, 
    -0.02092592f, -0.07242085f, -0.04523423f, 0.06583270f, -0.00095615f, 0.01029347f, 0.00187498f, -0.04831292f, 
    0.05863020f, 0.10079294f, -0.06723961f, -0.01849926f, -0.06617251f, -0.06376523f, 0.01964600f, -0.10526565f, 
    -0.00745592f, -0.09019946f, -0.11071372f, -0.06048204f, -0.10432479f, -0.00927109f, -0.08350556f, -0.07267860f, 
    -0.01317543f, -0.07160155f, 0.04327738f, -0.06597215f, -0.01418646f, -0.07284659f, -0.00983007f, -0.06537148f, 
    -0.08371131f, -0.06604418f, -0.10177185f, 0.11413082f, -0.08894603f, -0.08987777f, 0.00353810f, 0.00221966f, 
    -0.08759454f, -0.01593280f, -0.11944157f, 0.10057017f, -0.05644098f, -0.11442164f, -0.01385839f, -0.01329665f, 
    -0.02510904f, 0.07894729f, -0.12354203f, 0.04761688f, 0.09364764f, -0.10799427f, -0.02364962f, -0.07755251f, 
    0.00362705f, -0.06268337f, -0.07603075f, 0.06236641f, -0.12195869f, -0.02228178f, -0.08447486f, -0.01602457f, 
    0.11787745f, -0.04385604f, 0.02655077f, 0.04444460f, 0.00181158f, 0.04763587f, 0.02936361f, -0.14774315f, 
    -0.07252548f, -0.02957371f, -0.04172864f, -0.07524149f, -0.05121652f, -0.07687640f, 0.04552095f, 0.02831042f, 
    -0.05380886f, -0.03166970f, 0.02848913f, 0.07107234f, -0.01027040f, -0.19367427f, 0.08329263f, -0.07240693f, 
    -0.08730946f, 0.02586588f, 0.04612262f, -0.16610457f, -0.16201986f, -0.15112068f, -0.10095404f, -0.11982369f, 
    -0.01713800f, 0.07005996f, -0.05913709f, -0.12235590f, -0.04273579f, -0.08911261f, 0.11609873f, -0.11526483f, 
    -0.03599928f, -0.05202558f, -0.12475787f, -0.00925632f, -0.03289794f, -0.05993218f, 0.04911383f, -0.10421752f, 
    0.04081511f, -0.01124392f, -0.12416221f, -0.00867161f, -0.06836127f, -0.05551453f, 0.03943656f, 0.00775404f, 
    0.08468863f, -0.05130270f, -0.10770242f, 0.06211668f, 0.06097721f, 0.08722050f, -0.04434933f, 0.08528573f, 
    -0.05495968f, -0.11813612f, -0.06968985f, -0.16099329f, 0.03509936f, -0.11018134f, -0.00162288f, -0.10555560f, 
    -0.03458801f, -0.12368216f, -0.04254209f, -0.02376786f, -0.06958753f, -0.11630387f, 0.07670598f, 0.06543214f, 
    -0.02019603f, -0.11207239f, -0.11678325f, -0.14309920f, -0.01833808f, -0.03576718f, 0.07873517f, -0.07268667f, 
    0.01215048f, 0.01843961f, -0.04639152f, 0.00691237f, 0.10032860f, 0.04672993f, -0.01420589f, 0.07569703f, 
    -0.02030427f, 0.02135457f, -0.04235209f, -0.13475525f, -0.06185522f, -0.02219649f, 0.03815605f, -0.13737665f, 
    -0.09731591f, 0.05720781f, 0.05054381f, -0.02248891f, -0.10910840f, -0.03169618f, -0.12802669f, -0.02632977f, 
    -0.10504223f, 0.11531417f, 0.08495227f, 0.05805996f, -0.09537794f, 0.03322221f, -0.04783897f, -0.10239358f, 
    0.01741731f, -0.13381249f, 0.11015088f, 0.08823203f, -0.01361337f, 0.00136232f, 0.09583460f, -0.07124387f, 
    -0.29527363f, 0.14729327f, -0.42221901f, -0.26452869f, 0.09280600f, 0.46730644f, -0.24828373f, 0.26659057f, 
    0.12794067f, 0.01219694f, 0.18191084f, -0.07478855f, 0.41965386f, -0.05780243f, 0.06228954f, 0.43659812f, 
    -0.11093365f, -0.09506443f, 0.26969725f, -0.03212604f, -0.13359904f, 0.01935818f, -0.27574793f, 0.04253874f, 
    -0.16955534f, 0.13710122f, -0.06837710f, -0.05995335f, 0.10512889f, 0.08253539f, 0.11566711f, -0.68664396f, 
    0.26261458f, -0.73443609f, -0.24580756f, 0.22074285f, 0.00327106f, 0.04632251f, -0.10166031f, 0.17557666f, 
    -0.06310548f, -0.23806348f, -0.42878589f, 0.33812973f, -0.04966998f, -0.02696995f, 0.07496487f, 0.42715347f, 
    -0.37434554f, 0.07066625f, -0.02877648f, -0.07180937f, 0.31164759f, -0.12543616f, 0.05526314f, -0.07608567f, 
    -0.46016631f, 0.10967085f, 0.09939976f, 0.24431527f, 0.05042205f, 0.14447431f, -0.09895792f, 0.25085396f, 
    0.14016311f, 0.01386629f, 0.48772693f, 0.23060600f, -0.10435641f, 0.18881853f, 0.04274706f, -0.12405644f, 
    -0.03192934f, 0.13466066f, 0.12907277f, 0.09283026f, 0.34981966f, 0.08869069f, -0.04129885f, 0.24981736f, 
    -0.17251180f, 0.29735941f, -0.17827335f, 0.47984755f, -0.01938859f, 0.13421367f, -0.00202342f, 0.65274090f, 
    0.38137260f, 0.29380623f, 0.23769589f, 0.15075800f, 0.14230716f, -0.01981315f, -0.09555512f, 1.06767297f, 
    0.15250961f, -0.28322926f, -0.22743911f, 0.02164171f, 0.05940925f, -0.00835896f, 0.00045927f, 0.05670808f, 
    0.18130490f, 0.04318182f, 0.43625090f, 0.14288449f, 0.18572444f, -0.03011835f, -0.02806680f, -0.16736509f, 
    -0.17429703f, -0.13622163f, 0.05122806f, -0.06687181f, 0.23988126f, -0.01011069f, -0.20171760f, 0.01709579f, 
    -0.12766349f, 0.12781672f, 0.07179527f, -0.32024544f, 0.09589095f, 0.04114793f, -0.26750314f, 0.21739489f, 
    0.06743307f, -0.30709678f, 0.41386595f, -0.13387127f, -0.32255346f, 0.07553149f, 0.22005692f, 0.02371711f, 
    0.17397885f, -0.10510459f, 0.46676645f, -0.23176469f, 0.13781692f, 0.00817258f, -0.13160606f, -0.20191319f, 
    -0.07604153f, 0.09537639f, 0.19726709f, 0.27875981f, 0.10317192f, -0.18602949f, 0.18076649f, -0.23840100f, 
    0.16100477f, -0.24933876f, -0.23104149f, 0.23771547f, 0.17985840f, 0.20867141f, -0.08978809f, 0.73500681f, 
    -0.02377457f, 0.31138992f, -0.17122269f, -0.10049502f, -0.00038478f, 0.12478818f, -0.06967691f, 0.25054890f, 
    0.22511865f, -0.21068725f, 0.93760544f, 0.17560731f, 0.25968403f, -0.05212926f, -0.16420184f, -0.37964714f, 
    0.07732935f, 0.11336818f, 0.11275403f, 0.45867056f, -0.17022596f, 0.25247130f, -0.21090062f, -0.06608142f, 
    0.37500623f, 0.18738042f, 0.27058971f, -0.33495888f, -0.05576144f, -0.09957889f, 0.13567062f, 0.16049449f, 
    -0.09815369f, -0.13219050f, 0.10641444f, -0.14754130f, -0.10395350f, -0.00317642f, 0.05050074f, 0.12488878f, 
    0.00457226f, -0.08781032f, 0.04001701f, -0.01826702f, -0.08585560f, -0.11699075f, 0.10089728f, -0.03835674f, 
    -0.14397275f, -0.02513943f, -0.06237705f, 0.07764530f, -0.00575725f, -0.13645163f, -0.06999828f, 0.03043865f, 
    0.00242384f, 0.07523528f, -0.08357657f, -0.13151333f, 0.04380568f, -0.14709426f, -0.03803561f, 0.03405534f, 
    -0.09016933f, -0.02044445f, 0.09722976f, 0.06546846f, -0.12379823f, 0.00876448f, -0.07631510f, -0.14820644f, 
    -0.13832289f, -0.01819779f, 0.07246417f, -0.06600672f, 0.01865979f, 0.04777317f, 0.13914128f, 0.05909687f, 
    0.05306269f, 0.10674003f, -0.02484000f, -0.13594250f, -0.08354463f, 0.05978243f, 0.00856558f, 0.02919663f, 
    -0.08799215f, -0.03630631f, 0.04007544f, 0.02308802f, -0.11986722f, 0.11749847f, -0.11853407f, 0.08541791f, 
    -0.03730193f, -0.09153566f, 0.03582782f, 0.08683510f, 0.10444577f, 0.05847170f, 0.09501418f, -0.06437610f, 
    -0.05476035f, -0.09938917f, 0.03398257f, 0.09315345f, -0.11251236f, -0.12657030f, -0.01320620f, 0.06077273f, 
    -0.02829810f, -0.01745283f, -0.00304055f, -0.08211333f, -0.09557421f, -0.07451612f, -0.06221187f, 0.00874166f, 
    0.01790426f, 0.04784355f, -0.07995753f, -0.00843884f, 0.02317797f, 0.00797951f, -0.02894481f, -0.04853034f, 
    -0.05066132f, 0.11651355f, 0.00092053f, -0.03866039f, -0.14195058f, 0.07599226f, -0.05709891f, -0.09117146f, 
    0.01220518f, 0.02041232f, -0.05408858f, 0.06752173f, 0.03212125f, 0.01323517f, -0.10304070f, 0.04813519f, 
    -0.01590823f, -0.06047536f, -0.00835079f, -0.08251557f, -0.06095251f, -0.08457664f, 0.08436431f, -0.04397702f, 
    -0.07659554f, -0.00202761f, 0.06398497f, -0.08432537f, -0.03853600f, -0.07696596f, -0.03871181f, -0.02041140f, 
    0.60990590f, -0.42061612f, 0.03376387f, -0.17354816f, -0.25298673f, 0.00089394f, 0.26372492f, 0.02846340f, 
    0.02384515f, 0.10297649f, 0.03107645f, -0.36922488f, -0.01973559f, 0.06032069f, -0.24737217f, 0.17152312f, 
    0.17936648f, -0.12741679f, 0.40098485f, -0.13030615f, 0.20268707f, -0.23102657f, 0.10190389f, 0.47817174f, 
    0.22539286f, -0.25909257f, -0.02635041f, 0.12408108f, 0.15941250f, 0.07681377f, 0.17859152f, 0.20536664f, 
    -0.35681307f, 0.24542141f, -0.04100155f, -0.27832085f, -0.06841357f, -0.03627112f, 0.03321452f, 0.11507604f, 
    0.60248476f, 0.24451981f, 0.23935913f, -0.28389356f, -0.01990195f, -0.11858507f, -0.38404712f, -0.24335130f, 
    0.26518729f, 0.10454845f, 0.10607462f, 0.36452317f, 0.21406499f, 0.50965399f, -0.07661397f, -0.06251539f, 
    0.39948326f, 0.28283119f, 0.33473650f, -0.08734278f, -0.00625652f, -0.12584837f, 0.30278569f, 0.04089328f, 
    -0.39984250f, -0.21472670f, -0.09467459f, 0.01228356f, 0.08921189f, -0.31464061f, 0.16417550f, 0.07088191f, 
    0.21988092f, -0.04393002f, -0.12519698f, 0.05003585f, -0.84410918f, -0.08948503f, -0.13908519f, -0.30682591f, 
    0.09264445f, 0.28855419f, 0.02110203f, 0.12831876f, 0.01580799f, -0.06816156f, 0.05316751f, 0.03046597f, 
    0.16543148f, -0.23842517f, 0.21561584f, 0.13902715f, 0.07324074f, -0.05562691f, 0.14434658f, -0.19617845f, 
    -0.24473551f, -0.29081473f, 0.19792330f, -0.03761511f, -0.17966068f, 0.05544847f, 0.05232817f, -0.01290912f, 
    -0.31207269f, 0.23529960f, 0.11369032f, -0.09578025f, -0.22049969f, -0.39932147f, 0.01630414f, 0.05496315f, 
    0.10955324f, 0.04152870f, -0.06031168f, 0.22469661f, -0.17600423f, -0.71975446f, 0.28288135f, -0.02357498f, 
    -0.78936428f, 0.01154580f, 0.08546695f, -0.17456335f, 0.03905334f, 0.06040214f, 0.24413289f, -0.46898177f, 
    0.02065866f, -0.00531496f, 0.10989967f, -0.02901745f, -0.00021601f, 0.00002408f, 0.01218156f, -0.12195674f, 
    0.01363139f, 0.05474660f, 0.10752536f, 0.11116363f, 0.09413466f, -0.10848203f, -0.11728840f, -0.05557958f, 
    0.07079919f, -0.10444416f, -0.02612914f, -0.02554780f, 0.06734753f, 0.07226124f, -0.09552917f, -0.11347474f, 
    -0.11102789f, -0.00230136f, -0.01501723f, 0.04469488f, -0.06415170f, -0.12119896f, -0.12623389f, 0.03539865f, 
    -0.03033103f, -0.04400199f, -0.07233728f, 0.00549426f, -0.01818948f, -0.10622384f, 0.06221239f, 0.05060168f, 
    -0.06433539f, -0.09760983f, 0.02749164f, 0.00027931f, 0.06235798f, 0.07963008f, -0.13534161f, -0.03824119f, 
    0.03719345f, -0.07195067f, -0.10195065f, -0.10074791f, -0.13244474f, 0.11444342f, 0.07660580f, -0.01894973f, 
    0.02410957f, -0.12821029f, -0.10166155f, -0.11817990f, 0.02337059f, 0.11037344f, 0.09514128f, -0.03050463f, 
    0.05801329f, 0.24377003f, -0.30368608f, -0.07926702f, 0.40380433f, 0.24039075f, -0.35660359f, 0.20109466f, 
    -0.00463364f, 0.09843463f, -0.41148505f, 0.29356995f, -0.03925554f, 0.15986718f, 0.07201076f, -0.25646973f, 
    -0.19931416f, 0.10057510f, 0.20875788f, -0.00730454f, 0.07735465f, 0.20017003f, 0.09201392f, -0.00186567f, 
    -0.03948089f, -0.15459980f, -0.02583273f, -0.09908346f, -0.17947048f, -0.16400032f, 0.15878570f, -0.73989195f, 
    0.16957870f, -0.19518425f, 0.32300234f, 0.26957351f, 0.04469892f, -0.06931754f, -0.12119564f, 0.26970631f, 
    -0.11357034f, -0.06551874f, -0.59395564f, 0.00501739f, 0.10211107f, 0.20382211f, 0.08658536f, 0.55280167f, 
    -0.11532581f, -0.03161131f, -0.00298715f, 0.17473178f, -0.10044564f, -0.25497505f, 0.40387639f, -0.05671334f, 
    -0.37592098f, -0.16604830f, -0.19640647f, 0.05141017f, 0.01565188f, 0.04551667f, -0.54068995f, -0.12269165f, 
    0.46978286f, -0.08765035f, 0.06358167f, -0.09054333f, -0.05008263f, -0.17607075f, 0.34845263f, 0.07587753f, 
    0.11069572f, -0.03796970f, 0.48191884f, -0.78672063f, 0.23179552f, -0.14582925f, 0.14216110f, 0.17972542f, 
    0.36135077f, -0.11445175f, 0.15024957f, 0.02696073f, 0.11903410f, 0.08639712f, 0.28811440f, 0.17435351f, 
    0.38891691f, -0.02573415f, -0.01526628f, 0.22361295f, 0.11342753f, 0.05414679f, 0.12692118f, 0.57813400f, 
    -0.19928700f, 0.33117780f, -0.00880502f, 0.08606210f, 0.10746331f, -0.02534764f, 0.02150570f, -0.02428763f, 
    -0.52297229f, 0.18294655f, 0.48155239f, 0.32358307f, -0.28500149f, -0.23266327f, -0.08910662f, -0.39511618f, 
    0.10401750f, -0.11749119f, -0.03202710f, 0.66942698f, 0.20150423f, 0.29050326f, 0.03528101f, -0.05930362f, 
    0.22822718f, 0.15433605f, 0.22600242f, 0.71078658f, 0.03235798f, -0.05962971f, 0.18852866f, -0.22630429f, 
    -0.34143555f, 0.06315735f, 0.45900896f, 0.22058736f, -0.16754968f, 0.03088923f, 0.42368579f, 0.04582324f, 
    0.27603695f, 0.01553466f, -0.30624932f, -0.03648380f, -0.32570064f, -0.00333684f, -0.05883140f, 0.18928108f, 
    0.22351328f, 0.30419284f, -0.26914260f, 0.32031488f, -0.08625785f, 0.22795014f, 0.20329744f, -0.06563861f, 
    0.35955763f, 0.31641880f, 0.41130736f, 0.11282521f, 0.27946267f, -0.13507937f, -0.28544575f, -0.37588483f, 
    0.09192328f, -0.12086546f, -0.08901881f, -0.06564251f, 0.04096919f, 0.01173828f, 0.07559039f, -0.30517653f, 
    0.68671697f, 0.30835962f, -0.16916351f, -0.04350948f, 0.14544560f, -0.10504432f, 0.25831074f, 0.04137283f, 
    -0.16141450f, -0.08595198f, -0.11757676f, -0.33594584f, 0.21118231f, -0.08142431f, -0.27110621f, -0.13420242f, 
    0.03039925f, 0.23836046f, -0.04583195f, -0.09294037f, -0.07264353f, -0.07323203f, 0.17702332f, 0.06838827f, 
    0.12143609f, -0.03426456f, 0.25312153f, -0.06878935f, -0.41735715f, -0.10409636f, 0.01805010f, 0.48087192f, 
    0.27791616f, 0.04532618f, -0.03053852f, -0.29365706f, -0.16036917f, -0.56826347f, 0.06619117f, -0.01450190f, 
    0.56111890f, -0.07050607f, -0.26217091f, -0.09332458f, 0.22976555f, 0.15637289f, 0.35186851f, 0.32490441f, 
    -0.02433371f, 0.08550694f, 0.31482214f, 0.08918173f, 0.06522679f, -0.35191396f, -0.33683732f, 0.30280265f, 
    -0.18758734f, 0.02379523f, -0.28320286f, 0.24362586f, 0.03106669f, -0.11515340f, 0.01320559f, -0.63177979f, 
    -1.25947642f, 0.63696933f, 0.17578989f, 0.18868825f, -0.40253341f, -0.26744744f, 0.17873771f, -0.47343650f, 
    0.26126856f, 0.02148734f, -0.11757585f, 0.04158363f, 0.37066534f, -0.75665247f, 0.31099832f, 0.05951227f, 
    -0.42959085f, -0.07159619f, -0.22801292f, 0.37978119f, 0.01455728f, 0.11740957f, 0.05418606f, -0.59758419f, 
    0.54598022f, -0.12972173f, -0.02657001f, -0.18316959f, 0.21053307f, -0.21463610f, 0.15843534f, 0.09702183f, 
    0.09025666f, -0.02190054f, 0.03361818f, 0.03246719f, -0.01251015f, 0.02636927f, 0.23180521f, -0.31022766f, 
    0.05088323f, 0.06304272f, 0.25793168f, -0.12499004f, 0.27775359f, 0.03639356f, 0.51501012f, 0.23111023f, 
    -0.01844817f, -0.44435459f, -0.06820849f, 0.06489445f, -0.14552577f, -0.01003614f, 0.07766724f, 0.09593572f, 
    -0.09773233f, 0.50317717f, 0.48217508f, 0.04222128f, 0.02517836f, -0.08917966f, -0.04727568f, 0.40058646f, 
    0.06897534f, 0.28527519f, 0.02692545f, 0.00514604f, 0.22431111f, -0.02709982f, 0.07740258f, 0.27272877f, 
    0.26605436f, -0.11715201f, 0.04532580f, 0.42789087f, -0.27501434f, 0.59253806f, 0.43120787f, 0.11573994f, 
    0.17664725f, -0.09068443f, 0.14098643f, 0.11913538f, -0.02097824f, 0.07019784f, -0.07590427f, -0.30035624f, 
    0.06693290f, -0.13114341f, -0.16530526f, 0.01099545f, -0.06392514f, -0.02338661f, -0.07444487f, -0.03750414f, 
    -0.09077925f, 0.00853676f, -0.04631232f, -0.01560973f, -0.00044667f, 0.04074474f, -0.15225270f, 0.00636443f, 
    -0.08703639f, -0.08645697f, -0.08920262f, -0.00105776f, -0.05200573f, 0.05587123f, 0.06158575f, 0.01849805f, 
    -0.09014384f, -0.03752460f, 0.06152654f, 0.03366461f, -0.10219093f, -0.00770731f, 0.08649950f, -0.09513976f, 
    -0.15292218f, 0.01984254f, 0.02797751f, -0.12679525f, -0.05006474f, -0.10147582f, 0.08392034f, -0.00368893f, 
    -0.00269771f, 0.00755056f, -0.11599968f, -0.05333159f, 0.08079292f, 0.04479535f, -0.09788438f, -0.00374022f, 
    -0.11436798f, 0.04119344f, 0.10873632f, -0.13443241f, -0.15462355f, 0.10564413f, -0.03360893f, 0.09274293f, 
    -0.04703485f, -0.09209169f, -0.08313245f, 0.09618422f, -0.08588308f, 0.00218862f, 0.10507140f, -0.01072146f, 
    -0.13267015f, 0.06128627f, -0.27237418f, 0.01383221f, 0.06166115f, -0.07284517f, 0.10278431f, 0.12601186f, 
    0.13969311f, -0.04082351f, 0.25487432f, -0.28697640f, -0.06625389f, -0.07148249f, 0.25218609f, 0.00812314f, 
    0.13720883f, -0.03056908f, 0.09782954f, -0.11974066f, 0.14723350f, -0.07900368f, 0.23238803f, -0.08325663f, 
    0.25151181f, 0.07619506f, 0.13557152f, 0.23397575f, 0.17389844f, 0.12185376f, 0.06463099f, -0.49446121f, 
    -0.05185122f, 0.24919920f, -0.02452534f, 0.21279724f, -0.02616804f, 0.02894931f, -0.07051520f, 0.17255269f, 
    0.29138553f, 0.30049911f, -0.44248208f, 0.24978571f, -0.10959879f, 0.03769808f, 0.08696789f, 0.01789081f, 
    -0.27143934f, -0.01740500f, -0.01895085f, 0.18363960f, -0.07320321f, 0.21737437f, -0.45673743f, 0.07257266f, 
    -0.02823737f, 0.12276912f, 0.00692771f, -0.00302761f, 0.08893327f, 0.09138204f, 0.30303863f, 0.00018433f, 
    0.24055529f, -0.08236130f, -0.83895236f, -0.34417230f, -0.00842194f, 0.21605510f, -0.07901668f, 0.37155399f, 
    0.24153370f, 0.11760439f, -0.26385561f, 0.03599704f, -0.07691705f, 0.11942818f, 0.01015127f, 0.20639895f, 
    0.06823700f, -0.19209796f, 0.32634142f, -0.15477742f, -0.02449810f, -0.06960126f, -0.08039433f, 0.30455479f, 
    -0.04064812f, -0.11035038f, -0.04768708f, -0.02405766f, 0.03279556f, 0.16012903f, 0.23841430f, -0.47441682f, 
    0.01890154f, 0.03619126f, 0.07813256f, 0.15984605f, -0.06128789f, 0.01957125f, -0.10074914f, 0.19753402f, 
    0.46547619f, 0.05638980f, -0.42743638f, -0.00394398f, -0.01320069f, -0.03999721f, 0.10136610f, 0.55338061f, 
    -0.13689005f, -0.07332744f, 0.00645578f, 0.12983832f, 0.21529497f, 0.29344639f, 0.25632879f, -0.02314504f, 
    -0.32044014f, 0.12235741f, 0.09595743f, 0.19540332f, -0.04435446f, -0.03049444f, 0.21146357f, -0.16369571f, 
    0.36387697f, -0.28319991f, -0.00332337f, -0.42691153f, -0.20628108f, 0.37172160f, 0.28699616f, 0.18115059f, 
    0.20792033f, -0.07002792f, 0.14688697f, -0.14841434f, 0.00076190f, 0.03238216f, -0.31600857f, 0.12970145f, 
    0.18928011f, -0.10662831f, 0.32127479f, 0.18218675f, -0.04301501f, -0.05590758f, -0.01580619f, 0.27976048f, 
    0.00483761f, -0.29488534f, 0.02488271f, -0.06145288f, 0.07682932f, 0.22954756f, 0.30914411f, 0.01209744f, 
    0.00106201f, 0.40517437f, -0.18352433f, -0.26326665f, -0.08889873f, -0.12968335f, -0.03189187f, -0.18365945f, 
    0.78595650f, -0.00867765f, 0.28764996f, -0.48252615f, 0.33239675f, -0.06781495f, -0.14942046f, 0.20616899f, 
    -0.04034360f, -0.09445625f, -0.03512041f, 0.20969902f, -0.17328405f, -0.09659667f, 0.30460295f, 0.07281337f, 
    0.15382385f, 0.04562495f, 0.32703137f, 0.41980341f, -0.09494966f, -0.02812310f, 0.27522320f, -0.10284184f, 
    0.04562490f, -0.12321693f, -0.08265509f, -0.13400374f, -0.09464242f, 0.09878648f, -0.09417499f, -0.13833150f, 
    -0.03208007f, -0.09262305f, 0.04263306f, -0.03776061f, -0.03544205f, 0.02164257f, 0.08689333f, -0.08124753f, 
    -0.01330588f, -0.14330241f, -0.10866358f, -0.13362990f, -0.06876426f, 0.02020456f, 0.09656558f, 0.02798979f, 
    -0.05724042f, 0.14302427f, -0.00422147f, 0.08435195f, -0.09510868f, -0.02301187f, 0.10288920f, 0.07666981f, 
    -0.00694271f, 0.08852626f, 0.09767955f, 0.00400048f, -0.12831774f, 0.09265986f, -0.10214704f, -0.09034546f, 
    0.06198917f, -0.00388123f, 0.08101763f, 0.01657488f, -0.05578851f, 0.07283749f, -0.11194610f, -0.02984248f, 
    -0.12863028f, -0.02610542f, 0.04946055f, 0.06634934f, 0.05384693f, 0.01042806f, -0.08310787f, 0.06046130f, 
    0.10559250f, 0.03568533f, 0.06730910f, -0.02962312f, 0.01717667f, -0.01756474f, 0.07520146f, -0.09845410f, 
    0.27421641f, -0.05536672f, -0.24070619f, 0.10600127f, -0.06176559f, 0.23647201f, 0.12545714f, 0.16605824f, 
    0.13867766f, -0.06402155f, 0.56850886f, -0.02624610f, 0.10379731f, -0.00337500f, 0.18218181f, -0.19218145f, 
    -0.10693587f, -0.18648045f, 0.10383417f, -0.35194477f, -0.03844304f, -0.20973483f, 0.03750615f, -0.04920005f, 
    -0.13159841f, -0.07462449f, -0.10437410f, 0.21820766f, 0.08543877f, 0.24470793f, 0.28640667f, 0.20106833f, 
    0.12011798f, 0.40287620f, -0.19397324f, -0.00674874f, 0.04838237f, 0.00629253f, -0.11388607f, 0.03423754f, 
    0.40612364f, -0.12482595f, 0.51101810f, 0.03132880f, 0.07895944f, 0.09776113f, -0.07605748f, -0.50837892f, 
    0.46065661f, 0.06801445f, -0.07403304f, 0.29208720f, -0.00413634f, 0.03892415f, 0.21298856f, 0.09507482f, 
    0.44493634f, -0.06402887f, 0.35019824f, 0.00839944f, -0.06125544f, 0.07405869f, 0.21259017f, 0.16350381f, 
    -0.16537739f, -0.23276049f, -0.23162100f, -0.03875779f, -0.05467331f, 0.23115599f, 0.37059072f, -0.19573799f, 
    0.07186886f, 0.09479734f, -0.10847352f, 0.26179671f, -0.22048196f, 0.24638525f, -0.59492689f, 0.01306716f, 
    0.01268051f, 0.20905679f, 0.25379729f, 0.06438988f, -0.04883106f, -0.16428305f, -0.53323984f, 0.30426764f, 
    -0.06729921f, -0.25463611f, 0.01734250f, 0.08084407f, 0.35760382f, 0.21909544f, 0.32346100f, 0.29534230f, 
    0.24040729f, -0.51601648f, 0.07219438f, -0.37394485f, -0.09094260f, 0.07758371f, -0.07098153f, -0.32927838f, 
    0.15954952f, -0.24487872f, 0.23732211f, -0.88254958f, 0.22541334f, -0.02051551f, -0.08730466f, 0.01550735f, 
    0.17316309f, 0.07294291f, 0.10777509f, -0.02473840f, -0.23991761f, -0.49564594f, 0.21342522f, 0.10110062f, 
    0.29782277f, 0.28353897f, 0.33736470f, 0.01552445f, -0.01695187f, 0.07116090f, 0.06628295f, 0.31943467f, 
    0.11835383f, -0.01487757f, -0.04165496f, -0.11483784f, -0.00991279f, 0.08796118f, 0.02127339f, -0.09767058f, 
    0.07778583f, -0.08504067f, 0.03793924f, -0.12403485f, 0.00668411f, -0.05853206f, -0.06602302f, -0.03171279f, 
    0.12448531f, -0.00354503f, -0.09167312f, -0.06902857f, -0.11198747f, -0.01027645f, -0.06103195f, 0.06969641f, 
    0.00791900f, 0.05364038f, -0.04973482f, 0.11236258f, -0.08054358f, 0.03769732f, -0.06850792f, -0.09870882f, 
    -0.09025459f, -0.05888522f, -0.07857455f, -0.06361213f, -0.09075391f, -0.00793114f, 0.05970567f, 0.04492475f, 
    0.00890923f, -0.02878521f, 0.10047810f, 0.01450893f, 0.06709465f, 0.08135305f, -0.03960611f, -0.04626946f, 
    0.04516932f, -0.03559929f, -0.06101075f, -0.02353495f, -0.02583882f, 0.00436939f, 0.06048238f, 0.09686667f, 
    -0.09212382f, 0.00364915f, -0.10549478f, -0.03178455f, 0.07817706f, -0.06349760f, 0.03806144f, 0.04321900f, 
    -0.30759662f, 0.19764918f, -0.45442420f, 0.35685828f, 0.25501296f, -0.26342964f, -0.67139292f, -0.01134272f, 
    -0.00250071f, -0.05335351f, -0.84178001f, 0.36230960f, 0.24643636f, 0.19230971f, 0.32046387f, -0.32484999f, 
    -0.20539097f, -0.18251340f, 0.01192472f, -0.21483283f, -0.08905082f, 0.10138310f, 0.17396115f, -0.54338175f, 
    -0.16449429f, -0.17768410f, 0.05546151f, 0.09777661f, -0.09384960f, 0.03557946f, -0.13535871f, -0.34208977f, 
    -0.06385939f, -0.48416021f, 0.28196824f, 0.20962879f, 0.15453939f, 0.09917748f, 0.07532981f, 0.39969224f, 
    -0.74449432f, 0.06290072f, 0.17099777f, 0.13867109f, -0.05056893f, 0.22340347f, 0.11787735f, -0.52385634f, 
    0.12790821f, 0.05782038f, 0.01572239f, 0.10084200f, 0.03637519f, -0.03693863f, -0.19561635f, 0.06807981f, 
    0.72028726f, 0.03020701f, -0.09457969f, -0.27733386f, -0.05312768f, 0.07227601f, -0.73384637f, 0.14850330f, 
    -0.29304826f, 0.36683089f, 0.44026545f, 0.14040507f, 0.39028823f, -0.03925113f, -0.53320795f, 0.16609061f, 
    -0.24806191f, 0.08553749f, 0.15299244f, 0.22158360f, 0.63584405f, 0.13799782f, 0.48840368f, -0.05731044f, 
    0.01536676f, 0.04791557f, -0.33608323f, 0.25737867f, 0.12520725f, 0.21393730f, 0.05710250f, -0.33355412f, 
    0.22537844f, 0.22696166f, -0.01844145f, -0.04635420f, -0.08157865f, -0.12816188f, -0.27565300f, -0.00136450f, 
    0.13636997f, -0.26610947f, 0.07580038f, 0.45008242f, 0.11212260f, 0.05729950f, -0.04369883f, 0.28167951f, 
    0.12631592f, -0.02443564f, -0.26060462f, 0.17585270f, -0.19989277f, 0.23211534f, 0.25069743f, 0.29291376f, 
    -0.07456492f, 0.11496942f, 0.00819467f, -0.07627413f, 0.09500264f, -0.38298526f, 0.04440650f, 0.06743261f, 
    -0.45817626f, -0.11955816f, -0.15154876f, 0.17512670f, -0.07717853f, 0.02355741f, -0.47961456f, 0.02097092f, 
    -0.03530170f, 0.00080788f, -0.10179621f, 0.01818477f, 0.03863395f, -0.15031591f, -0.05845753f, -0.08547724f, 
    -0.06085393f, -0.00260408f, 0.05498296f, -0.12498456f, -0.06248850f, 0.00010957f, -0.09619668f, -0.09773239f, 
    -0.00224098f, -0.00115788f, -0.13106646f, 0.09160766f, 0.02181006f, 0.07569426f, 0.00922472f, 0.04748873f, 
    -0.01164287f, 0.05586205f, -0.15113774f, -0.12192661f, -0.10530590f, -0.04981073f, -0.02666409f, -0.06703235f, 
    -0.05514883f, 0.07816674f, 0.00810030f, -0.06923187f, 0.03334289f, -0.11165233f, 0.05271599f, 0.01119758f, 
    -0.10214152f, -0.00788571f, 0.06176910f, -0.16525744f, -0.01373595f, -0.02452378f, -0.14590135f, 0.01297676f, 
    -0.00306592f, 0.04819493f, 0.09808199f, 0.09785488f, -0.03460163f, 0.08905263f, -0.14250271f, -0.01601169f, 
    0.08270009f, -0.08355594f, -0.09652058f, 0.07117902f, -0.02055658f, -0.07894038f, -0.08019754f, -0.12683395f, 
    -0.08818111f, 0.03917793f, 0.17621143f, 0.09095267f, 0.02909003f, 0.00507443f, 0.15643248f, -0.44463050f, 
    -0.22319494f, -0.05583721f, 0.24013741f, -0.00822608f, 0.01290424f, 0.27482364f, -0.13232633f, -0.29440275f, 
    0.11658145f, 0.20106743f, -0.20913845f, 0.40975049f, -0.27948785f, 0.28659448f, -0.97894257f, -0.26198956f, 
    0.02102521f, 0.19261453f, 0.15077087f, 0.14350361f, 0.27619097f, 0.10490004f, -0.29217508f, 0.13084053f, 
    0.04694695f, 0.88629025f, 0.09314810f, -0.12444078f, -0.03494307f, 0.05371874f, -0.01353289f, -0.26083234f, 
    0.03131755f, -0.13094345f, 0.52627188f, -0.45658401f, 0.30329502f, 0.35991770f, -0.04470453f, 0.35876164f, 
    -0.14050771f, 0.05574952f, -0.04705331f, -0.34772509f, -0.17391488f, -0.15028074f, 0.31437796f, -0.11704537f, 
    0.16391321f, 0.13195243f, 0.26573417f, 0.59806830f, 0.00603893f, -0.11609981f, 0.15316665f, 0.18684183f, 
    0.08441854f, 0.02203719f, -0.08868843f, -0.02251912f, -0.11606384f, -0.04718871f, -0.12979420f, -0.15262651f, 
    -0.10628685f, -0.11817320f, -0.11519472f, -0.00922569f, -0.02816901f, -0.13709317f, -0.04547529f, -0.13233088f, 
    -0.00656158f, 0.00570189f, -0.04347136f, 0.04065273f, -0.14959104f, 0.07564701f, -0.02004483f, -0.01993214f, 
    -0.01992319f, 0.09287465f, 0.03362495f, -0.02327540f, -0.05944780f, 0.06850182f, -0.07265265f, -0.00163957f, 
    0.03677148f, 0.08677116f, -0.08524515f, -0.03398691f, -0.12849517f, 0.08443548f, 0.11833675f, -0.14522764f, 
    -0.00542004f, -0.14834216f, -0.05253703f, -0.05846405f, -0.09455416f, 0.07160038f, 0.02252782f, -0.04205245f, 
    -0.13429350f, -0.06137103f, -0.04244345f, -0.13770400f, -0.09203167f, 0.11895127f, 0.07173524f, 0.07349397f, 
    -0.15353614f, 0.07790940f, -0.03340479f, 0.11376723f, -0.05701868f, 0.02557090f, -0.09344363f, -0.07848810f, 
    -0.00554055f, -0.13574781f, 0.03175499f, -0.07728139f, -0.03925332f, 0.05237703f, -0.05878249f, -0.13666335f, 
    0.03530446f, 0.01887722f, -0.01503167f, -0.02576290f, -0.12500881f, -0.09297500f, -0.03518156f, 0.06865307f, 
    -0.13627030f, -0.06428948f, -0.01627025f, 0.05507655f, 0.03185484f, -0.07441114f, -0.04752084f, -0.03614609f, 
    -0.08490312f, -0.00018587f, 0.02678327f, -0.13925791f, 0.02680206f, -0.13894141f, 0.04752385f, 0.11129424f, 
    -0.00195730f, -0.01329885f, 0.06340235f, 0.05049229f, 0.08876756f, 0.04471095f, -0.06803603f, -0.14996791f, 
    -0.11792462f, 0.03174935f, -0.04073331f, -0.06341939f, 0.04173887f, -0.14384654f, -0.00993211f, -0.10965635f, 
    -0.00574049f, 0.04712206f, 0.06485921f, -0.04847042f, -0.07451492f, 0.02107305f, -0.12537266f, -0.04034208f, 
    0.07747803f, -0.10312478f, 0.03150136f, 0.02164027f, 0.04285456f, -0.11812167f, -0.02654363f, -0.11526559f, 
    0.03067680f, 0.05529246f, 0.04940563f, 0.30862251f, -0.07754823f, 0.14527749f, 0.12713958f, 0.04187350f, 
    0.27950406f, 0.05459598f, -0.29738119f, 0.37998122f, -0.03641336f, -0.08051869f, -0.03971260f, 0.09488921f, 
    0.09333985f, -0.10814833f, -0.05172101f, -0.14493357f, 0.02386378f, 0.12396640f, 0.01712088f, 0.03790487f, 
    0.09376067f, 0.03510114f, 0.25144550f, 0.04943182f, -0.05150343f, 0.08493755f, 0.05190403f, -0.95715296f, 
    0.02241624f, 0.15117861f, -0.21999426f, 0.00487661f, 0.17180873f, 0.01315164f, -0.11997308f, -0.21908011f, 
    -0.47102877f, -0.00689517f, -0.32626346f, -0.08903997f, 0.01445351f, -0.02959515f, 0.17797303f, -0.48628387f, 
    0.06268305f, 0.03388484f, 0.01737075f, -0.09967267f, -0.10572052f, -0.37804493f, -0.14148103f, -0.10458523f, 
    0.03390333f, 0.09375380f, -0.14795551f, -0.14707261f, -0.02525801f, -0.05507109f, -0.17493238f, 0.06064548f, 
    -0.37017816f, -0.10675525f, 0.55722308f, 0.13310903f, -0.23715776f, -0.19677678f, 0.10002748f, 0.03712739f, 
    0.28854558f, -0.04477281f, 0.02731258f, 0.16801870f, -0.24343231f, 0.08802018f, -0.18375988f, 0.27158037f, 
    0.23129560f, 0.51234752f, -0.08032148f, 0.35286677f, 0.05031272f, 0.24803483f, 0.27235192f, 0.03757104f, 
    0.31475523f, 0.46348107f, 0.41552353f, 0.14843954f, 0.16769373f, 0.00862996f, -0.28205329f, -0.26996145f, 
    0.01254563f, -0.13616511f, -0.00707807f, -0.04006189f, 0.07848524f, 0.07168766f, 0.06748851f, 0.04270284f, 
    0.30614415f, 0.20268652f, -0.44753045f, 0.06859017f, -0.00006519f, -0.17934714f, 0.06510740f, -0.20114411f, 
    -0.29353768f, 0.15130022f, -0.01875317f, -0.27262554f, 0.15990700f, 0.03497320f, -0.37064326f, -0.04840445f, 
    -0.11254096f, 0.00886822f, -0.03822787f, -0.29245475f, -0.07971214f, 0.06212937f, 0.42435706f, -0.01170814f, 
    0.16267781f, 0.32305393f, 0.13511391f, -0.00371501f, -0.06478726f, 0.44481549f, 0.26165339f, -0.24333982f, 
    0.00626109f, -0.01738655f, 0.33270845f, -0.01795512f, 0.01024415f, 0.07506478f, -0.29020789f, 0.36982900f, 
    0.10227468f, 0.27908295f, -0.10046007f, 0.06616700f, -0.09132621f, 0.15880772f, -0.43688422f, 0.05458706f, 
    0.02326862f, 0.56100219f, 0.20637348f, -0.10864280f, 0.13499586f, 0.07505755f, 0.01639462f, 0.26953986f, 
    0.37343729f, 0.06666382f, -0.25208837f, 0.01196006f, -0.05215245f, 0.09726643f, -0.10926507f, -0.53815812f, 
    -0.12237839f, -0.14081192f, -0.04662263f, -0.36139244f, 0.14494507f, 0.11054060f, 0.01821569f, 0.11645510f, 
    0.07558074f, -0.14470196f, -0.12179662f, -0.71595341f, 0.04931830f, 0.10662777f, 0.15096705f, -0.01969235f, 
    -0.19936736f, 0.05261583f, -0.09710304f, 0.34398711f, 0.05957661f, -0.06566198f, 0.40119788f, 0.24266292f, 
    -0.09407242f, 0.38871929f, 0.26258889f, 0.09808516f, 0.27878085f, 0.06043611f, -0.45376179f, -0.05038976f, 
    0.04588308f, 0.05962558f, 0.12617929f, 0.54627693f, 0.30418259f, -0.13918839f, 0.43115267f, -0.56626534f, 
    -0.40169433f, -0.01903344f, -0.37610608f, 0.08994532f, -0.15345676f, 0.35378432f, 0.22978233f, -0.01972510f, 
    0.12034644f, -0.25992471f, 0.02777051f, -0.02530421f, -0.26292753f, -0.15968250f, -0.08453917f, -0.03277989f, 
    0.28182837f, -0.39826789f, 0.26269060f, 0.35632890f, 0.18896207f, -0.04382198f, -0.00574745f, 0.04512710f, 
    -0.30671877f, 0.01734309f, -0.11035514f, 0.21420507f, -0.10363103f, 0.34165823f, 0.35443971f, 0.20480415f, 
    -0.20675841f, -0.12998982f, -0.07101080f, 0.08151004f, -0.42939734f, -0.33862016f, 0.18871944f, 0.02156003f, 
    0.06201695f, 0.13578156f, -0.17487773f, -0.01115966f, -0.08232683f, 0.03435006f, -0.28471193f, -0.10648228f, 
    -0.22317088f, 0.07645272f, -0.15421350f, 0.11402216f, -0.06438179f, 0.06987120f, -0.04479814f, 0.28230554f, 
    0.07315504f, 0.08007874f, -0.34798694f, 0.02145594f, 0.09750304f, -0.23387747f, 0.03777939f, -0.05191483f, 
    0.21319431f, -0.30359662f, -0.19252783f, -0.19211517f, 0.11465281f, -0.01900298f, 0.07421786f, -0.17762257f, 
    0.00593123f, 0.10577916f, 0.06638435f, 0.10236253f, -0.00958835f, -0.15367113f, -0.28016648f, -0.12653102f, 
    -0.00474720f, 0.85393149f, -0.21294110f, 0.14047435f, 0.10524308f, -0.07441805f, -0.06294711f, -0.30618584f, 
    0.31018832f, 0.25950071f, 0.07154362f, 0.19350798f, -0.11925290f, 0.16514887f, -0.06191942f, -0.10351562f, 
    0.19007345f, -0.04498874f, -0.06159598f, 0.03730961f, 0.30065203f, 0.26837054f, -0.17327379f, 0.07734716f, 
    0.41568655f, -0.04885857f, -0.02886377f, 0.28195092f, -0.01199396f, 0.02518280f, -0.22120999f, -0.04903483f, 
    -0.57834715f, 0.26881540f, 0.22456084f, 0.02892526f, -0.06451616f, 0.48568213f, -0.04020840f, -0.03500468f, 
    -0.04950922f, -0.00848666f, 0.01616898f, -0.10941277f, 0.43305001f, 0.16613664f, 0.03329892f, 0.14158636f, 
    -0.01253080f, 0.12597056f, -0.21449816f, 0.09291952f, -0.06846803f, 0.32590923f, -0.26223812f, -0.14996698f, 
    0.17129950f, 0.35431698f, 0.05122636f, 0.02834165f, 0.16203867f, 0.11473610f, -0.13776046f, 0.06333458f, 
    0.50715894f, -0.57614213f, -0.17795280f, 0.19267163f, 0.22539313f, 0.03008646f, -0.11212005f, -0.36964205f, 
    -0.19432777f, -0.13126135f, 0.03500501f, 0.11071804f, 0.03938824f, 0.26361537f, 0.03578722f, 0.22522928f, 
    -0.07506420f, 0.03861502f, -0.06818524f, -0.16821983f, 0.14452673f, -0.35289732f, 0.26164731f, -0.12160636f, 
    -0.38126430f, 0.10195073f, -0.00677603f, 0.27462146f, -0.12869936f, -0.03736756f, 0.00014383f, 0.40327746f, 
    -0.06267215f, -0.01657509f, -0.02878660f, -0.05568002f, -0.09776282f, -0.12732549f, 0.05265777f, 0.03091531f, 
    0.00357996f, -0.10701920f, -0.11541127f, -0.04837462f, -0.05920959f, -0.00123594f, 0.09282352f, -0.10210889f, 
    0.01783979f, 0.04542382f, 0.05800660f, 0.00165858f, -0.10487816f, 0.03049571f, 0.08991815f, 0.04789524f, 
    -0.06351048f, -0.02093728f, -0.07694586f, -0.12110934f, -0.07088319f, -0.07618918f, 0.02762732f, 0.03382355f, 
    0.00891847f, -0.05053418f, -0.09676899f, 0.03561130f, -0.13263997f, -0.08684355f, -0.03476830f, -0.07948531f, 
    0.00727239f, 0.09164588f, -0.15907240f, -0.05648318f, -0.02031296f, -0.08057421f, 0.02599600f, -0.12773924f, 
    0.02017391f, -0.07528794f, 0.10121253f, -0.06721423f, -0.00611925f, 0.05187010f, -0.09043110f, 0.05660217f, 
    -0.04046680f, -0.06540524f, 0.01785720f, 0.00242764f, 0.00329103f, -0.02510287f, -0.13086857f, -0.00172840f, 
    0.00665100f, -0.05077492f, 0.04737900f, 0.12402144f, -0.11741307f, -0.06797747f, -0.07218763f, 0.02924572f, 
    -0.11944574f, -0.07439880f, -0.00273059f, -0.09462363f, -0.01818314f, -0.12240683f, -0.10363781f, 0.00069925f, 
    -0.05139300f, -0.11127627f, -0.06876045f, 0.07025389f, -0.11975822f, -0.04714733f, -0.10949914f, 0.01211195f, 
    -0.00387624f, 0.01530886f, -0.04989506f, 0.03206900f, -0.08307342f, 0.03892662f, 0.11057940f, 0.08688086f, 
    0.06882563f, -0.10167031f, 0.07824700f, 0.08831707f, -0.06993411f, -0.01070698f, -0.07082582f, 0.12452769f, 
    0.06525697f, -0.09845164f, 0.07098004f, 0.04470764f, -0.11483549f, -0.01035978f, 0.00637273f, 0.02026740f, 
    -0.10458045f, -0.07977886f, 0.11726481f, 0.10113902f, -0.07139871f, -0.01526304f, 0.05492949f, -0.05762568f, 
    -0.06658714f, -0.08677359f, -0.08263578f, 0.08025372f, 0.04095468f, 0.12192163f, 0.01092830f, -0.12187724f, 
    -0.11303167f, -0.13245285f, -0.03585297f, -0.02424309f, 0.01429241f, 0.07787465f, 0.01033441f, -0.00533396f, 
    -0.00188475f, 0.00111900f, -0.06702268f, 0.09702521f, -0.10182010f, -0.14308488f, -0.16680059f, 0.01554577f, 
    -0.10949869f, -0.09300318f, -0.06648142f, -0.09775925f, -0.00282124f, -0.10347061f, -0.09488402f, -0.12046513f, 
    -0.03088281f, 0.06617472f, 0.03532061f, -0.07128414f, -0.08623425f, 0.07385544f, -0.14865603f, -0.09419735f, 
    0.01910337f, 0.10232557f, 0.03134409f, -0.10431594f, -0.00827682f, 0.11632138f, -0.06846949f, -0.02881856f, 
    -0.04773709f, -0.08658946f, 0.03416052f, -0.09322914f, -0.04642503f, 0.05325377f, 0.03736088f, 0.07087526f, 
    -0.07740144f, -0.07395922f, 0.08779928f, -0.12669447f, 0.06361144f, -0.09531205f, 0.02125117f, -0.09276021f, 
    0.02289815f, -0.08373632f, -0.01939244f, -0.12218465f, 0.06246782f, 0.11868645f, 0.03432225f, -0.08067507f, 
    0.60138249f, -0.04494324f, -0.44376242f, 0.08176646f, 0.22676179f, -0.25217387f, -0.11315261f, 0.12619741f, 
    -0.24914815f, 0.03849779f, -0.17997265f, 0.33030322f, 0.22925851f, 0.08992037f, 0.22383031f, 0.32810757f, 
    -0.10002938f, 0.09886961f, 0.36920336f, -0.05816885f, 0.20670077f, 0.09427201f, -0.11732270f, -0.21558587f, 
    0.06665662f, -0.04775905f, -0.32601824f, 0.10845974f, -0.11480922f, -0.06378236f, -0.28424704f, -0.07830702f, 
    -0.08224095f, 0.27320358f, 0.31735411f, 0.21087903f, 0.17709027f, -0.03860998f, 0.09782988f, 0.73636597f, 
    0.90074283f, -0.05790465f, -0.05117998f, 0.24141389f, -0.03128567f, 0.14890711f, -0.11284214f, 0.25863296f, 
    -0.05876204f, 0.07299072f, 0.04553390f, 0.00099278f, 0.22909783f, 0.70827574f, -0.15084156f, -0.08489027f, 
    0.23294917f, -0.26187676f, 0.05658408f, -0.42399728f, 0.09211121f, 0.06316250f, -0.60219574f, 0.06890162f, 
    -0.23781785f, -0.07686331f, 0.49963498f, 0.23699112f, 0.11931666f, -0.24926774f, 0.28269970f, -0.44648701f, 
    -0.39470381f, 0.05268517f, -0.46747053f, 0.19816077f, 0.08414006f, 0.33932406f, -0.09663392f, -0.48558813f, 
    0.00046190f, 0.27956849f, -0.01222399f, 0.24376443f, 0.04043457f, 0.10202254f, -0.03131687f, -0.28049919f, 
    0.15899885f, -0.41790649f, 0.06759451f, 0.20012011f, 0.07345449f, 0.05413311f, -0.15300605f, 0.30908045f, 
    -0.08960258f, -0.45953977f, 0.48544642f, 0.02633235f, 0.26060891f, -0.05367875f, -0.01048712f, 0.46899596f, 
    -0.14993000f, 0.19641818f, 0.28329030f, -0.21966664f, 0.18693122f, 0.16269425f, -0.05750703f, -0.04797143f, 
    -0.13608082f, -0.03169267f, 0.10128671f, 0.02581240f, -0.23854804f, 0.12541202f, -0.22723424f, 0.10226940f, 
    0.20958483f, 0.28444767f, 0.08842627f, -0.39943558f, 0.01430916f, -0.05061055f, -0.28346354f, 0.02209207f, 
    -0.01981794f, -0.08601014f, -0.10023706f, 0.00681199f, -0.09613160f, -0.00629736f, 0.03578543f, -0.00737268f, 
    0.06790473f, 0.11374073f, -0.08057577f, -0.00131544f, 0.05763249f, -0.14762676f, -0.16420227f, -0.12183999f, 
    0.08584991f, -0.07002750f, 0.00577096f, -0.00197448f, -0.02709174f, -0.12743518f, -0.07231027f, 0.16607799f, 
    0.03877173f, 0.02714582f, -0.14893670f, -0.12603666f, -0.16023000f, 0.05817641f, -0.01888334f, -0.07194337f, 
    -0.13041443f, 0.11984537f, 0.10026047f, -0.08574729f, 0.04087046f, 0.05260694f, 0.10611022f, -0.14078045f, 
    0.04017228f, -0.03159940f, -0.10615954f, 0.03013784f, -0.01316738f, 0.04593247f, -0.01890770f, -0.03654264f, 
    -0.04527442f, -0.00219490f, -0.02337690f, -0.07492007f, -0.04851908f, 0.08150166f, 0.07447624f, 0.11923373f, 
    0.01672788f, 0.02953291f, 0.00088748f, 0.00906702f, 0.00904573f, 0.04362845f, -0.12388419f, -0.04111559f, 
    -0.01790613f, -0.06039491f, -0.09039596f, 0.04755550f, -0.02479391f, 0.07135044f, -0.05895345f, -0.01876684f, 
    -0.00333561f, -0.07190537f, -0.05201766f, 0.02181769f, 0.04528505f, 0.08707713f, -0.04473299f, 0.08207133f, 
    -0.05478497f, -0.10373506f, 0.09016230f, -0.06913826f, -0.05208967f, 0.07324991f, 0.03480523f, 0.02788982f, 
    -0.02439583f, -0.00919279f, 0.05357100f, -0.12526298f, 0.05392076f, -0.09802005f, -0.13171741f, -0.02437805f, 
    -0.10774751f, -0.08248714f, -0.08438499f, 0.09491748f, -0.06953019f, 0.10948744f, -0.07007602f, -0.01168659f, 
    0.01168379f, -0.03307519f, 0.11081502f, -0.02409731f, -0.04895112f, -0.09504125f, -0.13429122f, -0.14781269f, 
    -0.11498380f, 0.09089766f, 0.07540219f, -0.12434019f, -0.00334304f, -0.06377588f, -0.12628637f, -0.11375584f, 
    0.08115095f, -0.05064011f, -0.09242247f, 0.13586184f, -0.00785141f, -0.07729189f, 0.03237265f, -0.03367662f, 
    0.69958067f, -0.22549972f, 0.51434171f, -0.02627941f, -0.15916499f, -0.18530889f, 0.04387839f, 0.30699202f, 
    0.31508073f, 0.04304091f, -0.10562032f, -0.06114309f, 0.09832340f, -0.21397898f, 0.29689446f, 0.20370419f, 
    0.16926871f, -0.02704837f, 0.17665941f, 0.32026464f, 0.14667790f, -0.17840429f, 0.57466078f, 0.40436381f, 
    0.08243906f, -0.22776279f, -0.03570910f, 0.09818842f, -0.03540264f, 0.06807254f, -0.04600544f, 0.47410408f, 
    -0.19570805f, -0.40004340f, -0.26256084f, 0.02332024f, 0.11815098f, 0.07477675f, 0.01026264f, 0.17164750f, 
    0.31554815f, 0.35378638f, 0.57340586f, 0.37361011f, 0.10591576f, -0.36347696f, -0.07998350f, -0.35812092f, 
    0.07527725f, 0.06865130f, -0.04794315f, 0.29051045f, 0.14901476f, 0.79980791f, -0.04119136f, -0.05950905f, 
    -0.50817096f, 0.12526698f, 0.11834994f, -0.82193524f, -0.05971356f, -0.06569874f, -0.08051792f, -0.20201878f, 
    -0.71390843f, 0.14598587f, 0.08720021f, 0.37627882f, -0.32315692f, 0.20453559f, 0.22565152f, -0.07393325f, 
    0.43233490f, 0.01775854f, 0.15052792f, 0.42291075f, -0.30575633f, -0.04468797f, -0.16073070f, 0.04664483f, 
    -0.14720479f, -0.03306076f, -0.10230526f, -0.15002398f, -0.03095184f, -0.10540956f, -0.00494137f, -0.09278163f, 
    0.26558039f, -0.00157197f, 0.38128090f, 0.22937974f, 0.27503395f, 0.26906547f, 0.25983569f, -0.38921627f, 
    0.19934273f, 0.29222938f, -0.36010447f, 0.02789460f, 0.09973365f, 0.02389709f, 0.06205882f, -0.20208676f, 
    0.32249495f, 0.06277029f, -0.27235180f, 0.14271250f, 0.11237001f, -0.27140972f, 0.28155139f, -0.46376252f, 
    -0.16121131f, 0.04325578f, -0.06564416f, 0.07091318f, -0.22198568f, -0.22595496f, -0.23922409f, 0.05175922f, 
    0.42683488f, 0.14123410f, 0.26682040f, -0.18681458f, -0.05982166f, -0.07879514f, 0.22154965f, 0.13461971f, 
    0.15463071f, -0.09771162f, 0.17534293f, -0.02406684f, 0.39729965f, -0.23131308f, 0.34507588f, -0.46132618f, 
    -0.28564292f, 0.05389520f, 0.01013143f, -0.22021009f, 0.10694858f, 0.25947449f, -0.02423341f, -0.31452686f, 
    -0.19019088f, 0.15684716f, 0.15204893f, 0.20888999f, 0.07558291f, 0.03337249f, -0.13273260f, -0.35283846f, 
    -0.09908409f, -0.41191819f, -0.41931617f, -0.00920779f, 0.15619086f, 0.08296705f, 0.07114184f, 0.41802186f, 
    -0.08481401f, 0.03712294f, 0.46368539f, -0.06396979f, 0.14822458f, 0.00167996f, 0.10426976f, 0.18447293f, 
    -0.12620057f, -0.22854075f, 0.32419676f, 0.02316159f, 0.29956102f, 0.09089971f, -0.30116156f, 0.32115212f, 
    0.03209804f, 0.09723584f, -0.09628372f, 0.31199005f, -0.27202785f, 0.37825426f, 0.12911122f, 0.11666470f, 
    0.23732553f, 0.06979717f, 0.18645759f, 0.43212712f, -0.10780784f, -0.06095196f, -0.14390816f, 0.15581171f, 
    -0.04063997f, -0.09652122f, 0.08477537f, 0.09369203f, -0.11587282f, -0.03611966f, -0.07664765f, 0.10050505f, 
    -0.05433073f, 0.02594012f, 0.03630766f, 0.03337155f, -0.04201094f, -0.06663343f, -0.07607391f, 0.04934816f, 
    0.09097555f, -0.11810350f, -0.08169734f, 0.00717457f, -0.07377923f, -0.04352402f, -0.08163474f, 0.02998272f, 
    0.10527661f, 0.04667661f, 0.06397218f, 0.02393715f, -0.12255085f, -0.10044330f, -0.10385123f, -0.10250923f, 
    -0.10008335f, 0.01573752f, 0.00496410f, -0.08698678f, -0.00186734f, -0.02556205f, 0.10551924f, -0.11308634f, 
    0.00743559f, -0.13388515f, -0.07686016f, -0.06118061f, -0.12709776f, -0.14287740f, 0.06091344f, 0.07170011f, 
    -0.04049056f, -0.01468565f, 0.01003337f, -0.01369581f, -0.09262319f, -0.03315870f, 0.02476257f, -0.02003260f, 
    -0.02145775f, -0.13410750f, 0.00318260f, -0.02966771f, -0.08926213f, -0.03537323f, -0.07836429f, 0.07716019f, 
    -0.23645693f, 0.18011674f, -0.22538863f, 0.22579667f, 0.14883901f, 0.30917218f, -0.03279538f, -0.00732828f, 
    0.29397005f, 0.08402089f, 0.01430527f, 0.69723672f, -0.07962068f, 0.12456696f, 0.15479264f, 0.14655145f, 
    -0.33540004f, -0.02109814f, 0.01556532f, -0.00276957f, -0.24343315f, 0.02610969f, -0.18747307f, -0.10974735f, 
    0.00791594f, 0.10743947f, 0.21639499f, -0.09151314f, 0.15297766f, 0.14753538f, 0.04228641f, -0.71329570f, 
    0.21485962f, 0.25333625f, -0.07928370f, 0.23278822f, 0.16058014f, -0.03304829f, 0.03174543f, 0.11165550f, 
    0.33820525f, -0.12595503f, -0.53136235f, 0.06693174f, 0.13943073f, 0.02337390f, 0.40677658f, 0.15320601f, 
    -0.36919862f, -0.13992837f, 0.00121017f, -0.03609879f, -0.03342792f, -0.23473363f, -0.31136432f, -0.04299252f, 
    -0.13299043f, 0.10780149f, -0.02853766f, -0.50155103f, -0.02773502f, -0.03156372f, -0.13641250f, 0.00277643f, 
    -0.03725421f, -0.04154761f, 0.03491129f, -0.03807072f, -0.08351669f, -0.09493410f, -0.00719673f, 0.03719670f, 
    -0.13222648f, 0.06697820f, -0.09102640f, 0.06279092f, -0.08242899f, -0.07006862f, -0.05915448f, -0.12865508f, 
    0.02036457f, -0.13227807f, -0.01460163f, -0.00157908f, 0.06206708f, -0.12308630f, -0.00053596f, 0.09526914f, 
    0.00276799f, 0.04836104f, -0.08480406f, -0.03757378f, -0.13326550f, 0.06292594f, -0.10123236f, 0.09170541f, 
    -0.11204348f, 0.07166621f, 0.07850922f, -0.04648568f, -0.08782383f, -0.09802029f, 0.03943814f, 0.03526589f, 
    -0.06959105f, 0.02112290f, -0.02107708f, -0.08144061f, 0.06522535f, 0.01650753f, 0.04597109f, 0.03687546f, 
    -0.06415555f, 0.01549073f, 0.00571689f, -0.09431524f, -0.06757514f, -0.02329284f, 0.02458159f, 0.01148495f, 
    -0.09014998f, -0.12597451f, -0.07591103f, 0.08669681f, 0.00367188f, -0.02824660f, -0.04562224f, 0.03637675f, 
    -0.62074155f, 0.07149016f, 0.87564844f, 0.26630974f, -0.10417052f, 0.04278843f, 0.15037189f, -0.18047649f, 
    -0.02279645f, 0.13406974f, 0.57250154f, 0.10356641f, 0.20346178f, 0.18330894f, -0.01205342f, 0.11680435f, 
    -0.03593644f, 0.40366071f, -0.32617739f, 0.61137253f, -0.08283357f, 0.37241879f, -0.02953266f, -0.22489877f, 
    0.43083593f, 0.40250319f, 0.34859690f, 0.05637763f, 0.09373090f, -0.10106014f, -0.28918681f, -0.03655446f, 
    0.21648665f, -0.22377637f, 0.08331241f, -0.01906100f, 0.26301217f, -0.07692327f, -0.07376328f, -0.21985170f, 
    0.20424415f, -0.03209415f, 0.17327160f, 0.11352008f, 0.22693081f, 0.20508045f, 0.26879832f, 0.28009149f, 
    -0.51322281f, 0.02752302f, -0.04525073f, -0.24652129f, -0.00606905f, -0.20704560f, -0.22207551f, 0.01528208f, 
    -0.28710940f, 0.30088195f, -0.00527762f, -0.11622842f, -0.04120011f, -0.04371204f, 0.19332033f, 0.09435306f, 
    -0.15553655f, -0.08841988f, 0.12675026f, -0.16609493f, -0.03429640f, 0.19014117f, 0.08130293f, -0.07007835f, 
    -0.01403474f, 0.13343923f, -0.38345379f, -0.07300919f, 0.51080692f, 0.12657662f, 0.20703840f, -0.01076076f, 
    -0.48258263f, -0.09358038f, 0.15967762f, 0.06690031f, 0.07501858f, -0.18080358f, -0.09871165f, -0.17241663f, 
    0.15937479f, -0.21437971f, -0.24419397f, 0.03470046f, -0.02693038f, 0.25191873f, -0.02092079f, 0.57094777f, 
    0.08203194f, -0.78497332f, -0.07286455f, -0.15441158f, 0.21835542f, -0.10144553f, -0.11976708f, 0.35727641f, 
    -0.03726333f, -0.38248110f, 0.96233594f, 0.11639199f, 0.23162411f, -0.14773408f, -0.10173170f, -0.18679117f, 
    -0.26563281f, -0.06041211f, -0.06910220f, 0.35118794f, -0.17444967f, -0.08634385f, -0.32413474f, 0.14406070f, 
    0.15484224f, 0.13280044f, 0.12959766f, -0.37757659f, -0.03733549f, -0.05000012f, -1.11036503f, 0.02057691f, 
    -0.03533135f, -0.00738835f, -0.04118836f, -0.02291529f, -0.06045724f, -0.12797259f, -0.04054800f, 0.00008579f, 
    -0.10395290f, 0.09156296f, 0.11181724f, -0.08218919f, -0.07429504f, -0.04910606f, 0.11334851f, 0.02856806f, 
    -0.08308975f, 0.00882587f, -0.02442472f, -0.14795059f, 0.05087162f, -0.15218069f, -0.04251438f, -0.07615703f, 
    -0.02638528f, -0.02537251f, -0.08244625f, -0.05883731f, 0.09225439f, -0.15208898f, 0.09130710f, 0.08212186f, 
    0.04056901f, -0.04832808f, 0.00140947f, -0.10632783f, -0.07410023f, 0.04386035f, 0.07497661f, 0.01995704f, 
    -0.13395974f, 0.01609579f, -0.06881286f, -0.04017688f, 0.06200803f, 0.02530026f, -0.03742808f, -0.06373706f, 
    -0.02639360f, 0.06610113f, -0.07102469f, 0.00980059f, -0.04437728f, -0.04511278f, -0.08656365f, 0.03364524f, 
    0.05080161f, -0.11799811f, 0.02962871f, -0.00874509f, 0.06878388f, -0.05667774f, -0.00871201f, -0.11909647f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05542531f, 0.09326905f, 0.14442672f, 0.25281754f, -0.02548678f, -0.15724811f, 0.21488716f, 0.24867851f, 
    0.08345884f, -0.39026543f, 0.01103803f, -0.12145180f, 0.09952718f, -0.06356236f, 0.01329270f, 0.33631766f, 
    0.05400041f, 0.02251740f, -0.12932794f, -0.12279624f, -0.08372705f, 0.06756794f, 0.02879329f, 0.20658123f, 
    -0.13013026f, -0.05293677f, 0.30479673f, -0.12432916f, 0.00783222f, 0.16074336f, 0.17877430f, -0.03771208f, 
    -0.12855026f, 0.10581599f, 0.03640971f, -0.02385904f, 0.00600475f, 0.48775771f, -0.06200566f, 0.04802447f, 
    -0.05782202f, 0.01345426f, 0.05958666f, -0.10088799f, 0.15285558f, 0.38823944f, 0.22334886f, 0.39810127f, 
    -0.04515101f, -0.08353898f, -0.03650215f, 0.04582461f, -0.16669875f, -0.12475212f, -0.12682466f, -0.11322967f, 
    0.07621393f, -0.31373131f, -0.12486209f, 0.36854318f, -0.01629620f, 0.09646446f, 0.03710208f, -0.13416390f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.45716992f, -0.01697280f, 0.30479383f, -0.15930367f, -0.05302088f, -0.45626059f, -0.06103862f, 0.39313513f, 
    -0.10703892f, 0.37013265f, -0.24165249f, -0.05753798f, 0.00227956f, 0.06703386f, -0.05751176f, 0.09019694f, 
    -0.05577139f, 0.18698473f, -0.07703742f, 0.00536321f, -0.23920715f, -0.11661337f, 0.03645137f, -0.05597216f, 
    0.25379360f, -0.36046815f, -0.23212504f, 0.09955338f, -0.10513695f, 0.15582369f, 0.02484708f, -0.31286573f, 
    -0.16015424f, 0.23484683f, -0.29652873f, 0.09982127f, 0.09328678f, 0.18065520f, -0.12723106f, -0.38652244f, 
    -0.14878695f, -0.05133345f, -0.00468084f, -0.20594464f, 0.00294292f, 0.23984826f, -0.16557600f, 0.05148456f, 
    -0.06966283f, 0.04478768f, 0.08686858f, 0.17296204f, -0.18419909f, -0.01813637f, -0.09063091f, -0.07315499f, 
    0.00081737f, 0.04276877f, 0.02110872f, -0.00554383f, 0.03941174f, 0.01414784f, 0.44953224f, 0.02276422f, 
    0.17130105f, -0.27073899f, -0.64800346f, 0.20700464f, -0.12921275f, 0.51973796f, -0.03115905f, 0.14652583f, 
    -0.04029861f, 0.38408524f, 0.27240348f, -0.08304672f, 0.02007969f, -0.02489220f, 0.04182292f, -0.34342897f, 
    -0.36241499f, -0.03287938f, -0.03759162f, 0.07430226f, 0.23054844f, -0.51748884f, 0.08487231f, 0.02568080f, 
    0.05197600f, -0.12355588f, -0.02476617f, 0.32026324f, 0.04449857f, 0.09021527f, 0.05804622f, 0.23333661f, 
    0.05846226f, 0.13893256f, -0.25266126f, -0.06929564f, 0.31272745f, -0.04574627f, -0.02778051f, 0.13740283f, 
    0.06291483f, -0.10263218f, 0.10249664f, -0.23963441f, -0.16923437f, 0.19465794f, 0.17240743f, -0.30484670f, 
    0.07498020f, -0.03782775f, -0.12708561f, 0.23881447f, -0.22907716f, -0.09333726f, 0.06642920f, -0.15851150f, 
    0.17907366f, 0.00833037f, -0.02778476f, 0.00749163f, -0.01603176f, -0.40637016f, -0.11184940f, -0.01566382f, 
    0.06254006f, 0.34800974f, 0.02164415f, 0.07261280f, -0.00390461f, -0.83603710f, 0.28663501f, -0.22870210f, 
    0.05928855f, -0.67601073f, -0.01847702f, 0.01187618f, 0.12073807f, 0.00608115f, 0.02120277f, 0.07735143f, 
    0.01666982f, -0.28015280f, 0.11562787f, 0.00192017f, -0.45233142f, -0.03390813f, -0.05438880f, -0.38297209f, 
    0.27816406f, 0.25529602f, 0.17836897f, -0.51462209f, 0.01851431f, 0.13095279f, -0.02120994f, -1.15549397f, 
    0.03805367f, -0.11392507f, -1.28522003f, 0.04194818f, -0.31047732f, -0.09427511f, -0.00675406f, -0.23368818f, 
    -0.11770549f, 0.02806716f, 0.03923893f, 0.18812118f, 0.32899475f, -0.26037276f, 0.18756779f, 0.19764391f, 
    0.03662929f, 0.08377628f, 0.10854468f, -0.46834993f, -1.53556263f, -0.03765210f, 0.11399226f, -0.02218160f, 
    0.20232126f, -0.47642791f, -0.01931563f, -0.08016235f, -0.03683198f, -0.02272496f, -0.20522177f, 0.11266616f, 
    0.41694552f, 0.18726936f, 0.20823747f, -0.51489592f, -0.06238991f, -0.08842090f, 0.18315904f, 0.04956477f, 
    0.09389365f, -0.40042558f, -0.36035261f, -0.09505946f, 0.01889926f, -0.04905073f, -0.01443235f, -0.38311303f, 
    0.08800644f, 0.23150395f, 0.04327536f, 0.03817548f, -0.22268397f, -0.54470432f, 0.10078314f, -0.47834218f, 
    -0.03137837f, 0.10499059f, -1.44453025f, -0.54765517f, -0.04259954f, -0.18390195f, -0.72502702f, -0.09052523f, 
    -0.14407785f, -0.01152027f, 0.06386835f, 0.01068649f, 0.01799554f, -0.03952815f, -0.15161268f, 0.28868261f, 
    -0.06783900f, 0.10355181f, -0.63427049f, 0.02221943f, 0.09859096f, -0.12528151f, -0.38857895f, 0.16816619f, 
    0.04321641f, 0.08898605f, 0.07151745f, -0.44761306f, 0.13116443f, 0.01653407f, -0.04834992f, -0.32159248f, 
    0.10500720f, 0.03491673f, -0.05694046f, -0.26572859f, -0.03653313f, 0.28836483f, 0.14629586f, 0.06553528f, 
    -0.52522457f, -0.80481130f, 0.17580283f, 0.15775254f, 0.05902611f, -0.09462171f, 0.06846160f, 0.32673964f, 
    0.10019846f, 0.09573288f, -0.09762906f, 0.07397794f, 0.06525776f, -0.06783246f, -0.03334068f, 0.23096633f, 
    -0.01963261f, -0.40348992f, 0.08668778f, 0.00589767f, -0.11079692f, -1.03334200f, 0.03836166f, 0.07754443f, 
    0.03448763f, 0.02177766f, 0.18452203f, -0.09070724f, 0.03879086f, 0.02626931f, 0.20130983f, -0.16904362f, 
    0.05619214f, -0.26031667f, -0.06518993f, 0.08598180f, -0.44420916f, 0.16160242f, -0.12105643f, 0.37722290f, 
    0.03491874f, -0.06431576f, -0.13657078f, -0.08590206f, 0.21315153f, 0.16245274f, -0.00720415f, 0.17166816f, 
    0.09546527f, -0.05533978f, 0.09181818f, -0.02859763f, -0.09515833f, 0.10368659f, -0.15349631f, 0.07954776f, 
    -0.01004051f, 0.01083456f, -0.07741441f, -0.06238716f, -0.03404696f, 0.22032759f, -0.37913296f, 0.11206736f, 
    0.21855496f, 0.17796057f, 0.20347521f, 0.15661411f, 0.00945528f, -0.17267343f, -0.24160811f, -0.14271665f, 
    -0.07396465f, -0.63290739f, 0.23735468f, -0.13207632f, 0.05869555f, 0.01465594f, -0.10729953f, 0.17126079f, 
    -0.29119292f, -0.39184082f, 0.04651712f, -0.05051944f, -0.11577848f, -0.00502893f, 0.06157607f, 0.22374709f, 
    -0.16926116f, -0.31456637f, 0.30754948f, 0.13556615f, -0.05997486f, -0.07770351f, 0.13311106f, 0.32787189f, 
    -0.11099700f, -0.14638501f, 0.26656124f, 0.05614410f, 0.22266568f, 0.03364083f, -0.06301010f, -0.11837642f, 
    -0.01827185f, -0.01577342f, -0.04030347f, -0.46740636f, -0.62099183f, 0.15399076f, 0.21014604f, 0.01320561f, 
    0.05983065f, 0.09140612f, 0.07086156f, 0.08696059f, 0.45156485f, 0.03320301f, 0.07953069f, -0.02327334f, 
    -0.40967512f, 0.47480497f, -0.05335201f, 0.00465084f, 0.10936991f, -0.35229617f, 0.23591568f, 0.04585472f, 
    0.26831055f, -0.05351864f, 0.21551444f, 0.05018976f, -0.12197957f, 0.08917761f, -0.28303957f, -0.27407616f, 
    -0.03220557f, 0.09839851f, -0.04821928f, 0.05914119f, -0.01082627f, -0.08551025f, 0.05995644f, 0.23114090f, 
    0.11243813f, -0.45138061f, 0.05052055f, -0.07481155f, -0.33679098f, 0.50839853f, 0.07664681f, 0.20028391f, 
    -0.11415625f, 0.02119568f, -0.21274556f, -0.30034208f, 0.00228135f, 0.12186959f, 0.07674485f, 0.52672958f, 
    -0.13928987f, -0.31118247f, -0.02141158f, -0.11178178f, 0.26739618f, 0.26303005f, -0.04272889f, -0.77572519f, 
    -0.11955757f, -0.09704257f, 0.01015992f, 0.08624407f, 0.01993235f, 0.08873102f, -0.07940377f, 0.22750944f, 
    0.10939182f, 0.10434759f, 0.09089828f, 0.26986289f, 0.02603590f, 0.09836621f, -0.04740849f, -0.90768456f, 
    -0.17719649f, -0.21993226f, 0.00237126f, 0.12899800f, -0.08817326f, 0.10359333f, -0.32334915f, 0.12275833f, 
    0.07568783f, 0.03154450f, 0.15344374f, -0.47853449f, -0.02101053f, 0.27702007f, -0.00256776f, -0.49311736f, 
    -0.08136485f, -1.42752993f, 0.14419380f, 0.03595505f, -0.02386685f, -0.05322149f, -0.13634846f, -0.83657122f, 
    0.10941184f, 0.20251040f, 0.09988029f, 0.09388828f, 0.27173901f, -1.01223385f, 0.08826415f, -0.27143750f, 
    0.29456645f, -0.42120203f, -1.28484118f, 0.24865039f, -0.09553290f, -0.36264855f, -0.35615128f, 0.06049737f, 
    -0.00795393f, 0.04755715f, 0.10137323f, -0.01941626f, 0.25864476f, -0.35389107f, -0.05637551f, 0.00402169f, 
    0.03312540f, -0.07588282f, -0.27805769f, -0.44593614f, -0.01790526f, -0.80479169f, 0.26741859f, -0.19891426f, 
    -0.06906290f, -0.07184543f, -0.02340337f, 0.07898787f, 0.12834446f, -0.08363005f, 0.06235130f, 0.56931347f, 
    -0.83660239f, 0.21072862f, -0.03291411f, -0.91946357f, -0.03535547f, -0.21402912f, 0.22859067f, 0.09443443f, 
    0.23065950f, 0.29749012f, -0.19240648f, -0.29115111f, -0.01002410f, -0.03772773f, 0.06036817f, -0.06772882f, 
    -0.04738771f, 0.06741563f, -0.16515997f, 0.06809871f, -0.09082326f, 0.03175621f, 0.09290698f, -0.05671083f, 
    -0.61880213f, 0.15760100f, 0.06285065f, -0.10687315f, 0.38044631f, 0.36245787f, 0.10454319f, -0.32447097f, 
    0.23257805f, 0.00388326f, 0.24155991f, 0.18224855f, -0.07422369f, 0.06508115f, 0.15993403f, -0.04157151f, 
    0.04608905f, 0.03158037f, -0.06200927f, 0.10551344f, -0.50853622f, -1.13892603f, -0.02705123f, -0.11290145f, 
    -0.06610180f, -0.12128006f, 0.04744193f, 0.01622187f, 0.13264237f, -0.68653333f, -0.11768121f, -0.58319032f, 
    0.00531416f, -0.08203807f, -0.09223745f, -0.01624766f, 0.13724314f, 0.00384547f, 0.01318193f, 0.16153505f, 
    -0.08308198f, 0.16373804f, -0.14470841f, -0.31297827f, -0.01332875f, -0.73626697f, -1.02880144f, -0.11610403f, 
    -0.32346070f, -0.51972365f, -0.41186813f, 0.17932187f, -0.10346484f, 0.31840816f, -0.60612291f, 0.25754157f, 
    0.01666252f, 0.56399167f, -0.23928729f, 0.08192267f, -0.00498573f, -0.04230646f, -0.16401489f, -0.33289662f, 
    -0.03843698f, -0.01877776f, 0.05056028f, -0.13542414f, -1.03723717f, 0.08378688f, -0.03396995f, 0.05840449f, 
    -0.28961119f, 0.12089323f, 0.13393165f, 0.05717985f, -0.05070972f, 0.06637602f, -0.11930786f, -0.28985381f, 
    -0.03780574f, -0.49317595f, 0.25106105f, -0.00460473f, 0.13893321f, 0.20333697f, 0.00922782f, 0.11424530f, 
    -0.00023874f, 0.08133274f, 0.04198219f, 0.23669031f, -0.35630339f, 0.28485861f, -0.10168216f, -0.12784265f, 
    -0.01742282f, 0.00008067f, -0.08018455f, -0.09910852f, 0.47815627f, 0.00716827f, 0.01279002f, 0.11470302f, 
    0.13690056f, 0.26225066f, 0.04161721f, 0.01796344f, 0.03583245f, 0.20136619f, 0.00741892f, -0.07750678f, 
    0.45790258f, 0.05881458f, -0.11794107f, -0.59079432f, -0.10780822f, -0.32605869f, 0.32816508f, 0.00473395f, 
    -0.01884020f, -0.57193393f, 0.15389988f, -0.00376397f, -0.05077644f, 0.03456159f, -0.01244793f, -0.00715204f, 
    0.07556932f, 0.06073384f, 0.07926401f, -0.07112044f, -0.03677152f, -0.32595161f, -0.12503287f, -0.23400426f, 
    -0.93218106f, -0.07594524f, -0.69616073f, -0.75278735f, -0.05720281f, -0.18254064f, -0.13516264f, 0.22972089f, 
    0.03645836f, 0.23697989f, 0.28986356f, 0.12456959f, -0.57178676f, -0.44217741f, -0.15243202f, 0.05417063f, 
    -0.05854010f, 0.07080070f, 0.24355383f, -0.10527593f, 0.35320160f, -0.07673009f, -0.54109746f, 0.20399383f, 
    0.04326313f, -0.05941890f, -0.10387108f, -0.81614989f, -0.40907803f, 0.00176648f, -0.03748086f, -0.63262933f, 
    0.31462023f, -0.32067484f, 0.07486243f, 0.18195537f, 0.03727791f, -0.03964911f, 0.04444650f, -0.03384121f, 
    -0.19717330f, 0.18838042f, 0.21370178f, -0.22218451f, 0.03508685f, -0.03949865f, 0.08618928f, -0.18284608f, 
    -0.01117256f, -0.67095053f, -0.37891302f, -0.10545439f, 0.10267326f, -0.06717675f, 0.00095981f, 0.10183749f, 
    0.09745216f, 0.05208675f, 0.05104546f, -0.08073413f, 0.24944010f, 0.11968484f, 0.01019272f, -0.14701127f, 
    -0.08307240f, 0.30283961f, -0.73024052f, -0.25406751f, -0.01861171f, 0.10745218f, 0.03029878f, -0.00927302f, 
    0.11649764f, -0.05344348f, -0.08188311f, -0.03874767f, -0.32629699f, 0.20630258f, -0.11617177f, -0.31008568f, 
    -0.11360162f, 0.00381288f, -0.08882470f, 0.32968456f, -0.02210837f, -0.06448265f, 0.05747246f, -0.10318670f, 
    -0.07686819f, 0.07854134f, 0.00951358f, 0.28230172f, -0.06664088f, -0.00657795f, 0.05657329f, 0.24461865f, 
    0.07624501f, -0.51153255f, -0.07712502f, 0.05856573f, -0.12669709f, 0.25288635f, -0.12711111f, -0.06291442f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.15140557f, 0.03161458f, -0.02787779f, -0.27115813f, 0.15111126f, 0.12316059f, -0.00262676f, -0.28548467f, 
    -0.24423203f, -0.12367292f, 0.14860569f, 0.06067807f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
