#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34063256f, -0.26910731f, 0.04984469f, 0.09202155f, -0.17766231f, -0.23244746f, 0.31387210f, -0.13816568f, 
    0.12784813f, -0.00007784f, 0.18172064f, -0.07050700f, -0.03454508f, -0.05624335f, 0.07363227f, 0.21612327f, 
    -0.20721444f, 0.02482564f, 0.08707771f, -0.14899071f, 0.22009309f, -0.20715672f, 0.27386740f, 0.08091446f, 
    -0.28422320f, -0.29421425f, -0.05395351f, -0.51746154f, -0.45324743f, -0.32259339f, -0.21970960f, -0.05918398f, 
    -0.21911785f, 0.02157178f, -0.29746348f, 0.53377122f, -0.00511223f, 0.55186373f, 0.12784764f, -0.02874242f, 
    -0.07600046f, -0.31766415f, -0.21389504f, -0.24232113f, -0.04078752f, -0.12507589f, -0.09706438f, 0.34628937f, 
    -0.10338429f, 0.11460141f, 0.39392552f, -1.02488887f, 0.31084582f, -0.20144826f, 0.52906722f, -0.17702118f, 
    0.05251386f, -0.30016208f, 0.07559802f, 0.50259447f, -0.26129347f, 0.23305485f, -0.10530128f, -0.29672578f, 
    0.46085179f, -0.24472329f, 0.16173491f, -0.19809294f, 0.19150156f, -0.20572405f, 0.36985350f, -0.21354896f, 
    -0.13369459f, 0.09491141f, 0.14172141f, -0.61033916f, -0.39312345f, 0.27247724f, -0.48180178f, -0.63141310f, 
    0.54367685f, 0.33118358f, 0.03299423f, -0.17004006f, 0.16617586f, -0.00327804f, -0.10050694f, -0.18652441f, 
    -0.20093094f, -0.31579420f, -0.00633148f, -0.14058618f, -0.25078344f, -0.04217119f, -0.15677041f, -0.23159389f, 
    -0.10874268f, -0.18612632f, 0.03410117f, 0.11990035f, 0.30084211f, -0.01261320f, 0.02885257f, 0.32721311f, 
    0.42695892f, -0.02727054f, 0.04974170f, 0.06967398f, 0.24738808f, 0.20791635f, 0.24967884f, 0.15092017f, 
    0.14904004f, -0.07983276f, -0.07541399f, -0.16698501f, -0.28010142f, 0.10934845f, 0.01569010f, -0.16199510f, 
    -0.15103026f, 0.01939607f, 0.20419465f, 0.10784724f, -0.09100626f, 0.29796183f, -0.31694257f, -0.12847252f, 
    0.13625942f, 0.57335573f, 0.19275747f, 0.33291811f, 0.06674372f, -0.28187746f, -0.25570902f, -0.18188964f, 
    -0.15995601f, 0.17289121f, -0.26654151f, 0.37682804f, -0.20910025f, 0.16264834f, 0.05759647f, 0.02579345f, 
    -0.20389712f, 0.31207454f, -0.18526074f, -0.17287591f, -0.19518001f, -0.12240550f, -0.63349295f, -0.69038147f, 
    0.08130663f, 0.52373630f, 0.25071225f, -0.49783632f, -0.49367478f, -0.40031537f, 0.28281713f, -0.01503717f, 
    0.47582844f, -0.16376275f, 0.20339161f, 0.39968419f, 0.23616880f, -0.27634415f, 0.30852425f, -0.09750458f, 
    -0.13805427f, -0.21802489f, 0.08136768f, 0.09979399f, -0.10454988f, 0.29635420f, -0.00605354f, -0.45824906f, 
    0.18898776f, 0.25603208f, 0.06519575f, 0.27366400f, -0.33981866f, -0.12449887f, 0.14398344f, 0.13945207f, 
    -0.13107879f, -0.13982314f, -0.12655029f, 0.03468012f, 0.03295452f, 0.00425026f, 0.13970642f, 0.16992491f, 
    0.07072508f, -0.41934323f, -0.01577232f, -0.30603939f, -0.11645786f, 0.13574521f, 0.39526224f, 0.03800620f, 
    -0.56216580f, -0.19606511f, 0.15243855f, 0.35455465f, 0.32806304f, -0.06388833f, -0.24729413f, -0.12118532f, 
    0.03181754f, -0.08162604f, -0.01963141f, 0.24164526f, -0.10491423f, 0.08279365f, -0.25291872f, -0.17400742f, 
    -0.21074083f, 0.16477041f, -0.20335034f, -0.06542528f, 0.22749048f, 0.25429818f, 0.17978396f, 0.09585281f, 
    0.16457058f, 0.61096501f, -0.38859203f, -0.17976624f, -0.10697293f, -0.28098974f, 0.16376241f, 0.18030708f, 
    -0.37814265f, -0.60642475f, -0.51681137f, -0.27819872f, -0.33707294f, 0.09411162f, -0.04218575f, 0.08893526f, 
    -0.22892229f, -0.29179445f, 0.08284431f, -0.24921846f, -0.08167521f, -0.39527741f, 0.06591523f, 0.13299410f, 
    0.13643298f, -0.20575888f, 0.21537097f, 0.14241886f, 0.14474083f, -0.26739678f, -0.29802251f, 0.37766665f, 
    -0.03956646f, 0.43317416f, -0.31653371f, -0.23008399f, -0.08704827f, -0.02025353f, 0.14540996f, 0.05492669f, 
    -0.09112041f, -0.19445719f, 0.05090457f, -0.07542392f, -0.09474966f, 0.23360723f, 0.21830195f, 0.01181433f, 
    -0.35935274f, -0.08403143f, 0.23924504f, -0.19553405f, 0.41274056f, -0.18869239f, -0.05949397f, 0.10963742f, 
    -0.35036415f, -0.53848672f, 0.09106074f, 0.50190359f, -0.01141920f, -0.22561288f, -0.15662883f, -0.16719437f, 
    0.00269309f, -0.09718181f, 0.14995788f, 0.19325468f, -0.15501018f, -0.13159409f, 0.16125315f, 0.17041259f, 
    -0.08941074f, -0.03779478f, 0.09103768f, 0.18373886f, -0.65629488f, -0.12041787f, -0.28810799f, 0.38799509f, 
    0.13546835f, -0.13182607f, 0.33059835f, -0.15214764f, 0.03920628f, 0.24387491f, 0.05975079f, -0.15484525f, 
    0.19651084f, -0.04467882f, 0.20025381f, -0.33074033f, 0.11973777f, -0.01077479f, -0.16510445f, -0.35422847f, 
    0.10756629f, 0.13531111f, 0.36046284f, -0.12201834f, 0.35114160f, -0.59862375f, 0.25374341f, 0.48808992f, 
    -0.38786417f, 0.11598846f, -0.60529953f, -0.48753318f, -0.22725567f, -0.27571535f, 0.00450987f, -0.08334774f, 
    0.31456870f, -0.40925899f, 0.07906518f, -0.06231210f, 0.03311134f, 0.09910575f, 0.24313837f, -0.30573148f, 
    -0.43617913f, -0.09669575f, 0.21292360f, 0.13705140f, 0.03323490f, 0.28889373f, -0.68900049f, -0.31823203f, 
    -0.11096572f, -0.37674692f, -0.19269986f, -0.08977845f, -0.17391200f, -0.49399543f, -0.09523870f, 0.01293747f, 
    0.08078150f, -0.09040030f, -0.13426073f, -0.40098432f, -0.35883027f, -0.03125633f, -0.08493642f, -0.08582216f, 
    0.06383976f, -0.15659171f, -0.04088103f, -0.01791883f, -0.23183636f, 0.01926676f, -0.05075426f, -0.57473612f, 
    0.60903120f, 0.53608859f, -0.28818405f, 0.08016165f, -0.16654882f, -0.06546520f, 0.20303568f, 0.29173148f, 
    -0.13080649f, -0.33234772f, -0.42901379f, -0.37581545f, -0.05058116f, 0.28415835f, 0.10890365f, -0.00738002f, 
    -0.17801420f, -0.06298438f, 0.60423893f, 0.05193217f, -0.03866096f, -0.28856871f, -0.28989640f, -0.13669200f, 
    0.11019981f, 0.35639074f, -0.46726587f, -0.39192408f, -0.12796652f, 0.16328518f, -0.12923869f, 0.00478737f, 
    -0.16156998f, -0.23270130f, 0.25146013f, -0.02722083f, -0.14851914f, -0.01318636f, 0.04190495f, 0.17838299f, 
    -0.27612296f, -0.27148458f, -0.29474974f, -0.00737756f, 0.19216444f, 0.19438295f, 0.18408078f, 0.14612500f, 
    0.36760998f, -0.10370831f, 0.34086215f, 0.37431324f, 0.51777917f, 0.31216809f, 0.13282321f, -0.31521955f, 
    -0.48183411f, -0.31733483f, -0.26627353f, -0.04680230f, -0.11720870f, 0.01202790f, 0.21636163f, 0.09578412f, 
    0.07231497f, 0.03915615f, -0.17948285f, 0.16660582f, -0.11021730f, 0.06155453f, -0.21277966f, -0.05324109f, 
    -0.02813184f, 0.08866798f, 0.16519649f, -0.02018513f, 0.20034650f, 0.15763496f, -0.50384897f, -0.54937321f, 
    -0.57189631f, -0.25147283f, -0.50101000f, -0.58290446f, 0.22395790f, -0.14867605f, -0.16500100f, 0.62581599f, 
    0.11127927f, -0.26812944f, -0.16021006f, 0.08559015f, -0.08921233f, -0.06310371f, 0.19607425f, 0.16683435f, 
    -0.02402165f, -0.34893116f, -0.28332701f, 0.00344902f, -0.57693750f, -0.63684881f, 0.11341283f, 0.01869979f, 
    -0.17410976f, -0.01573267f, 0.03395510f, -0.23274383f, 0.23722519f, -0.05945078f, 0.40636003f, 0.23017733f, 
    -0.18533409f, -0.09194490f, -0.17814676f, 0.21169005f, -0.15026475f, -0.22837774f, 0.21057574f, -0.34281319f, 
    0.15116364f, -0.03532262f, -0.33044475f, -0.30618176f, 0.01809393f, 0.02808893f, -0.36832339f, 0.42710224f, 
    -0.42181638f, 0.27738556f, -0.19705532f, -0.13189399f, -0.00618682f, 0.24460834f, -0.10473187f, -0.41944996f, 
    -0.20970689f, 0.50102979f, -0.08129827f, -0.15199356f, -0.29806399f, 0.19031066f, 0.36503699f, -0.14010729f, 
    -0.33887801f, 0.15397581f, 0.10829124f, 0.05462509f, -0.01015368f, 0.54907542f, -0.51914781f, -0.13425064f, 
    0.27807301f, -0.60524505f, -0.19400108f, -0.44743499f, -0.55742115f, -0.40480223f, -0.61108124f, 0.71005058f, 
    -0.06396349f, 0.05691213f, 0.13116603f, 0.10351671f, -0.13030902f, 0.09963940f, -0.01800543f, 0.08084366f, 
    -0.26343280f, -0.26576078f, 0.10447719f, 0.26110831f, -0.02852188f, 0.04994153f, 0.18053944f, -0.88196653f, 
    -0.26358861f, 0.49966532f, -0.05483690f, 0.12360623f, 0.40433258f, 0.21839090f, -0.05549623f, -0.16462515f, 
    0.48415667f, -0.45502669f, -0.22262539f, 0.08216031f, 0.20716383f, -0.31373620f, 0.05869232f, 0.14487924f, 
    0.00284991f, -0.07323284f, 0.07674920f, -0.06594964f, -0.10901847f, 0.28488603f, 0.03659395f, -0.18844602f, 
    0.54569620f, 0.53603643f, -0.48498452f, -0.59058344f, 0.33745617f, 0.16619632f, -0.11360284f, -0.20439585f, 
    -0.51720589f, 0.16547270f, 0.29975823f, 0.06783391f, 0.46567878f, -0.31352755f, 0.10810822f, -0.24243549f, 
    -0.22198607f, -0.23359354f, 0.26864123f, -0.18897362f, 0.11955697f, -0.06456089f, 0.15098168f, 0.11766448f, 
    0.22709736f, 0.22413453f, 0.12177325f, 0.04273577f, -0.02275086f, 0.05108694f, -0.24290529f, -0.08183975f, 
    0.33707935f, 0.07327773f, 0.26166722f, -0.20300116f, 0.03462532f, 0.23463392f, 0.15642391f, 0.00735587f, 
    -0.02714596f, -0.08650418f, -0.03955266f, -0.14072625f, 0.11726852f, 0.12331096f, -0.12374243f, 0.20624708f, 
    0.06841794f, -0.74268991f, -0.30569679f, -0.14378144f, -0.26912183f, -0.23220997f, 0.19788143f, 0.37734362f, 
    0.38211045f, 0.49220631f, 0.15041845f, -0.34608406f, -0.17097276f, 0.04977741f, 0.15385620f, 0.01813766f, 
    -0.10553409f, -0.26546052f, -0.24899915f, 0.15300319f, 0.11536058f, 0.21254632f, 0.09162360f, 0.31096193f, 
    0.30496478f, -0.34452543f, 0.43948391f, 0.25432569f, 0.11784799f, 0.32212865f, 0.19307278f, -0.08195876f, 
    -0.00997387f, -0.16480708f, -0.03961783f, 0.21153432f, -0.06454813f, 0.20104913f, -0.42591304f, -0.35145998f, 
    0.04799601f, 0.15171473f, 0.27887362f, -0.01066322f, 0.05977492f, -0.01274544f, 0.07753281f, -0.30308610f, 
    -0.16741219f, -0.23266098f, -0.33607653f, 1.09692717f, -0.78683066f, -0.68069547f, -0.52735054f, -0.52188939f, 
    0.48764655f, 0.41653359f, 0.43804070f, 0.11291001f, 0.16437298f, -0.07116721f, 0.20634067f, -0.11444655f, 
    -0.04121035f, 0.25848481f, -0.01580702f, -0.25616819f, 0.02777099f, 0.12772867f, -0.29065019f, 0.01242016f, 
    -0.12610753f, -0.09571540f, -0.17273100f, 0.01700089f, -0.28635943f, -0.31406561f, -0.44225380f, -0.46211627f, 
    -0.17199941f, -0.07332863f, -0.10842115f, -0.26165611f, -0.18762141f, 0.43763962f, 0.11951467f, -0.10619070f, 
    -0.10021887f, -0.09737393f, -0.35208359f, 0.04261110f, 0.06246211f, -0.12917775f, 0.11755224f, 0.02773450f, 
    -0.07984384f, -0.13048539f, -0.22444320f, -0.12311418f, -0.25438949f, 0.66433746f, 0.99104369f, 0.02928824f, 
    -0.26815322f, -0.32490808f, -0.20079391f, -0.38957933f, -0.10824539f, -0.22925614f, -0.65235865f, -0.22404638f, 
    -0.15997380f, 0.02219070f, 0.32604182f, -0.33144292f, 0.11814819f, 0.12336300f, 0.24568829f, -0.02566563f, 
    -0.21479739f, -0.37140471f, -0.02060450f, -0.02564315f, 0.06461393f, 0.13697597f, -0.24762961f, 0.06562259f, 
    0.33699575f, 0.09726617f, 0.09184974f, -0.19044174f, -0.27125284f, 0.15562028f, 0.06851610f, 0.22725289f, 
    -0.32867858f, -0.13857746f, 0.19193436f, -0.27527088f, 0.09341111f, 0.20107089f, -0.05418853f, -0.31736594f, 
    0.10065450f, 0.39103338f, -0.36775661f, 0.21531956f, -0.16805615f, -0.12041258f, -0.25965834f, -0.73882473f, 
    0.23975658f, -0.26946002f, -0.75636953f, -0.65053737f, 0.21350464f, -0.06975370f, 0.47839430f, 0.06423706f, 
    -0.02575157f, -0.24142770f, -0.21785071f, -0.12047107f, -0.58291405f, 0.13793583f, 0.26327375f, -0.10444693f, 
    0.18131647f, 0.22976211f, 0.10203942f, -0.05911574f, 0.32313871f, -0.06270742f, -0.07781255f, 0.21737981f, 
    -1.21860576f, -0.72901362f, -0.12501200f, 0.59178263f, 0.85046208f, 0.02127900f, 0.50704992f, -0.16082670f, 
    0.21946661f, 0.18108678f, 0.21634762f, -0.18449315f, 0.09649650f, -0.30489051f, -0.32576749f, 0.12969172f, 
    0.18137245f, 0.10131651f, -0.18768208f, -0.11875012f, 0.06018746f, -0.10949115f, -0.02333414f, -0.12720175f, 
    -0.03628937f, 0.37300438f, 0.13085002f, 0.33470300f, 0.09714825f, -0.04975677f, 0.23978789f, 0.05159949f, 
    0.20023873f, 0.02033566f, -0.15064557f, 0.18374611f, 0.13365430f, -0.15983789f, -0.31959191f, 0.10410502f, 
    -0.21222515f, -0.19768375f, 0.16205363f, 0.11997055f, -0.03833710f, -0.11516351f, 0.11533649f, -0.06206878f, 
    -0.21998696f, -0.33189037f, 0.90217507f, 0.20028313f, -0.18038790f, -0.40299875f, -0.68345946f, 0.25724134f, 
    -0.11646251f, 0.05817844f, 0.02644442f, -0.32718030f, 0.23880242f, -0.02395800f, 0.02458753f, -0.28193063f, 
    -0.20163202f, 0.21140642f, -0.00450456f, -0.20918365f, -0.20015515f, -0.33738354f, -0.35414022f, -0.21102382f, 
    -0.26534045f, -0.22101419f, -0.54093051f, 0.08016858f, 0.15710221f, -0.05548695f, 0.15310547f, 0.01069300f, 
    0.19103213f, 0.01231624f, 0.17773643f, 0.05779660f, 0.05399817f, 0.21603310f, -0.01495525f, -0.45686746f, 
    -0.33177665f, 0.38705564f, -0.20260014f, 0.24613059f, -0.08206451f, -0.11154398f, 0.02754221f, 0.28436804f, 
    -0.03975629f, -0.05434202f, -0.22671849f, -0.04098116f, 0.59983402f, 0.21549618f, -0.09226962f, -0.29772329f, 
    0.04125427f, 0.26127729f, -0.16877432f, -0.18168595f, 0.19702470f, 0.02088927f, -0.02502769f, 0.38572040f, 
    -0.29373538f, -0.12389092f, 0.13005854f, -0.30104777f, -0.18461096f, 0.31883919f, -0.03217877f, -0.09352247f, 
    -0.03903314f, 0.31955957f, 0.02582944f, -0.11537522f, -0.21822852f, -0.51689476f, -0.35313827f, -0.16065261f, 
    0.10165858f, -0.22102961f, -0.42348275f, -0.39793414f, -0.44469959f, -0.22065362f, 0.01408675f, -0.02431864f, 
    -0.17563967f, -0.24084805f, -0.39019465f, -0.00109776f, -0.07331892f, -0.12981361f, -0.12870151f, 0.05066660f, 
    -0.06683266f, 0.10708674f, -0.13637741f, -0.24079594f, 0.01032953f, 0.25848106f, 0.17805058f, 0.28533682f, 
    -0.49261114f, -0.50968456f, -0.00683574f, 0.55973136f, 0.10213745f, 0.19218199f, -0.49528703f, -0.00818294f, 
    -0.14363138f, 0.34844425f, 0.06008941f, -0.06473477f, -0.24330051f, -0.37968507f, 0.02073585f, 0.06977344f, 
    0.23600461f, 0.01892359f, 0.29674333f, -0.09503419f, -0.33852956f, -0.04629368f, -0.27926841f, -0.76051253f, 
    -0.34673434f, -0.54739523f, -0.20652594f, -0.32712024f, 0.41766447f, 0.23494078f, 0.21555325f, 0.17550445f, 
    0.31568313f, 0.11476520f, -0.29675707f, -0.49026924f, -0.29253712f, -0.20982894f, 0.16545127f, -0.02805318f, 
    0.04873620f, 0.13076957f, -0.24854599f, -0.19032535f, -0.23691931f, -0.31361613f, -0.27910736f, -0.37419730f, 
    -0.71317643f, -0.68677735f, -0.33741495f, 0.22495852f, 0.44401458f, 0.55026311f, 0.21558055f, -0.44734639f, 
    0.09900148f, 0.14827824f, -0.28275728f, -0.01542053f, 0.32004464f, 0.11485174f, -0.03120789f, -0.07415035f, 
    -0.12688199f, -0.00927200f, 0.15518084f, -0.13822097f, -0.01413349f, -0.04743705f, -0.09032211f, 0.40266985f, 
    0.35362676f, 0.68389279f, -0.42864645f, -0.58171093f, -0.41397402f, -0.74373293f, 0.55785090f, 0.00384898f, 
    0.04637554f, 0.35993057f, 0.12636557f, -0.35213047f, 0.01998505f, -0.09333233f, 0.04120214f, 0.22320580f, 
    0.07694561f, 0.27927268f, 0.08775073f, -0.18955761f, -0.02102402f, 0.06168872f, -0.03903205f, 0.13153355f, 
    -0.17486468f, 0.11156338f, 0.23400910f, 0.24866474f, 0.26217055f, -0.19537240f, -0.36440682f, 0.66092378f, 
    -0.15964055f, -0.17014322f, -0.21174005f, -0.14675489f, 0.02681960f, 0.22287039f, -0.00528505f, -0.20464590f, 
    0.15715773f, -0.17251387f, -0.26561007f, 0.14147606f, 0.30075720f, -0.11490990f, 0.12112070f, 0.24857347f, 
    0.11220139f, -0.21534728f, -0.20951635f, -0.22832984f, 0.25054681f, 0.19902749f, -0.46663964f, 0.28764370f, 
    -0.23247068f, -0.19737585f, -0.14613350f, -0.09212977f, -0.29847464f, 0.50495517f, -0.61164564f, 0.35770565f, 
    -0.23802650f, -0.19951519f, 0.30321428f, 0.09309757f, -0.18380171f, -0.08973028f, 0.10962742f, -0.17217039f, 
    -0.07212815f, -0.02733035f, 0.23824865f, 0.24994567f, 0.02110399f, 0.80147940f, 0.77620167f, -0.43743935f, 
    -0.60739565f, -0.53559828f, -0.00704874f, -0.25634876f, -0.14430816f, 0.31567901f, 0.18210569f, 0.12300750f, 
    -0.01303707f, -0.34737030f, 0.06516561f, 0.02026810f, -0.11233721f, 0.31252217f, 0.01121269f, -0.36773533f, 
    -0.05148295f, -0.11669082f, -0.36555886f, -0.19006389f, 0.20867628f, -0.63834798f, 0.03540556f, 0.24442983f, 
    0.65094578f, 0.00412409f, 0.66676468f, -0.04214234f, -0.71085906f, -0.40138853f, 0.15664443f, -0.12699242f, 
    -0.13148464f, -0.25982067f, 0.00070344f, 0.12616569f, -0.15176834f, -0.02303235f, 0.16121964f, 0.13835442f, 
    0.10308149f, -0.03359157f, 0.09341260f, -0.17085674f, 0.13587239f, -0.06572562f, -0.40987787f, -0.07743011f, 
    -0.53303939f, 0.01492504f, 0.13035946f, 0.31424743f, -0.13919438f, -0.65463954f, -0.58708096f, 0.47261646f, 
    0.19080222f, 0.05113924f, 0.19685702f, 0.38466612f, -0.06052579f, 0.23333189f, 0.13502914f, -0.29549560f, 
    0.01412079f, -0.42394724f, 0.02804111f, -0.14890221f, 0.13568607f, -0.11503953f, -0.23247537f, -0.26490331f, 
    -0.04305876f, -0.26120156f, -0.23899019f, 0.48816454f, 0.04462010f, -0.41403455f, 0.17462361f, 0.08683462f, 
    -0.50110352f, -0.37087667f, 0.29842290f, -0.35425064f, 0.44220597f, -0.44267830f, -0.26619533f, -0.06421685f, 
    -0.19464518f, 0.03927030f, -0.07540748f, -0.22529961f, 0.31127152f, -0.02315541f, -0.40211219f, -0.08552770f, 
    -0.46309426f, -0.65915465f, -0.05068173f, 0.91703808f, 0.54585004f, -0.35979009f, 0.45668399f, -0.63907498f, 
    -0.52246684f, -0.38024691f, 0.18645225f, -0.06972079f, -0.02189225f, 0.34724137f, 0.09826211f, 0.23174392f, 
    -0.37840554f, -0.10574493f, 0.19019118f, 0.06378760f, -0.23851900f, -0.09731632f, 0.15154801f, -0.05885932f, 
    -0.20746866f, 0.40276378f, -0.48318076f, -0.33045891f, 0.05325161f, -0.64201999f, -0.48598471f, -0.09001080f, 
    -0.10866021f, -0.45424366f, -0.39682668f, -0.07817545f, 0.17974690f, 0.00456386f, -0.42930514f, -0.32872781f, 
    0.02355617f, 0.06881648f, -0.10415788f, -0.17241308f, 0.10050087f, -0.09307323f, 0.14952293f, -0.05315300f, 
    -0.07252791f, -0.07150153f, 0.58983850f, 0.76520842f, 0.69172764f, -0.79125232f, -0.98545986f, -0.22347027f, 
    0.05345410f, -0.13092853f, 0.08326422f, -0.26563588f, 0.06324960f, -0.01780069f, 0.26142994f, 0.10755200f, 
    0.26307929f, 0.26470080f, -0.16648676f, 0.08818911f, -0.14184763f, -0.15322855f, 0.04799202f, -0.11718307f, 
    0.18329901f, 0.04094541f, -0.06109744f, -0.90756661f, -0.29023263f, -0.04300518f, -0.10750376f, -0.32011679f, 
    -0.31040257f, -0.31165382f, -0.14088647f, 0.33601573f, 0.36816284f, 0.01859266f, -0.41948232f, -0.33769813f, 
    -0.30045041f, 0.01355471f, -0.10452181f, -0.13925911f, -0.35046193f, -0.37892112f, -0.41391841f, -0.22123864f, 
    0.03448397f, -0.10060547f, -0.14053315f, 0.00906328f, 0.39439008f, -0.29684216f, -0.48472637f, -0.14676464f, 
    -0.81202382f, 0.23162915f, 0.03516075f, -0.08519222f, -0.37478212f, 0.05720000f, -0.27153119f, -0.17868514f, 
    -0.27101463f, -0.18761167f, 0.30979010f, 0.13974650f, 0.10553505f, -0.04072879f, -0.25970998f, 0.04305765f, 
    -0.50646061f, -0.09903169f, -0.13979489f, 0.17263693f, 0.00434929f, -0.73623723f, 0.50585133f, -0.46163633f, 
    -0.41713256f, 0.41400909f, -0.20942624f, 0.26284620f, 0.73012000f, -0.11120222f, -0.18957356f, 0.05066818f, 
    0.18886162f, -0.18429869f, 0.18704830f, -0.39445212f, -0.01895958f, 0.31976515f, -0.28548932f, 0.10949596f, 
    0.19360282f, 0.04670773f, -0.22886178f, 0.01256883f, 0.08138055f, -0.10310128f, -0.07108115f, -0.17695832f, 
    -0.33184361f, -0.38697383f, -0.27083346f, -0.02231834f, -0.49360916f, -0.23224756f, -0.39334255f, -0.51257038f, 
    0.35421121f, 0.03837442f, 0.20537587f, 0.12516776f, 0.23270293f, 0.23637272f, 0.22389609f, 0.06853607f, 
    0.17587774f, 0.03212008f, -0.09074421f, -0.02392296f, 0.19838519f, -0.06375373f, -0.21149847f, -0.46619651f, 
    0.32641622f, -0.20866124f, -0.38313937f, -0.40482712f, 0.31851250f, -0.14128691f, -0.04944262f, 0.15221217f, 
    0.02195744f, 0.22998579f, -0.06789377f, -0.07713988f, 0.26975903f, -0.27035397f, 0.10512002f, -0.21090649f, 
    -0.57476085f, -0.37760600f, -0.37817198f, 0.20880459f, 0.43713084f, 0.21626610f, 0.15380758f, -0.13029829f, 
    0.01240025f, -0.64264667f, -0.37963131f, -0.40572909f, 0.31951860f, 0.10072598f, 0.06588018f, -0.11403967f, 
    0.01956537f, 0.15280430f, -0.21518315f, 0.28689486f, 0.16519856f, -0.18964134f, 0.05979577f, -0.26335034f, 
    0.34969386f, -0.25669929f, -0.33339158f, -0.32362509f, 0.28378338f, 0.40093023f, 0.35432026f, -0.15625761f, 
    -0.11298089f, -0.50897700f, -0.19285443f, -0.35288671f, -0.09105337f, -0.07686084f, 0.32184812f, 0.26269126f, 
    -0.02696156f, 0.36515692f, 0.25176185f, 0.02291217f, -0.10163737f, -0.10599471f, 0.17676929f, -0.14266406f, 
    -0.05601818f, 0.09125909f, -0.29441872f, 0.15082476f, 0.18803275f, 0.17087880f, 0.02762084f, 0.06764530f, 
    0.20060702f, 0.05808146f, -0.39813533f, 0.03974881f, 0.26989135f, 0.40668541f, 0.24310060f, -0.23126099f, 
    -0.13065842f, 0.31397402f, 0.31761238f, 0.26114482f, 0.13446893f, 0.16950314f, 0.13349003f, -0.15354374f, 
    -0.27436623f, 0.00871963f, 0.02325821f, -0.18197031f, -0.10086378f, -0.17611471f, 0.18938918f, 0.09612051f, 
    -0.03590856f, 0.20307688f, -0.07037748f, -0.30219629f, 0.16968630f, 0.31655461f, -0.21445291f, 0.09137719f, 
    -0.75828868f, -0.57676911f, -0.18321435f, -0.15395264f, -0.20492820f, 0.40132111f, -0.06069819f, -0.13736150f, 
    0.27210566f, -0.23623858f, 0.01886044f, -0.41123155f, -0.08631988f, -0.41284117f, -0.45365661f, -0.23638307f, 
    0.00522485f, -0.24795914f, -0.42734331f, -0.54851878f, -0.56829703f, -0.60157233f, -0.84102076f, -0.27178350f, 
    -0.06061368f, 0.32137832f, 0.36240208f, -0.12008239f, -0.33347037f, 0.30030081f, 0.62508082f, 0.28722760f, 
    0.43102890f, -0.20804374f, 0.06770239f, -0.14042801f, -0.29783961f, -0.04685958f, 0.04903781f, 0.10316743f, 
    -0.22247185f, -0.10240012f, 0.30793294f, 0.17424911f, 0.11294626f, -0.19109872f, 0.25528687f, -0.32098323f, 
    -0.63748378f, -0.53396183f, -0.13667341f, 0.02656215f, 0.30094427f, -0.01523937f, 0.19287461f, -0.14637686f, 
    -0.06550322f, -0.21479116f, 0.15352909f, 0.15474324f, 0.44660717f, 0.13525966f, -0.24958134f, -0.22116898f, 
    0.06435886f, -0.11040939f, -0.10113232f, -0.08463244f, -0.33468699f, -0.37170923f, -1.02071643f, 0.07683831f, 
    -0.50478405f, 0.05992348f, 0.43796369f, 0.25934073f, 0.46679464f, 0.18750298f, -0.22130033f, 0.21560456f, 
    0.34121245f, -0.04666571f, 0.02496268f, -0.07836747f, 0.17438734f, 0.16907981f, -0.11088683f, -0.31575462f, 
    -0.16467914f, 0.14332075f, 0.24206077f, 0.16567205f, 0.10653479f, -0.11638356f, 0.01844114f, -0.00959197f, 
    0.32759422f, -0.31032604f, -0.28210163f, 0.24579266f, 0.36049110f, -0.15445107f, 0.34761503f, 0.34590912f, 
    0.05123005f, -0.29972115f, -0.26224077f, 0.05231143f, 0.27636108f, -0.31030110f, 0.10044256f, 0.05090883f, 
    -0.34940326f, -0.00738900f, -0.02755747f, 0.04774138f, 0.17741591f, 0.08090787f, 0.14636317f, -0.19036406f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12098756f, 0.12452254f, 0.16201435f, -0.10902806f, 0.02389268f, 0.13310567f, 0.12664838f, 0.20577972f, 
    0.12485125f, -0.24433027f, 0.25585306f, 0.02527399f, -0.07613200f, 0.31649074f, -0.14421836f, 0.11988036f, 
    0.07082112f, -0.03026767f, -0.07664404f, 0.10077718f, 0.08457318f, 0.00669413f, 0.21474071f, 0.09001819f, 
    -0.10171182f, -0.08314166f, -0.07852075f, 0.14361981f, -0.12831978f, 0.12116074f, 0.01119350f, -0.14220314f, 
    0.18315278f, -0.17628467f, 0.06462852f, 0.13784708f, 0.15086824f, -0.38605770f, -0.01800251f, -0.08559708f, 
    0.18411559f, 0.27861851f, 0.04119598f, 0.19889802f, 0.02453941f, 0.12436032f, 0.03660155f, -0.00915308f, 
    0.11657511f, -0.26512793f, 0.27978724f, -0.32940516f, -0.26287052f, 0.10850714f, -0.18520269f, 0.18165940f, 
    0.06127615f, -0.24735017f, -0.02649885f, -0.18532231f, 0.33799106f, -0.14776200f, 0.12961957f, -0.14629154f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02057532f, 0.01031831f, -0.08760838f, -0.06374338f, -0.08863702f, 0.18778838f, -0.06147498f, -0.06049969f, 
    0.10227017f, 0.10458434f, 0.07143775f, 0.06482381f, -0.23612152f, -0.02939017f, 0.06889636f, 0.11632268f, 
    -0.02092103f, -0.05807941f, -0.02250877f, 0.06228476f, -0.05494371f, 0.02383876f, 0.06746099f, 0.05024563f, 
    -0.07899500f, 0.09728526f, -0.12945688f, 0.26701397f, -0.06406762f, 0.02444694f, 0.08155484f, 0.15844573f, 
    0.08714908f, -0.01425877f, 0.05557049f, 0.06661594f, 0.26394719f, -0.03510053f, 0.31476060f, 0.15983358f, 
    0.00498865f, -0.00368822f, 0.06060930f, -0.04370410f, 0.02777392f, 0.05171629f, 0.01212686f, -0.08647674f, 
    -0.05538287f, -0.01837568f, -0.08474354f, -0.00701469f, -0.05112073f, -0.01498500f, 0.00138912f, -0.01433520f, 
    0.00222706f, 0.04898338f, -0.09792726f, -0.12312540f, 0.05993550f, -0.00736978f, 0.01400756f, 0.08404029f, 
    -0.01670096f, 0.03913188f, 0.01958979f, 0.03965233f, 0.01741624f, -0.01519892f, -0.04882414f, 0.08384243f, 
    -0.59685028f, -0.06295103f, -0.20750222f, 0.07952540f, -0.03730745f, -0.27414632f, -0.09506819f, 0.00004915f, 
    -0.11182404f, -0.01246693f, 0.04431469f, 0.00723065f, 0.00876515f, -0.04347750f, -0.12578560f, -0.04317464f, 
    -0.01828069f, 0.04525062f, -0.01349304f, 0.03749447f, -0.00981345f, 0.02473759f, -0.07155997f, 0.08161931f, 
    -0.23383795f, -0.04512146f, -0.26627037f, 0.15234628f, 0.07680649f, -0.05354368f, -0.05374740f, 0.05619900f, 
    0.05601285f, 0.02772259f, 0.03405635f, 0.04778377f, -0.18621717f, -0.21954994f, 0.20786391f, 0.07476359f, 
    -0.00598812f, -0.06756239f, -0.08818355f, -0.07333124f, 0.07265990f, 0.07115223f, -0.00339081f, 0.02615562f, 
    0.11831612f, 0.11340477f, 0.20801169f, -0.20133393f, 0.08020250f, -0.09842664f, 0.17750995f, -0.06215385f, 
    0.24491861f, 0.04459906f, 0.04054288f, 0.19339824f, -0.12432440f, 0.01865179f, -0.21297400f, 0.01925484f, 
    0.02116407f, 0.12504931f, 0.13887842f, 0.04770882f, -0.01212765f, 0.03164633f, 0.06522603f, -0.00581290f, 
    -0.32198742f, -0.07713000f, 0.08996268f, 0.01437570f, 0.01657276f, -0.00092948f, 0.09051154f, 0.07907570f, 
    0.04302569f, 0.21333985f, 0.14260745f, 0.11804033f, -0.07494994f, -0.29011554f, -0.31765288f, -0.05294951f, 
    0.00136757f, -0.11722204f, -0.03493397f, -0.01098550f, 0.03784522f, 0.06650501f, -0.04084499f, 0.06555316f, 
    -0.03791624f, -0.05523786f, 0.05309867f, 0.16169398f, -0.07415655f, -0.00424585f, -0.07990357f, -0.04316809f, 
    0.00228233f, 0.06921994f, 0.00403867f, -0.06099522f, 0.08134652f, 0.08224492f, -0.07900251f, 0.07542251f, 
    -0.02650094f, 0.02009282f, 0.13625328f, -0.14624481f, 0.05610004f, -0.06288910f, 0.15033340f, -0.07307076f, 
    0.05956773f, -0.08256081f, 0.07793450f, -0.14917286f, 0.08528165f, -0.07182412f, 0.19681783f, 0.12602103f, 
    0.08279743f, 0.02030611f, 0.09735073f, 0.01078849f, -0.12135126f, -0.05146825f, -0.25332734f, 0.00930552f, 
    0.06478693f, 0.08416405f, -0.04066844f, -0.00809106f, -0.02141411f, -0.02162533f, -0.06799205f, -0.06259993f, 
    -0.25722709f, -0.28278348f, -0.22476266f, -0.16139005f, 0.13090612f, -0.00232681f, -0.07923386f, -0.24606352f, 
    -0.00632037f, -0.02053853f, 0.00601227f, 0.10588883f, -0.16455582f, 0.17803456f, 0.04097402f, 0.12193189f, 
    -0.06366843f, 0.09432035f, 0.04944877f, 0.08419070f, 0.04188192f, 0.06583054f, -0.03188241f, 0.11924262f, 
    -0.12998113f, 0.32119602f, -0.10949396f, 0.06198784f, 0.05394259f, 0.06434755f, 0.04178291f, 0.10124560f, 
    0.11263037f, 0.06943463f, -0.00785834f, -0.01257645f, -0.40463036f, -0.10370808f, -0.14812391f, 0.02233549f, 
    -0.00092925f, 0.03070745f, -0.07369383f, -0.10040866f, 0.02519316f, 0.01959645f, 0.00976538f, 0.05891210f, 
    -0.35765517f, 0.40497974f, 0.13478370f, 0.07780586f, 0.09108008f, 0.10713610f, -0.07911415f, 0.08409039f, 
    0.29235706f, -0.04143701f, 0.29283419f, 0.05292617f, 0.04400217f, -0.13588990f, 0.39686045f, -0.20069531f, 
    0.05234683f, -0.17946808f, 0.11245757f, -0.07292817f, 0.24766582f, 0.00449808f, 0.00913975f, 0.10446274f, 
    0.03952732f, -0.04815078f, -0.15664403f, -0.05140917f, -0.04783466f, -0.02751760f, -0.01541113f, -0.11248928f, 
    0.02587949f, 0.01643347f, 0.00631852f, -0.04716203f, -0.17000380f, 0.11565177f, 0.04850917f, 0.09193946f, 
    -0.11465044f, 0.04734286f, -0.10720140f, 0.03619458f, 0.07868472f, 0.03267547f, 0.07465443f, 0.19135296f, 
    0.01425353f, -0.10281563f, -0.09125059f, -0.07545254f, -0.08596157f, 0.01466930f, 0.00267306f, -0.03136103f, 
    -0.16473554f, -0.15434287f, -0.05440607f, -0.11366123f, 0.25559315f, 0.44859496f, 0.13147365f, -0.07955722f, 
    -0.06409401f, -0.03070552f, 0.00362637f, -0.07141475f, 0.07668466f, 0.07987214f, 0.18399729f, 0.17872798f, 
    -0.02988540f, -0.10438298f, -0.06753191f, 0.11345722f, -0.16461618f, -0.05998818f, 0.06159579f, 0.00645398f, 
    0.03879880f, 0.07538681f, 0.00520115f, -0.13647638f, 0.08086699f, -0.29451305f, -0.10627128f, -0.43590361f, 
    -0.12460475f, -0.04059320f, 0.23329920f, -0.20305365f, 0.03174465f, 0.05440209f, -0.08494453f, 0.09476301f, 
    0.04751610f, 0.00548234f, -0.07466779f, -0.05690588f, -0.04818193f, 0.10684548f, -0.02297822f, 0.06418537f, 
    0.04072222f, -0.00974242f, 0.12942888f, 0.01513313f, -0.14501016f, 0.02339965f, 0.06639954f, 0.24159966f, 
    0.00803796f, 0.10216379f, 0.07657441f, -0.07341437f, -0.02308920f, 0.02368347f, -0.00171315f, -0.02663580f, 
    -0.03937993f, -0.02494979f, 0.25168779f, 0.27851325f, -0.02570109f, -0.03535987f, -0.01997154f, 0.06785724f, 
    0.09457386f, 0.04157397f, 0.03277178f, 0.02375265f, 0.04291067f, -0.02066285f, -0.03977563f, -0.09904390f, 
    -0.04681587f, -0.04722483f, 0.01097374f, -0.02812846f, -0.02042631f, -0.06002068f, -0.08700080f, -0.03258069f, 
    0.16641073f, 0.19176428f, 0.18228993f, -0.11335743f, 0.03684191f, -0.00189459f, 0.02155814f, 0.02562714f, 
    0.00032252f, 0.22071579f, 0.06003594f, -0.02644974f, 0.11323645f, -0.01818425f, 0.01967272f, 0.00177278f, 
    -0.00385412f, -0.03773491f, -0.01790273f, -0.09746414f, 0.17912942f, -0.03429295f, -0.02099690f, 0.00156653f, 
    0.22451375f, 0.10811427f, 0.16643339f, 0.05110634f, -0.01165436f, 0.00561752f, -0.00259249f, 0.00039248f, 
    0.04902899f, 0.08361532f, -0.06264318f, 0.08290071f, -0.16937867f, -0.07819267f, -0.20722540f, 0.02728311f, 
    -0.14545478f, -0.05006554f, -0.03793116f, -0.10102145f, -0.00348721f, -0.00672180f, 0.05400746f, -0.02328355f, 
    0.18344821f, -0.09993272f, 0.25124291f, -0.07894669f, 0.05398190f, -0.01645484f, 0.18352887f, -0.11801069f, 
    0.00275445f, 0.15345234f, -0.11942180f, 0.16813120f, -0.07387125f, 0.10482851f, 0.22522080f, 0.22319229f, 
    -0.02998268f, 0.05043563f, -0.01549564f, -0.05526498f, 0.03054018f, 0.11043657f, 0.04323818f, -0.12916502f, 
    -0.28817508f, 0.01062299f, 0.13891144f, 0.21429527f, 0.04631238f, -0.18898667f, 0.05354545f, 0.26521021f, 
    0.06476057f, 0.12797563f, 0.02937361f, 0.08739854f, 0.35010409f, 0.42439288f, -0.05492122f, -0.04946788f, 
    0.02813507f, 0.16362996f, 0.15466072f, 0.07022805f, 0.09534682f, 0.02939454f, 0.02643360f, -0.03308615f, 
    0.03593804f, -0.12715617f, 0.04532117f, -0.03271944f, 0.06977511f, 0.01696850f, 0.01920374f, 0.03885561f, 
    0.11232477f, 0.03447910f, -0.02740728f, 0.08644378f, 0.04309535f, -0.24142632f, -0.17920950f, 0.03515929f, 
    -0.13875514f, -0.07948709f, 0.19211721f, -0.01620466f, -0.05201795f, 0.10003022f, 0.04615350f, 0.04506438f, 
    0.38573757f, -0.13429728f, 0.23759988f, -0.36697161f, 0.00421576f, -0.00820991f, 0.24884325f, 0.05268419f, 
    0.04761579f, 0.04793875f, -0.08808409f, -0.10247869f, -0.16407521f, -0.09662407f, -0.14301248f, 0.32059908f, 
    0.15133913f, 0.25026730f, -0.10621066f, 0.12588540f, 0.03719836f, 0.06657197f, 0.07958446f, 0.01966598f, 
    -0.07463320f, -0.25473282f, 0.07267102f, 0.17743893f, 0.15916349f, -0.05133165f, 0.01479967f, 0.07868936f, 
    -0.08837548f, 0.07624875f, 0.06385881f, -0.02491803f, -0.11244179f, 0.14149769f, -0.12627351f, 0.21805149f, 
    0.00892477f, -0.00528557f, 0.14025368f, 0.00599976f, -0.02277405f, 0.10237776f, 0.09626769f, 0.13356285f, 
    -0.46628705f, -0.12251051f, -0.16513032f, 0.19026048f, 0.01264296f, 0.18966183f, 0.02042328f, 0.21692580f, 
    -0.02673014f, 0.00755318f, 0.12027061f, -0.02151177f, -0.12073328f, -0.11399554f, -0.20865694f, 0.01453039f, 
    -0.29969743f, 0.04719243f, -0.13384911f, -0.27784982f, 0.01730806f, 0.04042080f, -0.06642499f, 0.00137001f, 
    0.40604064f, -0.03881900f, 0.18021578f, -0.15169734f, 0.00882607f, -0.09732070f, 0.08485580f, -0.04752487f, 
    0.12668067f, 0.03873977f, -0.03726123f, 0.15083660f, -0.04115189f, 0.03554149f, -0.05515907f, -0.00181512f, 
    -0.06922828f, 0.00070847f, -0.06966236f, 0.01412606f, -0.08875319f, -0.02341493f, 0.12350737f, -0.04961161f, 
    0.12514393f, 0.06996480f, 0.11522535f, -0.00247498f, 0.16440052f, 0.08296432f, 0.03442951f, -0.01602776f, 
    0.19971022f, -0.00775121f, 0.11159945f, -0.19315393f, -0.21690148f, -0.17730486f, 0.23837617f, 0.03912786f, 
    0.00800551f, 0.07544992f, 0.23842712f, 0.03709679f, 0.19350043f, 0.08032842f, 0.09851809f, -0.04648842f, 
    -0.30785340f, -0.19830264f, -0.21745262f, -0.10298456f, -0.13192748f, 0.04700613f, 0.01868748f, -0.13573083f, 
    -0.02840473f, -0.03830007f, -0.02167997f, -0.03953329f, 0.06737568f, 0.25554541f, 0.18991567f, 0.01587066f, 
    0.03879458f, 0.00863751f, -0.02883541f, 0.17071246f, 0.12029378f, 0.11829027f, 0.27984765f, 0.10346635f, 
    -0.19206630f, 0.18458921f, 0.09395950f, 0.20676324f, -0.07294596f, -0.04862079f, -0.07277659f, 0.31311798f, 
    -0.07053448f, 0.02116164f, 0.02914601f, 0.08820767f, -0.12337295f, -0.03465881f, 0.04420064f, 0.01326571f, 
    0.03260243f, -0.00680289f, -0.09414583f, 0.09391046f, 0.11078561f, 0.03309393f, 0.13050061f, -0.02367837f, 
    0.01611408f, -0.06051555f, -0.24406675f, -0.07387636f, -0.07611992f, -0.07440203f, -0.06985504f, -0.03216660f, 
    -0.07342910f, 0.00083324f, -0.01384817f, -0.08826571f, -0.12392768f, -0.41445470f, -0.39335850f, -0.36676922f, 
    0.04327836f, -0.01893596f, 0.05003049f, 0.23728719f, -0.06455513f, 0.05454977f, -0.00108727f, -0.14196727f, 
    -0.30568799f, 0.08321745f, 0.40703911f, 0.09267706f, -0.05847219f, -0.08323404f, -0.11307362f, 0.10645094f, 
    -0.10918611f, 0.19565217f, 0.03662018f, 0.03411336f, 0.19633321f, 0.03657909f, 0.03253406f, -0.02744985f, 
    -0.03005910f, 0.04651536f, -0.04778318f, 0.20438735f, 0.17488751f, -0.01008936f, 0.14620236f, -0.12119437f, 
    -0.05335455f, -0.19459990f, 0.27067426f, -0.00712968f, -0.00342875f, -0.06126383f, -0.00379372f, 0.01312154f, 
    0.05725737f, 0.15162796f, 0.31820953f, 0.07991721f, -0.02905087f, -0.06605003f, -0.01982324f, -0.08451699f, 
    -0.14594579f, -0.08186127f, -0.07139260f, -0.05788615f, -0.01894253f, 0.22078529f, 0.17171535f, 0.19819193f, 
    0.07080195f, 0.03296240f, -0.01790588f, 0.01514757f, -0.00498944f, 0.08104174f, 0.02999694f, 0.03241663f, 
    0.08494093f, 0.02957422f, 0.08269554f, -0.03918267f, -0.26415756f, 0.01995722f, 0.16737308f, 0.02672835f, 
    -0.02744404f, 0.04765787f, 0.06322398f, 0.03869867f, 0.04680951f, -0.08401187f, -0.06597277f, 0.01394168f, 
    0.18581763f, 0.16697370f, -0.15910903f, 0.31528193f, -0.04973439f, 0.04003376f, 0.11609303f, 0.13542803f, 
    0.14975204f, 0.10075726f, 0.20086445f, 0.23119400f, 0.15951034f, -0.06624204f, 0.03183419f, -0.11582031f, 
    -0.00269371f, 0.00225317f, 0.12626769f, 0.00281586f, 0.06261249f, 0.01896185f, -0.06346031f, -0.04863058f, 
    0.23217280f, 0.16939434f, 0.10807805f, 0.15540943f, -0.01078369f, -0.00426826f, 0.01526475f, -0.02595118f, 
    0.01936311f, 0.04608695f, 0.03728016f, 0.07024482f, 0.08149040f, 0.05170616f, 0.18198258f, 0.04456673f, 
    -0.02926965f, 0.06825275f, -0.09281683f, -0.03080636f, 0.21916589f, 0.11700480f, 0.01816834f, 0.18836318f, 
    -0.52866030f, 0.05556788f, -0.10256284f, 0.06183033f, -0.05394387f, -0.12118211f, 0.17686641f, -0.12493028f, 
    0.08039176f, -0.13577335f, 0.06788359f, -0.09309270f, 0.07072194f, -0.05749237f, 0.01640400f, 0.04466014f, 
    0.08987719f, 0.04693102f, -0.01494623f, -0.06495282f, -0.00819269f, 0.03582111f, -0.05546311f, 0.04004541f, 
    -0.25022653f, -0.02777561f, -0.05340967f, 0.22839479f, -0.00007508f, 0.06325892f, -0.09273241f, -0.00995191f, 
    0.00077182f, -0.04489120f, -0.00914631f, 0.01882008f, 0.21827678f, -0.11679734f, 0.12917680f, -0.11489718f, 
    -0.01035937f, -0.00595119f, -0.08336371f, -0.01352683f, 0.02569021f, 0.07691765f, -0.02915644f, 0.16600172f, 
    0.13058428f, -0.04939841f, 0.30504096f, -0.03645472f, 0.12214583f, -0.04215863f, 0.14366108f, -0.00453748f, 
    0.22389749f, 0.10512717f, 0.17221859f, 0.30492508f, -0.11528527f, 0.03650844f, -0.14040902f, 0.02416116f, 
    0.09479875f, 0.03890847f, 0.02134603f, -0.01681765f, -0.09662022f, -0.02907678f, -0.02990303f, -0.02749721f, 
    -0.31095725f, -0.01578415f, 0.01568611f, -0.06326906f, -0.02382625f, -0.01587557f, 0.07094529f, 0.03268246f, 
    -0.00006689f, 0.01365068f, 0.01034550f, -0.03221769f, -0.18053894f, -0.11427558f, -0.06261861f, 0.03482983f, 
    0.01101258f, -0.07707203f, 0.04591876f, 0.16585445f, -0.06682055f, 0.04564926f, 0.02161190f, 0.10287028f, 
    -0.01629602f, 0.01562217f, 0.18558091f, 0.08920311f, -0.05458675f, 0.02637879f, -0.05392725f, -0.10936894f, 
    -0.04209768f, 0.02153424f, 0.00176817f, -0.08917505f, -0.25350887f, 0.13296358f, 0.00468348f, 0.00011424f, 
    -0.04103541f, -0.11386418f, 0.16114132f, 0.08448908f, 0.13087052f, 0.02424054f, 0.12861618f, -0.03620341f, 
    0.05507074f, -0.04272981f, 0.01849946f, -0.16176765f, -0.01157998f, 0.02521313f, -0.01055334f, 0.02708112f, 
    -0.05083714f, -0.00788771f, -0.01447020f, 0.02383379f, 0.06885002f, -0.03037080f, -0.06734504f, -0.06655081f, 
    0.17231578f, 0.10620523f, -0.00236977f, -0.11469452f, -0.00670759f, -0.04530334f, -0.00886118f, -0.02776641f, 
    0.07795211f, 0.01755266f, 0.02350000f, -0.10265443f, -0.01085468f, -0.10694717f, -0.06339806f, -0.11009932f, 
    -0.15340093f, -0.00041524f, 0.02611534f, 0.08980624f, -0.13529912f, 0.10006534f, 0.02812316f, 0.04567342f, 
    -0.06236156f, 0.15373111f, -0.08835550f, 0.01386963f, 0.08219104f, 0.03802140f, -0.00425376f, 0.02719235f, 
    0.19637145f, 0.19932739f, -0.13278322f, 0.12388844f, 0.09464104f, -0.07099136f, 0.03604766f, 0.22439861f, 
    0.11054631f, 0.01994731f, 0.14908989f, -0.05809222f, -0.01314176f, 0.18397500f, -0.01276848f, 0.08450303f, 
    -0.01731494f, -0.16844290f, -0.01261737f, -0.04189869f, -0.00498652f, -0.03387332f, 0.03579959f, 0.03100569f, 
    0.00300827f, 0.07101910f, 0.08832013f, 0.31207344f, 0.08709290f, 0.07452448f, -0.01003217f, -0.04160859f, 
    0.29500854f, -0.19163731f, 0.28332216f, 0.04742487f, 0.01239362f, -0.08037686f, 0.29495749f, -0.12071445f, 
    0.03937073f, -0.02375675f, 0.04758416f, -0.15519460f, 0.19118099f, -0.07470714f, -0.08426835f, 0.11189347f, 
    0.08900086f, 0.09235622f, -0.05881161f, 0.00957367f, 0.00206930f, 0.01825122f, -0.01291358f, -0.06887069f, 
    0.02106472f, -0.05224345f, 0.00339827f, -0.03351646f, -0.37926280f, -0.10483609f, 0.04151957f, 0.08293993f, 
    -0.07385647f, -0.07200047f, -0.09396505f, -0.13993293f, -0.07786659f, 0.00840301f, -0.05759656f, -0.03538651f, 
    0.11223677f, 0.03883059f, -0.01606949f, 0.03382232f, -0.04996306f, 0.02855367f, 0.00929055f, 0.03149281f, 
    0.07068735f, 0.06026219f, -0.03809712f, -0.08354772f, 0.58159512f, 0.08971959f, -0.10538331f, -0.22305718f, 
    -0.08004317f, -0.05143932f, -0.06522406f, 0.04762554f, 0.05794253f, -0.04343995f, 0.05635406f, -0.03489329f, 
    0.05306122f, 0.00736898f, 0.08731592f, 0.10156442f, -0.08333543f, -0.00360530f, -0.08784828f, -0.01547837f, 
    -0.04900661f, 0.03620605f, -0.02102362f, -0.14496875f, 0.48887205f, 0.00051009f, -0.14517157f, -0.23736648f, 
    -0.00977483f, -0.03005846f, 0.15795825f, -0.06622457f, -0.03353423f, 0.02923463f, -0.05810170f, 0.08070244f, 
    -0.05440816f, -0.00424067f, 0.06726781f, -0.00691145f, -0.00720940f, -0.00075207f, 0.02296849f, 0.09492802f, 
    0.10068125f, 0.06853630f, 0.22695318f, 0.03093158f, -0.37232956f, 0.21273977f, 0.04301326f, -0.09714515f, 
    -0.03140274f, 0.03079815f, 0.02043823f, -0.07204021f, -0.12050803f, -0.06590959f, -0.14801562f, -0.12336339f, 
    -0.22235477f, -0.33697021f, 0.25842270f, 0.39996055f, 0.00389152f, 0.08894458f, 0.08419210f, 0.01895093f, 
    0.13705452f, -0.07034274f, 0.08425231f, 0.02219315f, 0.09685450f, 0.06299521f, 0.01192298f, 0.09443150f, 
    -0.02877022f, -0.04344094f, -0.03612223f, -0.03481338f, 0.12117346f, 0.02389405f, 0.10927916f, 0.15581971f, 
    0.31552327f, 0.04232827f, 0.22916166f, -0.12879840f, -0.04389633f, 0.03540968f, 0.03532968f, 0.12796563f, 
    -0.02712125f, -0.09640023f, -0.14155523f, -0.12422806f, 0.06813636f, 0.12715867f, 0.00439159f, 0.16378024f, 
    -0.01395765f, -0.05915597f, -0.01114955f, -0.01009811f, 0.25827408f, 0.08341488f, -0.01482732f, 0.12746614f, 
    0.54671961f, 0.21132338f, 0.08316835f, 0.22658366f, -0.07283597f, 0.08151451f, -0.00667702f, 0.07559671f, 
    0.01498284f, 0.04250870f, 0.07412684f, 0.12979744f, 0.04735160f, 0.03777114f, 0.01064740f, 0.09911057f, 
    -0.08905359f, -0.06476768f, -0.09548012f, -0.13730441f, -0.01624696f, 0.00004785f, 0.05483004f, 0.01399219f, 
    0.06907900f, -0.05961755f, 0.15252523f, -0.10996683f, -0.02495993f, 0.16963390f, -0.05789647f, 0.09546852f, 
    -0.02124743f, 0.11193990f, 0.06241736f, 0.09189315f, -0.19952732f, 0.06748697f, -0.03756333f, 0.05025655f, 
    -0.05742062f, -0.02674148f, -0.09174956f, -0.08695367f, -0.01168739f, -0.15441027f, -0.17438440f, -0.14213020f, 
    -0.29835641f, -0.11317366f, 0.10643532f, 0.18048896f, 0.06563873f, -0.05962101f, 0.11514375f, 0.04323796f, 
    0.05558446f, -0.08487337f, -0.01968513f, 0.01956838f, 0.49708194f, 0.15217909f, -0.05262938f, -0.15792871f, 
    0.19656022f, -0.03238958f, -0.00893051f, 0.14394750f, -0.05966387f, -0.12730855f, 0.05846561f, -0.09329842f, 
    0.07248342f, -0.05113088f, 0.00563879f, 0.08394891f, 0.08735365f, 0.05669450f, -0.01847476f, -0.04166179f, 
    -0.07004203f, -0.03544122f, -0.00837381f, 0.02445116f, 0.07895496f, -0.05049424f, -0.02344812f, -0.01483258f, 
    -0.01669006f, 0.00139955f, 0.24893181f, 0.02803485f, -0.07405583f, -0.02881017f, -0.01167812f, 0.08492941f, 
    0.09314058f, -0.06467474f, 0.04491896f, -0.14198019f, 0.05391440f, 0.02511007f, 0.24678999f, 0.15841939f, 
    0.12680832f, 0.03055643f, -0.05913905f, -0.02289498f, -0.30990291f, -0.18580268f, -0.01020600f, 0.20629616f, 
    -0.01120591f, 0.16536745f, 0.13100122f, 0.13920015f, 0.18758957f, 0.05261563f, 0.04160924f, -0.06620169f, 
    -0.47013691f, 0.13378109f, -0.06274398f, 0.14480297f, 0.08214197f, -0.02843747f, 0.02896165f, 0.09744203f, 
    -0.05520356f, 0.06808329f, 0.02468139f, -0.11203876f, -0.22291976f, 0.09398571f, -0.00002437f, 0.13172004f, 
    0.09265558f, -0.01296009f, 0.10693456f, -0.02978353f, -0.00221715f, 0.10591827f, 0.02534450f, 0.17192018f, 
    -0.42823976f, -0.17872004f, 0.04849380f, 0.00292260f, 0.04925684f, 0.06488548f, 0.09836388f, 0.06914430f, 
    0.14204113f, 0.01959903f, 0.06184190f, -0.04618924f, 0.17537144f, 0.05203762f, 0.06722153f, 0.06522909f, 
    -0.22738771f, 0.08293262f, -0.15232357f, -0.21679482f, 0.05894639f, 0.01354383f, 0.03695748f, 0.13369161f, 
    0.37515721f, -0.12788227f, 0.03351318f, -0.23120087f, 0.09393299f, 0.12527756f, 0.14647892f, 0.23734772f, 
    0.06094551f, 0.09990711f, -0.05543129f, 0.07954827f, -0.21964248f, -0.02152131f, -0.16743056f, -0.17237593f, 
    0.09065547f, 0.06928761f, 0.01499262f, 0.15733221f, -0.01086684f, -0.00204546f, -0.00100099f, -0.12529454f, 
    0.37241921f, 0.10549392f, 0.01140019f, -0.10828765f, 0.13409305f, 0.08445127f, 0.04438289f, 0.08040009f, 
    0.18757510f, -0.02819053f, 0.01256111f, 0.06889796f, -0.62682569f, -0.17108549f, 0.24962446f, 0.09572979f, 
    0.09450496f, 0.13694583f, 0.13605565f, 0.08057344f, 0.10690151f, 0.05574032f, 0.30356520f, 0.02537685f, 
    -0.21680173f, -0.09271540f, -0.03718408f, -0.06092047f, -0.15851147f, -0.05731434f, -0.12851954f, -0.22159703f, 
    -0.22704825f, -0.10568900f, -0.09787928f, -0.15177017f, -0.32170153f, 0.12286681f, 0.02842691f, -0.20088950f, 
    -0.04533943f, -0.11935841f, -0.02790708f, 0.06751392f, 0.02247398f, 0.09690829f, 0.15311725f, 0.00763654f, 
    -0.15975019f, 0.07087965f, 0.10605140f, 0.07088495f, -0.01063585f, 0.04315087f, -0.17176621f, 0.16453801f, 
    -0.15005495f, -0.02996262f, 0.06950934f, 0.04671308f, -0.21028946f, -0.01703611f, 0.00583524f, 0.01827604f, 
    0.02583972f, -0.07941745f, -0.00936699f, -0.11518599f, -0.08656091f, -0.12147683f, -0.11305650f, -0.17437334f, 
    0.00378265f, 0.10973230f, 0.09455620f, 0.16487698f, -0.03623302f, -0.05087834f, -0.01507175f, -0.02846779f, 
    -0.01646693f, 0.00425008f, 0.04780431f, 0.12081435f, -0.06955720f, -0.21994109f, -0.07583184f, -0.26521745f, 
    0.09134693f, 0.05663792f, 0.18778905f, 0.23593734f, 0.02157763f, 0.09908222f, -0.07053225f, -0.20925088f, 
    -0.28301662f, 0.13187829f, 0.24019314f, 0.04087160f, -0.10489460f, 0.03481812f, -0.06985151f, 0.14330813f, 
    -0.02087865f, 0.22193576f, -0.13387960f, 0.03335734f, -0.10372038f, -0.00804809f, 0.03933481f, -0.23207471f, 
    -0.00971298f, -0.05048918f, -0.20518951f, 0.15323777f, 0.11890200f, -0.02354563f, 0.07688335f, -0.18391725f, 
    -0.17601424f, 0.01845066f, 0.17345437f, 0.21206434f, -0.07079022f, -0.02376569f, -0.11017679f, 0.03117306f, 
    0.04689552f, 0.14136660f, 0.16789857f, 0.14235799f, 0.02967818f, 0.07244063f, 0.15538710f, 0.01322091f, 
    -0.12167111f, -0.12255637f, -0.13615368f, -0.07120994f, 0.01174206f, 0.15454522f, 0.09153041f, 0.16038425f, 
    -0.03919532f, 0.00134142f, -0.02569320f, 0.02073378f, -0.02642523f, 0.00894731f, 0.01802308f, -0.01162195f, 
    -0.02982317f, -0.02513656f, 0.02521150f, -0.00782460f, 0.02474862f, -0.03217526f, -0.03508845f, 0.02969689f, 
    -0.03371250f, 0.00532641f, 0.00200585f, -0.00891844f, -0.03035075f, 0.02128203f, 0.02295758f, -0.04202127f, 
    0.02685966f, -0.00752103f, -0.02538439f, 0.01844422f, 0.01475605f, -0.03375610f, -0.02527788f, 0.00237932f, 
    0.00427283f, 0.01463591f, -0.01524610f, -0.03727524f, -0.02322540f, 0.00091239f, -0.02701619f, -0.04032813f, 
    -0.04107726f, 0.00157608f, 0.00313369f, 0.01923342f, -0.04032604f, 0.01346172f, 0.00137312f, 0.02630112f, 
    0.00771157f, 0.00294549f, -0.01725289f, 0.00539701f, -0.01947164f, -0.00548276f, 0.00889353f, 0.00495426f, 
    -0.03909446f, -0.00222259f, -0.00030009f, -0.00363180f, -0.01441245f, 0.00026178f, 0.01584763f, 0.00624848f, 
    0.00541845f, 0.00472829f, -0.03926375f, -0.03090068f, -0.03974473f, -0.03781822f, -0.02538081f, -0.03048413f, 
    -0.01057637f, -0.02968691f, -0.01212263f, -0.01943397f, -0.00459905f, 0.02086343f, -0.02072382f, 0.00257106f, 
    -0.03505791f, 0.00963459f, 0.02150917f, -0.03378053f, 0.01192579f, 0.02288178f, 0.01928257f, -0.00895454f, 
    -0.02572657f, -0.04076162f, -0.00434365f, 0.01139522f, -0.02031094f, 0.01057563f, -0.01965869f, 0.01683662f, 
    0.02375561f, -0.01233537f, -0.03993782f, 0.00495748f, -0.03773982f, 0.02005019f, 0.02092629f, 0.01305150f, 
    0.00337676f, 0.02086917f, -0.03374146f, -0.03968479f, -0.00540729f, 0.02820561f, -0.01091735f, -0.02463613f, 
    -0.03135854f, -0.01789054f, 0.01231240f, 0.02306513f, 0.01414409f, -0.03072702f, 0.01303230f, -0.01927890f, 
    -0.01046920f, -0.00907652f, 0.02913114f, 0.00618415f, -0.01268347f, -0.04010040f, -0.01706016f, -0.01553509f, 
    0.02535227f, -0.02841035f, -0.01488116f, 0.02556614f, 0.01846640f, -0.03032247f, 0.01557072f, -0.02221148f, 
    -0.01017337f, -0.01969063f, 0.01423907f, -0.01796463f, 0.00180640f, -0.00938163f, -0.02012007f, 0.00257183f, 
    0.00243966f, -0.03467058f, -0.02377123f, 0.01207949f, 0.02048357f, -0.00448842f, -0.02272094f, -0.02328498f, 
    0.00897606f, 0.02943796f, -0.02066354f, -0.02683508f, 0.02229812f, 0.02686089f, 0.01969099f, -0.03218346f, 
    -0.02426201f, -0.02543647f, 0.00664903f, -0.02797650f, -0.02678327f, 0.00371507f, 0.02558120f, -0.01565976f, 
    -0.03408857f, -0.03206835f, 0.01996584f, -0.03104519f, -0.04098557f, -0.02213527f, -0.03041612f, 0.01648447f, 
    -0.04167321f, 0.00102385f, -0.01216217f, -0.04162166f, -0.02049649f, 0.00373070f, -0.02251869f, -0.01644852f, 
    -0.00460941f, -0.00812678f, -0.02588811f, 0.01487576f, -0.00915427f, -0.00919525f, -0.02438658f, 0.00929030f, 
    -0.02303090f, 0.02316651f, -0.00138390f, -0.01994722f, 0.00754252f, 0.01772149f, -0.03544132f, -0.02859003f, 
    -0.02071162f, -0.02325953f, 0.03094050f, -0.00721146f, 0.00654631f, -0.01661571f, -0.03621762f, -0.03318418f, 
    -0.02196694f, 0.01494952f, -0.00066709f, 0.01252600f, 0.02035542f, -0.01001462f, 0.02373377f, -0.03896593f, 
    0.00968609f, 0.01034997f, 0.02139627f, 0.00852742f, 0.01181943f, 0.02776101f, -0.02273494f, -0.01848047f, 
    -0.00021017f, -0.01025224f, 0.02140151f, 0.00274562f, 0.02608037f, -0.00079979f, -0.00256434f, -0.01684770f, 
    -0.02990303f, -0.04153018f, -0.01283824f, 0.00837245f, 0.00890329f, -0.03305818f, 0.01680492f, -0.02652709f, 
    -0.04063797f, -0.00987988f, -0.02092509f, 0.00094358f, -0.02228497f, -0.01121956f, 0.00023944f, 0.00325708f, 
    -0.00334772f, -0.03559157f, -0.00365550f, -0.02465716f, -0.03336058f, 0.02659353f, 0.00154076f, 0.02993713f, 
    -0.01122412f, -0.03191507f, 0.02344401f, -0.00779726f, -0.01960096f, -0.02808994f, 0.02224310f, 0.02528055f, 
    0.02319492f, 0.00126866f, 0.01951656f, 0.00888388f, -0.01003632f, -0.00482704f, -0.00451384f, 0.00638113f, 
    0.01187309f, 0.01943105f, 0.00200434f, -0.01683934f, 0.02349139f, 0.00242064f, -0.02381184f, -0.01234651f, 
    0.02310326f, -0.04068008f, -0.03248128f, -0.01731095f, -0.02801491f, -0.03487684f, -0.02446695f, -0.02319896f, 
    -0.03984821f, 0.02615843f, 0.02873441f, -0.01886157f, 0.01494094f, 0.01249474f, -0.03805456f, 0.01425796f, 
    -0.01255581f, 0.01806201f, 0.00580990f, -0.00612376f, -0.01665908f, 0.02644286f, -0.01000640f, 0.00399091f, 
    0.00269169f, 0.02758388f, -0.02516860f, 0.00814928f, 0.02071009f, -0.02993285f, 0.00419010f, 0.00102692f, 
    -0.04158669f, 0.02207807f, 0.00653980f, 0.01653261f, -0.01405806f, -0.03589258f, 0.02260741f, -0.03564114f, 
    -0.02359797f, 0.01722820f, 0.01493481f, -0.02446385f, -0.02705150f, -0.02766715f, 0.02789076f, -0.00352954f, 
    0.00995766f, -0.04123561f, 0.00881357f, 0.01555749f, -0.04065401f, 0.00224451f, 0.02174541f, -0.00605851f, 
    -0.00940849f, 0.01675839f, 0.02203182f, 0.01040020f, 0.00354199f, 0.02932394f, -0.03633306f, 0.02863855f, 
    -0.04038533f, -0.02193464f, -0.03555024f, -0.01745028f, -0.00917840f, 0.02190831f, -0.02303684f, -0.01034113f, 
    -0.01725509f, -0.04123406f, 0.02318055f, -0.00863888f, 0.02290153f, -0.02978234f, -0.01570217f, -0.03912587f, 
    -0.03448080f, -0.02575111f, 0.02414671f, -0.02231201f, -0.00145189f, 0.01455859f, -0.04087544f, -0.03629041f, 
    -0.01884117f, -0.01402282f, 0.01680438f, -0.02006753f, 0.02106075f, 0.03423063f, -0.04125577f, 0.00430348f, 
    -0.03667568f, -0.03900142f, 0.00166494f, -0.00487878f, 0.02445820f, -0.00418466f, -0.03620920f, -0.02952978f, 
    0.02393501f, -0.02579127f, 0.02300558f, 0.00221081f, 0.00813629f, -0.02638727f, 0.01806955f, 0.00006528f, 
    -0.01609305f, 0.01408306f, 0.00158760f, -0.02041699f, 0.02213158f, -0.01096693f, 0.02813682f, 0.01492777f, 
    -0.03229116f, 0.01794237f, 0.02474586f, 0.00572390f, 0.02143206f, 0.00436987f, -0.01928442f, -0.02687490f, 
    -0.02967465f, -0.03494135f, -0.02405758f, -0.01013192f, 0.00047617f, -0.00033861f, 0.01809224f, -0.03677854f, 
    0.02484344f, 0.00602616f, -0.01485354f, 0.01562814f, -0.02453101f, -0.01777119f, -0.00339125f, -0.03587992f, 
    -0.00887441f, -0.02950722f, -0.02165693f, -0.03953790f, 0.00486170f, -0.00460526f, -0.03918039f, -0.02026138f, 
    -0.02884382f, -0.00402118f, -0.00549022f, 0.01959756f, 0.01804528f, -0.03501826f, -0.04019415f, -0.03794881f, 
    -0.01487462f, -0.00570536f, -0.00357334f, -0.00528660f, -0.02099975f, 0.00882272f, -0.02293859f, 0.03231999f, 
    0.01850835f, 0.00649543f, 0.00457518f, -0.00549031f, -0.02988426f, 0.01748240f, -0.00825639f, -0.00763346f, 
    -0.00516922f, -0.01048227f, -0.01190067f, 0.01993602f, -0.02787827f, 0.02106944f, -0.00581227f, -0.02860937f, 
    -0.00853935f, -0.01440480f, -0.02537880f, -0.02274002f, -0.03266232f, -0.02120477f, 0.02903200f, -0.00796492f, 
    -0.01960748f, -0.00832980f, -0.00270703f, -0.00677282f, 0.01213014f, 0.02810549f, 0.02065866f, -0.00014644f, 
    -0.02570174f, -0.01347040f, 0.01069643f, -0.01665392f, 0.03246219f, -0.01087630f, 0.01528193f, -0.01438918f, 
    -0.03953713f, -0.02747673f, -0.02360557f, -0.00691282f, -0.02268109f, -0.01463499f, -0.00440424f, 0.02605959f, 
    0.01326205f, -0.01000992f, -0.02419751f, 0.01387845f, 0.00497318f, -0.00835503f, -0.03331719f, 0.00961900f, 
    -0.03192847f, -0.01433058f, 0.00061428f, 0.00828791f, -0.01832747f, 0.01842834f, 0.02189294f, 0.00188159f, 
    -0.02659084f, -0.02873986f, -0.02007115f, -0.03463558f, -0.01619509f, -0.00610068f, -0.04151953f, -0.04145602f, 
    0.02475924f, -0.02434335f, -0.04171954f, 0.00237265f, -0.01090389f, -0.02253787f, -0.02890310f, 0.00276039f, 
    -0.03894827f, -0.00805968f, -0.03715452f, -0.02500804f, 0.01647544f, 0.02105014f, -0.00041689f, -0.02111543f, 
    0.01638450f, -0.02834616f, -0.03154648f, 0.00064436f, -0.03091465f, -0.03602178f, 0.03572948f, 0.02782921f, 
    -0.01575631f, -0.00802551f, 0.01339794f, 0.02006754f, -0.01616291f, 0.00623465f, 0.00289812f, 0.02487531f, 
    -0.01818057f, -0.00986059f, -0.01762803f, 0.02037127f, 0.00665141f, 0.01119327f, -0.02128003f, 0.01309662f, 
    0.00264708f, -0.00303269f, -0.00376268f, -0.02762118f, -0.03223670f, -0.01930458f, -0.01927201f, 0.02727407f, 
    -0.03222394f, -0.00226692f, -0.01764294f, 0.02043142f, -0.02675981f, -0.00472964f, -0.01974907f, -0.02139422f, 
    -0.04076656f, 0.02807819f, -0.03587139f, -0.01975480f, -0.03343472f, -0.03167556f, -0.00900494f, -0.02283045f, 
    -0.01551008f, 0.02049789f, 0.00534174f, -0.01192949f, 0.01018179f, -0.01848161f, 0.00875708f, 0.00063906f, 
    0.00416478f, -0.00594296f, -0.01050806f, -0.03407219f, 0.00950729f, -0.00635821f, -0.00906853f, -0.01794617f, 
    -0.00297256f, 0.02536726f, 0.01562478f, -0.02317724f, -0.01373919f, 0.00553711f, 0.00646601f, -0.01389313f, 
    0.00254383f, -0.01598134f, -0.03873130f, -0.01148633f, 0.00181477f, -0.00492977f, -0.03830241f, -0.03328115f, 
    -0.01116446f, -0.01756412f, -0.00280173f, -0.03829850f, -0.03234464f, 0.02324124f, 0.00786300f, 0.02585940f, 
    0.03167243f, 0.01513490f, -0.01610862f, 0.00049743f, 0.01601951f, 0.02757209f, 0.01618190f, -0.01980535f, 
    0.00363199f, 0.02560003f, -0.00035173f, -0.02759403f, 0.02087661f, 0.00493700f, -0.02465771f, -0.02044020f, 
    -0.01638921f, 0.02175100f, -0.03563322f, -0.01430031f, 0.01019310f, -0.02612020f, 0.03301276f, -0.00941819f, 
    -0.02880236f, -0.01554218f, 0.00517404f, 0.00188646f, -0.01004943f, 0.02111802f, 0.02847272f, -0.02667406f, 
    -0.02656286f, 0.01937975f, -0.01350037f, 0.01223630f, 0.02966446f, -0.02744713f, 0.00163272f, -0.01494522f, 
    -0.01358084f, -0.02430167f, -0.00849142f, 0.01088892f, -0.03815750f, 0.02162492f, -0.03161534f, -0.01095831f, 
    0.00326073f, -0.00393436f, -0.01017745f, 0.01615081f, 0.01416699f, 0.01039460f, -0.03694082f, -0.02774113f, 
    -0.01084295f, -0.03154459f, -0.01875477f, 0.01669999f, -0.02295838f, -0.01220301f, -0.01161117f, -0.01477222f, 
    0.00939276f, 0.00898006f, -0.03035820f, 0.00435982f, -0.03756718f, -0.00145743f, 0.01607313f, -0.01376064f, 
    0.00647061f, -0.00764944f, 0.01589895f, -0.03951280f, 0.02285967f, 0.02659155f, 0.00906053f, -0.04119850f, 
    0.01349016f, -0.02769501f, 0.02391944f, 0.01496150f, 0.00286652f, -0.03731261f, -0.00393407f, 0.02283902f, 
    0.00803468f, -0.02314653f, 0.02020091f, -0.00413513f, 0.00754190f, 0.00566561f, 0.01177142f, 0.02340709f, 
    0.00404559f, -0.01345768f, 0.01168477f, 0.02417961f, -0.00585664f, 0.01850663f, -0.01756292f, -0.02826602f, 
    -0.00546045f, 0.02612537f, 0.01646592f, -0.01883713f, 0.01322377f, -0.00145433f, -0.01510752f, -0.02110268f, 
    -0.03430758f, -0.03226435f, 0.01009927f, 0.02888988f, 0.01729815f, 0.02692756f, -0.01007638f, -0.04111873f, 
    0.01456096f, 0.02326950f, -0.00069503f, -0.04115967f, 0.02707323f, 0.02527170f, 0.00427244f, 0.00674161f, 
    -0.01584072f, -0.01705229f, -0.00478252f, 0.00721654f, -0.03869544f, -0.03857693f, -0.02300508f, 0.00682769f, 
    0.00692127f, 0.02553084f, 0.00804482f, -0.01623500f, 0.00522876f, 0.01699466f, -0.01712405f, -0.02218216f, 
    -0.01224042f, 0.00924554f, -0.02502164f, -0.07117552f, -0.04605244f, 0.12481479f, 0.04004687f, -0.08402064f, 
    0.02134132f, 0.01558770f, 0.22243653f, 0.00135900f, -0.03515719f, -0.14637399f, -0.06972089f, -0.10787845f, 
    0.14868675f, 0.07118257f, 0.11695060f, 0.16172230f, -0.05673955f, 0.04572137f, 0.00964613f, -0.06010127f, 
    -0.09270133f, 0.26007682f, -0.13270837f, -0.12668020f, 0.03704699f, -0.06195137f, -0.09583172f, -0.39288503f, 
    0.04355064f, 0.10200872f, -0.03329984f, 0.08056223f, 0.14041454f, -0.06437425f, -0.12460458f, 0.01490788f, 
    0.02033164f, 0.17186359f, 0.02717131f, 0.05551500f, 0.02495612f, 0.09020961f, 0.02206231f, -0.08311684f, 
    0.31485987f, 0.26696447f, 0.16468509f, -0.00908479f, -0.07497247f, 0.02927298f, 0.00350190f, -0.12448885f, 
    -0.00323690f, 0.11434574f, -0.05262505f, -0.08135892f, 0.02761092f, 0.18984914f, 0.04234962f, 0.20248649f, 
    -0.16204600f, 0.03436019f, -0.06462136f, -0.22567178f, -0.05139931f, -0.04257331f, -0.04536103f, 0.04178259f, 
    0.05423002f, 0.16935396f, -0.06344941f, -0.10235219f, 0.16192751f, -0.05437914f, 0.08844943f, 0.05160541f, 
    0.08368914f, -0.08484478f, 0.01197393f, -0.02548451f, 0.25714582f, 0.07138390f, 0.06792705f, -0.17308007f, 
    0.05614532f, -0.18943469f, -0.08238291f, -0.02445177f, 0.04080328f, 0.16241892f, -0.05436103f, -0.08302335f, 
    0.08440415f, 0.09768194f, -0.05458551f, -0.05997860f, 0.03172108f, -0.04985354f, -0.05027296f, 0.02301179f, 
    -0.03745613f, 0.05841434f, -0.04505988f, -0.07114120f, -0.01119733f, -0.11624641f, 0.02189889f, 0.15570013f, 
    -0.07344750f, -0.05819568f, -0.03786416f, 0.11265638f, 0.02022203f, 0.10398100f, -0.06117495f, 0.10178400f, 
    0.02525634f, 0.03613846f, 0.10284676f, -0.00191475f, -0.03866768f, 0.00703088f, 0.16388808f, 0.03605907f, 
    0.06634398f, -0.02073620f, 0.08592894f, 0.03209335f, 0.03710907f, 0.00021001f, 0.05231923f, -0.04521409f, 
    0.11147434f, -0.10811806f, -0.03719280f, -0.17300901f, -0.04998586f, -0.12333794f, -0.03451585f, -0.04857207f, 
    -0.09986597f, 0.10694847f, -0.03047862f, -0.18098639f, 0.10620949f, 0.12583368f, 0.07039338f, -0.07514360f, 
    0.05302454f, 0.13058960f, 0.09601940f, 0.04154709f, 0.11815063f, -0.02561223f, -0.01818114f, -0.13237451f, 
    -0.09391671f, -0.05076081f, -0.05392056f, 0.12798490f, 0.01738591f, 0.14442235f, 0.00627846f, 0.04988410f, 
    0.21611509f, 0.00911193f, -0.04188691f, -0.05293179f, 0.03372108f, 0.06871367f, 0.00926658f, 0.06049213f, 
    -0.07000689f, -0.02571519f, -0.07582889f, -0.04287789f, 0.14908296f, 0.08013424f, 0.17345898f, -0.28392616f, 
    0.00193530f, -0.05348689f, 0.03041554f, 0.10636078f, 0.04930761f, 0.04957423f, 0.00820393f, -0.16210353f, 
    0.00172295f, -0.06037363f, 0.07517652f, 0.07240120f, 0.05916303f, -0.00715952f, 0.04238050f, 0.02898377f, 
    -0.06624071f, 0.11822023f, 0.15815391f, -0.02847567f, 0.29717353f, 0.17540932f, 0.01748735f, -0.21527803f, 
    0.00873119f, -0.04632495f, 0.11503924f, -0.14277759f, 0.01475071f, -0.06702679f, 0.02990722f, -0.06920983f, 
    0.08706218f, -0.02999458f, 0.00196096f, -0.11883804f, 0.05176219f, -0.09239767f, -0.00970818f, 0.19117540f, 
    -0.02663855f, 0.02164457f, 0.07708710f, 0.08035330f, -0.05425804f, 0.06368854f, -0.23158044f, -0.02200078f, 
    0.06284097f, 0.12803848f, -0.01471974f, 0.00882674f, 0.03173734f, 0.00680429f, -0.14482129f, -0.02019689f, 
    0.08324426f, 0.06855032f, 0.02381593f, 0.10074478f, 0.06480119f, 0.01108923f, -0.03584469f, -0.08039017f, 
    0.03819291f, 0.05539257f, 0.08691975f, -0.03513618f, 0.01787173f, -0.08503199f, -0.11437634f, 0.03183732f, 
    -0.15992306f, -0.02695760f, 0.16778366f, 0.24487258f, -0.05290645f, 0.06026511f, 0.00522782f, 0.02485509f, 
    -0.04200182f, 0.24980146f, -0.02719495f, 0.17251924f, -0.01383690f, -0.04492868f, -0.08761904f, -0.00977324f, 
    0.14820486f, -0.06756622f, 0.24455136f, 0.12667932f, 0.02433464f, -0.18479666f, 0.37729439f, -0.01016434f, 
    -0.23183627f, -0.08520868f, 0.18541625f, 0.13988777f, 0.09248611f, 0.12314957f, 0.00849920f, -0.03399214f, 
    0.12025248f, 0.15016374f, 0.04527996f, -0.06301552f, -0.02147141f, -0.06653836f, -0.01763297f, -0.08435457f, 
    0.04825452f, 0.04007818f, 0.04722196f, 0.01765071f, 0.18796526f, -0.01650950f, -0.04843751f, -0.02641425f, 
    0.09586866f, 0.16838464f, 0.03767123f, 0.02012497f, -0.05837909f, 0.00650770f, 0.17184667f, 0.12208950f, 
    0.00728731f, 0.18392213f, 0.00222914f, 0.04803477f, -0.17536688f, -0.03389367f, -0.01703732f, -0.14705771f, 
    -0.00333857f, -0.00147603f, -0.07175199f, -0.05359504f, 0.17499271f, -0.27987847f, -0.11333831f, 0.09007658f, 
    -0.06747663f, 0.00432826f, -0.11664166f, -0.11640479f, -0.12898988f, 0.01111796f, 0.07518645f, 0.00898035f, 
    0.16947968f, 0.02270493f, -0.04754074f, -0.02793596f, 0.05818547f, 0.01125608f, 0.12046744f, -0.08050051f, 
    -0.00778337f, -0.00119064f, 0.01870220f, -0.01506426f, 0.03412883f, -0.18253478f, 0.17012160f, 0.04865877f, 
    -0.04058460f, -0.18166453f, 0.11456853f, 0.05914457f, -0.04529390f, 0.01048295f, -0.04645053f, 0.10994395f, 
    0.08053042f, 0.12518096f, -0.00353816f, -0.15125723f, 0.06321069f, 0.01606590f, -0.10686062f, -0.02339644f, 
    0.03495312f, -0.07943134f, 0.08132014f, -0.03031097f, 0.23567611f, 0.05037083f, -0.01221876f, 0.00096040f, 
    -0.04438367f, 0.10187189f, -0.01602517f, 0.04621718f, -0.05633778f, -0.05365758f, -0.10967049f, -0.07339791f, 
    0.13139896f, 0.34430680f, -0.24639282f, -0.10777607f, 0.14931099f, 0.05154575f, 0.07877140f, -0.01354406f, 
    0.03362511f, 0.04990346f, -0.03372640f, 0.02736941f, 0.02935409f, 0.11722581f, 0.11992989f, -0.06545542f, 
    -0.15911703f, -0.04151827f, -0.03324381f, -0.03358267f, -0.03534769f, 0.10531913f, 0.04619153f, -0.03618300f, 
    -0.13953726f, -0.07936678f, 0.22052896f, 0.08646461f, -0.04599274f, -0.08534513f, 0.10267437f, 0.12662897f, 
    -0.14312014f, 0.10974662f, -0.06437015f, 0.00848043f, 0.03295051f, 0.06263342f, 0.12962896f, 0.02944107f, 
    -0.12473945f, 0.07098243f, 0.09187244f, -0.10123093f, 0.05908594f, -0.01259138f, -0.06453203f, -0.13447349f, 
    0.00575158f, 0.17685521f, 0.36773965f, 0.24574581f, -0.16879171f, 0.02398463f, -0.07663964f, 0.03853229f, 
    -0.10858172f, 0.08768216f, -0.19532861f, -0.03140757f, 0.22496806f, 0.11774162f, -0.05025128f, -0.12409933f, 
    0.04322880f, -0.09106946f, 0.04271595f, -0.00067740f, -0.04454061f, -0.03560790f, 0.02138660f, -0.10980877f, 
    0.17987408f, 0.07666703f, 0.04475456f, 0.14120352f, -0.19564764f, 0.03763233f, 0.06314863f, -0.03729056f, 
    -0.14182329f, -0.03937741f, 0.04825821f, 0.21085601f, 0.21716934f, 0.07805526f, -0.02114075f, 0.06586435f, 
    0.16675539f, 0.08035181f, 0.05731001f, -0.10256463f, -0.04353965f, 0.01880753f, 0.09838339f, -0.02918796f, 
    0.06061780f, 0.03911781f, -0.16818307f, -0.11807537f, 0.25056168f, 0.01567372f, 0.11954381f, 0.07538185f, 
    -0.02663520f, -0.13740312f, -0.02804447f, 0.00290012f, 0.21059568f, -0.22541633f, 0.03008015f, -0.04639292f, 
    -0.01553462f, 0.08599744f, 0.15483053f, -0.05704981f, -0.06156728f, 0.02805910f, -0.01235419f, -0.12386098f, 
    -0.04581730f, 0.01316705f, 0.21489143f, -0.11163732f, -0.08262254f, 0.22750737f, -0.02587240f, 0.13290471f, 
    -0.13581963f, 0.05179878f, 0.10696983f, 0.05488364f, 0.22594926f, -0.02954532f, -0.02660652f, -0.12817618f, 
    -0.14437635f, -0.03312239f, 0.01375710f, -0.01715790f, -0.05231877f, 0.14776470f, -0.06182576f, -0.11630633f, 
    -0.04978693f, 0.08120321f, 0.27679449f, -0.21258317f, -0.00068165f, 0.14485586f, -0.03893775f, 0.18025227f, 
    -0.08139472f, -0.00911156f, 0.01633154f, -0.05045513f, -0.11113352f, 0.36947742f, -0.07355010f, 0.05716376f, 
    -0.06243521f, 0.08355382f, -0.01947112f, 0.05920301f, -0.03085137f, -0.05774343f, 0.08567102f, -0.00029664f, 
    -0.13580501f, 0.00367086f, -0.19293419f, 0.07388629f, 0.01513386f, 0.14404868f, 0.09821159f, 0.01565232f, 
    -0.01204027f, -0.02751154f, 0.07095824f, -0.07000979f, 0.06716878f, -0.03661999f, -0.23097520f, 0.06870498f, 
    0.05347623f, -0.03702395f, 0.02987326f, 0.13461404f, -0.04455112f, -0.01395969f, -0.00919052f, 0.07164709f, 
    0.11536293f, 0.02078280f, -0.28991571f, -0.05940792f, -0.07504742f, 0.09651330f, 0.07729705f, -0.03609174f, 
    0.10492319f, -0.03797229f, 0.20695814f, -0.08425964f, 0.03675516f, -0.06411094f, -0.17110384f, 0.04035694f, 
    -0.14404508f, -0.04638517f, -0.04337212f, 0.06563256f, -0.05656900f, 0.01402974f, -0.09003305f, -0.04345994f, 
    0.15602787f, -0.14925490f, 0.37482181f, -0.09086150f, 0.00691452f, -0.01320567f, 0.11354794f, 0.17402269f, 
    0.10195012f, 0.07776006f, 0.03056465f, 0.15812503f, 0.13716638f, -0.01981127f, 0.06145108f, -0.11731493f, 
    0.18324222f, 0.03976477f, 0.01156123f, 0.00156285f, -0.05699496f, 0.13700511f, 0.02907813f, -0.10022926f, 
    0.04968582f, -0.11153719f, 0.07932748f, 0.01328832f, -0.01110201f, 0.09053390f, 0.09601007f, -0.01363397f, 
    0.08241597f, 0.07271031f, -0.01227375f, -0.07395823f, 0.06833826f, -0.25130516f, -0.17272654f, -0.02123672f, 
    0.11738569f, 0.31326264f, 0.14558697f, -0.06423280f, 0.02791128f, -0.05986775f, 0.13332511f, 0.11080962f, 
    0.08335665f, -0.14713655f, -0.04008257f, -0.03132026f, -0.07361944f, 0.03458576f, 0.08393195f, 0.07175685f, 
    -0.10969172f, -0.08155851f, -0.07793622f, -0.15913266f, -0.20245317f, -0.17593521f, 0.09866284f, 0.04393357f, 
    -0.09103674f, 0.06291693f, -0.03369544f, 0.04633466f, -0.09660228f, 0.22946571f, 0.12734206f, 0.04089884f, 
    -0.06887954f, 0.04145074f, -0.11164139f, 0.11022832f, 0.04262451f, 0.05297057f, 0.11665925f, -0.02445501f, 
    -0.10077766f, 0.13982016f, -0.09941679f, -0.03404814f, -0.07524952f, -0.01762701f, -0.14366083f, -0.20745447f, 
    0.13007285f, 0.13135776f, 0.04593445f, 0.12593773f, 0.02543038f, -0.08031044f, 0.13589390f, 0.02804695f, 
    0.25558504f, 0.18484415f, 0.25037506f, -0.00544515f, -0.00525228f, -0.05018973f, -0.02565571f, -0.14560713f, 
    0.02954225f, 0.03735043f, -0.04761246f, 0.00420154f, 0.00993605f, -0.05125188f, -0.03490494f, -0.23296046f, 
    0.06701373f, 0.09816494f, 0.04964482f, 0.33656779f, -0.04470236f, 0.17156105f, -0.06089809f, -0.06661335f, 
    0.00376894f, -0.27081791f, -0.13342535f, -0.02758060f, 0.05474849f, 0.04162545f, 0.11800937f, 0.07936567f, 
    0.08812366f, -0.00487375f, 0.02468570f, -0.05816414f, 0.00740937f, -0.06992481f, 0.03219233f, -0.03516485f, 
    0.05818932f, 0.00012337f, -0.12934284f, 0.15683153f, -0.05607706f, 0.01714772f, 0.00723478f, -0.09595232f, 
    -0.05790707f, 0.01563689f, -0.16961834f, -0.01066240f, -0.02633957f, 0.03165932f, -0.00879378f, -0.11859687f, 
    -0.14551111f, 0.09345610f, 0.20910580f, 0.07783146f, -0.06151459f, -0.16172871f, -0.00670436f, -0.12325545f, 
    -0.11958381f, -0.12433363f, -0.04707575f, -0.03563746f, 0.00591014f, 0.06515723f, 0.26088154f, 0.12195233f, 
    -0.03770969f, -0.00853328f, 0.03525939f, 0.02014599f, 0.02463856f, -0.00185013f, 0.00653669f, 0.01261483f, 
    0.01071204f, 0.00364076f, -0.00417868f, 0.00335750f, -0.01376878f, 0.02687776f, 0.00859066f, -0.02686615f, 
    0.02354045f, 0.00051849f, 0.02983632f, -0.00739655f, -0.03307792f, -0.03948104f, -0.03499836f, 0.02603932f, 
    -0.01049629f, 0.02175142f, -0.01451056f, -0.00335499f, -0.03422551f, 0.02126238f, -0.00461311f, -0.01627657f, 
    0.02406437f, 0.02454249f, -0.03984144f, -0.01348888f, -0.00196165f, -0.01708727f, -0.01723462f, 0.03200926f, 
    0.01535058f, -0.03396827f, -0.01236816f, 0.01473939f, -0.01923159f, -0.04103726f, 0.02744001f, -0.00517652f, 
    -0.01974313f, -0.00969831f, -0.01314640f, 0.02392778f, -0.00313756f, 0.03310541f, -0.02436919f, 0.01153618f, 
    0.02874117f, 0.02413091f, 0.02275589f, 0.01154182f, -0.02580721f, -0.02124329f, 0.00767435f, 0.00262802f, 
    0.00648822f, -0.01356835f, 0.02719741f, -0.03201411f, 0.00035748f, -0.01208369f, -0.02754862f, 0.01861516f, 
    0.02567267f, 0.03045649f, 0.01339975f, -0.03275049f, -0.00818291f, -0.01670724f, 0.01820419f, 0.00764433f, 
    -0.00231204f, -0.00893524f, 0.00176972f, -0.01982185f, -0.03037379f, 0.02296228f, 0.00889527f, -0.00697092f, 
    0.00937236f, 0.00048495f, 0.02622449f, 0.01093432f, 0.02110413f, -0.00385658f, -0.03409410f, 0.00132251f, 
    -0.00158679f, 0.02689267f, 0.00654361f, -0.02963248f, 0.00988102f, -0.01959894f, 0.00731023f, 0.01121390f, 
    -0.03851262f, -0.02781453f, -0.03032821f, -0.01933425f, -0.00927058f, 0.00159483f, -0.00400423f, -0.03514543f, 
    -0.03290984f, 0.03935044f, -0.01873963f, 0.00275230f, 0.03076744f, -0.01333641f, 0.01990344f, 0.02384449f, 
    -0.00822839f, 0.00120096f, -0.00960624f, 0.03499416f, -0.04005801f, 0.01089607f, 0.00179335f, 0.00280407f, 
    -0.00193838f, -0.01568408f, -0.00953117f, -0.00644492f, -0.01370140f, -0.00962429f, 0.01575903f, 0.02560159f, 
    -0.01712722f, 0.02572232f, 0.00837220f, 0.01528963f, 0.00588817f, 0.02997220f, 0.02791824f, -0.02955657f, 
    0.00940768f, 0.02350174f, -0.01132077f, -0.00361911f, 0.02695168f, 0.03269404f, 0.01245983f, 0.00233467f, 
    -0.02404801f, -0.01039661f, -0.01104600f, 0.00259566f, 0.00182392f, -0.01327048f, 0.00955946f, -0.01578225f, 
    -0.00772587f, -0.03091384f, 0.00105894f, 0.01879033f, 0.02334486f, -0.01070196f, -0.00676800f, -0.02608681f, 
    -0.03242103f, 0.01557078f, -0.01419468f, 0.00989491f, -0.01157423f, -0.01366859f, 0.01751269f, 0.01666889f, 
    -0.02780967f, -0.00609293f, -0.00823032f, -0.00861986f, 0.01968118f, -0.02916985f, -0.01153620f, 0.00056764f, 
    -0.00244264f, 0.00353421f, 0.01104055f, 0.02529164f, -0.01357801f, 0.02218595f, -0.00364217f, -0.01727974f, 
    0.01399971f, -0.03481746f, -0.02649892f, 0.00168068f, -0.01987334f, 0.01210125f, -0.02179413f, -0.03275781f, 
    -0.02271335f, -0.02973646f, -0.03111717f, 0.02507392f, -0.01241355f, 0.03153613f, 0.00424441f, 0.02249223f, 
    0.01383035f, 0.02211105f, -0.02622358f, 0.00441661f, -0.02776487f, -0.03351108f, -0.02249564f, 0.02856898f, 
    -0.01444445f, -0.01704540f, 0.01558619f, -0.03557737f, -0.02708152f, 0.00541507f, 0.02970506f, -0.02126167f, 
    0.01349426f, 0.01593533f, -0.01510882f, -0.00760238f, 0.02147390f, 0.02714322f, -0.00510060f, 0.02828280f, 
    -0.01543396f, -0.03218731f, -0.02068783f, -0.02293801f, 0.02139056f, 0.01612285f, -0.00159962f, -0.02914844f, 
    -0.00548487f, -0.04357820f, -0.03914177f, 0.00708543f, 0.01867527f, -0.01340911f, 0.00032550f, -0.02272521f, 
    -0.02524422f, -0.02929936f, -0.02731874f, -0.02748334f, -0.03887583f, 0.00250766f, -0.02631313f, 0.00344388f, 
    0.00050586f, -0.02531871f, -0.01812741f, -0.00339851f, -0.00432950f, -0.00138519f, 0.02660291f, -0.03039851f, 
    -0.00267618f, -0.00507424f, -0.03238484f, -0.03438071f, 0.03251484f, -0.02813952f, 0.01131284f, -0.00375941f, 
    0.01463462f, -0.02812068f, 0.00720638f, -0.01671509f, -0.03510591f, 0.03348741f, 0.00227404f, 0.02573758f, 
    -0.03803965f, 0.00089809f, 0.03331817f, -0.02909320f, -0.01110680f, -0.02236087f, -0.00280640f, 0.00262005f, 
    -0.03135289f, -0.01536115f, 0.03294774f, 0.02922665f, -0.00611626f, -0.01764653f, -0.03482392f, -0.00685136f, 
    -0.01608138f, 0.00867409f, -0.02615454f, -0.04092423f, -0.02963931f, 0.00870062f, 0.02779742f, 0.01226384f, 
    -0.03045586f, 0.00207071f, 0.00923968f, 0.02661858f, -0.03744868f, -0.00636524f, 0.00139252f, -0.02143786f, 
    -0.02451288f, 0.02216099f, 0.03250154f, 0.01738667f, 0.00470179f, -0.02350425f, -0.02132739f, -0.02078297f, 
    -0.04025092f, -0.01196512f, -0.03770749f, 0.00134983f, -0.00133477f, -0.01305680f, 0.03748090f, 0.00315385f, 
    -0.00723351f, 0.02988579f, 0.00874111f, 0.01014411f, -0.01480388f, -0.03612779f, 0.03220098f, 0.02330907f, 
    0.00797948f, 0.02598032f, 0.01647088f, -0.03693370f, -0.02768033f, 0.01863396f, -0.00412691f, -0.01996715f, 
    -0.01541472f, -0.02557053f, -0.01663579f, 0.01958694f, 0.02289023f, -0.00985316f, 0.01937982f, -0.03913443f, 
    -0.02045599f, -0.01436563f, 0.01125846f, -0.01806631f, -0.00041129f, -0.02730097f, 0.00532647f, 0.03092664f, 
    -0.03032842f, -0.00609763f, -0.00102029f, 0.00803758f, -0.02657577f, -0.02551531f, -0.03698549f, -0.00753818f, 
    -0.01206098f, -0.03363276f, -0.00361151f, -0.03158983f, 0.00310372f, 0.00691142f, -0.00050562f, -0.01746991f, 
    -0.02288500f, 0.02528082f, 0.02818560f, -0.00421660f, 0.02912335f, -0.02967584f, -0.00134920f, 0.01886178f, 
    -0.01747038f, 0.02629722f, -0.00068510f, -0.00989786f, -0.02837723f, -0.00432513f, 0.03991253f, -0.02440495f, 
    -0.00043207f, -0.03356136f, -0.01801781f, 0.01418360f, -0.00021410f, 0.02911467f, -0.01870451f, -0.02151005f, 
    0.01634997f, -0.02409220f, -0.01068668f, -0.01143435f, -0.00254034f, 0.01247892f, -0.02978970f, 0.03216989f, 
    -0.02156730f, 0.01096082f, 0.01299723f, 0.00254002f, 0.01241515f, 0.02795104f, -0.00049854f, -0.00778344f, 
    -0.00532739f, 0.03558373f, -0.00211002f, -0.01326691f, 0.00871065f, -0.02386732f, 0.02475232f, 0.00369738f, 
    0.00750108f, 0.01798704f, -0.04223255f, 0.00212601f, -0.02283285f, 0.01952992f, 0.01506879f, 0.02014722f, 
    -0.03200450f, -0.03089561f, -0.03853867f, -0.02853302f, -0.00189469f, 0.02012489f, 0.01433779f, 0.03323859f, 
    -0.00983097f, 0.01640819f, 0.01415024f, 0.00519990f, -0.02778630f, -0.02281709f, -0.00887054f, -0.02569573f, 
    -0.00483130f, -0.01532557f, -0.02826167f, -0.02455122f, -0.02052288f, -0.01545127f, 0.01355004f, -0.02445892f, 
    0.00494369f, -0.01450585f, -0.00989479f, 0.02333981f, -0.00371242f, 0.01583656f, -0.03337347f, -0.02806978f, 
    0.00311024f, -0.03751354f, -0.02074254f, 0.01669486f, 0.01265945f, -0.01417498f, -0.01494350f, -0.01014398f, 
    -0.00297774f, 0.01434697f, -0.01091984f, 0.00199872f, 0.03132855f, -0.02048528f, 0.02349279f, -0.00305017f, 
    -0.00390716f, 0.00458354f, 0.02808260f, 0.00276930f, -0.01906866f, 0.01964413f, 0.02139697f, -0.03247430f, 
    0.00201445f, -0.03638169f, -0.02546460f, -0.01144701f, 0.02672894f, -0.03649325f, -0.02000603f, 0.00878703f, 
    0.00813419f, 0.02862181f, 0.00344272f, -0.00886391f, -0.01822177f, 0.01984034f, 0.01866101f, -0.02404708f, 
    -0.02344917f, -0.03841353f, 0.00006380f, 0.00810078f, -0.01133837f, -0.02030016f, 0.02000408f, -0.03824168f, 
    0.00277538f, -0.03893446f, 0.00025542f, 0.00158581f, 0.00996159f, 0.00595017f, 0.01479734f, -0.01099144f, 
    -0.03205136f, 0.00299148f, -0.01603046f, 0.00616261f, -0.03895558f, 0.02355751f, -0.00907131f, 0.00468677f, 
    -0.02635744f, -0.00570008f, -0.00768564f, 0.01491106f, 0.01157262f, 0.01954409f, 0.00293746f, -0.02522395f, 
    -0.02830182f, 0.02120015f, -0.02117925f, -0.02639597f, -0.02846782f, -0.01840612f, 0.01876411f, 0.00746328f, 
    -0.03936490f, 0.01999343f, -0.00894149f, -0.01150525f, -0.00566007f, -0.01183108f, -0.00322859f, -0.01231999f, 
    -0.03374269f, 0.00427013f, -0.03611390f, -0.02265466f, 0.00304916f, 0.01959691f, 0.02958420f, 0.02676716f, 
    -0.03046005f, 0.02503023f, -0.03643926f, -0.01570002f, 0.01009754f, 0.01704888f, -0.02611598f, 0.01328307f, 
    -0.01256015f, -0.02182298f, 0.00291266f, -0.02603647f, -0.03341762f, -0.00348678f, 0.03030701f, -0.01480685f, 
    0.00242559f, -0.00149318f, -0.01287196f, -0.02883851f, -0.00574109f, -0.01549587f, 0.01838790f, -0.00963693f, 
    0.02628078f, 0.03133664f, 0.02054022f, -0.00471008f, -0.01633191f, -0.01891225f, 0.01891590f, 0.01447477f, 
    0.03040347f, -0.03262575f, 0.03323931f, 0.01796383f, 0.01847615f, -0.02586791f, -0.03202800f, 0.02009770f, 
    -0.02955614f, 0.04234099f, 0.02267630f, -0.00352808f, 0.01276440f, -0.01054838f, 0.00768285f, 0.02954933f, 
    -0.00673312f, -0.02473289f, -0.02828856f, -0.01073411f, -0.01533384f, 0.00992504f, 0.03845187f, -0.01352033f, 
    0.04430552f, 0.01246615f, 0.00722236f, -0.01469399f, -0.00454945f, 0.02619412f, -0.03329370f, 0.04014128f, 
    0.01778247f, -0.04109163f, 0.00512115f, -0.01531639f, 0.01245019f, -0.02465989f, -0.00143930f, 0.00167996f, 
    0.01288366f, 0.01436180f, -0.01239246f, -0.00468608f, -0.00298157f, 0.01492070f, -0.01061238f, 0.00120853f, 
    0.00009386f, 0.00221381f, -0.02475538f, -0.01944622f, 0.02753284f, -0.01456846f, -0.02115172f, 0.03298469f, 
    -0.02245278f, 0.01456002f, 0.03449871f, -0.01836736f, -0.01959823f, -0.04200890f, -0.02951049f, -0.02705496f, 
    -0.02619857f, -0.01995632f, -0.01194403f, 0.00438061f, -0.03678892f, 0.01295810f, 0.00640819f, 0.02620279f, 
    -0.01405112f, 0.00220800f, -0.02397365f, 0.02654834f, -0.00905082f, -0.02972043f, -0.01669898f, 0.01841832f, 
    -0.02036698f, -0.03104616f, 0.01598138f, -0.03263646f, 0.01976973f, -0.01584888f, -0.01935968f, 0.00340559f, 
    0.01808369f, 0.00577715f, -0.00519732f, -0.02738610f, 0.01719168f, 0.01364764f, -0.01361555f, 0.00527606f, 
    0.00549579f, -0.02696820f, -0.01219420f, 0.00090448f, 0.02653769f, 0.02381789f, 0.00870310f, -0.00588935f, 
    0.02287532f, 0.00996827f, 0.03392271f, -0.00781192f, 0.01726002f, -0.02581498f, 0.00383645f, 0.02209135f, 
    -0.02554888f, 0.01147292f, -0.03183954f, 0.01301248f, -0.04140501f, -0.01378203f, -0.01620982f, 0.02011256f, 
    0.01321286f, -0.03070719f, -0.00588427f, -0.02966220f, -0.02795162f, -0.01372034f, -0.00656053f, -0.02859117f, 
    -0.02623727f, 0.01240604f, 0.01507698f, -0.03204856f, -0.00212136f, 0.00817578f, -0.01845995f, 0.00769237f, 
    -0.00523336f, -0.02761927f, -0.02644547f, -0.02792969f, 0.01656164f, 0.02576870f, 0.01364517f, -0.03554633f, 
    -0.03022494f, -0.00807193f, 0.01375117f, 0.02327934f, -0.02833788f, 0.03696316f, -0.01630905f, -0.01705684f, 
    0.01022580f, 0.01453205f, -0.00861364f, -0.03272145f, 0.00205156f, 0.00289544f, -0.01441820f, -0.00318433f, 
    -0.03698522f, -0.00198957f, 0.00480039f, 0.01635713f, -0.02813850f, 0.00945425f, 0.00543292f, 0.01028455f, 
    -0.00394955f, 0.00280377f, -0.00071668f, 0.02350709f, -0.00766526f, 0.02085553f, 0.01252586f, 0.02179690f, 
    0.00337208f, -0.04084219f, -0.02614318f, 0.00780697f, -0.02745574f, -0.02179187f, -0.02138923f, -0.02713459f, 
    -0.00531267f, -0.00755678f, 0.01030296f, -0.02118891f, -0.01863470f, 0.00774171f, -0.03017430f, 0.02468426f, 
    0.02452984f, -0.00202423f, 0.00434437f, -0.01601266f, 0.02902013f, -0.01911547f, -0.01741586f, 0.01813147f, 
    -0.01031165f, -0.01829153f, 0.02084556f, -0.03980281f, -0.00092490f, -0.01369268f, -0.03483643f, 0.01204772f, 
    0.02462885f, 0.00285107f, -0.00907018f, 0.01867743f, -0.01486277f, 0.03108854f, 0.02035174f, 0.03340231f, 
    -0.02941331f, 0.01935970f, -0.02447921f, -0.04037458f, -0.04182794f, 0.02408146f, 0.01023097f, -0.01744550f, 
    -0.01927237f, -0.00567159f, -0.03597047f, -0.01411685f, -0.02556725f, -0.00947142f, -0.02793241f, -0.02488164f, 
    -0.00539676f, -0.00054453f, 0.03095837f, 0.01201174f, 0.00057358f, -0.04122255f, 0.02902705f, -0.02859926f, 
    -0.00739462f, -0.02290100f, -0.02279500f, -0.00522191f, 0.00017025f, 0.01821378f, 0.02584451f, 0.03416744f, 
    0.02297899f, 0.03348549f, -0.03108745f, -0.01937190f, 0.03197044f, -0.02151949f, 0.00481386f, 0.01263423f, 
    0.00375729f, -0.03399285f, -0.00784709f, -0.02635737f, -0.02636977f, 0.01645756f, 0.00232919f, -0.00316186f, 
    0.02438704f, -0.04142919f, 0.01645658f, -0.01469719f, -0.03280087f, -0.01640975f, -0.00332392f, -0.02698064f, 
    -0.00574237f, -0.02270804f, -0.02606530f, 0.02921321f, 0.02117026f, -0.01227361f, 0.00464790f, -0.01512488f, 
    -0.04603464f, -0.03552850f, -0.04204008f, -0.01456192f, 0.02154049f, 0.02348641f, 0.00070712f, -0.01887071f, 
    -0.02373904f, 0.00165726f, 0.01380770f, -0.03350972f, -0.01083480f, -0.04164305f, -0.01163859f, -0.00399436f, 
    -0.03273354f, 0.00656923f, 0.00701285f, 0.02859704f, -0.01237058f, -0.02644583f, 0.03413285f, 0.01681248f, 
    -0.02430680f, -0.02456953f, -0.01660732f, 0.00722948f, -0.00441250f, 0.03317791f, 0.02245079f, 0.00631539f, 
    0.00033054f, -0.01039028f, -0.01607617f, -0.03414486f, -0.02214933f, 0.00350332f, -0.01571432f, -0.04575412f, 
    0.03272019f, -0.00783603f, 0.01246847f, 0.01329304f, 0.02733029f, -0.01861542f, 0.01408889f, -0.01677391f, 
    -0.01809474f, -0.00786766f, -0.01982753f, 0.00635984f, 0.01239270f, 0.01984016f, 0.00308630f, 0.03519053f, 
    -0.01728948f, 0.02613536f, -0.00676888f, -0.00103696f, -0.00509170f, -0.04515635f, -0.02545993f, -0.01430637f, 
    0.00988836f, -0.02850834f, -0.02930063f, -0.01943628f, 0.02876324f, -0.02244565f, -0.00632309f, -0.01566033f, 
    -0.02456022f, 0.01404127f, 0.02091364f, 0.01092964f, -0.00858286f, -0.02872656f, -0.00894390f, -0.04648637f, 
    -0.00932120f, 0.00852160f, 0.01193506f, -0.01672347f, 0.00833710f, -0.00358807f, 0.01799056f, -0.00446153f, 
    0.03162636f, 0.02285107f, -0.02024910f, -0.02815961f, 0.00417410f, 0.00920171f, -0.01359603f, -0.00788625f, 
    0.00953208f, -0.04342103f, 0.01332187f, -0.00115577f, -0.03975270f, -0.01848240f, -0.00362092f, -0.03578798f, 
    -0.00223412f, -0.02719419f, 0.00693077f, 0.03740533f, -0.03901259f, 0.01325940f, 0.03061573f, -0.03005974f, 
    -0.00430550f, -0.03797248f, 0.02857680f, -0.01502698f, -0.03203557f, -0.00985894f, -0.03216560f, -0.02122073f, 
    0.01185531f, 0.01865482f, 0.00552991f, 0.00002128f, -0.01933581f, 0.01500474f, -0.01011189f, -0.02431946f, 
    -0.00755755f, -0.00285856f, 0.00370983f, -0.02777153f, 0.01791980f, 0.02510894f, -0.01112240f, -0.00262359f, 
    0.03363186f, 0.00345182f, 0.01186600f, -0.00712645f, -0.02164218f, 0.00652414f, 0.01703021f, -0.00454373f, 
    -0.02728630f, -0.04400602f, 0.01024455f, -0.03269782f, 0.00372549f, -0.00386818f, -0.02489856f, -0.00249632f, 
    -0.02113661f, 0.01286358f, 0.01668589f, 0.01760082f, -0.03193479f, -0.02611026f, 0.01523744f, 0.02802443f, 
    0.00518189f, -0.02409335f, -0.00952500f, 0.00054939f, 0.01140218f, 0.02008443f, -0.03851237f, -0.03634175f, 
    0.01986446f, 0.02780342f, 0.02124034f, -0.02651531f, -0.00092913f, -0.01385608f, 0.01081540f, -0.02948544f, 
    0.03206956f, -0.01196675f, -0.03687223f, 0.03374093f, -0.01855003f, -0.00295630f, -0.00992377f, -0.00265381f, 
    -0.01857708f, -0.03683013f, -0.00256427f, -0.02670240f, -0.03003124f, 0.02488447f, 0.02727747f, -0.00401427f, 
    -0.02877297f, 0.00565995f, -0.01294625f, -0.02538206f, -0.00592622f, -0.03379449f, -0.03114716f, 0.03805440f, 
    0.03747101f, -0.01912822f, -0.01202143f, 0.02638896f, -0.00103839f, -0.02919394f, -0.03052355f, -0.01082904f, 
    0.01820899f, 0.00470772f, -0.02521149f, -0.03452136f, -0.04692144f, -0.03283180f, -0.03437127f, -0.01367991f, 
    -0.03363751f, -0.00325903f, -0.01023875f, 0.00253379f, -0.01991982f, -0.04211782f, -0.01729532f, -0.03806874f, 
    -0.01570808f, -0.03659781f, 0.00166986f, 0.01244408f, -0.03141683f, -0.00521518f, -0.03070540f, -0.02703143f, 
    0.03047291f, 0.03670616f, -0.03470408f, -0.02526908f, 0.02661525f, 0.00325264f, -0.00367169f, -0.00266111f, 
    -0.03479676f, -0.00561359f, -0.04190504f, -0.01647111f, 0.03522666f, 0.03054539f, -0.01979553f, -0.02018263f, 
    0.00824885f, -0.00911976f, -0.03743696f, -0.01043300f, -0.02215324f, -0.00799719f, -0.00896211f, 0.00571013f, 
    -0.01112254f, 0.02523925f, 0.01433264f, -0.03805236f, -0.00567674f, -0.00297503f, -0.02611990f, -0.02815371f, 
    -0.00552525f, -0.00343180f, 0.02765303f, 0.01496547f, 0.00781735f, 0.02927455f, 0.03297379f, -0.03055795f, 
    0.02930295f, -0.00729006f, 0.00258243f, 0.02333334f, 0.02182032f, -0.01682768f, -0.00529020f, -0.00220398f, 
    0.03609880f, -0.00686891f, -0.00837358f, -0.03341763f, -0.01214726f, 0.01832262f, -0.00078148f, -0.02491318f, 
    0.01253260f, 0.00283578f, -0.01650474f, 0.00897294f, -0.03364124f, 0.01086845f, -0.02518821f, 0.01922417f, 
    -0.01752597f, -0.04522311f, -0.01773372f, 0.01821781f, -0.02237718f, -0.00898252f, 0.02607632f, 0.03268703f, 
    -0.03279340f, 0.01191178f, -0.03510619f, -0.03441173f, -0.02353362f, -0.02692476f, -0.02021564f, -0.03908070f, 
    0.02948587f, 0.02727248f, -0.01637639f, -0.03536250f, -0.03507393f, -0.03704130f, 0.01461862f, 0.00002534f, 
    -0.02693183f, 0.00520893f, 0.00452145f, -0.04275906f, -0.03024232f, 0.03670627f, 0.00782781f, 0.00338730f, 
    -0.01222100f, -0.03769210f, -0.00155921f, -0.02522242f, -0.02559588f, 0.00935558f, -0.00900512f, -0.01620963f, 
    -0.00549268f, 0.02050508f, -0.04031153f, -0.03153575f, 0.04274463f, 0.03677720f, -0.00309916f, 0.02326026f, 
    0.02953911f, 0.01843440f, -0.00523066f, -0.01688943f, -0.03382849f, -0.01646765f, -0.04187359f, 0.01195588f, 
    -0.04271789f, 0.01835438f, 0.00111255f, -0.00182583f, 0.02338944f, -0.00812968f, -0.02550660f, 0.00443287f, 
    0.02712218f, 0.02389590f, -0.01029434f, 0.01254747f, 0.01012392f, -0.00678588f, 0.02455322f, 0.03105262f, 
    -0.03605231f, -0.02259565f, -0.03337638f, 0.00234284f, 0.02906854f, -0.00691518f, -0.04026687f, 0.01839042f, 
    -0.01558501f, 0.01151867f, 0.01799822f, -0.02579822f, 0.00529412f, 0.00722736f, -0.01219766f, -0.00085707f, 
    0.00534426f, -0.01043363f, 0.02645629f, 0.00169123f, -0.00173124f, 0.01756099f, 0.01374025f, -0.01015005f, 
    -0.03578425f, -0.01343102f, -0.01226823f, -0.02023617f, 0.01965986f, 0.00144687f, -0.00235133f, -0.01174286f, 
    0.02545355f, -0.03907008f, 0.00965913f, -0.03698039f, 0.03053607f, -0.03696480f, 0.02807264f, -0.00715780f, 
    -0.03060579f, 0.00198065f, -0.03517007f, 0.01055943f, -0.01508709f, 0.00605721f, -0.03250049f, -0.02753836f, 
    -0.01894064f, -0.03396878f, -0.02282151f, 0.02882729f, 0.01710593f, -0.00285389f, -0.04484065f, -0.01926964f, 
    -0.01418325f, 0.01968682f, -0.03375015f, 0.01321310f, 0.02752385f, -0.02217766f, 0.01914981f, 0.01396874f, 
    0.02042298f, 0.01072148f, -0.02909329f, 0.00624534f, -0.00553134f, 0.01937435f, 0.01428643f, -0.02319677f, 
    0.00988810f, 0.00962973f, 0.02423959f, 0.02271368f, 0.01303927f, -0.02486826f, 0.00722368f, -0.01190381f, 
    0.01484489f, -0.00386079f, -0.01767926f, -0.02948661f, -0.03985029f, -0.00498960f, 0.02575752f, -0.00411319f, 
    -0.01936342f, -0.02874289f, -0.00782058f, 0.02743230f, 0.00419418f, -0.01915827f, -0.03816389f, -0.02400689f, 
    0.00498547f, 0.01638081f, 0.02783338f, -0.01210556f, -0.01115200f, 0.01258684f, -0.04358491f, -0.01549993f, 
    0.02142623f, -0.01992195f, -0.00466016f, 0.02263522f, 0.00324125f, -0.01903944f, -0.03474778f, 0.03240265f, 
    -0.03191250f, -0.01291228f, -0.03189152f, 0.02040890f, 0.04337409f, -0.00483302f, -0.01217116f, 0.02964036f, 
    -0.00359247f, 0.02032314f, -0.03226831f, 0.02528529f, -0.00104250f, -0.02256991f, 0.00672677f, 0.00211929f, 
    0.01377921f, 0.02171701f, -0.02955455f, -0.02837193f, -0.00789187f, -0.02604843f, -0.03646382f, -0.03366199f, 
    0.03186715f, -0.02306366f, -0.02424232f, -0.02406129f, 0.00088239f, 0.01832709f, 0.01610814f, -0.00091651f, 
    0.02276775f, -0.02393126f, 0.01069059f, 0.01167850f, -0.00114810f, 0.01832117f, -0.01634949f, -0.04622950f, 
    0.00372506f, -0.02004600f, 0.03200562f, -0.02437406f, -0.03271211f, 0.00813663f, 0.00733964f, 0.02570045f, 
    -0.01768238f, -0.02873643f, -0.04386325f, -0.00041963f, 0.00345559f, -0.01353884f, 0.00715254f, -0.02852462f, 
    0.01738689f, 0.01479027f, -0.02827358f, 0.00884084f, -0.02618407f, -0.01424990f, 0.00519056f, -0.01391854f, 
    -0.02236249f, -0.01656090f, 0.01328905f, 0.02484406f, -0.00791271f, -0.01657486f, 0.02953853f, -0.00606430f, 
    0.00931303f, -0.04242194f, 0.02460275f, -0.02172903f, -0.00556470f, -0.00080744f, -0.02703467f, 0.03166267f, 
    -0.03742217f, -0.02420384f, -0.03388724f, -0.00569380f, 0.01570089f, -0.00299180f, 0.02889368f, 0.00393104f, 
    -0.00931947f, -0.03000573f, -0.03493684f, -0.01192063f, 0.02661640f, 0.02344638f, -0.00599852f, -0.03566340f, 
    0.00625156f, -0.00220937f, 0.00097791f, 0.00286957f, -0.01929744f, -0.03958672f, 0.01908548f, -0.01273562f, 
    0.00333276f, 0.03304890f, -0.02661081f, 0.03117223f, 0.00009667f, -0.00378019f, 0.01950135f, -0.01148615f, 
    -0.00832499f, 0.01702498f, 0.01745904f, -0.00983486f, -0.00073160f, -0.01764734f, 0.00905842f, -0.04277360f, 
    -0.03082913f, -0.00818320f, 0.02425473f, -0.00967891f, -0.01997491f, 0.01112727f, 0.00947664f, -0.01085023f, 
    -0.03792590f, -0.02296608f, -0.00304372f, 0.01038673f, -0.02640575f, -0.01195728f, -0.03274604f, 0.02434484f, 
    -0.01574018f, 0.02470825f, 0.00905964f, 0.00723559f, 0.03526023f, -0.01840409f, 0.01490918f, -0.02060980f, 
    0.02019301f, -0.01055304f, -0.00521876f, 0.00301863f, -0.03124143f, -0.02241868f, -0.00381551f, -0.00318771f, 
    0.00498266f, 0.02687577f, 0.00301407f, -0.03166341f, -0.03877769f, 0.01098751f, 0.02261301f, -0.01401378f, 
    -0.03183969f, 0.01707240f, 0.01454421f, 0.00895559f, -0.02036470f, 0.01775073f, 0.00212537f, -0.03697384f, 
    -0.02620036f, 0.02326823f, 0.00649327f, 0.01996740f, -0.03964578f, -0.01203806f, 0.00330085f, -0.02953264f, 
    -0.02649090f, 0.00023393f, 0.01300763f, -0.01021650f, 0.00339925f, 0.02251527f, -0.01772371f, 0.01057132f, 
    -0.03902108f, -0.08325201f, -0.03362303f, -0.03189981f, -0.03581867f, -0.00503864f, 0.01318715f, 0.10499728f, 
    0.00395229f, 0.14057535f, 0.01542139f, 0.10158032f, 0.22839396f, 0.25035441f, -0.00455556f, 0.05756145f, 
    0.10478544f, 0.16702160f, 0.06015693f, 0.03422030f, -0.11814418f, -0.15139084f, -0.09410426f, -0.02087157f, 
    -0.47448450f, 0.21630634f, 0.13904326f, -0.20815903f, -0.12407238f, -0.17108464f, -0.03310177f, 0.07202691f, 
    -0.09094985f, 0.04869663f, 0.10701853f, -0.04747443f, 0.24098343f, 0.21500108f, -0.16280478f, -0.12253827f, 
    -0.01463647f, 0.08445635f, 0.03203118f, 0.01176769f, 0.02943457f, -0.03824903f, -0.03467748f, -0.02073649f, 
    -0.13579296f, -0.11687881f, -0.07694215f, -0.11090443f, 0.01498776f, -0.03583467f, -0.09174702f, -0.01482612f, 
    -0.00518025f, -0.01508044f, -0.00631124f, 0.05466845f, -0.18471058f, 0.05462344f, -0.15398532f, -0.05264472f, 
    -0.10664650f, -0.09360822f, -0.05280820f, -0.06090599f, -0.06534251f, -0.13905495f, 0.02081895f, -0.05341516f, 
    0.04516791f, 0.26255733f, 0.37862977f, -0.28850922f, 0.02501264f, 0.24846509f, 0.06075962f, 0.12516528f, 
    0.14051254f, -0.08531559f, -0.03390314f, -0.03999436f, -0.25210062f, -0.19708383f, 0.18770985f, 0.02925695f, 
    -0.05251694f, -0.03898624f, 0.00611301f, -0.12966457f, -0.06160391f, 0.00929125f, -0.05836366f, 0.04675721f, 
    0.01313776f, 0.20852251f, 0.36026472f, 0.03697517f, -0.03918892f, 0.02117801f, 0.13188758f, 0.08020701f, 
    0.11575324f, 0.05355615f, 0.01616448f, 0.06292313f, 0.28081173f, 0.14977273f, -0.03332525f, 0.17142218f, 
    0.11466940f, -0.02025051f, 0.07666958f, 0.18679808f, -0.07075718f, 0.01196287f, -0.04745977f, -0.00178676f, 
    -0.01592923f, -0.04519450f, -0.21683809f, 0.11623362f, -0.07075589f, -0.01797673f, -0.00032191f, 0.01186628f, 
    0.07993730f, 0.00508930f, 0.12592357f, -0.01643599f, -0.08398826f, 0.02710667f, 0.14771432f, 0.01824741f, 
    -0.04237235f, 0.01894686f, -0.07429095f, -0.06439926f, 0.07205414f, -0.00274476f, -0.04778913f, 0.04361928f, 
    0.03245715f, 0.22948389f, 0.22924826f, -0.10761417f, -0.03636549f, -0.00554175f, 0.09469793f, 0.06313393f, 
    0.12225733f, 0.04686439f, 0.11862361f, 0.03325675f, 0.10351375f, 0.26090106f, 0.30201679f, 0.00660986f, 
    -0.01003054f, 0.01772153f, 0.09995231f, 0.18046486f, -0.06743596f, 0.06194907f, -0.05833799f, 0.05476304f, 
    0.27282792f, 0.24463157f, 0.13522968f, -0.01269910f, 0.21913649f, 0.27108729f, 0.13027839f, 0.15613550f, 
    -0.04949927f, -0.08322579f, -0.08776290f, -0.00887956f, -0.23149446f, 0.01378212f, 0.19148521f, 0.03073103f, 
    -0.08577999f, -0.02027540f, -0.06481375f, 0.19874023f, -0.07163154f, -0.02214726f, -0.15488710f, -0.25685900f, 
    0.21848866f, 0.12257925f, -0.10198703f, 0.09928468f, -0.08672851f, 0.07351676f, 0.11660636f, 0.02989596f, 
    0.08680566f, 0.06245341f, 0.03533456f, 0.01817638f, -0.31504688f, -0.21891239f, -0.22315371f, -0.13813505f, 
    -0.17384782f, 0.00468670f, -0.07564901f, -0.04036059f, -0.01770397f, -0.03691838f, 0.04349659f, 0.13845700f, 
    0.24017154f, 0.07275664f, 0.22102958f, 0.05080503f, -0.01271377f, 0.00543493f, 0.04299964f, 0.21979699f, 
    -0.08934537f, 0.08012005f, 0.04342264f, -0.06163808f, 0.13099112f, 0.05540459f, -0.06095633f, 0.02366056f, 
    0.11075912f, -0.04975784f, -0.00647774f, 0.06872843f, -0.11025903f, 0.02105637f, -0.04834894f, -0.00807831f, 
    0.19030111f, 0.09922800f, 0.05591059f, -0.14433365f, -0.14290322f, -0.04763688f, -0.00817450f, -0.00516547f, 
    0.07370900f, 0.05873265f, 0.04573563f, -0.12956825f, 0.20870090f, 0.12867667f, 0.07559209f, -0.05235896f, 
    0.03253129f, 0.09143506f, 0.10203807f, 0.09593224f, -0.16374214f, 0.02332581f, -0.00581731f, 0.00857398f, 
    0.14212030f, 0.06403147f, -0.22039098f, 0.03771479f, 0.06120657f, 0.03705840f, 0.01441952f, -0.14251417f, 
    0.02428676f, 0.09759708f, -0.07673438f, -0.10147484f, 0.07238167f, -0.02492544f, -0.10617366f, 0.28313187f, 
    -0.03505425f, 0.07995820f, 0.11777183f, 0.08031078f, 0.13355620f, 0.00122598f, -0.03695699f, 0.00734755f, 
    -0.02821541f, -0.14544967f, -0.15197498f, -0.02695786f, -0.03549523f, 0.05877792f, 0.09284540f, -0.00699670f, 
    0.12091174f, 0.13069603f, 0.14069133f, 0.07577626f, 0.05314977f, -0.08013404f, -0.08753954f, -0.17862944f, 
    0.15584552f, 0.07635822f, -0.02702004f, -0.02720017f, 0.08607520f, 0.22028445f, 0.06753106f, 0.06564817f, 
    0.01384627f, -0.00518633f, -0.04223298f, -0.01803654f, -0.09863191f, -0.09074080f, -0.11272506f, -0.07368786f, 
    -0.03339665f, -0.07925543f, 0.04032813f, -0.20015465f, 0.12990989f, -0.30453825f, -0.51032478f, -0.02057562f, 
    -0.06111772f, -0.04784418f, -0.08499873f, 0.01985900f, 0.11519734f, -0.05196901f, -0.11054403f, -0.21305142f, 
    0.25542659f, 0.20260741f, 0.04565258f, 0.00617951f, 0.25993422f, 0.22609703f, 0.07149724f, 0.11316047f, 
    -0.09815019f, -0.09232485f, -0.10902739f, -0.03704244f, 0.21054520f, -0.09565607f, -0.17961083f, 0.15208842f, 
    -0.16547510f, 0.11080655f, 0.08331703f, 0.04016898f, 0.04467868f, 0.10646278f, -0.07494042f, 0.07200310f, 
    -0.28104031f, -0.05871364f, 0.12481444f, 0.00463231f, -0.00604907f, -0.14856914f, 0.01890048f, -0.07382687f, 
    -0.11578680f, -0.08556893f, -0.01048978f, -0.14502409f, 0.12913465f, 0.23212001f, -0.01258295f, -0.04993302f, 
    0.16100860f, 0.18259682f, 0.08221419f, 0.09358262f, -0.00914545f, 0.04600378f, 0.03661732f, 0.05839241f, 
    0.13443992f, 0.34569499f, 0.27194467f, -0.15663622f, -0.01887568f, -0.02427986f, 0.11262947f, -0.01215565f, 
    -0.11506511f, -0.12180549f, -0.01282147f, 0.07313157f, -0.04384060f, -0.19466929f, -0.07281323f, 0.02757537f, 
    0.01431221f, -0.10232350f, -0.06721410f, -0.05887228f, -0.04286233f, -0.18020177f, -0.02374250f, -0.09007026f, 
    0.12973456f, -0.27933201f, -0.24334159f, 0.03391102f, -0.07374772f, 0.00796635f, -0.10190767f, 0.01026338f, 
    0.04663726f, -0.19514258f, -0.24123345f, -0.17715168f, -0.09819485f, -0.01782817f, -0.14271210f, -0.06442925f, 
    -0.04182778f, -0.09935936f, -0.09094729f, -0.07564564f, -0.04281638f, 0.08848848f, 0.07827873f, -0.04664490f, 
    -0.13199252f, -0.17523405f, -0.27396122f, 0.01052036f, -0.09343465f, -0.09868332f, -0.00031919f, -0.00413853f, 
    -0.08031151f, -0.10401696f, -0.04151755f, -0.22433226f, 0.31740728f, 0.29285839f, 0.22227687f, 0.04118892f, 
    0.24421644f, 0.23823878f, 0.09448922f, 0.17703693f, -0.05853019f, -0.05984318f, -0.01265747f, -0.09341925f, 
    -0.07898609f, 0.06590583f, -0.26509154f, 0.02820342f, -0.05218179f, 0.10826397f, -0.08256955f, 0.05469604f, 
    -0.09101206f, 0.01036670f, 0.11803319f, -0.00691646f, 0.16761267f, 0.10029078f, -0.21493377f, -0.13549598f, 
    0.09383830f, 0.05208502f, -0.04968975f, 0.12112747f, 0.00248520f, -0.09201026f, 0.01793669f, 0.03908882f, 
    0.00793021f, 0.29518846f, 0.21107252f, -0.19256614f, 0.13627458f, 0.00742637f, 0.03276183f, -0.08734840f, 
    0.13761403f, 0.05248923f, -0.03110946f, 0.05091203f, 0.35686070f, -0.08780081f, -0.13414633f, -0.07127029f, 
    0.06423584f, 0.05531809f, 0.04423103f, 0.20027368f, -0.03361155f, 0.00736001f, 0.04167505f, -0.12391978f, 
    -0.08263966f, -0.15669996f, -0.23257956f, 0.06990471f, -0.07935382f, 0.06770431f, 0.02685029f, 0.05914722f, 
    0.10805494f, 0.16073485f, 0.02952731f, 0.00839055f, -0.00425207f, 0.14089300f, 0.00540582f, 0.04606541f, 
    0.00285193f, 0.18692259f, -0.01777312f, 0.03834394f, -0.03060657f, 0.02567489f, 0.07034245f, 0.08717541f, 
    -0.24420378f, 0.13405365f, -0.02882390f, 0.05357287f, -0.13863437f, 0.03731251f, -0.04573164f, 0.22325499f, 
    -0.11398486f, -0.14303719f, -0.12988897f, 0.06371547f, -0.03308635f, 0.21968070f, -0.05403894f, -0.14491382f, 
    -0.28543758f, -0.06213629f, 0.05596651f, 0.10992404f, 0.10318869f, -0.04734203f, -0.05121848f, -0.03790726f, 
    -0.04685162f, 0.30729762f, -0.02922862f, -0.06717527f, 0.08194631f, -0.01759542f, 0.01396039f, 0.03034708f, 
    -0.06354286f, -0.16122812f, -0.02667954f, -0.00682306f, 0.13812736f, 0.31219244f, 0.13265714f, 0.11114887f, 
    -0.04760676f, 0.08105089f, 0.15800734f, 0.09100651f, -0.20531744f, -0.06428600f, -0.06546703f, -0.13134870f, 
    0.10443801f, 0.24242820f, 0.03629145f, -0.23763199f, 0.16089933f, -0.05043551f, 0.08283937f, -0.03926364f, 
    0.11189789f, -0.13468736f, -0.07665489f, 0.06642325f, 0.33359224f, 0.14796832f, 0.10626372f, 0.19902004f, 
    0.23008627f, 0.06973043f, 0.13202456f, 0.19569230f, -0.07901242f, -0.03669158f, -0.00094410f, 0.01832281f, 
    0.06305345f, -0.38591096f, -0.13129351f, 0.01044120f, -0.11797524f, 0.05906185f, 0.10637373f, 0.11468393f, 
    -0.00413860f, 0.08466068f, -0.03801946f, -0.00103560f, 0.25917345f, 0.05967491f, 0.15652291f, -0.11899539f, 
    0.03261039f, 0.08277608f, -0.04321107f, 0.12197293f, -0.04014189f, -0.01720015f, -0.11648109f, -0.16253152f, 
    0.33543739f, 0.16749161f, 0.11308443f, 0.13271594f, 0.11987111f, 0.16274683f, 0.10450009f, 0.09295852f, 
    -0.06381663f, -0.06380183f, -0.11178519f, 0.04403120f, -0.13438579f, 0.20600408f, -0.20387757f, 0.12833838f, 
    0.13242432f, -0.02318479f, 0.12847383f, -0.06742255f, -0.04592879f, 0.06785561f, -0.00723640f, 0.13351969f, 
    0.22114159f, 0.14098826f, -0.06692503f, -0.03081431f, 0.20612043f, 0.08280715f, -0.01643381f, 0.11417235f, 
    -0.10800231f, 0.01802330f, 0.09970070f, 0.04790733f, 0.10967601f, 0.03426678f, 0.00614772f, -0.00290572f, 
    -0.05824225f, 0.01324978f, 0.06975657f, -0.03999662f, 0.08799224f, 0.19628906f, -0.06441299f, -0.03389205f, 
    0.26981258f, 0.25285423f, 0.05084139f, 0.01719460f, 0.12158553f, -0.04416947f, 0.10942402f, 0.08577190f, 
    -0.02247729f, 0.00544841f, 0.06290910f, -0.03858793f, -0.14904395f, -0.07035943f, -0.13811545f, -0.21680012f, 
    0.14335185f, 0.08464752f, 0.05041683f, -0.01443670f, 0.06456710f, 0.21724421f, 0.11650035f, 0.05955532f, 
    -0.32589731f, -0.16415967f, 0.31654677f, -0.06057941f, -0.02497477f, -0.04789908f, -0.05586012f, -0.00433538f, 
    0.02965594f, -0.00375373f, 0.10660315f, 0.08789951f, 0.12410132f, 0.20566171f, 0.34552875f, 0.07140145f, 
    -0.06982673f, 0.01733900f, -0.08013649f, 0.04186434f, -0.13812123f, -0.01362306f, -0.14151864f, -0.08945902f, 
    0.04313280f, 0.20045811f, -0.16232347f, -0.13762502f, 0.07568950f, 0.06786764f, 0.07982758f, 0.08496456f, 
    0.07452196f, 0.12750584f, -0.09031809f, 0.05327665f, 0.13067418f, 0.02644285f, -0.01955727f, 0.07681465f, 
    0.11279521f, 0.05865315f, 0.01387519f, 0.15926939f, 0.06799282f, 0.03079329f, -0.07108231f, -0.04492403f, 
    -0.03465677f, 0.27142590f, -0.20616357f, -0.14690743f, 0.04435030f, -0.04732998f, -0.00197470f, -0.02918746f, 
    0.06418610f, 0.15044853f, 0.07342917f, 0.13840842f, 0.04307488f, 0.06251087f, -0.02541666f, -0.03131353f, 
    -0.03300775f, 0.03391817f, -0.03183869f, -0.08352430f, 0.12595057f, 0.00862690f, 0.01324394f, 0.09434622f, 
    0.01064284f, -0.02794619f, -0.03135790f, 0.02591032f, -0.01290666f, 0.01165491f, -0.03443932f, 0.01403359f, 
    0.00430139f, -0.02125759f, 0.02909198f, -0.03490765f, 0.01381530f, -0.00786617f, 0.02170108f, 0.02117014f, 
    -0.01632551f, -0.02998623f, -0.00627942f, -0.02280567f, 0.01521371f, 0.01895060f, -0.00246412f, 0.03068733f, 
    -0.01961135f, 0.00619725f, 0.02283162f, 0.01843648f, -0.01052357f, -0.02153610f, 0.03113435f, 0.02617735f, 
    -0.00358261f, -0.00223685f, 0.00765981f, 0.01757974f, -0.03805208f, 0.01449213f, 0.01441388f, -0.02139956f, 
    -0.02784337f, -0.01327359f, 0.00868846f, -0.01064097f, -0.00573103f, 0.02621343f, -0.00458864f, -0.01729445f, 
    0.01564206f, 0.00094173f, 0.00031785f, 0.00113007f, 0.02548363f, -0.00848927f, -0.00092156f, -0.02382406f, 
    -0.04234177f, -0.01000892f, -0.01762121f, -0.03366828f, -0.02250516f, -0.00852101f, 0.03193675f, -0.00974951f, 
    0.00895869f, -0.01416707f, 0.00488924f, 0.01389414f, -0.02822297f, 0.02477465f, 0.02369733f, 0.01189260f, 
    0.02788960f, -0.01997032f, 0.01829814f, -0.00980004f, 0.02796256f, 0.00286730f, 0.01015955f, -0.00522170f, 
    0.00553672f, 0.00359636f, -0.01186128f, -0.02040470f, -0.03785772f, -0.00325167f, -0.01007394f, 0.02371382f, 
    0.03287353f, 0.02313172f, 0.01612457f, 0.02438061f, -0.02946614f, -0.02052669f, -0.02714043f, -0.01435036f, 
    -0.01032973f, 0.01676393f, -0.00745029f, -0.03154127f, -0.03208641f, 0.02625982f, 0.01811129f, -0.03453269f, 
    0.00848520f, 0.01076773f, -0.03628638f, 0.01242454f, 0.02119769f, 0.01970643f, -0.02467484f, 0.01438345f, 
    0.01307109f, -0.00125400f, 0.01525488f, -0.02546176f, 0.02523421f, -0.00188367f, 0.01438403f, -0.02583702f, 
    -0.00213941f, -0.00978842f, -0.00758166f, 0.01679566f, -0.00390272f, -0.00292464f, 0.01280618f, 0.02267521f, 
    0.00534978f, 0.02293149f, 0.01550457f, 0.02531467f, 0.00431074f, -0.00302376f, 0.01116775f, -0.00534581f, 
    0.02649961f, -0.03526878f, -0.00063582f, -0.00968420f, 0.03973304f, 0.02473876f, -0.01461318f, -0.02256562f, 
    0.02732229f, 0.00481967f, 0.00676187f, 0.00374404f, 0.00108070f, 0.03100974f, -0.01320328f, -0.03147152f, 
    -0.00583826f, 0.01559542f, 0.00459956f, 0.02188343f, -0.02609931f, -0.03722832f, 0.02717640f, 0.00440836f, 
    0.02514354f, 0.00475487f, 0.01997616f, -0.00143592f, -0.01399985f, -0.02548572f, 0.02708426f, 0.00939876f, 
    0.01756931f, 0.00600897f, 0.01225718f, -0.02356046f, -0.03938624f, -0.03096327f, 0.00409888f, 0.00539437f, 
    0.02673784f, -0.01545112f, 0.03130795f, 0.03152017f, -0.00941122f, 0.02655925f, 0.02232930f, -0.01993266f, 
    -0.01427875f, -0.02466275f, -0.01595410f, 0.01838776f, -0.00441811f, -0.03700748f, 0.01617536f, -0.00308361f, 
    -0.00200467f, 0.00735499f, 0.01637197f, -0.03897521f, -0.02381275f, -0.03710414f, -0.02219018f, 0.00937971f, 
    -0.00657917f, 0.00011062f, 0.02057224f, -0.01986781f, -0.02241904f, 0.02467161f, -0.02726529f, -0.03777296f, 
    0.01649517f, 0.00332841f, -0.01805698f, 0.01059473f, 0.01524311f, 0.02072050f, -0.01840958f, -0.03607474f, 
    -0.03191677f, -0.01230782f, -0.03486689f, -0.00728770f, -0.01372384f, 0.02739808f, 0.01000492f, -0.03207633f, 
    -0.00349267f, -0.00025808f, 0.01201931f, 0.03516781f, -0.00393806f, 0.00064837f, 0.00366438f, -0.02635402f, 
    0.00593676f, 0.00342548f, -0.00375714f, 0.00934757f, -0.02975019f, 0.02006365f, 0.00395329f, -0.00354805f, 
    0.03454943f, -0.02938566f, -0.01650383f, -0.00661210f, 0.01554530f, 0.04009002f, -0.00657039f, 0.01010174f, 
    0.02628502f, -0.01418123f, -0.02321896f, 0.00642192f, 0.02725858f, -0.04068459f, 0.00374747f, -0.01237008f, 
    -0.01784382f, -0.02946557f, -0.01649632f, 0.01373505f, -0.02211782f, -0.01048872f, -0.02880839f, 0.00225762f, 
    0.03263079f, -0.02154864f, 0.02587451f, 0.00169070f, 0.03066450f, -0.01574669f, -0.03684179f, -0.03461409f, 
    -0.03482853f, -0.00949000f, 0.01634432f, 0.01138266f, -0.04037724f, -0.02118651f, 0.00322500f, -0.01825620f, 
    -0.00465218f, -0.01689512f, 0.02052941f, 0.00801755f, -0.01954122f, -0.03428796f, 0.02956978f, -0.01733945f, 
    -0.01932067f, 0.00234883f, -0.01713444f, -0.03678876f, -0.03478603f, -0.02255429f, 0.01190284f, -0.02833622f, 
    0.02376656f, 0.01033865f, 0.00917262f, -0.02176116f, 0.01893804f, -0.00878621f, -0.01567553f, 0.00966005f, 
    0.02077841f, 0.03320910f, -0.03575198f, 0.02108529f, -0.03976713f, -0.03214832f, 0.01723137f, 0.01705173f, 
    0.00078605f, -0.00669150f, 0.00155367f, 0.02614350f, -0.00509344f, -0.00880057f, 0.00446154f, 0.00194136f, 
    -0.02124804f, -0.04261352f, 0.00612568f, -0.02869805f, 0.02869077f, -0.01681060f, 0.01492283f, -0.00819505f, 
    -0.01131187f, -0.00189281f, 0.01931123f, -0.00578641f, -0.04251970f, 0.01990192f, 0.02495087f, 0.02532483f, 
    0.02222502f, -0.03387930f, 0.02980174f, -0.02276268f, -0.00069844f, -0.01211981f, -0.01019863f, -0.00727552f, 
    0.00434542f, -0.02141205f, 0.03767578f, 0.00109943f, 0.00570023f, 0.00826437f, 0.01466260f, -0.01609297f, 
    0.02520390f, -0.02112419f, -0.00605176f, -0.02643030f, 0.00447640f, -0.00775110f, -0.01803560f, -0.00470343f, 
    -0.02856081f, -0.02128567f, 0.01696772f, 0.00306834f, 0.03320646f, 0.01661474f, -0.00636820f, -0.01778959f, 
    0.00809973f, 0.01769620f, -0.02033611f, -0.04144162f, -0.00767895f, -0.03286366f, -0.01074287f, 0.01320876f, 
    -0.02365447f, -0.03646721f, 0.02935670f, 0.00439521f, 0.00821015f, 0.02498887f, -0.01551728f, 0.00746837f, 
    -0.01322409f, -0.02914848f, 0.01501718f, 0.00582941f, -0.01416460f, -0.02580276f, 0.00369599f, 0.01071259f, 
    -0.00055338f, -0.01584138f, 0.02169260f, -0.03678602f, 0.02602019f, 0.01745204f, 0.03219004f, -0.01601182f, 
    -0.01015919f, 0.01653796f, 0.01108295f, -0.00383301f, -0.00479529f, 0.01669766f, 0.00249414f, 0.02340078f, 
    -0.03192576f, -0.01997112f, 0.02124305f, -0.01252349f, 0.00231951f, 0.01288391f, -0.01993990f, -0.00524701f, 
    -0.02824445f, -0.01530682f, 0.00754915f, -0.01185603f, -0.01443211f, 0.01543637f, -0.01843652f, 0.00888829f, 
    -0.03529264f, -0.02546000f, -0.02253859f, -0.00793477f, -0.01078438f, 0.01045374f, -0.03022170f, -0.01285796f, 
    0.01973604f, -0.03647174f, -0.02972510f, -0.02260068f, -0.04164033f, 0.01544926f, 0.03941122f, 0.01609232f, 
    0.02108696f, -0.00292461f, 0.01403311f, 0.00208057f, -0.02639612f, -0.00718271f, 0.00922118f, -0.03229710f, 
    0.00554985f, -0.03297442f, -0.02659637f, 0.02745402f, -0.01868065f, -0.01565183f, -0.02670184f, -0.00508835f, 
    0.00015589f, 0.01481974f, -0.00818928f, -0.00032888f, 0.00613085f, -0.03576909f, 0.02278961f, -0.02193070f, 
    -0.00747797f, 0.02428907f, -0.02305657f, -0.00753898f, -0.00176541f, 0.01594129f, 0.00317215f, 0.00101296f, 
    0.00423157f, -0.00533088f, -0.01159618f, -0.02436002f, -0.02329626f, -0.00680044f, -0.00982760f, 0.00867742f, 
    0.01599871f, 0.00568952f, -0.00036844f, 0.00652878f, -0.02120379f, 0.01194624f, -0.00819944f, 0.01095725f, 
    -0.00342456f, 0.02073032f, -0.01541188f, -0.00624068f, 0.02375503f, 0.02803009f, -0.02282794f, -0.00199518f, 
    -0.03552333f, -0.03074222f, -0.03202753f, -0.01652051f, 0.01133179f, -0.03129477f, -0.00706188f, 0.02775501f, 
    -0.03888954f, 0.01300271f, 0.02306848f, 0.02386981f, -0.00959466f, 0.00115037f, -0.00145629f, 0.00649173f, 
    0.00493787f, 0.00910260f, -0.03807637f, -0.00782421f, -0.00520553f, 0.02194788f, -0.00623304f, 0.01518414f, 
    -0.02147530f, 0.02355141f, -0.02996800f, -0.01039797f, 0.02503303f, -0.00596687f, -0.01528763f, 0.01341793f, 
    0.00260355f, -0.01743849f, -0.03534296f, 0.03039478f, 0.01848860f, -0.00571447f, 0.00792670f, 0.01867322f, 
    -0.01998872f, -0.02304262f, 0.03539881f, -0.01461569f, -0.01288730f, -0.02161846f, 0.02758294f, 0.01901486f, 
    0.00619410f, -0.00215481f, 0.02211756f, -0.02809060f, 0.02602836f, -0.00798884f, -0.01874224f, 0.02847754f, 
    0.00311396f, -0.02983629f, -0.02644831f, -0.03542645f, -0.04256427f, 0.00039206f, -0.00601142f, -0.04037399f, 
    -0.00003947f, -0.02952654f, 0.00303177f, -0.00058359f, -0.03712305f, -0.03211439f, 0.00329390f, -0.02610672f, 
    -0.01137246f, -0.02749499f, -0.00743170f, 0.02379654f, 0.01157374f, -0.01991338f, 0.04128753f, 0.00297679f, 
    0.01119003f, -0.01918888f, -0.02389218f, 0.00070362f, -0.03747593f, -0.02531348f, -0.03462382f, 0.01074760f, 
    0.00862750f, 0.03650854f, -0.02501791f, -0.03553122f, 0.01105024f, -0.00793192f, 0.01224468f, -0.00720381f, 
    0.00261251f, 0.02898193f, 0.02440271f, 0.01951029f, -0.01241213f, 0.02235058f, 0.01225446f, 0.04022180f, 
    0.00617811f, 0.00372462f, 0.02332263f, 0.00341449f, -0.03024644f, 0.01278462f, -0.04168863f, 0.00231034f, 
    -0.03210011f, -0.01039489f, -0.01166432f, 0.01321690f, -0.02254985f, -0.01712280f, 0.03013051f, -0.01432357f, 
    0.02054045f, 0.01845581f, -0.02544627f, -0.01457500f, 0.00627949f, -0.00525781f, -0.00193258f, -0.03617860f, 
    -0.02066782f, -0.02840092f, 0.01584304f, 0.01847662f, -0.01604644f, 0.00246954f, 0.03379729f, 0.01024427f, 
    -0.02616668f, 0.03597337f, -0.01768465f, -0.01978511f, -0.01166435f, -0.00913968f, -0.04158067f, -0.01589331f, 
    -0.02960742f, -0.03211443f, -0.00371441f, 0.00883958f, -0.01618815f, -0.01219124f, -0.03250483f, 0.01710648f, 
    -0.01938808f, 0.01347478f, -0.03005506f, 0.01840057f, 0.00365642f, -0.02963382f, 0.00983798f, -0.02831531f, 
    0.03314747f, -0.01263266f, 0.00607609f, 0.03316845f, 0.02614384f, 0.02570243f, 0.01395370f, 0.02406621f, 
    0.02302548f, -0.01993903f, 0.00174746f, 0.02033263f, 0.00880150f, -0.01069707f, 0.02861719f, 0.02692039f, 
    -0.01441260f, 0.02624095f, -0.01764695f, 0.00579000f, -0.02281102f, 0.01108883f, -0.01619064f, -0.01050444f, 
    0.00140844f, -0.02363309f, -0.00807213f, 0.01025504f, 0.01839381f, -0.01217175f, 0.01700065f, -0.03311387f, 
    -0.03209735f, -0.01493116f, -0.02979644f, -0.01754601f, 0.00733412f, 0.00063037f, 0.01459511f, 0.00867387f, 
    -0.02504038f, 0.01499172f, -0.03433863f, 0.01024952f, 0.02558890f, -0.02287377f, -0.00022693f, -0.00235093f, 
    -0.00186391f, -0.02235034f, 0.00416761f, -0.03522190f, 0.00225748f, 0.00522081f, -0.03986475f, 0.00948158f, 
    -0.02049737f, -0.00087086f, 0.02083736f, 0.01969067f, 0.00577899f, 0.02324242f, 0.02767594f, -0.03416889f, 
    0.01732692f, -0.03119113f, -0.00515012f, -0.01729350f, -0.00515288f, -0.00047635f, 0.01415416f, 0.00003343f, 
    -0.03410041f, -0.00856117f, -0.03382744f, -0.02690468f, -0.03280491f, -0.00117775f, -0.03682772f, -0.02057450f, 
    -0.03634581f, -0.03276901f, -0.03676147f, -0.03337689f, -0.01353459f, -0.03086464f, -0.01279064f, -0.02122222f, 
    0.03184460f, 0.01848792f, -0.01351668f, -0.00704631f, 0.02434812f, -0.02307261f, -0.03661245f, -0.01844994f, 
    0.00344577f, -0.02247945f, 0.03035651f, -0.01247269f, -0.01634601f, -0.01187459f, -0.03214106f, -0.01214624f, 
    -0.00053982f, -0.01536839f, 0.01004702f, 0.00441808f, -0.02242835f, 0.00494987f, -0.03266582f, -0.04220217f, 
    -0.00161482f, -0.03548311f, -0.11633643f, 0.13481170f, 0.06258985f, -0.01867783f, -0.01796602f, 0.08749652f, 
    -0.08801607f, 0.09169435f, -0.22437659f, -0.11160141f, 0.07089920f, 0.33626869f, 0.05330845f, -0.14552017f, 
    -0.10724971f, 0.09522534f, -0.05782311f, -0.12775207f, 0.04027858f, -0.02209952f, -0.14739403f, -0.05735958f, 
    0.11854458f, -0.21164611f, 0.06156426f, 0.22291221f, 0.01798361f, -0.02707423f, 0.15614848f, 0.18355429f, 
    0.14753541f, 0.06511260f, 0.30079252f, 0.11837307f, -0.05648343f, 0.18633957f, 0.01815047f, -0.16541311f, 
    0.04495408f, -0.03181090f, 0.05460257f, 0.06396869f, -0.15688595f, -0.10176697f, 0.07378531f, 0.21732555f, 
    -0.02826820f, -0.01784932f, -0.03947084f, 0.18299396f, 0.02424751f, -0.00880378f, -0.04594271f, 0.14349581f, 
    -0.01292584f, 0.00257608f, 0.07965819f, -0.01563868f, -0.06892192f, -0.04879626f, -0.08477798f, -0.04317733f, 
    0.02958265f, 0.02964073f, 0.04214762f, 0.15023711f, 0.02061315f, 0.03107259f, 0.16874559f, 0.04947908f, 
    0.12628546f, 0.04214540f, 0.18140718f, -0.07643900f, 0.04063740f, 0.04351839f, 0.06089889f, 0.05423437f, 
    0.27331090f, -0.09494418f, -0.08672197f, -0.02976112f, -0.02440399f, -0.20268972f, 0.20804763f, 0.10709874f, 
    0.03846917f, 0.09444575f, -0.00780876f, 0.06980088f, -0.00258857f, -0.02742593f, 0.07480527f, 0.06930450f, 
    -0.10477913f, 0.06024750f, 0.03176089f, -0.04553334f, 0.03796492f, -0.01045314f, 0.04307743f, -0.03736436f, 
    0.05845810f, -0.08336946f, -0.00108046f, -0.02090236f, 0.26711103f, 0.02371715f, -0.30909824f, -0.23962480f, 
    -0.04592478f, 0.06757275f, 0.00224749f, -0.25272566f, 0.02154979f, -0.01488412f, 0.04125772f, 0.06110440f, 
    -0.00008598f, -0.22513095f, -0.08655480f, -0.18851878f, 0.07330702f, 0.02342837f, -0.19821262f, -0.06438284f, 
    -0.06932484f, -0.02188560f, -0.14290941f, 0.05788745f, 0.05732544f, -0.07109134f, 0.15405899f, -0.04244104f, 
    -0.01544149f, -0.07315607f, -0.09269744f, 0.08444465f, 0.00007889f, -0.03375664f, -0.08392064f, 0.07411131f, 
    -0.18505652f, 0.00679697f, -0.06479806f, 0.14844958f, -0.06728358f, -0.11938019f, -0.01139017f, 0.07238050f, 
    0.07255676f, -0.19589141f, -0.12384293f, -0.08715007f, 0.02586267f, 0.12278868f, 0.11306768f, -0.25950724f, 
    0.01744586f, 0.04588019f, 0.10554273f, 0.03154569f, 0.06449216f, -0.03739376f, 0.08601329f, 0.02678009f, 
    -0.00247852f, 0.22003306f, 0.20079055f, -0.13478667f, 0.10827624f, 0.11735317f, 0.11644869f, -0.07431596f, 
    -0.00797574f, -0.00719427f, 0.11419835f, -0.03241781f, -0.26174945f, -0.00657990f, 0.12491671f, 0.11836207f, 
    0.05882354f, -0.01953446f, 0.10702012f, 0.12679093f, 0.06585569f, -0.05976374f, -0.04958442f, 0.17109373f, 
    0.09928067f, 0.03085903f, -0.05976134f, -0.29977486f, -0.10075244f, -0.00990087f, -0.22609259f, -0.04112835f, 
    0.03967320f, -0.01534328f, -0.10046287f, -0.09098305f, -0.09211712f, 0.00226965f, 0.02018997f, 0.16813298f, 
    0.13652782f, 0.09471356f, -0.04585352f, 0.10156486f, 0.02962053f, -0.06790096f, 0.03722774f, 0.06117538f, 
    0.16267827f, -0.08491610f, 0.19426389f, -0.12380926f, 0.03948047f, 0.07129341f, 0.01569893f, -0.07614664f, 
    -0.01608373f, -0.02902620f, 0.01000429f, 0.07805321f, 0.16980615f, 0.14156388f, 0.08098972f, 0.02841477f, 
    0.05173532f, 0.08781184f, 0.05964771f, -0.02594358f, -0.01131972f, 0.20624141f, -0.00476276f, 0.05401216f, 
    0.24914625f, -0.09292347f, 0.07393419f, -0.01857036f, -0.02639885f, -0.04547223f, -0.01999767f, 0.28003004f, 
    0.13696492f, -0.00039916f, 0.05993481f, 0.20025294f, 0.22591102f, 0.16422847f, 0.09002730f, -0.30220827f, 
    0.13222434f, 0.11481295f, -0.01911433f, -0.34066325f, 0.09242471f, -0.07055563f, 0.01543677f, -0.07105888f, 
    -0.00906933f, -0.24227937f, -0.03013264f, 0.07908143f, 0.07920662f, -0.07190973f, 0.03515507f, -0.00647705f, 
    0.15288407f, 0.10515614f, -0.08833195f, -0.06850865f, -0.16047600f, -0.25517654f, -0.06391028f, -0.04341925f, 
    0.16317537f, 0.06581127f, -0.24220385f, -0.27515626f, 0.09516212f, -0.07964461f, -0.10666351f, 0.00686822f, 
    0.07045788f, -0.07564560f, -0.01162909f, 0.08671018f, 0.02289812f, 0.00929142f, 0.04136910f, 0.03729253f, 
    -0.01223060f, -0.02543114f, -0.06511461f, 0.00709502f, -0.38869718f, -0.34888887f, 0.03721813f, 0.32571393f, 
    0.14726812f, -0.09161703f, -0.01374821f, -0.14156277f, 0.18441556f, 0.10632835f, -0.11895540f, -0.07733490f, 
    0.05105141f, -0.02415568f, -0.13260446f, 0.16551901f, 0.03781126f, 0.05256460f, 0.13276738f, 0.09524304f, 
    0.02612767f, -0.02204028f, 0.05265822f, -0.05145085f, -0.12214363f, 0.09626491f, -0.16827920f, -0.01340197f, 
    -0.01118122f, 0.01022334f, 0.07041074f, 0.00903677f, 0.07074125f, 0.03641176f, 0.17200932f, -0.01199560f, 
    0.03905635f, 0.11872775f, 0.11961020f, -0.13348965f, 0.07048836f, 0.13751090f, 0.01637042f, 0.14196329f, 
    -0.01965268f, 0.02890851f, -0.00534963f, 0.03660803f, 0.34169695f, 0.00354596f, -0.02062782f, -0.22541641f, 
    0.04806232f, 0.18878725f, -0.12824942f, 0.05277751f, -0.01795593f, 0.04762485f, 0.00467280f, 0.08294580f, 
    -0.04773111f, -0.11507957f, 0.00111082f, 0.09264599f, -0.01197796f, -0.07894679f, 0.12880200f, 0.09953040f, 
    0.13174276f, 0.00629242f, -0.04027526f, 0.07964259f, -0.15924098f, 0.11005320f, 0.03746951f, -0.18226944f, 
    0.12348966f, -0.06355255f, 0.00668189f, 0.05005648f, -0.03476394f, -0.00678026f, 0.11057894f, 0.11307818f, 
    -0.32704005f, -0.14541371f, 0.16053142f, 0.17224365f, -0.00523312f, -0.17556305f, 0.10969965f, 0.14601389f, 
    0.01182478f, 0.07456390f, 0.21255776f, 0.17105165f, -0.01785739f, -0.05764604f, -0.13630308f, 0.07976796f, 
    0.10008737f, 0.00271812f, -0.04996165f, 0.05769380f, -0.06980336f, -0.01421421f, 0.04711050f, 0.14603043f, 
    0.08829266f, 0.05493580f, -0.22681046f, -0.16391928f, -0.01382004f, 0.13074626f, 0.06057233f, -0.06603231f, 
    0.14590076f, 0.01453724f, 0.26118860f, 0.00708296f, -0.05856976f, 0.06678423f, -0.16537417f, 0.09074501f, 
    0.06441589f, -0.00641453f, 0.01670635f, 0.05413565f, -0.06334899f, 0.09380222f, 0.14553677f, 0.13809414f, 
    0.19312170f, -0.12567177f, -0.26144138f, 0.06619585f, 0.09909400f, 0.11058433f, -0.03598785f, -0.03994494f, 
    0.00739816f, -0.06211528f, 0.05443691f, 0.02525427f, 0.15460114f, 0.16876628f, 0.20853515f, -0.08253723f, 
    0.08939001f, 0.08765573f, 0.14242794f, -0.07465635f, -0.01401229f, -0.02300978f, 0.07958401f, 0.11288250f, 
    -0.10411493f, -0.19387273f, -0.25604251f, -0.37328243f, 0.00572129f, 0.22695240f, 0.01288237f, 0.01281174f, 
    0.09959602f, 0.09426322f, 0.26339379f, -0.00406143f, -0.30922627f, 0.10173735f, -0.14786428f, -0.24012339f, 
    -0.06592255f, 0.04221354f, 0.09355202f, 0.02988767f, -0.18322983f, -0.13430694f, 0.14119409f, 0.20514131f, 
    -0.29119846f, -0.02367544f, 0.18974361f, 0.08169658f, 0.18013632f, -0.22147261f, -0.07133434f, 0.02587923f, 
    0.08160073f, 0.03454208f, -0.09586202f, 0.00686471f, -0.01939107f, 0.01014351f, -0.05156116f, -0.02676821f, 
    0.21713226f, 0.00338243f, -0.08073156f, 0.11359581f, 0.03252642f, -0.08558172f, 0.03632793f, 0.19305669f, 
    -0.02951830f, -0.08914392f, -0.10324770f, 0.08281507f, 0.03822538f, 0.01837986f, -0.01662188f, -0.15347761f, 
    0.08196191f, 0.00614949f, -0.08109047f, -0.01448183f, 0.11414459f, 0.01734488f, 0.12878805f, -0.30551258f, 
    0.23298521f, 0.15290646f, -0.12586877f, 0.26585272f, 0.04672989f, -0.04567317f, 0.13284668f, 0.09158888f, 
    0.02815996f, -0.07922438f, -0.22332910f, 0.14148130f, 0.05249470f, -0.05916390f, 0.03712383f, 0.15647113f, 
    -0.01610225f, 0.16225424f, -0.04332405f, 0.06695678f, -0.20346399f, 0.15672390f, -0.00055016f, 0.09774549f, 
    -0.10018835f, -0.02201306f, 0.17550002f, 0.07718258f, 0.12630072f, -0.12477108f, -0.02497002f, -0.01179188f, 
    -0.10327101f, 0.17937447f, 0.03495941f, -0.03706703f, -0.01851877f, -0.02542353f, 0.05344790f, -0.03973959f, 
    -0.01384905f, -0.06165075f, 0.06080272f, -0.01080601f, 0.19589283f, 0.01627113f, 0.32117483f, -0.19523750f, 
    -0.06792341f, 0.02272130f, 0.00018810f, -0.16520560f, 0.04003936f, -0.02272392f, 0.11272371f, -0.00448973f, 
    -0.06511195f, 0.13906540f, 0.05494064f, 0.11800195f, 0.30758992f, -0.18488453f, -0.02395532f, -0.04350850f, 
    0.13317849f, -0.08231600f, -0.06229636f, 0.08648128f, 0.29712442f, 0.10679448f, 0.13663515f, -0.09654403f, 
    0.07865112f, 0.01287903f, 0.05870611f, -0.13227294f, 0.03540943f, 0.00993183f, 0.07880905f, 0.08820400f, 
    0.21621840f, -0.16796251f, -0.09894074f, -0.11301949f, 0.12730150f, -0.05582961f, -0.02981056f, -0.05556092f, 
    0.02540291f, 0.00850492f, -0.11633342f, -0.07433860f, -0.16260484f, 0.03422997f, 0.08833862f, -0.04726286f, 
    -0.13281204f, -0.13964032f, 0.02600658f, 0.03222722f, -0.08586030f, -0.18354689f, 0.01016846f, 0.12109631f, 
    0.18195924f, 0.11840244f, -0.15025201f, -0.15560445f, -0.07144989f, -0.08798467f, -0.12236872f, -0.01900074f, 
    0.02155038f, -0.09871907f, 0.07857472f, 0.25798371f, -0.39373571f, 0.05097501f, -0.08344355f, 0.03195815f, 
    0.04705846f, -0.10184059f, -0.06224120f, 0.34681726f, 0.03432855f, 0.25629017f, 0.05773771f, -0.14689855f, 
    0.13965203f, 0.20773530f, -0.05023881f, -0.22392413f, -0.03921745f, 0.02674525f, -0.07094476f, -0.19187078f, 
    0.04326791f, -0.01375760f, 0.03649461f, 0.00849876f, -0.24188204f, 0.07567131f, 0.15696512f, -0.20768933f, 
    0.02506518f, 0.02059259f, -0.14848050f, -0.14997770f, 0.16398102f, 0.02675992f, -0.02920287f, -0.19512239f, 
    0.08237705f, 0.11999315f, 0.05843745f, -0.08964688f, 0.11677741f, 0.02657292f, 0.01481823f, -0.16257758f, 
    0.17270854f, 0.01850077f, 0.11612367f, -0.10313583f, -0.14269806f, -0.09195665f, 0.03051888f, 0.14457992f, 
    0.08525957f, -0.08088044f, -0.03565568f, -0.14049606f, 0.02573737f, 0.05117453f, -0.06999413f, 0.00060535f, 
    -0.08374968f, -0.00543285f, -0.03396772f, 0.17569374f, 0.02773547f, -0.03225564f, 0.04164900f, 0.03992561f, 
    -0.01309490f, -0.00495570f, 0.10651650f, -0.10981458f, 0.08317851f, -0.00688798f, 0.33228442f, -0.25948212f, 
    -0.08504812f, 0.04201244f, -0.06193157f, -0.10383080f, -0.02096177f, -0.05782859f, 0.08200115f, 0.09769362f, 
    -0.37610221f, 0.42683840f, 0.23406331f, -0.04860735f, 0.05508478f, 0.03949831f, -0.10339677f, 0.01194692f, 
    0.08412877f, 0.08385994f, -0.18246958f, -0.07966612f, 0.14105201f, 0.08432826f, -0.04298712f, -0.03117304f, 
    0.07929594f, 0.06288764f, -0.16672640f, -0.02863664f, -0.00227769f, -0.14651175f, 0.05693935f, 0.11416455f, 
    -0.33685809f, 0.05991391f, 0.03363456f, 0.12700860f, 0.08821497f, -0.02932218f, -0.05323381f, 0.03433595f, 
    0.23969519f, 0.05758184f, -0.05119426f, -0.09511425f, 0.08063299f, -0.01736677f, 0.02483743f, 0.01966440f, 
    -0.02177589f, 0.05679166f, -0.13637099f, 0.02864914f, 0.03875896f, -0.02659691f, -0.02519560f, 0.07193235f, 
    -0.03139849f, -0.03995730f, -0.01345743f, -0.00290831f, 0.01654027f, -0.02779048f, 0.02596781f, 0.01086456f, 
    -0.01862112f, -0.02660713f, -0.03196074f, -0.04022723f, -0.01833367f, 0.00315118f, -0.03978818f, -0.00592556f, 
    0.01191237f, 0.00233169f, -0.04054542f, -0.03173827f, -0.02288439f, 0.02371012f, -0.01302067f, -0.01712607f, 
    -0.00089492f, 0.03305685f, 0.01492094f, -0.01411761f, -0.00642727f, -0.02123474f, -0.02715973f, 0.02884186f, 
    0.02907994f, -0.02577499f, 0.00963516f, -0.02569722f, 0.02447366f, 0.01255114f, -0.00608705f, -0.03859858f, 
    0.01266329f, -0.03465407f, -0.01267779f, 0.02077241f, 0.02018118f, 0.01737641f, -0.00855445f, -0.01775806f, 
    0.01149564f, 0.01246465f, -0.02503158f, 0.02567289f, 0.00229220f, 0.00159652f, 0.01521830f, 0.01966153f, 
    -0.00903808f, -0.01124795f, 0.01627975f, -0.03028133f, 0.00369969f, -0.01171123f, -0.01900917f, -0.03476832f, 
    0.01431884f, -0.01321990f, -0.00657808f, -0.02780029f, 0.01532579f, -0.00592661f, 0.01321028f, 0.02485442f, 
    -0.02983203f, -0.04051957f, -0.01157425f, -0.03516087f, 0.00345459f, -0.02568102f, -0.01287217f, 0.01873269f, 
    0.00875765f, -0.04055275f, -0.02090407f, -0.00594043f, 0.01001865f, 0.00101001f, -0.02875060f, 0.01993936f, 
    0.01662268f, 0.01877784f, -0.02384107f, -0.03396196f, -0.02420461f, 0.02076213f, 0.00148512f, -0.03343091f, 
    -0.03406560f, -0.01310849f, 0.00495294f, -0.03069919f, -0.02219581f, 0.00420971f, 0.03000122f, -0.00667598f, 
    -0.01179022f, 0.01588485f, -0.02940916f, -0.03759918f, -0.03609344f, 0.00982436f, 0.01227436f, -0.00968656f, 
    0.00700678f, -0.01365464f, -0.02000115f, -0.01028562f, 0.00632116f, 0.01250102f, -0.02567372f, 0.00454467f, 
    0.01508023f, -0.00830478f, -0.02639183f, -0.03889533f, 0.02902198f, -0.00449656f, -0.02261516f, -0.00437825f, 
    0.00644881f, -0.02672168f, 0.02724361f, 0.02439468f, -0.03742389f, 0.00078090f, -0.03489905f, 0.00024427f, 
    -0.00885464f, 0.01777386f, -0.00425152f, 0.00162473f, -0.02940383f, -0.00169247f, 0.00922152f, -0.03287458f, 
    0.01985863f, -0.03320503f, -0.01406215f, -0.00933021f, -0.03828419f, 0.02275235f, -0.00833669f, -0.01229061f, 
    0.00970999f, -0.00080820f, -0.02419457f, -0.02856878f, 0.03072126f, 0.00228123f, -0.03434434f, 0.02648091f, 
    -0.00038795f, -0.01995780f, -0.01421958f, -0.04103694f, -0.01231820f, -0.04089240f, 0.00795568f, -0.01189279f, 
    -0.01200545f, -0.00407291f, 0.01975821f, -0.01118465f, 0.01165825f, -0.00037876f, -0.01381053f, 0.00645631f, 
    0.02299684f, 0.01939988f, -0.02321648f, 0.01443639f, -0.03390980f, -0.01560133f, -0.01361081f, 0.02153691f, 
    0.01426102f, 0.01326042f, 0.02683483f, 0.01921232f, -0.02160470f, -0.02067193f, 0.02578955f, 0.00519278f, 
    -0.02335834f, 0.03088736f, 0.01978119f, 0.00222756f, 0.00507645f, 0.02561861f, -0.00746769f, -0.00978841f, 
    -0.03710390f, 0.02413230f, -0.00984723f, -0.03703455f, 0.02094804f, -0.03571821f, -0.00156684f, 0.01665604f, 
    -0.02996363f, -0.01101220f, -0.03844531f, 0.03348333f, 0.00950053f, -0.02112787f, 0.01137047f, -0.02052919f, 
    -0.02372930f, 0.00339337f, 0.00526227f, -0.01404900f, -0.03063790f, 0.00978094f, -0.02480933f, -0.03434043f, 
    0.02457453f, -0.03129160f, 0.00543779f, 0.00103264f, 0.03031194f, 0.00375613f, -0.03250724f, 0.01272246f, 
    0.01752465f, 0.02092391f, -0.01721560f, -0.00882093f, 0.03025853f, -0.01294347f, -0.01139211f, 0.02637662f, 
    -0.03806395f, -0.03408722f, -0.02821499f, -0.01762703f, -0.03394152f, 0.00240904f, -0.02200353f, -0.02152939f, 
    0.01380896f, -0.03108884f, -0.03157291f, -0.03180225f, 0.02474867f, -0.02576189f, 0.02534473f, -0.03574499f, 
    -0.00747193f, 0.01347250f, 0.02072650f, -0.04078350f, 0.01196778f, -0.02742895f, -0.02940037f, -0.02606162f, 
    0.01560267f, -0.02002809f, -0.00473518f, 0.02219504f, 0.02874518f, 0.02657017f, 0.01690772f, 0.02186937f, 
    0.02451948f, 0.02122796f, -0.00690990f, 0.01342669f, -0.03429236f, -0.01514432f, -0.01421208f, -0.01446342f, 
    -0.00903673f, 0.02189812f, -0.00316658f, 0.00088734f, 0.00120377f, 0.00714014f, -0.00646307f, -0.02973366f, 
    0.01011164f, -0.02783670f, -0.00753674f, 0.01489740f, -0.02523203f, 0.02654237f, -0.03893291f, -0.03313817f, 
    0.00966387f, -0.00574023f, -0.03700653f, -0.00764404f, 0.02678012f, 0.03017310f, 0.02130699f, -0.03680024f, 
    0.02389044f, 0.01937506f, -0.01188822f, -0.03045366f, 0.01083957f, -0.00896457f, -0.03057015f, -0.02150810f, 
    0.02535567f, -0.02591618f, 0.02600572f, -0.03244652f, 0.01640186f, 0.00895228f, -0.01991707f, -0.02552789f, 
    -0.01796451f, -0.01319159f, -0.01937787f, -0.03049188f, -0.03527434f, -0.01701010f, -0.03078945f, 0.01189639f, 
    -0.01028045f, -0.00474543f, 0.02121361f, 0.02172072f, 0.01835384f, -0.00905298f, -0.03461211f, -0.02947503f, 
    0.02179737f, -0.00371305f, -0.00094447f, -0.03302824f, -0.03690220f, 0.01389050f, 0.02379697f, 0.00587783f, 
    -0.00332590f, -0.02902374f, -0.03446583f, -0.02064511f, -0.03977047f, 0.01330331f, -0.00611319f, 0.01437523f, 
    -0.02750205f, -0.02029642f, 0.00952790f, -0.02748259f, 0.01020325f, -0.02373145f, -0.02981828f, -0.04120649f, 
    -0.01624561f, 0.02507353f, -0.03352231f, 0.00761020f, -0.01167068f, 0.02541072f, -0.01715880f, -0.03046896f, 
    0.00750770f, -0.03262375f, -0.01625603f, 0.00090652f, -0.02075685f, 0.00870092f, 0.01088522f, -0.02481587f, 
    -0.01510204f, 0.01617819f, 0.00549564f, -0.02456787f, 0.01263257f, -0.01973945f, -0.01045985f, -0.01762506f, 
    0.02986223f, -0.01186852f, -0.03046699f, -0.03108374f, -0.03659161f, -0.03644519f, -0.01653007f, -0.03202007f, 
    -0.02545726f, 0.00500912f, 0.02526891f, -0.00949630f, -0.00332639f, 0.02870291f, -0.02083311f, 0.00479563f, 
    -0.01926967f, -0.00632178f, -0.03463398f, -0.02781795f, -0.02828440f, -0.02100087f, -0.02999263f, -0.02671265f, 
    -0.03148753f, 0.01266685f, 0.01821116f, -0.00893185f, 0.01895103f, -0.03147843f, 0.00908326f, -0.03682448f, 
    -0.00540494f, -0.03939160f, 0.03003556f, -0.01046453f, 0.01978973f, -0.00255773f, 0.00999842f, 0.01410733f, 
    -0.03670462f, -0.00031779f, -0.02762116f, -0.00698052f, -0.02829909f, 0.00799606f, 0.01576923f, 0.00767364f, 
    -0.01906340f, -0.02638895f, 0.01430739f, 0.03057870f, 0.00784261f, 0.03056692f, -0.04114290f, 0.02113772f, 
    -0.01338562f, 0.00408569f, -0.01407301f, -0.01458045f, 0.01753255f, 0.00630083f, -0.02069135f, 0.00269235f, 
    0.00155935f, -0.03272676f, 0.01892310f, -0.03419038f, 0.00743416f, -0.01768826f, 0.00445965f, -0.03097287f, 
    -0.03574674f, 0.00739453f, -0.03701776f, -0.01397594f, 0.02026667f, 0.00618640f, -0.02236260f, -0.00603474f, 
    0.01094252f, -0.03353456f, -0.03077189f, 0.00482972f, 0.02739299f, -0.03620588f, -0.00637840f, -0.02114353f, 
    0.02456840f, -0.01690444f, -0.03439857f, 0.01153376f, -0.01510034f, -0.00565147f, -0.03037653f, 0.03056957f, 
    0.02845113f, 0.01638394f, -0.03179682f, -0.00527625f, -0.01188282f, 0.01412817f, -0.02344421f, -0.03704399f, 
    0.01390734f, -0.00492451f, -0.00696862f, -0.02894186f, -0.01800842f, 0.02037769f, -0.01717047f, -0.01465719f, 
    0.03078809f, 0.02012354f, 0.01982611f, -0.00015986f, 0.00962051f, 0.00579836f, 0.02034754f, 0.02355333f, 
    -0.03107854f, -0.01200456f, 0.01384291f, 0.02888497f, -0.00949517f, 0.02967727f, 0.00839652f, -0.02789375f, 
    0.01090282f, 0.02868266f, -0.01776675f, 0.00779531f, -0.02117772f, -0.02260358f, 0.01646168f, 0.00500719f, 
    -0.00441871f, -0.00552302f, 0.03060769f, 0.02986433f, -0.03200828f, -0.00232720f, -0.02146819f, -0.01616087f, 
    -0.00355655f, 0.02331190f, 0.00106309f, -0.02074387f, -0.04041180f, -0.02092780f, -0.03900769f, -0.01337559f, 
    -0.03878659f, -0.02637654f, -0.00545282f, 0.03094718f, 0.00092322f, -0.02584489f, 0.02128773f, -0.01207410f, 
    -0.03794857f, -0.00438362f, 0.01905245f, 0.02608714f, -0.03131773f, 0.02008792f, -0.00077249f, 0.02305053f, 
    -0.03298412f, 0.01882338f, -0.00727110f, 0.02525579f, 0.01415892f, 0.02321511f, 0.02947301f, -0.00464431f, 
    0.00064046f, -0.00781997f, -0.00558805f, -0.00362904f, -0.00277298f, -0.01587385f, -0.00857781f, -0.02825476f, 
    0.02650081f, 0.00928753f, -0.03483816f, -0.01781289f, 0.00046190f, 0.02613311f, -0.02906137f, -0.00991612f, 
    0.01609375f, -0.01296312f, -0.01845434f, -0.00425781f, -0.01870087f, 0.00150851f, 0.02309703f, -0.00905262f, 
    -0.01981762f, -0.02663144f, 0.02515017f, 0.00238964f, -0.01947503f, -0.00138268f, 0.00744136f, 0.02649521f, 
    -0.03289538f, 0.01169805f, 0.02955905f, -0.01015549f, 0.02497454f, -0.01895257f, 0.00932729f, -0.03535109f, 
    -0.01246682f, 0.01448902f, 0.02882296f, 0.00129483f, -0.02907367f, -0.02776510f, -0.02982837f, 0.02135765f, 
    -0.01111869f, -0.01870295f, -0.01772070f, 0.02218101f, -0.01667636f, -0.03230850f, -0.02978048f, 0.00343914f, 
    0.00708267f, 0.00653168f, 0.01194097f, -0.00125699f, -0.00464375f, -0.01651089f, 0.01423780f, 0.02251297f, 
    -0.00488014f, 0.02489740f, -0.00827430f, -0.00315951f, 0.01990056f, -0.01928224f, 0.02368302f, -0.03646169f, 
    -0.01837858f, -0.03488195f, -0.02445412f, 0.00769036f, -0.03047472f, -0.03057208f, -0.01984839f, 0.01907546f, 
    -0.02535846f, 0.00699317f, -0.03506793f, -0.02370178f, -0.00840695f, -0.02936359f, -0.02054706f, -0.04032550f, 
    0.02367739f, 0.00449259f, 0.02889204f, 0.01553476f, 0.01313605f, 0.01867392f, -0.03507872f, 0.00814831f, 
    0.00381960f, 0.01626717f, 0.01866637f, -0.00617823f, -0.01844510f, 0.02785019f, -0.03958960f, 0.00504971f, 
    -0.03706732f, -0.01553094f, 0.02914185f, -0.01929796f, -0.02908274f, -0.02476696f, -0.02851273f, -0.01384387f, 
    -0.01447059f, -0.03572378f, 0.00118790f, 0.01908821f, -0.03946796f, 0.00339127f, 0.02154350f, 0.02040854f, 
    -0.00019888f, -0.03731911f, 0.00089525f, 0.02940686f, -0.03067547f, 0.00486513f, -0.00975490f, -0.02680574f, 
    -0.01441303f, 0.01340983f, -0.01059456f, -0.00865706f, 0.00694866f, -0.03940615f, -0.03501059f, 0.00419448f, 
    -0.01833187f, 0.01263901f, -0.04053698f, -0.01310526f, 0.01175259f, 0.02283676f, -0.00600953f, 0.01682757f, 
    -0.00861672f, 0.02847246f, 0.02623885f, 0.00274681f, -0.00725653f, -0.03171215f, -0.00017341f, -0.02547904f, 
    -0.02791866f, 0.00156074f, -0.02928951f, -0.01022129f, 0.01323300f, -0.02586964f, -0.03017283f, -0.02131201f, 
    -0.00329840f, 0.02734762f, 0.00011797f, -0.01667454f, 0.02622535f, -0.03151352f, 0.01155647f, -0.03140686f, 
    -0.01496708f, -0.04056096f, -0.01792813f, -0.03774765f, 0.02624267f, -0.00124780f, 0.02501890f, -0.01087046f, 
    -0.02285413f, -0.04104171f, -0.01520179f, -0.00195194f, -0.01953831f, 0.00154141f, 0.01383968f, 0.02022646f, 
    -0.02644147f, -0.03559647f, 0.01734818f, 0.00019637f, -0.00812532f, -0.02805384f, -0.02512837f, 0.00173456f, 
    -0.01047776f, -0.02375988f, -0.00790417f, 0.01088573f, -0.03897891f, -0.01900859f, 0.03010098f, 0.02952132f, 
    -0.00470933f, -0.03658424f, -0.01610714f, 0.01594704f, -0.02328669f, -0.02410553f, -0.01104242f, 0.02387269f, 
    -0.03015091f, 0.03384861f, -0.03716512f, 0.01522214f, -0.00018281f, -0.00809134f, -0.01245681f, -0.03666321f, 
    0.02235556f, 0.02707092f, -0.03843356f, 0.01880831f, 0.00288743f, 0.01404819f, 0.00869790f, 0.02018357f, 
    -0.02719218f, 0.01739495f, -0.02072974f, -0.03362922f, -0.02684593f, 0.01322868f, -0.02864324f, 0.00345428f, 
    -0.04066010f, -0.01286701f, -0.03961780f, 0.02391275f, -0.04313191f, 0.00064563f, -0.02222924f, -0.03684928f, 
    0.00892024f, 0.02561291f, 0.01021400f, 0.02775691f, -0.00097289f, -0.03333998f, 0.01151696f, -0.02040426f, 
    -0.00614774f, 0.02229517f, 0.01026958f, -0.01566837f, -0.00805198f, 0.01326292f, 0.01767683f, -0.01809007f, 
    -0.01493079f, -0.01801879f, 0.01858060f, -0.03769764f, 0.02182560f, 0.00382145f, -0.03145366f, -0.00142359f, 
    0.00462624f, 0.00617798f, 0.02779469f, 0.01744931f, -0.01617746f, -0.03713606f, 0.00424034f, 0.01428956f, 
    0.01477657f, -0.00105298f, -0.01329178f, 0.01414793f, -0.03966756f, 0.01796572f, 0.00807700f, -0.01639274f, 
    -0.03853698f, -0.03331212f, 0.02874926f, -0.00997753f, -0.02870995f, -0.00976350f, 0.00899267f, -0.03556347f, 
    -0.00248647f, -0.02734700f, -0.03290375f, -0.01675121f, -0.03136085f, -0.04023128f, 0.02744426f, -0.01412583f, 
    0.02642745f, 0.00749103f, 0.01397116f, 0.02735752f, -0.04055894f, 0.02327522f, -0.02407640f, -0.02675803f, 
    -0.00808098f, -0.02271441f, -0.02699384f, -0.01758983f, -0.01457744f, -0.02138725f, 0.01111308f, -0.03891816f, 
    -0.01847117f, 0.00787434f, -0.03457543f, 0.01066996f, -0.03102664f, 0.00714834f, 0.02681000f, -0.03582527f, 
    -0.01610437f, -0.02199696f, -0.01720407f, -0.02807675f, -0.00712609f, -0.03353402f, -0.03343791f, 0.00671967f, 
    -0.03009992f, 0.00604852f, -0.01581893f, 0.00607396f, -0.00885979f, 0.01929304f, -0.01660367f, 0.01654061f, 
    -0.00147040f, -0.03617356f, -0.04064894f, -0.02074410f, -0.00755732f, -0.00264155f, -0.03445686f, 0.00159316f, 
    -0.00014737f, 0.01858158f, -0.01407905f, -0.00607527f, -0.01293363f, 0.01509391f, 0.01485314f, -0.01483990f, 
    -0.03934925f, -0.04348774f, -0.00552891f, -0.03629443f, 0.00614257f, -0.02775533f, -0.00917986f, -0.00816528f, 
    -0.00473789f, -0.02413763f, -0.00415589f, -0.03180142f, 0.02792299f, 0.01276207f, 0.02643183f, -0.00361657f, 
    -0.04159672f, -0.04330029f, -0.00591229f, -0.01667995f, 0.01583044f, 0.00202629f, 0.01472290f, 0.02612946f, 
    -0.02180831f, 0.01819722f, -0.00589645f, -0.04071421f, -0.00838715f, -0.03057908f, 0.02021405f, -0.04013095f, 
    -0.02194700f, 0.01026744f, -0.04268333f, -0.01280400f, -0.00267487f, -0.00684064f, -0.02913157f, -0.02835038f, 
    0.01699201f, -0.03749332f, -0.00734908f, -0.03046741f, 0.02026335f, 0.01675232f, 0.01633864f, -0.00474518f, 
    -0.03038695f, 0.00898104f, -0.03927560f, -0.02249497f, -0.00104142f, -0.01166915f, -0.00068835f, 0.02677879f, 
    0.01055195f, -0.01891150f, 0.00057757f, -0.03121562f, 0.01682999f, -0.02043162f, 0.00259030f, -0.02099450f, 
    0.00478658f, 0.02158048f, 0.00745262f, 0.01924350f, -0.02424625f, -0.04215767f, -0.03501503f, -0.03670909f, 
    0.00584383f, -0.01802008f, -0.01602268f, -0.01275876f, -0.01585173f, 0.00969877f, 0.02969470f, -0.00154565f, 
    -0.03157581f, 0.02560367f, -0.03808074f, 0.02132498f, 0.01502420f, -0.02188248f, -0.03353415f, 0.00305003f, 
    0.02072798f, -0.00610072f, -0.03976882f, 0.01455847f, -0.02821977f, -0.00386025f, -0.01442975f, -0.03404132f, 
    0.00657572f, 0.01767009f, -0.00748700f, 0.01047369f, -0.02938009f, -0.03825788f, -0.01915796f, -0.01566330f, 
    -0.00440715f, 0.01895490f, -0.01186389f, 0.00025510f, -0.00623810f, 0.02809541f, 0.01991456f, 0.01088476f, 
    -0.02173099f, 0.00273040f, -0.01859853f, -0.00155716f, 0.02742854f, 0.02129149f, -0.01931764f, -0.01367654f, 
    -0.02197914f, -0.02300299f, -0.01278091f, 0.00165357f, -0.02331533f, -0.04114440f, 0.01418173f, -0.01997568f, 
    -0.01408988f, 0.00423829f, 0.02272950f, -0.02519335f, -0.02425934f, 0.02746904f, 0.01149243f, 0.01308462f, 
    -0.03587080f, -0.02345892f, -0.04097398f, 0.02057669f, 0.02894538f, -0.00039935f, -0.04178458f, 0.00057498f, 
    -0.01307988f, -0.00492172f, 0.02368959f, -0.00413175f, -0.02421922f, -0.01141192f, -0.01780966f, 0.01556606f, 
    -0.01933542f, -0.01338545f, 0.02004856f, 0.01889796f, -0.03519209f, -0.00547764f, -0.02181640f, -0.02959214f, 
    -0.01561230f, -0.01519443f, 0.02376055f, -0.00417100f, -0.01956426f, 0.00887298f, 0.01854773f, -0.02627965f, 
    -0.02462504f, 0.02603219f, 0.02699701f, -0.04174992f, -0.01638415f, 0.02839678f, 0.00856937f, 0.01052963f, 
    -0.01978456f, -0.02110403f, 0.00922259f, 0.02607601f, -0.01993566f, -0.02068560f, -0.00765457f, 0.00670949f, 
    -0.00371844f, 0.02063556f, 0.00839741f, 0.01455759f, -0.02128908f, -0.03966865f, -0.03489011f, -0.02871085f, 
    -0.03479223f, -0.01412544f, 0.00216000f, -0.02400530f, -0.00323097f, -0.03461782f, -0.01243327f, -0.00275771f, 
    -0.02305105f, 0.00847936f, -0.01637596f, -0.04036433f, 0.01540273f, 0.01805595f, -0.01588457f, -0.00718839f, 
    0.02331966f, -0.02094639f, -0.01546018f, 0.02575956f, -0.02903756f, -0.02019968f, -0.02905344f, 0.00780143f, 
    -0.03003005f, -0.00316954f, -0.00944977f, -0.02082415f, 0.02587599f, -0.03057696f, -0.01336422f, 0.00669913f, 
    -0.04147672f, -0.02193766f, 0.00336995f, -0.01168333f, -0.03051862f, 0.02595974f, 0.00944796f, 0.01114847f, 
    -0.01211097f, 0.02763397f, 0.00257805f, 0.01229263f, -0.01676390f, -0.03422564f, 0.00233900f, -0.01681619f, 
    -0.02299199f, 0.01528257f, -0.01166131f, 0.02109187f, -0.00928945f, -0.03490193f, -0.01165573f, -0.02968690f, 
    -0.00704810f, -0.00274211f, -0.02574120f, 0.02347146f, -0.01768913f, 0.02936539f, -0.03098646f, -0.02972532f, 
    0.02584530f, -0.00030409f, -0.01607588f, -0.00587145f, -0.01803069f, -0.02143395f, -0.00814285f, -0.01308978f, 
    0.01954946f, -0.02920830f, -0.01790331f, 0.01976093f, 0.01715734f, -0.03585735f, 0.00201901f, -0.01078098f, 
    -0.03934879f, -0.01687159f, -0.03517338f, -0.00435746f, 0.02485635f, 0.00289568f, 0.00945097f, 0.01047636f, 
    -0.01434058f, -0.03301658f, -0.03530511f, -0.00452349f, -0.03550915f, 0.00534129f, -0.01485754f, 0.02379157f, 
    -0.00608520f, 0.00620489f, 0.00045637f, -0.01004805f, -0.00902391f, 0.02238729f, -0.01470873f, 0.01682771f, 
    -0.00369161f, -0.00351962f, -0.04275200f, 0.00108635f, 0.02381514f, 0.00300915f, 0.01335943f, -0.03607976f, 
    -0.02855880f, -0.03350472f, 0.00414339f, -0.03602914f, 0.02636329f, -0.03095912f, -0.01980045f, -0.03614253f, 
    0.01615847f, 0.00483214f, -0.02920926f, 0.01985838f, -0.04314357f, 0.00285420f, 0.02433312f, 0.00638353f, 
    -0.01005317f, -0.01333611f, 0.02466971f, -0.03402732f, -0.03309766f, -0.01374247f, -0.01157580f, 0.03190944f, 
    0.02546819f, -0.03993551f, -0.01988455f, 0.00336602f, -0.00324062f, 0.01218917f, 0.01653550f, -0.00022630f, 
    -0.00401463f, 0.00777824f, 0.00174201f, 0.02879497f, 0.01198593f, 0.02146938f, 0.01794288f, -0.00568979f, 
    -0.02816309f, -0.02729353f, -0.00632366f, -0.02170381f, 0.02777490f, -0.02472397f, 0.02674286f, -0.04237944f, 
    -0.04337276f, -0.03709489f, -0.01868736f, -0.02773762f, 0.01152002f, -0.00172592f, 0.01052222f, -0.01193393f, 
    0.03407089f, 0.01630130f, -0.01198043f, 0.01816920f, 0.02364861f, -0.02424246f, 0.01381343f, -0.00626531f, 
    -0.01669014f, 0.00936855f, -0.01689365f, -0.01179718f, 0.00054527f, -0.04087162f, 0.01826177f, 0.02331754f, 
    0.02656531f, -0.03093942f, 0.01022401f, 0.00770157f, -0.02664909f, -0.03696577f, -0.01912807f, -0.01008346f, 
    0.00424050f, -0.00511845f, -0.02361721f, -0.02166224f, 0.02481798f, 0.00811677f, -0.02159915f, 0.00318245f, 
    -0.02672307f, -0.01563700f, 0.01802943f, -0.03437730f, -0.02163667f, 0.00626070f, -0.02232322f, -0.03724470f, 
    -0.02310705f, -0.01818811f, -0.03459842f, 0.02424911f, 0.01660699f, -0.01130014f, 0.01220102f, 0.02272642f, 
    -0.02115846f, -0.03603666f, -0.00444824f, -0.03587563f, 0.02336597f, -0.02466958f, -0.02550156f, -0.01273591f, 
    -0.00413835f, -0.00017283f, 0.00058092f, -0.03707068f, -0.02461407f, -0.03637110f, -0.00562041f, 0.02843888f, 
    -0.00422512f, -0.00075645f, -0.01224452f, -0.03601704f, -0.03297154f, 0.02389538f, 0.01093970f, 0.00527300f, 
    0.01524069f, -0.02355908f, -0.00034564f, 0.00346435f, 0.02556273f, 0.02047548f, 0.00831847f, 0.00395015f, 
    -0.00407121f, 0.02597329f, 0.01106712f, -0.01258710f, 0.02513547f, -0.01114604f, 0.02099315f, -0.00607484f, 
    0.02652606f, -0.02188355f, -0.01720082f, -0.04129244f, -0.01310769f, 0.01548469f, -0.03793376f, 0.01088501f, 
    0.03593825f, -0.03381882f, -0.01833301f, 0.02060676f, 0.01149821f, 0.00204316f, 0.02419257f, 0.01807774f, 
    -0.01219323f, -0.01650040f, -0.01566700f, -0.00367343f, 0.00342625f, -0.02968156f, 0.00877198f, 0.01624159f, 
    -0.04189963f, 0.01443325f, -0.01776057f, 0.02013174f, 0.02773637f, 0.02522360f, 0.00704762f, -0.03482232f, 
    -0.01385985f, -0.00054515f, -0.02296212f, -0.02891461f, -0.01795604f, 0.03226596f, 0.00031329f, -0.01594156f, 
    -0.00847668f, 0.02826112f, -0.04271602f, 0.00861330f, -0.00872406f, -0.01501056f, 0.02760033f, -0.02003863f, 
    -0.02498092f, 0.00638306f, -0.03701715f, 0.01537659f, -0.03908117f, -0.00174125f, 0.02088469f, 0.01672146f, 
    -0.01478405f, -0.00267744f, 0.02200660f, 0.00014375f, -0.00619618f, -0.00564035f, -0.02811849f, -0.01282244f, 
    0.01370663f, 0.02410845f, -0.00051828f, -0.03557101f, 0.01721282f, 0.01335951f, 0.01672328f, 0.02731475f, 
    0.00904213f, -0.03155221f, 0.00160049f, -0.01656283f, 0.01674697f, -0.03653750f, -0.03795870f, -0.03273691f, 
    -0.01813942f, 0.00893609f, 0.01006969f, -0.00000953f, -0.00735802f, -0.01225228f, 0.01349846f, 0.01570478f, 
    -0.03735178f, -0.02195695f, -0.00716848f, 0.02278678f, -0.03908619f, 0.00751808f, -0.02452888f, 0.00337650f, 
    -0.01016161f, -0.03342867f, 0.00930957f, 0.01365155f, -0.02454483f, -0.01754115f, -0.02855836f, 0.00062174f, 
    -0.01144058f, -0.00121660f, -0.01454445f, -0.00584639f, -0.03365423f, 0.02633017f, 0.00256262f, -0.02980190f, 
    -0.03078695f, 0.00690975f, -0.03468505f, -0.03957964f, -0.02565080f, -0.01455920f, -0.02342004f, 0.01983789f, 
    -0.03101168f, -0.03936892f, 0.01287689f, 0.00501649f, -0.00775394f, -0.02383010f, 0.00128968f, -0.00851833f, 
    -0.02364345f, 0.03436674f, -0.00124978f, -0.00685843f, -0.00324265f, -0.01450316f, 0.02529602f, 0.02259927f, 
    -0.03532851f, 0.02370288f, 0.02184875f, 0.01670438f, -0.00973709f, -0.00649065f, -0.03335346f, -0.01372899f, 
    0.02051591f, -0.04262571f, -0.00780206f, -0.03219507f, -0.00676941f, -0.03787561f, -0.02363348f, -0.01909708f, 
    -0.03359469f, -0.02135009f, -0.01337285f, 0.02450223f, -0.02951791f, -0.02300582f, 0.01800484f, 0.00700712f, 
    0.01314703f, 0.02535687f, -0.00803055f, 0.01989834f, -0.01699929f, -0.04094175f, -0.04398732f, 0.02223301f, 
    -0.00345232f, -0.01209989f, 0.02418575f, 0.00068823f, 0.00565346f, -0.00434511f, -0.01616943f, -0.01541082f, 
    -0.00099019f, -0.02257003f, -0.03049202f, -0.02024872f, 0.01769840f, 0.00414857f, -0.02807653f, -0.01701810f, 
    0.02409857f, 0.02623303f, 0.03205095f, -0.02324515f, 0.02292962f, -0.01624798f, -0.01995776f, -0.00839904f, 
    -0.02732639f, -0.02975701f, 0.01967874f, -0.01723526f, 0.00999460f, 0.02316973f, -0.01049725f, -0.02148491f, 
    -0.03290045f, -0.01589533f, 0.00835389f, 0.02866894f, -0.01207840f, 0.02616114f, -0.02247651f, -0.03849104f, 
    -0.02021084f, -0.03820942f, 0.00261056f, -0.01720029f, -0.01882607f, -0.02521932f, -0.03069467f, 0.02385352f, 
    0.00943310f, 0.01989399f, -0.00573580f, -0.02480657f, -0.01048877f, -0.01275217f, -0.01877805f, 0.02569777f, 
    -0.01123293f, 0.00625599f, -0.02970006f, -0.03814238f, -0.01149541f, -0.00740305f, -0.00050687f, -0.00556137f, 
    -0.00062459f, 0.00506160f, -0.02485387f, -0.03776243f, -0.02835890f, -0.03286915f, -0.02340003f, 0.02355482f, 
    -0.02014581f, 0.02421244f, -0.03372476f, 0.00052514f, -0.01700080f, -0.01501848f, 0.00586127f, 0.02056361f, 
    -0.00936956f, -0.01281565f, -0.00736255f, -0.02874603f, 0.01255924f, -0.02740255f, -0.00473771f, -0.03621017f, 
    -0.02904332f, -0.00869181f, -0.00653543f, -0.01151438f, -0.01668991f, -0.03678796f, -0.00465867f, -0.01720938f, 
    -0.02704617f, 0.00538888f, -0.02357877f, 0.01009254f, 0.02638937f, -0.02144571f, -0.00713469f, 0.01186152f, 
    -0.00609683f, -0.03529424f, -0.03231311f, -0.03293011f, -0.01871289f, -0.02044150f, 0.03034541f, 0.01434798f, 
    0.02297607f, 0.01741477f, -0.01994080f, -0.03819153f, 0.02461570f, 0.03380254f, -0.02957073f, 0.01748521f, 
    0.02365926f, -0.00446461f, -0.02615336f, 0.01083225f, -0.00478714f, -0.03422221f, -0.00785192f, -0.03380128f, 
    0.00609966f, -0.02299978f, 0.02145988f, -0.02135223f, 0.02792586f, 0.00773351f, -0.03727880f, 0.01780589f, 
    -0.00350591f, 0.00522998f, 0.01170846f, 0.00398967f, -0.01676065f, -0.00534302f, -0.00009090f, 0.01943432f, 
    0.02860366f, -0.03537640f, -0.02817796f, -0.02534202f, 0.00384246f, 0.02260704f, -0.00494583f, -0.01016406f, 
    -0.00223363f, 0.00884609f, -0.01750859f, 0.00084914f, -0.03476421f, 0.01387102f, 0.02029056f, 0.00698886f, 
    -0.00578131f, -0.03929143f, -0.03330437f, 0.01757019f, -0.03618321f, -0.00860833f, -0.01567915f, 0.02859896f, 
    0.02904817f, 0.02566475f, 0.01393223f, 0.02323787f, -0.01788914f, -0.00409665f, -0.01067608f, 0.00321432f, 
    0.02376466f, 0.01986260f, -0.00046671f, 0.01344145f, 0.02424889f, 0.02858362f, 0.02166909f, -0.00178715f, 
    0.03022855f, -0.02881265f, 0.02907940f, -0.03317034f, 0.00350534f, 0.02221692f, -0.00114994f, 0.02133590f, 
    0.01614050f, 0.00700744f, 0.03232516f, 0.01677612f, -0.00666938f, -0.03499989f, 0.01254927f, -0.03597427f, 
    -0.02068584f, -0.02415058f, -0.00215648f, -0.02177068f, 0.00933006f, -0.03663150f, 0.01697738f, -0.00931958f, 
    -0.00763436f, 0.01222188f, 0.03236941f, 0.00801718f, 0.02185347f, -0.02620302f, 0.02389979f, -0.02382301f, 
    0.01227330f, -0.03369969f, -0.01300455f, 0.00863636f, -0.01562791f, 0.00559418f, -0.01540953f, -0.03588764f, 
    -0.03694671f, -0.03805399f, 0.03412150f, 0.00773210f, -0.03021813f, 0.02395890f, 0.02808509f, 0.02109551f, 
    -0.01060563f, -0.01319251f, -0.01004637f, 0.03295117f, -0.03273068f, -0.01315462f, -0.00837284f, 0.00856736f, 
    -0.01556456f, -0.03730752f, 0.01013451f, -0.00158593f, 0.02797509f, -0.03152838f, -0.02541107f, -0.02494082f, 
    0.02992553f, 0.01133193f, 0.02660782f, -0.03745883f, -0.02672846f, -0.01188670f, 0.00978321f, 0.00994090f, 
    0.01811624f, -0.01776568f, -0.03579736f, 0.00998916f, -0.01883052f, -0.02357187f, 0.02845466f, -0.03156227f, 
    0.00663431f, 0.00485557f, -0.03559962f, -0.03125184f, 0.01900709f, -0.01899814f, -0.02125863f, 0.01532806f, 
    0.01392324f, -0.03143385f, 0.02574109f, 0.00642375f, -0.02116610f, -0.03944340f, 0.00145051f, -0.03574795f, 
    0.01983088f, 0.02064388f, -0.01423795f, 0.01969362f, -0.01369156f, 0.00361087f, 0.00852816f, -0.01607755f, 
    -0.01136391f, -0.01063618f, 0.01362022f, -0.01623679f, 0.01739603f, 0.01140641f, 0.02413933f, -0.03322679f, 
    -0.03715377f, 0.00403651f, -0.00517746f, -0.02383210f, 0.02189415f, -0.01901958f, 0.02444269f, 0.02478605f, 
    -0.02946229f, -0.00001129f, -0.00305464f, 0.02214556f, 0.00055233f, 0.01527109f, -0.00797527f, 0.00545519f, 
    0.00439256f, 0.00757862f, 0.01644131f, -0.03596049f, -0.00381215f, 0.00673480f, -0.00942025f, -0.00496690f, 
    -0.00753357f, 0.02108122f, 0.01040928f, -0.02641625f, 0.00111835f, -0.03959501f, -0.00312161f, 0.01158189f, 
    -0.03092358f, 0.02376247f, 0.01254055f, 0.02711041f, 0.01916027f, 0.00584870f, -0.03326571f, 0.01076727f, 
    -0.03623470f, -0.01777291f, -0.02696298f, -0.00648915f, -0.00654186f, -0.01506346f, -0.00053073f, -0.00710262f, 
    0.01592497f, -0.02945328f, 0.02337983f, -0.03440177f, -0.00556796f, 0.00795900f, -0.01889241f, 0.00801136f, 
    0.00695957f, -0.03713882f, 0.02309752f, -0.00608670f, 0.01624741f, 0.00893721f, 0.02327468f, 0.00769872f, 
    0.01867748f, -0.00588172f, 0.01417724f, 0.01603144f, -0.03233701f, -0.02380845f, 0.00173289f, 0.00222836f, 
    -0.04009158f, 0.00984831f, -0.00059827f, 0.01429496f, -0.02513329f, -0.02097986f, -0.03683685f, 0.01387078f, 
    -0.01459847f, -0.01518768f, 0.02171762f, -0.03200005f, -0.00664004f, -0.02898318f, -0.01961424f, 0.01690781f, 
    0.01661266f, 0.00491603f, -0.01714780f, 0.02073739f, -0.02553165f, 0.01971175f, -0.03173540f, 0.01060434f, 
    -0.01691009f, -0.00548312f, -0.01610084f, 0.02708424f, -0.03500169f, -0.02308252f, -0.03900538f, 0.00169921f, 
    -0.02225087f, 0.02395118f, 0.01964955f, 0.01117770f, -0.03724869f, -0.01425898f, 0.02717007f, 0.03137605f, 
    -0.03695742f, 0.00506928f, 0.00641697f, 0.03147035f, 0.00399465f, -0.02313456f, 0.01006574f, -0.00630814f, 
    0.01558458f, -0.01289251f, 0.01855737f, -0.03083362f, -0.03275149f, -0.00784655f, -0.03531419f, 0.00925075f, 
    -0.01101279f, 0.01924479f, -0.03325513f, 0.02400450f, 0.02610751f, -0.01422480f, 0.02184245f, -0.02159182f, 
    -0.03105707f, -0.02654608f, 0.03229197f, -0.03790064f, -0.01960546f, -0.03181480f, 0.02777181f, -0.00582761f, 
    0.02272729f, -0.02958844f, 0.02022532f, -0.01159372f, 0.02552196f, -0.01300688f, -0.00703859f, 0.01430348f, 
    0.02249319f, 0.02717604f, 0.00831018f, -0.01203840f, -0.03384200f, -0.00609154f, -0.00252181f, -0.03137782f, 
    0.01246175f, -0.03212801f, -0.03218067f, -0.02854526f, 0.02379512f, -0.02080965f, 0.01626559f, -0.01158866f, 
    -0.02050633f, 0.03086996f, 0.02926936f, -0.01079640f, -0.03438655f, 0.02024173f, -0.02361828f, -0.01561421f, 
    -0.02671182f, 0.01789443f, 0.03033808f, 0.02114501f, 0.03138117f, -0.03881706f, -0.00373891f, -0.03523083f, 
    0.00534992f, 0.01952436f, 0.01492338f, 0.00596165f, 0.01629456f, -0.03569089f, -0.02334272f, -0.01933632f, 
    0.01502051f, 0.00416701f, -0.01834604f, 0.00274840f, -0.00618466f, -0.03831099f, -0.00491306f, -0.01271590f, 
    -0.03697204f, -0.01619877f, 0.01137845f, 0.01058529f, 0.03162119f, 0.00501961f, -0.02597345f, -0.02949299f, 
    -0.03770336f, 0.02870919f, -0.03759756f, -0.01474548f, 0.01245860f, -0.00881051f, 0.03101334f, -0.02055470f, 
    -0.01042110f, -0.02270546f, 0.01753644f, -0.00942080f, -0.00883805f, 0.02537392f, -0.02482137f, 0.02360371f, 
    0.01620668f, 0.03052757f, -0.01325917f, -0.01416973f, -0.00702823f, 0.01261326f, -0.00349466f, -0.01516348f, 
    -0.03538572f, -0.00122292f, 0.00018746f, 0.00164130f, -0.01717399f, 0.00454113f, 0.00020354f, -0.02247423f, 
    -0.03528777f, -0.01124571f, -0.03895669f, 0.00535256f, -0.00934838f, -0.01901734f, 0.01029587f, -0.03612859f, 
    -0.03374691f, -0.00330342f, -0.02639195f, -0.01644323f, 0.00061182f, 0.00022499f, -0.01412646f, 0.00420319f, 
    -0.00267943f, 0.01145999f, 0.01134583f, -0.02639713f, -0.03073583f, -0.00881061f, -0.01933494f, -0.01635501f, 
    0.02725016f, 0.01718544f, 0.01176810f, -0.02429553f, -0.02170688f, -0.01454178f, 0.03214261f, -0.03826120f, 
    0.03133521f, 0.00567760f, 0.02037277f, -0.03772921f, -0.03919081f, -0.02745755f, 0.02516611f, -0.03202788f, 
    0.02087424f, -0.01986633f, 0.00925930f, -0.03764383f, -0.01444017f, -0.00873186f, 0.02422251f, -0.01782968f, 
    -0.02034141f, 0.00363229f, 0.01472909f, -0.02464993f, -0.02899793f, 0.02722934f, -0.00883565f, 0.01878621f, 
    0.02345955f, -0.00753994f, 0.01754255f, 0.01567941f, -0.01374765f, 0.03454668f, -0.03277891f, -0.02079217f, 
    -0.01312627f, -0.03401210f, -0.01802535f, -0.02724523f, -0.03420762f, -0.03452962f, 0.01797291f, -0.02640977f, 
    -0.01851907f, 0.02998581f, -0.01550521f, 0.01437678f, -0.01334199f, 0.00946614f, -0.00376009f, -0.03770834f, 
    -0.03942433f, 0.01473772f, -0.02033773f, 0.00389406f, -0.00219350f, 0.00428373f, 0.02349190f, -0.00616718f, 
    0.00598945f, 0.02591578f, 0.01942958f, -0.00506980f, -0.02970573f, -0.00788777f, -0.01173697f, 0.02247788f, 
    -0.02206420f, -0.00600879f, -0.02284411f, -0.00367833f, 0.03263242f, -0.00161475f, -0.00131158f, 0.02505380f, 
    0.01947597f, -0.00434000f, 0.02773933f, 0.01034248f, -0.01859093f, -0.02318931f, -0.00496350f, 0.01272436f, 
    -0.01190228f, 0.00943400f, -0.00832766f, 0.02488795f, -0.01050848f, -0.03109458f, -0.03362875f, -0.03235119f, 
    0.03322530f, -0.01240420f, 0.02436236f, -0.02832863f, -0.00417896f, -0.02989725f, 0.02517459f, 0.01208000f, 
    0.02634061f, -0.01212600f, 0.00981632f, 0.00470009f, -0.03645459f, 0.02948670f, 0.00847996f, -0.03420173f, 
    -0.01913719f, -0.02339626f, 0.00823660f, -0.01386043f, 0.02436086f, -0.01341058f, -0.02160669f, 0.01437750f, 
    -0.03323380f, 0.02181031f, -0.01815904f, -0.01444162f, -0.00874562f, 0.01722009f, 0.01815304f, -0.01431178f, 
    0.02305629f, -0.01035118f, 0.00552778f, -0.01117786f, 0.00977527f, -0.01463540f, -0.00596807f, -0.03809461f, 
    -0.02484882f, -0.03414991f, -0.03454886f, -0.02450431f, -0.02057330f, -0.03468489f, 0.02535058f, 0.00741913f, 
    0.02829394f, -0.01821501f, 0.01437423f, -0.01093958f, 0.00737300f, 0.01432719f, -0.03136707f, 0.00980897f, 
    0.02525264f, -0.01808896f, -0.02980850f, 0.01455931f, -0.02480141f, 0.02781511f, -0.03689434f, -0.02658406f, 
    -0.01707158f, -0.02098529f, 0.00138058f, -0.02199719f, 0.02445074f, 0.02902612f, 0.00944427f, -0.01605027f, 
    0.00074843f, 0.01584624f, 0.01125697f, 0.02958451f, -0.01974081f, -0.03681166f, 0.01330759f, 0.03234520f, 
    0.02389011f, -0.03334306f, -0.03877043f, 0.02388778f, -0.02825608f, 0.00154756f, -0.00171779f, 0.02016732f, 
    -0.03565728f, -0.02356296f, -0.02811529f, -0.03978776f, -0.01981071f, -0.02036674f, -0.01698644f, -0.03474452f, 
    -0.01562473f, -0.03336488f, 0.01202733f, 0.01326119f, 0.02134750f, 0.02635736f, -0.03167310f, -0.02700468f, 
    -0.01817336f, -0.00095797f, 0.01105832f, -0.03896861f, 0.00310022f, 0.02114156f, 0.03077072f, -0.00183031f, 
    -0.03490617f, -0.03685339f, 0.00426885f, 0.00497099f, 0.01995367f, 0.02464855f, -0.02992029f, 0.00000009f, 
    -0.05953250f, -0.02141664f, -0.00921803f, -0.15358217f, 0.03764039f, 0.00450804f, -0.01110958f, 0.05068890f, 
    0.03846826f, 0.10660109f, 0.03333560f, -0.02235716f, -0.04956111f, -0.13602358f, 0.03452122f, 0.24342380f, 
    0.07250424f, 0.06711640f, -0.04746359f, -0.01334280f, -0.02072437f, 0.02157019f, -0.02933118f, -0.05336367f, 
    0.16341850f, -0.18251134f, 0.01171993f, -0.11270968f, 0.07285839f, -0.06900593f, 0.08604966f, 0.39886144f, 
    0.07138149f, -0.02976872f, 0.18336761f, 0.07196148f, -0.06193148f, -0.05298092f, 0.18430541f, 0.19750322f, 
    0.03284208f, -0.13876455f, -0.09041495f, -0.05962305f, -0.04056337f, 0.05379087f, 0.12015253f, 0.10257772f, 
    -0.04912965f, 0.05925956f, -0.03976654f, -0.21784149f, -0.02901866f, -0.08301254f, -0.03878911f, 0.01748921f, 
    0.08801354f, -0.01815377f, 0.02153098f, 0.10844948f, -0.15670685f, 0.16229062f, -0.08613294f, -0.17290276f, 
    0.02334478f, -0.04928517f, -0.00609332f, -0.03625014f, -0.11271846f, 0.04892702f, 0.01723072f, -0.03235171f, 
    0.23525840f, -0.24129879f, -0.04677085f, 0.11725818f, -0.00792298f, 0.19140001f, -0.06467284f, -0.01546295f, 
    -0.05768410f, 0.15026359f, -0.03970518f, -0.00791466f, 0.20151056f, -0.01107666f, -0.07833792f, -0.00638516f, 
    -0.19185938f, 0.09390128f, -0.01460787f, -0.01751760f, 0.04788027f, -0.03291789f, -0.00794916f, 0.06720348f, 
    0.23670711f, -0.10057811f, -0.01960729f, 0.06018136f, -0.08701829f, -0.08799724f, -0.05714412f, -0.10752019f, 
    0.04169619f, 0.01198240f, 0.06825829f, 0.15384525f, -0.16750832f, 0.16638985f, 0.08586962f, 0.21938919f, 
    0.10749446f, 0.07221912f, 0.11795932f, 0.02355036f, -0.04049764f, -0.09646497f, 0.00872433f, 0.01746657f, 
    -0.12044939f, 0.24403727f, 0.08211959f, 0.20916951f, 0.14726521f, 0.04019072f, -0.06023990f, -0.02107678f, 
    -0.09481279f, 0.12649192f, 0.09391122f, 0.08446749f, 0.14919576f, -0.11099599f, -0.02698532f, -0.03306369f, 
    0.12226041f, 0.07907495f, -0.03143559f, 0.06336094f, 0.04923715f, 0.00021104f, 0.07921310f, -0.08644269f, 
    0.28197724f, -0.20176123f, -0.09230901f, -0.07701144f, -0.14536932f, 0.01338393f, 0.00601505f, 0.21263802f, 
    0.13265334f, 0.26128840f, 0.13961147f, 0.11878096f, 0.00605384f, -0.03525571f, 0.08355548f, 0.21596473f, 
    0.07483890f, 0.06552625f, 0.08171485f, -0.03913303f, 0.03164089f, -0.07674546f, 0.03772491f, 0.00807128f, 
    -0.14981984f, -0.21596056f, -0.07014792f, 0.11324981f, -0.02836262f, -0.01848974f, -0.00208274f, 0.01721868f, 
    -0.01758465f, 0.00148273f, -0.04982821f, -0.01210783f, 0.30191499f, 0.08297504f, 0.09169926f, 0.05689961f, 
    -0.09796069f, 0.01570078f, 0.13830508f, -0.05900950f, -0.08360511f, -0.06684941f, 0.02699337f, -0.14355010f, 
    -0.15189251f, 0.11744357f, 0.09507971f, 0.13600151f, -0.02289179f, -0.04871956f, 0.04645521f, 0.10777662f, 
    0.14775503f, 0.02499226f, 0.08213795f, 0.04266087f, -0.30234206f, -0.17030102f, 0.06957906f, 0.01902265f, 
    -0.16747077f, -0.00636158f, -0.01521123f, -0.05028611f, -0.03431949f, 0.03658256f, -0.09671262f, 0.08282647f, 
    -0.10526107f, -0.05709264f, 0.05117133f, 0.32851338f, 0.12988691f, 0.25696865f, 0.06321437f, -0.06857375f, 
    -0.02044897f, -0.06386401f, -0.10070156f, -0.02787928f, -0.13513835f, -0.12917475f, 0.01915609f, 0.05252958f, 
    -0.00384769f, 0.00602858f, 0.01797135f, 0.11207638f, -0.03274475f, -0.09593157f, -0.00351116f, -0.01964061f, 
    0.05122967f, 0.16041887f, 0.03883081f, 0.00911096f, 0.05354527f, -0.01811662f, -0.04128564f, -0.06046329f, 
    -0.15121853f, 0.19394645f, -0.04452698f, -0.01624025f, -0.09341583f, -0.12556180f, 0.17057742f, 0.28968269f, 
    0.20007803f, 0.19506924f, -0.02144544f, -0.14454107f, -0.02246177f, -0.15286438f, -0.03449081f, 0.03113648f, 
    -0.11064926f, 0.33137769f, -0.01511844f, -0.34779683f, -0.02097748f, 0.16336493f, 0.07701933f, 0.00867197f, 
    -0.03260928f, 0.08248602f, 0.01030435f, -0.04916772f, -0.15007998f, 0.21422476f, 0.03030806f, 0.11040413f, 
    0.18114443f, 0.05982050f, -0.19618981f, 0.00502191f, -0.03800349f, 0.06637821f, 0.08543138f, 0.05697830f, 
    -0.03925363f, -0.10776246f, -0.00266610f, -0.14079201f, -0.05107668f, 0.01024908f, 0.00530353f, 0.00978417f, 
    -0.08467802f, 0.05921685f, 0.14522628f, 0.02495925f, 0.30653718f, 0.01269292f, -0.06498940f, -0.12829232f, 
    -0.15298389f, 0.03915758f, -0.05909587f, 0.01034477f, 0.11896008f, 0.08917843f, 0.09594122f, -0.00905709f, 
    -0.11649764f, -0.12822434f, -0.03300883f, -0.21031357f, -0.00295770f, -0.11251278f, 0.02863022f, -0.07113526f, 
    -0.05898777f, 0.00260882f, 0.01006658f, -0.07435475f, -0.18456650f, 0.27103624f, -0.01798924f, 0.03646970f, 
    -0.00996010f, 0.02070562f, 0.08976921f, 0.08502244f, 0.04887165f, -0.03016099f, 0.11882369f, 0.00110609f, 
    -0.16192447f, -0.23558268f, -0.06751891f, 0.04171072f, 0.02690705f, -0.02902078f, 0.02765229f, 0.10244226f, 
    -0.02337786f, -0.00637087f, -0.07062241f, -0.03054012f, -0.14464960f, 0.11274756f, 0.08373295f, 0.06432753f, 
    0.02420351f, 0.18944006f, 0.04084967f, -0.05405873f, 0.05127392f, -0.12029213f, -0.02712464f, -0.04069345f, 
    0.06989834f, -0.18653105f, -0.05516988f, -0.04476533f, -0.12644774f, -0.02153351f, 0.13239670f, -0.00267288f, 
    0.05931530f, 0.06988963f, -0.01285788f, -0.01307151f, 0.10353123f, -0.18798046f, -0.06688027f, 0.19605641f, 
    0.07983287f, -0.11292414f, 0.06992930f, 0.11214702f, -0.07279992f, -0.05750898f, -0.03660508f, -0.04597445f, 
    -0.04118840f, 0.00972646f, -0.00461965f, -0.40288675f, -0.04770781f, 0.02246119f, -0.09146854f, -0.02540763f, 
    -0.04614618f, -0.00790473f, 0.04692220f, -0.10888812f, -0.09319805f, -0.10227782f, -0.04459350f, -0.07939066f, 
    0.06685730f, -0.08168409f, -0.00063787f, -0.02987628f, 0.05235423f, -0.02793230f, -0.07487342f, -0.03648747f, 
    0.09622138f, 0.08621573f, -0.17934409f, 0.05320633f, 0.01221510f, 0.06081618f, -0.04082780f, 0.01732620f, 
    0.17178646f, 0.02614105f, 0.03130825f, -0.13058323f, -0.02664085f, 0.01410528f, -0.00464168f, -0.15774988f, 
    0.00652367f, 0.02943444f, -0.04453874f, -0.02268096f, -0.05747943f, -0.02523937f, 0.19003107f, 0.07523823f, 
    -0.13741754f, 0.06281596f, 0.09892077f, -0.12409683f, 0.14090168f, 0.02932119f, -0.00543974f, -0.06040935f, 
    0.13190959f, -0.05012381f, 0.18839303f, 0.03467411f, -0.24368811f, -0.11075827f, 0.02245473f, 0.25238150f, 
    0.03280114f, 0.02379266f, -0.04024849f, 0.04868625f, -0.06334424f, -0.02600076f, -0.09592910f, -0.00805624f, 
    0.01171379f, 0.06021640f, 0.23754823f, 0.29530260f, 0.07135241f, -0.11895133f, 0.13997307f, 0.00326815f, 
    -0.03218032f, 0.10170674f, 0.02720065f, -0.05977437f, -0.05996565f, -0.07515044f, -0.08634049f, -0.10749147f, 
    -0.05474557f, -0.01434014f, 0.03505185f, 0.10728761f, -0.06508133f, 0.01898345f, 0.02149446f, -0.14282417f, 
    -0.04088813f, -0.05196338f, 0.05909847f, -0.14127305f, -0.02810964f, 0.11085100f, 0.05082144f, 0.05712503f, 
    0.00964861f, 0.22231455f, -0.05861844f, 0.06068851f, -0.20615503f, 0.06070439f, -0.09782480f, 0.26757762f, 
    0.07800380f, 0.04443532f, 0.11293402f, 0.16729914f, -0.03494153f, -0.03966088f, -0.10784275f, -0.04374629f, 
    -0.16378063f, -0.02156035f, 0.02821623f, 0.10277488f, -0.00645546f, -0.05472897f, -0.03154322f, 0.03916418f, 
    0.19832495f, -0.10953463f, 0.01466064f, 0.06672610f, -0.04748312f, -0.03870578f, 0.14154121f, 0.29127568f, 
    0.05177941f, 0.08914000f, -0.07446666f, -0.11129550f, 0.13141543f, -0.10939936f, 0.03802862f, 0.05995137f, 
    0.15490924f, -0.12152489f, -0.27730921f, 0.29074958f, 0.00371889f, -0.08992181f, 0.07335206f, 0.05752161f, 
    0.03988248f, 0.04892822f, -0.06319270f, -0.03874749f, -0.09767015f, 0.00274140f, 0.22741748f, 0.05259424f, 
    0.02842974f, 0.06442489f, 0.09642808f, -0.03937156f, -0.00332716f, 0.10654179f, -0.07994016f, 0.04639092f, 
    -0.08403741f, -0.15253937f, 0.18962893f, -0.10982759f, 0.04456666f, -0.05056371f, -0.03153097f, 0.07693511f, 
    0.01185298f, 0.14780679f, -0.01873254f, -0.04684446f, 0.02988105f, 0.05489587f, 0.34023470f, -0.06663304f, 
    0.01683471f, 0.06783728f, -0.09121558f, -0.04003615f, 0.04508842f, 0.07871211f, 0.05795467f, -0.00685160f, 
    -0.28992584f, 0.02343415f, 0.04410407f, 0.36020988f, 0.10025627f, 0.04226294f, 0.11015891f, -0.10558274f, 
    0.09457340f, 0.03029313f, -0.06196421f, 0.07096242f, -0.15137467f, -0.14815581f, -0.01991138f, 0.21998113f, 
    -0.00776428f, 0.00620610f, 0.09760955f, -0.12324619f, 0.01145309f, -0.04589369f, -0.02833419f, -0.06129162f, 
    -0.21537030f, 0.33365762f, -0.09007427f, 0.24426328f, 0.03301846f, -0.00407125f, -0.09776089f, 0.12908652f, 
    -0.07203510f, -0.08201217f, 0.03479734f, -0.14003551f, -0.01892459f, -0.22693792f, -0.13395585f, 0.12224904f, 
    -0.07750194f, -0.04006471f, 0.00311496f, 0.05639328f, 0.09913073f, 0.01774104f, 0.03948382f, 0.00644964f, 
    -0.14800566f, -0.10749402f, -0.04590138f, 0.10942820f, -0.01563707f, 0.02305887f, 0.07807118f, 0.07770143f, 
    -0.04513237f, -0.06312010f, 0.03170388f, -0.03603736f, 0.46425578f, 0.27929798f, 0.06614418f, -0.07523675f, 
    -0.01288194f, -0.05829979f, 0.03628381f, 0.14654711f, 0.01433597f, 0.04147797f, -0.08284112f, -0.08548398f, 
    -0.25239304f, -0.10783381f, -0.01358403f, 0.05737813f, 0.14324431f, -0.04054531f, -0.04075905f, -0.08768766f, 
    0.04300542f, -0.10607088f, -0.09162688f, 0.06347764f, 0.24466674f, 0.14151385f, 0.07024851f, -0.02955837f, 
    0.00636833f, -0.13964717f, 0.12729770f, 0.06376089f, 0.07813755f, 0.19216116f, 0.01120501f, 0.10465530f, 
    -0.03890496f, -0.09244926f, 0.00798249f, -0.02726979f, -0.00346838f, -0.07259163f, 0.03554258f, 0.19191039f, 
    -0.00978507f, 0.06970382f, 0.11385673f, 0.03042379f, 0.10044465f, -0.14670408f, -0.04886694f, -0.06094729f, 
    -0.10546886f, -0.01143987f, 0.09075262f, 0.03678304f, -0.01829379f, 0.12138501f, 0.03147721f, 0.05315182f, 
    0.17366357f, 0.02288073f, -0.11906117f, -0.27442688f, -0.10322471f, -0.07376912f, 0.00166514f, 0.00894951f, 
    -0.02448518f, 0.04161080f, 0.03165776f, 0.06401402f, 0.00768598f, -0.14651076f, -0.01533259f, 0.16259205f, 
    0.11978067f, -0.02058913f, 0.09468037f, -0.11277983f, 0.10387889f, 0.00561271f, 0.03902904f, -0.02402199f, 
    -0.08761472f, -0.02164366f, 0.07820552f, 0.10463266f, -0.04694719f, -0.01792115f, 0.00028840f, 0.06375131f, 
    0.10834789f, 0.01500262f, 0.03155958f, -0.11443251f, 0.13036311f, 0.00315312f, -0.14485113f, 0.09430523f, 
    -0.01142600f, -0.00390489f, 0.14418434f, 0.11915394f, 0.00756909f, -0.14441414f, -0.04326434f, -0.13527942f, 
    0.23938154f, 0.10412718f, -0.04223392f, -0.28130901f, -0.07413045f, -0.07888985f, 0.06582643f, 0.06415062f, 
    0.11069527f, 0.04256666f, 0.05072372f, 0.06052040f, -0.01636993f, -0.00527928f, 0.03899512f, -0.19514085f, 
    0.05930596f, 0.16241473f, -0.04640182f, -0.01115573f, -0.00835948f, 0.05246424f, 0.04248156f, 0.00025648f, 
    -0.02940802f, 0.01068010f, 0.00629865f, -0.03333227f, 0.01486834f, -0.03945315f, -0.01111106f, -0.01905851f, 
    -0.01547113f, 0.00970380f, 0.00402273f, 0.01374193f, 0.01785608f, 0.02819806f, -0.03634166f, -0.00651461f, 
    -0.04089954f, -0.01511584f, -0.03785283f, 0.01466070f, 0.00897348f, -0.00493711f, -0.01417986f, -0.03711983f, 
    -0.00776291f, 0.02399233f, 0.02108379f, 0.00571368f, 0.02923472f, 0.02844910f, -0.01322256f, 0.01259665f, 
    -0.03153135f, -0.00499851f, -0.03118032f, 0.02543977f, -0.04002819f, 0.01592594f, 0.02131686f, 0.01964569f, 
    0.01761531f, -0.02203853f, 0.01080196f, -0.01863384f, 0.02271361f, 0.02916039f, 0.01210860f, -0.02611997f, 
    0.00824815f, -0.04173670f, 0.02083417f, -0.02925161f, -0.00022252f, 0.00575297f, -0.03807121f, -0.03519545f, 
    0.02122974f, -0.00123445f, 0.00145278f, -0.03475189f, -0.04223858f, -0.03042478f, 0.00495438f, -0.02343041f, 
    -0.04177138f, 0.01383111f, -0.02207781f, -0.02224015f, 0.00790366f, -0.03039075f, 0.01849091f, -0.03395958f, 
    -0.00828603f, 0.01066338f, 0.00115214f, -0.03846537f, -0.03916793f, -0.03429528f, 0.02396069f, 0.00084210f, 
    0.01363771f, 0.02409036f, 0.00223853f, -0.02424118f, 0.01465205f, 0.00474366f, -0.04366682f, -0.02252017f, 
    -0.00294181f, 0.00084660f, 0.00489101f, -0.02849996f, 0.01635629f, 0.02295433f, 0.00040862f, -0.03342145f, 
    -0.01928494f, -0.00767309f, 0.00831316f, 0.01961517f, 0.00587219f, -0.02982942f, -0.01152128f, -0.02597416f, 
    -0.00540856f, -0.00045991f, 0.01518388f, -0.01480944f, 0.01650872f, -0.00826576f, -0.01423511f, -0.03278552f, 
    -0.00096397f, 0.00224156f, 0.00357344f, 0.02490921f, -0.00386809f, 0.00162646f, -0.02910444f, 0.03513375f, 
    -0.03004482f, 0.03167630f, -0.03072662f, 0.00590676f, -0.02537492f, -0.01302345f, 0.02664246f, -0.00048630f, 
    0.01012741f, 0.01064129f, -0.00982497f, 0.03205578f, 0.02450090f, -0.01700956f, -0.00210644f, 0.02243325f, 
    -0.03092852f, -0.03318888f, -0.04290096f, -0.04278533f, -0.03878858f, -0.00073547f, 0.01786729f, -0.01672689f, 
    0.02067106f, -0.02808435f, 0.00714712f, -0.01492465f, -0.04027829f, -0.02741103f, 0.02470566f, -0.04065943f, 
    0.02004909f, -0.01864050f, -0.02086293f, -0.01536594f, -0.02508826f, -0.01172450f, -0.03075737f, -0.00387977f, 
    0.02323017f, 0.00134351f, 0.01885236f, 0.00811815f, -0.00693151f, -0.03943941f, 0.03049683f, -0.01402397f, 
    -0.02232283f, -0.02217148f, -0.02935084f, 0.01998420f, -0.03072179f, 0.01331981f, 0.02426815f, 0.02595124f, 
    0.02419370f, -0.00765175f, -0.02970658f, -0.00280789f, -0.00107230f, 0.01872767f, -0.04008752f, -0.00146817f, 
    -0.01848640f, -0.02459083f, -0.00688717f, -0.02207177f, 0.00764300f, -0.01545063f, 0.03685444f, 0.02947576f, 
    -0.03659270f, -0.03587698f, 0.00761287f, 0.01755526f, 0.02694819f, 0.02536416f, 0.00133813f, 0.02300349f, 
    0.02381791f, -0.02941944f, -0.01756400f, -0.00611194f, -0.00843474f, 0.00414839f, -0.01089439f, 0.00445011f, 
    0.01305920f, 0.00410569f, -0.02104148f, -0.01912359f, -0.00525980f, -0.01854058f, -0.00285789f, -0.01892908f, 
    0.02476321f, 0.02424938f, 0.01564961f, -0.03936081f, -0.02751562f, 0.02793616f, 0.02332852f, -0.00630628f, 
    0.01657625f, 0.01903961f, -0.00750549f, 0.01375984f, -0.00446298f, -0.00567959f, 0.02371158f, -0.01764144f, 
    -0.01809658f, -0.02667436f, 0.01433537f, -0.03353401f, 0.02303781f, -0.01869033f, -0.02750299f, 0.00035294f, 
    0.02112369f, 0.00337378f, -0.01851884f, -0.04137729f, -0.01883859f, -0.03274632f, 0.02261748f, -0.01223359f, 
    -0.00175120f, 0.01119642f, -0.02155603f, 0.00806282f, -0.00616697f, -0.02276467f, -0.01912575f, 0.00787140f, 
    -0.00131922f, -0.02333860f, -0.03051175f, -0.00955288f, -0.00356103f, 0.02597428f, -0.00241354f, -0.04126578f, 
    -0.00080973f, -0.03667079f, -0.04606565f, -0.03741245f, 0.02277422f, 0.02612452f, -0.03716066f, 0.02635581f, 
    0.03114640f, -0.00732199f, -0.01959196f, -0.02923224f, 0.00323690f, -0.02739753f, 0.02242060f, 0.01417353f, 
    -0.03354640f, 0.02597602f, 0.02646852f, -0.01242366f, 0.00553057f, -0.02471549f, 0.00888927f, -0.00913118f, 
    0.02836738f, 0.01839146f, -0.00038087f, -0.04058788f, -0.03994490f, -0.00365593f, -0.01655239f, -0.02879270f, 
    -0.00703649f, 0.01013823f, -0.00067166f, 0.00789981f, -0.03254002f, -0.01148109f, 0.01296012f, 0.00715511f, 
    0.02457734f, -0.01541455f, -0.00770590f, -0.00620864f, -0.02728345f, 0.00119633f, 0.01261412f, 0.00101287f, 
    0.00734851f, 0.01287319f, 0.02301899f, 0.03181290f, 0.01695476f, 0.03603105f, -0.03897722f, 0.01819967f, 
    0.02594467f, 0.01159516f, -0.02425958f, -0.02750702f, -0.02276174f, 0.00575253f, 0.02613980f, -0.03839196f, 
    -0.03919172f, -0.02623318f, 0.00137736f, 0.01948760f, 0.01248481f, -0.02742559f, -0.01425165f, 0.02551066f, 
    -0.01488065f, -0.02325222f, -0.00358484f, -0.03684969f, 0.01484442f, -0.04460840f, 0.02157260f, -0.02471893f, 
    0.02096855f, -0.01952523f, 0.02845053f, -0.00912337f, -0.02523263f, 0.01595162f, 0.02196932f, -0.02506490f, 
    0.02259389f, -0.01883249f, -0.01691533f, -0.00738013f, 0.02701717f, 0.00294468f, 0.01173819f, -0.00079863f, 
    0.03603327f, -0.00384325f, -0.02534155f, -0.02455804f, -0.04311561f, 0.00604332f, -0.03284221f, -0.00640627f, 
    -0.03722828f, -0.02410259f, 0.00642090f, -0.00473196f, -0.00015481f, -0.00406390f, 0.02514324f, -0.00515222f, 
    0.01453214f, 0.02159655f, 0.00217536f, -0.03363300f, -0.01031093f, -0.03792219f, -0.01617433f, 0.00180248f, 
    0.02638732f, 0.01722738f, -0.01194835f, -0.00687686f, 0.03776448f, -0.00324833f, 0.01225325f, 0.00224917f, 
    -0.03231147f, 0.00750903f, 0.02977923f, -0.01217224f, -0.02212671f, 0.00514493f, -0.01432068f, -0.02114894f, 
    0.02061606f, 0.01184039f, -0.02025130f, -0.01086002f, 0.01745600f, -0.00316993f, -0.00243495f, 0.00088372f, 
    0.01387934f, -0.00607042f, -0.03692609f, -0.00074956f, 0.03419176f, -0.03370929f, -0.00115143f, 0.00819830f, 
    -0.00699622f, -0.02092012f, -0.02248511f, 0.02067347f, -0.03171855f, -0.04376881f, 0.01318376f, 0.01994195f, 
    0.00141243f, -0.02640594f, -0.03321768f, -0.00010300f, -0.03665243f, 0.02296288f, -0.02687073f, -0.03127299f, 
    -0.03227200f, -0.01236407f, 0.02159169f, 0.00678441f, -0.01921918f, 0.02285467f, -0.02301599f, 0.00185698f, 
    -0.01657797f, 0.00681813f, 0.00787197f, 0.01624190f, -0.02505748f, -0.02706430f, -0.02820409f, -0.03954400f, 
    0.01538645f, -0.01021867f, -0.00576033f, -0.03761422f, -0.03272624f, 0.02887772f, -0.02192865f, 0.01518480f, 
    -0.01470194f, -0.04069842f, 0.02200103f, -0.01883487f, 0.02439475f, -0.02183854f, 0.02696849f, -0.00198173f, 
    -0.03524739f, -0.03230225f, 0.01384909f, -0.00475069f, 0.01790868f, 0.01272408f, 0.01115671f, -0.00870231f, 
    -0.00180344f, -0.00829300f, 0.02418469f, 0.00294872f, -0.01695452f, -0.03284728f, 0.01053694f, -0.00378787f, 
    -0.04086450f, 0.00205995f, 0.01566459f, -0.02365489f, -0.01510464f, 0.01333934f, 0.00430822f, -0.01970524f, 
    -0.02790035f, -0.00832376f, 0.02175105f, 0.00096613f, 0.03264135f, -0.01687542f, 0.00237942f, -0.01650012f, 
    -0.03476287f, -0.00200772f, -0.02388595f, 0.02099746f, -0.04280795f, -0.01226756f, -0.00155252f, 0.01760672f, 
    -0.00494040f, -0.03297331f, 0.01684305f, -0.03442520f, -0.02607892f, -0.03459474f, -0.00183550f, 0.01621363f, 
    -0.04178051f, 0.01047508f, 0.00475876f, 0.02123939f, -0.03297624f, 0.01656075f, 0.01412670f, 0.02538105f, 
    -0.01346730f, 0.00667425f, -0.01216203f, -0.03499010f, -0.04335058f, 0.02983457f, -0.04539169f, -0.02735181f, 
    -0.01057327f, -0.00876382f, 0.01014699f, 0.02461926f, 0.01018249f, -0.01197731f, 0.01039489f, 0.01242797f, 
    -0.01653323f, -0.02237273f, -0.01785660f, -0.00731477f, 0.00399447f, -0.01979381f, -0.02331553f, 0.02441339f, 
    -0.00479247f, 0.00249649f, -0.03475048f, -0.02801509f, -0.02313169f, 0.02465435f, 0.00814561f, -0.02609219f, 
    0.02010895f, -0.00409490f, -0.02668028f, 0.00897968f, 0.00948984f, -0.02014729f, 0.00700685f, -0.04193450f, 
    0.00903054f, -0.02815341f, -0.02701936f, 0.01046121f, -0.00688279f, -0.00836239f, -0.02175289f, 0.01027967f, 
    -0.01563810f, -0.03555261f, 0.02014063f, -0.04538088f, -0.01468106f, -0.02101734f, -0.01233764f, -0.00344263f, 
    -0.00227162f, 0.00632991f, 0.02153741f, -0.02379966f, -0.01577626f, 0.01909775f, 0.01846292f, -0.00535838f, 
    -0.01494808f, -0.04468141f, -0.03970573f, 0.00574761f, -0.03508291f, -0.03297826f, 0.00537902f, -0.01621088f, 
    -0.03948044f, -0.00273802f, 0.02401893f, -0.03473240f, -0.01648067f, 0.00813007f, -0.01305312f, -0.02049430f, 
    0.01519651f, -0.02060986f, -0.01245652f, 0.02243946f, 0.00398590f, -0.02989894f, 0.01144031f, 0.00887287f, 
    0.00607453f, -0.01988442f, -0.03650156f, 0.01880862f, -0.00035777f, 0.00842196f, -0.03603324f, 0.00303198f, 
    0.02354785f, -0.00747985f, -0.02125422f, -0.00848172f, -0.02246580f, 0.01851228f, 0.00698289f, -0.01942130f, 
    0.00186184f, -0.02867028f, -0.03426636f, 0.00071220f, -0.01494400f, -0.01209379f, 0.02348376f, 0.01388749f, 
    -0.00181649f, 0.03783458f, -0.02784911f, 0.02776216f, -0.02120955f, -0.04493351f, -0.00878766f, -0.01116345f, 
    0.00366522f, -0.02706135f, -0.03328437f, 0.00830923f, -0.03413852f, -0.02547444f, -0.03294814f, -0.03985882f, 
    0.02228423f, -0.03456262f, -0.04072618f, 0.01536642f, -0.02019975f, 0.01426764f, -0.00007096f, 0.02086655f, 
    0.00381077f, -0.03925884f, -0.03950961f, -0.03955523f, -0.01977375f, 0.01187709f, -0.00734344f, -0.00646577f, 
    -0.02519133f, -0.02073604f, -0.03020355f, -0.01110801f, 0.01193325f, 0.00503448f, -0.01963320f, -0.02275882f, 
    -0.04372268f, -0.03818331f, -0.00843705f, -0.01928190f, -0.00945811f, 0.00096529f, 0.00915860f, -0.01874896f, 
    -0.04323209f, -0.00436343f, -0.00848780f, 0.00712394f, 0.00249194f, -0.03600596f, 0.02761634f, 0.01602398f, 
    -0.03278525f, -0.03380802f, -0.03272367f, -0.03897797f, -0.02017436f, 0.00975923f, 0.01969558f, 0.02522759f, 
    0.02347804f, -0.04041268f, -0.00354899f, -0.00714101f, -0.00076492f, -0.03616602f, -0.00497809f, -0.00525792f, 
    -0.02707229f, -0.04250015f, 0.00533160f, -0.02754487f, 0.01670985f, 0.01585288f, -0.03259269f, -0.01776576f, 
    0.02955195f, -0.00935058f, 0.03157801f, 0.00732024f, 0.02132713f, -0.02358246f, -0.00039636f, -0.03146581f, 
    0.00199813f, 0.01807145f, -0.02682102f, -0.02393833f, -0.01808560f, 0.02418416f, -0.01811724f, 0.01989199f, 
    -0.03949873f, -0.01420966f, 0.00662512f, -0.01843955f, 0.02242205f, -0.01976298f, 0.02702428f, -0.01553724f, 
    0.00996529f, 0.00635508f, 0.01422362f, -0.03015545f, -0.02309361f, -0.01877897f, -0.01662703f, -0.00642972f, 
    0.00680302f, 0.00602903f, -0.00415801f, 0.02097884f, -0.04397305f, -0.03804425f, 0.00748909f, -0.03739092f, 
    0.00949975f, 0.02609096f, 0.02803103f, 0.01559093f, -0.02755507f, -0.01491430f, -0.03769451f, -0.01535007f, 
    -0.02247650f, -0.00815934f, -0.02245264f, -0.00612409f, -0.02003147f, -0.01342331f, -0.00089029f, 0.01404595f, 
    -0.00716953f, 0.02942364f, 0.00626353f, -0.03486399f, 0.00945252f, 0.01459278f, -0.01430596f, -0.00778098f, 
    0.02415644f, -0.00616185f, 0.01899844f, -0.02767573f, 0.00754466f, 0.01302126f, 0.02684591f, 0.01665303f, 
    -0.02839772f, -0.03081172f, -0.02736100f, 0.01400765f, -0.01841705f, 0.01784612f, -0.01903927f, 0.00885559f, 
    0.02834633f, -0.03203519f, -0.00189524f, 0.00710848f, -0.02995359f, -0.00477367f, 0.02746759f, 0.01847357f, 
    -0.03923963f, 0.00587129f, 0.02890672f, 0.01700117f, 0.01699090f, -0.02033559f, -0.01206086f, -0.01341053f, 
    -0.03494368f, -0.01304918f, 0.00008487f, 0.00219033f, -0.01068310f, -0.00817223f, 0.02754769f, -0.01671269f, 
    -0.01987131f, -0.01238769f, 0.01182719f, 0.02569100f, 0.02640623f, 0.02855510f, -0.02452563f, -0.01382090f, 
    0.03094273f, -0.02071029f, 0.01375420f, 0.02187660f, 0.00062402f, 0.02951537f, -0.00564807f, -0.03105070f, 
    -0.00044949f, -0.00889919f, 0.02297710f, -0.03482044f, -0.00145106f, 0.02454627f, 0.02545807f, 0.01096148f, 
    0.02215916f, 0.02391581f, 0.03341133f, -0.03463105f, -0.03769394f, -0.03952379f, 0.03750038f, -0.02510903f, 
    -0.03314294f, -0.02281241f, 0.00679881f, 0.00043958f, -0.02014561f, -0.02040874f, 0.00700025f, -0.00598734f, 
    -0.00825338f, 0.00156423f, -0.01399508f, -0.00416995f, -0.01685161f, -0.01734244f, 0.00622205f, 0.02864247f, 
    -0.01887088f, -0.02945438f, 0.01733122f, -0.01504095f, -0.04167079f, -0.04191958f, -0.00202308f, -0.00769686f, 
    0.01193905f, -0.00897282f, 0.00915999f, 0.01244885f, -0.02241731f, -0.02442490f, 0.01286572f, -0.01434242f, 
    -0.01127817f, -0.00919799f, -0.04169662f, 0.01266811f, -0.02623907f, -0.01230782f, 0.00468041f, 0.02373195f, 
    0.01919142f, 0.01639710f, -0.01426615f, 0.01716673f, -0.02007420f, -0.00395574f, 0.01004311f, -0.00428291f, 
    0.00662856f, -0.02201225f, 0.02263281f, -0.00430298f, -0.03097348f, -0.01680878f, -0.02104364f, 0.04051045f, 
    0.01415778f, -0.01556389f, 0.02719020f, -0.03892751f, 0.01593312f, -0.03555352f, -0.01490808f, -0.03563391f, 
    -0.02507050f, -0.03870471f, -0.01205173f, 0.01076912f, 0.01807235f, 0.02714130f, -0.02825074f, -0.02191902f, 
    0.00761756f, 0.00438996f, 0.00119333f, -0.02470661f, -0.01290662f, -0.01036640f, 0.02618679f, 0.02474134f, 
    0.01257272f, -0.04201527f, 0.01140598f, -0.03279958f, -0.02832555f, -0.01802638f, -0.00673479f, 0.02389273f, 
    0.03399244f, 0.02889487f, -0.02319957f, 0.02988305f, 0.01074203f, 0.00347855f, -0.03930312f, -0.02508392f, 
    0.01647663f, 0.02821030f, 0.00594093f, -0.03105638f, -0.00899440f, 0.00304146f, -0.02539006f, -0.02490711f, 
    -0.03756373f, -0.02016242f, -0.02142163f, 0.02420318f, 0.01524488f, -0.02538520f, -0.03183211f, -0.02681888f, 
    -0.02921345f, -0.02469365f, -0.00513700f, 0.00071257f, -0.02906938f, 0.00106400f, -0.00363690f, 0.00619958f, 
    -0.02521820f, -0.03638963f, -0.03699904f, 0.02226341f, 0.00758254f, -0.02724696f, 0.00496616f, -0.00741673f, 
    0.00518579f, -0.02378276f, -0.00270038f, -0.02742899f, 0.02223758f, -0.00714316f, -0.01172317f, -0.01136927f, 
    -0.02364978f, 0.01267548f, -0.02364434f, -0.02638575f, 0.02923120f, -0.03516503f, -0.01096621f, -0.03470591f, 
    -0.02880589f, -0.02482958f, -0.03490396f, 0.00413332f, 0.01036548f, 0.02171736f, 0.01932344f, 0.01280930f, 
    0.02723420f, 0.00805181f, -0.00654620f, 0.02205516f, 0.01474433f, -0.00877411f, 0.00971870f, -0.03188061f, 
    -0.02941972f, 0.00928774f, -0.01338553f, -0.03301266f, 0.01851978f, 0.00719646f, 0.02431322f, -0.03410533f, 
    0.00624997f, 0.02723318f, -0.03269175f, -0.03602921f, -0.01011295f, 0.02837585f, 0.01631030f, 0.00524547f, 
    -0.04190206f, -0.03888107f, -0.00853983f, -0.02545146f, -0.04072781f, -0.01881150f, -0.02367132f, 0.01913375f, 
    0.00436498f, -0.03482346f, 0.01021067f, -0.03252301f, -0.04196386f, 0.02835316f, -0.03105195f, -0.03992642f, 
    0.02751075f, -0.01664157f, -0.02200816f, -0.04135841f, -0.02444466f, -0.03144794f, 0.01987481f, 0.02272265f, 
    0.03217787f, 0.02689930f, 0.00399529f, 0.03760619f, 0.03094240f, -0.01819388f, -0.02954531f, 0.02589664f, 
    0.01639475f, 0.02374751f, 0.01843002f, -0.02492324f, -0.02220070f, -0.03818014f, -0.00328215f, -0.01110372f, 
    0.00185686f, -0.01630056f, 0.02214297f, -0.02031080f, 0.02287972f, -0.02583770f, -0.00527804f, -0.03790312f, 
    0.01548763f, 0.00939825f, -0.01296679f, -0.00865956f, 0.01732620f, 0.02014645f, 0.00135177f, 0.01580083f, 
    0.02819709f, 0.01162003f, -0.00337366f, -0.02240464f, -0.02494824f, 0.00452280f, 0.02514941f, 0.01578819f, 
    -0.03012546f, -0.02541836f, -0.02129501f, 0.02714564f, 0.01571435f, -0.01478584f, -0.00426595f, -0.00009953f, 
    -0.01643237f, -0.03303640f, 0.01891292f, 0.00403862f, -0.00926926f, 0.01622625f, 0.02056183f, -0.00939946f, 
    0.01800296f, -0.00252414f, 0.00661056f, 0.03428416f, 0.01021135f, 0.00913280f, -0.02887278f, 0.00851770f, 
    -0.03855123f, -0.03938606f, -0.00565115f, 0.01562730f, 0.02331935f, -0.00368710f, -0.00329007f, -0.01172379f, 
    0.00791989f, -0.00266995f, -0.00789520f, -0.00527504f, -0.01191588f, -0.03092345f, -0.00631162f, -0.01067301f, 
    0.00925338f, 0.00653307f, 0.00721383f, 0.00599259f, 0.01575757f, -0.02548365f, -0.03694000f, 0.00853177f, 
    -0.04018503f, 0.00365110f, -0.02796221f, -0.03184255f, 0.01609609f, -0.01966317f, -0.02974194f, 0.02837020f, 
    0.02883423f, 0.00820673f, 0.01786598f, -0.03058868f, -0.04146218f, -0.00411400f, 0.00673913f, 0.01095696f, 
    0.00020478f, 0.00917186f, -0.03901144f, 0.02754889f, -0.01458534f, -0.02863239f, 0.00617785f, -0.01587287f, 
    -0.02755774f, -0.00935830f, 0.02967964f, -0.02933910f, 0.01812844f, -0.03410320f, -0.02191478f, -0.02497146f, 
    0.01407493f, -0.04016751f, 0.00145423f, -0.03029268f, 0.02502180f, -0.02965914f, 0.00078926f, -0.02993144f, 
    0.00173203f, -0.03627515f, -0.01710857f, -0.01522217f, 0.02497398f, 0.01715048f, -0.01944629f, -0.03875541f, 
    0.02264995f, -0.00474263f, 0.00275938f, -0.03357447f, 0.00046047f, -0.01905777f, -0.00047129f, 0.01392398f, 
    0.01376138f, 0.00091730f, -0.00282670f, -0.02583567f, -0.00531200f, 0.00198992f, -0.02594573f, -0.00983581f, 
    -0.00369256f, -0.03575942f, 0.00760147f, 0.00292194f, 0.01382734f, 0.02667877f, 0.00407552f, -0.00711593f, 
    0.00381404f, 0.03290150f, 0.00806076f, 0.01276958f, -0.01855040f, -0.01553590f, 0.00524104f, 0.00567661f, 
    0.01681783f, 0.03308263f, -0.03532931f, -0.00476508f, 0.00478238f, -0.00908877f, 0.01789080f, 0.02793432f, 
    -0.00487062f, 0.01490709f, 0.01893040f, -0.02688538f, 0.00761420f, 0.00423433f, 0.01140202f, 0.02858086f, 
    0.01570250f, 0.00107125f, 0.00700292f, -0.00608537f, -0.00154196f, 0.00257959f, 0.00574332f, 0.01560092f, 
    -0.02454598f, -0.02493871f, -0.03171114f, -0.02239982f, -0.02929807f, 0.01733981f, -0.02166467f, 0.02526360f, 
    0.01350515f, -0.02039849f, -0.02443508f, -0.04090498f, -0.01585976f, 0.01741404f, 0.00092576f, 0.02710363f, 
    0.00842626f, 0.01808353f, -0.03878596f, 0.02564831f, -0.01065243f, 0.01409591f, -0.01473984f, 0.01449654f, 
    0.02820286f, 0.00739705f, -0.03757548f, -0.04093067f, -0.01511617f, 0.02223232f, -0.00083998f, -0.01504689f, 
    -0.04008977f, 0.00758939f, -0.02337379f, -0.00500204f, -0.03524812f, -0.00528644f, 0.01503378f, 0.03570199f, 
    -0.01964010f, -0.03674601f, -0.02090540f, 0.02912058f, 0.03760543f, 0.03237895f, -0.00136411f, -0.01200867f, 
    0.00342392f, -0.02870045f, -0.02823173f, 0.00168716f, -0.00114731f, 0.00481449f, -0.03006634f, -0.02369146f, 
    -0.01498500f, -0.00837205f, -0.02972426f, -0.03599184f, 0.02447842f, 0.00556355f, 0.01886454f, 0.02195879f, 
    -0.01627838f, -0.01500811f, -0.00442062f, 0.00547327f, 0.00030371f, -0.02183188f, -0.00515490f, -0.02395120f, 
    0.02653539f, -0.00839042f, -0.02431274f, 0.00816758f, 0.01107570f, -0.03520984f, -0.03129262f, 0.01560378f, 
    -0.01822186f, -0.01534750f, 0.00979285f, -0.03040765f, -0.02910052f, -0.01133783f, -0.01504627f, -0.00043713f, 
    -0.03187434f, -0.02642794f, 0.01913443f, -0.03942219f, -0.01546400f, 0.03301786f, -0.03544671f, -0.01583738f, 
    -0.02429768f, 0.02235074f, 0.01048252f, -0.04166150f, -0.02362943f, -0.00132726f, 0.00996348f, -0.00790523f, 
    -0.02481711f, -0.00816432f, 0.00454219f, -0.00177625f, -0.01264706f, 0.04000539f, -0.01942548f, -0.02169423f, 
    0.01629527f, 0.01343927f, -0.01789075f, 0.01910870f, 0.01496815f, 0.00726470f, 0.00325056f, -0.00946143f, 
    0.02099144f, 0.03730714f, -0.03229438f, -0.01627295f, 0.01104920f, 0.00888192f, 0.00997403f, -0.00206294f, 
    -0.04060785f, -0.01654505f, 0.02649890f, 0.02244257f, 0.04199269f, -0.01028908f, -0.01445225f, 0.02865466f, 
    0.02752747f, 0.01661848f, 0.02190250f, -0.03685752f, -0.00454531f, 0.02368461f, -0.02589529f, -0.02133797f, 
    -0.02915018f, 0.01303154f, -0.03895002f, 0.01388920f, 0.00195973f, -0.03122456f, -0.01536783f, -0.00626339f, 
    -0.00173835f, 0.01602156f, 0.01661102f, 0.02388500f, 0.01306443f, -0.01470633f, 0.01859457f, -0.02750549f, 
    -0.02005621f, -0.02929505f, -0.01374474f, 0.01360025f, -0.02665380f, -0.02912652f, -0.00291716f, 0.01315001f, 
    0.02325041f, 0.02441066f, 0.02757411f, -0.01671940f, -0.03578928f, -0.01340189f, 0.00885188f, 0.02191736f, 
    0.02845404f, 0.02291845f, -0.01797423f, 0.02462467f, 0.00828111f, -0.02540625f, 0.00191702f, 0.02700301f, 
    -0.01290076f, -0.03116773f, 0.00885522f, 0.01908328f, 0.02680168f, -0.02151780f, 0.02586102f, 0.02099318f, 
    0.00228769f, -0.00127135f, -0.02011295f, -0.01923927f, 0.03476765f, 0.02478619f, -0.03501484f, 0.00685136f, 
    -0.02578819f, 0.02979265f, -0.00411998f, -0.02607656f, 0.01573119f, 0.02684925f, -0.01171445f, 0.00226988f, 
    -0.00920449f, 0.02617090f, 0.01652346f, -0.01002049f, -0.03829680f, -0.01851286f, 0.00055953f, -0.00987346f, 
    -0.00191084f, 0.01248798f, -0.02209920f, -0.00381452f, -0.01113225f, -0.00356399f, 0.00868123f, 0.01314735f, 
    0.01678808f, -0.02278828f, -0.02573672f, 0.01499892f, -0.02876507f, -0.03564322f, 0.01164256f, 0.01947464f, 
    -0.03014421f, 0.00829957f, 0.00287125f, -0.03441320f, -0.03831149f, 0.00000385f, 0.00809984f, -0.02557491f, 
    0.02240947f, -0.00267797f, 0.00890152f, 0.02449773f, 0.02632499f, -0.03936512f, -0.03065676f, 0.00845226f, 
    0.01428386f, 0.00576728f, -0.02802859f, -0.01007180f, 0.03578961f, 0.01733905f, -0.01635648f, 0.04049195f, 
    -0.00471188f, -0.03180601f, -0.01704798f, 0.00633503f, -0.00759176f, -0.00407473f, 0.00721032f, -0.00106128f, 
    -0.02028735f, -0.02052945f, -0.02917318f, -0.03450372f, 0.00908573f, -0.03893871f, 0.01928657f, 0.00336900f, 
    -0.03115740f, -0.00928023f, -0.03809538f, 0.01787170f, 0.00407244f, 0.01705002f, 0.01754291f, 0.02016851f, 
    0.00032969f, -0.00912051f, 0.00832875f, -0.01773085f, -0.00627318f, -0.02988210f, -0.01844906f, -0.01214628f, 
    0.01244063f, 0.00958381f, -0.02148630f, 0.00545621f, -0.02972276f, -0.02492613f, -0.02360533f, 0.02770591f, 
    0.12256062f, -0.03737185f, -0.21954171f, -0.16803613f, 0.02311740f, 0.00701668f, 0.05883591f, -0.18887900f, 
    0.04723773f, -0.22595683f, -0.21188411f, 0.05959189f, 0.01821976f, 0.23723663f, -0.07275293f, -0.12538546f, 
    -0.05319286f, -0.09684382f, -0.13398293f, 0.05646168f, 0.07577575f, -0.00155741f, 0.04422329f, -0.06360254f, 
    0.18169712f, -0.12205779f, -0.06442136f, -0.11971473f, -0.14256090f, 0.07029779f, 0.00718853f, -0.16364798f, 
    -0.02300080f, -0.00028665f, -0.11472109f, 0.04286034f, 0.05024193f, 0.10007092f, 0.19624044f, 0.17322809f, 
    -0.11075731f, 0.02619813f, 0.04794146f, 0.06877102f, 0.00192709f, 0.13355523f, 0.16125233f, 0.10192071f, 
    -0.02374798f, -0.06666905f, -0.02112752f, -0.10522082f, 0.07969791f, -0.05188298f, 0.03213099f, -0.15599160f, 
    -0.06961660f, -0.08163717f, -0.04737681f, 0.02149645f, 0.08190855f, -0.19168167f, 0.07367539f, 0.12795548f, 
    0.09130029f, -0.09993181f, -0.04068143f, -0.02781465f, 0.13858609f, 0.08290182f, 0.08987869f, 0.21057162f, 
    -0.03270269f, -0.03335791f, 0.05504185f, -0.30414617f, 0.00636865f, -0.12956822f, -0.02248613f, 0.15091723f, 
    -0.01612322f, -0.17435558f, 0.00625300f, -0.14136840f, -0.20732848f, 0.08527679f, -0.08545782f, -0.00755167f, 
    0.08831247f, 0.03280818f, -0.00868246f, -0.01978434f, -0.15989843f, -0.07470557f, 0.01734153f, -0.10604730f, 
    0.02596570f, -0.02182136f, -0.10930207f, 0.00352364f, 0.20130853f, 0.07459711f, -0.04362179f, -0.06749163f, 
    -0.28205907f, -0.14233953f, -0.21694644f, -0.15822132f, 0.10397620f, -0.05783594f, 0.18820074f, -0.01257416f, 
    0.11950437f, -0.02565725f, 0.08749621f, 0.02526207f, 0.00306101f, -0.03439678f, 0.06806739f, 0.15878820f, 
    0.02052499f, 0.21579538f, 0.08758768f, -0.17870365f, 0.00500901f, -0.05582356f, 0.02659660f, -0.05233793f, 
    0.06275498f, -0.06737226f, -0.15239744f, 0.06653306f, -0.43952221f, 0.19411315f, -0.16477443f, -0.07283770f, 
    0.01183201f, -0.01983876f, 0.05496961f, -0.03338723f, -0.07419150f, -0.18133897f, -0.07730196f, -0.18714969f, 
    0.08415871f, -0.03871327f, 0.17511353f, -0.07582085f, 0.16649826f, -0.00667598f, 0.00869364f, -0.10935576f, 
    -0.07030015f, -0.01321566f, -0.15349635f, -0.00110374f, -0.20669796f, -0.15026855f, -0.42694592f, 0.11773347f, 
    -0.00384825f, 0.10920770f, -0.13458604f, -0.06469180f, 0.01828873f, -0.15808995f, -0.03432481f, -0.15659092f, 
    0.06073719f, 0.01451153f, -0.08167855f, 0.00415754f, 0.05272686f, 0.08088010f, -0.03324010f, 0.07902060f, 
    -0.09849367f, -0.00354494f, -0.03262489f, 0.05273576f, -0.11875663f, 0.10605218f, -0.09526458f, 0.22795370f, 
    0.00940125f, 0.09884749f, -0.02152784f, -0.16729617f, 0.01002164f, 0.11048803f, 0.19773555f, 0.18998906f, 
    0.04778101f, 0.09271605f, 0.00055032f, 0.14693891f, 0.14641048f, -0.11312733f, 0.13486491f, -0.11293873f, 
    -0.25313896f, -0.25293079f, 0.02824947f, -0.35528994f, -0.30255342f, -0.21541619f, -0.08144333f, 0.13891584f, 
    0.04683990f, 0.10626451f, 0.05362099f, -0.02081422f, -0.09018406f, -0.07472788f, -0.14121264f, -0.11819139f, 
    -0.10730893f, 0.09394237f, -0.21390580f, -0.03020029f, 0.03578109f, 0.04618324f, 0.13146591f, 0.03916273f, 
    0.08338440f, -0.01060519f, 0.01716947f, 0.09489723f, -0.01094306f, 0.12512314f, 0.04130890f, 0.01295218f, 
    0.03400389f, 0.07688840f, 0.08438033f, -0.03183375f, 0.15912524f, 0.05639806f, 0.08697876f, 0.17197835f, 
    -0.05509540f, -0.05433413f, 0.11072668f, -0.15085901f, -0.08289772f, 0.05557141f, -0.01809719f, 0.06810964f, 
    -0.10440280f, -0.16274002f, 0.18994120f, 0.06869531f, 0.16348754f, -0.00921048f, 0.01998416f, -0.33890995f, 
    0.06197790f, -0.01582377f, 0.02596793f, -0.06460066f, 0.15553096f, 0.09154217f, -0.05021775f, -0.09497887f, 
    0.18791294f, -0.06269013f, 0.20505442f, -0.44084835f, -0.05790494f, -0.11309614f, 0.03014204f, -0.07670440f, 
    0.12172312f, -0.03565419f, 0.07089406f, -0.09016965f, -0.02763226f, 0.18553825f, -0.04733710f, -0.04553690f, 
    -0.11058466f, -0.03382232f, -0.09303781f, 0.01919355f, 0.00649070f, -0.14617294f, -0.04566559f, -0.14290394f, 
    -0.06579949f, 0.00552576f, -0.04999133f, -0.18386471f, -0.06750803f, -0.04944006f, 0.08746895f, -0.09016789f, 
    -0.08915979f, -0.29424855f, -0.17893967f, -0.13940294f, 0.02868656f, 0.20585653f, -0.06244873f, 0.23054363f, 
    -0.07177988f, 0.00852899f, -0.07075947f, 0.05449148f, -0.05326950f, -0.12025223f, 0.08991299f, 0.28131798f, 
    -0.07195777f, -0.23855950f, 0.02775198f, -0.15386097f, 0.03652268f, 0.09412098f, 0.23063695f, -0.14959359f, 
    0.16868025f, 0.05397006f, 0.06153868f, 0.15278824f, 0.21742775f, 0.15532760f, 0.18891557f, 0.08817065f, 
    -0.10756278f, -0.11570434f, 0.12090831f, -0.10670682f, 0.08659599f, 0.06717275f, 0.10157108f, 0.21835320f, 
    0.04832266f, -0.05990032f, -0.00648870f, 0.08922763f, 0.03800391f, 0.09439658f, 0.09076204f, 0.05346159f, 
    -0.02980053f, 0.07174697f, 0.07303130f, 0.02365041f, -0.32691056f, 0.15327428f, -0.07482413f, -0.06965928f, 
    0.08223917f, -0.08937896f, 0.19578281f, 0.10572042f, 0.10285786f, -0.04543563f, -0.14547095f, -0.07214615f, 
    0.00911600f, 0.10025051f, -0.26132041f, 0.10136527f, 0.16103606f, 0.17834602f, 0.08771393f, -0.00502122f, 
    0.11866287f, -0.05993343f, 0.23809376f, 0.14305796f, -0.27776024f, -0.03994561f, -0.12961848f, 0.11360066f, 
    0.00164336f, 0.02754799f, -0.03156716f, -0.03868244f, -0.01603972f, -0.13248421f, -0.01752871f, -0.02499798f, 
    0.62446243f, 0.28781828f, 0.13673085f, -0.16888112f, -0.07317430f, -0.09128037f, -0.04820220f, 0.09523183f, 
    0.17241760f, 0.15470268f, -0.08779912f, 0.00025861f, 0.10545869f, -0.02313449f, 0.08741885f, -0.09094332f, 
    0.00642257f, -0.06483243f, 0.08790966f, -0.10936849f, 0.13870327f, 0.04834653f, 0.10039359f, 0.21020231f, 
    0.02332451f, 0.06820818f, 0.06065550f, 0.11009873f, 0.03757362f, -0.07346782f, 0.05444803f, -0.01033679f, 
    0.12697187f, 0.27866507f, 0.18617056f, 0.26627263f, 0.12924969f, -0.09374291f, 0.06795478f, -0.01000297f, 
    0.00871263f, 0.08431512f, 0.00563031f, -0.24890719f, 0.09827141f, -0.01248562f, -0.03738401f, 0.03833961f, 
    0.00292528f, -0.09278246f, 0.11592529f, -0.12696210f, 0.10337391f, -0.18433610f, 0.11431699f, -0.05792298f, 
    -0.06481481f, -0.00980267f, -0.16014820f, 0.12948561f, 0.17240472f, 0.12215925f, -0.01791919f, -0.13845171f, 
    0.03287950f, -0.06344984f, 0.06035812f, 0.00713850f, -0.07747753f, -0.14414330f, -0.02875335f, -0.04118207f, 
    0.09225212f, 0.01097983f, 0.09834637f, 0.05971634f, 0.07811601f, -0.03927089f, 0.07776438f, -0.04410835f, 
    0.03880573f, 0.18694477f, -0.07790684f, 0.23991932f, 0.23141463f, 0.00847308f, 0.14400959f, 0.26527804f, 
    -0.04278472f, 0.03972327f, 0.07688233f, 0.06357060f, 0.22934762f, 0.18242791f, 0.12649836f, 0.19739953f, 
    0.45033705f, 0.02230490f, 0.07024626f, -0.04347496f, -0.12869656f, -0.04609092f, 0.05983297f, 0.21411361f, 
    0.04075134f, -0.02570887f, -0.04392782f, -0.11681171f, 0.17378816f, 0.16883744f, -0.15257332f, -0.11005127f, 
    -0.08139712f, 0.00764140f, 0.06673241f, -0.02977189f, 0.03522714f, -0.02551678f, -0.04302124f, 0.16765970f, 
    0.13140042f, -0.06161716f, 0.19528575f, -0.07649691f, 0.10385650f, -0.13456237f, 0.04725064f, 0.12583785f, 
    -0.13334116f, -0.14062008f, -0.16374819f, -0.01729216f, -0.41240272f, -0.10198866f, -0.28040549f, 0.06225607f, 
    0.10440171f, -0.01822873f, 0.11202429f, 0.04585221f, -0.15723424f, -0.07061759f, -0.14201820f, -0.25954479f, 
    0.18725033f, -0.24691428f, 0.00026547f, -0.04132555f, -0.06183636f, 0.05762042f, 0.05877291f, -0.01990091f, 
    0.26007986f, 0.26324004f, 0.14719346f, 0.12458496f, 0.53103679f, -0.26382729f, -0.11441435f, 0.01444638f, 
    -0.03196010f, 0.08928772f, 0.01297085f, 0.09280679f, 0.01386828f, -0.02232540f, -0.06388953f, 0.05019455f, 
    0.34606299f, -0.36064133f, 0.13123918f, 0.06196190f, -0.15699792f, 0.11843316f, -0.12988682f, -0.02914195f, 
    0.11923885f, 0.19259268f, 0.04202237f, -0.04014771f, -0.01970914f, -0.02694781f, -0.29488954f, 0.08481100f, 
    0.03369632f, 0.00004504f, 0.12815289f, 0.14142779f, 0.03430587f, 0.03244296f, 0.00332898f, 0.09958845f, 
    0.01805492f, -0.39689186f, -0.00379957f, -0.11812387f, 0.17429844f, 0.08484700f, 0.08480268f, 0.04347381f, 
    0.02795024f, 0.07944163f, 0.04438516f, -0.03679859f, 0.12917069f, 0.10978483f, 0.00416155f, -0.22181401f, 
    0.14416853f, -0.02269563f, 0.13557982f, -0.09953944f, -0.07138404f, -0.01282082f, 0.01156018f, 0.07246927f, 
    0.31762454f, 0.13873465f, -0.11680382f, 0.16519676f, -0.14789265f, 0.00823199f, 0.06127366f, -0.07068472f, 
    0.11318581f, -0.02817546f, -0.15477900f, -0.01436116f, 0.21016698f, 0.14347807f, 0.12761196f, 0.28238869f, 
    -0.01357811f, 0.00372291f, 0.06533252f, 0.03143993f, 0.04901193f, 0.11884265f, 0.22035548f, 0.11646058f, 
    0.10698473f, -0.01784034f, 0.14536129f, -0.04943345f, 0.13018489f, 0.01807728f, 0.04617575f, -0.05141763f, 
    -0.08444601f, -0.04212565f, 0.19742574f, 0.08821674f, 0.04884547f, 0.03329590f, 0.03496109f, 0.15931718f, 
    -0.02326368f, -0.10566083f, 0.15693064f, 0.11974545f, 0.10272074f, 0.01612448f, -0.08389881f, -0.07552381f, 
    0.00821719f, -0.05640810f, -0.18143047f, -0.13664542f, -0.03650264f, 0.13913922f, -0.00124082f, 0.11367962f, 
    0.04020797f, 0.00560779f, -0.02734420f, -0.11196940f, 0.26801041f, 0.10253368f, 0.03348916f, -0.04790333f, 
    -0.03452598f, -0.03083267f, -0.02362881f, 0.03288703f, 0.05988107f, -0.07727764f, 0.09607816f, 0.02809034f, 
    0.19259568f, 0.03930821f, -0.05976632f, -0.02720771f, 0.02946302f, 0.05158427f, -0.06517343f, 0.04984776f, 
    0.01332048f, -0.10085878f, -0.08886193f, 0.09671407f, 0.30755129f, 0.07128315f, -0.01386115f, 0.06873512f, 
    -0.10507143f, -0.00728192f, -0.01089890f, 0.21485610f, -0.00591668f, -0.16117087f, 0.04304612f, -0.04899985f, 
    0.19425568f, 0.03487477f, -0.12091599f, -0.05607065f, -0.12908672f, 0.10989988f, -0.03865819f, -0.09398276f, 
    0.01771137f, -0.03410583f, -0.12326776f, 0.13130160f, -0.05363358f, -0.01900623f, -0.32520679f, 0.09848146f, 
    -0.04586676f, 0.01237218f, -0.01657249f, 0.06998921f, 0.15959136f, 0.15543823f, 0.13088515f, 0.12048151f, 
    0.33518401f, 0.24989124f, 0.33786744f, -0.10946651f, -0.07780764f, -0.23974442f, -0.07789642f, 0.04680712f, 
    -0.04309596f, -0.10536500f, -0.05067768f, -0.12078109f, -0.01299531f, 0.02302132f, -0.05229188f, 0.10884368f, 
    0.11185206f, 0.27218404f, 0.14039281f, 0.09933200f, 0.03274290f, 0.04823325f, 0.07217288f, 0.15124188f, 
    0.40391886f, 0.04687388f, 0.21967673f, -0.06985273f, 0.03696173f, -0.09738757f, -0.03714862f, -0.07443529f, 
    0.02675235f, 0.02748683f, 0.09551080f, -0.07655130f, 0.06313594f, 0.19585159f, 0.01156919f, -0.07597455f, 
    -0.00940916f, -0.07096796f, 0.11350014f, 0.11396875f, 0.02790983f, -0.00440737f, 0.05499317f, 0.09820035f, 
    0.03361109f, -0.02355465f, -0.02489112f, -0.00943298f, 0.00280711f, -0.02208763f, 0.00560310f, -0.03416302f, 
    0.02200564f, -0.03731843f, -0.00854059f, -0.03886271f, 0.01387865f, -0.03561235f, 0.00345216f, -0.00103082f, 
    0.00569275f, 0.00377319f, 0.01753696f, 0.00870606f, 0.01124261f, -0.00621631f, -0.01129570f, 0.01042966f, 
    0.02519988f, -0.03463572f, -0.01113468f, -0.01769986f, 0.01948176f, 0.02620352f, 0.01919564f, 0.01035505f, 
    0.01069053f, 0.02359676f, 0.02227536f, 0.01102761f, -0.03255479f, 0.01302417f, 0.00889640f, 0.00348470f, 
    -0.03621152f, -0.01784562f, -0.01479883f, 0.00331506f, 0.01612263f, -0.03369278f, 0.02152785f, -0.01723790f, 
    0.01769159f, 0.01702855f, -0.00402598f, 0.00861481f, 0.00163974f, 0.00600174f, 0.02052673f, -0.00635530f, 
    -0.00194115f, -0.03044665f, -0.03432628f, -0.00986208f, 0.01377458f, -0.00967222f, 0.00848443f, -0.00258031f, 
    -0.04455283f, -0.01528191f, -0.01704625f, 0.01671997f, -0.01716283f, -0.00174515f, -0.00916940f, -0.02674067f, 
    -0.01789697f, -0.00948658f, -0.00854541f, 0.00111239f, 0.00287462f, -0.00624970f, -0.03159215f, -0.01022082f, 
    -0.01252463f, -0.01023735f, 0.02276767f, -0.01256869f, -0.03808577f, -0.02847374f, -0.01407644f, -0.00497412f, 
    0.04002546f, -0.00800180f, -0.00876601f, -0.03275613f, -0.03144472f, 0.02515335f, -0.02279449f, 0.00848687f, 
    -0.01558121f, -0.00752573f, -0.02579749f, -0.01360988f, 0.01047997f, -0.00384626f, -0.00376324f, 0.00436785f, 
    0.00464531f, -0.00506128f, 0.02464268f, -0.01740586f, 0.01531793f, 0.00283273f, 0.01136256f, 0.01476287f, 
    0.02942463f, -0.01047345f, -0.01213659f, -0.02893054f, 0.00428625f, -0.02567277f, 0.02962207f, -0.03116978f, 
    0.00580990f, -0.03498033f, -0.02535304f, -0.03985625f, -0.03749704f, -0.03118165f, -0.00805099f, 0.00788915f, 
    0.01942838f, -0.01609051f, 0.00560156f, -0.01841455f, -0.00653677f, -0.00615491f, -0.02858915f, -0.00247557f, 
    -0.01667130f, -0.02250973f, 0.01741293f, -0.01601767f, -0.02694981f, -0.03772253f, 0.00935690f, -0.01388129f, 
    -0.02573290f, -0.01005335f, 0.01702066f, 0.01338266f, 0.01047316f, 0.01477323f, 0.01803334f, 0.01634439f, 
    -0.00502231f, 0.01742681f, -0.04364157f, 0.00727837f, 0.01787673f, -0.02127459f, -0.02074667f, 0.00789277f, 
    -0.01114582f, 0.01188976f, -0.03796493f, -0.01853560f, -0.04187358f, 0.02258447f, -0.00186926f, -0.01869311f, 
    0.01326145f, 0.00022811f, 0.02355386f, -0.00670045f, -0.03120951f, 0.01872690f, 0.00867151f, -0.04297233f, 
    -0.02696096f, 0.02014097f, -0.03307408f, -0.01830107f, -0.04566696f, -0.02415632f, 0.01190282f, 0.00662206f, 
    -0.03435846f, 0.03810921f, -0.02245660f, 0.02525677f, -0.03887830f, 0.00626440f, -0.03648008f, 0.01319264f, 
    -0.01117975f, 0.02194602f, 0.02887196f, -0.01243501f, 0.00820730f, 0.00660167f, -0.02315684f, -0.02184670f, 
    0.01936620f, -0.00787345f, -0.00768656f, 0.01359562f, 0.02910938f, -0.02696651f, 0.02649874f, -0.03601961f, 
    0.03210782f, 0.02354671f, 0.01976086f, 0.01116033f, -0.02678797f, 0.02354844f, -0.02501908f, 0.00599118f, 
    -0.04151867f, 0.03256136f, -0.04485998f, -0.01686699f, 0.00276999f, 0.01448384f, -0.00988230f, -0.01085847f, 
    -0.00378645f, -0.02893868f, -0.02622561f, 0.00518361f, -0.03810920f, -0.00206794f, -0.01649259f, -0.02803344f, 
    -0.00335937f, -0.00692312f, 0.01498626f, -0.03202699f, 0.01898740f, -0.01890081f, -0.03325189f, -0.00922084f, 
    -0.04637389f, -0.03465164f, -0.00644026f, -0.01860203f, -0.01722362f, 0.01155282f, 0.01822351f, -0.01099421f, 
    -0.01680396f, -0.01655783f, -0.03516669f, -0.00970079f, -0.02429559f, 0.00457294f, 0.01508626f, -0.01793654f, 
    0.00594317f, -0.01022809f, -0.02968932f, -0.02237986f, -0.02058958f, 0.01467298f, -0.02130196f, 0.02278449f, 
    0.01873896f, -0.04192871f, 0.01794359f, 0.01221031f, -0.00491303f, 0.02770367f, 0.02245617f, 0.01938538f, 
    -0.04203585f, -0.01611541f, -0.00667920f, 0.02658432f, 0.01318668f, -0.01067111f, -0.02097972f, -0.04235747f, 
    -0.01688354f, 0.01617240f, 0.02735201f, -0.00943829f, -0.01494738f, 0.03140572f, 0.01567687f, 0.01386182f, 
    -0.01057206f, -0.03116096f, -0.02765242f, 0.00056543f, 0.02291990f, -0.00127694f, 0.02705440f, -0.00846072f, 
    -0.01433123f, 0.03106512f, -0.02918245f, -0.02187561f, 0.03155153f, -0.01140908f, 0.02252080f, -0.03344573f, 
    -0.00776566f, -0.01101766f, 0.02943406f, -0.00779928f, -0.01411602f, -0.01096652f, -0.04634563f, -0.00253779f, 
    0.01401821f, 0.01611571f, -0.00671826f, -0.01697108f, 0.00429837f, 0.01419509f, 0.02776797f, 0.02793219f, 
    -0.03254718f, -0.02768517f, 0.01925530f, -0.01172809f, -0.01564922f, 0.01820173f, -0.01651842f, 0.02100728f, 
    0.00320540f, 0.01699025f, -0.02916007f, 0.01389888f, -0.00132541f, -0.03312887f, 0.01101496f, -0.00565821f, 
    -0.00782556f, 0.01683747f, 0.02609389f, -0.03276623f, -0.02029523f, -0.01150863f, -0.03743979f, 0.01980954f, 
    -0.02630288f, 0.00924671f, 0.00501223f, -0.00702441f, -0.01504944f, 0.00968125f, -0.01625741f, -0.04443450f, 
    -0.03490984f, -0.01931112f, 0.01085912f, 0.01634934f, 0.02879998f, 0.02525393f, 0.01436357f, -0.03883331f, 
    -0.00950610f, 0.01863722f, -0.01231783f, 0.02652721f, -0.04366174f, 0.01259387f, -0.04798834f, -0.00039372f, 
    0.00652972f, 0.03436187f, -0.02803829f, -0.02892402f, -0.03620955f, -0.04078672f, 0.00557174f, 0.00831013f, 
    -0.01560814f, 0.01659735f, 0.00513326f, -0.03641541f, 0.02633091f, 0.01798015f, 0.00673151f, 0.02353604f, 
    -0.00975622f, 0.02101041f, 0.02461441f, -0.01728729f, 0.03261536f, -0.02637801f, -0.04498257f, 0.00248068f, 
    -0.01039716f, -0.01702643f, 0.00232348f, -0.03667045f, 0.02215177f, 0.01260377f, -0.01260552f, 0.01770168f, 
    0.00452144f, 0.00128586f, -0.02345147f, -0.04677640f, 0.02803773f, 0.02206748f, 0.02477252f, -0.00167956f, 
    -0.04231960f, -0.01736828f, -0.01787699f, -0.00038881f, 0.01946606f, 0.00528133f, -0.01268857f, 0.00797169f, 
    -0.00706077f, -0.01065597f, -0.01175522f, 0.03398825f, 0.02637158f, 0.01567161f, -0.02309165f, 0.00148744f, 
    -0.00467708f, 0.00444584f, 0.02524274f, -0.02777042f, 0.01738975f, 0.00999933f, -0.03854195f, 0.00081422f, 
    -0.00178996f, -0.01062453f, -0.02188414f, -0.00794610f, 0.02643376f, -0.02602349f, 0.01646720f, -0.02266265f, 
    0.00456484f, 0.02100453f, 0.01596604f, -0.00465786f, 0.01883259f, -0.03067523f, -0.03052718f, 0.03534381f, 
    0.01287312f, -0.02613079f, 0.02234043f, 0.01755647f, -0.04356049f, -0.00852363f, -0.02983037f, 0.03198570f, 
    0.01907757f, 0.04262096f, 0.02106309f, -0.00676947f, 0.01803606f, -0.00883970f, 0.02716399f, -0.03333909f, 
    -0.01998737f, -0.01668765f, -0.03205748f, -0.04618066f, -0.01332476f, 0.02261288f, 0.03719433f, -0.01435383f, 
    -0.03246233f, -0.02602688f, -0.01791089f, -0.00679722f, -0.01763245f, -0.02160654f, -0.01267531f, -0.00030647f, 
    -0.04018306f, 0.01344259f, 0.00279716f, -0.01500390f, 0.00047307f, -0.00768856f, 0.00462139f, -0.02192736f, 
    0.01453264f, 0.00948862f, -0.01445254f, -0.04432486f, 0.00243024f, -0.03868557f, 0.00100496f, -0.01212260f, 
    0.02272517f, -0.00216804f, -0.02292093f, 0.01900918f, -0.00541472f, 0.02327266f, -0.03262614f, 0.01462448f, 
    -0.03139286f, 0.03250062f, 0.02422893f, -0.01792118f, -0.00416987f, 0.01282515f, 0.00675053f, 0.00543788f, 
    0.02277205f, 0.01649875f, -0.03634848f, 0.01029305f, -0.03546825f, -0.00966840f, 0.03559331f, 0.03561038f, 
    -0.00543912f, -0.03772057f, 0.02325609f, 0.01854439f, -0.00105744f, 0.00057678f, -0.00312176f, -0.01331836f, 
    0.02988104f, -0.02223145f, 0.02576892f, 0.02506217f, 0.00948352f, -0.00795848f, -0.04222910f, -0.00220082f, 
    0.01678843f, -0.00364935f, 0.03157922f, -0.02548413f, -0.02956266f, -0.03534649f, -0.00740420f, 0.03232980f, 
    0.00796790f, -0.02121725f, -0.02713657f, 0.01150749f, -0.03735562f, 0.01140728f, -0.00312645f, -0.01182907f, 
    -0.03781920f, -0.02061028f, -0.02282790f, -0.03813562f, 0.02450536f, 0.00749190f, -0.00385165f, -0.03274688f, 
    -0.02495969f, 0.02571843f, 0.00002467f, -0.02072136f, -0.00807913f, -0.00674053f, -0.01450517f, 0.02983799f, 
    0.01774120f, 0.01189532f, -0.01322218f, -0.03724147f, 0.02155131f, -0.01881204f, -0.03217596f, -0.01839153f, 
    -0.03936043f, -0.01972635f, 0.01503157f, 0.02656482f, -0.04155247f, -0.03234069f, -0.02904486f, 0.00492419f, 
    0.02512339f, 0.01685588f, 0.00488153f, -0.00296197f, 0.00029410f, 0.01280600f, -0.03653758f, -0.01757367f, 
    0.00189128f, 0.00225632f, -0.02839874f, 0.02888962f, -0.00538484f, 0.02482285f, 0.00833675f, -0.00448957f, 
    -0.02542948f, -0.00108359f, 0.00132750f, 0.02004953f, -0.04233014f, -0.02213587f, 0.00773355f, -0.04470788f, 
    -0.01384690f, 0.00453870f, 0.02193488f, 0.00793628f, -0.03098693f, -0.00684862f, 0.01675478f, 0.00870398f, 
    0.00640797f, 0.02227270f, -0.04977054f, -0.02134142f, -0.03049480f, 0.01952743f, -0.01602229f, -0.02311403f, 
    0.01943536f, 0.02283276f, 0.01895519f, -0.03602598f, -0.02494653f, -0.00048240f, -0.01959524f, 0.00032563f, 
    -0.03471651f, 0.00688627f, -0.01926663f, -0.02642044f, 0.02739782f, 0.03190092f, 0.03762532f, 0.00048965f, 
    -0.03564487f, 0.01207577f, 0.01030282f, -0.02991647f, -0.02589087f, -0.02495639f, -0.03770945f, -0.02825081f, 
    0.01199546f, -0.01804974f, -0.00890519f, 0.00543947f, -0.01109329f, 0.02613747f, -0.02227645f, -0.02720204f, 
    -0.03106152f, -0.00055533f, 0.03174543f, 0.01198388f, 0.01707061f, -0.02753186f, -0.03977466f, -0.03209307f, 
    -0.02579223f, -0.02717346f, -0.01322286f, 0.02694411f, 0.01888790f, -0.03878099f, -0.00315636f, -0.01989358f, 
    0.00055255f, 0.00135946f, 0.03071420f, -0.03990702f, 0.00174570f, -0.01703825f, 0.03692894f, 0.00741543f, 
    0.02709557f, 0.00922556f, -0.01184294f, 0.02621439f, -0.03332008f, 0.01374112f, -0.02123791f, 0.02252986f, 
    0.00940565f, 0.02258185f, 0.00735154f, -0.04062576f, -0.02128306f, -0.03885032f, 0.00913246f, 0.02347329f, 
    -0.00918943f, -0.04230507f, 0.01134351f, 0.00349128f, -0.02982400f, 0.02698109f, 0.00136953f, -0.03056104f, 
    -0.00812455f, -0.02374794f, 0.01065865f, -0.00286523f, -0.04188572f, -0.00886702f, -0.00424057f, 0.01928422f, 
    0.02359978f, -0.00217452f, -0.00091621f, -0.04776235f, -0.02851909f, 0.01399275f, 0.00039465f, -0.02158093f, 
    0.01916412f, 0.03174395f, 0.02285743f, -0.03580790f, -0.03268122f, -0.01681149f, -0.00950501f, 0.00647518f, 
    -0.01941011f, -0.01468764f, -0.02498445f, -0.02740281f, -0.01286629f, 0.00925309f, 0.01877104f, -0.01589490f, 
    -0.01314065f, 0.00306217f, 0.03263522f, -0.04232225f, -0.02821439f, 0.02780332f, -0.02508672f, 0.00654209f, 
    -0.01485819f, 0.02582055f, 0.02100016f, 0.01078642f, 0.00324516f, -0.00638061f, -0.01985916f, -0.01035881f, 
    -0.01426299f, 0.01472861f, 0.01301920f, -0.00518939f, 0.00692705f, -0.02999103f, 0.01429994f, -0.00593192f, 
    -0.00172332f, 0.02865864f, 0.00227992f, 0.00471014f, 0.02311206f, 0.02367534f, -0.02332515f, -0.00422092f, 
    -0.07733143f, 0.01390035f, 0.03147414f, -0.00840681f, -0.06381467f, 0.08056890f, 0.05296972f, 0.03078188f, 
    -0.00557891f, 0.10304120f, 0.14340228f, 0.05878100f, -0.05564201f, -0.26888120f, -0.06353790f, 0.10209560f, 
    0.08792023f, 0.13091379f, 0.04348435f, 0.00817080f, 0.04626277f, -0.01252658f, 0.01642580f, 0.00820908f, 
    -0.17627639f, 0.32465366f, -0.37282282f, 0.06557583f, 0.07029060f, 0.04535500f, 0.02931010f, -0.01605095f, 
    0.12213907f, 0.10396833f, 0.04554541f, 0.16328359f, 0.13919136f, -0.10242774f, 0.04339848f, 0.11620404f, 
    0.05635991f, 0.01906403f, -0.00847048f, 0.01112564f, 0.00516137f, 0.03346308f, 0.05174311f, -0.04525740f, 
    0.17786001f, 0.27244464f, 0.06385195f, 0.03171396f, -0.13623756f, -0.03394850f, -0.01622526f, -0.03138109f, 
    -0.01225993f, 0.05670062f, 0.00387052f, 0.02635006f, -0.08557640f, 0.35929826f, -0.13131170f, 0.07984861f, 
    -0.08428274f, 0.05220895f, -0.02632061f, -0.07765663f, 0.03351508f, 0.05520520f, 0.02622963f, -0.02876639f, 
    -0.13745026f, 0.15496542f, -0.19168268f, -0.17177409f, 0.09199948f, -0.00784200f, 0.03607294f, -0.01143875f, 
    0.09392995f, -0.03622892f, 0.00956511f, -0.03669191f, 0.32391325f, 0.09358910f, 0.06545828f, -0.15010250f, 
    -0.05179548f, -0.11102826f, -0.08974865f, -0.08626609f, 0.01964937f, 0.19750810f, -0.05211620f, 0.01691071f, 
    0.04718369f, 0.18204360f, -0.13460600f, -0.04873681f, 0.03184863f, -0.09840477f, -0.12729938f, -0.05544942f, 
    -0.05338663f, 0.00605400f, 0.02508051f, 0.04352970f, -0.22999409f, -0.12083831f, -0.00127047f, 0.20320858f, 
    -0.10537037f, -0.03677395f, 0.00726671f, 0.02701925f, -0.03945572f, 0.03488138f, 0.02797269f, 0.09561992f, 
    0.03764004f, -0.01001445f, 0.19570115f, 0.09427459f, 0.05222424f, -0.04575845f, 0.12821509f, 0.09027059f, 
    -0.01257008f, 0.17758361f, 0.17527331f, -0.01384676f, 0.07750107f, -0.08056110f, 0.14645350f, -0.04428023f, 
    0.09523921f, 0.00050704f, -0.17387021f, 0.03942696f, 0.00538051f, -0.03231028f, 0.04249752f, -0.03823807f, 
    -0.20808622f, 0.01518063f, -0.07459120f, -0.19665442f, 0.03754650f, 0.15167911f, 0.12464681f, -0.06641778f, 
    0.08028101f, 0.14955859f, 0.02899359f, 0.07800649f, 0.18146153f, -0.07244980f, 0.07811755f, -0.11539419f, 
    -0.08265736f, -0.01072074f, 0.03658542f, 0.12558264f, 0.04802170f, 0.11389185f, 0.03739674f, 0.07781899f, 
    0.13322116f, -0.05201050f, -0.05613934f, 0.05227296f, -0.04959430f, 0.01126976f, -0.07879927f, -0.05700298f, 
    -0.02609831f, -0.03597691f, -0.03580889f, 0.00360404f, 0.39626044f, 0.07137311f, 0.24530397f, -0.26952979f, 
    -0.02280808f, -0.02200466f, 0.11109555f, 0.07991721f, 0.06378655f, 0.05868156f, 0.01899139f, -0.17175695f, 
    -0.08322495f, -0.09140337f, 0.08441982f, 0.06702700f, 0.03522721f, 0.00700530f, -0.05241876f, 0.01584492f, 
    -0.08923230f, 0.03204529f, 0.12323457f, 0.07493728f, 0.10420180f, 0.27304742f, 0.15621930f, -0.05342125f, 
    -0.02892591f, -0.07243640f, -0.09533728f, -0.14509809f, 0.05780562f, -0.05082227f, -0.00675022f, -0.06781034f, 
    -0.10948794f, -0.25886989f, 0.12893532f, -0.10979303f, 0.06680204f, -0.01660084f, -0.14177258f, 0.07108391f, 
    -0.00842355f, -0.05862746f, 0.08040954f, 0.12552989f, -0.11644282f, 0.01455891f, -0.25379550f, 0.12350865f, 
    -0.02107934f, 0.09614778f, 0.07393876f, 0.11663718f, -0.02110182f, 0.08062112f, -0.05089568f, -0.01290666f, 
    -0.03628421f, 0.25466907f, 0.03920419f, 0.17996193f, 0.06632787f, -0.01706836f, 0.11316469f, -0.02025616f, 
    0.10606380f, 0.11190244f, 0.08932879f, -0.03153476f, -0.28943804f, -0.11160878f, -0.08203825f, 0.21325044f, 
    -0.08558746f, 0.01402098f, 0.05007849f, 0.02809316f, 0.01937885f, 0.01981885f, 0.07221813f, 0.12723809f, 
    -0.23031656f, 0.47875807f, -0.15288934f, 0.04308742f, 0.01002031f, -0.02934950f, 0.01542015f, 0.04948179f, 
    0.17826562f, 0.00265530f, 0.20638056f, 0.16506350f, 0.06657178f, -0.30583489f, 0.45265886f, 0.00734641f, 
    -0.00509501f, -0.04739815f, 0.00691435f, 0.05991840f, 0.03141746f, 0.19407520f, -0.03121145f, -0.04783377f, 
    0.07386725f, 0.05448480f, 0.01544922f, -0.02920415f, -0.02993063f, -0.03358654f, -0.09530349f, -0.03890467f, 
    -0.08921203f, 0.04097641f, 0.04336883f, 0.03241070f, 0.02391999f, -0.18548125f, 0.06411877f, -0.09724810f, 
    0.04985944f, 0.13514543f, 0.07732797f, 0.00318833f, -0.04169236f, 0.09029217f, -0.01392061f, 0.03657402f, 
    -0.03134811f, 0.13297258f, 0.00996617f, 0.11756767f, -0.15485464f, -0.12770848f, -0.05100150f, -0.07941305f, 
    -0.00566717f, -0.01491631f, -0.09335996f, -0.10840075f, -0.06735422f, 0.09530919f, -0.26708335f, 0.09834412f, 
    -0.06803959f, 0.05340356f, 0.01998194f, 0.04746945f, -0.00336668f, -0.07459836f, 0.06522916f, -0.01034202f, 
    0.05743032f, -0.08694319f, -0.17641474f, 0.08577078f, 0.05218322f, -0.01478820f, 0.08850773f, -0.09492137f, 
    -0.02752713f, -0.02504598f, 0.00874513f, -0.02201164f, 0.09449931f, -0.26669696f, 0.26220670f, 0.01386223f, 
    -0.11278866f, 0.01871122f, -0.02766054f, -0.06187114f, -0.03848336f, 0.00278360f, 0.02641965f, 0.01880313f, 
    0.03553262f, 0.02227673f, 0.04849910f, -0.18514457f, 0.00160989f, 0.06629565f, -0.01360257f, 0.01702727f, 
    0.06895954f, 0.07850870f, 0.00974932f, -0.04686678f, 0.24397998f, -0.02423680f, 0.07814420f, 0.14578779f, 
    -0.04394390f, 0.01483860f, -0.05148946f, 0.00554239f, -0.05489405f, -0.08614767f, -0.05813510f, -0.13635668f, 
    -0.04115106f, 0.10593811f, -0.26082486f, -0.38883173f, 0.09005091f, 0.12693034f, 0.09081019f, -0.01532476f, 
    0.01310617f, 0.03644786f, 0.06698345f, 0.06197459f, -0.05864671f, 0.07874243f, -0.02494014f, 0.01513457f, 
    -0.11223365f, -0.07111691f, -0.09281737f, -0.01848420f, -0.01323885f, 0.09899446f, -0.01566453f, -0.11118793f, 
    -0.11336906f, -0.06109496f, 0.09743751f, 0.05579254f, 0.01001392f, 0.02311105f, 0.03440302f, 0.02675603f, 
    -0.04015645f, 0.05998219f, -0.07253422f, -0.09451889f, -0.05468139f, 0.09608262f, -0.00363599f, 0.01428081f, 
    -0.06371048f, -0.01993500f, 0.02586932f, -0.00716490f, 0.05881158f, -0.00257587f, 0.00161610f, 0.03994329f, 
    -0.05988976f, 0.25681621f, 0.29822156f, 0.34078467f, -0.04525187f, 0.08396102f, -0.07565767f, 0.08819948f, 
    -0.08747106f, 0.04440834f, -0.07332582f, 0.02714754f, 0.09885237f, 0.00306262f, -0.17895393f, -0.02462637f, 
    -0.03767355f, 0.00015019f, -0.01199304f, -0.03752209f, 0.01045559f, -0.05023377f, -0.06955440f, -0.08743615f, 
    0.10307756f, -0.05252929f, 0.03341056f, 0.31865257f, -0.08604772f, -0.00396691f, 0.14018647f, -0.02953980f, 
    -0.04612314f, -0.07571386f, 0.11680163f, 0.13584131f, 0.04965469f, 0.03495762f, -0.11891618f, -0.12639786f, 
    0.12567568f, 0.03274963f, 0.02202563f, -0.03435451f, -0.07430287f, 0.03769296f, 0.05518920f, -0.11264135f, 
    -0.13718574f, 0.13679439f, -0.08874902f, 0.01769647f, 0.26886410f, -0.05046554f, 0.09341410f, 0.04917309f, 
    0.02725266f, -0.01686359f, -0.01242048f, -0.03811445f, 0.13088782f, -0.07453003f, 0.01986989f, 0.24846086f, 
    0.08577982f, 0.13252084f, 0.16281055f, 0.02871393f, -0.03422739f, -0.01871617f, -0.07273294f, -0.07220767f, 
    -0.16561641f, -0.01691459f, 0.15673223f, 0.02788171f, 0.01573567f, 0.06472711f, 0.01495754f, 0.14169595f, 
    -0.22111602f, -0.01668073f, 0.06625631f, 0.00180070f, 0.33951724f, -0.11551492f, 0.22440606f, 0.02870332f, 
    -0.16879694f, 0.01495457f, 0.01409877f, -0.05435593f, 0.00393126f, 0.12411293f, 0.03573902f, 0.00001346f, 
    0.17497428f, -0.08892512f, 0.29558286f, -0.10160271f, 0.04832158f, 0.08449173f, 0.07015608f, 0.06011887f, 
    -0.07318290f, 0.00339314f, 0.04536120f, -0.13917577f, -0.21879904f, 0.58642006f, -0.04093435f, 0.20896533f, 
    0.05882906f, 0.01442413f, 0.07185665f, 0.04006240f, -0.03019435f, 0.00047306f, 0.11009952f, -0.02317902f, 
    -0.26265135f, 0.01333022f, -0.19292700f, 0.14399718f, 0.05988174f, -0.00459822f, 0.11697142f, 0.06125450f, 
    0.00392652f, -0.01461732f, 0.07790889f, 0.05462198f, 0.18696415f, -0.01748465f, 0.00012635f, -0.01316975f, 
    0.06490349f, 0.05952423f, 0.03949951f, 0.12225673f, -0.03826959f, 0.06759248f, -0.00206982f, 0.16645801f, 
    -0.18534705f, 0.16471584f, -0.27997789f, 0.33239377f, -0.11321833f, 0.09056307f, 0.10317682f, -0.05112300f, 
    0.12730707f, 0.00517227f, 0.18317312f, 0.07846964f, -0.09643582f, -0.20741855f, -0.22294782f, 0.08605209f, 
    -0.24705170f, 0.03487662f, -0.07764771f, -0.10461167f, -0.02906011f, -0.01565444f, -0.04784429f, 0.00740369f, 
    0.20690843f, -0.31156409f, 0.40277824f, -0.06001341f, 0.06701501f, 0.08424129f, 0.02966549f, 0.14054684f, 
    -0.04292865f, 0.12930590f, 0.05115630f, 0.06956491f, 0.13844870f, -0.07043640f, -0.14119811f, -0.14185676f, 
    0.12770253f, 0.04606372f, -0.07749598f, 0.04602632f, 0.00552863f, 0.10007884f, 0.03748561f, -0.00431737f, 
    -0.15251258f, -0.06586721f, 0.05265142f, 0.12542224f, -0.02944671f, 0.06141948f, 0.04773271f, -0.06057172f, 
    0.11295783f, 0.07738702f, 0.05355664f, -0.03926599f, 0.20499411f, -0.26984927f, 0.07707231f, -0.16588813f, 
    0.02684942f, 0.27684772f, 0.26460791f, 0.13180374f, 0.06958909f, 0.10201867f, 0.09546668f, 0.08604248f, 
    -0.16022497f, -0.25453708f, 0.02038625f, 0.00749003f, -0.04794163f, -0.10118468f, -0.03366841f, -0.16623496f, 
    -0.08266436f, -0.07065375f, -0.11931312f, -0.07005794f, -0.16871361f, -0.14536268f, 0.10200096f, 0.11388452f, 
    0.04236851f, -0.02717178f, 0.00425795f, 0.08409695f, -0.02822584f, 0.23859088f, 0.07482146f, 0.13006869f, 
    -0.15996721f, 0.10255830f, -0.16212581f, 0.08112353f, 0.01859083f, 0.01845642f, 0.14808497f, 0.05009311f, 
    -0.06934087f, 0.08142353f, -0.05604047f, -0.02700421f, -0.15098125f, -0.07630441f, -0.10170370f, -0.06083770f, 
    0.12886338f, 0.00018903f, 0.03347239f, 0.08803023f, 0.00105685f, -0.00000909f, 0.05897507f, -0.02468617f, 
    0.25683150f, 0.17104290f, 0.18571030f, -0.23154345f, -0.03561036f, -0.04544360f, -0.07873851f, -0.02509425f, 
    -0.04917150f, 0.04381036f, 0.02196642f, 0.14253365f, 0.05407688f, -0.18471973f, -0.05840927f, -0.28237572f, 
    0.15101482f, -0.00783131f, -0.04529092f, 0.21543235f, -0.03793587f, 0.13671289f, 0.10629521f, 0.01330545f, 
    -0.27298984f, -0.17362478f, -0.19088073f, 0.16808200f, 0.00472652f, 0.06444211f, 0.10931315f, 0.12895420f, 
    0.13623512f, -0.00749139f, -0.03330769f, -0.07340470f, 0.06646279f, -0.09788286f, 0.01645828f, -0.00610574f, 
    0.02932709f, 0.01644449f, -0.05426522f, 0.10431404f, -0.03501219f, 0.01174844f, -0.02525562f, -0.11197586f, 
    -0.12452128f, -0.08594599f, -0.12921758f, -0.19547905f, -0.04868269f, -0.00398220f, 0.02896994f, 0.09240951f, 
    -0.00202264f, 0.11284846f, 0.09501576f, 0.14265956f, 0.04972732f, -0.19801255f, 0.09846210f, -0.12876113f, 
    -0.10264970f, 0.02382050f, -0.07118926f, 0.03859900f, -0.00040700f, 0.12534070f, 0.18979901f, 0.09395855f, 
    -0.07384793f, 0.07368214f, 0.06340095f, 0.07772435f, -0.07432968f, 0.05061760f, 0.07218069f, 0.01535911f, 
    0.01352960f, -0.02174177f, -0.09050163f, 0.05264327f, 0.24183558f, 0.22078677f, 0.18868358f, 0.16559535f, 
    -0.12115247f, -0.09867824f, -0.02087585f, -0.00173605f, 0.14551392f, 0.12873393f, 0.09680504f, 0.05354573f, 
    -0.40803468f, 0.25696900f, -0.08202615f, 0.05041318f, -0.10959844f, 0.09477699f, -0.11088696f, -0.45168498f, 
    -0.19165909f, 0.14834665f, -0.22072667f, -0.05121930f, 0.02319640f, 0.11993109f, 0.20526892f, 0.26480156f, 
    0.00280476f, -0.07092843f, 0.03018788f, -0.02783482f, -0.05147006f, 0.03951052f, 0.01749110f, 0.02228976f, 
    -0.12706682f, -0.11166948f, -0.11153588f, 0.07671889f, -0.17686763f, 0.05682200f, -0.05536021f, -0.05700782f, 
    -0.01388845f, 0.05886402f, -0.01333645f, 0.03714162f, 0.07795105f, -0.01574356f, -0.08355816f, 0.08959266f, 
    0.06201794f, 0.03534826f, 0.01272301f, -0.01504954f, 0.27454549f, 0.15980308f, 0.13375391f, 0.21532094f, 
    -0.10048594f, 0.23894808f, 0.03351993f, 0.25260898f, 0.03781081f, -0.13763840f, -0.04476098f, 0.07768654f, 
    -0.15337200f, -0.11390343f, 0.00242463f, -0.00465986f, -0.08909475f, 0.04630635f, -0.09883674f, -0.05730385f, 
    0.07539442f, -0.04067305f, -0.09626542f, -0.03333508f, -0.12240892f, 0.02385631f, -0.06905846f, -0.21195821f, 
    -0.17718214f, 0.05464363f, -0.06749367f, 0.01423442f, 0.21865034f, 0.19574766f, 0.05080549f, -0.07186459f, 
    -0.30980131f, -0.24058484f, -0.42407051f, -0.21089561f, -0.03367564f, 0.03760298f, 0.00992073f, 0.03980589f, 
    -0.09911948f, -0.04029062f, -0.03679300f, 0.12831025f, 0.06796508f, 0.03034071f, 0.08117839f, -0.00401084f, 
    0.11190381f, -0.07443955f, 0.01512600f, -0.17573535f, -0.08819626f, 0.04262498f, -0.07396631f, 0.00987643f, 
    -0.04961295f, -0.09091502f, -0.18501370f, -0.11971357f, -0.03423112f, -0.23338738f, -0.12127798f, -0.03138907f, 
    -0.08636848f, -0.02532665f, -0.05018729f, 0.03787719f, -0.11387468f, -0.05437600f, -0.24622707f, -0.23036052f, 
    -0.02829504f, 0.22949719f, 0.09030683f, 0.21285480f, 0.27473915f, 0.07189360f, -0.00790576f, -0.20267995f, 
    -0.14618251f, -0.25543430f, -0.24654156f, -0.34399149f, 0.11345004f, 0.06029042f, -0.02273348f, 0.00880856f, 
    -0.06307696f, 0.07173241f, 0.03502882f, -0.03184335f, -0.13567433f, -0.16127507f, -0.13822345f, -0.13538441f, 
    0.07775554f, 0.09796758f, -0.01954081f, 0.11688372f, -0.04198286f, -0.04384243f, -0.02050845f, 0.03648322f, 
    -0.01995745f, 0.05918595f, 0.00404241f, 0.09673758f, 0.31090212f, -0.18000400f, -0.26370713f, -0.07859246f, 
    0.02497497f, 0.09049138f, -0.13911739f, -0.08807839f, 0.16829135f, 0.18068860f, 0.09455342f, 0.25422713f, 
    0.09276117f, -0.03239340f, 0.01779631f, 0.07180171f, 0.10602256f, 0.12175976f, -0.00558148f, 0.11123702f, 
    -0.21462044f, -0.21704622f, -0.23008230f, -0.21514288f, 0.10321411f, 0.28525349f, 0.14194916f, 0.25795630f, 
    0.19877604f, -0.04426615f, 0.03476517f, 0.07353281f, 0.03166509f, -0.00519430f, -0.07911730f, -0.11240592f, 
    -0.09435234f, 0.06586305f, 0.05829223f, -0.08145099f, 0.04544941f, -0.08237155f, 0.10175195f, 0.05584710f, 
    0.06183285f, -0.12385482f, 0.06969151f, 0.09069359f, 0.14713605f, 0.02109768f, 0.13205035f, 0.04718726f, 
    0.01930339f, -0.16552036f, 0.05742989f, -0.11332247f, 0.09789900f, 0.16623762f, 0.11196034f, 0.20748198f, 
    -0.36146265f, -0.02733486f, -0.01260611f, 0.12270861f, -0.06000875f, 0.00585013f, 0.07348660f, -0.11477557f, 
    0.01127589f, -0.20391126f, 0.04713810f, 0.00253773f, -0.08030368f, 0.09081499f, 0.15195766f, 0.09311005f, 
    -0.18948264f, 0.03481850f, 0.11867166f, 0.25658742f, 0.13548842f, -0.01890977f, 0.00278297f, -0.03712097f, 
    -0.09690105f, 0.00462215f, 0.29501498f, 0.25691018f, -0.11019558f, -0.16649219f, -0.16239370f, 0.00900883f, 
    0.03610048f, 0.17258281f, 0.03051147f, 0.04503747f, 0.41350502f, -0.03028820f, 0.08400558f, -0.08413526f, 
    0.04260406f, -0.05836615f, 0.04421988f, 0.14370516f, 0.00471587f, -0.03410624f, -0.12100421f, -0.11257795f, 
    -0.08464107f, -0.04518071f, -0.08253510f, 0.08422629f, 0.01145086f, 0.12703665f, 0.01016166f, 0.06479948f, 
    -0.07601243f, -0.03328160f, -0.25027114f, -0.11086208f, 0.16921805f, 0.38401085f, 0.50205803f, 0.27762458f, 
    0.06163492f, -0.08757473f, 0.14896281f, 0.16375247f, -0.06449507f, -0.15808208f, -0.13512270f, -0.03722262f, 
    -0.03221755f, -0.07167541f, -0.15988149f, 0.12142006f, -0.11299856f, 0.02987914f, 0.02664072f, 0.04671425f, 
    0.25043699f, 0.09110551f, 0.06920527f, 0.33285826f, -0.23518291f, 0.25526327f, 0.39272332f, 0.08735349f, 
    -0.12271825f, -0.00498307f, -0.11569103f, -0.09572889f, -0.06533781f, 0.01261629f, 0.01324719f, 0.17279603f, 
    0.03269462f, 0.16001417f, 0.13558486f, 0.19991454f, -0.01103439f, -0.00184108f, -0.01766247f, -0.00440077f, 
    0.01087541f, 0.06469354f, 0.12461706f, 0.13660890f, 0.10113680f, 0.00630267f, 0.33796722f, 0.13031478f, 
    -0.04407602f, -0.07041236f, -0.17937909f, 0.09951426f, -0.11576103f, 0.06108607f, -0.00050819f, -0.14181867f, 
    -0.00433040f, -0.05785919f, -0.13503720f, -0.14528964f, 0.01976297f, 0.01612155f, -0.03915541f, -0.07835888f, 
    0.14295565f, 0.10608666f, 0.14716229f, 0.05381832f, 0.11958072f, 0.07839596f, 0.15278731f, 0.11373923f, 
    -0.10327148f, -0.02530402f, -0.19439663f, -0.08665177f, 0.03307547f, -0.02870196f, -0.02567538f, -0.04031515f, 
    -0.04849461f, -0.12141575f, 0.00466182f, 0.42932779f, 0.07101385f, 0.10219865f, -0.07362321f, -0.09110670f, 
    0.07702296f, 0.16268013f, 0.05805089f, 0.18345354f, -0.07512683f, -0.10173501f, -0.29251564f, -0.12373888f, 
    -0.10170962f, -0.02940184f, 0.03538305f, -0.02270323f, 0.12073634f, 0.26186833f, 0.20460030f, 0.18702956f, 
    -0.17010725f, 0.07194819f, 0.15937129f, 0.06403112f, -0.03665473f, -0.03004381f, -0.04558594f, -0.07880801f, 
    0.02618603f, 0.22771390f, 0.18919761f, 0.53258288f, -0.06549679f, -0.09228452f, -0.15377797f, 0.01088322f, 
    0.04323423f, 0.03974729f, 0.06025799f, -0.01404292f, 0.06409732f, 0.05234959f, -0.08697489f, 0.13467810f, 
    0.04621818f, -0.03968274f, -0.11140985f, 0.09256928f, -0.06973721f, -0.01080566f, -0.02877528f, -0.10654362f, 
    -0.17463523f, 0.06681076f, -0.17982854f, 0.08113752f, 0.02456651f, -0.01415955f, -0.11833946f, -0.02060733f, 
    -0.14016171f, 0.02557033f, -0.01908598f, -0.01574747f, -0.13124302f, -0.02605408f, -0.03460987f, -0.07988150f, 
    0.12812597f, -0.03784868f, -0.00971483f, -0.17790972f, 0.12963124f, -0.10013039f, -0.11269014f, -0.08492544f, 
    0.13679661f, 0.00347560f, -0.11926522f, 0.12818792f, 0.15848590f, 0.15990256f, 0.34337634f, 0.39102843f, 
    0.07222964f, -0.03751878f, -0.03635787f, -0.13116288f, 0.10304521f, 0.16404285f, 0.19837984f, 0.40450945f, 
    0.02211886f, 0.17373431f, -0.04982336f, 0.31069472f, 0.03287419f, 0.07321282f, -0.06348354f, -0.05495806f, 
    -0.15887593f, -0.16907302f, -0.02247410f, -0.21135962f, -0.11628035f, 0.33710033f, 0.43250418f, 0.09436178f, 
    -0.16589811f, -0.01027103f, -0.03962915f, -0.16477309f, -0.06329619f, 0.06446610f, -0.06432048f, 0.20894343f, 
    0.07716458f, 0.09644055f, 0.03493360f, -0.15664490f, 0.22256325f, 0.03341111f, 0.08615944f, -0.02998960f, 
    -0.22511558f, -0.01129510f, -0.12883414f, -0.04193791f, 0.09588688f, -0.06441929f, -0.00399812f, -0.00653138f, 
    -0.02223977f, 0.07591805f, 0.08178142f, 0.14208505f, -0.08534443f, -0.04713431f, -0.10235758f, -0.32969168f, 
    0.22834814f, 0.03628223f, 0.16965489f, -0.26897767f, 0.00213306f, -0.00918716f, -0.19197643f, -0.21424048f, 
    0.15332378f, 0.10909302f, 0.12615237f, 0.15764825f, 0.07233901f, 0.05821373f, -0.10504736f, 0.25981712f, 
    0.11574610f, -0.09815206f, -0.08978216f, -0.16259284f, -0.05387136f, -0.08116161f, 0.06613818f, -0.04342774f, 
    0.32735074f, 0.08388390f, -0.12149998f, 0.30747575f, -0.04805177f, 0.01221490f, 0.04955429f, -0.02785156f, 
    0.19156127f, -0.09894972f, 0.08573617f, 0.20050788f, -0.05551112f, -0.20499766f, 0.02440262f, 0.05929363f, 
    0.06155941f, -0.04775567f, -0.04918679f, 0.07700119f, 0.04775744f, -0.05248037f, 0.00000565f, 0.15268824f, 
    0.08953111f, 0.06621311f, 0.05795847f, 0.19825570f, -0.06315603f, 0.03488177f, -0.14836772f, 0.18054302f, 
    -0.04765811f, -0.02045968f, 0.08741427f, -0.01147628f, -0.16240533f, 0.09255739f, 0.13627507f, -0.08243350f, 
    0.06495149f, -0.00880181f, -0.00160067f, 0.25420478f, -0.07061235f, 0.04138751f, -0.06500222f, -0.04585638f, 
    0.16689719f, -0.10331653f, 0.23532093f, -0.16085619f, -0.07143711f, 0.04388847f, 0.00011085f, -0.11887193f, 
    0.01154948f, 0.14168280f, 0.02331440f, 0.00676218f, 0.22227557f, 0.31372446f, 0.12491194f, 0.19271488f, 
    0.06534541f, 0.04982344f, -0.00187225f, -0.10407338f, -0.07972061f, 0.09042342f, 0.16037795f, 0.26398519f, 
    -0.08850113f, 0.12955278f, 0.11774474f, 0.19294979f, 0.01005107f, -0.03025830f, 0.03882188f, 0.02966589f, 
    -0.06011379f, 0.20285897f, -0.07255341f, 0.10189527f, 0.10755684f, -0.33493039f, 0.28737241f, -0.13455781f, 
    -0.00606768f, 0.04174944f, -0.08414812f, 0.08426027f, 0.04539846f, 0.03505418f, 0.05643877f, 0.14212604f, 
    0.17679782f, -0.00842994f, 0.17948402f, 0.08790170f, -0.12436279f, -0.03083819f, 0.07977754f, 0.04403439f, 
    0.02551740f, 0.05633561f, -0.02078325f, -0.11187007f, 0.15922448f, 0.11316683f, 0.11572351f, 0.39282081f, 
    0.04290485f, -0.00448022f, -0.07127704f, 0.09090834f, 0.04990764f, -0.32802585f, -0.03719924f, 0.13991965f, 
    0.12423659f, 0.22152343f, 0.07452268f, 0.20577693f, 0.06568323f, 0.06054644f, -0.05417798f, -0.10920601f, 
    0.10273065f, -0.14880739f, -0.17794065f, -0.01043168f, 0.16084185f, 0.25862744f, 0.32216749f, 0.24895881f, 
    0.16825174f, 0.10913847f, 0.00262474f, 0.16337045f, 0.04854464f, -0.12282819f, -0.07211008f, -0.05484230f, 
    -0.26409376f, -0.10294806f, -0.11992993f, 0.21475279f, 0.08256864f, -0.01187165f, -0.02194885f, -0.03467927f, 
    -0.03298291f, 0.00166851f, -0.11925296f, 0.02808157f, 0.08873026f, 0.20708084f, 0.12054335f, 0.02511816f, 
    0.02467474f, 0.02529782f, -0.06122792f, -0.04470735f, 0.07372089f, -0.02011090f, 0.27818006f, 0.40949410f, 
    0.32560742f, 0.22886004f, 0.16906694f, 0.20260775f, -0.03648575f, -0.15375720f, -0.04605489f, -0.19339569f, 
    -0.05384173f, -0.04075770f, 0.04178870f, -0.02346078f, -0.03970935f, 0.13248663f, 0.15492569f, 0.08966804f, 
    -0.02726307f, -0.05711381f, 0.05457435f, -0.12534547f, -0.05261170f, 0.09989916f, 0.02956689f, 0.34872538f, 
    -0.06903959f, -0.09656201f, 0.18774460f, 0.22907172f, 0.02557819f, 0.01064717f, -0.06216992f, 0.02867174f, 
    0.04964180f, -0.04722513f, -0.07506958f, -0.04212163f, 0.07809938f, -0.04938837f, -0.12775069f, 0.21584587f, 
    0.01253046f, -0.03206639f, -0.01387452f, 0.22158198f, 0.12080865f, 0.00325685f, 0.01067653f, -0.13794871f, 
    -0.11404316f, -0.10016749f, -0.12192836f, -0.08176584f, -0.00727465f, 0.02494906f, -0.00412656f, -0.07115246f, 
    0.03574186f, -0.03940704f, 0.21929002f, -0.07464541f, -0.07950305f, -0.10021489f, -0.05432972f, 0.06645996f, 
    0.17861894f, 0.09454618f, 0.20955667f, -0.04766174f, 0.03052661f, 0.02877746f, 0.01105227f, -0.05788069f, 
    0.32746464f, -0.28742877f, 0.08767153f, -0.01078179f, 0.11846711f, -0.00379319f, -0.25812843f, -0.14826752f, 
    -0.00378134f, 0.12156053f, 0.03653714f, -0.05057471f, -0.09123667f, 0.10442903f, 0.20344429f, 0.08864014f, 
    0.03007603f, 0.04015816f, -0.05993762f, 0.03030270f, -0.00590028f, 0.02143926f, -0.00090222f, 0.08289216f, 
    -0.01445229f, 0.07254709f, 0.07848630f, -0.13944535f, -0.11710333f, -0.11317372f, -0.05057469f, -0.09221467f, 
    0.04930163f, 0.03586726f, 0.01292942f, -0.06188060f, 0.06393582f, 0.09880319f, -0.05020573f, -0.00999405f, 
    -0.01776573f, -0.04629911f, -0.00402803f, 0.00806101f, -0.05732337f, 0.20080501f, -0.06028891f, -0.11220721f, 
    0.41976446f, -0.33908007f, -0.12056120f, 0.13775867f, 0.07588973f, 0.07620991f, 0.06497124f, 0.12622285f, 
    -0.06053109f, 0.03173651f, 0.02392628f, -0.02888539f, 0.22094619f, 0.06204303f, -0.02685129f, 0.07516181f, 
    -0.14755777f, -0.09036567f, -0.03995648f, -0.05593285f, 0.04057815f, 0.00575739f, 0.03902123f, -0.03162251f, 
    0.12657897f, 0.03159536f, -0.04056161f, -0.08555338f, 0.05939608f, -0.15759112f, 0.00584519f, 0.06758603f, 
    -0.04858581f, 0.02066213f, 0.03530289f, -0.07114662f, -0.25161666f, 0.08755243f, 0.05029392f, 0.09396999f, 
    0.02971759f, 0.12973061f, 0.16973600f, -0.14922003f, -0.03534501f, -0.06354810f, -0.01960538f, -0.17120992f, 
    -0.04944147f, 0.23912834f, -0.23275383f, -0.01586292f, 0.05623642f, 0.02937810f, -0.02425539f, 0.01603583f, 
    0.01390765f, 0.11849485f, 0.02251657f, 0.08236488f, 0.18290024f, -0.12405843f, 0.16541515f, 0.05626286f, 
    0.18510358f, -0.01083251f, -0.00794327f, -0.01234182f, 0.02645908f, -0.00192946f, 0.01442906f, -0.01256956f, 
    0.19915763f, -0.09856447f, -0.13551171f, -0.00265298f, -0.05895044f, 0.02088813f, -0.16982330f, 0.06694294f, 
    0.03544292f, 0.10424159f, 0.00149121f, -0.00073966f, 0.18457142f, -0.05812334f, 0.19522868f, 0.20161477f, 
    0.18307985f, 0.05328941f, -0.06031271f, 0.13860556f, 0.08629394f, 0.06622516f, 0.06065762f, 0.04576668f, 
    -0.13304141f, -0.05387917f, 0.06465162f, 0.11984952f, -0.04054760f, -0.05143258f, 0.06503556f, 0.17370340f, 
    0.01232908f, 0.00888962f, -0.03758484f, -0.00145943f, 0.29347378f, 0.11599187f, 0.12862623f, 0.01999865f, 
    -0.03307709f, 0.01860221f, 0.03336824f, 0.03307169f, -0.02326232f, 0.14246985f, -0.08182986f, -0.00856778f, 
    -0.17551114f, 0.04719110f, 0.06117494f, 0.00651626f, 0.05804178f, 0.05595067f, 0.00514137f, -0.03684151f, 
    0.06225553f, 0.08908184f, -0.08598973f, 0.05310312f, -0.16995609f, 0.20047961f, 0.15757436f, -0.13543211f, 
    -0.24983110f, -0.28024694f, -0.10790770f, -0.00673394f, -0.04903523f, -0.05814368f, 0.06255183f, -0.01222656f, 
    -0.13376689f, -0.03091009f, 0.10508876f, 0.23412237f, 0.12388264f, 0.10437491f, 0.00077694f, 0.01742062f, 
    -0.00691777f, -0.09410406f, -0.01832599f, -0.09591873f, 0.03925965f, -0.25831217f, -0.02877661f, 0.17011160f, 
    -0.03959268f, -0.01340838f, 0.02448572f, 0.09297502f, -0.05142278f, 0.01740940f, -0.00169406f, -0.05801777f, 
    0.03070571f, -0.04923935f, 0.20299399f, 0.05029624f, 0.08968839f, 0.08284979f, -0.10430597f, 0.00638723f, 
    -0.13533990f, -0.01079188f, 0.18864629f, -0.02124840f, -0.26755872f, -0.04609895f, 0.18357606f, 0.08123974f, 
    0.07892226f, 0.15628871f, 0.04476361f, -0.05864575f, -0.02938178f, -0.09922525f, -0.04890977f, 0.04633520f, 
    0.07217988f, 0.18374583f, 0.13105878f, -0.20567101f, -0.03918051f, -0.04512413f, 0.09501367f, 0.05803537f, 
    -0.08353442f, 0.15291643f, 0.06628834f, 0.00346076f, -0.13788109f, 0.02345077f, -0.08292010f, 0.06362636f, 
    0.13327917f, -0.03350716f, -0.05742326f, 0.19458678f, 0.06092546f, 0.11537899f, 0.00412803f, 0.01477929f, 
    -0.21037832f, -0.13696605f, 0.09296250f, -0.15727963f, -0.08673018f, -0.11097506f, -0.11205027f, 0.02522390f, 
    -0.04412488f, -0.01855001f, 0.01787392f, -0.01708050f, 0.27845454f, -0.02564989f, -0.01992640f, 0.16232049f, 
    -0.06485649f, 0.02036650f, 0.09660647f, -0.01863752f, 0.04156082f, -0.06535561f, 0.18097465f, 0.03839515f, 
    -0.14932530f, -0.06078560f, 0.12974389f, -0.07751460f, -0.04553683f, -0.06250149f, -0.11107300f, -0.07759940f, 
    -0.01397992f, -0.05382502f, -0.10533544f, 0.00948065f, -0.12556534f, -0.01588762f, 0.18349402f, -0.06171842f, 
    -0.02346783f, 0.03490284f, 0.02081321f, -0.04700072f, -0.08221918f, 0.10444055f, 0.07221311f, 0.08513584f, 
    -0.11403384f, -0.05167315f, 0.07846114f, 0.09954242f, -0.06317841f, -0.04083135f, 0.12769447f, 0.08312659f, 
    -0.00113979f, -0.00289807f, 0.00631933f, 0.04587109f, -0.23879044f, -0.01253711f, 0.31093815f, 0.11686213f, 
    0.02189187f, 0.03390979f, -0.04739356f, -0.04244039f, -0.01180160f, -0.10312682f, 0.09471112f, -0.03865216f, 
    0.02329267f, -0.06388675f, -0.17224336f, 0.07589892f, -0.10007409f, 0.01449230f, -0.07739425f, 0.00754376f, 
    -0.00890281f, 0.02454024f, 0.12282676f, -0.07611217f, 0.16606112f, 0.04971994f, -0.06311359f, 0.17782342f, 
    0.15626559f, -0.12696636f, 0.11207933f, 0.07299604f, -0.02076256f, -0.06571400f, -0.01532772f, 0.06800616f, 
    -0.16468598f, 0.07899106f, -0.14735171f, -0.24693267f, 0.02408671f, 0.02509169f, -0.08561031f, 0.13632087f, 
    -0.03810784f, 0.00052073f, 0.03193181f, -0.05757974f, -0.08592939f, 0.02398627f, 0.04083502f, -0.08344722f, 
    -0.07216366f, 0.00656365f, -0.18329333f, -0.06856439f, 0.06596767f, 0.09607730f, -0.06417986f, 0.03399885f, 
    -0.16715883f, 0.13668211f, 0.09956029f, 0.01147856f, -0.01750624f, 0.08291361f, 0.02895991f, -0.03676911f, 
    0.18424404f, 0.09737241f, -0.07333179f, 0.03329375f, -0.04250707f, -0.12460831f, 0.04792433f, -0.15992795f, 
    -0.07365390f, 0.00119183f, -0.08392656f, -0.03246465f, 0.07441054f, 0.05921931f, -0.09008697f, 0.07772072f, 
    -0.11467473f, 0.08652397f, 0.26689085f, -0.14506847f, 0.00026608f, 0.02684399f, -0.21115676f, -0.09834601f, 
    0.17752106f, 0.00171368f, 0.03088364f, 0.01556042f, -0.24700098f, -0.16035171f, 0.10070759f, 0.16803686f, 
    0.03786526f, 0.03146328f, -0.00938265f, 0.10430822f, 0.00061785f, 0.00953391f, -0.02934831f, 0.00273911f, 
    0.08773885f, 0.15903856f, 0.12957862f, -0.02607816f, -0.02922277f, -0.10936506f, 0.08069521f, 0.17913774f, 
    0.06925478f, 0.02006846f, 0.15288350f, 0.04355074f, 0.03073950f, 0.04307469f, 0.18896247f, -0.03492954f, 
    -0.02594188f, -0.05328802f, 0.06261653f, -0.00415321f, -0.05682067f, -0.06082971f, 0.05101082f, -0.04360557f, 
    -0.01359694f, -0.13089533f, 0.08601163f, -0.09053320f, 0.14408793f, 0.12318628f, -0.01925148f, 0.11569704f, 
    -0.05032843f, 0.03053745f, -0.06636213f, -0.02975742f, -0.20465419f, 0.07529280f, 0.18778807f, 0.09083685f, 
    0.03600834f, 0.13142687f, 0.15408958f, -0.05178972f, -0.03060047f, 0.03272334f, -0.04652046f, 0.07215644f, 
    -0.11821263f, 0.09293111f, 0.03244994f, -0.24570851f, -0.07966936f, -0.00628080f, -0.21262187f, 0.14113697f, 
    0.15596408f, 0.00158338f, 0.09253676f, -0.01126008f, 0.07752160f, 0.00324782f, 0.15748109f, -0.03423382f, 
    0.10908867f, -0.04158589f, -0.00707973f, -0.01446470f, 0.04681955f, -0.00638852f, 0.05817788f, 0.05632442f, 
    -0.02543995f, 0.01612164f, 0.11372896f, 0.20781918f, 0.06193659f, 0.00986419f, -0.19355908f, 0.04707684f, 
    0.04459179f, -0.02106994f, -0.04266625f, -0.01878314f, -0.05895218f, 0.37046182f, 0.30346066f, -0.07930383f, 
    -0.00364337f, -0.09422430f, -0.08875673f, 0.16639476f, -0.08670459f, 0.05792836f, 0.00400738f, -0.01824925f, 
    0.07336532f, -0.35987160f, 0.36721838f, -0.07249018f, 0.05885902f, -0.00399337f, -0.03095762f, 0.02306995f, 
    -0.00065244f, -0.03002781f, 0.05159432f, 0.00529966f, 0.04293904f, -0.01253653f, 0.00486181f, -0.05755991f, 
    0.02276494f, -0.05600324f, -0.02509881f, 0.02460287f, 0.10210573f, 0.02476801f, 0.03499825f, -0.03897307f, 
    0.05233906f, 0.21694322f, -0.15323243f, 0.17791879f, -0.02480973f, -0.02353122f, 0.09787855f, 0.08036747f, 
    0.01680715f, -0.03525352f, 0.00288139f, -0.04210358f, -0.21390906f, 0.02088624f, -0.01653425f, 0.12870529f, 
    -0.04100418f, 0.00954957f, 0.09938151f, -0.02910121f, -0.02573651f, 0.03441682f, -0.06531026f, -0.06512948f, 
    -0.48379201f, 0.32766575f, -0.03603048f, 0.06435800f, 0.02563256f, -0.08129367f, -0.08162469f, 0.09385250f, 
    0.05807420f, 0.01465699f, 0.14147899f, -0.06843647f, 0.00870837f, -0.10017407f, 0.10051708f, 0.23948574f, 
    -0.00572074f, -0.01542036f, -0.09711513f, 0.04002826f, 0.13802248f, 0.06337575f, -0.07954894f, 0.09513342f, 
    -0.14455318f, -0.12200072f, 0.17263988f, 0.04018402f, -0.07105644f, -0.04029126f, -0.04086808f, 0.04897610f, 
    -0.03714914f, 0.00226770f, -0.12292608f, -0.09083845f, 0.38999411f, 0.29652292f, -0.32394969f, 0.02684744f, 
    0.06911755f, -0.07288926f, 0.09707125f, -0.05492401f, 0.02758849f, -0.09719221f, -0.09647696f, 0.17505281f, 
    -0.23967662f, -0.13817410f, 0.09339956f, -0.10504062f, 0.09165339f, 0.01914074f, 0.18203662f, -0.08781170f, 
    0.09099375f, -0.07734888f, -0.07011238f, -0.01467756f, 0.14655162f, -0.05961724f, 0.04963072f, 0.08713384f, 
    0.00902275f, -0.00880265f, 0.05409099f, 0.04904955f, 0.08604610f, 0.13315816f, 0.11684819f, 0.18392229f, 
    0.11407753f, -0.16302572f, 0.07724667f, 0.04692187f, 0.00117958f, -0.07469616f, 0.19155198f, 0.08827831f, 
    0.10495281f, 0.06372453f, -0.01167771f, 0.08304572f, 0.00240182f, -0.16525048f, -0.16034935f, -0.10726233f, 
    -0.03771931f, 0.08259234f, 0.06170058f, 0.02264646f, 0.05055522f, -0.04279270f, 0.06458571f, 0.17345923f, 
    0.06370645f, 0.01350783f, -0.15870914f, -0.04451136f, -0.06836263f, -0.15952128f, -0.04272347f, -0.04912306f, 
    0.01420504f, 0.00815983f, -0.05322449f, -0.04907950f, -0.11376737f, -0.17443617f, 0.08080947f, 0.20043154f, 
    0.13779010f, 0.00367482f, -0.10322450f, 0.02457150f, 0.08678230f, -0.06235489f, -0.03411940f, -0.02324263f, 
    0.03933903f, -0.45655721f, -0.01925576f, -0.06782451f, 0.06107467f, 0.02522854f, 0.15909076f, 0.00224609f, 
    0.08459754f, -0.03814391f, 0.11357480f, -0.07546110f, -0.00780583f, -0.01505795f, -0.08218671f, 0.19446345f, 
    -0.03078431f, 0.02534036f, 0.06096455f, -0.13532561f, 0.00800350f, -0.10734878f, -0.01706518f, 0.04299506f, 
    0.15871161f, 0.02484362f, -0.24767970f, -0.09564066f, 0.02861077f, -0.09927315f, -0.02463725f, -0.05684488f, 
    0.01615661f, 0.03233172f, -0.02295247f, 0.07705906f, -0.09552680f, -0.15620594f, -0.11188310f, -0.09820687f, 
    0.05507103f, -0.00508686f, -0.03385708f, -0.06629770f, 0.00375915f, -0.08462881f, 0.03747308f, 0.00052018f, 
    -0.17341524f, 0.01288853f, 0.09889790f, -0.00898987f, -0.02568745f, 0.00585919f, 0.00492018f, 0.05558803f, 
    -0.04037564f, 0.11347016f, 0.12520225f, 0.03926681f, 0.08574304f, -0.16308457f, 0.02694385f, 0.15095429f, 
    0.07214352f, 0.06879566f, 0.19992210f, -0.06597790f, -0.01569454f, 0.08842143f, -0.07412997f, -0.01419040f, 
    0.01765891f, 0.24173459f, 0.13852099f, 0.17335950f, 0.14650205f, -0.01211916f, 0.01434222f, 0.14170565f, 
    0.11325952f, -0.00489383f, 0.20202020f, -0.00136659f, 0.06088255f, -0.06725505f, 0.17312837f, 0.13387711f, 
    0.01936764f, -0.01715579f, -0.12143309f, 0.07055206f, 0.03214439f, -0.00207672f, -0.04180441f, -0.05347177f, 
    -0.04745398f, 0.04418677f, -0.09408569f, 0.07446710f, -0.07833539f, -0.03634750f, -0.04349751f, -0.00174894f, 
    -0.07924498f, -0.01138593f, 0.11570610f, 0.09479061f, -0.17217380f, 0.34033567f, -0.12089588f, -0.07860257f, 
    -0.12894335f, 0.05522173f, 0.02711620f, 0.10746019f, -0.00091709f, 0.13171454f, -0.01742018f, -0.09324869f, 
    0.28413293f, -0.08591029f, -0.21595891f, 0.10458013f, 0.03076476f, 0.15596347f, -0.00410228f, -0.04615672f, 
    -0.04216074f, 0.04997554f, -0.02222199f, -0.05800796f, 0.34258068f, 0.12807748f, -0.04947496f, 0.12749173f, 
    -0.12847009f, -0.07840893f, -0.00916895f, 0.07265209f, -0.06691126f, 0.04623468f, 0.03303466f, 0.01341387f, 
    0.05792613f, 0.09847091f, -0.00712103f, -0.09752004f, -0.07063335f, 0.00326893f, 0.02223261f, -0.03862412f, 
    0.01611468f, -0.08492523f, 0.07655716f, 0.05916531f, -0.43730080f, -0.04131538f, -0.23204710f, 0.00434269f, 
    0.06152310f, 0.07441819f, 0.01656033f, 0.02162781f, 0.10858154f, 0.01874444f, -0.04214097f, -0.08766899f, 
    -0.07974514f, 0.00087560f, 0.09090563f, 0.23040988f, 0.01656879f, 0.07230784f, 0.01233259f, 0.01080320f, 
    0.00881970f, 0.09744748f, 0.07538261f, -0.06700644f, 0.22115888f, -0.06845776f, 0.07438501f, 0.11527374f, 
    0.02185556f, 0.02949468f, 0.00144033f, 0.10694250f, 0.02889101f, -0.01615482f, 0.09796776f, -0.03526148f, 
    0.00144062f, -0.00331298f, -0.15198269f, -0.00617567f, -0.02199830f, 0.03633655f, 0.03262966f, 0.08367127f, 
    -0.01724621f, 0.03927688f, 0.02870700f, 0.03737004f, 0.32309529f, 0.11086534f, 0.24987878f, -0.09636729f, 
    0.14774269f, 0.04303584f, 0.15233475f, 0.08746634f, 0.05253338f, 0.05839410f, 0.00786944f, 0.14348464f, 
    -0.15105186f, -0.13647333f, -0.04063538f, -0.11209847f, -0.01089954f, -0.10672279f, 0.06047404f, 0.06124743f, 
    -0.03240323f, 0.01791919f, 0.02556533f, -0.01565767f, 0.34336892f, 0.03626617f, 0.05720752f, -0.23903149f, 
    -0.10636440f, -0.05456961f, 0.16457060f, 0.02441043f, -0.02242863f, 0.13214445f, -0.10253866f, -0.09594406f, 
    -0.15404421f, -0.14345264f, -0.08904579f, -0.06248959f, -0.03862317f, 0.05977156f, -0.04853354f, -0.03068696f, 
    0.00418742f, -0.02363420f, -0.01747376f, 0.12723474f, -0.17613368f, 0.17563502f, 0.16161425f, -0.14685047f, 
    -0.16398618f, -0.12964931f, 0.01061200f, 0.01681192f, -0.01248554f, 0.05871931f, -0.04019707f, -0.06230257f, 
    -0.23089552f, -0.14073198f, -0.04110798f, 0.02464000f, 0.14730106f, 0.07282177f, -0.10516544f, -0.08322196f, 
    0.09093346f, 0.02025339f, -0.02415330f, 0.05933417f, 0.06833006f, -0.07728054f, 0.00249084f, 0.11834298f, 
    -0.00120009f, -0.02364702f, 0.06500154f, 0.13683361f, -0.11456863f, 0.04271923f, -0.05849750f, -0.12967116f, 
    -0.07309772f, 0.24970572f, 0.14918809f, 0.22032845f, 0.10111447f, 0.04449640f, 0.01239349f, -0.10654221f, 
    0.11106698f, 0.10463013f, -0.03827625f, 0.02715031f, -0.42510349f, -0.12185826f, -0.26241797f, 0.27606088f, 
    0.12586132f, 0.16393432f, 0.02045827f, 0.01228068f, -0.03525731f, -0.00436547f, 0.07373816f, 0.09211305f, 
    -0.14595543f, 0.36344942f, 0.03325924f, 0.31075194f, 0.04284624f, 0.03922991f, 0.08864754f, 0.14116968f, 
    -0.00846973f, 0.23494740f, 0.07742637f, 0.09888411f, 0.05966861f, 0.03546390f, 0.08269890f, -0.04569267f, 
    0.04584748f, 0.08849785f, -0.00406783f, 0.07911644f, -0.11185041f, 0.24803489f, 0.01257849f, 0.02755886f, 
    -0.13071842f, -0.11513700f, 0.01238943f, -0.01921298f, -0.04814416f, 0.00075413f, 0.00665304f, -0.01510535f, 
    -0.09255043f, 0.06963081f, 0.04725571f, 0.05754605f, 0.11762048f, -0.02876223f, 0.18627618f, 0.08504517f, 
    -0.08358838f, -0.07623410f, 0.02859852f, 0.03120549f, 0.12348566f, 0.06391159f, -0.04386052f, -0.22673652f, 
    -0.30462646f, -0.06224263f, -0.12749952f, -0.07354679f, -0.07813739f, -0.01957682f, -0.11332576f, 0.06417952f, 
    -0.06562258f, -0.04362373f, -0.10265387f, -0.11558565f, -0.52954501f, 0.34125361f, 0.20721762f, 0.02020973f, 
    -0.02708876f, -0.02129096f, 0.03462004f, 0.16785017f, 0.01403266f, 0.02756988f, -0.01740624f, -0.06553978f, 
    -0.12403577f, 0.02810716f, -0.04545926f, 0.01816385f, 0.03725161f, -0.04418084f, 0.07491674f, 0.05374973f, 
    0.04318603f, 0.02138560f, -0.05648760f, -0.04976258f, -0.21567722f, -0.26198640f, 0.29959753f, 0.04475771f, 
    0.03939238f, 0.12646519f, -0.08033533f, -0.07508324f, -0.00108903f, -0.03847091f, 0.11178526f, -0.09906554f, 
    -0.04149931f, -0.15702158f, -0.03550921f, -0.13161266f, -0.12154981f, 0.01397014f, 0.08192226f, -0.04838204f, 
    -0.02273276f, 0.16128087f, -0.08962344f, -0.02745637f, 0.24052873f, -0.21465348f, 0.13202296f, 0.22827448f, 
    0.07933471f, -0.03493112f, 0.10268365f, 0.18937767f, -0.14100322f, -0.00803777f, 0.03511934f, 0.07373661f, 
    -0.32454470f, 0.15624715f, -0.08553004f, -0.01422958f, 0.00765051f, 0.06295797f, -0.04047077f, 0.05756850f, 
    0.03233947f, -0.05042470f, 0.18613313f, 0.05352389f, -0.20895618f, -0.13519639f, -0.22750530f, -0.08319301f, 
    -0.04728600f, 0.02275657f, -0.05907262f, 0.01048921f, 0.01411294f, 0.06486509f, -0.17383614f, 0.02934830f, 
    -0.27846405f, 0.13968314f, -0.09022297f, 0.01504798f, 0.04962021f, 0.13104247f, -0.03817740f, -0.07901426f, 
    0.05487753f, -0.06639951f, -0.05840809f, -0.10642725f, -0.13566631f, 0.05265926f, -0.03252012f, -0.08866310f, 
    -0.11286885f, -0.05563350f, 0.04665008f, 0.04934466f, -0.05768446f, 0.12148307f, 0.03285414f, 0.11560908f, 
    -0.33229932f, 0.11649159f, 0.19293554f, 0.21891880f, -0.05863834f, 0.06131839f, -0.16869996f, 0.04264394f, 
    0.05591358f, 0.01052719f, 0.05823245f, 0.09023676f, -0.25608376f, -0.23418204f, -0.24562673f, -0.05881515f, 
    0.00770970f, 0.07399506f, -0.00266603f, 0.08781315f, -0.03986607f, -0.00216561f, -0.02671581f, -0.04031331f, 
    -0.02136986f, 0.07311603f, 0.23098545f, 0.26177928f, -0.02634610f, -0.09367356f, 0.17222905f, 0.18065470f, 
    0.09398080f, -0.05560286f, 0.00803819f, -0.14612938f, 0.01124238f, 0.09707110f, 0.16666535f, -0.05198443f, 
    -0.03143052f, -0.00083047f, 0.03235903f, -0.00059548f, -0.05228473f, 0.00729524f, 0.01124748f, -0.09980676f, 
    -0.16373958f, 0.11483736f, 0.05790565f, 0.04976315f, 0.12254708f, 0.06483774f, 0.02358605f, 0.01256637f, 
    -0.06253536f, -0.03837679f, -0.06849959f, -0.13256988f, -0.44944063f, 0.18601474f, 0.19436763f, 0.32815871f, 
    0.04763970f, 0.08288185f, 0.11494924f, 0.05325563f, -0.11212109f, 0.03782975f, -0.10897548f, -0.03348497f, 
    -0.25369310f, -0.05826798f, 0.05021981f, -0.03271959f, -0.04175784f, -0.03536995f, -0.03095886f, 0.05608796f, 
    0.06897959f, 0.02850191f, -0.00620469f, 0.02982825f, 0.23291455f, -0.12860593f, 0.26881626f, 0.10958871f, 
    0.01893006f, 0.12625094f, 0.00624115f, 0.02887300f, 0.11369347f, 0.02522391f, 0.11147964f, 0.12142447f, 
    0.00662504f, 0.03487427f, 0.13322236f, 0.03429906f, 0.09045886f, -0.13006268f, -0.05923499f, 0.00377366f, 
    -0.09107850f, 0.00281046f, -0.14009824f, -0.04048477f, -0.24065904f, 0.45760110f, 0.29606333f, -0.04203912f, 
    0.09137928f, -0.12981224f, 0.07866506f, 0.03543593f, -0.08882935f, 0.08227697f, -0.02749632f, -0.08602659f, 
    0.07103002f, -0.02387790f, 0.06669633f, -0.06025700f, 0.08651186f, 0.00270681f, 0.06390832f, -0.00053889f, 
    0.02948961f, -0.07135511f, -0.04026452f, 0.15119177f, 0.17233944f, 0.11526147f, 0.18685751f, 0.01773905f, 
    -0.02665335f, 0.13563217f, -0.00144296f, 0.07860486f, 0.12363825f, 0.03479269f, 0.08198841f, 0.03798621f, 
    -0.13021599f, 0.34908080f, -0.09219834f, 0.25548676f, -0.00640788f, 0.10478569f, 0.00912852f, -0.00768924f, 
    0.09630896f, 0.03288778f, -0.08564700f, 0.06018253f, -0.36387116f, -0.30674446f, -0.19840056f, 0.10673492f, 
    -0.04578865f, 0.14057496f, -0.08385152f, 0.03362463f, 0.00156127f, 0.03272331f, -0.01841267f, -0.06795797f, 
    -0.42752248f, -0.08471794f, 0.20827837f, 0.02947940f, 0.06611196f, -0.00218415f, -0.07585831f, 0.04151685f, 
    -0.09028396f, 0.00838957f, 0.04578048f, 0.10276337f, -0.07818682f, -0.04953228f, 0.00076326f, -0.00285282f, 
    -0.06709767f, 0.03373808f, 0.05078616f, -0.01798345f, 0.01772843f, -0.04741846f, -0.08410739f, -0.00230111f, 
    -0.32990918f, -0.04481253f, -0.04559147f, 0.01759882f, -0.15152417f, 0.01832808f, 0.02779270f, 0.06900106f, 
    0.02514019f, 0.02039717f, -0.09561983f, -0.03419123f, 0.54414868f, 0.24595086f, 0.09431588f, -0.08998605f, 
    -0.05678901f, 0.06334989f, 0.06443854f, 0.16227069f, -0.01393182f, 0.05217211f, 0.00349596f, 0.07518394f, 
    -0.27722871f, -0.26573071f, -0.24171200f, -0.07475961f, 0.03435210f, -0.19512491f, 0.13699701f, -0.05686680f, 
    -0.02488590f, -0.08292677f, -0.09666622f, 0.06131752f, 0.13626401f, 0.05482627f, -0.01996568f, 0.13677950f, 
    -0.00163716f, 0.07515658f, 0.03696425f, -0.04025974f, 0.00422539f, 0.07293723f, -0.11975140f, 0.11333164f, 
    -0.04424574f, 0.01913639f, 0.02929153f, 0.09292622f, -0.01344722f, -0.09238245f, 0.14235103f, -0.05052597f, 
    -0.00560110f, 0.04648190f, 0.01625543f, 0.05880196f, -0.06210423f, -0.11163471f, 0.05524400f, 0.02557581f, 
    -0.01260362f, 0.02159560f, 0.01899225f, 0.06043987f, 0.01659980f, 0.08310947f, -0.00172076f, 0.05247207f, 
    -0.08894932f, -0.02326322f, -0.07302340f, -0.06800161f, -0.05409124f, -0.02955389f, 0.00630056f, -0.02162992f, 
    -0.11836448f, -0.06357669f, 0.08570759f, -0.01362277f, 0.03562420f, -0.07065437f, -0.01890196f, 0.02518153f, 
    0.12131425f, -0.01782743f, -0.00349777f, -0.12551542f, -0.01840303f, -0.02980820f, 0.04943068f, 0.05440624f, 
    -0.11583910f, -0.15509355f, 0.07298835f, 0.18189959f, -0.05408483f, -0.02456073f, 0.09035973f, 0.06425488f, 
    0.04948769f, 0.04711016f, 0.04308254f, -0.16631864f, 0.13360789f, -0.01257122f, 0.01195022f, 0.05644974f, 
    -0.09243073f, -0.09327633f, 0.21661299f, -0.00505678f, -0.04328093f, -0.03882002f, -0.13910364f, 0.01787173f, 
    -0.07865870f, -0.02201562f, -0.02399245f, -0.00269591f, -0.05334330f, -0.06210265f, 0.05118228f, 0.15053979f, 
    0.09431248f, 0.02376281f, -0.02321231f, 0.02765227f, -0.06209121f, -0.13751228f, -0.08787407f, 0.02766699f, 
    -0.01214339f, 0.02638122f, -0.01423114f, -0.10102576f, 0.06159143f, 0.08208820f, -0.01788158f, 0.03781402f, 
    -0.08906219f, -0.01839694f, 0.02815589f, -0.01518314f, -0.00603095f, -0.16767518f, -0.06724347f, 0.06323789f, 
    0.04837943f, 0.02697551f, -0.10606471f, 0.12255173f, 0.04124729f, 0.08360370f, 0.14285497f, 0.16860618f, 
    -0.02036924f, 0.00306726f, 0.01901788f, 0.05161338f, 0.13432093f, 0.11842383f, -0.04482652f, 0.00347816f, 
    -0.38449812f, 0.12790568f, -0.06950829f, 0.11249935f, -0.13755532f, 0.09719034f, -0.04668012f, 0.23321772f, 
    -0.10665384f, -0.02260683f, -0.03737345f, -0.06523054f, 0.10538406f, -0.02012147f, 0.01801956f, 0.02228848f, 
    0.02237310f, -0.01816022f, 0.05820077f, -0.01204622f, 0.00447624f, 0.05767997f, -0.04502269f, -0.13384758f, 
    -0.39142621f, -0.27776760f, -0.26304218f, -0.16881888f, -0.08088429f, 0.00941646f, -0.01690335f, -0.01158945f, 
    -0.02879194f, -0.12925696f, -0.02829077f, -0.01310199f, -0.01981288f, -0.21043514f, 0.05972145f, -0.37315509f, 
    -0.02700796f, 0.01590120f, -0.07368001f, 0.01841335f, 0.13036527f, -0.12610115f, 0.02724280f, -0.04888733f, 
    -0.24709502f, 0.16837703f, 0.01521234f, 0.26021448f, -0.11008009f, 0.03103920f, 0.13648719f, -0.01855733f, 
    0.04115394f, 0.10644733f, 0.01863932f, 0.04233035f, -0.28615052f, -0.05986401f, -0.12981057f, 0.02190446f, 
    0.05085693f, 0.04518714f, 0.03367519f, -0.02394967f, 0.04537888f, -0.07491335f, -0.03888851f, -0.08266278f, 
    -0.09826145f, -0.00538313f, 0.16837156f, 0.21522011f, -0.03734541f, 0.11932699f, -0.02841374f, 0.03253869f, 
    0.00235266f, 0.01902937f, 0.00555802f, 0.05765478f, 0.14116772f, 0.13144629f, 0.17159630f, -0.14378844f, 
    0.04216797f, -0.03943639f, -0.12131777f, 0.16098812f, -0.02019732f, 0.03587399f, 0.02948598f, 0.07487500f, 
    0.11389317f, -0.17603990f, 0.13583280f, 0.13641068f, -0.05616813f, 0.01847424f, 0.01376328f, -0.05312372f, 
    -0.00739928f, -0.02750544f, -0.01392120f, 0.05522890f, -0.18353455f, 0.10122121f, -0.14560312f, 0.13823955f, 
    0.01515427f, 0.07259469f, 0.02928199f, 0.08990099f, 0.01801424f, 0.01263090f, 0.05493105f, -0.01164749f, 
    0.02748369f, 0.00205058f, 0.09201067f, 0.02571736f, 0.06795433f, 0.05336497f, 0.07629512f, 0.04466274f, 
    -0.07146865f, -0.06223330f, 0.05743275f, 0.03524551f, -0.13904582f, 0.08337788f, 0.02565178f, 0.27941763f, 
    0.01462129f, 0.01175891f, 0.08567689f, -0.07019874f, -0.07987232f, 0.05034580f, 0.04443231f, -0.04550044f, 
    -0.00820322f, -0.04753504f, -0.01973496f, 0.12104633f, -0.06629236f, -0.07487188f, -0.15104921f, -0.04087091f, 
    0.04074009f, -0.00312992f, 0.04268142f, -0.02024656f, -0.17433926f, -0.12924343f, -0.23803131f, 0.07645156f, 
    -0.01583184f, -0.05785066f, -0.05243291f, -0.18301043f, -0.01266410f, -0.06108501f, 0.03033176f, 0.05719280f, 
    0.11095674f, 0.05555183f, 0.07268541f, 0.10678148f, 0.04493498f, 0.05404063f, 0.07240325f, 0.09730366f, 
    -0.05302381f, -0.09901827f, 0.00262267f, 0.07202122f, -0.11085483f, -0.22842756f, -0.15358907f, -0.05779868f, 
    0.05625095f, -0.07298590f, -0.04916017f, 0.03494080f, -0.00568057f, 0.13401100f, -0.13687608f, -0.03039109f, 
    -0.05639889f, 0.20723662f, -0.06965039f, 0.07802066f, -0.12690246f, -0.04533820f, 0.04320127f, -0.09701588f, 
    -0.03659606f, 0.08748773f, -0.02836880f, 0.02719983f, 0.05282758f, 0.09277009f, 0.14881584f, -0.05422607f, 
    0.10554297f, 0.00379960f, -0.01514950f, -0.04360566f, -0.06628738f, -0.04099653f, 0.08728492f, -0.01237204f, 
    -0.07321430f, 0.23740388f, -0.00976646f, 0.09269237f, 0.01380452f, -0.00044945f, 0.14433263f, -0.11326001f, 
    0.01596454f, 0.00526584f, -0.24647292f, 0.06902179f, 0.11473944f, 0.23337482f, 0.13547304f, 0.16246578f, 
    -0.01971787f, -0.16692767f, -0.05038361f, 0.09484179f, 0.02402963f, 0.00802966f, 0.05197302f, -0.02983970f, 
    0.16238640f, -0.14078078f, 0.02347763f, 0.19571887f, -0.13477661f, 0.15244241f, 0.01427866f, 0.04902284f, 
    0.04045136f, -0.08519609f, -0.10578850f, -0.04117771f, 0.20371908f, 0.23732257f, -0.00281481f, 0.03640759f, 
    0.02162944f, 0.19143416f, 0.20055348f, -0.05350668f, 0.00440383f, -0.05137539f, -0.04984531f, 0.08288772f, 
    -0.12723319f, -0.04850328f, -0.15405622f, -0.07730741f, -0.03716240f, 0.08699607f, 0.00816691f, -0.01105482f, 
    0.01514053f, -0.03558571f, 0.00731171f, 0.02801935f, -0.09947373f, 0.21280247f, 0.08234122f, -0.16728808f, 
    -0.06341802f, -0.05664544f, 0.04432862f, 0.05909593f, -0.05024088f, 0.02469690f, -0.22775173f, -0.03235693f, 
    -0.01467865f, -0.05616187f, -0.02215269f, -0.17769194f, -0.00704353f, -0.06440504f, -0.09298488f, -0.00839151f, 
    -0.07258467f, 0.03475228f, 0.07184768f, -0.07257950f, 0.19896753f, 0.10886434f, 0.00552366f, -0.09342778f, 
    -0.03723091f, -0.01654211f, -0.06456535f, 0.05568990f, 0.11445496f, -0.06085386f, -0.16179684f, -0.03020387f, 
    -0.01326604f, 0.07419132f, 0.05915267f, 0.04589023f, -0.00423500f, -0.00877157f, -0.17961703f, -0.00310119f, 
    0.03269875f, 0.02845659f, 0.02337644f, -0.10232691f, 0.12136842f, 0.26628405f, -0.08154486f, 0.05475480f, 
    0.04227314f, -0.06845957f, -0.04712718f, 0.05295180f, 0.02071567f, 0.03432119f, 0.02014548f, -0.05446034f, 
    -0.08450245f, -0.11826909f, 0.07728758f, -0.02476697f, -0.01866282f, -0.09181543f, 0.05952627f, -0.06099868f, 
    -0.06465323f, -0.02177753f, -0.07052503f, 0.02363740f, -0.15154153f, 0.17765188f, 0.17924099f, 0.01806024f, 
    -0.07470590f, 0.07421719f, 0.05057196f, -0.02984310f, -0.03265701f, 0.01622003f, -0.06089355f, -0.11242513f, 
    0.07256856f, -0.31660664f, 0.16291419f, 0.25162306f, -0.19117531f, 0.05891996f, -0.01797069f, -0.01247175f, 
    0.07802804f, -0.00508484f, 0.00482179f, -0.00039170f, -0.02325868f, -0.13506639f, -0.10260977f, -0.10172018f, 
    0.00329432f, -0.11865786f, 0.06354111f, -0.04840400f, -0.09319224f, -0.14758453f, -0.01056632f, -0.08010771f, 
    0.23281421f, 0.08174291f, -0.04568573f, -0.00625977f, 0.06988478f, 0.00072135f, -0.11624543f, -0.02834987f, 
    -0.00823849f, -0.21145108f, -0.16779558f, -0.05563045f, -0.15710773f, -0.02607301f, -0.11403804f, -0.06695475f, 
    0.02350426f, -0.09446310f, -0.05169995f, -0.03713901f, -0.09132140f, -0.08604860f, -0.00197898f, -0.01594025f, 
    0.25232524f, -0.04205473f, -0.16667022f, 0.06088633f, -0.06278960f, 0.00490036f, 0.14338371f, -0.05555530f, 
    -0.06460009f, -0.05940591f, 0.06962560f, -0.00930048f, -0.03287013f, 0.07738236f, 0.04544194f, 0.12962735f, 
    -0.10336566f, 0.09049051f, -0.14942896f, -0.02008293f, 0.04157632f, 0.04797077f, 0.01683922f, 0.01485242f, 
    0.04774996f, 0.00602339f, -0.01668858f, 0.11172494f, 0.14166173f, 0.01049446f, -0.04006001f, 0.12754384f, 
    -0.04216721f, -0.08995925f, -0.19301184f, -0.23964643f, 0.00648435f, 0.01254148f, -0.00134003f, 0.09128891f, 
    -0.00173037f, -0.01229482f, -0.09118316f, 0.06243536f, 0.02583786f, 0.03166442f, -0.19699790f, -0.09590622f, 
    0.17081027f, 0.00661479f, 0.06262539f, 0.11309068f, -0.16433193f, 0.09221077f, 0.04700583f, 0.17580770f, 
    0.12545629f, 0.03758164f, 0.07273465f, -0.01923541f, 0.10032244f, 0.15303880f, 0.00600587f, -0.01261904f, 
    -0.00118483f, 0.01700230f, -0.08805374f, 0.02501217f, -0.00830043f, 0.01098148f, -0.02155736f, -0.09282158f, 
    0.13808410f, -0.04579134f, -0.17994152f, 0.16375791f, 0.09326383f, -0.02096401f, 0.18605073f, -0.16300674f, 
    -0.08770195f, 0.04529921f, -0.06350657f, -0.01058618f, -0.12997794f, 0.14077109f, 0.03500311f, 0.29789940f, 
    -0.07164226f, 0.02313165f, 0.14330627f, 0.02175279f, 0.05140398f, -0.07627828f, -0.05966595f, -0.00152216f, 
    0.03568943f, 0.03432686f, 0.00248995f, 0.02151776f, 0.08197577f, -0.06780117f, 0.00957263f, -0.21042486f, 
    0.12610278f, -0.09458560f, 0.03744997f, 0.01401561f, 0.15908089f, -0.37655005f, -0.08964437f, 0.04353049f, 
    0.04161399f, -0.07036301f, 0.08414382f, 0.00359067f, 0.05728179f, 0.06078818f, -0.05528452f, -0.01810736f, 
    0.02498325f, 0.23121297f, 0.07584824f, 0.12831387f, -0.00626181f, -0.02468009f, 0.12176403f, 0.09963045f, 
    0.06455593f, 0.11373318f, 0.01224027f, 0.00388542f, -0.15112913f, 0.10128898f, 0.10105875f, 0.15593989f, 
    -0.03403787f, -0.03067553f, 0.03258142f, -0.05777586f, 0.08624660f, 0.02460191f, -0.02110317f, 0.03332365f, 
    -0.07797817f, -0.05011510f, 0.35502091f, -0.04302204f, -0.04575289f, 0.04383159f, -0.04189159f, 0.21139269f, 
    -0.05419273f, 0.15979899f, -0.10609295f, 0.06426070f, 0.10187291f, 0.05427514f, 0.14158106f, -0.06179303f, 
    0.01748756f, 0.03543814f, -0.13590491f, -0.02875137f, 0.00662601f, -0.03838342f, 0.09481048f, 0.02694280f, 
    0.01138028f, -0.10337324f, -0.13153835f, 0.03933265f, -0.01801771f, 0.20388627f, -0.05613527f, -0.18078645f, 
    0.00075094f, 0.12110804f, -0.06624543f, 0.05927136f, -0.08151259f, 0.04582132f, -0.12487415f, -0.00995706f, 
    -0.00935289f, 0.03718476f, 0.06921157f, 0.02414694f, 0.10834816f, -0.03337923f, -0.02176451f, -0.04911490f, 
    0.09871475f, 0.22182328f, -0.04737440f, -0.01104767f, 0.14037684f, 0.06714739f, 0.12471371f, -0.00515057f, 
    0.01714726f, -0.01886133f, -0.08920094f, -0.02979105f, -0.23447730f, -0.10185467f, 0.39365605f, 0.00594428f, 
    0.00708410f, 0.02511037f, -0.01110910f, 0.06090551f, -0.00028466f, 0.04989323f, 0.11509247f, -0.11989615f, 
    0.06833856f, 0.19788332f, 0.15889847f, 0.23032206f, -0.04180886f, -0.05820687f, -0.07255966f, 0.08271503f, 
    0.00151842f, 0.06758751f, -0.05328278f, 0.04116343f, 0.14690609f, 0.17141075f, -0.06784214f, 0.07189625f, 
    0.03858736f, 0.08751928f, 0.13694240f, 0.03557467f, -0.09856655f, -0.33593845f, -0.11871794f, -0.02313372f, 
    -0.04591381f, 0.09356822f, 0.14652371f, 0.05894779f, -0.04156608f, 0.15949553f, -0.13387170f, 0.03277384f, 
    0.06689496f, -0.07953136f, 0.03858168f, -0.03222288f, 0.01192906f, 0.05320410f, 0.02641694f, -0.06577457f, 
    -0.08031017f, -0.05723006f, -0.00972458f, -0.01600274f, -0.02309625f, -0.00172150f, -0.14691335f, -0.12366492f, 
    -0.38406754f, -0.18476005f, -0.24581289f, -0.37748140f, -0.00628350f, 0.01938543f, -0.05652339f, 0.00093302f, 
    -0.04879393f, -0.06200818f, 0.01441387f, 0.05980627f, -0.05374001f, 0.09224017f, -0.07149662f, 0.14866702f, 
    0.05116903f, 0.02879046f, 0.10134257f, -0.11111341f, 0.08744869f, 0.00597299f, -0.02860332f, 0.03764154f, 
    0.23297404f, 0.24349494f, -0.00028062f, 0.13971491f, -0.02197199f, -0.01089487f, 0.05899984f, 0.09296626f, 
    -0.05326570f, 0.04225098f, 0.04469009f, 0.04561588f, -0.08787892f, 0.13375415f, 0.08057780f, -0.03421767f, 
    0.07320563f, -0.04969187f, 0.09781200f, -0.04854610f, -0.00486147f, 0.07656690f, -0.11258005f, 0.02543354f, 
    0.00444563f, -0.13645093f, 0.08464999f, -0.01915450f, -0.13946719f, 0.02087267f, 0.01974826f, 0.05781970f, 
    0.15337040f, 0.07432337f, -0.01960409f, 0.09449261f, -0.01263380f, 0.11980594f, -0.11395545f, 0.04092447f, 
    -0.03389736f, -0.00302911f, -0.00263983f, -0.03270059f, 0.03917893f, -0.01810844f, -0.22184852f, -0.04041801f, 
    0.07046173f, 0.01084055f, 0.03488085f, -0.09226815f, 0.06330845f, -0.13165466f, -0.03888299f, -0.01768873f, 
    0.03795379f, -0.10040440f, 0.05589600f, -0.08405796f, 0.03445920f, 0.08602918f, 0.03556766f, -0.05343894f, 
    -0.01939703f, -0.01160958f, 0.06011456f, 0.08094013f, 0.06349637f, 0.03087753f, 0.01444100f, 0.03504339f, 
    0.13564795f, -0.18717010f, 0.24790855f, -0.11347753f, -0.03314124f, 0.00113788f, -0.13577943f, -0.02797809f, 
    -0.19059236f, 0.01601362f, -0.04075513f, -0.11852616f, -0.07495674f, 0.03255267f, -0.21144675f, -0.13377151f, 
    0.00549257f, 0.11983082f, -0.03996748f, -0.01395712f, 0.10234284f, -0.02816406f, -0.07234722f, 0.05411700f, 
    0.18242690f, -0.00980077f, 0.09350247f, -0.03339244f, 0.07097139f, -0.01389759f, 0.01766794f, -0.06451860f, 
    0.15759112f, -0.01796899f, 0.06919614f, -0.05025877f, 0.11328657f, -0.09342518f, 0.28011847f, 0.04862504f, 
    0.01169180f, -0.06283389f, -0.01306374f, -0.06754050f, 0.16314277f, 0.03749909f, 0.13279761f, -0.12568995f, 
    0.12660229f, -0.06281118f, 0.14550298f, 0.01401348f, 0.01813500f, 0.14717878f, 0.17270474f, 0.02797340f, 
    0.05347130f, 0.11286673f, 0.05079133f, -0.00251559f, -0.03764949f, 0.07005296f, 0.00751557f, 0.14614139f, 
    -0.00677763f, 0.06171196f, 0.06444146f, -0.08286559f, 0.06406804f, -0.07779740f, 0.00546318f, -0.05203184f, 
    0.10951755f, 0.00332039f, 0.32274821f, 0.09163897f, -0.01705300f, 0.16311876f, 0.16354167f, 0.08169691f, 
    0.03424514f, -0.00465512f, -0.02531084f, -0.09475666f, 0.32130781f, 0.20428638f, 0.09440101f, -0.14797640f, 
    0.05195802f, 0.04573955f, 0.04661468f, 0.12315796f, -0.06605426f, -0.08268204f, 0.08153857f, -0.05855188f, 
    0.03162371f, 0.04215477f, -0.17045905f, 0.18556181f, -0.05326431f, 0.07274302f, 0.03160281f, 0.00084781f, 
    -0.07011148f, 0.00399031f, 0.02501059f, 0.09356650f, -0.13107321f, 0.03235885f, -0.03494582f, 0.07440995f, 
    0.06076464f, -0.04649524f, 0.02026290f, -0.08129099f, 0.04710379f, 0.03022984f, -0.05866699f, -0.00065363f, 
    0.29877096f, 0.07621893f, 0.05029528f, 0.04347723f, -0.03666051f, -0.08271396f, 0.00742839f, -0.03446117f, 
    -0.06680008f, -0.11038105f, 0.06173681f, -0.08548775f, -0.23684169f, 0.11195262f, 0.03849135f, 0.21354093f, 
    0.11278320f, 0.07325041f, 0.02762999f, 0.04488469f, -0.07389105f, 0.03033717f, 0.03322020f, -0.01263435f, 
    0.01274048f, 0.09108736f, 0.10105305f, 0.03438670f, 0.03416480f, 0.00130414f, -0.00402532f, 0.15076113f, 
    0.00772542f, -0.01452466f, 0.01624088f, 0.07268316f, -0.24994972f, 0.04561814f, -0.05450667f, 0.21485063f, 
    0.04089852f, -0.02176121f, -0.16035044f, 0.07296555f, -0.10372352f, 0.05251085f, -0.08157148f, 0.16185415f, 
    0.09146157f, 0.16481318f, -0.00538804f, 0.08722253f, 0.05114139f, 0.13312662f, 0.11562199f, -0.01494594f, 
    -0.06259613f, -0.02301482f, -0.09777771f, 0.03347758f, 0.19649035f, -0.09448578f, 0.09515805f, -0.06743449f, 
    -0.15354085f, -0.17476477f, 0.03647498f, 0.05531668f, -0.02117232f, 0.04069820f, -0.04089874f, 0.00591742f, 
    0.13443020f, 0.41574734f, 0.08141439f, 0.14681593f, -0.09223083f, -0.05899151f, 0.12143523f, 0.13471040f, 
    0.00256988f, 0.10379703f, 0.02259019f, -0.03811867f, 0.08679443f, -0.22450054f, 0.04283686f, -0.20299201f, 
    -0.02671537f, -0.01391344f, -0.04434130f, -0.04938950f, 0.06472884f, -0.00841492f, 0.15714820f, -0.00993577f, 
    0.15784487f, -0.18835902f, 0.09829763f, -0.04449096f, -0.00590351f, -0.03381605f, 0.10910977f, -0.08253425f, 
    -0.08698092f, -0.04246341f, -0.00778541f, 0.02147472f, 0.26483387f, 0.19202682f, 0.21951212f, -0.00625378f, 
    0.08938510f, -0.02534753f, 0.09533607f, 0.20316559f, -0.00518509f, 0.07364924f, 0.02147624f, -0.01585776f, 
    0.50911558f, -0.46793395f, 0.08713108f, 0.03540470f, -0.01875139f, -0.02991262f, -0.02477291f, -0.03626303f, 
    -0.07763388f, 0.09948731f, -0.19781290f, -0.02907934f, -0.04578840f, 0.13186450f, -0.35709974f, 0.14400491f, 
    0.01490472f, 0.20924854f, 0.33840942f, 0.02014045f, -0.17614518f, 0.04622820f, 0.11513516f, 0.09179599f, 
    0.08225687f, 0.11298364f, 0.08659729f, 0.00226167f, 0.03514999f, 0.03219946f, -0.00317064f, 0.00047318f, 
    0.08219149f, -0.01168001f, 0.00946404f, -0.03892054f, 0.18688272f, 0.06771778f, -0.17353994f, -0.13723741f, 
    -0.01591625f, -0.22272658f, 0.00091509f, 0.01195365f, -0.02779939f, -0.02335861f, 0.04604552f, -0.11996930f, 
    0.14877445f, 0.13878742f, 0.14032389f, 0.05089433f, 0.04141282f, -0.02599768f, -0.01586646f, 0.03809040f, 
    0.14311852f, 0.16703451f, 0.12635885f, 0.10945056f, 0.17980352f, -0.37121782f, -0.11478394f, -0.14612684f, 
    -0.03102262f, -0.09190768f, -0.02076354f, 0.09339882f, 0.02318634f, 0.03162486f, -0.13997631f, -0.06024455f, 
    0.01700262f, 0.11797725f, 0.05796191f, -0.07249326f, -0.00393680f, -0.01480297f, -0.10074078f, 0.03412446f, 
    -0.02582473f, -0.07939986f, 0.00851925f, 0.07882509f, 0.10690682f, 0.41609278f, -0.19373739f, 0.12868269f, 
    0.17505583f, -0.16666161f, -0.18213639f, 0.25744003f, 0.01980500f, -0.02047664f, 0.12319188f, -0.03199328f, 
    0.05991399f, 0.00036820f, 0.02834470f, 0.06825215f, 0.05129945f, -0.09990425f, -0.03515886f, -0.07120620f, 
    -0.10900674f, 0.14877948f, -0.10435084f, -0.01443925f, -0.34043893f, 0.06283474f, -0.08044413f, -0.31602898f, 
    -0.00805725f, -0.02543222f, 0.06881917f, 0.01597629f, 0.06091822f, 0.06515409f, -0.04885979f, 0.02334968f, 
    0.37438133f, -0.12524135f, 0.07181209f, 0.09906385f, -0.00172767f, 0.01682407f, -0.07536368f, -0.08894946f, 
    -0.01420461f, -0.07112341f, -0.06443074f, 0.02829713f, 0.07212509f, 0.09938550f, 0.11676680f, 0.04605183f, 
    0.00721986f, 0.06831168f, -0.01053714f, -0.01140745f, 0.13861240f, 0.04586932f, 0.15873162f, -0.03386168f, 
    0.05963635f, -0.11577597f, -0.02809196f, 0.06108654f, -0.00272184f, -0.02455422f, 0.07973081f, 0.08305016f, 
    -0.03428492f, -0.11644281f, -0.07274844f, 0.05870109f, 0.02476222f, 0.11947856f, 0.06781285f, 0.03099958f, 
    -0.02445017f, 0.04435944f, -0.05316059f, 0.03411698f, 0.07282647f, -0.00049617f, 0.03400929f, -0.08596140f, 
    0.22537626f, 0.14325632f, -0.03978392f, -0.04117645f, 0.00493624f, -0.01958639f, 0.09645694f, 0.03271531f, 
    0.05692440f, -0.02550524f, 0.09987885f, -0.12379946f, 0.10815632f, 0.09623006f, 0.24441722f, 0.08435956f, 
    0.08411867f, 0.07742153f, 0.00004844f, 0.12984781f, 0.02518998f, -0.00218820f, -0.02401502f, 0.09938771f, 
    -0.08275328f, 0.17856494f, -0.17429185f, -0.13601109f, -0.06580514f, 0.09983180f, -0.17710663f, 0.20191331f, 
    0.03068507f, -0.00478842f, 0.02619284f, -0.06491901f, 0.04320760f, -0.13308561f, -0.10113464f, -0.12078426f, 
    0.00058202f, -0.14775383f, -0.17420840f, -0.04097251f, 0.07017912f, -0.14499307f, -0.04792352f, 0.09680510f, 
    0.54911005f, -0.09272761f, -0.06316694f, -0.16743718f, -0.23094472f, 0.19052371f, -0.05094974f, -0.02508353f, 
    0.06967293f, -0.04781380f, 0.07879614f, -0.08809648f, -0.05307180f, -0.23790722f, -0.12592234f, -0.25204679f, 
    -0.14812145f, -0.13447015f, -0.12883963f, 0.07027453f, -0.01290972f, 0.00782475f, -0.02410333f, -0.07327066f, 
    0.11997314f, 0.14433146f, -0.05289592f, -0.03360456f, -0.01347307f, 0.07347135f, 0.12785345f, 0.02791893f, 
    0.00815586f, 0.18414854f, -0.03057991f, -0.15992774f, -0.21536145f, 0.17231137f, -0.13291967f, 0.07451280f, 
    0.11904498f, 0.02347125f, 0.04149046f, 0.03543872f, -0.00556760f, -0.03039824f, -0.01976873f, -0.04098872f, 
    -0.31707045f, 0.15134415f, -0.16917759f, 0.19180694f, -0.01610773f, 0.05293044f, -0.26202130f, 0.04686942f, 
    0.06076805f, -0.03128306f, 0.08437224f, 0.23481363f, 0.30227619f, -0.43041489f, 0.00502303f, -0.21121173f, 
    -0.10036118f, -0.16894785f, 0.13185292f, 0.08815179f, 0.01492713f, 0.08961433f, -0.06093270f, -0.03048121f, 
    -0.04241028f, 0.02664648f, 0.08266891f, 0.01378165f, -0.09334458f, 0.11347035f, -0.04573796f, 0.03328281f, 
    0.04739705f, 0.09337356f, 0.03929495f, -0.05227334f, -0.18980509f, 0.05836422f, -0.04240010f, 0.03199058f, 
    0.01665039f, -0.01938406f, -0.08008590f, 0.01948396f, 0.06160679f, -0.06936405f, -0.07785838f, -0.13242796f, 
    0.12977068f, -0.26477215f, 0.36693940f, -0.36801657f, -0.01171093f, 0.01606144f, 0.09010811f, -0.01140445f, 
    -0.04587344f, 0.08318756f, -0.09074274f, 0.05591809f, 0.21186253f, 0.20204945f, 0.23400524f, -0.01419393f, 
    0.20054130f, -0.02615781f, 0.14293094f, 0.23314561f, -0.02480854f, 0.00582454f, 0.09506898f, 0.09196917f, 
    -0.25968805f, 0.23030853f, -0.28693402f, 0.01316549f, -0.01579842f, 0.20483530f, 0.13027237f, 0.07035182f, 
    -0.02207059f, 0.07599950f, 0.06558675f, -0.00391860f, -0.02877871f, 0.06425961f, 0.03999750f, 0.13165018f, 
    -0.03967374f, -0.04176779f, 0.01823330f, 0.01431839f, 0.12181342f, 0.03796226f, -0.00546052f, 0.01820793f, 
    0.23907003f, 0.12126002f, -0.00205933f, -0.10832460f, 0.12555294f, 0.01865105f, 0.01756931f, 0.08122090f, 
    -0.07332992f, 0.03379829f, -0.11127940f, -0.03318552f, -0.11520524f, 0.24350919f, -0.15511946f, 0.05283557f, 
    0.02135739f, -0.17779259f, -0.21092236f, -0.12847556f, -0.14866242f, -0.08350632f, -0.08360764f, 0.17496233f, 
    0.02322513f, 0.15850712f, 0.09041179f, -0.06477834f, 0.12139938f, 0.08537357f, 0.04594202f, 0.18139666f, 
    0.00849069f, 0.09977300f, 0.01494749f, 0.07082941f, 0.04375491f, -0.03511752f, -0.23804532f, -0.06316844f, 
    -0.13655475f, -0.05646885f, 0.18428409f, -0.00634039f, -0.07880956f, -0.18296117f, -0.05084541f, -0.06712458f, 
    0.20162986f, -0.13711075f, 0.12089409f, -0.10849578f, -0.07014644f, 0.05193584f, -0.01660189f, 0.02403131f, 
    0.08793058f, -0.07145122f, 0.12573546f, -0.06191218f, 0.16986948f, 0.04765876f, -0.05236356f, -0.08899960f, 
    -0.19850628f, -0.07881862f, -0.00097311f, -0.02738318f, -0.02048222f, 0.02066348f, -0.04361353f, -0.02656377f, 
    0.15421569f, 0.17084363f, 0.11591795f, 0.15133865f, 0.03406710f, 0.07012483f, 0.05684571f, 0.00118643f, 
    0.08222858f, 0.01707124f, -0.04072430f, -0.00524780f, -0.08683901f, 0.14823145f, 0.06625807f, 0.29477510f, 
    -0.02333343f, 0.06937672f, 0.05927814f, -0.14456107f, 0.18141048f, -0.12221079f, -0.02043374f, 0.04932178f, 
    0.49794957f, -0.19159833f, -0.29758441f, -0.21949580f, -0.00440021f, -0.02484384f, 0.03730787f, 0.07761703f, 
    0.03073460f, -0.05115143f, 0.03660135f, 0.07508888f, -0.35008001f, 0.05970572f, -0.03384180f, -0.10980639f, 
    -0.06422673f, -0.03430862f, 0.03113688f, -0.14565206f, -0.06566968f, 0.03361864f, -0.15122612f, -0.02597115f, 
    0.24977164f, 0.25566804f, -0.11891751f, 0.05871306f, -0.00728909f, 0.03003804f, -0.10126125f, -0.09558114f, 
    0.01779348f, -0.03948514f, -0.08685390f, -0.00246870f, 0.02793093f, 0.18720664f, -0.01909454f, 0.10360703f, 
    0.09749111f, -0.01349111f, 0.06763305f, 0.03085957f, 0.05304815f, -0.18870229f, -0.22170921f, -0.17553395f, 
    0.09058706f, 0.04723537f, 0.02621290f, -0.00420497f, -0.10809960f, 0.02562499f, 0.21559258f, -0.00114059f, 
    0.01993352f, -0.08702423f, -0.01893789f, 0.08367340f, -0.02563035f, -0.08254220f, 0.05697986f, 0.11061623f, 
    0.00463110f, 0.03536097f, -0.06570265f, 0.04773579f, 0.06046458f, -0.06019046f, 0.02600195f, -0.00979945f, 
    -0.24740566f, 0.38386026f, -0.37407550f, 0.18556453f, -0.00928008f, 0.13832881f, -0.04478869f, -0.08062759f, 
    -0.09335514f, 0.15140964f, -0.35037264f, 0.01558373f, 0.19586851f, 0.08919372f, 0.18140069f, 0.30876985f, 
    0.00279096f, -0.05222798f, 0.02655718f, -0.09280351f, -0.05310856f, 0.08373268f, -0.05814671f, -0.14492741f, 
    0.09117376f, 0.21520191f, 0.07583386f, -0.00012621f, -0.06075331f, -0.02712261f, 0.00740538f, -0.02535059f, 
    0.02652514f, 0.12580417f, -0.01006948f, -0.00569011f, 0.13782312f, 0.04934633f, -0.12493537f, 0.09251529f, 
    0.04894852f, -0.01341675f, -0.01151028f, 0.00954815f, 0.17952897f, 0.12834255f, -0.00439885f, 0.06556622f, 
    -0.42270309f, 0.07430270f, -0.06844791f, 0.12907280f, -0.05447558f, -0.07999220f, -0.03046815f, 0.01098712f, 
    -0.06496812f, -0.09526780f, 0.00448255f, -0.03861899f, 0.08429176f, 0.09081473f, -0.04562969f, -0.07919557f, 
    -0.02399586f, -0.06136658f, 0.02597742f, -0.03805295f, 0.02757149f, 0.17410444f, -0.13180195f, -0.00003898f, 
    -0.02104504f, 0.07851011f, -0.10121635f, 0.08371887f, 0.23577316f, -0.00855050f, -0.08632796f, 0.02042618f, 
    -0.07587165f, -0.04275965f, -0.11413047f, -0.00878295f, -0.09780319f, 0.00053914f, 0.27620375f, 0.15178645f, 
    -0.11181080f, -0.16695191f, 0.00815143f, 0.09063236f, -0.14013784f, 0.01180703f, -0.03560076f, -0.03750831f, 
    0.22813167f, 0.03210442f, 0.15431733f, -0.18338653f, -0.01573817f, -0.04924343f, 0.04116740f, 0.07700594f, 
    0.06212078f, 0.06462809f, 0.01036554f, -0.02772325f, -0.12297291f, -0.00676024f, 0.07732928f, 0.03859360f, 
    0.01931601f, 0.08707501f, -0.10097536f, 0.10159034f, -0.03124035f, 0.00601613f, -0.07381780f, -0.04650524f, 
    -0.09382862f, 0.01357775f, 0.15638790f, 0.00004905f, 0.13379766f, 0.16761327f, 0.12241391f, -0.03904002f, 
    0.03526163f, 0.03436730f, 0.01861175f, -0.16544458f, -0.05872886f, -0.20257494f, -0.11909851f, 0.08986595f, 
    -0.11535711f, 0.08156839f, -0.20442392f, -0.00335562f, -0.06948864f, -0.04095000f, -0.09615602f, -0.09061029f, 
    0.21234082f, 0.07141241f, -0.04625689f, 0.25525072f, -0.10740554f, 0.03990215f, -0.17484112f, -0.01752389f, 
    -0.05599824f, -0.01679414f, -0.10708477f, 0.01301671f, 0.23330784f, 0.02456367f, -0.09402519f, -0.14214292f, 
    -0.01256974f, -0.03815963f, -0.07610700f, -0.17296591f, 0.12225840f, 0.12225608f, 0.09383754f, -0.07484128f, 
    0.08447149f, 0.03780847f, 0.10853139f, 0.20620519f, 0.17396614f, 0.01629744f, -0.01409699f, 0.09200409f, 
    -0.11789482f, -0.04185871f, -0.08323351f, -0.08048776f, 0.07513884f, 0.32965961f, 0.01353951f, 0.15876494f, 
    0.05523494f, -0.11596549f, -0.10148275f, 0.03650899f, 0.08679780f, 0.03364896f, 0.05769972f, -0.00136670f, 
    -0.31492513f, -0.10284600f, 0.12950934f, -0.17824003f, 0.04416328f, -0.15525497f, -0.01904431f, 0.01959448f, 
    -0.09142113f, -0.10195499f, 0.03624813f, 0.05950989f, -0.00816661f, 0.01227676f, -0.18241747f, 0.10279994f, 
    -0.04993495f, -0.00836581f, 0.04568655f, -0.14605491f, 0.05015562f, 0.02321411f, 0.06677238f, 0.04543406f, 
    -0.27150810f, 0.18445356f, -0.00645760f, 0.04966829f, 0.03972853f, -0.03807798f, 0.13797243f, 0.00331165f, 
    -0.00937223f, -0.04303567f, 0.19833916f, -0.21432197f, -0.32660392f, 0.07344981f, 0.14915618f, 0.04708205f, 
    -0.23679072f, -0.09683292f, 0.05305608f, 0.11368231f, 0.00266874f, -0.01771999f, 0.02629920f, 0.05356432f, 
    -0.08413333f, 0.27418637f, 0.09998990f, -0.27028388f, -0.08049841f, -0.03414382f, 0.04463801f, -0.04582911f, 
    0.03127236f, -0.02061657f, 0.19481795f, -0.04436381f, 0.25157067f, -0.19234595f, 0.23036645f, 0.00005775f, 
    0.04940543f, -0.12261353f, 0.02878285f, 0.04391479f, 0.00597379f, 0.06774794f, -0.04864949f, 0.01195129f, 
    0.05406018f, 0.08599772f, 0.06881843f, 0.04133587f, 0.04964895f, 0.08288908f, -0.06969932f, 0.10109556f, 
    0.01437533f, -0.07870572f, -0.00173209f, -0.03368595f, 0.05444551f, 0.22374831f, 0.18381633f, -0.13577460f, 
    -0.11166714f, 0.09381136f, 0.14990421f, 0.03857987f, -0.16715065f, -0.08224416f, -0.01682135f, 0.07787187f, 
    0.08241922f, 0.11968660f, 0.07144031f, 0.11358729f, -0.06797359f, 0.01237526f, 0.05614284f, -0.03498553f, 
    0.12561414f, 0.05929630f, -0.05566771f, 0.26215056f, 0.15063038f, 0.10037657f, -0.04025745f, 0.09313174f, 
    -0.05642725f, 0.04044080f, -0.00967216f, -0.04683657f, -0.02993464f, -0.07962631f, -0.05215654f, 0.16911460f, 
    0.17001136f, 0.02521600f, -0.10322502f, 0.35493362f, 0.05447164f, -0.03066269f, -0.03120502f, -0.10127127f, 
    -0.03931424f, -0.02494394f, 0.07035791f, 0.04517007f, 0.12632461f, -0.14283302f, 0.28244594f, -0.13666885f, 
    -0.10705740f, -0.19643946f, -0.10488210f, -0.09547842f, -0.00085230f, -0.03417417f, -0.00042005f, -0.00324163f, 
    -0.00727032f, 0.11238857f, 0.01424918f, 0.00579375f, 0.04520360f, 0.08456693f, -0.07598778f, -0.06240172f, 
    -0.00798948f, 0.01371672f, 0.20879260f, 0.05044467f, 0.03500974f, 0.30098704f, 0.18348905f, 0.20924008f, 
    -0.12253907f, 0.09246413f, -0.14430855f, -0.17121887f, -0.04809271f, -0.03801109f, -0.11467873f, -0.18023312f, 
    0.26433855f, -0.28168675f, -0.18914317f, -0.11158708f, -0.03621890f, 0.31439394f, 0.07980623f, -0.02649557f, 
    0.02849395f, 0.04942710f, -0.06953178f, 0.00799260f, 0.06933650f, 0.09637448f, 0.02072559f, 0.03967458f, 
    -0.00076891f, -0.06755855f, -0.01903931f, 0.00580945f, 0.12181100f, 0.15601736f, 0.14443392f, 0.02009377f, 
    -0.03246043f, -0.07717197f, 0.23510802f, 0.00970914f, 0.02175307f, -0.10252420f, -0.06175958f, -0.03909536f, 
    -0.02536852f, 0.13493316f, 0.02446954f, 0.28035358f, 0.15886930f, 0.02618106f, 0.03155376f, 0.02158299f, 
    0.02588365f, -0.00124193f, 0.01274675f, 0.01148002f, 0.16689369f, 0.01794676f, -0.21635891f, 0.04870432f, 
    0.13693595f, 0.19697954f, 0.23870905f, 0.12473496f, 0.00549994f, 0.00212726f, 0.03327394f, 0.03516301f, 
    -0.10435963f, 0.07878664f, -0.06132913f, -0.02609936f, 0.09465957f, 0.06738407f, -0.06794967f, 0.03837332f, 
    -0.08794909f, 0.03992939f, -0.09731768f, -0.10818981f, 0.01416137f, -0.06137907f, -0.13823240f, -0.15896149f, 
    0.11743981f, -0.11368936f, -0.13883980f, 0.17626175f, 0.01940484f, -0.17010167f, -0.17910744f, -0.11356542f, 
    -0.02018603f, -0.10538264f, -0.11151965f, 0.11269563f, 0.22448146f, 0.11339106f, 0.08972748f, 0.19612472f, 
    0.02777788f, -0.02286403f, -0.09210244f, -0.04944677f, 0.01602458f, 0.15896377f, -0.02847186f, 0.03686658f, 
    0.06942476f, 0.09455042f, -0.00774027f, 0.16770926f, 0.03496412f, -0.01599735f, 0.06795678f, 0.04537103f, 
    0.01869623f, -0.12417847f, 0.10237539f, -0.11286794f, 0.19872411f, 0.28300273f, 0.14051494f, 0.15251778f, 
    -0.10815016f, 0.13896812f, -0.03532472f, -0.18058698f, -0.05542608f, 0.03356547f, -0.02009698f, -0.00564991f, 
    0.15484057f, 0.13696198f, 0.06692517f, -0.12033916f, 0.22156076f, -0.11457074f, -0.03307418f, 0.15057549f, 
    -0.16278680f, -0.01902154f, 0.13641153f, -0.07430306f, 0.13726607f, -0.03068343f, 0.10379504f, 0.08667572f, 
    -0.14271972f, -0.09408120f, 0.00919416f, -0.02233520f, 0.00489016f, 0.03229123f, -0.11322325f, -0.03179188f, 
    0.33475539f, -0.09817064f, 0.30687147f, -0.32323688f, -0.02337463f, 0.07255129f, 0.05393492f, -0.24470387f, 
    0.20328975f, -0.11589976f, 0.18515480f, -0.13351764f, 0.11492386f, 0.21169350f, -0.23774804f, 0.27919707f, 
    0.10729185f, 0.00657426f, -0.06802141f, -0.00246423f, -0.03854783f, 0.08298816f, 0.12806132f, -0.04777898f, 
    0.10824939f, -0.12954490f, -0.12596291f, 0.42123431f, 0.10153849f, 0.04279580f, -0.04585771f, -0.02449789f, 
    0.11989752f, -0.09307755f, 0.06788989f, 0.09932460f, -0.05021983f, -0.10406793f, -0.17355274f, 0.04794548f, 
    -0.02918395f, -0.04275789f, -0.01715136f, 0.06381868f, -0.08008350f, -0.04148466f, -0.11280504f, 0.21102443f, 
    -0.06658743f, 0.04596733f, -0.27902290f, 0.22464064f, -0.26529631f, -0.01768541f, 0.08810873f, 0.06654648f, 
    -0.10652631f, 0.04562636f, 0.20545931f, 0.05141657f, -0.00354026f, 0.03338335f, -0.05807726f, -0.08767749f, 
    -0.11524449f, -0.03444990f, -0.01357148f, -0.11148217f, -0.02951750f, -0.03657085f, -0.11263568f, -0.07937314f, 
    0.21636611f, -0.23010944f, 0.26370630f, -0.04840216f, 0.05802569f, 0.19388624f, -0.03225042f, -0.06787740f, 
    0.09257933f, 0.22328249f, 0.00899928f, 0.04275391f, 0.21354741f, 0.17530414f, -0.11678477f, -0.03899032f, 
    0.05419336f, 0.04226447f, -0.12539253f, -0.04010212f, -0.03383303f, 0.08179705f, 0.13840875f, 0.17419976f, 
    0.03833750f, 0.11058814f, 0.13873127f, 0.23290622f, 0.14766966f, 0.09385472f, 0.07425942f, -0.14783181f, 
    0.03738191f, 0.04569568f, -0.05889348f, -0.05501320f, -0.01721438f, -0.37166542f, 0.37066966f, -0.02105816f, 
    -0.06959859f, 0.31623018f, 0.15544619f, 0.00677585f, 0.10709587f, -0.13731393f, 0.00240740f, -0.04140677f, 
    0.00846994f, 0.04240075f, 0.19103295f, 0.23806824f, -0.10297374f, -0.08866534f, -0.03906523f, -0.09334073f, 
    -0.06344330f, 0.02859296f, -0.03510626f, -0.05551635f, 0.08495790f, -0.07063212f, 0.09769757f, 0.24189484f, 
    0.05632687f, 0.01717968f, 0.01598943f, 0.18116465f, 0.00111559f, -0.26171607f, 0.06591175f, 0.06147322f, 
    -0.02462008f, 0.10639358f, -0.01744808f, 0.09503110f, -0.10045417f, 0.11027943f, -0.02965522f, 0.07774875f, 
    -0.04798283f, -0.10501821f, -0.06725059f, -0.08554608f, 0.05168582f, 0.09456296f, 0.09713949f, 0.05254625f, 
    0.01329525f, 0.03286512f, 0.00826633f, 0.11599722f, -0.11521586f, -0.06914275f, -0.01753725f, -0.08109821f, 
    0.21983345f, 0.12150060f, 0.09296430f, -0.13814150f, -0.01370228f, 0.03495502f, -0.01545968f, 0.09596550f, 
    0.01534504f, 0.00414086f, -0.11722266f, 0.22678740f, -0.04215053f, -0.20093274f, -0.05246781f, -0.13111185f, 
    0.09483322f, -0.02052499f, -0.12426366f, 0.13918597f, -0.01680681f, 0.01305581f, 0.19945759f, 0.07387720f, 
    0.14519149f, -0.05513747f, -0.21500365f, 0.16948222f, 0.04669691f, -0.03826394f, 0.07680984f, -0.01244590f, 
    -0.06076182f, -0.04480458f, 0.01321014f, 0.05227382f, -0.07278721f, -0.05493913f, 0.12239900f, 0.10061826f, 
    0.04818616f, 0.10055588f, -0.07691403f, -0.07198405f, -0.01969743f, 0.13261297f, 0.12385822f, 0.08694189f, 
    0.20172399f, -0.21308503f, -0.01375248f, 0.03501240f, -0.01471103f, 0.02728610f, 0.04049904f, 0.10169414f, 
    -0.04195447f, 0.03274538f, -0.01984608f, 0.08916742f, 0.12471100f, -0.04056113f, 0.10196586f, 0.07708699f, 
    -0.03864705f, -0.05554585f, 0.03495698f, 0.14501660f, 0.05947253f, 0.00082836f, 0.01360682f, -0.10375159f, 
    -0.15536273f, -0.06308569f, 0.05228900f, -0.07299089f, 0.01535104f, -0.01291651f, -0.13718833f, -0.03525853f, 
    -0.07296601f, -0.10771953f, 0.08917526f, 0.04535587f, 0.29598844f, 0.23202699f, -0.11469053f, -0.05488306f, 
    0.03811894f, 0.04257934f, 0.23830810f, 0.04609674f, -0.04915335f, -0.01235287f, 0.01452041f, 0.02977744f, 
    0.14622776f, 0.11879725f, 0.24077068f, -0.16371474f, -0.15049338f, 0.01385546f, -0.23623741f, 0.01289356f, 
    0.04087954f, 0.05370552f, -0.06674869f, -0.07815026f, 0.29270014f, 0.24804519f, 0.10837979f, 0.17145444f, 
    -0.10637800f, -0.04070640f, 0.03925331f, 0.17748609f, 0.07653807f, -0.08930777f, -0.04526395f, -0.03076795f, 
    -0.19324362f, -0.16031753f, -0.06540643f, -0.02176876f, -0.01525068f, -0.06988616f, -0.02532023f, -0.01567506f, 
    0.06457770f, 0.01294622f, 0.07305357f, 0.18723026f, -0.06182020f, -0.12701242f, 0.01168004f, -0.01677127f, 
    -0.04532102f, -0.02260987f, -0.05446468f, 0.02345450f, -0.02888631f, 0.00263464f, -0.03821164f, -0.07801227f, 
    0.20707023f, 0.30760953f, -0.05378478f, -0.23193692f, -0.15933649f, 0.10412183f, 0.06094913f, 0.05228690f, 
    0.08958703f, 0.00185832f, -0.00830288f, 0.00753225f, -0.18734734f, -0.06435401f, 0.04380199f, 0.02824472f, 
    0.06024051f, -0.11361569f, 0.08786360f, -0.04585978f, 0.04585562f, 0.01636664f, 0.04670411f, 0.10396519f, 
    0.01459745f, 0.09793341f, 0.08959227f, -0.05288868f, 0.12477918f, 0.10105959f, 0.08082631f, 0.00574143f, 
    0.07010014f, 0.07925122f, 0.02450138f, 0.14860797f, 0.15150604f, -0.03594301f, -0.16929874f, 0.04348088f, 
    0.24241935f, 0.11358328f, -0.00655349f, 0.08450853f, -0.04794404f, -0.03497133f, -0.03791017f, 0.00051877f, 
    0.09873614f, -0.10627994f, -0.12980965f, 0.22267592f, 0.01417140f, 0.01191594f, -0.10301911f, 0.11872213f, 
    0.05561306f, 0.00941333f, 0.19344661f, -0.02735902f, -0.00506968f, 0.18188787f, 0.07767032f, 0.03866831f, 
    -0.02137836f, -0.03021878f, 0.01362600f, -0.08428264f, -0.02202036f, 0.10470074f, 0.01181772f, 0.12166923f, 
    -0.01447716f, 0.09088771f, 0.12017941f, -0.06836379f, -0.02067889f, 0.10753547f, -0.03424999f, 0.00148075f, 
    0.02767993f, 0.05801524f, 0.05037820f, 0.18399461f, 0.13468242f, 0.14066616f, 0.10101376f, -0.15382622f, 
    0.29169407f, 0.14463055f, 0.09597542f, 0.25095874f, 0.01160374f, 0.12368616f, 0.04579508f, 0.10862615f, 
    0.15390851f, 0.31946394f, 0.06770399f, -0.01061412f, 0.23781259f, 0.26061878f, 0.09765948f, 0.20316334f, 
    -0.01759611f, -0.04265178f, -0.03683445f, 0.06087663f, -0.18079340f, -0.09332492f, 0.02045150f, -0.07961994f, 
    0.01980054f, 0.02830375f, -0.13422550f, 0.15964885f, -0.11427931f, 0.08236859f, -0.17417422f, -0.10003655f, 
    0.10604957f, -0.07439328f, -0.06708296f, 0.18483129f, 0.05241257f, 0.09590571f, 0.00160036f, -0.18297963f, 
    0.08378138f, 0.12745717f, 0.10306033f, 0.16299236f, -0.36975342f, -0.15097322f, -0.22831364f, 0.03534746f, 
    -0.08096281f, -0.08179447f, -0.10931815f, -0.06621736f, -0.04635482f, -0.00037559f, 0.05846301f, 0.02188587f, 
    0.10032403f, 0.02593055f, -0.18878318f, -0.21617422f, 0.08982492f, 0.12451463f, 0.10604414f, 0.18686269f, 
    -0.07760328f, 0.09559873f, -0.00860037f, -0.03583127f, 0.20237058f, 0.02622810f, 0.02403522f, 0.11425784f, 
    0.12431682f, 0.05275702f, 0.03861324f, 0.04322967f, -0.03046122f, 0.12547489f, -0.11288885f, -0.09937477f, 
    -0.06817929f, 0.17998947f, 0.10246046f, -0.07215405f, -0.06685497f, 0.10862564f, -0.09446092f, 0.01765417f, 
    0.11765490f, -0.03240683f, 0.08384987f, -0.03367687f, 0.08402809f, 0.02063556f, -0.15129712f, -0.33297908f, 
    0.20404261f, 0.08945671f, -0.07848534f, 0.16000730f, 0.03673818f, 0.13103385f, 0.01996588f, 0.05439293f, 
    0.08582139f, 0.10598084f, -0.00926441f, 0.01150817f, 0.04253488f, -0.01747163f, -0.02750621f, -0.00541363f, 
    0.01987366f, 0.07229838f, 0.00342944f, 0.01292030f, 0.37389478f, -0.13618098f, -0.37471336f, 0.03844560f, 
    -0.08788473f, -0.05572325f, -0.04089885f, 0.03915578f, 0.00313501f, 0.00972853f, 0.08679341f, -0.02609840f, 
    -0.34486741f, -0.08924900f, -0.14222983f, -0.09944104f, -0.15388164f, -0.03850869f, 0.00654346f, -0.02072697f, 
    0.01794769f, 0.03557917f, 0.15411009f, 0.18428548f, -0.11067536f, 0.05277331f, 0.29779401f, 0.24966298f, 
    0.04176226f, 0.01206569f, 0.03285230f, -0.03060741f, -0.09189722f, -0.00623260f, 0.01484975f, -0.16497692f, 
    -0.30902544f, -0.17738819f, -0.06585713f, -0.15725841f, -0.01571495f, -0.03258911f, -0.13761114f, -0.01326287f, 
    -0.03428918f, 0.00918870f, -0.01288381f, 0.00898899f, 0.10562865f, -0.08133225f, 0.06592396f, 0.02855517f, 
    0.06927956f, 0.03707569f, -0.05238463f, 0.02437533f, 0.23537962f, 0.09434208f, -0.12452242f, -0.00209350f, 
    0.18931974f, 0.15252723f, 0.02679116f, 0.09628014f, 0.22192632f, 0.21026243f, 0.01067316f, 0.04729132f, 
    -0.06307578f, -0.10695320f, -0.07032289f, 0.04924022f, -0.32717526f, -0.21175446f, -0.16471353f, 0.07564009f, 
    0.07780865f, -0.04142325f, -0.10478088f, -0.07632273f, 0.01264455f, -0.01649908f, 0.05898070f, -0.03061427f, 
    -0.23323300f, -0.09015591f, -0.01657933f, 0.07444298f, 0.01654608f, 0.02036109f, 0.00851132f, 0.02515969f, 
    -0.05953160f, -0.05417351f, -0.04857241f, -0.03396339f, 0.23613438f, 0.28286204f, 0.07001600f, 0.27778471f, 
    0.03946380f, 0.26791763f, -0.00164657f, 0.07954857f, -0.03569683f, 0.05777122f, 0.08226056f, 0.10207964f, 
    0.04676801f, 0.47371522f, 0.09683305f, -0.06772217f, 0.03492149f, -0.00421437f, 0.02080304f, 0.09381963f, 
    -0.05704931f, -0.07304094f, -0.08166499f, 0.22475143f, -0.21242355f, -0.19442280f, -0.03792043f, -0.05155883f, 
    -0.01494368f, -0.06933161f, -0.12435759f, -0.00177890f, -0.10961014f, -0.08236445f, -0.04245530f, -0.06502737f, 
    -0.07388556f, -0.17001523f, -0.16189100f, 0.03033418f, -0.00745301f, -0.04430116f, -0.08358059f, -0.01363114f, 
    0.06750268f, -0.02378711f, -0.24665539f, 0.00499326f, -0.18110876f, -0.10940319f, 0.00101180f, -0.04511150f, 
    -0.00661920f, -0.02391078f, -0.10387472f, 0.03095044f, 0.05230504f, 0.14093588f, 0.00535046f, -0.02525517f, 
    -0.25386089f, -0.08144888f, -0.06645130f, -0.21687903f, -0.03945264f, -0.03289243f, -0.03881274f, 0.06496638f, 
    0.04935385f, 0.03798434f, -0.10397829f, 0.00711528f, 0.18391195f, 0.22147359f, 0.11042043f, -0.09318238f, 
    0.30251724f, 0.27000675f, 0.06984989f, 0.18828547f, -0.01823503f, 0.04229739f, -0.01073665f, -0.04181981f, 
    0.19579722f, -0.16073529f, -0.27818525f, -0.01088473f, 0.02306172f, 0.04861242f, -0.07280450f, 0.02751557f, 
    0.15164439f, -0.00585719f, 0.04621962f, 0.03726180f, 0.16195957f, 0.11171126f, 0.03568877f, -0.00050168f, 
    0.03055779f, 0.03669100f, -0.00333668f, -0.00938048f, -0.08523577f, -0.03775417f, -0.13921493f, -0.04192616f, 
    -0.02253970f, 0.20781367f, 0.16850898f, 0.03654848f, 0.11154784f, 0.08969703f, 0.01903866f, -0.15037560f, 
    0.12295114f, -0.05341754f, 0.07941404f, 0.05365360f, 0.11060963f, 0.10090603f, 0.02041309f, 0.20870940f, 
    0.11842240f, 0.17060460f, 0.04907371f, -0.08266136f, -0.03134111f, 0.06286676f, -0.00562804f, 0.01664214f, 
    -0.05076745f, -0.26563096f, -0.11869354f, -0.00854020f, 0.04531834f, -0.01420822f, -0.25183207f, 0.14311416f, 
    -0.00596854f, 0.05985335f, 0.05525440f, 0.04773501f, 0.05933207f, 0.14209414f, -0.13592838f, -0.11286453f, 
    0.23575473f, 0.07073384f, 0.23096971f, 0.07346146f, 0.04945849f, 0.09232042f, 0.03070266f, 0.12943268f, 
    -0.29687312f, 0.00066145f, 0.06632847f, 0.02849100f, 0.06929023f, -0.00084314f, -0.17584747f, -0.07031862f, 
    0.01013656f, -0.06267899f, -0.02066634f, -0.03204145f, 0.16960046f, 0.30334988f, 0.04325354f, -0.14379981f, 
    -0.09838172f, -0.20413515f, -0.09335231f, 0.19378749f, 0.05473135f, -0.02886529f, 0.05300044f, -0.00893960f, 
    0.15537572f, 0.05992496f, 0.08622434f, -0.09107967f, 0.01521677f, 0.12426431f, 0.07333412f, -0.06363777f, 
    0.10207088f, -0.23098637f, -0.11210953f, 0.00978781f, 0.31154087f, 0.37274429f, -0.12080769f, 0.13980809f, 
    -0.12795022f, 0.09225236f, 0.26924542f, 0.10847921f, -0.05422287f, 0.05596720f, -0.11334104f, -0.05942345f, 
    0.41713467f, 0.38082775f, -0.01880674f, -0.23842414f, 0.18270786f, 0.05896527f, -0.11282167f, 0.03017535f, 
    0.09627488f, -0.00771247f, 0.00202471f, 0.04823937f, 0.15601659f, 0.06410275f, 0.06472819f, 0.02134228f, 
    0.29169112f, 0.24042451f, 0.04646036f, 0.02434995f, -0.04007139f, -0.05088412f, 0.03614844f, 0.07363076f, 
    -0.18628092f, -0.25444683f, -0.06073437f, -0.06657776f, -0.04382319f, -0.10824311f, -0.03078911f, -0.04523410f, 
    -0.01462449f, 0.13242453f, 0.07716160f, -0.04710608f, 0.11521374f, 0.25309008f, 0.27113089f, -0.02315567f, 
    0.01452726f, 0.05511588f, 0.03398511f, 0.07873824f, 0.01666978f, 0.03563124f, -0.19760162f, -0.02424131f, 
    0.14689261f, 0.10530167f, 0.20587181f, 0.11094768f, 0.07186700f, 0.02725341f, -0.04699999f, 0.02883653f, 
    -0.02331453f, 0.01118680f, -0.12491724f, 0.07764965f, -0.01722679f, -0.03023619f, -0.16023400f, 0.13189441f, 
    0.03327087f, -0.15587239f, 0.12014370f, -0.12087236f, -0.07669742f, -0.05868977f, 0.03218998f, 0.14054017f, 
    0.21539710f, 0.09114227f, 0.01429690f, 0.05817987f, 0.16213463f, -0.00827988f, 0.26611400f, 0.15603411f, 
    -0.02387826f, 0.05993775f, 0.07398900f, 0.00810758f, 0.19682530f, 0.07423707f, -0.08768668f, 0.16001648f, 
    -0.00266649f, 0.10481101f, 0.04895206f, -0.02219436f, 0.00032780f, 0.23820922f, 0.06175781f, -0.00022822f, 
    0.22914942f, 0.12205622f, 0.10675179f, 0.16032733f, 0.14116345f, 0.12811068f, 0.18883726f, -0.03479096f, 
    -0.10891730f, 0.07219725f, -0.04174010f, 0.13343012f, -0.12782863f, -0.05374530f, 0.01335394f, 0.04296669f, 
    0.01469104f, 0.07341164f, -0.01518863f, -0.10107951f, -0.02950325f, -0.00348821f, 0.10805194f, 0.03058655f, 
    -0.25462416f, -0.13355257f, -0.01217832f, 0.04421283f, -0.04829758f, -0.00188516f, 0.06011965f, 0.04568135f, 
    0.08581133f, -0.01188487f, 0.17070177f, 0.23883387f, 0.06660430f, 0.26177636f, 0.14688136f, 0.08081864f, 
    -0.02183860f, -0.09139346f, 0.06677956f, -0.04455461f, -0.04732031f, 0.00408126f, -0.09769484f, -0.00918813f, 
    0.23577328f, 0.03232362f, -0.05545051f, -0.08935986f, 0.08642386f, 0.10850951f, 0.20201080f, 0.03537905f, 
    0.04996870f, -0.02099245f, -0.00418079f, -0.01525736f, 0.01496474f, -0.09741694f, 0.12956129f, 0.20719893f, 
    0.18000665f, -0.00215497f, 0.06951769f, 0.04761954f, -0.14759405f, 0.09694208f, -0.11626230f, -0.02283457f, 
    -0.14030848f, -0.08724431f, 0.02888569f, 0.08094825f, 0.02818844f, -0.06216576f, 0.03581347f, 0.00435607f, 
    -0.14656667f, 0.03362822f, -0.01926319f, 0.08738565f, -0.19673505f, -0.04273123f, -0.07556668f, 0.10413313f, 
    -0.07242949f, -0.04176237f, 0.08197940f, -0.08190430f, 0.12455935f, 0.20175645f, 0.00158573f, 0.05471230f, 
    -0.14518712f, 0.03937092f, -0.03739342f, 0.08390171f, 0.04797032f, -0.08253168f, 0.05577677f, 0.10626955f, 
    0.07407045f, 0.26102477f, -0.02915813f, -0.05215729f, 0.04424874f, -0.06248072f, 0.19635539f, 0.21157040f, 
    -0.09806864f, -0.09031241f, -0.02197329f, 0.11461824f, 0.04913800f, 0.05899436f, -0.05906736f, -0.04688632f, 
    -0.62200642f, 0.23786874f, -0.00245652f, -0.04997775f, 0.08751703f, -0.10927529f, 0.35522118f, -0.08355857f, 
    -0.11093042f, -0.01689103f, 0.03419854f, 0.16100718f, -0.24416062f, -0.15457176f, -0.03830501f, 0.01682609f, 
    0.16104046f, -0.06320281f, -0.02858116f, -0.02639304f, -0.03976627f, 0.06095942f, 0.12107072f, 0.16566052f, 
    -0.08463471f, -0.14060324f, -0.13757472f, 0.02327901f, 0.00459818f, 0.10538749f, -0.03972241f, 0.04142904f, 
    -0.07310596f, -0.02804345f, -0.00702239f, 0.03015416f, -0.18475130f, 0.24293847f, -0.06169525f, -0.21234512f, 
    0.05110932f, 0.02110927f, 0.02562030f, 0.02255338f, -0.06799497f, 0.05173272f, 0.05302199f, 0.22312307f, 
    0.19016337f, 0.06342056f, 0.11066788f, 0.31067187f, 0.14179513f, 0.16178648f, -0.08960564f, -0.05477029f, 
    -0.02817579f, 0.02654322f, -0.11049858f, -0.06344509f, 0.04336316f, 0.02154050f, 0.04263387f, -0.10406338f, 
    -0.04697456f, 0.03699803f, -0.10045079f, 0.11290619f, -0.15091878f, -0.03412173f, -0.02488262f, -0.14628305f, 
    0.00047620f, 0.00629294f, 0.08183367f, 0.07440767f, -0.07198868f, 0.13237143f, -0.11025342f, -0.08383150f, 
    -0.08664826f, -0.16204225f, 0.00172528f, -0.06485996f, -0.10617387f, 0.06099487f, -0.04676216f, 0.29366794f, 
    -0.05793156f, 0.07693048f, 0.05026309f, 0.21536438f, 0.14758675f, 0.00979551f, 0.07981014f, 0.06161987f, 
    -0.24733369f, -0.01997442f, 0.12055758f, 0.10542736f, 0.02206859f, -0.04866967f, 0.08138894f, -0.17805503f, 
    -0.17409608f, -0.00201439f, -0.06573588f, -0.02366103f, 0.29070330f, -0.17863947f, -0.06884743f, -0.06480680f, 
    -0.13625321f, -0.03339220f, 0.00800076f, 0.03379588f, -0.04478977f, -0.05384539f, 0.00278775f, -0.26298803f, 
    0.11087961f, 0.06961880f, -0.10417150f, 0.10382681f, -0.03717954f, -0.09922990f, -0.01072416f, 0.06191136f, 
    -0.03327093f, -0.06234285f, -0.07452734f, -0.13490215f, 0.10811993f, 0.26460242f, 0.16657032f, 0.05920508f, 
    -0.15130340f, -0.05219936f, 0.13996668f, -0.24622816f, -0.06054310f, -0.14535622f, -0.03743329f, -0.12031815f, 
    -0.14685458f, -0.29612979f, -0.00477184f, -0.01214206f, -0.06525227f, -0.11612704f, 0.08957475f, -0.02912348f, 
    0.03545456f, 0.09821256f, 0.04071940f, -0.04580203f, 0.21960275f, -0.06021020f, -0.06571535f, -0.06073204f, 
    -0.10899144f, 0.08500225f, 0.25608763f, -0.12546754f, 0.14437497f, -0.13243559f, 0.11173195f, 0.16426699f, 
    -0.03613899f, 0.03760666f, 0.00817257f, 0.01380647f, -0.04862429f, 0.08424377f, -0.14984152f, 0.17986599f, 
    0.03779381f, -0.10476228f, -0.05482454f, -0.19736572f, 0.24868888f, -0.02599953f, 0.12916605f, 0.08713045f, 
    0.09396143f, 0.33603135f, 0.25773752f, 0.05974548f, 0.00710685f, 0.01552387f, -0.10705722f, 0.04473365f, 
    0.12336411f, 0.03841326f, 0.16213174f, 0.32822150f, -0.01357071f, 0.17209105f, 0.06568392f, -0.01619319f, 
    0.08525874f, -0.06481622f, -0.01742188f, -0.00367310f, -0.16542263f, 0.06284671f, 0.18874529f, -0.14162169f, 
    0.00964885f, -0.15382341f, -0.02636826f, 0.03204562f, 0.01009669f, 0.09037220f, 0.01926717f, 0.05146857f, 
    0.02593494f, 0.00920654f, -0.15628298f, 0.15658242f, -0.02457278f, 0.05424903f, -0.08053412f, -0.04374632f, 
    -0.00498152f, 0.02579163f, -0.22196466f, 0.12471246f, 0.20627649f, -0.09160256f, 0.09864554f, 0.40852216f, 
    -0.00672683f, 0.15004502f, 0.08741696f, 0.15894143f, -0.08651921f, -0.07941256f, -0.02582767f, -0.08308215f, 
    -0.28434536f, 0.16364746f, -0.13766347f, 0.30097142f, 0.03117606f, 0.02947507f, -0.17105386f, 0.12527137f, 
    -0.14147234f, 0.08071413f, -0.03552611f, 0.01913603f, -0.11757110f, 0.41899702f, 0.14266023f, -0.01065106f, 
    0.06241714f, 0.19641103f, 0.01464528f, -0.14775333f, -0.03775102f, 0.03921734f, -0.09265152f, -0.09033535f, 
    0.09842063f, -0.12478610f, -0.01729779f, 0.01617608f, -0.00977189f, 0.10475518f, -0.03726812f, -0.02290576f, 
    -0.02231810f, -0.02318386f, -0.07115064f, -0.04045515f, 0.27411857f, 0.25142539f, 0.10901806f, -0.09487599f, 
    0.13913876f, 0.03274278f, -0.11069378f, -0.01646457f, -0.00360454f, -0.02682021f, -0.12998047f, 0.18195574f, 
    0.03546870f, -0.09152436f, -0.27735752f, 0.01669603f, -0.11186817f, 0.03050904f, 0.04848867f, 0.10898896f, 
    0.10161185f, 0.13456398f, 0.11498550f, -0.00943079f, -0.46194130f, 0.03777418f, 0.03984002f, 0.09758815f, 
    0.04088024f, -0.09053579f, -0.04543482f, 0.13489421f, -0.06406067f, 0.05920135f, 0.12405285f, -0.02347399f, 
    -0.17705667f, -0.04192518f, 0.05358235f, 0.00241202f, 0.02861929f, -0.01858971f, -0.03394179f, 0.10415910f, 
    0.08009303f, 0.15269580f, 0.07100780f, 0.08927952f, 0.19681010f, 0.05845733f, 0.18130437f, 0.29015014f, 
    0.03769883f, 0.13330258f, 0.03250343f, 0.21227382f, -0.00002325f, 0.15670091f, -0.08984976f, -0.12102222f, 
    0.05658961f, -0.07040858f, 0.03325276f, -0.24617615f, -0.09324391f, -0.07372202f, 0.15784332f, 0.01261217f, 
    0.21641108f, 0.03670118f, 0.01110559f, 0.06236470f, 0.31561953f, -0.31123605f, 0.03019732f, 0.01443372f, 
    -0.00856290f, -0.15976903f, 0.04359215f, 0.12356386f, 0.05677904f, -0.04067801f, 0.00964495f, 0.08199965f, 
    -0.37807962f, 0.08627702f, -0.01180825f, 0.17954394f, 0.12668452f, 0.13460520f, -0.09242295f, -0.09639841f, 
    -0.08730714f, 0.10796154f, 0.16911340f, -0.06992871f, -0.14823611f, -0.13553542f, -0.17955540f, -0.07345507f, 
    -0.02605523f, 0.06414477f, 0.10698617f, 0.02012736f, 0.15006247f, 0.13442533f, 0.10896885f, 0.06303684f, 
    0.01945450f, 0.05645206f, -0.02638512f, 0.14685272f, -0.01863793f, 0.05234269f, -0.01145627f, -0.03412375f, 
    0.09670258f, 0.07410103f, 0.19509484f, 0.09210560f, -0.08732962f, 0.07549836f, -0.22455764f, -0.14753553f, 
    -0.05966234f, 0.02668310f, 0.08218360f, 0.03126910f, -0.08375062f, -0.03045327f, 0.26367012f, 0.01289009f, 
    0.03882896f, -0.15604420f, -0.24793094f, 0.18247637f, -0.05035945f, 0.14320089f, -0.13219061f, -0.21834868f, 
    -0.02455310f, -0.08023649f, 0.21458815f, 0.00988691f, -0.14908423f, -0.11104798f, -0.07606652f, 0.16206133f, 
    -0.10759625f, -0.05200516f, 0.06304301f, -0.01910681f, 0.01116607f, 0.06349529f, 0.00571602f, 0.04000685f, 
    -0.17568628f, 0.22654893f, 0.42800316f, 0.13523604f, -0.01147404f, 0.08739527f, 0.12344775f, -0.09475517f, 
    -0.01352100f, 0.03867763f, -0.11372343f, -0.04841676f, -0.10741364f, -0.11880857f, -0.09675161f, 0.04040557f, 
    0.02980603f, 0.09277096f, 0.02971674f, 0.12790896f, 0.02502826f, 0.09342170f, 0.30107436f, 0.15241666f, 
    -0.19012499f, 0.15160508f, -0.13500828f, -0.01065163f, -0.02424490f, 0.09430354f, -0.09208987f, -0.13434614f, 
    -0.28445578f, 0.00081897f, -0.14212123f, 0.00131779f, -0.22061823f, -0.13204026f, 0.03224389f, 0.14209250f, 
    -0.00634990f, -0.02922477f, -0.04886065f, 0.08455698f, -0.05291903f, -0.04766314f, -0.09831655f, 0.04423090f, 
    -0.12213242f, 0.03293020f, -0.02595765f, 0.27839097f, 0.10029082f, 0.17378712f, 0.08029570f, -0.43545493f, 
    0.05283507f, -0.18396653f, -0.15667693f, 0.04864559f, 0.01108391f, -0.04053945f, 0.27301559f, 0.17745496f, 
    -0.03868020f, 0.15830211f, -0.20831841f, 0.06433338f, 0.01749174f, -0.09328828f, -0.01032015f, -0.23882465f, 
    0.00323666f, 0.20452046f, -0.27210325f, 0.21189085f, -0.19127589f, -0.11266088f, 0.15568432f, -0.12404928f, 
    0.06181073f, 0.02059768f, 0.03546028f, 0.01472676f, -0.27083772f, -0.15957955f, 0.24655442f, 0.19143774f, 
    0.06631152f, 0.19708332f, 0.13281308f, -0.30864039f, -0.04879189f, -0.08208979f, -0.10274054f, 0.00553286f, 
    0.03339643f, 0.28128433f, -0.22981231f, 0.10434896f, -0.01086802f, -0.03007435f, 0.05126954f, 0.06811653f, 
    0.10057691f, 0.14594218f, -0.02130755f, 0.15439135f, -0.04825808f, -0.20132531f, 0.42689523f, -0.03526136f, 
    0.16906969f, 0.15350880f, -0.09018447f, -0.08169225f, 0.10269696f, 0.03311978f, 0.15898836f, 0.05231198f, 
    -0.16436791f, 0.10399432f, 0.18730342f, 0.32162955f, 0.04662905f, 0.11527684f, -0.07543765f, -0.06975158f, 
    -0.06736668f, -0.09570179f, -0.15850230f, 0.08579253f, -0.20378187f, -0.03728258f, 0.17887996f, 0.25572789f, 
    0.09659942f, -0.05596646f, 0.00889200f, 0.28146720f, 0.02082206f, 0.08626737f, 0.04729515f, -0.10519101f, 
    0.02589021f, 0.28118089f, 0.01632796f, 0.14945401f, -0.02998164f, 0.10756732f, 0.02979032f, 0.03901463f, 
    -0.09053846f, -0.10318913f, -0.09949899f, 0.03580574f, -0.05568529f, -0.13532969f, -0.10948180f, 0.11732998f, 
    -0.02270581f, 0.00799851f, 0.12845516f, -0.09837197f, 0.05869001f, 0.05929746f, 0.23635188f, 0.05863506f, 
    -0.27976248f, -0.02794955f, -0.26441696f, 0.10807229f, -0.16994551f, -0.04099461f, 0.13590127f, 0.21860440f, 
    0.01553894f, 0.06474002f, 0.15043104f, 0.16938239f, 0.19400148f, 0.09354956f, 0.22342002f, -0.33458263f, 
    0.04130959f, 0.06390452f, -0.29719979f, 0.12647913f, -0.07645316f, 0.18473554f, 0.09985100f, -0.10434183f, 
    0.17917356f, 0.12547456f, 0.12909290f, 0.28232121f, 0.00766467f, 0.06228903f, -0.02740435f, 0.14608887f, 
    0.07408859f, -0.09266366f, -0.10227522f, 0.04815349f, 0.10075068f, 0.19742416f, 0.19680381f, 0.15467188f, 
    -0.06980040f, -0.12056431f, -0.02224952f, -0.11151046f, 0.06851442f, 0.02919244f, -0.12770842f, -0.05148788f, 
    -0.03276882f, 0.11162598f, -0.00207770f, -0.06376079f, -0.04001467f, -0.10425918f, -0.09751105f, -0.15261285f, 
    0.09795707f, -0.01186977f, 0.00395922f, 0.00815580f, 0.07282830f, 0.13958608f, 0.07839954f, -0.04048704f, 
    0.15607771f, 0.06850880f, -0.04822755f, -0.02586403f, -0.12744276f, -0.00461824f, -0.07627065f, -0.00634211f, 
    -0.25321019f, -0.01382486f, 0.01357883f, -0.04884530f, -0.01372194f, 0.04265549f, -0.02801520f, -0.01224569f, 
    0.02640114f, -0.05537521f, -0.06677165f, -0.13733265f, 0.18155175f, 0.18438816f, 0.12502328f, 0.25411218f, 
    0.10047458f, 0.06104191f, 0.05528780f, -0.11271122f, 0.06521019f, 0.09193169f, 0.20810199f, 0.16072376f, 
    -0.01899777f, 0.26487193f, 0.10348226f, 0.24799061f, -0.02610959f, -0.06888514f, -0.08730212f, -0.00106793f, 
    -0.06509954f, 0.00317834f, 0.03543143f, -0.03759141f, 0.12163438f, 0.07062717f, -0.12244637f, -0.05844919f, 
    -0.16499718f, -0.08659769f, 0.23174186f, 0.01047601f, 0.12847970f, 0.01335719f, 0.08307816f, 0.17789613f, 
    -0.07864838f, 0.29795244f, -0.02349006f, -0.06600291f, -0.05536254f, 0.09408552f, -0.04916722f, 0.04662988f, 
    0.11830958f, -0.04579729f, -0.02220201f, -0.12101088f, 0.09486455f, -0.10692628f, -0.12964281f, -0.10418043f, 
    0.05921405f, 0.17518517f, -0.02039568f, 0.04147068f, 0.01180797f, 0.13077632f, -0.00168839f, 0.00423164f, 
    0.01910716f, -0.04636428f, -0.08667631f, -0.05702064f, 0.02422403f, 0.01322528f, 0.00273846f, 0.04240404f, 
    0.00777395f, 0.11948263f, -0.03157583f, 0.01990505f, -0.12217281f, 0.13400246f, 0.06218236f, -0.09999622f, 
    -0.07015930f, -0.17924507f, 0.02544267f, -0.05457802f, -0.08160038f, 0.02397111f, 0.01761151f, -0.02774936f, 
    0.13787039f, -0.52141339f, 0.30880755f, 0.10102634f, 0.12556796f, -0.05927791f, 0.01626508f, -0.02903342f, 
    0.11841360f, 0.11195501f, 0.15876369f, 0.05523134f, -0.17234209f, 0.14309071f, 0.08534016f, -0.23987852f, 
    0.00087076f, -0.00080190f, -0.09509276f, -0.04407395f, 0.09675535f, 0.02143574f, 0.08243152f, 0.15053554f, 
    0.06269510f, -0.05112104f, 0.07342063f, 0.11431652f, 0.05146518f, 0.01817977f, 0.03500844f, 0.05652254f, 
    0.02010764f, -0.03829142f, -0.01031129f, -0.09018226f, 0.07993012f, -0.10701670f, 0.09236666f, -0.12030074f, 
    0.08574092f, 0.03530978f, 0.06814398f, 0.05653713f, -0.05170607f, 0.12107319f, 0.06143208f, 0.01968045f, 
    0.13090844f, -0.31711313f, 0.12369258f, 0.41718820f, 0.10271619f, 0.08588710f, -0.10869680f, -0.09017881f, 
    0.04521906f, 0.04061241f, -0.01688924f, 0.06136940f, -0.07704193f, -0.09694859f, -0.07467423f, 0.09523384f, 
    0.05448985f, 0.12596372f, 0.04090061f, -0.02966391f, -0.08019849f, -0.10296716f, 0.08905213f, -0.03605054f, 
    -0.08605984f, -0.26497653f, -0.04792907f, 0.01657178f, 0.03421332f, 0.14524309f, 0.08455499f, 0.04244098f, 
    0.05820893f, -0.08653051f, -0.03317872f, -0.13080715f, 0.05575870f, 0.04666148f, -0.01732497f, -0.28888166f, 
    0.12695938f, 0.09537130f, 0.04653225f, -0.15437579f, -0.04874524f, -0.06726182f, -0.02608461f, -0.14791317f, 
    -0.03841738f, 0.20702799f, -0.05264067f, -0.14413197f, 0.05298027f, -0.00015898f, 0.09849425f, 0.03842264f, 
    0.07318889f, 0.05676757f, -0.03665864f, 0.08799126f, 0.01284724f, -0.09716440f, -0.09358950f, -0.02953328f, 
    0.08895421f, 0.09793402f, 0.11936920f, 0.06033220f, -0.02408968f, 0.01139785f, -0.01327001f, 0.01248476f, 
    0.01341289f, -0.20995317f, -0.09072088f, 0.11921487f, 0.08318588f, -0.01580488f, 0.00574902f, 0.02539733f, 
    -0.07588886f, -0.09045407f, -0.07633641f, 0.04463787f, -0.16710182f, -0.08509787f, -0.03104617f, 0.10926638f, 
    0.09875862f, 0.01749871f, 0.10843723f, 0.00149001f, 0.06110568f, -0.09676731f, -0.06312514f, -0.00330185f, 
    -0.24985175f, 0.00928445f, 0.22316900f, -0.01863953f, -0.01193327f, -0.01985706f, 0.09238009f, 0.11081678f, 
    0.02978356f, -0.02112648f, 0.02159251f, -0.04986696f, -0.24939200f, -0.00735713f, -0.26526543f, 0.09555466f, 
    0.07632203f, 0.03935417f, 0.18354426f, 0.12149850f, 0.03923950f, 0.05783653f, -0.04321094f, 0.21182287f, 
    -0.07527564f, -0.00662448f, -0.00265467f, -0.28630519f, -0.04742900f, -0.01892734f, 0.07104594f, 0.05795740f, 
    0.08637813f, 0.03058798f, -0.14156111f, -0.09386517f, 0.05691433f, -0.10206559f, -0.08966927f, -0.12185244f, 
    0.10364795f, 0.15982498f, 0.16891511f, 0.15290572f, -0.08529742f, -0.00661944f, -0.04129973f, -0.02534116f, 
    0.00391224f, 0.13570194f, 0.01228565f, 0.17221834f, 0.05498979f, 0.04614320f, 0.04531673f, -0.25183558f, 
    0.12495429f, -0.02562015f, -0.11688118f, -0.09967426f, -0.00164222f, -0.08120313f, 0.25463980f, -0.09042051f, 
    -0.12137702f, -0.07171009f, -0.11467993f, 0.13954294f, 0.07559832f, 0.05755618f, 0.22898486f, 0.16092785f, 
    0.22189969f, -0.23634306f, 0.02170451f, 0.03596421f, 0.04499456f, 0.01093846f, -0.04875650f, 0.09933162f, 
    -0.12231877f, 0.05592425f, 0.01379238f, 0.07499234f, 0.03068003f, -0.00769894f, 0.08892458f, -0.02701276f, 
    0.04746750f, 0.17102785f, 0.09978674f, -0.20028760f, -0.07347861f, -0.11434848f, -0.10929305f, -0.10361313f, 
    0.04188582f, -0.17089422f, 0.04557551f, 0.20390783f, 0.11393165f, 0.07767157f, 0.02117938f, 0.05427863f, 
    0.07371970f, 0.14801972f, -0.00127648f, 0.05855786f, -0.17706481f, 0.16347931f, -0.04476643f, -0.06269412f, 
    0.14019600f, -0.20762756f, 0.13164733f, -0.01370256f, 0.07511006f, 0.02775332f, 0.04488616f, 0.04885332f, 
    -0.04971235f, -0.03822217f, -0.02093806f, 0.00629557f, -0.01231391f, 0.00182213f, 0.04149547f, -0.02043982f, 
    0.01254402f, 0.00383203f, -0.01983633f, 0.02323972f, -0.02825070f, 0.04882123f, -0.28985548f, 0.21847965f, 
    0.09047208f, 0.00511546f, 0.03407595f, -0.07533829f, 0.08075382f, 0.05881577f, 0.08914151f, -0.00029194f, 
    0.05476792f, -0.12692255f, -0.06211894f, -0.06235490f, 0.00872048f, 0.06558783f, 0.06375074f, 0.07579511f, 
    -0.00773482f, 0.01706758f, 0.08547011f, 0.00703781f, -0.00885137f, 0.15168633f, 0.36956742f, -0.08056325f, 
    -0.06628951f, -0.10273506f, 0.00407046f, -0.01519970f, -0.05020446f, 0.12865262f, 0.14559972f, 0.01621219f, 
    -0.21263474f, 0.03821872f, 0.26026541f, -0.12799500f, -0.06790079f, -0.04629775f, 0.05514256f, 0.17405285f, 
    0.00018431f, 0.03938959f, 0.07569841f, 0.07961486f, 0.08041681f, 0.15349835f, -0.24626663f, -0.21826060f, 
    0.11131521f, 0.04893921f, 0.18716933f, 0.01376157f, 0.04189532f, 0.02747068f, 0.02221483f, 0.00685741f, 
    0.04840265f, -0.04062235f, -0.15369983f, -0.02101276f, 0.01820982f, 0.01512097f, 0.09709962f, -0.01513670f, 
    0.07959533f, 0.10257832f, -0.03696390f, 0.22552349f, -0.29242450f, 0.00237125f, -0.04329582f, -0.23967105f, 
    0.12714252f, -0.16830806f, 0.13096742f, 0.01722294f, 0.05287660f, -0.02067672f, 0.05984471f, 0.00452230f, 
    -0.15669775f, -0.18300125f, 0.20917122f, 0.51235056f, 0.05431996f, -0.01976101f, -0.02112662f, 0.08249897f, 
    0.21851744f, 0.07334590f, 0.12241133f, -0.03593684f, 0.03759796f, -0.00251645f, 0.03532489f, -0.05726724f, 
    -0.02560723f, 0.02921757f, 0.02045038f, -0.00019472f, 0.05003775f, -0.01026605f, 0.05231686f, 0.13232231f, 
    0.16283634f, 0.16471560f, 0.03162628f, -0.26316488f, -0.07874873f, 0.02913007f, 0.14118601f, -0.07048898f, 
    0.10368947f, 0.05041589f, 0.23369333f, 0.09713394f, 0.04643468f, 0.00829548f, 0.02634470f, 0.00922225f, 
    -0.00975471f, 0.00125015f, -0.02846426f, 0.02330619f, -0.05110692f, 0.12395285f, 0.05629389f, 0.03638467f, 
    0.20913853f, -0.04428560f, -0.11412743f, -0.12604222f, 0.03775637f, -0.07361422f, 0.07326236f, -0.03597016f, 
    0.14790267f, 0.00701262f, 0.10270638f, -0.00279764f, -0.19124031f, -0.19674540f, 0.13102464f, 0.12565039f, 
    0.02432397f, -0.07780415f, 0.02701478f, 0.05126340f, -0.04903109f, -0.03667955f, -0.01682691f, 0.11207270f, 
    -0.18076968f, 0.10297655f, 0.18509418f, -0.34770164f, 0.08804067f, 0.06075232f, -0.04815285f, 0.08919881f, 
    0.11092112f, 0.20021980f, 0.16822858f, 0.07003285f, -0.12469597f, 0.04555589f, 0.21266077f, -0.03007400f, 
    -0.11247529f, -0.13672748f, 0.00643639f, -0.02945882f, 0.12499987f, -0.02488457f, 0.15356615f, 0.24467406f, 
    -0.01724509f, -0.23641725f, 0.26044261f, 0.06161001f, -0.02735531f, 0.16277407f, 0.01662369f, 0.07823794f, 
    -0.01943110f, 0.08430702f, -0.02883587f, 0.01761902f, -0.13662727f, 0.15323940f, 0.12677526f, -0.18148269f, 
    0.04434796f, 0.04804839f, 0.09722612f, 0.19774601f, 0.03542705f, 0.00082135f, 0.02582209f, -0.03469762f, 
    -0.01575655f, 0.14722528f, -0.08869500f, -0.12413140f, 0.02798337f, -0.13351086f, 0.05944417f, -0.00145738f, 
    0.17975742f, -0.00785952f, 0.01732002f, 0.04196637f, -0.22933884f, -0.09133632f, -0.05090965f, -0.13294953f, 
    0.10638839f, 0.05785971f, -0.02787715f, 0.11118543f, -0.08258808f, -0.08768560f, 0.06442704f, 0.05231761f, 
    -0.11386292f, -0.00879078f, -0.25994790f, 0.03345457f, -0.07276408f, -0.00446144f, 0.04248738f, 0.00737301f, 
    0.02388285f, 0.09387273f, -0.04282779f, 0.10602614f, -0.08884037f, -0.33622175f, 0.06473736f, -0.08821860f, 
    0.16432519f, 0.24580525f, -0.05937859f, 0.04344067f, -0.03633820f, 0.06602303f, 0.03281420f, -0.07837918f, 
    0.02518815f, -0.07934950f, 0.30171511f, -0.09727803f, 0.00098137f, -0.15722403f, -0.21332450f, 0.01015643f, 
    0.08450912f, 0.09712438f, 0.01988595f, 0.04385030f, -0.25910598f, 0.01571911f, 0.04915323f, 0.01342975f, 
    0.17248356f, 0.09468171f, 0.01108591f, -0.09752899f, 0.09810485f, -0.00064894f, 0.02770741f, -0.05173380f, 
    -0.15582718f, -0.26624683f, 0.08374606f, -0.03872918f, 0.21603571f, -0.02203256f, -0.08061720f, -0.04054817f, 
    0.01276752f, 0.02805625f, -0.05584737f, -0.10065258f, -0.05911034f, 0.07693365f, 0.12970404f, -0.06034872f, 
    -0.02530071f, 0.00451846f, 0.14283781f, 0.08199594f, -0.02506859f, -0.03170003f, 0.02991800f, -0.02717992f, 
    -0.00929328f, 0.41980225f, -0.22840960f, -0.01052798f, -0.00641293f, -0.13457428f, 0.16339646f, -0.02216136f, 
    0.13451706f, -0.03987394f, -0.06004576f, 0.01080956f, -0.22072788f, -0.09950139f, 0.07362127f, 0.28753069f, 
    -0.08840907f, -0.08777747f, 0.02805704f, 0.00504445f, 0.07293049f, 0.00241824f, 0.01552265f, 0.07617309f, 
    0.10322094f, -0.03498680f, -0.01854426f, -0.31344765f, 0.02040921f, 0.02735603f, -0.04147397f, 0.19474967f, 
    -0.10258184f, -0.03085995f, -0.01801182f, -0.05416086f, -0.12548821f, 0.27427620f, 0.04507079f, 0.06052659f, 
    0.04408024f, -0.08532612f, -0.13687651f, 0.02730833f, 0.21903636f, 0.03341226f, 0.04187111f, 0.04472362f, 
    -0.17807189f, -0.03401523f, 0.02989600f, -0.11075661f, -0.03966468f, 0.05988099f, 0.07314737f, -0.17975162f, 
    0.07107674f, 0.00225679f, 0.01677976f, -0.03175367f, 0.00504225f, 0.15356986f, 0.11085857f, -0.17813633f, 
    -0.00930083f, -0.07465008f, 0.01853904f, -0.12336341f, 0.03265456f, 0.04860613f, 0.09038649f, 0.06039090f, 
    0.07421624f, -0.13357928f, 0.16902621f, -0.10431395f, 0.11153911f, -0.08241533f, -0.05829268f, -0.04025896f, 
    0.11714026f, -0.03919522f, 0.05999331f, -0.01601891f, -0.02332534f, -0.05237488f, -0.00704305f, 0.01309976f, 
    0.05517287f, 0.11043624f, 0.00181659f, -0.05172437f, 0.09820501f, 0.05905586f, 0.03596395f, 0.06489977f, 
    -0.10413535f, -0.15908915f, -0.11708444f, 0.26167509f, -0.03437021f, 0.04083594f, -0.01028579f, -0.01486432f, 
    0.04417925f, -0.02436736f, -0.09447359f, -0.21187590f, -0.15393892f, -0.09969261f, -0.07633762f, 0.21997571f, 
    -0.01725101f, 0.08461065f, 0.03746788f, -0.21296209f, 0.10495311f, -0.17567781f, -0.04760800f, 0.10075632f, 
    0.02006276f, 0.07520062f, 0.56328142f, -0.02451758f, -0.06305887f, -0.08367035f, -0.15631454f, -0.01167271f, 
    -0.01895849f, 0.16006652f, 0.03569767f, -0.00741364f, -0.05544502f, 0.09238551f, -0.14215456f, -0.23144457f, 
    -0.17690499f, -0.04240587f, 0.10093965f, -0.00688167f, 0.29922682f, 0.01291963f, 0.08105288f, 0.08619703f, 
    0.02365745f, 0.09865572f, 0.08621046f, 0.17168821f, 0.07323787f, -0.02627648f, -0.04186485f, -0.04174077f, 
    0.07145698f, -0.01608040f, -0.01456314f, 0.06848854f, -0.04896497f, -0.06606875f, -0.14268973f, 0.04144556f, 
    0.05273697f, 0.00287546f, 0.03965434f, -0.09108701f, 0.02280834f, -0.11581168f, 0.04969706f, 0.08338249f, 
    0.05040703f, -0.03499861f, 0.00327658f, 0.00109627f, -0.01087011f, 0.00750132f, -0.02084445f, -0.00439639f, 
    0.13008299f, 0.06213832f, 0.13090797f, 0.00633089f, -0.12731682f, 0.01661589f, 0.12635444f, -0.05819842f, 
    0.06768833f, 0.04486582f, 0.13303363f, 0.12178667f, 0.01142295f, -0.08329313f, -0.03174409f, 0.01358955f, 
    0.48154682f, -0.04845701f, 0.06720388f, 0.03004728f, -0.13051161f, 0.05568546f, -0.05127455f, 0.05803064f, 
    0.07722250f, -0.00159342f, 0.20809850f, 0.08482278f, 0.06637114f, -0.10759726f, -0.09767700f, -0.15718794f, 
    -0.00270247f, 0.03259649f, 0.08279957f, 0.05939440f, 0.13654833f, 0.03649594f, -0.05217865f, -0.01549541f, 
    0.17527689f, 0.11096535f, 0.14532597f, 0.15660708f, -0.00538449f, 0.03277482f, -0.02309475f, -0.07374018f, 
    0.03734965f, 0.05646395f, 0.03811913f, 0.11978091f, 0.13623749f, -0.09236288f, 0.28699535f, -0.06513478f, 
    -0.01903966f, 0.02883889f, -0.11298911f, -0.07556528f, 0.06119018f, 0.04788502f, -0.11727629f, -0.00237497f, 
    -0.29444376f, 0.04007138f, -0.08969912f, 0.04268263f, -0.02357550f, 0.02263348f, 0.20890750f, -0.08574098f, 
    0.03924216f, -0.08352409f, 0.03417154f, -0.03021687f, 0.05110051f, -0.03514120f, 0.11703727f, 0.12735003f, 
    0.10307108f, 0.00878462f, 0.04261605f, -0.08809317f, 0.03756783f, -0.06550366f, -0.01400311f, 0.02825596f, 
    -0.10097852f, -0.06812608f, 0.08082049f, 0.19585080f, -0.05145688f, 0.13205186f, 0.02004877f, -0.04947122f, 
    0.03536080f, 0.01412694f, 0.00404965f, 0.03594316f, 0.29228219f, 0.01189280f, 0.06600359f, -0.14124097f, 
    0.15915713f, 0.05240738f, -0.03849358f, 0.08805794f, -0.01322959f, 0.00261807f, -0.03068238f, 0.08445075f, 
    0.11312546f, -0.02552762f, 0.03297577f, 0.06075431f, -0.00338746f, -0.03687964f, 0.06104312f, 0.06724218f, 
    0.21689215f, 0.07579548f, 0.23959701f, 0.26040265f, -0.19433472f, 0.16529898f, -0.14411296f, 0.01415778f, 
    0.13789657f, 0.07696508f, 0.11458392f, -0.14456399f, -0.06600517f, 0.00948505f, 0.01694001f, 0.05342593f, 
    -0.14607935f, -0.07539827f, 0.01964140f, -0.01947447f, -0.02767741f, 0.05790455f, -0.07048363f, 0.01295754f, 
    -0.00356343f, -0.00639252f, 0.05239703f, 0.05210981f, -0.17032413f, 0.03863226f, 0.04377287f, 0.14772479f, 
    0.16606636f, -0.03456592f, 0.09258028f, 0.23666930f, -0.07316287f, 0.05258884f, 0.04477568f, 0.14026995f, 
    0.01257432f, 0.08004565f, 0.14203380f, 0.13112907f, 0.05616144f, 0.00772973f, -0.04730389f, -0.00182137f, 
    -0.02206354f, 0.00088124f, 0.00575883f, 0.00326326f, -0.37067458f, 0.07210846f, -0.02078603f, 0.09271067f, 
    -0.03486126f, -0.14932132f, 0.04505113f, 0.11843812f, -0.00806536f, -0.08316901f, -0.02811097f, -0.07832397f, 
    0.00329087f, -0.04214995f, -0.08643608f, -0.05537445f, 0.03868700f, 0.07191862f, 0.10663500f, 0.00705763f, 
    -0.00668267f, 0.01303801f, 0.02261657f, 0.09387456f, 0.06567100f, -0.03075265f, -0.01406292f, -0.10172086f, 
    0.05256305f, -0.01756928f, 0.01486273f, -0.05251698f, -0.03212953f, -0.05101342f, 0.00226551f, -0.05105454f, 
    0.18904074f, 0.18795839f, -0.00467170f, 0.04075021f, -0.08980174f, -0.06502935f, 0.02340963f, 0.05462429f, 
    -0.17948955f, 0.00354443f, 0.02467533f, 0.04290592f, -0.01700783f, 0.01088076f, 0.07408640f, 0.00255106f, 
    0.07204209f, 0.07030462f, -0.02428729f, 0.03613452f, 0.04314136f, -0.06930661f, -0.00101313f, -0.07826506f, 
    0.25526220f, 0.07097878f, -0.04386937f, 0.05134867f, 0.03918752f, -0.08204165f, -0.00653334f, 0.05998051f, 
    0.04889030f, -0.00606370f, 0.03818557f, -0.03546059f, 0.20188068f, 0.17540668f, 0.05417555f, -0.05599750f, 
    0.12119194f, -0.14465737f, -0.05731564f, 0.13450086f, -0.05269340f, -0.01237639f, 0.01422768f, -0.05839645f, 
    0.30189377f, -0.26126075f, 0.13710384f, 0.12755571f, -0.02886887f, 0.04220795f, 0.00720445f, -0.05994876f, 
    0.23063460f, -0.09415416f, 0.13658080f, 0.03345934f, -0.00928508f, -0.01490480f, -0.08928607f, -0.07694959f, 
    -0.06895291f, -0.03668120f, 0.10314590f, -0.02080131f, 0.25200740f, -0.06730031f, -0.01033042f, 0.05676720f, 
    0.05768463f, 0.06112908f, -0.03993347f, 0.04136721f, 0.03173728f, -0.00773011f, -0.01917588f, -0.07725329f, 
    0.04151126f, 0.00536961f, 0.09931939f, 0.06210341f, -0.30458552f, -0.11528438f, -0.04977720f, -0.00661901f, 
    -0.12048846f, -0.12877640f, -0.06877080f, -0.09443477f, 0.05428773f, -0.02887534f, 0.07484278f, -0.03582483f, 
    0.02740174f, 0.05957855f, 0.07893697f, 0.02154077f, 0.00071682f, -0.04031499f, -0.03342384f, -0.02129246f, 
    -0.04463679f, -0.03885853f, -0.05358798f, -0.06366482f, 0.55777305f, -0.25881803f, -0.06810429f, -0.24434087f, 
    -0.05154535f, -0.06415620f, -0.11759954f, 0.00599796f, 0.09368651f, 0.03684450f, -0.12415383f, -0.15464324f, 
    0.04260476f, 0.05463225f, 0.12438412f, 0.06591619f, -0.04804996f, 0.01015692f, -0.16549647f, -0.06968899f, 
    -0.04589885f, -0.08270294f, -0.03659650f, -0.09018768f, 0.27517885f, 0.25731316f, -0.21054105f, 0.01262250f, 
    0.13560961f, -0.02348028f, 0.09162145f, 0.01613929f, -0.06201339f, -0.02154443f, 0.00949511f, 0.00333378f, 
    -0.07650539f, 0.00355589f, 0.02592740f, 0.01691992f, 0.01189182f, -0.00977677f, 0.01547490f, -0.00613459f, 
    0.01593543f, -0.04234907f, 0.00507662f, -0.04465136f, -0.27341866f, 0.20826912f, -0.04303427f, -0.14949529f, 
    -0.06287342f, 0.03161072f, 0.09457479f, -0.03456504f, -0.11910916f, -0.01004543f, -0.10255495f, -0.03891908f, 
    -0.10377951f, -0.22716986f, 0.15426607f, 0.34658924f, -0.10255267f, 0.07636847f, 0.00496057f, -0.05266222f, 
    0.19070829f, -0.10147907f, -0.06547944f, 0.09214380f, 0.04049125f, 0.03144239f, 0.07721432f, 0.07043391f, 
    -0.05191056f, -0.06950471f, -0.04638802f, -0.04021115f, 0.03358349f, -0.09393304f, -0.01088687f, 0.06055397f, 
    0.30179596f, -0.03334713f, 0.08721285f, -0.04862608f, -0.03719338f, -0.03106287f, -0.02047069f, 0.14105844f, 
    -0.03182986f, -0.26679787f, -0.27169496f, -0.22196311f, 0.04025912f, 0.10389855f, 0.06369288f, 0.12027910f, 
    -0.04859803f, -0.01978145f, -0.08531249f, -0.00150172f, 0.15311895f, 0.10966688f, -0.02625095f, 0.14862575f, 
    0.42224765f, 0.16650183f, 0.02240338f, 0.04002551f, -0.02533704f, -0.04739901f, 0.00343287f, 0.05664649f, 
    0.00706157f, -0.01452218f, 0.03741416f, 0.07890384f, 0.06070631f, 0.05565726f, 0.19471499f, 0.12032760f, 
    0.06948776f, 0.06520125f, -0.10117295f, -0.01229763f, 0.01495539f, 0.03471410f, 0.08746947f, 0.06844309f, 
    0.02744885f, -0.04889268f, -0.06016033f, -0.12308452f, -0.05190429f, 0.01783721f, -0.14730448f, 0.17927486f, 
    0.01313431f, 0.00803446f, 0.08458020f, -0.09408940f, -0.17150755f, -0.09890590f, -0.05068028f, -0.03636645f, 
    -0.04675344f, -0.02781305f, -0.16720045f, -0.05399738f, -0.00960518f, -0.14619350f, -0.25922775f, -0.23463582f, 
    -0.10118926f, -0.15952364f, -0.04521812f, 0.01492223f, -0.04290783f, 0.02984741f, 0.10271280f, 0.03486321f, 
    0.18918236f, -0.05289953f, 0.08480018f, 0.02175277f, 0.26503363f, -0.14668901f, -0.14715992f, -0.19083542f, 
    0.16439924f, -0.12490336f, -0.04154877f, 0.12061796f, -0.04740440f, -0.05933668f, 0.03406569f, -0.06058476f, 
    0.17244004f, -0.07022847f, -0.05907484f, 0.03692935f, 0.13471247f, 0.02722506f, -0.12058382f, 0.06098420f, 
    -0.01357919f, 0.01784749f, 0.04296298f, 0.08213544f, -0.05540843f, 0.08087837f, -0.12018877f, 0.01648281f, 
    0.10718914f, 0.01238124f, 0.21902035f, 0.01021574f, -0.04322031f, 0.00113354f, 0.00054624f, 0.03852337f, 
    -0.11298411f, 0.03566618f, -0.00034060f, 0.09488220f, 0.04794585f, -0.02801529f, 0.12167845f, 0.09840468f, 
    0.06175479f, -0.19708282f, -0.09881560f, -0.06334288f, 0.06778492f, -0.23607126f, 0.09452761f, -0.11414430f, 
    -0.09554905f, -0.00841186f, 0.08812617f, 0.23054859f, 0.10482778f, 0.08911650f, -0.01758032f, -0.08840472f, 
    -0.27071294f, 0.07199650f, 0.06848878f, -0.03356101f, 0.08172311f, 0.04860416f, 0.05138342f, 0.11779499f, 
    -0.07840498f, 0.02387848f, -0.05896591f, -0.15240964f, -0.15777743f, 0.16664563f, -0.07432666f, 0.12147934f, 
    0.05173490f, -0.03820655f, 0.12591876f, -0.02267164f, 0.02757501f, 0.16595395f, -0.00950130f, 0.00400166f, 
    -0.05680450f, -0.07921615f, 0.25137964f, -0.24895614f, 0.04889239f, 0.00437708f, 0.09488873f, 0.10043173f, 
    0.01054813f, 0.09678748f, -0.07521475f, -0.11848928f, 0.24981759f, 0.08874735f, 0.13914905f, 0.01688714f, 
    0.01149665f, 0.04036118f, -0.12469573f, -0.06058590f, 0.05096682f, -0.05741026f, 0.06809023f, 0.18577509f, 
    -0.04418601f, -0.04260918f, -0.11661326f, -0.06271458f, 0.05755248f, 0.13082875f, 0.08682290f, 0.16194031f, 
    0.13201086f, 0.03435434f, 0.05941159f, -0.01708172f, -0.23944312f, -0.02286508f, -0.10317825f, -0.12237937f, 
    0.07760799f, 0.07188057f, 0.06039668f, 0.24413629f, 0.13540605f, -0.00138328f, -0.12212357f, -0.15964733f, 
    0.32387599f, 0.07484699f, 0.02962420f, -0.06275262f, 0.19696218f, 0.10810734f, 0.05611074f, 0.07234246f, 
    0.08779763f, -0.03855766f, -0.12299789f, 0.11659381f, -0.51956260f, -0.10897850f, -0.00113695f, 0.09349541f, 
    0.05793382f, -0.01053009f, 0.02119415f, -0.15259619f, 0.05111747f, 0.04641203f, 0.21034561f, 0.03168409f, 
    -0.12030709f, 0.04783101f, 0.09410451f, -0.00127143f, 0.05648467f, 0.01084911f, -0.01709175f, 0.02605668f, 
    -0.19257818f, -0.03488376f, -0.03268886f, -0.08085760f, -0.14582361f, 0.10515790f, -0.18414702f, -0.13923016f, 
    0.00028813f, 0.03258650f, 0.08871168f, 0.02205212f, 0.06006337f, 0.13933934f, 0.08203258f, 0.03377986f, 
    -0.03818947f, -0.02594656f, 0.08490296f, 0.08120770f, 0.02154529f, 0.13219275f, -0.09808702f, 0.19618256f, 
    -0.13092054f, 0.03438712f, 0.04511587f, 0.08985960f, -0.12439594f, -0.01442910f, -0.01655415f, -0.03140013f, 
    -0.09614805f, -0.01612077f, -0.02068688f, -0.11172993f, -0.06090240f, -0.02369739f, 0.00895660f, -0.05655590f, 
    0.02263959f, 0.12459086f, 0.15524520f, 0.18347636f, -0.07147597f, 0.01782455f, 0.01584527f, -0.03951129f, 
    0.02133492f, 0.05256495f, 0.14699362f, 0.14990690f, -0.08011559f, 0.02375130f, 0.03020146f, 0.04388233f, 
    0.10775132f, 0.00105152f, 0.31390592f, 0.19618380f, 0.06593940f, 0.06880949f, -0.17905444f, -0.17701486f, 
    -0.07788000f, -0.14692658f, -0.07368548f, -0.13389884f, -0.09011005f, 0.06371257f, 0.00361197f, 0.15757100f, 
    0.11023118f, 0.16875622f, -0.03435876f, 0.05311888f, -0.23814856f, -0.01851867f, 0.07518439f, -0.12951539f, 
    0.08911417f, -0.09130465f, -0.14233896f, 0.03039485f, 0.06468695f, -0.01922876f, -0.06846777f, -0.19431154f, 
    -0.07313129f, 0.01523931f, 0.09404887f, 0.10101992f, -0.11975257f, 0.01554619f, -0.06970239f, -0.02649278f, 
    0.15732135f, 0.23424520f, 0.09990950f, 0.21009116f, -0.05022272f, 0.16805118f, 0.14993730f, 0.06387005f, 
    -0.11603244f, -0.10617296f, -0.02800056f, -0.12452108f, 0.04016725f, 0.16801357f, 0.10564520f, 0.18766786f, 
    -0.01501438f, -0.02653565f, 0.02113789f, 0.03054467f, -0.03481082f, 0.00134900f, -0.00689663f, 0.00021290f, 
    -0.01142356f, 0.00775264f, 0.03007088f, -0.01988545f, -0.02211733f, 0.01855978f, -0.02148730f, 0.02276496f, 
    -0.02898885f, 0.01056395f, 0.00112947f, 0.02407080f, -0.04097294f, 0.00740058f, 0.00236075f, -0.01855516f, 
    -0.01146235f, 0.02049888f, 0.01788622f, -0.04051957f, -0.01084364f, -0.01602593f, -0.01017371f, -0.00722810f, 
    0.01514797f, 0.02464995f, 0.02020479f, -0.00785915f, 0.02515354f, 0.01919777f, -0.01877701f, 0.02241089f, 
    -0.02115302f, 0.00418203f, 0.02339286f, -0.02629503f, -0.03984635f, -0.03110336f, -0.01172994f, -0.01352913f, 
    -0.00690107f, -0.00852005f, -0.02829353f, -0.01461243f, -0.02531311f, -0.01477197f, -0.00622231f, -0.03426024f, 
    0.00761882f, 0.01868470f, 0.02809914f, 0.00980197f, -0.00202326f, -0.00992788f, -0.01639962f, 0.01107585f, 
    0.00144783f, 0.00650261f, -0.03794574f, -0.00612025f, -0.01959708f, -0.03000606f, 0.01813185f, 0.02580341f, 
    0.02163848f, 0.01602532f, -0.00202829f, -0.01304288f, -0.03534539f, -0.00984470f, 0.00230820f, 0.01449622f, 
    0.01017847f, -0.01869537f, -0.02886149f, 0.01672202f, -0.01350390f, -0.03679585f, 0.01132728f, -0.01268209f, 
    0.00932165f, 0.00572780f, 0.01615776f, 0.01650607f, 0.00517633f, 0.00656660f, -0.01138138f, 0.00874088f, 
    -0.02215483f, 0.01879041f, -0.03044892f, -0.00978382f, -0.01019570f, -0.04119644f, -0.03452044f, 0.01395746f, 
    -0.03756769f, 0.00581249f, -0.01313773f, 0.00954537f, -0.03605462f, 0.00380280f, 0.01343723f, 0.02249049f, 
    0.01449159f, 0.01424043f, -0.00425534f, -0.01326497f, -0.00654415f, -0.02674810f, 0.00520094f, 0.02620350f, 
    -0.02192316f, -0.00389391f, 0.01732382f, -0.02342658f, -0.00261294f, -0.00226333f, -0.02726395f, -0.01667609f, 
    0.02771976f, 0.00307162f, -0.03364975f, -0.00536435f, -0.04127355f, -0.00472543f, -0.02987764f, 0.02851131f, 
    0.00284766f, 0.01107267f, -0.03680321f, -0.01183769f, 0.00834028f, 0.01539083f, -0.03735472f, -0.00098516f, 
    0.01721944f, 0.02758899f, 0.00503620f, -0.02815428f, 0.00653167f, 0.02645617f, 0.02765245f, -0.00368467f, 
    -0.02234509f, 0.01380997f, -0.02426850f, -0.00697925f, 0.00078019f, -0.03924020f, 0.02138262f, -0.00128803f, 
    -0.01328481f, -0.03414956f, -0.00397005f, -0.01182047f, -0.03232195f, -0.00289844f, -0.03064780f, 0.01509189f, 
    0.01160639f, -0.00064477f, -0.03252963f, 0.00876874f, -0.00507949f, 0.00277475f, -0.01600767f, 0.02092850f, 
    -0.00038229f, 0.01228020f, -0.03957199f, -0.02851769f, 0.02134851f, -0.02498464f, 0.00767121f, 0.02481698f, 
    0.01870024f, 0.01557026f, -0.01859679f, 0.00316475f, -0.01529583f, 0.01681239f, -0.01931409f, -0.00989501f, 
    0.01493182f, 0.02166597f, -0.01257210f, 0.02532762f, 0.01527986f, -0.01454315f, 0.00240747f, 0.00466645f, 
    0.00604790f, -0.01028139f, 0.02626840f, -0.00596842f, 0.00079073f, 0.00981615f, -0.02795092f, -0.02003163f, 
    -0.02796986f, 0.02679320f, -0.00029054f, 0.00893584f, -0.00834007f, 0.00588491f, -0.01845657f, -0.01747695f, 
    0.02209630f, -0.03566043f, -0.02922991f, 0.01665051f, -0.00510963f, -0.02286597f, -0.03620734f, -0.01765324f, 
    -0.01510193f, 0.03078122f, -0.03289351f, -0.00939175f, -0.02266498f, 0.01639765f, -0.01378834f, -0.03290653f, 
    -0.02207053f, 0.02092033f, -0.01590444f, 0.01534617f, -0.01383948f, -0.03136376f, 0.01239573f, 0.01409574f, 
    -0.01043533f, -0.00566412f, -0.03142533f, 0.02301438f, -0.00084946f, -0.02111372f, 0.02677078f, 0.03516347f, 
    -0.02237223f, 0.00742561f, 0.03056121f, -0.01031297f, -0.03492182f, 0.01319749f, -0.03044665f, -0.00051419f, 
    -0.00207407f, -0.02009384f, 0.02662800f, 0.01866011f, 0.00073496f, 0.01977837f, -0.02784660f, -0.02307112f, 
    0.01484758f, -0.01115321f, -0.00306396f, 0.03017228f, -0.00176174f, 0.02686472f, -0.02436476f, 0.00838752f, 
    -0.00481074f, -0.03435566f, -0.01880868f, -0.02680103f, -0.03406740f, -0.00031456f, -0.03170513f, -0.02793067f, 
    0.00105394f, -0.02647275f, 0.01366607f, -0.03730815f, 0.00563026f, -0.01511655f, -0.00410777f, 0.02539326f, 
    -0.04075457f, 0.00370979f, -0.01949750f, 0.00654581f, -0.00125263f, 0.00063079f, 0.00153938f, -0.02330393f, 
    0.02494958f, -0.03280095f, -0.01743177f, 0.02035541f, -0.01983450f, -0.00067176f, 0.03041087f, -0.02312207f, 
    -0.01921425f, 0.02564121f, -0.01781374f, -0.00559227f, -0.00052836f, -0.02153179f, -0.01030199f, 0.00241622f, 
    0.02130040f, -0.01769361f, 0.01523911f, -0.01859241f, 0.00919113f, -0.02765313f, -0.00474882f, -0.02766917f, 
    0.00202597f, 0.01258779f, 0.00509966f, -0.00813919f, -0.01726103f, -0.00058732f, -0.02763133f, 0.02913854f, 
    -0.01762393f, 0.01754051f, -0.01431119f, -0.04126005f, -0.00574205f, -0.03559790f, 0.02908680f, -0.01798382f, 
    0.00772793f, -0.01453297f, -0.03472280f, -0.02491281f, -0.00320849f, -0.02247585f, -0.00557760f, -0.01601988f, 
    -0.02295531f, -0.00163885f, -0.01990955f, -0.01185324f, -0.03524030f, -0.00061122f, 0.01999174f, -0.02945903f, 
    0.01501732f, -0.01019429f, 0.00308189f, 0.01378848f, -0.03270233f, 0.02950240f, -0.00781989f, -0.00196471f, 
    0.00197927f, -0.03983600f, 0.01602961f, 0.01960962f, 0.00440390f, -0.00562328f, -0.02591728f, -0.01032325f, 
    -0.00506199f, 0.00456505f, -0.02329609f, -0.00182340f, 0.00340885f, -0.03220827f, 0.02393429f, -0.00843977f, 
    0.00432799f, -0.00410484f, -0.02905411f, 0.00571196f, 0.01690893f, 0.01083720f, 0.00069674f, 0.00730852f, 
    0.00097630f, 0.01786141f, 0.00224330f, 0.00165737f, 0.01589246f, -0.01827615f, 0.00253640f, -0.00712914f, 
    0.00088713f, -0.01254592f, -0.02504471f, 0.01417352f, -0.03242037f, -0.03727059f, -0.03302885f, 0.01561303f, 
    -0.01034535f, -0.01669914f, -0.03703090f, -0.00572294f, 0.01765541f, -0.03802045f, 0.01302606f, 0.02411298f, 
    -0.00804772f, -0.01992482f, 0.00301024f, -0.00771743f, -0.02258085f, -0.03484350f, 0.00894372f, -0.00116707f, 
    0.01776698f, -0.03915615f, -0.03597657f, -0.03488228f, 0.01166878f, -0.02342728f, -0.03025801f, 0.01401250f, 
    0.01459203f, -0.00083966f, 0.01572043f, -0.01633789f, 0.00367158f, -0.00648247f, -0.02431541f, -0.01361588f, 
    -0.03516302f, 0.00414405f, 0.00493000f, 0.02506812f, 0.03036239f, -0.03344544f, -0.02978629f, 0.02399836f, 
    -0.02944607f, 0.00600313f, 0.01808599f, 0.02365401f, -0.02875253f, -0.00718181f, -0.02182330f, -0.01250509f, 
    -0.04039765f, 0.01150581f, 0.02982864f, 0.00617530f, -0.00145472f, -0.02237975f, 0.01319860f, -0.01746983f, 
    -0.03889862f, 0.00406035f, -0.01902925f, -0.02182220f, 0.00841349f, 0.02421230f, -0.01216620f, 0.02188889f, 
    -0.02800371f, -0.00338411f, -0.00724937f, -0.02583088f, 0.00217456f, -0.03888443f, 0.02401113f, 0.00823890f, 
    -0.01099714f, 0.02162081f, 0.02944482f, -0.00437594f, 0.03066143f, -0.01034680f, -0.02008227f, -0.02819249f, 
    -0.02911699f, -0.03422394f, -0.02407263f, 0.00116877f, 0.01018236f, 0.02638684f, -0.03059737f, -0.03195778f, 
    -0.03697726f, -0.00408274f, 0.00639199f, -0.00718962f, -0.01391116f, 0.02830392f, -0.00340197f, 0.01910751f, 
    -0.00707543f, 0.01428197f, -0.00649365f, -0.01260688f, 0.02488627f, -0.04071298f, -0.03197588f, 0.00151133f, 
    0.00063989f, 0.02141046f, -0.03272914f, 0.02009252f, -0.00902754f, 0.00235113f, -0.03706157f, 0.01686716f, 
    0.03263222f, -0.01253271f, -0.02968808f, -0.02524032f, 0.02993469f, 0.01337389f, -0.03699788f, -0.00921487f, 
    0.01159466f, 0.02319123f, -0.03704495f, -0.00171564f, -0.01065134f, 0.01420890f, -0.03507165f, -0.00701267f, 
    -0.00686618f, -0.02074017f, 0.00981964f, 0.01718512f, 0.02956258f, 0.02227332f, 0.00790954f, 0.01710575f, 
    -0.02538342f, -0.03484876f, -0.00541975f, -0.00253846f, 0.00382319f, -0.00432992f, -0.04118525f, -0.00406933f, 
    -0.02337923f, -0.02042306f, 0.00251993f, -0.01874061f, -0.01554533f, -0.01248005f, 0.00362325f, 0.00147737f, 
    -0.03497133f, -0.02936831f, 0.00550267f, 0.00000024f, -0.02087828f, 0.02786212f, -0.00224055f, -0.03411123f, 
    -0.02977732f, -0.03368875f, -0.02366609f, -0.01890730f, -0.02286603f, -0.02091012f, 0.02189261f, 0.01416829f, 
    -0.02380842f, -0.01946254f, -0.03131974f, -0.02896144f, 0.01263367f, -0.01635760f, -0.03066987f, -0.01347561f, 
    0.01399016f, 0.00489016f, -0.01716876f, 0.02645809f, 0.02499683f, 0.00038845f, -0.00448322f, -0.00955849f, 
    -0.03844671f, -0.02881390f, 0.00779311f, 0.01249849f, -0.03541964f, 0.02640025f, 0.01304241f, 0.02364030f, 
    -0.00797134f, 0.03276481f, 0.02839335f, 0.00603201f, -0.03742692f, 0.00447056f, -0.01256994f, -0.01002858f, 
    0.01841240f, 0.01732830f, -0.01637099f, -0.01153385f, -0.01197957f, -0.03767324f, -0.04128765f, 0.01858799f, 
    0.00132997f, -0.00173800f, -0.01806820f, -0.03384330f, -0.01303050f, -0.03406538f, 0.01519598f, 0.01648952f, 
    0.00047277f, 0.02938755f, -0.03391980f, 0.02444121f, 0.00332945f, 0.01297062f, 0.01032635f, -0.01627431f, 
    -0.00192362f, -0.02720717f, -0.00208867f, 0.02763009f, 0.00833510f, 0.00779482f, 0.02196939f, -0.01245736f, 
    -0.02853723f, -0.02902831f, -0.02729900f, 0.02661918f, -0.02988069f, 0.01755068f, 0.02887913f, -0.02643683f, 
    -0.01826613f, 0.00833589f, 0.01982620f, -0.00671577f, -0.00870829f, -0.03752878f, -0.03365749f, 0.01835298f, 
    -0.00854979f, 0.00352758f, 0.01718205f, -0.00865777f, -0.03104333f, 0.02433584f, -0.01672673f, 0.00277758f, 
    -0.02015983f, -0.01689356f, 0.00243862f, 0.00364762f, 0.01879442f, -0.03936395f, 0.01208407f, -0.00358958f, 
    0.00897629f, -0.02932949f, -0.03464486f, -0.00856498f, -0.00541348f, 0.01863853f, -0.02936364f, 0.00157946f, 
    -0.03686675f, -0.00713330f, 0.01555804f, -0.02841006f, -0.02389497f, -0.02630139f, 0.01134207f, 0.00192500f, 
    -0.01204919f, 0.01558563f, -0.03773729f, 0.01815037f, 0.00283980f, -0.02744999f, 0.00133010f, -0.01406755f, 
    -0.03115323f, -0.02511527f, -0.00793312f, -0.00569440f, -0.00599434f, 0.00900404f, -0.03410200f, -0.02883420f, 
    -0.00413536f, -0.03819713f, -0.03624490f, -0.00295501f, -0.00342086f, -0.02690371f, 0.00291293f, 0.00480770f, 
    0.00987970f, -0.01447542f, 0.00727395f, -0.01834300f, -0.00185537f, -0.00311288f, -0.02827383f, -0.00508016f, 
    -0.02785057f, 0.01117363f, 0.03532484f, -0.02789941f, -0.04000214f, -0.03194588f, -0.01612467f, 0.01566849f, 
    -0.00800184f, -0.02794203f, -0.04115173f, 0.02357828f, 0.00843170f, -0.01945612f, -0.03697888f, -0.00093935f, 
    0.00920751f, -0.03761860f, -0.03289810f, -0.00821063f, 0.01773431f, -0.02698943f, -0.02657248f, -0.00626649f, 
    0.01750992f, -0.01842238f, -0.03088796f, -0.03256691f, 0.02037206f, -0.01904024f, -0.01144009f, -0.02740956f, 
    0.00924407f, 0.00041258f, -0.03155534f, -0.00784777f, -0.01551319f, -0.04007929f, 0.02720796f, -0.03230704f, 
    -0.01165721f, 0.00669000f, -0.02691454f, 0.01888842f, 0.02632397f, 0.01245506f, -0.01216015f, -0.00126007f, 
    0.00200716f, 0.01992571f, -0.00349396f, 0.00896861f, 0.00292239f, 0.01102530f, -0.03470426f, -0.02465402f, 
    0.01294158f, -0.00589546f, -0.00625917f, 0.02872991f, 0.00088401f, -0.02595523f, 0.02864121f, 0.02541703f, 
    0.03287952f, -0.01121020f, 0.03308599f, -0.00452106f, -0.02883399f, 0.00769515f, 0.01756307f, 0.01222598f, 
    -0.01141258f, -0.02539141f, -0.00559445f, 0.02561760f, 0.01999501f, -0.00929316f, -0.00475252f, -0.01565886f, 
    0.04252410f, 0.01418777f, 0.00421453f, 0.02108919f, -0.02026617f, 0.00781335f, -0.02392062f, -0.03534348f, 
    -0.03916430f, 0.00381602f, 0.02346128f, 0.02621337f, -0.02125377f, -0.02708968f, 0.02026453f, 0.01086334f, 
    0.02662484f, 0.01689807f, -0.03056535f, -0.02135992f, -0.00491226f, 0.02897230f, 0.01465508f, -0.01967808f, 
    -0.01630292f, 0.01762620f, -0.00254700f, -0.01424554f, 0.01936902f, -0.01053525f, -0.02234225f, 0.00862234f, 
    -0.02520823f, 0.03358848f, 0.01469378f, -0.01083226f, 0.01668916f, 0.01504183f, -0.00787646f, -0.02757662f, 
    -0.01466824f, -0.01683636f, 0.02614709f, -0.02589988f, 0.00984279f, -0.00559097f, -0.03525373f, -0.01531818f, 
    -0.01557016f, 0.02804424f, -0.00613078f, -0.01020237f, 0.00385082f, -0.00468231f, -0.03643699f, 0.00007524f, 
    0.03098079f, -0.04029497f, 0.02794145f, -0.00044289f, -0.03042798f, 0.00019152f, -0.00302033f, -0.00589109f, 
    0.00148280f, 0.00953355f, -0.02204897f, 0.00980746f, -0.03804148f, 0.02209501f, 0.02926925f, 0.01194378f, 
    0.02030333f, -0.02031603f, -0.04079983f, 0.02147809f, 0.00352862f, -0.02693962f, -0.00274606f, 0.01421876f, 
    0.00206913f, -0.00217584f, -0.02297609f, 0.02076196f, 0.02566308f, -0.03476653f, -0.01381031f, -0.00543043f, 
    -0.01953023f, 0.01834985f, -0.04029744f, 0.01873800f, -0.04073922f, -0.02411565f, -0.00856895f, 0.03151694f, 
    0.01659770f, -0.00310615f, -0.03099396f, -0.01713400f, -0.03749492f, 0.01198745f, -0.03590233f, -0.00086150f, 
    0.01720157f, 0.01185139f, 0.00249409f, 0.02425037f, 0.00669426f, 0.01177959f, 0.00654106f, -0.02547458f, 
    -0.02761718f, 0.02821280f, -0.01494242f, -0.04032743f, -0.02133822f, -0.03215910f, 0.02442001f, -0.03617412f, 
    -0.01121533f, -0.01530175f, 0.03739747f, 0.01459800f, 0.02723078f, 0.03188173f, 0.03185824f, 0.01447848f, 
    -0.01386322f, -0.03861075f, 0.01594776f, 0.01637322f, -0.00537267f, 0.01746680f, -0.01478883f, -0.03924359f, 
    -0.03269283f, -0.02272782f, 0.01941713f, 0.00329181f, 0.00995683f, 0.01146242f, 0.01989867f, 0.02782890f, 
    0.01251169f, 0.01909201f, 0.01731891f, -0.03890568f, -0.00836862f, 0.03100148f, -0.04122934f, 0.00749559f, 
    0.01458405f, 0.02730564f, -0.00635544f, -0.04129703f, -0.00792020f, 0.03137517f, -0.00793539f, -0.01074788f, 
    -0.03981902f, 0.02150009f, 0.03715827f, 0.02053928f, -0.04056923f, 0.01233774f, -0.01866569f, -0.02487160f, 
    -0.01279769f, 0.02390351f, -0.03172919f, -0.02230133f, -0.01746479f, -0.01738018f, 0.02570133f, -0.03767104f, 
    -0.03856935f, -0.04148130f, 0.01466273f, -0.03783691f, -0.04084538f, -0.00056560f, -0.03737669f, -0.01232711f, 
    0.01489395f, 0.00065344f, 0.03844346f, -0.02740294f, 0.02875178f, -0.00605950f, -0.02846284f, -0.01477360f, 
    0.00890975f, -0.03045512f, -0.02759397f, 0.00525124f, -0.00092943f, -0.01085778f, 0.00461729f, -0.01581936f, 
    -0.03228337f, -0.01039446f, -0.02257123f, -0.02164128f, -0.01500166f, 0.02920998f, 0.01132126f, -0.04304107f, 
    0.01972431f, -0.00646736f, 0.01782822f, -0.03827277f, 0.02278497f, -0.03268166f, -0.03914166f, -0.02187866f, 
    0.00256545f, 0.01593550f, 0.00599826f, 0.02003774f, -0.01130458f, -0.01364887f, 0.01085651f, 0.02591973f, 
    0.02975875f, 0.02482931f, -0.00547818f, 0.00219255f, 0.01199688f, -0.01142987f, -0.03922640f, 0.02004427f, 
    -0.00106604f, -0.03370981f, 0.00228137f, -0.01061061f, -0.02578799f, -0.03564244f, -0.00255823f, -0.03539531f, 
    0.00494106f, 0.01169591f, -0.01976248f, 0.00068484f, 0.01834479f, -0.02898274f, 0.01927788f, -0.00729635f, 
    0.02952257f, -0.02479345f, -0.04002425f, 0.01947158f, -0.00940331f, -0.01898667f, 0.02653226f, 0.02703878f, 
    -0.01016373f, -0.01334291f, -0.01279654f, -0.01770530f, 0.01411713f, 0.01925822f, -0.00099784f, -0.03754712f, 
    0.03270124f, -0.01865532f, 0.00896316f, -0.00070695f, -0.00272886f, -0.01836299f, -0.00901205f, 0.02132465f, 
    -0.01936753f, 0.01983264f, -0.01666012f, 0.01717738f, -0.03621891f, 0.01308340f, -0.00487767f, -0.02145308f, 
    -0.03678074f, 0.01643883f, 0.02289152f, 0.01119260f, 0.00902069f, -0.00283127f, -0.03233887f, -0.03555485f, 
    -0.02418883f, 0.02492335f, 0.01756124f, -0.00418878f, -0.03043452f, -0.01414273f, -0.00000949f, 0.02746643f, 
    0.02451505f, -0.01800573f, 0.01571707f, -0.02046043f, -0.00744295f, 0.01043376f, -0.03075281f, 0.03110863f, 
    0.02276513f, 0.02599190f, -0.02940109f, 0.01637203f, -0.01933397f, -0.02639303f, -0.04015193f, -0.03710742f, 
    -0.03675583f, -0.00539754f, -0.00105739f, 0.02398453f, 0.02242176f, 0.00497497f, -0.02206392f, -0.02122727f, 
    -0.00526260f, 0.02770686f, -0.03988801f, -0.02393885f, 0.00670885f, 0.02060745f, -0.01963066f, -0.00461703f, 
    0.00923825f, -0.00604956f, -0.01209634f, 0.00294705f, 0.00915418f, -0.00470061f, -0.03883410f, -0.00824407f, 
    0.00352396f, 0.00732029f, -0.01916210f, -0.01848186f, 0.00565116f, 0.01937415f, -0.02925992f, -0.03475709f, 
    -0.02504589f, 0.01068508f, -0.03141071f, 0.03084528f, 0.01373418f, -0.02740929f, 0.00288179f, 0.02006278f, 
    -0.00228610f, -0.03807247f, -0.02619663f, 0.00905762f, 0.02836077f, 0.00979721f, -0.02171356f, 0.02352033f, 
    0.01520471f, -0.01659443f, -0.01092242f, -0.00983763f, 0.01264239f, -0.01146411f, -0.01022307f, 0.01969875f, 
    0.01720415f, -0.00040607f, 0.00267131f, 0.00849226f, -0.01240604f, -0.02799364f, -0.00437612f, -0.00635152f, 
    0.01331546f, -0.00243221f, -0.02979598f, -0.02369683f, -0.02169437f, 0.03363451f, -0.03945963f, -0.03168261f, 
    0.02457148f, -0.02842047f, -0.03815160f, 0.01652187f, 0.01251777f, -0.01508322f, 0.00145316f, -0.03709582f, 
    -0.00775396f, -0.01613658f, -0.00869236f, -0.03516629f, -0.02630322f, -0.01206111f, -0.03970045f, -0.01779557f, 
    -0.00209133f, -0.00544228f, -0.01224548f, 0.00469159f, -0.00807059f, 0.02179766f, -0.02109427f, 0.02109103f, 
    0.01244326f, 0.00993119f, -0.01591048f, -0.02099798f, 0.00141235f, -0.02573645f, -0.04001475f, -0.02823716f, 
    -0.02389513f, 0.01933874f, -0.01071436f, -0.03468832f, -0.00228832f, -0.01474269f, 0.00059969f, 0.01112668f, 
    0.02171387f, 0.00593700f, -0.02920923f, 0.01434138f, 0.01433673f, -0.03334870f, -0.00566521f, 0.00241017f, 
    -0.03025329f, -0.02251601f, -0.01475233f, -0.00090090f, 0.00227710f, 0.01913977f, -0.04122635f, -0.01121094f, 
    -0.00530853f, 0.00588579f, -0.01219514f, -0.01795404f, 0.03165491f, -0.00125537f, -0.00059596f, -0.00683198f, 
    -0.02159047f, 0.02135980f, 0.00997835f, 0.02491388f, -0.03669037f, 0.02740653f, -0.02822185f, -0.01682310f, 
    -0.03907310f, 0.00640218f, 0.01480730f, 0.01361507f, -0.01279095f, 0.02711081f, -0.03706503f, 0.01362672f, 
    -0.02605374f, -0.02491442f, -0.00961413f, -0.01076660f, 0.00365310f, 0.02289004f, 0.01843022f, -0.03045462f, 
    0.02269081f, -0.03225196f, -0.03896775f, 0.02725888f, -0.00272924f, -0.02500600f, 0.01000394f, 0.01746372f, 
    0.00977989f, 0.00270025f, -0.00784699f, 0.03223765f, 0.01586303f, 0.02636191f, -0.02191535f, -0.01518895f, 
    -0.03811379f, -0.02137666f, 0.02361854f, 0.02229831f, -0.02590161f, -0.02210826f, 0.01899902f, -0.02679076f, 
    -0.00816416f, -0.01557218f, 0.01647695f, -0.00383458f, -0.02958195f, 0.02494329f, -0.00428174f, -0.03289954f, 
    0.00913917f, -0.02134918f, -0.02087805f, 0.01242757f, -0.03005279f, 0.01083758f, -0.02818295f, 0.02548266f, 
    0.01733595f, 0.00423102f, 0.02091450f, -0.04268203f, -0.00355891f, -0.01145632f, 0.00330194f, -0.00010954f, 
    -0.02881597f, -0.03893216f, -0.03591542f, 0.00175777f, 0.00973752f, 0.01812166f, -0.03106352f, -0.00840030f, 
    -0.02505070f, 0.01026849f, 0.00944774f, -0.00740483f, 0.02303643f, -0.01749209f, -0.00588943f, 0.02380802f, 
    -0.02815463f, 0.00860253f, 0.00535647f, -0.04187552f, -0.03411964f, -0.02211752f, 0.02252791f, -0.01472392f, 
    0.02789165f, -0.03077079f, 0.02038696f, 0.01487724f, -0.00482327f, -0.03164553f, 0.01695108f, -0.00202037f, 
    0.02752022f, -0.00772644f, -0.00775921f, 0.02572188f, -0.03824252f, 0.04475159f, -0.00354730f, -0.02121781f, 
    -0.03016158f, -0.00103512f, 0.02124308f, 0.01891457f, -0.03449715f, 0.02612736f, -0.02542897f, -0.02520555f, 
    0.02111341f, 0.00277567f, 0.02656008f, 0.00304127f, 0.03254746f, 0.00670756f, 0.00609966f, -0.03693620f, 
    0.03381719f, -0.03191206f, -0.01628221f, -0.04163015f, -0.02581288f, 0.00626842f, 0.00881988f, -0.02314692f, 
    0.00623803f, -0.03887067f, 0.01364635f, 0.03338633f, -0.02899837f, 0.00470646f, 0.02442168f, 0.02479235f, 
    0.01970079f, -0.01126214f, 0.00812183f, -0.01226030f, 0.01162222f, -0.00740460f, 0.03464565f, -0.03315767f, 
    -0.03724308f, -0.04079297f, -0.03431917f, -0.03621458f, 0.00438829f, -0.02483749f, 0.02374684f, 0.03538666f, 
    0.02340202f, 0.02270412f, -0.03236997f, -0.01023931f, -0.03171524f, -0.02743455f, -0.02337544f, 0.01076944f, 
    -0.02057829f, -0.03704887f, 0.00161798f, 0.02399745f, 0.02645363f, -0.03405390f, -0.03435234f, -0.02476111f, 
    -0.03064751f, 0.00889889f, 0.00056757f, -0.02862516f, -0.00490485f, -0.02062595f, -0.02682911f, 0.01220491f, 
    0.01929585f, -0.02907278f, 0.02656610f, 0.02702358f, -0.00217204f, -0.00171793f, -0.02967072f, -0.00603503f, 
    -0.01451281f, -0.03013620f, -0.04314714f, -0.00481921f, 0.00865845f, -0.03335068f, -0.03500838f, 0.00925750f, 
    0.00691862f, 0.00036269f, -0.03833822f, 0.00759760f, -0.01345799f, 0.02659893f, -0.02255066f, -0.03761848f, 
    0.00231883f, -0.02263585f, 0.03066487f, 0.01066506f, -0.01052972f, 0.03634485f, -0.02303059f, 0.01345530f, 
    0.00669898f, -0.01569601f, -0.02238195f, 0.03031659f, 0.03074645f, 0.02527453f, -0.03085722f, -0.04311578f, 
    0.02735057f, 0.02824580f, 0.00231623f, 0.03818097f, -0.00584519f, 0.02001409f, 0.01122660f, -0.01386616f, 
    -0.00127366f, -0.03953059f, -0.03482733f, 0.02397238f, 0.01143902f, -0.02804067f, 0.01311967f, 0.01054586f, 
    -0.00385434f, -0.03906398f, 0.02748928f, -0.01129805f, 0.01456218f, -0.01662370f, -0.01155542f, -0.02869242f, 
    0.02713912f, -0.00882545f, 0.01174510f, 0.02994561f, 0.03081572f, -0.00554700f, 0.01198429f, -0.00914426f, 
    0.01785001f, -0.03635869f, -0.03843862f, 0.00143695f, 0.00648508f, 0.01816810f, -0.00791543f, 0.00389683f, 
    -0.00532658f, -0.01363875f, 0.01517813f, -0.02251290f, -0.00163493f, 0.01413035f, 0.02628503f, -0.01683133f, 
    -0.03697595f, -0.02954168f, 0.03405135f, -0.00775568f, -0.01629748f, 0.02142307f, -0.03165681f, 0.01845284f, 
    -0.03376155f, -0.02350182f, 0.00307299f, 0.02642469f, -0.03256783f, 0.00347570f, -0.00288708f, 0.00603899f, 
    -0.04124148f, -0.01621778f, 0.01491218f, 0.00761802f, -0.03864746f, -0.01013789f, -0.02112585f, 0.02687138f, 
    -0.07800663f, -0.12632445f, -0.13946198f, 0.03750215f, 0.12517992f, -0.05084751f, -0.01823035f, -0.01086477f, 
    0.13689674f, 0.07409027f, 0.21493752f, -0.03500913f, 0.01065274f, -0.02594245f, 0.08337949f, 0.01823095f, 
    0.09448314f, 0.11715274f, 0.08496000f, 0.02917324f, 0.11037298f, 0.12220264f, 0.02617631f, -0.03081947f, 
    0.47828251f, -0.42298830f, 0.00370626f, -0.04686610f, 0.22567804f, -0.07932340f, -0.18622093f, -0.17647736f, 
    -0.02330742f, -0.07251615f, 0.12957503f, 0.13613921f, -0.23374341f, -0.02092015f, -0.06104514f, 0.06118431f, 
    0.10530441f, 0.05033106f, 0.04706340f, -0.05405655f, 0.04889736f, 0.09152476f, 0.06807556f, 0.14424631f, 
    0.06020503f, -0.03593047f, 0.03029367f, -0.08590775f, -0.00837128f, -0.10016614f, -0.00725485f, -0.03231096f, 
    0.02159844f, 0.06902298f, -0.03093584f, 0.14969854f, -0.02869308f, -0.11750042f, 0.02057125f, -0.12723409f, 
    0.00072737f, -0.03327206f, -0.05907677f, -0.00472160f, -0.07774791f, 0.07400325f, -0.07089818f, -0.04957372f, 
    0.39617804f, -0.13359343f, 0.02301399f, 0.12618220f, 0.00704923f, 0.05689614f, 0.03454645f, 0.06480534f, 
    0.06941595f, 0.00029649f, 0.06822634f, 0.01801767f, 0.16610575f, 0.04104885f, 0.09885945f, 0.14123796f, 
    0.08882915f, -0.03424294f, -0.07880598f, -0.04027427f, 0.05280627f, -0.08335698f, 0.05322338f, -0.02168423f, 
    0.10463916f, -0.10043158f, 0.06581178f, -0.02130650f, -0.07561711f, -0.02006691f, -0.01889211f, -0.03267474f, 
    -0.03666241f, 0.03143936f, 0.01174925f, -0.03587508f, 0.04617463f, 0.16772056f, 0.01750093f, -0.01653069f, 
    -0.01111513f, 0.13649262f, 0.04963929f, -0.03214392f, 0.06564125f, 0.02346464f, 0.05934005f, -0.06357735f, 
    -0.17463322f, -0.03028844f, -0.24358447f, -0.01726327f, -0.00641462f, 0.05604258f, 0.00760435f, -0.00716228f, 
    0.00367819f, 0.06499802f, -0.01584316f, 0.15234758f, 0.12905136f, -0.10629915f, 0.10384680f, 0.05047583f, 
    0.24449632f, -0.13744633f, 0.03517315f, -0.11936580f, 0.05864334f, -0.01106012f, 0.09295611f, 0.05083742f, 
    0.14536756f, -0.08192318f, -0.21609603f, 0.01474374f, -0.06344604f, -0.07881851f, -0.19020554f, 0.02556727f, 
    0.01534322f, -0.00117573f, -0.04994394f, 0.03655976f, 0.15685759f, 0.07504109f, 0.22469057f, 0.20912609f, 
    0.12174106f, -0.05689730f, 0.05856959f, 0.04963065f, 0.02970847f, 0.02618124f, 0.08832685f, 0.00521151f, 
    -0.07762818f, -0.02343137f, 0.12358424f, 0.08144774f, -0.04304770f, -0.07715563f, 0.06727718f, -0.03737414f, 
    0.01039864f, 0.06743346f, 0.03622132f, 0.05777533f, 0.03364902f, -0.02420121f, 0.12210454f, -0.04703856f, 
    0.05369989f, -0.04604246f, 0.05060544f, 0.09451935f, 0.06190954f, -0.01255044f, 0.03063530f, 0.05625448f, 
    -0.12614714f, -0.00292236f, 0.04703424f, 0.01455564f, 0.04660350f, 0.08221838f, -0.07945097f, 0.09035609f, 
    0.08191205f, 0.06136436f, 0.07425809f, 0.04390696f, 0.19125235f, 0.11694618f, 0.36977008f, -0.04099805f, 
    0.00740977f, -0.07963420f, 0.11141939f, 0.02902763f, -0.06982427f, -0.03599422f, 0.02038905f, -0.01815244f, 
    0.16353393f, 0.11972336f, 0.18722425f, 0.19349919f, -0.10857131f, 0.04451218f, 0.09459335f, 0.04205430f, 
    0.01344488f, -0.03482814f, 0.01483181f, -0.01615115f, 0.08662099f, -0.14259838f, 0.07680601f, -0.00175813f, 
    0.04522699f, -0.02992465f, -0.02988042f, 0.07119883f, -0.02382952f, -0.04734858f, 0.01688140f, 0.04299858f, 
    0.10259534f, -0.22755411f, 0.18013892f, 0.07222708f, 0.09061893f, -0.01014317f, -0.05073863f, 0.08093542f, 
    -0.04502686f, -0.04445591f, -0.00035489f, 0.10005628f, 0.21736056f, 0.19328326f, 0.28011951f, 0.17543136f, 
    -0.00130881f, 0.00338380f, -0.00596259f, 0.07532834f, 0.02042031f, -0.06036531f, 0.00588109f, -0.06790956f, 
    0.17011933f, -0.27068108f, 0.02288966f, -0.02315261f, -0.02841908f, -0.04147961f, 0.11083438f, 0.11864392f, 
    0.00341324f, -0.03632618f, -0.09238752f, 0.07562865f, -0.25800398f, 0.07531986f, -0.19312896f, 0.09040605f, 
    0.08490010f, 0.02424178f, -0.06326770f, 0.08577263f, 0.03149789f, -0.10010491f, -0.11113125f, 0.06731997f, 
    -0.15894480f, -0.15976965f, 0.06173183f, -0.03548658f, 0.08795503f, -0.03673638f, -0.07225538f, 0.04472021f, 
    0.01787286f, 0.04977142f, 0.14885575f, 0.02237530f, 0.00245412f, -0.16103511f, -0.15604399f, 0.02095773f, 
    0.01192332f, -0.05628663f, 0.11052985f, 0.01546856f, 0.03980238f, -0.06746303f, 0.07872757f, 0.02403341f, 
    -0.18415715f, -0.12054677f, 0.00826666f, 0.00755331f, 0.00231933f, -0.01840922f, 0.00841381f, 0.01067457f, 
    0.00758225f, 0.02938774f, -0.03176495f, 0.00962849f, -0.10198027f, -0.30275613f, -0.03135342f, -0.07892436f, 
    0.05335774f, 0.07022425f, -0.00698687f, -0.04812161f, -0.03815695f, 0.02984742f, -0.01590382f, -0.01937142f, 
    -0.06812913f, -0.00655452f, 0.17530295f, 0.03505780f, -0.08461350f, -0.05140402f, -0.01543318f, -0.01409598f, 
    0.01714838f, 0.01458588f, 0.02601714f, 0.07835873f, 0.07048942f, 0.25523219f, 0.25762460f, 0.33577830f, 
    0.18963833f, 0.04261076f, -0.20923673f, 0.11826609f, -0.03428873f, -0.09905713f, 0.03242765f, -0.05293147f, 
    -0.06866311f, -0.08529270f, -0.09503086f, -0.01032619f, -0.02278764f, -0.11029276f, -0.06969152f, 0.04568414f, 
    -0.02133287f, -0.06034066f, 0.05093968f, -0.03465496f, 0.07468956f, 0.02723429f, -0.00955228f, -0.01366353f, 
    0.02021894f, -0.12487623f, 0.02923274f, 0.07491798f, -0.02614653f, -0.05196171f, -0.03916325f, -0.02893159f, 
    -0.30996910f, -0.12887356f, -0.14217269f, 0.02742668f, 0.00420819f, 0.00421174f, -0.05852881f, -0.00571079f, 
    0.00413838f, 0.10440356f, 0.08783326f, 0.07081435f, -0.18548615f, -0.10956483f, -0.07441813f, -0.06535929f, 
    0.00049226f, 0.00044782f, -0.07746498f, -0.00840462f, -0.03488188f, 0.08541788f, -0.06556669f, 0.08736546f, 
    0.00481624f, 0.06479891f, 0.02899366f, 0.01794140f, -0.02576314f, 0.06466595f, 0.00908489f, 0.00326845f, 
    0.13934186f, -0.07486230f, -0.03768602f, -0.05052940f, -0.22970060f, -0.10678837f, -0.02852714f, -0.12252510f, 
    -0.04892705f, -0.04556018f, -0.04242332f, -0.01005980f, -0.04721062f, 0.00028843f, 0.06665531f, 0.11670449f, 
    -0.07815566f, -0.06154616f, -0.10166038f, -0.10819481f, -0.05043338f, 0.03819698f, -0.09049941f, 0.00616859f, 
    0.03762875f, -0.08036300f, 0.02086927f, 0.08961809f, -0.10046237f, -0.09879915f, 0.16531578f, 0.17545508f, 
    0.01174184f, -0.04010577f, 0.00818350f, -0.02868566f, 0.00711280f, 0.03696109f, 0.06393574f, 0.11671649f, 
    -0.01794844f, 0.00357215f, 0.01465089f, -0.15080935f, -0.08717917f, 0.04532687f, -0.01394937f, 0.20347644f, 
    0.05246239f, -0.01461367f, 0.19532688f, -0.06955314f, -0.11593428f, -0.07576327f, -0.02827451f, 0.01218318f, 
    0.02848592f, 0.01883013f, 0.11048616f, 0.00024610f, -0.00432266f, -0.06251699f, -0.04836744f, -0.04685697f, 
    -0.01062261f, -0.08658007f, -0.13395099f, -0.04295128f, -0.00154481f, 0.04669756f, -0.03688036f, -0.02192614f, 
    0.06863269f, -0.03199224f, -0.07019244f, 0.09277966f, -0.11536661f, -0.27975565f, 0.11021245f, 0.01122342f, 
    0.02633364f, 0.01283016f, 0.00328777f, 0.02374272f, -0.01900768f, -0.08950390f, -0.03167902f, 0.03529555f, 
    -0.14183791f, 0.04262900f, -0.10916229f, -0.11895728f, -0.05859398f, 0.10646798f, -0.11344842f, -0.03636478f, 
    0.03968912f, -0.04278781f, -0.04077079f, 0.01141605f, -0.01081745f, 0.23264380f, 0.18710780f, 0.02881289f, 
    0.22714096f, -0.01921069f, -0.01458668f, 0.02375748f, 0.06741592f, -0.07258947f, 0.04746253f, -0.07486980f, 
    -0.06828088f, 0.09828433f, -0.01285866f, 0.34452736f, 0.07254317f, -0.05243956f, -0.03599302f, 0.00271765f, 
    -0.10830796f, -0.06598672f, 0.07918438f, 0.03243028f, -0.03523672f, 0.10813529f, 0.28218347f, -0.08264951f, 
    0.06218694f, -0.19356425f, 0.02058452f, 0.03109059f, -0.07274049f, 0.01945002f, -0.05374691f, -0.04286411f, 
    0.00789002f, 0.00658996f, 0.24062951f, -0.05706342f, -0.08080912f, -0.02544888f, 0.00614736f, 0.06290413f, 
    -0.02269377f, 0.00628204f, -0.01231786f, -0.05973793f, 0.02534857f, -0.14449580f, 0.11130819f, -0.20159249f, 
    0.05709067f, -0.04999295f, -0.12356295f, -0.09011228f, 0.12894262f, 0.09900291f, 0.08832814f, 0.00786955f, 
    0.22709684f, 0.12266743f, 0.15498808f, 0.06109042f, -0.00325413f, -0.04884065f, 0.08408572f, 0.10193398f, 
    0.00505962f, -0.02265027f, -0.08165797f, 0.04061158f, -0.02815832f, 0.12874196f, 0.15581371f, 0.09483010f, 
    0.02047710f, -0.08392627f, -0.02382663f, 0.03177313f, 0.01356257f, 0.02952952f, 0.07930292f, 0.01447687f, 
    -0.41473836f, 0.35126621f, -0.17593050f, 0.12646081f, 0.11507431f, 0.05161655f, 0.02324159f, 0.13413528f, 
    0.03153393f, 0.03914418f, 0.08148913f, -0.06408212f, -0.08089223f, -0.09204081f, 0.00480219f, 0.12180810f, 
    0.08996259f, -0.04118913f, -0.02785470f, -0.02823487f, 0.24114618f, 0.13681266f, 0.01321219f, 0.02456005f, 
    -0.02288748f, -0.08119062f, -0.04965059f, 0.09873041f, -0.12584674f, -0.19175592f, -0.00011952f, 0.07428747f, 
    0.05000302f, 0.01970622f, -0.00361684f, 0.06161997f, 0.06034311f, -0.04562828f, -0.31698954f, -0.03075487f, 
    0.14438379f, 0.00955111f, -0.09605604f, -0.01458697f, -0.05490147f, -0.02563746f, 0.03333141f, 0.11780251f, 
    0.00150256f, 0.14572933f, 0.31505752f, 0.06929354f, 0.05403991f, 0.07435906f, 0.05288798f, 0.07676603f, 
    0.00040609f, -0.03956476f, -0.04014116f, -0.01423100f, -0.10969692f, -0.03378954f, 0.03959715f, 0.03796305f, 
    0.02090153f, -0.02372630f, -0.03147910f, -0.00238624f, 0.07782348f, 0.08833754f, 0.11466473f, -0.00827698f, 
    0.07668306f, -0.12793823f, 0.11113837f, 0.01994284f, -0.01097360f, 0.10199355f, 0.02820602f, 0.06611405f, 
    0.14342515f, 0.02004562f, -0.00616038f, 0.07087675f, -0.03599032f, -0.13484676f, -0.13736038f, -0.07282963f, 
    0.00609888f, 0.14360178f, 0.22666706f, -0.01750858f, 0.02857608f, -0.02568392f, 0.00569477f, 0.09292889f, 
    -0.00038036f, 0.01832635f, 0.03308373f, 0.06283133f, -0.02392687f, -0.07257404f, -0.01518844f, -0.07018293f, 
    0.05496557f, 0.08089159f, 0.09917993f, 0.05536491f, 0.06888280f, 0.04096470f, 0.27381194f, 0.22033049f, 
    0.16446194f, 0.03602336f, 0.02130983f, 0.03576882f, 0.16936833f, 0.00289613f, 0.01380117f, 0.03375258f, 
    0.04174699f, -0.17998008f, -0.09818461f, 0.05423604f, 0.01177392f, 0.06846378f, 0.12702252f, 0.05663273f, 
    0.12656137f, 0.00207062f, 0.03817520f, -0.03179766f, -0.09169776f, 0.04154393f, -0.01169437f, 0.04748521f, 
    -0.02351992f, 0.02325858f, -0.02287057f, -0.08967054f, 0.01284742f, -0.12681735f, 0.06002610f, 0.01758023f, 
    -0.21991527f, 0.04722915f, -0.32828578f, -0.02881418f, -0.01627937f, 0.03219722f, -0.10135573f, -0.06529897f, 
    0.11826446f, 0.09480146f, 0.02039760f, 0.07044654f, -0.13628276f, -0.11219271f, 0.00326418f, -0.12447024f, 
    0.06282456f, 0.02059926f, -0.08269633f, -0.00609735f, 0.00893009f, -0.15270668f, 0.17123613f, 0.06675080f, 
    0.02736490f, -0.03826206f, 0.01453774f, -0.07510078f, 0.10918050f, 0.04101798f, -0.04076156f, 0.02605161f, 
    0.14337920f, 0.01269842f, 0.03676394f, 0.06337042f, 0.06186022f, 0.06255446f, -0.05786210f, -0.17754339f, 
    0.00868512f, -0.14973222f, -0.06011798f, 0.14995991f, -0.17487738f, -0.05381326f, 0.06516112f, -0.02377532f, 
    0.70663995f, -0.25036961f, 0.21238184f, -0.18031880f, 0.10568677f, -0.04547628f, -0.09142038f, -0.07582566f, 
    0.13314080f, -0.17693698f, 0.21326423f, 0.12292466f, -0.21029665f, -0.07697137f, -0.13149358f, -0.01130628f, 
    -0.10589427f, 0.04531214f, -0.00379541f, 0.05331591f, 0.03636249f, 0.02204884f, 0.09165193f, 0.03990339f, 
    -0.00643062f, -0.07955005f, -0.06042584f, -0.13278843f, 0.11196817f, 0.07928227f, 0.07058182f, -0.03024860f, 
    0.04939105f, 0.00373777f, -0.00074193f, 0.12839399f, -0.13307536f, -0.30913162f, 0.15658578f, -0.12821984f, 
    -0.00318752f, 0.03636875f, 0.06838086f, -0.05934862f, -0.11081310f, -0.08234449f, 0.01389206f, 0.12417032f, 
    0.45293942f, 0.06867713f, 0.07114193f, -0.05965254f, 0.02151314f, -0.05872155f, -0.01132269f, -0.18413214f, 
    0.02539570f, 0.00219981f, -0.05572741f, -0.01255463f, 0.07678875f, 0.07368612f, -0.08401178f, 0.06834521f, 
    0.09820193f, 0.04152087f, 0.02856340f, 0.07253653f, 0.08301741f, -0.16959454f, 0.05859233f, 0.02580881f, 
    0.22723076f, -0.17429677f, -0.04782068f, 0.00666921f, -0.08933201f, 0.01748601f, -0.00093938f, -0.05724925f, 
    0.04932952f, 0.05323483f, 0.04297956f, 0.06801171f, 0.18353182f, -0.14827590f, -0.02751037f, -0.14536317f, 
    0.16616592f, 0.04403844f, 0.02148451f, -0.06040606f, 0.01562325f, -0.02854030f, 0.02170941f, 0.01804856f, 
    -0.24661516f, 0.05810934f, 0.06570745f, 0.11855889f, 0.06545603f, 0.03300764f, 0.05427305f, 0.08597802f, 
    0.06802472f, 0.05968200f, 0.15303634f, 0.08005589f, 0.05879973f, 0.13865493f, -0.12533896f, -0.01305700f, 
    0.12686315f, -0.15305467f, 0.17959045f, 0.05281868f, 0.03702595f, -0.07277216f, 0.09406307f, 0.06444593f, 
    0.07579365f, -0.04755694f, -0.07651673f, -0.06092314f, 0.11011861f, 0.05381333f, -0.06289951f, 0.05375412f, 
    0.01797756f, 0.03082636f, -0.01199192f, 0.12511568f, -0.00964001f, 0.21338017f, -0.16073179f, 0.07792722f, 
    0.05772028f, -0.07889810f, 0.05305423f, -0.03717813f, 0.03570215f, 0.00290637f, 0.03996217f, 0.05321701f, 
    -0.02235244f, -0.04413679f, -0.04251311f, -0.15890148f, 0.01973692f, -0.02182897f, 0.02438629f, -0.05402817f, 
    -0.02622403f, -0.07578562f, 0.01560518f, -0.00332515f, -0.31260327f, 0.02289295f, 0.02820794f, 0.06792607f, 
    0.02024543f, 0.00720943f, -0.08643439f, 0.07913958f, -0.01798176f, 0.03093638f, 0.04800735f, 0.16222318f, 
    -0.10303193f, -0.03667171f, -0.06241602f, 0.03767873f, -0.04834917f, -0.07202177f, 0.10990810f, -0.04933245f, 
    -0.01354648f, 0.03096996f, 0.09765407f, -0.00050369f, -0.05004319f, -0.20029557f, 0.00610409f, -0.10321448f, 
    0.00666407f, 0.12100270f, 0.20688848f, 0.06233702f, -0.03878348f, -0.03769049f, -0.02175300f, -0.00007489f, 
    0.27111211f, 0.20366651f, -0.25849268f, 0.08439130f, -0.10733715f, 0.04382995f, 0.03102176f, 0.00361359f, 
    0.00208761f, 0.10909951f, 0.04886780f, -0.03785698f, 0.07651670f, 0.06052146f, 0.16050012f, -0.09855114f, 
    0.07523528f, 0.05699609f, -0.04454868f, -0.00731500f, 0.14745237f, -0.10509806f, -0.03551913f, 0.03614420f, 
    0.25770184f, -0.25474411f, 0.09816770f, -0.03942753f, -0.03515116f, -0.01140467f, -0.05124480f, -0.03644254f, 
    -0.06049272f, 0.08260696f, -0.12847775f, 0.24478422f, 0.54245865f, -0.11251337f, -0.06748750f, -0.11532134f, 
    0.15331632f, -0.15490006f, -0.13733388f, 0.04153595f, -0.03873443f, 0.07848673f, -0.07195686f, -0.03433744f, 
    0.22794852f, -0.29121447f, 0.07940874f, 0.03245705f, 0.06121659f, 0.05502580f, 0.01557333f, 0.01917493f, 
    0.10756949f, -0.08065738f, -0.05839093f, 0.12248494f, -0.20794792f, 0.17219043f, -0.07580040f, 0.06071729f, 
    -0.11857966f, 0.08446337f, 0.01939737f, 0.13508427f, -0.02769570f, -0.02117332f, 0.12141451f, -0.05165419f, 
    -0.06226534f, 0.02985452f, -0.05691285f, -0.09895808f, 0.06880827f, 0.03513442f, 0.10214587f, 0.01047626f, 
    0.03610149f, 0.07554866f, 0.03734180f, 0.03957491f, -0.01381880f, 0.03739792f, -0.14556912f, 0.04899254f, 
    -0.07651086f, -0.03269924f, -0.13093786f, 0.06172184f, 0.12771715f, -0.11107019f, 0.10688785f, 0.02992134f, 
    -0.20323339f, -0.17821088f, -0.05991120f, -0.19048718f, 0.10279210f, 0.09556347f, 0.08003614f, -0.03875567f, 
    -0.09236021f, 0.07543102f, -0.01679872f, -0.06094266f, -0.00578652f, -0.23243840f, 0.33025262f, 0.06710156f, 
    0.05682572f, -0.08698384f, -0.02683261f, 0.05705926f, 0.06512631f, 0.11180398f, -0.03938747f, -0.03794459f, 
    0.04032411f, -0.12168370f, 0.05413847f, -0.11870607f, -0.08018625f, 0.01319187f, -0.04112441f, 0.00020562f, 
    0.00983892f, -0.04606969f, 0.02870313f, -0.05657473f, -0.50556004f, 0.31914812f, -0.18141332f, 0.20009460f, 
    0.18526083f, 0.00745659f, 0.11115041f, 0.10559378f, 0.04728213f, -0.00353165f, -0.03515511f, -0.02824320f, 
    -0.03816178f, -0.04643114f, -0.11484076f, -0.06945737f, 0.10014531f, -0.02232534f, 0.07095023f, 0.00311558f, 
    0.03334722f, -0.04243392f, -0.03048304f, 0.15222222f, -0.18413317f, -0.21077020f, -0.16068408f, -0.04042548f, 
    -0.04511255f, 0.04368696f, 0.01052064f, 0.09685075f, 0.01952356f, -0.03670878f, -0.00057573f, 0.02671476f, 
    0.33615544f, 0.09825570f, 0.09143433f, 0.05857990f, -0.02635354f, -0.06704017f, -0.01732385f, -0.11988840f, 
    0.24349374f, 0.17741841f, 0.01086379f, 0.03272644f, -0.10956869f, -0.14985505f, 0.01807921f, -0.12382635f, 
    -0.01506994f, 0.03113545f, 0.05069400f, 0.03532601f, 0.02936947f, 0.04279983f, -0.00446888f, 0.10627288f, 
    -0.15186398f, -0.09104716f, 0.01383912f, 0.13813038f, 0.04900724f, 0.00892128f, -0.00608904f, 0.05486468f, 
    -0.00975964f, -0.01147668f, 0.03031256f, -0.11185778f, -0.13373253f, -0.04828425f, 0.11184321f, -0.02093475f, 
    0.01564509f, 0.03367036f, 0.01468485f, -0.05331434f, 0.00080797f, 0.03646206f, 0.14409493f, 0.08499695f, 
    -0.13496269f, -0.10075711f, 0.02074231f, -0.12740609f, 0.03527281f, -0.04996362f, 0.07957848f, -0.01203487f, 
    0.06418908f, 0.03563860f, 0.02595516f, 0.09390107f, 0.17882016f, 0.08365650f, 0.03386316f, -0.14135589f, 
    0.00045373f, -0.18480542f, 0.03145357f, 0.01093372f, 0.02707538f, -0.05220968f, -0.02187602f, -0.01952537f, 
    -0.13108717f, -0.06986456f, 0.16229458f, 0.07327194f, 0.00531071f, -0.01480028f, 0.06256323f, 0.07188026f, 
    0.05547296f, 0.16695632f, -0.01035550f, -0.07978538f, 0.00925026f, -0.06188665f, 0.13341399f, 0.14602996f, 
    -0.04611515f, 0.02937140f, 0.02320139f, 0.09065028f, 0.10986618f, 0.11149465f, -0.05125297f, -0.12192672f, 
    0.35525844f, -0.15987773f, -0.06325138f, -0.04780827f, -0.14784440f, 0.09329437f, 0.05897443f, 0.02433649f, 
    -0.01995314f, 0.01768876f, -0.00490342f, 0.09103503f, -0.18682772f, -0.15106724f, -0.03745174f, 0.07264069f, 
    0.09606539f, -0.10838509f, 0.13442516f, 0.10491810f, -0.02634634f, 0.03358975f, 0.03065350f, -0.00170832f, 
    -0.04888995f, -0.13549772f, 0.04794491f, 0.01498651f, -0.06527749f, 0.05505620f, 0.06251658f, 0.02276572f, 
    0.02941130f, 0.17813937f, -0.07826291f, 0.15350254f, -0.13778713f, 0.07677940f, -0.08277144f, 0.10994320f, 
    0.16101398f, -0.05119435f, 0.19442192f, 0.00788047f, 0.01568368f, -0.01608857f, 0.03523938f, -0.06672014f, 
    -0.33322480f, -0.02770961f, -0.27394211f, 0.18866310f, -0.00188527f, -0.06770939f, 0.02852290f, 0.11867674f, 
    -0.12714586f, 0.12753445f, -0.00009250f, 0.13392816f, 0.34245116f, -0.45025676f, 0.10457505f, -0.12341992f, 
    0.00988677f, 0.03225205f, 0.09669947f, 0.03924242f, -0.02524436f, -0.05864309f, -0.04669853f, 0.09418158f, 
    0.15399033f, 0.04083141f, 0.10616094f, -0.16762078f, -0.12069901f, 0.03461591f, -0.12867358f, 0.01777904f, 
    -0.08288801f, 0.08617959f, -0.06246725f, -0.12967147f, 0.09314744f, -0.03697404f, -0.12919012f, -0.02685009f, 
    0.06667822f, 0.03247051f, 0.00151958f, 0.03198370f, 0.06446856f, 0.00610083f, 0.05224334f, -0.02110915f, 
    0.41112277f, -0.31778145f, 0.20326042f, -0.21442007f, 0.17879348f, 0.07641523f, 0.00064856f, -0.11861753f, 
    0.11738617f, 0.02633809f, -0.15281039f, -0.06090418f, 0.12872124f, -0.07334799f, 0.04261490f, -0.14491287f, 
    0.06333923f, -0.01416570f, -0.11168882f, -0.08215360f, -0.01180652f, -0.00732594f, 0.02141464f, -0.01664557f, 
    -0.22112241f, 0.27753389f, -0.02744060f, 0.19345210f, -0.03411238f, -0.08380746f, 0.05221491f, 0.20628265f, 
    0.03937316f, 0.00240781f, 0.07944621f, -0.02964604f, -0.19114369f, -0.05192053f, 0.06681798f, -0.00967679f, 
    -0.01759627f, -0.08705720f, 0.19132589f, 0.09909581f, 0.15118718f, -0.02076286f, -0.03891902f, -0.07193609f, 
    -0.03683079f, -0.11462360f, -0.14994150f, -0.23168902f, 0.06865560f, -0.03906238f, 0.09969516f, -0.01664381f, 
    -0.03727454f, -0.07048269f, 0.12318113f, -0.00241471f, 0.04922752f, 0.07097402f, 0.01162634f, 0.18347047f, 
    -0.08523285f, -0.03146681f, -0.15726143f, 0.01502914f, 0.10472947f, -0.02128826f, 0.00494897f, -0.03833984f, 
    0.08022594f, -0.01080368f, -0.06643275f, 0.07192069f, 0.03464412f, 0.10905026f, -0.05352692f, 0.18945451f, 
    -0.05071606f, -0.07492099f, -0.03669046f, -0.05112010f, -0.06607518f, 0.10005029f, -0.09128117f, -0.10523733f, 
    0.01913712f, 0.06965952f, 0.05317246f, -0.12679589f, -0.10419030f, 0.14899716f, 0.03617695f, 0.02410176f, 
    0.06048143f, -0.17347379f, 0.01196714f, -0.02121990f, 0.10218527f, 0.03646572f, -0.14646429f, -0.03471673f, 
    -0.08308750f, 0.00257142f, -0.02996627f, 0.14211500f, 0.06357172f, 0.00938790f, 0.00134403f, -0.02254445f, 
    -0.00600816f, 0.02724262f, 0.02451255f, 0.12944366f, 0.02908399f, -0.01465646f, 0.03241184f, 0.09356802f, 
    0.12444476f, -0.01136308f, -0.09500770f, -0.05918962f, -0.02298573f, 0.04248340f, 0.02562321f, -0.04444417f, 
    0.07462771f, 0.04520346f, 0.06803849f, 0.04817183f, 0.03815076f, 0.24599835f, -0.18869790f, 0.09683731f, 
    -0.05469584f, -0.00589994f, 0.09240914f, -0.09701856f, 0.07567061f, 0.02469907f, -0.12797634f, -0.19894144f, 
    0.16715358f, 0.10623388f, 0.18812048f, 0.06093589f, 0.06408940f, 0.02796187f, -0.09535487f, 0.03275076f, 
    0.00728809f, -0.17571345f, 0.05563704f, 0.01232174f, -0.13986436f, -0.00335808f, 0.03108713f, -0.06512839f, 
    -0.00323928f, 0.05623633f, 0.08073944f, 0.13614649f, 0.00698019f, -0.01359088f, 0.05440848f, -0.08875802f, 
    0.00412868f, 0.05722165f, 0.10050295f, -0.03772721f, -0.03542445f, 0.08553695f, -0.02196271f, -0.05104055f, 
    0.09620424f, 0.08965459f, 0.11539477f, 0.05285962f, -0.14540783f, 0.10703971f, 0.01698386f, -0.10238093f, 
    0.02075452f, -0.08019675f, -0.00138699f, -0.08714262f, 0.07925630f, 0.10570949f, 0.12250824f, 0.11386279f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14849706f, 0.26799676f, 0.02990829f, 0.01783285f, -0.01142130f, -0.01703407f, -0.04929943f, 0.00209921f, 
    0.11556233f, -0.00336088f, 0.01209528f, -0.00639581f, 0.01206459f, 0.00383772f, -0.01295811f, -0.02746826f, 
    0.00411008f, 0.06017320f, -0.00288850f, 0.06637465f, 0.07076812f, -0.02172953f, -0.01976590f, -0.02875327f, 
    0.05693232f, -0.04932076f, 0.10503364f, 0.21927552f, -0.01499922f, -0.02322231f, 0.04883043f, 0.01205671f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.46845424f, -0.30630925f, -0.03695287f, 0.05791494f, 0.01893292f, 0.17711651f, 0.34604478f, 0.02293829f, 
    0.11031590f, -0.03011762f, 0.09197019f, -0.12201855f, -0.73812944f, -0.09276574f, 0.08422013f, 0.21063849f, 
    -0.13527001f, -0.13160898f, 0.09731857f, -0.34189513f, -0.33399707f, -0.00454546f, 0.01908664f, 0.16055395f, 
    0.27833915f, -0.20969780f, -0.36771432f, -0.17391169f, 0.00285027f, 0.08874724f, -0.17552328f, -0.03334271f, 
    0.03680939f, 0.28399932f, -0.17875260f, 0.23547882f, -0.15042754f, -0.17228067f, 0.13229100f, -0.15761787f, 
    -0.02876142f, -0.06365651f, 0.09585643f, 0.01414739f, -0.36816663f, -0.00133516f, 0.12836501f, -0.08393005f, 
    -0.14801614f, 0.12560230f, -0.11154301f, -0.07130057f, -0.41872776f, 0.18575293f, 0.08183702f, 0.30271646f, 
    0.10506665f, -0.76351619f, -0.17864361f, 0.31614152f, 0.04690618f, -0.05443802f, -0.03975802f, -0.30205765f, 
    0.14015183f, -0.16469815f, 0.06626396f, -0.28986311f, 0.02378503f, 0.02653628f, -0.45772344f, -0.00153297f, 
    0.02265002f, 0.06666322f, 0.07564532f, -0.08252394f, -0.14819334f, -0.01650399f, 0.12066758f, 0.05791463f, 
    0.09067875f, -0.09429944f, 0.28648788f, 0.40620366f, 0.44630098f, -0.07176637f, -0.20490079f, 0.18820013f, 
    0.13724160f, -0.53194529f, 0.12923279f, -0.21639207f, -0.07176831f, 0.06392715f, -0.09863503f, -0.12461640f, 
    -0.23575276f, -0.56572157f, -0.06562018f, 0.08052500f, 0.01954181f, -0.08797155f, 0.11616211f, -0.08760762f, 
    -0.09436485f, 0.00534292f, -0.07977381f, -0.10942413f, 0.18940760f, -0.05683059f, 0.03513161f, -0.10308215f, 
    -0.17027187f, 0.18710245f, 0.10145216f, 0.23655602f, 0.12807523f, -0.37716991f, -0.26978955f, 0.06885853f, 
    0.14436166f, 0.25305542f, -0.29267013f, -0.49741673f, -0.16475570f, 0.11483584f, 0.12871444f, -0.46131450f, 
    -0.40148544f, -0.24189338f, 0.15559909f, -0.57718062f, -0.11943141f, -0.09736770f, -0.03780084f, 0.04637270f, 
    0.07535930f, -0.04401159f, -0.06362358f, 0.05198229f, 0.05064117f, -0.07450894f, -0.02518124f, 0.01857288f, 
    0.13585047f, -0.39940259f, 0.18759610f, -0.11740655f, -0.18410632f, 0.25162014f, 0.24835880f, 0.10394657f, 
    -0.01887411f, 0.30789000f, -0.03645472f, -0.09991132f, 0.14701979f, -0.02907063f, 0.20640929f, -0.04766615f, 
    -0.23512240f, 0.07695972f, 0.00322872f, -0.35676780f, -0.15239352f, -0.07345271f, 0.30425990f, 0.10511526f, 
    0.29341230f, 0.10752275f, -0.15454237f, 0.03846064f, 0.16007708f, 0.03365320f, 0.13529314f, -0.36068374f, 
    0.04316135f, -0.24010494f, -0.35628951f, 0.09268224f, 0.00622865f, -0.06135646f, 0.16945292f, -0.39510396f, 
    0.16996910f, -0.14978039f, 0.18979955f, 0.23421438f, 0.17095715f, -0.05641997f, 0.19182976f, 0.00015957f, 
    0.36405763f, 0.22958747f, -0.03846714f, -0.20588335f, 0.00889265f, -0.00092654f, -0.45994645f, 0.13403216f, 
    0.13482611f, 0.06477901f, 0.04816777f, 0.10722280f, 0.32378697f, 0.17894727f, -0.10326687f, 0.30443382f, 
    -0.10556535f, 0.00179460f, -0.17422146f, -0.26129842f, -0.21602042f, -0.28668633f, -0.39030045f, -0.02477617f, 
    -0.32640204f, 0.06609786f, 0.13293184f, -0.18500815f, -0.04427318f, 0.16327736f, -0.52601105f, -0.07520526f, 
    -0.21836415f, -0.28275523f, -0.06549258f, 0.01239952f, -0.03966283f, 0.05485805f, -0.12960787f, 0.14209753f, 
    -0.48806015f, -0.03986567f, 0.08430949f, 0.00877185f, 0.43841523f, -0.10527112f, -0.14080964f, 0.35564247f, 
    0.07532647f, -0.15778100f, -0.47452623f, 0.36503437f, -0.27614200f, -0.20114386f, 0.36076087f, 0.09596487f, 
    -0.26997709f, -0.10338475f, 0.15385936f, -0.05906612f, -0.02931911f, -0.06342793f, 0.06185328f, 0.06943680f, 
    -0.07930093f, -0.16882190f, -0.01753636f, 0.19023986f, -0.04538956f, 0.02093644f, -0.43137667f, 0.11576109f, 
    -0.20225808f, -0.16290972f, -0.12120303f, -0.16561082f, 0.23322766f, -0.01793484f, -0.06009232f, -0.16793470f, 
    -0.10865084f, 0.23583460f, -0.60994697f, 0.23207639f, 0.21517615f, -0.31785232f, -0.16379243f, -0.03263959f, 
    0.13965002f, -0.43027005f, -0.36549103f, 0.08533489f, 0.07942861f, -0.10389324f, 0.26785985f, 0.42363173f, 
    0.02666485f, 0.04226278f, 0.06544732f, 0.01209762f, 0.11822488f, -0.06378208f, -0.35535410f, 0.06779829f, 
    -0.18117768f, -0.04464523f, 0.06442960f, 0.08589973f, -0.53275627f, 0.11264662f, -0.14096785f, 0.18904479f, 
    -0.00702883f, -0.80092549f, 0.14703216f, -0.09336652f, -0.29464895f, -0.08185315f, 0.17307951f, -0.30941436f, 
    0.00010806f, 0.21283948f, 0.35537615f, 0.16652273f, 0.14322890f, 0.14168361f, -0.00821427f, 0.35133171f, 
    0.15831617f, 0.07963178f, 0.04318057f, -0.10430643f, 0.08424437f, 0.05481897f, 0.09295841f, 0.11734589f, 
    -0.39404735f, -0.15648958f, -0.03258968f, 0.15651570f, 0.18265615f, -0.13143629f, 0.07984117f, -0.55418754f, 
    0.06495676f, 0.16524185f, -0.17288202f, -0.29323637f, 0.43087435f, 0.32253829f, -0.25799304f, -0.11019967f, 
    0.10459369f, 0.27241135f, -0.22364047f, 0.08383430f, 0.07203699f, 0.12629734f, -0.51421589f, -0.21341415f, 
    -0.10187969f, 0.10547822f, -0.08492378f, 0.29437196f, 0.07549311f, -0.10471483f, -0.15222688f, -0.07360329f, 
    0.12520874f, -0.02356951f, 0.02964603f, 0.04477533f, -0.22731203f, -0.14789560f, -0.03791970f, -0.64622438f, 
    0.02298973f, 0.42138380f, 0.10936259f, 0.00189177f, 0.27545923f, -0.50769591f, -0.15094331f, 0.09788707f, 
    -0.48038307f, 0.39276427f, 0.06296780f, -0.22746567f, 0.09183511f, 0.05930648f, 0.05169695f, -0.45606866f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.32109502f, 0.03039757f, 0.09534102f, -0.11944853f, -0.19521788f, -0.08797789f, 0.07901194f, -0.23343907f, 
    0.10429634f, -0.07840120f, -0.01025341f, -0.17634481f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
